#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.28240573f, -0.87077433f, -0.14047475f, 0.48279393f, -0.17872722f, -0.02059136f, 0.25684428f, -0.30122605f, 
    0.14018069f, 0.18877827f, -0.31348738f, -0.39021972f, -0.74538302f, -0.30083683f, 0.21393450f, -0.35975367f, 
    0.63897264f, 0.53055501f, 0.46752286f, -0.66019905f, 0.36068177f, 0.06198997f, 0.36590096f, 0.06882679f, 
    0.00380145f, 0.10843673f, -0.69345081f, 0.13211407f, 0.53385645f, 0.21174011f, -0.04445945f, 0.27943730f, 
    -0.06482425f, 0.06007660f, -0.02755084f, 0.47677997f, -0.73567003f, 0.49879462f, 0.07673934f, 0.30034006f, 
    0.58070374f, 0.00940687f, 0.14538662f, 0.52212346f, 0.19163726f, -0.08269846f, -0.55022663f, -0.58499020f, 
    0.72604978f, 0.46288770f, -0.09253652f, -0.21645430f, 0.14345166f, -0.57686615f, 0.68737161f, 0.48710459f, 
    -0.50951481f, 0.55905342f, -0.22120258f, -0.05152980f, 0.30245084f, 0.33279574f, -0.25135764f, 0.43862337f, 
    0.38034457f, -0.32532910f, 0.34278482f, 0.65552735f, 0.45432153f, 0.27830225f, 0.41222364f, -0.43345174f, 
    -0.50880545f, 0.00040125f, 0.25620630f, 0.22673994f, -0.51719677f, -0.33239850f, -0.02481083f, 0.74139392f, 
    0.15057494f, -0.03822548f, 0.11781142f, 0.26047289f, 0.45522961f, 0.16454034f, -0.02507889f, -0.54757941f, 
    0.37592447f, 0.36097997f, -0.73050416f, -0.00595100f, 0.67783982f, -0.49752218f, -0.54429948f, 0.57988346f, 
    0.41781875f, -0.14236647f, 0.28296185f, -0.16258018f, 0.77589893f, -0.49207762f, 0.23637091f, -0.50795728f, 
    0.10263827f, -0.10415998f, -0.11789782f, 0.47089386f, -1.09733498f, 0.03069343f, 0.08724487f, -0.29781261f, 
    1.00354373f, 0.64481884f, 0.22708882f, -0.17498632f, 0.11489441f, -1.14235818f, -0.92504072f, 0.68326962f, 
    1.06244326f, -0.04225274f, -0.15278822f, 0.01289479f, -0.42512420f, -0.58963203f, 0.62972540f, 0.37262794f, 
    0.82917732f, -0.43221837f, 0.25374669f, 0.14024767f, -0.14602877f, 0.24603581f, -0.45089418f, 0.00976272f, 
    -0.43303323f, 0.02789908f, -0.08966802f, -0.25735411f, -0.18549867f, -0.24788006f, -0.33531365f, -0.36659837f, 
    -0.87332606f, -0.73138034f, 0.02265458f, -0.23583183f, -0.57447970f, 0.08582728f, 0.09239542f, -0.15533328f, 
    0.16670503f, 0.49090993f, -0.68850189f, 0.83349997f, 0.20523353f, -0.26879269f, 0.36150354f, 0.03759907f, 
    0.23270084f, 0.02040524f, 0.31672287f, -0.25601017f, -0.27262276f, 0.13970415f, -0.15865582f, 0.05661274f, 
    0.45413220f, 0.49749324f, 0.35363132f, 0.39731976f, -1.08917427f, 0.48996300f, 0.06723814f, 0.12629230f, 
    -0.32093659f, -0.03298221f, -0.25382099f, -0.13156739f, -0.10869540f, -0.38084126f, -0.68846565f, -0.38908610f, 
    0.54659373f, 0.07974906f, -0.32670671f, -0.39675537f, -0.34903434f, -0.07573225f, -0.23268025f, 0.15740687f, 
    -0.36553398f, -0.39333805f, -0.59705877f, 0.63273817f, 0.59299308f, 0.51642382f, 0.28717849f, 0.12605761f, 
    -0.84379750f, -0.83048767f, -0.13787755f, 0.00250847f, -0.42926022f, -0.51600581f, -0.24201970f, 0.00160901f, 
    -0.16926953f, -0.23844899f, -0.68294621f, -0.62447530f, -0.93586886f, 0.03103781f, -0.48030698f, 0.44114226f, 
    1.40506411f, -0.85690618f, -0.58046895f, -0.33880472f, -0.24991432f, -0.52428740f, -0.03771050f, 0.03555028f, 
    0.15128756f, -0.92644227f, -0.33752078f, -0.11822412f, 0.46795735f, -0.40765035f, 0.72602397f, 0.30408657f, 
    0.17765070f, 0.40866011f, 0.99188763f, 0.91532040f, -0.00827137f, -0.54461259f, -0.05611687f, -0.43886530f, 
    -0.05892660f, 0.30850068f, -0.02017312f, -0.97381985f, -0.37940386f, -1.22550154f, 0.82550675f, 0.09188957f, 
    0.49679485f, 0.38468787f, 0.10236470f, 0.26289698f, -0.67632222f, 0.45413491f, 0.57440549f, -0.24461703f, 
    -1.12962210f, -0.91115224f, 0.01190765f, 0.29830635f, -0.01230189f, 1.05354047f, -1.14325190f, -1.05228353f, 
    0.48269749f, -0.02028361f, 0.48914585f, -0.11759961f, 0.21723706f, -0.04390991f, 0.39244556f, 0.84684122f, 
    -1.15711570f, 0.17818774f, 0.78990954f, -0.02683356f, -0.40755239f, -0.10988007f, -0.24726637f, -0.57899016f, 
    -0.40317023f, 0.11274470f, -0.62577921f, 0.51032436f, -0.86879545f, -0.03939825f, 0.06637739f, -0.37101361f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13671273f, 0.20584880f, 0.09347628f, 0.38031867f, -0.30459583f, 0.35593542f, -0.12657113f, -0.22498024f, 
    -0.10533014f, 0.38880494f, 0.20376709f, 0.24561115f, -0.30431867f, -0.18596689f, 0.10385717f, 0.17631412f, 
    -0.21745498f, -0.08627970f, 0.24360242f, 0.38512278f, -0.08502456f, -0.17510064f, -0.10979888f, -0.00613211f, 
    0.08375095f, 0.18117622f, 0.39509231f, 0.05172214f, 0.29404172f, 0.19084089f, 0.02299367f, -0.30207565f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.26880944f, -0.36106592f, 0.06600460f, 0.12762836f, 0.06832647f, 0.09533398f, 0.12257902f, 0.08729459f, 
    -0.17694600f, 0.02474254f, 0.24130818f, 0.02302974f, -0.02727091f, 0.13575903f, 0.02946093f, 0.00184484f, 
    0.14008768f, 0.17985724f, -0.15155764f, -0.31900516f, 0.15175694f, 0.04396196f, -0.09505639f, 0.12626432f, 
    -0.13206266f, 0.12859561f, -0.17706771f, -0.18967946f, -0.15536469f, -0.00049029f, -0.00542644f, -0.12926792f, 
    -0.08262514f, 0.00395232f, -0.07064127f, -0.09212905f, -0.08034210f, -0.07254235f, -0.04961138f, 0.03957772f, 
    0.03062856f, -0.10522429f, -0.14111079f, 0.01297708f, 0.07137507f, 0.05683284f, 0.01622909f, 0.30023304f, 
    0.03013907f, -0.05714343f, -0.12759188f, -0.06245166f, -0.17022438f, -0.01197179f, -0.39287227f, -0.21854632f, 
    -0.00666638f, -0.01716930f, 0.02528059f, 0.06562578f, 0.05629407f, -0.02977495f, -0.17955278f, -0.20940559f, 
    -0.22269358f, -0.05059502f, 0.05301625f, -0.12468640f, -0.10283055f, 0.00345428f, -0.15292516f, 0.13960825f, 
    0.12820369f, 0.24929404f, 0.47133330f, -0.05521313f, 0.17818931f, 0.10987648f, 0.05166278f, 0.06859550f, 
    0.11579764f, -0.11632275f, -0.04766491f, 0.03670471f, -0.21212515f, -0.01165787f, -0.14844292f, 0.10526047f, 
    0.08675355f, -0.17538072f, -0.09992433f, 0.07893258f, 0.09440466f, -0.10083166f, 0.28377542f, 0.02530807f, 
    0.09534311f, 0.01554348f, 0.21357904f, -0.04372295f, 0.00832676f, 0.06844172f, 0.16539429f, -0.02402862f, 
    0.10857999f, -0.06180279f, 0.16420898f, -0.04080469f, 0.22622551f, 0.08109763f, 0.04927741f, -0.22324632f, 
    -0.11633425f, -0.14144394f, -0.01161939f, -0.04234282f, 0.21509519f, -0.05258094f, -0.02013010f, -0.02239399f, 
    -0.06706005f, -0.08706334f, 0.08839238f, -0.11824845f, -0.05985618f, -0.27062601f, -0.39135793f, -0.07846048f, 
    0.04634478f, -0.06528556f, -0.13050814f, 0.00181867f, 0.06279856f, 0.08343508f, -0.13097787f, 0.09974234f, 
    -0.01535445f, -0.12688324f, 0.05991721f, -0.06372365f, 0.07108346f, 0.07185210f, -0.05001213f, -0.13340022f, 
    0.00433817f, 0.23173398f, 0.26568094f, -0.13944191f, -0.08697589f, 0.08885708f, 0.11977302f, 0.10190591f, 
    0.11230333f, -0.37070680f, -0.20496163f, -0.14848796f, 0.10880315f, -0.05774095f, -0.07730251f, 0.12843829f, 
    0.03954587f, -0.11570372f, -0.04136268f, -0.04063890f, 0.05571948f, -0.04882798f, 0.00548372f, 0.03016629f, 
    0.34210268f, 0.08920126f, 0.16079418f, -0.05553529f, -0.16833691f, -0.23859909f, -0.11362468f, -0.00862638f, 
    0.15304382f, 0.06825037f, 0.14142081f, -0.17414883f, -0.00587942f, 0.11792019f, 0.16334333f, -0.02922386f, 
    -0.19066153f, 0.03948901f, -0.00140626f, -0.19043052f, -0.14779331f, 0.16324632f, 0.17141864f, 0.35417405f, 
    0.13198870f, 0.29056540f, 0.08353823f, 0.06869012f, 0.08529153f, 0.24122868f, 0.26806834f, 0.08717911f, 
    -0.26933372f, -0.05792797f, -0.03688449f, 0.15657517f, 0.01853358f, -0.04397658f, -0.18222141f, 0.15475139f, 
    0.20572844f, 0.30040032f, -0.04791455f, 0.01637204f, -0.14489894f, 0.08718108f, 0.01927953f, -0.12283921f, 
    -0.00907739f, -0.03470628f, -0.16603149f, -0.19055168f, 0.32657543f, 0.07742373f, -0.18569537f, 0.09719986f, 
    -0.02579213f, 0.08933131f, 0.08286986f, 0.05189079f, 0.05608841f, 0.02405895f, -0.07283254f, 0.11234868f, 
    0.11592858f, 0.02020091f, -0.14385100f, -0.56305802f, -0.26050499f, -0.04344326f, -0.11079638f, 0.05681657f, 
    0.03515171f, 0.11875037f, 0.23079079f, 0.30089399f, 0.19608368f, 0.11028758f, 0.06328542f, -0.09268203f, 
    0.08067746f, -0.04120994f, 0.10001253f, -0.00788460f, 0.02673867f, -0.01915473f, 0.22930641f, 0.11523403f, 
    0.07602151f, -0.04353197f, 0.00849854f, 0.08062694f, 0.22659566f, -0.15660705f, -0.15106823f, 0.09738424f, 
    0.06543762f, 0.12196764f, 0.08767029f, -0.03411217f, -0.06229154f, 0.01360143f, -0.49057817f, -0.03664096f, 
    -0.13680300f, 0.01066579f, -0.01399654f, 0.08687678f, 0.19481693f, -0.09835280f, 0.23601416f, 0.09380677f, 
    0.06658919f, 0.23172690f, -0.06176100f, -0.12237872f, -0.11694504f, -0.00661506f, 0.04756893f, -0.15406775f, 
    -0.04480364f, -0.04124605f, -0.04743392f, -0.00902921f, 0.02919351f, -0.06627449f, -0.06376385f, -0.06775127f, 
    -0.03033705f, -0.04897721f, 0.00608150f, -0.01454076f, 0.04862064f, 0.01403015f, 0.04109364f, 0.03868959f, 
    -0.06380107f, 0.04879967f, -0.01682731f, -0.03180246f, 0.02954717f, -0.02355471f, 0.01904511f, -0.05966074f, 
    -0.03914602f, 0.03126350f, -0.03509480f, 0.05205976f, 0.00651802f, -0.05863215f, -0.05545662f, -0.01994930f, 
    -0.00318303f, 0.03696499f, -0.01675216f, 0.01698546f, -0.04153025f, -0.04650608f, -0.05349842f, 0.02819145f, 
    0.01709830f, 0.02833075f, -0.05292475f, -0.01346694f, -0.00552203f, -0.03018055f, 0.04187198f, -0.00971588f, 
    0.01985518f, -0.03166556f, -0.00396072f, 0.01061060f, -0.00032841f, -0.05353136f, -0.00668728f, 0.00531306f, 
    0.01827305f, 0.03036148f, 0.01334832f, 0.03988445f, -0.03582217f, 0.04818431f, 0.04896726f, 0.05794691f, 
    0.06494756f, -0.02439485f, -0.06440799f, -0.01082281f, -0.04676720f, 0.02992714f, -0.04131516f, -0.06589696f, 
    0.03040870f, -0.01951964f, -0.06411058f, -0.03448922f, -0.01221127f, 0.04103056f, -0.02551790f, -0.00114253f, 
    0.00438437f, 0.00283713f, 0.02228855f, 0.04134193f, -0.03434167f, -0.02311963f, 0.00089766f, -0.01853073f, 
    -0.06631290f, -0.00881212f, 0.01428906f, 0.00308108f, -0.06498051f, 0.04858439f, 0.01657426f, -0.02567880f, 
    -0.01631343f, 0.02608031f, 0.00086107f, -0.02316950f, -0.05747041f, 0.03869805f, -0.04882731f, -0.00143854f, 
    -0.03707317f, -0.06219859f, 0.03803362f, 0.01617941f, -0.04079492f, 0.00738337f, 0.00388196f, -0.04535347f, 
    -0.04594287f, -0.05469814f, 0.00790207f, -0.00287926f, -0.02504076f, 0.01732549f, 0.02617586f, -0.04412341f, 
    -0.02170571f, 0.01548080f, 0.04997741f, -0.02493624f, -0.01302892f, 0.03087867f, 0.05565343f, 0.03867752f, 
    -0.03559954f, -0.04278450f, 0.02214061f, -0.06660042f, 0.03412243f, -0.03192060f, 0.04098065f, -0.06139468f, 
    0.04339253f, 0.00976556f, -0.02183553f, 0.03984747f, -0.02772338f, -0.04853603f, -0.03347991f, -0.02157797f, 
    -0.00873850f, -0.02119851f, 0.04454448f, 0.05013035f, -0.03227844f, 0.02530354f, 0.01599235f, -0.03301552f, 
    0.02225102f, -0.00985324f, -0.04276584f, 0.04323941f, -0.01510867f, 0.03026240f, -0.01983583f, -0.01854817f, 
    0.04423862f, -0.01716068f, -0.05419633f, -0.04745182f, 0.04366855f, -0.04358185f, -0.00753364f, 0.01173000f, 
    0.01062096f, -0.03550918f, 0.00570280f, -0.00333360f, -0.01673068f, 0.02351838f, 0.03825434f, -0.03445595f, 
    0.00717470f, -0.04831405f, 0.03771018f, 0.01758160f, 0.01651825f, 0.03673867f, 0.01420066f, 0.00239526f, 
    -0.00298480f, -0.01510421f, -0.04786886f, 0.02188792f, 0.04804061f, -0.00966625f, -0.03569859f, -0.04921889f, 
    -0.04174121f, -0.01723402f, 0.01588919f, -0.05372811f, -0.05599097f, -0.01415546f, 0.00820624f, -0.03302831f, 
    0.02483604f, -0.01774729f, 0.04419022f, -0.01771315f, 0.02287740f, -0.04067222f, 0.04512619f, -0.04009444f, 
    -0.05849367f, -0.04324753f, -0.00546169f, -0.02924323f, -0.04942066f, 0.03022637f, 0.01718447f, -0.02571667f, 
    0.00165406f, 0.02288871f, 0.01719321f, 0.00751666f, -0.04350241f, -0.02346880f, 0.01904387f, 0.01751342f, 
    -0.00058613f, 0.01812175f, -0.06358863f, -0.05931072f, -0.04028148f, 0.00123314f, -0.03188246f, -0.04863027f, 
    0.00469372f, 0.03822464f, -0.05130095f, -0.06756278f, -0.03767612f, -0.03086469f, -0.00362454f, -0.03190935f, 
    -0.05116498f, 0.01996709f, 0.00006399f, 0.00016269f, -0.02919878f, 0.02633802f, -0.05338597f, 0.00675729f, 
    0.02579676f, 0.01962738f, 0.00957834f, -0.06736955f, -0.01374912f, 0.01552378f, 0.04301710f, -0.01123651f, 
    -0.06171780f, -0.02269739f, -0.02841483f, -0.04213620f, 0.05284314f, -0.02329416f, 0.01595677f, 0.03965917f, 
    -0.06618470f, -0.02663479f, 0.00862575f, -0.04108980f, 0.02456588f, -0.00407336f, -0.00300085f, -0.02650270f, 
    0.04372825f, -0.05826663f, -0.04316104f, -0.00969907f, -0.00192810f, 0.00964453f, -0.04117608f, -0.00993661f, 
    0.00098756f, -0.02724815f, 0.04056771f, -0.02749142f, -0.04358257f, -0.03231271f, -0.01911090f, 0.02111065f, 
    0.49117804f, 0.01691054f, 0.04537614f, -0.22413932f, 0.22966617f, 0.26490456f, 0.05159428f, -0.15223949f, 
    0.10418484f, -0.11080818f, -0.57968837f, -0.52896172f, -0.00071203f, -0.09857689f, 0.10683070f, 0.05470515f, 
    -0.11521753f, -0.00021653f, 0.27887455f, -0.04582409f, 0.18665284f, -0.01953117f, -0.13717146f, -0.03767499f, 
    -0.01624551f, 0.16725607f, 0.13327910f, 0.08743537f, 0.02066446f, 0.00067021f, -0.05795161f, 0.14208399f, 
    -0.04687808f, 0.03136512f, -0.07382663f, -0.09204070f, 0.29758692f, 0.31636766f, -0.00184450f, -0.08404738f, 
    -0.11952209f, 0.00836013f, 0.07026681f, -0.13615111f, -0.07288262f, -0.21574730f, -0.26440299f, 0.24216157f, 
    -0.01241330f, 0.09890863f, 0.03855659f, -0.11004412f, 0.12009058f, -0.06533866f, 0.30804545f, 0.04677770f, 
    -0.04692701f, -0.06179791f, -0.23091190f, 0.02953948f, 0.07039777f, 0.00823601f, -0.01441311f, 0.16581880f, 
    0.07265618f, 0.07014162f, -0.25542337f, -0.36266112f, -0.09324855f, 0.03895226f, -0.12090814f, -0.04960572f, 
    0.33935523f, 0.04919925f, 0.68431723f, 0.21906999f, 0.01596316f, -0.00405310f, 0.05080091f, 0.07717647f, 
    0.19944324f, 0.08773226f, 0.18699907f, -0.01843416f, -0.13563550f, -0.03091037f, -0.12936527f, -0.16664782f, 
    -0.06334825f, 0.10469118f, -0.01349357f, 0.21723406f, 0.10748110f, 0.14252274f, -0.08582826f, -0.03380137f, 
    -0.03521999f, 0.03638314f, -0.16877751f, -0.14044727f, 0.15622869f, 0.10326721f, -0.08145425f, 0.06415562f, 
    0.41496629f, -0.01963890f, -0.03522865f, 0.27158850f, 0.26930436f, 0.48184106f, -0.47422868f, -0.21866323f, 
    -0.32934240f, 0.01942108f, 0.06300303f, 0.10238441f, -0.06837343f, 0.52771205f, -0.08712044f, -0.12963359f, 
    -0.19669920f, 0.20548934f, -0.26802146f, 0.24817279f, 0.19307029f, -0.00896723f, 0.16454455f, -0.03271841f, 
    0.01623331f, -0.05301407f, -0.02066798f, -0.06211271f, 0.02302149f, 0.13337131f, 0.07538429f, -0.50696582f, 
    -0.42325526f, -0.08605035f, 0.04010622f, 0.00123327f, -0.11668209f, -0.03252898f, -0.06408840f, 0.02949128f, 
    0.88583493f, 0.19930464f, -0.38807008f, 0.01995507f, 0.02262002f, -0.22003631f, 0.07781482f, -0.10553624f, 
    -0.07643206f, 0.10821097f, 0.03641001f, 0.22496390f, -0.25322866f, -0.04191805f, 0.10789234f, -0.14829205f, 
    0.04473239f, 0.08416495f, 0.05211696f, -0.09668739f, -0.08560747f, 0.07902068f, -0.09812572f, 0.12371228f, 
    0.02472562f, -0.09642476f, 0.00735176f, -0.46850562f, -0.53174371f, -0.18157169f, -0.04070963f, 0.04169004f, 
    0.02184064f, -0.01641892f, 0.01682639f, 0.05965158f, -0.24276811f, -0.09021288f, -0.26962143f, -0.02341167f, 
    -0.05309661f, 0.04134187f, -0.18731585f, 0.16472706f, -0.06353569f, -0.25008187f, 0.01756590f, 0.24272540f, 
    0.19292176f, -0.00465830f, 0.05822956f, 0.06736208f, -0.07572267f, -0.08090296f, -0.49901089f, -0.06456957f, 
    -0.11211689f, 0.06184998f, 0.00632183f, -0.04358812f, 0.01568067f, 0.14525606f, -0.02087164f, -0.26927757f, 
    -0.36032647f, -0.06958522f, -0.11190392f, -0.04572094f, -0.02021210f, -0.03782410f, 0.01533119f, 0.05279087f, 
    -0.10070668f, -0.91976762f, 0.22356769f, -0.11642456f, 0.03733703f, -0.12441757f, -0.11050306f, -0.23393391f, 
    -0.09599895f, 0.53817785f, 0.27299541f, -0.44192639f, 0.08150790f, 0.08423647f, -0.02273663f, 0.02676070f, 
    -0.03726365f, -0.10031489f, -0.10107746f, -0.32668224f, -0.03485401f, 0.09129231f, 0.09660274f, 0.08160044f, 
    0.12245854f, -0.03353876f, 0.04030801f, 0.79442364f, 0.09856320f, -0.84193927f, -0.27355671f, 0.14037888f, 
    0.06209943f, 0.05864350f, 0.08440971f, -0.13310792f, -1.05210865f, -0.55669731f, 0.35089076f, 0.07967746f, 
    0.04896707f, 0.03316569f, 0.00275655f, 0.04847173f, 0.32737079f, 0.47644058f, -0.44797179f, -0.64187068f, 
    -0.07036911f, 0.15410690f, 0.21552154f, 0.04525178f, 0.02366891f, 0.05256990f, 0.22425930f, 0.39670193f, 
    0.12959507f, 0.10373240f, -0.05972261f, 0.31028807f, -0.04719652f, 0.13038291f, 0.22915162f, -0.07296129f, 
    0.17133507f, 0.05509763f, -0.02975219f, -0.04817557f, -0.10705459f, 0.14367948f, 0.02104632f, 0.04122904f, 
    0.37682131f, -0.20574528f, -0.09559476f, 0.02769809f, -0.25158483f, -0.13088064f, 0.16658671f, 0.09976646f, 
    0.23054470f, -0.01289677f, -0.40851936f, -0.08967549f, 0.07097808f, 0.03077506f, -0.03380539f, 0.06153841f, 
    -0.02436996f, 0.02949563f, -0.18259963f, -0.00533059f, 0.07566433f, -0.02165423f, -0.12747544f, 0.01187942f, 
    0.04910602f, -0.03858518f, 0.26613626f, -0.19100629f, -0.17205337f, 0.01451879f, -0.13424152f, 0.10485411f, 
    0.05772806f, 0.10328732f, 0.23460230f, 0.12072477f, 0.09901133f, -0.02289354f, 0.04423040f, -0.30530730f, 
    -0.15766039f, -0.12070510f, -0.03408374f, 0.10870569f, -0.02544350f, -0.05782913f, 0.13215023f, 0.08930352f, 
    -0.02849421f, 0.04532710f, -0.17298950f, -0.11905145f, -0.09970951f, 0.03380321f, 0.03498476f, -0.01183038f, 
    -0.19436067f, -0.23998199f, 0.02824820f, -0.23569144f, -0.07928696f, 0.00276012f, 0.22181195f, 0.03982576f, 
    -0.14356107f, -0.05152354f, -0.28889737f, -0.25622851f, -0.37843597f, 0.02316787f, 0.09801532f, 0.22044195f, 
    -0.02149719f, -0.21749948f, -0.01506942f, 0.09022708f, -0.07019002f, -0.01198905f, 0.00916795f, -0.00994737f, 
    0.01136457f, -0.05072377f, 0.03215777f, -0.04308540f, -0.00960537f, 0.19570456f, -0.03189043f, 0.22320126f, 
    0.15294929f, 0.08666925f, 0.23342843f, -0.06070812f, 0.05519765f, 0.02728371f, -0.05544559f, -0.03608349f, 
    -0.03222288f, 0.15259430f, -0.09074988f, -0.30411422f, -0.03901536f, 0.11284605f, 0.05068987f, -0.09680635f, 
    0.18646130f, 0.06881405f, 0.07888650f, 0.08491731f, 0.12475651f, -0.01928818f, 0.01060726f, -0.25356945f, 
    -0.21006949f, 0.01817625f, 0.02219136f, -0.02798818f, -0.13334267f, 0.20342234f, 0.15683709f, -0.04309952f, 
    -0.05228328f, 0.12107480f, -0.29405478f, 0.00026278f, -0.17846954f, -0.16158739f, -0.13059345f, 0.07485456f, 
    0.18095674f, -0.18020606f, -0.21337686f, 0.09868643f, -0.08345708f, -0.00996342f, 0.11681575f, 0.00164782f, 
    -0.03547651f, -0.03943043f, 0.09888491f, 0.01416958f, -0.13147447f, 0.24350782f, 0.15391080f, 0.04869243f, 
    0.39307532f, -0.25499606f, -0.12859263f, 0.04293388f, -0.15507334f, -0.12343954f, -0.06918234f, 0.04404500f, 
    -0.15338728f, -0.15468399f, -0.14518501f, 0.07587090f, 0.14239450f, -0.15993845f, 0.17292812f, 0.02160083f, 
    0.09609633f, 0.05593741f, -0.14155513f, -0.28147793f, -0.12089473f, 0.14413224f, 0.05811209f, -0.07564569f, 
    0.11435405f, -0.01047754f, -0.06802569f, 0.22189309f, 0.21346742f, 0.01675378f, -0.04144922f, 0.12481614f, 
    -0.13250086f, 0.10247954f, 0.01964517f, 0.06500124f, 0.06713334f, 0.04759602f, 0.18589629f, -0.05898358f, 
    0.02904304f, -0.26443043f, 0.14257863f, -0.19099519f, -0.14323094f, -0.31690824f, -0.61960959f, -0.46198869f, 
    0.09347188f, -0.09443618f, -0.08808307f, 0.00509772f, 0.01511484f, -0.04332255f, -0.02885323f, -0.01593870f, 
    0.19705465f, 0.03791779f, 0.03680478f, -0.07995628f, -0.08589789f, -0.12825012f, 0.01817697f, -0.07887340f, 
    -0.20999275f, -0.05844662f, -0.02141884f, 0.05282909f, -0.00297846f, 0.08484537f, 0.09853160f, 0.14513642f, 
    0.16987611f, -0.30611011f, 0.01852103f, -0.17569180f, 0.15776688f, -0.09812982f, 0.02244004f, -0.17917894f, 
    0.15798390f, 0.19308218f, 0.08897542f, 0.21002454f, 0.16905151f, -0.13125372f, -0.01957512f, -0.03831941f, 
    0.11915050f, -0.09377007f, -0.67578298f, -0.01828289f, 0.25929803f, -0.12391734f, -0.09163257f, -0.03003583f, 
    0.00661313f, 0.05293741f, 0.17538005f, 0.10170740f, 0.19185567f, 0.31495321f, 0.02361307f, 0.01794981f, 
    0.14936945f, -0.06040647f, 0.11933218f, 0.00467709f, -0.14413407f, 0.05792538f, -0.05846572f, 0.04917815f, 
    -0.03984420f, -0.07824489f, 0.04375217f, 0.18378566f, 0.03830735f, 0.59660321f, 0.14025261f, -0.07000265f, 
    -0.00764486f, 0.03907043f, -0.16345264f, 0.12053053f, 0.01092269f, -0.00521741f, -0.04851852f, -0.08097570f, 
    0.08219577f, 0.04314768f, -0.08849972f, -0.34950033f, -0.01802613f, -0.38162544f, -0.03717280f, -0.03896032f, 
    0.04396100f, 0.22168945f, 0.01397814f, -0.11685368f, 0.06977693f, 0.02957302f, -0.08457694f, 0.10628027f, 
    0.02124716f, 0.00782492f, 0.01698627f, -0.02773719f, -0.04906837f, 0.02906314f, -0.04980551f, -0.01177537f, 
    -0.03899838f, 0.02942529f, 0.01063543f, 0.04885964f, -0.04862376f, -0.00481918f, -0.03552783f, 0.01445202f, 
    -0.04445278f, 0.01472796f, -0.00370296f, 0.04512225f, 0.03267794f, -0.03045657f, 0.04636999f, -0.03300925f, 
    -0.03987643f, -0.05222948f, 0.04191222f, -0.06313482f, -0.03955539f, -0.04774571f, -0.04356730f, 0.02786432f, 
    0.02425363f, 0.02068671f, 0.02944200f, -0.05274844f, -0.06044576f, -0.03070661f, -0.00534806f, -0.01247440f, 
    0.04857120f, -0.04097683f, -0.03889430f, 0.03096796f, -0.01084006f, -0.05454038f, 0.03171455f, 0.01801546f, 
    -0.03739243f, -0.03643153f, -0.00503386f, 0.00695715f, 0.04125376f, 0.00127419f, -0.01388325f, 0.01082099f, 
    0.00640103f, -0.05035574f, 0.02154933f, -0.06667033f, -0.00315398f, -0.05401184f, -0.03793042f, -0.03550998f, 
    0.04957731f, -0.00145585f, 0.00383458f, -0.01083715f, -0.04002493f, 0.05158524f, 0.04368505f, -0.00389740f, 
    -0.04981092f, 0.01875746f, 0.01771214f, 0.05380262f, 0.01425405f, 0.05557925f, -0.05785312f, -0.02187615f, 
    -0.05579776f, -0.03736761f, -0.02785419f, 0.03247425f, 0.02890811f, 0.01861058f, 0.02089279f, -0.00533136f, 
    -0.05227954f, 0.04579138f, -0.03382093f, -0.01352782f, -0.03609641f, 0.00636150f, 0.00423410f, -0.03111720f, 
    -0.02018163f, 0.01472218f, 0.04674705f, -0.04354485f, -0.01499173f, -0.05675395f, 0.01058602f, -0.01542755f, 
    -0.02207452f, -0.01035303f, -0.02618525f, -0.04401346f, 0.04171305f, -0.04394233f, -0.06424940f, 0.05278711f, 
    0.03439055f, -0.06084253f, -0.04614140f, -0.03426712f, -0.06172367f, -0.04369999f, 0.04568313f, -0.03118455f, 
    0.00020544f, 0.00887071f, -0.00340429f, -0.01838468f, 0.03241738f, 0.05687081f, -0.03902036f, 0.03146041f, 
    0.04877273f, 0.01922348f, 0.01129749f, -0.03079429f, 0.04887197f, 0.01115342f, 0.04257822f, -0.02623806f, 
    -0.04887260f, -0.01575389f, -0.00028041f, 0.05466512f, 0.00248476f, -0.01059245f, -0.01576070f, -0.01745253f, 
    -0.05736548f, -0.05107564f, -0.03525106f, 0.01746604f, 0.04757499f, -0.00170523f, -0.03201137f, 0.00108055f, 
    0.00269459f, -0.01698728f, -0.03829839f, 0.04207096f, -0.05361182f, -0.01511801f, -0.02325973f, 0.01085681f, 
    -0.06585643f, 0.04658695f, -0.00035800f, -0.05076699f, -0.00446045f, -0.02086427f, -0.02404188f, -0.06200661f, 
    0.00729162f, 0.03307993f, -0.04718346f, 0.03745152f, 0.02469329f, -0.01315013f, -0.05521150f, -0.00873192f, 
    0.03669965f, -0.05266742f, 0.00235260f, 0.04211945f, -0.01394114f, 0.01265040f, -0.00904257f, -0.01373321f, 
    -0.05151226f, -0.03097962f, -0.02300112f, 0.00135631f, -0.01167036f, 0.00914747f, 0.00711300f, -0.00127297f, 
    -0.02405151f, -0.04176133f, -0.04106640f, -0.05479805f, 0.00349076f, -0.02988280f, 0.01645629f, -0.02096107f, 
    -0.00974662f, 0.03900413f, -0.01718358f, 0.02673445f, 0.04246292f, 0.01893769f, 0.03287178f, 0.03477458f, 
    0.01536168f, 0.03951836f, -0.04030569f, -0.05246092f, -0.01253053f, -0.01106073f, 0.01423112f, -0.03186904f, 
    -0.06033406f, 0.03825219f, 0.01620967f, 0.05085382f, -0.01355175f, 0.02440889f, -0.00465939f, 0.00220291f, 
    0.04850371f, -0.05530855f, -0.05909622f, -0.02023307f, 0.04865139f, 0.01171899f, -0.03256883f, 0.03283269f, 
    0.02108291f, -0.02842439f, 0.04023315f, 0.04249590f, -0.04644592f, 0.03274649f, 0.01200692f, -0.04335475f, 
    0.00353609f, 0.01200818f, -0.03715097f, -0.03861640f, -0.00285951f, 0.05158210f, -0.00800726f, -0.03522090f, 
    -0.03207335f, -0.02919403f, 0.05096858f, -0.04280628f, -0.00033754f, -0.04923437f, 0.03660661f, 0.00764465f, 
    -0.01509015f, 0.00667155f, 0.01507184f, -0.03119048f, -0.00900954f, -0.05909926f, 0.05305094f, 0.00173017f, 
    -0.05732055f, 0.02460146f, 0.03303104f, -0.01748596f, 0.00980523f, -0.06016072f, 0.01636043f, 0.02141270f, 
    -0.00440999f, 0.03689642f, -0.00090883f, -0.02941313f, -0.02131912f, -0.05671424f, 0.04350799f, -0.01454183f, 
    -0.03990246f, -0.00617569f, -0.05494322f, -0.05371949f, 0.03565238f, 0.05425138f, -0.01332470f, -0.04520711f, 
    -0.32104298f, 0.16600592f, -0.01940943f, 0.04247481f, 0.16686144f, -0.00051191f, 0.03659599f, -0.10236362f, 
    0.09958242f, -0.20725153f, -0.33904198f, 0.15545970f, 0.14032125f, -0.20339191f, 0.02200364f, -0.16669807f, 
    0.09851541f, 0.10311970f, -0.01550857f, 0.18315344f, 0.05918145f, 0.06775883f, -0.07256514f, 0.01328386f, 
    0.00745802f, 0.13769299f, 0.17007302f, 0.28197178f, 0.25353795f, 0.25257927f, 0.04241239f, 0.04975306f, 
    -0.03908899f, 0.05357882f, -0.13566634f, 0.19852534f, 0.06295307f, -0.05835346f, -0.03449009f, -0.04786345f, 
    -0.00517933f, 0.11490097f, 0.19982769f, -0.12872487f, 0.00501782f, 0.00235640f, 0.06134586f, 0.34910026f, 
    -0.02497454f, 0.00699882f, -0.10641943f, 0.00118446f, -0.22212055f, 0.06188570f, -0.12069859f, 0.36659619f, 
    -0.02537595f, -0.08682808f, 0.01497948f, 0.00820096f, -0.11270309f, 0.10273217f, -0.04712327f, -0.14981888f, 
    0.34406510f, -0.01597113f, -0.13842386f, -0.07480616f, -0.17607035f, 0.19133949f, 0.10893799f, 0.15597954f, 
    -0.15081470f, -0.13390294f, -0.33854681f, -0.16657731f, -0.33992037f, -0.04588545f, -0.12287249f, -0.04904580f, 
    0.08604444f, 0.05552354f, 0.14699015f, 0.13934989f, 0.00096560f, 0.05326704f, 0.02809640f, -0.02559100f, 
    -0.09643950f, 0.08257931f, 0.11684109f, -0.11298443f, -0.00084756f, 0.10241748f, 0.02777482f, 0.14870048f, 
    0.11151419f, 0.04103041f, 0.08669870f, 0.00110671f, 0.05545149f, -0.07072961f, -0.02550465f, 0.26911223f, 
    0.07954668f, 0.09010852f, 0.02202250f, -0.07204495f, 0.01034666f, -0.21508196f, -0.22098023f, 0.02773527f, 
    -0.11101206f, 0.14268234f, 0.11789960f, -0.13116018f, -0.01496814f, 0.17630255f, -0.70976555f, -0.25751942f, 
    -0.24344115f, 0.13929471f, -0.08934415f, 0.12302111f, -0.10474862f, -0.08559000f, 0.25735536f, 0.31840217f, 
    0.16903234f, -0.00684024f, -0.02423754f, -0.05106313f, 0.04179195f, -0.01774465f, 0.20303218f, 0.32484007f, 
    -0.00635784f, -0.11065140f, -0.14734757f, 0.08067458f, 0.11841954f, 0.18490909f, 0.01709478f, 0.00876358f, 
    -0.06307670f, -1.10779858f, -0.41590032f, -0.37199873f, -0.05874544f, 0.05594017f, -0.02844418f, 0.00716402f, 
    -0.02991228f, 0.05073752f, -0.01065696f, -0.12444022f, 0.02527733f, 0.03385624f, -0.09172840f, 0.10354242f, 
    0.09842315f, -0.13881700f, -0.15922822f, -0.00610848f, -0.02557734f, 0.08460783f, -0.00026061f, 0.17338429f, 
    0.20256443f, 0.11607029f, 0.12050692f, -0.08246116f, -0.17203480f, -0.12604721f, 0.05309076f, 0.16154903f, 
    0.16491745f, 0.08235308f, -0.03913805f, -0.12083791f, -0.19289613f, -0.67757380f, -0.25624180f, 0.15809716f, 
    0.08820200f, 0.10955369f, -0.04837989f, -0.14712134f, -0.04841686f, -0.06062099f, -0.09891070f, -0.00234897f, 
    -0.09391525f, -0.32918230f, -0.02503074f, 0.07501639f, 0.10939240f, 0.19141410f, -0.20353444f, -0.60400790f, 
    -0.15959883f, -0.03119747f, 0.02771565f, 0.03904846f, 0.02936438f, 0.08775703f, -0.10413817f, -0.42676204f, 
    -0.09555850f, 0.00894556f, -0.22499317f, 0.05575341f, -0.08270723f, 0.10498422f, 0.17581572f, 0.12951168f, 
    -0.82333231f, -0.43733922f, -0.21760003f, -0.02307540f, 0.13529770f, 0.33967519f, -0.14438683f, 0.07767714f, 
    0.09378569f, -0.21878350f, -0.35449493f, -0.23933819f, 0.06068558f, 0.05382778f, 0.10681384f, 0.10079005f, 
    0.03544487f, -0.05034718f, 0.19180295f, 0.29627997f, 0.22104746f, -0.00027787f, 0.06286284f, -0.08104792f, 
    0.16751252f, 0.06625209f, 0.10592920f, -0.40459731f, -0.65667170f, -0.25928420f, -0.00019651f, 0.18136247f, 
    0.20990111f, 0.08300792f, -0.18702407f, -0.16662726f, 0.00623826f, 0.33717385f, 0.08672309f, -0.07710259f, 
    -0.06393119f, -0.11865677f, 0.07053761f, 0.06580947f, 0.11101580f, -0.71606606f, -0.36856467f, -0.22808002f, 
    0.07939681f, 0.17722911f, -0.02018257f, 0.12589172f, 0.05109078f, -0.19020587f, -0.33292380f, 0.07459036f, 
    -0.24491185f, 0.05126842f, 0.00124178f, 0.05929620f, 0.03010058f, -0.12510447f, -0.02775590f, 0.23174554f, 
    -0.94039500f, -0.17705435f, -0.15676162f, 0.05157726f, 0.03347068f, 0.09678794f, -0.06343620f, -0.01735348f, 
    0.00168061f, 0.06537146f, 0.34162730f, -0.01822034f, -0.00584644f, 0.23691450f, -0.03816834f, 0.19868074f, 
    0.08524274f, 0.02249814f, 0.00336977f, 0.23697707f, 0.01549955f, 0.12199470f, -0.24204004f, -0.19429171f, 
    -0.02585912f, -0.03411097f, -0.08201682f, 0.11766837f, 0.02461887f, 0.01738604f, -0.16754146f, 0.01803317f, 
    0.03176938f, 0.12768611f, -0.06765312f, 0.02465622f, -0.07956581f, 0.01754345f, 0.17342620f, 0.01175140f, 
    0.04457026f, 0.09707785f, 0.09392652f, -0.03282865f, 0.04789472f, 0.05476800f, -0.10858926f, -0.00471326f, 
    -0.01883271f, -0.01428391f, 0.06985787f, -0.10822272f, -0.02375919f, 0.02297569f, 0.07280394f, 0.25812861f, 
    -0.12259629f, -0.01878517f, 0.24575087f, -0.06820321f, 0.06098833f, 0.24750020f, 0.15404685f, -0.08437542f, 
    0.25047430f, -0.00297396f, 0.01811486f, 0.23040603f, 0.05146343f, 0.19763096f, 0.12331529f, 0.13936499f, 
    0.04999233f, 0.06264667f, -0.01671722f, 0.07228761f, 0.15967624f, 0.23070098f, -0.00895779f, -0.09900438f, 
    -0.18448327f, 0.04628931f, -0.04685609f, 0.08362953f, -0.21888033f, -0.23172489f, -0.39061695f, 0.08314268f, 
    -0.19708794f, 0.10653297f, 0.13998029f, 0.00657824f, 0.04265076f, -0.10127677f, -0.00671177f, 0.07590614f, 
    0.11560559f, -0.34518096f, -0.06730624f, 0.05840821f, -0.03737850f, 0.01015973f, 0.00141187f, 0.02380810f, 
    -0.06267544f, 0.00140666f, -0.06110724f, 0.00628885f, -0.18652958f, 0.40137193f, 0.10999279f, 0.01852248f, 
    -0.01571810f, 0.11439804f, -0.05752547f, 0.05007248f, 0.18447545f, 0.14174721f, -0.13284780f, -0.10716357f, 
    -0.03718488f, -0.03946079f, -0.20528419f, -0.34315157f, -0.01810897f, -0.17387311f, 0.22861595f, -0.23927794f, 
    -0.19890490f, 0.13686025f, 0.23280963f, -0.01739076f, -0.03757285f, 0.03796405f, 0.02444442f, 0.10032894f, 
    0.05121414f, 0.02883254f, -0.00629838f, -0.02904387f, 0.03344459f, -0.07788936f, -0.16040407f, -0.05276244f, 
    0.13105835f, 0.19422992f, 0.10415474f, 0.01426153f, 0.01184788f, 0.11763670f, 0.07945248f, 0.12365416f, 
    -0.16828644f, 0.18124309f, 0.27810940f, 0.23700181f, 0.28513715f, -0.05285493f, -0.01798354f, 0.08283372f, 
    -0.09185123f, 0.07411452f, 0.22466466f, 0.05626472f, -0.08465663f, 0.09113577f, 0.02901878f, 0.17985530f, 
    -0.04649070f, -0.22509860f, 0.13887115f, 0.03736962f, -0.00988319f, 0.06900744f, 0.02444078f, -0.07181243f, 
    -0.15325527f, 0.03216161f, -0.20449555f, -0.12003844f, 0.09139130f, 0.17305556f, -0.03540008f, 0.00347121f, 
    0.04122308f, 0.04046646f, 0.27237123f, 0.27008006f, 0.02418159f, -0.03918614f, 0.21661957f, 0.04879023f, 
    0.01280516f, 0.05479259f, 0.07735437f, 0.01980083f, 0.26816970f, -0.07965499f, 0.05895346f, -0.11156609f, 
    0.09262889f, -0.05516126f, -0.30563802f, -0.23088406f, 0.04355724f, -0.11691166f, -0.04632527f, -0.14436308f, 
    0.21644165f, 0.18870422f, 0.17535119f, -0.19528374f, -0.05526097f, -0.03978505f, 0.12612027f, -0.03756027f, 
    0.32252267f, 0.14723207f, 0.05583273f, 0.00153853f, -0.31795979f, -0.07784425f, 0.06126961f, 0.00652041f, 
    0.03284389f, 0.18182428f, 0.58194047f, 0.05792233f, 0.03703419f, 0.13098530f, -0.22316705f, 0.27705875f, 
    -0.03817738f, -0.03867402f, 0.13871060f, 0.01944368f, -0.02902350f, -0.11160182f, -0.09251352f, -0.20262411f, 
    -0.24093395f, -0.18553387f, 0.06134810f, -0.02610124f, 0.01948881f, 0.25701240f, 0.00523076f, -0.01928608f, 
    -0.04145781f, -0.01002145f, 0.03489619f, 0.06081606f, 0.06397621f, 0.03480056f, -0.18919276f, -0.25366092f, 
    -0.14659818f, -0.08804307f, -0.07102006f, -0.11116575f, -0.20903812f, 0.07081747f, -0.04097932f, 0.09263209f, 
    -0.16432446f, -0.09740380f, -0.12665015f, -0.06070750f, 0.02314411f, 0.12138335f, 0.00920452f, 0.56756872f, 
    -0.15600802f, -0.20420344f, 0.07276888f, -0.04982534f, 0.24065317f, 0.02122133f, 0.15422729f, -0.36337256f, 
    0.24562854f, 0.16980086f, -0.12872638f, 0.03303268f, -0.08350859f, 0.03621343f, 0.23907726f, -0.05957032f, 
    0.07494077f, -0.00098064f, 0.14052959f, 0.16659394f, -0.09929759f, 0.06951959f, 0.09033094f, 0.11849174f, 
    0.03328388f, 0.08077782f, -0.22277409f, 0.04190773f, 0.09537813f, 0.01153960f, 0.17572345f, 0.00680605f, 
    0.31822476f, 0.35875508f, 0.06149336f, 0.16106698f, -0.13576819f, -0.02447778f, -0.10354209f, 0.17419665f, 
    0.01653545f, 0.10466696f, 0.00087755f, -0.05241552f, 0.00701478f, 0.10574973f, -0.00585538f, -0.06945539f, 
    0.02761211f, 0.03293900f, -0.04971964f, -0.14768893f, -0.21714863f, -0.08693266f, 0.03510332f, 0.06552248f, 
    -0.03448033f, 0.03798411f, 0.21294867f, 0.00791155f, -0.31070516f, -0.17191595f, -0.17212008f, 0.06111425f, 
    -0.02987389f, -0.05284628f, -0.17171595f, 0.15773462f, -0.11006741f, 0.11087930f, 0.02174022f, -0.20089430f, 
    0.12809245f, 0.11906795f, 0.17333283f, -0.03302271f, -0.05602661f, 0.13188459f, -0.15567575f, -0.14219330f, 
    -0.12573881f, 0.02655388f, -0.02390253f, 0.01885068f, 0.18254484f, 0.06760799f, 0.14227705f, -0.27753040f, 
    -0.20837383f, -0.34605905f, 0.06318456f, -0.01612781f, -0.00698216f, -0.04813227f, -0.13715032f, -0.10920683f, 
    0.03400828f, -0.33546296f, 0.31613365f, -0.07465108f, -0.10539749f, -0.15514508f, 0.12898128f, 0.08580079f, 
    0.02348067f, -0.08002503f, -0.08795011f, -0.08532248f, 0.12846048f, 0.11471222f, -0.05776731f, 0.06094904f, 
    0.09265189f, 0.05840748f, 0.15335919f, -0.22496554f, 0.16388035f, 0.14969654f, 0.17701647f, 0.04131559f, 
    -0.03140141f, 0.33486971f, 0.01452331f, 0.19679391f, -0.12403928f, 0.06291077f, 0.17756289f, 0.10825181f, 
    0.15059990f, 0.22975497f, 0.23672085f, 0.11970068f, -0.15568459f, -0.35654444f, -0.01773197f, 0.27359271f, 
    0.05881678f, -0.08028329f, -0.04360044f, -0.02503139f, -0.12066924f, 0.16891278f, 0.26684913f, 0.08431672f, 
    0.17652594f, -0.06578686f, 0.18576884f, -0.36706614f, -0.16953769f, -0.05435676f, -0.12530267f, -0.21001191f, 
    -0.17558753f, -0.14377433f, -0.14615184f, -0.01303472f, 0.01415144f, 0.07293783f, -0.21383515f, 0.14252204f, 
    0.24328147f, -0.05549253f, 0.09088493f, 0.12423156f, 0.14945483f, 0.01385008f, 0.25261053f, -0.13482779f, 
    0.02607248f, 0.04601515f, 0.00390893f, -0.06941528f, -0.06592518f, -0.00070886f, -0.02615132f, 0.06339793f, 
    -0.10752363f, -0.08788045f, -0.20649637f, -0.21681643f, 0.06798550f, -0.02891826f, 0.02852065f, 0.04223118f, 
    0.10592945f, -0.14618039f, -0.11812831f, -0.10456827f, -0.08472776f, 0.10016949f, 0.02428484f, -0.08377399f, 
    0.13584368f, 0.12804620f, 0.15609713f, 0.26621190f, 0.32795313f, 0.21008611f, 0.25075930f, 0.07833374f, 
    0.19398311f, 0.01364402f, 0.19798902f, 0.07635859f, 0.14948761f, 0.09496546f, 0.16997178f, -0.02889833f, 
    0.03456570f, 0.05519341f, 0.01646432f, 0.02196592f, 0.03751342f, -0.09304599f, -0.09960999f, -0.04068477f, 
    -0.08037663f, 0.06087019f, -0.19681925f, 0.03961168f, 0.07805748f, -0.00294288f, 0.21791579f, 0.12042372f, 
    0.02883880f, -0.01241016f, 0.01666729f, 0.07253627f, -0.04679418f, -0.01152690f, 0.04359009f, 0.14118889f, 
    0.08033310f, -0.18744655f, -0.00708780f, 0.09066550f, 0.18313064f, -0.01461017f, 0.11785416f, 0.03796723f, 
    0.03014256f, 0.05076567f, -0.31829709f, 0.22561304f, 0.22071536f, 0.27947319f, -0.07386533f, -0.10277267f, 
    0.34201422f, -0.01406529f, 0.00850038f, -0.04034755f, 0.02248411f, -0.03398716f, -0.14675617f, 0.01055742f, 
    0.18006992f, 0.02151307f, -0.07912730f, -0.16019647f, -0.07825338f, -0.06349037f, -0.07797509f, 0.08054193f, 
    0.08165167f, 0.05163710f, 0.11514863f, 0.03090698f, 0.30674511f, -0.14692827f, -0.06571525f, 0.04377462f, 
    -0.09439536f, -0.12336037f, 0.06803602f, 0.12484089f, -0.08847915f, -0.32796702f, 0.04855535f, 0.09700900f, 
    0.15469162f, 0.22319289f, 0.02343217f, 0.10674790f, -0.13105488f, 0.48216707f, 0.19464613f, -0.04038664f, 
    0.16725744f, 0.05518620f, 0.17203356f, 0.04445720f, 0.04507729f, -0.04722793f, 0.02586173f, -0.13892157f, 
    -0.02859109f, -0.10959423f, 0.04980961f, 0.16538098f, 0.27583918f, -0.08739472f, -0.13723564f, 0.01598217f, 
    0.07862446f, -0.12588367f, 0.07527342f, -0.01791689f, 0.20038193f, 0.01742444f, 0.07515660f, 0.06121470f, 
    -0.22092067f, 0.04765462f, -0.31105334f, -0.32424191f, 0.24819957f, 0.02297316f, 0.17074099f, -0.12387426f, 
    0.13191064f, 0.07523158f, -0.08103794f, 0.19572765f, -0.03132166f, 0.03463704f, 0.00664341f, 0.01832774f, 
    -0.03575889f, 0.19017725f, -0.08822647f, -0.21268734f, -0.17015125f, 0.10626378f, 0.04244391f, 0.12574263f, 
    -0.36034054f, -0.10726698f, 0.06801777f, -0.04817108f, -0.03582051f, 0.08823452f, 0.04235119f, 0.10812440f, 
    -0.08294929f, 0.08153969f, -0.00993180f, 0.07368245f, -0.08314343f, 0.02391813f, -0.16751340f, 0.18104486f, 
    -0.02920990f, -0.02174628f, 0.11121405f, 0.23662364f, 0.15995510f, 0.01485137f, 0.12294538f, -0.17483751f, 
    -0.11664331f, -0.02234880f, 0.19991796f, -0.15236065f, -0.24898843f, -0.07494970f, -0.36744985f, -0.12190560f, 
    -0.09516916f, -0.13107657f, 0.14461054f, 0.04770166f, 0.14236423f, 0.07522083f, 0.02717640f, -0.28150094f, 
    -0.04688070f, -0.29157320f, 0.04925428f, 0.23997217f, -0.02148411f, -0.11387358f, 0.06781431f, -0.00345809f, 
    0.08874955f, 0.11910915f, 0.14864638f, -0.25755957f, 0.05251984f, -0.20025241f, 0.26626751f, 0.18711080f, 
    0.16286744f, 0.06523155f, 0.07940791f, -0.05465063f, 0.14788334f, -0.11295403f, -0.08966092f, 0.03850415f, 
    0.04989107f, 0.16364039f, 0.12216733f, -0.05413357f, 0.27160063f, 0.42295095f, 0.01855709f, 0.07369141f, 
    0.16607596f, 0.02876258f, 0.19879143f, 0.03081341f, -0.22713822f, 0.21948949f, 0.23201635f, 0.12087808f, 
    -0.06582740f, 0.17093177f, -0.07636270f, 0.14475459f, 0.26769358f, -0.18024670f, 0.02986663f, 0.18253550f, 
    -0.11600954f, -0.05875516f, 0.07619984f, 0.01889033f, -0.03842687f, -0.58720362f, -0.00067408f, 0.26988551f, 
    0.30616671f, -0.25439703f, 0.30029181f, -0.16623521f, -0.25148717f, -0.04231832f, -0.20417297f, -0.20396589f, 
    -0.01854205f, 0.17566919f, 0.00087687f, -0.02187974f, -0.08790392f, 0.05786161f, -0.06511147f, -0.07685000f, 
    -0.09589181f, 0.03947458f, 0.04453716f, -0.02341556f, 0.10656041f, -0.10287268f, 0.01969636f, -0.34949252f, 
    -0.24281102f, -0.16831176f, 0.07613543f, 0.28359559f, -0.19927557f, -0.01229190f, 0.05599349f, 0.06332630f, 
    0.12777573f, -0.02176451f, -0.17529702f, -0.18472910f, 0.14115004f, 0.01220981f, -0.07725830f, -0.01174000f, 
    0.05539698f, -0.13821758f, -0.02885517f, -0.00904925f, -0.05568592f, -0.02584796f, 0.09266177f, 0.02772556f, 
    0.18687996f, 0.21150638f, 0.12976544f, 0.00942696f, 0.02071716f, -0.04517427f, 0.11419706f, -0.03504941f, 
    0.24117385f, -0.11588570f, 0.05772572f, -0.01968349f, 0.09805306f, -0.34147367f, -0.09612349f, -0.08488787f, 
    -0.06789356f, -0.04429604f, -0.25788045f, -0.03929320f, 0.08083481f, 0.01496170f, 0.10511193f, 0.17229497f, 
    -0.31062019f, 0.00390524f, -0.02452536f, 0.09151439f, 0.18173234f, 0.03168453f, -0.05060769f, -0.32091686f, 
    -0.07903817f, 0.06611363f, -0.04878555f, 0.05309539f, -0.02153673f, 0.11446957f, -0.25121897f, 0.23076136f, 
    0.11308179f, -0.06992104f, 0.06457135f, -0.05685655f, 0.11159922f, 0.08244057f, 0.08891049f, -0.03330397f, 
    -0.04193928f, -0.01719829f, -0.47301465f, -0.10641825f, 0.11931942f, 0.27000123f, -0.07041637f, 0.19197720f, 
    -0.03254211f, 0.14099592f, 0.09322181f, -0.17927605f, 0.02226644f, -0.14018406f, 0.00660900f, 0.14952905f, 
    0.14850040f, 0.06938504f, 0.05105699f, -0.21402515f, -0.02976410f, 0.05342717f, 0.04097639f, 0.05709472f, 
    0.03407941f, 0.19713022f, -0.05159260f, 0.13749784f, -0.00948577f, -0.51979804f, -0.07800841f, -0.28849250f, 
    0.00304986f, -0.02456862f, 0.00472792f, 0.07192589f, -0.02648218f, -0.17394367f, 0.37805772f, 0.07817764f, 
    0.03550874f, -0.00969600f, 0.20566607f, 0.05150933f, -0.24291968f, -0.14322849f, 0.03846396f, -0.35321939f, 
    -0.35459992f, 0.38760799f, 0.12586777f, -0.07259805f, -0.01158099f, 0.00873075f, -0.14625290f, -0.18540826f, 
    -0.34017065f, -0.17941691f, 0.39740893f, 0.33908948f, 0.03381558f, -0.40179577f, -0.05291517f, -0.38647294f, 
    -0.11834528f, -0.03321794f, 0.08517391f, -0.06643495f, -0.04677878f, 0.00406524f, 0.11495876f, -0.04212520f, 
    0.47285452f, 0.22297023f, 0.22161447f, 0.05975114f, 0.11194202f, 0.04719193f, -0.03937754f, 0.09982422f, 
    -0.04490345f, 0.06452494f, -0.22017221f, -0.21100795f, 0.05347382f, 0.09681024f, 0.14811927f, 0.38958946f, 
    0.02623050f, 0.25273302f, 0.11545316f, -0.05699259f, 0.11823543f, 0.02871578f, 0.06118582f, -0.00987340f, 
    -0.06717689f, -0.11162937f, -0.06534183f, 0.00534840f, 0.01993146f, 0.14827415f, -0.03230451f, 0.04109693f, 
    0.04283211f, 0.00609139f, 0.03424373f, -0.01181693f, -0.10130278f, -0.01488219f, 0.03394099f, -0.02823253f, 
    -0.03785179f, -0.04821512f, 0.01426965f, -0.01621822f, 0.11841112f, -0.16304831f, 0.12222144f, 0.16189153f, 
    0.03433990f, 0.04545830f, -0.06756441f, -0.07117659f, -0.29912317f, 0.11953104f, 0.17413957f, -0.04578185f, 
    0.14062215f, 0.06845557f, -0.16858417f, -0.14824311f, 0.06709882f, 0.15987289f, 0.00958286f, -0.02675325f, 
    -0.19546559f, -0.09510366f, 0.05538599f, -0.23996995f, -0.24912964f, -0.13801014f, -0.17106017f, 0.06672661f, 
    -0.17780758f, 0.12395037f, 0.54721993f, -0.01290927f, -0.03562062f, 0.01343512f, 0.13475621f, -0.04927886f, 
    0.07752243f, -0.07012375f, 0.10459114f, 0.05602287f, 0.01763559f, -0.01339142f, -0.01932382f, 0.13084097f, 
    0.06072061f, 0.06632135f, -0.01250226f, 0.34912679f, 0.21406573f, 0.05059404f, 0.09459125f, 0.03481321f, 
    -0.01153327f, 0.21989663f, 0.11693737f, 0.18177661f, 0.24981776f, 0.44542953f, 0.17729950f, 0.08033888f, 
    0.30059096f, 0.12856214f, 0.04661939f, 0.09816583f, -0.06187405f, -0.13227028f, -0.13376093f, 0.09240154f, 
    -0.01126463f, -0.07297201f, 0.11142424f, -0.15612070f, 0.06582168f, -0.48589817f, -0.18618050f, 0.09184632f, 
    -0.24305712f, -0.13320874f, -0.02657239f, -0.10015968f, -0.24676527f, -0.37782696f, 0.02175165f, -0.03679136f, 
    0.17153800f, -0.07785895f, 0.00033549f, -0.08462253f, 0.24266571f, -0.18019889f, 0.13988873f, -0.16370581f, 
    -0.04443340f, -0.09092490f, 0.04715455f, -0.01547043f, 0.06631503f, 0.11096163f, -0.02768750f, -0.23232111f, 
    -0.28690106f, 0.00354570f, 0.05951480f, -0.16273673f, -0.04925880f, -0.13295937f, 0.04087508f, 0.08045344f, 
    -0.26145476f, 0.02749428f, 0.24666816f, 0.04327526f, -0.10654213f, -0.08376011f, 0.16393593f, -0.04860210f, 
    0.07341490f, 0.03305306f, -0.02540945f, -0.01009806f, 0.02218201f, 0.00870887f, -0.16906708f, 0.09616504f, 
    0.12607181f, 0.06118814f, 0.26369390f, 0.20771410f, 0.17060202f, 0.12435669f, -0.07157037f, 0.11966648f, 
    0.11250733f, -0.02834537f, 0.07056056f, -0.02684931f, -0.29574019f, 0.09552166f, -0.03745391f, -0.19273056f, 
    -0.09531709f, -0.15337147f, -0.18602327f, -0.04733439f, -0.02433502f, -0.01830997f, 0.20836659f, 0.03566116f, 
    0.26965806f, -0.04671974f, 0.04469134f, 0.01740731f, -0.02287859f, 0.11620992f, -0.02589983f, -0.07864019f, 
    -0.29448444f, 0.01711108f, 0.02502218f, -0.01321836f, -0.10014602f, 0.07444242f, -0.11105575f, -0.13373813f, 
    0.06724368f, -0.20552510f, 0.09389409f, 0.01384366f, 0.05491971f, 0.12487436f, 0.14813460f, -0.23965713f, 
    0.00743200f, -0.22407010f, -0.09212531f, -0.05391175f, 0.12010822f, -0.05436201f, 0.07136607f, 0.10532226f, 
    0.31601933f, -0.00731557f, 0.02074015f, -0.11526332f, 0.12507685f, -0.24581537f, 0.07797638f, 0.06679650f, 
    0.04776255f, -0.09251150f, 0.11337950f, -0.34934849f, 0.23051561f, 0.08105545f, 0.13261196f, 0.03182675f, 
    0.04976583f, 0.05709978f, 0.24087268f, -0.26175201f, 0.02085408f, -0.31523067f, -0.09980977f, -0.14439057f, 
    -0.07084879f, 0.09934115f, -0.01224572f, 0.07796209f, -0.47047928f, 0.01381294f, 0.36951208f, 0.14706178f, 
    0.04543144f, 0.12207632f, 0.03795797f, 0.26411030f, 0.17083006f, 0.31966475f, 0.11290945f, -0.25879741f, 
    -0.11613244f, -0.16826037f, -0.13441400f, -0.05207239f, 0.01341147f, -0.01295618f, 0.01734939f, 0.08596500f, 
    0.02345666f, -0.00279830f, 0.19440708f, 0.18557703f, 0.14030069f, -0.19130585f, -0.17714266f, -0.35518733f, 
    -0.33234480f, 0.23986670f, -0.09863619f, -0.19675621f, -0.11575651f, -0.03832381f, -0.08312694f, -0.07086436f, 
    -0.08506320f, 0.09794277f, 0.09716521f, -0.12056126f, -0.21767950f, 0.23881428f, -0.00508655f, -0.04529290f, 
    0.03004185f, -0.04533140f, 0.19194190f, -0.07430156f, 0.06079582f, 0.25269240f, 0.08438909f, 0.12548329f, 
    0.10445069f, 0.12403483f, 0.10820705f, -0.07962192f, -0.07625656f, -0.10034493f, 0.02277533f, -0.06378205f, 
    0.06567761f, 0.02549006f, 0.00509588f, 0.07174885f, 0.03192383f, 0.03994185f, 0.01064786f, -0.07427298f, 
    0.05874209f, 0.00372134f, 0.03051617f, 0.02777201f, -0.08001729f, -0.14598824f, -0.09567352f, -0.03127097f, 
    -0.00395086f, -0.07309264f, 0.10719962f, 0.14842939f, 0.02671902f, 0.04106264f, 0.07244165f, 0.30573612f, 
    -0.02211574f, 0.01944733f, 0.14123079f, -0.03916401f, 0.23866411f, 0.10279555f, 0.01747215f, -0.08364150f, 
    0.00017623f, -0.16070578f, -0.15288591f, -0.11749355f, 0.08988676f, 0.01989155f, -0.21945970f, 0.01487687f, 
    -0.05186353f, -0.14493603f, -0.13870232f, -0.02216826f, -0.01846079f, -0.02265150f, 0.17771502f, 0.21358454f, 
    -0.09548943f, -0.12504077f, -0.19001725f, -0.09531996f, -0.11191417f, -0.09157912f, 0.37482542f, -0.11974745f, 
    0.03166525f, 0.02868558f, 0.03745580f, -0.02601714f, -0.06804644f, 0.03897597f, 0.09808069f, 0.36397740f, 
    0.04491187f, 0.17209078f, -0.02735499f, -0.09251641f, 0.07128707f, -0.18238662f, 0.08628267f, -0.12337182f, 
    0.10014673f, -0.10273241f, 0.16254035f, 0.21766219f, 0.06927369f, 0.07066821f, 0.17427972f, -0.16486765f, 
    0.13650045f, 0.15644938f, -0.11057255f, 0.15898590f, -0.30047917f, -0.19823104f, 0.01398488f, 0.01703166f, 
    0.05344970f, 0.06973017f, -0.00442279f, 0.01289715f, 0.13565661f, 0.07568583f, -0.29429984f, 0.56406629f, 
    -0.17963864f, -0.18664132f, -0.06798787f, -0.15307564f, 0.12858343f, 0.23408224f, 0.00302206f, -0.22696351f, 
    -0.16749887f, -0.02602028f, 0.02129549f, 0.00335134f, -0.05008658f, 0.06706024f, -0.09625442f, -0.11493783f, 
    -0.05878935f, 0.12517864f, -0.14945498f, -0.00916203f, 0.09911851f, -0.02949110f, 0.07614601f, 0.10272649f, 
    -0.15630873f, -0.15659453f, 0.18293773f, 0.04815837f, -0.10713759f, -0.17507273f, -0.03990420f, 0.04555533f, 
    0.03014286f, -0.05135347f, 0.00014779f, -0.10773187f, -0.18701388f, 0.04099206f, -0.02648636f, -0.10697946f, 
    -0.29372585f, 0.06009665f, -0.04147115f, 0.19006404f, -0.00427300f, -0.14876953f, 0.03518124f, -0.07820882f, 
    0.22228275f, 0.01697468f, -0.04214970f, 0.12991416f, -0.00471214f, 0.27679449f, 0.04869302f, 0.01266429f, 
    0.18108596f, 0.10011822f, 0.01885244f, 0.27596378f, -0.12236530f, -0.02633681f, 0.09596334f, -0.25887418f, 
    -0.14815907f, 0.03698523f, 0.06556161f, 0.10601555f, 0.17941910f, -0.02657797f, -0.00407813f, -0.12298777f, 
    -0.21147515f, -0.06931960f, -0.31799060f, 0.12719192f, -0.26738006f, -0.14291874f, -0.34780571f, -0.10617062f, 
    -0.16221976f, -0.21849459f, -0.02878503f, 0.03414363f, 0.00748059f, 0.24498047f, 0.03941436f, -0.19793838f, 
    -0.19032745f, -0.18598680f, 0.07068336f, 0.06051921f, -0.07322726f, 0.04103622f, 0.08538355f, 0.06800422f, 
    -0.00428887f, 0.08486872f, -0.16053206f, 0.03348180f, 0.13985476f, -0.19513461f, -0.04857173f, 0.19769707f, 
    0.03680634f, -0.17928481f, 0.05410091f, 0.06520249f, 0.03019907f, 0.08629115f, -0.02581195f, -0.03809189f, 
    -0.19663528f, -0.10034890f, 0.30541608f, -0.06367137f, 0.03772124f, 0.10234831f, 0.20313095f, -0.15310107f, 
    -0.08633589f, 0.09997471f, 0.03339685f, -0.33691227f, 0.16250549f, 0.20864631f, 0.07279714f, -0.00078423f, 
    0.14505924f, -0.21509725f, -0.14232150f, 0.00349517f, -0.07264841f, -0.39683765f, 0.04938612f, 0.06060365f, 
    0.02647557f, -0.22367874f, 0.12408992f, -0.04429681f, 0.05495089f, -0.36295378f, 0.34669805f, 0.19482313f, 
    0.05770746f, 0.06992941f, 0.25929624f, 0.04903358f, 0.14084780f, -0.01985881f, 0.02918295f, 0.20950703f, 
    -0.19505954f, -0.09378953f, -0.18299106f, -0.03534820f, 0.10706356f, 0.16616462f, -0.11321904f, -0.38074788f, 
    -0.47884592f, -0.19935834f, -0.19189443f, -0.16147678f, -0.12628251f, -0.07575639f, -0.08610088f, 0.19213898f, 
    0.00679677f, -0.18622468f, -0.06607465f, 0.13529384f, 0.04793095f, 0.06621858f, 0.16226348f, -0.24568208f, 
    -0.02477016f, -0.16599144f, 0.14063789f, 0.12927796f, 0.07628635f, 0.01596862f, -0.03050910f, 0.05660351f, 
    0.02690494f, -0.19223668f, -0.17749675f, -0.00336498f, 0.00570862f, 0.18675007f, 0.20653524f, 0.21910167f, 
    -0.18749987f, -0.21771371f, -0.22738184f, -0.00521577f, -0.07455014f, -0.01565450f, 0.00257752f, 0.06540558f, 
    0.07521107f, -0.10504368f, -0.00143176f, -0.01207540f, 0.10928994f, 0.08246287f, -0.00070461f, -0.23467998f, 
    -0.27915278f, -0.12417056f, -0.01519592f, 0.09920083f, -0.01944275f, -0.15832265f, -0.00034813f, 0.05540863f, 
    0.09171236f, 0.02276039f, -0.05441902f, -0.06515594f, -0.21556617f, -0.01808718f, 0.04375551f, 0.10686975f, 
    -0.00338204f, 0.24066710f, 0.05120077f, -0.11360324f, 0.00895841f, -0.05692421f, 0.05424776f, 0.00128039f, 
    -0.06865332f, 0.03004163f, 0.04441907f, -0.14015709f, -0.24694267f, -0.12145795f, -0.09127235f, -0.03520208f, 
    0.15502764f, 0.57269180f, 0.47480249f, -0.12802517f, 0.10512648f, -0.14507954f, 0.07554695f, 0.10082185f, 
    -0.04872138f, -0.03751899f, -0.13347754f, -0.08068392f, -0.06802201f, -0.00533657f, -0.08146861f, 0.08589979f, 
    0.05746324f, -0.06578805f, -0.10256679f, 0.27798659f, 0.15218401f, 0.03599923f, 0.04282613f, -0.26108432f, 
    -0.04680831f, 0.09556586f, -0.01797108f, 0.04659952f, 0.29638651f, 0.03518965f, -0.09947293f, 0.13043216f, 
    0.04162789f, -0.00835825f, 0.10435871f, -0.10032874f, -0.01476026f, 0.03293174f, 0.16231522f, -0.49457088f, 
    -0.14707926f, -0.28330418f, -0.09367980f, -0.02670942f, -0.04599161f, -0.54317904f, -0.17926677f, 0.15439080f, 
    -0.00115659f, -0.02266176f, 0.07370201f, -0.06439214f, -0.05271310f, -0.15565445f, -0.12111931f, -0.09962225f, 
    0.05894374f, 0.11513455f, 0.02890792f, 0.00502921f, 0.05521648f, 0.06470624f, -0.26494160f, 0.03467077f, 
    0.25972939f, 0.14907388f, 0.09525360f, 0.10657533f, 0.04648942f, 0.10213970f, -0.14856234f, -0.08720605f, 
    0.26993209f, 0.11360173f, 0.26913643f, -0.10731252f, -0.08747835f, -0.09300052f, 0.13296629f, 0.19206467f, 
    -0.00311943f, 0.00462684f, 0.05991538f, -0.04610472f, 0.06282269f, -0.06702723f, -0.07287328f, -0.00864713f, 
    0.15787014f, -0.07706159f, 0.07429495f, -0.02299597f, -0.03684316f, -0.11955014f, -0.08246525f, 0.01457746f, 
    0.17058752f, -0.05758775f, 0.12903181f, -0.14060871f, 0.10801927f, 0.05031823f, 0.08414118f, 0.12575820f, 
    0.14059158f, 0.04405611f, 0.02665823f, -0.19846544f, -0.03106299f, 0.00385476f, 0.07673638f, -0.00285569f, 
    0.02520553f, -0.06809252f, 0.08977929f, 0.08418591f, -0.01066054f, 0.33974913f, 0.30426639f, 0.18042871f, 
    0.17979616f, 0.05905339f, 0.02922479f, 0.10409698f, -0.01321542f, -0.13917659f, 0.18283136f, 0.35088047f, 
    0.29047090f, 0.11977628f, 0.00598930f, 0.05450185f, 0.06145934f, 0.08733719f, -0.21636193f, 0.18131255f, 
    0.40050974f, 0.29365009f, 0.12703775f, 0.15863082f, 0.06224553f, 0.06174904f, -0.14259131f, -0.38223982f, 
    -0.07510343f, 0.07287648f, 0.05848478f, 0.07312264f, 0.11853397f, 0.14248838f, 0.03863263f, -0.13241792f, 
    -0.31835747f, 0.05707789f, 0.08949405f, 0.13912918f, -0.02474041f, -0.16106391f, -0.23473427f, 0.02660085f, 
    0.15244640f, 0.07751260f, -0.24895713f, -0.52045655f, -0.09802721f, 0.04090070f, 0.04993060f, 0.04723920f, 
    0.01984045f, 0.01062648f, -0.08472213f, 0.21062472f, 0.05969944f, 0.19259322f, -0.12731116f, -0.22432065f, 
    -0.08508005f, 0.07328206f, 0.01800952f, 0.10889218f, -0.14587334f, 0.12952381f, 0.31508344f, 0.05367997f, 
    0.07351431f, -0.01517624f, 0.01200472f, -0.02580637f, -0.12826571f, -0.09060771f, 0.03900982f, -0.12767562f, 
    -0.24223989f, 0.12907943f, 0.05657000f, 0.09301585f, -0.09926419f, -0.03896302f, 0.07137568f, -0.03104690f, 
    0.00979441f, 0.22656257f, 0.01141861f, -0.03616083f, -0.47372445f, 0.08164865f, -0.08561112f, 0.02415432f, 
    0.21629351f, 0.23197116f, -0.06252548f, -0.10725584f, 0.03177501f, 0.13709857f, 0.18472524f, -0.18787074f, 
    0.27730116f, 0.21943827f, 0.22588441f, 0.02374985f, 0.14558969f, -0.02712959f, 0.08776732f, 0.01885806f, 
    -0.08721951f, 0.00599396f, 0.32502559f, -0.30564114f, 0.04322244f, 0.13248116f, -0.00758093f, 0.11437079f, 
    0.05686905f, 0.08212391f, 0.01598951f, -0.03974689f, -0.21071926f, -0.16228241f, -0.13173088f, 0.04310190f, 
    0.26842213f, 0.03338832f, 0.12037341f, 0.10810369f, 0.05225735f, 0.08309485f, 0.08499777f, 0.09666348f, 
    0.04696459f, 0.03985872f, 0.11969107f, 0.02953693f, -0.35458457f, -0.01470551f, 0.06481087f, -0.11221647f, 
    -0.00427294f, -0.12678131f, 0.16384184f, -0.04498290f, -0.05128769f, 0.15029342f, 0.08835659f, 0.19455820f, 
    0.08500843f, -0.08040182f, -0.26124683f, 0.08117542f, 0.17647883f, 0.15831545f, 0.02596024f, -0.06987468f, 
    0.12348323f, 0.00342078f, 0.04978490f, -0.04364792f, 0.01984128f, 0.15476300f, 0.06278868f, -0.16215163f, 
    -0.03581586f, -0.04411089f, 0.25344241f, -0.10599156f, -0.00183189f, 0.10235417f, 0.14149058f, 0.04593076f, 
    -0.55950451f, -0.32166517f, 0.02418339f, -0.18697582f, -0.15730843f, 0.03062682f, 0.01191584f, -0.21660312f, 
    -0.09296645f, -0.09340104f, -0.00237445f, 0.17205322f, 0.20236973f, 0.15781778f, 0.03581403f, 0.03699017f, 
    0.17441222f, 0.08981060f, -0.10588484f, 0.04449433f, -0.11408284f, -0.07613652f, 0.17199755f, 0.10651065f, 
    0.17737186f, 0.12055272f, 0.07478078f, -0.04113089f, -0.09986087f, -0.10377407f, 0.07995605f, -0.00610909f, 
    0.08510128f, 0.32553396f, -0.06004052f, 0.06558721f, -0.45629370f, -0.06480828f, -0.24212918f, -0.12143478f, 
    -0.06323803f, 0.00551281f, 0.17476916f, 0.01498919f, 0.03988239f, 0.09831998f, -0.12506875f, 0.00139066f, 
    -0.12771225f, -0.00019967f, -0.21584083f, 0.02050466f, -0.18827704f, -0.03526523f, 0.13057911f, -0.08252279f, 
    -0.33067736f, -0.00539167f, -0.02634120f, 0.05691429f, 0.17952736f, 0.11014558f, 0.16025187f, 0.32283953f, 
    -0.01185874f, -0.41571209f, 0.05219526f, 0.09425448f, 0.15524246f, 0.00325047f, 0.04544336f, -0.03501708f, 
    -0.42967248f, 0.10277367f, 0.29970214f, -0.00765554f, 0.05271760f, 0.11400289f, 0.11939083f, -0.06258415f, 
    -0.05176348f, 0.07089096f, -0.00171606f, -0.17812611f, 0.01809325f, 0.11274780f, 0.20988742f, 0.22203787f, 
    -0.16613369f, 0.07789039f, 0.13128017f, 0.10094839f, 0.07204578f, 0.02113114f, 0.11796825f, 0.09571397f, 
    -0.13272747f, 0.09341200f, 0.15289357f, 0.27809849f, 0.05060272f, -0.19675098f, 0.13483419f, 0.19180773f, 
    0.10229979f, 0.04321793f, -0.01843557f, 0.14843036f, -0.01990690f, -0.01704044f, 0.01883368f, -0.01978965f, 
    0.05232447f, -0.14675957f, 0.03058894f, -0.11311575f, -0.06231469f, -0.09156801f, -0.01793235f, -0.18377005f, 
    -0.23378724f, 0.08682635f, 0.04706085f, -0.08807381f, -0.08485071f, -0.05761428f, -0.11117138f, -0.14062637f, 
    -0.51923376f, -0.09090324f, 0.08684684f, 0.07250807f, 0.00300217f, 0.01074051f, -0.16580416f, -0.15802267f, 
    0.01903659f, -0.46345642f, 0.12802261f, -0.07495023f, -0.01510759f, 0.14353029f, 0.00182586f, -0.01595058f, 
    0.09029482f, 0.02719291f, -0.92405558f, -0.11752311f, 0.13998917f, -0.20058891f, 0.12385689f, -0.02151191f, 
    0.04405366f, -0.12024441f, 0.05669164f, 0.09802468f, -0.13277785f, 0.09820570f, 0.10484013f, 0.18595482f, 
    -0.05159850f, -0.07645629f, 0.56951427f, -0.23845465f, -0.20557457f, 0.10954966f, 0.08507818f, 0.12873799f, 
    -0.04039471f, 0.17487000f, 0.09030068f, -0.37617856f, 0.08513354f, 0.28795210f, 0.04369608f, 0.01833271f, 
    -0.02696833f, 0.11869170f, 0.09812188f, -0.07226577f, -0.41236097f, -0.47259799f, -0.47270769f, -0.08627039f, 
    0.06246115f, 0.09160951f, 0.16109855f, 0.01833099f, 0.02341207f, 0.04087980f, 0.25021970f, 0.17290750f, 
    -0.03370489f, -0.09636366f, -0.07731793f, -0.00184857f, -0.03399431f, -0.23005728f, -0.30985034f, -0.28555223f, 
    -0.08557217f, -0.27003607f, 0.13055027f, -0.05252361f, 0.01044575f, 0.06436963f, 0.13164702f, -0.16346264f, 
    -0.08202879f, -0.28891462f, 0.01921790f, 0.10218512f, -0.06415732f, 0.07197239f, -0.33897278f, -0.07078888f, 
    0.01824654f, -0.31305766f, 0.04987797f, -0.06348921f, -0.12620375f, 0.45927605f, -0.18769114f, -0.43396679f, 
    0.11770021f, -0.08129434f, 0.12092379f, 0.00661774f, 0.02465986f, 0.10868321f, -0.04439419f, -0.00101670f, 
    -0.06262104f, -0.06840898f, -0.12422483f, 0.07685468f, -0.15130560f, -0.06403155f, 0.06206847f, 0.12683609f, 
    -0.14182599f, 0.09755681f, -0.13389741f, -0.19956847f, 0.01355429f, -0.10501606f, -0.11816418f, -0.10704839f, 
    -0.26213813f, 0.04290611f, 0.08304016f, -0.08179286f, 0.00534785f, 0.10211738f, -0.06450159f, 0.05761940f, 
    0.00040702f, -0.07648285f, 0.07586807f, 0.09219427f, -0.08598152f, 0.03027698f, 0.14567395f, 0.16641290f, 
    0.06622931f, 0.02875544f, -0.11995426f, -0.07431837f, -0.14273389f, -0.22016928f, -0.13155693f, -0.02658780f, 
    0.11812306f, 0.02797613f, 0.01171925f, -0.22939326f, -0.19429328f, 0.48139077f, -0.11395703f, -0.09939037f, 
    0.04211593f, -0.09562591f, -0.01411990f, -0.00258384f, -0.00008919f, 0.05035463f, 0.12783846f, 0.00143225f, 
    0.21555804f, 0.31273630f, -0.05952832f, -0.16348490f, 0.51707655f, -0.22334707f, 0.18592285f, 0.15543707f, 
    -0.01744763f, -0.26620394f, -0.09598257f, -0.03900416f, -0.21234682f, -0.18212414f, -0.10645940f, 0.13040520f, 
    0.00796956f, 0.02557894f, 0.05687673f, 0.10049474f, 0.05265347f, -0.16338181f, 0.13646787f, 0.06678312f, 
    -0.10282234f, 0.05017100f, 0.07634011f, -0.06543462f, 0.36616749f, 0.09415605f, -0.12109821f, 0.37977839f, 
    0.01823498f, -0.11413214f, 0.15411203f, -0.11313708f, -0.01801200f, 0.34657243f, -0.18808754f, -0.14277864f, 
    -0.21814603f, -0.30529583f, -0.01379289f, -0.08502168f, -0.09098180f, -0.48712859f, -0.48091918f, 0.31124571f, 
    -0.07712599f, 0.11283868f, -0.23153463f, 0.05979739f, -0.09099393f, 0.04695063f, -0.25024110f, 0.05086168f, 
    0.07351440f, -0.12928747f, -0.03664721f, 0.05581152f, -0.00264110f, 0.09428088f, -0.15148461f, -0.03350544f, 
    -0.09791543f, 0.22774687f, 0.03436866f, -0.04214429f, -0.10054959f, 0.05252204f, 0.04653749f, 0.11435042f, 
    -0.00595707f, -0.08529707f, 0.24868271f, -0.23554936f, 0.04488743f, 0.02898635f, 0.06483083f, 0.10430979f, 
    0.23268507f, -0.07768504f, 0.08818524f, 0.07395383f, -0.11641014f, 0.11373951f, 0.10255835f, 0.11055457f, 
    0.13027795f, 0.09132285f, -0.13065317f, -0.06025501f, 0.01380799f, -0.07756316f, -0.12210587f, -0.02186123f, 
    -0.02066347f, 0.00491025f, 0.06164838f, 0.07177767f, -0.02895764f, -0.02128990f, 0.06108502f, 0.02121170f, 
    0.20023160f, 0.03202055f, 0.04208951f, -0.09464789f, -0.13022524f, -0.02465365f, -0.13777317f, 0.16891654f, 
    -0.10259280f, -0.02667139f, -0.08483022f, 0.02879714f, -0.07995347f, -0.20430280f, 0.12305817f, 0.01692167f, 
    -0.19396196f, 0.19853184f, -0.16511664f, 0.10037805f, 0.06978939f, 0.04995608f, 0.19338122f, -0.05052213f, 
    -0.00140488f, 0.23344484f, 0.08358198f, 0.05867289f, 0.16739739f, 0.01460802f, 0.26973391f, -0.06495241f, 
    0.41024023f, 0.38936156f, -0.05607784f, 0.03983605f, 0.04517642f, 0.14435296f, -0.07298274f, 0.04729703f, 
    0.10692409f, -0.10271295f, 0.18730462f, -0.03878269f, -0.19140758f, 0.40429792f, -0.08363412f, -0.14686361f, 
    0.08115128f, 0.07101049f, 0.00249718f, 0.12776197f, -0.25656152f, -0.02906151f, -0.13509740f, 0.08131759f, 
    -0.01050248f, -0.00483280f, -0.16207530f, -0.10169733f, -0.01529747f, -0.09992816f, 0.00730893f, -0.07620385f, 
    -0.00935931f, 0.25421819f, 0.10155552f, -0.03587673f, -0.06278776f, 0.22864959f, -0.33518836f, -0.13011488f, 
    -0.10344919f, 0.06740455f, -0.12729549f, -0.12887393f, -0.20334399f, 0.18028794f, 0.24961986f, -0.05645603f, 
    0.10447995f, -0.09739219f, 0.13763192f, 0.07137400f, -0.03303488f, -0.14984566f, -0.10909467f, 0.00417999f, 
    -0.02004976f, -0.08600298f, 0.23663606f, -0.14571857f, -0.03226685f, 0.17007624f, -0.14227243f, 0.43141726f, 
    -0.30404255f, 0.24399686f, 0.15503204f, -0.08592279f, 0.09535121f, -0.09913622f, -0.41137335f, -0.00935561f, 
    0.16672270f, 0.52134109f, 0.03038251f, 0.09304300f, -0.01395657f, -0.00127470f, 0.30149856f, 0.02945777f, 
    -0.13697530f, -0.05946277f, 0.27677789f, 0.09893035f, -0.01844900f, 0.15463106f, 0.23119138f, 0.15084480f, 
    0.14117560f, -0.16568817f, -0.06598134f, 0.02930527f, 0.05484889f, 0.19388716f, 0.09937242f, -0.02646882f, 
    -0.25998846f, -0.02519614f, -0.29488340f, -0.12255824f, -0.19580631f, 0.09266508f, -0.01368662f, 0.06998476f, 
    0.11512526f, -0.02146012f, 0.02157796f, 0.02699230f, 0.05686056f, 0.00362870f, 0.11752424f, 0.16714752f, 
    0.04065004f, 0.07940213f, 0.00084871f, -0.11575803f, -0.00166409f, 0.08124164f, 0.06957675f, -0.01817322f, 
    -0.03639664f, -0.05423363f, -0.13516408f, -0.15044077f, -0.10545171f, -0.28433427f, -0.15574785f, 0.09465627f, 
    0.17681699f, 0.12612602f, 0.22488630f, 0.00206564f, 0.18581280f, 0.12539685f, -0.09294979f, -0.01719514f, 
    0.09811989f, -0.00203203f, -0.08488411f, 0.16200238f, 0.01652406f, -0.10820694f, 0.04007608f, -0.01641566f, 
    0.11079276f, 0.19385618f, 0.10690242f, 0.00313888f, 0.16434565f, -0.03193357f, -0.18394993f, 0.02102600f, 
    -0.11727455f, -0.08202349f, -0.04374733f, 0.07095820f, -0.08519011f, -0.18273900f, 0.03540446f, -0.21579240f, 
    -0.14407419f, 0.01669767f, 0.12354977f, 0.00564056f, 0.07651909f, 0.01867164f, 0.02879651f, -0.04134044f, 
    0.07941847f, -0.14920656f, 0.07085852f, 0.10173552f, -0.22170883f, -0.04768828f, 0.16941239f, 0.18845619f, 
    -0.17158021f, -0.05115210f, 0.05196594f, 0.03419401f, -0.00287088f, 0.05862845f, 0.00914613f, 0.11294705f, 
    -0.00180143f, 0.32021657f, 0.00797000f, -0.03144862f, 0.12525705f, 0.12880407f, 0.27180085f, -0.09075168f, 
    0.05422980f, -0.12113319f, -0.06888451f, -0.22593501f, 0.27664551f, -0.22281717f, -0.11483322f, -0.16511092f, 
    0.01536721f, 0.02676057f, 0.04706981f, -0.14524342f, 0.20838250f, 0.17334300f, -0.01082643f, -0.00271450f, 
    -0.13520546f, -0.04526577f, -0.02697404f, -0.06172250f, 0.06034477f, 0.06836671f, -0.02357025f, -0.23735642f, 
    0.07177608f, 0.06954355f, -0.03883144f, 0.07791046f, 0.04782779f, 0.08937816f, 0.15056808f, 0.03758562f, 
    -0.01283530f, 0.04819255f, 0.22243878f, -0.10389280f, -0.01428759f, 0.26049396f, -0.06043801f, 0.01809100f, 
    0.00278381f, -0.09339355f, 0.05763462f, 0.00792032f, 0.04619215f, 0.00831075f, 0.02428733f, -0.00612751f, 
    0.02120993f, -0.08422119f, -0.08857962f, 0.00694448f, 0.02026721f, 0.07857649f, -0.01356081f, -0.06638439f, 
    -0.14962313f, -0.34047773f, -0.21125789f, -0.32169649f, 0.16423245f, 0.22600773f, 0.00042037f, 0.05452168f, 
    0.03157643f, 0.07653195f, 0.11805144f, 0.11077406f, -0.22791800f, -0.16366464f, 0.00864219f, -0.12059981f, 
    0.05779156f, 0.03417746f, 0.17114817f, 0.12373716f, 0.06695914f, -0.12444068f, -0.14808898f, -0.07018968f, 
    0.13765188f, 0.15968153f, -0.22807090f, -0.19542013f, -0.51797146f, -0.29728812f, -0.03830853f, 0.07581711f, 
    0.03056475f, -0.24697648f, 0.04785248f, -0.13375577f, 0.07775877f, 0.04897556f, 0.00443576f, -0.12693186f, 
    0.07670753f, 0.22397533f, 0.06974119f, 0.13799450f, -0.06679743f, -0.02281949f, -0.01891881f, -0.06388031f, 
    -0.16946773f, 0.22649956f, 0.25508541f, -0.12457002f, 0.18494691f, -0.08661369f, 0.08149628f, 0.13485888f, 
    -0.09126058f, 0.20261954f, 0.04095881f, 0.09315756f, 0.00724384f, -0.12116542f, -0.15583640f, -0.13926898f, 
    0.15557103f, 0.21955664f, 0.03411752f, -0.03508992f, 0.03391642f, -0.05916033f, 0.11541421f, -0.09788444f, 
    -0.00494777f, -0.03639314f, -0.01342665f, 0.37404451f, -0.11783828f, 0.16295210f, -0.01121749f, -0.14956903f, 
    -0.20879470f, 0.05295717f, 0.28578407f, 0.12418997f, -0.04647663f, -0.05834871f, 0.05685500f, 0.02681563f, 
    -0.21350569f, -0.12695195f, -0.03411980f, -0.00994510f, -0.05057595f, -0.30370039f, -0.02675237f, 0.59842283f, 
    -0.02089725f, -0.10212577f, -0.06094123f, 0.04285719f, 0.10108726f, 0.18725203f, -0.32576323f, -0.18875326f, 
    -0.01539656f, 0.08146174f, 0.21391121f, -0.08367833f, 0.00790738f, 0.05197675f, 0.13304867f, -0.06107469f, 
    -0.04797961f, -0.25252181f, -0.11514439f, 0.00951356f, 0.05028782f, 0.10028096f, -0.01204542f, -0.02371377f, 
    0.08378712f, 0.25382999f, -0.43116513f, -0.25336817f, 0.13820146f, -0.06642714f, 0.08757301f, -0.17252895f, 
    0.10697588f, -0.07741340f, -0.09249387f, 0.12802073f, 0.00059333f, 0.00003928f, -0.05479569f, 0.06850941f, 
    0.16439357f, -0.14137657f, 0.09626592f, -0.00610310f, -0.17726043f, 0.03750690f, 0.18709411f, -0.36610767f, 
    0.18877368f, 0.00095950f, 0.04139928f, 0.08952267f, -0.03691759f, -0.01241180f, -0.06295113f, -0.00899099f, 
    -0.11229325f, -0.00672150f, 0.25012174f, 0.06957175f, 0.12079936f, -0.02055646f, -0.11956086f, -0.24192302f, 
    -0.18309377f, -0.07234707f, 0.18294922f, 0.17293693f, 0.04551574f, -0.24040739f, 0.19528303f, 0.36996755f, 
    0.13968192f, -0.01169981f, 0.14707913f, 0.10367111f, 0.06815311f, 0.15350899f, 0.04422401f, 0.21980657f, 
    -0.11187239f, 0.02244764f, -0.17341061f, -0.13368367f, 0.15549098f, 0.06304440f, 0.13474913f, 0.05283329f, 
    0.13940060f, -0.05128929f, -0.26182932f, -0.29335546f, -0.18011029f, 0.07707550f, 0.16385409f, 0.06760332f, 
    -0.34023446f, -0.11861809f, -0.09463523f, -0.13175781f, 0.20559666f, -0.25192595f, 0.05816728f, 0.10197932f, 
    0.07410760f, 0.11689340f, 0.06007851f, -0.05939667f, -0.30503759f, -0.00156744f, -0.06343050f, 0.11919524f, 
    0.06657927f, -0.00395364f, 0.65266502f, -0.37780103f, -0.29972062f, 0.14821754f, -0.02005392f, 0.07156118f, 
    -0.07187360f, 0.02776157f, -0.03484371f, 0.40834627f, -0.01368994f, -0.08571714f, -0.14629008f, 0.20579407f, 
    -0.01617634f, 0.17817274f, 0.04464979f, -0.10188103f, 0.10060818f, -0.18359010f, -0.25048229f, -0.37607485f, 
    -0.04626778f, -0.36985523f, 0.07231762f, 0.01169886f, 0.09735673f, -0.47858119f, 0.11068519f, -0.11883462f, 
    0.00408191f, 0.04426637f, -0.11940312f, -0.13446996f, -0.08491461f, 0.13315368f, -0.04375751f, 0.08093537f, 
    -0.04054355f, 0.07701488f, -0.15776250f, -0.12228511f, -0.16659419f, 0.13611795f, 0.06770089f, 0.09587053f, 
    0.16189554f, 0.16248947f, -0.03851257f, -0.05344031f, -0.02935015f, 0.06035628f, 0.06432628f, 0.05161677f, 
    -0.10431889f, -0.09596194f, 0.21042006f, 0.04325936f, -0.06776188f, -0.03652753f, -0.11444226f, 0.02633076f, 
    -0.04963557f, 0.17588602f, -0.01458997f, -0.11118279f, -0.10818587f, -0.08989605f, -0.35469580f, 0.11161619f, 
    0.09938243f, 0.05934973f, 0.01094976f, 0.09990255f, -0.05490010f, -0.06379294f, 0.15053456f, 0.02013913f, 
    0.04671673f, 0.08347898f, 0.02213286f, 0.16310896f, 0.12726919f, 0.06162015f, -0.01087274f, 0.18143970f, 
    -0.03760707f, 0.11094496f, 0.09999850f, -0.12544224f, -0.10315994f, -0.12774381f, -0.04824259f, 0.11781113f, 
    0.03103529f, -0.13549782f, -0.06688317f, 0.06129901f, -0.05148888f, -0.36271447f, -0.29827815f, 0.24789228f, 
    -0.02421804f, 0.05873907f, -0.05353270f, 0.00161395f, 0.03845787f, 0.06554122f, 0.22400434f, -0.26469791f, 
    -0.10655273f, -0.12021989f, -0.00835158f, -0.06343011f, 0.27056557f, 0.18225387f, 0.10017975f, -0.10083868f, 
    0.03352814f, 0.31210080f, 0.00525472f, -0.06092537f, -0.11260189f, -0.00761761f, 0.04484363f, -0.07294498f, 
    0.07219703f, 0.19224657f, -0.23385577f, -0.03328913f, 0.04778650f, -0.13313171f, 0.09939930f, -0.08792222f, 
    -0.21719804f, 0.17776731f, -0.11644576f, -0.14146662f, 0.14273649f, 0.06614875f, 0.04616309f, -0.03121478f, 
    -0.02309102f, 0.02193255f, 0.25591552f, 0.13116097f, -0.09384093f, 0.12698175f, 0.02138253f, 0.01035295f, 
    0.12636702f, 0.08541504f, 0.02727152f, -0.39985445f, -0.19440915f, 0.21476276f, 0.12092808f, -0.02904286f, 
    0.01638528f, -0.02093895f, -0.07489236f, 0.06938261f, -0.14487375f, -0.02751464f, 0.63719022f, 0.04014671f, 
    -0.11688727f, -0.22549123f, 0.08675885f, -0.05232415f, -0.06588264f, -0.34413457f, 0.05558312f, 0.48762727f, 
    0.02555083f, 0.18492910f, 0.10715117f, 0.00972368f, 0.12474725f, -0.07288270f, 0.37643561f, -0.00867755f, 
    -0.17588462f, -0.47867268f, -0.06541129f, 0.09495968f, 0.04021633f, 0.01687436f, 0.01314570f, -0.27101079f, 
    -0.07118924f, 0.31920919f, 0.00141575f, -0.00245739f, -0.12822999f, -0.10303243f, 0.01728973f, 0.09431058f, 
    0.19154012f, -0.16903664f, -0.01452974f, 0.19015670f, -0.21695355f, 0.11422540f, -0.10130074f, 0.14285377f, 
    0.03377193f, -0.10374602f, 0.07986355f, 0.35992202f, 0.01459772f, -0.10605745f, 0.19517697f, -0.17941761f, 
    -0.04393115f, -0.12901887f, 0.01498775f, 0.09132058f, 0.14379251f, 0.00168114f, 0.01222047f, 0.03634805f, 
    -0.05632382f, -0.08428321f, -0.01138816f, -0.10000576f, 0.03458807f, 0.11899894f, 0.22989257f, 0.08675388f, 
    0.13548361f, 0.11039764f, 0.12806900f, -0.11396337f, 0.01031446f, 0.06841218f, 0.00432493f, 0.05107673f, 
    0.01636474f, 0.02194678f, 0.00204423f, -0.05163307f, 0.00914319f, 0.24905114f, -0.07796784f, -0.13078667f, 
    -0.12723909f, -0.00229943f, -0.25049573f, -0.03165571f, 0.19306812f, 0.17365764f, 0.14974250f, -0.19844544f, 
    0.04242824f, 0.05861837f, 0.08568074f, 0.04622803f, 0.06883943f, -0.11918718f, 0.01451749f, 0.06161106f, 
    0.08790059f, 0.13889405f, 0.06718569f, -0.05405886f, 0.09975974f, -0.00511702f, -0.02696270f, 0.00859178f, 
    -0.01050864f, -0.07746691f, 0.12468261f, -0.25222135f, -0.02974838f, -0.16874172f, 0.12362072f, -0.10220382f, 
    -0.10713292f, -0.21122235f, -0.06435167f, 0.07100378f, 0.15958154f, -0.09863929f, -0.01149594f, -0.00379004f, 
    0.12428667f, 0.00828447f, -0.01589767f, 0.09624892f, -0.00672131f, -0.02819042f, -0.07240470f, 0.06074529f, 
    -0.12063242f, -0.27000067f, -0.15875156f, -0.37946776f, -0.03215974f, -0.24315709f, -0.06428073f, -0.02957164f, 
    0.02401803f, 0.07044466f, -0.04047954f, -0.08019080f, -0.25819242f, 0.24488547f, 0.20778804f, 0.06313416f, 
    -0.10112000f, 0.09206741f, -0.02127963f, 0.23323089f, -0.29305050f, -0.24706756f, 0.01285304f, 0.01862495f, 
    -0.47393364f, 0.26651129f, -0.10768924f, 0.13390243f, -0.06590942f, 0.18312636f, 0.00191357f, 0.11238920f, 
    -0.06814133f, 0.14420256f, 0.14411660f, 0.09712297f, 0.15682861f, 0.00487834f, -0.10641272f, -0.06031744f, 
    -0.10787045f, -0.12191325f, 0.11353842f, -0.04348555f, -0.02147593f, 0.15572250f, 0.02682728f, 0.13351545f, 
    -0.47796750f, -0.11206625f, 0.25400212f, 0.09780758f, 0.22044654f, 0.15685652f, 0.13388507f, -0.11556275f, 
    -0.12606828f, -0.03165900f, -0.09261685f, -0.07183850f, 0.09883937f, 0.17919818f, 0.01457864f, 0.06733829f, 
    -0.03354465f, -0.26355758f, 0.19488829f, 0.15596706f, 0.32107574f, 0.20755357f, 0.04788268f, -0.11263734f, 
    -0.17346607f, -0.05976991f, -0.20071013f, -0.19973680f, -0.33043551f, -0.07992879f, -0.25501341f, -0.04535117f, 
    -0.01627711f, 0.14498316f, 0.02670434f, -0.04718129f, -0.04029498f, -0.19304290f, -0.45470887f, 0.18781795f, 
    0.10265020f, 0.14905329f, 0.01769098f, 0.02636178f, 0.04196808f, 0.34499025f, 0.23222843f, 0.33312789f, 
    -0.14268659f, 0.04349800f, -0.31288818f, -0.13115433f, -0.12217107f, -0.06880885f, -0.14961115f, -0.42107639f, 
    -0.43075377f, 0.11617012f, -0.16756335f, -0.10311891f, 0.06736325f, 0.10335993f, 0.00922636f, 0.01899307f, 
    -0.13298784f, -0.07327027f, 0.03177000f, -0.10553895f, -0.07385956f, 0.08827800f, -0.02451747f, -0.05078681f, 
    0.05530849f, -0.08641542f, 0.26317769f, 0.02676418f, -0.23289222f, 0.16563642f, 0.02753256f, 0.05691202f, 
    -0.24588683f, -0.16879509f, 0.04408548f, 0.21246216f, -0.00463971f, -0.03452457f, -0.02917767f, 0.08973607f, 
    -0.02842552f, -0.19125569f, 0.29800650f, 0.11856514f, -0.07292836f, 0.11730517f, 0.13950966f, 0.13185941f, 
    0.06694827f, 0.10101103f, -0.14941238f, 0.07009118f, -0.03810902f, 0.06719406f, 0.05487894f, -0.03189124f, 
    -0.05065054f, 0.23238914f, -0.01811128f, -0.08423344f, 0.17831890f, 0.22725460f, -0.39859605f, 0.04298910f, 
    0.17302102f, -0.09241109f, 0.18448183f, 0.03854659f, -0.02693167f, -0.14387201f, -0.17184180f, 0.14710851f, 
    0.28053698f, -0.18312360f, 0.05973639f, -0.13127424f, 0.09584742f, -0.00447475f, 0.16587995f, -0.21686324f, 
    0.06455360f, 0.09395392f, -0.05445259f, 0.11423573f, -0.14243196f, 0.03257322f, -0.08072136f, -0.21157144f, 
    -0.41912794f, -0.57669449f, 0.15199323f, 0.15876013f, 0.04025714f, 0.10821258f, -0.00782146f, 0.03527267f, 
    -0.35578403f, 0.20938218f, -0.11030492f, 0.01198946f, 0.05468966f, 0.07785258f, 0.04793792f, 0.21646862f, 
    0.06647064f, -0.22159983f, -0.19050711f, 0.07089385f, 0.05623693f, 0.13586704f, 0.07270286f, -0.02332473f, 
    -0.10930433f, -0.02177180f, 0.00816135f, -0.13863367f, -0.13422284f, -0.00528502f, 0.02702008f, 0.00284390f, 
    0.07003625f, 0.06381012f, -0.02574224f, 0.03966968f, 0.08806454f, -0.01364825f, -0.01812492f, -0.00845303f, 
    0.02141440f, 0.07463255f, -0.02724069f, -0.03672188f, -0.12166039f, -0.09400789f, -0.20636763f, -0.14173152f, 
    -0.00786335f, 0.15424110f, -0.11375997f, -0.22257939f, -0.31704366f, -0.16435555f, -0.15349931f, 0.14567970f, 
    0.11915962f, 0.17956288f, 0.22039467f, 0.08474711f, 0.10170878f, 0.24545196f, -0.40473858f, 0.23137045f, 
    -0.01235102f, -0.00054635f, -0.07300367f, 0.13709064f, -0.10001210f, -0.03793247f, 0.20221514f, -0.40495041f, 
    0.14624006f, -0.14799318f, 0.07283348f, -0.06493387f, 0.10531814f, 0.05674705f, -0.03310839f, -0.21999235f, 
    -0.01950118f, 0.06568687f, -0.10815883f, 0.20644726f, -0.04326905f, 0.03190523f, 0.19356973f, 0.05994464f, 
    -0.22629622f, -0.01229515f, -0.01458475f, -0.14193594f, -0.14149077f, -0.00641135f, 0.12913851f, -0.01246221f, 
    0.07497170f, -0.31931636f, 0.21422687f, -0.01693459f, -0.03746562f, 0.08260606f, 0.21133552f, -0.01735061f, 
    0.11028764f, -0.17269358f, 0.05748536f, 0.11198833f, 0.19385421f, -0.00807577f, 0.27506173f, 0.15538679f, 
    0.03769151f, 0.04208098f, -0.00820631f, 0.00912206f, -0.01190654f, -0.58795393f, -0.09835985f, 0.01142455f, 
    0.09936187f, 0.25769350f, -0.15849176f, -0.10847299f, -0.57496059f, 0.20478454f, -0.36835667f, -0.10206311f, 
    0.10877880f, -0.04090692f, 0.11440860f, 0.15503025f, -0.01013327f, 0.18760435f, 0.17947359f, 0.28169230f, 
    -0.12081720f, -0.14790629f, -0.03200644f, 0.01660686f, -0.06404926f, 0.03822711f, -0.17740214f, 0.00525004f, 
    0.01197372f, 0.12544648f, 0.04120794f, -0.00847741f, 0.06756272f, 0.04193868f, 0.08969311f, 0.20397149f, 
    -0.09739430f, -0.03955536f, 0.18543372f, 0.14149702f, 0.06909754f, -0.02823749f, 0.03040213f, -0.10762163f, 
    0.10651200f, 0.15463930f, -0.10552422f, -0.25471908f, -0.07559634f, -0.00068845f, -0.20754190f, -0.08545330f, 
    -0.04323980f, -0.18071674f, -0.07551829f, -0.08353405f, -0.08147881f, -0.04006549f, 0.01706569f, -0.01758776f, 
    -0.10064537f, -0.10655858f, 0.01152688f, 0.08228523f, 0.01689443f, 0.14777696f, 0.21781352f, 0.02495175f, 
    0.05383720f, 0.16039029f, -0.01196184f, 0.04582445f, 0.02023110f, -0.27390498f, -0.02144669f, -0.00797254f, 
    -0.03234121f, 0.07465717f, -0.00043467f, 0.10037849f, 0.09490535f, -0.01086512f, -0.11283197f, -0.04369193f, 
    0.07630167f, 0.10996680f, -0.12888737f, 0.01614003f, -0.07207739f, -0.17170320f, -0.04029768f, -0.06006039f, 
    0.05059537f, 0.06077562f, 0.00791573f, 0.03678266f, -0.01730084f, 0.05921728f, 0.09149575f, -0.21149874f, 
    -0.04871376f, 0.02412494f, 0.10045665f, 0.07204568f, 0.04428352f, -0.11149903f, -0.00886998f, -0.04989119f, 
    -0.36756817f, 0.30729711f, 0.15588671f, -0.00327713f, 0.40847379f, -0.18346037f, -0.03920819f, -0.02733069f, 
    -0.02188799f, -0.06573600f, -0.33782977f, -0.10387380f, 0.14302377f, 0.17346992f, 0.15536067f, 0.03976471f, 
    0.03919591f, -0.02111846f, 0.15349896f, 0.34843516f, 0.14560691f, -0.09603426f, 0.04832029f, -0.25994003f, 
    -0.05788819f, -0.04630874f, -0.10733232f, 0.16796918f, -0.51199943f, -0.09729907f, 0.05760114f, 0.01342786f, 
    0.15032515f, -0.09441817f, 0.08669477f, -0.03041849f, 0.22107257f, 0.33477265f, 0.02295723f, 0.10624224f, 
    -0.00079334f, 0.01867614f, -0.19811502f, -0.08781031f, -0.05381825f, -0.54347318f, 0.18544847f, 0.28450239f, 
    0.10749725f, 0.21079047f, -0.02164560f, 0.00908611f, 0.10156414f, 0.02171615f, -0.79780114f, 0.35109967f, 
    0.14897797f, -0.01500994f, 0.09109948f, 0.15248792f, 0.08586704f, 0.17205523f, 0.13585871f, 0.13026461f, 
    -0.41339514f, -0.13445008f, -0.07041412f, 0.13142347f, 0.19080073f, 0.09915594f, -0.04002186f, 0.00581804f, 
    0.05231914f, 0.03200708f, -0.03854569f, -0.02016460f, 0.00516681f, 0.04009165f, 0.03536716f, 0.03203950f, 
    -0.02839092f, 0.01898902f, -0.01740076f, -0.01102054f, -0.06170630f, 0.01431223f, -0.04736423f, 0.01183817f, 
    -0.03548617f, -0.00491676f, 0.00111370f, -0.06243184f, -0.05291396f, -0.03349036f, -0.00412324f, -0.00540321f, 
    0.05058471f, -0.03078865f, 0.03557071f, 0.00247399f, 0.03817565f, 0.02304307f, 0.00285701f, -0.00345432f, 
    0.01642082f, 0.00501531f, 0.02126940f, -0.02804042f, -0.03764404f, 0.03366258f, -0.04813361f, -0.02693854f, 
    -0.05234381f, -0.00648470f, -0.00750908f, -0.02779474f, -0.03308035f, -0.04569831f, -0.01473728f, -0.06219430f, 
    0.03067649f, 0.01505177f, 0.02951384f, 0.04277756f, -0.06350685f, 0.02251779f, -0.02493969f, -0.05434346f, 
    -0.02811309f, 0.00905391f, 0.03582844f, -0.03934213f, -0.03376976f, 0.02885885f, -0.02146785f, -0.03021132f, 
    -0.05346593f, -0.03457463f, 0.03635908f, -0.03426036f, -0.03750557f, 0.02197316f, -0.03114489f, -0.01764427f, 
    0.00279720f, -0.03588348f, 0.01899530f, 0.03241947f, -0.05034121f, 0.02666063f, -0.04848357f, -0.05309724f, 
    0.04573199f, -0.03385236f, -0.01139500f, -0.02130674f, -0.03120935f, -0.01205693f, 0.04975692f, -0.00114080f, 
    0.00871876f, -0.00506484f, 0.04824699f, -0.00688403f, -0.00899929f, -0.05541717f, 0.03895986f, 0.00205329f, 
    -0.02833804f, -0.01870788f, -0.05240213f, -0.04266378f, -0.04791418f, -0.02375107f, 0.02699856f, -0.03232661f, 
    -0.01239538f, 0.02363598f, -0.04000211f, 0.00163024f, 0.01868585f, 0.01714615f, -0.06140510f, -0.04116155f, 
    -0.04419940f, 0.04212787f, -0.03193786f, -0.04921762f, -0.04107814f, -0.04295850f, -0.03361597f, -0.05142534f, 
    -0.05787540f, -0.00413744f, -0.03002401f, 0.02442664f, 0.03341618f, 0.05316417f, -0.04352639f, 0.00099825f, 
    -0.04069224f, -0.05087259f, 0.03592096f, -0.04879985f, 0.02688706f, -0.04748298f, -0.05606932f, -0.01636337f, 
    -0.02566656f, -0.01099747f, 0.00107766f, -0.05009363f, -0.03572492f, 0.02637844f, 0.04058161f, -0.03756260f, 
    -0.01240510f, -0.03442190f, -0.05205930f, 0.03615896f, 0.02491084f, -0.05318285f, 0.03909206f, -0.02296143f, 
    -0.00302813f, 0.05701185f, -0.00455999f, 0.02819326f, -0.04196747f, -0.03740993f, -0.01202502f, 0.05311704f, 
    0.05557297f, -0.02875006f, 0.03356662f, -0.01001667f, 0.05264731f, -0.00051565f, -0.06068509f, 0.01942535f, 
    -0.05046866f, -0.03035852f, -0.05279046f, 0.01141856f, -0.05622895f, 0.03783888f, 0.04213360f, 0.04177597f, 
    -0.03064288f, -0.05351042f, -0.01332782f, -0.01906633f, -0.01465578f, -0.06247162f, 0.02135727f, -0.02379087f, 
    0.04370708f, -0.01954010f, -0.02740416f, 0.05216195f, 0.02026086f, 0.03868126f, -0.00982168f, -0.01510899f, 
    0.02734539f, 0.01513069f, 0.01142275f, -0.03435731f, 0.00200829f, -0.04137087f, -0.04900556f, -0.02129195f, 
    0.02615857f, -0.00547140f, -0.05276221f, -0.04006474f, 0.02495877f, -0.02049059f, 0.01023703f, 0.00572105f, 
    -0.05883133f, -0.04118716f, -0.05020319f, 0.02906547f, 0.02658916f, -0.03866315f, 0.03667943f, -0.04466632f, 
    0.02960151f, 0.03511825f, -0.05867713f, 0.04369903f, 0.03700491f, 0.04604714f, -0.02255801f, -0.01537568f, 
    0.02411673f, -0.03984644f, -0.04860827f, 0.02052223f, 0.02884339f, -0.02884660f, -0.05615330f, 0.04719282f, 
    -0.05758738f, -0.04806467f, -0.05558189f, -0.01238424f, 0.02436175f, -0.06268488f, 0.02822192f, 0.05190843f, 
    0.00037149f, -0.03650200f, 0.02573640f, -0.04018221f, 0.03216445f, -0.04111310f, -0.06254505f, 0.00906965f, 
    -0.03479885f, 0.03422380f, -0.01908397f, -0.05518337f, -0.01101002f, 0.03983350f, -0.04756128f, 0.00097320f, 
    0.03151358f, 0.00065741f, -0.04833493f, -0.04589160f, 0.03541351f, -0.02860077f, -0.03075086f, -0.00892944f, 
    -0.02167364f, -0.03675139f, -0.02636952f, -0.00345546f, -0.04157394f, 0.00451061f, -0.01560216f, -0.05618107f, 
    -0.05297725f, -0.05548451f, -0.05057602f, -0.02494860f, 0.05062600f, -0.03752215f, -0.01830005f, 0.05054034f, 
    0.01807431f, -0.01753375f, -0.03543864f, 0.04966537f, 0.00588383f, 0.02012953f, 0.04028191f, 0.04038713f, 
    0.40663856f, 0.00912019f, 0.29482311f, 0.05127936f, -0.17809413f, 0.18285680f, 0.14906171f, -0.35947394f, 
    0.18723416f, 0.15576710f, -0.03090636f, -0.25566131f, 0.03794443f, -0.12318014f, -0.02527854f, 0.00247312f, 
    0.05193480f, 0.14861055f, -0.14319578f, 0.12188879f, 0.07890962f, 0.05380311f, 0.10581351f, 0.02048371f, 
    0.23882999f, 0.06437146f, -0.09135979f, -0.01511219f, 0.00670530f, 0.08293176f, 0.04776800f, 0.09085330f, 
    0.06347273f, -0.07287496f, 0.02491899f, -0.02577230f, -0.16579019f, 0.10469835f, 0.08054623f, -0.01107323f, 
    -0.10216332f, -0.12823553f, -0.25730512f, -0.05679847f, -0.05671512f, 0.27079388f, 0.12822932f, -0.10369792f, 
    -0.01380692f, 0.06361019f, -0.01108808f, 0.13597199f, 0.29213229f, 0.09355454f, 0.15561335f, -0.02531357f, 
    0.09595985f, 0.03183244f, -0.00009875f, -0.07839005f, -0.18491068f, -0.14168780f, -0.07261845f, -0.02326520f, 
    0.02254570f, 0.16109583f, 0.04896770f, 0.00478721f, -0.15092109f, -0.08156163f, 0.11792558f, -0.03068629f, 
    -0.14799391f, 0.06246654f, -0.42074859f, -0.34600797f, 0.21661009f, -0.05743987f, 0.06655342f, -0.06296599f, 
    -0.01146829f, -0.02432562f, -0.06384414f, 0.10946095f, 0.02502147f, 0.15346536f, 0.00743463f, -0.00345959f, 
    0.26608297f, 0.00277740f, -0.07192749f, 0.36709172f, 0.12333048f, -0.01192953f, -0.20206325f, 0.18185817f, 
    -0.14940482f, 0.13672258f, -0.05596508f, 0.11628555f, -0.01880573f, 0.07785234f, -0.09233159f, 0.16978678f, 
    0.03635266f, 0.27838686f, 0.01182410f, 0.01873444f, -0.42507198f, -0.09880024f, 0.02453414f, 0.05555049f, 
    -0.13410251f, 0.00114769f, 0.08406944f, -0.06215444f, -0.06076857f, -0.36628330f, 0.10242264f, -0.07328057f, 
    0.12389360f, -0.08356427f, -0.01463590f, -0.02493029f, -0.02267582f, -0.04243929f, -0.05133297f, -0.07596118f, 
    0.20275213f, 0.10781484f, 0.10016053f, -0.06494860f, -0.09009564f, 0.05710581f, -0.02372873f, 0.15718466f, 
    -0.03745738f, -0.10977147f, -0.00105998f, 0.13400529f, 0.30727291f, 0.10343120f, -0.07322479f, 0.14830089f, 
    -0.42224383f, 0.13374567f, 0.32844728f, 0.00553230f, 0.00604372f, -0.02339543f, -0.10415394f, -0.11778281f, 
    0.06676172f, -0.02987125f, 0.15871012f, 0.30209360f, 0.02133385f, 0.03018364f, 0.08303617f, -0.17252232f, 
    -0.10421167f, -0.05222945f, 0.20874543f, 0.17719872f, 0.02398115f, -0.17301571f, -0.10116538f, 0.05332118f, 
    -0.07061167f, -0.05358703f, -0.06777449f, 0.02186454f, 0.02192310f, 0.11496034f, 0.19790673f, 0.21891600f, 
    0.28480265f, 0.10518110f, -0.01421494f, 0.09948592f, 0.15097527f, -0.01706777f, -0.31478104f, -0.05933473f, 
    0.02972127f, -0.01751297f, 0.20191711f, -0.06076286f, 0.14868426f, -0.03843565f, 0.15776379f, -0.54332691f, 
    -0.31751367f, -0.08892847f, 0.03864295f, -0.17865016f, -0.07190710f, 0.00013306f, 0.08888245f, -0.11412291f, 
    -0.38650739f, -0.09134136f, -0.00979113f, 0.04641774f, 0.07212634f, -0.04321720f, 0.24907570f, 0.09222047f, 
    -0.18044125f, -0.36470872f, -0.17384088f, -0.05057263f, 0.07333329f, 0.06088309f, -0.18082744f, 0.18150705f, 
    0.26211700f, -0.18550402f, -0.06516934f, -0.13440175f, -0.21335082f, 0.25615090f, 0.02623305f, -0.15696457f, 
    -0.04592434f, -0.21757481f, 0.19194330f, 0.12269077f, -0.07158458f, 0.01846907f, 0.00276503f, -0.35881877f, 
    -0.13756399f, -0.01886666f, 0.47712320f, -0.14926238f, -0.14532128f, -0.09911045f, 0.34286600f, -0.06244565f, 
    0.00378356f, 0.05366519f, -0.08113681f, -0.36466831f, -0.06219587f, 0.16826431f, 0.16349235f, 0.02631117f, 
    -0.11776641f, -0.16006479f, 0.02262851f, 0.06071280f, -0.11014616f, -0.27849722f, -0.70902181f, 0.09343603f, 
    0.08343526f, 0.19147085f, 0.07259929f, -0.09397201f, 0.08509982f, 0.36856332f, -0.14859118f, 0.20348097f, 
    0.02412701f, -0.07100541f, 0.05098676f, 0.09482450f, -0.26480633f, -0.05111311f, 0.09597678f, 0.10165785f, 
    -0.08760918f, -0.03313463f, 0.09146903f, 0.09729243f, 0.10696120f, 0.21599689f, -0.23148087f, -0.23018320f, 
    -0.04705654f, -0.02722131f, 0.09553178f, 0.00400921f, -0.06572349f, -0.08112205f, 0.03045809f, 0.02198010f, 
    0.03305707f, 0.22145432f, -0.05463180f, -0.04949996f, -0.04033971f, -0.03753261f, -0.10285573f, -0.12965967f, 
    0.11740452f, 0.04530549f, -0.26182157f, -0.10919565f, 0.09968936f, 0.25874123f, -0.05101275f, 0.05666871f, 
    0.22135767f, 0.02897601f, -0.07746123f, -0.14485326f, -0.10230883f, 0.05079154f, 0.11272545f, -0.01723710f, 
    0.04291795f, -0.06101367f, 0.31263429f, 0.48909429f, 0.19576038f, 0.20848547f, -0.02739969f, -0.02413395f, 
    0.02669417f, 0.02746992f, -0.07364481f, -0.20546420f, -0.08423313f, -0.07340851f, -0.20425522f, -0.23195036f, 
    -0.01883631f, -0.06232093f, -0.00170548f, -0.09298721f, 0.00182915f, -0.03025801f, 0.13805732f, -0.10265557f, 
    -0.03294145f, 0.27343908f, 0.03762926f, 0.04308859f, -0.16663286f, 0.12570713f, 0.27673003f, 0.06337011f, 
    -0.12135378f, -0.10019711f, -0.18680637f, -0.07886420f, -0.14376946f, 0.06062454f, -0.12035365f, 0.07291441f, 
    0.05743933f, -0.09468501f, -0.20313084f, 0.04696393f, -0.16472340f, 0.03708476f, 0.08086007f, 0.15565754f, 
    -0.51805604f, -0.39691156f, -0.23596482f, 0.03826474f, -0.02420583f, -0.27695134f, -0.00369674f, 0.05464907f, 
    -0.07463585f, 0.10954679f, 0.02861428f, 0.00248648f, -0.17022909f, 0.06458167f, -0.17181206f, 0.13855144f, 
    -0.11564129f, -0.16020860f, 0.02697987f, -0.35716227f, -0.05014783f, 0.01152266f, 0.10399707f, 0.09617762f, 
    0.03968185f, 0.09611816f, 0.09929542f, 0.09502334f, -0.08568413f, 0.28624567f, 0.10246446f, 0.23674130f, 
    -0.00737708f, 0.20689102f, 0.15643187f, -0.11890980f, -0.10874423f, -0.23253788f, -0.28850931f, -0.24593490f, 
    0.08191960f, -0.04482594f, -0.30801472f, -0.05564108f, 0.06769648f, 0.21749477f, -0.29447314f, -0.19479869f, 
    -0.08555979f, 0.02506369f, 0.16034681f, 0.10180591f, -0.07748907f, 0.16349986f, 0.47816324f, 0.21025473f, 
    0.21993244f, -0.14436260f, -0.04799841f, -0.08499029f, -0.05192427f, 0.04540346f, 0.13211231f, 0.23370469f, 
    0.04415814f, 0.06106026f, -0.03992607f, -0.25318986f, 0.10060502f, 0.16171303f, -0.09529985f, -0.03897989f, 
    0.61571604f, 0.01308509f, 0.09145278f, -0.22216706f, -0.16878349f, -0.04952434f, -0.12261985f, -0.06832867f, 
    0.13421014f, 0.19397807f, 0.10478156f, -0.06032484f, -0.07832491f, 0.04615594f, 0.12651272f, -0.07414690f, 
    -0.09572708f, -0.02858139f, -0.09495836f, -0.17563798f, -0.10534549f, 0.04149726f, 0.06245770f, 0.13457204f, 
    0.31291646f, 0.14479136f, 0.08335747f, -0.12399396f, -0.23784989f, -0.29803228f, 0.20204566f, 0.16361465f, 
    0.21257547f, 0.10723963f, -0.01969823f, -0.03366872f, 0.02644649f, -0.12293343f, -0.23338585f, -0.04167332f, 
    0.11370423f, 0.07252302f, 0.08157383f, -0.12568298f, -0.19745089f, -0.52969462f, -0.37748098f, 0.06313856f, 
    -0.01861774f, -0.00902376f, -0.12801819f, 0.16262950f, 0.12670112f, 0.12824604f, 0.05702896f, -0.18431911f, 
    -0.41275862f, -0.15067022f, -0.27287516f, -0.12487299f, 0.00975800f, -0.00318056f, -0.08374038f, -0.06728476f, 
    -0.20289347f, -0.04365142f, -0.14642388f, -0.06793740f, -0.08080196f, -0.01038872f, 0.00417968f, 0.12704559f, 
    0.12316196f, -0.03429087f, -0.59568936f, 0.09064492f, 0.01804467f, 0.16770999f, 0.01469390f, -0.02783178f, 
    -0.02714351f, -0.07926393f, -0.32409090f, 0.11002269f, 0.14338630f, 0.05999874f, 0.10864130f, -0.01241373f, 
    -0.07907346f, -0.00501897f, 0.74972641f, 0.42186412f, 0.20670949f, -0.05588281f, 0.00939367f, -0.05887855f, 
    -0.08816448f, 0.16374527f, 0.00445437f, -0.35605365f, -0.45043480f, -0.04939907f, -0.17065699f, 0.05377476f, 
    0.14148659f, -0.09113807f, -0.23673873f, 0.04514178f, -0.10668836f, -0.00660348f, 0.25591353f, -0.16146277f, 
    -0.08629282f, -0.07903081f, 0.04514821f, 0.12052098f, 0.08450259f, -0.33620256f, -0.50770867f, -0.28867549f, 
    -0.10162535f, 0.10375816f, -0.06163708f, 0.14827082f, -0.07474172f, -0.03254196f, 0.06173554f, -0.21907882f, 
    -0.43705294f, -0.13238443f, -0.01162218f, -0.13232081f, 0.01047407f, -0.13905041f, 0.09795848f, 0.25012138f, 
    -0.28758305f, -0.67210823f, 0.01079360f, -0.10231663f, 0.06441543f, 0.09728568f, -0.14793752f, -0.02356076f, 
    -0.02334335f, 0.04296064f, -0.02655403f, -0.02030833f, 0.03679005f, -0.06073553f, 0.00159286f, -0.02690969f, 
    -0.04848241f, -0.03200114f, -0.03742437f, -0.03471838f, 0.02601414f, -0.02801140f, -0.00765909f, 0.05552537f, 
    0.02967438f, -0.01834469f, -0.02303324f, -0.04867792f, -0.02270363f, -0.02688328f, 0.04460546f, -0.05795872f, 
    -0.06213136f, -0.02549442f, 0.03946836f, -0.01355095f, 0.04538577f, -0.00940751f, -0.00208889f, -0.06250983f, 
    0.02328815f, 0.03871593f, 0.03449821f, 0.03058562f, 0.05185739f, 0.02571708f, 0.01587217f, -0.03979443f, 
    0.01234502f, -0.03216439f, 0.03348626f, 0.04463723f, -0.00560576f, -0.05535681f, 0.00507104f, -0.01379150f, 
    -0.01109102f, -0.02616259f, -0.04410300f, 0.01015977f, -0.00343410f, 0.02736248f, -0.04063525f, 0.04001674f, 
    -0.03783709f, -0.02354689f, 0.03080245f, 0.03693175f, -0.01730327f, -0.01962720f, -0.05947579f, 0.05293639f, 
    0.02873420f, -0.01173543f, -0.04654093f, -0.03129824f, -0.02826657f, 0.00452449f, -0.02587389f, -0.00021709f, 
    0.05573690f, 0.05983585f, -0.03458456f, -0.01370557f, -0.04600222f, -0.01662750f, -0.04117520f, -0.05548007f, 
    -0.04871643f, -0.05026052f, 0.03394570f, -0.02586978f, 0.03213502f, 0.00113344f, -0.06326190f, 0.00336352f, 
    0.01795021f, 0.05149489f, -0.00615634f, -0.01369945f, -0.04474325f, 0.04688899f, 0.00668031f, -0.04260078f, 
    -0.04330744f, -0.05381161f, 0.01632435f, 0.01606931f, 0.00532552f, 0.02938823f, -0.03922519f, -0.01779900f, 
    0.01478268f, 0.01378424f, 0.04037875f, 0.03030219f, 0.01455240f, 0.03971459f, -0.02975900f, 0.03677169f, 
    -0.05882990f, 0.02782117f, 0.02028006f, -0.05191498f, -0.04721281f, 0.01213115f, 0.06265333f, -0.03428950f, 
    0.01917813f, -0.00189636f, -0.02209384f, -0.00094002f, -0.06317782f, 0.01516792f, 0.02807041f, -0.02971711f, 
    -0.05291565f, -0.01606679f, -0.06241357f, 0.03525815f, -0.02435171f, -0.00180248f, -0.03140585f, 0.02610417f, 
    -0.05010689f, 0.02054109f, -0.04871857f, -0.06214119f, -0.01200678f, -0.05496106f, 0.01624982f, -0.02561742f, 
    -0.05035778f, 0.00364371f, -0.05329041f, 0.01037972f, 0.03151226f, 0.03088954f, -0.03998084f, -0.05766494f, 
    -0.01399393f, -0.00257322f, 0.00263141f, -0.01943422f, -0.05563414f, -0.03815262f, -0.04885652f, 0.03505405f, 
    0.03262293f, -0.00864782f, 0.00980354f, -0.01000413f, 0.04103177f, -0.03797623f, -0.00718934f, -0.02943717f, 
    -0.03354064f, -0.03800893f, -0.01717179f, 0.01509050f, -0.02340136f, -0.00705215f, 0.03872116f, -0.01469391f, 
    0.01051637f, 0.01119223f, -0.02564005f, 0.01361642f, -0.02781704f, -0.03303818f, 0.04438695f, 0.00270766f, 
    -0.02985679f, 0.04644014f, 0.03786606f, -0.04122441f, 0.04248191f, 0.03719271f, 0.03067413f, -0.02895817f, 
    -0.00014996f, -0.03600134f, -0.06031069f, 0.02507352f, -0.00079292f, -0.01593987f, -0.04491263f, 0.01955688f, 
    -0.03093610f, 0.01405247f, -0.02205640f, 0.00822232f, 0.05879556f, -0.01597222f, 0.00551791f, 0.03596540f, 
    0.03505627f, -0.05647621f, 0.02460681f, -0.01223254f, 0.04315585f, -0.02288350f, 0.03341655f, -0.05982769f, 
    0.02619461f, -0.02031539f, 0.04702937f, 0.01669472f, -0.01683866f, 0.02696208f, 0.04416333f, -0.01586669f, 
    0.02496625f, -0.03981954f, -0.01481933f, -0.00159650f, -0.02561877f, -0.05603208f, -0.03411551f, -0.04957142f, 
    0.04035524f, -0.04147742f, -0.04494458f, -0.02490864f, 0.05046819f, -0.00229405f, 0.01953136f, 0.03924541f, 
    -0.03567290f, 0.01446430f, 0.05171904f, -0.04598838f, -0.06044349f, 0.00335592f, -0.00419836f, -0.06209532f, 
    -0.05830461f, 0.00407063f, -0.04987039f, 0.04486975f, 0.02735311f, 0.05605327f, -0.03796913f, -0.01934889f, 
    -0.06410863f, 0.01316636f, 0.01442987f, 0.00489436f, -0.00807428f, 0.00485781f, -0.01904040f, -0.06416208f, 
    -0.01051418f, -0.04461357f, -0.04509347f, -0.03979854f, -0.00729235f, -0.01777253f, 0.01996757f, -0.01880577f, 
    -0.01604146f, 0.04064198f, -0.01581640f, 0.00911521f, -0.06842298f, -0.00159998f, -0.04321602f, -0.02021209f, 
    0.00620799f, 0.02422987f, 0.01050629f, 0.05403955f, 0.00067283f, 0.01962607f, -0.05426427f, 0.04715435f, 
    0.00223056f, -0.01636191f, -0.04658842f, -0.04680621f, -0.04156235f, -0.07037405f, -0.03932524f, -0.04651412f, 
    -0.00963682f, 0.04481612f, -0.07510290f, -0.05856841f, 0.01652971f, 0.02108328f, 0.00999203f, -0.00341707f, 
    -0.00526854f, -0.00160857f, -0.00548817f, 0.00853352f, -0.07937996f, 0.03707394f, -0.03113272f, -0.01736616f, 
    0.03189910f, 0.01305838f, -0.00859494f, -0.07958878f, -0.08283557f, 0.02417811f, 0.03209979f, -0.06608267f, 
    -0.04679726f, -0.01632049f, -0.08393284f, -0.04965713f, -0.04615132f, -0.08264952f, -0.09874025f, -0.05750661f, 
    -0.04142322f, -0.00114460f, 0.01010626f, 0.03132603f, -0.00269822f, -0.08316542f, 0.00486309f, -0.07829222f, 
    -0.06977499f, -0.03606017f, -0.05494025f, -0.01113221f, -0.02832971f, -0.04298557f, -0.04671086f, -0.08211902f, 
    0.00993013f, 0.05849798f, -0.09036066f, -0.05548772f, -0.10205168f, -0.04879242f, -0.04830692f, -0.11334375f, 
    -0.00735801f, -0.02271944f, 0.03505201f, 0.00940070f, 0.02866512f, -0.03798368f, -0.01631492f, 0.00516607f, 
    0.04617447f, -0.05409749f, 0.02836714f, -0.01773469f, -0.08500204f, -0.00720889f, -0.07583033f, 0.02872090f, 
    -0.06531411f, -0.02414940f, -0.00628059f, -0.08540562f, 0.02009977f, -0.01874848f, -0.02270765f, -0.07171740f, 
    -0.06215676f, 0.03882521f, -0.05119205f, -0.01495994f, 0.00078262f, -0.07208572f, -0.06449219f, -0.01145326f, 
    -0.04013073f, 0.03950363f, -0.07358749f, -0.06125880f, -0.01461790f, 0.00974191f, -0.03312568f, 0.02402342f, 
    -0.06171514f, 0.01996959f, -0.00133761f, -0.01610849f, -0.02850378f, -0.07752157f, -0.06808955f, -0.05315108f, 
    0.02647609f, 0.01101047f, -0.09742980f, -0.05251373f, -0.00600897f, 0.00841611f, -0.01524406f, -0.02595523f, 
    -0.05106470f, -0.00536069f, -0.03491744f, -0.05626889f, -0.03913163f, -0.03893730f, -0.07109512f, -0.06315067f, 
    -0.05573129f, -0.01902506f, -0.06206370f, -0.05636122f, -0.03318351f, -0.08667018f, 0.03204682f, -0.04060401f, 
    -0.01691131f, -0.01390675f, -0.02317174f, 0.03358975f, -0.06237987f, -0.05517077f, -0.04356567f, -0.06947082f, 
    -0.04105066f, -0.01828892f, -0.02006119f, -0.11398128f, -0.05870932f, -0.06031018f, -0.06935833f, -0.02526235f, 
    -0.03564456f, -0.04454794f, -0.05662624f, 0.02308614f, -0.07910593f, 0.03107897f, 0.02311525f, -0.02663357f, 
    -0.03930943f, -0.07425150f, 0.00954401f, -0.03856588f, -0.00227536f, 0.01221137f, -0.04908310f, -0.00175143f, 
    -0.00532474f, -0.09536739f, -0.05671103f, -0.06632780f, -0.01740637f, -0.02584925f, -0.01621397f, 0.03324891f, 
    -0.07391380f, -0.01064183f, -0.07729211f, -0.04937324f, -0.00083640f, -0.05363686f, -0.01274429f, -0.02875034f, 
    -0.05235989f, -0.07204701f, 0.02749809f, -0.06497973f, -0.06588736f, -0.05037014f, -0.07801829f, 0.02511823f, 
    -0.00347688f, -0.03286346f, -0.02950632f, -0.06993730f, -0.02036034f, 0.01351587f, -0.02945649f, 0.02693004f, 
    -0.05585295f, -0.05786427f, -0.04823113f, 0.00162978f, -0.00350937f, -0.00434231f, -0.03958952f, -0.06086640f, 
    -0.07064886f, -0.03342422f, -0.01594344f, -0.07090704f, -0.08478220f, -0.06685681f, 0.03173045f, -0.07280542f, 
    -0.05554885f, 0.03451147f, -0.00452388f, 0.02230940f, -0.03034917f, -0.04474820f, 0.04758675f, 0.01994850f, 
    0.02488543f, 0.00490493f, 0.00785800f, -0.08940589f, -0.08549784f, -0.02340434f, -0.02524418f, -0.04099381f, 
    -0.05394080f, 0.02976689f, -0.10069793f, -0.03793302f, -0.04844593f, 0.01675210f, 0.01256363f, 0.00422254f, 
    0.01347026f, -0.10041447f, -0.01988578f, -0.04390125f, -0.06882096f, -0.07090111f, -0.07360139f, -0.06412528f, 
    -0.06034278f, -0.02585691f, -0.08155385f, -0.01732826f, 0.00161204f, -0.06303117f, 0.02044555f, -0.05375180f, 
    -0.01713929f, 0.02281372f, 0.00983316f, 0.03634356f, -0.04781082f, -0.01469194f, -0.02544336f, -0.06824864f, 
    -0.07220442f, -0.07579778f, -0.01132741f, -0.02941667f, 0.01084544f, -0.07855205f, -0.10491834f, -0.01558396f, 
    -0.04065510f, -0.05364284f, -0.02442873f, -0.07206410f, -0.01285888f, -0.06033083f, -0.00301712f, 0.02422685f, 
    0.02008112f, -0.05783300f, -0.00106638f, -0.06246847f, 0.00793120f, 0.04204042f, -0.04004399f, -0.04136673f, 
    -0.33256704f, -0.09610212f, -0.11311128f, -0.12734541f, -0.06617017f, -0.11185293f, -0.01363398f, -0.11110587f, 
    0.17601806f, -0.01920772f, 0.28305417f, 0.03033050f, -0.00911056f, -0.04610994f, -0.00979204f, -0.04897414f, 
    -0.00163750f, -0.10952803f, -0.01644265f, -0.10993386f, -0.07423125f, -0.00308373f, 0.05503058f, -0.06146660f, 
    0.07300863f, -0.18565965f, 0.04384302f, 0.01608737f, 0.08942809f, 0.01605467f, 0.05357606f, -0.03635262f, 
    -0.10680839f, 0.17933060f, 0.06655291f, -0.04957161f, 0.15287168f, 0.11818256f, 0.09755757f, -0.29338035f, 
    -0.38727424f, -0.26180822f, 0.19279616f, 0.10773512f, 0.04806711f, 0.08915182f, 0.04426370f, -0.05213648f, 
    -0.22395384f, -0.03887342f, -0.19291423f, 0.07903322f, -0.12359970f, -0.01598411f, -0.15298995f, 0.06182258f, 
    0.05782089f, -0.00819102f, -0.05960682f, -0.11934125f, 0.26110303f, 0.15620086f, 0.08299854f, 0.14032950f, 
    0.22046790f, 0.18122089f, -0.39948013f, -0.31808206f, -0.36424887f, 0.12071177f, 0.16856201f, 0.10559664f, 
    0.50746310f, 0.35935268f, -0.13478823f, -0.13347439f, 0.10395528f, -0.26327458f, 0.06327929f, 0.02407454f, 
    0.18146731f, 0.16794303f, 0.14662917f, -0.00348261f, -0.07516605f, -0.38687211f, -0.15364535f, 0.19874875f, 
    0.07010943f, 0.07039197f, 0.21294186f, 0.17888016f, 0.00711366f, -0.24063587f, 0.03314140f, -0.32733127f, 
    0.18167374f, 0.02754142f, -0.07327670f, -0.22704269f, -0.06942475f, -0.29467440f, -0.01608742f, 0.19073595f, 
    -0.11574492f, 0.07489099f, 0.11281276f, 0.02268861f, 0.36593363f, 0.28236094f, 0.24088523f, -0.59313917f, 
    -0.44206157f, -0.10852793f, 0.01189179f, 0.06024500f, -0.07808235f, 0.51041836f, 0.05627482f, -0.17741601f, 
    -0.18375608f, -0.07975763f, -0.04255966f, -0.12116936f, 0.01688457f, -0.01441839f, -0.21664768f, -0.01015893f, 
    0.10569090f, 0.15050626f, 0.11035885f, 0.03983345f, 0.14965928f, -0.09031921f, -0.03961054f, 0.03364347f, 
    0.10767592f, 0.04602471f, -0.05697202f, 0.03685423f, 0.08210861f, 0.00751987f, -0.01937017f, 0.01775842f, 
    0.41743633f, 0.32179376f, -0.06160153f, 0.04165771f, -0.08006796f, -0.18268193f, 0.00729315f, 0.07215040f, 
    -0.09286119f, -0.04597444f, -0.01202612f, -0.02832950f, -0.01951814f, 0.08911949f, -0.23599055f, 0.12875070f, 
    0.20372148f, -0.09237394f, 0.17869763f, 0.09898060f, 0.01203310f, 0.05895546f, 0.05038173f, -0.06637324f, 
    0.28506303f, 0.18758546f, 0.12703452f, -0.13709550f, -0.17016546f, -0.18357530f, -0.19870034f, -0.03426493f, 
    -0.05008423f, -0.05971813f, 0.03159229f, -0.07804985f, 0.15044643f, -0.17820005f, -0.11403116f, -0.04112964f, 
    -0.13165958f, 0.07361494f, 0.07270758f, 0.09101830f, 0.00966084f, 0.38019088f, 0.41654959f, 0.16614556f, 
    0.03868435f, 0.01768919f, -0.08212636f, 0.14149818f, 0.05966395f, 0.10997937f, 0.03923321f, 0.10831030f, 
    0.20867623f, -0.01370298f, -0.13820086f, 0.05018320f, 0.02720113f, -0.00319319f, -0.05706408f, 0.27836224f, 
    0.29930732f, 0.27555466f, -0.08354412f, -0.13672620f, -0.02684683f, -0.10697669f, -0.17232592f, 0.12254083f, 
    -0.05258001f, 0.22216029f, 0.15730526f, -0.05686512f, -0.27145207f, 0.26599455f, 0.06967162f, -0.17819822f, 
    -0.07591512f, 0.16332006f, 0.10938530f, 0.15904276f, -0.03718236f, 0.19574706f, -0.19256790f, -0.11112977f, 
    0.12699027f, 0.10986058f, -0.55774361f, -0.01102055f, 0.08396185f, 0.18533763f, 0.06223422f, 0.03539196f, 
    0.03643746f, 0.09854151f, 0.02764520f, 0.25632942f, -0.02739742f, 0.12460136f, 0.09868135f, -0.02015512f, 
    -0.10182597f, -0.02217410f, -0.09552152f, 0.03916872f, 0.36310619f, 0.29672149f, 0.13555275f, -0.09894341f, 
    -0.02968521f, -0.22899784f, 0.04179516f, -0.10238656f, -0.06692675f, -0.05729748f, -0.02423951f, -0.00804879f, 
    -0.18605247f, 0.15652454f, -0.07719871f, 0.00173284f, -0.14531119f, 0.02147157f, 0.03062342f, -0.00245652f, 
    -0.17096592f, -0.22753789f, -0.45780927f, -0.09391667f, 0.02452182f, -0.15821773f, 0.00445310f, 0.48949766f, 
    -0.01625600f, 0.02574065f, -0.02017871f, -0.05777866f, -0.08037350f, -0.00123824f, 0.01683338f, 0.02272666f, 
    -0.17393409f, 0.13310811f, -0.16267957f, 0.02219816f, -0.05938321f, 0.13357480f, 0.38376659f, -0.03197441f, 
    0.24460457f, -0.06806027f, 0.08766434f, -0.00665656f, 0.04416199f, 0.19427903f, 0.06632384f, 0.05604796f, 
    -0.07129890f, -0.22293994f, -0.24871740f, 0.28182077f, -0.44384375f, 0.05878004f, -0.10444645f, 0.02198073f, 
    -0.00321719f, 0.12390590f, 0.40587711f, -0.03185364f, -0.07870299f, -0.13669890f, 0.00213262f, 0.04706096f, 
    0.04352283f, -0.07640465f, 0.00166004f, -0.12287270f, -0.19570740f, 0.02341056f, -0.04886250f, -0.00085127f, 
    0.05657224f, 0.04096455f, -0.42946967f, -0.60147697f, -0.61074078f, -0.13122287f, -0.00879450f, -0.16860752f, 
    0.20219584f, 0.09582468f, 0.07079940f, 0.08126570f, 0.28726831f, 0.30985323f, -0.03858804f, -0.04923594f, 
    -0.04450345f, -0.02896591f, 0.06809158f, 0.12844995f, 0.24491617f, -0.16218702f, -0.12398880f, -0.09177134f, 
    0.09231472f, 0.08141236f, 0.02313399f, 0.05775845f, 0.15804642f, -0.09725562f, -0.35530841f, -0.06239103f, 
    0.08998066f, -0.20687999f, -0.02417891f, 0.27821174f, 0.21396706f, 0.06110895f, 0.00465583f, -0.26475358f, 
    -0.23754366f, 0.02518056f, 0.06607484f, 0.03274770f, 0.19105905f, 0.08680392f, 0.16884910f, -0.13797645f, 
    -0.31000322f, -0.19005275f, 0.15955618f, -0.00029571f, -0.28427723f, 0.10707628f, 0.09330098f, 0.11725342f, 
    0.26149926f, -0.11145762f, -0.14213629f, 0.13064682f, 0.18079993f, -0.27708504f, -0.07239396f, 0.14970091f, 
    -0.13352118f, 0.12598723f, 0.04043520f, -0.16765106f, -0.05215569f, -0.22665372f, 0.16421254f, 0.22714238f, 
    0.19047369f, 0.15801853f, -0.00222721f, -0.28185305f, 0.04797833f, -0.00586303f, -0.08965033f, -0.07425620f, 
    0.09443377f, -0.03820004f, -0.05329347f, 0.17372796f, 0.16675001f, 0.18080162f, -0.24491993f, -0.13872136f, 
    -0.31822848f, -0.06717855f, -0.07974289f, 0.05760393f, 0.04722451f, -0.07151690f, 0.16088808f, 0.14207993f, 
    0.16570695f, 0.05305250f, -0.09180848f, 0.02616504f, -0.09644825f, 0.02612075f, 0.09593204f, 0.09679943f, 
    0.17763136f, -0.12598923f, -0.13999029f, 0.07002424f, 0.16969024f, 0.30065554f, 0.20797622f, -0.05553188f, 
    -0.10758588f, -0.01034190f, 0.02528487f, -0.18216646f, -0.10857743f, -0.05324270f, -0.07477645f, -0.12403373f, 
    -0.03544964f, 0.04258682f, 0.09357841f, -0.02942044f, 0.01554901f, 0.04693511f, 0.09447254f, 0.03765862f, 
    0.02003228f, -0.57204342f, -0.31423125f, -0.09877916f, 0.34679663f, -0.16698141f, -0.07092189f, 0.00180541f, 
    -0.04495458f, 0.08795942f, 0.09338628f, 0.24158514f, -0.00013729f, -0.02063559f, -0.06185734f, 0.09027893f, 
    0.15888828f, 0.09946870f, -0.06313642f, 0.15983950f, 0.09029786f, 0.10597133f, 0.01056864f, -0.03203616f, 
    0.06530412f, -0.00957143f, 0.03222767f, 0.28768092f, -0.42616788f, -0.31276309f, 0.10012668f, -0.03040529f, 
    0.10852323f, 0.02279215f, 0.04094559f, -0.13780557f, -0.10612568f, 0.01285699f, 0.04048215f, 0.14697206f, 
    -0.00974143f, 0.02766090f, 0.19133854f, 0.13831846f, 0.03706621f, 0.00259397f, 0.06795853f, -0.12855950f, 
    -0.00157105f, 0.27920857f, -0.24651179f, 0.05271013f, 0.05245024f, -0.10694960f, 0.20170619f, 0.10676761f, 
    0.00668870f, -0.13541819f, -0.18609326f, -0.03941437f, 0.04734284f, -0.02570073f, 0.10986477f, 0.18458383f, 
    -0.05700883f, 0.05576804f, -0.03679490f, -0.05050029f, -0.18053897f, -0.01889684f, -0.04901528f, 0.05548589f, 
    0.03599933f, -0.15908411f, -0.08844360f, -0.16185410f, -0.21915326f, -0.06809861f, 0.22372361f, -0.00975774f, 
    0.09429318f, 0.00551916f, 0.09078322f, 0.11651985f, 0.33328441f, -0.20787071f, 0.03226546f, 0.11862230f, 
    0.05426873f, -0.04678976f, -0.05521426f, 0.04616777f, 0.03630063f, -0.39434266f, 0.17948423f, -0.01661073f, 
    0.05010977f, 0.03827563f, 0.05996023f, 0.13231173f, 0.30425990f, 0.03507404f, -0.18362661f, 0.05714723f, 
    -0.16051811f, 0.23117551f, 0.11455397f, 0.05752003f, 0.12028367f, -0.09513238f, 0.23894562f, -0.05490156f, 
    0.02175692f, 0.06095934f, -0.03451539f, 0.03742236f, -0.17206618f, 0.11652073f, 0.09110161f, -0.02035108f, 
    0.04051152f, 0.21107319f, -0.00051909f, -0.03369095f, 0.04962351f, -0.15707831f, 0.27252120f, -0.06130060f, 
    0.03496847f, 0.04794656f, -0.00570804f, -0.19966604f, -0.00151044f, -0.00475814f, 0.01477909f, 0.04370137f, 
    0.08234746f, 0.00494804f, -0.03458641f, -0.04608653f, 0.00106750f, -0.17338084f, -0.02162660f, 0.12836786f, 
    0.27645409f, 0.13378277f, 0.24655657f, 0.10120589f, -0.08195062f, -0.05721017f, 0.08732915f, -0.15735862f, 
    0.12499470f, -0.04820479f, 0.12756307f, 0.01007777f, -0.17770307f, -0.16414259f, -0.07901195f, 0.08611961f, 
    0.05312474f, -0.06853773f, 0.11161813f, -0.03919548f, 0.10371969f, -0.07564652f, 0.09935800f, 0.38294551f, 
    0.15399386f, 0.09446615f, 0.13829716f, 0.05100900f, 0.08579199f, 0.28124961f, 0.09599989f, -0.08916422f, 
    -0.16093147f, -0.00804563f, -0.07472307f, -0.10025573f, 0.15562333f, 0.02430441f, 0.17103361f, -0.05111242f, 
    -0.10118329f, -0.10258916f, -0.12023084f, 0.05389072f, 0.06186400f, 0.16321665f, 0.15407319f, 0.10741512f, 
    -0.22880019f, -0.70135987f, -0.11755246f, -0.02529404f, 0.15376343f, -0.23205650f, 0.17864710f, -0.03890710f, 
    0.23317663f, 0.07521599f, -0.00150816f, -0.08718023f, 0.08828773f, 0.23887533f, 0.00114093f, 0.10361316f, 
    0.00747892f, 0.16276871f, 0.15820849f, -0.27244225f, -0.24029770f, -0.10061107f, -0.07208686f, 0.12020029f, 
    0.06792592f, 0.11379173f, -0.04495452f, 0.24804057f, -0.08324017f, 0.20643045f, -0.00569763f, -0.03387830f, 
    0.12053858f, 0.21190529f, 0.07618579f, 0.06610695f, -0.28147212f, -0.09163379f, -0.07841387f, -0.40091175f, 
    -0.15293811f, -0.05932102f, 0.05880231f, 0.00949697f, 0.07862009f, -0.08892290f, 0.06169217f, 0.22563954f, 
    -0.22355042f, -0.02020575f, -0.05182506f, -0.15315135f, 0.08881823f, -0.09676021f, -0.08832758f, -0.01314432f, 
    -0.12654179f, -0.00896978f, -0.17956941f, -0.03803620f, -0.15909177f, 0.08130195f, 0.10929386f, 0.07847325f, 
    -0.02375693f, -0.04679617f, -0.02004104f, -0.02036848f, -0.03075684f, 0.11461893f, -0.17830427f, 0.02179907f, 
    0.02901027f, -0.07030676f, 0.07865312f, -0.08691657f, 0.01014484f, 0.09522497f, -0.16477542f, -0.10612925f, 
    0.04758493f, -0.00084501f, -0.09262623f, -0.12027593f, -0.04604162f, 0.01165868f, 0.16741423f, 0.00901774f, 
    0.00800005f, -0.07593608f, 0.03694033f, 0.05662664f, -0.08535103f, -0.04551970f, 0.02164747f, -0.10034923f, 
    0.10405291f, 0.07786549f, 0.07867908f, 0.23906070f, 0.12869810f, 0.08175951f, 0.07641493f, 0.06726696f, 
    -0.08644928f, 0.06948999f, 0.02502391f, 0.14513880f, -0.09538323f, -0.18251304f, 0.10536243f, -0.03988224f, 
    0.04238480f, 0.02804309f, -0.10607873f, -0.08729675f, 0.05473005f, -0.10399404f, -0.60327232f, -0.57250673f, 
    -0.29974830f, -0.17074984f, -0.11608034f, 0.00327012f, 0.08251728f, 0.05848237f, -0.23638712f, -0.16295695f, 
    -0.04736153f, 0.01945154f, 0.04315725f, 0.05378797f, -0.00077026f, -0.05461897f, 0.04463036f, -0.44132367f, 
    -0.47115728f, -0.14096539f, 0.00383146f, -0.05477515f, -0.01467451f, -0.03918641f, -0.07523812f, 0.00693436f, 
    0.07000890f, 0.32344306f, -0.35472709f, 0.10627957f, 0.12259666f, -0.24899013f, -0.08313715f, 0.05762009f, 
    -0.15647687f, -0.13988882f, 0.19695181f, 0.24476826f, 0.03688501f, -0.02637511f, 0.01923751f, 0.01944274f, 
    0.03563722f, 0.00990941f, 0.29360887f, -0.04710676f, -0.09321114f, 0.05048282f, 0.07005450f, -0.05734548f, 
    -0.01069953f, 0.14157434f, -0.02409749f, -0.31898496f, 0.24013899f, 0.46163455f, 0.05443287f, 0.06077504f, 
    0.18717378f, -0.06903371f, -0.00665410f, 0.00570215f, -0.28691432f, -0.68559873f, -0.35923555f, 0.04347504f, 
    0.17723089f, -0.06802955f, 0.21189320f, 0.04948359f, 0.08000901f, -0.24600245f, 0.35144907f, 0.16177474f, 
    0.10447322f, 0.05051812f, 0.08974029f, 0.00014797f, -0.11337408f, 0.11369360f, -0.12979630f, -0.20310867f, 
    0.06429026f, 0.01636847f, -0.29949492f, -0.05429534f, -0.07777485f, 0.07830445f, 0.02801481f, -0.54176217f, 
    -0.33928895f, 0.13441016f, -0.16248782f, -0.00193306f, 0.01926282f, -0.17518596f, -0.13529952f, -0.06773846f, 
    -0.03098485f, -0.02551781f, -0.01331428f, -0.00224118f, -0.04718908f, 0.02951804f, 0.04348009f, -0.03240135f, 
    -0.02496289f, 0.02199037f, 0.02038224f, 0.03127328f, 0.04311970f, -0.01478889f, -0.05595661f, -0.06287591f, 
    0.04804315f, 0.01100141f, -0.03303005f, 0.04309990f, 0.04537559f, 0.01708908f, 0.01401893f, 0.02840272f, 
    -0.06225908f, 0.01280821f, 0.03369191f, 0.02936976f, -0.01444583f, 0.03807499f, -0.03501581f, 0.00689251f, 
    -0.04628954f, 0.01660312f, 0.01518314f, -0.01877115f, 0.00488042f, -0.03975914f, -0.02463422f, 0.01394287f, 
    -0.00574079f, -0.03800642f, -0.00319005f, 0.01365936f, -0.04907577f, 0.05040799f, -0.03201463f, -0.00846254f, 
    -0.06359407f, -0.01160142f, -0.03959212f, -0.01184575f, 0.03525906f, -0.01098938f, -0.00385144f, 0.05273239f, 
    -0.03415793f, 0.04535004f, -0.00024183f, -0.02611964f, -0.00531573f, -0.02503804f, -0.06289514f, 0.02924888f, 
    0.02727379f, 0.06350356f, 0.05225080f, -0.05543341f, 0.04417967f, -0.05802283f, 0.03319025f, -0.05480423f, 
    0.00810126f, 0.03308873f, -0.01202126f, 0.00316604f, -0.06426772f, 0.00120654f, 0.02824487f, 0.03903949f, 
    -0.04939178f, -0.05288218f, 0.00971601f, 0.00950123f, -0.06493185f, -0.02474853f, 0.01018076f, -0.00578756f, 
    -0.03576257f, -0.04762150f, -0.03815144f, -0.04644024f, 0.04460249f, -0.02219511f, 0.01223442f, 0.02734996f, 
    -0.05201092f, -0.01080930f, -0.03840930f, -0.02005440f, 0.01630136f, 0.00123487f, -0.01635546f, 0.03292593f, 
    0.04944004f, -0.06011136f, -0.05863097f, 0.00460204f, 0.00424350f, -0.01091926f, -0.06271640f, 0.02244228f, 
    0.02797302f, -0.06528739f, 0.03631707f, -0.04372554f, 0.03975280f, -0.01804993f, -0.00218822f, 0.03418324f, 
    0.01765353f, 0.01388538f, 0.01842036f, -0.02466234f, 0.02036281f, -0.02703558f, -0.01601445f, 0.04908996f, 
    -0.03790723f, -0.06003035f, 0.03374059f, 0.04788782f, -0.01770936f, -0.06186662f, -0.01316766f, -0.02576010f, 
    -0.02252433f, 0.04415227f, -0.05775656f, 0.03676004f, -0.06624698f, 0.01328694f, -0.05908950f, -0.00649164f, 
    -0.04784551f, 0.00214568f, 0.01404435f, -0.00381409f, 0.02846007f, 0.00382478f, -0.06521297f, -0.05808546f, 
    -0.04070235f, -0.02686021f, 0.01258948f, -0.05172189f, -0.04832896f, 0.00241750f, 0.05021840f, -0.02722888f, 
    -0.04079354f, 0.03821428f, -0.03199619f, 0.02307130f, -0.04993529f, 0.03434572f, -0.06420080f, -0.00287983f, 
    -0.00872874f, -0.05271557f, 0.01602114f, -0.04926248f, 0.03568003f, -0.04822730f, 0.02131898f, 0.03358466f, 
    0.01041520f, -0.02802208f, -0.00648545f, 0.02349486f, 0.03490006f, -0.04769194f, -0.01888192f, 0.03737044f, 
    -0.05459884f, -0.01732330f, 0.05039595f, 0.01046105f, -0.05959872f, 0.04906426f, -0.03154179f, 0.01373001f, 
    -0.05673619f, 0.01083607f, 0.02686122f, 0.02217372f, 0.03114174f, 0.04624072f, -0.02926771f, -0.04417849f, 
    -0.01034174f, 0.01196458f, -0.02925111f, -0.06181291f, -0.05626383f, -0.02712416f, -0.00247458f, 0.01726297f, 
    -0.01478056f, 0.02850797f, -0.02122600f, -0.03019555f, 0.01551720f, 0.02183678f, -0.05086558f, 0.01444110f, 
    -0.05256597f, -0.04693901f, -0.06021801f, -0.06335332f, -0.02555523f, 0.01254295f, -0.06371404f, -0.01216491f, 
    0.00817412f, -0.05621285f, -0.00516799f, 0.03422908f, 0.03847459f, -0.02348449f, 0.00477161f, -0.01576991f, 
    -0.02172082f, 0.04055145f, -0.01471252f, -0.06294736f, 0.04371737f, -0.00482649f, -0.05381694f, -0.02806940f, 
    -0.02576908f, -0.03962105f, 0.02329622f, -0.03042774f, -0.03136790f, -0.01009199f, 0.04713743f, 0.02638942f, 
    0.03073428f, 0.00405181f, 0.03380591f, 0.01807491f, -0.05500598f, -0.01240881f, -0.00888992f, 0.04100884f, 
    0.03894692f, -0.02364927f, 0.01291624f, 0.00804971f, 0.00426420f, -0.00323006f, 0.03218997f, 0.02041781f, 
    -0.03529430f, -0.01095126f, 0.03801812f, 0.04179039f, -0.05111498f, 0.00254585f, -0.03587972f, -0.03215845f, 
    0.00910208f, 0.01699605f, -0.01008984f, -0.05492052f, 0.03490510f, -0.02970881f, -0.03122844f, -0.06427749f, 
    -0.00424607f, 0.01526276f, -0.05147021f, -0.03826580f, -0.00675952f, -0.02527874f, -0.04025033f, 0.01698303f, 
    -0.43658721f, 0.21285325f, 0.16366370f, -0.07264167f, -0.05442825f, -0.01450325f, -0.07478453f, -0.01288979f, 
    0.04322018f, 0.06258985f, 0.06915989f, 0.05871668f, 0.02233110f, -0.10328193f, -0.07125102f, 0.08412693f, 
    -0.02572393f, -0.13725655f, -0.65542150f, 0.02506219f, -0.05834328f, -0.14014766f, 0.03507031f, 0.15061171f, 
    -0.02395573f, 0.17269526f, 0.19506608f, -0.15002370f, -0.44845644f, 0.01883834f, -0.11483065f, 0.05770292f, 
    -0.01712308f, 0.09241895f, 0.13514157f, 0.02947372f, 0.44380030f, -0.02600914f, 0.18037859f, -0.20302111f, 
    -0.11839525f, 0.16324723f, -0.03316147f, 0.03461291f, -0.26757920f, 0.06959477f, 0.23251066f, -0.12152700f, 
    0.04292897f, 0.15697050f, 0.22747767f, -0.12531766f, 0.11095738f, 0.22182710f, 0.31110978f, -0.22122987f, 
    -0.11351672f, -0.25856209f, -0.17526495f, -0.01202306f, 0.20243086f, 0.05168677f, 0.06060829f, 0.06284603f, 
    0.07169080f, 0.24204040f, -0.06491069f, -0.07249355f, -0.05808306f, -0.14003365f, 0.07601465f, 0.02636854f, 
    -0.00394621f, 0.00973922f, -0.23965605f, -0.05217989f, -0.01008983f, 0.01357026f, -0.19118872f, 0.00867459f, 
    0.19176793f, -0.09474510f, -0.11675261f, -0.23446374f, -0.07402159f, 0.17065541f, -0.06412593f, -0.00088649f, 
    0.11455450f, 0.04803265f, 0.43473190f, -0.01267079f, -0.03900200f, -0.04212241f, -0.08335732f, 0.01205286f, 
    0.12400974f, 0.09280530f, -0.05989115f, -0.27320632f, -0.18013571f, 0.32029390f, -0.08997640f, 0.16478091f, 
    0.02945062f, 0.22072826f, 0.05804380f, 0.00985451f, 0.21036251f, -0.40703392f, 0.26298565f, 0.01816857f, 
    0.12045843f, -0.06019814f, -0.04027250f, 0.06659936f, -0.02154295f, 0.04888441f, 0.48255590f, -0.36748531f, 
    0.13003726f, 0.12887898f, 0.15802385f, -0.00836143f, 0.04144722f, -0.06167927f, -0.35904643f, -0.35097551f, 
    -0.04606002f, -0.17495778f, 0.15415482f, -0.06609207f, -0.05073538f, 0.00449171f, 0.21498442f, -0.07098226f, 
    0.05610551f, 0.08131651f, 0.06151180f, 0.00651387f, 0.09992615f, 0.06767397f, -0.00078819f, -0.16363953f, 
    0.28258309f, -0.10931734f, 0.02575978f, 0.14625181f, 0.00597832f, -0.13154735f, 0.01422210f, 0.12565714f, 
    0.03310711f, -0.38251743f, 0.00615629f, 0.26632425f, -0.19994491f, -0.14102025f, -0.03059794f, -0.09857713f, 
    0.16543801f, 0.12870610f, -0.29611292f, 0.02308117f, -0.18746647f, 0.00243918f, 0.04581160f, -0.08986446f, 
    -0.09441432f, -0.04464473f, -0.19320481f, -0.33579826f, 0.42479792f, 0.16424669f, -0.15514958f, -0.05703462f, 
    0.07879797f, 0.08473477f, 0.09774068f, -0.04055657f, 0.06697886f, 0.07661359f, 0.11938618f, 0.03547565f, 
    0.14496472f, 0.06231863f, 0.15996294f, 0.22258243f, 0.13393480f, 0.23501568f, 0.05040330f, -0.22271371f, 
    0.07300762f, 0.03926384f, 0.06062939f, 0.01670793f, -0.10375109f, -0.10089716f, 0.24948925f, -0.00933550f, 
    0.16599721f, -0.05877194f, 0.05136759f, -0.02620559f, 0.11184565f, -0.17745510f, -0.01736663f, 0.18020876f, 
    0.00234271f, -0.00117683f, -0.00980750f, -0.04571721f, 0.02084465f, -0.00190061f, -0.08421174f, 0.07009953f, 
    -0.12322649f, 0.18842725f, 0.32356223f, 0.05899500f, -0.05602035f, 0.04874647f, -0.00403482f, -0.05976760f, 
    -0.07555540f, 0.00593080f, -0.05749845f, 0.11031661f, 0.16401292f, -0.06368544f, -0.03858660f, -0.07729551f, 
    0.08804159f, 0.00262153f, -0.37114215f, -0.43851948f, 0.37710595f, -0.21339284f, -0.00386774f, -0.08965665f, 
    -0.06567868f, -0.00731023f, 0.12177651f, -0.35849890f, -0.28617314f, 0.03768776f, 0.26463640f, 0.09912996f, 
    0.03377997f, -0.09731293f, 0.13122034f, 0.12812017f, 0.13722850f, 0.12474883f, 0.20407552f, -0.05800894f, 
    0.03725566f, 0.09340037f, -0.08143120f, -0.07902747f, -0.11855548f, 0.01014708f, 0.32208011f, 0.46007964f, 
    -0.11897230f, -0.08021310f, -0.12789668f, 0.00536033f, 0.28775647f, 0.02964645f, 0.71539092f, -0.33589181f, 
    0.04048193f, 0.08639476f, 0.07667332f, 0.12972212f, -0.06130472f, -0.06163138f, 0.00028906f, 0.15976264f, 
    0.16420640f, 0.05767881f, 0.22405764f, 0.05988229f, 0.06613313f, -0.15336277f, 0.19454350f, 0.13200551f, 
    -0.02954532f, 0.00407965f, -0.03650379f, 0.04747808f, 0.00139824f, -0.05660611f, 0.03024228f, 0.02254736f, 
    0.05092930f, 0.00615717f, 0.00886048f, -0.05397381f, 0.01035058f, 0.00932795f, 0.01556460f, -0.00810198f, 
    0.02250337f, -0.04391037f, 0.02471054f, -0.00492301f, -0.02910642f, -0.00320790f, 0.05021758f, 0.01873324f, 
    0.04357650f, 0.03637765f, 0.01420064f, 0.03316618f, -0.02424320f, 0.04100121f, -0.04946744f, -0.04587339f, 
    0.04907119f, 0.05155293f, -0.05837993f, 0.03938762f, -0.03706076f, 0.05072084f, 0.01641165f, -0.01614990f, 
    0.02075423f, -0.05719658f, 0.01781516f, 0.05359741f, -0.04344608f, -0.03259290f, -0.05226949f, 0.01870894f, 
    -0.03055084f, -0.03345709f, -0.05085554f, 0.01143540f, -0.05717648f, -0.00781476f, 0.01607625f, -0.02216809f, 
    -0.03156033f, -0.01095283f, 0.00611067f, 0.02689505f, -0.02932973f, -0.05832910f, -0.06213386f, -0.01213046f, 
    0.04750977f, 0.00836445f, 0.03188680f, 0.05134584f, -0.02147618f, 0.02971718f, -0.04339539f, 0.01574273f, 
    -0.04966531f, -0.01167457f, 0.05273516f, 0.00740418f, -0.01937866f, -0.00425264f, -0.05592659f, 0.04054295f, 
    0.01190977f, -0.05298257f, 0.00219122f, -0.00547201f, -0.03746188f, -0.04572139f, 0.04521719f, -0.05003754f, 
    -0.04470824f, -0.06280043f, -0.01197128f, 0.04723428f, -0.02944324f, -0.03341550f, -0.05057999f, -0.00893665f, 
    -0.03472362f, 0.03298288f, -0.03899243f, 0.03233112f, 0.00672411f, 0.01273398f, -0.01135619f, 0.03541408f, 
    -0.03417037f, -0.00550155f, 0.00344621f, 0.00848882f, -0.01253768f, 0.03640460f, 0.04107798f, 0.02211093f, 
    0.01897566f, 0.04371396f, 0.01779732f, 0.03167064f, 0.02196667f, 0.04526044f, -0.03385027f, -0.01698288f, 
    -0.00388674f, -0.05098993f, 0.02548744f, 0.01257974f, 0.05554807f, 0.03487149f, 0.00603656f, -0.04033665f, 
    0.00266071f, 0.03991485f, -0.01850106f, -0.06280512f, -0.06330803f, -0.03535779f, -0.04723235f, -0.03962529f, 
    0.03296999f, -0.00276412f, 0.04781365f, 0.02270908f, -0.02328078f, -0.04507574f, 0.03783583f, -0.01187255f, 
    0.02646536f, 0.01433313f, -0.05375610f, 0.05247815f, 0.05272826f, 0.01490363f, -0.05398592f, 0.04686764f, 
    -0.00254553f, 0.00854921f, 0.04329038f, -0.03325681f, -0.03781693f, -0.06342056f, -0.01199227f, 0.04742352f, 
    -0.06389791f, 0.00484815f, -0.04619490f, -0.04806545f, -0.01061450f, 0.00033363f, -0.01221365f, -0.00129647f, 
    0.00339382f, 0.00266829f, 0.04239642f, 0.00595912f, 0.04149750f, 0.01671871f, 0.03179505f, -0.04777043f, 
    -0.01901334f, 0.01087504f, 0.04612880f, -0.06063133f, -0.04659253f, 0.04421242f, 0.04636814f, -0.04551986f, 
    -0.04864336f, -0.05392417f, -0.04390487f, -0.02295876f, 0.04740676f, -0.03464624f, -0.02351139f, 0.01061182f, 
    0.01732013f, -0.03926179f, -0.05088119f, 0.04368893f, -0.04012391f, 0.00140788f, 0.00905879f, -0.00112656f, 
    0.03990464f, 0.04356286f, 0.02594138f, -0.00612248f, 0.01542497f, 0.04364204f, -0.05042611f, -0.03443809f, 
    -0.03339286f, 0.02282965f, -0.02853555f, -0.05415446f, 0.05177912f, -0.04421886f, -0.04726376f, -0.01459713f, 
    0.04880981f, 0.04364314f, -0.01882830f, -0.03192865f, 0.04935302f, -0.01344499f, -0.00859775f, 0.05233696f, 
    -0.00267137f, -0.00987653f, -0.03822062f, 0.04352642f, -0.05194010f, -0.01728484f, -0.02857156f, -0.04219474f, 
    -0.04507793f, -0.04207928f, -0.01846464f, -0.02450126f, -0.05644085f, -0.04471466f, 0.03131922f, -0.04395118f, 
    -0.05696248f, 0.00690710f, -0.02050019f, 0.04391783f, -0.01704996f, 0.04368047f, -0.04185127f, -0.03612414f, 
    0.02543564f, -0.04773558f, 0.01682749f, 0.04986600f, 0.01053720f, -0.02098204f, -0.03122017f, -0.05155690f, 
    -0.04413409f, 0.00737426f, -0.04044610f, 0.00713127f, -0.04948662f, -0.02469945f, 0.05385798f, -0.05090382f, 
    0.04034970f, -0.03055633f, 0.00869053f, -0.04833955f, -0.04624439f, 0.04161764f, -0.03091597f, -0.05711481f, 
    0.04782717f, -0.05134643f, 0.05245294f, 0.02385520f, 0.00429625f, -0.05203694f, -0.01962594f, 0.00724582f, 
    0.01750828f, -0.01300927f, 0.00253614f, 0.01672218f, 0.04492374f, -0.00440651f, -0.03289905f, -0.00686175f, 
    -0.05787918f, -0.10763706f, -0.39342073f, -0.20565264f, 0.07730223f, 0.05788391f, 0.08436988f, -0.09330604f, 
    0.09967209f, 0.20371902f, 0.16839436f, 0.27814293f, 0.15757570f, 0.02491662f, -0.21809745f, 0.17490132f, 
    -0.04293394f, -0.19138150f, 0.31112829f, -0.43037888f, -0.02297326f, 0.12490533f, -0.05042891f, 0.03721147f, 
    0.15940712f, -0.02941130f, 0.15755184f, 0.04083110f, -0.18399811f, -0.39450243f, 0.10399782f, -0.02050805f, 
    -0.10064355f, -0.04886489f, 0.00913004f, -0.05124786f, 0.00928310f, -0.24111946f, -0.37274751f, 0.09915537f, 
    -0.01309297f, 0.05094212f, 0.26620114f, 0.16974545f, 0.24121262f, -0.20138247f, -0.13228114f, -0.13691257f, 
    0.11969428f, 0.00299660f, -0.15361199f, 0.14166087f, -0.08903802f, 0.18201293f, 0.25910527f, 0.13547379f, 
    -0.33694190f, 0.00187856f, 0.00289834f, -0.08826756f, 0.31442797f, 0.06128439f, 0.09447847f, 0.33637524f, 
    -0.05652547f, -0.56771839f, -0.02590746f, -0.02902152f, -0.00410143f, 0.00855027f, 0.14360096f, 0.10426890f, 
    0.26604465f, 0.16790570f, 0.46558088f, 0.00591193f, 0.07798646f, -0.32206285f, 0.16923420f, 0.03980851f, 
    0.19285125f, -0.20822482f, -0.34579965f, -0.49969178f, 0.16722116f, 0.00571624f, -0.11357561f, 0.03909640f, 
    0.04219018f, 0.07136617f, -0.08550947f, 0.03700653f, -0.12140137f, 0.04811083f, 0.03882289f, -0.17515144f, 
    0.12975371f, 0.00760495f, -0.12690087f, 0.32254660f, 0.07373968f, -0.22951539f, -0.07078329f, -0.00197816f, 
    -0.09140079f, 0.13270521f, 0.04851504f, -0.15703072f, -0.04626768f, -0.05901510f, -0.14896746f, -0.17382601f, 
    -0.26803905f, 0.13827945f, 0.09057296f, 0.04424636f, -0.00245733f, -0.39579049f, -0.09246546f, -0.40582073f, 
    -0.08953201f, 0.01775651f, 0.15509926f, 0.05019214f, 0.00133510f, 0.00018953f, 0.06626748f, -0.24374835f, 
    0.06642576f, 0.23812972f, -0.07726616f, -0.16092624f, -0.01265945f, 0.06634379f, -0.00477214f, 0.21853034f, 
    0.09046893f, 0.20505705f, 0.01975958f, 0.13520171f, 0.26058710f, 0.01090013f, -0.02425370f, -0.01855278f, 
    0.28428054f, 0.06699204f, 0.19244173f, 0.09593709f, -0.12223363f, -0.16909474f, 0.18639743f, 0.00122334f, 
    -0.06962103f, 0.11339547f, 0.03562846f, -0.68731165f, 0.02478487f, 0.01756717f, -0.00164361f, -0.13737249f, 
    0.36736900f, 0.07004182f, 0.20286162f, 0.02932753f, -0.18548745f, 0.04487771f, 0.09445515f, 0.03968768f, 
    -0.20443390f, 0.03941753f, 0.01942891f, 0.39011681f, -0.25046721f, -0.08004619f, -0.07456005f, 0.11645832f, 
    0.23402786f, 0.01790419f, 0.11089934f, -0.12302661f, -0.14651166f, -0.10926178f, -0.13854854f, -0.01904176f, 
    0.01998889f, 0.30178806f, -0.01579651f, 0.13872172f, 0.07475878f, 0.45113727f, 0.35704318f, 0.38065323f, 
    -0.02871288f, -0.11631814f, -0.08409461f, 0.09696542f, 0.01871730f, -0.15704869f, -0.06828758f, 0.11915376f, 
    0.11402606f, 0.17837200f, 0.04614660f, 0.40136284f, 0.05225764f, -0.02065551f, 0.02808826f, 0.32222727f, 
    0.28283641f, 0.49774262f, -0.13579440f, 0.15896034f, -0.02228801f, 0.05600468f, -0.10972486f, 0.01627026f, 
    0.23138426f, 0.18818365f, 0.39705163f, 0.01887568f, 0.07474660f, -0.08277947f, -0.06067865f, -0.06490932f, 
    0.04430858f, -0.11306022f, -0.06884766f, 0.04486466f, -0.10492146f, 0.05390931f, 0.13630527f, 0.02772125f, 
    0.01522602f, -0.09581743f, 0.30094734f, -0.46444699f, -0.73157173f, 0.12739973f, -0.01786715f, 0.04538622f, 
    0.06555299f, 0.05113740f, 0.03383719f, -0.06321647f, -0.12745173f, -0.23008507f, -0.06439730f, 0.06095644f, 
    0.14763951f, 0.02881989f, -0.20481239f, 0.12308798f, 0.04862358f, -0.01562641f, 0.35691509f, -0.12935552f, 
    -0.08464822f, -0.06063171f, -0.07324963f, 0.04252426f, -0.10333104f, -0.10096880f, -0.43373710f, -0.12658539f, 
    -0.00994830f, -0.11042142f, -0.18548851f, -0.07335814f, 0.02664465f, 0.00503547f, 0.17725977f, -0.05325737f, 
    -1.12590516f, -0.02609063f, -0.15349236f, 0.09963549f, 0.09508108f, 0.09925404f, -0.18515123f, -0.16403531f, 
    -0.06747622f, 0.44132158f, -0.08596638f, -0.14551336f, 0.16368659f, 0.00044143f, -0.02838477f, -0.06943464f, 
    -0.34323886f, 0.11071847f, 0.44789365f, 0.02735112f, 0.21978982f, 0.02262258f, 0.05968310f, -0.27677381f, 
    0.37282237f, 0.33954680f, -0.07419618f, 0.14292340f, -0.09305624f, -0.00251419f, -0.24150224f, 0.25018737f, 
    -0.08717980f, 0.07414520f, -0.21136850f, 0.07429581f, 0.13938661f, -0.03964606f, 0.16042860f, -0.05935178f, 
    -0.01950600f, -0.09923413f, -0.14083350f, -0.11662271f, -0.09230793f, -0.04756827f, 0.01774237f, -0.00867651f, 
    0.03526842f, -0.06768739f, 0.13666311f, 0.09816764f, 0.18452291f, -0.02861731f, 0.05452962f, 0.11724036f, 
    -0.07446773f, -0.03172110f, 0.08337528f, 0.05538677f, 0.07231804f, -0.04919489f, 0.01476860f, -0.07102976f, 
    -0.06907455f, 0.20395391f, -0.00828548f, -0.22396721f, -0.30849266f, -0.30968413f, -0.07482551f, 0.16286284f, 
    -0.13528383f, 0.15320800f, 0.16404392f, -0.04354005f, -0.18884107f, 0.23002219f, -0.05990710f, -0.10649713f, 
    -0.20287187f, -0.13202217f, 0.21765482f, 0.10500807f, -0.00569155f, -0.01408824f, -0.04554628f, -0.04193989f, 
    0.16433838f, 0.09612476f, 0.09673536f, -0.06899077f, 0.19214132f, 0.01412864f, 0.23742932f, -0.04181848f, 
    0.19332652f, -0.02139513f, -0.13872357f, -0.08678988f, 0.08935603f, 0.14063829f, 0.12272864f, 0.02617330f, 
    -0.15399224f, 0.19037478f, 0.23487896f, 0.21972486f, -0.02997847f, 0.14089331f, -0.20227516f, 0.07120547f, 
    0.13782933f, 0.30220971f, 0.19258687f, 0.02897858f, 0.49636129f, 0.08601557f, -0.07165202f, 0.17764258f, 
    0.01542806f, -0.00184372f, 0.29326174f, 0.20690542f, 0.03955013f, -0.17701837f, 0.04236658f, 0.24575430f, 
    -0.00368854f, 0.11303586f, -0.05016633f, -0.01869407f, -0.03881056f, -0.00058608f, 0.18332583f, -0.01887848f, 
    -0.09804982f, -0.04351750f, -0.05449562f, -0.19005907f, -0.09450901f, -0.33044717f, -0.53222209f, -0.26172727f, 
    0.13430329f, 0.07570323f, 0.14551476f, 0.03357577f, -0.08751704f, 0.07551263f, -0.03131037f, 0.03590665f, 
    -0.03306711f, -0.05305821f, -0.07188521f, -0.02664744f, -0.05639620f, -0.07346813f, -0.19302620f, -0.35443145f, 
    -0.03415788f, -0.38067776f, -0.12133032f, -0.03484581f, -0.12153464f, -0.05167225f, 0.02078841f, 0.21627866f, 
    -0.00462157f, -0.23378718f, 0.25056067f, 0.25545204f, 0.00998000f, 0.09127197f, -0.06315048f, 0.04020231f, 
    0.13610686f, 0.31545544f, -0.04323469f, 0.02898197f, 0.09508744f, -0.09837610f, -0.08831575f, -0.10170047f, 
    0.27464399f, -0.01712712f, 0.10371450f, 0.03751115f, 0.29491019f, 0.32592201f, -0.20338193f, 0.08399470f, 
    -0.18933652f, -0.12291993f, -0.05317850f, -0.01184351f, 0.09413686f, -0.01292388f, 0.03919993f, -0.04932165f, 
    -0.12086976f, -0.08592195f, -0.07822652f, -0.12409954f, -0.24321473f, 0.00611369f, 0.03929730f, 0.00325231f, 
    -0.19053587f, 0.12755151f, -0.03270001f, 0.26067394f, 0.07358519f, 0.15150736f, 0.08965075f, 0.15300198f, 
    -0.12223186f, 0.07507498f, 0.10585438f, 0.08016514f, -0.10483202f, -0.07944857f, -0.33578393f, -0.09294383f, 
    -0.19506486f, -0.07714123f, 0.04079794f, 0.05834381f, 0.01489662f, 0.09311176f, -0.01222749f, 0.01515994f, 
    -0.19247901f, 0.00680744f, 0.64054316f, -0.03373021f, 0.19520797f, 0.00146294f, -0.01825146f, 0.05977143f, 
    0.12494105f, -0.03469455f, 0.09905694f, 0.06615246f, 0.12293707f, -0.04268209f, -0.10770203f, 0.13476928f, 
    0.06811628f, 0.04179318f, -0.33601770f, -0.13661002f, -0.07405362f, -0.03536508f, 0.20001066f, 0.10997403f, 
    0.04962401f, 0.11868250f, 0.11422276f, -0.28233904f, 0.15527034f, 0.22471114f, 0.14147784f, 0.12182277f, 
    0.08421750f, 0.02662348f, -0.11398172f, -0.07725206f, -0.14472386f, -0.11997045f, 0.18442814f, 0.10026591f, 
    0.12806064f, 0.21333690f, 0.01947660f, -0.12748477f, -0.13138197f, 0.04690206f, -0.01654618f, 0.40210676f, 
    -0.00470318f, 0.21579064f, -0.19876987f, 0.15088837f, -0.19397880f, 0.02705189f, -0.04839770f, 0.33181503f, 
    -0.30800182f, 0.24485362f, 0.04276776f, 0.02688163f, -0.06593226f, -0.13266400f, -0.24847668f, 0.09614263f, 
    -0.35402709f, 0.07202071f, 0.02213836f, 0.12088954f, 0.03376906f, -0.07198169f, 0.22719496f, 0.01438453f, 
    0.39529246f, -0.10266212f, -0.53816390f, -0.36079928f, -0.00179117f, -0.10517804f, -0.08120093f, 0.22362857f, 
    0.19888300f, -0.02087864f, 0.14348018f, -0.10253891f, -0.04819323f, 0.06178131f, -0.01006625f, 0.10254248f, 
    -0.09404829f, 0.14798677f, 0.37448645f, -0.68069011f, 0.09973703f, -0.08867899f, -0.06802141f, -0.16497210f, 
    0.01753110f, 0.05938671f, -0.03426605f, 0.31772798f, 0.04817434f, 0.02382128f, 0.01891065f, 0.07323451f, 
    0.05265277f, -0.01937162f, 0.01395498f, 0.04097311f, 0.06065598f, -0.31912941f, -0.37782937f, -0.20180802f, 
    -0.06436267f, 0.10981495f, -0.13950133f, 0.11546679f, -0.05592970f, 0.25478634f, -0.05834448f, 0.12606332f, 
    0.10895249f, -0.06088835f, -0.03898358f, 0.20229512f, 0.06674126f, -0.13790189f, -0.18033423f, 0.15098611f, 
    -0.10259055f, 0.09432246f, -0.20808552f, 0.26903120f, -0.03355458f, 0.29656368f, -0.23337296f, 0.03692695f, 
    -0.05546413f, -0.38590676f, -0.33175594f, -0.28615156f, 0.03193023f, 0.06272019f, 0.09911375f, -0.02496794f, 
    0.05415811f, 0.09527538f, 0.28596953f, -0.05032446f, 0.03242764f, -0.05512071f, -0.11915861f, 0.01357633f, 
    0.01441415f, -0.00820951f, -0.31960392f, 0.16622427f, 0.13614947f, 0.03157735f, 0.04457629f, 0.08958775f, 
    0.13858853f, -0.02327020f, -0.68034697f, -0.11434086f, 0.30529213f, -0.06758227f, -0.00278527f, -0.05150963f, 
    -0.06131062f, 0.10572261f, 0.04453374f, -0.13056470f, -0.45249024f, -0.16391945f, 0.01410295f, -0.07465527f, 
    -0.06378492f, -0.10273779f, 0.08714694f, -0.06751247f, -0.47613174f, -0.86990994f, -0.00404794f, -0.10299295f, 
    -0.01918666f, -0.00465328f, -0.05992250f, 0.13017768f, 0.26322210f, 0.42268458f, -0.04221989f, 0.37654522f, 
    0.03455834f, 0.00066484f, 0.18429244f, 0.11262981f, 0.19730011f, -0.01498694f, 0.44923168f, -0.35252678f, 
    -0.38413045f, 0.23160732f, 0.07468030f, -0.35486299f, -0.00046808f, -0.06265742f, 0.00851024f, 0.11392185f, 
    0.03922888f, 0.14447537f, 0.10934314f, 0.01932256f, 0.09844464f, 0.16931047f, -0.04889349f, -0.05059858f, 
    0.17942879f, 0.15931068f, 0.10671363f, -0.11583290f, -0.00295609f, 0.17300482f, -0.08649913f, 0.11476750f, 
    0.06634173f, -0.49729612f, -0.40422687f, -0.36119503f, -0.38438225f, 0.11983620f, 0.31525189f, 0.02568355f, 
    0.13439389f, 0.04751125f, -0.15610486f, -0.17161548f, -0.37784085f, -0.05796997f, 0.15526889f, 0.09903649f, 
    0.03749579f, 0.22942965f, -0.04864241f, 0.35400945f, -0.45702860f, -0.01803315f, 0.01466875f, -0.09365556f, 
    0.17074428f, 0.20075992f, -0.10211016f, -0.03680950f, 0.17276332f, -0.01193766f, 0.44283289f, 0.10598499f, 
    0.08428622f, 0.22762299f, 0.24081446f, 0.18783316f, -0.04981482f, 0.34136480f, 0.36252278f, 0.18718131f, 
    -0.16687776f, 0.02574361f, -0.03692970f, 0.10182462f, 0.06791292f, 0.11259249f, -0.08016036f, 0.16944344f, 
    0.33332729f, 0.13481352f, -0.06146491f, 0.20982768f, 0.06303679f, -0.05963031f, -0.01269593f, 0.12418466f, 
    0.15469135f, 0.07747860f, 0.00731722f, -0.13529733f, -0.10859274f, -0.07706777f, -0.13238248f, 0.02319335f, 
    0.05550983f, 0.18058005f, -0.33501473f, -0.21927769f, -0.14443310f, -0.22482365f, 0.12198445f, 0.11749779f, 
    -0.00951549f, -0.61615306f, -0.25638938f, -0.09108993f, -0.03642552f, 0.10440440f, -0.00977592f, -0.20652325f, 
    0.13493815f, 0.02969684f, -0.22804280f, -0.81987065f, -0.64616895f, -0.17150526f, -0.09933937f, -0.23520876f, 
    -0.03109775f, 0.11433733f, -0.01470820f, 0.02059468f, 0.07709232f, -0.20682377f, -0.05877542f, 0.05211721f, 
    0.29131055f, -0.20079212f, 0.02429410f, 0.03127667f, -0.08620068f, 0.05764084f, -0.08582852f, -0.13268016f, 
    -0.11172733f, -0.21205650f, -0.04078459f, -0.02214347f, 0.17462304f, 0.85207886f, -0.02048866f, -0.73666203f, 
    -0.06620044f, -0.06856801f, 0.03503896f, 0.06852414f, -0.01006754f, -0.08869455f, 0.07867367f, -0.27639815f, 
    -0.36433497f, -0.11411122f, -0.07173207f, -0.03085892f, 0.12926552f, 0.07678769f, 0.00499116f, 0.37918627f, 
    -0.14131920f, 0.24780062f, -0.14827892f, -0.07835448f, -0.05353775f, 0.08043583f, -0.01510591f, -0.10670580f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.00819479f, -0.06358750f, -0.11118656f, 0.09873378f, 0.02440822f, 0.23218954f, 0.02200801f, 0.33409044f, 
    0.09935493f, 0.29570612f, 0.29023945f, -0.00084682f, 0.35188529f, -0.09949228f, 0.10351294f, 0.20869111f, 
    -0.04610418f, 0.14367189f, 0.01102728f, 0.30376461f, 0.17708758f, -0.02517768f, -0.06342040f, -0.01442762f, 
    0.01536115f, 0.24992147f, -0.02699114f, 0.01803240f, -0.04018413f, 0.03556520f, 0.02709995f, -0.06646322f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.25397277f, 0.06947992f, 0.04724054f, -0.31489459f, -0.05207389f, 0.05169548f, -0.06110751f, 0.14771791f, 
    0.31144828f, 0.01047399f, 0.32152581f, -0.02009638f, -0.09509355f, 0.33402783f, 0.19174480f, 0.41067007f, 
    -0.04529157f, 0.35464400f, -0.07804763f, 0.06628548f, -0.21343249f, 0.01231150f, -0.03873090f, -0.07854602f, 
    0.13491513f, 0.31432432f, -0.04766980f, -0.16737543f, 0.07502215f, 0.27929091f, -0.05487781f, -0.42307797f, 
    0.16975696f, -0.06771639f, -0.20445877f, 0.33140039f, -0.17178589f, -0.16203921f, -0.28810164f, 0.28355440f, 
    0.25207934f, 0.16528504f, 0.13523497f, 0.13371699f, -0.23664092f, 0.02508182f, -0.22322145f, -0.24725917f, 
    0.05523578f, 0.06430312f, -0.16212541f, 0.16194206f, -0.43481776f, 0.07111575f, 0.08567890f, 0.20164214f, 
    -0.05715457f, -0.04707331f, 0.16856571f, 0.11101749f, -0.03919854f, -0.44505739f, 0.36298436f, 0.17414612f, 
    0.12060236f, -0.03353113f, -0.02138658f, -0.11151414f, 0.13647689f, 0.10687469f, -0.04592375f, -0.12042186f, 
    -0.12001580f, 0.01370266f, -0.19437677f, -0.02443550f, -0.22042222f, 0.11865153f, 0.00588616f, -0.13898309f, 
    -0.14050382f, -0.13506161f, 0.13185447f, 0.07918505f, 0.03746719f, 0.11725528f, 0.11067552f, -0.16378547f, 
    -0.14516392f, 0.04049353f, -0.08636848f, -0.14925632f, -0.00852492f, -0.02033259f, -0.07948156f, -0.04749457f, 
    0.47555709f, 0.12731047f, 0.40239412f, -0.07436439f, -0.10476779f, -0.25355870f, 0.22867242f, -0.08757525f, 
    -0.34035248f, -0.05453071f, -0.32171881f, 0.06916530f, -0.08248101f, 0.19779849f, 0.22064914f, -0.36789110f, 
    -0.25181663f, 0.13300718f, 0.12705715f, -0.03088357f, 0.19473940f, 0.07509464f, -0.08591140f, 0.01292771f, 
    -0.01493928f, -0.07611825f, -0.14829014f, 0.43047819f, 0.07020010f, -0.18513830f, 0.20822465f, 0.38719708f, 
    -0.04515908f, 0.12398785f, 0.20183623f, -0.21065375f, -0.12946627f, 0.17311844f, -0.18670562f, 0.07239725f, 
    0.16255173f, 0.39742640f, 0.16332740f, 0.13498595f, 0.05399628f, 0.43921638f, -0.26159087f, 0.35687751f, 
    -0.19763054f, -0.30123660f, 0.02116816f, 0.24510570f, 0.56413031f, 0.16828850f, 0.08198746f, -0.36279821f, 
    -0.11972702f, 0.02295733f, 0.00483444f, -0.23745398f, -0.15450582f, 0.34429184f, 0.22940211f, 0.33701089f, 
    -0.01494397f, 0.16943188f, -0.00416125f, -0.18651450f, 0.13880537f, -0.27253419f, -0.17702790f, 0.14309487f, 
    -0.00860821f, 0.20517643f, 0.23335275f, 0.23899980f, 0.37059999f, 0.08132918f, -0.12275767f, -0.10237923f, 
    0.22204565f, 0.23412755f, -0.05625626f, 0.43311054f, -0.55229712f, -0.11982899f, -0.07993794f, -0.11482416f, 
    0.05478035f, 0.39536026f, -0.00916577f, -0.24647719f, 0.02936400f, 0.56048572f, -0.24010235f, 0.36215353f, 
    -0.17675431f, -0.14994512f, -0.97454172f, 0.29718456f, -0.07846206f, -0.55172032f, 0.00152595f, 0.21892633f, 
    0.03421803f, -0.19582853f, 0.24035728f, 0.04901887f, -0.37913164f, -0.32097796f, 0.29787901f, 0.09011943f, 
    -0.08207037f, 0.05594585f, -0.01582118f, -0.12801833f, -0.54342580f, 0.07822760f, -0.15204611f, 0.48833367f, 
    0.40454611f, 0.04099412f, -0.16307645f, 0.21769945f, -0.09515289f, 0.33291873f, -0.06856281f, -0.22947246f, 
    -0.24852754f, -0.06750759f, 0.33879384f, 0.22515024f, -0.16580400f, -0.56123567f, 0.05217784f, 0.24550046f, 
    -0.02220823f, 0.35070914f, 0.10603007f, -0.12660928f, 0.11147468f, -0.19827172f, -0.15989369f, 0.49600509f, 
    -0.55200547f, -0.40447232f, -0.10093606f, -0.18660930f, 0.12074590f, 0.03559266f, 0.15233122f, -0.33561033f, 
    -0.04214042f, 0.09769612f, 0.12870958f, 0.46223500f, 0.14753544f, -0.07500498f, 0.20823233f, 0.11815317f, 
    0.06098746f, 0.03347273f, -0.14613463f, -0.11758963f, -0.04708395f, -0.10071690f, -0.15515710f, 0.06160686f, 
    -0.18196601f, 0.01846656f, -0.06618077f, -0.03735115f, 0.01917900f, 0.05906981f, -0.12843736f, -0.09145062f, 
    0.16887583f, -0.08398147f, -0.06682857f, -0.05687462f, -0.04514578f, -0.12809242f, -0.09501912f, -0.18220812f, 
    -0.06250049f, 0.12216388f, 0.07307248f, -0.12053546f, -0.10934058f, -0.07994068f, 0.07677928f, 0.08196739f, 
    -0.06931359f, 0.16002287f, 0.05203560f, -0.26509270f, 0.03683327f, 0.24948870f, 0.11515280f, -0.09456800f, 
    -0.14083354f, -0.06261750f, 0.21559547f, -0.39106679f, -0.07968833f, -0.17527254f, -0.02240230f, -0.23479992f, 
    0.12152193f, -0.06091228f, -0.13081300f, -0.06247456f, 0.27131462f, -0.16374263f, 0.03932918f, -0.12160373f, 
    -0.21058249f, -0.12673458f, -0.13008313f, -0.53237599f, -0.07518128f, -0.15893207f, 0.12415142f, 0.13130543f, 
    0.20599934f, 0.16995852f, -0.31736147f, -0.07217617f, 0.15867254f, -0.02251968f, 0.28966162f, 0.15721864f, 
    0.40327135f, -0.04910478f, 0.18859264f, -0.10295729f, -0.03982839f, 0.46201113f, 0.15865415f, 0.53941143f, 
    -0.09469285f, 0.38754901f, -0.07626208f, -0.19926046f, 0.36009300f, -0.05276148f, -0.03933427f, -0.13310289f, 
    -0.25859529f, 0.03184271f, 0.16196914f, 0.34790611f, 0.14002602f, -0.21744667f, 0.27816242f, -0.73943228f, 
    0.05548709f, 0.04715117f, 0.08366670f, 0.34657770f, 0.17938943f, -0.15015650f, -0.16879572f, 0.02944697f, 
    -0.22354813f, 0.02135646f, -0.19571191f, 0.39331746f, -0.24339250f, 0.05187966f, -0.00850383f, -0.17070532f, 
    -0.04997803f, -0.20114906f, -0.05886621f, 0.18595834f, -0.11431301f, 0.05996151f, 0.05647769f, 0.24648942f, 
    0.05812321f, 0.17818852f, 0.04806692f, 0.10640820f, -0.14665598f, 0.35395485f, 0.20689185f, 0.35693222f, 
    0.21827224f, 0.14397852f, -0.39839265f, -0.24215816f, 0.01541535f, -0.32503048f, 0.34555578f, -0.04195695f, 
    -0.21570593f, 0.26996520f, 0.04092816f, -0.03587312f, 0.42193082f, -0.23348625f, 0.17909959f, -0.04511146f, 
    0.14764997f, 0.26803023f, -0.04096682f, 0.35553741f, 0.39773482f, -0.14010763f, 0.08189224f, -0.34008318f, 
    -0.02879092f, -0.12199979f, 0.17956361f, -0.12790640f, 0.08863407f, 0.16999829f, -0.24053217f, 0.49981678f, 
    -0.06845039f, -0.10948993f, 0.07695488f, 0.09835716f, 0.04048228f, -0.21742058f, 0.09554924f, -0.05519247f, 
    -0.13992791f, -0.37349537f, 0.04086166f, -0.08001824f, -0.04103650f, -0.01562028f, 0.32591736f, 0.13492167f, 
    0.19433281f, 0.41598478f, 0.15700856f, -0.14594640f, -0.41877013f, -0.11202403f, -0.09485737f, 0.30102876f, 
    0.12548229f, 0.09981366f, -0.13690603f, 0.21977967f, 0.07572364f, 0.03337425f, -0.08266720f, -0.35945332f, 
    0.05193899f, 0.04441961f, 0.14922722f, 0.46389124f, 0.14300679f, 0.36640340f, -0.32514617f, 0.24127771f, 
    0.16770701f, 0.18888716f, 0.09396802f, 0.34848297f, -0.22906514f, -0.14925107f, -0.30411789f, 0.12496020f, 
    -0.23109190f, -0.03599924f, 0.02425971f, -0.34503672f, -0.05459195f, -0.09627935f, -0.13688350f, 0.06644716f, 
    0.26350787f, -0.09601084f, 0.06278063f, -0.03132852f, -0.01770860f, 0.18336593f, -0.00821456f, 0.50587904f, 
    -0.11437730f, -0.05211626f, -0.34251273f, 0.09051364f, -0.00724565f, -0.06486610f, 0.21551287f, 0.22343090f, 
    0.22104761f, 0.24494928f, 0.36414415f, -0.26756030f, 0.32816339f, 0.03301546f, 0.12522225f, -0.17553182f, 
    -0.12794329f, -0.17569031f, 0.10386179f, 0.37196094f, 0.06026630f, -0.10516664f, -0.13085113f, -0.11615025f, 
    -0.15445352f, 0.20951606f, -0.13681526f, 0.14999783f, -0.09237658f, -0.23843436f, 0.24166588f, -0.02250438f, 
    0.31957689f, -0.11547345f, -0.16079308f, 0.17630868f, 0.05662599f, 0.33120689f, -0.16015230f, 0.29065537f, 
    0.17632239f, 0.03150931f, 0.09767253f, -0.17250721f, 0.40990251f, -0.35874259f, -0.08523516f, -0.24941467f, 
    -0.23474120f, 0.26565155f, 0.16340573f, -0.02816902f, 0.11583596f, -0.11120459f, 0.16607557f, -0.25481898f, 
    -0.00348510f, 0.15403050f, -0.11848518f, -0.11647478f, 0.06505857f, -0.12910010f, -0.11996087f, 0.44508281f, 
    0.70360249f, -0.14803410f, -0.10089228f, -0.37770376f, -0.01539404f, 0.44360030f, -0.14620514f, 0.09162404f, 
    0.35425141f, -0.08144810f, -0.24103348f, 0.06999971f, -0.05660386f, 0.23982161f, -0.00149813f, 0.29312858f, 
    0.07978109f, 0.46582586f, -0.05325964f, -0.01874303f, -0.11744107f, -0.11781464f, 0.11444457f, 0.17984778f, 
    -0.16698517f, -0.30443484f, -0.09394584f, -0.32484469f, 0.04404856f, 0.09830510f, -0.04003667f, -0.00545832f, 
    -0.35417396f, 0.14403698f, 0.39267182f, -0.18842800f, 0.14683810f, -0.07527838f, 0.01091612f, -0.10427076f, 
    0.23094949f, 0.23861155f, 0.00176404f, -0.05643849f, -0.12890737f, -0.21077076f, -0.03116294f, 0.06280125f, 
    -0.22594026f, -0.17981753f, -0.15899551f, 0.01726072f, 0.53642470f, 0.03605001f, -0.04035452f, 0.12746276f, 
    0.16907702f, -0.07473846f, 0.00673585f, 0.25060716f, 0.13705750f, 0.32295394f, -0.10727697f, 0.29630131f, 
    0.18876414f, -0.07142043f, -0.02468381f, 0.17111503f, -0.15226702f, 0.06071623f, 0.04001255f, 0.05285655f, 
    -0.02375616f, 0.24981783f, 0.22256626f, -0.06008974f, 0.38630962f, 0.04784035f, -0.03488462f, 0.25812250f, 
    -0.12583528f, 0.05375089f, 0.02221097f, 0.14792301f, -0.03018520f, 0.01035288f, 0.05459345f, -0.22406216f, 
    0.11608181f, 0.26358116f, 0.02166004f, -0.34760177f, 0.12372774f, -0.58946973f, 0.02317057f, 0.44406351f, 
    0.03402463f, -0.03821130f, 0.02263445f, 0.10891080f, -0.08420444f, -0.09241781f, 0.01965798f, -0.09914584f, 
    0.08697878f, -0.15214130f, 0.08661015f, -0.01587903f, 0.09943186f, 0.03324775f, -0.03537855f, -0.03380720f, 
    -0.11970226f, 0.02490215f, -0.00591958f, -0.13932601f, 0.17907989f, -0.12271763f, -0.04287324f, -0.01476489f, 
    -0.03914445f, -0.17229651f, -0.04648659f, -0.18799117f, 0.17671818f, -0.04096319f, -0.11322504f, -0.05083457f, 
    0.45514411f, -0.06015417f, 0.05600868f, -0.13322093f, -0.00456742f, 0.15576731f, 0.17247671f, -0.19423532f, 
    -0.14177510f, 0.17375989f, -0.05314705f, 0.18195398f, -0.06337334f, 0.11479898f, 0.22576970f, 0.21438740f, 
    0.18487550f, 0.18982610f, 0.06137747f, -0.10821890f, 0.17330045f, 0.05235540f, 0.08576758f, 0.22463924f, 
    0.00358464f, -0.13474168f, -0.04734971f, -0.29316375f, -0.02093604f, 0.47380301f, -0.20111890f, 0.22646837f, 
    -0.30562380f, -0.08232746f, -0.45982435f, -0.02107182f, 0.06416297f, -0.33143261f, 0.19185032f, 0.05866203f, 
    0.24898709f, -0.25221294f, 0.54531491f, 0.04004315f, -0.28474775f, -0.18254218f, 0.24667205f, 0.63981527f, 
    -0.15533547f, 0.17552789f, 0.17123693f, -0.45508030f, -0.01160059f, 0.06145467f, -0.11010273f, -0.01420847f, 
    0.24469371f, 0.47759244f, -0.08300414f, 0.16799508f, -0.09127410f, 0.09068538f, -0.12915532f, -0.41092589f, 
    0.16643697f, 0.03931930f, 0.03605654f, -0.05334106f, -0.07019819f, 0.36429521f, 0.18691920f, 0.13264480f, 
    0.07703675f, 0.21628119f, -0.18838923f, 0.20847158f, -0.11785385f, -0.09188726f, -0.24581893f, -0.18885852f, 
    -0.07274652f, -0.34403932f, -0.07646401f, -0.02318595f, 0.72803080f, -0.05837042f, -0.18011826f, 0.08659738f, 
    -0.14673392f, -0.28523031f, -0.01263370f, 0.41095924f, 0.01730252f, 0.43228251f, 0.09603065f, 0.40015808f, 
    0.05438564f, -0.10903832f, -0.11807790f, 0.15464978f, -0.02024503f, -0.12648548f, -0.15281636f, -0.12782198f, 
    -0.13426922f, 0.07044292f, -0.07223154f, -0.15633866f, -0.12088624f, -0.12350547f, -0.10529052f, -0.01865978f, 
    -0.17887980f, -0.09913449f, -0.11041914f, 0.14205359f, -0.04956527f, -0.04161959f, 0.00567444f, -0.16837133f, 
    0.10442386f, -0.09906565f, -0.06375807f, 0.09606326f, -0.07352001f, 0.09901520f, 0.01650562f, 0.06713386f, 
    0.28822467f, -0.00040444f, -0.42762730f, 0.39291486f, -0.14687933f, -0.44955263f, -0.31225044f, -0.02685441f, 
    -0.04273485f, -0.06364514f, -0.02932194f, 0.41313228f, -0.11073961f, 0.40674958f, -0.04766949f, 0.32748926f, 
    -0.23366579f, -0.14985640f, -0.07496563f, -0.11349506f, -0.81588870f, -0.03454518f, 0.12432046f, 0.14917295f, 
    0.10789399f, 0.21019931f, 0.01193743f, 0.25546139f, -0.13896303f, 0.36886650f, 0.34802574f, -0.48411217f, 
    0.15483758f, -0.11506473f, 0.31412476f, -0.04938725f, 0.13455862f, -0.41211942f, -0.08371188f, 0.00501666f, 
    -0.19686520f, 0.07338954f, 0.36883959f, -0.05923913f, 0.22353153f, -0.17868547f, 0.15787286f, 0.22742891f, 
    -0.15198362f, 0.46734735f, 0.07305267f, 0.09179665f, -0.55239612f, 0.07172114f, -0.00611682f, -0.12653591f, 
    0.19295070f, 0.26382652f, 0.10592144f, -0.21716832f, 0.09568626f, -0.44400683f, -0.16640501f, 0.15862249f, 
    -0.33907181f, 0.15266575f, 0.00922729f, -0.13455306f, 0.13965383f, -0.45853144f, 0.31929630f, -0.11219211f, 
    -0.12488498f, -0.04004663f, 0.38545278f, -0.12211415f, 0.06927881f, -0.20578602f, 0.11335240f, 0.19946003f, 
    0.01656354f, 0.17472188f, -0.07582568f, -0.15765993f, -0.28433472f, -0.04685951f, 0.11818554f, 0.06869638f, 
    0.32680976f, 0.09255804f, 0.13715537f, 0.47730356f, -0.09811099f, 0.17916636f, -0.08591453f, -0.40536031f, 
    -0.08206742f, -0.04605636f, 0.23124105f, -0.15385538f, 0.15241377f, 0.09008156f, -0.00312414f, -0.10971237f, 
    -0.13520294f, -0.14255823f, 0.07379626f, -0.15599284f, 0.10574685f, 0.08199254f, -0.20422055f, -0.11122659f, 
    0.21684389f, -0.05509841f, 0.15814018f, 0.19426714f, -0.15732653f, 0.08914044f, -0.02788178f, -0.17264065f, 
    0.05065285f, -0.07888237f, 0.01939371f, -0.10757751f, -0.17752925f, -0.01825048f, 0.04234857f, -0.02851835f, 
    0.13283053f, -0.08015610f, -0.11228942f, 0.06796202f, 0.07052732f, -0.09566652f, 0.03942014f, -0.08041509f, 
    -0.11508987f, 0.05553545f, -0.17361900f, -0.01612899f, 0.05137456f, -0.00772931f, -0.03531729f, -0.13935530f, 
    -0.07668543f, 0.01675124f, 0.13772294f, 0.00005882f, -0.10076044f, -0.10904205f, 0.09884827f, -0.16807683f, 
    -0.06069338f, -0.17148258f, -0.07619872f, -0.15687710f, 0.04098429f, -0.04605281f, 0.02528044f, -0.00825855f, 
    -0.52711964f, -0.09111666f, 0.01370479f, 0.01529802f, -0.00379732f, 0.15606242f, -0.16472341f, -0.19519955f, 
    -0.07054047f, 0.00935107f, -0.28461280f, -0.35840306f, 0.04082397f, -0.16834795f, -0.11397511f, -0.03895231f, 
    0.05376946f, -0.27307558f, 0.14905812f, 0.13874772f, 0.10112958f, -0.10198669f, -0.08660255f, -0.02390503f, 
    -0.18621513f, 0.06758156f, -0.05328021f, -0.14264558f, -0.02084211f, -0.20060369f, 0.06782830f, -0.01394756f, 
    0.28387335f, 0.00036734f, -0.20907001f, -0.48685452f, -0.08724679f, -0.24569361f, 0.01998845f, 0.25344464f, 
    0.40769342f, -0.14670949f, -0.09273639f, 0.06856950f, 0.02657731f, -0.28849593f, -0.17767711f, -0.45085657f, 
    0.24654360f, 0.16118531f, -0.15759595f, -0.14207289f, 0.12003424f, 0.07022232f, 0.00090500f, 0.37901950f, 
    0.13509338f, -0.57804871f, -0.06597468f, 0.14784919f, -0.14562505f, 0.46270043f, -0.26811573f, 0.83537436f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.20374027f, 0.06719118f, -0.18387629f, -0.25343728f, 0.13546725f, 0.14244185f, 0.17609705f, 0.30589056f, 
    -0.08587723f, 0.43596092f, 0.14737220f, 0.13772129f, 0.21073624f, 0.14262943f, 0.23057091f, 0.31612727f, 
    0.10215145f, 0.16621657f, -0.26479250f, 0.19639529f, 0.03623816f, -0.02102868f, 0.21336004f, 0.01721913f, 
    0.04359153f, 0.34148848f, 0.19839010f, 0.13643794f, -0.32909763f, -0.09298117f, 0.00770384f, 0.10986406f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.48593235f, 0.07519085f, -0.12813789f, 0.36218688f, -0.31334499f, 0.13187006f, 0.22255880f, -0.64940137f, 
    -0.13413210f, -0.01650553f, -0.80440789f, 0.23068644f, 0.11787769f, -0.12771711f, 0.19837552f, -0.34419832f, 
    0.19795644f, -0.12684073f, 0.15948373f, -0.08385520f, -0.04316344f, 0.09638114f, -0.85800344f, 0.18545122f, 
    -0.09443584f, -0.15832955f, 0.17451702f, -0.34667757f, -0.03798131f, -0.15096702f, -0.24591768f, 0.43524656f, 
    -0.31477615f, 0.09210633f, -0.13729884f, 0.06366652f, 0.22382294f, -0.07319952f, -0.41309121f, 0.48762399f, 
    -0.14615420f, 0.41819376f, -0.24751490f, 0.04768719f, 0.39524800f, -0.44746745f, 0.27062535f, 0.07115727f, 
    0.43877250f, -0.08831868f, 0.11009943f, 0.15200803f, -0.14974169f, -0.07262199f, -0.94520330f, 0.25214630f, 
    -0.03382776f, -0.06788223f, -0.00396341f, -0.39314380f, -0.02050094f, 0.07440556f, -0.02026649f, 0.12283391f, 
    -0.02406116f, 0.08840565f, -0.17959410f, -0.26234543f, -0.14374362f, -0.04716108f, 0.47011751f, 0.15830746f, 
    0.01827723f, -0.28897950f, -0.12715268f, 0.03975419f, -0.20730230f, 0.10068750f, 0.16565272f, 0.06511106f, 
    -0.11971431f, -0.51196647f, -0.03465690f, 0.22490822f, 0.05866379f, -0.26715672f, 0.48224708f, -0.44376552f, 
    -0.04862086f, 0.19358279f, 0.24145557f, 0.12406576f, 0.15797988f, 0.15705138f, 0.12382496f, -0.92560697f, 
    -0.21699117f, 0.06475878f, -0.03909683f, 0.08825358f, -0.94509947f, -0.59372002f, 0.30598053f, 0.14991130f, 
    -0.11982084f, -0.06968202f, 0.10430116f, -0.00124871f, -0.63920426f, 0.55754107f, 0.16671433f, -0.27627787f, 
    -0.38474762f, -0.12631692f, 0.01749936f, -0.43823504f, 0.11165147f, -0.30596673f, 0.31646624f, 0.10341771f, 
    0.14632250f, 0.20742269f, -0.33088499f, 0.35141975f, -0.05452685f, -0.05999688f, -0.26094428f, 0.06227683f, 
    0.00353255f, -0.26012409f, -0.15007569f, -0.00528744f, 0.05648377f, 0.14638820f, -0.06194141f, -0.96036220f, 
    -0.16942495f, -0.10659582f, -0.03480428f, 0.13816009f, 0.24343877f, 0.12929338f, 0.06918265f, -0.31941444f, 
    -0.75736547f, 0.19925168f, -0.20543849f, -0.31595144f, 0.09225888f, 0.43642923f, -0.26399001f, 0.06146762f, 
    0.01546621f, 0.27361214f, -0.41922149f, -0.03353615f, -0.01002085f, -0.09244424f, 0.16077983f, 0.11432640f, 
    0.14085424f, 0.02355091f, 0.09354191f, -0.39058113f, 0.29385164f, 0.15261628f, 0.07898641f, 0.27173832f, 
    0.12355291f, -0.68370414f, -0.05223949f, 0.06463473f, -0.25851122f, -0.38772750f, 0.22880438f, -0.01574806f, 
    -0.28383291f, -0.04947231f, 0.24318644f, -0.24790059f, -0.02765121f, -0.18184890f, 0.17750564f, 0.20919620f, 
    -0.11213873f, 0.21431926f, -0.49812993f, -0.11543436f, 0.04481610f, 0.00353357f, -0.14301915f, 0.01826146f, 
    0.16594826f, -0.40065178f, -0.14619163f, -0.32427269f, -0.12768497f, 0.35548663f, -1.05151510f, 0.31043273f, 
    0.01325979f, 0.17018174f, -0.03916725f, -0.30820784f, 0.25973931f, 0.10397884f, -0.51472062f, 0.16728254f, 
    0.25285590f, -0.71895814f, -0.00719406f, 0.12844345f, -0.06012858f, -0.44736627f, 0.04471417f, -0.56600356f, 
    0.03880155f, -0.52270156f, 0.48888057f, 0.30070597f, -0.05632925f, -0.01101512f, -0.29432872f, -1.03586638f, 
    0.16226469f, -0.46583432f, 0.08899944f, 0.28044349f, 0.18627909f, -0.62651873f, -0.41849223f, 0.27023715f, 
    -0.03129645f, -0.33780822f, 0.23835573f, -0.08944781f, -0.61876398f, -0.02277708f, 0.21718293f, -0.27349430f, 
    -0.82779920f, 0.19834585f, 0.39677337f, 0.05853647f, -0.05428857f, 0.19963089f, 0.15223022f, 0.01495660f, 
    -0.09700549f, -0.98799729f, 0.31219488f, -0.06247908f, -0.21394539f, 0.04703156f, 0.10114109f, -0.43508002f, 
    0.15344098f, 0.30367586f, 0.13673507f, -0.37657493f, 0.04136588f, -0.19494207f, -0.49239156f, -0.39643267f, 
    -0.05954956f, -0.01721181f, 0.31946602f, -0.28277174f, -0.31494257f, -0.25566059f, 0.27332628f, 0.12764810f, 
    0.68727291f, 0.48793414f, -0.57756394f, 0.23213533f, -0.07485805f, -0.22659548f, -0.04813774f, 0.06362011f, 
    -0.11102234f, -0.23949090f, -0.18173833f, -0.85181296f, -0.15530191f, -0.03196725f, 0.03325590f, -0.38659385f, 
    0.14515027f, -0.01129386f, 0.00921199f, -0.53394949f, -0.25180340f, 0.31684664f, 0.20166564f, -0.96695811f, 
    0.13850868f, -0.54187214f, 0.06968143f, -0.60465991f, 0.35928968f, 0.08647001f, -0.54782969f, 0.11268393f, 
    0.09118473f, 0.46722949f, -0.14865661f, 0.03794375f, 0.15947326f, 0.14493586f, 0.11674967f, -0.45170531f, 
    0.17140268f, -0.23441906f, 0.31546393f, -0.00245375f, -0.27959254f, -0.01421230f, -0.21943527f, 0.36961752f, 
    -0.09313010f, 0.44935885f, -0.00197183f, 0.56125021f, 0.12160605f, -0.04106878f, -0.19346850f, 0.20864835f, 
    -0.16496737f, -0.25354624f, 0.28348565f, 0.32852593f, -0.55442721f, -0.22911547f, -0.37695283f, 0.19716910f, 
    -0.47983587f, -0.02488779f, -0.61389393f, -0.13311049f, -0.04875820f, -0.76937908f, -0.42822415f, -0.13867977f, 
    -0.14879382f, 0.45949626f, -0.04321101f, -0.50805819f, -0.46867403f, -0.03915282f, -0.26821366f, -0.73699927f, 
    0.01922856f, -0.21447311f, 0.15907627f, -0.07412963f, -0.05106375f, -0.56901067f, -0.01989341f, 0.03294012f, 
    -0.14258297f, -0.59976327f, 0.44476914f, -0.41937962f, 0.53073168f, -0.23841523f, -0.82573014f, 0.39539388f, 
    -0.16646814f, -0.25361699f, 0.04736297f, -0.08494779f, 0.05696620f, -0.14886077f, 0.26315644f, 0.36056602f, 
    -0.02530942f, -0.45904785f, -0.77709943f, 0.07788068f, -0.23320512f, 0.11914454f, -0.35295898f, -0.08299734f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.10219575f, -0.06366976f, 0.20215109f, 0.14773111f, -0.02658067f, -0.15640487f, -0.04642030f, -0.04122061f, 
    0.30354398f, 0.01552003f, -0.08425674f, 0.06217616f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
