#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.71621042f, -1.08996534f, -0.07040174f, 1.21062696f, 0.69675171f, -0.36641279f, 0.57209468f, 0.18190958f, 
    -0.52179122f, 0.11645236f, -0.04490303f, -0.02824982f, 0.04549170f, 0.09939943f, 0.25965825f, -0.10303001f, 
    0.13623498f, 0.27906471f, 0.00092313f, -0.14945282f, -0.11034891f, -0.00314611f, -0.09580259f, -0.17141692f, 
    -0.22378458f, 0.66239285f, 0.27066594f, -0.42057234f, 0.04418350f, 1.32577670f, 0.28394461f, -0.06209223f, 
    0.64286238f, 0.05294108f, 0.38575482f, -0.44194496f, -0.09964641f, -0.08778612f, -0.05787885f, -0.12679553f, 
    -0.14038125f, -0.53873152f, 0.17177084f, 0.04160450f, -0.45866841f, 0.25358757f, -0.03283600f, -0.18699606f, 
    0.23740549f, 0.14915054f, -0.70254529f, -0.77059567f, -0.09076919f, 0.09793339f, -0.49874407f, 0.56462568f, 
    -0.19321151f, 0.36847615f, 0.05007966f, -0.38789439f, -0.12586409f, 0.10062496f, -0.43176216f, 0.26596513f, 
    0.52466345f, 0.11773121f, 0.22915083f, -0.53165847f, -0.00606132f, 0.32483080f, -0.22981946f, -0.03860756f, 
    0.71375549f, 0.45986548f, -0.11230903f, 0.68869400f, 0.99964797f, 0.86419767f, 0.50567877f, 0.10301325f, 
    -0.44530404f, 0.70746464f, -0.25573945f, -0.46923357f, 0.16364181f, -0.25023347f, 0.27800477f, 0.12045109f, 
    0.19108394f, 0.12733780f, -0.23934011f, -0.25298414f, -0.23255177f, -0.27156526f, -0.08991568f, -0.15543769f, 
    0.39500812f, 0.09914543f, 0.31663954f, 0.15342185f, 0.68151104f, -0.33967569f, -0.70019907f, -0.43281475f, 
    -0.46329248f, 0.52219027f, 1.16339052f, -0.29985783f, 0.22617118f, 0.37914610f, 0.01940472f, 0.31937209f, 
    -0.61900812f, -0.17956389f, 0.15009831f, 0.13224603f, -0.17038022f, 0.05037199f, -0.02340084f, -0.13259812f, 
    -0.05307397f, -0.08844172f, -0.09185373f, -0.25857499f, 0.30890396f, 0.33794793f, 0.91714036f, 0.74729437f, 
    -1.13348591f, -0.89063036f, -0.32008058f, -0.08193271f, -0.02032448f, -0.77264863f, -0.22751006f, 0.34600088f, 
    0.30108142f, -0.02674688f, -0.00152046f, -0.10109138f, 0.14132346f, 0.09198643f, -0.03327522f, 0.01022969f, 
    0.05241503f, 0.31543827f, 0.21993242f, 0.21878217f, 0.02613714f, 0.11955505f, 0.60334909f, 0.59489316f, 
    -0.48924798f, -0.97157711f, -0.90611780f, 0.79292679f, -0.16332026f, -0.08855245f, 0.32683995f, 0.20648524f, 
    0.57994717f, -0.03612487f, 0.10096820f, -0.02060251f, -0.27814475f, 0.07673675f, 0.17437366f, 0.13264684f, 
    0.40474570f, -0.02378661f, -0.43042612f, -0.33273497f, 0.01399655f, -0.16700594f, 0.29532725f, 0.69066209f, 
    0.66011798f, 0.87656420f, 0.81245607f, 0.12893502f, -0.22099783f, -0.27409407f, -0.49667469f, 0.08924996f, 
    0.29287288f, 0.63216990f, -0.42341813f, 0.01466806f, -0.22209108f, -0.37614784f, -0.43651831f, -0.37035495f, 
    0.13678117f, 0.11603671f, 0.04915377f, -0.13541648f, 0.19427817f, 0.25638187f, -0.23023698f, 0.34429991f, 
    -1.01359093f, 1.14590442f, 0.20588490f, -0.49070758f, -0.45524129f, -0.02787527f, 0.76716495f, -0.39570978f, 
    -0.20539735f, -0.10688105f, -0.21804874f, 0.07267638f, -0.08885495f, -0.26018733f, 0.21169268f, -0.35432863f, 
    -0.07219730f, 0.19812910f, 0.16259395f, -0.58260465f, 0.23104051f, -0.33433482f, -0.12093218f, 0.08847361f, 
    0.25821152f, 0.54698694f, 0.56902224f, -0.01757088f, 0.07510936f, 0.50295150f, -0.92759860f, -1.09028625f, 
    -0.20497432f, -0.49858099f, -0.41280389f, -0.06340642f, 0.35708258f, -0.01019653f, 0.18731050f, 0.17337018f, 
    0.24815896f, -0.13133571f, -0.21611595f, -0.28360841f, 0.04404571f, 0.00599807f, 0.28257328f, -0.14925210f, 
    0.37809595f, 0.06230834f, -0.99871451f, -0.13919960f, -0.46147740f, -0.52327615f, 0.08997080f, 0.54231089f, 
    0.46257791f, 0.44195396f, 0.79488611f, 0.84570396f, 0.22399701f, -0.11904151f, 0.34611279f, 0.00613138f, 
    0.40166008f, 0.18563500f, -0.00776404f, -0.14714022f, 0.29257348f, -0.10563370f, -0.24533708f, -0.05478016f, 
    -0.44504291f, -0.01946739f, 0.20308210f, -0.85947174f, -0.71215320f, 0.44172254f, -0.01123852f, -0.42981288f, 
    -0.38256440f, -0.36933815f, 0.53392607f, 0.61457717f, -0.50299525f, 0.31277132f, -0.05663055f, -0.07458215f, 
    0.13851254f, -0.54882574f, 0.17772846f, 0.18858664f, 0.34471110f, -0.44467062f, -0.48899233f, -0.10317508f, 
    0.17200787f, 0.07352545f, -0.10597944f, -0.11507830f, -0.02868093f, -0.75400430f, -0.19593319f, 0.78721589f, 
    0.55793858f, -1.12125969f, -0.15510009f, 0.02816086f, -0.69026977f, -0.11618954f, 0.54365343f, 0.49481511f, 
    -0.19865215f, -0.10240249f, 0.10851038f, -0.19466417f, 0.34804380f, 0.15040834f, 0.25847918f, 0.29069862f, 
    0.22404419f, -0.21855547f, -0.31600052f, -0.16709690f, -0.11262348f, -0.46369928f, 0.27306604f, -0.20168237f, 
    -0.69056147f, 0.56834793f, 0.77129418f, -0.13540965f, -0.75572765f, -0.13049765f, -0.83898610f, -0.44792119f, 
    -0.27913919f, -0.46234909f, 0.30341819f, -0.23971592f, 0.06931008f, -0.30535239f, -0.16613621f, -0.01871708f, 
    0.12344348f, 0.33402774f, 0.25633022f, -0.33174428f, -0.04716470f, -0.00792166f, -0.71618730f, -0.66944081f, 
    -0.48839599f, -0.15286078f, -0.71726137f, 0.65826190f, 1.01399553f, -0.57380253f, 0.50733095f, 0.60110885f, 
    -0.04429341f, -0.43233001f, 0.23035406f, -0.21786326f, 0.21180208f, -0.28645065f, -0.07760445f, 0.17286453f, 
    -0.13931042f, -0.15147714f, 0.12174302f, -0.14595811f, 0.23194195f, 0.28579065f, -0.00344209f, -0.96075964f, 
    0.26045302f, 0.83752841f, 0.03627033f, -0.36117813f, -0.70443332f, 0.78979731f, 0.27766138f, -0.46112543f, 
    -0.50584781f, -0.16720289f, 0.52787244f, -0.48396263f, 0.25080165f, 0.22947010f, 0.06890906f, -0.09747361f, 
    -0.06850075f, -0.12301476f, 0.04759055f, -0.20637563f, -0.06691812f, 0.28980580f, 0.35735145f, 0.00238758f, 
    0.01752112f, -0.64377612f, -1.00131583f, -0.93123531f, -0.24105260f, 0.20329559f, 0.12337766f, 0.44849342f, 
    0.67082310f, 0.36373931f, -0.50269789f, -0.50616282f, -0.43026793f, -0.22839254f, -0.26201394f, -0.07456841f, 
    0.15591089f, 0.05901917f, -0.03499550f, 0.07068136f, 0.07570497f, 0.06921969f, -0.18778226f, -0.09665731f, 
    -0.16098331f, -0.02996226f, -0.18295464f, -0.87479055f, -0.51834887f, -0.31633973f, 0.34110788f, -0.03614605f, 
    -0.33112806f, -0.52586317f, 0.29794684f, 0.28079486f, -0.12884246f, 0.27670318f, 0.43568826f, 0.53625745f, 
    -0.42290950f, -0.36989707f, -0.23602763f, -0.26984727f, -0.35662603f, -0.08041642f, 0.01226944f, 0.34260780f, 
    -0.25113100f, 0.01543888f, -0.89975125f, -0.69254309f, -0.04350569f, -0.39921251f, -0.59888697f, 0.09904607f, 
    -0.26582733f, 0.12937929f, -0.31162310f, -0.42233828f, -0.38042077f, 0.01542279f, 0.12616727f, 0.25888512f, 
    0.49245518f, 0.21487452f, 0.25136971f, 0.46852258f, 0.25213316f, -0.26854306f, 0.53568381f, -0.29797712f, 
    -0.66237265f, -0.14094694f, -0.12506847f, -0.43453500f, 0.11320422f, 0.49796224f, 0.00157310f, -0.11528606f, 
    -0.05039015f, -0.53888106f, -0.50799435f, -0.41769922f, -0.12943709f, 0.29604006f, 0.65292704f, 0.41457033f, 
    0.13251100f, 0.31316236f, -0.50991046f, -0.44039947f, 0.45649412f, 0.18493165f, 0.69680923f, 0.19329606f, 
    0.03803088f, -0.37351030f, 0.23094156f, 0.50187176f, -0.93135035f, 0.13696106f, -0.33203766f, -0.82293230f, 
    -0.84951735f, 0.42088714f, -0.09720699f, -0.48765418f, -0.36527979f, 0.48062980f, -0.19041753f, 0.19529758f, 
    -0.00416845f, 0.00326095f, -0.07239074f, 0.33320802f, 0.29524583f, 0.05709597f, -0.00132076f, 0.37586856f, 
    -0.05231954f, -0.16831391f, -0.00112359f, -0.09885910f, 0.13298322f, 0.92427218f, 0.47693214f, -1.02352190f, 
    -0.75547457f, -0.83121616f, -0.11421627f, -0.02613772f, 0.37706208f, 0.21732630f, 0.13533306f, -0.27734533f, 
    0.27943841f, 0.20425190f, 0.18956219f, 0.07030715f, 0.05383725f, 0.19929378f, -0.31799984f, -0.35075966f, 
    0.30954027f, -0.04617057f, 0.04417263f, 0.53279704f, 0.22322777f, 0.22249351f, 0.89863527f, 0.26336533f, 
    0.47834340f, 0.43152955f, 0.58930069f, 0.59526110f, -0.53619868f, 0.07146688f, -0.29727051f, 0.21894094f, 
    0.29251701f, 0.09615074f, -0.40380022f, -0.02937291f, -0.20915231f, 0.58368415f, 0.10814316f, 0.06162782f, 
    0.16808327f, 0.19421978f, 0.57313246f, 0.43303666f, 0.35076910f, -0.11258626f, 0.30271870f, 1.21777737f, 
    0.25344267f, -0.11967625f, 1.28335929f, 0.50227821f, -0.09238902f, 0.31017914f, -0.05339093f, 0.61870915f, 
    0.18130733f, -0.28738204f, -0.04150181f, 0.10441253f, -0.32245004f, -0.51906401f, 0.16417609f, 0.01189009f, 
    -0.22774653f, -0.32186437f, -0.07846430f, -0.05351340f, -0.01926357f, -0.22033866f, -0.10085276f, 0.00514819f, 
    -0.57480109f, -0.18859841f, -0.06007776f, -0.19846204f, 0.04536749f, -0.32389724f, 0.24837138f, -0.44067338f, 
    -0.93720388f, -0.35761106f, -0.04910216f, 0.37245950f, 0.12388372f, 0.21452622f, -0.63375390f, -0.26067251f, 
    -0.27311143f, -0.32818964f, -0.50410014f, -0.67189044f, 0.14713296f, -0.09153523f, 0.11608217f, 0.16799054f, 
    0.30477905f, 0.97326666f, -0.87854576f, 0.78135586f, 0.52820212f, -0.38968706f, 0.86667818f, -0.18712476f, 
    -0.17313498f, -0.09664869f, -0.05995842f, -0.04621252f, 0.03373162f, -0.04588791f, 0.39006570f, -0.02167960f, 
    0.22079450f, 0.16053753f, 0.11997497f, 0.19182692f, 0.19464506f, 0.17927107f, -0.27780485f, 0.14622854f, 
    -0.24830444f, 0.19238161f, -0.84272438f, 0.18481964f, 0.53550768f, 0.19950639f, -0.16996935f, -0.09244368f, 
    0.02699378f, -0.00849167f, 0.00350900f, -0.49170065f, -0.10642706f, 0.26153949f, -0.32091638f, -0.45494592f, 
    -0.45197839f, -0.40016815f, 0.68178999f, 0.19005725f, -0.09126458f, -0.12541358f, -0.01067428f, 0.37944451f, 
    -0.63236505f, -0.13578674f, -0.42860040f, 0.96465737f, 0.41455379f, -0.66773844f, 0.06606441f, -0.41462037f, 
    -0.44442940f, -0.51365077f, -0.43610460f, -0.40401909f, -0.55408877f, -0.15957759f, -0.25749499f, 0.45067742f, 
    -0.05420374f, -0.17063335f, -0.29535654f, -0.29827759f, -0.19729771f, -0.11575049f, 0.13596252f, 0.33328128f, 
    0.05553360f, -0.11973350f, -0.50097835f, -0.50765401f, 0.97609860f, 0.81578732f, 0.56354469f, 0.71036875f, 
    0.80881315f, -0.01890917f, 0.28277341f, -0.26472542f, -0.61323184f, -0.09785686f, 0.25415504f, -0.34758759f, 
    -0.22013265f, 0.20152611f, 0.27589300f, -0.11336623f, 0.19051439f, 0.28291211f, 0.34486738f, 0.37941933f, 
    0.20215358f, -0.19965822f, -0.05072586f, 0.21826196f, 0.44546482f, 0.13622336f, -0.79064518f, 0.03617834f, 
    0.45652393f, 0.18926328f, -0.41810152f, -1.01563668f, -0.43448001f, -0.26186389f, -0.39851183f, 0.35448456f, 
    0.19191937f, -0.36318234f, 0.35978988f, -0.50811565f, 0.37085450f, 0.17017034f, -0.11675579f, -0.20130251f, 
    -0.42176083f, 0.19526389f, 0.08599640f, 0.07437936f, -0.09791890f, 0.26246908f, -0.58194357f, 0.90182728f, 
    0.78580493f, 0.51215649f, 0.36839944f, 0.41108808f, 0.98082203f, 0.36986476f, 0.07703450f, 0.38627002f, 
    -0.42978486f, 0.20465878f, 0.39988619f, -0.14358418f, -0.30433506f, -0.00160754f, -0.06436386f, 0.23080535f, 
    -0.15287831f, -0.05224461f, -0.19262558f, 0.17454107f, -0.34132713f, -0.10809456f, -0.30525067f, 0.11947923f, 
    0.47572932f, 0.34530842f, 1.13788044f, -1.05837619f, 0.32449543f, -0.36942935f, -0.11662104f, -0.07134879f, 
    0.04315228f, 0.13034092f, -0.15963922f, 0.16735497f, 0.46985188f, -0.30602312f, -0.21681121f, 0.24204518f, 
    0.24139744f, -0.28709260f, -0.08015411f, -0.38820848f, -0.32876730f, -0.03893505f, -0.05160407f, -0.44062391f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09918576f, 0.20607004f, 0.04226053f, 0.18626934f, 0.29965025f, 0.37174270f, 0.08539937f, 0.13379821f, 
    0.10494960f, 0.30233645f, 0.08648586f, 0.44112760f, 0.37663707f, 0.17713366f, 0.08034864f, 0.34670028f, 
    0.08733701f, 0.12845445f, 0.12897646f, 0.39831486f, 0.13763264f, 0.27886787f, 0.27620679f, 0.30205274f, 
    0.28398371f, 0.11894703f, 0.07099592f, 0.17318647f, 0.27956089f, 0.13538143f, 0.18982981f, 0.18555757f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04172395f, -0.01772848f, 0.02647446f, -0.03008644f, -0.04892739f, 0.03031172f, -0.04074275f, 0.02051483f, 
    -0.00536812f, 0.04227184f, 0.02807825f, -0.00013107f, -0.05258815f, 0.02907453f, 0.00340377f, 0.05027537f, 
    -0.03357500f, -0.04197267f, 0.01901262f, 0.03401096f, -0.04680651f, 0.03536047f, -0.05199783f, -0.00885681f, 
    -0.01169578f, -0.03774776f, -0.01603643f, -0.01717517f, 0.03512383f, 0.03381682f, 0.02415539f, 0.02307145f, 
    -0.01207153f, -0.01933313f, 0.04188200f, -0.01002587f, 0.01546011f, 0.03081864f, -0.04492936f, -0.04454694f, 
    -0.03674926f, -0.05243971f, 0.02220979f, -0.04517879f, 0.00285420f, -0.02471155f, 0.02318670f, -0.04814696f, 
    0.00226581f, -0.01362430f, 0.02815864f, 0.03377745f, 0.04033065f, 0.03366863f, 0.00222953f, 0.03285617f, 
    -0.04397966f, 0.00568010f, -0.01429872f, 0.00145960f, -0.03329325f, -0.04559515f, 0.02580411f, 0.03710573f, 
    -0.02245361f, 0.00498252f, 0.00309841f, -0.02396202f, -0.01252799f, 0.01411379f, -0.01974157f, -0.04106582f, 
    0.00662710f, 0.03766971f, 0.02327086f, -0.02324985f, 0.00936029f, -0.02109547f, -0.03400776f, -0.02414424f, 
    -0.00434877f, -0.02838144f, 0.03529694f, 0.04264281f, -0.06179244f, -0.05144053f, -0.04425955f, -0.00812297f, 
    0.03807164f, -0.01351094f, -0.00367517f, -0.00349446f, -0.05577064f, 0.01566673f, -0.02859901f, 0.03237735f, 
    0.01128700f, -0.00217213f, 0.01515164f, 0.00560947f, 0.04236746f, -0.04685241f, -0.03277450f, 0.04406089f, 
    -0.00782468f, 0.03455283f, -0.00542502f, 0.01833389f, -0.02261224f, -0.03522417f, -0.05172447f, 0.02179263f, 
    -0.02403796f, -0.04773700f, -0.01965182f, 0.02978493f, 0.02972095f, 0.00395351f, 0.00690660f, -0.00521575f, 
    0.00176706f, 0.04115314f, -0.03844067f, 0.00293107f, -0.05854584f, -0.05273122f, -0.03504573f, -0.04766056f, 
    0.01713726f, -0.02035194f, -0.05014913f, -0.05605069f, 0.02556042f, -0.05537043f, 0.04907525f, 0.01534791f, 
    0.03817463f, 0.00881051f, -0.00519743f, 0.04508444f, -0.03805385f, 0.00965532f, -0.01590515f, 0.02419480f, 
    -0.00877781f, 0.02971571f, 0.00986564f, -0.03246344f, -0.04585111f, -0.02577878f, 0.00575580f, -0.03504818f, 
    0.00311386f, 0.03955426f, 0.01886139f, -0.02945820f, 0.01869495f, -0.02117123f, 0.00430323f, 0.00233055f, 
    0.03743409f, -0.05571099f, -0.02058631f, -0.05250239f, 0.03199322f, 0.00262693f, -0.02236791f, 0.00494650f, 
    -0.03153938f, 0.05711203f, 0.03793876f, 0.01529532f, -0.01947252f, -0.02179476f, -0.00983034f, -0.03396854f, 
    -0.03486985f, 0.03668943f, 0.03576273f, 0.04273199f, 0.03964367f, 0.01138177f, 0.04137758f, -0.00766036f, 
    0.03893425f, 0.03757356f, -0.00293846f, -0.04538035f, -0.02860573f, 0.01616298f, 0.04016833f, -0.00113468f, 
    0.00213444f, 0.01636733f, -0.02817132f, -0.04155953f, -0.02381451f, -0.00244402f, 0.04343455f, -0.03970107f, 
    0.01158378f, 0.01168582f, -0.01131754f, 0.03859629f, 0.05209823f, -0.02773896f, 0.01047695f, 0.00467883f, 
    0.00678110f, -0.03254686f, -0.04704244f, -0.02443462f, 0.01256400f, -0.02994250f, -0.01359046f, -0.01729918f, 
    -0.05427354f, 0.04491723f, -0.01352167f, -0.04107489f, -0.01699797f, 0.00732940f, -0.02972861f, -0.01246676f, 
    -0.00313798f, -0.04784948f, -0.01676239f, -0.00933216f, 0.04464502f, 0.01587908f, -0.00479970f, -0.02485153f, 
    0.03144901f, 0.03646566f, 0.03015485f, -0.00794135f, -0.00991824f, 0.02900063f, 0.00349146f, -0.00764249f, 
    -0.02348313f, 0.02517536f, 0.01027900f, -0.04663590f, 0.04123822f, 0.01572167f, 0.00430774f, 0.02813687f, 
    -0.00032868f, 0.03985554f, -0.01629665f, 0.04934034f, 0.05093056f, 0.03034450f, 0.03985342f, -0.05999437f, 
    -0.02521140f, -0.01836293f, 0.02545460f, 0.01730964f, -0.01423433f, -0.05813688f, -0.04374937f, 0.04108527f, 
    -0.04751384f, -0.06026834f, -0.04476975f, 0.00923168f, -0.05588435f, -0.05714947f, -0.01565292f, -0.00904523f, 
    0.01277303f, -0.03526215f, 0.01999160f, -0.04822846f, -0.04136033f, 0.02043713f, 0.00003551f, 0.04102630f, 
    0.03808263f, -0.05146222f, 0.01183300f, 0.03073649f, -0.04975166f, 0.04327342f, 0.01000425f, -0.02274424f, 
    -0.04095693f, -0.04140051f, -0.05387969f, -0.03329992f, -0.03290503f, -0.01375083f, -0.02201478f, -0.01482928f, 
    -0.00713027f, 0.01816305f, -0.03678052f, -0.03783695f, -0.01572548f, 0.01504801f, -0.01809611f, -0.04310112f, 
    -0.01569662f, 0.00052893f, 0.03665954f, -0.01438973f, -0.05549161f, -0.02125294f, 0.04315068f, 0.01904348f, 
    -0.03242864f, 0.02263370f, 0.00126848f, 0.05200380f, 0.01206056f, -0.00696018f, -0.00597398f, -0.02874087f, 
    0.00669578f, 0.01001645f, 0.00239337f, -0.05319746f, 0.03114796f, -0.02316206f, -0.02919163f, 0.02296347f, 
    -0.04454758f, -0.01040182f, -0.03631130f, 0.01759537f, -0.02105257f, 0.00414079f, 0.00902080f, 0.01162525f, 
    0.03954627f, -0.04513937f, 0.02782398f, 0.02018175f, 0.03217103f, -0.01151387f, 0.00126766f, 0.00491987f, 
    0.01285806f, 0.00269145f, -0.01535215f, -0.04033730f, 0.00784119f, -0.04312372f, -0.02194094f, -0.00582862f, 
    0.01546362f, -0.00236849f, -0.00747017f, 0.01617584f, -0.02420542f, -0.05254083f, 0.03324445f, -0.01994732f, 
    0.02347124f, -0.04029939f, 0.01503913f, -0.02002647f, 0.03539665f, -0.05163190f, -0.00285482f, -0.02076416f, 
    0.03635019f, 0.00971029f, -0.02015647f, 0.00030017f, -0.02016528f, -0.04792375f, -0.03082149f, -0.02166780f, 
    0.03417223f, 0.00571649f, -0.01321586f, 0.01901684f, 0.03008354f, -0.02448692f, -0.05492008f, -0.02791852f, 
    -0.50533438f, -0.00116682f, 0.11339141f, 0.12762965f, -0.02688200f, -0.03093230f, -0.08363140f, -0.05660437f, 
    0.05718163f, -0.09956165f, 0.04494025f, -0.08487626f, 0.08973411f, 0.07214315f, 0.07969131f, -0.01222363f, 
    0.05212354f, 0.05806467f, -0.09966739f, 0.07734344f, 0.09573858f, -0.02740761f, 0.10902323f, -0.14457677f, 
    -0.07869365f, 0.01992166f, 0.10921738f, 0.05715577f, 0.07513069f, 0.06082469f, 0.27426508f, -0.08184907f, 
    0.14162269f, 0.46714553f, -0.11190955f, 0.00853121f, -0.06326362f, -0.38715142f, -0.08480977f, 0.06426347f, 
    -0.03362676f, 0.02261246f, -0.02562308f, -0.02561886f, -0.00791202f, -0.02950751f, 0.01522502f, -0.02945890f, 
    0.30558014f, 0.05140094f, -0.33514383f, 0.01014605f, -0.10964322f, 0.01717015f, 0.02027019f, -0.03673246f, 
    -0.01380762f, -0.15900481f, -0.04458140f, 0.11352018f, -0.06605892f, 0.15294112f, 0.07444400f, 0.14051387f, 
    0.12432756f, -0.17435052f, 0.00130453f, 0.11491709f, 0.12412710f, 0.15774426f, -0.06244436f, 0.05689380f, 
    0.04000809f, 0.27452534f, -0.15680876f, -0.20786767f, 0.12856902f, 0.05149494f, -0.20339954f, -0.14939308f, 
    -0.04210844f, -0.21067040f, -0.03265543f, 0.19864471f, -0.02486191f, -0.34902218f, -0.12285108f, 0.06895216f, 
    0.04576443f, -0.05759845f, 0.10518390f, 0.03138674f, 0.09281049f, -0.14360064f, 0.04293067f, 0.05024349f, 
    -0.30093685f, 0.19222952f, 0.08233709f, 0.28568867f, 0.07567350f, 0.04645628f, -0.07273109f, -0.00196690f, 
    0.00223619f, -0.07889417f, 0.14530066f, -0.21031702f, 0.20636708f, 0.00723719f, 0.06629547f, 0.29897645f, 
    0.08614335f, -0.05918190f, -0.01455930f, 0.16666584f, -0.09643181f, -0.07797904f, -0.10060232f, 0.21573885f, 
    -0.21937048f, 0.31666791f, 0.05601687f, -0.20653303f, 0.03680651f, -0.00092407f, 0.03333070f, -0.31273934f, 
    0.12431943f, -0.01179752f, -0.00098649f, 0.04669835f, -0.14464846f, 0.21170551f, 0.05168048f, 0.02627199f, 
    0.07914234f, 0.18079160f, 0.03553344f, -0.00498960f, -0.06573564f, -0.13825330f, 0.15335931f, 0.02921246f, 
    -0.09992433f, 0.04619608f, 0.07716152f, -0.12204736f, -0.04802853f, -0.05753186f, -0.15582970f, 0.10879128f, 
    -0.06741390f, 0.22288884f, 0.00291946f, 0.29533237f, 0.30001903f, 0.10546247f, 0.14286067f, 0.25600255f, 
    0.13996153f, 0.11794877f, 0.04642663f, 0.08120636f, -0.00862680f, 0.05678315f, -0.06940877f, 0.05921576f, 
    -0.17235191f, 0.34785035f, -0.25049323f, 0.15371200f, 0.08492827f, 0.01506873f, 0.17732878f, -0.01153444f, 
    0.12868041f, -0.06395294f, 0.10806682f, -0.20753467f, -0.07158646f, 0.25090981f, 0.26444450f, 0.04772882f, 
    0.00956793f, 0.04204332f, -0.07524132f, 0.08929358f, 0.04293389f, 0.08330189f, -0.13223660f, 0.19361132f, 
    0.48699945f, 0.04586251f, -0.16135068f, -0.13628826f, 0.00448095f, 0.12285095f, -0.12075452f, -0.13585345f, 
    0.07638127f, 0.10385343f, -0.19319049f, -0.22267438f, 0.04454671f, -0.15302289f, -0.09408347f, -0.00296636f, 
    -0.10191661f, -0.03305164f, 0.05726407f, 0.16122624f, 0.10996946f, 0.07240254f, 0.13137545f, -0.01535573f, 
    0.06009801f, -0.10753452f, 0.00393433f, 0.07343065f, 0.10515381f, 0.11219189f, -0.15348902f, -0.05607009f, 
    0.08384138f, 0.22678955f, 0.28351998f, -0.04610418f, 0.23931518f, 0.04416509f, 0.04586246f, 0.18617593f, 
    -0.21053791f, -0.04592461f, -0.03962827f, 0.07678142f, -0.12863378f, 0.29087570f, 0.25981942f, 0.15996844f, 
    -0.12633531f, 0.24304330f, 0.00123761f, 0.36638632f, 0.11631180f, 0.07331546f, -0.02206343f, -0.15616618f, 
    0.07690378f, -0.09904101f, -0.03493265f, -0.11984169f, 0.24976785f, 0.07587633f, -0.01998863f, -0.18991646f, 
    0.00927565f, 0.10685793f, -0.02090469f, 0.01641480f, 0.15235545f, 0.07950862f, -0.11458001f, 0.06835224f, 
    -0.15130574f, -0.19965631f, 0.01157229f, 0.19543518f, -0.03129157f, -0.02059031f, 0.18407927f, 0.01312509f, 
    0.09485704f, 0.22986491f, -0.02706530f, 0.40289959f, 0.07714584f, -0.31028065f, -0.00292394f, -0.10108610f, 
    0.00480276f, -0.19847678f, -0.02771066f, -0.19173639f, 0.07156589f, -0.08286114f, -0.28360978f, -0.01632851f, 
    0.24164703f, 0.11432088f, 0.24030685f, 0.40879497f, -0.06317959f, 0.08717419f, 0.06564444f, 0.00390305f, 
    -0.02530489f, -0.10701139f, -0.02069206f, 0.02572700f, -0.17582372f, -0.16910475f, -0.02004488f, 0.55528682f, 
    -0.02814856f, -0.11158735f, -0.12267969f, -0.07922792f, 0.13954796f, 0.15567315f, 0.12895817f, 0.22508694f, 
    -0.26792368f, -0.01141947f, 0.16027844f, 0.03041106f, 0.21462423f, 0.10403634f, -0.35429817f, 0.15814728f, 
    0.17650434f, -0.07573222f, -0.12667149f, 0.06029749f, 0.27578604f, 0.13068913f, 0.14360447f, 0.29152617f, 
    -0.05297621f, -0.09448537f, -0.01397077f, 0.19393443f, -0.07613882f, 0.11349683f, 0.04006163f, -0.17291647f, 
    -0.17134382f, -0.28282657f, -0.05746569f, 0.10084053f, -0.07622173f, 0.13351651f, 0.07711264f, -0.06275773f, 
    -0.01159508f, 0.17392655f, 0.19676588f, 0.27709255f, 0.17582197f, 0.12791513f, 0.09183511f, 0.34350446f, 
    0.12391724f, -0.12618145f, -0.07465944f, 0.01545297f, 0.04333814f, -0.07179832f, 0.12113389f, 0.18633571f, 
    -0.50634265f, 0.06175883f, 0.14587018f, -0.08339021f, 0.22204840f, -0.11117505f, -0.21663132f, -0.08584242f, 
    0.00195880f, -0.02239747f, 0.04316876f, -0.03290355f, 0.07522672f, -0.25470507f, 0.02789030f, 0.07441559f, 
    0.18614729f, -0.18019503f, -0.10138497f, -0.03352272f, -0.08854271f, -0.10990026f, 0.12482861f, -0.01714041f, 
    -0.26026216f, 0.06447222f, -0.42218986f, 0.10975035f, -0.09984687f, -0.13568708f, -0.15979768f, -0.05993896f, 
    -0.06291491f, -0.09670861f, 0.11366881f, 0.03524325f, 0.20920929f, 0.24948838f, -0.08352061f, 0.08285267f, 
    0.07483350f, 0.06520218f, -0.01406935f, 0.08997001f, 0.20130789f, 0.05845239f, 0.07639727f, 0.12818569f, 
    -0.05652582f, -0.01989860f, 0.09535629f, 0.06753685f, 0.13109030f, -0.14057551f, 0.18133278f, 0.00639741f, 
    -0.08272657f, 0.22723204f, 0.02372076f, 0.22649682f, 0.39073238f, 0.03050190f, 0.07464838f, -0.05203057f, 
    0.07835787f, 0.14563660f, -0.03248851f, 0.00147380f, 0.11049332f, -0.01194206f, -0.02303239f, 0.02051665f, 
    0.14319360f, 0.07020942f, -0.00151952f, -0.21230884f, 0.16493860f, -0.03490220f, 0.09880187f, 0.11108097f, 
    0.09408315f, -0.02672296f, 0.09863710f, -0.12760720f, 0.05671986f, 0.30191204f, 0.18362047f, -0.27482936f, 
    0.17710623f, 0.04088011f, 0.04448924f, 0.04199360f, 0.00821021f, 0.08420555f, 0.14363149f, 0.17421442f, 
    0.06909893f, -0.08534884f, 0.46181676f, -0.29027742f, 0.23939778f, -0.08759735f, 0.08875312f, 0.10695017f, 
    -0.18805654f, -0.00761550f, 0.08716755f, -0.00977829f, -0.04866434f, -0.00099681f, 0.24905741f, -0.23273745f, 
    0.00197750f, -0.01854323f, 0.01522203f, 0.01950930f, -0.08600906f, -0.11888016f, -0.02937587f, 0.01449743f, 
    -0.29854283f, -0.25365368f, -0.18985568f, -0.08125740f, 0.03327753f, 0.12655756f, -0.10558440f, -0.09650858f, 
    0.03174899f, -0.10252710f, 0.16752975f, -0.09827465f, -0.12561798f, 0.01612186f, 0.08493334f, -0.18404751f, 
    0.04864416f, 0.05420073f, 0.05476141f, 0.06477559f, 0.02967074f, -0.04697239f, -0.12346731f, 0.14701925f, 
    0.47749510f, 0.03333101f, 0.11586618f, 0.01040374f, -0.08050666f, -0.01692295f, 0.16076502f, 0.22553751f, 
    -0.02123867f, 0.04168170f, 0.08544427f, -0.05642362f, 0.14689548f, 0.22110429f, -0.18264389f, -0.03740612f, 
    0.07604615f, 0.12617360f, 0.13598239f, 0.17001371f, 0.05742958f, 0.00783787f, 0.01438916f, 0.02578605f, 
    -0.08677375f, -0.09614694f, -0.21803974f, -0.17626846f, 0.05126814f, -0.03361719f, -0.13454945f, 0.17811680f, 
    0.10054278f, 0.05861650f, 0.26191142f, 0.27843788f, -0.50655055f, -0.01287286f, 0.04911520f, -0.18412292f, 
    0.06987315f, 0.13596474f, 0.08788516f, 0.05139900f, 0.08762701f, 0.01725073f, -0.11379326f, -0.00313569f, 
    0.11111265f, -0.10541388f, 0.01289318f, 0.28019816f, 0.10041077f, -0.15534419f, 0.01293798f, 0.01360689f, 
    0.16340441f, 0.12869830f, -0.01434304f, -0.04168577f, 0.02372423f, -0.09147651f, -0.37012580f, 0.07184698f, 
    -0.06439017f, 0.02634088f, -0.08938663f, 0.07979614f, 0.15117918f, 0.03184240f, -0.07354529f, -0.03869678f, 
    0.29659244f, 0.01827184f, 0.18049006f, 0.13748784f, 0.08708523f, -0.06650713f, -0.10203727f, 0.14366521f, 
    0.13642991f, -0.03397358f, -0.08611501f, -0.07415821f, -0.15498792f, -0.15722199f, 0.04809362f, 0.04873491f, 
    0.00996740f, 0.02593494f, 0.03090278f, 0.07334245f, -0.00500197f, -0.18508671f, -0.18586260f, -0.11760106f, 
    0.06376117f, 0.14193475f, -0.20532951f, 0.12009565f, 0.07158886f, 0.02203252f, 0.05737875f, -0.10974290f, 
    0.13422261f, 0.06192309f, 0.15243888f, -0.26399788f, 0.13461667f, 0.12207428f, -0.02586154f, -0.05122469f, 
    -0.10183565f, 0.04732223f, 0.00616443f, 0.19063301f, -0.13757446f, 0.12268321f, 0.23260245f, 0.16482542f, 
    -0.27380705f, -0.17079444f, 0.12400583f, -0.07925835f, 0.03969715f, 0.14115821f, 0.02745104f, 0.04138292f, 
    0.07764559f, 0.03562332f, 0.08986335f, -0.10880867f, -0.16815455f, 0.32516754f, 0.24888127f, -0.25891000f, 
    0.08379112f, -0.08060507f, 0.14445122f, 0.07579979f, 0.04099379f, -0.07370372f, 0.14060122f, 0.08545036f, 
    0.09352334f, 0.17110768f, 0.16098352f, -0.20992531f, 0.14017196f, -0.15406951f, 0.14060208f, 0.01501626f, 
    0.09932948f, 0.12173817f, -0.04714025f, 0.19203863f, -0.08498851f, -0.15220694f, -0.00133518f, 0.12780365f, 
    0.16748135f, 0.01782595f, -0.08673330f, 0.02220420f, 0.18350638f, 0.07377540f, -0.01425475f, 0.04895873f, 
    0.07877747f, -0.05959811f, -0.30690840f, -0.08780343f, -0.15514320f, 0.08261029f, 0.08174732f, 0.08516159f, 
    -0.02815634f, -0.18628593f, -0.03698665f, -0.22013187f, 0.08491988f, 0.08995230f, 0.17200288f, 0.04280902f, 
    0.02983829f, 0.07406898f, -0.02695300f, 0.01416970f, 0.18734466f, 0.01056908f, 0.12418076f, 0.06476580f, 
    -0.15912101f, -0.05008915f, -0.28400117f, -0.16709653f, -0.01940838f, -0.11567640f, -0.16523008f, -0.04138157f, 
    -0.00144438f, -0.09584271f, -0.01929912f, -0.10305751f, -0.33634877f, -0.10303213f, 0.10914942f, -0.11339772f, 
    0.02035542f, -0.00464130f, 0.12202632f, 0.02169053f, -0.06944262f, 0.07671832f, -0.02723876f, -0.17340568f, 
    0.07460788f, -0.02046194f, -0.31073344f, -0.00513883f, 0.13313209f, 0.06446630f, 0.03135826f, -0.04612586f, 
    -0.06878696f, 0.15957747f, -0.03062751f, 0.08332796f, -0.07551545f, 0.17731252f, -0.07951916f, -0.02297405f, 
    0.11676834f, 0.20291656f, -0.07891460f, 0.23251620f, 0.12041251f, -0.15638192f, 0.12850377f, 0.09707268f, 
    0.30236363f, 0.10720059f, -0.05040490f, -0.15450582f, 0.11202951f, 0.04528413f, -0.18966380f, -0.08148365f, 
    -0.08321904f, -0.03243850f, 0.14213435f, 0.08939613f, -0.56438488f, 0.18418217f, 0.06837082f, 0.01217627f, 
    0.18975951f, -0.03480960f, -0.23942220f, -0.19242288f, -0.10331945f, -0.11694453f, -0.01171368f, -0.06294162f, 
    0.24372283f, -0.21928771f, -0.18778607f, 0.19273512f, -0.16564010f, 0.18892545f, 0.05826378f, 0.04125390f, 
    -0.06356103f, -0.03135636f, -0.09254758f, -0.10125248f, -0.04056061f, 0.28810957f, -0.02019840f, 0.05592618f, 
    0.06377250f, 0.04791854f, -0.05212215f, -0.14714800f, 0.12347900f, 0.12697703f, -0.06451485f, 0.04685225f, 
    0.37563303f, 0.07016473f, -0.25640038f, 0.28174010f, -0.05836174f, -0.08626807f, -0.12942229f, -0.00965711f, 
    -0.02236524f, -0.11832997f, 0.30915213f, 0.04914118f, -0.06426756f, -0.02737706f, 0.08375803f, -0.09139784f, 
    -0.13435739f, 0.22132632f, 0.02327626f, -0.06267682f, -0.01960446f, 0.02304971f, -0.13456573f, 0.07111623f, 
    0.18247539f, 0.09548903f, 0.26561931f, -0.18605831f, 0.00995449f, -0.09844290f, 0.01267344f, 0.04179575f, 
    -0.02052223f, 0.04094611f, 0.00946042f, 0.03740090f, -0.30753106f, 0.20058781f, 0.21024422f, -0.10669786f, 
    0.19707946f, 0.08330511f, 0.02729330f, -0.02137959f, -0.13600136f, -0.06544176f, 0.13532923f, -0.05578664f, 
    -0.22673537f, -0.18481314f, 0.47025087f, -0.33713672f, -0.00742008f, -0.14543499f, 0.08240131f, 0.26476526f, 
    -0.07730605f, 0.08322705f, 0.05584906f, -0.10466298f, -0.11281256f, 0.07769839f, -0.12985338f, 0.17958637f, 
    -0.06415823f, 0.06350812f, 0.01116390f, -0.01049980f, -0.29891112f, 0.01343411f, -0.05394864f, -0.01772307f, 
    0.18164824f, 0.15541478f, -0.11085777f, -0.25155288f, 0.11383444f, 0.08910814f, 0.12884100f, -0.10494013f, 
    -0.06080028f, 0.01623175f, 0.10480943f, 0.10297788f, 0.17511116f, -0.12634267f, 0.07157813f, -0.14511676f, 
    0.16532552f, 0.03092931f, -0.03439365f, -0.00105017f, 0.02650582f, 0.07702751f, 0.07525939f, -0.13789620f, 
    0.53266484f, 0.41878882f, -0.02965407f, -0.12398679f, -0.05799085f, -0.19935404f, -0.04766614f, 0.13872953f, 
    0.05723141f, -0.12364912f, -0.00535076f, -0.07336634f, 0.14092612f, -0.07112022f, -0.08148299f, 0.31908503f, 
    0.00393554f, 0.05081075f, 0.22407494f, 0.08713169f, 0.13830942f, 0.10024114f, -0.01492776f, -0.03829909f, 
    0.35445988f, -0.19036065f, 0.05543409f, 0.17961694f, 0.12258214f, 0.06874590f, -0.15594476f, -0.11234019f, 
    -0.03044038f, -0.04910982f, 0.18938495f, 0.02013741f, -0.36661401f, 0.15574136f, 0.02493585f, -0.03377144f, 
    0.03954799f, -0.04153189f, 0.28553072f, 0.01029079f, -0.05721067f, 0.03162748f, -0.04614244f, -0.04113876f, 
    0.40881786f, 0.30395865f, 0.19235927f, 0.01731109f, 0.07679629f, -0.18267420f, -0.10450386f, 0.11008003f, 
    0.17711104f, 0.11129273f, 0.05664764f, 0.13244975f, -0.01693029f, 0.16060530f, -0.10485925f, 0.11706784f, 
    0.08383618f, -0.03478763f, -0.03533179f, 0.02297391f, 0.10380335f, -0.19918367f, 0.02894457f, -0.06867366f, 
    0.40978488f, 0.14809082f, 0.26184857f, 0.04604981f, 0.06333417f, 0.11279020f, 0.06657936f, 0.12878765f, 
    -0.04238348f, 0.01610360f, -0.03825159f, 0.08898809f, -0.02634036f, 0.07090136f, 0.13156275f, -0.04620431f, 
    -0.21962225f, -0.04152537f, -0.07139071f, -0.01027396f, -0.03669608f, -0.05724494f, -0.27351445f, -0.13753963f, 
    0.15621053f, 0.22377987f, -0.11301800f, 0.17998938f, 0.03127333f, -0.07305329f, 0.22368610f, -0.09832449f, 
    -0.04520922f, -0.15254283f, -0.20922883f, 0.02761949f, -0.13483858f, 0.22517645f, 0.00522665f, -0.20262612f, 
    -0.01521683f, -0.02342066f, -0.01353482f, -0.06224074f, 0.02590236f, 0.02207659f, -0.10767664f, -0.00664386f, 
    -0.07633918f, 0.19023958f, 0.23419735f, -0.32074344f, 0.23314890f, 0.04929176f, -0.00305852f, 0.11910896f, 
    0.00531427f, 0.00980964f, 0.02620124f, -0.04741147f, -0.15139323f, -0.26958072f, 0.33443576f, -0.11820245f, 
    -0.11189352f, -0.12012778f, 0.19729187f, 0.11975393f, -0.11940558f, -0.07131582f, 0.11212487f, -0.02063871f, 
    -0.01631020f, -0.03136184f, -0.06365125f, 0.03124152f, 0.04992390f, -0.10929453f, 0.00890333f, 0.01005302f, 
    -0.16832174f, -0.08179314f, 0.06670281f, 0.05289936f, -0.00852487f, -0.09788252f, -0.21069968f, 0.25176114f, 
    0.09906745f, 0.05204175f, -0.06788494f, -0.03517964f, -0.00134149f, 0.09309802f, -0.09725276f, 0.04054135f, 
    0.09827057f, 0.06343674f, -0.02662717f, -0.18838853f, 0.01823642f, 0.01941601f, -0.13715388f, 0.07105021f, 
    0.06112214f, 0.13649841f, -0.13391691f, -0.10086639f, 0.06888048f, 0.08358251f, -0.13509178f, 0.01512701f, 
    0.00167463f, 0.00125680f, 0.19928759f, -0.01494716f, 0.05265836f, 0.12483910f, 0.10298077f, -0.07150912f, 
    -0.13580695f, 0.02310804f, -0.21968542f, 0.37109524f, -0.11317302f, -0.03488223f, 0.17329074f, -0.07659408f, 
    -0.21041051f, 0.07088760f, -0.08126611f, -0.14583203f, -0.08116122f, -0.06019037f, 0.02159556f, -0.15863706f, 
    -0.09027024f, 0.02533573f, 0.08253551f, 0.11312319f, -0.10519603f, 0.06379238f, -0.10334238f, 0.09061915f, 
    -0.10255654f, -0.08065467f, -0.01472084f, -0.02076108f, -0.06390403f, -0.07941912f, -0.04761473f, 0.01295345f, 
    -0.05735435f, -0.02300484f, -0.10109350f, -0.08650477f, -0.01759845f, -0.00957508f, 0.05689115f, 0.12554349f, 
    0.00694752f, 0.12510292f, 0.08432604f, 0.10570782f, 0.07774310f, 0.06423075f, 0.03774840f, -0.08612929f, 
    0.33288062f, 0.01067372f, 0.05050722f, 0.05252738f, 0.01217363f, 0.16029494f, -0.03093652f, -0.19618557f, 
    -0.00667021f, 0.02640206f, -0.05080787f, -0.00399351f, -0.39722300f, 0.30369055f, -0.29897642f, 0.34977186f, 
    -0.00215761f, 0.13868217f, 0.10998837f, -0.00987540f, 0.13328101f, 0.06867281f, 0.05861831f, -0.12384440f, 
    0.03236400f, -0.01867105f, -0.02017572f, -0.01986909f, -0.04004604f, 0.00498726f, -0.02570556f, -0.04031403f, 
    -0.03819910f, 0.00928154f, 0.02655592f, -0.03661279f, 0.00413074f, -0.03296095f, -0.03661043f, -0.05274129f, 
    -0.00311742f, -0.03549752f, -0.04041436f, 0.03011667f, 0.01106647f, 0.02558362f, 0.03620272f, 0.01733251f, 
    -0.00817398f, 0.01358097f, 0.02875788f, -0.04278434f, -0.02141683f, -0.01277211f, 0.04025346f, 0.03449057f, 
    0.03485534f, -0.04144455f, 0.03083089f, -0.01125121f, -0.05119007f, 0.03495362f, -0.02298497f, -0.01427485f, 
    -0.01179637f, 0.01077680f, -0.01817495f, -0.03907290f, -0.02052109f, 0.03439277f, 0.00395321f, -0.02723734f, 
    -0.02833416f, -0.03054265f, 0.04683646f, 0.02936637f, -0.03144789f, -0.00062717f, -0.00857336f, 0.00284342f, 
    -0.04312257f, -0.02116195f, 0.04087160f, 0.02283228f, 0.03036140f, 0.00355644f, 0.00290825f, -0.04122061f, 
    0.02908546f, -0.03838938f, -0.01198016f, -0.01340794f, 0.04268931f, -0.04292608f, -0.03240930f, -0.04994551f, 
    -0.05021324f, -0.01277248f, 0.04416460f, -0.01628703f, -0.04973488f, 0.01282330f, -0.05226963f, -0.01941545f, 
    -0.05591856f, -0.00556848f, -0.03789727f, -0.04998501f, -0.00708555f, -0.05102828f, 0.01937061f, -0.00386532f, 
    0.01348095f, 0.04093966f, -0.01553956f, -0.05537592f, -0.02879036f, 0.04089355f, 0.01991027f, -0.03668091f, 
    0.01352860f, -0.05282995f, 0.03065044f, -0.05452925f, -0.04235687f, 0.01902949f, -0.03223822f, 0.03623993f, 
    0.02182314f, 0.03825871f, 0.02873785f, -0.04383633f, -0.00686101f, 0.00798427f, -0.03724114f, 0.03692758f, 
    -0.04356539f, 0.00809606f, 0.04290801f, -0.04760943f, -0.04998241f, 0.00936212f, 0.02946876f, 0.00224710f, 
    -0.04256340f, -0.04726704f, 0.01863576f, -0.03123607f, -0.02089010f, 0.02025895f, 0.00024367f, 0.02898969f, 
    -0.04850049f, -0.04473348f, -0.05041798f, -0.04556426f, -0.03858484f, 0.02493769f, 0.00909233f, 0.01687950f, 
    0.03443473f, 0.01814448f, -0.01466816f, -0.05541942f, -0.05515356f, 0.00641709f, 0.03521707f, 0.02082223f, 
    -0.00533148f, -0.01287528f, -0.05247049f, 0.03835743f, -0.00647752f, -0.03703820f, 0.02403080f, 0.03260449f, 
    0.00243814f, -0.00546071f, -0.00472641f, 0.03417718f, -0.00110195f, 0.02861312f, -0.04331850f, -0.04240581f, 
    -0.02826713f, 0.02104854f, -0.05890184f, 0.02406965f, -0.03615126f, 0.01100474f, 0.03061973f, -0.00084536f, 
    0.03450078f, 0.00984136f, -0.02155913f, -0.05816960f, 0.03736991f, -0.03718798f, -0.00467073f, 0.04478882f, 
    -0.00604664f, -0.00565547f, -0.02476784f, -0.04123247f, -0.05220076f, 0.03691931f, 0.01042657f, -0.00603322f, 
    0.01475708f, -0.05591246f, -0.00724712f, 0.01315199f, 0.03311037f, 0.04342416f, 0.03700162f, 0.00423360f, 
    0.02132575f, 0.00217458f, 0.03234902f, -0.01023526f, -0.00139643f, 0.00750589f, -0.02705093f, 0.01701906f, 
    -0.02119585f, -0.03687131f, 0.00626621f, -0.03802695f, -0.02736198f, 0.00515443f, 0.01776169f, 0.03045365f, 
    0.00943987f, -0.03755128f, -0.00886106f, -0.04725835f, 0.01674140f, 0.00208310f, 0.01889243f, -0.03555550f, 
    0.03034686f, 0.03290555f, -0.05110929f, 0.03396546f, -0.00196263f, 0.02565100f, -0.04612854f, -0.02629286f, 
    -0.05585666f, 0.01122871f, -0.02855281f, -0.02029868f, -0.02458045f, -0.05757024f, -0.02135495f, -0.03145191f, 
    -0.02484815f, -0.01909992f, 0.02862589f, -0.02225420f, 0.03359639f, 0.03814769f, -0.04048745f, -0.04456014f, 
    0.03083152f, -0.05692069f, -0.05108184f, 0.02775833f, 0.02326218f, 0.02620662f, 0.00501846f, 0.01010965f, 
    -0.00473149f, -0.00346112f, -0.04857116f, 0.04307332f, 0.00441925f, -0.04163445f, -0.01381281f, 0.00044481f, 
    0.00028069f, 0.03033091f, -0.03960573f, -0.04283832f, 0.02676426f, 0.02909609f, 0.02913081f, 0.01610539f, 
    -0.03893920f, 0.02079556f, -0.03426244f, 0.02293649f, 0.02946290f, 0.01505673f, 0.02706466f, 0.02933447f, 
    0.00977606f, -0.01577180f, 0.00488881f, 0.02194713f, 0.03774021f, -0.00509498f, -0.04387894f, -0.02355504f, 
    0.00666296f, 0.02101970f, -0.03693497f, 0.00334908f, -0.00346492f, -0.03336508f, -0.04572798f, 0.02095177f, 
    0.02667191f, -0.04841241f, -0.02814831f, -0.00865852f, 0.01306793f, -0.03932903f, -0.01225395f, -0.00418429f, 
    0.04149798f, 0.01455269f, -0.01519128f, 0.00374888f, 0.00470786f, -0.01090211f, -0.04417559f, 0.03477395f, 
    -0.03739455f, 0.00281233f, 0.00693550f, 0.04333806f, 0.00375030f, 0.04369120f, -0.01625900f, 0.03109662f, 
    -0.03751831f, -0.02944327f, -0.01269301f, 0.01317932f, 0.00057334f, -0.02101805f, -0.05648546f, -0.01234712f, 
    0.01542726f, -0.04414260f, 0.02585609f, -0.01979898f, -0.03738652f, -0.00139539f, -0.01596293f, -0.01214425f, 
    -0.03921216f, 0.03339492f, 0.04200638f, 0.02479187f, 0.02863506f, -0.03575680f, -0.04027797f, 0.03062535f, 
    0.02810897f, -0.02986606f, -0.03556852f, 0.03634576f, 0.01467529f, -0.03462779f, -0.05455375f, 0.00266828f, 
    -0.03789322f, -0.05202049f, -0.04863246f, -0.01714205f, 0.02135923f, -0.02164074f, -0.03952298f, 0.03538588f, 
    0.03531811f, 0.00371444f, -0.02771387f, 0.01754097f, -0.02281612f, -0.01504465f, 0.03148723f, -0.03078008f, 
    -0.00144042f, -0.04974268f, 0.02376628f, -0.04287142f, -0.01368942f, -0.03809181f, -0.00172708f, -0.02947099f, 
    -0.00222925f, -0.03107228f, -0.02349061f, 0.04026663f, -0.02093169f, 0.02520780f, -0.05349214f, -0.04682187f, 
    -0.03245591f, -0.03973893f, 0.02932396f, -0.00678527f, 0.01400653f, 0.01017312f, -0.02608584f, 0.03173378f, 
    -0.15691051f, 0.40850303f, -0.08029397f, -0.17341407f, -0.12299179f, -0.11763898f, -0.04872737f, -0.01908835f, 
    0.12659411f, 0.05462317f, 0.06476316f, -0.01514670f, 0.37709495f, 0.14648929f, 0.10490544f, -0.09765255f, 
    -0.12427232f, -0.04724075f, -0.01455782f, 0.00859390f, -0.05245819f, -0.06914990f, -0.02209123f, -0.03252396f, 
    -0.25446498f, 0.03607654f, -0.17004679f, 0.24995007f, 0.16478378f, 0.14850754f, 0.11961289f, -0.04833248f, 
    0.10595666f, 0.22638476f, -0.16022724f, 0.06200403f, -0.24086292f, 0.04354063f, 0.26266170f, -0.01452562f, 
    -0.11272479f, 0.04450262f, -0.05361558f, 0.10478523f, 0.04211248f, -0.04742496f, -0.06624310f, 0.06875679f, 
    -0.22650377f, 0.01936215f, -0.08674061f, 0.05286040f, 0.04791044f, -0.02950155f, 0.05029480f, 0.03701767f, 
    0.14808051f, 0.01614559f, -0.01665496f, 0.01302236f, -0.23292065f, -0.20569548f, 0.16635783f, 0.20551486f, 
    -0.05939762f, -0.00344049f, 0.07255162f, -0.02431673f, -0.02368319f, 0.01645315f, -0.04437459f, 0.02984380f, 
    -0.01844773f, -0.02019859f, -0.07251555f, 0.02861072f, 0.07672743f, 0.06779411f, 0.12239298f, 0.10973247f, 
    0.05173699f, -0.08043126f, 0.03254622f, -0.02777999f, -0.44161838f, 0.00096986f, 0.40444383f, -0.10564616f, 
    -0.16480747f, -0.12912661f, -0.01524416f, 0.00998480f, 0.08201876f, -0.16455869f, -0.14333755f, -0.13253529f, 
    -0.07884488f, -0.30789959f, 0.33431536f, 0.22550283f, 0.22671385f, 0.08197506f, -0.06727956f, -0.00748836f, 
    0.12176767f, -0.06738348f, -0.07205936f, -0.05840509f, -0.25048816f, -0.10927719f, 0.21480870f, 0.18648826f, 
    -0.17143138f, -0.05496491f, -0.08271380f, -0.12969838f, -0.18992960f, -0.09885827f, 0.04155397f, 0.22578925f, 
    -0.15013467f, -0.25632545f, -0.21879986f, -0.19936714f, 0.17866375f, 0.00949150f, 0.18462984f, -0.14847700f, 
    0.16389892f, 0.02741705f, 0.13252716f, 0.13988641f, 0.35219195f, 0.01667235f, -0.19396804f, 0.29393423f, 
    0.26997879f, 0.05755015f, 0.10638750f, -0.04022849f, -0.06327574f, -0.01610316f, 0.05363312f, 0.08269977f, 
    -0.25163344f, -0.17792279f, 0.02794465f, -0.05067950f, -0.07544913f, -0.04202114f, -0.02937810f, 0.14825015f, 
    0.20369244f, 0.16649947f, 0.01368348f, 0.11760464f, -0.09899198f, 0.31651646f, -0.09912430f, -0.20611174f, 
    0.19457754f, 0.13883924f, 0.16184187f, 0.13527073f, -0.10331086f, 0.03114666f, 0.09432324f, -0.02011641f, 
    -0.74033189f, 0.19646958f, -0.28020397f, 0.04188677f, 0.27303204f, 0.11234496f, 0.11365755f, -0.04563583f, 
    0.09236153f, 0.01438793f, 0.10778424f, 0.06699023f, -0.02245183f, -0.39660236f, 0.13569823f, 0.10897054f, 
    0.04948533f, 0.12654242f, 0.00672165f, 0.06440564f, -0.02629111f, 0.00432549f, -0.05641834f, 0.05127642f, 
    0.19278400f, -0.09702659f, -0.20738208f, 0.00073226f, 0.23783807f, 0.15417652f, 0.01784461f, 0.04946850f, 
    0.11498561f, 0.00252232f, 0.07747775f, -0.02981742f, -0.38912386f, -0.04834819f, -0.00050910f, 0.21232465f, 
    0.00100289f, -0.05575327f, 0.08974126f, 0.12265052f, -0.06789736f, -0.08069054f, 0.12078555f, 0.09751269f, 
    0.11986154f, 0.04318715f, -0.05218317f, 0.17676061f, 0.32292315f, 0.04149682f, 0.04232547f, -0.06175477f, 
    0.04529100f, 0.04643300f, 0.02336011f, 0.04620199f, -0.13750353f, -0.00165297f, -0.01568808f, 0.00217443f, 
    0.01578301f, 0.02437946f, 0.05934438f, -0.06333118f, -0.04985168f, 0.07488356f, 0.10049144f, 0.11408573f, 
    -0.23261574f, 0.00834893f, 0.08148833f, 0.33676812f, 0.27400449f, 0.08711506f, 0.16415797f, -0.02884794f, 
    0.02389804f, 0.12000680f, 0.01414327f, 0.00671456f, 0.18406020f, -0.03620702f, -0.07545535f, 0.06603511f, 
    -0.12769093f, 0.13594398f, 0.04771904f, -0.00835555f, 0.05284403f, -0.05540031f, 0.06753623f, 0.00085752f, 
    -0.19166376f, 0.18251604f, 0.19077811f, -0.14298175f, -0.12882541f, 0.02970407f, 0.07714733f, -0.07311092f, 
    0.01738840f, 0.10859776f, -0.10816177f, 0.04914784f, 0.01288395f, 0.20587412f, 0.15489933f, 0.05518566f, 
    -0.11888263f, 0.02166584f, -0.05126613f, -0.08599152f, -0.02499973f, -0.11236448f, -0.08635845f, -0.00803257f, 
    -0.01938694f, -0.06140734f, 0.13419394f, 0.11856341f, -0.01716101f, -0.06878861f, 0.10118434f, 0.19500299f, 
    0.06843854f, -0.14343385f, -0.09488976f, -0.12620781f, 0.15738374f, 0.50560546f, -0.03661199f, -0.00699018f, 
    -0.00697084f, -0.03943901f, 0.05373212f, -0.02948204f, 0.04847407f, -0.03067725f, 0.08805840f, 0.07836863f, 
    0.06263570f, 0.03864196f, -0.01773459f, 0.01381624f, 0.12547897f, 0.00407321f, -0.09973636f, 0.06957265f, 
    0.09297229f, -0.06593629f, 0.17045541f, 0.02445203f, -0.00758105f, -0.03155990f, 0.25352827f, 0.33313465f, 
    0.02111671f, 0.00744530f, 0.05063677f, -0.06167665f, -0.25202149f, -0.03959832f, 0.00314305f, 0.08673667f, 
    -0.11774263f, 0.28880468f, 0.09022680f, -0.20893015f, -0.15754992f, 0.04128108f, 0.00640326f, 0.03994831f, 
    0.02682465f, 0.07249366f, 0.03694494f, 0.01190462f, 0.21060011f, 0.28325853f, 0.07103524f, 0.09546489f, 
    0.04516441f, -0.05032751f, -0.10526159f, -0.11913893f, 0.09320533f, 0.02455781f, 0.11662546f, 0.20196420f, 
    -0.01360146f, 0.16613205f, 0.19515617f, 0.13282359f, 0.10680569f, 0.02852560f, 0.02633231f, 0.10082655f, 
    -0.09122436f, -0.00042216f, 0.02010920f, 0.06711518f, -0.25522792f, 0.06922292f, 0.17878021f, -0.01581859f, 
    -0.01643700f, -0.04681212f, 0.01718464f, -0.06278057f, -0.04442791f, -0.14446834f, 0.00542828f, 0.02345345f, 
    0.01786983f, 0.34919769f, -0.09965125f, -0.19616368f, 0.17375880f, 0.04883246f, 0.10109653f, 0.01351091f, 
    -0.09103025f, 0.08475649f, -0.11045660f, -0.00812734f, 0.13558719f, -0.05895751f, -0.09285051f, 0.01545145f, 
    -0.08623306f, -0.07289469f, 0.08997357f, -0.18244657f, -0.19137599f, 0.01917814f, 0.10614970f, -0.19701622f, 
    -0.08705567f, 0.10044619f, -0.12384569f, 0.16506882f, 0.02182378f, 0.11510029f, -0.12620653f, 0.16684034f, 
    -0.06910980f, -0.28921682f, 0.03976407f, -0.28678682f, -0.15687588f, 0.00274896f, 0.10316110f, -0.01388544f, 
    -0.07550690f, -0.09403625f, -0.09234814f, 0.10225964f, -0.05245193f, -0.04229672f, -0.00497494f, 0.06983944f, 
    -0.51637441f, 0.25083238f, 0.28218901f, 0.22233398f, -0.10579380f, 0.05323333f, -0.03709817f, -0.04163600f, 
    0.04856610f, 0.13524054f, -0.09458604f, 0.11386383f, 0.00366208f, -0.32393721f, 0.36477590f, 0.03249813f, 
    -0.21314164f, -0.02372907f, 0.01123228f, -0.20866176f, -0.05974264f, -0.20153154f, -0.14023829f, -0.11077910f, 
    -0.04319783f, 0.25686905f, -0.06775986f, 0.06758187f, -0.11264457f, 0.13766216f, 0.14395857f, 0.15793186f, 
    0.10546832f, 0.01411758f, 0.02946633f, 0.03237120f, -0.21462469f, -0.03025295f, -0.00929000f, -0.05074767f, 
    -0.04302106f, 0.10588393f, -0.17864439f, -0.04090313f, 0.07891462f, 0.00565694f, -0.07959898f, -0.09626058f, 
    0.54057312f, -0.05681044f, 0.50580478f, 0.08055905f, 0.15653600f, -0.07502952f, 0.19114400f, -0.11609921f, 
    -0.02309900f, 0.13522701f, -0.12167067f, 0.01053978f, -0.06591102f, -0.13144042f, 0.10563062f, 0.18054517f, 
    -0.17795630f, 0.01557297f, -0.03378167f, -0.18460603f, -0.09486251f, -0.03118088f, 0.24168347f, -0.21748634f, 
    -0.01037563f, -0.05423313f, -0.03442867f, 0.07168412f, 0.10623382f, -0.04668100f, 0.00188287f, -0.09406277f, 
    0.20354640f, 0.00162501f, 0.17796078f, 0.04225087f, 0.27056971f, 0.00352993f, -0.02305862f, 0.25905398f, 
    0.05582293f, 0.01185908f, 0.05351267f, -0.04630169f, 0.09870794f, 0.19240506f, -0.07545588f, -0.03864911f, 
    -0.18231659f, -0.20987654f, 0.11615861f, 0.08182463f, 0.04030820f, 0.01949997f, 0.08780455f, -0.12162900f, 
    0.19956763f, -0.00505097f, -0.05076158f, -0.20876803f, -0.04836835f, 0.27473578f, 0.08899646f, 0.09411829f, 
    0.13257289f, -0.00057595f, 0.07483822f, -0.03492073f, -0.00936498f, -0.05601275f, 0.11730612f, 0.18338938f, 
    -0.42389506f, 0.26251224f, 0.11354769f, 0.10734349f, 0.06968315f, 0.19775669f, -0.01969844f, 0.06713903f, 
    -0.08216892f, -0.02790033f, -0.03850517f, 0.09078518f, 0.22416458f, -0.17503096f, 0.37753817f, 0.05962578f, 
    0.05432941f, -0.01467799f, 0.12296207f, 0.06646109f, -0.07886101f, -0.00662254f, 0.12180145f, 0.03255740f, 
    -0.07686809f, 0.25556010f, -0.05669902f, 0.29055429f, 0.20263080f, 0.17222786f, 0.14654028f, 0.07812040f, 
    -0.06347734f, -0.02984585f, 0.18034391f, 0.14359087f, -0.22563128f, 0.06924658f, 0.13849844f, 0.17586461f, 
    0.07972010f, -0.14832205f, -0.01998170f, -0.00049396f, -0.00726631f, 0.03453449f, 0.16454072f, 0.20914863f, 
    -0.05308960f, -0.02239897f, 0.17825516f, -0.03489827f, 0.19358097f, -0.08314888f, 0.21973647f, 0.25771302f, 
    0.10567042f, -0.08823245f, -0.12901652f, 0.03870986f, -0.28356168f, -0.11729290f, 0.08497165f, -0.06554019f, 
    0.23785697f, 0.08863150f, 0.03264192f, -0.11036769f, -0.07895301f, -0.15776207f, -0.21151581f, 0.11476766f, 
    0.40045178f, -0.01854013f, 0.23815401f, 0.19549656f, 0.22993185f, -0.08207824f, -0.11638312f, 0.11838555f, 
    -0.04911267f, 0.01467438f, -0.04251723f, 0.15583530f, 0.05465325f, 0.02310638f, -0.20614558f, 0.23317902f, 
    -0.20168439f, 0.04991296f, 0.04483592f, -0.02372714f, -0.03008651f, 0.06173554f, -0.02007900f, 0.04968996f, 
    0.04558288f, 0.05505104f, -0.08517894f, -0.08412903f, -0.01526502f, 0.13806412f, -0.06090527f, -0.01275320f, 
    -0.00902040f, -0.10356167f, 0.03983663f, -0.25376889f, -0.04541500f, 0.31112465f, -0.05298682f, 0.02090944f, 
    -0.07551893f, 0.05836480f, 0.03365519f, 0.09791738f, -0.06089913f, 0.10213421f, 0.05231382f, 0.06736685f, 
    -0.30154359f, -0.06319398f, 0.38357997f, 0.02879040f, 0.06183806f, -0.11986168f, -0.02512493f, -0.00093177f, 
    -0.08228491f, 0.20757052f, -0.08778946f, 0.10682013f, 0.08429318f, 0.32142136f, -0.03970197f, -0.12957653f, 
    0.08697186f, -0.01253039f, 0.11665887f, -0.00731989f, -0.01521473f, -0.12630044f, -0.11642873f, 0.01708583f, 
    0.08654604f, 0.08015438f, 0.20355581f, 0.12459070f, -0.06180714f, 0.08448394f, 0.17246471f, 0.00033616f, 
    0.03264475f, 0.04702909f, 0.17412388f, 0.08480290f, 0.16211487f, 0.20832849f, -0.00961038f, 0.16850074f, 
    -0.08254538f, 0.06354431f, -0.01514195f, -0.11392896f, -0.00602084f, -0.18171093f, 0.01826338f, 0.05156913f, 
    0.07630084f, 0.11680388f, 0.16662216f, -0.03936575f, -0.01045503f, 0.01159186f, 0.05741914f, 0.05576690f, 
    0.00627295f, -0.13351962f, 0.03261303f, -0.20914128f, 0.14234422f, -0.13473336f, 0.13014141f, 0.26455274f, 
    -0.10781461f, -0.15699744f, -0.03746330f, -0.16429600f, -0.00866838f, 0.26055351f, -0.08821983f, 0.12005568f, 
    -0.19213328f, -0.16392137f, 0.06231056f, 0.07609878f, -0.04368648f, 0.04800199f, 0.23151688f, 0.10262354f, 
    0.10481278f, 0.01233241f, -0.14896253f, 0.09384260f, 0.20202664f, 0.06655650f, -0.15792960f, -0.11206893f, 
    -0.23302324f, 0.16057600f, 0.05101421f, 0.08153069f, -0.03360003f, 0.15073693f, -0.14874768f, 0.03720303f, 
    0.02396167f, 0.01939048f, 0.01566088f, -0.04132799f, -0.00319472f, 0.05205858f, 0.04076634f, -0.00481471f, 
    -0.01972267f, -0.00318359f, 0.01875554f, -0.01112284f, 0.00754461f, -0.00339627f, -0.04538147f, -0.02637297f, 
    0.02915382f, 0.03181868f, 0.00771037f, -0.04868039f, -0.02807100f, -0.02766631f, -0.05754538f, -0.05066271f, 
    -0.02488637f, 0.02204194f, -0.01965411f, -0.05277354f, 0.03754922f, 0.03409883f, 0.00206479f, -0.03572743f, 
    -0.01828588f, -0.03924701f, 0.03750436f, -0.05158626f, 0.05532603f, 0.01632337f, -0.02891352f, -0.00493565f, 
    -0.03368623f, -0.00410731f, -0.05084676f, -0.05105991f, 0.02639950f, 0.03510240f, -0.00488140f, 0.00122907f, 
    -0.05058476f, -0.03474324f, -0.02946345f, -0.01691849f, 0.05392125f, 0.01642332f, -0.04560250f, -0.03235820f, 
    0.00794533f, -0.00653892f, 0.04763018f, -0.04252436f, -0.02688749f, -0.02630211f, -0.03943897f, -0.04692481f, 
    0.01002577f, -0.01553757f, 0.03375715f, 0.04426872f, -0.02136437f, -0.02695542f, 0.03893373f, -0.05616259f, 
    -0.01702631f, 0.01538767f, 0.00949874f, -0.05560017f, 0.00591515f, -0.01676436f, 0.05082605f, 0.03336446f, 
    -0.01151092f, 0.01656086f, 0.04752868f, -0.04257627f, 0.01209266f, 0.05329372f, 0.00223538f, 0.01900557f, 
    -0.03167796f, 0.00708784f, -0.04808997f, -0.05458886f, -0.05834005f, -0.05612574f, -0.02488638f, -0.02239410f, 
    -0.02681941f, 0.02177733f, -0.05900825f, 0.02457795f, -0.00187094f, -0.01766112f, 0.02151423f, 0.01404563f, 
    -0.03220228f, -0.02324785f, -0.02081260f, 0.00858374f, -0.06258135f, -0.04209387f, 0.00543788f, -0.03276824f, 
    -0.00299133f, -0.01471073f, -0.00294342f, -0.05744917f, 0.01260835f, -0.01280377f, -0.03769333f, -0.00032645f, 
    0.03368373f, 0.02744303f, -0.02705150f, -0.03497001f, 0.04703462f, -0.00204249f, -0.04063865f, -0.00444402f, 
    -0.01944755f, -0.05047626f, -0.01389661f, 0.01676039f, -0.00368998f, 0.02247372f, 0.03627386f, -0.01384077f, 
    0.03342847f, 0.02118142f, -0.05099409f, -0.05547565f, -0.03442806f, 0.02336760f, -0.01910852f, -0.02294012f, 
    -0.00981718f, -0.02928923f, -0.01593149f, 0.02659338f, 0.00415844f, 0.02863594f, 0.01392812f, 0.02009189f, 
    -0.01965265f, 0.02476582f, -0.00493680f, 0.01780851f, -0.06336571f, -0.00747244f, 0.03120568f, 0.02605225f, 
    -0.01620639f, 0.02630649f, -0.03180107f, 0.00324898f, -0.03728386f, -0.03363235f, 0.02381715f, 0.04714691f, 
    0.02470926f, 0.00472201f, -0.05056437f, -0.03074209f, 0.01812933f, 0.00153249f, -0.03952618f, -0.04081203f, 
    -0.02580073f, 0.03995419f, -0.01710392f, -0.01113211f, 0.04541523f, 0.02475564f, 0.01425596f, -0.03645474f, 
    0.03463731f, 0.02513971f, -0.05335895f, 0.01076720f, -0.01587402f, -0.02044614f, -0.02462818f, 0.02206017f, 
    0.02262523f, -0.02224626f, -0.04513336f, -0.02190589f, 0.02242233f, -0.03732363f, -0.00668780f, -0.01288331f, 
    -0.04619043f, 0.02155845f, -0.03475782f, -0.01874925f, -0.00764596f, 0.01542034f, 0.02346981f, 0.03431383f, 
    0.00300390f, -0.03238740f, -0.03618504f, 0.01047052f, -0.03778359f, -0.00304899f, -0.01575713f, 0.00436381f, 
    0.01412701f, 0.03312516f, -0.02172739f, -0.05895573f, 0.02289510f, -0.01763455f, -0.04015414f, 0.04243505f, 
    -0.03943520f, -0.00300046f, -0.05107671f, -0.00636059f, -0.04876002f, 0.02348882f, 0.03319128f, -0.00507372f, 
    -0.02740433f, 0.00796950f, -0.02940673f, -0.02792745f, 0.03508520f, -0.02487372f, 0.01491236f, -0.01984304f, 
    -0.05898577f, 0.03174164f, -0.01719653f, -0.02039477f, 0.00365858f, 0.01971656f, 0.00341562f, -0.03379720f, 
    0.02059182f, -0.04084843f, -0.03649268f, 0.02168782f, -0.04628677f, 0.01820335f, 0.00047763f, -0.00164979f, 
    0.04454015f, -0.05295279f, -0.01857143f, 0.00820627f, -0.00465624f, 0.01150090f, -0.01033707f, -0.05419174f, 
    0.01368061f, -0.04103174f, 0.01277619f, 0.04482455f, 0.01458296f, 0.03136104f, -0.03794801f, 0.01330868f, 
    0.03940948f, 0.01119095f, -0.01484729f, 0.00951607f, 0.03174712f, 0.03850854f, -0.01042020f, 0.03487203f, 
    -0.05301098f, 0.01766339f, 0.02746408f, 0.00146994f, -0.00801313f, 0.00101537f, 0.04382279f, 0.04532712f, 
    -0.04013779f, -0.04050809f, -0.05485588f, 0.00811687f, 0.03523223f, -0.01903947f, -0.00254925f, -0.03607200f, 
    -0.00340763f, -0.02895498f, -0.00483795f, -0.01147041f, -0.05113082f, 0.03775761f, -0.02458593f, -0.03214164f, 
    -0.05176692f, -0.04000484f, 0.04467653f, -0.00867116f, -0.04705920f, 0.02892720f, 0.00682591f, -0.02718842f, 
    -0.01480445f, 0.04030780f, -0.02113660f, -0.04546765f, -0.00964899f, -0.04200062f, -0.02548102f, -0.05184631f, 
    -0.00496043f, 0.01776058f, 0.03281648f, 0.03018248f, -0.02037051f, -0.00307037f, -0.03747557f, 0.04137786f, 
    -0.02866234f, -0.04230674f, 0.02165262f, 0.01273990f, 0.00061088f, 0.01325555f, -0.02318090f, 0.05381140f, 
    -0.02398612f, 0.03154103f, 0.00989819f, -0.02000353f, -0.04707206f, 0.04292763f, 0.03356733f, 0.00936276f, 
    0.03552013f, -0.04685351f, -0.01761821f, -0.03396032f, 0.01141727f, -0.02512718f, -0.03124939f, 0.01154762f, 
    -0.04080399f, -0.04553226f, 0.03838094f, 0.01561626f, -0.02798720f, -0.01249352f, -0.05020158f, -0.03450716f, 
    -0.03254067f, 0.01925076f, -0.03829306f, -0.01072308f, 0.02031506f, 0.00625422f, -0.04003757f, -0.01664267f, 
    -0.02218682f, -0.03760303f, 0.01532298f, -0.00437025f, 0.03636863f, 0.01423562f, -0.02032267f, 0.03332916f, 
    0.01715849f, 0.00868435f, -0.00167729f, -0.01148612f, 0.02401412f, -0.02790507f, -0.00330953f, 0.03314913f, 
    -0.05108199f, -0.01487892f, -0.02433094f, -0.05121405f, 0.04331618f, -0.05174695f, -0.02675012f, -0.04363206f, 
    -0.00981116f, 0.00162097f, 0.01433932f, -0.01445228f, -0.02110174f, -0.01720054f, -0.02624411f, -0.04557159f, 
    -0.00099829f, -0.01335346f, -0.05551128f, 0.01979841f, 0.01537790f, -0.04345983f, -0.04376527f, -0.03445635f, 
    -0.02057915f, -0.05000361f, -0.00309987f, -0.04595859f, 0.03303030f, -0.05225939f, -0.00538884f, -0.04060539f, 
    0.00954096f, 0.03562279f, -0.02602196f, 0.00023403f, 0.00679688f, -0.03211270f, -0.04591673f, -0.04613200f, 
    -0.02723854f, -0.02363683f, -0.03229822f, 0.02800648f, 0.01135979f, -0.01645772f, -0.04580259f, 0.00692722f, 
    0.01415720f, -0.02178428f, 0.01755377f, -0.01610583f, 0.03246315f, -0.03987684f, -0.03940710f, 0.00894175f, 
    -0.01934971f, 0.00138425f, -0.00840864f, -0.00568541f, 0.03776733f, -0.03018727f, 0.01124784f, -0.04221327f, 
    -0.00731029f, 0.01060349f, 0.03634638f, 0.00747678f, -0.05343750f, -0.03019216f, -0.00959316f, 0.02905899f, 
    -0.00313880f, -0.02812903f, -0.02509671f, 0.03370133f, 0.00437730f, -0.03303925f, 0.00322211f, 0.03569680f, 
    0.02341886f, 0.03106727f, 0.00586790f, 0.04278046f, -0.00798362f, 0.03611489f, 0.03809169f, 0.00849349f, 
    0.00526843f, -0.02371253f, -0.02676008f, -0.01066593f, 0.00208889f, 0.03544212f, -0.05144964f, 0.03834605f, 
    -0.03408202f, -0.00350850f, -0.01458172f, 0.01516024f, 0.01529778f, -0.01976713f, 0.01310780f, -0.04484328f, 
    -0.01149711f, 0.01134004f, 0.02408461f, -0.02293254f, -0.03212471f, -0.04213090f, 0.03771130f, -0.05002557f, 
    0.02831880f, -0.03466722f, 0.01155890f, -0.04940175f, 0.01902237f, -0.04274328f, 0.04331652f, 0.01347728f, 
    -0.02727739f, -0.01232902f, -0.03810760f, -0.00811348f, -0.02771392f, -0.05303131f, 0.04357586f, -0.03971493f, 
    -0.05442644f, -0.03623506f, -0.05704829f, 0.03853647f, -0.03195131f, 0.02671764f, -0.05105038f, 0.03521620f, 
    0.04311239f, 0.00898252f, -0.01548092f, -0.03621987f, -0.00448593f, 0.01779460f, 0.00659698f, -0.01743074f, 
    -0.04310140f, 0.02818959f, -0.00411341f, -0.00219195f, -0.00048356f, -0.05777417f, 0.02116981f, -0.02591276f, 
    -0.00083244f, -0.00244185f, -0.04496870f, -0.03422645f, 0.01722972f, -0.02891914f, -0.01195820f, -0.00467017f, 
    0.00400115f, -0.03820042f, -0.01555614f, 0.02008627f, -0.03660123f, 0.01967583f, -0.05212686f, 0.00918523f, 
    -0.01519269f, -0.01220766f, 0.00982933f, -0.01500961f, -0.02659976f, 0.01796334f, 0.03303724f, -0.03870894f, 
    -0.01777219f, -0.00419268f, -0.02833356f, 0.03932204f, -0.02225594f, 0.00851692f, 0.03780813f, 0.02318975f, 
    0.03256045f, -0.00897499f, -0.03421019f, -0.00333254f, -0.04651350f, -0.00180100f, 0.03978001f, -0.02928583f, 
    0.01325285f, -0.00890432f, 0.01152642f, -0.05372186f, -0.05219149f, 0.02197461f, 0.03923283f, -0.01949934f, 
    -0.01835618f, 0.00485083f, -0.00745633f, 0.04146260f, -0.05476290f, -0.03082190f, 0.02342681f, -0.00385819f, 
    -0.00284725f, 0.03429892f, -0.03764141f, 0.02964534f, 0.00088591f, -0.05676454f, -0.01901738f, -0.00107460f, 
    0.03171197f, -0.00042293f, 0.00160375f, -0.03679024f, -0.01273919f, -0.02908251f, -0.00557285f, -0.05255399f, 
    0.00719468f, 0.03713207f, -0.03225327f, -0.02220296f, 0.00068408f, 0.01694776f, -0.01883217f, 0.03371407f, 
    -0.05737537f, 0.04284381f, -0.02073923f, -0.02515435f, 0.03877972f, -0.00593795f, -0.04482672f, 0.01203020f, 
    0.02412925f, -0.04203587f, 0.01232939f, -0.01032032f, -0.05179477f, 0.02429684f, -0.02923419f, 0.00062560f, 
    0.00193408f, -0.03951113f, 0.00553079f, -0.02716240f, -0.04604309f, -0.03438722f, -0.04456423f, -0.04723323f, 
    0.01620013f, -0.03767425f, -0.01706122f, 0.00110533f, 0.04403766f, -0.03795019f, 0.00478832f, 0.03847376f, 
    -0.02243689f, -0.03307237f, -0.02397566f, 0.04059817f, 0.04412211f, -0.05384851f, -0.05659254f, -0.02961240f, 
    -0.03715120f, -0.00852918f, 0.02774116f, -0.00536148f, 0.02840011f, -0.01082037f, -0.04193054f, -0.03564310f, 
    -0.04731521f, -0.00256010f, -0.02813036f, -0.04283373f, 0.00714781f, 0.00654736f, 0.01525000f, -0.04828449f, 
    -0.01787057f, -0.01350543f, -0.04312511f, -0.03008982f, 0.00693849f, 0.02575856f, 0.03187333f, -0.03968811f, 
    0.03228578f, -0.02228530f, -0.02139837f, -0.05383726f, -0.02431985f, 0.04487694f, 0.01365042f, -0.00656033f, 
    -0.04664023f, 0.00849231f, -0.00590170f, -0.04549223f, -0.03315086f, -0.00213227f, 0.01330739f, 0.03710425f, 
    0.01508655f, 0.00932248f, -0.01016892f, 0.03677311f, -0.01917501f, -0.05464413f, -0.03861641f, -0.00869054f, 
    -0.00468455f, -0.03816808f, -0.01498341f, 0.02741487f, -0.04783602f, -0.02507212f, -0.02262092f, 0.04085733f, 
    -0.01875447f, -0.04709321f, 0.03070782f, -0.02245643f, 0.04130341f, -0.01734418f, 0.03330985f, -0.00449520f, 
    -0.02878156f, 0.03612212f, -0.00961988f, -0.02000281f, -0.02151723f, 0.02164730f, -0.03725205f, 0.02263824f, 
    0.00082985f, 0.01051287f, -0.02694052f, -0.02627300f, 0.03323105f, -0.01635949f, 0.01389057f, -0.00476954f, 
    -0.02606759f, -0.00705526f, -0.03597827f, 0.03724639f, -0.03437003f, -0.02106099f, 0.00718281f, -0.04256126f, 
    0.00488474f, -0.02294907f, 0.00715473f, -0.00344514f, -0.03164019f, 0.00100415f, 0.02909463f, -0.00324448f, 
    0.00463274f, -0.04627923f, 0.02151890f, 0.04094628f, -0.03541527f, -0.02274808f, 0.02812375f, -0.02868594f, 
    -0.04074118f, -0.02371950f, 0.01069806f, -0.00987206f, 0.00241718f, -0.00179199f, -0.02654649f, -0.02753094f, 
    -0.03683749f, 0.03730725f, 0.02707449f, -0.04480758f, 0.01360311f, -0.03122260f, -0.01253508f, -0.03132677f, 
    0.00895985f, 0.04434384f, -0.04954318f, -0.01573987f, 0.01471048f, -0.04607325f, -0.02453990f, -0.03174879f, 
    -0.01017902f, 0.01206432f, 0.04582568f, -0.02514485f, -0.01200328f, 0.02131878f, -0.04725512f, -0.02993533f, 
    -0.01574280f, -0.04103737f, -0.01825256f, 0.02341731f, -0.00664784f, -0.02774412f, 0.02092198f, -0.02562689f, 
    0.00296963f, -0.00775333f, -0.01456144f, -0.00943848f, 0.03489487f, -0.03615716f, 0.00936316f, 0.04179003f, 
    -0.01753619f, -0.03104301f, 0.01236841f, -0.04448377f, 0.05013330f, 0.03339517f, 0.02069274f, -0.00582164f, 
    0.02747441f, 0.03022830f, 0.00019971f, 0.04073910f, -0.00401731f, -0.03927117f, -0.04746011f, 0.00961274f, 
    0.04990103f, 0.04118497f, -0.01637510f, -0.03778159f, 0.04198630f, -0.01272706f, -0.03309041f, -0.00568765f, 
    -0.00378460f, -0.01315617f, -0.03283396f, -0.04472275f, -0.00318120f, -0.04350381f, 0.02580339f, 0.03739106f, 
    0.00344869f, -0.04448811f, -0.00482504f, -0.00025588f, 0.01552474f, -0.02426917f, 0.04979378f, -0.04819990f, 
    -0.02406550f, 0.01477318f, 0.00031124f, 0.03209083f, 0.03371187f, -0.02541078f, -0.00195113f, -0.01552655f, 
    0.05071463f, -0.04807828f, -0.02319481f, 0.04353785f, 0.01795293f, -0.00512583f, -0.04025937f, 0.00781914f, 
    0.03941109f, -0.02242835f, -0.04651631f, 0.00215893f, 0.00562154f, -0.03288420f, -0.03047369f, 0.03113689f, 
    -0.02189731f, 0.00370823f, 0.00879450f, 0.04406035f, -0.04707621f, 0.01752942f, -0.00640511f, -0.03132761f, 
    -0.03573852f, 0.00612108f, -0.04662191f, 0.00232370f, 0.00130173f, -0.02885029f, 0.00141367f, 0.00706036f, 
    -0.02849245f, 0.01449635f, -0.04066889f, 0.03329555f, -0.04427928f, -0.04845857f, -0.04223614f, -0.03845464f, 
    -0.04491851f, -0.00167217f, 0.01111365f, 0.02124879f, -0.01232845f, 0.02200594f, -0.02114729f, 0.02230892f, 
    -0.03461083f, 0.04109379f, 0.04733424f, -0.02813370f, 0.02117975f, 0.01628765f, -0.02465345f, 0.04866967f, 
    -0.02028915f, 0.01061049f, -0.00207476f, -0.03819773f, 0.03536300f, 0.03084267f, -0.00388170f, 0.00617981f, 
    0.05064589f, -0.03638008f, -0.02285600f, -0.02566777f, -0.03558114f, -0.04988690f, 0.04703745f, 0.02094271f, 
    -0.04033581f, 0.02524820f, 0.02170703f, 0.02801449f, 0.00893861f, 0.02236243f, -0.01774069f, 0.02079564f, 
    0.03369753f, 0.04089415f, 0.01878607f, -0.04487604f, -0.04364438f, 0.02614934f, 0.01744273f, 0.03959240f, 
    -0.01335051f, 0.02529837f, -0.02500228f, 0.04172067f, -0.02162386f, -0.00406670f, 0.02436156f, -0.04570964f, 
    0.00661307f, -0.03998143f, 0.03403244f, -0.04029122f, -0.04220127f, -0.00610644f, -0.04205633f, -0.01196698f, 
    -0.02116139f, -0.03298682f, 0.02452635f, -0.03059088f, -0.01324504f, 0.04789272f, 0.01244832f, -0.00326545f, 
    -0.00647230f, -0.04149445f, -0.03920915f, 0.04594572f, 0.04764369f, 0.01219535f, -0.02671205f, -0.01048997f, 
    0.04564159f, 0.01367160f, 0.02438897f, 0.00654720f, 0.03595721f, -0.02308690f, -0.01362726f, -0.02873900f, 
    -0.02475096f, 0.04934078f, -0.02183502f, 0.02072857f, -0.04395151f, 0.03984736f, -0.01726493f, -0.03291932f, 
    -0.02222471f, -0.01411015f, 0.00333579f, 0.05036359f, 0.00483381f, 0.00747973f, 0.02569008f, 0.02855825f, 
    -0.00505818f, -0.03805019f, -0.03942007f, -0.00851561f, -0.02862589f, 0.03437468f, 0.01141403f, -0.04245546f, 
    -0.01138028f, -0.02114403f, -0.02493823f, 0.02762684f, -0.01661844f, 0.01236097f, 0.02251305f, -0.01275089f, 
    -0.01840817f, 0.00453211f, -0.03118956f, 0.01835354f, 0.04727883f, -0.02902083f, 0.01363169f, 0.00168755f, 
    0.01720070f, 0.02482992f, -0.00450569f, 0.02398455f, 0.01223524f, 0.01062430f, -0.04932234f, 0.03068438f, 
    0.01987609f, -0.03701341f, -0.04946156f, -0.00768053f, 0.02997177f, -0.03882410f, -0.01023252f, 0.02557428f, 
    0.04974175f, 0.00032561f, -0.03803182f, -0.01786984f, 0.01900565f, 0.03668352f, -0.04091353f, -0.03081122f, 
    -0.01773880f, -0.01207618f, -0.03383068f, 0.04781654f, -0.03867024f, -0.04371477f, -0.01190258f, 0.00726935f, 
    -0.04269362f, 0.03268776f, -0.04048399f, 0.00462327f, 0.02262961f, -0.00104247f, -0.05009436f, -0.01854115f, 
    -0.01555734f, -0.01183564f, -0.03983567f, -0.03103706f, -0.01069006f, 0.03681442f, -0.03365910f, 0.01397283f, 
    -0.03358481f, 0.03251562f, 0.01861340f, 0.00335436f, -0.02360145f, 0.00766419f, -0.02267228f, -0.00043996f, 
    -0.02786103f, -0.00841303f, -0.00868278f, 0.04968617f, -0.00847742f, 0.00607587f, 0.01307156f, 0.02030509f, 
    0.03135228f, 0.03988092f, -0.04721647f, -0.02650993f, -0.01892822f, 0.00861053f, -0.01758412f, -0.02544494f, 
    -0.01165321f, 0.02043087f, 0.03207543f, -0.01798965f, 0.01220445f, -0.01440876f, -0.05046247f, -0.03628085f, 
    -0.02912584f, 0.04629013f, -0.03873188f, -0.00236540f, 0.02206712f, -0.02724431f, 0.01509225f, -0.00097280f, 
    0.02285952f, -0.00446042f, 0.02924431f, -0.00741701f, 0.03417234f, -0.00514574f, 0.00678518f, -0.00371929f, 
    0.05018074f, -0.01062571f, -0.03157284f, 0.04231927f, -0.04853597f, 0.04757648f, 0.01825976f, -0.02652499f, 
    -0.02367498f, -0.01221498f, -0.02255730f, 0.02721662f, 0.02318880f, -0.04311634f, 0.00251467f, -0.03768777f, 
    -0.02588788f, -0.03669462f, -0.04274541f, 0.04105255f, -0.03198809f, -0.03298631f, 0.04312880f, 0.01827967f, 
    0.02042046f, -0.03423756f, -0.00886785f, 0.00152458f, 0.01105308f, -0.02333255f, 0.00023367f, 0.04809196f, 
    -0.00143991f, -0.01317802f, 0.02252786f, 0.01617573f, 0.01603630f, 0.01178394f, -0.03299234f, 0.01948741f, 
    0.01222016f, -0.02019592f, 0.02441206f, 0.03773887f, -0.00972830f, -0.03252807f, -0.04845317f, -0.04920866f, 
    -0.05625889f, -0.03055397f, -0.05697843f, -0.02919278f, 0.02706905f, 0.01521045f, 0.02547537f, -0.03728331f, 
    -0.03426699f, -0.04819217f, -0.02172934f, -0.02579282f, -0.02267868f, 0.02355542f, 0.02186901f, 0.01155096f, 
    -0.00658475f, 0.02567833f, 0.00133727f, 0.00458909f, -0.02127317f, 0.02862026f, 0.04258769f, -0.02115127f, 
    0.01940077f, -0.03483054f, -0.05585082f, 0.03532199f, 0.03797793f, 0.02595509f, 0.00121112f, -0.05275681f, 
    0.02147312f, -0.02474370f, 0.03272932f, 0.00671181f, -0.04161238f, 0.04151767f, -0.00613057f, 0.01075250f, 
    -0.00908328f, -0.05218432f, 0.03408351f, -0.05604360f, -0.05355809f, -0.01685347f, -0.04658049f, -0.00950848f, 
    -0.01696747f, -0.04575582f, 0.02710469f, -0.01717278f, 0.03226917f, 0.01298380f, -0.03390770f, 0.00495223f, 
    -0.01442587f, -0.01256100f, -0.02583378f, 0.03312873f, -0.03863056f, -0.02179272f, -0.02426893f, 0.03997612f, 
    -0.02868089f, 0.02009326f, 0.02936690f, 0.02653228f, 0.02112833f, -0.03606575f, 0.00819988f, -0.04472532f, 
    0.00193628f, -0.01600105f, -0.00328156f, -0.01927457f, 0.03974851f, -0.02415512f, -0.00001265f, -0.04915476f, 
    0.02503643f, -0.01935447f, 0.00827148f, 0.03447009f, -0.01708767f, 0.00399720f, 0.02005342f, 0.00234335f, 
    0.02130941f, -0.00577780f, 0.01013703f, -0.02938519f, -0.02542971f, 0.01171555f, -0.00501461f, 0.01146897f, 
    -0.04203096f, -0.02675598f, 0.03261786f, -0.05579360f, -0.02199074f, 0.03184609f, -0.04352157f, -0.03841172f, 
    0.01579445f, 0.00667264f, -0.05266399f, -0.05441830f, -0.05086925f, -0.02300017f, -0.02058109f, -0.02728271f, 
    -0.03281199f, -0.05379702f, 0.00956696f, -0.04107701f, -0.04773741f, -0.01620685f, -0.04091898f, 0.01940848f, 
    0.01316698f, 0.00677912f, -0.03661754f, 0.02261964f, -0.01679180f, 0.02049365f, -0.04004019f, -0.04494631f, 
    0.04427802f, -0.03700929f, -0.05563091f, -0.00671956f, 0.03521667f, 0.03571359f, -0.02372453f, -0.01600974f, 
    0.02112747f, 0.02646819f, -0.04605218f, -0.00238251f, -0.03499560f, -0.00709399f, -0.00713800f, 0.04073649f, 
    -0.00976816f, 0.03604707f, 0.03714693f, 0.00980934f, -0.03655501f, 0.00400893f, -0.00531321f, -0.02327230f, 
    -0.01268252f, 0.00232850f, 0.01778376f, 0.02906828f, -0.03770453f, -0.03662535f, 0.02367552f, -0.04531262f, 
    0.03390489f, -0.02818125f, -0.04047566f, 0.03665236f, -0.02565546f, 0.01911204f, 0.03490962f, -0.00465780f, 
    -0.03096265f, -0.04656422f, -0.01686438f, -0.00606603f, 0.01486686f, -0.05434462f, -0.05067717f, -0.05690674f, 
    -0.00853698f, -0.03873387f, 0.03614006f, -0.05436932f, -0.00163399f, -0.03976766f, -0.04700855f, -0.04545312f, 
    -0.00945023f, -0.02089991f, -0.04051492f, 0.00845663f, -0.03263983f, -0.02247644f, 0.02749880f, -0.00649242f, 
    -0.05015777f, 0.03735109f, 0.02756026f, -0.03988970f, -0.03319335f, -0.04211978f, -0.01659571f, -0.04833147f, 
    0.02517734f, -0.00950505f, -0.02914705f, -0.04039868f, 0.02872763f, 0.00751709f, -0.00153329f, -0.02186841f, 
    -0.04858652f, -0.03901951f, 0.03526964f, -0.01214044f, -0.04467443f, 0.01912039f, -0.04620910f, -0.03079188f, 
    0.02131446f, -0.01484179f, -0.03121488f, -0.01545672f, -0.01936426f, 0.01485675f, 0.01292142f, -0.05186133f, 
    0.02155865f, -0.00769843f, 0.02454052f, 0.03994989f, -0.03077802f, -0.03961046f, 0.03808410f, 0.03248531f, 
    0.01631535f, 0.01415798f, -0.01528522f, -0.01515623f, -0.03436724f, 0.01605702f, -0.00704667f, -0.03009506f, 
    -0.00061264f, 0.03933633f, -0.01549285f, -0.02364215f, -0.02546855f, -0.04264282f, 0.01438762f, -0.04082609f, 
    0.01037408f, -0.01072530f, -0.02459705f, 0.01705585f, 0.04201717f, -0.03677197f, -0.03977843f, -0.02404848f, 
    0.01144685f, -0.05009629f, 0.04393389f, 0.01305696f, -0.01056449f, 0.03794074f, -0.04369584f, 0.01333626f, 
    0.03170743f, -0.04571190f, 0.01449311f, 0.03843939f, 0.03076027f, 0.02985315f, 0.01811268f, -0.02228142f, 
    -0.00384936f, 0.02884217f, -0.04910171f, -0.03106363f, 0.03819007f, -0.01476490f, -0.03809603f, -0.05489898f, 
    -0.00464437f, 0.00082708f, -0.01873801f, 0.00237352f, 0.01266643f, -0.04995947f, 0.01388428f, -0.01349415f, 
    0.01150871f, -0.04143115f, 0.00347922f, -0.02755645f, 0.02866182f, -0.04683906f, -0.00290850f, -0.01705490f, 
    0.03968802f, -0.03768015f, 0.00677566f, -0.03275181f, -0.01016524f, 0.00680111f, -0.02017059f, 0.01646491f, 
    -0.03292516f, -0.03279018f, -0.04236049f, -0.00321270f, -0.02300280f, -0.00617224f, -0.00464002f, -0.00980356f, 
    0.01987784f, 0.03276361f, -0.01010629f, 0.01854954f, -0.02417758f, 0.03111587f, 0.01459134f, -0.03442526f, 
    -0.00410209f, 0.01014722f, -0.05020465f, 0.02712945f, -0.02762188f, 0.02131837f, 0.03521802f, -0.02238175f, 
    -0.02204751f, 0.03811038f, -0.05350580f, -0.01307548f, -0.02802410f, -0.01376127f, -0.00961546f, -0.03848261f, 
    -0.05699800f, 0.03313569f, -0.00117778f, 0.00694168f, -0.02038286f, 0.01566391f, -0.02499193f, -0.01519696f, 
    -0.01416439f, 0.02156722f, 0.03482490f, 0.04095700f, -0.03940548f, -0.01482851f, -0.01502509f, -0.03435635f, 
    -0.04364982f, 0.03719244f, 0.02676302f, 0.00460471f, -0.05447084f, -0.00841251f, 0.01692361f, -0.01337424f, 
    0.02075630f, 0.04216564f, -0.04635884f, 0.01114987f, 0.02031119f, -0.00582138f, -0.05266402f, -0.04909610f, 
    -0.03518679f, 0.03988571f, 0.00478393f, 0.00068010f, -0.03916527f, 0.03407446f, -0.05762819f, 0.00099921f, 
    -0.03743776f, -0.00842800f, -0.00166680f, -0.00708768f, -0.04449288f, 0.02345397f, -0.02763135f, -0.03122908f, 
    -0.00559697f, 0.04190833f, 0.00094154f, -0.01894579f, -0.00499362f, -0.04230583f, -0.01318056f, -0.01381444f, 
    -0.02375093f, 0.02834066f, -0.05569901f, 0.04743791f, 0.04306066f, 0.00478774f, 0.01476260f, 0.00277662f, 
    -0.05955692f, 0.02351112f, 0.03887776f, -0.05842095f, -0.03743069f, 0.00314136f, -0.01579843f, 0.03050409f, 
    0.00618580f, 0.03685969f, 0.00292377f, -0.00190442f, -0.02286103f, -0.00574505f, 0.02293252f, -0.00483399f, 
    0.01330831f, 0.02380069f, 0.00612522f, 0.03672779f, 0.01234005f, -0.03316926f, -0.01002308f, -0.03618924f, 
    0.02317826f, 0.00510587f, -0.03698655f, -0.02689207f, 0.02758360f, -0.02865568f, -0.03540720f, -0.00737212f, 
    0.02991330f, -0.02766503f, -0.04533224f, 0.03370446f, -0.01512760f, 0.01308864f, 0.00294784f, -0.05531500f, 
    0.00260141f, -0.01865242f, 0.01740734f, -0.04581202f, -0.01287291f, -0.02475638f, -0.03836051f, 0.01706463f, 
    -0.04577598f, 0.03944137f, 0.02357270f, 0.00527159f, -0.00085706f, 0.03716889f, 0.01212507f, -0.03702278f, 
    0.01250701f, -0.04738206f, -0.01420708f, -0.01637949f, -0.04260062f, -0.03643924f, 0.00371088f, 0.03127004f, 
    -0.00645002f, -0.02929588f, -0.03707925f, -0.04782644f, -0.00257187f, -0.04836922f, 0.03665263f, -0.05766167f, 
    0.03106681f, 0.02315008f, -0.03762187f, 0.01645434f, -0.03098910f, 0.03680767f, -0.03495023f, -0.04602579f, 
    0.02309438f, -0.02948276f, -0.03429582f, 0.03815455f, -0.03952124f, -0.02032197f, 0.02891202f, -0.04391855f, 
    0.03631636f, 0.02208801f, -0.02488798f, 0.00856449f, -0.03925348f, -0.05688133f, 0.00408391f, 0.02177577f, 
    -0.05137587f, -0.04211890f, 0.00576465f, 0.02201716f, 0.00780439f, -0.03510784f, -0.01169060f, 0.03182483f, 
    0.01029764f, -0.00575594f, -0.00779703f, 0.01097867f, -0.01158278f, -0.00450799f, -0.03623405f, -0.05553318f, 
    -0.05730890f, -0.03995239f, -0.02336273f, -0.02968294f, 0.03039684f, 0.01799276f, -0.01508849f, 0.03686945f, 
    0.01532045f, 0.00300764f, -0.03514993f, -0.05055196f, 0.01591393f, 0.02617558f, 0.02789297f, 0.04996283f, 
    -0.00514884f, 0.04413824f, -0.01756803f, 0.03145628f, 0.01242351f, -0.01309753f, 0.02364696f, -0.04775632f, 
    0.00290376f, -0.02464662f, 0.00234945f, 0.04537721f, 0.01109232f, -0.00037281f, -0.01664845f, 0.02604921f, 
    -0.03657457f, -0.03021375f, 0.02176429f, -0.00366424f, -0.02339591f, -0.01949034f, -0.03087434f, -0.02267864f, 
    0.00422439f, 0.01737128f, 0.03272586f, -0.00795425f, 0.00073680f, 0.03486132f, 0.03833039f, 0.03820160f, 
    -0.00746711f, -0.03680925f, 0.03365522f, 0.04507690f, 0.03413742f, 0.01083956f, 0.01585236f, 0.03291963f, 
    -0.04050790f, 0.01857067f, -0.03709034f, 0.01898898f, -0.00925749f, 0.00851275f, -0.04813374f, -0.00711355f, 
    -0.01293538f, -0.03407682f, 0.03317583f, -0.04355057f, -0.01250705f, 0.02495812f, -0.02178823f, -0.03175301f, 
    0.01969043f, -0.04346693f, -0.02502138f, 0.03694908f, -0.03524506f, 0.04067738f, 0.02242392f, -0.01018498f, 
    -0.04024012f, -0.04426843f, 0.01716129f, 0.01425119f, -0.04520135f, 0.02552589f, -0.05181820f, -0.01258118f, 
    0.03321178f, 0.03006541f, 0.01409676f, -0.00102377f, -0.03669434f, 0.01654789f, 0.00176687f, -0.00167702f, 
    0.01251685f, 0.03539221f, 0.00499965f, 0.04295096f, 0.02311473f, -0.00863807f, 0.02545127f, 0.00386706f, 
    0.03095148f, -0.02225461f, -0.01719540f, -0.05010631f, -0.03217763f, 0.01138412f, -0.03566907f, 0.01848648f, 
    0.00378170f, -0.03091235f, 0.01146104f, -0.00120543f, -0.03944884f, 0.02310781f, -0.00924186f, -0.02491736f, 
    0.03564236f, -0.04803152f, 0.01038064f, -0.01457688f, 0.01078922f, -0.05795851f, -0.04232086f, -0.00166947f, 
    -0.05916486f, 0.00841372f, -0.05626823f, -0.00220826f, -0.03997288f, 0.03535763f, 0.03630821f, -0.00131186f, 
    -0.03821271f, 0.01460759f, -0.00983130f, 0.02856456f, -0.05414870f, 0.01888507f, -0.03459599f, -0.00747608f, 
    -0.02901591f, -0.01978954f, -0.04210367f, 0.00984766f, 0.01718117f, -0.03111629f, -0.04829335f, -0.00437493f, 
    0.00392391f, -0.03036307f, 0.01302775f, -0.00111146f, 0.01819613f, -0.00960616f, -0.02720745f, 0.00169723f, 
    -0.04647471f, -0.01044574f, -0.05588062f, 0.03181729f, -0.05722641f, -0.02911433f, -0.01777202f, 0.03773307f, 
    -0.00162468f, 0.03354272f, -0.00076743f, 0.02587777f, -0.04644554f, 0.00491252f, -0.01577429f, -0.05425319f, 
    0.02589801f, 0.03383588f, 0.01768325f, 0.01724410f, -0.05245206f, 0.02053851f, -0.01666870f, -0.04313072f, 
    0.04318016f, 0.01278478f, 0.03391784f, -0.01701345f, 0.01645761f, 0.00683289f, 0.03072446f, -0.02643845f, 
    0.00291527f, 0.01619016f, -0.06692980f, -0.01850592f, 0.03995463f, 0.01826479f, 0.02118334f, -0.02028102f, 
    -0.01477486f, -0.05246194f, 0.00507026f, 0.02700084f, 0.00140797f, -0.02392872f, -0.01185456f, -0.00715364f, 
    -0.02506703f, 0.01650276f, -0.05343408f, 0.02093444f, -0.01019474f, 0.02185439f, 0.03753263f, 0.02502008f, 
    -0.04113636f, 0.01901457f, -0.01998895f, 0.00360717f, 0.01353080f, -0.00422840f, -0.06051341f, -0.05425309f, 
    -0.03811341f, -0.00749666f, -0.05177229f, -0.03181894f, -0.03421910f, 0.00631378f, -0.00243146f, -0.01194367f, 
    0.04119614f, 0.03582212f, -0.05141715f, -0.02227403f, 0.03598442f, 0.00896474f, -0.03170132f, 0.00563593f, 
    -0.00057283f, 0.01983160f, 0.04919440f, -0.00254691f, -0.03420350f, -0.02332354f, 0.01666757f, -0.02655709f, 
    0.02809494f, 0.00310199f, 0.01185571f, -0.03117512f, -0.00041964f, 0.00172038f, -0.03519069f, -0.02702422f, 
    0.00046692f, 0.02296062f, -0.01826664f, 0.03123697f, -0.00985910f, 0.02030919f, 0.00302945f, 0.02524288f, 
    -0.05230586f, 0.01020007f, 0.01829390f, 0.01478346f, 0.01636059f, 0.00011028f, -0.01018991f, 0.01498248f, 
    0.04999524f, -0.01924695f, -0.03063224f, -0.00599036f, 0.00758266f, -0.03968803f, -0.01664974f, -0.03395009f, 
    -0.01349896f, -0.00759621f, -0.03138942f, 0.03291778f, 0.03369494f, 0.01558848f, -0.00225532f, 0.04089972f, 
    0.04548956f, 0.03882359f, 0.03736544f, -0.04216935f, 0.03714278f, -0.04357205f, 0.01144112f, 0.00613481f, 
    -0.04701741f, -0.03696656f, 0.02897050f, -0.01072976f, 0.01374736f, 0.05256736f, -0.05272960f, -0.04799138f, 
    0.00292332f, -0.03518502f, -0.04713504f, -0.05527133f, -0.05468616f, 0.03407867f, 0.04881766f, 0.04689782f, 
    -0.01820858f, 0.04388977f, 0.04298696f, -0.01137724f, 0.04827095f, -0.01422211f, 0.05314502f, -0.02375590f, 
    -0.01620779f, 0.00541975f, -0.05543865f, -0.01098571f, 0.02266363f, -0.03880044f, 0.03995519f, 0.00644159f, 
    -0.02092304f, -0.02552203f, 0.03303411f, 0.00157000f, -0.03843197f, 0.02005151f, -0.03687818f, -0.01952404f, 
    0.04145903f, -0.00680762f, 0.00223200f, 0.04804423f, 0.03328522f, -0.01212661f, 0.03664954f, -0.03454776f, 
    -0.02524170f, 0.04455500f, -0.02403919f, 0.03155512f, -0.02604025f, 0.01008783f, -0.01380673f, -0.04522671f, 
    -0.01523827f, -0.00537076f, 0.04311913f, 0.00868508f, 0.02421953f, -0.03366003f, 0.03083152f, 0.04940575f, 
    -0.03850421f, 0.05244754f, -0.05250128f, 0.00136180f, 0.02505841f, -0.03678758f, -0.02337683f, -0.00017573f, 
    -0.03999874f, 0.01043084f, 0.01073703f, -0.00238684f, -0.00935098f, -0.00623980f, -0.03902388f, -0.04489554f, 
    -0.04644604f, -0.04530475f, -0.04292093f, 0.03480643f, -0.04413242f, -0.03159003f, 0.01042417f, -0.03192040f, 
    -0.01243556f, -0.04184864f, 0.02349526f, 0.02014302f, 0.00671585f, 0.00916982f, 0.04349935f, -0.03829580f, 
    0.01156304f, -0.02690206f, 0.04164408f, -0.01920175f, -0.01686750f, 0.01558885f, -0.04805489f, 0.00304953f, 
    -0.00277420f, 0.01307312f, 0.03753994f, -0.02142484f, -0.02835527f, -0.03848443f, 0.01151882f, -0.05182182f, 
    0.01616273f, -0.00193053f, 0.02636662f, -0.02593945f, -0.04933728f, 0.03052347f, -0.04078080f, 0.00292922f, 
    0.04503334f, 0.03082100f, -0.03534215f, -0.01795017f, 0.00246196f, -0.03320069f, -0.01792733f, -0.05558919f, 
    -0.03804045f, -0.04054841f, 0.01332746f, 0.04353873f, -0.05178374f, -0.02923338f, -0.03822032f, -0.03538001f, 
    -0.00503407f, 0.02918609f, 0.03308911f, 0.03059367f, 0.01915909f, -0.02150893f, 0.01622503f, 0.04044913f, 
    0.02919670f, -0.02730183f, -0.01042789f, -0.04968136f, -0.00615184f, -0.04569945f, 0.02410710f, 0.00270510f, 
    -0.00345289f, 0.04358164f, -0.00306688f, 0.03563935f, -0.00305383f, 0.02497270f, -0.03674342f, -0.03956662f, 
    -0.03636233f, 0.02709489f, 0.03031362f, -0.03405942f, -0.02435377f, 0.03540239f, -0.04379673f, 0.04436431f, 
    0.02249091f, 0.02247239f, -0.05160540f, -0.00077560f, -0.04693853f, -0.04537160f, 0.03561771f, -0.00788950f, 
    -0.05129209f, -0.03852868f, 0.01453878f, -0.05019680f, 0.00492289f, 0.00761894f, -0.04646597f, -0.00081563f, 
    0.02435631f, -0.01269633f, -0.04191904f, -0.04006183f, -0.00709857f, 0.04473496f, -0.03702785f, 0.01926658f, 
    0.01985946f, 0.03042513f, -0.05563919f, -0.00391662f, -0.03166047f, -0.04058715f, 0.01225822f, 0.02734226f, 
    0.04265318f, -0.03487471f, 0.03016702f, -0.05030564f, -0.01250693f, 0.01117910f, 0.01755141f, -0.01832947f, 
    -0.03448848f, 0.04112980f, 0.00641297f, -0.03134285f, 0.02229301f, -0.05251191f, -0.02054641f, -0.03691243f, 
    -0.04587113f, -0.01471855f, -0.03854436f, -0.02622932f, 0.00644461f, -0.00993231f, -0.04807474f, 0.00513540f, 
    0.03276885f, 0.04467409f, 0.03785023f, 0.00606342f, -0.05073267f, 0.03471402f, -0.04768675f, -0.02861077f, 
    0.00733322f, -0.02112796f, 0.04466534f, -0.04315906f, -0.05240174f, 0.01800317f, 0.02760864f, 0.01572569f, 
    -0.04948181f, 0.00457912f, 0.02362617f, -0.02484597f, 0.01718094f, -0.01364494f, -0.04553151f, 0.01042484f, 
    0.04394496f, 0.01236036f, 0.02944297f, 0.03849193f, 0.01123979f, 0.00446322f, -0.05488384f, 0.00007513f, 
    -0.05713920f, -0.03946309f, 0.00752458f, -0.04018430f, -0.02928888f, -0.00479815f, 0.01080460f, -0.00671552f, 
    -0.02248515f, -0.03123151f, -0.02908903f, 0.00828924f, -0.02423357f, -0.02824783f, -0.05186360f, -0.04244597f, 
    0.01778319f, -0.03444422f, 0.02557622f, -0.01333392f, -0.03015039f, 0.03100089f, -0.03436729f, -0.03455772f, 
    -0.03932024f, 0.03866304f, 0.04164474f, 0.01889891f, -0.02759142f, -0.01473445f, -0.01291900f, -0.04715853f, 
    0.00537686f, 0.01463783f, 0.04311601f, 0.02830076f, 0.00699889f, -0.04458042f, 0.00065028f, -0.00810848f, 
    -0.00672818f, -0.04862497f, 0.03691593f, 0.04066087f, 0.03023868f, -0.03313893f, 0.04164375f, -0.03063511f, 
    -0.01019081f, 0.02686276f, 0.01620959f, 0.00436761f, -0.01468932f, -0.03209992f, 0.04793878f, 0.00639564f, 
    0.01317672f, 0.02694958f, -0.04091679f, -0.04939371f, 0.03440784f, 0.04468678f, -0.04324355f, -0.03750511f, 
    0.03005854f, 0.00662421f, -0.02496309f, -0.01335439f, 0.03836311f, 0.04359678f, 0.00946615f, 0.04285248f, 
    -0.35943076f, 0.21490698f, -0.02610856f, 0.11351974f, 0.23407647f, 0.00523986f, 0.03729645f, 0.07914430f, 
    -0.11004715f, 0.13361916f, -0.11538205f, 0.20083506f, -0.02429292f, -0.21634479f, -0.14823835f, 0.04264948f, 
    0.08276076f, -0.11446579f, 0.18563780f, -0.09658720f, 0.02332963f, 0.11178447f, 0.07337312f, 0.05928850f, 
    0.04048869f, -0.08550276f, -0.02748580f, 0.00124483f, -0.00259965f, 0.13725033f, -0.20465256f, 0.23460454f, 
    0.05188403f, -0.23575319f, 0.22636515f, -0.31088823f, -0.27328449f, -0.01870335f, 0.05045629f, -0.15569936f, 
    -0.00042499f, -0.12617077f, -0.15354812f, 0.07773057f, 0.16241786f, 0.06757522f, 0.00575058f, 0.08776344f, 
    -0.52416068f, -0.16562071f, 0.23462982f, 0.06247658f, -0.00060149f, 0.22555459f, 0.07965076f, -0.04327894f, 
    0.10927626f, 0.05426399f, 0.02830909f, -0.02025391f, -0.13627847f, -0.15540884f, 0.36904058f, 0.00351741f, 
    -0.11124282f, 0.04498610f, -0.07048767f, -0.09821624f, 0.00788933f, -0.00486989f, -0.05313036f, -0.07988220f, 
    -0.08066934f, -0.35477543f, 0.09271180f, -0.02237159f, -0.08274846f, 0.10260804f, 0.15560105f, 0.07825733f, 
    0.09414840f, 0.22350320f, 0.01065535f, -0.01624474f, 0.15446198f, 0.04146013f, -0.10716654f, -0.18687962f, 
    -0.00064347f, -0.00898938f, -0.21222517f, 0.00183402f, 0.13742414f, 0.03890754f, 0.01986798f, 0.11049771f, 
    0.12612484f, 0.11946583f, 0.44180694f, -0.11254375f, -0.09779334f, -0.01628928f, 0.15854204f, 0.03088189f, 
    0.05578406f, 0.21846192f, 0.04782023f, 0.04506225f, 0.26943436f, 0.16383983f, 0.22196862f, 0.39542428f, 
    -0.10307202f, 0.09821704f, 0.07581314f, -0.07249467f, 0.00037868f, -0.01658900f, 0.17723258f, -0.29407522f, 
    0.17396337f, -0.03837442f, -0.14053313f, -0.12322955f, 0.01012168f, -0.00099435f, 0.07986075f, 0.09058574f, 
    0.05120024f, -0.00341976f, -0.00819993f, 0.01051974f, 0.37620187f, 0.37418041f, -0.12076606f, -0.17839222f, 
    -0.14107355f, 0.05319975f, 0.19895896f, 0.03968110f, 0.13813776f, 0.25625688f, -0.06980213f, 0.03045631f, 
    -0.23253483f, 0.14441527f, 0.20324403f, 0.23676720f, 0.16630204f, -0.01904376f, 0.19157732f, -0.08004299f, 
    0.05564176f, -0.09674831f, -0.09109490f, -0.20000994f, 0.26143003f, 0.00073558f, 0.29482493f, 0.19519852f, 
    0.00924510f, -0.01189426f, 0.17560504f, -0.02210638f, 0.06493826f, -0.21035649f, 0.13380098f, 0.11776235f, 
    0.08870784f, -0.11855490f, -0.11098699f, 0.05632276f, -0.06729303f, 0.09678864f, 0.04714106f, 0.16930743f, 
    0.09659013f, -0.08505169f, -0.05657953f, 0.08254572f, -0.18031162f, 0.47786018f, 0.29315206f, 0.06660471f, 
    0.00812435f, -0.10637730f, 0.08542538f, 0.25854230f, -0.06643175f, -0.00757866f, 0.17444526f, 0.00160923f, 
    -0.02249190f, -0.18062574f, -0.20246042f, 0.17701283f, -0.06043347f, 0.04842618f, 0.30594349f, -0.07967948f, 
    -0.10202606f, -0.06434847f, 0.10823173f, 0.17611247f, 0.24046002f, -0.36406627f, -0.10062435f, 0.06882237f, 
    0.08674435f, 0.01786949f, 0.05426561f, 0.02717270f, 0.16648690f, -0.08375743f, 0.10379308f, 0.20333479f, 
    0.02782083f, 0.03627717f, 0.08224192f, -0.21410704f, -0.13731909f, 0.02733808f, 0.19122480f, 0.11589501f, 
    0.02127358f, -0.03545176f, -0.08983290f, 0.13284576f, -0.20189637f, 0.09906203f, 0.06023483f, 0.12898692f, 
    0.20101799f, 0.15666769f, 0.06374749f, 0.07110574f, 0.20675126f, -0.12643978f, -0.19243033f, 0.05617117f, 
    0.51003903f, -0.27153674f, 0.02187592f, -0.08155110f, -0.17035013f, 0.10308705f, -0.19349246f, 0.03304472f, 
    -0.00526365f, -0.00180962f, -0.04810223f, 0.12253314f, -0.08838531f, -0.24464509f, -0.12185472f, 0.11305007f, 
    -0.00118527f, 0.06644543f, 0.02900663f, 0.00822329f, 0.02420353f, 0.16585071f, -0.06472842f, 0.10569571f, 
    0.10824943f, -0.24839149f, -0.25742361f, 0.04520305f, 0.18915023f, -0.06024443f, -0.06556804f, -0.01861759f, 
    0.06671941f, -0.13132074f, 0.12445580f, -0.17124695f, -0.30512884f, 0.02508586f, -0.30877176f, -0.17423332f, 
    0.01238655f, 0.03482203f, -0.00372980f, 0.07238368f, 0.10372550f, 0.18399072f, 0.15671156f, 0.26961723f, 
    -0.12255115f, 0.31621310f, 0.30660948f, -0.09668050f, 0.08334024f, -0.04837326f, -0.00838766f, -0.05317385f, 
    0.02588358f, 0.31355542f, 0.00132921f, 0.23337297f, -0.31656054f, -0.12074370f, 0.06131542f, 0.08320303f, 
    0.30913639f, 0.11111533f, -0.05256930f, 0.04140928f, -0.01225788f, 0.05682017f, -0.04039894f, 0.09067395f, 
    -0.05570290f, 0.44935468f, 0.20481019f, 0.07983113f, -0.13432014f, 0.10863560f, 0.08764847f, -0.04847920f, 
    -0.06518335f, 0.10226630f, -0.01799674f, 0.04883104f, 0.36480546f, 0.30997565f, 0.32614306f, -0.01590620f, 
    0.02215681f, 0.17804250f, 0.00788426f, -0.26148865f, 0.13442980f, -0.07241714f, 0.04232628f, 0.25474700f, 
    0.01453833f, -0.14525011f, 0.04145399f, -0.09631323f, 0.08648759f, 0.02267166f, -0.02410468f, 0.05809605f, 
    0.13708821f, -0.06481585f, 0.11552588f, -0.17019629f, 0.32138896f, -0.09046787f, 0.29749075f, 0.19661504f, 
    0.03822041f, -0.07483822f, 0.21561736f, -0.01006719f, -0.03991042f, 0.26602003f, -0.04561936f, -0.00972452f, 
    -0.54246187f, -0.22139637f, -0.16146679f, -0.19379973f, 0.03611945f, -0.03707695f, 0.11642291f, 0.22172171f, 
    0.10545640f, -0.01582936f, -0.13528816f, 0.10626304f, 0.11891048f, 0.02771952f, -0.11371287f, -0.11630256f, 
    -0.01125167f, 0.25584570f, -0.00990871f, 0.01386527f, 0.11970935f, 0.14969468f, -0.16848516f, 0.23454626f, 
    0.00901969f, 0.00174179f, 0.04404017f, -0.03631630f, -0.01245902f, -0.02783593f, 0.00454935f, 0.03527592f, 
    -0.03389362f, -0.04803356f, 0.01671241f, 0.02894110f, 0.01810586f, -0.03206332f, -0.02676714f, 0.03061474f, 
    -0.03093550f, -0.02039173f, 0.03133742f, -0.01451825f, 0.02504569f, -0.03929623f, -0.00115957f, -0.02818875f, 
    -0.04662758f, 0.00836906f, -0.02262509f, -0.03239704f, 0.03952932f, -0.01238810f, 0.01631304f, -0.00672382f, 
    -0.04680746f, 0.00694441f, 0.01920469f, 0.00868827f, -0.02050824f, -0.04605747f, -0.01822872f, 0.02774425f, 
    -0.00646640f, 0.00327113f, -0.02348904f, 0.02583977f, -0.01630656f, 0.03281120f, -0.00070617f, -0.05414281f, 
    -0.03077128f, -0.05401325f, -0.02184248f, 0.03589218f, -0.00748069f, 0.01600089f, -0.03847125f, 0.01392002f, 
    -0.01730341f, 0.03411901f, -0.05658532f, -0.02876792f, -0.03679907f, -0.02179084f, 0.02839792f, -0.03416332f, 
    -0.01264649f, -0.01040641f, -0.00404478f, -0.05255361f, 0.03956142f, -0.01395960f, 0.02312067f, -0.04492243f, 
    0.01343619f, -0.00196987f, 0.01691789f, -0.02582454f, -0.00624487f, 0.03123260f, 0.02860839f, 0.01040130f, 
    0.01202211f, -0.04192130f, 0.04598339f, 0.02323105f, -0.00812471f, -0.00854630f, -0.03264292f, -0.04113764f, 
    -0.03365471f, 0.03810675f, 0.03086325f, -0.04680417f, -0.04270978f, 0.01815788f, -0.05226329f, 0.02869452f, 
    -0.01171420f, -0.04806563f, -0.01495192f, -0.02253854f, 0.03775284f, -0.00791642f, -0.01243291f, -0.00089345f, 
    0.02232646f, 0.01265545f, 0.00689618f, 0.02500132f, -0.03269265f, -0.00096874f, 0.04469110f, 0.03961625f, 
    0.03318389f, 0.01120437f, 0.01133671f, -0.04415770f, -0.04527769f, -0.00315629f, -0.00514655f, 0.04339390f, 
    -0.01577156f, 0.01098806f, 0.03495004f, -0.04494252f, -0.04694447f, 0.02206941f, 0.00319621f, -0.02813379f, 
    0.02739144f, 0.00747411f, -0.04887725f, -0.02885230f, -0.00389164f, -0.01198609f, -0.04789190f, 0.02339686f, 
    -0.02988404f, 0.04503607f, 0.01416564f, -0.04009644f, 0.01844403f, 0.04224157f, -0.05090733f, 0.01017395f, 
    0.02305688f, 0.01924616f, -0.04064965f, -0.05537826f, -0.02347263f, 0.04117269f, 0.04436210f, 0.02168157f, 
    0.03292847f, -0.00843385f, -0.03728521f, -0.02675209f, -0.04967678f, 0.01177676f, -0.01137055f, -0.01908125f, 
    0.04260455f, -0.04037644f, -0.02512157f, -0.00764466f, 0.01494810f, -0.03079043f, -0.01317053f, -0.05393339f, 
    0.00594983f, -0.04753172f, 0.04027649f, -0.02394381f, 0.02368554f, -0.02957585f, -0.00930534f, 0.00308012f, 
    -0.01659971f, 0.04120976f, 0.02818252f, -0.00944567f, -0.00423357f, -0.00611665f, -0.01297331f, 0.00333306f, 
    -0.01556713f, -0.03463149f, -0.01683162f, -0.01370370f, 0.01841317f, -0.05178986f, 0.03714036f, -0.04620840f, 
    -0.00375421f, 0.04105435f, -0.00536121f, -0.02873777f, -0.04801301f, 0.02493274f, -0.03952017f, 0.03776278f, 
    -0.00069984f, 0.02645335f, 0.02210199f, 0.04448033f, 0.02613777f, -0.00848907f, -0.00791936f, -0.04725453f, 
    -0.05107905f, -0.04621721f, 0.04255738f, -0.04167983f, -0.04711404f, -0.03944842f, -0.01578021f, -0.05499364f, 
    -0.04822257f, -0.04009546f, -0.03160377f, -0.03519688f, 0.00690339f, 0.01878896f, -0.05431604f, 0.01156138f, 
    -0.04998129f, 0.03947077f, 0.04355764f, -0.00876745f, -0.00198153f, -0.05501084f, -0.04786258f, 0.02726359f, 
    0.00186086f, -0.01585768f, 0.01507819f, -0.05157397f, 0.03231006f, -0.01391872f, 0.04293347f, -0.02805816f, 
    0.03366906f, -0.02433538f, -0.05134757f, -0.03942304f, -0.02901324f, 0.00398953f, 0.00453942f, -0.04874265f, 
    -0.04584399f, 0.01820288f, 0.01637628f, -0.05360474f, 0.00177698f, 0.02313347f, 0.04154462f, -0.03400935f, 
    -0.05278383f, 0.03522336f, 0.00689262f, -0.00547662f, -0.05249898f, -0.02646600f, -0.01273767f, -0.04270385f, 
    0.04382496f, 0.00669158f, 0.04389574f, 0.02641155f, -0.00467212f, 0.00001828f, 0.03791626f, -0.03323946f, 
    0.00607380f, -0.04924562f, -0.02044912f, -0.03163491f, -0.05413848f, -0.01380720f, -0.01358670f, 0.01011321f, 
    0.03186701f, -0.01565305f, -0.03361536f, -0.01854027f, -0.01012174f, -0.02292538f, 0.01817407f, -0.03169410f, 
    0.00581388f, 0.02071402f, -0.01406309f, 0.01597751f, -0.05014348f, -0.04475478f, 0.00697983f, 0.02619336f, 
    -0.02326232f, -0.00825341f, 0.01341769f, -0.00470734f, -0.05273274f, -0.02080548f, -0.05635390f, -0.03714824f, 
    -0.05551406f, 0.02279853f, 0.03572929f, -0.02364287f, -0.03201164f, -0.01605080f, -0.02546131f, 0.02642434f, 
    -0.04430359f, 0.03276756f, 0.02766560f, -0.04022925f, -0.02012063f, -0.01063224f, 0.00591104f, -0.00420519f, 
    -0.03641711f, -0.04461993f, -0.00952342f, -0.03820377f, -0.03280069f, 0.03633071f, -0.01915555f, 0.03696930f, 
    0.01921863f, -0.00336967f, 0.02285673f, -0.03667259f, 0.03630196f, -0.02299548f, -0.01823950f, -0.01287729f, 
    0.00058019f, -0.02055959f, 0.03927891f, -0.03572501f, -0.03836503f, -0.05573423f, 0.00232921f, -0.01486846f, 
    -0.00661134f, 0.00393882f, 0.03399875f, -0.04372397f, -0.02257373f, -0.04191605f, 0.03753548f, 0.00271299f, 
    0.02448560f, -0.02710456f, -0.01519312f, -0.04894416f, -0.03582937f, -0.05113289f, 0.00955883f, 0.02857991f, 
    0.02646375f, 0.03667113f, 0.03065521f, -0.00841828f, -0.01545188f, 0.03468316f, 0.01123728f, 0.01743530f, 
    -0.03215384f, 0.00944767f, -0.03399426f, 0.02406236f, -0.02348667f, -0.02076418f, -0.03577429f, 0.01008651f, 
    0.01744730f, -0.02392955f, 0.03175461f, 0.01068165f, -0.02130624f, -0.05088524f, 0.00481328f, 0.02541216f, 
    -0.28836343f, -0.11637023f, -0.04313720f, 0.04421056f, 0.00315736f, -0.07231587f, 0.11854278f, -0.05875976f, 
    -0.12861155f, -0.06744193f, 0.09091776f, -0.11760103f, -0.35401562f, 0.19867855f, -0.34566647f, 0.25967765f, 
    0.07189725f, 0.03234800f, 0.03693537f, -0.07951958f, 0.06562516f, 0.06044203f, 0.14663950f, 0.00773632f, 
    0.56005275f, 0.06182579f, -0.02326520f, 0.22205965f, -0.10196726f, -0.13607220f, -0.14853154f, 0.12656616f, 
    0.02386814f, -0.14853784f, 0.11016304f, 0.07089987f, 0.20913553f, -0.25239444f, -0.21283591f, -0.16702466f, 
    0.00339381f, -0.11544657f, -0.14672542f, -0.04439312f, 0.01270207f, -0.11605523f, 0.06762695f, 0.02831210f, 
    -0.07240663f, 0.14836121f, -0.11038114f, 0.12362966f, 0.07385366f, 0.10181701f, -0.01653156f, 0.19805595f, 
    0.02595329f, 0.12561855f, -0.05180874f, 0.00120241f, 0.47246787f, -0.19973075f, 0.04858197f, 0.21454750f, 
    0.05176894f, 0.08313910f, -0.10290690f, 0.06750800f, 0.02117654f, 0.07765290f, -0.00851799f, 0.07840537f, 
    0.12309934f, -0.19372225f, 0.17846376f, -0.01395679f, -0.12697180f, -0.01799126f, -0.12640382f, 0.18114027f, 
    0.11972716f, 0.08450087f, -0.11395815f, -0.08317517f, 0.21610489f, -0.09233736f, -0.08659749f, -0.33085957f, 
    -0.01659089f, -0.07414577f, -0.07093678f, 0.01954432f, -0.09187834f, -0.02109218f, -0.09624594f, 0.17854044f, 
    0.13678834f, -0.08039007f, 0.08699133f, 0.23609503f, -0.05046243f, -0.10708773f, -0.05682722f, 0.15974718f, 
    -0.05185209f, 0.15406209f, 0.14090227f, 0.30793378f, 0.05536608f, -0.02339730f, -0.09013078f, -0.12514953f, 
    0.06400421f, 0.00409465f, -0.05293367f, 0.13167562f, 0.17410828f, 0.01996558f, -0.02915771f, -0.10067334f, 
    -0.30238590f, -0.00937993f, 0.17052671f, -0.00020743f, 0.03223621f, -0.00635886f, 0.08952687f, 0.34219512f, 
    0.08909353f, -0.13048771f, 0.02964087f, -0.02905579f, 0.28849790f, 0.34588066f, 0.22269145f, -0.05896329f, 
    0.03790295f, 0.03885632f, -0.09178179f, 0.02767881f, -0.07677566f, 0.05120376f, 0.07940914f, -0.06462108f, 
    -0.27045771f, 0.25553080f, 0.01441004f, 0.04077150f, 0.22275199f, -0.06161345f, 0.00880362f, 0.05562944f, 
    0.00101733f, -0.04122044f, -0.01337516f, -0.13886271f, 0.20374432f, 0.12906075f, 0.07036924f, 0.46314472f, 
    -0.13804126f, -0.02370541f, -0.09902303f, -0.08408615f, -0.05628522f, -0.06718171f, 0.06170070f, -0.07610685f, 
    0.02651788f, 0.04496687f, 0.08257680f, 0.14043333f, -0.04962328f, -0.08088972f, 0.00443991f, -0.06072056f, 
    0.07694917f, -0.05102105f, 0.03326581f, 0.05435168f, -0.06240620f, 0.20927605f, 0.42110080f, 0.26299608f, 
    0.09197851f, -0.04444919f, 0.01075196f, 0.03619863f, 0.00335447f, 0.09761740f, 0.10387504f, 0.06122427f, 
    0.16936143f, 0.06729229f, 0.21281108f, -0.07611012f, -0.20920654f, -0.07169262f, -0.02620175f, -0.10954703f, 
    0.00545774f, 0.10767630f, 0.07508690f, 0.03824131f, 0.40060136f, 0.10299768f, -0.03956195f, 0.16219310f, 
    -0.11638203f, 0.21781148f, -0.04813049f, -0.18457970f, 0.03568411f, 0.00160797f, 0.03327502f, 0.06060175f, 
    0.30360004f, 0.16060577f, 0.16148233f, 0.18300049f, -0.11927560f, 0.09316793f, 0.22886285f, -0.36473802f, 
    -0.17585665f, -0.02647155f, -0.07796027f, 0.02248659f, 0.11295569f, 0.01817800f, -0.13793510f, 0.03322630f, 
    0.18820320f, -0.06979422f, 0.01353564f, 0.03704223f, 0.18869166f, -0.03191525f, -0.20809431f, -0.18231596f, 
    0.07562916f, 0.16693906f, -0.01690273f, 0.03731820f, -0.14883712f, 0.13419068f, 0.06440715f, 0.04343405f, 
    -0.04811789f, -0.10854420f, -0.11450579f, -0.09848778f, -0.00165188f, 0.05271589f, 0.14862886f, 0.08154366f, 
    0.10054889f, 0.16445620f, -0.20545976f, 0.08164371f, -0.10310598f, 0.03754331f, 0.11965220f, 0.11924448f, 
    0.10100621f, -0.04436308f, -0.32930389f, -0.05769006f, 0.10347605f, -0.12118293f, -0.04816306f, 0.00201398f, 
    -0.28025556f, -0.07700336f, 0.12234966f, -0.23854910f, -0.48812699f, -0.02218096f, -0.04087299f, -0.33746052f, 
    0.04680386f, 0.05537046f, -0.00504490f, -0.00206965f, 0.14566213f, -0.05959554f, 0.11309991f, 0.13568768f, 
    -0.01019464f, -0.04075425f, 0.06941000f, 0.12893964f, -0.00765052f, 0.00451116f, -0.01582115f, -0.06279187f, 
    0.06879233f, -0.04427496f, -0.02795790f, 0.06223580f, 0.26258090f, -0.28911415f, -0.10873235f, -0.05332349f, 
    0.10140703f, -0.12416989f, 0.06584207f, 0.15738755f, -0.04095172f, 0.03369137f, 0.04359937f, 0.08185278f, 
    -0.03955398f, 0.08698368f, 0.21173759f, 0.20958485f, 0.04503039f, -0.01193646f, 0.02686541f, -0.05958042f, 
    -0.19422102f, 0.04449546f, 0.01204301f, -0.03607221f, 0.13835582f, 0.04287631f, -0.06013070f, -0.01802774f, 
    0.01478313f, 0.26412028f, -0.14577205f, 0.06472009f, 0.00574794f, 0.00406200f, 0.03125013f, 0.01827119f, 
    -0.11768193f, -0.12825063f, -0.23120216f, 0.05985057f, 0.09803706f, -0.10095811f, -0.06473234f, -0.08419700f, 
    -0.03697171f, -0.11375025f, -0.13262786f, -0.19566463f, 0.03854753f, -0.00351230f, 0.07518161f, -0.15071854f, 
    -0.03952362f, 0.04409739f, 0.17967606f, 0.03857666f, -0.05874605f, 0.00204759f, -0.02162678f, -0.08674473f, 
    -0.06881160f, -0.13872449f, -0.15611856f, -0.30657777f, -0.07140087f, 0.03825356f, -0.01031200f, 0.06876791f, 
    -0.06681322f, 0.07939783f, 0.00059041f, 0.06411066f, 0.15997177f, 0.01929940f, 0.09505126f, 0.16874948f, 
    0.04311181f, -0.06330630f, 0.06466477f, 0.04758158f, 0.15335505f, 0.18434341f, 0.09759693f, 0.07866704f, 
    0.38990122f, -0.08134904f, 0.23026846f, 0.03676980f, -0.00476390f, 0.23356062f, -0.04605803f, 0.06846832f, 
    0.09759071f, 0.03068202f, 0.13454100f, 0.09172852f, 0.12426154f, -0.02584806f, 0.37863761f, -0.07807885f, 
    0.04248322f, 0.08477701f, 0.08108071f, 0.26871303f, -0.02914359f, -0.07737479f, -0.04937187f, 0.16492468f, 
    -0.15686023f, 0.02670424f, 0.12066047f, -0.17819259f, 0.00931798f, 0.09265608f, -0.03942701f, -0.07592350f, 
    0.04782799f, 0.03130420f, -0.09994171f, 0.13885731f, 0.59016651f, 0.55165350f, 0.18721673f, 0.25417757f, 
    -0.04238389f, -0.09792554f, 0.15371594f, 0.07745802f, 0.04092002f, 0.01121098f, 0.17963034f, -0.04494850f, 
    0.46995997f, -0.39842060f, 0.00384836f, -0.11766896f, 0.13022174f, -0.04839704f, 0.10976020f, 0.01194729f, 
    -0.11381390f, 0.09238910f, -0.09048904f, 0.04412157f, -0.01200838f, 0.16815649f, -0.35466325f, 0.12084486f, 
    -0.01715502f, 0.07925920f, 0.22662868f, 0.15990092f, 0.11228861f, 0.04985158f, 0.12207792f, -0.04268485f, 
    0.31162712f, -0.38370603f, -0.17301215f, 0.09024398f, 0.14955845f, 0.04116624f, -0.00073259f, -0.15160838f, 
    0.06531839f, 0.13371330f, 0.09287900f, 0.07454299f, 0.66015726f, 0.37047067f, 0.15992039f, 0.24108328f, 
    0.00046433f, -0.01016219f, 0.23730259f, 0.14217627f, 0.00666525f, 0.08153530f, 0.09651376f, 0.15036212f, 
    -0.22960058f, 0.16343252f, -0.24683630f, 0.00084106f, -0.12701808f, 0.03976795f, 0.08092703f, 0.05924797f, 
    0.14322822f, -0.03082410f, 0.03660720f, 0.13853525f, 0.12279914f, 0.43705502f, -0.01986408f, -0.03632649f, 
    0.09373616f, 0.03959775f, 0.07463743f, 0.12080710f, 0.09027015f, 0.06025768f, -0.10402605f, 0.19183426f, 
    -0.21943399f, -0.08244816f, 0.01238225f, 0.03034333f, 0.15759565f, 0.23593751f, -0.01892261f, 0.14102487f, 
    -0.00418075f, 0.22474350f, -0.15159382f, 0.02420324f, -0.47596204f, 0.01464985f, -0.01598692f, -0.10317040f, 
    0.02297057f, 0.00624478f, -0.01815678f, -0.00221081f, 0.04952885f, -0.15738139f, 0.00688855f, 0.09146328f, 
    0.11356840f, -0.03147558f, -0.15455459f, 0.10629038f, 0.00116367f, 0.14240153f, 0.03980976f, 0.05976821f, 
    -0.07409465f, -0.04836974f, 0.00862769f, 0.07957435f, 0.16165859f, -0.25147447f, -0.04441173f, -0.04714081f, 
    -0.10828815f, 0.08569892f, -0.07322262f, -0.02407986f, 0.10507822f, 0.16804266f, 0.00134501f, -0.03584270f, 
    0.43919402f, -0.30869621f, 0.02616828f, -0.17206539f, -0.05624064f, 0.14058432f, -0.07712518f, 0.04060499f, 
    -0.08733246f, 0.07382584f, 0.09062623f, 0.01141237f, -0.27644327f, -0.02877327f, -0.11727905f, 0.11581807f, 
    0.02157939f, 0.13144566f, 0.06576024f, -0.05792351f, 0.04594818f, 0.16994175f, 0.13377918f, 0.01155466f, 
    -0.06370725f, -0.08475548f, 0.06034984f, -0.31582424f, 0.11369245f, -0.21721302f, 0.05429965f, 0.03749358f, 
    0.11218799f, 0.06711853f, 0.07507918f, 0.11362683f, 0.26803464f, -0.01574823f, 0.02220854f, -0.07043968f, 
    0.16914383f, 0.09689969f, 0.07161617f, 0.13660949f, -0.06113166f, 0.06274397f, -0.12049825f, 0.04943451f, 
    -0.15661682f, 0.12548137f, 0.10262232f, 0.28424236f, -0.08248321f, 0.12783530f, -0.15930185f, 0.02655667f, 
    0.04869293f, 0.16108437f, 0.15246993f, 0.12598592f, -0.09379572f, -0.19309694f, 0.06753872f, 0.19633931f, 
    -0.09373990f, 0.09196883f, 0.00273218f, 0.09927262f, 0.13399962f, -0.06390279f, 0.08256124f, -0.15996286f, 
    0.00204279f, -0.05040834f, -0.18597320f, -0.13220407f, -0.08916734f, 0.11046343f, 0.17279521f, 0.04573740f, 
    0.12351164f, 0.22071305f, 0.02001805f, 0.00111694f, 0.24904244f, -0.02596810f, 0.08053997f, -0.17488472f, 
    0.20590273f, -0.12412795f, 0.01023158f, 0.09541929f, -0.14395082f, -0.01229868f, 0.03566292f, -0.07281899f, 
    0.47266302f, 0.12325688f, 0.38024721f, 0.07702418f, 0.01853069f, 0.08293510f, -0.01750442f, 0.05068854f, 
    0.07516305f, 0.03999884f, -0.03597874f, -0.05015789f, 0.43553236f, 0.27215216f, 0.25430429f, 0.21092494f, 
    -0.02697423f, 0.16286208f, 0.07208224f, 0.13817069f, -0.03598091f, 0.01740501f, 0.16036835f, -0.05822824f, 
    -0.11577805f, -0.06209303f, -0.21777526f, 0.09436221f, 0.03171393f, 0.07100838f, 0.09204804f, 0.07088464f, 
    0.13278043f, -0.14952552f, 0.11369692f, 0.02065586f, 0.29273042f, -0.08296406f, 0.10505415f, -0.06400194f, 
    -0.12346605f, 0.01307580f, 0.01987469f, -0.03715392f, -0.07116904f, 0.02185793f, 0.03869238f, -0.11982567f, 
    0.20049006f, -0.04729877f, -0.03255603f, -0.09821488f, 0.07630230f, -0.01144356f, 0.02392288f, -0.03944406f, 
    0.01640101f, 0.04169689f, 0.04219254f, 0.08964735f, 0.07205322f, -0.05663707f, -0.13678907f, 0.01442717f, 
    0.06131063f, -0.06278579f, 0.07601243f, 0.20948565f, 0.06173037f, 0.07806333f, -0.01546259f, 0.09919894f, 
    0.63715583f, 0.32241383f, 0.23111598f, 0.09930334f, -0.06136441f, 0.01790587f, 0.11552026f, 0.12304220f, 
    0.09088330f, 0.05184739f, -0.11138925f, 0.07238197f, -0.27724031f, 0.07292518f, -0.23344748f, -0.09278409f, 
    0.08743769f, 0.07545952f, -0.04772476f, 0.16023791f, -0.12154661f, -0.17209990f, -0.03041208f, -0.06538182f, 
    0.16072932f, 0.27222788f, 0.12936078f, 0.16257323f, -0.07536865f, 0.06358182f, 0.10935976f, 0.03559797f, 
    0.04082688f, 0.15859687f, 0.16739999f, 0.01168237f, 0.22772343f, 0.14596818f, 0.15009333f, -0.02946706f, 
    0.04133795f, -0.03750915f, -0.00873957f, 0.12750970f, 0.11389708f, -0.12166873f, 0.09440970f, 0.14302740f, 
    -0.05331933f, -0.05688716f, -0.04528644f, -0.04412551f, 0.01012867f, -0.05016342f, -0.01482103f, 0.00302085f, 
    0.02414539f, 0.02371622f, -0.04817997f, -0.05671277f, 0.03269104f, -0.01922850f, -0.05687824f, 0.00396287f, 
    -0.03848471f, -0.02461047f, -0.01661595f, 0.03087923f, -0.02814222f, 0.02832696f, -0.02110098f, 0.03382340f, 
    0.01161702f, -0.01769930f, 0.01314473f, -0.03720272f, 0.00623328f, 0.04367292f, 0.01403761f, -0.01505820f, 
    -0.04153032f, -0.00440900f, -0.00865022f, -0.00476913f, -0.04214865f, -0.00823388f, 0.03924574f, 0.01239849f, 
    -0.01576116f, -0.00604632f, 0.03917053f, -0.02986134f, -0.00902429f, 0.01902915f, -0.04700847f, -0.04687165f, 
    0.00016934f, -0.01758894f, -0.01100788f, -0.00961657f, 0.00182950f, -0.03849718f, 0.04468435f, -0.02147301f, 
    -0.05404311f, -0.02987943f, 0.03136054f, -0.03634202f, 0.01527388f, -0.02605630f, 0.03080831f, -0.03723975f, 
    0.03868154f, 0.03582538f, -0.02481485f, -0.05353473f, 0.01658943f, 0.02977311f, -0.04987352f, 0.03981250f, 
    0.04087169f, 0.04059767f, 0.00169673f, 0.00887650f, 0.01969387f, 0.01867842f, -0.02815625f, -0.04452426f, 
    -0.04547299f, -0.01875649f, -0.00589433f, 0.02093210f, 0.01499020f, -0.01504210f, -0.04650011f, -0.04720664f, 
    -0.02294569f, -0.01754667f, -0.01571894f, 0.00690480f, 0.03599962f, -0.04006698f, 0.02020728f, -0.04999882f, 
    0.02586848f, -0.04874026f, -0.01499458f, 0.00343495f, -0.01831319f, -0.00226986f, 0.02093942f, -0.02829937f, 
    -0.00707558f, 0.03362077f, -0.03983848f, 0.02580644f, -0.03776619f, -0.03693973f, 0.00701819f, 0.00361673f, 
    -0.00707798f, 0.03299626f, -0.01015399f, -0.05107930f, -0.03014060f, 0.00070308f, 0.04161488f, 0.00592427f, 
    -0.04604724f, -0.01061926f, -0.01731338f, 0.04323379f, -0.05371863f, 0.04363837f, 0.02682610f, 0.03435359f, 
    0.00907200f, -0.01873635f, 0.01572023f, -0.04749170f, 0.01260071f, -0.02921672f, 0.00647605f, 0.01653372f, 
    -0.03203056f, -0.04380952f, -0.01202767f, 0.01962867f, -0.01785189f, 0.01112750f, -0.02448065f, -0.01778741f, 
    -0.01777528f, -0.01911313f, -0.03845248f, 0.02175084f, 0.00613518f, -0.01787925f, 0.01507946f, 0.01068977f, 
    0.00839761f, -0.05567325f, 0.03083046f, -0.00989365f, -0.00134820f, 0.00928701f, 0.03450793f, 0.01411994f, 
    0.01890783f, 0.01987426f, -0.00424201f, -0.01607133f, -0.03138112f, -0.01182986f, 0.04812393f, -0.01546036f, 
    0.03912976f, -0.00614807f, -0.03028110f, 0.02559946f, -0.05604000f, -0.02406763f, -0.01235888f, 0.04079785f, 
    -0.03584883f, 0.01233103f, -0.03708538f, 0.00171116f, 0.00226952f, -0.00628836f, -0.01379993f, 0.01108015f, 
    -0.02036444f, -0.04459522f, -0.01103766f, -0.04534591f, 0.03303208f, -0.05130995f, 0.02889230f, 0.00000175f, 
    0.01239048f, 0.02562106f, 0.03584586f, 0.02559727f, 0.03449845f, 0.00987817f, -0.04120616f, -0.02388698f, 
    0.01540088f, 0.00778120f, -0.04310852f, -0.02098836f, -0.04417573f, 0.03237375f, -0.02558161f, -0.04095089f, 
    -0.03148507f, 0.00638827f, -0.04055628f, -0.01058466f, 0.03765322f, -0.05131771f, -0.05296554f, 0.01701048f, 
    0.01295116f, 0.00964739f, -0.01296940f, 0.01252115f, -0.03620428f, 0.03274726f, 0.01701959f, -0.04418453f, 
    -0.01063197f, 0.02934119f, -0.03372716f, 0.01887241f, -0.03401418f, -0.02177316f, 0.01180187f, 0.03556748f, 
    -0.05509646f, 0.03454825f, 0.04375770f, 0.03105589f, -0.04288199f, -0.03625724f, -0.00360591f, 0.01159051f, 
    0.02845966f, 0.03151801f, 0.00666951f, 0.01266980f, 0.00632279f, -0.02377822f, -0.03474360f, -0.00267195f, 
    -0.05110658f, -0.04181536f, -0.01958029f, -0.00797947f, -0.05488724f, 0.03439751f, 0.00519664f, 0.00453916f, 
    0.02423614f, -0.05384417f, 0.02702330f, 0.01481343f, -0.05112918f, 0.02420738f, -0.04422435f, 0.00402170f, 
    0.01242930f, 0.03374302f, -0.01796597f, -0.04841152f, -0.02088127f, 0.03746712f, 0.02410231f, -0.04272469f, 
    0.02808712f, 0.00934137f, -0.03424831f, -0.05641450f, -0.03195322f, 0.01237291f, -0.05362850f, 0.03406554f, 
    0.02375419f, -0.04974871f, -0.02927718f, -0.05576719f, 0.00356710f, -0.04098768f, 0.01853304f, 0.02570779f, 
    -0.02163768f, -0.02734869f, 0.04271771f, -0.05494295f, -0.04743179f, -0.02903694f, -0.05366515f, 0.01437057f, 
    0.04098116f, -0.02901892f, -0.00694294f, 0.01515866f, -0.03777365f, -0.03588506f, 0.00162946f, 0.00067694f, 
    -0.00948148f, -0.00512914f, -0.02982475f, 0.02767447f, -0.01083201f, -0.04454947f, -0.05659210f, -0.03510255f, 
    0.02468337f, -0.04515577f, -0.03512519f, -0.04836928f, 0.02849275f, 0.02257572f, -0.02627088f, 0.03124952f, 
    0.02968442f, 0.03472757f, 0.02362828f, -0.02433648f, 0.02934961f, 0.03911896f, -0.01850885f, -0.04047200f, 
    0.01139278f, -0.03669589f, -0.02490557f, 0.02509793f, 0.04392228f, -0.02422295f, 0.03257804f, -0.03575354f, 
    0.01207244f, -0.04099115f, 0.01817771f, -0.02626186f, -0.04599361f, 0.03167925f, -0.03303422f, 0.03584397f, 
    -0.03071391f, 0.04231086f, 0.01420806f, 0.01503601f, 0.02261901f, 0.00457079f, 0.03726905f, -0.03639157f, 
    0.03045359f, -0.05606554f, 0.03940630f, -0.02638389f, -0.05457501f, -0.02665484f, -0.03251664f, 0.03041122f, 
    -0.05677724f, 0.02942005f, -0.00180163f, 0.04096096f, -0.02695609f, -0.00875912f, -0.01179956f, -0.05078956f, 
    -0.01498104f, 0.01083613f, -0.04752454f, 0.02629944f, 0.01149502f, 0.02012213f, -0.01141003f, -0.01079583f, 
    -0.04081037f, -0.02335039f, -0.02107065f, -0.01948923f, -0.04760606f, -0.01412916f, 0.01789943f, -0.02607870f, 
    -0.50110716f, 0.07040937f, 0.23151319f, -0.05141604f, 0.21173084f, -0.01285800f, 0.08254047f, -0.07805527f, 
    0.16065840f, -0.06266791f, 0.11965737f, 0.09839749f, -0.03891514f, 0.26716849f, -0.12748837f, -0.12143575f, 
    0.00563652f, 0.10990568f, -0.07314780f, -0.15260017f, 0.12502797f, 0.00740543f, 0.19936110f, -0.10416903f, 
    -0.19937092f, 0.03917760f, -0.12356363f, -0.25376910f, 0.02519749f, -0.12589119f, 0.04506567f, 0.04199704f, 
    -0.12481323f, 0.17870587f, -0.00277817f, 0.15001674f, 0.18940607f, -0.15166447f, -0.04321455f, 0.22491024f, 
    0.14422627f, 0.13572331f, 0.08267647f, -0.04134091f, -0.15344939f, -0.05881068f, -0.03752224f, -0.01908893f, 
    0.28015521f, 0.11137567f, -0.03475413f, 0.11293826f, 0.13155408f, 0.00321061f, -0.12307829f, 0.03741575f, 
    -0.14711775f, 0.04116325f, 0.03671481f, 0.17561185f, 0.24916036f, 0.34963346f, 0.13020280f, -0.21607795f, 
    0.07451007f, -0.07053279f, 0.01127080f, 0.02382110f, 0.23311827f, 0.25776592f, 0.06404138f, 0.04154432f, 
    0.29417649f, 0.35608715f, 0.29971349f, -0.07437347f, -0.07632317f, 0.06082766f, -0.11414181f, 0.10682195f, 
    -0.05706083f, -0.26428151f, 0.01540317f, 0.14882998f, -0.07062692f, -0.15289019f, -0.01733585f, 0.40278924f, 
    0.09198024f, 0.09084902f, 0.03451227f, -0.05107719f, 0.03335604f, -0.07600161f, 0.08727317f, -0.07293627f, 
    -0.23770286f, -0.11569704f, 0.17043848f, -0.13317229f, 0.01397487f, 0.13847089f, -0.03136921f, 0.09032595f, 
    -0.05779149f, -0.04069233f, 0.35200140f, 0.05832998f, -0.06870180f, -0.16194080f, -0.02481965f, 0.12654027f, 
    -0.01046280f, 0.07463613f, 0.19288601f, 0.08806791f, -0.06436064f, -0.07266794f, -0.05903193f, 0.03432144f, 
    -0.14070505f, -0.05977625f, 0.06787521f, -0.02525253f, 0.06869215f, -0.06867649f, -0.04979113f, -0.13472463f, 
    -0.00110741f, -0.06436984f, 0.12557493f, 0.04899808f, 0.10875710f, -0.16551133f, -0.13509786f, 0.20307043f, 
    -0.16476727f, 0.02713371f, -0.06124607f, 0.11145858f, 0.11748765f, 0.05179148f, 0.04998081f, 0.22965828f, 
    -0.45749724f, -0.00993945f, -0.02334115f, -0.00825798f, 0.13550806f, -0.02652702f, 0.02041771f, 0.10414939f, 
    0.05293999f, 0.15157694f, 0.09041933f, 0.09412719f, 0.02436669f, -0.03092959f, -0.01997277f, 0.00193851f, 
    0.09144745f, 0.05994305f, -0.02114220f, 0.00529059f, -0.01864622f, 0.11377139f, 0.08841276f, 0.03667131f, 
    -0.48294076f, -0.29708275f, -0.14748858f, -0.09743068f, 0.04847256f, -0.01232263f, 0.06453254f, 0.02889870f, 
    0.16767085f, -0.11172553f, -0.04546239f, -0.10354873f, -0.00463038f, 0.27084339f, -0.03668892f, -0.15734550f, 
    -0.09388345f, -0.12999189f, -0.04989257f, 0.09505177f, -0.00922402f, -0.07970710f, -0.15589517f, 0.19551800f, 
    -0.05791684f, -0.03276085f, -0.13186574f, 0.06323799f, -0.06061228f, 0.17051521f, -0.15961519f, 0.17458610f, 
    -0.01442737f, -0.03387414f, -0.15266256f, -0.07255203f, -0.20573154f, -0.04524284f, 0.03157772f, -0.09477839f, 
    0.04962349f, -0.05697776f, 0.01705022f, 0.03560142f, 0.22037658f, 0.07668233f, 0.23490062f, -0.11882845f, 
    -0.16912410f, -0.34225914f, -0.01770744f, -0.23936756f, 0.11846704f, 0.03481515f, 0.06376333f, -0.06016997f, 
    0.21328335f, -0.01801083f, 0.13368483f, 0.13538903f, 0.05073555f, 0.06647003f, -0.04161626f, -0.04501547f, 
    -0.03803489f, -0.03175636f, 0.01720150f, -0.00349553f, -0.33198103f, 0.03598703f, 0.12952760f, 0.10213024f, 
    -0.53069639f, -0.22994590f, 0.11641089f, -0.32458147f, 0.08303648f, 0.08258877f, -0.09931163f, 0.14983357f, 
    0.04164725f, -0.08788522f, 0.01001112f, 0.05135142f, 0.38466918f, 0.12630384f, 0.16485299f, 0.11966949f, 
    0.00737409f, -0.08991901f, 0.09155414f, 0.00130462f, 0.10112178f, -0.01939039f, -0.03712545f, 0.17112008f, 
    0.04907874f, 0.05840720f, -0.15277089f, 0.33306068f, 0.10618557f, 0.09438976f, 0.15176472f, -0.03992396f, 
    0.01898432f, 0.09377430f, -0.16021982f, 0.13597395f, 0.27954492f, -0.17187119f, 0.09396639f, 0.04169516f, 
    0.06907890f, -0.26959997f, 0.09015726f, -0.10167611f, 0.04447658f, 0.15146208f, -0.16202135f, 0.07390056f, 
    -0.09231292f, 0.24406034f, -0.13304143f, 0.13994747f, -0.01361270f, 0.00804090f, -0.00422470f, 0.04902786f, 
    -0.07237300f, 0.17386100f, 0.12627129f, 0.14110346f, 0.40740219f, -0.07621214f, -0.03782334f, 0.00142985f, 
    0.10062388f, 0.11740413f, -0.08975764f, 0.04845534f, 0.00445394f, -0.07536437f, 0.15160814f, 0.23480405f, 
    -0.13988949f, -0.16207288f, -0.03408854f, 0.16558124f, -0.00335965f, 0.01323565f, -0.11283503f, 0.19604258f, 
    0.04151202f, 0.07401498f, -0.13990183f, 0.19648695f, 0.34426972f, -0.01358375f, -0.02334784f, 0.02773735f, 
    0.26369298f, -0.08890545f, 0.18097593f, 0.09007770f, 0.13205218f, 0.21086682f, 0.00757820f, -0.27467644f, 
    -0.01632763f, -0.06757449f, 0.00422882f, 0.41658098f, 0.26667964f, 0.19628756f, -0.02593099f, -0.05471643f, 
    -0.16256379f, 0.01814910f, 0.18616349f, 0.20978995f, -0.13310520f, -0.01971631f, 0.10974538f, 0.07020473f, 
    0.12700988f, 0.08671573f, -0.01321909f, 0.00704571f, 0.20724176f, 0.06513312f, 0.13968600f, 0.14026786f, 
    0.18779035f, -0.07778572f, 0.11888415f, 0.17874320f, 0.18412551f, -0.04868710f, -0.03876608f, 0.08310702f, 
    0.06474904f, 0.00526165f, 0.04742600f, 0.09104280f, 0.19692656f, 0.06278553f, -0.11348315f, -0.12617388f, 
    0.08981129f, 0.03863179f, -0.03381003f, 0.23029427f, 0.02820290f, -0.07168146f, 0.07193770f, -0.01377445f, 
    -0.02527294f, 0.01375306f, 0.03527045f, -0.04435124f, -0.01305557f, 0.00160048f, 0.02836625f, -0.02472434f, 
    -0.04606302f, -0.03434601f, -0.02541985f, -0.04786913f, -0.03245394f, -0.03657518f, -0.02848577f, -0.00369231f, 
    0.02079526f, 0.04032438f, -0.01617154f, 0.00211984f, -0.01942708f, 0.03376275f, 0.01535612f, 0.01705076f, 
    -0.02879251f, -0.04977148f, 0.03899267f, -0.05640319f, 0.02051868f, -0.02604259f, -0.03196635f, -0.05293614f, 
    -0.04269379f, -0.05671489f, 0.02571487f, -0.01006305f, -0.02987387f, -0.00248929f, 0.00949023f, -0.05000034f, 
    -0.01845291f, 0.02221331f, 0.01738875f, -0.01012538f, -0.04620721f, -0.02277459f, 0.03346210f, 0.02768597f, 
    -0.03930483f, 0.00063989f, -0.00701441f, -0.04343519f, 0.03637762f, -0.02455101f, -0.02812213f, 0.03970343f, 
    -0.04073374f, -0.04364105f, -0.02192095f, -0.03963938f, -0.04085859f, -0.02788350f, -0.04567648f, -0.00343381f, 
    -0.04187769f, -0.00109089f, 0.03048487f, 0.04016682f, -0.00634150f, -0.02201441f, -0.04458631f, -0.03256778f, 
    -0.05236762f, -0.05712877f, 0.00517012f, -0.02100129f, -0.04343798f, 0.01443370f, -0.05037690f, 0.01079282f, 
    -0.03391802f, -0.00901067f, 0.01680814f, -0.00834894f, 0.00491859f, 0.03647636f, 0.01166634f, -0.02499062f, 
    -0.03067260f, -0.04456534f, -0.05551524f, 0.03231039f, -0.01038920f, -0.02656783f, 0.00129044f, 0.00630463f, 
    0.00182762f, -0.05383603f, -0.02443545f, -0.00904506f, 0.03263888f, 0.00602415f, -0.04099691f, 0.00588042f, 
    -0.04970881f, -0.03443000f, 0.01260882f, 0.01449815f, -0.04778473f, -0.02713768f, 0.02733475f, -0.00966720f, 
    0.03879091f, -0.01674407f, 0.01622319f, -0.02013901f, 0.04188585f, 0.01701122f, 0.01198238f, 0.03621917f, 
    0.02074356f, 0.01962139f, 0.00599584f, 0.02971389f, -0.00835519f, 0.02844697f, -0.00785180f, -0.00870893f, 
    -0.04554455f, 0.01468454f, -0.01567218f, 0.01681970f, -0.00017525f, -0.02423995f, -0.01042144f, 0.04079605f, 
    -0.03892340f, 0.02760455f, -0.02414299f, 0.03667920f, 0.02888164f, 0.01562592f, -0.05412745f, -0.04035715f, 
    -0.01016290f, -0.04388784f, -0.05084079f, 0.02486827f, 0.01500393f, -0.02849550f, -0.02859894f, -0.00858901f, 
    -0.00242119f, -0.05220756f, -0.00599719f, -0.03930645f, 0.02181844f, 0.00227323f, 0.00442456f, -0.04279845f, 
    -0.04068644f, -0.05241613f, -0.01816196f, -0.01728058f, -0.02966474f, 0.04484371f, 0.04086789f, -0.00091950f, 
    -0.03214083f, -0.04329907f, -0.01001984f, 0.03509759f, 0.02133332f, 0.00174250f, -0.04542783f, -0.03635259f, 
    -0.03965517f, -0.00098246f, 0.01636896f, 0.01048754f, -0.02877590f, 0.02212714f, 0.02276910f, 0.02411782f, 
    0.01504731f, -0.04883184f, 0.01141368f, 0.01548797f, 0.00498793f, -0.02277336f, -0.01004627f, 0.01468621f, 
    -0.02926324f, -0.00752775f, -0.03005846f, -0.03015736f, 0.03385472f, 0.00413358f, 0.03626142f, -0.00183927f, 
    0.00023888f, -0.04727409f, 0.01491387f, 0.01783270f, 0.01748684f, -0.05286648f, -0.05743526f, 0.00707087f, 
    0.00354217f, 0.02484304f, -0.01045003f, 0.03517714f, 0.02650030f, -0.00826487f, -0.02857107f, 0.01219485f, 
    0.02927619f, -0.05336789f, 0.02606023f, -0.04300322f, -0.04151276f, -0.00357029f, -0.03825182f, 0.02798831f, 
    -0.04612008f, -0.02986745f, 0.00882170f, 0.03859926f, -0.02022079f, -0.00652728f, 0.01869510f, 0.04270171f, 
    0.01482621f, 0.00312511f, -0.02845612f, -0.00255623f, 0.02352176f, -0.04472704f, 0.00779040f, 0.04155359f, 
    0.00733338f, -0.02003122f, -0.04128615f, 0.04553672f, -0.03102629f, 0.04145809f, -0.01691447f, 0.04234188f, 
    0.00414949f, -0.04210519f, -0.01083551f, -0.00902350f, 0.00450074f, -0.05135383f, -0.00667244f, 0.02450459f, 
    -0.04989684f, -0.00209754f, 0.02636562f, -0.04696020f, -0.02188615f, -0.01543633f, 0.02421879f, -0.02844642f, 
    0.04683033f, -0.04559279f, -0.03822305f, -0.04434220f, -0.00142399f, -0.01258719f, -0.05364439f, -0.00919345f, 
    -0.01904854f, 0.00435484f, -0.01942739f, -0.04106375f, 0.03885156f, 0.03952467f, -0.05199024f, -0.01798496f, 
    -0.03292117f, -0.04736987f, -0.00145492f, 0.02596959f, 0.00290914f, -0.03958837f, -0.01768931f, 0.02432927f, 
    -0.01914258f, -0.05280424f, 0.00690408f, -0.03800827f, 0.01325888f, -0.04813002f, 0.02310969f, 0.01799967f, 
    0.02000654f, 0.04292114f, -0.00612680f, 0.00031706f, 0.03239601f, -0.00944992f, -0.01611922f, 0.00889802f, 
    0.03274071f, 0.01403686f, -0.01917477f, -0.04491147f, -0.01629235f, -0.05256267f, 0.00679587f, -0.02655694f, 
    0.00501809f, 0.02710772f, -0.00457796f, 0.00220492f, -0.02169709f, 0.03529990f, -0.02635377f, 0.00122333f, 
    0.03583886f, 0.04231575f, 0.01905489f, -0.02037719f, -0.00880330f, 0.01491948f, -0.01663089f, -0.03704315f, 
    -0.03576996f, -0.04364013f, -0.03428548f, -0.00114973f, -0.01401884f, 0.02979861f, 0.02356984f, -0.03119072f, 
    -0.04335032f, -0.03230828f, -0.03385966f, 0.04509397f, 0.01157378f, -0.04012765f, 0.00228115f, 0.02667638f, 
    -0.00839340f, -0.01828354f, -0.00702743f, 0.01881337f, 0.02586480f, -0.00237597f, 0.00253773f, 0.03250596f, 
    -0.01213563f, 0.02998637f, -0.04683797f, -0.00965643f, 0.03874998f, -0.04080109f, 0.02618024f, 0.01055030f, 
    0.03160611f, 0.03843655f, 0.03607062f, 0.04390863f, 0.01794337f, -0.02794887f, -0.00343074f, 0.02137882f, 
    -0.02203690f, 0.01658468f, -0.04472695f, 0.02692953f, 0.03705591f, 0.01095902f, 0.00120478f, -0.04949080f, 
    0.00279988f, 0.01930806f, 0.01803055f, 0.03058755f, 0.00867274f, -0.02411286f, 0.01242214f, 0.03090202f, 
    0.03321028f, 0.04933702f, 0.01805266f, 0.01103000f, 0.04845424f, 0.04078708f, 0.03460487f, -0.04201988f, 
    -0.00192061f, 0.00148653f, -0.03649119f, 0.01346521f, 0.00420770f, -0.04173958f, 0.00968869f, -0.02277002f, 
    -0.05102031f, -0.02713159f, -0.01727468f, -0.01076953f, 0.04502368f, 0.02751652f, -0.01038602f, -0.02411076f, 
    -0.01155662f, 0.04331723f, -0.04963879f, 0.00374039f, 0.00273208f, -0.02772453f, -0.02905675f, 0.00124610f, 
    -0.02312977f, -0.03286855f, 0.00609573f, -0.04971618f, 0.03492199f, -0.03115818f, -0.02678221f, 0.04449400f, 
    -0.03991698f, -0.02314706f, 0.02585730f, 0.02000873f, 0.05035203f, 0.01722112f, -0.02977433f, 0.00703738f, 
    0.00498930f, 0.03414931f, 0.00805610f, -0.02695529f, -0.01476383f, 0.03555329f, -0.01883776f, 0.02379798f, 
    -0.04097575f, 0.04610709f, -0.03719020f, -0.03028924f, 0.02630448f, -0.01192847f, 0.03402191f, 0.01009637f, 
    0.04129409f, 0.00020533f, -0.03603273f, 0.01391389f, 0.02839139f, -0.02375767f, -0.03043907f, 0.03104857f, 
    0.02579875f, -0.01248986f, 0.01484392f, 0.01956590f, -0.02172121f, 0.00265276f, -0.04478659f, -0.01266322f, 
    0.03978068f, -0.04554204f, 0.00058787f, 0.00182765f, -0.04532845f, -0.04669985f, -0.01893838f, -0.01601242f, 
    0.03925971f, 0.01356873f, -0.02174632f, -0.00501984f, 0.00852065f, -0.03616548f, 0.00218486f, -0.03086291f, 
    0.01541093f, -0.02017968f, 0.03230029f, 0.01476440f, -0.03068497f, 0.00332832f, -0.01396881f, 0.03011299f, 
    -0.03542700f, 0.03649856f, 0.01283074f, -0.04580551f, -0.05052729f, -0.01645865f, -0.01284871f, -0.05080790f, 
    0.05083587f, 0.01081227f, -0.05021199f, 0.04679150f, 0.02858525f, -0.03409696f, -0.03634744f, 0.01830215f, 
    0.04177483f, -0.02840318f, -0.00360715f, -0.02745248f, 0.04847309f, -0.04243280f, -0.04256345f, 0.01351052f, 
    -0.02884058f, 0.04437328f, 0.02821443f, -0.00113167f, -0.04519955f, 0.01472224f, -0.02536830f, -0.00237910f, 
    -0.04110310f, -0.03295333f, -0.00417888f, -0.03700467f, 0.04393213f, -0.05041701f, -0.01267813f, -0.00369558f, 
    0.02060153f, -0.01398535f, -0.04622385f, 0.03948997f, -0.02437191f, -0.00016030f, -0.03196018f, -0.03101681f, 
    0.04828177f, -0.03769399f, -0.04769436f, -0.03932489f, -0.04546206f, -0.02328401f, -0.03540149f, 0.04080832f, 
    -0.04911045f, -0.03434063f, -0.03996856f, -0.03614751f, 0.02961857f, -0.04590220f, 0.00212087f, 0.01932215f, 
    -0.00038194f, 0.02261992f, -0.02252353f, -0.01338497f, -0.04892250f, -0.02968783f, -0.04632681f, 0.03156082f, 
    0.03661993f, -0.04472143f, -0.05093763f, -0.01637597f, 0.01008141f, -0.02690822f, 0.03501670f, -0.02068057f, 
    0.02569221f, -0.03177349f, 0.01500510f, -0.04041445f, -0.03240537f, 0.01193068f, 0.04990301f, -0.04943609f, 
    0.01955707f, -0.01667222f, -0.04929243f, 0.02208178f, -0.02925503f, 0.05102077f, 0.04392200f, -0.03348386f, 
    -0.04567678f, 0.02717048f, -0.01234172f, 0.01679867f, 0.04590822f, 0.00486503f, -0.02318406f, 0.03061064f, 
    0.02405871f, -0.00693651f, 0.03595827f, 0.00225582f, 0.04080455f, -0.02119488f, -0.04920303f, -0.04617241f, 
    -0.00504354f, 0.04307476f, -0.03310264f, 0.04778343f, 0.01666079f, 0.01023509f, -0.02663726f, -0.04019614f, 
    -0.00935170f, -0.00021793f, -0.02176533f, 0.03943522f, 0.00947709f, -0.04246932f, -0.04725501f, -0.01964479f, 
    -0.04973269f, 0.02138424f, -0.00238584f, 0.04843202f, -0.02331826f, -0.03221239f, 0.04453273f, 0.00372998f, 
    0.01877771f, -0.04481060f, 0.01140608f, 0.01296231f, -0.02733402f, -0.04765902f, 0.02720715f, -0.03682841f, 
    0.04521105f, -0.02798186f, -0.00960351f, 0.03311533f, 0.02293151f, 0.01899193f, 0.04354559f, -0.02786146f, 
    0.03951183f, -0.00374399f, -0.01755556f, 0.03272811f, 0.04332957f, 0.00628489f, -0.03819448f, 0.00685835f, 
    0.01261532f, -0.03842241f, 0.01436086f, -0.00993277f, -0.04374946f, 0.03865594f, -0.02111002f, -0.00459627f, 
    -0.01059348f, -0.04244621f, -0.00900289f, -0.03305750f, -0.03445544f, -0.04265800f, 0.02626317f, 0.00982546f, 
    -0.04331364f, 0.03116718f, 0.04254703f, -0.04977351f, -0.04541714f, -0.01927442f, 0.04881659f, 0.02210754f, 
    0.03494699f, 0.00655820f, 0.03916500f, 0.01022582f, 0.00795148f, -0.00752431f, -0.02636970f, -0.02951796f, 
    -0.00649229f, 0.00017909f, -0.00136046f, -0.01587160f, 0.02937695f, -0.01085111f, -0.04394837f, 0.03963073f, 
    0.01627063f, 0.00380473f, -0.02570466f, -0.03693232f, 0.02270909f, -0.02108493f, -0.03054727f, 0.01205798f, 
    -0.00816023f, 0.02921383f, 0.02282196f, 0.01430325f, -0.02866618f, -0.03298942f, -0.00273776f, -0.00600815f, 
    -0.03634118f, -0.04830522f, -0.02934653f, -0.04800783f, 0.03892206f, 0.02358197f, -0.03805003f, 0.04719298f, 
    -0.00908080f, 0.02227917f, 0.01190960f, 0.01959868f, -0.03472228f, 0.01581653f, -0.03229646f, -0.03082721f, 
    -0.02755396f, -0.00110562f, -0.04157765f, -0.00377242f, -0.02590830f, -0.04049386f, 0.00422316f, 0.01424560f, 
    0.02828241f, 0.00051911f, -0.04292575f, 0.00891071f, -0.00720425f, 0.01679879f, -0.02228343f, 0.00478737f, 
    0.02768734f, 0.04488361f, -0.02068621f, -0.00837516f, -0.02804204f, 0.03392223f, -0.01660228f, -0.01021494f, 
    -0.00872704f, -0.01531847f, -0.04078757f, -0.03611268f, -0.02561813f, -0.02970984f, -0.03695327f, -0.04771048f, 
    0.03248563f, -0.02708977f, 0.00367795f, 0.04058858f, 0.00112932f, 0.02180527f, -0.03178127f, -0.03481664f, 
    0.02020852f, 0.01631818f, 0.02102849f, 0.01076134f, 0.02781569f, 0.01645473f, -0.04761673f, -0.01448098f, 
    -0.01532087f, -0.01150742f, -0.05408636f, 0.02566067f, -0.03439273f, -0.01576679f, -0.04885768f, 0.02391239f, 
    0.00808067f, -0.03262367f, 0.02437339f, -0.03938737f, -0.04361375f, -0.04175979f, 0.02083811f, 0.00128029f, 
    -0.01722506f, 0.03218253f, -0.03719753f, 0.01885501f, 0.00728149f, -0.03230549f, 0.02650001f, -0.00246115f, 
    -0.03582432f, -0.03869998f, -0.02137426f, 0.02190047f, -0.02664775f, -0.02540258f, -0.00963437f, 0.01609438f, 
    -0.03849830f, 0.03328542f, 0.00470031f, -0.03144706f, -0.01954162f, -0.03418919f, -0.02056218f, -0.04691981f, 
    -0.02706770f, -0.04367909f, -0.04972034f, 0.00531678f, -0.01568232f, -0.01677731f, -0.04573299f, -0.04135241f, 
    0.02092094f, -0.02704747f, 0.00372603f, 0.01739178f, -0.03793880f, -0.01780020f, -0.01911701f, 0.01777194f, 
    0.02966106f, 0.02791700f, 0.01020433f, -0.02260760f, 0.00763909f, -0.00946582f, 0.00420763f, 0.02567518f, 
    -0.01639434f, 0.03794099f, -0.01389293f, -0.01194594f, -0.01820443f, -0.03730629f, -0.01729021f, -0.01250516f, 
    -0.01606581f, 0.03892990f, 0.03522595f, -0.05547247f, -0.03563997f, 0.04355760f, -0.00273382f, -0.00554301f, 
    0.00070931f, -0.01178613f, -0.00764078f, -0.03444634f, -0.02077074f, 0.03722603f, -0.02056391f, -0.03325824f, 
    0.04199693f, 0.01560243f, 0.01001031f, -0.05058766f, -0.03938920f, -0.03551318f, -0.04528514f, -0.00720155f, 
    -0.01903581f, 0.02332142f, -0.03165635f, -0.00838338f, 0.01633219f, 0.03361686f, 0.03723405f, 0.01118241f, 
    -0.05606862f, -0.00544847f, -0.04963671f, 0.01154155f, 0.01446482f, -0.02828349f, -0.05060335f, 0.01378469f, 
    0.04297378f, 0.00032651f, -0.04581892f, -0.03972066f, -0.04585215f, -0.01352935f, -0.04341032f, 0.00412000f, 
    0.00092838f, 0.03500896f, -0.03886865f, 0.04135470f, 0.05068882f, -0.04671629f, -0.03990017f, 0.00779172f, 
    0.02684363f, -0.00276811f, 0.03935676f, -0.03450449f, 0.02735911f, -0.04315155f, -0.00479294f, -0.04599380f, 
    0.04198971f, 0.01879673f, 0.03187282f, -0.00624799f, -0.01165894f, -0.01000392f, -0.04593752f, -0.03029340f, 
    -0.01608257f, -0.01177461f, -0.02979548f, 0.00279384f, -0.00522849f, -0.01389920f, -0.04138216f, -0.04562948f, 
    -0.03540083f, -0.01895104f, -0.01116869f, -0.05464867f, -0.00097022f, 0.01984007f, -0.00337357f, 0.00003340f, 
    0.00185310f, -0.04410120f, -0.01748127f, 0.02479835f, -0.00495673f, 0.01225031f, -0.00831767f, 0.02226151f, 
    0.01783381f, -0.02160256f, -0.02714266f, -0.00254391f, -0.00093560f, 0.04267128f, 0.00938074f, -0.03956271f, 
    0.01890757f, -0.02783475f, -0.00885282f, 0.04353123f, 0.04289888f, -0.03165809f, -0.04156980f, 0.00151918f, 
    -0.01457955f, 0.03207458f, -0.04291422f, 0.02168047f, -0.03389939f, -0.04252601f, 0.04024565f, -0.03555991f, 
    -0.04629106f, 0.00344694f, -0.04595325f, 0.02981651f, 0.01009069f, 0.02942307f, -0.03684341f, -0.01315879f, 
    -0.02024104f, -0.00774896f, -0.01766260f, 0.03923368f, 0.01427069f, -0.02039395f, 0.01998804f, -0.05453600f, 
    0.03178439f, -0.04182004f, 0.01692329f, -0.03745690f, 0.00670011f, -0.04045470f, -0.02854314f, 0.01493703f, 
    -0.03844157f, -0.04158335f, -0.00000887f, -0.00948571f, 0.04222798f, 0.03676771f, 0.01942691f, 0.01852559f, 
    0.01608034f, 0.03776051f, 0.00385074f, -0.02842063f, -0.00632947f, -0.01681777f, 0.03949018f, 0.01316729f, 
    -0.05333803f, -0.03599519f, -0.03476429f, 0.03633002f, 0.04314435f, -0.01991077f, -0.00285021f, 0.03828635f, 
    0.01461743f, 0.04311069f, 0.04310637f, -0.03151292f, 0.00409948f, 0.04586950f, 0.01590449f, 0.02070160f, 
    -0.02750805f, -0.01972856f, 0.03670003f, 0.00825686f, -0.05332778f, -0.05085872f, -0.02226886f, 0.03509237f, 
    -0.02292496f, 0.01390304f, 0.03019464f, 0.01406586f, -0.04219354f, -0.03830676f, -0.01925673f, 0.00018403f, 
    0.01725341f, 0.02125245f, 0.03980607f, -0.01233709f, -0.05310012f, -0.02290500f, 0.02129742f, -0.01452663f, 
    -0.02094099f, -0.01144668f, -0.00199214f, 0.04111004f, 0.00433130f, -0.05477696f, 0.01001172f, -0.01797435f, 
    0.02462724f, -0.01051492f, 0.03489068f, -0.00204439f, -0.05268044f, 0.02893007f, -0.01572391f, 0.00957022f, 
    0.00908820f, 0.01735072f, 0.02138383f, -0.04789477f, -0.00372321f, -0.00087195f, 0.00355404f, -0.00000347f, 
    0.00075840f, -0.01943710f, 0.02801077f, 0.02517252f, -0.02900717f, 0.00350562f, 0.04287868f, -0.00750766f, 
    -0.04182170f, -0.00340040f, -0.05197801f, 0.01709063f, -0.04518359f, 0.00140326f, -0.05574763f, -0.00660534f, 
    -0.04863939f, -0.04563486f, 0.01511586f, 0.02771049f, -0.04944281f, 0.01733002f, -0.03901219f, -0.00329697f, 
    -0.03300708f, -0.02306363f, 0.03675195f, -0.02713533f, -0.01915472f, -0.02154957f, -0.03532730f, 0.02835798f, 
    0.01371111f, -0.02892601f, 0.02426409f, -0.00427526f, -0.00309006f, 0.03126432f, -0.00954198f, 0.01204031f, 
    0.03962737f, 0.01714874f, -0.01066939f, -0.00891439f, 0.01293260f, -0.02411450f, -0.02433003f, 0.03762971f, 
    0.00668434f, -0.02960462f, 0.02210796f, 0.01577252f, -0.04102137f, 0.03098554f, -0.03154218f, -0.00252156f, 
    -0.03015434f, -0.04458762f, 0.00097220f, -0.02008843f, 0.02170707f, 0.00243839f, -0.00399556f, 0.01910150f, 
    -0.05493532f, -0.02521762f, -0.03272473f, -0.05274858f, 0.03664890f, 0.00583548f, 0.00477464f, 0.01106684f, 
    0.04464624f, -0.01700547f, -0.01541052f, 0.03237029f, 0.02205961f, 0.04434690f, -0.03650080f, -0.00550365f, 
    -0.02707423f, -0.04378273f, 0.00682710f, 0.00738696f, -0.00611241f, -0.01911899f, -0.05068931f, -0.05582194f, 
    0.16057019f, 0.04630169f, 0.10137614f, -0.23014042f, 0.14432947f, 0.00152378f, -0.01746677f, -0.04139220f, 
    -0.14932053f, 0.01466296f, 0.06663132f, -0.07036212f, -0.42288843f, 0.18721776f, 0.26713812f, -0.10679490f, 
    0.14973366f, 0.06452931f, -0.00354819f, 0.05989224f, 0.02395974f, -0.02638399f, 0.10119296f, 0.03213548f, 
    0.26738510f, -0.03431523f, 0.33496952f, 0.14955097f, -0.16214740f, 0.07173337f, 0.08610728f, 0.06236696f, 
    0.03797500f, 0.04907893f, 0.10503990f, -0.05763578f, -0.05171870f, -0.21592498f, -0.16938943f, -0.29614586f, 
    0.10837239f, 0.06010379f, 0.02129277f, 0.00166663f, -0.06569891f, 0.04340927f, 0.00008505f, 0.11888763f, 
    -0.18245234f, 0.10707916f, -0.10307170f, 0.21806455f, -0.01129074f, 0.08444055f, 0.22910224f, 0.19887461f, 
    0.25142449f, -0.05031758f, 0.14059238f, -0.22927172f, -0.07910042f, -0.27295837f, 0.06750172f, 0.37999815f, 
    0.03707005f, -0.05133879f, -0.00918171f, 0.12561052f, 0.00130849f, -0.03365315f, -0.09771447f, 0.05857063f, 
    -0.16284327f, 0.19664583f, -0.04907181f, 0.29667646f, 0.13655813f, -0.20149180f, 0.00897397f, -0.01675314f, 
    0.07102925f, 0.07714882f, -0.10838267f, -0.02034748f, 0.01580023f, 0.14360619f, -0.16480295f, -0.48813197f, 
    0.08640867f, 0.10222401f, -0.11287569f, -0.12278219f, 0.14196810f, 0.15413861f, -0.02120321f, 0.15557863f, 
    0.18280396f, -0.05587378f, 0.01606587f, 0.41031739f, 0.14585410f, -0.14035465f, 0.01192332f, -0.02391166f, 
    -0.09689651f, 0.12169088f, 0.02419189f, -0.08996792f, 0.12480146f, 0.31993398f, -0.11757659f, -0.09818402f, 
    0.14227495f, 0.10377105f, -0.03323957f, 0.10211293f, -0.11699454f, -0.04587689f, 0.07736267f, 0.03934992f, 
    0.07676917f, -0.07016689f, 0.08441234f, 0.09350430f, -0.17910521f, 0.07464410f, 0.10646422f, -0.07100746f, 
    -0.06960640f, 0.06187280f, -0.16305570f, 0.04240707f, -0.08692231f, -0.11566932f, 0.12516402f, -0.14630988f, 
    0.01522785f, 0.09371030f, 0.02664668f, -0.03244925f, -0.08560954f, 0.12822631f, 0.02409419f, -0.13928261f, 
    0.57493287f, 0.29630777f, 0.14350533f, -0.25547600f, -0.08655310f, 0.10434869f, 0.07796438f, 0.00399238f, 
    -0.03160914f, -0.01378936f, -0.09957054f, -0.03368857f, -0.02598752f, -0.06852822f, 0.09942503f, 0.44937673f, 
    0.15080670f, 0.13838433f, 0.05694137f, 0.01384672f, 0.15716842f, -0.07881245f, 0.01085482f, 0.07141513f, 
    0.45098349f, 0.19163547f, 0.03130420f, 0.09494117f, -0.19213377f, -0.04833447f, 0.03185445f, -0.03488688f, 
    0.04108373f, 0.02087027f, -0.00319520f, 0.00763189f, 0.62977338f, -0.20465355f, -0.04470151f, 0.15169255f, 
    0.05130902f, 0.10179516f, 0.06470530f, 0.15940857f, 0.10334622f, 0.14919069f, 0.01088352f, -0.03317381f, 
    0.20016292f, 0.31214112f, -0.17125189f, 0.09186386f, -0.13362341f, -0.00621744f, 0.02403374f, -0.13989557f, 
    -0.13343586f, -0.04445874f, -0.07160176f, 0.02412888f, -0.08047307f, 0.01201109f, -0.01147273f, 0.08086707f, 
    0.00625567f, 0.07890952f, -0.09371925f, 0.10027763f, 0.24052943f, -0.02885610f, 0.11556837f, 0.04702076f, 
    0.00026791f, -0.14217027f, -0.31749830f, -0.05517013f, 0.01476638f, -0.07806504f, -0.15050457f, 0.00425249f, 
    -0.07343509f, -0.04974953f, 0.03691406f, -0.11666480f, 0.33035955f, 0.21977031f, -0.04952899f, 0.14512342f, 
    0.03328043f, -0.09982397f, 0.08920147f, 0.05393628f, -0.03475608f, 0.03144477f, -0.05462197f, 0.00341337f, 
    0.26626602f, 0.05942306f, -0.27008078f, 0.19354914f, -0.05665132f, 0.05274907f, -0.18285912f, -0.13512719f, 
    -0.02465923f, -0.11887659f, 0.11624981f, -0.01845492f, -0.41248009f, 0.54480541f, 0.09999578f, 0.22131589f, 
    -0.08544691f, 0.09810425f, 0.01321729f, -0.13903850f, 0.19737773f, -0.10227176f, 0.01851687f, -0.05961346f, 
    -0.14086457f, 0.12129928f, -0.00773554f, -0.23551787f, 0.12941600f, -0.02345002f, 0.12732814f, 0.01110872f, 
    -0.06894257f, 0.00355812f, 0.14157423f, 0.03148276f, -0.61988133f, 0.12421374f, -0.04040747f, -0.57052624f, 
    0.20153151f, -0.05238273f, -0.02832418f, -0.05179710f, 0.05213280f, -0.02355293f, 0.01918876f, 0.07013914f, 
    0.15322778f, -0.11756420f, -0.05863772f, 0.25015798f, 0.00847475f, 0.11075912f, -0.01533721f, -0.15661962f, 
    -0.07595834f, 0.06348234f, 0.14621443f, -0.03315518f, -0.46473289f, -0.31972224f, 0.17872067f, 0.07248607f, 
    0.08974380f, 0.06641723f, 0.01970581f, 0.10542202f, 0.02215333f, 0.15031053f, -0.04533776f, -0.05017349f, 
    -0.00932403f, -0.04937221f, 0.10054816f, 0.16065444f, -0.07681735f, -0.12401733f, -0.04916988f, 0.00659876f, 
    0.12946901f, -0.10572368f, 0.04167053f, 0.13909355f, -0.38466427f, 0.26836714f, 0.09652852f, 0.16235302f, 
    0.16720466f, -0.08206299f, 0.01897402f, 0.00390399f, 0.09200108f, -0.07074291f, 0.08190065f, 0.03799080f, 
    -0.23542382f, -0.03882681f, -0.04276652f, -0.36174843f, 0.18413499f, 0.00884088f, 0.04887400f, -0.02299850f, 
    0.04106009f, 0.04241944f, -0.05920373f, 0.09655812f, 0.38549235f, 0.03912570f, -0.31016114f, -0.25291952f, 
    0.18615800f, -0.03444398f, 0.03440608f, -0.05817894f, 0.12176232f, -0.15234803f, 0.02216269f, -0.06832813f, 
    0.00790012f, -0.26097474f, -0.00078254f, -0.23150644f, -0.00957404f, -0.08211234f, -0.11028713f, -0.13085003f, 
    0.02961806f, 0.04069799f, 0.02656802f, 0.05775144f, 0.11576266f, 0.18632931f, 0.36686033f, -0.04165051f, 
    0.17872851f, 0.16529927f, 0.02864579f, 0.06969083f, 0.09125250f, 0.20234570f, -0.13180456f, -0.10900732f, 
    -0.02829601f, -0.00252218f, -0.05873759f, -0.00817417f, -0.04242953f, 0.01356659f, -0.04103009f, -0.03036946f, 
    0.02938770f, -0.00493046f, -0.01040647f, -0.02697012f, -0.00335850f, -0.05461169f, 0.04753292f, -0.05300395f, 
    0.02032252f, -0.03964051f, 0.04047734f, -0.03856053f, 0.00900367f, -0.00984106f, -0.03976832f, -0.01040013f, 
    -0.00559128f, -0.00520539f, -0.03678776f, -0.05078516f, 0.02603402f, -0.05568292f, 0.03587611f, -0.00676500f, 
    -0.03569464f, -0.02303455f, -0.01612566f, 0.01929509f, 0.04320399f, -0.04725165f, -0.05520932f, -0.03225721f, 
    -0.00713243f, -0.02278881f, -0.03966883f, 0.03897573f, 0.04091816f, 0.05296335f, 0.01440218f, 0.02814450f, 
    -0.01762434f, -0.02950963f, 0.04839948f, -0.02171382f, -0.04770305f, 0.03382187f, 0.00190210f, 0.04213856f, 
    -0.04610271f, 0.04305186f, 0.02237818f, -0.04922884f, 0.03721484f, 0.01435915f, 0.04780905f, -0.01010352f, 
    0.01620382f, 0.02988357f, -0.00199803f, 0.04741943f, 0.00486696f, 0.00796148f, 0.04352041f, 0.02308472f, 
    0.01038107f, -0.01954500f, -0.00627060f, -0.01399649f, -0.02031226f, 0.00681681f, 0.03452893f, 0.03083042f, 
    -0.00980767f, -0.04216674f, 0.00104901f, -0.04488954f, -0.04442189f, 0.03552646f, 0.03981013f, -0.00690926f, 
    -0.01617184f, 0.03369327f, -0.02816905f, 0.02693849f, 0.00948625f, -0.02677688f, -0.05998187f, -0.04452630f, 
    -0.00896247f, -0.02859376f, 0.03428664f, 0.03768646f, 0.01558762f, 0.02234490f, 0.03443634f, 0.01505570f, 
    -0.01269518f, 0.00348475f, -0.04046823f, -0.04448339f, 0.02362668f, 0.02019906f, -0.01243496f, -0.01468999f, 
    -0.03094083f, -0.03536340f, -0.01087381f, -0.03378494f, 0.01074910f, -0.01884126f, -0.04650366f, 0.03432336f, 
    -0.02298227f, -0.03802597f, -0.03063682f, 0.02410901f, -0.03383948f, -0.00455354f, 0.01432052f, -0.03709802f, 
    -0.02739686f, -0.05212375f, 0.00359088f, -0.03901039f, 0.03127474f, 0.02401524f, -0.02413188f, 0.01682983f, 
    -0.01068213f, 0.04003032f, 0.03837997f, -0.02370526f, 0.02901420f, 0.00847522f, -0.02363686f, -0.03021753f, 
    -0.01062549f, 0.01734639f, 0.03495480f, -0.00585795f, -0.05676158f, -0.04825547f, -0.00228623f, 0.00432477f, 
    0.01935697f, -0.01009456f, -0.03824921f, -0.00292033f, -0.02682406f, -0.02668625f, -0.01367575f, -0.01945150f, 
    -0.02610010f, -0.05045082f, -0.02555154f, -0.02927258f, 0.03475460f, 0.04127087f, -0.02052224f, -0.03667961f, 
    -0.05502697f, -0.02212005f, -0.04811453f, 0.00679372f, -0.02188185f, 0.01335123f, -0.01428250f, -0.01069465f, 
    0.00297919f, -0.03886703f, 0.01097323f, -0.02477788f, 0.00783766f, -0.02756661f, 0.03988080f, -0.00257047f, 
    -0.02541546f, 0.03029965f, 0.04078964f, 0.01386113f, 0.03076846f, -0.00807671f, 0.02809354f, -0.04862343f, 
    0.00873114f, -0.05634305f, 0.02315736f, -0.03869027f, -0.02285298f, 0.03938926f, -0.05107730f, -0.01218269f, 
    -0.02742585f, 0.01707386f, -0.05565717f, 0.03147699f, 0.02620515f, 0.01138831f, -0.01016971f, 0.01547885f, 
    0.03726286f, 0.01103903f, 0.03227186f, -0.01145673f, -0.03216511f, -0.02006236f, -0.01003079f, -0.01325482f, 
    0.02803494f, 0.02992541f, 0.04178470f, 0.03887880f, 0.02213539f, 0.02677667f, 0.03046317f, -0.01062675f, 
    0.02047234f, -0.05704756f, -0.02341343f, 0.03150561f, -0.01991479f, 0.01482593f, -0.05786220f, -0.01724832f, 
    -0.04110098f, 0.02718588f, -0.03643055f, -0.01083201f, -0.02202771f, -0.04218111f, 0.00651724f, -0.04703021f, 
    -0.03574695f, -0.02475547f, 0.04001049f, -0.04240841f, -0.06087303f, 0.00158030f, -0.05072414f, -0.03277086f, 
    0.03652798f, 0.03999041f, -0.04945591f, -0.04875827f, 0.02609902f, -0.00360650f, 0.01715122f, -0.03064552f, 
    0.05088818f, -0.00028442f, 0.01378635f, 0.04188720f, 0.01149841f, -0.00756661f, 0.03786426f, -0.04901946f, 
    0.01729891f, -0.03937383f, -0.00602126f, -0.03662144f, -0.03594273f, -0.03800043f, -0.01356678f, -0.00384010f, 
    0.00671025f, 0.03308104f, -0.03225851f, -0.04245301f, -0.00852743f, 0.04637986f, -0.03282994f, -0.03425816f, 
    -0.00915790f, -0.03508342f, 0.00021285f, 0.01430732f, -0.03782371f, 0.03009276f, -0.05335869f, -0.00785804f, 
    0.04055559f, -0.00031352f, -0.02052651f, 0.02769604f, 0.01902197f, 0.02948227f, 0.00841595f, 0.03776811f, 
    -0.03932638f, 0.01053795f, -0.01772779f, 0.02442850f, -0.01503637f, -0.03951607f, 0.01751237f, -0.00908609f, 
    0.02405200f, -0.02170607f, -0.03816294f, -0.00842180f, -0.04765720f, -0.04998022f, -0.01307685f, -0.05189360f, 
    -0.02312945f, 0.02137234f, 0.02745651f, -0.02612430f, 0.00006291f, -0.04194941f, 0.01408570f, 0.00250611f, 
    -0.00309985f, -0.00070938f, 0.03601883f, 0.00806525f, -0.06016612f, 0.03076735f, -0.04961316f, -0.04760331f, 
    -0.05190842f, -0.02696005f, 0.01427348f, -0.01589875f, -0.04411586f, -0.05414682f, 0.04436316f, -0.04377704f, 
    -0.03738891f, 0.01552261f, -0.04398629f, -0.03785800f, -0.02360735f, -0.03609700f, -0.00770359f, 0.04017780f, 
    -0.02386108f, -0.03294511f, 0.01799073f, -0.04828044f, 0.01158731f, 0.02830103f, -0.05288903f, -0.00766194f, 
    0.00468541f, -0.03482254f, 0.03388355f, -0.01047457f, -0.00970362f, -0.05244889f, 0.02973329f, 0.00738035f, 
    -0.04285162f, -0.03087206f, -0.03038747f, -0.02098894f, -0.00675974f, 0.03580388f, 0.02167918f, 0.03547119f, 
    -0.01373798f, -0.02561266f, -0.02462818f, -0.04757958f, -0.04576848f, -0.04044830f, 0.00554326f, -0.05587168f, 
    -0.04537854f, 0.01052975f, 0.00170899f, 0.03844722f, 0.01250896f, 0.04552421f, 0.00089231f, -0.03127751f, 
    -0.05264683f, -0.03537177f, 0.01259863f, -0.03820412f, -0.02472655f, -0.01802975f, -0.01517225f, -0.02894582f, 
    0.03396371f, -0.02259196f, 0.03551655f, -0.02729734f, -0.01441484f, 0.02769440f, -0.01418986f, 0.02751178f, 
    -0.04588715f, -0.02398929f, -0.00315256f, -0.01441132f, -0.02616623f, -0.00713404f, -0.01165960f, 0.01660206f, 
    -0.03096039f, 0.01128157f, -0.05144981f, 0.03804535f, -0.05590255f, -0.03801477f, 0.01709956f, -0.05163168f, 
    0.00485123f, -0.05586156f, -0.00323729f, -0.02111404f, 0.02440525f, -0.02590204f, -0.03344764f, -0.03650161f, 
    -0.01199856f, 0.00828649f, -0.02503126f, 0.04212419f, -0.05285157f, -0.03366695f, 0.01231154f, -0.00739970f, 
    0.02942689f, -0.02700795f, 0.00878772f, -0.00423856f, -0.01706797f, -0.03115274f, -0.00454149f, 0.00081705f, 
    0.03544068f, -0.03791480f, -0.00895291f, -0.00702143f, 0.02901079f, 0.01431813f, 0.04037967f, -0.03767564f, 
    -0.00813428f, -0.00225083f, 0.03147840f, -0.00593083f, 0.01521389f, 0.03213831f, 0.04306254f, 0.02696950f, 
    -0.05041387f, 0.01185588f, 0.04240854f, 0.03518258f, 0.01268324f, 0.02122236f, -0.03089580f, -0.01581498f, 
    0.04475374f, -0.03959475f, 0.00431751f, -0.03394105f, -0.05657464f, 0.01263951f, 0.00649510f, 0.04297178f, 
    0.02115703f, 0.01925218f, 0.03644910f, -0.00885211f, -0.04709699f, -0.03728075f, 0.02827906f, 0.03166322f, 
    -0.05232928f, -0.02100194f, 0.03665985f, -0.04764294f, 0.03828309f, -0.00215405f, -0.02548859f, -0.04953992f, 
    -0.04403139f, -0.01789216f, -0.04863445f, -0.01807283f, -0.03701903f, -0.01580757f, 0.02867603f, 0.02343566f, 
    -0.04495607f, 0.00481210f, -0.05384507f, 0.04107274f, 0.04601327f, -0.02393929f, 0.01401311f, 0.01581961f, 
    -0.02282015f, -0.03361523f, -0.01189888f, -0.02639380f, -0.05151282f, -0.04271452f, -0.01203324f, 0.01593936f, 
    0.01749014f, 0.02909476f, -0.01061775f, 0.02734239f, -0.01652005f, -0.01727115f, 0.02799425f, -0.00675037f, 
    0.00574616f, -0.02081394f, -0.03932450f, -0.01415489f, 0.00546220f, 0.03279244f, 0.00448420f, -0.01231002f, 
    -0.03123254f, 0.00553586f, 0.03936384f, 0.04372538f, -0.03090534f, 0.03856022f, -0.01261661f, 0.04134043f, 
    -0.02378430f, -0.04198923f, 0.01034995f, 0.01284194f, 0.01993208f, 0.00128864f, -0.01172036f, 0.02317595f, 
    -0.05339279f, 0.03170727f, 0.03176372f, 0.01736933f, -0.03886186f, -0.01649984f, 0.04199234f, -0.04968777f, 
    -0.01588638f, -0.02616845f, 0.02440561f, -0.03985620f, -0.05266585f, 0.03703704f, 0.01596513f, -0.01053810f, 
    -0.05597670f, 0.03979692f, -0.03561708f, -0.05649908f, 0.01004117f, -0.03220177f, 0.01173802f, -0.01491184f, 
    -0.02811068f, -0.04149989f, -0.05222614f, 0.02301359f, 0.03325975f, 0.00895646f, -0.04381463f, -0.03304166f, 
    0.04094480f, 0.03011398f, -0.04544215f, 0.00259747f, 0.04297870f, 0.02816613f, -0.04442929f, -0.00448927f, 
    0.03335912f, -0.00319897f, 0.00817630f, 0.04549474f, 0.02456301f, -0.05184004f, -0.02228257f, -0.02188351f, 
    -0.03627564f, -0.02213068f, 0.00492322f, 0.01408768f, -0.04951726f, -0.00456324f, 0.02068169f, 0.04515854f, 
    0.04481208f, 0.04451774f, -0.04354826f, -0.04060876f, 0.00534930f, -0.05356275f, -0.00389184f, 0.03257555f, 
    -0.01602549f, -0.03798594f, 0.00071329f, -0.05552064f, 0.01008876f, -0.05400596f, 0.03432196f, -0.04634253f, 
    -0.03080522f, 0.00835819f, -0.05216872f, 0.03771920f, -0.04631823f, 0.01996140f, 0.01237314f, -0.05534053f, 
    0.00582901f, -0.03572411f, -0.00055985f, 0.00410456f, -0.05640301f, 0.02082053f, 0.01136423f, 0.02574340f, 
    -0.04915578f, 0.02788146f, -0.02362295f, 0.02025701f, 0.02740198f, -0.01184347f, 0.03780523f, -0.04160991f, 
    0.00985447f, -0.03469954f, 0.01150163f, -0.04920842f, -0.05138657f, -0.02031444f, 0.03688416f, -0.05587291f, 
    -0.04359875f, 0.01997554f, -0.02394336f, 0.00494413f, -0.04714235f, 0.02530602f, -0.01867503f, 0.00225538f, 
    -0.02979829f, 0.02033456f, -0.03198320f, 0.02400711f, 0.00175297f, -0.03232564f, -0.01840854f, 0.02582710f, 
    -0.01784609f, -0.05651179f, -0.02125398f, -0.01395581f, -0.03644414f, 0.01739895f, 0.03516742f, 0.00914463f, 
    -0.02454417f, 0.00789846f, -0.00053849f, -0.03192289f, -0.05635749f, -0.03898522f, -0.02112891f, -0.01983172f, 
    0.00428395f, -0.01275136f, -0.04960209f, -0.01148346f, -0.05283991f, 0.01108864f, -0.00555662f, -0.00949400f, 
    -0.01126903f, -0.02449457f, -0.04707118f, -0.03047968f, 0.01969590f, -0.01425750f, 0.01716284f, -0.04176876f, 
    -0.05627265f, -0.04615365f, 0.00073676f, -0.04395177f, -0.01181887f, 0.00892593f, 0.00799067f, -0.00516083f, 
    0.01764902f, 0.04824952f, -0.03354404f, -0.01803395f, -0.03344696f, -0.03387876f, 0.04050670f, 0.00163493f, 
    -0.00296704f, 0.01748954f, -0.02630138f, -0.00945666f, -0.05540648f, 0.01546475f, 0.01378696f, -0.04361670f, 
    -0.01143564f, -0.01583357f, 0.00334065f, 0.02513289f, 0.03627786f, -0.03719800f, -0.04609011f, -0.03575188f, 
    -0.00187092f, 0.00809575f, 0.02303075f, -0.00300815f, -0.04657014f, -0.01680329f, -0.02084450f, -0.02517692f, 
    0.04152576f, -0.01532242f, -0.01016681f, -0.00901903f, 0.01564042f, 0.00356360f, -0.03257501f, -0.04555744f, 
    -0.01398181f, 0.03990402f, 0.04039732f, -0.03884889f, 0.02012582f, 0.02407742f, -0.03607336f, 0.01972675f, 
    -0.01843659f, -0.05461602f, 0.02693193f, 0.03653287f, -0.00369485f, 0.00068102f, 0.02275112f, -0.03772430f, 
    -0.01020963f, -0.03605889f, -0.02753364f, 0.03913045f, -0.02088581f, 0.00623849f, 0.03487510f, 0.02664119f, 
    0.47674656f, -0.31725168f, 0.20919679f, 0.22884047f, -0.20100702f, 0.16471505f, -0.15144862f, 0.24650976f, 
    0.08906468f, 0.09158773f, 0.02507707f, 0.03202476f, -0.07734136f, -0.32052526f, 0.31520128f, -0.09366140f, 
    -0.12804620f, 0.00196918f, -0.00269057f, 0.13846546f, 0.12118715f, 0.00448947f, -0.03265028f, 0.20472585f, 
    0.06759387f, -0.13607831f, 0.04080226f, 0.06887259f, -0.05416239f, 0.08914796f, -0.02683978f, -0.24836455f, 
    0.20593216f, 0.08717159f, -0.00503746f, 0.08889391f, -0.70504284f, 0.16811563f, 0.16604893f, -0.07423221f, 
    -0.06125700f, -0.01821384f, 0.02024569f, -0.03913375f, 0.08040974f, 0.17242040f, 0.05444555f, 0.13001497f, 
    0.25801441f, -0.28010070f, 0.08686782f, -0.12929228f, -0.05504549f, 0.02762972f, 0.05911429f, 0.02701095f, 
    0.01702418f, -0.09653609f, 0.06894651f, 0.13117594f, -0.66780436f, 0.09017253f, -0.15213789f, -0.02615341f, 
    0.15317495f, 0.14042364f, 0.02335639f, 0.14237656f, -0.07933352f, 0.04639001f, 0.00354163f, 0.00529211f, 
    -0.17671202f, -0.11827945f, -0.21588032f, 0.21326330f, 0.06393126f, 0.09698875f, 0.13913949f, -0.10415924f, 
    0.02881647f, 0.07699656f, 0.07480469f, -0.11385053f, -0.32094878f, 0.13362132f, -0.02438503f, 0.19609968f, 
    0.11905234f, 0.03338946f, 0.10621188f, 0.01900624f, 0.10130673f, 0.04156236f, 0.06896517f, 0.04582938f, 
    -0.30981380f, 0.33750018f, -0.18342325f, -0.11301532f, -0.02230012f, 0.10980262f, -0.02809438f, 0.03729611f, 
    0.09501553f, 0.03685052f, -0.11307783f, 0.06314725f, 0.05466494f, 0.02426000f, 0.14320430f, 0.01927048f, 
    0.21236604f, 0.19771419f, 0.00251960f, -0.05506344f, 0.05461447f, -0.01334882f, 0.04614530f, 0.12393333f, 
    0.14368223f, 0.28249517f, -0.13028097f, -0.22056924f, -0.16077465f, -0.05006563f, -0.07070467f, -0.07935440f, 
    -0.12891728f, 0.00817480f, -0.05896054f, 0.23441708f, -0.14691833f, -0.14474690f, 0.12240812f, -0.17151909f, 
    -0.00347373f, -0.05007439f, 0.11698812f, 0.02821195f, -0.08140679f, 0.04289548f, 0.02274194f, 0.15230672f, 
    0.51182324f, 0.07386165f, 0.15439028f, 0.21369074f, -0.14321110f, 0.19663024f, 0.00949331f, 0.12261391f, 
    -0.11440123f, -0.06258339f, -0.06224637f, 0.07505319f, 0.42271882f, -0.04886461f, -0.03747812f, -0.23064639f, 
    0.07255941f, -0.05646151f, 0.06462122f, 0.09856409f, -0.10215609f, 0.09425515f, 0.01781828f, -0.14294519f, 
    0.43919781f, 0.07936763f, -0.07795777f, -0.14148563f, -0.20354345f, -0.03308780f, -0.00790675f, -0.03093082f, 
    0.00816835f, 0.03395246f, 0.16482730f, 0.01705543f, -0.17482269f, 0.13837822f, -0.18056451f, -0.15848830f, 
    0.06708224f, 0.09790793f, 0.06648848f, -0.04023785f, 0.05394328f, 0.03452817f, -0.04401127f, 0.04274180f, 
    -0.20269601f, -0.24855177f, 0.07784187f, -0.16807990f, -0.08500769f, -0.05435701f, 0.16314797f, 0.10540063f, 
    -0.02265774f, 0.02664814f, -0.08765472f, 0.01929409f, 0.19196825f, 0.12683721f, -0.06928291f, -0.04448087f, 
    -0.14364816f, 0.05299741f, 0.10748594f, 0.09893913f, -0.13607712f, -0.03488915f, -0.14549895f, -0.04264988f, 
    0.02391421f, -0.10276761f, -0.03807047f, -0.07862749f, -0.18836309f, -0.08249698f, -0.07233387f, 0.12872347f, 
    -0.17639664f, 0.21081574f, -0.03586882f, 0.14444320f, -0.03964153f, 0.12452216f, 0.22931799f, -0.04653089f, 
    -0.02832014f, 0.01187435f, -0.02884472f, -0.01150817f, 0.25997856f, -0.02761786f, 0.15046106f, -0.07816875f, 
    -0.02486025f, 0.20293239f, -0.00327927f, -0.12338635f, -0.13963619f, -0.01346148f, 0.22698848f, -0.00639981f, 
    -0.10288086f, 0.04835275f, 0.11250739f, -0.01971279f, 0.12761231f, -0.43477845f, 0.04916028f, 0.13409251f, 
    0.05320778f, 0.11593685f, 0.08107401f, 0.06245974f, -0.01973735f, -0.07114740f, -0.05244953f, -0.01910923f, 
    -0.35366842f, -0.15160657f, 0.06208516f, 0.06635943f, -0.04644003f, 0.05877711f, -0.01751934f, 0.02783619f, 
    0.16110270f, -0.04805796f, 0.09721392f, 0.08561255f, 0.15507589f, -0.17558107f, -0.05168366f, 0.21751913f, 
    -0.08696447f, 0.04511594f, -0.03415491f, -0.02261872f, 0.03151837f, -0.04848485f, 0.20400250f, 0.02379017f, 
    0.37721914f, 0.17907768f, 0.15706943f, -0.07163320f, -0.07729094f, 0.01235873f, 0.04517435f, 0.04124234f, 
    0.10697493f, -0.01710538f, 0.02910110f, -0.06582493f, -0.39487109f, -0.02112577f, -0.07425901f, 0.27447847f, 
    -0.08618511f, 0.03396833f, 0.07811730f, -0.05556870f, 0.05796214f, 0.18955754f, 0.14439717f, -0.11677966f, 
    0.13940583f, 0.13075821f, -0.00846231f, -0.19113702f, 0.06038127f, -0.02411535f, 0.12533280f, 0.23402567f, 
    -0.01778292f, 0.17514823f, -0.03165197f, 0.02854231f, 0.12074552f, -0.27058372f, 0.16823030f, -0.03059645f, 
    0.01265693f, 0.09662056f, 0.01299254f, 0.01975268f, 0.05896576f, 0.05490855f, -0.03486785f, 0.24586448f, 
    -0.40376166f, -0.05035675f, 0.26641175f, -0.34751385f, -0.10051971f, -0.09925503f, 0.00953904f, 0.12013675f, 
    0.13870206f, 0.02532650f, 0.08437868f, 0.10905528f, 0.14608547f, 0.15715756f, 0.08153970f, 0.07707147f, 
    0.01989933f, -0.02556333f, 0.06738503f, -0.03124987f, 0.00051809f, -0.19348851f, -0.05425269f, -0.16774420f, 
    0.04335427f, 0.07106057f, -0.06575875f, 0.12484839f, -0.02218228f, -0.07176553f, -0.08309965f, -0.01603847f, 
    0.06709322f, 0.03467059f, 0.07017951f, 0.00238149f, -0.22002552f, -0.09177459f, 0.04267566f, 0.10044411f, 
    0.05978072f, 0.02158993f, 0.15596075f, -0.04911003f, 0.02736771f, 0.02165707f, 0.03829604f, 0.14065148f, 
    0.07191958f, -0.13075244f, -0.07754976f, 0.22185665f, 0.02558889f, 0.09155512f, 0.02940743f, -0.01972484f, 
    0.01985030f, 0.03855310f, -0.13109386f, 0.03896381f, 0.32433996f, -0.31555104f, -0.24321505f, 0.16264302f, 
    -0.02654104f, -0.18720242f, 0.00193902f, -0.12643826f, 0.05185178f, 0.08650180f, -0.10157198f, -0.00316592f, 
    0.11758868f, 0.06011047f, -0.00045920f, -0.00426960f, 0.11097942f, 0.00431729f, -0.02603935f, -0.05739209f, 
    0.07051130f, -0.06135897f, -0.09255140f, 0.02269743f, -0.14600140f, 0.11611345f, 0.01908701f, 0.13843913f, 
    -0.02162356f, -0.19521889f, -0.09226093f, -0.09370750f, 0.13170566f, 0.11080078f, 0.03990952f, -0.05169549f, 
    0.00776249f, 0.20988584f, 0.23440984f, -0.11825240f, -0.17430738f, 0.00794835f, 0.00847898f, -0.05736826f, 
    -0.06131169f, -0.08582471f, 0.00733179f, 0.10176196f, 0.14147736f, 0.08990357f, -0.06791800f, -0.31283399f, 
    0.00222709f, -0.09201225f, 0.00097636f, -0.14165764f, -0.02589892f, -0.08446129f, 0.05202527f, -0.04375401f, 
    -0.21941097f, 0.22831807f, -0.07048307f, -0.10650581f, -0.08607160f, 0.00068181f, -0.08040427f, -0.00597170f, 
    -0.04362255f, 0.03750467f, 0.11986838f, -0.00895539f, 0.00275362f, -0.10284981f, -0.02969304f, 0.31951478f, 
    0.12272286f, 0.02314343f, -0.06414530f, -0.01066249f, -0.10313289f, -0.01789821f, 0.11928328f, -0.04332633f, 
    0.09827202f, 0.40279397f, -0.22396231f, -0.23001228f, -0.07179111f, 0.04921405f, 0.00372405f, 0.07691873f, 
    0.03878767f, 0.09714461f, -0.07429127f, -0.06684479f, -0.07338397f, -0.13202044f, -0.10642428f, 0.10999621f, 
    -0.04012097f, -0.05028320f, 0.08043393f, -0.16140072f, 0.26143083f, 0.20191915f, 0.02835350f, -0.10917450f, 
    0.30473766f, 0.54120910f, 0.19713847f, 0.27146712f, -0.01623795f, -0.06222197f, -0.04498260f, 0.08586717f, 
    -0.05179945f, 0.03070184f, 0.08211595f, -0.08006649f, 0.09030078f, 0.23264635f, 0.19704634f, 0.01265939f, 
    -0.05905340f, 0.07423650f, 0.09995618f, 0.08580647f, -0.06034799f, 0.03813731f, -0.00621335f, 0.08219121f, 
    0.05645080f, -0.19553855f, -0.05446801f, 0.19166213f, 0.14139897f, -0.04873544f, -0.03479181f, -0.06936178f, 
    -0.07266013f, 0.04715227f, 0.07817328f, 0.06647436f, 0.04988695f, 0.22226129f, 0.03582343f, -0.13204320f, 
    -0.06844241f, -0.19576982f, -0.02372459f, 0.09721449f, 0.03450483f, 0.02733991f, -0.02762447f, -0.01062204f, 
    0.21019785f, 0.28998744f, 0.39719024f, 0.24015211f, 0.08697788f, 0.02829850f, 0.00489450f, 0.12828054f, 
    -0.09902089f, 0.00323797f, 0.00731914f, -0.10295337f, 0.08189238f, 0.20562769f, -0.04707606f, -0.14488426f, 
    0.04422506f, -0.03052833f, -0.00246443f, -0.07212278f, -0.04232010f, 0.01363349f, 0.03402606f, 0.00237642f, 
    -0.12226857f, 0.06351396f, 0.37162650f, 0.33478627f, -0.02917101f, 0.02959988f, 0.13014622f, 0.10265318f, 
    0.01606518f, 0.02397949f, 0.03625180f, -0.01642056f, 0.38815844f, 0.21128510f, -0.09550076f, -0.19920102f, 
    -0.02964229f, -0.01393752f, 0.05477744f, -0.01722111f, -0.07748383f, -0.04247196f, -0.07546913f, 0.00779459f, 
    0.17269404f, 0.18606204f, 0.40197748f, -0.05728751f, -0.06617612f, 0.17013530f, 0.09416503f, 0.27443844f, 
    0.02358985f, 0.09257279f, -0.05745151f, -0.04742789f, -0.02416327f, -0.05152147f, 0.15748586f, -0.07567525f, 
    0.00340664f, 0.13874847f, -0.10752118f, 0.10410004f, 0.10025232f, 0.05269818f, -0.01091877f, 0.00154321f, 
    0.54445171f, 0.25564280f, 0.35313854f, 0.31869653f, 0.00675765f, -0.10565532f, 0.10793106f, 0.10336050f, 
    -0.01390545f, 0.12397599f, -0.04043044f, 0.01340735f, -0.02860994f, -0.15596434f, -0.27057973f, -0.05079642f, 
    0.00798965f, 0.00673258f, 0.09607080f, 0.09589097f, -0.01128945f, 0.24911876f, -0.05423388f, -0.04576313f, 
    -0.15309416f, -0.22231765f, 0.01442048f, 0.14785233f, 0.10028410f, -0.08523227f, -0.10659777f, -0.05940014f, 
    0.20265472f, -0.04231594f, 0.03303219f, 0.08360406f, 0.56028116f, -0.16210909f, -0.11539464f, 0.33659372f, 
    0.00525026f, 0.02704433f, 0.04556845f, 0.06668745f, -0.00685555f, 0.03446091f, 0.14002064f, -0.02720826f, 
    0.16361639f, 0.01192209f, 0.28635401f, -0.23698694f, 0.10354774f, 0.03008051f, -0.03495301f, -0.01169812f, 
    0.05533876f, 0.01179237f, -0.03098599f, 0.03017726f, -0.37493128f, 0.08874377f, -0.03063229f, 0.07476070f, 
    0.00199293f, 0.00814563f, -0.05612287f, -0.08560716f, 0.16660734f, 0.03670779f, -0.10434099f, 0.00896424f, 
    0.07219138f, 0.07747240f, -0.02016884f, -0.24285035f, -0.01732180f, 0.19978610f, 0.07551451f, 0.02087710f, 
    0.00638128f, -0.05644787f, -0.08400740f, -0.05033717f, 0.07712416f, -0.05436794f, -0.12711550f, -0.08176171f, 
    -0.15223444f, 0.06766897f, -0.01550232f, -0.09872280f, 0.10656491f, 0.03704665f, 0.02293332f, -0.08999538f, 
    0.05407142f, -0.17080431f, -0.03590319f, 0.26014760f, -0.00133005f, -0.02841989f, 0.04249641f, -0.09462627f, 
    0.02559012f, 0.09476428f, 0.15307924f, 0.06968726f, -0.07290659f, -0.24493572f, 0.31554896f, 0.27285117f, 
    -0.09453587f, 0.07193594f, -0.07122663f, 0.05116075f, -0.10675178f, 0.04893073f, -0.05272780f, -0.02541811f, 
    -0.08716018f, 0.15003592f, -0.12483183f, 0.06778931f, -0.06903309f, -0.03407967f, -0.07731337f, 0.03679880f, 
    0.00870483f, -0.03777315f, -0.15608343f, -0.04019314f, -0.13671598f, -0.33339205f, -0.29900607f, 0.07984483f, 
    -0.23371866f, -0.05810475f, 0.03556406f, -0.04688828f, -0.15123428f, 0.00743101f, 0.03784360f, 0.02599701f, 
    0.43738356f, -0.02059810f, -0.29993787f, 0.35066417f, -0.24269401f, -0.18007378f, 0.12540230f, 0.00227294f, 
    0.00381838f, -0.03067966f, -0.00568033f, -0.05838527f, -0.07341449f, 0.20142023f, 0.15842526f, 0.01659562f, 
    -0.17347670f, 0.04061849f, -0.18065482f, 0.00431997f, -0.00134405f, 0.03654342f, 0.09641244f, -0.03548209f, 
    0.10353976f, -0.14854227f, 0.04240077f, 0.07714233f, 0.04635157f, 0.07294713f, 0.20019914f, -0.06351963f, 
    -0.11055896f, -0.00408828f, 0.06207759f, -0.06110541f, 0.13390048f, -0.18392512f, -0.25745553f, -0.03792371f, 
    0.02509816f, 0.15689246f, -0.06289838f, -0.07414167f, -0.20192696f, -0.03386443f, 0.01267197f, -0.04340800f, 
    0.08602926f, 0.32628781f, -0.16926543f, -0.06827979f, -0.16849197f, 0.00718067f, 0.09963159f, -0.02471700f, 
    0.14801194f, 0.15592791f, -0.04140192f, 0.09524805f, 0.06600002f, 0.18641663f, 0.10144092f, -0.10483392f, 
    0.09714009f, 0.13831986f, -0.14558820f, 0.06551547f, -0.08934662f, -0.12528808f, 0.01918245f, 0.02670944f, 
    0.11149392f, 0.34978235f, 0.03742455f, -0.02115020f, 0.05368718f, 0.10446827f, -0.00555539f, 0.01884071f, 
    0.07579524f, 0.05716146f, -0.19888313f, -0.06273171f, 0.04209786f, 0.00206836f, -0.21583781f, -0.00089251f, 
    0.11869376f, -0.04643930f, -0.14021763f, 0.02105554f, -0.02879017f, 0.11721706f, -0.03114337f, -0.03625746f, 
    0.59066778f, -0.10181012f, 0.15915731f, 0.16836332f, 0.05904959f, -0.02504591f, -0.02779668f, -0.02108008f, 
    -0.02197552f, -0.06064903f, 0.01173422f, 0.01740687f, 0.15730305f, 0.00422468f, -0.09974103f, -0.23152514f, 
    0.10285410f, 0.10602707f, -0.16566984f, 0.13029189f, -0.01079704f, -0.04609967f, 0.07704971f, 0.07690816f, 
    0.12867643f, -0.30388153f, 0.10607439f, 0.00482211f, -0.04567394f, 0.02463091f, 0.06269071f, 0.01816549f, 
    0.08162596f, -0.14069724f, 0.14584878f, -0.01897480f, -0.05900384f, -0.34933725f, 0.28129840f, 0.14040387f, 
    0.02576719f, -0.09622218f, -0.03177447f, -0.03571416f, -0.08172316f, 0.02946012f, -0.02218833f, -0.15042678f, 
    0.32089329f, -0.09849598f, 0.01704499f, -0.21001829f, -0.09244733f, 0.05947192f, 0.20800357f, 0.05903430f, 
    0.03073612f, -0.05300955f, -0.15927663f, 0.05014534f, -0.51581842f, -0.11120962f, 0.19754599f, -0.16594608f, 
    -0.00790069f, -0.11028984f, -0.05536271f, 0.03694131f, 0.06875255f, 0.05065907f, 0.10245039f, 0.11720230f, 
    0.44094628f, 0.11831018f, 0.05181120f, -0.39418939f, 0.03481587f, 0.16284782f, -0.03266616f, 0.00390433f, 
    0.03500880f, 0.11453599f, 0.05745544f, 0.14944787f, 0.02604066f, -0.33796459f, 0.17414971f, 0.29733688f, 
    0.19121259f, 0.11851931f, -0.03421067f, -0.02338899f, 0.22673509f, 0.11694127f, 0.05730806f, 0.06474416f, 
    -0.01133624f, 0.38436890f, -0.09313769f, -0.33762002f, 0.06502593f, 0.12836806f, 0.05815382f, 0.04167829f, 
    -0.10554034f, 0.05198882f, 0.08860113f, 0.02737877f, -0.12514967f, 0.09795401f, 0.29682818f, -0.06826174f, 
    0.01252224f, 0.00993045f, -0.01059113f, -0.09959674f, 0.04274756f, 0.21413717f, 0.01780246f, -0.05441577f, 
    -0.36115873f, -0.27655393f, 0.02616716f, 0.09447939f, 0.04961689f, -0.01431954f, 0.20586099f, 0.03234823f, 
    0.06282897f, -0.06582523f, -0.09093840f, -0.11651149f, 0.03743225f, 0.11898537f, -0.05366300f, -0.14872111f, 
    0.07128932f, -0.13115279f, 0.16626459f, -0.15270895f, -0.15695293f, -0.11469498f, -0.16913366f, -0.05467146f, 
    0.36271891f, 0.10381232f, -0.14811823f, -0.23621456f, 0.24893524f, 0.04147747f, 0.03114048f, -0.01326554f, 
    0.02644084f, -0.22324562f, -0.02135152f, -0.00194014f, -0.26804203f, 0.03586802f, 0.04504847f, 0.14305073f, 
    -0.00591236f, -0.01398672f, -0.06180300f, 0.00647143f, 0.12184359f, -0.10787763f, 0.04886843f, 0.10720764f, 
    0.10317372f, 0.08441430f, 0.05578527f, -0.11730951f, 0.02724179f, 0.14464350f, -0.07187328f, -0.06263406f, 
    -0.03833701f, -0.08289818f, -0.00133103f, -0.16724636f, -0.29072523f, -0.01959514f, -0.03919268f, 0.34275970f, 
    -0.05167876f, -0.05340351f, -0.05156118f, -0.21449581f, 0.00026657f, 0.05826338f, 0.12706248f, -0.00362961f, 
    -0.14840288f, -0.18178065f, -0.10128666f, 0.00927746f, -0.06797833f, 0.05290953f, -0.07642278f, -0.07032582f, 
    -0.14567661f, 0.14061880f, -0.02888396f, -0.00605787f, 0.40454781f, -0.00060161f, -0.02768107f, 0.12683605f, 
    -0.02297582f, -0.26354030f, 0.05434823f, -0.05063212f, -0.04086398f, -0.01702540f, -0.17803417f, 0.10601158f, 
    -0.07950877f, 0.02654896f, 0.12973127f, 0.22794023f, 0.05822531f, -0.09721570f, 0.11455561f, 0.08984070f, 
    0.00949350f, 0.12636273f, 0.00725687f, 0.10119570f, -0.20583010f, 0.21910216f, -0.10912481f, -0.19297475f, 
    -0.10349908f, 0.25034806f, -0.11095075f, 0.08477526f, 0.01443374f, -0.03516189f, 0.01446406f, -0.02659029f, 
    0.05696651f, 0.15392256f, -0.08466021f, -0.08008107f, -0.00068237f, -0.11570092f, -0.07868004f, -0.03478151f, 
    0.04763169f, -0.16631757f, 0.01959116f, 0.02166598f, 0.08375002f, -0.17549911f, -0.16818339f, -0.08790648f, 
    -0.07391568f, -0.05911046f, 0.11810866f, -0.06999719f, 0.02985040f, -0.00743074f, 0.05215257f, -0.05721757f, 
    0.31340036f, -0.18437277f, 0.11249059f, 0.15000601f, -0.06283527f, -0.01384351f, -0.02142199f, -0.08429390f, 
    0.07253645f, 0.02577526f, -0.07950540f, 0.01707927f, 0.29901746f, 0.13589945f, 0.07529255f, 0.11687268f, 
    0.06882379f, -0.12628593f, 0.06035698f, 0.01722895f, 0.05306828f, 0.10836050f, -0.07161818f, -0.09713257f, 
    -0.04618991f, 0.02570258f, 0.01798743f, 0.01307762f, -0.04671721f, -0.05291719f, 0.00288792f, 0.00774668f, 
    -0.02621423f, -0.01201681f, 0.02695874f, -0.01742079f, -0.03160184f, 0.03809250f, 0.03181302f, -0.03265282f, 
    0.03261149f, -0.05761049f, 0.02130517f, -0.02154179f, 0.03746485f, -0.00597733f, -0.02780824f, -0.03225867f, 
    0.02393115f, 0.03161278f, -0.04022222f, -0.03479188f, 0.00171385f, -0.02246760f, -0.02920268f, -0.05448679f, 
    -0.00275058f, -0.00313793f, -0.02700798f, -0.01509142f, 0.01055433f, 0.04013006f, -0.04053013f, -0.03884429f, 
    0.03877662f, -0.03607699f, 0.02505186f, 0.00307754f, -0.00213183f, -0.04671541f, 0.02425053f, -0.04266608f, 
    0.03002089f, -0.01205736f, -0.05640806f, -0.02262499f, -0.01179163f, -0.00430795f, -0.06052886f, -0.01080506f, 
    0.00688103f, -0.00199962f, 0.01656042f, 0.00227281f, -0.02430592f, -0.04484949f, 0.03190323f, -0.04031614f, 
    -0.01365575f, 0.02851840f, -0.01880178f, -0.01303043f, -0.01742627f, -0.00816262f, -0.04099345f, 0.02339114f, 
    0.02394878f, 0.02473824f, 0.03919100f, -0.05586074f, 0.01893974f, -0.00215458f, 0.03394403f, 0.02723088f, 
    0.01225929f, -0.04025507f, 0.00023724f, 0.03084110f, -0.01775298f, -0.04643999f, -0.04596910f, -0.03072160f, 
    0.02731306f, -0.03470420f, -0.05248370f, -0.04057878f, 0.00406822f, -0.01609151f, -0.04349503f, -0.05524644f, 
    -0.01894505f, 0.00301298f, -0.03409669f, 0.02984406f, 0.02088578f, 0.00522385f, 0.01694330f, 0.04138044f, 
    -0.05555073f, -0.00365288f, 0.01636968f, -0.01853373f, 0.01902165f, 0.02181036f, -0.01651886f, -0.01459683f, 
    -0.04797418f, -0.01735588f, -0.03500178f, -0.02460690f, 0.01654891f, 0.01856557f, -0.04195129f, -0.05622306f, 
    0.00280007f, -0.02467356f, -0.00518641f, -0.02461505f, -0.02517148f, 0.02046365f, 0.03453723f, -0.05887325f, 
    0.02533908f, -0.02472045f, -0.06009961f, -0.03335676f, -0.02265602f, 0.03243782f, -0.04496038f, 0.03124293f, 
    -0.04166850f, 0.01392823f, -0.04319482f, -0.00576112f, -0.05509525f, 0.02885956f, -0.00850535f, -0.04282901f, 
    -0.00841588f, -0.02266051f, 0.04002185f, 0.02227854f, -0.03007479f, -0.05245014f, -0.04417087f, 0.02181931f, 
    0.01920861f, 0.00613162f, -0.03616037f, 0.00512803f, -0.02654854f, 0.00986349f, -0.03428009f, -0.01492509f, 
    -0.04068584f, -0.03524433f, -0.02995031f, 0.01461052f, -0.01016598f, 0.02833823f, -0.05077220f, -0.00058027f, 
    -0.02963670f, -0.04783289f, -0.05459644f, 0.02944188f, 0.00205261f, 0.01701552f, -0.06047740f, 0.01748640f, 
    0.01369694f, -0.05798669f, 0.04054338f, 0.01796818f, 0.00622231f, 0.03382233f, 0.01962819f, 0.00834237f, 
    0.00290716f, -0.01194667f, -0.00793252f, 0.00406475f, 0.03056066f, 0.03153643f, -0.04502678f, -0.05077708f, 
    0.01677413f, -0.00004626f, -0.03986625f, -0.01540647f, -0.03146619f, 0.01567644f, 0.02426394f, -0.04221770f, 
    -0.03233267f, -0.02846270f, -0.04078155f, 0.02775344f, -0.04352793f, 0.02234937f, -0.03637004f, -0.05206985f, 
    -0.02506029f, -0.02970518f, 0.00913470f, -0.03588969f, 0.01500255f, -0.01894375f, 0.01353361f, 0.00289000f, 
    -0.03491051f, -0.04425333f, -0.03254591f, -0.00508249f, -0.03780047f, 0.02487795f, -0.05051431f, 0.01923887f, 
    0.01817292f, -0.02911351f, 0.00462197f, 0.02383814f, 0.00142121f, 0.01857114f, -0.02841480f, -0.01389294f, 
    -0.02591572f, 0.00605930f, 0.00097939f, 0.01346023f, -0.02745200f, 0.00723498f, -0.02298976f, 0.00014513f, 
    0.02610385f, 0.03559980f, 0.02100733f, -0.02539741f, 0.00157812f, 0.01437512f, -0.04332567f, 0.03948035f, 
    -0.01593416f, 0.00326624f, -0.03712198f, -0.04618338f, -0.05899948f, -0.01865664f, -0.04923137f, -0.02785043f, 
    -0.04132461f, -0.01167144f, 0.03440001f, -0.03875330f, -0.00661031f, 0.02619287f, 0.03645686f, -0.01977213f, 
    -0.01941073f, 0.02688247f, -0.01484611f, -0.01082460f, -0.02574573f, -0.02581350f, -0.03205823f, -0.05574752f, 
    0.00224903f, -0.01061264f, 0.01834685f, 0.00281745f, 0.04122052f, -0.04042877f, 0.03214088f, 0.02779572f, 
    -0.03204544f, -0.01997435f, 0.01557903f, -0.00031161f, -0.05238797f, 0.02015750f, 0.03324500f, -0.02595048f, 
    -0.02903736f, 0.00343108f, -0.05762920f, 0.03072020f, 0.01472189f, -0.05971142f, -0.02612411f, -0.03095658f, 
    -0.00647808f, 0.01178333f, 0.01246070f, 0.00210569f, 0.01592596f, 0.00246628f, 0.03559568f, -0.01125872f, 
    0.01175952f, 0.02310774f, 0.03828884f, -0.05356699f, -0.03019232f, 0.01475223f, 0.02473835f, 0.01691667f, 
    0.01574222f, 0.02962630f, 0.01622014f, -0.00064579f, 0.02709282f, 0.01661555f, 0.01292431f, -0.00438998f, 
    -0.01448510f, 0.03369744f, -0.03216919f, -0.05712742f, -0.03232828f, -0.00893179f, 0.00526965f, -0.00398852f, 
    -0.01634938f, -0.02054334f, -0.05323014f, -0.05903190f, -0.04590383f, 0.02061985f, -0.05107355f, -0.02965184f, 
    0.03246963f, -0.03181512f, -0.00768546f, 0.01727541f, -0.00348224f, 0.00573744f, -0.04051180f, -0.05741215f, 
    -0.01031246f, 0.01167462f, 0.01315850f, 0.00731761f, -0.04481019f, -0.02976263f, -0.00793524f, -0.01427425f, 
    -0.05787002f, 0.03489141f, 0.00307791f, -0.03801258f, -0.01431417f, 0.01069892f, 0.03173942f, -0.01931896f, 
    0.02902465f, -0.04054194f, -0.00865073f, -0.00546257f, 0.03999501f, -0.03807896f, 0.04005415f, -0.01700368f, 
    -0.04871577f, 0.02722281f, 0.00646180f, -0.02248678f, -0.04777656f, 0.02427360f, -0.02156321f, -0.04421285f, 
    0.03059224f, 0.02555525f, -0.04513258f, 0.04069715f, -0.03562218f, -0.01675499f, 0.00644288f, -0.00374989f, 
    0.21320875f, 0.06117806f, 0.05935074f, -0.30116555f, 0.08615752f, -0.04876868f, 0.12003719f, 0.05966775f, 
    0.04578363f, 0.14113070f, 0.03709913f, 0.01928556f, -0.11948587f, 0.02705441f, -0.26179606f, 0.24384651f, 
    0.05696920f, -0.09469404f, 0.10055744f, -0.21972872f, -0.05477246f, -0.04131671f, -0.02413811f, 0.15973173f, 
    0.48160470f, 0.10139144f, -0.02734182f, 0.07302558f, -0.07297876f, -0.01074746f, -0.15445279f, 0.06307539f, 
    -0.07730857f, -0.21991123f, -0.08691010f, 0.10249749f, -0.04939328f, 0.04529353f, -0.04950052f, -0.11146643f, 
    0.28831831f, 0.06474237f, -0.05084232f, -0.08280971f, 0.05566064f, -0.03501055f, 0.05146530f, 0.00633585f, 
    -0.24931361f, 0.28807035f, 0.07254454f, 0.23438506f, 0.13596329f, 0.06457008f, 0.01042396f, 0.12901822f, 
    0.21244951f, 0.14944886f, 0.05415212f, -0.10816808f, 0.66502178f, -0.36850303f, -0.00024208f, 0.08547977f, 
    0.00304423f, 0.05568236f, -0.05343152f, 0.03514081f, -0.09831919f, 0.02803047f, -0.08350826f, 0.07427235f, 
    -0.17444378f, 0.14334126f, 0.23048320f, 0.34038398f, -0.15399317f, 0.02949783f, 0.06893195f, 0.24944490f, 
    0.12572628f, 0.08898906f, 0.03144163f, -0.08575101f, -0.29562926f, 0.08657508f, 0.22171633f, -0.27018073f, 
    0.16656601f, 0.08148815f, -0.07191540f, -0.09013039f, -0.04364236f, 0.15915135f, 0.03060779f, -0.10210085f, 
    0.31886402f, -0.29078183f, -0.08303947f, -0.03198340f, 0.10995547f, -0.03081525f, 0.01422354f, 0.24205916f, 
    -0.03119916f, 0.13085563f, -0.06592675f, 0.26151627f, -0.39175072f, -0.16310330f, -0.22597256f, -0.21287873f, 
    0.11580448f, 0.03999009f, 0.07277469f, -0.09830848f, 0.17890501f, 0.08363314f, 0.12414242f, -0.01065776f, 
    -0.08485800f, -0.28808197f, 0.12815507f, 0.32980466f, -0.08635253f, -0.07088130f, 0.11224473f, 0.35233274f, 
    -0.09913480f, -0.02307201f, 0.13784912f, -0.04676608f, 0.52407241f, -0.06785245f, 0.11512516f, 0.03569262f, 
    -0.01559633f, -0.08134996f, -0.04617941f, 0.09871644f, -0.05855205f, 0.20254779f, 0.16172618f, 0.06654409f, 
    0.02030561f, 0.21355033f, 0.01733084f, -0.02132516f, 0.13575208f, 0.10658558f, 0.11140821f, 0.06239154f, 
    0.09627431f, 0.06551427f, 0.00896831f, -0.17977098f, 0.15824406f, 0.28256810f, -0.21991405f, 0.01548565f, 
    -0.02447840f, -0.05328040f, -0.22355442f, 0.01324712f, -0.09225588f, -0.03347649f, 0.08462130f, 0.00516504f, 
    -0.30621213f, -0.09801842f, 0.26747775f, 0.02816090f, -0.05744966f, -0.09292422f, -0.03390547f, -0.01018912f, 
    -0.08101581f, 0.13489181f, -0.01119352f, 0.16053727f, 0.60451847f, -0.16215655f, -0.09585624f, -0.01426641f, 
    0.02089854f, 0.02155387f, 0.02557451f, -0.08686447f, -0.03827881f, 0.07004182f, 0.01148470f, 0.04574845f, 
    -0.46841535f, -0.01062022f, 0.20989609f, 0.26656258f, -0.09354865f, -0.06490169f, 0.06241272f, 0.16516356f, 
    -0.05990720f, 0.03117286f, 0.11629574f, 0.15285884f, 0.03196094f, 0.37374800f, 0.04390065f, 0.11138233f, 
    0.05438434f, 0.06692005f, -0.02505710f, -0.09302445f, -0.00481145f, 0.00002246f, -0.00496810f, 0.03712252f, 
    0.38908082f, 0.02399263f, -0.01099965f, -0.20466366f, -0.05474903f, -0.02643903f, 0.17034474f, 0.00757814f, 
    -0.11785083f, -0.18102928f, -0.16807464f, 0.01269526f, 0.22891283f, 0.08671923f, -0.04409522f, -0.19023582f, 
    0.23177382f, -0.01936218f, -0.04544472f, -0.03867195f, 0.11594811f, -0.06623375f, -0.11209902f, -0.22601545f, 
    -0.10735464f, 0.01001469f, -0.04474778f, 0.13100025f, -0.05944287f, -0.00807262f, 0.08628720f, 0.14674439f, 
    -0.05101855f, 0.04275419f, -0.00304357f, 0.11583022f, -0.12861931f, 0.32766786f, 0.00204534f, 0.39230371f, 
    0.02677062f, 0.02572427f, -0.13656180f, -0.04931089f, 0.11666688f, 0.02640145f, 0.23039059f, 0.03909348f, 
    -0.14847501f, 0.28218412f, -0.06831826f, -0.18108672f, 0.03457964f, 0.14248770f, -0.00545408f, -0.19398402f, 
    -0.17690083f, -0.15912102f, 0.07240213f, -0.24769603f, -0.17644742f, 0.17850907f, 0.15541022f, -0.26014096f, 
    0.14619170f, 0.03397233f, 0.04058641f, 0.00926483f, -0.01739538f, 0.00523032f, 0.19658767f, 0.08808829f, 
    0.11431558f, -0.07607692f, -0.16266198f, -0.24724351f, 0.09676017f, -0.02288390f, 0.00641480f, -0.05622087f, 
    0.09778421f, 0.12263903f, 0.13503250f, 0.03717846f, 0.22196275f, 0.19358976f, 0.09674071f, -0.61307597f, 
    0.02906067f, 0.19267443f, -0.02477697f, 0.03828236f, -0.12413608f, -0.13312913f, -0.09247355f, -0.05389220f, 
    0.38717312f, -0.03380498f, 0.01605269f, -0.00711609f, -0.02427974f, -0.01095216f, 0.14519815f, -0.06485283f, 
    0.02768243f, 0.06068921f, 0.19692707f, 0.11187719f, -0.23537612f, 0.00176649f, -0.05565729f, -0.03893813f, 
    0.15705730f, 0.18634465f, 0.13862714f, -0.18690993f, 0.10941406f, 0.00218127f, 0.10274838f, 0.07110652f, 
    -0.18910065f, 0.18631975f, -0.08319173f, -0.03732171f, 0.40311864f, -0.10720196f, -0.13828577f, -0.11751714f, 
    -0.03230362f, -0.05703520f, -0.08003341f, -0.19319814f, 0.01766251f, 0.09982545f, 0.00288445f, -0.36874685f, 
    0.08822653f, 0.18766189f, 0.03560412f, -0.09358365f, 0.04479735f, 0.00961663f, -0.04150795f, 0.08302825f, 
    0.57794070f, -0.02474416f, -0.15196025f, -0.04553836f, -0.01016587f, 0.10568243f, 0.01050327f, 0.21283858f, 
    -0.10091256f, 0.05907477f, 0.00092390f, 0.07036029f, -0.09133121f, 0.08385564f, 0.22568133f, -0.06100221f, 
    -0.07966875f, 0.06113870f, 0.12453783f, 0.02711668f, 0.07754605f, 0.09859968f, -0.04889170f, 0.10118781f, 
    -0.00602462f, 0.00700371f, -0.01360024f, 0.03966083f, -0.05387633f, -0.03494827f, -0.01069718f, -0.02856966f, 
    -0.04681331f, 0.02723633f, -0.04167623f, 0.00064041f, -0.03768313f, 0.01724441f, -0.00477644f, -0.04296439f, 
    0.01595338f, -0.02643467f, -0.03335050f, 0.01379626f, 0.04022314f, -0.03149195f, 0.01858882f, -0.05333478f, 
    0.02447075f, -0.04007130f, 0.00702512f, -0.01496021f, 0.03743992f, 0.01994159f, 0.01712021f, 0.00967517f, 
    0.00027231f, 0.03697406f, 0.03643664f, -0.03282560f, 0.00729653f, -0.03493187f, 0.02885637f, -0.05652226f, 
    0.02692853f, 0.04239022f, 0.01490862f, 0.00431926f, -0.02886659f, -0.00302977f, 0.04745767f, -0.03297972f, 
    -0.04811062f, -0.05688050f, -0.05269347f, -0.03912279f, -0.03631299f, -0.00785028f, 0.03764606f, 0.03320672f, 
    0.03539879f, 0.01663578f, 0.02996169f, -0.04001057f, -0.05448435f, -0.04444369f, -0.02419799f, 0.03925785f, 
    0.03909475f, -0.04407757f, 0.01270045f, -0.00992440f, -0.02490154f, -0.04705143f, 0.01599753f, 0.02850553f, 
    0.02024250f, -0.02405125f, -0.05861369f, 0.00795423f, -0.01019258f, 0.03624765f, 0.01688995f, 0.02761636f, 
    0.00936154f, -0.05422807f, -0.00696061f, -0.03148593f, 0.01056059f, -0.03877930f, -0.00880249f, 0.00934102f, 
    0.01254939f, -0.03219666f, -0.00396018f, -0.05392299f, 0.04236494f, -0.00229497f, -0.02479314f, -0.03523245f, 
    -0.02860930f, -0.03424426f, -0.00813526f, 0.02177772f, 0.03894161f, -0.05492832f, 0.02354455f, 0.02975773f, 
    -0.05526870f, -0.04722609f, 0.02644983f, 0.03950619f, 0.00780929f, 0.00805190f, -0.03843196f, -0.04844969f, 
    0.01146787f, -0.01092533f, 0.04237955f, -0.05371213f, -0.03809900f, 0.02836726f, 0.02177365f, 0.02754667f, 
    -0.02968079f, 0.03927247f, 0.02730329f, 0.03799292f, 0.03612156f, 0.00538553f, 0.01864812f, 0.01515713f, 
    -0.03870114f, 0.05353848f, -0.01278316f, -0.00830352f, 0.01026953f, -0.04038064f, -0.05362269f, -0.05031177f, 
    0.02989072f, 0.04157124f, 0.01459561f, -0.04817106f, 0.03505260f, 0.00944081f, 0.00887518f, -0.01957308f, 
    0.00651855f, -0.06316169f, -0.01721741f, -0.04060527f, 0.00553880f, 0.04121127f, 0.04029933f, 0.02935022f, 
    -0.05159077f, 0.01640778f, -0.00056868f, 0.03956788f, 0.03563377f, -0.00397937f, 0.04734232f, 0.04396393f, 
    0.03418336f, 0.02686869f, -0.02133377f, 0.02774078f, -0.04737636f, 0.01500517f, -0.05224955f, -0.00094796f, 
    -0.03131741f, 0.00010925f, -0.03278461f, -0.01796786f, -0.00275067f, -0.04973399f, 0.02570235f, -0.01588402f, 
    -0.03889319f, -0.04477946f, -0.05437173f, -0.01165804f, -0.04414318f, 0.03928247f, 0.00848399f, -0.02761658f, 
    -0.04566285f, -0.03245448f, -0.00917864f, -0.05890446f, -0.00839364f, 0.02537304f, -0.03176763f, -0.03868563f, 
    -0.01995966f, -0.06197915f, 0.04438380f, -0.02789959f, -0.02218017f, 0.02129345f, -0.01919401f, 0.00525165f, 
    0.03796587f, -0.02204338f, -0.04057798f, 0.02570483f, -0.01138018f, -0.02281020f, -0.03532960f, 0.00941555f, 
    0.02609518f, 0.03683681f, 0.03015631f, -0.03078990f, 0.01890358f, -0.00862467f, 0.04612020f, -0.03225391f, 
    -0.04630554f, -0.05411900f, -0.04834154f, 0.02510739f, 0.00441160f, -0.03836698f, 0.00447303f, 0.00102090f, 
    -0.04488179f, -0.01594435f, 0.02669737f, 0.03473662f, 0.00226985f, -0.00704177f, -0.04511833f, 0.02279459f, 
    0.00141865f, 0.00140676f, 0.00169595f, 0.03486985f, 0.04207589f, -0.02614532f, -0.04725469f, -0.01108444f, 
    -0.03439042f, 0.02076034f, 0.02000044f, -0.01515092f, 0.03183971f, 0.03051999f, 0.02518972f, 0.01433565f, 
    -0.02319030f, -0.03497053f, -0.02467247f, 0.03324959f, -0.01201431f, 0.03140153f, -0.03034899f, 0.03872048f, 
    -0.01572400f, 0.03055194f, -0.04436608f, 0.03376390f, -0.05550777f, -0.01790470f, 0.00803956f, -0.00926156f, 
    -0.05061713f, -0.01385077f, 0.00911585f, 0.03832807f, -0.02264922f, -0.02251742f, -0.05241716f, -0.02256895f, 
    -0.02867282f, -0.04153730f, 0.03597844f, -0.03181719f, -0.04624247f, -0.00414829f, -0.00651113f, -0.05761986f, 
    -0.03103837f, -0.03886598f, 0.02889050f, 0.00873271f, -0.02766396f, 0.02241599f, 0.02030942f, -0.01453360f, 
    -0.04132870f, -0.01766137f, 0.02687155f, -0.00923150f, -0.01100370f, 0.02886864f, 0.02325924f, -0.02301851f, 
    0.02202389f, -0.00203176f, -0.05064438f, -0.00308601f, -0.03195130f, 0.00165307f, -0.03080052f, 0.01804195f, 
    -0.01482021f, 0.02490377f, -0.04833932f, -0.01821737f, -0.01776353f, 0.04815946f, 0.04438888f, -0.05583003f, 
    -0.02608209f, -0.04481002f, -0.05192825f, 0.03970814f, 0.03446903f, -0.05524312f, -0.01089276f, -0.01917283f, 
    0.03148103f, 0.01806846f, 0.03742042f, 0.02281074f, -0.01762271f, -0.04950479f, 0.03090541f, 0.01831001f, 
    -0.01975670f, -0.01133506f, -0.02626004f, 0.01470735f, 0.02581025f, -0.04910393f, -0.01040112f, 0.02962161f, 
    0.04378631f, -0.04966182f, -0.01806013f, -0.03473010f, 0.03258985f, 0.03119584f, -0.00061174f, -0.01816615f, 
    0.00060013f, 0.02524189f, -0.02315607f, 0.04093541f, 0.02788026f, -0.04104684f, -0.05373779f, -0.01215274f, 
    -0.03448903f, 0.03036596f, -0.03391855f, -0.03883497f, 0.03760242f, 0.04308453f, 0.04455514f, -0.02730804f, 
    -0.02932167f, -0.05297402f, 0.04078449f, -0.04302681f, -0.03376291f, 0.01334685f, -0.04757863f, -0.00640888f, 
    0.00041348f, -0.00870983f, -0.01338569f, -0.05192776f, 0.01244017f, 0.01994388f, -0.02903146f, -0.04188224f, 
    -0.02309574f, 0.04406372f, -0.01977241f, -0.04759822f, -0.03894186f, -0.00556623f, 0.01302038f, 0.02257415f, 
    -0.03439098f, 0.01771382f, 0.00758288f, -0.02358579f, -0.02290977f, -0.01484850f, 0.03440702f, -0.02269701f, 
    -0.03894278f, -0.00083922f, 0.03628724f, -0.00370328f, 0.02436124f, -0.04903988f, -0.05307487f, 0.01608668f, 
    0.02517390f, 0.01408553f, 0.02723086f, 0.03297707f, -0.04286876f, 0.00589690f, -0.05160954f, 0.00359751f, 
    -0.01271704f, -0.02611063f, -0.01383539f, -0.03881132f, -0.04544069f, -0.01849043f, -0.04280978f, 0.01701416f, 
    -0.03913263f, 0.01647847f, 0.02067891f, -0.05411854f, 0.02907016f, -0.04116401f, -0.00041796f, -0.02660231f, 
    -0.01888590f, -0.00339361f, -0.02845374f, -0.00636926f, -0.04431377f, 0.02412681f, 0.03264184f, 0.02901013f, 
    -0.03028139f, -0.04539965f, -0.03176625f, -0.02627726f, -0.04921624f, 0.00660659f, 0.02225806f, 0.03080145f, 
    -0.02434385f, -0.02188327f, 0.01574918f, -0.01971280f, -0.01204482f, -0.03948665f, -0.04262592f, 0.03753566f, 
    -0.00808311f, -0.04297729f, -0.02707510f, -0.04088160f, 0.02825955f, 0.01465277f, 0.01848787f, -0.03371480f, 
    0.00576291f, -0.01631262f, 0.01863595f, -0.04265980f, 0.00246033f, -0.01791051f, 0.03310252f, -0.02518339f, 
    -0.03358637f, -0.01547015f, -0.01892708f, 0.00168454f, 0.02527658f, -0.04822852f, -0.01458014f, -0.04500963f, 
    -0.05096804f, 0.02545607f, -0.00561613f, -0.04097682f, -0.03686862f, -0.00468310f, -0.01571329f, 0.00233631f, 
    0.03603275f, -0.01317404f, -0.03487713f, -0.00440365f, -0.04299511f, -0.01602311f, -0.05102054f, -0.02066007f, 
    0.04698865f, -0.02083127f, -0.03332469f, 0.03713972f, 0.03675417f, -0.04659741f, 0.01575012f, -0.03490176f, 
    -0.04100635f, -0.03100557f, -0.01166561f, -0.01437619f, -0.01611806f, 0.01442930f, -0.05412868f, -0.02953459f, 
    -0.02513433f, 0.02731678f, -0.01862176f, 0.02812712f, 0.03884914f, 0.02228636f, 0.00850012f, 0.04028842f, 
    -0.03224020f, 0.00199430f, 0.00545820f, 0.02441056f, -0.04889281f, 0.01698786f, -0.00892749f, 0.01111828f, 
    -0.05450223f, -0.00741297f, -0.05060075f, 0.00394409f, 0.00631126f, 0.01298367f, -0.01325724f, -0.01955657f, 
    0.02322526f, 0.02861569f, -0.01575941f, -0.00346344f, -0.02370408f, -0.02949485f, -0.01712644f, -0.05522678f, 
    0.03018587f, -0.03021751f, 0.04312973f, -0.00605516f, -0.03661758f, -0.04113650f, 0.02308781f, -0.02822937f, 
    -0.05315605f, -0.02196341f, 0.02788256f, -0.02772810f, -0.04472545f, 0.00277630f, -0.01297737f, 0.02233897f, 
    -0.03555701f, -0.02905637f, -0.00395781f, -0.04729565f, -0.04836418f, 0.00190379f, 0.00773936f, -0.05250390f, 
    -0.00332359f, 0.03839213f, 0.01544210f, -0.04536593f, -0.05256595f, 0.02975423f, -0.00013816f, 0.01607514f, 
    0.02502067f, 0.03985425f, -0.00486219f, -0.02403726f, -0.02257490f, -0.01384318f, -0.00022437f, -0.00350159f, 
    0.03431126f, 0.02805628f, -0.00406359f, -0.04104610f, 0.01995841f, -0.04075006f, -0.01445237f, 0.00464235f, 
    -0.04276438f, -0.03460805f, -0.03178829f, -0.00849038f, 0.00790081f, -0.02768637f, 0.01916591f, 0.04292420f, 
    0.01792278f, -0.02443018f, -0.02258701f, -0.01706919f, 0.04132730f, -0.04147714f, -0.01875731f, 0.01375398f, 
    -0.00317911f, 0.03331476f, -0.01613507f, -0.00006837f, 0.03151153f, -0.00780194f, -0.00228814f, 0.00968756f, 
    -0.01774687f, -0.01827898f, -0.04598924f, -0.00558545f, -0.03349720f, 0.02234254f, -0.04064125f, -0.04864055f, 
    -0.00651020f, 0.03688000f, 0.01948329f, 0.01972470f, 0.02602546f, -0.05092480f, -0.03942922f, -0.01536379f, 
    0.02759479f, -0.01544259f, 0.00405004f, 0.00845097f, -0.04653217f, 0.01284388f, -0.03264529f, 0.03544744f, 
    0.00118036f, -0.04741184f, 0.02333349f, -0.02542274f, -0.04544018f, -0.02764537f, -0.01989077f, -0.00185746f, 
    0.01040878f, -0.02003824f, 0.02600535f, -0.04701427f, -0.03591296f, 0.04287582f, 0.02358761f, 0.02083048f, 
    -0.04007187f, 0.01600567f, 0.02466940f, -0.04411966f, -0.04835279f, -0.02485125f, 0.04166689f, -0.01603858f, 
    0.00759395f, -0.05592930f, 0.04476637f, -0.01939534f, 0.00746859f, 0.00765221f, -0.02565656f, 0.00433285f, 
    0.01718200f, -0.02142771f, 0.03735099f, -0.01359211f, -0.02104120f, -0.01069245f, 0.04481968f, 0.03464383f, 
    0.01159399f, 0.01353214f, -0.01066058f, -0.00594385f, -0.00869753f, 0.02194036f, 0.01800932f, -0.02800743f, 
    -0.04674036f, -0.00147323f, -0.03547980f, -0.00465707f, 0.01810298f, -0.03427026f, 0.03832439f, 0.00831534f, 
    0.01652575f, -0.04375585f, 0.01078999f, 0.02157113f, 0.00883207f, 0.01229633f, 0.03636327f, -0.05371220f, 
    -0.02913495f, -0.01659206f, 0.02043142f, -0.00804759f, -0.02546909f, -0.04393148f, 0.04433709f, 0.00863345f, 
    0.02711837f, -0.04166425f, 0.02538293f, -0.02399648f, -0.03178639f, -0.03355743f, 0.03429756f, 0.00551416f, 
    0.01604034f, 0.01578502f, 0.01922713f, -0.05377806f, -0.03490031f, -0.05459712f, -0.00438203f, -0.03930479f, 
    -0.00533728f, -0.02448378f, 0.02927412f, -0.03793933f, 0.00943232f, -0.04931684f, -0.00073771f, -0.02480640f, 
    -0.00475196f, -0.03796113f, -0.03710967f, -0.05645581f, 0.03249336f, -0.01582141f, 0.02701694f, 0.04268407f, 
    -0.02020484f, -0.05556833f, 0.01512211f, 0.02706898f, 0.04103667f, -0.01170485f, 0.02675681f, 0.00957216f, 
    -0.02070205f, 0.04151128f, -0.00766180f, 0.01272843f, -0.02676283f, -0.05658026f, -0.02695807f, 0.01135289f, 
    0.00919629f, -0.04586858f, 0.01627921f, -0.03784634f, -0.01223321f, -0.04639277f, 0.01552866f, 0.04088339f, 
    -0.01841041f, 0.00442456f, -0.02616831f, -0.01897214f, 0.00930531f, -0.01582148f, 0.01957566f, 0.04465066f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01060027f, 0.08340389f, 0.08183067f, -0.04220907f, -0.00472461f, 0.11893012f, -0.09211101f, 0.03167283f, 
    -0.05033811f, 0.02224401f, 0.02803007f, -0.01313884f, 0.03228811f, 0.06907011f, 0.03270018f, 0.03728721f, 
    0.07242651f, -0.01559330f, 0.01599910f, -0.05473210f, 0.00380013f, -0.04117575f, 0.07853103f, -0.03658226f, 
    -0.05304319f, 0.07806366f, 0.00428071f, -0.11417533f, 0.01584709f, 0.00967460f, 0.02114797f, 0.02450864f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.00580718f, -0.14985673f, -0.01834966f, 0.33513483f, 0.02429043f, -0.10341717f, 0.21540688f, 0.15916988f, 
    0.14939645f, 0.01490618f, 0.16918617f, -0.11300912f, -0.03320388f, 0.15723762f, -0.13245909f, -0.40925953f, 
    0.12268257f, 0.09798015f, -0.21513811f, 0.10389868f, -0.13267642f, -0.05575598f, -0.25880480f, 0.04252345f, 
    0.01612743f, 0.12934387f, 0.08984202f, 0.69353497f, -0.02639082f, -0.69089204f, -0.02629665f, 0.05030584f, 
    -0.12213428f, 0.03770319f, 0.27709007f, 0.18610272f, 0.06161877f, 0.11358147f, -0.43477696f, 0.05474801f, 
    0.16116701f, -0.14801000f, 0.08013752f, -0.13766719f, -0.04584379f, -0.35410133f, 0.10245310f, 0.11190073f, 
    0.32327127f, -0.01978648f, 0.09946738f, -0.00683337f, -0.14847961f, -0.06052476f, -0.74017566f, -0.02296268f, 
    -0.11500923f, 0.13652958f, -0.02463432f, -0.54803926f, -0.08710042f, -0.18758683f, 0.06286699f, -0.06570775f, 
    0.15209711f, -0.68296659f, 0.23776022f, 0.50422722f, 0.09770797f, -0.57210642f, -0.10115612f, 0.16109753f, 
    0.10193992f, -0.06271851f, -0.06864095f, -0.15487696f, 0.12554419f, -0.03548108f, 0.05387856f, -0.71665841f, 
    -0.05946129f, -0.11377899f, -0.06301311f, -0.02701203f, -0.07512992f, -0.08342216f, 0.43719214f, 0.13929525f, 
    -0.04297796f, 0.14885680f, 0.27272677f, -0.10743554f, -0.12798432f, 0.19872893f, -0.00660709f, -0.06983966f, 
    0.11296126f, 0.24783064f, -1.04151249f, 0.10073903f, -0.12165420f, -0.30865288f, 0.04887667f, 0.02142068f, 
    -0.12391474f, -0.07291095f, -0.01430353f, -0.12069196f, 0.03822435f, 0.33452338f, -0.12156399f, 0.19136621f, 
    -0.32437691f, 0.15817209f, 0.25439113f, -0.16297242f, 0.16529097f, 0.00619244f, -0.09755157f, -0.08286186f, 
    -0.15324099f, 0.40551105f, 0.07879715f, -0.25438055f, -0.16824135f, -0.10758504f, -0.14246069f, 0.00390100f, 
    -0.14020418f, -0.28790888f, -0.13344122f, -0.34875131f, -0.16837344f, 0.32477835f, 0.43644711f, 0.00695842f, 
    0.11726881f, -0.09055025f, 0.05626747f, 0.01608629f, 0.06591576f, 0.30362663f, 0.09081228f, -0.25056392f, 
    -0.10126363f, 0.10820913f, -0.03071139f, -0.06209219f, -0.05263574f, 0.13896070f, -0.40107828f, -0.02995346f, 
    -0.06587703f, -0.07869275f, 0.25763431f, -0.77777433f, -0.00084440f, 0.23934482f, 0.01095498f, 0.06670444f, 
    -0.06742946f, 0.50602192f, 0.10908717f, -0.40882441f, 0.11040706f, 0.38800842f, 0.06712611f, 0.03802557f, 
    0.11301177f, -0.03622113f, 0.01933547f, 0.13457298f, 0.07950222f, -0.05698667f, 0.11092121f, -0.64769262f, 
    0.00203912f, -0.18025263f, 0.29348010f, -0.08606367f, 0.08593654f, -0.15766507f, 0.29821661f, -0.09097644f, 
    0.03281510f, -0.18040925f, -0.58486897f, -0.11534660f, -0.08730489f, -0.39304617f, 0.08126311f, -0.09583639f, 
    -0.04301806f, -0.52225131f, -0.41257739f, -0.48796758f, 0.05818810f, 0.03730754f, -0.01504691f, 0.16802087f, 
    0.12748696f, 0.15340956f, -0.02216112f, -0.15484363f, -0.02953278f, -0.08260018f, -0.04464526f, -0.10295051f, 
    0.32588005f, 0.01535316f, -0.28732491f, 0.17433323f, 0.13606174f, -0.02294776f, 0.44496977f, 0.05671636f, 
    -0.04222158f, 0.35101220f, -0.54143465f, 0.20666766f, 0.04630744f, 0.35007584f, -0.06048297f, 0.01157543f, 
    0.04017535f, 0.20730700f, -0.21869673f, 0.24196412f, -0.15733102f, 0.20262949f, 0.31201884f, -0.06140871f, 
    0.00503118f, 0.14478560f, -0.11838822f, 0.12944290f, -0.06637403f, -0.24689266f, -0.16736715f, 0.27395079f, 
    -0.42027077f, -0.08799855f, -0.44952783f, 0.14976193f, 0.14037625f, 0.09776994f, 0.30831197f, 0.05449853f, 
    -0.11600755f, -0.34575734f, 0.21513940f, 0.15211178f, -0.09048882f, 0.17332846f, -0.01031145f, -0.08834323f, 
    0.07646420f, 0.17489681f, 0.19942120f, -0.50757164f, -0.06764828f, -0.47715208f, -0.28053316f, -0.04880243f, 
    -0.11824462f, 0.09965669f, 0.11215957f, 0.02359582f, 0.03162441f, -0.71781194f, 0.04459090f, -0.20183422f, 
    0.05045943f, 0.15418732f, 0.38948601f, 0.08470397f, -0.06461795f, -0.18168847f, -0.21729261f, -0.12580730f, 
    0.06479703f, -0.18978880f, 0.41150427f, 0.44874945f, -0.01646933f, 0.23953143f, -0.14000599f, -0.04478404f, 
    -0.09474850f, -0.51052135f, 0.39205548f, 0.30699334f, -0.01029489f, 0.19319344f, 0.16980304f, 0.07583873f, 
    -0.03026854f, 0.15624344f, -0.13016841f, 0.15744334f, -0.13093095f, 0.05952943f, 0.04785388f, 0.28466386f, 
    -0.32835963f, -0.01481127f, 0.17625180f, 0.06603511f, 0.02167992f, -0.04192561f, 0.14028083f, 0.11680061f, 
    0.07310193f, -0.48231834f, -0.65006632f, 0.21456614f, -0.08996601f, 0.41573906f, -0.15987566f, 0.06374336f, 
    -0.05405862f, 0.40310338f, 0.43943763f, 0.05692895f, -0.01115886f, 0.05234744f, -0.59870899f, -0.09236382f, 
    0.09578433f, -0.17199728f, -0.15137333f, 0.06024776f, 0.08336713f, 0.07820921f, 0.12825237f, 0.05494502f, 
    -0.35019267f, -0.12813641f, -0.35455415f, -0.00538676f, 0.07583012f, 0.07664789f, 0.46755275f, 0.16759524f, 
    -0.13367055f, 0.46280757f, 0.04971726f, -0.50894076f, 0.04093596f, -0.14340292f, 0.16448094f, 0.03615816f, 
    -0.15462562f, 0.00855754f, 0.03572192f, -0.44576761f, 0.09070127f, -0.54404300f, -0.19521871f, 0.07226627f, 
    0.02682717f, -0.16401720f, -0.04864828f, 0.05531341f, 0.07937578f, 0.30118528f, 0.08999078f, 0.53453779f, 
    0.24142610f, -0.07341612f, -0.03453077f, -0.18064038f, -0.04886680f, 0.09745132f, 0.27999976f, 0.04951141f, 
    0.07781956f, -0.64003009f, -0.15178035f, -0.35027707f, 0.16868035f, -0.03699994f, 0.15101153f, -0.12444202f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04209897f, 0.01842395f, 0.13154191f, -0.03195613f, 0.09832872f, -0.15344059f, 0.09023999f, -0.30974650f, 
    -0.01076755f, 0.00143038f, 0.06498007f, 0.08340455f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
