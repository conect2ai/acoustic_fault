#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.26081902f, -0.81403315f, -1.15852737f, -0.40746826f, -0.34641409f, 0.44813117f, 0.56513965f, 0.08902324f, 
    -0.10999817f, 0.77110046f, -0.51908058f, 0.42698455f, 0.69730860f, 0.19785957f, 0.41596863f, -0.58711702f, 
    -0.14104207f, -0.15652318f, 0.77380282f, 0.91975695f, 0.87903827f, -0.00412826f, -0.09288850f, -0.56219471f, 
    0.31620836f, -0.29903522f, 0.01274772f, 0.14088327f, -0.58569568f, -0.49400455f, -0.28823987f, -0.76784712f, 
    -0.40782207f, -0.32154655f, -0.39415354f, 0.53547025f, -0.42565677f, -0.62781876f, -0.95551687f, -0.47221458f, 
    0.76448053f, 0.89620674f, -0.08168126f, -0.26981062f, 0.02106275f, -0.66044390f, -0.08734979f, 0.26103902f, 
    0.89400959f, -0.41319379f, -0.87079799f, -0.14017811f, -0.26567984f, -0.04303768f, -0.32796171f, -0.76955390f, 
    -0.57737660f, -0.12236822f, 0.17986366f, -0.24237306f, -0.39081553f, 0.77592367f, 0.34181187f, 0.35218641f, 
    0.91069698f, 1.11702621f, -0.62372881f, -0.15808204f, -0.94507706f, 0.20524159f, 0.83907402f, 0.01612821f, 
    0.91196227f, 0.10177173f, 0.14009987f, 0.65807372f, 0.65169114f, 0.20278889f, -0.02763517f, 0.55594319f, 
    -0.45502385f, 0.77066922f, 0.31343946f, -0.10466140f, -0.45206273f, -1.10489261f, -0.18897387f, 0.43731368f, 
    0.80112499f, -0.26713011f, -0.89539313f, -0.92165244f, 0.26398030f, 0.56003165f, -0.06254639f, 0.78177214f, 
    -0.12186857f, -0.05490435f, -0.04281300f, 0.89421797f, 0.62189221f, 0.83838159f, -0.44500613f, -0.77566588f, 
    0.41068467f, 0.19976592f, 0.05122090f, 0.15489367f, -0.23588808f, -1.00952125f, 0.46150312f, 0.45798004f, 
    0.66235167f, -0.07003246f, 0.10338437f, -0.46961030f, -0.40707132f, 0.85991937f, -0.49426302f, -0.85284543f, 
    0.04300022f, -0.51941836f, 0.51021290f, -0.63539296f, -0.14174254f, -0.14762910f, -1.20775163f, 0.19178957f, 
    -0.48318693f, -0.83810431f, 0.98266619f, 0.00970982f, -0.43073928f, -0.15017717f, 0.29550371f, -0.05130861f, 
    -0.55907041f, -0.52289647f, -0.06698083f, -0.64481550f, -0.26962858f, -0.71070719f, 0.11359740f, -0.31636837f, 
    -0.02670547f, -0.79903609f, -0.73440564f, 0.48453614f, 1.14255941f, -0.27350670f, 0.23101874f, -0.41231993f, 
    -0.36740470f, -0.38853353f, -0.46987522f, -0.39436969f, -0.59194732f, -0.24467610f, 0.60463887f, 0.10949660f, 
    0.29358494f, 0.57410026f, 0.94790822f, -0.34864676f, 0.42415121f, 0.49681509f, -0.63753945f, -0.09378144f, 
    -0.02600119f, -0.39445436f, -0.22855371f, 1.31925213f, 0.54873842f, -0.64795262f, -0.79126376f, 0.43539745f, 
    0.53060329f, 0.00317741f, 0.02030504f, 0.07401182f, 0.34415826f, -0.16517201f, 0.23585270f, 0.17885959f, 
    -0.23680592f, 0.76347399f, 0.45470262f, -0.27934170f, -0.38321325f, 0.14960758f, -0.48039159f, -0.57758594f, 
    -0.39316216f, 0.82054418f, -0.51190162f, -0.18866989f, -0.21967673f, -0.07587262f, -1.28710234f, 0.46467113f, 
    -0.37156641f, 0.63215560f, -0.55069989f, 0.05296851f, 0.22862960f, -0.56483579f, -0.04070564f, -0.80610847f, 
    -1.01967084f, -0.20365039f, -0.83188778f, 0.14886898f, 0.47297078f, 0.26766348f, -0.24368060f, -0.24974431f, 
    -0.17969266f, -0.73034084f, -0.40934330f, -0.75739467f, -0.76059252f, -1.06929410f, 0.31874555f, 0.34444055f, 
    0.31617600f, -1.34034562f, 0.58703101f, 0.67593670f, 0.63871545f, 0.90346777f, -0.48697606f, 0.27542537f, 
    0.51614475f, 0.06148684f, -0.76518214f, 0.78755301f, 0.77586961f, 0.31790444f, -0.20634945f, 0.73815709f, 
    -0.45583475f, -0.31858191f, 0.18427803f, -0.78438568f, -0.84149379f, 0.54560608f, 0.69270563f, 0.30401435f, 
    -0.03299346f, 0.50015450f, 0.05256624f, -0.37759748f, -0.64543760f, -0.77002627f, -0.47165212f, 0.54956484f, 
    0.06112123f, -0.05723673f, -0.39622000f, -0.29034916f, 0.16054296f, -0.64861202f, -0.05289711f, -0.57010108f, 
    0.56962800f, 1.04740942f, 0.56115985f, -0.02243981f, -0.51889682f, -0.09294669f, -0.48357505f, -0.60109037f, 
    0.55969036f, -0.60356849f, -0.37120256f, -0.51911426f, -0.24342714f, -0.03405255f, -0.68437427f, 0.68474907f, 
    1.04059172f, -0.14666194f, 0.80098319f, 0.79457980f, 0.00848919f, -0.01863928f, 0.03166014f, 0.06231595f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07987567f, 0.17473875f, -0.07738455f, -0.16075002f, 0.12228043f, -0.16304809f, -0.00173715f, 0.33310184f, 
    -0.04940425f, 0.16467689f, 0.28583106f, 0.18656887f, 0.22550480f, 0.19485010f, 0.21637960f, -0.12762977f, 
    0.16777872f, 0.07483193f, 0.02554169f, 0.17347348f, 0.27719110f, 0.01026081f, 0.24855836f, 0.03439062f, 
    0.44757494f, 0.20762525f, -0.02169352f, 0.04490249f, -0.17022154f, -0.05417385f, 0.00131176f, -0.12309823f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.19824103f, 0.13009138f, 0.20831460f, -0.02779621f, -0.03258322f, 0.04317529f, -0.07575286f, -0.14596279f, 
    0.26114950f, -0.00116835f, 0.06713851f, 0.01846630f, -0.04285725f, 0.08345054f, 0.01361951f, 0.08616368f, 
    0.10358690f, 0.04375300f, -0.22672470f, 0.10321701f, 0.06350471f, -0.01496847f, 0.05538693f, 0.02026924f, 
    -0.17745543f, -0.05699642f, -0.03612480f, -0.03408734f, -0.09285795f, -0.08293091f, 0.21122077f, 0.09621809f, 
    0.09783473f, -0.07210037f, -0.03895307f, -0.04631653f, -0.05814334f, 0.08261406f, 0.13029456f, -0.01339967f, 
    -0.33318764f, -0.46137094f, -0.21361949f, 0.27786443f, 0.16086602f, -0.01233602f, 0.05300676f, 0.12154273f, 
    -0.00387590f, 0.08071181f, -0.03157736f, -0.03474708f, 0.11068348f, 0.11597705f, 0.11483897f, 0.02696918f, 
    0.22122543f, 0.00022946f, -0.02558308f, 0.04812529f, 0.35550031f, 0.47424200f, 0.04236326f, 0.01361773f, 
    0.10061395f, -0.09512015f, -0.11831310f, -0.03713722f, -0.14505132f, -0.06151091f, 0.02931032f, -0.10194585f, 
    0.19711357f, -0.00220597f, 0.04796213f, 0.03937341f, -0.05172462f, -0.16265872f, -0.02514328f, -0.03059986f, 
    0.37888673f, -0.24615793f, 0.10662197f, -0.09121755f, -0.00592546f, -0.03646680f, 0.09357250f, 0.13099165f, 
    -0.04044767f, -0.00844153f, 0.08936473f, 0.09566096f, -0.10766196f, -0.04621341f, 0.04290424f, 0.02489869f, 
    0.01456585f, 0.13547793f, 0.08091808f, 0.01725335f, 0.22490628f, 0.21985677f, -0.17635654f, 0.04791035f, 
    -0.10159615f, 0.17118213f, 0.01393841f, 0.00188561f, -0.00176116f, 0.08751650f, 0.03705991f, 0.02853837f, 
    0.03850670f, 0.11305417f, 0.16710626f, -0.09043345f, 0.00028463f, -0.12964733f, 0.03233443f, -0.04767615f, 
    0.11421431f, 0.17555772f, -0.03616511f, 0.11283360f, -0.15728720f, 0.14462611f, -0.01314297f, -0.02304740f, 
    0.11829313f, 0.04824236f, -0.10952418f, 0.05475779f, 0.17270036f, 0.17522952f, 0.04540257f, 0.10297719f, 
    0.20626891f, 0.00017287f, -0.00676265f, -0.05970529f, -0.22102693f, -0.14244883f, -0.29888293f, 0.20008403f, 
    0.19915386f, 0.01605953f, 0.00076189f, 0.06740821f, 0.08804743f, 0.08071209f, 0.05029208f, -0.11703840f, 
    -0.02342399f, 0.14597900f, 0.12414126f, -0.00284566f, 0.16543880f, 0.00844332f, -0.08248314f, 0.12217371f, 
    0.28989702f, -0.20517246f, 0.24843198f, 0.01624362f, -0.10750239f, -0.05546173f, 0.00360144f, -0.03178073f, 
    -0.19808419f, 0.02071440f, -0.02970342f, -0.03760166f, -0.13780524f, 0.03808000f, -0.04896302f, -0.01436617f, 
    0.13426569f, -0.04738288f, 0.11644855f, 0.14390993f, 0.02673049f, -0.18786800f, -0.30006489f, 0.25463834f, 
    0.25597993f, 0.02095866f, -0.15311120f, -0.03543780f, 0.02070159f, 0.02894942f, -0.04424913f, 0.02997057f, 
    -0.21000181f, 0.21532901f, 0.00274847f, 0.06533406f, -0.03099365f, -0.06843400f, -0.22012323f, 0.01965250f, 
    -0.05386754f, 0.03561486f, 0.12036546f, 0.13691656f, -0.01697667f, 0.01846294f, 0.05671411f, 0.05141356f, 
    0.01260013f, -0.07096564f, -0.03730583f, 0.07037671f, -0.07036805f, 0.00232243f, -0.08133778f, 0.13756025f, 
    0.08985952f, 0.05631116f, -0.04903750f, 0.06620405f, -0.06488366f, -0.22915655f, -0.23401274f, 0.19080061f, 
    0.22783665f, 0.03687176f, -0.02558499f, 0.01903428f, -0.10382468f, 0.02878157f, 0.04249841f, 0.07374275f, 
    0.08619180f, 0.22826952f, 0.06665261f, 0.09530202f, 0.01324722f, 0.22226898f, -0.03221690f, -0.05628859f, 
    -0.15321398f, 0.24631259f, 0.04736391f, 0.10582639f, 0.07417265f, -0.08776347f, 0.02004607f, -0.03058627f, 
    -0.10959592f, -0.13989173f, 0.09760813f, 0.05571150f, 0.02661994f, -0.08424433f, 0.00252473f, 0.01322032f, 
    0.11248743f, 0.03995709f, 0.09077840f, -0.06837747f, -0.16817136f, -0.19007552f, 0.22448689f, -0.13228865f, 
    -0.08687740f, -0.15527272f, 0.04764897f, -0.08381636f, 0.00561361f, 0.14670397f, 0.06108034f, 0.06481350f, 
    0.02170297f, -0.11093434f, 0.08551662f, -0.11967663f, -0.11825111f, -0.19211067f, 0.16777459f, -0.03054336f, 
    -0.48636845f, 0.08954635f, -0.02415408f, -0.06482620f, -0.08654892f, 0.18337449f, 0.02542667f, -0.13760479f, 
    0.04474947f, 0.19327678f, 0.06382262f, 0.06610026f, -0.02117233f, 0.02313280f, -0.00382868f, 0.04540681f, 
    -0.05874583f, -0.07918935f, -0.05235149f, -0.12796108f, 0.20544057f, 0.13884805f, 0.12203947f, 0.26005775f, 
    0.18652815f, 0.05480373f, 0.13726048f, -0.02943843f, 0.03939210f, 0.05357121f, -0.01415006f, 0.12315878f, 
    0.05371737f, -0.07478309f, -0.03710167f, -0.20018098f, 0.02762051f, -0.15369955f, 0.05837584f, -0.04595905f, 
    0.13649432f, 0.10397714f, -0.21963370f, -0.02630237f, -0.09658049f, -0.01414397f, -0.12458780f, 0.11601257f, 
    0.02369833f, 0.00412620f, 0.00628900f, -0.02388802f, -0.04483455f, -0.07958946f, 0.11106835f, -0.08555452f, 
    0.13338219f, -0.11475409f, 0.19341376f, -0.04585845f, 0.03327790f, -0.04915025f, 0.25763720f, 0.05399803f, 
    -0.01161634f, -0.02606442f, 0.02563361f, -0.01183899f, -0.05223055f, 0.03197092f, -0.09089545f, 0.06083433f, 
    0.08667690f, 0.14028385f, 0.01650692f, 0.09644234f, 0.11152428f, -0.04741086f, -0.16596003f, 0.17671387f, 
    -0.28835809f, 0.02716377f, -0.02446524f, 0.32423380f, 0.06653710f, 0.05806569f, -0.03420094f, -0.00152817f, 
    -0.16622505f, 0.00946912f, 0.19869931f, 0.03096977f, 0.07704361f, 0.21909088f, -0.06407493f, -0.07415497f, 
    0.03832868f, -0.26469725f, 0.05637306f, -0.16401911f, 0.46560845f, -0.49342504f, -0.12996009f, -0.25082210f, 
    0.06955586f, -0.08361319f, -0.05979241f, -0.08468813f, -0.25619230f, 0.07956066f, 0.01307124f, 0.17009746f, 
    -0.04241645f, 0.03031926f, 0.07916497f, 0.01713523f, -0.04383717f, 0.01528834f, 0.03826953f, 0.11062860f, 
    -0.21531175f, -0.04282777f, 0.01185008f, -0.03667795f, 0.03941249f, -0.05219316f, 0.04548463f, -0.02737124f, 
    0.00923156f, 0.04310640f, -0.02126642f, -0.00175321f, -0.06272773f, 0.05812282f, -0.06471747f, 0.01187802f, 
    0.14849798f, 0.03298992f, 0.02516884f, 0.15332974f, 0.13579792f, -0.04953124f, -0.05483643f, 0.20974085f, 
    0.02649456f, 0.06374429f, -0.04730243f, 0.02063617f, 0.15165186f, 0.27461296f, 0.02895355f, 0.03090954f, 
    -0.09398857f, -0.07552029f, 0.07870997f, -0.19964951f, 0.07323706f, -0.20277734f, -0.07104112f, 0.03250623f, 
    -0.15229414f, 0.33431154f, 0.02680618f, -0.09877745f, 0.00269846f, 0.31645185f, -0.04822254f, 0.08340783f, 
    0.08125200f, -0.04923887f, 0.01861424f, 0.03450325f, 0.00485288f, -0.01964401f, -0.06618957f, -0.04429427f, 
    0.12029083f, -0.10841160f, -0.05093059f, 0.13128442f, -0.13605854f, -0.20088267f, 0.24491712f, -0.08881818f, 
    0.01510253f, 0.23589578f, -0.00691703f, -0.01099808f, 0.05513256f, 0.03193780f, 0.03078234f, 0.02667048f, 
    -0.09153816f, 0.05868652f, -0.02395299f, -0.06829017f, 0.03611027f, 0.07480136f, -0.31773940f, -0.04848664f, 
    0.19645306f, 0.16864772f, 0.16115855f, 0.11491705f, 0.03523738f, -0.04375765f, -0.11793862f, -0.01901035f, 
    0.05145281f, 0.06041471f, -0.13097630f, -0.04254520f, 0.26878715f, 0.22421595f, 0.08127572f, 0.00713874f, 
    0.11694341f, -0.14285652f, -0.18282060f, -0.06787101f, -0.55318159f, 0.55432338f, -0.00594878f, -0.17917401f, 
    -0.13783942f, -0.02312333f, 0.05996770f, -0.02537059f, 0.07476486f, 0.03999431f, 0.02476278f, 0.11097029f, 
    -0.00210191f, 0.01267560f, -0.06219959f, -0.00812143f, 0.16412959f, 0.07079576f, 0.12268242f, 0.01335775f, 
    -0.24641021f, 0.16137502f, -0.18124892f, -0.03825046f, 0.08935472f, -0.02856225f, 0.02762351f, -0.07815647f, 
    -0.04470906f, -0.04131319f, 0.01873004f, 0.06421517f, 0.00736126f, -0.02784447f, -0.08797150f, 0.10751943f, 
    0.03227807f, 0.31499025f, 0.05259278f, 0.09446790f, -0.05914748f, 0.20382190f, 0.25799543f, 0.00281297f, 
    0.00755150f, -0.09144623f, -0.03239030f, -0.08563638f, -0.02821288f, -0.06285757f, -0.00778125f, -0.00024517f, 
    0.02770577f, 0.04756442f, 0.00475733f, 0.08029811f, 0.11400115f, -0.00733465f, 0.05958111f, -0.08677458f, 
    0.03396744f, 0.36831224f, 0.01216347f, 0.10137408f, -0.11119322f, 0.16041356f, -0.05197060f, 0.17951588f, 
    0.05842903f, -0.10641217f, 0.06768580f, -0.01144579f, 0.11238065f, -0.16815396f, 0.07153032f, 0.10344996f, 
    0.03055001f, 0.17098284f, 0.13197750f, -0.06097073f, 0.00039003f, 0.40892527f, -0.14124078f, -0.10375762f, 
    -0.09837955f, -0.03476826f, -0.03737506f, 0.16820467f, -0.10271630f, -0.07796683f, 0.05700538f, -0.00770473f, 
    0.02016562f, -0.12688003f, 0.01697283f, 0.06894026f, -0.01448270f, 0.05653021f, 0.12708300f, 0.02901520f, 
    0.08377808f, 0.31883046f, 0.17801419f, 0.13083687f, -0.00536582f, 0.15017562f, -0.07736102f, -0.11536510f, 
    0.08872676f, 0.02429372f, -0.09548384f, 0.01870308f, 0.04855606f, 0.16493167f, 0.11670747f, -0.15071754f, 
    -0.01992635f, -0.01872516f, -0.16043018f, -0.09372467f, 0.14838143f, 0.32869720f, 0.04236975f, -0.06960431f, 
    0.04340908f, -0.04931901f, -0.05764528f, -0.24103546f, -0.07464348f, 0.02636243f, -0.15896057f, -0.15759312f, 
    0.11028118f, -0.00482845f, 0.00067736f, 0.07262024f, 0.14539488f, -0.19227782f, 0.20508625f, -0.05084291f, 
    -0.04241287f, -0.10262791f, 0.19173636f, 0.08906841f, 0.10103433f, 0.00095526f, 0.06960264f, 0.12502022f, 
    -0.00746171f, 0.06404180f, 0.02063594f, 0.05427077f, -0.00859453f, 0.08268533f, -0.02189317f, 0.06144066f, 
    -0.00490547f, -0.04530651f, 0.04644988f, -0.01435052f, 0.35281655f, 0.04990653f, 0.26180288f, 0.19196056f, 
    0.09249949f, 0.06999811f, 0.07333431f, -0.08476576f, 0.06254522f, 0.14628480f, 0.10836520f, 0.04521214f, 
    0.02707971f, -0.01324923f, 0.05866753f, -0.00073873f, -0.01351090f, 0.05384737f, 0.13651897f, 0.04753180f, 
    0.17412402f, 0.30192325f, 0.20041068f, 0.18008821f, 0.19275227f, 0.10594677f, -0.02419669f, 0.08493471f, 
    0.03099723f, -0.03031692f, -0.11061042f, -0.05236726f, -0.00884480f, 0.01087395f, -0.02591047f, 0.00062293f, 
    -0.00808674f, 0.00674470f, -0.03290557f, -0.03456322f, -0.36440119f, -0.33581889f, -0.02370267f, -0.07042781f, 
    0.02366945f, 0.00453353f, 0.08105309f, 0.09619500f, 0.05646473f, 0.21493593f, -0.14278352f, -0.05962508f, 
    0.06542429f, 0.10419247f, -0.04705432f, -0.08553636f, 0.00614219f, -0.11061637f, -0.13062124f, -0.19205226f, 
    0.00871335f, 0.12951055f, -0.23376653f, -0.03071054f, -0.01139659f, -0.03005742f, 0.01871794f, -0.03724242f, 
    0.04700849f, -0.05986499f, 0.04661170f, 0.01808761f, 0.05648251f, 0.04930308f, -0.00243205f, 0.10035955f, 
    -0.01423072f, -0.05774313f, -0.11591837f, 0.12239418f, -0.31634966f, -0.12545811f, 0.14349094f, -0.14942513f, 
    -0.13464682f, 0.02062049f, 0.01249976f, 0.04399213f, -0.08301493f, 0.00593491f, 0.12467849f, 0.05656154f, 
    0.09565049f, -0.03192379f, 0.04795580f, -0.13216417f, -0.04363707f, -0.04940173f, -0.00453246f, 0.06089715f, 
    0.07805550f, -0.21268514f, 0.03405872f, -0.03133960f, -0.02064140f, -0.15322910f, 0.10713794f, 0.13669467f, 
    -0.06118658f, 0.09990236f, 0.03333508f, -0.06608856f, 0.07404260f, 0.04545305f, -0.03239073f, 0.01891369f, 
    0.09957933f, -0.04277783f, 0.04413591f, 0.15767241f, 0.03571830f, 0.20559660f, 0.02843363f, -0.12071078f, 
    -0.06532126f, -0.00939693f, 0.04084339f, 0.08128787f, -0.02020742f, 0.07283894f, 0.06662440f, -0.01350766f, 
    0.04659997f, 0.11028679f, 0.02283833f, -0.01967848f, -0.01025802f, -0.00283494f, -0.04243411f, 0.00818940f, 
    0.51465970f, 0.24353386f, 0.23657185f, 0.13429239f, 0.27876285f, 0.04012078f, 0.02523644f, 0.01329557f, 
    0.00720128f, 0.02188979f, -0.00179859f, -0.01640787f, -0.02018420f, 0.05692922f, -0.03473986f, 0.00081677f, 
    0.04407873f, 0.06583961f, 0.10017490f, 0.06491609f, 0.06350394f, 0.11886910f, 0.27270669f, -0.13020074f, 
    -0.03128651f, 0.01637664f, -0.01455607f, 0.07854471f, 0.11334418f, -0.10416421f, -0.02573687f, -0.13756678f, 
    0.09661425f, 0.23049670f, -0.06837740f, 0.11830927f, -0.00229178f, -0.05379693f, 0.12090502f, -0.06856868f, 
    -0.13389114f, 0.06929950f, -0.15405251f, 0.09471984f, -0.26581746f, 0.03399897f, 0.02578920f, 0.00639981f, 
    -0.15494885f, 0.11956177f, 0.09270167f, 0.01820167f, -0.03495925f, 0.10291440f, -0.01507225f, 0.02454419f, 
    0.05097093f, 0.01359507f, 0.00013150f, 0.04877280f, -0.12395006f, 0.37852702f, 0.25668174f, 0.12598570f, 
    -0.02137234f, 0.13594970f, -0.07718073f, 0.04104520f, 0.14512241f, 0.03540555f, -0.06533182f, -0.03118691f, 
    0.05912019f, 0.08205213f, -0.03959988f, 0.11828151f, 0.07545573f, 0.01190355f, -0.04476856f, -0.03175749f, 
    0.23446131f, -0.09931529f, -0.12609911f, 0.03257843f, -0.05173732f, 0.14408113f, 0.05121768f, 0.08037079f, 
    -0.06902751f, 0.02039221f, 0.01679148f, -0.05086066f, -0.03760461f, -0.03409559f, 0.05190206f, 0.03961882f, 
    0.04390881f, 0.00544214f, 0.00009844f, 0.00178766f, 0.01293531f, -0.23329280f, -0.01124650f, -0.28926229f, 
    -0.00239087f, 0.01147622f, -0.00390806f, -0.00862851f, -0.03444639f, -0.03235724f, 0.12948248f, -0.03488928f, 
    -0.03223396f, 0.09611808f, -0.10749567f, -0.05762601f, -0.14211437f, -0.01041151f, 0.11274792f, -0.05484349f, 
    0.14366518f, -0.08618652f, -0.20661467f, -0.04177479f, 0.15060624f, -0.05733744f, 0.11427903f, 0.02575456f, 
    0.03436617f, 0.01587804f, 0.03532202f, 0.00722523f, 0.05947569f, -0.04885314f, 0.04835910f, -0.03931281f, 
    -0.07354881f, -0.00347187f, -0.11422557f, 0.00291870f, -0.20209120f, -0.12506631f, -0.02368235f, -0.38583606f, 
    -0.03415025f, 0.08437306f, -0.13750029f, 0.11274157f, -0.00653318f, 0.03274550f, -0.06291882f, 0.01364993f, 
    0.10090372f, 0.03105963f, -0.03914771f, -0.07156017f, 0.07759801f, -0.02810209f, -0.08352947f, -0.01426935f, 
    0.28659582f, -0.14936282f, -0.24859491f, -0.01215334f, 0.09843775f, 0.11944897f, 0.02427552f, -0.07889251f, 
    0.07784238f, 0.02748025f, 0.22894497f, 0.07380395f, -0.11253649f, -0.12299118f, 0.00599919f, 0.12397255f, 
    0.03279406f, -0.07626055f, -0.09610902f, 0.11209840f, -0.01327008f, -0.14068544f, -0.03774080f, 0.05639295f, 
    0.01015089f, 0.01707397f, -0.07750182f, 0.03519676f, 0.15166046f, 0.05615195f, -0.02149215f, -0.10074697f, 
    -0.01101151f, -0.07943657f, 0.03050558f, 0.06483977f, -0.06220476f, 0.08929020f, 0.02508743f, 0.15137406f, 
    0.05876128f, 0.07742777f, 0.19215047f, -0.03806531f, 0.05584598f, 0.05383492f, -0.02082650f, 0.06494582f, 
    -0.03366347f, 0.06604404f, 0.03049231f, -0.12476700f, 0.10824858f, -0.01940304f, 0.05642899f, 0.11750285f, 
    -0.05955377f, 0.02636218f, 0.11315762f, 0.06960373f, 0.18706465f, 0.30377015f, 0.08364111f, 0.29180229f, 
    0.11906692f, 0.04899586f, -0.04623191f, -0.06563216f, 0.13107382f, -0.14944580f, 0.04651673f, -0.02416823f, 
    -0.03144734f, 0.12621507f, -0.12032074f, -0.02117060f, -0.07456089f, 0.12793048f, -0.00005229f, -0.00325938f, 
    0.01419820f, 0.26345935f, 0.14923419f, 0.20083869f, 0.13470538f, 0.16403356f, -0.07542373f, 0.06374072f, 
    0.03455574f, 0.08303767f, 0.05069743f, 0.00961954f, 0.05910148f, 0.04230243f, 0.05761158f, 0.01276049f, 
    0.07440830f, 0.13846166f, 0.10571066f, 0.07553406f, 0.10591722f, -0.15304135f, -0.25135961f, -0.15799402f, 
    0.07166211f, 0.01734818f, -0.01700603f, 0.07958492f, -0.01421834f, 0.01088314f, 0.09781766f, -0.01165659f, 
    0.09359837f, 0.00002647f, 0.09933189f, -0.10589687f, 0.12322388f, -0.01067404f, -0.10242816f, 0.06702600f, 
    -0.18311848f, -0.07603578f, 0.16571620f, -0.12109995f, 0.07901897f, 0.07272601f, 0.05041562f, 0.01508188f, 
    -0.08292827f, 0.06712092f, 0.13353691f, 0.07869577f, 0.08179503f, 0.04799780f, -0.00497971f, -0.06354890f, 
    0.06151764f, 0.08784658f, -0.01111809f, 0.06270098f, 0.28892857f, -0.05549733f, -0.11275452f, 0.07409518f, 
    -0.03873074f, -0.02556208f, -0.06753163f, -0.00968753f, 0.00604230f, 0.00394895f, 0.10296196f, -0.03747977f, 
    -0.11795787f, 0.09525865f, -0.00427995f, -0.00952086f, 0.01085519f, 0.03835612f, -0.18643662f, 0.03680467f, 
    -0.01842196f, -0.10922077f, 0.02240583f, -0.04015779f, 0.00456343f, -0.06101155f, -0.01665477f, -0.00250732f, 
    0.05379145f, 0.07883785f, -0.05054303f, 0.11188523f, 0.11566085f, 0.10115658f, 0.04177745f, -0.02931274f, 
    0.06146889f, -0.10044078f, -0.15064578f, -0.01930432f, -0.35737520f, -0.44089106f, 0.09185376f, 0.08050717f, 
    0.22215414f, -0.10519789f, 0.00899533f, -0.09188686f, -0.02218582f, 0.16028346f, 0.01384141f, -0.06251356f, 
    0.05431310f, -0.11253147f, -0.03261671f, 0.09056232f, -0.04534366f, 0.15265314f, 0.03918616f, 0.06786215f, 
    0.05370239f, 0.17887028f, 0.10157327f, 0.08255664f, -0.05422492f, 0.09299744f, 0.08414833f, 0.08869657f, 
    -0.03871669f, 0.02826511f, -0.04789168f, 0.00243806f, 0.06761903f, -0.11603123f, 0.12102616f, 0.11423143f, 
    -0.02281051f, 0.16421245f, 0.04831740f, -0.04577092f, -0.04543666f, -0.15350555f, -0.16926047f, 0.12560955f, 
    -0.21834868f, -0.01354089f, 0.03902500f, 0.09079713f, -0.03081601f, 0.05336491f, 0.01219730f, 0.00767943f, 
    -0.10472491f, -0.07711857f, 0.00056145f, 0.05646842f, 0.06489170f, 0.09525092f, 0.02655738f, 0.06868509f, 
    -0.02017713f, -0.01771265f, -0.03362137f, -0.05988789f, -0.06166282f, 0.01628503f, -0.05704975f, -0.14374603f, 
    -0.05123760f, 0.05193050f, 0.07180646f, 0.08545557f, 0.03148345f, -0.01067680f, -0.00314529f, -0.10430530f, 
    0.19272916f, -0.14591207f, 0.01220368f, 0.00133238f, 0.22349796f, 0.09954453f, -0.05578430f, 0.01932687f, 
    0.16766229f, 0.06273837f, 0.03289772f, -0.18881008f, -0.04290593f, -0.02178260f, 0.13595544f, 0.00634482f, 
    -0.14244489f, -0.07679873f, 0.07999911f, 0.09305921f, -0.06368389f, -0.04881135f, -0.08977140f, 0.14289519f, 
    0.05721762f, -0.09181017f, -0.24211974f, -0.14312740f, -0.29091695f, -0.00882555f, 0.01017857f, 0.09604399f, 
    -0.06891828f, -0.01862457f, -0.02048691f, 0.06761452f, 0.01144074f, -0.04681884f, -0.07489982f, -0.10412269f, 
    0.03120358f, -0.01952115f, -0.16832912f, 0.06002310f, 0.40008071f, 0.19882786f, 0.16890572f, 0.05323163f, 
    0.24042456f, -0.12156232f, 0.16901933f, 0.00059321f, -0.07030839f, -0.01541959f, 0.02130436f, 0.06293654f, 
    0.00346388f, -0.00009317f, 0.05905034f, 0.02250995f, -0.05152766f, 0.09397768f, 0.15082890f, -0.03896540f, 
    -0.10959800f, 0.22828110f, -0.11915480f, 0.03601884f, 0.11339435f, 0.02236306f, -0.03886014f, -0.21904770f, 
    0.13709538f, 0.00291821f, -0.06729757f, 0.05201778f, -0.01317067f, -0.05760546f, -0.10331414f, 0.03587417f, 
    0.05524581f, 0.13253410f, -0.04032608f, -0.06087394f, 0.00059009f, 0.15647015f, 0.00662610f, -0.02298605f, 
    -0.11152371f, 0.04324932f, -0.13078003f, 0.13321106f, 0.01747256f, -0.13091438f, 0.03015242f, -0.00423546f, 
    -0.10004827f, 0.03288640f, -0.04202081f, -0.03015288f, 0.00890420f, 0.05932969f, -0.05761641f, -0.04578930f, 
    -0.03859453f, -0.10152337f, 0.09524684f, 0.01496816f, -0.04293604f, -0.09714232f, 0.08586103f, 0.05077577f, 
    0.03174561f, 0.13304202f, -0.00340801f, -0.04508836f, 0.04850454f, -0.00708816f, 0.21907337f, -0.07488240f, 
    -0.11094949f, 0.01493462f, 0.16601348f, 0.13643646f, 0.19562027f, 0.22343960f, -0.04599765f, 0.00288565f, 
    0.09995088f, 0.04238440f, -0.02902020f, -0.25110790f, 0.05179149f, -0.18926214f, 0.10146882f, 0.01507831f, 
    -0.00595355f, -0.04818153f, 0.04265738f, 0.06882367f, 0.00707477f, 0.01317449f, 0.17144784f, 0.13084607f, 
    -0.15878795f, -0.01250341f, 0.18037218f, -0.09282053f, 0.15762772f, 0.14132904f, 0.14480007f, -0.05143370f, 
    0.00457476f, -0.01334094f, 0.04486923f, 0.02225282f, 0.01803102f, 0.01356093f, -0.04281994f, -0.00561477f, 
    0.10112131f, 0.09039553f, 0.09316108f, -0.12542996f, -0.15470155f, 0.23823667f, -0.06113278f, -0.03956727f, 
    0.08127262f, -0.02800667f, 0.16342169f, -0.01964233f, -0.07533492f, 0.01752347f, -0.00089784f, 0.11173336f, 
    -0.02882696f, 0.08855374f, -0.09432873f, 0.10480428f, -0.01360689f, 0.02472936f, 0.08233178f, -0.05750388f, 
    -0.34493262f, 0.04968914f, 0.09039015f, 0.05413609f, 0.07181410f, 0.19761400f, -0.04203596f, -0.00351206f, 
    0.00132116f, 0.06488936f, 0.07236946f, 0.12392209f, 0.02500614f, -0.04982932f, 0.02781365f, -0.01455987f, 
    -0.12480327f, 0.01786458f, 0.01564495f, -0.04743365f, -0.26109695f, -0.33300492f, 0.15027806f, 0.23103115f, 
    -0.00016004f, -0.13740784f, -0.01322282f, -0.02896518f, 0.02098142f, 0.00309717f, -0.09072106f, -0.01217812f, 
    -0.02539101f, 0.05390267f, 0.21209171f, -0.16275975f, -0.07395532f, -0.01072755f, 0.02668644f, -0.01908832f, 
    -0.31647110f, -0.06323931f, 0.24676709f, 0.06949580f, -0.04345330f, 0.10981749f, 0.06014430f, 0.04990733f, 
    -0.00246773f, 0.00815474f, 0.08138512f, 0.04974893f, -0.01349851f, 0.05913143f, 0.02948500f, 0.03210365f, 
    0.00858636f, -0.02614291f, -0.11518881f, -0.04078811f, -0.20232022f, -0.17650609f, -0.35345581f, 0.22793546f, 
    0.01007145f, -0.17097522f, -0.09598025f, -0.08936787f, -0.08806769f, 0.06719854f, 0.00630135f, -0.02189556f, 
    -0.11757919f, -0.05957630f, 0.10910559f, -0.14802851f, -0.08875848f, -0.07645599f, -0.16198188f, 0.09789325f, 
    -0.05027097f, 0.01962505f, -0.06667477f, 0.13473329f, 0.30456612f, 0.14152442f, 0.06882086f, 0.04077328f, 
    0.16117479f, -0.12264330f, -0.02380531f, -0.02398480f, 0.01664382f, 0.01180542f, -0.07258110f, 0.02892922f, 
    -0.02420259f, -0.03910485f, -0.03212273f, -0.00888298f, 0.29875892f, -0.17215207f, -0.02715768f, -0.05886256f, 
    -0.01192064f, -0.18547751f, 0.01029484f, -0.06044423f, -0.02550964f, 0.06106364f, 0.07929874f, -0.00023710f, 
    -0.10133333f, 0.02697477f, 0.09632555f, -0.08420132f, -0.12904891f, 0.01600129f, 0.07807323f, 0.06959142f, 
    -0.33238947f, 0.39620453f, 0.11636411f, 0.03591685f, 0.07924289f, -0.08330636f, 0.04759090f, 0.01435997f, 
    0.04077389f, -0.11668722f, -0.02357784f, -0.01985761f, 0.03939259f, 0.06458881f, -0.10386436f, -0.00066026f, 
    -0.01660030f, 0.02487128f, 0.00540681f, 0.00901781f, 0.09017231f, 0.16727200f, -0.01063285f, 0.12472078f, 
    -0.11953066f, -0.07829547f, 0.03297733f, -0.08912165f, 0.02410224f, 0.02740940f, -0.09330254f, 0.15361436f, 
    0.08948470f, -0.11284038f, 0.02727346f, -0.06508990f, 0.10001802f, 0.03547706f, -0.01437659f, -0.04336385f, 
    -0.16357230f, -0.14860813f, 0.14222147f, 0.04312233f, -0.06316148f, 0.12503731f, -0.01149494f, 0.00636209f, 
    0.04895169f, 0.01152436f, 0.06661154f, -0.01219304f, 0.01545523f, 0.05818625f, -0.05259777f, -0.06678937f, 
    0.05051359f, -0.03745120f, 0.07143420f, 0.07588395f, 0.14319344f, 0.13241324f, -0.00777415f, 0.37789577f, 
    0.14701875f, 0.02270759f, 0.15332420f, -0.03014390f, 0.02711090f, 0.02078081f, 0.08277395f, 0.00045759f, 
    0.01445418f, -0.00272504f, 0.06597461f, -0.15252382f, -0.00182503f, 0.00112212f, 0.21229981f, 0.04336284f, 
    -0.77247846f, 0.33970889f, 0.30301338f, 0.05720389f, 0.07412566f, 0.01919919f, 0.06898911f, -0.04611741f, 
    -0.08798102f, -0.14567026f, -0.07639711f, 0.00321764f, 0.07855718f, 0.05141312f, -0.02444415f, -0.05285500f, 
    0.01474299f, 0.05714883f, 0.07804129f, -0.00090060f, -0.00994031f, -0.02274945f, 0.00653702f, 0.00846400f, 
    0.19060403f, 0.04400206f, 0.04167814f, -0.08313426f, -0.03319679f, -0.03098387f, 0.03413995f, 0.13632914f, 
    -0.07175042f, 0.08230487f, -0.01860470f, -0.05886434f, -0.02179189f, 0.03704596f, -0.02792120f, -0.05856455f, 
    0.15568598f, 0.21120231f, -0.10091618f, 0.10005835f, -0.01046849f, -0.03861089f, -0.02064773f, -0.06926900f, 
    0.07509766f, -0.01933820f, 0.05474713f, 0.11301407f, -0.12246645f, 0.10157434f, -0.07071832f, -0.02351056f, 
    -0.03942404f, -0.05340433f, -0.00209812f, -0.09663904f, 0.21254310f, -0.12465888f, 0.15964583f, -0.34521052f, 
    -0.07158786f, 0.01658461f, 0.03885254f, 0.02972428f, -0.12342062f, 0.23471160f, -0.03180658f, -0.02381721f, 
    -0.03488864f, -0.07304355f, 0.13978833f, 0.04756311f, 0.01177640f, -0.02487772f, 0.03539478f, -0.01866820f, 
    -0.00387404f, -0.14877230f, -0.02912717f, -0.18054552f, -0.27105135f, -0.15138662f, 0.03666506f, -0.11417861f, 
    -0.01863128f, 0.08055598f, 0.03096994f, -0.08195918f, -0.07054072f, -0.00501691f, -0.12211818f, -0.00731482f, 
    -0.05475355f, -0.08178950f, -0.03622292f, 0.03511939f, -0.30590031f, 0.05514859f, 0.32930255f, 0.04563987f, 
    0.16471377f, 0.03942338f, 0.02517529f, -0.20712684f, 0.12220987f, -0.01595729f, 0.05630861f, 0.04108139f, 
    0.01029280f, 0.04227320f, 0.03160646f, -0.16101940f, -0.04241983f, 0.01331816f, 0.05729721f, -0.06587624f, 
    0.05832749f, 0.03552046f, -0.02014503f, 0.20090127f, -0.15506479f, 0.04755842f, 0.08870012f, 0.05632051f, 
    0.07471409f, 0.05505330f, -0.03314985f, 0.05060078f, 0.04228720f, -0.09770493f, -0.10429085f, 0.08691997f, 
    -0.05790865f, -0.13371007f, -0.01444815f, -0.06213930f, -0.34221840f, 0.05419089f, -0.02519476f, -0.05249223f, 
    0.16719264f, 0.09672137f, 0.03562596f, 0.00697287f, 0.05156236f, 0.01913758f, -0.03863952f, 0.05898993f, 
    0.05373374f, -0.06416254f, -0.09203684f, 0.02011255f, 0.00412406f, -0.07711706f, 0.13139638f, -0.08396546f, 
    -0.33883744f, -0.27436393f, -0.08627351f, 0.08030935f, 0.12551354f, -0.06737868f, -0.05399094f, 0.09593608f, 
    -0.00412661f, 0.01928452f, 0.08527566f, -0.03502170f, -0.00162913f, 0.06865413f, -0.00833321f, -0.03274852f, 
    -0.08724250f, 0.05111025f, 0.10101862f, 0.03450262f, -0.07464473f, 0.37208328f, 0.25232568f, -0.12718831f, 
    -0.16972457f, 0.15402956f, 0.05820638f, 0.13641551f, 0.02373552f, -0.17975362f, 0.02289850f, 0.04807912f, 
    -0.01401399f, 0.15267408f, -0.03749291f, 0.09431429f, 0.16457014f, -0.00791392f, -0.05248058f, -0.06805578f, 
    0.26849881f, 0.00730267f, -0.02483216f, 0.14455034f, 0.00663689f, -0.02566899f, -0.09735138f, -0.04737807f, 
    0.00110438f, -0.00191155f, -0.05866490f, 0.01576184f, -0.01328364f, 0.04307413f, -0.13931885f, -0.10010509f, 
    0.04958762f, 0.02690581f, 0.02039588f, 0.00322393f, 0.02493287f, 0.45434481f, -0.01286140f, -0.04361693f, 
    0.31786725f, 0.02198280f, 0.07817069f, 0.07594605f, 0.00086105f, -0.07206469f, 0.03708096f, -0.00541191f, 
    0.07832060f, 0.03004132f, -0.08869778f, 0.06756920f, -0.02617290f, -0.11932408f, -0.01333679f, -0.03480090f, 
    -0.34487039f, 0.13914649f, 0.04771160f, 0.26242158f, 0.19685636f, 0.11814006f, 0.20389479f, 0.05987363f, 
    -0.01534775f, 0.01277927f, 0.05881804f, 0.00502813f, -0.03229220f, 0.02571151f, 0.13033080f, 0.23983847f, 
    0.13207284f, 0.09738096f, 0.07615971f, 0.07215955f, -0.41633105f, 0.15140699f, 0.17230523f, 0.06815950f, 
    -0.01953707f, 0.09368368f, 0.07228583f, 0.14756064f, -0.00743850f, -0.02479065f, 0.06865043f, 0.00595990f, 
    0.09695686f, 0.08075732f, -0.07864752f, 0.02289765f, 0.02090139f, 0.09954005f, 0.06419764f, -0.06147087f, 
    0.04689573f, -0.14703996f, 0.06722683f, 0.01550362f, 0.28286228f, -0.04173084f, 0.06380235f, -0.05964004f, 
    0.13355985f, 0.01652662f, 0.00476105f, -0.02664361f, -0.04856826f, 0.11614596f, 0.07579914f, -0.05929479f, 
    0.04122384f, 0.09437358f, 0.03133452f, -0.03129574f, -0.07598139f, 0.23051469f, 0.20093074f, 0.03801194f, 
    0.03805899f, 0.19343545f, -0.10875596f, 0.02586775f, 0.05502739f, 0.06575379f, 0.12987158f, -0.02974116f, 
    0.01711538f, 0.02685528f, 0.00269704f, 0.20833147f, 0.01517281f, -0.06861147f, -0.02923504f, 0.06210373f, 
    0.01847164f, 0.00555082f, -0.00206440f, 0.00271009f, -0.03040388f, -0.03801192f, 0.02999425f, 0.01410742f, 
    -0.00376546f, -0.04119715f, -0.02440739f, -0.02491084f, 0.01631856f, -0.01100271f, -0.03296831f, -0.00990970f, 
    -0.00975606f, 0.00805854f, -0.02621935f, -0.00713259f, 0.01564334f, -0.01165601f, 0.01267201f, -0.00441400f, 
    -0.03736971f, -0.00940042f, 0.01193957f, -0.03062789f, -0.03269423f, -0.01144556f, -0.02248587f, -0.02542805f, 
    -0.02260082f, -0.02696984f, -0.00160419f, -0.01295434f, 0.00723088f, -0.01019310f, -0.02727957f, -0.04238403f, 
    -0.00843825f, -0.04309698f, -0.02954799f, -0.04125512f, 0.02872820f, -0.03523525f, 0.01902775f, 0.02376866f, 
    0.01625729f, 0.02124300f, -0.03317296f, -0.03651573f, 0.02543721f, -0.03676819f, 0.00664887f, -0.01642701f, 
    -0.01131975f, -0.03509172f, 0.01759650f, 0.02484824f, -0.01770244f, 0.02830552f, 0.03315506f, 0.02903826f, 
    0.00959291f, 0.00369176f, -0.02253164f, 0.01773014f, -0.00606419f, 0.03774562f, -0.03357723f, 0.00204882f, 
    0.00987305f, -0.03071958f, -0.00276911f, 0.03135055f, -0.00464230f, -0.03275165f, -0.01224676f, 0.02849602f, 
    0.01983508f, -0.02283205f, 0.00478248f, 0.02492164f, 0.02029398f, 0.00657490f, -0.03084860f, 0.01867541f, 
    -0.00574862f, -0.01844899f, 0.03222995f, -0.03006793f, -0.03845644f, 0.01112618f, 0.01067993f, 0.02930540f, 
    0.00034474f, 0.03130381f, 0.01743161f, 0.00386679f, 0.00479708f, -0.03333604f, 0.00772584f, 0.01218548f, 
    0.02685850f, -0.01459240f, -0.03624365f, 0.00578432f, -0.04092429f, -0.04073507f, 0.02217990f, -0.00746023f, 
    0.00652393f, -0.03797339f, -0.01737267f, 0.02153430f, 0.02747396f, 0.00160788f, -0.03136403f, -0.00459545f, 
    -0.04457576f, -0.00510938f, -0.01912527f, 0.03131390f, 0.02451205f, -0.02102019f, 0.03126266f, -0.03368861f, 
    -0.02713477f, 0.02697186f, 0.03340052f, 0.01663676f, 0.02469636f, -0.02018535f, -0.01668131f, 0.01010922f, 
    -0.02742704f, -0.01762694f, -0.03795408f, -0.04185389f, -0.00329146f, -0.02711207f, 0.00929711f, 0.00567149f, 
    0.01978343f, -0.00458988f, 0.00444738f, -0.01811572f, 0.02666967f, -0.01329881f, -0.02737352f, 0.01920338f, 
    0.00036661f, 0.01592361f, -0.04390793f, -0.00523468f, -0.04443561f, -0.02227445f, -0.02352687f, -0.01043314f, 
    0.01171997f, 0.01101753f, -0.00976471f, -0.00613391f, -0.02990897f, 0.00036129f, -0.03036386f, 0.01138471f, 
    0.03848872f, -0.00537447f, -0.01365776f, -0.01214016f, -0.00655587f, -0.02436857f, 0.03916278f, 0.00245178f, 
    -0.02688393f, 0.01552833f, -0.02890382f, 0.00454986f, -0.01954829f, 0.02270110f, 0.01805843f, -0.03344381f, 
    -0.03373583f, -0.01700832f, 0.03342234f, -0.04183369f, -0.04098716f, -0.00346968f, -0.04386491f, -0.04261624f, 
    0.00283684f, -0.03258391f, -0.03192871f, 0.03335788f, 0.01774002f, -0.03904073f, -0.01168451f, 0.00627414f, 
    0.00197840f, -0.02013206f, -0.03582091f, -0.02835676f, -0.01118222f, -0.02453269f, -0.04352446f, 0.02571769f, 
    -0.01807382f, -0.01520725f, 0.02044421f, -0.04154896f, 0.03105232f, -0.04296627f, 0.01668760f, -0.01920667f, 
    -0.03786886f, -0.02128140f, -0.02346393f, -0.01604157f, -0.04266615f, 0.01169340f, 0.00258957f, 0.00417425f, 
    -0.00938240f, -0.04016209f, -0.02069662f, -0.03703775f, -0.04015342f, -0.01796089f, 0.00609935f, 0.03236898f, 
    -0.03321994f, -0.03240074f, -0.01563954f, -0.01601651f, 0.00326370f, -0.01348114f, 0.00344933f, -0.00564627f, 
    -0.02765203f, -0.04390636f, 0.02936057f, -0.03996437f, 0.02474310f, -0.00817062f, -0.01477375f, 0.00795973f, 
    -0.01225551f, -0.02635633f, -0.03593168f, -0.00108789f, 0.02936403f, 0.00704782f, -0.03537929f, -0.01065035f, 
    -0.04391867f, -0.02257933f, -0.03626271f, -0.02646956f, 0.02176254f, 0.00145841f, -0.01479558f, -0.02498510f, 
    -0.02454169f, -0.01734031f, -0.01757143f, 0.03229748f, 0.02697583f, -0.00267560f, -0.01873671f, -0.02400481f, 
    0.02558108f, -0.03294894f, 0.02881501f, 0.00690354f, 0.01114198f, 0.02973882f, 0.00739563f, -0.04253419f, 
    -0.02759124f, 0.01360256f, -0.01723099f, -0.01178720f, -0.04236452f, 0.02631008f, 0.00479745f, 0.03117155f, 
    0.02556914f, -0.02878432f, 0.00281158f, -0.03285630f, -0.01261426f, 0.00229590f, 0.00765539f, -0.03556040f, 
    -0.01903130f, 0.02961041f, 0.01479653f, -0.03806531f, -0.03020397f, -0.02589889f, 0.03183834f, 0.00282492f, 
    0.02237226f, -0.03273686f, -0.00769442f, -0.02950920f, -0.03669635f, 0.03421026f, 0.01970334f, -0.03159718f, 
    -0.03550250f, -0.01539871f, -0.03681948f, 0.02453104f, -0.02219700f, 0.00593437f, 0.02827655f, -0.02832145f, 
    -0.02703334f, -0.01760135f, 0.02797581f, -0.03281476f, -0.04126005f, -0.03392074f, -0.04279980f, -0.00023415f, 
    0.01910739f, 0.02175110f, -0.00148473f, -0.01020133f, -0.04194192f, -0.02603484f, -0.01423659f, 0.02096171f, 
    0.01761866f, -0.03191441f, -0.02581044f, -0.03390028f, -0.03563648f, 0.00458386f, 0.01568859f, 0.01240262f, 
    0.01249440f, -0.02757282f, -0.03009308f, -0.00908605f, -0.01337839f, -0.03690944f, 0.03236660f, 0.01426626f, 
    -0.04072103f, -0.03682128f, 0.01252224f, -0.02565263f, -0.04462951f, -0.03537597f, 0.02229147f, -0.01768542f, 
    -0.00449229f, 0.03316117f, 0.02104401f, 0.01136903f, 0.02208505f, 0.03872363f, -0.02241601f, -0.00027467f, 
    0.01275232f, 0.01042359f, -0.00696973f, -0.02848548f, 0.00629503f, 0.02801340f, -0.03568520f, -0.03871282f, 
    -0.02861891f, -0.03872673f, -0.04201269f, 0.03240820f, 0.02563053f, -0.01609655f, -0.01609485f, -0.01743647f, 
    -0.04377652f, -0.04073006f, -0.00765166f, 0.01422108f, 0.00457765f, -0.00150691f, -0.00005128f, 0.03105941f, 
    -0.03044221f, -0.01912921f, -0.03991945f, 0.02473145f, -0.01823805f, 0.02396473f, 0.02702919f, -0.02318178f, 
    0.00100834f, 0.00186741f, -0.03362235f, 0.00928942f, -0.00916926f, 0.00089757f, 0.00093720f, -0.02715854f, 
    0.00875826f, 0.02898238f, 0.00993898f, -0.01272137f, -0.02622924f, -0.02548427f, 0.01204536f, -0.01351522f, 
    -0.02000996f, -0.01025801f, 0.01320186f, 0.03038886f, 0.00221967f, -0.00143985f, 0.01443416f, -0.00537697f, 
    0.00386814f, -0.00740457f, -0.00009055f, -0.03583005f, 0.00045741f, -0.00449964f, 0.00399432f, 0.02382416f, 
    -0.03766736f, -0.03037308f, -0.02705153f, 0.01624716f, 0.03189697f, -0.04195000f, 0.01246327f, -0.02593779f, 
    0.01088061f, -0.02963713f, 0.02490363f, 0.02713278f, 0.01712312f, 0.00954741f, -0.01687147f, 0.03004778f, 
    -0.01841449f, -0.00303357f, 0.02248262f, 0.00272815f, 0.01352396f, -0.01597913f, -0.02879136f, 0.03000944f, 
    0.01334903f, 0.02247467f, -0.03498265f, 0.02762320f, -0.00384424f, -0.03510115f, 0.00237408f, -0.02221678f, 
    -0.01953005f, -0.00206185f, -0.03397259f, 0.03209480f, -0.02878345f, -0.03662108f, 0.02212128f, -0.04145930f, 
    0.00394838f, -0.03121814f, 0.01155448f, 0.01859184f, -0.03683909f, 0.01079366f, -0.03870504f, -0.00167657f, 
    -0.01301076f, -0.01706969f, -0.00868072f, -0.02853562f, 0.00538600f, 0.00857424f, -0.01973004f, 0.02261817f, 
    -0.01748185f, -0.03699818f, 0.02993222f, 0.00093165f, 0.02034215f, -0.03879460f, -0.02887849f, -0.00313750f, 
    -0.01901508f, 0.00386792f, 0.03342972f, -0.02521514f, -0.00307535f, 0.03500206f, 0.01882030f, 0.02049982f, 
    0.02044105f, 0.00847409f, -0.00207834f, -0.00090795f, 0.00884719f, 0.02824785f, -0.04234271f, 0.00911776f, 
    0.02156291f, -0.01338350f, 0.02148200f, -0.01306854f, 0.01175862f, 0.01777640f, -0.02274719f, 0.02120729f, 
    0.01341635f, 0.01156724f, -0.02947291f, 0.00738304f, -0.01365194f, 0.03130003f, 0.02923976f, 0.00520704f, 
    -0.01282418f, 0.02959963f, 0.01404243f, -0.02958431f, -0.02818944f, 0.01112574f, 0.01400954f, -0.03852411f, 
    0.00322562f, -0.00857410f, -0.00349337f, -0.03710257f, -0.00742138f, -0.00494907f, -0.03737080f, 0.00132169f, 
    -0.03693899f, -0.01760510f, 0.03313266f, 0.02053489f, 0.01619982f, 0.02063012f, -0.02858454f, 0.03248813f, 
    -0.03682795f, 0.02684796f, -0.03946529f, -0.02135039f, 0.02129285f, -0.03165542f, -0.03627053f, -0.00460829f, 
    0.00097911f, 0.02768613f, -0.03557242f, -0.03609388f, -0.00358930f, -0.04059532f, -0.00595397f, -0.04310216f, 
    0.00503141f, 0.03420911f, -0.02060254f, -0.01513202f, -0.01009221f, -0.00767433f, 0.00119479f, 0.00201382f, 
    0.00773401f, -0.00926973f, 0.03029457f, -0.04440273f, -0.02102197f, 0.02820953f, 0.01110634f, -0.03111129f, 
    -0.02641930f, -0.02706697f, 0.01045355f, 0.00087799f, 0.01858341f, -0.00784703f, -0.00080834f, -0.01887458f, 
    0.01925207f, 0.00575093f, 0.02250723f, -0.03250597f, 0.01037448f, -0.00018159f, 0.01157481f, -0.02621714f, 
    -0.02460854f, 0.02764601f, 0.02841149f, -0.03179226f, -0.02289598f, -0.00915014f, -0.02210682f, 0.01031564f, 
    -0.01622224f, -0.01589326f, 0.01517917f, -0.02643167f, -0.02174699f, 0.00114329f, 0.01373874f, 0.03337865f, 
    -0.04394703f, -0.03536606f, -0.02193808f, -0.02728477f, -0.02109471f, 0.01356054f, 0.00549394f, 0.00063808f, 
    0.03000675f, -0.01166077f, 0.00125560f, -0.02395171f, 0.01695410f, -0.02292133f, -0.00408131f, -0.02003187f, 
    -0.02363355f, -0.02788226f, -0.02281467f, 0.03602315f, -0.02226664f, 0.00104834f, 0.02306114f, 0.01518972f, 
    -0.04223229f, 0.02094010f, 0.02987300f, -0.03237702f, -0.02999881f, 0.00270075f, -0.00751150f, -0.01074214f, 
    0.01648474f, -0.03347189f, -0.02865621f, -0.03721412f, -0.03122310f, -0.03287067f, -0.01140627f, 0.00314956f, 
    0.02400902f, 0.03518921f, -0.04045586f, -0.01160788f, 0.01437645f, 0.01626280f, 0.01571443f, -0.00402217f, 
    -0.00301092f, -0.01295207f, 0.00940921f, -0.02489326f, 0.02140974f, -0.02164891f, 0.00800184f, -0.00358294f, 
    0.00400476f, -0.02648116f, 0.03779810f, 0.00651260f, 0.02894375f, 0.03985105f, -0.04408135f, 0.03106724f, 
    -0.03355218f, -0.01652805f, 0.02928534f, 0.01460822f, 0.00951019f, -0.03304615f, 0.02056853f, -0.03196122f, 
    -0.00270754f, -0.00732454f, 0.00841113f, -0.03635732f, 0.02808587f, 0.00061637f, -0.01063117f, -0.03185883f, 
    0.01889457f, 0.00003461f, 0.00819597f, -0.03611375f, -0.00281520f, -0.02326391f, 0.02565846f, -0.01282400f, 
    0.03972220f, -0.00957349f, 0.01056863f, 0.01661938f, -0.03399008f, -0.01614071f, -0.02187499f, -0.02134169f, 
    -0.02320552f, 0.01850502f, 0.01744293f, -0.03366611f, -0.01239199f, 0.01903133f, -0.02045156f, 0.01660295f, 
    -0.02158713f, -0.01699600f, 0.02664714f, -0.03004660f, -0.03732784f, 0.01462476f, -0.01770384f, -0.03130114f, 
    0.01053911f, 0.02162681f, 0.02904177f, 0.03591430f, -0.00253981f, -0.00884754f, -0.00229173f, -0.01756636f, 
    -0.02489325f, -0.03550479f, 0.02120022f, 0.00176266f, -0.03097042f, -0.00663319f, 0.03549586f, -0.04288331f, 
    0.00625700f, -0.01346171f, 0.01295378f, 0.02129459f, -0.01969828f, 0.01222609f, 0.00947708f, 0.00915035f, 
    -0.02886110f, -0.03300471f, 0.01553413f, 0.00237213f, 0.02689576f, 0.00862099f, -0.01429313f, -0.01614315f, 
    -0.03263309f, -0.03273899f, -0.01931390f, -0.01514192f, 0.02620883f, -0.02873065f, -0.01158541f, -0.02063223f, 
    0.00857396f, 0.02134626f, -0.02584413f, -0.04394996f, -0.03080117f, 0.03711025f, -0.00608455f, 0.02062092f, 
    0.02609759f, 0.03935276f, -0.00695975f, -0.01510942f, 0.00773798f, 0.01834271f, -0.03229477f, 0.01830480f, 
    -0.03212312f, 0.01674526f, -0.01755512f, -0.00493728f, -0.03925529f, -0.00303926f, -0.02213588f, 0.02027803f, 
    -0.03315667f, -0.02391427f, 0.01859471f, -0.02227606f, -0.01542845f, -0.03628062f, 0.03028228f, -0.00967051f, 
    0.00846482f, -0.02393457f, -0.03599687f, -0.00157761f, 0.02855830f, -0.02172764f, -0.02669205f, -0.01331936f, 
    -0.00304747f, 0.03025296f, -0.04658820f, -0.04530535f, -0.01195121f, -0.00249263f, -0.01084208f, 0.02955700f, 
    -0.02456112f, -0.04209088f, 0.02715298f, -0.00066922f, 0.01488053f, -0.00088256f, -0.03400670f, 0.02138819f, 
    -0.01674031f, -0.01635802f, -0.01462164f, -0.00723579f, 0.01150162f, 0.01591514f, 0.00878854f, -0.03505987f, 
    -0.01082988f, -0.01185956f, -0.04097279f, 0.00057641f, 0.01149840f, 0.01717731f, -0.03242175f, 0.02226876f, 
    -0.03283232f, 0.01895969f, 0.02876829f, 0.02945201f, -0.04013884f, -0.01916006f, -0.04128418f, 0.03989170f, 
    -0.02428815f, -0.02397716f, 0.00064662f, -0.01363230f, -0.02657950f, -0.03645979f, -0.01119317f, -0.03185115f, 
    -0.00676477f, -0.01108945f, -0.01110926f, 0.00766432f, 0.02279841f, -0.02181085f, 0.02862021f, -0.04070871f, 
    -0.01338234f, -0.01065660f, -0.03908053f, -0.02750063f, -0.03292130f, 0.01881076f, -0.03116006f, 0.01588355f, 
    0.02785377f, -0.00641754f, -0.01287753f, -0.03983700f, 0.01634383f, 0.01386807f, 0.00784643f, 0.01859528f, 
    0.02225417f, 0.01625000f, 0.00980081f, -0.02396601f, -0.02889867f, -0.00375274f, -0.02625833f, -0.02644792f, 
    -0.02311718f, 0.01213208f, 0.03890608f, -0.00567832f, 0.00415109f, 0.01392990f, 0.02613890f, 0.01295363f, 
    -0.02008203f, 0.01830809f, -0.01395784f, -0.00406321f, 0.01412839f, -0.02681692f, -0.02698908f, -0.01306491f, 
    0.03405873f, -0.02997931f, -0.04506210f, 0.01731960f, -0.01217478f, -0.01950543f, 0.00933253f, 0.03657678f, 
    -0.04191430f, 0.01217833f, -0.00792038f, -0.00258708f, -0.02329676f, 0.03474869f, -0.01905070f, -0.03381409f, 
    -0.02379252f, -0.03481359f, -0.00878701f, -0.01553245f, -0.00577191f, -0.03009273f, -0.03772877f, 0.03011230f, 
    -0.00010305f, 0.01394734f, -0.01021716f, 0.01426420f, 0.01086424f, -0.03069460f, 0.00083240f, 0.00392494f, 
    -0.01439773f, -0.00150738f, -0.01055877f, 0.00781445f, -0.01869936f, -0.01934523f, 0.01139151f, -0.01565272f, 
    0.01733637f, 0.01339968f, 0.01499852f, -0.03642565f, 0.02800796f, -0.03841732f, -0.02981772f, 0.01390121f, 
    -0.02323740f, -0.01230475f, -0.02284138f, 0.03442327f, 0.01706447f, 0.00234382f, 0.00801995f, -0.04356847f, 
    -0.03052627f, 0.00809648f, -0.02630293f, -0.03901070f, -0.02793636f, -0.01820043f, 0.04510245f, 0.02494947f, 
    -0.04364106f, 0.02554283f, 0.03471231f, -0.03138351f, -0.01142130f, -0.00228411f, -0.00828632f, 0.01332675f, 
    0.00306865f, 0.01198820f, 0.01390210f, -0.00733125f, 0.01476640f, -0.03198534f, -0.01906495f, 0.02541716f, 
    -0.01262648f, 0.01915487f, -0.01586927f, 0.00892928f, 0.03915434f, -0.01930921f, -0.01267214f, 0.00913383f, 
    -0.04694434f, -0.00960867f, -0.01959306f, -0.00819682f, 0.02832208f, 0.01020952f, 0.02241847f, -0.01965939f, 
    -0.02622257f, -0.02263225f, 0.02277472f, 0.01559403f, 0.02941545f, -0.00939511f, 0.02603030f, 0.01047504f, 
    0.01902299f, -0.01132847f, -0.02781224f, -0.03616118f, 0.02284794f, 0.00116394f, -0.03162668f, -0.00884736f, 
    0.01524614f, -0.03415917f, -0.02955125f, -0.01704737f, -0.00058983f, 0.01181175f, -0.02356764f, -0.00799442f, 
    0.00487780f, 0.00410504f, -0.00925571f, 0.03005167f, 0.01759904f, 0.00776616f, -0.03494591f, 0.01910256f, 
    -0.02794294f, 0.01109247f, 0.00887155f, -0.00975563f, -0.01784886f, 0.02746044f, -0.01830674f, -0.01946856f, 
    0.02883464f, -0.04014250f, -0.01273715f, -0.01635342f, 0.01927406f, -0.01349942f, 0.02644674f, 0.01187947f, 
    0.01208247f, -0.02178191f, -0.02046454f, -0.00924214f, 0.00205177f, -0.03601885f, -0.03584116f, 0.01944328f, 
    -0.02056871f, -0.03208983f, 0.01975301f, -0.03254191f, 0.01982732f, 0.03500945f, 0.03000684f, 0.02108846f, 
    -0.00121733f, 0.02854140f, 0.02270315f, 0.01639060f, -0.03284586f, 0.02482043f, 0.00541701f, 0.03314009f, 
    0.03816597f, -0.01689669f, 0.00541667f, -0.00507535f, -0.00197132f, 0.00517438f, 0.02648178f, -0.01954304f, 
    -0.00969032f, -0.02374082f, -0.02611836f, 0.03046941f, 0.01237876f, -0.00403834f, -0.01901993f, 0.03548018f, 
    0.00920798f, 0.00736758f, 0.03236696f, 0.00977162f, 0.00324407f, -0.02663886f, -0.01164572f, 0.02055462f, 
    -0.03154369f, 0.02058499f, 0.02133883f, -0.02148129f, -0.00981807f, 0.00439123f, -0.03222143f, -0.02284099f, 
    -0.00825632f, -0.02232842f, -0.04007984f, 0.02849052f, 0.00301279f, -0.01832282f, -0.01641991f, 0.01984748f, 
    0.02495158f, -0.01542156f, 0.00348942f, 0.00926869f, -0.04636308f, -0.03041288f, 0.03126727f, -0.00637315f, 
    0.00186072f, 0.01372564f, 0.03417323f, 0.01257605f, 0.02335181f, -0.01512695f, -0.02825012f, 0.00769341f, 
    0.00373292f, -0.02848514f, -0.00430776f, 0.01212412f, -0.00401489f, 0.00421625f, -0.02888658f, -0.01168997f, 
    0.00800649f, -0.03352225f, -0.03181322f, -0.04015848f, 0.00391506f, 0.00576347f, 0.01121184f, 0.04232675f, 
    0.00038250f, 0.01639112f, -0.01833558f, 0.02103164f, -0.01872486f, -0.02535891f, -0.03221230f, 0.02660328f, 
    0.00858035f, -0.01525179f, -0.04241588f, 0.04454018f, 0.01237484f, 0.00271689f, 0.00435839f, 0.04093110f, 
    -0.01715596f, -0.00612451f, -0.04810033f, -0.01673391f, -0.00869051f, -0.00755415f, 0.03435966f, 0.03286127f, 
    -0.02395197f, -0.00249920f, -0.04899903f, -0.01292531f, 0.03085429f, -0.03418243f, -0.00292511f, 0.01067440f, 
    -0.03730986f, 0.00290951f, -0.01929202f, -0.01488267f, 0.00405329f, 0.00687408f, 0.01846725f, 0.00026463f, 
    -0.00598175f, 0.00025238f, 0.01778672f, 0.00816484f, -0.03664996f, -0.02339723f, -0.02319913f, 0.03397560f, 
    -0.03237844f, -0.03468085f, 0.03038667f, 0.00773846f, 0.00295276f, 0.00830890f, -0.02026761f, -0.03853648f, 
    -0.03674819f, 0.03177024f, -0.03162771f, -0.00333945f, 0.03822125f, -0.02429319f, -0.03236733f, 0.01844127f, 
    -0.01440035f, 0.02765012f, -0.02883474f, 0.02325610f, 0.03165733f, -0.00890637f, 0.03015929f, 0.00398088f, 
    -0.03615302f, 0.03393913f, -0.03248891f, 0.01384681f, -0.00611424f, 0.00603279f, -0.03601426f, 0.02942888f, 
    -0.02990601f, 0.04310266f, 0.01550826f, 0.02220286f, 0.03737766f, 0.02085339f, -0.03239911f, 0.02033899f, 
    -0.03758354f, -0.01099495f, 0.00426465f, -0.01256459f, 0.03039435f, -0.04045575f, -0.02179796f, 0.02056550f, 
    -0.01732374f, 0.03170525f, -0.01986681f, -0.02001499f, -0.02716558f, -0.04146108f, -0.00134700f, -0.03475264f, 
    0.01958246f, 0.00656410f, 0.03204746f, 0.03755232f, 0.00538759f, 0.02239810f, 0.02844493f, 0.01493357f, 
    0.03551806f, -0.01414099f, -0.02533001f, -0.01397909f, -0.01359040f, -0.01696084f, -0.02313821f, -0.00124004f, 
    -0.03054277f, 0.00292657f, -0.00026992f, -0.02974715f, 0.01060788f, 0.01268915f, 0.00227194f, -0.03287078f, 
    0.00560632f, -0.00910811f, -0.02152673f, 0.03721024f, -0.02127361f, -0.03933603f, -0.04105778f, 0.01505440f, 
    0.01692104f, 0.00048008f, -0.00169017f, -0.03279494f, -0.03795242f, 0.03057457f, -0.04131087f, 0.02277607f, 
    0.03314950f, -0.00189047f, -0.01683160f, 0.02734865f, 0.01717197f, 0.00670359f, -0.01857780f, 0.02036381f, 
    -0.03836550f, 0.02094728f, 0.01634705f, -0.01459204f, -0.03141794f, 0.02019564f, 0.01798549f, -0.02935031f, 
    -0.00594254f, 0.03218773f, 0.00171900f, 0.00442329f, -0.02787383f, -0.03063678f, -0.04208148f, -0.01586194f, 
    -0.01031457f, -0.01928305f, -0.03881619f, 0.00562413f, -0.00702137f, 0.01595708f, -0.00891881f, -0.03036238f, 
    -0.01988040f, 0.01610082f, -0.00328300f, -0.01773095f, -0.02733946f, -0.02620106f, 0.01995283f, 0.00493987f, 
    -0.00334364f, -0.04384069f, 0.01529493f, -0.04048860f, -0.02982589f, 0.01376973f, 0.02893809f, -0.02044606f, 
    -0.03077099f, 0.00955127f, -0.00057980f, -0.03175953f, 0.01922597f, -0.01525561f, 0.03147995f, -0.02115075f, 
    -0.02507921f, -0.04022809f, -0.01038227f, -0.01408562f, 0.00956190f, 0.03023623f, -0.03076084f, 0.02875537f, 
    -0.02667340f, 0.02521214f, -0.00958411f, -0.00422634f, -0.04080866f, 0.01371730f, 0.00558386f, 0.02550627f, 
    -0.02303420f, 0.02311662f, -0.01033737f, 0.01505049f, -0.00435603f, 0.03233051f, 0.00889902f, 0.00436612f, 
    0.00730858f, 0.02215751f, 0.02957860f, -0.01377614f, 0.02871810f, -0.03035771f, 0.03397400f, 0.02091338f, 
    -0.02436607f, 0.02823207f, -0.04352326f, -0.02333182f, 0.02645786f, 0.00290272f, -0.01132918f, -0.00888546f, 
    0.01542480f, 0.01840416f, -0.00489373f, -0.03044657f, -0.01183054f, 0.00640218f, -0.00665862f, 0.00965477f, 
    -0.03959465f, -0.02226846f, -0.00752211f, 0.03016659f, 0.01713565f, -0.00154448f, -0.03211547f, -0.03348775f, 
    0.01663716f, 0.00158936f, -0.00571453f, -0.00819070f, 0.02440986f, -0.04090510f, -0.00350105f, -0.04255515f, 
    -0.00258479f, 0.00833547f, -0.03924302f, 0.02049369f, -0.03465417f, 0.00586434f, 0.01641768f, -0.00955078f, 
    -0.03251725f, 0.02300470f, 0.00372532f, -0.02200980f, -0.03560767f, 0.02998042f, 0.00334273f, -0.04091945f, 
    -0.03812671f, -0.01335866f, -0.02639081f, 0.02100395f, -0.01876045f, -0.00641039f, -0.00463544f, 0.01456498f, 
    0.00952674f, -0.02269259f, -0.01630025f, -0.00164406f, -0.01481772f, 0.02531781f, -0.04410107f, -0.00897656f, 
    -0.00845373f, -0.02060870f, -0.03981943f, -0.00506277f, 0.00927135f, -0.01551175f, -0.02636203f, 0.01029661f, 
    -0.02753755f, -0.00110729f, -0.04096892f, -0.02050349f, 0.01429063f, 0.02353623f, -0.03207149f, 0.00354654f, 
    -0.03556259f, 0.00529779f, 0.02061620f, -0.01262188f, 0.03046831f, 0.00315303f, -0.03631879f, 0.02013297f, 
    -0.03694122f, -0.02111263f, -0.01900984f, 0.03214291f, 0.01324919f, -0.02997463f, 0.01688240f, -0.01186252f, 
    -0.01620469f, 0.02228152f, 0.02228208f, 0.01720642f, -0.02221349f, -0.04110238f, 0.01475877f, -0.02324613f, 
    -0.00757795f, -0.02262497f, -0.00712802f, 0.02457216f, 0.02516531f, -0.03660630f, -0.03633105f, -0.03060236f, 
    0.02843846f, 0.00780252f, 0.01246841f, -0.01424295f, -0.02615251f, 0.00375762f, -0.00959819f, -0.03077679f, 
    0.02678242f, 0.01642075f, -0.03347100f, 0.01434070f, 0.02561197f, -0.00417128f, -0.00070738f, 0.00919508f, 
    0.01847538f, 0.01490749f, 0.00980609f, 0.03146353f, -0.03754988f, -0.00610500f, 0.00081571f, 0.02390528f, 
    0.00175238f, -0.01789439f, 0.02204630f, -0.02246436f, -0.01628157f, -0.02563813f, 0.01893050f, 0.02852446f, 
    0.00543249f, -0.04249145f, -0.02084870f, 0.00548159f, -0.01366080f, -0.03233732f, -0.02753129f, 0.02164305f, 
    0.02717558f, 0.02390820f, 0.01041955f, -0.01587509f, -0.01454243f, -0.02930723f, -0.01302248f, 0.01647274f, 
    0.03061915f, -0.04194617f, -0.02608704f, -0.01756711f, -0.02415822f, 0.01752048f, 0.01308736f, -0.01896555f, 
    -0.03793500f, 0.00809178f, -0.02006496f, -0.04140293f, 0.00853438f, -0.00901698f, -0.00814564f, -0.01234916f, 
    0.00295676f, -0.03008045f, -0.02493321f, 0.00318018f, 0.02520594f, 0.01829658f, 0.02595206f, 0.00295497f, 
    0.03216457f, 0.03199746f, 0.02387167f, -0.02861483f, -0.03233226f, 0.00239832f, -0.04080709f, -0.02659225f, 
    -0.03151391f, -0.01551556f, 0.01742549f, 0.01341050f, -0.03946877f, -0.00063569f, 0.02125663f, -0.03605661f, 
    -0.00868481f, -0.01797426f, -0.03723095f, -0.02372593f, -0.00245796f, -0.01222615f, -0.03160155f, -0.02165335f, 
    0.00847289f, -0.02197605f, -0.02237179f, 0.02787710f, -0.03002887f, 0.00423288f, -0.04258255f, -0.01819603f, 
    -0.00305771f, -0.01199818f, -0.02571044f, 0.01362989f, 0.01648692f, 0.01877172f, -0.02030414f, 0.00542101f, 
    0.01008105f, 0.01209535f, -0.01849909f, 0.03018785f, -0.03761521f, -0.01087779f, 0.00519174f, 0.02134739f, 
    0.00506107f, -0.03146914f, -0.02998278f, 0.02535901f, -0.01623255f, 0.02451907f, -0.01847399f, -0.03339830f, 
    0.00944435f, -0.00721905f, 0.00166427f, -0.01736482f, 0.02925368f, -0.01234419f, 0.01699076f, -0.03714949f, 
    -0.04244826f, -0.00419854f, -0.03795732f, 0.01351077f, 0.00563641f, -0.01070916f, -0.00466435f, -0.03864365f, 
    -0.04205796f, 0.02960384f, 0.00223564f, -0.02088902f, -0.03078639f, -0.01956568f, 0.02804236f, 0.02834584f, 
    -0.00579937f, -0.01222186f, 0.01378290f, -0.03216640f, -0.01953498f, -0.00689555f, 0.00329660f, -0.00033548f, 
    -0.00099696f, -0.01351809f, -0.02990796f, 0.02483073f, -0.00996249f, 0.02371346f, -0.03057792f, 0.00812770f, 
    0.00786545f, -0.01919506f, -0.00039480f, 0.02618910f, 0.03030609f, -0.02975655f, -0.01417501f, -0.00939086f, 
    -0.01584884f, -0.04418500f, -0.02733952f, 0.00329644f, 0.02057109f, 0.00381232f, 0.02425852f, -0.01558059f, 
    -0.03181899f, -0.02121853f, 0.02921209f, 0.00610919f, -0.02346682f, -0.00715293f, -0.02871036f, 0.02580128f, 
    0.00621647f, -0.00343937f, -0.04370073f, -0.00156020f, 0.01840806f, -0.01023848f, 0.02907076f, -0.03159459f, 
    0.02958181f, 0.01768259f, 0.03429916f, -0.04056065f, 0.02263637f, -0.04092775f, -0.01040743f, -0.02382533f, 
    -0.02063699f, -0.00788539f, 0.03121139f, 0.02618290f, -0.00532745f, 0.02126478f, -0.03416330f, -0.04135257f, 
    0.02204552f, 0.02103258f, -0.03904697f, -0.03886655f, -0.03282694f, 0.01650470f, 0.03067173f, -0.03568657f, 
    -0.02879165f, -0.00595024f, -0.04082748f, -0.03012946f, 0.02844575f, -0.03592224f, 0.01951194f, 0.00898495f, 
    -0.02579227f, -0.00966485f, 0.01022234f, -0.04024181f, 0.01559771f, 0.00700809f, 0.03196403f, -0.04226213f, 
    -0.00624237f, 0.00688838f, -0.00336681f, -0.02639337f, 0.02427618f, 0.02668772f, -0.03714065f, -0.01087042f, 
    0.01640896f, 0.00583851f, 0.01345092f, 0.01630519f, -0.03108306f, 0.02171129f, 0.02892405f, -0.00496424f, 
    0.03127832f, -0.02122800f, -0.03949715f, 0.03245214f, -0.03253114f, 0.02751560f, 0.01102141f, 0.03172606f, 
    0.01851086f, -0.03699971f, -0.00683579f, -0.03050945f, -0.03067239f, -0.00089895f, -0.04118723f, 0.01747425f, 
    -0.00750556f, 0.00809215f, -0.01284679f, 0.01492577f, -0.00753912f, 0.00248878f, -0.03176752f, 0.00162465f, 
    0.02640497f, 0.03347921f, -0.02526383f, -0.02350065f, -0.03647420f, -0.00710498f, 0.01381636f, -0.03641104f, 
    -0.00873416f, -0.00770944f, -0.00926211f, -0.04100857f, 0.02355740f, -0.01671079f, -0.03366020f, -0.03732179f, 
    0.00191501f, 0.01407040f, 0.03049876f, 0.02167116f, -0.03040439f, -0.04303864f, -0.02126006f, -0.02152567f, 
    0.02676325f, -0.04553019f, -0.00548554f, -0.03724337f, 0.02010520f, -0.00491177f, -0.01570533f, 0.02063862f, 
    -0.03136838f, 0.01299976f, 0.00220324f, 0.02037721f, -0.00157715f, -0.03832924f, -0.01215477f, -0.00426887f, 
    -0.00326667f, 0.01529237f, -0.04212472f, -0.00104169f, 0.01330035f, -0.00499442f, -0.03301666f, 0.00491555f, 
    0.01400691f, 0.02375478f, -0.01659205f, 0.02062631f, -0.03117908f, -0.01998637f, 0.01165507f, -0.00393514f, 
    -0.04306657f, -0.01845209f, -0.02673872f, -0.03461680f, -0.04352122f, 0.03441095f, -0.00734112f, -0.01119629f, 
    0.00181184f, 0.02219143f, -0.01049184f, -0.03024578f, 0.00524207f, -0.00532148f, -0.00520913f, -0.00433309f, 
    0.03324814f, -0.01313815f, -0.04186476f, 0.01668305f, -0.01957163f, 0.01561944f, 0.01846798f, 0.03390567f, 
    -0.02462521f, 0.01895960f, -0.02205427f, -0.00149728f, -0.03313829f, -0.03617023f, -0.03062264f, -0.04081243f, 
    -0.04098007f, -0.01623327f, -0.02817333f, -0.03657390f, 0.03351096f, -0.03690130f, -0.01511696f, -0.04273814f, 
    0.00997149f, -0.01455529f, -0.02642115f, -0.03163569f, 0.01271176f, -0.04052635f, -0.01487489f, -0.00681915f, 
    0.02754889f, -0.03503547f, -0.04514375f, 0.01267163f, -0.01768712f, -0.01498481f, 0.01778373f, 0.03181009f, 
    -0.03595893f, -0.01757588f, -0.03664003f, -0.02471024f, -0.01281190f, 0.00672865f, 0.01812946f, -0.03896020f, 
    0.00270061f, 0.03299093f, 0.02165197f, 0.00366368f, 0.03088216f, 0.00059254f, 0.01546603f, -0.00061469f, 
    -0.02248529f, -0.02009039f, 0.02829851f, -0.01977780f, -0.01348243f, -0.03878094f, -0.04312477f, 0.00604291f, 
    -0.03147051f, 0.01871560f, 0.02270099f, 0.00064753f, -0.04506148f, -0.01515101f, -0.04306193f, -0.00343356f, 
    -0.01476425f, 0.02321270f, -0.04406422f, 0.01912321f, -0.02509938f, 0.02702570f, 0.01364790f, 0.01673083f, 
    0.14702450f, -0.12157471f, 0.04251136f, 0.19493535f, 0.00335639f, 0.01315131f, 0.00177538f, 0.12871416f, 
    0.02754497f, 0.16968712f, -0.11800055f, 0.02026925f, 0.01492801f, -0.04018427f, -0.03960853f, 0.04592595f, 
    -0.06707399f, 0.06824542f, 0.08554513f, -0.09831398f, 0.22573063f, 0.00606247f, 0.12322261f, 0.09022661f, 
    -0.01857040f, 0.06778860f, 0.04408779f, -0.06495710f, -0.01587445f, 0.08652249f, 0.09983166f, 0.05589069f, 
    -0.05181585f, 0.04048664f, -0.03307741f, -0.07760222f, 0.06200535f, 0.01532167f, 0.04121174f, 0.03699121f, 
    0.33508539f, 0.29055437f, 0.13889939f, -0.05880495f, 0.20586878f, -0.12929648f, -0.15461510f, 0.07921751f, 
    0.04599602f, -0.03812693f, -0.06361321f, 0.01214339f, 0.05242765f, -0.03509074f, -0.00341861f, 0.09856196f, 
    -0.07368302f, 0.00403698f, -0.06128669f, 0.05484161f, -0.28213143f, -0.25953430f, 0.18196514f, 0.14277895f, 
    0.05154433f, -0.01472412f, 0.05560242f, 0.04391983f, 0.09028199f, 0.12785527f, -0.15818004f, -0.04013530f, 
    -0.02132213f, 0.10702767f, -0.00168161f, -0.11574597f, 0.04335716f, 0.04997145f, 0.03451981f, -0.14502311f, 
    -0.18034837f, 0.27749255f, -0.15780318f, -0.01036988f, -0.05532599f, 0.10392342f, 0.06396912f, -0.07311639f, 
    0.08329912f, 0.01758054f, -0.01816212f, -0.06928425f, 0.11775193f, 0.06700329f, -0.03527692f, 0.06475578f, 
    -0.02489913f, -0.11590565f, -0.06136925f, 0.00125070f, -0.12728338f, -0.00754552f, 0.17823094f, -0.01237654f, 
    -0.09156121f, 0.01564733f, 0.05122035f, 0.05653096f, -0.15985480f, 0.02336874f, -0.07263947f, 0.14996119f, 
    0.01374102f, 0.01519025f, 0.00314048f, 0.04979254f, -0.12607749f, 0.06544233f, -0.11797778f, 0.07601216f, 
    0.05188539f, -0.20767675f, 0.06817967f, -0.03329099f, 0.02595173f, -0.02554912f, 0.16098396f, 0.08725086f, 
    0.07047217f, 0.10006244f, -0.04324879f, -0.04219200f, 0.13394256f, -0.10694516f, 0.02973068f, -0.00035684f, 
    0.03239668f, 0.00865344f, -0.03994340f, 0.17134191f, -0.18329136f, 0.16550660f, 0.07397966f, 0.00971935f, 
    -0.02847221f, -0.13824880f, -0.00749986f, -0.00638817f, -0.02398600f, 0.01407911f, 0.12271670f, 0.04421305f, 
    -0.06127590f, -0.02539133f, 0.01590746f, -0.05700554f, -0.06172063f, 0.00496696f, -0.06537728f, -0.01159743f, 
    0.33319920f, -0.05771649f, 0.21785358f, -0.06262480f, 0.17374544f, 0.00657128f, 0.01814812f, -0.09504603f, 
    0.02210381f, 0.15051854f, -0.02750777f, 0.06059705f, 0.11927817f, 0.07154278f, -0.05402918f, -0.00777588f, 
    -0.02689738f, -0.09492608f, -0.03562463f, 0.09480797f, 0.09747417f, -0.16687718f, 0.32164910f, 0.02394419f, 
    -0.00302796f, -0.11246432f, 0.00062374f, 0.07027733f, 0.08318870f, -0.08679730f, -0.05212453f, -0.19642837f, 
    0.01997613f, 0.15720305f, 0.04127149f, -0.01228114f, -0.06909858f, -0.01353151f, 0.09518298f, -0.04735806f, 
    -0.30746767f, 0.06020170f, -0.09210700f, -0.00458976f, -0.36012372f, 0.04278759f, 0.15160145f, -0.11235240f, 
    -0.01989160f, 0.12257265f, 0.00562883f, 0.05590348f, 0.00859001f, 0.08631449f, -0.08502045f, 0.03491043f, 
    0.01695285f, -0.11311448f, -0.03306180f, 0.03841146f, 0.10558919f, 0.19678912f, 0.16012624f, 0.00282910f, 
    0.05220122f, -0.15993440f, -0.20815861f, -0.02733448f, 0.07332601f, 0.01009789f, -0.02933135f, -0.00604065f, 
    0.00332423f, 0.02411813f, -0.02133541f, 0.12072445f, 0.05012912f, -0.10813162f, -0.02954760f, 0.05615155f, 
    -0.08690464f, -0.01200366f, 0.05124560f, -0.02977696f, -0.18822180f, 0.04723328f, 0.13451041f, 0.10331359f, 
    -0.02341481f, -0.01193110f, 0.00839748f, -0.06408909f, -0.02144136f, -0.05560209f, 0.01830779f, 0.09157887f, 
    0.05721619f, 0.04944011f, -0.03811270f, 0.02389131f, 0.22296646f, -0.32211059f, 0.01883051f, -0.18993811f, 
    -0.09445425f, 0.06151209f, -0.03729403f, 0.04630961f, 0.01526875f, -0.06239109f, -0.05798589f, 0.04871550f, 
    -0.11429505f, -0.01399675f, -0.12974738f, -0.05141021f, -0.07860086f, 0.06806774f, 0.09941565f, -0.16981086f, 
    -0.05229459f, 0.28822136f, -0.16894940f, 0.00655123f, 0.06966080f, -0.01684935f, 0.05817671f, 0.04045902f, 
    0.06580501f, -0.03919965f, -0.00533603f, -0.08794311f, 0.10975429f, -0.01307798f, 0.00112190f, -0.09499332f, 
    -0.06880414f, -0.00347026f, 0.11555851f, -0.02211998f, -0.07456111f, -0.22062165f, 0.06948349f, -0.07817777f, 
    0.01128902f, 0.07520106f, -0.20407350f, 0.13802934f, 0.00785728f, -0.06616855f, 0.00280774f, -0.10770880f, 
    0.09679817f, 0.07498556f, 0.06740732f, -0.06100357f, 0.07085004f, 0.11288166f, -0.02072451f, 0.08491888f, 
    0.07743709f, -0.12992804f, -0.08722980f, -0.11222617f, -0.02705845f, 0.07240988f, 0.14367710f, -0.03619128f, 
    0.01470617f, -0.04068473f, 0.14128298f, 0.00797813f, -0.05770743f, -0.06364673f, -0.04997465f, 0.10350007f, 
    -0.01190280f, 0.07710332f, -0.07678518f, 0.07063165f, -0.07315043f, 0.04330667f, -0.04288201f, 0.03903972f, 
    0.02560295f, 0.09052958f, -0.00737839f, -0.05365242f, 0.11731631f, -0.04764255f, -0.04778864f, -0.04089727f, 
    -0.02830961f, -0.07392168f, 0.00231601f, 0.01371151f, -0.08194464f, 0.04836127f, -0.00233339f, -0.01837889f, 
    0.33106744f, -0.11436039f, 0.20467196f, -0.14757374f, 0.02959722f, -0.03170047f, -0.04797810f, -0.02978083f, 
    0.03373516f, 0.04331101f, 0.03391403f, -0.10855056f, -0.00203287f, 0.00947883f, 0.03653268f, 0.14925300f, 
    -0.08743775f, 0.16889779f, 0.01454905f, 0.12781513f, 0.41564474f, 0.07334520f, 0.15559386f, 0.04292475f, 
    0.15973388f, -0.18202840f, -0.15535647f, -0.08406448f, 0.13504209f, -0.07189693f, -0.04540084f, 0.02902638f, 
    -0.05065311f, -0.00495964f, -0.03035343f, -0.04272562f, -0.05603757f, -0.05162726f, -0.10962835f, -0.08448339f, 
    -0.12254237f, -0.07093690f, 0.07698307f, 0.04786561f, 0.01219395f, -0.03961586f, 0.04415407f, -0.02897236f, 
    -0.11669668f, 0.06700591f, 0.03227367f, 0.10709137f, 0.07683344f, -0.04128969f, -0.04310507f, -0.04358430f, 
    -0.09606857f, -0.01982352f, 0.04274889f, 0.03461811f, 0.04885396f, -0.22032194f, 0.02303608f, -0.01306020f, 
    0.02450217f, -0.01823018f, 0.01748448f, 0.02673384f, 0.00170266f, 0.04232971f, 0.07315741f, -0.00350225f, 
    0.10144013f, -0.05373891f, 0.01785073f, -0.07538489f, 0.01191957f, 0.06444833f, -0.00820953f, 0.09984338f, 
    0.16812596f, 0.07498150f, 0.09575295f, -0.02100839f, 0.08599637f, 0.08812249f, 0.04835120f, -0.06391263f, 
    -0.00466148f, 0.06710494f, 0.05511147f, 0.02749932f, 0.05107895f, -0.02069888f, -0.07696189f, -0.02837571f, 
    0.01872029f, 0.06820213f, 0.00249465f, -0.03806188f, 0.08573767f, 0.17157295f, -0.19757029f, 0.29762688f, 
    -0.07049530f, -0.11835188f, 0.03705602f, -0.03647740f, 0.08700118f, 0.06129063f, 0.06874597f, -0.01847938f, 
    -0.07196346f, 0.09620152f, -0.10423125f, 0.06393904f, -0.07535844f, -0.08120108f, 0.00598544f, 0.00538630f, 
    -0.07347049f, -0.35970309f, 0.03531121f, 0.10724592f, -0.03550458f, 0.08389157f, 0.02732096f, 0.12828241f, 
    0.09329557f, 0.04548316f, -0.00317859f, 0.01181886f, 0.03939428f, 0.02993569f, 0.01387219f, -0.06512889f, 
    -0.01450410f, -0.00476141f, 0.02018614f, -0.00504699f, -0.26772299f, -0.25562418f, 0.33971849f, -0.08821695f, 
    0.06550661f, -0.04059142f, 0.09205107f, -0.00907113f, -0.02928194f, 0.12571356f, 0.00848131f, 0.01514318f, 
    0.10027078f, -0.13223763f, -0.12206592f, 0.10044358f, -0.10719330f, 0.09435418f, -0.06863150f, -0.03552020f, 
    0.05633220f, 0.20846227f, 0.01201082f, 0.17495385f, 0.10467967f, -0.09020545f, -0.01908376f, 0.14901043f, 
    -0.10418708f, 0.03079221f, -0.02047252f, -0.03239136f, 0.08583193f, -0.10474407f, 0.09984068f, 0.01577580f, 
    -0.09420135f, 0.02380121f, 0.09384696f, -0.00833086f, -0.19262122f, -0.06453533f, -0.09583911f, -0.03130423f, 
    -0.36049005f, 0.00035236f, 0.19234374f, 0.13726193f, 0.08676531f, -0.02788916f, -0.09079911f, -0.00436275f, 
    -0.05876900f, -0.06508056f, -0.08399881f, 0.10328186f, 0.03992803f, 0.02397500f, -0.02638112f, -0.00834247f, 
    -0.08371282f, -0.05012885f, -0.12571549f, -0.00558365f, -0.10423103f, 0.03489096f, 0.10336174f, -0.20908438f, 
    0.02398137f, -0.10219235f, 0.02056736f, 0.07045775f, -0.00102368f, 0.05892761f, 0.06287076f, 0.05283889f, 
    0.22107853f, -0.13540301f, -0.01666434f, 0.05768082f, 0.03926435f, 0.11947676f, -0.01429143f, -0.04945043f, 
    0.00033804f, 0.13329832f, 0.12540622f, -0.14637962f, -0.01958845f, -0.08055288f, 0.16787823f, 0.03963297f, 
    -0.04447887f, 0.00189012f, 0.04953174f, 0.09684167f, 0.01265118f, -0.04713603f, -0.03322259f, 0.02436509f, 
    -0.00203355f, -0.08085111f, -0.28427362f, 0.10223807f, -0.40111256f, -0.05616239f, 0.04947589f, 0.06433567f, 
    0.04156436f, -0.01637286f, -0.08118299f, -0.00433942f, -0.09369908f, -0.07632187f, -0.09771325f, -0.01500768f, 
    -0.08391423f, 0.01361837f, -0.01792870f, 0.09422566f, 0.33640862f, -0.22832590f, 0.12292879f, 0.03335430f, 
    0.34574085f, -0.12169926f, 0.12982756f, 0.01622442f, 0.10228117f, 0.03165058f, 0.08060611f, 0.08310305f, 
    -0.02827789f, 0.05623118f, 0.07276134f, -0.07992680f, -0.08595087f, 0.02808377f, -0.03723237f, -0.03898525f, 
    0.00624166f, -0.00331423f, 0.00137124f, 0.02626806f, -0.03994020f, -0.04147391f, -0.01253334f, -0.02977146f, 
    -0.04019230f, 0.02321549f, -0.03697440f, -0.01617623f, -0.01932634f, -0.03423453f, -0.02916146f, 0.01413266f, 
    -0.00615396f, -0.03539979f, 0.01536444f, -0.04126250f, 0.02732772f, 0.01722736f, -0.02836428f, 0.02405700f, 
    0.01853888f, -0.03041646f, 0.04059236f, -0.03687182f, -0.01672802f, -0.04416123f, -0.04691902f, -0.00898463f, 
    0.01313709f, -0.03386464f, 0.03436011f, 0.03200734f, 0.02266395f, 0.03092269f, -0.03469553f, -0.04278112f, 
    0.01197640f, -0.03930384f, -0.03121688f, 0.04418313f, 0.00149685f, 0.01435884f, -0.02988924f, 0.02176752f, 
    -0.02646956f, -0.03398984f, 0.00473782f, -0.03752748f, -0.02093186f, -0.02344507f, 0.01881290f, 0.01853907f, 
    -0.00672289f, -0.02571309f, -0.03922559f, 0.02051355f, 0.01379176f, -0.01979005f, -0.02147426f, -0.02865838f, 
    0.01634327f, 0.01129128f, -0.03726126f, 0.03004724f, 0.00083877f, -0.03368926f, 0.03958349f, 0.02757076f, 
    0.00745477f, -0.03008157f, -0.04683981f, -0.02769586f, -0.00878760f, -0.03501307f, 0.03853204f, -0.00477751f, 
    -0.00795466f, 0.01704247f, 0.03156980f, 0.01864859f, -0.04774522f, 0.02393125f, 0.01556097f, -0.02313522f, 
    0.02518075f, -0.02452751f, 0.00787336f, 0.00772363f, -0.02454782f, -0.02487521f, -0.00628780f, 0.02363283f, 
    -0.03305078f, 0.01553126f, 0.01412866f, 0.02136070f, 0.01953535f, -0.00291996f, -0.01144020f, -0.02473375f, 
    -0.02205580f, 0.01046794f, 0.02459867f, -0.02688159f, -0.01086400f, 0.00354207f, -0.01503843f, 0.01367859f, 
    0.01664700f, -0.00623591f, -0.03986415f, 0.02737420f, -0.02044763f, 0.02066365f, -0.00765838f, 0.02494262f, 
    -0.01736996f, 0.02845451f, -0.03304217f, -0.00216714f, 0.01622528f, -0.01421049f, 0.01441975f, 0.01814514f, 
    -0.02067128f, -0.00443753f, -0.01850476f, -0.03701894f, -0.02357738f, -0.02186661f, 0.00158313f, 0.02838136f, 
    -0.01834837f, 0.02413895f, 0.04600222f, 0.03184262f, -0.00828295f, 0.02930162f, 0.02583779f, 0.00858975f, 
    -0.04002486f, 0.01046933f, -0.00614909f, -0.02588483f, 0.01855375f, 0.00631534f, 0.02549686f, 0.00451007f, 
    -0.01249989f, 0.00829950f, -0.00199356f, -0.02798360f, -0.01676990f, -0.01679417f, 0.02469628f, -0.00315630f, 
    -0.01356350f, -0.02843152f, 0.02903432f, 0.00144526f, 0.02235173f, 0.00385919f, 0.01950143f, 0.03437244f, 
    0.02376346f, -0.04227436f, -0.03837410f, -0.04012291f, 0.02855101f, -0.03279324f, 0.00305990f, -0.01222842f, 
    -0.02111277f, -0.02240905f, -0.03098306f, -0.04057619f, 0.00226630f, 0.01021765f, 0.02325172f, -0.03382044f, 
    0.00915605f, 0.02528011f, -0.00845179f, -0.00243404f, -0.02803523f, 0.00537710f, 0.01450649f, -0.00622258f, 
    0.00509939f, -0.01320296f, 0.02972071f, -0.03299028f, 0.01522357f, -0.03654076f, 0.01285018f, -0.02469787f, 
    0.02025484f, 0.01843700f, -0.00219752f, 0.00513428f, 0.00498808f, -0.01871121f, -0.03673605f, -0.00401200f, 
    -0.01422137f, 0.00452506f, -0.02405503f, -0.02778538f, -0.02779748f, -0.01809406f, -0.01030257f, -0.03086334f, 
    0.02120503f, -0.03132738f, -0.02439608f, -0.04306172f, 0.02901218f, -0.04437812f, -0.00820076f, 0.00484617f, 
    -0.03182108f, 0.01618218f, -0.01432971f, -0.00384609f, -0.02152680f, 0.00349455f, 0.02700619f, -0.00258933f, 
    -0.03143121f, 0.01327420f, 0.00457571f, -0.03091626f, 0.02337365f, -0.01120782f, 0.01634833f, -0.03576323f, 
    -0.01845782f, -0.04621288f, 0.01673651f, 0.02254465f, -0.04580839f, -0.02396977f, -0.00984135f, -0.02256928f, 
    0.01622020f, -0.00133999f, 0.01659367f, 0.01170728f, 0.03227869f, -0.04199459f, -0.02407561f, 0.00673279f, 
    0.03295038f, -0.00249300f, -0.04640277f, -0.03992495f, -0.03402972f, 0.01259541f, -0.02344092f, -0.02149863f, 
    -0.02596127f, -0.03499948f, -0.01371934f, 0.00658927f, -0.03983812f, -0.00058834f, -0.00853792f, -0.00063878f, 
    0.02344843f, -0.02312615f, -0.03658484f, -0.00051353f, -0.03170742f, -0.03496685f, -0.03827313f, 0.00461412f, 
    -0.03124821f, -0.03112397f, -0.04528183f, 0.01819218f, -0.00874960f, -0.00747755f, 0.03190291f, -0.01292481f, 
    0.01771556f, 0.02655052f, -0.02539671f, -0.00215944f, 0.02965921f, -0.00429919f, -0.01524336f, 0.01987275f, 
    -0.03162941f, 0.02323025f, 0.01476010f, -0.02769717f, 0.00941373f, 0.00403728f, 0.02746706f, -0.03648627f, 
    0.01005716f, -0.00482660f, -0.02087414f, -0.02505883f, -0.03739518f, 0.03307818f, -0.00575313f, -0.00994545f, 
    -0.04083059f, -0.01491130f, -0.04063213f, -0.01856126f, 0.01820757f, 0.00850147f, 0.00144028f, -0.02546279f, 
    -0.01672927f, 0.01732881f, -0.01101297f, 0.00819340f, 0.00826412f, 0.02555650f, 0.03230257f, 0.01422673f, 
    -0.02017641f, 0.03061106f, -0.01331949f, -0.02410397f, -0.02806597f, 0.03301442f, 0.03162555f, -0.01796354f, 
    -0.03571315f, -0.01623612f, 0.04536878f, -0.00618301f, -0.03587699f, -0.02146834f, -0.03923390f, 0.00223848f, 
    0.03141122f, 0.01754596f, -0.01319048f, 0.00223809f, 0.02924384f, -0.01776323f, 0.03411926f, -0.01119771f, 
    0.00502380f, 0.00404082f, 0.03344512f, 0.02249900f, -0.04285988f, -0.04437524f, 0.02590062f, 0.02915349f, 
    -0.00081292f, -0.03824418f, -0.01076453f, 0.03023274f, 0.02496650f, -0.00091520f, -0.03298018f, -0.00349669f, 
    0.02799319f, -0.02727090f, 0.02307967f, -0.00398078f, 0.00646071f, 0.00848500f, -0.02012182f, -0.02728324f, 
    0.00649043f, -0.02250570f, 0.00671824f, 0.02631898f, -0.01505944f, 0.02600481f, -0.00130742f, -0.04204948f, 
    -0.01793493f, 0.01878775f, 0.00010582f, -0.03686601f, -0.03387884f, -0.01401729f, 0.01587166f, -0.01279601f, 
    -0.02354160f, 0.02768687f, 0.02152509f, -0.01018235f, 0.02312180f, 0.02358106f, -0.00415238f, -0.01752238f, 
    0.00951524f, -0.01135298f, 0.00920295f, -0.00305466f, -0.03583312f, -0.00464507f, -0.02621212f, -0.03735244f, 
    -0.02012006f, -0.00972971f, -0.02821929f, -0.02090617f, 0.01768085f, 0.02102387f, -0.03177704f, -0.00433677f, 
    -0.04311163f, -0.00586974f, -0.03306409f, -0.04676622f, 0.01123177f, 0.02215815f, 0.02384186f, -0.00806681f, 
    -0.00495958f, 0.03502405f, 0.01246794f, 0.01866520f, 0.00508842f, 0.01882098f, -0.02523189f, -0.00472707f, 
    -0.03914010f, 0.03054055f, -0.00750089f, 0.01570724f, -0.03614774f, -0.03507266f, -0.03952036f, 0.00422822f, 
    0.02504939f, -0.03097872f, -0.01269974f, -0.04291926f, -0.02313922f, -0.03196527f, 0.01521183f, 0.00829139f, 
    0.00768860f, 0.03415132f, 0.01964337f, -0.02843704f, 0.02854902f, 0.01726274f, -0.01430478f, 0.03130439f, 
    0.03089022f, -0.04201737f, -0.02286185f, 0.03157285f, 0.01690553f, 0.04308315f, -0.01508540f, 0.02402187f, 
    0.02509419f, -0.01446761f, 0.02081686f, 0.02057709f, 0.03059144f, 0.02048185f, -0.03081763f, -0.01204929f, 
    0.00862831f, -0.03373257f, 0.02934423f, -0.01662933f, 0.02319462f, 0.00100773f, 0.02007040f, -0.01228191f, 
    0.03528111f, 0.02689197f, 0.00316506f, 0.03226799f, -0.03655064f, 0.02798462f, -0.03198737f, -0.03399382f, 
    -0.02032619f, -0.01952320f, 0.01368311f, 0.03086540f, -0.02913980f, 0.02986787f, -0.03471305f, 0.03260842f, 
    -0.00960677f, -0.02523332f, -0.00436966f, -0.01059103f, -0.00128853f, 0.01533112f, -0.04195496f, 0.00501235f, 
    -0.02115061f, 0.00590356f, 0.01768158f, 0.02354150f, -0.00515453f, -0.02954544f, 0.00255622f, 0.00121517f, 
    -0.02499886f, 0.00906463f, 0.01078803f, -0.02183689f, 0.01684426f, -0.01203817f, -0.01122681f, 0.01847028f, 
    -0.03987614f, -0.00742966f, -0.02238914f, -0.01603136f, -0.04133867f, 0.00886757f, 0.02727120f, 0.01942868f, 
    -0.02225739f, 0.00256174f, -0.01753239f, -0.02167762f, -0.01066065f, -0.01791436f, 0.01699383f, -0.01278497f, 
    0.00164844f, -0.00979327f, -0.00181606f, -0.01733565f, -0.02932459f, -0.04325629f, -0.03254591f, -0.02741897f, 
    0.01095084f, -0.02891853f, 0.01704410f, -0.01060932f, -0.00032353f, -0.02500604f, 0.00381184f, 0.03618543f, 
    0.00610828f, -0.04601626f, 0.02546937f, -0.01159383f, 0.03100592f, -0.03521185f, -0.02263736f, 0.01638836f, 
    0.00293099f, 0.02205125f, -0.00478289f, 0.02990370f, -0.03387398f, 0.00887141f, 0.01410288f, 0.02180647f, 
    -0.01999973f, 0.02798290f, 0.02184379f, 0.02167383f, -0.01273795f, 0.00537528f, 0.03143720f, 0.03981869f, 
    0.02323150f, -0.03663755f, 0.01245795f, -0.01410259f, 0.00854738f, -0.03192281f, 0.02493609f, -0.03815599f, 
    0.00020990f, 0.00501837f, 0.01106293f, 0.01651716f, -0.00641882f, -0.00469383f, -0.02877212f, -0.01403822f, 
    -0.04045019f, -0.04269917f, -0.02646981f, 0.02442055f, 0.02939443f, -0.00123300f, 0.01468923f, -0.00653944f, 
    -0.03988184f, 0.01958987f, -0.01337162f, -0.04122029f, 0.02171915f, 0.01114774f, -0.00909790f, -0.02171391f, 
    0.01930791f, -0.01846188f, 0.00351970f, 0.00008364f, -0.00943236f, -0.00754528f, 0.03140200f, 0.04267713f, 
    -0.00003327f, 0.00437271f, 0.02365126f, 0.00813079f, -0.01785277f, 0.01152352f, -0.02973154f, -0.00059723f, 
    0.00639106f, -0.01785988f, -0.01964663f, -0.02056905f, 0.00703373f, 0.00616348f, 0.02295673f, -0.03109995f, 
    0.01637803f, 0.03002933f, -0.03317384f, 0.00419773f, -0.00922427f, 0.03063967f, 0.03010341f, 0.03852973f, 
    0.00971815f, -0.03805539f, 0.01310954f, -0.00675496f, 0.03881834f, 0.01939635f, 0.02823376f, 0.01966817f, 
    -0.03530674f, 0.01194676f, -0.00427405f, -0.02658515f, -0.01083282f, -0.00747993f, -0.04546198f, 0.02134539f, 
    0.01024990f, 0.02828110f, -0.00505891f, -0.03083695f, -0.02188256f, 0.00030455f, 0.01724608f, -0.03386196f, 
    -0.04371451f, -0.00598693f, -0.03997760f, 0.00659723f, -0.02815808f, -0.04126047f, 0.01503006f, 0.02458967f, 
    0.02013689f, -0.01286037f, -0.03361173f, 0.01575283f, -0.02149143f, -0.04204929f, -0.02712359f, -0.02619347f, 
    0.01797301f, -0.01107578f, -0.01332071f, 0.03022148f, 0.02182988f, -0.00908912f, -0.00923731f, 0.01733764f, 
    -0.00337549f, 0.01563224f, -0.03082828f, 0.00358596f, 0.02568589f, 0.01427124f, -0.00708415f, 0.01484085f, 
    0.00240497f, 0.01028904f, -0.00788830f, 0.01831670f, -0.03864622f, -0.00817514f, -0.00248456f, 0.00171721f, 
    -0.02902349f, 0.02869011f, 0.00407630f, 0.00745327f, -0.00002056f, -0.01836486f, -0.01139096f, 0.00872639f, 
    0.01870651f, -0.01710845f, -0.01536370f, -0.03743084f, -0.01592364f, -0.04543047f, -0.03677530f, -0.04065183f, 
    0.00515963f, 0.01006452f, 0.03051282f, -0.02139626f, 0.01455007f, 0.02970838f, -0.04067421f, 0.00732337f, 
    -0.02442965f, 0.00619183f, -0.01825984f, -0.03249765f, -0.02824680f, -0.01773397f, -0.01998855f, 0.00688427f, 
    0.02873991f, -0.00956592f, -0.00919189f, -0.00290920f, -0.00002296f, 0.03644208f, 0.02451759f, 0.02597209f, 
    0.02410192f, 0.02255274f, 0.01105873f, -0.03055318f, 0.02370302f, -0.01005346f, -0.01874267f, -0.02992103f, 
    -0.02576676f, -0.04375262f, -0.01265728f, -0.04397529f, 0.01506873f, 0.00207724f, -0.00594012f, -0.03853055f, 
    -0.01940272f, -0.01322758f, -0.02585825f, -0.01611853f, -0.01118684f, -0.03446992f, -0.03115275f, 0.02275958f, 
    -0.04246858f, 0.01491103f, -0.02920162f, 0.00940032f, -0.02785610f, 0.00675637f, -0.03910577f, 0.00896783f, 
    0.01957588f, 0.01804631f, 0.03528648f, 0.01762846f, 0.01631765f, 0.00670641f, -0.01917684f, -0.03658868f, 
    -0.01197493f, -0.00044496f, -0.02091908f, 0.02794277f, -0.01338870f, 0.01858563f, 0.02422572f, -0.02567569f, 
    -0.00869542f, 0.02422664f, -0.04410967f, 0.01131479f, 0.01463329f, -0.03879263f, 0.02191965f, 0.02037210f, 
    -0.02146585f, -0.02082323f, -0.00203852f, -0.04385773f, -0.03111950f, -0.00569440f, -0.04504609f, -0.01907445f, 
    -0.01434634f, 0.00182314f, -0.02028235f, 0.00423849f, -0.02605740f, -0.02713363f, 0.00792194f, -0.03858834f, 
    -0.01092752f, 0.02215363f, -0.01044714f, -0.02181517f, -0.04788418f, 0.02453735f, -0.01878915f, -0.04604588f, 
    -0.02159533f, -0.00002083f, -0.02123658f, -0.01215900f, -0.01985287f, -0.03756944f, -0.00748740f, -0.04761453f, 
    -0.01235039f, -0.03934270f, -0.04444221f, 0.02344108f, -0.02416005f, -0.03801147f, -0.00178377f, -0.03853038f, 
    0.02852516f, -0.00548355f, 0.02930857f, -0.00229215f, -0.03473077f, -0.03529386f, 0.00681929f, -0.01870989f, 
    -0.01081053f, -0.04638422f, -0.03773061f, -0.01841397f, -0.01617951f, -0.03333239f, -0.01780355f, 0.01506112f, 
    0.03033985f, -0.02981963f, 0.01993248f, -0.02624205f, -0.00642932f, 0.02215873f, -0.02330062f, -0.04369209f, 
    -0.03438810f, -0.01722472f, -0.02991745f, 0.00380659f, 0.01841856f, 0.01727321f, -0.00383044f, -0.03892492f, 
    0.01207591f, 0.02144470f, 0.02628641f, 0.00026255f, -0.02094966f, 0.01513071f, -0.02265439f, 0.02781485f, 
    0.03110688f, -0.01747046f, -0.04014095f, -0.02401679f, -0.00410697f, -0.02409406f, -0.00146402f, -0.00998707f, 
    -0.00091053f, -0.02414033f, 0.01732944f, 0.01598846f, 0.02004760f, 0.02476017f, -0.01948346f, 0.02981719f, 
    -0.03925923f, -0.04225893f, 0.00806809f, -0.04433443f, -0.03580848f, 0.02323802f, 0.01184758f, -0.04137597f, 
    0.01066315f, -0.03320064f, -0.02819564f, -0.00728260f, 0.03020922f, -0.03095059f, -0.03244089f, 0.01828821f, 
    -0.04115347f, 0.01712421f, -0.00275514f, -0.01040934f, -0.04639683f, -0.00956389f, -0.01422903f, -0.04348708f, 
    -0.03568323f, -0.00854601f, 0.00420697f, -0.04218247f, 0.02401075f, -0.02106530f, -0.00044413f, -0.00036813f, 
    -0.00572241f, -0.01978577f, 0.01630058f, 0.00320377f, -0.01373957f, -0.03327668f, 0.02954244f, -0.03384905f, 
    -0.04059941f, -0.02574401f, -0.03591764f, -0.00501247f, 0.03133025f, -0.02419180f, -0.01477734f, -0.03876736f, 
    -0.02752366f, 0.01063611f, 0.01157253f, -0.04511335f, -0.00423698f, -0.02538660f, -0.01328433f, -0.03035541f, 
    0.02593061f, 0.03043099f, 0.00652038f, -0.00951990f, 0.02024089f, 0.02545874f, 0.02275729f, -0.04097476f, 
    -0.02420127f, 0.02936162f, -0.02539134f, -0.02766386f, 0.01864137f, -0.03333519f, -0.00762617f, 0.02889878f, 
    0.00962348f, -0.02332787f, 0.02623213f, 0.01515495f, -0.02533294f, 0.02655347f, -0.01339667f, 0.01682438f, 
    0.02695092f, -0.00191395f, -0.00039172f, 0.00641367f, -0.00353283f, -0.03729900f, -0.00388094f, 0.00505776f, 
    -0.02511040f, -0.02240280f, 0.00712887f, -0.03607090f, -0.01817133f, 0.02128659f, -0.01756223f, -0.04189061f, 
    -0.00768723f, 0.01290802f, 0.02657798f, 0.00602090f, -0.04135978f, 0.02086383f, -0.02439040f, -0.03690407f, 
    0.00972714f, -0.02714470f, -0.02877112f, 0.00089342f, -0.01591062f, -0.01823926f, -0.01531388f, 0.02838008f, 
    -0.01276364f, -0.01016349f, 0.00919964f, 0.01912655f, 0.02640285f, 0.02161840f, -0.01103381f, 0.00671639f, 
    0.01649844f, 0.03133840f, -0.00627086f, -0.00348675f, 0.00532846f, -0.01913366f, -0.00420133f, -0.03669913f, 
    0.02582506f, -0.02537647f, -0.00906263f, 0.00788870f, -0.01761467f, -0.01986215f, -0.00277775f, -0.03306850f, 
    -0.00019003f, 0.00068633f, 0.02965475f, 0.02301990f, -0.01928144f, -0.01557881f, 0.00119203f, 0.02327270f, 
    0.02446395f, -0.02755191f, -0.02004852f, -0.03739563f, -0.01939398f, -0.01557271f, 0.02250109f, -0.02886018f, 
    0.00149565f, 0.02790995f, 0.00611960f, -0.02393740f, -0.02377068f, 0.00974485f, -0.00684895f, 0.03079353f, 
    -0.04490500f, -0.01173637f, -0.02235235f, -0.04067793f, 0.01162625f, 0.00213401f, -0.03248834f, -0.03310532f, 
    0.01806833f, -0.01891795f, -0.02438083f, 0.01579626f, -0.01121541f, 0.02078402f, -0.01189170f, -0.03736956f, 
    0.01329248f, -0.04166055f, -0.03166833f, -0.03625771f, 0.02635140f, -0.02283533f, 0.01652511f, 0.02869857f, 
    -0.04009236f, -0.03562318f, -0.03658670f, -0.01063310f, -0.02710365f, -0.00441548f, 0.01995237f, -0.00579025f, 
    -0.03395002f, 0.02049372f, 0.01958171f, 0.01786594f, -0.00758982f, -0.02087151f, -0.03939286f, -0.02118399f, 
    0.00633667f, -0.04064114f, 0.01651303f, -0.04613876f, -0.04229700f, 0.03073551f, 0.00807796f, -0.03365161f, 
    0.00251072f, -0.00858831f, 0.01429640f, -0.03978713f, -0.00764694f, 0.02745204f, 0.00798188f, -0.03337523f, 
    -0.02624699f, -0.01981860f, -0.01872157f, 0.01519674f, 0.02640037f, -0.04062814f, -0.03626909f, -0.00682345f, 
    0.01686294f, -0.02930104f, -0.02766370f, -0.00645027f, 0.00352621f, -0.03046540f, -0.03072579f, -0.03777374f, 
    -0.04478253f, -0.01229280f, 0.00567856f, 0.02981766f, -0.03416768f, 0.02892393f, 0.00673303f, 0.00659728f, 
    0.02576394f, -0.04636404f, 0.03041734f, 0.01417737f, -0.00079799f, -0.01737485f, -0.01084857f, 0.01505295f, 
    0.02480882f, -0.00287645f, -0.04455280f, 0.01202931f, -0.00403159f, 0.02917546f, 0.01867977f, -0.01403402f, 
    0.00066455f, -0.02304276f, -0.01843222f, -0.02283117f, 0.00676160f, 0.01562683f, -0.03018128f, -0.01220410f, 
    0.01877259f, -0.03209298f, -0.03179792f, -0.03884201f, -0.04259946f, -0.00960887f, 0.00758836f, -0.01221169f, 
    0.00907801f, -0.03677158f, 0.02810731f, 0.01954126f, 0.01979435f, 0.00229598f, -0.02739727f, -0.02725495f, 
    0.01863640f, -0.00062211f, -0.02172906f, 0.00408981f, 0.01060425f, -0.00028786f, -0.00656128f, 0.00393512f, 
    0.02180177f, -0.02225996f, -0.00734185f, -0.01741206f, -0.00915247f, -0.01036107f, -0.00659343f, -0.03604525f, 
    0.02386784f, 0.01266566f, -0.03931444f, 0.01931818f, 0.01662374f, -0.03752585f, 0.02810002f, -0.02823513f, 
    0.00847051f, -0.01308648f, -0.00589150f, -0.01954468f, -0.02698419f, -0.03392635f, -0.02300747f, 0.03192449f, 
    -0.01193320f, 0.00677400f, -0.00717837f, 0.01849893f, 0.02381534f, -0.03409393f, 0.01845013f, -0.04530196f, 
    0.02341460f, 0.01687567f, 0.00078717f, -0.02797540f, -0.01735570f, -0.01472333f, 0.02775198f, 0.00399070f, 
    0.02883517f, -0.02108883f, -0.01123488f, -0.02845146f, 0.01900073f, 0.00410759f, -0.03394036f, -0.02246170f, 
    -0.03761894f, 0.02114014f, -0.01505626f, -0.01919983f, -0.01797067f, -0.00514837f, -0.02102048f, -0.00124776f, 
    -0.02485486f, 0.00590844f, 0.00268414f, 0.00762362f, -0.01390075f, 0.00969133f, 0.01121878f, -0.00919859f, 
    -0.00106416f, -0.01256612f, -0.00345371f, -0.00779325f, 0.00978660f, 0.02570634f, 0.01228762f, 0.02623531f, 
    -0.02781537f, -0.01998416f, -0.00261169f, 0.00803296f, 0.01777258f, -0.04061414f, 0.00133148f, 0.01254801f, 
    0.00630578f, -0.03820749f, -0.04355856f, -0.03114874f, -0.00267558f, 0.03402999f, -0.04028780f, 0.01302901f, 
    -0.03439887f, -0.00018856f, 0.02764779f, -0.02389866f, -0.00460575f, 0.00707223f, 0.01883261f, 0.01113973f, 
    -0.02991077f, 0.05070013f, -0.03645286f, -0.08830547f, 0.16493893f, 0.05506036f, 0.03250409f, -0.00518019f, 
    -0.13824570f, -0.15122953f, 0.07235484f, 0.02730917f, 0.03980641f, 0.11789955f, 0.06217563f, -0.08623085f, 
    0.02818681f, -0.08049610f, -0.03502068f, 0.05224728f, -0.19900462f, -0.18677203f, -0.22861992f, -0.16103524f, 
    0.04684225f, -0.02295595f, -0.00580928f, 0.15266208f, 0.10310315f, 0.06380808f, 0.00417074f, -0.07076607f, 
    0.07920052f, 0.01919943f, -0.00750201f, 0.06716691f, 0.06949839f, -0.01121460f, 0.05937548f, 0.05181705f, 
    -0.14628579f, -0.30133271f, -0.03777264f, -0.38658661f, -0.46605179f, 0.07480188f, 0.11670236f, -0.15032290f, 
    -0.16101424f, 0.07577251f, 0.13908747f, 0.03155002f, -0.13303798f, 0.12163282f, -0.02883740f, -0.03634661f, 
    -0.00825951f, -0.03049844f, -0.05427423f, -0.02474584f, 0.17361216f, 0.17325032f, -0.17968519f, 0.18476473f, 
    0.05614298f, -0.01968599f, 0.12383221f, 0.07978326f, -0.01845173f, -0.15017572f, 0.06223045f, 0.06864824f, 
    -0.07959349f, -0.06917439f, 0.06500868f, 0.09542999f, 0.05774679f, 0.08650034f, -0.06531146f, 0.06846795f, 
    0.30795041f, -0.17845045f, 0.21251519f, 0.17667173f, 0.06632355f, -0.02253048f, 0.03402039f, -0.06527471f, 
    -0.01514784f, -0.00861253f, 0.00672240f, 0.01101983f, -0.06183478f, -0.10405968f, 0.09991644f, -0.05913867f, 
    0.07340914f, 0.00064779f, -0.03458432f, -0.01816237f, -0.12325368f, 0.12906976f, -0.10372938f, 0.12984343f, 
    0.23964989f, -0.09096061f, -0.03795499f, 0.02819680f, 0.06437789f, 0.08231957f, 0.02296725f, -0.24488325f, 
    0.04025672f, 0.01046720f, -0.15717305f, 0.10891157f, 0.08780543f, -0.03471233f, 0.05555708f, -0.03886626f, 
    0.06614623f, 0.31854063f, -0.05761106f, 0.15143685f, 0.11743651f, 0.04121105f, -0.08043170f, 0.09205726f, 
    -0.00354214f, -0.06665701f, 0.06391733f, 0.01199679f, -0.09444761f, -0.02553271f, 0.00102620f, 0.01160095f, 
    0.04136152f, 0.06308808f, 0.13594031f, -0.03602609f, 0.26538146f, -0.20567645f, 0.11980730f, -0.36906177f, 
    -0.20196882f, 0.08444403f, 0.00366907f, -0.10877041f, -0.04630433f, 0.06900875f, 0.06095552f, -0.03284255f, 
    0.12804031f, 0.03137323f, -0.00903463f, 0.12766264f, 0.03765096f, -0.05364980f, 0.08706497f, 0.09509556f, 
    -0.43824106f, 0.05755902f, -0.28379545f, -0.08389176f, -0.25262925f, 0.13827004f, 0.11497504f, 0.24008708f, 
    -0.00937021f, -0.04081667f, 0.10837744f, 0.00769415f, -0.03127327f, -0.04579788f, 0.02442368f, 0.03242159f, 
    0.11359669f, 0.13625804f, 0.08453143f, -0.03830459f, -0.07297942f, 0.29969808f, -0.08430383f, -0.26409280f, 
    -0.14673351f, 0.20747820f, 0.03477385f, 0.03094113f, -0.12992387f, 0.13177226f, 0.12403958f, 0.21133313f, 
    0.14447875f, -0.21366890f, -0.00659743f, 0.04588589f, 0.12866670f, -0.00800013f, 0.01000218f, 0.03362120f, 
    0.30511311f, 0.12899379f, -0.01677131f, -0.00066526f, 0.36023718f, 0.06994092f, -0.07190898f, 0.05537784f, 
    0.11762345f, -0.04080813f, 0.03372031f, -0.06310704f, 0.10251638f, 0.00305284f, 0.07391094f, 0.01430728f, 
    -0.06799866f, 0.12200307f, 0.05648397f, 0.05794331f, -0.09938656f, -0.12668823f, -0.02641467f, -0.30602056f, 
    -0.38004774f, 0.16167663f, 0.11089164f, 0.01623909f, -0.04696114f, 0.02665528f, 0.20115441f, 0.07830144f, 
    0.01838337f, 0.06303956f, 0.03818088f, -0.07378487f, -0.03775398f, 0.05058626f, -0.00607010f, 0.00123999f, 
    0.25765651f, 0.02765623f, -0.03602293f, 0.00472949f, 0.23430768f, 0.12204856f, -0.07228716f, -0.02950033f, 
    0.10569151f, 0.18779160f, -0.05074809f, 0.00910327f, 0.01967366f, 0.08653037f, -0.00667103f, -0.09933114f, 
    -0.05722784f, -0.01432538f, 0.07962874f, 0.02945630f, -0.16426009f, 0.36542535f, -0.05434897f, 0.31052175f, 
    0.27451244f, 0.03245136f, -0.10304489f, 0.07926784f, 0.01389238f, 0.10771815f, 0.01084942f, -0.11954627f, 
    0.12979124f, 0.07883757f, 0.13831535f, 0.12977245f, 0.12964456f, -0.04104047f, -0.04546553f, 0.20881926f, 
    0.48403496f, -0.45003915f, 0.18810299f, 0.19832775f, -0.01503616f, 0.00041253f, -0.04564261f, -0.04396702f, 
    0.11907089f, 0.06943399f, 0.08331326f, 0.09566937f, -0.00146574f, -0.00016092f, -0.05770376f, 0.08018114f, 
    0.11936784f, 0.06839643f, -0.13384162f, 0.14233103f, 0.21272552f, 0.31522179f, -0.07291249f, 0.09049431f, 
    0.04492050f, -0.12250780f, 0.17956100f, 0.05916067f, 0.03837223f, -0.03624812f, 0.01427212f, 0.02686928f, 
    -0.06311097f, 0.01197731f, 0.04727059f, 0.13535605f, 0.01123138f, -0.12394111f, 0.05710281f, 0.01678226f, 
    0.02315394f, 0.08629548f, 0.29119194f, 0.19888864f, -0.01758297f, 0.12207592f, 0.01655208f, 0.12567870f, 
    -0.06087975f, 0.17734839f, -0.16792637f, -0.01930012f, 0.10440455f, -0.05278273f, -0.00456592f, -0.05963272f, 
    -0.01867338f, -0.08717156f, 0.03891577f, -0.07760140f, 0.10270527f, 0.19998395f, -0.04846928f, 0.02906710f, 
    0.14152661f, -0.00188815f, 0.04233854f, 0.06800897f, 0.03293490f, 0.02507402f, 0.02958810f, -0.01066152f, 
    -0.03985661f, -0.05214253f, -0.03150486f, -0.00929474f, -0.02070935f, 0.04164814f, 0.17189915f, 0.04736045f, 
    -0.22970223f, -0.06622695f, -0.17175910f, -0.14650321f, -0.29344964f, 0.10711940f, -0.08073453f, 0.13601577f, 
    -0.05684823f, 0.11172616f, -0.05072913f, 0.06721917f, 0.00874013f, -0.11804519f, 0.06189090f, 0.02573195f, 
    0.17184019f, -0.09223413f, -0.02490103f, -0.01824026f, -0.65451872f, 0.12138209f, -0.06103241f, 0.02906361f, 
    -0.23830837f, 0.29890600f, 0.08028574f, 0.10486861f, -0.09828668f, -0.00478764f, 0.11240428f, 0.04880193f, 
    0.04712725f, 0.03539753f, 0.10548676f, 0.11649299f, 0.12253156f, 0.14594430f, 0.10664344f, 0.06805684f, 
    0.13716750f, 0.10142649f, -0.08222638f, -0.07220030f, -0.00813466f, 0.05794708f, -0.04618207f, 0.02665289f, 
    0.14745618f, 0.01608433f, 0.07742873f, 0.00460069f, -0.00058332f, 0.04771934f, 0.03720767f, 0.06704530f, 
    0.03246986f, 0.07964296f, 0.01672522f, 0.06734660f, 0.10651883f, 0.26865458f, -0.07019870f, 0.11914923f, 
    -0.01659901f, 0.01619090f, 0.03484723f, 0.01963291f, -0.00461577f, -0.08347362f, -0.10055435f, 0.01626749f, 
    0.00283035f, -0.04317400f, 0.01528065f, 0.08877464f, 0.09150165f, 0.01200990f, 0.02553039f, -0.07408933f, 
    -0.23276648f, -0.19038816f, -0.11020054f, 0.15158667f, 0.07176438f, -0.12242329f, 0.00826083f, 0.08701675f, 
    0.00153897f, -0.03741448f, -0.05407514f, -0.03984309f, -0.10466894f, 0.12269509f, 0.18118708f, 0.21707495f, 
    -0.07930532f, 0.03107355f, 0.00762718f, 0.11026758f, 0.05553094f, 0.05528879f, 0.10630212f, -0.07658008f, 
    0.18255702f, 0.01620204f, 0.05769105f, -0.04419852f, -0.01034166f, -0.00781207f, -0.02753249f, 0.02933523f, 
    0.14401554f, -0.03398961f, 0.08669401f, -0.05747487f, 0.06748379f, 0.08966750f, 0.09615806f, 0.06724179f, 
    0.24095406f, 0.36602756f, -0.09122666f, -0.07303872f, 0.08793507f, 0.04917491f, 0.08134191f, 0.01016799f, 
    0.01109455f, -0.05536634f, 0.07163230f, 0.03285993f, -0.07871907f, -0.14582589f, -0.01036456f, 0.06616335f, 
    0.07313643f, -0.03174023f, 0.10110790f, 0.04924013f, 0.20244212f, -0.00585463f, -0.42412055f, -0.01172853f, 
    0.05858318f, 0.07662472f, 0.02910136f, -0.05976935f, -0.05788048f, 0.04422684f, 0.08018965f, -0.04567773f, 
    0.07392383f, 0.10457107f, 0.03663281f, 0.03668433f, 0.02414224f, 0.00688907f, 0.06641922f, 0.08782137f, 
    -0.13845800f, -0.21892898f, -0.12806308f, -0.23332585f, -0.11828769f, 0.21182534f, 0.17333643f, -0.16415083f, 
    0.16674687f, 0.02262234f, 0.06681465f, -0.05373495f, -0.02618891f, 0.13328718f, -0.00519687f, 0.06034740f, 
    0.01459379f, -0.00395522f, -0.08930533f, -0.00110235f, 0.23324014f, 0.19548069f, -0.05108449f, 0.08122713f, 
    0.36090726f, 0.15294555f, -0.04928313f, -0.00330269f, 0.01791090f, 0.15853095f, 0.05987297f, -0.03020911f, 
    0.05172554f, 0.17721587f, 0.05889750f, -0.04634253f, -0.09271964f, -0.02598912f, 0.05702600f, 0.05252773f, 
    0.25042564f, 0.14128077f, 0.19078043f, 0.16658303f, 0.12685002f, 0.07042506f, -0.13682330f, 0.20247190f, 
    -0.13537058f, 0.20515189f, -0.04829825f, -0.04809709f, 0.03230978f, 0.07170443f, -0.15800488f, 0.00863852f, 
    -0.26139888f, 0.04450518f, 0.00858272f, -0.03661134f, 0.05309548f, -0.31343883f, -0.00039760f, 0.11810127f, 
    -0.01762757f, -0.00900183f, -0.01303466f, 0.01184871f, 0.12107863f, 0.12678042f, -0.22678918f, 0.08498276f, 
    0.04316569f, 0.00089911f, -0.08868625f, -0.14697473f, 0.01068123f, 0.04148410f, -0.12219770f, 0.00306043f, 
    0.04415628f, 0.02689438f, 0.15288918f, -0.03507491f, 0.46190315f, -0.10971728f, -0.01655057f, 0.01754320f, 
    0.03872441f, -0.02552505f, 0.15410690f, -0.01477459f, 0.11970180f, 0.06516235f, 0.03234956f, 0.13705668f, 
    0.11675941f, -0.02433684f, 0.07304518f, 0.03634100f, -0.54094827f, -0.08451539f, -0.01857342f, -0.10726728f, 
    -0.43017918f, 0.18307762f, -0.00182937f, 0.18748723f, -0.13908102f, -0.04816452f, 0.10228864f, -0.01323429f, 
    0.04116643f, -0.03138951f, 0.02106014f, 0.07530978f, 0.04945141f, 0.07298552f, 0.02682062f, 0.03115036f, 
    0.01812481f, -0.03263856f, -0.02735566f, -0.02590088f, -0.02558981f, -0.03573140f, 0.02267414f, -0.04984405f, 
    0.02595031f, -0.00728016f, 0.00355167f, -0.00911764f, -0.03620334f, -0.04678288f, -0.04007948f, -0.00111718f, 
    0.00201518f, -0.00690172f, 0.00113526f, 0.01324263f, -0.00067902f, -0.03175332f, -0.04956508f, -0.02714905f, 
    -0.03428230f, -0.04673114f, 0.01885829f, -0.01595977f, -0.00307742f, -0.02417325f, 0.01356697f, -0.01213546f, 
    -0.04120612f, -0.02337400f, 0.01878664f, -0.04456975f, 0.01198555f, -0.03455398f, 0.01859577f, 0.01262374f, 
    -0.03272578f, -0.02218051f, 0.03207457f, -0.03041555f, -0.00945892f, 0.00102411f, -0.01159720f, 0.03595012f, 
    -0.03666646f, 0.03153393f, -0.03415521f, -0.02272194f, -0.03117482f, -0.01670092f, -0.03435668f, 0.01089527f, 
    -0.03038711f, 0.00877798f, 0.02229933f, 0.00325373f, -0.01756585f, 0.00370364f, -0.02463673f, 0.00809207f, 
    -0.01718252f, -0.04079494f, 0.02496971f, -0.04678943f, -0.00553520f, 0.00468273f, 0.02342090f, -0.04205791f, 
    -0.03881795f, -0.01132410f, -0.04266264f, 0.01942858f, -0.02283563f, -0.03175653f, -0.00058751f, -0.00522320f, 
    0.01857543f, -0.04150788f, -0.03088372f, 0.01655880f, -0.02953996f, -0.04969554f, 0.02146593f, -0.03876229f, 
    0.00588697f, -0.02314062f, -0.01666032f, -0.04205035f, -0.03960420f, -0.00341485f, 0.00550921f, 0.02666542f, 
    -0.01354612f, -0.04617153f, -0.03529718f, -0.03599491f, 0.01658803f, -0.04071218f, 0.02008273f, -0.02984329f, 
    0.01586612f, -0.04801819f, -0.01636814f, -0.03845815f, 0.00873338f, 0.00398877f, -0.01047841f, -0.01789089f, 
    -0.04253721f, -0.04419436f, -0.03637245f, 0.02028062f, -0.04526193f, -0.05165496f, 0.01630105f, 0.02952008f, 
    -0.00025801f, -0.00543606f, 0.01504109f, -0.03274370f, 0.00234497f, 0.01352122f, 0.00688557f, 0.00403820f, 
    0.00879691f, -0.03648233f, -0.04021109f, -0.04340357f, -0.02540359f, 0.00781548f, -0.01316969f, -0.00162933f, 
    0.02258071f, -0.01251321f, -0.03745297f, -0.04108217f, -0.00148993f, 0.00293244f, 0.02524491f, -0.05108451f, 
    -0.02805927f, -0.01612300f, -0.01279317f, 0.01590724f, -0.03625129f, -0.00184832f, 0.01306397f, -0.02218053f, 
    -0.03642873f, -0.02508683f, 0.00990752f, -0.03425970f, 0.00031067f, -0.02923204f, -0.02208847f, -0.00778570f, 
    0.00703616f, -0.02094861f, 0.00466587f, -0.00575919f, 0.02771691f, -0.02534003f, 0.01900831f, -0.00937292f, 
    -0.00459079f, 0.00925532f, 0.03726434f, 0.00583397f, -0.00011655f, -0.00519956f, -0.02829974f, 0.01986453f, 
    0.02212307f, -0.01417296f, 0.02097298f, -0.00930095f, 0.01655963f, -0.02796092f, 0.02272609f, -0.00401885f, 
    -0.02766570f, -0.03416119f, -0.00485126f, 0.01489054f, 0.01656155f, -0.04084889f, -0.03478733f, -0.00897822f, 
    0.00078911f, -0.03033423f, -0.02249895f, -0.03138014f, -0.00697612f, -0.00208535f, -0.03358591f, -0.05000040f, 
    -0.01653110f, -0.04704245f, -0.04153266f, 0.00467569f, -0.01526452f, -0.00768786f, 0.00077413f, -0.02775605f, 
    0.02658180f, -0.01641107f, -0.01887363f, -0.05099874f, -0.03933005f, 0.01177092f, 0.00752975f, -0.01345714f, 
    0.01389524f, -0.02036255f, 0.00275701f, 0.02546026f, -0.03981642f, -0.04290117f, -0.00763025f, 0.00709915f, 
    -0.00587490f, -0.00847823f, -0.03686184f, -0.03915637f, -0.03411319f, -0.01538894f, 0.01184619f, -0.02669103f, 
    -0.01661992f, -0.02282893f, -0.04320853f, -0.02924187f, -0.01356457f, -0.03882453f, -0.02583665f, 0.00631736f, 
    0.00864196f, -0.02794444f, -0.01559759f, -0.04028518f, -0.02641020f, -0.04932258f, -0.00732873f, -0.01274221f, 
    -0.00678277f, -0.04026727f, 0.02432253f, 0.01848146f, -0.01309471f, -0.02719400f, -0.02876787f, 0.01104759f, 
    0.02101491f, -0.02588838f, -0.02794423f, 0.00233370f, -0.04401048f, 0.00564731f, 0.00927517f, 0.00727149f, 
    -0.04927856f, -0.01814438f, -0.00287993f, 0.00679287f, 0.00027663f, -0.03426189f, -0.01179016f, -0.01036469f, 
    -0.00379570f, 0.00391097f, -0.01423767f, -0.02853696f, -0.01317407f, 0.02469518f, -0.01241073f, -0.05063689f, 
    -0.04404488f, -0.04185490f, -0.00271601f, 0.01768500f, -0.03935564f, -0.01256371f, -0.04889759f, -0.02115649f, 
    -0.00884738f, 0.00334080f, 0.01183153f, -0.05030063f, -0.04474650f, -0.04164175f, -0.00097197f, -0.04811852f, 
    -0.01699647f, -0.05022572f, -0.01200115f, -0.02277675f, -0.03807374f, -0.04334725f, 0.01003133f, 0.00339410f, 
    -0.00786169f, 0.01451178f, -0.00275605f, -0.00921300f, -0.05089574f, 0.01840300f, -0.04743285f, -0.01822824f, 
    -0.02526453f, 0.00424279f, 0.02206825f, -0.00983666f, 0.00043726f, -0.03279950f, 0.01336545f, 0.00149195f, 
    0.01425665f, 0.00484439f, -0.02052843f, -0.03054249f, -0.04328703f, -0.03637242f, -0.02785204f, 0.00867182f, 
    -0.04296534f, -0.00745230f, -0.04514263f, -0.00256322f, -0.01449631f, 0.02688770f, 0.01529931f, -0.03922497f, 
    0.03112844f, -0.04608178f, -0.02809655f, 0.00698635f, 0.01010044f, -0.04480271f, -0.02421633f, -0.00616996f, 
    0.02525081f, -0.02549678f, 0.01987099f, 0.02333660f, 0.00726113f, -0.00049886f, -0.02933049f, -0.03558388f, 
    -0.05078075f, 0.02725357f, 0.01325881f, -0.05121538f, 0.01787882f, -0.00766069f, -0.00715307f, -0.00425888f, 
    0.00881434f, 0.01320297f, 0.00397667f, -0.02301772f, -0.02282280f, -0.00404751f, -0.03360544f, -0.03577623f, 
    -0.01635936f, -0.02330661f, 0.02781276f, -0.05121898f, -0.03123279f, -0.00026239f, -0.00305635f, -0.03074957f, 
    0.00326031f, -0.01951740f, -0.01924457f, -0.03980725f, 0.02660353f, -0.01801882f, -0.04089361f, 0.00223423f, 
    0.00013479f, -0.01209754f, -0.04809805f, -0.01868959f, -0.01680647f, 0.00476189f, -0.00184853f, 0.02655880f, 
    -0.01721992f, -0.04681825f, 0.00813259f, 0.01176887f, 0.01786880f, -0.04239755f, 0.02814691f, -0.01380500f, 
    -0.03212788f, 0.00880535f, -0.02577935f, 0.02257897f, 0.01324822f, -0.02377599f, -0.04749613f, -0.04156336f, 
    0.00601770f, -0.02927841f, -0.00612288f, -0.01474250f, -0.01217571f, 0.01279858f, 0.02197526f, 0.00677955f, 
    0.00711221f, -0.00872007f, -0.02931396f, 0.02150703f, 0.00450382f, -0.01979182f, -0.02315056f, -0.05081935f, 
    -0.02820294f, -0.01833755f, 0.00556957f, -0.00994462f, -0.00950680f, -0.00886022f, -0.00390617f, 0.02140568f, 
    0.01637534f, -0.03280233f, -0.02257858f, 0.00138173f, -0.01350034f, -0.04251744f, 0.02190362f, -0.04238287f, 
    -0.00230685f, -0.02283228f, -0.00253054f, -0.03237588f, -0.02086591f, -0.03673154f, 0.00029002f, -0.03195639f, 
    -0.02974746f, 0.01504503f, -0.01553673f, -0.03000433f, -0.04949484f, -0.03705386f, -0.00397667f, -0.02929328f, 
    -0.00838183f, -0.00337146f, -0.04383956f, -0.05054041f, -0.02775832f, -0.03156912f, 0.02724198f, -0.03658338f, 
    0.02355754f, -0.00135899f, 0.02343768f, 0.02013509f, -0.00179971f, -0.03556785f, 0.01045583f, -0.00158372f, 
    -0.04397725f, -0.04600654f, 0.02102397f, -0.01230758f, -0.03336843f, -0.03673123f, -0.03638164f, -0.01109584f, 
    -0.02512890f, -0.00433632f, -0.00668224f, -0.04462108f, -0.04385905f, -0.02150234f, -0.03943741f, 0.01496698f, 
    0.01352152f, -0.00648711f, -0.02591307f, 0.01099667f, 0.01900009f, -0.01746988f, -0.03091974f, -0.02716468f, 
    -0.04332345f, -0.01305788f, -0.01474255f, 0.01736884f, -0.00882411f, -0.02785376f, -0.04833530f, -0.01374832f, 
    -0.02565072f, 0.01874790f, -0.01330702f, -0.03506059f, -0.01321801f, -0.03468942f, -0.03381949f, -0.04693286f, 
    -0.01660210f, 0.00302249f, -0.03584105f, -0.04474011f, 0.01358630f, -0.04838555f, 0.03602712f, 0.00231841f, 
    0.01862674f, 0.00971151f, 0.02674922f, 0.00501580f, -0.00744090f, -0.03806693f, 0.00296039f, -0.00748449f, 
    -0.03675680f, -0.02221636f, 0.02081539f, -0.03924240f, -0.03480203f, -0.00827094f, -0.03754419f, -0.04732139f, 
    -0.01988601f, 0.00497181f, -0.02305666f, 0.02168776f, 0.00211932f, -0.03165992f, -0.04645447f, -0.03461102f, 
    0.02738075f, -0.02530628f, 0.02167435f, 0.01071807f, -0.00577897f, -0.00282931f, 0.02431556f, -0.03033649f, 
    0.00524546f, 0.00314880f, -0.01128397f, -0.05109581f, -0.02253028f, 0.01711082f, 0.01279456f, 0.02045569f, 
    -0.01579481f, 0.01659271f, -0.00966685f, -0.00950017f, -0.01678629f, 0.02091385f, -0.02155480f, -0.00710141f, 
    -0.01577560f, -0.04680575f, -0.02384555f, 0.00790850f, -0.04467466f, -0.02454573f, -0.00843608f, -0.01369480f, 
    -0.03467816f, 0.00331279f, 0.01910870f, 0.02950502f, -0.00936266f, -0.01932813f, 0.00822016f, -0.03937931f, 
    -0.03366302f, -0.04607263f, -0.04697317f, -0.04240362f, 0.01742767f, 0.02104586f, -0.02432376f, -0.00582149f, 
    0.01742908f, 0.02397118f, -0.01212382f, -0.01114639f, -0.04136756f, -0.04998939f, -0.00760274f, -0.01519363f, 
    -0.03977937f, -0.05092219f, -0.04621730f, -0.04532526f, -0.01201061f, -0.01630272f, -0.00429107f, 0.00608108f, 
    -0.00464913f, 0.00968068f, -0.00904690f, 0.00899490f, -0.02709077f, 0.00310231f, -0.02664519f, -0.03606374f, 
    -0.02678577f, 0.01139170f, -0.02677656f, -0.02765699f, -0.03105850f, -0.01698148f, 0.02313928f, -0.02983547f, 
    -0.02346136f, 0.02858828f, 0.03876084f, 0.00869989f, -0.01408729f, -0.00411216f, 0.02648410f, -0.03791050f, 
    0.02039790f, 0.01862735f, 0.02588192f, -0.03275127f, 0.01943382f, 0.00645851f, -0.01824279f, -0.00635004f, 
    0.36227438f, -0.10543131f, -0.36415333f, 0.17556770f, -0.30536246f, 0.11108536f, 0.09244577f, 0.30458471f, 
    0.01592616f, 0.13718376f, 0.03371217f, -0.06884297f, 0.20608720f, 0.01020732f, -0.04589197f, -0.01759868f, 
    0.01495731f, 0.30388829f, -0.04883398f, 0.18874790f, -0.12055839f, 0.14004196f, -0.14961402f, 0.01970882f, 
    -0.01015298f, 0.14066006f, 0.15691720f, -0.05220526f, 0.01619663f, -0.03433384f, 0.09242150f, 0.03256316f, 
    0.19241126f, 0.14611819f, -0.04755721f, 0.04536338f, 0.16046669f, -0.11729672f, -0.07062983f, 0.07485069f, 
    -0.71394634f, -0.01623451f, 0.48219091f, 0.05618726f, 0.01346583f, -0.10153618f, 0.12648599f, 0.02460187f, 
    0.09955828f, 0.08471336f, 0.00668857f, 0.02349489f, -0.07049519f, -0.18270221f, -0.11874426f, 0.11150495f, 
    0.04434068f, -0.10366463f, -0.04248030f, 0.02078300f, 0.17723778f, -0.15604371f, 0.04473123f, 0.09661087f, 
    -0.08849292f, -0.08708680f, 0.26422915f, 0.16442092f, -0.08263841f, -0.16008295f, -0.00844585f, 0.08579875f, 
    -0.19412643f, -0.11499023f, 0.23484582f, -0.03916615f, 0.07559700f, 0.25368181f, 0.16284330f, -0.00964583f, 
    0.41509968f, -0.28139612f, -0.17057838f, 0.14189796f, 0.10952000f, -0.02046418f, -0.06670026f, -0.03024606f, 
    0.09880578f, 0.18692203f, 0.00976312f, -0.00668643f, 0.20135322f, 0.18434054f, 0.00926474f, -0.00371504f, 
    0.04182161f, -0.01869578f, 0.09116757f, -0.05169034f, 0.53783143f, 0.39798254f, -0.31181413f, -0.33236611f, 
    0.00713559f, 0.21881258f, 0.08602665f, -0.01412338f, 0.01106602f, 0.11120686f, -0.12191002f, -0.07371183f, 
    0.01321426f, 0.19837496f, -0.02024966f, -0.01164692f, 0.02096532f, 0.18950085f, -0.13938421f, 0.12011590f, 
    0.16597033f, 0.32608607f, 0.05281124f, -0.02211201f, 0.14188400f, 0.08738066f, -0.07486527f, -0.18455940f, 
    0.15938194f, 0.08381189f, -0.08195718f, 0.04461034f, -0.14831403f, -0.09263042f, 0.06315160f, 0.07630982f, 
    0.00927230f, 0.13062122f, 0.18261850f, 0.15845346f, -0.58781075f, 0.32740071f, 0.38157851f, -0.03399127f, 
    0.13815701f, -0.02689891f, 0.07226276f, 0.06345290f, 0.00416142f, 0.07285200f, 0.01745070f, 0.06384160f, 
    -0.08861302f, -0.21243566f, -0.22085956f, 0.03203616f, 0.02623152f, 0.04908828f, -0.01923108f, 0.16156495f, 
    -0.27943146f, 0.20152949f, 0.16032301f, -0.03966038f, 0.09502326f, 0.12103863f, -0.04880771f, -0.09041434f, 
    0.07240909f, -0.07254674f, -0.05717478f, -0.12661341f, 0.07741170f, 0.02012714f, 0.09053127f, 0.12596625f, 
    0.04105495f, -0.13061967f, -0.06477474f, 0.10590806f, -0.19226739f, -0.34222722f, 0.31977141f, 0.37327436f, 
    -0.24858552f, -0.12781106f, 0.07528837f, 0.13440695f, -0.22865725f, -0.12793435f, 0.05419178f, 0.10857102f, 
    0.08812346f, -0.08723003f, -0.02345804f, -0.03493705f, 0.01961151f, 0.21577401f, -0.00667720f, -0.06239268f, 
    0.53861320f, -0.00584064f, -0.21547984f, -0.16969077f, -0.03016260f, 0.04908879f, -0.09218383f, -0.16488254f, 
    0.07057754f, 0.07800531f, 0.00083553f, 0.08024010f, -0.11923009f, 0.17621994f, 0.08757708f, 0.06030323f, 
    0.11884431f, -0.28874353f, 0.16739544f, 0.05646514f, -0.47070369f, -0.22213714f, 0.26676020f, 0.35263968f, 
    0.08176625f, -0.00593900f, 0.21236695f, 0.16847862f, -0.00768222f, 0.00477745f, 0.01124749f, 0.09777299f, 
    -0.03675453f, 0.02167644f, -0.08252256f, 0.08677728f, 0.05824807f, -0.10643683f, 0.07114812f, 0.05179534f, 
    0.32041079f, -0.18252555f, -0.16453546f, -0.09594640f, 0.05625523f, 0.07899237f, -0.08795004f, -0.03823529f, 
    0.12733600f, 0.13241640f, 0.22694772f, 0.03450306f, 0.05285708f, 0.16991962f, 0.18970028f, 0.03677664f, 
    0.27064216f, 0.03295302f, 0.00758687f, 0.01938973f, 0.05917070f, -0.30017978f, -0.17700307f, 0.07899638f, 
    0.01565679f, -0.03708751f, 0.02867825f, 0.25794777f, 0.10854038f, 0.17983870f, 0.07630147f, -0.08631263f, 
    0.01443006f, 0.08386911f, -0.05029520f, 0.02543256f, 0.01517030f, 0.10257117f, 0.04639571f, 0.01631512f, 
    0.05967021f, 0.05296296f, -0.22857919f, 0.02271347f, 0.13845198f, -0.07014100f, -0.05493403f, 0.08308759f, 
    0.17764021f, 0.18655694f, -0.01873356f, -0.01245806f, -0.07038539f, 0.15082489f, 0.08188501f, 0.03778880f, 
    0.25446370f, 0.10192948f, 0.20282477f, -0.04655766f, -0.34409592f, -0.01842039f, -0.07385325f, 0.06005667f, 
    -0.17093469f, -0.18055794f, 0.20050871f, 0.12521850f, 0.16959248f, 0.07112602f, 0.03009393f, -0.09875092f, 
    -0.18774828f, -0.06328044f, 0.19837102f, 0.15337220f, -0.04800805f, 0.03605855f, 0.16271318f, 0.24133262f, 
    0.01787608f, -0.10552431f, -0.09322122f, -0.07393798f, 0.09208880f, 0.05288287f, 0.03672778f, 0.11367559f, 
    0.16809499f, 0.17319623f, 0.03858487f, 0.03976643f, 0.01235820f, 0.22500587f, 0.09558744f, -0.14208645f, 
    0.11719733f, 0.14568445f, 0.02694682f, 0.01797545f, 0.39856470f, 0.01041034f, -0.14814682f, 0.11756612f, 
    -0.09410317f, 0.00859701f, 0.02852081f, 0.08880606f, 0.11486501f, 0.16868450f, -0.01061830f, 0.11385205f, 
    -0.04020878f, -0.16963805f, -0.01463730f, 0.04052585f, -0.04977765f, 0.07922118f, 0.26374081f, -0.05493372f, 
    -0.37184840f, 0.24658838f, 0.22777085f, -0.01622141f, -0.12256560f, 0.10358888f, 0.31083167f, 0.16413134f, 
    0.01222498f, -0.09397777f, 0.15788314f, -0.01025235f, -0.07739500f, -0.04124084f, 0.09318265f, 0.02922039f, 
    -0.00516827f, -0.00948816f, -0.21841714f, 0.06105988f, 0.35206285f, -0.58728868f, 0.24875294f, -0.10797949f, 
    -0.01169387f, -0.15137084f, -0.09387586f, 0.05980191f, 0.01197533f, -0.03424371f, 0.01505218f, 0.00781037f, 
    0.09309545f, -0.01844431f, -0.05572091f, 0.08486712f, 0.09237820f, 0.00893870f, -0.07802489f, -0.03546333f, 
    0.11150289f, 0.04358016f, 0.15611044f, 0.08818211f, 0.22035077f, -0.06286609f, 0.00402236f, -0.02081838f, 
    0.06598771f, -0.17835666f, 0.06534343f, 0.10049605f, 0.17264271f, 0.17593814f, -0.02912046f, -0.00390440f, 
    0.09871781f, -0.05107498f, -0.00038707f, 0.06093325f, -0.01838753f, -0.19378933f, -0.14149317f, -0.01775889f, 
    0.01252936f, 0.02807690f, 0.08079378f, -0.04690446f, 0.20118949f, 0.11497957f, -0.05535779f, -0.04495686f, 
    -0.00699428f, 0.24566671f, 0.07458910f, 0.04392220f, 0.04899075f, 0.10157155f, 0.14752737f, 0.11280614f, 
    0.43151042f, 0.41353318f, -0.30190095f, -0.13688128f, 0.14682296f, 0.18062435f, 0.03598689f, -0.05104516f, 
    0.05732007f, 0.08125415f, -0.06157605f, -0.03969737f, 0.01545495f, 0.09465933f, 0.05436672f, 0.02535047f, 
    0.08394203f, -0.00015147f, 0.24443223f, 0.26470685f, 0.38781440f, -0.13939913f, -0.21623245f, 0.33162674f, 
    0.12558880f, -0.06561635f, 0.00454809f, 0.09761447f, 0.16104442f, 0.18226214f, -0.03494966f, -0.00166364f, 
    0.21909551f, 0.05578369f, -0.03807777f, 0.01862511f, 0.32272425f, -0.03189343f, 0.28144249f, -0.00772816f, 
    0.27556482f, 0.12063396f, 0.02750914f, 0.32987195f, -0.14244941f, 0.15613356f, 0.03975958f, -0.01823607f, 
    -0.04789970f, 0.03516978f, 0.00399444f, 0.01352293f, -0.05373329f, -0.02339258f, 0.18907820f, -0.00956358f, 
    0.00548726f, 0.22967330f, 0.09144432f, 0.14871885f, 0.16296411f, 0.26526847f, -0.39731163f, -0.40199813f, 
    0.23845723f, -0.09068744f, 0.13400838f, 0.01187837f, 0.05652580f, 0.12073444f, -0.00395316f, 0.18025964f, 
    -0.09244959f, -0.09174401f, 0.01959904f, -0.01747430f, 0.10511944f, -0.07917473f, 0.01200886f, -0.13934727f, 
    0.66898900f, 0.28612670f, -0.49858713f, -0.16641171f, 0.02508268f, -0.00312788f, -0.01386095f, 0.18329224f, 
    0.00281857f, 0.02218016f, 0.08114988f, 0.09699555f, 0.05229846f, 0.22034280f, 0.02943760f, 0.18604369f, 
    0.15245929f, -0.20009360f, 0.08167841f, -0.02482373f, 0.56025016f, 0.02422165f, -0.20895307f, -0.30761975f, 
    -0.16606060f, -0.01294928f, -0.08427254f, -0.12704088f, -0.02906702f, 0.11664468f, 0.02996502f, -0.10206849f, 
    -0.14448775f, 0.01524846f, 0.07335324f, -0.02095172f, 0.07162852f, -0.04779255f, 0.04203640f, 0.03197161f, 
    -0.12243877f, 0.08128507f, -0.34895137f, 0.11418768f, 0.07122352f, -0.11783024f, -0.17505313f, -0.00277913f, 
    0.24284680f, 0.24995695f, -0.03527633f, 0.06628295f, -0.08736086f, 0.31585595f, -0.02210911f, 0.02378801f, 
    -0.35858887f, 0.08763787f, 0.10706241f, 0.20873752f, 0.04845759f, -0.09982445f, -0.18239993f, 0.12666541f, 
    0.17060708f, 0.08911638f, -0.03202221f, 0.12554522f, 0.08569270f, 0.04941764f, 0.01194994f, 0.03868687f, 
    0.17400445f, 0.16474251f, 0.14457305f, -0.08476070f, 0.16448651f, 0.10526530f, 0.09274446f, 0.06443467f, 
    0.28434888f, 0.20624441f, 0.15226498f, 0.04345661f, -0.42469490f, -0.10933707f, 0.05218208f, -0.05557027f, 
    -0.11108213f, 0.09682561f, -0.04798859f, -0.01450866f, -0.01715643f, 0.04405771f, -0.07495102f, 0.10184179f, 
    -0.03548830f, 0.05008523f, 0.30809239f, 0.19473036f, -0.28017122f, -0.21269485f, 0.14921822f, 0.00670167f, 
    0.03033898f, 0.00702770f, -0.06693530f, -0.04556076f, 0.14420094f, -0.01105996f, -0.17779757f, -0.00922063f, 
    0.13399883f, 0.04444100f, 0.15740272f, 0.01272828f, 0.13764918f, -0.04812666f, -0.14009592f, -0.09336774f, 
    0.06120374f, 0.09105835f, -0.33343655f, 0.14247476f, -0.03512536f, 0.03266220f, -0.06123656f, -0.15744033f, 
    -0.09647130f, 0.11214795f, -0.09011251f, 0.00973097f, -0.05402442f, -0.00247494f, 0.08746324f, -0.03470315f, 
    0.01277143f, -0.03042611f, 0.04862969f, -0.10236612f, 0.29667190f, 0.19490893f, -0.16507426f, -0.00790381f, 
    -0.17093363f, 0.07202643f, 0.04231078f, -0.01666522f, 0.03896200f, -0.07707997f, -0.08321455f, -0.00831114f, 
    0.01307597f, 0.06868430f, 0.02380655f, 0.10957848f, 0.09396819f, 0.08754771f, -0.14929245f, -0.02159677f, 
    0.41753641f, 0.21823923f, 0.19621204f, 0.03483199f, 0.05792311f, -0.05316454f, -0.00447705f, -0.05408110f, 
    -0.10582968f, 0.06074721f, 0.01737506f, -0.08330600f, 0.07233725f, -0.12459374f, 0.13354279f, 0.07081116f, 
    -0.03030137f, 0.05421370f, 0.04597028f, -0.02524661f, 0.09030716f, -0.02686850f, 0.16431363f, 0.25162435f, 
    0.07048821f, 0.06939761f, -0.13693821f, -0.19064443f, 0.00424805f, 0.01855774f, -0.04787016f, -0.15939203f, 
    -0.01934616f, 0.12839821f, 0.11992585f, 0.04142537f, -0.08295491f, 0.01950780f, -0.01591563f, 0.17842418f, 
    -0.55653769f, 0.33553225f, -0.33177075f, -0.00847204f, -0.12628296f, 0.18126296f, 0.02954653f, 0.04404216f, 
    0.05935017f, 0.07281174f, -0.02206613f, -0.02432796f, -0.00745777f, 0.04956242f, -0.03492448f, -0.01864686f, 
    0.15089166f, 0.04175236f, 0.03577523f, -0.06330726f, 0.10963021f, 0.08731240f, 0.15650569f, -0.08415904f, 
    0.21270831f, -0.04663766f, 0.00975524f, -0.10344462f, 0.08197750f, 0.00514261f, -0.05489151f, 0.22094257f, 
    -0.09271730f, -0.11086218f, 0.11979319f, 0.01804235f, 0.02859794f, 0.06906415f, 0.00934446f, -0.08126450f, 
    -0.40456891f, -0.06608048f, -0.24868956f, 0.19553703f, 0.00175115f, 0.02945013f, -0.05314832f, -0.01506674f, 
    -0.15840423f, 0.02299060f, 0.17130893f, 0.15474887f, 0.15343408f, -0.06242975f, 0.18440047f, -0.02705679f, 
    -0.16235463f, -0.00639349f, -0.12279137f, -0.03833991f, -0.06303839f, 0.05488906f, 0.20658065f, 0.15202914f, 
    0.07116097f, -0.00370828f, -0.02915630f, -0.06201671f, -0.01176061f, -0.04135561f, -0.14122729f, 0.09620105f, 
    -0.12388022f, -0.01965860f, 0.03442932f, -0.11907832f, -0.06750186f, -0.04346498f, 0.03895383f, -0.18108778f, 
    -0.32855767f, -0.03737919f, -0.24478593f, -0.07606451f, -0.06898481f, 0.09778017f, 0.19551663f, 0.00458448f, 
    0.03532635f, -0.14969482f, 0.09096602f, 0.19449922f, 0.04731521f, 0.13154222f, 0.15478346f, 0.09382211f, 
    -0.06829783f, -0.01382725f, -0.13497935f, -0.02331572f, 0.41753045f, -0.03644384f, 0.10564863f, 0.23914956f, 
    0.05212044f, -0.22014675f, -0.02539674f, -0.03370185f, -0.06487904f, 0.12431294f, 0.00273161f, -0.15935718f, 
    -0.16752283f, -0.04222064f, 0.11512356f, -0.10595594f, -0.04236569f, -0.01442717f, 0.09433134f, -0.01185426f, 
    -0.01467383f, 0.03371849f, -0.20328626f, -0.17308637f, -0.09517580f, 0.23172851f, 0.10835093f, 0.03758755f, 
    0.09648353f, 0.01104442f, -0.01691735f, 0.02293626f, 0.05980752f, 0.03945584f, 0.00411000f, 0.02191694f, 
    0.01136670f, 0.03814307f, -0.02121854f, -0.09818169f, 0.61300713f, -0.08872375f, 0.15952125f, 0.09048943f, 
    -0.00138312f, -0.18749392f, 0.06323912f, -0.07508344f, -0.04887040f, 0.02533208f, 0.00350176f, -0.05153022f, 
    -0.02581448f, -0.17514199f, -0.00260895f, 0.04357132f, 0.00641716f, -0.09816727f, -0.04814876f, 0.05175278f, 
    -0.12761760f, 0.07331834f, -0.08659986f, 0.00660302f, -0.30535686f, 0.05984089f, 0.02343984f, 0.04777555f, 
    0.08501524f, 0.01068225f, -0.07510385f, -0.03556451f, 0.00602456f, -0.01045030f, -0.00788225f, 0.01181245f, 
    0.01768083f, 0.07154608f, -0.04371774f, 0.03384759f, 0.40243658f, 0.12644614f, -0.11934300f, 0.17523767f, 
    -0.11309104f, 0.09628055f, -0.00506204f, -0.01596712f, -0.10419145f, 0.01286875f, -0.05095804f, 0.08916310f, 
    0.14654003f, -0.10038894f, 0.05622661f, 0.09657578f, 0.17567083f, 0.19059740f, -0.13166645f, 0.10435040f, 
    0.08739399f, 0.30296138f, -0.02159965f, 0.11509395f, -0.11801361f, 0.03494242f, -0.03225304f, 0.21291967f, 
    0.08078860f, -0.07212658f, 0.03271087f, -0.05169189f, -0.02402014f, 0.07605061f, -0.07078554f, -0.07268219f, 
    -0.01427399f, 0.06991176f, 0.13868736f, 0.01696317f, 0.23471244f, -0.05175096f, 0.05142263f, 0.29931915f, 
    -0.09838074f, 0.05906216f, -0.20781380f, 0.04795314f, -0.10830231f, 0.14356312f, 0.01492836f, -0.13731414f, 
    0.10727812f, 0.08893204f, 0.10057777f, -0.00392159f, -0.04014845f, 0.12222990f, -0.01267986f, 0.06499522f, 
    -0.48149279f, 0.12545742f, -0.21604878f, -0.05788805f, -0.00436505f, 0.06530927f, 0.08709073f, -0.03581999f, 
    -0.07781710f, -0.11462162f, -0.05130710f, -0.02629647f, 0.08106073f, 0.01623441f, 0.06030032f, 0.00406373f, 
    0.07946490f, 0.04477842f, 0.06337910f, 0.01874303f, -0.25519866f, -0.01486784f, -0.29530150f, 0.02373815f, 
    0.09189010f, -0.01584163f, 0.00191675f, -0.10751300f, -0.01931584f, -0.07923139f, 0.07789666f, 0.10360742f, 
    -0.03879684f, 0.10069516f, 0.11074743f, -0.10678460f, 0.00843942f, 0.02716270f, -0.04992287f, 0.04511677f, 
    0.81735855f, -0.16319698f, -0.03900002f, 0.05620872f, 0.11065327f, -0.14224157f, 0.05478554f, -0.07687163f, 
    0.04176506f, -0.01424086f, -0.01588308f, -0.04523998f, -0.05321679f, 0.01869440f, 0.07895554f, 0.13313971f, 
    -0.01766997f, 0.16187871f, -0.12574345f, -0.04769034f, 0.11834516f, 0.05267653f, 0.15234621f, 0.08198073f, 
    0.25724903f, -0.10347746f, 0.16316184f, -0.08575674f, 0.04280692f, 0.15560210f, -0.05871222f, -0.07955190f, 
    0.09038451f, -0.13484223f, 0.02067327f, 0.00484986f, 0.00866842f, -0.06075488f, 0.04758172f, -0.11119632f, 
    0.26749733f, -0.25557610f, -0.18962367f, -0.05584446f, -0.19202618f, 0.00689417f, 0.21277760f, 0.13877378f, 
    -0.00447988f, 0.08981191f, 0.05016679f, -0.00222815f, 0.05744641f, -0.10815095f, -0.02337094f, 0.04459243f, 
    -0.05696791f, -0.13650535f, -0.07267643f, -0.00833511f, -0.33944193f, 0.08237176f, 0.18368250f, 0.19092539f, 
    0.13287346f, -0.00926962f, -0.03123060f, 0.05612416f, -0.09844100f, 0.00853670f, 0.03731601f, 0.09535360f, 
    0.05491832f, 0.06710558f, -0.01290712f, 0.01627252f, -0.02872700f, 0.03050270f, 0.00856898f, 0.10202351f, 
    0.43249625f, -0.22224574f, 0.02624055f, 0.08727661f, -0.18570441f, -0.14827770f, 0.06097430f, 0.07804583f, 
    -0.04928403f, 0.18724529f, -0.01359438f, -0.00955745f, 0.09291846f, -0.04792593f, -0.04454017f, -0.02172976f, 
    -0.10715850f, 0.13675788f, 0.04291803f, -0.10652707f, -0.36752129f, 0.18023251f, -0.38469127f, 0.17990366f, 
    -0.08917380f, 0.03074365f, -0.10682042f, 0.08907109f, 0.02569250f, 0.03640984f, -0.05971014f, 0.08503678f, 
    0.02943468f, -0.07838130f, 0.04486332f, 0.09018457f, -0.08002795f, -0.10239458f, 0.18560831f, -0.05505054f, 
    -0.38373974f, -0.17933232f, 0.02241943f, 0.29103580f, 0.21190526f, -0.05120672f, -0.06908588f, 0.09277529f, 
    -0.13263381f, 0.00587338f, 0.12318478f, -0.04123862f, -0.09175754f, 0.01898338f, 0.05275532f, -0.00512362f, 
    0.02497857f, 0.11169977f, 0.10282312f, 0.05794772f, 0.04991534f, 0.00086648f, 0.35491884f, -0.11036591f, 
    -0.15551734f, 0.18590109f, 0.00549297f, 0.00393292f, 0.14235684f, -0.21978292f, -0.08509675f, 0.05514738f, 
    0.02742446f, 0.12931310f, 0.09701934f, -0.02210508f, 0.06283449f, -0.14491001f, 0.00254478f, -0.00624920f, 
    -0.12276503f, -0.09196738f, 0.27559960f, 0.33795199f, 0.03256328f, -0.01205205f, -0.12268227f, 0.06027789f, 
    0.04295445f, -0.02128696f, -0.10490672f, -0.04624603f, 0.01108519f, 0.05913335f, -0.01373723f, -0.05768831f, 
    0.05690647f, -0.16945229f, 0.02928560f, -0.04168528f, -0.08151542f, -0.00236465f, -0.17009573f, -0.06499197f, 
    -0.04175350f, 0.16838571f, -0.00129152f, 0.20116468f, 0.01911621f, 0.03550518f, -0.00219147f, 0.10993420f, 
    0.10691506f, -0.08199523f, 0.00907364f, -0.07223780f, 0.04719662f, 0.03517025f, -0.08118553f, -0.07977487f, 
    -0.12020203f, -0.26255521f, -0.45036605f, -0.10718916f, -0.03893143f, 0.19061005f, 0.24974306f, -0.02593949f, 
    0.04859819f, 0.04106247f, 0.01585184f, -0.01739194f, 0.02170158f, -0.02375469f, 0.15861590f, 0.19908735f, 
    0.20436113f, 0.07076146f, -0.10720020f, 0.01995523f, -0.23123047f, -0.02288098f, -0.07796798f, -0.25709873f, 
    -0.24378955f, 0.20338885f, 0.19252346f, 0.14297915f, 0.08970803f, 0.01023844f, 0.17905074f, -0.05692660f, 
    -0.01563692f, 0.08019481f, -0.00152441f, 0.04046591f, 0.14207344f, 0.01335306f, 0.11528688f, -0.06662752f, 
    -0.02251667f, 0.01694711f, 0.01659593f, 0.19594344f, 0.14463528f, 0.00667024f, 0.06861519f, -0.09661131f, 
    0.10651936f, 0.12974003f, -0.01788072f, 0.08200528f, -0.08000838f, -0.08005960f, 0.02601204f, 0.02650420f, 
    -0.01178672f, 0.03071012f, 0.04311908f, 0.05777929f, -0.16862810f, -0.22284129f, -0.20704971f, -0.05856945f, 
    0.31348392f, 0.07386928f, 0.09133278f, -0.09560586f, 0.13358888f, 0.00336688f, 0.24226367f, 0.10336644f, 
    -0.03662400f, 0.04793741f, 0.07504735f, 0.12576850f, 0.08412526f, -0.05373114f, -0.09986023f, 0.19777070f, 
    0.05824133f, -0.06092754f, 0.26296315f, 0.23733552f, -0.33306798f, -0.20658100f, 0.06578150f, -0.01236858f, 
    0.10494619f, 0.04132571f, -0.01175215f, -0.04450877f, -0.02569920f, 0.17686544f, 0.13302690f, 0.05001302f, 
    -0.07598443f, 0.13545711f, 0.02525044f, 0.09966546f, 0.57308370f, 0.26291916f, -0.11156064f, -0.00464577f, 
    -0.24361409f, 0.12416945f, 0.05395463f, 0.00340841f, -0.01224854f, -0.06842324f, -0.00345791f, 0.11193650f, 
    0.00332638f, -0.09230047f, -0.14056174f, 0.02044578f, 0.11610572f, 0.05819243f, 0.02868147f, 0.02848237f, 
    0.12243211f, -0.12211035f, -0.16989960f, -0.11643753f, 0.68471038f, 0.18384254f, 0.01332577f, -0.05376696f, 
    -0.07315052f, -0.21649590f, -0.09224772f, -0.05620458f, 0.04265511f, -0.01703585f, -0.07757509f, 0.05351618f, 
    0.29929650f, 0.20143102f, -0.13231798f, -0.06791136f, -0.26305273f, -0.17054692f, 0.06877010f, 0.13314511f, 
    -0.40288615f, 0.02400396f, 0.04471416f, 0.00191367f, 0.05389010f, 0.09698984f, -0.08507509f, 0.01441101f, 
    -0.04158494f, 0.07892706f, 0.09747132f, 0.08802020f, 0.08519487f, 0.10884225f, -0.02741604f, -0.07302870f, 
    0.05194061f, 0.34114125f, -0.04796919f, 0.33216384f, -0.27397358f, -0.14672454f, 0.09992129f, 0.06695739f, 
    0.14057450f, 0.19359732f, -0.02457801f, 0.02551948f, -0.06480394f, -0.05866318f, 0.20527606f, 0.03907966f, 
    0.06910921f, -0.01197024f, 0.06524786f, 0.12075722f, -0.39678565f, -0.41708162f, 0.04889287f, -0.01903145f, 
    -0.17790172f, 0.28372324f, -0.24461399f, -0.10673516f, 0.17311783f, 0.18557632f, 0.03871410f, 0.12263464f, 
    0.12848081f, -0.02217036f, 0.05638215f, 0.08782801f, -0.14235367f, 0.18218285f, 0.01010256f, -0.19395272f, 
    -0.03645397f, -0.31049478f, -0.00268405f, 0.16151838f, -0.23607625f, -0.10063758f, -0.00445169f, 0.11035788f, 
    -0.01642329f, 0.21287082f, 0.10292143f, 0.04483472f, 0.00666979f, 0.01478844f, 0.08629312f, 0.15208066f, 
    0.01643912f, -0.00556933f, -0.01599942f, 0.19922914f, 0.08095010f, -0.07827295f, -0.18858971f, -0.30040407f, 
    0.23494762f, 0.08618291f, -0.03304027f, -0.09480347f, 0.01901076f, -0.01803038f, 0.15625687f, 0.04181295f, 
    0.11592552f, -0.07501601f, 0.04201436f, -0.04396269f, 0.17319739f, 0.01410286f, 0.12104808f, 0.05114731f, 
    0.46508807f, 0.41785070f, -0.16888237f, -0.13338268f, 0.05839674f, -0.04971266f, 0.00922677f, 0.05220781f, 
    -0.11173689f, -0.03308478f, 0.02242696f, 0.10654016f, 0.08414598f, -0.03763884f, -0.09292459f, 0.09613337f, 
    -0.04078006f, 0.10667759f, 0.11250094f, -0.00039455f, 0.13107568f, 0.05786683f, 0.10562335f, -0.28396991f, 
    -0.10233367f, -0.02186583f, 0.07876504f, 0.08045922f, 0.01257527f, 0.02705922f, 0.05946641f, 0.10230490f, 
    0.05589934f, -0.04857262f, -0.05575773f, 0.06831870f, -0.00702513f, -0.20809764f, 0.28508797f, -0.08977801f, 
    0.22341524f, 0.18760182f, 0.18920033f, 0.09038235f, -0.07772548f, -0.02140828f, -0.01253025f, -0.13084646f, 
    0.08398928f, 0.17562413f, -0.04657439f, -0.00039374f, 0.03925484f, 0.04247097f, -0.04744986f, 0.11288357f, 
    0.02539599f, 0.06994902f, 0.00886106f, 0.12181119f, 0.16125694f, -0.03463054f, -0.16466789f, -0.15429835f, 
    0.08960085f, 0.11146826f, -0.03709828f, -0.07514437f, -0.07231406f, -0.09943590f, -0.01836769f, 0.11232291f, 
    0.08353868f, -0.04264794f, -0.07829016f, -0.05578201f, 0.10643488f, 0.02802693f, -0.06378036f, 0.01476882f, 
    0.11954214f, -0.13605934f, 0.22904252f, 0.07013056f, -0.08783957f, 0.19106777f, 0.00705761f, -0.00985822f, 
    -0.12922221f, 0.16796139f, 0.07217661f, 0.00085340f, -0.04336745f, 0.05096405f, 0.04504701f, -0.06121873f, 
    -0.01687564f, -0.06710649f, 0.10514643f, -0.03143959f, 0.00012797f, 0.18659408f, 0.05566713f, 0.27421954f, 
    -0.42715362f, -0.00143380f, 0.07332708f, -0.02286353f, -0.01951732f, -0.10228518f, -0.02250115f, 0.08026055f, 
    0.05744344f, 0.13748214f, 0.14141433f, 0.02782317f, 0.05997716f, 0.03117894f, -0.16057573f, 0.09778414f, 
    0.56520069f, 0.29415461f, 0.08109984f, -0.07552724f, -0.08919963f, -0.14732443f, 0.00271177f, -0.06958355f, 
    0.16138992f, 0.10185857f, -0.04360675f, 0.04561098f, -0.05672538f, 0.00311629f, 0.01977827f, 0.07715097f, 
    -0.01095772f, -0.14306982f, 0.21253833f, -0.03034423f, -0.01169378f, -0.25867939f, 0.20207329f, 0.05545843f, 
    -0.41016033f, -0.00785848f, -0.05750224f, -0.14556175f, -0.09545466f, 0.07398804f, 0.02919778f, 0.03099899f, 
    -0.04693601f, 0.23935787f, -0.02061754f, 0.11839716f, 0.11917596f, -0.03883936f, -0.16105261f, 0.00217648f, 
    0.13794431f, -0.02686530f, 0.02554435f, 0.24120909f, -0.08437157f, 0.03037481f, -0.06992075f, 0.02023065f, 
    0.02029067f, 0.31277654f, 0.00917831f, 0.11539672f, -0.02334847f, 0.02969362f, 0.06617680f, 0.18213372f, 
    0.02943853f, -0.01404519f, -0.03837847f, -0.01823844f, 0.11755090f, 0.05946728f, -0.02031371f, 0.16223297f, 
    -0.21280238f, -0.00401129f, -0.16538765f, -0.03378024f, 0.13015099f, -0.09159762f, -0.01643136f, 0.04870555f, 
    0.03943789f, 0.11749917f, 0.13110176f, 0.08295815f, 0.04609913f, 0.05456343f, 0.01107086f, 0.22293453f, 
    0.30235305f, -0.10135182f, 0.00710053f, -0.02819940f, -0.02748351f, -0.07002467f, 0.09946799f, -0.13698594f, 
    -0.05087841f, -0.03312993f, -0.12039560f, 0.09563190f, -0.11841203f, -0.06629380f, 0.14644566f, 0.03797318f, 
    0.19154069f, 0.03073023f, -0.04172092f, -0.08937073f, 0.08017500f, 0.17678873f, -0.15644707f, -0.07813480f, 
    -0.02585606f, -0.00755814f, -0.02720587f, -0.02396638f, 0.05578043f, -0.04568514f, 0.09362683f, 0.01633917f, 
    0.01201925f, 0.14719330f, 0.10035812f, -0.06787799f, -0.07003280f, 0.01815650f, -0.05534592f, 0.04841887f, 
    0.39309937f, 0.35699144f, -0.10032633f, -0.02083248f, -0.00447301f, -0.10357761f, 0.00329693f, 0.07172912f, 
    0.03941855f, 0.04391246f, 0.03458317f, -0.03536822f, 0.02637483f, -0.14464706f, 0.09903049f, -0.09092487f, 
    0.07294080f, 0.03116341f, -0.05785622f, -0.07436372f, 0.06117242f, 0.03668457f, -0.17610672f, 0.02583641f, 
    -0.17425367f, -0.16961025f, -0.05433016f, 0.18531056f, -0.03253626f, 0.35562971f, -0.14278722f, 0.19238208f, 
    -0.07702661f, 0.03294537f, -0.00695574f, -0.06882291f, 0.06707587f, 0.13356264f, 0.01682590f, -0.01231289f, 
    -0.17358142f, -0.16716436f, -0.13359666f, -0.12032824f, -0.14234829f, -0.09713753f, -0.05647378f, -0.06916071f, 
    0.20350307f, 0.04031833f, 0.02882312f, 0.00987562f, -0.01441106f, 0.08456248f, 0.06449588f, 0.05946174f, 
    -0.05111225f, 0.22833963f, 0.14952786f, -0.24507569f, 0.19979791f, -0.05620907f, 0.19196633f, 0.34691259f, 
    -0.23136695f, -0.14608103f, 0.04559924f, -0.20965044f, -0.00580057f, 0.16852577f, 0.07847340f, 0.14880297f, 
    -0.02473521f, 0.16790183f, 0.12234241f, -0.00213379f, -0.07988536f, 0.00205276f, 0.13230734f, 0.10886928f, 
    -0.14386815f, -0.24224740f, 0.04728695f, -0.10902752f, -0.29759508f, -0.15357612f, 0.02352046f, 0.00461162f, 
    0.04703662f, -0.05997022f, 0.04256254f, 0.22252159f, -0.04668932f, -0.15642032f, -0.00774095f, 0.11028919f, 
    0.10086948f, 0.07527716f, 0.10767354f, -0.02016072f, 0.23980936f, 0.00035761f, 0.29525489f, -0.05494730f, 
    0.14456460f, -0.06974566f, -0.00693658f, -0.06002915f, 0.07130544f, 0.13514908f, 0.00252519f, 0.00554702f, 
    0.14672382f, -0.07532011f, 0.02868303f, 0.06849164f, -0.03990286f, -0.20225979f, 0.02574388f, 0.11605489f, 
    -0.20463601f, 0.05155906f, 0.18605708f, 0.01836943f, 0.33417213f, -0.03980443f, 0.21594062f, -0.17557891f, 
    -0.04600449f, -0.11862385f, 0.10060204f, 0.00669341f, 0.09221451f, 0.22272974f, 0.07089639f, 0.00467565f, 
    0.03714587f, 0.03532514f, 0.03950283f, 0.03654455f, -0.12778223f, -0.38635671f, 0.36108404f, -0.00287364f, 
    -0.04823541f, 0.16054209f, 0.09119210f, -0.02094527f, 0.01189138f, 0.23923044f, -0.04518983f, 0.00673089f, 
    0.11629921f, 0.17486194f, -0.03788313f, -0.06354436f, 0.11634198f, 0.04441577f, 0.11912853f, -0.05796804f, 
    -0.00103416f, -0.18361685f, 0.20964187f, 0.17447944f, -0.25128826f, 0.12895656f, -0.10576241f, 0.01315407f, 
    0.11557271f, 0.22193369f, 0.05649171f, -0.08340226f, 0.01177734f, -0.06344775f, -0.02770636f, 0.04837442f, 
    -0.10169318f, 0.12385337f, -0.05409151f, 0.09309750f, 0.42373851f, 0.20301595f, 0.14008315f, 0.03367074f, 
    0.08778021f, -0.04214033f, 0.04944721f, -0.18535379f, 0.12709625f, 0.07456741f, -0.01865115f, -0.07988330f, 
    -0.11697061f, -0.04269742f, 0.07351527f, 0.04959669f, 0.17815003f, -0.08892193f, 0.03613176f, 0.11888111f, 
    -0.02776270f, -0.44275692f, -0.14879653f, 0.12050694f, -0.30709064f, -0.04441332f, 0.09319898f, -0.00275470f, 
    0.04506837f, 0.05570451f, 0.19522548f, 0.03708275f, 0.08054438f, 0.02732578f, -0.26244864f, -0.00672221f, 
    0.09260198f, 0.15679462f, -0.07224937f, 0.05824591f, 0.40840465f, 0.01056795f, 0.19585685f, -0.19669087f, 
    0.33968878f, -0.01628507f, -0.02354110f, 0.05653066f, -0.15893558f, -0.27167800f, 0.14880767f, 0.24550596f, 
    -0.08828598f, 0.07128520f, 0.09435277f, 0.05136865f, 0.07653387f, 0.04842595f, -0.00270429f, -0.04990350f, 
    -0.00853900f, 0.01544670f, -0.01179074f, 0.00627053f, -0.03276669f, 0.03637067f, 0.01837498f, -0.00025061f, 
    -0.01838799f, 0.02918769f, 0.01991240f, -0.02619063f, -0.00873560f, -0.03813156f, 0.01337294f, -0.01533409f, 
    -0.00803415f, -0.01745220f, -0.00149702f, -0.00109214f, -0.03257352f, 0.01018512f, 0.01904784f, 0.00157955f, 
    -0.01250066f, 0.01019997f, 0.02435641f, -0.02687705f, -0.02996379f, -0.03118904f, 0.01327795f, 0.03161781f, 
    -0.02693650f, -0.00301255f, 0.00503278f, -0.03054731f, -0.02233475f, -0.00095521f, -0.02087061f, -0.02876763f, 
    -0.01844106f, 0.01666428f, -0.01430808f, 0.02135440f, 0.02920554f, 0.02222507f, -0.02130341f, -0.00688567f, 
    0.00548817f, -0.01170643f, 0.02087382f, 0.02570474f, -0.01479444f, 0.00972821f, -0.04291077f, 0.03417702f, 
    -0.01868963f, 0.03087365f, 0.01505714f, 0.03210206f, -0.02434115f, 0.02152584f, -0.00901500f, 0.00699841f, 
    -0.03190159f, -0.03116121f, -0.02633894f, -0.03247742f, 0.03379798f, -0.03355517f, -0.00047670f, 0.01410669f, 
    0.01948582f, -0.02099789f, 0.02733625f, 0.01284926f, -0.01854756f, 0.00035889f, -0.03843614f, 0.00488513f, 
    0.00133273f, -0.03762883f, 0.02844838f, 0.01100243f, -0.01183415f, -0.02549274f, -0.02161259f, 0.01006644f, 
    -0.01772272f, 0.01140204f, -0.02131970f, -0.04111931f, -0.02993143f, -0.02379113f, -0.03859985f, -0.04006532f, 
    0.02396012f, 0.01945577f, 0.01510629f, 0.01530574f, 0.00336700f, 0.00162312f, 0.03618197f, -0.00712967f, 
    -0.02127861f, 0.00357923f, 0.03268937f, -0.02212581f, -0.01684205f, 0.00467943f, -0.03813227f, 0.01784480f, 
    0.00791378f, 0.02286190f, -0.02257576f, 0.02841967f, -0.01147371f, 0.01526825f, 0.03535571f, -0.01558197f, 
    -0.01770764f, -0.03626684f, -0.02315856f, -0.00195731f, 0.03862868f, 0.02417160f, 0.00480401f, 0.00331192f, 
    -0.02605039f, 0.00036280f, -0.00356474f, -0.02510257f, -0.00913119f, 0.01929624f, 0.02937506f, 0.01191714f, 
    0.02738626f, -0.03750769f, -0.04079702f, -0.00512115f, 0.01972486f, 0.01423823f, -0.01737070f, -0.03267384f, 
    -0.04376727f, 0.00643395f, -0.02364947f, -0.03091151f, -0.03298388f, -0.01334788f, 0.02293429f, -0.02726119f, 
    -0.01685202f, 0.02787922f, 0.01406942f, -0.03930081f, 0.03592684f, -0.02224364f, -0.03379881f, -0.04025304f, 
    0.03045380f, 0.01580370f, -0.01652652f, -0.03550496f, -0.01989093f, -0.00255492f, 0.00077130f, -0.04355823f, 
    0.02336130f, 0.02825577f, -0.00680139f, -0.00074438f, 0.01010690f, -0.02257803f, -0.02829857f, -0.02728694f, 
    -0.00143317f, -0.02941212f, 0.03915196f, 0.00333988f, -0.02105877f, -0.03545672f, 0.00444612f, -0.01503830f, 
    0.00473222f, -0.00591239f, -0.02264593f, 0.03430191f, -0.01676912f, 0.02587754f, -0.00790000f, 0.03411339f, 
    -0.01109660f, -0.00802013f, -0.01865616f, -0.03167578f, -0.03332046f, -0.02329243f, 0.00326393f, 0.02078441f, 
    -0.00862263f, -0.04061476f, -0.01152936f, -0.03528047f, 0.01731279f, -0.01233039f, 0.03248890f, -0.01545369f, 
    0.00181355f, -0.02572654f, -0.02252488f, 0.00452675f, -0.00786724f, -0.01620232f, -0.01620570f, -0.00690889f, 
    0.01680371f, 0.01626016f, 0.01817102f, 0.01552522f, -0.02931009f, 0.00092744f, 0.02546800f, 0.00860882f, 
    -0.01516257f, -0.00561489f, 0.01539989f, 0.03333357f, -0.02485349f, -0.02526195f, -0.03133880f, 0.02755294f, 
    -0.03141451f, 0.00732733f, 0.01657198f, 0.02744614f, -0.01870167f, 0.01231911f, -0.02760418f, 0.00460843f, 
    0.02489111f, 0.03333602f, 0.00547806f, -0.02462555f, -0.02028224f, 0.03106255f, -0.02049580f, -0.02177712f, 
    -0.03534530f, 0.03034848f, 0.02939903f, -0.01089767f, 0.01942533f, 0.01191801f, -0.02022709f, 0.03192053f, 
    -0.03430466f, -0.01496750f, -0.02330545f, -0.02989773f, 0.00561281f, 0.01350538f, 0.01371028f, -0.02564445f, 
    -0.03362542f, 0.01106177f, -0.02677485f, -0.02325520f, 0.02734411f, -0.01628430f, -0.00540161f, -0.00795209f, 
    0.01386326f, -0.03996475f, -0.00889145f, -0.02663620f, -0.00868643f, -0.01972635f, -0.00815296f, -0.00324536f, 
    -0.01213016f, 0.02552355f, 0.02971386f, -0.01093669f, -0.01188256f, -0.00265273f, 0.03519022f, 0.01106946f, 
    0.01117152f, 0.02498995f, 0.00081628f, -0.02393983f, 0.00033419f, -0.01790965f, -0.00745443f, 0.00802825f, 
    -0.01202733f, -0.03910281f, 0.00497188f, -0.02647520f, -0.02288002f, -0.02007369f, -0.02515129f, 0.00542361f, 
    -0.02029236f, -0.03318432f, -0.01512054f, -0.00316017f, -0.01939259f, -0.02802143f, 0.02563603f, 0.00505466f, 
    0.02176907f, 0.00042694f, -0.01777520f, 0.03217314f, -0.03414948f, 0.02206376f, -0.01177095f, 0.03196714f, 
    -0.03722449f, 0.01360662f, -0.01159302f, -0.01013812f, 0.01027428f, 0.00783770f, 0.02191085f, -0.01929859f, 
    0.02353560f, -0.01362770f, -0.03309172f, -0.01818576f, -0.00321479f, 0.00833273f, -0.02666758f, 0.00750207f, 
    -0.02489969f, -0.03179766f, 0.00970136f, 0.02071590f, -0.00998052f, -0.00895093f, -0.02681198f, -0.00726616f, 
    0.01449277f, -0.02771696f, -0.00923446f, -0.00083805f, 0.01082365f, 0.02174933f, -0.03110274f, -0.00391233f, 
    0.02880014f, 0.00500925f, -0.03161258f, 0.01839912f, 0.03318103f, -0.02180334f, -0.00003044f, 0.02683811f, 
    -0.01524909f, -0.00686218f, -0.00215052f, 0.00327777f, -0.01798929f, -0.02299186f, 0.00368337f, 0.03440787f, 
    -0.02856386f, 0.02116168f, 0.02053763f, 0.02307244f, -0.02823910f, -0.01557971f, -0.03378873f, 0.03337014f, 
    0.02335406f, 0.01969132f, -0.04176872f, 0.03333290f, 0.03259682f, 0.01600576f, -0.03753012f, 0.02896286f, 
    -0.03292295f, -0.02290579f, 0.03121333f, -0.00843871f, -0.00771898f, -0.03343445f, -0.02517255f, -0.01799106f, 
    -0.01881227f, 0.02819531f, -0.00180029f, -0.03637178f, -0.02987180f, 0.03072528f, 0.01725286f, -0.03637578f, 
    -0.02908789f, -0.00989302f, 0.00452045f, -0.03606920f, -0.00631333f, -0.03312394f, 0.02140080f, 0.01485634f, 
    -0.00758933f, 0.01981608f, 0.00083987f, -0.03669880f, 0.00436722f, 0.00531079f, -0.00415521f, 0.00623345f, 
    -0.01561352f, 0.02599533f, -0.01801942f, 0.02523240f, -0.01964058f, -0.03978895f, 0.01965213f, -0.02939123f, 
    0.01178894f, 0.03289186f, 0.03365560f, -0.02571175f, -0.03524586f, -0.01285550f, -0.02921985f, -0.02349441f, 
    -0.02874250f, -0.00871975f, -0.00999750f, 0.02288806f, -0.02428649f, 0.01244877f, -0.00637813f, 0.02971974f, 
    0.01769300f, -0.02518721f, -0.02415754f, 0.01136416f, 0.00514330f, -0.03529962f, 0.02563404f, -0.03670210f, 
    0.00664524f, -0.00235667f, -0.00001600f, -0.00006074f, 0.02493061f, -0.02437387f, 0.01157054f, -0.01474288f, 
    -0.00674469f, 0.00384801f, 0.00947788f, 0.00929466f, -0.03295839f, 0.01576421f, -0.04035375f, -0.03662680f, 
    0.02829743f, 0.03806921f, -0.03815340f, -0.03504716f, 0.03587240f, 0.02617439f, -0.01511525f, -0.00565979f, 
    0.01968344f, 0.02912252f, -0.01277319f, -0.04340675f, 0.00215424f, -0.02081035f, -0.03228955f, -0.03442329f, 
    -0.00600992f, 0.03505426f, -0.03056993f, 0.00079039f, -0.00573667f, -0.01379782f, -0.00046874f, 0.01293666f, 
    0.02128106f, -0.02879699f, 0.01248153f, -0.00724018f, 0.01877848f, 0.01997585f, -0.00145811f, -0.01832296f, 
    -0.00721444f, 0.02231980f, -0.01243113f, 0.01747815f, -0.03318428f, -0.02488174f, 0.00793118f, 0.00524385f, 
    0.01572815f, 0.01173035f, -0.04156263f, 0.00570463f, -0.01221750f, 0.02501785f, 0.02115784f, -0.04442265f, 
    0.00342460f, -0.02595680f, 0.02112630f, 0.02491873f, -0.01447994f, -0.01335450f, -0.03273195f, -0.03745629f, 
    0.00419613f, 0.03584561f, -0.01197395f, 0.03351103f, 0.00987362f, -0.01017444f, -0.01111337f, -0.00340466f, 
    -0.03109382f, 0.01062847f, 0.00522960f, -0.00405455f, -0.04005257f, -0.04145757f, 0.03212577f, 0.03002838f, 
    0.00445535f, -0.02259627f, 0.02267750f, -0.02031780f, 0.01934611f, 0.00048021f, -0.03315563f, 0.02098377f, 
    0.00879603f, 0.02944660f, 0.01579993f, 0.01576403f, -0.03798714f, -0.03219738f, -0.00414417f, 0.00055730f, 
    -0.02166418f, -0.02329827f, -0.01620627f, -0.00535111f, 0.01508733f, 0.03158814f, 0.03159759f, 0.01585951f, 
    0.01885947f, 0.00445113f, -0.03259671f, -0.00182468f, 0.04418875f, 0.00808258f, -0.02390619f, 0.03160976f, 
    0.00827242f, 0.01896254f, 0.00988070f, -0.03123028f, -0.00557915f, 0.02744505f, 0.04133187f, 0.00867226f, 
    0.02686999f, -0.02761324f, 0.02710473f, 0.02790635f, -0.03569920f, -0.02425695f, -0.02263581f, -0.01428169f, 
    -0.00731796f, -0.00783371f, 0.00052924f, 0.02566605f, -0.02364794f, 0.00475675f, 0.01854212f, -0.02729918f, 
    0.01382505f, 0.01489765f, 0.00719221f, -0.02506027f, -0.02432615f, -0.01406927f, 0.01416165f, -0.02328106f, 
    0.01128660f, -0.04253307f, 0.03396922f, 0.01551593f, 0.01123142f, 0.02261905f, 0.03083669f, -0.03890247f, 
    0.03582473f, -0.01223714f, 0.00107633f, 0.01486478f, -0.03523509f, 0.03453228f, -0.00310939f, -0.00803957f, 
    -0.01419822f, 0.01203333f, -0.02063814f, -0.00736612f, 0.02031438f, -0.02939621f, 0.01001962f, -0.03901825f, 
    0.02878704f, 0.02509771f, 0.00084097f, 0.00763500f, -0.02229878f, -0.01285452f, 0.03110155f, -0.02763126f, 
    0.03648328f, 0.02910121f, 0.01316300f, -0.01112575f, 0.01523576f, 0.03360765f, -0.03063020f, 0.03235163f, 
    0.00905723f, 0.00423788f, 0.01608616f, -0.01457959f, -0.02554744f, 0.00863026f, -0.02658405f, -0.00641493f, 
    0.00966665f, -0.01532198f, -0.02938583f, -0.01563268f, 0.01604369f, -0.02448904f, -0.00258730f, -0.00063380f, 
    0.00662592f, -0.01243077f, -0.02187947f, -0.01442392f, 0.03200053f, 0.00060710f, -0.04463345f, -0.03052310f, 
    0.01904130f, -0.03519131f, 0.00824525f, 0.03323724f, -0.04100118f, 0.03017950f, -0.01470535f, 0.01670852f, 
    -0.01979151f, -0.01032437f, -0.01922151f, 0.00369577f, -0.00388691f, -0.03716731f, -0.00709224f, 0.01846230f, 
    0.01449337f, -0.03686380f, -0.02186231f, 0.03024337f, 0.03339686f, 0.00375282f, -0.01807895f, -0.01921047f, 
    -0.00706792f, -0.02141807f, -0.00664233f, 0.02535029f, 0.00519985f, -0.03710401f, 0.03241425f, 0.01618015f, 
    -0.01611487f, -0.03626555f, 0.03602671f, -0.02027073f, -0.03118788f, -0.01498222f, -0.02954085f, -0.02725388f, 
    -0.02504066f, -0.00553011f, -0.00936827f, -0.03381312f, 0.01294626f, -0.00490677f, 0.02146498f, 0.02864303f, 
    0.01704812f, 0.00797489f, -0.02903496f, -0.04187131f, -0.00535515f, 0.01673622f, -0.02365179f, -0.02142608f, 
    0.00263991f, 0.00695785f, -0.01215404f, -0.01217706f, -0.04428910f, -0.01311684f, 0.01411148f, 0.01210815f, 
    -0.00710901f, -0.03760058f, 0.00560311f, 0.00204941f, 0.02332428f, -0.01012598f, -0.04340528f, -0.00971025f, 
    -0.03353209f, -0.00812334f, -0.00351217f, 0.02427696f, -0.02132520f, -0.02455924f, -0.03375911f, -0.01287255f, 
    0.02699078f, 0.02361451f, 0.02488395f, -0.02403625f, -0.00643455f, 0.02040758f, 0.02983931f, -0.00528969f, 
    -0.01959312f, -0.00919119f, -0.01767733f, 0.02462888f, 0.02682689f, -0.02445245f, -0.01528256f, -0.03689187f, 
    -0.03895351f, -0.03622487f, -0.03119664f, 0.01490477f, -0.01719960f, 0.03231657f, -0.02294174f, 0.04269681f, 
    -0.02559077f, 0.01911721f, 0.02899292f, -0.00051345f, 0.02645928f, -0.01849174f, 0.02499365f, 0.03167419f, 
    -0.02345921f, -0.02944891f, -0.01939483f, 0.02890466f, 0.01616626f, -0.01907832f, -0.00206367f, 0.01503037f, 
    0.02346930f, 0.00057660f, -0.03947438f, -0.04289719f, -0.03197294f, -0.03446835f, -0.00375595f, -0.00673559f, 
    0.02458802f, 0.01547373f, 0.00144027f, -0.01494709f, 0.00282160f, -0.01328529f, -0.01756167f, -0.00025054f, 
    -0.01839500f, 0.00491611f, -0.03009501f, -0.04085348f, -0.03383150f, 0.01773902f, 0.03185370f, -0.00764786f, 
    0.00602534f, -0.02780102f, 0.00763396f, -0.03281436f, -0.01196560f, -0.00782625f, 0.01643993f, 0.00727700f, 
    0.00060807f, 0.02088261f, 0.01108704f, -0.02142464f, -0.04338700f, 0.00611456f, 0.02286835f, -0.03289022f, 
    -0.01146521f, 0.01983391f, 0.01584780f, -0.02324432f, -0.04513497f, -0.04545815f, -0.04447075f, 0.02386299f, 
    -0.03984540f, -0.03547035f, 0.02932967f, -0.01725831f, 0.00271957f, -0.04411480f, -0.02082724f, -0.03575904f, 
    -0.01384233f, 0.00003481f, -0.02738414f, 0.02775430f, 0.01172942f, -0.02085909f, -0.03321848f, 0.02035533f, 
    0.02775308f, -0.02071692f, -0.02989011f, -0.01644818f, -0.00442328f, 0.01341692f, -0.00296672f, -0.01725193f, 
    0.00451909f, -0.00334079f, 0.02814718f, -0.03440995f, -0.00855447f, 0.00636842f, -0.02661359f, -0.02915522f, 
    -0.03457237f, -0.04509281f, 0.01216058f, 0.02092828f, 0.02060787f, 0.02835460f, 0.00802793f, -0.00854389f, 
    -0.03238879f, -0.02873570f, -0.01404115f, 0.00303319f, 0.00163415f, 0.01788704f, -0.03676412f, -0.01894363f, 
    0.00570127f, -0.04105996f, -0.00900473f, 0.00616098f, -0.02542837f, 0.02508257f, -0.00085383f, -0.04415549f, 
    -0.00886252f, 0.00322857f, -0.01619818f, -0.03807101f, -0.01613374f, 0.01357604f, 0.02582409f, -0.02293068f, 
    -0.03367256f, 0.01404668f, -0.02243929f, -0.01055906f, -0.00978372f, 0.03131623f, -0.03437241f, 0.02956644f, 
    -0.00812844f, -0.02994055f, -0.02237360f, -0.03792849f, -0.03312306f, -0.03864664f, -0.04465485f, -0.02197800f, 
    -0.04361255f, -0.02916562f, -0.01310618f, 0.00931325f, -0.02575476f, 0.03237529f, -0.00766063f, -0.03511334f, 
    -0.02550800f, -0.01527761f, -0.04027360f, -0.00070171f, -0.01158697f, 0.03065186f, -0.02786558f, 0.00138851f, 
    0.03113453f, -0.00788056f, -0.04516385f, 0.02810656f, 0.01511720f, -0.00934396f, 0.03220728f, 0.01573927f, 
    0.02162881f, -0.02891501f, 0.02325288f, -0.01659987f, -0.02066582f, 0.01680359f, -0.00538773f, 0.03249865f, 
    -0.01618082f, 0.02010185f, -0.04006700f, 0.00322299f, 0.00218756f, -0.03125248f, -0.00478796f, -0.03159522f, 
    -0.04259463f, 0.02717989f, 0.01123898f, -0.04039649f, -0.01694698f, -0.00263672f, -0.00007348f, -0.01585993f, 
    0.00705741f, -0.00413266f, 0.02650623f, -0.02520280f, -0.02478865f, 0.01900431f, 0.01272801f, -0.00446052f, 
    -0.01287937f, -0.00434556f, -0.03719459f, 0.01446878f, -0.04409438f, -0.02079083f, 0.01820306f, 0.02995729f, 
    -0.04515778f, -0.00924440f, -0.02303711f, -0.03843804f, -0.00018582f, -0.03791805f, 0.02677230f, -0.04326686f, 
    0.02037069f, 0.02090757f, 0.01086180f, 0.00320077f, 0.00253374f, -0.02368476f, -0.01633262f, 0.00121801f, 
    0.02004914f, -0.01117840f, 0.01394911f, -0.03386324f, -0.04216048f, -0.03348320f, -0.02596252f, -0.01954466f, 
    0.01141527f, -0.00626847f, -0.00598280f, -0.00457174f, 0.00250371f, -0.02366030f, 0.01281229f, 0.01353232f, 
    -0.00912230f, -0.01088374f, 0.01006257f, 0.00124339f, -0.03783300f, -0.00429649f, -0.02915699f, -0.01913567f, 
    0.03285965f, -0.03409864f, 0.02956804f, -0.02506015f, -0.01961154f, 0.02701606f, 0.01614644f, 0.00101859f, 
    0.02728385f, -0.04013215f, -0.03675536f, -0.00740332f, 0.00937012f, 0.02945820f, -0.02379098f, -0.01847628f, 
    -0.00433348f, -0.04155809f, -0.02687303f, -0.00016442f, -0.00022067f, 0.03037888f, 0.01902907f, -0.03716267f, 
    0.00778677f, 0.02879904f, -0.02554071f, 0.03237459f, -0.01831992f, -0.02381276f, -0.00586076f, 0.00167466f, 
    0.00857645f, 0.02973427f, 0.02968579f, -0.03054244f, 0.02924648f, 0.01905020f, 0.01632881f, -0.03925873f, 
    -0.03650383f, -0.02274116f, 0.00837436f, -0.03011119f, 0.01806301f, 0.01460102f, -0.00125881f, 0.00986099f, 
    0.00852518f, 0.03351575f, 0.02735287f, -0.00934949f, -0.02652245f, -0.01752700f, -0.02311270f, 0.00967471f, 
    -0.03137374f, -0.02828740f, 0.02054314f, 0.01413029f, 0.01401448f, -0.00531137f, -0.00291188f, -0.02954707f, 
    -0.02395446f, 0.01412399f, 0.03231087f, -0.00619256f, -0.00327565f, 0.01975266f, -0.00733245f, -0.00816481f, 
    -0.00459262f, -0.03501370f, -0.01528671f, -0.00210555f, -0.02740103f, 0.02604806f, 0.01405246f, -0.00557919f, 
    0.01532048f, 0.02710055f, -0.03075156f, 0.02932202f, -0.03575233f, -0.00209880f, 0.01951236f, 0.02301995f, 
    -0.03379634f, -0.04147400f, 0.00548114f, -0.03683417f, -0.01049244f, 0.00319054f, 0.03965283f, 0.01143448f, 
    -0.00406379f, 0.02374901f, -0.01270210f, -0.03933089f, -0.00857693f, 0.00233906f, -0.03016417f, 0.00780433f, 
    -0.01642080f, 0.02623545f, 0.01614836f, -0.03421389f, 0.03983529f, 0.01461260f, 0.02426975f, -0.02058194f, 
    0.02255765f, -0.04112430f, 0.01227776f, 0.00706401f, -0.03959103f, -0.03410893f, -0.02715900f, -0.02535750f, 
    0.01623263f, 0.03167584f, -0.03521695f, -0.04148204f, 0.03066243f, -0.00794643f, -0.01853647f, -0.01754744f, 
    -0.02106267f, -0.02216000f, -0.02403125f, -0.01409875f, -0.01992731f, 0.02560426f, 0.03012808f, 0.02748755f, 
    0.03012153f, 0.02178657f, -0.02396610f, -0.02020449f, 0.02122856f, 0.00669461f, -0.00590123f, 0.02720012f, 
    0.01469627f, 0.00684624f, 0.01753685f, -0.01165242f, 0.02787664f, -0.03485622f, -0.04341790f, -0.00239117f, 
    0.02681900f, -0.02800590f, 0.03264764f, -0.01084837f, -0.02466853f, 0.03076397f, -0.03329039f, 0.01190099f, 
    -0.01070922f, -0.04372956f, 0.00081095f, -0.04247769f, 0.00117917f, -0.01940187f, -0.04424313f, -0.00400316f, 
    -0.01872083f, -0.02455607f, -0.03631007f, -0.02161043f, -0.02010006f, 0.02854885f, 0.00724045f, 0.02128784f, 
    0.02459765f, -0.00879038f, 0.01536061f, 0.00382848f, -0.03552473f, 0.02543364f, -0.01152309f, -0.01505925f, 
    -0.03419545f, 0.03193415f, 0.02720987f, 0.01285009f, 0.02883335f, 0.02948230f, -0.04272417f, 0.02268704f, 
    0.04406407f, -0.00950436f, -0.00702232f, -0.00844699f, -0.00000361f, 0.02207385f, -0.00377286f, -0.00335205f, 
    -0.03819761f, -0.01779944f, 0.02867566f, 0.03100102f, 0.00227716f, -0.02412760f, -0.04042152f, -0.01209568f, 
    -0.01946521f, 0.01511405f, -0.00857885f, -0.03502338f, 0.02105463f, 0.02055315f, -0.03947750f, 0.03001978f, 
    -0.03099114f, -0.02479941f, -0.00893570f, 0.01564678f, -0.04371060f, -0.04464867f, -0.01825193f, 0.00388463f, 
    -0.02463494f, 0.02230097f, -0.00829069f, -0.01766868f, 0.02535367f, -0.03602677f, -0.04067576f, 0.02458265f, 
    -0.03559159f, 0.00959827f, -0.02912127f, -0.04334141f, 0.03293293f, -0.03873757f, -0.00729783f, -0.04044782f, 
    -0.03257640f, -0.02837315f, -0.01750129f, -0.01202645f, 0.02435386f, -0.03919599f, 0.00649267f, -0.00297498f, 
    0.02261683f, -0.00647871f, -0.01278799f, 0.01327659f, 0.02574639f, -0.00381584f, -0.00861120f, -0.03273489f, 
    -0.02659008f, 0.03594667f, -0.02577298f, -0.01329812f, 0.02640220f, 0.02443414f, -0.02995029f, 0.02778616f, 
    0.00849413f, 0.01056290f, -0.03285201f, -0.01427520f, 0.03556366f, -0.04232156f, 0.00913231f, 0.01802745f, 
    0.01896656f, 0.02177954f, 0.03139303f, 0.02765568f, 0.03343903f, 0.00779835f, 0.02852557f, 0.03147476f, 
    0.00175197f, 0.03213124f, -0.04084693f, -0.04819335f, 0.00939450f, -0.03660294f, -0.03676669f, 0.01944701f, 
    0.02865052f, -0.04890288f, 0.00215052f, 0.02613661f, -0.02606810f, 0.01946679f, 0.02684221f, -0.00366033f, 
    -0.00686290f, 0.00525204f, 0.03228832f, 0.01913177f, -0.01944581f, 0.02189163f, -0.01260714f, -0.01550952f, 
    -0.01322435f, -0.02430309f, -0.00049869f, 0.01726307f, 0.02460414f, -0.00908802f, -0.02146520f, -0.02504923f, 
    -0.02215621f, 0.02291471f, -0.01246614f, 0.02220570f, 0.03371790f, -0.03204346f, -0.04549222f, -0.01691766f, 
    0.02762202f, -0.02558007f, 0.02339018f, -0.02323927f, -0.03011510f, -0.00666451f, 0.03844953f, 0.00110240f, 
    0.03244419f, -0.02392270f, 0.03396512f, -0.03208086f, 0.03104404f, -0.00730562f, -0.03362450f, -0.00092243f, 
    -0.01627111f, -0.00617077f, -0.00457943f, -0.03166417f, 0.04089103f, 0.00032559f, -0.01827762f, -0.03265728f, 
    -0.03498634f, -0.00824486f, 0.01395549f, -0.03698213f, 0.02152619f, 0.01490264f, 0.00422034f, -0.03905061f, 
    -0.01719448f, 0.02884173f, -0.02569924f, 0.01343837f, -0.02480426f, -0.00277982f, -0.01777592f, 0.03800278f, 
    -0.02703478f, 0.01367471f, -0.03170099f, 0.02144481f, -0.01188342f, -0.02763693f, -0.04512427f, -0.03296736f, 
    0.01318191f, -0.02572544f, 0.00760190f, 0.03631366f, -0.04388709f, 0.00514487f, -0.00451801f, 0.01760087f, 
    0.02178823f, -0.04616716f, 0.00812761f, 0.00579668f, -0.01440151f, 0.00203607f, -0.00664728f, 0.00574662f, 
    0.01720924f, -0.00905379f, 0.00703661f, 0.02842407f, 0.00578519f, -0.01468063f, 0.02064327f, 0.02783323f, 
    -0.04019530f, 0.00408082f, -0.02597202f, -0.02243973f, 0.02205352f, -0.00860456f, -0.04000565f, -0.03198683f, 
    -0.00880017f, 0.02104956f, -0.01697503f, -0.03245801f, -0.03625420f, -0.04204398f, -0.01422288f, -0.01359400f, 
    -0.00325563f, -0.01444613f, -0.02509758f, 0.01273143f, -0.01799509f, 0.02556323f, -0.01346653f, -0.03166627f, 
    0.00971784f, 0.02094359f, -0.03894692f, 0.02333976f, -0.03516787f, -0.03220167f, 0.01124486f, -0.02888460f, 
    0.03384816f, -0.01956054f, 0.02254127f, 0.02131304f, -0.03762246f, -0.00214133f, 0.01732424f, -0.02725579f, 
    0.01137363f, -0.02484106f, -0.02603610f, -0.01584567f, 0.01940184f, -0.03458711f, -0.00989305f, -0.02106516f, 
    0.00337892f, -0.01392316f, 0.01738653f, -0.04337664f, -0.04151895f, 0.02189084f, -0.00671356f, 0.01309993f, 
    -0.01023299f, 0.01014128f, -0.02494200f, -0.00056521f, 0.02232694f, -0.01636606f, -0.02770479f, -0.01611244f, 
    0.02930464f, -0.04157629f, -0.03511048f, -0.00839449f, 0.01781714f, -0.03911499f, -0.02580018f, -0.01383423f, 
    -0.02699898f, -0.00936864f, -0.03325519f, -0.01261077f, -0.00025612f, 0.00098852f, -0.03014428f, 0.00218859f, 
    -0.03395092f, -0.00586255f, 0.00576757f, 0.01849025f, -0.04530874f, 0.02190936f, -0.02891056f, 0.02488589f, 
    -0.02206727f, -0.02554572f, 0.01828329f, 0.02160964f, -0.02442936f, 0.01013063f, -0.01117264f, -0.02878897f, 
    -0.01599227f, 0.00283994f, -0.04179061f, 0.02426151f, -0.01577230f, -0.00201777f, -0.03431059f, -0.02696865f, 
    -0.03872287f, 0.02468368f, 0.02533303f, -0.03782354f, -0.03609112f, 0.03307776f, -0.03614060f, -0.04658559f, 
    0.02155482f, 0.00982158f, -0.03513952f, -0.00694810f, 0.02563802f, 0.02494025f, -0.01372042f, 0.02107595f, 
    -0.00308516f, -0.04337462f, 0.01193920f, -0.00564810f, -0.02316108f, -0.00226797f, -0.04575656f, -0.00110945f, 
    -0.00131785f, -0.03688928f, -0.03488076f, 0.01796274f, -0.00555966f, 0.02866153f, -0.01512852f, 0.02451567f, 
    0.02397545f, -0.00905137f, 0.01371419f, -0.00858891f, -0.00530854f, -0.02402641f, -0.02233010f, -0.01305627f, 
    -0.02897413f, -0.03269717f, -0.03705390f, -0.02584083f, 0.01491943f, 0.01063306f, 0.02120201f, -0.02678514f, 
    0.02344217f, -0.02212411f, -0.00735798f, 0.01669767f, 0.02251879f, -0.00203753f, -0.03430342f, -0.01698270f, 
    -0.00939622f, 0.00577491f, -0.01482317f, -0.01805570f, -0.01763705f, -0.00816808f, -0.01699431f, -0.01858760f, 
    -0.00778917f, -0.01001140f, 0.01379835f, 0.02377428f, -0.04296706f, 0.03577299f, -0.01304946f, 0.01092141f, 
    0.00238653f, -0.00323710f, 0.02736993f, -0.00613061f, -0.01414529f, -0.04373985f, 0.00242420f, -0.04428117f, 
    -0.01057125f, -0.00997311f, -0.01940094f, 0.04638435f, 0.00963546f, -0.03429045f, -0.03326069f, 0.01326253f, 
    -0.00379556f, -0.02183721f, 0.01925904f, -0.04196300f, -0.04683601f, -0.04375700f, -0.03044393f, 0.01601644f, 
    0.03138702f, 0.03380512f, 0.01812889f, -0.02121943f, 0.01824833f, -0.03543704f, -0.01813455f, 0.00493009f, 
    -0.01822263f, 0.02676431f, -0.04797827f, -0.03438915f, 0.00810919f, 0.02169923f, -0.01840107f, -0.01981836f, 
    -0.02282691f, -0.00664399f, -0.03566721f, -0.02346070f, -0.03881468f, 0.03125846f, 0.00128209f, 0.01221052f, 
    -0.04017335f, -0.01630707f, 0.00742382f, -0.03563090f, 0.01804046f, 0.01408748f, 0.00020508f, -0.00803257f, 
    -0.01543677f, -0.03672108f, 0.00046579f, 0.03300867f, -0.01951337f, -0.03317647f, 0.01029505f, -0.02137949f, 
    0.00333161f, 0.00368734f, 0.00392021f, -0.04751505f, 0.03518309f, 0.00446814f, 0.00748978f, -0.00819296f, 
    0.02549414f, 0.03293984f, 0.01699200f, -0.03920485f, -0.00050000f, -0.03834507f, -0.02629312f, 0.02766038f, 
    -0.04102942f, 0.03131680f, 0.00291694f, -0.02216076f, -0.04421085f, 0.00191339f, -0.01132395f, 0.00590584f, 
    0.00640750f, 0.01829248f, -0.04447771f, -0.01903157f, 0.02200119f, 0.02451619f, 0.01826400f, -0.04526112f, 
    0.01720604f, 0.01942448f, 0.02726542f, 0.00291137f, 0.01183362f, -0.01173667f, -0.01733379f, -0.03152951f, 
    0.02524594f, -0.01529686f, -0.04162350f, -0.01767396f, -0.01417003f, 0.00417446f, 0.01574180f, -0.01550639f, 
    -0.02317685f, -0.00589537f, -0.02254916f, 0.00027087f, -0.00409050f, -0.00275990f, 0.02854025f, -0.00517666f, 
    0.02836083f, -0.01370575f, 0.02674849f, 0.02901423f, -0.01827739f, -0.00938432f, 0.02466696f, -0.03768659f, 
    -0.03708501f, 0.01085744f, -0.03353533f, -0.00684367f, 0.01108080f, 0.00250197f, -0.01806207f, 0.01562504f, 
    0.00588160f, -0.00815307f, -0.01403343f, -0.00885786f, -0.04186558f, 0.00985654f, 0.00819083f, 0.01485104f, 
    0.01038945f, -0.02973020f, 0.03189399f, 0.00388183f, 0.02097386f, -0.02874389f, -0.00091899f, -0.01897904f, 
    0.02481961f, 0.01350373f, -0.01883512f, -0.01355074f, 0.00365233f, 0.01838883f, 0.00346693f, -0.03575915f, 
    -0.04163435f, -0.02310207f, 0.02546270f, 0.02409896f, 0.02630885f, 0.01705589f, 0.03457207f, -0.00091357f, 
    0.00063840f, 0.03809565f, -0.03260135f, -0.01091164f, 0.03896587f, 0.02211089f, -0.02413432f, -0.03360505f, 
    0.02775102f, -0.03566130f, -0.02988990f, 0.00926073f, 0.01108859f, 0.02706211f, 0.04461461f, -0.01728974f, 
    -0.03379018f, -0.03314382f, 0.00031741f, -0.03506965f, -0.01892993f, 0.00569092f, 0.00850748f, -0.02955599f, 
    0.02490796f, -0.02778561f, 0.04150972f, 0.01499584f, -0.00456226f, -0.04498217f, -0.04143331f, -0.00488461f, 
    0.02451535f, -0.02075345f, 0.02697038f, 0.01312247f, 0.00939793f, -0.04633078f, -0.03034322f, -0.03078948f, 
    -0.01165705f, -0.04691307f, -0.03829103f, 0.00619850f, -0.02398936f, 0.01082141f, -0.00231835f, -0.01335952f, 
    0.01358606f, 0.02209385f, 0.02029901f, -0.02204745f, -0.04214196f, 0.00445195f, -0.01788083f, -0.02118211f, 
    0.02589924f, 0.01892992f, 0.00031823f, 0.03838797f, 0.00327178f, -0.04276897f, -0.02963220f, 0.02837835f, 
    0.02251312f, -0.03386453f, -0.00674058f, 0.00250960f, -0.02737561f, 0.00394928f, 0.00842793f, -0.00653030f, 
    -0.01176416f, 0.02546501f, -0.01030268f, 0.04285979f, 0.00715553f, 0.01456197f, 0.02019418f, 0.02263898f, 
    -0.01704833f, -0.02353849f, -0.02477386f, -0.01458496f, 0.00763890f, 0.01509611f, -0.03632974f, 0.02705995f, 
    0.01799173f, 0.03049538f, 0.01365602f, 0.00039056f, -0.03922735f, 0.01063291f, 0.01935244f, 0.03872659f, 
    -0.02428367f, -0.02552859f, -0.00366594f, -0.00552586f, -0.02927252f, 0.02867589f, 0.00725619f, 0.02911736f, 
    0.00354269f, -0.00593597f, -0.02530417f, -0.02043607f, -0.04229211f, -0.01115095f, 0.00845485f, -0.00556447f, 
    -0.03825364f, -0.00360372f, -0.03371595f, -0.01926807f, 0.03593306f, 0.01171911f, -0.02848815f, 0.01417826f, 
    0.02151754f, 0.01515119f, -0.02235557f, 0.01908263f, -0.00652843f, 0.02830634f, 0.01435865f, 0.01902189f, 
    -0.01575342f, -0.00782488f, 0.01925979f, -0.01264257f, 0.00651273f, -0.01630305f, -0.01750006f, -0.00070039f, 
    -0.00125958f, 0.00902153f, 0.02657229f, -0.03388543f, 0.01614727f, 0.01789309f, 0.02507462f, 0.01932132f, 
    -0.03052073f, 0.00294337f, -0.03692405f, 0.00366909f, 0.00919787f, -0.04380229f, -0.02914161f, 0.03302234f, 
    0.01953999f, 0.02218299f, 0.01081464f, -0.01864727f, -0.00858313f, 0.00509791f, 0.02154045f, -0.00802151f, 
    0.02639074f, 0.01631662f, 0.01694450f, 0.01379872f, 0.03489946f, -0.02923035f, -0.01919786f, 0.02638530f, 
    -0.00596742f, 0.02568511f, 0.02394114f, -0.02743379f, -0.01390069f, 0.02528036f, -0.03215220f, -0.00875801f, 
    0.02722329f, -0.02595155f, 0.00045136f, 0.01242675f, -0.02580138f, -0.02708168f, 0.03086677f, -0.00809125f, 
    -0.02777039f, 0.00069850f, 0.03222493f, -0.04160298f, -0.02398220f, 0.02884521f, 0.02462181f, 0.02674866f, 
    -0.03652634f, 0.03134803f, 0.00322552f, 0.01375645f, -0.03821770f, 0.01644674f, -0.00048208f, -0.03319688f, 
    0.02008604f, -0.02122999f, -0.04317699f, 0.00783333f, 0.02430328f, 0.01803417f, -0.03684421f, -0.03199796f, 
    -0.00487998f, -0.00906700f, -0.02454064f, 0.01933778f, -0.03635716f, 0.01337820f, -0.01799895f, -0.01973027f, 
    -0.03871604f, -0.02379543f, -0.00011655f, 0.00825602f, 0.03955022f, -0.01081959f, -0.02972586f, -0.01644226f, 
    -0.01021354f, -0.01933148f, -0.04453210f, 0.03583131f, 0.03035563f, 0.02190043f, -0.03840488f, -0.04208929f, 
    -0.04120199f, 0.02569457f, 0.02955179f, 0.00306700f, 0.02636826f, -0.00071755f, -0.00557442f, -0.00848166f, 
    -0.01657597f, -0.00363011f, 0.03094573f, 0.04195087f, 0.01696106f, 0.00275490f, -0.02445315f, 0.01898993f, 
    0.02006054f, -0.01729514f, 0.01169452f, -0.02505782f, -0.02297576f, -0.01965769f, -0.01527555f, -0.01391251f, 
    -0.00612377f, 0.00565619f, -0.00003732f, 0.00821756f, 0.01057257f, -0.04281960f, 0.01818806f, -0.02450126f, 
    0.01090894f, -0.02233723f, 0.01738203f, 0.00500891f, 0.01780662f, -0.03702023f, -0.00842351f, 0.00368331f, 
    -0.00933807f, -0.00083683f, 0.01026575f, -0.04244871f, -0.02374913f, -0.03777379f, -0.03891968f, 0.02876371f, 
    -0.02936155f, 0.01547577f, -0.00073480f, 0.00303418f, -0.01161727f, 0.01432114f, -0.02521926f, 0.00400381f, 
    0.01716097f, -0.04621001f, 0.02306003f, 0.01341212f, 0.01762516f, 0.00142417f, -0.02416968f, -0.00820772f, 
    0.03385736f, 0.00658378f, -0.00291891f, 0.00713024f, -0.01757491f, -0.02894886f, 0.01251484f, -0.04353150f, 
    -0.00072698f, -0.00704200f, 0.01475902f, -0.04278566f, -0.03663282f, -0.01565297f, 0.02161918f, 0.02365841f, 
    -0.02456609f, -0.02618659f, 0.02213626f, -0.00484128f, -0.03929935f, -0.04228400f, 0.01376039f, 0.00977228f, 
    -0.00319178f, -0.00859944f, -0.01661712f, -0.00360161f, -0.03115384f, -0.03874731f, -0.03365289f, 0.01292011f, 
    0.01283148f, -0.02354986f, 0.00823758f, 0.01133676f, -0.00472765f, -0.02285153f, 0.00357552f, 0.01601061f, 
    0.03787014f, -0.02997922f, -0.04161451f, 0.01415937f, 0.02083190f, -0.04363556f, 0.02630086f, -0.02229011f, 
    0.01437600f, 0.01290141f, 0.01109617f, -0.01296392f, -0.01692316f, -0.03169672f, -0.01530598f, 0.02293027f, 
    -0.00490635f, -0.04176362f, -0.01952871f, -0.00813786f, 0.00200859f, 0.01262831f, 0.03197016f, -0.02534817f, 
    0.01045775f, 0.01085607f, -0.02810343f, -0.02072335f, -0.00347661f, 0.00266690f, 0.01073284f, -0.01693499f, 
    0.00112554f, -0.00694401f, 0.03137207f, 0.02677185f, -0.01603907f, -0.04302961f, -0.02200105f, -0.02394696f, 
    -0.04109958f, 0.00159631f, -0.00843638f, 0.01345833f, -0.00041069f, 0.03347341f, -0.00576394f, 0.01565951f, 
    -0.04275195f, 0.02365496f, 0.01488584f, -0.03517079f, 0.03466699f, 0.02545811f, -0.01770270f, 0.01206314f, 
    0.01442815f, -0.01806818f, -0.04716505f, -0.00805013f, -0.03879161f, -0.02302757f, 0.03043282f, -0.00885802f, 
    0.01550737f, -0.02514263f, 0.01271625f, -0.01637318f, -0.02527562f, 0.02236509f, 0.01647278f, -0.00504204f, 
    0.03010909f, -0.04319090f, -0.03429049f, -0.03309654f, -0.02552984f, 0.01641685f, -0.04041126f, -0.03933695f, 
    -0.03938290f, 0.02264983f, -0.03017693f, -0.01383411f, 0.00629800f, -0.00995249f, -0.03112919f, -0.04397218f, 
    -0.04387128f, 0.02989083f, 0.02515952f, -0.00967537f, -0.01085557f, -0.03555357f, -0.00347693f, -0.03065988f, 
    0.00769973f, -0.02575253f, 0.01938050f, -0.03344524f, 0.02014542f, -0.00176141f, 0.03180008f, -0.02510275f, 
    0.01611464f, 0.01614793f, -0.02502801f, -0.02459790f, 0.01091556f, -0.00355670f, -0.04094968f, 0.02353309f, 
    -0.02961247f, -0.00964072f, 0.00244311f, -0.01220069f, -0.00034671f, 0.02144773f, 0.01164924f, -0.02793208f, 
    -0.00860474f, -0.02927379f, 0.02811460f, -0.03160514f, -0.02990031f, 0.02062519f, 0.03369032f, 0.02139856f, 
    0.02383447f, 0.02140838f, -0.01795773f, 0.01118583f, 0.02677400f, -0.00004589f, 0.02277107f, -0.00171889f, 
    -0.01431172f, -0.01983020f, -0.00728928f, -0.04628852f, -0.03027341f, -0.00062607f, -0.02177252f, 0.00198946f, 
    -0.01762183f, -0.03025181f, 0.00041177f, 0.00546731f, -0.00347932f, -0.01579164f, -0.04031308f, -0.00346466f, 
    0.00935155f, -0.02056998f, -0.00372077f, -0.01140580f, 0.01120357f, 0.03540533f, 0.02710414f, 0.01862342f, 
    -0.03077603f, 0.03184108f, -0.00293448f, -0.01148867f, 0.00237469f, 0.00738446f, 0.00814478f, 0.02206959f, 
    -0.01051291f, 0.01303556f, 0.00504751f, -0.02318213f, -0.03166682f, -0.03208489f, 0.02218092f, -0.00185321f, 
    0.00605259f, -0.00785623f, 0.00685148f, -0.02968173f, 0.01865474f, -0.00480186f, -0.02243377f, 0.03165238f, 
    -0.00848396f, -0.03785299f, -0.00366275f, -0.00501701f, -0.01207232f, -0.03213978f, 0.02148639f, -0.01964404f, 
    -0.03972836f, -0.02864020f, 0.01516972f, -0.04459699f, 0.00679111f, 0.00707361f, -0.04393717f, -0.00418917f, 
    -0.02929059f, -0.03996209f, -0.00079142f, -0.02946363f, 0.00026997f, -0.02280843f, -0.03020630f, 0.03325072f, 
    -0.04317178f, 0.02211305f, -0.01002023f, 0.03617669f, 0.01170405f, 0.00341355f, 0.00133981f, -0.03177958f, 
    0.03308456f, 0.02169509f, -0.00813377f, 0.02951556f, -0.02567512f, -0.04062478f, -0.04600827f, 0.02617648f, 
    -0.03368920f, -0.01204932f, 0.00392105f, -0.03005960f, -0.04088879f, 0.02985285f, 0.01725604f, 0.01256510f, 
    -0.01519104f, 0.00246666f, -0.01067303f, -0.00317241f, 0.02578837f, 0.00727815f, -0.03706804f, 0.00941367f, 
    0.00883224f, -0.03285861f, 0.00830221f, -0.01763014f, -0.03583114f, 0.01043297f, 0.00115134f, -0.04225098f, 
    -0.03438623f, -0.01898647f, 0.00788207f, -0.04057045f, 0.02988687f, -0.03608199f, 0.00628188f, 0.02902358f, 
    -0.04411191f, -0.00988164f, 0.03148615f, -0.02746511f, -0.00695872f, -0.03471273f, 0.01592046f, -0.03317758f, 
    -0.02889469f, 0.00354759f, -0.03746875f, 0.02310731f, 0.02596054f, 0.01984795f, 0.00967954f, -0.04341476f, 
    -0.00979346f, 0.00818354f, 0.00699611f, -0.04195159f, -0.02455885f, -0.01022822f, 0.02788705f, 0.01990107f, 
    -0.01367395f, 0.01051557f, 0.00093607f, 0.00026650f, -0.03960519f, 0.02499002f, 0.01561709f, -0.01443182f, 
    -0.03346460f, -0.03586789f, -0.00113997f, 0.00305554f, 0.00828919f, 0.02861194f, -0.03338458f, -0.04154428f, 
    -0.02426717f, -0.01486906f, 0.00596233f, 0.01663742f, 0.03386357f, -0.03379559f, 0.02462300f, -0.02957044f, 
    -0.00912977f, 0.03198675f, 0.00685073f, 0.02093961f, 0.02048015f, -0.01257996f, -0.01698287f, 0.02323302f, 
    -0.03451158f, -0.00745916f, -0.01020481f, -0.03320294f, 0.03078483f, 0.00109535f, 0.01022427f, 0.02706791f, 
    0.00364707f, 0.02915785f, -0.01485414f, -0.02146109f, 0.01716527f, -0.00102222f, -0.00785474f, 0.02499095f, 
    -0.03416423f, -0.00599365f, 0.00780436f, -0.03882055f, -0.02971224f, -0.03976397f, 0.01853515f, 0.02056049f, 
    0.01234412f, 0.01131971f, -0.00014901f, 0.01942327f, 0.02625132f, 0.02166509f, 0.02483992f, 0.03575743f, 
    0.02755475f, 0.02519170f, 0.02485273f, 0.02376637f, -0.03946307f, -0.03011189f, -0.01234179f, 0.02409314f, 
    -0.01959106f, -0.00218609f, -0.00965264f, 0.03837049f, -0.01354736f, 0.00406279f, 0.00180677f, 0.00636940f, 
    -0.01934894f, 0.00392963f, 0.01515037f, 0.01556252f, 0.03172900f, 0.02809101f, 0.02924957f, -0.02596996f, 
    -0.01285392f, 0.01442832f, -0.04237968f, 0.02930062f, -0.01451783f, -0.00494863f, 0.00947276f, -0.02826552f, 
    0.03351584f, 0.01415044f, 0.00080383f, -0.00229096f, 0.03012013f, -0.01465325f, -0.04162269f, 0.02250216f, 
    -0.02616577f, -0.00512063f, 0.02771441f, -0.00362752f, 0.02369179f, 0.02342565f, -0.03342200f, -0.00401287f, 
    -0.00716907f, -0.03337407f, 0.02292676f, -0.01969459f, 0.01438485f, -0.03074319f, -0.03383024f, -0.02080916f, 
    -0.01744370f, -0.00555981f, 0.03148494f, 0.01525893f, 0.00274394f, 0.02732489f, 0.02327038f, -0.03717838f, 
    -0.04362521f, -0.00343767f, -0.02851265f, 0.02733367f, 0.01580812f, -0.01926494f, 0.00866055f, 0.02878499f, 
    -0.02679813f, -0.04114753f, 0.01781763f, -0.02281996f, -0.03861462f, -0.04330905f, -0.01784717f, -0.00299188f, 
    0.02946126f, -0.02994154f, -0.02773123f, -0.01153437f, -0.03408697f, 0.02845111f, -0.00185875f, -0.02098110f, 
    -0.03797606f, -0.02861098f, -0.03269477f, 0.01572658f, -0.03403510f, -0.02522391f, 0.00344043f, -0.01167929f, 
    0.00757411f, -0.00459615f, 0.01716659f, -0.02547996f, 0.01955362f, -0.01901378f, -0.00692167f, 0.02330910f, 
    -0.00472791f, 0.00530703f, -0.04051830f, -0.01371850f, -0.00228875f, -0.04043230f, 0.01415492f, 0.00271223f, 
    -0.01385745f, -0.02712962f, -0.01464159f, -0.00619205f, -0.01165030f, -0.03317050f, -0.03599626f, -0.03172123f, 
    -0.01027905f, -0.02677570f, 0.03393365f, -0.01728522f, -0.03869641f, -0.02219222f, 0.00719367f, 0.00244658f, 
    -0.02273371f, -0.01844187f, -0.00067151f, 0.00160978f, -0.04642296f, 0.03048987f, -0.02192560f, 0.00055260f, 
    0.03992608f, -0.02323486f, -0.03571482f, 0.03281960f, -0.01177188f, -0.02029421f, 0.00064253f, 0.01411012f, 
    0.01774452f, -0.00039087f, -0.03861167f, 0.03110700f, 0.01459191f, 0.02121839f, 0.02816077f, 0.00638698f, 
    0.00340866f, -0.04273834f, 0.00777189f, -0.02910803f, 0.01995218f, 0.02284648f, -0.01107808f, 0.01491780f, 
    -0.00933789f, -0.03172776f, -0.00846442f, -0.04184194f, -0.03436469f, -0.03820098f, -0.02859262f, -0.03242682f, 
    -0.01262299f, -0.02900532f, 0.00373515f, 0.01756227f, -0.04562959f, -0.03777671f, -0.03406774f, -0.00365912f, 
    0.00300438f, -0.03146492f, -0.03028204f, 0.01265611f, 0.02463800f, -0.01276816f, 0.02475085f, -0.02871620f, 
    -0.03229802f, 0.01712102f, -0.04790161f, 0.00028593f, 0.01729598f, -0.02896184f, -0.01752233f, -0.00428309f, 
    0.02929592f, 0.00913998f, 0.02188374f, -0.00069010f, -0.00914379f, -0.03847758f, 0.02456332f, -0.04532752f, 
    -0.03703571f, 0.03509837f, 0.00477664f, 0.03144544f, -0.03454433f, 0.04484978f, -0.00760788f, -0.02706177f, 
    -0.04373537f, 0.03465164f, 0.00590609f, -0.02379515f, 0.02449788f, 0.02271136f, -0.02085873f, -0.01298934f, 
    -0.01054993f, -0.00624294f, 0.02699575f, -0.04022237f, 0.01145892f, 0.00533916f, 0.03197951f, -0.02525796f, 
    0.00921267f, -0.03327042f, -0.04270656f, 0.02400457f, -0.00754989f, -0.01977901f, 0.04119283f, -0.00343582f, 
    0.02578191f, 0.02700708f, 0.01821703f, 0.03524309f, 0.03556206f, 0.00472801f, -0.02861294f, 0.00945656f, 
    0.02547977f, -0.03762031f, 0.01304314f, 0.03290004f, -0.00574116f, 0.03117399f, 0.01628202f, 0.01625398f, 
    -0.02537111f, 0.01636610f, -0.04536958f, 0.00601433f, 0.02651302f, -0.00354939f, -0.02006755f, 0.02236515f, 
    -0.01398583f, -0.00973676f, -0.02898759f, -0.04034074f, -0.03692522f, 0.01139173f, 0.01439713f, 0.01196150f, 
    -0.01485735f, -0.01696768f, 0.02103920f, -0.01763097f, 0.01203498f, 0.02615080f, 0.00428237f, -0.00155868f, 
    -0.00447878f, 0.01364341f, 0.00402721f, -0.01459657f, 0.02076290f, -0.03979081f, -0.05027399f, -0.01939384f, 
    0.00288922f, -0.00034698f, 0.01545004f, 0.00900546f, -0.00868006f, -0.02196152f, 0.02879992f, 0.02447224f, 
    -0.01764381f, 0.00286082f, -0.04727645f, -0.03805691f, -0.02113034f, -0.03998933f, 0.01624021f, -0.00996489f, 
    -0.01449748f, -0.00105226f, 0.01862234f, 0.01469403f, -0.03513407f, -0.00022457f, 0.02404061f, 0.00956831f, 
    0.00389875f, -0.00404624f, -0.00131483f, -0.04065191f, -0.01390670f, -0.00708921f, -0.03925366f, -0.00652964f, 
    0.01804611f, -0.01189608f, -0.04230721f, -0.00179365f, 0.02246160f, -0.01421385f, -0.01440328f, 0.02457542f, 
    0.00349345f, -0.04766963f, 0.00102170f, 0.00444847f, -0.01843359f, -0.02977616f, -0.01804646f, 0.01314605f, 
    0.02246113f, 0.00525510f, 0.02686426f, -0.00001579f, 0.01278560f, -0.03574680f, -0.00089648f, -0.00783532f, 
    -0.01766922f, -0.01750295f, 0.00175947f, -0.02658462f, -0.03529600f, -0.00451173f, -0.00843681f, -0.00276842f, 
    -0.00629249f, -0.03810684f, -0.00164917f, -0.01034418f, 0.04187754f, 0.02176599f, -0.03863774f, -0.00157567f, 
    -0.01903488f, -0.03286694f, 0.00440720f, 0.01773120f, -0.04682481f, -0.00766663f, 0.01773500f, -0.03389361f, 
    0.00741425f, -0.04516830f, -0.04339739f, 0.00180861f, -0.00487136f, -0.01262946f, 0.00112641f, -0.03229227f, 
    0.00529454f, -0.02902422f, 0.00429188f, -0.01788208f, 0.01831076f, 0.00970471f, 0.02560243f, 0.00174734f, 
    -0.01867168f, 0.00737959f, 0.00384853f, -0.00286058f, -0.02636123f, 0.00098356f, -0.00174102f, -0.03722619f, 
    0.01013423f, 0.02695214f, 0.01935519f, 0.00956493f, -0.04027477f, 0.00614952f, -0.02239596f, 0.03315189f, 
    0.02014625f, -0.01798035f, -0.04381860f, -0.03420354f, -0.01576628f, 0.01154895f, 0.01935147f, 0.01747083f, 
    -0.00773344f, 0.03045793f, -0.03585578f, -0.02341121f, -0.01988037f, -0.00963822f, -0.01514619f, -0.02574635f, 
    -0.02964119f, -0.03098955f, -0.03476518f, 0.03729013f, -0.00560095f, -0.01301733f, 0.01709730f, -0.01046699f, 
    0.01689477f, 0.01934719f, -0.02502762f, 0.02814986f, -0.03524262f, -0.01623320f, 0.03100325f, 0.00133608f, 
    0.02106085f, -0.01534116f, 0.02657371f, -0.03743132f, 0.00604381f, -0.01998527f, 0.00360923f, -0.01046160f, 
    0.00945686f, -0.03902951f, 0.01173319f, 0.02727500f, 0.02164394f, 0.02986565f, -0.03273174f, 0.01084539f, 
    -0.00827193f, 0.02005518f, 0.02642866f, -0.01107125f, -0.00514112f, 0.02348528f, 0.04123087f, 0.02430737f, 
    -0.01158770f, 0.00895869f, 0.00027763f, -0.03239925f, -0.01449105f, 0.01497092f, -0.03239791f, 0.00075255f, 
    -0.02947606f, -0.01147713f, -0.01234027f, 0.00258558f, -0.01713056f, 0.02023163f, 0.00854729f, -0.01581855f, 
    0.00594050f, -0.03776138f, -0.02827348f, -0.03683277f, -0.00334671f, -0.00875860f, -0.03142870f, -0.03608976f, 
    -0.02188705f, -0.02179899f, -0.00550665f, -0.02698524f, 0.00846752f, -0.00748486f, -0.03025501f, 0.00851565f, 
    0.02058424f, -0.03781836f, -0.01662635f, -0.00492301f, 0.00367337f, -0.00802974f, 0.01321454f, -0.00286827f, 
    0.00636703f, 0.00557405f, 0.03358205f, 0.04051964f, -0.03478967f, -0.01466677f, -0.03455652f, 0.00086874f, 
    -0.01723780f, -0.04204733f, 0.01789489f, 0.00689483f, -0.02628731f, -0.04322562f, 0.02509829f, -0.03760991f, 
    -0.01725882f, 0.00020892f, 0.00234652f, -0.04528658f, 0.02172067f, -0.02332581f, -0.04044478f, 0.02166122f, 
    -0.04193346f, -0.04551721f, 0.00892528f, -0.04127389f, 0.01771521f, -0.03318753f, 0.02751371f, -0.04217243f, 
    -0.04150339f, -0.04519900f, -0.03797985f, -0.00331468f, -0.02984064f, 0.02600983f, -0.03828267f, -0.00164797f, 
    0.00502637f, -0.02867931f, -0.03054052f, 0.02509153f, -0.01443040f, -0.04406234f, -0.00448695f, -0.01449303f, 
    0.00501126f, 0.00554539f, -0.02923393f, -0.00286958f, 0.01670068f, 0.02382914f, 0.02980588f, -0.00652654f, 
    0.02009013f, -0.00687619f, -0.03502014f, -0.03185827f, 0.01514850f, -0.01259312f, -0.01581690f, 0.03116375f, 
    0.03261684f, -0.04219821f, 0.01262675f, -0.02704429f, -0.01074516f, -0.03227622f, 0.03244067f, -0.00012489f, 
    0.01606185f, -0.01465067f, 0.02321232f, 0.00337915f, 0.01949022f, 0.03788279f, -0.01487942f, -0.03155547f, 
    -0.00725876f, -0.00518304f, -0.00170269f, -0.02087411f, 0.02495676f, -0.00346874f, 0.00505729f, 0.00883382f, 
    -0.01082011f, 0.01811185f, 0.02161219f, 0.02690557f, -0.02176027f, -0.01043807f, -0.00324718f, -0.01903503f, 
    0.03750464f, -0.03815423f, 0.00195945f, -0.00335338f, -0.03049679f, -0.00792533f, -0.01207761f, -0.01122904f, 
    -0.02023512f, 0.02463164f, -0.00217205f, 0.02700644f, 0.04002499f, 0.03534724f, 0.03434309f, 0.00468607f, 
    -0.01114267f, -0.02842235f, 0.00511172f, 0.00197926f, -0.01265244f, 0.01724143f, 0.01446506f, -0.04061566f, 
    0.01285531f, 0.03186169f, 0.01101167f, 0.02056818f, 0.01854894f, -0.03050807f, -0.02834349f, 0.00528535f, 
    -0.03377128f, 0.02798536f, -0.01009956f, -0.04040775f, 0.00400095f, 0.02609809f, -0.04566426f, -0.04214386f, 
    -0.04565090f, 0.04015545f, 0.03067110f, -0.00161829f, 0.00203204f, 0.03026806f, -0.03481494f, 0.00943970f, 
    -0.04490653f, -0.02019215f, -0.01557756f, -0.00825946f, 0.00669499f, 0.01183566f, -0.03354856f, 0.00296838f, 
    -0.03560343f, -0.02685561f, 0.03689206f, 0.01828379f, -0.02243743f, 0.01496479f, 0.02462908f, 0.00275915f, 
    0.04292848f, -0.03441405f, 0.02415918f, -0.01860198f, 0.02421615f, 0.03218363f, -0.00827572f, -0.01480929f, 
    -0.04029909f, 0.00128754f, 0.00323327f, -0.02755367f, -0.01887819f, 0.03508464f, 0.01506921f, -0.01741146f, 
    -0.00484364f, -0.01707968f, -0.04862868f, 0.01094968f, -0.02818422f, 0.00101385f, -0.02018406f, -0.00186309f, 
    -0.02077743f, 0.03496648f, 0.00531339f, 0.02942183f, -0.02673261f, -0.03029765f, 0.00190145f, -0.00974326f, 
    -0.01257259f, 0.02257708f, 0.02235691f, 0.01491627f, -0.00194792f, 0.03128774f, -0.01968692f, -0.00130277f, 
    -0.03018104f, -0.02258036f, 0.02011260f, -0.02648255f, 0.00868362f, -0.01221034f, -0.02945245f, -0.00502890f, 
    -0.01744601f, 0.03076083f, 0.00470079f, 0.00637656f, -0.02957353f, 0.02678642f, -0.01327921f, 0.00327990f, 
    0.00759925f, -0.00022743f, 0.00534685f, 0.02788201f, 0.02637158f, -0.01493436f, -0.02114002f, 0.02389877f, 
    -0.00528668f, 0.02742407f, 0.02941365f, 0.01910600f, 0.01588071f, -0.01550746f, 0.00207626f, -0.01165564f, 
    0.03297419f, 0.00886029f, 0.00571382f, -0.01265312f, 0.03477315f, 0.00612321f, -0.02135631f, 0.01188863f, 
    -0.03463416f, -0.02042286f, -0.02934331f, 0.02735349f, -0.00189676f, -0.02372258f, 0.01696097f, 0.02685223f, 
    0.02985846f, -0.00610134f, 0.01688299f, 0.03294518f, 0.00871061f, 0.00448312f, 0.02865212f, -0.01133688f, 
    0.01264094f, 0.03180454f, 0.04120193f, -0.03047113f, 0.00188654f, 0.00869816f, -0.02715820f, -0.03849733f, 
    -0.04852312f, 0.01972750f, -0.02107175f, -0.01039850f, -0.00916510f, -0.03267139f, -0.01670863f, 0.03619604f, 
    -0.04289106f, -0.01885165f, 0.01480777f, -0.04657474f, 0.02071382f, -0.00423156f, 0.00625249f, -0.00379829f, 
    0.01230007f, -0.01843391f, -0.00400877f, 0.01457807f, -0.04105009f, -0.00765067f, 0.01848019f, -0.00032443f, 
    0.00905617f, -0.02686888f, -0.02711540f, 0.02767704f, -0.01922212f, -0.04398033f, -0.03180976f, -0.00091933f, 
    -0.03572807f, 0.01827626f, -0.03983609f, -0.03489253f, 0.02594903f, -0.01502904f, -0.00219176f, 0.01326513f, 
    0.01389547f, 0.01256510f, -0.01960350f, -0.01108913f, 0.03337540f, -0.02952148f, -0.03886945f, 0.00327763f, 
    0.02051327f, 0.00408238f, 0.01414488f, -0.01348519f, 0.01492460f, -0.00932510f, -0.02660297f, 0.02204358f, 
    -0.03189221f, -0.02916402f, -0.02653383f, 0.01133096f, 0.00463024f, 0.02749586f, -0.04227076f, -0.02543379f, 
    -0.02577232f, 0.00785724f, 0.01622326f, -0.04513455f, 0.01779157f, 0.00421333f, -0.00872666f, -0.01090281f, 
    0.00604255f, 0.03608078f, -0.03256516f, 0.01882553f, 0.00986481f, 0.01054486f, -0.00917094f, -0.02066449f, 
    -0.03835922f, 0.01793061f, 0.00092564f, -0.04543401f, -0.03942547f, -0.00708432f, 0.03142871f, -0.01781212f, 
    -0.00350663f, 0.01874155f, -0.01313955f, -0.02979436f, -0.01740773f, 0.01418583f, 0.01266146f, 0.01527235f, 
    -0.03549244f, -0.03859121f, 0.00348096f, -0.02746568f, 0.01904810f, 0.01417127f, -0.02732259f, -0.02202352f, 
    -0.03123470f, 0.02512746f, -0.02700505f, -0.02451296f, -0.03391377f, 0.02459459f, 0.01161108f, 0.02999303f, 
    -0.04073152f, -0.02131433f, -0.03905140f, 0.03160736f, -0.00793348f, -0.00475212f, 0.01193841f, -0.00819711f, 
    -0.02909209f, -0.01005229f, 0.01883902f, -0.00648881f, -0.01382682f, -0.00723912f, -0.01389649f, 0.02764554f, 
    0.00999149f, 0.01120661f, -0.02561460f, 0.00541964f, -0.01543682f, -0.04039542f, 0.00106597f, 0.01807765f, 
    0.00607516f, 0.02683290f, -0.03082913f, 0.00998475f, 0.02366358f, -0.03094930f, 0.01904265f, -0.04316885f, 
    0.02811339f, -0.02385021f, -0.03059897f, 0.03127674f, -0.00746519f, -0.01122376f, 0.02346926f, -0.00816515f, 
    -0.00103690f, 0.01257860f, 0.03209398f, -0.02107652f, -0.01819792f, -0.02441643f, -0.03171356f, -0.00893660f, 
    -0.04490264f, -0.00999308f, -0.03018906f, -0.02384630f, -0.03800946f, 0.01414884f, 0.01657671f, -0.03346132f, 
    -0.01285919f, 0.00949029f, -0.03547118f, -0.04129108f, 0.02626858f, -0.03162450f, -0.00114059f, -0.03443630f, 
    -0.04302535f, -0.03257984f, -0.04287411f, 0.01812094f, -0.01908694f, -0.04102324f, -0.00884878f, 0.02511737f, 
    0.00983162f, 0.03235454f, 0.00771111f, -0.04185443f, 0.01906625f, 0.02448960f, 0.00532247f, 0.00270540f, 
    0.03345265f, 0.00263730f, 0.02690066f, 0.02376309f, -0.00956655f, -0.01584621f, -0.00471765f, 0.01490609f, 
    -0.02385428f, 0.01556564f, -0.03134215f, 0.00661176f, -0.02686092f, 0.03195887f, 0.01858147f, -0.03891335f, 
    -0.04295327f, 0.00156714f, 0.03281067f, -0.02223838f, -0.01812137f, 0.02380492f, -0.01451907f, 0.01722638f, 
    -0.01199227f, -0.04113730f, -0.01420770f, -0.00764197f, -0.02394722f, 0.01264718f, 0.01186177f, -0.03420790f, 
    -0.00874528f, -0.03897833f, -0.03649981f, 0.00605835f, -0.01986968f, -0.01092945f, -0.00063416f, -0.03668064f, 
    0.01660473f, 0.00590434f, 0.02959033f, -0.02995413f, -0.03895066f, -0.04180746f, -0.04293095f, -0.00040995f, 
    0.02271829f, -0.03362348f, -0.04024372f, -0.00327024f, -0.01536893f, -0.00527081f, 0.03170204f, 0.02718347f, 
    -0.03509370f, -0.02652427f, -0.03561611f, 0.00486555f, 0.01126852f, -0.03628036f, -0.03050098f, -0.04338669f, 
    -0.00549706f, 0.00718472f, -0.02772944f, -0.03145295f, -0.02312471f, 0.03281761f, -0.00782419f, -0.04036335f, 
    -0.04308802f, -0.00803433f, 0.00268096f, -0.02483826f, -0.03587174f, -0.03845279f, -0.02623978f, 0.01189107f, 
    0.03093903f, -0.00588278f, 0.02504667f, -0.02164346f, 0.01031793f, 0.00047363f, -0.01624515f, -0.01143243f, 
    0.01874115f, -0.04485945f, -0.04494495f, 0.01540429f, -0.03214435f, 0.01888463f, 0.01436993f, -0.02962532f, 
    -0.01301273f, -0.03208038f, -0.01269976f, -0.03649946f, -0.03921613f, 0.01510470f, 0.01353173f, 0.01013190f, 
    0.00535861f, 0.02299865f, 0.03085670f, -0.02173888f, -0.02109763f, 0.01095712f, 0.00600508f, -0.02170240f, 
    -0.01524811f, -0.01876394f, -0.01988652f, -0.02648889f, 0.00194844f, 0.01225557f, -0.00930144f, -0.01580707f, 
    -0.03133785f, 0.00783792f, -0.00905065f, 0.03115378f, -0.00284772f, 0.00141667f, 0.03158075f, 0.03206223f, 
    -0.03780605f, 0.00599392f, 0.00494792f, -0.01026110f, -0.02443401f, 0.00941212f, 0.01705240f, -0.00780102f, 
    0.01468670f, 0.00415027f, 0.01348923f, -0.01786523f, 0.02776442f, -0.03302919f, -0.01282639f, -0.00068229f, 
    0.01832928f, -0.00593922f, 0.01630449f, -0.03395212f, -0.02123392f, -0.04208891f, 0.03188226f, -0.02529664f, 
    0.03035329f, -0.01364241f, -0.00093039f, -0.03468465f, -0.01045633f, -0.00572707f, -0.01903855f, -0.01783938f, 
    -0.01761935f, -0.01327693f, -0.02052244f, -0.01915373f, -0.02589586f, 0.02829184f, 0.00623365f, 0.00053906f, 
    -0.02664347f, -0.02321038f, -0.03037541f, 0.03267207f, 0.02005393f, 0.01852415f, -0.00991331f, 0.00510081f, 
    0.01331902f, 0.03077072f, 0.03567413f, 0.00235744f, -0.02456978f, 0.01311974f, 0.00061793f, -0.03868588f, 
    -0.03680950f, 0.02008590f, 0.02187782f, 0.01777377f, 0.02900139f, -0.02026251f, -0.02786010f, -0.02711697f, 
    -0.04232859f, -0.03869038f, 0.01575162f, -0.00542066f, -0.01088872f, -0.01377543f, -0.01952843f, 0.02975892f, 
    -0.02734874f, -0.03213848f, -0.01307601f, 0.00172145f, 0.02278600f, -0.02097129f, -0.03665448f, 0.03088960f, 
    -0.02288569f, -0.02082319f, -0.03144659f, 0.02562251f, 0.01558402f, -0.03445086f, -0.02893806f, 0.02140504f, 
    -0.04148992f, -0.02951849f, -0.02149139f, 0.01542953f, 0.03181700f, 0.00448192f, 0.02722568f, -0.04053752f, 
    -0.02272518f, -0.02590053f, 0.00261307f, -0.00248606f, -0.00051764f, -0.04010294f, -0.03550960f, -0.03364155f, 
    0.00854516f, 0.01486714f, -0.01463709f, 0.01827077f, -0.02232042f, -0.00096274f, 0.00923114f, -0.00018196f, 
    0.02376255f, -0.00501733f, 0.02484544f, -0.04107090f, 0.03243005f, -0.02811434f, -0.03371205f, 0.01959338f, 
    0.01762294f, -0.01490390f, 0.02469100f, -0.03031443f, -0.01636577f, -0.00055718f, 0.00012423f, -0.00981858f, 
    0.01837758f, 0.00894879f, -0.00880107f, -0.02589536f, -0.04094003f, 0.01609116f, 0.00423893f, 0.01061189f, 
    0.01920199f, -0.04430895f, 0.01941230f, 0.03072042f, 0.03171207f, -0.03584237f, 0.02979083f, -0.00397344f, 
    -0.00247800f, -0.01573145f, -0.02565066f, 0.03324362f, -0.03674484f, -0.02293701f, -0.03153830f, 0.01651240f, 
    -0.02468209f, 0.01358535f, -0.02115542f, 0.00893475f, -0.04065751f, 0.03049842f, -0.03189588f, 0.01234182f, 
    0.00070969f, -0.01766900f, -0.01832956f, -0.00199574f, 0.02904303f, -0.00596494f, -0.01990360f, -0.00449939f, 
    -0.00357821f, -0.02394760f, -0.00740245f, -0.02996545f, 0.00450233f, 0.00044509f, -0.02114005f, 0.02211470f, 
    -0.02305928f, 0.01125339f, 0.00292601f, 0.02392808f, 0.02371683f, -0.00522656f, 0.00294560f, -0.03977036f, 
    0.00864212f, 0.02190990f, 0.00667799f, -0.00137696f, -0.02548922f, -0.01534282f, -0.01738283f, -0.01521958f, 
    0.03211690f, -0.02925306f, 0.03116453f, 0.00567123f, -0.01139291f, -0.04082131f, -0.02186232f, -0.02723128f, 
    -0.02629621f, -0.02199022f, -0.03250626f, -0.02890785f, 0.01171565f, -0.03510546f, 0.01546405f, 0.03173940f, 
    -0.03007253f, 0.01884665f, 0.03261074f, 0.00395922f, -0.00210185f, 0.02666059f, -0.03075210f, -0.03618620f, 
    -0.03685317f, -0.01660655f, 0.00197547f, -0.01914223f, -0.04148219f, 0.00735536f, -0.03475296f, -0.01167867f, 
    0.03334659f, 0.00675239f, 0.02870448f, 0.02334251f, -0.03016183f, 0.02370269f, 0.02121473f, -0.00323181f, 
    -0.01561576f, 0.02065032f, 0.00563031f, 0.02636923f, -0.00151456f, -0.01771780f, 0.01610493f, -0.01499719f, 
    -0.00348143f, -0.00129002f, 0.03312782f, -0.01868638f, -0.01589787f, -0.03013039f, -0.00552116f, -0.02758569f, 
    0.02354674f, 0.01983749f, 0.01241746f, -0.03764261f, -0.01817342f, -0.01384636f, -0.01713438f, -0.00630154f, 
    -0.02064896f, -0.02928279f, 0.01209458f, 0.01192636f, -0.00567746f, -0.04541542f, 0.01161985f, -0.01814784f, 
    0.02514729f, -0.03924095f, 0.00268943f, 0.03214749f, -0.03584415f, 0.02362180f, -0.00750822f, -0.00482889f, 
    -0.03223671f, 0.00259157f, 0.01016182f, 0.02720038f, 0.00954620f, 0.02422363f, 0.00553355f, -0.02981733f, 
    0.03238576f, -0.00391645f, 0.00237323f, 0.01560546f, 0.02973703f, -0.01320147f, 0.00980605f, -0.01549728f, 
    -0.03628428f, 0.00983394f, 0.00592877f, 0.02858356f, 0.01965467f, -0.03989554f, 0.01542096f, 0.01502315f, 
    -0.03773299f, -0.03659027f, -0.00764473f, -0.02346657f, -0.00745175f, -0.03387222f, 0.02479503f, -0.01645968f, 
    0.00017183f, 0.00465447f, -0.04398835f, 0.01523108f, -0.01801268f, -0.01066178f, -0.03245214f, -0.01648849f, 
    -0.04069066f, -0.01262906f, 0.00953185f, -0.00542525f, -0.00285151f, 0.02478679f, 0.00791918f, 0.01597665f, 
    -0.03109436f, 0.01743299f, 0.00644120f, -0.00866128f, 0.00102248f, 0.03720939f, -0.04377147f, -0.00893617f, 
    -0.04213222f, -0.01304731f, 0.03213814f, -0.01255977f, -0.01842079f, -0.02077231f, 0.02588482f, -0.01323002f, 
    0.00277642f, -0.03225879f, 0.02479305f, 0.01641657f, -0.00251256f, -0.02076926f, -0.01696188f, -0.02971211f, 
    -0.01515275f, 0.02970065f, -0.01304533f, 0.03311161f, -0.02682148f, -0.00553839f, -0.03834608f, 0.01789779f, 
    0.02084561f, 0.01651692f, -0.04234870f, -0.02305794f, -0.02185541f, -0.00203531f, -0.00486693f, 0.02218165f, 
    -0.02950360f, 0.00501347f, -0.01851078f, -0.02450889f, -0.00314731f, 0.01579042f, 0.01407306f, -0.02131516f, 
    0.00113039f, -0.00757232f, 0.00467844f, -0.03006478f, -0.00251350f, -0.03141753f, -0.04021102f, -0.01773064f, 
    0.02739209f, 0.02554271f, 0.00887398f, 0.00692878f, -0.03675655f, -0.00378782f, 0.01953606f, 0.00405382f, 
    0.02473381f, -0.00948158f, -0.04125129f, -0.00751887f, 0.03314345f, 0.02182708f, -0.03667752f, 0.00301314f, 
    0.00539885f, -0.03191205f, -0.00993889f, -0.02438386f, 0.03808242f, 0.02552924f, 0.03428526f, 0.00447406f, 
    0.01868341f, -0.03297107f, -0.02783665f, -0.02734426f, -0.02184933f, 0.01349266f, -0.03300368f, -0.00039912f, 
    0.01899870f, 0.00904811f, 0.02594305f, 0.00994897f, 0.02238422f, -0.00150619f, -0.03506152f, -0.02125559f, 
    0.03112718f, -0.00781071f, -0.03731126f, -0.00317070f, -0.00401974f, 0.01799872f, 0.02154117f, -0.01783075f, 
    -0.02551776f, 0.01682224f, 0.01094384f, -0.03159654f, 0.03094392f, -0.01535855f, -0.01724186f, -0.00161380f, 
    -0.00109923f, -0.00577573f, -0.02941403f, 0.02734677f, -0.03648981f, -0.02443240f, 0.03662776f, 0.01099802f, 
    0.03053098f, -0.03251610f, -0.03206105f, -0.01928995f, -0.04248624f, 0.02388462f, -0.02348970f, -0.00665587f, 
    -0.00938111f, 0.02439183f, 0.01376844f, -0.00773894f, -0.02255087f, -0.02151962f, -0.01930413f, 0.02125359f, 
    -0.03359295f, -0.02258402f, 0.01390872f, -0.01578102f, 0.02196964f, -0.03562403f, -0.03556788f, -0.00401861f, 
    -0.00192765f, 0.01314770f, 0.01315451f, -0.03613930f, -0.03577910f, -0.00284571f, 0.02060113f, -0.00421120f, 
    -0.02821588f, -0.02568448f, -0.01644137f, 0.01614433f, -0.00568262f, 0.02182310f, 0.03304937f, -0.03788308f, 
    -0.03331972f, -0.00594535f, -0.00214981f, 0.00134201f, 0.00533639f, -0.01103406f, -0.01261679f, 0.00260401f, 
    -0.00557375f, -0.00572991f, -0.02365775f, -0.02462133f, -0.03456424f, 0.01055468f, 0.01116062f, 0.00485261f, 
    -0.02947203f, -0.01764962f, -0.02422925f, -0.01406838f, -0.03131872f, 0.01701836f, 0.01748503f, -0.01600137f, 
    -0.00528700f, 0.00830822f, 0.03303863f, 0.02789011f, -0.03385010f, -0.02148153f, 0.01585012f, -0.01897601f, 
    0.01763046f, -0.03100076f, -0.00679601f, -0.02586066f, -0.00960734f, 0.02307768f, 0.00819248f, -0.00880403f, 
    0.00619051f, -0.02825095f, -0.01423174f, -0.03382035f, -0.01783291f, 0.01017635f, -0.02468636f, -0.04209916f, 
    -0.01473320f, -0.02737712f, 0.03302529f, -0.02142787f, -0.03271392f, 0.01434800f, -0.02644492f, -0.02868750f, 
    0.01028240f, -0.02823103f, 0.01239221f, -0.04409679f, 0.00643608f, -0.03175145f, 0.01084215f, 0.00930000f, 
    0.03382874f, 0.00434644f, -0.01601571f, -0.00040763f, 0.00398865f, 0.02613762f, -0.01771242f, -0.03350987f, 
    -0.02370365f, -0.01367503f, 0.02880507f, -0.00294228f, 0.02411775f, -0.03056861f, -0.02920177f, 0.02464903f, 
    -0.02118238f, 0.01048431f, -0.02785789f, 0.00451926f, -0.02997688f, 0.00777543f, -0.04370558f, 0.00273442f, 
    0.03135989f, 0.03429737f, -0.01473518f, -0.03275061f, -0.02797711f, -0.03443606f, 0.02250073f, -0.03620379f, 
    0.03166259f, -0.03163379f, -0.03279904f, 0.01719876f, -0.02609942f, -0.00771515f, 0.02469147f, -0.01579661f, 
    -0.01059153f, -0.00595740f, -0.01552232f, -0.00227201f, -0.00824086f, 0.00528655f, -0.00482030f, -0.01460766f, 
    -0.02005835f, 0.00900977f, -0.00163988f, -0.00084768f, 0.00857916f, 0.03422130f, -0.02790899f, 0.01844116f, 
    -0.02164347f, -0.02826449f, 0.02044117f, -0.00996843f, -0.03238418f, 0.02621932f, -0.00732915f, -0.01994986f, 
    -0.01524392f, -0.00182527f, -0.01360822f, -0.00287155f, 0.00374001f, -0.02084381f, -0.02771825f, -0.03484354f, 
    -0.02778339f, 0.01298901f, 0.02846679f, 0.02842052f, 0.01803986f, -0.00943378f, 0.02981243f, 0.02281006f, 
    -0.02691131f, 0.02173859f, -0.04087247f, -0.00322694f, -0.02347633f, -0.02883428f, 0.02206510f, -0.00568075f, 
    -0.00425407f, 0.01107664f, -0.01410077f, -0.01481780f, -0.02895882f, 0.03613526f, -0.01879448f, 0.02469765f, 
    -0.03154357f, 0.02400291f, 0.00389344f, -0.03278200f, -0.02999201f, 0.03278659f, -0.03131447f, -0.03228069f, 
    0.02845801f, -0.03371122f, -0.00526049f, -0.02945746f, -0.04312652f, 0.02285101f, 0.02189586f, 0.00681421f, 
    0.00129200f, 0.01096726f, 0.00854950f, -0.01257152f, 0.03002399f, -0.03443770f, -0.02926543f, 0.00934952f, 
    -0.02877975f, 0.03426770f, -0.02256710f, 0.02809186f, 0.01331621f, -0.04394692f, 0.00359848f, -0.02878231f, 
    0.00202378f, -0.03240626f, 0.01292045f, -0.04145280f, -0.01828091f, 0.00892123f, -0.04178267f, 0.00347025f, 
    -0.02722496f, 0.00520382f, 0.01250408f, -0.00812007f, -0.02488755f, -0.00744548f, 0.03298800f, 0.02306811f, 
    -0.02590027f, -0.04121049f, -0.03363661f, 0.00791152f, -0.02759502f, -0.02837775f, -0.01793609f, -0.02333738f, 
    0.01983706f, -0.02096672f, -0.01770926f, 0.02710162f, 0.02163702f, 0.03039305f, -0.03242585f, 0.02805294f, 
    -0.03062480f, -0.03912245f, 0.00836790f, -0.03408288f, -0.00066042f, 0.02420245f, -0.03642520f, 0.01132025f, 
    -0.03982797f, -0.02287810f, -0.01331821f, 0.03885246f, -0.03035983f, 0.00261586f, -0.01001573f, 0.00083136f, 
    0.01573431f, 0.00366552f, -0.02411052f, 0.02800089f, -0.02971615f, 0.02625902f, -0.00243638f, 0.01315535f, 
    -0.03441509f, -0.01632900f, 0.02172484f, -0.02862392f, -0.00243012f, 0.00853523f, -0.03714487f, -0.00306757f, 
    -0.02926213f, -0.01890870f, 0.00083386f, 0.00312160f, 0.00425415f, 0.02688479f, -0.04058246f, 0.02487741f, 
    0.03358928f, -0.02952056f, 0.02681868f, 0.00119607f, -0.01342812f, -0.04459067f, 0.01106427f, -0.03120657f, 
    -0.02076955f, -0.04047761f, -0.01354392f, 0.00143415f, 0.01143518f, -0.00632262f, -0.01751910f, 0.00874226f, 
    -0.03075866f, 0.01360329f, -0.02699842f, 0.03212963f, 0.03042356f, -0.00505306f, -0.03672128f, 0.03318326f, 
    0.02160095f, -0.00011647f, -0.00861710f, -0.00278610f, -0.04078405f, 0.01066344f, 0.03404867f, -0.01852173f, 
    0.00725455f, -0.03734054f, -0.01769444f, -0.02421062f, -0.02437202f, -0.01111275f, -0.03121238f, -0.00467542f, 
    0.02462560f, -0.02507884f, 0.02311854f, 0.02819360f, -0.03451420f, -0.01568567f, -0.00351401f, -0.01507049f, 
    -0.02575604f, 0.03359137f, 0.02341726f, -0.03491765f, -0.00010030f, -0.01776929f, -0.00198562f, -0.02609227f, 
    -0.03596986f, 0.00687571f, -0.02428742f, -0.03751157f, -0.01195077f, -0.01042873f, 0.00290147f, 0.03060748f, 
    0.02465677f, -0.02566079f, 0.02565019f, -0.00897671f, 0.02976577f, 0.00798928f, -0.02409414f, 0.01236798f, 
    -0.03489523f, 0.01094281f, -0.04354628f, -0.04041800f, -0.02272763f, 0.01756905f, -0.02609035f, -0.02501366f, 
    0.01013267f, -0.03050924f, -0.02358948f, 0.03430623f, -0.00353505f, -0.02915551f, 0.00146691f, -0.02436041f, 
    0.03140747f, 0.01744602f, -0.02093497f, 0.01632810f, -0.03691332f, -0.02227929f, 0.02959615f, -0.03687476f, 
    -0.01188850f, 0.00699434f, 0.00410855f, 0.00575625f, 0.00120947f, -0.03182491f, -0.02652130f, 0.02587480f, 
    -0.01515194f, 0.03093927f, -0.00861665f, 0.03623460f, -0.01120023f, 0.02235813f, 0.01501548f, -0.02090170f, 
    -0.02744257f, -0.00680341f, -0.01629254f, -0.04389073f, -0.01076996f, 0.01449766f, -0.04182206f, -0.00850955f, 
    -0.04311436f, -0.00571379f, -0.01946499f, 0.03044843f, -0.01198707f, -0.01896152f, 0.01459383f, -0.01924754f, 
    0.02193138f, -0.03300817f, -0.02945348f, -0.03579309f, 0.01499161f, 0.01585918f, -0.00220366f, -0.01540840f, 
    0.00651878f, -0.03545198f, 0.00428278f, 0.00104032f, -0.00413248f, 0.01779237f, 0.00222433f, -0.03152984f, 
    0.03275173f, -0.04242221f, -0.02341133f, -0.00451989f, -0.02630475f, -0.03602376f, -0.00378005f, -0.01162621f, 
    -0.01445574f, -0.03072696f, 0.01355572f, -0.03341253f, 0.02220764f, -0.01444659f, -0.00016054f, 0.00379228f, 
    -0.00953255f, 0.03006352f, -0.02352578f, 0.03193217f, 0.02767281f, 0.00212825f, 0.01664810f, 0.00383895f, 
    -0.02295252f, -0.03492550f, 0.02931802f, -0.03435495f, 0.00436786f, -0.01413116f, -0.01056663f, -0.03921406f, 
    -0.01805741f, 0.00939367f, -0.00144340f, 0.00358569f, -0.00016917f, 0.00263927f, 0.02939106f, 0.01484448f, 
    -0.03005429f, 0.00299869f, 0.00320211f, 0.01020656f, 0.02551371f, -0.00577155f, -0.01829299f, 0.00365510f, 
    0.02995650f, -0.03608688f, 0.01515570f, -0.01165382f, -0.00338128f, -0.01680151f, 0.00311544f, -0.01334938f, 
    -0.01719593f, -0.02766140f, -0.04047523f, 0.03137563f, -0.03385319f, -0.00542585f, -0.03307775f, -0.00061183f, 
    -0.03467593f, -0.04204029f, -0.04185786f, 0.02829069f, 0.00680763f, -0.03568961f, -0.01171766f, -0.02937921f, 
    -0.04328914f, 0.01995042f, -0.02422754f, 0.00202130f, -0.01382860f, -0.04468731f, -0.02288668f, 0.01433004f, 
    0.01529038f, 0.01357571f, 0.00830151f, 0.01811741f, 0.01064752f, 0.01516764f, -0.01182524f, 0.00806351f, 
    -0.03978131f, -0.03669501f, -0.03710536f, 0.00152013f, -0.03825380f, -0.00768314f, 0.00902084f, 0.01265390f, 
    0.03796165f, 0.02644280f, 0.03231978f, 0.01417101f, 0.03273965f, 0.00867093f, 0.02283581f, -0.02972146f, 
    0.03452707f, -0.03564575f, 0.00212413f, 0.00808943f, -0.01309402f, 0.03783532f, 0.02062682f, 0.02846818f, 
    0.01743528f, -0.03941287f, 0.00142622f, 0.01922483f, -0.00474127f, -0.02621089f, 0.00544614f, -0.00309073f, 
    -0.02478418f, -0.00917226f, 0.00181164f, 0.01898927f, 0.01550124f, 0.01329033f, 0.01980380f, 0.03063140f, 
    0.02007498f, 0.00862837f, 0.02340740f, 0.03308300f, 0.02811066f, -0.03413338f, -0.03498993f, 0.01088111f, 
    0.00179997f, -0.00538042f, -0.03615309f, -0.02189866f, 0.02777685f, -0.03633694f, 0.02019139f, 0.03052624f, 
    0.01541368f, 0.02725672f, 0.02888247f, -0.00510119f, -0.02751959f, -0.02832003f, -0.02430947f, 0.01515616f, 
    0.02732059f, 0.02625750f, -0.00833322f, -0.03413139f, -0.02512139f, 0.02241039f, -0.03700398f, -0.04473208f, 
    0.03628990f, -0.03544467f, -0.02128134f, 0.00629802f, -0.01307835f, -0.03559116f, -0.00283143f, 0.02266400f, 
    -0.03198649f, -0.01640741f, 0.02330547f, 0.00061885f, -0.03009086f, -0.03244688f, -0.03373700f, 0.02810848f, 
    -0.03111811f, -0.00625012f, 0.01253139f, 0.01737903f, -0.02895649f, -0.01207568f, -0.01296221f, 0.02213680f, 
    0.00548663f, -0.01731130f, 0.00512070f, -0.01417019f, -0.02233011f, -0.04193271f, 0.02733740f, -0.03796351f, 
    0.01474301f, -0.01801342f, -0.03094745f, -0.02723079f, -0.01403753f, 0.00496192f, -0.00027573f, 0.02581570f, 
    0.03884441f, 0.02813833f, -0.01145535f, 0.00321645f, -0.00581024f, -0.03077515f, -0.01829052f, -0.01480557f, 
    0.02716517f, -0.03509067f, -0.01105660f, -0.01343288f, 0.03778583f, 0.02967414f, 0.00100814f, -0.01250150f, 
    0.00246774f, -0.00576044f, -0.04346257f, -0.03324560f, -0.03635271f, 0.02575032f, -0.04719037f, -0.00769737f, 
    -0.02988536f, -0.01794479f, -0.01517440f, -0.00288178f, -0.01497280f, 0.03102954f, 0.02696211f, 0.02776178f, 
    0.00716286f, -0.03028656f, -0.01487250f, -0.03926028f, 0.02666132f, -0.01610456f, -0.02413047f, 0.00137835f, 
    -0.03191220f, -0.03189865f, 0.02603296f, -0.03596674f, -0.02536950f, 0.01609595f, 0.00944940f, -0.01924224f, 
    0.03236573f, 0.00178085f, -0.01754043f, -0.02516541f, -0.01898194f, -0.04264382f, -0.04118872f, 0.03108579f, 
    -0.02552734f, -0.01698495f, -0.02054329f, -0.03518193f, 0.01655313f, -0.00995489f, 0.01507065f, 0.03217378f, 
    -0.01377041f, -0.03735678f, -0.03805770f, 0.00126620f, 0.01262469f, -0.00848556f, 0.02652981f, 0.02740211f, 
    -0.00868075f, -0.02367962f, 0.01846728f, -0.02517844f, -0.00983641f, -0.02135473f, -0.02745412f, -0.03973676f, 
    0.02016185f, -0.00807233f, -0.03341135f, 0.01736754f, -0.04263143f, 0.00382832f, -0.03444355f, -0.00324820f, 
    -0.00025373f, -0.01810155f, 0.01620210f, 0.01584104f, 0.02304740f, 0.00671407f, 0.03193585f, 0.03148312f, 
    -0.00452074f, -0.04228195f, -0.03569353f, -0.01358084f, -0.02251848f, -0.03327085f, -0.00466387f, 0.00715892f, 
    -0.01888528f, 0.02822478f, -0.00961825f, 0.01010839f, 0.02293644f, 0.02225696f, -0.00901197f, -0.01260624f, 
    -0.04462930f, 0.00609678f, 0.01890671f, 0.02701422f, -0.02301611f, -0.03853881f, 0.01952831f, 0.01520105f, 
    0.03465125f, 0.03654700f, 0.03731073f, 0.00448051f, 0.01313567f, -0.01399506f, 0.00979604f, 0.02660275f, 
    0.03684062f, -0.03315616f, -0.01663799f, 0.00597578f, -0.03668151f, -0.03377347f, -0.03355652f, -0.01677859f, 
    0.03081732f, -0.02990262f, -0.02673960f, -0.01198660f, 0.02992489f, 0.01986111f, -0.03486787f, -0.00563705f, 
    -0.01443455f, -0.02627395f, 0.01058235f, 0.02223880f, 0.01790668f, 0.02388825f, -0.02508770f, 0.02112212f, 
    0.00500906f, -0.03955467f, -0.00772299f, -0.03135425f, -0.01255504f, 0.02802439f, -0.00312161f, -0.03893721f, 
    -0.00841299f, -0.00790346f, 0.02778287f, 0.00908494f, -0.01667842f, -0.02376867f, 0.02016320f, 0.02077444f, 
    0.03182356f, -0.03078660f, -0.03321477f, -0.04170513f, 0.00358365f, -0.02346435f, 0.02142588f, 0.01305024f, 
    -0.00770471f, -0.01960297f, -0.03079216f, 0.00128934f, -0.00681284f, 0.03775850f, 0.01330419f, -0.01445347f, 
    -0.02800749f, 0.02805122f, -0.01039590f, 0.00320048f, -0.03580650f, 0.00125023f, -0.04744368f, -0.04191895f, 
    0.03100602f, 0.03691618f, 0.03291324f, -0.01733935f, -0.00431757f, -0.00840776f, -0.00784466f, -0.02536307f, 
    0.00734452f, -0.02372293f, -0.03344005f, 0.01180620f, -0.02562784f, 0.03561785f, 0.03536835f, 0.00985505f, 
    -0.02998662f, -0.01694781f, 0.00861004f, -0.01445685f, -0.01013706f, -0.00862899f, -0.02740003f, 0.02952265f, 
    -0.03432801f, 0.01087106f, -0.03184390f, -0.00055078f, 0.01170305f, -0.00014330f, 0.00819405f, 0.01226149f, 
    0.02106990f, 0.00664800f, 0.02764461f, -0.00110035f, 0.01381476f, -0.00285717f, 0.00698146f, 0.02052368f, 
    -0.00955948f, 0.02749389f, -0.03071830f, 0.02016346f, 0.02589722f, -0.00140045f, -0.02826191f, 0.00080198f, 
    -0.03314773f, -0.04121985f, 0.03366306f, -0.02994609f, -0.03672395f, -0.02869131f, -0.03157675f, 0.03353414f, 
    -0.02348686f, 0.02498359f, 0.02657657f, 0.00142967f, 0.00419559f, 0.03371056f, -0.00376484f, -0.00175316f, 
    -0.01351154f, 0.02035537f, -0.03351776f, 0.00155112f, -0.00489082f, -0.00734720f, 0.00067700f, -0.02898056f, 
    -0.03418564f, -0.00089106f, 0.03291308f, -0.04243882f, 0.03148316f, -0.03670104f, -0.01353986f, -0.04321112f, 
    -0.02084982f, 0.02006088f, 0.01634941f, -0.01704705f, -0.01528759f, 0.02281036f, 0.03399424f, -0.02659166f, 
    -0.03235835f, 0.01239044f, -0.00684821f, -0.04607222f, -0.03803923f, -0.01760862f, 0.02429600f, -0.03076858f, 
    0.00195245f, -0.01928150f, -0.02624265f, 0.02742163f, 0.02708310f, 0.00980907f, 0.00756367f, -0.01757366f, 
    -0.04244061f, 0.00534711f, -0.00804972f, 0.00467995f, 0.02152310f, 0.01702889f, 0.02675438f, -0.00582077f, 
    0.01394477f, 0.03065320f, -0.03157675f, -0.02231482f, 0.02729526f, 0.02934006f, 0.01188011f, 0.01949470f, 
    -0.02612069f, -0.02914183f, -0.03053625f, -0.00015220f, 0.00568539f, 0.00086548f, 0.00997518f, -0.02563723f, 
    -0.04564397f, -0.03068416f, -0.02658996f, -0.01426988f, -0.03959094f, -0.01693846f, -0.00080956f, 0.00073364f, 
    -0.00187975f, -0.04085666f, -0.01119681f, -0.00378632f, -0.00011182f, -0.00848844f, -0.00190582f, 0.01925920f, 
    0.01928017f, 0.00480390f, 0.02511500f, -0.02255732f, 0.01644654f, -0.00586003f, 0.02672152f, 0.01968247f, 
    0.00759955f, -0.03068776f, -0.02114933f, -0.01606584f, -0.00369260f, 0.02720716f, 0.00070510f, -0.04022596f, 
    -0.00568019f, -0.01647298f, 0.01871704f, 0.01735384f, 0.00623542f, 0.03167108f, 0.02295769f, -0.01583822f, 
    -0.00203024f, -0.03127782f, 0.01371638f, 0.00868684f, 0.02651151f, -0.04092384f, 0.00494523f, 0.02771824f, 
    0.00619032f, 0.00733607f, 0.00457049f, 0.01931932f, 0.02197068f, 0.03565145f, 0.02639590f, 0.03105647f, 
    -0.01922330f, -0.03126590f, -0.01990849f, -0.00147854f, -0.03595392f, -0.02452890f, -0.02501763f, 0.01271449f, 
    0.02587479f, 0.00966351f, -0.03585579f, -0.02385679f, -0.04367822f, -0.01089240f, -0.02386557f, 0.00466944f, 
    0.03040582f, 0.01621683f, 0.01236228f, 0.00466583f, -0.00095384f, 0.01133509f, 0.01018176f, 0.00912385f, 
    -0.02687622f, 0.02519447f, 0.01460183f, -0.01926682f, -0.00904773f, 0.01877487f, -0.03020450f, -0.01075600f, 
    -0.03847392f, 0.01854533f, 0.01053241f, 0.03047512f, -0.02211451f, -0.00011726f, -0.00705188f, 0.00383107f, 
    -0.02929535f, -0.03449530f, -0.00594435f, 0.03106065f, -0.04017119f, 0.03859977f, -0.03497804f, -0.00598258f, 
    -0.00156687f, 0.03159042f, -0.00734288f, -0.00472867f, -0.03926804f, -0.01152850f, 0.00392553f, 0.00542757f, 
    0.00092274f, 0.02860125f, 0.01750589f, 0.02805220f, -0.01688255f, 0.01975141f, -0.02804407f, -0.00497609f, 
    0.02737384f, -0.00098660f, -0.00640694f, 0.01572165f, 0.00969081f, 0.01730745f, -0.00578447f, -0.03121490f, 
    -0.04901078f, -0.01178126f, 0.00999921f, -0.04462381f, -0.00110897f, 0.00970080f, -0.01518039f, 0.01100504f, 
    -0.03381943f, 0.01105738f, 0.02279100f, 0.02591071f, 0.01425582f, 0.02122814f, -0.02129871f, 0.00363938f, 
    -0.00418323f, 0.01798749f, 0.02190181f, -0.01468805f, -0.02577577f, 0.03056135f, -0.03636149f, -0.02362203f, 
    0.00326569f, 0.01041191f, 0.02399654f, 0.00532739f, 0.02778999f, 0.00832579f, -0.03380099f, 0.02493194f, 
    -0.00794446f, -0.00868869f, -0.02016262f, -0.00016361f, 0.02449512f, -0.01648856f, 0.00908676f, 0.00627879f, 
    0.01297324f, -0.01889298f, 0.01307776f, 0.02023968f, 0.01156032f, 0.00280361f, 0.01523185f, 0.00949339f, 
    0.01279958f, -0.01402827f, 0.01704260f, 0.02324637f, -0.01189638f, 0.00882923f, -0.00842359f, -0.01941248f, 
    0.00497249f, 0.00076315f, -0.01917961f, 0.01255927f, -0.00782203f, -0.00275294f, 0.04597261f, -0.00933585f, 
    0.00726207f, 0.01371861f, -0.02533598f, 0.03487153f, -0.02277992f, -0.01748323f, 0.00893513f, -0.01036859f, 
    -0.02478622f, -0.00157269f, -0.02677686f, -0.03635662f, -0.00430482f, -0.03774057f, 0.01379049f, -0.03842786f, 
    0.03334789f, -0.02351655f, 0.01325763f, -0.02426999f, 0.02647494f, -0.01841911f, -0.01672324f, -0.03964824f, 
    0.00149799f, -0.04234383f, -0.03874395f, -0.03986087f, 0.03579776f, 0.02200460f, -0.02076771f, 0.01097551f, 
    -0.01670567f, -0.00801280f, 0.01541346f, 0.01223634f, -0.04436179f, -0.01107825f, -0.02325355f, -0.02691729f, 
    -0.00408335f, -0.01787669f, 0.02853983f, -0.02485625f, 0.02062918f, 0.01435383f, 0.02509760f, -0.03134171f, 
    -0.03704093f, -0.01174980f, 0.00853559f, -0.04340867f, -0.02930571f, 0.01926746f, -0.01477710f, 0.00891635f, 
    -0.03712464f, -0.00654337f, 0.02694250f, 0.00973150f, -0.03943163f, 0.00749133f, 0.00501601f, -0.00189873f, 
    -0.03662936f, -0.03801767f, 0.02446655f, -0.03830988f, 0.02188470f, -0.01223800f, 0.00384893f, -0.03882081f, 
    0.00516659f, 0.01207381f, -0.00756446f, -0.04424496f, -0.03241550f, -0.04501804f, 0.00340828f, -0.01630601f, 
    0.00020537f, -0.04246191f, -0.02321768f, 0.00019684f, 0.00001573f, -0.00820674f, 0.00453574f, -0.02066210f, 
    0.01941150f, -0.00860570f, -0.01350698f, -0.00047246f, -0.00077080f, 0.00747452f, 0.00910147f, -0.00218723f, 
    0.00657055f, -0.03025310f, -0.00530963f, -0.02852845f, -0.00428461f, 0.00770119f, 0.00703936f, 0.00965019f, 
    -0.01301132f, -0.00118117f, 0.01238477f, -0.03160039f, -0.02888227f, 0.01151603f, 0.00500223f, -0.03784164f, 
    -0.01085455f, -0.00138443f, -0.02748479f, -0.03175970f, 0.00682140f, 0.02119656f, 0.01722070f, -0.03508946f, 
    0.01405353f, -0.02572004f, -0.02790808f, 0.00411857f, 0.02874810f, -0.04937981f, 0.02373441f, 0.00992917f, 
    0.02032469f, -0.02643329f, 0.01293624f, 0.01234541f, 0.01982300f, 0.00725020f, 0.01095597f, -0.04410635f, 
    -0.02040204f, -0.03522405f, 0.03026352f, -0.01754021f, -0.02245405f, 0.00390958f, -0.01011101f, -0.00852098f, 
    0.01323214f, -0.00642108f, -0.01530458f, -0.00061471f, 0.03289348f, -0.01201109f, -0.01464896f, 0.02496980f, 
    -0.01443655f, -0.00475620f, 0.02224928f, 0.03288648f, 0.02779207f, 0.03158849f, -0.00196456f, 0.02803672f, 
    -0.00783275f, -0.03973159f, 0.02347190f, 0.01608966f, -0.03341845f, -0.00041074f, -0.03567019f, 0.01324200f, 
    0.03001450f, -0.04375150f, -0.03786928f, 0.03233179f, -0.00147103f, 0.03047068f, -0.03782164f, -0.00976851f, 
    0.01507010f, -0.00083797f, -0.00959845f, -0.01554941f, 0.02133624f, 0.00298886f, -0.03933925f, -0.02681765f, 
    0.02987065f, -0.01743847f, -0.00815371f, -0.01438904f, -0.01577951f, -0.01616962f, 0.03443564f, -0.03393278f, 
    0.01956138f, -0.02258893f, -0.03562469f, 0.02942467f, -0.02894177f, -0.00461291f, 0.02009725f, 0.00209435f, 
    0.00780838f, -0.01835499f, 0.03435734f, 0.02850101f, 0.02705158f, -0.03813422f, -0.03820016f, 0.01064290f, 
    -0.03667744f, -0.00516187f, -0.04068429f, 0.00721791f, -0.00774849f, 0.02221967f, -0.04505481f, 0.02594635f, 
    -0.03814541f, 0.00641092f, -0.01986824f, 0.02908753f, -0.02724445f, 0.03161604f, 0.01366660f, -0.03035268f, 
    0.01337761f, -0.02473371f, -0.03921948f, -0.04330695f, -0.02871820f, -0.02128032f, -0.03862593f, -0.02641686f, 
    -0.00339057f, -0.02101599f, 0.00712902f, 0.00194770f, -0.04702610f, 0.03103857f, 0.03170424f, -0.01154442f, 
    0.00654630f, 0.00140708f, -0.04046074f, -0.03708987f, -0.00564919f, -0.01577182f, 0.01871871f, -0.02851687f, 
    0.02307023f, -0.01410259f, 0.00662310f, -0.02630368f, -0.04249301f, -0.01143372f, -0.02138001f, 0.00720395f, 
    0.00056303f, 0.03301132f, 0.01552502f, 0.01223045f, -0.01946316f, 0.01047559f, -0.01486288f, -0.00383641f, 
    -0.03478971f, 0.01094677f, -0.04476387f, -0.02667039f, 0.02868783f, 0.01807540f, -0.01277993f, -0.04115657f, 
    0.00839740f, -0.02869795f, -0.02741486f, 0.02021324f, -0.01008441f, 0.00194693f, 0.01591036f, -0.00491598f, 
    -0.03128755f, 0.00998616f, -0.02776651f, 0.01355753f, 0.01037018f, 0.03185829f, -0.00819324f, 0.01274715f, 
    0.01074392f, 0.02147135f, -0.04016912f, 0.02755777f, 0.00819293f, -0.03833955f, -0.03993994f, -0.03659995f, 
    -0.02383525f, -0.02125820f, -0.03642752f, -0.03825667f, 0.02043775f, -0.02261615f, -0.04362814f, -0.03905423f, 
    -0.01606957f, -0.00376291f, 0.00401269f, -0.00092847f, -0.03698039f, 0.01384238f, -0.03962029f, -0.01329983f, 
    0.00153116f, 0.02468079f, -0.00517598f, -0.01616888f, 0.02560891f, 0.03242616f, -0.01375382f, -0.03954037f, 
    0.01825318f, -0.01076690f, 0.02904732f, 0.03008010f, 0.02342514f, -0.04558891f, 0.01859277f, -0.02559324f, 
    0.02031939f, 0.01413526f, -0.01900092f, 0.01524385f, -0.01557350f, -0.01128703f, -0.02987546f, 0.01382981f, 
    0.01550072f, 0.02500041f, -0.01159058f, 0.02397744f, -0.02988965f, -0.04393037f, -0.03717763f, 0.01869719f, 
    0.01966768f, -0.01831021f, -0.01808016f, -0.03107289f, 0.03238497f, -0.03891170f, -0.04963335f, 0.00058249f, 
    -0.03558735f, 0.02835615f, 0.00921649f, -0.02312608f, -0.00570097f, -0.02411860f, -0.04288346f, -0.02467819f, 
    0.02887547f, -0.02948735f, -0.02847675f, -0.00972242f, 0.01672313f, -0.03589006f, -0.04285370f, -0.03860015f, 
    0.01455051f, -0.04103985f, 0.03055039f, 0.01827396f, -0.01138095f, 0.02373533f, -0.01114377f, -0.02911520f, 
    0.02302830f, -0.01959525f, 0.00234407f, -0.03855395f, -0.01706033f, -0.02983137f, 0.02140004f, 0.02138710f, 
    -0.00795467f, 0.00863128f, 0.02065395f, -0.01122625f, -0.00554188f, -0.02593129f, -0.03054856f, -0.01572652f, 
    0.00664810f, -0.01742826f, 0.00348387f, -0.01098825f, -0.00035464f, 0.00492460f, -0.02363788f, -0.02301625f, 
    -0.00758988f, -0.00047903f, -0.03261566f, 0.00161804f, -0.03698344f, -0.00203342f, 0.00279992f, 0.02836421f, 
    -0.04623592f, -0.01822768f, 0.01246679f, 0.02108280f, -0.01763377f, 0.02706338f, 0.00886706f, 0.03062248f, 
    0.00533391f, -0.02680700f, 0.01381432f, 0.01924792f, -0.02688092f, 0.00358869f, -0.00437159f, 0.02957382f, 
    -0.03981876f, 0.01968938f, -0.03745229f, 0.00620332f, -0.04444357f, -0.03435688f, -0.04322584f, -0.00951110f, 
    0.00552647f, -0.04353351f, -0.04235794f, -0.04335146f, -0.03641418f, 0.00745817f, -0.01462031f, 0.02640462f, 
    -0.03143603f, 0.00939682f, 0.00478127f, -0.01574249f, -0.03632903f, 0.00811815f, -0.02804016f, -0.04207940f, 
    0.02504046f, -0.00531924f, -0.02720597f, 0.00497596f, 0.02130188f, 0.02959066f, 0.03050939f, 0.02056198f, 
    -0.03268494f, 0.01182771f, -0.01481363f, -0.02062625f, 0.00656790f, 0.01292986f, -0.04358429f, 0.01032783f, 
    -0.01220521f, -0.01952984f, -0.00500174f, -0.04628935f, -0.03379115f, 0.00796027f, -0.03255054f, 0.02582878f, 
    0.01835741f, -0.04322539f, -0.02950027f, -0.00976582f, 0.01294533f, -0.01970974f, 0.00918594f, -0.01270976f, 
    -0.02660918f, -0.03093759f, -0.04484244f, 0.01165919f, 0.00984975f, -0.04709211f, -0.00387379f, -0.03707789f, 
    -0.01899448f, -0.01647261f, -0.01231226f, -0.02929465f, -0.00128236f, 0.00385535f, -0.02462645f, -0.01996347f, 
    -0.03803143f, -0.04272041f, -0.00491184f, -0.00254906f, 0.03428955f, 0.02837136f, -0.00009199f, 0.03199620f, 
    0.02605104f, -0.03673314f, -0.00289494f, -0.03957837f, -0.01649803f, -0.00169108f, 0.00215387f, -0.03726087f, 
    0.02781902f, -0.01242036f, -0.00100385f, 0.00294925f, 0.02199270f, 0.02861691f, -0.04241702f, -0.01001257f, 
    -0.03790101f, -0.03620299f, -0.03571437f, 0.03246252f, 0.00725363f, 0.02247634f, -0.01246467f, -0.02810814f, 
    0.03325026f, -0.00152258f, -0.02585972f, -0.00001692f, -0.01792053f, -0.00324668f, 0.01868202f, 0.03140433f, 
    0.02886659f, 0.01107153f, 0.00005661f, -0.02182674f, 0.02529075f, 0.01260459f, 0.02343230f, 0.01668340f, 
    0.02053290f, 0.00498003f, -0.01263648f, -0.02537159f, -0.00501507f, -0.01198269f, 0.01635325f, -0.00373198f, 
    0.02422422f, -0.01388266f, -0.01014662f, 0.01325469f, -0.03111056f, -0.02868810f, 0.03188237f, -0.02196541f, 
    -0.02597938f, -0.00909683f, 0.00859759f, -0.02286750f, -0.03858011f, -0.01390306f, 0.00821420f, -0.04170894f, 
    -0.01441154f, -0.00295452f, 0.00236840f, -0.00509449f, -0.03834580f, -0.01206582f, -0.03053583f, 0.00965329f, 
    0.01285260f, 0.04211277f, 0.03483881f, -0.03951754f, 0.03105810f, 0.02286331f, -0.00599741f, 0.03391504f, 
    0.01642809f, 0.01151748f, 0.02110519f, -0.00696387f, -0.02550757f, 0.00366123f, -0.04309128f, -0.01185128f, 
    0.01913363f, -0.01551090f, -0.04327007f, -0.00766594f, 0.02916579f, 0.00003528f, 0.00876445f, 0.01938278f, 
    0.02423706f, -0.03372123f, -0.01449632f, -0.01456831f, -0.03994605f, -0.00881129f, 0.01969536f, 0.00558707f, 
    0.01232566f, 0.00692148f, -0.00390736f, 0.01386517f, -0.02380725f, -0.04272544f, -0.00776489f, -0.00149305f, 
    -0.04317603f, -0.04039028f, 0.03374784f, -0.01436826f, 0.02528855f, -0.00258344f, -0.00639664f, 0.00854815f, 
    -0.01129728f, 0.00324129f, -0.00342306f, 0.02225228f, -0.01020465f, -0.01720525f, -0.02079961f, -0.01040681f, 
    -0.00238781f, 0.02524546f, 0.02609554f, -0.02516286f, 0.03631159f, -0.00646907f, -0.04495844f, 0.01677408f, 
    -0.02998973f, -0.00212360f, 0.00427149f, -0.01610404f, -0.01918726f, 0.00868033f, -0.01217741f, -0.02388670f, 
    -0.02656700f, 0.01994115f, 0.00599073f, -0.00513748f, -0.02528193f, -0.01671447f, -0.01618768f, -0.02385449f, 
    -0.51043248f, -0.06331706f, 0.08387396f, 0.00431870f, 0.12037586f, 0.00835179f, -0.00145712f, -0.04322051f, 
    -0.11385751f, -0.01611285f, -0.05705896f, 0.01439444f, -0.06863207f, 0.15264672f, -0.03627685f, 0.04318675f, 
    0.07574808f, 0.05876952f, -0.07298730f, -0.07546376f, 0.36281413f, 0.03413949f, 0.07180060f, 0.21110368f, 
    0.05298567f, -0.01876016f, 0.07052141f, -0.09228178f, -0.08107201f, 0.02358708f, 0.10538701f, -0.08195421f, 
    -0.01114838f, 0.05448062f, 0.06112128f, -0.07424846f, -0.04239891f, 0.11019839f, 0.13682403f, -0.00295151f, 
    -0.10599148f, 0.10914838f, 0.32045096f, 0.22505242f, -0.03551842f, 0.13123375f, 0.11825935f, 0.06973881f, 
    -0.10217307f, -0.01809114f, -0.07550509f, -0.10641635f, 0.01346925f, 0.08461269f, 0.13078959f, -0.09962089f, 
    -0.03649632f, 0.03991555f, 0.04266372f, 0.12328452f, -0.27274278f, -0.13511640f, -0.10120652f, -0.06331366f, 
    -0.00088956f, 0.06494947f, -0.00253238f, -0.00857493f, -0.00889986f, 0.16304198f, 0.00610108f, -0.28233778f, 
    0.09307636f, 0.07487768f, -0.02126121f, 0.09966782f, -0.03599625f, -0.00905101f, -0.12845865f, 0.03069429f, 
    -0.30035099f, -0.06886529f, -0.33447775f, -0.08758266f, -0.03238920f, 0.07855740f, 0.05715257f, -0.03515357f, 
    0.12672876f, -0.08605503f, 0.04706964f, 0.08048360f, -0.04660062f, 0.06122934f, -0.03888369f, 0.05796554f, 
    0.09498300f, 0.00753573f, -0.00782812f, 0.03561876f, -0.49289176f, 0.27394116f, 0.03370221f, -0.21462379f, 
    -0.17570412f, -0.04664017f, 0.07232977f, 0.07844487f, -0.18360870f, 0.09926389f, 0.07222286f, 0.14769240f, 
    0.13471925f, -0.02705978f, 0.00194904f, -0.10740501f, -0.02432964f, -0.05606641f, -0.02964073f, -0.00404385f, 
    -0.33357075f, -0.12855434f, -0.14405856f, 0.13464375f, -0.09282870f, -0.03443727f, 0.02325928f, 0.24711904f, 
    -0.15352535f, 0.16483806f, -0.00002447f, 0.04128875f, 0.11035308f, -0.02728323f, -0.01731242f, -0.06559215f, 
    -0.10849660f, -0.04445745f, 0.17355607f, 0.20033404f, -0.10495334f, 0.02410945f, 0.30214104f, -0.01745742f, 
    -0.01607957f, -0.04240658f, 0.03766012f, 0.03459864f, 0.03053121f, 0.06050372f, -0.03790036f, 0.04373698f, 
    0.06124831f, 0.19899736f, 0.16257758f, -0.00649008f, 0.00295359f, 0.00059296f, 0.06002776f, -0.01582792f, 
    -0.10215492f, 0.15405409f, 0.17963861f, 0.21444707f, 0.00146508f, 0.13755007f, 0.15861093f, 0.05675216f, 
    -0.25451168f, -0.11442666f, 0.06050644f, 0.07868440f, -0.09032791f, 0.09762060f, 0.03328608f, -0.05181196f, 
    0.08239732f, 0.15207486f, 0.04266576f, 0.03768623f, -0.01600948f, 0.27640146f, 0.13569877f, -0.04151050f, 
    0.01308259f, -0.08846547f, -0.16443494f, 0.01095486f, 0.03176757f, -0.00811185f, -0.22448558f, -0.11067651f, 
    -0.02664966f, 0.16328095f, 0.07263413f, -0.07704090f, 0.06805152f, -0.04419014f, 0.09994509f, 0.04748444f, 
    -0.09744547f, -0.04493685f, -0.31129432f, 0.05944348f, -0.12870947f, 0.17373332f, 0.04271406f, 0.13444246f, 
    0.01903870f, 0.09921654f, 0.08913871f, 0.03255143f, -0.01334083f, 0.03745210f, 0.07519680f, 0.04434317f, 
    0.13224682f, -0.03560571f, -0.08048573f, 0.08596545f, -0.10607554f, 0.07352651f, 0.31957614f, 0.23785985f, 
    -0.11666624f, 0.01786236f, 0.00541473f, 0.08284700f, 0.01187818f, 0.08623698f, -0.01743316f, -0.07365014f, 
    -0.04012089f, 0.16049346f, 0.05516091f, 0.07333478f, 0.02797693f, 0.01194543f, -0.05547227f, 0.03104842f, 
    0.23447807f, 0.19290398f, -0.13825212f, 0.05039851f, -0.04948279f, 0.11352472f, 0.05734841f, 0.07290965f, 
    -0.02257469f, 0.04633126f, -0.13508642f, 0.05285327f, 0.01294166f, -0.03699933f, -0.06087771f, 0.03368572f, 
    -0.03358544f, 0.04169200f, 0.06747992f, 0.06881645f, -0.25434366f, -0.07817594f, -0.09382453f, -0.15382239f, 
    0.04120308f, -0.09223999f, -0.05530077f, -0.05650718f, -0.07177149f, 0.10281419f, 0.12417898f, 0.01366517f, 
    -0.07284496f, 0.03946935f, 0.00135035f, 0.05739948f, -0.00684195f, 0.03467849f, 0.03617492f, 0.02749944f, 
    -0.02941956f, -0.46360847f, -0.23991990f, 0.17900452f, 0.12401373f, -0.01289542f, 0.12443991f, 0.02428804f, 
    0.20649858f, 0.08829971f, 0.17767729f, 0.14137338f, 0.02850563f, -0.03497195f, 0.00682643f, 0.01968323f, 
    0.03634998f, -0.09078690f, -0.14563568f, 0.14766961f, -0.21926047f, 0.11251959f, -0.02569532f, -0.10340808f, 
    0.17269070f, 0.07850078f, -0.11707789f, 0.10820234f, 0.05493505f, 0.13311210f, 0.02009144f, -0.07551803f, 
    0.06806700f, 0.09452192f, 0.02082664f, -0.12802058f, 0.01730436f, -0.03866489f, 0.07638360f, 0.11434526f, 
    -0.36411870f, 0.00109225f, -0.31543490f, -0.06161664f, -0.06855776f, 0.16011651f, -0.02871515f, -0.01075176f, 
    -0.01603651f, -0.02123287f, 0.09287637f, 0.10183142f, -0.08923745f, -0.14211389f, -0.00248329f, 0.09838419f, 
    0.01158681f, -0.16926607f, 0.03117363f, 0.08778864f, -0.28782254f, -0.24022715f, -0.20974351f, -0.02815908f, 
    0.04072849f, 0.02198093f, 0.06032739f, -0.02249904f, 0.24794079f, -0.02907030f, -0.09111735f, 0.09451233f, 
    -0.10211913f, 0.00308550f, 0.02751041f, 0.03415713f, -0.01503211f, 0.09371908f, -0.04609204f, 0.23605911f, 
    -0.12644315f, -0.06055965f, -0.04778738f, 0.19757059f, -0.04876685f, 0.05022712f, -0.01010983f, -0.03547285f, 
    -0.12989050f, 0.00353128f, 0.12754489f, -0.11054908f, 0.09322549f, 0.02040659f, 0.04923874f, 0.23142408f, 
    -0.05268518f, -0.08360302f, 0.01392698f, -0.00470407f, -0.14706612f, 0.03831569f, 0.15485860f, 0.14436419f, 
    0.18232253f, 0.01316838f, 0.03792478f, -0.02337681f, -0.21048076f, -0.02859848f, 0.01226861f, -0.06442328f, 
    -0.03391071f, 0.09607904f, -0.03860310f, -0.10023394f, -0.02636607f, 0.15498342f, 0.02567253f, -0.00018482f, 
    0.07441340f, 0.06223882f, -0.05853315f, 0.00141040f, -0.01170535f, 0.13858497f, -0.05631855f, 0.13054630f, 
    -0.04131386f, 0.14482537f, 0.04771089f, -0.09902547f, 0.02801886f, -0.01835945f, -0.06711844f, 0.10412206f, 
    0.02726285f, 0.10905255f, -0.01216263f, 0.11329276f, -0.29607263f, -0.08610392f, -0.28599778f, 0.10501345f, 
    0.21075501f, -0.01701950f, -0.02123514f, 0.04259526f, -0.00467445f, 0.03675005f, 0.18410578f, -0.05300542f, 
    0.03526726f, 0.05322155f, -0.03064769f, -0.17095104f, 0.12711306f, -0.11568949f, -0.09789775f, 0.09459708f, 
    -0.36983606f, -0.31653738f, 0.21729587f, 0.08056419f, -0.07919054f, 0.06930403f, 0.11153366f, 0.12237101f, 
    -0.02010218f, 0.27674642f, 0.08379357f, 0.04015946f, 0.10853782f, 0.02004740f, -0.11143588f, 0.01984540f, 
    0.08403774f, 0.09498812f, 0.03902682f, 0.10333113f, -0.03717620f, -0.29999098f, -0.09416175f, -0.02226345f, 
    -0.00369460f, 0.17809036f, -0.04904842f, 0.11224079f, 0.11253380f, 0.02293770f, 0.04305160f, 0.13893683f, 
    -0.12009484f, 0.00428646f, -0.09353305f, 0.01762064f, -0.04299299f, 0.04393658f, -0.16851977f, 0.04644747f, 
    -0.03932985f, 0.06942267f, 0.09337304f, 0.05364997f, 0.13986245f, -0.07450958f, -0.06145831f, 0.10682015f, 
    -0.02309830f, -0.02685785f, -0.09664588f, 0.05604887f, 0.12388009f, 0.31625763f, 0.04905189f, -0.04116481f, 
    0.14770465f, -0.12487133f, -0.12261772f, -0.01968186f, -0.69290078f, -0.43496180f, 0.02339693f, -0.02148541f, 
    0.01714918f, -0.02457181f, 0.02706808f, 0.00704464f, 0.05770362f, -0.00948981f, -0.01165672f, -0.09467958f, 
    0.02843518f, -0.02550668f, 0.03735539f, 0.03534909f, 0.10731590f, 0.20100141f, 0.02211835f, 0.04054919f, 
    -0.05004737f, -0.04431330f, 0.12237694f, 0.18274958f, -0.35485163f, 0.14579535f, -0.02949051f, -0.05693555f, 
    -0.09930344f, 0.03072086f, -0.00086654f, -0.01321851f, 0.09900472f, -0.10349844f, 0.08627423f, 0.12713383f, 
    0.07666833f, 0.22519250f, 0.02652210f, 0.03073310f, -0.04495587f, 0.07742772f, -0.23002678f, 0.08518288f, 
    -0.08135338f, 0.10164440f, -0.02676336f, 0.22158940f, -0.07155447f, 0.02909001f, 0.01314409f, 0.02288248f, 
    0.03085179f, -0.12752149f, 0.02599908f, 0.13780244f, 0.11378518f, 0.11479503f, -0.00525986f, 0.06256530f, 
    -0.23987049f, 0.01606455f, -0.33271462f, 0.13285486f, -0.07030997f, 0.09046797f, 0.01292606f, 0.02036795f, 
    -0.07690680f, 0.08375696f, -0.09729929f, 0.10207011f, -0.13905966f, -0.14997265f, 0.04346044f, 0.10819319f, 
    0.24244094f, -0.03044247f, 0.09247413f, -0.01614157f, -0.18645355f, 0.09572913f, -0.18326080f, -0.14471500f, 
    -0.09863945f, 0.06445311f, 0.10587002f, 0.03180908f, 0.06468250f, -0.05312180f, 0.11957179f, 0.04339255f, 
    -0.06201959f, 0.03169021f, -0.01755594f, 0.08216827f, -0.08254564f, -0.02636356f, -0.09033211f, 0.04142599f, 
    0.04439420f, 0.09003527f, 0.03506567f, 0.03710911f, 0.07221715f, 0.01473575f, 0.01459131f, 0.04470542f, 
    0.09152666f, -0.03332472f, -0.10921088f, 0.06274604f, -0.01084623f, -0.05741033f, 0.08942429f, -0.07534799f, 
    0.18123016f, -0.01438915f, -0.13156755f, 0.00979506f, -0.15238872f, 0.31004080f, 0.10798160f, -0.00511729f, 
    0.12531397f, 0.02668769f, 0.06368612f, -0.05299968f, -0.21893777f, -0.09445013f, 0.13646148f, 0.03808471f, 
    0.05195235f, -0.02530862f, 0.04352951f, 0.05898303f, 0.04519776f, 0.02471293f, 0.10975210f, -0.00740516f, 
    -0.03741669f, -0.03444577f, -0.01077064f, -0.03457023f, -0.01993714f, -0.00442958f, 0.03116236f, -0.00679652f, 
    0.03336620f, 0.02416191f, -0.03433702f, 0.01810140f, 0.03561226f, 0.03588256f, -0.02273157f, 0.00274133f, 
    0.03114857f, 0.03284082f, 0.02813978f, -0.01825852f, -0.01583936f, 0.00571736f, 0.01944557f, 0.02532884f, 
    -0.01577298f, -0.00156329f, -0.00303450f, 0.03666556f, -0.00152951f, -0.02381149f, 0.00072405f, -0.01148921f, 
    0.00766068f, -0.03667391f, 0.02476740f, -0.01864465f, -0.01181585f, -0.01563897f, 0.00574174f, 0.01123923f, 
    0.01622802f, -0.01882490f, -0.01715737f, 0.02209755f, 0.01528700f, -0.00109672f, -0.00416204f, 0.00089020f, 
    0.01449896f, 0.00415046f, 0.02481358f, -0.04168276f, 0.03817567f, 0.01636292f, -0.00117891f, 0.02116957f, 
    0.01058173f, 0.01114030f, -0.00711165f, 0.02130212f, -0.01581080f, -0.02537124f, -0.03623748f, -0.03114607f, 
    -0.00350324f, 0.00361631f, 0.02122185f, -0.00389305f, -0.03814041f, -0.02386897f, 0.00171430f, 0.01069890f, 
    -0.03719923f, -0.00124566f, 0.01260489f, -0.01377656f, 0.01343479f, -0.04108371f, 0.00940169f, -0.01743894f, 
    0.02010919f, -0.01662134f, -0.01701425f, 0.00481232f, -0.02162450f, 0.00776958f, -0.02090736f, -0.00200121f, 
    0.03385561f, 0.00160891f, -0.03294467f, -0.00415831f, 0.02734381f, 0.02893968f, 0.02852241f, -0.00347315f, 
    -0.03584518f, -0.02557806f, 0.01447440f, -0.00539691f, -0.02548372f, -0.01393851f, -0.02380678f, -0.02300141f, 
    -0.04104083f, -0.00436771f, 0.02181019f, 0.00050899f, -0.02929557f, -0.02475158f, -0.03149025f, -0.01452281f, 
    0.04371622f, -0.01072286f, 0.02856575f, 0.00124676f, -0.02756536f, -0.03107856f, -0.00679690f, 0.03574644f, 
    -0.01134561f, -0.03748574f, -0.01147471f, 0.03293972f, -0.02332648f, -0.01017284f, -0.01058855f, -0.01796612f, 
    0.03862968f, 0.01641402f, -0.01294910f, -0.00916148f, -0.02907603f, -0.02847626f, -0.03395509f, -0.02749310f, 
    -0.02794272f, 0.04082676f, -0.03194566f, -0.00564367f, -0.03070324f, -0.03227909f, -0.00379150f, -0.01221216f, 
    -0.02700175f, 0.00806235f, 0.02221848f, -0.03593238f, -0.00901796f, -0.02803691f, -0.04130767f, 0.01933281f, 
    -0.02017799f, 0.02872047f, -0.03760083f, 0.03686896f, 0.00964898f, -0.01182727f, 0.01324754f, 0.01773533f, 
    0.02700799f, 0.02214022f, -0.03170590f, 0.01083587f, -0.01368144f, 0.01010588f, -0.03554739f, -0.01369796f, 
    -0.00976632f, -0.00141308f, -0.01343187f, -0.00456009f, 0.01123425f, -0.03463598f, -0.00708627f, 0.03279139f, 
    -0.03322854f, 0.00582488f, 0.01570477f, 0.00966785f, -0.00809215f, -0.01821586f, 0.02553745f, 0.01476950f, 
    -0.03816514f, 0.02422917f, 0.02707122f, 0.02461561f, -0.03724856f, -0.02527856f, 0.01563590f, -0.02795498f, 
    -0.02618004f, 0.02034010f, -0.03965357f, -0.01716648f, -0.02279001f, -0.00757706f, 0.01065864f, -0.01625377f, 
    -0.00468946f, 0.02563783f, 0.00622084f, -0.01638918f, 0.02263121f, 0.00529061f, 0.01288193f, 0.03492338f, 
    -0.02862277f, 0.00735469f, 0.00665820f, 0.00308642f, -0.03032411f, -0.04404592f, 0.03346714f, 0.02923827f, 
    -0.00260390f, -0.03679692f, -0.01883115f, -0.00035478f, 0.03384998f, -0.01009337f, 0.01011066f, 0.00434438f, 
    0.01064427f, -0.02036480f, -0.00962235f, -0.00042602f, -0.04488679f, 0.01940329f, -0.01259629f, -0.00925867f, 
    0.03414426f, -0.00170334f, -0.00253981f, -0.00775920f, -0.00188052f, 0.03012593f, -0.01902995f, -0.03313388f, 
    0.01331732f, -0.02586316f, -0.00420967f, -0.02276531f, -0.03414914f, -0.01834345f, 0.03368641f, -0.01889104f, 
    0.02364274f, -0.01944915f, 0.03287385f, -0.04339590f, -0.00443082f, 0.00349067f, 0.00506177f, -0.00050565f, 
    -0.02785963f, -0.00942635f, -0.02021238f, -0.01360951f, 0.02124967f, 0.00573945f, -0.00287721f, -0.02014638f, 
    -0.04375490f, 0.03140349f, 0.01155769f, -0.00428860f, -0.03199163f, 0.02648029f, 0.00130205f, 0.03546913f, 
    -0.03282434f, -0.01181190f, 0.00547651f, -0.02838055f, -0.00452290f, -0.01638683f, -0.03529651f, -0.02133251f, 
    -0.01556564f, -0.03719249f, -0.03303660f, 0.01723478f, -0.03688388f, -0.01747844f, -0.03749274f, 0.02540303f, 
    0.02949451f, 0.02437023f, 0.02483493f, -0.02527211f, 0.01157082f, 0.02701538f, 0.02391747f, 0.03353278f, 
    -0.03002252f, 0.02290806f, -0.00531380f, 0.02167930f, 0.02317212f, -0.03246098f, -0.00824321f, -0.04165422f, 
    -0.00847746f, 0.03769808f, -0.00572157f, 0.02444133f, -0.01975125f, 0.03080910f, 0.00316664f, -0.02446990f, 
    0.00099810f, -0.02755184f, -0.02494842f, 0.00497037f, -0.03920594f, -0.02699792f, -0.03369937f, 0.03243885f, 
    0.00431007f, -0.00908796f, -0.03949546f, -0.04259382f, -0.00004031f, -0.02976546f, -0.01261166f, -0.03066685f, 
    0.01186657f, -0.00619723f, -0.03434197f, -0.03517109f, -0.02189909f, 0.00674621f, -0.03486994f, 0.00235549f, 
    0.01480343f, 0.00533616f, -0.03183690f, 0.01150143f, -0.04255114f, -0.00031770f, -0.00402072f, -0.02663503f, 
    0.02459735f, -0.03089817f, -0.00323047f, -0.03735716f, -0.00992669f, -0.00615220f, -0.02714429f, -0.02788864f, 
    -0.00206399f, -0.04633280f, 0.03670644f, -0.01454258f, 0.01130297f, -0.02793848f, -0.03845181f, 0.02748458f, 
    0.00143935f, -0.01109706f, -0.01409540f, 0.01641322f, -0.01715565f, 0.02238815f, -0.01098337f, -0.00459446f, 
    -0.01892377f, 0.02319183f, 0.01760631f, -0.04228891f, 0.00202733f, 0.02130465f, 0.03247759f, 0.00223274f, 
    -0.01138362f, 0.02415978f, -0.01803676f, -0.03794757f, -0.00305980f, 0.02790367f, -0.03388558f, 0.03330196f, 
    -0.01440449f, -0.02351269f, -0.00430980f, 0.03370796f, 0.01905220f, 0.01167883f, 0.00293051f, -0.00239476f, 
    0.01551754f, -0.02096411f, 0.02929358f, 0.00647083f, 0.03349609f, 0.01416939f, -0.03931867f, 0.03278486f, 
    -0.00440737f, -0.01077356f, -0.03075035f, 0.01380495f, 0.01988974f, -0.03852218f, -0.01276146f, -0.02127685f, 
    0.01732877f, 0.01976475f, -0.00077200f, -0.01759207f, -0.02105243f, -0.01417290f, -0.00511869f, -0.01828925f, 
    -0.01762548f, 0.02309023f, 0.01366462f, -0.00347906f, -0.02320705f, -0.01110311f, -0.04330796f, -0.01202040f, 
    0.00751941f, 0.01926184f, -0.03030046f, -0.03056716f, 0.02580625f, 0.01530214f, -0.02129441f, -0.02663080f, 
    -0.03413135f, 0.02004114f, -0.00099984f, -0.03008251f, -0.03928019f, -0.03137187f, -0.04563361f, 0.02910096f, 
    -0.01975933f, -0.02416085f, 0.01013791f, -0.03335903f, 0.01529684f, 0.02948500f, -0.02795777f, -0.00552877f, 
    -0.02059709f, -0.03774754f, -0.00851998f, -0.02092775f, -0.03104407f, -0.01587318f, -0.03746809f, -0.00970393f, 
    0.01498363f, 0.02012346f, 0.00459776f, -0.00944424f, 0.01145595f, -0.01263563f, -0.02346973f, -0.00049294f, 
    0.01446585f, -0.02600295f, -0.02337202f, 0.03162511f, -0.02590124f, 0.00113648f, -0.03042258f, 0.00028769f, 
    0.04064614f, -0.00413950f, -0.00223606f, -0.00830995f, 0.01266592f, 0.03498356f, 0.02198257f, -0.04121555f, 
    -0.01125651f, -0.01864540f, -0.00870633f, -0.00732530f, -0.02280643f, 0.00609022f, -0.04261420f, -0.01860095f, 
    -0.00131559f, -0.00260003f, -0.00841378f, -0.02909250f, 0.02310250f, -0.00649219f, -0.01822458f, -0.02615882f, 
    -0.00731551f, -0.00533218f, 0.01389363f, 0.01645895f, -0.00865391f, 0.02897177f, -0.02847069f, 0.02817735f, 
    -0.00828438f, -0.00745797f, 0.03864252f, -0.02801155f, 0.00333490f, -0.01482198f, 0.02043666f, -0.00469427f, 
    -0.03140794f, 0.03143050f, -0.03470846f, -0.00458558f, -0.03102844f, -0.00226047f, -0.01660262f, 0.01365296f, 
    0.02804232f, 0.00568193f, -0.03256747f, 0.00066903f, -0.03036246f, -0.03267042f, 0.03336960f, -0.03056107f, 
    0.03108853f, -0.03008599f, 0.00633822f, -0.02254334f, -0.02505149f, 0.01403458f, 0.00293251f, -0.03249110f, 
    -0.01669110f, 0.00226017f, -0.04389536f, -0.02698942f, 0.02122408f, -0.02469188f, -0.02299005f, 0.01550499f, 
    0.00690866f, -0.01424380f, -0.03671240f, -0.00762197f, 0.00624814f, 0.03141234f, 0.02158303f, -0.03784189f, 
    -0.02854926f, 0.02250587f, -0.04005756f, 0.01373258f, 0.00790559f, -0.00709563f, -0.03371908f, 0.02147616f, 
    -0.01224482f, -0.02787818f, 0.00421611f, -0.03176229f, 0.02689099f, -0.02940084f, -0.00191476f, 0.03239845f, 
    -0.03997807f, 0.00193074f, 0.03152495f, 0.01119425f, -0.02408193f, 0.02355647f, 0.03781599f, -0.00642214f, 
    0.00412987f, 0.03399201f, 0.01379993f, 0.02780732f, 0.02299683f, -0.00369962f, -0.00357211f, -0.04210082f, 
    0.01579131f, 0.02290709f, -0.03552225f, 0.02761805f, 0.02633798f, 0.02490086f, 0.01578029f, -0.00969250f, 
    -0.00741117f, 0.02450582f, 0.01987489f, 0.01759755f, 0.00866986f, -0.01352402f, 0.01846717f, 0.00804506f, 
    -0.01339404f, -0.00203451f, 0.02636337f, -0.02638961f, 0.02477678f, -0.02115268f, -0.03754472f, 0.01056821f, 
    -0.03944318f, 0.00966236f, -0.01039084f, 0.02954895f, -0.02305852f, -0.02208970f, 0.02727924f, 0.03944474f, 
    -0.02538509f, -0.00541276f, -0.01937422f, -0.00506837f, -0.01702248f, 0.01783392f, 0.04286531f, 0.02116322f, 
    0.00821575f, -0.03805709f, 0.02300546f, 0.00648193f, -0.02269181f, -0.03011382f, -0.00591678f, -0.03420923f, 
    -0.02116336f, -0.02207727f, -0.00971691f, -0.00813531f, -0.01439676f, 0.01035913f, 0.01809735f, -0.02407059f, 
    0.00151821f, -0.00264862f, 0.01813027f, 0.01656172f, -0.02405954f, -0.03279981f, -0.00883627f, -0.02987604f, 
    0.01431575f, -0.01690996f, -0.02440226f, 0.03093956f, -0.01845131f, 0.00841615f, -0.02485711f, -0.00681695f, 
    0.01586171f, -0.02382700f, -0.03327799f, -0.01499196f, 0.02756553f, -0.04537616f, 0.03330183f, -0.00743591f, 
    0.02216811f, -0.00673861f, -0.00443397f, 0.01948979f, -0.00804169f, -0.00182991f, 0.01433308f, 0.00883087f, 
    0.03020308f, -0.04478567f, 0.00923831f, 0.01576297f, -0.00035215f, 0.02564257f, -0.03511947f, 0.01346871f, 
    0.03347406f, -0.03563075f, -0.03818835f, -0.00410277f, 0.01577867f, -0.03629110f, 0.02199684f, 0.02445230f, 
    -0.00811311f, -0.01098527f, -0.01467550f, -0.02777973f, -0.02187328f, -0.01347007f, -0.02281930f, 0.03007414f, 
    0.02601949f, -0.03162862f, 0.03200091f, -0.01326368f, 0.02372807f, -0.01632529f, -0.04040099f, -0.03883214f, 
    -0.02222080f, 0.01002420f, -0.04538412f, 0.00750718f, -0.02476660f, -0.03371268f, -0.02322656f, 0.01013315f, 
    0.02208001f, 0.02113350f, 0.02512415f, -0.00566584f, 0.02582162f, 0.02910681f, -0.02568462f, 0.01270844f, 
    -0.00838206f, 0.01565581f, -0.01101893f, -0.02593713f, -0.00245472f, 0.02790673f, 0.02576652f, -0.02909463f, 
    0.03268293f, -0.02840945f, -0.00450376f, 0.03310310f, -0.02558654f, 0.00847530f, -0.02728680f, 0.01876477f, 
    -0.00502028f, 0.00199465f, 0.02555606f, 0.02361637f, 0.01521603f, 0.02446422f, 0.01730060f, 0.02813497f, 
    -0.02141272f, -0.02962888f, -0.00315784f, -0.02296978f, -0.01148911f, -0.00873443f, -0.02566084f, -0.04379205f, 
    0.01879636f, 0.01433540f, -0.04371841f, 0.00783125f, -0.00528163f, -0.00620023f, -0.02242050f, 0.00611209f, 
    -0.03044727f, -0.00390749f, 0.02565783f, 0.01777840f, 0.02753779f, 0.00300091f, 0.01962509f, 0.03071167f, 
    0.02097615f, 0.02727987f, 0.00902166f, -0.02108228f, 0.01653657f, 0.00255279f, -0.02077794f, -0.01273763f, 
    0.01841032f, 0.00618422f, 0.00881457f, 0.01943175f, -0.00677968f, 0.00219509f, 0.00579368f, 0.03048896f, 
    -0.01108908f, -0.01139321f, 0.02067161f, -0.04370647f, 0.00274835f, 0.03166525f, 0.00889269f, 0.01624212f, 
    -0.00536586f, -0.02629674f, 0.02480719f, -0.00484770f, -0.03510306f, 0.01174030f, -0.01684338f, -0.03400315f, 
    0.02322000f, -0.02426080f, 0.03020146f, -0.03987077f, -0.00294756f, -0.02748949f, 0.02025620f, 0.00720161f, 
    -0.03077027f, -0.01248723f, 0.00040995f, -0.01662683f, -0.01518434f, 0.01945440f, 0.01518554f, 0.01314024f, 
    -0.03353523f, 0.01579981f, 0.00347765f, 0.02803930f, -0.00292927f, -0.00598882f, 0.01095169f, -0.04212626f, 
    0.02625673f, -0.02078970f, 0.01905918f, 0.00700770f, -0.02080087f, -0.00267894f, 0.02109746f, -0.03153462f, 
    -0.02131883f, 0.02403873f, 0.03098129f, 0.00088602f, -0.02040490f, 0.01314468f, -0.04252699f, 0.01906905f, 
    0.00039141f, 0.00830827f, -0.00392264f, -0.00078601f, -0.01119982f, -0.01239779f, -0.03460003f, -0.00718822f, 
    0.01504869f, -0.02188794f, -0.01652922f, -0.00522115f, -0.00301163f, -0.00094115f, 0.00641249f, 0.02574609f, 
    -0.02068893f, 0.01760252f, -0.03071542f, -0.02982596f, -0.03203492f, -0.02737608f, -0.02735318f, 0.02280527f, 
    -0.02897218f, -0.02846226f, -0.03566237f, -0.01467279f, -0.03350313f, -0.04223750f, 0.01228885f, -0.00302130f, 
    0.02379872f, 0.01079197f, 0.02236973f, 0.00807826f, -0.02947038f, -0.00823184f, -0.03070934f, -0.03538086f, 
    -0.01579721f, -0.03146384f, -0.03728282f, -0.04013430f, 0.02001802f, 0.02261570f, 0.01060033f, 0.02405673f, 
    0.01043897f, -0.00918002f, -0.00199288f, 0.00792962f, -0.01862627f, -0.00406835f, -0.02822652f, -0.02984865f, 
    -0.02915998f, 0.02866291f, 0.01040711f, 0.02797646f, -0.00413752f, 0.02731109f, -0.01916270f, -0.03142857f, 
    0.01431459f, 0.02033455f, -0.00320340f, -0.03140058f, 0.03002865f, -0.00372294f, -0.00749170f, -0.02844831f, 
    -0.04459848f, 0.01777343f, 0.00876039f, 0.02104943f, 0.00495756f, 0.00924542f, -0.04031990f, -0.00195709f, 
    -0.03514840f, -0.02307682f, -0.02574481f, 0.02584030f, -0.00474210f, 0.01330610f, -0.03960913f, 0.01376091f, 
    -0.03920419f, -0.03145068f, -0.02997856f, -0.03817840f, -0.00716939f, -0.03705362f, 0.00534242f, -0.02096187f, 
    -0.00389832f, 0.01464789f, -0.02377501f, -0.04484934f, -0.00344864f, -0.03022714f, -0.03424707f, -0.03974868f, 
    0.03221997f, 0.02779913f, -0.00558488f, 0.02803019f, 0.02526489f, 0.01285804f, -0.03306945f, -0.02443065f, 
    0.00297230f, 0.01018614f, 0.00997736f, -0.03604953f, 0.01723477f, -0.00849167f, 0.00163579f, 0.02138660f, 
    0.01020258f, -0.03030726f, 0.01792281f, 0.02826079f, -0.00451522f, -0.03668773f, -0.02402049f, 0.02792140f, 
    -0.02653727f, -0.00163668f, 0.00056343f, -0.04166500f, -0.01493229f, 0.00844081f, -0.02324772f, -0.02567254f, 
    0.02922420f, -0.00718310f, 0.02057858f, -0.04027094f, 0.01926178f, -0.01989891f, 0.01345931f, -0.02363563f, 
    0.02191661f, 0.03142936f, -0.03514623f, -0.01622160f, -0.03506755f, 0.01383008f, -0.01266366f, -0.00630183f, 
    -0.01195474f, 0.00985156f, -0.02517598f, -0.03753881f, -0.01182340f, 0.02857733f, -0.00493491f, -0.04156699f, 
    0.00378032f, 0.00634188f, -0.03064664f, -0.01890910f, 0.00885759f, 0.01549031f, 0.00237866f, 0.03009431f, 
    -0.03942865f, -0.00106471f, 0.02346337f, -0.01841892f, -0.03343963f, -0.03534216f, 0.00412492f, -0.01674904f, 
    -0.03729915f, -0.01394535f, -0.04013179f, 0.03145066f, 0.00124517f, -0.02682325f, -0.00440436f, 0.01429451f, 
    -0.01826638f, 0.01912935f, -0.04514192f, 0.00246311f, -0.00184867f, 0.00143256f, 0.01454997f, -0.01736397f, 
    0.02209262f, -0.01491914f, 0.02281251f, -0.04193267f, -0.01045096f, 0.00334341f, -0.00594418f, 0.03285433f, 
    0.01968966f, 0.01235091f, -0.03931155f, -0.03865382f, -0.02337720f, 0.01264051f, -0.02413951f, -0.00394444f, 
    -0.01298718f, 0.02224734f, -0.03446794f, -0.03266430f, 0.00484848f, -0.02514838f, -0.03743883f, 0.02071991f, 
    -0.02486517f, -0.01666181f, -0.02682872f, -0.02437303f, 0.01982703f, 0.02321509f, -0.03056521f, -0.02008070f, 
    0.02614934f, -0.02925806f, -0.04148697f, -0.03849518f, 0.00858212f, -0.04518656f, -0.03312325f, 0.01413855f, 
    0.03207169f, -0.00183170f, -0.00230800f, -0.00098438f, -0.01090582f, -0.03205089f, 0.01211486f, 0.02413741f, 
    0.01239178f, -0.01535480f, -0.04365561f, -0.00475943f, -0.01977930f, 0.01835924f, 0.02605812f, -0.00199666f, 
    0.01163118f, 0.00101150f, -0.04060366f, 0.01564520f, 0.02694622f, 0.02114622f, -0.02382888f, 0.02493857f, 
    0.01948296f, -0.00044634f, -0.04324929f, -0.03716187f, 0.00812814f, -0.03819050f, 0.00639350f, 0.01101304f, 
    -0.01891202f, -0.04227440f, -0.00041348f, 0.03298020f, -0.02291541f, 0.02686571f, 0.00083300f, -0.03063750f, 
    -0.04036167f, -0.01650484f, -0.03065473f, -0.00704465f, -0.02505273f, -0.02077188f, -0.04457336f, 0.02576155f, 
    0.02119532f, 0.00648656f, 0.03084605f, -0.03031256f, -0.01059927f, -0.04477321f, -0.04490781f, 0.03300769f, 
    -0.02654697f, 0.00047776f, -0.01081001f, -0.03572759f, 0.02502207f, -0.01693382f, -0.01796662f, 0.01437697f, 
    -0.03381152f, -0.01002742f, -0.02702093f, 0.00126697f, -0.02406239f, -0.00180509f, 0.02535059f, 0.01150757f, 
    -0.01558549f, 0.02727245f, 0.02891191f, -0.02392571f, 0.03003127f, -0.01084198f, 0.04091989f, -0.00491844f, 
    0.01170130f, -0.02575919f, -0.00579571f, -0.04243130f, -0.02379900f, -0.02570088f, 0.02494395f, 0.00839075f, 
    -0.01200154f, 0.02559463f, 0.02842226f, -0.03634847f, -0.02540506f, 0.01751781f, 0.02463210f, -0.02530572f, 
    -0.04309858f, 0.01367195f, -0.03201674f, 0.02965205f, 0.03108295f, -0.02252499f, -0.00467150f, -0.03379663f, 
    -0.01217485f, -0.04324854f, 0.00945638f, -0.04206120f, -0.00283255f, -0.03861891f, -0.01681117f, -0.01873481f, 
    -0.00916785f, 0.00324592f, -0.01586318f, -0.03228432f, 0.01562458f, -0.01297662f, 0.00395362f, -0.04528794f, 
    -0.03499794f, -0.00784751f, -0.01046149f, -0.02072242f, 0.01389686f, 0.01174070f, -0.03972723f, 0.01823920f, 
    -0.02570416f, 0.00122360f, -0.01797612f, 0.02372248f, 0.00197851f, -0.00237201f, -0.02094855f, -0.00009671f, 
    -0.04143444f, 0.02080984f, 0.03199908f, 0.03288984f, -0.03138180f, -0.02420983f, -0.03959223f, 0.01884262f, 
    -0.02477990f, -0.03078873f, -0.04039232f, -0.00698384f, -0.02008495f, -0.01346157f, -0.03317865f, -0.02767991f, 
    -0.02410442f, 0.00149969f, -0.02430306f, -0.04471039f, -0.00761164f, 0.03006422f, -0.01824736f, 0.03091568f, 
    -0.01194597f, 0.02421746f, 0.02410829f, -0.01092868f, 0.01860715f, 0.01865061f, 0.01130458f, 0.00239868f, 
    -0.01310901f, -0.03760355f, -0.02624194f, -0.03812884f, -0.02007865f, 0.00364572f, 0.01311853f, 0.02200602f, 
    0.03351379f, -0.01245288f, -0.04137010f, 0.00654998f, -0.03932245f, 0.02502544f, -0.02602636f, -0.03952410f, 
    -0.02767528f, -0.00999203f, 0.02462115f, -0.00655700f, -0.03042307f, -0.04013475f, 0.02070556f, -0.00247657f, 
    0.00828075f, -0.02064329f, 0.02014208f, 0.01772796f, 0.00087210f, -0.02528110f, -0.03417246f, 0.01250271f, 
    -0.02740624f, 0.01951028f, 0.03008999f, 0.00853624f, 0.00874237f, -0.04388021f, -0.00940905f, 0.00522394f, 
    -0.04640928f, -0.02595680f, 0.03117604f, -0.01302132f, -0.00080879f, 0.01221222f, -0.01711545f, 0.02244315f, 
    -0.03251253f, -0.03528096f, 0.03276773f, 0.02485154f, 0.01362368f, 0.02717941f, -0.02214732f, -0.03352940f, 
    0.02387473f, -0.02881074f, 0.01322318f, 0.03988791f, -0.02536801f, -0.00505645f, -0.01848212f, 0.01136406f, 
    0.01286763f, -0.03665106f, -0.03764417f, -0.04095718f, -0.04590051f, 0.00408260f, -0.01404817f, 0.02144042f, 
    -0.03455039f, 0.01892041f, 0.01358221f, -0.02617203f, 0.00209074f, 0.02805712f, -0.03211456f, -0.01680507f, 
    -0.02839115f, -0.00811732f, -0.03228890f, 0.01405404f, -0.03396568f, -0.02058030f, 0.00736100f, 0.01696689f, 
    -0.00787264f, 0.01988688f, -0.02348949f, 0.01604803f, 0.02444367f, 0.03043981f, -0.02014202f, -0.03970213f, 
    0.01231907f, 0.01368615f, 0.01791043f, 0.01318813f, 0.00744410f, -0.01140801f, 0.01733976f, -0.01776400f, 
    0.00269647f, 0.02027760f, 0.00748670f, -0.00006762f, -0.00339270f, 0.01942523f, 0.03344960f, 0.01912659f, 
    -0.03795498f, -0.03529487f, 0.01875708f, -0.03881149f, 0.01054128f, -0.02108018f, 0.02061739f, -0.04388794f, 
    0.00816591f, 0.00532604f, 0.01853900f, -0.02093468f, -0.02165913f, -0.04359854f, -0.00181807f, -0.03479459f, 
    -0.00942829f, -0.01437566f, -0.01012348f, -0.02152392f, -0.00034403f, -0.00873473f, 0.02722071f, 0.01281018f, 
    0.02799445f, -0.00094237f, -0.00810446f, -0.02432284f, -0.00544139f, -0.04273093f, -0.00151256f, 0.00486261f, 
    0.00532207f, 0.02010886f, 0.01765843f, -0.03372661f, -0.03852768f, -0.00848640f, -0.03246044f, -0.03476008f, 
    -0.02927904f, -0.02655989f, 0.00891212f, 0.03418966f, 0.00184588f, 0.00922343f, -0.03595857f, -0.00601231f, 
    -0.01548448f, -0.01480552f, 0.00673744f, 0.02926878f, -0.00866374f, -0.00336070f, -0.02344135f, 0.02501572f, 
    -0.01967130f, -0.01368390f, 0.02586990f, -0.00223222f, 0.00075006f, -0.01308457f, 0.03344577f, 0.01982148f, 
    0.02695207f, -0.00798539f, 0.02667757f, 0.02292512f, 0.03375534f, 0.00648265f, -0.03346945f, -0.04333615f, 
    0.03445062f, -0.01896473f, 0.02892452f, 0.02637819f, 0.02106014f, -0.02076049f, 0.03274607f, -0.03930270f, 
    0.01991303f, 0.02759494f, -0.01602172f, -0.04384115f, -0.02013158f, 0.00270015f, -0.03809340f, -0.03940048f, 
    0.04378241f, 0.03181612f, 0.00070647f, -0.02042470f, -0.00701771f, 0.03776222f, -0.01479836f, 0.02285322f, 
    0.01555861f, 0.00197012f, 0.02198531f, 0.02944924f, 0.02176180f, -0.02563662f, -0.02521279f, 0.00715252f, 
    0.02863193f, -0.03786475f, 0.04436494f, -0.02896810f, -0.01734551f, -0.01013616f, -0.01107101f, -0.03458187f, 
    0.03222812f, 0.02135652f, 0.00902894f, -0.02684995f, -0.03264990f, 0.01082395f, -0.01929176f, -0.03803681f, 
    -0.00837668f, 0.02285873f, 0.02545541f, -0.01772523f, -0.04310818f, -0.01163983f, 0.02350155f, -0.02233052f, 
    0.00496840f, -0.04563078f, -0.01219780f, -0.04019882f, -0.03645593f, -0.03245467f, -0.02043794f, 0.02625877f, 
    -0.01691250f, -0.03577372f, 0.03176187f, 0.03324524f, -0.01384531f, 0.00657086f, -0.02261111f, -0.01449153f, 
    -0.04146831f, 0.01370687f, -0.00859193f, -0.02272834f, -0.02080604f, 0.00106179f, -0.02437172f, -0.02094389f, 
    -0.02973046f, 0.00323204f, 0.03269619f, 0.02983274f, 0.02398819f, -0.01394923f, 0.00934737f, -0.01204900f, 
    -0.03333780f, 0.02853343f, 0.00820544f, -0.00642350f, 0.02391656f, -0.02084991f, 0.00080043f, -0.01875135f, 
    0.01499612f, 0.02348043f, -0.04085324f, -0.02794204f, -0.03882790f, -0.00809114f, -0.00138027f, -0.02206008f, 
    0.00267239f, -0.02044111f, 0.00717253f, 0.00767550f, 0.00157697f, -0.01782378f, -0.01878445f, 0.02153422f, 
    0.01877315f, -0.03436929f, 0.01313880f, 0.02073921f, -0.03745210f, 0.02568974f, 0.00132848f, 0.01916979f, 
    -0.01223630f, 0.00770994f, 0.02161284f, 0.00281420f, -0.02841803f, -0.01528446f, -0.01832108f, -0.01754225f, 
    -0.03759921f, -0.01000529f, -0.02911101f, -0.03096578f, -0.01971560f, -0.01886279f, -0.02014560f, 0.02178772f, 
    -0.03723356f, -0.04540436f, -0.01358382f, -0.00473358f, -0.01926632f, 0.01200609f, -0.00867803f, 0.03253359f, 
    -0.00466519f, 0.02508016f, -0.01851542f, -0.01079396f, -0.02522282f, -0.00040847f, -0.02761235f, -0.02018596f, 
    0.00083994f, -0.03437416f, -0.02188665f, -0.01229768f, 0.02708616f, -0.01822034f, -0.02061033f, 0.03019564f, 
    -0.02151717f, 0.03078078f, -0.01586654f, 0.01660904f, 0.02557182f, 0.00038725f, 0.00569629f, 0.00036280f, 
    0.03385654f, 0.02117100f, 0.02754554f, -0.01437387f, -0.04624344f, -0.00202287f, 0.01608694f, 0.02075119f, 
    0.00830749f, 0.00121223f, 0.00960884f, 0.02078209f, 0.00991907f, 0.02793096f, -0.00347420f, -0.00435600f, 
    -0.00487296f, -0.01838784f, 0.02030222f, -0.00840103f, -0.00980195f, 0.00600428f, 0.00550644f, -0.01368230f, 
    0.00076665f, -0.05118937f, -0.01403367f, -0.00393765f, 0.00948264f, 0.02601877f, 0.02071081f, 0.01986082f, 
    0.00474221f, 0.01328858f, -0.04023248f, -0.03684298f, 0.02726278f, 0.02782808f, 0.02565688f, -0.03135436f, 
    0.01870948f, -0.03428116f, -0.02564669f, 0.01038582f, -0.03198847f, 0.00328221f, -0.02254281f, -0.03892873f, 
    -0.02392529f, 0.03529456f, 0.00797092f, 0.00501674f, 0.00047971f, 0.01688471f, 0.01761531f, -0.03150925f, 
    0.00489751f, 0.00048151f, 0.02953439f, -0.03756285f, -0.00484809f, 0.02745437f, -0.02709104f, 0.02446723f, 
    0.00457090f, 0.01886178f, 0.02423064f, -0.04099047f, -0.03148311f, 0.02351866f, -0.01171195f, 0.02218857f, 
    -0.03022072f, -0.01035885f, -0.04882288f, 0.01434211f, 0.00200744f, -0.02793526f, -0.02893305f, -0.04261392f, 
    -0.03508656f, 0.02565056f, -0.04228061f, -0.00769164f, -0.04081826f, -0.04376612f, -0.02692495f, -0.02981587f, 
    0.01280350f, 0.02304682f, -0.02926706f, -0.01305429f, 0.02657906f, 0.00926808f, -0.00633023f, -0.01950612f, 
    -0.03956351f, 0.00802550f, 0.02472181f, -0.01410081f, -0.01477589f, 0.00970291f, -0.01073460f, 0.00746924f, 
    -0.01195051f, -0.00997612f, -0.03289915f, -0.03459982f, -0.02293673f, 0.01577061f, -0.00339764f, 0.02916565f, 
    0.00593921f, 0.02678267f, 0.03646786f, 0.02865976f, 0.01145973f, -0.00792579f, -0.04371541f, 0.03213467f, 
    0.01617040f, -0.04115270f, -0.04113519f, -0.00126655f, 0.01490592f, 0.01030942f, 0.02332928f, -0.00380048f, 
    0.00042757f, -0.03289768f, 0.01635030f, -0.03794126f, -0.01865118f, -0.01852045f, 0.01748032f, 0.01096261f, 
    0.02469370f, -0.01959782f, 0.01713880f, -0.03753521f, 0.02742973f, -0.02508489f, -0.04262106f, -0.00086394f, 
    0.00632820f, 0.00030546f, -0.03481401f, -0.02828621f, -0.01879847f, -0.01419064f, 0.03222074f, 0.00028123f, 
    0.01017013f, -0.03220320f, -0.01738868f, -0.00465412f, 0.00968810f, 0.01087308f, -0.03614358f, 0.00100727f, 
    0.01464917f, -0.04130388f, 0.01038283f, 0.01430015f, 0.02367147f, 0.00866227f, 0.00700598f, -0.03049158f, 
    -0.01532279f, -0.00054584f, -0.02020517f, -0.03773460f, -0.00393273f, -0.01855011f, 0.02924375f, 0.03647224f, 
    0.02914452f, -0.00439992f, -0.00859656f, -0.02000450f, -0.02433201f, -0.01571539f, -0.02245882f, 0.03178167f, 
    -0.03866566f, 0.00525645f, 0.00180429f, -0.01599254f, 0.03105128f, -0.00985048f, -0.01859145f, -0.03455811f, 
    -0.02651698f, -0.03450070f, -0.01816514f, 0.01836275f, 0.02602175f, 0.01871550f, 0.01489503f, -0.02163828f, 
    -0.01675477f, 0.02316662f, 0.03065020f, -0.03590448f, -0.01204082f, -0.01810336f, -0.00018574f, 0.00644034f, 
    -0.00229774f, -0.03223151f, -0.02904361f, -0.01390581f, -0.01864303f, 0.02716387f, 0.00328753f, -0.03080729f, 
    -0.00195742f, -0.04006223f, 0.03280064f, 0.00086249f, -0.00257315f, -0.03484006f, -0.03213289f, -0.00500228f, 
    -0.00813802f, 0.01395879f, 0.01579542f, -0.01731372f, -0.01011226f, -0.01836077f, 0.03360437f, -0.03313678f, 
    -0.01572830f, 0.01205440f, -0.01410580f, -0.03696466f, -0.03602198f, -0.00741148f, 0.02609624f, -0.03021183f, 
    0.00602999f, -0.00669631f, -0.03406429f, -0.03501000f, 0.03622285f, -0.03053564f, -0.02760976f, -0.03622731f, 
    0.00123459f, 0.02168791f, -0.03569340f, -0.02528880f, 0.01922469f, -0.02618357f, -0.03665179f, 0.02246013f, 
    0.02211751f, 0.00848377f, -0.03748476f, -0.03400989f, -0.00922068f, 0.02266309f, -0.01172305f, 0.01590224f, 
    -0.01810251f, -0.03186411f, 0.02638775f, 0.01764862f, -0.03608703f, 0.02979430f, 0.01069883f, 0.00296325f, 
    -0.02826168f, -0.02541873f, -0.03734480f, 0.02647270f, -0.00343440f, -0.02569713f, -0.00645778f, 0.02797351f, 
    -0.01696750f, 0.01907953f, 0.01518493f, 0.00438571f, -0.03159542f, -0.00648329f, -0.01900304f, 0.03327880f, 
    0.01455529f, 0.02398182f, -0.02366373f, -0.02921695f, 0.03123048f, -0.01164112f, 0.01583408f, 0.00134264f, 
    -0.03003805f, 0.00881264f, -0.03177362f, -0.02436802f, -0.01530446f, 0.00355764f, -0.00984248f, -0.02989171f, 
    -0.01461906f, 0.00331965f, 0.00745447f, -0.01251643f, 0.03887840f, 0.04175693f, -0.04638182f, -0.00056609f, 
    0.01232633f, 0.01232305f, -0.03294979f, 0.01925250f, -0.02810037f, -0.02233855f, -0.01143549f, 0.00020203f, 
    0.00746226f, -0.03540390f, -0.04194263f, -0.03671699f, -0.03728076f, -0.04206358f, 0.04225133f, 0.03947438f, 
    0.00914775f, -0.00044033f, 0.02399282f, 0.02201463f, 0.01354002f, 0.01186238f, 0.01876801f, -0.00066750f, 
    0.01489027f, -0.00842839f, -0.01816188f, -0.00860151f, -0.03787396f, 0.00678230f, -0.02603669f, -0.03781768f, 
    0.01273824f, 0.02265259f, 0.01597563f, 0.01177098f, 0.00043647f, 0.03270878f, -0.03827943f, 0.00018551f, 
    -0.02592143f, 0.00778789f, -0.04197215f, -0.02383260f, -0.01827097f, 0.03638651f, -0.01043865f, -0.03901715f, 
    -0.00086205f, 0.01222979f, -0.00460329f, -0.01747152f, 0.02297208f, -0.03677599f, -0.01999898f, -0.01619571f, 
    0.02976400f, 0.00467082f, 0.03159141f, 0.01954264f, 0.01017473f, -0.00755266f, -0.01024089f, -0.03689313f, 
    0.00682761f, -0.02896271f, -0.03520706f, -0.02031795f, 0.02654657f, -0.01189022f, -0.03816596f, 0.01032910f, 
    -0.04255699f, -0.03831661f, 0.02430195f, -0.01731039f, -0.00304446f, -0.02871842f, 0.01362040f, -0.00149594f, 
    -0.01892987f, -0.01735575f, -0.02319271f, -0.03266831f, -0.01551911f, 0.03048100f, 0.02739336f, -0.00706094f, 
    0.00740870f, -0.01497435f, -0.00117135f, -0.04198796f, 0.01369613f, 0.00425724f, -0.01095459f, -0.01045906f, 
    -0.02226078f, -0.04446565f, 0.01617703f, 0.00847399f, -0.01482821f, -0.00228208f, -0.03664009f, 0.01274081f, 
    -0.02532899f, 0.02360142f, -0.00331507f, 0.00486663f, -0.01808607f, -0.00928935f, 0.02883724f, 0.01081834f, 
    -0.03191615f, -0.03513078f, 0.00541553f, 0.02905503f, -0.00584696f, -0.03794856f, -0.03880884f, -0.00295618f, 
    0.00031119f, -0.02603919f, -0.03835096f, -0.03203518f, -0.00899616f, -0.01813556f, -0.01208340f, 0.01173639f, 
    -0.03457947f, 0.00214334f, -0.00937297f, 0.00291277f, 0.02933102f, -0.02939802f, -0.00654387f, 0.03480254f, 
    0.02102575f, 0.03636018f, -0.00962745f, -0.02108388f, -0.00990405f, -0.00613380f, 0.02065837f, 0.02366351f, 
    0.02274024f, -0.03323352f, 0.03597287f, 0.00227796f, 0.00053038f, -0.03903084f, -0.00590002f, -0.00214113f, 
    -0.02731027f, 0.00101483f, -0.01876520f, -0.01090629f, -0.01512042f, 0.00999503f, -0.03788165f, -0.03420433f, 
    0.00718198f, -0.00362419f, 0.02851653f, 0.02393227f, -0.01456419f, -0.00280659f, -0.00614068f, -0.01169125f, 
    0.00128609f, 0.03138525f, -0.00725530f, 0.00374050f, -0.00901095f, 0.02581598f, 0.00027280f, -0.04069287f, 
    0.01502701f, -0.01851923f, -0.01118307f, 0.03577242f, 0.00165577f, -0.04701810f, -0.03142791f, -0.02441751f, 
    -0.03174882f, 0.03438387f, -0.00750952f, -0.04578713f, -0.01079193f, 0.02257496f, -0.00615190f, 0.00775494f, 
    0.03058369f, -0.02277195f, 0.02963981f, 0.03331006f, -0.01207231f, -0.03279795f, 0.03301808f, -0.01039067f, 
    -0.00438141f, -0.01883023f, -0.01962186f, 0.03309276f, -0.03015373f, -0.01309652f, 0.00618297f, -0.03954979f, 
    0.02231883f, -0.02718720f, -0.03478358f, 0.02884432f, -0.01521405f, -0.00043055f, 0.01772343f, 0.02237278f, 
    0.00794749f, -0.03212025f, -0.03706624f, -0.00895268f, 0.02043186f, -0.03701751f, -0.04262687f, 0.00900361f, 
    -0.03681667f, 0.00332840f, 0.03172037f, 0.02469781f, 0.02502719f, 0.01256197f, -0.02437198f, -0.04582345f, 
    0.02085455f, -0.01791308f, 0.01573674f, -0.03100611f, 0.01873362f, 0.03160795f, -0.04198622f, -0.03948061f, 
    -0.02049686f, 0.03234283f, -0.02383921f, 0.01212720f, -0.03243880f, 0.00461762f, -0.00416545f, 0.02245035f, 
    0.00483599f, -0.04137541f, 0.00373329f, 0.03489305f, 0.02941178f, -0.03402774f, -0.00206407f, 0.00236125f, 
    -0.02078162f, 0.00049415f, -0.00061733f, -0.02244949f, 0.01517379f, 0.03340783f, -0.00430864f, 0.02268002f, 
    0.00397783f, 0.01247049f, -0.03654234f, -0.01015874f, -0.02000809f, -0.01024717f, -0.04036421f, -0.00483163f, 
    -0.01364813f, 0.01911168f, -0.02465724f, -0.01576242f, -0.03038963f, 0.00414978f, -0.02669571f, 0.02457862f, 
    -0.00980636f, -0.02443823f, 0.02772266f, 0.00036935f, -0.02377501f, -0.01977060f, -0.00078348f, 0.03295004f, 
    0.02123729f, 0.00134273f, 0.00447692f, 0.00129720f, -0.02021502f, -0.01257401f, 0.01589460f, -0.03029022f, 
    -0.00873011f, 0.00084722f, -0.03901706f, -0.03427480f, -0.01987205f, -0.03652849f, 0.01186851f, -0.02985247f, 
    -0.00942203f, 0.01360817f, -0.04049414f, -0.02296997f, 0.00624247f, 0.01525848f, -0.00413463f, 0.03058670f, 
    0.02120537f, 0.01626808f, -0.04107198f, -0.04377475f, -0.02580011f, 0.01531101f, -0.03003911f, 0.00592683f, 
    -0.02989102f, -0.04219045f, 0.01264209f, -0.01194637f, 0.00492302f, -0.02106561f, 0.00559175f, 0.01927223f, 
    -0.00591722f, -0.03627264f, 0.00707348f, 0.02091823f, 0.02102864f, -0.00391891f, 0.00231148f, 0.01395379f, 
    -0.01352171f, 0.00580124f, 0.01294891f, -0.01242443f, -0.04042222f, 0.02788527f, -0.03712206f, -0.03332202f, 
    -0.02911988f, 0.03379348f, 0.00608412f, -0.01519791f, 0.01500327f, -0.03044919f, 0.03345266f, -0.01670418f, 
    -0.01397129f, 0.00254250f, 0.00282590f, 0.03627005f, 0.00019841f, -0.00447903f, -0.00303387f, 0.02912809f, 
    -0.00176313f, 0.02461055f, 0.02214978f, -0.00209778f, -0.02151481f, 0.00208905f, -0.02611149f, -0.01470931f, 
    0.02169617f, -0.03435892f, 0.00865108f, -0.00304988f, 0.01880325f, -0.02007234f, -0.02947284f, -0.03993960f, 
    -0.01223228f, -0.02226415f, -0.03136551f, -0.02990412f, -0.00747068f, -0.01905371f, 0.03096260f, -0.02266536f, 
    -0.03544205f, 0.02961509f, 0.01722990f, 0.02199635f, -0.00536074f, -0.00677045f, -0.03974940f, -0.03319814f, 
    -0.04302232f, -0.01469581f, 0.00151697f, 0.01919151f, -0.02256277f, -0.01803681f, -0.01201686f, -0.02717816f, 
    -0.00193816f, -0.02276735f, -0.01401598f, -0.02396186f, 0.01610053f, 0.02341254f, 0.02069110f, 0.00523086f, 
    -0.03186042f, 0.01262668f, -0.02342956f, 0.02496482f, 0.02068038f, -0.03898633f, 0.01693743f, -0.01802885f, 
    -0.02697890f, 0.00259495f, -0.01020088f, 0.01235765f, -0.01134791f, 0.02692593f, -0.03973053f, 0.01870013f, 
    0.02435392f, 0.03379323f, -0.03085721f, 0.03160247f, -0.03042727f, 0.01763217f, -0.03367482f, -0.02527700f, 
    -0.04232541f, 0.00225777f, -0.03451829f, -0.03277237f, -0.02183380f, -0.03666732f, 0.03373048f, -0.03255053f, 
    -0.00845698f, 0.02442809f, -0.01205331f, 0.02394214f, 0.02234313f, -0.00879396f, 0.02382741f, -0.00765163f, 
    -0.03286407f, 0.00352357f, 0.01581455f, -0.02735681f, -0.04482497f, -0.00028769f, 0.01292427f, 0.03344862f, 
    0.03352139f, -0.00221192f, -0.00244581f, -0.04397551f, -0.00634281f, -0.03608451f, 0.02886167f, -0.02449282f, 
    -0.03038464f, -0.01432108f, -0.00187121f, -0.02352297f, 0.00818280f, -0.00128104f, 0.00769283f, 0.01748609f, 
    0.00751389f, -0.03896735f, -0.04452474f, 0.02336385f, 0.00322447f, -0.00630887f, -0.01686629f, -0.00437438f, 
    -0.03531915f, 0.02449475f, -0.01633634f, -0.04280587f, -0.01944273f, 0.00091202f, -0.00893192f, 0.01965373f, 
    -0.01853238f, -0.04352200f, -0.00410916f, 0.01670870f, -0.03043044f, 0.01808566f, 0.00694867f, -0.00705626f, 
    -0.03218111f, -0.02457884f, 0.02689881f, -0.01685023f, -0.01230133f, 0.00594905f, -0.04042185f, -0.02162242f, 
    0.02017258f, 0.01780736f, -0.01880045f, -0.01384834f, -0.04261842f, 0.01783379f, 0.03081271f, -0.03359345f, 
    -0.01186706f, 0.01177297f, -0.01720891f, 0.02478746f, -0.01110883f, 0.01858416f, -0.00842653f, -0.04165100f, 
    -0.04332647f, -0.03626402f, 0.01856969f, 0.00441774f, -0.02434182f, 0.00816446f, 0.01764738f, 0.03150059f, 
    -0.01949471f, 0.00554369f, -0.03484534f, -0.04112030f, -0.03375177f, -0.01533133f, -0.03058638f, 0.00966063f, 
    0.02698546f, -0.04014896f, 0.01273577f, 0.01768554f, 0.00003849f, 0.01338231f, 0.03395908f, -0.00060279f, 
    0.00601963f, 0.02030287f, -0.01937381f, 0.01548319f, -0.03457092f, 0.02181695f, -0.03277574f, 0.01303204f, 
    -0.00344460f, 0.00137820f, -0.01699209f, 0.00580535f, -0.01638582f, -0.01287289f, -0.02813314f, 0.00341263f, 
    -0.00028686f, -0.03947302f, 0.03268287f, 0.01054490f, -0.04479163f, -0.03146202f, -0.01399488f, -0.04142554f, 
    -0.00007733f, -0.00442067f, -0.03747295f, -0.03596532f, -0.02659055f, -0.00092276f, 0.01194457f, -0.03765825f, 
    0.02055224f, -0.00391373f, -0.02694324f, -0.03188217f, 0.03010046f, -0.00659191f, 0.00257782f, -0.01202921f, 
    -0.03008585f, -0.00568523f, -0.00133529f, -0.00932425f, -0.00393221f, -0.02332949f, 0.00417704f, -0.01139923f, 
    -0.03630506f, 0.00967919f, 0.03151451f, -0.03637529f, -0.01865562f, 0.01617972f, 0.01734815f, 0.01948803f, 
    0.03090811f, -0.01554592f, 0.01665127f, -0.02961041f, 0.02738651f, -0.00076481f, 0.02491675f, -0.02298506f, 
    -0.00992838f, -0.03045163f, 0.00792233f, 0.03194074f, 0.02036943f, 0.02861157f, 0.01645289f, 0.01653487f, 
    -0.00691485f, -0.01667740f, -0.01704858f, -0.01159982f, -0.02292997f, 0.03497847f, 0.03285905f, 0.02642186f, 
    0.01728360f, 0.01279745f, -0.02986242f, 0.00451064f, -0.00884304f, 0.04033800f, 0.02947455f, -0.01441344f, 
    -0.04168379f, -0.01987991f, 0.00633425f, 0.02334733f, 0.00307991f, 0.02971888f, -0.03085234f, 0.03639765f, 
    0.03257701f, 0.00086414f, -0.02738926f, -0.03037508f, -0.02747078f, 0.01211409f, 0.01690924f, -0.03199536f, 
    -0.03175222f, -0.04305331f, -0.01432019f, -0.03471356f, 0.02290398f, -0.04108296f, -0.01614765f, 0.01175128f, 
    -0.00066201f, 0.01549151f, 0.01776693f, 0.02747518f, -0.02634124f, 0.02015761f, 0.00045768f, -0.00942906f, 
    -0.03653909f, 0.02859794f, -0.04188288f, -0.00535022f, 0.01374674f, 0.01840200f, 0.01484258f, -0.01011178f, 
    0.02136562f, -0.01926693f, 0.00501518f, -0.02325531f, 0.02550096f, 0.01594283f, -0.03773405f, -0.02760581f, 
    -0.00048520f, 0.02353216f, 0.01429111f, 0.02997334f, -0.02966353f, 0.03232384f, -0.02961724f, 0.01346464f, 
    0.01549719f, 0.00736418f, -0.02573668f, -0.03434752f, 0.02301128f, 0.00790688f, -0.00565894f, -0.01642804f, 
    -0.04134414f, 0.02890048f, -0.00507525f, 0.00812075f, 0.02357720f, 0.03921000f, -0.01687095f, 0.03250558f, 
    0.02146769f, -0.02223923f, -0.02706563f, 0.02910841f, 0.01430144f, -0.03186560f, 0.01974423f, -0.00297042f, 
    -0.03590219f, 0.01184199f, 0.02690247f, 0.01044544f, -0.01178248f, -0.00822598f, -0.00898363f, 0.00368867f, 
    0.03446111f, 0.01716608f, 0.01980891f, -0.01065028f, 0.03086410f, 0.02263841f, 0.02723481f, 0.03040828f, 
    -0.03115863f, -0.01512087f, 0.02463359f, 0.01874587f, 0.01347542f, 0.00747640f, -0.01227643f, -0.00902310f, 
    -0.00603680f, -0.02024703f, -0.01726777f, 0.02976794f, -0.03532662f, 0.01214879f, -0.02604721f, -0.03758277f, 
    0.02118026f, 0.01553534f, -0.02330762f, -0.01282045f, 0.02600474f, 0.00176747f, -0.02330135f, 0.00152153f, 
    -0.03095686f, 0.00482565f, 0.02568422f, -0.03389917f, 0.00493680f, -0.02264014f, 0.02646489f, -0.04324320f, 
    -0.02025421f, -0.02945587f, -0.01416883f, -0.00490178f, 0.02107591f, -0.03733705f, -0.03344330f, -0.00373260f, 
    0.03096333f, 0.02403937f, -0.03526486f, -0.02822991f, 0.01606178f, -0.01260454f, -0.02653249f, -0.03399186f, 
    -0.00868516f, -0.00356537f, -0.01703993f, -0.02126504f, -0.01268211f, 0.01871718f, 0.00518659f, -0.01833479f, 
    -0.04525233f, 0.03157079f, -0.02080821f, 0.01645242f, -0.02833099f, -0.01162030f, 0.01192055f, 0.02696327f, 
    0.03535029f, 0.01499391f, -0.03445026f, -0.02592891f, -0.03966117f, 0.02243230f, -0.02084805f, -0.03550740f, 
    -0.02363400f, -0.03807114f, -0.03030566f, -0.04170223f, -0.01725823f, -0.00475963f, 0.00636414f, 0.02665130f, 
    -0.00455395f, -0.03629003f, -0.01552059f, -0.01413427f, 0.00260267f, -0.01360268f, -0.00824138f, -0.00779590f, 
    0.03937643f, -0.00596918f, 0.02456952f, -0.03140692f, -0.03416180f, -0.02287498f, 0.02953324f, -0.00223540f, 
    -0.00551189f, 0.00893762f, -0.02705001f, -0.01146026f, -0.02451862f, -0.04245733f, -0.02355278f, -0.04112318f, 
    -0.02844723f, 0.03244071f, -0.01404916f, 0.04103776f, 0.01665746f, 0.00046200f, -0.04326305f, 0.02374004f, 
    -0.03242977f, 0.01675870f, -0.03101014f, 0.00080603f, 0.03161311f, -0.02363510f, 0.02050899f, 0.02944825f, 
    -0.00733139f, 0.01555604f, 0.00403173f, -0.03452453f, -0.01752105f, 0.01570216f, -0.01147877f, -0.01793894f, 
    -0.00297262f, 0.02213189f, 0.01953893f, -0.00542352f, -0.01804003f, -0.02665843f, -0.03720867f, 0.00738858f, 
    -0.02304467f, 0.00303325f, -0.03070678f, -0.03284654f, -0.03383081f, -0.02302788f, -0.02348424f, -0.03041226f, 
    0.01041985f, 0.00863327f, 0.02000809f, 0.01823636f, -0.02881991f, -0.02279998f, 0.01846004f, 0.00877615f, 
    -0.03624900f, -0.01251375f, -0.00362873f, 0.01257345f, -0.01582436f, -0.00876194f, -0.00856378f, 0.02524466f, 
    -0.01569895f, 0.01830243f, 0.03463566f, 0.00682069f, -0.03692139f, 0.02231380f, -0.02965608f, -0.03451062f, 
    -0.03028662f, 0.00219263f, -0.03821631f, -0.02642700f, 0.01003624f, -0.01101757f, -0.04254934f, 0.03257487f, 
    -0.03309731f, -0.00787453f, 0.00154737f, 0.03077414f, -0.02816219f, 0.03210714f, -0.00432504f, 0.00829836f, 
    -0.03571721f, -0.01689196f, 0.02606932f, 0.00635342f, 0.02643530f, -0.02443422f, 0.01826085f, 0.01739834f, 
    0.03160021f, -0.02800447f, -0.01964492f, -0.01135145f, -0.03316218f, -0.01442238f, 0.00574618f, 0.02677249f, 
    -0.02307127f, -0.00496047f, -0.00101268f, -0.01924951f, -0.04065888f, -0.01790595f, -0.03850299f, -0.02360700f, 
    -0.03307066f, -0.04070269f, -0.00230475f, -0.00429818f, -0.00806060f, -0.03871237f, -0.02164271f, -0.02398087f, 
    -0.02474210f, 0.00896874f, -0.03967446f, 0.00039500f, 0.02821596f, -0.02357373f, -0.04030397f, -0.02562799f, 
    -0.03787044f, 0.00289919f, 0.00637915f, -0.02131864f, -0.01007168f, 0.02956137f, -0.00463070f, -0.00343744f, 
    0.03628446f, 0.00050257f, 0.00775769f, -0.00233644f, 0.03586309f, 0.00451162f, 0.01420387f, 0.01897716f, 
    -0.02229231f, -0.01182469f, -0.01238683f, 0.00842033f, 0.00425560f, 0.04354792f, 0.01774087f, 0.02470937f, 
    0.01049324f, -0.03235555f, -0.02501883f, 0.02144730f, -0.02937271f, 0.00525390f, -0.03133674f, -0.01310914f, 
    -0.01270143f, -0.02081004f, 0.00604879f, -0.03104132f, 0.03181721f, -0.03945836f, 0.01188151f, -0.00559577f, 
    0.02854033f, 0.03272661f, 0.02670622f, 0.03229476f, 0.02991838f, 0.02982728f, -0.03537830f, -0.02569744f, 
    -0.03724921f, -0.03424677f, -0.01829382f, -0.00487348f, -0.01902563f, -0.01189736f, -0.04320801f, 0.03018460f, 
    -0.02470748f, -0.01199966f, 0.00651204f, 0.02649891f, 0.00009555f, 0.01844412f, 0.02606801f, 0.02321194f, 
    -0.01756316f, 0.00134845f, -0.02549571f, -0.02083182f, 0.02088763f, -0.01839235f, 0.03270256f, -0.03456022f, 
    -0.03661543f, -0.04080299f, 0.01239671f, -0.03514193f, 0.01231803f, 0.03178101f, 0.00957576f, 0.02052947f, 
    -0.02620764f, -0.00378758f, 0.00023084f, 0.00696413f, -0.01477480f, 0.03532851f, 0.01456416f, -0.01612321f, 
    0.03574799f, -0.02772718f, 0.00734887f, 0.02332199f, -0.03795294f, -0.01046861f, -0.03944836f, 0.03081927f, 
    0.02017113f, -0.00730417f, -0.02173608f, -0.01645994f, -0.02239438f, 0.00727325f, -0.03432467f, 0.00651467f, 
    -0.01121662f, 0.00264703f, -0.00582239f, 0.01238537f, 0.01352212f, -0.01057154f, -0.01437286f, 0.02804961f, 
    -0.00765489f, -0.03685851f, 0.03100719f, 0.02998437f, 0.02931549f, 0.03188278f, 0.02971459f, 0.00137852f, 
    0.00027594f, -0.03907508f, 0.03082363f, -0.00125939f, 0.02854044f, -0.03380044f, 0.00924465f, -0.02206691f, 
    -0.03686227f, 0.01576122f, -0.03700693f, -0.02638396f, -0.01220458f, 0.00711562f, -0.00519268f, 0.02013292f, 
    -0.01577345f, 0.03102861f, 0.03092026f, 0.02880168f, -0.03141886f, 0.01611057f, 0.00336488f, -0.02003663f, 
    0.02048043f, -0.02617874f, -0.01376941f, 0.03169429f, 0.02348305f, -0.02322248f, -0.00122560f, 0.03996641f, 
    -0.04151370f, 0.01586432f, 0.01075338f, 0.01508902f, -0.00202290f, -0.00357886f, -0.01519268f, -0.03345700f, 
    -0.00902533f, 0.01504297f, 0.02834266f, -0.02620219f, -0.01761744f, 0.02525696f, -0.01641929f, -0.00566865f, 
    -0.03836819f, 0.02537391f, -0.01813710f, 0.01181811f, 0.02510699f, -0.01142318f, 0.04345423f, 0.00367121f, 
    0.01148167f, -0.00222535f, -0.00069285f, -0.04477279f, -0.01410703f, -0.01709181f, 0.00291171f, -0.02721184f, 
    -0.00057002f, 0.01089547f, 0.03393546f, 0.00119136f, 0.02593330f, -0.00812557f, -0.00012270f, -0.00586821f, 
    0.01937629f, 0.00918248f, 0.01540440f, -0.03939728f, -0.02528590f, 0.00630396f, 0.01306014f, 0.01480974f, 
    0.00481077f, 0.00116803f, 0.01127684f, 0.01274487f, 0.03016117f, -0.01361797f, -0.01797554f, 0.02686446f, 
    -0.02804388f, 0.02845674f, -0.00791892f, 0.01980179f, -0.02808100f, -0.03478848f, -0.01480497f, -0.03943943f, 
    0.02725639f, 0.00689237f, -0.03018158f, -0.00863581f, 0.01512121f, 0.00216744f, -0.00465103f, 0.03795254f, 
    -0.03889899f, -0.01752886f, 0.02821556f, -0.03562365f, 0.03108328f, -0.02201296f, -0.02732916f, -0.03136115f, 
    0.01153334f, 0.01033987f, -0.04381586f, 0.02352833f, -0.03586914f, 0.02241204f, 0.02556472f, -0.04180790f, 
    -0.01289014f, -0.03183779f, 0.01945839f, 0.02198715f, 0.01627093f, 0.00092887f, 0.03189661f, 0.01356410f, 
    -0.01740996f, -0.01413715f, -0.03361886f, 0.01843926f, 0.01438323f, -0.03754216f, -0.01810586f, -0.02429750f, 
    -0.01124678f, 0.03215524f, -0.00176149f, -0.01177599f, 0.01176710f, -0.02132161f, -0.03613202f, 0.00531470f, 
    0.01259124f, -0.00201529f, 0.02571374f, -0.02781316f, 0.00700537f, -0.03758874f, 0.00599283f, -0.00881762f, 
    0.03267112f, -0.02253626f, -0.01409638f, 0.02078394f, 0.01972201f, 0.00564208f, -0.01663715f, 0.02415171f, 
    -0.01711091f, 0.02128936f, 0.02676891f, -0.01608564f, -0.02413823f, 0.02487453f, -0.00239578f, 0.02266757f, 
    0.00601744f, -0.02284479f, -0.00003376f, -0.03860610f, 0.01703159f, -0.04296397f, 0.03104531f, -0.03582184f, 
    -0.00203763f, -0.02233440f, -0.00132948f, -0.02963189f, 0.03151724f, -0.03225724f, 0.03072868f, -0.02384546f, 
    -0.02586106f, -0.02368600f, 0.02422832f, 0.01922870f, -0.03480984f, 0.01414355f, -0.00629946f, 0.01435666f, 
    -0.01047063f, -0.01815944f, 0.02825659f, -0.02139242f, -0.04505357f, -0.00878152f, -0.00369369f, -0.01315414f, 
    -0.03821608f, 0.03173289f, 0.01840885f, -0.01112655f, -0.02351565f, 0.03370849f, 0.02141090f, 0.01392732f, 
    0.02805552f, 0.03962244f, 0.01453541f, -0.04258509f, -0.02083205f, 0.03036769f, -0.03666751f, -0.00232366f, 
    -0.03301205f, -0.04458219f, -0.02029321f, -0.02322760f, 0.02304327f, 0.02567644f, 0.01985285f, -0.03277517f, 
    -0.01792721f, -0.00795007f, -0.04078937f, -0.00511230f, -0.01647716f, 0.04406064f, -0.01548801f, 0.00764659f, 
    -0.02535569f, 0.00958051f, 0.02569863f, -0.02140995f, 0.01654159f, 0.01688867f, -0.01168990f, 0.02557842f, 
    0.03387904f, -0.02690449f, 0.01562586f, 0.00591041f, -0.01963061f, 0.03416315f, -0.00606239f, 0.02453314f, 
    0.01158539f, 0.02449385f, 0.03511679f, -0.02574652f, -0.00418968f, -0.00113577f, -0.03712670f, -0.00576123f, 
    -0.03145174f, -0.00276965f, 0.03393768f, -0.00092342f, -0.02368675f, -0.02000865f, -0.02261067f, 0.02683420f, 
    -0.02243934f, 0.00785694f, 0.00797234f, -0.01413606f, -0.00159933f, 0.02874811f, 0.03268834f, 0.01764251f, 
    -0.00151482f, -0.03157125f, 0.01080691f, -0.01125060f, -0.01390980f, 0.03187718f, 0.03348423f, 0.02228111f, 
    0.03002176f, -0.00725881f, 0.02685841f, 0.01063959f, -0.03738788f, 0.01797756f, -0.02451682f, -0.02237001f, 
    -0.02292539f, 0.00980306f, -0.01780166f, 0.03931216f, -0.01498276f, 0.01033146f, 0.01605984f, -0.04309667f, 
    0.03421680f, -0.01320687f, 0.03548834f, 0.01842911f, -0.00143541f, -0.02834990f, 0.02893117f, 0.02214519f, 
    0.00760948f, 0.00981122f, -0.02986054f, -0.03938194f, 0.00679287f, 0.00710889f, -0.00029497f, 0.03423689f, 
    0.01030948f, 0.03174247f, -0.00895467f, -0.01453792f, 0.03460995f, 0.02805303f, 0.02662950f, -0.02726083f, 
    0.00231055f, 0.03395452f, 0.02163364f, 0.00564134f, 0.03880093f, -0.04440670f, -0.01783249f, -0.03649157f, 
    0.03596118f, 0.02048523f, 0.03952122f, 0.00149867f, -0.03396933f, -0.01625636f, -0.01664862f, 0.01743221f, 
    0.01677353f, -0.01973768f, -0.03465263f, 0.03659033f, -0.01999270f, 0.02284891f, 0.00371355f, -0.01122138f, 
    -0.03910590f, 0.00861337f, -0.00950617f, 0.02867061f, -0.00431906f, -0.03177046f, 0.01473195f, -0.02658704f, 
    -0.04422035f, -0.02190281f, 0.02081048f, -0.00262948f, 0.00294162f, -0.02358275f, -0.02424988f, 0.01415557f, 
    -0.03672327f, -0.00201731f, -0.02811598f, -0.03054010f, 0.02123408f, 0.01053694f, 0.02079063f, -0.04107599f, 
    -0.01862131f, 0.00802189f, -0.01271281f, -0.04232798f, -0.03514282f, -0.01557483f, -0.04183423f, 0.00930237f, 
    -0.00191900f, -0.02032766f, 0.01519319f, 0.00793776f, -0.03101246f, -0.01770980f, 0.01100359f, 0.01205731f, 
    0.01128119f, -0.03963391f, -0.00866176f, -0.01960370f, -0.00507624f, 0.00316124f, -0.04447533f, 0.00225126f, 
    -0.03835705f, -0.01389135f, 0.00134856f, -0.02515093f, 0.00561371f, -0.02513706f, 0.02902793f, 0.00757900f, 
    -0.00772238f, -0.00408601f, 0.03413187f, -0.03384225f, -0.02150754f, -0.02789558f, 0.00288046f, 0.00853517f, 
    -0.03295764f, 0.03704176f, 0.02829441f, 0.00536987f, -0.00811684f, -0.02534005f, -0.01128419f, -0.02090175f, 
    -0.00856968f, 0.02567011f, -0.01342120f, 0.00490841f, 0.01517485f, -0.03788214f, -0.02937954f, -0.01093345f, 
    0.01904462f, -0.03391656f, -0.02600690f, 0.01199706f, 0.02786400f, 0.00792137f, -0.03573733f, -0.02409755f, 
    -0.02606675f, -0.01266944f, -0.04134591f, -0.00957194f, 0.03302754f, 0.00707281f, -0.04246075f, -0.04396372f, 
    -0.00153218f, 0.00892042f, -0.03040894f, -0.01503950f, 0.03991253f, 0.00981145f, -0.02436398f, -0.03593338f, 
    0.01725059f, 0.02209541f, 0.00142842f, -0.00464644f, -0.02936118f, 0.00702083f, 0.01740827f, -0.00306421f, 
    -0.02888419f, -0.01414614f, -0.02981950f, -0.01774728f, 0.03059265f, -0.04156921f, -0.00833048f, 0.01708044f, 
    0.03609753f, -0.00479562f, 0.03214910f, -0.03904904f, -0.01767437f, -0.00553541f, -0.01839692f, -0.00096722f, 
    0.03180716f, -0.03650650f, 0.02392933f, 0.01118306f, -0.03076734f, -0.03654199f, -0.00037048f, 0.02182981f, 
    -0.01130445f, 0.00263179f, -0.04024130f, 0.02023550f, 0.01144717f, 0.00082363f, -0.01047032f, -0.03032666f, 
    0.00812816f, -0.03744003f, 0.01049099f, -0.00001064f, -0.03885815f, 0.03644716f, 0.00663811f, -0.03325216f, 
    -0.01300324f, -0.02575669f, 0.01210546f, 0.00515905f, -0.03006069f, 0.02488588f, 0.00440447f, -0.03321260f, 
    0.02285619f, -0.02547375f, -0.03706050f, 0.02266793f, 0.01718193f, 0.01690228f, 0.02638867f, -0.02680156f, 
    -0.03196587f, -0.02524506f, -0.03332891f, -0.00789280f, 0.01690151f, -0.03843886f, 0.02982773f, -0.00342658f, 
    -0.04294832f, 0.01263532f, -0.02002867f, 0.00324958f, -0.04325261f, -0.03059711f, -0.01719844f, -0.03355397f, 
    -0.02090597f, -0.03391397f, 0.00865031f, 0.01653397f, -0.01838746f, -0.04436548f, 0.00108738f, 0.00644374f, 
    -0.00187465f, -0.04105174f, -0.04502312f, -0.01217964f, -0.00070422f, -0.03012786f, 0.03648800f, 0.01009132f, 
    -0.02754842f, -0.04493494f, -0.01375098f, -0.01490725f, 0.00891499f, -0.02528068f, 0.01918012f, 0.01771301f, 
    0.02364139f, 0.01702124f, -0.00446106f, 0.03176604f, -0.00809476f, -0.00433768f, -0.00346626f, 0.02115675f, 
    -0.04639720f, -0.02098748f, 0.02318923f, 0.00191042f, -0.03037935f, -0.03968869f, 0.01782776f, 0.02520874f, 
    -0.01033974f, 0.00868500f, -0.00153786f, 0.02938747f, -0.00191803f, -0.01465493f, 0.01452423f, -0.04184148f, 
    0.00234488f, -0.02026696f, -0.01849205f, 0.00732170f, 0.03522884f, 0.01261278f, -0.00147473f, 0.01490664f, 
    -0.01913681f, 0.03015686f, 0.01832069f, -0.03201598f, -0.02654797f, 0.04025926f, 0.01303679f, 0.02795926f, 
    0.02753188f, 0.00507313f, -0.02656172f, 0.00738700f, -0.03538029f, -0.02277726f, -0.01238871f, -0.00462421f, 
    -0.00433943f, -0.03412299f, -0.01930136f, 0.02110050f, 0.00834617f, 0.00335577f, 0.03751248f, -0.02063183f, 
    0.00728604f, 0.03328721f, -0.00233886f, -0.01208475f, -0.01084415f, 0.02632283f, 0.00616454f, -0.02505667f, 
    0.00119004f, 0.02689353f, -0.01115453f, 0.03151781f, 0.01926427f, 0.02131682f, -0.03142373f, -0.01870064f, 
    0.00254597f, 0.01189453f, 0.01264331f, -0.01095311f, -0.02825965f, 0.00954724f, 0.01838693f, -0.01802355f, 
    0.01482216f, 0.02452468f, 0.00143112f, -0.04118595f, 0.02514186f, 0.00936596f, -0.01596501f, 0.02606712f, 
    0.00421442f, -0.02966198f, -0.02328143f, -0.03225588f, -0.03667599f, 0.02501909f, -0.02290317f, 0.01827722f, 
    -0.04025110f, -0.02285339f, -0.01230788f, -0.03096138f, -0.00940866f, 0.03201281f, -0.00074800f, 0.02866908f, 
    -0.00955350f, -0.01187588f, 0.00338504f, 0.03517644f, 0.01085094f, 0.00793452f, -0.04257454f, -0.03798517f, 
    0.01010867f, 0.01491846f, 0.02146350f, 0.02570818f, 0.01291921f, -0.01060969f, 0.02634856f, 0.03165327f, 
    -0.01631183f, -0.03517690f, -0.04377482f, 0.01289259f, -0.00206663f, -0.00202514f, -0.02514635f, -0.02110329f, 
    0.00118182f, -0.02397857f, 0.02497681f, 0.03592870f, 0.03712476f, -0.00724765f, -0.04567169f, 0.01824885f, 
    0.01420237f, 0.00226836f, -0.00511687f, 0.03709534f, -0.02440912f, -0.01498014f, -0.03631525f, -0.01000140f, 
    0.02066793f, -0.01547300f, 0.00848486f, 0.03645381f, -0.00234993f, -0.03486857f, -0.01693385f, 0.00427598f, 
    0.00311938f, -0.03061159f, 0.01021045f, -0.02095640f, -0.01610555f, 0.00656281f, 0.03296621f, 0.02817346f, 
    -0.02115578f, 0.02047502f, 0.01207979f, -0.00683281f, 0.00244949f, -0.00965274f, -0.01311271f, 0.00500397f, 
    -0.01130034f, -0.03704657f, -0.02582800f, 0.01038509f, -0.03357304f, 0.01983807f, 0.00186679f, 0.02882574f, 
    -0.03680357f, -0.02144359f, 0.03950957f, 0.00242526f, 0.00615411f, -0.01006267f, 0.02637099f, -0.02919958f, 
    -0.00426081f, 0.02160124f, -0.01863329f, -0.03772222f, 0.02746811f, 0.02656791f, 0.00550662f, 0.01856261f, 
    -0.00806435f, -0.00900334f, -0.04187600f, 0.02595057f, -0.03610298f, 0.00208627f, 0.03230197f, 0.02047042f, 
    0.01617131f, -0.03312298f, -0.01601036f, 0.01797358f, 0.02262222f, 0.03117976f, -0.03353871f, 0.01517737f, 
    -0.00028947f, -0.04268993f, 0.02722904f, -0.03582286f, 0.03023851f, 0.00551883f, -0.02416767f, -0.04347064f, 
    -0.01488891f, -0.01432557f, -0.02448792f, -0.01984685f, 0.02249643f, 0.03196285f, 0.02735763f, -0.02704590f, 
    0.03099074f, -0.01947700f, 0.00835721f, -0.01978783f, 0.00457931f, -0.02500509f, -0.03199942f, -0.01500340f, 
    -0.00987779f, -0.03816716f, -0.03212240f, -0.02245044f, 0.03592042f, -0.03024917f, -0.03228867f, 0.01857373f, 
    0.02951200f, -0.01775396f, 0.03469038f, 0.00898991f, 0.02304346f, -0.00360166f, 0.01107736f, -0.01907337f, 
    -0.02083281f, -0.00620187f, -0.01653253f, 0.02355701f, 0.01240432f, 0.01275491f, -0.03589210f, 0.02784237f, 
    -0.00902794f, -0.02335097f, 0.00919646f, 0.03854477f, -0.02448622f, -0.00668814f, 0.01644809f, 0.02710136f, 
    -0.00056004f, -0.04324958f, -0.01045092f, 0.02726785f, 0.02869056f, -0.00894908f, 0.00966421f, 0.01918329f, 
    0.02298788f, 0.00384047f, -0.01633262f, 0.02535515f, 0.01131861f, -0.02755447f, -0.00387757f, 0.02612738f, 
    -0.03891677f, -0.01888553f, 0.01960808f, 0.00325103f, 0.01574049f, 0.01532001f, 0.03330533f, -0.01375359f, 
    -0.02359924f, 0.01154971f, 0.04711737f, -0.00185701f, -0.02101116f, -0.01195744f, -0.02716352f, -0.00437706f, 
    0.01396294f, -0.04164173f, 0.00859432f, 0.01480489f, 0.00695346f, -0.01896286f, 0.03344980f, -0.02979656f, 
    -0.00245284f, 0.01594894f, -0.02209982f, 0.02766467f, -0.04087052f, -0.02582135f, 0.01999803f, -0.04126846f, 
    -0.13089371f, 0.21310112f, -0.13750732f, -0.36473387f, 0.05800449f, 0.15531157f, -0.08654169f, 0.07092118f, 
    0.02046736f, -0.02209505f, 0.07158363f, 0.14533743f, 0.00861638f, -0.09095651f, -0.00228173f, -0.03322097f, 
    0.13130981f, -0.30393070f, 0.23409921f, 0.13850476f, -0.62017983f, -0.11395469f, 0.27659357f, -0.05754195f, 
    0.26065254f, -0.04403517f, 0.00032667f, 0.01620411f, 0.01655220f, 0.10281283f, -0.12490579f, -0.00118788f, 
    0.06442835f, 0.08361567f, 0.22432908f, 0.09346511f, 0.05185794f, -0.01049283f, -0.04993203f, 0.02217738f, 
    0.52625066f, 0.29291740f, -0.14768670f, 0.32870716f, -0.11942041f, 0.08958539f, -0.01694387f, -0.10188077f, 
    0.02251681f, 0.02094490f, 0.24081220f, 0.15827210f, 0.08864419f, 0.02944262f, 0.01181714f, 0.14761597f, 
    0.04668997f, -0.06484683f, 0.10262398f, -0.04497171f, 0.13917020f, 0.03895238f, -0.19916673f, -0.07026796f, 
    0.08885524f, -0.02598330f, -0.13201687f, 0.02822031f, 0.08369125f, 0.05123076f, 0.22300339f, 0.20749842f, 
    0.16374168f, 0.06987351f, -0.08855236f, 0.06482293f, 0.06912591f, -0.00422379f, 0.10429715f, 0.09398169f, 
    -0.43549943f, 0.00062133f, 0.03622543f, -0.09406304f, 0.17130975f, 0.13666867f, -0.17483385f, 0.18712652f, 
    -0.04426125f, -0.00752363f, 0.01462192f, -0.01867582f, 0.04528516f, 0.06232498f, -0.00217540f, 0.10649008f, 
    0.02068175f, -0.05466488f, -0.02076778f, 0.10587370f, 0.48323968f, -0.37314683f, 0.15408343f, 0.13160466f, 
    0.08432233f, -0.27910817f, 0.06860010f, 0.16972873f, 0.08366911f, -0.25851113f, 0.12791090f, -0.03845562f, 
    -0.09581356f, -0.05042819f, 0.16744427f, -0.02717380f, 0.27904472f, -0.05043611f, 0.09598441f, 0.25269356f, 
    0.06114529f, 0.23608917f, -0.17528731f, -0.22952203f, 0.01504413f, 0.07111839f, 0.04779618f, -0.07954806f, 
    0.04342292f, -0.22907172f, 0.12185430f, -0.04219737f, -0.00534748f, 0.22537167f, 0.04296960f, -0.07586847f, 
    0.06603908f, 0.00257677f, -0.09517062f, -0.12028051f, 0.46563634f, 0.25492752f, -0.21334499f, 0.42120063f, 
    0.12747923f, 0.14345829f, 0.02314564f, 0.07053199f, 0.05799045f, 0.00469655f, 0.07423734f, 0.03805469f, 
    0.02529329f, 0.13609630f, 0.00731193f, 0.21297562f, 0.00604017f, 0.03521003f, 0.05651733f, 0.09350564f, 
    -0.14851201f, -0.22008389f, -0.14635862f, -0.01017920f, -0.08007153f, 0.00733696f, 0.04690757f, 0.06247541f, 
    0.06088566f, 0.10839223f, 0.11038166f, -0.03867238f, 0.03472386f, -0.01876494f, 0.05963000f, -0.05721527f, 
    -0.02790263f, -0.03516121f, -0.11329699f, -0.02753841f, 0.13092382f, 0.11412681f, -0.19268949f, 0.03157348f, 
    0.25360349f, 0.20269281f, 0.28868985f, -0.01766946f, 0.12701365f, 0.08897985f, 0.20898034f, 0.07313059f, 
    0.00851112f, 0.08748370f, 0.04545998f, 0.12764362f, 0.16085501f, 0.24224439f, -0.08581511f, 0.17196847f, 
    -0.37362882f, -0.20539163f, 0.20299241f, -0.14356634f, 0.13784492f, -0.10483972f, 0.04489103f, 0.10158209f, 
    0.07588971f, 0.02052660f, -0.06221129f, -0.04479956f, 0.04127685f, -0.01122031f, 0.10491140f, -0.02283966f, 
    -0.01823141f, 0.14222617f, -0.02172640f, -0.06532613f, 0.30308086f, 0.15271628f, -0.09397928f, 0.18115579f, 
    0.24580917f, 0.15650935f, 0.09913477f, -0.08411769f, 0.06983127f, 0.01475446f, 0.15405233f, 0.02401727f, 
    0.08372898f, -0.00126100f, 0.15081653f, 0.02894922f, 0.16971603f, 0.07674444f, 0.12884003f, -0.04768300f, 
    -0.12217008f, -0.26847056f, -0.00408487f, 0.07077347f, 0.07502022f, -0.00960161f, 0.03049915f, -0.01919900f, 
    0.12534058f, 0.01551553f, -0.09368505f, 0.00442673f, 0.09995421f, 0.01594410f, 0.04776027f, 0.16985171f, 
    0.09608404f, 0.00115632f, 0.00017237f, 0.12277242f, -0.09101849f, 0.14676450f, -0.05902635f, -0.05508584f, 
    0.22728828f, 0.14422549f, -0.02735537f, 0.13849698f, 0.03044003f, -0.00219052f, 0.11016447f, 0.05255269f, 
    0.12109077f, 0.04089934f, -0.00245079f, 0.06238187f, 0.07117099f, 0.09379646f, 0.18073927f, 0.06845883f, 
    -0.52152359f, 0.21289892f, 0.03631914f, 0.07373073f, 0.12266015f, 0.03088479f, -0.08547613f, 0.21258903f, 
    -0.21698129f, -0.07587149f, -0.03045374f, -0.07160382f, 0.14117649f, 0.03897785f, 0.11229516f, 0.03901161f, 
    -0.05068627f, 0.12995867f, 0.10301512f, 0.06198192f, 0.10093057f, -0.03064629f, -0.26031974f, -0.15458940f, 
    -0.00239020f, 0.07608589f, -0.21134782f, 0.07563714f, 0.05202604f, -0.18463634f, -0.02581184f, 0.13368249f, 
    0.06892460f, -0.02765107f, -0.01976389f, 0.04442608f, -0.00181774f, 0.16458225f, 0.00369861f, -0.09678990f, 
    0.33090076f, -0.20044163f, -0.06004142f, 0.01464868f, -0.04785221f, -0.00412129f, 0.00952429f, 0.07923045f, 
    -0.00741263f, -0.01609845f, -0.06621546f, -0.08384555f, 0.11228257f, 0.08908027f, -0.00293162f, 0.02306351f, 
    0.05391912f, -0.03528019f, 0.03315197f, 0.03547917f, -0.35723653f, 0.26746511f, -0.00892838f, -0.22168995f, 
    0.10728385f, 0.00505299f, 0.13218515f, 0.09670674f, -0.15578805f, 0.06553970f, 0.15039003f, 0.00638723f, 
    0.09737807f, 0.09130103f, -0.02703200f, -0.04041171f, 0.14162709f, -0.13352339f, -0.01095082f, -0.06518042f, 
    -0.02011622f, -0.04582305f, 0.05470090f, 0.13686185f, 0.21173449f, 0.07077174f, 0.01395393f, 0.05052659f, 
    0.09959313f, -0.02623494f, 0.11068527f, -0.04150846f, 0.21866900f, 0.13073467f, -0.02925135f, -0.11042137f, 
    0.11322116f, 0.24767666f, 0.12951714f, -0.01776202f, -0.42414626f, 0.32106072f, -0.25976601f, 0.32642180f, 
    0.01295313f, 0.12874305f, 0.25031322f, 0.04844982f, 0.03326422f, 0.03970889f, 0.06487922f, 0.03373853f, 
    0.09816369f, 0.03626083f, 0.03756483f, 0.01622487f, 0.19570719f, -0.03714399f, 0.14651296f, 0.06332453f, 
    -0.18662372f, -0.11115380f, 0.10699736f, 0.14357114f, 0.08688496f, 0.28645033f, 0.14162816f, -0.02909407f, 
    0.05813084f, 0.05273100f, -0.09476245f, 0.12776932f, 0.05001657f, 0.07840198f, 0.17161904f, 0.05053403f, 
    0.04235678f, 0.07112881f, 0.10375233f, -0.07560776f, -0.03566343f, 0.16791585f, 0.02491373f, -0.00960149f, 
    -0.16376552f, 0.13519995f, 0.00847443f, 0.12624775f, -0.06536464f, -0.21422751f, 0.03077991f, -0.09575577f, 
    0.07124883f, 0.01114128f, 0.09118456f, 0.28318852f, -0.03294355f, 0.00190807f, 0.14235672f, 0.09492755f, 
    0.37083900f, -0.06560630f, 0.17579448f, 0.04021931f, 0.27881777f, -0.17467327f, -0.03048432f, -0.01290543f, 
    -0.01913045f, -0.03048147f, 0.04886634f, 0.05092935f, 0.03796124f, 0.04126879f, 0.10695186f, 0.02107397f, 
    0.09082992f, 0.03197908f, 0.02543628f, 0.12966907f, -0.53377855f, 0.24979496f, -0.03808855f, -0.39583391f, 
    0.05994524f, 0.02566165f, -0.10646988f, 0.15327466f, -0.05955037f, -0.05999739f, -0.03820850f, -0.07377528f, 
    -0.01382666f, -0.00582390f, 0.13279001f, 0.09206711f, 0.07742550f, 0.11854616f, 0.00633207f, 0.03385938f, 
    0.00136700f, 0.30574936f, -0.16940096f, -0.21301439f, 0.05126184f, 0.16806835f, 0.00526226f, -0.00162697f, 
    0.06739196f, 0.03756395f, 0.16043589f, 0.00486600f, 0.04895168f, 0.10063853f, 0.03702128f, 0.07265656f, 
    0.00642569f, 0.11624694f, 0.08389492f, 0.14765561f, 0.41089457f, -0.07030757f, -0.23551215f, 0.31303361f, 
    -0.12799852f, 0.08574910f, 0.04330009f, -0.00259833f, 0.09124809f, -0.00504237f, 0.01551481f, 0.06420596f, 
    0.01967325f, 0.06616636f, 0.10569157f, -0.03037878f, -0.00655993f, 0.08804610f, -0.05479844f, 0.07757255f, 
    -0.04264061f, -0.12314418f, 0.30201182f, -0.12495280f, 0.15420572f, 0.03987890f, 0.05859533f, 0.03304293f, 
    0.15052705f, 0.05816071f, -0.04847778f, -0.01448267f, -0.07290098f, -0.09869389f, 0.06722867f, -0.07873976f, 
    0.00877444f, -0.05611833f, 0.03382621f, 0.07571817f, -0.14710459f, -0.21665558f, 0.07009853f, 0.06033013f, 
    0.00526005f, -0.05235721f, -0.08559462f, -0.06740626f, 0.18059216f, -0.08954777f, -0.00042520f, 0.10874639f, 
    -0.01321390f, 0.01554622f, 0.09875217f, -0.01489604f, 0.02300394f, 0.08932447f, -0.04598266f, 0.11965960f, 
    0.15485111f, -0.40960115f, -0.09814764f, -0.48661375f, 0.07494466f, -0.22722052f, 0.01305274f, -0.00088138f, 
    0.05827996f, -0.25665164f, -0.02599778f, 0.09643476f, 0.02476799f, 0.00226642f, -0.02551264f, -0.14570473f, 
    0.15420730f, 0.05582666f, -0.08100203f, 0.06184478f, -0.13109119f, -0.39517820f, -0.08313181f, -0.03307688f, 
    0.04892660f, -0.11835874f, -0.04651221f, 0.11070470f, -0.00541741f, 0.15847968f, -0.07990427f, 0.01527533f, 
    0.05390917f, 0.06528611f, 0.10109578f, 0.01647167f, -0.03577087f, 0.03938904f, -0.04839148f, -0.08762383f, 
    -0.37792498f, 0.20111525f, -0.08909567f, -0.11747819f, 0.34711501f, 0.16242030f, -0.08605022f, 0.04744740f, 
    0.00841316f, 0.15195665f, 0.04155526f, 0.06090958f, 0.02963136f, 0.09780052f, 0.24285175f, 0.20003858f, 
    -0.02166331f, 0.00302214f, 0.16681089f, -0.11846600f, 0.02033895f, -0.06389498f, -0.50064176f, 0.26117104f, 
    -0.44106126f, -0.00033476f, 0.18876824f, -0.01307530f, 0.03959041f, 0.19305010f, -0.03276032f, -0.07110979f, 
    0.06023508f, -0.14490728f, 0.01179526f, -0.14319211f, -0.01404636f, 0.06065890f, 0.02068453f, 0.07154702f, 
    0.00425327f, -0.02453589f, 0.02413590f, 0.01254947f, -0.03328699f, 0.02208052f, 0.01805138f, -0.01995953f, 
    -0.00444596f, 0.02964669f, -0.00109064f, -0.03871217f, -0.03806898f, -0.00728549f, 0.02944321f, -0.02506140f, 
    0.00497767f, 0.03017124f, -0.01241952f, -0.02325986f, 0.02638042f, -0.04019916f, -0.00365360f, -0.01855319f, 
    -0.03185088f, 0.01440728f, 0.01025093f, -0.00235386f, -0.02469005f, -0.03829491f, 0.00605435f, -0.03212948f, 
    0.00548582f, -0.02804678f, -0.00325276f, -0.03182416f, -0.04239979f, 0.01722964f, 0.02495562f, -0.00842373f, 
    0.00329352f, 0.02813475f, 0.01245487f, -0.03614487f, -0.02639526f, -0.00549158f, 0.03138721f, 0.03416706f, 
    0.00797010f, 0.00302438f, -0.00474884f, 0.00804318f, 0.03860265f, -0.01161736f, -0.00891294f, -0.00514515f, 
    0.01977940f, 0.00671106f, -0.02745549f, -0.00464122f, 0.00952172f, -0.02225947f, 0.01427983f, -0.03232641f, 
    -0.01624651f, -0.04095472f, -0.02265862f, -0.00124212f, 0.00522722f, 0.00641106f, 0.02256302f, -0.00101083f, 
    -0.01862337f, 0.02464434f, 0.03843108f, -0.03885875f, -0.03322883f, 0.03476978f, -0.00501952f, 0.01419172f, 
    -0.02402757f, 0.01602593f, -0.03848579f, 0.02661172f, -0.02819262f, 0.03351009f, 0.03095225f, -0.02745470f, 
    0.01509905f, -0.01444937f, -0.01971173f, -0.00319624f, -0.01134753f, -0.00238377f, -0.01366994f, -0.00163378f, 
    0.03270421f, -0.04487013f, -0.02081466f, -0.03087457f, -0.02595244f, -0.04359652f, -0.02238519f, 0.00241535f, 
    -0.01945929f, 0.01223509f, -0.00109276f, 0.02298954f, 0.01019011f, 0.00345991f, 0.00572876f, 0.01096942f, 
    -0.01559645f, 0.00389618f, -0.02553442f, -0.02712845f, -0.02286315f, -0.04076404f, 0.03133125f, 0.01325402f, 
    -0.01188717f, 0.02550429f, 0.01151905f, -0.01395992f, -0.02889330f, -0.03454484f, 0.03724665f, 0.02816341f, 
    -0.01067907f, 0.01723113f, 0.00126795f, -0.03488802f, 0.02911286f, -0.00222613f, -0.02450389f, -0.00882349f, 
    -0.00674384f, 0.00543699f, -0.01931523f, 0.03015702f, 0.00116456f, -0.04466527f, 0.02865358f, -0.02601484f, 
    0.02382841f, 0.02475150f, -0.03354732f, -0.02959995f, 0.01709707f, -0.03524330f, -0.04188139f, 0.00692528f, 
    0.03155784f, -0.01283891f, -0.03544755f, -0.00696450f, -0.02651520f, -0.02474870f, 0.02693302f, -0.01364908f, 
    0.00790893f, 0.00467198f, -0.02637009f, -0.01650522f, -0.03591095f, 0.00718862f, 0.02217219f, 0.03675302f, 
    0.02118300f, 0.03105709f, -0.03659635f, -0.02344558f, -0.03832338f, -0.00048983f, -0.00911738f, 0.03266291f, 
    0.00225599f, -0.01002917f, -0.03294738f, 0.02393026f, 0.00423613f, -0.03650244f, -0.00001728f, 0.01839836f, 
    -0.03416769f, -0.03795738f, -0.00414307f, -0.02028052f, -0.03086333f, -0.00158213f, -0.03071647f, 0.01751710f, 
    -0.00036033f, 0.01773077f, -0.04184934f, -0.02391796f, 0.00089726f, -0.00241243f, -0.03814015f, -0.01601105f, 
    -0.00662839f, -0.01847884f, -0.00922437f, -0.03260301f, 0.01822745f, 0.00235509f, -0.02736515f, -0.02114704f, 
    -0.04454235f, -0.02683100f, 0.00086163f, -0.00498559f, -0.01585532f, 0.01083062f, 0.01156524f, 0.01493842f, 
    -0.01473960f, -0.01853028f, -0.04366733f, 0.00494753f, -0.04156239f, -0.02255359f, -0.02926902f, -0.02750545f, 
    -0.04100888f, -0.03657179f, 0.00546408f, 0.02476369f, 0.00839997f, -0.00076405f, 0.01081584f, -0.01596673f, 
    -0.03084081f, 0.00909511f, 0.00575864f, -0.02379875f, 0.01274673f, -0.00995955f, 0.01712234f, 0.01026027f, 
    -0.01703002f, 0.02355878f, 0.01613001f, -0.03405559f, -0.01585118f, -0.00205756f, 0.02339844f, -0.03974646f, 
    -0.04062840f, -0.01215840f, 0.00119607f, -0.03671888f, -0.00583579f, -0.03660630f, -0.02305055f, -0.02820964f, 
    -0.02117994f, 0.02133573f, 0.00506522f, -0.02396668f, 0.02670275f, 0.02789282f, 0.00999155f, -0.03228886f, 
    0.03351274f, -0.02742654f, 0.00298068f, 0.02327153f, 0.03393425f, -0.00767960f, -0.00055226f, 0.02612714f, 
    0.00637079f, 0.01398454f, -0.03235861f, 0.02983633f, -0.00955445f, 0.01166619f, 0.01221609f, -0.03135294f, 
    0.03156925f, 0.00234448f, 0.01381102f, -0.01738056f, -0.03041867f, -0.04267964f, -0.03260452f, -0.02955138f, 
    -0.01228071f, 0.00294852f, -0.02263721f, 0.00328010f, -0.00252459f, -0.01031837f, 0.00822170f, -0.03221336f, 
    0.01420914f, -0.03719130f, -0.02169999f, 0.02010314f, -0.03752638f, 0.01453778f, -0.04161159f, -0.00974616f, 
    -0.01371650f, -0.03412762f, 0.02887792f, -0.03301654f, 0.01833805f, 0.02059039f, 0.01967781f, -0.02425152f, 
    -0.01413406f, -0.01935996f, 0.00082852f, -0.03970431f, -0.03932732f, -0.01491986f, 0.01265611f, 0.03291686f, 
    0.00677180f, -0.03841585f, 0.02179534f, -0.01035883f, -0.03489834f, 0.01493827f, -0.00441652f, 0.01250621f, 
    0.02015435f, -0.03104915f, -0.00894041f, -0.00945523f, -0.00052119f, -0.03178259f, -0.03389114f, -0.00440090f, 
    -0.02790127f, 0.02445919f, 0.00655957f, -0.01744599f, 0.01613826f, -0.01081575f, -0.02899928f, -0.02798069f, 
    -0.01344000f, -0.03063051f, 0.02561704f, -0.03560830f, -0.00847192f, 0.01460972f, -0.01559511f, 0.00500957f, 
    0.02789378f, -0.04041598f, 0.02355682f, 0.00470738f, -0.04226813f, -0.01550743f, 0.02799662f, -0.01941827f, 
    -0.03154011f, -0.02991951f, -0.03890138f, -0.03143422f, -0.00505232f, 0.03124680f, 0.02622284f, -0.01888412f, 
    -0.03894491f, 0.03889108f, -0.02596471f, -0.00775917f, 0.02808334f, 0.01298121f, 0.03112917f, -0.01199384f, 
    -0.04265029f, -0.04053697f, -0.01236221f, -0.03578191f, 0.02902671f, -0.04403483f, -0.00322200f, 0.03396083f, 
    0.02020122f, -0.02039010f, -0.04458230f, -0.01895490f, -0.02449333f, 0.02945268f, 0.00196650f, 0.01860922f, 
    -0.02456680f, -0.02596363f, 0.02193674f, -0.01282259f, -0.04190982f, 0.02053881f, -0.01829321f, 0.01601199f, 
    -0.03454855f, 0.02648949f, -0.03142900f, -0.02047998f, 0.02607670f, 0.01702356f, 0.02122389f, -0.01222047f, 
    -0.02026226f, -0.00775549f, -0.00156801f, 0.00713172f, -0.04139255f, 0.03253297f, -0.03982950f, -0.03987272f, 
    -0.01837838f, -0.00394307f, -0.01654994f, -0.03938243f, 0.02625406f, 0.02666184f, -0.04030875f, -0.03493564f, 
    -0.01387645f, 0.01355551f, 0.01782005f, -0.03690370f, 0.00015421f, 0.03247938f, -0.04416044f, -0.04418861f, 
    -0.01710676f, -0.02770484f, -0.02963111f, 0.02936479f, 0.01374374f, 0.03087485f, 0.01246273f, -0.01475660f, 
    0.02499449f, -0.02981802f, -0.03471277f, 0.00074292f, 0.01112368f, 0.01060783f, 0.01768099f, -0.04457660f, 
    -0.03597710f, 0.00734371f, 0.01976192f, -0.00653326f, -0.02882891f, -0.01908652f, -0.02840704f, -0.02604688f, 
    0.01161719f, -0.01880868f, -0.01502665f, -0.00536539f, -0.02014263f, -0.00815454f, -0.02923151f, 0.02949613f, 
    0.01160847f, 0.02178694f, 0.01586753f, -0.01643586f, -0.00681334f, -0.02276269f, -0.01667856f, -0.04351994f, 
    -0.02770634f, -0.01777254f, 0.02623039f, -0.03474751f, -0.01894216f, -0.00997851f, -0.03502772f, 0.01492980f, 
    -0.01517498f, 0.00287049f, 0.02340010f, 0.00410110f, -0.03660905f, 0.02427582f, -0.00407263f, -0.01281984f, 
    0.01202187f, 0.00469905f, -0.03142627f, 0.01581726f, -0.03990169f, -0.00617281f, 0.01141495f, 0.00557694f, 
    -0.01990639f, 0.01415056f, 0.01599655f, 0.02092541f, -0.02786944f, -0.02327020f, -0.00419234f, -0.03990195f, 
    -0.00842192f, -0.00570605f, -0.03626679f, -0.02825391f, 0.01339545f, -0.02608237f, -0.03166826f, 0.02345078f, 
    0.00175109f, -0.00534708f, 0.01594423f, -0.03494238f, 0.02989286f, 0.03058393f, -0.01654703f, -0.01166434f, 
    -0.01768917f, 0.00840945f, -0.01387980f, -0.03315029f, 0.03227789f, -0.01609042f, 0.02743322f, -0.03583499f, 
    0.02545026f, -0.03956047f, -0.03109931f, 0.02639362f, -0.01653222f, -0.03505329f, -0.00299185f, -0.01445683f, 
    -0.02007964f, 0.01312612f, 0.02366602f, -0.04286491f, 0.02769359f, -0.01221406f, 0.02753721f, -0.03099309f, 
    0.01982120f, 0.00387463f, 0.03038652f, 0.00876034f, 0.01659718f, -0.00911578f, 0.00126186f, 0.00976056f, 
    0.00787389f, 0.00882893f, -0.02868344f, -0.00878061f, -0.03772432f, -0.00067780f, 0.01506813f, 0.00555925f, 
    -0.03854856f, -0.00998430f, -0.00434692f, 0.01084458f, -0.03334527f, -0.02929158f, -0.03571547f, -0.04165506f, 
    -0.00587248f, 0.01939609f, -0.02318374f, -0.00186797f, -0.02960674f, -0.00913834f, -0.02678274f, 0.02368135f, 
    -0.01554223f, -0.01209327f, 0.01436844f, -0.04341857f, -0.00346250f, 0.00042683f, -0.04212229f, 0.03110577f, 
    -0.01363272f, -0.03667096f, -0.02170341f, -0.00497224f, -0.00169846f, 0.01084492f, -0.02056031f, -0.01643264f, 
    -0.00340419f, -0.03591119f, -0.02788396f, -0.03535766f, -0.03609151f, 0.03266291f, 0.01208730f, -0.02119626f, 
    0.00131137f, 0.02856510f, -0.03087765f, 0.02466268f, 0.01515804f, -0.02984756f, -0.00590441f, -0.03220955f, 
    -0.02880560f, -0.00906826f, -0.03429027f, -0.00472472f, -0.00415094f, -0.01794482f, 0.01251105f, 0.01420566f, 
    -0.04067449f, 0.01744814f, 0.00409058f, -0.03769496f, 0.00584669f, -0.00600647f, 0.00946787f, -0.01446744f, 
    -0.01618988f, -0.03398031f, 0.00465819f, 0.00234769f, -0.01634676f, 0.02528928f, 0.01938134f, 0.01845051f, 
    0.01740321f, 0.03143813f, -0.02475791f, -0.03654606f, -0.02068213f, 0.00435239f, 0.03370849f, -0.01109663f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.06086089f, 0.05955572f, -0.05266368f, -0.01811052f, 0.02225054f, 0.00720523f, 0.00013017f, -0.03846367f, 
    0.00141760f, 0.09428954f, -0.04621993f, 0.08395500f, 0.00310548f, -0.04481763f, -0.02307190f, -0.04092688f, 
    -0.02137239f, 0.02477952f, -0.01581026f, 0.02910594f, 0.02646516f, -0.04153544f, 0.02019809f, 0.06187272f, 
    0.02968294f, -0.03581550f, 0.00575682f, -0.03723451f, -0.03031815f, -0.02782448f, 0.14020790f, 0.01502809f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04769612f, -0.09778388f, -0.17157844f, 0.09441286f, -0.02532431f, -0.11234980f, -0.15556069f, -0.10877764f, 
    0.08512675f, -0.05588965f, -0.14822355f, -0.02312555f, -0.01871936f, 0.03186731f, 0.01417687f, 0.10864948f, 
    -0.07942776f, -0.05301301f, 0.02926623f, 0.14945494f, 0.16001958f, 0.00637494f, -0.13419189f, 0.14024669f, 
    -0.04569732f, 0.02990355f, -0.01953057f, 0.06729933f, 0.08303034f, -0.16648644f, -0.09389000f, -0.17469727f, 
    -0.29269251f, 0.22598456f, -0.36629978f, -0.13389592f, 0.10086115f, -0.11227236f, -0.48597938f, 0.00926790f, 
    -0.04829545f, 0.45887759f, 0.04988282f, -0.09177864f, -0.20887829f, 0.23014618f, -0.07886136f, -0.03385326f, 
    -0.00213763f, -0.06107688f, 0.04862183f, 0.01506254f, -0.12534606f, 0.11060162f, -0.14892501f, -0.04085074f, 
    0.00471852f, 0.09670085f, 0.09820187f, -0.10270988f, -0.05201998f, 0.05420731f, 0.38355100f, -0.10708822f, 
    -0.04760254f, -0.09300244f, -0.11035590f, 0.14883129f, 0.09132803f, 0.04213800f, 0.17070431f, -0.05083058f, 
    0.16166422f, -0.17085236f, -0.01280192f, -0.10781486f, -0.09764232f, -0.10782190f, 0.12299275f, 0.06474369f, 
    -0.10318319f, 0.01520465f, 0.06127916f, -0.10306982f, -0.03552484f, 0.16834053f, 0.16709676f, 0.01653163f, 
    -0.06924739f, -0.04342172f, 0.01429063f, 0.05453869f, -0.13162248f, -0.00525811f, 0.03346716f, -0.08554569f, 
    -0.12585728f, 0.12065188f, -0.03183868f, -0.07302955f, -0.01713354f, 0.01534731f, -0.18023214f, -0.05376623f, 
    -0.12196603f, -0.09800057f, -0.13662605f, -0.15054066f, -0.11403050f, -0.19378741f, -0.13502190f, -0.12229785f, 
    -0.17249808f, 0.11877821f, -0.05186966f, -0.00296345f, -0.10812908f, -0.13043398f, -0.12594239f, -0.05655131f, 
    0.01677504f, 0.02413436f, -0.03194459f, -0.01800800f, 0.06720602f, 0.04608221f, 0.08811074f, -0.06123073f, 
    -0.43407699f, -0.20841777f, -0.22624744f, 0.09238684f, -0.13244331f, -0.11848010f, -0.16951312f, -0.00223909f, 
    -0.04332594f, 0.03291527f, 0.15675929f, 0.36823362f, 0.27447215f, 0.04496474f, 0.15657571f, 0.10408946f, 
    -0.00102578f, -0.02126605f, 0.15919301f, -0.04401552f, 0.13316020f, -0.00486849f, 0.10777152f, -0.37481904f, 
    0.01203954f, -0.13172758f, -0.01764707f, -0.08160122f, -0.05029254f, 0.08265276f, 0.16196552f, -0.16700526f, 
    0.10529594f, 0.34806845f, -0.19978493f, 0.14086704f, 0.10697116f, -0.06792510f, 0.54814672f, 0.13813975f, 
    -0.13265745f, -0.33660966f, 0.09847748f, 0.05285155f, 0.05839529f, 0.26149881f, 0.09446542f, 0.14475793f, 
    0.13537809f, 0.14238733f, 0.08053327f, 0.12442240f, 0.07019939f, 0.12983303f, 0.09787419f, -0.13944298f, 
    0.04245148f, 0.11003405f, 0.05071978f, -0.12716655f, 0.00365739f, -0.08126780f, 0.01402526f, -0.07793361f, 
    0.59559959f, -0.01889598f, 0.39852610f, 0.15844707f, -0.00816610f, 0.08634043f, -0.31557107f, 0.08270359f, 
    -0.08740657f, 0.11572517f, -0.01069666f, 0.14113408f, -0.05306982f, -0.27835396f, 0.08373622f, -0.11237854f, 
    -0.14556280f, -0.11402485f, 0.00715165f, -0.15353230f, -0.14429498f, 0.03779488f, -0.11199853f, 0.55192423f, 
    -0.14723925f, 0.02578407f, -0.05895889f, 0.09353407f, -0.17352007f, -0.11896005f, 0.04357333f, -0.12629022f, 
    0.14571287f, 0.26768523f, 0.27965477f, -0.06849549f, -0.02872059f, 0.12564188f, -0.04625893f, -0.08057808f, 
    0.14713448f, -0.05412971f, 0.04283338f, -0.21901932f, -0.78861135f, 0.00239610f, -0.05668526f, 0.11539713f, 
    -0.06352385f, 0.14614019f, 0.02775506f, 0.01766576f, -0.10851932f, 0.15956834f, -0.14177898f, 0.01194550f, 
    -0.08356560f, -0.14286801f, -0.14815904f, 0.13106109f, -0.00670618f, 0.14798720f, 0.07066260f, -0.14953668f, 
    0.03300090f, 0.34604526f, -0.22499973f, 0.00598876f, 0.03272010f, -0.15639845f, 0.08386198f, -0.08406894f, 
    0.04632154f, -0.05539366f, -0.00281094f, 0.13752191f, -0.69666171f, 0.28752458f, 0.08999198f, -0.11710075f, 
    0.15819573f, -0.00236998f, 0.13121273f, 0.11906783f, -0.14756125f, -0.01324170f, 0.05768279f, -0.00014133f, 
    0.10831150f, -0.02374219f, 0.07913815f, -0.13449664f, 0.07573945f, -0.03029304f, -0.14155942f, -0.05511834f, 
    -0.52704167f, 0.15357916f, -0.11973305f, 0.02050012f, 0.08542447f, -0.08273615f, 0.57203108f, -0.07655807f, 
    0.00175048f, -0.14199285f, -0.02365515f, 0.20037691f, 0.28819129f, 0.28598803f, 0.13062567f, 0.04125216f, 
    0.14024734f, -0.12395944f, -0.15612048f, -0.12451182f, -0.14310060f, -0.11475728f, -0.00004834f, -0.08400339f, 
    -0.14897509f, 0.16895360f, 0.11028693f, -0.09721467f, 0.01337336f, -0.05724455f, 0.13013846f, -0.06166642f, 
    -0.26189902f, 0.25051194f, 0.37175480f, 0.04826585f, -0.13994919f, -0.17023478f, 0.13123681f, -0.06299347f, 
    0.00528788f, -0.25296539f, 0.09155405f, 0.23471160f, 0.28189346f, 0.03924600f, 0.04777110f, 0.13156453f, 
    0.10745785f, -0.08241861f, -0.04168380f, -0.02941770f, -0.09930255f, 0.04176778f, 0.11539896f, 0.59835553f, 
    0.03932169f, -0.11741573f, -0.08372360f, 0.01932692f, -0.11813311f, 0.11285729f, -0.21050321f, 0.02504587f, 
    -0.02150274f, -0.06518607f, 0.07482065f, 0.06767635f, -0.11516123f, 0.03575966f, -0.16574290f, -0.09061936f, 
    0.09741484f, -0.05721565f, -0.11793223f, -0.09052069f, 0.09101331f, -0.01912424f, -0.16312952f, -0.06837349f, 
    -0.12603500f, 0.05080016f, -0.15466785f, -0.11091819f, 0.13838370f, 0.01020329f, -0.13564542f, 0.10572138f, 
    0.16734286f, 0.13733681f, -0.01748446f, 0.04108548f, -0.05185791f, -0.12162404f, -0.06630690f, 0.00081607f, 
    -0.16434222f, -0.07481887f, 0.04910701f, -0.16531394f, 0.06974366f, 0.16366185f, -0.15069760f, -0.14809905f, 
    -0.12112994f, -0.17360474f, 0.00679728f, -0.05579226f, 0.02358934f, -0.00317807f, 0.03798383f, 0.12759399f, 
    0.16372712f, -0.11504549f, 0.09109546f, -0.01018923f, 0.10255808f, 0.05569845f, -0.11848153f, -0.10898742f, 
    0.05995014f, -0.00520433f, -0.01808108f, 0.13373686f, -0.06731315f, -0.05627388f, 0.07417046f, 0.01506200f, 
    -0.06336927f, 0.29005870f, -0.14354081f, 0.16128725f, -0.09315954f, -0.11327709f, 0.37763149f, -0.12500896f, 
    -0.06558295f, -0.00188879f, -0.13278411f, 0.23224325f, 0.04884563f, 0.10425886f, 0.16022120f, -0.08692340f, 
    -0.09795684f, -0.01494663f, 0.15647905f, -0.05613976f, -0.01404667f, -0.06737321f, 0.00574193f, 0.43185800f, 
    -0.06458863f, -0.12478746f, 0.06188241f, -0.05877503f, 0.06462741f, 0.06157486f, -0.29087880f, -0.10176321f, 
    0.03205027f, 0.04200926f, 0.04286037f, -0.07442583f, -0.13567036f, -0.14147112f, -0.07734213f, 0.12205146f, 
    -0.14717542f, -0.00029821f, -0.04446918f, -0.11833010f, 0.04102473f, 0.00453617f, -0.05785297f, 0.13106383f, 
    -0.09975510f, 0.03707201f, 0.12870544f, 0.11698993f, 0.07894422f, 0.11890525f, 0.12591645f, -0.17733935f, 
    0.16739318f, -0.11592951f, 0.13133278f, 0.01507389f, -0.18389936f, 0.05065279f, -0.21698761f, 0.06598751f, 
    -0.15735166f, -0.06028010f, 0.14361157f, 0.15044709f, 0.09703991f, 0.11822176f, 0.04928882f, -0.02396194f, 
    -0.06597672f, 0.01046878f, -0.16179587f, 0.00255967f, -0.17806084f, 0.00213697f, 0.11486179f, -0.09997801f, 
    0.14031166f, -0.10391980f, -0.07007533f, -0.07274929f, 0.06712832f, -0.03129715f, -0.08029088f, 0.09597310f, 
    0.00412367f, -0.10846058f, -0.05746562f, -0.17658770f, 0.16655524f, -0.09876467f, -0.11669496f, 0.11916667f, 
    0.47897398f, -0.27639899f, 0.17243248f, -0.05270842f, 0.09290489f, -0.13885313f, 0.02949385f, 0.07484465f, 
    -0.05904227f, -0.09771842f, 0.15021427f, 0.35980707f, -0.25370121f, -0.10141996f, -0.01316468f, 0.00575322f, 
    0.00194925f, -0.08359169f, 0.08942319f, -0.11782101f, -0.13925096f, -0.11288179f, -0.08938318f, -0.56305218f, 
    0.05669404f, -0.14458355f, -0.13014960f, -0.15316896f, -0.08227667f, 0.16036560f, 0.18801330f, 0.02885529f, 
    -0.11015628f, 0.27224860f, 0.19041817f, -0.13345027f, 0.04905072f, -0.03124881f, 0.52881253f, 0.01920980f, 
    -0.14777236f, -0.02356614f, 0.12448028f, 0.09476959f, 0.43438351f, -0.11146014f, -0.02934910f, -0.02614522f, 
    0.14541641f, 0.02957453f, 0.05630520f, -0.08640798f, 0.03188884f, 0.16973051f, -0.02567580f, 0.66958702f, 
    0.14526457f, 0.09888247f, 0.16588089f, -0.15150027f, -0.09251504f, 0.14513841f, -0.26940244f, -0.11466632f, 
    0.39090803f, -0.16447856f, 0.29372963f, -0.03771828f, -0.04970715f, 0.17790948f, -0.44008160f, -0.05366391f, 
    0.14715706f, 0.21570973f, -0.00246808f, 0.03049919f, 0.02024124f, 0.35650405f, 0.07247833f, -0.06697968f, 
    -0.07009029f, 0.09194762f, -0.13518111f, 0.12198007f, 0.03281921f, -0.09004967f, 0.05255425f, 0.13687229f, 
    -0.00635428f, -0.10280074f, 0.11628069f, 0.02128416f, -0.11301108f, -0.16758820f, -0.25933418f, 0.14024608f, 
    -0.01760444f, -0.02121112f, -0.10977503f, -0.13897708f, -0.08412102f, 0.16354498f, 0.08661761f, -0.03498349f, 
    0.05352321f, -0.14009851f, 0.02262576f, 0.07339136f, -0.00211867f, -0.06966037f, -0.05765942f, -0.14176619f, 
    -0.00160832f, -0.03406289f, -0.07125418f, 0.09736092f, 0.00207362f, -0.12666790f, -0.06552745f, 0.04963852f, 
    -0.11614984f, 0.05128186f, 0.05516909f, -0.03386980f, -0.02788783f, 0.04873082f, -0.14277500f, 0.16646236f, 
    -0.00863990f, -0.02872985f, -0.05027281f, 0.09973380f, -0.02423369f, -0.13026679f, -0.02218698f, 0.10087879f, 
    -0.01877132f, -0.03643689f, -0.11039764f, -0.16838361f, 0.00941235f, -0.01485007f, -0.09672427f, -0.15666269f, 
    -0.11971290f, 0.12574995f, 0.05931827f, -0.05225157f, -0.00857282f, 0.06722945f, -0.05461469f, 0.07697123f, 
    0.04762923f, 0.01291524f, -0.00084234f, -0.00767820f, -0.00396684f, 0.15461665f, 0.04806210f, -0.06114692f, 
    0.28461617f, 0.01833485f, 0.18092011f, 0.10827658f, -0.17048916f, -0.15123428f, 0.19947654f, -0.06202709f, 
    0.02987462f, -0.20464283f, 0.10145599f, -0.22148700f, 0.46670476f, 0.45371521f, -0.02167790f, 0.07672122f, 
    -0.16262154f, 0.09066336f, -0.12259423f, -0.16821539f, 0.09467375f, -0.10781399f, 0.05503024f, -0.24294962f, 
    0.07154837f, -0.07423372f, -0.00121692f, 0.14664370f, -0.16145754f, 0.15049638f, 0.05076998f, -0.01810334f, 
    0.09603141f, 0.18360478f, -0.36359292f, -0.07583379f, -0.10493948f, -0.12982652f, 0.03775559f, 0.03254361f, 
    0.10720160f, 0.19921677f, 0.00953430f, 0.29186434f, -0.12116162f, 0.12610221f, 0.09953655f, -0.17361633f, 
    0.16860989f, 0.10645548f, -0.09870882f, 0.09536842f, -0.00538266f, -0.04306208f, 0.02597589f, -0.07960670f, 
    0.12324461f, -0.09205259f, -0.05436788f, 0.11099316f, -0.11441689f, -0.15925160f, -0.28823781f, 0.05114667f, 
    0.34303802f, -0.02221132f, 0.32862240f, 0.08965534f, -0.13575989f, -0.07363649f, 0.22854616f, 0.12932511f, 
    0.06359033f, -0.46850353f, -0.16234201f, 0.17312910f, 0.36585340f, -0.22444654f, 0.00664983f, -0.03381148f, 
    0.05838276f, -0.00362520f, 0.15194128f, -0.15018740f, -0.01229355f, 0.13189611f, 0.05948076f, -0.13381824f, 
    0.13247471f, 0.14983064f, 0.16697000f, 0.14604060f, -0.04361301f, -0.09350901f, 0.18904907f, -0.08988260f, 
    -0.22567682f, -0.09814519f, 0.25963968f, 0.15131158f, -0.03784852f, 0.15244764f, -0.21787830f, -0.08378021f, 
    0.13881643f, 0.46063602f, 0.15826605f, 0.34116170f, -0.40997040f, -0.17913929f, -0.15929803f, 0.00384357f, 
    0.10144049f, 0.05530527f, -0.06186552f, -0.15360440f, 0.08312834f, -0.06859986f, 0.06867401f, -0.33728755f, 
    0.10410439f, 0.08447686f, -0.12676603f, 0.15029864f, -0.01918207f, 0.10576558f, 0.19239594f, -0.03675324f, 
    0.15039682f, -0.14790854f, -0.03623446f, -0.06790768f, -0.14932197f, 0.14341502f, 0.04927795f, -0.09819137f, 
    0.17491515f, -0.10942343f, -0.03273025f, -0.12139610f, 0.15012968f, -0.12264682f, -0.09520970f, 0.16742241f, 
    -0.02703240f, 0.00157226f, 0.02811761f, -0.15564784f, -0.06482290f, 0.11651734f, 0.01249705f, 0.03014532f, 
    0.02735928f, -0.11788680f, 0.05427409f, -0.17841414f, 0.06117504f, -0.06239363f, -0.17495407f, -0.10031207f, 
    -0.25995275f, -0.31689587f, 0.45906624f, -0.14636159f, 0.12990868f, 0.05817152f, -0.17189129f, 0.13173839f, 
    -0.14654963f, 0.37958655f, 0.08589011f, 0.04452779f, 0.64557993f, 0.03562554f, 0.16684379f, 0.06275303f, 
    -0.14969695f, -0.09571052f, 0.17875136f, 0.15452154f, 0.15411642f, -0.13693099f, 0.02148804f, -0.30448714f, 
    0.14163525f, 0.04151775f, 0.15082440f, 0.09227520f, -0.16907926f, -0.04249332f, 0.29858160f, -0.12611011f, 
    0.44598219f, 0.20765689f, -0.55936009f, 0.14096977f, 0.06194343f, 0.14885585f, -0.12708093f, 0.07108733f, 
    -0.12992364f, -0.06636680f, -0.03505513f, 0.07532482f, -0.28582448f, -0.05946983f, 0.05774617f, -0.00464082f, 
    -0.00501714f, -0.07152051f, -0.13822171f, 0.07288123f, 0.11986510f, -0.06742890f, 0.15758997f, 0.05610546f, 
    0.07979717f, -0.14511772f, 0.09589320f, -0.15046120f, 0.02573895f, -0.09879897f, 0.39438027f, -0.00418687f, 
    -0.06400505f, -0.12701681f, -0.00107956f, 0.14094438f, 0.15580413f, 0.09469748f, 0.01512218f, -0.17870440f, 
    0.13038796f, 0.03391341f, -0.09301771f, -0.10724306f, -0.10922238f, -0.12430435f, -0.15806076f, 0.06068359f, 
    0.06890453f, 0.05461618f, -0.02514228f, 0.06610727f, -0.02794987f, -0.08150797f, -0.03084688f, -0.00222860f, 
    0.10346920f, 0.13980107f, -0.11627085f, -0.02536435f, 0.13066681f, 0.02806694f, -0.04571439f, -0.09506502f, 
    -0.25264579f, 0.37269771f, -0.01357912f, 0.10350663f, 0.06280211f, 0.13531977f, 0.33043537f, -0.13982268f, 
    0.17920920f, -0.24504262f, -0.01748564f, 0.00157134f, 0.26532066f, 0.22752871f, -0.16401054f, 0.16525596f, 
    0.03644113f, -0.14778830f, -0.03248245f, -0.11471904f, 0.02574152f, 0.13490802f, -0.12630269f, 0.57087749f, 
    0.13703993f, -0.08123109f, -0.02480752f, 0.04995548f, -0.00583775f, 0.14388371f, 0.28172353f, 0.09820472f, 
    0.26465496f, -0.28189659f, 0.26059061f, -0.04162288f, -0.16452445f, -0.06256178f, -0.21215189f, -0.05052623f, 
    -0.11632856f, 0.08167902f, -0.06018841f, 0.35638255f, -0.03813487f, 0.37006667f, 0.09551807f, 0.13906947f, 
    -0.02784993f, 0.05540040f, 0.16221449f, -0.15268086f, 0.04911644f, 0.03688913f, 0.01058029f, -0.25716588f, 
    -0.15038048f, 0.01355498f, -0.05459137f, 0.16952972f, 0.04891403f, -0.08275693f, -0.30082431f, 0.07705084f, 
    0.02731011f, -0.02102631f, 0.05088989f, 0.09728759f, 0.14824399f, -0.16314636f, 0.03494126f, -0.15653197f, 
    0.02265192f, -0.19706498f, -0.07783537f, -0.20948318f, 0.04965977f, -0.12579930f, 0.00776680f, 0.02106511f, 
    -0.11454767f, -0.05654721f, -0.18101032f, 0.10272320f, -0.02842133f, 0.02494650f, 0.05858905f, 0.09702838f, 
    0.13640724f, -0.02558233f, -0.05388289f, -0.10648558f, 0.02913714f, -0.10988857f, 0.00930468f, 0.06515591f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04494801f, 0.28914544f, 0.01242710f, -0.16017954f, 0.23332940f, 0.01264889f, 0.28757787f, -0.03230264f, 
    0.16826287f, 0.08795868f, -0.01955452f, 0.04487278f, -0.17133822f, 0.11365423f, -0.09595792f, -0.10229550f, 
    -0.01722628f, -0.05854167f, 0.18487360f, -0.11605134f, -0.00706389f, 0.12647165f, -0.02163580f, -0.14282461f, 
    0.12205259f, -0.02225271f, -0.05915363f, 0.13213132f, 0.02699928f, 0.01428917f, 0.09359284f, 0.04129740f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.15879242f, -0.28839326f, 0.11474805f, 0.08989064f, 0.01184862f, 0.27195585f, -0.54546750f, 0.39742115f, 
    -0.25038972f, 0.27115646f, 0.19972906f, 0.15478906f, 0.12463655f, 0.15959075f, -0.06244951f, -0.10347944f, 
    -0.48517799f, 0.11936742f, -0.08340611f, -0.12498700f, 0.14819990f, 0.41421461f, -0.27527493f, 0.18413773f, 
    -0.71866965f, 0.02399328f, -0.00839796f, -0.32187146f, -0.17002159f, 0.07446029f, -0.00566398f, 0.09622411f, 
    0.08181264f, -0.28868648f, 0.11014680f, 0.10357024f, -0.63702995f, 0.33626094f, 0.04631109f, -0.32123685f, 
    0.41991043f, 0.08721574f, 0.11651923f, -0.16978095f, -0.07750581f, 0.10975536f, -0.07149358f, -0.05341268f, 
    0.05015909f, 0.23388806f, -0.25627512f, 0.01005528f, -0.09165238f, -0.12873781f, 0.36486337f, -0.00583443f, 
    -0.32758084f, 0.12373745f, -0.82679319f, 0.06146186f, 0.14139606f, 0.08711847f, -0.03359026f, 0.16960640f, 
    0.06436819f, 0.14181016f, 0.12380522f, -0.00086433f, 0.35764697f, 0.16430365f, -0.49550924f, 0.43202052f, 
    0.46215782f, 0.18343264f, 0.02648233f, 0.09703171f, -0.13518906f, 0.13897488f, 0.16584413f, 0.11535513f, 
    -0.05131757f, -0.29067951f, -0.39916885f, 0.11607970f, -0.08980086f, -0.39838308f, 0.26357621f, -0.39736453f, 
    0.30862856f, -0.09829263f, -0.43534979f, -0.07061566f, -0.04478450f, -0.07425515f, 0.08375929f, 0.01035625f, 
    0.14103441f, -0.16288356f, 0.15435380f, -0.10449462f, 0.41851845f, -0.16829039f, -0.00330983f, -0.02986391f, 
    -0.62755603f, -0.20622949f, -0.45470521f, -0.12400815f, -0.12466609f, -0.38841286f, 0.05005439f, 0.04001192f, 
    0.38949811f, -0.62901115f, 0.06709239f, 0.09861616f, -0.00026743f, 0.16004743f, 0.16672382f, 0.40323067f, 
    -0.18107508f, -0.05637078f, 0.03832177f, 0.14717327f, 0.12133458f, -0.26214343f, 0.27621278f, 0.14976880f, 
    -0.01713310f, -0.30034783f, 0.06049675f, -0.19668370f, 0.05560277f, -0.24353664f, 0.16655549f, -0.07322524f, 
    0.04701731f, 0.05900327f, 0.22278570f, 0.04947571f, -0.13089944f, -0.00623051f, -0.09881427f, -0.06469185f, 
    0.10672809f, -0.00409697f, -0.11684826f, -0.00478955f, -0.13194935f, -0.21888654f, -0.32893938f, 0.31001174f, 
    0.12771849f, 0.11506426f, 0.16520937f, -0.28532872f, -0.17858811f, -0.04184935f, 0.05318930f, 0.16944100f, 
    -0.14210340f, -0.04014594f, -0.16262801f, -0.06765475f, -0.76559997f, -0.08545429f, 0.32600543f, -0.20212354f, 
    -0.32946953f, -0.11356637f, 0.32492262f, 0.04957958f, -0.15721196f, 0.06143295f, -0.16168955f, -0.15532370f, 
    -0.32890838f, 0.27433816f, -0.12896156f, 0.14368050f, -0.01491976f, -0.00533427f, -0.45961681f, 0.25283629f, 
    -0.44183353f, 0.05677177f, -0.09653613f, -0.02990100f, 0.02544956f, 0.22592749f, -0.53337085f, -0.06510967f, 
    -0.10981477f, 0.17749614f, 0.09955693f, -0.09382098f, 0.38565573f, -0.01299843f, -0.10640283f, 0.35753956f, 
    -0.27019158f, 0.24802406f, 0.20764725f, -0.04075430f, 0.04090888f, -0.10546687f, -0.13935521f, -0.01184593f, 
    -0.24433444f, -0.07357954f, -0.73963028f, 0.07652254f, -0.01453173f, -0.78078896f, -0.17853595f, 0.05250343f, 
    0.21125925f, 0.02693726f, 0.00589263f, 0.29000196f, -0.14126350f, 0.08888707f, -0.70815635f, -0.03424352f, 
    0.13978682f, -0.30394068f, 0.06562645f, 0.00180881f, -0.34009340f, -0.32441869f, 0.15387404f, 0.02300029f, 
    0.37971869f, -0.71199989f, 0.09242869f, -0.14881296f, 0.13104860f, -0.53589439f, -0.12993485f, 0.17961599f, 
    0.16164996f, -0.13588540f, 0.42203221f, 0.09390572f, -0.08527406f, -0.04251076f, -0.20177640f, 0.00195557f, 
    0.24474625f, 0.07764208f, 0.30636713f, -0.36861044f, -0.10164531f, -0.61473352f, 0.41367480f, -0.02812428f, 
    -0.08687246f, 0.36071846f, -0.12382609f, -0.09963996f, -0.50828397f, -0.00445608f, -0.09813280f, -0.06676041f, 
    0.35709614f, -0.06253709f, -0.31250140f, 0.04760613f, -0.03765687f, -0.17410570f, -0.12048823f, 0.06622235f, 
    -0.29154935f, -0.46805680f, 0.18743430f, -0.02545848f, -0.03283919f, 0.35394958f, -0.28778395f, -0.28187960f, 
    -0.30332127f, -0.01046521f, -0.43266714f, 0.32245451f, -0.08310746f, 0.17467287f, -0.00336089f, 0.01598093f, 
    0.01178582f, 0.21515074f, -0.06620538f, 0.11079577f, 0.15487550f, -0.32308313f, -0.13669708f, 0.08541959f, 
    -0.16678594f, 0.13849606f, 0.21358897f, -0.02263067f, -0.14770587f, 0.18097475f, 0.13914619f, -0.03848680f, 
    -0.84583342f, 0.13518372f, 0.21968435f, 0.01032375f, 0.06930532f, -0.27887237f, 0.37958482f, -0.61695892f, 
    -0.12945627f, 0.06223790f, 0.19399509f, -0.56644815f, -0.04757014f, 0.06476378f, 0.12757888f, 0.01794829f, 
    0.07938829f, 0.19645812f, 0.08834583f, -0.05874700f, -0.17840286f, -0.39826247f, 0.24963526f, -0.63750380f, 
    0.16930033f, -0.36728141f, -0.54389286f, 0.10784968f, 0.10350480f, 0.23229583f, -0.07006498f, 0.10952035f, 
    0.08243758f, -0.20436066f, 0.21144909f, -0.12768820f, 0.03567330f, -0.80913967f, 0.29088971f, -0.38598552f, 
    0.25121173f, -0.04698937f, -0.26644003f, 0.35352254f, 0.05962504f, -0.23242144f, 0.02956109f, -0.02905355f, 
    -0.03342362f, 0.40456185f, 0.03436086f, -0.11964443f, 0.12849662f, -0.24055623f, -0.15032062f, -0.20695257f, 
    -0.60220277f, 0.15996112f, -0.71969944f, 0.14237718f, -0.09217975f, -0.60962009f, 0.05012831f, -0.15107657f, 
    -0.04983265f, -0.36130267f, -0.39670238f, -0.01811841f, -0.13763610f, 0.28231198f, -0.67561167f, -0.10502905f, 
    0.25219938f, -0.00086712f, 0.50409442f, 0.06019747f, 0.16158266f, 0.07157876f, -0.46511567f, -0.09946048f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.05304395f, 0.01098495f, -0.03469917f, -0.01975158f, 0.05752843f, 0.15845883f, 0.14878081f, -0.10797096f, 
    -0.05460308f, -0.11533392f, -0.02501290f, 0.17768428f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
