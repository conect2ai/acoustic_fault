#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.78927833f, 0.16821955f, 0.07144029f, -0.20695041f, -0.21568014f, -0.05576095f, 0.26914734f, 0.22849616f, 
    0.38093477f, 0.17653562f, -0.24908051f, -0.16352458f, 0.14300391f, -0.24882473f, -0.29771242f, -0.04360062f, 
    0.01252684f, 0.05804535f, 0.15620258f, -0.27418777f, 0.25511771f, 0.05421721f, -0.17302980f, -0.00908840f, 
    -0.19645666f, 0.20022838f, -0.44740847f, -0.42885792f, 0.64916652f, -0.03403765f, -0.38670075f, 0.30130816f, 
    0.16917425f, 0.31950182f, -0.02938600f, 0.37849519f, 0.08354935f, -0.20751221f, -0.14715257f, 0.09459058f, 
    -0.12455942f, -0.14126831f, -0.24082255f, 0.09262065f, -0.19748037f, -0.06130144f, -0.18429631f, -0.03197167f, 
    -0.18873203f, -0.17962885f, 0.24720897f, 0.23224641f, -0.64739746f, -0.31479165f, -0.33722460f, 0.49981570f, 
    -0.17555612f, -0.20131904f, -0.00720769f, -0.20500651f, -0.23003966f, -0.27375072f, 0.15512171f, 0.27778426f, 
    -0.26189843f, -0.31929877f, 0.20235552f, -0.03040467f, 0.24450937f, -0.00010120f, -0.11892519f, -0.14063773f, 
    0.06124743f, -0.09446613f, 0.12469647f, 0.39876410f, 0.35858908f, -0.25604653f, -0.35417557f, -0.57170099f, 
    0.26335010f, 0.05333350f, -0.12511244f, 0.17976964f, 0.49369794f, 0.15592988f, 0.15910293f, -0.09648721f, 
    -0.03401290f, 0.12591355f, -0.02637339f, -0.02748430f, -0.02990231f, -0.13546886f, -0.06157749f, 0.22425725f, 
    -0.08841436f, 0.15871283f, -0.08179245f, -0.06287719f, -0.61857933f, 0.26818004f, 0.19480498f, 0.07351635f, 
    0.22055690f, 0.44167122f, 0.34396943f, 0.34595287f, 0.26840591f, 0.21057019f, 0.35924998f, -0.38363343f, 
    0.05843550f, -0.47112173f, 0.13833779f, -0.23693910f, -0.18392204f, -0.06865775f, -0.10519798f, -0.04789563f, 
    -0.19694391f, -0.08433083f, -0.00123592f, 0.11426278f, -0.09268414f, 0.58821791f, 0.69414276f, -0.05122911f, 
    -0.72974879f, -0.46337435f, -0.33044481f, 0.17710714f, -0.18400703f, -0.35858351f, -0.18954918f, 0.04814028f, 
    0.22798946f, 0.06965513f, 0.09894786f, 0.18913461f, 0.12760358f, 0.04838849f, 0.04540031f, -0.03160169f, 
    0.02533983f, 0.17482211f, 0.15621369f, -0.11516991f, 0.07774414f, 0.29887363f, 0.61793554f, 0.45997900f, 
    0.23169136f, -0.11614460f, -0.29326525f, -0.12426442f, 0.26589620f, -0.48991865f, 0.09503120f, 0.38566732f, 
    0.30520284f, 0.14843182f, 0.05592565f, 0.07048709f, -0.34925327f, -0.07465444f, -0.33920223f, 0.31185386f, 
    -0.04014343f, -0.29734576f, 0.10497899f, 0.04234889f, 0.02927347f, -0.05277704f, 0.34979999f, -0.01725918f, 
    0.14990601f, -0.31512761f, -0.20708412f, 0.03202858f, -0.31789386f, -0.60464430f, -0.04120591f, 0.50154376f, 
    -0.28176245f, -0.23216318f, 0.05262843f, 0.51325393f, 0.20979524f, -0.02217093f, -0.02146255f, -0.26954013f, 
    0.20674655f, 0.23078226f, -0.05455072f, 0.19597745f, 0.12765960f, -0.18339017f, -0.07272544f, 0.01879874f, 
    -0.53212631f, -0.32066786f, 0.46925315f, 0.73871660f, 0.04265070f, 0.21824676f, -0.13858084f, 0.13870254f, 
    0.12660955f, -0.38622198f, 0.53697520f, -0.09326605f, 0.15409194f, -0.05634567f, -0.06763324f, -0.03757385f, 
    0.39135349f, 0.41586018f, -0.25344971f, -0.05306352f, -0.36730465f, -0.08458542f, -0.06379718f, 0.06139265f, 
    0.05339153f, 0.33243817f, 0.29910684f, -0.15850993f, 0.66812229f, -0.29035738f, -0.00035747f, -0.12336234f, 
    0.16600458f, -0.17993800f, -0.35121471f, -0.21488796f, -0.10116558f, -0.15214284f, 0.21118174f, 0.42909577f, 
    -0.10824852f, 0.08404820f, 0.02567239f, -0.07429138f, 0.48405311f, 0.46144903f, -0.12867932f, 0.19336562f, 
    -0.15130702f, 0.08980053f, 0.50257778f, 0.72155768f, 0.52274132f, -0.36211285f, -0.20914768f, -0.36940759f, 
    0.30583420f, 0.18351088f, -0.11291314f, 0.45164636f, 0.00978323f, 0.20533262f, -0.19325791f, -0.25052187f, 
    -0.05646635f, -0.18755288f, -0.16415377f, -0.16181765f, -0.06746279f, -0.23963973f, -0.12525040f, -0.17772390f, 
    0.15599237f, -0.09937108f, -0.07068251f, -0.34182382f, -0.26095602f, -0.01872034f, -0.02181174f, -0.48099732f, 
    0.26901296f, -0.18297537f, 0.42452082f, -0.29147467f, 0.07124762f, -0.27437863f, -0.04567856f, 0.11607672f, 
    0.36926073f, 0.17224342f, -0.02693619f, 0.00763742f, -0.43384758f, -0.43424541f, 0.11288319f, -0.19201872f, 
    0.11490132f, 0.11854863f, -0.14407788f, -0.07562752f, -0.18829209f, -0.74545437f, -0.46156847f, -0.42809343f, 
    -0.33496270f, -0.24403283f, -0.07307402f, 0.00701232f, 0.05203650f, 0.31196803f, 0.12804660f, 0.21472159f, 
    0.24238701f, 0.15841690f, 0.42890456f, -0.19895636f, 0.09727389f, -0.24662307f, -0.09129436f, 0.09273820f, 
    0.25861982f, -0.07716761f, 0.08646525f, 0.12001420f, -0.02894829f, -0.35168418f, -0.11502353f, 0.26843324f, 
    -0.43590644f, -0.36784530f, 0.41208541f, -0.29718113f, -0.27401116f, -0.54454184f, 0.04670751f, -0.01322435f, 
    -0.22972046f, -0.10613724f, -0.08077037f, 0.09314183f, -0.21250306f, -0.18005617f, 0.18413548f, -0.30918190f, 
    -0.10019273f, -0.06961457f, 0.00905870f, -0.23434080f, -0.26003751f, -0.03283212f, 0.19268921f, -0.21628876f, 
    0.24211173f, 0.49492490f, 0.28514808f, 0.08412796f, 0.50994509f, 0.43833244f, 0.14082778f, 0.57743436f, 
    -0.17057991f, -0.07914636f, 0.06700704f, -0.17445326f, -0.06316406f, -0.42196566f, -0.15816289f, 0.10791083f, 
    0.01803996f, -0.11910637f, 0.25441378f, -0.05291737f, -0.05747614f, -0.18392929f, -0.00615670f, -0.20460394f, 
    -0.32162085f, -0.37674680f, -0.50794476f, -0.26972947f, 0.11572016f, -0.06913704f, -0.27291766f, -0.08033208f, 
    -0.08224511f, 0.37938395f, 0.46861008f, -0.06555510f, -0.26652107f, -0.05919334f, 0.21745203f, 0.01423534f, 
    0.32959193f, 0.11025652f, -0.08682063f, -0.17936772f, -0.01531742f, 0.01741008f, -0.17785907f, 0.00802744f, 
    -0.30475876f, -0.12413160f, 0.38127625f, -0.17272724f, -0.46363574f, -0.33522645f, -0.14517479f, 0.33704266f, 
    0.22559232f, -0.19317509f, 0.01369256f, -0.09249908f, -0.07015497f, 0.37211448f, -0.15686369f, 0.10691126f, 
    0.15847307f, -0.03810313f, -0.41293848f, -0.46893200f, 0.03750191f, -0.26487762f, 0.19498123f, -0.10955311f, 
    0.11399574f, 0.62958437f, 0.34811947f, -0.29909885f, -0.43838564f, -0.37384143f, 0.45851532f, 0.39403084f, 
    0.25096536f, 0.39651242f, 0.33860785f, -0.00288260f, -0.22028293f, -0.27117610f, -0.12930503f, 0.05799065f, 
    0.01032621f, 0.04699790f, -0.19655752f, 0.15392482f, 0.24743207f, -0.03444925f, 0.08561252f, -0.11229184f, 
    -0.21214779f, -0.23306325f, -0.14301094f, -0.72697914f, -0.02474084f, 0.64659536f, 0.47289819f, 0.17074898f, 
    -0.13883902f, 0.05532756f, 0.14737447f, -0.45702457f, 0.01954357f, -0.32744706f, -0.29048458f, 0.15898767f, 
    0.07305621f, 0.34660235f, 0.19939129f, 0.09263909f, 0.19825709f, 0.18531904f, -0.04954564f, -0.15982272f, 
    0.17394072f, -0.26277396f, -0.14046873f, 0.23374684f, 0.83218867f, -0.29555166f, 0.12028934f, 0.21153603f, 
    -0.06233640f, 0.37868658f, 0.24390031f, -0.19797657f, -0.02844088f, 0.15355167f, -0.01102522f, -0.15214603f, 
    -0.14200315f, -0.21080948f, -0.00748030f, 0.00380515f, 0.00240200f, 0.20841888f, -0.22530229f, -0.25768876f, 
    0.20886430f, 0.00930732f, -0.19139111f, -0.00661850f, 0.23391712f, 0.55114871f, 0.51113445f, 0.67426503f, 
    0.11031993f, -0.22352548f, 0.15427725f, -0.13887410f, -0.33454657f, 0.06008368f, 0.22860503f, 0.22295097f, 
    0.26440465f, 0.36485922f, -0.06595447f, -0.15598448f, 0.22701672f, 0.33792174f, 0.21021736f, 0.08817127f, 
    -0.02796353f, -0.20493509f, -0.13426307f, -0.07268681f, -0.01607663f, -0.39124379f, -0.93193156f, -0.45026571f, 
    -0.06752764f, -0.11910705f, 0.38041103f, 1.01639295f, -0.39057148f, -0.00295207f, 0.39461693f, -0.41762382f, 
    -0.00962068f, 0.00609556f, 0.06111187f, 0.13970239f, -0.05898567f, 0.13098361f, 0.04029822f, 0.08112495f, 
    -0.19171260f, -0.05749368f, -0.13835597f, -0.17708637f, 0.01393209f, 0.11872245f, 0.29585180f, -0.06286302f, 
    -0.65212470f, -0.63767755f, 0.12969384f, 0.43381551f, -0.28691649f, 0.22669369f, 0.31982887f, 0.13485953f, 
    -0.60761374f, 0.01619555f, -0.09564800f, -0.11662383f, -0.38496968f, -0.18146744f, -0.13891415f, 0.00887914f, 
    0.10393029f, -0.18022506f, -0.21736267f, 0.31361789f, -0.16200280f, 0.12068579f, 0.27894744f, -0.57247776f, 
    -0.56801820f, -0.69516104f, -0.49532896f, 0.36756355f, 0.06825034f, 0.30501080f, 0.42470768f, -0.28864312f, 
    0.34602851f, -0.26961055f, -0.04549535f, 0.11171453f, -0.18051045f, 0.27445936f, -0.03059850f, 0.05643087f, 
    0.08059172f, -0.05847078f, -0.09131240f, 0.14373630f, -0.13860694f, -0.30249736f, -0.07303125f, -0.18933915f, 
    0.81623358f, 0.08261654f, 0.72760439f, -0.23919064f, 0.14467053f, 0.18331699f, -0.76587701f, 0.13606946f, 
    0.41749230f, 0.18700442f, -0.03417078f, 0.11808103f, -0.17701320f, -0.09045380f, 0.13326678f, 0.00143283f, 
    0.03174083f, 0.02544833f, -0.30540350f, -0.00150297f, 0.19002250f, -0.02098047f, -0.11063826f, 0.08375935f, 
    -0.17180744f, -0.56858754f, 0.80063784f, -0.35810536f, 0.14615320f, -0.15703799f, -0.00792472f, 0.58763266f, 
    -0.18630776f, 0.35249704f, 0.39619312f, 0.13959241f, 0.01677483f, 0.08181477f, -0.26940545f, 0.10065258f, 
    -0.07136452f, -0.32635963f, 0.13009658f, 0.08536917f, -0.07082595f, 0.11900673f, 0.20164432f, 0.02369433f, 
    -0.06673185f, 0.12404656f, 0.56219530f, 0.52618825f, 0.17264459f, -0.48310342f, 0.15541066f, -0.21544413f, 
    -0.38530108f, 0.20375256f, -0.00930820f, 0.39011091f, 0.06168162f, 0.06974246f, 0.10796469f, -0.27041626f, 
    -0.05506529f, -0.13806218f, -0.06614282f, 0.00351333f, -0.00357323f, -0.02072262f, -0.14393671f, 0.08655465f, 
    0.01000498f, 0.27540007f, -0.03740270f, -0.09603945f, 0.30916199f, 0.67946261f, 0.72058773f, 0.10705923f, 
    -0.68891352f, 0.35437858f, -0.55498296f, -0.30934122f, 0.18294196f, 0.38419852f, 0.18839821f, 0.03662666f, 
    -0.07920023f, -0.15881899f, 0.13005224f, -0.24650040f, 0.10113912f, 0.25378197f, 0.21161973f, -0.05278351f, 
    0.08652848f, 0.15420541f, -0.07545628f, 0.01462823f, -0.42136130f, -0.70173723f, -0.60060239f, -0.29417583f, 
    0.23845929f, -0.54258406f, 0.35239330f, -0.16036294f, -0.18676268f, 0.26067466f, 0.16634817f, 0.11895008f, 
    0.18060113f, -0.05093126f, 0.12001803f, -0.13993086f, -0.13902508f, 0.05118568f, -0.35255662f, -0.11969571f, 
    -0.18708386f, -0.25527319f, 0.11524645f, 0.16800739f, 0.14343645f, 0.01226578f, -0.02341632f, -0.21989967f, 
    -0.42730132f, -0.32483464f, 0.15156911f, 0.17943032f, -0.24697168f, -0.31301796f, -0.47879413f, -0.17660688f, 
    -0.23179097f, -0.23734035f, 0.21881148f, -0.35445446f, -0.20897356f, -0.26509848f, -0.29971197f, -0.20244814f, 
    -0.06114479f, -0.26749212f, 0.17148516f, 0.02058714f, 0.10291495f, -0.28292012f, -0.34864712f, 0.75997138f, 
    0.26595885f, -0.44794080f, -0.17742087f, -0.26480162f, 0.37325346f, 0.16413291f, 0.37937975f, -0.12488285f, 
    -0.14637022f, 0.29320934f, -0.38798207f, -0.02343588f, -0.02289075f, -0.14258984f, 0.06559890f, -0.17963780f, 
    0.07580686f, -0.27865526f, -0.22536117f, -0.02426155f, -0.13522202f, -0.11779208f, 0.12549900f, 0.27272120f, 
    0.12056636f, -0.29084936f, -0.12956306f, 0.62860548f, 0.42859787f, -0.16533938f, 0.41128322f, 0.24847430f, 
    0.09687315f, 0.11508029f, 0.02673707f, -0.33982286f, -0.08122209f, -0.01399290f, -0.06109248f, -0.22822390f, 
    -0.16151030f, 0.25399113f, 0.15548234f, 0.12070951f, -0.15893343f, -0.16766377f, 0.19746800f, -0.43031189f, 
    0.79534227f, -0.01120770f, 0.42834815f, 0.73851502f, 0.40324387f, 0.25459749f, 0.11853740f, 0.03520858f, 
    -0.04245694f, -0.46704432f, -0.09756139f, -0.23644994f, -0.19518466f, 0.21171913f, 0.19264109f, -0.09838079f, 
    -0.15080784f, 0.34792376f, 0.15724845f, 0.12172749f, -0.23949026f, 0.29088867f, -0.10023586f, 0.10341514f, 
    -0.16358557f, 0.18983540f, -0.20478223f, -0.37316856f, -0.12502319f, 0.22031535f, -0.18389344f, -0.81138337f, 
    -0.37454915f, -0.32059935f, -0.17845927f, -0.06870749f, 0.49285558f, 0.06143657f, 0.08044929f, 0.18222225f, 
    0.28223217f, -0.17241623f, -0.29757375f, -0.09029606f, -0.09607472f, -0.00454533f, 0.20032680f, 0.16364303f, 
    0.12557353f, -0.03963117f, -0.40951917f, -0.61099142f, -0.30280197f, -0.28744751f, -0.34672737f, -0.15471697f, 
    -0.07359837f, 0.13423193f, 0.32846510f, 0.45936248f, 0.33226025f, 0.18929923f, -0.20617616f, -0.22371249f, 
    -0.23794778f, 0.10975168f, 0.32978159f, 0.07200783f, 0.33371702f, -0.10803291f, -0.17204933f, -0.36775681f, 
    -0.00364043f, 0.16626458f, 0.41789034f, 0.62301183f, 0.20906033f, 0.59598029f, 0.09464881f, 0.14323668f, 
    0.13833874f, -0.69420147f, 0.18335821f, 0.22867881f, 0.01546540f, 0.26393440f, -0.22622436f, -0.17029886f, 
    0.08287998f, 0.05372477f, -0.15144175f, 0.00424187f, -0.04147872f, 0.07141594f, -0.01132911f, 0.27841479f, 
    0.20882595f, 0.22795719f, -0.09919593f, 0.31108788f, -0.80392975f, 0.28587651f, -0.43539995f, -0.53557485f, 
    0.09026794f, -0.05268304f, 0.55751926f, 0.09576152f, 0.05017742f, 0.43118393f, 0.03470897f, -0.41863447f, 
    0.29697672f, -0.24879110f, 0.19475126f, -0.02043566f, -0.10255268f, -0.18319604f, 0.15479338f, -0.23182763f, 
    0.26667857f, 0.00202791f, 0.24671918f, 0.42306504f, -0.16607022f, 0.03505386f, -0.34695366f, -0.38831985f, 
    -0.52493817f, 0.32248443f, -0.32236966f, -0.26605815f, -0.04268916f, -0.06974537f, -0.21983086f, 0.30206972f, 
    -0.01718629f, 0.28973728f, 0.29556456f, -0.05778950f, 0.11165857f, -0.25154626f, -0.39414340f, 0.23699023f, 
    0.26129135f, -0.09737762f, -0.26238433f, 0.18645680f, -0.20953861f, 0.06249033f, -0.31261554f, -0.22851223f, 
    0.10217974f, -0.62053722f, 0.70573699f, 0.08972751f, 0.30426913f, -0.02247940f, 0.02590849f, -0.46635893f, 
    0.06488003f, -0.27795929f, -0.04006925f, -0.12328015f, -0.11834728f, 0.28005174f, -0.36917329f, -0.00694504f, 
    0.02467072f, 0.20557581f, 0.06591496f, 0.11360561f, -0.02739739f, -0.08174150f, -0.06248752f, 0.37561995f, 
    -0.33887184f, -0.61777192f, -0.50925720f, -0.22577643f, -0.02426334f, 0.25280178f, 0.18492711f, 0.15517269f, 
    0.30338672f, -0.29984131f, 0.29524162f, -0.10383625f, 0.10247799f, -0.26130301f, -0.12395979f, 0.04852219f, 
    -0.07894425f, 0.28284308f, 0.29510945f, -0.11491490f, 0.26032531f, -0.18050611f, -0.27717596f, -0.12348577f, 
    -0.16285820f, -0.41418979f, -0.22699505f, -0.20064141f, 0.03276309f, 0.23683430f, -0.54583013f, 0.22998929f, 
    0.27923626f, -0.51659048f, -0.43384027f, -0.05039450f, 0.10058019f, 0.22012703f, -0.12172158f, 0.33091143f, 
    0.25430605f, 0.19294931f, 0.23165102f, 0.09102770f, 0.14611040f, 0.02739519f, 0.22360638f, -0.05484678f, 
    0.10215067f, -0.80749398f, 0.70260125f, 0.08225592f, -0.08811007f, 0.35512421f, 0.19039744f, -0.22536434f, 
    -0.56875968f, 0.23407553f, -0.38453811f, 0.01964951f, 0.18985413f, -0.29558888f, 0.24194792f, -0.18526334f, 
    -0.02076573f, 0.03222437f, -0.14014851f, -0.06539022f, 0.19556797f, 0.00422694f, -0.14425865f, 0.04670655f, 
    -0.02945445f, -0.08539911f, -0.39389136f, 0.45579046f, -0.32468700f, -0.15886521f, 0.19214951f, -0.50748008f, 
    -0.53263146f, -0.08356661f, 0.07985128f, -0.27054423f, -0.05193631f, -0.16511880f, -0.32863697f, 0.12177669f, 
    -0.17523244f, 0.15374187f, -0.15590820f, -0.07067846f, 0.05158317f, 0.32824498f, 0.30164415f, 0.15109453f, 
    0.24540064f, 0.00645687f, 0.22762296f, 0.48936731f, 0.20592938f, 0.38014522f, 0.56331271f, -0.11776264f, 
    -0.04606710f, 0.12295045f, 0.23763867f, 0.25030681f, 0.25491095f, 0.18395385f, -0.05326454f, 0.40182433f, 
    -0.59589481f, 0.28612366f, -0.15455078f, -0.20214881f, -0.19937882f, -0.00134201f, 0.20018135f, -0.21908194f, 
    -0.11706667f, -0.23496327f, -0.11663511f, -0.03520939f, 0.10355565f, 0.21784873f, 0.43456107f, -0.01353991f, 
    0.11088536f, -0.38214684f, 0.29545709f, -0.04547602f, -0.19571833f, 0.14541379f, 0.38192457f, -0.00301967f, 
    -0.30402154f, 0.03081601f, 0.34033281f, 0.20203780f, 0.21443324f, -0.16663623f, -0.23386425f, 0.13926552f, 
    -0.29463735f, -0.02649559f, -0.00297588f, 0.00649751f, 0.42247880f, -0.11716730f, -0.35448918f, -0.19799490f, 
    0.51790142f, -0.19355784f, 0.18219627f, 0.69843280f, -0.02486124f, 0.21657301f, 0.27850196f, -0.25008062f, 
    -0.08409155f, -0.30022469f, 0.26184276f, 0.30587885f, -0.45994326f, -0.08517244f, 0.04985607f, 0.00830942f, 
    0.02404674f, 0.30341211f, 0.29238889f, 0.18519767f, -0.04000674f, -0.27555102f, -0.67934257f, -0.41330409f, 
    -0.03540353f, 0.02340228f, -0.53003299f, 0.02349147f, 0.19125286f, -0.10770720f, 0.40421870f, 0.30817261f, 
    0.25234574f, -0.37263596f, 0.05157713f, 0.22314215f, -0.04424549f, 0.05448060f, -0.11925101f, -0.02596847f, 
    0.07671329f, 0.03328506f, 0.05441454f, -0.00375449f, -0.02374016f, -0.02036722f, 0.09779873f, -0.48254505f, 
    -0.48832658f, -0.43476629f, -0.18716770f, -0.41539311f, -0.24645212f, -0.20132872f, -0.12956443f, 0.25075153f, 
    0.15803656f, 0.24736124f, 0.21187498f, -0.21815053f, -0.06396692f, -0.05145372f, 0.12482136f, -0.05181362f, 
    0.19082472f, 0.21702281f, -0.24915497f, 0.23098262f, 0.02260468f, 0.07744168f, -0.22922070f, 0.25982052f, 
    0.73368466f, -0.45256004f, 0.30696645f, -0.56475413f, 0.20427909f, -0.22831900f, -0.24426576f, -0.11426797f, 
    0.01949656f, 0.35820746f, -0.12267300f, 0.21420753f, 0.30965248f, -0.11041133f, -0.13060294f, 0.11387740f, 
    -0.04791994f, 0.22845611f, 0.09217745f, -0.15627690f, 0.25309208f, 0.03628790f, 0.06045591f, -0.25933671f, 
    0.14423230f, 0.40956217f, 0.38461176f, 0.12301012f, -0.45185754f, -0.31325573f, 0.15967810f, 0.15201990f, 
    -0.24069001f, 0.00323611f, 0.34640235f, -0.27227926f, -0.03595631f, -0.11410474f, -0.31790289f, -0.00665745f, 
    -0.37181330f, 0.15702167f, -0.14157079f, -0.28870547f, -0.03662902f, -0.20061369f, -0.22884704f, -0.18207410f, 
    0.00560752f, 0.41589066f, -0.70270842f, 0.22672600f, 0.41784430f, -0.04832400f, 0.17671302f, -0.21067707f, 
    0.56677341f, -0.47131237f, -0.54597664f, -0.39534149f, 0.18149418f, 0.17964004f, -0.08059195f, 0.00349351f, 
    -0.16802788f, 0.10093156f, 0.17133012f, -0.06460108f, -0.14162616f, 0.02099477f, -0.15271708f, 0.25075081f, 
    0.27089602f, 0.39815399f, -0.06007895f, 0.46496099f, 0.13981879f, -0.62755227f, -0.37874815f, -0.24725996f, 
    0.32578495f, 0.41026810f, -0.37041441f, -0.28037873f, 0.20858325f, 0.42489362f, -0.10449968f, -0.23813841f, 
    -0.04313156f, 0.21643926f, 0.08071666f, 0.05817863f, -0.16597514f, -0.11430745f, 0.22979686f, 0.11337877f, 
    -0.15146619f, 0.28637263f, 0.30117846f, 0.21023916f, 0.08766846f, 0.04291167f, -0.28947428f, -0.09544700f, 
    -0.24199121f, -0.32271430f, -0.50492436f, -0.34991616f, 0.24327622f, 0.17497103f, -0.02522645f, 0.21549554f, 
    0.15334550f, -0.10654538f, -0.03994989f, 0.01653993f, 0.40231568f, -0.43276358f, -0.19944653f, 0.37957710f, 
    -0.35114014f, -0.04366048f, 0.30832934f, 0.04783157f, 0.21759295f, 0.57410389f, 0.33506140f, 0.00483018f, 
    0.14495511f, 0.39435807f, 0.23837841f, 0.15801755f, 0.22248489f, 0.25132200f, 0.34078729f, -0.33673859f, 
    0.04946815f, -0.35513714f, -0.01316227f, -0.19323346f, 0.06339497f, 0.15817201f, -0.19128592f, -0.15127575f, 
    0.07814475f, -0.14896160f, 0.00042373f, -0.06112685f, 0.08764908f, 0.03476319f, 0.31321487f, 0.33721393f, 
    0.58540988f, 0.52101398f, 0.21226984f, 0.26272872f, 0.01439826f, -0.52143794f, 0.36406353f, 0.23744743f, 
    0.11579879f, -0.07382908f, -0.08452120f, -0.30458465f, 0.06888255f, -0.02459906f, 0.03679979f, -0.14670540f, 
    -0.09287246f, -0.36009175f, -0.04153367f, 0.12004069f, 0.21976656f, 0.21179108f, -0.25629407f, 0.05938051f, 
    0.65282220f, 0.53523618f, 0.42020392f, 0.64216316f, -0.73446900f, 0.25252533f, -0.26426342f, -0.69397831f, 
    -0.52028114f, -0.19330660f, -0.34245718f, 0.12308948f, 0.21620120f, 0.13254145f, 0.11013048f, 0.05474921f, 
    0.03239650f, -0.21427295f, 0.02290663f, -0.03908399f, 0.06675833f, -0.13231517f, 0.40937668f, 0.05207556f, 
    0.38677207f, 0.28312534f, -0.44471833f, -0.49298716f, 0.23225492f, 0.03721660f, -0.49940690f, 0.60873771f, 
    0.52564597f, 0.21263197f, -0.31717512f, 0.00513470f, -0.21112099f, 0.04598293f, -0.15074171f, -0.02702212f, 
    0.12085272f, -0.13093042f, 0.00804852f, -0.18085101f, -0.07751353f, 0.24112393f, 0.01154810f, 0.14638186f, 
    -0.06727913f, -0.93258363f, 0.67143375f, 0.22114088f, -0.49399391f, -0.18894161f, 0.20258220f, 0.77864718f, 
    0.00568836f, 0.17606969f, 0.27339315f, -0.16351260f, 0.29312703f, 0.12642369f, -0.09599148f, -0.13081835f, 
    0.29155087f, -0.05582283f, 0.07106235f, -0.02779330f, -0.19978440f, 0.06285220f, 0.04975845f, 0.05618491f, 
    -0.17468077f, 0.03080006f, 0.70309520f, 0.33941585f, 0.42137107f, -0.14843504f, 0.31597617f, -0.10291383f, 
    -0.28247064f, -0.32767990f, -0.16370243f, 0.07234343f, -0.05055482f, 0.36501366f, -0.06883390f, 0.23136538f, 
    0.03656556f, 0.23896827f, 0.01857842f, -0.22445828f, 0.24390388f, 0.19467230f, -0.13211697f, -0.04134053f, 
    0.22607446f, -0.17226820f, 0.41495386f, -0.80777597f, -0.07261984f, -0.35857978f, -0.55446786f, 0.01358721f, 
    0.46779609f, -0.12750292f, 0.20045750f, 0.28060001f, 0.32752255f, 0.28127649f, -0.12023801f, -0.06227445f, 
    0.09934168f, 0.23603533f, 0.07259268f, 0.03598014f, -0.46263328f, -0.18781023f, -0.27633443f, -0.25836179f, 
    -0.01533832f, 0.01582795f, -0.23295541f, 0.00680379f, 0.53962386f, 0.50357956f, -0.10488424f, -0.08962382f, 
    0.41017926f, -0.02847134f, 0.25854900f, 0.36972886f, 0.05898124f, 0.24388565f, -0.28213048f, 0.19095339f, 
    0.02300870f, -0.32808161f, 0.03979114f, 0.20039661f, -0.21754536f, 0.14989008f, 0.17147963f, 0.08953774f, 
    0.09751106f, -0.05872468f, 0.19440420f, 0.02769810f, -0.17699474f, -0.25007492f, 0.50914389f, 0.14423959f, 
    -0.75639683f, -0.06476556f, 0.46611086f, -0.32223046f, -0.60383588f, -0.72418231f, -0.31714115f, 0.05948848f, 
    0.22072047f, 0.33486599f, 0.25433218f, -0.01270820f, -0.22352475f, 0.12177313f, 0.13471998f, 0.24848324f, 
    0.28352106f, 0.13252160f, 0.22994997f, 0.09409352f, 0.01654147f, -0.02741890f, -0.59614998f, -0.29312378f, 
    0.04665215f, -0.15976220f, -0.21915208f, 0.35005072f, 0.62184364f, -0.34194398f, 0.33970767f, 0.33870614f, 
    -0.22862154f, -0.24236862f, -0.35990533f, -0.19752495f, -0.15616879f, 0.01553780f, -0.02319377f, 0.03646864f, 
    -0.11088343f, 0.17249030f, -0.31326956f, -0.02593958f, 0.05636061f, 0.09222592f, 0.10113256f, 0.47138456f, 
    0.30162659f, 0.39530817f, 0.49653453f, 0.54141712f, 0.15765749f, 0.32502991f, 0.22811528f, 0.35339284f, 
    -0.15424888f, -0.22250305f, 0.10809567f, 0.03275215f, -0.27507496f, -0.17508170f, -0.12842281f, -0.24520098f, 
    0.12417989f, -0.04768395f, -0.08034457f, 0.07234135f, -0.03086551f, -0.05671278f, -0.05761560f, 0.16326097f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01777806f, 0.24363993f, 0.20447877f, 0.01646534f, -0.03244844f, 0.42113662f, -0.06668879f, 0.02358423f, 
    0.21294260f, -0.00825743f, 0.03894041f, 0.08657049f, 0.26002300f, 0.09495611f, -0.03131903f, 0.01824402f, 
    0.14290486f, 0.17120318f, 0.17206690f, -0.09180829f, 0.07605515f, 0.15303843f, 0.10804454f, -0.02581029f, 
    0.22830363f, -0.16779642f, 0.23754436f, 0.28414544f, -0.06035135f, -0.05536928f, 0.08324119f, -0.00071476f, 
    0.02694557f, 0.23396905f, -0.14722012f, 0.27513152f, 0.09630162f, 0.25312719f, -0.06777057f, 0.07532834f, 
    0.04724461f, 0.00733941f, 0.34925002f, 0.00342554f, -0.00070103f, 0.18064521f, -0.11250310f, 0.08734620f, 
    0.07907393f, -0.03475980f, 0.08575828f, 0.28944138f, 0.17025769f, 0.10858961f, 0.15268017f, 0.21188390f, 
    0.12723741f, 0.15108354f, 0.17991617f, 0.12921269f, 0.22094315f, 0.30248716f, -0.02431103f, 0.04307336f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05436259f, 0.14983080f, 0.01984860f, -0.01113173f, -0.02670079f, -0.05604483f, 0.08458666f, 0.16328414f, 
    -0.07667319f, 0.01845265f, -0.07069793f, 0.00919699f, 0.12802713f, -0.15207486f, -0.11363414f, 0.25843626f, 
    0.03116661f, 0.08110518f, 0.08303022f, -0.00681890f, -0.02371135f, 0.02196843f, -0.03488663f, 0.14672978f, 
    -0.00090787f, -0.22815053f, 0.12912250f, -0.15682021f, 0.03222767f, -0.00806376f, 0.07818837f, 0.12726639f, 
    -0.00985675f, -0.00000103f, 0.05088692f, -0.04130461f, 0.11762150f, -0.17779329f, 0.17403585f, -0.12113232f, 
    0.01947071f, 0.01936901f, 0.07561898f, 0.03040222f, -0.07780332f, 0.00882522f, -0.00892183f, 0.09309108f, 
    0.16968046f, 0.22760041f, 0.04329187f, 0.00417520f, 0.03278399f, 0.09733915f, -0.09176257f, 0.06820387f, 
    -0.03061478f, -0.04618616f, 0.06093282f, 0.12009608f, -0.01674968f, 0.10005116f, 0.09227645f, -0.34265980f, 
    0.03160414f, 0.08052083f, 0.04250106f, 0.08199907f, 0.02905164f, 0.03651341f, 0.04071457f, 0.09855182f, 
    0.01454658f, -0.03248046f, 0.09036576f, -0.08291921f, -0.08134746f, 0.00686587f, -0.06452707f, 0.02171232f, 
    0.04478820f, 0.08426204f, -0.01473089f, -0.04843937f, -0.24427880f, -0.24737565f, 0.10512011f, -0.14387025f, 
    -0.07507052f, 0.07773576f, 0.03715201f, -0.02878393f, -0.04171572f, 0.00095634f, -0.02317715f, 0.01099613f, 
    -0.11117941f, 0.09297547f, -0.20164767f, 0.28446564f, 0.08673700f, -0.01481436f, 0.06987718f, 0.02995822f, 
    -0.08691218f, 0.00893791f, -0.04309206f, -0.01097962f, 0.08139928f, -0.15673141f, -0.21408926f, 0.20509839f, 
    -0.01587567f, 0.03704407f, -0.06855953f, -0.02485209f, 0.02915683f, 0.01405223f, 0.01666569f, 0.08876511f, 
    -0.26181838f, 0.12093479f, 0.09974398f, 0.03919436f, -0.03522852f, 0.02236954f, 0.09540635f, -0.00645543f, 
    0.05703888f, 0.04664934f, 0.15093988f, 0.05293389f, 0.07775334f, 0.09025986f, -0.03157900f, -0.00460056f, 
    -0.01981347f, 0.01169195f, -0.09431295f, 0.09310781f, -0.01867523f, -0.07755622f, -0.03280632f, -0.01448306f, 
    0.24358399f, -0.13553722f, 0.01919215f, -0.07242277f, 0.07378323f, 0.08364426f, 0.06047290f, 0.11736454f, 
    -0.05013981f, -0.06846247f, -0.01279619f, 0.00162724f, -0.01123354f, 0.10712137f, 0.14130054f, -0.20953090f, 
    -0.06360044f, -0.01587162f, 0.09231635f, -0.04236972f, -0.03022802f, -0.05857571f, -0.09585419f, 0.08686563f, 
    -0.02033769f, -0.05060370f, -0.01233319f, 0.24948393f, -0.04256565f, 0.13999401f, 0.11152835f, -0.01426654f, 
    0.04966467f, 0.14331995f, 0.04498042f, 0.12504703f, -0.04065617f, -0.07793608f, 0.17735648f, -0.12189710f, 
    0.01940851f, 0.04657859f, 0.13677056f, 0.09995683f, 0.01520099f, 0.01039735f, 0.06079330f, 0.02333048f, 
    -0.08737496f, 0.09243540f, -0.04391664f, -0.18144697f, -0.03493981f, 0.04271466f, -0.02009420f, 0.05165516f, 
    0.00375001f, -0.01801596f, -0.03740623f, -0.11864985f, 0.12492897f, -0.18875355f, 0.16878451f, 0.03483493f, 
    0.08316420f, -0.01904383f, 0.09893154f, 0.09909301f, -0.06876829f, -0.03751929f, -0.05385612f, -0.02731726f, 
    0.09614691f, -0.07626099f, -0.05670837f, 0.33094960f, 0.10366417f, 0.11259321f, 0.03640893f, 0.15954375f, 
    -0.04876488f, -0.03120373f, 0.05758336f, -0.01596222f, 0.20525165f, -0.15507051f, -0.05458786f, -0.22883578f, 
    0.07511717f, -0.03734972f, 0.01197399f, 0.12851776f, -0.03223053f, -0.05240610f, 0.02081159f, -0.10410221f, 
    -0.13793130f, -0.10168247f, 0.01314155f, 0.33838373f, -0.11638021f, 0.03413694f, 0.00484543f, -0.03372521f, 
    0.06179566f, -0.03160213f, -0.02920309f, -0.16289805f, 0.20195986f, -0.07420687f, 0.03935236f, 0.15298069f, 
    -0.02053621f, -0.10663430f, 0.00062162f, 0.11329278f, -0.01867397f, 0.09056018f, -0.03632921f, 0.00822435f, 
    -0.16227268f, -0.21314974f, 0.03811338f, -0.06179564f, 0.00953252f, -0.08337662f, 0.07050973f, -0.01556867f, 
    -0.03988888f, 0.04497436f, 0.13244484f, 0.16470377f, 0.32247424f, 0.11478779f, -0.05438282f, 0.05874356f, 
    -0.04760294f, -0.11837301f, -0.08011889f, 0.18489678f, 0.04139790f, 0.10342938f, -0.01534110f, -0.02377267f, 
    -0.08797590f, -0.17064922f, 0.12261608f, -0.04335602f, -0.10989683f, -0.01692394f, 0.08173937f, 0.04275240f, 
    0.11408887f, 0.00622689f, -0.00409488f, -0.01651121f, 0.22988842f, 0.01944899f, -0.12077030f, -0.10816941f, 
    0.05411235f, 0.14568219f, 0.00988493f, -0.04856863f, 0.01560040f, -0.02666670f, -0.11895254f, 0.02169678f, 
    0.15714371f, -0.10013402f, 0.08659972f, 0.01020597f, -0.13815977f, -0.01285611f, 0.11985175f, 0.02413271f, 
    0.09251202f, 0.02967040f, 0.04789202f, 0.12246615f, -0.35913160f, 0.10675438f, 0.03738009f, 0.23984848f, 
    -0.02433419f, 0.05462720f, -0.03190798f, -0.04006295f, -0.05525880f, 0.02167450f, -0.05322425f, -0.11297200f, 
    0.28298604f, -0.04860790f, -0.02442276f, 0.08143254f, 0.04524819f, -0.01562898f, -0.12304113f, 0.07880925f, 
    0.00433988f, -0.10104312f, 0.01747909f, -0.07343952f, -0.08466915f, 0.05063603f, -0.00925196f, -0.11351123f, 
    -0.03219674f, -0.12966119f, -0.06909849f, 0.04620666f, -0.05038000f, -0.06461321f, 0.00068734f, -0.00115720f, 
    -0.12819955f, 0.19144087f, -0.06152471f, -0.33914429f, -0.00496067f, -0.05930518f, 0.10218268f, 0.08916631f, 
    0.03719050f, 0.05150537f, 0.03874889f, -0.00067996f, 0.02404651f, -0.14587897f, 0.00584688f, 0.09599110f, 
    0.05159960f, 0.06660554f, 0.11343426f, -0.02950751f, 0.12404768f, -0.02707571f, 0.02476766f, 0.09483601f, 
    0.01268258f, -0.10290369f, -0.02156666f, 0.24894346f, -0.03017987f, -0.03313305f, 0.04217825f, 0.07354536f, 
    0.05747820f, -0.02711384f, -0.04201792f, 0.04388340f, 0.04970983f, -0.05856127f, 0.17459166f, -0.12487168f, 
    0.04766617f, 0.12114695f, 0.05604340f, -0.00835693f, 0.05201360f, 0.02321588f, -0.02811350f, -0.07999288f, 
    0.01851413f, -0.23291549f, 0.03804937f, 0.09759118f, -0.11871355f, -0.11740728f, -0.02478590f, 0.15190667f, 
    -0.02956217f, 0.00415398f, -0.00959509f, 0.09038807f, -0.05460818f, -0.04744297f, 0.10315682f, 0.13863362f, 
    -0.05432481f, -0.02276302f, 0.06130213f, -0.10226718f, 0.00493846f, -0.03423516f, 0.02573406f, 0.00402764f, 
    0.31498256f, 0.21617681f, 0.00349090f, -0.12282766f, 0.09309778f, 0.07286787f, -0.25955117f, -0.05796714f, 
    0.02829548f, 0.06011306f, -0.01144919f, 0.10414124f, 0.13481468f, 0.05835296f, 0.09411381f, -0.11825250f, 
    0.04821523f, -0.09221886f, 0.14241789f, 0.07917617f, -0.05837747f, 0.07251264f, -0.09547745f, -0.05416241f, 
    -0.19662213f, 0.00919017f, -0.07401779f, -0.26530051f, -0.13702211f, -0.05651510f, 0.00381299f, 0.02181934f, 
    0.01213458f, -0.02014535f, -0.06788904f, 0.04532978f, 0.13969187f, -0.09298846f, 0.13978541f, -0.17127696f, 
    0.07148928f, 0.05240173f, 0.17606230f, 0.07139698f, -0.16815740f, -0.05879209f, 0.04695082f, -0.02667442f, 
    -0.13246341f, -0.12354641f, -0.02590607f, -0.12124379f, -0.11129539f, 0.04239435f, 0.07141537f, 0.10347410f, 
    0.13697757f, 0.02447849f, -0.04629074f, 0.06074827f, 0.25509274f, 0.34475231f, -0.14468004f, -0.17351292f, 
    0.02928321f, 0.02771585f, 0.00745386f, -0.06093354f, 0.08039270f, 0.09120072f, -0.00691011f, -0.11526936f, 
    0.02424585f, 0.17268391f, 0.01127053f, -0.25841168f, 0.02170706f, 0.02311143f, 0.11116447f, 0.08791095f, 
    0.12724145f, 0.01751268f, 0.07520907f, 0.01424986f, -0.02085366f, -0.13251701f, -0.09791910f, 0.28436098f, 
    0.12960866f, -0.01449061f, -0.00201670f, 0.03249916f, 0.05377537f, 0.08288604f, 0.05124811f, -0.01959727f, 
    -0.19856170f, 0.02180559f, -0.03887611f, 0.10105024f, 0.03352233f, 0.02687027f, 0.00186757f, -0.08566181f, 
    0.11741513f, -0.03432010f, 0.08153044f, -0.02658747f, 0.15549955f, -0.08902688f, -0.19339722f, 0.20916651f, 
    -0.02090750f, 0.09610429f, 0.00454615f, -0.10728247f, 0.03145190f, 0.05576387f, 0.01024468f, 0.20364709f, 
    0.20792818f, 0.08720980f, -0.01570228f, -0.01493554f, -0.02910031f, -0.00730556f, -0.03560724f, 0.29511988f, 
    -0.00742355f, 0.12497879f, -0.07994680f, 0.13042550f, -0.02618902f, -0.02545152f, 0.01578353f, 0.02164874f, 
    -0.11846416f, -0.04572763f, 0.14174646f, 0.26551190f, 0.03514111f, -0.03981029f, 0.02987974f, 0.04223545f, 
    -0.02496632f, -0.01778129f, 0.03713915f, -0.12936604f, 0.14909950f, 0.15260340f, -0.00090072f, 0.06392956f, 
    0.01591482f, 0.08332472f, -0.07301668f, -0.05564379f, -0.04106480f, 0.08400111f, 0.16348121f, -0.13368481f, 
    0.07422396f, 0.02727116f, 0.00315469f, 0.12178922f, 0.16770846f, -0.09439396f, 0.11818781f, 0.11141824f, 
    -0.12105948f, 0.18102838f, -0.09260798f, -0.20539732f, 0.03225236f, 0.02839104f, -0.06575970f, -0.08376849f, 
    -0.02778180f, -0.03843099f, 0.09954470f, -0.08039425f, 0.30561376f, -0.15608902f, 0.00433462f, -0.09762420f, 
    -0.13835020f, 0.00853185f, 0.03444050f, 0.00096691f, -0.14958002f, -0.00978630f, 0.05881590f, 0.10814655f, 
    0.00566209f, -0.12890810f, 0.00422698f, -0.00726498f, 0.07270162f, -0.05249083f, 0.02718226f, -0.01567366f, 
    -0.06035117f, 0.08309638f, 0.22444431f, -0.11517171f, 0.17848505f, -0.12423747f, -0.03501406f, 0.20204082f, 
    0.04323664f, 0.03205188f, -0.00362609f, 0.04337255f, 0.00415408f, -0.01205614f, 0.07837396f, 0.01585052f, 
    0.05393596f, -0.08833234f, 0.05634943f, 0.24129698f, -0.09762932f, -0.01308253f, 0.02746516f, -0.01031068f, 
    0.07909518f, -0.09243593f, 0.07627354f, 0.05399206f, -0.15216084f, 0.15870866f, -0.02930488f, 0.08351564f, 
    0.04831029f, 0.07308785f, 0.02914588f, -0.04123269f, 0.05105408f, -0.02228812f, -0.07395609f, -0.08524361f, 
    -0.02189969f, -0.26154596f, 0.11135391f, -0.12451401f, -0.10339627f, -0.02133574f, 0.13321507f, 0.05796978f, 
    -0.01500143f, -0.00907718f, -0.00279035f, -0.03388222f, 0.09187506f, 0.20560570f, 0.01048590f, -0.20033342f, 
    -0.01633027f, 0.02645254f, -0.01792148f, 0.03057536f, -0.00752766f, 0.10639644f, 0.05625256f, -0.08527102f, 
    0.01715011f, -0.15302077f, 0.07970713f, 0.02790044f, 0.12652355f, -0.00798144f, -0.01056401f, 0.08106934f, 
    0.06763957f, 0.02792766f, 0.04674420f, 0.02810895f, 0.29899201f, 0.24968974f, 0.01484341f, 0.02139376f, 
    -0.02019103f, 0.01902658f, -0.05415827f, 0.12090315f, -0.03991781f, 0.05160037f, 0.00077512f, -0.01113570f, 
    0.22091305f, -0.07368715f, -0.03006019f, 0.00516348f, -0.02574721f, 0.07558664f, 0.04595100f, 0.00803877f, 
    0.02141839f, -0.04699958f, 0.03188380f, 0.04064050f, 0.07207611f, 0.13255949f, 0.05400180f, -0.41347980f, 
    0.06081994f, 0.09446580f, 0.05009792f, -0.06836197f, 0.02325411f, 0.00833780f, 0.03288516f, -0.02780773f, 
    0.05749627f, -0.14886197f, 0.00611803f, 0.00765971f, -0.03649587f, -0.09149610f, -0.10267744f, 0.04781904f, 
    0.03544675f, 0.05729792f, 0.05627448f, 0.08795391f, 0.21081203f, -0.01781828f, -0.11782480f, 0.23939827f, 
    -0.06115102f, 0.01408875f, 0.12574533f, 0.02967441f, 0.00581957f, -0.01359272f, 0.08766086f, 0.07117553f, 
    0.00968498f, -0.00453275f, -0.00625381f, -0.01105523f, 0.00192885f, 0.02215555f, -0.03071788f, 0.00612015f, 
    0.00601489f, -0.03080373f, 0.00765949f, -0.03753607f, 0.01080982f, -0.02090411f, -0.00086489f, -0.02985696f, 
    -0.00239722f, -0.02462447f, -0.00382507f, -0.01232302f, 0.02125382f, -0.03594591f, -0.03138694f, 0.00968902f, 
    0.00445794f, 0.00053361f, 0.03089098f, -0.00562879f, 0.02170046f, -0.00692365f, -0.02966519f, 0.03118440f, 
    -0.02993410f, -0.03706792f, -0.02952873f, -0.04006586f, 0.02507652f, -0.00919478f, -0.03307071f, -0.03564555f, 
    -0.03915649f, 0.01230351f, -0.01766382f, -0.01389306f, 0.00445836f, -0.02131339f, 0.02665221f, -0.00719798f, 
    -0.02065607f, 0.02113452f, -0.02415763f, -0.03099254f, -0.04041795f, -0.02304513f, -0.00306520f, -0.02111595f, 
    0.02064665f, -0.00812238f, 0.00454253f, -0.01495248f, -0.03484373f, 0.02759448f, -0.03680187f, -0.00159630f, 
    0.02411791f, -0.01162192f, -0.01140789f, -0.01767108f, -0.01936371f, 0.00040681f, 0.02361442f, 0.01698052f, 
    -0.02238462f, -0.02468368f, -0.00075818f, 0.00713919f, -0.02212740f, 0.01551833f, 0.00852709f, 0.00117270f, 
    -0.02894093f, 0.02068996f, -0.01705811f, -0.00477786f, 0.00283408f, -0.00166307f, -0.02940970f, -0.02100904f, 
    0.02030256f, -0.04088138f, 0.02208305f, -0.01951773f, -0.02412203f, 0.00346546f, 0.02124190f, 0.02175141f, 
    0.01091162f, -0.01672185f, 0.00594002f, -0.02294508f, 0.02708052f, 0.01307300f, -0.00757932f, -0.02976805f, 
    0.04058417f, 0.02037572f, -0.03999859f, 0.03057551f, -0.00733690f, 0.01077357f, -0.03807742f, 0.02588621f, 
    0.00266858f, -0.03072328f, 0.02143509f, 0.02893658f, -0.02920238f, 0.00292237f, 0.01263354f, 0.00361258f, 
    -0.01489054f, -0.00960059f, 0.01542666f, -0.02375077f, 0.01111922f, 0.01537432f, 0.03146061f, 0.01402147f, 
    0.02408958f, -0.03352439f, -0.00086855f, 0.02380589f, -0.03481478f, 0.01234906f, -0.00298318f, -0.00286531f, 
    0.02573191f, 0.02640819f, 0.02128073f, -0.00183903f, 0.00266961f, -0.01813624f, -0.02943730f, 0.02090692f, 
    -0.03424946f, -0.02753164f, 0.00641436f, -0.01940561f, -0.02962233f, -0.02895667f, -0.01665818f, -0.01216129f, 
    0.01660164f, 0.02560798f, -0.01389250f, 0.00877890f, -0.02939305f, -0.02689289f, -0.00771542f, -0.00428621f, 
    -0.02461435f, 0.02131498f, 0.02755993f, -0.00410259f, -0.00026547f, 0.01892775f, -0.02843112f, 0.00184899f, 
    -0.01448029f, -0.00521112f, -0.03300633f, -0.00552118f, -0.01252344f, -0.02034366f, 0.01618020f, -0.04336691f, 
    0.01762068f, -0.01012040f, 0.01259998f, -0.01292924f, -0.04236231f, -0.02814876f, 0.01943897f, 0.02823656f, 
    0.01743528f, 0.02339569f, -0.00697846f, 0.00477120f, -0.02344050f, -0.02311647f, 0.02145969f, 0.02630582f, 
    -0.02970292f, 0.00689045f, 0.00074547f, -0.00044366f, -0.00201515f, -0.02933837f, -0.03189323f, -0.04022877f, 
    -0.01088631f, -0.01411975f, -0.01055384f, -0.01770125f, -0.02099477f, 0.00694735f, -0.01257917f, 0.00434566f, 
    0.00757392f, -0.03718442f, -0.03985771f, 0.01206477f, -0.00956171f, 0.00977236f, -0.04076498f, -0.01757040f, 
    -0.01523587f, -0.01201042f, 0.00536463f, -0.02747263f, 0.01268807f, -0.02883574f, 0.02141958f, 0.01880433f, 
    -0.00771644f, 0.00042323f, 0.01101314f, -0.01493167f, -0.02736255f, -0.03004213f, -0.02668878f, 0.00276920f, 
    -0.03475112f, 0.01747180f, -0.02942576f, -0.02532506f, -0.01998954f, -0.00113246f, -0.00624380f, -0.04180066f, 
    0.00254309f, -0.01173560f, 0.00791574f, 0.00921291f, 0.01521719f, -0.04137473f, 0.00781319f, 0.00324231f, 
    -0.03476562f, -0.03831796f, 0.02395813f, 0.02341823f, 0.00979967f, -0.01952347f, 0.01475260f, -0.02530359f, 
    0.02241008f, 0.02116137f, 0.02282415f, -0.03730436f, 0.00840432f, 0.00117163f, 0.00530922f, 0.02011899f, 
    -0.01283661f, 0.02007372f, -0.00479994f, -0.03176811f, 0.02084797f, -0.00728214f, -0.03871324f, -0.01355022f, 
    0.03240755f, 0.02813190f, 0.02830299f, -0.03863687f, 0.01238807f, -0.02409935f, 0.02734727f, 0.01260441f, 
    -0.02237967f, 0.00105041f, 0.01342973f, -0.00789300f, -0.00908488f, -0.03484822f, 0.02060581f, 0.00140589f, 
    -0.01194729f, -0.03979934f, -0.03997271f, 0.00616941f, -0.00936702f, -0.01671741f, -0.02100298f, -0.01023786f, 
    -0.02670144f, -0.03625849f, -0.00164228f, 0.01520350f, -0.01585542f, 0.01757495f, 0.02258900f, -0.03472935f, 
    0.02449730f, -0.02710639f, 0.00023193f, -0.00341701f, 0.01121140f, 0.00466372f, 0.02113407f, -0.00228372f, 
    -0.00227148f, -0.00431680f, 0.00856468f, -0.02755659f, -0.01629945f, -0.03688577f, -0.02955180f, 0.02583315f, 
    0.02282061f, -0.03419674f, 0.00793122f, 0.02667389f, -0.00698016f, 0.01291604f, -0.01057631f, -0.00290556f, 
    -0.03554566f, -0.02493085f, -0.01393297f, -0.03742430f, -0.00797243f, -0.01406268f, -0.02998145f, -0.03669386f, 
    0.03026952f, 0.02285396f, -0.03213682f, -0.03393373f, 0.02867096f, -0.02479289f, 0.01267932f, -0.00682526f, 
    -0.00890169f, 0.02748491f, -0.01398318f, 0.01053837f, -0.01785594f, -0.03294588f, 0.00022135f, -0.02046641f, 
    -0.03210373f, -0.00104349f, -0.03415937f, -0.02881480f, -0.03014259f, 0.03184189f, 0.00405596f, 0.00190435f, 
    0.01745316f, -0.02610626f, -0.02949018f, -0.02600996f, -0.02793981f, -0.00728322f, -0.01455524f, 0.01297788f, 
    0.01268708f, -0.00041121f, -0.02790599f, -0.00637629f, 0.01407040f, -0.02715198f, -0.01780331f, -0.00160168f, 
    0.01904970f, 0.00965420f, -0.03085382f, -0.01106490f, 0.02795817f, -0.02974065f, 0.00306338f, -0.02211610f, 
    0.02087506f, 0.01446518f, -0.01775078f, 0.02187831f, 0.00452813f, 0.00336708f, 0.03974396f, -0.00267824f, 
    -0.00678926f, 0.01229833f, 0.01761884f, -0.01338364f, 0.01302604f, 0.02610331f, 0.01126897f, -0.01842025f, 
    -0.00859252f, 0.01185966f, -0.01577498f, -0.03993114f, 0.03090302f, -0.02673818f, -0.00496880f, -0.01860750f, 
    -0.04046371f, -0.01538910f, -0.01701466f, -0.02982545f, -0.00632569f, -0.00922779f, -0.02307476f, -0.03413274f, 
    -0.01667738f, 0.00649152f, -0.04384230f, 0.00254594f, -0.02919378f, -0.02251743f, 0.01851558f, -0.04403644f, 
    -0.03214163f, 0.01446851f, 0.01491623f, -0.04027947f, -0.02320335f, -0.02591663f, 0.00327608f, -0.00811803f, 
    -0.04043587f, -0.01339551f, -0.00907618f, 0.02548542f, 0.02488649f, 0.01138873f, 0.01482149f, -0.01433159f, 
    0.01389310f, -0.03039197f, 0.02690068f, 0.00855487f, -0.00010602f, -0.04270955f, 0.00884538f, -0.03008954f, 
    -0.02071475f, 0.01242690f, 0.01937601f, 0.01138441f, -0.01363767f, 0.00117281f, -0.00860135f, 0.02847736f, 
    -0.02587887f, -0.01971946f, -0.00025704f, 0.02598961f, 0.00738357f, 0.01328383f, -0.00821427f, 0.02413490f, 
    -0.02163690f, -0.01265420f, 0.00537895f, 0.03056514f, 0.00544650f, -0.01132161f, -0.03302876f, 0.01250303f, 
    -0.00258548f, -0.02951859f, 0.00893308f, 0.01592265f, 0.01996125f, -0.03155229f, 0.00987845f, -0.00211246f, 
    0.03446911f, 0.02018289f, -0.01309350f, 0.03458661f, -0.03603479f, 0.00452684f, -0.00626523f, -0.02937188f, 
    -0.02922274f, -0.01857412f, 0.00864586f, 0.01812140f, 0.02631379f, -0.03150379f, -0.03565162f, 0.00924082f, 
    -0.01237349f, -0.01002689f, -0.01936023f, -0.03900875f, 0.00277742f, 0.02523070f, 0.01493785f, -0.01494065f, 
    -0.04383065f, -0.03887514f, -0.01807049f, 0.00175413f, -0.00620820f, 0.02620603f, -0.03819077f, 0.00096491f, 
    -0.02324912f, 0.00594679f, -0.00150318f, -0.04081933f, 0.01155320f, -0.03675989f, -0.03601612f, 0.02439256f, 
    -0.01172763f, 0.00415860f, -0.00084621f, 0.02599066f, -0.00085180f, 0.02473214f, 0.01064047f, -0.03189008f, 
    -0.03712360f, 0.01120459f, 0.02004828f, 0.00882411f, -0.03324730f, -0.02861052f, 0.03258501f, -0.01029393f, 
    0.02156851f, 0.00442508f, 0.01412654f, -0.00184782f, -0.03928688f, -0.00415540f, -0.01774706f, 0.01368299f, 
    -0.04355955f, 0.00547485f, -0.00166138f, 0.02059191f, -0.01364702f, 0.00527172f, -0.02416597f, 0.00592621f, 
    0.00246614f, 0.02402587f, -0.03580499f, -0.00336242f, -0.03645115f, -0.02048808f, -0.03484340f, -0.00168367f, 
    -0.00758046f, -0.00457539f, 0.00383785f, 0.02378690f, 0.00755085f, 0.01675164f, 0.00518851f, 0.01758822f, 
    0.02257333f, 0.00133583f, -0.03095987f, -0.01588813f, -0.03353365f, -0.03176575f, -0.03092795f, -0.00208504f, 
    -0.02899105f, -0.00478172f, 0.01553725f, 0.02221780f, 0.00930761f, -0.01879831f, -0.00564568f, 0.02858461f, 
    -0.04008875f, -0.02467092f, -0.00446477f, 0.01528917f, -0.01987176f, -0.02145152f, -0.00948658f, 0.00340221f, 
    0.01364655f, 0.00949057f, 0.02532501f, -0.03291552f, 0.02418398f, -0.01285083f, 0.00102867f, 0.02492459f, 
    0.01175239f, -0.02719914f, -0.02213395f, 0.03167066f, -0.00433470f, 0.01387994f, -0.02883428f, -0.00478509f, 
    -0.03783319f, -0.01881123f, -0.01632620f, -0.01019269f, -0.00799153f, -0.00428869f, -0.02133034f, -0.03040981f, 
    -0.01321488f, -0.02027752f, 0.01947456f, 0.02153002f, -0.00585582f, 0.02313926f, 0.00544310f, 0.02547978f, 
    0.01147571f, -0.01113454f, -0.01531224f, -0.00735720f, 0.01432466f, -0.03556887f, 0.00848477f, -0.02022160f, 
    0.00562940f, -0.02138425f, -0.00784366f, -0.02055749f, -0.03018783f, 0.00644687f, -0.03783401f, 0.00856820f, 
    0.02389104f, -0.03206398f, 0.01160489f, 0.02329027f, 0.00956770f, 0.02788460f, -0.01724494f, 0.00777635f, 
    0.02898191f, -0.02127360f, 0.01881293f, 0.00790030f, -0.03742928f, 0.02163215f, -0.00000006f, 0.02688110f, 
    0.00138174f, 0.00707316f, 0.01770175f, -0.03840782f, -0.01171752f, 0.00553452f, -0.03540431f, -0.03656205f, 
    -0.01398263f, -0.02986149f, -0.00349254f, 0.02058720f, -0.01206717f, -0.02417357f, -0.00754279f, 0.00401107f, 
    -0.02079176f, -0.03297037f, -0.03096911f, -0.01063573f, -0.01955331f, -0.01775815f, 0.00935149f, -0.00779575f, 
    -0.04179333f, -0.03655931f, 0.01145473f, -0.01932111f, 0.01201099f, -0.00785710f, -0.02991737f, -0.02538938f, 
    -0.04349126f, 0.00412248f, 0.00885245f, 0.00238200f, -0.03159399f, -0.01884022f, 0.00495860f, -0.01806200f, 
    -0.01292257f, -0.02809672f, -0.03465432f, 0.02633654f, -0.02543912f, -0.00229036f, 0.03720840f, 0.02943083f, 
    -0.01358362f, -0.01614065f, 0.01261941f, 0.01527805f, -0.04236881f, 0.01886250f, -0.01626952f, -0.03031815f, 
    -0.01110356f, 0.04019124f, 0.00637259f, 0.02349995f, -0.01972514f, 0.02196786f, -0.00176320f, -0.02123270f, 
    -0.00852931f, 0.02348906f, 0.02258491f, 0.01857878f, -0.01551080f, -0.03897409f, -0.02560866f, 0.00094378f, 
    -0.02227690f, -0.02926647f, -0.03013346f, -0.01405618f, -0.01825895f, 0.01745958f, 0.00026253f, 0.02978613f, 
    0.01659065f, -0.00248157f, -0.03237857f, -0.00512348f, -0.02546353f, -0.04124795f, 0.01290838f, 0.03534584f, 
    0.01736692f, 0.02233273f, 0.02448270f, -0.00100808f, 0.02330531f, 0.01217781f, -0.03460046f, -0.03029130f, 
    -0.00827965f, 0.04188178f, 0.01040546f, 0.01196434f, 0.01975195f, -0.00094108f, 0.00404729f, 0.00459821f, 
    0.02538894f, -0.00916206f, 0.02770452f, 0.00319893f, 0.00691775f, -0.01739699f, -0.02869360f, -0.02880228f, 
    0.01895448f, 0.02870224f, 0.02015228f, -0.01823167f, 0.00930150f, 0.00015996f, -0.02539462f, -0.02778985f, 
    0.01545769f, -0.02665536f, 0.02457360f, 0.01055134f, -0.01137558f, 0.00970812f, -0.01932420f, 0.03310706f, 
    -0.03319007f, -0.03393011f, 0.03074487f, -0.03288764f, -0.00502788f, 0.02913227f, 0.02867241f, -0.01172237f, 
    0.00732117f, 0.01738942f, -0.03511149f, -0.00302049f, 0.01666406f, 0.00689148f, 0.03071100f, -0.01116304f, 
    0.02377523f, -0.00838640f, -0.01958490f, -0.04012658f, 0.01450141f, 0.00150832f, -0.03683873f, 0.01873732f, 
    0.01484667f, -0.02065675f, -0.02933153f, 0.03268069f, 0.01348871f, -0.03824978f, -0.02811946f, -0.01630735f, 
    0.00222107f, -0.01168356f, 0.01244374f, -0.01284995f, 0.00123840f, -0.02851788f, -0.01340773f, 0.01758950f, 
    -0.03646236f, 0.02524027f, -0.03157953f, -0.00338548f, -0.00327618f, -0.00968100f, 0.00958063f, 0.02665036f, 
    0.01528918f, 0.02142445f, 0.03025911f, -0.01903659f, -0.00947803f, -0.02746461f, -0.00593691f, 0.00591994f, 
    0.02209909f, -0.03457533f, 0.02203071f, 0.02733262f, 0.03476300f, -0.03551982f, -0.01758263f, 0.02541123f, 
    -0.02083722f, -0.03752517f, -0.03219389f, -0.00735378f, 0.02027697f, 0.03359696f, -0.00871382f, 0.02760817f, 
    0.03005929f, -0.02907053f, -0.02982859f, -0.02356406f, -0.02717540f, -0.03914170f, -0.03690899f, -0.00690334f, 
    0.01251935f, 0.00547032f, 0.02216551f, -0.00961499f, 0.02493625f, -0.02547768f, 0.03065206f, -0.00297236f, 
    -0.01590933f, -0.03815736f, 0.01991003f, -0.03542752f, 0.01137602f, -0.01667717f, -0.02606729f, -0.00837003f, 
    -0.03444555f, 0.00451676f, -0.01212587f, -0.03833449f, -0.00023958f, 0.03011824f, 0.01295949f, -0.01145157f, 
    -0.00807627f, -0.02044553f, -0.01251846f, -0.03513299f, 0.00281057f, 0.03202885f, 0.02694576f, 0.02879718f, 
    -0.00382093f, -0.03835689f, -0.02250024f, 0.00786787f, 0.01875085f, -0.01176474f, 0.00340613f, -0.02970003f, 
    0.02948472f, -0.01627180f, -0.00803110f, -0.02599563f, -0.00080825f, -0.01683930f, -0.00745645f, -0.03689196f, 
    -0.03969625f, -0.03629747f, -0.00548393f, 0.00024460f, -0.00545760f, 0.01255257f, -0.01051064f, 0.01844108f, 
    0.00845284f, -0.01158782f, 0.02760525f, -0.02683355f, -0.03770628f, -0.00973970f, 0.02796130f, -0.00035645f, 
    0.02866352f, -0.01328277f, 0.00204905f, -0.01465807f, -0.03565944f, -0.02874624f, 0.01843764f, -0.01084020f, 
    -0.02391396f, -0.00234173f, 0.01028223f, -0.00697877f, 0.03189099f, 0.00467724f, -0.00496426f, -0.01564611f, 
    0.02379917f, -0.03181462f, -0.03206575f, 0.01082785f, -0.00889849f, -0.01977277f, 0.00769489f, 0.01687368f, 
    0.01770118f, 0.00148945f, 0.01401775f, 0.00516937f, -0.01973339f, 0.00967850f, -0.01302315f, 0.01622815f, 
    0.00729104f, 0.01946016f, -0.02613147f, -0.02477501f, -0.03018717f, 0.02540925f, -0.00364001f, -0.02804628f, 
    0.01190725f, -0.00482626f, 0.01686746f, 0.01835720f, -0.01005866f, 0.00368877f, 0.01665703f, -0.02222473f, 
    -0.01007156f, 0.03016367f, 0.00659467f, 0.02544972f, -0.01562192f, -0.02852106f, 0.00472925f, 0.03112883f, 
    -0.01211535f, 0.00762781f, 0.00783654f, 0.02255932f, 0.01543573f, 0.00107055f, -0.02109282f, -0.01563769f, 
    0.03217830f, -0.00187762f, 0.03001247f, 0.00723646f, 0.02458587f, -0.02189742f, 0.02303208f, 0.00997599f, 
    -0.01228294f, 0.01930882f, 0.00579080f, -0.03669597f, -0.00367993f, -0.00446479f, 0.00796633f, 0.00951762f, 
    0.00406259f, 0.01075924f, 0.02204621f, -0.01051488f, -0.03759814f, -0.00390313f, -0.00412829f, -0.01112235f, 
    -0.02695154f, 0.02123610f, -0.03498742f, -0.03663765f, -0.02966820f, 0.00424988f, -0.00830321f, -0.00029612f, 
    -0.00603842f, 0.00429048f, 0.02060082f, 0.01921570f, -0.00391701f, -0.03074847f, -0.03556488f, -0.00075245f, 
    0.01845402f, -0.02336719f, 0.00592146f, -0.01327542f, 0.01998389f, -0.02603856f, 0.01095604f, -0.02274235f, 
    -0.01581806f, 0.00937123f, -0.00476045f, 0.00879665f, 0.03037409f, 0.01285204f, 0.02638994f, -0.02200749f, 
    -0.02352894f, -0.01613835f, -0.00249886f, -0.01424538f, -0.00525624f, 0.01772494f, 0.01430873f, 0.00886710f, 
    0.01891286f, 0.03203569f, -0.01555897f, -0.00650510f, 0.02621271f, 0.02654629f, -0.00826689f, -0.03820037f, 
    -0.01342344f, 0.02658824f, 0.02484794f, -0.01750000f, 0.02926278f, -0.01253168f, 0.02430610f, 0.00752062f, 
    0.02366792f, -0.03775651f, -0.00163224f, 0.01598970f, 0.03036308f, -0.00513635f, -0.02907282f, 0.01004598f, 
    -0.00733197f, -0.01792733f, 0.00397657f, -0.03179353f, 0.00186927f, -0.02099070f, -0.01414424f, -0.02231841f, 
    -0.02082112f, 0.02539222f, -0.01155866f, -0.03101004f, -0.00479787f, -0.01511141f, 0.00462356f, 0.03037788f, 
    0.02068636f, 0.00559327f, -0.01807782f, 0.00074588f, 0.00408749f, 0.02419968f, 0.00281108f, 0.00736079f, 
    -0.03543363f, -0.03279960f, 0.00174177f, -0.02386847f, 0.00050620f, 0.01984868f, 0.00421779f, -0.00676257f, 
    0.03372474f, -0.00844881f, 0.00710131f, -0.02165472f, 0.01892243f, -0.02466762f, 0.02010171f, 0.00996196f, 
    0.01550654f, -0.00679077f, 0.00850165f, 0.00209994f, -0.00387690f, 0.02681347f, 0.02872367f, -0.00234364f, 
    -0.00254023f, -0.03632429f, -0.01495284f, 0.03194384f, -0.00470755f, 0.03085252f, -0.01402641f, -0.02651318f, 
    0.03068691f, 0.00957829f, -0.02551067f, -0.01840876f, 0.03409277f, 0.03117418f, -0.03950101f, 0.01236364f, 
    -0.01314345f, -0.02377399f, 0.01946892f, 0.01571173f, 0.02933310f, -0.00928614f, 0.00224745f, -0.01776600f, 
    -0.01663471f, -0.03632323f, -0.02242374f, 0.01528307f, -0.00307246f, -0.00591756f, -0.03539870f, -0.02573460f, 
    0.02004873f, 0.00844760f, -0.02126318f, 0.02252662f, -0.00269108f, 0.00190554f, 0.01942415f, 0.00005132f, 
    0.01658185f, -0.00120265f, 0.02464513f, -0.03424211f, 0.00418483f, -0.00566924f, -0.01789217f, -0.03936154f, 
    -0.02684921f, 0.00863315f, 0.01674187f, 0.00589646f, -0.02583464f, -0.00427580f, -0.02618704f, -0.00560087f, 
    0.00882816f, 0.00202837f, 0.01581225f, -0.01400762f, -0.00734337f, -0.02588517f, 0.00324043f, -0.03041993f, 
    -0.02255225f, -0.01632444f, -0.02443847f, -0.02427684f, -0.03678268f, -0.02762722f, 0.00929788f, 0.00425346f, 
    -0.00672094f, -0.02484500f, -0.01952743f, 0.00205597f, -0.00823808f, -0.01633978f, 0.02006081f, -0.00836250f, 
    -0.00266049f, -0.03760903f, -0.00817786f, -0.01683393f, 0.01773249f, 0.02945562f, -0.01223417f, -0.03259407f, 
    -0.02214364f, 0.01182856f, -0.00134867f, -0.01138105f, 0.00216457f, -0.02687700f, -0.03298135f, -0.00854203f, 
    -0.00678647f, 0.02392875f, 0.00039521f, -0.00639151f, 0.01455400f, -0.02772719f, -0.02786191f, 0.00313475f, 
    -0.00277891f, 0.02960436f, -0.01704787f, -0.00857553f, 0.03292353f, -0.02539811f, 0.02358216f, 0.01969484f, 
    0.01327462f, -0.03293623f, 0.01643977f, 0.00937985f, -0.02969794f, 0.00445277f, 0.00790110f, -0.00619207f, 
    -0.01023282f, -0.00555119f, -0.01241536f, -0.01558409f, 0.02768755f, 0.00416317f, -0.00753215f, -0.01233995f, 
    -0.00560845f, 0.02383863f, 0.01310728f, 0.01771718f, -0.00131786f, -0.02110986f, 0.02518409f, -0.03024206f, 
    0.02462466f, -0.02371175f, 0.02437309f, -0.02411287f, 0.02185824f, -0.02990042f, -0.04000442f, -0.04043113f, 
    0.02668788f, 0.00850007f, 0.02439664f, -0.01364651f, -0.00395114f, -0.02951979f, -0.03220195f, 0.00315763f, 
    -0.01638502f, -0.03341929f, -0.02861621f, -0.00119801f, 0.01065530f, -0.02788482f, -0.03903724f, 0.01833558f, 
    -0.01392746f, 0.02571322f, -0.02608877f, -0.01994298f, -0.00556483f, -0.02457085f, 0.00801795f, -0.03782550f, 
    0.03240358f, 0.00141874f, -0.00768801f, -0.02291620f, 0.03886161f, -0.02279424f, -0.01274326f, -0.00364765f, 
    -0.00008559f, -0.02964532f, 0.00411870f, 0.00730299f, -0.00621581f, 0.02998581f, 0.02198823f, -0.00190249f, 
    0.01137081f, -0.00826713f, -0.01003578f, 0.02190762f, 0.02202522f, 0.02627864f, -0.03435773f, -0.03251999f, 
    -0.01079502f, -0.00383129f, -0.03624480f, -0.00210459f, -0.00367134f, -0.00994031f, 0.00136240f, 0.00914779f, 
    0.01632490f, 0.02315001f, -0.00038790f, 0.02758357f, -0.03831044f, 0.00455292f, -0.03916578f, -0.02140493f, 
    -0.01142441f, -0.02068543f, 0.00573900f, -0.01657618f, 0.00584090f, -0.01709046f, -0.03691886f, -0.03669262f, 
    0.02944551f, -0.03289215f, 0.01337160f, 0.00613718f, 0.00883543f, -0.02702609f, 0.00165931f, 0.00286481f, 
    0.00850022f, 0.02483339f, -0.02924840f, 0.00681951f, -0.02187593f, 0.00359334f, -0.01866511f, -0.01648230f, 
    -0.03158233f, -0.02540308f, 0.00566489f, -0.01655057f, 0.02731206f, -0.03126349f, -0.00034934f, -0.02046017f, 
    0.00868005f, -0.00968786f, 0.02295250f, -0.00080862f, 0.03007144f, 0.02801945f, 0.00777974f, -0.00514195f, 
    -0.03394975f, 0.01213950f, -0.01909525f, 0.01014978f, -0.00921247f, 0.00171700f, 0.03258847f, -0.04150890f, 
    -0.00488552f, -0.01961019f, -0.03299364f, 0.00243878f, -0.03315636f, -0.03448467f, 0.01186682f, -0.00779872f, 
    0.02101135f, -0.00626186f, -0.00387156f, -0.01324411f, 0.00523786f, -0.00733956f, -0.00630122f, -0.02902674f, 
    -0.03541756f, 0.00994951f, -0.00950808f, -0.03818075f, 0.01714564f, -0.03683660f, -0.02157148f, 0.03053547f, 
    0.01192528f, -0.03590653f, -0.00304049f, 0.01124629f, -0.00622383f, -0.02942961f, -0.01439712f, -0.01248282f, 
    -0.03429399f, -0.00748676f, 0.02961171f, -0.00524386f, -0.00317277f, -0.00925420f, 0.01601294f, 0.02401107f, 
    0.01158546f, -0.03094431f, 0.00004686f, 0.00324400f, 0.03105225f, 0.02337291f, 0.01996318f, 0.02114983f, 
    -0.03098336f, -0.02561419f, 0.03142533f, -0.02259004f, 0.01777859f, 0.03202153f, -0.02122510f, -0.01175691f, 
    0.01826657f, -0.03335002f, 0.03355401f, -0.01671316f, 0.01838903f, -0.02248229f, 0.01626121f, 0.01793720f, 
    0.00176565f, -0.01007884f, -0.01191198f, -0.03053463f, -0.00866802f, -0.00855768f, 0.02666289f, 0.01540667f, 
    0.03225483f, -0.00808419f, -0.02649502f, 0.02863832f, 0.02402420f, -0.03945287f, -0.03721835f, -0.03422438f, 
    -0.01746005f, -0.01425678f, -0.03501306f, 0.02624849f, -0.01368906f, -0.01753628f, 0.02872020f, -0.01012167f, 
    -0.02455342f, -0.03046214f, -0.00449680f, 0.02268947f, -0.03237395f, -0.00603228f, -0.01643108f, 0.01788051f, 
    -0.02641531f, -0.03385082f, 0.01427415f, 0.02322633f, -0.02576182f, 0.00111159f, 0.00721938f, -0.01699742f, 
    -0.03280847f, 0.01903463f, -0.03194783f, 0.00630528f, -0.00807768f, 0.01116062f, -0.00229224f, 0.00604984f, 
    0.01982934f, -0.01674266f, -0.03291326f, 0.01286304f, -0.01689988f, -0.00275417f, 0.00032129f, 0.00613295f, 
    0.00584026f, 0.02205835f, 0.00740416f, -0.01596610f, 0.00143879f, -0.00763098f, -0.02435551f, -0.01429237f, 
    -0.00017808f, 0.01274626f, 0.03210543f, 0.00298344f, 0.01314793f, 0.02902088f, 0.00600646f, 0.01998494f, 
    -0.01962729f, -0.02251076f, -0.02927586f, 0.00257270f, -0.00090191f, -0.02251765f, -0.01022082f, -0.02897843f, 
    -0.03034913f, -0.02544999f, 0.00046255f, -0.00996821f, -0.02898470f, 0.03340579f, -0.02020676f, 0.03083178f, 
    -0.02529174f, -0.00866983f, 0.01642800f, -0.01669196f, -0.02654198f, -0.01979397f, -0.02897386f, 0.00973933f, 
    0.02574268f, 0.02110291f, 0.02502239f, 0.01180287f, -0.01672169f, 0.01487638f, -0.01642827f, -0.01882822f, 
    0.01802984f, 0.02455551f, 0.02877853f, -0.04131022f, 0.02810387f, 0.00514604f, -0.03051699f, 0.02294702f, 
    -0.02523579f, 0.02131305f, 0.02628486f, -0.00877859f, 0.02032298f, -0.02542190f, 0.02885086f, -0.01785399f, 
    0.00978308f, -0.03627708f, -0.03857127f, -0.00114239f, -0.00139009f, -0.00829666f, 0.00671754f, -0.02744649f, 
    -0.03434157f, -0.02999751f, -0.01905657f, -0.03987197f, 0.02600459f, -0.01324105f, -0.00095105f, 0.00746447f, 
    -0.02699911f, -0.01795433f, -0.03258909f, -0.02579501f, -0.00919440f, 0.02374139f, -0.00104033f, 0.00070793f, 
    0.01340465f, 0.00840334f, -0.03546562f, 0.00745326f, -0.01908759f, 0.01582347f, -0.00950084f, -0.03939841f, 
    0.02339972f, -0.03751012f, 0.01703444f, -0.00133761f, -0.01953030f, 0.00333839f, -0.02748507f, 0.03518323f, 
    -0.03584125f, -0.01168970f, 0.03176652f, 0.01852942f, 0.03954227f, -0.00509139f, 0.01280382f, -0.03062088f, 
    0.01319238f, -0.01444033f, -0.02641056f, 0.00503849f, 0.02694712f, -0.00934567f, -0.02304377f, 0.00165631f, 
    -0.03274411f, -0.02495847f, -0.01659154f, 0.01276476f, -0.02837177f, -0.00614126f, -0.03034158f, 0.00451887f, 
    -0.02728048f, -0.03760172f, -0.01221910f, -0.01738769f, 0.00602190f, 0.00789549f, -0.02020428f, 0.00714000f, 
    0.00794175f, 0.02765130f, -0.03463476f, 0.00467488f, 0.00807615f, 0.01726951f, -0.00681507f, -0.00187654f, 
    0.00098158f, -0.02992961f, -0.00974915f, -0.03787868f, 0.00899060f, 0.00611616f, 0.01248728f, 0.04004407f, 
    -0.00796984f, -0.03925326f, 0.02012192f, 0.00335766f, 0.03237971f, -0.02068347f, -0.01939136f, -0.03346189f, 
    -0.00609647f, 0.00589487f, -0.00618669f, -0.02816812f, -0.00188156f, -0.01889222f, -0.03577373f, 0.00327910f, 
    0.00876113f, 0.01016635f, -0.01335118f, -0.02140933f, 0.02098658f, 0.02347571f, -0.02070344f, -0.01108868f, 
    -0.03955032f, -0.02986959f, 0.00456405f, -0.02314274f, -0.00843948f, -0.01670860f, 0.02187944f, -0.00666251f, 
    0.00015772f, 0.00488898f, -0.00402446f, -0.01283099f, 0.00732782f, 0.00126122f, 0.03229455f, -0.01503933f, 
    -0.00244888f, 0.02917735f, -0.03168556f, 0.00898326f, 0.00110966f, 0.02622524f, -0.03336371f, -0.02649169f, 
    0.00260085f, -0.03818373f, -0.01464723f, 0.03982025f, 0.02341945f, -0.01683068f, 0.02687494f, 0.00284071f, 
    0.02229131f, 0.02429807f, -0.01917516f, 0.02946224f, 0.00252667f, -0.03311714f, 0.01143383f, 0.00772883f, 
    -0.02119614f, -0.01787671f, 0.00542299f, 0.02861925f, -0.00519795f, -0.01483905f, -0.02373067f, -0.00002091f, 
    -0.03192280f, -0.02384906f, 0.00570640f, -0.03266713f, -0.03778449f, 0.04122045f, -0.03836285f, -0.03312870f, 
    0.02379113f, 0.02464833f, -0.00035904f, -0.02859501f, 0.00972570f, -0.03160257f, 0.02505265f, -0.03673407f, 
    0.01535590f, -0.00682932f, -0.01573988f, -0.02049306f, -0.01637927f, 0.00390282f, 0.01427011f, 0.01492164f, 
    -0.02390611f, 0.01716067f, 0.00129118f, -0.01873742f, -0.01290731f, -0.04070233f, -0.00520012f, -0.03454563f, 
    0.00327245f, 0.03509004f, -0.02944628f, -0.02478921f, -0.03421260f, 0.02118195f, 0.00385362f, -0.03084691f, 
    0.03920681f, -0.02448087f, 0.01733365f, 0.01576126f, 0.01337145f, 0.01940088f, -0.03438690f, 0.03665711f, 
    0.02286433f, -0.02897432f, -0.00561498f, 0.02452858f, -0.01844813f, -0.00261549f, -0.01347825f, -0.01106466f, 
    -0.02416142f, -0.01174124f, -0.02111820f, 0.03151983f, -0.02633093f, 0.00869143f, -0.01054493f, 0.01935321f, 
    -0.00162054f, 0.01553833f, -0.03024616f, 0.00081054f, -0.00185040f, -0.00711862f, -0.02750877f, -0.00138657f, 
    0.03879631f, -0.01937998f, -0.02846818f, -0.02748763f, -0.02716986f, -0.00798744f, -0.03394174f, -0.02117508f, 
    -0.03601264f, -0.00852232f, 0.01779799f, -0.01477286f, 0.02832482f, 0.02279025f, -0.01146789f, -0.02597234f, 
    0.00816162f, -0.01925899f, 0.00549377f, -0.04062143f, -0.01512962f, 0.03744266f, 0.02785902f, 0.00487107f, 
    0.01254060f, 0.01918276f, 0.00771785f, -0.00881182f, -0.00626844f, -0.00745695f, 0.02781742f, -0.00995576f, 
    -0.00486594f, 0.03883787f, 0.02667425f, -0.02779979f, 0.01961999f, 0.02844652f, 0.00592208f, 0.02600918f, 
    -0.02680738f, -0.03484045f, 0.00095966f, 0.01569487f, -0.01919220f, -0.02879398f, -0.01258023f, -0.00131047f, 
    0.00380204f, -0.01546135f, 0.04137404f, -0.04093340f, -0.00842849f, -0.01415213f, -0.01951758f, 0.02512834f, 
    -0.00768920f, 0.01873760f, 0.01796590f, 0.01599060f, -0.00538580f, -0.01660147f, 0.00849568f, -0.03812549f, 
    -0.00768274f, -0.00084833f, -0.01017201f, 0.00640213f, -0.02113427f, -0.01797963f, -0.02903995f, -0.01202447f, 
    -0.01451152f, 0.01281878f, 0.02576415f, -0.00712520f, -0.03562109f, -0.02952647f, 0.00753632f, 0.01880710f, 
    -0.02422240f, 0.01724278f, -0.02165561f, -0.01579627f, 0.02585620f, 0.00217128f, 0.02952917f, 0.02674194f, 
    0.02074449f, 0.02490783f, 0.00764510f, -0.00659235f, -0.01803877f, -0.01625575f, -0.00762194f, 0.02517764f, 
    0.00394414f, -0.01011148f, -0.00125952f, -0.03603241f, -0.00362127f, 0.01002508f, -0.02851622f, 0.01821127f, 
    -0.02913293f, 0.02040493f, -0.02739699f, -0.03457977f, 0.02698148f, -0.01916376f, 0.01967441f, -0.00950811f, 
    0.00313487f, 0.01206271f, -0.03729148f, -0.01822629f, 0.00898587f, -0.00970063f, 0.02026366f, -0.01583764f, 
    -0.01772811f, -0.01468006f, 0.02075894f, 0.03021058f, -0.03064758f, 0.01058736f, -0.00438220f, -0.00584019f, 
    -0.00504647f, -0.03018215f, -0.01549197f, -0.00876073f, -0.02274461f, 0.01530367f, -0.03538245f, -0.01788364f, 
    -0.01146270f, -0.03488333f, -0.03977605f, 0.01383151f, 0.00174332f, 0.02110326f, -0.03815032f, 0.02973908f, 
    -0.01915922f, 0.02210120f, 0.02621216f, -0.00676453f, 0.02817470f, 0.01612249f, -0.00596259f, 0.02195710f, 
    0.01515761f, -0.00437301f, -0.02800495f, 0.00158404f, -0.03019626f, 0.02965367f, -0.02033938f, 0.01354119f, 
    0.01179524f, -0.03984238f, 0.02811921f, -0.02769468f, -0.00362867f, 0.00759684f, 0.02764708f, -0.00206094f, 
    -0.00903493f, 0.01024892f, 0.02910169f, 0.01135807f, 0.02922119f, -0.00482069f, -0.02250892f, -0.03424006f, 
    -0.02887578f, 0.03265099f, -0.02876572f, 0.01293468f, 0.01834598f, 0.00158561f, -0.02071050f, -0.01965257f, 
    -0.03735781f, -0.00513694f, -0.02858996f, 0.01181733f, 0.00594302f, -0.00961089f, 0.01810219f, 0.02379820f, 
    -0.02109081f, 0.01316935f, -0.01359922f, 0.02935755f, -0.02045023f, -0.02268976f, 0.00157622f, 0.01209672f, 
    -0.00469531f, 0.02762399f, 0.01929059f, 0.01737455f, -0.03347241f, -0.01093303f, 0.00169857f, -0.03700389f, 
    -0.02699343f, 0.03875371f, -0.01051518f, 0.01071655f, -0.03687261f, -0.03127513f, 0.03706770f, -0.02281622f, 
    -0.00929002f, -0.00028905f, -0.03858288f, -0.00328888f, -0.04051283f, -0.03950030f, 0.00370259f, 0.02365010f, 
    0.00786969f, 0.02784781f, 0.01565034f, 0.02758675f, 0.00865890f, -0.01670544f, 0.01847209f, 0.01638282f, 
    0.02963725f, 0.01663241f, -0.02137775f, -0.01417192f, -0.02904460f, 0.00436020f, -0.01511531f, 0.03180012f, 
    -0.01027024f, 0.01519659f, -0.03565164f, 0.01347981f, -0.01434365f, 0.00124067f, -0.03772134f, -0.01026815f, 
    -0.02186138f, 0.03484301f, -0.01231722f, -0.01022890f, 0.01056698f, 0.02572932f, -0.01762548f, 0.03021138f, 
    0.03063269f, -0.01020840f, 0.00121133f, -0.00933220f, -0.03267122f, 0.02404192f, 0.01509245f, 0.00440007f, 
    -0.03971556f, -0.03669191f, -0.01884867f, 0.01517532f, -0.03888374f, -0.02405830f, -0.00101336f, 0.00204108f, 
    -0.02679536f, 0.02306999f, -0.02007422f, -0.00419471f, -0.01777586f, 0.02826159f, 0.02429841f, -0.00583354f, 
    -0.00645318f, -0.01665109f, -0.02944395f, -0.01379504f, -0.02347548f, -0.03905107f, -0.01166921f, -0.01929087f, 
    -0.01785832f, -0.01932249f, 0.02291176f, -0.03297931f, -0.01246733f, 0.02673374f, -0.00757670f, -0.03581731f, 
    -0.03881672f, 0.03694657f, -0.02247722f, -0.03158721f, 0.02741073f, 0.01702488f, 0.02409687f, 0.02204105f, 
    0.00580192f, 0.03868743f, -0.02460999f, 0.01692710f, -0.02799029f, -0.02787293f, -0.02852172f, -0.02103783f, 
    0.02512777f, 0.04051487f, 0.02642991f, 0.02948093f, 0.03121114f, 0.01229110f, -0.01107031f, 0.01393561f, 
    0.02574608f, -0.01130407f, 0.02416807f, -0.01919268f, 0.02557892f, 0.00283707f, -0.01171564f, 0.01686004f, 
    0.02857756f, -0.03085919f, 0.00789702f, -0.03075663f, 0.00951541f, -0.02715522f, 0.02884771f, 0.02730380f, 
    0.00613982f, -0.02536803f, -0.00089270f, 0.02127067f, 0.00784359f, 0.00425969f, 0.00620986f, -0.02978755f, 
    -0.01170964f, 0.00799378f, -0.03107658f, -0.03331463f, -0.01508101f, 0.01487124f, 0.02961890f, -0.02036739f, 
    -0.03969708f, 0.04135003f, 0.03011944f, -0.02798177f, 0.02470473f, -0.02488946f, -0.02454717f, -0.01068163f, 
    0.02135570f, 0.02770304f, 0.02337869f, -0.00853682f, -0.03933952f, -0.04012311f, -0.00332729f, -0.01551479f, 
    -0.00905380f, 0.00904467f, -0.03911311f, -0.00531434f, -0.02059547f, 0.00900378f, 0.02958404f, 0.02744138f, 
    -0.04075954f, -0.00900559f, 0.01282736f, -0.02236250f, 0.01825714f, -0.02875321f, 0.01602474f, 0.00792327f, 
    -0.02068255f, -0.03173736f, 0.02089570f, -0.01956702f, 0.03158173f, 0.02464511f, -0.03446461f, -0.01174419f, 
    -0.01781234f, 0.00848901f, 0.02381044f, 0.03015086f, 0.02541292f, 0.03508674f, 0.00490224f, -0.00567523f, 
    0.02425376f, -0.01380158f, -0.01657324f, 0.01473330f, 0.00507500f, -0.03442672f, -0.01277406f, 0.02466449f, 
    -0.03529403f, 0.00740969f, -0.00936540f, 0.01767987f, 0.02349143f, 0.00286315f, -0.02313002f, 0.01439149f, 
    -0.01807553f, -0.03797300f, -0.03916283f, -0.03313547f, -0.01541575f, 0.00005700f, -0.01358148f, -0.01960563f, 
    -0.01172538f, -0.00619778f, -0.02320137f, -0.03326358f, -0.03098281f, -0.04130629f, 0.01781313f, -0.03468886f, 
    0.02132025f, 0.01952600f, -0.01093859f, 0.00308786f, -0.02940148f, 0.03043422f, 0.01928443f, 0.00740918f, 
    0.02747770f, 0.01310225f, 0.00422767f, 0.02018565f, -0.03005303f, -0.01587566f, 0.00586930f, 0.00387621f, 
    0.01156702f, 0.02852109f, -0.00631495f, 0.01063242f, -0.02507694f, -0.02079558f, -0.03126566f, -0.03904711f, 
    0.01772210f, -0.01391029f, -0.00346517f, 0.01599713f, 0.00279031f, -0.02711404f, 0.01086728f, 0.01801419f, 
    -0.03438340f, -0.01508207f, -0.01915441f, -0.02455406f, 0.00314894f, -0.01366696f, 0.03496072f, -0.01574649f, 
    -0.01537390f, 0.01696354f, -0.01362908f, -0.00267546f, 0.03836792f, -0.03426689f, -0.01044141f, 0.00757996f, 
    -0.02803327f, -0.01374036f, 0.01419393f, -0.00869661f, 0.01800646f, -0.01720434f, 0.01918899f, -0.03084274f, 
    0.00278289f, -0.03567389f, -0.02558969f, 0.00504765f, 0.03429095f, -0.01706116f, -0.03123219f, -0.03079457f, 
    -0.03375773f, 0.02334172f, -0.02918846f, 0.00242129f, 0.01486712f, 0.02435329f, 0.02299295f, -0.02420071f, 
    -0.02096151f, -0.00955219f, 0.00767944f, -0.00619125f, 0.02838455f, -0.02624027f, 0.01663810f, 0.01109610f, 
    0.00355735f, 0.02778423f, -0.03138001f, 0.00714140f, -0.02386476f, -0.01219359f, -0.00718586f, -0.01443084f, 
    -0.02308657f, -0.02333034f, -0.01768951f, -0.02107653f, -0.00595401f, -0.03555931f, 0.01746610f, 0.02880345f, 
    -0.01561327f, -0.03528230f, 0.00661264f, 0.02398946f, -0.03435048f, -0.02451424f, -0.03141701f, 0.02768248f, 
    0.01136969f, 0.01982601f, -0.04093309f, -0.00306889f, -0.00535750f, -0.02453636f, 0.00609968f, -0.03388439f, 
    -0.04053619f, -0.03474061f, -0.00207137f, -0.00534744f, -0.00018270f, -0.01101159f, -0.02843018f, -0.00396184f, 
    -0.01864972f, -0.04190482f, -0.03479366f, -0.01170336f, 0.02646486f, 0.01914800f, -0.02646321f, 0.00543006f, 
    -0.01995271f, 0.00398517f, -0.02373540f, -0.02868629f, -0.01709650f, 0.02954729f, -0.01168548f, 0.01412276f, 
    -0.00277854f, -0.04053210f, -0.02844160f, 0.00228516f, 0.00661972f, -0.03717338f, -0.03845710f, -0.02637150f, 
    -0.03815869f, -0.01646896f, -0.03170607f, 0.01452007f, 0.00833395f, 0.00040143f, -0.02250439f, -0.03319808f, 
    -0.01364612f, 0.01785937f, -0.01273244f, -0.04169942f, -0.01756679f, 0.00849165f, -0.01612950f, -0.03245956f, 
    0.00072351f, -0.01650757f, 0.00488987f, 0.01248877f, 0.01622762f, -0.01440151f, -0.02061121f, -0.02296193f, 
    -0.01227626f, 0.00704900f, -0.03263509f, 0.00578236f, -0.02510934f, 0.00298000f, -0.04019083f, -0.01668684f, 
    0.01300570f, 0.02536844f, -0.02762708f, -0.03044226f, 0.02579733f, 0.02519715f, -0.02570685f, -0.01288380f, 
    0.02438245f, 0.00991638f, -0.01485359f, 0.01769770f, 0.02921405f, -0.00438692f, 0.01318206f, 0.02392885f, 
    -0.01287005f, -0.02681459f, 0.01500672f, -0.01805223f, 0.02653436f, 0.00523083f, 0.01083721f, -0.02980262f, 
    -0.00680999f, -0.02464316f, 0.01171777f, 0.02392545f, 0.02255188f, 0.00985002f, 0.02104478f, -0.03738904f, 
    -0.03153155f, 0.02301636f, -0.02673384f, -0.01303743f, 0.01000004f, -0.01490987f, -0.01214834f, 0.02033233f, 
    -0.03138265f, -0.01146835f, -0.02859646f, 0.01244232f, 0.01865491f, 0.01772261f, -0.03690283f, 0.01006397f, 
    -0.04127729f, -0.02816026f, -0.03252130f, -0.02517551f, -0.01198276f, -0.01671831f, 0.00302592f, -0.03823908f, 
    0.01675772f, -0.00368847f, -0.04047185f, 0.01403890f, -0.04030919f, 0.02303649f, 0.01844948f, 0.00243116f, 
    0.01294727f, -0.02550944f, 0.00783136f, -0.01235952f, 0.02233920f, -0.00686662f, -0.03139282f, -0.02647188f, 
    -0.00621219f, 0.01359138f, 0.01788696f, -0.02354458f, -0.01669249f, -0.00495666f, 0.01406241f, -0.02690058f, 
    0.00241792f, 0.01154980f, 0.02655649f, 0.02686974f, 0.01806271f, 0.02680214f, -0.02603769f, 0.01643005f, 
    -0.02513857f, 0.01424542f, 0.01796337f, 0.00994991f, -0.01785485f, 0.00570334f, 0.02271453f, 0.00173450f, 
    -0.02298082f, 0.00089680f, -0.02431116f, -0.01451595f, 0.00001897f, 0.01252010f, -0.01445693f, 0.02198050f, 
    0.00385121f, -0.02668810f, -0.01243375f, -0.03194611f, 0.02045837f, -0.02760467f, -0.00382449f, -0.03515749f, 
    -0.00375956f, -0.02795099f, -0.02221105f, -0.01600089f, -0.01620723f, 0.00154660f, 0.00299101f, -0.02291019f, 
    -0.02985832f, -0.03257198f, 0.00464284f, -0.02727765f, -0.00043544f, -0.04202025f, -0.03926604f, 0.00296634f, 
    0.00777344f, -0.03881710f, -0.02452979f, 0.00196454f, -0.01628852f, 0.02570783f, -0.01856508f, -0.00440690f, 
    -0.01468740f, 0.00328430f, 0.01939839f, 0.01783863f, 0.01763132f, -0.04140281f, -0.00871239f, 0.00431821f, 
    -0.03943457f, -0.00297271f, -0.01499789f, 0.02184025f, 0.00651614f, -0.01749803f, -0.00129908f, -0.02554900f, 
    0.01307515f, -0.04065057f, -0.01216897f, 0.02536250f, 0.00470861f, 0.02283799f, 0.02792620f, -0.01055717f, 
    -0.04135394f, 0.02191804f, -0.00526146f, -0.00110378f, -0.02694318f, -0.02475884f, -0.04131484f, -0.02823375f, 
    -0.01787892f, 0.02062172f, -0.03936793f, -0.00366424f, 0.02371126f, 0.01986966f, 0.02135088f, -0.01436768f, 
    0.01164545f, -0.01840342f, 0.01647075f, -0.03639266f, 0.01787386f, 0.01476962f, -0.01803299f, -0.03405568f, 
    -0.01895867f, -0.03087182f, -0.01945074f, 0.02816021f, 0.01943864f, 0.00460384f, 0.02572096f, -0.00726525f, 
    0.02804184f, -0.00719486f, -0.00387624f, -0.03633327f, 0.01877589f, 0.02422933f, 0.01844939f, -0.03246711f, 
    -0.01585448f, 0.01557687f, 0.01751224f, 0.01580634f, 0.02445184f, -0.02320966f, 0.02095524f, -0.03202001f, 
    0.01923754f, 0.01604714f, -0.01312529f, -0.03823864f, 0.00956082f, 0.02943611f, -0.02116539f, -0.00937248f, 
    -0.03231108f, -0.00925317f, 0.01815293f, 0.01322555f, 0.02041085f, -0.01967710f, -0.03745710f, -0.02703446f, 
    -0.01750460f, 0.01117688f, 0.00663058f, -0.00786845f, -0.01224184f, 0.00136666f, 0.02100275f, -0.00122842f, 
    0.00564981f, -0.00771909f, 0.00553616f, -0.03436923f, 0.00471660f, 0.00510903f, 0.02190588f, 0.02640415f, 
    -0.04161416f, -0.00054590f, -0.02574798f, -0.04134335f, -0.01912807f, -0.00833834f, -0.00153365f, 0.00789115f, 
    -0.01744657f, -0.01086020f, -0.01002258f, 0.01702653f, 0.00910576f, 0.01563398f, -0.03064210f, -0.03929731f, 
    0.01496235f, -0.02494632f, 0.01813775f, 0.01148541f, -0.01128058f, -0.01592413f, -0.00250596f, -0.00451810f, 
    -0.01555097f, -0.03554511f, 0.02215647f, -0.02946131f, 0.01560315f, 0.01975442f, -0.01759699f, -0.02058094f, 
    -0.02879268f, -0.00014893f, 0.01734444f, 0.02403508f, 0.00625195f, 0.02080499f, -0.01272436f, -0.03065424f, 
    -0.00753056f, 0.02128989f, -0.01253916f, -0.02409883f, 0.00537481f, 0.02861086f, 0.00175235f, -0.03009482f, 
    -0.01428974f, -0.03471942f, 0.01952418f, -0.02027768f, -0.01649434f, 0.02446524f, -0.00562507f, 0.00034444f, 
    -0.01667972f, -0.01093838f, -0.02608066f, -0.01799787f, -0.04014770f, 0.00166282f, -0.01255618f, -0.02803437f, 
    -0.01025612f, 0.00051402f, -0.02061497f, -0.00288497f, -0.03868432f, -0.01952158f, 0.04073945f, -0.00423709f, 
    0.00942484f, -0.02280826f, 0.00811497f, -0.03465373f, -0.00225962f, -0.00479385f, -0.00608297f, -0.02315391f, 
    0.02925660f, -0.01622061f, -0.00168738f, -0.01484267f, 0.01371190f, -0.04011796f, -0.03036738f, 0.02422300f, 
    -0.02823195f, 0.02459748f, -0.03206221f, -0.01865738f, -0.00247584f, -0.02120006f, -0.01899439f, -0.03581173f, 
    -0.00795965f, 0.02838594f, -0.02261151f, 0.01033651f, 0.02452897f, 0.02138213f, -0.00319360f, 0.01730290f, 
    0.02808395f, -0.00301347f, -0.00885590f, -0.01323083f, -0.02724130f, -0.01144221f, 0.00804830f, -0.02697814f, 
    -0.02071712f, -0.00800331f, 0.00255288f, -0.00049084f, -0.00349268f, -0.00846751f, -0.01944125f, 0.00163105f, 
    -0.03015138f, -0.02382247f, -0.01842878f, 0.02457970f, 0.00959199f, -0.01259874f, -0.00636169f, 0.00535583f, 
    0.00068023f, -0.02641871f, -0.01347013f, 0.02456027f, 0.00555114f, -0.00856846f, -0.02027486f, 0.01111533f, 
    0.02013207f, 0.01657661f, -0.03992293f, -0.00630471f, -0.00887958f, 0.01882870f, -0.01246584f, -0.03193263f, 
    -0.00671373f, 0.02752894f, -0.03630866f, -0.00466979f, 0.02005183f, -0.01825072f, -0.03985902f, 0.01841806f, 
    0.00409486f, -0.00925931f, -0.02340217f, 0.02134897f, 0.01503219f, 0.01313869f, 0.00113883f, -0.00127439f, 
    0.02970744f, 0.00047864f, -0.03768443f, -0.00811259f, -0.00496683f, -0.02862366f, -0.03318981f, 0.00727152f, 
    -0.03706734f, 0.00323319f, -0.02675598f, -0.03704325f, -0.00408861f, -0.04091736f, -0.00118262f, -0.00577788f, 
    -0.01583592f, -0.01497417f, -0.00880685f, -0.02162612f, -0.00843737f, -0.01707722f, 0.00213125f, 0.01586189f, 
    -0.04180427f, -0.00450112f, -0.00194995f, -0.02119697f, -0.02618065f, -0.03851617f, -0.02447925f, 0.01938064f, 
    -0.02894325f, -0.01011258f, 0.00156690f, 0.01518321f, 0.00275457f, 0.02565929f, -0.01051018f, -0.02990274f, 
    0.01673554f, -0.01280021f, -0.00175000f, -0.00173701f, -0.02724451f, -0.01835126f, -0.02012625f, -0.01729531f, 
    0.00947999f, 0.00643099f, 0.02040762f, 0.01451490f, 0.00008881f, 0.02942202f, -0.03233973f, -0.00000078f, 
    0.02595147f, -0.02675792f, 0.00518030f, -0.01129638f, -0.00217131f, -0.03177461f, 0.02311559f, -0.01963386f, 
    0.01094790f, -0.03710124f, 0.00677893f, -0.02960678f, -0.03414220f, -0.00483652f, -0.02559461f, -0.02421883f, 
    0.01031413f, -0.03249058f, -0.03639209f, -0.03095184f, 0.02622677f, -0.01613007f, 0.02625421f, -0.02084288f, 
    0.01837341f, -0.01185757f, 0.00676854f, -0.01419200f, -0.00779509f, -0.02109345f, -0.00253988f, 0.00148529f, 
    0.02924370f, 0.01677092f, 0.00062742f, 0.00532843f, -0.03207308f, 0.01203574f, 0.01323521f, -0.00093461f, 
    0.01421787f, -0.01116224f, 0.00896087f, 0.00187680f, 0.02843828f, -0.00453099f, -0.02643720f, -0.00699738f, 
    0.00308137f, -0.01851861f, 0.01053788f, 0.00305998f, 0.02867305f, 0.02240011f, -0.00982048f, -0.00077788f, 
    -0.02166191f, -0.02394695f, 0.01095278f, -0.01438871f, -0.01672290f, -0.03629509f, -0.02332997f, 0.00586831f, 
    0.01641721f, -0.01484893f, 0.02760361f, 0.02826177f, -0.00925018f, 0.02118421f, -0.02246344f, 0.00347526f, 
    -0.02994472f, -0.01601498f, 0.01905627f, -0.00973198f, -0.01912552f, 0.02556754f, 0.00396132f, 0.02669170f, 
    0.01701598f, 0.01821648f, -0.03205724f, -0.03452747f, -0.03909767f, -0.02484730f, -0.00668755f, 0.01671065f, 
    -0.00009563f, 0.02523828f, 0.01599634f, 0.00198198f, -0.03278186f, -0.03316755f, -0.03874403f, -0.03787112f, 
    0.00425300f, 0.01316170f, -0.03953956f, -0.01270952f, 0.02839438f, -0.00617697f, 0.00883791f, -0.02734684f, 
    -0.03309813f, -0.04032949f, 0.01402212f, -0.02024396f, 0.01598295f, -0.01085979f, -0.03993897f, 0.01046904f, 
    0.02965351f, 0.02811879f, -0.03179973f, -0.00316896f, 0.02091008f, 0.02941415f, -0.02837553f, -0.00226088f, 
    0.01002883f, -0.02261465f, 0.02999971f, -0.02225325f, -0.00120206f, 0.02840960f, 0.02541013f, -0.03893233f, 
    0.01147633f, -0.00467901f, 0.00655828f, -0.00689160f, 0.00505206f, -0.01261421f, -0.02654825f, 0.00397557f, 
    0.01229085f, 0.01203683f, -0.03479823f, 0.00071476f, 0.02724983f, 0.02703864f, 0.01284987f, 0.01365419f, 
    -0.03166804f, -0.00371379f, -0.04095205f, -0.02271615f, -0.01862489f, -0.02118102f, -0.00185419f, 0.00711767f, 
    -0.00298816f, -0.02070593f, -0.01005559f, 0.02147488f, -0.01696375f, -0.02647249f, 0.02299056f, 0.00464264f, 
    -0.01299556f, 0.00213959f, 0.00953767f, 0.00234354f, 0.01675759f, 0.00952993f, 0.01125762f, 0.01777997f, 
    -0.02235594f, -0.00871471f, 0.01270646f, 0.00414069f, 0.00653429f, 0.01775096f, -0.03588105f, -0.02689752f, 
    -0.00620842f, -0.01940299f, -0.03721729f, -0.03068812f, 0.00764912f, 0.00815530f, -0.01893392f, 0.01717957f, 
    -0.01034526f, -0.03583320f, -0.02049625f, -0.00815831f, -0.02376509f, 0.00883464f, -0.01111415f, -0.00728743f, 
    -0.01518335f, -0.02637875f, -0.01438606f, -0.00679264f, 0.01689504f, 0.02169395f, 0.01377558f, -0.00557796f, 
    -0.01073904f, -0.02001623f, -0.02576695f, -0.02979088f, -0.02178232f, -0.04183415f, 0.01227272f, 0.00206949f, 
    0.15916431f, -0.11444345f, -0.01912485f, 0.04701455f, 0.11215198f, -0.01098764f, -0.02849721f, 0.06985123f, 
    0.06832034f, 0.04915504f, 0.03940323f, -0.04787041f, -0.33898053f, 0.09069075f, -0.02793837f, 0.03525212f, 
    0.11132795f, 0.04630465f, -0.02958181f, 0.04878249f, 0.04970120f, -0.03405162f, -0.04616667f, 0.05115574f, 
    -0.13906722f, 0.20336851f, 0.04954176f, 0.10159317f, 0.09620213f, 0.06829308f, 0.05094473f, -0.05659688f, 
    0.08184699f, 0.02564724f, 0.00497793f, 0.11826654f, -0.06097534f, -0.12105657f, -0.02787052f, 0.01536224f, 
    0.06050623f, 0.07296637f, 0.08345737f, -0.01072800f, 0.02203851f, 0.02577207f, 0.00633838f, 0.05833933f, 
    -0.10082223f, 0.05839840f, -0.04901231f, -0.06538739f, 0.22116706f, -0.04513028f, 0.07163703f, 0.00517457f, 
    0.03873191f, -0.03770323f, 0.01439627f, -0.01899613f, -0.21429317f, 0.00808107f, 0.28387111f, 0.14895941f, 
    -0.03136012f, 0.01496118f, -0.00764200f, -0.05581749f, 0.00871294f, 0.01373638f, 0.06887254f, 0.05346665f, 
    -0.34103617f, -0.11058684f, 0.04778381f, -0.02730401f, 0.03118055f, 0.15991586f, -0.01834923f, 0.04124997f, 
    0.03955820f, 0.00373971f, -0.01132151f, 0.00046069f, 0.19506316f, -0.14125647f, -0.08120280f, 0.15714376f, 
    0.01685227f, 0.11517058f, 0.05203705f, 0.00707823f, 0.04380243f, -0.01700002f, 0.05353924f, 0.08583049f, 
    0.03934848f, 0.17115319f, 0.02321848f, -0.07429440f, 0.06403302f, 0.08350527f, 0.02244753f, 0.13543470f, 
    0.11965778f, 0.00066887f, 0.07806048f, 0.06675863f, 0.11909723f, 0.06833741f, 0.21158446f, 0.01572170f, 
    0.16204935f, 0.05326100f, 0.04682830f, -0.07607812f, 0.03611091f, 0.06303731f, 0.00805632f, 0.06030748f, 
    -0.16592894f, -0.29896781f, 0.15623242f, -0.07832593f, 0.09261122f, 0.08903728f, -0.05262558f, -0.05516224f, 
    0.00451710f, 0.07915571f, 0.04298585f, -0.01852242f, -0.09303167f, -0.11779989f, -0.17849705f, 0.01904803f, 
    0.06324799f, 0.11523811f, 0.06130407f, 0.09751868f, -0.09065203f, 0.08137069f, 0.00541409f, -0.06138692f, 
    -0.24003212f, -0.14674753f, -0.16288514f, 0.09986329f, 0.05714747f, -0.01773043f, 0.11221027f, 0.04482944f, 
    0.01341863f, 0.02719924f, -0.05504393f, 0.10954671f, -0.01301171f, 0.04724561f, 0.21819513f, 0.12875153f, 
    0.08345446f, 0.07656641f, -0.02524029f, 0.05381290f, -0.07027360f, 0.01321816f, 0.03770855f, -0.02676810f, 
    -0.11132682f, 0.01258215f, 0.00735939f, -0.10050090f, 0.03432988f, -0.01985052f, -0.03597027f, 0.06858814f, 
    0.00346740f, 0.00896369f, 0.03920283f, -0.00342003f, 0.02134530f, 0.04846706f, 0.11282717f, 0.07535528f, 
    0.08387374f, 0.07677306f, 0.04305122f, 0.06249939f, 0.05909018f, 0.06105667f, 0.04531128f, -0.02008454f, 
    0.34889436f, -0.11531986f, -0.10557500f, 0.12654139f, -0.01453248f, 0.07629225f, 0.08338563f, 0.05503285f, 
    -0.00110215f, 0.04985894f, 0.05072640f, 0.11364761f, 0.04449869f, -0.02325580f, 0.10132813f, 0.03945017f, 
    0.06006400f, 0.10060131f, -0.01062762f, -0.00112964f, 0.11442939f, 0.07809439f, 0.05651216f, 0.12984018f, 
    0.07410964f, 0.20081772f, -0.09004564f, 0.00076693f, 0.08619392f, -0.05532723f, 0.04525217f, 0.02716391f, 
    0.28342485f, 0.07133790f, 0.11518602f, 0.12157527f, 0.01456974f, -0.01996295f, 0.04224949f, 0.09552260f, 
    -0.01530989f, 0.09309880f, -0.00366408f, -0.09050966f, 0.09705234f, 0.00783721f, -0.01923556f, 0.06928359f, 
    -0.11261099f, -0.02592295f, 0.00172269f, -0.05463196f, 0.06643573f, 0.05729987f, 0.06340550f, 0.08179159f, 
    0.05501341f, 0.05337441f, 0.11102404f, 0.13960317f, -0.38816890f, 0.19950451f, 0.01210602f, 0.06616186f, 
    0.09054961f, 0.02506365f, 0.00180310f, 0.04255717f, 0.02310283f, -0.01810113f, 0.00926381f, -0.02565795f, 
    0.03373418f, -0.05454251f, -0.00874992f, 0.07443791f, 0.10185504f, -0.02465908f, 0.12352478f, -0.02830629f, 
    0.00894305f, -0.02950985f, 0.07157385f, -0.04124110f, -0.25020930f, 0.00955346f, -0.14662108f, -0.03536655f, 
    0.08175040f, 0.05091988f, 0.13386290f, 0.00256961f, 0.00400484f, -0.08956746f, -0.01984945f, -0.06293731f, 
    0.13866846f, -0.16211142f, 0.09368322f, -0.01693847f, 0.08009671f, 0.01657125f, -0.03029135f, -0.09553044f, 
    0.08179986f, 0.10568313f, 0.07428395f, 0.08960891f, -0.00756253f, -0.08947075f, 0.06830176f, -0.05830824f, 
    0.08546894f, 0.09001348f, 0.00378975f, -0.09658812f, 0.09782070f, 0.07330788f, 0.07466942f, -0.09781467f, 
    -0.08267409f, -0.23983355f, 0.01097900f, -0.03929103f, 0.04839041f, 0.06018458f, 0.04479364f, -0.04869451f, 
    0.13786183f, -0.02044968f, 0.06535657f, -0.01117732f, -0.21203101f, 0.08602957f, 0.12928294f, -0.06681928f, 
    0.02412600f, 0.04710636f, -0.04260943f, 0.09506097f, 0.09295408f, 0.10576437f, 0.04954861f, 0.08079609f, 
    -0.39389169f, -0.06368788f, -0.06587846f, -0.06183869f, 0.10191602f, 0.05541743f, 0.14769773f, 0.04476451f, 
    0.07033934f, -0.03494108f, -0.00760206f, -0.04391327f, -0.04114323f, 0.05501095f, 0.17694657f, 0.08084925f, 
    -0.02244483f, 0.13432547f, 0.05269432f, 0.05011332f, -0.01828439f, 0.00464180f, -0.02275840f, 0.10650980f, 
    0.23876886f, -0.08564229f, 0.14618243f, 0.10585241f, 0.07812275f, 0.08774492f, -0.05267261f, 0.04457137f, 
    0.01819951f, 0.02898151f, 0.02211821f, 0.12236651f, 0.21784410f, 0.04180321f, -0.01423051f, -0.09546610f, 
    0.24434720f, -0.02410477f, -0.04709420f, -0.01659466f, 0.01659425f, -0.00628182f, 0.11328162f, 0.07255115f, 
    0.18972541f, 0.23215836f, -0.04366755f, -0.09307662f, 0.02288801f, 0.02021078f, 0.01769743f, -0.03324030f, 
    0.01111152f, 0.00336457f, 0.07523917f, 0.10311440f, -0.02316713f, -0.04378821f, 0.03193991f, 0.30031216f, 
    -0.09223342f, 0.06468476f, 0.05944453f, -0.03147493f, -0.00786006f, 0.06313729f, 0.04628896f, 0.06298816f, 
    0.02915664f, 0.02057233f, -0.16099010f, 0.10551173f, 0.19162345f, 0.19983850f, 0.13186526f, 0.10109631f, 
    -0.01949374f, 0.07650049f, 0.01659205f, 0.03036085f, 0.19364317f, -0.00121448f, 0.12164205f, -0.03352392f, 
    0.05577537f, -0.09573434f, -0.01543874f, -0.06235207f, 0.13072075f, 0.12611000f, 0.06963105f, 0.11530583f, 
    -0.01588198f, -0.08307291f, -0.09231300f, -0.03267080f, 0.10448377f, 0.01267908f, 0.16634552f, 0.10935278f, 
    0.05713558f, 0.01907744f, -0.03984504f, -0.02700272f, 0.05049889f, -0.03775997f, -0.07860482f, 0.03123172f, 
    0.02561779f, 0.01306880f, -0.00470611f, 0.07796440f, 0.02715663f, 0.00748913f, 0.05226287f, 0.10331257f, 
    0.15325044f, 0.14949811f, -0.02818489f, -0.23138814f, 0.09014816f, -0.04289808f, 0.02439597f, 0.06929634f, 
    0.05675257f, 0.03543760f, 0.15293215f, 0.05164943f, -0.10927446f, -0.00372657f, -0.03743285f, 0.20695527f, 
    0.09788857f, 0.03336454f, -0.00830733f, 0.04640875f, 0.06866368f, -0.05427588f, 0.03573098f, -0.02185097f, 
    0.19263959f, 0.10279861f, -0.02958531f, 0.06252070f, 0.19944517f, 0.07733712f, 0.01802518f, 0.02028386f, 
    0.05917516f, 0.04991828f, 0.11336737f, 0.06365062f, -0.16779032f, 0.07013634f, 0.23450196f, -0.09572611f, 
    -0.08340061f, -0.05367800f, -0.01823166f, 0.08924754f, -0.06221566f, 0.05728016f, 0.02227289f, 0.10150264f, 
    0.29607368f, 0.00604103f, 0.21228029f, 0.25647840f, -0.04381744f, -0.13111144f, -0.01999791f, 0.03701307f, 
    0.09910937f, 0.02323463f, 0.09739086f, 0.02032606f, 0.03651688f, -0.07216991f, 0.04640860f, 0.01237539f, 
    0.05915888f, 0.09892975f, -0.01748821f, -0.08829892f, -0.02365522f, -0.02266387f, 0.00430490f, 0.01646590f, 
    -0.04555868f, -0.02451307f, 0.08307488f, -0.14235680f, 0.13910733f, 0.13328324f, 0.04061949f, 0.03498051f, 
    0.01547195f, 0.21535423f, -0.01279876f, 0.16827273f, -0.19891177f, 0.07254451f, 0.10720731f, 0.03338278f, 
    0.20386055f, -0.00499657f, 0.06023446f, 0.22423302f, 0.07304317f, 0.06841981f, 0.14006513f, 0.00326865f, 
    0.06536587f, -0.08452954f, -0.16670834f, 0.20677990f, 0.03370647f, -0.02328020f, 0.02996856f, 0.00958860f, 
    0.06497684f, -0.03187751f, 0.04924802f, -0.05088039f, 0.13595761f, -0.02961058f, -0.07424348f, 0.03163150f, 
    0.14337215f, 0.12058286f, 0.11344124f, 0.06108696f, 0.08366969f, 0.10993358f, 0.03459529f, -0.00448608f, 
    -0.05185545f, -0.25231376f, 0.11463719f, 0.04045667f, -0.00520329f, 0.03449596f, 0.09474731f, 0.07423136f, 
    0.15638323f, 0.05446621f, -0.02376968f, 0.02801996f, -0.06769278f, -0.17905569f, -0.01496126f, 0.09052612f, 
    0.08974732f, 0.05278088f, 0.07814042f, -0.04389576f, 0.01392229f, -0.03213806f, -0.03175197f, 0.09887315f, 
    -0.19186509f, 0.08876913f, 0.19126388f, 0.02196094f, 0.07814933f, 0.08197805f, 0.00863173f, 0.07738089f, 
    0.09256317f, 0.14959531f, -0.04674655f, 0.23864649f, -0.23046321f, 0.09726082f, 0.15924078f, 0.12107889f, 
    0.11870690f, 0.16163726f, 0.10509768f, 0.11301349f, 0.20543469f, 0.06194732f, -0.10727043f, 0.02554669f, 
    0.11639844f, 0.00540910f, 0.13074416f, 0.17880540f, -0.01378113f, -0.00678078f, 0.01870301f, 0.01978136f, 
    0.12446102f, 0.03094173f, -0.02355065f, 0.11366298f, 0.01993391f, 0.00944479f, 0.00132324f, -0.00778060f, 
    0.02594130f, 0.02726907f, -0.01296797f, -0.07551153f, 0.10452651f, 0.08162252f, 0.02238215f, 0.07704421f, 
    -0.06414286f, 0.07399060f, 0.07013577f, -0.09623370f, 0.07647088f, -0.06105921f, -0.12659718f, 0.11771667f, 
    0.06516074f, 0.07537754f, 0.00739838f, 0.11298174f, 0.11997904f, 0.06234513f, 0.11640766f, 0.09189251f, 
    -0.15059862f, -0.07139884f, -0.08813071f, 0.08423018f, -0.00852688f, 0.03082884f, 0.13963875f, 0.17916042f, 
    0.25952983f, -0.18516965f, 0.08471273f, 0.03784685f, -0.03317032f, 0.16896358f, 0.02283580f, -0.07258552f, 
    0.07291492f, 0.12609817f, 0.10183700f, -0.03196931f, 0.08754502f, -0.13590626f, 0.09306135f, 0.00183365f, 
    0.16812803f, 0.11294014f, 0.07375179f, 0.00053844f, 0.12864202f, 0.08055682f, 0.07909127f, 0.10048660f, 
    -0.05486705f, 0.12454148f, 0.21123071f, 0.00830765f, 0.01084990f, 0.01750176f, 0.02063050f, -0.03402748f, 
    0.14712119f, 0.02050040f, 0.11157709f, 0.14188175f, 0.15120988f, -0.21433601f, -0.10735694f, -0.04005786f, 
    0.16334759f, -0.02759042f, 0.15287399f, 0.10338834f, -0.03331877f, -0.00491209f, 0.00661103f, 0.06879288f, 
    0.14544548f, -0.12841764f, 0.02002370f, -0.01563069f, -0.03743260f, 0.03820919f, 0.05037825f, -0.04146495f, 
    0.12029219f, 0.14137545f, 0.05941582f, 0.01497245f, -0.21376723f, 0.03593351f, 0.12457331f, 0.07933438f, 
    0.02763778f, 0.00917945f, 0.02719232f, -0.03495593f, 0.05550096f, 0.02855447f, 0.06370946f, 0.12845820f, 
    -0.05485358f, 0.14450124f, 0.05627071f, 0.01109306f, 0.17779873f, 0.09884126f, 0.00253167f, 0.05470037f, 
    0.09916829f, -0.03659083f, 0.01192173f, 0.09318975f, 0.07360122f, 0.02785921f, -0.04835181f, -0.11646146f, 
    0.03277709f, -0.04623149f, -0.06369726f, 0.00413324f, -0.00188904f, 0.09786651f, 0.04825263f, 0.06775191f, 
    -0.02358673f, -0.04174007f, -0.00876666f, -0.03175712f, -0.02925468f, -0.01976569f, 0.02537909f, 0.01492152f, 
    0.00204606f, 0.02022468f, -0.02700622f, -0.04036542f, -0.02620541f, -0.02250556f, 0.00012326f, 0.01828614f, 
    -0.03896409f, -0.01946096f, 0.02037895f, 0.00004595f, -0.00433661f, -0.03926570f, 0.00329809f, -0.01648214f, 
    0.01607082f, -0.03310710f, 0.02900678f, 0.01478209f, -0.03160200f, 0.02134968f, -0.02284345f, -0.03005880f, 
    -0.02308344f, 0.01955074f, -0.00477846f, 0.02384490f, -0.03642095f, -0.01780245f, 0.01965575f, 0.02806734f, 
    0.01948752f, -0.01785000f, -0.00522228f, -0.01155448f, -0.00356980f, -0.02505066f, -0.00909700f, -0.02081278f, 
    -0.01074314f, -0.03232018f, -0.01450392f, -0.01341746f, 0.00511071f, -0.01594083f, -0.00705627f, -0.02929048f, 
    0.02629000f, 0.00813108f, -0.01541567f, -0.00050711f, -0.03121210f, -0.01976219f, 0.02257923f, -0.02472190f, 
    -0.02292769f, -0.00855622f, 0.01425562f, -0.01413158f, -0.01510924f, -0.01695486f, -0.02350326f, 0.02175512f, 
    -0.02194413f, 0.02914011f, -0.04091525f, -0.03308941f, -0.04163233f, -0.02182266f, -0.00708443f, -0.01445445f, 
    0.01297736f, 0.01063811f, 0.00122293f, -0.00457540f, 0.00089189f, -0.03004781f, 0.02066793f, -0.01458667f, 
    0.02869143f, -0.01941702f, -0.03272986f, 0.01879827f, -0.02003689f, -0.03512624f, -0.03251147f, -0.00120830f, 
    -0.01053183f, -0.00417756f, 0.03529913f, -0.02715308f, -0.02312094f, -0.03448370f, -0.02834815f, -0.00086351f, 
    0.00249539f, 0.00969389f, 0.03448099f, -0.02162192f, -0.00607843f, 0.01684412f, -0.01719445f, -0.04103966f, 
    -0.01295908f, -0.01531828f, 0.03625170f, -0.03556942f, -0.03326915f, 0.02963876f, -0.02002459f, 0.01276716f, 
    0.02833338f, 0.02581487f, 0.01439010f, -0.02732447f, 0.01317988f, 0.01479200f, 0.00060623f, -0.00195709f, 
    0.00520030f, 0.02260739f, -0.03385634f, -0.00627604f, 0.01576249f, -0.03623293f, 0.01490682f, -0.02093725f, 
    0.02894941f, -0.01862818f, 0.02443132f, 0.02173028f, 0.02185170f, -0.01835523f, -0.00764072f, -0.00198456f, 
    0.02089626f, -0.01081722f, 0.02824415f, 0.00362316f, -0.00987393f, 0.00427574f, -0.01937141f, 0.02918343f, 
    -0.01337306f, 0.00648603f, -0.01747604f, -0.00498311f, 0.00021593f, -0.00216203f, -0.01811052f, -0.00836283f, 
    -0.04177829f, -0.00296095f, 0.01246970f, 0.01191738f, 0.02200067f, 0.02159703f, 0.01083245f, -0.03446189f, 
    0.01655344f, -0.00543513f, -0.01797603f, -0.02088070f, 0.00066336f, -0.02942341f, 0.01956758f, -0.02019978f, 
    0.02856435f, 0.01900151f, -0.02240713f, -0.00608011f, -0.00510460f, -0.03979532f, 0.02241420f, -0.02387636f, 
    0.01691314f, 0.00903706f, -0.00300642f, -0.01836805f, -0.03959855f, 0.02673539f, -0.04067360f, -0.00387232f, 
    -0.03295632f, -0.01258664f, -0.01686171f, -0.00567656f, 0.00708350f, 0.00058214f, -0.00512862f, -0.03726986f, 
    0.00808971f, -0.00851865f, -0.02049130f, 0.01888108f, -0.02806121f, -0.03195708f, -0.01809887f, 0.01523058f, 
    -0.01375959f, -0.02061128f, -0.02111996f, -0.02174709f, 0.01714686f, 0.01780765f, -0.02030909f, -0.03835113f, 
    -0.01702509f, -0.01756287f, -0.00439527f, 0.01790854f, -0.03529996f, -0.00633536f, -0.02601104f, 0.02548005f, 
    -0.02262512f, -0.03711750f, 0.02482801f, -0.00251898f, 0.02499444f, 0.00039779f, -0.01024979f, 0.04159696f, 
    -0.01341304f, 0.01942523f, -0.03813296f, 0.00498405f, -0.02661476f, 0.03535166f, -0.03623075f, -0.02273857f, 
    0.01620024f, 0.04014512f, 0.03695684f, -0.01796144f, -0.01316401f, -0.00826370f, 0.00634527f, -0.01222034f, 
    0.00639196f, -0.00382942f, -0.01157417f, -0.02184669f, -0.00566260f, -0.02763024f, 0.00703995f, -0.00382212f, 
    -0.02196521f, 0.00994049f, 0.00937253f, -0.01037085f, -0.01245129f, 0.00125312f, -0.03858975f, -0.01162058f, 
    0.02579572f, -0.01922585f, 0.02662207f, -0.00411379f, 0.02325702f, -0.02070294f, 0.01660139f, -0.03120769f, 
    0.01447808f, -0.02945730f, -0.04179886f, -0.00421914f, -0.03561063f, 0.00462280f, -0.00980338f, 0.01053606f, 
    -0.03195325f, 0.01356737f, -0.00535927f, -0.00528664f, -0.01434431f, 0.02123460f, -0.00551614f, 0.01542826f, 
    0.00834202f, 0.02150515f, 0.01864972f, 0.01980791f, 0.01141200f, 0.01709871f, 0.01891431f, -0.03595744f, 
    -0.03042211f, 0.02300742f, -0.00160730f, -0.00183562f, 0.01535702f, -0.00088477f, 0.03610770f, -0.01548176f, 
    -0.01689020f, 0.01929803f, -0.03640949f, 0.00510919f, -0.01081341f, 0.00263048f, -0.00449426f, 0.04160447f, 
    -0.02268888f, -0.01291372f, -0.02246730f, 0.02090444f, -0.03836834f, 0.01278341f, -0.02341715f, -0.01654918f, 
    0.02132373f, -0.01553957f, -0.00766103f, 0.01428998f, 0.01576263f, -0.00554328f, -0.00516897f, -0.01374969f, 
    0.00038756f, 0.00404527f, -0.03885456f, 0.02831957f, -0.00178975f, -0.00052337f, 0.00207096f, -0.02386556f, 
    -0.00546534f, -0.00742468f, 0.01738678f, -0.02539082f, 0.02088496f, -0.03172410f, -0.01415479f, -0.03895094f, 
    -0.00865313f, 0.03259188f, -0.01556704f, -0.00283943f, -0.02490162f, -0.02287445f, -0.01306089f, -0.00610017f, 
    -0.03806103f, 0.02847986f, -0.01422209f, -0.02030387f, 0.00992009f, -0.01999411f, -0.03366408f, -0.03651107f, 
    -0.01686130f, -0.01362541f, -0.01695454f, -0.02766638f, -0.02361778f, -0.03580172f, 0.00125535f, 0.00520613f, 
    0.02840194f, -0.00263096f, 0.02745396f, -0.02143099f, -0.02065247f, 0.02834404f, -0.02216321f, -0.01886897f, 
    -0.03864476f, 0.00851598f, -0.00738075f, -0.01115936f, 0.00124337f, 0.00472523f, -0.01802274f, -0.02746832f, 
    -0.00068709f, -0.02746340f, -0.02089396f, -0.00927822f, -0.01297392f, -0.01421053f, -0.01114122f, 0.02384554f, 
    0.02880721f, 0.03478407f, -0.03380406f, 0.00758723f, 0.00281359f, -0.03569295f, -0.03781668f, 0.01170639f, 
    0.02073008f, -0.02079902f, -0.03220748f, -0.01364016f, -0.01737352f, 0.03366070f, -0.01615662f, -0.03639976f, 
    0.01505332f, 0.02951973f, 0.01374164f, -0.01556750f, 0.01126135f, 0.02957615f, 0.02335547f, 0.02824833f, 
    -0.01985862f, -0.00090118f, 0.02347949f, -0.02960819f, -0.03714939f, 0.02745303f, -0.03128596f, 0.00823316f, 
    -0.02813483f, -0.00348906f, -0.00330880f, 0.00584426f, 0.02534878f, 0.02674157f, -0.00201882f, -0.01089656f, 
    -0.02754313f, 0.01390759f, -0.02315546f, -0.01911774f, -0.01098520f, -0.00879621f, -0.02643307f, 0.01374888f, 
    -0.00952787f, -0.02480978f, -0.01104601f, 0.01100020f, 0.00632873f, 0.01875835f, 0.00533902f, -0.03809217f, 
    0.01100226f, -0.03470104f, -0.02999401f, 0.01597031f, 0.00061753f, -0.02826905f, -0.02191924f, 0.00288561f, 
    0.01302008f, -0.01345470f, -0.03409249f, -0.03711830f, -0.02076529f, -0.02389895f, 0.02995118f, -0.01339967f, 
    0.01945994f, -0.02914472f, -0.00612114f, -0.00933427f, -0.02731865f, 0.00025409f, -0.02984991f, 0.01412545f, 
    0.01439848f, -0.03516040f, 0.02137727f, -0.00429078f, -0.02111561f, 0.00478253f, -0.00686704f, -0.02085863f, 
    -0.00821179f, -0.02024486f, 0.00300679f, 0.00651715f, 0.03809652f, 0.02693078f, 0.01616816f, 0.00791374f, 
    0.00156969f, 0.00607982f, 0.02126113f, -0.03754574f, 0.02943373f, -0.00592300f, -0.01979073f, 0.02144470f, 
    -0.03980457f, 0.00580086f, 0.02084204f, 0.00354602f, 0.01147262f, 0.02077156f, -0.00246344f, 0.02778738f, 
    -0.00904742f, 0.01081391f, -0.02354673f, -0.01428769f, -0.02210483f, 0.00780837f, 0.02402883f, 0.02841106f, 
    -0.03624452f, 0.01043539f, 0.01249941f, -0.00459488f, -0.01618058f, 0.03116703f, -0.03982937f, 0.00959862f, 
    -0.03924026f, 0.02556122f, 0.01877813f, -0.00780104f, -0.01713453f, 0.02299464f, -0.03644450f, -0.01604136f, 
    -0.00948061f, -0.03802515f, 0.02711168f, 0.01660845f, 0.01017361f, 0.01416372f, 0.01363900f, 0.01593975f, 
    0.01895503f, 0.01333155f, -0.00167215f, 0.00211513f, 0.01546293f, 0.00465784f, 0.01457545f, 0.01095745f, 
    -0.00059505f, -0.01586756f, 0.02954074f, 0.00120323f, 0.00381446f, 0.02415046f, 0.00657097f, 0.00425268f, 
    -0.00107706f, -0.00498276f, -0.00329287f, -0.02317098f, 0.02414999f, -0.01838733f, 0.00674244f, -0.03598263f, 
    -0.02631807f, -0.03531467f, -0.03290732f, -0.02953180f, -0.01487624f, -0.01852277f, -0.02198400f, 0.01236577f, 
    -0.03741966f, 0.00809472f, 0.02976704f, -0.01889197f, -0.01463951f, -0.00895926f, 0.02353318f, -0.02804387f, 
    0.00442980f, -0.00735179f, 0.00495769f, -0.04026819f, -0.01787115f, 0.00597756f, 0.03803910f, -0.01839223f, 
    0.02091045f, -0.01487316f, -0.02930437f, -0.00864258f, -0.03594542f, 0.00478844f, -0.01310514f, 0.01382950f, 
    -0.01092914f, 0.01824429f, 0.01790151f, -0.04147635f, -0.03724077f, 0.02068254f, -0.03705286f, -0.02565925f, 
    0.02544983f, -0.02368961f, 0.00021546f, -0.01790585f, -0.01164573f, 0.01519415f, 0.01656276f, 0.00316941f, 
    0.01862000f, 0.02613650f, 0.03231142f, -0.03819888f, -0.02757108f, -0.03057900f, -0.01896500f, -0.01964449f, 
    -0.03401160f, -0.02786908f, -0.00536746f, -0.03765412f, 0.00427094f, -0.02083736f, -0.02572859f, -0.00955438f, 
    -0.03051539f, 0.02206813f, 0.01796265f, -0.01572012f, -0.01582774f, 0.00333268f, -0.03621426f, -0.00778330f, 
    0.02664412f, -0.02532647f, 0.01698521f, 0.02252406f, 0.02756105f, 0.01100470f, -0.03796716f, 0.01393590f, 
    -0.03184358f, -0.02036854f, 0.00220131f, -0.03781418f, 0.02297886f, 0.00507072f, -0.02461456f, -0.03499074f, 
    -0.01592983f, 0.01030986f, -0.02679890f, 0.02391582f, -0.01402993f, -0.01804583f, -0.00466527f, 0.02010442f, 
    -0.02080035f, -0.01532329f, 0.01654519f, -0.00650814f, -0.02420388f, -0.00629795f, 0.00540552f, -0.02159065f, 
    -0.00816974f, 0.01036596f, -0.01452834f, -0.01836047f, -0.02395670f, -0.01940873f, 0.00164397f, -0.00628494f, 
    0.02033428f, 0.03923986f, -0.00823776f, 0.02714301f, 0.01598924f, -0.01166869f, 0.01212371f, 0.00669788f, 
    -0.03706854f, -0.03549240f, 0.01899439f, -0.02047030f, -0.01493746f, -0.00923397f, -0.01627990f, -0.01449890f, 
    -0.04075665f, -0.00990186f, 0.02798483f, 0.01222043f, 0.02350907f, 0.01724866f, -0.00131730f, 0.02539678f, 
    -0.03290289f, -0.01866287f, 0.00214482f, 0.02177360f, -0.01454321f, -0.01589158f, -0.02047619f, -0.01491071f, 
    0.01032523f, -0.02626339f, -0.02109566f, 0.01142547f, 0.02923756f, -0.00039734f, -0.01646060f, 0.02714067f, 
    0.02610068f, -0.03731680f, 0.00324888f, -0.01357791f, 0.00312393f, 0.02361105f, 0.00846855f, -0.02795765f, 
    -0.03592250f, 0.02218483f, 0.00266143f, -0.01324959f, -0.02215354f, -0.01066404f, -0.01458968f, -0.03930986f, 
    0.01431064f, 0.00776898f, 0.00568944f, 0.01293516f, -0.00049951f, -0.02523461f, -0.01295181f, -0.03001904f, 
    -0.03359297f, -0.02460253f, -0.02932545f, 0.01797678f, -0.00666291f, 0.00174150f, 0.02067220f, -0.01415991f, 
    0.01869674f, -0.03081775f, -0.01179021f, -0.00531999f, 0.02318584f, -0.00725391f, 0.02850480f, 0.02159140f, 
    -0.00241633f, -0.02041785f, -0.03017776f, 0.01213013f, -0.00244887f, 0.00012942f, -0.00927166f, 0.02346194f, 
    0.00215264f, -0.02879945f, 0.03638566f, -0.01412539f, 0.03877451f, -0.04007091f, 0.01065388f, -0.03320583f, 
    0.26640540f, -0.00772736f, -0.02250973f, 0.00402711f, 0.14097284f, -0.02419451f, 0.09260874f, 0.06512506f, 
    -0.02288318f, 0.10056905f, -0.02420274f, 0.11718713f, -0.03051703f, -0.05190118f, -0.02362534f, 0.11283761f, 
    0.03527757f, 0.11204522f, 0.07935926f, -0.09613536f, 0.11129388f, -0.11025411f, 0.08097184f, 0.05813866f, 
    -0.09056355f, 0.06452739f, 0.15224402f, 0.05632495f, 0.03293278f, -0.02270049f, 0.02284855f, -0.00627143f, 
    0.02785351f, 0.04374083f, 0.04145031f, 0.12437667f, -0.02317653f, -0.06664284f, -0.01434019f, 0.04160234f, 
    -0.03011469f, -0.01468866f, 0.06791099f, 0.06421479f, -0.04105378f, -0.01915754f, -0.02193117f, -0.02253694f, 
    0.15434794f, 0.00549047f, -0.01711694f, -0.00042349f, 0.05897333f, 0.02182002f, 0.06451895f, -0.01753266f, 
    0.02155129f, -0.07994626f, 0.07079738f, 0.12934244f, -0.20855333f, -0.00003916f, 0.08634309f, 0.00245763f, 
    -0.00801255f, 0.06573559f, 0.05903165f, -0.03236794f, -0.04560078f, -0.13149813f, 0.04180788f, -0.03325981f, 
    -0.23924403f, 0.07545032f, 0.17746280f, -0.01391323f, -0.04234199f, 0.07155646f, -0.05220587f, 0.00134441f, 
    0.00739081f, 0.09823231f, -0.08988748f, -0.11872787f, -0.08795935f, -0.19068904f, 0.07865085f, 0.00467742f, 
    0.02381492f, 0.06785557f, 0.04899277f, -0.00551055f, 0.05427115f, -0.06809882f, -0.00067885f, 0.08271910f, 
    0.19891474f, 0.11526813f, -0.12119886f, 0.03902611f, 0.02986928f, 0.05125388f, 0.04655270f, 0.02788063f, 
    0.15200576f, 0.02540045f, -0.07100630f, 0.00585739f, 0.11426966f, 0.11498459f, 0.04902441f, 0.06024373f, 
    0.09294222f, 0.06841139f, 0.00148502f, -0.13277198f, -0.05518360f, -0.10946123f, 0.04522153f, -0.06916805f, 
    -0.17019899f, -0.13762578f, 0.11326938f, 0.14179380f, 0.00688716f, 0.04197235f, 0.00849367f, 0.02524784f, 
    0.02413334f, -0.01155384f, 0.09921721f, 0.02022696f, 0.07366224f, 0.06039631f, -0.12262505f, -0.01835838f, 
    0.02606653f, 0.05503399f, -0.11544979f, 0.04657472f, -0.09663840f, 0.01699712f, 0.04844750f, -0.04446496f, 
    -0.11952218f, -0.10989495f, -0.10517997f, 0.02594492f, -0.01932686f, 0.00328436f, 0.01712333f, 0.05596324f, 
    0.01307741f, -0.11495197f, -0.03266408f, -0.03994100f, 0.02269072f, 0.18156618f, 0.07894617f, -0.15878198f, 
    0.02286017f, 0.07082391f, 0.02983353f, 0.00598339f, -0.07253834f, 0.01108396f, 0.05132324f, 0.08546744f, 
    -0.12206505f, 0.02388149f, 0.10966019f, 0.08006784f, 0.00542655f, 0.02630940f, 0.04417226f, -0.01422798f, 
    -0.02892915f, 0.02292408f, -0.03061891f, 0.15361109f, -0.15501592f, -0.08706123f, 0.13514645f, 0.02630018f, 
    0.05226417f, 0.01972042f, 0.04947023f, 0.05138759f, 0.02316114f, 0.00928772f, -0.02883355f, -0.02067958f, 
    0.20562136f, -0.03408573f, -0.12107787f, 0.03557513f, 0.02631850f, 0.03480959f, 0.05893132f, 0.06046679f, 
    0.01938295f, 0.11665615f, -0.06734324f, -0.09069053f, -0.08209869f, 0.03203200f, 0.06726634f, 0.08011916f, 
    0.02467813f, 0.11128855f, 0.04575121f, 0.12507835f, 0.07417023f, -0.05437953f, 0.04620789f, 0.04009054f, 
    0.19481751f, 0.10397667f, -0.00185044f, 0.12666190f, 0.07140829f, 0.07851250f, -0.01644974f, 0.01525247f, 
    0.17506155f, -0.06075328f, 0.02285906f, -0.05545359f, 0.08010830f, -0.11119419f, 0.06616453f, -0.01509021f, 
    -0.02340084f, 0.01346898f, 0.08403482f, 0.11686198f, 0.01168540f, 0.01307406f, -0.05494755f, 0.01044481f, 
    -0.03296530f, 0.09899806f, 0.04067807f, 0.03646067f, -0.05999117f, 0.01940737f, 0.04495408f, 0.00474162f, 
    0.07820218f, 0.07358254f, -0.10114377f, 0.02628485f, -0.21129864f, -0.10710457f, 0.09207249f, -0.04627361f, 
    -0.02372843f, -0.04687956f, -0.11240213f, 0.02893580f, 0.17630561f, 0.08932104f, -0.05016697f, 0.12565784f, 
    -0.11669119f, -0.04802414f, 0.06131361f, -0.02773655f, 0.08374614f, -0.12151912f, 0.11011156f, -0.04339281f, 
    -0.00406971f, 0.03094712f, -0.02772757f, 0.01127850f, -0.10726728f, -0.07183642f, -0.07263458f, -0.13783106f, 
    -0.01664918f, -0.01830469f, -0.04557314f, 0.06966160f, 0.08742312f, -0.00677248f, -0.01968770f, 0.02567645f, 
    0.06183008f, -0.03156968f, 0.14571746f, 0.03973166f, -0.02826636f, -0.01235741f, 0.06194424f, 0.02799403f, 
    0.00075680f, 0.11288551f, 0.00579577f, -0.04652149f, 0.21558198f, -0.09586100f, 0.14484313f, -0.01318968f, 
    0.04044642f, 0.03848138f, 0.10599270f, -0.11999907f, 0.00815236f, 0.00472185f, -0.03880520f, -0.06956504f, 
    -0.04552962f, -0.07132421f, 0.07273646f, -0.02621233f, -0.05056594f, 0.02826547f, 0.07025611f, -0.02210801f, 
    -0.02114072f, -0.06033307f, 0.03111628f, 0.01472077f, -0.23300691f, 0.12193116f, 0.20738335f, 0.02908759f, 
    -0.00470865f, 0.04659020f, -0.01977110f, 0.04374063f, 0.07263362f, 0.08761779f, -0.07957557f, -0.10640259f, 
    -0.20903045f, -0.12784587f, 0.00355411f, -0.01314698f, -0.03518161f, 0.01868699f, -0.06818084f, -0.02708488f, 
    0.02681775f, 0.02093296f, -0.07742798f, -0.06373741f, -0.16139555f, 0.06048967f, 0.01774968f, -0.06413122f, 
    -0.01606738f, 0.14411618f, -0.06307469f, -0.00363676f, 0.04583881f, -0.00118323f, 0.09308320f, 0.14765544f, 
    0.16282853f, -0.10710835f, 0.08731110f, 0.11953456f, 0.11190010f, -0.03503400f, 0.00682562f, 0.04557616f, 
    -0.06654336f, 0.03533021f, 0.10026839f, 0.00698881f, 0.02199532f, 0.06210335f, -0.04934502f, -0.04751350f, 
    0.05993695f, 0.03594993f, -0.02164268f, -0.01809527f, 0.00799373f, -0.01938235f, 0.05114931f, 0.05050587f, 
    0.13671903f, 0.27127445f, -0.11658043f, -0.05970991f, -0.04881424f, -0.04071544f, 0.05872230f, 0.05531416f, 
    0.00729008f, -0.06351782f, -0.05088207f, 0.01355941f, -0.11416084f, -0.04480020f, 0.11418760f, 0.10085306f, 
    -0.15159336f, 0.11098062f, 0.01743175f, -0.06983846f, -0.03901423f, -0.03901867f, 0.09109703f, -0.00237144f, 
    -0.09027401f, -0.17384394f, -0.14808163f, -0.04371947f, 0.14526983f, 0.06031395f, -0.05145372f, 0.08170036f, 
    -0.03878613f, 0.15837301f, 0.05559528f, -0.04287719f, 0.03266948f, 0.02737684f, 0.11595744f, -0.02263887f, 
    -0.00960461f, -0.00792182f, -0.01555843f, -0.09006273f, 0.01610366f, -0.01179526f, -0.00913244f, 0.02771207f, 
    0.08488312f, -0.01876924f, -0.02174599f, -0.14454268f, 0.08979160f, 0.08703554f, 0.00575096f, 0.01356654f, 
    -0.02256540f, 0.00185318f, -0.02728780f, 0.06263579f, -0.10228322f, -0.00492269f, -0.06481822f, 0.00486498f, 
    -0.06483903f, 0.02183900f, -0.02843868f, -0.01224205f, 0.07836032f, -0.09902591f, 0.05295646f, 0.01995072f, 
    -0.06920707f, -0.02832597f, -0.08223800f, -0.19230036f, 0.08269355f, 0.01194982f, 0.05554072f, 0.02095680f, 
    0.09043567f, 0.02334216f, 0.08857910f, -0.04601451f, -0.12538783f, -0.04519247f, 0.02013235f, -0.07088964f, 
    0.05319317f, 0.01168210f, 0.03531521f, 0.01799029f, -0.05175790f, -0.06381518f, 0.02039537f, 0.04247971f, 
    -0.05219501f, -0.03962455f, -0.08191625f, -0.00952714f, 0.09581491f, 0.01914486f, -0.01306773f, 0.05026707f, 
    0.06707626f, -0.02134479f, -0.01167642f, 0.07877854f, 0.04923363f, 0.05499144f, 0.13465075f, -0.11356521f, 
    -0.01275325f, 0.05583672f, -0.02256185f, -0.00272349f, -0.02347797f, 0.05690767f, -0.02287861f, 0.02439948f, 
    -0.02690015f, -0.04614687f, 0.13293785f, 0.00393394f, -0.12081534f, -0.11029525f, -0.02430435f, -0.05659925f, 
    -0.03077288f, 0.03682851f, 0.09526616f, -0.01751037f, 0.01661923f, 0.02837756f, -0.02037739f, 0.11817423f, 
    0.01991999f, -0.00486620f, 0.00230138f, 0.02379509f, -0.00332286f, 0.05804865f, 0.01330185f, 0.03241390f, 
    -0.04125496f, -0.08832575f, 0.03053995f, 0.04106182f, 0.08009706f, 0.05344677f, 0.03506242f, -0.07285886f, 
    0.08735887f, 0.05982797f, 0.06180497f, 0.02056553f, -0.12835170f, -0.03967113f, 0.04882940f, 0.03607875f, 
    0.08593170f, 0.02631685f, -0.03862269f, -0.02662906f, 0.00105111f, 0.02815430f, 0.06729235f, 0.10325217f, 
    0.10476976f, 0.03021836f, -0.13132136f, -0.00041246f, -0.04909507f, -0.07546113f, 0.02729345f, 0.04913894f, 
    0.03430510f, 0.01173089f, -0.00511453f, 0.00696943f, -0.16111664f, -0.14333518f, -0.11391130f, 0.04920907f, 
    0.06329930f, 0.01011618f, 0.11028039f, 0.12653585f, 0.02236434f, 0.11060911f, -0.04556732f, 0.01695093f, 
    -0.04794525f, -0.01960194f, 0.14465240f, -0.03836907f, -0.04198066f, 0.12919006f, 0.01782805f, 0.02132994f, 
    -0.00901412f, 0.10804246f, -0.08237295f, 0.02364765f, 0.01664431f, 0.00422824f, 0.11023199f, 0.04898148f, 
    0.06515814f, -0.03028583f, 0.00834596f, -0.00353742f, 0.06212362f, -0.02242836f, 0.03814351f, 0.08425704f, 
    0.01712977f, -0.06056077f, 0.03901779f, -0.01698273f, 0.14707071f, 0.12678356f, -0.03382751f, 0.05332842f, 
    0.05218821f, 0.01108911f, 0.01695769f, 0.05344153f, -0.16520627f, 0.07226788f, 0.08183419f, 0.01652843f, 
    -0.00564916f, 0.11322500f, 0.04854592f, 0.09566303f, 0.10345062f, 0.00393273f, 0.05001431f, 0.00917214f, 
    -0.02278881f, 0.02724223f, 0.10670699f, 0.12813221f, -0.02996084f, 0.02850930f, -0.03421720f, 0.07162007f, 
    0.03214781f, -0.02579815f, 0.07194702f, -0.08917027f, -0.02827173f, -0.00517546f, 0.01317093f, 0.07201453f, 
    0.05966086f, 0.01286697f, -0.04621890f, 0.03860740f, 0.00357759f, 0.01294639f, 0.04260542f, 0.01347131f, 
    -0.06623123f, 0.14095202f, 0.07114442f, 0.02707093f, 0.04529037f, 0.03310495f, -0.02678245f, 0.02004068f, 
    -0.05415357f, 0.05908779f, 0.04547787f, 0.07418105f, 0.12512520f, 0.15115726f, 0.00864898f, -0.09621678f, 
    0.00266843f, -0.04877058f, -0.02880668f, 0.03813085f, -0.04492580f, 0.01237107f, 0.08010056f, -0.06484466f, 
    0.02305808f, -0.13479260f, 0.13852215f, -0.05778182f, -0.04750799f, 0.07793050f, 0.05695131f, 0.07592075f, 
    -0.00322171f, 0.05702160f, 0.02809190f, -0.02528752f, 0.36485404f, -0.15793335f, 0.04067761f, -0.00839500f, 
    0.11882389f, 0.03468545f, 0.04373282f, -0.04852784f, 0.03071677f, 0.03435797f, -0.04307448f, 0.02348566f, 
    -0.07272158f, 0.17492230f, 0.21677282f, -0.14181386f, -0.04818940f, 0.04275030f, 0.00666277f, 0.02937361f, 
    0.03804268f, -0.05144840f, 0.10246635f, -0.05026076f, 0.15579489f, -0.08244237f, -0.06977047f, -0.03383742f, 
    0.00059148f, 0.02238758f, -0.00923831f, 0.14084706f, -0.03434933f, -0.02046116f, 0.05829092f, -0.02831450f, 
    0.02157887f, -0.13921866f, -0.03469723f, -0.00957773f, -0.05562923f, 0.04092133f, 0.00609740f, 0.04757817f, 
    -0.04099380f, 0.01653996f, 0.02317508f, -0.02192710f, -0.14331113f, 0.08057785f, 0.10405750f, -0.19258541f, 
    0.02484571f, -0.01680407f, -0.04879387f, -0.01054686f, -0.02820278f, -0.01456170f, -0.06497076f, 0.10964042f, 
    0.09737151f, -0.09742665f, 0.00082158f, -0.09889546f, 0.03231041f, 0.09587754f, -0.03455136f, 0.10275026f, 
    0.12242516f, 0.03210554f, 0.06810942f, 0.03858464f, 0.08776630f, 0.13856608f, -0.01347764f, 0.04425478f, 
    -0.03980414f, -0.05199209f, 0.08362073f, -0.01326847f, -0.04347282f, -0.01432703f, -0.05465379f, 0.12143130f, 
    -0.03121517f, 0.02265189f, -0.00327288f, 0.00060667f, -0.03198668f, -0.04231310f, 0.02820732f, 0.02714174f, 
    0.02640495f, -0.04026285f, 0.03047341f, 0.02829039f, 0.02768760f, -0.00495479f, 0.02462240f, 0.00363076f, 
    -0.00306433f, -0.00123367f, -0.01688998f, -0.01784269f, -0.00805178f, 0.01495744f, 0.00298620f, 0.01810404f, 
    0.01152029f, 0.02957303f, 0.00605755f, -0.04089364f, -0.03522743f, 0.00251848f, -0.00866567f, -0.02335495f, 
    -0.03283567f, 0.02095031f, -0.00777298f, 0.00020881f, 0.01821774f, -0.03206545f, -0.00829875f, 0.01637837f, 
    -0.04152902f, 0.00031254f, -0.01458705f, 0.00854716f, 0.00122145f, -0.01033946f, -0.03425733f, -0.01324425f, 
    0.01336884f, -0.00985220f, 0.02415262f, -0.03643795f, -0.01659048f, 0.01782188f, -0.03396830f, -0.02066408f, 
    -0.01655857f, 0.01140501f, 0.02592908f, -0.00051768f, -0.01336652f, -0.01470021f, 0.01122739f, 0.00130001f, 
    -0.02444646f, -0.01591612f, 0.02963423f, -0.04071181f, 0.01184140f, -0.00212515f, 0.01556406f, 0.01505642f, 
    -0.01962664f, 0.00375460f, 0.02216676f, -0.03025329f, -0.01858977f, -0.03477438f, -0.04070833f, 0.02726018f, 
    0.02005168f, -0.00794128f, -0.03605983f, -0.03110609f, -0.00966324f, 0.01987264f, -0.02296736f, 0.02518990f, 
    -0.03246666f, -0.00387354f, 0.02932460f, -0.00205507f, 0.03044392f, -0.02468163f, -0.00670361f, -0.03356166f, 
    -0.02052800f, -0.03345830f, -0.03062980f, -0.00848093f, -0.02655309f, 0.00415067f, 0.00836542f, 0.01030377f, 
    -0.01888989f, 0.00552949f, -0.03458947f, -0.03538945f, -0.00289350f, 0.01883985f, 0.00822422f, -0.03406754f, 
    0.01719284f, -0.02451107f, -0.00546181f, 0.03143035f, -0.03376882f, 0.02658249f, -0.00923319f, -0.01777506f, 
    -0.02691673f, 0.02674460f, -0.01126528f, -0.01644331f, 0.00338377f, 0.02358762f, -0.03696335f, -0.00757576f, 
    0.01155524f, -0.00357179f, -0.03071152f, 0.02245444f, 0.00161844f, 0.00600653f, -0.01416814f, -0.02317274f, 
    0.02060651f, -0.00893940f, -0.02184348f, -0.03401864f, 0.00436781f, 0.01010209f, -0.00786530f, 0.01631362f, 
    -0.01714601f, 0.02299901f, 0.00640392f, -0.02949950f, 0.01717971f, -0.01460908f, 0.01222794f, -0.00599880f, 
    0.00219838f, -0.01047367f, 0.00100265f, -0.03081572f, 0.00290701f, -0.01038452f, -0.00452455f, -0.01603766f, 
    -0.03232427f, -0.01360089f, -0.02813137f, 0.02400833f, -0.00339446f, 0.00456568f, -0.03302244f, 0.02446088f, 
    0.02417628f, 0.01067617f, -0.02805506f, 0.01476895f, 0.00353186f, 0.00511644f, -0.02264086f, -0.01449590f, 
    -0.01037692f, -0.03335408f, -0.04124503f, 0.00413947f, -0.01528911f, -0.00299987f, -0.00300480f, 0.02242997f, 
    0.02575530f, 0.00921284f, 0.02298740f, -0.02914245f, -0.00539643f, -0.02745773f, 0.03101530f, 0.01770482f, 
    -0.03330320f, -0.02500489f, -0.03725006f, -0.03156090f, 0.00237005f, -0.01623158f, -0.01074066f, 0.02569021f, 
    -0.01239551f, -0.01725709f, 0.02786949f, -0.00763063f, 0.01756526f, -0.00361507f, -0.01089711f, -0.04123758f, 
    0.01459487f, 0.02168569f, -0.02330739f, -0.03177814f, -0.03537400f, 0.01306331f, 0.00395004f, 0.01697582f, 
    -0.00512453f, -0.02471302f, 0.00948257f, 0.01638383f, 0.02186880f, 0.00583745f, 0.02333333f, -0.02426277f, 
    -0.01708854f, 0.02423521f, -0.02604881f, -0.00881638f, 0.02193373f, 0.02943953f, 0.00763119f, 0.02784724f, 
    0.03019253f, -0.00225071f, -0.03545344f, 0.02076412f, -0.04197511f, -0.03643787f, -0.00488230f, -0.00769811f, 
    0.02907123f, -0.04322584f, 0.00711699f, -0.00931420f, 0.02338200f, -0.02662919f, -0.01941194f, -0.02197479f, 
    -0.00309487f, -0.02599170f, -0.02720664f, 0.00005367f, -0.04022584f, 0.01541389f, -0.03225939f, -0.00696724f, 
    0.00238688f, -0.00182109f, 0.01315258f, -0.04233566f, 0.01537725f, -0.04184769f, 0.02514399f, 0.00503466f, 
    -0.00651370f, -0.02389095f, -0.03888822f, -0.01172542f, 0.02238130f, 0.02233114f, -0.03385191f, -0.04101205f, 
    0.01380160f, 0.02123553f, -0.03632071f, 0.00399991f, -0.03250853f, 0.01476754f, -0.00710690f, -0.00144379f, 
    0.01820248f, 0.02445290f, 0.02357167f, 0.02498340f, 0.02152830f, 0.01201756f, -0.00221987f, -0.01957730f, 
    -0.00706784f, -0.02847610f, -0.04213825f, -0.02771920f, -0.01284376f, 0.01362268f, 0.02723692f, -0.02249506f, 
    -0.01141085f, 0.00883973f, -0.01369644f, -0.02929186f, -0.00076728f, -0.00145680f, -0.00426799f, -0.02046171f, 
    -0.01809032f, -0.01443870f, 0.00056075f, -0.00620497f, 0.02358135f, 0.02399466f, 0.01460720f, -0.00479829f, 
    0.02864898f, -0.04007622f, -0.00335165f, 0.01774382f, -0.01465668f, -0.04013599f, -0.01536584f, -0.02854591f, 
    0.01721594f, -0.01490761f, 0.01600768f, 0.02435822f, -0.01056253f, 0.00733285f, 0.01385411f, 0.01934508f, 
    -0.01839791f, -0.00864128f, 0.00332074f, -0.01934698f, 0.02480445f, 0.02208867f, 0.01161189f, 0.00940492f, 
    -0.03146931f, -0.02368531f, 0.01328290f, -0.03247078f, 0.02469420f, -0.02857282f, 0.01054274f, 0.02854174f, 
    -0.01080630f, 0.01191806f, 0.02294686f, 0.02303151f, 0.01926626f, 0.01876820f, 0.01169327f, -0.01144847f, 
    0.00284410f, -0.02396834f, -0.01934535f, 0.02054560f, -0.01325816f, -0.00209768f, 0.00015567f, -0.00621572f, 
    -0.02628452f, -0.03458985f, -0.00203712f, -0.00030272f, 0.01124548f, 0.02049341f, -0.03179014f, 0.01719640f, 
    -0.01729696f, -0.00177208f, -0.00909761f, 0.01613642f, -0.00830010f, 0.01133649f, -0.00684448f, -0.00534954f, 
    0.02222404f, -0.02487869f, 0.01847256f, -0.02736124f, -0.02333833f, -0.03391061f, 0.00195692f, 0.01029501f, 
    0.02671898f, -0.00741436f, 0.01586083f, -0.03718872f, -0.02768609f, 0.01581503f, -0.01020409f, -0.03220577f, 
    -0.01033935f, 0.01651021f, 0.01273432f, 0.02245878f, -0.03938474f, -0.03117009f, 0.02460653f, -0.00738092f, 
    0.02936826f, 0.00813909f, -0.04132490f, -0.00327713f, 0.00346834f, -0.02688289f, -0.00672193f, 0.01443958f, 
    -0.03052364f, 0.03191207f, 0.02510804f, 0.01307196f, -0.03679308f, 0.00632988f, -0.03191259f, -0.00174714f, 
    -0.00223708f, -0.00236671f, -0.00142226f, 0.02040679f, -0.03974740f, -0.03712901f, -0.04294286f, -0.00268088f, 
    0.02015906f, 0.02655723f, 0.02276816f, -0.01200007f, 0.02814724f, 0.02617640f, -0.04080641f, -0.03631494f, 
    -0.00851573f, -0.00565200f, -0.00000499f, -0.01449218f, -0.03785987f, -0.02410295f, 0.00491538f, 0.01292790f, 
    -0.01556616f, 0.00510043f, 0.00279235f, 0.01171740f, -0.00365200f, 0.01943417f, 0.02031924f, -0.00865947f, 
    0.00269948f, 0.00651618f, 0.01379070f, 0.01692808f, -0.00637242f, -0.03581198f, -0.01698100f, -0.02732527f, 
    -0.03857643f, 0.00357112f, -0.03439102f, 0.02001481f, -0.01201463f, 0.01307532f, -0.03897869f, -0.00720863f, 
    -0.00209497f, -0.01364824f, 0.00540168f, -0.04076250f, 0.01207618f, 0.00461451f, 0.01376066f, -0.00708550f, 
    0.01660154f, 0.03122183f, -0.03650184f, 0.02937462f, 0.03163274f, -0.03836478f, -0.01571277f, -0.01220650f, 
    -0.03490735f, 0.03359793f, -0.03733920f, -0.02721283f, 0.01153406f, -0.02078192f, 0.01502086f, -0.03336838f, 
    -0.02620877f, 0.00869244f, -0.00796815f, 0.02670260f, 0.00582543f, 0.02085577f, -0.01336966f, -0.00368330f, 
    0.01791453f, -0.01986880f, 0.00316938f, 0.01899238f, 0.02349180f, -0.02679303f, -0.02537688f, 0.02170129f, 
    -0.04581648f, -0.03930916f, -0.03365627f, -0.00056491f, 0.02340164f, -0.03833835f, -0.02427623f, 0.00910405f, 
    0.00224476f, -0.02612303f, -0.03027174f, -0.01585818f, -0.02079287f, -0.01442281f, -0.02265207f, -0.02841145f, 
    -0.00388864f, 0.01110635f, 0.00737464f, -0.00256787f, 0.02577838f, -0.03085148f, 0.01133112f, -0.02564572f, 
    0.01398394f, -0.00542131f, -0.01795145f, -0.03976967f, -0.01845593f, -0.04122016f, -0.03746168f, -0.02373912f, 
    -0.02086380f, 0.00023993f, 0.00146492f, -0.01993253f, -0.03290132f, 0.00155635f, -0.03244717f, -0.00301041f, 
    -0.02600334f, 0.00682309f, -0.00895553f, 0.01925884f, 0.02104957f, 0.01152129f, -0.00191707f, 0.01154483f, 
    -0.02431440f, -0.03371515f, 0.01415740f, -0.03502017f, 0.00149204f, 0.02659764f, 0.01607511f, -0.03823854f, 
    0.02196116f, -0.01840106f, -0.02031680f, -0.02868002f, -0.02151167f, -0.03792460f, -0.00410600f, -0.03042946f, 
    0.00885479f, -0.00117066f, 0.00327043f, -0.01365124f, -0.02794395f, 0.02273636f, -0.01584737f, -0.03727204f, 
    0.02983851f, -0.00484937f, -0.00798067f, 0.00458496f, -0.00518180f, 0.02721031f, -0.03069198f, -0.03369857f, 
    0.02462745f, -0.03051373f, -0.01353906f, -0.00103773f, 0.01525064f, 0.01212189f, -0.04441692f, 0.01684612f, 
    -0.04102180f, -0.01058667f, -0.04086719f, 0.00026873f, 0.02236036f, -0.04171821f, -0.04107584f, -0.01798000f, 
    -0.01654961f, -0.02854181f, -0.00757914f, -0.00842878f, 0.00800515f, -0.02537778f, 0.01761403f, -0.02787979f, 
    -0.00376919f, 0.02489015f, 0.02135887f, -0.03839203f, -0.00116661f, -0.01270982f, 0.00180911f, -0.03236051f, 
    0.02078256f, -0.01022326f, 0.01000841f, 0.00492625f, -0.02176665f, 0.02361862f, 0.00861185f, -0.03673198f, 
    0.01178798f, -0.01457963f, 0.00608648f, -0.03669070f, 0.00920810f, 0.00220306f, -0.01072428f, -0.00428665f, 
    -0.04267505f, -0.03593015f, 0.02716449f, -0.00378307f, 0.00913277f, -0.00212738f, -0.01558903f, -0.00448826f, 
    -0.00710156f, -0.00914281f, 0.01987661f, 0.00194740f, 0.02676156f, -0.03105652f, 0.00655671f, -0.03940926f, 
    0.02291023f, 0.00352987f, 0.00099288f, -0.00991104f, 0.00604160f, 0.00454836f, -0.02734658f, -0.02106055f, 
    0.02403231f, 0.01594021f, -0.02169987f, 0.00792611f, 0.01424213f, 0.01403140f, -0.00513051f, -0.02070359f, 
    0.02222217f, 0.02376989f, 0.00937738f, -0.01262948f, -0.02823589f, -0.02277302f, -0.02594442f, -0.00580564f, 
    -0.03560840f, -0.01601486f, -0.04061026f, -0.01085803f, 0.02761643f, 0.00945326f, -0.03340138f, 0.01521206f, 
    0.00699404f, -0.03300242f, -0.01615816f, 0.02554783f, -0.01638906f, 0.01972256f, 0.02157509f, -0.02609298f, 
    0.01232123f, -0.00213982f, -0.02608141f, -0.03579535f, 0.02935895f, -0.03714421f, -0.00335342f, 0.01991144f, 
    -0.00040500f, 0.02188182f, -0.03451643f, -0.04014246f, -0.02564783f, 0.02300011f, 0.02941101f, -0.00807369f, 
    -0.00522695f, 0.03137264f, 0.02026404f, -0.02952632f, -0.02786161f, -0.03454933f, 0.02101447f, -0.02648749f, 
    -0.00224919f, 0.00501625f, -0.03718973f, -0.00628509f, 0.01977620f, -0.01853821f, -0.03461623f, -0.03131501f, 
    -0.02136147f, -0.01672980f, -0.03888479f, 0.02146508f, 0.00322032f, -0.03173137f, -0.03921477f, -0.00951811f, 
    0.00291609f, -0.03139556f, -0.01260450f, -0.01203744f, -0.02000203f, 0.02173481f, -0.02484340f, 0.00234208f, 
    -0.02449724f, -0.01621603f, -0.04170384f, 0.03037774f, -0.03527920f, -0.00872060f, 0.01442235f, 0.00312492f, 
    -0.03854343f, 0.00733681f, 0.02691052f, -0.04046540f, -0.02862728f, -0.01838591f, 0.02118984f, 0.02012965f, 
    -0.03093389f, -0.02213487f, -0.01741132f, -0.03116944f, -0.02239102f, -0.00073936f, 0.02973135f, -0.01134360f, 
    0.02888932f, 0.01561722f, 0.00203112f, -0.03202172f, -0.04114230f, 0.02740675f, -0.02243430f, -0.01991397f, 
    -0.02386691f, 0.10915792f, -0.12458722f, -0.15442067f, 0.12262165f, 0.06782261f, 0.01211236f, 0.02504009f, 
    0.03245072f, -0.07640339f, 0.01877472f, -0.00484770f, 0.23304883f, -0.10250502f, -0.10757930f, 0.11436380f, 
    0.05785249f, 0.00290177f, 0.06762884f, -0.01322954f, -0.00431933f, 0.06526941f, -0.03073868f, 0.04264026f, 
    0.20084904f, -0.27147159f, 0.03210201f, -0.24511784f, 0.02435162f, 0.00632275f, 0.06026717f, 0.12403461f, 
    -0.01112853f, -0.00547130f, 0.02293270f, -0.04042894f, 0.12791544f, -0.19962284f, -0.04368851f, -0.12080802f, 
    0.02846652f, -0.01123676f, 0.02475042f, 0.04305105f, 0.00534693f, 0.10018047f, 0.12138607f, 0.01557066f, 
    0.22224797f, 0.02891581f, 0.05111536f, 0.01655142f, -0.08152442f, 0.13663551f, -0.06083626f, 0.04385428f, 
    0.01348186f, 0.00871019f, -0.02040083f, 0.00042783f, 0.00943974f, 0.26558912f, -0.08620780f, -0.14856344f, 
    0.03632139f, -0.00416795f, -0.00885066f, 0.12703103f, 0.01869772f, 0.04040078f, 0.08080274f, 0.12054612f, 
    0.22597396f, 0.01196498f, 0.03027597f, 0.16397940f, -0.07338338f, -0.07356751f, 0.00495177f, 0.13557386f, 
    0.05567636f, -0.04576009f, 0.00150707f, 0.04595253f, -0.17792229f, -0.02621068f, 0.05899325f, -0.12271976f, 
    0.15866911f, -0.08194331f, 0.05051143f, -0.02465584f, -0.06926557f, -0.08805875f, 0.02754116f, 0.07277619f, 
    -0.27559546f, -0.01746479f, -0.07530653f, 0.07927083f, 0.13902605f, 0.05612963f, 0.13125303f, -0.03081041f, 
    0.03408729f, -0.08631650f, -0.03535841f, 0.06304429f, 0.10218862f, 0.03997492f, -0.01383391f, 0.26691818f, 
    -0.12689805f, -0.08399934f, -0.16431786f, 0.14162304f, -0.01208086f, 0.05600137f, 0.12502450f, 0.14282544f, 
    -0.12966235f, 0.31152490f, -0.15198711f, 0.07794287f, -0.09559109f, -0.13303825f, -0.01798643f, 0.06138334f, 
    0.04482389f, -0.08436251f, 0.00459812f, -0.03400603f, -0.11405622f, 0.01621815f, -0.04476236f, 0.00180310f, 
    0.03674028f, -0.02510610f, 0.01677238f, -0.08386015f, 0.11197633f, -0.08334509f, 0.04282235f, 0.03870116f, 
    -0.01822334f, -0.22812767f, 0.00713123f, -0.09956820f, 0.20207126f, 0.15024114f, 0.01669042f, -0.03810895f, 
    -0.03179754f, 0.09424105f, 0.01778133f, -0.01251000f, -0.15295564f, 0.03986702f, -0.05198073f, 0.04439667f, 
    -0.05681236f, 0.01514225f, 0.04132911f, -0.01591442f, 0.03422312f, 0.07025935f, 0.01628681f, -0.03675619f, 
    0.14781798f, -0.00142280f, 0.00785992f, 0.08178128f, -0.00894683f, 0.05005379f, 0.03916932f, 0.07877652f, 
    0.07106645f, -0.03635917f, 0.06554607f, 0.09519912f, -0.06468347f, -0.08647167f, -0.13713098f, -0.19936977f, 
    0.02738113f, 0.01690759f, 0.01811230f, -0.01437393f, -0.00873788f, 0.01386237f, -0.01834335f, 0.12856694f, 
    -0.46316111f, 0.18340142f, -0.05710028f, -0.11502618f, 0.09511637f, 0.11777893f, 0.02159459f, -0.00111662f, 
    0.13068475f, -0.06790248f, 0.02252054f, -0.12034773f, 0.25590616f, -0.27837670f, -0.12439519f, -0.20423943f, 
    0.05403512f, -0.05610299f, 0.03235077f, 0.07035869f, -0.11491621f, 0.02896421f, -0.03701776f, 0.00545179f, 
    -0.03730900f, -0.03686116f, 0.00880996f, 0.23213518f, 0.02408274f, 0.09999267f, -0.03507906f, 0.06058912f, 
    -0.07959437f, 0.05198202f, -0.02653601f, -0.05014988f, 0.10877179f, 0.11369900f, 0.13496345f, -0.16098054f, 
    -0.10895628f, -0.03079544f, -0.03180983f, 0.10312515f, -0.01684616f, -0.02448637f, 0.08237559f, 0.06741484f, 
    0.22384205f, 0.10877039f, 0.14303169f, 0.18810186f, -0.09167996f, -0.04160343f, -0.02437700f, -0.03016816f, 
    0.07293016f, -0.00941700f, 0.09884252f, 0.00118128f, 0.43851221f, -0.05839505f, -0.10820095f, -0.19700944f, 
    0.01282196f, 0.11183595f, 0.05858614f, 0.04114674f, 0.05614654f, 0.02261055f, 0.10493971f, 0.02887635f, 
    0.20782329f, -0.22249757f, 0.04307198f, -0.34512269f, 0.11787904f, 0.06759683f, -0.07199589f, -0.04323163f, 
    0.06935281f, -0.00788056f, 0.08710643f, 0.08380330f, 0.22471674f, 0.08941032f, 0.00392710f, -0.25356469f, 
    0.20733313f, 0.07261839f, -0.15682220f, 0.14116392f, 0.06171045f, 0.09104405f, -0.01239808f, 0.14409700f, 
    -0.08147082f, 0.15099351f, 0.17588089f, 0.21696050f, -0.07267025f, -0.10630211f, 0.03495918f, 0.11049590f, 
    0.13658367f, -0.07510475f, -0.01013075f, 0.06188086f, 0.11445005f, 0.07722573f, -0.13797683f, -0.06481743f, 
    0.02915802f, -0.01840694f, 0.06004636f, 0.03708243f, -0.00781749f, -0.05076616f, -0.05094809f, 0.11136977f, 
    0.09273443f, 0.19471569f, 0.25177294f, -0.02815798f, 0.02890130f, -0.03975459f, 0.07018057f, 0.16946633f, 
    -0.00881544f, -0.02736419f, 0.04036218f, 0.04096965f, 0.25216332f, 0.03064358f, 0.05869815f, 0.24301869f, 
    -0.04837177f, 0.03527639f, 0.04521561f, -0.00174846f, 0.00800217f, 0.03594514f, 0.01940325f, 0.04090129f, 
    0.26838279f, 0.03476465f, -0.11481071f, -0.17190051f, 0.08844285f, -0.01701391f, -0.15061481f, -0.07191474f, 
    -0.05084326f, 0.01116556f, 0.01251149f, 0.00555974f, 0.08682266f, -0.05620420f, -0.05926345f, -0.18934540f, 
    0.00932527f, -0.10520671f, 0.01107465f, 0.00091567f, -0.03620119f, 0.10796126f, -0.01790608f, -0.11198648f, 
    -0.28815490f, 0.19158405f, -0.31647757f, -0.07185972f, 0.00201041f, 0.08947036f, -0.00661561f, -0.03345339f, 
    0.11900134f, 0.00745360f, -0.00668730f, -0.07448880f, 0.04958946f, -0.08861336f, 0.30974767f, -0.03868833f, 
    -0.01044744f, 0.02341985f, 0.05558047f, 0.09185696f, 0.05997035f, 0.13955712f, -0.08068080f, 0.20455906f, 
    0.09884160f, -0.10962616f, 0.20379862f, 0.29861572f, -0.10347907f, -0.06241661f, -0.07385497f, 0.01532197f, 
    0.05483669f, 0.10579019f, -0.04186508f, 0.08699581f, 0.23275912f, 0.03537117f, 0.19273610f, -0.32394564f, 
    0.19655669f, -0.04655051f, 0.08098903f, 0.07148119f, 0.04784557f, 0.05357515f, 0.04018676f, 0.04858471f, 
    -0.00313991f, -0.03388064f, -0.09953737f, -0.20825993f, 0.01312553f, -0.04335748f, 0.00708058f, -0.02309121f, 
    0.06918853f, -0.06384982f, -0.01956093f, 0.12064279f, -0.02442231f, 0.08206742f, 0.26391906f, 0.17679638f, 
    -0.08364918f, 0.00319378f, 0.04595411f, 0.08702069f, 0.03476699f, -0.05620686f, 0.07280420f, 0.06038910f, 
    0.16045682f, 0.12211096f, -0.00181184f, -0.20573442f, 0.03556355f, 0.07557257f, -0.10461363f, -0.08465990f, 
    0.03928021f, 0.12377966f, 0.04436735f, 0.01540908f, 0.08301345f, -0.00641007f, 0.23628300f, -0.19051416f, 
    0.07028276f, 0.01951760f, 0.08969020f, 0.02100244f, -0.01544377f, 0.06269438f, -0.04865738f, -0.01551332f, 
    -0.02843454f, 0.00657930f, 0.06342252f, -0.22643456f, -0.04656571f, -0.01778236f, 0.02424769f, 0.08705596f, 
    0.07192592f, 0.04052402f, -0.25957429f, 0.04177989f, 0.22169805f, -0.27419168f, -0.14478886f, -0.38785633f, 
    0.08301536f, -0.06371843f, 0.08815594f, -0.01044182f, -0.01382647f, -0.00967296f, 0.00742921f, 0.09611561f, 
    -0.27811566f, -0.07680397f, 0.03192440f, -0.09328688f, -0.00536114f, 0.00352986f, 0.12090346f, 0.01359822f, 
    0.11644902f, 0.05672060f, -0.00448815f, -0.01370392f, -0.01317701f, 0.01175692f, 0.04694866f, 0.09481446f, 
    0.07361757f, 0.11194151f, 0.01526575f, -0.06213235f, 0.10282557f, 0.09125976f, -0.08216833f, 0.04263217f, 
    -0.05970392f, 0.20586410f, 0.03733979f, -0.04253507f, 0.13636695f, 0.17081793f, 0.11291961f, 0.04870246f, 
    0.04202810f, 0.01160215f, 0.02690106f, 0.04205688f, 0.12065060f, -0.04132497f, 0.01389560f, 0.26401094f, 
    -0.10164755f, -0.10989904f, 0.01126068f, 0.04422707f, 0.00395218f, 0.00840093f, 0.05795573f, -0.03062019f, 
    0.04613362f, 0.19869268f, 0.02042710f, 0.18501246f, -0.05814270f, 0.03166643f, -0.00781955f, 0.07819067f, 
    0.09801214f, -0.00505660f, 0.00512746f, -0.00139950f, 0.20525254f, -0.07751427f, -0.14264984f, 0.00357201f, 
    0.05506371f, 0.04903533f, 0.04442558f, 0.05004494f, 0.04556449f, 0.01430444f, 0.05350266f, 0.00378339f, 
    0.19678670f, -0.04608204f, -0.06951457f, -0.14713228f, -0.01163924f, 0.12219147f, 0.01850801f, 0.12789942f, 
    -0.00766672f, -0.00877441f, 0.00009074f, 0.06308759f, -0.07705135f, -0.01674935f, -0.12222183f, -0.11513280f, 
    0.12516266f, -0.03050466f, -0.01097408f, 0.05227809f, 0.01189545f, -0.06684592f, 0.03376548f, 0.06172484f, 
    0.13793847f, -0.05280155f, 0.25252011f, -0.10432991f, 0.16289258f, 0.01110855f, -0.06948571f, 0.18161967f, 
    0.03090090f, 0.01785500f, -0.01851196f, -0.03025518f, 0.10061820f, 0.15988383f, 0.02810402f, -0.12253458f, 
    -0.03994025f, 0.08685730f, -0.02708350f, -0.06901752f, 0.00155770f, -0.08775378f, 0.06120901f, -0.00078412f, 
    -0.07550873f, 0.04619776f, -0.01916784f, 0.00979801f, 0.10906034f, 0.07840898f, 0.04873874f, 0.01527695f, 
    0.05891355f, 0.04599547f, 0.10615820f, -0.06710153f, 0.31385580f, -0.25823334f, 0.00632820f, -0.26595554f, 
    -0.03495580f, -0.00646519f, 0.00287514f, 0.05710193f, -0.03225680f, 0.07952375f, 0.02627449f, 0.09236808f, 
    0.02832272f, -0.00562040f, -0.06248251f, -0.10878621f, 0.08314988f, -0.05109004f, 0.11778765f, 0.03367918f, 
    -0.07069667f, -0.05467226f, 0.09389391f, 0.07539237f, 0.18994759f, -0.06622402f, 0.20726635f, 0.05926796f, 
    -0.05080390f, -0.03759625f, 0.01193256f, 0.10400720f, -0.05736391f, 0.00952958f, -0.05413960f, 0.07455189f, 
    0.19986792f, -0.08780071f, 0.11267776f, 0.29358530f, -0.15138288f, -0.01810404f, 0.09927312f, -0.00701702f, 
    0.00922283f, 0.04558620f, 0.06656612f, -0.07535363f, 0.13603018f, 0.29792637f, -0.00740075f, 0.12081852f, 
    -0.06322307f, 0.01908884f, 0.08361939f, -0.06891371f, -0.01288363f, 0.02116598f, 0.06588261f, -0.06485309f, 
    -0.08425181f, 0.03879537f, 0.07098209f, -0.22559400f, 0.07149523f, -0.11162421f, 0.06801453f, -0.05896108f, 
    -0.03094086f, -0.01640417f, 0.03081857f, -0.02982611f, -0.09382930f, -0.00668369f, -0.18419464f, -0.15856948f, 
    -0.08152552f, 0.05022259f, 0.00162225f, 0.07675780f, 0.10157400f, 0.00913922f, -0.03806505f, -0.03073584f, 
    0.14635460f, -0.03144846f, 0.10411894f, 0.01308188f, 0.01448858f, -0.05561736f, -0.01708695f, 0.05418625f, 
    -0.03031885f, 0.07903731f, 0.04654275f, 0.06673085f, 0.03189452f, 0.02887090f, 0.05468051f, -0.17038539f, 
    -0.01873120f, 0.11418474f, -0.02171043f, -0.05549342f, -0.02428038f, 0.10325312f, -0.10153672f, -0.03886340f, 
    0.01332983f, 0.07984462f, 0.14792173f, -0.12490655f, -0.02279576f, -0.00623926f, -0.00456521f, 0.04254128f, 
    -0.05773897f, 0.01386171f, 0.04084070f, 0.21664554f, 0.03009800f, 0.08761199f, 0.06908213f, -0.00667206f, 
    0.00450370f, 0.11041711f, 0.09978651f, -0.01042032f, 0.10197435f, 0.04298478f, 0.13046870f, 0.02298493f, 
    0.35402071f, -0.12147174f, -0.11006446f, -0.20053814f, -0.05668420f, 0.06761742f, 0.02650305f, -0.13661802f, 
    -0.01663794f, 0.16680865f, -0.02701265f, -0.07743298f, 0.04770170f, 0.01671995f, 0.14729837f, 0.22672410f, 
    -0.08367729f, 0.00592374f, 0.10732310f, 0.05038007f, 0.04283500f, 0.05819278f, 0.08998683f, 0.06447681f, 
    0.01723918f, 0.00665797f, -0.01085857f, 0.03038987f, -0.03366283f, -0.03089505f, -0.01276577f, 0.01920502f, 
    0.00713229f, -0.02719090f, -0.03751352f, 0.02212665f, -0.00727586f, 0.01589329f, 0.00441904f, -0.01895506f, 
    0.03328313f, 0.00666462f, -0.03444984f, 0.00672905f, -0.01651671f, 0.00367265f, -0.03605762f, 0.02311404f, 
    -0.00367235f, -0.03354281f, -0.02300471f, -0.00739924f, -0.03117460f, -0.00012153f, 0.02550446f, -0.00400841f, 
    -0.00675469f, 0.00839219f, -0.01596406f, 0.01364289f, -0.00390550f, -0.01597668f, -0.01127966f, 0.00725298f, 
    0.01802323f, -0.01883831f, -0.02406259f, -0.03024839f, 0.02943014f, -0.00697982f, 0.00063143f, -0.01718117f, 
    0.00710747f, -0.02446929f, -0.01021368f, 0.02802436f, 0.03189984f, 0.01712330f, 0.00224530f, 0.00036409f, 
    0.01214842f, 0.02284016f, -0.02781747f, 0.00508226f, 0.01221186f, -0.01948865f, -0.03685903f, -0.03943169f, 
    -0.03105428f, 0.00820061f, 0.00377426f, -0.00849522f, 0.02676164f, -0.02958194f, -0.00477359f, -0.03996511f, 
    -0.01894152f, 0.03312331f, 0.03316782f, 0.01024514f, 0.02664258f, 0.01204833f, -0.01779217f, 0.01015218f, 
    0.00757901f, -0.01935229f, 0.01582820f, 0.02507243f, -0.03749018f, 0.01741829f, 0.00957966f, 0.02440117f, 
    0.01141110f, 0.00161461f, 0.00621576f, -0.02140851f, 0.01251836f, -0.00115851f, 0.01980967f, -0.02444725f, 
    0.01420653f, 0.02029929f, -0.03858351f, 0.00633124f, -0.03677240f, -0.01999537f, -0.03301636f, -0.03782805f, 
    -0.01871096f, 0.02588395f, 0.02516889f, -0.01551798f, 0.01087970f, -0.00026393f, -0.04146258f, -0.01717288f, 
    0.00961998f, -0.02886195f, -0.02022623f, -0.00598343f, -0.00976143f, 0.02468771f, -0.02993902f, 0.02771404f, 
    0.00853540f, 0.02448134f, -0.03482594f, 0.00077207f, 0.00797672f, -0.01478881f, 0.00014569f, -0.01322355f, 
    0.01759069f, -0.03054666f, 0.01839102f, -0.02497896f, 0.01505862f, -0.04070655f, -0.03120803f, -0.02183739f, 
    0.01590144f, 0.01694875f, 0.00975741f, -0.03834252f, -0.01145529f, -0.02221949f, 0.00856655f, 0.01692913f, 
    -0.00137463f, 0.02353796f, 0.02633035f, -0.03857994f, 0.00669313f, 0.02899697f, 0.03153201f, -0.01609153f, 
    -0.01849164f, 0.02820219f, 0.02655210f, 0.02777531f, 0.02293854f, -0.01580280f, -0.00633108f, -0.04041502f, 
    -0.03881276f, -0.01555855f, -0.00129182f, 0.00209370f, -0.00428476f, 0.03027345f, 0.01563157f, 0.02497146f, 
    -0.02596635f, -0.02173276f, 0.03740686f, -0.02531463f, -0.02851246f, -0.01107733f, -0.00720520f, -0.03652216f, 
    -0.00505460f, -0.01951228f, 0.00785260f, 0.02057865f, -0.02225277f, -0.00273753f, -0.03382911f, -0.03442241f, 
    -0.03557442f, -0.01036597f, 0.03079676f, -0.03293685f, 0.01696932f, -0.02812449f, 0.02482568f, -0.03893806f, 
    0.00031966f, -0.00202310f, 0.03010915f, -0.00156958f, 0.03029723f, 0.03929489f, -0.00081718f, 0.00524315f, 
    -0.00611140f, -0.03245052f, -0.02232240f, 0.02773603f, -0.01925959f, 0.02481160f, 0.02235592f, -0.04235930f, 
    0.03034934f, 0.01222276f, -0.02230898f, 0.01954473f, -0.01583150f, 0.00933689f, -0.01931327f, -0.01184716f, 
    -0.02498492f, -0.03375351f, 0.01630406f, 0.04001771f, -0.01279895f, -0.01342197f, -0.01821727f, 0.02947067f, 
    0.00276535f, -0.01400530f, -0.02272688f, 0.02045202f, 0.02446400f, -0.01254851f, -0.01250393f, -0.03177409f, 
    0.00622803f, 0.01783199f, -0.03045925f, 0.03192972f, 0.01880533f, -0.00084354f, -0.03117214f, -0.00366406f, 
    -0.02557983f, 0.00215033f, 0.01322392f, 0.00791033f, 0.01934340f, 0.00446673f, 0.01569297f, 0.03089834f, 
    0.01890851f, -0.00222048f, -0.01172941f, -0.03837261f, 0.01492262f, -0.00272185f, 0.02338456f, -0.02008500f, 
    0.02365476f, 0.02614825f, -0.00102758f, -0.00586632f, 0.00586927f, 0.03244501f, -0.00018926f, 0.00253076f, 
    0.01261712f, -0.03343972f, 0.00837793f, 0.01645044f, 0.00069655f, -0.00122559f, 0.01172737f, 0.02059407f, 
    0.02908695f, 0.00650990f, -0.01431040f, 0.00454980f, -0.03206249f, -0.01992060f, 0.01351253f, -0.02287781f, 
    0.00574747f, 0.03638165f, -0.01735936f, -0.01597863f, -0.01985190f, -0.01504700f, -0.03762424f, -0.00633531f, 
    0.03672222f, -0.01572395f, 0.01107512f, 0.01792123f, 0.01020020f, -0.02144452f, 0.01667067f, 0.01594360f, 
    -0.02128456f, -0.02488835f, -0.00375363f, -0.03824486f, 0.00054116f, 0.01350971f, 0.00288025f, -0.01980290f, 
    -0.00013721f, -0.03963480f, 0.01395653f, -0.00201611f, 0.02150494f, 0.00055691f, -0.03043802f, 0.01565732f, 
    0.01330828f, 0.00481777f, 0.01667086f, -0.02376534f, 0.02589992f, 0.03189089f, -0.03776988f, -0.02217506f, 
    -0.02407415f, 0.01124449f, -0.03237120f, -0.03740894f, -0.02972869f, -0.02756711f, -0.02758767f, 0.01535572f, 
    0.01824027f, 0.02194482f, -0.00402505f, -0.03189270f, -0.01716411f, 0.03424017f, 0.00620271f, 0.01429395f, 
    0.02551444f, -0.03831518f, -0.00280088f, 0.01793744f, -0.00798145f, -0.01768684f, 0.00598584f, 0.02079031f, 
    -0.01233465f, -0.03249816f, 0.00857264f, -0.00164521f, -0.03540483f, -0.02058613f, 0.01467951f, 0.00839011f, 
    -0.01596912f, 0.00158778f, 0.02728362f, -0.02062793f, 0.02933187f, 0.02348262f, -0.01378028f, 0.03638551f, 
    0.00037774f, 0.01521197f, 0.02382338f, -0.00737219f, 0.02817482f, -0.00814194f, 0.01764257f, 0.01713603f, 
    0.02114026f, 0.01941893f, -0.02626450f, -0.03171489f, -0.00428568f, 0.02848790f, 0.01090064f, -0.01162261f, 
    -0.02273053f, 0.01069605f, -0.00052197f, -0.00824061f, -0.03597723f, 0.00128940f, 0.02406028f, -0.02251859f, 
    -0.02142899f, 0.00991798f, -0.01253321f, 0.03629362f, -0.03251464f, -0.03549086f, -0.02822853f, 0.02556512f, 
    0.00886224f, -0.03953868f, -0.01409497f, -0.02892941f, 0.00531593f, 0.00632123f, -0.00969761f, -0.01841942f, 
    -0.00575865f, -0.02512427f, 0.01874040f, -0.02152661f, 0.01667728f, -0.00841692f, 0.00487659f, -0.00360081f, 
    -0.02405926f, -0.00916163f, -0.03128830f, -0.02072056f, 0.02659056f, 0.03665316f, -0.00806075f, -0.00388740f, 
    -0.00686585f, -0.01248138f, 0.01358387f, -0.02902142f, 0.02156558f, -0.01518924f, 0.00797657f, -0.00671555f, 
    0.01437617f, 0.01991337f, 0.01856796f, -0.01550312f, -0.02316892f, 0.02949289f, 0.01402410f, 0.00438081f, 
    -0.00012257f, 0.01161119f, 0.00443990f, -0.01252255f, 0.00230024f, -0.01398507f, 0.02083461f, -0.02390636f, 
    0.01830117f, 0.00680348f, -0.00551307f, -0.02377221f, 0.01795636f, 0.02884933f, -0.00591933f, -0.03286523f, 
    0.02220413f, -0.00509848f, -0.03266428f, 0.02687697f, -0.03008306f, -0.00379697f, 0.02223164f, 0.03323105f, 
    -0.02931487f, -0.01722850f, 0.02279109f, -0.03863052f, 0.01823625f, -0.04143338f, -0.02202842f, -0.01315195f, 
    0.00373459f, 0.02768411f, 0.02700957f, -0.00556821f, -0.01407663f, -0.02960047f, -0.01697453f, 0.01765495f, 
    -0.03118876f, -0.03083376f, 0.02399295f, -0.02772610f, -0.00415379f, 0.02834730f, -0.03543475f, -0.02803843f, 
    -0.02645425f, 0.00284772f, 0.00182114f, 0.02862339f, -0.03834688f, 0.02131089f, -0.01967073f, 0.00245334f, 
    0.02308186f, -0.00865753f, 0.00921905f, 0.01273102f, -0.01284920f, 0.01479364f, -0.03300790f, 0.01325151f, 
    -0.01185478f, -0.02850916f, -0.03327557f, -0.00619085f, -0.01738460f, -0.02744834f, 0.00134779f, 0.03089493f, 
    -0.01600409f, 0.00985942f, -0.00795879f, -0.02326556f, 0.01028133f, 0.02319163f, 0.03164597f, -0.01379831f, 
    0.00695590f, -0.02389532f, 0.00055092f, -0.03469051f, 0.03487101f, -0.02872343f, 0.01046270f, -0.02692685f, 
    -0.03024598f, 0.00633103f, -0.03078433f, -0.02160643f, -0.00075372f, -0.02589054f, 0.00208919f, 0.00122736f, 
    -0.01586646f, 0.02281676f, -0.02500444f, -0.04082262f, 0.01004783f, -0.02018059f, -0.01753995f, -0.02128179f, 
    -0.03475583f, -0.01838072f, 0.01967393f, 0.00718374f, -0.02358990f, -0.03294850f, -0.03031605f, 0.00317610f, 
    -0.03171396f, -0.00057148f, -0.03410174f, -0.02226654f, 0.02829124f, 0.01638365f, -0.01554257f, -0.01187001f, 
    0.00170288f, 0.01150361f, -0.03802362f, -0.00304937f, -0.01116309f, -0.03407361f, -0.02657833f, -0.00573799f, 
    0.02017345f, -0.00808123f, 0.03625446f, -0.00544786f, 0.00238746f, 0.00814864f, 0.00265586f, -0.01788522f, 
    0.03062323f, 0.03316244f, 0.02410767f, 0.03170662f, -0.00621589f, -0.00298220f, 0.03218568f, -0.03277082f, 
    -0.03450461f, -0.00599650f, 0.01520203f, 0.01775285f, 0.02760186f, -0.02808753f, 0.01543612f, -0.02675453f, 
    0.03624081f, 0.00752675f, 0.01364158f, 0.01995789f, -0.01503076f, -0.02267513f, -0.00279669f, -0.00868213f, 
    0.00881639f, -0.03321585f, -0.01236883f, -0.00705380f, -0.00063219f, 0.00027317f, -0.02631640f, 0.01034018f, 
    0.00716679f, -0.00617092f, 0.02599443f, -0.01525396f, 0.00486044f, -0.03015110f, -0.00734612f, -0.02220294f, 
    -0.02953581f, -0.02252174f, 0.02275867f, 0.01836705f, 0.00408152f, -0.02174301f, -0.02114775f, -0.00041643f, 
    0.01996891f, -0.01045261f, 0.00723034f, -0.01321288f, 0.03117923f, 0.01844781f, -0.02228159f, 0.02203977f, 
    -0.02383225f, -0.02275879f, 0.00274809f, 0.02370870f, 0.02141579f, 0.00772165f, -0.01890580f, 0.01648797f, 
    -0.01685965f, -0.03958460f, -0.00704179f, 0.00074419f, 0.00403447f, 0.00117679f, -0.01961508f, 0.02240840f, 
    -0.00133676f, 0.00303739f, -0.00071635f, -0.02389487f, -0.00827356f, 0.01130417f, -0.01281872f, -0.01729590f, 
    0.00211589f, -0.00669636f, 0.02053159f, 0.02068615f, -0.03038760f, 0.00428741f, -0.01922513f, 0.00782245f, 
    -0.02512932f, -0.02885956f, -0.02381969f, 0.01012961f, 0.01258655f, 0.02452040f, -0.02533758f, 0.02828132f, 
    -0.00547782f, -0.02563146f, 0.03626864f, 0.00445538f, 0.02873208f, 0.00524427f, -0.03387044f, -0.01594418f, 
    -0.00109133f, -0.00563797f, -0.00808672f, 0.02551817f, -0.02195553f, -0.01202694f, 0.02391321f, 0.02069702f, 
    0.00499658f, -0.00639574f, 0.01881823f, 0.01941255f, -0.03629282f, -0.02736317f, 0.00995466f, 0.01711679f, 
    -0.01749597f, 0.03057290f, 0.01680462f, -0.00583196f, 0.02689326f, -0.02060605f, -0.00823107f, 0.02716301f, 
    -0.00416996f, 0.02528833f, 0.00381317f, -0.02812893f, -0.02772888f, -0.02370642f, -0.01021398f, -0.03462693f, 
    0.01705097f, -0.01572073f, -0.00800161f, 0.03352626f, -0.00690056f, -0.00501425f, -0.00468496f, 0.02586535f, 
    0.01431781f, 0.00194155f, 0.00051707f, 0.00011146f, 0.01662774f, 0.00387878f, -0.00268732f, -0.03421774f, 
    0.02125139f, 0.01562263f, 0.00778890f, -0.02392778f, 0.01315839f, 0.00027553f, -0.02256266f, 0.01218068f, 
    0.01270270f, 0.01025417f, -0.03977110f, -0.02432062f, -0.03136329f, -0.03186246f, 0.00832690f, 0.01821631f, 
    -0.02673251f, 0.01165952f, 0.02082023f, 0.01896604f, 0.00903282f, 0.01408407f, 0.01501114f, -0.02590179f, 
    0.02661161f, 0.01123681f, 0.02439337f, -0.03608694f, 0.01127105f, -0.02476266f, 0.02776163f, -0.00905309f, 
    0.00367181f, 0.02392038f, 0.01008373f, -0.02894421f, 0.02570000f, 0.00596771f, 0.01116655f, -0.00005703f, 
    0.02154374f, 0.01865872f, -0.00707568f, -0.02336422f, -0.03426768f, 0.02799953f, -0.01315753f, 0.01629361f, 
    -0.02231564f, 0.02235616f, -0.02558460f, -0.00028928f, -0.02919960f, 0.00921436f, -0.01155120f, -0.04278477f, 
    -0.01474583f, -0.02464129f, 0.02422584f, -0.02064231f, -0.01195876f, 0.00210506f, 0.00980254f, 0.01248971f, 
    0.00491476f, -0.02945859f, 0.00198119f, -0.00683121f, -0.04171294f, -0.02642949f, -0.03054053f, 0.00016592f, 
    -0.00226411f, 0.01270001f, 0.01588615f, -0.00435434f, -0.02932359f, -0.02809611f, 0.00879766f, -0.00562410f, 
    -0.04543189f, 0.01157587f, -0.01686842f, -0.00173387f, -0.00647698f, -0.02774803f, 0.01008368f, -0.01532507f, 
    -0.03419355f, -0.03502950f, 0.01632776f, 0.00601525f, -0.00980977f, -0.00183533f, -0.02816197f, -0.01071270f, 
    -0.01800158f, 0.00329065f, 0.00570635f, 0.01401030f, -0.02490712f, -0.03310749f, 0.01684235f, 0.02730969f, 
    -0.01994165f, -0.03756840f, -0.03737220f, 0.01951133f, -0.03620250f, -0.03638748f, 0.00374345f, 0.02249121f, 
    -0.01179971f, 0.00805298f, -0.00846522f, -0.03098712f, -0.02133574f, 0.01215757f, -0.00420540f, -0.04067827f, 
    -0.00093992f, 0.03218102f, -0.00939816f, 0.01899460f, 0.01475699f, -0.02393462f, -0.03917857f, -0.03536770f, 
    -0.02705703f, 0.02426186f, -0.04205302f, 0.01466189f, -0.02276811f, -0.00048934f, 0.01663492f, -0.02446281f, 
    -0.00958621f, -0.01331620f, 0.02367612f, -0.01817190f, -0.01176040f, -0.00035690f, 0.01214525f, 0.00975116f, 
    -0.00827998f, -0.00028979f, -0.02236115f, 0.03245325f, 0.01191971f, -0.00053044f, 0.00652836f, -0.01027678f, 
    -0.02521426f, -0.00615678f, 0.02126140f, -0.03278264f, -0.00554284f, -0.00297468f, -0.02625558f, 0.02228490f, 
    0.02329573f, 0.01409301f, -0.01870900f, -0.02811047f, 0.00310600f, 0.01450914f, -0.02070925f, 0.02051567f, 
    -0.01947957f, 0.00287757f, 0.02956264f, 0.03576028f, -0.00255559f, -0.03814285f, 0.00472207f, 0.01065360f, 
    0.02841396f, -0.00275689f, 0.00069102f, 0.01459354f, -0.01955299f, -0.01304197f, -0.02109103f, -0.03877827f, 
    -0.04300107f, 0.00528782f, 0.01126164f, -0.04044209f, 0.01486810f, -0.00616885f, -0.02109850f, -0.02654956f, 
    -0.02077567f, -0.03805700f, -0.01345891f, 0.01667927f, -0.01565719f, 0.01555401f, 0.01465931f, -0.02312599f, 
    -0.01514567f, -0.01725419f, 0.02842439f, 0.00517435f, -0.02394515f, -0.03484293f, 0.02427024f, -0.00710533f, 
    -0.00453214f, -0.01820669f, 0.02245909f, -0.03473677f, 0.01698621f, 0.01144142f, 0.01596802f, -0.00182182f, 
    -0.01625786f, 0.00561099f, 0.01820168f, 0.01261618f, 0.02928540f, 0.00249123f, 0.02016160f, 0.00964801f, 
    -0.02970897f, 0.00308628f, -0.02159344f, 0.01716152f, 0.00021404f, 0.00267328f, -0.00271324f, -0.04162434f, 
    -0.04426333f, -0.00132041f, -0.00988133f, -0.01291642f, -0.03910197f, 0.01899103f, 0.01960455f, -0.02290077f, 
    0.00420856f, 0.03192599f, -0.04228560f, -0.00989145f, -0.03078861f, 0.00682437f, 0.01261230f, -0.01448022f, 
    0.00889166f, -0.03138816f, -0.01867501f, -0.03648390f, 0.00488729f, -0.02798636f, -0.02064709f, 0.01125669f, 
    -0.03266056f, 0.02701721f, -0.03562006f, -0.03812089f, -0.03461104f, 0.00655707f, 0.00834322f, -0.00337408f, 
    -0.04202020f, -0.03377977f, 0.02618322f, -0.00107335f, 0.02583041f, 0.00965094f, -0.00163346f, 0.01114815f, 
    0.02420977f, -0.03553731f, -0.00312061f, 0.01320431f, -0.00216227f, 0.02245864f, -0.00943193f, 0.03225030f, 
    -0.03301352f, 0.01315384f, -0.02027430f, 0.02864745f, -0.01925056f, -0.03837121f, -0.01713016f, -0.02667101f, 
    -0.02870714f, -0.01119686f, -0.00260904f, 0.00496098f, 0.00148319f, -0.02394200f, 0.00944785f, 0.00104903f, 
    0.02019212f, -0.02442960f, -0.00410673f, -0.02602004f, -0.01840812f, -0.00574261f, 0.01571750f, 0.01295173f, 
    -0.02294420f, -0.03847960f, -0.04001610f, -0.03129964f, 0.00912102f, -0.01548878f, 0.02972528f, 0.01074885f, 
    -0.02468793f, 0.02677267f, -0.02855571f, 0.01657516f, 0.02081057f, -0.03314831f, 0.01749343f, 0.01613241f, 
    0.01843772f, 0.01429060f, -0.02851123f, 0.01104954f, 0.03077869f, -0.01038466f, -0.00452654f, -0.00737778f, 
    -0.02411961f, 0.02788345f, 0.01135178f, 0.00769568f, -0.00022456f, 0.03825156f, -0.03701545f, -0.01327423f, 
    -0.00023256f, -0.01697958f, -0.00391982f, 0.00057260f, -0.01023785f, 0.00163669f, 0.00646799f, 0.02298920f, 
    -0.00756090f, 0.00610763f, -0.04262366f, -0.03690320f, -0.04119520f, 0.01682312f, -0.01525595f, 0.02354789f, 
    0.01011373f, -0.01156949f, 0.02793172f, 0.02616776f, 0.01552125f, 0.02995114f, -0.01509999f, -0.00877604f, 
    0.02114838f, -0.02714556f, 0.02441427f, -0.00729478f, 0.00640074f, 0.00716162f, -0.03934654f, 0.00727398f, 
    -0.03714242f, -0.00801183f, -0.03829816f, -0.02669159f, -0.01682468f, 0.01952995f, 0.02959165f, -0.02435239f, 
    -0.01420651f, -0.01983524f, 0.01034986f, -0.02366383f, -0.03292561f, -0.04241551f, -0.01812129f, 0.00844919f, 
    0.00864094f, 0.02108916f, -0.01631861f, -0.03235565f, -0.02750100f, -0.02786620f, -0.01212099f, -0.00329668f, 
    -0.02521943f, 0.02801823f, -0.00124138f, -0.01645906f, 0.01628953f, 0.02496207f, -0.03520763f, -0.01568696f, 
    -0.00875976f, 0.02688758f, -0.00034282f, 0.03027766f, -0.00313957f, -0.02768673f, 0.01150819f, 0.01113883f, 
    0.01433446f, 0.02852137f, -0.02023801f, 0.01130147f, 0.02700620f, -0.02275095f, -0.00821091f, 0.01215098f, 
    -0.04062739f, -0.00870758f, -0.02433918f, 0.00913642f, -0.01753383f, -0.03596289f, -0.02713207f, -0.03033774f, 
    0.03023081f, 0.02080676f, -0.01626357f, -0.02515174f, -0.03926073f, -0.00455596f, -0.00669624f, -0.01549182f, 
    -0.03703561f, -0.03448328f, -0.00620988f, -0.03200114f, -0.03343851f, -0.00688303f, -0.03089184f, -0.00372877f, 
    -0.01851435f, 0.02256709f, 0.01320571f, -0.03652775f, -0.01662695f, 0.02990714f, -0.03207833f, -0.00269793f, 
    -0.00785608f, -0.01074879f, -0.02925307f, 0.01937759f, -0.00986268f, -0.03983111f, -0.02710584f, 0.00168179f, 
    0.02645213f, -0.02365872f, -0.02077929f, 0.01568490f, -0.01701822f, 0.02901032f, -0.00353631f, 0.02506296f, 
    -0.03461782f, -0.03825070f, 0.00576150f, -0.02700559f, -0.02500175f, -0.04347927f, -0.00876347f, 0.03030046f, 
    -0.00051951f, 0.01250433f, -0.02444750f, -0.02463389f, 0.00314969f, -0.00796274f, -0.03166603f, -0.03782297f, 
    0.02939291f, -0.04079029f, -0.01916892f, 0.00925803f, -0.00199962f, -0.00404620f, 0.02594815f, -0.03955996f, 
    -0.03802389f, -0.01805654f, -0.02711100f, -0.02640587f, -0.00002092f, 0.00316849f, -0.00889955f, 0.00638710f, 
    -0.00644532f, -0.01729868f, 0.01440457f, 0.02221276f, -0.00462872f, -0.00592461f, 0.01092362f, 0.00599151f, 
    -0.00756406f, 0.00212844f, -0.02375615f, 0.00813060f, -0.04287051f, -0.01235423f, -0.01891627f, -0.03017711f, 
    0.02022835f, 0.01795577f, -0.02526530f, 0.03169625f, 0.00763977f, 0.00644874f, 0.00084269f, 0.00782239f, 
    -0.04030447f, 0.00693503f, 0.01806728f, 0.00859703f, -0.01535631f, -0.03327817f, -0.03112682f, 0.01481292f, 
    0.01460006f, 0.00782950f, -0.04074656f, -0.01455469f, 0.02818858f, 0.02052522f, -0.01305400f, 0.01841092f, 
    -0.03028711f, -0.02358317f, -0.01614715f, -0.01100619f, 0.00617812f, -0.03090217f, -0.00981757f, -0.02568004f, 
    -0.00400098f, -0.03708751f, -0.03377088f, -0.02478200f, 0.00978600f, -0.00184981f, 0.00934851f, -0.02930523f, 
    -0.00565352f, -0.00599316f, -0.03634455f, -0.02198611f, 0.02407990f, -0.01812192f, -0.02169983f, 0.01056181f, 
    0.01097210f, -0.01902344f, -0.02157126f, -0.02128021f, -0.01209000f, -0.03639267f, 0.00419967f, -0.02216366f, 
    -0.00517295f, 0.01426054f, -0.02459339f, 0.00905262f, -0.02579327f, 0.00796143f, -0.02614331f, -0.02206117f, 
    0.03038432f, -0.02538680f, 0.02583025f, -0.01358599f, -0.02704753f, -0.00884266f, 0.00594996f, -0.00902871f, 
    0.01676685f, -0.02118834f, -0.00454248f, -0.00940451f, -0.02603398f, -0.01292897f, -0.00716887f, -0.02191621f, 
    0.01294101f, -0.00322400f, -0.03811254f, -0.00616523f, 0.03216505f, -0.01269385f, 0.02480074f, -0.02505470f, 
    0.02286114f, -0.03514343f, -0.01457658f, -0.02514643f, -0.04021686f, 0.00118673f, 0.01673747f, -0.00006145f, 
    -0.00214565f, -0.02342455f, -0.01606249f, 0.00188532f, -0.01510674f, 0.00530082f, -0.03195833f, -0.03241511f, 
    -0.04338514f, 0.02980361f, -0.03684682f, -0.01058929f, 0.02269705f, -0.00254552f, 0.00406362f, 0.00021683f, 
    -0.03065030f, -0.02728986f, 0.01831930f, 0.01575605f, -0.01837049f, 0.01264202f, -0.03925530f, -0.04192428f, 
    -0.00195248f, 0.01494656f, -0.02357534f, 0.00943083f, -0.00243298f, -0.01865713f, -0.01217127f, -0.03612009f, 
    -0.01294069f, 0.01992786f, -0.03083803f, -0.00633890f, -0.01777120f, -0.00512452f, 0.02495955f, 0.01853118f, 
    0.02145125f, -0.01810046f, 0.02142777f, -0.01334221f, -0.03406170f, 0.01598540f, -0.03413608f, -0.01826647f, 
    0.01328224f, 0.00781648f, 0.00441311f, -0.00571987f, -0.03256731f, 0.01676331f, -0.00310701f, 0.00647827f, 
    -0.03527675f, -0.00875994f, -0.01310979f, -0.02403514f, -0.00351775f, -0.01428076f, -0.02822352f, -0.02998409f, 
    0.02306067f, 0.02370506f, -0.00542961f, 0.02050749f, 0.01211547f, -0.01598640f, -0.00647493f, 0.00471039f, 
    -0.00418192f, -0.01795536f, -0.02425848f, 0.00276218f, -0.02533529f, 0.00941141f, 0.02215937f, -0.03524554f, 
    -0.01247208f, -0.03067935f, 0.01036848f, -0.00017345f, 0.01472503f, 0.01075960f, -0.01894666f, -0.01893228f, 
    -0.01373501f, -0.03190037f, 0.00688736f, 0.00438193f, 0.00658937f, -0.00317011f, 0.02360302f, -0.03439276f, 
    -0.02803270f, -0.03798958f, 0.01615841f, 0.01237189f, 0.01866012f, -0.01413673f, -0.03492011f, 0.02574623f, 
    0.00533139f, 0.02544577f, -0.02908180f, 0.02243481f, -0.02122651f, -0.02416653f, -0.01834685f, -0.01526518f, 
    0.00860094f, 0.02269921f, -0.02525127f, -0.02052423f, -0.03127624f, -0.04268563f, -0.01538729f, 0.00185886f, 
    -0.02620188f, 0.00996904f, 0.00520297f, -0.03254315f, 0.02798497f, -0.01576044f, -0.02283687f, 0.01231017f, 
    -0.00069532f, -0.02794074f, 0.02422746f, 0.02301175f, 0.02151994f, 0.01950205f, -0.00026023f, -0.03021877f, 
    0.01468623f, -0.00283473f, 0.01308839f, -0.00870957f, -0.02165409f, 0.00174867f, -0.00862770f, -0.02858801f, 
    0.02673913f, 0.00448747f, -0.02596922f, 0.01940202f, 0.01068331f, -0.01486627f, -0.00001180f, 0.00831762f, 
    0.02272577f, -0.02594056f, -0.03698607f, -0.00140805f, -0.02076039f, -0.01842753f, 0.00065693f, 0.01583976f, 
    0.01500420f, 0.01572917f, 0.00647494f, 0.00270146f, -0.02612393f, 0.00768084f, 0.01488630f, 0.00876234f, 
    -0.02949749f, 0.01455411f, 0.02390967f, -0.01034513f, -0.04209622f, 0.02485802f, -0.00733908f, 0.02031711f, 
    0.02454403f, -0.02246067f, -0.01385474f, 0.00204329f, -0.00764387f, 0.02498497f, 0.00610524f, -0.01849225f, 
    0.00281631f, -0.00266351f, 0.03056725f, 0.03270167f, 0.00747397f, -0.01010522f, -0.02702636f, -0.01620926f, 
    0.01935388f, 0.00366778f, 0.02349252f, 0.02767510f, 0.00792471f, -0.02037717f, 0.03631383f, -0.02510578f, 
    -0.01580179f, 0.01409773f, 0.02455274f, 0.00328430f, -0.01710996f, -0.04122647f, -0.03079228f, -0.01545559f, 
    0.05233802f, -0.14656207f, 0.00541368f, 0.06496778f, 0.16004600f, 0.02600352f, -0.01317630f, 0.07677977f, 
    -0.01796372f, 0.09507336f, 0.07544456f, 0.22825186f, -0.12098176f, 0.00902374f, -0.06881604f, 0.08206926f, 
    -0.01678978f, 0.02540276f, 0.09158561f, -0.04820662f, 0.13541523f, 0.01683559f, 0.03704550f, 0.05850087f, 
    0.05567917f, -0.06692050f, 0.19114067f, 0.12022521f, 0.05416625f, 0.06863371f, 0.00636255f, 0.10054810f, 
    0.00142509f, 0.10733811f, 0.04529288f, 0.11492020f, 0.08120367f, 0.00563714f, 0.10806356f, -0.08257104f, 
    -0.02530500f, -0.01330193f, 0.03429674f, 0.08308505f, -0.04931078f, 0.00433587f, 0.00490264f, 0.03970502f, 
    -0.19138660f, -0.14517254f, 0.05468717f, -0.02393652f, 0.04479762f, 0.10538922f, 0.05954245f, 0.06807699f, 
    0.00497520f, 0.01852210f, 0.16262500f, 0.10047436f, 0.17145181f, -0.05615123f, 0.08542112f, 0.26578051f, 
    0.00419546f, 0.07796710f, 0.01296027f, 0.00644425f, -0.10177214f, 0.04217439f, 0.04674812f, -0.01414986f, 
    0.04497453f, 0.13271111f, 0.22290507f, -0.03418951f, -0.07580734f, -0.11875772f, -0.06236552f, 0.00485191f, 
    -0.02858694f, 0.08845667f, -0.10502000f, 0.00531460f, 0.04114832f, -0.19777155f, 0.12416533f, 0.08987062f, 
    -0.09092104f, 0.04680428f, 0.12473609f, 0.04826025f, 0.09014260f, 0.00095892f, -0.14075080f, 0.05432634f, 
    0.19017102f, 0.28836125f, -0.04254099f, -0.06792785f, 0.01044917f, 0.14461254f, -0.03914466f, 0.00827662f, 
    0.04678865f, 0.14182283f, 0.07350894f, -0.05944610f, -0.00371463f, 0.21784499f, 0.09543820f, 0.02643516f, 
    0.00599799f, 0.02265213f, 0.07087392f, -0.11231455f, -0.04530206f, -0.18068857f, -0.03822792f, -0.07056312f, 
    0.22728996f, -0.16945663f, 0.27980623f, 0.13068882f, 0.00906671f, -0.01228870f, 0.02163154f, 0.00232063f, 
    -0.05836625f, 0.00673348f, 0.11229642f, 0.01869872f, 0.07025738f, 0.26304558f, -0.01026705f, 0.14040734f, 
    0.04075525f, -0.03616222f, 0.00176915f, 0.01018312f, 0.12643316f, 0.08205865f, 0.05623815f, 0.14521766f, 
    -0.05051760f, -0.03604727f, -0.15107837f, 0.01181287f, 0.00561293f, -0.09719515f, 0.07376618f, -0.03420510f, 
    -0.04153843f, -0.03922982f, -0.02811168f, 0.03118163f, 0.03194610f, 0.08431406f, 0.06699270f, 0.21939513f, 
    0.04683177f, 0.01595738f, 0.08949532f, -0.00851058f, 0.01762173f, 0.04028001f, 0.12616351f, 0.14518175f, 
    -0.34058800f, -0.03450465f, 0.06150893f, -0.08110155f, 0.04624867f, 0.10674370f, 0.03930478f, 0.00767194f, 
    -0.04585508f, 0.08877759f, -0.03269819f, 0.11898738f, 0.10140839f, 0.04051461f, -0.01568476f, 0.21518290f, 
    0.11931343f, 0.10487788f, 0.06664564f, 0.03942687f, -0.01054570f, 0.14414750f, 0.00427059f, -0.15404259f, 
    0.18601716f, 0.02319035f, 0.11671164f, 0.18794207f, -0.01418198f, -0.03772491f, 0.01580768f, 0.03355253f, 
    0.09923504f, 0.10361589f, 0.03667727f, 0.02975933f, -0.06919098f, -0.04514294f, 0.13258688f, 0.01238995f, 
    0.08769551f, 0.08010191f, 0.03651821f, 0.14977016f, 0.05011923f, 0.03747775f, 0.09033675f, 0.04327756f, 
    0.33686993f, 0.19959778f, 0.00084846f, -0.06643835f, 0.12950338f, 0.11102702f, 0.01765112f, -0.00330449f, 
    0.03367530f, 0.00609500f, 0.08046807f, 0.01055805f, 0.11311751f, -0.16335474f, 0.08879781f, 0.07315528f, 
    -0.09942639f, 0.10651038f, 0.01746565f, 0.06441603f, 0.04913607f, 0.11340921f, -0.11006597f, -0.02031595f, 
    -0.00755049f, 0.09550139f, 0.08432005f, -0.20571679f, 0.01861162f, -0.02146826f, -0.01220077f, 0.01458470f, 
    0.07787573f, 0.02887838f, -0.14628384f, -0.01675845f, -0.04003884f, -0.04970257f, -0.07962403f, -0.10088509f, 
    0.18593776f, 0.03684204f, 0.02092716f, 0.05188667f, 0.08640665f, 0.09862334f, 0.01583725f, 0.04676895f, 
    0.17139368f, 0.05939691f, 0.15861315f, -0.09467424f, 0.09811390f, -0.02739993f, -0.01142374f, 0.03884585f, 
    0.00865368f, 0.04783516f, -0.05610461f, 0.03101662f, 0.06434356f, -0.06409601f, -0.04505193f, -0.18679856f, 
    0.09508085f, -0.00042887f, 0.07902328f, 0.09490249f, 0.14762017f, -0.06229879f, 0.06122520f, 0.06568296f, 
    0.43553460f, 0.11000775f, 0.04968083f, 0.01832003f, -0.11333345f, -0.00774840f, 0.03254694f, 0.04432420f, 
    -0.10384867f, -0.10075130f, 0.06159556f, 0.05287476f, -0.05241025f, -0.26950771f, 0.24156764f, 0.00439873f, 
    -0.03403820f, 0.00198068f, 0.10172814f, -0.05496258f, -0.09907664f, 0.04438776f, -0.08037958f, 0.07341731f, 
    0.16543385f, 0.05045401f, 0.16103218f, 0.07366057f, 0.00411996f, 0.01381311f, -0.02609962f, 0.05699464f, 
    0.00241207f, -0.08093128f, 0.02986914f, 0.01999041f, -0.02670139f, -0.07682341f, 0.11201095f, -0.15403253f, 
    -0.00488197f, 0.01866033f, -0.01933868f, 0.01032801f, 0.11921165f, 0.01132959f, -0.05956015f, -0.01769835f, 
    0.02010219f, -0.03474483f, 0.03107616f, 0.02483666f, 0.06231796f, 0.00072177f, 0.04394261f, 0.10082231f, 
    -0.02234465f, -0.00249110f, 0.04207287f, -0.01877165f, -0.08767938f, 0.00651394f, -0.02111009f, 0.28547332f, 
    0.03500208f, 0.13778844f, -0.10884272f, 0.05554782f, 0.01971154f, 0.03088365f, 0.16465661f, 0.14722465f, 
    -0.00945404f, -0.32618809f, 0.26363054f, 0.22896074f, -0.03358871f, -0.10269615f, -0.00063904f, 0.12825404f, 
    0.07563878f, 0.07089634f, 0.08174646f, 0.07576565f, -0.08449057f, 0.08108573f, 0.07956382f, -0.07365650f, 
    0.06821814f, 0.01025640f, -0.05377230f, 0.03067893f, 0.06429858f, -0.03813279f, 0.11969326f, -0.01607596f, 
    0.17004955f, 0.14079276f, -0.24016814f, -0.17842630f, -0.00351675f, -0.04879405f, 0.10790614f, -0.01757132f, 
    0.00418135f, -0.04151240f, -0.14811841f, 0.03496625f, -0.06540214f, 0.02168474f, -0.01520250f, 0.12522602f, 
    -0.07032537f, 0.07517653f, -0.00120751f, 0.05316146f, -0.04948836f, -0.04933194f, 0.00743763f, 0.02947758f, 
    0.15245965f, 0.01366176f, -0.19230661f, -0.08337782f, 0.26359552f, 0.03447850f, -0.01812152f, 0.10536560f, 
    0.00839880f, 0.20372856f, 0.11114747f, -0.09807057f, 0.35102552f, -0.01834297f, 0.06168645f, -0.14161322f, 
    -0.02019704f, -0.07225149f, 0.04177088f, 0.04044393f, -0.07113954f, -0.12267762f, 0.01423305f, -0.01448786f, 
    0.12256220f, -0.22056904f, -0.02820748f, -0.21720536f, 0.07018680f, 0.11382213f, -0.10248484f, 0.08696987f, 
    -0.01973416f, -0.01094481f, 0.03290033f, 0.07790147f, 0.16189390f, -0.07000097f, -0.02714782f, 0.11668488f, 
    0.03662331f, 0.06596098f, -0.01340717f, -0.00134477f, 0.08516312f, -0.03038120f, 0.03056461f, -0.04551379f, 
    0.05486839f, -0.10436121f, -0.02632636f, 0.10430951f, 0.05324207f, 0.16208698f, 0.00795740f, -0.02801751f, 
    -0.03267346f, -0.00913852f, 0.14291874f, -0.07150371f, 0.00537928f, -0.04707044f, 0.07321966f, -0.01193936f, 
    0.17588003f, 0.00219424f, 0.04467585f, -0.02774460f, -0.05961427f, 0.06191510f, -0.07204800f, -0.00959905f, 
    0.30234042f, 0.07272088f, 0.01923388f, 0.09067528f, 0.10503797f, -0.05309555f, 0.01666801f, -0.03472358f, 
    0.04342689f, -0.09535811f, 0.00240620f, 0.05914247f, -0.36921453f, -0.24732943f, 0.08656464f, 0.01730352f, 
    -0.12472365f, -0.03947457f, 0.10352904f, 0.10465287f, -0.17182951f, -0.04924836f, 0.04863191f, 0.05496510f, 
    0.09784178f, -0.19927189f, 0.14959356f, 0.02289126f, -0.14421234f, -0.03274848f, -0.01369889f, 0.09665062f, 
    -0.04312888f, -0.02180734f, -0.03657143f, 0.03159028f, -0.17045739f, 0.22154664f, 0.11054066f, 0.08987085f, 
    -0.03980318f, 0.01047724f, -0.04796789f, 0.03516097f, 0.16900474f, -0.02599447f, -0.07488625f, 0.16931736f, 
    0.04911476f, -0.15064053f, 0.04878556f, -0.00710667f, 0.07578359f, -0.06005785f, -0.04368984f, -0.08065493f, 
    -0.06612189f, 0.02295099f, 0.11215501f, -0.08538392f, -0.31980106f, -0.05249991f, 0.15704340f, 0.04179006f, 
    0.14187869f, 0.07029840f, 0.04635817f, -0.08768032f, -0.01463129f, -0.02014486f, 0.03525459f, 0.22795077f, 
    -0.17376174f, 0.22396310f, -0.11368507f, -0.01758105f, 0.05391851f, -0.09376007f, 0.07242069f, -0.01459379f, 
    0.04861241f, 0.09728203f, -0.00903984f, 0.07794135f, 0.07656771f, 0.06607545f, -0.13850774f, 0.07008468f, 
    0.04427416f, 0.06482055f, 0.14196903f, -0.00288183f, -0.00403407f, 0.07927102f, -0.01164136f, 0.02276815f, 
    0.27640310f, -0.01846261f, 0.01497664f, 0.06417395f, 0.03348620f, -0.00361197f, 0.02018147f, 0.01465522f, 
    -0.14249520f, 0.08940067f, -0.06210903f, 0.02732343f, 0.22568865f, 0.10178208f, 0.14647563f, 0.17117421f, 
    -0.03002254f, -0.07074454f, -0.01543864f, 0.09410551f, 0.13655157f, 0.08799104f, 0.09188767f, 0.04558916f, 
    0.02448953f, -0.16125695f, -0.10927819f, 0.17212582f, 0.00083868f, 0.08485305f, -0.10861451f, 0.08259870f, 
    -0.04492939f, 0.01965375f, 0.08516319f, 0.02184186f, -0.06796326f, 0.01483222f, 0.00362685f, 0.07497785f, 
    0.03900914f, -0.03823799f, -0.02421543f, 0.01786126f, 0.04337283f, -0.00054279f, 0.00839034f, -0.01417282f, 
    0.08408986f, -0.02917724f, 0.14101359f, -0.03556284f, 0.10807544f, -0.08215726f, -0.05980139f, 0.10109373f, 
    -0.08166517f, 0.01362291f, 0.10225043f, -0.08501514f, -0.14112234f, 0.18665759f, 0.04127732f, 0.05961817f, 
    0.07689656f, 0.00084909f, -0.02319483f, 0.00818736f, 0.06318866f, 0.00846436f, 0.09006182f, -0.02380599f, 
    0.01057045f, 0.26325777f, 0.08765834f, -0.20796025f, 0.05843651f, 0.03699401f, 0.02261831f, -0.01884128f, 
    -0.10400759f, -0.07360970f, 0.06259123f, 0.04316077f, 0.38519940f, 0.01231063f, -0.01632881f, -0.34631276f, 
    -0.07062591f, 0.03047898f, -0.02154292f, 0.04002074f, -0.03384821f, 0.00407752f, -0.02400473f, -0.01443278f, 
    0.20938359f, 0.05818918f, 0.16112588f, 0.00724075f, 0.03964504f, 0.08262604f, -0.03405033f, 0.15991928f, 
    0.00542913f, -0.00629319f, 0.10701065f, 0.03732652f, -0.10324757f, -0.42399484f, 0.04585725f, -0.10025649f, 
    0.02851416f, 0.09543756f, 0.03263706f, -0.03437777f, -0.03926447f, 0.10058086f, 0.02042008f, 0.08012407f, 
    0.11718722f, 0.17076375f, 0.13331540f, -0.03544173f, -0.04514414f, -0.00776333f, -0.09875053f, 0.00619622f, 
    -0.00538577f, -0.05700317f, -0.08294081f, -0.08955479f, -0.13841964f, -0.19128191f, -0.11186038f, -0.09347411f, 
    0.05720379f, -0.00247313f, 0.11260803f, 0.18197039f, 0.11028720f, -0.00805118f, 0.07934511f, -0.01594843f, 
    -0.06529772f, 0.07520718f, 0.08817682f, 0.07826381f, 0.06545911f, 0.09559838f, -0.00631263f, 0.08039305f, 
    -0.02299457f, -0.07176078f, -0.00560568f, -0.11977743f, -0.07237527f, -0.20602180f, 0.02777917f, 0.03251504f, 
    -0.11011419f, -0.03364780f, -0.05820289f, -0.02033154f, -0.07916209f, 0.00781988f, -0.02454067f, 0.04375252f, 
    -0.29639947f, -0.02251302f, -0.05983360f, -0.07082273f, 0.16450326f, -0.03662768f, 0.04891002f, 0.08832203f, 
    0.02454110f, 0.05923048f, 0.04842062f, 0.00507157f, -0.17326616f, 0.15324488f, -0.06339881f, -0.02824689f, 
    -0.08636212f, 0.01633380f, -0.01434516f, -0.00805533f, -0.04092896f, -0.05889100f, -0.06090113f, 0.05569419f, 
    -0.35198158f, -0.22429259f, -0.05382641f, 0.03285652f, -0.00480007f, 0.02221592f, -0.12084197f, 0.13704722f, 
    0.02280217f, -0.05144178f, 0.04132979f, -0.01857265f, -0.18658750f, -0.00986616f, 0.01645777f, -0.00581353f, 
    0.06608506f, -0.06622537f, -0.10677812f, 0.12299436f, -0.01093050f, 0.15397839f, -0.03454375f, -0.03477413f, 
    -0.05586644f, -0.30816397f, -0.01984661f, -0.04557304f, 0.04117811f, 0.05759889f, -0.04690768f, 0.00542018f, 
    0.07956525f, -0.02331802f, -0.02171953f, -0.02158564f, 0.16051589f, 0.01744169f, 0.08633233f, -0.16140856f, 
    0.02879289f, 0.02240217f, -0.00518237f, 0.03811234f, 0.01754310f, 0.11648008f, -0.05940052f, 0.05265438f, 
    -0.27026340f, -0.10501959f, -0.01594367f, 0.00171583f, 0.09121473f, 0.09585747f, 0.02233038f, 0.13080767f, 
    -0.00696934f, 0.04447429f, -0.03882681f, -0.18394314f, 0.40041372f, -0.02579495f, 0.04940764f, 0.14839502f, 
    0.05257925f, -0.04556502f, 0.02739577f, 0.05241513f, -0.00487072f, 0.11958870f, 0.05627608f, 0.10949478f, 
    0.36451089f, 0.02418382f, 0.03731193f, 0.03433200f, -0.01968174f, -0.07939268f, 0.02284832f, 0.03279119f, 
    0.07746947f, -0.09640840f, 0.08245538f, 0.10921159f, -0.03152681f, -0.10340980f, 0.04316596f, 0.23656394f, 
    -0.09632234f, 0.02955155f, 0.04245432f, 0.02193142f, 0.03166028f, 0.00829541f, -0.09220953f, -0.01924435f, 
    -0.21585456f, 0.17671603f, 0.03098370f, -0.14123683f, 0.08453893f, 0.05492435f, -0.08441361f, 0.13523398f, 
    -0.09459162f, 0.04096649f, 0.15442334f, 0.02521933f, -0.07252603f, -0.06683967f, 0.11720638f, -0.09713369f, 
    0.04040084f, -0.01760444f, -0.03085306f, 0.11162059f, -0.00450789f, 0.12558894f, -0.07488810f, 0.10802641f, 
    0.46398759f, 0.09466682f, 0.04601492f, -0.01576933f, 0.00649807f, -0.05798446f, 0.09865391f, 0.05590820f, 
    -0.01777520f, 0.02482352f, -0.06284634f, 0.03919150f, -0.18935229f, 0.05856520f, 0.04443172f, -0.03230851f, 
    -0.01744133f, -0.03265151f, 0.11081092f, -0.05429649f, 0.12300374f, -0.00119676f, 0.03221841f, 0.08132648f, 
    -0.08843018f, 0.02868358f, 0.04669944f, 0.04408958f, 0.07676272f, 0.00906351f, 0.02696073f, -0.00789674f, 
    0.00611687f, 0.15126733f, -0.04397029f, 0.01538093f, -0.11761431f, -0.17811160f, -0.01371679f, 0.08690032f, 
    -0.11911401f, -0.03645011f, -0.11023343f, -0.05604207f, 0.12944348f, -0.03051208f, -0.00639260f, 0.02872062f, 
    0.00468240f, -0.05745830f, -0.01605545f, -0.01271109f, 0.09878633f, -0.03794998f, 0.05004641f, 0.09835084f, 
    0.06456436f, -0.03482647f, 0.07237586f, -0.09431626f, 0.11220309f, -0.00626903f, -0.17405882f, -0.01196135f, 
    0.10069378f, 0.00843058f, -0.01743272f, 0.00149231f, 0.06243522f, 0.06916884f, 0.04354965f, 0.05263153f, 
    -0.09157363f, 0.15034986f, 0.13422035f, -0.05320267f, 0.01526298f, 0.00517646f, -0.03203825f, 0.02808836f, 
    -0.00463089f, -0.16869903f, 0.12951450f, 0.12421224f, 0.14882290f, -0.06564038f, 0.06826442f, -0.00349939f, 
    0.06790680f, -0.12140952f, 0.08393078f, -0.00389821f, -0.01196129f, 0.04262389f, -0.01959042f, -0.01351206f, 
    -0.01573722f, 0.08927448f, -0.04724191f, -0.18275255f, 0.10187332f, -0.12124830f, 0.02303440f, 0.01698905f, 
    -0.13164119f, 0.20704141f, -0.02853004f, 0.08190814f, 0.08742838f, 0.03065974f, -0.10782738f, 0.03017461f, 
    -0.03737205f, 0.08941761f, -0.06087323f, -0.14489973f, 0.01557668f, -0.01135971f, -0.03360699f, 0.07507558f, 
    0.17680643f, 0.05635565f, 0.06317235f, -0.12059046f, 0.13610187f, 0.03689111f, -0.10605071f, -0.00382342f, 
    0.01745852f, -0.06617281f, 0.10187039f, 0.06259356f, 0.13575681f, -0.08495643f, -0.30021524f, 0.00304867f, 
    0.18290678f, 0.00460985f, 0.08883463f, -0.02637901f, -0.08650620f, -0.05018734f, 0.05682489f, -0.13118568f, 
    -0.09734171f, -0.03079250f, 0.06835800f, -0.00617016f, 0.01517708f, 0.08526772f, -0.10110942f, 0.02073610f, 
    0.07945137f, -0.09364378f, -0.03501745f, 0.01246276f, 0.12265671f, -0.03502958f, -0.10038611f, 0.01953499f, 
    0.11475160f, 0.00041834f, -0.02066922f, 0.00951996f, 0.02278488f, -0.02241797f, 0.04666697f, -0.05104457f, 
    0.18646674f, 0.11340243f, 0.00620044f, 0.02604471f, -0.07042221f, 0.04844908f, -0.05977015f, 0.01433259f, 
    0.08086403f, -0.13289395f, 0.07924152f, 0.08923507f, -0.25120133f, -0.20644814f, -0.03602970f, -0.00137877f, 
    -0.03761304f, -0.04787268f, -0.02300811f, 0.12897427f, -0.10934418f, 0.01118840f, -0.02810768f, 0.04877359f, 
    0.30526912f, 0.06330939f, 0.07691596f, 0.14606458f, 0.02789425f, 0.05210698f, -0.00960917f, 0.06639456f, 
    0.00625294f, 0.08466119f, 0.05151710f, 0.10469288f, 0.23715915f, -0.08675043f, -0.11462423f, -0.20997661f, 
    0.07412747f, -0.02177991f, 0.04620319f, -0.01029757f, 0.08227441f, -0.03445516f, 0.17361587f, 0.12334801f, 
    0.13393210f, -0.02215401f, -0.12083226f, -0.04643537f, 0.11639284f, 0.04933195f, 0.14539321f, 0.07140751f, 
    -0.08839982f, -0.10041832f, 0.10957327f, -0.03799113f, 0.09997115f, -0.13521606f, -0.05719969f, 0.04023180f, 
    0.08287849f, -0.04065452f, 0.05602746f, 0.02957420f, 0.05708575f, 0.05745330f, -0.01083894f, -0.06168763f, 
    -0.15260915f, -0.12205373f, -0.00624822f, 0.02767900f, -0.12218389f, 0.04103820f, -0.02948092f, 0.08613009f, 
    0.08871041f, 0.05208249f, 0.00127102f, 0.02143019f, -0.01904018f, -0.00158627f, 0.06752172f, 0.01480948f, 
    0.06130332f, -0.04819335f, -0.06965491f, 0.09905165f, 0.04500921f, 0.05044061f, -0.07089474f, 0.03825816f, 
    0.00117153f, -0.08391289f, 0.04980697f, -0.07330362f, 0.17197180f, 0.02241933f, -0.00830296f, -0.02471066f, 
    0.00726425f, 0.11243258f, -0.02341369f, 0.09746386f, 0.07083365f, 0.12862992f, -0.06773496f, -0.00202625f, 
    0.14401577f, -0.10424288f, 0.05930861f, 0.11663769f, 0.10238813f, 0.06143162f, -0.11947285f, 0.16902794f, 
    0.00911066f, -0.00583288f, -0.01274642f, -0.03659045f, -0.03541818f, -0.06091637f, 0.07684624f, 0.01172316f, 
    -0.04363897f, -0.14907798f, -0.00190007f, 0.03730458f, 0.25234056f, 0.01140067f, 0.07442432f, 0.08524910f, 
    0.02342477f, -0.01024071f, 0.04514727f, 0.15051731f, 0.10572879f, -0.05894608f, 0.03878702f, 0.05062112f, 
    -0.17027049f, -0.29723087f, -0.09916016f, 0.03730303f, -0.03286563f, -0.02553788f, 0.05224001f, -0.01318009f, 
    0.03556782f, 0.03675622f, 0.04936031f, -0.02198613f, 0.10997929f, -0.06250896f, 0.08531531f, 0.09522581f, 
    0.10424433f, -0.01040793f, 0.02313317f, 0.02517633f, -0.07210246f, 0.10214052f, 0.01202462f, 0.08267259f, 
    0.26488912f, -0.15342891f, -0.08223023f, 0.09901577f, 0.07174551f, -0.08589181f, -0.07533834f, 0.04614493f, 
    -0.05881365f, 0.04762591f, -0.06047682f, -0.10587519f, 0.00870649f, 0.00110678f, -0.03311425f, 0.13873476f, 
    0.02589281f, -0.03932095f, -0.07400325f, -0.00614886f, 0.04553058f, 0.02480877f, -0.05360600f, 0.03332234f, 
    0.09764294f, -0.09500933f, 0.00091397f, 0.03445936f, -0.01369374f, -0.08457909f, -0.01104672f, -0.04279061f, 
    0.06483007f, -0.04225661f, 0.00304286f, -0.06678230f, -0.24736051f, -0.27915761f, -0.08661854f, 0.11991718f, 
    -0.03280497f, 0.04322764f, -0.03879041f, 0.05839479f, -0.05096801f, -0.03334919f, 0.04696919f, 0.11166316f, 
    0.03511161f, -0.15965179f, 0.01876481f, 0.10947746f, -0.00370090f, 0.15939374f, 0.03614790f, 0.02727161f, 
    0.05202101f, -0.00523883f, -0.04357765f, 0.10324833f, -0.03980577f, 0.06392999f, 0.14093761f, -0.12455900f, 
    0.00879523f, 0.10043091f, -0.00938499f, 0.05620120f, 0.03475839f, -0.05318756f, -0.05415948f, 0.06138330f, 
    0.13918723f, 0.05769479f, 0.06937452f, -0.02296204f, 0.03065048f, 0.04147920f, 0.01274686f, 0.09991758f, 
    -0.12359999f, 0.05498727f, 0.04309233f, -0.04195969f, -0.06841077f, -0.00672958f, -0.05625812f, 0.01488843f, 
    0.06045259f, -0.05521868f, 0.09952906f, 0.07693877f, 0.04364095f, 0.00150687f, -0.09123228f, 0.03949467f, 
    -0.39449379f, -0.16274984f, -0.07904673f, -0.00635190f, -0.00353167f, -0.03177515f, 0.06315017f, 0.07106984f, 
    -0.15132108f, 0.01432934f, -0.01399325f, 0.05111960f, -0.06527735f, 0.06381225f, -0.08540129f, 0.00940518f, 
    -0.00731054f, 0.02011004f, -0.05059167f, -0.09845141f, -0.01011320f, 0.00071110f, 0.01680088f, 0.10887487f, 
    0.16246709f, 0.09000868f, 0.00978317f, 0.08919441f, 0.04608179f, -0.12296642f, 0.06247254f, 0.02605772f, 
    0.02809525f, -0.06792229f, -0.00315526f, -0.03659229f, 0.09156404f, -0.05613222f, -0.00561171f, 0.00561817f, 
    -0.04839647f, -0.01053070f, 0.02619383f, -0.10101419f, -0.04616793f, 0.05063273f, 0.05791516f, -0.06783313f, 
    -0.04525345f, 0.03112898f, -0.22823049f, 0.03050708f, -0.12953512f, 0.00453410f, 0.09109343f, 0.00613977f, 
    0.04045764f, 0.03426770f, 0.05295323f, 0.01775198f, 0.30624747f, -0.12887497f, -0.02528517f, 0.01171178f, 
    0.11931934f, -0.06855164f, -0.01798563f, -0.01639263f, 0.06757003f, 0.04314329f, -0.04886457f, 0.03284431f, 
    0.05257949f, -0.01601223f, 0.06135523f, -0.10308021f, 0.05942514f, -0.04351753f, 0.06373430f, -0.05566056f, 
    -0.07166719f, 0.06806228f, -0.06620914f, 0.14426094f, 0.03338689f, 0.13750669f, 0.05245135f, -0.03697970f, 
    0.06334007f, 0.04384127f, 0.09967022f, -0.06032557f, 0.09151187f, -0.00208880f, 0.01102227f, 0.04574632f, 
    0.19904613f, -0.05408083f, 0.07268818f, -0.08763736f, 0.03249871f, 0.03281398f, 0.10862689f, 0.00394734f, 
    0.08873431f, -0.07305923f, 0.05636017f, 0.00684806f, 0.04815599f, 0.02382576f, -0.00010104f, -0.05986088f, 
    0.02451144f, 0.10982323f, 0.03221278f, 0.01030446f, 0.01487376f, 0.05844594f, 0.01996647f, 0.19720845f, 
    -0.09436451f, 0.06706331f, -0.02458726f, 0.11174862f, 0.13976613f, -0.05983899f, -0.06033586f, 0.00033653f, 
    0.04759393f, -0.03463205f, -0.03173481f, 0.07330380f, -0.53953302f, -0.15159182f, -0.08490805f, -0.05682710f, 
    -0.12366974f, 0.01594685f, -0.02948347f, 0.06123771f, -0.00875945f, 0.01638383f, 0.08583523f, 0.03250819f, 
    0.21840818f, 0.07900842f, -0.02736479f, 0.17452992f, 0.01199872f, -0.04404691f, 0.04126104f, -0.08347223f, 
    -0.05770242f, 0.04930106f, -0.10264967f, 0.08998356f, -0.26903260f, -0.20423624f, 0.05688265f, -0.07710952f, 
    0.01667222f, 0.02577627f, 0.06925917f, -0.01879608f, 0.04632801f, 0.04351581f, -0.05333059f, 0.02697431f, 
    -0.00048483f, 0.25864831f, 0.08025301f, 0.07677477f, 0.12305800f, -0.04097090f, 0.00609214f, 0.00451475f, 
    0.05674061f, -0.01787701f, -0.03803340f, 0.06288889f, 0.14642166f, -0.22504313f, -0.06497590f, 0.25164139f, 
    -0.05933456f, 0.08946232f, 0.04446594f, 0.05657382f, 0.08197249f, 0.04417975f, 0.12272611f, 0.02770223f, 
    -0.28398967f, -0.17837738f, -0.16401969f, -0.00573196f, 0.04273884f, -0.11033944f, -0.01189404f, -0.07803374f, 
    -0.18413152f, -0.07103679f, -0.13503575f, -0.17008038f, -0.15682496f, 0.04275018f, 0.02753300f, -0.02800417f, 
    0.06530429f, 0.09394795f, -0.03056401f, 0.06967084f, 0.08141282f, -0.06861328f, 0.05645638f, -0.06229490f, 
    -0.14854364f, 0.13915922f, 0.05135939f, -0.10296234f, -0.07198163f, 0.11835825f, 0.04276071f, -0.01405393f, 
    0.08753510f, 0.06672547f, 0.00276445f, 0.02293216f, 0.05650946f, 0.16326943f, 0.11172470f, -0.18134318f, 
    0.06516498f, 0.00996245f, 0.03662085f, 0.06394422f, 0.03631347f, 0.06646945f, 0.06444578f, -0.05951154f, 
    0.22480571f, 0.08887473f, -0.15265453f, 0.25117385f, -0.08108488f, 0.04074433f, 0.00900805f, -0.02996835f, 
    0.06222798f, 0.05659805f, 0.07880147f, 0.13607638f, -0.12794846f, 0.01247781f, -0.02017055f, 0.11675440f, 
    0.01533138f, 0.02036149f, -0.04533510f, 0.02771847f, 0.04276015f, -0.02812935f, -0.04455067f, 0.04397958f, 
    -0.07820410f, 0.01428962f, -0.07571100f, -0.10063486f, 0.06256718f, -0.02795651f, -0.00531056f, 0.07755255f, 
    0.03579273f, 0.10382903f, 0.04751593f, 0.04253671f, 0.00691483f, -0.07955386f, -0.00737116f, 0.10528692f, 
    0.01298694f, -0.07603566f, 0.02930371f, -0.00685358f, 0.09989627f, 0.01390162f, -0.00327203f, -0.07205966f, 
    -0.05754340f, -0.12978700f, -0.17497548f, -0.11644682f, 0.07192845f, 0.03840550f, 0.01749891f, -0.03564730f, 
    0.06287555f, 0.10618941f, 0.06088047f, 0.02691743f, 0.26495439f, 0.32015440f, -0.10773584f, -0.02237369f, 
    0.07192258f, 0.07228463f, -0.06789569f, -0.02523251f, 0.07344154f, 0.06953166f, -0.01018286f, -0.02961584f, 
    0.07375038f, -0.14014728f, 0.19642794f, 0.02425081f, -0.07234883f, -0.03821590f, -0.00333589f, 0.08583067f, 
    0.03470960f, 0.08124002f, -0.00774243f, -0.02686742f, 0.12573971f, -0.02435876f, 0.13328482f, -0.03274458f, 
    0.03223680f, 0.05816339f, 0.06474253f, -0.07396054f, 0.05718090f, -0.02622107f, 0.07151223f, -0.07037878f, 
    -0.11321177f, 0.02727170f, -0.10446613f, -0.05213253f, 0.05703995f, 0.08796411f, 0.01939781f, 0.00697344f, 
    0.04094471f, 0.09579426f, 0.02778979f, 0.09903210f, 0.13685428f, -0.10747840f, -0.00338749f, 0.01502987f, 
    0.02975480f, 0.14939591f, 0.00918828f, 0.10505711f, -0.02917919f, 0.03397011f, 0.04657301f, 0.09794920f, 
    0.12646471f, 0.20766990f, 0.01636070f, 0.04283336f, 0.01042150f, 0.08407334f, -0.00798653f, -0.06166239f, 
    0.01784456f, 0.03850087f, 0.08797015f, 0.03773683f, 0.30008781f, 0.02621223f, 0.03566870f, 0.09108780f, 
    0.03902739f, 0.06242496f, 0.06128377f, 0.09768983f, 0.08048768f, 0.07367446f, -0.00667752f, 0.08986112f, 
    -0.10901219f, 0.06303791f, -0.02203632f, -0.16752373f, 0.04420644f, 0.00854113f, -0.03961609f, 0.04146994f, 
    -0.00989914f, 0.02237738f, 0.04379306f, -0.05178919f, 0.13577579f, -0.00301157f, 0.02923502f, 0.06797777f, 
    0.03852983f, -0.02816375f, -0.05726100f, 0.02460489f, -0.04819475f, -0.04103073f, 0.00330419f, 0.03798490f, 
    0.06335645f, 0.01521151f, 0.06596492f, -0.00534312f, 0.03253983f, -0.02221778f, 0.01973010f, 0.04335591f, 
    -0.09082226f, 0.03432003f, 0.03781994f, 0.13090318f, -0.15752663f, 0.03873349f, 0.01734950f, 0.07808017f, 
    0.00454030f, 0.06653846f, 0.03607159f, -0.01312757f, 0.11942447f, 0.01352340f, 0.04431381f, -0.00195492f, 
    -0.05065979f, -0.02198820f, 0.17320783f, -0.02175456f, -0.01474797f, 0.00415408f, 0.03799791f, 0.02673492f, 
    0.04745544f, -0.06181690f, 0.05844027f, 0.03725499f, -0.15499236f, -0.02531682f, -0.09984834f, 0.08835733f, 
    0.04911552f, -0.06602018f, 0.04103821f, 0.01432625f, -0.01915200f, 0.04853765f, 0.09847237f, -0.02994929f, 
    -0.03105397f, -0.12344857f, -0.05151339f, 0.13222012f, -0.05974127f, -0.02113417f, 0.04908615f, 0.03869989f, 
    -0.00258073f, 0.07508224f, -0.00337912f, -0.00173988f, -0.16993122f, 0.08779690f, 0.03520302f, 0.14180127f, 
    -0.02233609f, 0.04433659f, 0.06328070f, 0.02749757f, -0.08400389f, 0.00407726f, -0.02987640f, 0.08481325f, 
    0.12016029f, 0.00421593f, -0.12620313f, 0.19547534f, -0.06634600f, 0.00254896f, 0.10871242f, -0.00128985f, 
    0.00998308f, 0.04696735f, 0.02852228f, 0.02314985f, -0.18519762f, -0.00020300f, 0.00527398f, 0.18111992f, 
    0.02274493f, 0.08950491f, 0.18145354f, -0.05212805f, -0.07537143f, 0.00341996f, 0.03867104f, -0.02587209f, 
    -0.00140551f, -0.06672641f, -0.23256716f, -0.07896177f, 0.12863927f, 0.02195186f, 0.04680455f, 0.00567962f, 
    -0.01395593f, 0.06027929f, -0.03492980f, 0.02418028f, -0.25033507f, 0.21957582f, 0.02967763f, -0.02656131f, 
    0.00824038f, 0.09707720f, -0.13278893f, 0.12872703f, 0.05213169f, 0.01919295f, 0.01480682f, -0.02220142f, 
    -0.15261975f, -0.05248892f, -0.23825435f, 0.03245410f, 0.05954425f, 0.03490938f, -0.02104891f, -0.00939943f, 
    0.00001522f, 0.05649724f, -0.03178752f, -0.03170808f, -0.03507224f, 0.06470172f, -0.05141338f, 0.14370894f, 
    0.08436257f, 0.04198299f, -0.01931516f, 0.05514836f, -0.02044188f, 0.01047759f, 0.07395810f, -0.04121381f, 
    -0.16526671f, 0.21197946f, 0.01534008f, 0.09985529f, 0.11217725f, 0.02234467f, 0.04951422f, 0.08345781f, 
    0.02365139f, 0.06904225f, 0.01351229f, 0.10742179f, 0.17718744f, 0.06378802f, 0.12349226f, 0.10715090f, 
    0.02918739f, -0.00461539f, 0.06434806f, 0.02330046f, 0.00028922f, -0.05686965f, 0.03097234f, 0.16371542f, 
    0.17871527f, 0.19503243f, 0.09746957f, -0.03835564f, -0.02194148f, 0.09510781f, 0.11629748f, 0.03769712f, 
    0.07991434f, 0.03337073f, 0.03232077f, 0.04700040f, -0.03201707f, -0.15120983f, -0.14778507f, -0.04334134f, 
    -0.01828506f, 0.10523515f, 0.10261758f, 0.02065039f, -0.03821395f, -0.06417929f, 0.08806002f, -0.05168596f, 
    0.02728552f, -0.15015779f, 0.15741986f, -0.05252770f, 0.00794597f, 0.12168700f, 0.01333822f, 0.00856570f, 
    0.07308053f, -0.03266025f, 0.18371280f, -0.00179152f, 0.08478753f, 0.03916468f, -0.11989454f, 0.26337460f, 
    0.03470759f, 0.00627915f, -0.10641126f, -0.01116999f, 0.05594248f, 0.07529076f, 0.03015427f, -0.02420473f, 
    0.04575204f, 0.15141423f, 0.04047842f, 0.04553553f, -0.08323221f, 0.08779414f, 0.03845864f, -0.00408892f, 
    0.00822396f, 0.02832565f, -0.01880728f, -0.04510373f, 0.07770794f, -0.05222602f, -0.28444558f, -0.01804347f, 
    0.07098851f, 0.07413277f, 0.01272837f, -0.05793768f, 0.04886030f, 0.08715071f, 0.01155725f, 0.05479648f, 
    -0.17880259f, 0.17155217f, 0.00570429f, 0.11558030f, 0.03834481f, -0.04617968f, 0.10537443f, 0.03829514f, 
    0.00121351f, -0.03125298f, -0.02967183f, 0.00894355f, 0.02664976f, 0.13509305f, -0.05094049f, 0.10613725f, 
    0.07085662f, 0.02304107f, 0.06498419f, 0.03698527f, 0.07091909f, 0.06758893f, 0.13427608f, 0.01512695f, 
    0.01951090f, 0.16162041f, 0.17699145f, 0.26886386f, 0.01692592f, 0.05514587f, 0.06333283f, 0.03016394f, 
    -0.00410430f, -0.04215972f, 0.23353304f, 0.15167341f, -0.04761973f, 0.15541029f, 0.04573915f, 0.12247220f, 
    -0.07571423f, 0.07530025f, -0.01714525f, 0.02771930f, 0.08301923f, 0.12716436f, 0.01375493f, 0.01552452f, 
    0.19177857f, 0.12899965f, 0.01532062f, 0.11104557f, -0.01583914f, 0.06489383f, -0.03000369f, -0.01222268f, 
    -0.12210657f, -0.00720289f, -0.01001775f, -0.03597489f, 0.45917398f, 0.26310095f, 0.09772690f, 0.15684399f, 
    0.01465436f, 0.06513532f, 0.01801564f, 0.04527655f, 0.02131163f, -0.07752682f, 0.06289198f, 0.00179306f, 
    0.16801961f, 0.27796909f, -0.04735475f, 0.12726459f, 0.14999145f, -0.07282776f, -0.07378233f, -0.09420243f, 
    0.02865638f, -0.02489103f, -0.01048347f, -0.02607013f, 0.00682560f, -0.06087260f, -0.03799254f, -0.17521678f, 
    0.01528712f, 0.01066451f, 0.06302164f, 0.03459484f, 0.00428020f, 0.07262316f, 0.10723244f, -0.01977076f, 
    0.02532335f, 0.03898079f, -0.00647664f, 0.01700971f, -0.12196884f, -0.04148804f, 0.09381631f, -0.02011165f, 
    -0.03081878f, -0.06399633f, -0.03246765f, -0.01218356f, 0.04778786f, 0.06996750f, 0.08814381f, -0.08915100f, 
    0.03821958f, 0.01298907f, -0.01571116f, 0.01191639f, -0.07006989f, -0.04485157f, 0.00796666f, -0.07012899f, 
    -0.03312857f, 0.09971645f, 0.08240329f, -0.01109196f, 0.05288766f, 0.19772980f, -0.01496550f, -0.03709560f, 
    0.10127365f, -0.09380920f, 0.02649067f, -0.02242380f, 0.19797449f, 0.15836041f, 0.12823337f, -0.01002321f, 
    0.01221071f, 0.00810697f, 0.00051566f, -0.07658249f, 0.00752445f, 0.02697704f, 0.01793477f, -0.06945928f, 
    -0.05030733f, 0.20986183f, -0.20048647f, 0.07439734f, 0.01380464f, -0.07299014f, 0.07255986f, -0.12272214f, 
    0.07895824f, -0.02872809f, 0.11649138f, 0.02488870f, -0.08036046f, -0.06980827f, -0.09799553f, 0.06994778f, 
    0.03787288f, 0.01119244f, 0.06259518f, 0.09382288f, 0.05589864f, 0.10858788f, 0.02920233f, 0.05734972f, 
    0.05655821f, 0.22601579f, 0.29094535f, 0.10775352f, -0.03809287f, -0.08478087f, 0.03426226f, 0.04872986f, 
    -0.05783494f, 0.00143457f, -0.03436974f, 0.02559736f, 0.07137706f, 0.05548535f, 0.00950320f, 0.17539741f, 
    0.03397570f, 0.00541008f, 0.02918210f, -0.05442411f, -0.08245868f, -0.05548047f, 0.07093991f, -0.09770092f, 
    0.10183346f, 0.10930920f, -0.12308665f, 0.08265294f, -0.06529201f, 0.11154652f, 0.00126888f, 0.10231934f, 
    0.18848845f, 0.06812694f, -0.12752204f, 0.03474716f, -0.05326286f, -0.05250744f, -0.14672849f, -0.10095177f, 
    -0.08668755f, -0.06286024f, 0.01479409f, -0.01523793f, 0.05292033f, 0.06971822f, 0.06404679f, 0.06901147f, 
    0.03255581f, -0.03879537f, -0.19026558f, 0.01053459f, -0.04711450f, 0.04562613f, -0.05581621f, 0.00902211f, 
    0.01533168f, 0.03700437f, 0.01138199f, 0.13391735f, -0.15881760f, -0.09783585f, 0.15791048f, 0.22927502f, 
    0.08158974f, -0.01347858f, 0.00016296f, 0.05837164f, 0.09542157f, -0.02193974f, 0.03105839f, 0.04070796f, 
    0.05954620f, 0.04255794f, -0.16983707f, 0.05944823f, -0.01702716f, 0.06602068f, 0.02358239f, -0.09267393f, 
    0.04421024f, 0.03915075f, -0.02482414f, 0.04537131f, -0.03731114f, 0.27605402f, 0.10392773f, 0.08063788f, 
    0.01064966f, 0.02495146f, 0.04391993f, 0.01504268f, 0.00120180f, -0.01308890f, -0.09405693f, -0.05630855f, 
    0.02280884f, -0.08795605f, -0.22759055f, 0.20037846f, -0.00986728f, -0.05267921f, 0.04496894f, 0.02055509f, 
    0.08654919f, 0.02433597f, -0.01346152f, -0.05849429f, 0.10598708f, 0.10259423f, -0.05213773f, 0.09768309f, 
    0.10892455f, 0.02307303f, -0.02487310f, 0.03742729f, 0.06699935f, 0.00006155f, 0.11546227f, 0.02255812f, 
    -0.08076151f, -0.02133478f, -0.06417114f, -0.01312863f, -0.02798140f, -0.01800297f, 0.02785064f, -0.04450820f, 
    0.06155707f, 0.02183898f, -0.01871047f, -0.04819049f, 0.31012392f, -0.03935451f, 0.07828954f, 0.26061037f, 
    0.02685234f, -0.02622418f, -0.05394620f, 0.05252935f, 0.00869965f, -0.04277536f, -0.12113396f, 0.02226200f, 
    -0.03083301f, 0.19384898f, 0.02315442f, 0.12458945f, -0.00088943f, 0.06472231f, 0.05071817f, 0.10549568f, 
    -0.03733046f, -0.09168959f, 0.06527847f, 0.09065416f, 0.07278179f, -0.09398232f, -0.04380243f, -0.24101095f, 
    -0.00548900f, -0.01980438f, -0.10233779f, 0.02001644f, 0.09119307f, 0.08357492f, 0.01328426f, -0.00108036f, 
    0.07474909f, -0.13791516f, -0.04333558f, 0.17774859f, -0.03549766f, -0.04382621f, 0.01356554f, 0.01983480f, 
    -0.02723707f, -0.04641261f, -0.05942734f, -0.10095584f, 0.08368636f, -0.11145607f, 0.05939685f, 0.11171366f, 
    -0.00046204f, 0.02352089f, -0.09699366f, 0.15706243f, -0.15243734f, 0.02455496f, -0.04441229f, 0.08072522f, 
    -0.22681196f, -0.03680441f, -0.06171757f, -0.13129093f, 0.06781336f, 0.03599450f, 0.06858033f, 0.05507097f, 
    0.05166296f, -0.03368831f, -0.03865460f, -0.17589246f, -0.01164567f, -0.00944552f, -0.01351702f, 0.06508243f, 
    0.06035711f, 0.02374919f, 0.06676996f, 0.04516251f, -0.02168688f, 0.04349812f, 0.02513622f, -0.06137413f, 
    0.11317483f, 0.22582549f, -0.02716983f, 0.04452721f, -0.05203899f, -0.03005858f, -0.01787356f, -0.02232653f, 
    -0.02810057f, -0.03933487f, -0.12028529f, -0.14094836f, -0.02129991f, -0.00858866f, 0.09373872f, -0.09685554f, 
    0.08329595f, -0.02219840f, 0.03641764f, 0.04996841f, 0.02189730f, 0.05838829f, 0.04841500f, 0.09324993f, 
    0.00363108f, -0.04800670f, 0.08226603f, 0.07024245f, -0.00006806f, 0.00337938f, 0.09663990f, -0.00562490f, 
    0.01868493f, -0.16979229f, 0.12387501f, -0.01530997f, -0.12197386f, -0.07270427f, 0.00627933f, 0.09782378f, 
    -0.02919384f, 0.07181738f, -0.00585803f, 0.07308795f, -0.12615666f, -0.04792738f, 0.04588068f, -0.02759928f, 
    -0.17233285f, 0.04099000f, -0.00295513f, -0.06847815f, 0.04741438f, 0.00135767f, -0.01532790f, 0.04068308f, 
    -0.09483966f, -0.07065138f, 0.01805362f, 0.09800151f, -0.21565844f, -0.17675069f, 0.02268359f, -0.03908798f, 
    0.02125197f, -0.07939625f, -0.06302792f, 0.16037124f, 0.06319389f, 0.19205433f, -0.03403729f, 0.20598525f, 
    -0.06919397f, 0.07847482f, 0.00432434f, -0.00552317f, 0.00764929f, -0.01099375f, 0.07711872f, -0.02215705f, 
    -0.04994580f, 0.01507202f, -0.17428108f, 0.02471886f, -0.17580912f, -0.02415504f, 0.02823101f, 0.04702871f, 
    -0.06980725f, -0.02406871f, 0.11572102f, -0.08196641f, 0.01380278f, -0.09896177f, -0.18990059f, -0.06661616f, 
    0.16241269f, 0.04652929f, 0.19953445f, 0.03811505f, 0.11141595f, 0.11449142f, -0.00159887f, 0.11099731f, 
    -0.00593364f, 0.04402131f, -0.06367945f, -0.05424782f, -0.13642533f, -0.02618190f, 0.02776530f, 0.03731931f, 
    -0.02019268f, -0.08884414f, -0.08015345f, -0.04895591f, -0.09320462f, -0.09519047f, -0.11113244f, -0.00852678f, 
    0.47147870f, 0.01660405f, -0.04507897f, 0.11285629f, -0.06935034f, -0.00426501f, 0.00331082f, 0.08048872f, 
    0.08379926f, 0.03450998f, 0.07322828f, -0.04572456f, 0.03466108f, 0.13708912f, -0.04245229f, -0.14565296f, 
    0.06084539f, -0.01058270f, 0.05006606f, 0.00531018f, 0.06680737f, 0.02048695f, 0.11470201f, 0.12013866f, 
    -0.02393259f, -0.02264366f, 0.07462154f, -0.15666424f, 0.04739897f, 0.12962180f, 0.04062910f, 0.06476478f, 
    -0.04021435f, -0.18426020f, 0.08899904f, 0.09106118f, 0.23074314f, -0.02263658f, -0.05898217f, -0.01430935f, 
    0.03548486f, -0.15371265f, 0.02986875f, -0.11669975f, -0.10233346f, -0.03756116f, -0.05602875f, -0.03561816f, 
    -0.13659286f, -0.00872499f, -0.16442758f, -0.10430218f, -0.03082442f, -0.06733262f, 0.02099396f, 0.10726050f, 
    -0.10808950f, 0.17745206f, -0.09130064f, 0.07564427f, -0.04100572f, 0.09077041f, -0.04954511f, -0.06228355f, 
    0.00750108f, -0.06747534f, -0.12672797f, -0.15287115f, 0.03045148f, -0.06901141f, -0.02150504f, 0.01883755f, 
    -0.04075789f, 0.05531597f, 0.06988730f, -0.04872814f, 0.09200184f, 0.05797233f, -0.11406337f, -0.03378056f, 
    0.00804601f, -0.10567884f, 0.13564108f, -0.06225396f, 0.18811056f, 0.04145187f, -0.02491932f, 0.09732523f, 
    -0.00831217f, -0.02570389f, 0.00021391f, 0.01240233f, -0.01742451f, -0.07682171f, 0.10874611f, -0.06867597f, 
    -0.24332620f, -0.08199844f, 0.01966231f, 0.07257440f, 0.01402124f, 0.12850873f, -0.12141777f, 0.02893108f, 
    0.02423478f, -0.06356720f, 0.11610654f, -0.02114425f, 0.28854024f, 0.02943130f, 0.07645880f, 0.17905612f, 
    -0.04812096f, -0.06492192f, -0.10318214f, 0.05903276f, -0.02706437f, 0.06971929f, 0.00915935f, -0.01526715f, 
    -0.40485933f, -0.03727760f, 0.20169155f, -0.01202157f, 0.04416803f, 0.09403942f, -0.01098722f, -0.06099503f, 
    0.13990186f, -0.04524409f, 0.04989159f, 0.05618855f, -0.08579889f, -0.02161058f, -0.22860080f, 0.09304927f, 
    0.04183797f, -0.03658776f, 0.03257408f, 0.02449469f, 0.05772492f, 0.08189558f, 0.02499874f, -0.06716313f, 
    -0.09419135f, -0.03469404f, 0.12104644f, 0.14842860f, -0.01930389f, 0.05700510f, 0.08841404f, -0.01587986f, 
    0.03762062f, 0.04651878f, 0.01703770f, 0.06809504f, 0.08137142f, -0.01207554f, -0.04833938f, -0.10828721f, 
    0.02882062f, 0.00941248f, 0.03121727f, -0.02447134f, -0.04311495f, 0.03496885f, 0.10335543f, 0.06567220f, 
    0.36403108f, -0.02200499f, -0.03305578f, -0.03545485f, 0.06297299f, 0.06959157f, 0.07324100f, 0.06577725f, 
    -0.04782701f, -0.12933046f, 0.07926796f, -0.04419794f, 0.04364600f, -0.00429753f, -0.02788899f, -0.09395301f, 
    0.02943817f, -0.09979172f, 0.09880495f, -0.04809698f, -0.05570015f, 0.08183657f, -0.07045202f, -0.12575877f, 
    -0.16521661f, 0.01811926f, -0.28033799f, -0.05588819f, 0.00165901f, -0.03369448f, -0.01861866f, -0.08128907f, 
    -0.04408901f, -0.02988893f, -0.08770167f, -0.10929436f, 0.10704787f, -0.00785342f, 0.02115038f, -0.00984849f, 
    0.03393260f, -0.19450893f, -0.04852400f, 0.01193107f, 0.04507633f, 0.12915884f, -0.16102958f, 0.08407199f, 
    -0.21610607f, 0.07464694f, 0.22580272f, 0.03295450f, 0.14675975f, 0.00028542f, -0.11529878f, 0.03241113f, 
    -0.04403604f, 0.22731401f, -0.00384763f, 0.13421175f, 0.07129527f, 0.10691071f, 0.03397758f, -0.18774921f, 
    0.16072312f, 0.03795153f, 0.08122887f, 0.00447939f, 0.02820632f, 0.01001826f, -0.07783656f, 0.08859114f, 
    -0.00930813f, -0.06302133f, 0.24976386f, 0.25037313f, -0.14347677f, -0.05769716f, 0.08219764f, -0.02904599f, 
    -0.10754712f, -0.18030281f, -0.00721600f, 0.13787536f, -0.44666472f, 0.12007351f, 0.25992408f, 0.10942495f, 
    0.03522983f, 0.00670141f, 0.04969894f, 0.06846974f, 0.01421500f, 0.01230885f, 0.09549844f, 0.08943234f, 
    0.07580207f, -0.02791048f, -0.03127379f, 0.19838870f, 0.01243977f, -0.03604614f, 0.03693145f, -0.14273223f, 
    0.11335640f, 0.12806527f, 0.01057289f, -0.00510711f, 0.15979715f, -0.02533876f, 0.15719305f, -0.10561044f, 
    0.11520357f, 0.01220968f, 0.09991676f, 0.03799180f, -0.14354840f, 0.11599100f, -0.11349086f, 0.07963120f, 
    0.30672240f, -0.03111492f, -0.22025394f, -0.16264735f, 0.01903902f, -0.09090712f, 0.03984128f, 0.03599705f, 
    -0.01313725f, 0.09311236f, -0.23334680f, 0.03285328f, 0.09780855f, 0.05048564f, 0.06216814f, 0.23671386f, 
    -0.06951430f, 0.07433937f, 0.03112774f, 0.05165651f, 0.11127246f, -0.09360025f, -0.00490843f, -0.04880108f, 
    -0.24796154f, -0.05176461f, 0.04101030f, -0.13153288f, 0.00125348f, 0.03205288f, 0.04561724f, 0.01938635f, 
    0.08673738f, 0.05420922f, -0.00400618f, -0.07530748f, -0.05009188f, 0.02840414f, -0.25124115f, -0.12821548f, 
    0.12716559f, 0.00151260f, -0.06397801f, 0.02634747f, 0.07614567f, 0.11003117f, -0.00291784f, 0.07972440f, 
    -0.01087978f, -0.00150156f, -0.04893446f, 0.03040841f, 0.07964595f, 0.12799573f, 0.11438348f, 0.09309923f, 
    0.04552382f, 0.09176493f, -0.00050503f, 0.17034274f, 0.04865511f, -0.05750581f, 0.07666630f, -0.01535325f, 
    0.00254573f, 0.08361850f, -0.01284373f, -0.04979222f, -0.05997965f, -0.06204495f, -0.09971964f, -0.07167348f, 
    -0.02751919f, 0.15912966f, 0.00402311f, 0.04734256f, 0.04758933f, 0.06769409f, -0.04415398f, 0.03652518f, 
    0.09164100f, 0.07264685f, 0.03966174f, 0.11293515f, 0.25546691f, 0.04195445f, -0.11661003f, 0.08242218f, 
    -0.12157623f, -0.07690189f, 0.05206038f, 0.11825223f, 0.11559873f, 0.10311877f, -0.05549816f, -0.02961013f, 
    0.06727666f, -0.15419403f, 0.14182985f, 0.15605618f, 0.04999051f, -0.01032102f, 0.00579791f, 0.16241711f, 
    -0.19380999f, 0.04244547f, 0.01962891f, 0.07987481f, 0.01326123f, 0.00071581f, 0.16480039f, 0.11296789f, 
    -0.00021615f, 0.01460991f, 0.01428743f, 0.04815714f, 0.00786257f, 0.03915289f, 0.09362798f, 0.10150911f, 
    -0.15023464f, -0.14956769f, 0.11108416f, 0.10933249f, -0.01940639f, 0.02116340f, 0.01209178f, 0.07516185f, 
    0.09557401f, -0.16654287f, 0.11314490f, -0.07990140f, -0.19267380f, -0.08944912f, -0.01185887f, 0.01031604f, 
    0.09705638f, 0.10591640f, -0.03818624f, -0.18097314f, -0.09066906f, -0.08602364f, 0.00267160f, -0.08645521f, 
    -0.00482347f, 0.10828593f, -0.32295838f, -0.21620448f, -0.03566605f, -0.03658929f, 0.16198865f, -0.10970201f, 
    0.10216985f, 0.04383247f, 0.00260745f, 0.01919674f, 0.06422553f, -0.07069128f, -0.05505355f, -0.08073054f, 
    0.04818727f, 0.02042176f, 0.01107259f, 0.04827311f, 0.02165809f, 0.04927269f, -0.04598162f, 0.09424330f, 
    -0.02533985f, -0.09636969f, 0.09555521f, -0.01427764f, 0.13698387f, -0.03134221f, 0.15481196f, -0.09955877f, 
    -0.02642185f, 0.03016037f, 0.02992055f, 0.07933151f, 0.11505269f, -0.06044665f, 0.07639182f, 0.03167703f, 
    0.03746316f, 0.08977578f, 0.07609461f, -0.06525448f, -0.00012495f, -0.05071063f, -0.04270898f, 0.11103108f, 
    -0.05359295f, -0.06020249f, 0.15319890f, 0.02731898f, 0.06097957f, 0.06698594f, 0.01403616f, -0.02834750f, 
    0.13413267f, -0.02553878f, 0.05923386f, -0.00478644f, -0.10032834f, 0.18912801f, -0.04792140f, 0.07424348f, 
    0.03853099f, 0.09889011f, 0.08072337f, -0.02916877f, 0.09715968f, 0.07645357f, -0.02014846f, 0.14842044f, 
    -0.25818288f, -0.09245216f, -0.05607817f, 0.13741003f, 0.05230009f, -0.03286360f, 0.02169036f, 0.00720114f, 
    0.01281806f, -0.07123886f, 0.00430717f, 0.02034320f, -0.12790482f, 0.12513788f, -0.21854912f, 0.06628143f, 
    -0.04102566f, -0.06607338f, 0.02766059f, 0.03104050f, -0.04619426f, 0.01864307f, 0.07626411f, -0.02603150f, 
    -0.10126582f, 0.03637199f, 0.14673154f, 0.05002742f, 0.08372957f, -0.02785851f, 0.02923906f, -0.10408091f, 
    0.00634534f, 0.10439330f, 0.00129678f, 0.16570550f, 0.04357463f, 0.10933971f, 0.06815789f, 0.10239462f, 
    -0.08725967f, -0.03633925f, 0.07760876f, -0.08032340f, -0.01845208f, 0.04381508f, -0.16882424f, 0.04177023f, 
    0.18429206f, -0.06533032f, 0.08901763f, 0.04314495f, 0.02917363f, -0.03717138f, 0.01685206f, -0.03689022f, 
    0.08999934f, 0.03713262f, -0.00437132f, 0.16102205f, -0.07227702f, 0.16679735f, -0.10399103f, -0.09023365f, 
    0.14802329f, 0.04197627f, 0.08994529f, 0.05034350f, 0.04026880f, 0.13370237f, 0.09426428f, -0.07522456f, 
    0.12981129f, -0.01761959f, -0.10064703f, 0.09724386f, -0.04622218f, -0.13051622f, -0.08216192f, -0.17332518f, 
    0.01856928f, 0.06406082f, -0.09878209f, -0.05041477f, 0.14090243f, 0.05128565f, 0.04561787f, 0.04128706f, 
    0.06054824f, 0.09585682f, 0.05108838f, 0.00687034f, -0.01264539f, -0.03755875f, 0.07224736f, -0.00864904f, 
    -0.03068240f, -0.09233121f, 0.03435843f, -0.05513882f, -0.10974808f, 0.07345448f, 0.08218929f, -0.05243182f, 
    -0.09157956f, 0.07779851f, 0.03925005f, 0.11900567f, 0.18025696f, -0.01619130f, 0.17116010f, -0.13785394f, 
    0.02852057f, 0.05635981f, 0.10081386f, 0.05790011f, 0.07881071f, 0.06794223f, 0.20514114f, -0.01181191f, 
    0.08745593f, -0.07468635f, -0.04641768f, 0.17078990f, 0.01243070f, 0.04794433f, -0.01962988f, -0.12937936f, 
    0.01489051f, 0.01868950f, 0.06338266f, 0.10293492f, 0.05387137f, 0.16908993f, 0.10693718f, 0.26945463f, 
    -0.04129602f, 0.08027699f, 0.02314173f, 0.04780516f, 0.04665739f, 0.08855917f, 0.05511510f, -0.04033311f, 
    0.16688405f, -0.32547337f, -0.16715738f, 0.01680804f, -0.09176374f, -0.04769015f, -0.00370357f, 0.08637477f, 
    -0.00657176f, 0.15313129f, 0.07626186f, 0.09302235f, 0.21344933f, 0.00783966f, -0.17755941f, 0.22851962f, 
    0.07081661f, 0.07290978f, 0.08722764f, -0.00419096f, 0.10282607f, -0.09836400f, -0.02706614f, -0.02665387f, 
    0.24317925f, 0.24924472f, 0.01173649f, 0.11629168f, 0.06694579f, -0.02093059f, -0.01306256f, -0.10394791f, 
    0.12053953f, 0.23606905f, 0.09535655f, -0.02258479f, -0.17282219f, 0.06651053f, 0.10878942f, 0.02580612f, 
    0.08730130f, 0.03524132f, -0.03051631f, 0.01594437f, 0.12695393f, 0.01620159f, -0.06158064f, -0.04845630f, 
    0.31521180f, -0.18505172f, 0.04920723f, -0.11336756f, -0.04827574f, -0.07728230f, -0.02632645f, 0.08639062f, 
    0.02779739f, 0.14921291f, -0.11905152f, -0.03310678f, -0.07668860f, 0.02323727f, 0.12341347f, -0.03790078f, 
    0.02986278f, 0.06012122f, -0.02722172f, -0.08619626f, 0.00294783f, -0.10564077f, 0.07757033f, 0.01188901f, 
    0.14453548f, 0.29896080f, 0.00146551f, 0.28562638f, 0.01382006f, 0.07798335f, -0.02412120f, 0.04226241f, 
    -0.00791802f, 0.00704998f, 0.07974392f, 0.09348647f, 0.13416949f, 0.06857987f, 0.11641381f, -0.10119049f, 
    0.12985273f, -0.02113664f, -0.03458433f, 0.03077788f, -0.02276854f, 0.01426012f, 0.06525087f, 0.06923152f, 
    -0.05701242f, 0.10233228f, 0.05189905f, -0.15732153f, -0.00105897f, 0.07107303f, -0.04874322f, -0.12914175f, 
    0.07405491f, -0.04253523f, 0.14744683f, -0.14157747f, 0.04179367f, -0.03467335f, -0.17425276f, -0.22459894f, 
    -0.09995206f, -0.01607556f, 0.01329272f, 0.01197234f, 0.10854213f, 0.08771781f, 0.12455238f, 0.10007688f, 
    0.09453624f, -0.12242331f, 0.04235282f, 0.04089485f, 0.05110624f, -0.02748220f, 0.02792064f, -0.01023239f, 
    -0.03343198f, -0.00611470f, -0.01223636f, 0.17465715f, -0.12629071f, -0.09926874f, -0.16762789f, -0.06801122f, 
    0.05877151f, -0.04226929f, -0.08043754f, -0.14312004f, -0.08363840f, -0.01711603f, -0.15269713f, 0.04160182f, 
    -0.08462355f, 0.08565638f, 0.01029384f, -0.09511175f, 0.00210714f, -0.01308903f, -0.05506388f, 0.04482936f, 
    0.01689221f, 0.09120163f, 0.01969249f, -0.08453950f, -0.28101948f, 0.21069860f, -0.10704697f, 0.15962699f, 
    -0.00896458f, 0.13690333f, 0.10572140f, 0.11567350f, 0.02140407f, -0.07592886f, 0.04036623f, -0.02315558f, 
    0.09260027f, -0.12793331f, 0.15993999f, -0.10129055f, -0.04620594f, -0.00476069f, -0.02477142f, 0.05170085f, 
    -0.20626917f, -0.07072487f, -0.07270598f, -0.02204938f, -0.03938369f, 0.11747328f, -0.09770233f, 0.08491724f, 
    0.13000186f, 0.06782497f, 0.06494258f, 0.09001255f, 0.06423437f, 0.11022156f, 0.08990927f, 0.08054239f, 
    0.31245154f, 0.15424132f, 0.09484877f, -0.02247610f, 0.03478989f, 0.00680951f, -0.09817804f, -0.03492692f, 
    0.03148663f, 0.03949271f, -0.20036386f, -0.07633899f, 0.14519641f, -0.34157169f, 0.00604001f, -0.07748558f, 
    0.05340043f, 0.11652962f, 0.03893819f, -0.03444744f, 0.04552848f, -0.02244027f, 0.04740350f, 0.09998339f, 
    -0.23049653f, 0.24940298f, 0.00412113f, 0.12435786f, -0.07597132f, 0.00397733f, 0.00572707f, 0.02307292f, 
    0.02674638f, 0.06739651f, -0.08267298f, 0.09812108f, -0.18110277f, -0.22199512f, -0.10293212f, -0.00785812f, 
    0.00995973f, 0.02656627f, 0.00247080f, -0.03680102f, -0.10001963f, -0.04073634f, -0.02138930f, 0.13708378f, 
    -0.15154418f, 0.28698185f, 0.03840214f, 0.06695890f, 0.01420949f, 0.02949679f, 0.04653668f, 0.06306979f, 
    0.01062054f, 0.10360419f, 0.05299105f, -0.06410021f, 0.11059657f, -0.06996387f, 0.04818052f, 0.12150077f, 
    -0.01133807f, 0.04559873f, -0.02237587f, 0.15065551f, -0.07019968f, -0.07292728f, -0.04470960f, 0.07790968f, 
    0.00639515f, 0.30220672f, -0.01435408f, 0.15326203f, 0.01851121f, 0.05911700f, -0.01868227f, 0.05405998f, 
    -0.06075078f, 0.08738346f, 0.00310365f, 0.08565661f, 0.27301738f, 0.09319191f, -0.01616675f, -0.01331404f, 
    0.13132362f, 0.03786528f, 0.04039370f, -0.01241200f, 0.00728059f, -0.01116896f, -0.01724102f, 0.01680660f, 
    0.12776205f, -0.00880323f, -0.03932584f, -0.12414040f, -0.04241872f, 0.01173457f, -0.06427214f, -0.08416043f, 
    -0.00298248f, 0.08591788f, -0.06640555f, 0.01031359f, 0.05376296f, -0.02758425f, -0.19817254f, 0.04441346f, 
    0.04107046f, 0.03523542f, -0.01084936f, -0.10574169f, 0.11389424f, -0.00207881f, 0.18900624f, 0.12603930f, 
    0.09016066f, -0.05540257f, -0.00029878f, 0.17650902f, 0.02166490f, -0.00786281f, 0.04713300f, 0.01835642f, 
    -0.01178380f, 0.02477158f, 0.11703250f, -0.04484662f, -0.19487692f, -0.05560574f, -0.08103967f, 0.10004487f, 
    -0.14954646f, 0.04064612f, 0.13421716f, 0.08938394f, -0.05560166f, 0.03273109f, 0.04345580f, 0.05130756f, 
    -0.09468233f, 0.04321686f, 0.12925045f, -0.15798226f, 0.21624301f, 0.02069169f, -0.10727012f, 0.01688711f, 
    0.05781199f, -0.05171176f, -0.10361016f, 0.04519507f, -0.08292415f, 0.13965540f, -0.10664204f, -0.22658242f, 
    0.10276905f, 0.02155650f, -0.05752162f, 0.06268870f, 0.11330780f, -0.00985702f, 0.00621872f, -0.08114595f, 
    -0.26765519f, -0.18442462f, 0.04001863f, -0.20048445f, -0.15490843f, -0.16930579f, -0.15647112f, -0.09556136f, 
    -0.02507604f, 0.01394782f, -0.01930808f, -0.07280362f, 0.02100126f, 0.18437742f, -0.10319467f, -0.01591062f, 
    0.08235238f, 0.15887406f, -0.01253777f, 0.03171616f, 0.02997360f, 0.05046242f, -0.00953261f, -0.02216972f, 
    -0.06415286f, -0.08444568f, 0.05056285f, 0.10697572f, -0.06863503f, 0.06199376f, 0.03196893f, -0.01536045f, 
    -0.16585955f, 0.00701831f, 0.00666989f, 0.01041635f, -0.20198807f, 0.09957147f, -0.04220331f, 0.02237323f, 
    0.00652403f, 0.09649993f, 0.04228239f, -0.06322812f, 0.04955332f, -0.11156879f, 0.09824045f, 0.03059499f, 
    0.03125105f, -0.24999526f, -0.01690072f, 0.27648652f, 0.05541628f, 0.01006810f, 0.05377872f, -0.03455510f, 
    0.01861074f, 0.00782228f, 0.02582538f, 0.02723659f, -0.30392924f, 0.12987979f, -0.12657101f, 0.05664056f, 
    0.00579658f, -0.00312164f, 0.03961021f, -0.03279817f, -0.04748620f, -0.00422406f, -0.04136279f, 0.11597269f, 
    -0.16746351f, -0.15734050f, -0.04700939f, 0.04841643f, 0.02022532f, -0.00630243f, -0.02612058f, -0.08831171f, 
    -0.11716058f, -0.12811027f, -0.07874580f, -0.04032727f, 0.30074513f, -0.13657080f, -0.01418967f, 0.24139246f, 
    0.07800676f, 0.19209766f, 0.00185045f, 0.03369950f, 0.11621606f, -0.06675219f, 0.03234740f, 0.08103587f, 
    -0.18007483f, -0.02385780f, -0.02015432f, -0.04230097f, 0.04161039f, 0.13063841f, -0.06694537f, -0.10986032f, 
    -0.05080583f, 0.04493397f, 0.02992536f, -0.00800696f, -0.13296033f, 0.07122320f, 0.01199916f, -0.04594677f, 
    0.00455292f, -0.01807221f, 0.02571879f, 0.04815977f, 0.10438903f, 0.09980996f, 0.15896168f, 0.15240759f, 
    0.17458975f, 0.05504626f, 0.03226184f, 0.19509037f, 0.04485812f, -0.03771050f, 0.00990732f, -0.00781158f, 
    0.04670503f, -0.16548401f, 0.05238059f, -0.18801749f, 0.10004554f, -0.02376566f, 0.13516028f, -0.07480106f, 
    -0.00980641f, -0.01206931f, -0.01774440f, -0.16590893f, -0.04484643f, -0.10397571f, -0.04349170f, 0.08464676f, 
    -0.07681574f, -0.14471608f, 0.10864569f, -0.27631173f, -0.06731287f, -0.00436963f, -0.02251562f, -0.05732563f, 
    -0.07871464f, 0.08435142f, -0.02125442f, -0.01284729f, -0.33839926f, -0.16624968f, 0.03956492f, -0.15717348f, 
    -0.06189491f, -0.05192131f, -0.07923973f, -0.18948536f, -0.10025123f, 0.00831743f, -0.02398264f, -0.06760280f, 
    -0.03924911f, 0.34252462f, -0.08082232f, 0.12832898f, -0.02493458f, 0.07487430f, 0.00412482f, -0.17731865f, 
    -0.12657523f, 0.07113107f, 0.08758931f, 0.00265129f, 0.12518205f, 0.15269911f, 0.06058321f, 0.11607326f, 
    -0.08733910f, 0.01900880f, 0.01381466f, -0.02936632f, 0.06273029f, 0.18377970f, 0.02996635f, 0.02097773f, 
    0.46073544f, -0.10798021f, -0.13084520f, 0.01893821f, 0.04649792f, 0.00457490f, 0.06956463f, 0.02680839f, 
    -0.04783002f, -0.09676410f, 0.02637556f, -0.09006792f, 0.10210248f, 0.10379819f, -0.00984891f, 0.06828084f, 
    0.09614925f, -0.01540840f, -0.07638254f, -0.05077506f, 0.05928453f, 0.03393217f, 0.14953680f, -0.06664991f, 
    -0.07684881f, 0.15469664f, 0.06173525f, -0.06853557f, 0.00458578f, 0.09644019f, -0.03603991f, 0.06676336f, 
    -0.01294728f, -0.06809591f, -0.02997320f, -0.00537126f, -0.19161628f, 0.19349150f, -0.01311066f, -0.04568191f, 
    0.09083926f, -0.01643691f, 0.02126699f, 0.07319473f, 0.02385012f, 0.00276204f, 0.07810671f, 0.04242124f, 
    0.23561454f, 0.07451890f, 0.08006255f, -0.09768809f, 0.07702470f, 0.12976432f, 0.03322393f, -0.07789531f, 
    -0.02206698f, 0.12426173f, 0.08022170f, -0.02545596f, 0.07998033f, 0.14998235f, -0.02112248f, -0.12689832f, 
    0.23148268f, 0.09088950f, 0.01916133f, 0.04843503f, 0.05239960f, 0.00692954f, 0.01898365f, -0.05043289f, 
    -0.31761065f, 0.24309056f, -0.03014985f, 0.22509943f, 0.09635850f, -0.03448533f, -0.07958980f, 0.09364362f, 
    0.06592468f, 0.00812012f, -0.00086785f, 0.11517167f, 0.13367242f, -0.08643760f, -0.10970521f, 0.11425147f, 
    -0.08858975f, -0.01502981f, 0.03636166f, -0.00934746f, -0.13969104f, -0.02417256f, -0.06968210f, 0.01967640f, 
    0.03269486f, 0.22360322f, -0.07544432f, 0.05243744f, 0.03150743f, 0.07777330f, -0.05432327f, -0.04676223f, 
    0.03607899f, -0.01749940f, 0.01099125f, -0.15221955f, -0.10518136f, -0.05352784f, 0.07977302f, 0.09467314f, 
    -0.05848986f, 0.07040595f, -0.00955071f, 0.09672904f, -0.02539690f, 0.02546870f, 0.12499696f, 0.03283918f, 
    -0.19401278f, 0.18310775f, -0.04350937f, 0.11254308f, 0.11842015f, 0.01541356f, 0.05204885f, 0.07450677f, 
    -0.01112196f, -0.10807790f, 0.05236401f, 0.06484389f, 0.40026480f, -0.00503737f, -0.15397738f, 0.07195971f, 
    0.07286439f, 0.02319870f, -0.04900462f, 0.07909048f, -0.01469531f, -0.14899504f, -0.09950096f, 0.03145523f, 
    0.11500225f, -0.28288946f, -0.05987938f, -0.07237244f, -0.14099415f, 0.02337325f, 0.03756986f, 0.06360522f, 
    -0.04813926f, 0.00762848f, 0.05241011f, -0.00166674f, -0.07454479f, 0.04237414f, 0.08768904f, -0.15262526f, 
    0.10167947f, -0.02361137f, -0.05705873f, 0.03781021f, 0.10766877f, -0.00653353f, 0.01866828f, 0.10023969f, 
    -0.02091579f, -0.02065745f, -0.03110025f, -0.04170529f, -0.00238249f, 0.01209987f, -0.02076799f, -0.00102788f, 
    -0.00309358f, 0.01372927f, 0.00910231f, -0.01158345f, 0.01531097f, -0.03362504f, 0.02947992f, -0.01738970f, 
    -0.03534835f, -0.01592641f, 0.00074709f, -0.01062859f, 0.01488414f, -0.02821184f, -0.01512792f, -0.00684236f, 
    -0.02168279f, 0.02808050f, -0.03907852f, -0.01713330f, 0.02808828f, 0.02761042f, -0.00434166f, -0.02828729f, 
    -0.01081832f, 0.00536026f, -0.02881011f, 0.00445623f, -0.02358052f, -0.00287382f, 0.01329860f, 0.00525078f, 
    -0.03845692f, -0.00797369f, -0.04059239f, -0.01888947f, -0.00666888f, 0.00041699f, 0.02032214f, 0.02542957f, 
    -0.02429270f, 0.02822202f, 0.00094024f, 0.01147291f, 0.01622121f, -0.00421389f, -0.00815835f, -0.00146122f, 
    0.00174426f, 0.01625875f, 0.01478132f, -0.02672168f, -0.00893620f, -0.00217066f, -0.03148311f, 0.02709966f, 
    0.00850179f, -0.02775820f, -0.03310746f, -0.00918536f, -0.03260820f, 0.01571011f, 0.01378529f, 0.00836076f, 
    -0.00940448f, -0.00082335f, -0.00000330f, -0.01881117f, 0.02198064f, -0.03295521f, -0.03484075f, -0.01531753f, 
    0.00120411f, -0.02360787f, 0.02954100f, 0.00783709f, -0.02978177f, -0.00259270f, 0.00965000f, 0.01757502f, 
    0.02921807f, -0.01237790f, -0.03235769f, 0.01873095f, 0.02486435f, 0.01728198f, -0.02073652f, 0.01713257f, 
    -0.00521250f, -0.03861116f, -0.01924976f, 0.02553642f, 0.00513732f, 0.00966100f, -0.01972001f, 0.01444919f, 
    0.02250424f, -0.03606949f, 0.00104777f, -0.03528187f, 0.01042243f, -0.01918528f, -0.02057310f, -0.00513235f, 
    -0.04300550f, -0.03773993f, -0.01833088f, 0.02214035f, 0.01903225f, 0.02466477f, -0.00053787f, 0.01906820f, 
    -0.02390132f, -0.03326337f, -0.02651846f, 0.03592186f, -0.01171696f, 0.01136525f, 0.02442497f, -0.01183274f, 
    -0.03153114f, 0.00031541f, -0.02085788f, 0.00951064f, 0.00784662f, 0.02303142f, -0.02173100f, 0.01300749f, 
    -0.00848560f, 0.01309113f, -0.02728324f, -0.00761389f, -0.03821332f, 0.01595474f, 0.02239845f, 0.02154449f, 
    0.00227308f, -0.01218130f, -0.02808959f, 0.02710530f, -0.01918302f, 0.01922838f, 0.00067294f, 0.00589612f, 
    0.01221532f, -0.02858897f, -0.01306408f, 0.01207245f, 0.03356453f, -0.00561550f, -0.02442239f, -0.03900525f, 
    -0.03282756f, 0.02480201f, 0.02082836f, -0.02545025f, 0.02466178f, 0.01364626f, 0.00162792f, -0.00174932f, 
    0.02064249f, -0.00218674f, 0.02457829f, -0.03343934f, -0.02883304f, -0.01282444f, 0.00258764f, 0.02608414f, 
    -0.02199780f, 0.02763479f, 0.01139885f, -0.00345575f, 0.01854715f, 0.01285880f, -0.02778468f, -0.04326750f, 
    0.01359317f, 0.02831021f, -0.01489158f, 0.02557771f, 0.02110930f, -0.02629327f, -0.03169780f, -0.01211213f, 
    -0.02667076f, -0.00576201f, -0.00188050f, 0.01412573f, -0.00327518f, 0.00972896f, -0.00377618f, -0.02230713f, 
    -0.01190071f, 0.01610360f, -0.02055288f, -0.01721934f, -0.02804995f, 0.00651828f, 0.01181474f, -0.03101666f, 
    -0.02450795f, 0.00669232f, 0.01635631f, -0.01790934f, 0.02502986f, 0.01394823f, 0.00510826f, -0.02613753f, 
    -0.01636679f, -0.02341191f, -0.01978551f, -0.00690963f, -0.03063002f, -0.01542770f, -0.03323229f, 0.00352900f, 
    -0.03614840f, 0.00656126f, -0.02609964f, 0.01560906f, 0.02387006f, 0.01539861f, 0.02517289f, 0.00762624f, 
    -0.03781891f, 0.00726381f, 0.01554062f, 0.02368202f, -0.00468951f, -0.00020225f, -0.02326669f, 0.02484018f, 
    -0.03923222f, -0.03655157f, 0.02481191f, -0.01608203f, -0.03706244f, -0.02045084f, -0.01090797f, -0.01166521f, 
    -0.02406278f, 0.00573624f, 0.01383706f, 0.00494529f, 0.01485326f, -0.01902706f, 0.01024625f, -0.00826957f, 
    -0.00762313f, -0.01027948f, 0.00473217f, -0.01161482f, -0.03558256f, 0.01400910f, -0.02212478f, -0.03590130f, 
    -0.00516618f, 0.02276619f, -0.00405283f, 0.02901169f, -0.01626619f, 0.00250124f, 0.00734712f, 0.00608421f, 
    0.01431539f, -0.02924470f, 0.00769296f, 0.01074042f, -0.03286046f, -0.01585073f, -0.00144585f, 0.02675887f, 
    -0.00742622f, 0.01695051f, -0.01781226f, -0.02728671f, -0.03053328f, -0.00927734f, 0.01354137f, 0.01247146f, 
    0.01053484f, -0.01892337f, -0.02745672f, -0.02602053f, -0.02288233f, 0.02401387f, -0.01638345f, -0.02474919f, 
    0.02277287f, -0.03145556f, 0.01958026f, -0.02120057f, -0.00163956f, 0.02113708f, 0.00384179f, -0.03959808f, 
    -0.01133559f, -0.00920058f, -0.00448762f, -0.01552844f, -0.01492043f, -0.02344300f, -0.00054650f, -0.02204977f, 
    -0.03448312f, -0.00560265f, -0.03363926f, -0.03782754f, -0.02235667f, 0.00794894f, 0.00862135f, -0.02214099f, 
    -0.03885344f, -0.04016019f, -0.02127564f, -0.03029242f, 0.01423125f, 0.01265471f, -0.02632068f, -0.01427146f, 
    0.00296456f, 0.00699499f, -0.00426563f, -0.03215973f, -0.00653047f, -0.00746307f, -0.03432472f, -0.00188805f, 
    -0.00159105f, 0.00710319f, -0.03175061f, -0.01569463f, 0.03289963f, -0.01827871f, -0.04031739f, -0.00612664f, 
    0.00625149f, 0.00751611f, -0.00376612f, -0.01475270f, 0.00528597f, -0.02497377f, -0.00977903f, 0.03428291f, 
    0.03606448f, -0.01555043f, -0.00062695f, -0.02775697f, -0.01230191f, -0.03286963f, -0.03983240f, 0.01009103f, 
    -0.02768705f, 0.02700740f, 0.00312319f, -0.04283807f, -0.03065075f, 0.02022502f, -0.00971203f, -0.04003823f, 
    -0.01207941f, 0.01446142f, 0.00861882f, -0.00077684f, -0.02300617f, 0.01643845f, -0.02510180f, 0.00577756f, 
    0.00655934f, -0.00089478f, 0.00708261f, 0.00891498f, 0.01746524f, 0.02916670f, 0.00202670f, -0.03631334f, 
    0.00347937f, -0.03757172f, -0.01089041f, -0.00013748f, -0.02977898f, -0.04209182f, -0.02602958f, 0.02383942f, 
    -0.00970511f, -0.01912218f, -0.01745878f, 0.02742814f, -0.00559675f, -0.01183568f, -0.01144058f, -0.03348947f, 
    -0.02960244f, 0.01237229f, -0.02379210f, -0.02882326f, -0.02354955f, -0.00954544f, 0.01731836f, -0.02283201f, 
    0.01124138f, -0.01125549f, 0.01474953f, -0.02553481f, 0.01597968f, -0.02148238f, 0.02154343f, 0.01509596f, 
    0.01197257f, -0.02017846f, -0.00737288f, -0.01056637f, 0.01227900f, 0.01564268f, 0.01193925f, 0.00183350f, 
    0.01978600f, -0.02561072f, -0.02409812f, 0.01491624f, -0.01892587f, -0.03044133f, -0.00117487f, 0.02673425f, 
    -0.00083484f, 0.01841296f, -0.01344731f, -0.00367599f, -0.04121432f, 0.02387694f, -0.02188562f, 0.02770946f, 
    -0.00788137f, -0.02749730f, -0.03745539f, 0.02295439f, -0.02822999f, -0.00675505f, -0.00982748f, 0.01525335f, 
    -0.01456906f, -0.00072909f, -0.03033369f, -0.01126638f, -0.01038086f, -0.00390121f, -0.02231118f, -0.03199141f, 
    0.02943952f, -0.01516576f, -0.04116426f, 0.02322602f, -0.00069866f, 0.00177188f, 0.03378833f, -0.01196875f, 
    0.00299704f, -0.04177414f, 0.01559247f, -0.03884132f, -0.01278590f, -0.00177186f, -0.00512815f, -0.01252829f, 
    -0.02651570f, 0.00870809f, -0.00277415f, 0.01629487f, 0.02770324f, 0.02140240f, -0.00087722f, 0.00627296f, 
    -0.01861885f, -0.02943943f, 0.02812677f, 0.01450447f, 0.02633081f, -0.01721447f, 0.01609347f, 0.02759057f, 
    0.02570253f, -0.01013874f, -0.02735125f, 0.01530182f, -0.02447714f, 0.00416617f, 0.01617667f, -0.03436747f, 
    0.01721124f, 0.01851428f, -0.00945696f, -0.00387783f, -0.00408922f, -0.00242827f, 0.01404660f, -0.01395694f, 
    -0.00847423f, -0.01149855f, -0.04007231f, -0.01709411f, 0.01959994f, -0.02767828f, 0.00714660f, 0.02258189f, 
    -0.04175515f, 0.00571686f, -0.04108538f, -0.00886474f, -0.01209090f, 0.01390932f, -0.02052369f, -0.00749986f, 
    -0.01067623f, 0.01773057f, -0.00371927f, 0.02436883f, -0.03645202f, -0.04057707f, -0.03198085f, -0.01699243f, 
    -0.03291844f, 0.00693135f, -0.04264036f, -0.02530251f, -0.01426664f, -0.02368502f, 0.01041114f, -0.03735830f, 
    -0.02152555f, 0.01670235f, 0.01478334f, -0.02209142f, 0.01848408f, 0.00411580f, -0.01475085f, -0.01072878f, 
    -0.02705097f, 0.00731592f, 0.01427860f, -0.00149773f, -0.00319184f, -0.03812835f, 0.00939121f, -0.02542815f, 
    0.02170878f, -0.02241478f, 0.01417313f, -0.04047497f, 0.02248225f, 0.01538507f, 0.01278363f, 0.01315312f, 
    -0.00709345f, -0.00789116f, 0.00105847f, 0.01967534f, 0.01195402f, -0.01311000f, 0.01515608f, -0.03314374f, 
    -0.02114532f, 0.02789772f, 0.01614494f, -0.00453994f, -0.02174411f, -0.03848324f, -0.01428161f, -0.02696178f, 
    -0.00070342f, -0.03217439f, 0.01091475f, -0.02086171f, -0.04210366f, 0.01217678f, -0.01286788f, -0.02828185f, 
    -0.01205654f, -0.03411995f, 0.00064516f, -0.00938632f, -0.04310817f, -0.01364760f, 0.00813653f, -0.02644561f, 
    -0.01807655f, -0.02869579f, 0.00788449f, -0.01653906f, 0.00611426f, -0.02550888f, -0.00216827f, -0.02509358f, 
    -0.00904602f, 0.01607055f, -0.01252839f, 0.00395831f, 0.01990073f, -0.02956835f, -0.00100729f, 0.01755216f, 
    0.01243028f, -0.00976869f, 0.00810495f, -0.00865227f, -0.01348546f, 0.02804418f, -0.03145653f, 0.01138343f, 
    -0.01671879f, -0.01055975f, -0.03779623f, -0.02935397f, 0.02616831f, 0.02148445f, -0.01454820f, -0.01252521f, 
    0.00862190f, 0.02198745f, -0.00046811f, -0.03629433f, 0.02987466f, 0.02047805f, -0.04211433f, -0.03720803f, 
    -0.03301012f, 0.01839556f, -0.03025635f, -0.00767668f, 0.01476603f, -0.00139281f, -0.01949407f, -0.02825956f, 
    0.01559255f, -0.02461428f, 0.00918571f, -0.01031200f, -0.00056900f, 0.02044488f, 0.01165462f, -0.03306202f, 
    0.01526378f, -0.00199631f, -0.02560301f, -0.03070105f, -0.00278640f, -0.00160182f, -0.02873517f, -0.01360692f, 
    -0.02577304f, -0.01031582f, -0.00770559f, 0.00798671f, 0.01015285f, 0.03675489f, -0.01481496f, 0.01631581f, 
    0.01151260f, -0.01147901f, 0.01038739f, -0.00667636f, -0.01676614f, -0.01883220f, -0.02612045f, -0.01162658f, 
    -0.00866113f, -0.02923723f, -0.01384472f, 0.02873255f, 0.01375585f, 0.01830754f, -0.02879467f, -0.02483745f, 
    -0.03306326f, -0.00091641f, 0.02201426f, -0.03581071f, 0.01746249f, -0.03795729f, 0.01864199f, 0.02677526f, 
    -0.01120157f, -0.01310904f, 0.01284210f, 0.00915851f, 0.02736189f, 0.01910139f, 0.00835100f, -0.02782560f, 
    0.01041557f, -0.03121233f, -0.04087989f, -0.04072611f, -0.03525566f, -0.00888006f, -0.03932351f, -0.00634067f, 
    0.02159683f, -0.03815214f, 0.02773614f, -0.00810117f, -0.02352654f, -0.03340610f, 0.00235020f, 0.02795226f, 
    0.00976476f, -0.00104735f, 0.02268372f, 0.00573105f, 0.01169871f, -0.00892187f, 0.00526557f, -0.02247224f, 
    -0.01880847f, 0.01661930f, 0.00692360f, -0.02478752f, 0.01905518f, -0.02388765f, -0.03278851f, 0.00004574f, 
    -0.01273317f, 0.00990175f, 0.02684291f, -0.02112580f, -0.02369219f, 0.02876594f, 0.01079087f, -0.01657476f, 
    0.01757290f, 0.00135778f, 0.00773330f, -0.00287912f, 0.01224509f, 0.01350008f, 0.01913687f, 0.01335546f, 
    0.02891927f, 0.02227904f, -0.02534540f, 0.02126906f, 0.00156751f, -0.03097644f, 0.02622061f, -0.02830423f, 
    0.02331395f, -0.00241995f, -0.02931726f, -0.00646130f, -0.01721380f, -0.03676264f, -0.01657862f, -0.03902441f, 
    0.00372801f, -0.00555683f, -0.01342169f, -0.00958406f, -0.00661797f, 0.01731353f, -0.04158067f, 0.03435365f, 
    0.00491952f, -0.03231719f, 0.01517411f, 0.02895935f, -0.03415563f, -0.02617374f, 0.02371078f, -0.03481100f, 
    -0.02835671f, 0.02329078f, -0.03695545f, 0.00706066f, 0.01742591f, 0.02977384f, -0.03868024f, 0.03033352f, 
    0.02935810f, -0.03484149f, 0.00187424f, 0.01373719f, -0.01478783f, -0.03497970f, 0.00735301f, -0.02406086f, 
    0.01490891f, -0.00627622f, 0.00123669f, -0.02089441f, -0.01433092f, -0.02994771f, -0.00545492f, -0.01877070f, 
    0.02404014f, 0.02060808f, -0.01642166f, -0.01558707f, -0.03602502f, -0.03877350f, -0.00264197f, -0.04190218f, 
    -0.00644468f, -0.02238739f, -0.01249816f, -0.01752061f, -0.00621481f, 0.01241476f, -0.00062475f, -0.00784740f, 
    0.01238206f, -0.02249809f, -0.01716283f, 0.00080825f, 0.00631777f, -0.01005860f, -0.03182989f, -0.00964949f, 
    -0.02034291f, -0.00598495f, -0.02092081f, -0.00970340f, -0.02643531f, -0.02441445f, 0.00595438f, -0.00502294f, 
    0.00408026f, -0.00864284f, -0.02284473f, 0.01797679f, 0.00791801f, -0.03110263f, 0.01759411f, -0.02698249f, 
    0.00309551f, 0.00316768f, -0.02833225f, 0.01004464f, 0.01356623f, -0.03012155f, -0.03950329f, -0.00371679f, 
    -0.02260258f, -0.01537283f, 0.00862976f, 0.01432136f, -0.02788525f, -0.01490457f, -0.04124178f, 0.02466208f, 
    0.03007088f, 0.03025527f, 0.01207204f, -0.02586438f, 0.00446744f, -0.02464347f, 0.00915373f, -0.01482160f, 
    0.04265856f, -0.02067940f, -0.04091784f, -0.00825498f, -0.02291533f, 0.00611585f, -0.00232210f, 0.02087320f, 
    0.00476462f, -0.01178612f, -0.01190734f, -0.01082858f, -0.02440066f, -0.00897916f, -0.02642434f, -0.01268282f, 
    0.02848840f, 0.01409846f, 0.02683564f, 0.00768195f, 0.00237859f, 0.00451562f, 0.02579894f, -0.02924504f, 
    0.00614679f, -0.02101201f, -0.03663830f, 0.02112354f, 0.02899477f, 0.03477190f, 0.02273555f, -0.01147066f, 
    0.01396702f, 0.01141311f, 0.03780719f, 0.01424675f, 0.00712792f, -0.01687559f, 0.00625728f, 0.00871429f, 
    0.00521783f, 0.03650619f, -0.00365022f, -0.02045163f, 0.00643970f, 0.02445725f, -0.02759584f, 0.02389265f, 
    -0.03893008f, 0.00445114f, 0.01912380f, 0.02147822f, 0.01273568f, 0.01343513f, 0.01738456f, -0.01223833f, 
    0.01213331f, -0.02925288f, 0.03040943f, 0.00108945f, 0.01760191f, -0.01988622f, 0.01470538f, -0.00282865f, 
    -0.03383751f, 0.02916359f, 0.01151088f, -0.02584287f, 0.03047287f, -0.00407423f, 0.01993794f, -0.01553367f, 
    0.01401696f, 0.01171863f, -0.00547900f, 0.02223549f, -0.00254524f, -0.00301923f, -0.00312352f, -0.00750325f, 
    -0.03886584f, 0.01354215f, 0.02265711f, -0.00923546f, 0.00053945f, 0.01362685f, 0.02266986f, -0.00331702f, 
    0.03276672f, 0.01798898f, 0.01570486f, 0.01989848f, 0.00381774f, -0.03342061f, -0.03526809f, -0.01360145f, 
    -0.03555347f, 0.00451871f, 0.01587192f, 0.02436454f, -0.00833338f, 0.03426269f, 0.00099995f, 0.01763325f, 
    -0.03091902f, 0.01214149f, -0.02277689f, 0.02010275f, -0.02811773f, 0.02723178f, 0.00943237f, -0.03717136f, 
    -0.03545115f, 0.02798839f, -0.01115768f, 0.01619985f, -0.02522333f, 0.00295731f, -0.00151951f, -0.02747671f, 
    0.02839819f, 0.01350963f, -0.01624020f, -0.02190100f, -0.02677558f, -0.03509209f, 0.01754976f, 0.02248632f, 
    0.00139342f, 0.00561554f, -0.01578029f, -0.00794775f, 0.03096368f, -0.02186704f, -0.02393736f, -0.02449770f, 
    -0.03022869f, -0.01022878f, 0.01466701f, -0.02855649f, 0.01676735f, 0.00946656f, -0.01825953f, -0.04013786f, 
    0.00763684f, 0.00220515f, -0.03785897f, -0.00835551f, -0.01189750f, -0.01120057f, -0.00069332f, 0.02557644f, 
    0.01181943f, 0.01778327f, 0.00023687f, -0.01011969f, 0.01554183f, -0.02739311f, 0.00481407f, 0.02696658f, 
    -0.02697661f, 0.00754010f, -0.01506940f, -0.00981969f, -0.03921271f, -0.03080618f, 0.04171507f, 0.00737661f, 
    -0.03528061f, 0.01790337f, -0.01137000f, 0.02229167f, 0.01872966f, 0.00694331f, -0.02356675f, 0.03682348f, 
    -0.01386226f, -0.02092560f, 0.03407576f, -0.00661274f, -0.02194365f, 0.02629104f, 0.01377777f, -0.00931743f, 
    -0.03340838f, -0.02198998f, -0.01720151f, 0.00739353f, -0.02422433f, 0.00584966f, -0.03143469f, 0.00244002f, 
    0.03681805f, 0.02351574f, 0.01102208f, -0.00220393f, -0.02928003f, 0.02162183f, 0.00166387f, -0.01020505f, 
    0.02726170f, -0.03076424f, 0.01172367f, 0.00626965f, -0.01911401f, 0.02364350f, 0.02315570f, 0.02418514f, 
    -0.03658533f, 0.00532606f, -0.01594768f, 0.00138521f, -0.02960440f, -0.01086378f, -0.02839909f, -0.03725043f, 
    0.02360453f, -0.02879224f, -0.02259780f, -0.00088409f, -0.03067222f, -0.03307433f, -0.01104249f, 0.02103824f, 
    -0.00311503f, -0.03903467f, -0.00081392f, -0.00820254f, -0.01636344f, -0.02730291f, 0.00145078f, 0.00779325f, 
    -0.00354235f, -0.03878134f, -0.02702677f, 0.00887867f, -0.00051946f, 0.00049758f, -0.03106497f, -0.01834454f, 
    -0.02867471f, -0.01532634f, 0.02926596f, -0.03821726f, 0.00994921f, -0.02143942f, 0.01713974f, -0.00674419f, 
    0.02747974f, 0.00036958f, -0.02708918f, -0.01375050f, 0.00455523f, 0.01207940f, -0.00811955f, 0.01463603f, 
    -0.02852304f, 0.02672009f, 0.01816161f, 0.01829196f, 0.01460502f, -0.02150704f, -0.00709167f, 0.01547956f, 
    -0.03393740f, -0.00026050f, 0.00352542f, -0.02651479f, -0.00407314f, -0.01016118f, 0.03301455f, 0.00487548f, 
    -0.01017845f, -0.00781676f, -0.03279628f, -0.03715554f, 0.02778062f, 0.01634959f, -0.00745657f, 0.00259951f, 
    -0.02850416f, -0.01755085f, 0.02053163f, -0.00284520f, 0.02256143f, 0.01181030f, -0.00897892f, -0.00559913f, 
    -0.00102993f, 0.04150643f, 0.02900828f, -0.02942985f, 0.01549274f, -0.02401142f, 0.02266429f, -0.02205466f, 
    -0.01630923f, -0.04123709f, 0.02691053f, -0.00362058f, 0.00269693f, 0.01730482f, -0.02734874f, 0.03258606f, 
    -0.03817758f, 0.00856285f, 0.01275599f, 0.02298917f, -0.00112554f, -0.01732393f, -0.02004835f, -0.00257428f, 
    -0.03850722f, -0.01587423f, -0.02928401f, 0.00007662f, 0.01343173f, 0.00409740f, -0.01013935f, 0.02139446f, 
    -0.01557527f, 0.03062415f, 0.00607178f, -0.02239476f, 0.03319207f, -0.02591199f, -0.00497592f, -0.01977159f, 
    0.00062882f, -0.03280222f, -0.00977817f, -0.03697810f, -0.03019495f, 0.00244970f, 0.02157026f, -0.03781831f, 
    0.03050239f, -0.00061588f, -0.00484489f, 0.00403027f, -0.01378514f, 0.03202079f, 0.02288084f, 0.01271387f, 
    0.00654468f, 0.02663072f, -0.02769259f, 0.03881845f, -0.03426046f, 0.00261241f, 0.02377295f, 0.01600398f, 
    0.03959644f, -0.00045862f, -0.00766744f, 0.01877034f, -0.01306256f, 0.01729991f, 0.01143749f, -0.02251011f, 
    0.00192821f, -0.02420426f, 0.00389325f, 0.01363855f, 0.00948957f, -0.04014836f, -0.02262792f, 0.01878385f, 
    -0.00207327f, 0.01092546f, 0.02151846f, 0.02749871f, -0.02614754f, 0.02831745f, -0.01053856f, 0.01185883f, 
    -0.03138689f, 0.03469265f, -0.00592314f, -0.02843022f, -0.02950923f, -0.02663392f, 0.02402151f, -0.00805139f, 
    0.02210538f, 0.02750365f, -0.00709281f, -0.03144835f, 0.01668213f, 0.01751850f, 0.03483619f, -0.01084152f, 
    0.01989757f, -0.02499442f, -0.01782767f, -0.03765913f, -0.00076471f, 0.03047126f, -0.03849018f, -0.01190394f, 
    -0.02919681f, 0.00466707f, 0.02764584f, 0.04133644f, -0.03787462f, -0.00953214f, 0.01471701f, -0.01043997f, 
    -0.00192787f, -0.01762157f, 0.00455033f, 0.01855789f, 0.00761318f, 0.00413229f, -0.01463713f, -0.04113977f, 
    -0.03277873f, -0.02642646f, 0.01832137f, -0.00065957f, 0.01775157f, 0.03861802f, 0.02127091f, 0.02442612f, 
    -0.03556103f, -0.00727683f, 0.02106148f, -0.04147375f, 0.00927251f, -0.03554758f, 0.01916861f, -0.01816864f, 
    0.00165948f, -0.00830254f, -0.04060923f, 0.01511561f, -0.02680722f, 0.00163528f, 0.01948245f, 0.00688551f, 
    -0.02170847f, -0.04197680f, -0.02344786f, 0.00592701f, -0.01161145f, 0.00114227f, 0.00909081f, -0.01157302f, 
    0.02689183f, 0.01877679f, 0.01269393f, -0.01963504f, 0.01564443f, -0.01839301f, -0.03589102f, -0.03447591f, 
    -0.00015850f, 0.00843990f, 0.00453318f, 0.00983177f, -0.02808477f, -0.03314512f, -0.02546048f, -0.01463860f, 
    -0.03648594f, 0.00761080f, -0.01988622f, -0.01309971f, -0.02150391f, 0.01717393f, -0.03189477f, 0.00012517f, 
    0.04071083f, -0.04083784f, -0.02472058f, -0.02986454f, -0.03449280f, 0.02492521f, 0.02464382f, 0.01017307f, 
    -0.03547012f, 0.01778758f, -0.00149106f, -0.01193031f, 0.02847481f, 0.02683260f, -0.02384342f, -0.03824035f, 
    -0.02823731f, -0.00289224f, -0.03840092f, -0.01179202f, -0.03480114f, 0.01021083f, 0.02730020f, -0.03308964f, 
    0.00703847f, 0.01514402f, -0.03755067f, -0.01856500f, -0.01167480f, -0.01362481f, 0.02308155f, 0.02156775f, 
    0.02676951f, -0.01629979f, -0.01661853f, 0.00256231f, -0.02502455f, 0.01970861f, 0.00073566f, -0.01757114f, 
    0.02528257f, -0.02703535f, -0.00282356f, 0.00327803f, 0.01586276f, -0.00060577f, 0.00412931f, -0.03726937f, 
    -0.01493434f, 0.00080385f, -0.02201825f, -0.00381359f, -0.01446818f, -0.00373064f, -0.02921860f, -0.03542681f, 
    -0.04142091f, 0.03016714f, 0.00109484f, 0.00845103f, 0.00699662f, -0.04045505f, 0.02186753f, -0.00441633f, 
    -0.01923192f, 0.01157853f, 0.00450786f, 0.00413447f, -0.02552148f, -0.02943420f, -0.01393762f, 0.02474349f, 
    0.02329074f, 0.02684355f, 0.02304606f, 0.02076798f, -0.01880866f, -0.00293061f, 0.00475800f, 0.03467961f, 
    0.00245918f, 0.02798461f, -0.02589343f, 0.00958007f, -0.01060181f, -0.00836276f, -0.02735886f, 0.00267710f, 
    0.02842427f, -0.00224285f, 0.00860823f, -0.03726362f, -0.01716483f, 0.01956007f, -0.02210165f, -0.04097470f, 
    0.02037514f, -0.03090685f, 0.02792520f, -0.04109846f, -0.03351824f, 0.02253756f, 0.01224105f, -0.03379092f, 
    0.01842690f, 0.01816629f, -0.01933153f, -0.02359110f, -0.01253753f, -0.04017234f, -0.00105257f, 0.02714731f, 
    -0.01738092f, -0.03492125f, 0.00111301f, 0.00032354f, -0.02082425f, -0.00056678f, 0.00852407f, -0.03124325f, 
    -0.02130610f, 0.03032809f, 0.00604641f, 0.02801495f, -0.00533622f, -0.02940922f, -0.00818358f, -0.03596941f, 
    0.02904171f, -0.01689098f, -0.03902139f, 0.01864667f, -0.01448267f, 0.02497759f, 0.01067011f, -0.02127830f, 
    -0.02393028f, -0.03478916f, 0.00842127f, 0.01047563f, -0.00929924f, -0.00779850f, 0.01020888f, 0.01759413f, 
    0.00568420f, -0.02406611f, 0.00105876f, -0.00319665f, 0.02035103f, 0.02827814f, -0.00856975f, -0.02852158f, 
    0.01876158f, 0.00453607f, 0.00031919f, -0.00590749f, -0.02305849f, -0.03493314f, -0.01120378f, -0.02083131f, 
    -0.02667210f, -0.02823459f, -0.04033102f, -0.02422333f, 0.00512023f, 0.01569352f, -0.01050644f, -0.01180372f, 
    -0.03595160f, -0.04123949f, -0.04147263f, -0.03845945f, 0.02220837f, 0.01530267f, -0.03677114f, 0.01942522f, 
    -0.01761021f, -0.01726702f, 0.02426309f, -0.02037402f, 0.01964554f, 0.01396882f, -0.04051636f, -0.00992844f, 
    0.00019856f, 0.01764546f, 0.01619791f, 0.00757636f, 0.03869143f, 0.03328872f, -0.03096028f, -0.04078676f, 
    -0.02788959f, 0.02059180f, 0.01582869f, 0.02975659f, -0.03979737f, -0.00951044f, -0.01262603f, -0.00783349f, 
    0.29613322f, -0.05116588f, 0.07315307f, 0.19659737f, -0.00028870f, 0.10147189f, -0.00775599f, 0.00448082f, 
    -0.04051879f, -0.07294223f, 0.04681856f, -0.00065926f, -0.07213185f, -0.06739508f, -0.07242806f, 0.02925526f, 
    0.02497383f, 0.02974254f, 0.11043163f, 0.01684911f, 0.07574314f, 0.00284018f, 0.10797394f, 0.07409049f, 
    -0.27198550f, 0.16954456f, 0.12672064f, -0.13014424f, 0.10578901f, 0.04581098f, -0.07169783f, 0.03925364f, 
    0.00062975f, 0.01322834f, 0.03499514f, -0.02586487f, 0.19026801f, 0.16891238f, 0.17042008f, -0.11724377f, 
    -0.00661404f, -0.00920196f, 0.15914597f, 0.00779251f, 0.12095137f, -0.01661781f, 0.04242932f, 0.02485642f, 
    0.04273058f, -0.06556728f, 0.08636070f, -0.05352828f, -0.05117093f, 0.11704569f, 0.02037260f, -0.00640531f, 
    -0.10649455f, 0.07652978f, 0.09380280f, 0.01025258f, 0.12474752f, 0.26527959f, -0.02931153f, -0.10759173f, 
    -0.07438565f, 0.08976916f, -0.06941137f, -0.08943959f, -0.04563694f, -0.05957162f, -0.01169107f, 0.01550253f, 
    0.22125417f, 0.18963958f, 0.08350603f, 0.02345714f, -0.02236825f, 0.05995675f, 0.01526601f, -0.08466322f, 
    -0.07628334f, 0.10847311f, 0.07192600f, 0.01823477f, -0.17095728f, 0.03823437f, -0.05789761f, -0.00154871f, 
    -0.04347377f, -0.08516413f, 0.00540076f, 0.06737975f, 0.04288607f, 0.05801048f, 0.04808684f, -0.06444126f, 
    0.11243559f, -0.00421040f, -0.06716537f, 0.01942977f, -0.03311500f, 0.05637633f, -0.09919678f, -0.00108511f, 
    -0.03004433f, -0.00536252f, 0.02783157f, -0.02999172f, -0.06039795f, 0.04585692f, -0.23848292f, -0.06471827f, 
    -0.00867029f, 0.03383505f, 0.02060735f, -0.03633069f, -0.03857669f, -0.03426515f, -0.09587918f, -0.09577607f, 
    0.46267903f, -0.07789526f, 0.07815950f, -0.03215755f, -0.09587690f, 0.02413114f, 0.04090407f, -0.05806931f, 
    -0.05208111f, 0.05941703f, 0.07824179f, 0.03095309f, 0.03873124f, 0.19898413f, 0.15010796f, -0.00290154f, 
    0.02505592f, -0.07544393f, 0.00785678f, 0.08883463f, -0.01238284f, 0.03717813f, 0.02578901f, -0.02677414f, 
    0.14712824f, -0.04102008f, 0.16987492f, 0.05301142f, 0.00898472f, -0.08115609f, -0.07341032f, 0.00316798f, 
    -0.00994051f, -0.07379340f, -0.11128099f, -0.04240639f, -0.18519221f, -0.07421048f, -0.07234639f, -0.25666478f, 
    0.08980234f, -0.01371395f, 0.00407826f, -0.02907592f, 0.03965642f, 0.03182859f, 0.08475859f, -0.07758492f, 
    -0.10231460f, 0.01551954f, -0.13676019f, 0.14719503f, 0.03940424f, 0.04516403f, 0.14257407f, -0.03892018f, 
    -0.04383783f, 0.04911272f, -0.06174077f, 0.11047664f, -0.11069111f, -0.01111961f, 0.21399592f, 0.09809259f, 
    -0.02366599f, 0.01521915f, 0.02279412f, -0.02971054f, 0.11530944f, -0.06497756f, 0.01399474f, -0.20983006f, 
    0.09615713f, -0.04819376f, 0.05353748f, 0.08944359f, -0.01274505f, 0.04030260f, -0.04315835f, -0.00777093f, 
    0.06629296f, 0.16715625f, -0.00088688f, -0.09210468f, 0.07795363f, 0.20381308f, 0.03875808f, 0.04967190f, 
    0.02231929f, -0.00684563f, 0.09308044f, 0.07648011f, 0.00979476f, 0.04002145f, -0.01552503f, 0.02058334f, 
    0.17052665f, -0.07581297f, 0.02052160f, 0.17135480f, 0.00429887f, -0.04785831f, -0.12661229f, -0.05465455f, 
    0.00145079f, -0.02434902f, -0.00013724f, 0.03943083f, 0.30524623f, -0.04203071f, 0.01474176f, -0.07155720f, 
    0.16815838f, 0.07999776f, -0.01681310f, -0.09222592f, -0.00497296f, 0.00584648f, 0.07001405f, -0.06485773f, 
    0.02211148f, 0.04936218f, -0.08133638f, 0.00067334f, 0.15041569f, -0.00045969f, -0.03790571f, -0.05718711f, 
    -0.05476049f, 0.04158760f, -0.10028907f, -0.00882119f, 0.24982409f, -0.07070987f, 0.25337166f, 0.04021031f, 
    -0.01089939f, -0.04746706f, 0.07509346f, 0.06266354f, 0.09677978f, 0.08076598f, -0.03842172f, 0.00094709f, 
    -0.01380934f, 0.33866963f, 0.10992982f, 0.14529848f, 0.12098198f, -0.06511104f, 0.01249814f, 0.04670127f, 
    0.02554970f, 0.06686748f, -0.06030077f, 0.07530284f, 0.20277923f, 0.01456327f, -0.03001485f, 0.17783675f, 
    -0.07097785f, -0.02027673f, 0.01010390f, 0.09884445f, 0.08868399f, 0.04247428f, -0.09181034f, 0.04144016f, 
    0.28779835f, 0.17807026f, 0.06268479f, -0.12509261f, -0.04863577f, 0.02493992f, -0.04303640f, -0.00652950f, 
    -0.01568904f, -0.05041080f, 0.01807295f, -0.01535522f, 0.38959399f, -0.15124246f, 0.00355088f, 0.04331106f, 
    0.05930613f, -0.00988863f, 0.07837802f, -0.07912630f, -0.02199738f, 0.03357907f, -0.05447067f, 0.01145547f, 
    0.25653803f, 0.13751598f, 0.04402070f, -0.05180845f, -0.02745214f, 0.00720392f, 0.02990169f, 0.06688079f, 
    0.03551883f, -0.03947480f, 0.10261296f, 0.10797146f, 0.17856215f, -0.02251842f, -0.09996737f, 0.01322656f, 
    0.00071607f, -0.08736134f, -0.01411565f, 0.00209765f, 0.01975995f, 0.03437217f, -0.04875794f, 0.03192936f, 
    0.23702259f, -0.15666454f, 0.11831964f, 0.09207346f, -0.11003398f, -0.02974278f, -0.10153724f, -0.03004468f, 
    -0.01179457f, 0.09379348f, 0.02357402f, -0.06102950f, -0.28198621f, -0.00347502f, -0.07958640f, 0.02643424f, 
    0.01722377f, 0.12681080f, -0.21823534f, -0.07232456f, 0.08867320f, -0.00380575f, 0.10940450f, -0.05726010f, 
    0.23865843f, -0.17047083f, 0.02733761f, 0.06680998f, -0.04657283f, 0.06014133f, -0.11842548f, 0.03520419f, 
    -0.13368727f, 0.06414653f, 0.05699313f, 0.04485065f, -0.02486613f, 0.27103391f, -0.03107242f, 0.09020376f, 
    0.00658035f, -0.03583325f, 0.09657684f, 0.02638119f, 0.07674547f, -0.05347388f, 0.08141781f, 0.00245548f, 
    -0.05182323f, 0.13914226f, -0.16485570f, 0.08592472f, 0.07802877f, -0.03229772f, -0.04693830f, -0.05346714f, 
    0.04852707f, -0.01783971f, -0.12948492f, -0.11385197f, -0.22349724f, 0.06210570f, -0.06373058f, -0.21563974f, 
    -0.04519013f, 0.06208377f, 0.06125178f, -0.09056724f, 0.02562989f, -0.01060769f, 0.08198135f, -0.00128118f, 
    0.05400073f, -0.11790136f, 0.33969438f, 0.19081952f, 0.04427432f, -0.00108735f, -0.02584732f, 0.12931427f, 
    -0.00104500f, 0.07567367f, -0.00408144f, -0.12337092f, 0.15391453f, 0.03325602f, -0.02488785f, -0.07503618f, 
    0.09233160f, 0.02139685f, -0.10229907f, -0.11635870f, -0.01399110f, -0.06551261f, -0.03779887f, -0.01099959f, 
    0.23762099f, -0.01973496f, 0.16824605f, 0.09130323f, 0.02143687f, 0.12572022f, -0.09653136f, 0.02682698f, 
    0.00328244f, 0.04082169f, 0.09202435f, -0.00017359f, -0.16393721f, -0.00685359f, -0.05126420f, 0.01318168f, 
    -0.10312701f, 0.07858620f, -0.03408248f, -0.11875609f, -0.05120206f, -0.02501396f, -0.03697202f, -0.08373070f, 
    -0.27728620f, -0.16992676f, -0.02334967f, 0.05020752f, -0.06272386f, 0.10157558f, -0.05059226f, -0.06722470f, 
    -0.00427253f, -0.01241329f, -0.01618268f, -0.00418257f, -0.09484628f, 0.15846987f, 0.10830509f, 0.02355635f, 
    0.02674590f, -0.01535240f, 0.08197954f, -0.00377498f, -0.08719427f, -0.05831850f, -0.10761502f, -0.02046318f, 
    0.02396509f, 0.08709134f, 0.03633495f, 0.15919761f, 0.06934850f, -0.01952760f, -0.04957969f, 0.07735169f, 
    -0.02172082f, -0.06872336f, 0.01493381f, 0.03546042f, -0.37182462f, -0.20536000f, -0.10901136f, -0.02840446f, 
    -0.06618667f, 0.03725377f, 0.00986018f, -0.01751271f, -0.09068195f, -0.08023685f, 0.05318415f, -0.05404767f, 
    -0.12515061f, -0.20677809f, 0.03368362f, -0.13301532f, -0.13341531f, 0.04402833f, -0.06417060f, 0.11130469f, 
    0.03407965f, 0.00980974f, 0.12829380f, 0.03052500f, -0.01434242f, 0.07923661f, -0.16770495f, 0.09746514f, 
    0.05868984f, 0.04554531f, -0.07185101f, 0.01407947f, 0.04949852f, 0.07832674f, 0.03933850f, 0.04381194f, 
    0.15277746f, -0.21684657f, 0.00808553f, 0.05575735f, 0.14691937f, -0.03314972f, -0.09250437f, 0.06429788f, 
    -0.02894912f, -0.02708227f, 0.04739890f, 0.07213596f, -0.06730862f, -0.02250182f, 0.02813649f, 0.10073416f, 
    0.04316921f, 0.02794388f, -0.02477025f, -0.07400125f, 0.02723982f, 0.01104939f, 0.04023961f, 0.11419432f, 
    0.29522699f, 0.02628860f, 0.20790629f, 0.09827221f, 0.00129709f, -0.09383564f, 0.11786507f, 0.03546871f, 
    0.04292556f, 0.19609800f, -0.04645958f, 0.05489080f, -0.03100651f, -0.14764187f, 0.12662111f, 0.13429898f, 
    0.00140706f, 0.01018256f, 0.01646760f, 0.03782307f, 0.10324834f, -0.07600971f, -0.03412058f, -0.07073034f, 
    -0.03504109f, 0.14612480f, -0.17368537f, -0.12173947f, -0.04532265f, 0.01043132f, -0.00564352f, 0.02283044f, 
    -0.13897467f, 0.13105974f, -0.12335651f, 0.03881577f, 0.23747961f, 0.05661633f, 0.13708165f, -0.04739689f, 
    -0.00362015f, -0.03166736f, 0.01792884f, 0.01974627f, 0.10352851f, 0.05965328f, -0.02102984f, 0.18771632f, 
    0.29260546f, -0.19391546f, -0.19406918f, -0.00962596f, -0.01845562f, -0.03397749f, -0.10936043f, -0.02864139f, 
    0.04021488f, -0.09187109f, 0.04976853f, 0.01631396f, -0.01611196f, 0.10129349f, 0.10145839f, 0.05318219f, 
    -0.06664798f, -0.11673491f, 0.00485164f, -0.04065993f, 0.02095486f, -0.04174222f, 0.08945987f, 0.13266377f, 
    -0.02515042f, 0.00414446f, 0.10962714f, -0.04797090f, 0.04835973f, -0.01582276f, -0.03175264f, -0.00526590f, 
    -0.11786571f, 0.03888212f, 0.14244452f, -0.04468387f, 0.12350527f, 0.09076645f, -0.09977911f, 0.10673092f, 
    0.15064271f, -0.00481036f, -0.00557094f, 0.02839506f, -0.00020196f, 0.03860903f, 0.04483086f, -0.04334506f, 
    -0.00144147f, -0.00768501f, 0.03537345f, -0.09522635f, 0.07586305f, 0.05661632f, -0.01031138f, -0.11127285f, 
    0.03618472f, 0.01059143f, 0.02642681f, -0.09526012f, 0.20909919f, -0.12701590f, -0.22970992f, -0.02770217f, 
    -0.01757666f, -0.02215770f, -0.19858810f, -0.05011277f, -0.03474161f, -0.02158178f, -0.00143750f, -0.04380206f, 
    0.14378600f, 0.24349086f, -0.02849239f, 0.12228495f, 0.03812846f, -0.03980485f, -0.02405895f, 0.15394388f, 
    0.02595615f, 0.01970310f, 0.03657094f, 0.06481314f, 0.49590200f, -0.16257992f, 0.07629361f, 0.08732913f, 
    0.10097314f, 0.08734532f, 0.03039853f, 0.05436041f, -0.01880480f, -0.04949275f, 0.13505191f, 0.01039565f, 
    0.02727093f, 0.11162221f, -0.00129041f, -0.11669737f, -0.03651881f, 0.09822450f, -0.06574427f, 0.03922740f, 
    -0.06937853f, -0.05783441f, 0.02267001f, 0.00297057f, -0.00334974f, 0.03020211f, 0.09824750f, 0.16754287f, 
    0.01693844f, 0.06007894f, 0.08796029f, 0.11080812f, 0.06788552f, -0.03295904f, -0.00674569f, -0.02688127f, 
    0.13799603f, 0.15598695f, -0.21478660f, 0.14480546f, 0.10921881f, -0.00006672f, 0.04353106f, 0.00530363f, 
    -0.04456755f, 0.01333650f, 0.06728077f, -0.02027981f, -0.27111328f, 0.17518999f, -0.10845441f, -0.21575522f, 
    0.00095457f, -0.10642826f, -0.04919767f, -0.12561159f, 0.07108879f, 0.03972731f, -0.06805550f, -0.00096250f, 
    0.16916165f, -0.09040427f, 0.22706757f, 0.04901358f, 0.08640414f, -0.05674540f, 0.04310820f, 0.09820460f, 
    0.00116963f, 0.04415797f, 0.02410298f, -0.03181195f, -0.13811038f, 0.03213190f, -0.08906737f, 0.18076181f, 
    0.10279649f, -0.02305887f, -0.00057023f, -0.14748828f, 0.02935761f, 0.04873401f, 0.01155787f, 0.03129913f, 
    -0.02362977f, -0.03519496f, -0.04316256f, 0.01468574f, 0.01934560f, 0.03006760f, -0.00104846f, 0.01634948f, 
    -0.03127707f, 0.01427038f, -0.01901182f, 0.00781243f, 0.01491457f, 0.02404580f, 0.02546677f, 0.00407438f, 
    0.01074133f, 0.02228472f, -0.00560853f, -0.03969087f, -0.01393304f, 0.00126342f, 0.00063120f, 0.02559572f, 
    0.02121512f, 0.00816922f, 0.02796496f, -0.03530134f, -0.01505830f, -0.01024619f, 0.01737445f, -0.02895743f, 
    -0.02280173f, -0.00584902f, -0.02250155f, -0.01726703f, 0.02678579f, 0.02709802f, -0.01058300f, -0.00813008f, 
    -0.02107926f, -0.03693309f, 0.01905652f, -0.03670593f, -0.01698209f, 0.03149154f, -0.01384472f, -0.01739700f, 
    0.00115293f, -0.02201841f, 0.03326700f, -0.00436363f, -0.01704661f, -0.03999138f, 0.00436774f, -0.03846660f, 
    -0.00427561f, 0.00390352f, -0.03391574f, 0.01596922f, 0.00828085f, -0.02511209f, 0.02157406f, 0.00414289f, 
    0.02951064f, -0.00346507f, 0.00593413f, 0.02503004f, 0.01186924f, -0.03657081f, -0.01231478f, -0.02954348f, 
    -0.00697316f, -0.00389592f, 0.00808943f, 0.02830257f, -0.03411191f, 0.01992259f, -0.01092676f, 0.00448621f, 
    0.00477993f, -0.02127006f, -0.03093976f, -0.01343037f, -0.00003362f, -0.01013577f, 0.02351449f, -0.04478155f, 
    -0.04190204f, 0.01741726f, -0.00520059f, 0.01340547f, 0.02184742f, 0.03289915f, -0.00684597f, -0.01866593f, 
    0.03284518f, -0.00099583f, 0.03264036f, -0.02608840f, -0.03508534f, -0.02297252f, -0.03061913f, 0.00121733f, 
    0.01906297f, -0.00292582f, -0.03769201f, 0.01613214f, 0.00721949f, -0.00520816f, 0.02766480f, -0.04347882f, 
    -0.02396861f, 0.01793004f, -0.02529594f, -0.02864375f, 0.01387286f, -0.02096602f, -0.03582081f, 0.00224404f, 
    -0.01339346f, 0.00809734f, 0.01067731f, -0.00226405f, -0.01630451f, -0.02911566f, -0.04048267f, 0.01852280f, 
    0.01784703f, 0.02039445f, -0.00410564f, -0.00599901f, 0.03084149f, 0.00508312f, -0.02635928f, -0.03402716f, 
    0.00202033f, -0.00203853f, -0.02183372f, -0.00393321f, 0.01355409f, -0.01379219f, -0.00899145f, -0.00812813f, 
    0.00646202f, -0.00187735f, -0.02798056f, -0.02016106f, -0.01450146f, 0.00815570f, 0.00861559f, -0.00795638f, 
    0.02085911f, -0.01829156f, 0.01270122f, 0.02187025f, -0.03331500f, -0.03183699f, -0.00434833f, -0.00206543f, 
    0.02750786f, -0.03562758f, -0.00528750f, 0.02993548f, -0.01121689f, 0.02023399f, -0.02174725f, -0.00845128f, 
    -0.02373064f, -0.01332186f, -0.03045249f, -0.04090866f, 0.00686071f, -0.01736696f, -0.00584068f, -0.01871853f, 
    -0.04028907f, 0.01346841f, -0.03803576f, -0.04164862f, 0.02605849f, -0.02925983f, -0.01984439f, -0.01655203f, 
    0.00372340f, -0.03391951f, -0.00163959f, -0.01993465f, -0.00911976f, 0.00099533f, 0.00891350f, 0.03130105f, 
    0.00926799f, -0.02334790f, -0.02764046f, -0.02380028f, -0.03226847f, -0.03297509f, 0.00686824f, 0.00577831f, 
    -0.00976780f, 0.00731819f, -0.02718579f, 0.02942021f, 0.00068574f, 0.00660545f, -0.03038033f, 0.00286302f, 
    0.00713730f, -0.03344591f, 0.02464207f, -0.02585233f, -0.02899149f, -0.02444049f, -0.01068050f, 0.00986384f, 
    0.03152675f, -0.00482679f, 0.00303080f, -0.03971835f, 0.01293706f, 0.02170947f, -0.02960461f, -0.00535683f, 
    0.01659132f, -0.02507221f, -0.02887300f, -0.00246716f, -0.01899497f, 0.00556194f, -0.02566586f, 0.03339983f, 
    0.02313862f, -0.01188466f, -0.01463678f, 0.02553795f, -0.02766229f, -0.01325916f, 0.02343693f, -0.02611518f, 
    -0.01956485f, -0.01998026f, -0.02496296f, 0.01274116f, -0.02509445f, -0.00907591f, 0.00130005f, -0.03637020f, 
    0.02458999f, 0.01888843f, -0.02708633f, -0.00183013f, -0.03806248f, -0.01528004f, -0.04088148f, 0.01917662f, 
    -0.00089688f, 0.01262474f, 0.00618799f, -0.00931033f, -0.00098070f, 0.02251178f, 0.03027764f, -0.01945306f, 
    -0.01738965f, -0.03899757f, 0.00497460f, -0.01110222f, -0.00688763f, -0.01680696f, -0.00978246f, -0.01671731f, 
    0.01244165f, 0.01890436f, -0.02397596f, -0.00606780f, 0.00186251f, 0.02644155f, -0.02635416f, -0.01836043f, 
    0.02277058f, 0.01461846f, -0.03094278f, -0.01007043f, -0.01102260f, -0.02994085f, -0.00900553f, -0.00376581f, 
    -0.04434862f, -0.00538186f, 0.00724570f, 0.01979994f, -0.03018335f, 0.02680775f, 0.00542340f, -0.04003527f, 
    0.01997644f, 0.02211286f, 0.00087262f, 0.00420600f, -0.00077841f, -0.00863307f, -0.00812841f, 0.02572557f, 
    -0.04699786f, -0.01798350f, -0.00489755f, -0.02762668f, 0.00565115f, -0.01291914f, 0.00637805f, 0.00056338f, 
    -0.01787712f, -0.00730810f, 0.03822337f, -0.01957766f, -0.01279752f, -0.02540799f, 0.01644128f, -0.03326586f, 
    -0.00606418f, -0.03179407f, -0.01337069f, 0.02453214f, 0.02445181f, -0.02174072f, 0.01540073f, 0.02063612f, 
    -0.02018476f, 0.02238163f, -0.01633064f, -0.01545219f, -0.04126813f, 0.02722157f, 0.02523410f, -0.03056510f, 
    -0.00576417f, -0.01536668f, 0.02832651f, -0.02364178f, 0.00364480f, -0.03228356f, 0.00907348f, -0.04034493f, 
    0.00725466f, 0.00785173f, -0.00373346f, -0.01580286f, -0.02905487f, 0.02744068f, -0.03475209f, -0.02456546f, 
    -0.02370240f, 0.01412102f, -0.00368239f, 0.01351264f, -0.03877450f, -0.03193471f, 0.00125390f, 0.02722550f, 
    -0.02251307f, -0.00364234f, 0.01641452f, 0.00367373f, 0.02129680f, -0.00403812f, -0.00027015f, -0.03538574f, 
    0.02139979f, 0.00691084f, -0.02141277f, -0.03798786f, -0.02851624f, 0.01893948f, 0.02243966f, 0.00664862f, 
    -0.00566094f, 0.00543842f, -0.00910402f, 0.00836296f, 0.00440672f, -0.02237092f, 0.01108750f, -0.02836947f, 
    -0.00393630f, -0.02978512f, -0.01726870f, 0.02533060f, 0.00327823f, -0.03747090f, -0.03332330f, -0.03794284f, 
    0.01180183f, -0.00749357f, -0.03542959f, 0.01788363f, -0.04403448f, 0.00135809f, -0.02736480f, -0.02703372f, 
    0.02864430f, -0.02828738f, 0.00003234f, -0.00785186f, -0.03317827f, -0.01024067f, 0.02712161f, -0.02882117f, 
    -0.00627026f, -0.03891979f, -0.00382536f, -0.04521408f, 0.00453557f, 0.01146638f, -0.01929566f, 0.01490181f, 
    0.00749608f, 0.02466474f, 0.00608191f, 0.02051298f, -0.01791484f, -0.03956788f, 0.02549189f, 0.01547452f, 
    -0.01840680f, 0.01249735f, 0.02266157f, 0.01685773f, 0.02246694f, -0.01971813f, 0.00309298f, -0.00840483f, 
    -0.02336466f, -0.02439773f, 0.00597572f, 0.00310346f, -0.00171369f, -0.00873913f, 0.02893920f, -0.03874195f, 
    0.00410964f, -0.03262255f, -0.01213626f, -0.00675203f, -0.01536723f, 0.02320329f, -0.01712658f, -0.00757923f, 
    -0.01332746f, 0.02384128f, 0.01281543f, 0.00375573f, 0.02210054f, -0.01042284f, 0.00812604f, -0.00549902f, 
    -0.01142713f, -0.01214940f, 0.01490125f, 0.00929896f, -0.01762302f, -0.03610248f, -0.00040998f, 0.01169915f, 
    -0.02871484f, 0.02480659f, 0.00195499f, -0.00632889f, 0.01049881f, 0.02691933f, 0.00676606f, -0.01513139f, 
    -0.02673497f, -0.03776457f, 0.00976137f, -0.00930166f, 0.03217601f, 0.01093970f, 0.00833426f, -0.01324618f, 
    0.01466789f, -0.00964349f, -0.01455141f, -0.00980442f, -0.04377013f, -0.02884995f, -0.00138393f, -0.01819797f, 
    0.01443069f, 0.02093033f, 0.00803061f, -0.03439065f, -0.01613811f, 0.00683384f, 0.01915065f, 0.01385440f, 
    -0.01268339f, -0.02473421f, 0.02486972f, -0.01657948f, 0.02641824f, 0.03083794f, 0.00401364f, -0.01644208f, 
    -0.03507591f, -0.02412952f, -0.03045045f, -0.03530965f, 0.00387169f, 0.02661527f, -0.01666758f, 0.01879417f, 
    0.02472971f, 0.00121879f, 0.02408130f, -0.00599733f, -0.02182502f, 0.02920813f, 0.00909035f, -0.01740643f, 
    -0.00531608f, -0.00902537f, -0.03090329f, 0.00168300f, 0.02069631f, 0.01054548f, -0.03962703f, -0.02334736f, 
    0.00946528f, -0.01030065f, -0.00905817f, 0.02927603f, -0.01061358f, 0.00951558f, -0.00140516f, 0.00632410f, 
    -0.02507306f, -0.04109852f, -0.01768072f, -0.00735093f, 0.02064108f, 0.01366338f, -0.01111671f, -0.03043512f, 
    0.00321900f, -0.00514157f, 0.01812281f, 0.00660908f, 0.02231281f, -0.03520464f, -0.00142061f, -0.01395673f, 
    0.02834131f, -0.02043974f, -0.01716582f, 0.00520057f, 0.01543751f, -0.01101081f, 0.03308321f, -0.00124766f, 
    0.01671279f, -0.03788323f, 0.02834262f, 0.00452570f, -0.01297063f, -0.01460332f, 0.01402252f, -0.03057616f, 
    -0.03240148f, -0.00894115f, 0.00544930f, 0.02145797f, -0.03177088f, 0.03031557f, 0.02657870f, -0.01090180f, 
    0.02600383f, -0.01067397f, -0.03427935f, -0.00841383f, 0.00840489f, 0.01177082f, 0.03053790f, 0.02435163f, 
    0.00618393f, 0.02124606f, -0.03178015f, -0.04072572f, -0.02515292f, -0.00303566f, -0.01836413f, 0.00201868f, 
    0.03607986f, 0.02375269f, -0.01463053f, -0.03144146f, -0.00368723f, -0.01626439f, 0.02142758f, -0.02365976f, 
    -0.02051010f, 0.00545316f, -0.00307750f, -0.01292342f, 0.00015236f, 0.02043199f, -0.03087280f, -0.02468983f, 
    -0.00896770f, 0.00646260f, 0.01614722f, -0.00529505f, 0.01464858f, -0.02422814f, -0.02141517f, -0.00236219f, 
    0.01059197f, -0.02337391f, 0.02331241f, -0.02499612f, -0.00511125f, -0.02949058f, -0.02126310f, 0.02358265f, 
    -0.03141980f, -0.01067708f, -0.01562268f, 0.01999455f, -0.02836200f, -0.04210028f, -0.01368061f, -0.00744266f, 
    0.01843595f, 0.01113700f, 0.01055665f, 0.02656521f, -0.02026757f, -0.03961395f, -0.00326662f, -0.01692968f, 
    0.01752995f, -0.00743553f, -0.01259093f, -0.01789123f, -0.00334504f, -0.01881484f, -0.02503741f, -0.02093003f, 
    0.01187902f, 0.03634815f, -0.02559738f, 0.03024178f, -0.01415155f, 0.00685725f, 0.00193081f, 0.00866526f, 
    -0.03053655f, 0.01560334f, 0.01020964f, -0.00445301f, -0.04135513f, 0.01793480f, -0.01784245f, 0.02754766f, 
    -0.01526103f, 0.01350118f, -0.02360097f, -0.01471054f, 0.01458682f, 0.02594625f, -0.00847786f, -0.00855092f, 
    -0.02757044f, 0.01606916f, 0.03217027f, -0.01672184f, -0.02995572f, 0.01919521f, -0.02178922f, 0.01258645f, 
    0.02173560f, -0.01077443f, 0.00140498f, -0.02276899f, 0.01783463f, -0.01316611f, -0.01561928f, 0.01278071f, 
    0.00246528f, 0.01647552f, 0.02050404f, 0.01594862f, 0.01100068f, 0.01639284f, -0.01744409f, -0.02659021f, 
    -0.03608232f, -0.00580293f, -0.03366630f, 0.02982967f, -0.03033254f, -0.00867168f, -0.01301255f, -0.03985007f, 
    0.01827880f, 0.01795998f, 0.01421025f, 0.01573424f, -0.00934225f, 0.00542198f, 0.00183717f, -0.02740498f, 
    0.02512044f, -0.03345288f, -0.00867756f, -0.02194608f, 0.01776020f, 0.00596814f, -0.01182247f, 0.00679676f, 
    0.01702691f, -0.01150454f, -0.01758032f, -0.03937445f, -0.02203557f, -0.01618459f, -0.00962224f, -0.01835440f, 
    -0.00015945f, 0.00076306f, 0.02394035f, 0.01410340f, -0.01640294f, -0.00768800f, 0.01768779f, 0.02127363f, 
    0.01894833f, 0.02231637f, -0.01641477f, 0.01136228f, -0.03154032f, 0.00373617f, -0.02397337f, -0.03994229f, 
    -0.01225006f, -0.03141149f, 0.00259424f, 0.02098659f, 0.01077206f, -0.02356830f, 0.01257479f, 0.01183447f, 
    -0.02057563f, -0.01104025f, -0.03667442f, -0.01525221f, -0.02402143f, 0.00235180f, 0.03902895f, 0.00786113f, 
    -0.04026421f, 0.01369907f, 0.00986366f, 0.01218788f, -0.01235070f, -0.00459442f, -0.02512828f, -0.04288628f, 
    -0.17011330f, 0.10287163f, 0.06679577f, -0.02307856f, 0.01301210f, 0.09292363f, 0.00911893f, 0.01531632f, 
    0.07877398f, 0.05107054f, 0.00751026f, -0.00246052f, 0.06130758f, 0.13294001f, 0.15669800f, -0.14131448f, 
    0.02198286f, 0.06558760f, -0.03367458f, 0.06998657f, 0.00876246f, 0.06734099f, 0.02315703f, -0.03908966f, 
    0.22452417f, 0.08572526f, -0.15901561f, 0.18663572f, -0.08895832f, 0.01223979f, 0.06719309f, -0.00685855f, 
    0.07743426f, 0.05649300f, 0.07406683f, 0.08234260f, -0.09613799f, 0.02220465f, -0.13887405f, 0.15573584f, 
    0.02181518f, 0.01708469f, -0.06365169f, 0.02656633f, 0.01545574f, -0.01818467f, 0.00393160f, 0.01308032f, 
    -0.04974620f, 0.06906056f, -0.02462059f, -0.02662850f, 0.07802909f, -0.11264803f, 0.06571799f, -0.00928339f, 
    0.09932618f, 0.02411203f, 0.04052190f, -0.01816340f, -0.02195899f, -0.05943898f, -0.02542803f, 0.11123004f, 
    0.07326555f, -0.06983236f, 0.09246267f, 0.02752155f, 0.07194234f, 0.05632647f, -0.00275566f, -0.00940274f, 
    -0.10110413f, -0.15735641f, -0.17869188f, -0.00334728f, 0.06815031f, 0.03155765f, 0.06370249f, 0.02642761f, 
    0.05943122f, -0.05465836f, 0.03996104f, -0.01565537f, 0.26231840f, 0.22388405f, -0.04583145f, 0.04708738f, 
    0.11540687f, 0.06892449f, -0.08677738f, -0.02562458f, -0.00323940f, 0.04041335f, 0.04446964f, 0.05049693f, 
    -0.04283160f, -0.08930235f, 0.22373988f, -0.00614044f, 0.00905882f, -0.01394412f, 0.00837173f, 0.04067159f, 
    -0.00978613f, 0.01668597f, 0.07310390f, 0.04448589f, 0.15709156f, -0.00274674f, 0.19534962f, -0.04575244f, 
    0.03502525f, -0.00364241f, 0.06266000f, -0.01425495f, 0.05588831f, 0.02077159f, 0.05746463f, 0.00820380f, 
    -0.15069897f, 0.01953032f, -0.06001770f, -0.06838389f, 0.10545351f, 0.07207766f, 0.04436158f, 0.06115215f, 
    0.06307074f, 0.04518570f, -0.04312707f, 0.05880496f, 0.01228759f, -0.16188458f, -0.02503411f, 0.05016302f, 
    0.01155260f, 0.12051384f, 0.04598841f, 0.01369900f, 0.01077149f, 0.03420455f, 0.02337114f, 0.12023918f, 
    -0.03652267f, 0.16514547f, -0.04210123f, 0.04451163f, 0.01529013f, 0.03820563f, 0.07993426f, -0.00168337f, 
    0.08408555f, 0.11720136f, 0.12240872f, 0.07699496f, 0.27681348f, -0.01627215f, 0.03750856f, 0.22338280f, 
    0.08165612f, 0.09539749f, 0.02424124f, 0.09756520f, 0.05469211f, 0.03914477f, 0.03290417f, 0.09129796f, 
    0.11742480f, 0.05800764f, 0.08061127f, -0.10253884f, -0.03342900f, -0.04647231f, -0.07428036f, 0.08379931f, 
    -0.00180984f, -0.04127549f, 0.07988835f, -0.09790749f, 0.13485909f, 0.08115368f, 0.00188480f, 0.06071851f, 
    0.04473834f, 0.01838686f, -0.05146255f, 0.01689393f, -0.01572220f, 0.00891696f, 0.04595862f, 0.11363386f, 
    0.05260832f, -0.00908458f, 0.04870776f, 0.03279922f, 0.06971066f, 0.01354367f, 0.02097382f, 0.04735606f, 
    -0.02040890f, 0.04105806f, 0.04431698f, 0.18533497f, 0.01399127f, 0.08138850f, -0.08231363f, 0.05401406f, 
    -0.01962197f, 0.01119957f, -0.05292372f, -0.05831761f, 0.06856385f, 0.06888914f, 0.02925075f, 0.05330938f, 
    -0.14873758f, 0.02664024f, 0.13003211f, -0.08854593f, 0.02105149f, 0.04298452f, 0.08711927f, -0.00561122f, 
    0.08779192f, 0.01723624f, 0.03419264f, 0.02058601f, -0.16423678f, 0.12454925f, -0.02567401f, 0.21361290f, 
    -0.06875727f, -0.05527363f, -0.00826468f, -0.00463254f, 0.00585265f, 0.03431493f, 0.02414886f, 0.04964900f, 
    0.03800047f, -0.06159800f, 0.09294852f, 0.12538360f, 0.01599780f, 0.04265206f, 0.09164844f, 0.09082487f, 
    -0.04501624f, 0.02734897f, 0.09201490f, 0.09249451f, -0.27805617f, 0.15698427f, -0.00216169f, 0.08988357f, 
    0.06087054f, 0.07337952f, 0.04784167f, -0.02035969f, -0.03709417f, -0.02722923f, 0.02427482f, 0.07441510f, 
    0.13132097f, -0.04612342f, -0.15134060f, 0.09430307f, -0.01928932f, 0.07077169f, 0.01371233f, -0.01027703f, 
    0.01511101f, 0.03583326f, 0.05463828f, -0.02329600f, -0.27690315f, 0.05846733f, 0.08795108f, 0.09495161f, 
    0.05341781f, 0.08319708f, 0.11237346f, -0.05751806f, -0.07917595f, -0.00216884f, 0.08010381f, -0.03232402f, 
    -0.05919702f, -0.08519054f, -0.11407430f, 0.09587086f, 0.10362642f, -0.03342319f, 0.01865801f, 0.00144953f, 
    -0.02110540f, 0.10610993f, 0.03844142f, 0.07531052f, -0.30479431f, 0.24709973f, 0.01633517f, 0.00566881f, 
    -0.02666400f, -0.01160891f, -0.06522293f, 0.06926927f, 0.08642582f, -0.01848402f, 0.12250398f, -0.03757203f, 
    -0.16559266f, -0.05379602f, -0.17750168f, 0.01403638f, 0.10716339f, 0.04720079f, 0.00121022f, -0.01567680f, 
    0.01778894f, 0.05333745f, -0.05171247f, -0.09948850f, -0.04166371f, 0.00552158f, 0.06179131f, 0.09052314f, 
    0.06503131f, 0.06386303f, 0.08748639f, 0.03160482f, 0.01362157f, -0.01935302f, 0.10184714f, 0.03926720f, 
    -0.21577285f, 0.21996637f, 0.05278873f, 0.00524190f, 0.13865925f, 0.04322242f, 0.12592818f, 0.05078719f, 
    0.02729899f, 0.06195430f, 0.06997624f, 0.14123645f, 0.25302693f, 0.06565140f, 0.08445789f, 0.08496782f, 
    0.04835153f, -0.05435316f, 0.17781085f, 0.09838239f, 0.01766466f, 0.04278846f, 0.00427614f, 0.15205836f, 
    0.14511374f, 0.19632284f, 0.03166794f, 0.04484906f, 0.07657744f, 0.05546649f, 0.09919700f, 0.04364419f, 
    0.09409431f, -0.00660883f, 0.00390118f, 0.06882276f, 0.08517624f, -0.02757406f, -0.08245660f, -0.03813307f, 
    -0.01331027f, 0.00366386f, -0.01689515f, 0.00910180f, -0.01081385f, 0.01445039f, 0.02754080f, 0.01540839f, 
    0.08704545f, 0.03464701f, 0.21881489f, 0.10283840f, -0.01118335f, 0.08875082f, 0.04644774f, 0.04447045f, 
    0.03729012f, 0.01127643f, 0.19700548f, 0.00254521f, 0.13376513f, 0.04645975f, 0.00307738f, 0.29686248f, 
    0.05037261f, -0.02977572f, -0.02395249f, 0.08059803f, 0.01984646f, 0.02925722f, -0.00623940f, 0.06525542f, 
    -0.03308599f, 0.19414669f, 0.01439238f, 0.04285062f, 0.03027556f, 0.09801187f, 0.07201410f, -0.03084253f, 
    0.04230103f, -0.01064970f, 0.03365447f, 0.02940876f, -0.00412712f, -0.03589586f, -0.08802583f, 0.09054264f, 
    0.02206101f, 0.02831952f, 0.04280694f, 0.05875104f, 0.07103390f, 0.05225985f, 0.02057318f, 0.06470515f, 
    -0.28243592f, 0.08396376f, -0.03689504f, 0.09210079f, 0.02846135f, -0.05289014f, 0.18766561f, 0.02130972f, 
    0.06676217f, -0.03832018f, -0.00368381f, -0.01563029f, 0.06451305f, 0.10188566f, 0.02401452f, 0.07124045f, 
    0.12971127f, -0.00117868f, 0.00000458f, 0.09868221f, 0.06310028f, 0.06010412f, 0.12033179f, 0.13737439f, 
    0.14794821f, 0.20668279f, 0.15279302f, 0.13308841f, 0.04785946f, -0.00428770f, 0.10202715f, 0.09569949f, 
    0.00097445f, 0.03384123f, 0.15804707f, 0.09471392f, -0.02185433f, 0.11026388f, -0.00970351f, 0.19985299f, 
    0.02351398f, 0.08263348f, -0.04059938f, 0.02797753f, 0.14742842f, 0.09424879f, 0.08737531f, 0.02932469f, 
    0.04743042f, 0.10918489f, -0.03416935f, 0.02808100f, 0.03814277f, 0.06956425f, 0.01675534f, -0.07307083f, 
    -0.06069923f, 0.05947147f, 0.01075299f, 0.03565929f, 0.37629732f, 0.16304934f, 0.16589977f, 0.13229701f, 
    0.06278456f, 0.03642465f, 0.00133615f, 0.08374439f, 0.05322520f, 0.05164497f, 0.04800363f, 0.06287736f, 
    0.13959970f, 0.22986671f, -0.03268399f, 0.17204009f, 0.15476862f, -0.04373287f, -0.01599885f, -0.06224532f, 
    -0.01060582f, 0.03574809f, -0.05020788f, 0.04446499f, 0.15972252f, -0.00236382f, 0.07422131f, -0.15903391f, 
    -0.04400411f, -0.03109749f, 0.09589130f, 0.01381527f, -0.06504609f, -0.02042728f, 0.01755340f, -0.05118378f, 
    0.04753697f, 0.14106812f, 0.01691167f, -0.04127568f, -0.06205678f, -0.03685243f, 0.13402319f, 0.06622908f, 
    -0.06176928f, 0.02873392f, -0.05733415f, 0.02966893f, 0.06264263f, 0.10697623f, 0.03050167f, -0.10457520f, 
    0.08151439f, -0.03603250f, 0.06355819f, 0.12261811f, 0.00539231f, -0.00839906f, 0.00572107f, -0.11011382f, 
    -0.11649955f, 0.00863011f, 0.06414726f, 0.06162940f, 0.09841608f, 0.20005153f, -0.01358793f, -0.09608354f, 
    0.02684995f, -0.12701848f, 0.13649635f, -0.06233907f, 0.10955963f, 0.17339517f, 0.06435035f, -0.00305890f, 
    0.08348646f, 0.05418601f, -0.01305087f, -0.09467059f, 0.00065420f, 0.07700408f, 0.07381827f, 0.01579015f, 
    0.04210772f, 0.09259601f, -0.01781483f, 0.07875550f, 0.03188754f, -0.02581020f, 0.03480788f, -0.02064147f, 
    0.14725718f, -0.04733228f, 0.10007702f, -0.00022549f, -0.10910624f, -0.04441271f, -0.18169646f, 0.05517945f, 
    0.04766631f, 0.02725398f, 0.08688735f, 0.05211306f, -0.06200722f, 0.04919038f, 0.03375059f, 0.00093400f, 
    -0.09283309f, 0.19085777f, 0.28591427f, 0.09526058f, 0.03281319f, 0.00999536f, 0.07960238f, 0.06610096f, 
    -0.03703880f, 0.07424936f, -0.07067142f, 0.10573164f, -0.05434034f, 0.05742767f, -0.05082603f, 0.13710009f, 
    0.14086398f, 0.09760991f, 0.03443071f, 0.02832957f, -0.00265147f, -0.01696411f, 0.01441227f, -0.05304298f, 
    0.13298748f, 0.07896269f, -0.10128702f, 0.11418396f, 0.00336391f, 0.12424704f, 0.06437637f, 0.01121161f, 
    0.18827938f, 0.06921712f, -0.17018776f, 0.09932073f, 0.04559720f, -0.02930419f, 0.03059858f, -0.08006335f, 
    -0.08514526f, 0.01863432f, 0.05151866f, -0.02048797f, 0.04510078f, 0.06994929f, -0.01064851f, 0.04082496f, 
    0.04037378f, 0.00365973f, -0.04384881f, 0.10399783f, -0.02186044f, -0.01351606f, 0.04039110f, 0.09225302f, 
    0.06957132f, 0.01374294f, 0.01987338f, 0.06439172f, -0.07045460f, 0.00868969f, 0.27637771f, 0.26606026f, 
    0.03410484f, 0.03135725f, 0.07757825f, 0.05328247f, 0.04819551f, 0.02532184f, 0.04780261f, 0.14532986f, 
    0.04923468f, 0.01580793f, -0.10696840f, 0.02474254f, 0.02546446f, 0.05021660f, 0.02029034f, -0.07678387f, 
    0.01343019f, 0.05501311f, -0.01380275f, 0.02527791f, -0.21939740f, 0.26453727f, 0.02489299f, 0.11632408f, 
    -0.01498963f, 0.02725512f, 0.01023546f, 0.00952655f, 0.07311928f, 0.04467582f, -0.09836445f, 0.04704652f, 
    0.02380297f, -0.02156270f, -0.04560417f, 0.20462525f, 0.04136492f, -0.02242307f, 0.06934148f, 0.01035383f, 
    0.07277713f, 0.02497525f, 0.01064602f, 0.02657740f, 0.00161397f, 0.04655351f, -0.03077971f, 0.04684072f, 
    0.08883080f, -0.01324280f, 0.02019603f, -0.04749725f, 0.04795395f, 0.07492109f, 0.08447853f, 0.08485460f, 
    -0.04721403f, -0.01330184f, 0.04311302f, -0.00025039f, -0.06108546f, -0.03236556f, -0.02266557f, -0.05829253f, 
    0.07028497f, 0.04425682f, -0.04162145f, -0.02019894f, 0.18230055f, -0.02096319f, 0.07243743f, 0.33985654f, 
    0.01749037f, 0.05149003f, 0.01682661f, 0.04047963f, 0.01592203f, 0.01956887f, 0.04273671f, 0.00545959f, 
    -0.07312378f, 0.22623049f, 0.01066920f, 0.11186405f, -0.01399042f, 0.09738267f, 0.06227391f, 0.02546572f, 
    -0.03277181f, -0.03437317f, 0.02976459f, 0.03305686f, 0.19148259f, -0.00426770f, 0.18602689f, -0.10686210f, 
    -0.00215267f, 0.00473867f, -0.07841914f, 0.04475004f, 0.05791320f, 0.08424962f, 0.07080557f, -0.01967843f, 
    0.02022157f, 0.01034528f, -0.03810639f, 0.02122219f, -0.04071463f, -0.01967844f, -0.03405760f, -0.02067977f, 
    -0.04327302f, 0.01666067f, 0.00523555f, 0.00152092f, 0.02171212f, 0.00359056f, -0.01313635f, 0.03439775f, 
    -0.00902511f, -0.00465985f, 0.01882573f, 0.01941919f, -0.00540373f, 0.01209945f, 0.02469824f, 0.00400769f, 
    0.01305131f, -0.01188730f, -0.00590242f, 0.00000332f, -0.03911811f, -0.04154523f, -0.00354145f, -0.02268028f, 
    -0.00620779f, 0.02105661f, 0.00702400f, -0.03696088f, 0.01738151f, -0.03101730f, -0.02980088f, -0.03044589f, 
    -0.02157411f, -0.03934434f, 0.00213653f, -0.02823379f, -0.04292192f, -0.01920976f, -0.02757499f, -0.04065795f, 
    0.00551786f, 0.01241269f, -0.02470425f, -0.00037029f, 0.02499132f, 0.02127004f, 0.00343125f, 0.01606492f, 
    -0.03348194f, 0.02597662f, -0.00217903f, 0.02104530f, 0.00745013f, 0.00314010f, -0.02462948f, -0.01110059f, 
    -0.02659337f, 0.01181298f, 0.02360483f, 0.02745923f, -0.02415366f, -0.03461115f, 0.02460804f, -0.03269267f, 
    0.00575510f, -0.03293342f, 0.02221917f, 0.00709708f, -0.00447287f, -0.01667067f, 0.01632758f, -0.01799815f, 
    0.02067809f, 0.02439621f, 0.01987181f, -0.03904188f, 0.00616349f, 0.01334507f, -0.02567570f, -0.02912926f, 
    0.01774278f, 0.00045193f, -0.03032353f, 0.02734528f, -0.02251719f, 0.01903075f, 0.02658037f, -0.00996339f, 
    -0.03655471f, -0.04172254f, 0.01528436f, 0.03182903f, -0.00825945f, -0.01086467f, -0.03993631f, 0.02119697f, 
    0.02175735f, 0.01356210f, 0.02973295f, -0.01738472f, 0.01686258f, -0.03034914f, -0.04143727f, -0.03579549f, 
    -0.02078667f, -0.02900692f, 0.00935313f, -0.03257204f, 0.00560008f, 0.01230985f, -0.01220877f, 0.00267855f, 
    -0.01328905f, -0.02392518f, 0.01864669f, -0.01346924f, -0.02110131f, 0.00538118f, -0.00062115f, 0.01552158f, 
    0.01368232f, -0.03870502f, 0.00684986f, 0.01402580f, 0.00618175f, -0.01527060f, -0.02173401f, -0.04145983f, 
    -0.00221691f, -0.02048296f, -0.03891695f, -0.01365726f, 0.01015804f, 0.03187003f, 0.01954174f, -0.02049337f, 
    0.00683310f, 0.00632166f, -0.04085178f, -0.04055492f, -0.03528564f, 0.00794378f, -0.00706029f, 0.01713028f, 
    -0.03533710f, -0.01584689f, -0.01056505f, 0.00803425f, 0.00419204f, -0.00816488f, 0.02229330f, 0.02136911f, 
    -0.01460751f, -0.00799658f, -0.00634242f, 0.01391112f, 0.01932179f, 0.01239795f, -0.01881535f, 0.01942037f, 
    0.02238890f, -0.01334511f, 0.01472035f, -0.01334803f, -0.04194250f, -0.00026441f, -0.01835594f, -0.04345367f, 
    -0.02386918f, -0.00149980f, -0.03883991f, -0.02730291f, 0.01394555f, -0.00180897f, 0.00375290f, -0.01668335f, 
    -0.04268087f, 0.01254541f, -0.02810716f, 0.03248041f, -0.02367701f, -0.00236888f, 0.00267293f, -0.03534097f, 
    0.00063635f, -0.00390790f, -0.03922752f, 0.00531412f, -0.01464606f, 0.00425154f, -0.02411906f, 0.02060087f, 
    -0.00293777f, 0.01732875f, 0.02994303f, 0.01340484f, 0.01433792f, 0.01373611f, -0.03440480f, -0.02360427f, 
    -0.02806874f, 0.01827863f, 0.00882523f, -0.04276770f, 0.01185542f, -0.00070983f, -0.02486211f, 0.00696762f, 
    -0.04447692f, -0.03837920f, -0.01517248f, 0.03503419f, -0.01234724f, 0.00836968f, 0.01370319f, -0.02861305f, 
    0.02043179f, -0.00978321f, 0.00906557f, -0.03281577f, 0.00545772f, -0.03002347f, 0.02177809f, 0.03069069f, 
    -0.01531412f, 0.00244309f, 0.02650693f, -0.02711444f, -0.01307038f, -0.02306884f, 0.01825140f, -0.04076757f, 
    -0.00625704f, 0.00524404f, -0.01589154f, 0.00719906f, -0.03977021f, -0.02057186f, -0.02599904f, 0.02478613f, 
    -0.00536799f, 0.00883375f, -0.02474393f, -0.00879593f, 0.01786552f, -0.03851457f, -0.02944034f, -0.02681695f, 
    -0.03868843f, -0.01812172f, 0.02808514f, -0.04192479f, -0.00877204f, 0.01605892f, 0.01113215f, -0.00663719f, 
    -0.00247368f, -0.03745427f, -0.03433362f, -0.00703376f, -0.00447660f, 0.00598468f, 0.01240775f, 0.00054678f, 
    -0.03261328f, -0.00212502f, 0.01883719f, -0.02301337f, 0.02901482f, 0.00090040f, -0.01175135f, -0.02938263f, 
    0.00546231f, -0.00076493f, -0.02861542f, -0.00685879f, -0.03753790f, 0.02803200f, 0.00613196f, -0.00672872f, 
    0.00859310f, 0.02819998f, -0.03237353f, 0.03156119f, 0.02705927f, 0.02610960f, -0.03912713f, -0.03627907f, 
    0.01603627f, -0.03089897f, 0.01028402f, 0.00788247f, 0.00022242f, 0.00328878f, -0.01814155f, 0.02888031f, 
    0.00625372f, -0.01848321f, -0.03608011f, -0.01610857f, 0.01097570f, 0.01086324f, -0.00019986f, 0.00593909f, 
    -0.00781863f, -0.01652110f, -0.03085096f, -0.00128671f, -0.03308890f, -0.01868181f, 0.01937345f, -0.01747340f, 
    -0.02681623f, -0.02908900f, -0.01392498f, 0.02320679f, 0.01837467f, 0.00581582f, -0.00821165f, 0.00977497f, 
    0.01858944f, 0.00406822f, 0.00044433f, -0.00811552f, -0.03235256f, -0.01632265f, -0.01634327f, 0.00931324f, 
    -0.00420506f, -0.00724631f, 0.01249410f, -0.01142291f, -0.01748881f, 0.00934647f, -0.04080440f, -0.03010754f, 
    0.02678963f, 0.00731786f, -0.00652659f, 0.00693366f, -0.03245607f, 0.02511376f, -0.01323151f, -0.01628684f, 
    0.01790497f, -0.01360233f, 0.01960497f, -0.02132568f, -0.02599040f, -0.03519166f, -0.00358864f, -0.02865656f, 
    0.02871598f, -0.02207439f, -0.00687261f, -0.02631869f, 0.00822570f, -0.00438596f, -0.00365197f, -0.03911769f, 
    0.01657383f, 0.02348273f, 0.00896461f, 0.01789268f, -0.04408012f, -0.02649379f, 0.00667451f, 0.03173650f, 
    -0.03269222f, -0.00601618f, -0.03961591f, -0.03098135f, 0.02297273f, -0.01319363f, 0.01769459f, -0.03123485f, 
    -0.03839771f, -0.03805413f, -0.02322668f, -0.03485825f, -0.03540776f, 0.00451462f, 0.02873704f, -0.00833513f, 
    -0.01684493f, -0.00436356f, 0.02299743f, -0.00619835f, -0.00879328f, -0.03279201f, 0.02683156f, -0.00100232f, 
    -0.04489466f, -0.02358150f, -0.01340023f, -0.00274380f, -0.02914362f, -0.00943690f, -0.01155155f, -0.00285931f, 
    0.02141340f, 0.03910587f, -0.02459556f, -0.01211221f, -0.03522663f, -0.04148835f, -0.03609179f, 0.00989418f, 
    0.00221741f, 0.02362428f, 0.02894481f, 0.02188628f, -0.03835793f, 0.02829175f, 0.01221895f, -0.00260873f, 
    -0.02478340f, -0.02667109f, 0.01397715f, -0.00905921f, 0.01559346f, -0.01544756f, 0.01025046f, -0.04159742f, 
    -0.00008257f, 0.01711810f, -0.03337295f, -0.04095868f, 0.00635328f, -0.03316328f, 0.02353922f, 0.03086855f, 
    -0.00099479f, -0.00322354f, 0.01783478f, -0.00881078f, 0.01038647f, -0.03387911f, -0.04174655f, -0.02623147f, 
    -0.01369012f, -0.01493268f, 0.00289583f, -0.02258500f, -0.03357906f, 0.01183011f, 0.01470943f, 0.01761274f, 
    0.00347017f, 0.01176862f, -0.01981896f, 0.01399135f, 0.00416973f, 0.01509815f, -0.02564758f, -0.01231945f, 
    0.01488786f, -0.03426810f, -0.01468620f, 0.01626529f, 0.01595975f, -0.03838822f, -0.01568219f, -0.01442988f, 
    -0.00807560f, -0.03117087f, -0.00806298f, -0.00127862f, 0.01831121f, 0.00171259f, -0.03771048f, 0.01328606f, 
    -0.01949538f, -0.00499400f, 0.00479515f, 0.01187116f, 0.00150924f, 0.01778641f, -0.01724317f, -0.01957823f, 
    -0.01596519f, -0.01282268f, -0.02979187f, 0.00816710f, -0.00637373f, 0.01384364f, 0.01152127f, -0.00412031f, 
    -0.00095829f, -0.00378471f, 0.02467444f, -0.03279032f, -0.03681697f, -0.01471636f, -0.02660387f, 0.01578451f, 
    -0.02412200f, -0.04324513f, -0.03223311f, 0.01653686f, -0.00442061f, -0.02972621f, 0.00428108f, -0.01658731f, 
    -0.01682660f, 0.03100603f, 0.02136459f, 0.01984305f, -0.01954246f, -0.02049102f, -0.03970205f, 0.00565062f, 
    -0.03020564f, 0.00342329f, -0.03350682f, -0.03385734f, 0.01951073f, 0.02118418f, 0.01222499f, 0.00767612f, 
    0.02669241f, -0.01484036f, 0.02300891f, -0.01886865f, -0.01861056f, 0.02080086f, -0.03858780f, 0.00568769f, 
    0.01511033f, -0.00256459f, 0.03068782f, -0.03116937f, -0.03280374f, -0.01729768f, -0.01190684f, -0.02438672f, 
    -0.01410473f, 0.00838210f, -0.02110204f, -0.04341935f, 0.00955200f, 0.01470658f, -0.03683414f, -0.00269331f, 
    0.02877528f, -0.00196598f, 0.02468722f, -0.00255151f, 0.01313455f, 0.00764417f, -0.00478189f, -0.00057788f, 
    -0.02127503f, -0.03420327f, 0.01631398f, 0.01562297f, 0.00496859f, 0.00451314f, 0.00789589f, 0.01957676f, 
    -0.00377920f, 0.00801937f, 0.00914990f, 0.02731063f, 0.01534950f, 0.00191141f, 0.01002658f, -0.01910052f, 
    -0.00584065f, 0.00903050f, 0.00280955f, -0.03349841f, -0.03041562f, 0.01395276f, -0.00930225f, 0.00888605f, 
    -0.01032044f, 0.02046288f, 0.00683701f, -0.04338076f, 0.01668204f, 0.01860092f, 0.02152131f, -0.01969011f, 
    0.02323535f, -0.00601803f, 0.00277664f, 0.03000660f, 0.02483763f, 0.00016841f, 0.00468604f, -0.02784485f, 
    -0.00498284f, -0.03284435f, 0.01397637f, 0.03246033f, -0.02785922f, 0.02164215f, 0.00932224f, 0.01418668f, 
    0.02682038f, 0.01356236f, 0.00804528f, -0.01111541f, -0.02793498f, 0.00940233f, -0.02827073f, 0.02454003f, 
    -0.00538593f, 0.02533850f, -0.00097054f, -0.03625814f, -0.03102890f, 0.00786334f, -0.02249024f, -0.03873890f, 
    -0.04415527f, 0.00468957f, 0.00153901f, -0.03061542f, 0.00914254f, 0.02095548f, 0.02351992f, -0.02957332f, 
    0.02424218f, -0.03015019f, 0.02629014f, 0.00720567f, -0.03565265f, 0.01132314f, -0.02767784f, -0.03424659f, 
    -0.00520502f, 0.00273469f, -0.01832007f, -0.03064639f, -0.03259040f, 0.02168206f, -0.00635615f, -0.00695102f, 
    -0.01349419f, 0.02517408f, 0.00867673f, -0.01132159f, -0.01478223f, 0.02477451f, 0.01830693f, -0.00445783f, 
    -0.00961318f, -0.01203210f, -0.00978192f, -0.01721793f, 0.02504197f, 0.01819297f, -0.00052375f, -0.01345218f, 
    -0.03458450f, 0.00009402f, -0.02245722f, -0.01448959f, -0.04095617f, -0.03677381f, 0.01936025f, 0.00666734f, 
    -0.01998619f, -0.03660676f, -0.00742135f, -0.02259151f, -0.04256443f, 0.03009195f, 0.00398046f, 0.00269142f, 
    -0.01245592f, 0.01998235f, -0.02862435f, -0.00392385f, -0.02063040f, -0.01970316f, 0.03667389f, -0.01446027f, 
    -0.02132420f, -0.00233367f, 0.01153804f, 0.01536955f, -0.01321084f, -0.02068984f, 0.02800586f, -0.00790292f, 
    -0.01035037f, 0.00308671f, 0.01447683f, -0.00416583f, -0.01818179f, 0.00683183f, -0.00257018f, 0.02560638f, 
    -0.00574114f, -0.01490454f, -0.00451001f, -0.03536159f, -0.00374345f, 0.02040899f, 0.03979987f, 0.02149487f, 
    0.01722261f, 0.00804830f, -0.02687106f, 0.01276549f, 0.02571889f, 0.00763295f, 0.01611214f, 0.00210900f, 
    -0.02354674f, 0.01504718f, 0.01492265f, 0.00654772f, 0.01347143f, -0.01113706f, -0.04265125f, 0.02532559f, 
    -0.04051766f, 0.00265386f, -0.03699879f, 0.01062987f, 0.00374793f, 0.00799372f, -0.00620610f, 0.00078294f, 
    0.00281793f, -0.04225832f, 0.01156253f, -0.02199141f, 0.01363681f, -0.02890307f, 0.03111004f, 0.00579977f, 
    0.01893869f, 0.01217312f, 0.02490609f, -0.02430307f, 0.00726024f, 0.02451187f, -0.03209475f, -0.00711397f, 
    -0.02621304f, -0.01042425f, -0.00771637f, -0.03971364f, -0.02860934f, -0.01946202f, 0.02865304f, 0.02436775f, 
    0.00049752f, 0.00164313f, 0.00208631f, -0.03328686f, 0.00869319f, 0.01350323f, 0.02689387f, 0.00022973f, 
    0.01370664f, 0.00497969f, -0.02822498f, -0.01737409f, -0.03436746f, -0.01487068f, 0.00131266f, -0.01451324f, 
    0.02882448f, 0.00443579f, -0.02946047f, -0.03922933f, 0.00894549f, 0.01433985f, -0.01911134f, 0.01382686f, 
    0.00745053f, -0.00400103f, 0.00969482f, -0.01748054f, 0.00092791f, 0.02939391f, 0.02868394f, 0.01138590f, 
    -0.03750364f, -0.00729151f, 0.01483164f, -0.03847843f, 0.00415296f, 0.02685873f, -0.03879767f, 0.01217594f, 
    -0.01733902f, -0.02519957f, 0.02148389f, -0.00531943f, -0.02723894f, 0.02012202f, -0.01909000f, -0.00378714f, 
    -0.02589582f, 0.01082181f, -0.01270966f, 0.02094522f, -0.03391282f, -0.00607458f, -0.02905849f, 0.01550498f, 
    0.00362681f, 0.00066706f, 0.00855742f, -0.00950983f, -0.00742781f, -0.02591322f, 0.00306950f, 0.00132013f, 
    -0.01173358f, -0.01146616f, 0.00456914f, -0.02178609f, 0.00014820f, -0.00366702f, -0.02296159f, 0.00919337f, 
    -0.03197774f, -0.00179670f, -0.00706508f, -0.00015394f, -0.03438552f, 0.01722658f, -0.02017561f, -0.01625319f, 
    -0.02960312f, 0.01970634f, -0.01866503f, -0.02922207f, -0.00718860f, -0.02851398f, -0.03835643f, -0.02162189f, 
    -0.00317251f, 0.02644250f, 0.02034162f, -0.03344865f, 0.01185601f, -0.01454087f, -0.00703993f, -0.00376891f, 
    0.00948326f, 0.02234782f, -0.02960463f, 0.01551162f, 0.02612035f, -0.00308537f, -0.01361173f, 0.02471081f, 
    -0.03404888f, -0.01666800f, 0.00581866f, 0.00650921f, -0.03266076f, -0.00290788f, 0.00371973f, 0.02643593f, 
    -0.00804148f, -0.00885816f, -0.00973437f, 0.01655028f, -0.02091471f, -0.01215691f, -0.03455110f, -0.01105867f, 
    0.01294466f, 0.02330405f, -0.03206580f, -0.03947248f, -0.03278632f, -0.00496529f, -0.02563730f, -0.00543195f, 
    0.02938419f, 0.02604265f, -0.03510922f, -0.01282648f, 0.01540305f, 0.01924629f, 0.02505351f, -0.00710107f, 
    0.01537749f, -0.03009022f, 0.00264172f, 0.00620321f, -0.01140452f, -0.04266614f, 0.01431733f, 0.02795759f, 
    0.00435905f, -0.02863881f, 0.02914502f, -0.03685824f, -0.01315693f, 0.00838302f, -0.01836812f, 0.00765194f, 
    -0.03627771f, -0.03069411f, -0.01459254f, -0.03268908f, 0.02615426f, -0.01177669f, 0.02924690f, 0.02059665f, 
    -0.03137791f, 0.00651104f, -0.04012931f, 0.01938215f, -0.01874716f, -0.00577652f, -0.00283608f, 0.00160372f, 
    0.01254706f, 0.01939701f, -0.02067676f, -0.01202166f, -0.01561137f, -0.01830948f, -0.02139972f, -0.00620488f, 
    -0.02197112f, 0.01987002f, -0.00733093f, 0.01930990f, -0.02130842f, 0.00327267f, 0.01220035f, 0.00359709f, 
    -0.01370331f, 0.01092569f, -0.01642219f, 0.00612103f, 0.00028142f, 0.01832972f, -0.00032788f, 0.00297874f, 
    -0.03790206f, -0.00389724f, -0.01332881f, -0.03946055f, -0.03885568f, -0.00484076f, 0.00323957f, 0.02889747f, 
    -0.02038487f, -0.01209458f, 0.02163983f, 0.02767220f, 0.03113415f, -0.02897678f, -0.03436723f, -0.00300393f, 
    0.01646201f, -0.03212830f, 0.02908917f, 0.02635680f, -0.03322722f, -0.03503058f, 0.00169119f, -0.03720909f, 
    -0.03262424f, 0.01984803f, 0.01702727f, -0.01089758f, 0.02398354f, 0.02973732f, -0.02293067f, 0.02673873f, 
    -0.01710010f, -0.02150347f, -0.03908772f, -0.03365458f, -0.01174303f, -0.03862842f, 0.01172786f, 0.03127490f, 
    -0.01009195f, -0.02465797f, -0.03753697f, -0.01071086f, 0.02756901f, -0.00491799f, -0.01576873f, -0.00072287f, 
    0.01398385f, 0.02336707f, 0.02059818f, -0.03140806f, 0.02637718f, -0.00180572f, 0.00797416f, -0.03516889f, 
    -0.00177169f, -0.03862508f, -0.00514927f, 0.00041290f, 0.00297415f, 0.01565402f, -0.01692505f, 0.00191184f, 
    0.02258769f, 0.01541836f, 0.03349625f, -0.01611805f, 0.00553367f, -0.00174904f, 0.02292256f, 0.02174607f, 
    0.01084255f, -0.02317688f, 0.00978382f, 0.01851419f, 0.02747973f, 0.01819163f, 0.01460287f, 0.00499763f, 
    0.02218513f, -0.03567543f, 0.02469039f, -0.02418686f, 0.02641443f, 0.02328546f, -0.03779716f, -0.03278055f, 
    0.00546086f, 0.00126162f, -0.03992540f, -0.00270267f, 0.01986799f, -0.01329294f, -0.03572365f, -0.00129729f, 
    -0.03456919f, 0.03126655f, -0.01680320f, -0.02136218f, -0.02968119f, -0.01153431f, -0.02996286f, -0.01836851f, 
    0.01354920f, -0.00259896f, 0.01516907f, -0.00739102f, 0.01764577f, -0.00379483f, -0.02607413f, -0.00422202f, 
    -0.00840801f, -0.03030116f, -0.02104743f, 0.03002189f, -0.01744205f, -0.01250481f, -0.00449260f, -0.00444291f, 
    0.00295023f, -0.01660086f, -0.03337796f, 0.00324558f, -0.01843365f, 0.01643314f, 0.02660985f, 0.02335430f, 
    -0.01511628f, 0.02024765f, -0.00518532f, -0.00398558f, -0.00471615f, -0.02345255f, 0.01178470f, 0.02881020f, 
    -0.01139553f, -0.03073596f, -0.00838413f, 0.01883799f, -0.02827559f, -0.03696515f, -0.03445973f, 0.00095493f, 
    -0.02046077f, 0.00311290f, -0.01241540f, 0.03127872f, -0.00988394f, -0.00505454f, -0.01161538f, -0.04079753f, 
    -0.02509998f, 0.00401505f, -0.02916657f, 0.02576136f, -0.02740275f, 0.00313326f, -0.01946727f, -0.00314235f, 
    -0.01323823f, -0.01262957f, 0.02722052f, -0.01086478f, 0.02018225f, -0.03441603f, -0.03679723f, 0.00659494f, 
    0.00443236f, 0.00413053f, -0.01892985f, 0.00944943f, 0.00490605f, 0.01497610f, -0.01513514f, -0.00102603f, 
    -0.02113315f, 0.00688893f, 0.02194735f, 0.00140750f, 0.02268188f, 0.00254965f, 0.00008212f, -0.03247226f, 
    -0.01071240f, -0.02563660f, -0.03451514f, -0.01571989f, 0.00985195f, 0.02733099f, -0.00213078f, -0.00506620f, 
    -0.02511869f, -0.02953126f, 0.00345411f, 0.01788114f, 0.02550481f, -0.00285207f, 0.02373008f, 0.00697912f, 
    0.00865522f, -0.00566218f, 0.02586794f, 0.01793805f, -0.03702240f, -0.03524086f, 0.01200626f, -0.02802327f, 
    -0.03964691f, -0.03117876f, -0.00041171f, -0.00147555f, 0.02534332f, -0.01459782f, -0.01157428f, 0.02401046f, 
    -0.02744647f, 0.01249904f, 0.02734708f, -0.02591518f, 0.00464892f, 0.00214384f, -0.00379250f, -0.01332352f, 
    0.00367694f, 0.02322794f, 0.01499208f, 0.00685017f, 0.01137608f, 0.01602679f, 0.01177861f, -0.01180828f, 
    -0.02422968f, 0.02370162f, -0.02905455f, 0.00697907f, -0.00612772f, -0.01414541f, 0.01537172f, -0.02758217f, 
    0.00738787f, 0.02741431f, -0.03632733f, -0.00150120f, 0.01775808f, 0.01074587f, -0.02941195f, 0.01892577f, 
    0.00003253f, -0.01916654f, -0.02738281f, -0.00108367f, -0.02585120f, -0.00218808f, -0.01171411f, 0.01418211f, 
    0.02288842f, 0.01958496f, 0.03008795f, 0.02718429f, 0.00506825f, -0.01198791f, -0.00505557f, 0.01619484f, 
    0.02698863f, 0.01334205f, 0.02014125f, 0.00309642f, 0.01380121f, -0.02494548f, 0.02619402f, -0.03989007f, 
    0.02862161f, 0.01152348f, -0.03732805f, -0.00972153f, -0.02460279f, 0.01096632f, 0.01704557f, 0.01158680f, 
    0.01681148f, 0.03248791f, -0.00449268f, 0.02462839f, 0.01428167f, -0.00795193f, -0.03415814f, -0.03513685f, 
    -0.02249792f, 0.01405881f, -0.00843399f, -0.00886619f, 0.00151998f, -0.01214509f, 0.02176033f, 0.01284154f, 
    -0.03835356f, -0.01095948f, 0.00222232f, -0.03361051f, 0.02871325f, -0.00664472f, -0.03155826f, -0.03889714f, 
    0.00770009f, 0.01169607f, -0.03114084f, 0.01028426f, -0.00090545f, 0.01494856f, -0.00414381f, 0.02724673f, 
    0.02528701f, 0.00761601f, 0.01856189f, -0.03125652f, -0.00794944f, -0.00252961f, 0.01435299f, -0.01988577f, 
    0.02309473f, -0.00841961f, -0.01027748f, 0.03011671f, -0.03375725f, 0.02124983f, -0.01870482f, -0.03299932f, 
    0.02146848f, 0.01138915f, -0.03227528f, 0.01140496f, 0.01777907f, 0.03122575f, 0.00427947f, 0.00240897f, 
    0.00465834f, 0.00617581f, 0.03041210f, -0.04170149f, -0.03847220f, 0.02260362f, -0.01882309f, 0.00329259f, 
    0.01633554f, 0.01623888f, -0.02814682f, -0.01427501f, -0.00998412f, -0.03362133f, -0.00890230f, -0.02861238f, 
    0.01077704f, 0.02995127f, -0.01968085f, 0.03156838f, 0.01412613f, 0.00428994f, -0.03596497f, -0.03310571f, 
    0.00782734f, 0.02340578f, -0.03503424f, 0.00511944f, -0.01671137f, -0.01581151f, -0.02577315f, 0.01144951f, 
    0.00103681f, -0.02559395f, 0.01626636f, -0.00401291f, 0.02166003f, -0.00617945f, -0.00716389f, -0.01761034f, 
    0.00872042f, -0.02153358f, 0.01273962f, -0.01038009f, 0.02243756f, 0.01236798f, 0.00625364f, -0.03330604f, 
    0.02467265f, 0.02424906f, -0.00574156f, -0.02414515f, 0.02639325f, 0.00980431f, -0.00893562f, -0.02630609f, 
    0.00348870f, -0.01224232f, 0.01321013f, 0.02098217f, -0.00268467f, -0.00116668f, -0.00759104f, -0.02069152f, 
    -0.03858874f, 0.01221032f, 0.03027923f, -0.00973325f, 0.00964691f, 0.03072414f, 0.01308485f, -0.03357993f, 
    -0.00710167f, -0.00018794f, 0.01033059f, 0.01810603f, -0.02421351f, -0.03977445f, -0.02988303f, 0.02124797f, 
    -0.04024987f, 0.01801262f, -0.02949382f, -0.00364978f, -0.02541376f, -0.00168388f, 0.02756168f, 0.03013096f, 
    0.01154889f, -0.02876991f, -0.00604539f, 0.01935194f, -0.00146205f, -0.02597029f, 0.02237247f, 0.00393225f, 
    0.03134346f, -0.01590917f, -0.02813565f, -0.01220324f, -0.02615050f, -0.01799498f, -0.00995220f, 0.00734758f, 
    -0.01014770f, -0.02575571f, -0.04264971f, -0.04119593f, -0.03131283f, 0.00657736f, -0.03193726f, 0.00768744f, 
    0.01092447f, 0.00638265f, -0.03833593f, 0.01025305f, -0.01587346f, 0.01477450f, -0.00505473f, 0.02121566f, 
    0.02272086f, -0.02485947f, 0.00657268f, -0.01084401f, 0.00322548f, 0.01160326f, 0.01795757f, 0.00800429f, 
    -0.03375812f, -0.02361734f, 0.01971904f, -0.02505611f, -0.02655440f, 0.01574701f, -0.01901809f, -0.03256751f, 
    0.01113379f, -0.02760116f, -0.03459056f, 0.02169210f, -0.03051267f, 0.02024201f, 0.02470488f, 0.00997686f, 
    0.02258347f, -0.01320583f, 0.02634981f, -0.02974469f, 0.02083726f, -0.01787898f, -0.02471245f, -0.04104338f, 
    -0.02642859f, -0.02845442f, -0.02137740f, -0.02524932f, -0.01598584f, 0.00771810f, -0.03871278f, 0.03019086f, 
    -0.03942078f, -0.01258755f, 0.01246866f, -0.03005257f, -0.00791927f, 0.00825386f, -0.00775163f, -0.01839871f, 
    -0.01850195f, 0.01378618f, 0.00313875f, 0.00089693f, -0.01966228f, -0.03625703f, -0.03207763f, -0.02173096f, 
    -0.02776515f, -0.02527319f, -0.00668290f, 0.00442411f, -0.03617625f, 0.01494647f, -0.00600135f, -0.00756348f, 
    -0.03903675f, -0.03869887f, -0.03904707f, -0.02352982f, -0.01172555f, 0.01068386f, -0.02073167f, 0.02025246f, 
    -0.00061261f, -0.00624298f, -0.01707193f, -0.04022691f, -0.03897334f, 0.00126675f, -0.02354641f, -0.02102811f, 
    0.00212899f, 0.00334623f, -0.00501509f, -0.03905685f, 0.00825163f, -0.03615183f, 0.02681930f, -0.02166794f, 
    -0.03277058f, 0.00449353f, 0.00465716f, -0.03321221f, -0.02734454f, 0.01279293f, -0.02692727f, 0.01144188f, 
    0.00399043f, -0.01046112f, 0.01880229f, -0.01620022f, 0.02952890f, 0.01126520f, -0.00921746f, -0.02893500f, 
    0.00344247f, 0.01678378f, 0.01828086f, 0.01600738f, 0.01221344f, -0.02726998f, 0.03165772f, 0.02369778f, 
    0.01151024f, -0.02129445f, 0.02358026f, -0.02150931f, 0.02438704f, 0.02704428f, -0.00960509f, 0.01779893f, 
    -0.01112959f, -0.02448448f, -0.02653657f, 0.01729584f, 0.01290867f, 0.02780080f, 0.00032603f, -0.00462376f, 
    -0.02080355f, 0.01954442f, 0.00081670f, 0.02990409f, 0.02214495f, 0.02610118f, -0.01415567f, -0.02595377f, 
    -0.01502638f, -0.02160312f, -0.03385556f, 0.00357096f, -0.02845005f, 0.01112021f, -0.02539394f, 0.00876806f, 
    -0.00847329f, -0.02764375f, 0.02879328f, -0.01425402f, -0.00506756f, 0.00596417f, 0.00643047f, 0.01278465f, 
    0.02863439f, -0.02127510f, -0.01656896f, 0.01966591f, -0.02151789f, -0.00381670f, -0.01265187f, -0.01863451f, 
    -0.04094999f, -0.01185809f, -0.02792687f, 0.00455614f, -0.01532101f, 0.01716644f, 0.02304343f, 0.03036960f, 
    0.00748103f, -0.01556443f, 0.00508337f, -0.00184066f, -0.03503466f, -0.03584888f, -0.03085464f, -0.02293720f, 
    -0.00142033f, -0.00968658f, -0.03195907f, 0.01725087f, -0.03523709f, 0.02641155f, -0.01531633f, -0.00450301f, 
    0.02262372f, -0.03802235f, 0.02534182f, 0.02461846f, 0.01901728f, -0.00650548f, -0.03109708f, -0.02883691f, 
    -0.00378967f, -0.03894142f, 0.01181731f, -0.01953546f, 0.00830144f, 0.02832218f, -0.00874790f, 0.01453931f, 
    0.02060767f, 0.00854239f, -0.00856191f, -0.00001825f, 0.00338486f, -0.01033637f, -0.01898683f, -0.00052852f, 
    0.01876217f, -0.02084556f, -0.00958566f, -0.01163435f, -0.01848226f, 0.01830155f, 0.02007006f, -0.03497726f, 
    -0.03490169f, -0.02367157f, 0.01793380f, -0.01885792f, -0.01811044f, -0.01494504f, 0.02380481f, 0.00988532f, 
    -0.03502921f, -0.02000331f, 0.01924629f, 0.00727147f, -0.03686093f, -0.00285863f, 0.01364475f, -0.02655663f, 
    -0.03526546f, -0.03285895f, -0.04109332f, -0.01687548f, 0.01441748f, 0.02714063f, -0.02596886f, -0.02144951f, 
    0.02427339f, -0.01585499f, -0.02350003f, 0.01310723f, 0.02684622f, 0.01539368f, 0.00577136f, 0.01137310f, 
    -0.00944323f, 0.00673427f, -0.01415883f, 0.02440878f, 0.01760819f, -0.00083869f, -0.00766523f, -0.02957566f, 
    -0.04143383f, -0.03135403f, -0.00292770f, 0.03045993f, 0.03020414f, -0.00646596f, 0.02759424f, 0.02609409f, 
    -0.01641251f, 0.00355696f, 0.00977581f, 0.02968895f, -0.01492756f, -0.00398663f, -0.03280307f, 0.00120158f, 
    0.00054920f, -0.01611590f, -0.03457259f, 0.02428919f, -0.04078193f, -0.00692829f, -0.02569042f, 0.02893946f, 
    -0.03798334f, -0.00306919f, -0.00450328f, -0.01366409f, -0.02411744f, 0.00114957f, -0.01890431f, 0.02420885f, 
    -0.03007015f, -0.02329535f, 0.01434068f, -0.02671294f, 0.01747424f, -0.00870760f, 0.00414088f, -0.02475326f, 
    -0.01682340f, -0.02471503f, 0.01351205f, 0.00962423f, 0.02775450f, -0.01162431f, -0.00485798f, -0.01500336f, 
    0.00798661f, -0.03247346f, -0.03223204f, 0.03248698f, 0.01820126f, 0.00955584f, -0.02025788f, -0.02818659f, 
    0.01553845f, 0.01131683f, 0.01349430f, -0.03215126f, 0.02320343f, -0.03775408f, -0.04041308f, -0.00067809f, 
    0.00014130f, -0.01771463f, 0.02043313f, 0.02793506f, -0.01898346f, 0.00783479f, -0.04054486f, -0.02250358f, 
    0.00868137f, 0.02308516f, 0.02402768f, -0.00536260f, 0.00792535f, -0.01764704f, -0.01819385f, -0.01606005f, 
    0.00758294f, -0.03017643f, 0.01089728f, 0.01197130f, -0.00230365f, 0.01575724f, 0.00362196f, -0.02430637f, 
    -0.02780343f, -0.03468351f, -0.02247563f, -0.00586673f, 0.01092060f, 0.02530206f, -0.03068104f, 0.02850172f, 
    -0.02697039f, 0.00018059f, 0.02781620f, 0.00770126f, -0.02897850f, 0.01250871f, -0.02723919f, -0.02027805f, 
    0.00515505f, -0.02725211f, -0.01109300f, -0.02833496f, -0.03722403f, 0.01905092f, -0.01385764f, 0.02465972f, 
    -0.01307585f, -0.04157763f, 0.02591921f, -0.00411361f, 0.01728129f, -0.03214015f, -0.01693549f, -0.01396409f, 
    -0.03820334f, -0.03567299f, -0.02302492f, 0.01506956f, -0.03989117f, -0.01241444f, -0.00715820f, -0.01896695f, 
    -0.00938281f, 0.02111962f, 0.02882642f, 0.02277614f, -0.02922086f, -0.00430707f, -0.00932296f, 0.03000800f, 
    0.02741150f, -0.03906692f, -0.02716969f, -0.01345501f, 0.00610118f, 0.02854318f, -0.01572532f, 0.00298931f, 
    -0.00536081f, 0.02202457f, 0.00482995f, 0.02130703f, -0.01168678f, -0.03854965f, -0.02212598f, -0.03185228f, 
    -0.01925438f, -0.03295865f, 0.02262771f, 0.00338166f, -0.02526446f, 0.01893239f, 0.01369165f, 0.01867813f, 
    0.00730784f, 0.02777968f, -0.03230692f, -0.03633865f, -0.00953536f, -0.00611124f, 0.01451437f, -0.01616989f, 
    0.02491373f, 0.02892526f, 0.00508804f, -0.02786351f, -0.03063735f, 0.01036625f, -0.01861788f, 0.01989772f, 
    -0.00538530f, 0.02362406f, -0.01674986f, -0.01168782f, -0.03778072f, -0.03018611f, 0.01912425f, 0.01318192f, 
    -0.03453256f, -0.01220521f, 0.00214428f, 0.02749653f, -0.00257330f, -0.00745606f, -0.02600501f, -0.02934995f, 
    0.02308348f, 0.01150177f, 0.01760911f, -0.03122610f, 0.01492118f, -0.03439016f, 0.02143229f, 0.02707488f, 
    -0.02103905f, -0.00745828f, -0.00337185f, 0.01537062f, -0.01309497f, 0.02397394f, 0.01187538f, 0.01054768f, 
    0.01834721f, -0.00392979f, 0.01060063f, 0.01880643f, 0.01021679f, 0.00349089f, 0.03504723f, 0.00306802f, 
    -0.00088458f, 0.02394547f, -0.00918964f, 0.02172820f, 0.02034581f, 0.00972988f, 0.02806821f, -0.02468294f, 
    0.01093821f, -0.03772996f, -0.03493956f, -0.01556543f, -0.00624635f, 0.01947630f, -0.04012747f, -0.01798183f, 
    -0.03416033f, 0.01601267f, 0.02160209f, 0.00610457f, -0.02053169f, 0.00370085f, -0.01783677f, -0.04154040f, 
    0.00107379f, -0.02371040f, 0.01755974f, -0.00721086f, -0.04100074f, 0.00965722f, -0.01748186f, 0.00814156f, 
    -0.03693432f, -0.03161454f, 0.02483995f, 0.01124369f, 0.00979730f, -0.00589911f, 0.01192615f, -0.02584078f, 
    0.00886418f, -0.01177029f, 0.00653880f, 0.01854311f, -0.02346437f, -0.03384050f, -0.00953524f, -0.03150154f, 
    -0.00983125f, 0.00663402f, -0.00802861f, 0.02219226f, 0.01669479f, -0.04161199f, -0.01029516f, -0.00813675f, 
    0.02835896f, 0.00127314f, -0.01030045f, 0.02744939f, 0.01542894f, 0.01453906f, 0.02309524f, 0.00127189f, 
    -0.01908420f, -0.01610455f, -0.00532029f, 0.00587917f, -0.02879411f, -0.00684005f, -0.00027496f, -0.00575379f, 
    -0.02591157f, 0.02958569f, 0.02207224f, 0.02037634f, 0.01242068f, -0.01864360f, -0.03184837f, 0.01799144f, 
    -0.01766558f, -0.00121962f, -0.00397690f, 0.00345829f, -0.00299443f, -0.03249731f, 0.00197474f, -0.03142393f, 
    -0.00877988f, -0.01637340f, -0.01221354f, -0.00127465f, -0.03338419f, -0.03443724f, -0.00268055f, -0.01122354f, 
    -0.04057708f, 0.01573870f, -0.00813830f, 0.02306130f, -0.03076927f, -0.01813335f, -0.00526202f, -0.01825818f, 
    0.02886781f, -0.02384922f, 0.01780257f, 0.01581295f, -0.02461930f, -0.02886374f, -0.00533666f, -0.03525499f, 
    0.02768496f, -0.01568567f, 0.01544466f, -0.00833488f, -0.00914657f, -0.02976471f, -0.03141037f, -0.02118785f, 
    0.02663719f, -0.01936494f, 0.02392611f, 0.00312376f, -0.01664418f, -0.00493725f, -0.01840259f, -0.02906995f, 
    0.01943188f, -0.01928267f, -0.00071052f, -0.01350844f, -0.00031909f, -0.03048049f, -0.03816058f, -0.02650548f, 
    0.00749373f, 0.00251030f, -0.01685096f, 0.01686367f, -0.00557215f, 0.01472585f, -0.01118173f, -0.02073447f, 
    -0.01165513f, -0.00602404f, 0.01887394f, 0.02629543f, -0.03800990f, -0.03405868f, -0.02165779f, 0.01571866f, 
    -0.00824951f, -0.00176313f, -0.02922856f, 0.01788774f, -0.00227324f, 0.00926306f, -0.02252655f, 0.01338819f, 
    -0.00187785f, -0.00069888f, -0.00351480f, 0.02216484f, 0.01851529f, -0.00297116f, -0.03413621f, -0.04128931f, 
    -0.00061048f, 0.02389637f, -0.00748536f, 0.00421999f, -0.01208566f, 0.01483186f, -0.01888500f, -0.04144363f, 
    -0.00393525f, 0.00962058f, -0.00709563f, -0.00203717f, 0.00957065f, -0.03940841f, -0.04007727f, -0.02459630f, 
    -0.01843990f, -0.02033343f, -0.01869763f, -0.01437542f, 0.02584778f, -0.02978299f, -0.01013068f, -0.03255030f, 
    -0.02139410f, -0.02333581f, 0.02170600f, -0.01127981f, -0.03900661f, 0.00649760f, 0.00922795f, 0.01389796f, 
    -0.03239432f, -0.03328830f, 0.00579469f, -0.00132699f, 0.01366143f, -0.02953622f, 0.02582581f, -0.04105993f, 
    -0.02675463f, 0.00234429f, -0.01699031f, -0.03253872f, 0.00292543f, -0.04043744f, 0.02250907f, 0.00317799f, 
    -0.03429603f, 0.01460909f, -0.01754510f, 0.00154661f, -0.01460725f, -0.02769151f, 0.01604769f, -0.01115835f, 
    0.01670573f, 0.02617969f, -0.02394400f, 0.00773420f, 0.00948998f, -0.04006438f, -0.02677584f, 0.01072030f, 
    -0.03325181f, 0.01830342f, 0.00260273f, -0.00693745f, -0.02654555f, -0.03549248f, -0.03040077f, -0.03259594f, 
    0.00776563f, -0.02739122f, 0.02339739f, -0.00649098f, 0.02734024f, 0.01354969f, -0.01370082f, -0.01219895f, 
    -0.03993461f, 0.00356059f, -0.03392390f, -0.03429856f, 0.00040943f, -0.03495179f, 0.00069069f, -0.01890369f, 
    -0.01658516f, -0.02312597f, -0.03313764f, -0.03942071f, 0.02123377f, 0.00937824f, -0.00845239f, 0.00079196f, 
    0.02156170f, -0.04020090f, -0.02642583f, 0.00569099f, -0.03456210f, 0.02471551f, 0.02813424f, 0.02598277f, 
    0.02910041f, -0.00252880f, 0.02405442f, -0.03418729f, -0.02901047f, -0.00826844f, 0.02936100f, 0.00947403f, 
    0.01040142f, -0.03394582f, 0.01693336f, -0.01337191f, 0.00532058f, -0.02750254f, -0.01615651f, -0.01751633f, 
    -0.01223699f, -0.01011697f, -0.01720438f, 0.01000517f, -0.01134494f, -0.04005993f, 0.01987600f, -0.03265743f, 
    -0.00176125f, -0.04085068f, -0.02439111f, -0.00516362f, -0.01592110f, 0.00978061f, -0.01964788f, -0.03057634f, 
    -0.02986402f, -0.00294761f, -0.02979450f, 0.01133983f, -0.02239631f, -0.01803529f, -0.02877701f, -0.03880642f, 
    0.01849752f, 0.00397307f, 0.02613712f, -0.00651461f, -0.03761707f, 0.00746656f, -0.03228060f, -0.01164350f, 
    -0.02913914f, -0.00037691f, -0.01107913f, -0.02225836f, 0.02120976f, -0.03836048f, -0.02836422f, -0.02903715f, 
    -0.03648505f, 0.00932513f, 0.02711139f, -0.02182362f, 0.00684228f, -0.00502525f, -0.01056121f, 0.01649542f, 
    -0.01018471f, 0.01381276f, -0.01699138f, 0.00435202f, 0.01972905f, -0.02338382f, -0.00009143f, -0.02682115f, 
    -0.03941998f, -0.01960637f, -0.01444400f, -0.00911155f, 0.01672413f, 0.02995424f, -0.03677217f, -0.00559952f, 
    0.00026009f, -0.02898347f, -0.00849608f, -0.04086882f, -0.00598429f, -0.04024782f, -0.03572178f, 0.01990024f, 
    -0.03122568f, -0.04042175f, 0.01311908f, -0.00010359f, 0.02891964f, -0.01651440f, -0.00490617f, 0.01555156f, 
    0.00809291f, -0.01759972f, -0.00033721f, -0.01739454f, -0.03002309f, -0.01935365f, 0.00309650f, -0.03438698f, 
    -0.01416216f, 0.02730742f, -0.01161652f, 0.00549124f, -0.00700119f, -0.01635087f, -0.03109959f, 0.01266876f, 
    0.01003570f, 0.02650627f, 0.00524301f, -0.03014922f, -0.01641364f, -0.01335198f, -0.02757071f, -0.04072746f, 
    0.02311719f, -0.03203604f, -0.03413788f, 0.01446495f, -0.00228027f, -0.01331420f, 0.00464883f, -0.01873936f, 
    -0.00726925f, -0.02729273f, 0.00559891f, 0.02029272f, 0.02478286f, 0.01114976f, 0.01158285f, -0.04058558f, 
    0.00916383f, 0.02279629f, -0.02265684f, 0.00209401f, -0.03387794f, -0.01068339f, -0.00221823f, -0.00519231f, 
    0.00518217f, -0.01592470f, -0.01848109f, -0.03363930f, -0.01241416f, 0.00999544f, -0.02991699f, -0.04053601f, 
    -0.02688697f, -0.28163049f, -0.05516452f, 0.02752262f, 0.11646032f, -0.01415159f, -0.02804356f, 0.05505220f, 
    0.08673891f, -0.10700052f, 0.02778288f, -0.05378701f, -0.00884112f, 0.02886933f, 0.04865175f, 0.02944469f, 
    0.01746199f, -0.07623258f, -0.17016609f, 0.00751503f, -0.04642986f, 0.07187384f, -0.07420137f, -0.02310062f, 
    -0.15526636f, 0.01335322f, -0.04023416f, -0.19107795f, 0.01305425f, 0.04327163f, 0.01480030f, 0.02827987f, 
    0.00223820f, -0.07970865f, -0.03086944f, -0.09238557f, 0.10795949f, 0.09579091f, -0.10880402f, 0.04522866f, 
    0.02304841f, 0.01686087f, 0.04614374f, -0.01488042f, 0.03401158f, 0.04831354f, 0.02799886f, -0.00507607f, 
    0.15592356f, 0.07377089f, 0.07269192f, 0.06343890f, -0.00171768f, 0.00594567f, 0.03531903f, -0.10282762f, 
    0.03020654f, -0.02634703f, -0.09651475f, -0.10431767f, 0.09772459f, 0.16751805f, -0.05675770f, 0.08033203f, 
    0.06268398f, 0.03338872f, -0.01486243f, -0.00113215f, 0.00205443f, -0.00175948f, 0.02507294f, 0.15095609f, 
    0.10775456f, 0.06939091f, 0.00708659f, 0.21681389f, 0.06081436f, -0.01388763f, 0.03666197f, 0.07465181f, 
    -0.04148437f, -0.20170592f, 0.12066372f, 0.03720109f, -0.14412805f, -0.07206670f, -0.02782418f, 0.10303114f, 
    0.03082057f, -0.01735814f, 0.01148255f, 0.11285892f, -0.09037197f, -0.01436986f, 0.09405565f, 0.05393597f, 
    -0.12732863f, -0.03737241f, 0.12537296f, -0.13392545f, 0.09383303f, 0.05436543f, 0.04041254f, -0.05702617f, 
    -0.02341843f, -0.09671722f, 0.07609434f, 0.10861050f, 0.02808236f, -0.01966760f, 0.13035756f, 0.00178246f, 
    -0.04716049f, -0.00043067f, -0.11465110f, 0.13399911f, 0.01818416f, 0.17708486f, -0.06251757f, 0.04870884f, 
    0.22106986f, 0.05182566f, -0.12474497f, 0.08091823f, 0.00431745f, -0.03561556f, 0.03086727f, 0.08927070f, 
    -0.02553339f, -0.03571655f, -0.16434193f, -0.05804845f, -0.31482145f, -0.03981667f, -0.01054720f, -0.05101587f, 
    0.03387137f, -0.09342106f, 0.09563583f, -0.10563830f, 0.03421834f, 0.03987689f, -0.04336121f, -0.01088225f, 
    -0.29036677f, -0.12018948f, 0.02174822f, 0.02979395f, 0.08464644f, -0.01698071f, 0.02006887f, 0.06085298f, 
    0.03456125f, 0.15436856f, -0.05793673f, 0.05741916f, -0.25064674f, -0.06614164f, -0.03547399f, 0.09682832f, 
    0.03826119f, -0.03769823f, -0.12621453f, 0.01053035f, 0.00308971f, 0.01169850f, 0.09484112f, -0.09542927f, 
    0.42607057f, 0.08123702f, 0.04377237f, -0.00916071f, 0.03048084f, -0.05549987f, -0.05608231f, 0.03796166f, 
    0.05467665f, -0.07670358f, 0.05690471f, -0.10290605f, -0.11837135f, 0.08684035f, -0.17065261f, -0.11053190f, 
    0.05905783f, 0.02840981f, -0.07384884f, 0.02298027f, 0.04475726f, -0.00409457f, 0.02968353f, 0.18605500f, 
    -0.20301220f, -0.09649110f, -0.05381240f, -0.03375027f, 0.08352737f, 0.04156689f, 0.04975031f, 0.00630239f, 
    0.04215541f, -0.06829667f, 0.07423761f, 0.09325374f, 0.29367092f, 0.04440790f, -0.15310992f, -0.13263395f, 
    0.03014744f, -0.04768496f, -0.07633609f, -0.05432752f, -0.05337132f, 0.04741678f, 0.02240826f, 0.00143996f, 
    -0.23950532f, 0.07033589f, -0.05831909f, -0.16435555f, -0.04283947f, -0.02784527f, -0.00552515f, -0.11988065f, 
    0.01345109f, 0.21835193f, -0.08550086f, 0.04137847f, 0.01459282f, 0.36063415f, 0.11373166f, 0.09242567f, 
    0.00978881f, 0.05462360f, -0.08128801f, -0.09936405f, 0.08138768f, 0.06653152f, 0.03891099f, 0.08841550f, 
    0.28483778f, 0.15349963f, 0.15477110f, -0.02611952f, 0.11224752f, 0.05528165f, -0.08118276f, -0.02730201f, 
    -0.04983487f, -0.01705943f, 0.23369713f, 0.09953676f, 0.00916169f, 0.06395950f, -0.14832805f, -0.27019137f, 
    0.00105909f, 0.16457881f, -0.00286908f, -0.09020683f, 0.09921412f, -0.01671352f, 0.08846336f, -0.02972139f, 
    -0.03499096f, -0.03889178f, 0.05105466f, -0.21011142f, 0.00419689f, 0.19512586f, -0.14110745f, 0.10549679f, 
    0.06143210f, -0.06042322f, 0.06364711f, -0.04096211f, -0.16453768f, 0.00614534f, 0.04652314f, -0.16327070f, 
    0.07576790f, 0.06473524f, -0.14901309f, 0.01395282f, 0.04720210f, 0.09880567f, 0.01900125f, 0.07766631f, 
    -0.04960347f, 0.21383600f, 0.19891925f, 0.23932394f, 0.09850745f, -0.00733733f, -0.04500171f, 0.02814796f, 
    0.02021782f, 0.00367235f, -0.00487457f, 0.02134581f, -0.05114626f, 0.03285334f, -0.05859879f, 0.13158464f, 
    -0.02859055f, -0.10305312f, 0.04195082f, -0.02663943f, 0.05600752f, 0.03736923f, 0.13348030f, 0.06761031f, 
    0.01973884f, 0.12467184f, 0.13788038f, 0.05420725f, 0.12502652f, 0.10665255f, -0.02705454f, 0.02269676f, 
    0.00582379f, -0.06907940f, 0.01327022f, -0.03433933f, 0.32928506f, -0.04761826f, 0.06930976f, -0.05289207f, 
    -0.01219575f, -0.04990547f, 0.09571368f, -0.02427613f, 0.04819321f, -0.01609043f, 0.14660041f, 0.10551543f, 
    -0.12906788f, -0.05158876f, -0.09684108f, -0.23322414f, 0.03295896f, 0.07133846f, 0.04335257f, -0.08107972f, 
    -0.01200265f, 0.04092982f, 0.07523495f, 0.02930450f, -0.01400822f, -0.14584427f, -0.08759309f, -0.06447139f, 
    0.02672657f, 0.00872342f, 0.12511815f, 0.05960597f, -0.00788766f, 0.11651812f, -0.04217070f, -0.12399983f, 
    -0.02742843f, -0.09433633f, -0.25800171f, 0.14512511f, 0.07982347f, 0.08527771f, -0.14699349f, -0.03583746f, 
    0.00706167f, 0.00903829f, -0.05604083f, -0.01776006f, 0.14715791f, 0.13551390f, 0.24704683f, -0.01633044f, 
    0.01056816f, -0.15518959f, -0.18425110f, 0.00399122f, -0.04908219f, 0.13751902f, -0.14733745f, 0.12097659f, 
    0.02816061f, 0.14785470f, 0.20414700f, 0.19499129f, 0.05483248f, 0.05180093f, -0.03818953f, -0.05453000f, 
    -0.08236458f, 0.20759748f, 0.06964421f, 0.00422313f, -0.07580449f, 0.05343839f, 0.04290901f, -0.22762622f, 
    -0.00933481f, -0.05730897f, -0.01883662f, 0.03932128f, 0.06233427f, -0.00778360f, -0.04698197f, 0.13760488f, 
    -0.12565368f, -0.05957575f, -0.04752560f, -0.05731336f, 0.09218520f, -0.01638320f, 0.01470248f, -0.04844592f, 
    0.03162505f, -0.16240467f, -0.01691157f, 0.16205305f, -0.16648361f, 0.13327675f, 0.19338213f, 0.18651631f, 
    0.02190106f, 0.09656084f, 0.04047659f, 0.16868466f, 0.07294202f, -0.00866209f, 0.04044604f, 0.04018721f, 
    -0.17732359f, -0.20909388f, -0.05740389f, -0.03905355f, -0.11027182f, -0.02351911f, 0.17444864f, -0.04753297f, 
    0.03965807f, 0.04644321f, 0.06386434f, -0.09583800f, -0.10081710f, -0.07177260f, 0.06540480f, -0.08315746f, 
    0.01945692f, 0.07345855f, -0.11626816f, 0.02944307f, -0.04376195f, 0.01952719f, 0.04795320f, 0.10116865f, 
    0.06452472f, -0.13502140f, -0.11591522f, -0.20132215f, 0.11096366f, -0.08224914f, 0.00346297f, 0.08827905f, 
    0.09631087f, 0.13970217f, -0.22434577f, -0.03787019f, -0.02976343f, -0.15357861f, -0.14048906f, -0.04277989f, 
    0.07977214f, 0.00866665f, -0.09388692f, 0.06781260f, 0.15553875f, 0.01400261f, 0.02777789f, 0.04031491f, 
    -0.35179120f, -0.07500219f, -0.00275309f, -0.09117316f, -0.00405808f, -0.05428445f, 0.06947205f, -0.01611604f, 
    0.13425344f, 0.03346712f, -0.00532342f, 0.02526895f, -0.25724685f, -0.30726755f, -0.02370045f, 0.02968942f, 
    0.06977703f, 0.03800222f, -0.03917091f, -0.08674074f, 0.03096883f, 0.11086450f, 0.00336922f, 0.11570843f, 
    -0.13360618f, -0.17610669f, 0.01519223f, 0.00760686f, 0.03514349f, 0.12252276f, 0.05349147f, 0.04433124f, 
    -0.03961347f, 0.03807213f, 0.02713243f, 0.03164667f, 0.27546608f, 0.10031542f, 0.19264816f, 0.11124776f, 
    -0.03615773f, 0.09509421f, 0.03704888f, -0.01045942f, -0.09728660f, -0.03756300f, -0.02338099f, -0.07495274f, 
    0.11815767f, 0.14177236f, 0.11129901f, 0.03651553f, 0.07802737f, 0.08655239f, 0.02845449f, 0.08023456f, 
    -0.00187250f, 0.06387511f, -0.01232702f, 0.08848289f, 0.09977356f, 0.03151141f, -0.04646643f, -0.08527060f, 
    0.03283945f, -0.08129584f, 0.06320173f, 0.10125352f, 0.09870797f, 0.05384874f, 0.02373032f, -0.16682734f, 
    -0.21772185f, -0.27316746f, 0.01488797f, 0.04005226f, -0.03772714f, -0.00951747f, 0.00621184f, -0.03339420f, 
    -0.04422687f, 0.02708209f, 0.05786022f, 0.00869370f, -0.24162124f, -0.10738550f, -0.02898970f, 0.00365845f, 
    0.12786005f, 0.00786795f, -0.09596930f, -0.01213834f, 0.05792769f, -0.02593973f, -0.01713391f, 0.12986897f, 
    0.06033703f, -0.06315457f, 0.20994519f, 0.04739159f, -0.01870600f, 0.01464119f, -0.03963589f, 0.13332115f, 
    0.11575770f, -0.12087750f, 0.02794503f, 0.01363983f, 0.04048013f, 0.07209602f, -0.11941624f, 0.00597744f, 
    0.01375763f, 0.14958137f, -0.05446433f, -0.21272963f, -0.19626486f, -0.04708436f, 0.00839953f, -0.06170415f, 
    -0.01588339f, -0.13761871f, -0.05745505f, -0.00824827f, 0.05438078f, 0.04342471f, 0.12918238f, -0.06584390f, 
    0.09722817f, 0.05285643f, -0.04575669f, 0.06083279f, -0.07670897f, 0.07639626f, -0.12196773f, -0.11975536f, 
    0.07380977f, 0.02026232f, 0.02314324f, 0.08502647f, 0.14237453f, 0.04751993f, -0.04742543f, 0.10498200f, 
    -0.10498509f, 0.02479278f, -0.06964181f, -0.07416402f, 0.05258401f, 0.03921553f, 0.11682006f, -0.10406782f, 
    0.00937043f, -0.06866036f, -0.08366390f, 0.11514017f, 0.17593633f, 0.08456242f, 0.29810014f, 0.04068233f, 
    0.02695289f, 0.03951625f, 0.03100515f, -0.08860506f, -0.02208263f, 0.07291692f, -0.07036901f, 0.00966929f, 
    0.08985218f, 0.05864530f, 0.21690693f, 0.15916155f, 0.08869246f, 0.04519290f, 0.07299691f, -0.02395017f, 
    0.04536191f, 0.09188176f, -0.11331493f, -0.13923848f, 0.15210639f, 0.11844993f, 0.05700790f, 0.17459744f, 
    -0.01078837f, 0.02344166f, 0.13525766f, -0.01164869f, 0.00000612f, 0.10047504f, 0.07185119f, 0.10218027f, 
    -0.11483038f, 0.10655539f, 0.04167934f, 0.03578948f, 0.11644979f, 0.01909514f, -0.03248923f, -0.01020151f, 
    0.07196866f, -0.02593368f, -0.00080503f, -0.01341866f, -0.16339953f, -0.19947924f, -0.14843781f, 0.04982939f, 
    -0.02534355f, -0.07475061f, 0.06189018f, 0.05275853f, 0.09936955f, -0.01410951f, 0.03713768f, 0.03409754f, 
    0.08464225f, 0.20212163f, 0.17475925f, -0.03459444f, 0.05102879f, 0.08755700f, 0.01747993f, -0.03248372f, 
    -0.06736771f, 0.06619582f, 0.02882765f, 0.13682403f, -0.31474885f, -0.15381712f, 0.06586839f, -0.07083683f, 
    -0.05678732f, 0.04878839f, 0.05451296f, -0.12328941f, 0.04466544f, 0.03511179f, -0.09881444f, 0.05264157f, 
    0.11041350f, 0.10457999f, 0.22701937f, 0.00985440f, -0.03182017f, -0.01674790f, -0.01338643f, -0.00280769f, 
    -0.00022365f, 0.07173205f, 0.00542166f, 0.15766007f, -0.10331310f, 0.08306504f, -0.06689912f, 0.13677092f, 
    -0.04081441f, 0.04972390f, 0.09252023f, 0.07614114f, 0.07879119f, 0.08643649f, 0.22297695f, 0.05249338f, 
    0.08676358f, -0.13474037f, -0.07462145f, -0.08322598f, -0.02190762f, 0.01660591f, 0.03725933f, -0.15431033f, 
    0.01355064f, 0.06918874f, -0.07468925f, -0.08721188f, 0.10609798f, 0.12919475f, 0.30308500f, 0.23763093f, 
    0.14102806f, 0.06603061f, 0.04085994f, 0.02214708f, -0.03195506f, 0.03274374f, 0.02764315f, -0.06789004f, 
    0.01332683f, -0.01586841f, -0.01766235f, -0.03750393f, 0.02672869f, -0.02591436f, -0.03049980f, 0.01011995f, 
    -0.03993531f, -0.02155411f, 0.00675593f, -0.04136717f, -0.03195515f, -0.02491363f, -0.02678540f, 0.01412546f, 
    -0.03048815f, -0.04069741f, 0.00708515f, 0.00836436f, 0.00447834f, -0.01865458f, -0.01122725f, -0.00314355f, 
    -0.00947316f, -0.04043460f, -0.00604930f, -0.00543729f, -0.02962141f, 0.01766329f, 0.02606310f, 0.01179149f, 
    -0.02974356f, 0.00951411f, 0.00344957f, 0.00766331f, -0.00905638f, -0.00037865f, 0.01218778f, 0.02179633f, 
    -0.00605450f, -0.00634331f, -0.02276446f, 0.02684276f, -0.00755731f, 0.01606134f, 0.00198733f, 0.00464626f, 
    -0.03878480f, 0.00768437f, -0.01436563f, 0.01728602f, -0.00379773f, 0.00240202f, -0.03029480f, 0.02135475f, 
    -0.02519288f, -0.00020897f, -0.00725469f, 0.01461056f, -0.04215748f, 0.01877866f, 0.01191982f, -0.02394892f, 
    0.01619664f, -0.02409990f, 0.02013740f, -0.04121401f, 0.02071624f, 0.00616299f, -0.03152249f, -0.01939466f, 
    -0.02355796f, 0.00662083f, -0.00279481f, 0.01020040f, -0.00520279f, -0.02014899f, 0.01551858f, -0.03689152f, 
    -0.03972617f, -0.00668012f, 0.02556337f, 0.00176004f, -0.04130651f, 0.00084660f, 0.02319355f, 0.01844292f, 
    -0.01394517f, -0.00127435f, 0.00099124f, -0.02195248f, -0.02026011f, -0.01131530f, 0.02194607f, -0.03078680f, 
    0.02771428f, -0.01909319f, -0.02936665f, -0.02738557f, -0.02067800f, -0.01300464f, 0.00965734f, 0.01420629f, 
    -0.03480573f, -0.04053479f, 0.01566697f, -0.04244170f, 0.01517978f, -0.01776431f, 0.00467826f, 0.00954168f, 
    -0.00504840f, 0.02465447f, 0.00239094f, -0.01244534f, -0.00123773f, -0.02665791f, -0.02799040f, 0.01777414f, 
    -0.01153896f, -0.02174117f, -0.03537613f, 0.00221208f, 0.02179317f, -0.03203519f, 0.00847493f, -0.01887133f, 
    -0.02374246f, -0.02524713f, 0.01950626f, -0.00696607f, -0.00900992f, -0.02597520f, -0.02776575f, -0.00087531f, 
    -0.04247242f, -0.03524354f, 0.01052720f, 0.01382764f, -0.01016741f, 0.01361757f, 0.00959030f, -0.04106759f, 
    0.01064380f, 0.02038591f, -0.03971133f, -0.03335421f, 0.01187487f, -0.02074016f, 0.01155838f, -0.01493802f, 
    -0.01690532f, -0.01778099f, -0.00184188f, 0.01371057f, 0.00882022f, -0.03023423f, 0.01240413f, 0.01947699f, 
    0.02705711f, -0.02618348f, -0.03474301f, 0.01590173f, -0.03339677f, 0.02341520f, -0.01148188f, -0.02041474f, 
    -0.02786352f, -0.02539867f, 0.00259425f, 0.02424299f, 0.00514757f, 0.01294950f, -0.01359587f, -0.03867732f, 
    -0.01986840f, -0.03141796f, -0.03817480f, 0.01900684f, -0.01499396f, 0.02185577f, -0.02283057f, -0.00396113f, 
    -0.01771226f, -0.02853645f, 0.00152968f, -0.02887039f, -0.02572370f, 0.00509235f, -0.01780676f, 0.00907205f, 
    0.01902397f, -0.02086083f, 0.00074918f, 0.00781948f, 0.00945771f, -0.01403590f, 0.00753339f, 0.00378944f, 
    0.00752071f, 0.01074602f, 0.00520980f, 0.02281919f, -0.03474265f, -0.03195914f, 0.02445901f, -0.03614841f, 
    -0.02849098f, 0.02371272f, 0.01619012f, -0.00678863f, 0.00374264f, 0.00189665f, 0.00950812f, -0.04072618f, 
    0.02390466f, -0.00611634f, 0.02467187f, 0.00263473f, 0.02415638f, -0.02270466f, 0.02584391f, -0.02306889f, 
    -0.01322972f, -0.01019885f, -0.03620541f, -0.02412215f, -0.02246155f, -0.03316167f, 0.00775852f, -0.03307025f, 
    -0.03975011f, -0.02366631f, -0.02025180f, -0.02822234f, 0.02875424f, 0.01259090f, -0.02281017f, -0.01038371f, 
    -0.00264477f, -0.03015246f, -0.01249627f, -0.02031797f, -0.03090548f, -0.03521835f, -0.03351530f, 0.01806537f, 
    -0.01124647f, -0.00403581f, 0.00551515f, -0.02340562f, -0.00775051f, -0.02145076f, -0.01877081f, 0.01589904f, 
    -0.01330983f, -0.02505370f, 0.02423033f, -0.01796127f, 0.01120231f, 0.00481229f, 0.00052863f, -0.02700669f, 
    -0.01812075f, -0.01462728f, -0.03869777f, -0.00312048f, 0.01167855f, -0.04257735f, -0.01553406f, -0.00541474f, 
    -0.02690389f, 0.00743051f, 0.01441585f, -0.00891294f, 0.01906895f, -0.01957677f, 0.00541636f, 0.02060366f, 
    -0.00028415f, -0.02597932f, 0.01962020f, -0.00594884f, 0.01577427f, -0.03785104f, 0.01128538f, 0.00521269f, 
    -0.02480639f, 0.01066526f, -0.03095012f, -0.02951190f, 0.00527085f, 0.01115134f, -0.03877948f, -0.00387143f, 
    0.00119961f, 0.00876298f, -0.01937972f, -0.02771116f, -0.00306613f, -0.01597661f, 0.03176845f, 0.00268556f, 
    0.00204018f, -0.03271694f, 0.00776687f, 0.02622899f, -0.01814266f, 0.02173178f, -0.00139905f, 0.02152009f, 
    -0.01465859f, -0.00613629f, -0.03616209f, -0.02226246f, -0.01287788f, 0.01506699f, -0.03410889f, 0.00125550f, 
    0.02133489f, 0.00986711f, -0.04357597f, -0.01901366f, -0.00580909f, -0.03829359f, -0.03404172f, -0.04092822f, 
    -0.03761832f, -0.03138842f, -0.04328641f, -0.02116088f, 0.02644527f, -0.02599030f, 0.01612771f, 0.00133756f, 
    0.01377145f, -0.00615488f, -0.02574550f, -0.00175832f, 0.00364331f, -0.03428176f, 0.01451566f, -0.02338704f, 
    -0.02072496f, -0.01264598f, 0.01973526f, -0.02129364f, -0.04351030f, 0.01440533f, -0.01759806f, -0.00973741f, 
    0.02532374f, -0.01110810f, -0.02161492f, -0.03873491f, 0.02571701f, 0.00861626f, -0.00338862f, 0.00655474f, 
    0.01562200f, 0.01169783f, -0.00256388f, 0.01682571f, 0.01193674f, 0.02177871f, 0.01330031f, -0.01481025f, 
    0.00897989f, -0.00944196f, 0.02761053f, -0.04322413f, 0.02807613f, 0.01550846f, 0.01256037f, 0.01464970f, 
    0.00703913f, -0.02570210f, -0.04171281f, -0.00277556f, 0.00392215f, -0.03481562f, -0.03378798f, -0.01728553f, 
    -0.00284322f, -0.03645281f, 0.00299463f, -0.01566359f, 0.00507845f, -0.01337131f, -0.00049287f, 0.01535728f, 
    -0.01206813f, -0.03215694f, 0.01949382f, 0.02466014f, 0.00734779f, -0.01589179f, -0.03299180f, -0.00330221f, 
    -0.00497237f, 0.01284896f, -0.00828436f, -0.02681200f, -0.03829597f, -0.03422805f, -0.01247344f, 0.00151389f, 
    0.01246687f, -0.02319656f, -0.02288756f, -0.02990858f, 0.01820717f, -0.04288615f, 0.00368600f, -0.02703670f, 
    -0.03417054f, 0.01313610f, 0.00637423f, 0.02030871f, -0.04227468f, -0.03942749f, -0.03190001f, 0.02022115f, 
    -0.01313968f, -0.04247864f, -0.00211056f, -0.04049666f, -0.00288835f, 0.00805268f, -0.02417048f, -0.01853582f, 
    -0.02241543f, 0.02303017f, 0.02501307f, -0.01819392f, -0.01746127f, -0.02173486f, 0.00282416f, 0.00061784f, 
    0.01005010f, -0.03954312f, 0.01539047f, 0.02563897f, 0.01318633f, -0.03989372f, -0.01687381f, 0.00461411f, 
    0.00873998f, -0.02993073f, -0.03778077f, 0.02268196f, -0.04391123f, -0.03104086f, -0.00791691f, -0.02088179f, 
    0.02110344f, 0.00795309f, -0.00792790f, -0.01997488f, -0.02549483f, -0.02389212f, -0.02598436f, -0.01905853f, 
    0.00431427f, -0.00459885f, -0.01956799f, 0.01226939f, 0.00638542f, -0.00242327f, -0.00722993f, 0.01272457f, 
    -0.03308751f, 0.00359900f, -0.02069228f, -0.02310792f, -0.04254781f, -0.01018884f, 0.02254981f, -0.01328574f, 
    0.01918246f, 0.03708573f, -0.03538534f, -0.01289229f, -0.04334645f, -0.03858094f, -0.02547721f, -0.02211600f, 
    0.01240558f, -0.00945570f, -0.04036398f, 0.02547594f, -0.00565152f, -0.04103661f, -0.00896717f, 0.01481840f, 
    -0.01205593f, 0.02307866f, -0.01378533f, 0.00668334f, -0.00976506f, -0.02297544f, -0.04054954f, -0.03516404f, 
    -0.03794551f, -0.04066527f, 0.00727583f, -0.02624909f, 0.00083465f, -0.02163740f, 0.01831940f, -0.00535404f, 
    -0.02508893f, 0.00979283f, -0.01507589f, 0.00142605f, -0.01829657f, -0.03944559f, 0.01392476f, 0.01443458f, 
    0.01067693f, -0.00264796f, -0.02694455f, 0.00964333f, -0.00608685f, 0.01869418f, -0.00816522f, -0.01864662f, 
    -0.00459669f, 0.01016182f, -0.03102949f, 0.02231339f, -0.03242603f, -0.04139843f, 0.01285031f, -0.03278573f, 
    -0.00750254f, 0.02473824f, 0.00336653f, 0.01050973f, -0.01107284f, 0.02494423f, 0.01198012f, -0.01658925f, 
    -0.01854118f, 0.02133744f, 0.01449576f, -0.04211630f, -0.02382907f, 0.00967492f, -0.02292947f, 0.02756129f, 
    -0.04045675f, -0.03094215f, -0.03318014f, -0.00666003f, 0.00454520f, 0.01575715f, -0.00271138f, 0.00514508f, 
    0.02428085f, 0.00059150f, 0.00738546f, 0.00125609f, 0.01822095f, -0.02581386f, 0.02354227f, -0.01776343f, 
    0.00142452f, -0.01919584f, 0.02317888f, -0.00664024f, -0.01910979f, -0.04172415f, -0.03793186f, 0.02176716f, 
    0.01757533f, 0.02020576f, -0.00385136f, 0.00724701f, -0.03322374f, -0.01348924f, -0.00196985f, 0.01147745f, 
    -0.03229768f, 0.00192822f, -0.04157922f, 0.02505078f, -0.03306710f, -0.01962017f, -0.04237430f, -0.00453869f, 
    -0.00095128f, 0.00447125f, 0.01420648f, -0.02824222f, -0.02012994f, 0.00795790f, 0.01029451f, -0.04340906f, 
    0.02204723f, 0.01079932f, 0.02589960f, -0.03445712f, 0.01757990f, -0.03882308f, 0.01370913f, 0.02067106f, 
    -0.02388903f, -0.02774226f, 0.00112145f, -0.02653207f, -0.02313675f, -0.01277678f, 0.01326568f, 0.01869751f, 
    0.00220724f, -0.02585147f, 0.01387664f, 0.02024290f, -0.01298319f, -0.03481032f, 0.00472803f, -0.02960958f, 
    -0.03330339f, -0.03627363f, 0.01830021f, -0.01237499f, -0.00299590f, -0.02241973f, -0.04111705f, 0.02103521f, 
    -0.02583830f, -0.03612894f, 0.01191903f, -0.02848551f, 0.00762623f, 0.00790915f, 0.02435255f, -0.02040139f, 
    -0.01693859f, -0.00681143f, 0.02315687f, 0.00513538f, -0.02673524f, 0.01463408f, -0.00092484f, 0.02558250f, 
    -0.01319709f, 0.01694389f, -0.02941300f, 0.00602449f, 0.00532212f, 0.03118358f, 0.02668884f, -0.04087764f, 
    -0.01971678f, -0.02741952f, -0.03663893f, -0.01255971f, -0.01094035f, -0.01629148f, -0.02674949f, -0.03647621f, 
    -0.00537357f, -0.02919210f, -0.02170922f, 0.02318830f, -0.00900886f, -0.04109327f, 0.01721807f, 0.01094321f, 
    -0.02569544f, 0.02748627f, -0.03830124f, -0.02640219f, -0.00380363f, -0.00954920f, 0.03099663f, -0.02190848f, 
    -0.02906755f, -0.02115693f, 0.00507953f, 0.02675632f, -0.01673932f, -0.01043946f, -0.03125134f, -0.01241487f, 
    0.00414927f, -0.03195155f, 0.01192211f, 0.01428990f, 0.02411956f, 0.00962633f, -0.00039801f, -0.01937849f, 
    0.01267329f, 0.00735347f, -0.00027626f, -0.01452104f, -0.00236623f, -0.02208765f, -0.02786100f, -0.02926889f, 
    0.01885155f, 0.00363008f, 0.02952403f, 0.02697418f, 0.01586695f, -0.01907392f, -0.02020178f, -0.02455630f, 
    0.00624413f, -0.03009646f, 0.00924650f, 0.00891827f, 0.01114751f, -0.02753534f, -0.01605319f, -0.03824731f, 
    -0.00368266f, 0.01891358f, -0.03420492f, -0.01582785f, -0.03477439f, 0.01584600f, -0.02311751f, -0.00298511f, 
    0.00943407f, -0.02665312f, 0.00623008f, -0.01719620f, -0.03912701f, 0.00677934f, -0.01841383f, -0.00774282f, 
    0.01285882f, -0.02274106f, -0.00074188f, 0.02942153f, -0.02228898f, -0.03072964f, 0.02122641f, -0.00476147f, 
    0.01237911f, -0.01897548f, 0.01504039f, -0.03930686f, -0.02954532f, -0.02893392f, 0.00506477f, 0.02477460f, 
    0.00763274f, -0.00999077f, -0.04219129f, 0.00457060f, -0.01593336f, -0.02279527f, 0.00669278f, -0.02585619f, 
    -0.01777085f, 0.02142766f, -0.03940354f, -0.00215815f, -0.00841856f, -0.00625189f, -0.02378783f, -0.00763308f, 
    0.12261462f, 0.01941203f, -0.02090177f, -0.04891801f, -0.10377862f, 0.03564163f, 0.11359830f, 0.02133295f, 
    -0.07814986f, 0.13949521f, -0.03908977f, 0.11032149f, 0.10608166f, -0.02180663f, 0.05956133f, -0.03388650f, 
    0.07988388f, 0.10032195f, 0.11361527f, 0.01973024f, 0.05479372f, 0.01668986f, 0.16185682f, 0.09350360f, 
    -0.06194753f, -0.11448264f, 0.09957712f, 0.19475845f, -0.00878938f, -0.03659454f, 0.01301032f, -0.05880601f, 
    0.08128834f, 0.08021734f, 0.02733330f, 0.06149652f, -0.05671911f, -0.08780055f, 0.17778425f, 0.15433186f, 
    -0.04286107f, 0.07060199f, -0.01226697f, 0.08577816f, -0.01903128f, 0.03558446f, -0.09067181f, -0.00115476f, 
    0.11785441f, -0.19269431f, -0.22318500f, -0.00293174f, -0.05133281f, 0.03214692f, 0.00591587f, 0.11039978f, 
    0.02433194f, 0.04183381f, 0.00665076f, 0.11416083f, -0.04275535f, -0.20558622f, 0.07469098f, 0.13652691f, 
    0.05705286f, 0.13331236f, 0.01389326f, 0.07843089f, 0.10513011f, -0.03541616f, 0.04202736f, -0.01680532f, 
    -0.12992264f, 0.07084266f, 0.18022856f, -0.06285596f, -0.01519153f, 0.02126686f, -0.00114165f, -0.02054378f, 
    0.15055929f, 0.21114840f, -0.03781375f, -0.08502429f, -0.10927706f, -0.08663422f, 0.14291449f, -0.01284899f, 
    0.00089463f, 0.13027932f, 0.05548247f, 0.00288558f, 0.11141219f, -0.03530358f, -0.08810836f, 0.01480853f, 
    0.28615874f, 0.06678383f, -0.07994734f, -0.02379604f, -0.00870228f, -0.05146764f, 0.01479403f, 0.10299044f, 
    0.06701156f, 0.10778809f, -0.12547566f, 0.01172522f, -0.06275369f, 0.04307752f, 0.10473408f, -0.01590803f, 
    0.13266091f, 0.05949606f, 0.00611149f, -0.10558853f, -0.00483786f, -0.09295426f, 0.13600755f, 0.09869129f, 
    -0.23539460f, 0.09108997f, 0.21017762f, 0.21830648f, -0.00023781f, 0.12652434f, 0.02500811f, 0.00301618f, 
    -0.01332559f, 0.04984479f, 0.04230359f, 0.02399277f, 0.22502635f, 0.07691377f, -0.01814024f, -0.03163549f, 
    0.07032414f, 0.02999876f, -0.10563780f, 0.05400722f, -0.05654098f, -0.04087429f, 0.03388595f, 0.03772793f, 
    0.05237557f, 0.03232915f, -0.08873813f, -0.09549882f, -0.00910906f, 0.05426187f, 0.04054491f, -0.06836283f, 
    0.00758296f, -0.07385547f, 0.07286721f, -0.08924079f, 0.10117324f, 0.00749671f, -0.01609059f, -0.23392603f, 
    -0.10679144f, -0.02192304f, 0.06974134f, -0.01559765f, 0.06636085f, 0.04180459f, 0.00325428f, 0.15892646f, 
    -0.06061150f, -0.12770949f, 0.01281955f, 0.02928948f, 0.03195607f, 0.03788414f, 0.09731187f, 0.00905799f, 
    0.00231702f, 0.09482939f, -0.00262878f, 0.21900553f, -0.06099578f, -0.17197131f, 0.00876492f, -0.04042216f, 
    0.00473200f, -0.05223481f, 0.02966444f, -0.05671958f, -0.09729590f, 0.01887224f, -0.07109176f, 0.00135193f, 
    0.10206495f, 0.12653442f, -0.00229620f, -0.11584374f, 0.00107332f, -0.00502688f, 0.00995769f, 0.06882163f, 
    -0.00822386f, 0.08138414f, -0.06497175f, -0.13097565f, -0.31802455f, -0.04731035f, 0.08045217f, 0.18682376f, 
    0.02026998f, 0.12557471f, 0.13585967f, 0.13524702f, 0.09123158f, -0.12471831f, 0.03474197f, -0.08462198f, 
    0.26094466f, -0.04388903f, -0.02592146f, 0.01931075f, 0.05897838f, 0.05205673f, -0.02707857f, 0.12513423f, 
    -0.06499393f, -0.11577902f, -0.02769401f, 0.01076335f, -0.17271814f, -0.24574329f, -0.16259000f, -0.08021998f, 
    0.09031576f, 0.01104709f, 0.12651451f, 0.09166120f, 0.02221652f, 0.11991853f, 0.04950183f, 0.04649131f, 
    -0.04123126f, 0.09337804f, 0.07790625f, -0.05329201f, -0.02670326f, 0.00566471f, -0.02062154f, 0.00402039f, 
    0.05232821f, 0.10353831f, -0.16739860f, -0.09098364f, 0.07547407f, -0.26252744f, -0.04592018f, 0.12282578f, 
    -0.01231697f, -0.05899158f, -0.03450314f, 0.01132671f, 0.06655280f, 0.08124314f, 0.00591827f, 0.07208294f, 
    -0.33201063f, 0.02766308f, 0.04648954f, 0.15172972f, -0.00324915f, -0.11341564f, 0.07873495f, 0.00535484f, 
    -0.01689832f, 0.07791300f, -0.04106750f, 0.07373413f, 0.13913263f, -0.14509857f, -0.18288209f, -0.04288612f, 
    -0.06964272f, -0.10034419f, 0.00651135f, -0.01167644f, -0.06562824f, -0.00319149f, -0.03489969f, 0.02955771f, 
    -0.26264462f, 0.06342392f, 0.08392775f, 0.00570035f, 0.00829661f, 0.04553076f, 0.14625718f, 0.02256251f, 
    0.03684010f, 0.07479165f, 0.08249044f, 0.01637985f, 0.07655383f, -0.19088709f, 0.12232465f, 0.05248889f, 
    -0.04408697f, 0.02798481f, -0.00456691f, 0.04046020f, -0.05312769f, -0.02472272f, -0.13913298f, -0.01278205f, 
    -0.07244919f, 0.01306329f, 0.03251443f, 0.19861260f, -0.00759404f, 0.07322901f, 0.08554629f, 0.00847262f, 
    -0.01084109f, 0.12245187f, 0.03777421f, 0.06233812f, -0.09564535f, 0.21952373f, 0.05783611f, -0.04077253f, 
    0.10017524f, 0.10866614f, 0.01808250f, 0.04468076f, -0.00663259f, 0.05341982f, -0.03794258f, -0.10808609f, 
    0.19969204f, -0.10554269f, -0.13735913f, 0.02695550f, -0.00438887f, 0.02123772f, -0.05013068f, 0.04549412f, 
    0.01193110f, 0.04295843f, -0.05167619f, -0.08454704f, 0.04541642f, 0.01466911f, -0.04275275f, 0.02748800f, 
    0.00352260f, 0.02319323f, -0.02378497f, -0.07093367f, 0.12477951f, 0.00228860f, 0.09148412f, 0.12538528f, 
    -0.04833651f, -0.07201678f, 0.10758571f, -0.00755449f, 0.02014579f, -0.05664827f, 0.10857672f, -0.00215988f, 
    -0.00717270f, 0.03800588f, 0.11510938f, -0.10499815f, -0.13617855f, -0.16085717f, -0.17407148f, -0.00650562f, 
    -0.04823203f, 0.05404305f, 0.11915110f, 0.03624702f, -0.01586170f, -0.05254560f, 0.06799567f, -0.00167134f, 
    -0.22455898f, -0.03350771f, -0.03295792f, -0.32663897f, 0.15362874f, -0.01167662f, -0.01231735f, 0.09456076f, 
    0.02449347f, -0.06487235f, -0.08413043f, 0.09192689f, 0.09021563f, 0.02302644f, -0.00870086f, 0.03593041f, 
    0.10881040f, 0.03897324f, -0.01764370f, 0.04158590f, 0.06951460f, -0.06306109f, 0.03800500f, -0.10271645f, 
    -0.17844571f, -0.19806011f, -0.09088492f, -0.06213689f, -0.11582237f, -0.18930727f, -0.10646936f, -0.01867224f, 
    -0.05341917f, 0.03136152f, 0.02326400f, -0.08967179f, -0.10865828f, 0.07948153f, -0.01710328f, -0.12496727f, 
    0.09567577f, 0.07594300f, 0.09083360f, 0.03836983f, 0.03402064f, 0.04225975f, 0.02472522f, -0.00731426f, 
    0.13072297f, -0.05143605f, -0.02869539f, 0.01479856f, 0.07330773f, 0.03876732f, -0.04020366f, -0.02497585f, 
    -0.11592539f, 0.04403272f, 0.00773820f, 0.07917315f, 0.03681216f, 0.07027503f, -0.01252227f, 0.00259814f, 
    0.05145051f, 0.00084756f, 0.11454543f, -0.02193262f, 0.11664364f, -0.02954635f, 0.02469823f, -0.03611415f, 
    0.19492902f, -0.13458470f, -0.09738135f, 0.10783941f, 0.09280117f, -0.03375865f, 0.01953524f, -0.04518038f, 
    -0.02358078f, -0.03731294f, 0.04963698f, -0.00136911f, -0.15986203f, 0.02261547f, -0.07664295f, 0.07952514f, 
    -0.04538507f, -0.01404785f, 0.12172720f, 0.03038659f, -0.08333095f, -0.01195438f, -0.01104022f, 0.03233063f, 
    -0.05750341f, -0.13006748f, -0.09777188f, 0.00407398f, -0.00679804f, -0.06993909f, -0.00647464f, -0.02089953f, 
    -0.09338361f, -0.07451957f, -0.03730424f, 0.02452352f, 0.45530242f, 0.09549852f, 0.01290078f, 0.06583292f, 
    0.01706896f, 0.11287680f, 0.01331738f, 0.05025067f, 0.05152033f, 0.05533502f, -0.00125706f, 0.03369652f, 
    0.04842621f, 0.06289575f, 0.05096491f, -0.04376521f, -0.04067709f, 0.06767185f, -0.02663391f, -0.08643609f, 
    0.01309759f, 0.09419548f, 0.07956925f, -0.00713896f, -0.27633557f, -0.00797162f, -0.03899190f, -0.13407727f, 
    0.04138125f, 0.02366944f, 0.00476281f, 0.08611762f, 0.06503374f, 0.13564435f, 0.05301088f, 0.13444789f, 
    -0.03532718f, 0.00553674f, -0.07564427f, 0.14707741f, 0.06251178f, 0.01125201f, 0.06864821f, -0.10223821f, 
    0.11802416f, -0.04890462f, 0.14955789f, -0.16192849f, 0.11559415f, -0.01274717f, 0.05234922f, 0.01046705f, 
    0.02316261f, 0.00333534f, -0.02164046f, -0.14681070f, -0.06865522f, 0.00138436f, -0.03103992f, 0.14351551f, 
    0.13793832f, 0.00499522f, -0.11862358f, -0.21007796f, -0.03745607f, -0.05520118f, -0.06257824f, 0.07053040f, 
    -0.03265155f, 0.08748621f, -0.04755635f, -0.02112970f, -0.12573297f, -0.13377905f, -0.07569029f, -0.06477065f, 
    -0.02820365f, -0.08023911f, 0.05059972f, -0.06325171f, -0.09253739f, 0.08879974f, 0.02756940f, -0.03750408f, 
    -0.17301106f, 0.21300630f, 0.02269363f, 0.16034299f, 0.02616326f, 0.13199842f, 0.03439274f, -0.16878347f, 
    -0.10356231f, 0.07899988f, 0.02544007f, 0.03464798f, -0.07314442f, -0.00806756f, 0.21994004f, 0.12289054f, 
    -0.04088847f, 0.01966965f, 0.04570805f, 0.01851049f, 0.13744946f, 0.14694645f, 0.02627408f, -0.07872546f, 
    0.27789509f, 0.09048469f, -0.11145546f, -0.04176847f, 0.05836782f, 0.06743622f, 0.02090035f, 0.03168372f, 
    -0.04242617f, 0.01741477f, 0.05385775f, 0.01859186f, 0.20300135f, -0.09784281f, 0.09287133f, 0.07992976f, 
    0.11127230f, 0.03407509f, -0.00102947f, -0.00107058f, 0.06655502f, 0.01568478f, 0.11163035f, -0.08442037f, 
    0.01375933f, 0.07029341f, 0.17581311f, 0.07581937f, 0.00818224f, 0.05753277f, -0.02170758f, 0.06098788f, 
    -0.00699357f, 0.06358941f, 0.05299989f, -0.03582194f, -0.28411633f, 0.01074673f, -0.11466070f, -0.00617732f, 
    0.14645223f, 0.01849240f, 0.03189250f, 0.02569901f, 0.05196697f, -0.01299226f, 0.08616297f, 0.01775449f, 
    0.03298943f, 0.03750921f, -0.00003246f, -0.14305131f, 0.09516273f, 0.09011659f, 0.02777832f, -0.01618489f, 
    -0.02740622f, 0.00436069f, 0.09302058f, 0.08282904f, 0.00274508f, 0.21175823f, -0.00873499f, -0.29806796f, 
    0.18796113f, 0.12675892f, 0.03083765f, 0.07855700f, 0.06350480f, 0.03285906f, -0.00842392f, -0.01698791f, 
    -0.32386318f, -0.02290999f, 0.06350690f, 0.15102492f, -0.04845283f, -0.00913683f, 0.03878954f, 0.08481362f, 
    0.07839523f, 0.01299741f, -0.05646814f, 0.06535225f, 0.10379854f, -0.03857044f, -0.07724714f, 0.00523539f, 
    -0.04143981f, 0.02943635f, 0.00542817f, 0.00912318f, -0.17305675f, 0.01488167f, -0.09903182f, -0.00225350f, 
    -0.04487336f, 0.13578381f, 0.09545659f, 0.06288750f, 0.00636223f, 0.04805658f, 0.02916351f, -0.03681139f, 
    0.11312891f, -0.01169434f, 0.04071630f, -0.11335899f, 0.20679557f, 0.05711256f, 0.00390300f, -0.03588390f, 
    -0.05928181f, 0.03504551f, -0.01390948f, 0.15771064f, -0.03067534f, 0.00367596f, 0.07847455f, -0.00524549f, 
    -0.16276376f, -0.05504786f, -0.07157749f, 0.03683872f, 0.08967023f, 0.08629476f, 0.07132540f, 0.07025687f, 
    0.03904876f, -0.13147922f, 0.07816473f, 0.04060899f, 0.24426578f, -0.06383304f, -0.01442440f, -0.07828460f, 
    0.09487990f, 0.03829961f, -0.06688303f, 0.06959303f, -0.02953387f, -0.04018198f, -0.05266442f, 0.06664406f, 
    0.08424100f, -0.23134451f, -0.14427701f, 0.00492399f, -0.04847987f, -0.03050850f, -0.04602901f, 0.12274837f, 
    0.03225075f, -0.01106993f, 0.07107219f, 0.02357602f, -0.07908424f, 0.03204777f, -0.12859911f, -0.24414276f, 
    0.00664915f, -0.00078164f, 0.07234910f, 0.06802636f, 0.02335438f, 0.02019524f, 0.03255356f, 0.07733231f, 
    0.00514365f, 0.09214446f, -0.07673325f, 0.08850543f, 0.08483793f, 0.06992476f, -0.07321353f, 0.04490905f, 
    0.04644861f, -0.08011439f, 0.11661638f, -0.05042658f, -0.12221679f, 0.05110301f, -0.13927950f, 0.11989082f, 
    0.06416316f, -0.02382451f, 0.03793713f, 0.03230346f, 0.02432199f, 0.03239442f, -0.04990776f, 0.01071691f, 
    -0.02335084f, -0.06275544f, 0.04289848f, -0.15270001f, 0.04260314f, 0.01019723f, -0.02990369f, 0.00386710f, 
    -0.08022435f, 0.00728370f, 0.01670156f, -0.01852052f, 0.23258176f, -0.05237594f, 0.11354996f, -0.22792856f, 
    0.08647116f, -0.10336433f, 0.12075959f, -0.04754530f, 0.01775590f, 0.03007381f, 0.08624043f, 0.00833561f, 
    -0.06373784f, 0.05922645f, 0.16042569f, -0.02820124f, 0.09558747f, 0.14947754f, 0.09832494f, 0.08153656f, 
    -0.05011287f, 0.03732312f, 0.10176979f, 0.01582031f, 0.11849716f, 0.26155186f, -0.00504736f, -0.13396519f, 
    -0.09730847f, -0.04744146f, 0.03843790f, -0.07603893f, -0.06773655f, 0.05091027f, 0.07764464f, -0.01409264f, 
    0.28657636f, 0.03752655f, 0.09890769f, 0.00520630f, -0.02009325f, 0.00862326f, 0.10335182f, 0.07985856f, 
    -0.07639234f, -0.04347443f, -0.04420231f, 0.05392149f, -0.05796514f, 0.01573238f, -0.14423747f, 0.06178853f, 
    -0.03533107f, -0.06915593f, 0.07121710f, -0.00559370f, -0.04117758f, 0.01786794f, -0.02210142f, 0.03466423f, 
    -0.19723959f, 0.07861725f, -0.02630631f, 0.03754560f, 0.03524586f, 0.15409146f, -0.07316760f, -0.01885427f, 
    0.01375316f, -0.05139114f, 0.08999956f, -0.00384585f, 0.11439350f, 0.07234200f, -0.11670323f, 0.13377252f, 
    -0.01831848f, 0.06522746f, -0.05503405f, 0.03811240f, -0.02353360f, -0.04479463f, -0.09210341f, -0.06519071f, 
    0.35854119f, -0.08777433f, 0.09709339f, -0.18267739f, -0.07318718f, -0.05325775f, 0.06238188f, 0.06911027f, 
    0.00624238f, -0.03583802f, 0.15547276f, 0.00984648f, -0.14161676f, 0.07736485f, -0.01851887f, 0.00627174f, 
    -0.00299668f, -0.04813685f, -0.06176680f, 0.06006308f, 0.08053631f, 0.04317758f, -0.01797580f, 0.01321942f, 
    -0.05226167f, -0.07513585f, 0.00391456f, 0.11113193f, 0.08732032f, -0.07586890f, -0.06271520f, 0.07351901f, 
    -0.07153033f, -0.00602988f, -0.13742818f, 0.04036849f, -0.19640546f, -0.05319199f, 0.01291713f, 0.04420936f, 
    0.04381569f, 0.01628952f, -0.04021927f, -0.06169003f, 0.00439615f, -0.00136299f, 0.03389336f, -0.07466742f, 
    -0.19819570f, 0.11480411f, -0.01671019f, 0.04393652f, 0.09428606f, 0.09169301f, 0.11193107f, 0.08330874f, 
    0.03677258f, -0.03388739f, -0.02259876f, -0.00594471f, 0.00435550f, -0.02246683f, 0.16891862f, 0.10391022f, 
    0.06625236f, 0.03175909f, 0.05458622f, 0.01342954f, 0.11252487f, -0.05790479f, 0.01811874f, -0.15110688f, 
    -0.07068186f, 0.00871034f, -0.05616660f, 0.06849463f, -0.06543729f, 0.00877755f, -0.00216180f, -0.02678408f, 
    0.08605586f, 0.02511588f, 0.01084102f, 0.00231928f, 0.27779740f, -0.07455320f, 0.15023510f, -0.04723306f, 
    0.06217849f, -0.04230631f, 0.07268506f, -0.00277631f, -0.03749903f, 0.10138353f, 0.01393571f, 0.07261056f, 
    0.02382229f, 0.05483506f, -0.00590310f, 0.06323560f, 0.06359521f, 0.08474503f, -0.04249606f, -0.04072626f, 
    0.05466538f, 0.02323163f, 0.04117752f, 0.01082857f, 0.44097623f, 0.02733427f, 0.21568961f, -0.07307605f, 
    0.08624003f, 0.05526032f, 0.02490179f, -0.05842578f, 0.02011970f, -0.02503359f, -0.01005980f, -0.05575604f, 
    0.06684026f, 0.08347111f, 0.01302636f, 0.18523033f, 0.07085647f, 0.06560784f, 0.03605879f, 0.02916700f, 
    -0.02026727f, -0.08357965f, -0.00898193f, 0.02731698f, 0.06794561f, 0.02964560f, 0.15367097f, -0.05535717f, 
    0.12328361f, -0.06661980f, 0.06416756f, 0.04262955f, 0.01409556f, 0.03204971f, -0.03716100f, -0.06111106f, 
    0.28876635f, -0.05838096f, -0.00938090f, -0.07618316f, 0.13835980f, -0.03821212f, -0.00490957f, -0.03349023f, 
    -0.03456340f, -0.00031540f, 0.01665794f, 0.03277055f, 0.07700938f, 0.14578658f, 0.05521688f, 0.01198580f, 
    0.10498475f, 0.01574929f, 0.03772120f, 0.08191139f, 0.11941432f, -0.01369328f, -0.02201364f, 0.04254332f, 
    0.49334404f, 0.11502878f, 0.08400731f, -0.05738923f, -0.08007672f, -0.04693916f, -0.05303172f, 0.07131012f, 
    0.07398500f, -0.04701737f, 0.03326929f, 0.04186171f, 0.21831514f, -0.00233737f, 0.03598578f, -0.07746511f, 
    0.03404553f, 0.06182363f, 0.09391160f, -0.07656108f, -0.01240539f, 0.00357665f, 0.03621786f, 0.04132060f, 
    0.38603970f, 0.10778518f, 0.11321105f, -0.15350229f, 0.01678983f, -0.08755618f, 0.03828664f, 0.05443858f, 
    0.05367421f, -0.08004430f, 0.05743682f, 0.02124422f, 0.17365600f, -0.12332312f, -0.02523214f, 0.11399376f, 
    -0.09072012f, 0.03566683f, -0.07056846f, -0.00791275f, 0.03827101f, 0.00181589f, -0.00709606f, -0.01384181f, 
    -0.01863179f, -0.07034674f, 0.07317802f, -0.00317038f, 0.00379234f, -0.02230491f, -0.04963447f, 0.00533446f, 
    -0.11584894f, -0.00371098f, 0.06373789f, 0.00048703f, -0.21868348f, -0.09515527f, 0.01133116f, -0.00513400f, 
    -0.03516394f, 0.00827374f, -0.07880116f, -0.01005808f, -0.01849687f, 0.00670127f, 0.03397192f, -0.01955750f, 
    0.07148491f, 0.00573292f, -0.02378297f, -0.02909915f, -0.05977397f, 0.08884477f, -0.06192902f, 0.06825510f, 
    -0.00040779f, -0.01515387f, 0.02154400f, 0.07180303f, 0.09648664f, 0.16300146f, 0.14401312f, 0.05028102f, 
    0.16731638f, 0.07138107f, 0.00332165f, 0.03925448f, 0.10075787f, -0.00046855f, 0.03362374f, 0.02983754f, 
    0.30623010f, 0.12185946f, -0.06534036f, 0.25019512f, -0.02237292f, -0.02108095f, 0.04696848f, -0.02714703f, 
    0.07751159f, 0.03071140f, -0.02269099f, -0.07753433f, -0.13722913f, -0.03934323f, 0.05444015f, -0.04140232f, 
    -0.04518983f, -0.04869676f, 0.08348386f, -0.04569080f, -0.01536533f, 0.03488963f, -0.00663880f, 0.02272493f, 
    0.18589154f, 0.08171422f, 0.07585185f, 0.17630664f, 0.14583352f, 0.11128616f, 0.05739340f, 0.15115832f, 
    -0.02153937f, 0.11294014f, -0.06284967f, -0.07237376f, 0.41290209f, 0.04419546f, 0.11376732f, 0.09072477f, 
    -0.03953356f, -0.07279268f, -0.09876499f, -0.04062205f, 0.05087076f, -0.05877415f, 0.01648385f, -0.00361196f, 
    0.10237857f, -0.00609427f, 0.03441030f, -0.09704029f, 0.04318180f, 0.09192497f, -0.09989221f, 0.07972977f, 
    0.05977690f, -0.00155062f, 0.02851665f, -0.00154551f, -0.00703679f, -0.09535732f, -0.07239515f, 0.00476785f, 
    0.00668368f, 0.02179579f, -0.04784681f, 0.04301888f, -0.08859913f, -0.00198615f, -0.03193876f, 0.00364091f, 
    -0.26657304f, -0.01215420f, -0.02185864f, -0.11747091f, -0.01288484f, 0.08205415f, -0.12476150f, 0.03709595f, 
    0.01375990f, 0.00319198f, -0.02508949f, 0.00495744f, 0.10483878f, -0.10356168f, 0.11016265f, -0.07506884f, 
    0.15028067f, -0.04040202f, 0.10417488f, -0.08917633f, -0.06750161f, -0.03863471f, -0.06588228f, -0.01842067f, 
    0.09378848f, 0.19665079f, 0.08425817f, 0.18891598f, 0.02329241f, 0.00983694f, -0.03908676f, 0.08655882f, 
    0.12841900f, 0.00249364f, 0.02951918f, -0.00486585f, -0.48646766f, -0.15479362f, 0.01156050f, -0.02746128f, 
    -0.10751615f, 0.01970849f, -0.00909782f, -0.07483000f, -0.11508834f, -0.04798646f, -0.00050140f, -0.02831564f, 
    -0.02331441f, -0.09158830f, -0.03764386f, -0.01619239f, -0.17785063f, -0.02854268f, -0.04581215f, 0.06371229f, 
    -0.00199464f, -0.04289185f, 0.01406727f, -0.02959411f, 0.12448793f, 0.13180506f, 0.01665049f, 0.20763493f, 
    0.04404701f, 0.07953735f, 0.01169608f, 0.07458136f, 0.04861717f, -0.02221185f, 0.01867103f, -0.06037814f, 
    0.17533256f, -0.10001121f, 0.10735118f, -0.05524230f, -0.00623355f, 0.02087063f, 0.00210086f, 0.09631099f, 
    -0.13379543f, 0.09171573f, 0.03699069f, 0.06040606f, -0.25145641f, -0.01178868f, -0.02453573f, 0.05485513f, 
    0.12802707f, 0.10315915f, 0.05721594f, 0.08900701f, 0.02433754f, -0.05980775f, 0.00509008f, 0.09886112f, 
    0.09214409f, 0.14012304f, 0.00478423f, 0.15280092f, 0.00892525f, 0.02631202f, 0.00561428f, 0.14967464f, 
    0.05850188f, 0.05975404f, -0.08460591f, 0.01833307f, 0.07259545f, 0.05789692f, -0.00150833f, 0.18333940f, 
    0.03892209f, 0.07086419f, -0.00882756f, 0.05546000f, 0.10214593f, -0.10433301f, -0.04607877f, 0.03340746f, 
    0.21461977f, -0.10422420f, -0.07636020f, -0.26479247f, 0.01986743f, -0.16181228f, -0.00468561f, 0.13935459f, 
    0.00869709f, 0.04485165f, -0.12212659f, 0.01748506f, 0.22852512f, -0.06051130f, 0.07242803f, -0.05431046f, 
    -0.02184665f, -0.03891110f, 0.12472474f, -0.01454419f, 0.02294412f, -0.02148605f, 0.04726907f, 0.10931063f, 
    -0.06900084f, -0.12013365f, 0.01207914f, 0.07483839f, -0.06214713f, -0.02000875f, -0.10630874f, -0.05830050f, 
    -0.02535883f, -0.02745479f, 0.09660783f, 0.00192431f, 0.12429278f, -0.13094705f, 0.09220526f, -0.00527863f, 
    -0.04398807f, -0.12477915f, 0.06331863f, 0.00848590f, -0.03469828f, -0.04078681f, -0.09028064f, 0.11481021f, 
    0.05895327f, -0.05953917f, 0.04041586f, -0.08846331f, 0.06610429f, -0.13426837f, 0.02026664f, 0.02300347f, 
    -0.09177887f, 0.04734439f, 0.11739885f, -0.06701408f, 0.28638935f, 0.02492077f, 0.08807023f, 0.08210271f, 
    0.10370225f, -0.03173958f, 0.02532940f, 0.09006827f, 0.02195622f, 0.06954116f, 0.00845816f, -0.07418631f, 
    0.15961826f, 0.04243658f, 0.10860240f, 0.11080183f, -0.05528031f, -0.03683472f, 0.00885745f, 0.09504710f, 
    0.04205721f, 0.02495498f, -0.04003550f, 0.01538243f, 0.26407871f, -0.04996073f, -0.07325741f, 0.18016864f, 
    -0.20993921f, -0.05088583f, -0.11613545f, -0.09691045f, -0.03786756f, -0.06393714f, 0.07968155f, -0.00262761f, 
    0.33927149f, 0.08057419f, 0.03406816f, -0.11741845f, 0.10889523f, -0.08153873f, 0.06247630f, 0.05020844f, 
    -0.01714634f, 0.00121868f, 0.09524566f, -0.05667359f, 0.10709038f, -0.12383784f, 0.06148100f, -0.08673919f, 
    0.09728700f, 0.07731158f, 0.02447985f, 0.01871447f, 0.08218287f, -0.00234544f, 0.06385339f, 0.00890021f, 
    0.18131486f, 0.06329463f, 0.06714247f, 0.03105998f, -0.04770991f, -0.03068718f, 0.00341638f, 0.09417037f, 
    -0.05915047f, -0.04958431f, 0.00809028f, 0.02563224f, 0.05651189f, -0.10467768f, 0.01995314f, -0.01359206f, 
    0.09771615f, 0.11256430f, 0.03755789f, 0.09730602f, 0.00949086f, -0.01028955f, -0.01657319f, -0.01259314f, 
    0.25761920f, 0.14426716f, 0.02647256f, 0.02283685f, 0.06816220f, -0.01756185f, 0.14946163f, 0.04246789f, 
    -0.03057508f, 0.02416425f, 0.00688009f, 0.00642473f, -0.31670865f, -0.00954961f, 0.04974999f, 0.06218844f, 
    -0.05497993f, -0.01977775f, 0.05777596f, -0.13110608f, 0.04583579f, 0.04733110f, 0.05993590f, -0.05418023f, 
    -0.02707566f, 0.05498257f, 0.11391317f, -0.00979807f, 0.07609494f, -0.00873220f, 0.01213349f, 0.02139476f, 
    -0.03931726f, 0.06081589f, -0.06386051f, -0.03600596f, 0.00942101f, 0.06674454f, 0.02578964f, 0.25662071f, 
    0.03274810f, -0.02506541f, 0.06299210f, -0.02108054f, 0.05594328f, 0.05456599f, -0.00640309f, -0.02415742f, 
    0.01380896f, 0.00532618f, -0.03143213f, -0.03134155f, -0.01311015f, 0.03594999f, -0.01999277f, 0.01188429f, 
    0.00147037f, 0.01401403f, -0.01821470f, -0.00457701f, -0.02363810f, -0.01857292f, -0.02380616f, -0.01071908f, 
    0.00084551f, -0.01752875f, 0.02798508f, -0.01740340f, -0.00379908f, 0.02586681f, 0.03171613f, -0.00404315f, 
    -0.03006150f, -0.02033571f, 0.01395539f, -0.04061977f, -0.00880965f, -0.00036127f, 0.02608696f, 0.02950197f, 
    0.02030077f, 0.00130006f, -0.03444907f, 0.02702019f, -0.02033505f, 0.01085521f, -0.02260358f, -0.03521707f, 
    -0.02030900f, -0.00306911f, -0.01567890f, -0.00153497f, -0.01933832f, 0.02766981f, 0.01187182f, -0.01441533f, 
    -0.02421672f, -0.03431136f, 0.00631043f, -0.03155741f, 0.02374906f, -0.01966819f, -0.02730385f, 0.02761876f, 
    0.01027733f, -0.02328702f, 0.02166575f, -0.02908579f, 0.02552866f, -0.02622596f, -0.01848841f, -0.02449803f, 
    -0.04094212f, 0.01209955f, -0.03884523f, -0.00584690f, 0.01789009f, 0.02602763f, 0.01119568f, -0.03952803f, 
    0.01327419f, 0.02060607f, -0.02093953f, -0.01813619f, -0.00986085f, -0.02790899f, -0.02978026f, -0.03387852f, 
    -0.03724930f, 0.02015510f, -0.02938734f, 0.01642555f, 0.02083611f, 0.00375529f, -0.01438984f, -0.01447063f, 
    -0.03241747f, 0.02280900f, 0.03388973f, -0.03424294f, -0.01380851f, -0.00269533f, 0.01311921f, -0.01809669f, 
    0.00706759f, 0.02148683f, -0.00167464f, 0.02294057f, -0.02710453f, -0.01639411f, -0.01364001f, 0.02141061f, 
    -0.03228803f, 0.01489251f, 0.03036356f, -0.03842202f, 0.00219497f, 0.00566016f, -0.01427949f, -0.00953383f, 
    0.00989890f, -0.02484313f, -0.03814967f, -0.02683724f, 0.01038563f, -0.03572519f, -0.00609513f, 0.03539649f, 
    0.02297693f, -0.02184789f, -0.01890598f, -0.01213543f, -0.00852822f, -0.02205059f, 0.01413394f, 0.00460436f, 
    0.01701277f, 0.01172456f, -0.02874776f, -0.01825214f, 0.00112356f, -0.03003013f, 0.01183514f, 0.00778467f, 
    0.02621411f, 0.02952399f, 0.02527701f, 0.00995589f, -0.02822603f, -0.01270851f, -0.01615659f, -0.00561261f, 
    0.00773197f, -0.01070254f, -0.00296494f, -0.02370957f, -0.00081687f, -0.03686135f, -0.03106160f, -0.03288561f, 
    0.01493536f, -0.00807306f, -0.00650189f, -0.03899538f, 0.02607001f, -0.01986356f, 0.03163990f, 0.01030631f, 
    -0.03182396f, -0.02839650f, 0.00050682f, 0.01079141f, -0.01516015f, -0.02556830f, 0.00536041f, 0.02746978f, 
    0.02545577f, 0.03783349f, -0.03047955f, -0.01618701f, -0.01399884f, 0.01486098f, -0.01552708f, -0.00527905f, 
    0.01548848f, -0.01326002f, 0.02393467f, 0.02779081f, 0.01521654f, -0.00515054f, -0.00490291f, 0.02929304f, 
    -0.02489334f, -0.00074763f, -0.01652096f, 0.00454591f, -0.01065964f, -0.02002743f, -0.00317568f, -0.02753163f, 
    -0.02036242f, 0.00882538f, -0.00725727f, -0.01032376f, 0.02998812f, 0.01443168f, -0.01146616f, 0.01530047f, 
    -0.03071791f, 0.01670490f, -0.02678893f, -0.03353478f, -0.01752677f, -0.00393047f, 0.01651503f, 0.02426921f, 
    0.01840419f, -0.01343536f, -0.02185350f, 0.02110658f, -0.00194051f, 0.01553921f, 0.02513596f, 0.00008636f, 
    -0.00053952f, 0.02726218f, 0.00371341f, -0.02736083f, -0.01036821f, -0.00491911f, 0.00319921f, -0.00503468f, 
    -0.02768979f, 0.02472427f, 0.00036497f, 0.00141079f, 0.00389351f, -0.01521138f, -0.01597657f, 0.03893564f, 
    -0.04117820f, 0.01665211f, 0.02442462f, -0.01807423f, -0.01858488f, -0.01336709f, -0.00025139f, -0.02955671f, 
    -0.00569474f, 0.00709963f, -0.02204400f, 0.01937917f, -0.02058353f, 0.01312297f, -0.03612686f, -0.03350021f, 
    0.00753534f, -0.04139527f, -0.01814418f, -0.00634384f, 0.01160901f, -0.02482331f, -0.03857493f, 0.00116008f, 
    -0.03911442f, 0.02486342f, -0.00159371f, 0.01630862f, -0.01708757f, -0.01156840f, -0.00948088f, 0.00477578f, 
    0.00216465f, -0.01160529f, -0.02198122f, 0.00987753f, 0.01559277f, -0.02762593f, 0.03060589f, 0.00440875f, 
    0.02181199f, 0.00127767f, -0.00655049f, -0.02456170f, 0.00311960f, -0.02517341f, -0.01234039f, -0.02050527f, 
    -0.03153221f, -0.00757668f, -0.00885710f, 0.01078779f, -0.01665895f, 0.03263154f, -0.03659827f, 0.01478687f, 
    -0.03516735f, -0.01115531f, -0.01086205f, -0.02473829f, 0.02997090f, -0.02413191f, -0.02632511f, 0.02572504f, 
    0.01038995f, -0.03170859f, -0.02286329f, -0.01912722f, -0.01950742f, -0.01914644f, 0.00633961f, -0.01474144f, 
    -0.02543889f, 0.01196660f, -0.00276549f, -0.02422382f, -0.03288539f, 0.02163822f, -0.03826939f, -0.00254350f, 
    0.02801169f, 0.03059420f, -0.01319904f, -0.01420861f, -0.01151941f, 0.00082422f, 0.01567146f, -0.02057198f, 
    -0.02619816f, -0.01893849f, -0.00023682f, -0.01178847f, -0.03232647f, 0.02841378f, -0.01392636f, 0.00955515f, 
    -0.00156125f, -0.01374064f, 0.02787744f, 0.00936423f, 0.02304532f, -0.00237199f, -0.02790375f, -0.01811041f, 
    0.01208974f, 0.01635762f, 0.03039634f, -0.01387980f, -0.01267557f, 0.01627880f, 0.02564239f, 0.01806724f, 
    0.00620082f, -0.00908414f, -0.03261117f, 0.01142524f, 0.02034462f, 0.02531331f, 0.01051687f, -0.03269877f, 
    0.00744590f, 0.02342045f, -0.03453109f, -0.02858057f, -0.03788266f, 0.02096404f, -0.03958153f, 0.01943791f, 
    -0.00104320f, -0.02819641f, 0.01762208f, -0.02519534f, 0.00002911f, -0.01827065f, -0.03184455f, -0.01414392f, 
    0.01479730f, -0.03967413f, 0.02473599f, -0.03495296f, -0.00940084f, 0.01840893f, 0.00878466f, -0.00121665f, 
    -0.03994980f, 0.01586951f, -0.00557445f, -0.01498157f, 0.01200016f, 0.01803056f, -0.02001151f, 0.01598274f, 
    0.02867129f, -0.02233011f, -0.01646288f, 0.03131787f, -0.00112703f, -0.02528458f, -0.02288460f, -0.00054716f, 
    0.02038572f, 0.00712275f, 0.01306122f, 0.00907476f, 0.01416402f, -0.03658969f, 0.02309989f, -0.01606008f, 
    -0.01103493f, 0.02493646f, -0.01547033f, 0.01148374f, -0.02258805f, 0.02595158f, -0.00328168f, -0.03041549f, 
    -0.03450014f, -0.01962508f, -0.00525745f, 0.00025200f, -0.01762976f, -0.01858319f, 0.02317711f, 0.00700992f, 
    0.00287059f, -0.01112762f, -0.01992246f, -0.02856963f, 0.02059879f, -0.02216921f, 0.01049664f, 0.02559677f, 
    -0.03634963f, 0.02637262f, -0.03463505f, -0.03515666f, -0.00505940f, -0.02075706f, -0.03422816f, -0.01358685f, 
    -0.01989568f, 0.01941065f, 0.02363235f, 0.02096362f, -0.01939039f, -0.02735643f, 0.02845719f, 0.02497582f, 
    -0.01786097f, -0.00338621f, -0.01482194f, -0.01847495f, 0.01315994f, -0.02466784f, -0.02426103f, -0.03960332f, 
    -0.03935005f, -0.01683738f, -0.00018141f, -0.03116859f, -0.03817414f, 0.02023636f, -0.03108465f, -0.00988839f, 
    0.01883361f, 0.01088356f, 0.02807507f, -0.00631113f, -0.02732057f, -0.00432182f, 0.01409278f, -0.00275907f, 
    0.01918288f, 0.00021140f, 0.02112855f, -0.02193929f, -0.02794402f, 0.02843004f, -0.01771931f, 0.00065451f, 
    -0.02783298f, -0.03541338f, -0.02023775f, 0.03087292f, 0.02786622f, 0.01323116f, -0.03045384f, -0.00991304f, 
    -0.01967128f, 0.02327589f, -0.00291735f, -0.01758477f, 0.02340315f, 0.01548726f, -0.00091829f, 0.01977971f, 
    -0.01369767f, 0.00731093f, -0.04052040f, -0.02427530f, 0.02162430f, 0.00642662f, 0.00607475f, 0.00819637f, 
    -0.01558666f, 0.00805344f, -0.02143694f, 0.01187523f, 0.00439892f, 0.00577852f, -0.00746682f, -0.02091491f, 
    0.02044729f, -0.03661013f, -0.01341561f, 0.01503182f, -0.01921949f, -0.03202422f, 0.00548429f, 0.02442340f, 
    -0.04113320f, -0.02533613f, 0.01942907f, 0.02815941f, 0.02447739f, -0.02702923f, 0.03007423f, -0.00842556f, 
    -0.00880666f, 0.00553764f, 0.00691342f, 0.03024043f, -0.00311633f, -0.01006770f, 0.01356110f, 0.01661387f, 
    -0.03740937f, -0.03645051f, -0.00160021f, 0.01930593f, 0.02600852f, 0.02724173f, -0.03307604f, -0.02567204f, 
    -0.00738247f, -0.03681793f, 0.01236499f, -0.02663429f, -0.00255509f, 0.00702737f, 0.00267843f, 0.01759115f, 
    0.02431433f, -0.03834735f, -0.01089693f, -0.01685483f, 0.01673117f, -0.03596536f, 0.01576504f, 0.00235619f, 
    0.02497079f, 0.00768533f, -0.03158306f, -0.00224510f, 0.02927336f, -0.02269849f, -0.00561638f, -0.00840530f, 
    -0.01985257f, -0.01611280f, 0.02311862f, 0.02872216f, -0.02698318f, -0.01909191f, -0.00244192f, -0.02111970f, 
    0.00058821f, 0.02069864f, -0.01590386f, -0.03514241f, 0.02478962f, -0.03637499f, -0.01820692f, -0.03934434f, 
    0.02424134f, 0.01952243f, -0.03018381f, 0.00094996f, 0.01040146f, -0.00230267f, 0.01968164f, -0.02101023f, 
    -0.00063880f, -0.01193319f, -0.01630186f, -0.01677274f, 0.01731037f, 0.02248094f, 0.02633455f, -0.01992389f, 
    0.02005904f, 0.00524366f, 0.01010356f, -0.00563807f, -0.01342489f, 0.01440371f, -0.01999162f, 0.00874324f, 
    0.01799028f, 0.02378407f, 0.01715937f, 0.02109741f, 0.02793774f, 0.02587055f, -0.03824999f, -0.02443949f, 
    0.00242012f, 0.01943391f, -0.03070106f, -0.02982658f, -0.03475103f, -0.03356920f, -0.01533377f, 0.01361030f, 
    0.01711983f, -0.02909297f, -0.03605711f, 0.01711487f, 0.00261172f, 0.02704526f, -0.01240106f, -0.02936358f, 
    -0.02683730f, -0.01458968f, -0.03797243f, -0.01988047f, -0.03308375f, -0.00380840f, -0.01119405f, -0.02993817f, 
    0.02508580f, -0.00086549f, 0.01002352f, -0.01606044f, -0.00186771f, -0.03513146f, 0.00559972f, -0.00145643f, 
    -0.02050643f, 0.01916297f, 0.02406555f, 0.00171228f, -0.02449070f, 0.00638459f, 0.02688929f, 0.01954753f, 
    -0.02406205f, 0.01767388f, -0.02494946f, -0.03957192f, -0.01213757f, 0.02115150f, 0.01475154f, -0.03191287f, 
    0.00853149f, 0.02630065f, -0.00524340f, 0.00331088f, -0.02748877f, 0.00688527f, -0.01851790f, -0.02519797f, 
    -0.01537938f, 0.02882096f, -0.01195247f, -0.03797690f, -0.02525659f, -0.00116322f, -0.01050864f, 0.02842503f, 
    -0.04220806f, -0.03786801f, 0.00271937f, -0.01983181f, -0.02280450f, 0.00317468f, -0.03227922f, -0.02580138f, 
    0.03015731f, 0.00224013f, 0.01354431f, -0.03124123f, 0.02162991f, -0.03414265f, 0.02244003f, -0.01756572f, 
    0.02976040f, 0.02457044f, 0.01000569f, -0.04063031f, 0.01255300f, 0.02109594f, -0.02720615f, 0.02391710f, 
    0.01025522f, 0.01301039f, 0.01462248f, 0.02820894f, -0.03110935f, -0.03591678f, -0.01395065f, 0.01353425f, 
    -0.03781255f, -0.04122787f, -0.01879780f, 0.02456949f, -0.01426682f, 0.00686920f, -0.03410392f, 0.00745792f, 
    -0.03731929f, -0.00088511f, 0.02956185f, 0.01456447f, -0.00725094f, 0.02757760f, 0.02991264f, -0.00687801f, 
    -0.01842224f, -0.01210414f, 0.03035485f, 0.03579609f, 0.00275201f, 0.00465448f, -0.01519504f, 0.00226946f, 
    0.01477126f, -0.00487525f, -0.00262069f, 0.00548113f, -0.00902989f, -0.02319732f, -0.01578384f, -0.01538774f, 
    -0.01666326f, -0.02269961f, -0.00999512f, 0.01662322f, -0.03096024f, 0.02341688f, -0.00208481f, 0.01804562f, 
    0.02900629f, -0.02843329f, 0.00757379f, 0.01711048f, -0.00225315f, 0.01624271f, -0.01694418f, 0.01150072f, 
    0.02792943f, 0.02398111f, -0.02401069f, 0.01775950f, 0.00188527f, -0.02018322f, 0.01649023f, 0.00399284f, 
    -0.03706178f, -0.01552483f, -0.00274271f, 0.01486040f, 0.02330638f, 0.03570721f, 0.03002269f, -0.01070922f, 
    -0.03688491f, 0.05538875f, -0.04560117f, 0.00158268f, -0.10661332f, 0.04244185f, 0.03100726f, -0.02793686f, 
    -0.02109264f, 0.00827302f, 0.02337462f, -0.09655551f, 0.03905489f, -0.03477802f, 0.01516565f, -0.04750640f, 
    -0.04459526f, -0.04095398f, 0.01293595f, 0.17530675f, -0.06136707f, 0.06178709f, -0.04720243f, 0.00536878f, 
    -0.08973300f, -0.04425599f, -0.00851338f, -0.15348026f, 0.03585992f, 0.04526906f, -0.06889236f, 0.09711242f, 
    0.03991812f, -0.00484129f, 0.01321115f, -0.03929709f, -0.02344542f, 0.10853620f, 0.04432596f, -0.10877808f, 
    0.04573080f, 0.03311502f, 0.06899289f, -0.00543081f, 0.12059069f, 0.05462528f, 0.07643317f, 0.02191795f, 
    -0.06645192f, -0.06395736f, 0.02861997f, -0.11684386f, -0.13185373f, 0.01919552f, -0.08160121f, 0.08167713f, 
    -0.03046632f, 0.10143746f, -0.08553853f, -0.12224355f, 0.10743282f, 0.02766125f, 0.06904847f, -0.03717986f, 
    0.02096854f, 0.02833249f, -0.04922756f, 0.05271124f, 0.05487489f, 0.07537821f, -0.03784838f, 0.13241906f, 
    0.21845838f, 0.00144131f, -0.02980656f, 0.01316040f, 0.10387250f, -0.00205317f, 0.03728967f, -0.03316627f, 
    0.04250927f, 0.06492471f, 0.14355223f, 0.17269710f, 0.05050465f, 0.23237033f, -0.00272846f, -0.00748041f, 
    0.05243029f, 0.03645601f, -0.01192771f, 0.06893609f, 0.00998449f, 0.13978890f, 0.05485930f, -0.08197783f, 
    -0.07533568f, 0.03298227f, 0.01324745f, 0.02691480f, 0.04054216f, -0.02978348f, -0.03140872f, 0.03149454f, 
    -0.08904590f, 0.08039512f, 0.13532199f, -0.02164024f, -0.25972000f, -0.07294995f, -0.13371921f, -0.05612768f, 
    0.00064126f, -0.04122208f, -0.00139031f, 0.11519819f, 0.10961449f, 0.18598905f, 0.01421148f, 0.10615997f, 
    0.24432369f, 0.16556217f, -0.15378939f, -0.10944819f, 0.00653046f, 0.02099457f, 0.02728721f, -0.07130164f, 
    0.03634430f, -0.01151439f, -0.01939609f, -0.01579358f, 0.12312884f, 0.07104570f, 0.16733813f, 0.09071076f, 
    -0.04624291f, -0.07886644f, 0.15077130f, -0.07030503f, 0.11331134f, -0.01720126f, 0.04543535f, 0.02763407f, 
    0.31261581f, 0.12647353f, 0.20041408f, -0.03324858f, -0.03247656f, 0.07358021f, 0.01575949f, -0.07066169f, 
    0.07905628f, 0.04042365f, 0.00061858f, 0.01457255f, -0.14201126f, -0.05805568f, -0.09678975f, 0.07822540f, 
    -0.05458860f, -0.06469733f, 0.03965314f, -0.06985342f, 0.06285389f, 0.03069578f, -0.08210116f, -0.11387456f, 
    0.12365992f, -0.08216394f, -0.23659313f, -0.06285722f, -0.02923368f, 0.04888191f, 0.04945608f, 0.04387215f, 
    0.11172836f, 0.05262726f, 0.03958974f, -0.02259608f, 0.08904506f, 0.04321591f, -0.05871234f, -0.06015950f, 
    -0.06695651f, -0.07135288f, 0.00909432f, -0.00617238f, 0.04370022f, -0.04370654f, 0.04463124f, -0.05250116f, 
    -0.08667622f, 0.08889965f, 0.21790388f, -0.04022788f, 0.02522546f, 0.11551008f, 0.03291060f, -0.04941297f, 
    0.00100252f, -0.09482757f, 0.11548532f, 0.03272284f, 0.00527109f, -0.00241386f, -0.02011709f, -0.12776764f, 
    0.03883080f, -0.01622900f, 0.10657968f, -0.03175870f, -0.07390446f, -0.00718078f, -0.01204084f, -0.04272561f, 
    -0.01684865f, -0.14313342f, 0.00714265f, 0.10780211f, 0.00395500f, -0.12860984f, -0.01885018f, 0.05223874f, 
    -0.18144383f, 0.11918992f, -0.01862993f, 0.02866308f, -0.08802544f, 0.01574861f, -0.07633247f, -0.15291373f, 
    0.12190469f, 0.05132121f, -0.13711333f, -0.12426054f, 0.04798661f, -0.06165405f, 0.03773435f, 0.04919263f, 
    0.03985546f, -0.00099237f, -0.19104514f, -0.22726618f, 0.10574897f, -0.02121031f, -0.13736801f, -0.06796291f, 
    -0.01909384f, 0.01434000f, 0.08039763f, -0.00335139f, 0.58925956f, 0.07688390f, -0.05057232f, 0.05623214f, 
    -0.01498060f, 0.00415166f, 0.13535830f, 0.08176424f, -0.07046105f, -0.03575294f, 0.07267167f, -0.11418400f, 
    0.02124508f, 0.17606972f, 0.08138222f, 0.02985430f, 0.00929285f, 0.14075325f, -0.08354569f, 0.08352260f, 
    0.09957924f, -0.02695645f, 0.01756324f, 0.00862829f, 0.46569291f, 0.07029535f, 0.01009777f, 0.08257684f, 
    -0.05002957f, -0.01764725f, -0.01311281f, 0.05293570f, 0.00089453f, 0.08030638f, 0.00057467f, -0.06214949f, 
    -0.11306511f, 0.07151242f, -0.06822307f, -0.16071922f, 0.04354375f, 0.06817041f, -0.10192538f, 0.03311620f, 
    0.04355444f, -0.06272363f, 0.02971949f, -0.00487344f, 0.12272295f, 0.00923750f, -0.20698300f, 0.00500730f, 
    0.03881321f, -0.03737010f, -0.03843052f, 0.10145247f, -0.01303967f, 0.08801945f, -0.01994990f, 0.06570415f, 
    0.05988114f, 0.18873242f, 0.01763173f, 0.05157457f, 0.09116824f, 0.08679916f, -0.00186382f, 0.08650959f, 
    0.04782875f, 0.10051071f, 0.06346437f, 0.12344518f, 0.35891992f, -0.01530118f, -0.18146133f, -0.14121816f, 
    0.10059858f, -0.03995045f, 0.00639183f, -0.00782794f, 0.00186455f, 0.05374803f, 0.11494789f, 0.16080706f, 
    0.48980930f, 0.02682265f, 0.00755713f, 0.10047779f, -0.02217201f, -0.03852651f, 0.02048076f, -0.00084650f, 
    0.07222077f, 0.04424059f, 0.07708391f, 0.00541375f, 0.03907068f, -0.05693173f, -0.03501853f, 0.03013442f, 
    0.01337000f, -0.09477545f, -0.06119538f, -0.07579599f, 0.09447679f, -0.04968766f, -0.05133137f, -0.20775041f, 
    -0.22149387f, -0.02621994f, -0.09306707f, -0.10981508f, -0.07626604f, 0.05779428f, -0.03625099f, -0.10111578f, 
    0.04675647f, 0.04271597f, -0.03303600f, -0.01425164f, -0.08345112f, 0.00619298f, 0.05083787f, 0.04842465f, 
    0.01185047f, -0.00752866f, 0.07589620f, 0.12230862f, 0.09710796f, 0.06594712f, -0.06108094f, -0.03057630f, 
    -0.30457520f, -0.30959210f, -0.12676977f, -0.07465427f, 0.05130100f, -0.02416006f, -0.06140891f, -0.08231016f, 
    0.05102643f, 0.07861069f, 0.03427649f, -0.02388193f, 0.11646244f, 0.07147920f, -0.11609468f, -0.18411164f, 
    0.19604039f, -0.03929763f, 0.06671768f, 0.01691454f, 0.08269380f, 0.05344930f, -0.05737054f, 0.02108941f, 
    0.16535190f, 0.14306641f, 0.15485916f, -0.12956183f, -0.13643074f, -0.05728428f, 0.07203773f, -0.01941428f, 
    0.07877960f, -0.14306639f, -0.09628008f, -0.05738655f, -0.10660335f, 0.00224193f, -0.07193242f, -0.10868146f, 
    0.10825703f, 0.04195771f, 0.02840794f, 0.10151357f, -0.00644408f, 0.07378694f, 0.07562879f, 0.02492750f, 
    0.23388471f, -0.00424952f, 0.08151449f, 0.14839444f, -0.02287756f, -0.01506339f, -0.10509516f, 0.01063611f, 
    -0.00091736f, 0.12117578f, 0.09457394f, 0.00513042f, 0.16043398f, 0.00267132f, 0.12243924f, 0.03021970f, 
    -0.01442635f, 0.08744603f, 0.05877233f, -0.00433213f, -0.03072579f, 0.15997924f, -0.10905846f, -0.05022633f, 
    0.05962110f, -0.01556691f, 0.16372670f, 0.19440371f, -0.10296010f, -0.02023268f, -0.00656985f, 0.05927616f, 
    -0.01597471f, 0.00586660f, -0.02009633f, 0.06356384f, 0.12770593f, 0.01510662f, -0.06632002f, -0.11884457f, 
    -0.10869821f, 0.03623261f, -0.02488226f, 0.04963777f, 0.06225694f, -0.00091439f, -0.02767971f, 0.01485198f, 
    0.15773512f, 0.10259495f, 0.11028370f, 0.05230614f, -0.02544418f, 0.05657004f, 0.10401326f, 0.05502165f, 
    -0.04233762f, 0.06709342f, 0.01190826f, -0.05202789f, -0.21116115f, -0.10253514f, -0.28852379f, 0.10928235f, 
    0.03101446f, -0.03481578f, 0.05349171f, 0.08921395f, 0.05517022f, -0.00732813f, 0.07252728f, -0.00886389f, 
    0.02959656f, 0.00064411f, 0.01119854f, 0.02216999f, 0.13628878f, 0.12872030f, -0.01219075f, 0.11745967f, 
    0.09239151f, 0.06269472f, -0.03794960f, 0.12596011f, -0.17880230f, 0.00368401f, -0.09046806f, -0.20685430f, 
    0.02741433f, 0.06889973f, -0.11083287f, -0.00562879f, 0.10504432f, 0.00164153f, -0.02679072f, 0.06002835f, 
    0.04267434f, 0.04543111f, -0.01712134f, 0.03127099f, 0.06814063f, 0.02228901f, -0.06811409f, 0.02193252f, 
    0.05723592f, 0.01028161f, 0.03496538f, 0.05276911f, 0.26832628f, -0.04736650f, -0.07933711f, 0.01977803f, 
    -0.08896916f, 0.00621194f, 0.06828947f, 0.02147267f, 0.05127360f, 0.06673699f, 0.00705604f, 0.00482818f, 
    0.20366408f, 0.00978454f, 0.11229625f, -0.05736916f, -0.01472876f, -0.00725323f, 0.12242614f, 0.05519297f, 
    -0.01532753f, 0.10670054f, -0.02926397f, 0.06374268f, 0.12349126f, 0.12622239f, 0.11607908f, -0.07615525f, 
    -0.06097761f, 0.01037935f, 0.03409348f, -0.09833040f, 0.05048837f, -0.03367313f, 0.01360340f, 0.00272981f, 
    -0.10350306f, 0.08254164f, -0.00652597f, 0.14113648f, 0.01760821f, -0.00350492f, -0.02705400f, 0.02615844f, 
    -0.05263735f, -0.00013584f, 0.12050784f, 0.02232720f, -0.02656847f, 0.03586611f, 0.02687613f, -0.05943421f, 
    -0.03027890f, 0.06333443f, -0.02943504f, -0.02100941f, 0.06100182f, 0.05219102f, -0.07103606f, -0.01361548f, 
    0.21073438f, 0.03127603f, -0.19450803f, 0.06851292f, -0.04531124f, -0.06229254f, 0.04045016f, 0.03738866f, 
    0.06587037f, 0.02744205f, 0.00273606f, -0.03712520f, 0.17819495f, -0.05169795f, 0.01523437f, -0.00322807f, 
    0.01171845f, -0.03579305f, 0.01061422f, -0.00964416f, 0.05891798f, 0.03296726f, 0.06276743f, 0.15055259f, 
    0.02271445f, 0.04063839f, 0.03361539f, -0.05197782f, 0.17074208f, 0.00789708f, 0.01355690f, 0.00403155f, 
    -0.02522066f, 0.05596909f, 0.04771659f, 0.11019433f, -0.09887408f, -0.04891312f, -0.13320422f, -0.08341908f, 
    0.01789565f, 0.03384284f, 0.03452208f, -0.03637605f, 0.00652346f, -0.01054039f, 0.01286402f, 0.02583055f, 
    -0.11387096f, -0.20902818f, -0.12505557f, -0.20972106f, 0.06078760f, 0.03459576f, 0.07285915f, -0.09165501f, 
    0.08294890f, -0.02566944f, 0.02468986f, -0.04775077f, -0.08658198f, -0.20261687f, -0.28297520f, -0.12503360f, 
    0.06609124f, 0.01128613f, -0.01706880f, -0.02827456f, 0.04616787f, 0.04869548f, -0.05517026f, 0.03843120f, 
    -0.16449018f, 0.20746565f, -0.06889637f, 0.08329894f, 0.06967033f, 0.00648729f, -0.03720774f, 0.07872195f, 
    0.00575639f, -0.07076541f, -0.03678866f, 0.01210917f, -0.04096614f, 0.17131886f, -0.08994609f, -0.02071578f, 
    -0.06691679f, -0.03342035f, -0.05222111f, 0.10032228f, -0.07693281f, 0.02153839f, 0.13406263f, -0.01653493f, 
    0.08627325f, -0.11493914f, -0.17320438f, -0.02783206f, 0.11708608f, -0.03438111f, -0.06739569f, -0.00872062f, 
    0.00861333f, 0.14448604f, -0.00569535f, 0.12286732f, -0.05910729f, 0.15092830f, 0.10325641f, 0.01485376f, 
    -0.08088393f, -0.01672860f, 0.04891494f, -0.02898100f, 0.06179437f, 0.03573881f, -0.12001639f, 0.01325181f, 
    -0.11001502f, 0.12838553f, -0.03992209f, 0.02703200f, 0.15211092f, 0.02155958f, 0.00222063f, 0.02974044f, 
    0.02293797f, 0.05743563f, 0.08465268f, 0.04024579f, 0.09923368f, 0.14882322f, -0.13914584f, 0.06439914f, 
    0.08247507f, -0.01902678f, -0.00768509f, 0.09835867f, 0.12613292f, 0.09508593f, 0.03566130f, 0.00265796f, 
    0.06360795f, 0.14507791f, -0.00738715f, 0.00037384f, -0.06625889f, -0.09743074f, 0.02783833f, -0.00754697f, 
    -0.04408250f, 0.08103064f, -0.07810135f, -0.03223906f, -0.27458298f, -0.12702683f, -0.19393308f, -0.18830110f, 
    -0.00759639f, 0.05814056f, -0.07353158f, -0.01284191f, 0.04873143f, -0.03927721f, 0.07724598f, -0.03613406f, 
    0.03110545f, -0.02332989f, -0.02662560f, -0.01006580f, -0.00766648f, 0.00563636f, -0.03951086f, -0.02512710f, 
    -0.02958804f, -0.01171816f, -0.03555019f, 0.00231493f, -0.01938426f, 0.01854023f, 0.02300241f, -0.02129403f, 
    0.00675055f, -0.03616482f, 0.02284329f, 0.00590659f, 0.00522729f, -0.02194740f, 0.00262209f, -0.01955518f, 
    -0.03952490f, 0.01415788f, 0.00548324f, -0.00911989f, 0.02158692f, 0.00357850f, -0.03534554f, 0.01138288f, 
    0.02926286f, 0.02200565f, 0.01423971f, -0.03111113f, -0.01507913f, -0.04305284f, -0.01846000f, -0.01592024f, 
    -0.02950092f, 0.00885755f, -0.00934426f, -0.05869515f, 0.01151760f, -0.00067448f, 0.00190224f, -0.04254489f, 
    0.01245057f, 0.02870362f, 0.01228544f, 0.03161329f, -0.02391792f, 0.02128666f, -0.00137046f, -0.03650691f, 
    0.00865093f, 0.01297226f, 0.02379856f, -0.02251076f, -0.01113304f, -0.01964249f, -0.03207139f, -0.01783855f, 
    0.00233824f, -0.03781951f, -0.03705372f, -0.00617347f, 0.02064916f, 0.00735750f, -0.00232942f, 0.02930233f, 
    -0.01605974f, -0.00524783f, 0.02653878f, -0.01626563f, -0.03839376f, -0.02089325f, 0.02367854f, 0.02176215f, 
    -0.03075888f, 0.00729721f, -0.02895875f, 0.01126636f, 0.01907807f, -0.02226900f, -0.04528034f, 0.01083346f, 
    0.02149179f, -0.01637564f, 0.02364028f, -0.04208413f, -0.00304929f, -0.02144505f, -0.03191244f, -0.04014396f, 
    0.01942007f, -0.04096026f, -0.01092854f, 0.00311757f, -0.03858688f, -0.01467372f, 0.00132003f, 0.00217644f, 
    -0.03621351f, -0.00385412f, -0.00200899f, 0.00407892f, -0.04102212f, 0.01641105f, 0.00796337f, -0.00470096f, 
    -0.02562091f, -0.02562711f, -0.02228639f, 0.02660838f, 0.01790282f, 0.02271880f, -0.02598357f, -0.00229989f, 
    0.00877873f, 0.00197640f, 0.00478891f, 0.02973475f, -0.00763031f, 0.01270295f, -0.02211130f, -0.00869379f, 
    -0.01275784f, -0.02019919f, 0.01346880f, -0.02694537f, -0.01177734f, 0.02559234f, 0.01321277f, -0.00222166f, 
    0.01700864f, 0.02059687f, -0.01392850f, -0.01903860f, -0.02785729f, -0.00454202f, -0.01782499f, -0.00938497f, 
    -0.01603572f, -0.00554409f, 0.02279345f, -0.01128531f, 0.00033359f, -0.02911275f, 0.02081450f, -0.03718583f, 
    -0.03052805f, -0.04034497f, 0.02524025f, -0.01810204f, -0.02509301f, 0.02487032f, 0.01285009f, 0.00664973f, 
    -0.03549160f, -0.02239122f, 0.02684918f, -0.04820398f, -0.03536677f, -0.01929160f, 0.01423197f, -0.03658092f, 
    -0.00168848f, 0.00928500f, 0.04153366f, 0.00778044f, 0.01278934f, -0.02298125f, -0.00558085f, -0.02853711f, 
    -0.02869845f, -0.01484147f, -0.02064246f, 0.00827069f, 0.00718840f, -0.01872367f, 0.02127430f, -0.00168150f, 
    0.01319431f, 0.02395251f, -0.00086945f, -0.02250826f, 0.02472077f, 0.00603303f, -0.03790472f, 0.00464564f, 
    -0.03037208f, 0.01310123f, -0.03240531f, -0.02526957f, 0.01429412f, -0.00653238f, 0.02342285f, -0.01923952f, 
    -0.00448783f, 0.00105975f, -0.04081105f, -0.02390770f, -0.00069404f, -0.03704677f, -0.02435394f, -0.03420216f, 
    -0.04403758f, -0.02400550f, -0.02825584f, -0.02193709f, -0.04856114f, -0.04403488f, -0.00267463f, -0.00925593f, 
    0.01491924f, -0.02674325f, -0.00611739f, 0.01760211f, -0.02850620f, -0.01837998f, -0.00022149f, 0.00202629f, 
    0.01648062f, -0.00871002f, -0.01348202f, -0.03163041f, 0.00656341f, 0.01657167f, -0.00056074f, 0.00494290f, 
    0.01662058f, 0.01108631f, -0.00207856f, -0.03483308f, -0.02674344f, -0.01125770f, -0.01756324f, -0.00994142f, 
    -0.01242818f, -0.00440717f, -0.01257925f, 0.01844713f, 0.01314669f, 0.02763866f, -0.00033134f, -0.01978431f, 
    -0.01139536f, -0.01565475f, -0.00192787f, -0.01414241f, -0.03518194f, -0.00875379f, 0.00417898f, -0.01760731f, 
    0.01478702f, -0.02643645f, -0.01320169f, -0.02060942f, -0.05178103f, -0.01847333f, -0.04587997f, -0.00840020f, 
    0.00111384f, 0.01905204f, 0.00666527f, -0.03721040f, 0.01317397f, 0.01805482f, -0.03084534f, 0.00627840f, 
    0.00199635f, 0.00035542f, -0.00796565f, 0.00076733f, -0.00655886f, -0.00956989f, 0.01893047f, 0.02146897f, 
    0.02786020f, -0.01818765f, 0.01221358f, -0.04346808f, -0.00440304f, 0.02124278f, 0.00878774f, 0.03201345f, 
    -0.00499249f, 0.01945640f, -0.01078925f, 0.00475347f, -0.06119039f, -0.03318147f, -0.01833821f, -0.03872342f, 
    -0.00038762f, 0.01023529f, 0.00237119f, 0.02286215f, 0.00458150f, -0.00516433f, -0.00631645f, 0.03634829f, 
    -0.01423263f, 0.00709981f, 0.02387847f, -0.04071120f, -0.01956024f, -0.03594634f, -0.02846763f, 0.02076623f, 
    -0.00067170f, -0.03366313f, 0.01229437f, 0.02639190f, -0.03534001f, -0.00570136f, 0.02161725f, 0.01504478f, 
    -0.02230067f, 0.01873433f, -0.03235886f, -0.01349165f, 0.01611871f, -0.03302390f, -0.01181267f, 0.02974129f, 
    -0.00467628f, 0.00980521f, -0.02470244f, 0.03499225f, 0.01700976f, -0.01194318f, 0.03009341f, -0.03089378f, 
    0.00503269f, -0.04525568f, 0.02988329f, -0.03076104f, 0.01209143f, 0.01145639f, -0.03071383f, -0.00750219f, 
    -0.03079635f, 0.00342453f, 0.01009370f, 0.02375545f, 0.02648055f, -0.01707147f, 0.01732592f, -0.00964841f, 
    -0.02474764f, 0.00339717f, 0.01012434f, 0.00948670f, 0.01977362f, 0.01014911f, -0.02978689f, 0.01035397f, 
    -0.00228713f, -0.03242562f, 0.01026123f, 0.01805763f, 0.01265108f, -0.04319558f, 0.02272256f, -0.03134404f, 
    -0.01908898f, 0.02054562f, -0.03047553f, -0.03852171f, -0.01840167f, -0.03159037f, 0.03030747f, -0.00218000f, 
    0.01533998f, -0.02114758f, -0.02812120f, -0.03112569f, -0.04200095f, -0.02977543f, -0.00557409f, 0.02071459f, 
    -0.00030085f, -0.01862746f, 0.00411049f, -0.00330291f, -0.01150049f, 0.01801316f, -0.00552304f, 0.00431248f, 
    -0.02666241f, 0.01364632f, -0.02587677f, -0.03936496f, 0.00040926f, -0.03143162f, -0.03107085f, 0.00621546f, 
    -0.02481723f, -0.03892585f, 0.02239425f, -0.03992132f, -0.00753075f, -0.01291462f, -0.03539421f, -0.00860559f, 
    -0.02961227f, -0.02432691f, -0.00462580f, -0.02300833f, -0.02892962f, 0.00380096f, 0.01866149f, -0.01529053f, 
    0.01064555f, -0.00430459f, 0.01986035f, 0.01037969f, 0.02146274f, -0.03550490f, 0.02820852f, -0.02705439f, 
    -0.04065715f, -0.01558017f, -0.01895945f, 0.02822125f, 0.01771811f, -0.02199876f, -0.00465264f, -0.03667527f, 
    -0.02290435f, 0.01650906f, -0.02705773f, 0.01751133f, -0.04398282f, -0.00968000f, -0.00717107f, -0.01543862f, 
    -0.01765072f, 0.01075968f, -0.04134652f, 0.03315409f, 0.01270223f, -0.03497318f, -0.00761238f, -0.03829585f, 
    -0.00421816f, 0.01637565f, -0.02797696f, 0.03071197f, -0.03024969f, -0.03432851f, 0.02983239f, -0.00583442f, 
    -0.00553096f, 0.02933195f, -0.02511546f, -0.02530579f, -0.01654427f, -0.03665444f, -0.04341616f, -0.03773624f, 
    -0.00458531f, 0.02393445f, -0.02129016f, 0.00894473f, -0.01600252f, -0.01355838f, -0.03625149f, 0.01768662f, 
    -0.02967087f, -0.01395706f, 0.02393865f, -0.02910947f, -0.00973370f, -0.01166846f, -0.01391795f, 0.01258695f, 
    -0.03518341f, 0.02492315f, -0.01519099f, 0.01773337f, -0.02195252f, -0.03242135f, 0.02440950f, -0.01233553f, 
    -0.00361733f, 0.03586898f, -0.00988088f, 0.01274423f, -0.02110488f, -0.03631072f, -0.03356473f, -0.03034033f, 
    0.01323911f, 0.00181078f, 0.03029162f, -0.00709314f, 0.01205963f, 0.02434658f, -0.01537901f, 0.02453610f, 
    -0.00177002f, 0.01590494f, 0.01622681f, -0.00264849f, -0.03285572f, -0.02506187f, -0.03670125f, -0.03071221f, 
    0.02771119f, 0.00087054f, -0.04324153f, 0.02409073f, 0.01992259f, -0.00765417f, -0.01395334f, -0.02294586f, 
    -0.03486528f, -0.02239532f, 0.02897441f, -0.00628190f, 0.01040234f, -0.01950660f, -0.01719270f, -0.03184834f, 
    -0.00326015f, 0.01870250f, 0.02401059f, 0.01720256f, -0.03788333f, 0.01838472f, 0.01806513f, 0.02812670f, 
    0.02432975f, 0.01032239f, -0.01204053f, 0.02325096f, -0.01040821f, -0.02962681f, 0.00156470f, 0.01681688f, 
    -0.02355405f, -0.01661545f, -0.03259629f, -0.00060522f, -0.00951737f, -0.00991957f, 0.00717575f, 0.00273798f, 
    0.00454462f, -0.00639003f, 0.01421830f, -0.03229519f, 0.01329421f, 0.01696778f, -0.04209279f, -0.01547652f, 
    -0.00258096f, 0.03361783f, -0.03124564f, 0.02791716f, -0.04038065f, -0.02921354f, -0.03052496f, -0.01607784f, 
    0.02995470f, 0.02417822f, -0.03765134f, -0.00917478f, -0.02969523f, 0.00105146f, 0.02810714f, -0.01495013f, 
    -0.00280827f, 0.00654311f, -0.03456036f, 0.00436078f, -0.03211094f, -0.01125078f, 0.02842437f, -0.03007364f, 
    0.00137501f, 0.01994650f, -0.00570425f, -0.00418190f, -0.02705874f, -0.02415513f, -0.03440862f, 0.01589803f, 
    -0.00470171f, -0.04050772f, -0.00109130f, 0.01110454f, -0.02591830f, -0.04255673f, -0.01777053f, 0.00149768f, 
    -0.01230390f, -0.05700091f, 0.00810288f, -0.01680397f, -0.01534722f, 0.02401322f, -0.02049498f, -0.02387584f, 
    -0.00813106f, 0.00121300f, 0.01766523f, -0.00572071f, -0.00866402f, -0.01163996f, 0.00396555f, 0.01486192f, 
    -0.02211669f, -0.01689550f, 0.00150074f, 0.00725337f, -0.04257119f, -0.01973514f, -0.00435039f, 0.01632263f, 
    -0.00480220f, 0.01136517f, -0.04261082f, -0.02268066f, 0.00491536f, -0.03096640f, 0.00652521f, -0.01458901f, 
    -0.00995008f, -0.00692868f, 0.01768930f, 0.00342854f, -0.03310725f, -0.00735427f, 0.03034375f, -0.02602019f, 
    0.01317992f, 0.01555432f, -0.03847070f, -0.03786650f, 0.02396927f, -0.01336446f, 0.01615003f, -0.01524744f, 
    -0.03203166f, -0.00121391f, -0.01622978f, -0.03376086f, -0.00844702f, 0.00473214f, 0.00447926f, 0.02801885f, 
    -0.00179972f, -0.03868820f, 0.00951773f, -0.00827918f, -0.02996334f, -0.01057947f, -0.01466244f, -0.01230002f, 
    -0.03820058f, -0.00895923f, -0.00612657f, 0.03068442f, -0.00546747f, -0.03475167f, -0.00500761f, -0.03949212f, 
    0.03346755f, -0.02960026f, -0.00723616f, -0.03537663f, -0.00077011f, 0.00948759f, -0.01504152f, -0.01344318f, 
    -0.02330471f, -0.03336289f, -0.04601377f, -0.04438719f, 0.01836041f, -0.02218109f, -0.03058964f, -0.02028815f, 
    -0.02132078f, -0.02246005f, 0.00176100f, 0.02223537f, 0.01852771f, -0.02530521f, 0.02160562f, -0.03519542f, 
    0.00177468f, -0.02097661f, -0.00840932f, -0.02562122f, 0.01841674f, -0.04317695f, -0.01132096f, -0.03803313f, 
    -0.03077509f, 0.01729772f, -0.03804901f, 0.04070061f, -0.01873052f, -0.02853792f, -0.00985787f, 0.01752224f, 
    -0.02565864f, -0.03426323f, 0.02197261f, 0.01231883f, -0.03689219f, -0.00425092f, 0.02696564f, 0.02409486f, 
    0.02705138f, 0.00802489f, -0.04020502f, -0.01835610f, -0.00419484f, -0.03689117f, 0.00879378f, -0.02223099f, 
    -0.01445205f, 0.01922500f, -0.04366845f, -0.04205956f, -0.03492706f, -0.01474486f, 0.00661640f, -0.01232954f, 
    -0.02917008f, 0.02491063f, 0.01878435f, -0.04667776f, 0.00786687f, -0.01944321f, -0.00071899f, -0.04789877f, 
    0.00237378f, -0.01109737f, -0.00640251f, -0.01730195f, -0.03588210f, -0.03078268f, -0.01564028f, -0.01181540f, 
    -0.03725556f, 0.00625916f, -0.00311449f, 0.02127140f, 0.01222278f, 0.02035756f, 0.02349617f, -0.00701841f, 
    0.01110287f, -0.03412273f, -0.02614185f, -0.01706893f, 0.02004387f, -0.02748558f, 0.00010295f, -0.02584326f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.05127669f, 0.00896404f, 0.01529059f, 0.00818748f, 0.02000277f, 0.08365937f, 0.01601266f, -0.00139180f, 
    -0.03966284f, 0.06042121f, -0.01754101f, 0.00882527f, 0.02912993f, 0.05846618f, 0.05750820f, 0.04959341f, 
    0.01819193f, 0.01292561f, 0.00687359f, -0.02441302f, -0.03360500f, 0.06830639f, -0.01405065f, 0.01489410f, 
    -0.01895165f, 0.04451873f, -0.03514280f, 0.06602738f, 0.00685621f, -0.00098891f, 0.05904835f, -0.01941015f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.08215790f, -0.13445264f, -0.02520917f, -0.10605959f, -0.07803670f, -0.04231352f, -0.04328641f, -0.08310684f, 
    0.17474295f, -0.07548659f, 0.13086021f, 0.11153093f, 0.10098717f, -0.08451800f, -0.10620257f, 0.12685090f, 
    0.16459164f, 0.16459084f, -0.14994091f, -0.16433123f, -0.12691550f, -0.16940954f, 0.06646200f, -0.02683296f, 
    -0.12782304f, -0.15937322f, -0.14804780f, -0.16072136f, -0.11232702f, -0.15353768f, 0.07781048f, 0.08382167f, 
    0.14222817f, 0.16111322f, 0.03443620f, -0.07743771f, 0.07584210f, 0.07568203f, -0.03687514f, -0.14112647f, 
    -0.15153648f, 0.02240704f, 0.11440481f, -0.12514117f, 0.09574297f, -0.17742158f, -0.15699227f, -0.21774863f, 
    0.07520748f, -0.13893525f, -0.16466242f, -0.11763175f, 0.11667661f, -0.07173006f, 0.09254098f, 0.08264703f, 
    0.11102162f, -0.04673515f, 0.09654910f, -0.10172118f, -0.05969563f, 0.04097142f, -0.19000994f, 0.16850246f, 
    -0.13150197f, 0.08947653f, -0.03494553f, 0.07716323f, 0.07815572f, 0.06677686f, -0.05875057f, 0.01898727f, 
    0.09044071f, 0.20332873f, -0.03509888f, -0.02117529f, 0.34530261f, 0.02408220f, -0.00569393f, -0.16130406f, 
    -0.28211394f, -0.15784043f, -0.13847268f, -0.34299889f, 0.02758929f, 0.16452166f, 0.02684946f, 0.11508095f, 
    -0.15488259f, 0.18374345f, -0.08676011f, -0.36522242f, 0.25506276f, -0.05616895f, 0.02523270f, -0.15480331f, 
    0.05470757f, -0.16729268f, 0.17318125f, -0.15227790f, 0.03882502f, 0.15059054f, 0.04814245f, 0.15414082f, 
    0.14394359f, 0.01152295f, 0.17663448f, 0.12541212f, -0.00865763f, -0.43827698f, 0.30019903f, 0.02093857f, 
    -0.34962291f, -0.06383944f, 0.12238109f, 0.05922845f, 0.11177066f, 0.20208958f, -0.04106627f, 0.05896691f, 
    0.01169525f, -0.06847513f, -0.10617986f, -0.30499610f, 0.04217793f, -0.08062383f, -0.38043672f, -0.07493942f, 
    0.44959652f, -0.12655661f, -0.15098421f, 0.14950715f, 0.03463636f, -0.07741114f, 0.06629325f, 0.10808466f, 
    0.03472098f, -0.02103109f, -0.16796534f, 0.16221046f, -0.21335983f, -0.17378996f, 0.19763544f, 0.47886369f, 
    0.19424504f, -0.07577001f, 0.00924869f, -0.33464879f, 0.17222361f, 0.15371665f, -0.05100173f, -0.04035560f, 
    0.07272203f, -0.10136432f, -0.06284031f, 0.36002868f, -0.20865887f, 0.12329523f, -0.09882030f, 0.17281446f, 
    -0.11474482f, -0.08368383f, 0.06583354f, 0.12825699f, 0.13742986f, -0.13205639f, 0.11602673f, -0.08999564f, 
    0.10789849f, -0.06928965f, 0.05699347f, 0.13013741f, -0.04493682f, 0.05488789f, -0.12291189f, 0.16017349f, 
    -0.06254296f, 0.09298003f, -0.17281093f, -0.13183518f, 0.14765012f, 0.12403397f, -0.11560749f, -0.04746484f, 
    -0.04799676f, 0.10810322f, 0.02828851f, -0.02907517f, -0.12899005f, 0.04946217f, -0.09686922f, 0.13417965f, 
    0.14159164f, -0.03891521f, -0.09100489f, 0.13801065f, 0.02716061f, 0.09199049f, -0.02067022f, 0.36057916f, 
    -0.11923035f, 0.31783539f, 0.02818364f, -0.06654654f, 0.35127571f, -0.01879077f, -0.16922742f, -0.43410909f, 
    0.29238060f, 0.14838627f, 0.05545848f, -0.16179901f, 0.05128364f, -0.06025805f, 0.07637845f, 0.14077593f, 
    0.16428927f, 0.07627194f, -0.17140245f, 0.23993881f, 0.03759412f, 0.04670552f, -0.36218768f, -0.04336241f, 
    0.14708844f, 0.10911386f, -0.01208664f, 0.17066899f, -0.03810368f, 0.05375165f, -0.04367085f, 0.14060985f, 
    -0.16484547f, 0.28485170f, 0.02501073f, 0.02041015f, 0.20333360f, -0.01711492f, -0.37766793f, 0.45222500f, 
    -0.04977976f, 0.05254777f, 0.10640731f, 0.23507813f, 0.12658335f, -0.22687933f, 0.16513339f, -0.08856326f, 
    -0.12465765f, 0.20687999f, 0.07885558f, 0.14136949f, -0.14569157f, -0.00853931f, 0.33239421f, 0.06832915f, 
    0.04530266f, -0.04526366f, 0.16589889f, -0.16546416f, -0.05445574f, -0.13206474f, -0.03585923f, 0.06142087f, 
    0.07277898f, -0.05580389f, -0.03172024f, 0.10053876f, -0.01180608f, -0.13533312f, -0.04141822f, -0.10531297f, 
    -0.07294255f, 0.02461198f, -0.09404995f, -0.15075867f, 0.11018572f, -0.00007962f, 0.12516287f, 0.15697511f, 
    0.03333602f, 0.08705311f, -0.14033857f, -0.19375259f, 0.15692435f, -0.15139224f, -0.06507117f, 0.06681464f, 
    -0.15981539f, 0.07277427f, 0.11640115f, 0.11950473f, 0.06327503f, 0.25963759f, -0.08116326f, -0.24013123f, 
    -0.04958535f, -0.10173045f, -0.11385998f, 0.06447216f, 0.06462058f, 0.23054433f, 0.33166462f, 0.07390504f, 
    0.27838826f, 0.00213812f, 0.12724063f, -0.32927889f, -0.08269269f, 0.34602162f, 0.02130711f, -0.07823205f, 
    -0.15886824f, -0.03661552f, 0.13561469f, 0.35945374f, -0.16721575f, 0.07118697f, 0.27979180f, -0.05050323f, 
    0.12642324f, 0.17600878f, 0.11171681f, 0.05698117f, 0.00650483f, 0.01402000f, -0.16183595f, -0.33335102f, 
    -0.04367186f, 0.36291701f, 0.13615572f, 0.05167432f, -0.12228757f, 0.53624451f, 0.00923424f, 0.14780731f, 
    -0.18219234f, -0.15090229f, -0.00114198f, -0.13743734f, -0.18059851f, 0.14728706f, 0.08598295f, 0.06132719f, 
    -0.13185437f, 0.29809201f, 0.05763763f, -0.40206927f, 0.17391966f, 0.12435253f, 0.08960897f, 0.02858242f, 
    -0.37895274f, -0.16988190f, -0.07340217f, -0.10685913f, -0.08276450f, 0.05397570f, 0.08726792f, 0.21254407f, 
    -0.00219190f, 0.09965437f, 0.09023074f, 0.16848405f, -0.02153734f, 0.05184788f, -0.08979515f, 0.19749014f, 
    0.51124465f, -0.00872769f, 0.00415983f, 0.17379493f, 0.12497802f, 0.15703446f, -0.14584498f, 0.05777076f, 
    0.04334506f, 0.33720818f, -0.16896641f, 0.24421249f, -0.06679048f, 0.15690823f, -0.11245009f, -0.07493483f, 
    -0.08743698f, 0.13492842f, 0.12781906f, 0.06201380f, 0.10789577f, -0.15144174f, 0.03795838f, -0.05928186f, 
    -0.08049371f, 0.16725478f, 0.16366281f, -0.04257548f, -0.01266179f, -0.12300639f, 0.17081222f, 0.15216738f, 
    -0.04297279f, -0.12711270f, 0.02278170f, -0.13803308f, -0.01428851f, -0.17966060f, 0.09898250f, -0.12615082f, 
    0.09982987f, 0.14438605f, 0.10082361f, 0.16254766f, -0.06307321f, -0.03804329f, -0.15505938f, 0.16596617f, 
    0.17081398f, -0.06054383f, -0.00799179f, 0.13871090f, 0.03389413f, -0.09632614f, 0.07063328f, 0.14562646f, 
    -0.11009134f, 0.02622270f, 0.08621878f, -0.04051667f, 0.11831597f, -0.25915608f, 0.05079811f, -0.38246152f, 
    0.28113741f, 0.00650146f, 0.05780031f, 0.55505806f, -0.12921694f, -0.11190246f, -0.03328731f, 0.09185880f, 
    0.18023254f, -0.12061121f, 0.15176003f, -0.00486161f, 0.16948402f, 0.05545814f, 0.32843044f, -0.04974397f, 
    0.36836967f, 0.18261538f, -0.07706126f, 0.06666748f, 0.07818352f, -0.12426415f, 0.10831332f, 0.01911628f, 
    -0.05428099f, 0.31948534f, 0.16583265f, 0.10578218f, 0.07330544f, 0.07534161f, 0.05629340f, 0.13052374f, 
    0.25901824f, -0.09229551f, -0.10358953f, 0.07109397f, 0.01678918f, -0.16653208f, 0.14455020f, -0.11650530f, 
    -0.16361293f, -0.29889107f, -0.10158765f, 0.50118124f, 0.02839049f, 0.01913347f, 0.31286171f, 0.07087640f, 
    -0.04464497f, -0.08978861f, -0.13017614f, -0.08555427f, 0.08348368f, 0.04699826f, -0.01781834f, -0.19942483f, 
    0.17461568f, -0.36147237f, -0.15815367f, 0.01700267f, 0.30444404f, 0.15277912f, 0.22657984f, -0.09828872f, 
    -0.14178897f, 0.00279927f, 0.00184670f, 0.23316897f, 0.00423340f, 0.10232424f, 0.17336871f, 0.04564046f, 
    0.17116824f, -0.39087048f, -0.00024127f, 0.00021967f, 0.01334565f, -0.07898363f, 0.22998802f, -0.10865074f, 
    -0.08367361f, -0.14008799f, 0.16855273f, -0.16173273f, 0.15812275f, -0.09726820f, 0.06010693f, -0.09606143f, 
    -0.07875895f, -0.02703651f, 0.04851739f, 0.13881551f, 0.05323701f, -0.05808752f, 0.03633263f, -0.04158111f, 
    0.14123139f, -0.06856982f, 0.04270279f, 0.08480567f, -0.15472475f, -0.11335333f, 0.07048812f, -0.07331002f, 
    0.02707585f, 0.02163760f, -0.17320481f, -0.11927543f, -0.16392761f, 0.03082974f, 0.07619963f, 0.01493657f, 
    0.29735163f, -0.05305979f, 0.03939720f, 0.00202209f, -0.02480623f, -0.17556408f, -0.13196187f, -0.13351710f, 
    0.10605447f, 0.38328448f, 0.12801291f, -0.10362752f, -0.05797447f, 0.02032213f, -0.25878939f, 0.40771434f, 
    -0.10273168f, -0.12627177f, -0.13903509f, 0.09555464f, -0.13693962f, -0.00501917f, 0.13627672f, 0.08857635f, 
    -0.01406730f, 0.33889258f, 0.00468552f, -0.19136566f, 0.22431342f, 0.12029768f, 0.22014917f, 0.13577373f, 
    -0.43078661f, 0.02474377f, 0.05275319f, 0.06453671f, 0.03677378f, 0.13921024f, 0.15679260f, -0.18651406f, 
    -0.02507685f, -0.10182995f, -0.17565791f, -0.14059351f, 0.06228273f, 0.10964724f, 0.22929478f, 0.02433868f, 
    0.29334515f, -0.11667591f, -0.06264333f, 0.19160318f, -0.15276664f, 0.00638606f, 0.01000138f, 0.14043215f, 
    -0.00488804f, 0.27160057f, -0.08770578f, -0.24935339f, 0.08431037f, 0.05881409f, 0.29012361f, 0.15381199f, 
    0.00376948f, -0.10912132f, -0.13744138f, 0.10803778f, -0.00997839f, -0.02728761f, -0.08085191f, 0.04805409f, 
    -0.13528083f, -0.13944840f, -0.12552486f, 0.15407909f, -0.08315641f, -0.15157734f, 0.04157477f, -0.08088858f, 
    -0.05217559f, -0.06005798f, -0.05443466f, 0.07129124f, 0.11048491f, -0.14750609f, -0.12597632f, -0.02366357f, 
    0.14722492f, -0.16388932f, 0.15895370f, 0.05148088f, -0.02901820f, -0.15578184f, 0.12390286f, 0.06480086f, 
    -0.03237975f, -0.06501395f, 0.02913883f, -0.03876129f, -0.15401617f, -0.04223983f, -0.11667180f, 0.07130836f, 
    0.13690686f, 0.00578155f, -0.09628426f, 0.00190716f, -0.09275656f, 0.13077638f, -0.06004833f, 0.10024700f, 
    0.06732794f, 0.16510832f, -0.00598747f, -0.10614979f, -0.17678913f, -0.06069509f, -0.09595784f, 0.11613780f, 
    0.00825106f, -0.13890244f, 0.09047261f, -0.16911042f, -0.09974482f, -0.13297482f, 0.13642353f, -0.14212085f, 
    0.03108837f, 0.10052567f, 0.12329149f, 0.17197606f, 0.04590838f, 0.22351825f, -0.15381873f, 0.32157239f, 
    0.12790291f, -0.18598324f, -0.11708457f, 0.03388678f, 0.05238165f, 0.02597260f, -0.19781266f, 0.26432213f, 
    -0.30745578f, 0.06998628f, 0.02334754f, 0.29076815f, 0.14596753f, -0.10866725f, -0.03947428f, 0.12989938f, 
    -0.10835917f, -0.09424917f, -0.13104755f, 0.01942887f, 0.16752489f, -0.15246989f, 0.07507501f, 0.14785263f, 
    -0.17227845f, -0.09497523f, 0.12285583f, -0.04147615f, 0.08516944f, 0.05325413f, 0.01791039f, -0.14567775f, 
    0.12097595f, 0.09477085f, 0.16284448f, 0.00922184f, 0.16171241f, -0.13748816f, -0.09648899f, 0.03606778f, 
    0.11406305f, -0.09050182f, -0.16719802f, -0.15469219f, 0.00056605f, -0.16943520f, -0.04879834f, 0.05350344f, 
    0.11305631f, -0.09969313f, 0.14606021f, 0.10043024f, -0.01813856f, -0.11870836f, -0.00857225f, 0.06938107f, 
    -0.02631881f, -0.10023070f, -0.04069411f, -0.07474322f, -0.16380695f, 0.31570470f, 0.15310898f, 0.21149051f, 
    0.05127149f, -0.04712889f, -0.08186483f, -0.12790035f, 0.09564171f, -0.06882647f, -0.07665741f, -0.05581119f, 
    -0.38981062f, -0.03881967f, -0.13865167f, -0.17768310f, -0.03886171f, 0.02101726f, -0.13924077f, 0.17602943f, 
    -0.04292785f, 0.05070304f, -0.02241508f, 0.04479764f, 0.09479241f, -0.08879639f, -0.12668128f, -0.01871495f, 
    -0.02587855f, 0.14714931f, -0.16555738f, 0.08198752f, -0.12606293f, -0.02118110f, 0.15252948f, 0.00059322f, 
    0.07318894f, -0.18188171f, 0.00163241f, 0.13660388f, 0.07804605f, -0.01001978f, 0.07776519f, -0.01541778f, 
    -0.12954354f, 0.17013958f, 0.02667052f, 0.07025968f, 0.02423063f, -0.20553200f, -0.02856419f, -0.15383151f, 
    -0.06613681f, 0.09112695f, 0.03108541f, -0.04883247f, -0.04036276f, 0.02794314f, 0.09458978f, -0.14384550f, 
    0.26341850f, -0.11058445f, -0.01718080f, -0.01713086f, 0.15461381f, 0.19860297f, 0.00283716f, 0.41787022f, 
    0.01114138f, -0.13348827f, -0.12699376f, -0.10381548f, 0.10023574f, -0.36809167f, -0.11932363f, -0.26616818f, 
    0.24660647f, 0.13980491f, -0.14585629f, 0.30289310f, -0.08257741f, -0.17015588f, 0.16106595f, -0.03503264f, 
    -0.03367592f, -0.10884821f, 0.08320941f, 0.12668206f, 0.16529293f, 0.12819758f, -0.28943872f, -0.02767321f, 
    0.12079018f, -0.01032965f, -0.14275330f, 0.12618639f, 0.12229884f, 0.19108671f, 0.00140957f, 0.40042365f, 
    -0.12068221f, -0.00055433f, -0.12299688f, 0.13771124f, 0.15616289f, 0.03256020f, 0.24338226f, -0.23811974f, 
    -0.11401972f, 0.04675233f, 0.06574392f, -0.25976917f, -0.15621389f, 0.13434525f, 0.01669383f, 0.15787527f, 
    -0.00539682f, -0.19757308f, -0.13520807f, 0.15986374f, -0.20931530f, -0.00803576f, -0.24022351f, 0.10415196f, 
    -0.10524859f, -0.04920594f, 0.08420534f, 0.09890781f, -0.01861529f, 0.05249239f, 0.05968725f, 0.21447349f, 
    0.09693098f, 0.09596554f, -0.11976796f, -0.15557370f, 0.04624489f, -0.41854832f, 0.35131264f, -0.47652379f, 
    -0.00145779f, -0.04135880f, -0.06835523f, -0.01308689f, -0.00162876f, 0.28046110f, -0.06015534f, -0.12379292f, 
    0.00715748f, -0.41943419f, 0.05826304f, 0.15350057f, 0.16382003f, 0.07022581f, -0.03115073f, -0.00795860f, 
    -0.10749720f, -0.12106635f, 0.12142073f, -0.13511382f, -0.04903308f, 0.05227562f, -0.01934888f, 0.21754652f, 
    -0.00638203f, -0.10095689f, 0.01793296f, -0.04865744f, 0.26401561f, 0.31341955f, -0.21830869f, 0.09646980f, 
    0.00426063f, -0.09333392f, 0.08165680f, 0.24657804f, -0.03174921f, -0.00521163f, -0.01982110f, -0.14179215f, 
    0.12232242f, 0.35134214f, 0.00452556f, -0.12190481f, 0.32316652f, 0.00929730f, -0.29302698f, -0.01006305f, 
    0.04519027f, -0.04257626f, 0.11969953f, -0.00728749f, -0.14793247f, -0.11357434f, 0.13866943f, 0.20537359f, 
    -0.06481960f, -0.30270535f, -0.07931653f, 0.09145968f, 0.28428549f, 0.13862416f, -0.00468318f, 0.14225450f, 
    -0.19613937f, -0.14865471f, 0.11706379f, 0.15850101f, 0.09911187f, 0.04870084f, 0.06599207f, -0.01806271f, 
    -0.05786054f, -0.07484846f, 0.01671651f, -0.06117064f, 0.12646554f, 0.06118601f, -0.14196485f, -0.09856731f, 
    0.20518449f, -0.14482071f, 0.16083506f, -0.03307626f, 0.15740530f, 0.05847209f, -0.00786658f, 0.21304105f, 
    -0.09978158f, 0.10551370f, 0.08345017f, 0.07069608f, 0.25314578f, 0.33794338f, -0.21881634f, -0.13802020f, 
    0.10963250f, -0.12691726f, -0.02175243f, 0.31351048f, -0.16739070f, -0.24383648f, -0.01493004f, 0.00897433f, 
    -0.02752522f, -0.19441770f, -0.10817870f, 0.21669789f, 0.31714019f, 0.05580469f, -0.19111873f, 0.10027742f, 
    0.49033007f, -0.06391348f, -0.06521913f, -0.00620768f, 0.12515143f, 0.20671320f, 0.04268746f, -0.01803480f, 
    -0.01189715f, 0.24446702f, 0.01050193f, 0.04714892f, -0.22372846f, -0.23122339f, -0.02329537f, 0.21946885f, 
    -0.28940237f, 0.18133195f, 0.03216307f, 0.11609522f, 0.07756553f, -0.04013695f, -0.09092952f, 0.15070002f, 
    -0.01864448f, -0.00851909f, 0.18116137f, -0.24486727f, 0.17538710f, -0.06310076f, 0.09458941f, 0.11407456f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.00485799f, -0.06516122f, 0.11997182f, 0.07210705f, 0.16875169f, 0.11423344f, 0.07366773f, 0.12800448f, 
    -0.04616690f, 0.24647669f, -0.00773643f, 0.15074867f, 0.12261723f, -0.06880854f, -0.03786681f, 0.15998638f, 
    -0.16819981f, 0.20500614f, -0.14267023f, 0.10854950f, 0.10794674f, 0.05369833f, -0.18174469f, -0.10817444f, 
    -0.18559055f, 0.01062975f, 0.20103286f, 0.03742826f, -0.12876877f, -0.00426868f, -0.11655292f, -0.06299708f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.16316569f, -0.01049803f, 0.15797745f, 0.29639968f, -0.47590965f, -0.07955139f, 0.16990453f, 0.13199174f, 
    -0.07113864f, -0.38641286f, -0.06059561f, -0.26833916f, 0.09269360f, 0.23472285f, -0.11013922f, -0.52844918f, 
    0.04762900f, 0.13276860f, -0.35055542f, 0.03987207f, 0.11584380f, 0.08062894f, -0.03709199f, 0.26162964f, 
    0.08483921f, 0.31980330f, 0.02369749f, 0.20832646f, -0.07301689f, -0.22113335f, 0.14187998f, 0.36948484f, 
    -0.04810808f, -0.12009283f, 0.24309333f, -0.18088838f, 0.05983050f, -0.08223508f, 0.11727448f, 0.26474538f, 
    0.08677473f, -0.19736281f, 0.26913106f, -0.25572547f, -0.03191810f, -0.24867578f, 0.06610570f, 0.23879790f, 
    0.09818111f, 0.33805713f, -0.28701073f, -0.05939814f, 0.08569627f, -0.04571247f, 0.08909696f, -0.15927503f, 
    -0.15356296f, -0.23783281f, -0.25331724f, -0.42806128f, 0.20838182f, 0.12547183f, 0.16607289f, 0.24835545f, 
    0.16870089f, 0.12039881f, -0.67513192f, -0.16191356f, 0.19772241f, 0.16215181f, -0.10898741f, 0.22698055f, 
    -0.21350035f, -0.21702518f, -0.35929441f, 0.06309450f, -0.15520485f, 0.33717528f, 0.29124692f, -0.27089694f, 
    -0.10747480f, 0.18730932f, -0.13159981f, 0.06316899f, -0.15934239f, 0.11936005f, 0.16824386f, -0.34452656f, 
    -0.09532773f, 0.23547326f, -0.42289492f, 0.01356175f, 0.06622317f, -0.17982061f, 0.16837135f, 0.16466603f, 
    0.05844301f, -0.16243786f, -0.11765634f, 0.19220433f, 0.40729126f, -0.04736527f, -0.03152640f, -0.66013187f, 
    -0.11409101f, 0.25093815f, -0.14586669f, -0.21674785f, 0.09706073f, 0.11349618f, 0.17127442f, 0.11555662f, 
    0.15506165f, -0.38551980f, -0.30330324f, -0.15664512f, -0.16943751f, -0.51444751f, -0.09540645f, -0.19520988f, 
    0.09634694f, -0.04327455f, 0.33406183f, 0.26995629f, -0.80512810f, -0.61321557f, -0.29391298f, 0.07730805f, 
    -0.09504907f, 0.10346931f, -0.04524046f, 0.39150754f, 0.26246929f, 0.11149941f, 0.04860195f, -0.35901368f, 
    0.03028442f, 0.08463274f, -0.24750717f, -0.04112836f, 0.08351542f, -0.39526251f, -0.20490304f, 0.05429166f, 
    -0.03093659f, -0.34849837f, -0.20306325f, -0.10476536f, -0.13187025f, 0.12598461f, 0.02541214f, 0.27432680f, 
    -0.16947889f, 0.24079457f, 0.23887570f, 0.01304628f, 0.10327719f, 0.20684834f, 0.10004878f, 0.08166373f, 
    -0.16601504f, -0.09481683f, 0.28329855f, 0.16179441f, -0.50857675f, 0.16835959f, 0.07698068f, -0.02561952f, 
    -0.06078510f, 0.09450231f, 0.15847498f, 0.22709988f, -0.05339029f, -0.49361682f, -0.38260651f, -0.43481174f, 
    0.13943128f, -0.09693204f, 0.18933652f, -0.00221437f, -0.09097159f, 0.08343235f, -0.12541062f, 0.28265715f, 
    0.05768169f, -0.26225457f, -0.00063793f, -0.16546153f, 0.22872163f, -0.21548392f, -0.05281671f, -0.13983943f, 
    -0.00390488f, -0.16492619f, -0.03664114f, -0.46378499f, 0.24459323f, 0.05734368f, 0.35673243f, 0.07291213f, 
    -0.19058023f, 0.11404842f, -0.36798364f, 0.37487289f, 0.08846298f, -0.08009153f, 0.15467319f, -0.54000461f, 
    -0.02409489f, -0.27002794f, 0.01307384f, -0.15143719f, -0.15771572f, -0.55958021f, 0.05478988f, -0.27588680f, 
    0.03056608f, 0.10209726f, 0.08382086f, 0.02125077f, -0.02066782f, -0.73710954f, -0.09091599f, -0.68982393f, 
    -0.12677290f, -0.04686259f, 0.24965742f, 0.32152104f, -0.38053799f, 0.05491344f, -0.42998856f, -0.27198914f, 
    0.09295683f, 0.14089026f, -0.29476565f, -0.36156335f, -0.15427078f, 0.21857353f, -0.35741028f, 0.42826965f, 
    0.14620030f, -0.12283281f, 0.33535761f, 0.15910576f, -0.15926626f, -0.06439478f, -0.15797456f, -0.04418363f, 
    -0.13206470f, -0.32360455f, -0.02547501f, 0.33426052f, -0.07631030f, 0.01415549f, -0.49777994f, -0.00004094f, 
    0.12949944f, -0.16732819f, -0.16751915f, -0.01067517f, 0.00418404f, 0.13153279f, -0.55899787f, 0.06695107f, 
    0.09392517f, 0.09881862f, 0.32525110f, 0.31938195f, 0.02210873f, 0.07768425f, -0.19629584f, -0.15997474f, 
    -0.05053978f, 0.28875044f, 0.34359461f, -0.04200571f, 0.13655506f, -0.21618871f, -0.15236086f, -0.63081443f, 
    -0.02080221f, -0.21719810f, -0.56209910f, -0.45921576f, -0.02646017f, -0.32853815f, -0.29504037f, 0.19688550f, 
    0.13843912f, -0.02099745f, -0.10960018f, -0.41138288f, -0.47088701f, -0.14227721f, 0.17079936f, 0.18961218f, 
    0.09468845f, -0.01994755f, -0.59837663f, -0.03590170f, 0.05098177f, 0.29946285f, -0.09095468f, 0.28770906f, 
    0.12850431f, -0.38982588f, -0.08735155f, -0.16799814f, 0.10022302f, 0.30988166f, -0.12849762f, 0.02624244f, 
    -0.13946046f, 0.31067261f, 0.12326747f, -0.16528460f, 0.23794217f, 0.42012092f, 0.27499223f, -0.35677072f, 
    -0.12195460f, -0.08700972f, -0.07499731f, -0.20977384f, 0.34484789f, -0.01683720f, -0.57081610f, 0.43887550f, 
    -0.00426165f, 0.29500642f, -0.06035580f, -0.08125807f, -0.15975836f, -0.44621798f, 0.23050278f, 0.06763230f, 
    0.05242292f, 0.06616018f, -0.04511314f, -0.14137766f, 0.14071493f, 0.22864193f, 0.01827522f, 0.17692974f, 
    -0.06539403f, -0.49983189f, 0.09943511f, -0.16977629f, -0.63428259f, -0.55564934f, -0.36564431f, 0.17286122f, 
    0.02808082f, -0.10546585f, 0.00124547f, -0.60515946f, -0.36002055f, 0.09589064f, -0.10513403f, -0.30645880f, 
    -0.09556954f, 0.26453629f, 0.25421825f, -0.06009937f, -0.03823256f, 0.14328077f, 0.29304916f, 0.27250561f, 
    -0.00085459f, -0.24583553f, 0.23708627f, -0.05333668f, 0.01673485f, -0.34136596f, 0.15765388f, -0.33262056f, 
    -0.06642611f, -0.36633143f, -0.09595606f, 0.10304102f, -0.08668780f, -0.29602152f, 0.25421056f, -0.38142028f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.23772393f, -0.10933337f, -0.03458687f, 0.08889439f, 0.04988642f, 0.07147041f, 0.07149352f, -0.13768888f, 
    0.14793359f, -0.13868956f, 0.14226398f, -0.10705976f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
