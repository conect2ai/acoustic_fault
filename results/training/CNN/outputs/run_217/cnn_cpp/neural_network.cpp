#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.31767240f, 0.31379408f, -0.17518410f, -1.05690479f, -0.13578983f, 0.98452342f, 0.15822881f, 0.08168644f, 
    0.73989415f, -0.36252612f, 0.73533005f, 0.38743833f, 0.84219253f, 1.23244643f, 0.60998923f, 0.24217081f, 
    0.28814292f, 0.19207852f, 0.72547185f, 0.62205279f, -1.12640870f, -0.54521757f, 0.79549915f, -0.78002542f, 
    0.36372599f, 0.11211113f, -0.18245263f, 0.24472615f, 0.53698856f, 0.52338880f, -1.16203475f, -0.81464458f, 
    -1.12331522f, 0.15669325f, 0.00350545f, -0.02695555f, -0.93285507f, -0.65011120f, 0.92034566f, 0.49386650f, 
    0.85532421f, -1.25149083f, 0.20171215f, -0.06164073f, 0.07584589f, -0.68184304f, -0.22424100f, 1.16282845f, 
    -0.22982819f, -0.60178632f, 0.14400396f, 0.43838486f, 0.17889474f, 0.48797631f, -0.67000759f, -0.22174262f, 
    -0.79411572f, -0.11754441f, 1.11393487f, -1.03175557f, -0.29029503f, -0.27308965f, -0.43330750f, -0.75952125f, 
    -0.78596407f, -0.84967858f, 0.48802674f, 0.16725907f, -0.65614945f, 0.54516447f, 0.31794262f, 0.20241019f, 
    0.11143552f, -1.20145547f, -0.30622303f, -1.05006754f, -0.01571506f, 0.01586807f, 0.16149133f, 0.67497575f, 
    0.72634482f, 1.16962850f, 0.81305683f, 1.07115626f, 0.43516326f, 0.14572752f, 0.35992900f, 0.07300245f, 
    0.26964307f, 0.24535760f, -1.61638772f, -0.73690981f, 0.01929745f, 0.70800179f, 0.59291005f, 0.16517450f, 
    0.20560995f, -0.16641796f, 0.17711186f, 0.47100636f, -1.00599802f, 0.14039882f, -0.76269388f, -1.29097188f, 
    -1.06338000f, -0.85204095f, -0.26562363f, -0.47031778f, -0.61794788f, -1.02101696f, -0.54929751f, -1.15599334f, 
    -0.83900130f, -0.07144951f, 0.29403573f, 0.28417277f, 0.10465743f, 1.09406555f, 1.38659298f, -0.02716768f, 
    0.33013156f, -1.01703942f, -0.16896035f, 0.04293348f, -0.13323870f, 0.07328978f, 0.77035713f, -1.05740535f, 
    -1.29866016f, -0.45883957f, -0.31365639f, -0.33475286f, -0.20337963f, 0.29969391f, 0.27249208f, -0.89254338f, 
    -1.11055994f, -0.85474581f, 0.28727794f, 0.45728955f, 0.79372239f, -0.38682103f, -0.58060455f, -0.31066337f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.09743098f, 0.22968884f, 0.00738159f, 0.32365674f, -0.07822301f, 0.25176790f, 0.18528186f, -0.21334265f, 
    0.37169048f, 0.99836606f, 0.27905315f, -0.75847828f, 0.09640922f, -0.21277273f, -0.44236389f, 0.12696803f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.17756233f, -0.64904809f, -0.51416570f, -0.22944666f, 0.08642141f, 0.03851823f, 0.01178920f, -0.05429690f, 
    0.28943166f, -0.22058564f, 0.44910806f, -0.00724789f, 0.25738209f, 0.16072854f, -0.05926915f, 0.24951592f, 
    0.27425522f, 0.36785379f, -0.41275406f, -0.42293459f, -0.33934644f, -0.08270155f, 0.05148624f, 0.11544354f, 
    0.02139348f, 0.15059769f, 0.06408316f, 0.28256997f, 0.02242398f, 0.38302600f, 0.28590506f, -0.10874870f, 
    0.12159392f, -0.14067045f, -0.09146772f, 0.05055759f, 0.05814105f, 0.02903149f, -0.08154442f, -0.16801387f, 
    -0.22130628f, -0.11098427f, -0.05308671f, -0.12103681f, 0.07727548f, -0.07573437f, 0.49758795f, -0.02380446f, 
    0.07145528f, 0.01396676f, -0.00888858f, 0.03726962f, 0.12682153f, 0.08293211f, 0.00353275f, -0.00201923f, 
    0.16273564f, 0.10222299f, 0.04375977f, 0.24728447f, 0.20481232f, 0.10425172f, -0.04004569f, -0.15273042f, 
    0.20660332f, -0.08979940f, -0.42123565f, -0.28316256f, 0.35017627f, 0.04347242f, 0.12013691f, 0.12527260f, 
    -0.00068828f, 0.16178839f, 0.17084476f, 0.13133714f, 0.11603022f, 0.17682950f, 0.30719453f, 0.02180078f, 
    0.23930781f, -2.12407732f, -0.30501646f, -0.11398889f, 0.38323119f, 0.12823179f, 0.26752397f, 0.10634929f, 
    0.02327433f, 0.22938845f, 0.34810179f, 0.27507490f, 0.21472140f, -0.09319451f, 0.01110237f, 0.05525393f, 
    0.17827062f, 0.06069036f, -0.15817417f, -0.01563160f, 0.67611188f, 0.44992858f, -0.05987376f, 0.17074350f, 
    0.21887165f, 0.06068926f, -0.23460212f, 0.08698577f, -0.24063325f, 0.11855857f, -0.19893727f, -0.21052542f, 
    -0.17439781f, -0.21391809f, -0.18832476f, 0.11518605f, -0.23072684f, -0.02687936f, -0.59221369f, -0.37498748f, 
    0.04523147f, 0.03195595f, 0.16998363f, 0.00239865f, -0.01056920f, -0.43122861f, 0.09507384f, 0.10632252f, 
    -0.08516857f, 0.08834613f, -0.15117218f, -0.22704186f, -0.11274989f, 0.17172717f, -0.00754909f, 0.48404697f, 
    0.21652734f, -0.08472851f, 0.17794470f, 0.04499362f, -0.04419729f, -0.18659008f, 0.53157479f, -0.06359690f, 
    -0.01514577f, -0.00667161f, 0.05049254f, 0.04414667f, 0.04818443f, -0.04640299f, 0.05471825f, 0.00200330f, 
    0.01936013f, 0.00153676f, 0.03067937f, -0.07724378f, 0.02630103f, 0.05016353f, -0.02575206f, -0.05764285f, 
    0.01287975f, -0.02074670f, -0.07023618f, -0.01642924f, 0.00605534f, 0.01588648f, -0.04366723f, 0.03934916f, 
    0.04553048f, -0.01924546f, -0.08321710f, -0.08320869f, -0.04712687f, -0.02147611f, -0.03679563f, -0.06558893f, 
    -0.01547406f, 0.02583616f, -0.05162083f, -0.01192798f, -0.05248224f, 0.03796737f, 0.01715871f, -0.02527508f, 
    -0.01729607f, -0.07971328f, -0.02634652f, -0.06267452f, -0.07105044f, 0.04764988f, -0.03714772f, 0.02328792f, 
    0.00130440f, 0.04353199f, -0.06917215f, 0.03763213f, -0.05523315f, -0.00590454f, 0.01952727f, -0.03864028f, 
    -0.02207627f, -0.02269410f, 0.06559864f, -0.04137601f, -0.07547977f, -0.06034954f, -0.01687546f, 0.06255013f, 
    -0.00325291f, -0.04066864f, 0.04420245f, -0.04980038f, -0.02366836f, 0.02876814f, -0.04307749f, 0.04061859f, 
    0.01719628f, -0.03701948f, -0.04821758f, 0.07713436f, -0.08711609f, 0.04130828f, -0.04711980f, -0.02246647f, 
    0.03655455f, 0.07439795f, -0.00093713f, 0.02423915f, -0.04035999f, -0.02002242f, -0.05635809f, 0.03035841f, 
    0.04439318f, 0.07294268f, 0.05682550f, -0.07296398f, -0.02214159f, -0.04472607f, 0.04374261f, -0.03223292f, 
    0.00484173f, 0.07574552f, -0.03888888f, -0.08328158f, 0.03555811f, 0.00727993f, -0.06718369f, 0.00774919f, 
    0.05152159f, 0.05958288f, 0.00918762f, 0.03823333f, 0.00454435f, 0.05133804f, -0.01079912f, -0.01736937f, 
    0.03721698f, -0.01829210f, 0.01926349f, -0.06624614f, -0.07395758f, -0.06050730f, -0.04470490f, -0.08029773f, 
    -0.07229892f, -0.05518474f, -0.07253836f, -0.00707892f, -0.08131330f, -0.04858077f, 0.01113880f, 0.04604494f, 
    -0.02231342f, -0.02432120f, 0.03110449f, -0.06707380f, -0.03538829f, -0.05774489f, 0.06760952f, -0.01922846f, 
    -0.08028349f, 0.07441388f, -0.04330230f, 0.03203114f, -0.04604651f, 0.02267480f, -0.00151153f, -0.04273305f, 
    0.01997966f, -0.03128173f, 0.00256898f, -0.04214773f, 0.04774463f, -0.00238567f, -0.12066731f, -0.00934264f, 
    -0.05509302f, 0.03662036f, -0.09350471f, -0.11441820f, 0.03606902f, 0.04024447f, -0.02777998f, -0.09162088f, 
    0.04057461f, -0.06056111f, 0.01991381f, -0.02237548f, -0.04753955f, 0.01238436f, 0.01074770f, -0.02576411f, 
    -0.08668657f, 0.00317786f, -0.09673455f, 0.03980582f, -0.08263537f, -0.03656075f, -0.05738494f, -0.07764155f, 
    -0.00634127f, 0.02392901f, 0.04374461f, -0.05317066f, 0.02388890f, -0.03644779f, -0.05912381f, -0.10019630f, 
    0.01791902f, -0.12705491f, -0.01945315f, -0.05315032f, -0.00695099f, 0.06407323f, -0.11749467f, -0.11527302f, 
    -0.00205206f, 0.05057194f, 0.02985327f, -0.11605374f, -0.11543819f, 0.01796375f, 0.01099965f, -0.02895521f, 
    -0.05511369f, -0.09002950f, -0.05939990f, 0.05309946f, -0.04050960f, -0.02133358f, 0.01807905f, 0.09071805f, 
    0.08296484f, 0.02655738f, -0.04597360f, -0.06854162f, 0.09723330f, -0.09455037f, -0.02286307f, 0.01413299f, 
    0.01810241f, -0.02565648f, -0.10656317f, 0.00322224f, 0.01382485f, -0.02409139f, -0.04844344f, -0.07793524f, 
    -0.05045852f, -0.08416632f, -0.09158181f, -0.13791052f, 0.04138704f, -0.10236757f, 0.03147583f, -0.02626259f, 
    -0.05206953f, -0.02001751f, -0.01879933f, -0.08506604f, 0.03658490f, -0.09652368f, -0.10223723f, -0.01656948f, 
    0.02883817f, -0.01256102f, 0.00128787f, -0.03998024f, 0.04747260f, -0.01438040f, -0.07642720f, -0.03370833f, 
    0.06606577f, -0.11601251f, -0.02354264f, -0.04056935f, -0.01977680f, 0.05674779f, 0.05814645f, 0.04659694f, 
    0.01569055f, -0.06379759f, -0.08654149f, -0.04266545f, 0.05699288f, -0.06483871f, -0.01748123f, -0.09085629f, 
    -0.09540789f, -0.06321111f, 0.02223049f, -0.08053049f, -0.07527179f, -0.01499265f, 0.03309361f, 0.02969459f, 
    0.04967139f, -0.12580115f, 0.03991944f, 0.00820378f, -0.05174836f, -0.00112147f, 0.02918413f, 0.11198032f, 
    -0.03974266f, -0.02679758f, -0.04960642f, -0.09002243f, 0.06090593f, 0.00730772f, -0.07458473f, 0.03938159f, 
    -0.02241796f, -0.04469595f, -0.04377421f, -0.02951609f, -0.02286131f, 0.03466455f, -0.07662281f, -0.05380649f, 
    0.04092867f, -0.00110671f, 0.00521150f, 0.00181432f, 0.05301183f, -0.05114948f, -0.09311457f, -0.07926566f, 
    0.04732081f, 0.05147683f, -0.08193383f, 0.02766580f, -0.10435997f, -0.03889951f, -0.01546692f, -0.04987948f, 
    -0.06468936f, 0.00742859f, 0.00890691f, 0.02626334f, 0.03032924f, 0.04362299f, -0.05480756f, -0.02143459f, 
    0.01069405f, -0.00446247f, -0.07990743f, -0.00257149f, -0.05219484f, -0.04988855f, 0.06380086f, -0.05931006f, 
    -0.00512160f, -0.01536718f, 0.02148140f, 0.04751856f, -0.04491768f, -0.10354331f, -0.02721150f, -0.06124034f, 
    0.00700485f, 0.01181428f, -0.09508631f, 0.06177214f, -0.09180092f, -0.02567531f, -0.04645385f, -0.07348207f, 
    -0.03849943f, 0.02869661f, -0.03471063f, -0.08458650f, -0.02470432f, -0.04149216f, 0.07140787f, -0.04867902f, 
    -0.04521506f, 0.04675236f, 0.03203783f, 0.03216823f, -0.00968927f, -0.06562801f, -0.03480033f, -0.10472690f, 
    0.02499981f, -0.04108804f, -0.04449924f, -0.08116509f, 0.02014801f, -0.10248090f, -0.07636889f, -0.02164744f, 
    -0.04589165f, -0.06776226f, -0.03375912f, 0.04360149f, -0.03861195f, -0.03184848f, -0.02638156f, -0.02939949f, 
    -0.03560195f, 0.02281711f, 0.01113963f, 0.00712542f, -0.02847799f, -0.08107249f, -0.00673367f, -0.04027169f, 
    0.02909014f, -0.08327264f, -0.04326909f, -0.07364877f, 0.01002414f, -0.03332671f, 0.01004707f, -0.02532942f, 
    -0.01934137f, 0.04460323f, -0.05313169f, -0.05771471f, 0.00369901f, -0.00504069f, -0.00081883f, -0.04857768f, 
    -0.00532339f, -0.01285136f, 0.04984247f, 0.04798264f, -0.00811656f, -0.00328834f, 0.00958400f, 0.04418845f, 
    0.04008639f, -0.02796235f, -0.02850635f, -0.00969819f, -0.09953085f, 0.02015097f, -0.04961527f, 0.04022969f, 
    0.04410243f, -0.01966534f, -0.03719634f, -0.07751422f, -0.02378356f, -0.08953708f, -0.04881191f, 0.03386738f, 
    0.02210819f, -0.08647880f, -0.04045520f, -0.06243446f, 0.03246845f, -0.04963616f, 0.03350132f, 0.04111208f, 
    0.05668392f, 0.14447929f, 0.03570096f, -0.12461770f, -0.18831502f, 0.18958803f, -0.12146094f, 0.03604086f, 
    0.12929109f, -0.04491410f, -0.16065016f, -0.07415615f, -0.17081521f, 0.26644379f, -0.03592481f, 0.06658251f, 
    -0.16215804f, -0.13530138f, -0.48738500f, -0.36679402f, 0.20314732f, -0.02948216f, 0.01123410f, -0.25887826f, 
    0.23611808f, 0.05547909f, -0.05090828f, 0.31677362f, 0.59136569f, 0.16347244f, -0.09591320f, 0.24871065f, 
    0.09833792f, -0.03214183f, 0.11736650f, 0.35233676f, -0.05076294f, -0.27905610f, -0.15020698f, 0.09535372f, 
    0.02756395f, -0.04270309f, 0.07436616f, -0.02468637f, 0.00275435f, -0.03473191f, -0.29739565f, -0.02812558f, 
    0.06840096f, -0.10116229f, 0.01213306f, -0.04004521f, 0.09296478f, 0.04626591f, -0.33894128f, -0.31151339f, 
    -0.38474846f, 0.13260239f, 0.06657434f, 0.21586943f, -0.03232186f, -0.10693776f, -0.14865956f, -0.41293699f, 
    0.15954512f, -0.05454819f, 0.12757781f, -0.04097773f, -0.07817150f, -0.13554527f, -0.13213210f, 0.16043919f, 
    -0.13054302f, 0.03781815f, -0.24196972f, 0.05887537f, -0.01341028f, 0.05032158f, 0.24998352f, -0.17288905f, 
    0.26498872f, 0.05312737f, 0.27499253f, 0.67302543f, 0.31520095f, 0.40491489f, 0.00987614f, 0.31884858f, 
    0.11791869f, 0.01600056f, -0.51619107f, -0.35457450f, -0.50293601f, -0.02029292f, 0.02296343f, 0.36959052f, 
    0.25209162f, -0.00486231f, 0.09125112f, 0.19398369f, 0.25676319f, 0.00996070f, -0.42014751f, 0.09413020f, 
    -0.03096444f, -0.08023505f, 0.09679152f, 0.07257262f, -0.21088715f, 0.03549347f, 0.01333074f, 0.19243406f, 
    0.16704646f, 0.21260053f, 0.35475007f, -0.00653895f, -0.10096531f, -0.46607924f, 0.00800461f, 0.21434765f, 
    0.03519665f, 0.09174163f, 0.01823004f, -0.10258854f, -0.25195247f, -0.11381567f, -0.10624847f, -0.19530930f, 
    -0.18126963f, 0.11050436f, -0.00297112f, -0.47880176f, -0.00111073f, -0.04945628f, 0.00885122f, 0.13321391f, 
    0.16510820f, -0.16915785f, 0.11854104f, -0.14575799f, -0.12145691f, 0.06790572f, -0.09498262f, -0.20590319f, 
    -0.24982551f, -0.13860755f, -0.64012539f, -0.28351805f, -0.08783061f, -0.23539802f, 0.19414198f, -0.01360982f, 
    -0.20028976f, -0.20512190f, 0.44384155f, 0.43769446f, 0.49732849f, 0.29033914f, 0.33261317f, 0.02116966f, 
    0.22760849f, 0.24378493f, -0.27328560f, 0.23549600f, -0.42863101f, 0.07027784f, 0.00889084f, -0.04735093f, 
    0.29824752f, -0.08946356f, 0.19651160f, -0.01258361f, -0.10295588f, -0.03742569f, -0.07549795f, -0.03382409f, 
    -0.12970082f, 0.00273586f, 0.09198818f, 0.02663826f, 0.16857605f, 0.09885205f, -0.14390026f, -0.08003798f, 
    -0.32969663f, -0.04086312f, -0.11936943f, 0.08025375f, -0.09235718f, -0.15772146f, -0.00884122f, -0.50741923f, 
    0.20524226f, -0.29965150f, -0.18737745f, -0.12642860f, 0.04402496f, -0.22777928f, -0.08675241f, 0.47991812f, 
    0.11726994f, -0.08744206f, 0.05030879f, 0.05232580f, -0.28076822f, 0.21084119f, 0.06603839f, -0.22869533f, 
    0.03241324f, 0.22346382f, 0.22604385f, 0.06254982f, 0.17014541f, 0.07990147f, -0.36127245f, -0.08836826f, 
    0.17968173f, 0.01082609f, -0.01496745f, -0.07254127f, -0.12988062f, 0.11675414f, 0.03228640f, -0.22509368f, 
    -0.14906663f, -0.07456771f, -0.06276987f, -0.13901767f, 0.12917575f, 0.21064322f, 0.18388444f, 0.08311338f, 
    -0.00884297f, -0.22034179f, 0.03279680f, -0.05268927f, 0.27966774f, 0.18917720f, 0.12490794f, -0.00666055f, 
    -0.05308209f, -0.13590932f, 0.25842974f, 0.49012202f, 0.09857722f, 0.00124751f, -0.33987734f, -0.19328783f, 
    -0.13867834f, 0.16743580f, 0.20680693f, 0.21734221f, -0.24494262f, -0.14449425f, 0.25360414f, 0.08448321f, 
    0.26318890f, -0.27171871f, 0.16503415f, 0.15932707f, 0.03949497f, 0.63095051f, 0.12004678f, -0.03481435f, 
    -0.05037425f, -0.26538879f, 0.26162276f, 0.00050071f, 0.01185729f, -0.03855392f, 0.27345893f, 0.36338124f, 
    -0.04500151f, -0.02207098f, -0.01159676f, -0.22908151f, 0.11879533f, 0.15174077f, -0.03531332f, 0.08263943f, 
    0.16541556f, 0.49580646f, 0.53819752f, 0.19044124f, 0.04804255f, -0.08640309f, 0.09699611f, 0.46622831f, 
    0.00628986f, -0.24492504f, 0.10437526f, -0.21067478f, 0.01915389f, 0.00849852f, -0.22413126f, 0.00414108f, 
    0.07441089f, 0.43978816f, 0.29388368f, -0.02969892f, 0.13677807f, 0.03859492f, 0.07185420f, 0.14203067f, 
    0.18790707f, 0.10059003f, -0.01726582f, -0.06177070f, -0.37442479f, 0.16244821f, -0.00164054f, -0.12502462f, 
    0.00593769f, -0.02674921f, -0.07800274f, -0.62734723f, -0.16206515f, -0.60991967f, 0.06583552f, 0.15916245f, 
    -0.12307320f, -0.03914893f, 0.11604322f, -0.08821028f, -0.28090277f, -0.64525521f, -0.30477706f, 0.04543340f, 
    0.05462012f, -0.05153012f, 0.14005421f, 0.12525177f, -0.02773822f, 0.29927480f, -0.00270739f, 0.02408943f, 
    -0.03044455f, -0.06538509f, -0.29892105f, 0.04562216f, -0.08069933f, 0.11078060f, -0.05963329f, -0.06450784f, 
    0.07277246f, 0.11763012f, 0.04336675f, 0.23592404f, -0.05335470f, -0.16793884f, -0.10346842f, -0.07271250f, 
    -0.31291002f, 0.51335502f, -0.24429071f, 0.02285397f, 0.14245591f, 0.03341463f, 0.02872178f, 0.31465518f, 
    -0.54328620f, -0.06838515f, -0.18786259f, 0.07622113f, -0.18257527f, 0.03359393f, -0.08280336f, -0.15208645f, 
    -0.08772740f, 0.22381429f, -0.00913300f, 0.17313704f, 0.14428400f, 0.13512559f, -0.17191862f, -0.11867238f, 
    0.09108525f, 0.21744458f, 0.42634085f, -0.30922449f, 0.27645329f, 0.26915979f, 0.03117073f, 0.03564498f, 
    -0.11510859f, -0.04649664f, 0.06894173f, 0.31873277f, -0.00986546f, -0.33102682f, 0.06888610f, 0.01319141f, 
    0.00989491f, 0.07059795f, 0.11128655f, 0.17649730f, -0.32870698f, 0.25358716f, 0.19393043f, -0.03821481f, 
    -0.06390183f, -0.05686214f, 0.04920487f, 0.13656861f, 0.01293786f, -0.55687892f, 0.21815535f, -0.11590467f, 
    -0.24220015f, 0.14308846f, -0.12035768f, -0.02938406f, -0.05754945f, -0.01833864f, 0.20360252f, 0.22616474f, 
    0.47031739f, 0.30000466f, 0.05969044f, -0.16510189f, -0.06434451f, -0.16736509f, -0.11494694f, 0.66138756f, 
    0.18827257f, 0.53381538f, -0.21252094f, -0.19771168f, -0.06463527f, 0.00898221f, 0.17959471f, -0.00603689f, 
    0.06000441f, -0.00301756f, -0.05810631f, 0.06448695f, -0.05516934f, -0.08704926f, 0.06778739f, -0.02713108f, 
    0.01231915f, -0.07650585f, -0.00941118f, -0.02655783f, -0.02268837f, -0.05727826f, 0.02597069f, -0.02827228f, 
    -0.05894796f, 0.02670173f, -0.01204096f, -0.02678530f, 0.02905172f, 0.00822484f, -0.03748187f, 0.01072922f, 
    0.00403041f, 0.02107046f, 0.03661576f, 0.03051531f, -0.07709909f, -0.01688486f, -0.04590206f, 0.07221875f, 
    0.02951296f, 0.01377057f, -0.03571292f, 0.02302846f, -0.02494550f, 0.06847575f, 0.06263731f, -0.07311352f, 
    0.01195442f, -0.10123496f, 0.02984980f, 0.04945980f, -0.03996966f, 0.06045795f, 0.02260275f, -0.04269311f, 
    -0.01606019f, -0.04585165f, -0.05504073f, 0.01462720f, -0.08520165f, -0.09242833f, -0.03044579f, -0.05924381f, 
    -0.00992589f, 0.06876451f, 0.02660642f, -0.02362470f, 0.05514134f, -0.00122132f, -0.08014911f, -0.03530942f, 
    -0.00234184f, 0.06885843f, -0.06708362f, 0.03768050f, -0.08379507f, 0.01651963f, -0.03456230f, -0.08323171f, 
    -0.00355970f, 0.02603556f, -0.06801812f, 0.06278500f, -0.04150126f, -0.07493907f, 0.05772702f, 0.05127189f, 
    -0.06603424f, 0.01948320f, 0.03748873f, 0.04379042f, 0.06913528f, -0.05801668f, -0.06101646f, 0.02867323f, 
    0.03866684f, 0.03164795f, -0.03280302f, 0.01603027f, -0.08302825f, -0.01203351f, 0.00649691f, -0.08965803f, 
    -0.04413356f, -0.03508326f, -0.07041248f, -0.07649247f, 0.05430733f, 0.07035205f, -0.02332012f, 0.01907782f, 
    0.02819555f, 0.05097630f, -0.03141199f, -0.00914978f, 0.02431489f, 0.04848323f, 0.05211496f, 0.00547940f, 
    -0.08739962f, -0.07035857f, -0.06077776f, 0.03863385f, -0.02502069f, -0.10779829f, -0.07300367f, -0.06728307f, 
    -0.01855990f, 0.07224900f, 0.02033637f, 0.02514947f, -0.04752480f, -0.05611428f, -0.08662519f, -0.03313025f, 
    -0.00875646f, 0.04363567f, -0.05304532f, 0.04010834f, -0.03835351f, 0.02461995f, 0.01175587f, -0.05378155f, 
    -0.05616769f, 0.06879668f, -0.01963470f, 0.00339537f, -0.01434883f, -0.03398519f, -0.09475091f, 0.04727622f, 
    -0.14504543f, -0.07649706f, -0.09674455f, 0.04544185f, 0.02869788f, -0.07406030f, -0.11786846f, -0.03266312f, 
    -0.06497640f, -0.07097870f, 0.03836580f, -0.03953581f, -0.09992476f, -0.06776397f, 0.05123181f, -0.11514696f, 
    0.06844181f, -0.01068034f, 0.00353899f, -0.10285568f, -0.02355037f, -0.06368011f, -0.08931223f, -0.00730885f, 
    0.05977667f, 0.02381469f, -0.02718987f, -0.04975180f, -0.03481231f, -0.07613949f, 0.02119681f, -0.03283571f, 
    0.02687654f, -0.00019722f, 0.05307825f, -0.10075121f, -0.03175453f, -0.06742996f, -0.04471672f, -0.06402402f, 
    0.03456062f, -0.03166173f, 0.03566741f, 0.05471457f, -0.09523016f, -0.01733170f, -0.06653827f, -0.07586298f, 
    0.06751940f, -0.09762455f, 0.06786813f, -0.07711671f, -0.04072341f, -0.10306276f, -0.11351356f, -0.04875791f, 
    -0.11350667f, 0.01639639f, -0.15345903f, 0.01841847f, -0.05762174f, -0.01564558f, 0.00054647f, -0.03438785f, 
    0.02915912f, -0.08113387f, 0.05728951f, 0.08386750f, -0.01774060f, 0.03148856f, -0.09073905f, 0.05242643f, 
    -0.09724745f, -0.03634785f, -0.05299034f, -0.04613928f, 0.02069565f, 0.03712473f, -0.00240553f, 0.02056593f, 
    -0.10976269f, -0.06799662f, -0.04721279f, 0.02000333f, -0.01737166f, -0.06444605f, -0.13173102f, -0.01872043f, 
    0.01866464f, -0.02540833f, -0.07151763f, 0.02795577f, -0.13251595f, 0.07448310f, -0.04180894f, 0.04563363f, 
    0.01003230f, -0.09690732f, -0.02790629f, -0.00700862f, -0.00593126f, 0.06267974f, 0.03842174f, 0.03164285f, 
    -0.08440258f, -0.03419969f, -0.04369462f, -0.10885667f, -0.05878212f, -0.08616444f, -0.09757222f, 0.04718906f, 
    0.00401613f, -0.05984473f, 0.02403912f, -0.04310199f, -0.10408644f, 0.00945780f, -0.05069982f, 0.02726747f, 
    -0.02912622f, -0.02415491f, -0.07384335f, 0.00159535f, 0.06464677f, 0.01148298f, -0.08508712f, -0.02133264f, 
    -0.00624893f, -0.08796139f, 0.00600286f, -0.03828824f, -0.01662800f, -0.06952607f, -0.07082713f, 0.02607083f, 
    0.02435917f, -0.06951117f, 0.05044415f, 0.04059269f, -0.01733734f, -0.05755160f, 0.05452240f, 0.04788320f, 
    -0.05465063f, 0.00511705f, -0.03406114f, -0.03875912f, -0.02735488f, -0.04200783f, -0.01381175f, -0.03569927f, 
    0.00070249f, 0.03592282f, -0.00759521f, -0.09682716f, -0.07788653f, 0.00761661f, -0.03101742f, -0.08482598f, 
    -0.06489794f, -0.03908722f, 0.04605892f, -0.00393674f, 0.05530269f, -0.02892679f, -0.09016243f, 0.03540759f, 
    0.03028541f, 0.04621980f, -0.09666122f, -0.00232546f, -0.07629475f, -0.02101400f, 0.01960795f, 0.02287045f, 
    0.05583097f, 0.06313800f, 0.01273929f, -0.09332435f, -0.00036085f, 0.06011667f, 0.03838308f, -0.02819495f, 
    -0.03326863f, -0.03686887f, -0.04315408f, -0.06884623f, -0.02449209f, -0.05075457f, -0.07948526f, -0.00889501f, 
    -0.09646780f, 0.03944026f, 0.04636753f, -0.02297881f, 0.00909463f, 0.01984312f, -0.04086446f, 0.01635965f, 
    0.04928555f, 0.05315985f, -0.06870393f, -0.00872642f, -0.01277710f, -0.02166609f, -0.02855055f, -0.06550261f, 
    -0.02219609f, 0.05544060f, -0.00255144f, -0.08226542f, 0.03550581f, -0.03409126f, -0.08603685f, -0.00984105f, 
    -0.04341466f, -0.06142940f, 0.03504400f, -0.08031760f, -0.06956417f, 0.06270065f, 0.01779992f, -0.05938141f, 
    0.05124005f, 0.00469652f, -0.02514222f, -0.09360887f, 0.05274418f, -0.02095364f, -0.03971139f, -0.07058047f, 
    0.00768218f, -0.08309576f, -0.07614978f, -0.07530241f, 0.05478206f, -0.01446309f, -0.04467580f, -0.05737661f, 
    -0.04077087f, -0.03861697f, 0.06103117f, 0.02872962f, 0.01887830f, -0.08335200f, 0.04002931f, -0.07544871f, 
    0.05076555f, -0.08203231f, 0.05341107f, 0.00738133f, -0.01732859f, 0.03028727f, 0.04726322f, -0.00500330f, 
    -0.00136674f, 0.04109573f, -0.01352504f, -0.08653977f, -0.08676263f, 0.05929008f, -0.02901338f, -0.01872378f, 
    0.07738836f, 0.01610931f, -0.07475221f, -0.08268335f, -0.02933475f, 0.04193138f, -0.09060506f, -0.03331055f, 
    -0.08830184f, 0.05391192f, -0.03273126f, 0.03803577f, 0.02003252f, -0.05495733f, 0.03711032f, -0.04514012f, 
    0.05830087f, -0.03791010f, 0.02938915f, -0.07484295f, 0.04268388f, -0.05709983f, 0.06968880f, -0.05935558f, 
    -0.05662816f, -0.09378906f, -0.00760926f, -0.09319291f, -0.01829175f, -0.09435630f, -0.05929411f, -0.01760322f, 
    -0.09987883f, -0.07184526f, -0.08424975f, -0.06075525f, 0.01487998f, -0.07883804f, -0.10784036f, -0.00094301f, 
    0.02493820f, -0.03252282f, 0.04571521f, 0.00518808f, -0.03214100f, -0.08467346f, 0.03054419f, -0.09584549f, 
    0.01509347f, -0.09708822f, -0.05546667f, 0.01524657f, -0.03387726f, -0.07072929f, -0.10142920f, 0.05068192f, 
    -0.05791394f, -0.04099339f, -0.11778201f, -0.04428892f, -0.04012605f, 0.00794355f, 0.04889607f, 0.02076030f, 
    0.04963260f, 0.02021606f, -0.06726754f, -0.03078762f, 0.02111133f, -0.10828649f, 0.03249181f, -0.00272265f, 
    -0.07866142f, -0.01352945f, 0.04000634f, -0.02329568f, -0.00780255f, 0.00910529f, -0.08538779f, -0.09704673f, 
    0.02003543f, -0.00264239f, -0.10429299f, -0.01408490f, 0.00356702f, -0.06018009f, -0.08572368f, -0.07969854f, 
    -0.05981489f, -0.05282604f, -0.03767293f, -0.00150107f, -0.04285463f, 0.01359987f, 0.01618613f, -0.08000690f, 
    -0.04662693f, -0.07627641f, -0.00478334f, -0.08876558f, 0.02233522f, 0.05104028f, -0.09504326f, -0.07820489f, 
    0.00749006f, 0.01929135f, 0.01429883f, 0.07493817f, 0.03437342f, -0.01859766f, -0.00247586f, -0.00078224f, 
    -0.03375984f, 0.00506181f, -0.05209404f, -0.09897042f, -0.04244624f, 0.02589287f, -0.07774543f, 0.00560949f, 
    0.02432788f, -0.06781491f, -0.05493930f, 0.01767632f, -0.00761733f, -0.04612673f, -0.04443784f, 0.04440546f, 
    -0.04120469f, -0.00699351f, -0.07246174f, 0.00245121f, 0.00699910f, 0.05714504f, -0.09836357f, 0.04936231f, 
    -0.00035394f, -0.06222926f, -0.10676344f, -0.12026292f, -0.10059881f, 0.04556027f, -0.05293399f, 0.08894530f, 
    -0.08410717f, -0.05845414f, -0.02949447f, 0.01554861f, 0.06955101f, 0.06850372f, -0.07124463f, -0.09241339f, 
    -0.02066665f, -0.07173952f, -0.04930056f, 0.05458585f, 0.02485566f, -0.12170210f, -0.09572377f, -0.05455301f, 
    -0.00658643f, -0.05567393f, 0.04570885f, 0.05087204f, -0.10814978f, -0.09301380f, -0.09659752f, 0.05664129f, 
    -0.09313477f, -0.09937386f, -0.29757765f, 0.01642343f, -0.22673155f, -0.02248812f, 0.09724862f, 0.06101644f, 
    0.23920345f, -0.08904853f, 0.04843477f, 0.34020779f, -0.10599079f, 0.02418575f, -0.04388469f, 0.05227874f, 
    0.13168648f, -0.05935016f, 0.52189565f, -0.32233104f, -0.45379651f, 0.08968337f, 0.08194448f, -0.03223763f, 
    -0.22323936f, 0.10337196f, 0.19257285f, 0.26745349f, -0.48737225f, -0.23613526f, -0.02371537f, -0.02588974f, 
    0.19740868f, 0.16390689f, -0.18203038f, 0.19670615f, -0.57247245f, -0.42197216f, 0.00640906f, -0.32634589f, 
    0.03191087f, -0.07553587f, -0.07721014f, -0.05787971f, 0.17830262f, -0.27624002f, -0.08964713f, -0.27311668f, 
    -0.02175409f, 0.16543396f, -0.05497174f, -0.05607785f, -0.04361378f, -0.08996385f, -0.34178245f, -0.11636728f, 
    -0.01479225f, -0.15077358f, 0.17250259f, 0.06947737f, -0.27864364f, -0.11931171f, -0.39658657f, 0.01673880f, 
    0.28670225f, -0.19443049f, -0.02487370f, -0.12887359f, 0.21452619f, -0.03017984f, 0.09040447f, -0.07592979f, 
    0.02091518f, -0.13072868f, -0.09291325f, 0.06296448f, 0.11056501f, 0.02754527f, 0.19658636f, 0.06129638f, 
    0.04555353f, -0.19538236f, 0.42476797f, 0.23089918f, 0.42269990f, 0.01732231f, 0.03192434f, 0.09640466f, 
    0.09528024f, 0.06605139f, -0.59556144f, 0.36443943f, -0.13088062f, -0.04219890f, -0.14422192f, 0.02106302f, 
    0.13381231f, 0.10323820f, 0.06071023f, -0.21051070f, 0.69532663f, -0.01999178f, 0.20887658f, 0.09876496f, 
    -0.17876807f, 0.01859264f, 0.07687145f, -0.01949113f, -0.27067694f, 0.26975289f, -0.02767133f, 0.00562163f, 
    -0.44693357f, -0.02009839f, -0.23845476f, 0.10633168f, 0.26859173f, 0.72523338f, -0.51393270f, 0.14446327f, 
    0.38032910f, 0.03477255f, 0.06068556f, 0.05233927f, -0.05352439f, 0.14384879f, 0.74250525f, 0.16861840f, 
    -0.49046618f, 0.08734667f, -0.04912328f, -0.16624126f, 0.03369619f, -0.11715288f, -0.07207801f, 0.30579951f, 
    0.37731671f, -0.14081573f, 0.05373853f, 0.09756161f, -0.12289500f, 0.03916923f, 0.18931124f, -0.00255691f, 
    0.05735032f, 0.07706815f, -0.05624379f, -0.00405681f, 0.07009476f, -0.04907617f, -0.03727226f, -0.06823276f, 
    -0.06344604f, -0.04818719f, 0.03646971f, -0.06259839f, 0.01863453f, 0.07464395f, 0.06445348f, -0.06767891f, 
    -0.05030689f, 0.00510032f, -0.04920007f, 0.05032859f, -0.07164315f, -0.05954203f, -0.08102518f, -0.08576488f, 
    0.04045499f, -0.07171382f, -0.05141564f, -0.04318744f, -0.04488386f, -0.05811283f, -0.00736910f, -0.01156046f, 
    0.01934592f, -0.00427177f, -0.08494682f, 0.06963959f, 0.05264535f, 0.01306289f, -0.04368867f, -0.05019864f, 
    -0.05542152f, 0.00646482f, 0.05440006f, 0.00519876f, -0.00491658f, -0.04703902f, -0.06465977f, -0.07397870f, 
    -0.00006378f, 0.04756359f, 0.05641067f, 0.04976232f, 0.03642795f, -0.08582800f, -0.00929612f, 0.00477136f, 
    -0.05044291f, 0.03688614f, 0.01866402f, -0.06239262f, 0.01486993f, -0.04744741f, 0.03575044f, 0.06590175f, 
    -0.01031924f, -0.07785887f, -0.04975008f, 0.00733949f, 0.02260105f, 0.00410669f, 0.03521722f, 0.01707572f, 
    -0.04421933f, 0.04694454f, 0.01580243f, 0.06205035f, -0.01420434f, 0.05540704f, -0.06445389f, -0.01601400f, 
    0.04747975f, -0.00659711f, 0.03635454f, 0.00104999f, -0.06262363f, 0.01902374f, -0.05599977f, -0.06141388f, 
    0.00571823f, -0.06312909f, -0.05195923f, -0.05977497f, 0.01153484f, 0.00089517f, -0.07053637f, -0.00222954f, 
    -0.05026218f, -0.02216483f, -0.00730310f, 0.02077686f, -0.04455779f, -0.07625211f, -0.07711773f, -0.01214356f, 
    -0.03506953f, -0.03281810f, 0.02389404f, 0.04681241f, -0.01662203f, 0.05449329f, 0.05885592f, -0.07361958f, 
    -0.01349490f, -0.02491651f, -0.02556202f, 0.01550697f, 0.02379619f, -0.03568255f, -0.06082898f, 0.00413931f, 
    -0.00151059f, -0.05956358f, 0.05935560f, 0.05777663f, -0.07504969f, -0.08880378f, 0.01394163f, -0.05888594f, 
    -0.04169542f, 0.06553129f, 0.05191697f, 0.06599918f, 0.03550979f, 0.04905443f, -0.05364714f, 0.00378194f, 
    0.00223058f, -0.07897219f, -0.04144313f, 0.04279163f, 0.06798672f, 0.07207046f, -0.04298510f, 0.00614263f, 
    -0.08664729f, -0.04738783f, -0.02963992f, -0.00839065f, -0.05531481f, 0.01854203f, -0.04271834f, -0.07164524f, 
    0.05509264f, 0.06596649f, 0.01251340f, 0.02763977f, 0.00945813f, -0.03617260f, 0.03383020f, -0.06235252f, 
    0.03833199f, -0.01439483f, -0.01765885f, -0.03387424f, 0.00935656f, -0.05073914f, 0.00158506f, -0.08553055f, 
    -0.09043212f, 0.04289788f, 0.00359863f, -0.01352679f, -0.08667437f, -0.04729978f, 0.00393324f, -0.09216391f, 
    -0.04882309f, -0.05219012f, -0.00081758f, -0.04526542f, 0.01910582f, -0.09080814f, -0.06374523f, 0.04588430f, 
    -0.08499566f, -0.03852794f, -0.08025660f, -0.06071432f, 0.02019978f, -0.06180558f, 0.04562626f, -0.08653218f, 
    -0.00364147f, 0.04212339f, -0.05264338f, -0.09153882f, 0.05847996f, 0.00541642f, 0.00677058f, 0.03280077f, 
    0.01537766f, 0.00505346f, 0.00720706f, 0.06216800f, 0.00089901f, 0.01932888f, 0.02857203f, -0.02950863f, 
    -0.03641130f, -0.02066829f, -0.01396834f, -0.01878640f, 0.04668615f, -0.05441369f, 0.03524239f, -0.05250531f, 
    -0.04611288f, -0.00886308f, -0.04674462f, -0.03134258f, -0.02505580f, 0.06995293f, 0.04647217f, 0.01438644f, 
    0.07300303f, 0.05430436f, -0.04808541f, 0.00457217f, -0.01932864f, -0.06356443f, -0.00602764f, 0.05630478f, 
    0.03071098f, -0.06435142f, -0.00516683f, -0.05005827f, -0.00248048f, 0.06705688f, -0.08452879f, -0.04879740f, 
    -0.01916191f, -0.05827592f, -0.07815934f, 0.03254545f, 0.05218068f, 0.00144740f, -0.06879265f, 0.00089038f, 
    -0.00669991f, -0.05860009f, -0.04007900f, -0.04138292f, -0.06776113f, -0.00698922f, -0.08868747f, -0.03679977f, 
    -0.08811115f, 0.06135429f, 0.05641227f, -0.06172417f, -0.04345626f, 0.03111230f, 0.01052290f, -0.08407544f, 
    0.05800803f, -0.03810533f, -0.02381468f, 0.00225196f, -0.03825526f, -0.08144128f, 0.04855919f, 0.01884813f, 
    -0.03079394f, -0.08180592f, 0.06059741f, -0.01219275f, 0.02479475f, 0.05847156f, -0.05982905f, 0.02787982f, 
    0.01248050f, -0.09126871f, 0.02621661f, 0.02934624f, 0.01122314f, -0.03938319f, -0.06128890f, -0.05971840f, 
    0.00366962f, 0.39094827f, -0.02896225f, -0.07416951f, -0.17681220f, 0.03494013f, 0.19085921f, 0.18757671f, 
    0.05751110f, 0.48954451f, 0.02535738f, -0.08564032f, -0.47570980f, -0.01351640f, 0.12736505f, 0.03414080f, 
    0.22024721f, 0.15963401f, 0.35622269f, 0.21301883f, -0.06050064f, 0.01006976f, -0.01470512f, 0.15452291f, 
    -0.04168381f, 0.18140663f, -0.14413029f, 0.59281802f, 0.35061321f, -0.10287828f, 0.27273348f, 0.10782415f, 
    0.00906379f, 0.02925949f, 0.17162892f, -0.14374758f, 0.32233325f, -0.53247231f, -0.41324538f, -0.04937207f, 
    -0.06457917f, -0.06224615f, -0.02577472f, 0.08043016f, -0.20808062f, 0.45735234f, 0.15696143f, 0.01946134f, 
    -0.32998800f, -0.04124532f, 0.10350072f, 0.00926184f, 0.13591865f, -0.01326079f, -0.54843444f, -0.20247974f, 
    -0.17044264f, 0.07645784f, -0.07150169f, -0.13719326f, -0.35117325f, -0.21708597f, 0.16557969f, 0.25984746f, 
    -0.04116768f, 0.30216345f, -0.16002689f, -0.06481345f, -0.20361008f, 0.02322522f, -0.14303827f, 0.04053104f, 
    0.85174823f, 0.30701390f, -0.23089787f, 0.11687306f, -0.08102589f, 0.05227023f, -0.19903411f, -0.11718493f, 
    -0.11247956f, 0.05205852f, -0.10226850f, -0.00005005f, 0.05286324f, 0.31655669f, 0.32870477f, -0.02826656f, 
    0.04513875f, 0.12115409f, -0.02373827f, 0.04226602f, 0.21313672f, -0.04109164f, -0.05903269f, -0.03366788f, 
    0.01876345f, -0.18125278f, -0.08675079f, -1.11161387f, -0.12767121f, 0.09610073f, 0.25427634f, 0.57219172f, 
    0.26336554f, -0.10432433f, 0.07153647f, 0.13346057f, 0.74994045f, 0.02231311f, -0.31985974f, 0.02217830f, 
    0.05842867f, 0.01055760f, -0.19525193f, 0.00377954f, -0.00857724f, 0.41617736f, 0.05299990f, 0.03853096f, 
    0.15216483f, 0.19272950f, 0.14260694f, -0.05924100f, 0.08407265f, 0.09721003f, 0.19286394f, -0.79771692f, 
    -0.22125138f, -0.07282348f, -0.03616550f, 0.02594450f, -0.08316559f, -0.03428460f, -0.09972604f, -0.19549707f, 
    0.15580885f, 0.02003715f, -0.36808172f, 0.06493528f, -0.03629356f, 0.06227781f, -0.05020608f, -0.03510883f, 
    -0.29319572f, -0.17488596f, -0.21452117f, 0.04544607f, -0.17517240f, -0.38677719f, 0.24739796f, 0.13290659f, 
    0.26436228f, 0.23020661f, 0.38872847f, 0.20173697f, -0.05183021f, 0.39198458f, -0.20686236f, -0.15854724f, 
    0.06807052f, -0.07428656f, 0.01516086f, 0.01785692f, 0.24761087f, -0.05279676f, 0.03745087f, 0.06907525f, 
    -0.01335352f, -0.19353536f, 0.19320481f, 0.23032418f, -0.03946923f, 0.04077267f, 0.13629428f, -0.08959760f, 
    0.09317045f, 0.03662613f, 0.24574387f, 0.34843284f, -0.87843311f, -0.36274859f, 0.24909118f, -0.12956995f, 
    0.10144436f, 0.02024030f, -0.08522356f, 0.18513826f, -0.08249129f, -0.77861404f, -0.11742437f, 0.01545113f, 
    0.17391767f, 0.04825474f, -0.26779276f, -0.07895964f, 0.03879444f, 0.14451304f, 0.53701520f, -0.37222269f, 
    -0.73191470f, 0.21710101f, 0.22019443f, 0.01250750f, 0.07244951f, -0.04040839f, -0.09403976f, 0.30284411f, 
    -0.45341814f, -0.03933457f, -0.40621877f, 0.18743630f, 0.05840118f, 0.11385249f, -0.19731313f, -0.05787730f, 
    0.03386052f, -0.10933430f, 0.14975393f, 0.35828629f, 0.47415030f, -0.05176221f, -0.07447985f, 0.19540896f, 
    -0.20725903f, 0.26421130f, 0.27745083f, 0.14384425f, -0.39705935f, 0.00241261f, 0.24725640f, 0.21281633f, 
    0.06728561f, 0.12042385f, 0.55117154f, 0.39280176f, 0.29600692f, -0.07559022f, -0.02624638f, 0.01406070f, 
    -0.08660621f, -0.08250437f, -0.11052177f, -0.35630691f, -0.04285291f, -0.12872858f, -0.24238250f, 0.29780915f, 
    0.24676111f, -0.04559475f, 0.09942219f, 0.07843515f, -0.31585586f, -0.15261766f, 0.34079155f, 0.00605458f, 
    0.05533181f, 0.37097239f, 0.01483934f, 0.13090858f, 0.26598996f, 0.35584256f, 0.14845113f, -0.15341918f, 
    -0.67452943f, -0.16484900f, -0.10772860f, -0.01279291f, -0.10734318f, -0.01371698f, -0.35800245f, -0.17618188f, 
    0.40690532f, -0.16566868f, 0.17815883f, -0.07358438f, -0.02111894f, -0.36028540f, -0.23334229f, 0.40826800f, 
    0.15202886f, -0.74043208f, 0.13559583f, -0.07036152f, 0.11652309f, 0.11825036f, -0.14646006f, -0.06682811f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.10535826f, 0.04801115f, -0.07465287f, -0.07227050f, 0.58066368f, -0.05793689f, 0.03684568f, 0.03850822f, 
    -0.02448068f, -0.08317834f, -0.05016404f, 0.01693957f, -0.07690266f, -0.02844607f, -0.07438797f, 0.33176705f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.18140703f, 0.20749973f, 0.22162162f, -0.26035529f, -0.29889131f, 0.16899832f, -0.19267635f, 0.08788137f, 
    0.09301826f, 0.13708772f, 0.00577939f, -0.24631914f, 0.02891030f, 0.13002239f, -0.47698092f, 0.82003015f, 
    -0.16847126f, -0.14693660f, 0.16399145f, -0.13085270f, 0.21274447f, -0.30250376f, 0.32940903f, 0.13989535f, 
    -0.20763661f, -0.18082593f, 0.23057394f, 0.20538639f, 0.21378608f, 0.17842765f, -0.33728477f, 0.49123421f, 
    -0.35574934f, -0.19584623f, -0.14255551f, 0.10564401f, -0.35738859f, -0.39333236f, 0.22405584f, -0.19558594f, 
    -0.18007109f, 0.08769212f, 0.13888551f, -0.61080843f, 0.02222234f, 0.20771445f, 1.10190976f, -0.12828492f, 
    0.67530131f, 0.12072741f, -0.08221403f, -0.17360452f, -0.57537001f, -0.02357524f, -0.58504802f, -0.22729079f, 
    -0.01534185f, 0.14058882f, 0.05603923f, 0.42114201f, 0.16454911f, -0.08830182f, -0.19922483f, -0.48861742f, 
    -0.11809503f, -0.14959304f, -0.09359974f, -0.19656740f, 0.18932095f, 0.42495406f, 0.20301519f, 0.05540410f, 
    0.01123230f, -0.07629730f, -0.00351701f, -0.58571476f, -0.05427630f, 0.00888253f, -0.14991836f, -0.30675724f, 
    -0.26425955f, -0.10895557f, 0.07900655f, -0.10909441f, 0.76880521f, 0.08626048f, -0.32429039f, -0.14258435f, 
    -0.00048078f, 0.19853429f, -0.13993244f, -0.15206493f, -0.23178625f, 0.17954324f, -0.29041407f, 0.12692325f, 
    -0.31357610f, -0.06280290f, -0.26193896f, -0.02458905f, 0.50467086f, 0.05218084f, -1.09023631f, -0.18214789f, 
    0.08928338f, 0.08078200f, -0.01840685f, -0.09818402f, -0.24664800f, 0.18736160f, -0.02380430f, 0.30217248f, 
    0.29438701f, 0.07446900f, 0.24632178f, 0.07277044f, -0.73041612f, 0.60510772f, 0.74726593f, 0.02709742f, 
    -0.16281720f, -0.03851416f, -0.23496152f, -0.50091618f, 0.23213707f, -0.15894385f, -0.44650131f, -0.58052033f, 
    -0.36166891f, 0.20790201f, -0.05577086f, 0.06281207f, -0.17213333f, -0.43460935f, 0.94884574f, -0.14509375f, 
    0.16261569f, 0.09687828f, -0.15386440f, 1.04671216f, -0.00897586f, 0.10886951f, -0.12717263f, -0.36979017f, 
    -0.38135031f, -0.18907015f, 0.18879786f, 0.14268374f, 0.34659392f, 0.40160894f, 0.42731553f, 0.23053385f, 
    0.01010561f, 0.16540340f, 0.12989427f, -0.79329646f, 0.21187031f, -0.01499292f, -0.28388265f, 0.05978736f, 
    0.76207572f, 0.04536524f, -0.03520231f, 0.08663812f, -0.58666641f, -0.45281240f, -0.19109038f, 0.03093888f, 
    0.18659821f, 0.08134713f, -0.04821944f, -0.31797570f, 0.21689709f, 0.19393399f, 0.43926674f, -0.33766657f, 
    -0.13840701f, 0.04279624f, -0.17866716f, 0.20030606f, -0.45930800f, 0.32149479f, -0.78905356f, 0.08984824f, 
    -0.07339180f, 0.14104421f, 0.15199488f, 0.30322105f, -0.16769513f, 0.19970456f, 0.26413235f, -0.09292640f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.35086802f, -0.24378656f, -0.75744331f, 0.36999094f, 1.09081864f, -0.52445143f, 0.24814096f, -1.75768805f, 
    -0.51221538f, 0.36294341f, 0.34144172f, -0.17487501f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
