#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.81192732f, -0.38576093f, -0.29849944f, 0.09633742f, -0.50745410f, 0.63603789f, -0.58060515f, -0.35095081f, 
    0.49307209f, 0.21951121f, 0.44376409f, -0.30177081f, -0.39883319f, 0.22302260f, -0.11684608f, -0.31236982f, 
    -0.11564814f, 0.26000628f, 0.19100794f, -0.04002753f, -0.25529292f, -0.14402239f, 0.02059050f, 0.31953642f, 
    0.21858799f, -1.25309646f, -0.57447368f, 0.29678851f, 0.29785326f, 0.40473795f, 0.32653254f, 0.80066377f, 
    -0.06464329f, 0.57644409f, 0.60281610f, 0.18470594f, 0.11915563f, 0.31904191f, -0.13651219f, -0.43484384f, 
    -0.18419366f, 0.16476394f, -0.35584456f, -0.33613181f, -0.53750092f, -0.00617775f, 0.38198754f, 0.45178577f, 
    0.25939286f, 0.23332760f, -1.26809239f, -0.62884301f, -0.54380780f, 0.41873094f, -0.08917052f, -1.32284880f, 
    -0.96557564f, -0.17905948f, 0.51995659f, 0.27393350f, -0.13333227f, -0.23540235f, 0.22839461f, -0.01563614f, 
    -0.05334949f, 0.39441189f, 0.49096906f, 0.15562180f, 0.33077705f, 0.10522152f, -0.01703252f, -0.16421485f, 
    -0.27776664f, -0.07869729f, 0.25644809f, -1.13628483f, -0.83902651f, -0.10857599f, -0.66739333f, -1.31546521f, 
    1.27916849f, 0.12244278f, 0.32509688f, -0.03735276f, 0.39417294f, 0.10171231f, 0.13948767f, 0.25620219f, 
    0.31327757f, 0.15955639f, -0.00620233f, 0.17360137f, -0.06619418f, -0.21140084f, -0.13897955f, 0.15665293f, 
    -0.00416759f, 0.16201657f, -0.04928720f, -0.00253303f, 1.16810715f, 1.04851210f, 1.12622476f, -0.70047426f, 
    -0.51104164f, -0.62384677f, 0.54297560f, -0.42297268f, -0.09378844f, 0.11662146f, 0.17821565f, -0.15917940f, 
    -0.12624103f, -0.03129211f, -0.10497990f, 0.00604587f, -0.18162726f, 0.00047147f, -0.00334993f, 0.22484927f, 
    -0.25052816f, 0.35714206f, 0.06887987f, -0.38299051f, 0.08577093f, 0.77384973f, 0.15862378f, 0.13566558f, 
    0.69511175f, 0.22994898f, 0.79962373f, 0.58481854f, 0.27837178f, -0.40263420f, -0.25084561f, -0.23210628f, 
    -0.16368209f, -0.17427866f, -0.04451784f, -0.13667130f, 0.04705628f, -0.37330416f, -0.21919163f, -0.08498879f, 
    -0.38187426f, 0.22644952f, -0.09267334f, -0.09939731f, -0.27801937f, -0.15962803f, -0.66238892f, -0.25168118f, 
    0.23022801f, 1.04154027f, 0.66056144f, 0.59849161f, -0.33973870f, -1.29536915f, -0.76394570f, 0.79888409f, 
    -0.62477982f, 0.85005313f, -0.83447140f, -0.39970171f, 0.23205112f, 0.04359544f, 0.29324895f, -0.08823158f, 
    0.42416981f, -0.05895560f, 0.38046587f, -0.13738914f, -0.29551005f, -0.02946968f, -0.35662127f, 1.28834069f, 
    1.07107556f, -0.15711106f, 0.30767158f, -0.31420186f, -0.96157014f, -0.55609739f, -0.27164996f, -0.23457730f, 
    -0.68345076f, -0.18382934f, 0.52127862f, 0.49695033f, -0.09423105f, -0.39810416f, 0.15224569f, 0.29326940f, 
    0.17769238f, 0.03926649f, -0.23621020f, -0.07365070f, 0.02875561f, 0.01969460f, 0.04951846f, -0.11226273f, 
    -1.83160710f, -0.54632068f, -0.72784096f, -1.51606262f, -0.62985033f, 0.80825758f, -0.09380851f, -0.60763431f, 
    0.45694473f, 1.23037517f, -0.26803747f, -0.64069074f, -0.40366799f, -0.40600875f, -0.33977029f, 0.18214074f, 
    0.25196293f, 0.03418835f, 0.17588019f, -0.01535400f, -0.05450528f, 0.02546821f, -0.02651529f, 0.02104724f, 
    -0.02615893f, -1.40439916f, 0.59695029f, 0.64193261f, -0.77336806f, 0.47729039f, -0.45191813f, 0.18550749f, 
    0.41006520f, 0.94848752f, 0.47294530f, -0.35002998f, -0.31659362f, -0.06079019f, -0.23487426f, 0.25168166f, 
    0.37831193f, 0.05503592f, -0.47623387f, -0.01415653f, -0.17637070f, -0.29851705f, 0.07171816f, 0.43130288f, 
    -0.23972200f, -0.43018225f, 0.31711259f, 0.09888458f, -0.43072495f, -0.52933675f, 0.81838393f, 0.00235171f, 
    -0.19468285f, -0.36090541f, -0.44388354f, -0.87600094f, 0.30042830f, 0.13541251f, -0.02229612f, 0.18433560f, 
    -0.12222326f, 0.07227829f, -0.09692808f, -0.05561772f, 0.20689815f, 0.02279405f, 0.41832006f, 0.09911792f, 
    -0.00338850f, 0.32953167f, 0.34915093f, -0.58801186f, -1.09080791f, -1.11254561f, -0.68139148f, -0.56226027f, 
    -0.47235325f, -0.32014775f, -0.57006633f, -0.04958775f, 0.19342519f, 0.24033533f, -0.34102514f, -0.53906626f, 
    -0.58193213f, -0.29838577f, -0.07028608f, -0.07306254f, -0.19131237f, -0.21798566f, -0.57147998f, -0.31123814f, 
    -0.07156456f, -0.10296813f, -0.16717193f, -0.05245231f, 0.22746095f, 1.31744754f, 0.08390917f, -1.63324022f, 
    -1.09707797f, -0.19442402f, 0.23372164f, 0.78862995f, -0.36426461f, 0.02271640f, 0.03776479f, 0.26602477f, 
    -0.24098031f, -0.28842819f, 0.51441002f, -0.10166270f, 0.38953933f, -0.15615320f, -0.11209083f, 0.15860112f, 
    0.01802230f, -0.06103772f, -0.36724168f, -0.42944640f, 0.09753832f, 0.62932873f, -0.22481559f, 0.18779388f, 
    0.52431566f, -0.07889982f, -0.41532522f, -0.01131407f, 0.63190901f, -0.30415988f, 0.12851702f, -0.04790772f, 
    0.02024511f, -0.12231117f, -0.12131637f, 0.09960542f, 0.05632232f, -0.07369050f, -0.43670747f, -0.08662236f, 
    0.02405894f, 0.01341007f, -0.09432115f, 0.03032991f, 0.29177696f, 0.10652679f, -0.83675772f, -1.17324293f, 
    -0.37674370f, 0.49971989f, -0.24514918f, -0.84136307f, -0.82398731f, -0.98168123f, -0.83889878f, -1.34795094f, 
    -0.05264484f, 0.70078778f, -0.29249835f, 0.12436685f, -0.35389602f, -0.37471762f, -0.37489390f, -0.03145997f, 
    -0.08612356f, -0.55130267f, -0.05179074f, 0.05805359f, -0.24900390f, 0.13145703f, 0.32948494f, 0.00435627f, 
    1.37812352f, -0.67192239f, 0.00358831f, -0.61389273f, -0.12912093f, 0.03035569f, -0.15094857f, -0.10769898f, 
    0.49795419f, -0.18764369f, -0.17257690f, 0.02925681f, -0.14042784f, -0.23972125f, 0.04041682f, -0.11782444f, 
    0.04502336f, -0.18210846f, -0.50744647f, -0.72320479f, -0.54136586f, -0.83748227f, -0.75045228f, -1.26896417f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.68815118f, 0.61452407f, 0.38793659f, 0.63976288f, 0.84102386f, 0.22978592f, 0.48375472f, 0.12469719f, 
    -0.26931283f, 0.67627734f, 0.39614329f, -0.04789911f, 0.50459039f, 0.57395488f, 0.07089017f, -0.03241802f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.16612588f, -0.31685260f, -0.23724766f, -0.13826968f, -0.20492318f, -0.03671037f, -0.18519281f, -0.24693342f, 
    -0.23532313f, -0.06663996f, -0.11832584f, -0.22472282f, 0.05161083f, 0.21741977f, 0.00284861f, -0.05181644f, 
    0.04189231f, -0.02442978f, 0.10275715f, 0.01840200f, -0.23330306f, -0.16546029f, -0.24300596f, -0.53110290f, 
    0.52759212f, 0.52237004f, 0.50359952f, -0.60625094f, 0.08354366f, 0.07732487f, 0.04706408f, -0.05493335f, 
    0.11620711f, -0.06792376f, -0.00500881f, 0.05841161f, 0.22088861f, -0.34029499f, -0.05167182f, -0.05343806f, 
    -0.03213977f, 0.18020692f, -0.10489097f, -0.26480240f, 0.06397894f, -0.03731204f, 0.01613495f, 0.03632348f, 
    -0.67531800f, -0.64995146f, -0.35729694f, 0.08932523f, 0.15179355f, 0.05596879f, 0.02084059f, 0.06758407f, 
    -0.12587754f, -0.04417716f, -0.05568711f, 0.02012278f, 0.13206890f, -0.30200183f, 0.08563586f, 0.15373392f, 
    0.06362057f, 0.04736871f, 0.18761484f, 0.00972763f, 0.02238643f, 0.06672354f, 0.08572026f, 0.11532541f, 
    0.49064732f, 0.71186739f, -0.19398475f, -0.09764589f, -0.13886371f, -0.38504952f, -0.02734674f, -0.19989021f, 
    -0.08845607f, -0.12991840f, -0.02708221f, -0.14279915f, 0.04212682f, -0.16338339f, -0.50924253f, -0.07638635f, 
    -0.15462208f, 0.00760181f, -0.08802448f, 0.04517036f, -0.02536940f, 0.08342746f, -0.07406536f, 0.07940608f, 
    0.38072175f, 0.33721846f, 0.11968529f, -0.32977846f, 0.06675798f, 0.41365919f, -0.00764581f, 0.11858686f, 
    0.14240307f, 0.13988104f, 0.06488799f, -0.08628587f, -1.07667565f, -0.40923980f, 0.18947326f, -0.30302602f, 
    -0.13037309f, -0.01297667f, 0.09805696f, 0.08664411f, -0.05843994f, 0.01537286f, -0.06021747f, -0.01942976f, 
    0.13445483f, 0.10791390f, -0.37558344f, 0.04902609f, -0.00593784f, -0.17983881f, -0.26450059f, -0.14080106f, 
    -0.10714408f, 0.00838363f, -0.02167337f, -0.19201438f, 0.35831332f, 0.32287318f, 0.09847096f, -0.28937584f, 
    0.35483274f, 0.32882017f, 0.03382977f, -0.10924147f, -0.10336354f, -0.11137491f, -0.12795088f, 0.02289030f, 
    0.12180816f, -0.21072870f, -0.06412402f, 0.16452649f, -0.01596047f, -0.20006771f, -0.31648839f, -0.12669180f, 
    -0.04634114f, 0.06124017f, 0.13638975f, -0.28255403f, -0.44317639f, -0.09409916f, 0.05377940f, -0.10329730f, 
    0.01679938f, 0.08974451f, 0.06795625f, 0.00168630f, -0.15346229f, -0.06626526f, 0.01536694f, 0.00517273f, 
    0.51340741f, 0.27386650f, -0.24804562f, -0.59191269f, 0.18345992f, -0.20134276f, 0.13474810f, -0.07204183f, 
    -0.03782962f, -0.06542788f, -0.09166411f, -0.13317990f, -0.56326181f, -0.15264498f, -0.05956614f, 0.14326666f, 
    -0.02813332f, -0.02784251f, -0.06249942f, 0.05350932f, -0.22420257f, -0.14869259f, 0.14922427f, 0.35776007f, 
    0.20484199f, 0.31585920f, -0.07745046f, -0.13947286f, 0.03398345f, 0.00719407f, 0.16960111f, 0.08913725f, 
    -0.03828386f, 0.10332091f, 0.06417003f, 0.04982294f, -0.08848158f, -0.02335547f, -0.05179540f, 0.02285688f, 
    -0.07590836f, 0.05170687f, 0.05269893f, 0.16203514f, 0.00975466f, 0.04136328f, -0.07277422f, 0.36786106f, 
    -0.70747674f, 0.27133870f, 0.13444538f, 0.09995275f, 0.00319418f, -0.12723637f, -0.19620924f, -0.38937438f, 
    -0.05484881f, -0.03554082f, -0.10461715f, 0.05288915f, -0.02982179f, -0.30896029f, -0.15365039f, -0.39674014f, 
    0.10197543f, 0.06403919f, 0.04782443f, -0.04505475f, -0.06771982f, -0.02632969f, 0.16869500f, -0.08650469f, 
    0.68271244f, -0.11728867f, 0.13102913f, -0.04679952f, -0.13673908f, -0.10529185f, -0.12408896f, 0.15286450f, 
    0.00509640f, 0.07743803f, -0.06057779f, -0.10255233f, 0.99706328f, 0.23821327f, 0.50343609f, 0.57331753f, 
    -0.07761972f, -0.05046487f, -0.09002918f, -0.10565702f, -0.08993070f, 0.00479023f, 0.08387515f, -0.07549060f, 
    -0.12380291f, 0.13212517f, -0.13446096f, -0.12476165f, -0.11719418f, 0.26837644f, -0.04224658f, 0.33357409f, 
    0.24813201f, -0.03616387f, -0.04954691f, 0.05892332f, -0.03180176f, -0.12972565f, -0.46471968f, -0.41457203f, 
    0.02549863f, -0.32291636f, -0.35808241f, -0.26982141f, -0.08022097f, -0.11563829f, 0.03973150f, 0.30035701f, 
    0.52863240f, 0.52605361f, -0.00640417f, -0.16393611f, -0.12609416f, 0.09927520f, -0.33237979f, -0.16904594f, 
    -0.04667638f, -0.01379705f, -0.19224577f, -0.30982736f, -0.57007760f, 0.15098833f, 0.19530441f, 0.08714110f, 
    0.17521112f, 0.02071999f, -0.21602280f, -0.00492888f, -0.06120727f, 0.10473596f, -0.26339427f, -0.09757960f, 
    0.12002280f, 0.01439385f, -0.15433246f, 0.11637056f, 0.02667853f, -0.02997038f, 0.15145957f, 0.03589563f, 
    -0.18604088f, -0.07148494f, 0.07851199f, 0.07198791f, 0.24164219f, 0.46638736f, 0.12700833f, 0.01810408f, 
    0.12688398f, 0.20432076f, -0.23776123f, -0.02420216f, 0.07583132f, 0.03368689f, -0.22186741f, -0.01388493f, 
    -0.08742423f, -0.43152362f, 0.13172050f, -0.26614660f, 0.09542873f, 0.26738828f, -0.20136897f, -0.01746375f, 
    0.08613834f, 0.12046476f, -0.26021096f, 0.21267132f, 0.22393218f, 0.01313693f, -0.04070913f, 0.02333480f, 
    -0.12013730f, -0.00328388f, 0.07404023f, -0.01444771f, -0.02647154f, -0.02599936f, 0.05244086f, 0.11623561f, 
    -0.37995514f, 0.02809367f, 0.09066142f, 0.14304878f, -0.35500598f, 0.04372287f, 0.03228960f, 0.09743135f, 
    0.06522267f, 0.04853937f, 0.01006833f, 0.08654175f, -0.07273883f, 0.01782609f, 0.13474910f, -0.15534225f, 
    0.06071810f, 0.00236070f, -0.18066452f, -0.02102107f, -0.48076382f, -0.31145293f, -0.46443185f, -0.25940731f, 
    -0.58311182f, 0.54287434f, 0.11170395f, -0.43834448f, 0.08198423f, -0.01391061f, 0.10623752f, 0.00482098f, 
    -0.12757488f, 0.00841801f, 0.01967219f, 0.13191034f, 0.04058654f, -0.58854634f, -0.25133666f, 0.02598738f, 
    0.05042840f, -0.03320049f, -0.01595049f, 0.05262804f, 0.06932355f, -0.40736818f, -0.25630346f, 0.11554650f, 
    -0.18771759f, -0.27526844f, -0.71688122f, 0.07286307f, 0.02086035f, 0.28752151f, -0.00737711f, 0.03875377f, 
    -0.07507715f, 0.00895540f, 0.07898686f, 0.05826965f, 0.59381044f, 0.29483792f, 0.53645843f, 0.29736006f, 
    -0.12502325f, 0.06281617f, 0.10641067f, -0.12161177f, 0.22160815f, -0.04888298f, 0.04711061f, 0.12012140f, 
    -0.36436525f, -0.08839017f, 0.59996063f, -0.41492575f, 0.09274300f, -0.04020818f, -0.20091894f, 0.17220989f, 
    0.07948279f, -0.03324156f, -0.02446569f, 0.08651647f, 0.02687839f, 0.12698691f, -0.48962396f, -0.19774118f, 
    0.05474276f, -0.14636743f, -0.01065906f, 0.12458821f, 0.00302028f, -0.01554499f, 0.12263961f, -0.03143248f, 
    0.00791416f, -0.25407577f, -0.13997729f, -0.07833800f, 0.17844829f, 0.03831812f, -0.21931770f, 0.24507229f, 
    0.07532597f, -0.06696296f, -0.06799206f, 0.03807091f, -0.89845133f, -0.41986975f, 0.52369535f, -0.35049313f, 
    -0.28263712f, -0.00969335f, -0.53711271f, -0.39635408f, 0.07583714f, -0.03620444f, 0.05955842f, 0.06652606f, 
    -0.14919829f, 0.42502713f, 0.72552401f, 0.91992033f, -0.17622979f, -0.13672820f, -0.12899607f, 0.24243391f, 
    0.07069910f, 0.00757385f, -0.08759064f, 0.03524428f, 0.24178326f, -0.16278996f, -0.06646200f, 0.12324888f, 
    0.00366062f, 0.01060618f, 0.10506744f, -0.05707584f, -0.14220181f, 0.28085291f, -0.05908601f, 0.09104381f, 
    -0.20393279f, -0.01022686f, -0.06499118f, -0.11063249f, 0.08552144f, -0.00446724f, 0.19573079f, 0.34680840f, 
    0.09403335f, -0.08607904f, -0.07610486f, -0.03985694f, -0.59344131f, 0.23150095f, 0.13260792f, -0.03579597f, 
    -0.16128698f, -0.22744611f, 0.08812442f, -0.03822931f, -0.03546204f, -0.00561315f, -0.03053955f, 0.01993385f, 
    0.11387234f, 0.04646866f, 0.10600958f, -0.18525755f, -0.02950918f, 0.11331289f, -0.25744650f, -0.39512822f, 
    0.26887795f, 0.14886045f, -0.35048726f, 0.09758804f, -0.20808995f, -0.07239133f, -0.28093740f, 0.25943494f, 
    0.02415882f, -0.00550000f, 0.04766418f, -0.04141225f, -0.04818136f, -0.03085214f, -0.10559510f, 0.06398816f, 
    -0.77303863f, -0.44386372f, -0.96422452f, -0.43159971f, 0.15646152f, -0.00376018f, -0.05345150f, 0.07538949f, 
    -0.11059117f, -0.06226038f, -0.01663613f, -0.10508156f, 0.16010183f, 0.00198983f, 0.07490097f, -0.12494113f, 
    0.04157432f, -0.03581188f, -0.05508251f, -0.14869595f, 0.12166892f, 0.29643166f, 0.31692198f, 0.25509453f, 
    -1.35699034f, -0.34964406f, -0.05541999f, -0.07194138f, -0.26376459f, -0.01183698f, -0.15978275f, -0.44114685f, 
    -0.06184924f, -0.17113711f, -0.07710671f, -0.07059135f, -0.08045880f, 0.15491056f, 0.01682551f, -0.37314883f, 
    0.16795112f, 0.33000034f, -0.29987249f, 0.08698609f, -0.07284817f, 0.03189633f, 0.02096883f, 0.04430568f, 
    0.09882806f, -0.04086683f, -0.16455448f, -0.13966042f, 0.00036086f, -0.11854597f, -0.05982639f, -0.14821997f, 
    0.01928159f, -0.01574985f, -0.12401113f, -0.00005574f, -0.13333404f, -0.35022098f, 0.20298938f, 0.28640231f, 
    0.21637407f, 0.11549140f, -0.00636677f, 0.13715661f, -0.35328138f, 0.16396195f, -0.16563569f, 0.02826169f, 
    -0.74758285f, -0.18364286f, 0.14610280f, -0.01407019f, -0.17433742f, -0.34179780f, -0.36989534f, -0.22455274f, 
    -0.03402170f, -0.04828134f, 0.25298199f, -0.11043584f, -0.40323865f, 0.09154020f, -0.37006208f, 0.05267661f, 
    0.09186494f, 0.10763060f, -0.27100009f, 0.19077317f, 0.00713339f, 0.13468288f, 0.20795977f, 0.12740737f, 
    -0.13193254f, 0.56241411f, -0.51375395f, -0.08564703f, -0.26616073f, -0.23162358f, 0.18673873f, -0.27207854f, 
    -0.30260929f, 0.06882858f, -0.24117064f, 0.38305813f, -0.03348210f, -0.06944270f, 0.58757067f, 0.42232382f, 
    -0.11935043f, 0.15141515f, 0.15758666f, 0.04208684f, -0.05860260f, 0.33552551f, -0.17237225f, 0.06556337f, 
    0.57676399f, -0.41960719f, -0.17181285f, 0.21717530f, 0.30323240f, 0.02565630f, 0.15803127f, -0.19729352f, 
    0.08992795f, -0.04974348f, 0.15152451f, 0.23046695f, 1.61840677f, 0.06899676f, -0.20043495f, -0.34093416f, 
    -0.06359285f, 0.05769647f, -0.20044847f, -0.01629520f, -0.26568976f, -0.13828856f, 0.00944186f, 0.08062137f, 
    -0.01079825f, -0.04426493f, 0.36709544f, 0.53563595f, 0.02759317f, 0.03030794f, 0.02512157f, -0.17171657f, 
    -0.01680724f, -0.25051469f, 0.08195674f, -0.37369072f, -0.17422879f, -0.15133482f, -0.01531052f, 0.37760058f, 
    0.03786418f, -0.13569252f, -0.00084881f, -0.07017217f, 0.05589639f, 0.21988377f, -0.03762121f, 0.02853088f, 
    0.50598669f, 0.01116747f, 0.03978448f, 0.61252803f, 0.06152434f, -0.03220990f, -0.01094430f, -0.01477253f, 
    -0.06247500f, -0.17471239f, -0.00801427f, 0.23128213f, -0.64798397f, -0.02301845f, -0.20481141f, -0.04214618f, 
    -0.11082982f, -0.48514092f, -0.24536355f, -0.12768590f, -0.04041110f, 0.14852242f, -0.24022016f, 0.03143390f, 
    -0.12745808f, -0.02482478f, -0.31551108f, 0.26378408f, 0.12086420f, 0.01335183f, 0.24270082f, 0.25765744f, 
    -0.16211137f, 0.05599234f, 0.05178095f, -0.11440824f, 0.00089387f, -0.16328466f, -0.04784510f, 0.00612743f, 
    0.02440262f, 0.16904226f, -0.21702048f, -0.09813935f, 0.18182354f, 0.03248870f, -0.04906910f, -0.00458130f, 
    -0.06792235f, -0.17951636f, -0.22585018f, 0.03863127f, 0.12851115f, -0.09574449f, -0.19133951f, 0.19765137f, 
    0.03842717f, -0.20152293f, -0.38808066f, -0.24888177f, 0.41212592f, 0.24517220f, 0.08555473f, 0.19815671f, 
    0.07566284f, 0.01678971f, -0.03168735f, -0.13483456f, 0.05726106f, -0.27827671f, -0.24666971f, -0.41131368f, 
    0.09480943f, -0.14681737f, -0.00057503f, 0.23338708f, -0.48486081f, 0.02074520f, -0.12146737f, -0.19056848f, 
    0.02032407f, 0.06449204f, -0.02808278f, -0.09340613f, 0.23418446f, 0.25288609f, 0.18729913f, 0.18254238f, 
    -0.10769700f, -0.41340581f, 0.10898903f, -0.20348921f, -0.06507774f, 0.08427741f, 0.06466920f, 0.09152820f, 
    0.14465903f, 0.12573899f, -0.40268424f, 0.16369742f, 0.14410770f, 0.03324665f, 0.08020514f, -0.00856966f, 
    0.19261193f, -0.01354719f, -0.00489420f, -0.03193741f, -0.32208672f, -0.89568663f, -0.64861280f, -0.22032940f, 
    0.09404898f, 0.01681768f, 0.05389636f, 0.03188201f, 0.07806312f, 0.03049719f, -0.03015084f, 0.08940520f, 
    0.00640526f, -0.71508527f, 0.19469683f, 0.50880611f, -0.19486819f, -0.19035973f, 0.06175592f, -0.26371780f, 
    -0.23194222f, -0.06802543f, -0.04449882f, 0.02880140f, 0.14248036f, 0.18535268f, 0.29937333f, 0.12202466f, 
    0.01454447f, 0.35314339f, 0.16228905f, 0.28225231f, 0.09494358f, -0.03670379f, 0.02516266f, -0.25172415f, 
    -0.32548207f, 0.03022900f, 0.00499214f, 0.30240071f, -0.16745171f, -0.06753473f, -0.05328849f, -0.09299153f, 
    -0.01823702f, -0.09360740f, 0.08245918f, 0.04296275f, -0.85777020f, -0.73592424f, -0.18858053f, -0.40358412f, 
    0.02362924f, -0.15323943f, 0.20573922f, -0.05590155f, 0.00312656f, -0.25362018f, 0.21618320f, 0.07411904f, 
    0.17734858f, 0.06335659f, -0.00148572f, 0.07340030f, 0.10299225f, -0.10397552f, 0.03494420f, 0.19970818f, 
    0.04165052f, -0.02355378f, -0.14955369f, -0.14404629f, -0.05131398f, -0.00523718f, -0.03743009f, 0.10796571f, 
    -0.01537884f, 0.09417422f, -0.10643096f, -0.09446614f, -0.00680839f, -0.01435485f, 0.14127977f, 0.16783991f, 
    -0.02334310f, 0.08919606f, -0.20367076f, 0.12228971f, 0.05086055f, -0.14379308f, -0.27486914f, -0.56099701f, 
    -0.07514716f, -0.20366184f, 0.13053514f, -0.30912337f, -0.02573788f, -0.27326280f, 0.22952519f, -0.08035523f, 
    0.10682306f, 0.07985590f, -0.00909879f, 0.16056657f, -0.09280113f, -0.06183515f, -0.19539614f, -0.09253202f, 
    0.30499664f, 0.03059332f, 0.47188029f, 0.25000641f, 0.01348044f, 0.14588927f, -0.04409432f, 0.03940004f, 
    -0.10255563f, 0.10217458f, -0.03167463f, -0.08175682f, 0.12171910f, -0.00656683f, -0.09331789f, 0.16030772f, 
    0.04999280f, -0.15384328f, 0.12095372f, -0.11991856f, 0.19252385f, 0.14570549f, 0.18781763f, 0.50542086f, 
    0.42984992f, -0.31733561f, -0.08737168f, 0.15811923f, 0.04132301f, 0.04062090f, -0.23145431f, -0.10093047f, 
    0.31072548f, 0.00607996f, 0.13549946f, 0.25088853f, -0.27401409f, -0.19960012f, 0.22213279f, 0.27357137f, 
    -0.13668688f, -0.24559861f, -0.13524118f, -0.14736621f, 0.18753092f, -0.02409016f, 0.22807626f, 0.19632375f, 
    0.23320876f, -0.27558932f, 0.35864606f, 0.19270894f, 0.28249076f, 0.07546724f, 0.00178613f, 0.41519415f, 
    -0.09428436f, -0.07493725f, 0.01512888f, 0.12597871f, -0.51489425f, -0.16482174f, -0.69035584f, -0.47844252f, 
    0.12396991f, 0.12476365f, -0.15066309f, 0.17291722f, 0.11824652f, -0.04616719f, -0.06468434f, -0.19315796f, 
    -0.37554830f, -0.00592715f, -0.53641993f, 0.34527534f, 0.16911240f, 0.00000106f, 0.15932666f, -0.06285264f, 
    0.08777680f, -0.04124843f, -0.15479377f, 0.09127650f, -0.64294600f, -0.02808143f, -0.15959692f, 0.16991942f, 
    -0.02967999f, -0.03411759f, 0.08330008f, 0.09394714f, 0.05933816f, -0.12228528f, -0.11728273f, -0.04246158f, 
    -0.17800596f, -0.25451601f, 0.66060424f, -0.22655560f, 0.19346716f, -0.15227444f, -0.08888807f, 0.25696683f, 
    0.17329900f, 0.01064749f, 0.17488843f, -0.12363826f, 0.47891805f, 0.05830668f, -0.36484274f, 0.18496861f, 
    0.15897793f, -0.01398651f, 0.07151084f, 0.04983516f, 0.01902696f, -0.03869306f, 0.04383648f, -0.23597559f, 
    -0.76180238f, -0.10266193f, 0.01706040f, -0.34278747f, 0.03766955f, -0.16920312f, 0.08819213f, -0.05197171f, 
    -0.03460107f, -0.15113524f, 0.03455690f, 0.06888606f, -0.72290540f, -0.25140005f, 0.03021535f, 0.26702255f, 
    0.00424719f, -0.09511069f, 0.01625397f, -0.00453440f, 0.18025048f, 0.05642690f, -0.31692427f, -0.17939064f, 
    -0.03028068f, -0.08841679f, -0.13102481f, -0.42514187f, -0.03305591f, 0.14979832f, 0.05972503f, 0.05354238f, 
    0.16179304f, 0.08427249f, -0.10544836f, 0.12932673f, 0.07945481f, 0.07127593f, 0.23864068f, -0.05639882f, 
    -0.10931162f, -0.04651357f, 0.08979258f, 0.13833098f, 0.09458084f, -0.19642384f, -0.02390727f, -0.02638194f, 
    -0.23530670f, 0.32706988f, -0.46582603f, 0.00235616f, -0.04318884f, -0.31695262f, -0.08507582f, 0.30100808f, 
    0.07883431f, -0.06960099f, 0.13377598f, 0.09483640f, -0.12186803f, 0.04404612f, 0.11208460f, 0.20525911f, 
    0.22118229f, -0.17686045f, -0.13448527f, 0.06142874f, 0.04553568f, 0.11670379f, 0.07320040f, 0.04303319f, 
    0.25055218f, 0.29547361f, 0.38717476f, -0.07496173f, 0.30029941f, 0.34789836f, 0.23369434f, -0.32626605f, 
    0.11473140f, 0.02737089f, -0.03318155f, 0.18884397f, 0.16467780f, -0.11328845f, -0.16388285f, -0.12094243f, 
    0.03289506f, 0.12820303f, 0.05372106f, 0.06768682f, -0.20324580f, -0.54311699f, -0.27638847f, -0.99338984f, 
    0.17608462f, 0.23297636f, -0.16140825f, 0.12573265f, 0.26758879f, -0.19745524f, 0.30685931f, 0.20397334f, 
    0.15497822f, -0.23200275f, -0.11981507f, -0.17278361f, -0.28266585f, -0.18381432f, 0.40388945f, -0.14421251f, 
    0.05078530f, -0.07242012f, -0.10363375f, 0.10620887f, 0.03146451f, 0.28373250f, 0.14749511f, -0.30864871f, 
    -0.96384424f, -0.81624037f, -0.67723233f, -0.15321605f, -0.26247236f, -0.17459281f, 0.29444090f, 0.15660077f, 
    -0.01478819f, 0.12032852f, -0.10242883f, 0.12589233f, -0.39395738f, 0.60378915f, 0.80896270f, -0.09544771f, 
    -0.08540745f, -0.16201150f, -0.13218944f, -0.33570015f, -0.16290849f, 0.03959244f, -0.04600997f, 0.00471694f, 
    0.35734957f, -0.17356226f, -0.15978882f, -0.10007589f, -0.02496552f, 0.12487306f, 0.17598608f, -0.17806017f, 
    -0.10121599f, -0.06254159f, 0.03610941f, -0.00345689f, -0.42494208f, 0.01572869f, 0.10667809f, -0.04505637f, 
    0.10971365f, 0.06488437f, 0.02307768f, -0.09868089f, -0.00285308f, 0.02163136f, -0.06924886f, -0.18348826f, 
    0.07048339f, -0.64498240f, -0.46864876f, 0.61833030f, 0.18945406f, 0.35241738f, 0.13712560f, 0.05659337f, 
    0.19325987f, -0.00933135f, 0.11530609f, 0.01481704f, 0.26229319f, -0.47866791f, -0.72988492f, -0.75917971f, 
    -0.13109261f, 0.30613858f, 0.51785290f, -0.24919468f, 0.00976897f, 0.10427618f, -0.18785399f, -0.04437715f, 
    -0.96504867f, -0.79935747f, 0.50561923f, 0.57293707f, -0.18297951f, 0.00710817f, 0.03194597f, 0.11496553f, 
    -0.09392384f, 0.02933497f, 0.09812632f, 0.07731499f, 0.24831593f, -0.11106160f, -0.03125817f, 0.13801767f, 
    -0.02487768f, 0.04821949f, -0.00756832f, 0.19661495f, 0.04190448f, 0.09981932f, 0.31629965f, 0.04903063f, 
    -0.16176991f, -0.24556312f, 0.10209249f, -0.02307323f, 0.05294314f, -0.36415732f, -0.29643038f, -0.50511134f, 
    0.04752644f, 0.00198764f, -0.07577381f, -0.09293989f, -0.82163966f, -0.72292835f, -0.22205649f, 0.11621729f, 
    -0.35162333f, 0.14835383f, -0.08515979f, -0.07023725f, -0.04893564f, 0.12984875f, 0.18444191f, -0.11426918f, 
    0.59405643f, -0.10812416f, -0.08687203f, 0.10852813f, -0.11209235f, 0.00864322f, 0.32846475f, -0.06244710f, 
    0.34565055f, -0.01804325f, 0.21676148f, -0.13060841f, 0.13009603f, 0.01411003f, -0.17378779f, -0.25611669f, 
    0.09353093f, 0.03343436f, 0.05353027f, -0.04522019f, 0.03311520f, -0.10347480f, 0.04994796f, -0.25213408f, 
    -1.37435448f, -1.65283883f, -0.81736946f, -0.18195444f, -0.24078786f, -0.37780517f, -0.40216315f, -0.68876290f, 
    -0.14565818f, -0.05557615f, -0.11810762f, -0.13345572f, 0.15860359f, -0.11882506f, -0.05708952f, -0.02912023f, 
    -0.10572151f, 0.02905334f, 0.19845115f, 0.20825075f, 0.29644266f, 0.67543364f, 0.15049753f, 0.13515326f, 
    0.16863416f, -0.22221419f, 0.40809608f, -0.39778030f, -0.26037943f, 0.30117381f, -0.06909502f, -0.20419228f, 
    -0.15908669f, 0.05790295f, 0.06318956f, -0.01396479f, 0.45281851f, 0.15921631f, -0.15021111f, -0.42320919f, 
    0.02483138f, 0.08111884f, 0.06300750f, -0.04327029f, -0.07285246f, 0.03444073f, -0.07824229f, -0.33518058f, 
    0.59270626f, -1.17517817f, -0.24379766f, 0.43938705f, -0.01867902f, 0.13493915f, -0.09558419f, 0.11924437f, 
    0.04847606f, -0.00342278f, -0.10021299f, -0.00971156f, 0.60588837f, -1.02687252f, -0.58470523f, -0.35161713f, 
    -0.14906943f, 0.01638677f, -0.21078379f, 0.24548274f, 0.17338558f, 0.16968504f, 0.11197362f, 0.03840297f, 
    -0.12771121f, 0.25561982f, -0.03955393f, -0.01137869f, -0.05531830f, 0.12834701f, -0.08190560f, -0.10351197f, 
    0.01715221f, -0.03676562f, 0.10421694f, -0.05509000f, 0.30277723f, 0.07592003f, -0.02928417f, -0.08417047f, 
    0.06303836f, 0.00832151f, -0.01188478f, -0.09883621f, 0.05202816f, -0.03813252f, -0.05794642f, -0.07755364f, 
    0.45485908f, -0.64214420f, 0.22225802f, -0.74618095f, 0.32778853f, -0.22607225f, -0.09673362f, -0.01677326f, 
    -0.07575829f, 0.04044094f, -0.00592967f, -0.00517122f, -0.87928718f, 0.11377548f, -0.05648313f, 0.09649293f, 
    -0.00251222f, -0.38854504f, 0.02670819f, 0.42467293f, 0.10236493f, -0.03795733f, 0.09938582f, 0.03583322f, 
    0.58955860f, -1.18750906f, -0.91998374f, -1.03940594f, -0.19282970f, 0.16321978f, -0.05230392f, 0.33253747f, 
    0.15681422f, -0.13813965f, -0.04081430f, -0.06255645f, 0.48929483f, 0.07037912f, -0.07981309f, -0.01265897f, 
    -0.04749143f, 0.03458781f, -0.03493947f, -0.18714628f, -0.14359996f, -0.32896748f, -0.26559412f, -0.02684291f, 
    -0.11719318f, 0.25347707f, 0.19102377f, 0.08084476f, -0.27930787f, -0.25579375f, 0.01872791f, -0.02469289f, 
    -0.06961364f, -0.00697213f, -0.02210311f, 0.01497943f, -0.25221995f, -0.72153616f, -0.84088635f, -0.07574314f, 
    -0.16075951f, -0.13533165f, 0.13685149f, -0.04756894f, 0.07609058f, -0.10307190f, -0.26978317f, -0.08593418f, 
    -0.10237477f, 0.37497965f, -0.19145277f, 0.26532355f, 0.06486506f, 0.01075661f, 0.45726073f, -0.03922863f, 
    -0.28726062f, 0.10249480f, -0.08736615f, -0.10302306f, 0.04393731f, 0.08390884f, -0.16107184f, -0.03426161f, 
    -0.04410841f, 0.07837031f, -0.07916445f, -0.14144745f, -0.03612773f, 0.05032708f, -0.08107861f, -0.10015314f, 
    -1.28779709f, -0.62830520f, 0.73144889f, 0.71469772f, 0.03633968f, -0.16993836f, 0.15931943f, 0.22623464f, 
    -0.02768787f, -0.09685984f, -0.01987513f, -0.01243750f, 0.01630593f, -0.07495818f, -0.03341843f, 0.03441528f, 
    -0.08374985f, 0.01798085f, -0.05937596f, -0.03827442f, 0.06388816f, 0.05906094f, 0.05769876f, 0.16729505f, 
    -0.03872159f, 0.18667711f, 0.11342788f, 0.00334985f, 0.17564407f, -0.06134988f, 0.11650414f, -0.01956752f, 
    0.11096794f, 0.11089099f, 0.15940297f, 0.20120196f, -0.12563106f, -0.16964798f, -0.39061967f, -0.08884697f, 
    -0.25432289f, -0.01959112f, -0.13041748f, -0.11077956f, 0.18355457f, 0.22428489f, 0.20660920f, 0.28896227f, 
    0.31095493f, 0.14219725f, -0.43618563f, 0.03345854f, 0.43970087f, 0.01985666f, 0.30135390f, 0.19048411f, 
    -0.04216928f, 0.00420632f, 0.06599550f, -0.03802237f, -0.54363877f, -1.14813578f, -0.47553396f, 0.36370373f, 
    0.07849240f, 0.27257413f, 0.40490860f, 0.26594055f, 0.05655960f, -0.02656645f, -0.23642568f, -0.17159840f, 
    -0.74899739f, 0.56457049f, 0.28824732f, 0.13250077f, 0.00203637f, -0.09454768f, -0.21469826f, -0.03811030f, 
    -0.21161808f, -0.05684896f, 0.11006288f, 0.12275255f, -0.71895182f, 0.03525045f, 0.23485082f, -0.27190638f, 
    -0.24264039f, -0.18142180f, -0.12208126f, -0.16334264f, -0.21291605f, -0.27197945f, -0.10366362f, -0.12261868f, 
    0.47691599f, 0.48890868f, 0.40722260f, -0.31175390f, 0.23615390f, 0.24487832f, 0.06849067f, -0.43107539f, 
    -0.21860650f, 0.10595518f, -0.09935142f, -0.02120173f, -0.66865700f, 0.32250392f, -0.07035954f, 0.29041022f, 
    0.04518834f, -0.05547296f, -0.34704173f, -0.01274815f, 0.00416362f, 0.19222380f, -0.04678202f, 0.16338281f, 
    -0.12857252f, -0.56526077f, -1.34458506f, 0.29984149f, 0.14082754f, 0.19259907f, 0.22870716f, -0.06143538f, 
    -0.03400507f, 0.08698190f, -0.24741739f, -0.20548224f, 0.34048876f, 0.22397690f, -0.23924024f, -0.40649214f, 
    0.02025743f, -0.06331266f, -0.00689670f, -0.05314814f, 0.05715747f, 0.17645864f, 0.04758079f, 0.06639693f, 
    -0.03803154f, -0.00951677f, -0.04400803f, -0.01633357f, -0.11938744f, -0.50257999f, 0.07757903f, -0.19968578f, 
    0.02189731f, 0.22632712f, 0.32698813f, 0.29958445f, 0.22114994f, -0.65406018f, -0.88103187f, -0.47782883f, 
    0.04165105f, -0.18393973f, 0.07034964f, 0.19015576f, 0.00925375f, 0.03728888f, -0.10554299f, -0.03909506f, 
    -0.58896697f, -0.26882866f, 0.26798683f, 0.30751684f, -0.21495667f, 0.24654394f, -0.12090363f, 0.37747753f, 
    -0.28131402f, -0.12113923f, 0.11802680f, -0.20159116f, 0.06725962f, 0.28061911f, 0.08182168f, -0.09027153f, 
    -0.02022771f, -0.06324646f, -0.03507572f, -0.16123779f, 0.17288698f, 0.07398582f, 0.19954295f, 0.19737653f, 
    0.32314372f, -0.49835113f, -0.95663041f, -0.30832022f, -0.33451080f, -0.21370883f, 0.24436489f, 0.02881557f, 
    0.04003574f, 0.20972691f, 0.06611642f, 0.16711140f, -0.33707699f, -0.20093776f, 0.02822846f, 0.12758109f, 
    0.02583092f, 0.09354864f, -0.06199376f, -0.09042288f, -0.35568303f, 0.05083678f, -0.30947712f, -0.72794211f, 
    0.37611395f, -0.66527480f, 0.01226769f, -0.29324052f, -0.28111646f, 0.12104718f, -0.06729850f, -0.10146145f, 
    -0.22575200f, 0.28254098f, -0.10243294f, -0.04913330f, -0.04429169f, 0.24017054f, 0.31527856f, 0.80521166f, 
    0.17035268f, 0.08297439f, -0.34505644f, -0.08776314f, -0.28053749f, -0.07136142f, -0.18713649f, -0.03707487f, 
    -0.74282682f, 0.20323581f, 0.17493410f, 0.15446885f, -0.08753916f, -0.23849446f, -0.07485824f, -0.17690670f, 
    0.16125977f, 0.00275225f, -0.02566522f, -0.02019040f, 0.21234186f, 0.67448664f, -0.32401115f, -0.05432749f, 
    -0.27546754f, -0.15925734f, -0.45061415f, -0.10434528f, 0.22235793f, 0.02107435f, 0.22595511f, 0.04527404f, 
    -0.11681756f, -0.09566921f, -0.78722316f, -0.18900159f, 0.01190783f, 0.22868170f, 0.34489924f, -0.04311325f, 
    0.09411618f, 0.13443117f, 0.08845238f, 0.07784595f, -0.26590723f, -0.33043289f, 0.31619626f, -0.19044921f, 
    -0.01981438f, 0.06204528f, 0.03513041f, 0.15581316f, -0.03452333f, 0.17323214f, -0.04791804f, 0.08618033f, 
    0.24230535f, -1.44113886f, 0.15243122f, -0.36585438f, -0.18148522f, 0.17485946f, -0.24565676f, -0.14640126f, 
    0.03606723f, 0.02013209f, 0.11558732f, -0.15416053f, -0.23311640f, 0.43604904f, -0.82854611f, 0.22416319f, 
    0.32991347f, -0.04343597f, 0.17306520f, 0.07909658f, 0.03972616f, -0.10163668f, -0.13586821f, -0.11179793f, 
    0.06081166f, -0.42222631f, 0.38850948f, -0.39176223f, -0.41869807f, 0.06724117f, 0.04835778f, -0.16545729f, 
    0.10588343f, -0.11228411f, 0.04616643f, 0.10366326f, -0.70578086f, 0.78153676f, 0.02883120f, 0.44430032f, 
    -0.03045039f, 0.06329805f, -0.21072792f, -0.19386913f, 0.20420273f, -0.15788919f, 0.22365034f, -0.02397780f, 
    -0.00375227f, -0.17576276f, -0.04594291f, -0.19722752f, 0.19826677f, -0.19979683f, 0.02523923f, 0.10783784f, 
    -0.05816971f, -0.10276863f, -0.08380873f, -0.17709042f, 0.25036898f, 0.26815009f, 0.79071391f, 0.10316272f, 
    0.18548356f, -0.23225303f, -0.02906840f, 0.09596420f, 0.01485654f, 0.12901029f, 0.00164688f, -0.04790415f, 
    -0.49687240f, 0.86495936f, -0.18134911f, -0.54806364f, -0.06569663f, -0.15990272f, 0.26209119f, 0.11864751f, 
    -0.08981542f, -0.01917019f, 0.17216949f, -0.02877981f, -0.38489747f, -0.27102503f, -0.40961707f, 0.15488344f, 
    0.12356829f, 0.24471927f, -0.02844854f, 0.00795404f, -0.05364141f, -0.11417188f, -0.09383363f, -0.26015311f, 
    -0.80145729f, -0.47903129f, -0.34241888f, -0.22724418f, -0.20987491f, -0.09829506f, -0.09422016f, 0.14785537f, 
    -0.10223396f, 0.00127453f, -0.02673246f, -0.12314469f, -0.08110944f, 0.04570354f, 0.17178798f, -0.03751171f, 
    0.02551388f, -0.00399743f, 0.10338109f, 0.05671429f, 0.10826763f, 0.22110069f, 0.38780320f, 0.32435438f, 
    -0.19854836f, 0.48636198f, -0.48645604f, 0.45668703f, 0.17118672f, 0.28880468f, -0.09321505f, -0.07608143f, 
    0.07564761f, 0.25188607f, -0.19158567f, 0.04500328f, -0.14347431f, 0.45851439f, 0.40747985f, -0.42064163f, 
    -0.03558507f, -0.26642549f, -0.00621870f, -0.26751441f, -0.02518381f, 0.09832749f, 0.19993109f, 0.19655801f, 
    -0.50884908f, 0.11914786f, 0.06373297f, 0.08415942f, -0.01860764f, 0.20214984f, -0.03232925f, 0.14177147f, 
    -0.25238064f, 0.02905477f, -0.28241831f, -0.31133154f, 0.48077503f, 0.14132872f, 0.27888396f, 0.65711439f, 
    0.20758756f, -0.04731885f, -0.16749588f, 0.23330045f, -0.34368944f, 0.25923529f, -0.01388438f, -0.10347976f, 
    0.24893571f, -0.28208295f, 0.50072724f, -0.17658743f, -0.30038187f, -0.49875066f, 0.03306758f, 0.16123174f, 
    -0.10626921f, 0.14839992f, -0.30381054f, -0.07868692f, -0.14989550f, -0.53369844f, -0.38173306f, -0.22589989f, 
    -0.20812300f, 0.02818882f, -0.24259208f, -0.25034261f, 0.32857046f, -0.14570843f, -0.41180021f, -0.06481063f, 
    -0.85624951f, 0.11281882f, 0.16846186f, 0.28195220f, -0.19486487f, 0.21056895f, -0.22236383f, -0.05728937f, 
    0.11386492f, -0.06939447f, 0.25840801f, -0.29450604f, -0.75207382f, -0.22544903f, -0.16363645f, 0.15268075f, 
    -0.01773794f, 0.03482813f, -0.05871664f, 0.16964246f, -0.16415162f, -0.15227343f, -0.10652193f, -0.07332096f, 
    -0.16429612f, -0.06298836f, -0.32191950f, -0.13049453f, 0.14764979f, -0.31803903f, 0.12164257f, -0.11292944f, 
    -0.23107992f, 0.18054530f, 0.02766858f, -0.49541691f, 0.58776844f, -0.04417899f, 0.29342866f, -0.27905479f, 
    -0.32527134f, -0.09938329f, 0.24584575f, 0.12841825f, -0.04112249f, -0.00498633f, -0.40114459f, -0.08566575f, 
    -0.03717184f, -0.44913059f, -0.03208788f, 0.19563092f, -0.26012161f, 0.35118216f, -0.06983207f, -0.07469936f, 
    0.26036060f, 0.25040367f, 0.33221376f, 0.26812676f, -0.32847601f, -0.25995034f, -0.70142370f, 0.11548944f, 
    -0.07843935f, -0.17289172f, 0.01855566f, 0.12767032f, -0.06073833f, -0.03543300f, -0.22738217f, -0.12916622f, 
    0.40324450f, -1.01048827f, 0.66379994f, 0.36231974f, 0.08337140f, 0.04682351f, 0.32114187f, 0.03210535f, 
    -0.34559879f, 0.00332082f, 0.05514156f, -0.10626396f, -0.31826955f, -0.17086625f, 0.49829963f, -0.44892198f, 
    -0.11067610f, -0.03068087f, -0.14626519f, 0.20859830f, 0.12502131f, 0.03487084f, 0.47441772f, 0.17199773f, 
    -0.48525152f, 0.04019728f, 0.25389987f, 0.32078955f, -0.08068214f, 0.27358201f, -0.27973056f, 0.13506110f, 
    0.06012703f, 0.25592226f, 0.21360251f, -0.08891005f, 0.13150381f, 0.66507518f, -0.07927737f, 0.03826388f, 
    0.04326634f, 0.03416468f, 0.35340673f, -0.00652383f, -0.02632384f, -0.63062882f, -0.75431353f, -0.57813573f, 
    -0.05225584f, -0.14475173f, 0.39473215f, 0.89841318f, 0.09293672f, -0.09277160f, 0.13543287f, 0.25123215f, 
    -0.25822669f, -0.15202059f, 0.06610527f, 0.03034367f, -0.59970611f, 0.14654897f, -0.50814307f, 0.05981091f, 
    0.25980806f, 0.05154136f, -0.03004094f, -0.07224192f, -0.08561160f, 0.16207616f, 0.02891740f, -0.21539116f, 
    0.75892997f, -0.21799947f, -0.18877517f, -0.47804469f, 0.15250297f, -0.35285786f, 0.18635781f, 0.12258986f, 
    0.06600062f, -0.01704591f, -0.02884709f, 0.02935606f, -1.06608534f, 0.18669683f, -0.04760193f, 0.37286788f, 
    -0.26878586f, -0.08139256f, 0.13462961f, -0.11395244f, -0.16365016f, -0.25161636f, -0.29024407f, -0.12433464f, 
    0.28027984f, 0.10932707f, 0.44712555f, 0.03567108f, -0.00339071f, 0.09764521f, -0.04935956f, -0.19660492f, 
    -0.20070282f, -0.08941229f, 0.13045621f, -0.09203976f, 0.02504226f, 0.33076507f, -0.26549435f, -0.29432875f, 
    -0.01117987f, -0.06502541f, 0.01105818f, 0.06914467f, 0.00045102f, -0.01442980f, 0.16517553f, 0.00730192f, 
    -0.75419599f, 0.61605173f, -0.80363929f, 0.33298993f, 0.08449538f, -0.18054011f, 0.34874776f, -0.20121001f, 
    0.00141127f, -0.04997347f, -0.10653496f, -0.03800225f, 0.79797828f, 0.13066684f, 0.72090310f, 0.15003526f, 
    -0.12607990f, 0.11686936f, -0.14234973f, -0.03939779f, -0.23269343f, 0.16918801f, 0.14019957f, 0.08833732f, 
    -0.36862221f, 0.68134183f, -0.03279163f, -0.78733873f, 0.25568315f, -0.28809029f, 0.17723149f, 0.11541924f, 
    -0.02407816f, -0.00056339f, 0.10136905f, 0.03504896f, 0.05686813f, -0.24645665f, -0.27131894f, -0.26636916f, 
    0.04608185f, 0.19411586f, -0.01130010f, -0.13780355f, -0.01090226f, 0.10049148f, 0.24086511f, 0.04489418f, 
    0.13936017f, 0.02285512f, 0.10187410f, -0.34858122f, 0.02238911f, 0.59334117f, -0.45849568f, 0.25589275f, 
    0.01672307f, -0.16683000f, -0.10391644f, -0.24925783f, -0.25440446f, -0.08207912f, -0.23834585f, -0.17110467f, 
    -0.13869157f, -0.26935622f, 0.07800959f, 0.03034421f, -0.00936800f, 0.17629482f, 0.29619125f, -0.03121259f, 
    -0.24119054f, 0.01155081f, 0.41423815f, -0.55542302f, -0.01477402f, -0.00790270f, 0.06625687f, 0.03401811f, 
    -0.03683225f, 0.21615417f, -0.07980079f, 0.14037937f, 0.33158582f, 0.14295261f, 0.08192178f, -0.07180998f, 
    -0.04966572f, -0.05245655f, 0.13601331f, 0.07920723f, -0.07288951f, -0.12509100f, -0.03963352f, -0.26115298f, 
    -0.13071834f, -0.61027491f, -0.14906585f, 0.22729491f, -0.23057409f, -0.32972702f, -0.37133378f, -0.01139969f, 
    0.07774166f, 0.01391834f, -0.07151296f, -0.15109780f, -0.12711151f, 0.07967410f, -0.06049495f, -0.06879808f, 
    0.03587356f, -0.01326615f, -0.08308031f, 0.12683856f, 0.17128369f, -0.02609351f, 0.17652683f, 0.14056572f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.38687930f, 0.05182330f, 0.02974583f, -0.10888439f, -0.19242989f, 0.17379153f, -0.03617246f, -0.18970211f, 
    0.19401224f, 0.18431103f, 0.05790663f, 0.02782959f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
