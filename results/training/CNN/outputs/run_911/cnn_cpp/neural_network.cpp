#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.17484301f, 0.33357558f, -0.44273773f, 0.48149094f, -0.35319906f, -0.46868432f, -0.28608409f, -0.20581436f, 
    -0.39006245f, 0.25462928f, 0.74263185f, -0.16231559f, 0.66527790f, -0.50298792f, 0.11946428f, -0.43699467f, 
    -0.16099405f, 0.12526917f, 0.47143686f, 0.47276935f, 0.64925992f, 0.08396807f, -0.26187974f, 0.13868703f, 
    0.02858658f, -0.17772327f, 0.11858580f, -0.07413507f, -0.41384336f, -0.43094835f, 0.35840392f, 0.32882041f, 
    -0.55946624f, 0.14760259f, 0.27660322f, -0.19598670f, 0.72248006f, 0.15110967f, 0.05287138f, -0.14406405f, 
    -0.07590181f, 0.50868750f, 0.61129189f, 0.14512374f, -0.47775516f, 0.75654501f, 0.65848315f, 0.64888942f, 
    -0.54628134f, -0.23437998f, -0.10942081f, 0.07904267f, -0.07384657f, -0.10413909f, 0.54615748f, -0.69404644f, 
    0.50959957f, 0.52147675f, -0.47569069f, 0.11498607f, -0.09860767f, 0.13948075f, -0.47248095f, -0.36047423f, 
    -0.48680708f, -0.32706049f, -0.13890634f, 0.64605033f, -0.55607533f, -0.39042059f, -0.03249859f, 0.05255017f, 
    0.39062324f, 0.46069640f, 0.31093806f, -0.60405689f, 0.28585184f, -0.04528633f, 0.10321342f, 0.17669632f, 
    0.56226563f, 0.57352573f, 0.30868056f, 0.32619461f, 0.71708941f, 0.64410275f, 0.21877295f, -0.29825842f, 
    0.28273925f, 0.20823535f, -0.51721090f, -0.55679142f, 0.42622343f, 0.78513783f, 0.25250638f, -0.59413970f, 
    -0.12830435f, 0.25137269f, -0.12478676f, 0.40279356f, 0.42531404f, 0.38435858f, -0.13931498f, 0.02587324f, 
    -0.75077385f, -0.29749474f, 0.06863032f, 0.12580128f, -0.05745471f, -0.01014772f, 0.14058709f, 0.16685179f, 
    -0.43646431f, -0.03890280f, -0.40240967f, -0.11657116f, 0.57950217f, -0.93437195f, 0.36165118f, -0.23084092f, 
    0.65717888f, 0.18836056f, -0.38259536f, -0.10134869f, -0.01879056f, 0.30116048f, 0.75877708f, -0.79494351f, 
    -0.40941146f, -0.01861806f, -0.62410271f, -0.47470745f, -0.12355760f, -0.12297071f, 0.02907585f, -0.60461026f, 
    0.08681828f, -0.51982385f, -0.33480132f, -0.56218141f, 0.49801323f, -0.18952277f, 0.31072336f, -0.24247093f, 
    1.03305900f, -0.38005772f, 0.44490132f, -0.52340150f, -0.34487495f, 0.48529166f, -0.38345292f, 0.20393816f, 
    0.23825815f, -0.49148405f, 0.37749469f, 0.23851351f, 0.45832542f, 0.34267718f, 0.59955591f, 0.40049919f, 
    -0.40022632f, 0.28332004f, -0.18459798f, -0.58617920f, -0.51662284f, 0.39966589f, 0.69566631f, 0.43182331f, 
    -0.07254539f, -0.18385543f, -0.49802479f, -0.44607320f, -0.51358128f, -0.17097192f, -0.28876361f, -0.46460038f, 
    -0.21388872f, 0.21262863f, 0.15917622f, -0.38086879f, 0.45443380f, -0.28778777f, -0.42758366f, 0.41533786f, 
    -0.06915211f, 0.12921286f, 0.34741700f, -0.25910825f, 0.19892919f, 0.53765059f, 0.45957729f, -0.65533155f, 
    -0.25188145f, 0.28193694f, 0.03432145f, -0.00567228f, 0.50354123f, 0.22030929f, 0.02464220f, -0.34239599f, 
    0.59474367f, -0.47972092f, 0.02187631f, -0.49538442f, 0.10657970f, -0.28521964f, -0.18202534f, -0.27805272f, 
    -0.90833074f, 0.07411674f, 0.38439241f, -0.54209596f, 0.60473102f, -0.06069762f, -0.29906231f, -0.02480544f, 
    0.24142595f, -0.63042575f, -0.25053921f, 0.18925267f, 0.11054928f, -0.23647512f, -0.39568111f, 0.00621315f, 
    0.52187461f, -0.78497833f, 0.10181229f, 0.11572602f, -0.02397493f, 0.47754464f, -0.50319493f, 0.20370907f, 
    -0.13413802f, -0.50182259f, -0.71901155f, -0.62728304f, -0.69809753f, 0.19049846f, -0.18240592f, 0.21275651f, 
    0.17495789f, -0.08923942f, 0.08315554f, -0.52302980f, -0.49153936f, -0.56057030f, 0.24495661f, 0.63134307f, 
    0.04547306f, 0.35609472f, -0.23172207f, -0.00972835f, 0.11086424f, 0.42351100f, -0.43693185f, -0.76616859f, 
    -0.67821914f, -0.53592980f, 0.32206804f, -0.12250362f, 0.17686599f, 0.33208120f, 0.18534370f, -0.10574676f, 
    -0.58847505f, 0.70014501f, -0.50996023f, -0.11908833f, 0.12383983f, 0.01562529f, 0.21430060f, 0.53211683f, 
    -0.89668471f, 0.06551874f, 0.34994221f, 0.39585385f, 0.14591643f, -0.28453708f, -0.05335739f, -0.39667121f, 
    0.65309805f, -0.34154230f, 0.33180204f, 0.74326611f, -0.30989578f, 0.28091925f, 0.01903818f, 0.10200614f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24512818f, -0.23339616f, 0.22856186f, 0.16072853f, -0.05297666f, -0.16228184f, -0.25996375f, -0.27313831f, 
    -0.24753271f, 0.09085601f, 0.02590731f, 0.17368641f, 0.14626226f, -0.34418768f, 0.18943952f, -0.22222823f, 
    -0.40267423f, -0.21539639f, -0.17436050f, 0.36817336f, 0.16146053f, -0.02412716f, 0.02070847f, -0.04581780f, 
    -0.18470900f, -0.15553303f, -0.22225630f, 0.14073376f, -0.02100924f, -0.05805432f, -0.41201273f, -0.27951565f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.10572010f, 0.07139982f, -0.02196624f, -0.01295175f, -0.00162028f, 0.18779248f, 0.10871699f, 0.05735529f, 
    0.25903466f, -0.05418870f, 0.10580408f, 0.22440919f, 0.10754362f, 0.10824187f, 0.01616898f, -0.08578180f, 
    0.10146506f, -0.11626138f, 0.15759245f, 0.20075437f, 0.06842922f, 0.08629798f, 0.02537269f, 0.12732984f, 
    0.12748630f, 0.08183590f, 0.04432359f, 0.01901021f, 0.09615072f, 0.00914734f, 0.20012003f, 0.01170574f, 
    -0.15340823f, 0.00671637f, 0.11403596f, -0.05394551f, -0.00917954f, -0.09731462f, 0.09536634f, -0.05101561f, 
    0.20777498f, 0.20055467f, -0.06635785f, 0.10389996f, -0.07459326f, 0.04578158f, 0.09039002f, 0.15753265f, 
    0.13584147f, -0.03616776f, -0.03831835f, 0.00608130f, 0.07576136f, 0.02906066f, 0.18757913f, -0.02350793f, 
    -0.14880732f, -0.15838693f, 0.22256251f, 0.03938214f, 0.10731553f, 0.00970556f, -0.03398989f, -0.09069639f, 
    0.08646520f, -0.06235302f, 0.11471350f, -0.14579566f, 0.07657889f, -0.15490702f, 0.03478165f, 0.15507804f, 
    -0.06818241f, 0.22411506f, 0.01325993f, 0.01032569f, -0.00450980f, -0.12849507f, -0.17465711f, 0.05650798f, 
    -0.15682703f, -0.25788000f, -0.17134972f, -0.14988814f, 0.14065421f, -0.02303417f, 0.21143369f, -0.10810644f, 
    0.11266229f, -0.28189370f, 0.02236321f, -0.24676839f, -0.04176617f, 0.22249156f, -0.01012615f, -0.00380978f, 
    0.23707935f, 0.00484602f, -0.01625789f, 0.06711917f, 0.14939748f, 0.02710919f, 0.16292289f, 0.02638879f, 
    -0.10199158f, 0.09423753f, -0.02372431f, 0.09114911f, -0.18219264f, -0.11421338f, 0.13403232f, 0.04035879f, 
    0.06946436f, -0.12193368f, 0.15846238f, -0.02478185f, -0.08943880f, 0.49136829f, -0.03002938f, 0.12896492f, 
    -0.03808379f, -0.18927228f, 0.12652646f, 0.20642187f, 0.00548234f, 0.05754339f, 0.13149118f, -0.07614656f, 
    0.17935878f, -0.02879368f, -0.00782174f, -0.03441566f, 0.12911855f, 0.03378026f, 0.12419344f, -0.16060917f, 
    0.01090420f, -0.06591981f, -0.06855880f, 0.05556775f, 0.15686519f, 0.03262044f, 0.23217571f, 0.12561733f, 
    0.01080185f, -0.11938605f, 0.10650451f, -0.20609270f, 0.24083146f, -0.12678437f, -0.00344182f, 0.05516836f, 
    -0.08652648f, -0.11384273f, -0.22533691f, -0.19531932f, 0.11765246f, 0.05555520f, 0.09453114f, 0.07638033f, 
    -0.19525111f, -0.33064818f, -0.31184620f, -0.12654559f, 0.03752588f, 0.04175339f, -0.03927610f, 0.15366228f, 
    -0.17635985f, 0.04011315f, 0.06444822f, -0.05553669f, 0.07496832f, 0.03079889f, 0.17481287f, -0.00086415f, 
    -0.06293274f, 0.03697177f, -0.06543709f, 0.00613484f, 0.07152709f, -0.00208757f, 0.09509984f, -0.00278727f, 
    0.07956171f, 0.12692831f, -0.17280966f, 0.11766730f, 0.18049686f, -0.10644495f, 0.10937857f, -0.03571780f, 
    -0.05479046f, 0.14001077f, 0.00171344f, -0.16426286f, -0.02808169f, -0.24280724f, 0.20961906f, 0.06859367f, 
    0.07570846f, 0.02426182f, -0.08595616f, -0.09160507f, 0.08830129f, -0.04759411f, 0.08953088f, -0.05668543f, 
    -0.06568224f, -0.19866098f, -0.21762896f, 0.09181267f, -0.10399813f, -0.07682264f, -0.03848705f, 0.17655079f, 
    -0.07237796f, 0.13496330f, 0.05383841f, 0.02522659f, 0.00406510f, 0.04800587f, 0.12115352f, 0.04474990f, 
    0.10077339f, -0.00857104f, -0.17235172f, -0.02710664f, 0.13885325f, -0.13088952f, -0.16968927f, -0.14935030f, 
    0.00628750f, -0.02458873f, 0.01784038f, -0.06290463f, 0.08938325f, -0.06620615f, 0.00269820f, -0.04793449f, 
    -0.15958984f, -0.13490087f, 0.00851843f, -0.06464218f, -0.16544600f, 0.08463074f, 0.14304866f, 0.08312563f, 
    0.08559372f, -0.01156602f, -0.09204641f, 0.15393804f, -0.16492760f, -0.03671162f, -0.12282275f, -0.04457860f, 
    0.11304829f, -0.08939787f, 0.16555700f, 0.05026137f, 0.03778243f, -0.20087141f, 0.25134814f, 0.06610087f, 
    -0.00307378f, -0.00617130f, 0.00728392f, -0.22772262f, 0.12573370f, 0.07812911f, -0.01714196f, -0.09592388f, 
    0.33128151f, -0.03738916f, 0.07047474f, 0.12596528f, 0.05547355f, -0.12924808f, -0.13821511f, 0.22029169f, 
    -0.13985699f, 0.11515458f, 0.01609943f, -0.15410368f, 0.25373900f, -0.20130973f, -0.10438058f, -0.14492895f, 
    -0.02344745f, -0.06331836f, -0.00085302f, 0.03366106f, -0.06408931f, 0.05038872f, -0.02362163f, -0.01397186f, 
    0.04702708f, -0.04083784f, -0.05373177f, 0.03121120f, 0.05633039f, 0.00316522f, 0.00508617f, -0.01158919f, 
    -0.05140704f, 0.00278694f, 0.00867244f, -0.05158745f, -0.04554622f, -0.00244955f, -0.00275468f, -0.02949611f, 
    0.04668587f, -0.02987357f, -0.05209495f, 0.04079772f, -0.03162128f, -0.00072437f, -0.01458507f, -0.00190984f, 
    -0.01685508f, -0.03076515f, 0.01001899f, -0.04332270f, 0.01406318f, 0.01979912f, -0.01641675f, 0.02363613f, 
    -0.04043119f, -0.03531130f, -0.00022367f, -0.03915797f, -0.01253746f, 0.04195336f, -0.00806371f, 0.00611048f, 
    0.00537630f, -0.02116383f, -0.03135132f, -0.06125770f, -0.02020921f, 0.02874835f, -0.03623835f, -0.02620475f, 
    -0.00838153f, 0.04209046f, 0.03603042f, -0.04756858f, 0.00185179f, -0.04223641f, -0.00861688f, -0.00681955f, 
    0.02550430f, 0.01731566f, -0.05016258f, -0.05905579f, 0.04485203f, 0.04530605f, -0.05508029f, 0.01545105f, 
    -0.03630017f, -0.03715442f, -0.04730783f, -0.05894619f, -0.02233261f, -0.02770501f, 0.01718837f, -0.02360016f, 
    -0.03179221f, -0.01069734f, -0.05191479f, -0.01945929f, 0.01963923f, 0.00134994f, 0.04836039f, -0.02788157f, 
    0.04691537f, -0.00800441f, -0.00308923f, -0.05621081f, -0.00400766f, 0.04319445f, 0.04621281f, -0.02078177f, 
    -0.00488698f, -0.01115263f, -0.02546964f, -0.03630881f, 0.00630034f, 0.00448215f, 0.02241586f, 0.00513403f, 
    0.04089666f, -0.01547913f, 0.02988903f, -0.00151339f, 0.02376998f, -0.04388921f, -0.01833143f, 0.00124118f, 
    -0.03748176f, -0.03536326f, 0.03918281f, -0.02578376f, -0.00107081f, -0.05463549f, -0.05434076f, -0.01349546f, 
    -0.05641704f, 0.00238151f, -0.01850943f, -0.02470500f, -0.04933354f, -0.00857501f, 0.05310731f, 0.04357234f, 
    0.03099382f, -0.01707390f, 0.01296675f, 0.04222288f, -0.02807545f, -0.00422558f, 0.01131658f, -0.04625922f, 
    -0.03514451f, -0.02078322f, -0.04380795f, 0.00133283f, -0.04096802f, -0.06433685f, 0.01013866f, -0.05196052f, 
    -0.04592378f, -0.01017228f, -0.00559139f, -0.02330687f, -0.03285919f, -0.04927179f, -0.02034377f, 0.01696289f, 
    -0.01728847f, 0.01373409f, 0.01298326f, -0.05355020f, -0.03975714f, -0.05728537f, -0.01387048f, 0.04980710f, 
    0.02121118f, 0.03611000f, -0.04075331f, 0.00511374f, -0.00378101f, 0.02871205f, -0.03328459f, 0.03680512f, 
    -0.02724318f, 0.04992045f, 0.02004234f, -0.05490721f, -0.00782865f, -0.05503650f, -0.02650548f, 0.02924540f, 
    -0.05591170f, 0.02728344f, 0.01511753f, -0.06597832f, -0.01745716f, -0.05118593f, 0.03803372f, -0.03417809f, 
    0.03947055f, 0.02258159f, -0.06153433f, -0.06624462f, -0.04515610f, 0.04050358f, -0.02079071f, -0.00949908f, 
    -0.00315031f, 0.02033023f, 0.03321786f, 0.01192718f, -0.05194110f, -0.03176215f, -0.05912850f, 0.01636278f, 
    -0.05747116f, -0.06025624f, -0.04196904f, 0.02130239f, -0.03309401f, -0.02710078f, 0.01323384f, -0.00443928f, 
    0.03835724f, 0.01956909f, -0.05279287f, -0.00621175f, -0.01525502f, -0.02477560f, -0.05204921f, 0.00252724f, 
    0.03653878f, -0.01399943f, -0.02763548f, 0.02439681f, 0.04216116f, -0.01989188f, -0.04337735f, -0.02290227f, 
    -0.02551104f, 0.00929379f, 0.04369707f, -0.02109958f, -0.02883630f, 0.02361193f, 0.02447331f, 0.00217751f, 
    -0.03148146f, 0.02465985f, -0.05150093f, 0.01655379f, 0.04776647f, 0.00485678f, -0.04645948f, 0.02077001f, 
    -0.04716555f, 0.03386939f, -0.01632952f, 0.04104456f, -0.04002185f, 0.00561995f, -0.02525156f, 0.00031221f, 
    0.00983221f, -0.05070978f, -0.03313581f, -0.04457001f, -0.04498293f, -0.00423056f, -0.05308926f, -0.04975017f, 
    -0.01646731f, 0.00638627f, -0.04106648f, -0.05759931f, 0.00003831f, 0.05346487f, -0.02721000f, 0.03326814f, 
    -0.06198261f, 0.00864806f, -0.00008709f, -0.01102493f, -0.00869557f, 0.00914715f, -0.02419792f, -0.02786751f, 
    0.03539284f, 0.05127737f, 0.04605312f, -0.02993092f, -0.00201666f, -0.00981324f, 0.03422603f, 0.04937767f, 
    0.00994178f, -0.02456584f, 0.01759069f, -0.03117334f, -0.00829977f, -0.05100143f, 0.04487745f, -0.00055232f, 
    0.17981587f, 0.06757917f, 0.12034260f, -0.02018496f, 0.03518403f, 0.17975287f, 0.03508177f, -0.05587585f, 
    -0.03366606f, 0.41344556f, 0.09802587f, 0.16079108f, -0.06192223f, -0.05634939f, 0.04137486f, 0.03122606f, 
    0.01080724f, 0.12058487f, 0.14542997f, -0.00216415f, -0.06293632f, -0.10943920f, -0.06586165f, -0.00126860f, 
    -0.03218037f, -0.02491349f, 0.19332428f, -0.28900430f, 0.20171244f, 0.01815984f, -0.13219936f, -0.03795052f, 
    -0.05389165f, -0.04412422f, -0.00180927f, -0.13484555f, -0.30559552f, 0.02891706f, -0.20423667f, 0.08103872f, 
    0.00710177f, -0.14527592f, 0.10758536f, -0.08752360f, 0.01154850f, -0.17521757f, -0.06354296f, 0.19271351f, 
    0.01284444f, -0.11019203f, 0.12376741f, -0.16255914f, 0.00927758f, 0.09612167f, -0.08875775f, -0.12366834f, 
    -0.14715758f, 0.00147717f, 0.15613838f, -0.01306883f, 0.04384011f, -0.36696655f, -0.14854443f, -0.27091953f, 
    0.21113236f, 0.29599020f, 0.02687426f, -0.03071029f, 0.04873032f, -0.16293688f, -0.05578791f, 0.05837223f, 
    -0.00541092f, 0.10605583f, -0.10006855f, -0.02584228f, -0.06275810f, 0.07170179f, -0.19239978f, -0.17901753f, 
    -0.11534560f, -0.11708429f, 0.08541541f, -0.13425936f, -0.17071906f, -0.04552271f, -0.01960117f, 0.27764118f, 
    0.07937916f, -0.03708065f, -0.07450114f, 0.22996795f, -0.15242809f, 0.00324600f, 0.05170158f, -0.02620296f, 
    0.09738999f, -0.05048104f, 0.04041133f, -0.18265125f, -0.02563821f, -0.01463640f, 0.05158816f, -0.07767776f, 
    -0.06174524f, -0.01515232f, -0.07831735f, 0.00650053f, 0.11040687f, 0.01150073f, -0.09355234f, -0.08106042f, 
    -0.06875825f, -0.08022943f, 0.04515996f, 0.16235016f, -0.08034151f, -0.14123984f, -0.04723112f, 0.18795456f, 
    0.04327286f, 0.07150918f, 0.17063884f, 0.06790287f, 0.10116532f, -0.00006750f, 0.00963153f, 0.11853188f, 
    0.18214478f, -0.09070951f, -0.05312565f, -0.06880474f, -0.03647823f, -0.01600596f, 0.16964923f, 0.18118358f, 
    -0.07057360f, 0.10681487f, 0.11180559f, 0.15822151f, -0.08239684f, 0.03281497f, 0.10880899f, -0.10314250f, 
    0.16012162f, 0.11560106f, -0.11467359f, 0.07352118f, 0.03785687f, -0.15929389f, -0.09521287f, -0.11834610f, 
    0.21087426f, 0.08031061f, 0.11684072f, -0.00281412f, 0.03364117f, 0.14633045f, -0.22081982f, -0.07215949f, 
    -0.01252197f, 0.11759008f, 0.14062688f, 0.21948898f, -0.16358759f, 0.00053823f, 0.26686805f, -0.14436278f, 
    0.05041320f, 0.00910404f, 0.12776484f, 0.00897820f, -0.18375470f, 0.14391643f, 0.05229688f, -0.04339431f, 
    -0.09425990f, 0.08052156f, 0.01711572f, -0.18727563f, 0.08518715f, 0.02609073f, -0.31512591f, -0.12501919f, 
    -0.10927625f, -0.01404624f, -0.19323952f, 0.05843227f, 0.05346830f, -0.45056584f, 0.26495910f, -0.08216937f, 
    -0.03334218f, -0.12468737f, -0.11185777f, -0.10151382f, 0.08985689f, 0.06646677f, 0.09175518f, -0.01316196f, 
    0.09366915f, -0.01558436f, -0.06092911f, -0.11703887f, 0.02055012f, -0.05553386f, 0.02225737f, 0.02573609f, 
    0.11235334f, 0.01834559f, 0.00430998f, -0.05473212f, 0.02978735f, 0.13255994f, -0.08617815f, -0.09224481f, 
    0.19945839f, 0.04910028f, 0.05833227f, -0.06112405f, -0.15770829f, 0.06754370f, -0.01358161f, -0.03099329f, 
    0.10695978f, 0.22018927f, 0.25882837f, 0.06897610f, -0.01812249f, 0.04011144f, 0.05770597f, 0.04397364f, 
    -0.01083758f, -0.05933797f, -0.18873590f, 0.17100015f, 0.07196008f, 0.23217963f, 0.07323436f, 0.05243474f, 
    -0.01685085f, 0.14206250f, 0.04763935f, -0.09653518f, 0.23136593f, -0.00169808f, 0.03422647f, 0.04103033f, 
    -0.03930437f, -0.17380069f, 0.01205859f, -0.04299959f, -0.15902777f, -0.05535821f, 0.06735562f, -0.16143258f, 
    -0.10019137f, -0.11903077f, 0.14197239f, 0.07966958f, -0.03699708f, -0.01895858f, -0.02623392f, -0.15744364f, 
    0.11047381f, 0.04156068f, 0.09019759f, -0.01496623f, -0.12027176f, -0.31688839f, -0.01287587f, -0.07606271f, 
    -0.21079268f, -0.04544678f, -0.13308182f, -0.11637662f, 0.26540437f, -0.06586547f, 0.06839769f, -0.12112145f, 
    -0.02812867f, 0.21372782f, -0.01038046f, -0.06956234f, -0.06708161f, -0.11630183f, -0.02726465f, -0.14821790f, 
    -0.05558945f, 0.03455830f, -0.01694918f, -0.05183620f, -0.03819546f, 0.03265679f, -0.03947948f, -0.03806708f, 
    0.04277268f, -0.00625981f, 0.01299694f, -0.01240182f, -0.03145232f, 0.01262018f, -0.02740516f, -0.05946689f, 
    0.03391411f, -0.02949083f, 0.00096365f, -0.00889256f, -0.02278912f, 0.02356760f, 0.04072132f, 0.00193440f, 
    -0.01616236f, -0.00868353f, 0.00965773f, -0.03445920f, -0.00007118f, 0.01716279f, 0.03062132f, 0.01000593f, 
    -0.04964393f, 0.01660161f, 0.04458326f, 0.00543808f, 0.04193091f, -0.02993956f, -0.03217059f, -0.03637002f, 
    0.03151970f, -0.00714164f, -0.04827639f, -0.04978992f, -0.05506308f, -0.06123979f, -0.04799238f, 0.01532049f, 
    -0.01258940f, 0.03413140f, 0.01379174f, 0.04412911f, -0.01851503f, 0.04896918f, -0.06824847f, -0.02268233f, 
    -0.02583323f, -0.00031148f, -0.06499977f, -0.05216634f, -0.00204108f, -0.00421412f, 0.00575548f, -0.03398951f, 
    -0.04425917f, -0.01420198f, 0.03491869f, 0.01742699f, 0.01569966f, -0.06194327f, -0.02256618f, -0.00130819f, 
    -0.00840336f, 0.00687106f, -0.03525411f, 0.03420372f, 0.04441509f, -0.05483850f, 0.03935562f, -0.00495517f, 
    -0.02136252f, -0.01374579f, -0.00044018f, 0.01868475f, -0.04248056f, 0.00607758f, 0.04131779f, -0.05295548f, 
    0.02382295f, -0.00748358f, -0.05866134f, 0.00232255f, -0.03634807f, 0.03624681f, 0.04266231f, 0.01249357f, 
    -0.01253632f, -0.02109179f, -0.01199322f, -0.06229294f, -0.01372585f, 0.03360362f, 0.04324594f, -0.04856591f, 
    -0.01935859f, -0.05206551f, -0.02996246f, 0.03692062f, -0.00791669f, 0.01165735f, 0.05300706f, 0.04809131f, 
    -0.03183949f, -0.04401021f, -0.05426145f, -0.05051031f, -0.05781278f, 0.02891956f, 0.04409539f, -0.01004648f, 
    -0.00001939f, 0.02009715f, 0.03965858f, 0.05018466f, -0.05618080f, -0.03693711f, 0.03189880f, -0.03627908f, 
    0.02071338f, -0.01474480f, -0.01407371f, -0.03533097f, 0.01259118f, 0.02845120f, -0.06970102f, -0.00271124f, 
    0.02019717f, 0.02564081f, 0.00551359f, 0.02509603f, -0.01256593f, -0.02967697f, 0.02401030f, -0.05018118f, 
    -0.06401940f, -0.05912168f, 0.03609130f, -0.04590584f, -0.01462833f, 0.02301093f, -0.00171318f, -0.03713361f, 
    -0.01535617f, -0.04312384f, 0.01309420f, -0.06247338f, -0.01699608f, 0.00938857f, -0.05662191f, 0.03591883f, 
    -0.01450307f, 0.02601012f, -0.05013093f, -0.04747460f, 0.02281554f, -0.05041092f, -0.06541630f, -0.04988585f, 
    -0.00532978f, -0.02792697f, -0.03774412f, -0.00404718f, 0.04932370f, -0.06225486f, 0.04825039f, 0.02027259f, 
    -0.03319028f, -0.05883503f, -0.00008976f, -0.02489259f, -0.06076493f, -0.03612171f, -0.05654826f, -0.01220886f, 
    -0.01351064f, -0.03975843f, 0.04002299f, 0.04950478f, 0.01214106f, 0.04152108f, -0.04627219f, 0.03608495f, 
    0.01787324f, -0.00520113f, -0.04650878f, 0.00777674f, 0.02941520f, -0.03132098f, -0.03207416f, -0.06011193f, 
    -0.01516705f, -0.07322930f, 0.02920962f, -0.02867081f, 0.00853431f, 0.02309435f, 0.00038297f, -0.00422032f, 
    -0.03369859f, -0.03418563f, -0.02601843f, 0.00910773f, -0.00173883f, 0.01795597f, 0.00289378f, -0.05101669f, 
    0.01577200f, -0.05743838f, 0.02562194f, 0.03517574f, 0.03012607f, 0.02459978f, -0.00520514f, -0.05773918f, 
    -0.01022670f, -0.04326860f, 0.03992859f, 0.02749122f, -0.03211139f, 0.03064472f, 0.01203535f, -0.03528460f, 
    0.03369183f, 0.01989736f, 0.01905656f, 0.03688158f, -0.05805411f, -0.03765621f, 0.03109228f, 0.04192810f, 
    0.03959669f, 0.05238705f, -0.00339318f, -0.00929617f, 0.00428312f, 0.02745036f, -0.00591077f, -0.00315407f, 
    0.01012638f, 0.02850047f, 0.01081124f, -0.01441244f, -0.04880622f, -0.00985941f, -0.02551883f, 0.00211165f, 
    -0.02878195f, 0.01660274f, 0.01717126f, -0.00877254f, 0.03567603f, -0.01011115f, -0.02064365f, -0.06600330f, 
    -0.05888968f, 0.04081509f, 0.03070409f, -0.02765532f, -0.04957685f, -0.04424577f, -0.01742174f, 0.01019147f, 
    -0.00681615f, 0.00727590f, 0.01256028f, -0.05249765f, -0.05939720f, -0.04994648f, 0.05025788f, 0.04345033f, 
    0.04456522f, -0.01118734f, -0.00576394f, 0.00612525f, -0.04629567f, 0.00845363f, 0.04522100f, 0.01676967f, 
    0.00514316f, 0.03787939f, -0.03206239f, 0.00361829f, -0.05726822f, 0.01475481f, -0.03546674f, 0.02321048f, 
    -0.02373255f, 0.02938790f, -0.06549341f, 0.00711718f, -0.05767496f, -0.02200593f, 0.05042312f, 0.00197991f, 
    -0.02876227f, -0.00341123f, 0.01970033f, -0.02806054f, -0.03097302f, -0.05241573f, -0.03106331f, -0.04359080f, 
    0.02319375f, -0.05887337f, -0.00350158f, -0.04787706f, -0.05543589f, -0.01056270f, -0.03890693f, 0.04293196f, 
    -0.04596391f, -0.03085113f, -0.03639286f, -0.04814037f, -0.03011597f, -0.04379797f, -0.00594989f, 0.00043871f, 
    -0.04692056f, 0.01932385f, -0.04137028f, 0.00087753f, -0.04123637f, -0.03844404f, -0.02658487f, 0.03927104f, 
    -0.03991206f, -0.02289125f, -0.04172539f, -0.02430311f, -0.02596107f, -0.05893883f, 0.02057465f, -0.02606581f, 
    0.01294264f, 0.03529293f, -0.01741867f, -0.03437954f, -0.03850215f, -0.05888115f, -0.00384799f, 0.01189572f, 
    0.04208423f, 0.04243376f, 0.03951737f, -0.04978225f, -0.04848109f, 0.04220188f, -0.04779444f, 0.01631011f, 
    -0.06412411f, -0.04633027f, 0.00449217f, -0.03111955f, -0.00994508f, 0.04573616f, 0.00158732f, 0.04233216f, 
    0.01278894f, -0.03235035f, 0.03211747f, 0.01013620f, -0.02248171f, 0.04087963f, 0.02467111f, 0.00209658f, 
    0.01531971f, -0.03129990f, 0.00527797f, 0.05159171f, -0.04671526f, 0.04627916f, -0.00400942f, -0.05759095f, 
    -0.00709742f, -0.06366815f, 0.02311475f, 0.05073317f, -0.06399005f, -0.03493426f, -0.04019070f, 0.04676330f, 
    0.01979988f, -0.06329717f, 0.03776783f, 0.02325411f, 0.04165325f, -0.03781868f, -0.06029764f, -0.05719312f, 
    -0.02809907f, -0.00153982f, -0.03252235f, 0.01080624f, 0.01650234f, -0.03884984f, -0.05692297f, 0.02403657f, 
    0.05143076f, 0.05202103f, 0.00221300f, -0.04883041f, -0.04052824f, 0.00410481f, -0.02900320f, -0.05871033f, 
    0.02607693f, 0.00290464f, -0.05128836f, -0.05879441f, 0.04057748f, -0.01325859f, -0.01032881f, 0.00804688f, 
    -0.05031897f, 0.02284640f, 0.01707032f, -0.06578831f, -0.03404896f, 0.04650458f, 0.05330838f, 0.02305347f, 
    0.03634121f, 0.00951540f, 0.04051667f, 0.00118057f, -0.01100923f, 0.04908274f, -0.02231334f, -0.02407392f, 
    0.02878641f, -0.01121960f, -0.06387857f, 0.00538764f, 0.05154933f, -0.02953480f, -0.06293213f, 0.00651259f, 
    -0.02163676f, -0.04539096f, -0.05989435f, 0.04292675f, -0.04040724f, -0.03241327f, -0.02650862f, 0.01378294f, 
    0.00191578f, -0.04737978f, 0.00609263f, -0.01799317f, -0.01736102f, 0.00379139f, -0.04268863f, -0.02947976f, 
    -0.05855701f, 0.02209206f, 0.00573785f, -0.04211865f, 0.03080329f, 0.01653556f, 0.04123849f, -0.05788625f, 
    0.04353347f, -0.01872556f, 0.03898660f, -0.03679117f, -0.02919643f, 0.03600577f, -0.03356802f, -0.04976314f, 
    0.03190812f, -0.01906483f, 0.01905786f, 0.02521649f, 0.04763247f, -0.01459018f, 0.02925769f, 0.03420464f, 
    -0.02461068f, -0.01532271f, 0.03269439f, 0.00294689f, 0.03755200f, 0.03823290f, -0.03733974f, -0.03725889f, 
    -0.06598546f, 0.04537875f, -0.02097229f, 0.04732601f, -0.04837216f, -0.06097275f, -0.06233912f, -0.03760242f, 
    0.02954567f, 0.01054550f, -0.04264588f, -0.02405894f, -0.05541838f, -0.03694609f, 0.03448067f, 0.01235892f, 
    -0.02226072f, 0.02789940f, -0.00522747f, 0.02453698f, 0.04947469f, -0.06105078f, 0.05164244f, -0.03573426f, 
    0.01783184f, 0.00317037f, 0.04309857f, 0.03513131f, 0.03669975f, -0.04215968f, -0.02293003f, 0.00852720f, 
    -0.03467808f, 0.04167784f, -0.01877822f, 0.05099206f, 0.04991943f, 0.03043022f, -0.02749705f, -0.06410076f, 
    0.00935364f, 0.03842064f, -0.05339521f, -0.06018208f, 0.03681332f, 0.00216722f, 0.00725653f, 0.03009781f, 
    0.05065134f, 0.01239508f, 0.00885548f, -0.00074445f, -0.03789616f, -0.03350473f, 0.00123597f, -0.00987986f, 
    0.04928304f, -0.03951786f, -0.04841644f, 0.00331197f, -0.02616621f, -0.04356196f, 0.02284674f, 0.03308008f, 
    -0.05940006f, -0.06017569f, 0.00210243f, 0.00374038f, -0.05119482f, 0.03172719f, 0.04046215f, 0.05246390f, 
    0.05171242f, -0.02667506f, 0.01099421f, -0.02004324f, -0.05214889f, 0.03189287f, 0.02984984f, 0.00446218f, 
    0.03924289f, 0.03709734f, -0.02611948f, -0.00876230f, 0.01813090f, 0.03498102f, -0.06123088f, -0.04744901f, 
    0.02178402f, -0.00133212f, -0.01369189f, 0.00232157f, -0.00730877f, -0.02539161f, -0.05612815f, 0.00960798f, 
    0.01034715f, 0.02490475f, -0.04915740f, -0.02554799f, 0.05187664f, 0.00010467f, -0.02569116f, -0.04981888f, 
    0.00144132f, -0.02182654f, -0.03823942f, 0.03204851f, 0.01514233f, -0.00148105f, -0.04623465f, -0.06726778f, 
    0.04316560f, -0.03679460f, 0.05050426f, 0.01791993f, -0.03322282f, 0.02788522f, -0.00042345f, 0.00839055f, 
    -0.02181195f, 0.01454695f, 0.03047400f, 0.01959786f, -0.04906321f, -0.05938148f, 0.01355443f, -0.04862828f, 
    0.00071311f, 0.00605854f, -0.03682832f, 0.00341879f, -0.05935659f, 0.02976105f, -0.02258912f, 0.03986466f, 
    -0.05650070f, 0.03729912f, -0.06596836f, -0.03646056f, 0.02814463f, -0.05737095f, -0.05373865f, -0.02832351f, 
    0.03187379f, 0.02878735f, 0.04876989f, 0.00500836f, -0.03117097f, 0.04755220f, 0.03098980f, -0.03725797f, 
    -0.05379328f, -0.02645923f, -0.05280400f, 0.02104827f, -0.00583645f, -0.03484025f, -0.02132628f, 0.01169523f, 
    -0.02391519f, 0.03862817f, -0.04339604f, 0.00819157f, 0.00470965f, 0.00590346f, -0.04462656f, -0.02874681f, 
    -0.01976607f, -0.05736238f, 0.03787544f, -0.01995724f, 0.01143615f, -0.03051756f, 0.01200916f, 0.01612289f, 
    -0.06988722f, -0.03636751f, -0.02221785f, -0.03248863f, 0.05042772f, 0.03859043f, 0.03557189f, -0.06110400f, 
    -0.07246923f, -0.05504612f, -0.02898276f, 0.04190728f, -0.05565219f, 0.00275491f, -0.01889846f, 0.03188974f, 
    0.01784337f, -0.00846711f, 0.04472461f, -0.01568434f, -0.00593922f, 0.02016718f, -0.04714390f, 0.05491849f, 
    0.00180048f, 0.03374979f, 0.02764181f, -0.03371771f, -0.05315680f, 0.02547892f, 0.02518147f, -0.06636804f, 
    -0.01406282f, -0.01000434f, 0.01045528f, -0.03940358f, -0.04008685f, -0.02664722f, -0.04210298f, -0.00040690f, 
    -0.00800363f, -0.00329570f, 0.03056902f, 0.04904164f, 0.04539393f, -0.07047021f, 0.03024939f, 0.04477731f, 
    0.00507680f, -0.05834954f, -0.04914096f, -0.06580835f, -0.00057131f, 0.01545488f, 0.03981957f, 0.04120395f, 
    0.01542857f, -0.01823307f, -0.03495392f, -0.00033874f, 0.00437007f, -0.05888876f, 0.04706747f, 0.01280999f, 
    -0.03252881f, -0.02907177f, 0.01444251f, -0.02073484f, -0.02835640f, -0.04813205f, -0.00048971f, -0.05600058f, 
    -0.05067088f, -0.05652397f, 0.01989482f, -0.05639603f, -0.00916185f, -0.05456990f, 0.04190407f, 0.02267659f, 
    -0.03522678f, -0.04659938f, -0.02472453f, -0.03650453f, -0.04643762f, -0.04379195f, -0.04058909f, 0.01526594f, 
    0.04224904f, -0.04867408f, 0.00651129f, -0.05031126f, -0.05347611f, -0.03842248f, -0.03333880f, -0.00940880f, 
    -0.02052177f, 0.01650819f, -0.03294317f, -0.00070878f, -0.03920616f, -0.05417394f, -0.05192126f, -0.05598654f, 
    0.02967113f, -0.01003875f, 0.01988244f, -0.00640742f, 0.00564937f, -0.06658676f, -0.03250832f, -0.06470450f, 
    0.02148995f, 0.02006221f, -0.05370901f, -0.04090804f, -0.06187410f, -0.04559912f, -0.05052557f, 0.03480647f, 
    0.03504069f, 0.00837192f, -0.05396028f, 0.00968838f, -0.02339699f, -0.01358482f, 0.01159303f, -0.05972144f, 
    0.02283286f, -0.05141248f, -0.01195352f, 0.03080666f, 0.03175078f, 0.04197192f, 0.01999282f, 0.00990771f, 
    -0.05160877f, -0.02445948f, -0.06393976f, -0.05245940f, 0.01042027f, -0.06721081f, 0.03421469f, -0.04222408f, 
    -0.03519418f, 0.00373614f, -0.05169023f, -0.06171720f, -0.00630249f, 0.01207137f, 0.02407906f, -0.03716539f, 
    -0.00738357f, -0.04302965f, -0.05425777f, -0.06478449f, -0.06043760f, 0.01510006f, 0.02670326f, 0.02197093f, 
    0.03428275f, 0.00750787f, -0.06172720f, 0.03573656f, -0.05756207f, -0.01433834f, -0.02567155f, 0.04047162f, 
    -0.07107192f, -0.06019016f, 0.03587250f, 0.02793044f, -0.05584498f, -0.01421135f, -0.00473560f, -0.03181766f, 
    -0.06296088f, 0.00302797f, 0.01127908f, -0.01046298f, -0.03349539f, -0.04110655f, 0.01545660f, -0.05493138f, 
    -0.04143601f, -0.02084020f, 0.01247848f, -0.01436890f, -0.06729957f, 0.04517262f, -0.00356578f, 0.05132787f, 
    0.24649915f, -0.06105287f, 0.11152120f, 0.03042997f, 0.05247743f, 0.22720620f, 0.18668322f, 0.05409001f, 
    0.04145153f, 0.03184275f, -0.02454568f, 0.03691982f, 0.05334803f, -0.01174682f, 0.13722371f, -0.08442856f, 
    0.17074014f, -0.07392461f, -0.09724791f, -0.32383928f, 0.03544901f, -0.00112148f, 0.08890028f, 0.02120740f, 
    0.02827485f, -0.20840083f, -0.00760090f, 0.00108362f, -0.09262616f, 0.20055006f, 0.04980335f, 0.18613182f, 
    0.05169433f, -0.09367438f, 0.13684940f, 0.05426357f, -0.30210450f, -0.17283578f, 0.00445612f, 0.05505881f, 
    0.25281200f, -0.25908768f, 0.14537893f, -0.20436351f, -0.18046206f, -0.32389793f, -0.34825981f, 0.05673537f, 
    -0.05242056f, 0.16967326f, -0.05313717f, 0.12242223f, -0.11158376f, -0.10767496f, -0.10271490f, 0.06947809f, 
    0.12255362f, -0.01920030f, -0.03452744f, -0.01249133f, -0.06237155f, -0.01348206f, -0.01296037f, -0.13296419f, 
    -0.09771195f, 0.15044038f, -0.14824821f, -0.06535216f, 0.03359914f, 0.04441762f, -0.00993605f, 0.11854000f, 
    -0.31848237f, -0.15872246f, -0.00828947f, -0.11182828f, -0.06224695f, -0.03969988f, 0.10283229f, 0.04823258f, 
    0.02903737f, -0.35592467f, 0.03153541f, -0.08637848f, 0.14310876f, 0.19289607f, 0.16571768f, 0.04294661f, 
    0.13609338f, -0.01012789f, 0.06923616f, 0.02246183f, -0.23061724f, 0.02069510f, -0.15244199f, 0.05271801f, 
    0.05059844f, 0.16843964f, -0.00970971f, -0.19919400f, -0.13127267f, 0.06939610f, -0.16015781f, -0.01647341f, 
    0.15904771f, 0.17207661f, -0.00390038f, 0.16612922f, 0.09285731f, -0.04309282f, 0.00853990f, -0.03355874f, 
    0.07371861f, -0.09064549f, -0.08948700f, 0.12788884f, -0.11165832f, 0.14850627f, -0.08315986f, -0.03065312f, 
    -0.16617258f, -0.07161786f, -0.03190168f, 0.03063405f, -0.01186799f, -0.10396689f, 0.00630682f, 0.13204931f, 
    0.02542367f, -0.10332648f, -0.04060815f, -0.00896330f, 0.13379146f, 0.15659744f, 0.08770303f, 0.15112947f, 
    -0.02280625f, -0.22048023f, 0.01217897f, -0.06301372f, 0.02939589f, -0.01257212f, 0.08201809f, -0.03920784f, 
    -0.24439193f, -0.25179270f, -0.08970662f, -0.00970993f, 0.06224070f, 0.02228334f, -0.05170461f, 0.18679027f, 
    -0.20568432f, -0.14328362f, 0.05133870f, -0.04870674f, 0.22769088f, 0.11574528f, 0.12411045f, 0.10030559f, 
    0.07418155f, 0.10515518f, -0.17365423f, -0.05364326f, -0.03642606f, -0.06612853f, 0.12078086f, 0.13566425f, 
    0.06007750f, 0.11618415f, -0.03480381f, 0.16180716f, -0.13544230f, 0.09049644f, 0.10086291f, 0.09726202f, 
    -0.07545400f, -0.15540239f, 0.03173507f, 0.27778959f, -0.10235302f, 0.10044666f, -0.14573625f, -0.03002617f, 
    0.10320516f, 0.18186001f, -0.12307808f, 0.20948744f, 0.04225906f, -0.16209002f, 0.15512013f, 0.03107110f, 
    0.03021189f, 0.09557144f, -0.00412078f, -0.01808828f, 0.13421094f, -0.05276115f, 0.00928016f, -0.06722746f, 
    0.12138330f, 0.01444467f, -0.11827127f, -0.08928994f, 0.05601647f, -0.16965191f, 0.20239721f, 0.38270167f, 
    -0.05650786f, 0.07936001f, 0.03321787f, -0.10001717f, -0.07926916f, 0.05706806f, 0.19255775f, -0.01541087f, 
    -0.03472646f, 0.05489070f, -0.01343028f, 0.02169972f, 0.01531546f, 0.09806295f, 0.11727472f, 0.12997173f, 
    0.01536801f, -0.14217187f, 0.14331150f, -0.00254466f, -0.03450144f, -0.14816545f, 0.12322654f, 0.04859865f, 
    0.08902645f, -0.01347841f, 0.08789668f, -0.22052853f, -0.05111403f, 0.01906348f, -0.01695368f, -0.00518658f, 
    0.07548945f, 0.03848551f, -0.11677398f, 0.07349122f, -0.02410945f, -0.11829098f, -0.08746076f, -0.01630224f, 
    0.12687306f, -0.14775309f, 0.08126066f, 0.19666472f, 0.13379219f, 0.11925862f, 0.09162378f, 0.13022055f, 
    0.20128760f, -0.14300901f, -0.02099737f, 0.11668725f, -0.05388464f, -0.36669865f, 0.14812106f, 0.26118451f, 
    -0.00618177f, -0.09130012f, -0.11365400f, 0.20227158f, -0.01020067f, -0.10830528f, -0.10566559f, -0.18439151f, 
    -0.04955676f, -0.06582545f, 0.02934970f, -0.00631716f, 0.06692388f, 0.09977694f, -0.11987527f, -0.11578748f, 
    0.21427156f, 0.04652182f, 0.14805689f, -0.01205707f, 0.08223824f, 0.18192492f, 0.19530931f, 0.03680082f, 
    -0.03445107f, -0.06221222f, 0.05248318f, -0.03401046f, 0.04175049f, -0.02159336f, 0.00791227f, 0.02817790f, 
    -0.01923203f, -0.07111923f, -0.00304264f, 0.01035466f, -0.05049384f, 0.00209919f, -0.03937293f, -0.05737496f, 
    0.04561853f, 0.02039238f, 0.00180066f, -0.05079188f, 0.02360244f, 0.02585976f, 0.03225249f, 0.00331979f, 
    -0.05194451f, 0.04125487f, -0.04675155f, -0.01420516f, 0.00974133f, -0.06124111f, 0.03984502f, -0.04274490f, 
    -0.05987555f, 0.04916000f, 0.01060029f, 0.00890281f, 0.00384694f, 0.02442068f, -0.04287597f, -0.06732873f, 
    0.03446002f, 0.00260434f, 0.01465520f, -0.05695021f, 0.02486747f, 0.04298789f, 0.04453728f, -0.05935393f, 
    -0.01523983f, -0.00157732f, 0.02404252f, -0.02046026f, 0.02574331f, 0.03425798f, -0.01034992f, -0.01935525f, 
    0.03240926f, -0.05586219f, 0.03665414f, -0.00416831f, -0.04510593f, -0.04040064f, -0.02528902f, -0.00317916f, 
    -0.00477383f, 0.05081385f, 0.02577213f, -0.02801292f, -0.04064255f, -0.01914011f, -0.05316774f, -0.02505379f, 
    -0.00066362f, -0.06805084f, -0.02095400f, 0.01136838f, 0.02687278f, -0.04569124f, -0.03341387f, 0.03049215f, 
    0.02756174f, -0.05737930f, 0.04449184f, -0.04890163f, -0.01993530f, -0.02710959f, -0.03224681f, 0.04551534f, 
    0.04856510f, -0.04991195f, 0.01032844f, 0.04074656f, 0.00638599f, -0.02863850f, 0.03386194f, -0.00176806f, 
    0.04830924f, -0.06005529f, -0.03214439f, -0.04135437f, -0.00144818f, 0.00890060f, -0.04339380f, 0.01005363f, 
    0.04050149f, -0.01955001f, -0.02884495f, -0.02109607f, -0.02648374f, 0.02697237f, -0.04015565f, 0.04573298f, 
    -0.00606423f, -0.03989234f, -0.04299621f, 0.03827117f, 0.04537475f, 0.01074400f, 0.01881532f, 0.04940825f, 
    -0.03923394f, -0.02960985f, -0.05108614f, 0.02980195f, 0.04068091f, 0.04338750f, 0.05021721f, -0.01755561f, 
    0.03541631f, -0.05820030f, -0.06105401f, -0.04685220f, 0.03972624f, 0.02775490f, -0.01324974f, -0.06260940f, 
    0.03700861f, -0.03050582f, 0.00405140f, 0.01180903f, -0.03129212f, -0.04418344f, -0.05338157f, -0.02053141f, 
    -0.05749739f, -0.03094625f, 0.02338898f, -0.00363150f, 0.04481115f, 0.00105234f, -0.01546325f, 0.00133112f, 
    -0.02015784f, -0.01387918f, -0.04758418f, 0.03737412f, -0.05582145f, -0.04788208f, 0.00881779f, -0.05358544f, 
    0.02540242f, -0.02355407f, -0.00228258f, -0.04501215f, -0.04629467f, 0.02865398f, 0.04444436f, -0.00074837f, 
    0.00616987f, 0.02264048f, -0.00474112f, -0.03183937f, -0.05186480f, 0.03521449f, -0.00996925f, -0.04511284f, 
    0.00896174f, -0.04671743f, -0.05474542f, -0.01726246f, -0.02914220f, 0.04273343f, 0.05223309f, -0.04650093f, 
    0.03200887f, 0.02823398f, -0.02782473f, -0.03992641f, 0.01041826f, -0.06053178f, 0.04769528f, 0.03940582f, 
    0.03066916f, 0.05045079f, -0.04164047f, -0.02715318f, -0.06277451f, -0.06187090f, -0.05377178f, -0.05341022f, 
    0.00140557f, -0.05092548f, -0.03080565f, -0.01791862f, -0.06297294f, -0.00152676f, 0.00804733f, 0.04494514f, 
    0.02545033f, -0.00644556f, -0.00763391f, 0.01392236f, -0.02646001f, -0.01951540f, 0.03136024f, 0.01129822f, 
    0.01715677f, -0.00851884f, 0.03260349f, -0.05040442f, -0.04943303f, -0.05217439f, -0.04769067f, -0.01636689f, 
    0.03554323f, 0.00734329f, -0.06008646f, -0.02867089f, 0.01207855f, -0.00503165f, 0.04973666f, 0.00786149f, 
    -0.03901667f, -0.00935419f, 0.01470184f, 0.01625252f, 0.00279833f, -0.03476114f, 0.00030491f, -0.01783167f, 
    0.03987116f, 0.02326466f, 0.00086628f, 0.00312468f, 0.04270748f, 0.04500425f, -0.01043487f, -0.01567649f, 
    0.05304020f, -0.02447213f, -0.01959590f, -0.04264637f, -0.05530376f, -0.02326466f, 0.02322324f, -0.00987286f, 
    0.04085862f, -0.03021592f, 0.02990565f, 0.03143372f, -0.02865308f, -0.00501962f, -0.04307538f, -0.00335337f, 
    -0.06429962f, -0.05547389f, 0.02328530f, -0.02301118f, 0.03246090f, 0.00715769f, -0.01381881f, 0.02197517f, 
    -0.06030036f, -0.02978082f, -0.00268932f, 0.05511510f, 0.03145649f, 0.03887389f, 0.00266517f, -0.02560135f, 
    0.00842571f, -0.04133140f, 0.02654680f, -0.01765909f, -0.01418262f, 0.01444578f, -0.00452149f, -0.01304588f, 
    0.02484899f, -0.00602183f, -0.08187369f, 0.09397105f, 0.09944668f, -0.04657265f, -0.12293405f, 0.09376261f, 
    -0.11699542f, -0.02973381f, -0.17856860f, 0.10068280f, -0.10507103f, 0.06456822f, -0.02663530f, -0.00203193f, 
    0.19808576f, -0.08333467f, -0.10744394f, -0.14285779f, 0.02350038f, -0.02766054f, 0.04188005f, 0.02903389f, 
    -0.06836401f, -0.11809236f, 0.07385980f, 0.06070268f, 0.03193037f, -0.00458246f, -0.07312811f, -0.06079158f, 
    0.09265797f, 0.17150636f, -0.00201834f, 0.07782594f, 0.05954323f, -0.16932048f, 0.02747747f, -0.06534977f, 
    0.00872571f, -0.21175310f, 0.19320749f, -0.01418165f, 0.15619746f, -0.06952745f, -0.22580622f, 0.01271350f, 
    -0.01166101f, 0.00835014f, 0.07408644f, -0.16119061f, 0.00974777f, 0.03072828f, -0.08500458f, -0.07319427f, 
    0.13704321f, 0.16491957f, -0.03180750f, 0.03014307f, -0.14122015f, 0.06680918f, -0.06889435f, 0.19951269f, 
    0.04516865f, -0.00124943f, 0.05907815f, -0.15640502f, 0.11812554f, 0.01180124f, -0.03282000f, -0.12439442f, 
    -0.32196799f, -0.03895971f, -0.14353655f, 0.01702433f, 0.02022133f, 0.13967417f, 0.08221964f, 0.03461619f, 
    0.11663506f, -0.11391670f, 0.01014653f, -0.06459948f, 0.05640027f, -0.04199212f, 0.11813541f, 0.05842066f, 
    0.16127928f, 0.10544378f, -0.02189342f, 0.08313587f, 0.06779423f, 0.02226392f, 0.06480375f, 0.05633735f, 
    -0.05846483f, 0.05654816f, 0.06190158f, -0.17391776f, -0.09594937f, 0.11809663f, -0.10547870f, -0.03381317f, 
    0.15634692f, -0.11812928f, -0.01620871f, -0.01239669f, 0.09871885f, -0.10755642f, 0.03106305f, -0.05668474f, 
    0.12596282f, 0.09995519f, 0.07931264f, -0.06356007f, 0.03529023f, 0.05618996f, -0.03691741f, 0.13763613f, 
    0.00026293f, 0.04531040f, -0.00709953f, 0.01190058f, -0.02866545f, -0.07754065f, 0.10840694f, 0.07059745f, 
    0.00644963f, -0.01642625f, -0.03779671f, -0.01570269f, -0.20734870f, 0.00330597f, -0.19216374f, -0.06059090f, 
    0.07677153f, -0.07425062f, 0.05780423f, 0.04894693f, -0.09049513f, -0.00474082f, 0.11149630f, 0.02438574f, 
    0.14054845f, -0.09232692f, 0.03215225f, -0.04569019f, -0.20720039f, -0.09235854f, -0.12559308f, -0.11002202f, 
    0.17554957f, -0.07249231f, 0.04387970f, 0.07312351f, 0.23027869f, -0.00494019f, -0.01600249f, 0.12966135f, 
    0.05433271f, -0.01373793f, 0.27808616f, 0.08334091f, 0.08846658f, 0.16420582f, 0.11167311f, -0.00807333f, 
    0.12584950f, 0.03036431f, -0.00876200f, 0.00606482f, 0.10963913f, 0.03344404f, -0.02653394f, -0.15383630f, 
    0.03289670f, -0.02886057f, 0.06658000f, -0.23754428f, 0.07331163f, -0.01759591f, -0.16791405f, 0.01751786f, 
    0.14530838f, -0.02918762f, 0.02342684f, 0.01191096f, -0.03394594f, -0.13745505f, -0.04887418f, -0.05264329f, 
    -0.08959176f, -0.08522870f, -0.03833221f, -0.01648705f, -0.06326800f, 0.03817396f, 0.07656696f, 0.12403070f, 
    0.07692850f, 0.00235187f, 0.06573378f, 0.12477882f, -0.06986620f, 0.07482335f, -0.00955879f, 0.06258684f, 
    0.12910888f, 0.08372651f, 0.21146178f, 0.08963222f, -0.09376499f, -0.03290058f, 0.13777182f, -0.03005717f, 
    0.19156909f, 0.27041516f, -0.01625157f, 0.00575420f, -0.10423938f, -0.05099242f, 0.06910922f, 0.05429897f, 
    0.00331329f, 0.05556000f, 0.14811787f, 0.07739832f, 0.03516563f, 0.02096290f, -0.00369128f, -0.18595721f, 
    -0.00965299f, -0.02731258f, 0.18538253f, 0.35402894f, 0.07924264f, -0.15664394f, 0.00856762f, 0.05866712f, 
    0.19837688f, 0.19644099f, 0.21346456f, 0.17515932f, 0.19834125f, 0.05619956f, 0.03083175f, -0.03405166f, 
    -0.00840537f, 0.15709008f, 0.03875530f, -0.10018528f, 0.09044576f, -0.41593304f, -0.07978234f, -0.29111263f, 
    0.05916991f, 0.21322972f, -0.04877656f, -0.13229172f, -0.31065425f, -0.17871018f, -0.29511818f, -0.13321963f, 
    0.18808323f, 0.01099897f, -0.01070556f, 0.01601330f, -0.08544984f, -0.01365017f, 0.12096025f, -0.21486701f, 
    -0.03974026f, -0.03805677f, -0.13325945f, -0.13717997f, 0.10348926f, 0.02572047f, 0.02847561f, -0.01020775f, 
    0.02915172f, -0.09273769f, 0.14947730f, -0.13753888f, -0.01479547f, 0.06433702f, -0.03776887f, -0.07670259f, 
    0.01596714f, 0.00774362f, 0.01124244f, -0.02472549f, -0.02322819f, 0.02926981f, 0.03617313f, -0.02964828f, 
    -0.05079311f, -0.01663156f, 0.04244149f, -0.03023771f, -0.00387397f, -0.03088169f, -0.05772310f, -0.05616032f, 
    -0.03670472f, 0.04316886f, 0.00092534f, -0.02173550f, 0.02435935f, 0.04254039f, 0.01569648f, 0.02930467f, 
    -0.06283692f, -0.05028002f, 0.01457658f, 0.01242804f, -0.00527288f, 0.00768776f, -0.01586532f, 0.05242352f, 
    -0.01990313f, -0.06460661f, -0.04382690f, -0.04671166f, 0.03062866f, -0.05355100f, -0.05351286f, -0.00119556f, 
    0.03765030f, -0.05714128f, -0.01216059f, -0.01619630f, -0.00263731f, 0.00838433f, 0.04471413f, -0.01046440f, 
    -0.04812000f, -0.03228430f, -0.03169575f, -0.00890184f, -0.04554245f, 0.02023364f, 0.04765611f, 0.04822502f, 
    0.02485508f, 0.05106611f, -0.02606099f, 0.04755774f, -0.00042614f, 0.02734446f, 0.05302091f, -0.02501626f, 
    -0.03869443f, 0.01432440f, -0.01192834f, 0.03222589f, 0.04813685f, 0.02038832f, -0.00691890f, -0.00921208f, 
    -0.02874766f, 0.02402724f, -0.05320175f, 0.01925916f, -0.00231916f, -0.04506894f, -0.01504891f, 0.01762897f, 
    -0.06345909f, -0.01882792f, -0.05587192f, -0.04444523f, 0.04585235f, -0.01712927f, -0.03529374f, 0.00642451f, 
    -0.04783117f, -0.01611898f, -0.02116046f, -0.04873928f, -0.00695498f, 0.02845520f, -0.02293636f, 0.01911298f, 
    -0.05880424f, -0.06362040f, -0.02249959f, -0.05564838f, -0.02562010f, -0.05078495f, 0.02149106f, -0.03308644f, 
    -0.04674137f, -0.05492286f, 0.01642429f, 0.03691333f, 0.04692399f, -0.02731765f, -0.03554635f, 0.02856539f, 
    -0.00571221f, -0.00717037f, -0.03468000f, 0.02298678f, 0.02492418f, 0.03111629f, 0.04228159f, -0.04514181f, 
    -0.01982139f, -0.03767369f, -0.03094509f, -0.04553314f, 0.04836930f, -0.01594560f, 0.02557927f, 0.04664909f, 
    -0.03628939f, -0.01159426f, -0.01494112f, 0.03139511f, 0.04724206f, 0.04565924f, -0.02061693f, -0.04177520f, 
    0.03636382f, 0.02626675f, -0.02410348f, -0.04880838f, 0.03434538f, -0.03739807f, 0.04307216f, -0.05934105f, 
    -0.05145472f, 0.02181035f, -0.02136269f, -0.01313660f, 0.01226707f, -0.03703418f, 0.01387415f, -0.01668918f, 
    0.04992727f, 0.00124428f, -0.02487856f, -0.02515609f, -0.03907712f, 0.01590779f, 0.00148591f, 0.02931520f, 
    -0.02485982f, 0.00137970f, -0.02418421f, -0.00892829f, 0.01054370f, -0.06468662f, 0.03898075f, 0.05270532f, 
    0.03696686f, 0.03842771f, 0.00518016f, -0.00982849f, -0.02170383f, -0.00849961f, -0.05385594f, -0.04054154f, 
    -0.01695272f, 0.02563279f, 0.03859148f, -0.03411748f, -0.05323084f, 0.03372757f, -0.00739789f, -0.04474163f, 
    -0.02716617f, -0.04154585f, -0.02316573f, -0.04224668f, -0.03319724f, 0.03021265f, 0.03564222f, 0.01219272f, 
    -0.01499984f, -0.05225335f, 0.00508323f, 0.05280726f, -0.02857450f, -0.05337965f, 0.00066515f, 0.00309533f, 
    -0.04498612f, -0.01334462f, -0.03385108f, -0.02170162f, 0.00885341f, -0.00441081f, 0.00924309f, -0.05086885f, 
    0.02993788f, -0.04072163f, -0.04709366f, 0.00115226f, 0.04529540f, 0.01343028f, 0.03972529f, 0.02237699f, 
    0.03109247f, -0.03214198f, -0.00844562f, 0.01978519f, -0.01332413f, -0.06086816f, 0.03517137f, 0.04701949f, 
    -0.03349972f, -0.01709291f, 0.01549442f, -0.02137415f, -0.03757841f, -0.00201389f, -0.04884066f, 0.00054652f, 
    -0.02053701f, 0.03383710f, 0.02690814f, 0.01389024f, 0.02065915f, -0.00877427f, -0.03533522f, 0.00595024f, 
    -0.03659274f, -0.05263129f, 0.00164238f, -0.04473938f, -0.06130354f, -0.04234388f, 0.00592941f, 0.00507273f, 
    0.01937965f, -0.01266976f, -0.00687557f, -0.00930054f, 0.01891002f, 0.00750508f, 0.02357271f, 0.01394797f, 
    0.03245540f, -0.00036517f, 0.03412278f, 0.04653430f, 0.04532452f, -0.00041731f, -0.00975218f, 0.01034506f, 
    0.01227105f, -0.02699205f, 0.04558954f, 0.01872851f, 0.03011266f, 0.00919401f, -0.02509317f, 0.05023477f, 
    -0.00744449f, -0.04427262f, 0.03596710f, 0.05184761f, 0.03209563f, -0.05284754f, 0.02056621f, -0.05014566f, 
    -0.02505220f, -0.04213224f, -0.04948070f, -0.03482267f, 0.01397639f, 0.01724358f, 0.00570977f, -0.00207749f, 
    -0.00759691f, -0.42888623f, -0.07954875f, 0.06743564f, 0.12382727f, 0.00635343f, 0.04346963f, 0.04020551f, 
    -0.08160117f, -0.00051171f, -0.22182812f, 0.02583496f, -0.00122902f, -0.02293552f, 0.16609934f, 0.01946935f, 
    0.01841985f, -0.03013622f, -0.14791043f, 0.07460319f, 0.12082408f, 0.11609157f, 0.00084058f, 0.00743623f, 
    -0.07042062f, -0.03783735f, 0.07326460f, 0.01668247f, -0.20360252f, -0.04897584f, 0.08807406f, 0.08339812f, 
    0.06208037f, 0.03750428f, 0.01994809f, -0.02241047f, -0.32691813f, -0.07278061f, 0.03246510f, -0.00280513f, 
    -0.20790967f, -0.03118420f, 0.07802021f, -0.03613177f, -0.03160706f, -0.21687953f, 0.10492325f, -0.05954657f, 
    0.09762269f, -0.06759536f, 0.07899258f, 0.03443380f, 0.14968349f, -0.03743150f, -0.17282213f, 0.23229054f, 
    -0.00611654f, -0.00077950f, -0.04452053f, -0.07406921f, -0.15372722f, 0.00860485f, -0.06461249f, -0.03013749f, 
    -0.19685318f, 0.00568856f, 0.08852304f, 0.08979563f, 0.08670200f, -0.00841479f, 0.01591847f, 0.03830968f, 
    0.01663332f, 0.06720033f, -0.13951133f, 0.05780765f, -0.12563707f, -0.07003728f, 0.07890336f, -0.02718620f, 
    0.09776665f, 0.00034508f, 0.32162398f, 0.26002553f, -0.02641119f, -0.05577649f, -0.14768329f, -0.01039748f, 
    0.04144976f, 0.18855688f, 0.20117855f, -0.15868226f, 0.09439488f, 0.06714608f, -0.05205253f, 0.00115484f, 
    0.07219410f, -0.07076015f, 0.10044405f, -0.03489803f, -0.01163054f, 0.12606236f, 0.01294597f, 0.05873801f, 
    0.00918705f, -0.10477140f, -0.03782572f, 0.13103136f, -0.17696314f, -0.03169989f, -0.06780141f, 0.04816469f, 
    0.03798926f, 0.12681068f, 0.06999415f, -0.05299900f, 0.17681913f, -0.38755393f, 0.08882271f, -0.20444915f, 
    0.06777841f, 0.13563788f, 0.12892464f, -0.02357494f, -0.04574988f, 0.02449595f, -0.40036431f, 0.02801134f, 
    -0.07399336f, 0.11105619f, 0.11929055f, 0.15291369f, -0.12890580f, -0.02616520f, -0.00974826f, -0.11227667f, 
    -0.04713793f, -0.19813004f, 0.24409431f, -0.01625174f, -0.06271175f, 0.03514807f, 0.01129490f, 0.04014650f, 
    -0.53119463f, -0.18596405f, -0.28460029f, 0.17947860f, -0.05854003f, -0.06548781f, -0.01158299f, -0.07392835f, 
    0.02053498f, 0.20485315f, 0.42789459f, 0.01597993f, 0.08493260f, 0.00583436f, 0.14011306f, 0.10590243f, 
    0.10936221f, -0.15866159f, 0.16690378f, -0.04734541f, -0.09152016f, 0.03627763f, 0.03979807f, 0.07734324f, 
    0.05127968f, 0.01263441f, -0.04468165f, -0.04110055f, -0.13453501f, 0.02465358f, -0.00559274f, -0.01332474f, 
    0.23251721f, -0.06316833f, -0.02462759f, 0.01680189f, -0.13032150f, -0.06627031f, -0.03093643f, -0.10174695f, 
    0.02035111f, -0.00484244f, 0.20468567f, -0.01701134f, 0.01108803f, 0.18070358f, 0.03325844f, 0.19116268f, 
    -0.05129182f, -0.05179669f, -0.17195113f, 0.00563889f, -0.05484913f, -0.01670929f, -0.15298820f, 0.07079107f, 
    -0.01075838f, 0.08664803f, 0.14029491f, 0.00920679f, -0.01322101f, 0.02126244f, -0.03751853f, -0.21260913f, 
    0.18535884f, 0.21060669f, 0.10966455f, 0.07273111f, -0.13427962f, 0.14510934f, -0.02728531f, -0.01206222f, 
    -0.19861598f, -0.18296129f, -0.00437414f, -0.05237129f, -0.16994867f, 0.18678071f, 0.04932105f, -0.03047254f, 
    0.15354015f, -0.10618351f, -0.15179919f, -0.21362515f, 0.05716155f, 0.12613332f, -0.02112138f, -0.08507588f, 
    -0.03006875f, -0.06374467f, 0.24759831f, 0.46311834f, 0.23365119f, 0.09133679f, -0.09943397f, -0.03650439f, 
    0.00730274f, 0.10205358f, -0.00924457f, 0.25613606f, 0.01171794f, 0.10310550f, -0.05079565f, 0.15389192f, 
    -0.05802081f, 0.03839275f, 0.00417129f, -0.06496862f, 0.05622218f, -0.21414566f, -0.26828706f, 0.03155909f, 
    -0.01062584f, 0.09591451f, -0.05114525f, -0.02070503f, 0.01795055f, 0.11399853f, 0.00356909f, -0.00854354f, 
    0.04064446f, -0.06928872f, 0.07356800f, -0.12251043f, -0.04620899f, -0.01142496f, 0.23553605f, -0.32916424f, 
    -0.23438008f, -0.02171147f, -0.18907002f, -0.14226592f, 0.10699818f, -0.08580542f, 0.15180303f, -0.06168737f, 
    -0.07163243f, -0.01712137f, -0.09814641f, 0.06760306f, -0.06940953f, -0.09724934f, 0.08960015f, 0.04186206f, 
    -0.03021801f, 0.02405321f, -0.03514564f, 0.03135820f, -0.01880171f, 0.03244523f, -0.04303942f, -0.02616842f, 
    0.00801193f, 0.00857965f, 0.00859489f, 0.04242771f, -0.05091057f, -0.04267161f, 0.02984885f, 0.05311235f, 
    0.02961119f, -0.01102149f, 0.00158634f, -0.05502214f, 0.01985031f, 0.03958565f, 0.03567486f, -0.01378474f, 
    0.02062692f, -0.05444822f, -0.04284680f, -0.00438011f, -0.00836307f, 0.03694772f, -0.04246161f, -0.00577433f, 
    0.01664099f, -0.05655369f, 0.03632831f, 0.04218331f, -0.04295143f, -0.01161306f, 0.01425568f, 0.04192458f, 
    0.01762143f, 0.04866111f, 0.02157192f, 0.02773776f, -0.03400154f, 0.02565312f, 0.01884671f, -0.00999326f, 
    -0.03408980f, -0.03697440f, 0.00702651f, -0.03776509f, -0.03342073f, -0.06007911f, -0.00851871f, 0.01377076f, 
    -0.04918210f, -0.02388855f, -0.01806088f, 0.01253425f, -0.02744928f, 0.02070561f, 0.02165418f, 0.00873426f, 
    -0.06121384f, 0.02007265f, -0.00069674f, -0.03743099f, -0.03124907f, -0.02212189f, 0.03274180f, 0.01629941f, 
    -0.04275427f, -0.00718050f, 0.00014805f, -0.05783986f, -0.01597899f, -0.00582975f, -0.00782488f, -0.02743858f, 
    0.04834430f, 0.03348980f, -0.00042042f, -0.03567035f, 0.00862540f, -0.05839353f, -0.06256741f, -0.04459256f, 
    -0.03652171f, -0.05044232f, -0.01536406f, 0.04613506f, -0.04749246f, -0.03473856f, -0.03917688f, -0.06902028f, 
    -0.00476089f, -0.03739368f, -0.02332087f, 0.04280271f, -0.02659511f, 0.00900000f, -0.06467731f, -0.04066683f, 
    -0.00818492f, -0.05685940f, 0.00377030f, -0.03347098f, -0.03610981f, -0.01981546f, -0.06155652f, 0.03870206f, 
    0.01010678f, 0.01600176f, -0.03498526f, -0.03976522f, -0.03780302f, -0.03761830f, 0.04959292f, -0.00493470f, 
    -0.02198709f, -0.03466550f, 0.04123229f, 0.04112948f, -0.00652145f, -0.02336924f, -0.06622390f, -0.01144483f, 
    0.04429885f, 0.01407674f, 0.00704061f, 0.02605585f, -0.00926301f, -0.02072435f, 0.02721554f, -0.04848247f, 
    -0.03220780f, -0.07030347f, -0.00733498f, 0.05511604f, -0.01378561f, -0.06564075f, -0.03365014f, -0.02030803f, 
    0.01330937f, 0.00705546f, 0.03332127f, -0.02186339f, 0.02157944f, 0.01689217f, -0.04642652f, 0.04748717f, 
    0.01660810f, -0.01777438f, 0.02130749f, -0.00441782f, 0.01736640f, -0.05225832f, 0.05716086f, -0.03883628f, 
    -0.04117287f, -0.04773708f, 0.00399470f, -0.05688957f, 0.05390612f, -0.05063853f, 0.03892584f, -0.06064046f, 
    -0.03457144f, 0.00616497f, 0.00666565f, 0.01844196f, -0.03825595f, -0.04189244f, 0.02639747f, 0.02042425f, 
    -0.01684147f, -0.05470551f, -0.01455242f, -0.04906657f, -0.06511737f, 0.02995200f, -0.01412662f, -0.00179608f, 
    -0.05199349f, 0.04301030f, 0.04099337f, -0.03943487f, 0.04479658f, 0.04971943f, -0.04621435f, 0.00565253f, 
    0.02460668f, -0.04178711f, 0.01282688f, 0.04875602f, -0.03260216f, -0.02685806f, -0.04915523f, 0.04430876f, 
    0.02426449f, 0.05198171f, 0.00905530f, 0.03579744f, 0.01882129f, 0.02313003f, 0.02389835f, 0.00064756f, 
    0.03912778f, -0.05996727f, -0.06429275f, -0.01742849f, -0.03838428f, 0.02349332f, -0.04346073f, -0.01795775f, 
    -0.03299640f, -0.03178807f, -0.06263001f, 0.00286829f, -0.03365560f, -0.03802308f, 0.03042366f, 0.04220149f, 
    0.03339868f, 0.01861531f, 0.00330381f, -0.03798541f, 0.01334002f, -0.05882893f, 0.02935344f, 0.00813043f, 
    -0.03769861f, 0.02786196f, 0.04610564f, -0.03825663f, 0.01303376f, 0.04662855f, -0.05758886f, 0.03315122f, 
    -0.06430987f, -0.00255437f, -0.04361192f, -0.02999836f, -0.03060577f, -0.06245416f, -0.04875728f, -0.04640716f, 
    -0.03924585f, 0.00473237f, 0.00750586f, 0.02416998f, -0.02705159f, 0.01685268f, -0.00381883f, 0.03095516f, 
    0.03156438f, -0.00089131f, -0.03846965f, -0.04241682f, -0.01328470f, -0.01924019f, -0.05161355f, -0.03658847f, 
    0.02628293f, -0.02126211f, 0.01609215f, 0.00086765f, -0.05337595f, -0.02969089f, -0.03748398f, 0.00831094f, 
    0.00028924f, 0.00062374f, -0.07140008f, -0.00668574f, 0.02050759f, 0.05677632f, -0.02367914f, 0.05180018f, 
    0.02607654f, -0.03094340f, -0.05930793f, -0.04597325f, 0.00953902f, 0.03346703f, -0.00489209f, -0.05341369f, 
    0.04938586f, -0.03892975f, 0.02318729f, -0.01449534f, -0.04702235f, 0.00555397f, -0.03077212f, -0.05105668f, 
    -0.04324752f, -0.02341309f, -0.05410273f, 0.04273457f, -0.05631651f, -0.00716808f, 0.02703616f, 0.02427828f, 
    -0.05004407f, -0.01455659f, 0.04142186f, 0.03674533f, 0.00527538f, 0.00371664f, 0.03893632f, 0.02127267f, 
    0.03126614f, -0.02498945f, -0.02424984f, -0.05161879f, -0.02300442f, 0.02224719f, -0.01921737f, -0.01365795f, 
    0.02008617f, 0.01970708f, -0.03542913f, 0.00749308f, -0.01970632f, -0.00537685f, 0.01570082f, -0.05288517f, 
    0.04123789f, -0.03126176f, -0.03863192f, 0.01183202f, 0.04660256f, 0.01402397f, -0.02498008f, -0.01060546f, 
    0.03972606f, -0.02008273f, -0.01546104f, 0.02671122f, -0.05662900f, -0.03648334f, -0.04440119f, -0.02248210f, 
    0.04053964f, 0.04146038f, 0.02872155f, -0.03990414f, -0.01299153f, -0.05035334f, -0.01348374f, -0.03767316f, 
    0.05051693f, -0.05592810f, -0.04251159f, -0.03248177f, -0.01470044f, 0.00200159f, -0.05359988f, -0.06145003f, 
    -0.02551410f, -0.02602032f, -0.02581061f, -0.02377235f, -0.01578830f, -0.03593300f, 0.03131694f, 0.04619667f, 
    0.00487597f, 0.03511070f, 0.04198129f, -0.01753060f, 0.01672539f, 0.03294803f, -0.00097686f, -0.05063690f, 
    0.05352575f, -0.00339707f, -0.04450010f, 0.02247786f, -0.05645534f, -0.02761064f, 0.03415469f, -0.05993938f, 
    0.04702138f, 0.00792024f, -0.00860522f, -0.02036535f, -0.04064053f, 0.00077110f, 0.04849852f, -0.02703665f, 
    0.00617089f, 0.01522379f, -0.02122770f, 0.00505624f, -0.00140047f, 0.01609092f, -0.03662268f, 0.00186794f, 
    0.00107753f, -0.03540985f, -0.04580493f, -0.04610425f, -0.05158804f, -0.06098417f, -0.05052587f, -0.04439090f, 
    -0.06438121f, 0.06671135f, 0.03723409f, -0.05885123f, -0.05267537f, -0.06091067f, -0.04706502f, 0.02101491f, 
    -0.00144431f, 0.00293476f, -0.03521375f, -0.04853435f, -0.04625995f, -0.00277581f, -0.02267508f, -0.06185262f, 
    -0.03447946f, 0.00100539f, 0.01553227f, 0.02541501f, 0.02085313f, 0.02697454f, -0.05577441f, -0.00471034f, 
    -0.05102154f, 0.04761073f, -0.02882864f, 0.00051124f, -0.03189424f, -0.03449002f, 0.04933956f, -0.03613446f, 
    -0.00463290f, -0.03396921f, -0.06716564f, 0.00696737f, -0.01342689f, 0.03441945f, 0.03852420f, -0.00445085f, 
    0.01886099f, 0.00899366f, 0.04197039f, -0.04805791f, -0.00378229f, 0.02156878f, -0.01708278f, 0.02861097f, 
    -0.05002835f, 0.00157972f, 0.01433299f, 0.00000258f, -0.01033671f, 0.02506642f, 0.00056230f, -0.01801545f, 
    -0.05860250f, 0.03961214f, 0.04322161f, -0.04416437f, 0.01813488f, 0.00721846f, 0.00260438f, -0.03330988f, 
    -0.01469531f, 0.02014088f, -0.02315984f, 0.04689398f, -0.06417418f, -0.05319442f, 0.01133851f, -0.04602584f, 
    -0.03154739f, -0.02239833f, -0.01768150f, 0.03770434f, -0.04042981f, 0.04243650f, 0.02929946f, -0.01566216f, 
    -0.03654784f, 0.00799099f, 0.00168793f, -0.04161576f, 0.03634497f, 0.01798125f, 0.02795964f, -0.01449519f, 
    0.02016890f, -0.04014973f, 0.00655688f, -0.05357090f, 0.02125029f, -0.02944037f, 0.00345042f, -0.03328258f, 
    -0.06516332f, -0.04008164f, 0.01919454f, 0.04118615f, 0.00766918f, -0.02030817f, 0.01819672f, 0.02118292f, 
    0.00723360f, -0.02250092f, -0.02458325f, 0.04964642f, 0.01026382f, -0.03054177f, 0.04051339f, -0.00257195f, 
    0.03522120f, 0.00849225f, -0.03270974f, -0.01087916f, 0.04399742f, -0.03955660f, 0.00690211f, -0.00670762f, 
    0.05318198f, -0.05975055f, 0.03227418f, -0.01949241f, 0.00493716f, 0.01220293f, -0.01722553f, 0.05537656f, 
    -0.03799143f, 0.02428189f, 0.02638992f, -0.03330749f, 0.03552706f, 0.03461400f, -0.06097102f, -0.02059809f, 
    0.02011449f, -0.01480281f, -0.02206278f, -0.00688910f, -0.04316655f, 0.00027074f, -0.01098801f, -0.02927173f, 
    -0.02358224f, 0.01613420f, 0.02801532f, 0.03093153f, 0.02050680f, 0.00301630f, -0.03134907f, 0.01845947f, 
    -0.01080879f, -0.00441976f, 0.02528178f, -0.00846006f, -0.00169106f, -0.05129024f, 0.00652779f, 0.01372811f, 
    -0.04488979f, -0.06120543f, 0.03973648f, -0.04956372f, 0.02694131f, 0.02397072f, -0.00193667f, -0.04715746f, 
    0.00938075f, 0.02314391f, -0.05884467f, 0.03998227f, -0.03074987f, -0.04029356f, 0.03506036f, 0.00698415f, 
    -0.01122403f, -0.05269038f, -0.06121049f, 0.02673577f, -0.01547423f, -0.04418774f, -0.04447647f, 0.01835204f, 
    -0.03070921f, -0.05689096f, -0.04313101f, 0.05045258f, -0.04113673f, -0.03811643f, -0.02496997f, 0.02178767f, 
    -0.04596503f, 0.03955635f, -0.00159132f, 0.00669478f, -0.05829768f, -0.01857425f, -0.03791194f, 0.04617166f, 
    0.03119194f, -0.01705900f, 0.03344321f, -0.02066826f, 0.01120760f, 0.01765492f, 0.00185949f, 0.01436153f, 
    0.00652680f, -0.05591722f, 0.03743303f, -0.01014554f, -0.06320349f, 0.01102501f, 0.01337970f, -0.05080653f, 
    -0.00249105f, 0.01657460f, 0.02264853f, 0.02324374f, -0.03530974f, -0.04409098f, -0.01693217f, -0.04707772f, 
    -0.05040951f, -0.05040070f, 0.05247214f, 0.02874205f, 0.02480914f, -0.02150946f, -0.05094837f, 0.02421363f, 
    -0.05390027f, 0.02570382f, -0.05155801f, 0.05248006f, 0.01388970f, 0.03912749f, 0.02910337f, -0.00823761f, 
    -0.03253823f, 0.04395453f, -0.03818471f, 0.03900714f, 0.00620759f, -0.03640724f, -0.00360166f, -0.03972366f, 
    -0.03256561f, 0.03224151f, 0.02088329f, -0.04936622f, 0.04311401f, -0.00909740f, 0.04821895f, -0.01182870f, 
    -0.02888459f, -0.02318488f, 0.02327777f, -0.00301641f, 0.01474579f, -0.02260658f, -0.04346433f, 0.02486065f, 
    -0.04520268f, -0.05924802f, -0.04399636f, -0.01565871f, 0.03530819f, 0.01047857f, -0.05542771f, -0.05340456f, 
    0.00219109f, -0.05103095f, -0.06334758f, 0.01047262f, -0.01130635f, 0.03492690f, 0.04527858f, -0.03143339f, 
    0.04420674f, -0.01041092f, -0.04892425f, 0.01410245f, 0.04049346f, -0.06104911f, -0.01131824f, -0.02502610f, 
    0.00055778f, -0.03709725f, -0.04657947f, -0.02805574f, -0.06534799f, -0.05971644f, -0.04894951f, -0.04394745f, 
    -0.03406501f, 0.04721887f, 0.01185020f, -0.01477824f, -0.04895256f, -0.05566017f, 0.02023827f, 0.01137439f, 
    -0.05223072f, 0.00441010f, 0.04880165f, 0.03964370f, -0.02919068f, 0.01914425f, 0.04732952f, 0.04697954f, 
    -0.03226364f, -0.05985567f, 0.03792174f, -0.03746467f, 0.02783878f, -0.04983209f, -0.02877725f, -0.02738108f, 
    -0.01168512f, 0.05735511f, 0.05210276f, -0.00954244f, -0.03105230f, 0.00986752f, 0.01142082f, 0.00299441f, 
    0.01296325f, -0.03323383f, -0.03115571f, -0.02580204f, -0.03123342f, 0.03667936f, -0.02294286f, -0.02612936f, 
    -0.00592105f, -0.05882354f, -0.05899971f, -0.05839482f, -0.02202702f, -0.00823385f, 0.04601726f, 0.02996055f, 
    -0.04496857f, -0.01217131f, 0.02980232f, -0.02153523f, 0.04775807f, 0.00890094f, 0.05363402f, -0.00451529f, 
    0.05113047f, -0.02929263f, -0.05199777f, 0.02700562f, -0.02046646f, -0.05973259f, -0.02881123f, -0.00758225f, 
    -0.03144512f, -0.02449401f, -0.02774719f, -0.04217765f, 0.00653774f, 0.04767205f, -0.01816061f, -0.03484579f, 
    -0.01091123f, 0.04777091f, -0.06162526f, -0.01255788f, 0.03520827f, 0.01591655f, 0.01950907f, 0.03510255f, 
    -0.00015433f, 0.00832628f, 0.01962826f, 0.01730836f, -0.03597633f, 0.01931076f, -0.05669437f, 0.01561126f, 
    0.04944954f, -0.01260242f, -0.00794949f, 0.01951372f, -0.01691355f, 0.03840843f, -0.02198251f, -0.04932543f, 
    0.00602126f, 0.05177512f, -0.06258320f, 0.04845591f, 0.04047989f, -0.01883033f, -0.00777007f, -0.00468564f, 
    -0.04746059f, -0.00790707f, -0.05775837f, 0.01956026f, 0.01663844f, 0.00070696f, -0.00803047f, -0.03956826f, 
    -0.01310923f, 0.01404581f, -0.00502578f, 0.04898772f, -0.01218839f, -0.04085729f, 0.04661925f, 0.02038145f, 
    -0.01145561f, -0.00646282f, -0.00247013f, -0.04868893f, -0.00452364f, 0.02908504f, -0.05209370f, 0.00117897f, 
    0.01450538f, -0.06265686f, -0.03289963f, -0.02810954f, 0.01415043f, -0.04617921f, 0.02619854f, -0.05879969f, 
    -0.04151504f, 0.03488149f, -0.01242338f, 0.04324479f, -0.00988510f, -0.04834671f, -0.00680638f, 0.01620303f, 
    -0.02815877f, 0.02482970f, 0.04904291f, 0.02976621f, 0.01212403f, 0.04234165f, 0.02858051f, 0.02583279f, 
    0.01757551f, -0.04234287f, -0.02941629f, -0.04600806f, 0.01089421f, -0.01209725f, -0.03678759f, -0.02575648f, 
    -0.01348937f, -0.01676976f, -0.06684919f, 0.02921353f, -0.05369915f, -0.06618810f, -0.03608762f, -0.04308278f, 
    0.00571915f, -0.01442574f, -0.05133109f, 0.00104363f, -0.01541623f, -0.04749499f, 0.05215400f, -0.00901506f, 
    -0.04154782f, -0.04021876f, 0.00570574f, 0.00221880f, 0.00871293f, 0.00159343f, -0.04324473f, -0.03425737f, 
    0.02079144f, 0.01776737f, -0.00624637f, -0.00598437f, -0.07288671f, -0.02905063f, 0.01599498f, -0.06891488f, 
    0.02049132f, 0.00189877f, -0.03196324f, -0.05702660f, -0.03579642f, -0.06832048f, -0.05885840f, -0.00011067f, 
    -0.05777142f, -0.06985809f, -0.06729099f, -0.01618917f, -0.05076367f, -0.05453346f, 0.03667058f, -0.01161681f, 
    -0.02891803f, -0.04181489f, 0.06438123f, -0.00350477f, 0.01124358f, -0.02867792f, 0.01352658f, 0.01270334f, 
    0.00964614f, -0.03878520f, -0.03546965f, 0.03956004f, 0.02291460f, 0.00959059f, -0.00742855f, -0.00046068f, 
    -0.01235231f, -0.01308212f, -0.04803190f, -0.02918117f, -0.04176532f, -0.06589402f, 0.02063070f, 0.02655216f, 
    0.04784346f, 0.00338436f, -0.02947933f, 0.00070118f, -0.02710010f, 0.02024759f, -0.03716588f, -0.01344689f, 
    0.02666328f, -0.05994727f, -0.02235121f, -0.01888404f, -0.05734402f, -0.05993564f, -0.00117744f, -0.03342262f, 
    0.03169794f, 0.04485971f, -0.05314935f, -0.06193241f, 0.02595852f, -0.05181779f, -0.00103784f, -0.02736438f, 
    -0.03392389f, 0.01678012f, 0.01113135f, 0.00976186f, 0.01860213f, 0.02399065f, -0.04158041f, -0.04942761f, 
    0.03876687f, 0.02875528f, -0.05334171f, -0.02693540f, -0.03787960f, 0.01605219f, -0.03577054f, 0.01522656f, 
    0.00773617f, 0.04367734f, -0.07125323f, 0.02910877f, 0.02991110f, 0.01777305f, 0.04586805f, 0.02120366f, 
    -0.03105337f, -0.06392213f, -0.02785023f, -0.03518056f, -0.04008742f, -0.04516298f, -0.04096979f, 0.03716199f, 
    -0.06571816f, 0.02284652f, -0.05688716f, -0.00001694f, 0.01365033f, -0.01624528f, -0.02035081f, 0.00513698f, 
    0.01710425f, 0.03694577f, -0.00044392f, -0.03787447f, 0.02120807f, 0.03096511f, 0.02414537f, 0.00968833f, 
    -0.03182557f, -0.07467777f, 0.02745226f, 0.04866806f, -0.05481811f, -0.01529540f, 0.02777507f, -0.01302169f, 
    0.02294397f, 0.04169011f, -0.05144331f, 0.02066494f, -0.00190484f, -0.00142365f, 0.01315972f, 0.04897473f, 
    -0.04421494f, 0.00018132f, -0.06136380f, -0.03245554f, -0.04927269f, 0.04266520f, -0.03294972f, -0.03443966f, 
    -0.05954795f, -0.02587872f, -0.05810001f, -0.00429971f, -0.00114507f, -0.03710494f, -0.05718473f, 0.05217471f, 
    0.03360505f, -0.03211880f, -0.05116747f, -0.07410087f, -0.04847806f, 0.01322532f, -0.00931320f, -0.03857649f, 
    0.02679045f, -0.01982829f, -0.03215281f, -0.04933510f, 0.04169793f, -0.01805300f, 0.02752143f, -0.04331949f, 
    -0.01338660f, -0.02750225f, -0.01748733f, -0.02757585f, -0.05059989f, -0.05404910f, 0.02596358f, 0.02617583f, 
    -0.03692760f, -0.06791157f, 0.04358287f, 0.01954815f, -0.05938186f, -0.02945317f, -0.01345162f, -0.05401811f, 
    -0.03087763f, -0.03707708f, -0.03013007f, 0.03778254f, -0.02888613f, 0.02912501f, -0.02346148f, -0.01563340f, 
    -0.04290689f, 0.01203855f, -0.03520101f, -0.01856365f, 0.01644860f, 0.00350971f, -0.02642644f, -0.05395369f, 
    0.00617879f, -0.03070557f, -0.02107408f, -0.01269495f, -0.02874300f, -0.05486253f, -0.03205187f, -0.06545506f, 
    -0.04309814f, 0.02883652f, -0.01144748f, 0.03688905f, -0.04105062f, 0.00100932f, -0.04345817f, 0.03039983f, 
    -0.02492729f, -0.04943420f, -0.01087340f, 0.01273384f, 0.01779386f, 0.01779333f, -0.06259831f, -0.04251572f, 
    0.03096464f, 0.03530167f, 0.00318433f, -0.00992738f, 0.03079504f, -0.02682196f, -0.03116669f, -0.01023083f, 
    0.04851247f, -0.04001104f, -0.03442515f, 0.00034626f, -0.04025718f, -0.01421165f, 0.03117839f, -0.00018886f, 
    -0.05741686f, 0.01015187f, -0.05509838f, -0.04394742f, -0.05745133f, -0.01064894f, -0.03786957f, -0.05656933f, 
    -0.00735680f, 0.04248722f, 0.03315963f, -0.02922043f, 0.03950752f, -0.07760573f, 0.05158261f, 0.04440442f, 
    -0.01778335f, -0.04133259f, -0.03716839f, -0.01530191f, -0.05825970f, 0.05532360f, 0.03445021f, 0.04436988f, 
    0.24513142f, 0.16534838f, -0.16898876f, -0.04231431f, -0.27643251f, -0.03995170f, 0.04176414f, 0.00016738f, 
    0.09224480f, 0.49395522f, 0.10604025f, 0.17230110f, -0.01663784f, -0.15731576f, 0.06083655f, 0.05762633f, 
    -0.10960761f, -0.05537358f, -0.05629550f, -0.17464367f, -0.22586355f, -0.06975417f, -0.01645289f, -0.00785134f, 
    0.03047757f, 0.02787639f, -0.10814882f, -0.08671816f, 0.08862504f, -0.13337255f, 0.05888546f, 0.05870401f, 
    -0.03785021f, -0.02782891f, 0.05668364f, -0.11025345f, -0.07773522f, -0.02342957f, -0.04001853f, -0.09962090f, 
    0.17862891f, 0.02386920f, 0.07559095f, 0.04193413f, -0.26753819f, 0.00235705f, -0.13480745f, -0.17553706f, 
    -0.10394002f, 0.07849504f, -0.11178898f, -0.00485102f, 0.03806540f, 0.10821421f, -0.01282055f, -0.06223583f, 
    -0.20974952f, 0.01435409f, 0.08733141f, -0.03602004f, 0.14733942f, -0.10842236f, -0.05278561f, -0.15379976f, 
    0.23739986f, 0.24419843f, 0.02851145f, 0.12980050f, 0.13919204f, -0.11088739f, -0.02779156f, -0.09486384f, 
    -0.08387700f, 0.09747645f, 0.06034251f, -0.12211528f, 0.09299865f, 0.06088708f, -0.01478156f, -0.09233138f, 
    -0.03300204f, 0.05233238f, 0.05096054f, -0.05040178f, 0.07817141f, 0.03717707f, 0.13993779f, -0.12277172f, 
    0.18973605f, -0.17604046f, -0.02137773f, -0.00057984f, -0.08090238f, -0.04299700f, -0.01816948f, -0.06125745f, 
    -0.03834641f, 0.00554928f, -0.12699306f, 0.04462380f, -0.24793923f, -0.05809975f, 0.00819989f, -0.07560132f, 
    0.08816230f, -0.06589232f, -0.08012606f, 0.02293641f, -0.04159686f, -0.06766722f, -0.06312443f, -0.09187097f, 
    -0.03805454f, -0.03320786f, -0.08420535f, -0.01736416f, -0.18099351f, 0.16964819f, 0.06847312f, 0.09218307f, 
    0.03272844f, 0.01747309f, -0.04509075f, -0.05301058f, -0.08035964f, 0.02943892f, 0.37232992f, 0.25530899f, 
    -0.04993707f, -0.21777171f, -0.19115907f, -0.17227727f, 0.12940487f, 0.00042835f, 0.10884278f, -0.11239614f, 
    0.01883128f, 0.03679241f, -0.18162431f, 0.14040181f, 0.15634799f, 0.03846484f, 0.16535366f, -0.04557936f, 
    0.04465077f, 0.00143048f, -0.32047141f, -0.21298198f, -0.02584234f, 0.14536574f, -0.00292805f, -0.12558694f, 
    0.08204556f, -0.16984029f, 0.13535067f, 0.06329101f, 0.04152808f, 0.08744828f, -0.07352092f, -0.12123077f, 
    0.03197684f, 0.06323031f, 0.18672170f, 0.15605649f, 0.14662443f, 0.05782100f, 0.08202218f, -0.04839331f, 
    0.07763199f, 0.11918237f, 0.21495542f, -0.10795826f, 0.01278678f, -0.01978397f, -0.06682276f, 0.03102772f, 
    -0.18682912f, 0.07113865f, -0.05575144f, -0.09471099f, -0.05704632f, 0.06609090f, -0.10985848f, 0.00169456f, 
    0.05971659f, -0.08556575f, 0.05361135f, -0.15451811f, 0.00488259f, 0.02252584f, -0.03334302f, 0.09155824f, 
    0.10922699f, -0.02933971f, -0.17883250f, -0.05837245f, 0.02259723f, -0.02879901f, -0.12297744f, 0.04752069f, 
    0.00507812f, -0.00450579f, -0.06257354f, -0.12938771f, -0.11186755f, 0.03571089f, 0.20946749f, 0.54419380f, 
    -0.07488292f, 0.07226797f, 0.16383198f, 0.02658424f, 0.08107589f, -0.03483247f, 0.05645720f, 0.03172693f, 
    0.20506772f, 0.05956175f, -0.13444468f, -0.20373149f, 0.05576423f, 0.07383310f, -0.12856579f, 0.08291155f, 
    -0.06948549f, -0.11038164f, 0.20305723f, 0.15191795f, -0.21246247f, -0.00502340f, 0.01237670f, -0.06050256f, 
    -0.07159966f, 0.01348578f, 0.02507700f, 0.03916437f, 0.16946900f, 0.29263258f, -0.01020677f, 0.05522301f, 
    0.09005389f, 0.11273450f, 0.06826276f, -0.05308838f, 0.03166254f, 0.11673201f, 0.00381226f, -0.00625857f, 
    -0.01825264f, -0.08395755f, 0.16488297f, 0.02569216f, 0.06590587f, 0.15346844f, -0.13973083f, -0.05936194f, 
    -0.19358170f, -0.21473132f, 0.03682481f, -0.00593799f, 0.06605460f, -0.04451647f, -0.23463263f, -0.25162700f, 
    0.00792296f, -0.11319847f, 0.07253585f, -0.02617196f, -0.02994912f, -0.06640533f, -0.12437624f, 0.28361619f, 
    -0.01154224f, 0.05562933f, 0.05679341f, -0.02936878f, 0.10142471f, 0.17087249f, 0.02624507f, 0.08669621f, 
    0.11950282f, 0.15182705f, 0.08943269f, 0.03156681f, -0.01041804f, 0.04793005f, -0.02725705f, 0.16768973f, 
    0.03230764f, -0.02474889f, -0.19566113f, 0.13784802f, -0.10038805f, -0.04881506f, 0.10200950f, 0.04238945f, 
    0.07380752f, -0.22755517f, 0.06753152f, -0.25194362f, 0.03101714f, 0.03416516f, -0.07059000f, 0.10907066f, 
    -0.03612985f, -0.01037215f, -0.10173844f, 0.20612682f, 0.12111486f, 0.00291870f, -0.05071459f, 0.01310187f, 
    0.02554064f, 0.06850313f, 0.02981916f, 0.13749765f, -0.20671931f, 0.06811382f, -0.12639479f, 0.05328479f, 
    0.03099555f, 0.17436543f, 0.01228491f, 0.17993402f, -0.00204209f, 0.05312561f, 0.15029517f, -0.04576928f, 
    0.12883982f, -0.09635016f, 0.07689875f, 0.06827728f, -0.11062203f, -0.26120338f, 0.06851041f, -0.04867401f, 
    0.13075188f, 0.05224529f, 0.01554236f, 0.09523427f, 0.10960621f, -0.00065812f, -0.07708515f, -0.03909333f, 
    0.05738040f, -0.09936194f, 0.07671882f, 0.01121219f, 0.01850816f, 0.08813829f, -0.03860649f, -0.05416427f, 
    0.06808996f, -0.03111134f, -0.05907765f, 0.02107197f, 0.00840502f, -0.01928442f, 0.00452255f, -0.04429119f, 
    0.16460891f, -0.03551101f, -0.32220870f, -0.00158531f, 0.00732553f, 0.03889037f, -0.02798550f, -0.08312531f, 
    0.05441327f, 0.29273382f, 0.00042310f, 0.10868829f, 0.06342585f, -0.04833754f, 0.06451479f, 0.12480137f, 
    0.16118082f, 0.17019594f, 0.20842166f, -0.28429618f, 0.08649272f, -0.11853200f, -0.16843754f, -0.02198901f, 
    0.00903562f, 0.11137790f, 0.19256385f, 0.15261999f, -0.14860618f, -0.27604872f, 0.13064975f, 0.06187036f, 
    0.06582488f, -0.01848886f, 0.06188712f, 0.23466168f, -0.00338245f, -0.01506280f, -0.04305594f, -0.04472020f, 
    -0.00962593f, 0.13929503f, 0.20611204f, -0.03535131f, 0.15797761f, -0.52626252f, -0.23131496f, -0.23153557f, 
    0.14742759f, -0.04469903f, 0.12064808f, -0.04479529f, -0.15809219f, 0.01738348f, -0.00689713f, 0.11704434f, 
    0.25165215f, 0.05336955f, -0.06713369f, 0.07205497f, 0.09457395f, 0.09816917f, 0.02242892f, -0.56344277f, 
    -0.19943640f, -0.13043502f, 0.02563586f, 0.10283545f, -0.19449544f, 0.12515600f, -0.07324910f, -0.14109838f, 
    -0.21845084f, -0.20769115f, -0.08263107f, 0.13408697f, -0.00754113f, 0.05455202f, 0.03276429f, 0.05092141f, 
    -0.07449814f, 0.10290778f, -0.06009151f, 0.08220339f, 0.13161817f, -0.17829424f, -0.12080707f, -0.02690405f, 
    -0.01539835f, 0.01692036f, 0.20229053f, -0.05495674f, -0.06239969f, -0.05211089f, -0.08065533f, -0.02367346f, 
    -0.04220924f, 0.00317544f, -0.13493960f, -0.24150874f, -0.15711527f, 0.26411438f, 0.13348252f, 0.10759415f, 
    -0.03998120f, -0.05871226f, 0.01494033f, -0.00980869f, 0.16355379f, 0.07940347f, 0.12734069f, -0.08135796f, 
    0.18349849f, -0.05317888f, 0.13795835f, 0.04743916f, -0.11561801f, 0.07457453f, 0.25044361f, -0.04097374f, 
    -0.01431634f, 0.05427944f, -0.15737762f, -0.02085685f, -0.00030063f, 0.00094064f, -0.25254229f, -0.15175913f, 
    -0.33339426f, 0.28738585f, 0.10178361f, 0.23909639f, 0.02765339f, 0.03671905f, 0.17254607f, 0.13581032f, 
    0.05849547f, -0.01331180f, -0.15184924f, -0.03622681f, 0.05290110f, -0.12615368f, 0.03390316f, 0.08970481f, 
    0.01212116f, 0.05034919f, 0.02980811f, -0.06334367f, -0.04010808f, 0.01215623f, 0.01515031f, -0.04631473f, 
    -0.02755808f, -0.50214601f, -0.04677080f, -0.04783283f, -0.01231708f, 0.03164421f, -0.00395135f, 0.02644115f, 
    -0.10996353f, 0.00442780f, -0.29266381f, -0.04103643f, 0.44248939f, 0.05963818f, 0.04486541f, 0.02200614f, 
    -0.07444829f, -0.02482802f, 0.00256877f, -0.06422057f, -0.06845544f, 0.29918793f, -0.11431181f, -0.02803017f, 
    0.04213861f, -0.04559875f, -0.07293236f, 0.03040818f, -0.19842385f, 0.20287330f, -0.45716172f, 0.07492570f, 
    0.10837708f, -0.00204183f, -0.03411373f, 0.13244726f, -0.05081088f, 0.00823509f, 0.03393452f, -0.26437363f, 
    -0.00476355f, 0.12645239f, 0.00092108f, -0.01919199f, -0.17103912f, 0.05691040f, 0.03648525f, 0.22039258f, 
    -0.32556659f, -0.01847383f, -0.03621106f, -0.18863286f, 0.08109540f, 0.22987604f, 0.06357758f, -0.07974960f, 
    0.05283346f, -0.43967316f, -0.02958378f, -0.17753388f, -0.00601677f, -0.06150473f, 0.00238807f, 0.09854346f, 
    0.03010410f, -0.05953463f, -0.02759999f, 0.00753285f, -0.04172698f, 0.04114126f, 0.03426776f, 0.01331616f, 
    0.00436281f, 0.04458436f, 0.05084078f, 0.03008907f, -0.00192313f, -0.04219972f, 0.01854574f, 0.01988593f, 
    0.01819200f, -0.00540432f, -0.06441342f, -0.00618355f, -0.03703339f, -0.05650974f, -0.04426246f, 0.05051165f, 
    -0.01642445f, 0.03853900f, -0.06883330f, -0.01288425f, -0.06249845f, -0.06092269f, -0.01090341f, -0.04198371f, 
    0.03898728f, 0.04256543f, -0.03605604f, -0.01540452f, -0.07197998f, 0.03003214f, -0.03083755f, 0.00776881f, 
    0.01981767f, 0.00451597f, -0.05748551f, 0.03713197f, -0.04187172f, 0.00997898f, 0.05245823f, -0.03922694f, 
    -0.05306676f, 0.02122384f, 0.00586796f, -0.05423316f, -0.00128346f, -0.00695287f, 0.02216311f, -0.05253777f, 
    0.03743300f, -0.01731366f, -0.00773342f, -0.02437210f, 0.00224605f, -0.00107363f, -0.04238523f, 0.02112643f, 
    -0.05624167f, 0.01159662f, -0.06604542f, -0.03750941f, 0.04132065f, -0.04107087f, -0.05258090f, 0.03021601f, 
    0.00455790f, 0.02137882f, 0.01686552f, 0.01787692f, -0.06485661f, -0.00658575f, 0.02471344f, -0.02598795f, 
    0.04590597f, -0.05626079f, 0.04642093f, 0.00167097f, 0.00708338f, 0.00165580f, -0.02288828f, -0.04448112f, 
    -0.05504517f, -0.04886940f, 0.00785157f, 0.01032358f, 0.00383702f, -0.02709034f, -0.01535068f, 0.00457097f, 
    -0.06545877f, 0.01506318f, -0.00311295f, 0.00549229f, -0.00550487f, -0.01450557f, -0.05786789f, -0.04601555f, 
    0.03047695f, -0.06380402f, -0.02837650f, 0.01771134f, 0.04018195f, 0.00283149f, 0.02222469f, 0.00132806f, 
    -0.00112306f, 0.03778009f, 0.00717568f, -0.03301240f, 0.01333186f, -0.04308543f, -0.02728390f, -0.00034351f, 
    0.02250962f, -0.04707780f, 0.04331253f, -0.03450728f, 0.04741698f, -0.02038924f, -0.05431883f, -0.05049212f, 
    -0.03699616f, -0.05253651f, -0.02213197f, -0.06600400f, -0.06679607f, -0.03796377f, -0.01758262f, -0.01891635f, 
    0.04998158f, 0.02762812f, 0.03308104f, -0.00815732f, -0.07087262f, 0.00676099f, -0.00165112f, 0.02060256f, 
    0.01243948f, -0.01496458f, -0.03616568f, 0.03444650f, -0.04386827f, 0.04393268f, 0.02580296f, 0.01119978f, 
    0.01928150f, -0.01102584f, -0.03310022f, 0.04646095f, 0.00420390f, 0.03617788f, -0.02399424f, 0.04830893f, 
    -0.00837976f, -0.03105883f, -0.02592731f, 0.03561505f, -0.00793741f, 0.00782732f, -0.03623531f, 0.04270180f, 
    -0.05852039f, 0.00711491f, 0.02728480f, 0.04136957f, -0.04490989f, -0.02113100f, -0.00275366f, 0.04227913f, 
    -0.01570123f, 0.02138450f, -0.00577699f, -0.07095104f, -0.04148325f, -0.01417810f, -0.00461930f, -0.00234846f, 
    0.03880480f, 0.01083342f, 0.01414970f, -0.03833872f, 0.04837360f, -0.05759438f, -0.03751275f, 0.00456951f, 
    -0.00400997f, -0.02373615f, 0.00014994f, -0.06162957f, -0.05958722f, 0.00997745f, -0.01035292f, -0.01612497f, 
    -0.05528310f, -0.01034184f, 0.04561462f, 0.00605772f, -0.04649239f, 0.04596081f, 0.04171627f, -0.01471112f, 
    0.00690746f, 0.02835190f, 0.00087815f, -0.04152649f, -0.03792388f, 0.01176086f, 0.01394732f, -0.05812207f, 
    -0.06351416f, -0.00338558f, -0.05129879f, -0.06236132f, 0.02597372f, 0.03905061f, 0.01076942f, -0.04579895f, 
    -0.00726109f, 0.02216910f, 0.02963916f, 0.03011554f, -0.04204041f, -0.05228903f, 0.02105621f, 0.03507594f, 
    0.00600604f, 0.02007868f, -0.03328640f, 0.01302890f, -0.00301268f, 0.00850367f, 0.05087526f, -0.02340410f, 
    0.01132426f, 0.01674670f, -0.04619047f, -0.00732527f, -0.02623947f, -0.01746135f, 0.00668632f, 0.03257332f, 
    0.01559182f, -0.04111949f, -0.01115784f, -0.03286593f, -0.03309114f, -0.00225792f, 0.01366479f, -0.01228980f, 
    0.00287075f, -0.03899952f, 0.03053064f, -0.00959463f, -0.00114780f, 0.00059727f, -0.04742903f, 0.02218583f, 
    -0.05437489f, 0.01052425f, -0.02721224f, -0.05720592f, -0.02237265f, 0.05078089f, -0.00276738f, 0.00326152f, 
    -0.01997593f, 0.01715613f, 0.04726512f, 0.05611072f, -0.03912103f, -0.03892956f, -0.04231668f, -0.04585068f, 
    0.00565749f, -0.02543353f, -0.02318564f, -0.06725275f, -0.01758227f, -0.06544299f, 0.02572428f, 0.00981295f, 
    -0.15636349f, -0.17948519f, 0.19770400f, -0.11885482f, 0.00464399f, 0.00703913f, -0.00029665f, -0.04516378f, 
    0.08193292f, 0.01487900f, -0.00546361f, -0.11134471f, 0.00562397f, 0.04669983f, -0.03609411f, -0.05135684f, 
    0.01302351f, 0.01754619f, -0.28721911f, 0.01872034f, -0.05824581f, 0.10972771f, 0.08413032f, 0.00843543f, 
    -0.10610422f, 0.00933471f, 0.05061755f, 0.02503515f, -0.18310833f, -0.01679344f, 0.04527520f, -0.02170037f, 
    0.01082465f, 0.00718389f, 0.09388506f, -0.06077432f, -0.09410290f, 0.12840845f, -0.07325244f, -0.08374815f, 
    -0.02266756f, 0.07224508f, 0.09999768f, -0.12823908f, -0.04672660f, -0.28327635f, 0.25321326f, 0.00706934f, 
    0.10024897f, 0.11553533f, 0.05714069f, 0.06562645f, 0.01342836f, -0.01212105f, -0.47687322f, 0.09483314f, 
    -0.19269103f, 0.12635013f, 0.09644091f, -0.06178125f, 0.25130096f, 0.03012734f, -0.01112876f, -0.19209349f, 
    0.02507704f, 0.08013527f, -0.01002185f, 0.11361470f, -0.13944250f, -0.15504672f, -0.16092132f, 0.05461826f, 
    -0.03547421f, 0.21853818f, 0.03701814f, -0.04849782f, 0.16197520f, 0.12669960f, -0.05537824f, -0.10184158f, 
    -0.03720397f, -0.09235765f, -0.04366631f, 0.15513846f, 0.03250811f, -0.05523265f, -0.01506828f, -0.04201885f, 
    0.05433539f, 0.08561011f, 0.28070742f, -0.11329363f, 0.09534641f, 0.03607290f, -0.04383936f, -0.08574516f, 
    0.06365484f, 0.10104276f, 0.00467846f, -0.11556197f, 0.12271496f, -0.13917838f, 0.06046437f, 0.14842458f, 
    -0.05628650f, -0.19438128f, -0.01892563f, 0.09196062f, -0.07611897f, 0.04188966f, 0.03413538f, -0.07432532f, 
    -0.05900853f, -0.16196412f, 0.04419854f, 0.09691293f, 0.02403402f, 0.41638553f, 0.10161936f, -0.05785524f, 
    0.02956902f, -0.23968266f, 0.02069701f, 0.08889542f, 0.04954987f, 0.10543553f, -0.24308255f, 0.00887222f, 
    -0.06017393f, -0.06501186f, -0.05424988f, -0.14877564f, 0.08974116f, -0.01334285f, -0.00193151f, -0.17185880f, 
    -0.13087541f, -0.10859516f, -0.15454662f, -0.08378208f, -0.03840331f, 0.06584866f, -0.00584915f, 0.10451701f, 
    -0.18273994f, 0.27050102f, -0.25827104f, 0.03486306f, 0.10215706f, 0.10028282f, -0.09736904f, 0.02731934f, 
    -0.12854885f, 0.45258898f, 0.19868733f, 0.01158648f, 0.08549244f, -0.02758019f, 0.15992634f, 0.01063209f, 
    0.11587210f, -0.03293507f, 0.26476523f, 0.13480054f, 0.26519808f, -0.14132220f, 0.10309563f, -0.01571375f, 
    0.00695911f, 0.01126760f, 0.04666434f, 0.05998003f, -0.20266725f, 0.01555053f, -0.17391822f, -0.03041633f, 
    -0.16657303f, 0.06883550f, 0.15129873f, 0.01287780f, 0.14883482f, 0.17133124f, 0.00998256f, -0.19965032f, 
    -0.07968447f, 0.10026214f, -0.04096055f, -0.18241270f, -0.15505230f, 0.10778523f, 0.13806297f, -0.04025248f, 
    -0.05868991f, -0.07763309f, 0.06668761f, -0.13555457f, 0.03342297f, -0.20497520f, 0.19926564f, 0.09065219f, 
    -0.15373617f, 0.03466440f, 0.05508138f, -0.00163018f, 0.00876699f, -0.11217131f, 0.01745505f, -0.04546260f, 
    0.18000610f, 0.09728459f, -0.24742705f, -0.15038911f, -0.15824308f, -0.04865281f, -0.09699363f, 0.13246982f, 
    -0.02035709f, 0.07810275f, 0.15023758f, -0.06511796f, -0.05409871f, -0.06098230f, -0.01134465f, -0.03242125f, 
    -0.19669114f, 0.27485785f, -0.22995175f, -0.36330268f, 0.08369891f, 0.08210661f, -0.00005931f, -0.03590795f, 
    0.05440040f, -0.02634426f, -0.01181493f, -0.05310004f, 0.33498645f, -0.08078378f, -0.02953910f, -0.15306653f, 
    -0.05111230f, 0.03940378f, -0.00432242f, 0.12500669f, 0.09052959f, 0.31851259f, -0.05901998f, -0.08628065f, 
    -0.04516707f, -0.00463985f, -0.07353543f, 0.07527880f, 0.06721043f, -0.19623464f, -0.14742608f, 0.06686386f, 
    0.18824621f, -0.12977895f, -0.04060613f, 0.12396096f, 0.04404360f, -0.05250066f, 0.06764939f, -0.02337661f, 
    0.00105020f, 0.03782707f, 0.19712366f, -0.19077682f, -0.17232187f, -0.10347737f, 0.23144627f, -0.03289188f, 
    -0.18922056f, -0.11632367f, 0.10218413f, -0.08513857f, 0.11553745f, -0.00149918f, 0.07215817f, 0.31222913f, 
    0.00019775f, -0.24322759f, 0.03438731f, -0.21161461f, 0.07780414f, 0.07466573f, -0.06159232f, 0.01838513f, 
    0.01418674f, -0.08599836f, -0.05336367f, -0.01884281f, -0.07803472f, -0.03330731f, -0.07350506f, -0.04864260f, 
    -0.02851254f, -0.05672667f, -0.02848188f, -0.04125758f, 0.02756297f, -0.05291231f, 0.04121683f, -0.07882119f, 
    0.03080460f, 0.01582910f, 0.02914253f, -0.02353546f, -0.02465099f, -0.05308807f, 0.06048695f, 0.03127087f, 
    -0.09616186f, -0.07622195f, -0.06836993f, 0.02262020f, -0.04205243f, -0.04444768f, -0.05606157f, -0.02894646f, 
    -0.06503110f, 0.00785733f, 0.00980769f, 0.00154442f, 0.02588033f, 0.03077044f, 0.05568253f, 0.00554011f, 
    0.00724358f, -0.05851288f, 0.00801003f, -0.07368390f, -0.05822280f, -0.02947607f, 0.01649724f, -0.03721525f, 
    -0.06262246f, 0.05725441f, 0.04474625f, -0.07345577f, -0.02128462f, 0.04838937f, -0.08522740f, 0.01573933f, 
    -0.06282981f, -0.04900238f, -0.02067215f, -0.04430983f, -0.01031913f, -0.06594075f, -0.04554456f, -0.01408412f, 
    -0.01095864f, -0.05679052f, 0.01784134f, 0.00081738f, 0.04069169f, -0.04436617f, -0.06242789f, -0.07048201f, 
    0.02888565f, 0.04527162f, -0.01254863f, -0.07471088f, 0.04424356f, 0.05158292f, 0.04703839f, -0.02371116f, 
    -0.05333535f, 0.02920877f, 0.01022964f, -0.00065277f, 0.04345307f, 0.03333912f, 0.03281628f, 0.02751194f, 
    -0.02932834f, -0.00957108f, 0.01584131f, -0.05491518f, 0.00778793f, 0.01253763f, 0.00673899f, -0.01278707f, 
    0.01704516f, 0.02285498f, 0.01967320f, -0.00780498f, -0.05365297f, -0.01548143f, -0.00137564f, 0.00768586f, 
    0.06220355f, 0.03272305f, -0.07402609f, 0.02059032f, -0.07439343f, -0.04614812f, 0.01146410f, -0.02262371f, 
    -0.08756568f, -0.01576985f, -0.00152404f, -0.03980520f, -0.06140252f, -0.06712633f, -0.08027744f, 0.00542247f, 
    -0.03270388f, -0.07748142f, -0.01450318f, 0.02490592f, -0.05981126f, 0.01152577f, 0.02209616f, -0.01506143f, 
    -0.02278297f, -0.04101269f, 0.02386864f, -0.05059528f, -0.02813156f, 0.00246399f, -0.03841975f, -0.02686500f, 
    0.03179003f, 0.01644786f, -0.03240370f, -0.03647780f, 0.00769567f, -0.04020090f, -0.00284854f, -0.05632642f, 
    0.03215692f, -0.03566030f, -0.04447548f, -0.07216521f, -0.03578138f, -0.00557769f, 0.01592014f, 0.00054008f, 
    0.01014320f, -0.06971933f, -0.00861352f, 0.07493283f, 0.04308537f, 0.00320022f, -0.03338559f, 0.03568337f, 
    -0.01019671f, -0.04802876f, -0.01024855f, 0.03359350f, 0.01903844f, -0.05912793f, 0.01019458f, 0.00298141f, 
    -0.00641567f, 0.02282418f, -0.02390245f, 0.03272873f, -0.00030142f, 0.02558533f, -0.07363889f, -0.01707407f, 
    0.01921435f, -0.03680589f, -0.03082485f, -0.03924362f, -0.04303381f, -0.02984473f, 0.02577189f, -0.08000372f, 
    0.01255184f, -0.06515475f, -0.01497660f, -0.02846739f, -0.03799082f, 0.00444385f, -0.01470948f, -0.03632683f, 
    0.02084829f, 0.00639150f, 0.01869168f, -0.04286773f, -0.05356980f, 0.01286209f, -0.05426431f, -0.06362280f, 
    -0.07429838f, -0.00561952f, 0.01588523f, -0.01975992f, -0.03842452f, -0.03606967f, -0.01149856f, 0.02375261f, 
    -0.02392915f, -0.00737324f, 0.00602133f, -0.00982798f, 0.00089291f, 0.01672681f, -0.03655877f, 0.03213679f, 
    0.00888102f, 0.02538619f, -0.05992999f, -0.03456645f, -0.08125018f, 0.03993264f, -0.00058412f, -0.06179439f, 
    -0.03692164f, -0.01305784f, -0.06373874f, 0.04181686f, -0.03891779f, -0.01694087f, 0.01055656f, -0.06112519f, 
    -0.04419785f, 0.01447505f, 0.01758757f, -0.05465532f, 0.02013410f, -0.04162314f, 0.02143889f, 0.04004045f, 
    0.04222998f, 0.03323421f, 0.04015044f, -0.01775351f, -0.06592033f, -0.03436798f, 0.00166907f, 0.00344051f, 
    0.04308792f, 0.02852124f, -0.01446244f, -0.04050489f, -0.00050618f, -0.00704784f, -0.04032413f, 0.03563012f, 
    0.01256332f, 0.04860541f, -0.03287452f, 0.02027907f, -0.03218077f, 0.01975568f, 0.03415919f, 0.03720862f, 
    0.01066723f, 0.00752458f, 0.01538868f, -0.00984999f, 0.00815076f, -0.03853214f, -0.05415250f, 0.05995971f, 
    0.03777576f, 0.01801808f, 0.04030046f, 0.00342687f, -0.05102442f, 0.01801932f, -0.08390068f, -0.06493893f, 
    0.06359513f, 0.00404856f, -0.07226007f, -0.06145956f, -0.06470248f, 0.01171248f, 0.02617660f, 0.04267970f, 
    0.10367474f, -0.01543669f, 0.27348313f, 0.01009016f, 0.05850203f, -0.04064591f, 0.12013415f, -0.00293133f, 
    0.09240432f, 0.03001497f, -0.17693883f, -0.12518889f, 0.20766188f, 0.11426421f, 0.00732317f, -0.05561025f, 
    0.03077301f, -0.06453018f, 0.38167471f, -0.01785044f, 0.03366561f, -0.05237791f, 0.10020623f, -0.03119399f, 
    0.07282805f, 0.10380968f, -0.00866683f, -0.00373703f, 0.08636671f, -0.07934961f, -0.03224662f, 0.01447292f, 
    -0.11850189f, -0.02207952f, 0.03616226f, -0.01860280f, 0.10373710f, -0.07009240f, -0.05580974f, 0.21099649f, 
    0.19277360f, 0.03411484f, 0.12668002f, 0.11750925f, 0.17556764f, 0.58276474f, 0.19761017f, -0.07921344f, 
    -0.02436938f, 0.01698228f, -0.08989003f, 0.11464870f, 0.11611045f, 0.01248004f, -0.18803751f, -0.31397641f, 
    -0.17203130f, -0.06165307f, 0.11752807f, -0.17635600f, -0.06203197f, -0.09301870f, -0.15276302f, -0.15210722f, 
    0.15171655f, -0.01530676f, 0.02020225f, -0.04164108f, 0.01492270f, -0.07476855f, -0.03659120f, 0.02320732f, 
    0.14762571f, 0.00096634f, 0.02416733f, -0.07053258f, -0.02697333f, 0.06023751f, 0.08761586f, 0.06097037f, 
    -0.18788578f, -0.22778079f, -0.20362249f, -0.08692956f, 0.12956960f, 0.00836142f, 0.19702813f, 0.10422458f, 
    -0.06683419f, 0.09037630f, -0.06307391f, -0.07314944f, -0.01873805f, -0.13537635f, 0.08093254f, 0.15575624f, 
    0.02576756f, -0.02806835f, 0.12761749f, 0.33340231f, 0.14961590f, -0.06034147f, -0.03610791f, 0.00271256f, 
    -0.05412397f, -0.01579002f, -0.06943439f, 0.12202571f, -0.02071766f, -0.06695099f, 0.04374321f, -0.06149253f, 
    0.05640167f, 0.04645284f, 0.19433840f, 0.01670454f, -0.10065526f, -0.07205132f, -0.15280902f, 0.17236799f, 
    -0.00583116f, -0.01894801f, -0.08518585f, 0.02511021f, -0.15004373f, -0.11511880f, 0.15349729f, 0.01993101f, 
    -0.01940858f, 0.05669954f, -0.12996738f, 0.00441993f, -0.05761551f, 0.14879267f, -0.06891375f, -0.27279931f, 
    0.22409336f, -0.14238296f, 0.10873522f, 0.05542209f, -0.05227055f, -0.12866004f, 0.00577974f, -0.05373415f, 
    -0.46272027f, 0.15062796f, -0.12593843f, -0.07648607f, -0.04605128f, -0.05075995f, 0.11364128f, 0.12476953f, 
    0.04586598f, -0.36761048f, -0.29254571f, 0.04282097f, 0.07923297f, 0.22068615f, 0.14445932f, -0.16135965f, 
    0.02427058f, -0.16310737f, -0.27627900f, 0.08752935f, 0.00714336f, -0.01632529f, -0.04748511f, 0.05184932f, 
    -0.17297180f, 0.09584682f, 0.01920662f, -0.16679357f, 0.09223835f, -0.23227093f, -0.10996209f, -0.11657280f, 
    0.14976983f, -0.14105222f, 0.10290646f, -0.02051685f, 0.01529418f, -0.27886868f, 0.02677030f, 0.13670790f, 
    -0.04340324f, 0.19612333f, -0.03574017f, 0.00088253f, 0.08146399f, -0.25030866f, 0.16033223f, -0.01068246f, 
    0.13236865f, 0.05757378f, 0.03711289f, 0.00723081f, -0.12960786f, -0.09591435f, 0.11006035f, 0.13119310f, 
    -0.01551356f, 0.05613384f, -0.09676261f, 0.13891761f, 0.05735899f, 0.00507440f, -0.11064403f, -0.02082504f, 
    0.07276792f, -0.09215847f, 0.01885896f, 0.01626722f, -0.01571773f, -0.12263601f, -0.03681171f, 0.06120937f, 
    0.09784246f, -0.17960148f, 0.03959040f, -0.00332118f, -0.04899713f, 0.18471834f, 0.16199769f, 0.04554238f, 
    -0.07286799f, -0.03583801f, 0.05000916f, -0.10519327f, -0.10093521f, -0.22331131f, 0.00580795f, -0.23255429f, 
    0.25906613f, 0.11682136f, 0.00063941f, 0.22192420f, 0.13110569f, -0.20591332f, 0.08594281f, -0.10038520f, 
    0.12461861f, 0.04716711f, 0.03610015f, -0.04365226f, -0.00093649f, 0.21266128f, 0.00905700f, -0.01656104f, 
    0.06435670f, -0.10008613f, 0.02299229f, 0.16470687f, 0.23758096f, 0.13770299f, -0.15730408f, 0.12364334f, 
    -0.00809499f, -0.17917337f, 0.10259449f, 0.08428769f, -0.15510471f, 0.06337585f, 0.05340660f, -0.18410951f, 
    0.02622076f, -0.05109733f, 0.06059930f, -0.13007560f, -0.03782201f, -0.02601678f, -0.04912233f, -0.18450169f, 
    -0.01784042f, 0.17238493f, 0.23477986f, -0.01586221f, -0.07243130f, -0.09500025f, -0.01535899f, 0.35494518f, 
    0.04908898f, -0.01152449f, 0.06906611f, -0.01656606f, -0.04931648f, 0.01512914f, -0.03190083f, -0.06390025f, 
    -0.10246508f, -0.11305925f, 0.06520984f, 0.10492285f, -0.01050091f, -0.04693121f, 0.06843492f, 0.04204798f, 
    -0.02020154f, -0.29458874f, 0.13913229f, 0.32556191f, -0.06114285f, 0.12749654f, 0.01600761f, 0.17318077f, 
    0.18145631f, -0.17220388f, -0.04603522f, 0.07183234f, 0.17901687f, -0.04361132f, -0.05654376f, -0.04609374f, 
    0.03271033f, 0.01661249f, -0.08890160f, -0.16275305f, -0.00712014f, -0.19020690f, 0.08341419f, -0.03348542f, 
    -0.04860083f, 0.18183815f, 0.05992841f, 0.06388912f, 0.00429491f, -0.10650453f, -0.04086064f, -0.16187710f, 
    -0.12410071f, 0.16948245f, -0.02643461f, 0.03344961f, 0.12091491f, 0.04153565f, 0.21718736f, 0.21676536f, 
    -0.11454701f, -0.30864853f, -0.11941679f, -0.08776791f, -0.00229631f, 0.12553731f, 0.42565012f, 0.03268378f, 
    -0.02837389f, -0.18204919f, -0.02399798f, 0.04612265f, 0.00119718f, -0.02556016f, -0.16110454f, -0.06743300f, 
    -0.02356049f, -0.10199551f, 0.05317880f, 0.05587871f, -0.00498363f, -0.21428612f, -0.02485552f, -0.07344261f, 
    0.11577257f, 0.06602404f, -0.09554738f, -0.24632810f, 0.04366821f, -0.00355848f, -0.10089426f, -0.01039267f, 
    -0.01318092f, -0.01411328f, 0.13908496f, 0.14316590f, -0.10405421f, -0.01641687f, -0.05175649f, 0.09675229f, 
    0.19827290f, -0.03191955f, -0.24517286f, -0.00318500f, 0.08494201f, 0.21710917f, -0.15525082f, -0.01042128f, 
    0.00462105f, -0.00831688f, 0.05438271f, 0.02395216f, 0.22040392f, 0.09492982f, -0.07306043f, -0.06230061f, 
    -0.07662367f, -0.11104716f, 0.10472823f, -0.02359792f, -0.24069282f, 0.03079099f, -0.10171641f, -0.07595155f, 
    0.08645523f, -0.11332603f, 0.20565952f, -0.06518744f, -0.08846115f, 0.42572489f, -0.29997450f, 0.10222310f, 
    0.15694448f, -0.03369588f, -0.09627797f, 0.09811778f, -0.14626238f, -0.02437732f, -0.13994911f, -0.24365869f, 
    0.10268603f, -0.11403067f, 0.10055013f, 0.11474158f, -0.03944549f, 0.05208548f, 0.02379197f, -0.24513547f, 
    -0.05811800f, -0.13498139f, -0.00667709f, -0.02862751f, -0.02729645f, -0.06104418f, -0.06278852f, 0.21765950f, 
    0.02597846f, -0.14143756f, -0.09459310f, -0.17100225f, -0.13598962f, -0.10309910f, -0.18935934f, 0.09205961f, 
    -0.09998290f, 0.08911889f, -0.00640516f, -0.14262380f, 0.09131911f, 0.05437610f, 0.18450189f, -0.07025144f, 
    0.05597182f, -0.04408731f, 0.16123343f, 0.18311393f, -0.24870004f, 0.09622137f, 0.07617655f, -0.01577417f, 
    0.01350466f, 0.01165794f, -0.04789493f, -0.27701074f, -0.12295141f, 0.00897969f, -0.07492447f, 0.12948628f, 
    0.01907391f, 0.06059877f, 0.09067588f, -0.07687895f, 0.19927493f, -0.26285151f, -0.01401331f, 0.18296653f, 
    0.12734321f, 0.07234383f, -0.16178830f, 0.12812430f, 0.10668714f, -0.32445046f, -0.20949250f, 0.12563834f, 
    -0.03343249f, -0.08674755f, 0.05865956f, 0.00549110f, -0.07086133f, -0.14359516f, 0.11814505f, -0.06260245f, 
    0.05511419f, -0.02833983f, -0.05468586f, -0.03355377f, 0.02881923f, 0.14428656f, 0.09412681f, 0.36287254f, 
    0.23654513f, -0.17791551f, 0.17927711f, 0.03156902f, -0.01380922f, -0.05224743f, -0.12862876f, -0.09970735f, 
    0.03694728f, -0.11829360f, 0.11053310f, -0.02881828f, 0.03902790f, 0.04276903f, -0.01875344f, 0.04436347f, 
    0.00067780f, -0.11825504f, -0.22484176f, 0.08476711f, 0.03818247f, 0.18488525f, 0.02743013f, -0.12299782f, 
    0.03837624f, -0.01812213f, -0.17622694f, 0.22899260f, -0.26923221f, 0.14734292f, 0.14676321f, 0.03406141f, 
    0.06893472f, 0.04274767f, -0.10245056f, 0.07031865f, 0.07936019f, -0.07963514f, 0.20310807f, 0.20698707f, 
    -0.01230683f, 0.00027002f, 0.03790498f, -0.11660112f, 0.07295349f, 0.09567063f, 0.09968226f, -0.10182818f, 
    -0.05668604f, -0.00304655f, -0.10213712f, 0.08123778f, 0.08281542f, -0.24645561f, -0.10540041f, -0.02789531f, 
    -0.00433876f, 0.07890473f, -0.04793926f, 0.04992391f, -0.01448169f, 0.06976364f, 0.00436282f, 0.02634233f, 
    0.11079440f, -0.18608168f, -0.12230404f, -0.04361231f, -0.10641388f, 0.11626109f, 0.04216055f, 0.43456179f, 
    -0.10581236f, -0.03350447f, -0.15963373f, 0.14781797f, 0.04900159f, -0.06059107f, 0.00554193f, -0.07191291f, 
    0.05711271f, 0.00437830f, 0.05923099f, -0.03824054f, 0.10271783f, 0.08494733f, 0.00952646f, 0.13973667f, 
    -0.10443528f, 0.00359670f, -0.07128756f, -0.01201556f, 0.15960892f, -0.05458229f, -0.00253315f, 0.00120476f, 
    0.02196782f, -0.05471346f, -0.32925403f, 0.11362511f, -0.18094359f, 0.00751434f, -0.00013550f, -0.00733993f, 
    -0.02799888f, 0.03917863f, -0.01109978f, 0.11931939f, 0.10622502f, 0.01044959f, -0.11962003f, -0.01038827f, 
    0.07844497f, -0.02216272f, 0.12088510f, 0.07716220f, -0.15873039f, -0.21483339f, -0.08773502f, 0.09344854f, 
    -0.04151122f, -0.03998613f, 0.06444860f, 0.05245623f, 0.07338662f, -0.58491629f, -0.18737206f, 0.01050049f, 
    0.10572435f, 0.00917027f, -0.08009257f, -0.03607431f, 0.03169744f, -0.02590333f, -0.02710222f, 0.08814595f, 
    -0.00593209f, 0.17078392f, 0.02390192f, -0.06398826f, 0.02150334f, -0.15536906f, 0.02056959f, 0.14164469f, 
    0.01586129f, -0.05845679f, -0.25479209f, -0.09897811f, 0.09338994f, 0.03105664f, -0.04993353f, -0.16762543f, 
    -0.43576357f, -0.28387091f, -0.01115553f, 0.00882503f, 0.03216870f, -0.10380501f, 0.00363625f, 0.14721660f, 
    0.07251453f, -0.12541658f, 0.22805934f, -0.14651069f, 0.18885529f, -0.02072794f, 0.06559510f, 0.17325285f, 
    -0.04967390f, -0.03881377f, -0.05074714f, 0.16497417f, -0.18987909f, 0.04526921f, -0.09264556f, 0.02879853f, 
    0.09603282f, -0.02580655f, 0.08759668f, -0.44714126f, -0.31532916f, 0.18068293f, 0.01158078f, 0.03717072f, 
    0.04973711f, -0.10812552f, 0.02552756f, 0.20233709f, 0.15109155f, 0.08157296f, -0.17799912f, 0.05202616f, 
    -0.05792365f, 0.00949544f, 0.06772452f, 0.10955097f, -0.04677660f, -0.01096805f, -0.03289936f, -0.29118866f, 
    -0.09085818f, -0.11299061f, -0.00161260f, 0.10121566f, 0.06514041f, 0.17755902f, -0.04094446f, -0.05016790f, 
    0.15524608f, 0.00381095f, -0.05291967f, 0.04961190f, -0.00238109f, 0.07418177f, 0.09395696f, -0.04694322f, 
    -0.05770795f, 0.03382377f, 0.00473671f, 0.11983026f, -0.03956146f, -0.01266007f, -0.09158842f, -0.11514547f, 
    -0.44045889f, -0.06362187f, -0.00830266f, 0.02021039f, 0.04590096f, -0.00532329f, 0.01177217f, 0.05957685f, 
    0.03349269f, -0.03719715f, 0.19980763f, 0.04854388f, 0.25094187f, -0.00243100f, 0.08925585f, -0.07520673f, 
    0.03985218f, -0.14141563f, 0.19244288f, 0.15278316f, 0.21885592f, -0.01942868f, 0.02084190f, -0.02565618f, 
    0.03317919f, -0.05354668f, -0.03429249f, 0.12408935f, 0.18208605f, -0.01574221f, 0.08161899f, -0.09724144f, 
    -0.05840718f, 0.03972937f, 0.04864229f, -0.07217415f, 0.00477097f, 0.18095222f, 0.18055312f, 0.10275143f, 
    -0.08590570f, 0.11586308f, -0.06767957f, 0.08151177f, -0.09028438f, -0.19732513f, -0.20632541f, -0.08333045f, 
    -0.13806914f, 0.10582213f, -0.04823247f, -0.00494960f, 0.00993302f, 0.05830964f, -0.24301587f, 0.19172926f, 
    -0.02764758f, -0.07338246f, -0.04886338f, -0.13354507f, 0.00044704f, -0.01464815f, -0.01110864f, 0.00093610f, 
    0.30107695f, -0.01487894f, 0.10589373f, 0.11385293f, -0.14173076f, -0.00638695f, 0.03774998f, 0.02960713f, 
    -0.01381446f, 0.10622205f, 0.07952728f, -0.05542998f, -0.01911766f, 0.08997960f, 0.06346301f, 0.13329187f, 
    -0.01061673f, -0.07705268f, 0.17492771f, -0.21011567f, -0.10506934f, 0.12013596f, -0.03178522f, 0.01260037f, 
    -0.10684698f, 0.11412598f, -0.03525640f, 0.25988376f, 0.25457329f, 0.20810786f, 0.15444221f, 0.05445718f, 
    -0.05145376f, 0.00523965f, 0.07327768f, 0.06248697f, 0.21436393f, 0.24876779f, 0.03367143f, -0.09213340f, 
    0.01776372f, 0.00169389f, -0.09207562f, 0.04365066f, 0.23494716f, -0.10130765f, -0.10562517f, 0.03790237f, 
    -0.07384055f, 0.04769409f, -0.13762261f, -0.09078765f, 0.02324896f, -0.32700574f, -0.41869769f, 0.06536610f, 
    -0.04110176f, 0.20813031f, -0.10257778f, 0.02042709f, -0.07869805f, 0.01128432f, 0.00187614f, -0.24685277f, 
    -0.06737483f, -0.02212283f, -0.01941652f, 0.01737782f, -0.13139936f, -0.01550470f, -0.06108335f, -0.07500894f, 
    0.10140334f, -0.04806973f, -0.01924210f, 0.14241843f, 0.02107578f, 0.02687705f, 0.03573978f, 0.22823828f, 
    -0.16320165f, 0.06202581f, 0.14073555f, 0.11344574f, 0.05812415f, -0.01614754f, 0.06320806f, -0.02121196f, 
    -0.01100242f, -0.00152930f, 0.01748753f, -0.03688354f, 0.03562776f, 0.08910564f, 0.09653132f, 0.02499796f, 
    0.04314018f, 0.12869190f, 0.10638485f, 0.13361722f, 0.11665305f, 0.05349594f, 0.12566245f, 0.08281785f, 
    0.13352960f, 0.09438799f, 0.16507566f, -0.18253204f, -0.11050075f, -0.28667614f, 0.04623001f, 0.04177176f, 
    0.02638095f, -0.02016871f, 0.06783126f, 0.07190178f, 0.35221571f, 0.17932174f, -0.07214043f, 0.02042632f, 
    -0.09195342f, -0.01534020f, 0.11492096f, 0.15298212f, 0.00582713f, 0.10815727f, 0.15227158f, 0.09268446f, 
    -0.02198789f, 0.11170172f, -0.01730079f, 0.01656202f, 0.01537262f, 0.06914812f, -0.23151024f, 0.00285364f, 
    -0.08077388f, -0.18095660f, -0.18169108f, 0.17094317f, 0.06916328f, -0.00584106f, -0.10855375f, -0.07439204f, 
    0.01116934f, -0.48360226f, 0.01283874f, 0.00244296f, 0.13312151f, -0.09075086f, -0.15936814f, 0.02942322f, 
    0.22892702f, 0.17154196f, -0.01835395f, 0.10260559f, -0.13027376f, -0.06431262f, 0.05167880f, 0.07834554f, 
    0.01769250f, -0.13585173f, 0.06893376f, 0.12190856f, 0.08760098f, 0.19773981f, -0.01475988f, 0.05317102f, 
    0.01056516f, 0.13733996f, -0.11750456f, -0.16397338f, 0.07644907f, -0.01413028f, 0.12072171f, 0.10497764f, 
    0.11038048f, 0.03637457f, -0.01326676f, 0.22999901f, 0.11895165f, -0.04218633f, 0.06916524f, 0.14416519f, 
    0.11799590f, -0.06570920f, 0.06419020f, 0.08786605f, -0.05616722f, 0.08566087f, 0.04240803f, -0.05798829f, 
    0.04549215f, 0.05735842f, 0.03101951f, 0.13488883f, 0.28022882f, -0.38165948f, -0.12494072f, 0.13440803f, 
    0.00162968f, -0.00464930f, 0.02385313f, 0.08076546f, -0.05316572f, -0.09799994f, -0.30160162f, -0.09326006f, 
    -0.31326842f, -0.07665055f, -0.03594944f, -0.06833480f, 0.04918121f, 0.02523207f, -0.08916952f, -0.58449161f, 
    0.14665042f, -0.02600834f, 0.07381436f, 0.07395038f, -0.09581946f, -0.03016141f, -0.16777696f, -0.07357482f, 
    0.09603874f, 0.25927284f, -0.07494863f, 0.03631749f, -0.10522234f, -0.10299555f, -0.17979547f, -0.09303888f, 
    0.14703110f, -0.37639734f, -0.13098596f, -0.03411289f, -0.07054978f, -0.01938045f, -0.05721434f, 0.16628961f, 
    -0.03928920f, -0.09627336f, -0.02152712f, -0.01281982f, -0.48465368f, -0.09774169f, -0.09981562f, 0.05924961f, 
    -0.11207915f, -0.00753135f, -0.14431103f, -0.08646938f, 0.05459984f, -0.21575761f, 0.01633058f, 0.03922028f, 
    0.03936326f, -0.00396709f, 0.10901017f, -0.08155888f, -0.09808745f, -0.07479278f, -0.01481517f, -0.05833609f, 
    0.05257935f, -0.03579044f, 0.26823300f, 0.03595661f, -0.05304785f, 0.10398964f, -0.00264612f, 0.17386331f, 
    -0.04017777f, -0.07190342f, -0.18997897f, -0.08523806f, 0.00970733f, 0.01599246f, 0.12681749f, 0.06339566f, 
    -0.11384494f, 0.04847702f, 0.05920444f, 0.12093030f, -0.10173556f, 0.10695956f, -0.00918432f, -0.48328200f, 
    0.08127239f, -0.25472760f, -0.04883789f, 0.09808148f, 0.07426843f, 0.07539724f, -0.01724630f, 0.00736364f, 
    -0.17222276f, -0.02693963f, -0.08496558f, -0.05640360f, 0.07660167f, -0.13666792f, -0.07753094f, 0.04095724f, 
    0.11483495f, 0.01733068f, -0.23435974f, -0.00992167f, 0.08549277f, 0.14284633f, -0.22694327f, 0.01471491f, 
    -0.00358096f, 0.14458486f, -0.29510894f, 0.19216092f, -0.26086232f, -0.10761411f, 0.04548411f, 0.01297281f, 
    0.11025118f, 0.12238330f, -0.15920155f, -0.04334557f, -0.15673026f, -0.05992192f, -0.11463837f, -0.04515723f, 
    0.05301217f, -0.06331000f, 0.06839857f, -0.12848492f, 0.07168011f, 0.05992999f, -0.11523806f, -0.08476224f, 
    0.00345947f, 0.06776325f, 0.12832268f, -0.09056902f, 0.06311493f, 0.05469821f, 0.02953178f, 0.06886896f, 
    0.11087202f, 0.07163523f, 0.10254508f, -0.11915503f, -0.00730179f, 0.03530075f, -0.46685204f, 0.19276990f, 
    0.35802433f, -0.06488344f, -0.04549928f, -0.09141304f, 0.04490353f, 0.05735641f, 0.01093725f, -0.27410197f, 
    -0.19175768f, 0.23960383f, 0.06176868f, -0.00554461f, -0.13750066f, 0.01934099f, -0.08456085f, 0.01219596f, 
    -0.06584693f, 0.03400738f, 0.03250719f, 0.02768349f, -0.04230455f, 0.04244430f, 0.01815208f, -0.02482795f, 
    -0.00442849f, 0.03716527f, 0.04026452f, -0.00706156f, -0.02691990f, -0.01807233f, -0.03796000f, 0.00767475f, 
    0.01673886f, -0.02451722f, -0.00706895f, -0.02552368f, -0.02799263f, 0.03224047f, -0.04463102f, 0.04928709f, 
    -0.02825652f, 0.01413886f, 0.02034559f, 0.04618016f, -0.06323811f, 0.01615224f, 0.04705556f, 0.02295844f, 
    0.03531043f, -0.01493818f, -0.04862645f, -0.02913629f, -0.03288136f, -0.02643136f, 0.03271209f, -0.01233918f, 
    0.02777449f, 0.00109622f, -0.01256793f, -0.01509459f, 0.01091444f, -0.05520975f, 0.04284738f, 0.04012585f, 
    0.03533574f, -0.02173603f, -0.02745603f, 0.02161031f, -0.03502391f, -0.02152620f, -0.03957137f, -0.05320181f, 
    -0.01980608f, -0.00020794f, 0.05132943f, 0.02329523f, 0.00469246f, 0.03144776f, 0.02355544f, -0.03779001f, 
    -0.00790690f, -0.03874528f, 0.00781547f, 0.01777056f, -0.06094497f, -0.01378922f, -0.02056267f, -0.01192448f, 
    0.03623853f, -0.04207693f, 0.04591262f, -0.05677737f, -0.04773428f, 0.01602588f, -0.00147637f, -0.00063833f, 
    0.00717844f, -0.06803937f, 0.01213811f, 0.05455943f, -0.04853715f, -0.04072761f, 0.03079715f, -0.01016418f, 
    0.00279765f, -0.04566214f, 0.03697279f, 0.01711956f, -0.04897292f, 0.00091866f, -0.05045457f, -0.04187659f, 
    0.05421800f, -0.01364438f, 0.00466105f, -0.03462664f, 0.04574628f, 0.03217822f, 0.03008384f, -0.04476918f, 
    -0.01870721f, -0.02223068f, -0.03639263f, 0.02037301f, -0.02829267f, 0.01106308f, -0.00655968f, -0.04551261f, 
    -0.06587665f, -0.06418210f, -0.01865724f, -0.01968059f, -0.04538464f, -0.02439595f, 0.03625355f, -0.04430685f, 
    0.03828092f, 0.02153451f, -0.02131327f, -0.01712769f, 0.03899647f, 0.03992446f, 0.01032407f, -0.01390074f, 
    0.00825458f, -0.00384936f, -0.04662561f, 0.00539458f, -0.03028130f, -0.04514579f, -0.03013162f, 0.05626017f, 
    -0.01049703f, -0.03953771f, 0.01709956f, -0.03778675f, -0.04312400f, 0.04500577f, 0.01529557f, -0.00314853f, 
    0.04515141f, 0.04915488f, -0.01119770f, -0.01400285f, -0.03724569f, -0.03993852f, -0.00270864f, 0.04777166f, 
    0.00927823f, -0.05116841f, 0.00012508f, 0.02657317f, 0.03763223f, 0.05467936f, 0.01733892f, 0.02415870f, 
    -0.06693637f, -0.03335126f, -0.03676707f, 0.01535142f, -0.02465624f, 0.01437540f, -0.00009235f, 0.02631243f, 
    -0.01941221f, 0.03792113f, -0.03171648f, 0.01944005f, -0.02039643f, -0.05581688f, 0.00087288f, 0.04000624f, 
    -0.04569916f, -0.04992288f, 0.05564268f, -0.04367102f, -0.06259131f, -0.04934706f, 0.04298968f, 0.01186785f, 
    -0.04634674f, -0.04821620f, -0.04519456f, -0.05613586f, -0.04209446f, -0.01830597f, 0.03462033f, 0.04780867f, 
    -0.01919477f, 0.02257414f, 0.00664166f, -0.05959428f, -0.02411598f, -0.04770309f, 0.01466070f, -0.02654487f, 
    -0.02350472f, 0.00173154f, -0.02686095f, 0.03196074f, 0.01536893f, -0.02425539f, -0.02336621f, 0.02580641f, 
    -0.01239985f, -0.02774504f, 0.02577332f, 0.04416361f, 0.00013722f, -0.01492987f, 0.04809204f, 0.02023105f, 
    -0.05939992f, -0.05955678f, 0.03927016f, -0.04322503f, 0.03597452f, 0.04830934f, -0.05443952f, -0.04869736f, 
    0.03605967f, 0.02173408f, -0.00819094f, 0.02139208f, 0.04142719f, 0.05100514f, -0.01554177f, -0.02058453f, 
    0.04196460f, -0.04092873f, -0.01635202f, -0.01144800f, 0.01764305f, -0.02170134f, -0.04545996f, -0.00256400f, 
    -0.02651175f, 0.04313540f, 0.03849036f, 0.00133122f, -0.08099502f, 0.00313157f, -0.06050336f, 0.02050453f, 
    -0.03588533f, 0.01813740f, 0.01224889f, -0.04735110f, -0.03380238f, -0.04939666f, 0.00959024f, -0.03309105f, 
    -0.02782149f, -0.04193232f, -0.05483612f, 0.04317030f, -0.01625787f, -0.06182864f, -0.00415572f, -0.04932843f, 
    0.03920192f, -0.00669997f, -0.02986556f, -0.04224885f, 0.05721647f, 0.02915982f, 0.03230279f, 0.04074417f, 
    0.03939749f, 0.06447803f, -0.04924749f, 0.05091786f, -0.02787063f, -0.03964373f, -0.05703490f, 0.00088040f, 
    -0.01960240f, -0.05380760f, -0.03492876f, -0.05177698f, 0.01651019f, 0.02355520f, 0.01628631f, -0.07138301f, 
    -0.32389790f, -0.09896840f, -0.06660556f, 0.08918283f, 0.04157348f, 0.04463653f, 0.04287044f, -0.15336843f, 
    0.03518803f, 0.05947499f, -0.06795122f, -0.17432362f, 0.16154212f, 0.10941141f, 0.06596690f, -0.18019906f, 
    0.18378365f, 0.01644829f, -0.08549964f, 0.20428914f, 0.08642510f, -0.14503346f, -0.10039833f, 0.09159825f, 
    -0.02631077f, 0.03457278f, -0.03277044f, 0.03577061f, -0.25735673f, -0.05677481f, -0.04408635f, -0.11733900f, 
    0.18002230f, -0.01018227f, 0.01784169f, -0.09906735f, 0.02641543f, 0.15292108f, -0.02921993f, 0.15627725f, 
    -0.06283551f, 0.03491114f, -0.06360877f, 0.18359716f, -0.01647081f, 0.50576800f, 0.17336443f, -0.32096866f, 
    -0.00963528f, -0.03093590f, 0.19495893f, -0.00526505f, 0.04968388f, -0.02212492f, -0.09894294f, -0.07954045f, 
    0.04690696f, -0.10363049f, 0.11956513f, 0.09532708f, 0.02770120f, 0.09740376f, 0.11933108f, -0.13742925f, 
    -0.10231140f, -0.15347937f, 0.17047523f, 0.17099524f, 0.09319712f, 0.07619253f, 0.05222445f, -0.30981755f, 
    0.46841556f, 0.07826126f, -0.33903965f, -0.07792126f, -0.12619196f, -0.03885590f, -0.09036671f, 0.10352375f, 
    0.06498148f, 0.08884788f, 0.11765208f, -0.00612749f, -0.03617749f, 0.13960063f, 0.04143355f, -0.16427839f, 
    0.16365413f, 0.11322711f, -0.17630957f, 0.04420063f, 0.26973298f, -0.07084590f, 0.01657003f, 0.09379910f, 
    -0.11747897f, -0.02978388f, 0.00060844f, 0.27274385f, -0.00277283f, -0.07270399f, 0.10818299f, 0.03262472f, 
    0.11107878f, -0.07160110f, -0.07003716f, 0.08020712f, -0.05220176f, 0.17059170f, -0.05854600f, 0.02141270f, 
    0.09932894f, -0.09595665f, -0.02918979f, 0.07166283f, 0.14508979f, -0.02394731f, -0.13331629f, -0.02696735f, 
    -0.10720749f, 0.01961408f, -0.12972799f, 0.05052913f, -0.18745877f, 0.02046839f, 0.02413049f, -0.32602426f, 
    0.07898712f, -0.01725204f, 0.08125950f, 0.07779117f, 0.07791780f, -0.02171544f, -0.03326159f, -0.03110280f, 
    -0.03393346f, -0.28053653f, 0.13047723f, -0.16299480f, -0.06930378f, -0.02120184f, 0.06134045f, -0.00560288f, 
    0.22060901f, -0.06583533f, 0.09050644f, 0.05272685f, 0.03397011f, -0.05058954f, -0.00151539f, 0.04985598f, 
    0.14660145f, -0.04265220f, 0.15956853f, 0.01923368f, -0.00466763f, -0.01684085f, -0.09876218f, -0.11674087f, 
    0.05085807f, -0.00782547f, 0.19865200f, -0.05362890f, -0.22518668f, -0.08937617f, -0.05384285f, -0.12710088f, 
    0.09925374f, -0.00301536f, 0.02658735f, 0.13390563f, -0.06834544f, -0.09774222f, -0.10576207f, 0.10413309f, 
    0.11301678f, -0.06370478f, -0.03837009f, -0.06333607f, 0.00904097f, -0.11240853f, 0.08278394f, 0.11826777f, 
    -0.02864370f, -0.01338569f, 0.10784870f, 0.06083582f, -0.07467380f, 0.22215343f, 0.00616566f, 0.05324473f, 
    0.05418056f, -0.09416408f, 0.01874319f, -0.02553140f, -0.09572410f, 0.07478206f, 0.08580094f, -0.19177309f, 
    -0.05528952f, -0.06481899f, 0.17557234f, -0.02180384f, 0.07051364f, 0.03628504f, 0.11501176f, 0.00984704f, 
    0.33170512f, 0.02980984f, 0.07021127f, 0.07816339f, 0.12052386f, 0.06841219f, 0.07014429f, -0.04699130f, 
    -0.27709356f, -0.13672611f, -0.09787472f, -0.16028701f, 0.18434787f, 0.15370645f, 0.04781290f, 0.10018303f, 
    0.07014796f, 0.06260679f, -0.02417619f, -0.02094079f, -0.11542270f, -0.07658537f, 0.09041777f, 0.16985451f, 
    -0.14226861f, 0.11610540f, 0.19933134f, 0.17125675f, -0.16916831f, -0.03121798f, 0.04552565f, -0.02382795f, 
    0.01653064f, -0.00248982f, -0.07386348f, 0.28248733f, 0.13277858f, -0.10802773f, 0.00297819f, 0.02256777f, 
    -0.01815498f, -0.10611316f, -0.05966697f, -0.26093456f, 0.15372905f, -0.31330734f, -0.10456075f, 0.14851904f, 
    0.12629493f, 0.18126796f, -0.04567068f, -0.08922808f, 0.13836113f, 0.11652874f, -0.16813333f, -0.26871222f, 
    -0.05946824f, 0.04332924f, 0.06370686f, -0.12006856f, -0.00781241f, -0.17796610f, 0.07273235f, -0.00644935f, 
    -0.14033909f, -0.23908673f, -0.01225561f, -0.09797673f, 0.14579587f, -0.02407784f, -0.08745606f, 0.23794277f, 
    -0.08206077f, -0.00937545f, -0.16992186f, -0.08818199f, -0.09112354f, -0.12742592f, -0.28316218f, -0.00171272f, 
    0.02435518f, -0.05128331f, -0.05412532f, -0.00117828f, 0.02418604f, -0.02281401f, 0.04082257f, 0.02421628f, 
    0.04649714f, 0.01359918f, 0.05371661f, 0.04132798f, -0.05659109f, 0.04520746f, 0.02867044f, -0.05068999f, 
    0.00724946f, -0.01941529f, -0.00139968f, 0.00857725f, 0.02245556f, -0.03955126f, -0.01055541f, -0.04635506f, 
    0.00615809f, 0.01162938f, -0.06309192f, -0.05223015f, 0.02987164f, 0.04654828f, -0.05410727f, -0.00978348f, 
    0.04718976f, -0.01457000f, 0.03324994f, 0.00624266f, -0.02171990f, 0.05969516f, -0.04707647f, 0.04123412f, 
    0.01484125f, -0.02916560f, 0.03803666f, 0.02972749f, -0.05285969f, 0.06272273f, 0.00528749f, -0.00752021f, 
    0.02509946f, -0.04390340f, 0.00807925f, -0.03789062f, -0.03639216f, -0.02976244f, -0.06657042f, 0.01064210f, 
    -0.02622022f, -0.02168394f, 0.03306333f, -0.07059880f, -0.05224858f, 0.04190413f, 0.00929489f, -0.00093356f, 
    -0.01485818f, 0.02459849f, -0.00255651f, 0.00453279f, -0.00892337f, 0.02818458f, 0.02095680f, -0.03858509f, 
    -0.00589205f, 0.02485499f, -0.05855544f, -0.03237837f, 0.00289339f, -0.05407190f, -0.01945115f, 0.04898028f, 
    -0.05128383f, -0.05780722f, 0.01895303f, -0.02569962f, -0.03770623f, -0.06296491f, 0.04275222f, 0.00155020f, 
    0.00237791f, -0.02007379f, -0.00654711f, -0.05889212f, -0.01527274f, -0.02650741f, -0.03632846f, 0.01341319f, 
    -0.01785194f, 0.02000012f, -0.00846176f, 0.00511224f, 0.01269047f, -0.02447768f, 0.03247443f, -0.04556435f, 
    -0.04731012f, -0.02886664f, -0.02100742f, -0.06125294f, -0.05048941f, 0.04540588f, 0.01451466f, -0.02088528f, 
    -0.03237780f, -0.00493824f, 0.00140749f, 0.02762440f, 0.05238439f, 0.01831496f, 0.04166153f, 0.04846090f, 
    0.00863785f, -0.03490061f, 0.05903954f, -0.04938921f, 0.01330252f, 0.04832998f, -0.02202716f, -0.02168438f, 
    -0.01691496f, 0.01313221f, -0.02282751f, 0.03987975f, 0.00929774f, 0.03791269f, -0.00943589f, 0.03181703f, 
    0.00855169f, 0.00880243f, -0.05984188f, -0.04969202f, 0.01349415f, -0.06435975f, 0.05375169f, 0.01449564f, 
    0.02686323f, 0.04090665f, -0.03306859f, -0.03448478f, 0.00033190f, 0.01426691f, -0.00449314f, 0.05103486f, 
    0.03948165f, 0.02483257f, -0.02703196f, -0.01291242f, 0.02857241f, 0.00594894f, -0.01608891f, 0.02182910f, 
    -0.03747981f, 0.02735778f, 0.01843127f, 0.04098558f, -0.04639489f, 0.01348821f, -0.03197908f, -0.00918435f, 
    -0.07043632f, -0.01031006f, -0.00761297f, -0.01297049f, 0.02127190f, -0.07902249f, -0.03795758f, -0.01619087f, 
    -0.05120447f, -0.00482637f, -0.04289928f, -0.03879750f, -0.00857089f, -0.03603557f, -0.02761237f, 0.02154273f, 
    0.01765024f, -0.02342517f, 0.02352010f, -0.00788340f, -0.04011476f, 0.01975930f, 0.03496962f, -0.02638051f, 
    0.04306386f, -0.04119147f, -0.05656377f, 0.03292768f, 0.03339953f, 0.00488316f, -0.03671642f, 0.04742204f, 
    -0.01114143f, -0.02437581f, -0.06191495f, 0.01144006f, -0.03126270f, 0.01951705f, -0.03823134f, -0.05081925f, 
    -0.00401921f, 0.04261594f, -0.02031794f, 0.02047469f, 0.04009175f, -0.04466107f, -0.04312968f, 0.04346733f, 
    -0.00814882f, -0.03871517f, 0.00353026f, -0.01042769f, 0.04319116f, -0.00741691f, 0.01866371f, 0.03301750f, 
    -0.01588346f, 0.03170128f, 0.00437927f, -0.05420037f, 0.03859437f, -0.02717074f, 0.01535084f, 0.00441639f, 
    -0.06040554f, -0.03042941f, 0.01252790f, -0.05461395f, -0.05724892f, -0.00083810f, 0.04302619f, 0.04436633f, 
    0.00669995f, 0.01995048f, -0.02905090f, -0.01175149f, -0.01275339f, 0.04698482f, -0.02592163f, -0.02869575f, 
    0.00009583f, -0.05972824f, -0.06826571f, 0.01157951f, -0.03364366f, -0.01899870f, -0.01421926f, -0.01322913f, 
    -0.03131552f, -0.05214239f, 0.03866719f, 0.03667226f, 0.02689171f, -0.03407456f, -0.05711014f, 0.02756376f, 
    -0.03415557f, -0.01915248f, -0.01032235f, 0.00435698f, -0.04573764f, 0.00752094f, -0.00631662f, 0.00687474f, 
    0.04611327f, -0.01936168f, -0.01523051f, -0.04916628f, 0.00787840f, -0.02389986f, -0.02560873f, 0.03826639f, 
    -0.07129575f, -0.00491549f, -0.02839491f, 0.03492263f, -0.02512851f, 0.00510681f, 0.04214730f, -0.04842101f, 
    -0.02641757f, 0.04922138f, -0.05154805f, -0.04011717f, -0.05667660f, 0.05325991f, 0.00323781f, 0.00568959f, 
    0.00542236f, -0.05523517f, -0.05107180f, -0.02125770f, 0.02111766f, -0.02063079f, -0.05059412f, 0.03587345f, 
    -0.03838657f, -0.05298150f, -0.03437703f, 0.02528823f, -0.04383656f, -0.03327187f, 0.03663254f, 0.02230210f, 
    -0.05646558f, -0.02514695f, 0.02432033f, -0.01464405f, -0.06431376f, -0.02402791f, -0.03124437f, -0.00343356f, 
    -0.00976895f, -0.01413682f, -0.02214334f, -0.04570444f, -0.04531422f, -0.05179245f, 0.03423694f, -0.05796359f, 
    -0.00592304f, -0.01425610f, 0.01765198f, -0.02144290f, 0.03481051f, -0.05273560f, -0.00985607f, -0.03457317f, 
    0.00011622f, -0.04996647f, -0.04948263f, 0.03665813f, 0.03225410f, 0.02130386f, -0.04952729f, -0.01025568f, 
    -0.02727421f, 0.03673198f, -0.01008018f, -0.06328756f, -0.02879588f, 0.00142145f, 0.05164749f, -0.03081648f, 
    -0.02510553f, -0.05300568f, -0.03757628f, -0.04541687f, -0.04486297f, 0.02954650f, 0.04005010f, 0.01602411f, 
    -0.05935798f, 0.03759126f, 0.00651192f, 0.00566747f, 0.05286418f, -0.02642856f, -0.03154873f, -0.04623120f, 
    0.00363181f, 0.02580274f, 0.05314201f, -0.06043890f, -0.02748332f, 0.00688085f, -0.00483084f, 0.01111596f, 
    0.03762008f, 0.04486535f, -0.06376863f, 0.02483501f, -0.04657704f, 0.01063128f, -0.03925774f, 0.02924999f, 
    0.01582470f, -0.02989274f, -0.03360840f, 0.04274221f, -0.02715456f, -0.00868473f, 0.03689469f, -0.04409748f, 
    -0.05837039f, -0.06122431f, 0.00783127f, -0.05670399f, 0.03683737f, 0.04687252f, -0.04004489f, -0.04565696f, 
    0.04614974f, -0.01870224f, 0.02827208f, 0.02494608f, 0.01061890f, 0.01104860f, 0.04427476f, -0.04576225f, 
    -0.02369361f, 0.03007917f, 0.01748256f, 0.00109969f, 0.03689657f, 0.04519231f, 0.02160393f, -0.05666186f, 
    0.02085299f, 0.03323876f, -0.04842804f, -0.04438041f, -0.01907972f, -0.02963676f, -0.03858813f, 0.01760593f, 
    0.03005563f, -0.04017907f, -0.02571525f, -0.02636250f, 0.03765775f, -0.01130747f, 0.02938471f, 0.01586164f, 
    -0.05862749f, -0.03715752f, -0.03154923f, 0.02006437f, -0.06266599f, -0.01921169f, -0.00382800f, -0.05993435f, 
    0.04845527f, -0.00287694f, -0.03504808f, -0.01362414f, 0.00643467f, -0.06379212f, 0.05280794f, 0.04594865f, 
    -0.04756128f, -0.03215949f, 0.02030980f, -0.04935175f, -0.04764280f, -0.00001510f, 0.00079184f, -0.01228565f, 
    0.03958740f, -0.00761656f, 0.01764042f, -0.02462430f, 0.03504653f, -0.04162132f, -0.04488080f, -0.00704755f, 
    -0.00721651f, -0.04872997f, 0.04282757f, -0.01535820f, 0.03386354f, 0.01375787f, -0.02380039f, -0.02140047f, 
    -0.04067306f, -0.01066931f, 0.00004073f, 0.00859896f, -0.03413630f, -0.03873789f, 0.05081253f, -0.01401751f, 
    0.03539751f, -0.00475074f, -0.05014146f, 0.01008904f, 0.01281085f, 0.01570882f, 0.01626886f, 0.00827552f, 
    -0.06337781f, 0.04189704f, -0.02028137f, 0.05204223f, 0.00088014f, 0.03751513f, -0.00134301f, 0.04199534f, 
    0.00762294f, 0.03395458f, 0.00890923f, -0.01308403f, -0.05255647f, -0.00906155f, -0.05580455f, -0.02576325f, 
    -0.05195070f, -0.04737797f, 0.04499999f, 0.01407554f, -0.02291196f, -0.03933080f, 0.00903739f, -0.05048688f, 
    0.04463618f, -0.04503958f, -0.01832264f, 0.03679948f, -0.05408606f, -0.03339722f, 0.04012962f, -0.00759308f, 
    0.01686991f, 0.05147299f, -0.05823740f, -0.00315581f, 0.05042861f, 0.03753806f, 0.01146746f, -0.02806793f, 
    -0.03659997f, 0.02136598f, -0.06417219f, -0.04857145f, -0.00992549f, -0.06063918f, -0.00078014f, -0.03065752f, 
    0.02003777f, -0.05467051f, -0.00539572f, -0.05908735f, -0.06393984f, -0.01860548f, 0.03613451f, 0.05023160f, 
    0.00407350f, -0.05266400f, -0.03092118f, -0.06169060f, 0.03423786f, -0.00397991f, -0.02234144f, 0.00349732f, 
    0.03101718f, -0.04616982f, -0.06443533f, -0.00101123f, 0.01748852f, 0.01306810f, 0.04256835f, -0.00001309f, 
    0.04299427f, 0.01791996f, 0.01284403f, -0.05407796f, 0.00206331f, 0.05093327f, -0.01090238f, 0.02821387f, 
    0.01484162f, -0.05452688f, -0.00538953f, 0.04930567f, 0.05110063f, -0.06142776f, -0.06132951f, -0.02473581f, 
    -0.06614234f, 0.10248526f, 0.05242963f, 0.02959164f, 0.08868092f, 0.04001196f, 0.09767325f, 0.01907219f, 
    0.12729801f, 0.00532344f, 0.13610950f, 0.17817850f, -0.10071887f, 0.00040995f, -0.22186783f, -0.02498122f, 
    0.06862435f, -0.06630263f, 0.08721139f, 0.08564100f, 0.24609368f, 0.22528224f, 0.13394378f, -0.02025273f, 
    0.12761547f, 0.06378491f, 0.19561972f, 0.02711880f, 0.04584095f, -0.05718592f, 0.14281015f, 0.01792281f, 
    -0.04395064f, 0.04778073f, -0.01808057f, -0.02893539f, -0.06530173f, -0.17445303f, 0.02324611f, 0.04735503f, 
    0.10327423f, 0.03795351f, 0.05960152f, 0.14583637f, -0.09069906f, -0.01400574f, 0.08165179f, 0.22670767f, 
    -0.02641032f, -0.02109740f, -0.10508859f, 0.02175338f, -0.13240618f, 0.11520971f, -0.16032170f, -0.14305562f, 
    -0.21003392f, -0.02731337f, -0.04043092f, -0.04353279f, 0.08738523f, -0.19263890f, -0.09040082f, -0.10307979f, 
    0.03820396f, 0.09261441f, 0.08278883f, -0.10460425f, 0.15527180f, -0.07155621f, -0.03716888f, -0.08796462f, 
    0.04509898f, 0.06427046f, 0.19496250f, -0.17525174f, -0.12997934f, 0.16086692f, 0.14576079f, -0.02514809f, 
    -0.20544356f, -0.12038475f, 0.03957818f, 0.14356299f, 0.17103124f, 0.14666255f, 0.03206606f, 0.00933018f, 
    -0.10903230f, -0.01020896f, -0.23670568f, -0.11079751f, -0.42565033f, 0.14122380f, -0.11430851f, -0.01594460f, 
    -0.05637495f, -0.08962839f, -0.02922742f, 0.23154435f, 0.13041751f, 0.24499153f, -0.07273071f, 0.07473911f, 
    -0.04633372f, 0.06451510f, -0.00116327f, 0.18994451f, -0.04189625f, -0.10633387f, -0.11011570f, -0.05981205f, 
    0.08939353f, -0.00252275f, 0.13770756f, 0.03381689f, 0.08225540f, -0.33061007f, -0.19550668f, 0.06114823f, 
    0.07251896f, 0.16863364f, -0.12688950f, 0.05343969f, 0.15592147f, 0.03624701f, 0.31978992f, -0.16848698f, 
    -0.32958946f, 0.00244347f, -0.00501751f, -0.09116095f, -0.00845105f, 0.01649340f, 0.09118181f, -0.10373328f, 
    -0.17952220f, -0.10263921f, 0.06059079f, 0.15840836f, -0.06456562f, 0.07017062f, -0.10004663f, -0.04322311f, 
    0.02725935f, 0.02187381f, -0.19215147f, 0.02204048f, -0.09982163f, -0.01497468f, 0.03226158f, -0.07434723f, 
    0.00555793f, -0.00193714f, 0.09176653f, -0.08640303f, 0.02305512f, 0.01716392f, 0.01316412f, -0.01783076f, 
    -0.11237931f, -0.22349142f, -0.15015063f, -0.00499544f, 0.00321662f, 0.14083120f, 0.02168084f, 0.02661749f, 
    -0.08473590f, -0.07921790f, -0.03262724f, 0.15341011f, -0.07629292f, -0.15023477f, 0.14784119f, 0.18275020f, 
    0.07634209f, 0.11719584f, -0.01124090f, 0.08381861f, 0.15485512f, -0.19880134f, -0.04423264f, 0.13858408f, 
    0.01245013f, 0.05561858f, -0.09560021f, 0.13632935f, 0.08080558f, -0.03563756f, -0.02132612f, 0.16882277f, 
    -0.11373046f, -0.06232308f, -0.03254821f, -0.00144752f, 0.01975577f, -0.00755463f, 0.14952919f, 0.04476561f, 
    0.13182318f, -0.12786178f, 0.10286868f, -0.27314425f, 0.05001731f, 0.07629806f, 0.08523478f, -0.12159213f, 
    -0.16294433f, -0.27215502f, -0.06399348f, 0.00315795f, 0.10750683f, -0.06983466f, -0.01676429f, -0.01842103f, 
    0.03578358f, -0.03275638f, -0.07688162f, 0.06086186f, -0.14809987f, -0.01570648f, 0.04196082f, -0.04258885f, 
    0.12435543f, -0.17808920f, -0.06329434f, -0.30970362f, 0.13842170f, -0.00030436f, 0.07314677f, 0.05430961f, 
    -0.11772609f, -0.05549752f, -0.32535273f, -0.03352064f, 0.00438727f, 0.19922172f, 0.16045792f, -0.09416012f, 
    -0.04141158f, -0.02019017f, -0.09426662f, -0.27020004f, -0.16930510f, -0.23691230f, 0.06748084f, 0.03008018f, 
    0.01259808f, 0.05606652f, 0.04921030f, 0.00446874f, -0.06467641f, 0.14430957f, 0.06311124f, -0.08314333f, 
    -0.02634862f, 0.10009675f, 0.04725500f, 0.02781396f, 0.22096853f, 0.03261466f, 0.29543194f, 0.25377890f, 
    -0.16031639f, 0.01212418f, 0.08891784f, -0.02132277f, 0.00101058f, -0.14314611f, 0.04324413f, 0.03912201f, 
    0.32002875f, 0.00639296f, 0.05122275f, -0.05272163f, -0.11943944f, 0.02510603f, 0.20476669f, -0.35271755f, 
    -0.05173288f, 0.00042042f, 0.08027034f, 0.13912672f, -0.06038626f, -0.10612208f, -0.09671705f, 0.01430220f, 
    0.15290223f, -0.03509420f, -0.04070381f, -0.00740216f, 0.00657175f, 0.05280243f, 0.00015403f, -0.03666142f, 
    0.04281705f, 0.17776586f, -0.48462248f, -0.17615062f, 0.14273420f, 0.12090035f, -0.09250173f, 0.01661378f, 
    -0.18182790f, -0.07486830f, -0.60067141f, -0.52334028f, 0.03314834f, 0.17983533f, 0.14071541f, 0.10526173f, 
    -0.07435828f, -0.02389956f, -0.02536167f, -0.04253824f, -0.05344642f, -0.15386482f, -0.00822023f, -0.04843559f, 
    0.00206815f, -0.13699672f, -0.00907333f, 0.02223962f, -0.22523703f, -0.43318993f, -0.12706681f, 0.00618670f, 
    -0.00892093f, 0.12337483f, 0.05534611f, 0.04422026f, 0.11152483f, -0.06805375f, -0.16463052f, -0.05124440f, 
    0.25679919f, 0.12706877f, 0.14538364f, 0.01005492f, 0.04630201f, 0.04126099f, -0.32127261f, 0.07174087f, 
    -0.03009407f, 0.06056243f, 0.18984856f, -0.12224098f, -0.20539421f, -0.07565957f, 0.02374939f, 0.03148365f, 
    -0.10474078f, 0.12769647f, -0.05052951f, -0.06051133f, 0.07140515f, 0.22190084f, -0.04708482f, -0.21113575f, 
    -0.03537620f, -0.08716395f, -0.02660976f, 0.12566271f, -0.06309200f, 0.11198452f, 0.11251669f, -0.12990947f, 
    0.01266292f, -0.51564240f, -0.02385816f, -0.07842647f, -0.12336747f, -0.02821369f, 0.05662816f, 0.03468832f, 
    0.08322442f, 0.04811668f, -0.11086803f, 0.01349753f, -0.03745404f, -0.17514795f, -0.02525373f, 0.04811536f, 
    0.04088903f, 0.04679527f, 0.04605381f, 0.27380508f, 0.13994664f, 0.04585872f, 0.16935889f, 0.05688919f, 
    0.17539448f, -0.03687094f, 0.05496185f, -0.07948828f, 0.02749637f, -0.02308318f, 0.26991451f, 0.17755398f, 
    0.17363983f, 0.06053481f, 0.03188097f, 0.05221701f, 0.12419438f, 0.39360645f, 0.01162213f, 0.04759516f, 
    -0.16937011f, -0.10890913f, -0.11944741f, -0.11991422f, 0.04500512f, -0.04589590f, 0.22864603f, 0.26250744f, 
    -0.23707445f, 0.05177217f, 0.14862880f, 0.00368398f, -0.10125741f, 0.01646561f, 0.01736700f, -0.19568983f, 
    -0.03751278f, -0.10949223f, -0.09192789f, 0.08842612f, -0.08081739f, -0.00278655f, -0.01893957f, -0.10752014f, 
    -0.15535350f, 0.13063574f, 0.00101705f, 0.04101032f, 0.02697233f, 0.02104625f, 0.24883181f, 0.03219647f, 
    -0.05500822f, -0.03255524f, 0.02393866f, -0.06141593f, -0.05365576f, 0.03887926f, -0.07049516f, 0.04127643f, 
    -0.14393137f, -0.00005179f, 0.08206735f, -0.13425259f, -0.20518395f, -0.17095859f, -0.02357479f, -0.09098025f, 
    -0.09506872f, 0.01698642f, 0.03193323f, -0.04445781f, 0.20716244f, -0.03340715f, 0.06388395f, -0.12003935f, 
    0.13410769f, 0.04358057f, 0.03172784f, 0.09504845f, 0.03366816f, 0.12541984f, -0.06651986f, -0.06567945f, 
    0.04477440f, 0.03944712f, -0.07654877f, 0.02521342f, 0.00108656f, -0.06949872f, -0.18933885f, -0.22673637f, 
    -0.08887368f, 0.08231230f, -0.21076050f, -0.01420968f, 0.11891776f, 0.14026158f, 0.13105761f, 0.33696449f, 
    0.18349677f, -0.00282590f, 0.04058374f, 0.05402292f, -0.02766802f, -0.06556690f, -0.01868560f, 0.29105312f, 
    0.07712060f, -0.20649499f, -0.03376329f, 0.02343962f, 0.03179352f, -0.16163462f, 0.24410462f, -0.06045267f, 
    0.05974724f, 0.11437891f, -0.00265887f, 0.03780425f, -0.13808502f, 0.00392644f, 0.09186565f, 0.22239180f, 
    -0.04959949f, -0.15196283f, -0.02821135f, 0.18693782f, -0.05332971f, 0.06288053f, 0.03809650f, -0.04395173f, 
    -0.02834437f, -0.10489774f, 0.05614207f, -0.02026115f, -0.16969965f, -0.21285741f, -0.07452182f, 0.03392796f, 
    -0.02960587f, -0.03369681f, 0.05989253f, 0.09391795f, 0.01555926f, 0.06551462f, 0.01086198f, 0.06830887f, 
    -0.02246033f, 0.07826888f, 0.06365436f, 0.00236896f, 0.33970073f, 0.16594876f, 0.04678214f, 0.16144055f, 
    0.05125919f, -0.01467351f, -0.06073066f, 0.01878246f, 0.19414659f, -0.12790298f, 0.11631859f, -0.11214563f, 
    0.02056951f, -0.14462011f, -0.02708809f, 0.03547307f, -0.00498315f, 0.00570593f, -0.05129785f, -0.22330236f, 
    -0.02523598f, -0.06550386f, -0.07293897f, 0.01902000f, -0.10705427f, -0.08131775f, -0.01071347f, 0.16933666f, 
    0.08625692f, 0.01659681f, -0.10076427f, -0.02756966f, -0.12853879f, -0.05554152f, 0.00080479f, -0.10990087f, 
    0.02230358f, -0.06477181f, 0.01110685f, -0.02211127f, 0.02711616f, 0.02500875f, -0.02042983f, -0.06039574f, 
    -0.05511754f, 0.03165800f, -0.04823365f, -0.05107209f, 0.03650957f, -0.01898612f, 0.00950263f, -0.04893506f, 
    -0.03244344f, 0.03436841f, -0.01773722f, 0.02910488f, 0.00250677f, -0.00086002f, 0.02484461f, -0.04067681f, 
    -0.03780407f, -0.04184853f, -0.04266036f, 0.04042238f, -0.03059013f, -0.00582303f, 0.01676106f, 0.03147884f, 
    0.02095488f, -0.00648001f, -0.02263151f, -0.02903488f, 0.04871503f, -0.02010083f, -0.00783634f, -0.01503202f, 
    0.01871679f, 0.04660824f, 0.02019551f, 0.02185323f, -0.05794825f, -0.00077398f, -0.02835067f, -0.06804108f, 
    -0.02954816f, -0.00781174f, -0.04977410f, -0.05184398f, 0.02416367f, 0.04217593f, -0.03506290f, 0.02906039f, 
    -0.05521015f, 0.04591302f, -0.01188239f, 0.00110753f, 0.04753000f, 0.02084588f, 0.00997411f, -0.00579304f, 
    -0.05151071f, -0.01289357f, 0.04093442f, 0.03771160f, 0.00088154f, 0.01989392f, -0.04444782f, 0.00692607f, 
    -0.04149146f, 0.03702233f, 0.05118182f, -0.02592647f, 0.03816158f, -0.03472928f, 0.03687219f, -0.02335753f, 
    -0.03726290f, -0.05374508f, 0.01329905f, -0.02772679f, -0.07731223f, -0.03047495f, 0.03750348f, -0.01951740f, 
    0.05208528f, -0.00456729f, -0.02657731f, -0.04041340f, 0.00589526f, 0.03464940f, -0.05993808f, -0.04100171f, 
    -0.03623915f, -0.04750361f, 0.01220174f, -0.03307708f, -0.05802386f, -0.00919080f, 0.05348804f, -0.04292047f, 
    -0.04352446f, 0.04839205f, 0.00715753f, 0.03289035f, -0.01707908f, 0.04780601f, -0.02676617f, -0.02859328f, 
    0.03497520f, -0.01587809f, -0.02071637f, -0.04926057f, -0.02115155f, 0.01750219f, 0.01309517f, 0.01350582f, 
    -0.01653335f, -0.06075386f, 0.00293963f, -0.03368682f, -0.05354070f, -0.03104551f, 0.03895128f, 0.00896837f, 
    -0.05257701f, -0.02321259f, 0.01540809f, 0.00897098f, -0.05774196f, -0.06385577f, -0.04078124f, 0.01414728f, 
    -0.05491919f, -0.04444914f, -0.01035125f, -0.06225688f, 0.00615034f, -0.01229564f, -0.00240323f, 0.01805191f, 
    0.05155166f, -0.05627071f, 0.01355788f, 0.02596210f, -0.02623411f, -0.03462704f, -0.05082853f, 0.02830528f, 
    0.02251998f, -0.03845350f, -0.06445576f, -0.02202217f, -0.04298903f, 0.03854398f, 0.01948668f, 0.04632658f, 
    -0.04164631f, 0.04967888f, 0.00345486f, 0.00060995f, -0.03612866f, -0.02508726f, 0.04332656f, -0.03526330f, 
    0.03394018f, -0.02260895f, -0.05284119f, -0.03439214f, 0.03455063f, -0.04313568f, 0.00702980f, -0.00987613f, 
    -0.01731123f, -0.06219064f, 0.01668633f, -0.03030254f, -0.01360145f, -0.00502044f, -0.03652792f, 0.01129082f, 
    0.04766230f, -0.03510016f, 0.00496633f, -0.00056561f, -0.00248063f, 0.04056831f, 0.05073255f, 0.04815521f, 
    0.03706419f, -0.03775661f, -0.05143847f, -0.07241251f, 0.04893724f, -0.01734239f, 0.02332664f, 0.02699313f, 
    -0.01504489f, 0.03625120f, 0.02049240f, 0.04128526f, -0.04283695f, -0.02147385f, 0.01204868f, -0.01711845f, 
    -0.02089551f, 0.01232051f, -0.01576602f, -0.02715994f, -0.04231313f, 0.05829054f, -0.04539856f, -0.02186118f, 
    0.02563714f, -0.02773750f, 0.02568737f, -0.01142664f, -0.01319266f, -0.04817366f, -0.00235751f, -0.01952132f, 
    -0.06346680f, 0.01853726f, -0.04735016f, -0.04931322f, -0.04054442f, -0.01743923f, -0.00170626f, -0.03542137f, 
    -0.05817236f, 0.03968039f, 0.04430946f, 0.05698953f, -0.00657733f, -0.07244184f, 0.01937080f, 0.03664932f, 
    0.02313343f, -0.02187331f, -0.02967534f, -0.03216816f, 0.00529100f, -0.03277803f, 0.04458800f, -0.06868517f, 
    -0.02108277f, -0.02967563f, 0.00047941f, -0.01949776f, 0.02330469f, 0.03668412f, 0.05050374f, -0.03603234f, 
    -0.03224029f, -0.01757406f, 0.03946180f, 0.03666896f, -0.05264807f, -0.01942221f, -0.00516306f, -0.02017526f, 
    0.01028376f, 0.01658173f, 0.02512573f, -0.05121296f, -0.05810739f, -0.02297352f, -0.04189254f, -0.02540142f, 
    -0.00369230f, -0.03639324f, -0.06027909f, 0.02679863f, -0.04281962f, -0.02923136f, 0.03316612f, -0.04012166f, 
    0.02812428f, 0.04272483f, 0.00614875f, 0.01035373f, 0.02444879f, -0.00521309f, 0.03410828f, -0.00291606f, 
    0.03469553f, 0.04863714f, -0.01267644f, 0.03513541f, 0.00595637f, -0.02700084f, 0.00654847f, -0.04872573f, 
    -0.05955849f, 0.00929843f, -0.02005303f, 0.01210883f, -0.00490024f, 0.02602144f, -0.00986709f, -0.05838151f, 
    0.03331333f, -0.00153541f, -0.02145489f, 0.02792220f, 0.04641567f, -0.03706110f, -0.06143300f, 0.04782001f, 
    0.04415796f, -0.06140855f, 0.04386777f, 0.05301233f, 0.04342287f, 0.05279602f, -0.01275893f, -0.03581001f, 
    -0.06065670f, 0.04181170f, 0.02319745f, -0.05513881f, 0.02923468f, -0.01913383f, -0.00139748f, 0.04633997f, 
    -0.06307923f, 0.01186619f, -0.02531458f, -0.06225817f, -0.02097984f, 0.00076193f, -0.02796892f, -0.06897141f, 
    -0.05344326f, -0.05805590f, 0.03438018f, -0.04344722f, -0.00499743f, -0.04227838f, 0.04518201f, -0.03687255f, 
    0.01204000f, -0.02124947f, 0.01713830f, 0.04433186f, -0.02048372f, -0.01530778f, -0.00824386f, -0.02922095f, 
    -0.03058781f, -0.04616853f, -0.01471264f, 0.00062714f, -0.03032929f, -0.05086871f, 0.01048166f, 0.02642313f, 
    0.03579058f, -0.00126146f, -0.03568366f, 0.02205359f, -0.02365660f, 0.00229600f, 0.01250839f, -0.02990310f, 
    0.00336931f, 0.02963706f, -0.03133392f, 0.03108760f, 0.02485699f, 0.01299612f, 0.01918457f, -0.06443956f, 
    0.05236560f, 0.05433911f, 0.00520578f, 0.02944013f, -0.00701230f, -0.00772044f, -0.03548502f, 0.02120078f, 
    -0.05104635f, 0.01247244f, -0.06169575f, 0.02852929f, -0.01261227f, 0.02215664f, 0.02568148f, -0.01462777f, 
    -0.05531903f, -0.04308203f, 0.04274516f, 0.00236714f, 0.03170747f, 0.02594698f, -0.02032940f, -0.04352088f, 
    0.04847229f, 0.02149928f, 0.03753556f, -0.00564523f, -0.01365131f, -0.05314318f, -0.04855264f, 0.04474149f, 
    0.02957011f, -0.05198387f, 0.02082608f, -0.01741427f, 0.03215640f, 0.03137683f, -0.01845000f, 0.01442277f, 
    0.03395681f, -0.05131821f, 0.00122978f, 0.03639305f, -0.03186760f, -0.03606943f, -0.04233228f, -0.06135386f, 
    -0.02698961f, -0.03756038f, -0.05764856f, 0.01151043f, -0.03054310f, -0.05833250f, -0.01600676f, 0.03218263f, 
    -0.05548495f, 0.02645257f, -0.05104522f, -0.04854034f, -0.06178454f, 0.05556799f, 0.00603536f, -0.04843428f, 
    0.00947254f, 0.00660162f, 0.04479349f, 0.02091195f, 0.01097783f, 0.05020546f, -0.04899581f, -0.01846008f, 
    0.00400928f, 0.03371024f, 0.04174626f, -0.04641588f, 0.00206194f, -0.02359707f, -0.04851916f, -0.03784829f, 
    -0.02399860f, -0.04268762f, -0.01062335f, 0.00746342f, -0.05092429f, -0.00337558f, -0.02129830f, 0.00384001f, 
    -0.00186133f, 0.01501234f, -0.00000691f, 0.04031894f, -0.04863070f, 0.04827559f, -0.00564113f, 0.02656155f, 
    0.03021712f, -0.04352824f, 0.00824051f, 0.03883202f, -0.00982216f, 0.01817982f, 0.00911396f, -0.02892803f, 
    -0.06345698f, -0.04180013f, -0.00551936f, 0.03006817f, -0.06341513f, 0.03239264f, 0.04071058f, -0.03608057f, 
    0.03858604f, -0.03438525f, -0.05842943f, -0.00452923f, 0.04760069f, -0.02608643f, -0.00841494f, 0.04568144f, 
    -0.02224633f, 0.00374307f, 0.02296681f, 0.02683447f, -0.04353847f, 0.02231921f, -0.01486168f, -0.06607198f, 
    0.00316348f, 0.02863367f, -0.04205073f, -0.04560959f, 0.01348623f, -0.00962105f, -0.03758536f, 0.01509534f, 
    -0.04052650f, 0.00269920f, -0.03447476f, 0.00328291f, 0.02842848f, 0.04880412f, 0.02500722f, -0.04719491f, 
    -0.06080257f, -0.05427132f, 0.03759411f, 0.01792333f, -0.04360921f, 0.03732705f, 0.03038255f, -0.01337456f, 
    0.00660544f, -0.00288515f, 0.02856388f, 0.01302476f, 0.02368225f, -0.05137393f, -0.02223611f, -0.01940608f, 
    -0.05568601f, -0.01655469f, 0.04108541f, -0.00001528f, 0.01957665f, 0.01980381f, 0.03887828f, -0.02150600f, 
    -0.03217321f, -0.06017432f, 0.00729986f, -0.02702038f, -0.02465041f, -0.03900927f, 0.03592915f, -0.05661991f, 
    0.02740163f, 0.03755544f, 0.03374264f, 0.03816574f, 0.04289746f, 0.01592396f, 0.00537705f, -0.03943404f, 
    0.04850243f, -0.04420656f, -0.03182784f, -0.02575462f, 0.01755401f, -0.04843128f, -0.05882925f, -0.06055703f, 
    0.00553704f, -0.01481308f, 0.03617388f, -0.02278806f, -0.02534277f, -0.07007713f, -0.04668356f, 0.02795592f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.11501841f, -0.00870215f, -0.04960091f, -0.02143403f, 0.03652850f, 0.02328017f, 0.19937478f, -0.03113548f, 
    0.00817768f, -0.02316736f, 0.09818620f, 0.03140358f, 0.04346278f, 0.00973337f, -0.06680103f, -0.16959056f, 
    0.14400706f, -0.02477174f, -0.00320556f, -0.00836535f, 0.03102455f, -0.00400997f, 0.07041800f, 0.12641205f, 
    0.01347478f, 0.01797592f, -0.06623155f, -0.01959827f, 0.18113065f, 0.06523363f, -0.01790065f, -0.05165339f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08584471f, 0.11908568f, -0.15638141f, 0.09223933f, -0.02334603f, 0.02802179f, -0.00914600f, 0.06002453f, 
    0.17481732f, -0.05530558f, 0.21301092f, -0.08825415f, 0.13718827f, 0.03227796f, 0.15881880f, -0.30302086f, 
    -0.53231740f, -0.01270242f, -0.12138339f, 0.03169456f, 0.07108382f, -0.02150431f, -0.00460981f, 0.63556594f, 
    -0.12821150f, 0.31536821f, -0.00871509f, -0.05793925f, -0.02310350f, 0.28849712f, 0.08639017f, -0.01473942f, 
    0.12211558f, 0.04570408f, 0.38833964f, 0.13773696f, -0.09654599f, -0.05571101f, -0.07203595f, -0.15120727f, 
    0.17863759f, -0.13999788f, 0.17408097f, -0.03916483f, 0.09138968f, -0.02516676f, 0.17098880f, 0.07330003f, 
    -0.12322362f, -0.01657249f, -0.39898777f, 0.14771870f, -0.27401400f, 0.29849970f, -0.19360919f, -0.14674510f, 
    -0.03651399f, -0.28922498f, 0.15413660f, 0.04298026f, 0.13430536f, 0.39274287f, -0.14803357f, -0.01553491f, 
    0.38191670f, -0.12965077f, 0.52232200f, 0.17301011f, -0.06297936f, 0.16231261f, 0.05072848f, 0.16771175f, 
    -0.28129655f, -0.03405141f, -0.48760575f, 0.13120930f, -0.09148131f, -0.08649164f, 0.00183682f, 0.33293813f, 
    -0.14105283f, -0.09360351f, 0.11512347f, -0.03571057f, 0.14884126f, 0.07580964f, 0.09604912f, 0.12327188f, 
    -0.07787057f, -0.19632827f, 0.08704817f, 0.05955964f, 0.28101054f, -0.26441553f, 0.09595922f, -0.15463251f, 
    0.12795480f, -0.03305141f, 0.05017596f, 0.16387881f, 0.09386165f, -0.15477403f, 0.12031991f, -0.10650741f, 
    0.02584463f, 0.14717458f, 0.24260595f, 0.16760153f, 0.11939605f, -0.00272610f, -0.00571456f, 0.38739315f, 
    0.12776287f, -0.14730002f, -0.05787618f, 0.14863923f, 0.07001112f, 0.50242805f, -0.13806926f, -0.43223697f, 
    0.00580598f, 0.17527649f, -0.03185426f, 0.13091527f, -0.11625566f, -0.29782668f, 0.05380346f, 0.12037668f, 
    0.19138509f, -0.00326779f, -0.06450763f, 0.16145438f, 0.15582129f, -0.11421759f, 0.22225769f, 0.09512370f, 
    0.21513285f, 0.13004753f, -0.16862455f, -0.15483375f, -0.10273463f, -0.09116983f, -0.03181817f, -0.01738886f, 
    0.01453660f, 0.08976360f, -0.30622831f, 0.08880753f, 0.23281750f, 0.08013801f, -0.20427087f, -0.52276438f, 
    0.16178335f, -0.22824371f, 0.06034267f, -0.12456693f, 0.10518228f, 0.14210573f, -0.17751576f, 0.12826605f, 
    -0.16630982f, 0.12193676f, 0.02230795f, -0.06985684f, 0.02422520f, -0.14480729f, -0.14599399f, 0.03854399f, 
    0.32856241f, 0.14903627f, 0.62053090f, 0.17112800f, -0.17502947f, -0.04123266f, -0.16447863f, -0.10317912f, 
    0.12988402f, -0.09976374f, 0.22651038f, -0.03561842f, 0.06291046f, 0.22363867f, 0.15674168f, -0.22265773f, 
    0.16165659f, 0.23918155f, 0.07503857f, 0.03982406f, -0.17068431f, 0.10048348f, 0.13079351f, 0.02667137f, 
    0.12363504f, 0.04027607f, 0.46490157f, 0.04326516f, -0.05301479f, 0.16286464f, 0.18958110f, -0.00860303f, 
    -0.26494226f, 0.03614178f, 0.28563881f, -0.16610385f, -0.04875030f, -0.16363312f, -0.14501481f, 0.03418473f, 
    -0.15007548f, -0.02847661f, 0.38124466f, 0.16791117f, -0.23591529f, -0.25988385f, 0.15164728f, -0.22244138f, 
    -0.04575760f, -0.26527074f, 0.08405588f, -0.07936436f, 0.31218946f, -0.05768605f, 0.14185518f, 0.07769036f, 
    -0.14813727f, 0.03993219f, 0.09364629f, -0.11467617f, -0.03058056f, 0.02038232f, -0.20190726f, 0.09347058f, 
    -0.22248635f, -0.07165474f, -0.10000963f, -0.11085071f, 0.09869114f, 0.17229460f, -0.17668512f, -0.04256542f, 
    -0.12189264f, 0.15378480f, -0.10193502f, -0.06402822f, -0.12174384f, -0.01508308f, 0.02000583f, -0.12638111f, 
    -0.14549518f, 0.10436346f, 0.13932993f, 0.03022235f, 0.01374070f, 0.07215124f, -0.00609765f, -0.03456418f, 
    0.29905957f, -0.08011933f, -0.32831582f, 0.18673158f, 0.10728531f, -0.11606514f, -0.14021410f, -0.03436669f, 
    -0.15779816f, -0.01545872f, 0.07525910f, -0.01903332f, -0.04777332f, -0.08968234f, -0.16748063f, 0.37175846f, 
    0.34952992f, -0.07367076f, 0.20260057f, 0.00505888f, 0.23872346f, 0.20716640f, -0.08629812f, -0.42090821f, 
    0.18770011f, -0.07600647f, 0.13334405f, 0.10632420f, 0.06307270f, 0.07209107f, -0.11323947f, -0.16933602f, 
    0.21567418f, -0.07439070f, 0.53421485f, 0.16454910f, -0.10540048f, 0.10263918f, 0.04983352f, 0.10087102f, 
    0.19127503f, -0.05813634f, -0.01829709f, 0.02263570f, 0.06978418f, 0.07101950f, -0.15762553f, 0.28370208f, 
    -0.18464980f, 0.13918541f, -0.09144937f, -0.17705366f, 0.36289623f, -0.44622871f, -0.10467649f, -0.73400581f, 
    -0.10935610f, -0.02552640f, -0.04269957f, -0.12315151f, -0.53644204f, 0.16911812f, -0.14723687f, -0.14923340f, 
    0.00470885f, -0.11789458f, 0.42526957f, 0.00535732f, 0.08776935f, 0.12403113f, -0.18975697f, 0.13295591f, 
    0.28835425f, -0.01022566f, 0.48303750f, 0.11233348f, 0.07514062f, 0.11536276f, 0.08878099f, -0.14184780f, 
    0.12664533f, 0.02623575f, 0.35263258f, -0.00074870f, -0.25225973f, -0.19278611f, -0.02980544f, 0.27617773f, 
    -0.04749339f, -0.10012554f, -0.16786028f, 0.00149426f, 0.02614164f, 0.36569276f, -0.03742285f, 0.12295136f, 
    0.12440544f, 0.08420855f, 0.03452519f, 0.13731599f, 0.12256639f, -0.04228157f, 0.18261540f, -0.05863273f, 
    0.09703187f, -0.06266662f, 0.25251201f, -0.15210649f, 0.12154512f, -0.00329247f, 0.09264890f, -0.16028348f, 
    0.56293160f, 0.15846136f, 0.11806693f, -0.08061933f, -0.29145792f, 0.13140351f, -0.55797607f, 0.03706476f, 
    -0.06133940f, 0.37499651f, 0.15314393f, -0.16024947f, -0.26812378f, -0.60688496f, -0.01026028f, -0.11817816f, 
    -0.13097432f, -0.09613819f, -0.00269487f, -0.09898876f, 0.05964220f, 0.08317283f, -0.17144987f, -0.04935102f, 
    0.01618910f, -0.01356781f, 0.12746079f, 0.09686078f, -0.02991813f, 0.11853358f, 0.11229236f, -0.10923288f, 
    -0.11705742f, -0.05006410f, -0.12522164f, 0.12053623f, 0.00173117f, 0.15714955f, 0.11536396f, 0.00164978f, 
    -0.16124462f, -0.10902440f, 0.15134442f, -0.16302665f, -0.08365773f, 0.03414802f, 0.06810529f, 0.00028792f, 
    -0.15171307f, 0.13303111f, -0.16221809f, 0.04448006f, -0.07125772f, -0.12799385f, -0.14953448f, -0.05506254f, 
    0.11576142f, -0.00083994f, -0.10058311f, 0.05177369f, 0.15911794f, -0.09264348f, 0.07083342f, 0.10322577f, 
    0.05061539f, 0.10350713f, -0.03676504f, 0.15573762f, -0.09648071f, -0.06541101f, 0.03350611f, -0.11599175f, 
    0.07163846f, -0.03151814f, 0.11736065f, -0.11551742f, -0.02894153f, -0.11149607f, -0.05901631f, -0.03179618f, 
    0.05570610f, -0.11546759f, 0.12094657f, -0.09550131f, -0.08065652f, 0.06333842f, 0.00069411f, -0.01867475f, 
    0.12632377f, 0.10740795f, 0.00047707f, -0.03804150f, -0.02683566f, 0.02253874f, 0.13637017f, -0.01434070f, 
    -0.24636823f, -0.03873883f, 0.49742198f, -0.06900835f, 0.29341984f, -0.36837456f, 0.17537889f, -0.12085919f, 
    -0.18014205f, 0.24567778f, 0.08635489f, -0.00584393f, -0.31406993f, 0.52473158f, -0.13074020f, 0.17428410f, 
    -0.06436518f, 0.13733171f, 0.13848151f, -0.02864274f, -0.11563352f, 0.00473742f, -0.22369069f, 0.05753677f, 
    0.17620066f, 0.12415982f, 0.61111623f, 0.08016627f, -0.12059665f, 0.14216101f, 0.02824084f, -0.16997451f, 
    0.28002498f, 0.01474971f, 0.02593655f, -0.04193497f, -0.29778314f, 0.12936895f, -0.12626395f, 0.00655397f, 
    0.04758079f, 0.17870136f, 0.08644373f, 0.03442325f, 0.19338234f, -0.03920203f, 0.14328444f, -0.04090775f, 
    0.19929600f, -0.06451172f, -0.12153738f, 0.12458036f, 0.04091088f, 0.06185365f, 0.09266400f, -0.07953469f, 
    0.31986672f, 0.08698043f, 0.10290509f, -0.08286721f, 0.04554785f, -0.06052879f, 0.12974943f, 0.08368238f, 
    0.09747005f, 0.11990038f, -0.43070778f, 0.14585176f, -0.29491422f, -0.02886539f, -0.04764603f, -0.17085393f, 
    0.05880738f, 0.18254289f, -0.14827715f, -0.04455645f, -0.49133033f, 0.53354889f, -0.09909359f, -0.04054425f, 
    0.35624751f, 0.08316225f, 0.23452562f, 0.10129968f, -0.15029109f, -0.13577680f, 0.12387972f, -0.17392592f, 
    0.02110797f, 0.08375092f, -0.44678324f, -0.16508773f, 0.06037604f, -0.06019956f, -0.03432331f, 0.30237877f, 
    -0.09287644f, -0.13984744f, -0.02066510f, -0.06659265f, -0.30974919f, 0.50193638f, 0.02047311f, 0.21308677f, 
    0.15267363f, -0.03593413f, -0.16808631f, 0.09664529f, -0.15943182f, 0.23654035f, -0.03330745f, -0.17631619f, 
    0.35439438f, 0.02753706f, -0.17096776f, -0.16025168f, 0.01293219f, -0.13087314f, 0.28335068f, 0.00476716f, 
    0.08194132f, 0.14629641f, -0.42587155f, 0.02830572f, 0.12674074f, -0.15952863f, 0.00572874f, 0.21937771f, 
    0.08709083f, -0.08169149f, 0.16472554f, -0.11315534f, 0.04186863f, 0.12052596f, -0.14475530f, -0.31434214f, 
    0.08852083f, -0.08387598f, 0.11383815f, -0.09916355f, -0.25743443f, 0.31821197f, -0.08948501f, -0.04811268f, 
    -0.17907335f, -0.04204708f, 0.03024562f, 0.01347191f, -0.07357529f, 0.16004816f, -0.28763744f, -0.04247494f, 
    -0.05961283f, -0.00177538f, 0.15349293f, -0.06950475f, -0.00960021f, 0.16764876f, 0.07067993f, 0.40880546f, 
    -0.28052366f, 0.06149037f, 0.18258452f, -0.13599879f, -0.39373186f, 0.33605877f, -0.16632754f, 0.14041083f, 
    0.10425532f, 0.16230422f, 0.05727058f, -0.14431359f, 0.10738243f, -0.04253099f, 0.15817320f, -0.15217218f, 
    -0.25613922f, 0.10712692f, -0.12702140f, 0.16807640f, -0.07067059f, -0.15214446f, -0.18624076f, 0.13537589f, 
    0.10901927f, 0.12998386f, 0.39752471f, -0.13052653f, 0.07671455f, -0.01633169f, -0.02774845f, 0.06282564f, 
    0.01196346f, -0.01426154f, 0.36824512f, -0.17317414f, -0.47425005f, 0.20277277f, -0.19753000f, 0.16160725f, 
    0.08426896f, 0.10607629f, -0.03343680f, 0.02715890f, 0.21981801f, -0.19778991f, 0.09459250f, 0.14510716f, 
    0.13591430f, 0.06614910f, -0.48814988f, 0.16250184f, 0.11966537f, 0.03529833f, 0.15357931f, 0.05464259f, 
    -0.02187137f, -0.14808282f, 0.05822943f, -0.17493956f, -0.05429874f, -0.11635935f, -0.04566735f, -0.10511642f, 
    -0.28686476f, 0.15425472f, -0.43257102f, 0.13928050f, 0.47302651f, -0.32625991f, -0.14058313f, 0.42981526f, 
    -0.00736077f, 0.16224462f, -0.14400813f, -0.07933237f, 0.28180364f, 0.21519086f, 0.14950131f, -0.13725281f, 
    -0.23113367f, 0.05455696f, 0.29909882f, 0.16280749f, 0.09790012f, -0.06174606f, 0.07582382f, -0.11378732f, 
    0.37977165f, 0.13934627f, -0.03416957f, 0.11254366f, 0.15432832f, -0.03809473f, -0.10698414f, 0.43438643f, 
    -0.20879965f, 0.17198293f, 0.21906163f, 0.05276450f, -0.10184707f, -0.09597216f, 0.39441428f, -0.14716892f, 
    -0.03374353f, -0.06506994f, 0.06654005f, 0.12001400f, -0.06620178f, 0.07428098f, 0.04527974f, -0.02785837f, 
    0.28402248f, 0.03258438f, 0.07595377f, 0.14433444f, -0.14614454f, -0.10392509f, -0.06402697f, 0.00984223f, 
    -0.46914479f, 0.12218904f, -0.04047735f, -0.07967959f, 0.04570929f, 0.01846979f, 0.05888395f, -0.25431040f, 
    -0.11920504f, 0.09154122f, 0.28026298f, 0.06760350f, 0.09843434f, 0.36793372f, -0.21091621f, -0.10265815f, 
    0.14954644f, 0.32828513f, 0.15135653f, -0.05382036f, 0.20124960f, 0.09471819f, -0.03280531f, 0.02456654f, 
    0.19307315f, -0.16403571f, -0.05545425f, 0.16368292f, 0.08792111f, -0.14410542f, -0.06792886f, -0.06076778f, 
    -0.11633149f, -0.00077507f, 0.03762918f, -0.05807788f, 0.03023891f, -0.17991361f, -0.11366551f, -0.01371429f, 
    0.68012697f, -0.16752960f, 0.42553136f, -0.03482514f, -0.25432339f, -0.11922939f, -0.60396135f, 0.01235117f, 
    0.02670564f, 0.27128142f, 0.13735425f, -0.08880383f, -0.27359173f, -0.23012032f, 0.16346756f, -0.08955467f, 
    0.20881888f, -0.07390427f, -0.16891900f, 0.07345202f, -0.07698051f, -0.06841306f, 0.22542261f, -0.12959237f, 
    -0.14921977f, -0.03300049f, 0.20829113f, 0.02062817f, 0.00770775f, 0.16135851f, 0.00857061f, -0.04274648f, 
    0.13424163f, 0.04953716f, -0.21494308f, -0.06290622f, -0.10524693f, -0.16569372f, 0.03405586f, 0.22681706f, 
    -0.17349537f, -0.30248088f, -0.07655723f, -0.05973528f, 0.43763086f, -0.23095180f, -0.08549654f, -0.01530230f, 
    -0.08683786f, -0.12143306f, 0.44388345f, -0.16229849f, 0.14901866f, -0.00812467f, 0.08756936f, -0.02991957f, 
    0.33554429f, 0.02291092f, 0.08982214f, 0.02386842f, 0.07726821f, -0.01498779f, -0.09002673f, -0.24419151f, 
    -0.23569086f, 0.17631975f, 0.19042970f, -0.04788914f, 0.14358070f, -0.30217168f, 0.41344535f, -0.34721488f, 
    0.11353046f, -0.07864244f, 0.12028499f, -0.00722882f, 0.04689356f, -0.13673864f, 0.12394392f, 0.15437672f, 
    -0.01734204f, 0.15906928f, -0.24585471f, -0.10695289f, -0.08877004f, -0.05706261f, 0.10659022f, -0.10567202f, 
    0.18682757f, -0.10722979f, 0.13078921f, 0.12520035f, 0.07055923f, -0.10429937f, -0.09711614f, 0.24716510f, 
    -0.15147220f, 0.09446077f, -0.40537414f, 0.15696631f, 0.40948313f, -0.17107007f, -0.21362862f, 0.31575945f, 
    0.15304908f, 0.08574935f, 0.11949442f, 0.03070485f, 0.14176291f, 0.12104430f, -0.07496784f, -0.03813194f, 
    0.19420297f, -0.15622583f, -0.58754617f, -0.09708107f, -0.05011437f, -0.14203542f, 0.13521045f, 0.03854149f, 
    -0.10564066f, -0.07738582f, -0.53911698f, 0.11528219f, -0.07337655f, -0.11692780f, 0.10822316f, -0.00161984f, 
    -0.06655298f, 0.01653286f, -0.07413089f, 0.16345406f, 0.15446809f, 0.05914324f, -0.03704720f, 0.30624044f, 
    0.02749590f, 0.16123015f, -0.08964700f, 0.14856601f, 0.19000940f, 0.04736697f, 0.06370182f, 0.13699993f, 
    0.25427359f, 0.03777463f, 0.16934696f, 0.15205669f, 0.15584204f, 0.08803060f, 0.23872145f, 0.15509015f, 
    -0.05448791f, -0.13286611f, -0.35953063f, -0.06072002f, 0.07172873f, -0.09851212f, -0.09974620f, 0.14639020f, 
    -0.35880089f, 0.00617271f, -0.10116513f, -0.06800373f, 0.15950005f, 0.03819101f, -0.03714632f, 0.38662690f, 
    0.01734283f, -0.14372547f, -0.16827373f, -0.01619739f, 0.41460618f, -0.13431239f, 0.10007844f, 0.07649215f, 
    -0.14187260f, 0.15754062f, 0.31728378f, 0.09869092f, 0.10222863f, 0.17241883f, 0.16178085f, -0.00746381f, 
    0.33444738f, -0.08776490f, -0.02460353f, -0.07634575f, -0.08899820f, -0.11184999f, 0.13947782f, 0.09132059f, 
    -0.13917604f, 0.05311153f, 0.17220329f, 0.16541314f, -0.20277289f, -0.21882527f, 0.20041686f, 0.00561739f, 
    -0.04741941f, -0.06198202f, -0.00089922f, -0.04784184f, -0.38619176f, 0.40464908f, -0.17394465f, -0.17362764f, 
    0.16568330f, -0.00109622f, 0.25862858f, -0.01843499f, -0.05507484f, 0.03975384f, 0.24327658f, 0.05261750f, 
    -0.19351079f, -0.12574831f, -0.09369811f, 0.08476191f, 0.11372884f, 0.15244308f, -0.04537996f, -0.16474722f, 
    -0.41293743f, 0.06229753f, -0.26050076f, -0.13783249f, 0.41990221f, 0.28516012f, -0.18782841f, 0.16603696f, 
    0.03539593f, 0.32700500f, -0.09936966f, 0.06526814f, 0.42965755f, -0.37483749f, -0.08937870f, 0.04471748f, 
    -0.13463701f, 0.10836212f, 0.28936842f, -0.02272054f, 0.08821262f, 0.02373947f, -0.03529810f, -0.05282549f, 
    0.30909160f, 0.11021622f, -0.06892802f, -0.04674128f, -0.04234464f, 0.10492814f, -0.15693128f, 0.07841393f, 
    0.03811011f, -0.05261267f, -0.28945661f, -0.19106337f, 0.05139441f, 0.45318282f, -0.01788251f, 0.21823075f, 
    0.12956271f, 0.38921121f, -0.17853329f, -0.09138761f, -0.02541226f, -0.39557576f, -0.15972038f, 0.10973342f, 
    -0.10251133f, -0.02982712f, -0.10813843f, 0.08668682f, -0.03723354f, 0.11378517f, -0.39277831f, 0.14795543f, 
    0.04590023f, -0.05093510f, -0.03367633f, -0.17371593f, -0.16817147f, -0.07007637f, 0.14679077f, -0.10658793f, 
    0.36592129f, -0.11878593f, 0.04474152f, -0.13407806f, 0.14275806f, -0.05949911f, 0.36034763f, 0.29009008f, 
    -0.05500957f, -0.03202888f, 0.01823502f, -0.16861531f, -0.07993118f, -0.05921255f, -0.10027814f, 0.00715682f, 
    0.19141561f, 0.01074481f, -0.32710823f, -0.01846827f, -0.11246923f, -0.04665973f, 0.15970762f, 0.09616110f, 
    -0.21706866f, 0.07341854f, 0.20102030f, -0.16086240f, 0.03578603f, -0.11870929f, 0.07725883f, -0.27304062f, 
    -0.07175534f, -0.08990687f, 0.17766528f, -0.07848947f, 0.27522415f, -0.21814562f, 0.19702178f, 0.21688084f, 
    -0.14873762f, -0.10891014f, 0.12695970f, 0.15203311f, -0.16181348f, 0.39287040f, 0.09971255f, 0.11297686f, 
    0.26651934f, -0.03289675f, 0.37166810f, 0.02947574f, 0.01283388f, -0.16088390f, 0.21579112f, -0.11321185f, 
    -0.20505206f, -0.15655668f, 0.25284469f, 0.09674672f, -0.03048050f, -0.12581971f, -0.12143224f, -0.20922874f, 
    -0.02933429f, 0.16490148f, -0.14790419f, -0.13134080f, -0.15519519f, 0.47028494f, -0.14133023f, -0.17184663f, 
    -0.12243487f, 0.14697307f, 0.06966362f, -0.14883895f, 0.27516964f, -0.35911641f, -0.03913422f, 0.15600838f, 
    -0.09492812f, 0.02443125f, 0.18974246f, 0.08703966f, -0.01929214f, 0.02690377f, 0.22479840f, 0.10193415f, 
    0.23961331f, 0.15570942f, -0.38969561f, 0.14843675f, -0.07974901f, 0.01813284f, -0.14233729f, 0.20901284f, 
    0.18376596f, -0.13100794f, -0.27904230f, 0.11807416f, -0.01748153f, 0.51793772f, 0.15388609f, 0.27307194f, 
    0.07978795f, 0.34330145f, 0.02131702f, 0.03247142f, -0.18308745f, -0.38097844f, -0.09086226f, 0.04445076f, 
    -0.22132982f, -0.17828660f, 0.01563308f, -0.01653581f, -0.13243821f, -0.09669039f, -0.06448618f, 0.07958952f, 
    0.19630162f, 0.13758852f, 0.15773603f, 0.12759261f, -0.14611749f, 0.07813581f, 0.16431648f, -0.26283401f, 
    0.37925828f, 0.11445525f, 0.02599649f, -0.10995513f, 0.35493448f, -0.52401823f, 0.33779672f, 0.10090567f, 
    -0.11306316f, 0.36370146f, 0.13126776f, -0.00779315f, -0.30216530f, -0.12511584f, 0.07077242f, 0.08814655f, 
    0.13825502f, 0.00036799f, -0.01357389f, 0.01412760f, -0.10114182f, 0.13713679f, 0.17840214f, -0.15346524f, 
    -0.21584727f, 0.08003144f, -0.37202683f, -0.14453074f, -0.08534846f, 0.09160206f, 0.06102278f, 0.29321393f, 
    -0.28254929f, 0.08749049f, -0.18211772f, -0.02086770f, 0.32130817f, -0.13757104f, 0.04330064f, 0.33876780f, 
    -0.01718872f, -0.02609594f, -0.03529087f, 0.13681540f, 0.17759432f, 0.17469160f, 0.01959219f, 0.02694858f, 
    0.02184425f, -0.05078458f, 0.58949518f, 0.06678568f, -0.03337391f, 0.02057153f, 0.01036514f, 0.02748876f, 
    0.21640502f, 0.18213071f, 0.13392250f, -0.05747300f, -0.14468499f, 0.08826201f, 0.16225958f, 0.19494870f, 
    -0.34270409f, -0.05892647f, 0.09010226f, 0.08134844f, 0.11764224f, -0.30969369f, 0.16230178f, -0.12398294f, 
    0.17193642f, -0.21550666f, 0.00731104f, -0.11238653f, -0.06019834f, 0.25444785f, 0.05681605f, 0.10554308f, 
    -0.02641096f, 0.09351213f, -0.02826778f, 0.08206775f, 0.14515023f, 0.01698871f, 0.29553354f, 0.06814843f, 
    -0.15988237f, 0.06262721f, 0.17414184f, -0.16376574f, -0.05016911f, 0.12308118f, -0.05500966f, 0.12480887f, 
    0.32611191f, -0.10703446f, 0.22507641f, 0.16966204f, 0.26866347f, -0.20243293f, 0.05680360f, -0.58393210f, 
    0.15161474f, -0.17559148f, -0.05580894f, 0.09959669f, 0.14827164f, 0.01786693f, 0.11633798f, -0.07771407f, 
    0.26432443f, 0.12595536f, -0.52721459f, 0.13293509f, 0.13673109f, -0.03071413f, 0.03293615f, 0.14769492f, 
    0.07955988f, -0.02465940f, -0.45729697f, -0.02689741f, -0.04816287f, -0.07929249f, -0.14889537f, 0.05328785f, 
    -0.29480767f, 0.07698360f, -0.27781838f, 0.14133190f, 0.38448465f, 0.03644214f, 0.13362758f, 0.35715154f, 
    0.12678903f, 0.29116580f, -0.00567638f, 0.02887575f, -0.14339405f, 0.30263898f, -0.10102595f, -0.09643652f, 
    0.01872554f, 0.01464976f, 0.22142389f, -0.03125138f, -0.01289053f, 0.18129341f, -0.06566369f, -0.13295791f, 
    0.04324146f, 0.11088832f, 0.46631056f, -0.09726824f, 0.00604860f, -0.01954730f, 0.00304082f, -0.04878085f, 
    0.06239197f, -0.01982150f, -0.17512882f, -0.02852887f, 0.04145239f, 0.14042531f, -0.05582592f, 0.30378667f, 
    0.07029468f, 0.25738832f, -0.01084206f, 0.09060127f, 0.26118860f, -0.23063046f, 0.17417131f, -0.09659176f, 
    0.08263694f, 0.01956779f, 0.13929760f, 0.00925530f, 0.09739538f, 0.06615475f, 0.07081442f, -0.15122095f, 
    -0.17391333f, 0.10506351f, -0.10412664f, 0.06072617f, -0.07646702f, 0.12856159f, 0.11038143f, -0.44706663f, 
    0.29671061f, -0.02504935f, -0.00155033f, 0.05519998f, 0.19450866f, -0.37687179f, 0.61982036f, -0.04203729f, 
    -0.16845173f, -0.16738471f, 0.04828600f, 0.07684068f, 0.20287539f, -0.05492072f, 0.08440907f, -0.02400130f, 
    0.22376609f, -0.00070965f, 0.25097033f, -0.04585323f, -0.11117533f, 0.09184060f, 0.26877794f, 0.15521155f, 
    0.03065920f, -0.12891419f, -0.23277067f, -0.07320764f, 0.00117277f, -0.00139350f, -0.08406390f, 0.12993170f, 
    -0.32765788f, 0.02375340f, -0.08478969f, 0.00802730f, 0.33013394f, -0.06475171f, 0.30673569f, -0.11618311f, 
    0.05368818f, -0.08366529f, 0.02322047f, -0.14030816f, 0.06690945f, -0.23034514f, 0.09125404f, 0.02730948f, 
    -0.13968782f, 0.15055640f, -0.11561390f, -0.06063246f, 0.05861752f, -0.02170032f, 0.03804381f, 0.02066532f, 
    -0.01423945f, -0.08452249f, 0.06557965f, 0.00864350f, 0.00194788f, -0.13408613f, 0.07302980f, 0.03884885f, 
    0.01556717f, 0.14193164f, -0.04970213f, -0.10819588f, -0.06347660f, 0.06133092f, 0.01379773f, -0.12587570f, 
    -0.04206266f, 0.00580633f, -0.00426426f, 0.04732691f, -0.11009666f, -0.03884427f, 0.06235930f, -0.18236959f, 
    0.10914277f, 0.16219856f, 0.22002693f, 0.00426445f, -0.02459580f, 0.01456816f, -0.17314729f, -0.13910680f, 
    0.14868858f, 0.09993190f, 0.42896754f, -0.15987490f, -0.04965630f, -0.01473279f, 0.11617769f, -0.32940003f, 
    0.29136690f, -0.15565090f, 0.27931738f, -0.15332103f, -0.12697692f, -0.11439090f, -0.05215246f, 0.19014823f, 
    -0.03712719f, -0.05625489f, 0.10218938f, -0.02037269f, 0.13102767f, 0.27861130f, -0.05134171f, 0.06754465f, 
    -0.31330442f, 0.01854232f, -0.32984069f, 0.11021485f, 0.10796958f, 0.15895899f, -0.18104607f, -0.01141906f, 
    0.23008083f, 0.10961586f, 0.04223820f, -0.01429265f, -0.12146419f, 0.03350817f, -0.08209176f, -0.12660846f, 
    -0.02795247f, 0.11690401f, 0.30419070f, -0.12331238f, 0.16155583f, 0.29331550f, -0.07098575f, 0.39596757f, 
    0.17029838f, -0.15995888f, -0.06927047f, 0.06368440f, 0.10317744f, -0.09310876f, -0.15366025f, -0.15323709f, 
    0.28141493f, 0.07391963f, -0.16799025f, 0.08916876f, 0.07302602f, -0.04392297f, 0.27950960f, 0.14839485f, 
    -0.08325057f, -0.11736012f, 0.11680026f, 0.06030892f, 0.11354117f, 0.16123337f, -0.11748577f, -0.07645702f, 
    -0.29079941f, -0.13340959f, -0.23134163f, -0.04385690f, -0.13966899f, 0.51096201f, 0.05337396f, 0.08113429f, 
    0.13355945f, 0.11954196f, 0.06573343f, 0.11513514f, 0.00870672f, -0.26681733f, -0.08593097f, -0.10152162f, 
    -0.09500921f, 0.09667682f, 0.11222665f, 0.00825027f, -0.01877752f, -0.15302622f, 0.13830990f, -0.07444604f, 
    -0.07319501f, -0.01622292f, -0.02608155f, -0.10145701f, -0.00598674f, -0.07316516f, 0.10695599f, -0.10603313f, 
    0.36629036f, -0.08810570f, -0.03472131f, 0.01453255f, -0.02433310f, -0.04018534f, -0.42717493f, -0.12574029f, 
    -0.10785435f, 0.25195643f, 0.12054019f, -0.04646163f, -0.09969149f, -0.05649951f, 0.09000099f, -0.00642723f, 
    0.15002264f, -0.16025491f, -0.30719492f, -0.06485162f, 0.05528021f, 0.11288096f, -0.06421573f, 0.09572391f, 
    0.19219922f, -0.12480277f, 0.49385288f, -0.06429690f, 0.07190920f, 0.00038906f, -0.07461538f, -0.03454384f, 
    -0.02585420f, 0.09294213f, -0.12968978f, 0.06809755f, 0.16025048f, 0.30410641f, -0.22272442f, 0.39873722f, 
    -0.00414168f, 0.10113367f, -0.09641735f, -0.09746681f, 0.05304391f, -0.08472805f, 0.15804653f, -0.07899269f, 
    -0.15464480f, 0.10754190f, 0.52023864f, -0.14524783f, -0.12556981f, 0.16319701f, -0.18415004f, -0.16231875f, 
    0.34040606f, -0.02709439f, -0.08135860f, 0.03607137f, -0.07661636f, -0.11776204f, -0.03282078f, 0.38824120f, 
    0.03137492f, -0.05973580f, -0.16455929f, -0.09235915f, -0.18282422f, 0.27824235f, 0.30359688f, -0.12191878f, 
    0.02058359f, -0.34479797f, 0.03209157f, 0.04281079f, 0.35424876f, 0.10241444f, 0.05351887f, 0.05418399f, 
    -0.29588306f, -0.17639717f, 0.29715025f, 0.01852907f, -0.14663073f, 0.06055805f, -0.08926389f, -0.04212964f, 
    0.36982337f, -0.07391622f, 0.23739515f, 0.00655097f, -0.10026795f, -0.07867093f, -0.18053648f, -0.09504599f, 
    0.40710086f, 0.05385696f, 0.01854382f, 0.07109570f, -0.27324286f, 0.34404415f, 0.02445740f, 0.23555671f, 
    0.11306884f, 0.26475343f, 0.06877215f, -0.05601288f, 0.18891166f, -0.26456612f, -0.03250346f, 0.09017839f, 
    -0.10978339f, -0.03010069f, 0.00153656f, -0.06241261f, -0.13356797f, 0.14044854f, 0.21719554f, -0.10140084f, 
    0.11180796f, -0.03225111f, 0.40484786f, 0.00015908f, -0.12551422f, 0.06069949f, 0.16078019f, -0.34025016f, 
    0.27005669f, -0.03379048f, -0.30890357f, -0.12543207f, -0.05873341f, 0.11891358f, 0.04408212f, 0.11567552f, 
    -0.13300088f, 0.32847899f, 0.00725734f, 0.17512792f, 0.14300752f, -0.21236953f, 0.13585688f, -0.04727806f, 
    -0.16119699f, 0.05074452f, 0.00339587f, -0.02859226f, 0.02362683f, 0.05663099f, -0.02769980f, 0.05096390f, 
    -0.00417427f, 0.13092524f, -0.05477864f, 0.03957426f, -0.03397065f, -0.13105747f, 0.11323217f, 0.05860491f, 
    -0.18711720f, 0.03643144f, -0.04703251f, 0.01342349f, -0.11707489f, 0.02667768f, -0.16789484f, -0.01464670f, 
    0.10818662f, -0.14744397f, 0.16030468f, 0.12524684f, 0.06777876f, 0.03012263f, -0.02233113f, -0.07845590f, 
    0.00064817f, 0.08605272f, -0.46551964f, 0.15428905f, 0.06796586f, -0.12832053f, 0.00541079f, 0.08344926f, 
    0.00695754f, 0.14759208f, 0.37543163f, -0.11117753f, 0.12161503f, 0.17322682f, -0.06956194f, 0.02291112f, 
    -0.25353530f, -0.02022932f, 0.16629925f, 0.06422485f, 0.29864880f, 0.26910314f, 0.17059948f, -0.10697465f, 
    0.16438286f, 0.26897863f, 0.07909643f, 0.01223114f, -0.47560322f, 0.27389517f, 0.05241903f, -0.13227765f, 
    -0.17267220f, 0.03366285f, 0.36539087f, -0.10315399f, 0.01025566f, 0.13693914f, 0.14733270f, 0.07676444f, 
    0.40855762f, -0.08790421f, 0.45066476f, 0.01328423f, -0.17431830f, 0.16514483f, 0.01359611f, 0.18784751f, 
    0.43012157f, -0.02093163f, -0.15213047f, -0.03111742f, -0.16297966f, 0.12700114f, -0.03231485f, -0.17519444f, 
    0.12306805f, -0.13903335f, 0.16304006f, 0.16694327f, 0.12314475f, -0.32824713f, -0.13495851f, 0.10756753f, 
    -0.09386087f, 0.15969229f, -0.38306987f, -0.06194532f, 0.15952224f, 0.14441924f, -0.28037572f, 0.07679878f, 
    0.18974510f, 0.04433688f, -0.20392607f, -0.05510528f, 0.05651191f, 0.06089970f, -0.17141436f, 0.48113886f, 
    0.35440305f, 0.13495897f, 0.01715448f, 0.16558595f, 0.46715650f, 0.03909088f, -0.04363822f, 0.40621197f, 
    -0.16421638f, 0.07814439f, 0.06242173f, 0.12157281f, -0.07163366f, -0.19768021f, 0.06612109f, -0.02834117f, 
    -0.11095528f, -0.11054494f, -0.00689262f, -0.06783515f, -0.10660674f, -0.12335263f, 0.23213218f, -0.17506722f, 
    0.09211063f, 0.02519361f, 0.15679784f, 0.05563474f, 0.06183615f, -0.03324052f, -0.10595313f, -0.03970804f, 
    -0.14777426f, 0.00761174f, 0.03970901f, 0.10526662f, 0.25699338f, -0.40225244f, -0.04423909f, -0.17528272f, 
    -0.11580388f, 0.10906795f, -0.01649000f, 0.08689730f, 0.05129977f, 0.42669839f, -0.15362243f, -0.17943704f, 
    -0.12293225f, -0.01311099f, 0.13523914f, 0.09135617f, 0.11286414f, 0.15958194f, -0.18577789f, 0.09267765f, 
    0.12282038f, -0.12255653f, -0.18743037f, -0.07817974f, -0.09916425f, -0.11432305f, -0.14048657f, -0.05714574f, 
    -0.08185257f, 0.16046488f, -0.18030396f, 0.12048954f, -0.15156582f, -0.07438441f, 0.04429772f, -0.17145014f, 
    -0.01645503f, 0.02074940f, -0.01346742f, -0.00523315f, -0.10809492f, 0.09667812f, 0.16652256f, -0.03934753f, 
    -0.17658602f, -0.09840555f, -0.33417836f, -0.09786891f, 0.12781481f, -0.09858802f, 0.27623403f, -0.07848533f, 
    0.31693292f, 0.07358947f, 0.05324325f, 0.05515151f, 0.06983513f, 0.02770586f, 0.04528538f, -0.05208669f, 
    0.48835921f, 0.11970158f, -0.39615282f, 0.15249184f, 0.32537591f, -0.06231422f, 0.09959113f, -0.13289976f, 
    -0.03565186f, -0.18531106f, 0.08571501f, -0.08952342f, 0.13726781f, -0.10016305f, -0.10263293f, 0.02837194f, 
    -0.10970711f, 0.16044976f, -0.13830790f, -0.09792994f, 0.09227870f, 0.00688251f, -0.02034538f, 0.02930277f, 
    -0.12588581f, 0.16875352f, 0.04975359f, 0.11437260f, -0.14169757f, -0.14975703f, -0.16767329f, -0.07518120f, 
    -0.11987363f, 0.14556010f, 0.08263420f, -0.16226800f, -0.12132762f, -0.02790465f, 0.08826796f, 0.09655547f, 
    0.13746162f, -0.03907815f, 0.15150110f, -0.07563478f, -0.05993884f, -0.15383624f, 0.16157943f, 0.06767137f, 
    0.15277115f, 0.06537557f, -0.41116074f, 0.01001754f, 0.06196630f, 0.14192845f, -0.06945557f, 0.05803202f, 
    -0.08024870f, 0.04527444f, -0.24233086f, 0.08025733f, -0.17239580f, 0.11802596f, -0.07767145f, 0.28270400f, 
    0.41472644f, -0.13061953f, 0.10617111f, 0.13104726f, -0.00105486f, 0.24059224f, 0.04136145f, -0.15919927f, 
    -0.03772390f, 0.20756160f, -0.06154197f, 0.04572324f, -0.04048301f, 0.03868271f, -0.12462184f, -0.13004363f, 
    -0.10960890f, -0.06908847f, -0.07983261f, 0.13865210f, 0.05130427f, 0.06649386f, -0.13222869f, -0.08889835f, 
    -0.15971246f, 0.15320939f, -0.11509322f, -0.10421611f, 0.05297225f, -0.11026438f, 0.07524999f, 0.03376461f, 
    -0.10335600f, 0.16519922f, -0.03063822f, -0.06600190f, -0.01217266f, 0.00443849f, 0.16547787f, 0.07845025f, 
    0.14773138f, 0.06162217f, -0.04899650f, -0.14525856f, 0.02176462f, -0.15628031f, -0.14987771f, -0.10702124f, 
    0.00985821f, -0.16781884f, -0.38654426f, -0.00047955f, -0.08658908f, -0.12357346f, -0.22952510f, 0.00925751f, 
    0.12548032f, 0.10012064f, -0.09714458f, -0.06516242f, 0.04741107f, 0.07146773f, -0.12376504f, 0.08831179f, 
    -0.19374742f, -0.01791458f, 0.11459117f, -0.16771384f, 0.40325600f, -0.16480123f, -0.19573382f, -0.18951191f, 
    0.10530611f, 0.30317962f, -0.09987313f, -0.05275784f, 0.11509602f, 0.04609391f, -0.07914978f, 0.14913397f, 
    0.19321305f, -0.14255448f, -0.08046880f, -0.10317419f, 0.08718666f, 0.08120404f, -0.08334299f, -0.10131746f, 
    -0.15818062f, 0.13678402f, -0.39177760f, 0.13087519f, -0.03657190f, -0.01652788f, -0.06011968f, -0.04537380f, 
    0.33728206f, -0.14915009f, 0.00274903f, -0.14929706f, -0.01274520f, 0.24999054f, 0.03628810f, -0.07444227f, 
    0.12522304f, 0.12865621f, 0.05267321f, 0.14242774f, 0.13943864f, -0.05380230f, -0.05841413f, -0.13632691f, 
    -0.19091113f, 0.06562833f, 0.12414537f, 0.09466589f, -0.00637205f, 0.04997132f, -0.08260459f, 0.04979723f, 
    0.18132767f, -0.15506294f, 0.48702088f, 0.17878862f, -0.11010014f, -0.11216345f, 0.10045478f, 0.05980024f, 
    0.48480919f, -0.05797692f, 0.24068451f, -0.00949159f, -0.12219773f, 0.06694575f, 0.09320249f, -0.05546043f, 
    -0.13582021f, -0.04302340f, -0.15761623f, -0.03733302f, 0.03587441f, 0.05938997f, -0.04140173f, 0.04543470f, 
    -0.01555735f, -0.10710858f, 0.27104974f, 0.15258840f, -0.16830875f, -0.16707221f, -0.13252006f, 0.06715508f, 
    0.22330520f, 0.03210659f, 0.20744576f, -0.11397776f, -0.12769189f, 0.05131974f, 0.11857252f, 0.26784751f, 
    0.43592265f, -0.04827776f, 0.15735166f, -0.11738437f, -0.25708133f, -0.09497047f, 0.15031759f, 0.04563778f, 
    -0.09084579f, -0.39746004f, -0.06125140f, -0.00973631f, 0.11639259f, 0.26744878f, -0.08140109f, 0.08877919f, 
    -0.02970386f, 0.04440255f, -0.03351779f, 0.05821921f, -0.11633158f, 0.11303701f, -0.03605853f, 0.03112414f, 
    0.03597352f, -0.05057076f, -0.12719919f, 0.10871461f, 0.07155661f, -0.09771787f, -0.13279791f, -0.04178521f, 
    0.04498141f, -0.14470771f, -0.05352926f, 0.08217514f, -0.17613305f, -0.17336179f, 0.07545036f, -0.14564054f, 
    0.08090732f, -0.11637225f, 0.02856037f, -0.17188154f, -0.10645877f, -0.00818028f, -0.00035492f, -0.09864566f, 
    0.04202389f, -0.05288320f, 0.07357646f, -0.12917152f, -0.14669609f, 0.06671071f, 0.08352906f, -0.09935334f, 
    0.29624444f, 0.12212173f, 0.25483865f, 0.10204975f, -0.02826684f, 0.09932733f, 0.00483427f, -0.37854907f, 
    -0.28211477f, 0.05758200f, -0.11256904f, -0.11223982f, 0.12108641f, -0.18443176f, 0.31719455f, 0.22813091f, 
    0.10597349f, 0.25259009f, 0.05013599f, 0.15709169f, -0.22731087f, 0.05075803f, -0.06181518f, 0.08202924f, 
    0.16689198f, 0.05529516f, 0.44487965f, -0.14426717f, 0.08424415f, -0.06772067f, -0.03065048f, 0.14861107f, 
    0.15191704f, 0.18216676f, -0.33492655f, 0.17047092f, -0.01512018f, 0.15457116f, 0.15186052f, 0.56649268f, 
    0.03670619f, 0.07853660f, -0.17222582f, -0.16309004f, 0.11117578f, -0.00242185f, 0.15396827f, 0.18135819f, 
    -0.07503504f, -0.26571348f, -0.05722630f, -0.14180635f, 0.32871750f, -0.14340903f, 0.11561060f, 0.16356848f, 
    0.08871576f, 0.01007107f, -0.21537885f, 0.05822838f, 0.01885501f, -0.15276845f, 0.03341886f, -0.01482557f, 
    -0.11783194f, -0.14499129f, -0.25022745f, -0.14467935f, -0.15302497f, 0.11465873f, 0.10359231f, -0.06424604f, 
    0.58059257f, -0.10253862f, -0.51002645f, 0.01134537f, 0.09779708f, 0.37567145f, -0.03493506f, 0.13764369f, 
    0.12661785f, -0.09683789f, -0.12900901f, 0.04970055f, 0.27807608f, 0.01188767f, -0.06481385f, -0.12594803f, 
    0.40848863f, 0.05230556f, 0.54597956f, 0.06450436f, 0.14030735f, -0.09221181f, 0.19442421f, 0.12029146f, 
    -0.34197593f, 0.09213798f, -0.31922293f, -0.16635095f, 0.06938315f, -0.13699636f, 0.16214202f, 0.12040452f, 
    -0.47295511f, 0.13584709f, 0.09857877f, 0.08843487f, 0.29904675f, -0.12203676f, 0.10712254f, 0.16814275f, 
    0.10352116f, -0.04348432f, 0.11825423f, 0.15252854f, 0.13895227f, -0.18746600f, -0.03906591f, -0.15636642f, 
    0.10143098f, -0.00152017f, 0.14605305f, -0.12723587f, 0.14553878f, -0.10597483f, 0.23191123f, 0.06103512f, 
    0.00958278f, -0.16216891f, -0.59897685f, -0.13410836f, -0.10070629f, -0.17524365f, 0.11595008f, 0.34490645f, 
    0.05932283f, -0.00340098f, -0.12279220f, 0.04335074f, -0.06272395f, 0.20215110f, 0.19437265f, 0.09509881f, 
    -0.12410897f, 0.09282337f, 0.16764323f, -0.06635559f, 0.07957921f, -0.09901946f, -0.13743310f, 0.14562686f, 
    0.05764177f, -0.04780880f, 0.66137826f, 0.04375635f, -0.04477288f, 0.08900057f, -0.01949415f, -0.00617038f, 
    -0.01923234f, 0.02453754f, 0.04737923f, 0.02597480f, 0.14283586f, 0.15178441f, 0.12362125f, 0.05692383f, 
    0.23639683f, 0.01069620f, -0.15422894f, -0.10532611f, -0.30947447f, 0.55547386f, 0.06640717f, 0.35135904f, 
    0.10263871f, 0.23733962f, 0.17600508f, 0.01114053f, -0.00781744f, -0.25788185f, 0.04640319f, 0.01436595f, 
    -0.15831806f, -0.14536884f, -0.24135463f, -0.10165558f, -0.09450038f, -0.05129581f, 0.10927963f, -0.01698935f, 
    -0.03621144f, 0.02456344f, 0.50166428f, 0.14489925f, 0.02156467f, -0.03272496f, -0.08054805f, -0.10592675f, 
    0.35431400f, -0.07575586f, 0.21120743f, -0.17782307f, 0.10091799f, 0.33921477f, -0.20266779f, -0.41758168f, 
    -0.16671781f, 0.22153434f, -0.18295731f, -0.01770014f, -0.15382482f, 0.05847424f, 0.04504697f, 0.04056553f, 
    0.15398276f, -0.16658852f, -0.10811671f, -0.00408734f, -0.13656490f, -0.08503500f, 0.04296892f, 0.03816925f, 
    -0.15818536f, 0.07673006f, 0.18151544f, -0.02691494f, 0.00092705f, -0.17561483f, -0.09801579f, -0.41650674f, 
    0.11650766f, 0.11641634f, -0.01749045f, -0.07718601f, 0.02837865f, 0.29112265f, 0.40707296f, 0.13629751f, 
    0.12547989f, 0.26096550f, -0.10707402f, 0.18174911f, -0.13476296f, -0.00668045f, -0.15381964f, 0.17250073f, 
    -0.14343618f, 0.16959478f, -0.15567449f, 0.04112706f, -0.13930313f, -0.08669438f, -0.12886906f, -0.14947945f, 
    0.00833393f, -0.05482372f, 0.08091863f, -0.03496275f, -0.06279859f, 0.00454541f, -0.01229832f, -0.18432300f, 
    0.16767204f, -0.04389080f, 0.21929680f, -0.14847259f, 0.00426018f, 0.08997367f, 0.05016891f, 0.00480506f, 
    -0.03582769f, -0.10723075f, -0.11633679f, -0.09370825f, 0.13025761f, -0.05085211f, -0.10880116f, 0.01655360f, 
    -0.20142640f, -0.12798752f, -0.23855899f, 0.11316506f, -0.08264079f, 0.01813057f, 0.10883997f, -0.14680050f, 
    0.28208190f, -0.10643805f, 0.40492666f, -0.11870698f, -0.05216722f, 0.03146511f, -0.04540934f, -0.20441826f, 
    -0.12000342f, 0.16480605f, 0.07058865f, 0.11775398f, 0.47355270f, -0.64719427f, 0.40267032f, 0.16366048f, 
    -0.00064353f, 0.19525039f, -0.15902811f, 0.15259680f, -0.11150405f, 0.03851000f, -0.08643979f, -0.04944999f, 
    0.26390308f, 0.02082580f, -0.45561853f, 0.03341148f, 0.15970455f, -0.13862763f, 0.06164645f, -0.11162347f, 
    -0.25555852f, -0.03027808f, -0.35193133f, 0.00132110f, 0.00497781f, -0.00385876f, -0.14703825f, 0.36077514f, 
    0.18688434f, 0.04872021f, 0.30473083f, -0.01348181f, 0.42536575f, -0.12301665f, 0.04646778f, -0.24024726f, 
    -0.12451816f, 0.15114743f, -0.16536531f, -0.14890325f, -0.14979605f, 0.58612388f, -0.09660936f, 0.04373692f, 
    0.19724149f, 0.03175820f, 0.26704150f, -0.02921732f, 0.02693741f, 0.01283308f, 0.01932697f, -0.11465981f, 
    -0.27743179f, 0.14151511f, -0.48623687f, -0.03328095f, -0.11861784f, -0.17133255f, 0.10839828f, 0.14837374f, 
    -0.01628795f, 0.11244155f, -0.16700143f, -0.08429549f, 0.15608378f, 0.12809896f, 0.13735178f, 0.17487098f, 
    0.10029154f, 0.04846777f, 0.15166937f, 0.15738888f, 0.44102463f, -0.23997779f, -0.09762542f, -0.05243523f, 
    0.08039155f, 0.02317522f, -0.04599418f, -0.08207225f, 0.16353652f, -0.01944752f, -0.11520478f, -0.00669034f, 
    -0.07643238f, -0.15655984f, -0.23539774f, -0.16556460f, 0.09214906f, -0.01219095f, 0.04117475f, 0.15476234f, 
    0.41042984f, -0.12667017f, 0.34726578f, -0.10998756f, 0.30647019f, -0.44297004f, 0.01200346f, -0.09639870f, 
    -0.01741658f, 0.18244639f, -0.11945263f, 0.15224369f, -0.28245184f, 0.30119830f, 0.00387367f, 0.06015522f, 
    -0.02941208f, -0.04131787f, -0.05210873f, 0.09571933f, -0.00600557f, -0.08351910f, 0.25287405f, -0.05219893f, 
    0.15689181f, -0.09520774f, -0.01969326f, -0.06299671f, 0.10246139f, -0.16424115f, 0.13204940f, 0.20283595f, 
    0.06768347f, 0.05543718f, -0.24640776f, 0.04708016f, 0.28414917f, -0.02543023f, 0.00109613f, -0.31498137f, 
    0.11992773f, 0.21643913f, 0.13967696f, 0.04115372f, -0.43981811f, 0.31615829f, -0.03426734f, 0.13527453f, 
    0.25874564f, 0.03936073f, 0.53278303f, 0.03406729f, -0.12852553f, -0.12782741f, 0.20336322f, -0.03482814f, 
    -0.07509623f, 0.16985659f, -0.27446565f, -0.08986649f, -0.17200831f, 0.03500835f, -0.08930278f, 0.09086637f, 
    -0.01745233f, -0.00764508f, -0.09650841f, 0.00710046f, -0.17327294f, 0.47591567f, -0.07904251f, -0.19108061f, 
    0.08452340f, 0.26591074f, 0.09404369f, -0.09559495f, 0.20961566f, -0.40381068f, -0.10422280f, 0.00914602f, 
    0.11414783f, 0.02655495f, 0.22908077f, 0.07581502f, 0.03166153f, -0.02054504f, 0.08408659f, -0.14896421f, 
    -0.10703914f, 0.11561741f, -0.34090754f, -0.07460624f, -0.00445498f, 0.06128968f, 0.05769255f, 0.45877862f, 
    0.53966743f, -0.02265157f, 0.23804335f, 0.14467333f, -0.19952352f, -0.07289746f, 0.20640911f, -0.02104997f, 
    0.17379223f, -0.10755950f, -0.08766358f, -0.08613683f, 0.11477689f, -0.46712059f, -0.14170468f, 0.12113983f, 
    0.25034663f, -0.16122158f, -0.04618320f, -0.02677712f, 0.15399952f, 0.07497887f, -0.08295120f, -0.01841326f, 
    -0.22760160f, 0.15329069f, 0.04531307f, 0.16676533f, -0.01211463f, 0.07454906f, -0.12530574f, -0.21409620f, 
    -0.09856171f, 0.06803348f, 0.12357697f, -0.12568119f, 0.34127942f, 0.15338713f, 0.08181593f, 0.22868212f, 
    -0.10846353f, 0.01133038f, -0.09951092f, 0.14151086f, 0.05977111f, -0.06945477f, 0.04176695f, -0.10516739f, 
    -0.16116381f, 0.12423489f, -0.20390011f, 0.14204386f, 0.09313445f, 0.12719825f, 0.15454350f, -0.11585084f, 
    0.21435368f, -0.04876485f, 0.20731692f, 0.12087085f, 0.15134399f, 0.05913410f, 0.12619160f, -0.60481268f, 
    -0.04939155f, -0.02230984f, 0.15680549f, -0.11252036f, -0.11124231f, -0.24982232f, 0.36719614f, 0.16671886f, 
    -0.07641242f, 0.21354492f, 0.08368490f, -0.07149337f, -0.10908475f, 0.27005729f, -0.03746362f, -0.15884316f, 
    0.11181945f, -0.02024376f, -0.33360413f, -0.17380916f, -0.04170772f, -0.14686355f, 0.18983030f, -0.05419758f, 
    0.20661701f, -0.01790676f, 0.09312548f, -0.00324409f, -0.13072968f, 0.07812831f, 0.05737253f, -0.31521675f, 
    -0.10499427f, -0.08106315f, 0.33486980f, 0.03180913f, -0.32552153f, 0.20856598f, 0.12963177f, -0.16045551f, 
    0.09409709f, 0.24605748f, -0.17191726f, -0.10211319f, -0.45506451f, 0.45302638f, -0.02137320f, -0.16427505f, 
    -0.08136517f, -0.04895957f, -0.09396812f, 0.11279130f, 0.02321554f, 0.01343614f, 0.09906954f, 0.04896240f, 
    -0.14513591f, -0.13634123f, -0.03938514f, 0.00743307f, 0.15214083f, 0.14257140f, 0.05118640f, 0.08412657f, 
    -0.28744748f, 0.00684213f, 0.28244975f, -0.05026125f, -0.15970545f, 0.32922196f, 0.27629778f, 0.41186762f, 
    0.08775669f, 0.13267614f, 0.05269980f, 0.18231994f, -0.19511205f, -0.46163464f, 0.08785611f, -0.17742747f, 
    -0.21021913f, -0.08105174f, -0.15450330f, -0.14058556f, 0.11464956f, 0.04433079f, -0.00353553f, 0.13786253f, 
    0.23832847f, -0.11277511f, 0.03498628f, 0.02406198f, -0.06791601f, 0.14192533f, -0.17525999f, 0.00494311f, 
    0.28188485f, 0.04254998f, 0.17433776f, -0.15076466f, 0.11233990f, 0.12945496f, 0.35402769f, 0.03573660f, 
    0.01869383f, 0.05116429f, 0.14594135f, -0.00377340f, -0.50299102f, 0.24978970f, 0.06510734f, -0.12357637f, 
    0.01655320f, -0.13296129f, -0.03684688f, 0.08433238f, 0.00472070f, -0.02751161f, -0.04348119f, -0.00103260f, 
    0.02357794f, 0.15586488f, -0.04281424f, 0.10288566f, -0.13421567f, 0.08199764f, -0.03179499f, -0.35848409f, 
    0.26144081f, -0.11443929f, -0.23081787f, -0.17640127f, 0.10853752f, -0.13690406f, 0.36760530f, -0.03107301f, 
    0.09451970f, -0.04241492f, 0.01514560f, -0.03364065f, -0.18305364f, -0.04361271f, 0.11645342f, 0.04902439f, 
    -0.05381058f, 0.04339172f, 0.51141781f, -0.13267632f, -0.04905182f, 0.09835157f, 0.16464241f, -0.17649853f, 
    0.10340378f, -0.13857724f, -0.27831101f, -0.06824978f, 0.05792889f, -0.09107826f, -0.03405149f, 0.41417155f, 
    -0.05386841f, 0.11136664f, 0.22039571f, 0.05285572f, -0.14318523f, 0.24353647f, -0.01884460f, -0.23873340f, 
    -0.10568483f, 0.19639985f, -0.06812188f, -0.12039740f, -0.24321076f, -0.28860015f, -0.02546709f, -0.02145582f, 
    -0.11364649f, 0.16158473f, -0.04980256f, -0.00742509f, 0.15617763f, -0.08367653f, -0.25871634f, -0.15536435f, 
    0.08813614f, 0.00589221f, -0.04484465f, -0.14667118f, -0.04096222f, -0.14864819f, 0.11439753f, -0.17918403f, 
    0.38301718f, -0.07291404f, -0.01536749f, -0.14598070f, 0.04481427f, 0.17708993f, 0.03151718f, -0.06719492f, 
    -0.12704915f, -0.01648024f, 0.00813328f, 0.11934978f, 0.04197481f, 0.24833781f, -0.15816467f, 0.13431166f, 
    -0.12593779f, 0.08522019f, 0.42092586f, 0.03611464f, 0.04091894f, -0.11204887f, 0.09052724f, -0.16988313f, 
    0.12727855f, -0.10724459f, 0.61544198f, -0.00905115f, -0.13445139f, 0.01563538f, -0.11302162f, -0.15909335f, 
    -0.25425220f, 0.03956670f, 0.13707519f, -0.04174276f, 0.33314326f, -0.14810504f, 0.01328708f, -0.30804333f, 
    -0.17413597f, 0.25468919f, 0.11561332f, 0.02938921f, 0.17132637f, -0.23382977f, -0.02668447f, 0.15346962f, 
    0.15472414f, -0.04018560f, -0.33628395f, -0.08182950f, -0.16511522f, 0.12495109f, -0.04023203f, 0.11302040f, 
    -0.22406408f, -0.07879311f, 0.25802273f, 0.05320437f, 0.10158807f, 0.02186752f, 0.00558021f, 0.16812897f, 
    -0.28663048f, 0.03715875f, 0.37844673f, -0.15241691f, 0.36655718f, -0.32842946f, -0.01319536f, -0.30191204f, 
    -0.16066931f, 0.03255074f, 0.02098218f, 0.08034713f, 0.24157184f, 0.30647835f, 0.10241415f, 0.08139906f, 
    0.20873375f, -0.01490156f, 0.26911822f, -0.00333200f, -0.09811162f, -0.10358185f, 0.38001621f, 0.16769716f, 
    0.23880967f, -0.07650309f, -0.30142617f, 0.12792416f, -0.14443479f, 0.06212015f, -0.05305639f, 0.00990338f, 
    -0.00286229f, -0.10619335f, -0.18406667f, 0.14047660f, -0.23616005f, 0.35054365f, 0.14427273f, 0.24707061f, 
    -0.12655087f, -0.12863994f, -0.02481584f, -0.10201124f, -0.03071559f, -0.01107263f, 0.07464562f, 0.16605508f, 
    -0.13927409f, 0.06143868f, -0.11105283f, 0.06481409f, -0.07242703f, 0.06599342f, -0.11074664f, 0.06081719f, 
    -0.13407950f, -0.13065784f, -0.18792216f, -0.13249262f, 0.09865975f, 0.09507363f, 0.14673099f, 0.13206623f, 
    -0.10997002f, 0.08140769f, -0.09529119f, 0.12256470f, -0.13622268f, -0.11152907f, 0.00981540f, 0.04631245f, 
    -0.14436105f, 0.12669560f, 0.16797297f, 0.12570995f, -0.05121502f, 0.04327324f, 0.16255328f, -0.14383733f, 
    -0.00754807f, -0.00977558f, 0.33739641f, -0.10036680f, -0.10205885f, 0.09119043f, 0.34855014f, 0.08438173f, 
    -0.02035171f, -0.12380452f, -0.05622184f, 0.18261662f, 0.13752249f, -0.04649525f, -0.03572476f, 0.15925314f, 
    0.03054791f, 0.12090077f, -0.08003772f, 0.07667187f, -0.08752900f, 0.31874716f, -0.20804808f, -0.12206838f, 
    0.09915255f, -0.23756075f, 0.03913917f, 0.04305612f, -0.38703164f, 0.23473538f, -0.11077824f, 0.00565692f, 
    -0.06447140f, 0.12329769f, 0.20048636f, 0.12740031f, 0.11110472f, 0.04073812f, -0.01520703f, -0.02488051f, 
    -0.04072956f, 0.09415017f, -0.02406635f, -0.17648971f, 0.00107972f, -0.04521117f, 0.16370790f, -0.04341874f, 
    -0.23814075f, 0.16423039f, -0.00708125f, 0.16676080f, 0.25582933f, 0.20064712f, 0.25657859f, -0.08408675f, 
    0.16383037f, 0.25086889f, 0.03060049f, -0.02978960f, -0.35642108f, -0.06551290f, 0.12708218f, -0.11393511f, 
    -0.20157902f, 0.03251850f, -0.18398967f, 0.07089157f, 0.15047680f, -0.02548737f, 0.24199493f, 0.08222989f, 
    0.15395482f, 0.07350917f, 0.59109139f, -0.10444362f, -0.17244841f, -0.02741987f, -0.08505495f, 0.11695742f, 
    0.37067965f, -0.08910728f, 0.10111190f, 0.02431713f, -0.13430741f, -0.04469755f, 0.03520269f, -0.46664444f, 
    -0.18273142f, 0.13812304f, 0.07613486f, 0.05481334f, 0.10458357f, -0.19528729f, -0.02449603f, -0.00926236f, 
    -0.22981811f, 0.08019228f, -0.34287471f, 0.12586375f, 0.11151268f, -0.00064722f, 0.13957019f, 0.08764497f, 
    0.22609533f, 0.09184141f, 0.47733578f, 0.05942329f, 0.15724978f, -0.04849327f, -0.10128064f, 0.03869916f, 
    0.19997203f, -0.05144904f, 0.10866105f, 0.16668968f, 0.15689677f, -0.59805852f, 0.08080952f, -0.05474447f, 
    -0.09750513f, 0.14966477f, 0.13021529f, -0.15549293f, -0.07260344f, 0.32328993f, -0.08239190f, 0.17075157f, 
    0.15574415f, -0.07733840f, -0.27502438f, -0.00481299f, 0.11713308f, 0.07463202f, -0.22175048f, 0.14140093f, 
    -0.07453987f, -0.12039581f, 0.04924854f, 0.13118671f, 0.08002859f, 0.13261580f, -0.02374357f, -0.00019750f, 
    -0.03930193f, -0.16430566f, 0.08150431f, -0.00859526f, 0.28498974f, -0.17863090f, -0.15241401f, 0.55919987f, 
    0.05744345f, -0.07973178f, 0.09579216f, 0.12533405f, 0.21169995f, 0.41828945f, -0.13289459f, -0.15706429f, 
    0.04733380f, -0.04457253f, 0.56840485f, -0.12410492f, 0.11454939f, 0.13235900f, 0.23239671f, 0.05013394f, 
    -0.16485591f, 0.17103828f, -0.18624425f, 0.05885844f, 0.10407984f, 0.04014796f, 0.06727532f, 0.17544483f, 
    0.22257933f, 0.04635041f, 0.05197649f, 0.11303844f, -0.22963224f, 0.32643294f, 0.30868039f, -0.31209075f, 
    0.05541001f, -0.10610799f, 0.13833316f, -0.16224296f, 0.13256849f, -0.39291444f, 0.16362874f, 0.14939451f, 
    -0.21313371f, 0.12337285f, 0.06118974f, -0.15087080f, 0.05050283f, -0.10167002f, 0.25803337f, -0.15329516f, 
    0.06641472f, -0.16839787f, 0.30077299f, -0.03731171f, 0.04336846f, 0.02320991f, 0.00190241f, -0.27089784f, 
    0.04960138f, -0.09979550f, 0.19465001f, 0.16015913f, 0.40594569f, -0.20637305f, 0.40033481f, -0.25441459f, 
    0.10221379f, 0.05405446f, 0.07283953f, 0.08591726f, -0.20130125f, -0.00222177f, -0.05327571f, 0.12552512f, 
    0.38000005f, -0.10057546f, -0.08862468f, -0.12843005f, -0.05452293f, -0.04048609f, 0.10266843f, 0.16349474f, 
    -0.24662462f, -0.10526411f, 0.39297885f, 0.11268949f, 0.10040146f, -0.05061603f, 0.10825564f, -0.24901530f, 
    -0.26993892f, 0.06299445f, 0.26456383f, 0.14623722f, 0.13417971f, -0.24993549f, -0.25327122f, -0.05451946f, 
    0.14354083f, 0.07441583f, -0.15466279f, 0.12945452f, 0.30760092f, 0.34315357f, 0.18449037f, 0.13865495f, 
    -0.21179989f, 0.05449855f, -0.17661281f, -0.11833068f, -0.07202129f, 0.00820442f, 0.06751962f, -0.10051346f, 
    0.05529847f, -0.19316119f, 0.55850953f, 0.11418567f, 0.15671267f, -0.02053685f, 0.17406425f, -0.27713925f, 
    0.01262920f, -0.07054479f, 0.14249723f, -0.03899313f, 0.41344336f, -0.26389793f, 0.34366912f, -0.28604510f, 
    0.00890290f, 0.19801114f, -0.00345395f, 0.15228027f, -0.02989214f, 0.13809188f, 0.09636024f, -0.16671632f, 
    -0.10660121f, -0.04337798f, 0.45018452f, -0.09376564f, -0.02757087f, 0.07372403f, -0.11719574f, -0.10542758f, 
    0.39073399f, -0.09609184f, 0.14760709f, 0.05230060f, 0.13650039f, 0.14870267f, 0.00548959f, 0.23521441f, 
    -0.32347736f, 0.11183001f, 0.07849783f, -0.02443784f, -0.08185895f, -0.13492280f, 0.28524330f, 0.01452460f, 
    0.09085371f, 0.03137179f, -0.07148314f, 0.15323798f, -0.20610775f, 0.00986038f, 0.07526285f, 0.00956782f, 
    0.11788797f, 0.03776020f, -0.14374685f, 0.16292894f, 0.16667461f, 0.08091594f, 0.15233484f, 0.12262706f, 
    -0.08213092f, -0.03379349f, 0.29552615f, -0.02907089f, 0.16698685f, -0.07993739f, 0.04498857f, -0.37527943f, 
    0.12867810f, -0.00766590f, 0.23005103f, -0.13247585f, -0.07230531f, 0.39246115f, 0.03425523f, -0.35415271f, 
    -0.15837584f, 0.27457917f, 0.06916545f, 0.00296866f, -0.15844083f, 0.13010609f, -0.08642421f, -0.03064254f, 
    0.29962328f, -0.01718671f, -0.14490242f, -0.11390855f, -0.08280498f, -0.15711012f, 0.31581268f, -0.02322822f, 
    -0.29733464f, -0.10831740f, 0.10636783f, -0.02883870f, 0.10128249f, 0.08696740f, -0.10605161f, -0.14135323f, 
    -0.35778633f, 0.08810716f, 0.30625480f, 0.13745524f, 0.23231970f, 0.00812677f, -0.10136072f, -0.29100254f, 
    0.14437017f, 0.04728521f, 0.12360707f, -0.08344562f, -0.06327868f, 0.51214552f, 0.12012587f, -0.16502100f, 
    -0.20854314f, 0.16948850f, -0.05402752f, -0.05865726f, 0.07396019f, -0.03656682f, -0.15261205f, -0.01557745f, 
    -0.06646689f, -0.13055085f, 0.01818053f, 0.16971920f, -0.02806606f, -0.03264938f, 0.15730299f, 0.00031667f, 
    0.02225277f, -0.11228248f, 0.11085577f, 0.03430154f, 0.10727109f, 0.05669381f, -0.15139852f, -0.14482954f, 
    0.02312673f, -0.21480329f, 0.01041100f, -0.14989719f, -0.05812818f, -0.20159046f, -0.06073897f, 0.16939156f, 
    -0.07467297f, -0.17424503f, -0.05531380f, 0.00409490f, -0.07726575f, 0.09164812f, -0.07966594f, -0.03575424f, 
    -0.09267057f, 0.08850253f, 0.32378912f, 0.12355058f, 0.08543839f, -0.14759442f, -0.11983282f, -0.01552351f, 
    0.06658577f, 0.16883065f, -0.11102895f, -0.07699296f, -0.25382528f, -0.02565137f, -0.05302631f, 0.18069007f, 
    -0.11515169f, 0.18055263f, -0.01163187f, 0.15305108f, -0.02635107f, -0.16453443f, 0.01951146f, -0.16968504f, 
    -0.03832705f, 0.04961637f, -0.05801984f, -0.03325478f, 0.13044183f, 0.06631976f, -0.10726222f, 0.07765012f, 
    0.25418791f, -0.00816515f, 0.32226795f, -0.03212079f, 0.00103313f, 0.14300805f, -0.12356646f, 0.06363034f, 
    -0.17316459f, 0.04015359f, -0.14014482f, -0.09326478f, 0.15020184f, -0.01862876f, 0.16032489f, -0.05587050f, 
    0.16562423f, 0.16780950f, -0.05038801f, -0.06860320f, -0.32319230f, 0.27121717f, 0.00598563f, 0.00425929f, 
    -0.15480928f, -0.17082581f, 0.22060223f, 0.05734564f, 0.11365214f, 0.17774396f, -0.14537559f, -0.16715485f, 
    0.14906804f, 0.04691688f, 0.02052680f, 0.07375468f, -0.03386711f, -0.09237816f, 0.13123162f, -0.19056863f, 
    0.39883882f, -0.09202771f, 0.19183095f, 0.04601020f, -0.13154466f, 0.07688564f, 0.48429677f, 0.17050034f, 
    -0.17876729f, 0.02833403f, 0.12781173f, -0.02565706f, 0.08053724f, -0.00268270f, 0.15135144f, -0.14900057f, 
    0.29873809f, -0.04236907f, -0.44364592f, -0.00675531f, 0.06657705f, -0.13759892f, 0.23088439f, 0.01809084f, 
    -0.16647948f, -0.09757734f, -0.47530839f, -0.16366905f, 0.16778640f, -0.08268615f, 0.16811277f, 0.14989683f, 
    -0.38994929f, -0.03916485f, 0.20196384f, -0.14122382f, 0.21943045f, -0.10584664f, -0.09202198f, -0.08630203f, 
    0.07227372f, 0.25431517f, 0.07630298f, -0.03615734f, -0.06807937f, 0.50689542f, 0.00246917f, -0.11025316f, 
    0.02113432f, 0.12790540f, -0.16875878f, 0.17511006f, -0.03534843f, 0.11449266f, 0.23760650f, 0.12915999f, 
    -0.21306635f, -0.04602174f, -0.24940708f, 0.03188594f, 0.04701257f, -0.17687160f, -0.01766923f, 0.29417264f, 
    0.46285370f, -0.08137789f, 0.40456212f, 0.08928747f, 0.01998479f, -0.06127364f, 0.15301336f, -0.22474270f, 
    -0.02881915f, -0.20890513f, 0.09189583f, 0.01930113f, -0.02616701f, 0.37236220f, 0.16424131f, 0.05328041f, 
    -0.05755670f, 0.01595808f, 0.13699956f, 0.04056471f, 0.05247856f, 0.05602368f, -0.06219170f, -0.01590923f, 
    0.42298236f, 0.01371245f, -0.05079143f, 0.10694389f, 0.08577117f, -0.03716892f, 0.16300999f, 0.12167984f, 
    0.32307178f, 0.15484582f, -0.24158542f, -0.10348757f, -0.08052231f, 0.05202217f, 0.20863292f, 0.44001237f, 
    0.08453602f, -0.12390313f, 0.02207843f, 0.09375569f, 0.19453281f, 0.07639555f, 0.09802217f, 0.14815407f, 
    -0.19869250f, -0.08414163f, -0.11455219f, -0.06760467f, 0.15021448f, -0.06554674f, -0.04775641f, 0.15952812f, 
    0.09075590f, 0.01246181f, 0.15982226f, 0.00620652f, 0.16011211f, 0.13624063f, -0.10826710f, -0.02982527f, 
    -0.08718029f, 0.14296968f, 0.02851002f, 0.14421552f, 0.25958025f, 0.24727868f, 0.15711533f, 0.05282069f, 
    0.11939646f, -0.22277892f, 0.02490116f, 0.11559872f, 0.00266180f, -0.29375625f, 0.12763691f, 0.12073754f, 
    -0.09106942f, -0.15928015f, -0.32329497f, -0.07898860f, -0.06024579f, -0.05643151f, 0.29218099f, 0.14387085f, 
    0.03066988f, -0.06552282f, -0.46101531f, 0.08329147f, 0.02375836f, 0.11128411f, -0.14033876f, 0.40619856f, 
    0.26180539f, 0.16702659f, -0.10451993f, -0.01544299f, 0.08440183f, 0.27052405f, 0.09668107f, -0.43385401f, 
    0.04150636f, 0.30164149f, 0.12012365f, -0.01279783f, -0.16262229f, 0.00016318f, -0.12775043f, -0.12612593f, 
    -0.12469892f, -0.06482011f, -0.04142908f, 0.00120344f, 0.08781277f, -0.05491821f, -0.18623160f, 0.03905883f, 
    0.01994871f, -0.15481600f, -0.09814458f, -0.01645856f, 0.13694669f, -0.17239705f, -0.11314871f, -0.17789702f, 
    -0.15010676f, 0.12830910f, -0.02630397f, 0.13492624f, -0.01699961f, -0.17441152f, -0.14341313f, 0.11450908f, 
    -0.00702004f, -0.08917985f, 0.00724407f, -0.11129997f, 0.14800847f, -0.14506942f, -0.01813459f, -0.13633288f, 
    0.00353583f, -0.11466126f, -0.00236673f, -0.09585514f, 0.06461035f, 0.14157948f, -0.04921213f, 0.13610245f, 
    -0.18433785f, 0.11743772f, -0.14935318f, -0.17222601f, -0.17073460f, -0.00243613f, 0.01161211f, -0.03964719f, 
    -0.07124651f, -0.12374727f, -0.21698181f, -0.05023858f, 0.06826247f, -0.15050866f, -0.12068795f, -0.03624424f, 
    -0.10164575f, -0.10189898f, 0.13794801f, -0.07180358f, -0.02024286f, -0.18652706f, -0.03123213f, 0.00295745f, 
    0.25684398f, 0.16086450f, -0.08740230f, -0.08915185f, -0.04022417f, 0.07606020f, -0.00726501f, 0.01556295f, 
    -0.33698487f, 0.05045216f, 0.07264651f, -0.15235095f, 0.10886554f, -0.12118047f, 0.06472594f, 0.20399942f, 
    0.59773129f, -0.06599080f, 0.35238701f, -0.12900178f, 0.24520756f, -0.43355402f, -0.25911504f, 0.00329129f, 
    -0.05210390f, -0.23115394f, -0.15082520f, -0.09157109f, -0.08166048f, -0.10707437f, -0.07854934f, -0.04107219f, 
    -0.09908567f, -0.16601539f, -0.10416045f, 0.01138397f, 0.09412257f, -0.06598245f, 0.20682502f, 0.04580726f, 
    0.12737282f, 0.05585826f, 0.52182919f, 0.16897680f, 0.00942064f, 0.09222139f, -0.13621986f, -0.52473742f, 
    -0.03870558f, -0.16457924f, 0.25696799f, 0.01517846f, -0.09589114f, -0.40088052f, 0.41663012f, 0.16314082f, 
    0.11326867f, 0.07293142f, -0.15568319f, 0.03639513f, 0.03569286f, 0.29018432f, -0.07866293f, -0.12058189f, 
    0.13299601f, -0.16803530f, -0.33799240f, -0.13660260f, -0.14407741f, -0.01803129f, 0.18579654f, 0.13962309f, 
    -0.05576514f, 0.09488580f, -0.16187787f, -0.14872490f, 0.02592753f, 0.04157745f, -0.17310931f, -0.04092586f, 
    0.19886918f, 0.05566922f, -0.31042987f, 0.11172260f, -0.22709484f, 0.17616522f, -0.17111018f, 0.27417868f, 
    0.02154577f, 0.01879049f, 0.10357143f, 0.04792823f, 0.24833941f, 0.33510131f, -0.06269372f, 0.09056342f, 
    0.27613014f, 0.13413318f, 0.27984661f, -0.02319383f, 0.09467466f, -0.13623278f, 0.29568100f, 0.13061526f, 
    0.13803674f, 0.04822664f, -0.17277119f, 0.01934556f, 0.07112998f, 0.10780291f, -0.05628739f, 0.45278063f, 
    -0.18274231f, -0.01325438f, -0.14852758f, -0.15269259f, 0.26638332f, -0.41341129f, 0.17604752f, -0.03242459f, 
    -0.07398235f, -0.37517589f, 0.08523257f, -0.08678527f, 0.09427401f, 0.17726061f, 0.15412290f, -0.14221604f, 
    0.15320960f, 0.06168544f, -0.33269709f, 0.06541053f, -0.09514611f, -0.07725726f, -0.06340721f, -0.08237759f, 
    -0.09952427f, -0.12581684f, -0.33342636f, -0.15291281f, 0.07526045f, -0.13014494f, 0.17012921f, -0.18224433f, 
    0.33903486f, -0.11763943f, -0.11752082f, -0.15416904f, 0.05050724f, 0.13700797f, -0.42718929f, 0.32504424f, 
    0.07416963f, 0.13430203f, 0.04468548f, 0.05452672f, 0.10282412f, -0.00444015f, -0.15024631f, -0.14711484f, 
    -0.15389346f, 0.15959981f, 0.06124340f, -0.06376335f, -0.08599439f, 0.07536734f, -0.12454159f, 0.12765528f, 
    -0.01790675f, -0.17351143f, -0.16354039f, 0.08765575f, -0.01637911f, -0.02305210f, -0.01814780f, -0.15804465f, 
    -0.10106119f, 0.06792506f, -0.01479789f, 0.17268933f, 0.08472061f, -0.06120845f, 0.08972728f, 0.05970313f, 
    -0.03483815f, -0.04305242f, -0.03943425f, -0.06619402f, 0.03276689f, -0.04601558f, -0.02624261f, -0.06012109f, 
    0.01363183f, -0.17158100f, 0.45862594f, -0.05611928f, -0.03382352f, 0.06722294f, 0.04122112f, -0.02345343f, 
    -0.03424072f, -0.12099709f, -0.14349218f, -0.00414466f, 0.13424249f, 0.15399548f, 0.07777414f, 0.25958726f, 
    -0.08780766f, -0.01358842f, 0.36417070f, 0.09043226f, 0.23162590f, -0.01994395f, 0.08144376f, -0.31231040f, 
    -0.18399090f, 0.04430189f, -0.16029525f, 0.11410079f, 0.26229355f, -0.28940660f, -0.08590829f, 0.16832194f, 
    -0.00231557f, 0.00900575f, -0.25483698f, 0.02092304f, 0.04885055f, 0.01186695f, -0.14338949f, -0.15231940f, 
    -0.02206479f, 0.06512630f, 0.01398834f, -0.11365286f, 0.02207228f, -0.11682276f, 0.05993832f, 0.30680645f, 
    0.27629834f, 0.01250408f, 0.28964847f, 0.02138733f, -0.01164115f, 0.05633673f, -0.03749319f, -0.20082380f, 
    -0.08468670f, 0.08026329f, 0.05583899f, 0.16365448f, -0.08325515f, -0.07796580f, 0.01241534f, -0.05854334f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.14595868f, -0.09177066f, 0.24943769f, 0.04620687f, 0.28932443f, -0.14185844f, 0.20272011f, 0.01469874f, 
    -0.11737446f, -0.04968483f, 0.23445012f, 0.36708024f, -0.05524151f, 0.02848267f, 0.00074356f, -0.00817338f, 
    0.03911294f, 0.05334162f, -0.02695364f, -0.16731317f, -0.26268804f, 0.02994374f, -0.24467711f, -0.15480487f, 
    0.22031663f, 0.27948764f, 0.03119037f, -0.01398703f, -0.06385780f, 0.30563354f, -0.17516847f, 0.26270491f, 
    0.26232147f, -0.09637600f, 0.30227962f, 0.02259801f, -0.09914085f, 0.38190541f, 0.33343813f, 0.11314772f, 
    -0.06831753f, 0.11448485f, 0.13698667f, 0.16166870f, 0.09750365f, -0.19768816f, 0.05865332f, -0.14075787f, 
    0.24159342f, 0.05994346f, 0.07836203f, -0.05087371f, 0.13875832f, 0.35450393f, -0.12768327f, 0.05783118f, 
    -0.08093064f, -0.28702280f, -0.11459617f, 0.01697523f, 0.22125544f, 0.14083973f, -0.24253839f, -0.00536570f, 
    -0.00071376f, 0.08957443f, 0.01271394f, 0.08018234f, -0.10262638f, 0.25618407f, 0.27553907f, 0.19861867f, 
    0.05609231f, 0.00247382f, 0.19422342f, -0.11353540f, 0.18224272f, -0.12928566f, 0.10658935f, 0.00523059f, 
    0.25448799f, 0.02196616f, -0.16334514f, -0.05980189f, -0.17447490f, 0.34208754f, 0.02507469f, -0.10049365f, 
    -0.17931646f, 0.04428650f, -0.02666952f, 0.06881414f, 0.09169712f, 0.02362806f, 0.24920990f, 0.30878747f, 
    -0.11477723f, -0.12955683f, 0.11055154f, 0.01102253f, 0.01808587f, 0.13196844f, -0.03395021f, -0.05933226f, 
    0.00776272f, -0.03900780f, -0.09577370f, 0.13022456f, 0.20111930f, -0.13706425f, -0.07827571f, 0.07649840f, 
    0.09695908f, -0.16901635f, -0.00181653f, 0.02136907f, -0.09506852f, 0.07803591f, 0.14989750f, 0.02804013f, 
    0.29604670f, 0.04381725f, 0.15857200f, -0.03121596f, 0.18989907f, -0.05484011f, 0.01785444f, 0.14620553f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.08325068f, -0.23880936f, 0.00444870f, 0.35554370f, -0.05165631f, 0.12808013f, -0.31037018f, 0.04695469f, 
    -0.00453300f, -0.45112091f, -0.30839971f, 0.37123641f, 0.08062990f, 0.05517271f, -0.08394676f, -0.06192593f, 
    0.25268933f, 0.26119494f, 0.12346568f, -0.27217585f, -0.12211926f, -0.37677133f, -0.24323058f, 0.15206794f, 
    0.00479100f, -0.38761288f, -0.26600501f, -0.19014469f, -0.03772498f, -0.11984873f, -0.09206263f, 0.06770627f, 
    0.38284579f, 0.05647058f, -0.17153133f, 0.13547438f, 0.35282660f, -0.39677680f, -0.14465359f, -0.24901937f, 
    -0.25530273f, 0.11628290f, -0.06476519f, -0.61801434f, 0.08881962f, -0.02316073f, -0.38486737f, -0.36450854f, 
    0.29492661f, -0.12117916f, 0.00356770f, -0.30946502f, 0.06914730f, 0.01689853f, -0.00489792f, 0.30777302f, 
    -0.00647375f, -0.33260834f, -0.20566729f, -0.09209301f, -0.21016929f, -0.03665915f, 0.03193567f, 0.02702119f, 
    -0.72682571f, 0.06747176f, -0.08844271f, -0.30272391f, -0.01912938f, 0.10550960f, -0.20375620f, -0.11482767f, 
    0.04853730f, 0.14959706f, 0.26328665f, 0.20820850f, 0.14105700f, -0.07121774f, -0.34195948f, -0.00086307f, 
    -0.06706342f, -0.31255540f, 0.25044245f, 0.32558614f, -0.03939148f, 0.00025759f, -0.11278907f, 0.31342083f, 
    0.14222845f, 0.16622475f, -0.40572137f, 0.33927685f, -0.08139740f, -0.06518617f, -0.42410159f, 0.13240530f, 
    0.04225311f, 0.22796607f, 0.48440018f, 0.02736291f, -0.39136815f, -0.71465588f, 0.19558839f, 0.05924368f, 
    -0.32859311f, -0.08966503f, -0.34071904f, 0.19317605f, 0.05967824f, -0.08993790f, -0.14871058f, -0.11502235f, 
    -0.05556383f, 0.07072870f, -0.12032679f, -0.24240847f, -0.05357689f, 0.40627557f, -0.04507185f, -0.00800748f, 
    -0.69881153f, -0.35965171f, -0.02876309f, -0.21869628f, -0.19507295f, -0.02332425f, -0.01623386f, -0.07164890f, 
    0.08799770f, 0.05496991f, -0.56927806f, 0.09873012f, -0.09120447f, 0.25517386f, -0.15714659f, 0.00281377f, 
    -0.08909914f, -0.33245215f, 0.13255596f, 0.25409907f, 0.00428251f, -0.08089439f, -0.22670506f, 0.33661470f, 
    0.46585715f, -0.18111046f, -0.19975279f, 0.05102946f, 0.22457698f, 0.08310339f, 0.18993391f, 0.00973093f, 
    0.04267402f, 0.06831208f, -0.07826961f, 0.12797540f, -0.11365979f, -0.24902190f, 0.08969335f, -0.00463966f, 
    0.15140139f, -0.37232774f, -0.10019303f, 0.12032383f, -0.01917368f, 0.06132855f, -0.45399287f, -0.06644544f, 
    -0.11885229f, -0.25327983f, 0.21556054f, -0.65857124f, -0.31062946f, -0.05476442f, 0.18248902f, 0.02037401f, 
    0.08529251f, 0.30126876f, 0.18384148f, 0.04136403f, 0.21219608f, 0.35383952f, 0.09533452f, 0.07715663f, 
    0.29911172f, -0.09151288f, 0.10902594f, -0.00706943f, 0.16114336f, -0.03153671f, -0.09984206f, 0.07126246f, 
    -0.24130931f, -0.07374122f, 0.11567283f, -0.02030862f, -0.01915847f, 0.11555006f, -0.36716190f, 0.05442405f, 
    -0.51758850f, -0.37252477f, 0.02511759f, 0.25009191f, 0.01395362f, -0.04942100f, 0.14867957f, -0.38929844f, 
    -0.29056892f, -0.36274338f, 0.23448841f, -0.06173142f, -0.34556147f, -0.10466388f, 0.17145376f, 0.14382784f, 
    -0.20986484f, -0.06416099f, -0.29305092f, -0.20286958f, -0.19249807f, 0.22775759f, -0.20501040f, -0.14034608f, 
    0.06463154f, -0.53045338f, -0.22627817f, 0.30353832f, 0.24790475f, -0.13030422f, -0.23871222f, -0.01914819f, 
    0.09578997f, 0.17107286f, 0.15831122f, 0.13836952f, -0.12870419f, 0.01156891f, 0.25212532f, 0.23542492f, 
    -0.01189337f, -0.28239578f, -0.43068600f, -0.00502030f, 0.00604772f, 0.02250369f, -0.07929304f, -0.09249403f, 
    -0.18421026f, 0.16584377f, 0.06698631f, -0.22739889f, -0.15878111f, 0.06196153f, -0.29734910f, -0.20693055f, 
    -0.06814295f, 0.20892541f, -0.04620198f, -0.02101649f, -0.49842036f, 0.18285084f, 0.41777208f, 0.00708290f, 
    0.27720320f, -0.67929566f, 0.28069025f, -0.04616247f, 0.04372954f, 0.02158099f, 0.24499680f, 0.22729544f, 
    -0.23570313f, -0.09244867f, -0.05775277f, -0.11200617f, 0.11137244f, -0.34060487f, -1.07885432f, 0.39419106f, 
    0.29492071f, -0.06673438f, -0.30722809f, -0.44742233f, -0.05746153f, -0.23856317f, -0.24956673f, -0.09317353f, 
    -0.45959127f, -0.16316664f, 0.15651698f, 0.05258464f, -0.67966890f, -0.12538314f, -0.31757385f, -0.30202618f, 
    0.15122305f, -0.32495227f, -0.04103969f, -0.04072811f, -0.36427835f, 0.05235410f, 0.30979162f, -0.02689011f, 
    -0.17463899f, -0.01772021f, -0.03202678f, -0.24460246f, -0.03189506f, -0.13438399f, -0.01485669f, 0.18509163f, 
    -0.29199493f, -0.29318017f, -0.02301026f, 0.05676358f, -0.67789477f, 0.09529117f, 0.04741656f, 0.02142021f, 
    0.19964966f, 0.03977669f, 0.12617335f, -0.00107413f, 0.00078684f, -0.32315782f, -0.52370548f, -0.36937806f, 
    0.01513451f, -0.51737624f, -0.12246892f, 0.23229559f, 0.03992650f, 0.04050513f, -0.10853776f, 0.20139723f, 
    -0.13435273f, 0.22994199f, -0.44259760f, -0.05213038f, -0.00563363f, 0.14587623f, -0.01984145f, 0.23816587f, 
    -0.01095633f, -0.13428818f, -0.13028851f, -0.08072814f, 0.17179452f, 0.14163724f, 0.46120030f, -0.47017235f, 
    -0.08809672f, -0.03673752f, -0.16965596f, 0.07524420f, 0.06245047f, 0.14266407f, -0.09892183f, -0.10757530f, 
    0.34778121f, 0.10556979f, -0.49424562f, 0.21467270f, 0.29041171f, 0.04808979f, -0.01247825f, -0.18598740f, 
    -0.05079611f, 0.10555471f, 0.11338305f, -0.63930088f, -0.15990625f, -0.41175029f, 0.02703580f, 0.03663207f, 
    0.22099519f, 0.10669315f, -0.09069901f, -0.40599126f, -0.26444656f, -0.07383627f, 0.14877002f, 0.16596533f, 
    0.06045256f, 0.28585637f, -0.09210265f, -0.26377702f, 0.23053332f, -0.08701225f, -0.19217362f, -0.04184353f, 
    0.09503803f, 0.31466499f, 0.13926379f, -0.48005366f, -0.03525181f, -0.06000365f, 0.16729264f, -0.27335018f, 
    0.30874288f, 0.23158592f, 0.40230331f, 0.03619804f, 0.21975006f, 0.07639726f, -0.00607546f, -0.47210547f, 
    -0.28052697f, -0.11736362f, -0.22937573f, 0.11138690f, -0.00772592f, -0.03630459f, 0.17127937f, -0.59820539f, 
    -0.58070952f, 0.03382413f, 0.13790785f, -0.29982638f, -0.17157616f, -0.41652596f, 0.06823934f, 0.13990763f, 
    -0.02735456f, 0.13062003f, -0.45676139f, -0.43262860f, -0.02118015f, 0.02535493f, -0.02742350f, 0.43963081f, 
    -0.15341714f, -0.03204823f, -0.04789409f, -0.24424040f, -0.22302184f, -0.69568855f, 0.02604039f, 0.10846004f, 
    -0.13713898f, 0.31870347f, 0.18344283f, -0.11242106f, -0.03478919f, 0.05554591f, 0.00228022f, 0.05059733f, 
    -0.24357601f, -0.14296073f, -0.01151686f, 0.18861438f, 0.01725309f, -0.00211858f, 0.01312284f, -0.23013335f, 
    -0.04311547f, 0.07841186f, -0.30352405f, -0.12952453f, -0.22245513f, 0.00679706f, -0.09063035f, 0.23494992f, 
    -0.36397383f, 0.14127116f, 0.18079093f, -0.33391324f, -0.05507720f, -0.20011650f, -0.12069341f, 0.22110778f, 
    0.73825985f, 0.12862414f, -0.46088979f, -0.13943650f, -0.15775137f, -0.50156975f, 0.07130717f, 0.09421396f, 
    -0.06958451f, 0.42926341f, -0.15040702f, -0.19938903f, 0.14442173f, 0.21616119f, -0.44490156f, -0.12843272f, 
    -0.03474289f, -0.25780940f, -0.16396742f, -0.11722787f, 0.13935331f, -0.12693037f, -0.05811081f, 0.07192736f, 
    -0.24204156f, 0.18312086f, 0.23864104f, 0.03327563f, 0.12641108f, 0.04653551f, 0.06511622f, -0.05054506f, 
    -0.26140314f, -0.02862903f, 0.10522553f, 0.21814281f, -0.76224196f, -0.02155339f, -0.22834729f, -0.16132699f, 
    -0.31317455f, -0.19226985f, 0.27532870f, 0.09232205f, 0.15620668f, -0.20600305f, 0.53867906f, 0.05636324f, 
    0.11957930f, -0.23896284f, -0.01742811f, -0.15825351f, -0.08166976f, -0.06205485f, -0.16769029f, -0.20862564f, 
    -0.54668713f, 0.01873595f, 0.07775432f, 0.33768576f, 0.17356105f, -0.04919520f, -0.28695953f, -0.06318678f, 
    -0.11633678f, 0.22440258f, 0.22866397f, -0.09490831f, -0.11559927f, 0.09650671f, -0.41351619f, 0.11656513f, 
    -0.34371373f, -0.60537207f, 0.06187901f, 0.15260856f, -0.21718003f, -0.36191419f, -0.00005105f, 0.15102354f, 
    0.33387911f, -0.21139251f, -0.02756864f, 0.43935871f, 0.21927847f, 0.04753417f, -0.06461879f, -0.33830315f, 
    0.11441477f, -0.20481150f, -0.11503678f, -0.11525027f, -0.29247424f, -0.09447295f, -0.02546550f, -0.26814118f, 
    0.14245589f, -0.68528831f, 0.02175682f, 0.07332683f, 0.15302679f, -0.04319539f, -0.21486388f, -0.06238636f, 
    -0.48385686f, -0.01005321f, -0.09305673f, 0.06284079f, -0.05421898f, -0.01489772f, 0.14735498f, -0.02302612f, 
    0.24487004f, -0.02649504f, -0.10660562f, -0.14645880f, -0.04655888f, -0.09534269f, -0.09291780f, -0.10377315f, 
    0.06106463f, -0.36016607f, -0.22780602f, 0.11120491f, 0.19279224f, 0.05238211f, -0.21000315f, -0.24449469f, 
    0.06582132f, -0.44155779f, -0.02015434f, -0.10596634f, -0.44430968f, 0.14737512f, 0.18792528f, 0.07463968f, 
    -0.01209470f, -0.32777870f, -0.14707254f, 0.08614976f, -0.05543048f, -0.23526648f, 0.26233795f, 0.13713893f, 
    0.16102728f, 0.02219015f, -0.21357912f, 0.01714818f, 0.16656679f, 0.01498500f, -0.14932026f, -0.38319102f, 
    -0.11968910f, -0.07433163f, 0.10036298f, -0.17953755f, -0.44672674f, -0.15392867f, -0.08169679f, -0.00587349f, 
    0.19849797f, 0.04244992f, -0.11977342f, 0.21795952f, -0.97042996f, 0.00757844f, 0.15862922f, -0.18927364f, 
    0.26064053f, 0.45326164f, 0.06192524f, -0.25460905f, -0.03504498f, -0.08615037f, -0.05714477f, -0.00425723f, 
    -0.35439998f, 0.28499630f, 0.15728967f, 0.18933579f, 0.00593425f, 0.02435358f, -0.25066105f, 0.12182590f, 
    -0.54280937f, 0.00562478f, -0.66450620f, -0.39770034f, -0.60701561f, 0.07605124f, 0.28670570f, -0.16615495f, 
    0.09859730f, 0.16105682f, 0.12030473f, 0.12731420f, -0.02115819f, 0.18562010f, 0.16416657f, 0.21608534f, 
    0.29812047f, -0.03951640f, -0.13029611f, 0.05151025f, 0.05607219f, 0.32388562f, 0.02625609f, 0.21615294f, 
    -0.61543429f, -0.04388361f, 0.12680005f, -0.12634264f, -0.05132447f, 0.06645155f, 0.08227009f, -0.29708472f, 
    0.07117418f, -0.09865929f, 0.10421385f, 0.28552490f, 0.25618476f, 0.18248168f, -0.01782893f, -0.17930958f, 
    0.06765291f, -0.03241317f, -0.13222282f, -0.02913343f, 0.05520943f, -0.04870571f, -0.25423861f, -0.05258919f, 
    -0.00715224f, -0.04386618f, -0.02878028f, 0.00066654f, 0.06477913f, 0.13474052f, 0.15162051f, 0.12934843f, 
    0.00982968f, -0.01547620f, 0.21161671f, -0.37901133f, -0.03141047f, -0.21478623f, 0.14359204f, -0.49974468f, 
    0.04584639f, -0.03853397f, -0.28585732f, 0.00502453f, -0.08536416f, 0.03667635f, -0.02779031f, -0.38918263f, 
    -0.13852012f, -0.08325981f, -0.13520406f, -0.02177863f, -0.10108905f, 0.03114307f, -0.36614913f, 0.10848358f, 
    -0.02406885f, 0.29181936f, 0.19128036f, -0.25445411f, -0.09454630f, 0.12889464f, -0.08685901f, -0.16615243f, 
    -0.17443746f, -0.17617685f, 0.48480007f, -0.11462924f, -0.35793233f, -0.06778476f, -0.16238345f, 0.34259284f, 
    0.04459255f, -0.45495859f, -0.56927800f, 0.24353008f, -0.08754761f, -0.44035426f, -0.05322142f, -0.03245899f, 
    0.21366595f, -0.05624557f, 0.13838321f, -0.08108120f, 0.28591931f, 0.03099171f, -0.08983503f, -0.32888231f, 
    0.39516142f, -0.51788777f, 0.26770064f, -0.26165912f, -0.14326173f, -0.54421794f, -0.11202272f, -0.09019211f, 
    -0.00418170f, -0.45407709f, -0.13364793f, -0.62738878f, 0.03429104f, -0.02900977f, -0.13177854f, -0.35607198f, 
    0.15711550f, 0.17893219f, -0.11695176f, -0.69705302f, -0.56773728f, 0.27637306f, -0.38008177f, 0.24032864f, 
    -0.77852219f, 0.10796671f, -0.63820356f, 0.12251581f, 0.22358088f, 0.27373663f, -0.07095604f, 0.24597709f, 
    -0.05604520f, -0.08279967f, 0.17221580f, 0.06189615f, 0.02030347f, -0.52150720f, 0.25394881f, -0.18938115f, 
    -0.57524484f, 0.39536449f, 0.12672211f, 0.07470143f, 0.10718630f, 0.01093191f, -0.08480670f, -0.06039678f, 
    0.20105579f, -0.24201852f, 0.15226991f, -0.39418054f, -0.24466126f, -0.00995312f, 0.08361488f, -0.08383299f, 
    -0.60395759f, 0.17996377f, -0.12999648f, -0.02090445f, -0.26854402f, 0.05361022f, -0.01995001f, 0.05708320f, 
    -0.15436819f, 0.16700773f, -0.54447180f, -0.28378296f, 0.04612410f, 0.07206845f, 0.03638683f, 0.08703844f, 
    0.26782352f, 0.10568638f, 0.03810035f, -0.49809039f, 0.16619471f, 0.02316866f, -0.06858431f, 0.05802859f, 
    0.26459780f, -0.40029579f, -0.50329190f, 0.07160886f, -0.14695832f, 0.21690637f, 0.03196416f, -0.06495485f, 
    0.29812458f, -0.17375965f, 0.10279958f, -0.58578098f, -0.12348408f, -0.30359185f, 0.05280099f, 0.01324125f, 
    0.06462373f, -0.50024092f, -0.30799261f, -0.81659919f, -0.53428084f, 0.36925471f, -0.22047500f, -0.55933505f, 
    0.25018853f, -0.38597089f, -0.51576585f, -0.07275679f, 0.13095827f, -0.07992472f, -0.30320674f, -0.21451201f, 
    -0.09693152f, 0.27307063f, -0.18479700f, -0.02489661f, -0.23715951f, -0.37857029f, -0.02946732f, 0.05373834f, 
    -0.33380207f, -0.17419732f, 0.16722651f, 0.02269414f, 0.02192269f, -0.01081086f, -0.22935349f, -0.39251113f, 
    -0.39420682f, 0.00699212f, 0.13989472f, -0.11029318f, -0.10059701f, -0.07554450f, 0.23346539f, -0.08108490f, 
    -0.29216051f, 0.24350099f, 0.13970657f, 0.25693414f, 0.07852290f, -0.01825248f, 0.12266111f, -0.11295947f, 
    -0.05762769f, 0.00543556f, -0.03559303f, 0.18088692f, 0.19954689f, -0.46395051f, 0.29835892f, -0.12354766f, 
    -0.05170131f, -0.26382810f, 0.24418209f, -0.07050161f, -0.27802324f, -0.01249594f, 0.28058273f, -0.28652871f, 
    0.01104150f, -0.05334353f, -0.54277307f, -0.15081926f, 0.12035992f, -0.21349971f, -0.07050937f, 0.22458985f, 
    -0.06641278f, -0.34027767f, -0.18162546f, 0.05999557f, 0.07996807f, -0.04237442f, -0.04566197f, 0.18018200f, 
    -0.41934752f, 0.12258268f, -0.36412781f, 0.33411992f, 0.02604503f, -0.46975878f, -0.09240700f, -0.42278007f, 
    0.18287557f, 0.00315665f, 0.07104807f, -0.03090692f, -0.20067210f, -0.06648920f, -0.19108756f, 0.00819633f, 
    -0.10230701f, -0.16123071f, -0.01036840f, 0.09613050f, 0.05536354f, -0.08137068f, 0.21356969f, -0.64428622f, 
    0.12252817f, 0.20172971f, 0.08852941f, -0.48215255f, -0.62316620f, -0.17898121f, -0.03495118f, -0.19384380f, 
    0.03648850f, 0.10974588f, -0.01533252f, 0.13664865f, 0.38761955f, -0.45759460f, -0.23000833f, -0.13537695f, 
    0.28850874f, -0.08470152f, -0.14560765f, 0.35421345f, 0.02738678f, 0.08532387f, -0.34081435f, -0.05932676f, 
    -0.08448353f, 0.02722905f, -0.06973784f, -0.09546432f, -0.06313129f, -0.12680797f, 0.15131779f, 0.01942525f, 
    -0.47186160f, -0.29758886f, 0.34417796f, -0.51183128f, -0.34207511f, 0.02518633f, -0.06817154f, -0.34940901f, 
    0.16989693f, -0.06491700f, -0.10097036f, 0.08265419f, 0.00077984f, 0.02557055f, 0.02292293f, 0.05150855f, 
    -0.47459322f, -0.24383384f, -0.48426932f, 0.13247465f, -0.02225667f, 0.08611930f, 0.28724003f, 0.14644027f, 
    -0.37563691f, -0.00643611f, -0.35651031f, -0.06136762f, -0.51135433f, 0.11011177f, -0.28994277f, 0.05911830f, 
    0.18493514f, -0.01462568f, 0.15087174f, -0.16931695f, 0.04673466f, -0.04889266f, -0.13137974f, 0.18182597f, 
    -0.11343027f, -0.31536517f, -0.40202078f, 0.26563025f, -0.01343049f, -0.35105908f, -0.11528088f, -0.31085026f, 
    0.09237871f, -0.03285015f, -0.35815629f, -0.12894079f, -0.15664585f, -0.50940114f, -0.31918016f, -0.53575635f, 
    -0.00574038f, 0.66752768f, -0.02414702f, -0.23734550f, -0.02391457f, 0.37745887f, -0.61674494f, -0.29265893f, 
    0.02801692f, -0.27343357f, 0.03713969f, 0.42294684f, -0.32534185f, -0.04970820f, 0.17433414f, 0.14829816f, 
    -0.42041934f, -0.12820718f, 0.04749596f, 0.17095923f, 0.16423436f, 0.12231265f, -0.10649049f, 0.03578423f, 
    0.24860632f, 0.35570201f, -0.41300407f, -0.04406109f, 0.28824082f, 0.02136011f, 0.16344520f, -0.05085780f, 
    0.00292928f, 0.04678736f, 0.30052182f, 0.32348317f, -0.04817958f, -0.21375661f, -0.03426677f, 0.20004651f, 
    -0.72558653f, -0.17407084f, 0.06064016f, 0.10548639f, 0.10939795f, 0.14415316f, 0.15617925f, 0.09160618f, 
    -0.17649671f, 0.27123681f, -0.09071450f, -0.41326544f, 0.26104251f, -0.03239314f, -0.02233876f, -0.25725803f, 
    -0.13336088f, 0.33984369f, 0.26967603f, -0.18223821f, 0.29577440f, -0.18302342f, -0.12268683f, -0.28878886f, 
    0.07729950f, -0.13273183f, -0.15641588f, 0.11938965f, 0.20584412f, 0.00932342f, 0.03072273f, 0.13495018f, 
    -0.35761875f, 0.14424255f, -0.05696290f, -0.06966268f, -0.63064057f, 0.00997062f, 0.05915239f, 0.01232990f, 
    0.31361917f, -0.61878860f, 0.19816159f, 0.26184633f, 0.19737029f, -0.06731597f, 0.03340079f, 0.02782819f, 
    0.26552072f, 0.01338133f, -0.13921541f, -0.28078720f, -0.23687686f, -0.06869708f, -0.18863313f, 0.28966153f, 
    -0.68370801f, -0.08324222f, 0.16416234f, 0.11329481f, 0.13553351f, -0.27554908f, -0.08027135f, -0.10761749f, 
    0.24306202f, -0.72577029f, -0.26492453f, 0.24485841f, 0.01926235f, -0.03711378f, -0.51669306f, -0.12777127f, 
    -0.19364393f, 0.18560149f, 0.13618112f, -0.54090238f, -0.99565935f, -0.21657561f, 0.09404422f, 0.02235916f, 
    0.47610289f, 0.14947712f, -0.17344749f, -0.06685349f, 0.14326434f, 0.09434839f, -0.12253079f, -0.00886390f, 
    0.01210248f, -0.33952573f, -0.17547584f, 0.07434253f, 0.17102839f, -0.21796356f, -0.00273837f, -0.30437768f, 
    0.08253109f, -0.01072366f, -0.05232502f, -0.19300118f, -0.03795648f, 0.01234307f, -0.15349390f, -0.54054016f, 
    0.10240926f, 0.40501109f, -0.06995727f, 0.48665449f, 0.04320772f, 0.05328332f, -0.01316898f, -0.33487135f, 
    0.07846317f, 0.27882349f, -0.36123085f, -0.02997090f, 0.18788679f, -0.05300403f, 0.19999580f, -0.07403932f, 
    0.15755144f, 0.23843217f, -0.04742004f, 0.10376324f, 0.06183793f, -0.53015691f, 0.16836482f, 0.34630021f, 
    -0.11124856f, 0.25981939f, 0.03977194f, 0.02875001f, -0.01454306f, -0.21771161f, -1.03749776f, 0.08827477f, 
    0.16383018f, 0.19897206f, -0.34234107f, 0.20018084f, 0.39596242f, -0.05667233f, -0.49724743f, -0.20172422f, 
    -0.59266973f, -0.07346796f, 0.07080933f, -0.09024069f, 0.09041218f, -0.51709998f, -0.21121724f, 0.12598979f, 
    0.04913063f, 0.09243630f, -0.75421011f, -0.00987432f, -0.60913581f, -0.21275325f, 0.23243466f, -0.42908627f, 
    -0.14020921f, -0.58678991f, -0.15744440f, 0.02892211f, -0.10155448f, 0.00433773f, -0.25610015f, -0.56790262f, 
    -0.01155686f, 0.02793481f, 0.28925949f, 0.09997791f, 0.13277064f, 0.27868077f, 0.06321726f, -0.10277291f, 
    0.29550147f, -0.65532047f, 0.19905593f, 0.01489507f, 0.25259846f, 0.05626743f, 0.02665695f, 0.15036197f, 
    0.20047380f, -0.73986721f, -0.47854882f, -0.57192874f, 0.00279963f, 0.07751761f, 0.01875187f, -0.09655717f, 
    -0.37998509f, 0.04781314f, 0.09775683f, -1.08665454f, 0.01450081f, 0.06364835f, 0.14479806f, -0.04806894f, 
    -0.00176428f, -0.22781575f, -0.09610859f, -0.45741647f, -0.11033254f, -0.02975823f, 0.05070298f, -0.25765982f, 
    -0.70864367f, -0.19774687f, 0.36683106f, -0.16771674f, -0.04171421f, -0.17747989f, 0.19201086f, -0.33302271f, 
    -0.40747049f, -0.13121127f, 0.25192824f, -0.24446273f, -0.11369702f, 0.45556691f, -0.10588888f, 0.04713879f, 
    0.01860181f, 0.10304572f, -0.24417751f, 0.42573696f, 0.01992627f, 0.04851848f, 0.11288366f, 0.02275360f, 
    -0.09857676f, 0.02123665f, -0.20928249f, -0.52131897f, -0.09369583f, 0.02735483f, 0.06323314f, 0.14397028f, 
    -0.25613022f, -0.40998611f, 0.19778331f, -0.01423364f, 0.04973343f, -0.03698977f, -0.21050231f, 0.04603360f, 
    -0.17192432f, -0.15830435f, -0.03404965f, -0.12340023f, -0.05446439f, 0.33409956f, -0.42060071f, -0.54221147f, 
    -0.19104661f, -0.05313956f, -0.37966275f, -0.04829061f, 0.20658775f, 0.06199434f, 0.34409297f, -0.00064805f, 
    -0.27384850f, 0.10157950f, -0.03107960f, -0.42280826f, -0.39555624f, -0.10492770f, 0.54804504f, 0.31841081f, 
    -0.31385496f, 0.23192200f, 0.44021550f, -0.34077296f, -0.00419636f, 0.01769246f, -0.00331924f, -0.00411074f, 
    -0.05850286f, -0.15964401f, 0.17847151f, -0.02569145f, 0.19804439f, -0.10809864f, -0.22061434f, 0.32074249f, 
    -0.10454420f, 0.31449071f, -0.05245803f, 0.12272455f, 0.09913320f, -0.00900810f, 0.05353853f, 0.14115672f, 
    0.20900717f, 0.02406758f, 0.04822966f, -0.07065337f, -0.12933107f, 0.01890955f, 0.02506386f, -0.05137086f, 
    -0.49122265f, 0.51387894f, -0.12684390f, -0.08138964f, -0.74016613f, 0.04353051f, -0.17548649f, -0.29077506f, 
    0.04969417f, -0.65724647f, -0.02584598f, 0.08816961f, 0.08296809f, -0.03224154f, -0.41488129f, 0.07064847f, 
    0.15678991f, -0.05717830f, -0.54499984f, -0.94470626f, -0.09232591f, -0.00044654f, 0.08668894f, -0.47925913f, 
    -0.15113342f, -0.29625413f, -0.02522982f, 0.11911956f, -0.12083446f, 0.26293299f, -0.31883630f, -0.09459794f, 
    -0.50622058f, -0.13577227f, -0.11314645f, 0.29742265f, 0.08778174f, -0.04003737f, -0.45476618f, 0.21701048f, 
    -0.00029967f, -0.50628620f, -0.01716619f, -0.19225983f, -0.03451425f, 0.11523536f, 0.12497850f, -0.06461779f, 
    0.20496182f, 0.28838474f, -0.13769911f, -0.12859197f, 0.15183531f, -0.02107462f, -0.42163312f, 0.10884207f, 
    -0.11836567f, -0.35189918f, 0.02302694f, -0.58227742f, -0.46051687f, -0.14003915f, -0.04858764f, 0.23334700f, 
    -0.21779959f, 0.44122189f, 0.20519306f, 0.02679312f, 0.18524610f, -0.06292488f, 0.03249159f, -0.00684780f, 
    0.42512509f, -0.09249576f, -0.23188488f, -0.37409189f, 0.07447446f, -0.00879864f, -0.06774478f, -0.04990878f, 
    0.09015293f, -0.03803708f, -0.61978608f, 0.01364842f, -0.14428601f, 0.07783042f, 0.32304963f, 0.27920762f, 
    0.00524791f, 0.23214966f, 0.10412633f, -0.16813184f, -0.22141679f, -0.03435720f, -0.24033485f, -0.31152597f, 
    -0.10810178f, -0.15559521f, -0.22933990f, -0.06052342f, -0.02952358f, 0.24777283f, 0.32903287f, -0.26292676f, 
    -0.06586256f, -0.31878191f, 0.09876490f, 0.05187945f, 0.16180550f, 0.03438554f, -0.44449410f, 0.15554665f, 
    0.04960217f, 0.29982463f, -0.24778350f, -0.11571738f, 0.06867012f, 0.05124550f, -0.19073968f, 0.08257749f, 
    -0.45406586f, 0.22640985f, -0.03682713f, -0.30249682f, 0.11052305f, 0.21473131f, -0.01991404f, 0.04466415f, 
    0.06450696f, -0.32571125f, -0.13446279f, 0.11286438f, -0.28920400f, 0.02401585f, 0.14184599f, -0.21624628f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05045809f, 0.03886549f, -0.00017887f, -0.11026438f, 0.24575941f, 0.19414844f, -0.10539818f, -0.30536717f, 
    -0.13853900f, -0.10317045f, 0.08620364f, -0.08103027f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
