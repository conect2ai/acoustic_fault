#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.82908893f, 0.93353319f, -0.17579710f, 0.79864740f, 0.51909739f, 0.65206110f, 0.04438560f, -0.17004663f, 
    0.13325201f, 0.32391074f, 0.91310108f, 0.19108360f, -0.42044386f, 0.69980955f, 0.87560683f, -0.03919432f, 
    -0.56872553f, -0.75088900f, 0.13300306f, -0.29991296f, -0.13331744f, -0.74260342f, -1.15722871f, 0.14514527f, 
    -0.50430661f, -0.54882312f, 0.37888044f, 0.01707646f, 1.27497768f, -0.12860361f, -0.94597238f, 0.11733029f, 
    0.80500054f, -0.21214384f, 0.59461397f, -0.75353026f, 1.09071660f, 0.43581814f, 0.91181272f, -0.98440307f, 
    0.27236423f, -0.55075097f, -0.34954420f, 0.18845320f, 0.12063326f, -1.26174140f, 0.35407019f, 0.53532058f, 
    0.72176778f, 1.12748873f, 0.48449996f, -0.50663179f, -0.47926265f, 0.18076986f, 1.11820054f, -0.92734635f, 
    0.25039312f, 0.62597048f, 0.63453704f, 0.37419352f, -0.19482438f, 0.03796974f, -0.64155328f, -0.34625509f, 
    -1.13645267f, 0.55241287f, 0.65019476f, -0.00657989f, 1.08164239f, 0.26390955f, -0.50715178f, 0.18265538f, 
    -1.01622725f, 0.80971730f, 0.88591063f, 0.38731003f, 0.37170476f, 0.47240001f, 0.04380435f, -0.00358765f, 
    0.32875845f, 0.22519332f, -0.69345957f, 0.82656354f, -0.89087820f, -0.75310248f, -0.59470427f, 0.18745056f, 
    0.03172788f, -0.32956991f, 0.83639967f, -1.05432618f, 1.14648092f, -0.75994581f, 0.53565770f, -0.31837592f, 
    0.48238730f, 0.11006010f, 0.05348993f, 0.32097536f, -1.48013604f, 0.17097113f, 0.84095150f, 0.32848147f, 
    0.59808868f, -0.57195395f, -0.25372943f, -0.61955488f, 1.06997907f, -0.77669394f, -0.53677583f, -0.68925452f, 
    -0.85623741f, -0.33174318f, 0.16741459f, -0.33730337f, -0.06738346f, 1.16183662f, 0.41139364f, 0.76772195f, 
    -0.48498771f, 0.40009627f, 0.03382232f, 0.34787652f, -0.12912232f, -0.13926899f, 0.64893651f, 0.94566613f, 
    0.89056897f, 0.65351593f, 0.36523694f, -0.15767929f, 0.34073573f, 0.55679840f, -0.20964980f, -0.66164911f, 
    -0.81917816f, -1.04467285f, -0.67449552f, 0.41136241f, 0.37979653f, -0.71947235f, 0.10086400f, 0.26157105f, 
    0.75143772f, 0.92982566f, 1.02623451f, 0.27899316f, -0.27500939f, -0.02540959f, 0.50624180f, 0.21456829f, 
    -0.33661634f, -1.22393847f, 0.37800941f, 0.91800511f, -0.52679640f, -0.00236533f, 0.40846425f, 0.30331260f, 
    -0.35440001f, 0.17763427f, -0.99565369f, -0.28371376f, 0.85475683f, 0.82224709f, 0.80675977f, -0.97870559f, 
    0.24551977f, 0.66859770f, 0.35299626f, 1.33465052f, 1.00925386f, -1.30071723f, -0.95148295f, 0.29426849f, 
    -0.16531904f, -0.16948192f, 0.23540875f, 0.22879626f, -1.40545225f, 0.00572041f, -1.16636539f, 0.62519938f, 
    0.47648039f, 0.01215115f, 0.14920042f, 0.33530185f, 0.48669612f, 1.23146915f, -0.51937383f, -1.10727704f, 
    0.77652901f, 0.28297210f, -0.23100814f, -0.37058029f, -0.07698594f, 0.18704918f, 0.63965487f, 0.61356503f, 
    0.14403209f, 0.36747316f, 0.14018270f, 0.53395790f, 0.23748837f, 0.58454478f, 0.51085538f, -0.48059705f, 
    -0.49974334f, -0.41499677f, 0.83630860f, 0.92017621f, -0.80234057f, 0.50413126f, -0.73064590f, -0.18528128f, 
    -0.29677856f, -0.21022944f, 0.07089172f, -0.62563837f, -0.60701114f, -0.81103855f, 0.60603702f, 0.76157320f, 
    0.24190447f, -0.21019354f, 0.03496977f, 0.64867282f, -0.84610331f, -0.73672813f, -0.71115553f, 0.57070726f, 
    0.17715684f, 0.23692501f, -1.10052860f, 0.83727551f, -0.90271753f, -0.22022395f, -0.15416315f, -0.67524010f, 
    -0.48252580f, -0.09353621f, -0.41225529f, 0.02636950f, 1.14465880f, 0.88731062f, -1.27459025f, 0.31473023f, 
    -0.18398353f, 0.18831217f, 0.33006451f, 0.13472819f, -0.64222169f, -1.31679130f, -0.52023691f, 0.87002170f, 
    1.03896487f, -0.18212050f, -0.74736220f, -0.20071511f, 0.10498676f, -0.59478515f, -0.82699049f, -1.14095807f, 
    -0.90220261f, -0.39610258f, 0.57491189f, 0.64452279f, -0.25867245f, 0.31013137f, -0.20066358f, 1.33967853f, 
    0.92306828f, -0.16899294f, 0.27339822f, 0.16745530f, -0.10222901f, -0.05044839f, -0.16680090f, -0.42840567f, 
    -0.27518213f, 0.25831619f, -1.02669799f, 1.08268428f, 0.54966432f, -0.30542484f, 0.00957510f, 0.11176230f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02554254f, -0.08872981f, 0.27435422f, 0.19708125f, 0.01000365f, -0.01780553f, 0.07179245f, -0.06693342f, 
    0.50311786f, 0.24271062f, 0.07838141f, 0.17494106f, -0.01555987f, 0.41794813f, 0.24532476f, -0.02055531f, 
    -0.00981237f, 0.11543502f, 0.10583128f, 0.11646567f, 0.04800566f, 0.12968455f, 0.27851745f, -0.09616444f, 
    0.26181030f, -0.05590604f, 0.26756862f, 0.10774015f, 0.11913688f, 0.02896451f, 0.32070360f, 0.20477323f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01491659f, -0.00277750f, -0.00031805f, 0.01399512f, 0.02807163f, -0.01225405f, 0.03903590f, -0.00185751f, 
    0.02456084f, 0.01336958f, 0.01703587f, -0.03681087f, 0.00276388f, -0.00836872f, 0.01002039f, -0.01648008f, 
    -0.03576532f, 0.00366376f, 0.00217291f, -0.03810378f, -0.01309468f, 0.01010147f, -0.00090660f, -0.00365728f, 
    0.02517414f, -0.03157904f, -0.01815528f, -0.04511734f, 0.00626425f, 0.01022445f, 0.00654208f, 0.01114094f, 
    -0.03277397f, 0.02939645f, -0.02583475f, -0.02204498f, 0.03168538f, -0.03531117f, -0.03386414f, 0.00383108f, 
    0.00159141f, -0.03257668f, -0.00111559f, 0.00901536f, 0.02800119f, -0.03089681f, -0.03171277f, -0.01729423f, 
    0.02368048f, -0.01752893f, -0.02412108f, 0.01728689f, 0.01008745f, 0.00793464f, -0.01012711f, -0.04025137f, 
    -0.03967707f, 0.00756422f, 0.02283024f, -0.03631914f, -0.01543030f, -0.00151299f, -0.01777080f, -0.04621158f, 
    -0.03579111f, -0.02819319f, 0.01364996f, -0.02511889f, -0.04085569f, -0.01919941f, 0.02618494f, -0.01544460f, 
    -0.01477266f, -0.01287380f, 0.00093612f, -0.01395568f, -0.02359707f, -0.00556372f, -0.04335689f, -0.02718645f, 
    -0.04479329f, 0.02370104f, -0.00973605f, -0.02002815f, -0.00517873f, -0.04520088f, 0.00390964f, 0.02920564f, 
    -0.04058859f, -0.02724068f, -0.00649008f, -0.01805503f, 0.01656085f, -0.00994253f, -0.03372751f, 0.01891303f, 
    -0.00022748f, 0.01471765f, 0.00613835f, -0.04318473f, 0.02551746f, -0.04650731f, 0.01773035f, 0.00171953f, 
    -0.00643660f, -0.01689760f, -0.04188859f, -0.00579296f, 0.01805014f, -0.00518047f, 0.03210887f, 0.02156200f, 
    -0.00624448f, -0.02434459f, 0.00828534f, 0.02762518f, -0.01321344f, -0.03964347f, -0.02761097f, 0.01985803f, 
    0.01011704f, -0.01804369f, 0.00222767f, 0.00207403f, 0.00082631f, -0.04095162f, -0.01653388f, 0.01002994f, 
    -0.00738700f, -0.00693807f, -0.02693916f, -0.00597357f, -0.03314216f, -0.02933555f, 0.03226658f, 0.00777064f, 
    0.01919400f, 0.02240787f, 0.00781818f, 0.00576592f, 0.03745047f, -0.04150285f, -0.03341047f, -0.00548412f, 
    -0.01490410f, -0.02163979f, 0.03406987f, -0.00754034f, -0.02575048f, -0.03283428f, -0.01191523f, -0.03922023f, 
    -0.00647196f, -0.00819458f, 0.02649617f, -0.03330872f, -0.02931235f, -0.03228199f, 0.00467912f, -0.03713936f, 
    0.03878488f, -0.03227404f, -0.01258170f, -0.02107255f, -0.01737432f, -0.01555330f, -0.04318834f, -0.01299976f, 
    -0.00168263f, 0.02904738f, 0.00248172f, 0.03076095f, -0.01412532f, 0.02509986f, -0.04370474f, -0.01136531f, 
    0.02827856f, -0.01500355f, -0.02479027f, -0.03810986f, -0.00028568f, 0.00299687f, 0.01801836f, -0.01182579f, 
    -0.03098801f, -0.00763716f, -0.04581672f, 0.02349559f, 0.02007483f, 0.01886549f, 0.00977013f, 0.02118168f, 
    -0.04013837f, 0.00970106f, 0.00359768f, -0.02010601f, 0.01229665f, 0.02108176f, 0.02679070f, -0.04686014f, 
    0.01510261f, 0.02143741f, 0.03186072f, 0.01502321f, -0.01343429f, -0.04099022f, -0.00537091f, -0.01903179f, 
    -0.01042854f, -0.01265153f, 0.01357399f, 0.02337577f, -0.00230561f, -0.02915873f, -0.03493139f, -0.00045081f, 
    0.00788211f, 0.02900765f, 0.01981122f, 0.02210923f, 0.01434082f, -0.00994689f, -0.03963243f, 0.02970903f, 
    -0.01560661f, 0.01752936f, -0.00020835f, -0.00893742f, 0.00140553f, 0.01762385f, 0.02062230f, 0.02499814f, 
    -0.01622646f, 0.02789881f, -0.03671828f, -0.03061702f, 0.03095742f, -0.02618709f, -0.02643922f, 0.02270632f, 
    0.02970152f, -0.03074148f, 0.01123613f, -0.00305068f, 0.01696705f, 0.02876948f, 0.00880740f, 0.01315499f, 
    -0.00654715f, 0.02254653f, -0.01533461f, 0.01791787f, -0.00437194f, -0.00471988f, 0.00322215f, -0.02861780f, 
    -0.00502668f, -0.00907119f, -0.00676868f, -0.00899786f, -0.03284098f, -0.01794410f, -0.03657081f, 0.00807899f, 
    0.01008639f, -0.03076286f, 0.00388780f, -0.04527026f, 0.02064763f, 0.00350089f, 0.01043268f, 0.03568519f, 
    -0.03908321f, 0.03108806f, -0.00430996f, -0.04010059f, -0.01994202f, 0.01228058f, -0.00365135f, -0.01653412f, 
    0.03960760f, 0.04282463f, -0.02122084f, -0.04596743f, 0.00605176f, -0.03083650f, -0.01291263f, -0.01393644f, 
    0.00150720f, 0.02336485f, 0.01779501f, -0.02671534f, 0.02229543f, -0.04359083f, -0.02717239f, 0.00005715f, 
    -0.01155503f, -0.00211753f, 0.00156393f, -0.03257387f, -0.03248477f, -0.02239419f, 0.02918511f, -0.00062655f, 
    0.02300508f, -0.03205442f, -0.02936542f, -0.01639306f, -0.02310663f, -0.04233101f, -0.03398560f, 0.01003262f, 
    -0.00834979f, -0.03781578f, 0.01495609f, 0.01057167f, -0.00525022f, 0.03483939f, -0.02352799f, -0.04589398f, 
    0.03551107f, 0.02045622f, 0.03090517f, -0.01661786f, -0.03280446f, 0.03458491f, 0.00892087f, 0.00728966f, 
    0.01286186f, 0.03054692f, -0.00319077f, 0.00704794f, -0.01690159f, -0.02341069f, 0.01588042f, -0.00933626f, 
    0.01103137f, 0.01677238f, 0.01111853f, 0.00543600f, -0.02722455f, -0.02346998f, 0.04251317f, 0.00464989f, 
    -0.03327313f, -0.01670823f, -0.02608581f, -0.02802363f, -0.02399617f, 0.00322153f, -0.01222127f, 0.01122758f, 
    0.01780653f, -0.03785024f, -0.03511702f, 0.00756487f, -0.03386634f, 0.02824884f, -0.02446421f, 0.03730441f, 
    0.00612184f, 0.02102715f, -0.03882185f, 0.02690025f, -0.02092475f, -0.00128183f, -0.03063726f, 0.01554617f, 
    -0.00250788f, -0.04396980f, 0.03032495f, 0.01668116f, -0.00384461f, -0.00704047f, 0.00118304f, 0.00116488f, 
    0.03257276f, -0.04514048f, -0.01682265f, -0.01927122f, -0.03125891f, 0.00599699f, 0.03122375f, -0.03167214f, 
    0.00169667f, 0.01212428f, -0.01235269f, -0.02795768f, -0.00989817f, -0.01291203f, -0.03211337f, -0.00181144f, 
    -0.02400272f, -0.02113450f, 0.00342037f, -0.04512003f, -0.01469665f, -0.03143076f, -0.00747129f, 0.01262924f, 
    -0.00107350f, 0.01698974f, 0.03034507f, -0.01425221f, 0.00764924f, -0.01867951f, -0.02332147f, 0.00447867f, 
    0.00260634f, -0.01737812f, -0.04142028f, -0.00563358f, -0.00756695f, 0.01116288f, -0.01980866f, -0.01389969f, 
    -0.01405823f, 0.02525284f, -0.00492130f, 0.01830452f, -0.03262464f, -0.03338512f, -0.02436462f, 0.00323022f, 
    0.01325834f, -0.02754174f, -0.03200361f, -0.01172511f, 0.02951968f, -0.03889704f, -0.01132733f, 0.01530719f, 
    0.02865461f, -0.03837549f, 0.02970499f, 0.00023315f, -0.00115238f, -0.00506476f, -0.01585085f, -0.00570008f, 
    -0.02033748f, 0.02672664f, 0.02965283f, -0.02869096f, -0.01316208f, 0.02173148f, 0.00649239f, 0.03587586f, 
    0.00721862f, -0.01998723f, 0.02112793f, -0.01657997f, -0.00781078f, -0.03409994f, -0.01550229f, -0.03777210f, 
    -0.01584204f, -0.04314576f, -0.02783948f, 0.02217894f, -0.02086122f, 0.00352410f, 0.02399333f, -0.02720505f, 
    0.02500540f, -0.00585718f, 0.01984791f, -0.03222276f, 0.00456047f, -0.02083841f, 0.01497012f, 0.01919774f, 
    -0.02599556f, 0.02637212f, 0.00145759f, 0.02388580f, 0.03191841f, -0.02389514f, -0.04085447f, 0.02729706f, 
    -0.00838502f, 0.03002980f, 0.02962041f, 0.01818584f, -0.03370406f, -0.00188459f, 0.03676310f, -0.04310429f, 
    0.03074658f, -0.04432035f, -0.03652545f, 0.00390275f, -0.02163902f, -0.01579758f, -0.03495983f, 0.01260797f, 
    0.02312419f, 0.01668794f, 0.00663284f, 0.00110767f, -0.03268722f, -0.02500623f, 0.01307060f, -0.04381288f, 
    0.01504813f, -0.00948468f, -0.02912142f, 0.01356859f, 0.02497264f, -0.00836504f, -0.02943364f, 0.03204697f, 
    0.00986197f, 0.00652230f, -0.02186696f, 0.01095490f, 0.02528719f, 0.03265183f, -0.03748223f, -0.00096347f, 
    -0.02215288f, -0.02299283f, 0.00604593f, -0.03077395f, -0.04064593f, -0.01213309f, -0.00490384f, -0.02015755f, 
    -0.01136577f, -0.00668664f, -0.00662205f, -0.02043100f, 0.02299061f, 0.00863810f, 0.03339431f, -0.02831806f, 
    0.00122945f, -0.02829705f, 0.00684294f, 0.00123746f, 0.01918869f, -0.00348786f, -0.01214780f, -0.03218998f, 
    -0.02118896f, -0.00858613f, 0.01631912f, -0.01603736f, 0.00311207f, -0.02950670f, 0.01133979f, -0.04087821f, 
    -0.03704939f, -0.02189749f, 0.03150464f, -0.04703830f, -0.02058812f, 0.03225831f, 0.03295732f, -0.01241544f, 
    0.01530212f, 0.00375573f, -0.00433119f, -0.01113496f, 0.00540330f, -0.00469789f, -0.02953661f, -0.03942444f, 
    -0.03701162f, -0.01420912f, 0.01334638f, -0.00637870f, 0.00704534f, 0.02824515f, -0.03035447f, 0.02511858f, 
    -0.02787123f, 0.01290474f, -0.02660054f, -0.02181975f, -0.03579319f, 0.00191858f, 0.01975077f, 0.01254391f, 
    -0.02782304f, -0.01357304f, 0.02849054f, 0.02134205f, -0.03997135f, -0.02115256f, -0.02425103f, -0.00360803f, 
    -0.02142488f, 0.01484698f, -0.02020242f, 0.02807009f, -0.02982943f, 0.02827352f, -0.03516462f, 0.00143485f, 
    -0.03363291f, 0.01785693f, -0.01277538f, -0.02621390f, 0.00293645f, 0.01793951f, 0.02970808f, 0.01584540f, 
    -0.01806429f, 0.03224621f, -0.03265513f, 0.02174340f, 0.03248651f, -0.00918309f, 0.02650396f, -0.04132219f, 
    0.03114839f, 0.02838209f, -0.04119535f, 0.01833212f, 0.00042582f, 0.03008850f, -0.00864412f, 0.01267232f, 
    -0.03321153f, 0.03224013f, -0.00621131f, -0.00639577f, 0.00204094f, -0.02653662f, -0.02502793f, -0.00416567f, 
    -0.01458994f, -0.00636223f, -0.01331136f, -0.04178111f, -0.02109127f, -0.01063548f, -0.02772045f, -0.01925063f, 
    -0.00785173f, 0.03194241f, -0.00361337f, -0.01726854f, -0.02437333f, 0.02658542f, -0.03258111f, 0.01664579f, 
    0.00896252f, -0.01099811f, -0.01453082f, 0.00793639f, -0.04184489f, -0.00195003f, -0.02837965f, 0.00902610f, 
    -0.02086442f, -0.04452278f, -0.02718588f, -0.01312779f, 0.00566065f, -0.02103490f, 0.02562670f, -0.02843822f, 
    0.02866202f, -0.02075014f, -0.00512298f, 0.02281546f, -0.03717414f, -0.01187087f, 0.02812836f, -0.01594545f, 
    -0.01655325f, -0.02220995f, -0.01695720f, -0.03861202f, -0.03631649f, 0.00372886f, 0.01070114f, 0.01899019f, 
    0.00011928f, 0.00506254f, 0.00917023f, -0.02584012f, -0.01523777f, -0.03297651f, 0.01378148f, -0.04204446f, 
    -0.02781793f, -0.01483168f, -0.01024012f, -0.01127080f, -0.03648269f, -0.03709891f, -0.03343962f, -0.03238523f, 
    0.00804648f, -0.03873397f, -0.00492770f, 0.00484706f, -0.00419692f, -0.02629311f, -0.01981046f, 0.00807075f, 
    0.00870551f, -0.03752465f, 0.01044933f, -0.03094566f, 0.03056457f, 0.01048447f, 0.00093903f, 0.00240598f, 
    -0.04134270f, -0.03581817f, -0.02717754f, 0.01728215f, -0.04519675f, -0.03101185f, -0.00494543f, 0.00076439f, 
    -0.04063702f, -0.02374877f, 0.01139870f, -0.03980734f, 0.03316662f, 0.00505673f, -0.00777757f, -0.00191558f, 
    -0.00716644f, -0.03772617f, 0.02560200f, -0.03402878f, -0.01506489f, -0.01691806f, -0.01905756f, -0.03852189f, 
    -0.03935725f, -0.01952412f, -0.04191276f, -0.00005922f, -0.00771939f, -0.04419076f, 0.01597369f, -0.01768717f, 
    -0.01865403f, -0.04411641f, -0.03008449f, -0.03345358f, -0.00383041f, -0.00860073f, -0.03079971f, 0.00607231f, 
    -0.03741895f, -0.01633085f, -0.02672642f, -0.02113364f, 0.01170571f, -0.00053311f, 0.01714569f, 0.00685363f, 
    -0.03990466f, 0.00778097f, -0.02537747f, -0.03310012f, 0.03076661f, -0.01756280f, -0.04524141f, -0.01473366f, 
    0.00677689f, -0.04430752f, -0.01423588f, -0.03270539f, 0.00084612f, -0.01398957f, -0.00857826f, -0.02415201f, 
    -0.03030264f, -0.01077821f, -0.02096213f, -0.00186638f, -0.03219986f, -0.02073064f, -0.02025177f, 0.02969338f, 
    0.01335611f, -0.00056739f, 0.01374018f, 0.00899050f, 0.03157464f, 0.00686254f, -0.03662888f, 0.02638433f, 
    0.03050593f, -0.02808270f, -0.03404855f, -0.00701256f, -0.00072381f, -0.02353767f, -0.02617066f, 0.01291130f, 
    0.01996187f, -0.01316328f, -0.01303444f, 0.02627236f, 0.00250369f, 0.01295833f, 0.02739821f, -0.03920319f, 
    0.00145380f, 0.01828580f, -0.03163596f, -0.00336222f, -0.03107998f, 0.00003551f, 0.00147815f, -0.00471267f, 
    0.01665067f, -0.02811879f, 0.02021115f, 0.01641502f, 0.00694050f, 0.00471161f, -0.04191054f, 0.01100464f, 
    0.01760451f, -0.03232893f, 0.02140558f, 0.02765987f, -0.01649852f, -0.03210701f, -0.01854367f, 0.01922026f, 
    -0.01671204f, -0.00486702f, 0.01484953f, -0.04487625f, 0.00372817f, -0.03203882f, 0.01221088f, -0.02178185f, 
    -0.01191043f, -0.03599019f, 0.01250128f, 0.02331977f, -0.00215285f, -0.03976201f, 0.03263412f, 0.00189414f, 
    -0.00470020f, -0.02639992f, 0.01792593f, 0.01601473f, 0.01148832f, 0.00229773f, 0.01763002f, -0.03048837f, 
    -0.02664982f, -0.01308356f, -0.01582884f, 0.02021692f, 0.03151873f, -0.03103519f, -0.01389740f, 0.01908598f, 
    0.00669350f, -0.03802612f, -0.02647196f, -0.03515253f, -0.03313783f, -0.02315541f, -0.01689510f, 0.03000308f, 
    -0.02671521f, 0.03174727f, -0.04201487f, 0.00327900f, -0.01615746f, 0.00527549f, -0.04198384f, -0.04001081f, 
    -0.03582675f, -0.00243903f, -0.01117887f, 0.01484057f, -0.02506982f, 0.00462412f, 0.02195966f, 0.00555045f, 
    -0.03581660f, 0.01045433f, -0.03702533f, -0.00537870f, 0.01058180f, -0.01083484f, -0.04266559f, -0.02668807f, 
    -0.03401835f, -0.00638475f, -0.01655641f, 0.03321484f, 0.02576743f, 0.03350588f, -0.03570263f, 0.00611844f, 
    0.03246572f, -0.03714228f, -0.03279019f, -0.03453097f, 0.00955205f, -0.01994301f, -0.00309557f, -0.04278911f, 
    0.00014816f, -0.02745385f, 0.02378071f, -0.02194822f, -0.02041564f, -0.02135452f, 0.02068312f, -0.02332757f, 
    0.00412937f, -0.00125302f, 0.02300596f, -0.03180486f, -0.00869710f, 0.00826488f, -0.01968944f, 0.00821623f, 
    0.02965331f, -0.01528507f, 0.00141760f, -0.00199451f, -0.03602600f, -0.03373991f, -0.03343844f, 0.00385589f, 
    -0.02945475f, -0.00732562f, 0.00533736f, -0.04187479f, 0.01858181f, -0.01550655f, -0.02809511f, 0.01446861f, 
    -0.00250247f, -0.02664986f, 0.00766067f, -0.00867730f, -0.01803694f, -0.02817374f, 0.02415822f, 0.00329474f, 
    0.02087997f, 0.03137990f, 0.02026685f, 0.00050119f, -0.01654594f, -0.02926640f, -0.01531629f, 0.02385072f, 
    -0.00801510f, 0.01030051f, -0.01964366f, -0.03242109f, 0.03462918f, 0.00554978f, -0.04235377f, -0.02792093f, 
    -0.02200752f, 0.02126989f, -0.03696717f, -0.02973651f, -0.03802532f, -0.00690442f, -0.03561569f, 0.03091297f, 
    0.01584270f, -0.01962329f, 0.01150041f, -0.01503728f, -0.00349952f, 0.00433388f, -0.00943567f, 0.01254629f, 
    -0.01678208f, 0.00659435f, -0.02313394f, 0.01478875f, -0.01270488f, 0.03308128f, -0.02441662f, -0.04550085f, 
    -0.01181595f, 0.01084365f, -0.01514772f, -0.00023742f, -0.00581880f, 0.01800817f, -0.01515365f, 0.01963847f, 
    0.00450036f, -0.01513995f, 0.01338699f, 0.00850746f, 0.03100437f, 0.02499385f, -0.02298689f, 0.00812559f, 
    0.03226768f, -0.00844502f, 0.02592804f, -0.01033494f, 0.00760655f, 0.00308484f, 0.01655122f, -0.00875562f, 
    0.00291934f, -0.04119220f, -0.03054771f, -0.01918938f, -0.02531523f, 0.01741611f, -0.00983781f, -0.02733234f, 
    -0.03465674f, -0.02546807f, -0.01496177f, 0.03063839f, 0.02325962f, 0.01724348f, 0.01059351f, 0.03489675f, 
    0.00458212f, -0.03034325f, 0.00574706f, 0.00123502f, -0.03094393f, 0.02419848f, -0.04202136f, 0.02439963f, 
    -0.00748793f, 0.02539260f, -0.01228231f, 0.00908124f, 0.02300016f, -0.01921654f, 0.02746452f, -0.01524409f, 
    0.01799330f, 0.00489682f, -0.01245916f, 0.02467901f, 0.01160098f, 0.02482897f, -0.02471949f, 0.02774037f, 
    -0.04249304f, -0.04381223f, 0.00484418f, 0.01843726f, 0.01433779f, 0.01281881f, 0.01637107f, -0.01266002f, 
    -0.01503796f, -0.01778486f, 0.00637631f, 0.02299065f, -0.03057251f, -0.03244119f, -0.01916824f, 0.01651568f, 
    -0.00878838f, -0.04175032f, -0.04087536f, -0.01215037f, -0.00862727f, 0.02021022f, -0.04121450f, -0.01974230f, 
    -0.01956488f, 0.03129994f, -0.01915457f, -0.01089379f, -0.00107358f, -0.02053616f, 0.01100634f, -0.00546407f, 
    -0.03315973f, 0.02482786f, 0.02345908f, 0.01138699f, -0.01698623f, -0.01756581f, -0.00798342f, -0.01984182f, 
    -0.03244025f, -0.04188863f, -0.01929175f, -0.00731696f, -0.02784960f, -0.04300755f, -0.02253203f, -0.01985920f, 
    -0.03854692f, -0.02187835f, -0.01842426f, -0.02988861f, -0.01776797f, 0.01801624f, 0.00887018f, 0.02780094f, 
    0.00040354f, -0.00605408f, 0.02955100f, -0.04155150f, 0.00233782f, 0.02894535f, -0.00895784f, -0.03385512f, 
    -0.02886672f, -0.00530610f, -0.03089685f, 0.00172810f, 0.02386864f, 0.02515469f, -0.03152953f, 0.01751265f, 
    -0.02901784f, 0.02101972f, 0.03107573f, -0.03883891f, 0.00994772f, -0.03874591f, 0.02755300f, 0.02554753f, 
    0.00063564f, -0.03161619f, -0.02479221f, -0.00677703f, 0.02995277f, -0.00795595f, -0.01247009f, -0.02579994f, 
    -0.02994036f, -0.02479379f, 0.00207840f, 0.02913788f, 0.01564621f, 0.01395872f, 0.02968255f, 0.00297427f, 
    -0.02462888f, -0.00824706f, 0.01006733f, -0.02614637f, 0.02252032f, 0.00396809f, 0.02372802f, -0.02779733f, 
    -0.03017367f, 0.00973681f, 0.01266634f, -0.02455095f, -0.03422812f, 0.01269340f, 0.02257158f, -0.02479086f, 
    0.01608674f, 0.00295980f, -0.01734165f, -0.01158667f, -0.02275671f, -0.02835260f, 0.01262855f, 0.01482107f, 
    0.01606842f, 0.03240547f, 0.00657863f, 0.00315916f, -0.00239896f, -0.00521325f, -0.03101195f, -0.03973673f, 
    -0.03209145f, -0.03781314f, 0.02796172f, -0.03061183f, -0.03992236f, -0.04551304f, 0.02859466f, -0.01891443f, 
    -0.02932772f, 0.00420489f, 0.02074621f, -0.02718555f, -0.02013819f, -0.01199265f, -0.01564731f, -0.03530893f, 
    -0.01534874f, -0.01553010f, 0.01226230f, 0.00646409f, -0.01347529f, -0.01749861f, -0.00404850f, 0.00491332f, 
    0.02986945f, -0.02416967f, 0.03198537f, -0.04104439f, 0.03130449f, -0.01377987f, -0.03355379f, 0.02946063f, 
    -0.01054785f, -0.01516404f, 0.01605368f, -0.03717579f, -0.03042946f, -0.01631347f, 0.02313112f, -0.01408848f, 
    -0.01794305f, -0.02388030f, -0.04461054f, -0.02044647f, 0.02631500f, 0.00862875f, 0.01156101f, -0.03835601f, 
    0.02332816f, -0.01372074f, -0.00201094f, -0.01693152f, 0.01822155f, -0.03505769f, 0.00151260f, -0.02785761f, 
    0.01753578f, 0.01171309f, 0.03257328f, -0.03204571f, -0.01409545f, -0.02037707f, -0.02709514f, 0.03001141f, 
    -0.00003098f, 0.03158277f, -0.03697594f, 0.00012625f, 0.00866290f, -0.00044089f, -0.04032318f, 0.01457095f, 
    0.00855817f, -0.00685460f, -0.03058743f, 0.01015662f, -0.02071048f, 0.01230639f, -0.00857693f, 0.01637542f, 
    -0.00086175f, -0.00069112f, 0.00467574f, 0.02260349f, -0.01404709f, -0.01247764f, 0.02942556f, -0.04177417f, 
    -0.00699058f, 0.00800852f, -0.01327320f, -0.03334942f, -0.00374111f, 0.02215604f, -0.00246560f, -0.02645826f, 
    0.02901614f, 0.14963725f, 0.16089657f, 0.15832885f, 0.07852348f, 0.06897062f, 0.05671935f, -0.01386848f, 
    0.06914376f, -0.06983273f, 0.08959825f, 0.06509999f, 0.06526472f, -0.00182535f, 0.00852244f, -0.13787930f, 
    0.05975613f, -0.03756251f, 0.00397138f, -0.09511753f, 0.38489729f, 0.18738854f, 0.09462260f, 0.13793279f, 
    -0.06957638f, -0.01750228f, -0.06255545f, 0.15806913f, 0.07018737f, 0.02936517f, 0.02633062f, 0.00873416f, 
    -0.02879017f, 0.07926366f, 0.01268931f, 0.12245092f, -0.03983261f, 0.05207765f, -0.02418817f, -0.01645179f, 
    -0.22177589f, -0.08111007f, -0.07562129f, 0.00059241f, 0.01513671f, -0.10111813f, -0.05122627f, -0.03240561f, 
    0.15325236f, -0.10589870f, -0.04989313f, 0.03259493f, -0.05766357f, -0.06690910f, -0.07388826f, -0.07240106f, 
    0.05410779f, 0.00958766f, 0.18292627f, -0.09011211f, 0.36239943f, -0.08594172f, 0.11175298f, -0.11135674f, 
    -0.17019883f, 0.05943469f, -0.14500442f, 0.09979206f, -0.08273050f, -0.13155577f, 0.05774940f, -0.01280028f, 
    0.04058912f, -0.04292776f, -0.19507813f, 0.07164296f, -0.01330495f, 0.03918784f, -0.02740390f, -0.09380763f, 
    0.33922705f, -0.07826906f, 0.02262548f, 0.15677141f, 0.02144857f, 0.01576082f, -0.11164902f, -0.00571033f, 
    -0.03357746f, -0.10457699f, 0.05717506f, -0.04012541f, -0.09095483f, -0.05483888f, 0.04439368f, -0.06179301f, 
    0.15239505f, -0.03662172f, -0.00495673f, -0.01358160f, 0.13570267f, -0.04475765f, -0.30330893f, 0.02135186f, 
    0.23013212f, 0.11988138f, 0.07696907f, 0.03051113f, 0.03319245f, 0.12455496f, -0.00395189f, 0.27499875f, 
    0.06743592f, 0.09579781f, 0.02659935f, 0.00144908f, -0.00106093f, -0.07010078f, -0.03142070f, -0.09156088f, 
    0.30508146f, -0.04095925f, 0.00527517f, -0.04369206f, 0.13402182f, 0.08687534f, -0.07574493f, -0.04327372f, 
    -0.00590228f, -0.02549687f, 0.11326456f, -0.02641720f, 0.07296944f, 0.11131853f, 0.03632847f, 0.07963169f, 
    -0.04028194f, -0.06457625f, -0.07065557f, -0.02659752f, -0.18423031f, 0.27503371f, -0.18305975f, 0.11130496f, 
    0.14232862f, -0.04424397f, -0.01686317f, -0.03662936f, 0.00007030f, 0.12451179f, 0.09185968f, 0.02054656f, 
    -0.02192664f, 0.07493269f, 0.12697710f, -0.08486204f, -0.01449276f, -0.13316335f, 0.08823840f, -0.01518715f, 
    0.41964018f, 0.21107085f, -0.14564885f, -0.06607641f, 0.07603435f, -0.06255971f, 0.10818411f, 0.03560402f, 
    0.02551408f, 0.09122407f, -0.12007244f, 0.03731044f, -0.04890243f, -0.07676864f, -0.00817991f, 0.11067037f, 
    -0.03429923f, -0.01420415f, 0.01213154f, -0.08049411f, -0.17431970f, -0.43853545f, -0.14107376f, -0.12335125f, 
    -0.11138804f, -0.00625798f, -0.10295738f, -0.02015713f, -0.13945930f, -0.07433154f, 0.03034096f, -0.01244519f, 
    0.00350857f, 0.02420632f, -0.02263924f, -0.02485827f, -0.02916016f, 0.01927652f, 0.09383317f, 0.02112691f, 
    0.12405929f, -0.34928161f, -0.01924040f, -0.23084247f, 0.24039850f, 0.01864304f, -0.05480936f, -0.01954908f, 
    -0.10415383f, 0.01882854f, 0.05591611f, -0.07876863f, 0.01993513f, 0.08874346f, -0.06759096f, 0.00045134f, 
    -0.07179967f, -0.05771009f, 0.01616475f, -0.00202173f, 0.08732700f, -0.13330719f, 0.12710138f, 0.09373023f, 
    0.22218557f, 0.04401075f, 0.06734598f, 0.01313486f, -0.00980040f, 0.10650381f, 0.09240381f, -0.03597128f, 
    0.01900598f, 0.11358373f, 0.03048255f, 0.00288687f, 0.09995607f, -0.10452250f, -0.04900869f, 0.01703194f, 
    0.00066625f, 0.20805003f, -0.30439240f, -0.14576590f, -0.22812867f, -0.10074127f, -0.04878865f, 0.05913867f, 
    -0.16871953f, -0.07380237f, -0.14196388f, 0.05839914f, 0.01978077f, 0.08069137f, 0.02750626f, 0.01372517f, 
    0.00786558f, 0.16475089f, -0.09000648f, 0.09764461f, 0.26652247f, 0.09644692f, 0.11816353f, -0.06488668f, 
    0.01332248f, 0.06978112f, -0.01512585f, 0.06818663f, 0.01748748f, -0.00049445f, 0.04914418f, 0.01020907f, 
    -0.06551855f, 0.06136174f, -0.04472273f, 0.00014030f, -0.01187412f, -0.07947441f, -0.00982839f, -0.08883820f, 
    0.13033439f, 0.31010121f, 0.17085806f, -0.14692755f, 0.22127369f, 0.03158764f, -0.01962860f, -0.00204014f, 
    0.03673679f, 0.03692937f, -0.03188855f, -0.03355299f, -0.01464025f, 0.06966187f, 0.01198280f, 0.00038586f, 
    0.05122998f, -0.11101591f, 0.02816538f, 0.06281146f, 0.32548267f, 0.02847597f, 0.41274202f, 0.14982767f, 
    0.27265576f, 0.08259343f, 0.01436869f, -0.13921320f, 0.09705483f, 0.25131562f, -0.02719222f, -0.08334289f, 
    0.04687153f, 0.00320545f, 0.01806353f, 0.10289323f, 0.06717283f, -0.04702654f, 0.08519524f, -0.05302257f, 
    0.16629653f, 0.27190220f, 0.23831472f, -0.09399222f, 0.16958298f, -0.03989178f, 0.03821740f, 0.05251062f, 
    0.01225594f, 0.02777023f, 0.04326032f, -0.02648122f, -0.00550316f, -0.02395792f, -0.04606610f, -0.00690895f, 
    0.06694954f, -0.08502422f, -0.05173746f, 0.14152890f, 0.54373938f, -0.05267278f, -0.13051081f, -0.05106871f, 
    -0.00790056f, 0.07796483f, 0.12450549f, 0.01421506f, 0.04608405f, 0.05888576f, -0.12771256f, -0.03746814f, 
    -0.04413427f, -0.09377964f, 0.05104616f, 0.05399977f, -0.07361470f, -0.06651822f, 0.07443435f, 0.06888653f, 
    0.16185890f, -0.06707256f, -0.14929773f, -0.27366900f, 0.19124411f, -0.01219196f, 0.09031849f, -0.06493460f, 
    -0.04793177f, 0.12665036f, 0.03029277f, -0.10434904f, -0.09369692f, -0.02477408f, -0.02668592f, 0.08864978f, 
    -0.03212706f, 0.03082796f, -0.07384308f, -0.01831224f, 0.40274969f, 0.13571870f, -0.01588005f, -0.27427202f, 
    -0.46967366f, 0.14516196f, -0.12664585f, -0.05097306f, 0.07248278f, -0.10544658f, -0.10520387f, 0.05066127f, 
    -0.00439448f, -0.05150855f, 0.04936184f, -0.03269877f, -0.03880810f, 0.10348357f, -0.11889147f, -0.08874427f, 
    -0.22489552f, -0.05578967f, 0.13887306f, 0.25693679f, 0.24317817f, 0.28827146f, 0.10755818f, 0.12915577f, 
    0.13607383f, 0.16911717f, 0.00721470f, 0.05617026f, -0.03015376f, -0.07817575f, -0.16263495f, 0.08242659f, 
    0.07827802f, 0.01526724f, 0.11716561f, 0.05027116f, 0.09374203f, -0.27271980f, 0.14425524f, -0.05838823f, 
    -0.18274167f, 0.02909768f, -0.07712606f, -0.09443862f, 0.00512544f, -0.03331035f, -0.07537041f, -0.01567697f, 
    -0.09669334f, 0.04971332f, 0.04822168f, 0.02270483f, -0.06029409f, 0.09892648f, -0.05393014f, 0.02459924f, 
    0.06710348f, 0.34679297f, 0.19915524f, 0.05865733f, -0.04633490f, -0.02711344f, -0.00886483f, -0.05819905f, 
    -0.06796480f, -0.06555216f, -0.05012567f, 0.12769642f, 0.08121435f, -0.01258409f, -0.05413746f, -0.07181656f, 
    0.06489756f, -0.08851369f, 0.07008971f, -0.09485929f, -0.33596867f, 0.09207703f, 0.07490399f, -0.07580849f, 
    0.19558282f, 0.09209601f, 0.07963360f, -0.03270648f, -0.02653165f, 0.13535599f, -0.11147657f, 0.17694396f, 
    0.11528526f, -0.06235225f, 0.03663269f, 0.10758669f, -0.00033074f, -0.01999105f, 0.12414358f, -0.06782469f, 
    -0.21579787f, -0.16104366f, -0.02509578f, 0.01210641f, -0.08930285f, -0.07483747f, 0.01015797f, -0.04240992f, 
    -0.05622651f, -0.06084131f, 0.00775890f, 0.06036989f, 0.07540937f, -0.05737818f, -0.03960035f, -0.11029841f, 
    -0.12542239f, 0.09249020f, 0.02068329f, 0.13081478f, -0.20135993f, -0.34211111f, -0.02418716f, -0.04005772f, 
    -0.19302651f, -0.05100121f, -0.08032517f, -0.03104326f, -0.10850582f, -0.07672392f, 0.11502784f, 0.13060486f, 
    0.10257433f, -0.02930225f, 0.01178356f, -0.15741111f, -0.13647118f, 0.01910086f, 0.03794574f, 0.02079605f, 
    -0.22861883f, -0.10060531f, -0.04378626f, -0.23471946f, 0.21380620f, 0.09336517f, -0.07402141f, -0.03522514f, 
    -0.00803344f, 0.03280884f, 0.11567391f, -0.02154621f, 0.03819006f, 0.00546150f, -0.06081485f, 0.03479209f, 
    0.09012992f, 0.09648309f, 0.01858272f, -0.05432476f, -0.06825275f, -0.04103208f, 0.09672955f, -0.07476839f, 
    -0.18287975f, 0.04207015f, -0.01240793f, -0.00000903f, -0.05903970f, 0.03651618f, 0.02124193f, 0.02057859f, 
    0.01566252f, 0.03213075f, -0.13298923f, 0.02206800f, -0.01062377f, -0.08760168f, -0.15824223f, -0.03419317f, 
    -0.06356587f, -0.19307862f, 0.24563494f, 0.11479459f, 0.21422948f, 0.15432736f, 0.13040330f, -0.11318908f, 
    0.06963972f, 0.19147515f, -0.02593407f, 0.07766864f, -0.00798347f, 0.11412028f, -0.05418474f, 0.00336655f, 
    -0.00009805f, 0.08464707f, -0.02998176f, -0.04679369f, 0.42003849f, 0.10273279f, 0.17582381f, 0.18390413f, 
    0.17770286f, 0.09602403f, 0.06921624f, 0.02123514f, 0.10716467f, 0.09055832f, 0.10317270f, 0.04367345f, 
    0.07499241f, -0.04113054f, -0.12278739f, 0.11019122f, -0.07993425f, -0.04305077f, 0.18691036f, -0.05147985f, 
    0.41317275f, 0.14191331f, 0.03990139f, -0.13541727f, -0.00626332f, 0.04679241f, 0.10585858f, 0.11773720f, 
    0.00339613f, 0.00162911f, -0.00812462f, -0.08641576f, 0.07605302f, 0.07768348f, -0.10839633f, 0.05918429f, 
    0.03788595f, 0.00519650f, -0.13312081f, -0.03165725f, 0.10793476f, -0.13778281f, 0.00298443f, -0.11060371f, 
    -0.01192519f, -0.21872996f, 0.00730730f, -0.12416089f, -0.06182016f, 0.29591775f, -0.06834592f, -0.08638067f, 
    0.01352744f, 0.05231037f, -0.06008216f, -0.05575873f, 0.04759794f, 0.02009390f, -0.11332816f, 0.02092821f, 
    0.52148390f, 0.03554993f, 0.10922169f, -0.01488204f, 0.37752348f, -0.10972923f, 0.05049561f, -0.02677753f, 
    -0.01464585f, -0.02815478f, 0.03292935f, 0.12993193f, 0.00285686f, 0.13486941f, 0.00240888f, 0.06974002f, 
    0.13024756f, 0.09313605f, -0.01757357f, 0.09920908f, 0.30161223f, 0.32582718f, 0.13280053f, 0.04762791f, 
    0.53662235f, -0.23302543f, 0.03182560f, -0.06642243f, -0.02044193f, 0.02009890f, 0.16726920f, 0.14348854f, 
    0.14636019f, 0.00824274f, -0.01744108f, 0.00431915f, 0.04834608f, 0.02424520f, 0.08415765f, 0.04414046f, 
    -0.05841753f, -0.32172403f, 0.13900290f, 0.17494947f, 0.12109407f, -0.03329153f, 0.02775248f, 0.04581805f, 
    0.00595122f, 0.02716690f, -0.13000953f, 0.04364343f, -0.08737274f, 0.02457161f, 0.09536270f, -0.03397604f, 
    -0.05298971f, -0.06170493f, 0.05070873f, -0.14986207f, 0.16882309f, 0.08423606f, 0.09302308f, -0.07893654f, 
    0.61127150f, -0.08778001f, 0.05586688f, -0.03763255f, -0.12870489f, -0.02880473f, -0.02822820f, -0.04969944f, 
    -0.09735714f, 0.11825832f, -0.07716049f, -0.02172492f, -0.05707246f, 0.02695730f, 0.05865926f, -0.09590501f, 
    0.32419470f, 0.16621855f, 0.09424184f, 0.35343480f, 0.13703714f, -0.10430969f, -0.10967164f, -0.11460624f, 
    0.04449161f, 0.01675990f, 0.01137018f, -0.08452339f, -0.01722872f, -0.01439153f, 0.05283283f, -0.16847394f, 
    0.07210308f, -0.06980458f, 0.04751376f, 0.02139971f, 0.09707190f, 0.43045232f, 0.12584995f, -0.01919698f, 
    0.00022440f, 0.07746039f, 0.05109104f, 0.04102380f, 0.02278677f, -0.04181389f, 0.12979145f, -0.02412067f, 
    -0.07061924f, -0.07489096f, -0.02841024f, 0.15569527f, -0.00154388f, 0.10815919f, 0.12581877f, 0.08051530f, 
    0.37888297f, 0.35895595f, 0.23572168f, -0.01650108f, -0.07683197f, 0.02067361f, 0.08224004f, -0.01385869f, 
    -0.07822742f, 0.01922733f, 0.13635737f, -0.01505681f, 0.01697345f, 0.01439832f, -0.08875575f, 0.05510406f, 
    0.09191936f, -0.03219403f, 0.04584371f, 0.00859695f, -0.05355376f, 0.38543147f, -0.04749326f, -0.07754500f, 
    -0.35263947f, 0.14849916f, 0.21971086f, -0.02880247f, -0.00566943f, 0.09431201f, 0.07667195f, 0.00137535f, 
    -0.18591385f, 0.08321184f, 0.06920607f, 0.10502325f, 0.17004737f, -0.04244731f, 0.13384891f, 0.10479006f, 
    -0.04613256f, 0.18768932f, -0.01800152f, -0.05674466f, 0.02359432f, 0.02160749f, -0.00088525f, 0.05113506f, 
    -0.03290475f, -0.05396336f, -0.00973564f, -0.01837570f, 0.06062154f, -0.04464936f, 0.01098233f, 0.05348244f, 
    -0.07210764f, 0.10394768f, 0.01863653f, 0.07243023f, 0.00838054f, -0.30384237f, 0.29900524f, 0.46511966f, 
    -0.43940958f, -0.02556277f, 0.09445628f, -0.03662338f, 0.06183344f, 0.04724541f, 0.02305744f, 0.00329809f, 
    -0.01816287f, 0.00543066f, 0.07428033f, 0.02175794f, -0.06727140f, -0.06650349f, 0.00860791f, 0.03596048f, 
    -0.20431086f, -0.17636611f, 0.11674437f, 0.00017229f, -0.49009460f, -0.17900254f, -0.09198573f, 0.04603786f, 
    0.04997791f, 0.02866966f, 0.14349554f, 0.05660670f, -0.04431802f, -0.14497791f, 0.01515949f, -0.16397056f, 
    -0.10068601f, -0.08423400f, -0.00348148f, 0.08468565f, 0.18189864f, 0.31963503f, 0.00157112f, 0.10724684f, 
    -0.31636426f, 0.11676050f, 0.15163773f, 0.02813231f, -0.04183503f, 0.09836107f, 0.19200133f, 0.00959407f, 
    0.02996164f, -0.04827784f, -0.05908337f, 0.07936367f, 0.20490170f, -0.05147620f, 0.04340327f, 0.06570415f, 
    0.04410083f, -0.47297940f, 0.33726093f, 0.41342750f, -0.18704246f, -0.01534943f, 0.00587881f, 0.06053813f, 
    0.06539771f, 0.02430368f, -0.12559175f, -0.00265776f, 0.12145358f, 0.12924032f, 0.02295136f, 0.00103920f, 
    -0.20454335f, 0.04542781f, 0.03857024f, -0.10325760f, 0.25824392f, 0.19717965f, 0.07619591f, 0.07040317f, 
    0.14816017f, -0.18572041f, -0.14464094f, -0.10056360f, 0.02917464f, 0.06310602f, 0.00213211f, 0.00920122f, 
    -0.04890716f, -0.03642040f, 0.03236020f, -0.02484289f, 0.08699472f, 0.03971356f, -0.04058227f, 0.08064502f, 
    -0.23293272f, 0.30728227f, 0.32906407f, -0.09175304f, 0.41091809f, -0.06811517f, 0.04071485f, 0.02079164f, 
    0.05331399f, 0.00397511f, 0.00517148f, 0.08454734f, -0.01772780f, 0.02110192f, 0.04136879f, -0.04178486f, 
    0.11961114f, -0.00092632f, 0.02577048f, 0.03901090f, -0.22743055f, -0.03818461f, -0.26859328f, 0.05803936f, 
    -0.24188565f, 0.19656841f, 0.11229086f, -0.07106435f, 0.23543684f, 0.25086933f, 0.00447297f, 0.00078026f, 
    0.09357689f, 0.08921970f, 0.06199639f, -0.05217301f, -0.00762821f, 0.07683076f, -0.10326245f, -0.00724749f, 
    -0.20159727f, 0.18682124f, 0.27592796f, 0.06122143f, 0.34235361f, -0.19542862f, -0.10275382f, 0.04724410f, 
    -0.02023208f, 0.04917163f, -0.04344101f, 0.03561335f, 0.06445704f, -0.04750320f, 0.04441064f, 0.00777913f, 
    -0.02329366f, 0.03996135f, -0.02067895f, 0.15032734f, -0.28516799f, 0.10584155f, -0.22343093f, -0.03857750f, 
    -0.20328577f, 0.02482338f, -0.01614840f, -0.05127821f, 0.00791277f, 0.00284747f, -0.05845113f, -0.08281776f, 
    0.05060847f, 0.02839627f, -0.06463677f, 0.04682060f, -0.10653687f, -0.05631893f, -0.07771413f, 0.04080346f, 
    -0.58771610f, 0.03888686f, 0.17780066f, -0.25167662f, -0.22902143f, -0.13784516f, -0.12205444f, 0.05943998f, 
    0.04394368f, 0.02120305f, -0.11696328f, 0.09902643f, 0.12307031f, 0.03747588f, 0.00844163f, 0.01504079f, 
    -0.00343753f, 0.03903649f, -0.05273822f, -0.04256825f, 0.52153766f, -0.26998922f, 0.33517629f, -0.38174206f, 
    0.25485557f, -0.17433269f, -0.19323194f, -0.07090988f, -0.01840604f, 0.00092331f, -0.07070218f, -0.02799732f, 
    0.00859312f, 0.04300885f, 0.15677866f, -0.08855081f, -0.11703805f, -0.12768832f, 0.04155045f, -0.11799362f, 
    -0.00655518f, 0.14087343f, -0.23606032f, -0.21301652f, -0.15682268f, 0.24847959f, 0.15035510f, -0.04837130f, 
    0.02562068f, 0.15158179f, 0.16377391f, -0.08410633f, -0.02806501f, -0.11277144f, 0.06988545f, 0.18660067f, 
    0.10388845f, -0.03796320f, 0.04102831f, 0.04101897f, 0.26244086f, -0.21160574f, -0.06886955f, -0.09643395f, 
    -0.08933150f, -0.02003777f, -0.06130524f, -0.01753322f, 0.11841919f, -0.09860048f, 0.02595832f, 0.02503160f, 
    0.13056400f, 0.02718846f, 0.04806564f, 0.02484829f, 0.00069304f, -0.08452232f, 0.00065792f, 0.05220069f, 
    0.27446255f, 0.09096122f, 0.11959446f, -0.16802369f, 0.19515482f, -0.15292060f, -0.00666549f, 0.08434200f, 
    -0.07500925f, 0.00015006f, 0.05303081f, -0.00693589f, 0.01185274f, 0.11176754f, 0.02079498f, 0.09167861f, 
    0.03968413f, 0.02193206f, -0.01529001f, 0.03208902f, -0.25222513f, -0.11573483f, -0.06154671f, -0.18565308f, 
    -0.17647949f, 0.10243030f, 0.02188183f, -0.00110733f, 0.08789377f, -0.13257465f, 0.11328339f, 0.00080339f, 
    -0.10588681f, -0.04585897f, 0.08861038f, 0.03082020f, 0.10767779f, -0.04797143f, 0.08739698f, -0.02227977f, 
    -0.22466291f, -0.30139691f, 0.04992554f, 0.14480890f, -0.04454719f, -0.04023720f, -0.07694281f, 0.01226548f, 
    0.02312760f, 0.04060002f, 0.00820393f, 0.11253566f, 0.01537395f, 0.03478371f, 0.07588290f, 0.08930121f, 
    0.06951293f, -0.09220545f, -0.04776884f, 0.00355767f, -0.30156216f, -0.22502732f, 0.14519075f, 0.21767034f, 
    -0.13096666f, 0.00520917f, -0.01641068f, -0.02045518f, 0.00329030f, -0.00199615f, -0.01169378f, 0.00202507f, 
    0.15579313f, 0.04394634f, 0.12902299f, 0.09267326f, 0.05540726f, -0.10277557f, -0.02668507f, -0.04908850f, 
    0.21229322f, -0.10855659f, -0.03084392f, -0.23103233f, 0.00199438f, 0.18091132f, 0.00963153f, 0.07358206f, 
    0.00179504f, 0.11134893f, 0.08366438f, 0.13300513f, -0.03420727f, -0.02283052f, 0.06988662f, -0.17856400f, 
    -0.00611474f, 0.03935781f, -0.08673801f, -0.13538693f, -0.36414519f, 0.29266790f, -0.21132264f, 0.06085593f, 
    0.25616434f, -0.13861831f, -0.06077012f, -0.04869688f, -0.09232187f, 0.01686387f, -0.03646539f, -0.11323117f, 
    0.03228835f, 0.07256584f, 0.10877068f, 0.01756808f, 0.02315659f, 0.02238683f, -0.13966343f, -0.00805218f, 
    -0.16817771f, 0.21964055f, -0.23916002f, 0.05853960f, -0.39068073f, 0.11099614f, 0.03357257f, -0.01080539f, 
    0.04645013f, 0.06981625f, 0.08082636f, 0.05704759f, -0.00883033f, 0.01580377f, 0.10932451f, 0.08801682f, 
    0.07574334f, 0.07852829f, -0.02370003f, -0.02003658f, -0.00708919f, -0.18978149f, -0.26942152f, 0.17717998f, 
    -0.08217926f, 0.14142229f, 0.07474134f, 0.02442102f, 0.23677242f, 0.12673014f, -0.08897651f, -0.01772271f, 
    -0.00180738f, 0.04014279f, 0.02659705f, 0.01718861f, -0.08214362f, 0.10073252f, -0.11289556f, 0.00633039f, 
    -0.05241627f, 0.35355851f, -0.03805793f, 0.06913394f, 0.38693213f, -0.08036944f, 0.00951679f, 0.04306396f, 
    -0.01604158f, 0.02025059f, -0.01584950f, -0.02595648f, 0.05893160f, -0.04448143f, 0.08085691f, 0.06635108f, 
    -0.00676508f, 0.04589631f, -0.09016889f, 0.01246977f, -0.31721544f, 0.14995864f, -0.24390076f, -0.02321099f, 
    -0.10499848f, -0.04945768f, 0.06033694f, -0.15067954f, -0.05605947f, -0.01113967f, 0.17163894f, 0.05688997f, 
    -0.04051301f, 0.00848728f, 0.00484063f, -0.08003025f, -0.11639114f, 0.05088567f, 0.04924444f, 0.06216437f, 
    -0.01742955f, 0.03193854f, 0.00451841f, 0.01604169f, -0.01134853f, -0.00193911f, -0.02538438f, 0.02228035f, 
    -0.01134519f, -0.01526052f, -0.03952013f, 0.02023851f, 0.00047677f, -0.03585120f, -0.03341573f, -0.03919111f, 
    0.03140525f, -0.01697532f, -0.02324813f, 0.02945740f, -0.03110335f, -0.03199746f, 0.02925693f, -0.02796375f, 
    -0.03437465f, -0.00243803f, -0.01240278f, -0.00914475f, 0.00424798f, -0.04465456f, -0.03474445f, 0.00942271f, 
    -0.04337521f, -0.00490040f, -0.00828936f, 0.00194988f, -0.02070501f, 0.02625836f, 0.02050078f, 0.02444632f, 
    0.01355733f, 0.01109993f, 0.00466991f, -0.01257039f, -0.01450747f, -0.04290945f, -0.02789827f, -0.01682937f, 
    -0.02566456f, -0.01353323f, 0.01211558f, -0.02595215f, -0.02289583f, 0.00410051f, -0.00788725f, -0.02625861f, 
    -0.00838425f, -0.01316698f, -0.00461514f, 0.01778888f, -0.04514587f, -0.03939195f, -0.03557035f, -0.04197546f, 
    0.01720215f, -0.00114589f, -0.00683020f, -0.02933414f, -0.01548857f, -0.01679661f, 0.03251927f, 0.01436189f, 
    -0.01136374f, 0.01430139f, -0.00206476f, -0.02317469f, 0.02162163f, -0.02500325f, -0.01039439f, 0.01640313f, 
    -0.01591116f, -0.01583249f, -0.00423517f, -0.02803783f, -0.01815033f, -0.01211069f, -0.00135161f, 0.02141008f, 
    -0.01574357f, 0.02784368f, -0.03392614f, -0.00648846f, -0.01277244f, -0.03119945f, 0.02508864f, -0.01838065f, 
    -0.01680415f, 0.02935627f, 0.00898201f, 0.00787092f, -0.04042260f, 0.00536690f, -0.00348649f, 0.03017046f, 
    -0.00097008f, -0.02575319f, -0.02326651f, 0.00837613f, -0.03741826f, 0.00427997f, -0.04070000f, -0.02512428f, 
    -0.03771804f, 0.03009166f, -0.00974290f, 0.01020441f, 0.01684427f, 0.00294791f, 0.01682092f, -0.01668734f, 
    0.02572627f, -0.00978718f, 0.00569551f, 0.00785047f, 0.00272800f, -0.02382215f, -0.01223129f, 0.00262610f, 
    0.02671479f, 0.01898859f, -0.01392781f, -0.01793591f, 0.02977501f, 0.00570106f, 0.02561957f, 0.03140149f, 
    0.01656420f, 0.01201577f, 0.02457809f, -0.03641635f, -0.02426745f, 0.03289982f, 0.01940875f, -0.04351810f, 
    -0.04454289f, -0.01524733f, 0.02281042f, -0.03105062f, -0.02112051f, 0.00173873f, -0.02429089f, 0.01949420f, 
    -0.03527647f, -0.02551190f, 0.01327606f, -0.02792855f, -0.00425293f, -0.01118717f, 0.01758915f, -0.02326190f, 
    -0.00732327f, 0.01156538f, -0.01959783f, -0.00623433f, -0.03363629f, -0.03219388f, -0.01956921f, 0.01699804f, 
    -0.00635225f, -0.03109513f, 0.00123439f, 0.02714286f, -0.03181183f, 0.00310471f, -0.02245593f, 0.02497229f, 
    0.02175614f, 0.02565507f, -0.03280178f, -0.01910588f, -0.02658127f, 0.01326271f, -0.04298135f, -0.02267312f, 
    -0.01713323f, 0.01963157f, -0.03113333f, 0.00722263f, 0.00128074f, 0.00649694f, -0.04528482f, -0.03367011f, 
    -0.01152382f, -0.04009391f, 0.00053662f, -0.03496055f, -0.04328376f, -0.03382677f, -0.00936263f, 0.02494876f, 
    -0.00288001f, -0.03061414f, -0.02704112f, 0.01540048f, -0.01167355f, -0.01110099f, 0.02750380f, 0.02231229f, 
    -0.02117153f, -0.02473548f, -0.02665863f, -0.01504256f, -0.00554032f, 0.00928117f, 0.02940519f, -0.03032211f, 
    -0.01199757f, -0.00695105f, -0.01896821f, -0.01445855f, -0.03180435f, -0.03639781f, -0.02708321f, -0.00551968f, 
    -0.02410821f, -0.03645255f, 0.01312169f, 0.00523390f, 0.00616330f, -0.00734048f, -0.02382686f, 0.01491852f, 
    0.03231676f, -0.00472121f, -0.03002613f, -0.03388221f, 0.02167637f, -0.00006114f, 0.01605624f, -0.01256430f, 
    0.00973569f, -0.03864859f, -0.01734097f, 0.01039839f, -0.00137283f, -0.03719295f, -0.04233697f, 0.02313209f, 
    -0.03360917f, -0.03612407f, 0.01981901f, -0.04515363f, -0.02492780f, 0.03239203f, 0.00166553f, 0.02811006f, 
    -0.02271003f, -0.01556441f, 0.00527639f, -0.02470141f, -0.00033258f, -0.01116405f, -0.04532024f, -0.01317412f, 
    -0.02216135f, -0.02867154f, -0.02579804f, -0.02448526f, 0.02993819f, -0.02215529f, 0.01870561f, 0.02856677f, 
    0.03051260f, -0.01849120f, -0.00597211f, 0.02192348f, -0.04113260f, -0.01916594f, 0.02022164f, -0.00975764f, 
    0.02557816f, 0.03168754f, -0.00659400f, 0.02343855f, 0.01457040f, 0.00908966f, 0.02288102f, -0.00673659f, 
    -0.01314294f, -0.01303087f, -0.02032670f, -0.00242876f, -0.04032024f, 0.00901770f, -0.03861693f, 0.00016514f, 
    0.00166657f, -0.01121897f, 0.02130168f, 0.03282539f, 0.02558371f, -0.01098640f, -0.01854688f, -0.03227561f, 
    0.00522785f, 0.01760423f, -0.02514268f, -0.01965096f, 0.01303175f, -0.03800735f, -0.00488660f, 0.02512096f, 
    -0.04495758f, -0.04357750f, -0.03740250f, 0.01783524f, -0.02620502f, 0.00978761f, -0.04515860f, -0.02797075f, 
    0.01320287f, -0.00454719f, 0.01636288f, -0.03058328f, 0.01363194f, 0.00173347f, 0.04032552f, -0.02119159f, 
    -0.03381140f, -0.02661516f, 0.01877828f, 0.01731464f, -0.00856350f, -0.03065652f, 0.02662915f, -0.02133790f, 
    0.00867548f, -0.03108819f, 0.01968238f, -0.02092125f, -0.01731400f, 0.03024681f, -0.04064409f, 0.02990227f, 
    0.01811062f, 0.03249392f, 0.03182453f, 0.00726037f, -0.03027043f, 0.02884150f, -0.04386614f, 0.01701537f, 
    0.02528439f, -0.02395066f, -0.02703774f, 0.02569396f, -0.03743020f, -0.04304837f, -0.00316047f, -0.02991620f, 
    -0.01071348f, 0.02796586f, 0.00534332f, -0.00637620f, -0.02023439f, 0.02585814f, 0.03102385f, 0.00947692f, 
    0.03513741f, 0.01285927f, -0.00272025f, 0.00276922f, 0.01556763f, 0.00489070f, 0.02048628f, -0.02979632f, 
    0.00900744f, -0.00849130f, 0.02933236f, 0.02381798f, -0.03580698f, 0.03180022f, 0.02365923f, 0.01152113f, 
    0.03776240f, -0.03579974f, -0.00848380f, -0.00795151f, -0.03866963f, 0.00814879f, 0.02741895f, -0.00436716f, 
    -0.01658199f, 0.02149070f, -0.03388652f, -0.01836096f, -0.01836157f, -0.02674649f, 0.01145987f, -0.03262248f, 
    -0.04219361f, 0.02558201f, 0.01711952f, 0.01354902f, -0.00793841f, -0.00693984f, 0.02651134f, -0.02039454f, 
    0.00078726f, 0.01845877f, 0.02585391f, -0.00951194f, 0.00428385f, -0.02852461f, -0.01690143f, 0.02094864f, 
    0.02543580f, 0.00494100f, 0.01127868f, -0.00731840f, -0.01663870f, -0.00027888f, 0.02543916f, -0.00776986f, 
    0.01074019f, 0.01312423f, 0.01628122f, 0.02463814f, -0.03134926f, -0.02130948f, 0.03258733f, -0.00452563f, 
    -0.01800441f, -0.04430116f, 0.01044589f, -0.03137693f, -0.00003662f, -0.03101879f, -0.00912459f, -0.00591856f, 
    0.02064286f, 0.02719568f, -0.04045662f, -0.00552200f, 0.04341993f, -0.03842563f, -0.04178356f, -0.03996083f, 
    0.00037478f, -0.00984155f, 0.00039857f, 0.03275569f, 0.00668287f, -0.00235905f, -0.03677962f, -0.01327622f, 
    0.02200196f, 0.00261591f, 0.00059255f, -0.01584951f, -0.03868860f, -0.03655850f, 0.00742118f, 0.03276914f, 
    0.00657153f, -0.01855745f, -0.02710121f, -0.01498413f, -0.03106064f, -0.03164473f, -0.02046289f, -0.00573118f, 
    -0.00345918f, -0.00821545f, 0.01699671f, -0.03845873f, -0.02361429f, 0.00476652f, -0.00809504f, -0.00729621f, 
    0.03175252f, -0.04504853f, -0.04222257f, 0.02061241f, 0.02471748f, -0.03452854f, -0.04119512f, 0.03258742f, 
    0.01722580f, -0.03870359f, 0.00017504f, 0.01206775f, 0.01921673f, -0.01623242f, 0.01851141f, -0.02187805f, 
    0.00280728f, 0.01675382f, -0.03124932f, -0.01450172f, 0.02906286f, 0.02890296f, -0.03478808f, -0.03141699f, 
    0.02816050f, 0.01938077f, -0.02927924f, -0.00523800f, 0.01915616f, 0.01111953f, -0.01447695f, 0.00641703f, 
    -0.02156594f, 0.00793810f, 0.01134436f, 0.01028510f, -0.02052928f, 0.02222292f, 0.00127877f, -0.01361822f, 
    -0.03631730f, -0.03740970f, 0.01753110f, -0.03084320f, -0.04363971f, 0.01226737f, 0.01546029f, -0.01800993f, 
    0.00926019f, -0.02518727f, 0.03170349f, -0.03120306f, -0.02985555f, -0.02801798f, -0.00748756f, 0.01928223f, 
    0.01386689f, -0.01796146f, 0.02303442f, -0.01829802f, -0.02791004f, -0.02398312f, -0.02741727f, 0.01300828f, 
    -0.00836317f, -0.01912275f, -0.03477703f, -0.04496519f, -0.01005228f, -0.01519301f, -0.02308969f, 0.02182513f, 
    -0.04210221f, -0.04043083f, -0.04483804f, -0.03354431f, -0.00372959f, -0.01875156f, 0.01689909f, -0.00110294f, 
    0.02295057f, 0.02561487f, -0.02875133f, -0.03428315f, -0.02721268f, -0.01496041f, -0.01431486f, 0.01302435f, 
    -0.00642958f, 0.02291152f, 0.02673429f, 0.03137045f, -0.02395874f, 0.02570285f, 0.00166207f, -0.02069918f, 
    -0.02168056f, -0.01717536f, -0.02269869f, 0.02167015f, 0.00786000f, -0.03150652f, -0.03243477f, 0.02692035f, 
    -0.03029099f, 0.01210041f, 0.01583240f, -0.03336404f, 0.01793073f, -0.04183408f, -0.03166655f, -0.04354772f, 
    0.00885531f, 0.00935435f, -0.00554557f, 0.02388910f, -0.04133215f, -0.01055468f, -0.02181024f, -0.01006528f, 
    0.01232080f, -0.00038067f, -0.02638861f, -0.01568743f, -0.00776873f, 0.02956885f, 0.00029288f, 0.02892930f, 
    -0.04153606f, 0.00700313f, -0.02512817f, -0.04087946f, -0.00448484f, 0.03115819f, -0.03278305f, -0.04505686f, 
    0.03079328f, -0.00707803f, -0.01096053f, 0.02110400f, -0.01587046f, -0.03015039f, -0.01520500f, -0.02509555f, 
    0.00857733f, -0.02179410f, -0.04048155f, -0.04177761f, 0.02799043f, -0.01129882f, -0.03009433f, -0.00610134f, 
    0.02595930f, -0.03960541f, 0.02168165f, -0.00682037f, -0.04227542f, -0.00897572f, 0.01554867f, 0.02671735f, 
    0.05717414f, 0.27016720f, -0.11775032f, 0.02926955f, 0.06440567f, -0.02773594f, 0.13550663f, -0.24779947f, 
    -0.13312557f, 0.01843610f, 0.06306798f, -0.12184642f, -0.03687781f, -0.06854625f, 0.08441176f, -0.07101218f, 
    0.07220902f, 0.03224934f, 0.13067731f, -0.09575032f, -0.10008353f, 0.12374849f, -0.19914867f, 0.10668620f, 
    0.11896002f, 0.08757510f, 0.04290556f, -0.14392446f, -0.00503889f, -0.07837895f, 0.02125928f, -0.03297772f, 
    -0.05545302f, 0.09763514f, 0.08408535f, 0.03871473f, 0.02790166f, 0.12562664f, 0.11800865f, -0.03608275f, 
    -0.03109591f, 0.20779330f, 0.08359019f, -0.31317395f, -0.08390182f, 0.03418451f, 0.15183450f, 0.08320419f, 
    0.11680441f, 0.03944449f, -0.01379493f, -0.11567774f, 0.05965800f, 0.09147465f, -0.10772310f, -0.00803165f, 
    -0.08243127f, 0.06195444f, 0.06468146f, -0.05362253f, -0.38893229f, 0.12652816f, -0.25744289f, 0.11824318f, 
    0.16785885f, 0.14841092f, 0.06679994f, -0.12335418f, -0.00421531f, 0.06033104f, 0.07148209f, 0.09060699f, 
    -0.17981820f, 0.26230681f, -0.03599643f, -0.00603552f, 0.21053445f, 0.01765063f, 0.12127376f, -0.05867812f, 
    -0.13244127f, -0.13394929f, -0.12415121f, 0.09217275f, 0.18799533f, 0.06787388f, 0.06793285f, 0.05184523f, 
    -0.08276960f, 0.02682802f, 0.03147535f, -0.04288789f, 0.14695846f, 0.11897713f, 0.05415066f, 0.22379822f, 
    0.06662353f, -0.02845542f, -0.08035701f, -0.01501354f, -0.23177904f, -0.06094821f, -0.05757444f, 0.02259372f, 
    0.03847223f, -0.16069376f, -0.03751877f, -0.15760930f, -0.08405728f, -0.03057094f, -0.02694136f, 0.04168845f, 
    -0.01445966f, -0.19790883f, -0.00093443f, 0.03104966f, -0.00392031f, 0.14124367f, 0.05391877f, -0.03649908f, 
    0.35149419f, -0.20730053f, -0.05177118f, 0.02448792f, 0.24208693f, -0.08723177f, 0.00453320f, -0.04000585f, 
    -0.16051637f, -0.08660639f, 0.15411034f, 0.04139125f, -0.05587657f, 0.02279741f, -0.02010328f, -0.07989602f, 
    0.14032342f, 0.06210148f, 0.04559688f, 0.05277393f, -0.01293798f, -0.07462990f, 0.12120114f, 0.17119911f, 
    0.07386646f, -0.12252153f, -0.12865488f, 0.07647295f, -0.01708311f, 0.04395946f, 0.03219633f, 0.00520790f, 
    -0.01304012f, 0.05662664f, 0.05720251f, 0.17527854f, 0.08692881f, 0.19311665f, -0.00271822f, 0.13626143f, 
    -0.23005237f, -0.14032046f, 0.09117471f, -0.01072146f, 0.15836787f, -0.02743083f, -0.04017412f, -0.04650027f, 
    0.00630610f, 0.06484953f, -0.00650203f, 0.04738879f, 0.01710816f, -0.05654901f, 0.03615520f, 0.05046472f, 
    0.09607290f, 0.13822576f, 0.03904000f, 0.09996637f, -0.12860897f, 0.42046860f, 0.08168374f, -0.12575670f, 
    -0.06072172f, 0.03969594f, 0.19660960f, -0.08380844f, 0.06716143f, -0.04243277f, -0.06657687f, -0.02299698f, 
    0.08813850f, 0.00775742f, -0.02042679f, 0.02657005f, 0.08673545f, -0.12731963f, -0.20914645f, -0.07126176f, 
    0.11023189f, 0.06268956f, -0.14707172f, 0.06468253f, 0.21977951f, 0.11086573f, 0.11437404f, -0.07612461f, 
    -0.00280561f, -0.05926155f, 0.09974536f, 0.03934279f, 0.07278544f, -0.06300540f, -0.00359944f, 0.20732802f, 
    0.10691556f, -0.01527196f, -0.07681292f, 0.00633615f, 0.12609658f, -0.04481834f, 0.16428865f, -0.04101259f, 
    0.05801309f, -0.11505214f, -0.05167224f, -0.12244986f, 0.07343578f, 0.00737287f, 0.09132906f, 0.15715744f, 
    0.02673328f, -0.06838322f, 0.09301062f, -0.09689073f, 0.07304869f, 0.07942568f, 0.01867433f, -0.04311687f, 
    -0.02601121f, 0.01661097f, 0.04963475f, -0.29257837f, 0.23544325f, 0.05661251f, 0.14224511f, -0.05314961f, 
    0.01499334f, -0.06948357f, 0.10554149f, 0.05984645f, 0.04102682f, 0.06483843f, -0.12294656f, 0.07546657f, 
    0.01041534f, -0.14523445f, -0.17904978f, -0.05197469f, -0.18605325f, -0.06715913f, -0.24014100f, 0.22694619f, 
    0.15941805f, 0.17302465f, -0.01015506f, -0.00123472f, -0.09107102f, -0.05112189f, 0.03458315f, 0.02444158f, 
    0.12916176f, 0.08209047f, -0.07964294f, 0.07546215f, 0.11741213f, 0.08283016f, -0.03285703f, 0.00963577f, 
    -0.06054298f, -0.06978904f, -0.16940933f, 0.22819331f, 0.01788915f, 0.06599349f, 0.01840343f, -0.04677314f, 
    -0.07800106f, 0.07359190f, 0.02079964f, -0.01095387f, -0.07011985f, 0.06968956f, -0.08713797f, 0.00194251f, 
    -0.01976753f, 0.07166781f, -0.03029141f, 0.03134371f, 0.03015605f, -0.12550087f, 0.19411498f, -0.27990294f, 
    -0.02383166f, -0.16017441f, 0.05281411f, 0.15865439f, -0.05176774f, -0.17814931f, -0.05315319f, -0.05502237f, 
    0.01106397f, -0.01582474f, -0.06242533f, -0.03232579f, 0.16069131f, 0.03269012f, -0.10700768f, -0.01170959f, 
    -0.23786087f, -0.03152664f, -0.11660720f, 0.23447564f, 0.07633864f, 0.17464839f, 0.02038162f, -0.08609282f, 
    -0.07068960f, -0.05529016f, -0.03541378f, 0.00241870f, 0.02213383f, 0.05975359f, -0.04832879f, -0.08140397f, 
    0.03856168f, 0.04108490f, -0.04154756f, -0.03085901f, -0.14362104f, -0.15679936f, 0.24243037f, -0.26581666f, 
    0.07505491f, -0.00289288f, -0.00109785f, -0.04018293f, 0.07912169f, 0.11433206f, -0.10429686f, 0.05987508f, 
    0.05448105f, -0.02878437f, 0.02816298f, -0.04108415f, 0.05986340f, 0.14559691f, -0.14204690f, 0.11192693f, 
    0.16383022f, -0.24248318f, -0.12884490f, 0.27682787f, 0.01471401f, -0.07413607f, 0.01127038f, 0.03268923f, 
    -0.01267389f, 0.10373889f, -0.02577568f, -0.08559112f, 0.02844089f, -0.01047133f, 0.01852716f, 0.03264702f, 
    0.07769578f, 0.03167108f, 0.07851107f, 0.08542442f, 0.02290062f, -0.13944122f, -0.18751276f, 0.08139947f, 
    0.17818494f, 0.02967339f, 0.09740815f, -0.06833023f, -0.03989033f, -0.04471176f, 0.03027799f, 0.09767746f, 
    -0.05203965f, 0.14882047f, 0.10398051f, 0.07059864f, -0.08375582f, -0.12323106f, 0.03080394f, 0.00511441f, 
    -0.01207551f, 0.36403427f, -0.01595781f, 0.00807093f, 0.02412520f, -0.31458557f, -0.22621030f, 0.09918886f, 
    0.00545863f, 0.02499151f, -0.02278700f, -0.09764308f, -0.00308002f, 0.02940315f, 0.03179815f, 0.08548631f, 
    0.16965225f, 0.00475924f, -0.01779615f, 0.06330503f, 0.08936731f, -0.14865553f, 0.09183628f, -0.36447883f, 
    0.05221348f, -0.17658442f, 0.06189480f, 0.02278539f, -0.07036134f, 0.02665850f, 0.22483979f, 0.00019982f, 
    -0.06632172f, -0.09874067f, 0.00585485f, 0.01495746f, -0.00868817f, -0.21780215f, 0.28818277f, -0.06719907f, 
    -0.02379804f, 0.13846652f, -0.12021694f, 0.23376666f, 0.18336803f, 0.07697360f, -0.01324001f, -0.06207621f, 
    -0.00560157f, 0.06860610f, 0.14270671f, -0.04118124f, -0.11520407f, 0.01444157f, -0.04222527f, 0.10898448f, 
    0.11995179f, 0.11141551f, 0.15662163f, 0.03143554f, 0.21950412f, 0.07245143f, -0.17533134f, -0.04262508f, 
    -0.11155687f, 0.03045036f, -0.01167530f, 0.01295483f, 0.14390017f, 0.12415920f, 0.08076574f, 0.04714474f, 
    -0.16007905f, -0.08417976f, 0.09768350f, 0.07259088f, 0.08047140f, -0.03647976f, -0.12332451f, -0.03747330f, 
    0.25242952f, 0.18934628f, -0.00243520f, -0.19301009f, -0.02529521f, 0.15748435f, 0.05004096f, 0.03308243f, 
    0.04167706f, 0.04235935f, -0.05133960f, 0.03398257f, 0.04207066f, 0.14219970f, -0.08665627f, 0.22461806f, 
    0.08098810f, 0.00895373f, -0.08461656f, 0.09291520f, 0.12599967f, 0.20462999f, 0.06020376f, -0.29283884f, 
    -0.01342970f, 0.18157388f, -0.03651042f, 0.09515011f, 0.11139408f, -0.10945949f, -0.04007401f, 0.01014078f, 
    0.11136047f, 0.08578151f, -0.07739428f, 0.13324346f, 0.09387328f, 0.01117569f, -0.19066128f, 0.01970088f, 
    -0.14662631f, 0.18095173f, 0.01103045f, 0.06335614f, 0.13112366f, 0.00008897f, -0.03805470f, -0.05709416f, 
    0.04042995f, 0.10446202f, 0.02493303f, 0.07306233f, 0.05002773f, -0.04187604f, 0.03394542f, 0.00963205f, 
    -0.01761395f, -0.27475145f, -0.05424462f, -0.05543987f, -0.01777698f, 0.23381618f, -0.14826958f, -0.06649697f, 
    0.04545594f, 0.14247076f, 0.01344524f, -0.07075185f, 0.06543732f, 0.07479391f, 0.05587665f, 0.08620661f, 
    0.00281280f, 0.18854372f, 0.01510842f, 0.11494693f, 0.11282901f, 0.05432600f, -0.00975518f, 0.09611974f, 
    0.66946286f, 0.13058349f, -0.14013304f, -0.11992411f, -0.21206933f, -0.25746807f, -0.05424528f, 0.05459575f, 
    0.06396151f, -0.12784512f, -0.00190160f, 0.00764609f, 0.07055026f, -0.20282024f, -0.01771392f, 0.06259545f, 
    0.07164539f, -0.13140073f, 0.05038138f, -0.03026877f, 0.01971569f, 0.19064845f, 0.36176163f, -0.27287799f, 
    0.01194501f, -0.00330385f, 0.08434722f, 0.10092750f, 0.05265142f, -0.00752113f, -0.00557789f, -0.04224260f, 
    0.06740100f, 0.14445443f, 0.05702896f, 0.07878905f, 0.14885136f, 0.09761886f, -0.19291992f, 0.17686787f, 
    -0.37537894f, 0.00060289f, -0.13871525f, 0.05915833f, -0.00596908f, 0.17619795f, 0.00833201f, -0.13265695f, 
    -0.03515334f, 0.06080523f, 0.05127072f, 0.01627508f, 0.11976859f, -0.00710111f, 0.10708144f, 0.06683003f, 
    -0.05120654f, 0.05160123f, 0.05112423f, -0.04572538f, 0.35660195f, -0.12314821f, 0.00658068f, -0.04499469f, 
    0.15784472f, -0.10743718f, 0.01778971f, 0.09510942f, -0.03954991f, -0.10726250f, 0.05547252f, 0.04983096f, 
    -0.09859636f, 0.00129796f, -0.00146418f, 0.12695630f, -0.12648307f, -0.04318856f, -0.01626817f, 0.16601464f, 
    -0.26417381f, -0.00073368f, -0.32781878f, -0.02525797f, 0.01517124f, -0.06138273f, -0.00216112f, 0.00189669f, 
    0.06886459f, -0.07338052f, -0.05300442f, 0.09707215f, 0.07479225f, -0.02743026f, -0.01321081f, 0.05370842f, 
    0.01090918f, -0.19807814f, -0.22327131f, -0.00538314f, -0.08314855f, -0.10743929f, 0.00977463f, 0.02470252f, 
    0.04247532f, 0.04183927f, -0.08610149f, -0.00982940f, -0.01897102f, -0.11152026f, -0.08375873f, 0.04449142f, 
    0.14512092f, -0.00135338f, 0.09428599f, 0.05286701f, 0.12807384f, -0.38829842f, 0.13797624f, 0.02637991f, 
    0.08610313f, -0.08730844f, -0.00516115f, 0.15567555f, -0.00810902f, -0.01882619f, 0.05583094f, -0.01100026f, 
    -0.12861072f, -0.01895794f, 0.05817224f, 0.08861990f, 0.02646808f, -0.05174050f, 0.16642387f, -0.03118022f, 
    0.21492840f, -0.04317513f, -0.04308273f, 0.09566204f, 0.03268953f, -0.05393633f, 0.07567266f, 0.07778134f, 
    -0.07989850f, -0.02629316f, -0.04935747f, 0.04878497f, -0.05040210f, 0.01001303f, -0.12574510f, 0.02221243f, 
    0.22656333f, -0.12769666f, 0.11587894f, 0.07153185f, 0.03375702f, -0.18455704f, 0.00404572f, 0.03371879f, 
    -0.17607445f, 0.01408508f, 0.13309070f, -0.07807002f, -0.31525469f, 0.01059671f, 0.14413510f, -0.07564470f, 
    -0.08568701f, -0.01568444f, -0.13341318f, 0.03888198f, -0.07012621f, -0.00992457f, -0.07013159f, 0.03575198f, 
    0.06942863f, -0.00063398f, -0.07945548f, -0.13382742f, 0.79043245f, -0.18052641f, 0.03413449f, 0.04199937f, 
    0.03054962f, 0.06012970f, -0.07070485f, 0.09120873f, 0.11818852f, 0.15643562f, -0.05981186f, -0.06503697f, 
    -0.03890605f, 0.17755280f, 0.04602632f, 0.12183370f, 0.18306814f, -0.12872835f, -0.04485793f, 0.04827325f, 
    -0.07290447f, 0.26098517f, -0.18710174f, -0.08411095f, 0.13231607f, 0.00908075f, -0.01597159f, 0.03411211f, 
    0.08928929f, -0.02198415f, 0.01078115f, -0.03089635f, 0.12189635f, 0.10380129f, 0.13866760f, 0.10199599f, 
    0.01401298f, 0.00282736f, -0.23320755f, -0.08201063f, 0.48259914f, -0.27717751f, 0.04196525f, -0.13691916f, 
    0.01786552f, 0.12685090f, 0.13698781f, -0.04473698f, 0.00281553f, 0.02408309f, -0.00366609f, 0.03432385f, 
    0.11844168f, 0.01769830f, 0.04467480f, 0.00675104f, 0.09777616f, -0.18258667f, 0.02812734f, -0.20846832f, 
    0.51161391f, -0.01591732f, 0.02071879f, 0.15470923f, 0.03818731f, -0.03700671f, -0.02883334f, 0.09640084f, 
    0.09310158f, -0.05512812f, 0.09755390f, -0.01658270f, -0.08280543f, 0.06270292f, -0.09073270f, 0.01125957f, 
    0.06947553f, -0.15588167f, -0.07842810f, -0.05019518f, 0.30313829f, -0.07876179f, -0.13106176f, -0.12469825f, 
    -0.13170961f, 0.00528329f, 0.01533948f, 0.00914726f, -0.15973063f, 0.05932870f, -0.11569893f, 0.08951347f, 
    -0.08841530f, 0.00441861f, -0.03263185f, 0.09275720f, 0.00280156f, 0.14316419f, 0.28757676f, 0.07748897f, 
    0.41187960f, 0.07965496f, -0.05294614f, 0.00755530f, -0.20323473f, -0.00478977f, 0.03608039f, -0.07026778f, 
    -0.08244589f, -0.08652350f, -0.21713424f, 0.01977491f, -0.06889270f, 0.08612195f, -0.01456612f, -0.01042964f, 
    -0.03068821f, -0.04472384f, 0.12684755f, -0.04732970f, 0.01557571f, -0.03708624f, -0.05982415f, -0.17719214f, 
    0.21195422f, 0.07837114f, 0.00381196f, 0.08482289f, 0.08497563f, -0.00773010f, -0.04322371f, -0.03631081f, 
    0.01339220f, 0.13699730f, 0.13449222f, 0.19522229f, 0.08822839f, 0.00939357f, -0.04064819f, -0.01729220f, 
    0.05777685f, 0.09050450f, -0.02053889f, 0.12370137f, -0.18113984f, -0.01727954f, 0.18188582f, 0.04964855f, 
    -0.06629845f, 0.00424879f, -0.10439698f, -0.10428705f, -0.07534557f, -0.06139730f, 0.10973342f, 0.11167973f, 
    0.17406096f, 0.18364467f, 0.23910628f, 0.19851939f, 0.00718072f, 0.13399589f, 0.05213939f, -0.05565582f, 
    -0.09098474f, -0.01477396f, 0.11072835f, -0.08768176f, -0.06351519f, -0.01753804f, -0.04144111f, -0.07185393f, 
    0.04201827f, -0.06382529f, 0.09143898f, -0.03930927f, 0.00648222f, -0.11983284f, -0.05921440f, -0.04911743f, 
    -0.16712566f, 0.16138628f, -0.14736776f, -0.03298629f, 0.03586875f, 0.05865519f, -0.07607567f, -0.04866689f, 
    0.08107034f, -0.07289004f, 0.03946766f, 0.04301158f, -0.04835468f, -0.00377238f, -0.10578856f, 0.04157130f, 
    0.02164677f, -0.12690277f, -0.09978510f, -0.13106142f, -0.19768324f, 0.23358753f, 0.11202952f, -0.00415875f, 
    0.15744896f, -0.01263546f, -0.13260303f, 0.10369668f, 0.00857326f, 0.06237981f, -0.11368294f, 0.01512198f, 
    -0.02074615f, -0.00837455f, -0.03887532f, 0.15313682f, -0.06217354f, -0.00762891f, 0.14711171f, 0.10980277f, 
    -0.09752824f, 0.18681207f, -0.10331876f, -0.08891642f, 0.11949959f, 0.02451096f, -0.03562351f, -0.08162689f, 
    0.07200343f, -0.01056281f, 0.12379247f, -0.06973922f, -0.04463970f, -0.13565111f, -0.08040040f, 0.08727482f, 
    0.05984898f, -0.13697818f, 0.05424651f, -0.09413989f, 0.44825870f, -0.07084640f, 0.12080230f, 0.13595107f, 
    0.09181973f, 0.01563559f, -0.17134209f, 0.03508716f, 0.01776037f, -0.01306453f, 0.11971751f, 0.06594444f, 
    0.03665988f, -0.03160490f, -0.03461732f, 0.05977840f, 0.11489672f, -0.14190434f, 0.09562502f, -0.00360755f, 
    0.41286692f, 0.08139803f, -0.05750893f, -0.05400392f, -0.05662184f, 0.09753758f, -0.04454635f, 0.00108757f, 
    0.01824836f, -0.13258141f, -0.01555564f, 0.14525571f, -0.03986370f, 0.04781232f, -0.00884618f, 0.01301625f, 
    -0.05962890f, -0.04522747f, -0.06020469f, -0.02773801f, -0.30593321f, 0.14696604f, -0.02299998f, 0.12033788f, 
    -0.09946656f, -0.04930502f, 0.00541532f, 0.00069348f, 0.01174467f, 0.03391907f, 0.09571349f, -0.00306899f, 
    0.05645332f, 0.01049130f, -0.09898826f, 0.08348215f, 0.09734065f, 0.08901361f, 0.04984279f, -0.05411451f, 
    0.46415296f, -0.12907633f, 0.01902257f, 0.03656725f, 0.05028390f, -0.02830828f, -0.01103687f, -0.18273503f, 
    0.15699239f, -0.03331517f, -0.14435612f, 0.02567985f, -0.07801595f, 0.13770869f, 0.03947658f, 0.01680582f, 
    -0.00303256f, 0.04285817f, -0.01488583f, 0.03229241f, -0.19237301f, 0.66817576f, -0.08144211f, 0.22085516f, 
    0.26096654f, -0.06963302f, 0.08361218f, 0.12008585f, -0.00174040f, -0.03625214f, -0.10455071f, 0.04074284f, 
    -0.01908938f, 0.12258153f, 0.09406212f, 0.09744238f, 0.05644640f, 0.17375223f, -0.30834812f, 0.05601985f, 
    -0.09098048f, -0.10040579f, -0.26788378f, -0.00228810f, -0.02114575f, -0.03211251f, -0.02542451f, -0.03057414f, 
    -0.00048378f, -0.05552561f, -0.02750798f, 0.05667708f, 0.09619028f, -0.08814572f, -0.06608877f, -0.00382956f, 
    -0.02928658f, -0.14651048f, -0.08566397f, -0.01887047f, 0.05218807f, 0.03929455f, 0.02986770f, -0.07680755f, 
    0.03595207f, -0.01006244f, 0.08795004f, 0.01564335f, 0.02316868f, 0.11503421f, 0.00673393f, 0.00662205f, 
    0.13705200f, 0.18596393f, 0.15680712f, -0.01135572f, -0.01294232f, 0.06255583f, -0.00887744f, 0.06865209f, 
    -0.15212002f, 0.04186634f, -0.06566799f, -0.10923388f, 0.02306904f, 0.01414617f, 0.01738497f, -0.09582074f, 
    -0.15411678f, -0.11563226f, -0.08959689f, -0.00003339f, -0.13098654f, -0.12404481f, -0.05690148f, -0.09938331f, 
    0.07021453f, 0.13120513f, 0.12005905f, 0.03251998f, -0.09872709f, -0.00555497f, -0.10244785f, -0.04129200f, 
    -0.07763171f, -0.01712818f, 0.03991247f, -0.02908307f, -0.18227267f, -0.02703995f, -0.06971575f, 0.10054969f, 
    -0.15368974f, -0.22897255f, -0.19545956f, 0.05973303f, 0.00976500f, 0.14212377f, 0.28710037f, -0.01909228f, 
    0.37871879f, 0.00177345f, 0.15077354f, 0.13009569f, 0.06106624f, -0.19831842f, 0.01417023f, -0.01069419f, 
    0.00402452f, -0.11118396f, -0.11867996f, -0.00935357f, -0.14859621f, 0.08061216f, -0.04820510f, 0.13770805f, 
    0.03578070f, 0.23496273f, 0.26392817f, 0.15700620f, -0.03883163f, -0.13515422f, 0.43957967f, 0.01230562f, 
    0.09538449f, 0.10646729f, 0.03485287f, 0.01289804f, -0.04344909f, -0.05931563f, -0.00280848f, -0.08658759f, 
    -0.15945956f, -0.18038683f, -0.17103767f, 0.00471999f, -0.03839625f, -0.00060512f, 0.21123159f, -0.11042301f, 
    -0.35064158f, -0.16176598f, 0.41022080f, -0.13028686f, 0.13207011f, -0.03470809f, 0.01689126f, 0.01144686f, 
    0.06745198f, 0.20343044f, 0.07884973f, -0.05537058f, -0.01321966f, 0.21512419f, 0.07275493f, 0.04653146f, 
    0.01513796f, 0.09264176f, 0.05358840f, 0.06783447f, -0.29083022f, -0.11538289f, -0.20109263f, -0.04245600f, 
    -0.13494599f, -0.08566752f, -0.08049506f, 0.01349542f, -0.05222281f, -0.03493894f, -0.15483175f, 0.04056041f, 
    0.01340775f, -0.04341756f, 0.09097753f, -0.12139896f, 0.03750182f, -0.07598505f, 0.22760732f, 0.00386791f, 
    0.24869812f, 0.00843058f, 0.19478768f, 0.06093346f, 0.25849918f, 0.04742990f, -0.02697343f, -0.02600367f, 
    0.00556410f, -0.04422251f, 0.01349065f, 0.01189199f, -0.08419450f, 0.04212168f, -0.12362667f, 0.06462625f, 
    0.04271071f, -0.10107490f, 0.17770845f, 0.01831153f, -0.00610963f, -0.05565657f, 0.21921830f, 0.09560923f, 
    -0.10752441f, 0.07356562f, 0.06345081f, 0.10816646f, -0.01417820f, 0.06330120f, -0.05382134f, -0.12678748f, 
    0.12653086f, 0.14880311f, 0.08859753f, 0.01433640f, 0.24765806f, -0.07680912f, 0.14182426f, -0.19968168f, 
    -0.24843588f, 0.06597140f, -0.16177440f, 0.10758527f, 0.02590600f, -0.02336453f, 0.09841356f, -0.07095660f, 
    0.05767147f, 0.04695605f, 0.02911735f, -0.03255663f, 0.10808951f, -0.09515005f, -0.03780008f, 0.05905867f, 
    -0.02367353f, -0.06532274f, 0.01590778f, 0.04912427f, 0.14193651f, -0.13909422f, 0.07667725f, -0.09719310f, 
    0.00002027f, -0.11394364f, -0.01489591f, -0.05338370f, -0.17192307f, -0.03948227f, 0.05108541f, -0.03946802f, 
    -0.00668680f, -0.07391427f, 0.05049438f, -0.01015185f, 0.04515754f, -0.07497562f, 0.09270072f, 0.10182759f, 
    0.23489381f, 0.03406686f, 0.07605657f, 0.29032627f, 0.17272760f, 0.02447093f, 0.05341700f, -0.02556151f, 
    -0.01986453f, -0.05610883f, 0.10182661f, 0.11876224f, -0.08657975f, 0.01868351f, 0.12390531f, -0.05709122f, 
    0.16268730f, -0.08708795f, -0.09984288f, 0.10057846f, 0.06648657f, 0.00300627f, 0.07102245f, -0.00561850f, 
    0.03595594f, -0.05452544f, -0.12555428f, 0.12696104f, -0.12289360f, 0.01289613f, 0.02844457f, -0.02161410f, 
    -0.04437603f, -0.03214753f, 0.06798726f, 0.08316240f, 0.04052416f, 0.03097261f, 0.00424093f, -0.00028924f, 
    -0.14439043f, -0.36363879f, 0.25120780f, 0.19184491f, -0.21772097f, -0.13976015f, -0.06022561f, -0.14478387f, 
    -0.04563251f, 0.01170209f, 0.05168719f, 0.01820746f, 0.15958044f, 0.00591377f, 0.11493359f, 0.02590219f, 
    0.07000645f, -0.07823759f, -0.04803978f, -0.02217654f, 0.01744597f, -0.00350206f, -0.22270526f, 0.14811048f, 
    0.02844082f, 0.09496435f, 0.01025642f, 0.06488892f, -0.01207822f, 0.10504065f, -0.05591723f, -0.03195196f, 
    0.02236025f, -0.01636266f, 0.00288014f, -0.00948942f, 0.14124693f, 0.04530649f, -0.04187265f, 0.09762666f, 
    -0.30067927f, 0.15429400f, 0.09742887f, -0.06125387f, -0.07597763f, -0.05236211f, 0.04512980f, -0.02172588f, 
    -0.11687251f, -0.09997960f, 0.03931201f, 0.03248498f, 0.01522723f, 0.00144188f, 0.07761857f, -0.05913080f, 
    -0.03723699f, 0.02038215f, 0.03569362f, -0.04937167f, 0.02520661f, -0.19907649f, -0.08386220f, 0.00162023f, 
    0.11855394f, 0.08206234f, 0.06812524f, -0.03150506f, 0.11702487f, 0.02073123f, -0.10306541f, -0.03534322f, 
    -0.00602063f, 0.02627138f, -0.00761568f, -0.11360558f, 0.04825317f, 0.04342714f, 0.01706429f, -0.09456570f, 
    0.02403274f, 0.05303507f, -0.08524827f, 0.01334127f, 0.16544205f, 0.13972373f, 0.02907826f, 0.01469665f, 
    0.08388064f, 0.14362742f, -0.01515112f, 0.00133661f, -0.07765341f, -0.01641866f, -0.00104618f, -0.00872683f, 
    0.05216042f, 0.08304632f, -0.01557637f, 0.01911919f, 0.20636028f, -0.16789211f, 0.15201306f, 0.18079729f, 
    0.10886319f, 0.04031660f, -0.16699420f, 0.01636337f, -0.06759315f, 0.11759794f, -0.05730959f, 0.14995061f, 
    -0.02400109f, 0.02828165f, 0.04588996f, 0.08581384f, -0.15075615f, 0.10335134f, 0.02596293f, 0.15352218f, 
    -0.06542145f, -0.05921345f, 0.03051333f, -0.12327299f, 0.04464071f, -0.07166489f, -0.02565963f, 0.02685578f, 
    -0.00231287f, 0.10523352f, -0.00983093f, 0.02938519f, 0.00069683f, -0.00406049f, 0.06516641f, 0.00541734f, 
    -0.09511137f, 0.08817462f, -0.09503438f, 0.08997408f, -0.15670891f, 0.06577462f, 0.08998838f, 0.12685344f, 
    0.03666805f, 0.01894839f, -0.03496719f, 0.08569738f, -0.04787572f, -0.04861951f, -0.03317662f, 0.04599512f, 
    -0.05902357f, 0.00320279f, -0.05687440f, 0.01719592f, -0.05418617f, 0.12053271f, -0.00586629f, -0.02009241f, 
    0.00582517f, 0.37972665f, -0.07966347f, 0.19599925f, 0.03950706f, -0.09123587f, 0.06156753f, -0.05226238f, 
    0.00674363f, -0.02534511f, 0.01663451f, -0.08715747f, 0.03605228f, 0.03773829f, 0.02902869f, 0.01128903f, 
    0.06150572f, -0.01616884f, 0.00652628f, 0.14606650f, -0.05143227f, -0.17078921f, 0.06071977f, -0.11306459f, 
    -0.16831960f, -0.10985667f, 0.03896003f, -0.01230540f, -0.05324021f, 0.10610272f, 0.04854250f, 0.01624903f, 
    0.06567244f, -0.03314203f, 0.07672542f, -0.05342802f, 0.07042359f, -0.00801410f, 0.03406628f, 0.05490043f, 
    -0.32871145f, -0.01113773f, -0.13956504f, -0.06423785f, -0.02478138f, -0.00855663f, -0.00812363f, -0.04128486f, 
    0.07787756f, 0.06020544f, 0.03106753f, -0.07153514f, 0.01046518f, 0.02533668f, -0.07314447f, 0.06160354f, 
    0.09465063f, -0.01326444f, 0.01839502f, 0.02278061f, -0.08440128f, 0.16141957f, 0.35854882f, -0.06813023f, 
    0.26593962f, 0.21743940f, 0.04516863f, -0.01630068f, 0.04278424f, -0.00372697f, -0.02317723f, 0.04179048f, 
    -0.05115652f, -0.00413167f, 0.05765052f, 0.04265668f, -0.04332328f, -0.03303626f, 0.09650208f, -0.02412631f, 
    -0.31350866f, -0.03500445f, -0.09367593f, -0.10853067f, -0.01403964f, 0.04776723f, -0.05699058f, -0.04809071f, 
    0.00041077f, 0.12005655f, 0.04215641f, 0.05654470f, -0.03227289f, 0.07342636f, -0.05745535f, 0.00431790f, 
    0.01242409f, 0.03599777f, 0.06370768f, 0.10137530f, 0.07030639f, 0.08272762f, 0.20776655f, 0.10831489f, 
    0.26559761f, 0.21363346f, -0.09007053f, 0.00557087f, 0.00436944f, 0.13659264f, 0.00341573f, 0.02420289f, 
    -0.04142800f, -0.04247077f, -0.04649298f, -0.02635919f, 0.03405276f, -0.07779585f, -0.11413806f, -0.03825692f, 
    -0.26301390f, 0.55666488f, -0.08310014f, -0.13921942f, -0.04060271f, 0.05682234f, 0.06254604f, -0.00022421f, 
    0.05891138f, -0.08334130f, 0.06286906f, 0.07809187f, -0.04211878f, 0.05967160f, 0.03903629f, 0.08131080f, 
    0.01931377f, -0.02834507f, -0.02291983f, -0.02612966f, -0.07442717f, -0.22899260f, 0.09076851f, 0.20312960f, 
    0.15063202f, 0.05909071f, -0.04732757f, -0.12761544f, -0.04238468f, -0.03796272f, -0.00008534f, 0.07928614f, 
    0.04714195f, -0.06310135f, -0.00524995f, -0.06534959f, 0.11182713f, -0.09615921f, -0.00984666f, -0.14358573f, 
    -0.00835113f, -0.00586853f, 0.09508192f, 0.08049771f, 0.01004562f, -0.05158501f, 0.09137643f, 0.24802713f, 
    -0.03605930f, -0.08459215f, 0.01947239f, 0.07823326f, 0.06749921f, 0.05293304f, 0.18167718f, 0.08494924f, 
    0.11307214f, 0.07032904f, 0.08543228f, -0.09828785f, 0.10055393f, 0.34820837f, -0.24286506f, 0.02643883f, 
    0.15349808f, -0.03500272f, 0.14643131f, -0.03809550f, -0.05227161f, -0.12867685f, -0.01913785f, 0.01208675f, 
    -0.00467000f, -0.02533164f, 0.00402965f, 0.01683948f, -0.01574730f, 0.05867737f, -0.01495792f, 0.09816701f, 
    -0.24370828f, -0.15294208f, -0.07804258f, -0.02754625f, 0.14020902f, -0.01269366f, 0.05302716f, -0.12626705f, 
    0.05813485f, 0.09163783f, 0.05141882f, -0.05230687f, 0.04621891f, 0.06172657f, -0.06595622f, 0.02867779f, 
    0.09551894f, -0.02723652f, -0.00708470f, 0.09490373f, -0.23959383f, 0.47438747f, 0.01469027f, 0.06289089f, 
    -0.07523733f, -0.12449773f, 0.13486105f, 0.05158621f, 0.08853823f, -0.20532523f, -0.05109728f, -0.00360220f, 
    0.13425925f, 0.03918422f, 0.02137068f, -0.11120433f, 0.03775166f, 0.14084651f, 0.16556166f, 0.06430691f, 
    -0.07562525f, -0.07513927f, -0.01433903f, 0.05605177f, 0.06752189f, -0.03934778f, -0.01647141f, 0.02177064f, 
    -0.01970123f, -0.08629937f, 0.02711771f, -0.00138247f, -0.04292277f, 0.02459436f, 0.08148903f, -0.13785146f, 
    0.00548418f, -0.00896021f, -0.05737904f, 0.02113778f, -0.09336894f, -0.26997122f, 0.17180273f, 0.09618616f, 
    0.10596877f, -0.05438882f, -0.15024982f, -0.09406579f, -0.09048451f, 0.02499367f, -0.07531439f, 0.04638978f, 
    -0.05419336f, -0.00748026f, 0.10300460f, -0.06312758f, -0.05964431f, -0.01899679f, 0.06067489f, 0.09390962f, 
    0.30001783f, 0.22694489f, 0.28611472f, 0.11441503f, 0.05694130f, 0.11740153f, 0.05140746f, 0.02347361f, 
    0.07179900f, 0.03311352f, 0.11319148f, 0.06843261f, 0.04493168f, 0.00008088f, 0.03844989f, 0.06150652f, 
    -0.07039140f, 0.03028872f, 0.06029753f, -0.04223133f, -0.49598470f, -0.33772269f, 0.22290200f, 0.11177932f, 
    0.11440805f, 0.07448855f, -0.05994138f, -0.03460715f, 0.00886723f, 0.10073051f, -0.06952405f, 0.05379386f, 
    -0.01173160f, 0.05025952f, -0.06980395f, 0.06460989f, -0.01180250f, 0.10035668f, 0.01801750f, -0.05478983f, 
    -0.34844548f, 0.35606587f, 0.09220083f, 0.10706639f, 0.03035698f, -0.02660518f, 0.07433259f, 0.08122177f, 
    -0.04472632f, -0.07687076f, 0.07154205f, 0.06858878f, 0.03071580f, 0.03315100f, -0.03015651f, 0.14882964f, 
    0.08856565f, 0.24140368f, 0.03215250f, 0.04229281f, -0.11941198f, 0.30003101f, 0.16243151f, 0.00646270f, 
    0.32202411f, 0.28998995f, 0.02457224f, 0.02829329f, 0.06711732f, -0.03418217f, 0.00504053f, 0.00248920f, 
    -0.08509135f, 0.03312130f, 0.05146468f, -0.14725731f, -0.00735602f, -0.03683507f, -0.00922996f, -0.07599098f, 
    -0.14789130f, 0.10837590f, 0.14954695f, 0.04007763f, 0.08511300f, 0.02432080f, -0.06538462f, -0.03254519f, 
    -0.05305662f, 0.02312936f, -0.01389539f, 0.01688807f, -0.09027805f, 0.07903183f, -0.02164689f, 0.04282067f, 
    0.04602159f, 0.03664540f, 0.05070937f, 0.06527951f, -0.42431244f, -0.20198122f, 0.20046051f, -0.11481653f, 
    0.22521777f, -0.02429362f, 0.11511770f, -0.01333666f, -0.03931668f, 0.05982016f, -0.02316468f, -0.06615468f, 
    0.08912157f, 0.12321158f, 0.02177903f, -0.04826998f, 0.16834709f, 0.13190854f, -0.06295162f, -0.11884789f, 
    0.04606843f, -0.23416151f, -0.02462547f, -0.01115404f, 0.12763859f, 0.05205656f, 0.04959255f, 0.14106672f, 
    -0.00555382f, -0.01467308f, -0.10960642f, 0.05003932f, -0.05499266f, 0.04248326f, 0.09077156f, -0.07659718f, 
    0.05448715f, 0.06282580f, -0.11544298f, -0.00332477f, -0.33478060f, 0.26668212f, -0.09740184f, 0.15600084f, 
    0.20588386f, 0.05089568f, -0.05911514f, 0.08150916f, 0.14519176f, -0.05193661f, -0.02597697f, 0.07114785f, 
    -0.05908889f, 0.10966875f, 0.11616447f, -0.05990622f, 0.04847697f, -0.00052617f, -0.16352823f, -0.06545781f, 
    -0.22128879f, -0.04514814f, -0.04462332f, -0.13168582f, -0.10149022f, 0.07492409f, 0.03013412f, 0.08054669f, 
    0.13494530f, 0.07825097f, -0.09579430f, -0.01868840f, 0.03161065f, 0.06224512f, -0.05229593f, 0.02424112f, 
    -0.06431215f, -0.01539952f, 0.09026848f, -0.14600973f, -0.22435050f, 0.27107340f, -0.07323354f, 0.00637028f, 
    0.19293854f, 0.11956762f, 0.04426225f, -0.03345925f, -0.01465699f, 0.00582054f, -0.06115871f, -0.01358358f, 
    0.16636275f, 0.11907487f, -0.04442751f, -0.03764614f, 0.20478900f, 0.02464706f, 0.03771662f, -0.01621616f, 
    0.18544216f, 0.37261742f, 0.05251182f, -0.11764541f, -0.08082704f, 0.10308804f, 0.07159015f, 0.03899354f, 
    0.00897844f, -0.00119703f, 0.05941450f, 0.13131338f, -0.04239130f, 0.07271743f, 0.02933933f, 0.11884578f, 
    0.10243832f, 0.02244415f, -0.08678521f, 0.05854626f, 0.35224849f, 0.02560314f, 0.08144952f, -0.02038749f, 
    0.09902961f, -0.12718220f, 0.11509178f, -0.13802369f, 0.08063509f, 0.18347423f, -0.05821622f, 0.15581363f, 
    0.05883876f, 0.01988522f, 0.14682490f, 0.04533812f, -0.06579678f, -0.02255867f, -0.12868612f, -0.04086642f, 
    0.38330534f, -0.27137190f, 0.11835501f, -0.06009230f, 0.16949944f, 0.13760345f, -0.08707531f, 0.07706713f, 
    0.10299081f, 0.17935941f, 0.02874918f, 0.04934968f, 0.10059644f, -0.10780843f, -0.05560398f, 0.04593424f, 
    0.01854329f, -0.00583308f, -0.05690398f, 0.02624121f, -0.12880553f, 0.21430321f, 0.16241960f, 0.02944773f, 
    -0.16165768f, -0.01500356f, 0.11928871f, 0.10011628f, -0.06634751f, 0.22764437f, 0.06955962f, 0.06433048f, 
    -0.02394779f, -0.02724917f, 0.20104451f, -0.06265844f, 0.04368100f, 0.04774281f, 0.07326181f, 0.12255234f, 
    0.08013123f, 0.11319780f, -0.10931055f, 0.05671124f, 0.16097237f, -0.12625875f, 0.03427340f, 0.01873198f, 
    -0.08342636f, 0.03942155f, 0.02614824f, 0.11687092f, 0.13637342f, 0.01929921f, 0.10880414f, 0.05210520f, 
    -0.01254670f, -0.01962937f, 0.08531673f, 0.04584652f, 0.14727712f, 0.15518664f, 0.03663659f, -0.19090155f, 
    -0.35484999f, 0.01126597f, 0.14371668f, -0.00918158f, 0.05464475f, -0.11204157f, 0.07573814f, 0.06022495f, 
    0.06326462f, 0.02207413f, -0.06265062f, 0.05887351f, 0.01672161f, -0.09197987f, 0.06145263f, 0.02904469f, 
    0.31525367f, -0.00375106f, 0.08788631f, 0.11745927f, -0.17855348f, 0.03750772f, 0.07998705f, 0.05869429f, 
    0.01704584f, -0.05541542f, 0.05113832f, 0.19276668f, 0.10455756f, -0.01140765f, -0.03853117f, 0.00784090f, 
    -0.03425513f, 0.09368968f, 0.11760726f, 0.02449577f, 0.16874444f, -0.11042388f, 0.06710728f, -0.03830153f, 
    -0.00474109f, 0.04574414f, 0.02618161f, -0.02544344f, 0.07689221f, 0.05880965f, 0.07572692f, 0.04571642f, 
    0.05091707f, -0.01679273f, 0.11515187f, 0.02806802f, 0.08082120f, -0.04969175f, -0.03629263f, 0.10595247f, 
    -0.02271193f, -0.47507700f, 0.10616180f, -0.16930282f, -0.05326477f, 0.16168170f, 0.00262635f, 0.16435568f, 
    0.00376501f, 0.03981586f, 0.02071566f, 0.02789555f, 0.00088211f, -0.01398261f, 0.01003397f, -0.02577430f, 
    -0.07367852f, 0.01673486f, 0.09479371f, 0.00556330f, 0.11888292f, 0.26736805f, 0.05196591f, 0.10802472f, 
    0.08658469f, 0.14875655f, -0.13100776f, 0.01411607f, 0.05019103f, -0.01712785f, 0.00626503f, 0.11319679f, 
    0.03237471f, 0.07901846f, 0.00243119f, 0.01898632f, -0.03438735f, 0.00215007f, -0.02277640f, -0.04909061f, 
    0.06198502f, 0.16195191f, 0.06793934f, 0.01638790f, 0.06074478f, 0.04095421f, 0.05195783f, 0.05513049f, 
    -0.05982690f, 0.11885082f, 0.08937830f, 0.14418027f, 0.06549641f, 0.04917119f, 0.03643347f, -0.05534877f, 
    -0.09265456f, 0.03015549f, -0.09512396f, 0.04053357f, 0.14710402f, -0.01533109f, -0.29870269f, -0.01207153f, 
    -0.08270030f, -0.13098125f, -0.08482955f, 0.03524064f, 0.01654598f, -0.09024556f, 0.07896205f, -0.09397429f, 
    0.13912769f, -0.00301103f, -0.05191509f, 0.09268167f, 0.02994418f, -0.12826945f, -0.14348088f, 0.09270823f, 
    0.03050276f, 0.27743587f, -0.00674031f, -0.02255227f, -0.01121097f, -0.04028153f, -0.03815835f, 0.04455819f, 
    -0.06101324f, 0.02003460f, 0.03645535f, 0.05243681f, -0.02646121f, 0.05384109f, 0.03211384f, -0.07874005f, 
    0.00174440f, -0.08346273f, -0.11992877f, 0.02476906f, -0.11032008f, 0.15273221f, -0.22392210f, -0.15112184f, 
    0.03065173f, -0.21239284f, 0.07250387f, 0.05459527f, 0.12938839f, 0.03620774f, 0.07101966f, 0.06279550f, 
    0.11230356f, -0.01635831f, 0.06846400f, 0.12124798f, 0.02077778f, 0.05367452f, 0.13650629f, 0.09459286f, 
    0.20561530f, -0.32149309f, 0.04075546f, 0.07372252f, 0.00266739f, -0.13873801f, -0.04917863f, 0.09418868f, 
    -0.09269218f, 0.15569220f, -0.00654684f, -0.05072136f, 0.13670512f, -0.06809445f, -0.07705927f, 0.03940118f, 
    -0.06814583f, 0.15476978f, 0.00240222f, 0.12903015f, -0.09992974f, 0.04003236f, -0.03234754f, -0.08221377f, 
    -0.05713739f, 0.11895298f, 0.08128271f, 0.10080881f, 0.13125518f, -0.03385511f, 0.03799174f, 0.07955583f, 
    0.01268706f, 0.17365274f, 0.03554246f, -0.03656740f, -0.02774831f, 0.13201067f, -0.01763670f, -0.05148529f, 
    0.51313519f, 0.01533434f, -0.10410289f, -0.00912905f, -0.00884660f, -0.09731203f, -0.08584319f, -0.12749565f, 
    0.08549599f, 0.09593189f, 0.04374646f, -0.11241892f, -0.01509393f, -0.06148446f, 0.01012795f, 0.08453254f, 
    0.04363882f, -0.03646713f, 0.00537575f, 0.07335296f, -0.06155436f, -0.67673689f, 0.16145633f, -0.07625382f, 
    0.10823479f, 0.00154154f, -0.17122978f, 0.08885705f, 0.06583389f, 0.03368765f, 0.05937385f, 0.01582621f, 
    0.01552199f, 0.00114887f, -0.07477667f, 0.05995626f, 0.03323162f, -0.02816899f, 0.02511071f, -0.03054827f, 
    -0.07541366f, 0.06859528f, 0.06630432f, 0.06341062f, 0.10763772f, 0.03255266f, -0.00219183f, 0.02863863f, 
    -0.06580052f, 0.00254506f, -0.03937982f, 0.07994021f, 0.03427804f, -0.01463545f, 0.00477374f, 0.02857546f, 
    -0.07168229f, 0.02406215f, 0.02128875f, -0.09542739f, 0.68520391f, -0.42528296f, -0.00610690f, -0.00840708f, 
    -0.04037905f, 0.08298706f, -0.01610566f, 0.00848208f, -0.02639326f, 0.08821661f, 0.11552081f, 0.08136514f, 
    -0.06049852f, 0.05839008f, 0.04626993f, 0.15106246f, -0.00040197f, -0.03111254f, -0.08768775f, -0.02350100f, 
    0.19851668f, 0.05591623f, 0.05636426f, -0.07865520f, -0.06947833f, 0.12223987f, 0.11403140f, -0.05843852f, 
    0.10125954f, -0.02911394f, 0.05187180f, 0.05760881f, 0.03235263f, -0.07305261f, -0.09931578f, 0.13963872f, 
    0.05937228f, -0.09476555f, 0.06558366f, 0.02665088f, 0.28656304f, 0.28663334f, -0.06996004f, -0.08584525f, 
    -0.17006443f, 0.12082644f, 0.15033688f, -0.00280539f, 0.13617118f, 0.02386538f, 0.07548119f, 0.13020091f, 
    0.02490180f, -0.00269654f, -0.20617510f, 0.09460000f, 0.11590109f, -0.02773915f, 0.08422123f, -0.12315828f, 
    -0.11212920f, -0.15688930f, -0.23632947f, -0.06166271f, 0.06137327f, -0.06789100f, -0.01302793f, 0.02481367f, 
    -0.05083071f, -0.03840143f, 0.04143228f, 0.04967667f, -0.04487202f, -0.06259068f, 0.09307525f, 0.01071106f, 
    0.01486134f, 0.10204425f, -0.03834455f, -0.09010097f, 0.20041989f, 0.43694746f, -0.20896856f, -0.15199719f, 
    0.03994713f, 0.06869721f, 0.04976371f, -0.03243379f, -0.05972898f, 0.03260401f, 0.06656399f, 0.02769239f, 
    0.00497399f, 0.01157709f, 0.00389846f, 0.10110719f, -0.03347098f, 0.02182192f, -0.09270336f, 0.03697813f, 
    0.65667558f, -0.28048259f, 0.01071660f, -0.04195354f, -0.23063149f, -0.10036646f, -0.13234335f, 0.02885141f, 
    0.03749776f, 0.00676316f, 0.02711193f, 0.00186657f, 0.08561473f, 0.06997159f, -0.02135613f, -0.06901759f, 
    -0.05523473f, -0.07123745f, -0.08616955f, 0.00396441f, 0.10511878f, -0.12608548f, -0.11660133f, 0.00778704f, 
    -0.23560061f, -0.16248846f, -0.01773206f, 0.14484225f, 0.05477029f, 0.10283616f, 0.01078602f, -0.06848910f, 
    0.07482897f, -0.03024618f, 0.09996972f, 0.03176929f, -0.08752102f, -0.01878910f, 0.09376698f, 0.14113468f, 
    0.02526397f, 0.28280294f, -0.19397993f, -0.08299149f, 0.25193030f, 0.02961243f, 0.02507045f, 0.04108818f, 
    -0.06312748f, 0.09060241f, 0.07618215f, 0.03434955f, 0.06130328f, 0.06131307f, 0.09047069f, 0.02596284f, 
    -0.05364669f, 0.07190853f, -0.10187218f, 0.07451001f, 0.29645565f, 0.14264502f, -0.23247583f, -0.03595047f, 
    -0.08011294f, -0.04671215f, 0.03742604f, -0.05972737f, 0.02306125f, 0.09231462f, 0.02683962f, 0.02288225f, 
    0.11856671f, -0.01541304f, 0.09171646f, 0.08229770f, -0.09194110f, 0.04019313f, -0.05787720f, 0.15746352f, 
    0.19760995f, 0.16226238f, -0.00582950f, 0.09628262f, -0.06221664f, -0.07754328f, 0.13236931f, 0.05276002f, 
    -0.06452367f, 0.09647180f, -0.08194887f, 0.02956394f, -0.01129069f, 0.03195469f, 0.02898985f, -0.00851599f, 
    0.08847882f, -0.02376673f, 0.03786016f, -0.03331359f, 0.04941286f, 0.23249190f, 0.07672731f, 0.02219245f, 
    -0.03743402f, 0.02168866f, 0.01642282f, -0.07554268f, 0.03720306f, -0.02609864f, 0.07683206f, 0.02063551f, 
    -0.13310695f, 0.02901389f, -0.00816729f, 0.11084446f, 0.04971658f, -0.01222872f, 0.04833746f, -0.10058165f, 
    -0.09894527f, 0.16009854f, -0.06646367f, -0.23517610f, 0.04791908f, 0.04727360f, -0.00471230f, -0.00886428f, 
    0.16497929f, 0.06804556f, 0.02440869f, -0.14904189f, 0.08921766f, 0.03967398f, -0.10418268f, -0.14031371f, 
    -0.06101105f, 0.04821419f, 0.10480987f, -0.08743473f, -0.14875080f, 0.36017442f, 0.01175187f, -0.12713440f, 
    0.07688637f, 0.14723721f, 0.04596634f, 0.02143106f, 0.07243925f, -0.01106380f, 0.07463284f, -0.03076175f, 
    0.02899504f, 0.02078587f, -0.12107315f, -0.01885981f, 0.05156016f, -0.03033721f, 0.08098184f, -0.06216746f, 
    0.82184619f, 0.40394992f, -0.19900613f, 0.13253924f, 0.30372781f, -0.02496632f, -0.06262714f, 0.02159451f, 
    -0.02451608f, 0.04669415f, -0.03352750f, 0.00108523f, 0.14585361f, -0.00931743f, 0.07376663f, 0.11961798f, 
    -0.03783872f, 0.01198582f, 0.00696083f, 0.00222233f, -0.30006054f, -0.08122393f, 0.19258021f, 0.05538986f, 
    -0.10717984f, -0.14539431f, 0.07978571f, -0.08880931f, -0.07985155f, -0.08067442f, -0.02667199f, 0.01354086f, 
    -0.00723112f, -0.04858341f, -0.03175034f, 0.06278765f, -0.04751655f, 0.02201557f, 0.02206292f, 0.00969575f, 
    0.13124770f, -0.23576167f, 0.10585979f, -0.10679092f, 0.14224595f, -0.05170906f, 0.00436297f, 0.05504714f, 
    -0.03496430f, -0.01503735f, -0.05635590f, 0.05265974f, -0.08039503f, 0.00616375f, -0.04830800f, 0.02194364f, 
    0.02801124f, 0.03194743f, -0.03431688f, -0.06993227f, -0.51488036f, -0.23772413f, 0.11169387f, 0.09912815f, 
    -0.06444295f, -0.01074439f, 0.20139049f, 0.09421701f, 0.04536133f, -0.00120291f, 0.11438308f, 0.07100569f, 
    0.00264941f, -0.01760853f, 0.00615373f, 0.07625338f, -0.07064242f, 0.13532484f, 0.00740621f, -0.01635004f, 
    -0.14628498f, -0.13693558f, 0.25664344f, 0.11499415f, 0.05940372f, -0.00500806f, -0.06802987f, -0.03206491f, 
    0.00165980f, -0.00696130f, -0.00814353f, -0.01874867f, 0.05726006f, -0.06122972f, -0.05074221f, -0.07670476f, 
    0.05052384f, 0.05099854f, -0.04004724f, -0.03269586f, -0.07186872f, 0.08664131f, -0.10712455f, 0.06950007f, 
    0.45352471f, 0.11111434f, -0.02914330f, 0.00126913f, 0.07306024f, -0.01726916f, -0.05732431f, -0.10056774f, 
    -0.00300469f, 0.05952672f, 0.07620683f, -0.01642481f, -0.02595651f, 0.06859010f, 0.01956300f, 0.02859576f, 
    0.41540435f, 0.17906667f, -0.05761059f, 0.26508066f, 0.45813406f, -0.01383019f, -0.05783296f, -0.01290721f, 
    -0.01072322f, 0.01152882f, 0.04494559f, -0.01901528f, 0.12552035f, 0.01044104f, -0.01797775f, -0.04170528f, 
    0.00805268f, 0.05426509f, -0.09536502f, -0.15298109f, -0.11275283f, 0.03293298f, 0.10541426f, -0.10243721f, 
    -0.04467702f, -0.04452626f, 0.01778636f, -0.04067084f, 0.10288622f, -0.14436349f, 0.03033557f, 0.06082064f, 
    -0.05923069f, -0.07851944f, 0.09218743f, 0.01761165f, 0.03642637f, 0.06680293f, -0.02104781f, 0.00394226f, 
    0.12559126f, 0.22490378f, -0.20005468f, -0.15447859f, 0.63997895f, 0.12558781f, -0.10418597f, 0.00602438f, 
    0.10527843f, -0.04637304f, 0.00558179f, 0.09963028f, 0.09988958f, 0.04050941f, -0.13616818f, -0.06859342f, 
    0.02813752f, 0.08839496f, 0.10908131f, -0.02839718f, 0.53620416f, 0.25504369f, -0.10214178f, 0.16732709f, 
    0.25409025f, -0.00433227f, -0.07559284f, -0.05720675f, -0.00223949f, -0.02978788f, 0.04957055f, 0.03591178f, 
    0.10946269f, -0.01334093f, -0.05570309f, 0.03295935f, 0.07012535f, 0.02119617f, -0.04076395f, -0.03485468f, 
    0.54333144f, 0.12052130f, -0.10260113f, 0.24391288f, -0.05802545f, -0.10301197f, -0.02600409f, 0.11229622f, 
    -0.06803050f, -0.01515578f, 0.15689065f, 0.04023567f, -0.01398535f, 0.00845923f, -0.08143111f, -0.01635197f, 
    -0.05942950f, 0.07007195f, -0.10194433f, -0.02503153f, -0.35159811f, 0.21832268f, 0.01483562f, -0.35143203f, 
    -0.05056868f, 0.15171517f, -0.05534307f, 0.06751619f, -0.12521867f, -0.20732120f, -0.05057240f, -0.13168578f, 
    0.16065660f, 0.00939898f, -0.08566663f, 0.00612437f, 0.07964456f, 0.02798489f, -0.01749551f, 0.00409141f, 
    0.54063153f, 0.25646341f, -0.17341377f, 0.20525663f, -0.03124348f, -0.00986132f, -0.07588536f, 0.01597552f, 
    -0.00992628f, 0.03783219f, 0.13721530f, 0.02122329f, 0.02669447f, -0.00700749f, -0.04028237f, -0.02793962f, 
    0.04164049f, 0.04300870f, -0.00951487f, -0.00631891f, -0.11331424f, -0.37703899f, 0.30038512f, -0.03843198f, 
    0.07215599f, -0.05183520f, 0.13966282f, -0.05539555f, 0.00923202f, -0.00758571f, -0.06257173f, 0.04372887f, 
    -0.00162560f, -0.04293265f, -0.00718352f, -0.16000879f, 0.09828795f, 0.09229393f, 0.00473091f, -0.01551872f, 
    -0.02597024f, -0.28525004f, 0.28843230f, 0.24895582f, 0.00212690f, -0.01232980f, 0.21960744f, 0.11930307f, 
    0.01135553f, -0.01212739f, -0.02781949f, -0.03226342f, 0.00623159f, 0.03976797f, 0.06786320f, 0.01645806f, 
    -0.02535456f, 0.06925286f, 0.00865652f, 0.04179924f, 0.36072066f, 0.45202932f, -0.15483801f, 0.09663756f, 
    -0.04024550f, -0.06923131f, 0.07970124f, -0.08518737f, 0.02179748f, 0.06224689f, -0.13242047f, -0.02507519f, 
    0.03679042f, 0.01948263f, 0.09018987f, 0.05073481f, -0.05030973f, -0.09151624f, 0.00513021f, 0.07679514f, 
    -0.17080459f, 0.07687470f, 0.04819340f, -0.20613979f, -0.04782211f, 0.11829495f, 0.01578929f, -0.01475004f, 
    -0.06504759f, -0.02250591f, 0.00311832f, -0.07027094f, 0.01156734f, 0.04499826f, 0.01958575f, -0.09513354f, 
    0.03584603f, 0.02419384f, -0.13114829f, -0.10311305f, 0.37356436f, -0.25094262f, 0.00900855f, -0.23303239f, 
    0.07766793f, -0.01362671f, 0.09498477f, 0.00134239f, -0.17426680f, 0.08364172f, 0.07845797f, 0.09318354f, 
    -0.12155844f, 0.02305348f, -0.11998726f, -0.00566305f, 0.15755534f, -0.06043501f, 0.06824483f, -0.10073982f, 
    0.03962907f, 0.15374330f, -0.01143689f, 0.12099497f, -0.04449460f, 0.00693070f, 0.01032202f, -0.03518810f, 
    -0.04025420f, 0.09594440f, 0.05426731f, 0.00186357f, -0.00910085f, -0.01051794f, 0.02960713f, -0.04085678f, 
    -0.05818928f, 0.00979011f, -0.02394848f, -0.01950376f, 0.24220155f, -0.11940241f, 0.17324452f, -0.03459245f, 
    -0.06371111f, -0.05868435f, 0.11197478f, 0.00710503f, 0.07172409f, -0.13024746f, -0.07043921f, 0.07601069f, 
    0.03592418f, -0.04439279f, 0.09814966f, 0.04400598f, 0.02650883f, 0.01824000f, -0.20248961f, -0.00370381f, 
    -0.15369055f, -0.13006133f, -0.09733064f, 0.00821353f, 0.08320795f, 0.08522444f, -0.02096761f, -0.07969477f, 
    0.03230834f, -0.03437048f, 0.02152173f, -0.01018627f, -0.00918740f, 0.16863175f, 0.06307136f, 0.11712873f, 
    -0.03514529f, 0.05620120f, -0.06101104f, -0.04556486f, -0.07017283f, -0.21299589f, -0.13625182f, -0.02828735f, 
    0.19793993f, 0.17622720f, 0.01429603f, -0.06901442f, 0.04578482f, -0.08062555f, 0.00709655f, 0.00373611f, 
    -0.05068290f, 0.10976809f, 0.11572167f, 0.05170479f, -0.00188011f, 0.04745634f, -0.01733352f, 0.03297950f, 
    -0.10052188f, 0.17233661f, -0.01438780f, -0.03877639f, 0.06886485f, 0.09277114f, -0.06041110f, -0.08848506f, 
    -0.00197615f, 0.03000037f, 0.02429469f, -0.02839251f, 0.04160125f, -0.00496633f, -0.09988467f, -0.02223379f, 
    -0.02336674f, -0.04239336f, 0.02268900f, 0.01136390f, 0.47753352f, 0.30875269f, -0.20813124f, 0.03485028f, 
    -0.06607804f, 0.01921334f, 0.09497897f, -0.05898973f, 0.02947094f, -0.01231569f, 0.02980334f, 0.04216979f, 
    -0.02386651f, 0.05148565f, 0.16236433f, -0.01723446f, 0.09227300f, 0.04961687f, 0.04283841f, 0.06673492f, 
    0.22373228f, -0.00355897f, -0.01604320f, -0.22344601f, -0.16224268f, 0.05002574f, 0.26392767f, 0.01927669f, 
    -0.04389456f, -0.15546726f, 0.05670808f, -0.05095831f, -0.01582533f, 0.00891002f, 0.11219740f, 0.05311161f, 
    0.19997698f, -0.13960563f, -0.02838263f, 0.06902748f, -0.46324483f, 0.22558311f, 0.05665600f, -0.19388366f, 
    0.12720495f, 0.05805286f, -0.06691841f, -0.00582609f, -0.07389598f, 0.01393892f, 0.11840928f, -0.01522597f, 
    0.01946683f, 0.03980250f, -0.06216123f, 0.10471566f, -0.04579273f, -0.09920996f, 0.03683979f, -0.05798361f, 
    0.23210824f, 0.06865194f, 0.02023306f, 0.12521692f, -0.05731160f, -0.03166826f, -0.02705413f, -0.02424820f, 
    -0.04460685f, 0.01074208f, 0.06720657f, -0.00511424f, 0.06259497f, -0.07851603f, 0.03008190f, -0.01135767f, 
    0.02662955f, -0.00266469f, 0.07251087f, -0.03359812f, -0.11766379f, 0.20678681f, -0.01521292f, -0.06278002f, 
    -0.04906007f, 0.03910767f, -0.09043312f, 0.03725042f, -0.02548810f, -0.07394301f, 0.00000856f, -0.04089480f, 
    0.03909279f, -0.07705023f, 0.03660265f, -0.05596751f, -0.18060026f, -0.01817816f, 0.05859031f, -0.12937516f, 
    -0.03478846f, -0.02281156f, -0.03609906f, -0.03015235f, 0.00291779f, -0.03216817f, -0.03008788f, -0.03592291f, 
    0.02743848f, -0.03526103f, 0.00577803f, 0.00613640f, 0.02319711f, 0.01438396f, 0.02893674f, 0.03513796f, 
    0.01499517f, 0.02346150f, 0.02953566f, 0.02911148f, -0.02659067f, 0.03068092f, -0.03891741f, -0.03072638f, 
    0.00273696f, -0.03176286f, 0.02750192f, -0.03917864f, -0.04692528f, -0.04307092f, -0.03964315f, -0.00516138f, 
    -0.01373785f, -0.03320302f, 0.00817481f, -0.01459964f, 0.00612580f, -0.03045777f, 0.00673497f, -0.01902611f, 
    0.00510400f, -0.01082955f, -0.03582554f, 0.04437792f, -0.04544691f, -0.04247443f, 0.00306723f, -0.03938587f, 
    -0.01252122f, 0.03487694f, -0.02465753f, -0.00362918f, -0.03669753f, 0.04172562f, -0.00456998f, 0.03042357f, 
    0.02804475f, 0.00225388f, -0.00934955f, 0.04073287f, 0.02465275f, -0.02296189f, 0.00564448f, 0.02394165f, 
    -0.03896133f, -0.03472076f, -0.01982704f, -0.02022399f, 0.02769130f, -0.02384613f, 0.01776534f, -0.02256431f, 
    -0.00583790f, 0.00891751f, -0.04087654f, -0.04355006f, -0.01294803f, 0.02013901f, 0.02143348f, -0.01732926f, 
    0.01386377f, 0.00479894f, 0.01778274f, 0.01175284f, -0.02117151f, 0.01783102f, 0.02191096f, 0.00907415f, 
    -0.04201356f, -0.00732115f, 0.02615929f, 0.02946556f, -0.01947600f, -0.04257511f, -0.01748768f, -0.02452976f, 
    -0.02248161f, 0.01807954f, -0.02872647f, -0.03850486f, 0.03130351f, -0.01742358f, -0.00338254f, 0.02064388f, 
    -0.01785945f, -0.01429950f, -0.01538151f, -0.04116262f, 0.00856733f, 0.00007213f, -0.04469297f, 0.01071438f, 
    -0.03677917f, -0.04003141f, -0.01433168f, -0.01650604f, -0.03976163f, -0.03468367f, -0.02665881f, 0.02512187f, 
    0.01500400f, 0.00444980f, -0.02550652f, 0.01536224f, -0.04490449f, 0.02437368f, 0.01294413f, 0.00132069f, 
    0.01992872f, 0.01222843f, -0.02563388f, 0.02932522f, 0.00890237f, 0.00369914f, -0.03375456f, 0.03096670f, 
    -0.04676335f, -0.04012732f, -0.00724316f, -0.00204301f, 0.01254506f, -0.02032156f, -0.03318707f, -0.02775188f, 
    -0.02925801f, -0.03312675f, -0.02326751f, 0.00473487f, -0.03790014f, 0.02933968f, -0.03270512f, -0.00666162f, 
    0.00478196f, -0.01967350f, 0.00415637f, 0.00617745f, 0.01614482f, 0.02033068f, -0.00994129f, 0.00899140f, 
    0.01099316f, -0.03618019f, -0.01002881f, -0.02985578f, -0.00764537f, 0.02128203f, -0.02852957f, -0.03023465f, 
    -0.00792768f, -0.04647014f, -0.04629911f, -0.03964024f, 0.02771191f, -0.01621282f, 0.00257272f, 0.01342157f, 
    -0.03659520f, 0.01141185f, 0.02474847f, -0.01083867f, 0.00647994f, -0.03871664f, -0.00793882f, 0.01439937f, 
    0.02608044f, 0.02890060f, -0.01318390f, 0.00381865f, 0.00005419f, 0.03375396f, -0.01017307f, 0.03075678f, 
    -0.00240482f, -0.00589711f, -0.03595831f, -0.01130666f, -0.02468106f, -0.00393227f, -0.00582807f, -0.02062933f, 
    -0.03972872f, -0.03704232f, -0.01374330f, 0.02572494f, -0.01710739f, -0.03554515f, 0.02323856f, -0.02261081f, 
    0.00670579f, -0.02498390f, -0.03564745f, 0.01836439f, 0.01453791f, 0.02580060f, 0.02357570f, -0.03831344f, 
    -0.01412739f, 0.01649470f, -0.04116074f, -0.02736664f, 0.01937786f, -0.00097245f, -0.02047514f, 0.02194716f, 
    -0.01707230f, -0.02948366f, 0.02167569f, 0.00333327f, -0.02803859f, -0.04549790f, -0.04412385f, 0.01476510f, 
    0.01590484f, -0.04748037f, -0.01803654f, 0.00097447f, 0.01869075f, -0.00670369f, -0.04419313f, -0.01838984f, 
    -0.00630815f, -0.01085543f, -0.00373311f, 0.03141190f, -0.01139198f, -0.03825443f, 0.01212349f, 0.00304835f, 
    0.03582869f, 0.00188849f, -0.00551960f, 0.00576451f, -0.00805940f, -0.02625974f, -0.02913079f, 0.01343369f, 
    -0.02347518f, 0.00674097f, -0.00333106f, 0.00652938f, -0.03960366f, -0.04038920f, 0.01957847f, 0.02935454f, 
    0.02086078f, 0.01235579f, 0.02394550f, 0.01704793f, -0.01136275f, -0.01948549f, -0.03779437f, -0.01051099f, 
    -0.00901865f, 0.01630760f, -0.00969108f, 0.02374971f, 0.02551921f, -0.02688952f, -0.03716166f, 0.00887492f, 
    -0.00214614f, -0.03679372f, -0.02442134f, -0.02892466f, 0.00709028f, -0.01750471f, -0.03643515f, -0.00309226f, 
    0.01867210f, 0.02491441f, -0.04626829f, 0.02088208f, 0.01187182f, 0.01364760f, -0.04330008f, 0.00959805f, 
    -0.02291787f, 0.00565928f, 0.02054113f, -0.04269234f, 0.02959612f, 0.00479585f, 0.02615975f, 0.01160442f, 
    0.00956001f, -0.02527421f, 0.02746904f, 0.00626442f, -0.03125637f, 0.00530267f, 0.00115231f, 0.01215342f, 
    -0.03837554f, -0.00122430f, 0.03146674f, 0.00371848f, 0.02015328f, 0.00885067f, 0.00583442f, -0.01721835f, 
    0.01585233f, 0.01451053f, -0.03607856f, -0.01305538f, 0.02710590f, 0.02144075f, -0.01890025f, 0.00600135f, 
    -0.01087696f, -0.04365281f, -0.02061903f, 0.01540712f, -0.01513838f, 0.01170887f, -0.01438246f, 0.03059852f, 
    -0.02813260f, -0.00504438f, -0.04034901f, -0.02588093f, 0.00489521f, 0.04144535f, 0.02481564f, 0.00058692f, 
    0.00692249f, -0.02129498f, -0.00628336f, 0.01012755f, -0.03856501f, -0.01102055f, -0.03198523f, -0.01175820f, 
    0.00000509f, 0.00468479f, 0.01645540f, 0.02641582f, 0.00547106f, 0.02571309f, -0.00858581f, -0.02627680f, 
    -0.01169379f, -0.03882621f, 0.00425399f, 0.00091419f, -0.00311264f, 0.02410418f, -0.01952046f, -0.01126002f, 
    -0.00448344f, -0.02120992f, 0.00789161f, -0.01836707f, -0.01366149f, -0.02740912f, 0.02667546f, 0.02667312f, 
    0.01841724f, 0.01246643f, 0.03087174f, 0.01582392f, -0.00337603f, -0.03588921f, -0.01709650f, 0.01797629f, 
    -0.01195632f, 0.01464917f, -0.01295498f, 0.01576440f, -0.01109242f, 0.00798771f, -0.02783096f, 0.02995309f, 
    -0.03133863f, -0.00700425f, -0.02955026f, -0.00201237f, -0.03227955f, -0.01984709f, 0.02781959f, 0.01018819f, 
    -0.01018857f, -0.00272710f, -0.03342953f, -0.00524129f, 0.02769981f, -0.00324044f, -0.03963747f, 0.01487579f, 
    -0.00349225f, -0.03556694f, 0.02730378f, 0.02326073f, 0.00981421f, -0.00474797f, 0.00245509f, -0.01832091f, 
    -0.00161420f, 0.02460267f, 0.01767036f, 0.00392116f, -0.04435736f, 0.00658916f, 0.00847028f, 0.01747957f, 
    -0.03709897f, -0.02431160f, -0.02630680f, -0.02296630f, 0.03010458f, -0.03394746f, 0.01871722f, -0.04456372f, 
    -0.03236072f, 0.00983351f, -0.04256765f, 0.03305256f, 0.00906639f, -0.02667876f, 0.00170640f, 0.01932302f, 
    0.02941420f, 0.01149802f, 0.01401708f, 0.00987486f, 0.02744942f, 0.02090255f, -0.00120655f, 0.00056201f, 
    -0.00753027f, -0.04107072f, 0.02578868f, 0.00272050f, 0.01848556f, -0.01991321f, -0.04487110f, 0.03955010f, 
    -0.01438072f, 0.02042705f, 0.01017082f, -0.03142327f, -0.04036150f, -0.00013240f, -0.02890055f, 0.00634098f, 
    0.00964559f, 0.02073354f, 0.00538341f, -0.03633491f, 0.02222048f, -0.01801359f, -0.00937038f, 0.00695967f, 
    -0.03804021f, -0.01055623f, -0.03795340f, 0.01027019f, -0.02955223f, 0.01872839f, 0.03249656f, -0.01618825f, 
    0.00624168f, 0.00997291f, -0.03403212f, -0.03498646f, 0.00072087f, -0.01290314f, 0.00486368f, -0.04371417f, 
    -0.04019576f, -0.03127217f, -0.01489971f, -0.01309944f, 0.00924827f, 0.02649436f, 0.02996717f, 0.04390392f, 
    -0.00943997f, 0.00351219f, -0.02399097f, -0.04421876f, -0.01367758f, -0.00372511f, -0.04238364f, -0.02634148f, 
    -0.02905548f, -0.02317671f, 0.00859505f, 0.02756811f, -0.02106025f, 0.01628757f, -0.03164951f, 0.01108645f, 
    -0.02176775f, -0.04494137f, -0.02768792f, 0.02243250f, 0.01504952f, -0.02042034f, 0.03319559f, -0.02166880f, 
    0.00307619f, -0.01194208f, -0.01622505f, 0.01354257f, -0.03292611f, -0.04179873f, 0.00861470f, 0.03845392f, 
    -0.03017257f, 0.01571186f, -0.03063445f, 0.00757962f, -0.02363522f, -0.03095557f, 0.02890902f, 0.02083832f, 
    0.01891908f, -0.00918042f, -0.03060237f, -0.02171256f, 0.01868714f, 0.03777006f, -0.02416985f, -0.04496254f, 
    -0.02253433f, -0.04212842f, 0.02295869f, 0.01079571f, 0.00015757f, 0.01221949f, 0.00019690f, -0.02897532f, 
    -0.01174935f, 0.00529738f, 0.02273506f, -0.02202801f, 0.02776041f, -0.00378198f, 0.02067286f, -0.03116464f, 
    0.02564883f, -0.01681190f, 0.00758915f, 0.01606725f, 0.00661758f, -0.01057390f, 0.00755916f, -0.01360447f, 
    0.01733754f, -0.03079493f, -0.02021423f, -0.03309794f, -0.02253747f, -0.02463106f, -0.04362701f, -0.00945453f, 
    0.03131598f, -0.03661932f, -0.02726304f, -0.00662313f, -0.01163391f, -0.02523947f, -0.01284543f, 0.04066712f, 
    0.03946523f, -0.02703372f, -0.01084066f, -0.01324225f, -0.03195741f, 0.00446669f, 0.00197492f, -0.03341914f, 
    -0.04513493f, -0.01456128f, 0.03655460f, -0.02802319f, -0.01641183f, 0.00261615f, -0.00022127f, 0.00996169f, 
    0.00407748f, -0.01591953f, -0.03990680f, 0.01061878f, -0.01062039f, -0.00396737f, -0.02552151f, -0.00069619f, 
    0.02563694f, 0.01400683f, -0.00048133f, -0.01802623f, -0.03224992f, 0.01446762f, -0.01598518f, 0.00124529f, 
    0.00601185f, 0.00070924f, 0.00094069f, -0.02532461f, 0.02669627f, 0.00201233f, 0.02265432f, 0.00875675f, 
    -0.03014387f, -0.03488370f, -0.00248502f, 0.00485144f, -0.01510242f, 0.01726102f, -0.00566696f, -0.01684932f, 
    -0.03438212f, -0.01708607f, 0.00289506f, -0.03555170f, 0.02508588f, -0.00188228f, 0.03208276f, -0.03086481f, 
    0.06359435f, -0.17888255f, -0.14404821f, -0.11407779f, -0.30998316f, 0.25869006f, -0.09682248f, 0.11773778f, 
    0.05074097f, 0.22668076f, 0.02540028f, -0.09425934f, 0.16420542f, -0.01551759f, -0.08785424f, 0.12024343f, 
    -0.09484490f, -0.05320555f, -0.05346118f, 0.00488186f, -0.15983555f, -0.18382460f, 0.04308450f, -0.16373169f, 
    -0.28791842f, 0.05752438f, 0.05576015f, 0.05174654f, -0.03469776f, 0.11361517f, -0.03537219f, 0.01592270f, 
    0.08158033f, 0.04029725f, 0.10386878f, -0.07388799f, 0.06816716f, -0.04287281f, -0.04673286f, 0.03667589f, 
    0.38195342f, 0.07670271f, -0.05889430f, 0.28812382f, 0.08508530f, -0.00650612f, 0.03965543f, 0.01404583f, 
    -0.05973202f, -0.03606993f, 0.18662407f, 0.15642942f, 0.01628011f, 0.06935030f, 0.02927426f, 0.01034488f, 
    0.08310297f, 0.07827112f, -0.05941659f, 0.24866100f, -0.01686986f, 0.03565606f, -0.01749937f, 0.03815692f, 
    -0.21659307f, -0.09292568f, 0.15195009f, 0.22747827f, 0.03497715f, 0.06691284f, 0.04762986f, 0.00885432f, 
    -0.00649410f, -0.07112583f, 0.27284065f, 0.08655888f, -0.09124433f, 0.03464897f, -0.04222191f, 0.07487882f, 
    -0.33817375f, 0.21778961f, 0.12269152f, 0.00108655f, 0.26947412f, 0.04188115f, 0.11536919f, 0.04993413f, 
    -0.05703692f, -0.04559772f, 0.04969945f, 0.15689932f, 0.04279562f, -0.09730700f, 0.01988141f, 0.01451283f, 
    -0.05226352f, 0.08180856f, 0.02187570f, 0.07265884f, -0.07426266f, 0.15471537f, -0.12299991f, -0.11293842f, 
    0.07741815f, -0.01272171f, -0.09052924f, 0.10404683f, 0.20618674f, 0.05707346f, 0.04687282f, -0.05760052f, 
    -0.01612462f, 0.10724904f, 0.06531737f, -0.10292031f, 0.18596976f, -0.02746277f, -0.04604607f, 0.03798674f, 
    -0.73831636f, 0.19943996f, 0.12673715f, -0.02079960f, -0.19926125f, 0.07220969f, 0.06298707f, 0.02882800f, 
    0.01462410f, 0.07373442f, -0.02199535f, -0.06541225f, 0.03399740f, 0.05779134f, 0.07893216f, -0.09673153f, 
    -0.05888576f, -0.05793699f, -0.04950238f, -0.02161016f, -0.12710656f, -0.13179231f, 0.01676724f, -0.11818928f, 
    0.22464834f, 0.03267121f, -0.01250293f, -0.13905875f, 0.14284348f, -0.01137976f, -0.08497348f, -0.00391310f, 
    0.15120880f, -0.06410203f, -0.07121310f, -0.03352563f, -0.13033105f, -0.09341698f, -0.17753848f, -0.09637532f, 
    0.06612435f, 0.24236311f, -0.19288595f, -0.03971143f, -0.10368434f, 0.06823468f, 0.14805669f, 0.04147827f, 
    0.08511429f, 0.02512850f, 0.02460720f, 0.03707480f, -0.07388262f, 0.03852715f, 0.01590026f, -0.05393779f, 
    0.04489233f, -0.06353453f, -0.04479560f, 0.07388661f, -0.01539499f, 0.13664946f, 0.18688385f, 0.27365112f, 
    0.50188267f, 0.14115274f, 0.01372318f, 0.07073172f, 0.04139708f, 0.04988596f, 0.08432733f, 0.03216916f, 
    0.04728658f, 0.02301819f, 0.06798654f, 0.08286095f, 0.04656946f, 0.11808052f, 0.13261588f, 0.06582213f, 
    -0.52210271f, 0.30416691f, 0.04542566f, -0.09161779f, 0.26893330f, 0.07530911f, 0.10437788f, -0.01769834f, 
    0.10780574f, 0.13283572f, -0.03521940f, -0.07365242f, 0.03019237f, -0.04960449f, 0.14184992f, 0.17451075f, 
    0.15710254f, -0.02950991f, 0.00059666f, -0.01093152f, -0.74056482f, 0.06555880f, -0.04228880f, 0.05514786f, 
    0.08267595f, 0.04278796f, -0.05742512f, 0.05718664f, 0.02117255f, 0.02593305f, -0.03728603f, 0.01055948f, 
    0.03246175f, 0.02788217f, 0.04753267f, 0.02215889f, -0.09366280f, -0.00865764f, 0.02695790f, 0.01116064f, 
    0.04720322f, 0.27356610f, -0.02705538f, 0.13365303f, 0.06523779f, 0.19657221f, -0.06972881f, 0.09585996f, 
    0.00775824f, 0.05076857f, 0.14562707f, 0.03781614f, 0.03435683f, -0.05625256f, 0.04729435f, 0.01569316f, 
    0.13637231f, 0.13088247f, 0.06661080f, 0.10096186f, -0.13065340f, -0.01462957f, 0.06021741f, -0.13369736f, 
    0.06376751f, 0.11003585f, 0.18150409f, 0.08658490f, -0.01731580f, 0.10326158f, 0.08314104f, 0.06246150f, 
    0.02704016f, -0.05699356f, 0.16952974f, 0.07398385f, 0.07345589f, -0.04564067f, 0.01638713f, 0.06303115f, 
    0.05887037f, -0.22829553f, -0.14938956f, -0.07223740f, -0.18935373f, 0.12587573f, 0.08721749f, 0.01910554f, 
    -0.01783960f, 0.07251635f, 0.05269443f, -0.02301643f, 0.08213531f, -0.04917000f, 0.01889698f, 0.15230006f, 
    -0.01905632f, -0.07797967f, -0.03138059f, -0.05322007f, 0.08594518f, 0.15083049f, -0.28058437f, 0.31218022f, 
    0.23019215f, 0.00813513f, -0.11582438f, -0.07197099f, 0.13589396f, 0.08424395f, 0.06309697f, 0.08171412f, 
    0.04826556f, -0.00904907f, 0.12559974f, 0.03433776f, 0.00726618f, -0.00294239f, 0.11558403f, -0.01542809f, 
    -0.02547462f, -0.32752880f, -0.04728974f, -0.09189072f, -0.00748794f, 0.11966746f, 0.14043735f, -0.03324870f, 
    0.00734502f, 0.03448935f, 0.11795806f, 0.04969741f, 0.04655430f, -0.02981373f, 0.09055101f, 0.16739237f, 
    -0.05217761f, -0.12599850f, 0.00484689f, 0.00397777f, 0.13507934f, 0.41837275f, -0.11317889f, 0.16191477f, 
    0.07573144f, -0.03617208f, 0.08689343f, 0.07825294f, 0.01582654f, -0.12992013f, 0.06207361f, 0.08756458f, 
    -0.06849851f, 0.04786880f, -0.00049898f, -0.00171729f, 0.08309324f, -0.20339927f, -0.02209677f, -0.03177128f, 
    0.21472315f, 0.34684458f, -0.12071891f, -0.12299670f, -0.16310810f, 0.18021461f, 0.04413782f, -0.05576825f, 
    0.08524664f, -0.03044811f, 0.10859307f, 0.11842293f, -0.07358295f, 0.06214393f, 0.12070684f, 0.06893460f, 
    0.03193721f, -0.05140326f, 0.13177334f, -0.07619911f, -0.01039951f, 0.05456391f, -0.09173850f, 0.19120847f, 
    -0.02005253f, 0.05724388f, 0.00791541f, 0.26574036f, -0.17713723f, 0.06979097f, 0.10413810f, 0.05001590f, 
    0.02380589f, -0.11750188f, 0.05044724f, 0.04249248f, 0.18175112f, 0.02765567f, -0.02057195f, 0.02748036f, 
    0.06048007f, 0.01679471f, 0.16624525f, -0.16587856f, 0.15630840f, 0.08344055f, 0.05206395f, -0.00027229f, 
    0.04718590f, -0.06441028f, -0.07977027f, 0.07775537f, 0.06972893f, 0.05062017f, -0.06810824f, -0.10026508f, 
    -0.07158687f, 0.05002791f, -0.01304959f, -0.05008733f, -0.03993358f, 0.45025095f, -0.22865376f, 0.36097017f, 
    -0.24311231f, 0.11982808f, -0.14966398f, 0.12336665f, -0.04199741f, 0.14963293f, 0.03149179f, -0.02417294f, 
    0.04496345f, 0.08097571f, 0.01468658f, -0.03311374f, 0.03858909f, 0.09690940f, -0.09188856f, 0.02760958f, 
    0.00261496f, -0.30971354f, -0.03810722f, -0.11113784f, -0.02169638f, 0.07188004f, 0.03595395f, 0.13174574f, 
    0.02757411f, 0.09139943f, 0.00048652f, -0.03760447f, 0.02386215f, -0.00627305f, 0.12199944f, 0.03119043f, 
    -0.04845491f, -0.06531669f, -0.06853510f, 0.10940403f, 0.08264755f, -0.09205927f, 0.01585251f, 0.10949288f, 
    0.09585076f, 0.01118320f, -0.05304365f, 0.17596498f, -0.04630281f, -0.04395651f, -0.00507115f, -0.14674653f, 
    0.17017591f, 0.10835849f, -0.12540016f, -0.09069222f, -0.01029391f, 0.12840582f, -0.02161221f, 0.14609650f, 
    0.17877164f, 0.19496199f, 0.12155089f, 0.13603203f, 0.04210279f, 0.07754225f, 0.05908967f, 0.11409266f, 
    0.04795067f, 0.06838232f, 0.07416271f, 0.05080873f, 0.01566135f, 0.01894983f, 0.17105314f, -0.12921079f, 
    0.07901210f, 0.09808163f, 0.02783827f, -0.00656553f, 0.27149385f, 0.11548769f, 0.12774672f, 0.31014878f, 
    0.23950599f, 0.03576079f, 0.18012744f, 0.05063070f, -0.01788008f, 0.00810009f, 0.01146765f, -0.09334667f, 
    -0.08230069f, 0.02453222f, 0.10402823f, 0.03531184f, 0.03265651f, 0.06451938f, 0.00416329f, 0.02364769f, 
    0.23924671f, 0.19248213f, 0.06520533f, 0.00997815f, -0.40265846f, -0.15777877f, 0.14356431f, 0.08700830f, 
    0.09525041f, -0.02445141f, -0.05018976f, 0.03121271f, 0.11900476f, 0.17495431f, 0.11240884f, 0.00081330f, 
    0.04468882f, 0.09060173f, 0.09242385f, 0.17911580f, -0.03232902f, -0.04473420f, 0.00829203f, 0.28823945f, 
    0.13710836f, -0.06410762f, 0.10757086f, 0.13344017f, -0.04711181f, -0.05468413f, -0.00442544f, 0.03801188f, 
    -0.08425733f, -0.10239595f, 0.11391991f, 0.07239259f, -0.01076405f, -0.08879728f, 0.07640049f, 0.03415834f, 
    -0.48794129f, -0.03960915f, -0.01341569f, 0.09458766f, 0.47076732f, 0.00434081f, -0.05578528f, 0.04785493f, 
    0.11259244f, 0.10951274f, 0.10109775f, 0.02216766f, -0.01505706f, 0.06141553f, 0.05514388f, -0.02184006f, 
    -0.00039869f, 0.16650565f, 0.07369373f, 0.09991558f, 0.28261045f, 0.01594358f, -0.32550976f, 0.05994656f, 
    0.03616771f, 0.09121995f, 0.07154305f, 0.06242108f, -0.07859799f, -0.01830904f, 0.04063824f, 0.18790412f, 
    0.06551524f, -0.12556130f, -0.04040144f, -0.04726148f, 0.05989724f, 0.08499508f, -0.01740596f, 0.09581691f, 
    0.05997440f, 0.06040869f, -0.07257909f, 0.06347544f, -0.24745955f, -0.06389193f, 0.11543176f, 0.01924134f, 
    0.04415987f, -0.01481640f, -0.00095598f, 0.10504441f, 0.01659391f, 0.02575446f, 0.12314580f, -0.06635711f, 
    0.04938246f, -0.04402744f, 0.02044284f, 0.10460433f, -0.25858042f, 0.40546292f, -0.00993924f, 0.09556635f, 
    0.12604018f, 0.16171700f, -0.00272710f, 0.05931187f, 0.17136014f, 0.17753595f, -0.02768104f, 0.00510469f, 
    -0.02456353f, 0.08358955f, 0.02772091f, -0.01793399f, 0.18657063f, -0.04645504f, 0.10441519f, -0.15744698f, 
    -0.02155232f, -0.01030208f, 0.01336410f, -0.00893679f, -0.03584880f, -0.01992789f, -0.02034409f, 0.01499852f, 
    -0.03549343f, -0.03995509f, 0.03092986f, -0.04049651f, -0.03694298f, 0.00035748f, 0.00431327f, 0.00943009f, 
    -0.00948068f, 0.02495519f, -0.01228703f, -0.00057149f, 0.01370192f, -0.00240201f, -0.01041686f, -0.04677701f, 
    -0.02515108f, -0.02160326f, -0.03243688f, 0.03125861f, -0.04585756f, -0.03659724f, -0.03663314f, -0.00157919f, 
    -0.03413672f, -0.01095341f, 0.02467048f, -0.02681284f, 0.01981725f, 0.00973521f, -0.01315266f, -0.01669266f, 
    0.03164613f, -0.02374904f, 0.02979181f, -0.01920653f, -0.01253971f, -0.01749247f, -0.00343608f, -0.03816924f, 
    0.00386584f, 0.01886628f, 0.01784431f, 0.03097363f, 0.00177591f, -0.01920919f, 0.01845746f, -0.00595404f, 
    -0.03404675f, -0.04037224f, -0.02875525f, 0.01530506f, 0.00401595f, -0.00690289f, 0.00559639f, 0.02457165f, 
    0.02603495f, -0.04231925f, 0.00877171f, 0.00322707f, 0.01518989f, 0.03053539f, 0.01111820f, -0.00283529f, 
    -0.01075478f, 0.00931051f, 0.01526410f, -0.01535928f, -0.03457963f, 0.00405274f, -0.01610590f, -0.03482334f, 
    -0.04470082f, -0.02025837f, -0.03985023f, -0.02261108f, 0.02812559f, 0.02604696f, 0.02048231f, -0.00206726f, 
    -0.00161678f, 0.02610611f, -0.03352866f, -0.02574476f, 0.00037299f, -0.02751294f, -0.00484046f, -0.01421238f, 
    0.01077052f, -0.01825731f, -0.03645270f, -0.03228272f, -0.03615472f, -0.02542782f, 0.03061556f, 0.03084921f, 
    -0.00089769f, -0.02734858f, -0.03213667f, -0.00593135f, -0.03741631f, 0.01777930f, 0.03417081f, -0.00600081f, 
    0.02606374f, 0.01121212f, -0.03356910f, -0.00423382f, 0.03153716f, -0.00933340f, 0.02613775f, -0.01451834f, 
    -0.01838998f, -0.03557054f, -0.02247919f, -0.03015936f, 0.01991671f, -0.01151935f, 0.02569608f, 0.02589314f, 
    0.02113486f, 0.02500840f, -0.03681746f, 0.04160266f, 0.02737997f, -0.00293737f, 0.00884614f, 0.01508864f, 
    -0.03807843f, 0.01171612f, -0.03779699f, 0.02570447f, 0.02832306f, -0.02938046f, -0.01437441f, 0.01384659f, 
    0.02614719f, -0.03007976f, 0.01408411f, -0.01068453f, -0.02558907f, 0.00838349f, -0.01482165f, -0.00350304f, 
    0.02286870f, -0.03547853f, -0.00967796f, -0.04236157f, 0.00210985f, -0.00542678f, -0.02274307f, -0.01160291f, 
    -0.01129154f, -0.03124135f, 0.01333452f, -0.04015677f, 0.00492741f, -0.00185054f, -0.01124427f, 0.02706291f, 
    0.01483343f, 0.01495864f, 0.02892907f, -0.02037652f, 0.00035070f, 0.01781766f, -0.01847817f, -0.01558335f, 
    -0.04039611f, -0.02211324f, -0.02040056f, -0.00795620f, 0.02750458f, -0.01988962f, -0.01282431f, -0.02412128f, 
    -0.01116220f, 0.00064241f, -0.02485644f, 0.03281470f, -0.03508786f, 0.00238477f, -0.02335680f, 0.02156174f, 
    -0.00253563f, -0.01975081f, -0.03089491f, 0.02755127f, 0.03325028f, 0.01707215f, 0.02541563f, -0.02262715f, 
    0.01865192f, 0.03107988f, -0.03638817f, 0.03061522f, 0.02329769f, 0.01853931f, 0.02558647f, -0.03567357f, 
    0.01096835f, -0.02560445f, 0.01594654f, 0.00093158f, -0.04217546f, 0.01195172f, -0.04327807f, -0.01016960f, 
    -0.00889352f, -0.04431155f, -0.01682970f, 0.00064072f, 0.01824751f, -0.02304593f, -0.01248471f, -0.01218701f, 
    -0.01093538f, -0.02664334f, -0.00056513f, 0.00063182f, -0.03794495f, -0.03551981f, -0.02686056f, -0.02249911f, 
    0.00553263f, 0.00558371f, -0.01900319f, -0.04120300f, -0.00575082f, -0.03306305f, 0.00433045f, 0.01299288f, 
    0.00968430f, -0.00473835f, -0.01131223f, 0.03232351f, -0.01779328f, -0.00632391f, -0.02228101f, -0.00533373f, 
    -0.04316509f, -0.00193944f, 0.02793055f, -0.00822019f, -0.01726076f, 0.02994354f, -0.03073141f, 0.03330134f, 
    -0.01386807f, -0.02068528f, -0.01673464f, -0.03055294f, -0.03028271f, -0.02498397f, -0.01995256f, -0.03318364f, 
    -0.01334249f, -0.00228891f, -0.00872780f, 0.00690706f, -0.01085767f, 0.01065836f, 0.00571092f, -0.02855511f, 
    -0.00321808f, 0.02986361f, 0.00322792f, -0.01379679f, -0.01667091f, -0.01899820f, -0.04252403f, -0.02947552f, 
    0.00362765f, -0.01851477f, -0.01255757f, 0.02084775f, -0.00656134f, -0.00355179f, -0.03265076f, -0.02441668f, 
    -0.01889576f, -0.03268597f, -0.00598277f, -0.03087564f, -0.00891484f, -0.03817545f, -0.00043248f, -0.01779918f, 
    0.01280988f, 0.00992574f, -0.01704740f, -0.01462865f, 0.00228990f, -0.00225631f, 0.00397466f, 0.01722590f, 
    -0.02883240f, -0.02161303f, -0.03048688f, 0.00332305f, -0.03913096f, 0.00595028f, -0.03737419f, -0.01561527f, 
    -0.04034800f, 0.02787439f, -0.02914255f, 0.03653511f, -0.01799006f, 0.03056556f, -0.02072001f, 0.01064568f, 
    0.01334988f, -0.03604430f, 0.02061215f, -0.01417153f, 0.01988689f, 0.01500406f, -0.01331103f, 0.01909358f, 
    -0.02443276f, -0.01740977f, -0.04666035f, 0.01604514f, 0.01580255f, 0.01346845f, 0.02465392f, -0.01787684f, 
    -0.02103522f, 0.02080406f, -0.03919150f, 0.00092223f, 0.01614008f, 0.01043269f, 0.01102948f, -0.00105259f, 
    -0.03404865f, -0.00408319f, -0.03979632f, -0.02868230f, 0.01350828f, -0.00741764f, 0.01333751f, 0.00636286f, 
    0.00268828f, -0.02164827f, 0.00920232f, 0.00074961f, 0.02020171f, -0.03561052f, -0.04090403f, 0.02444735f, 
    -0.00952351f, -0.04454463f, -0.01340896f, -0.02623392f, -0.02940709f, 0.00220934f, 0.02380765f, -0.03704947f, 
    -0.02917378f, -0.04349952f, 0.02272000f, 0.02736017f, 0.01159830f, 0.01398866f, 0.02031070f, 0.02681584f, 
    -0.00239473f, -0.01066045f, 0.02211786f, -0.00439375f, 0.02341142f, -0.04394689f, 0.00168024f, 0.02004419f, 
    -0.01685910f, -0.01110152f, -0.02784882f, 0.02434238f, -0.03128901f, 0.02833431f, 0.01487050f, 0.00121658f, 
    -0.01462116f, -0.01161900f, 0.02345517f, 0.02721498f, -0.02462512f, 0.01820866f, 0.01487925f, -0.03501983f, 
    0.00472231f, -0.02833435f, 0.02259815f, -0.03697931f, -0.03522281f, -0.02647842f, -0.03072787f, 0.00176851f, 
    -0.00945688f, 0.03908649f, 0.02228390f, 0.02500463f, -0.01994921f, -0.02592164f, 0.02838957f, 0.02610266f, 
    -0.00989958f, 0.01399772f, 0.02892723f, -0.04362781f, 0.01550898f, -0.03745099f, -0.00964645f, -0.04748460f, 
    0.02207720f, -0.00999591f, -0.00780434f, -0.03143954f, 0.02448809f, 0.03987442f, 0.02614573f, -0.02767048f, 
    -0.02759298f, 0.03677898f, -0.00027614f, 0.00423133f, -0.00224837f, 0.01993392f, 0.03109169f, -0.04490025f, 
    -0.03912379f, -0.04466774f, 0.02942761f, 0.01399936f, -0.00972112f, 0.01491780f, 0.00350485f, 0.00787848f, 
    0.02794918f, -0.02306584f, 0.01271670f, -0.00753678f, -0.01010667f, -0.02258352f, 0.01654007f, 0.02715006f, 
    -0.00356069f, -0.00905361f, 0.01378129f, 0.01495034f, -0.01766918f, 0.02662791f, 0.02772963f, -0.02369588f, 
    0.03324632f, 0.02099577f, 0.00666883f, -0.03153153f, 0.01394568f, 0.01800097f, 0.01793630f, -0.02348555f, 
    0.00108298f, 0.01107632f, -0.02139746f, 0.01748960f, 0.00634011f, 0.02201774f, -0.02339197f, 0.02440199f, 
    -0.03428894f, -0.03041421f, 0.00674401f, 0.03271313f, -0.02759564f, -0.04043057f, 0.00878563f, 0.02781066f, 
    -0.02190692f, -0.04263040f, 0.01673881f, 0.00390529f, 0.00200661f, -0.01629232f, 0.02399915f, 0.00191801f, 
    -0.02814997f, -0.02086052f, 0.02756755f, 0.00056897f, -0.01633478f, 0.01077684f, 0.00578164f, 0.02166990f, 
    -0.02243170f, 0.02002149f, -0.01653122f, 0.00173037f, 0.01222504f, -0.00111277f, -0.03529077f, 0.02451105f, 
    -0.02299568f, -0.03360958f, -0.02557015f, -0.02144543f, -0.01708288f, 0.00364384f, -0.00629149f, -0.01757951f, 
    -0.02669609f, 0.01593618f, 0.01187698f, -0.00094936f, 0.00428086f, 0.01366181f, -0.01848485f, 0.03662523f, 
    0.02373640f, -0.03404348f, -0.01889418f, -0.00228697f, -0.02597876f, 0.00028667f, -0.03903539f, -0.04324441f, 
    0.01758616f, 0.03438588f, -0.01508631f, 0.01779187f, 0.00040721f, -0.02460457f, -0.02719067f, -0.00164892f, 
    -0.00855485f, -0.00526526f, -0.00568993f, -0.00988058f, 0.01775796f, -0.01314377f, 0.00865478f, -0.03765729f, 
    0.00134547f, 0.02555102f, 0.02453257f, -0.02979515f, 0.01361286f, -0.00402966f, -0.00312376f, 0.02832491f, 
    -0.01364750f, 0.02550379f, 0.01175795f, -0.03002494f, 0.02820590f, 0.01232637f, 0.02828265f, 0.00807095f, 
    -0.01039121f, -0.02760166f, -0.01469170f, 0.01163220f, -0.02283940f, -0.01187063f, -0.01105105f, 0.00437022f, 
    -0.01090979f, 0.03597878f, -0.01335904f, 0.02034478f, -0.00849482f, 0.00078930f, -0.03924039f, 0.03238758f, 
    0.00752219f, -0.01582951f, -0.03196012f, 0.00974727f, -0.02885962f, -0.00503767f, -0.00162105f, 0.01041226f, 
    0.02377629f, 0.00705442f, -0.02799666f, 0.01892892f, 0.02355571f, -0.00433853f, 0.02409322f, 0.03356934f, 
    -0.01729057f, -0.00410929f, -0.00829513f, 0.00233757f, -0.02668304f, -0.01688817f, -0.04515268f, -0.03067614f, 
    0.01242126f, -0.02078556f, -0.03630106f, -0.01679663f, -0.02975045f, 0.00896808f, 0.01739904f, -0.03560703f, 
    -0.03567031f, -0.04427910f, -0.03945849f, -0.02536710f, -0.00788357f, 0.02032866f, -0.00922042f, -0.02699301f, 
    -0.01670620f, -0.02209654f, -0.03945587f, 0.01867788f, 0.01843280f, 0.02752610f, -0.04243857f, -0.02030463f, 
    -0.00775772f, -0.04469654f, 0.01661050f, 0.02826509f, 0.01926127f, -0.02664492f, -0.03138198f, -0.02565718f, 
    0.38150096f, 0.27810633f, 0.13520816f, -0.10784053f, 0.02873325f, 0.11274354f, -0.03970366f, -0.06561804f, 
    -0.24436197f, -0.16108249f, 0.10076387f, 0.00733343f, -0.02050360f, 0.00632120f, -0.02808296f, 0.02118560f, 
    -0.06298254f, 0.01098679f, 0.06755299f, -0.06270868f, 0.34709758f, -0.08234545f, -0.29559389f, 0.03181157f, 
    -0.13319211f, 0.05775136f, 0.09678075f, -0.09363887f, -0.12043668f, 0.19200666f, -0.03338072f, -0.02563388f, 
    0.11175227f, -0.14749600f, -0.02917212f, -0.04063177f, -0.09168221f, 0.13979030f, -0.00066375f, -0.06113865f, 
    -0.18113723f, 0.04652801f, -0.08838523f, -0.01701396f, -0.07338431f, -0.04287740f, 0.02963906f, 0.01751062f, 
    -0.03634221f, -0.04837075f, 0.06674325f, 0.09071211f, 0.05985333f, 0.03875338f, 0.06942279f, 0.07133096f, 
    -0.02516828f, 0.13221870f, -0.07660624f, 0.19749472f, 0.34070814f, -0.15515627f, -0.19291157f, 0.14498129f, 
    -0.16407372f, 0.04103405f, 0.06507246f, -0.17876852f, -0.01298912f, -0.00005993f, 0.00611322f, 0.07803388f, 
    -0.13232431f, 0.02749411f, 0.05830298f, 0.02390942f, -0.15975589f, 0.00326126f, 0.04532077f, -0.02687050f, 
    -0.17471154f, -0.38924670f, -0.06782254f, -0.15034623f, 0.20394722f, 0.06728013f, 0.09689756f, 0.03132392f, 
    -0.09509042f, -0.05170579f, -0.00125403f, -0.06000283f, -0.01207618f, -0.03201443f, 0.04892408f, -0.12048618f, 
    -0.03176802f, 0.11413997f, 0.03178314f, 0.00739383f, -0.13553156f, 0.07676741f, 0.06221068f, -0.05523337f, 
    0.24751873f, 0.00040253f, -0.02369020f, -0.01180801f, -0.09822242f, -0.08290772f, 0.07824235f, -0.01531946f, 
    0.02067935f, -0.08561899f, -0.02626335f, -0.07563204f, 0.02456222f, 0.02775215f, 0.15595400f, -0.05107556f, 
    0.00151495f, 0.30599895f, -0.10027523f, 0.21411222f, -0.12766908f, -0.07789158f, -0.08594934f, 0.08097596f, 
    -0.11845770f, -0.07754606f, 0.10928313f, 0.06148086f, -0.06794833f, -0.01830057f, 0.06058764f, -0.03652320f, 
    0.04498005f, 0.07062275f, 0.14732359f, -0.09655496f, 0.15809315f, 0.29040039f, -0.01813311f, 0.00915174f, 
    0.36112806f, -0.04389409f, -0.25014615f, -0.00544131f, 0.06585202f, -0.20116654f, 0.08117940f, -0.00864699f, 
    0.02903870f, -0.05706763f, -0.17239721f, 0.08154167f, -0.00458810f, 0.02182432f, -0.11474897f, 0.00280045f, 
    -0.05502279f, -0.02217552f, 0.09561803f, -0.00143258f, -0.07659052f, 0.06654357f, 0.08253451f, -0.08093713f, 
    -0.03042330f, -0.04634915f, 0.03665989f, 0.01396381f, -0.01263855f, 0.08994081f, -0.07163382f, -0.01024897f, 
    -0.01157354f, 0.06384225f, -0.01969321f, 0.13744538f, -0.09261228f, -0.05869138f, -0.11644464f, -0.16690707f, 
    0.11663117f, 0.01973580f, 0.02236519f, -0.03906662f, 0.03336859f, -0.01273201f, 0.09811392f, 0.04281729f, 
    0.13656045f, 0.10494160f, 0.05986676f, -0.06969229f, 0.22362833f, -0.02648481f, -0.27290758f, -0.04561862f, 
    -0.21409348f, -0.16953306f, -0.03636370f, -0.30039349f, -0.12418608f, 0.14864787f, 0.07491940f, -0.00132839f, 
    -0.06022422f, 0.05528565f, -0.03703753f, -0.08374449f, -0.05933698f, 0.01859109f, 0.02944890f, 0.04197722f, 
    0.14459616f, -0.05042725f, -0.04221136f, 0.11013857f, 0.09064116f, 0.34287986f, 0.01825143f, 0.01123769f, 
    0.05085035f, -0.15178853f, -0.10984389f, -0.04890050f, -0.00060380f, 0.06176943f, -0.00001756f, -0.04663493f, 
    -0.03608664f, -0.01158510f, -0.05668511f, -0.10670258f, 0.00079821f, 0.08612560f, 0.15166034f, -0.08574057f, 
    -0.34021446f, -0.02630471f, 0.02584135f, 0.04198157f, -0.24341659f, 0.08727558f, -0.07371581f, -0.16056229f, 
    0.02936088f, -0.06272329f, 0.13592322f, 0.04712258f, 0.07054930f, 0.05292295f, 0.08335936f, 0.09004106f, 
    0.01658131f, -0.08039928f, -0.27282435f, -0.08402219f, -0.10197762f, -0.23216960f, -0.03054739f, -0.01250160f, 
    0.04808265f, 0.11964689f, 0.12833899f, 0.03237203f, -0.13874219f, 0.02951140f, 0.02520338f, -0.03396752f, 
    -0.04258499f, -0.04659696f, -0.04186929f, 0.03086751f, 0.03938344f, 0.05973935f, 0.02951483f, 0.02016864f, 
    0.25961971f, -0.15911230f, 0.07155211f, -0.04454637f, 0.07295033f, 0.15716928f, 0.16461708f, -0.05676853f, 
    -0.05359479f, -0.03193893f, -0.03992229f, -0.00541817f, 0.01234818f, 0.02120586f, 0.07242958f, 0.07432492f, 
    0.09466308f, 0.11568196f, 0.13165425f, -0.01149997f, 0.07049781f, -0.02227340f, 0.08898634f, 0.31651577f, 
    -0.09924361f, -0.02261279f, 0.26238579f, -0.03189518f, -0.00116119f, -0.03451541f, 0.06461377f, 0.13232136f, 
    -0.14768535f, 0.05156370f, 0.02693423f, -0.15336043f, 0.03906642f, 0.04550656f, 0.00031029f, -0.06223250f, 
    0.22967920f, -0.18728305f, 0.18863851f, -0.09641614f, 0.12146347f, 0.16014011f, 0.29413870f, -0.04596888f, 
    -0.18227953f, -0.04459036f, -0.08163081f, -0.13254575f, 0.00468804f, 0.02016767f, 0.03737659f, 0.01583157f, 
    0.16244735f, 0.06652121f, 0.02053385f, -0.10941968f, 0.04498111f, -0.08143426f, -0.01187390f, 0.10204111f, 
    -0.01382372f, 0.06303369f, -0.04387603f, -0.01787873f, -0.08401401f, -0.00638389f, -0.02902758f, -0.03540039f, 
    0.07798105f, 0.20143315f, 0.09011624f, 0.06917723f, 0.01488862f, 0.07042155f, -0.12395367f, 0.08558558f, 
    -0.02496568f, 0.02522176f, -0.15428390f, -0.10306188f, 0.02616035f, 0.03580966f, -0.09072260f, -0.00380744f, 
    0.08742832f, 0.10588457f, 0.01196455f, -0.01106776f, -0.01908541f, 0.01527883f, 0.00970581f, 0.01541552f, 
    0.07517628f, -0.09991797f, 0.10216554f, -0.05192013f, -0.30127075f, 0.07072480f, -0.09074923f, 0.01064077f, 
    0.14139849f, 0.09383680f, -0.10314675f, -0.00610336f, -0.16154498f, -0.00307336f, 0.08042717f, -0.07852564f, 
    0.01177492f, 0.02692006f, 0.06464349f, 0.09948267f, -0.04900058f, -0.05025432f, 0.11208989f, 0.05025281f, 
    -0.37877709f, -0.14040892f, 0.19690040f, 0.16858847f, -0.07853197f, -0.02216976f, 0.00930876f, 0.03230065f, 
    0.02769969f, 0.04635178f, -0.01650159f, 0.00846429f, 0.06961527f, -0.07588264f, -0.09901751f, 0.10406011f, 
    -0.01145507f, -0.01439164f, 0.04254058f, 0.02339581f, -0.18964675f, 0.49444401f, 0.14442335f, 0.08423662f, 
    -0.15755264f, -0.01971932f, -0.06658849f, 0.07871637f, 0.02210247f, 0.03770331f, 0.12511104f, -0.07539165f, 
    0.04542570f, -0.09740275f, 0.22133313f, -0.03280354f, 0.05028293f, -0.04320138f, 0.10467470f, -0.06005461f, 
    0.23334891f, 0.20065898f, 0.02778869f, -0.12661847f, 0.00790638f, 0.12787803f, 0.01600621f, 0.03183354f, 
    -0.03160366f, -0.05555137f, 0.04896377f, -0.00071126f, -0.05529440f, 0.06008647f, -0.05039072f, 0.11520507f, 
    0.00642893f, 0.08497252f, 0.13998409f, 0.19181463f, -0.24360323f, 0.13612592f, 0.14344278f, 0.08408172f, 
    0.01025804f, 0.09530587f, -0.01532441f, 0.02387199f, -0.02582835f, 0.21584900f, 0.10075606f, -0.03698693f, 
    -0.09602993f, 0.00622254f, -0.10293883f, -0.01451449f, 0.03017459f, -0.14825308f, 0.09919988f, 0.01451263f, 
    0.20093490f, 0.15524463f, -0.05244849f, -0.22869243f, -0.06384752f, -0.06486288f, -0.06791097f, 0.07858019f, 
    0.11401304f, 0.08521062f, 0.10431515f, 0.07216962f, 0.11996736f, 0.03740740f, 0.06264552f, 0.05640508f, 
    0.01912840f, -0.00525364f, -0.08171526f, 0.23369528f, 0.12886479f, 0.16059731f, -0.14090401f, -0.29307669f, 
    0.05443148f, -0.05703346f, -0.10923664f, 0.08598708f, 0.04237136f, 0.00728796f, 0.01537598f, 0.00464613f, 
    0.16034278f, 0.13482460f, 0.08096628f, -0.00639341f, 0.09577245f, 0.02447397f, -0.25235304f, 0.05847796f, 
    -0.12683861f, -0.15133521f, 0.06020174f, 0.16770278f, -0.19760026f, 0.03209104f, 0.05184982f, -0.04642113f, 
    0.04526998f, -0.00512668f, 0.04160151f, -0.00128482f, 0.09254454f, 0.04043123f, -0.03105376f, -0.03583966f, 
    0.04611699f, -0.29390922f, -0.18167511f, -0.01793427f, 0.43264058f, -0.28020853f, 0.01917448f, -0.03859183f, 
    -0.04532310f, -0.14328726f, -0.03154437f, -0.03395906f, 0.03029817f, -0.04198565f, 0.00051337f, 0.04507232f, 
    0.12758458f, 0.04594446f, 0.08484685f, 0.08007766f, 0.03722103f, 0.06774340f, 0.09371740f, 0.06872104f, 
    -0.17959292f, 0.32223588f, 0.09396874f, -0.01045060f, 0.23134732f, 0.00563769f, -0.01741810f, 0.14270869f, 
    -0.02539703f, 0.18676730f, -0.11638536f, -0.04023864f, -0.02199235f, -0.20535047f, -0.02686395f, -0.05634180f, 
    -0.05369666f, -0.07599225f, 0.16689435f, -0.09987315f, -0.05443201f, -0.05359589f, 0.33028337f, 0.03296689f, 
    -0.05910037f, -0.04911089f, 0.06022716f, -0.07661413f, 0.12561513f, -0.03529919f, -0.01805868f, 0.10149578f, 
    0.03057783f, 0.14109194f, -0.10908171f, 0.14414795f, 0.13066444f, 0.18036290f, -0.26451549f, -0.02334558f, 
    0.06005019f, -0.25526473f, 0.01835607f, 0.03023295f, -0.14486210f, -0.01593372f, 0.14022793f, -0.23329581f, 
    -0.00433204f, -0.08338427f, -0.02547929f, 0.05693359f, 0.10283704f, 0.02620798f, 0.05735878f, -0.06912357f, 
    -0.00127583f, 0.00311679f, 0.02336351f, -0.05015811f, 0.41186967f, -0.00637337f, 0.00492379f, 0.10610566f, 
    0.07094954f, 0.01327246f, 0.06190927f, 0.07436605f, 0.08188128f, 0.02802308f, 0.12548098f, 0.17522210f, 
    -0.11527505f, -0.07344650f, -0.11718613f, 0.03356281f, -0.04733020f, -0.09212217f, 0.00356791f, 0.19445820f, 
    0.05233311f, 0.00864103f, -0.02658036f, 0.01327829f, 0.00927155f, 0.01164081f, -0.00855896f, 0.02140288f, 
    0.02460907f, -0.00486472f, 0.01172302f, -0.03634049f, 0.02839444f, -0.03473277f, -0.02720010f, -0.01749601f, 
    -0.02661118f, -0.01178215f, 0.00824771f, 0.03369385f, -0.00460384f, 0.03896367f, -0.02039263f, -0.01382319f, 
    -0.02846519f, 0.00038619f, 0.00327496f, 0.00571399f, -0.01893005f, 0.00561893f, -0.04013268f, 0.01992158f, 
    0.00572447f, 0.03393486f, -0.02599384f, 0.01740360f, 0.03380753f, 0.01665203f, -0.02965778f, -0.00006625f, 
    -0.03445159f, -0.00723173f, 0.01831028f, -0.01984988f, 0.01975341f, -0.03447429f, -0.00921589f, -0.01489255f, 
    -0.03467858f, -0.04275410f, -0.02225695f, -0.00253748f, 0.02551597f, -0.02991383f, -0.00636365f, -0.03549867f, 
    -0.02761379f, -0.01398888f, -0.02621854f, -0.02106153f, 0.02774147f, 0.01272301f, -0.02432892f, 0.01356536f, 
    0.03259780f, -0.00512705f, 0.02826064f, 0.03042782f, -0.02332727f, -0.04098772f, -0.03476563f, -0.02220029f, 
    0.01398665f, 0.01990061f, 0.00129915f, -0.00113073f, -0.03581771f, -0.02573906f, -0.01921002f, -0.00992254f, 
    -0.00229953f, 0.03598085f, -0.01675019f, -0.02934146f, -0.02796206f, 0.03373221f, -0.02979955f, 0.01152243f, 
    0.00505579f, 0.01888173f, -0.02420515f, 0.03245657f, -0.00168503f, -0.00809147f, 0.01394867f, -0.01915369f, 
    0.03336968f, 0.00526454f, -0.01057983f, -0.01350466f, -0.00661653f, 0.02956267f, -0.02034334f, 0.02645371f, 
    0.01168810f, 0.03732632f, 0.02159800f, 0.02908597f, -0.01331311f, -0.01199874f, -0.02736960f, -0.00722551f, 
    0.02814724f, 0.01005949f, -0.04386039f, -0.00905233f, -0.02939153f, 0.01071368f, -0.01757072f, 0.03490295f, 
    0.00569046f, 0.01333924f, -0.01560078f, 0.03199291f, 0.01267404f, 0.03465743f, 0.01356684f, -0.02016263f, 
    -0.03776439f, 0.03368369f, -0.01013959f, -0.01038953f, -0.01480662f, 0.03865329f, 0.03707020f, 0.00208849f, 
    -0.02653786f, 0.01444657f, 0.00156871f, -0.03677163f, -0.00933323f, -0.01144006f, 0.02296258f, -0.00418637f, 
    -0.02544173f, -0.01265656f, -0.03353525f, -0.00829324f, 0.01843458f, -0.00662409f, 0.01064021f, -0.01751295f, 
    0.00869233f, -0.00525101f, 0.03029623f, -0.00555150f, 0.00552258f, 0.03902690f, 0.00643981f, -0.01108918f, 
    -0.01028689f, -0.00737940f, -0.02399963f, -0.00308273f, 0.01367717f, -0.00310684f, 0.00923216f, 0.00169516f, 
    -0.02704953f, 0.01935801f, 0.02830569f, 0.02241010f, -0.03139304f, 0.00671289f, -0.02407333f, 0.00198662f, 
    0.03020563f, 0.02314764f, 0.01147045f, -0.03310487f, -0.04481515f, -0.00191212f, 0.01800830f, -0.01503050f, 
    0.01380475f, 0.00891326f, 0.01583543f, 0.03063016f, -0.00888843f, -0.00310461f, -0.03472608f, 0.00757539f, 
    0.02953101f, 0.02103220f, 0.01627974f, -0.01049443f, 0.01727144f, 0.02615126f, -0.02012407f, 0.02028718f, 
    0.00993329f, 0.01502913f, -0.02387435f, 0.01676206f, 0.01720079f, 0.03691567f, -0.03614780f, -0.00137749f, 
    -0.00013413f, -0.03661668f, -0.01103023f, -0.00542922f, -0.03490192f, 0.01058932f, -0.03009507f, 0.00916873f, 
    0.01722993f, -0.02579891f, 0.02945320f, 0.01801694f, -0.03555635f, 0.03281206f, 0.00459673f, 0.00483440f, 
    0.02902315f, -0.01454667f, 0.01716242f, -0.00058015f, -0.02259444f, -0.03689265f, 0.03607132f, 0.01780229f, 
    -0.01750789f, -0.00721079f, 0.03145788f, 0.02620526f, -0.00402462f, 0.02469744f, -0.04045542f, -0.04045135f, 
    0.02143793f, -0.00804205f, 0.02346824f, -0.00379836f, -0.01621326f, 0.04353697f, 0.01041008f, -0.00991999f, 
    0.02538831f, -0.02783045f, 0.03495067f, -0.03094925f, 0.00842283f, 0.01059468f, -0.02598107f, -0.02362987f, 
    -0.01995618f, 0.03419252f, -0.02098511f, 0.00260914f, 0.01942026f, -0.02158295f, 0.01652094f, 0.03131656f, 
    0.02380455f, -0.02124343f, -0.01966293f, -0.01218115f, 0.01301103f, 0.00964015f, -0.02700992f, -0.02115876f, 
    -0.01023185f, -0.01480747f, -0.04336090f, 0.03275148f, 0.00817708f, 0.02792569f, 0.02198723f, 0.03039697f, 
    -0.00246160f, 0.03083719f, -0.02536422f, 0.04344294f, 0.01222089f, 0.02926000f, -0.00436432f, -0.03102922f, 
    -0.00042152f, -0.03629519f, -0.01881122f, 0.02228113f, 0.02503814f, 0.01679846f, 0.00052939f, 0.00655436f, 
    -0.03613288f, 0.01220072f, -0.01323782f, -0.01310959f, -0.00975118f, -0.02295224f, -0.00735027f, 0.01010259f, 
    -0.03936139f, -0.01660537f, 0.01352818f, -0.00516094f, -0.01385239f, -0.00699440f, 0.01754965f, -0.03053867f, 
    -0.02808862f, -0.02161292f, 0.02920924f, -0.02653520f, -0.03240581f, -0.02817517f, -0.00996733f, 0.00541320f, 
    -0.01601502f, -0.00641073f, -0.02290733f, -0.02046148f, -0.00606842f, -0.01436706f, -0.03560536f, -0.03189940f, 
    -0.01437000f, 0.02691020f, -0.01932167f, 0.03791150f, -0.02363194f, -0.02524982f, -0.03861798f, -0.01466757f, 
    0.03745444f, -0.01687241f, 0.01268851f, 0.00251333f, 0.00051922f, -0.02350247f, -0.01107276f, 0.03215228f, 
    -0.02034301f, 0.01385865f, -0.03280474f, 0.01059658f, 0.00955408f, 0.01148610f, 0.03231220f, 0.02111096f, 
    -0.01585543f, -0.03510907f, 0.01652050f, -0.00776510f, -0.01418194f, 0.01183659f, 0.00402126f, -0.02346296f, 
    -0.01687726f, -0.03632560f, -0.01171964f, -0.02014118f, 0.00727835f, 0.01845003f, -0.04127718f, 0.03016775f, 
    0.03323159f, -0.02045278f, -0.02464791f, -0.01434590f, -0.00269231f, -0.01072764f, -0.03790392f, -0.00380425f, 
    0.00885260f, -0.01597587f, -0.02941852f, -0.01293836f, 0.01491199f, -0.01249163f, 0.00945782f, -0.03073205f, 
    -0.02194641f, 0.00709144f, 0.02484472f, 0.02205282f, -0.02525426f, -0.00872098f, -0.01222186f, 0.03608684f, 
    0.02633058f, 0.02173778f, 0.01692668f, 0.03249808f, 0.00274640f, 0.00063161f, 0.02095101f, -0.01789953f, 
    0.01543265f, -0.03230377f, 0.00988206f, -0.03754288f, 0.00357583f, 0.01548789f, -0.00736654f, 0.00235267f, 
    -0.00439084f, 0.00051263f, -0.01481903f, 0.02689452f, -0.02177327f, 0.00502813f, 0.00244970f, -0.03474139f, 
    0.01866796f, 0.03198724f, 0.02268112f, 0.00961152f, -0.00349308f, -0.01103966f, 0.01292062f, -0.02249279f, 
    -0.02066905f, -0.00737182f, 0.03161737f, -0.00136047f, -0.01679504f, -0.01418483f, -0.00082632f, 0.00654006f, 
    -0.00677284f, 0.01813325f, -0.00033974f, 0.01662370f, -0.01687498f, 0.03408873f, -0.03461357f, 0.03397145f, 
    0.02268984f, -0.02065963f, -0.02046333f, 0.03008306f, -0.01044729f, 0.03084909f, -0.01630950f, -0.03536317f, 
    -0.01487574f, 0.01229471f, -0.01081786f, 0.00993964f, 0.01575748f, -0.00383563f, -0.01322617f, -0.03754834f, 
    0.02309470f, -0.02864334f, 0.01005678f, -0.02392923f, 0.01607008f, 0.01402823f, 0.01496665f, 0.01132163f, 
    -0.00185623f, -0.03970014f, -0.03454724f, -0.03332661f, -0.02270364f, 0.01599075f, -0.01823104f, 0.00145058f, 
    0.03887869f, 0.02081712f, 0.02598955f, 0.01771886f, 0.01618410f, 0.02623346f, -0.02262965f, 0.01243524f, 
    -0.01292424f, -0.04596338f, -0.03274594f, 0.00144247f, 0.00822591f, -0.01408768f, -0.01141791f, 0.01739646f, 
    0.01398160f, -0.04819613f, -0.00894642f, 0.02344648f, 0.01326275f, -0.02174739f, -0.03849429f, -0.02199323f, 
    -0.01586794f, 0.00917392f, -0.02888955f, -0.02072981f, -0.02600507f, -0.04168357f, 0.00191554f, -0.03566267f, 
    0.02404603f, -0.01409496f, -0.03474082f, -0.01861438f, -0.01826480f, 0.00398136f, -0.00235280f, -0.02217278f, 
    -0.00823783f, -0.01346709f, 0.03389598f, -0.00697652f, -0.02706303f, 0.03218298f, -0.03193519f, -0.00621352f, 
    0.02610182f, -0.00826168f, 0.00985047f, -0.00744264f, 0.00092950f, -0.01961140f, -0.01276940f, -0.01389477f, 
    0.00874081f, 0.00832372f, -0.02015150f, 0.00671911f, -0.03680945f, -0.01589685f, -0.02918912f, -0.00824328f, 
    -0.02564392f, -0.00028896f, 0.01100275f, -0.00512867f, -0.01044823f, -0.01854366f, -0.00329793f, -0.01645239f, 
    0.02297061f, 0.01927060f, -0.03716437f, 0.00278412f, -0.01228989f, -0.02958766f, 0.01318889f, 0.01997698f, 
    -0.01530443f, 0.01331786f, -0.01140685f, -0.02634462f, -0.02005688f, -0.00169724f, -0.02328977f, 0.00893417f, 
    -0.00434104f, 0.01371365f, 0.01539080f, -0.00958821f, 0.00936039f, -0.04046691f, -0.03391733f, 0.00607292f, 
    -0.00877579f, 0.02612782f, 0.03184142f, -0.01560829f, -0.03062123f, -0.02754205f, 0.03767119f, 0.02263613f, 
    0.02074307f, -0.01443657f, -0.04190076f, 0.00877265f, -0.05243544f, 0.02511138f, -0.03281928f, -0.02202577f, 
    -0.00134759f, -0.00207178f, -0.00515999f, 0.02781418f, -0.00193194f, 0.00498790f, 0.03396015f, -0.00929651f, 
    0.00136129f, -0.00895899f, -0.02167865f, -0.00112254f, 0.02085239f, 0.00933504f, -0.02074590f, -0.00926615f, 
    0.04173733f, -0.01974219f, -0.03803160f, 0.04342119f, -0.02664424f, 0.01167271f, 0.00289177f, -0.02213888f, 
    -0.03756239f, -0.00996920f, 0.02212024f, -0.02316030f, -0.02726348f, -0.02001490f, 0.00286598f, 0.03400404f, 
    -0.02285699f, 0.01954770f, -0.03485327f, 0.02598900f, 0.01973989f, -0.00510002f, -0.00602984f, 0.02932559f, 
    -0.03682129f, -0.02241173f, -0.01583133f, 0.02593521f, 0.00636072f, 0.01706837f, -0.02609015f, -0.00789033f, 
    0.01388290f, -0.01475673f, -0.00144904f, 0.01427085f, 0.00713223f, 0.00354711f, -0.03352563f, 0.00444877f, 
    0.00982284f, -0.01775962f, 0.00708302f, -0.03316065f, 0.02483278f, -0.02453334f, 0.01317396f, 0.02699353f, 
    -0.02733630f, -0.00772271f, 0.01629906f, 0.02085101f, 0.00612664f, 0.00410787f, -0.02756107f, 0.00500809f, 
    -0.02135546f, -0.02874318f, -0.04547725f, -0.03333647f, -0.03336909f, -0.00656435f, -0.02581193f, 0.01164020f, 
    0.03146782f, -0.02816930f, 0.03129373f, -0.00285576f, 0.01705373f, 0.01327440f, -0.03177343f, 0.01210137f, 
    -0.01812183f, 0.03387402f, 0.02713641f, 0.02590660f, 0.00464528f, 0.02068795f, -0.03411275f, 0.02559168f, 
    -0.00263820f, -0.00191045f, 0.00128773f, 0.04115460f, 0.02181589f, 0.03505160f, -0.04506071f, 0.00833210f, 
    0.02731241f, -0.04065794f, -0.01461480f, -0.00925167f, -0.00832006f, 0.02386140f, -0.01750710f, 0.00291361f, 
    -0.01151427f, -0.03595273f, -0.01503822f, -0.00273095f, -0.02690952f, -0.00266754f, 0.01649469f, 0.00641126f, 
    0.02728503f, -0.01036378f, 0.02820086f, 0.03278004f, 0.00955387f, -0.02671073f, 0.00842939f, 0.00029620f, 
    0.00846419f, -0.03787361f, -0.03228982f, -0.03999034f, -0.01092217f, -0.01104638f, 0.02593075f, 0.00171464f, 
    0.02504421f, -0.04672528f, 0.02813479f, -0.03083394f, -0.00133435f, 0.03598127f, 0.01305220f, -0.00941455f, 
    0.00104462f, -0.00149426f, 0.00620902f, 0.01327686f, -0.00138576f, 0.02276629f, -0.03492426f, -0.00136304f, 
    -0.01749332f, 0.00413463f, -0.01932629f, 0.04319311f, 0.00574709f, 0.01526975f, -0.02913378f, 0.02991346f, 
    0.01199888f, -0.00252295f, 0.03723371f, 0.02634364f, 0.02941425f, -0.03393444f, -0.00140392f, -0.04088497f, 
    -0.02598868f, -0.02232851f, -0.03009977f, -0.02554339f, -0.03510663f, -0.01723742f, -0.02771688f, -0.01840992f, 
    -0.01036461f, 0.01203679f, -0.01507637f, -0.03137643f, -0.01276504f, -0.03022052f, -0.02927228f, -0.02459287f, 
    -0.01838692f, -0.01388035f, -0.03875536f, -0.00163989f, 0.01223145f, -0.03695184f, 0.03378103f, 0.00457573f, 
    -0.00467573f, 0.02856944f, 0.01266552f, 0.02954708f, -0.04737113f, 0.01790482f, 0.00830975f, -0.02251565f, 
    -0.03674556f, -0.04513626f, -0.00754327f, -0.03726408f, 0.02644939f, 0.00615219f, -0.00443097f, -0.04481877f, 
    0.01185079f, 0.03249775f, 0.02396953f, -0.03099518f, -0.02078672f, -0.01849902f, 0.02571045f, 0.03053232f, 
    -0.03181458f, 0.00326060f, 0.01658084f, 0.00408906f, 0.01426022f, 0.02768948f, 0.03668346f, -0.03579783f, 
    -0.02556581f, -0.00645145f, -0.00075650f, 0.00590940f, 0.02653113f, 0.02530970f, 0.04084703f, -0.02032476f, 
    -0.00518792f, -0.00808363f, -0.00866085f, 0.02589690f, -0.01669308f, -0.02567595f, -0.00511185f, 0.00676991f, 
    -0.01298672f, -0.02985881f, -0.00769522f, 0.01769412f, -0.01226832f, -0.03448103f, -0.01870590f, -0.01774822f, 
    0.00130997f, 0.01728527f, 0.02642236f, -0.00653821f, -0.04244152f, -0.02843596f, -0.01641885f, -0.01049572f, 
    0.01933408f, -0.00079715f, -0.03810477f, 0.00300837f, 0.00497761f, 0.02047167f, -0.02746689f, -0.03064899f, 
    -0.03699794f, -0.03769407f, 0.02141530f, -0.01748085f, -0.01826029f, 0.00243295f, 0.03242997f, -0.03370452f, 
    -0.02566338f, 0.01775279f, 0.01814526f, 0.01039758f, -0.01007803f, 0.01469202f, 0.02342348f, 0.02609326f, 
    -0.04488805f, 0.00589846f, 0.01775073f, -0.01507672f, -0.00273634f, 0.02277401f, -0.04214759f, -0.00948938f, 
    -0.00323670f, 0.00302318f, -0.04677286f, 0.03092261f, -0.04312610f, 0.03579461f, 0.01626727f, 0.01390128f, 
    0.04649000f, -0.01619254f, 0.02200930f, 0.03943483f, -0.01330258f, 0.02936909f, 0.01526012f, -0.00491022f, 
    -0.00344991f, 0.01052612f, -0.01664376f, -0.02195847f, -0.02720717f, 0.01001113f, 0.01139772f, 0.02025618f, 
    -0.03279863f, -0.04127325f, -0.03605754f, -0.00864893f, 0.01669985f, -0.02733277f, -0.04008801f, 0.02395912f, 
    0.01113457f, 0.00988425f, 0.01065970f, -0.03663145f, -0.00102093f, 0.00660311f, 0.02367984f, -0.03260732f, 
    0.01222008f, -0.04659609f, -0.02056123f, -0.04549644f, -0.02374802f, -0.04574136f, -0.00211144f, -0.04688093f, 
    -0.00472347f, 0.02433550f, 0.00568225f, -0.00384120f, -0.03974013f, -0.03783523f, -0.01678851f, -0.03580016f, 
    -0.02703658f, -0.03590294f, 0.01895855f, -0.03011970f, -0.00579803f, 0.02212052f, -0.00897190f, -0.03262433f, 
    -0.03390564f, -0.01523329f, -0.02828566f, -0.02773276f, -0.02234622f, -0.00280112f, -0.01590460f, 0.00372466f, 
    0.01412465f, -0.00793170f, -0.00255402f, 0.02553236f, 0.01847468f, 0.01214141f, -0.02413688f, 0.00481210f, 
    0.02341431f, 0.01837724f, 0.04387466f, -0.00535349f, -0.02728404f, 0.00736168f, 0.03280537f, -0.02893529f, 
    0.01108487f, 0.00361913f, -0.03457843f, -0.02363145f, -0.01033033f, -0.04036651f, -0.00315791f, -0.02002404f, 
    0.02862032f, 0.02065811f, -0.01739193f, 0.01514268f, -0.01616477f, 0.02730368f, 0.03263199f, 0.00303973f, 
    -0.02850285f, -0.03719694f, 0.03291247f, 0.00107658f, 0.00395371f, -0.03315638f, -0.04216056f, -0.02052113f, 
    -0.04246319f, 0.00687015f, -0.01548870f, 0.03108500f, 0.01110002f, 0.01196711f, 0.02589030f, -0.03039846f, 
    -0.00491854f, -0.01139280f, 0.03468369f, 0.01101472f, -0.02131770f, 0.02287219f, 0.03563255f, -0.02508716f, 
    -0.02341691f, 0.02075414f, -0.02007989f, -0.02142118f, 0.00319354f, -0.04359183f, -0.03297299f, -0.01054021f, 
    -0.02585749f, 0.00392457f, -0.00233531f, 0.01322621f, -0.01101037f, -0.00098263f, -0.01505931f, 0.03121655f, 
    0.01137150f, -0.02576318f, 0.02861559f, 0.01449971f, 0.01333996f, -0.03566085f, -0.00777645f, 0.02773787f, 
    -0.00661302f, 0.03143207f, 0.00994076f, -0.03356026f, -0.03152389f, 0.00765809f, 0.02227162f, 0.00705755f, 
    0.00406690f, 0.00540074f, 0.02880974f, -0.03814643f, -0.01302709f, 0.02835206f, -0.02136225f, -0.04392909f, 
    -0.03691805f, -0.02869316f, -0.00384636f, 0.01222365f, -0.04025420f, -0.02935645f, -0.03380782f, 0.01215829f, 
    -0.04724257f, -0.02431422f, 0.02703539f, 0.01058534f, -0.00779771f, -0.01297327f, 0.03527351f, 0.01563440f, 
    -0.02908351f, 0.01295047f, -0.01349777f, -0.00412760f, 0.00305499f, 0.03154878f, 0.01937106f, 0.03511155f, 
    -0.00280644f, 0.00214947f, 0.01970472f, 0.01786515f, 0.01292318f, -0.00480720f, 0.00841060f, 0.00924624f, 
    -0.00607234f, -0.01310701f, -0.02851515f, -0.00645993f, -0.02886416f, -0.00278962f, 0.01676928f, 0.00108958f, 
    -0.01566490f, 0.02583888f, -0.04214978f, 0.00935237f, -0.01595613f, 0.00093617f, 0.02609095f, -0.00311290f, 
    -0.02190743f, 0.00779531f, 0.02322385f, -0.00036862f, -0.00061445f, -0.01819581f, 0.02190034f, -0.03478910f, 
    -0.03490505f, 0.01500609f, -0.03251559f, -0.03897097f, -0.01128277f, -0.01958374f, -0.03185454f, -0.00994992f, 
    0.02113559f, -0.03676120f, 0.03141993f, -0.01578285f, 0.01561287f, 0.03003220f, -0.03297364f, -0.01753241f, 
    -0.04315774f, 0.03121202f, 0.01382054f, -0.01881099f, -0.03922666f, 0.02901921f, 0.00392546f, 0.01947719f, 
    -0.00246474f, 0.02786729f, 0.00695735f, -0.01360316f, 0.00000856f, 0.01195312f, 0.01925661f, 0.00174228f, 
    0.02984265f, 0.00409995f, -0.03600457f, 0.01394227f, 0.02714087f, -0.00672730f, 0.00641481f, -0.04034874f, 
    0.00001188f, 0.03204228f, -0.01682929f, 0.02660374f, 0.01695662f, 0.04291296f, -0.01227837f, -0.01306464f, 
    -0.02792153f, 0.03705905f, 0.00020529f, -0.00677218f, -0.00190371f, 0.03036985f, -0.01370332f, -0.01303869f, 
    0.01107373f, 0.02567984f, 0.03000344f, 0.01337532f, -0.02261526f, 0.02526974f, -0.01716087f, -0.02569158f, 
    0.00622448f, 0.00295916f, 0.03270110f, -0.01590692f, -0.02409625f, -0.03906427f, -0.02790934f, 0.00202644f, 
    0.00973184f, 0.03083918f, -0.02619530f, 0.02102741f, 0.00050032f, -0.01237306f, -0.04539271f, 0.01341215f, 
    -0.00810679f, -0.00595757f, 0.00479231f, -0.02239867f, 0.00333265f, 0.01424690f, -0.03716939f, -0.02283778f, 
    0.01445828f, 0.02755504f, 0.01503287f, -0.01395530f, -0.02166116f, -0.04786981f, -0.01286577f, -0.02246892f, 
    -0.03594429f, -0.03114370f, 0.02196978f, 0.00237166f, 0.00231591f, -0.02969391f, -0.03041242f, -0.01466883f, 
    -0.00610334f, 0.04661806f, -0.01502038f, 0.01567175f, 0.02742853f, 0.01675341f, -0.04636495f, 0.01191266f, 
    -0.03796933f, -0.02379391f, 0.01746010f, 0.02776498f, -0.00935840f, 0.01143629f, 0.03912404f, 0.00921771f, 
    -0.01271409f, -0.00410443f, 0.01641222f, -0.04024198f, -0.02592429f, -0.01113190f, -0.04571967f, -0.01530117f, 
    0.01093497f, 0.00029984f, 0.02413824f, -0.01297509f, 0.01105416f, 0.02760129f, 0.03631293f, 0.03151831f, 
    -0.04355732f, -0.01809393f, -0.03576142f, 0.00614547f, -0.03995197f, 0.00191207f, -0.02801222f, 0.02614882f, 
    -0.02252185f, 0.00861689f, 0.01835672f, -0.02840012f, 0.00560657f, -0.00006797f, -0.02563103f, 0.01887705f, 
    0.01312939f, -0.01766426f, 0.03367818f, 0.01280312f, -0.04243281f, 0.00903108f, -0.02587348f, -0.02967110f, 
    0.00383969f, -0.03062263f, -0.00232818f, -0.04272901f, -0.03643599f, -0.01802863f, 0.00070020f, -0.02573690f, 
    0.00633732f, 0.01335858f, -0.01020601f, -0.00800695f, 0.02263252f, -0.02254877f, 0.02059917f, -0.00862924f, 
    -0.01440215f, 0.03941222f, -0.04484966f, -0.02246847f, -0.00553194f, 0.01587025f, -0.01926422f, 0.02198536f, 
    -0.01374937f, -0.01922741f, -0.05062392f, -0.02110049f, -0.00795673f, 0.01433123f, -0.03969554f, -0.02843878f, 
    -0.00998446f, -0.00378249f, -0.00855162f, -0.04578329f, -0.04451054f, -0.04771958f, -0.00336454f, -0.03848559f, 
    0.01097685f, 0.00051158f, -0.03207366f, -0.00332878f, 0.00999365f, -0.03330128f, 0.02006823f, 0.01534186f, 
    -0.04021740f, -0.01240805f, -0.01280344f, -0.02720293f, -0.04879129f, 0.00932136f, 0.01614692f, -0.02357731f, 
    -0.04016031f, -0.02208092f, -0.01770450f, 0.01303225f, 0.01225612f, -0.05002189f, -0.03769390f, -0.00538621f, 
    0.02312691f, -0.02128559f, 0.01970637f, 0.02905979f, -0.04006886f, 0.00071234f, -0.01005248f, -0.04173220f, 
    -0.02536381f, -0.00271040f, 0.02583910f, 0.01474144f, 0.01894836f, 0.01680442f, 0.00154889f, -0.03211280f, 
    0.01234443f, -0.02144492f, 0.00745209f, 0.01620493f, 0.00288883f, -0.00999732f, -0.00652047f, 0.02853192f, 
    -0.02413856f, 0.02985764f, -0.02229920f, 0.00858241f, -0.01710525f, 0.02334175f, -0.00914231f, 0.00105607f, 
    -0.04342210f, 0.02985282f, 0.00496160f, -0.02710075f, -0.00753316f, -0.04214352f, -0.01148193f, -0.03493269f, 
    0.00525548f, 0.00650098f, 0.00218477f, -0.02174580f, -0.00165377f, 0.00252774f, -0.02578715f, -0.05071661f, 
    -0.02345491f, 0.00888336f, 0.00281281f, 0.01821796f, -0.00520337f, -0.01884967f, -0.00953420f, -0.04617083f, 
    0.02318023f, -0.00247121f, -0.03612476f, -0.03067179f, 0.03840590f, 0.02910946f, -0.03315143f, 0.02117443f, 
    -0.00843719f, -0.02215753f, 0.01987597f, 0.00448335f, 0.01173981f, -0.03717458f, -0.03990116f, -0.02800623f, 
    -0.03442747f, -0.02545835f, 0.01138095f, -0.04947634f, 0.01023832f, 0.00121432f, -0.02782893f, -0.00999733f, 
    0.02147472f, 0.00389610f, -0.00123572f, 0.02561120f, -0.01712840f, -0.04258650f, 0.02143580f, -0.00481378f, 
    -0.04092933f, 0.01077681f, -0.01822448f, -0.02398092f, -0.01009141f, 0.01397798f, 0.02189857f, -0.04840536f, 
    0.00820338f, -0.01712358f, 0.01916583f, 0.01464913f, 0.02990143f, 0.00838078f, -0.04514011f, 0.02417706f, 
    0.00994710f, -0.04043509f, -0.01527032f, 0.00018684f, -0.01592066f, -0.03767149f, 0.02145770f, 0.00738264f, 
    -0.05099272f, -0.02258979f, -0.00036305f, 0.02354900f, 0.01845340f, -0.02399100f, -0.00578161f, -0.02133527f, 
    -0.02985813f, -0.02420285f, -0.01497110f, -0.00758676f, 0.00747848f, -0.04739797f, -0.02835566f, -0.00568885f, 
    0.00794988f, -0.01147067f, 0.00555491f, -0.01241933f, 0.02184513f, 0.00490382f, -0.03099461f, -0.02040332f, 
    0.00226801f, 0.01441101f, -0.00732986f, 0.00331110f, -0.02276477f, 0.01168893f, -0.01948889f, 0.01432196f, 
    -0.01195034f, -0.01845437f, -0.03724265f, -0.02173596f, -0.03313066f, 0.01455689f, 0.02697531f, 0.01639618f, 
    0.01324053f, 0.02117162f, 0.03057565f, 0.01488492f, 0.02625538f, 0.00970947f, -0.01584056f, 0.02717005f, 
    0.03259466f, -0.02837924f, -0.03649481f, -0.04090941f, 0.02364182f, -0.00689613f, 0.01043539f, 0.01229203f, 
    0.01013856f, -0.00039301f, -0.02328218f, -0.02898108f, 0.02173598f, -0.01797353f, 0.02394788f, -0.00333609f, 
    -0.01522752f, -0.04531837f, -0.04700524f, 0.03037230f, 0.02240214f, -0.05065563f, -0.00691052f, 0.00398848f, 
    0.02667721f, -0.00372722f, 0.02074790f, -0.03543049f, 0.00601007f, -0.01365182f, 0.02599742f, -0.01458908f, 
    0.02936888f, 0.02565550f, -0.03260761f, 0.02410008f, -0.00067381f, -0.00902851f, -0.02955929f, 0.01209837f, 
    -0.03706232f, 0.00074444f, -0.02432062f, -0.03347389f, 0.02376335f, -0.00029017f, -0.03322813f, -0.02287993f, 
    -0.01714059f, -0.01012717f, 0.02161638f, 0.00828601f, -0.02292144f, 0.00821498f, -0.02586871f, 0.01456019f, 
    0.01594213f, 0.00574041f, -0.03668543f, -0.02345475f, -0.02238665f, -0.04612863f, 0.02634262f, -0.03024861f, 
    -0.03084368f, -0.02508200f, -0.02061343f, -0.01405133f, -0.00580478f, -0.02744282f, -0.01240754f, 0.01635604f, 
    -0.01317288f, -0.04726923f, 0.00869828f, 0.01088581f, 0.02423177f, -0.01817006f, 0.00180902f, 0.00274064f, 
    0.03146323f, -0.02727320f, 0.01993036f, -0.03285268f, -0.01105118f, 0.02998598f, -0.01984153f, -0.04479638f, 
    -0.00039458f, -0.00178804f, 0.01971429f, -0.04737755f, 0.00238706f, -0.01775476f, -0.00955631f, -0.02900307f, 
    0.02215643f, 0.00363231f, -0.02944759f, 0.02620108f, -0.02560157f, -0.01625156f, 0.00551925f, -0.01948825f, 
    0.02128634f, 0.00833713f, 0.02362736f, -0.03501374f, -0.02074601f, -0.00892377f, -0.03440386f, 0.02412156f, 
    -0.03417233f, -0.01858612f, 0.01085830f, -0.00816793f, -0.00738821f, 0.01908420f, 0.00510866f, -0.00661686f, 
    0.01516994f, 0.01028589f, -0.00190987f, -0.00735881f, -0.03276657f, -0.01231539f, -0.01091903f, -0.02637739f, 
    -0.04936801f, -0.00937354f, -0.03323652f, 0.02047056f, -0.02808689f, 0.00121244f, -0.01995681f, -0.01186895f, 
    -0.01870271f, -0.04958617f, -0.03574353f, 0.01019790f, 0.02857655f, 0.02103826f, -0.02790316f, -0.04880719f, 
    0.02288273f, 0.00626444f, 0.00676843f, 0.01485307f, 0.02592948f, -0.01367051f, -0.01049324f, -0.04177467f, 
    -0.02291487f, 0.01725379f, -0.00524282f, -0.02693946f, 0.00594164f, 0.00069764f, 0.00126037f, 0.02525235f, 
    0.01045711f, 0.00945431f, 0.02194440f, -0.02162278f, -0.03856140f, -0.01740315f, -0.04319972f, 0.01056981f, 
    -0.00875604f, -0.00315097f, 0.00632845f, 0.00830660f, -0.02400389f, 0.01349576f, 0.02472656f, 0.00250744f, 
    -0.01389193f, -0.02966002f, -0.04476473f, -0.03044639f, -0.01873584f, 0.02498682f, -0.01508763f, 0.00410910f, 
    0.02314297f, 0.02769979f, 0.01051025f, 0.00930552f, -0.05118315f, 0.00055977f, -0.03012359f, -0.01548563f, 
    -0.01192779f, 0.03134437f, -0.03762556f, 0.01208971f, 0.00843451f, -0.03874774f, -0.00221041f, -0.03706099f, 
    0.02340030f, -0.02135905f, -0.01692563f, -0.02876402f, 0.02044996f, -0.01307533f, 0.00486540f, 0.01100581f, 
    -0.04077949f, -0.04136197f, 0.00936393f, 0.02154850f, -0.03099668f, -0.04428103f, -0.00564776f, -0.01165909f, 
    0.01373965f, 0.00080354f, 0.00603720f, -0.04201909f, -0.00123595f, -0.02973849f, -0.03032810f, 0.02574808f, 
    -0.01684385f, -0.00041235f, -0.04052255f, 0.00099907f, -0.00476122f, -0.02003877f, -0.03761150f, -0.03297265f, 
    0.00753200f, -0.02762221f, -0.02566852f, -0.01450839f, 0.01119846f, -0.00897987f, 0.00614942f, -0.04209094f, 
    0.01745516f, -0.01128672f, -0.03756873f, -0.00547229f, 0.00319251f, -0.02545736f, 0.01739789f, -0.03447057f, 
    -0.00110127f, -0.00628707f, 0.02706139f, 0.00854446f, 0.02276165f, -0.04858453f, 0.00824722f, 0.01536924f, 
    0.01739593f, 0.02192168f, -0.00373921f, -0.02806126f, 0.03820039f, -0.00520726f, -0.02971385f, -0.00682594f, 
    -0.00305693f, -0.02846443f, 0.02423016f, 0.02572932f, 0.01712856f, -0.00147840f, 0.02033282f, 0.02455099f, 
    -0.04413477f, 0.02156316f, 0.02188186f, 0.00958016f, -0.02651415f, -0.02110386f, 0.01192189f, -0.04240367f, 
    -0.01715585f, 0.03670961f, 0.01009327f, 0.00215063f, 0.00865586f, 0.01376047f, -0.01748034f, 0.01551355f, 
    0.02024845f, -0.02366954f, 0.01174825f, 0.01408894f, 0.00998218f, -0.01088080f, 0.00610561f, 0.01279932f, 
    0.03215221f, 0.03513303f, 0.01396206f, -0.03367097f, -0.03332125f, -0.02029543f, -0.00143008f, 0.02497708f, 
    0.02404770f, 0.00563715f, -0.02037775f, -0.05185836f, -0.03430213f, 0.00468115f, 0.00390970f, 0.02521598f, 
    -0.04624292f, -0.02966087f, 0.02011287f, -0.03377890f, -0.00330951f, 0.03380442f, 0.00096096f, 0.01707135f, 
    -0.03363840f, -0.00571561f, 0.02207550f, -0.00139423f, -0.03586904f, 0.00668912f, 0.02729393f, 0.02454606f, 
    0.01950772f, -0.01656861f, -0.01746207f, -0.03291752f, 0.01098253f, -0.03530423f, 0.01361950f, -0.02612958f, 
    0.01199561f, 0.02624379f, -0.03670651f, 0.01352302f, 0.01643220f, -0.00544531f, 0.02089141f, -0.02582239f, 
    0.03085984f, 0.00612531f, -0.02352514f, -0.03889408f, 0.00439943f, 0.01727997f, -0.00911849f, -0.00414750f, 
    -0.02655865f, -0.00351098f, 0.00844639f, -0.03071803f, -0.03417952f, -0.00359092f, 0.02031067f, -0.00087701f, 
    -0.03632161f, -0.04274268f, -0.03775142f, 0.02340945f, 0.01885138f, 0.02370697f, -0.01694170f, -0.00510312f, 
    -0.02665690f, -0.00895125f, 0.00882998f, -0.00095557f, 0.00666736f, 0.01633552f, -0.00117132f, 0.02831005f, 
    0.02473262f, -0.00601459f, -0.01013104f, 0.01640196f, -0.00041327f, -0.03371013f, -0.01742693f, -0.01675314f, 
    0.00951301f, 0.01144225f, -0.03476953f, -0.00613518f, -0.03526607f, -0.05250822f, 0.02123559f, 0.01798599f, 
    0.00510180f, -0.03860291f, -0.00614973f, 0.02806362f, -0.01682235f, -0.01583437f, 0.01375864f, -0.02509677f, 
    0.01813714f, 0.01799241f, -0.00326089f, -0.01461138f, 0.02255265f, 0.00004908f, 0.00710775f, -0.01087352f, 
    0.01260788f, -0.01163386f, 0.00808021f, 0.02685444f, 0.01535600f, -0.03115827f, 0.02170354f, 0.01694684f, 
    -0.03633732f, -0.03596787f, -0.02545409f, -0.01719379f, 0.03024476f, 0.02925973f, -0.01447269f, -0.03565258f, 
    0.02390216f, 0.01272319f, 0.02938620f, 0.01998877f, 0.00154813f, 0.02100187f, 0.01398823f, -0.03983633f, 
    -0.02986401f, 0.00514277f, 0.01896346f, 0.02641684f, 0.00233313f, 0.01066838f, -0.04389118f, -0.03187669f, 
    0.13854712f, 0.28764820f, 0.19904466f, 0.04626999f, 0.00895926f, -0.08531707f, -0.10719832f, -0.11328752f, 
    0.01526766f, -0.04964698f, 0.03888829f, 0.00132180f, 0.03319887f, 0.05239989f, -0.03088078f, 0.02706346f, 
    0.02944119f, -0.01204883f, 0.02968238f, -0.03522065f, 0.00699021f, 0.12920015f, 0.13788767f, 0.04795158f, 
    -0.00731122f, 0.00222349f, 0.08942620f, 0.03481380f, 0.02353316f, -0.07149614f, 0.06500142f, 0.02216756f, 
    0.05543068f, 0.12666065f, -0.04430371f, 0.11287073f, -0.01269875f, 0.04934807f, 0.12068627f, -0.01972245f, 
    0.10805129f, -0.02018063f, 0.10559284f, -0.14536777f, -0.02625193f, -0.07127066f, 0.08409531f, 0.04002654f, 
    -0.01659883f, 0.12908415f, -0.11416011f, -0.05936784f, -0.05137471f, -0.02225336f, -0.08281163f, -0.00524103f, 
    -0.02495772f, 0.15653345f, 0.19463792f, -0.03673144f, 0.03462352f, -0.25945312f, 0.08384875f, 0.02929788f, 
    0.10328767f, -0.07279847f, 0.13886769f, 0.02432264f, 0.10801756f, -0.01797496f, 0.01281951f, 0.10100907f, 
    -0.04190246f, 0.11497686f, -0.12434088f, 0.00842614f, -0.05069289f, -0.01987322f, 0.06783164f, 0.00801957f, 
    -0.06792232f, 0.15961620f, -0.18091774f, 0.22314289f, 0.16798258f, 0.12452244f, 0.04964769f, 0.09636021f, 
    0.01365606f, -0.08507036f, -0.08990192f, -0.12337714f, -0.02073441f, -0.00262422f, 0.00836890f, 0.06426682f, 
    -0.07177408f, -0.06058346f, -0.02795241f, -0.06033543f, -0.19961500f, -0.00230367f, -0.15948604f, -0.01373680f, 
    -0.09799006f, 0.03206384f, -0.10982776f, 0.09409700f, -0.05456699f, -0.11473481f, 0.12101524f, 0.01333758f, 
    -0.02975193f, 0.08888281f, -0.14302255f, -0.04300264f, -0.06517618f, -0.02442920f, 0.12894006f, -0.06202284f, 
    0.20450713f, -0.07356573f, -0.15108006f, -0.06068525f, 0.03159567f, -0.03187712f, 0.04756178f, -0.09345851f, 
    -0.01649702f, -0.03448398f, 0.04957410f, -0.03590306f, 0.02391024f, 0.19136654f, 0.05193878f, 0.00599884f, 
    0.01810428f, -0.04926685f, -0.03446103f, 0.11508779f, 0.24320099f, -0.07260929f, -0.10400742f, 0.01733669f, 
    -0.10834787f, -0.07426807f, 0.00984559f, -0.05871684f, -0.03816915f, -0.04794241f, 0.03182404f, 0.03393576f, 
    -0.02337240f, 0.14321712f, 0.13371110f, 0.10976922f, -0.00497563f, -0.10538542f, -0.04192875f, 0.11111762f, 
    0.14904228f, -0.02460847f, -0.01787590f, -0.05019384f, -0.21635997f, -0.04675144f, -0.01469172f, -0.02925578f, 
    0.05991146f, -0.03643388f, -0.05948316f, -0.02629832f, -0.09993566f, -0.07263642f, -0.03263770f, -0.01691019f, 
    0.00067043f, -0.02591830f, 0.08008222f, -0.00319310f, -0.27624524f, 0.13800614f, 0.00496905f, 0.33486444f, 
    0.00137631f, -0.00681710f, 0.16655245f, 0.01455987f, -0.01156781f, 0.14559563f, -0.01110429f, -0.03258635f, 
    -0.04240474f, 0.00391796f, 0.00602253f, 0.02207911f, 0.04399510f, -0.04530608f, 0.14143057f, -0.09490488f, 
    -0.18410730f, 0.11897153f, 0.04644111f, 0.09639218f, 0.15752158f, -0.10097146f, 0.12638208f, 0.04567116f, 
    0.11263371f, 0.03226180f, 0.05815795f, -0.16886404f, -0.03351858f, -0.06691664f, 0.04864696f, 0.08070472f, 
    0.09632001f, -0.18564165f, 0.04959148f, -0.08906472f, 0.16439229f, -0.05544201f, -0.14039747f, -0.00371477f, 
    0.03401906f, 0.04281676f, 0.10018380f, -0.07899208f, 0.00973896f, 0.09526654f, 0.10884024f, 0.04244820f, 
    0.13659088f, 0.06766083f, 0.01832644f, -0.02806150f, 0.04648057f, -0.05137020f, 0.06557522f, 0.03798407f, 
    0.22946300f, 0.23685385f, 0.02941437f, -0.00905757f, 0.03299109f, -0.15520535f, 0.11250365f, -0.00723743f, 
    -0.01577665f, 0.15745535f, -0.05129257f, 0.03281946f, 0.02371187f, 0.04989425f, -0.03151410f, 0.07039499f, 
    0.04363936f, 0.01137081f, -0.10610493f, -0.05065568f, -0.11747012f, 0.01383767f, -0.02852522f, 0.18523365f, 
    0.11274147f, 0.01821741f, 0.06251623f, 0.03564264f, 0.05160901f, -0.09844928f, -0.06283688f, -0.04482244f, 
    0.07312746f, 0.03957626f, -0.10973652f, 0.09946459f, 0.06215525f, -0.07037297f, 0.05600353f, 0.00340306f, 
    -0.14431389f, 0.00241707f, 0.20551959f, 0.12405808f, 0.10684592f, -0.05693266f, -0.01987661f, 0.00285814f, 
    0.07146482f, -0.09014858f, -0.14576133f, -0.04571034f, -0.05538613f, -0.10574035f, 0.02822373f, -0.10950173f, 
    0.01360405f, -0.04289582f, -0.07623371f, 0.02929049f, 0.23771906f, -0.34160644f, 0.08217778f, 0.05808252f, 
    0.09787470f, -0.04215150f, -0.00229982f, -0.04211776f, 0.05721315f, 0.19465546f, -0.08810089f, -0.02335689f, 
    -0.02499497f, 0.09030503f, 0.10084707f, -0.00813159f, 0.08773043f, 0.14153975f, 0.15671422f, -0.09603205f, 
    -0.32849607f, -0.02026999f, 0.14372802f, 0.28231308f, 0.09839610f, -0.00225549f, 0.02642808f, 0.07859316f, 
    0.03096768f, -0.13446677f, -0.21355706f, 0.03779751f, 0.09870008f, -0.18075447f, -0.01430594f, -0.01553524f, 
    -0.02100292f, -0.02384498f, -0.08692735f, 0.05299920f, 0.36625785f, -0.10168274f, -0.03433814f, -0.04792885f, 
    -0.28380957f, 0.14526221f, 0.05245698f, -0.01991813f, -0.01692277f, 0.07339856f, -0.05525286f, -0.07218070f, 
    -0.07341862f, -0.08241531f, -0.08277360f, 0.03013360f, -0.00804072f, -0.02325195f, 0.08613586f, -0.00819338f, 
    0.12654914f, -0.12014871f, 0.03516117f, 0.02036271f, 0.12216825f, 0.05891355f, 0.01176189f, -0.12014831f, 
    0.09944339f, -0.02545646f, -0.06397551f, -0.00704159f, -0.08391910f, -0.07280912f, -0.00144713f, -0.14668454f, 
    0.07453150f, 0.02580940f, -0.00285564f, 0.00408483f, 0.63965112f, -0.23188435f, 0.04994458f, -0.23963739f, 
    -0.12729838f, 0.00450774f, -0.09437834f, 0.06529149f, -0.00806665f, 0.03805876f, -0.10973145f, -0.07529064f, 
    -0.04880903f, -0.04991498f, 0.04004237f, 0.08924799f, -0.08835132f, 0.09011823f, -0.06166272f, 0.04424785f, 
    -0.44738314f, 0.27410391f, -0.15572508f, -0.10345087f, 0.12850223f, 0.12456662f, -0.03623962f, 0.03426252f, 
    0.08521361f, 0.01189187f, -0.02622412f, 0.06669322f, -0.03616341f, -0.01945373f, -0.02148618f, -0.03172613f, 
    -0.03495261f, -0.08546366f, 0.06270801f, 0.13011836f, 0.23914239f, 0.09700810f, 0.06433593f, -0.21864903f, 
    -0.26992509f, -0.05581316f, 0.02505267f, -0.11316283f, 0.04678166f, 0.06597010f, 0.03195389f, 0.01587360f, 
    0.04572921f, 0.02986954f, 0.04633785f, 0.02487629f, -0.04042331f, -0.03712532f, 0.05938714f, 0.02018232f, 
    0.25429255f, 0.13967150f, 0.18613464f, 0.11417926f, -0.10529730f, -0.18153019f, -0.08216289f, 0.05612216f, 
    0.01279802f, -0.09863106f, -0.05559594f, 0.07782049f, -0.06249099f, -0.07564595f, 0.05042562f, -0.07976094f, 
    0.01373708f, -0.08331567f, -0.01309394f, -0.08148894f, -0.43078816f, 0.22966683f, -0.27008423f, -0.10883038f, 
    0.09186234f, 0.06706327f, -0.09093698f, -0.03133615f, 0.04601023f, 0.08352549f, -0.01445820f, 0.00976050f, 
    0.03187791f, -0.15016818f, 0.07307265f, -0.00383495f, 0.13152990f, 0.02332348f, -0.00252195f, 0.00184708f, 
    -0.14462300f, 0.02093872f, 0.03356432f, 0.16982096f, 0.06689187f, -0.01710649f, 0.05147414f, 0.02727307f, 
    -0.08970104f, 0.07632251f, -0.05714220f, -0.00254412f, 0.00663744f, -0.02483034f, -0.05349513f, -0.06883848f, 
    -0.05353355f, 0.16060217f, 0.03225169f, -0.01229802f, -0.30933794f, -0.04181536f, 0.09997138f, 0.14565052f, 
    -0.03867666f, 0.04329123f, 0.06324495f, 0.11997177f, -0.07283346f, 0.05728643f, -0.09152363f, -0.06492654f, 
    0.06411908f, 0.00701323f, -0.05090829f, 0.04544728f, -0.03277598f, 0.00526692f, -0.03036743f, -0.01982411f, 
    -0.03923973f, 0.20014444f, 0.12451264f, -0.20216987f, 0.18865263f, 0.03562520f, 0.05095772f, 0.06356256f, 
    0.11429898f, 0.17042612f, -0.03637256f, -0.01854606f, 0.07489412f, 0.02206728f, 0.06888986f, 0.03307303f, 
    0.06972436f, 0.17994711f, 0.07175116f, 0.19159384f, -0.35407162f, 0.15483335f, 0.04537218f, 0.03279446f, 
    -0.09232914f, 0.13348396f, 0.01258106f, 0.10108426f, 0.00065820f, -0.07485245f, -0.04435778f, -0.01959468f, 
    -0.07751619f, 0.05345032f, -0.05871239f, -0.08839711f, 0.02352394f, -0.11342759f, -0.02441446f, -0.03931742f, 
    0.04932366f, -0.03301457f, -0.32992604f, -0.06716014f, -0.06133221f, 0.06019745f, 0.00966688f, -0.13473427f, 
    0.09280886f, 0.05646283f, 0.00896448f, 0.11473286f, 0.08591287f, 0.08114841f, 0.03721847f, 0.09158792f, 
    0.18617271f, 0.05545073f, 0.09909970f, -0.04520371f, 0.36876413f, -0.13618751f, 0.00174999f, 0.13273269f, 
    0.04686583f, -0.04321050f, 0.08957528f, -0.04570496f, -0.04297875f, 0.03347770f, 0.01889443f, 0.05895901f, 
    0.03587918f, -0.02662550f, 0.02574651f, 0.02979215f, 0.13096932f, 0.09244683f, 0.05142713f, 0.09209827f, 
    0.02001069f, -0.09026499f, 0.01049074f, -0.00351456f, -0.13986909f, 0.10296945f, 0.08794810f, 0.08232667f, 
    0.04028041f, -0.02867938f, 0.07231066f, 0.08048212f, 0.01103354f, 0.06176028f, -0.06591620f, -0.00299343f, 
    0.05696130f, -0.04269320f, -0.04306515f, -0.01608658f, 0.22010820f, -0.15628956f, -0.02491395f, 0.10270510f, 
    -0.12999353f, -0.01891105f, -0.11194221f, -0.02297477f, -0.03651647f, -0.04747188f, -0.02883206f, -0.04671303f, 
    -0.11885206f, 0.05266085f, 0.05446652f, -0.04122832f, -0.03269363f, -0.00909547f, 0.16127904f, 0.02845353f, 
    -0.03223969f, -0.07420885f, -0.05424428f, 0.16889994f, 0.12097199f, -0.00662840f, 0.14294530f, -0.09358322f, 
    -0.03442441f, -0.18355685f, 0.08854696f, 0.13376439f, -0.06261634f, -0.15540686f, 0.01891606f, -0.09102433f, 
    0.05061192f, -0.05121923f, -0.07966735f, -0.03029375f, 0.19122894f, 0.03418983f, -0.04375599f, 0.24620020f, 
    0.07225229f, 0.09316042f, -0.02652813f, 0.07497920f, 0.09262908f, 0.13882159f, 0.06593079f, 0.01608858f, 
    0.01596854f, -0.05371841f, 0.12077966f, 0.10003851f, -0.09907387f, -0.01132415f, -0.04597379f, 0.02581940f, 
    -0.42775285f, -0.00593506f, -0.13849807f, -0.23599800f, -0.03006502f, -0.08193215f, -0.01069942f, 0.05616064f, 
    0.18113990f, -0.00499362f, 0.00422737f, -0.01593249f, -0.00895700f, 0.02241652f, -0.04062207f, 0.14417477f, 
    0.08327984f, 0.00370404f, 0.10938326f, -0.03391457f, 0.25008294f, -0.04896619f, 0.12793379f, 0.17604402f, 
    -0.14012906f, 0.08479678f, -0.07520235f, -0.03679350f, -0.04263812f, -0.00276014f, 0.12660488f, 0.11512055f, 
    0.08887255f, -0.14168525f, 0.03115150f, 0.00758330f, 0.02695022f, 0.04862058f, 0.02916374f, 0.04540553f, 
    0.17181832f, -0.17602491f, 0.22107531f, -0.03478087f, -0.07030391f, 0.09637775f, 0.13770555f, -0.05321089f, 
    0.03086483f, 0.00979796f, 0.06130155f, 0.03233810f, -0.06322420f, -0.07986288f, -0.12070461f, -0.07750973f, 
    0.20488702f, 0.06068777f, 0.08518665f, 0.03044000f, 0.21994174f, -0.35157740f, -0.08324321f, -0.09658343f, 
    0.27539128f, 0.02062750f, 0.07103216f, -0.03132922f, -0.00874343f, 0.15065913f, -0.12603189f, 0.22476143f, 
    0.05896964f, 0.04470577f, 0.13898808f, -0.04787941f, -0.02898075f, -0.13256560f, -0.06888770f, -0.03750582f, 
    0.43540263f, 0.03253543f, -0.22454086f, 0.10485739f, 0.10101929f, 0.17980208f, -0.06470840f, 0.11610964f, 
    -0.00739356f, 0.02331655f, 0.04211492f, 0.01116865f, 0.08627110f, 0.07248837f, 0.02588740f, 0.09356599f, 
    0.03308883f, 0.00529254f, 0.01981461f, -0.03083963f, 0.16184798f, 0.19223176f, -0.04649010f, 0.00692662f, 
    0.13734061f, 0.04612192f, -0.13779785f, 0.04460809f, -0.06795587f, 0.05134597f, 0.03804799f, 0.11376520f, 
    0.01144520f, 0.06606110f, -0.02590333f, -0.07880390f, 0.09079243f, 0.02945018f, 0.02135096f, -0.00544533f, 
    0.21329659f, 0.08527692f, -0.00411478f, 0.01019116f, 0.23947267f, -0.12670374f, 0.06564610f, -0.03284865f, 
    -0.01288209f, 0.01204733f, -0.03373276f, 0.07322336f, 0.06226752f, -0.04515534f, 0.07763256f, 0.05703568f, 
    -0.02643609f, -0.01208275f, 0.04694291f, -0.01162881f, -0.08315552f, -0.17246608f, -0.09806243f, -0.53661734f, 
    -0.21767935f, 0.13384022f, 0.00381925f, -0.01785106f, 0.05227482f, -0.04179590f, 0.06324229f, -0.00328181f, 
    0.08206291f, 0.07118225f, -0.07284863f, -0.03134771f, 0.12111758f, -0.01211946f, -0.00466704f, 0.03850060f, 
    0.19516025f, -0.19511147f, -0.01666944f, -0.17954899f, 0.02147219f, 0.20198222f, -0.00602517f, -0.00926496f, 
    -0.16884795f, -0.10420059f, -0.06569067f, 0.10349547f, 0.04569780f, 0.15623087f, -0.08821412f, -0.05746360f, 
    0.02476532f, 0.04945210f, 0.05250893f, 0.00014409f, 0.37947723f, -0.07945445f, 0.00415382f, -0.10280903f, 
    0.15925421f, 0.08800612f, -0.04019223f, 0.03220899f, 0.12393226f, 0.06225056f, -0.03078563f, -0.08191164f, 
    -0.00229213f, 0.18497409f, 0.04854690f, 0.02475011f, 0.10712007f, 0.01568720f, -0.00018801f, -0.02956797f, 
    -0.26764688f, -0.02610018f, -0.17884877f, -0.27689323f, -0.37165618f, -0.05162377f, -0.10720479f, 0.12730040f, 
    -0.09652127f, -0.06424868f, -0.03633032f, -0.03409001f, -0.09523644f, 0.08191567f, 0.13208033f, -0.00847404f, 
    0.10786889f, -0.00604436f, -0.06871108f, 0.03871838f, 0.14992064f, 0.02704736f, 0.15377991f, 0.11639054f, 
    -0.04717088f, 0.15903990f, 0.03408841f, 0.01986358f, -0.05178686f, 0.02107378f, 0.08010463f, 0.02012696f, 
    -0.05291841f, 0.03329411f, -0.05472232f, -0.05694784f, -0.09304287f, 0.04304964f, 0.04895814f, -0.02205014f, 
    0.24643597f, 0.12268712f, 0.03448432f, -0.00482833f, 0.12200262f, 0.07023445f, 0.09927402f, -0.10153965f, 
    0.01940632f, -0.02954532f, 0.06434286f, 0.02718538f, 0.00594813f, 0.03448662f, -0.03406582f, -0.02795345f, 
    0.11199164f, -0.02192125f, 0.08702625f, 0.08519307f, -0.26868695f, -0.00102349f, 0.06925222f, 0.10758586f, 
    -0.04467897f, -0.07452244f, -0.05424847f, 0.00622415f, 0.01645827f, 0.10297137f, -0.03177273f, -0.10991626f, 
    0.02969925f, 0.11185678f, 0.08065472f, 0.17846993f, 0.05353277f, -0.08909917f, -0.00599532f, 0.00377925f, 
    0.36703080f, 0.15182246f, 0.19406575f, -0.05046282f, 0.04462609f, 0.02349251f, 0.12410633f, -0.08291112f, 
    -0.00047907f, 0.05624349f, 0.11664829f, -0.04543784f, -0.04198122f, -0.01824626f, -0.11433458f, -0.03356481f, 
    0.03937426f, -0.05023617f, 0.03507278f, 0.03270483f, 0.06363109f, -0.14149609f, 0.06398650f, -0.30139613f, 
    0.19937828f, -0.15687492f, -0.00499966f, -0.02480536f, 0.12992753f, 0.02270421f, 0.04624243f, 0.07652571f, 
    -0.01281366f, -0.02645337f, 0.09097154f, 0.12573564f, -0.02063224f, 0.13014130f, 0.14791831f, 0.10596073f, 
    0.05135653f, -0.24414615f, -0.27955794f, -0.10165301f, 0.16041560f, -0.04068982f, -0.00606309f, -0.01685579f, 
    -0.16148162f, 0.11815819f, 0.03153072f, -0.17834315f, -0.04586799f, -0.02719819f, -0.01902483f, 0.03056096f, 
    -0.06502084f, -0.00214845f, -0.05176702f, 0.03285923f, -0.15301770f, 0.28174731f, -0.13085432f, 0.01997737f, 
    -0.31963387f, 0.01729558f, 0.01244336f, -0.04449328f, -0.02817581f, -0.06939585f, 0.10767993f, 0.06734862f, 
    -0.02606046f, 0.07956760f, 0.00265394f, 0.04046649f, 0.11971875f, 0.12718891f, 0.02118353f, -0.00209819f, 
    -0.04350922f, -0.36814624f, -0.01731150f, 0.32256985f, 0.02454126f, 0.02095001f, 0.09708542f, 0.02817359f, 
    -0.03597724f, 0.10772789f, -0.02241535f, -0.08623876f, 0.01068435f, 0.03217552f, -0.12648480f, -0.04357616f, 
    0.06235098f, 0.02114248f, -0.03129992f, 0.04577288f, -0.41138005f, -0.06197373f, 0.04261321f, 0.09146429f, 
    -0.13947767f, 0.13361783f, -0.03031405f, 0.03131954f, 0.02002063f, -0.02380320f, -0.02167842f, -0.04836151f, 
    -0.04028881f, 0.09288453f, 0.08990496f, 0.08753956f, -0.04133554f, 0.05794120f, -0.09907109f, 0.06519194f, 
    0.14064211f, 0.21184066f, -0.05139702f, 0.17991285f, 0.03730047f, 0.13329622f, 0.07363094f, -0.13291778f, 
    -0.19889691f, -0.09008317f, -0.00061162f, 0.17483304f, -0.01987834f, -0.07743148f, -0.05684875f, -0.16659687f, 
    0.06709049f, -0.03570306f, 0.04986867f, -0.10495491f, -0.00183960f, -0.52538705f, -0.04417710f, 0.02296160f, 
    0.01571032f, 0.14799044f, 0.08164538f, -0.01753206f, -0.13920313f, 0.22211748f, -0.05772705f, 0.10699138f, 
    0.03361317f, 0.11280245f, 0.10669517f, 0.07577131f, -0.04389062f, -0.08996757f, 0.05433302f, -0.17114457f, 
    -0.08888569f, 0.14988549f, -0.12766524f, -0.18780376f, -0.05301085f, 0.00014142f, 0.05329062f, 0.03076200f, 
    -0.01828019f, -0.10891315f, 0.06951384f, -0.03344906f, -0.03182353f, -0.03998966f, 0.01716014f, -0.02484317f, 
    -0.09830146f, 0.02348313f, 0.10338632f, 0.09082965f, -0.08176190f, -0.00081345f, -0.06187380f, -0.35130501f, 
    -0.13603875f, 0.06914073f, 0.08678401f, -0.01121014f, 0.08212946f, -0.01203430f, 0.11865532f, 0.07454027f, 
    -0.01155887f, -0.04110404f, -0.07525191f, -0.04404819f, -0.08729684f, 0.00049972f, 0.12552753f, -0.01012851f, 
    -0.19370787f, -0.29864573f, -0.14963515f, -0.03444686f, 0.02961359f, -0.09183519f, -0.06516115f, 0.02504126f, 
    0.02500437f, -0.03131056f, 0.09363062f, -0.02978471f, 0.02918676f, -0.04405802f, 0.04226718f, 0.19251728f, 
    0.18010472f, 0.03065103f, 0.03736806f, -0.05238895f, 0.15824305f, -0.19408795f, 0.28032872f, -0.13885504f, 
    0.06822880f, 0.04560350f, 0.05304314f, -0.04425264f, -0.02341576f, 0.04970378f, 0.09382251f, 0.02133678f, 
    0.07579279f, -0.07854678f, -0.03935907f, 0.00376452f, -0.04174537f, 0.03537386f, 0.06259391f, -0.01006063f, 
    -0.04180957f, -0.46571419f, 0.02378731f, 0.04549384f, -0.02787591f, 0.09205776f, 0.01951023f, -0.04523919f, 
    -0.08668220f, 0.10028037f, -0.04274204f, -0.02332982f, -0.07325280f, 0.17821473f, 0.04817873f, -0.03859018f, 
    -0.13078497f, -0.13470370f, -0.07395814f, -0.07734796f, -0.15787186f, 0.02457536f, -0.01052330f, -0.08388247f, 
    -0.11215531f, -0.12328582f, -0.04909879f, 0.12665987f, 0.09721296f, -0.03042340f, -0.02099459f, 0.04296119f, 
    0.02666465f, 0.15471643f, 0.04866615f, 0.02437805f, -0.03053822f, -0.12106598f, 0.13906696f, -0.04370010f, 
    0.35991174f, -0.07068235f, 0.13406518f, -0.00209422f, 0.27289316f, 0.03874880f, 0.09202165f, -0.06424966f, 
    0.05849473f, 0.02909539f, 0.08326804f, 0.00128564f, 0.10866430f, -0.05823334f, 0.00610258f, 0.10746826f, 
    0.03986274f, -0.01255246f, 0.00177206f, 0.06067373f, 0.01725806f, -0.10316022f, 0.00320718f, -0.03699494f, 
    0.05566946f, -0.07032441f, 0.01855669f, -0.03000091f, -0.00496426f, 0.11480664f, -0.01922840f, -0.04938689f, 
    0.12157845f, -0.03589866f, 0.08003657f, -0.00243703f, 0.13239717f, 0.06398855f, -0.06732094f, 0.11243082f, 
    0.03020624f, 0.01756111f, -0.01923010f, 0.00864192f, -0.03519532f, -0.02830570f, -0.01228201f, 0.02588847f, 
    0.02597130f, -0.03706706f, 0.03129089f, 0.00544690f, 0.03086275f, -0.01332717f, 0.00570447f, 0.00042038f, 
    -0.01407214f, -0.00767554f, -0.01063839f, 0.02609376f, 0.00024047f, 0.03059957f, -0.01970390f, -0.01760575f, 
    -0.02582630f, -0.04208138f, 0.02959809f, 0.01523369f, 0.03370102f, -0.00844414f, -0.03168721f, -0.01338951f, 
    -0.02854229f, -0.04030836f, -0.00354291f, -0.01203406f, -0.04063431f, 0.00882278f, 0.02063181f, 0.01823318f, 
    -0.00985233f, 0.01354654f, -0.02100156f, -0.03571031f, -0.02953124f, -0.01413330f, 0.02382513f, 0.02433584f, 
    -0.00540086f, 0.02715100f, 0.02011999f, -0.01036205f, -0.02416957f, 0.00074572f, -0.03334953f, -0.02859377f, 
    -0.01767675f, -0.00363889f, 0.01042634f, -0.00727732f, 0.03273972f, 0.02790097f, 0.01041928f, -0.02565931f, 
    0.02641185f, -0.04124537f, -0.02763092f, 0.02338252f, 0.00381982f, -0.04478649f, -0.00131823f, -0.02865666f, 
    -0.02819387f, 0.02247879f, -0.03061892f, 0.02643337f, 0.01572437f, 0.00196509f, -0.03953717f, 0.03100074f, 
    0.01355719f, -0.02224441f, -0.00441783f, -0.03345007f, 0.03077633f, -0.03459154f, -0.03773243f, -0.02310865f, 
    0.01862648f, 0.01784253f, -0.00207918f, -0.01203117f, -0.03324249f, 0.03374458f, -0.00767334f, -0.01811493f, 
    -0.02920585f, -0.03330171f, 0.00370783f, 0.00117715f, 0.00793169f, -0.02303739f, 0.02539469f, 0.00836547f, 
    0.03205017f, -0.03820347f, 0.01273573f, 0.02695797f, 0.02229239f, 0.02173253f, 0.00180834f, 0.02404582f, 
    -0.01746191f, -0.00618339f, -0.04314474f, -0.04410705f, -0.02473609f, 0.03160045f, -0.03486332f, -0.02404313f, 
    -0.01007554f, -0.03212325f, -0.01903229f, 0.00393580f, -0.01247096f, -0.03399820f, -0.03474146f, 0.00760736f, 
    0.03270075f, -0.00474764f, 0.00481669f, -0.01549470f, 0.00475117f, -0.02470113f, 0.01678026f, 0.00204758f, 
    -0.03394908f, 0.03006476f, 0.02754126f, 0.01359052f, -0.01716007f, -0.00754703f, -0.04361437f, -0.04403896f, 
    -0.01659906f, -0.03622715f, 0.00864419f, 0.02357697f, -0.03506136f, -0.03936400f, -0.01626604f, -0.01828296f, 
    0.02306448f, 0.00126337f, 0.02921498f, -0.02475099f, 0.00219989f, -0.04284810f, -0.01118391f, 0.01851269f, 
    -0.00241748f, -0.03183977f, 0.03310676f, 0.02219590f, 0.02092568f, -0.02542883f, 0.00993995f, 0.02210904f, 
    -0.00769793f, 0.02694539f, -0.02861598f, -0.01444761f, -0.02601468f, -0.02295579f, -0.00753258f, -0.01999522f, 
    0.01393019f, 0.02450734f, -0.03011060f, -0.03909320f, -0.01081212f, 0.00981580f, -0.00139132f, -0.01643029f, 
    0.03993343f, -0.02993144f, -0.02362912f, 0.02991255f, 0.00169431f, -0.01090224f, -0.00597614f, 0.00547756f, 
    0.01934993f, 0.00242150f, 0.02172471f, 0.02103424f, -0.04419715f, -0.02892160f, -0.01492737f, -0.00226259f, 
    -0.01881874f, -0.01056444f, 0.02484308f, 0.00182122f, -0.00643441f, 0.03072134f, -0.02576499f, -0.00415356f, 
    0.00037701f, 0.01395258f, -0.03143176f, -0.01453430f, 0.02437559f, 0.02439160f, -0.00437059f, 0.01222577f, 
    -0.02274777f, 0.01751648f, -0.00662364f, 0.01973554f, -0.03097001f, 0.03239097f, -0.00547826f, -0.03441719f, 
    -0.04181174f, -0.01526976f, 0.02033045f, -0.03960231f, 0.02047916f, 0.01918192f, 0.02365977f, -0.00260184f, 
    0.00010403f, 0.00963969f, -0.02583824f, -0.03937931f, -0.02448343f, -0.04489017f, -0.04189042f, -0.00956178f, 
    -0.04235506f, -0.00177491f, -0.02477601f, -0.00048338f, -0.01853957f, 0.02040518f, -0.02476305f, -0.00950290f, 
    -0.02179378f, 0.00069808f, 0.00150063f, -0.01660755f, -0.02819789f, 0.01357942f, -0.00689334f, -0.00204811f, 
    -0.04455636f, 0.01788295f, 0.02895736f, 0.01191585f, 0.00045006f, 0.01961555f, 0.02376513f, 0.00905930f, 
    0.00822248f, 0.01143186f, 0.01504759f, -0.03935339f, 0.02184805f, -0.00177732f, -0.03401905f, -0.00483277f, 
    -0.00323349f, 0.00798264f, -0.03210654f, -0.01711928f, -0.02181029f, -0.03489016f, -0.02669616f, 0.03011419f, 
    -0.02940102f, -0.01564592f, -0.04265636f, -0.00733531f, 0.02571004f, -0.02033255f, -0.01305725f, 0.00341224f, 
    0.03059874f, -0.02008809f, -0.00505270f, -0.03962774f, -0.00231926f, -0.02831403f, -0.02871952f, 0.01336748f, 
    -0.00253125f, -0.00060768f, 0.01373504f, -0.01083517f, -0.02913513f, 0.02982108f, -0.02856960f, -0.01811456f, 
    0.03337318f, -0.01455612f, -0.03327855f, -0.01739936f, -0.01858319f, -0.00946547f, 0.01433481f, 0.04042423f, 
    -0.02485370f, 0.04019430f, -0.02749901f, -0.01825202f, 0.00007155f, -0.02074568f, -0.02190435f, -0.02817283f, 
    -0.02793981f, -0.04141296f, 0.02721305f, -0.00462759f, 0.00199989f, 0.00916689f, -0.02034340f, -0.01024770f, 
    0.00919516f, 0.02889731f, 0.01394170f, -0.03205225f, -0.02514829f, -0.00185818f, -0.00308374f, -0.04373601f, 
    0.02037526f, -0.01327628f, -0.01409865f, -0.03215721f, 0.01146127f, 0.02392854f, -0.00109511f, -0.03893875f, 
    0.00260661f, 0.03282302f, 0.02858304f, 0.00889587f, -0.03494868f, 0.00600175f, -0.03152693f, -0.03322469f, 
    -0.03315362f, -0.00932380f, 0.02135050f, -0.02363695f, -0.03543344f, 0.00766934f, -0.00501293f, -0.03087462f, 
    -0.04036913f, -0.00135347f, 0.00312720f, -0.00437233f, -0.03433020f, 0.01989334f, 0.03361631f, -0.02740340f, 
    -0.00098939f, -0.04440941f, 0.02020906f, -0.03647009f, -0.02666231f, -0.00900366f, -0.00304993f, -0.02270410f, 
    -0.01087874f, -0.04380649f, 0.00542294f, -0.00577343f, 0.02088995f, -0.00855977f, 0.01996670f, -0.00164157f, 
    -0.04082147f, 0.00493967f, -0.02839393f, 0.01147567f, -0.02398016f, -0.03616228f, -0.01031469f, -0.01599636f, 
    -0.02293655f, -0.04169551f, 0.01223097f, 0.02299969f, 0.02089606f, -0.03274631f, -0.02256264f, -0.01593854f, 
    0.01628412f, 0.01940929f, 0.02561173f, 0.02751998f, 0.02295659f, -0.02127576f, -0.02055705f, -0.00512508f, 
    -0.02021526f, -0.02963483f, 0.01089519f, 0.02303297f, 0.01156161f, -0.01207611f, 0.01129310f, 0.01019724f, 
    0.01769917f, -0.00868309f, 0.01399716f, 0.00999928f, 0.01317732f, -0.03534168f, 0.01838467f, -0.02388632f, 
    0.01108553f, 0.03291387f, -0.02750350f, 0.03062263f, -0.01480589f, -0.03883144f, 0.02675547f, 0.01482227f, 
    -0.03456607f, 0.02482121f, 0.00418078f, 0.02766784f, -0.02327480f, 0.01064559f, -0.02210318f, -0.00029812f, 
    -0.03837762f, -0.01575779f, -0.01774019f, -0.01493505f, -0.00419837f, 0.00209872f, 0.00601310f, -0.03716915f, 
    -0.03622077f, -0.03057070f, 0.00524450f, 0.02926600f, 0.02038709f, -0.04175068f, -0.03008535f, -0.04462107f, 
    -0.00760250f, -0.01018464f, 0.03114674f, 0.02232428f, 0.01836742f, 0.02982243f, -0.04146819f, 0.03029964f, 
    0.00345148f, 0.03291502f, -0.02674906f, -0.03862264f, -0.00845806f, 0.00595790f, -0.03745559f, -0.02674364f, 
    0.01239923f, 0.00740666f, -0.03207808f, 0.00904571f, -0.01484525f, -0.03962881f, 0.02534512f, -0.00760304f, 
    -0.04147629f, 0.00620807f, -0.02580025f, 0.02829624f, -0.01771404f, -0.03025722f, 0.02405031f, 0.03375053f, 
    -0.04409290f, -0.01719903f, 0.00940396f, -0.04267360f, -0.04275227f, -0.03503109f, -0.00810841f, 0.01761349f, 
    0.00298543f, 0.02101734f, 0.00871332f, 0.00141263f, -0.04261965f, -0.00453215f, -0.01868015f, 0.04457224f, 
    0.01317906f, -0.00104137f, -0.01502818f, 0.01338350f, -0.04299536f, -0.00133910f, 0.03087457f, -0.02200231f, 
    -0.02040953f, -0.04214318f, -0.02103840f, -0.02996810f, 0.00382753f, 0.02167418f, 0.01490742f, -0.03381477f, 
    -0.02776901f, -0.00882199f, -0.03508477f, -0.01408355f, 0.01757810f, 0.02524397f, -0.03182388f, -0.00348378f, 
    0.02104231f, -0.00464990f, -0.01614577f, -0.00360302f, -0.04469661f, -0.02102521f, -0.02538401f, 0.02831842f, 
    0.01625385f, -0.00791466f, -0.04001353f, -0.04404630f, 0.00989805f, 0.02377992f, -0.01211481f, -0.00428096f, 
    0.02718494f, -0.00996097f, 0.02115213f, 0.01544946f, -0.00309518f, -0.02996332f, -0.02971751f, 0.00194176f, 
    -0.01154010f, -0.03721778f, 0.02504898f, -0.01442852f, 0.03341484f, 0.01509790f, 0.02704873f, -0.03912267f, 
    0.02696129f, 0.00597899f, 0.01151172f, -0.02897934f, 0.00606862f, -0.01062892f, -0.04434950f, -0.04374388f, 
    -0.03406125f, -0.02916636f, -0.02754136f, -0.00940053f, 0.01932613f, 0.01888735f, -0.03131163f, -0.02356905f, 
    0.02562418f, -0.00401021f, -0.00536700f, 0.02875411f, -0.01916456f, -0.02215228f, -0.02118534f, 0.02761259f, 
    -0.02397996f, -0.02446918f, -0.00918230f, 0.00019971f, -0.00364775f, 0.00975543f, -0.03256357f, 0.01532186f, 
    0.02574472f, -0.01405378f, 0.03152882f, 0.00387186f, 0.01162025f, 0.01587129f, -0.00636372f, -0.02069180f, 
    -0.00738940f, -0.03618822f, -0.04322642f, 0.01583315f, 0.01305619f, -0.03054436f, -0.03847924f, -0.04145270f, 
    -0.01611879f, -0.01288845f, 0.03021643f, -0.00345428f, -0.00846223f, -0.00085157f, -0.01496793f, -0.00032943f, 
    0.02418611f, 0.01871991f, 0.02405444f, -0.03221329f, -0.01582156f, 0.03186951f, -0.02084562f, 0.02609937f, 
    -0.02272370f, 0.00769758f, -0.03112232f, -0.02936915f, -0.03501457f, -0.02084715f, -0.02998869f, 0.00689132f, 
    0.03336394f, -0.00472218f, -0.02692007f, -0.03677024f, -0.03871262f, 0.03132024f, -0.02515739f, 0.02102767f, 
    0.00165580f, -0.03397848f, 0.03532548f, 0.01756852f, -0.01365386f, -0.03574112f, -0.01393292f, -0.02760000f, 
    -0.00587855f, 0.01873611f, -0.00584412f, -0.00907961f, -0.02799815f, -0.03017104f, -0.02848977f, 0.02689888f, 
    -0.04460330f, -0.00480695f, 0.00824858f, -0.00383894f, 0.02205456f, 0.00919728f, -0.02419461f, -0.01392597f, 
    -0.04054378f, 0.02218731f, -0.03306976f, -0.03739899f, -0.03643279f, 0.04092598f, -0.00748754f, -0.04463352f, 
    0.01317427f, 0.03179975f, -0.01169106f, 0.03134630f, 0.03009741f, -0.03537029f, 0.01969045f, -0.03574772f, 
    0.03153969f, -0.03849380f, 0.00198697f, 0.02162615f, -0.01542117f, -0.03059142f, 0.02442417f, -0.01126191f, 
    0.01958450f, 0.00269397f, -0.02877383f, 0.01918104f, -0.00388662f, -0.01193280f, 0.02645907f, 0.01980245f, 
    0.01310522f, 0.00457055f, -0.02066237f, 0.00687879f, -0.02084896f, -0.02155836f, 0.01247610f, 0.00419488f, 
    -0.02116613f, -0.03384072f, -0.01927448f, 0.01104163f, 0.02961746f, -0.02378194f, -0.04203196f, -0.02679927f, 
    -0.03983718f, 0.02383254f, 0.01108286f, 0.02736260f, -0.00360155f, -0.02539575f, 0.01118575f, 0.01802962f, 
    0.02829499f, 0.02166690f, -0.01726635f, 0.01075891f, -0.03602016f, -0.00849785f, 0.00700486f, 0.01933208f, 
    0.01408145f, 0.00822499f, 0.01113993f, -0.04607513f, 0.01174222f, 0.02258705f, 0.03262380f, -0.01934908f, 
    0.02902674f, 0.02842788f, -0.00637267f, 0.02190840f, 0.01371059f, -0.03309881f, 0.00075901f, 0.00047700f, 
    0.01231940f, 0.00606776f, 0.01589097f, -0.03348949f, -0.01027769f, -0.02018549f, 0.01322622f, -0.04716314f, 
    0.01054318f, 0.01607187f, 0.00220058f, 0.00238433f, 0.02919424f, -0.00256373f, 0.01576594f, -0.01503634f, 
    0.00542727f, -0.02071954f, -0.03943402f, 0.00958362f, 0.01205093f, 0.03146640f, -0.04513803f, -0.04406497f, 
    0.00622437f, -0.03479970f, -0.04178508f, 0.00148004f, 0.02114998f, 0.01627169f, -0.04380411f, 0.00082559f, 
    -0.04429778f, 0.02941813f, 0.02545261f, -0.00240226f, -0.03465433f, -0.03273602f, -0.02035277f, -0.02472309f, 
    -0.03240845f, 0.00557332f, -0.02496048f, -0.00098288f, -0.04427931f, -0.01314659f, 0.02629709f, -0.04325936f, 
    -0.01073798f, -0.00244485f, -0.00739360f, -0.01768471f, -0.03058324f, -0.00091239f, -0.01340068f, 0.02103327f, 
    -0.01502234f, -0.02135839f, -0.01570779f, 0.03315318f, -0.02589628f, 0.02843138f, 0.03055068f, -0.01893467f, 
    -0.01894959f, 0.00865166f, 0.02795933f, -0.04533089f, -0.02035469f, 0.02500733f, -0.03855119f, -0.04410490f, 
    0.00273129f, -0.02751005f, -0.01392050f, -0.00254874f, 0.02645688f, 0.02723337f, 0.02158243f, -0.04285560f, 
    -0.00639979f, 0.01875095f, -0.02580913f, 0.00099235f, -0.00978090f, -0.04183245f, 0.02941361f, 0.01987213f, 
    -0.03702122f, 0.01938389f, -0.03771949f, -0.02463974f, -0.01152170f, -0.00928959f, -0.02563956f, -0.04660018f, 
    -0.04305159f, -0.00917901f, -0.02995878f, -0.01242485f, -0.00154493f, -0.04426955f, -0.00104142f, -0.04515873f, 
    0.02399519f, -0.03978137f, -0.03576159f, -0.00132240f, 0.00672929f, 0.01730144f, -0.03261637f, 0.01569642f, 
    -0.03117019f, 0.01385776f, -0.00554418f, -0.00757635f, -0.01464971f, 0.01066601f, -0.03111342f, 0.01991672f, 
    -0.02545707f, -0.01785450f, -0.04376456f, 0.00009881f, -0.03396179f, -0.04424258f, -0.04339038f, -0.01753916f, 
    -0.00567213f, 0.01007086f, 0.00835553f, -0.02307931f, 0.01441833f, -0.01023754f, -0.02193547f, -0.02222541f, 
    0.02434289f, -0.02280160f, 0.00984756f, 0.00031309f, 0.00395409f, -0.03059678f, 0.01626958f, 0.01914153f, 
    -0.00773932f, 0.00029357f, -0.04339757f, 0.03128231f, -0.01266537f, -0.00365423f, -0.04067779f, 0.02837334f, 
    -0.03022758f, 0.02153343f, -0.01798853f, -0.04541861f, 0.01138951f, -0.03097561f, -0.02537511f, 0.02211354f, 
    0.01653112f, 0.02235820f, -0.00023733f, 0.00926713f, 0.01361991f, -0.04061840f, 0.01466015f, -0.02275971f, 
    0.03019835f, -0.04106019f, 0.03028489f, -0.00579923f, -0.02309586f, -0.00966273f, 0.01321940f, 0.02301834f, 
    -0.01844870f, -0.00663521f, -0.03148575f, 0.00181460f, -0.02919022f, -0.01652822f, 0.00474787f, 0.00645727f, 
    0.01851352f, -0.00808650f, -0.01372882f, -0.01077784f, -0.03981773f, -0.03640414f, 0.00766218f, -0.00193417f, 
    -0.03169722f, -0.03191962f, -0.04304408f, -0.02997742f, 0.02521582f, 0.00785084f, -0.03191312f, 0.01733671f, 
    -0.02782448f, 0.00868020f, -0.02777183f, -0.02855503f, -0.03332062f, -0.00227633f, 0.00919015f, -0.02730260f, 
    -0.00738852f, -0.04148516f, -0.00006341f, 0.02495174f, 0.03116402f, 0.02865701f, 0.00261248f, 0.01470960f, 
    0.00292302f, 0.01567441f, 0.03628542f, -0.00371604f, 0.01521054f, -0.01128527f, -0.00244772f, -0.01332212f, 
    -0.02780072f, 0.00008029f, 0.03425645f, 0.00654779f, 0.00057646f, -0.04524502f, -0.00930444f, -0.04714933f, 
    -0.02625148f, 0.01665184f, -0.04075009f, 0.02285818f, -0.00642455f, -0.02548025f, -0.00150529f, 0.00636150f, 
    -0.00707268f, 0.01125743f, 0.01821052f, 0.00035306f, -0.02484700f, -0.03890407f, 0.01193994f, 0.02559836f, 
    -0.03858745f, -0.03120515f, -0.02585929f, -0.04547232f, 0.01595477f, -0.04076369f, 0.01430987f, -0.01704029f, 
    0.00718239f, -0.01896998f, 0.04214391f, 0.02747724f, -0.01552965f, 0.02435982f, 0.01468803f, -0.01817032f, 
    -0.00848087f, 0.03365657f, 0.01616535f, -0.03606231f, -0.03736922f, 0.03066383f, 0.01069083f, -0.01821523f, 
    -0.01611307f, -0.01231936f, -0.02196773f, -0.02283654f, 0.00733129f, 0.02750611f, -0.00722753f, 0.02703675f, 
    -0.02025459f, -0.02192354f, -0.00221217f, 0.03067872f, -0.00207669f, -0.02527850f, 0.00928145f, -0.02792110f, 
    0.01433979f, 0.03064190f, -0.02440169f, -0.00182537f, 0.03222241f, 0.00648316f, -0.03321059f, 0.03048771f, 
    0.03136824f, -0.03799209f, 0.00667561f, -0.00405019f, -0.01348952f, -0.01076800f, -0.02822317f, 0.01658841f, 
    -0.01378270f, 0.00555794f, -0.02907740f, -0.04424706f, 0.02488330f, -0.01573671f, -0.01475133f, 0.01801078f, 
    -0.02768981f, 0.01823935f, 0.03518377f, -0.02176147f, -0.01205762f, -0.00409254f, -0.02440462f, 0.00698574f, 
    -0.03436418f, -0.01876565f, -0.02770483f, -0.00678683f, 0.02925608f, -0.02182720f, -0.03941000f, -0.01196497f, 
    -0.00209796f, 0.02835630f, -0.01927610f, 0.02232207f, 0.03190206f, -0.03395860f, 0.02585583f, -0.03448159f, 
    -0.04531552f, 0.00514013f, -0.02548371f, -0.03576118f, 0.03408273f, -0.00172718f, -0.03126463f, 0.01137314f, 
    -0.02215168f, 0.02535533f, 0.01236015f, -0.01646291f, -0.00177673f, -0.03817744f, 0.00086090f, -0.01512634f, 
    0.02462340f, -0.01640860f, -0.02382198f, 0.02533681f, -0.01409120f, -0.04375557f, -0.00573930f, -0.02852006f, 
    0.00746214f, -0.04570732f, 0.02449696f, 0.01938461f, -0.00084660f, -0.04389962f, 0.02464528f, -0.03235886f, 
    0.01913316f, -0.02047595f, -0.01431623f, -0.02697440f, 0.00120158f, -0.03513073f, 0.03391473f, -0.03230933f, 
    -0.00917221f, -0.00056852f, -0.00918431f, -0.03055328f, -0.01225990f, 0.03155715f, 0.01585520f, -0.01335249f, 
    -0.03955639f, 0.01927230f, 0.01493957f, 0.00274835f, 0.02048535f, 0.00056251f, 0.02652885f, -0.01769828f, 
    0.03005630f, -0.01977324f, -0.00643995f, -0.02034851f, -0.04108772f, -0.04435223f, 0.00136786f, -0.01024816f, 
    -0.03653214f, 0.01802875f, -0.01805151f, -0.02399833f, 0.00728005f, 0.01108963f, -0.03438977f, 0.01360275f, 
    0.02147621f, 0.02853519f, 0.00576875f, 0.00218964f, -0.01689033f, 0.02908915f, 0.00481946f, -0.00092115f, 
    0.01753625f, -0.01473608f, -0.02460866f, -0.03696412f, 0.01474957f, -0.00407555f, -0.04094420f, 0.02092667f, 
    -0.00304795f, -0.00620651f, -0.00221430f, 0.01706483f, -0.01178956f, 0.01439312f, -0.03984711f, 0.01206345f, 
    0.00393745f, 0.01020255f, -0.00599777f, 0.01435937f, -0.02056166f, -0.03671717f, -0.02951117f, -0.00472369f, 
    0.00520909f, 0.00920714f, -0.01434927f, 0.00853649f, 0.01520293f, 0.01367360f, 0.02924247f, 0.00689172f, 
    -0.03811191f, -0.02661555f, -0.01595636f, -0.03127939f, -0.02879309f, 0.01996751f, 0.00421402f, -0.03898935f, 
    0.01417736f, -0.04581628f, 0.00938405f, -0.01978421f, -0.02398756f, 0.02638824f, 0.02813900f, -0.02145510f, 
    0.00806030f, 0.00013399f, -0.00521548f, -0.04301303f, 0.03034923f, -0.01728665f, -0.00528607f, -0.04601985f, 
    0.02289460f, 0.02314644f, 0.01384622f, -0.01649499f, -0.02942667f, -0.01162984f, -0.03000970f, 0.02539882f, 
    -0.00598318f, 0.02145994f, -0.02903267f, -0.01392916f, -0.02003420f, -0.01542756f, 0.00390954f, -0.00221055f, 
    -0.00816853f, 0.00511915f, -0.01889284f, -0.03365000f, 0.01807315f, 0.00756792f, -0.02299910f, -0.03624134f, 
    0.01547171f, 0.02194685f, 0.00358057f, -0.02823748f, -0.03363383f, -0.03453097f, -0.03912587f, 0.01774994f, 
    -0.03420740f, -0.01497624f, -0.02311474f, 0.00513484f, 0.00310506f, 0.01237409f, -0.03773567f, -0.04130706f, 
    0.00296781f, 0.01965241f, 0.00166638f, 0.02025940f, -0.02142790f, -0.03709942f, 0.00884287f, 0.02161544f, 
    0.02771682f, -0.01316524f, -0.00411193f, -0.00287671f, 0.01187367f, 0.01575483f, 0.00729113f, -0.03456431f, 
    0.00562433f, -0.02913209f, -0.03881804f, 0.00441619f, 0.02422560f, 0.00227319f, 0.02843139f, 0.00672218f, 
    -0.00700875f, -0.04032524f, 0.03312655f, -0.02985593f, -0.01897407f, -0.04000922f, -0.01007521f, -0.00599797f, 
    -0.01546183f, 0.00277093f, 0.02170984f, -0.00762779f, -0.03414012f, 0.02892435f, 0.00350095f, -0.03374875f, 
    0.00101393f, -0.03754674f, -0.02293229f, -0.03999028f, -0.01587594f, -0.03095621f, -0.02708371f, 0.02530180f, 
    0.01997019f, 0.03190916f, 0.01656343f, -0.02323754f, -0.03391204f, -0.01259478f, 0.01969261f, -0.03354156f, 
    -0.02078296f, -0.03091071f, -0.00474043f, 0.00938168f, 0.02443507f, -0.02087374f, -0.01513292f, 0.02476558f, 
    -0.03094424f, -0.00369603f, -0.01667817f, 0.02839422f, -0.03414897f, -0.02756940f, 0.00868213f, -0.02556806f, 
    -0.02291677f, 0.00559655f, 0.02698522f, -0.00805539f, 0.00511609f, -0.01690739f, 0.02494216f, -0.02903201f, 
    -0.02054496f, -0.02759749f, 0.00969410f, 0.01113861f, 0.02849206f, -0.02584147f, 0.03096112f, -0.01818746f, 
    0.02688168f, -0.02166460f, -0.03756753f, -0.00410775f, 0.02969766f, 0.01501861f, 0.02783776f, 0.02157464f, 
    0.00347818f, -0.02212056f, -0.02856462f, -0.01869322f, 0.00933361f, -0.01877910f, 0.01093987f, -0.02685865f, 
    -0.03492210f, -0.03141752f, -0.04769216f, -0.00566384f, -0.04154523f, 0.00496666f, 0.03313588f, -0.03931560f, 
    0.01171089f, -0.04169322f, 0.02992224f, -0.03814438f, -0.00980146f, 0.03285565f, 0.00279453f, 0.01623133f, 
    -0.03969727f, -0.04492749f, -0.02638878f, 0.03151000f, 0.03025426f, -0.03865837f, 0.01464679f, -0.02333942f, 
    -0.02130308f, -0.02494389f, 0.01353638f, -0.01404902f, 0.01787112f, -0.01882784f, 0.02387648f, -0.00161790f, 
    0.00362108f, 0.01722434f, 0.00468790f, 0.03079432f, -0.00387091f, -0.03367217f, -0.04582238f, -0.04384095f, 
    0.01997368f, 0.00638505f, 0.01637951f, 0.00118861f, -0.00018597f, -0.04268908f, -0.00728829f, -0.03135730f, 
    -0.03280233f, -0.03449690f, 0.00880144f, -0.02365776f, 0.01678392f, -0.03174406f, 0.01528673f, 0.02098604f, 
    -0.00107091f, -0.01202254f, 0.00606161f, -0.00677687f, -0.02319369f, -0.02504593f, -0.02779205f, 0.03084073f, 
    0.00147073f, 0.03049877f, 0.02574054f, 0.00240171f, 0.01496616f, -0.01184952f, 0.01262414f, 0.00954129f, 
    -0.03333822f, -0.02380180f, -0.00759557f, -0.01524498f, -0.03378522f, -0.02943647f, -0.01311893f, -0.01892368f, 
    0.00871916f, -0.01170775f, -0.01981599f, -0.02267639f, -0.02172213f, -0.02080479f, 0.02687266f, -0.04413869f, 
    -0.04322473f, 0.01690810f, -0.00451543f, -0.03625154f, 0.01637791f, -0.01810711f, 0.00311787f, -0.01031210f, 
    0.02846722f, -0.01304702f, 0.02203225f, 0.01448697f, -0.01975739f, 0.01310450f, -0.03224696f, 0.02618545f, 
    -0.03355905f, -0.02847217f, -0.00494138f, -0.03220893f, -0.02260356f, -0.01947616f, 0.03177269f, -0.01174419f, 
    0.02785838f, 0.02462892f, 0.02990608f, -0.00452421f, -0.00311127f, -0.04123562f, 0.00916281f, 0.01670413f, 
    -0.01000847f, -0.00888248f, 0.02833206f, -0.02988279f, -0.02787424f, 0.00351526f, 0.02100611f, 0.01636228f, 
    0.02177520f, 0.00572664f, -0.01515869f, -0.03989261f, -0.01527569f, 0.01069523f, -0.03772471f, -0.01797826f, 
    -0.00553026f, -0.03026790f, -0.01558295f, 0.00643348f, -0.00585416f, 0.00969334f, -0.00836523f, -0.00117133f, 
    -0.01588514f, 0.03034424f, -0.02143042f, 0.02023493f, -0.00224244f, -0.00816446f, -0.03795788f, -0.04056713f, 
    0.00703789f, -0.02286004f, 0.02662564f, 0.01396729f, -0.02416737f, -0.04271708f, 0.02907505f, 0.02475249f, 
    -0.00964211f, -0.04022524f, 0.02223703f, 0.00283320f, -0.04115758f, -0.03136964f, 0.01256963f, -0.03868627f, 
    0.02842250f, 0.01360332f, 0.00024436f, -0.01349791f, -0.02564539f, -0.02950464f, -0.04376481f, 0.00802089f, 
    0.02409981f, -0.01855746f, -0.03001687f, -0.01713311f, 0.00317358f, -0.00912657f, -0.02737947f, -0.00000903f, 
    0.01018038f, 0.02301946f, -0.03286723f, 0.01189810f, 0.00433982f, 0.02934991f, -0.01440774f, 0.00955099f, 
    -0.03342998f, -0.02574608f, -0.00525409f, -0.02797156f, -0.04390327f, -0.04576874f, -0.01273134f, 0.02574694f, 
    0.00229399f, -0.01700997f, 0.03844176f, 0.01301702f, 0.00959429f, -0.00929488f, 0.03304952f, 0.00863745f, 
    -0.01782761f, -0.00684359f, 0.02387311f, -0.01853327f, -0.03319415f, 0.02638126f, 0.00342952f, 0.02766300f, 
    0.02356233f, 0.02623043f, -0.03432766f, 0.02454747f, 0.00681511f, -0.02776087f, 0.02099190f, 0.02415827f, 
    -0.00141924f, -0.04140759f, -0.03087540f, -0.03530050f, 0.01320583f, 0.00386900f, 0.00856082f, 0.02011978f, 
    -0.01866989f, -0.00342519f, -0.01697046f, -0.01701440f, -0.00835553f, -0.03382883f, 0.00921176f, -0.04284609f, 
    0.03217568f, -0.00922699f, 0.03384937f, -0.02055582f, 0.01725514f, -0.02588879f, -0.04416052f, -0.03061560f, 
    0.02016291f, 0.00029000f, -0.03929706f, -0.01172055f, -0.01974305f, 0.01229020f, -0.02973354f, -0.00569865f, 
    0.00114050f, 0.00015975f, -0.04437559f, -0.04626955f, -0.01677436f, -0.03834404f, 0.02622865f, -0.02206992f, 
    0.01511658f, -0.00450427f, 0.00132687f, -0.01442920f, 0.00488542f, -0.04404328f, 0.01487033f, -0.02721813f, 
    -0.02049590f, -0.01663219f, -0.02283043f, -0.01899343f, 0.02467589f, 0.02356053f, -0.00097382f, 0.01411874f, 
    0.00110652f, -0.00454635f, 0.01837816f, -0.03463343f, 0.01750575f, 0.02158448f, 0.01096162f, 0.02445048f, 
    0.02033926f, -0.04430711f, 0.01965879f, 0.01155895f, -0.02603734f, 0.01454209f, -0.02543598f, -0.02784627f, 
    -0.02266968f, -0.01327156f, 0.02301416f, 0.01497417f, 0.00801650f, -0.00956413f, 0.00822914f, -0.02718184f, 
    -0.03793883f, -0.03238164f, -0.02717550f, -0.02735647f, 0.01721456f, -0.02031457f, -0.00610879f, 0.02974184f, 
    -0.03736089f, -0.00669940f, -0.02449488f, -0.03791789f, 0.02916587f, -0.01630165f, -0.04206242f, -0.01488586f, 
    0.02475055f, 0.00637146f, -0.02378369f, -0.03043412f, 0.01327708f, -0.03409881f, -0.02241774f, -0.01482348f, 
    -0.01278362f, 0.02512642f, -0.02692285f, 0.02998129f, 0.00145545f, -0.00134071f, -0.00655418f, -0.02091506f, 
    -0.03913424f, 0.01862784f, -0.04318994f, 0.03124586f, 0.01260336f, -0.00108175f, 0.01913124f, -0.01212613f, 
    -0.00515813f, -0.03143892f, 0.02824952f, -0.02544824f, 0.01161050f, -0.01168722f, 0.03251395f, 0.00609334f, 
    -0.02593862f, 0.02585536f, 0.00128061f, -0.02985019f, -0.02819939f, -0.02752381f, 0.01261584f, -0.03272218f, 
    -0.00230616f, -0.02174708f, -0.00240319f, -0.02433256f, 0.01889612f, 0.01452327f, -0.03814043f, -0.02354460f, 
    0.03097312f, 0.00717150f, -0.02120551f, 0.00832457f, 0.02264826f, -0.04202740f, -0.04596166f, 0.00402982f, 
    -0.02106795f, -0.03208639f, -0.02689184f, -0.03332020f, 0.02766784f, -0.01545398f, 0.00336104f, -0.03289377f, 
    -0.00204992f, 0.02741534f, -0.03789930f, 0.03199234f, 0.00170767f, 0.02677417f, -0.04247731f, 0.02540636f, 
    -0.02289615f, -0.02871777f, -0.00560651f, -0.00268312f, 0.02298807f, -0.03804735f, -0.01265588f, -0.02337880f, 
    0.02749525f, 0.00924076f, 0.01659795f, 0.00004968f, -0.04506637f, 0.01199407f, -0.00081694f, 0.01050367f, 
    -0.00503932f, 0.03089095f, -0.00451357f, -0.00223054f, 0.02965925f, -0.01655366f, 0.01917376f, 0.02693052f, 
    0.00155674f, -0.00998747f, -0.01091790f, 0.02833550f, 0.00329359f, -0.00446174f, -0.00158189f, -0.02416642f, 
    -0.02694712f, 0.01796619f, 0.02700832f, -0.02151600f, -0.04317793f, -0.04282681f, -0.00801355f, -0.00049245f, 
    0.00815670f, -0.00574932f, -0.00054689f, 0.01464681f, -0.01414939f, 0.00554915f, -0.00423336f, -0.04135855f, 
    -0.02399954f, -0.04481467f, -0.01569345f, -0.03345854f, -0.02880133f, 0.03330250f, 0.01003200f, 0.00981962f, 
    -0.03736426f, 0.00224298f, 0.01514177f, 0.02456951f, 0.00131619f, 0.02719651f, -0.01193399f, 0.01991809f, 
    -0.00892209f, -0.00020503f, 0.01346465f, -0.00100956f, 0.02111896f, -0.00954878f, 0.02441910f, -0.00194100f, 
    0.02990991f, -0.00473219f, -0.01221794f, -0.00728341f, 0.00144431f, 0.02680199f, -0.00776281f, -0.01137598f, 
    -0.01115415f, 0.00236656f, 0.01161916f, -0.01793022f, -0.02087302f, -0.04146775f, 0.00236762f, -0.01116557f, 
    -0.02598078f, 0.02281342f, -0.00565177f, 0.01576763f, -0.01347290f, 0.00825133f, 0.02267637f, -0.03225056f, 
    -0.04482303f, -0.03261325f, -0.00655388f, -0.04605847f, -0.01477416f, -0.03535710f, -0.03376512f, -0.01835958f, 
    -0.03343495f, -0.00542622f, -0.01106290f, 0.00938279f, -0.01856205f, -0.04033205f, -0.02220309f, -0.02580903f, 
    0.03215647f, 0.00718046f, -0.03844284f, -0.02076167f, -0.01790947f, 0.00371870f, -0.03642383f, -0.00050365f, 
    -0.01187166f, 0.02976263f, -0.02362502f, 0.03163445f, 0.02109940f, -0.00882427f, 0.01643878f, -0.01797273f, 
    -0.03426621f, -0.00960337f, 0.02962191f, -0.00616397f, 0.02909466f, -0.02571098f, -0.03935050f, 0.01237342f, 
    -0.02683471f, 0.01793632f, -0.00871527f, -0.02445795f, -0.00144814f, 0.01252615f, -0.01452148f, -0.01072101f, 
    -0.03813753f, 0.00958551f, -0.01406834f, -0.04204718f, 0.00774381f, 0.00870562f, -0.01335627f, 0.02965807f, 
    -0.00139371f, 0.00151307f, -0.00805993f, -0.02361804f, 0.03372548f, -0.01257739f, -0.01484017f, -0.00921427f, 
    0.00686083f, -0.03038088f, -0.03263925f, -0.02476998f, -0.00439030f, -0.01446354f, 0.01351826f, 0.02255769f, 
    0.01814406f, -0.04121681f, 0.02802709f, -0.02499128f, 0.02506890f, -0.01752101f, -0.03185044f, -0.00644807f, 
    -0.02471778f, -0.01193839f, -0.03719428f, -0.01503382f, 0.01394007f, -0.03325218f, 0.01923315f, -0.00391009f, 
    -0.03451336f, -0.02456198f, -0.02274697f, 0.03375160f, -0.01804174f, 0.04187983f, -0.03042332f, 0.00543936f, 
    -0.03535145f, 0.02196155f, 0.03078678f, -0.01585114f, 0.00525160f, -0.00976906f, -0.00272133f, 0.01812627f, 
    -0.01490353f, -0.04047153f, -0.00511090f, 0.01586750f, -0.02479803f, -0.00808302f, 0.01526968f, -0.01608783f, 
    0.02382386f, -0.00910349f, 0.00713292f, 0.00939958f, -0.01899003f, -0.02631354f, 0.00183175f, -0.04563321f, 
    -0.00495301f, -0.03877973f, -0.01221070f, 0.03347166f, 0.01597319f, -0.02973226f, -0.00653575f, -0.01201851f, 
    0.01311517f, -0.00557757f, 0.02616363f, 0.03009007f, 0.02273133f, 0.00881956f, -0.02876529f, -0.02222844f, 
    0.00980163f, 0.03145110f, 0.01697247f, 0.02006835f, -0.00747822f, 0.03072178f, 0.02685649f, -0.04243363f, 
    0.00795305f, 0.02406307f, -0.00011764f, -0.01263590f, 0.03045391f, 0.03368696f, 0.02774938f, 0.02841970f, 
    -0.00683401f, 0.03956255f, -0.03834840f, 0.01099965f, 0.00168709f, -0.03156374f, -0.01933903f, -0.01596177f, 
    -0.04076442f, -0.03278406f, 0.02293021f, -0.00829543f, 0.00805576f, -0.02770681f, -0.04379330f, 0.01530402f, 
    0.00317333f, 0.01258488f, -0.02205819f, 0.02114599f, 0.00885641f, -0.02422148f, -0.00435527f, 0.02329140f, 
    -0.01682923f, 0.00162297f, -0.02475010f, -0.01253857f, -0.02981418f, -0.00179072f, -0.02284558f, 0.01792215f, 
    0.00993939f, -0.00887165f, -0.02821786f, 0.01347141f, 0.01765866f, 0.01767291f, 0.00087492f, 0.01442304f, 
    0.01299880f, -0.04347821f, 0.03664586f, -0.01736076f, -0.02388776f, 0.00652805f, -0.00734781f, -0.04109821f, 
    -0.03015440f, -0.00410406f, -0.02602368f, -0.01568627f, 0.01888609f, -0.04441355f, 0.00721932f, -0.03613219f, 
    -0.02283441f, -0.00292098f, 0.01639983f, 0.02962694f, -0.02291554f, 0.00975478f, -0.00099473f, 0.02197506f, 
    -0.02785810f, 0.00070567f, 0.00195412f, -0.02938960f, -0.02090722f, -0.01296503f, -0.00346629f, 0.02603906f, 
    0.00153545f, -0.03912368f, -0.01848402f, -0.03769989f, -0.00227951f, -0.03666944f, 0.02615440f, -0.01645396f, 
    -0.00663611f, -0.03350113f, 0.01036518f, -0.01292757f, -0.01678068f, 0.00494081f, -0.02672626f, -0.04412551f, 
    -0.03486501f, -0.00607180f, -0.00055232f, -0.00858776f, -0.01383689f, 0.02891769f, -0.02881963f, -0.04127109f, 
    -0.02417558f, -0.00076239f, -0.00706887f, 0.00451612f, -0.03975483f, 0.01942479f, -0.01307553f, 0.01741553f, 
    -0.00505992f, -0.00828267f, 0.01414786f, -0.03186945f, -0.00774064f, 0.02531073f, -0.01391656f, -0.00508712f, 
    0.00683835f, -0.00604582f, -0.00474594f, 0.00034675f, 0.01147956f, 0.01175324f, 0.02109191f, 0.02660093f, 
    0.01538467f, 0.01583716f, -0.01992156f, -0.02543856f, 0.02399511f, -0.03064893f, -0.02272892f, -0.03686850f, 
    0.01942659f, 0.03247217f, -0.02765332f, 0.01652141f, 0.02781005f, -0.00723333f, 0.01600934f, 0.00782621f, 
    -0.00106888f, -0.03991647f, 0.01521174f, -0.02899410f, -0.00608581f, 0.00255141f, -0.03758612f, 0.02356471f, 
    0.02263789f, 0.01944741f, -0.00820824f, -0.03856893f, -0.01957532f, 0.02561309f, -0.02965963f, 0.03075148f, 
    0.00177977f, -0.00288603f, 0.01480389f, -0.02998492f, -0.03461508f, -0.02214237f, -0.02023447f, -0.02024456f, 
    -0.03784252f, -0.03777549f, -0.02255856f, -0.03974592f, -0.02064901f, -0.02839622f, 0.00292095f, 0.00388174f, 
    -0.00791112f, -0.01148452f, 0.03356934f, -0.02926812f, 0.01061975f, -0.00218082f, -0.01514943f, -0.01716765f, 
    -0.02162479f, 0.00751108f, -0.02420502f, 0.02780131f, -0.01363799f, -0.00206468f, 0.01448580f, 0.03339427f, 
    -0.00378495f, -0.00311502f, 0.02180492f, -0.00496499f, 0.01097494f, -0.02294566f, 0.01893966f, -0.02302828f, 
    -0.00683973f, 0.01738748f, -0.00353539f, -0.01492633f, -0.01971789f, 0.02622904f, -0.02431320f, 0.01755216f, 
    -0.03653042f, -0.00053836f, 0.01781906f, -0.03692580f, -0.02538863f, 0.03153586f, 0.00627911f, 0.00468646f, 
    -0.04169894f, 0.02840102f, -0.03256500f, 0.02015993f, -0.02083820f, -0.01679025f, -0.01271939f, -0.02126272f, 
    -0.04421591f, 0.00498713f, -0.00792943f, -0.04458795f, -0.01035057f, 0.01845975f, -0.00439616f, -0.02783632f, 
    -0.01456094f, 0.02941385f, -0.02243104f, -0.02854406f, -0.04261547f, -0.01076620f, -0.00890573f, 0.02353164f, 
    0.02690509f, -0.03413665f, -0.04050645f, -0.01679219f, -0.00776470f, -0.01719922f, 0.02535339f, -0.01731863f, 
    -0.04057844f, -0.01638572f, 0.01107773f, 0.01274283f, -0.00499494f, -0.04104260f, 0.00081366f, 0.03394247f, 
    0.02063212f, 0.02984993f, -0.02576675f, 0.00524613f, -0.03999904f, -0.01757513f, -0.00829135f, -0.02789120f, 
    -0.01152769f, 0.00415664f, -0.02335638f, -0.02289856f, 0.02779135f, 0.03746292f, 0.01750606f, 0.02831915f, 
    -0.00106155f, -0.02701313f, -0.03435384f, 0.02563649f, -0.01721459f, 0.00367197f, 0.02458314f, -0.00775031f, 
    0.02621089f, -0.03442168f, -0.02499180f, -0.03906250f, -0.01074320f, -0.01274565f, 0.02145229f, -0.00431317f, 
    0.01893121f, 0.02212282f, 0.02969739f, -0.02421951f, -0.04124440f, -0.04241298f, 0.01605441f, -0.02908423f, 
    -0.01176652f, -0.04121611f, 0.00445329f, 0.01071234f, 0.00999582f, -0.03703435f, 0.01593536f, 0.00722716f, 
    0.03016607f, 0.02747258f, -0.00882169f, 0.00899373f, -0.00020964f, 0.02001842f, 0.01927919f, 0.02541069f, 
    -0.01718557f, 0.00135138f, -0.03164950f, -0.01665915f, -0.02977379f, -0.00381541f, 0.01905168f, -0.01092655f, 
    -0.03050600f, 0.02462579f, -0.01203845f, -0.01506473f, -0.03780561f, -0.02888939f, -0.01154654f, 0.01960318f, 
    -0.00373020f, -0.01507926f, 0.00175766f, -0.03647332f, -0.00616226f, 0.01284122f, -0.02322790f, 0.00498602f, 
    0.00089404f, -0.00591766f, 0.02439574f, -0.02418884f, -0.02644699f, -0.01174344f, 0.01735970f, -0.03019699f, 
    -0.00083142f, -0.02196104f, -0.02624073f, 0.00334886f, 0.00021462f, 0.00484545f, 0.00518199f, -0.00396630f, 
    0.01317300f, -0.01841766f, 0.02880483f, 0.01789243f, 0.01445277f, -0.01347634f, 0.00989369f, -0.02264763f, 
    0.01174258f, -0.03074466f, 0.03158969f, 0.01243234f, 0.00528162f, 0.01484687f, 0.03547344f, -0.01594617f, 
    -0.00522925f, -0.01186488f, -0.03417516f, 0.03145335f, 0.00689578f, 0.02822084f, -0.04319533f, -0.03783313f, 
    -0.03778000f, 0.03774038f, -0.03806300f, -0.00741784f, 0.01603285f, -0.01959772f, 0.01677102f, -0.00820520f, 
    -0.03735508f, -0.01273967f, -0.00917411f, -0.00958017f, 0.01264284f, 0.02107298f, -0.01162261f, -0.02300668f, 
    0.02284711f, -0.00297628f, -0.01124193f, 0.01150850f, -0.01565456f, -0.02772373f, 0.02944316f, -0.02843953f, 
    0.02625263f, 0.02596841f, -0.04754764f, -0.02643107f, 0.00848136f, -0.01766305f, -0.01525579f, 0.00159476f, 
    0.03130281f, -0.01943528f, -0.03327605f, -0.04133929f, 0.00620643f, 0.00091735f, 0.01937376f, -0.04178834f, 
    -0.02636509f, 0.00304635f, 0.01800441f, -0.02537178f, -0.04123069f, -0.00518410f, -0.02467166f, 0.00112565f, 
    -0.03988703f, -0.01336242f, -0.03991113f, -0.03662118f, 0.00830561f, -0.00166762f, -0.01200778f, 0.01356589f, 
    -0.00566689f, -0.02987673f, 0.02086299f, -0.00712643f, 0.01456760f, -0.02772902f, 0.00376252f, 0.02724630f, 
    0.01875705f, 0.02638016f, -0.02264728f, -0.02751571f, -0.04026668f, -0.00520417f, 0.01944293f, 0.02237233f, 
    -0.00266887f, -0.04796593f, 0.02274017f, 0.00638830f, 0.00754708f, -0.00292274f, -0.01641274f, -0.00778333f, 
    0.00764345f, 0.00441387f, -0.01746821f, -0.01347907f, 0.01070163f, -0.01390713f, -0.00207443f, 0.01919163f, 
    0.02840540f, 0.03751189f, -0.00012562f, -0.00476016f, 0.01378491f, 0.00379381f, -0.00974536f, 0.02521478f, 
    -0.01323742f, -0.01775357f, 0.02342967f, 0.01146224f, 0.00836379f, 0.02646313f, -0.03146059f, -0.00952595f, 
    0.02251911f, -0.03864579f, 0.00304924f, -0.04248658f, 0.01639751f, 0.03252027f, -0.01623094f, -0.02156795f, 
    -0.02265845f, -0.02924650f, -0.01735048f, 0.02720258f, -0.01436662f, -0.03254788f, 0.01162470f, -0.01932704f, 
    0.01167392f, 0.00292282f, -0.00728253f, 0.00867799f, -0.04322689f, -0.02692183f, -0.03405191f, -0.02447028f, 
    -0.00061129f, -0.02066427f, -0.04181955f, 0.03237170f, -0.02273172f, -0.03540019f, -0.03989065f, -0.00135893f, 
    0.02460003f, 0.01920591f, -0.01619060f, 0.00447683f, -0.01522954f, 0.02983017f, 0.01089975f, 0.02855151f, 
    0.00453306f, 0.03221120f, -0.03596750f, -0.03079062f, -0.01152164f, -0.00518680f, -0.02438385f, 0.00262297f, 
    -0.01187677f, -0.00747046f, -0.02395985f, -0.04030825f, -0.01832690f, 0.01826471f, 0.03248267f, 0.03006324f, 
    -0.03191615f, 0.01078681f, -0.02925657f, -0.02860875f, 0.02589289f, -0.00190394f, 0.01373539f, -0.00781682f, 
    0.01137995f, -0.01356480f, -0.02484849f, -0.02308590f, 0.00787535f, 0.01844067f, -0.01136123f, 0.00186353f, 
    0.03168036f, 0.01635074f, -0.03473811f, -0.00150951f, 0.01491545f, -0.02064570f, 0.02743670f, -0.00000770f, 
    -0.01690717f, 0.01178366f, -0.00981798f, -0.02623102f, -0.01501671f, 0.02946718f, -0.02960000f, -0.00258097f, 
    -0.09051119f, 0.32088327f, 0.04342042f, 0.17219254f, -0.08241363f, 0.06180546f, 0.07327632f, -0.12891085f, 
    -0.02545205f, 0.13441180f, 0.08130395f, -0.04423773f, -0.03410802f, -0.00106151f, 0.03658572f, 0.06823871f, 
    -0.01377883f, 0.00339448f, 0.04525121f, -0.00141955f, 0.17320567f, 0.26036933f, 0.24929060f, 0.13909584f, 
    -0.26676869f, -0.04952331f, 0.01169876f, -0.11740621f, -0.07057213f, -0.01041525f, 0.08569174f, -0.04174100f, 
    -0.00807389f, 0.12490131f, -0.07679927f, 0.12644015f, -0.05479143f, 0.11114046f, 0.06537314f, -0.01351074f, 
    0.05486184f, -0.01364872f, -0.00984783f, -0.10532884f, 0.00092688f, 0.02865174f, 0.09194865f, 0.10694484f, 
    -0.00404903f, 0.07764487f, 0.00282482f, 0.00621865f, 0.06092076f, 0.04133708f, 0.07637984f, 0.04933491f, 
    -0.03973787f, 0.14973126f, 0.00099113f, 0.14153484f, 0.01128714f, 0.14836001f, 0.19452651f, 0.19419079f, 
    -0.19838427f, -0.05980676f, 0.01504456f, 0.03088547f, 0.04554822f, -0.00060622f, 0.11208990f, 0.06837060f, 
    -0.07340360f, 0.06157952f, 0.03822032f, 0.07034076f, -0.03502975f, 0.10700472f, 0.07156041f, 0.04768287f, 
    0.05366682f, 0.07413977f, 0.45700079f, 0.16901919f, -0.05271138f, 0.02859361f, -0.09073567f, -0.01540653f, 
    -0.06078003f, 0.09015013f, -0.04167998f, -0.12701759f, 0.17477533f, 0.09485260f, 0.03922628f, 0.02433723f, 
    -0.20405051f, -0.01575799f, 0.01578080f, -0.02217671f, -0.29201961f, -0.16281518f, -0.15191737f, -0.04871044f, 
    -0.24331105f, 0.03774056f, 0.09553803f, 0.02189556f, -0.09059812f, -0.01012591f, 0.01951976f, -0.05568464f, 
    -0.08466932f, 0.05763675f, -0.02224643f, 0.00487100f, 0.04880742f, 0.07554472f, -0.01016696f, -0.02996750f, 
    -0.11961892f, -0.09624969f, -0.05059905f, 0.07138864f, 0.08724131f, 0.18093561f, 0.14632861f, -0.00495097f, 
    -0.02527593f, -0.12711385f, -0.04593174f, -0.02703574f, -0.04301621f, 0.14333339f, 0.11135089f, -0.04677033f, 
    0.04060579f, 0.05021947f, -0.06958624f, -0.00589991f, -0.28609085f, -0.36301613f, -0.25090477f, 0.01781970f, 
    -0.14979734f, 0.10632994f, 0.08065253f, -0.00783115f, 0.15099636f, -0.01978855f, -0.10677101f, -0.01831485f, 
    -0.02403652f, 0.14539556f, 0.00257986f, 0.11757656f, -0.06402002f, -0.01961611f, -0.01810359f, -0.04848988f, 
    -0.13617282f, -0.13111171f, 0.09035831f, 0.06917752f, -0.14579836f, 0.04851068f, -0.03730160f, 0.03380445f, 
    0.05200852f, 0.08535464f, -0.02665454f, -0.01889583f, 0.01408461f, 0.11366312f, -0.06246764f, -0.04039216f, 
    0.09969459f, 0.03963584f, -0.01794599f, -0.00741423f, -0.06062097f, 0.05351297f, 0.08613198f, 0.08418319f, 
    0.30372074f, 0.01857260f, -0.02511558f, 0.08654483f, -0.02165176f, 0.02617268f, -0.04825601f, 0.01301710f, 
    0.03653684f, 0.08022051f, 0.21033163f, 0.00249666f, -0.00967306f, -0.00223584f, -0.01742337f, 0.01724827f, 
    -0.16338457f, 0.05687292f, 0.23046921f, 0.02190639f, 0.12772778f, 0.04247060f, -0.06119171f, -0.01880052f, 
    -0.05033886f, 0.07578158f, 0.03759500f, -0.09486435f, 0.09940279f, 0.03549285f, 0.16576049f, -0.01131083f, 
    0.09740351f, 0.00010876f, -0.02109699f, -0.10646944f, -0.16080138f, 0.02628581f, -0.10978924f, -0.06384798f, 
    0.00983452f, 0.09599101f, -0.01898736f, -0.01383005f, 0.09690870f, -0.04334992f, -0.07123657f, 0.04544258f, 
    -0.06805974f, 0.08588698f, -0.02654634f, -0.02395472f, -0.00546548f, 0.04268358f, 0.08371233f, -0.08549736f, 
    -0.14972363f, 0.00315614f, -0.32481557f, 0.05373738f, 0.18300775f, -0.06438757f, -0.07864454f, -0.06857770f, 
    -0.01404142f, -0.06265856f, 0.02883358f, -0.01700466f, 0.07673960f, 0.21820073f, 0.14903188f, 0.13108565f, 
    0.04350907f, 0.03207568f, -0.07658832f, 0.09328609f, 0.01135776f, 0.14877819f, 0.32038686f, 0.20239940f, 
    -0.08240151f, 0.04177701f, 0.07068457f, -0.05121039f, 0.02467447f, 0.01349937f, 0.10483367f, 0.00119957f, 
    0.08132853f, 0.08406639f, 0.05866913f, 0.05725548f, 0.09552475f, -0.05883157f, 0.01128265f, -0.04860953f, 
    -0.07601147f, 0.15867826f, 0.18375534f, 0.27761877f, -0.14876725f, 0.10430163f, 0.04565379f, -0.09819410f, 
    0.07498197f, 0.01240982f, -0.01206162f, -0.10286137f, 0.06960136f, -0.00822958f, 0.06854805f, 0.04496206f, 
    0.02870516f, -0.04201284f, 0.01538546f, -0.06690641f, -0.69266427f, -0.25725308f, -0.40495992f, -0.22051840f, 
    0.23978296f, 0.17810774f, 0.08309055f, 0.03423790f, -0.01766988f, 0.04339909f, 0.05849569f, -0.03601699f, 
    0.03528432f, 0.03504809f, -0.09674335f, 0.03839300f, -0.11776295f, 0.02949825f, 0.05463676f, 0.05055168f, 
    -0.03323917f, 0.23082703f, 0.27341920f, 0.34561685f, -0.22729856f, 0.05965228f, 0.02349455f, -0.15556848f, 
    0.03311815f, 0.03975279f, 0.00419627f, 0.02913416f, 0.09482510f, -0.02843429f, 0.03158654f, 0.02786051f, 
    0.08619980f, -0.06139030f, -0.03322571f, -0.05714790f, -0.05008812f, -0.22146636f, -0.12860024f, -0.10521857f, 
    -0.03566914f, 0.03422339f, -0.10099744f, 0.00943880f, 0.03182926f, 0.05771139f, 0.00123903f, 0.01658875f, 
    0.02182121f, 0.01329401f, 0.08034196f, -0.07738314f, 0.06870654f, 0.15972856f, -0.00269884f, 0.02899488f, 
    -0.37811184f, -0.01240543f, -0.24313453f, 0.02739415f, -0.01326598f, 0.17949548f, 0.05834080f, -0.09148681f, 
    -0.05101533f, 0.02015153f, -0.07326309f, 0.00492086f, -0.02967432f, 0.00016783f, -0.00676453f, 0.04087062f, 
    0.14812760f, -0.00046858f, -0.05722488f, -0.05606992f, -0.02117438f, 0.05931411f, 0.19964388f, 0.34138599f, 
    -0.09310649f, 0.00269144f, 0.00147213f, -0.00915403f, -0.11454031f, 0.07860585f, 0.07006335f, -0.11106822f, 
    0.00149834f, 0.06823195f, -0.08596530f, 0.07875690f, 0.09324208f, -0.06580481f, 0.00874530f, 0.03201658f, 
    -0.63900942f, -0.24086717f, -0.14035282f, -0.14364438f, 0.05636967f, 0.03850670f, 0.18374160f, 0.09469983f, 
    -0.01980362f, -0.08961701f, -0.01321947f, 0.12653406f, -0.02278162f, 0.03146767f, 0.03343105f, -0.07083111f, 
    -0.00741331f, -0.14035825f, -0.14146103f, -0.00150627f, -0.09102030f, -0.10731503f, -0.33275512f, -0.06395349f, 
    0.13270588f, 0.04201835f, 0.04781725f, -0.00862102f, -0.12282957f, -0.00417614f, 0.20725153f, -0.04761000f, 
    0.09498115f, 0.03733701f, -0.02066846f, 0.05153523f, -0.07871186f, 0.12474828f, 0.04545346f, -0.02947519f, 
    -0.06221305f, 0.04815090f, 0.06968314f, 0.18625118f, -0.01426992f, 0.02239742f, 0.10033172f, -0.03956974f, 
    0.04381605f, 0.18017893f, 0.05197868f, -0.10886767f, -0.03863784f, 0.01987591f, 0.03617050f, 0.00442425f, 
    0.14861159f, -0.05257928f, 0.03846245f, 0.05414867f, -0.29600111f, 0.02298140f, -0.28971037f, -0.20762296f, 
    -0.06595752f, 0.03324481f, 0.22722679f, 0.00115239f, -0.00140056f, -0.00351208f, -0.10332292f, 0.02851176f, 
    -0.02336115f, -0.09543711f, 0.00102283f, -0.05596157f, 0.11099927f, 0.07484266f, -0.13413581f, 0.20778644f, 
    0.02635979f, -0.00126937f, -0.06116319f, 0.03160004f, 0.19774789f, -0.01962120f, -0.02065334f, 0.08949332f, 
    -0.05806031f, 0.08302563f, -0.01223726f, 0.09409284f, -0.03802806f, 0.10344315f, 0.08640008f, -0.04967153f, 
    0.01608223f, 0.00653709f, -0.02541696f, 0.02426549f, 0.13815920f, -0.00199830f, 0.13813478f, -0.12849680f, 
    0.13255069f, -0.02160268f, -0.09057114f, 0.08235064f, -0.06464855f, 0.04096611f, -0.08643945f, 0.00768258f, 
    -0.05565104f, 0.15569846f, 0.14115880f, -0.03456452f, -0.11878456f, 0.01159662f, -0.07610421f, 0.02774247f, 
    -0.09842000f, -0.02253065f, 0.22886083f, 0.14417593f, 0.10545717f, -0.08427282f, 0.12397007f, 0.05486938f, 
    0.05380457f, 0.07622791f, -0.02687081f, 0.11197264f, 0.14807878f, 0.01079232f, 0.06610991f, 0.03761630f, 
    0.03571605f, -0.00824116f, 0.09144888f, 0.17496255f, 0.03106285f, 0.03931103f, 0.31785879f, 0.09747641f, 
    -0.24879999f, -0.00295266f, -0.09722317f, 0.05670631f, 0.09668740f, 0.07853054f, 0.04684564f, 0.04238123f, 
    0.04318888f, 0.12705280f, 0.05752927f, -0.02915477f, -0.07450785f, -0.01380411f, -0.00578812f, -0.07493892f, 
    -0.29429284f, -0.10358422f, -0.61843598f, -0.31411269f, 0.00174888f, 0.18139179f, 0.15101346f, -0.10505638f, 
    -0.00193227f, -0.03688510f, -0.05505394f, 0.07608960f, 0.04852029f, 0.06187577f, 0.04911118f, 0.27856919f, 
    0.13035992f, -0.07147932f, 0.05530208f, 0.04750150f, -0.73173821f, -0.05976434f, -0.34031737f, -0.14596295f, 
    0.42687103f, 0.24760154f, 0.02937808f, 0.04051452f, 0.01681488f, -0.03298940f, 0.02711171f, 0.04521172f, 
    -0.00790385f, 0.07845861f, -0.06223759f, -0.03363651f, 0.15898301f, -0.06218945f, -0.03350027f, 0.07234863f, 
    0.05302532f, 0.11402708f, 0.18461603f, 0.15050963f, -0.35531679f, -0.05152338f, 0.03489935f, -0.01363846f, 
    0.02319354f, 0.01242160f, 0.02961314f, 0.04778405f, 0.08606915f, 0.02914851f, 0.01872668f, -0.01299008f, 
    0.02120330f, 0.01828131f, 0.05554073f, -0.04491840f, -0.42254868f, -0.15558718f, -0.02435706f, 0.01846118f, 
    0.07756770f, 0.00389163f, -0.04472599f, 0.11790627f, 0.09732821f, -0.05752524f, 0.06969284f, -0.01654861f, 
    0.10395368f, -0.03989264f, -0.00164248f, -0.03091489f, 0.05951967f, 0.06983197f, -0.02216208f, 0.02385039f, 
    0.01317593f, -0.03751655f, -0.00496568f, 0.03260329f, 0.00776283f, -0.02101407f, -0.02785996f, -0.00217609f, 
    0.02577365f, -0.00974332f, -0.02265009f, 0.02365620f, 0.00715016f, 0.02416314f, 0.03295286f, -0.00259879f, 
    0.02401973f, 0.01043770f, -0.02111496f, 0.00986536f, -0.00672972f, -0.02279240f, -0.01386017f, -0.02517989f, 
    -0.00718524f, 0.01897418f, -0.01245495f, 0.03120453f, -0.02489428f, -0.04284784f, 0.01137336f, -0.00911169f, 
    0.00964228f, 0.02275224f, -0.02519312f, -0.01975282f, 0.00567318f, -0.01832598f, 0.02616735f, -0.00204929f, 
    0.01839058f, -0.00027506f, -0.01916873f, -0.03167954f, 0.01343214f, 0.02156307f, -0.00754375f, 0.00412941f, 
    -0.04361182f, -0.03692368f, -0.03666814f, 0.02427817f, -0.01988696f, -0.01921618f, 0.03063471f, -0.03567346f, 
    -0.04498654f, 0.02876917f, -0.01580264f, 0.01142045f, 0.00317904f, 0.00549423f, 0.00659918f, -0.03362932f, 
    -0.00435215f, -0.00824535f, -0.00575106f, 0.01364082f, 0.02072347f, -0.04017592f, 0.01957384f, 0.00271826f, 
    -0.01749597f, -0.03082833f, -0.01482873f, -0.02970419f, 0.00549605f, 0.01330241f, -0.03319180f, 0.00041857f, 
    -0.02692369f, 0.00125245f, -0.02870556f, 0.02581260f, -0.01928779f, -0.00588746f, 0.00196070f, -0.00666619f, 
    -0.02094581f, 0.00125686f, -0.03972418f, -0.01290985f, 0.01112315f, 0.02519271f, -0.03323434f, -0.01171311f, 
    0.01983613f, -0.00393699f, 0.03328543f, 0.00437787f, 0.02253300f, 0.01252508f, 0.00851881f, -0.00671323f, 
    -0.00332585f, -0.01007680f, 0.03311545f, -0.01867405f, 0.01438730f, -0.02251203f, 0.00705399f, -0.03568636f, 
    0.01142901f, -0.03643604f, 0.01741478f, -0.03675917f, -0.02325340f, 0.01350548f, -0.02012034f, -0.00364316f, 
    0.02122783f, 0.02077928f, -0.01891312f, -0.03914812f, 0.01997857f, 0.00577249f, -0.00268857f, 0.00068565f, 
    0.01000497f, 0.00071197f, 0.02114725f, 0.01922963f, 0.00697983f, -0.01082248f, 0.00256598f, -0.00710163f, 
    0.00465888f, 0.01881508f, -0.03397933f, -0.03142892f, 0.00879849f, -0.00670400f, -0.00611275f, 0.00012122f, 
    -0.03813424f, 0.00467053f, -0.01896187f, 0.02962979f, -0.03678186f, 0.02728707f, -0.03896360f, -0.03135389f, 
    0.00890542f, 0.02378064f, -0.00273969f, 0.02904281f, -0.02948960f, -0.00334659f, 0.01850932f, -0.00917380f, 
    0.00437443f, 0.03221268f, -0.01449264f, -0.01285037f, -0.02330682f, -0.01643223f, 0.00165528f, -0.03771715f, 
    -0.01222769f, -0.01691492f, -0.01068945f, -0.03399625f, -0.02931236f, 0.02470260f, -0.03531406f, -0.03096729f, 
    -0.03408054f, -0.01172139f, 0.02119808f, -0.00035780f, 0.01832256f, -0.04335973f, 0.00288536f, -0.02351057f, 
    0.00378320f, 0.03285768f, -0.01517536f, 0.02595278f, -0.04106966f, -0.01934392f, 0.00357549f, -0.04525752f, 
    -0.01052926f, -0.01599902f, 0.01228442f, 0.01196154f, 0.00636346f, 0.02726660f, -0.03959933f, 0.00027914f, 
    -0.02914246f, -0.02834160f, 0.01668400f, 0.02756207f, -0.02761484f, -0.03345807f, -0.03432258f, 0.02538845f, 
    -0.00182590f, 0.02763372f, 0.01478690f, 0.00439328f, 0.00935789f, -0.01837772f, 0.02978965f, -0.04385934f, 
    0.01217214f, -0.02914769f, 0.01115245f, -0.02000323f, -0.03439117f, 0.02436142f, 0.01562035f, 0.01908032f, 
    -0.00980295f, 0.00696346f, 0.00977995f, 0.01547243f, -0.00228589f, -0.00970885f, 0.02880897f, -0.02296791f, 
    0.00137582f, -0.02438406f, -0.00644481f, -0.02683732f, -0.04512594f, 0.02795155f, -0.01484019f, -0.00733059f, 
    0.00511773f, 0.02993500f, 0.00685997f, 0.00198685f, -0.00810733f, -0.01463078f, 0.01849037f, 0.00410196f, 
    0.02974949f, -0.01970862f, 0.00293204f, 0.00527393f, 0.00256940f, -0.03878181f, 0.01518464f, -0.03917398f, 
    0.02724598f, 0.02804471f, 0.01881948f, -0.00174171f, 0.00430196f, -0.03772236f, 0.01816100f, -0.01719573f, 
    -0.00165298f, 0.01936137f, 0.02243088f, -0.00121804f, 0.02091556f, -0.01023361f, -0.02957271f, 0.01920501f, 
    -0.03086110f, -0.01575807f, -0.03573019f, -0.01470612f, 0.01707836f, -0.04552028f, 0.02580280f, 0.02715876f, 
    0.00382384f, -0.02862522f, 0.01837312f, -0.00854108f, -0.03740454f, 0.02935152f, -0.01775953f, -0.04539332f, 
    -0.01743545f, -0.02301372f, -0.00788022f, -0.04009857f, -0.01963638f, -0.04006240f, -0.01504318f, 0.03226249f, 
    -0.02263193f, -0.03584376f, -0.02731353f, -0.01109599f, -0.02575141f, -0.01712059f, -0.04511049f, -0.01356983f, 
    -0.01582138f, -0.00474495f, -0.00026841f, -0.01606685f, 0.02443205f, -0.02364520f, 0.01478782f, 0.00217642f, 
    0.00684607f, -0.00007185f, -0.00080498f, 0.00497518f, -0.00580902f, 0.03235165f, 0.02496613f, -0.01156325f, 
    -0.03632464f, -0.02669381f, -0.01950007f, -0.00637874f, 0.01194482f, -0.02884863f, 0.01498743f, -0.01273569f, 
    -0.00350492f, -0.00799169f, -0.03852680f, -0.02848581f, 0.01001258f, 0.01537033f, -0.00825765f, 0.02758835f, 
    0.02881699f, 0.02350486f, -0.00164282f, 0.01507147f, -0.01641323f, 0.00003327f, -0.01781980f, -0.00295876f, 
    0.01775966f, 0.01466420f, -0.01002917f, 0.01643879f, -0.02945801f, -0.00002229f, 0.00091774f, -0.00318268f, 
    -0.03741805f, 0.02344532f, -0.00897465f, -0.00653944f, 0.00612907f, 0.02911812f, -0.04019369f, -0.00890935f, 
    -0.00362566f, -0.01651094f, 0.00238900f, -0.00318697f, -0.02845638f, 0.02668709f, -0.00605364f, -0.03623294f, 
    -0.03865094f, -0.01665691f, -0.03672662f, 0.02996531f, -0.03609511f, -0.02042720f, -0.03702347f, 0.02711667f, 
    0.02532572f, -0.00695013f, -0.04485904f, -0.01349085f, -0.03974887f, -0.02946510f, 0.02508746f, -0.00862426f, 
    -0.03109539f, 0.00326382f, 0.00565829f, 0.00290294f, -0.01193937f, 0.01675477f, -0.02626484f, -0.00576725f, 
    0.02919219f, -0.03829620f, -0.03903452f, 0.02690948f, -0.00296577f, 0.00200750f, -0.00016702f, -0.01878124f, 
    0.01721833f, -0.01866218f, -0.00811160f, 0.00576204f, -0.02199616f, 0.02087110f, -0.02333556f, 0.01938722f, 
    -0.04467662f, -0.02359230f, -0.01477061f, 0.02872879f, -0.01902365f, -0.02901992f, -0.00763013f, -0.04359104f, 
    -0.02358623f, -0.03918529f, -0.04267123f, 0.00546800f, 0.00622782f, 0.03202196f, -0.03497595f, -0.03477124f, 
    -0.01933191f, -0.02947337f, -0.03098708f, -0.02641828f, -0.04168373f, 0.02314435f, -0.02398770f, 0.00969037f, 
    -0.03234263f, 0.01714674f, -0.00987866f, -0.00397142f, -0.02024631f, 0.02754921f, 0.02277936f, 0.02386515f, 
    0.03028147f, -0.04407258f, 0.00277166f, -0.02212920f, -0.01862516f, -0.01745832f, -0.03759170f, 0.02338747f, 
    -0.00626595f, -0.02636235f, -0.01832834f, 0.02253117f, 0.03283803f, 0.02044731f, 0.02628066f, -0.00462646f, 
    0.00243836f, 0.00797825f, 0.03325834f, 0.01644711f, -0.01204614f, -0.04217194f, 0.01144611f, 0.02605793f, 
    -0.00975276f, -0.04039375f, -0.01857341f, 0.02437148f, 0.00215744f, -0.03563564f, 0.00213079f, -0.02798299f, 
    -0.04257511f, -0.03039447f, 0.02458374f, 0.01487333f, 0.03296699f, -0.03803404f, -0.01621876f, -0.04426536f, 
    -0.03818777f, 0.01548276f, 0.02827942f, -0.03918712f, -0.02042272f, -0.04379279f, -0.04111347f, -0.00638304f, 
    -0.03349697f, -0.01910212f, -0.04229012f, 0.00117728f, -0.01487404f, 0.00190572f, -0.03530571f, -0.03279994f, 
    -0.03065448f, 0.00380194f, 0.00744593f, -0.00390220f, -0.01436145f, -0.04170826f, 0.01394339f, 0.01270317f, 
    -0.01279225f, -0.02075824f, -0.00807420f, 0.00196897f, -0.04531199f, -0.01794389f, -0.03082271f, -0.03618765f, 
    0.00124316f, -0.00487327f, -0.01684928f, 0.00191958f, -0.02974218f, 0.01935877f, -0.03702943f, -0.03885708f, 
    -0.00051602f, -0.04136382f, -0.01664728f, 0.02675729f, 0.01106054f, -0.03833386f, -0.01307414f, -0.00349941f, 
    -0.02398210f, 0.01945953f, -0.04376918f, -0.01432795f, 0.01063211f, 0.02505806f, -0.04183277f, 0.01624065f, 
    -0.03481637f, -0.04184498f, 0.02800506f, -0.01766623f, -0.00217696f, 0.01018714f, 0.00087187f, -0.03178400f, 
    -0.01347024f, -0.03653028f, -0.01319271f, 0.00922957f, -0.03528906f, -0.02055866f, -0.00636980f, 0.02409388f, 
    0.01796547f, 0.02001221f, 0.03242398f, -0.00555900f, -0.00295179f, 0.00239374f, -0.02510177f, 0.02472763f, 
    -0.00974656f, -0.02257130f, 0.00701719f, 0.02403169f, -0.00984866f, 0.01325998f, 0.00154443f, 0.02903099f, 
    -0.03718235f, -0.00069430f, -0.00795586f, 0.00185415f, -0.04390113f, -0.00576986f, -0.04307981f, -0.04175881f, 
    0.02775684f, -0.02389471f, -0.02949414f, 0.00368797f, -0.01572537f, -0.03649520f, -0.01088204f, 0.00495268f, 
    0.01080370f, -0.00662050f, -0.01684335f, 0.00307546f, -0.01465722f, 0.01735830f, -0.03569992f, -0.03557995f, 
    0.00083557f, -0.00567202f, -0.04348091f, -0.02388098f, -0.01448327f, 0.00476749f, -0.04517616f, 0.00508145f, 
    -0.01398767f, 0.02712042f, -0.03142740f, 0.00651086f, 0.02209706f, 0.02918512f, -0.02540744f, -0.03170101f, 
    -0.03623934f, -0.02334161f, 0.00718970f, 0.02947111f, -0.01364456f, 0.01240249f, 0.00319605f, 0.02478800f, 
    0.00328560f, -0.04096632f, 0.02560990f, 0.02277993f, 0.01795680f, -0.04418323f, -0.04395513f, 0.03194283f, 
    0.02049296f, -0.03143988f, 0.01685769f, 0.01012101f, -0.03008522f, 0.02414154f, 0.01681666f, -0.00479636f, 
    -0.02083227f, -0.01994328f, 0.00243782f, 0.00809433f, -0.04292770f, 0.01767918f, -0.01780947f, 0.02545482f, 
    0.02051513f, -0.02971455f, 0.01314956f, 0.02415569f, 0.02511247f, 0.02440855f, -0.02146574f, 0.04298453f, 
    -0.02336713f, 0.01302457f, 0.01557199f, 0.00636470f, 0.01018849f, 0.02950214f, 0.03311154f, -0.00373810f, 
    -0.00575032f, -0.00865086f, 0.00866329f, -0.03519847f, -0.01538082f, 0.03203239f, 0.01282411f, 0.00015186f, 
    -0.04504583f, 0.02975121f, 0.00246157f, -0.01703743f, -0.01465534f, -0.00658216f, -0.03162031f, 0.02809003f, 
    -0.01290805f, 0.03145397f, 0.02017135f, 0.00513351f, 0.01086739f, 0.00669913f, 0.01758924f, 0.02700396f, 
    -0.02017960f, 0.00321275f, -0.00651069f, -0.03159878f, -0.02708887f, 0.00431592f, -0.03136019f, -0.02935450f, 
    0.03037397f, -0.03719677f, 0.02505267f, -0.02861338f, -0.01351317f, -0.03994459f, 0.02771348f, 0.00513922f, 
    -0.01395271f, -0.03283107f, -0.00062428f, -0.01462069f, -0.02227531f, 0.00612293f, -0.00916270f, -0.03844994f, 
    -0.00692213f, 0.00085085f, -0.04180470f, -0.01937269f, -0.00490833f, 0.03023533f, -0.02902834f, -0.02318261f, 
    0.01007224f, -0.01689201f, 0.02607561f, -0.04036782f, -0.00594488f, -0.00908214f, -0.04218807f, 0.01262329f, 
    0.02359243f, -0.02244958f, -0.02677302f, 0.00526634f, -0.00843458f, -0.02184099f, -0.04012110f, -0.03164981f, 
    -0.04230427f, -0.02636493f, -0.03766170f, 0.01506551f, 0.01610163f, -0.03099512f, -0.00170324f, -0.04251366f, 
    0.03110670f, -0.00237717f, 0.00424160f, -0.03058727f, -0.01800041f, -0.02771739f, -0.02724601f, -0.00245837f, 
    0.02376406f, -0.03766906f, -0.01600574f, 0.01616264f, -0.01288626f, -0.02597488f, -0.01960023f, 0.03190531f, 
    -0.00154170f, 0.02486147f, -0.03202754f, 0.02567546f, -0.00067815f, -0.01870858f, 0.00424801f, -0.01363132f, 
    -0.04089477f, -0.01815348f, -0.00252827f, -0.00010132f, 0.03133752f, 0.02027440f, -0.03587715f, -0.02590209f, 
    0.00322298f, 0.02186049f, -0.00606610f, 0.01829236f, 0.02238102f, -0.04062751f, 0.00588115f, -0.02220264f, 
    -0.03691342f, 0.02981559f, -0.03631854f, -0.03663554f, -0.00416400f, -0.00933531f, -0.00669768f, 0.01451435f, 
    -0.03763178f, 0.03088722f, 0.01976020f, 0.01287101f, 0.02716238f, 0.03205838f, -0.00779846f, 0.00573206f, 
    -0.01812379f, -0.01104715f, -0.02300904f, -0.04301835f, 0.01140916f, -0.03016557f, 0.00935561f, -0.04203847f, 
    -0.00387588f, -0.03844446f, 0.01997424f, -0.02703981f, -0.01119176f, -0.02432948f, 0.02348063f, -0.01288344f, 
    -0.00240255f, 0.00340159f, 0.01658158f, 0.00281169f, -0.01842657f, -0.00468021f, 0.01185024f, 0.00335043f, 
    0.00779700f, -0.03894264f, -0.02271563f, 0.02122165f, -0.03734959f, -0.02235845f, 0.00276571f, -0.02287860f, 
    -0.02355794f, -0.00280893f, 0.01663598f, -0.02769575f, 0.01421470f, 0.00208313f, 0.00145494f, 0.02569163f, 
    -0.00708374f, 0.01130146f, -0.00161916f, -0.04418510f, 0.02957933f, 0.02728288f, -0.00057865f, 0.00341437f, 
    0.00631818f, -0.01278588f, 0.02865019f, 0.03331287f, -0.02500251f, 0.00658340f, -0.02712747f, 0.02290026f, 
    -0.02530617f, 0.00942825f, -0.04073167f, -0.02588329f, 0.02065997f, -0.03248804f, -0.01621522f, 0.02837650f, 
    -0.03006071f, 0.03276982f, -0.02638400f, -0.02536666f, -0.02925820f, -0.02926984f, 0.01535730f, 0.00116479f, 
    0.01597962f, -0.03906548f, 0.02793141f, -0.03421768f, 0.03339095f, 0.02778559f, 0.02070660f, -0.00466209f, 
    0.00094541f, -0.01622334f, 0.00441268f, -0.01175060f, -0.01161432f, -0.03343269f, 0.02582463f, 0.02265949f, 
    0.03213751f, -0.00679616f, -0.02489829f, 0.03300129f, 0.01060647f, -0.02269900f, -0.00832333f, -0.02762722f, 
    0.00443774f, -0.00619532f, -0.01714477f, 0.02876775f, 0.01299435f, -0.04138956f, 0.01643759f, -0.00730351f, 
    0.02870260f, -0.01894554f, -0.03941524f, -0.00588805f, -0.03291260f, 0.01933215f, 0.02067937f, -0.03306160f, 
    0.00439373f, -0.03946010f, 0.01450398f, -0.00733723f, -0.04380236f, 0.00220826f, -0.01054605f, 0.00178646f, 
    0.02605174f, -0.03517238f, -0.03362950f, 0.01251767f, -0.04348711f, -0.00301303f, -0.00853425f, -0.01869629f, 
    0.01097298f, -0.02994952f, 0.00365336f, 0.01888750f, -0.02468098f, -0.00957429f, -0.00148435f, -0.01564341f, 
    -0.01310574f, 0.00725014f, -0.00739353f, 0.02973229f, 0.03306272f, -0.02907145f, 0.03308725f, -0.04072684f, 
    -0.02206380f, 0.02877506f, -0.04180681f, -0.03565349f, -0.04451948f, -0.00150011f, 0.03061696f, 0.00024652f, 
    -0.03132851f, -0.04258266f, 0.01527515f, 0.02447213f, -0.01805775f, -0.00603017f, -0.02326645f, -0.03692534f, 
    0.03289614f, 0.03145913f, 0.01924227f, -0.02458071f, 0.01477177f, -0.03257809f, 0.01663968f, -0.00205234f, 
    0.02691867f, -0.00904514f, 0.00516509f, -0.00559241f, -0.03945000f, -0.03104299f, -0.02865103f, -0.03906267f, 
    0.00930609f, 0.00917222f, -0.01935933f, 0.02211207f, -0.02268192f, -0.01624534f, -0.00423712f, -0.04185438f, 
    -0.02088748f, 0.01206469f, 0.01469658f, 0.02285233f, 0.03117094f, -0.01030439f, -0.00377001f, 0.01520766f, 
    -0.01702897f, -0.00503059f, 0.03167399f, -0.00677992f, -0.03612472f, 0.01226535f, -0.01151595f, 0.03250400f, 
    -0.01694566f, -0.01867653f, 0.02205171f, -0.01532321f, -0.00638551f, -0.01419712f, -0.00693458f, -0.02649220f, 
    -0.03525335f, 0.01170130f, 0.02358108f, -0.03680573f, 0.01144095f, -0.04501009f, -0.03226298f, -0.02415265f, 
    -0.01126869f, -0.00589902f, -0.02821580f, -0.01544591f, -0.04008316f, -0.02268876f, 0.02688430f, 0.02901258f, 
    0.00587705f, 0.02210388f, 0.00134944f, -0.04519807f, -0.02330622f, -0.03284897f, 0.02268855f, -0.02989647f, 
    -0.01200525f, -0.00716961f, -0.03364738f, -0.01770396f, -0.03274706f, -0.03213204f, 0.01461182f, -0.02338798f, 
    -0.03196130f, -0.00645278f, -0.03873356f, -0.02842650f, -0.02677828f, -0.00267758f, 0.03163874f, -0.02922750f, 
    -0.02183266f, 0.01937502f, 0.01684553f, -0.04510530f, -0.03307205f, -0.00490186f, -0.01570853f, 0.00958683f, 
    -0.01446128f, 0.03276430f, 0.00713410f, 0.01717061f, 0.00242128f, 0.00368428f, 0.01712436f, -0.00171676f, 
    -0.04091627f, -0.02000007f, 0.02154313f, -0.00982424f, 0.02569152f, 0.01827615f, -0.01342125f, -0.00146296f, 
    -0.03541567f, -0.02285303f, -0.04384291f, -0.00174156f, 0.02105209f, 0.01662947f, 0.01169622f, -0.03806182f, 
    -0.03974101f, -0.01000304f, 0.03243943f, 0.02022928f, 0.02243844f, -0.00144860f, -0.01706811f, -0.03326046f, 
    -0.01286341f, -0.00177388f, -0.03317802f, -0.03048343f, -0.00763910f, 0.00889993f, -0.04368693f, 0.02443252f, 
    -0.03235621f, 0.00803411f, 0.00921171f, 0.03057307f, -0.00245809f, 0.02212209f, 0.01132148f, -0.01308364f, 
    0.01732076f, 0.03095316f, -0.01385559f, -0.02638035f, -0.02125608f, 0.00630940f, -0.00602647f, -0.02455519f, 
    -0.03625532f, 0.02245121f, 0.00233225f, -0.00793305f, 0.03263913f, -0.01223275f, -0.01431406f, 0.00861647f, 
    -0.02539352f, -0.03733553f, 0.02387830f, -0.02813159f, -0.00983536f, 0.01093820f, -0.00651895f, -0.01162154f, 
    -0.02175967f, 0.00148438f, 0.01910138f, 0.03263675f, -0.04550505f, -0.02720613f, 0.02965913f, -0.00278138f, 
    -0.00126892f, 0.00082824f, 0.02308453f, -0.02588001f, -0.00254081f, -0.00402399f, -0.03024914f, -0.00906628f, 
    -0.01422639f, 0.00394625f, -0.01544745f, -0.01134075f, 0.00112798f, 0.01427776f, 0.00449368f, 0.02771901f, 
    -0.01990624f, 0.01025179f, 0.02330449f, 0.02032592f, -0.02551009f, 0.01879572f, -0.02854299f, -0.00512153f, 
    0.03115094f, -0.00588768f, -0.02706056f, 0.00204810f, 0.02201946f, -0.00715821f, 0.03127498f, 0.01175333f, 
    0.02970893f, -0.00109459f, -0.04449114f, -0.03404197f, 0.02085318f, 0.02697285f, -0.00602038f, 0.02187308f, 
    -0.03333259f, -0.02383822f, 0.01927678f, 0.00918347f, -0.00533147f, -0.00709825f, 0.00743152f, -0.03647041f, 
    0.00344348f, -0.02484759f, 0.00773704f, 0.03076077f, -0.00437213f, -0.00970799f, 0.01981115f, 0.02664245f, 
    0.02682367f, 0.00973120f, -0.04529267f, 0.01172885f, 0.02103569f, -0.04027525f, 0.02766347f, -0.03358846f, 
    -0.00760977f, -0.03914842f, -0.04300476f, -0.03801340f, 0.01512701f, 0.02661918f, -0.01237258f, -0.01661365f, 
    -0.01512121f, -0.02412657f, -0.01489907f, -0.00318701f, 0.00956109f, -0.03608358f, -0.00116857f, 0.01790234f, 
    0.00892645f, 0.02063370f, -0.03789592f, 0.02001097f, 0.00965326f, 0.00440054f, -0.03917127f, -0.04493816f, 
    0.02787591f, -0.04418717f, 0.00632770f, -0.02354487f, 0.00151565f, -0.03231562f, 0.01672006f, 0.01507773f, 
    -0.02453267f, 0.01133367f, -0.00637791f, -0.01357132f, 0.00125920f, -0.03337724f, -0.00274142f, 0.00836068f, 
    -0.00498313f, -0.01960053f, 0.00018576f, 0.01361287f, 0.00757684f, -0.04416857f, -0.04526711f, -0.04245065f, 
    -0.00605004f, 0.01972909f, -0.02213324f, -0.01765980f, -0.00510465f, -0.02709693f, -0.01366739f, 0.00642992f, 
    -0.00957221f, 0.01730132f, 0.02559972f, 0.02051220f, -0.02440537f, -0.00317287f, -0.03359294f, -0.03007294f, 
    0.01471055f, -0.01466700f, -0.00575953f, 0.02117205f, -0.02782570f, -0.03177236f, -0.03820099f, -0.01783949f, 
    0.03335902f, 0.02442534f, 0.00140370f, 0.02986901f, 0.01807135f, -0.01291638f, 0.00625266f, 0.00590829f, 
    0.00851457f, 0.02889235f, 0.02206719f, -0.00520210f, 0.01439704f, 0.01216952f, -0.00557354f, -0.04203621f, 
    -0.02106791f, -0.01318979f, -0.04425478f, -0.03271529f, 0.02103303f, -0.02326538f, 0.02794700f, 0.02810601f, 
    -0.04105349f, -0.04058712f, 0.01957874f, 0.01395604f, -0.02520956f, 0.03230394f, 0.01644550f, -0.03714223f, 
    -0.01099812f, 0.01275652f, -0.00723865f, -0.01913171f, -0.01344072f, 0.02213450f, -0.01778227f, -0.00954937f, 
    0.02772177f, -0.02428147f, 0.01434745f, 0.02370353f, 0.03057300f, 0.00956448f, 0.02539920f, -0.01643730f, 
    -0.01641961f, 0.00312459f, -0.03221816f, -0.03906986f, -0.01183654f, 0.01478027f, -0.03997658f, -0.03172405f, 
    0.02696902f, -0.02504564f, -0.02829023f, -0.03829740f, -0.00727769f, 0.03346819f, -0.03073026f, -0.03860260f, 
    -0.02511568f, -0.01170685f, 0.00508362f, -0.04448387f, 0.00507467f, 0.00705465f, 0.01191436f, -0.03931404f, 
    0.01908020f, 0.01173296f, -0.00093171f, 0.01666301f, 0.00957486f, -0.02895375f, -0.00509201f, 0.00016258f, 
    -0.01505296f, 0.01370289f, -0.00827726f, 0.01996906f, 0.02155600f, -0.03629882f, 0.02647880f, -0.02704808f, 
    0.02309222f, 0.00341156f, -0.00019326f, 0.02482322f, -0.03900743f, 0.01174319f, -0.01354196f, 0.00011651f, 
    -0.00829440f, -0.02359222f, -0.04314972f, -0.03868911f, 0.01585956f, 0.00716186f, -0.03014160f, -0.02432816f, 
    -0.04527953f, -0.03837010f, 0.01114931f, 0.03032924f, 0.01415353f, -0.02199555f, -0.00311230f, -0.01919839f, 
    -0.00371993f, 0.02566818f, 0.00152677f, 0.00712641f, 0.01768387f, -0.03512438f, -0.03061032f, -0.02070576f, 
    -0.00617713f, 0.01933638f, -0.04122629f, 0.02747705f, 0.00831667f, -0.02482432f, 0.01016167f, -0.02744377f, 
    0.03099463f, 0.02465343f, 0.00807671f, -0.00013965f, -0.01043912f, -0.00094362f, 0.02204640f, 0.03342239f, 
    -0.03928441f, -0.03090713f, -0.00891229f, 0.01896548f, -0.01498105f, 0.01640887f, -0.00587557f, 0.02000290f, 
    0.02318734f, -0.01225251f, -0.01370873f, 0.03148681f, 0.01372064f, 0.01845157f, 0.00691935f, 0.01538714f, 
    0.02545639f, 0.00519625f, -0.01298375f, 0.01527283f, 0.02462366f, -0.01866692f, -0.02223079f, -0.01893803f, 
    -0.03134742f, 0.03115396f, 0.00352891f, -0.02861547f, 0.02622438f, -0.02681947f, -0.02939626f, -0.01319276f, 
    0.03113768f, -0.01423159f, 0.01962832f, -0.00597900f, 0.00191830f, 0.01052067f, 0.02752319f, 0.01904847f, 
    0.01197771f, -0.03510644f, -0.02623914f, 0.01558475f, -0.02214110f, -0.02638251f, -0.03877768f, 0.01199456f, 
    -0.02663828f, -0.00382249f, -0.03926939f, 0.01532390f, -0.02608510f, -0.04206330f, -0.01943431f, -0.03955755f, 
    0.01748582f, 0.01770961f, -0.00920110f, -0.03205072f, 0.02883335f, -0.01799375f, 0.01787432f, 0.01907318f, 
    0.03132226f, -0.04334153f, 0.03047995f, -0.00926289f, -0.02361266f, 0.01272875f, -0.03285149f, 0.00370686f, 
    0.01237764f, 0.01918759f, 0.00228809f, 0.01385108f, 0.00331176f, -0.00900917f, -0.00806196f, 0.00615533f, 
    0.02521175f, -0.04027697f, -0.00495376f, -0.01519686f, -0.04471580f, -0.04179813f, 0.01091175f, 0.01624990f, 
    0.00927387f, -0.01656092f, -0.01208688f, -0.00114775f, -0.03898238f, -0.03945670f, 0.02844439f, -0.03480190f, 
    0.00213920f, -0.00266857f, -0.01587352f, -0.03422275f, -0.02076324f, -0.01662745f, -0.00171049f, -0.01374674f, 
    0.03280826f, 0.03042414f, -0.00518864f, -0.00714245f, -0.02314602f, -0.01824349f, 0.01625087f, 0.02094727f, 
    -0.02980819f, 0.00248937f, -0.00810690f, -0.02651826f, 0.00869824f, 0.01932968f, 0.01255974f, -0.03269995f, 
    -0.02500914f, 0.02206221f, -0.01527078f, 0.00108077f, -0.01808281f, -0.02916391f, -0.00296661f, -0.01811896f, 
    -0.01905596f, -0.04364841f, 0.00274526f, -0.00304276f, -0.02783248f, -0.03930824f, 0.00338649f, -0.01370123f, 
    -0.02117205f, 0.00284142f, 0.03152313f, 0.02243133f, 0.01116945f, -0.04225273f, -0.00541079f, -0.03164551f, 
    -0.02741222f, 0.00018136f, 0.00630834f, -0.00469511f, 0.01401444f, -0.00790013f, -0.02464573f, 0.00802067f, 
    0.01010420f, -0.00812083f, -0.00273136f, -0.03731665f, -0.04411959f, 0.02839855f, -0.03331617f, 0.02971110f, 
    -0.01365583f, 0.02657958f, -0.03879004f, 0.02749780f, 0.00431345f, 0.00641123f, -0.04492733f, -0.01758178f, 
    -0.00526814f, -0.03886457f, 0.02463915f, -0.00728023f, -0.03583121f, 0.01843777f, 0.02282809f, 0.03258472f, 
    0.00244915f, -0.01828608f, -0.03427135f, -0.02139981f, -0.03890811f, -0.00777877f, 0.02408758f, -0.01410492f, 
    -0.02095207f, 0.02468927f, 0.01133607f, -0.01087664f, -0.03607415f, -0.01031695f, 0.01510603f, 0.00876806f, 
    -0.01766538f, 0.01170126f, -0.01539023f, -0.04430313f, -0.02858555f, -0.04300885f, -0.02578397f, 0.02970187f, 
    -0.03497736f, 0.01320914f, -0.04481370f, -0.02999102f, -0.01934364f, -0.01133518f, -0.01056286f, -0.04461200f, 
    -0.03076763f, -0.01518558f, 0.01708648f, 0.03127223f, 0.01513705f, -0.01421140f, -0.00400729f, 0.00179802f, 
    -0.02830275f, 0.01002628f, -0.01457476f, -0.03117490f, -0.03172186f, -0.03395858f, 0.00080193f, 0.00618113f, 
    0.01834278f, -0.01627793f, -0.01228936f, -0.00722510f, -0.04300120f, -0.03925893f, -0.01669482f, -0.00308586f, 
    -0.03600204f, -0.00539213f, 0.02202652f, 0.01140502f, -0.04198525f, 0.02476697f, -0.03668728f, -0.02084370f, 
    -0.01166784f, 0.02263479f, -0.00193550f, 0.01880709f, -0.03982594f, 0.02813512f, 0.01392788f, 0.02068221f, 
    -0.02785506f, 0.00619467f, -0.01362688f, -0.01497540f, -0.01734281f, 0.00613319f, -0.02570375f, -0.04095736f, 
    -0.03963285f, -0.03526833f, -0.02302587f, 0.02005205f, -0.02074635f, -0.00890524f, -0.01854619f, 0.01656553f, 
    0.01552654f, -0.00307961f, -0.00807110f, 0.03340321f, -0.03394739f, 0.03300074f, -0.01526270f, -0.00370026f, 
    0.00637958f, 0.03158413f, -0.02127647f, -0.03578031f, -0.03599032f, -0.00422819f, -0.00648676f, 0.01958746f, 
    0.02304455f, 0.01088201f, -0.04085883f, 0.02894481f, -0.00094573f, 0.00999596f, 0.02902913f, 0.03068536f, 
    -0.03931138f, 0.01996860f, 0.00227060f, -0.03134293f, 0.01323532f, -0.04499973f, -0.01136692f, -0.01842327f, 
    -0.00295322f, -0.02043531f, 0.01554108f, -0.00875333f, 0.01829106f, -0.04114260f, -0.04166483f, 0.00605024f, 
    0.02319757f, -0.01316304f, -0.03633528f, 0.02530779f, -0.02166007f, -0.02290772f, -0.04122314f, 0.02239537f, 
    0.00050528f, -0.00352427f, 0.01198451f, -0.01005752f, 0.00215136f, 0.03238926f, 0.00960650f, 0.03319503f, 
    0.01272427f, -0.01502895f, -0.03522595f, -0.02339118f, 0.02510484f, -0.01369544f, 0.00459209f, 0.01719328f, 
    0.00228962f, -0.02766888f, 0.02017199f, -0.04439840f, -0.00220715f, 0.02118648f, 0.02891675f, -0.02442742f, 
    -0.04365255f, 0.00488348f, -0.02825520f, 0.01533581f, -0.00575298f, -0.03121303f, -0.00863826f, -0.03106965f, 
    0.00144497f, -0.03855892f, -0.00038641f, -0.01238784f, 0.00327958f, -0.02233075f, -0.03363055f, 0.02091747f, 
    -0.03545299f, 0.01799872f, -0.00245208f, -0.03971892f, 0.02442705f, 0.01505232f, 0.03079013f, -0.04033541f, 
    -0.02330283f, 0.01793986f, -0.00911786f, 0.01643188f, -0.00602176f, -0.03906412f, 0.03072968f, 0.02850966f, 
    -0.01907965f, -0.03391314f, -0.00973386f, -0.02899468f, -0.02685325f, 0.02000870f, -0.04487883f, -0.00612781f, 
    -0.00067258f, -0.03288376f, -0.04191440f, 0.01784702f, -0.00206966f, 0.02608116f, -0.01130694f, -0.01665870f, 
    -0.02594211f, -0.03367388f, 0.01679313f, -0.03021519f, -0.00619233f, -0.03336693f, 0.01636329f, 0.01899934f, 
    -0.03932255f, 0.01355465f, 0.02856936f, 0.01476710f, -0.01560481f, -0.00459371f, -0.00194239f, 0.01227415f, 
    -0.02850530f, -0.02572848f, -0.02431564f, -0.00294983f, -0.02565503f, 0.02704159f, -0.03280805f, -0.00297900f, 
    0.02540323f, -0.01058499f, -0.03356816f, -0.00091851f, 0.02273368f, -0.01154547f, -0.00369190f, -0.03570806f, 
    0.01435445f, -0.03142991f, 0.01533380f, 0.01831203f, -0.00002862f, -0.02709034f, 0.02798096f, -0.03657802f, 
    -0.00038522f, -0.04391026f, 0.01677950f, -0.02433488f, -0.02545259f, -0.03415602f, -0.03158011f, 0.02189560f, 
    -0.01765549f, 0.01338592f, -0.03269506f, -0.00280215f, 0.00927963f, -0.01157741f, -0.00595156f, -0.02163087f, 
    0.01843209f, -0.01822365f, -0.03860915f, -0.04015649f, -0.04104366f, 0.00649370f, 0.00502638f, -0.00071037f, 
    0.02161355f, -0.01322539f, -0.00405793f, 0.00219390f, -0.02772421f, -0.01050587f, 0.00781041f, -0.04430310f, 
    0.03211357f, -0.00215960f, 0.03229403f, -0.00745326f, 0.01452480f, -0.01022695f, 0.00278679f, -0.00079049f, 
    0.00702118f, 0.01032949f, -0.03664549f, 0.02610872f, 0.00401149f, -0.00510496f, 0.01474333f, 0.00203294f, 
    -0.04430377f, -0.02351806f, -0.04530867f, -0.04180017f, -0.00102783f, -0.02690652f, 0.02288179f, 0.02935523f, 
    -0.03572581f, 0.03061813f, -0.00460180f, -0.00441505f, 0.01208170f, 0.02419404f, 0.01719048f, -0.02535489f, 
    0.02252706f, -0.00441516f, -0.01265257f, 0.03262248f, 0.01551986f, -0.01879866f, -0.03631487f, -0.00206326f, 
    -0.04155105f, 0.01334049f, -0.03206148f, 0.02395652f, 0.02538946f, -0.00107588f, 0.03068980f, -0.01734106f, 
    -0.02065516f, -0.02501232f, -0.03890686f, 0.03213852f, -0.01238786f, 0.02294518f, -0.01532675f, -0.03046052f, 
    -0.01256256f, -0.04359259f, -0.04100401f, -0.00718499f, 0.01181096f, -0.01759989f, 0.01112296f, 0.01782098f, 
    -0.43643031f, 0.29189286f, 0.33369523f, -0.25492260f, -0.02882002f, -0.07599800f, -0.02087782f, 0.06037067f, 
    -0.10265075f, -0.09432805f, 0.18739632f, 0.10515689f, -0.18391709f, 0.05286593f, 0.11506034f, 0.07168552f, 
    -0.00273219f, 0.01504663f, -0.07746492f, 0.00009357f, 0.16509145f, -0.06118932f, -0.16409624f, -0.09835952f, 
    -0.24834210f, 0.05051233f, -0.00749472f, -0.03768490f, -0.02944458f, 0.04782295f, -0.03475929f, 0.01351238f, 
    0.02698225f, -0.05865574f, -0.03811017f, 0.07381932f, 0.01918643f, 0.05778047f, -0.06248974f, 0.08861083f, 
    0.01848677f, 0.18233304f, -0.06660452f, -0.04731604f, 0.01165581f, 0.12268531f, -0.00519152f, 0.06463249f, 
    -0.10442393f, 0.09461258f, -0.12030206f, -0.07927747f, 0.10748329f, -0.03141491f, 0.05558760f, 0.13547632f, 
    -0.07748760f, 0.11580993f, -0.04345055f, 0.18108112f, 0.19328354f, -0.15071949f, -0.00504152f, -0.02045243f, 
    -0.17110854f, -0.00359853f, -0.07121592f, -0.27099568f, 0.05586908f, -0.02710550f, -0.02714256f, 0.05809572f, 
    0.12647413f, -0.01794867f, 0.04917041f, 0.00783261f, 0.06187857f, -0.02682329f, -0.02756012f, 0.08212866f, 
    -0.25335959f, -0.27493754f, 0.14466138f, -0.30664533f, -0.40326545f, -0.02490391f, 0.02231137f, 0.00038606f, 
    0.11000706f, 0.09743220f, -0.12518857f, -0.09972473f, -0.03693974f, 0.08327173f, -0.00053410f, 0.02373443f, 
    -0.05131944f, -0.05333469f, -0.05900977f, -0.04403120f, 0.18984392f, -0.12358351f, 0.04274137f, -0.04475161f, 
    -0.16806033f, 0.10017700f, 0.10877699f, -0.00070067f, -0.11922003f, -0.13407081f, 0.05477488f, -0.02703460f, 
    0.02772132f, 0.01072622f, -0.01055110f, 0.07435405f, -0.10750964f, 0.00928881f, -0.09954763f, -0.02560590f, 
    0.23162423f, 0.04054839f, -0.17935757f, 0.10137234f, 0.18604890f, -0.07795600f, 0.02328471f, 0.09971120f, 
    0.11904994f, -0.02401936f, -0.05961575f, 0.04930882f, 0.06013634f, 0.00232469f, 0.04483844f, 0.02323384f, 
    -0.01572609f, 0.10325794f, -0.04055066f, -0.02813204f, 0.28542623f, 0.04856590f, -0.21133496f, 0.04430612f, 
    -0.06049045f, -0.00710906f, -0.08003460f, 0.14305070f, 0.07751121f, -0.06455587f, 0.07144514f, 0.10213491f, 
    -0.00252022f, -0.05771348f, -0.01118685f, 0.00375482f, -0.07581085f, 0.02601161f, 0.02979569f, 0.08406383f, 
    -0.09656741f, -0.28414291f, 0.16621162f, 0.16959254f, -0.23928566f, 0.09165490f, 0.02957870f, -0.01199067f, 
    -0.02408508f, 0.02387385f, 0.13602248f, -0.05504830f, 0.01500615f, 0.07644870f, 0.02883821f, -0.03207262f, 
    0.11218749f, 0.08876189f, -0.01116757f, 0.02108161f, 0.31400949f, 0.18433997f, -0.13803113f, -0.11192352f, 
    -0.07844160f, -0.13309465f, 0.05692610f, 0.02335766f, 0.04060917f, 0.04412682f, -0.07019833f, 0.04234091f, 
    0.07008366f, 0.07812639f, 0.11960841f, -0.00917932f, 0.16166010f, -0.10018763f, -0.11291242f, -0.03294496f, 
    0.31513625f, -0.03084027f, 0.14805967f, -0.00961006f, -0.23157439f, -0.05740066f, 0.04802557f, 0.02724094f, 
    -0.01757310f, 0.01959974f, -0.03252352f, -0.05285128f, -0.02919183f, 0.11235436f, 0.08464173f, -0.02113747f, 
    0.07087351f, 0.01738738f, -0.03732679f, 0.07030637f, 0.53640884f, 0.11557052f, -0.09196369f, -0.05707921f, 
    0.04210969f, -0.03257093f, 0.05922066f, 0.09928828f, 0.03799925f, -0.00529592f, -0.15459879f, -0.02291835f, 
    0.01567310f, 0.02774751f, -0.03320881f, 0.00770267f, -0.05189774f, 0.02252870f, 0.04653989f, -0.03000611f, 
    -0.06403306f, -0.20597187f, 0.00293750f, 0.14499883f, 0.02401955f, -0.02613760f, 0.05468269f, -0.11741975f, 
    -0.08334646f, 0.08261104f, -0.02755800f, -0.09849790f, 0.02185832f, 0.04852862f, 0.13225688f, 0.14712828f, 
    0.01312735f, -0.11056151f, -0.12264139f, -0.06945320f, -0.24296740f, -0.06723223f, 0.11099200f, -0.07548590f, 
    -0.23301598f, -0.02804806f, 0.01820878f, 0.01684405f, -0.02651826f, 0.01520257f, -0.13150452f, -0.08573220f, 
    -0.02195742f, 0.08657391f, -0.06367814f, 0.03646977f, -0.02396302f, 0.05740944f, -0.02781679f, 0.04532852f, 
    -0.24374147f, -0.02761450f, 0.21767637f, -0.05247649f, -0.23958330f, 0.07695337f, 0.02968310f, -0.00779024f, 
    -0.00208355f, -0.01177664f, -0.06640646f, 0.07400668f, -0.04133819f, 0.03726679f, 0.05424129f, -0.00976864f, 
    0.00590755f, 0.02227313f, 0.00117917f, -0.03058590f, 0.15161438f, -0.11695743f, 0.04598244f, -0.00715847f, 
    0.09965999f, -0.03761721f, 0.33759025f, 0.10990454f, 0.00262501f, -0.02879426f, 0.04548213f, 0.15776227f, 
    -0.19063102f, 0.03634077f, -0.08348953f, -0.20061223f, 0.00223214f, -0.01374464f, 0.02729622f, 0.21716429f, 
    -0.13815051f, 0.11207731f, 0.18447168f, -0.19104050f, -0.40261120f, 0.03562808f, 0.07317133f, 0.01222811f, 
    0.00338221f, -0.04050194f, -0.16722880f, 0.02972276f, -0.03600633f, 0.04052379f, 0.08075785f, -0.02674066f, 
    0.05220973f, -0.04830166f, -0.06895376f, -0.04400341f, 0.10413820f, -0.25065839f, -0.25614038f, 0.23689172f, 
    0.09071771f, 0.04770086f, 0.09731899f, 0.04329652f, -0.02245318f, 0.03545898f, 0.08811425f, -0.07515322f, 
    0.13053718f, 0.02467018f, 0.08754531f, 0.01645070f, -0.00140970f, 0.24595633f, 0.02973950f, 0.09566922f, 
    0.03263360f, -0.02305944f, 0.01348148f, 0.16953501f, 0.15254985f, 0.01122060f, 0.00276574f, 0.07477670f, 
    0.02156527f, 0.10118649f, 0.02270496f, 0.00901654f, 0.03413988f, -0.09597082f, -0.01912485f, -0.01745293f, 
    0.08413411f, 0.07314408f, -0.04949613f, -0.01643874f, -0.62706357f, 0.01692848f, 0.34840301f, 0.18658866f, 
    0.26993942f, 0.11268032f, 0.04788477f, 0.05425546f, 0.04587532f, 0.11247864f, -0.00522154f, -0.12767687f, 
    0.07661400f, 0.09621933f, -0.13007298f, 0.17746836f, 0.03243107f, 0.03756398f, 0.00639996f, 0.08763475f, 
    -0.11827295f, -0.25303060f, 0.12193550f, 0.20968623f, -0.09570289f, -0.20501344f, -0.08962346f, 0.10518937f, 
    0.10804534f, -0.04265337f, 0.07057097f, 0.08924522f, 0.02475378f, -0.04405498f, 0.05070634f, -0.02714955f, 
    -0.08693485f, -0.00112105f, -0.07430428f, 0.00884360f, -0.39983043f, -0.00118233f, 0.22233368f, -0.05733265f, 
    0.46350077f, -0.00323607f, 0.14043972f, 0.06446541f, 0.03023799f, 0.07974748f, 0.05649575f, 0.05240583f, 
    -0.00837588f, -0.09080048f, 0.09174795f, 0.05475670f, 0.02623065f, 0.10779569f, -0.01780288f, -0.00100396f, 
    -0.17596401f, 0.22383398f, 0.18750715f, -0.05865703f, -0.09607220f, 0.01504452f, 0.10203087f, 0.00085717f, 
    0.00718578f, -0.02915698f, 0.10807240f, -0.04210126f, -0.06830348f, -0.03930359f, -0.02116206f, -0.01296912f, 
    0.07990200f, 0.08744379f, 0.04041957f, 0.04811735f, 0.03182910f, 0.34360272f, 0.18889956f, -0.07637586f, 
    0.08723535f, 0.06064316f, 0.11937593f, -0.17733535f, 0.02426866f, 0.17992796f, 0.06501969f, 0.05664475f, 
    -0.01296914f, -0.09988400f, -0.04424107f, 0.12330094f, -0.11194030f, 0.09753013f, -0.08301537f, 0.17501757f, 
    0.18907715f, 0.12984355f, -0.02372831f, -0.10138195f, 0.23970403f, -0.06064250f, -0.03048794f, 0.02395800f, 
    -0.03711921f, 0.08103001f, -0.02206904f, -0.00625226f, 0.00031121f, -0.02407711f, -0.09999098f, 0.06356763f, 
    0.07731893f, -0.05368520f, 0.06229438f, 0.07882166f, 0.31651354f, 0.37515277f, -0.01978984f, -0.27673191f, 
    0.04182674f, -0.14771509f, -0.04172570f, -0.05261577f, 0.07500214f, 0.11738171f, -0.08792969f, -0.08290523f, 
    0.07680695f, 0.00622777f, -0.00427958f, 0.03223572f, 0.01125820f, -0.00589446f, -0.03343231f, 0.01540662f, 
    -0.23669307f, -0.23995282f, 0.21682689f, 0.50769281f, 0.26568368f, 0.06686480f, 0.05726975f, 0.06915119f, 
    0.03109989f, 0.04009020f, -0.09322016f, 0.01542039f, -0.03597457f, -0.01368279f, 0.00649561f, 0.11032592f, 
    -0.00471861f, -0.14008906f, -0.02107803f, 0.13336794f, 0.40166527f, -0.20528136f, 0.15530086f, -0.31692302f, 
    -0.23491029f, -0.04233364f, 0.01607635f, -0.06141307f, 0.08805072f, 0.04233795f, -0.00596163f, -0.04323324f, 
    0.09386177f, -0.01688934f, -0.01198146f, -0.02723396f, 0.03827792f, 0.08545573f, 0.03017488f, 0.02666306f, 
    0.23101947f, 0.26408598f, 0.03186459f, -0.14035045f, 0.06654748f, 0.03314058f, 0.13615631f, 0.00464723f, 
    -0.04665499f, -0.04344631f, -0.07644089f, -0.06952836f, 0.07379463f, -0.02910304f, -0.06647974f, 0.02355948f, 
    0.05094612f, -0.10932208f, 0.00159673f, -0.14501418f, -0.20206226f, -0.27971408f, 0.24802817f, 0.07537611f, 
    0.12890866f, -0.03727683f, 0.10159744f, -0.10503984f, 0.02410661f, 0.03763811f, -0.00759989f, -0.01062261f, 
    -0.01749378f, 0.10780299f, -0.00300963f, 0.02667229f, 0.19693373f, 0.00171137f, -0.03734309f, 0.09288056f, 
    -0.11583532f, -0.28380433f, 0.13718869f, -0.11655395f, -0.25080740f, -0.01988641f, 0.00473605f, -0.12521635f, 
    0.01935432f, 0.01075815f, 0.00154585f, 0.03510720f, -0.04476605f, 0.00491122f, 0.06373581f, -0.02914543f, 
    0.03340739f, -0.03166869f, -0.03896229f, -0.01950661f, 0.76722366f, -0.45308474f, -0.04583263f, -0.01455325f, 
    -0.05733466f, 0.10347015f, 0.16917938f, 0.15020233f, 0.03206035f, -0.23246993f, 0.08806019f, 0.12475099f, 
    0.05059670f, -0.02888005f, -0.00783562f, 0.03151767f, 0.04481398f, -0.04357121f, -0.01717447f, 0.26281071f, 
    -0.00991738f, -0.00743981f, -0.00969586f, 0.00464162f, 0.02012727f, 0.00954252f, 0.00257156f, 0.01362049f, 
    0.01466219f, 0.01627101f, -0.01577663f, 0.00718123f, -0.00325795f, -0.03758251f, 0.02488699f, -0.00755946f, 
    -0.03127610f, 0.02111426f, -0.01668084f, -0.01045017f, 0.02404244f, -0.03196897f, -0.02322596f, -0.00191824f, 
    -0.00571940f, 0.02601090f, -0.03381977f, 0.00959044f, -0.03906164f, 0.01150021f, 0.02192978f, -0.01819019f, 
    -0.03969088f, 0.02785022f, -0.02543734f, 0.03480050f, 0.01825187f, -0.02699191f, 0.00692728f, 0.00790884f, 
    0.03211798f, -0.01010154f, -0.03831182f, -0.01653823f, -0.02243015f, -0.00574510f, -0.02372382f, -0.01363049f, 
    -0.01461884f, -0.01890470f, -0.03078029f, -0.01379648f, -0.01732661f, -0.01520403f, -0.02042181f, -0.00841403f, 
    -0.02703744f, -0.03301006f, -0.01900431f, -0.02903409f, -0.02192439f, -0.01511191f, -0.00425109f, -0.02260126f, 
    -0.02702302f, -0.00207667f, -0.02272505f, -0.00976938f, 0.01580397f, -0.03742402f, 0.03236882f, 0.02275679f, 
    -0.01548594f, -0.01236557f, -0.01389323f, 0.00581896f, 0.01326265f, -0.04041206f, -0.00266588f, -0.00972595f, 
    -0.02136042f, 0.00191096f, 0.02545949f, -0.01558368f, -0.02262701f, -0.04272693f, 0.00911719f, 0.01325770f, 
    -0.02156755f, -0.00976174f, 0.02478135f, 0.03107474f, -0.04439428f, 0.01782742f, 0.01428076f, 0.02509228f, 
    0.02839265f, -0.02428414f, 0.02207915f, 0.01156155f, -0.00948547f, 0.01192876f, 0.02959024f, 0.03056756f, 
    -0.01526440f, -0.03765842f, 0.00535871f, -0.01723949f, 0.02876225f, -0.03374220f, 0.03476210f, 0.01571753f, 
    -0.01641855f, 0.00935614f, -0.02332226f, -0.02479456f, -0.03160632f, -0.02659292f, -0.00006039f, -0.00382473f, 
    0.00847867f, 0.03698557f, 0.01648361f, 0.01529436f, -0.01676764f, -0.00099626f, 0.02991793f, 0.02001843f, 
    -0.00402822f, -0.00880266f, -0.04037372f, -0.03313783f, -0.03329487f, -0.03668962f, -0.02003996f, 0.00721210f, 
    0.01817051f, 0.02110309f, -0.03058163f, -0.01090709f, -0.01575753f, -0.00329473f, 0.00097244f, 0.01895210f, 
    -0.01654425f, -0.03585408f, -0.00172708f, 0.00364607f, 0.01313682f, 0.01964972f, 0.00826071f, -0.02424359f, 
    -0.01724526f, -0.04483387f, 0.00540094f, 0.00886039f, 0.00830064f, 0.00394593f, 0.03200002f, -0.00673872f, 
    -0.02468843f, -0.02523542f, -0.00564193f, 0.00947614f, -0.02975827f, -0.01221041f, 0.02465985f, -0.01952456f, 
    -0.01039195f, 0.03295600f, 0.02622342f, -0.02139863f, -0.03159134f, -0.03294690f, 0.01586802f, 0.00380625f, 
    -0.02001687f, -0.00057236f, 0.02604280f, 0.01355233f, 0.00421311f, 0.02224708f, -0.04191756f, 0.01109075f, 
    0.00901061f, 0.01854023f, 0.02699731f, 0.01553936f, 0.00734903f, -0.01948161f, 0.03157355f, -0.02815122f, 
    -0.02159033f, -0.03261092f, 0.02084960f, 0.03081376f, -0.03980739f, 0.03638861f, 0.00509764f, 0.02592285f, 
    0.00073908f, 0.01957106f, -0.01276004f, 0.03381911f, 0.03078371f, 0.01049505f, 0.01498925f, -0.03931271f, 
    -0.01491910f, 0.00553984f, 0.01712466f, 0.01166125f, -0.00538382f, -0.00144681f, -0.02980577f, 0.00501582f, 
    -0.02033459f, 0.01050401f, -0.00330927f, 0.00527352f, -0.00598521f, -0.01963306f, 0.02359973f, -0.03153482f, 
    0.02425125f, 0.00107848f, 0.03345625f, 0.02379146f, -0.01041098f, -0.01630495f, -0.02470146f, 0.01669351f, 
    -0.02200515f, 0.01079953f, 0.03143584f, -0.02584269f, -0.04203519f, 0.00325383f, -0.00639354f, 0.01746697f, 
    -0.03442898f, 0.03313789f, -0.02675380f, -0.01799957f, -0.01937568f, 0.00797465f, 0.02231568f, -0.02478671f, 
    0.00714038f, 0.00386603f, -0.03542436f, 0.02322623f, -0.03713347f, -0.03117482f, -0.01003842f, -0.00855425f, 
    -0.01004181f, 0.00713951f, -0.02109319f, -0.02044058f, 0.00417590f, -0.01756150f, 0.00372610f, 0.02776215f, 
    0.02194352f, -0.02878767f, -0.01155876f, -0.01169964f, -0.03351801f, -0.00608204f, 0.02239346f, -0.03570081f, 
    -0.01429289f, -0.02261823f, -0.03274998f, -0.01056742f, -0.02138364f, -0.01775576f, -0.02270810f, 0.00803102f, 
    -0.02451545f, -0.03506290f, 0.00194275f, -0.01042768f, -0.01329349f, 0.01764921f, -0.00460892f, -0.03207902f, 
    0.00435444f, -0.02025719f, -0.01672587f, -0.00740842f, -0.00345877f, -0.03698657f, 0.00964076f, -0.03251128f, 
    -0.03897515f, 0.00857418f, -0.03781764f, -0.04396130f, 0.00671741f, -0.02767412f, -0.00006806f, 0.02908615f, 
    0.02143409f, -0.03370753f, -0.01166024f, -0.01389825f, -0.01793283f, 0.02594442f, -0.01939128f, -0.00430565f, 
    -0.03566372f, 0.02614976f, -0.04198850f, -0.02646103f, 0.00745197f, 0.00685492f, 0.00517042f, -0.02669599f, 
    0.00715605f, 0.01210830f, -0.00792250f, 0.02275359f, 0.01387732f, 0.02783816f, -0.01881213f, 0.02696607f, 
    0.00017817f, -0.00806533f, 0.02455774f, 0.02451926f, 0.02105939f, -0.04045008f, 0.01399667f, 0.00815740f, 
    -0.02506488f, -0.03698000f, 0.01599730f, 0.01627880f, 0.00383966f, -0.00023510f, -0.01614281f, -0.01714224f, 
    0.00360123f, -0.02932326f, -0.02615728f, -0.00208494f, 0.00221155f, -0.03241320f, 0.02853352f, -0.04012944f, 
    -0.04304449f, 0.02384718f, -0.02118963f, -0.03708638f, -0.00084280f, 0.02661679f, 0.01091446f, -0.03813457f, 
    0.01168530f, -0.02052202f, 0.01188266f, 0.02498828f, 0.01137791f, -0.02096501f, 0.01530441f, -0.01969168f, 
    0.00193928f, 0.01805031f, -0.00515210f, 0.00094649f, 0.01743239f, 0.02768926f, 0.01331937f, 0.02314772f, 
    -0.03340476f, -0.04153647f, 0.00282432f, -0.03335877f, -0.02351454f, 0.01257046f, 0.02855255f, -0.00280794f, 
    0.03049212f, -0.01956032f, 0.01315289f, -0.02763070f, 0.00433523f, -0.03639310f, -0.01719603f, -0.01276235f, 
    0.01104526f, -0.02938651f, 0.01735329f, -0.02444025f, -0.01407124f, -0.02468501f, -0.00189235f, 0.02945730f, 
    -0.03129016f, 0.02444134f, 0.00986026f, -0.04344691f, 0.03693325f, -0.02928352f, -0.03753441f, -0.04270412f, 
    0.01516812f, -0.00593162f, -0.00527274f, -0.02291688f, -0.00913076f, 0.02588313f, -0.01664008f, 0.00893455f, 
    0.00619362f, 0.02999068f, -0.02700485f, 0.02915923f, -0.00417261f, 0.02390212f, -0.02763355f, 0.00635907f, 
    0.02112720f, 0.00405324f, -0.01912159f, -0.00648192f, -0.03672995f, 0.01449863f, -0.02245096f, 0.02849728f, 
    -0.01648001f, -0.03977254f, -0.00219036f, 0.03599316f, 0.02689212f, -0.03114236f, -0.03221170f, -0.02981872f, 
    -0.01231902f, -0.00074926f, -0.01607103f, -0.02727484f, 0.00526348f, -0.04361027f, -0.03691742f, 0.03050034f, 
    -0.00462917f, -0.03282805f, 0.01121017f, -0.02338562f, 0.02957565f, 0.02582083f, 0.03338097f, -0.03328355f, 
    0.01093221f, 0.03269471f, 0.02267043f, -0.02466580f, -0.01038879f, 0.01906096f, -0.01664809f, -0.01623028f, 
    -0.00430817f, -0.02576854f, 0.00130044f, 0.03018201f, -0.03967676f, -0.00177608f, -0.02256164f, 0.02458932f, 
    -0.01454439f, 0.00233395f, 0.02224795f, 0.00032882f, -0.00936371f, -0.03521224f, 0.01923522f, -0.01009736f, 
    -0.00826550f, 0.03248171f, -0.02623590f, 0.00038578f, 0.01028022f, -0.04031856f, -0.00843764f, -0.03844746f, 
    0.03343688f, -0.00091238f, 0.02244086f, 0.03216873f, 0.02903469f, 0.00381915f, -0.01586916f, -0.00866873f, 
    0.02901311f, -0.01463040f, -0.01311208f, -0.02811937f, -0.02566354f, 0.02480923f, 0.01678177f, -0.03964669f, 
    -0.01414785f, 0.00329627f, -0.00926021f, -0.04265011f, -0.01588317f, -0.01939004f, -0.00000574f, -0.03613931f, 
    -0.01622257f, 0.01931967f, -0.00688340f, 0.01013374f, -0.01874831f, 0.02481853f, -0.03684192f, 0.01329909f, 
    -0.04121869f, 0.02473994f, 0.02746961f, 0.03275235f, 0.02929384f, -0.01423132f, 0.01598590f, 0.02519682f, 
    -0.03149085f, -0.02676975f, -0.02036347f, 0.02489323f, -0.01370381f, -0.00607120f, -0.04150112f, 0.02464484f, 
    -0.02266746f, 0.01715407f, 0.02521100f, 0.02551691f, -0.02575108f, 0.01757396f, -0.02011110f, -0.00892713f, 
    0.02578373f, -0.03631611f, -0.01944848f, -0.00106417f, 0.00586377f, 0.02672161f, -0.01802314f, -0.00245735f, 
    -0.04341302f, 0.00254445f, 0.01978377f, 0.01247007f, 0.02601223f, -0.01510583f, -0.02764489f, 0.01813287f, 
    -0.02476483f, -0.01641012f, -0.01525577f, -0.00083068f, 0.03461734f, 0.02145485f, -0.03562549f, 0.02441436f, 
    -0.03574761f, -0.02562400f, -0.03398696f, 0.03371632f, -0.04112644f, -0.01828397f, -0.04017118f, -0.01811313f, 
    0.03036221f, 0.03693872f, -0.01032690f, 0.00057947f, 0.00188082f, -0.02579379f, -0.02919624f, 0.00145726f, 
    -0.02521479f, 0.03077316f, -0.00422176f, -0.03341429f, 0.00074603f, 0.01750844f, 0.03112401f, -0.04281209f, 
    -0.02945990f, -0.00244862f, -0.00551707f, -0.03076800f, 0.03384918f, -0.02606083f, 0.02873369f, 0.01678638f, 
    0.01999243f, -0.00877559f, -0.00081135f, -0.03076300f, 0.02750034f, 0.00432559f, -0.04389942f, -0.03293045f, 
    0.03257182f, 0.03442215f, -0.02438411f, -0.01309911f, 0.02834226f, -0.03959625f, -0.02988463f, 0.01436677f, 
    0.00143604f, -0.01632096f, 0.00440193f, 0.00903117f, 0.00944070f, 0.00520018f, -0.00360931f, -0.02313996f, 
    0.00071084f, -0.03591929f, -0.01363418f, 0.00045026f, -0.00666797f, 0.03504182f, -0.03422786f, -0.04331775f, 
    -0.00170936f, -0.02315060f, -0.01185085f, -0.00008573f, -0.01620764f, -0.01892999f, 0.00336698f, 0.01949399f, 
    -0.34540421f, -0.47659045f, 0.02259958f, -0.17705882f, -0.15797250f, 0.08675069f, -0.03135917f, -0.01778615f, 
    -0.06539771f, -0.11743418f, -0.00882167f, 0.06573945f, -0.06329640f, -0.01696567f, 0.00136170f, 0.00238438f, 
    -0.03685931f, 0.03040666f, -0.15229762f, 0.14621773f, -0.13202848f, -0.29601434f, -0.06738880f, -0.15996203f, 
    -0.02968075f, -0.07157134f, 0.12139458f, -0.02380118f, 0.05480881f, 0.03162202f, 0.06176417f, -0.03139060f, 
    -0.01068993f, -0.08358072f, 0.06925166f, 0.01536580f, 0.07281660f, -0.12700784f, -0.13948438f, 0.13169290f, 
    0.24739443f, 0.12437649f, 0.08242885f, 0.26214281f, 0.33267763f, -0.22431557f, -0.05023088f, 0.01169244f, 
    -0.02524820f, -0.06581620f, 0.01171073f, 0.10598808f, 0.02178483f, 0.10672133f, 0.07034133f, 0.17782171f, 
    0.14879598f, 0.01643178f, 0.04331000f, 0.14837462f, 0.14008835f, -0.22406642f, 0.03899968f, -0.07077202f, 
    0.06164717f, -0.11894042f, 0.09212937f, -0.14885779f, 0.06376148f, 0.07929128f, -0.00863399f, 0.07617933f, 
    -0.03791884f, -0.04639412f, 0.16040224f, 0.00211989f, 0.06547152f, -0.14009221f, -0.06954487f, 0.05120524f, 
    0.25651827f, -0.08921408f, -0.35872081f, -0.08717687f, 0.08362161f, -0.03143121f, -0.10312270f, -0.16444014f, 
    0.11861690f, -0.04254652f, 0.10915302f, 0.06602033f, -0.16355391f, 0.01109832f, -0.08300387f, 0.02083709f, 
    0.07280914f, 0.00057358f, -0.00911315f, 0.02414528f, -0.34291998f, 0.12975720f, 0.22626661f, -0.03504951f, 
    -0.15941061f, 0.12342358f, 0.00630407f, 0.03192129f, 0.11889405f, -0.09237771f, -0.08230040f, 0.06136197f, 
    0.06106916f, 0.10358708f, -0.06449593f, 0.09294582f, 0.02547048f, -0.07528057f, -0.04534340f, 0.04764336f, 
    -0.02331152f, -0.22579420f, -0.29097149f, 0.04589532f, -0.42912951f, 0.03720480f, 0.16129072f, 0.09100566f, 
    -0.03696101f, 0.12150154f, -0.08236478f, 0.11441103f, -0.00905330f, 0.02170179f, -0.05295134f, 0.05108411f, 
    0.03504737f, -0.06972295f, -0.02510013f, 0.01964954f, 0.48361522f, 0.21318319f, 0.01289062f, -0.18500639f, 
    -0.17258826f, 0.16462365f, -0.10490029f, 0.01470487f, 0.01676293f, 0.01148870f, 0.03630740f, 0.06012053f, 
    -0.08820532f, -0.03364103f, -0.15297672f, 0.01023529f, 0.01495979f, -0.02672431f, -0.08517183f, -0.04300546f, 
    -0.27275407f, 0.01019848f, 0.12747234f, -0.04936997f, 0.02528848f, 0.13623549f, 0.07341111f, -0.04668548f, 
    -0.03241725f, -0.11729507f, 0.08048215f, -0.01330445f, 0.04421230f, 0.10904121f, -0.03127110f, 0.11297084f, 
    0.00227930f, -0.08454909f, -0.00656753f, 0.00211404f, 0.13490337f, 0.06590684f, 0.01545588f, 0.15068330f, 
    0.31010997f, 0.07629365f, -0.12337451f, 0.06199395f, 0.04896812f, 0.08286971f, -0.03100297f, 0.09944761f, 
    0.04950749f, -0.00014697f, -0.01929741f, 0.04383871f, 0.08339535f, 0.04140105f, 0.08615199f, 0.10873677f, 
    -0.10461094f, -0.01061764f, -0.21056958f, 0.13190243f, 0.05612725f, 0.05744334f, -0.14848287f, -0.05900452f, 
    0.03464152f, 0.04467905f, -0.11246317f, 0.16494609f, -0.09334362f, 0.09948098f, 0.01947453f, -0.04172855f, 
    -0.00373803f, -0.07027533f, -0.01972610f, 0.05677550f, 0.40089315f, -0.14073853f, -0.12651043f, -0.05280893f, 
    -0.28636485f, 0.12809658f, 0.07703576f, 0.04418747f, -0.01336558f, 0.09117532f, -0.02732451f, -0.00757004f, 
    0.05994290f, 0.05151087f, -0.08830766f, 0.18789338f, -0.01848791f, 0.08729485f, -0.04966437f, 0.07987898f, 
    0.27461773f, 0.23748770f, 0.42558536f, 0.24742703f, 0.27718148f, 0.04086190f, 0.06328609f, -0.02427281f, 
    0.03350462f, 0.08114853f, -0.08767431f, 0.08505373f, -0.09830922f, -0.00729471f, 0.11667269f, -0.02774650f, 
    0.02038791f, 0.05010138f, 0.05936041f, 0.02313976f, 0.18004480f, -0.13455088f, -0.29642111f, -0.09516339f, 
    -0.11763482f, -0.10916765f, -0.00207203f, -0.11307923f, -0.05945883f, 0.03380135f, 0.05509997f, 0.01674274f, 
    -0.05184304f, -0.03292606f, 0.07281236f, 0.00727188f, 0.00753550f, 0.05799961f, -0.07293164f, 0.03475110f, 
    0.28393933f, -0.13333438f, -0.11817815f, -0.27462918f, -0.13589229f, -0.03937146f, -0.05435318f, -0.07163051f, 
    -0.02267171f, -0.09866306f, 0.04989991f, 0.07520775f, -0.03115490f, 0.05388935f, 0.01343369f, -0.03386446f, 
    0.09725876f, -0.00035850f, 0.03126439f, 0.02213833f, 0.23132718f, 0.11575408f, 0.09210673f, 0.25101864f, 
    -0.23506959f, -0.01073625f, -0.14647551f, 0.05926464f, -0.01076387f, 0.01200308f, -0.02813065f, 0.16801383f, 
    0.06645201f, -0.02299692f, 0.12903649f, 0.01435247f, 0.04714186f, 0.17026061f, 0.02913465f, 0.04324063f, 
    0.47434008f, -0.46897689f, -0.11714729f, -0.31622022f, -0.13850395f, -0.00379191f, -0.09793101f, -0.00326149f, 
    -0.01678777f, 0.00173709f, -0.02763841f, -0.01934537f, -0.01379873f, 0.01286151f, 0.07816218f, 0.00196740f, 
    -0.00491994f, 0.03055886f, 0.04505326f, -0.02819373f, -0.53108954f, 0.19815008f, 0.20570397f, 0.23871113f, 
    -0.01792040f, 0.04836710f, 0.01448398f, -0.08600162f, 0.03339368f, 0.05571295f, 0.07123194f, 0.01288614f, 
    0.09447233f, 0.19986357f, -0.06432847f, 0.22827503f, 0.04480955f, -0.05587408f, 0.05420856f, -0.00001922f, 
    -0.31989664f, 0.57456601f, 0.23967613f, 0.07339498f, 0.10851544f, 0.12301058f, -0.04812241f, -0.00614606f, 
    0.01979795f, -0.00421985f, -0.07271001f, 0.05323501f, 0.00954575f, 0.09926803f, -0.11389175f, -0.00216972f, 
    -0.00673616f, -0.11210387f, 0.07617761f, -0.01689981f, 0.06821378f, 0.09920111f, 0.10383724f, -0.19390731f, 
    0.29251233f, -0.10574619f, 0.11188956f, -0.14263962f, 0.07585850f, 0.03345119f, 0.05859369f, 0.02945882f, 
    0.00648583f, 0.04262638f, 0.10584963f, -0.01556789f, 0.18017951f, 0.06399608f, -0.08110600f, 0.08396879f, 
    0.33793554f, 0.05216083f, -0.20935278f, 0.01239461f, -0.26013651f, 0.16569138f, 0.01335150f, 0.10720041f, 
    0.01607877f, 0.00804426f, -0.09896439f, 0.05986237f, 0.04401668f, 0.05193610f, -0.09980912f, 0.07023668f, 
    -0.03904753f, 0.10209984f, 0.02064219f, -0.11370366f, 0.20026584f, 0.37785327f, 0.11204860f, 0.39132592f, 
    0.01040015f, 0.19336000f, 0.24706306f, 0.02953053f, -0.02534626f, 0.01206215f, -0.10576731f, 0.11748210f, 
    0.07547829f, 0.01241751f, 0.16768388f, 0.00426704f, 0.25025854f, 0.02360213f, -0.23705368f, 0.07146699f, 
    0.15285501f, -0.32819515f, -0.15243027f, -0.16273473f, -0.14075956f, 0.10029313f, -0.06197167f, -0.03311881f, 
    0.00330244f, -0.10895202f, 0.00658716f, 0.02517329f, -0.07325016f, -0.05167286f, 0.06956459f, -0.01702808f, 
    -0.03469483f, 0.05678755f, -0.16343114f, 0.04193813f, 0.05265927f, 0.06865825f, -0.02839427f, 0.28149799f, 
    0.03901420f, 0.08371378f, -0.14101675f, 0.05416296f, 0.07971916f, -0.13458890f, 0.00645241f, -0.00606612f, 
    -0.04859293f, 0.05793423f, -0.08493448f, -0.04366110f, 0.05958516f, -0.06969545f, 0.16688573f, -0.21406990f, 
    -0.05454476f, -0.07550327f, -0.13393879f, 0.11284537f, 0.03769111f, 0.01810197f, -0.02156527f, 0.05891809f, 
    0.12656932f, 0.01863886f, 0.00746928f, 0.05457471f, -0.00880836f, -0.14704946f, 0.05531764f, 0.03947788f, 
    0.01736537f, -0.01253807f, 0.20723403f, 0.04947301f, -0.14828473f, -0.08877803f, -0.14178357f, 0.15893668f, 
    0.14443046f, 0.01006575f, 0.04753273f, -0.04033439f, 0.10325715f, 0.13034986f, 0.03965429f, 0.05120909f, 
    0.15942539f, -0.12530522f, -0.04922814f, 0.02973574f, 0.02304817f, -0.00783487f, 0.11434809f, 0.10558388f, 
    0.24993747f, 0.15148938f, 0.00177177f, 0.14352174f, -0.02578540f, -0.02522737f, -0.08379700f, 0.03424073f, 
    0.12358299f, -0.04772798f, 0.04789924f, -0.07229850f, -0.00316011f, 0.09631947f, 0.09477150f, 0.09445471f, 
    0.12673970f, 0.09731322f, 0.04566047f, 0.01070614f, 0.03606137f, -0.26263064f, -0.03919959f, -0.02283001f, 
    0.18133977f, -0.15272871f, 0.03434067f, -0.12413722f, 0.16072570f, 0.06648809f, 0.03305686f, 0.00884210f, 
    0.08692041f, -0.07665364f, 0.02417917f, 0.01177502f, 0.03800183f, -0.07045508f, -0.04273684f, 0.02403369f, 
    -0.06532739f, 0.24243297f, -0.04018006f, 0.26162961f, -0.24880882f, 0.18409003f, -0.06733406f, 0.18262142f, 
    -0.06634633f, 0.05760748f, -0.18715617f, 0.03036906f, -0.01230814f, -0.01109061f, -0.07611740f, -0.10989908f, 
    -0.12832262f, 0.04238891f, -0.01943924f, -0.03112419f, 0.17200942f, 0.12432872f, -0.04468602f, 0.08738428f, 
    0.00034011f, -0.19008252f, -0.10591304f, -0.02453853f, -0.10925328f, 0.00851973f, -0.09245723f, -0.02168108f, 
    0.01439488f, -0.16402681f, 0.06678004f, 0.10689625f, 0.02092433f, 0.08830544f, 0.19117363f, -0.04120980f, 
    0.04335180f, -0.26126581f, 0.02002446f, -0.10631878f, 0.22898424f, -0.00736700f, 0.01379374f, -0.08491697f, 
    0.06761575f, -0.07649368f, 0.02429323f, -0.05631626f, 0.03317518f, 0.02990208f, 0.02324095f, 0.12052538f, 
    0.10153076f, -0.10658267f, -0.03769200f, 0.07780643f, -0.38242805f, 0.27435887f, 0.00852365f, 0.12913559f, 
    -0.10274049f, 0.06821797f, -0.00230118f, -0.10865346f, 0.07512993f, 0.01736103f, -0.03135055f, 0.02569239f, 
    -0.03552100f, 0.04861537f, 0.01939209f, 0.15896776f, -0.00791254f, 0.02985630f, 0.10967163f, -0.02197227f, 
    -0.00780167f, 0.01613223f, 0.00741192f, -0.01026515f, -0.01312932f, 0.01271388f, 0.02887826f, -0.01225513f, 
    0.01078619f, -0.02069746f, 0.00834992f, 0.00728805f, 0.03005425f, 0.01535208f, -0.01664026f, -0.02227634f, 
    -0.02529665f, -0.04226609f, -0.02191156f, -0.00371427f, -0.02359113f, 0.00819408f, -0.00145227f, -0.01872183f, 
    0.01411535f, 0.00517869f, -0.00330983f, -0.02712253f, -0.03444288f, 0.02404726f, 0.02757876f, -0.02895755f, 
    -0.04500696f, 0.01329994f, 0.01149057f, 0.01768827f, -0.03156660f, 0.00248266f, 0.03037589f, 0.02887564f, 
    0.00270798f, 0.02240896f, -0.03882965f, -0.00655699f, -0.03510351f, 0.02119651f, 0.02426159f, 0.01778460f, 
    -0.00034207f, 0.00615774f, -0.04140873f, 0.03047454f, -0.04660734f, 0.03350687f, -0.02091024f, 0.01286708f, 
    0.00759969f, 0.01123496f, 0.02980278f, 0.00104428f, 0.00467824f, -0.02785122f, -0.01295501f, -0.02543279f, 
    -0.01878940f, -0.00555195f, -0.03376932f, -0.01615328f, 0.02028135f, 0.00615174f, -0.03468654f, -0.01669611f, 
    0.00660525f, 0.02331450f, -0.02975225f, 0.01577252f, 0.01102229f, 0.02502166f, -0.00166664f, 0.01491261f, 
    0.00674495f, 0.00626401f, 0.01827778f, -0.02947049f, -0.04361601f, -0.04510116f, -0.02535154f, -0.00337917f, 
    -0.00857756f, 0.02686169f, -0.02643912f, -0.00341999f, 0.01119530f, -0.03236170f, -0.01331082f, 0.00660396f, 
    0.00584491f, -0.00791315f, -0.03283982f, 0.03276775f, 0.01690264f, -0.01840025f, -0.02371009f, 0.02978969f, 
    0.02825455f, -0.02473981f, 0.00311668f, 0.00398462f, -0.03155734f, -0.00704185f, -0.01735018f, 0.01145708f, 
    0.01567791f, 0.02257582f, -0.02735225f, -0.03902579f, 0.02129757f, -0.02261475f, 0.00286399f, 0.00684844f, 
    -0.01219767f, -0.03235479f, -0.01915341f, -0.00768327f, 0.01347285f, 0.03385629f, 0.03145660f, -0.01515755f, 
    -0.02173190f, -0.00414273f, -0.02651133f, -0.00871013f, 0.01489706f, 0.00481029f, 0.02308408f, -0.02118025f, 
    -0.04728655f, -0.00249513f, 0.00562457f, 0.02422015f, -0.00949978f, -0.04563548f, 0.03084708f, -0.00886098f, 
    0.02742913f, -0.00541680f, 0.00321049f, 0.03075707f, -0.03040055f, -0.02957159f, -0.03814613f, 0.02908221f, 
    -0.02280782f, -0.03427462f, 0.00125431f, 0.01016964f, -0.04034071f, 0.00098801f, -0.03438190f, 0.00710568f, 
    0.00344216f, 0.03002803f, -0.02233565f, -0.02581833f, 0.00832502f, -0.04349619f, 0.01959015f, -0.01815087f, 
    -0.01969922f, 0.00383358f, 0.02492086f, -0.00353206f, -0.02600172f, -0.03143071f, -0.00549397f, -0.02109220f, 
    0.02111568f, -0.00536303f, -0.01155019f, -0.02817457f, -0.00264511f, 0.02773999f, 0.01832020f, -0.04514568f, 
    0.03093015f, -0.04151816f, 0.00664965f, -0.00621729f, 0.01481661f, -0.01611267f, 0.02428946f, -0.04835391f, 
    -0.01997845f, -0.02104886f, 0.02156225f, 0.00661478f, -0.01763770f, -0.00719831f, -0.01852721f, -0.04109919f, 
    -0.02972766f, 0.01700241f, 0.03135591f, -0.02626461f, 0.00256209f, 0.01686723f, -0.01850284f, -0.03315033f, 
    0.02425750f, 0.00864848f, 0.00815813f, 0.02923433f, -0.02702117f, -0.02135341f, -0.03581920f, 0.03195822f, 
    -0.01938773f, 0.00879264f, -0.01093787f, -0.00417058f, -0.03510283f, -0.01243830f, 0.00686137f, 0.02758876f, 
    0.01878005f, 0.00319737f, -0.01416801f, -0.02524801f, -0.02035808f, 0.00836795f, -0.03472413f, -0.01784028f, 
    -0.01654975f, 0.02734307f, 0.03080220f, -0.00083205f, -0.04396665f, 0.01999792f, -0.02281416f, -0.03726641f, 
    -0.02053514f, 0.02937403f, -0.03294588f, 0.02215018f, -0.03842486f, 0.02979327f, -0.01755672f, -0.03154732f, 
    -0.00908920f, -0.00731625f, -0.03851261f, 0.00526941f, -0.00034013f, 0.02645360f, -0.03909143f, -0.03368223f, 
    -0.03821325f, -0.00190049f, -0.03334209f, 0.00502554f, -0.02385544f, 0.02748752f, -0.00866275f, -0.02948015f, 
    -0.04283120f, -0.00501414f, 0.02723498f, 0.01659217f, 0.01739158f, -0.00749607f, -0.01622115f, 0.00968318f, 
    0.00549201f, 0.00605242f, 0.01229805f, 0.01353912f, 0.02076511f, -0.04019474f, -0.00130939f, -0.01757155f, 
    -0.02177178f, 0.02091685f, -0.02062821f, -0.04538598f, 0.01466068f, 0.02866386f, -0.04402273f, -0.02972466f, 
    -0.01123733f, -0.00829536f, -0.02089996f, 0.00594515f, 0.01552554f, -0.01699478f, 0.01744121f, -0.02314331f, 
    -0.04490759f, -0.01575407f, 0.00606347f, 0.01518075f, 0.03451071f, -0.02726984f, -0.02773348f, -0.00050764f, 
    -0.00487516f, -0.01164842f, 0.01183186f, -0.03423979f, -0.02064982f, 0.02953050f, -0.03972896f, 0.01658632f, 
    0.01155237f, -0.02187067f, 0.01720797f, -0.02459338f, 0.03168125f, 0.02696357f, 0.01692415f, -0.02650645f, 
    -0.04626099f, 0.00311355f, -0.00093151f, 0.02021266f, 0.01247099f, -0.01807264f, -0.03320402f, 0.01603357f, 
    0.02748045f, 0.01809678f, -0.02614637f, -0.02292143f, -0.04210023f, 0.02919987f, -0.03364681f, -0.04712061f, 
    -0.01302094f, 0.01994442f, 0.01934491f, -0.04299319f, -0.04367391f, 0.03657430f, 0.01612793f, -0.01171369f, 
    0.01225446f, 0.02329180f, 0.00656466f, -0.00006832f, 0.02285270f, 0.02930268f, -0.00367372f, -0.00387065f, 
    -0.04086189f, -0.03372842f, -0.00023419f, -0.02082511f, 0.02988204f, 0.02323898f, 0.03225815f, -0.01402314f, 
    -0.01858623f, -0.01232879f, 0.00938562f, 0.00548660f, -0.02942083f, 0.01714789f, -0.00126632f, -0.01747325f, 
    -0.04162168f, -0.01936463f, -0.04639744f, -0.00249131f, 0.00070319f, 0.00279160f, 0.03295783f, -0.01888958f, 
    -0.03638457f, -0.00345700f, -0.00956724f, 0.01262542f, -0.02240964f, -0.03407411f, -0.03577805f, 0.00192555f, 
    -0.01828066f, 0.01712798f, 0.01920454f, -0.04559154f, -0.00800804f, 0.00707770f, 0.00744785f, -0.04391045f, 
    0.00046135f, -0.01578815f, -0.03033210f, -0.04101036f, 0.01118477f, -0.00802461f, -0.02170583f, -0.03866223f, 
    -0.02560842f, -0.01133496f, -0.00400803f, 0.00719419f, -0.03579995f, 0.02612910f, 0.03126278f, -0.01241319f, 
    0.03036404f, 0.00823459f, -0.01924214f, 0.03018984f, 0.02182659f, -0.03460532f, -0.01234808f, 0.03005489f, 
    -0.03626804f, -0.02551481f, 0.00063137f, -0.01273615f, 0.01084374f, 0.03026060f, 0.01926331f, 0.00627158f, 
    -0.03382022f, -0.03289523f, 0.00292999f, 0.02560487f, -0.03819335f, 0.01327121f, -0.00724214f, -0.01211174f, 
    0.02235284f, -0.03937655f, -0.00687368f, -0.00433109f, -0.01286058f, 0.01557769f, 0.02812849f, -0.01870181f, 
    0.02428396f, 0.01266649f, 0.01471908f, -0.02987113f, 0.00210343f, -0.01609517f, -0.01025375f, 0.02795911f, 
    0.01852507f, 0.01281246f, -0.03504573f, 0.02466625f, -0.03846948f, 0.01730459f, 0.00230711f, -0.01234352f, 
    -0.02418175f, -0.02605043f, 0.03014417f, -0.03626949f, 0.01529033f, -0.03629978f, -0.02158566f, 0.01625592f, 
    -0.02139082f, -0.01000266f, -0.01229173f, -0.00480128f, -0.02256089f, 0.02993581f, 0.02650460f, 0.01477521f, 
    -0.04169121f, 0.02745062f, -0.00881185f, -0.01230274f, -0.00430881f, 0.02236341f, 0.00143250f, 0.02798763f, 
    -0.01739661f, -0.00160562f, 0.00922789f, -0.03635132f, -0.01263139f, -0.01132263f, -0.01158327f, 0.01149868f, 
    0.00425948f, -0.00573310f, -0.01629342f, -0.00973003f, -0.02178876f, -0.03709775f, 0.02575589f, 0.01074316f, 
    -0.04247209f, 0.01615795f, -0.02455438f, -0.00345124f, -0.03315519f, 0.03751199f, 0.02876543f, -0.02833318f, 
    -0.04156455f, -0.03282304f, 0.02102899f, 0.03214809f, -0.00465417f, -0.01207230f, 0.02479197f, 0.02210034f, 
    -0.03238473f, -0.04507917f, -0.02304644f, -0.01681296f, 0.02482416f, 0.01697354f, -0.00618606f, -0.02890065f, 
    -0.01777915f, -0.01030484f, 0.01905396f, 0.01625112f, 0.02606364f, 0.00610247f, -0.02918828f, 0.02852073f, 
    0.01743730f, 0.01355322f, -0.03241326f, -0.03847115f, 0.01242019f, -0.04019894f, -0.03944352f, 0.02378132f, 
    -0.01025034f, 0.02646071f, 0.02343826f, 0.02630950f, 0.00301954f, 0.01666955f, -0.02309397f, -0.02886853f, 
    0.01018671f, -0.03754477f, -0.03924477f, -0.02585821f, -0.01960917f, -0.04264632f, -0.01806407f, -0.01898183f, 
    -0.00575430f, 0.00263333f, -0.03033981f, -0.02098300f, -0.02364570f, -0.03803922f, 0.00981722f, 0.00260545f, 
    0.02318709f, 0.01246682f, 0.01535881f, -0.04317224f, -0.03785713f, -0.03474501f, 0.01964911f, -0.04442360f, 
    -0.03706197f, -0.04031313f, -0.01818505f, 0.02958868f, -0.04552208f, -0.02209951f, -0.03128537f, 0.01954083f, 
    -0.04327083f, 0.01848822f, -0.00093695f, 0.00542023f, 0.03796073f, 0.03051600f, 0.00345412f, -0.01844883f, 
    0.00076826f, 0.02781045f, -0.03639234f, 0.02204330f, -0.03697674f, 0.00955785f, -0.02446616f, 0.00449445f, 
    -0.00801215f, 0.00895989f, 0.00048287f, 0.02249596f, -0.01974281f, 0.00640222f, -0.00778936f, -0.00766776f, 
    -0.00116513f, -0.02430376f, -0.02538160f, 0.02550153f, -0.00660076f, -0.01639902f, 0.00985905f, -0.04332083f, 
    -0.03740187f, -0.02914680f, 0.02430754f, -0.03834933f, -0.03311248f, 0.02905893f, 0.00684746f, 0.03092715f, 
    -0.01529961f, -0.04279403f, 0.00687959f, -0.00291737f, -0.00233169f, 0.01773982f, -0.01342344f, -0.03223378f, 
    0.01354361f, 0.01672502f, -0.02278664f, 0.01708554f, -0.04576638f, 0.01552362f, 0.02700979f, 0.02164652f, 
    -0.01061239f, 0.00207503f, 0.00905004f, 0.02215107f, 0.00095078f, -0.03477997f, 0.00592539f, 0.01036126f, 
    0.02536658f, 0.00784194f, 0.02111457f, 0.03271003f, 0.00909306f, 0.00153011f, -0.02274469f, -0.01026026f, 
    -0.02568993f, 0.00630026f, -0.01421555f, -0.04082726f, 0.01688663f, -0.02636836f, -0.02705981f, 0.00917477f, 
    0.01590599f, -0.03711247f, -0.00225489f, 0.00274837f, -0.00820153f, 0.00471444f, 0.02747178f, -0.01912984f, 
    0.02526147f, 0.02785292f, -0.02007565f, 0.00787826f, -0.02877977f, -0.03075147f, -0.04049131f, -0.03105718f, 
    0.01018130f, 0.03192262f, 0.00564486f, 0.02937699f, -0.01876139f, 0.01129085f, 0.02129155f, -0.01624527f, 
    -0.03155854f, -0.00328167f, -0.02447935f, -0.03453643f, -0.01661709f, 0.02831865f, 0.01632990f, -0.03277714f, 
    -0.01380066f, 0.01389589f, 0.00894336f, 0.03366768f, 0.02201267f, -0.02914632f, -0.01195384f, 0.01508790f, 
    0.00104186f, 0.02587711f, -0.03399051f, 0.00864889f, -0.02299511f, -0.00254453f, -0.04247085f, 0.03285225f, 
    0.00469079f, -0.04115339f, 0.00647606f, 0.00947572f, -0.03775332f, 0.01502814f, -0.02248954f, 0.02770109f, 
    -0.00072556f, -0.03038269f, 0.01432349f, -0.00564978f, -0.02590183f, -0.01083988f, 0.01835539f, 0.03291293f, 
    -0.04695102f, -0.01511268f, 0.00436403f, -0.03436250f, -0.00680464f, -0.00903831f, -0.00782979f, 0.01969445f, 
    -0.02704187f, -0.00690560f, 0.00883633f, 0.01337902f, 0.01602883f, -0.04599998f, 0.00108154f, -0.03458032f, 
    -0.03574085f, -0.04397901f, -0.02803960f, -0.03132825f, -0.03871031f, -0.00724919f, -0.01598078f, 0.02993139f, 
    -0.02951877f, -0.01428555f, 0.01150157f, -0.01674138f, 0.01622587f, -0.00376290f, -0.01517862f, -0.00483474f, 
    0.00465156f, -0.02576631f, 0.02405933f, 0.03149258f, 0.02338691f, -0.00344040f, -0.01993323f, 0.02110922f, 
    -0.02323802f, -0.01037376f, -0.00950603f, -0.01325177f, 0.02754603f, 0.00737431f, -0.00414316f, 0.02948770f, 
    -0.03946185f, -0.00644235f, -0.01841858f, 0.03435868f, -0.03852543f, -0.00802466f, -0.00630529f, -0.01757873f, 
    0.02276697f, -0.03153153f, 0.02752825f, -0.00613900f, 0.02867008f, 0.01336063f, 0.00589596f, -0.03331766f, 
    -0.00323995f, -0.03167584f, 0.00777704f, -0.00284151f, -0.00856148f, 0.03190921f, 0.02055344f, -0.03673257f, 
    -0.01306886f, 0.02975466f, 0.00851908f, -0.00916481f, -0.03091520f, -0.01170380f, -0.02909574f, 0.01583433f, 
    0.01082356f, 0.02321276f, 0.00014676f, -0.03245108f, 0.03203319f, -0.01537659f, -0.02541658f, 0.02753452f, 
    -0.02189869f, 0.01357246f, -0.02022304f, 0.02265392f, -0.01231227f, -0.03468560f, -0.02637939f, 0.00264293f, 
    -0.03605111f, 0.02140442f, -0.00672949f, 0.01668458f, -0.03348430f, -0.02378962f, 0.02555029f, -0.02749708f, 
    0.01926882f, 0.00069677f, 0.02903755f, -0.00413369f, 0.00304939f, 0.02752179f, -0.04597674f, -0.01646716f, 
    -0.00415171f, -0.02482299f, -0.01615563f, 0.03184473f, 0.02722965f, -0.02747704f, -0.02104138f, 0.00801471f, 
    -0.01489393f, -0.02613029f, -0.02930330f, 0.01195946f, 0.01450412f, -0.04262887f, 0.02851014f, -0.02467925f, 
    -0.00363135f, -0.01918160f, -0.02945425f, -0.02658535f, -0.01771792f, 0.01768199f, -0.00949133f, -0.03841395f, 
    0.00947311f, 0.00255758f, -0.02798796f, -0.03783776f, -0.04773292f, 0.03129118f, 0.00393642f, -0.02743198f, 
    -0.00171125f, -0.02481981f, -0.00495778f, -0.02888202f, 0.02561914f, -0.00796207f, -0.03311254f, -0.00817141f, 
    -0.01814486f, -0.04122559f, 0.00315931f, -0.04218437f, -0.02580087f, 0.01845933f, -0.03949914f, -0.03052701f, 
    0.00804674f, -0.02594544f, 0.00476253f, 0.01955044f, 0.02081674f, 0.00728637f, 0.01481793f, 0.01144389f, 
    -0.00597305f, -0.03235595f, -0.01415574f, 0.02588121f, -0.03285788f, 0.00679226f, -0.01774371f, -0.03772396f, 
    0.00631977f, -0.00782179f, 0.01475619f, 0.02243572f, 0.02961339f, -0.02037470f, -0.04203924f, -0.01537821f, 
    0.03811421f, 0.00706654f, -0.03025063f, -0.03510422f, 0.02190831f, -0.01541175f, 0.01187988f, 0.02822950f, 
    -0.02293215f, 0.00660478f, 0.01530448f, 0.01142805f, -0.00168278f, 0.00938941f, -0.03949935f, -0.03229107f, 
    0.02664540f, -0.00430450f, -0.02631664f, -0.01696004f, -0.00199713f, 0.03213044f, 0.00989884f, 0.01569881f, 
    -0.00652976f, -0.02039606f, -0.02647773f, -0.00771142f, 0.03088951f, 0.03304046f, 0.01157423f, 0.00898116f, 
    -0.02101276f, -0.02207474f, 0.00493069f, -0.03928632f, -0.02489248f, -0.00235457f, 0.02337621f, -0.00903812f, 
    -0.02015758f, -0.02403236f, -0.02075795f, 0.00984511f, -0.04341761f, 0.01127079f, -0.04634405f, 0.01760776f, 
    -0.03005599f, -0.03494303f, -0.03404606f, -0.03314088f, -0.04332437f, 0.01432420f, -0.01582010f, 0.00105636f, 
    0.02454370f, 0.02047277f, -0.03006676f, 0.00971355f, 0.03556487f, 0.02859166f, -0.01727832f, 0.03027877f, 
    0.01871965f, -0.04166799f, -0.01713467f, -0.00139086f, 0.00213708f, -0.04226875f, -0.01014907f, 0.01895880f, 
    0.02265700f, -0.00056956f, -0.02753046f, -0.02978513f, -0.00658645f, -0.02201323f, 0.02322577f, 0.00757461f, 
    -0.03957646f, -0.02220244f, -0.03078703f, -0.00800258f, -0.01312910f, -0.03170371f, 0.00936625f, -0.03309942f, 
    0.01457941f, -0.03409980f, -0.04396306f, -0.02376590f, -0.00620017f, -0.00463819f, -0.02851216f, -0.00143706f, 
    -0.00356568f, 0.01343437f, 0.01719017f, -0.01004710f, 0.02612836f, -0.03178180f, -0.04640936f, 0.03116642f, 
    -0.01220445f, 0.01332077f, 0.02744681f, 0.00807407f, 0.02243499f, -0.02226757f, -0.02318205f, -0.00182248f, 
    0.03293582f, 0.02524993f, -0.02298159f, -0.01404665f, -0.03329467f, -0.03333369f, 0.01981132f, -0.02724212f, 
    -0.00061175f, -0.03889430f, 0.02997169f, -0.00649103f, -0.02944770f, 0.03113689f, -0.00564452f, -0.04195557f, 
    0.01065674f, -0.00176989f, 0.02626175f, 0.01887031f, -0.03867373f, -0.02785907f, 0.03033117f, -0.01346560f, 
    -0.02151876f, 0.04131408f, -0.01536960f, 0.01144950f, -0.03245117f, -0.01577004f, -0.02194241f, -0.01017273f, 
    0.01358117f, 0.01883383f, -0.02358048f, -0.03646790f, 0.02150663f, 0.02532306f, 0.01544809f, 0.01180691f, 
    0.00364320f, 0.03364200f, 0.00600697f, -0.01216020f, 0.00078764f, 0.03417059f, 0.00188975f, 0.00079240f, 
    -0.00796542f, -0.03414391f, 0.00870678f, -0.00716492f, 0.00622984f, 0.00268895f, 0.02278083f, 0.03483901f, 
    0.01677735f, 0.00691045f, -0.03682289f, 0.02511192f, -0.02043614f, 0.01359229f, -0.03625389f, -0.02410693f, 
    0.01157041f, -0.02942784f, -0.02792397f, 0.00592757f, -0.01120706f, 0.00425980f, 0.00621311f, -0.03012797f, 
    0.00825132f, 0.01265151f, -0.02882472f, -0.00481986f, -0.02217926f, -0.00796537f, -0.03385379f, 0.00937341f, 
    0.01472194f, -0.02317494f, -0.01567173f, 0.03230520f, 0.00501769f, 0.01389880f, 0.02309309f, -0.03358807f, 
    0.01838495f, 0.00639036f, -0.02057214f, 0.02740824f, 0.00910441f, 0.02618691f, 0.02005988f, -0.03841802f, 
    -0.03108204f, 0.00691943f, -0.00954544f, -0.01159192f, -0.03721327f, 0.03431332f, -0.02319972f, 0.02262021f, 
    0.00812443f, -0.00176273f, -0.01457600f, 0.00777440f, -0.03431473f, 0.00782539f, -0.01042262f, 0.01401738f, 
    0.03282117f, -0.03482517f, 0.00617919f, 0.00915472f, -0.04208162f, 0.00169689f, 0.01239714f, 0.00287573f, 
    -0.04286111f, 0.02658179f, 0.01695582f, -0.02350965f, -0.01242790f, -0.03387389f, -0.03677149f, -0.01207478f, 
    -0.01616613f, 0.00847614f, -0.01105429f, -0.04738361f, 0.02781734f, 0.00278891f, -0.01455936f, 0.03191118f, 
    -0.03575389f, 0.01338856f, 0.02586330f, -0.00492021f, -0.03745300f, -0.03858973f, -0.03840533f, 0.02168535f, 
    0.02031371f, -0.01204869f, 0.01260737f, 0.03273600f, -0.01683772f, -0.03934497f, -0.04505079f, 0.01370191f, 
    0.02999310f, -0.02822362f, -0.02496593f, -0.01261072f, 0.00792496f, 0.01672295f, -0.02781812f, 0.03020136f, 
    0.00346015f, -0.03413539f, -0.02254835f, 0.02180118f, -0.02546518f, -0.02518394f, -0.00646401f, 0.02922362f, 
    0.00369083f, -0.02653849f, -0.00503337f, -0.03798617f, -0.03443205f, -0.03282490f, 0.01298264f, 0.03147054f, 
    0.00697754f, -0.03593943f, -0.03897781f, -0.01212048f, 0.03018665f, 0.01909341f, -0.00552661f, -0.00620194f, 
    0.00049549f, -0.03780025f, -0.01558363f, -0.02938097f, 0.01613156f, -0.02961028f, -0.03415821f, 0.01109506f, 
    0.02562181f, 0.01799712f, 0.00362636f, -0.00902156f, -0.02445784f, -0.00083645f, -0.02014347f, 0.00950107f, 
    -0.00280451f, -0.00479761f, -0.02354846f, 0.03259914f, -0.03529336f, 0.02973142f, -0.02474250f, 0.01047597f, 
    -0.04011759f, -0.04027111f, 0.02700090f, 0.00456824f, -0.03558374f, 0.02865932f, 0.02089380f, 0.02892356f, 
    -0.02408178f, -0.02139899f, 0.01052147f, -0.04350177f, -0.02708407f, 0.00126011f, -0.03322848f, 0.02891794f, 
    -0.00220461f, 0.01457328f, -0.03112444f, 0.01853284f, 0.03592525f, 0.01117088f, 0.01558605f, 0.01391849f, 
    0.02278555f, -0.00133629f, -0.01203473f, -0.02881545f, 0.01645368f, 0.02598183f, -0.02035910f, -0.03191705f, 
    -0.01664887f, 0.00542598f, -0.00037809f, -0.04459021f, 0.00920217f, 0.02585405f, -0.03129418f, -0.00611565f, 
    0.02400789f, 0.00709848f, -0.01901756f, 0.00443743f, -0.02927518f, -0.01520887f, 0.01836676f, 0.02885054f, 
    -0.02864604f, 0.01068106f, -0.03076642f, 0.00681139f, 0.03473508f, -0.03576164f, -0.01874148f, -0.03303745f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01417327f, -0.02281982f, -0.02859136f, -0.00196707f, -0.00549240f, 0.09025818f, 0.00203968f, 0.02563247f, 
    0.02557481f, -0.06613812f, 0.02233702f, 0.05462017f, -0.01472528f, 0.10408340f, -0.03217449f, -0.04669006f, 
    -0.00089546f, -0.00568914f, -0.00328832f, 0.01830729f, -0.00642338f, 0.01910265f, 0.02399954f, 0.08904674f, 
    -0.02302708f, -0.04471086f, -0.04234796f, 0.05431508f, -0.00517847f, 0.04927723f, -0.03233102f, -0.01253337f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.17539777f, -0.05541607f, -0.20353495f, 0.53079897f, -0.03931432f, -0.27108699f, 0.33711657f, 0.00143887f, 
    0.21105860f, 0.09163039f, -0.14892305f, -0.22947080f, -0.05009720f, -0.44876668f, 0.08576885f, -0.03141179f, 
    0.03663186f, -0.39869696f, -0.11035373f, -0.02935109f, -0.07350858f, 0.04239468f, -0.11878432f, -0.37239587f, 
    0.02143211f, -0.08832758f, 0.09104536f, -0.13877709f, 0.16614379f, 0.11991250f, -0.05651439f, -0.00811075f, 
    0.02271777f, 0.08288050f, 0.38472101f, 0.35264096f, 0.10722876f, 0.16272178f, -0.92582154f, -0.29017746f, 
    0.16248822f, 0.09611550f, -0.04527364f, -0.34828979f, -0.12303498f, -0.18344505f, -0.08566850f, 0.00242545f, 
    -0.15402654f, 0.34346184f, 0.14558904f, 0.13695993f, 0.17338642f, -0.15605791f, 0.16218032f, 0.00649796f, 
    -0.09115985f, 0.14999019f, 0.07737376f, -0.30738813f, -0.16500485f, -0.09742732f, -0.05330135f, -0.12601350f, 
    -0.00664093f, 0.12145930f, 0.12897667f, -0.16946426f, 0.07792619f, -0.12993360f, 0.16359147f, -0.65330261f, 
    0.35652766f, -0.17536749f, 0.12988378f, 0.30745798f, 0.06703662f, 0.07834559f, -0.11083645f, 0.10039033f, 
    0.13220151f, 0.03644591f, 0.00093777f, -0.04944561f, 0.16158609f, -0.00235847f, 0.02641807f, -0.79420513f, 
    -0.04434089f, 0.08770869f, 0.04441850f, -0.09562110f, 0.10953359f, -0.46440712f, 0.04146448f, 0.08580345f, 
    -0.12137190f, -0.10799423f, -0.69779181f, -0.08369940f, 0.00294898f, 0.10804678f, 0.20098805f, -0.04910377f, 
    -0.14498083f, -0.13700071f, -0.03381149f, 0.28833500f, 0.16469403f, -0.26211640f, -0.15205076f, 0.09582889f, 
    0.09217696f, 0.38516569f, -0.82367933f, -0.03636347f, -0.09037349f, -0.17167439f, 0.08193837f, -0.28650552f, 
    -0.00290020f, -0.06784054f, 0.07754162f, -0.47323528f, 0.08429697f, 0.33669871f, 0.11593927f, 0.10079039f, 
    -0.01742457f, 0.10101092f, 0.22545123f, 0.11774971f, 0.02992162f, -0.38492548f, 0.18249142f, 0.27265561f, 
    -0.25274032f, -0.33538634f, 0.15450220f, 0.32252860f, -0.03016560f, -0.06952736f, -0.03385369f, 0.00548354f, 
    -0.08616738f, -0.01340551f, -0.03353219f, -0.06729063f, -0.06722029f, -0.05779986f, -0.16512190f, 0.16497959f, 
    -0.12452506f, -0.01516800f, -0.02461387f, -0.57088584f, -0.13224305f, -0.16707404f, -0.02041070f, 0.02250943f, 
    0.00436397f, -0.00398586f, -0.28029406f, 0.08449324f, 0.08489805f, 0.02913672f, -0.44063312f, -0.12228330f, 
    -0.20676255f, 0.20327505f, -0.01435285f, 0.03599299f, -0.13829111f, 0.33607101f, -0.16804834f, -0.06565332f, 
    -0.08050252f, 0.11160593f, -0.27429968f, 0.06277034f, 0.07993376f, 0.09715399f, 0.08618794f, 0.49169236f, 
    0.15664850f, 0.11525351f, 0.15721579f, 0.23172019f, 0.10840599f, -0.30060354f, -0.11373277f, -0.00105254f, 
    -0.04665517f, -0.00760618f, 0.04673028f, -0.48694864f, 0.05917338f, 0.13401751f, 0.42170668f, 0.00706946f, 
    0.16525850f, 0.19916293f, 0.13927057f, -0.14368157f, 0.14908844f, -0.82622612f, 0.14778605f, 0.10279842f, 
    0.16784880f, -0.01589498f, 0.14063126f, 0.03798709f, 0.16851234f, 0.02347424f, 0.00514421f, 0.26460370f, 
    0.16509558f, -0.13979542f, 0.16785423f, 0.06668054f, -0.08103443f, -0.56713712f, 0.01280611f, 0.08084154f, 
    -0.13311632f, -0.12882355f, 0.31140381f, -0.51256150f, -0.10885957f, -0.06647410f, 0.15369503f, 0.30899793f, 
    -0.48740971f, -0.00472855f, -0.08802643f, -0.11047954f, 0.16137351f, 0.12947616f, -0.11729619f, -0.06544774f, 
    -0.07332135f, 0.05672278f, -0.29441887f, 0.16503780f, 0.18030070f, -0.17104791f, -0.07451031f, -0.37498572f, 
    0.03774625f, 0.05095622f, 0.00969786f, 0.32994547f, -0.00864736f, 0.10166154f, -0.06401354f, 0.03481045f, 
    -0.05782633f, -0.06946778f, 0.06376205f, -0.22694081f, 0.02299797f, 0.44253317f, 0.00340174f, -0.11045968f, 
    0.01411531f, 0.21225615f, -0.14177990f, -0.29321548f, -0.08033595f, 0.51301140f, 0.14644665f, -0.12664929f, 
    0.00299485f, -0.29487088f, 0.40547627f, -0.13999183f, -0.14185098f, -0.05890771f, -0.10875211f, -0.30435723f, 
    0.02437282f, -0.09604365f, -0.02260935f, -0.40520310f, 0.01769130f, -0.49451563f, -0.10215813f, 0.17055568f, 
    -0.04380681f, -0.11148904f, 0.08687489f, -0.23810516f, -0.04471368f, -0.37502864f, 0.35423213f, -0.22561093f, 
    -0.04319659f, -0.60527647f, 0.06297349f, -0.10643395f, -0.03026725f, 0.31487486f, -0.17694531f, -0.15916879f, 
    -0.00114548f, -0.07813543f, 0.45828941f, -0.06263236f, -0.06653392f, -0.04011668f, -0.06997935f, -0.03227895f, 
    0.16707943f, 0.11436364f, -0.07008894f, 0.44135907f, -0.12451116f, 0.20472826f, 0.13130550f, -0.14191586f, 
    0.02791414f, 0.00536985f, -0.70773411f, -0.20839246f, -0.02982903f, 0.37381554f, -0.37598121f, 0.12316136f, 
    0.20607105f, -0.66802830f, -0.14228818f, 0.13058379f, -0.08531631f, 0.24029027f, -0.10559274f, 0.14005363f, 
    0.01977628f, -0.44465780f, -0.21386793f, 0.08374797f, -0.15286455f, -0.13619250f, -0.11484631f, -0.14463368f, 
    0.08406965f, -0.00617265f, 0.12385092f, 0.37886450f, -0.15874016f, 0.01439420f, 0.00684957f, 0.08602500f, 
    0.03800016f, 0.14090474f, -0.18372241f, -0.58836460f, 0.11707036f, -0.14161116f, -0.24324152f, -0.22898939f, 
    0.07300040f, 0.51270288f, -0.17323498f, 0.27603322f, 0.03051969f, -0.08401446f, 0.06365459f, -0.02035733f, 
    0.05541912f, -0.51886874f, 0.03914835f, -0.08298899f, 0.06709466f, 0.05764591f, -0.13142437f, -0.02588990f, 
    0.01455137f, 0.04280085f, 0.05569562f, -0.37337795f, 0.11814275f, 0.33800018f, 0.08782790f, -0.01855083f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.15648673f, -0.10659992f, 0.08141869f, 0.06526213f, -0.13441102f, 0.10356244f, 0.02306406f, 0.10527446f, 
    -0.07609686f, -0.10922761f, 0.20324409f, 0.04980190f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
