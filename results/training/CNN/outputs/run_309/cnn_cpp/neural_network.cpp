#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.78147650f, -0.37038165f, 0.33106953f, -0.18667138f, -0.27448446f, 0.54296184f, -0.30517945f, 0.29271016f, 
    0.62730765f, 0.48057750f, -0.18395400f, -0.15193352f, -0.19049774f, -0.12499505f, -0.21227214f, -0.07706378f, 
    -0.00573914f, 0.06391966f, -0.18054463f, -0.11549847f, 0.26446351f, -0.10474263f, -0.12435090f, -0.03995435f, 
    0.01371977f, -0.73990458f, 0.07761106f, 0.04171135f, -0.51877540f, -0.14211158f, 0.17417811f, 0.11537571f, 
    0.16663021f, -0.26434493f, 0.28838688f, 0.10002975f, 0.26410607f, 0.32586482f, 0.18603010f, 0.10633813f, 
    0.19023992f, -0.15190889f, 0.05995915f, 0.23262280f, -0.05652802f, 0.18010397f, -0.04737689f, 0.10439233f, 
    -0.36056206f, -0.01139713f, 0.16149127f, -0.76091027f, -0.17718746f, 0.45328194f, -0.15410089f, 0.52109331f, 
    -0.68358827f, -0.26802871f, -0.46442994f, -0.26567319f, -0.36934820f, -0.38649574f, 0.13242960f, -0.07539193f, 
    0.33218792f, 0.27463061f, 0.13880600f, 0.15462729f, 0.12074823f, 0.12691095f, -0.07971327f, -0.16708200f, 
    0.24218017f, 0.01821093f, -0.18642110f, -0.44049373f, -0.37018874f, 0.47791120f, -0.12913649f, 0.60782450f, 
    -0.15164463f, 0.46863845f, -0.43528607f, -0.35811874f, -0.43831760f, 0.18207212f, -0.07952895f, 0.48477855f, 
    -0.08513165f, -0.00224663f, 0.08794985f, -0.08645971f, -0.12733188f, -0.44763315f, 0.01648135f, -0.35064304f, 
    -0.39296916f, -0.49274522f, -0.05322876f, -0.09885716f, -1.10062146f, 0.79896367f, 0.39149153f, -0.83208227f, 
    -0.32522973f, 0.59914815f, 0.25178695f, -0.09702347f, 0.56619292f, -0.01395917f, 0.02435176f, -0.24122019f, 
    -0.19802591f, 0.14314352f, -0.08688966f, -0.04740352f, 0.03674050f, -0.09875017f, -0.16395485f, -0.06006992f, 
    -0.09784479f, 0.11683997f, 0.30183548f, 0.32086113f, -0.08077258f, -0.41657779f, 0.63929635f, 0.07885760f, 
    -0.58121175f, 0.26767692f, -0.35804173f, -0.58707702f, -0.46222791f, -0.64730489f, -0.51652795f, 0.22238822f, 
    -0.22043356f, 0.22244538f, -0.01710805f, -0.31169400f, -0.40004626f, -0.19243877f, -0.36910614f, -0.16860427f, 
    0.07586302f, -0.17022231f, 0.06180970f, 0.12300546f, 0.13117592f, 0.27767736f, -0.81185639f, 0.33928138f, 
    -0.20014027f, -0.36705959f, -0.66894758f, 0.90898496f, 0.82205206f, 0.14230432f, 0.40639022f, 0.45093471f, 
    -0.08980640f, -0.35932761f, 0.04262767f, -0.17724192f, -0.09865911f, 0.11339318f, 0.12081460f, 0.08542654f, 
    0.11223606f, -0.04292847f, 0.09851100f, -0.32167527f, 0.01327087f, -0.05231215f, 0.08961350f, 0.72070587f, 
    0.10610479f, -0.33006957f, 0.48070222f, -0.52727860f, 0.31690320f, 0.26371282f, 0.29465225f, 0.06811881f, 
    0.14399943f, -0.20673449f, 0.01654609f, 0.03467018f, -0.27394554f, 0.04495863f, -0.48953530f, -0.18876998f, 
    0.06440070f, 0.25037587f, -0.13077864f, 0.33263832f, 0.10085975f, 0.08644584f, 0.09682623f, 0.23691726f, 
    -0.62583297f, -0.48966014f, -0.33550775f, 0.19402885f, -0.48792884f, -0.60461855f, 0.28892437f, 0.35936266f, 
    0.02109139f, 0.10848556f, 0.04968267f, -0.27676499f, 0.11168012f, 0.09190957f, -0.28109553f, 0.08633663f, 
    -0.27152553f, 0.06713235f, 0.06370384f, -0.14214087f, 0.51004440f, 0.35600373f, 0.09202983f, 0.37678206f, 
    0.14343578f, -0.12998714f, 0.42145512f, 0.02105538f, -0.28325865f, 0.21003336f, 0.48027962f, 0.13965295f, 
    0.47741550f, -0.48458731f, -0.54239202f, -0.11817341f, -0.17541440f, 0.14349052f, 0.13720629f, 0.03436469f, 
    -0.11635102f, -0.09995721f, -0.00843961f, 0.03561539f, -0.19074483f, 0.10308848f, 0.32919359f, -0.34894285f, 
    0.27035233f, 0.36719942f, 0.11847185f, 0.86631727f, 0.47399125f, 0.18120024f, 0.62337810f, -0.14483874f, 
    -0.58801663f, -0.55402631f, -0.37397957f, 0.06146820f, 0.14255005f, -0.23294283f, -0.25696862f, 0.23464103f, 
    -0.06533509f, -0.23119941f, -0.15887518f, 0.36432028f, -0.01930711f, 0.19752997f, 0.26960486f, -0.15099753f, 
    0.04729614f, -0.18068345f, -0.11840310f, -1.04338515f, 0.59634149f, 0.11588111f, 0.16984150f, 0.33125991f, 
    -0.19291937f, 0.50453252f, 0.24483037f, 0.40471444f, 0.17426412f, -0.34666231f, -0.31149259f, -0.12478402f, 
    0.08402060f, -0.36270568f, -0.16242880f, -0.05333251f, -0.33459345f, -0.08612595f, -0.26475149f, 0.01214652f, 
    0.05870768f, -0.07362623f, 0.00951467f, 0.08730704f, -0.64716774f, -0.48235896f, 0.46997777f, -0.10383356f, 
    -0.39897221f, 0.21351229f, -0.41790593f, -0.19163278f, -0.22878216f, 0.02301118f, 0.34408429f, 0.28657553f, 
    -0.43980205f, 0.33614260f, -0.26970240f, 0.18811692f, 0.11610676f, 0.02121862f, 0.18841277f, 0.02975069f, 
    0.14024746f, -0.12376639f, 0.13720271f, -0.10497367f, 0.34748134f, -0.58717400f, -0.75279719f, -0.64508092f, 
    -0.25378785f, -0.28042474f, 0.44499600f, 0.45987600f, -0.66849887f, 0.18360022f, 0.08866145f, -0.00712742f, 
    0.08493418f, 0.11202779f, 0.22740009f, 0.17725533f, -0.21989487f, 0.08456840f, -0.27010927f, -0.03536310f, 
    -0.01011388f, -0.05866702f, -0.26684383f, 0.01565319f, 0.04944287f, -0.07153303f, -0.12210505f, 0.92538911f, 
    -0.15784039f, -0.32255530f, 0.21782225f, 0.46732330f, 0.33744219f, -0.67685539f, 0.01536913f, -0.80421638f, 
    -0.19120139f, 0.03358348f, -0.19468057f, 0.19054362f, -0.04496263f, 0.02196737f, -0.28755468f, 0.31599155f, 
    0.24354854f, 0.14633223f, 0.29625651f, -0.40813738f, -0.09590353f, 0.17345619f, 0.27778363f, -0.70443487f, 
    -0.05252308f, 0.61365181f, 0.06198447f, 0.22866265f, -0.05937657f, 0.29332423f, -0.08301082f, 0.18339846f, 
    -0.06127920f, -0.59315652f, 0.08106816f, -0.04126726f, 0.46503618f, -0.32274607f, -0.34467897f, 0.02160823f, 
    -0.04692641f, -0.14211270f, -0.43087462f, -0.04490910f, -0.06658494f, -0.33653769f, 0.07991721f, 0.35178959f, 
    0.52264792f, 0.22515082f, 0.69851232f, 0.77771354f, 0.65823072f, 0.36024511f, 0.10613275f, -0.14186034f, 
    -0.40709278f, 0.09157059f, -0.01740364f, 0.10302736f, 0.14764425f, -0.07581253f, -0.04917980f, 0.05429368f, 
    0.37388319f, 0.37838966f, -0.05759587f, 0.20218481f, 0.24391420f, -0.16700345f, 0.02301612f, -0.05850794f, 
    0.22330622f, -0.36855674f, -0.70245492f, 0.72831303f, -0.22450273f, -0.18768939f, 0.65609998f, 0.47275203f, 
    -0.24041240f, -0.38334477f, -0.58014232f, 0.11160802f, 0.23805730f, -0.17779721f, 0.18215781f, 0.34310299f, 
    0.02844877f, -0.26425725f, -0.19264086f, -0.19708756f, -0.11569435f, 0.22817518f, 0.34977502f, 0.17095815f, 
    0.16261798f, -0.03410853f, 0.81129569f, 0.65395480f, 0.08625950f, 0.75083083f, 0.76096946f, 0.05956136f, 
    0.37217066f, 0.40302438f, 0.09930473f, 0.23610853f, -0.54207563f, -0.38373819f, -0.11942371f, -0.13260876f, 
    -0.13117386f, 0.01179580f, 0.06801076f, 0.08380964f, 0.06794963f, 0.29321146f, -0.16475141f, -0.26496395f, 
    -0.00766113f, -0.10300440f, 0.10328741f, 1.20482683f, 0.55061549f, -0.08570385f, 0.22109646f, 0.21428595f, 
    0.10028630f, 0.07167026f, -0.11785780f, 0.65378541f, 0.01292942f, -0.10881800f, 0.05949216f, -0.16101401f, 
    -0.09346236f, 0.03373521f, 0.35261652f, -0.05650449f, -0.11667275f, -0.06841314f, 0.21848406f, 0.04814165f, 
    0.11375570f, -0.01998450f, -0.12389632f, 0.45908454f, 0.10553852f, -0.81081766f, -0.56748033f, -0.34953982f, 
    -0.07599591f, -0.20325525f, 0.84099519f, 0.45030507f, 0.17577900f, 0.56475264f, 0.28052872f, -0.22057533f, 
    -0.20250888f, -0.20366678f, -0.08853440f, -0.15382691f, 0.01378995f, -0.37951449f, 0.25045183f, -0.19257420f, 
    -0.02400729f, 0.28262562f, -0.01766943f, 0.02127939f, 0.11030506f, 0.70573944f, 0.33954802f, -0.90808076f, 
    -0.43660724f, -0.17845617f, 0.53264117f, -0.10731791f, -0.00310133f, 0.46473306f, -0.36424467f, -0.52674669f, 
    -0.24461159f, -0.06549622f, 0.27684993f, 0.04114620f, 0.13525344f, -0.00570612f, -0.33445641f, 0.16718611f, 
    0.28645477f, 0.06664267f, 0.04204778f, -0.03506011f, -0.03727112f, 0.18329498f, -0.21985571f, -0.29400405f, 
    -0.30405873f, -0.56885570f, 0.19651558f, 0.04246422f, -0.05331260f, -0.33352894f, 0.27367288f, 0.49646646f, 
    0.06420718f, -0.26433870f, -0.05939584f, -0.41417691f, 0.09119000f, -0.39687988f, -0.45315295f, -0.02734536f, 
    -0.30592081f, -0.19968487f, -0.14089508f, -0.25356638f, -0.28086019f, 0.23972909f, -0.19884260f, -0.59304339f, 
    -0.41572750f, -0.56350285f, 0.04975052f, 0.27365929f, -0.65426743f, 0.19943722f, 0.11755219f, 0.36839607f, 
    0.23875867f, 0.46277967f, 0.10950831f, -0.01800452f, -0.03635316f, 0.20280911f, -0.26771179f, 0.12892765f, 
    0.33339292f, -0.18253751f, 0.09470122f, 0.07973510f, 0.30278260f, -0.26135075f, 0.32315353f, -0.20046113f, 
    0.43258190f, -0.53551203f, -0.28904894f, -0.29442474f, -0.34270325f, -0.01717161f, -0.32155129f, -0.25311136f, 
    -0.31071675f, -0.56517959f, 0.46956530f, -0.22197220f, 0.15998013f, 0.19427872f, 0.33628404f, 0.28730607f, 
    0.17020375f, 0.11512224f, -0.12976784f, 0.09320394f, 0.20059168f, -0.21242349f, -0.18659106f, -0.14419368f, 
    0.13190834f, 0.92954087f, 0.42961940f, -0.76964498f, -0.30597210f, -0.71348524f, -0.24051258f, 0.07094821f, 
    -0.12301006f, 0.05267975f, -0.19326247f, 0.10269953f, 0.31809646f, 0.43492332f, 0.14763679f, 0.23607515f, 
    -0.05615461f, -0.20411858f, 0.08448091f, 0.25722417f, -0.05178951f, -0.08426739f, 0.08426855f, 0.12047385f, 
    0.02899691f, -0.15077294f, 0.17997782f, 0.90635240f, 0.40452391f, -0.32299450f, -0.58653235f, -0.55689329f, 
    -0.04693802f, 0.04461796f, -0.60297567f, -0.23385720f, 0.04713641f, 0.33495450f, -0.34723377f, 0.16598523f, 
    0.25713712f, -0.03517953f, -0.12201900f, 0.19085801f, 0.01101944f, -0.25956523f, 0.28202656f, 0.21539292f, 
    -0.28283933f, 0.26587534f, 0.15442632f, -0.46298555f, -0.60568106f, -0.27980584f, 0.66029972f, 0.33106259f, 
    -0.49873379f, 0.74113685f, 0.37704700f, -0.10706336f, -0.60715014f, 0.27319080f, 0.11049710f, -0.19343343f, 
    -0.12546702f, 0.05294514f, -0.39730489f, 0.11263269f, -0.10207742f, 0.10063405f, -0.21428852f, 0.25439155f, 
    0.07849820f, -0.10433813f, 0.20821618f, 0.02453889f, -0.68659663f, -0.48273411f, -0.25291124f, -0.63728154f, 
    -0.27639505f, -0.15876251f, -0.20931245f, -0.07203873f, -0.15878882f, 0.03696520f, -0.18120307f, -0.08828151f, 
    -0.06694175f, 0.30778757f, 0.21480510f, 0.18580985f, -0.15669023f, -0.22907488f, 0.18611017f, -0.31212467f, 
    -0.04932897f, 0.09813794f, -0.11030625f, -0.13866198f, 0.04076827f, 0.53794354f, 0.36320779f, 0.57661110f, 
    0.37640491f, 0.53608155f, 0.42650968f, 0.19679350f, -0.22671758f, -0.14565118f, 0.28373516f, 0.23675658f, 
    0.50696397f, 0.13436973f, 0.38250491f, -0.03434760f, 0.26443347f, -0.19806135f, 0.17846556f, 0.28604671f, 
    -0.33675018f, 0.25523406f, -0.13858673f, 0.00600751f, 0.05417352f, -0.15519951f, 0.60875553f, 0.84522140f, 
    0.48105377f, 0.13845681f, 0.38069022f, -0.09644949f, 0.08389906f, -0.27591372f, 0.40852907f, 0.00270022f, 
    0.18459833f, 0.14016710f, 0.19768396f, 0.17085111f, -0.40155485f, -0.03071423f, -0.03153729f, -0.08463623f, 
    -0.09559876f, -0.52693015f, 0.09000598f, -0.20398021f, 0.11955352f, -0.04386371f, -0.22834750f, -0.79658675f, 
    -0.93730694f, -0.43311471f, 0.50081998f, 0.23145604f, 0.57495940f, 0.40594169f, 0.09578843f, 0.27330106f, 
    0.02466556f, -0.21831407f, 0.37057662f, 0.03180781f, 0.27350229f, 0.24780242f, 0.07040151f, 0.07558352f, 
    -0.00314439f, -0.09163414f, 0.02518044f, 0.04587977f, -0.04376704f, -0.23892774f, 0.05097430f, -0.06183492f, 
    0.84111029f, 0.52380848f, -0.48884764f, 0.78681546f, -0.30873635f, -0.45938146f, 0.08478200f, -0.37406701f, 
    0.12595005f, 0.35325617f, 0.32551298f, 0.15686144f, 0.27858603f, 0.03728282f, -0.26223677f, 0.20734222f, 
    -0.20278987f, 0.34630737f, 0.04753178f, 0.00451462f, 0.34810793f, -0.32278854f, 0.04426504f, -0.12834325f, 
    0.35197759f, -0.05018604f, -0.53777218f, -0.58062869f, -0.73016280f, 0.04663466f, 0.31743681f, -0.25238511f, 
    -0.18067920f, 0.25620714f, -0.08775327f, -0.33900660f, -0.35336420f, -0.00687967f, -0.31511989f, -0.54939240f, 
    0.10012726f, -0.14122783f, 0.05227108f, 0.01300562f, -0.26253930f, -0.05516133f, -0.04647738f, -0.21026465f, 
    0.49858928f, 0.32938328f, 0.69516182f, 0.20879234f, 0.58986235f, 0.25683483f, -0.13456075f, -0.01789341f, 
    0.18392305f, -0.59741563f, -0.05995718f, -0.20328408f, 0.22363578f, 0.04002619f, -0.18983701f, 0.18494967f, 
    -0.01263944f, -0.11983455f, -0.20777617f, 0.06950571f, 0.01466172f, 0.08451083f, 0.12726124f, 0.12677886f, 
    0.14502183f, -0.02535388f, 0.42685616f, 0.04714568f, -0.50354248f, -0.67336035f, -0.70657980f, -0.00784006f, 
    -0.10685578f, 0.60539305f, 0.12051114f, 0.00230661f, 0.11120097f, -0.14053960f, -0.31436452f, -0.09406275f, 
    0.05853406f, -0.26345590f, -0.15225025f, 0.45360669f, -0.12256012f, 0.09055968f, 0.09224967f, -0.15129958f, 
    -0.16644761f, -0.14237738f, -0.18197459f, -0.26666886f, -0.06225906f, 0.14382115f, -0.41493595f, -0.74437457f, 
    0.04990984f, 0.38825291f, 0.39170879f, -0.11623336f, 0.47189689f, 0.15542249f, -0.36866671f, 0.21027732f, 
    -0.47071624f, -0.30026951f, -0.27535406f, -0.02182225f, -0.11677103f, -0.04783311f, 0.46715719f, -0.20189865f, 
    -0.19481809f, 0.04727788f, -0.22182225f, -0.01589554f, 0.08520291f, 0.89027065f, 0.26387352f, -0.15480331f, 
    -0.53533411f, -0.20073472f, -0.22912849f, 0.38364425f, 0.16949145f, 0.22155233f, 0.63291562f, -0.02221938f, 
    -0.16684337f, 0.05692204f, -0.43630666f, 0.19914295f, -0.11424641f, 0.28762856f, -0.09783206f, 0.00096489f, 
    0.10387733f, 0.20279700f, -0.38431403f, 0.21722293f, -0.23180744f, -0.20937729f, -0.12218659f, -0.13564017f, 
    -0.00383474f, 0.38392752f, -0.01616476f, -0.05183737f, 0.79778773f, 0.26788163f, -0.65009165f, 0.38756305f, 
    0.41789204f, -0.23317955f, 0.08425017f, -0.39290318f, -0.27771917f, -0.33078176f, -0.33611974f, -0.22976542f, 
    -0.13472685f, -0.49241054f, -0.24394289f, 0.05240903f, 0.07645752f, -0.01410041f, -0.04283810f, 0.01013423f, 
    0.72742283f, 0.58168185f, -0.50251085f, 0.36777636f, -0.45022160f, 0.50742775f, 0.35125524f, -0.08133353f, 
    0.29911304f, -0.47547945f, -0.00886399f, -0.07459479f, 0.11224515f, -0.06177269f, -0.12157729f, 0.01561747f, 
    0.06500891f, -0.10542522f, -0.07238846f, -0.08309696f, -0.18067774f, -0.00214134f, 0.06008644f, 0.18100393f, 
    0.35150883f, 0.27609542f, -0.09174161f, -0.13709982f, -0.69636285f, 0.03803932f, -0.17671263f, 0.20284885f, 
    -0.04900000f, 0.37091535f, 0.33603746f, -0.35289520f, -0.19439942f, 0.18732014f, 0.20784663f, 0.35262161f, 
    -0.02040525f, -0.50230807f, 0.02518562f, 0.22059017f, -0.32844898f, 0.35636929f, -0.18531063f, 0.39160699f, 
    -0.30695456f, -0.65148532f, -0.71021491f, -0.13993637f, 0.35989267f, 0.27864191f, 0.27814326f, 0.47698429f, 
    0.66091460f, -0.03239221f, -0.04817994f, 0.10458983f, 0.00395745f, -0.28410330f, -0.06477188f, 0.20957740f, 
    0.03745502f, 0.19771113f, 0.11559468f, -0.28455064f, 0.23511626f, -0.36583903f, 0.00557757f, 0.00892834f, 
    0.02410403f, 0.10027519f, -0.43204862f, -0.53704596f, -0.35507566f, 0.35140347f, 0.40171877f, -0.84890062f, 
    0.26901886f, 0.78662533f, -0.60827374f, 0.19851571f, 0.23935449f, 0.18108404f, -0.15247956f, -0.29353574f, 
    0.09260982f, 0.26554608f, 0.04849146f, 0.02606587f, 0.13009639f, 0.02805848f, -0.14912453f, -0.36283299f, 
    -0.01760887f, -0.15457256f, -0.16324735f, -0.41453823f, 0.40015060f, 0.90969753f, -0.67070550f, -0.61517459f, 
    0.58056551f, -0.33251545f, 0.02597179f, 0.32647222f, -0.09410369f, 0.25969410f, 0.19298156f, 0.18007277f, 
    0.12836474f, -0.08244422f, -0.23037037f, -0.16418196f, -0.08261303f, -0.17031007f, -0.07388116f, 0.18061537f, 
    0.27638051f, 0.07360148f, 0.07449091f, -0.05893609f, 0.45886528f, 0.26629195f, 0.21832812f, 0.11042123f, 
    0.19496845f, 0.45643201f, -0.71403599f, -0.63573301f, -0.60531586f, -0.58911079f, 0.31762347f, 0.18133873f, 
    0.18197283f, 0.05802872f, -0.47022143f, -0.00893446f, -0.27199006f, -0.05953032f, -0.14808156f, 0.34459126f, 
    -0.28555810f, 0.09015032f, 0.25349534f, -0.06740068f, -0.05348773f, -0.63296497f, 0.29435378f, -0.38673946f, 
    -0.31384936f, -0.54091036f, 0.26892588f, 0.79731965f, -0.23023599f, 0.00084131f, 0.11480723f, 0.16830653f, 
    -0.01300749f, -0.05002371f, 0.00772220f, 0.42223853f, -0.10402970f, -0.31125042f, -0.02097641f, 0.14221743f, 
    -0.10271364f, -0.02291182f, -0.08193810f, 0.34837046f, 0.18912415f, 0.17308624f, 0.75910705f, -0.00178869f, 
    0.48501548f, 0.80419260f, 0.33759147f, -0.31966665f, -0.61451989f, 0.13611038f, -0.21463770f, -0.30600753f, 
    -0.10705644f, -0.28362796f, 0.06138952f, 0.26809099f, 0.35336998f, 0.00487879f, -0.20374745f, 0.11063499f, 
    0.08455365f, 0.34920812f, -0.27356902f, -0.03117434f, -0.24031267f, -0.03652428f, 0.12959917f, 0.50727469f, 
    0.27503106f, -0.17672716f, -0.64291716f, -0.17899062f, -0.38756526f, -0.06935713f, -0.46268427f, -0.25913420f, 
    -0.22419074f, -0.03085581f, -0.28640589f, -0.05623136f, 0.11739399f, 0.05099764f, -0.05330263f, 0.10936170f, 
    -0.25927934f, 0.03061210f, 0.28359759f, 0.35647613f, 0.01782216f, -0.04304071f, 0.01269219f, -0.03201938f, 
    0.40462625f, 0.79170084f, -0.63249546f, 0.51682949f, -0.29284209f, 0.17044646f, -0.34454772f, 0.06171149f, 
    -0.20366730f, -0.28110963f, 0.13964017f, 0.10606399f, -0.12653373f, 0.17100838f, 0.13862231f, 0.09438324f, 
    -0.11160414f, -0.04461978f, -0.16755365f, -0.01352904f, 0.18928748f, 0.03743921f, -0.17849214f, 0.16262172f, 
    -0.30685297f, 0.43272004f, -0.02785139f, 0.56374574f, 0.59170538f, 0.01218590f, -0.46747586f, 0.47125474f, 
    -0.31383434f, 0.10373177f, 0.50345987f, 0.15682992f, 0.34958228f, 0.01387507f, -0.27504733f, -0.00279567f, 
    -0.19427420f, -0.03803356f, -0.36214849f, 0.19798608f, 0.18896846f, -0.27633670f, 0.09847030f, 0.20692337f, 
    0.22876805f, -0.03296831f, -0.19214593f, 0.25019825f, -0.08701604f, -0.27150676f, 0.49547690f, -0.58196616f, 
    0.17491925f, -0.56526679f, -0.20813923f, 0.07791048f, 0.19439715f, 0.43902406f, -0.02704354f, -0.06414500f, 
    0.34508705f, -0.25534308f, 0.37422004f, 0.08349061f, -0.12809369f, 0.26081878f, -0.07154016f, -0.37812185f, 
    0.23670433f, -0.22826657f, 0.05113057f, 0.93726850f, 0.40682927f, 0.64219832f, -0.02258596f, -0.16837515f, 
    0.42837435f, -0.79638219f, 0.13641879f, 0.18704854f, 0.06573525f, 0.29970697f, 0.34415862f, -0.18224318f, 
    0.03148157f, -0.05657493f, 0.30830124f, 0.07684483f, -0.00492896f, -0.27189624f, 0.34210819f, -0.21987189f, 
    0.26605618f, 0.22413400f, 0.14725897f, 0.03860171f, 0.25664461f, -1.18159747f, -0.47922704f, 0.01592820f, 
    0.21323867f, -0.17305532f, 0.32833225f, 0.29468796f, -0.37631667f, 0.17947876f, 0.08200745f, 0.33935696f, 
    -0.34257653f, 0.21190050f, 0.28745961f, -0.11439064f, -0.20239978f, 0.16440324f, 0.04436696f, -0.01667506f, 
    -0.05682841f, -0.15590005f, 0.12065279f, -0.00392919f, 0.09176952f, -0.50358415f, -0.85183281f, 0.06341773f, 
    0.12097751f, 0.01318235f, 0.39194500f, -0.03919042f, 0.51470357f, 0.16205773f, -0.59068930f, -0.25151104f, 
    -0.28067973f, -0.22280465f, 0.05332790f, -0.18485507f, 0.26617107f, 0.17999095f, -0.13075466f, -0.12233436f, 
    -0.02020082f, 0.01201746f, 0.11030417f, 0.15093781f, 0.08251529f, 0.20939839f, 0.68776739f, 0.37684715f, 
    -0.72652882f, -0.52986640f, -0.51932013f, -0.40048060f, -0.25242636f, -0.00537726f, 0.02649063f, 0.01851750f, 
    -0.34507170f, 0.05372757f, -0.18827088f, -0.28124398f, -0.18415086f, -0.19740663f, 0.08042131f, -0.07532642f, 
    -0.29673505f, -0.24308780f, 0.05419831f, 0.09327290f, 0.06134257f, -0.04635105f, 0.03992743f, 0.03483050f, 
    -0.15316154f, 0.29558042f, -0.02682346f, 0.59284961f, -0.67531407f, -0.60640860f, 0.18442276f, -0.24808259f, 
    -0.44933239f, 0.27136219f, 0.02440711f, 0.29048866f, -0.19243562f, -0.13856073f, 0.26566020f, -0.00704059f, 
    -0.32368088f, -0.10977590f, 0.16136949f, -0.22833344f, -0.08253924f, -0.01868372f, -0.07918029f, -0.02274425f, 
    0.05302478f, -0.32094151f, 0.32148474f, 0.00434318f, 0.72412628f, -0.47514328f, -0.38629267f, -0.36115181f, 
    -0.62018776f, -0.19396436f, 0.27792305f, 0.49017078f, -0.07706853f, 0.39267248f, 0.13670135f, 0.38119456f, 
    0.21294010f, -0.23011415f, 0.24314491f, -0.13658106f, 0.31803131f, -0.04071170f, -0.38062847f, -0.02994216f, 
    0.15911306f, -0.30867466f, 0.59851784f, 0.73143703f, 0.55312276f, -0.68710971f, -0.48091641f, 0.14165497f, 
    -0.01709567f, 0.05845670f, -0.04271937f, -0.11255868f, -0.00058930f, 0.22475506f, -0.08759681f, 0.40765217f, 
    0.14142804f, -0.49271122f, 0.01292423f, -0.10050058f, -0.16197512f, -0.10180914f, 0.44259778f, -0.19066319f, 
    0.21012528f, -0.06945027f, 0.49888891f, -0.27185354f, -0.64857954f, 0.97933799f, 0.84343892f, 0.60890406f, 
    0.53735340f, 0.10709138f, 0.55353719f, 0.38810953f, -0.17241770f, -0.20661829f, -0.37290174f, 0.05376648f, 
    -0.23440406f, -0.05744701f, -0.42971906f, -0.05067952f, -0.34143412f, -0.17399652f, 0.03602253f, 0.00057008f, 
    0.07570633f, -0.07990743f, -0.24592911f, -0.29296285f, 0.98819143f, 0.70869750f, -0.28337994f, 0.09855477f, 
    -0.69918782f, 0.45147848f, 0.06701518f, -0.18504919f, -0.24978670f, -0.16916469f, 0.17688981f, -0.26330152f, 
    0.04956061f, 0.25960115f, -0.00147505f, -0.00721368f, 0.03323185f, -0.10678568f, 0.11114301f, 0.03771190f, 
    0.05846073f, 0.14637752f, 0.20692430f, 0.03064633f, 0.08456805f, -0.03850494f, -0.34724444f, -0.86327398f, 
    -0.65691555f, 0.27059501f, -0.50745189f, 0.04662181f, 0.28544524f, -0.35396260f, 0.20911670f, 0.16707411f, 
    -0.19281551f, 0.23939508f, -0.12139120f, 0.19437803f, 0.26348394f, 0.29825768f, 0.13208093f, 0.37631744f, 
    0.03833411f, -0.18953930f, 0.38872305f, -0.18121187f, -0.05801426f, 0.67266053f, 0.49411708f, 0.57856870f, 
    0.55137932f, -0.06810634f, -0.35516942f, 0.66268528f, -0.30477363f, -0.38289079f, 0.40144455f, -0.31897515f, 
    0.22749290f, -0.21823576f, 0.20350124f, -0.19788556f, 0.03335787f, -0.12611428f, -0.14044294f, 0.06022815f, 
    0.10240579f, 0.09801593f, 0.28871295f, 0.22153395f, 0.09004892f, 0.34879372f, 0.38283202f, -0.22197728f, 
    -0.54508728f, -0.57336664f, -0.41864777f, 0.06684306f, 0.03974095f, 0.49366012f, 0.52441645f, -0.01840653f, 
    0.07267693f, -0.04318351f, -0.10550797f, -0.11138195f, -0.03940355f, 0.23771654f, -0.23663589f, 0.20950800f, 
    -0.07714705f, 0.32476041f, 0.24540417f, 0.06181153f, -0.14916670f, 0.06062587f, -0.48007339f, -0.16284968f, 
    0.14745454f, 0.22484079f, -0.72924060f, -0.51422435f, 0.19657883f, -0.47820425f, -0.55418825f, -0.43542278f, 
    -0.22260393f, 0.09596441f, 0.09591354f, 0.23617786f, -0.08002263f, 0.22526656f, -0.03860611f, 0.05214249f, 
    0.18527620f, -0.02932955f, -0.19578491f, 0.11664978f, 0.16055577f, -0.09805626f, 0.35745564f, 0.22219892f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.00131116f, 0.19458444f, 0.07985542f, 0.18621054f, 0.01700516f, 0.18565015f, -0.04775958f, -0.06330749f, 
    -0.05235106f, 0.03615185f, -0.09122916f, 0.10036582f, 0.10382351f, -0.09120812f, -0.07735126f, -0.01912188f, 
    0.02358280f, 0.15155277f, 0.08807540f, 0.20068733f, -0.11006912f, -0.04286672f, 0.00081115f, 0.03482150f, 
    -0.10331322f, -0.11551879f, -0.01283373f, -0.00526865f, -0.17358311f, -0.07284344f, 0.13794412f, 0.11663543f, 
    0.03852459f, 0.08565453f, -0.02745202f, 0.02743762f, -0.20524815f, -0.05707882f, 0.06793817f, 0.11031626f, 
    0.00038256f, 0.05947394f, -0.08617774f, 0.12048327f, 0.10536421f, 0.13367820f, -0.14216967f, 0.21805394f, 
    0.05870507f, 0.17372508f, 0.00316285f, 0.14092334f, 0.20699713f, -0.09296416f, -0.01686989f, -0.05492081f, 
    -0.12388961f, -0.04419883f, 0.05941910f, 0.03507302f, 0.17784549f, 0.03365828f, 0.15129171f, 0.19457434f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.27470264f, -0.04265606f, -0.08544417f, 0.06190979f, 0.08654059f, -0.00256810f, 0.05059265f, -0.06082157f, 
    -0.15444380f, 0.02765630f, 0.00291278f, 0.12394749f, -0.02265423f, -0.06990699f, 0.01356537f, -0.09125825f, 
    -0.00380538f, -0.02731790f, -0.03468818f, -0.01037599f, 0.10796507f, -0.07912046f, 0.00443832f, -0.05231918f, 
    0.06732958f, -0.12647018f, 0.04673348f, 0.28060907f, 0.03145207f, 0.03609551f, -0.17187749f, -0.01825169f, 
    -0.08820435f, 0.00982389f, -0.02776898f, 0.04852132f, -0.09185443f, -0.16183555f, 0.09884366f, 0.01390714f, 
    -0.01815568f, -0.01735011f, 0.07858729f, -0.01066626f, 0.04388841f, 0.01205319f, 0.05605666f, -0.11126792f, 
    0.30544522f, -0.10546534f, 0.07633036f, -0.13530529f, -0.04882272f, 0.16292985f, 0.04023394f, 0.05903175f, 
    -0.01363449f, -0.04499187f, -0.00806030f, -0.05466031f, -0.18100502f, -0.01124779f, 0.14101954f, -0.05472869f, 
    -0.00743662f, -0.00770811f, -0.03300897f, 0.06557731f, 0.04731492f, -0.10776037f, -0.01443417f, 0.00639376f, 
    0.53172773f, 0.18719120f, 0.08618041f, -0.20221291f, 0.10195632f, 0.02879003f, -0.07342006f, -0.00732153f, 
    0.02118332f, 0.02904603f, -0.00954271f, 0.03526877f, -0.01526518f, -0.03334663f, -0.19933178f, 0.01374527f, 
    -0.05348712f, -0.12800746f, -0.03309789f, -0.04389436f, -0.02431797f, 0.04356214f, -0.05409476f, 0.04960515f, 
    -0.08561087f, 0.20415394f, -0.14903003f, -0.03419256f, -0.10610770f, 0.00376227f, -0.01069942f, 0.10982119f, 
    0.01781436f, 0.00100078f, 0.01374577f, 0.03198905f, -0.13950516f, -0.00001753f, 0.02255783f, -0.14776292f, 
    -0.15033107f, -0.05471781f, 0.02432070f, -0.04335497f, 0.03517472f, -0.01911058f, -0.06486353f, -0.03404303f, 
    0.13492958f, 0.12945303f, 0.19379702f, -0.13272551f, -0.15259668f, -0.08729700f, 0.02842260f, -0.01613610f, 
    0.09328126f, -0.13383855f, -0.06029520f, -0.09242169f, 0.14263071f, 0.17046125f, 0.09535513f, 0.07727320f, 
    0.04897291f, 0.04697219f, 0.01843231f, -0.04125874f, -0.05638241f, 0.00101858f, -0.00930721f, -0.06015980f, 
    -0.52884877f, -0.06543111f, -0.03297792f, 0.07793903f, -0.03140141f, 0.01681482f, -0.00281726f, 0.10061157f, 
    0.04780217f, 0.09626842f, -0.04282124f, -0.06013057f, 0.06583619f, -0.09276535f, -0.00305242f, -0.25598481f, 
    -0.06585190f, 0.00991949f, -0.04288181f, -0.01059114f, 0.07528023f, -0.03032038f, -0.00195667f, 0.02924320f, 
    -0.23148438f, 0.09449217f, 0.11920305f, -0.15598220f, -0.19655061f, -0.03981566f, 0.09175315f, 0.11078494f, 
    0.03862166f, -0.07273913f, 0.00550278f, 0.07932372f, -0.15481730f, 0.04198647f, 0.03124760f, 0.17221238f, 
    0.02664186f, 0.01666157f, 0.11229417f, -0.00430585f, -0.04638677f, 0.01223477f, -0.09323123f, 0.04849993f, 
    0.05693024f, -0.03583085f, -0.10563053f, 0.16227046f, -0.13527858f, -0.09681383f, 0.04051404f, 0.04431815f, 
    -0.00303225f, -0.01058627f, -0.12719147f, 0.07643258f, -0.35931343f, -0.02170305f, 0.23437677f, 0.09507629f, 
    -0.05764355f, 0.05420345f, -0.01811017f, -0.07480049f, -0.01769334f, 0.10270116f, 0.20326230f, 0.03550721f, 
    0.07824504f, -0.03488494f, 0.03276429f, 0.23112440f, -0.15579362f, 0.04506025f, 0.02760718f, 0.11327854f, 
    -0.01933591f, 0.01826364f, 0.03310957f, -0.04737869f, 0.11756943f, -0.06151487f, -0.03394841f, -0.12130405f, 
    -0.04541157f, -0.09800535f, 0.00131247f, 0.15609062f, 0.08166225f, -0.03276191f, 0.07466687f, -0.05674544f, 
    -0.10035231f, 0.22658083f, 0.02506448f, -0.15852898f, 0.13400395f, -0.03458684f, 0.09901726f, -0.12095104f, 
    -0.05591532f, 0.06510165f, -0.08817323f, -0.01586588f, 0.10916010f, -0.12549126f, 0.01045818f, -0.23250565f, 
    -0.00105400f, -0.08505121f, 0.08457518f, 0.07738082f, 0.05336805f, -0.00935051f, 0.01299589f, 0.12787724f, 
    0.08315879f, -0.04641777f, 0.01072098f, -0.13412391f, 0.03926266f, 0.04711804f, 0.07695922f, 0.05603164f, 
    -0.06030715f, -0.10854609f, -0.01448709f, -0.06002047f, -0.25609645f, 0.13366714f, -0.22114995f, 0.14424692f, 
    -0.04702542f, -0.05811780f, -0.01021991f, 0.06749246f, -0.03925667f, -0.06658641f, -0.11098608f, 0.04932007f, 
    -0.26337746f, -0.16050909f, 0.11047605f, 0.04607821f, -0.11442295f, -0.05242282f, 0.00755568f, -0.09781957f, 
    -0.00155707f, -0.05172686f, -0.03376204f, 0.05261383f, -0.38765013f, -0.00968261f, 0.12282141f, -0.25445431f, 
    0.01330353f, -0.04815237f, -0.01689155f, 0.07861040f, -0.04584114f, -0.07312995f, 0.04762663f, 0.06538960f, 
    -0.33183816f, 0.28768957f, 0.09116537f, 0.00087023f, -0.01063305f, 0.07242949f, 0.02235938f, -0.06812197f, 
    -0.15736356f, -0.04979626f, -0.10562916f, -0.00993920f, -0.26524356f, 0.31373245f, -0.08193313f, 0.06430116f, 
    0.02468901f, -0.01454985f, 0.01371800f, 0.05988257f, 0.03142729f, -0.07500996f, -0.08757019f, 0.01582932f, 
    -0.09392335f, -0.16802302f, -0.03296569f, -0.03939539f, -0.03139793f, -0.00982732f, -0.04762341f, 0.00128030f, 
    0.10370304f, 0.07208716f, -0.11282080f, -0.01393998f, 0.03066136f, -0.07343641f, -0.01469656f, -0.03392988f, 
    -0.09252483f, 0.00799621f, 0.01391779f, 0.00520531f, 0.05361363f, 0.04262290f, 0.02611485f, -0.12875971f, 
    -0.01225040f, 0.08368869f, -0.02981014f, -0.19152783f, -0.13362589f, -0.11776301f, 0.01542825f, 0.00316239f, 
    0.01785005f, -0.01313723f, 0.12952755f, -0.09822971f, -0.12374114f, 0.06275599f, -0.03852646f, -0.00315031f, 
    0.10469248f, -0.02375428f, -0.02640382f, -0.03167436f, 0.06513195f, -0.06507675f, 0.05457674f, -0.06173248f, 
    -0.03595659f, -0.01442455f, 0.02844094f, 0.17242484f, -0.09689630f, -0.03108922f, -0.07028525f, 0.05301085f, 
    0.03060902f, 0.02461620f, 0.06303388f, -0.06942632f, 0.04683471f, -0.09122910f, 0.03545907f, -0.16385747f, 
    0.11442491f, 0.00688882f, 0.10862649f, 0.05725954f, -0.05275001f, -0.00232422f, 0.01055562f, 0.05759340f, 
    0.10331558f, -0.00419923f, 0.00182330f, 0.10229586f, -0.25790757f, -0.02272329f, 0.01157155f, 0.00763191f, 
    0.02635570f, -0.02535839f, -0.15852940f, 0.04103917f, -0.18535717f, 0.12685294f, 0.06533255f, -0.38089612f, 
    -0.03405526f, 0.17194001f, -0.01751711f, 0.06391943f, -0.02713756f, 0.00478115f, 0.02242338f, -0.02463468f, 
    0.13851903f, 0.07144836f, 0.09033325f, -0.27820209f, 0.01888289f, 0.05544521f, 0.02844295f, -0.06052801f, 
    -0.04563616f, 0.06963865f, -0.01306444f, 0.02343056f, -0.15194587f, 0.05195758f, 0.03498392f, -0.30111101f, 
    0.04815435f, -0.10843191f, -0.02500027f, 0.03663526f, -0.00296664f, 0.04504528f, 0.00705670f, 0.08828203f, 
    -0.08931271f, 0.19203283f, 0.13899231f, -0.08073683f, -0.07337720f, -0.02355391f, -0.06107157f, 0.00227984f, 
    0.02370995f, 0.08122388f, -0.02677044f, 0.08997509f, -0.09645260f, -0.00900436f, 0.01994280f, -0.12507248f, 
    -0.01936068f, -0.05406614f, -0.00491054f, 0.01990422f, 0.08278929f, -0.11083295f, 0.00757448f, -0.08133087f, 
    0.01092136f, -0.09797699f, -0.13776492f, -0.15974502f, -0.11441968f, 0.08583712f, 0.02203169f, -0.02579252f, 
    -0.11009188f, -0.00119276f, 0.04272419f, -0.04707412f, -0.18558866f, 0.17908910f, -0.03298561f, -0.06501025f, 
    0.06018447f, 0.07176263f, -0.09307934f, 0.09401523f, -0.06416570f, 0.03448948f, 0.02880393f, -0.06322800f, 
    -0.30908498f, 0.11182181f, -0.00712422f, 0.11350992f, -0.04679186f, 0.10095617f, -0.06943178f, -0.01501049f, 
    0.11979076f, -0.02895903f, 0.05480693f, 0.02195550f, -0.11780548f, 0.01919996f, 0.10098870f, 0.15421596f, 
    -0.12798485f, 0.05265624f, -0.02699105f, -0.23661441f, -0.02457958f, -0.03283420f, 0.09099913f, -0.03187712f, 
    0.07068086f, -0.02407040f, 0.08776579f, -0.07153905f, -0.10039340f, -0.08316775f, -0.07546038f, 0.11030585f, 
    0.03397422f, -0.03605025f, -0.07280090f, 0.05196108f, 0.36898839f, 0.00686313f, 0.08228007f, -0.24602814f, 
    0.01221844f, 0.08932327f, -0.00504126f, 0.02664014f, 0.10584882f, -0.08310096f, -0.05142267f, 0.00956150f, 
    0.26196951f, -0.00333085f, -0.16583113f, 0.17573638f, -0.04827478f, -0.06484020f, -0.02272078f, 0.07682978f, 
    -0.05737508f, -0.06277819f, -0.00542307f, 0.00185707f, -0.15351707f, 0.14068966f, 0.02779699f, -0.20874321f, 
    -0.04879587f, 0.07896509f, 0.05500678f, 0.01520823f, 0.01774393f, -0.08470655f, 0.03589215f, 0.01409566f, 
    0.28710872f, 0.20488316f, 0.05678842f, -0.18858257f, -0.18027078f, 0.04155412f, 0.01338311f, -0.00155834f, 
    -0.07666089f, -0.02242001f, -0.03069884f, -0.08556487f, 0.23436712f, -0.03262590f, -0.08139157f, 0.22693934f, 
    -0.02566553f, -0.10832823f, -0.07479090f, 0.05416979f, -0.08710724f, -0.00705727f, -0.00934828f, 0.02112846f, 
    -0.11328637f, -0.12752883f, 0.06634269f, -0.03311180f, 0.01498609f, -0.00779526f, 0.02851627f, -0.05599383f, 
    0.04059065f, 0.05141978f, -0.00694946f, 0.01473480f, 0.26032656f, -0.22966175f, 0.00498550f, -0.10091115f, 
    -0.13753816f, -0.06868519f, -0.10056794f, 0.03601314f, 0.04633734f, -0.01009669f, -0.10671722f, 0.08301434f, 
    -0.06775900f, -0.06791276f, -0.01814420f, -0.05598621f, -0.07859482f, -0.02243011f, -0.12799744f, -0.04973598f, 
    -0.05806793f, 0.02423653f, -0.05071186f, -0.05897122f, -0.11946309f, 0.07676020f, -0.02347812f, 0.09278946f, 
    0.11477668f, 0.08657699f, 0.00950707f, 0.01389938f, 0.04647741f, 0.01139992f, 0.02370430f, -0.08025536f, 
    -0.13007240f, -0.06887054f, 0.00864679f, -0.16078991f, -0.03778357f, -0.14631337f, -0.08433809f, 0.02562730f, 
    -0.03424478f, 0.00087676f, 0.03698736f, 0.03458723f, 0.01597115f, 0.02288331f, -0.01254705f, -0.01645456f, 
    -0.02112433f, 0.05528614f, -0.14069073f, 0.05205528f, 0.07465037f, -0.06500408f, 0.12979180f, -0.12409139f, 
    -0.02002715f, -0.05672230f, 0.04268729f, 0.05471333f, -0.12226711f, 0.06051205f, -0.01049345f, -0.05709035f, 
    0.05838397f, 0.13122530f, 0.09137554f, -0.02345294f, -0.14370468f, 0.22529727f, -0.12805499f, 0.26228389f, 
    -0.02113813f, 0.11561463f, -0.02061056f, -0.04374769f, -0.02440760f, 0.11812937f, 0.00881835f, -0.08808810f, 
    -0.01691731f, 0.20481835f, 0.15835015f, 0.34932157f, -0.10252633f, 0.11900540f, -0.13537072f, -0.05886336f, 
    -0.13531582f, -0.01043637f, 0.05159937f, -0.10933134f, -0.10687034f, 0.15689889f, -0.04668706f, -0.04045106f, 
    0.13686869f, -0.02159596f, -0.00295795f, -0.09428230f, -0.11960342f, -0.09994172f, 0.01028148f, -0.07392541f, 
    -0.02723250f, -0.00262940f, -0.12646377f, -0.15243793f, -0.00234132f, -0.02768591f, 0.10607285f, -0.00772567f, 
    -0.12875974f, -0.01550298f, -0.01487496f, -0.08314410f, 0.10240360f, 0.09825481f, -0.02150908f, 0.17066646f, 
    -0.08883903f, -0.03030816f, -0.10570316f, 0.04696528f, -0.08488142f, 0.06724290f, -0.01023640f, 0.09720837f, 
    0.01834797f, 0.02769641f, -0.12736650f, -0.26033407f, 0.00038241f, 0.06761212f, 0.00929591f, -0.05864043f, 
    -0.02586605f, -0.00796586f, -0.01219002f, 0.08804502f, -0.40758887f, 0.15449944f, 0.04129676f, -0.09945006f, 
    -0.04625320f, 0.04601403f, 0.09365704f, -0.02857854f, -0.06560701f, 0.02018292f, -0.02894178f, -0.05102069f, 
    0.19814569f, 0.01525100f, 0.05772230f, -0.09002916f, 0.04394203f, 0.05422594f, -0.04088748f, -0.01884403f, 
    0.11677635f, -0.01847196f, 0.06944636f, -0.11380167f, -0.03763169f, 0.06262767f, -0.06740866f, -0.03608706f, 
    -0.02382330f, -0.03714879f, 0.04271196f, 0.05502647f, 0.00936692f, 0.09922091f, -0.05239866f, -0.02597309f, 
    -0.21443427f, 0.09753574f, -0.01558854f, 0.04296427f, -0.02203586f, 0.09227660f, 0.15678017f, -0.04065184f, 
    0.02535771f, -0.03130532f, -0.00765482f, 0.05275629f, -0.16770884f, -0.05016545f, -0.01919196f, -0.14000075f, 
    0.00853390f, 0.07518715f, -0.08432464f, -0.10841830f, -0.03446835f, -0.11858754f, -0.02244897f, -0.06151133f, 
    -0.67881995f, -0.05135859f, -0.13062243f, -0.15504867f, 0.00960173f, -0.05427147f, 0.00082671f, -0.15022512f, 
    0.00311359f, 0.02505495f, -0.01649653f, -0.04183342f, -0.00843125f, -0.06891887f, -0.14523889f, -0.29435387f, 
    0.06928992f, 0.03796213f, 0.08577076f, -0.02205616f, -0.04888422f, 0.10261568f, -0.01327540f, -0.06631659f, 
    -0.40732980f, -0.14582971f, -0.04375207f, -0.07071260f, 0.09157962f, -0.04544829f, 0.08729386f, -0.05120949f, 
    0.11194362f, 0.06079951f, -0.02233427f, -0.00762252f, 0.21992074f, -0.06598026f, 0.05014419f, 0.12899695f, 
    -0.07419323f, 0.05005508f, -0.10106692f, 0.00481665f, -0.03433892f, -0.10534163f, -0.04878793f, 0.06385196f, 
    0.09642978f, -0.07500994f, -0.18920037f, 0.07723770f, 0.04986588f, -0.03009523f, -0.05619017f, 0.02254734f, 
    0.09733936f, 0.00655500f, -0.08721258f, 0.13796656f, 0.20175536f, 0.02216479f, -0.14390224f, -0.02172516f, 
    -0.10825222f, -0.00118742f, -0.06366773f, -0.01797920f, -0.06732787f, 0.04535945f, 0.04161923f, 0.02513083f, 
    0.10282934f, -0.11046194f, -0.09323773f, 0.02759683f, 0.00340546f, -0.03444430f, 0.03024191f, -0.00500838f, 
    -0.13038315f, -0.01239141f, 0.00354324f, 0.05618438f, -0.17092770f, 0.02180755f, -0.07509279f, 0.04539603f, 
    0.03996203f, 0.12824558f, 0.01731105f, 0.08766971f, 0.04792041f, 0.04798340f, 0.00509502f, -0.14667629f, 
    -0.07320168f, 0.21330102f, -0.18297124f, 0.05175514f, -0.00493499f, 0.00946894f, -0.01898655f, 0.11120652f, 
    -0.07670859f, 0.00799656f, -0.00311192f, 0.14125869f, 0.06190802f, -0.02085588f, -0.01371282f, 0.02347972f, 
    0.07410992f, -0.04126752f, -0.04581510f, -0.00119240f, -0.15973437f, -0.00571954f, -0.04673146f, -0.00395590f, 
    -0.04680888f, -0.02622275f, -0.07215919f, -0.10850789f, -0.07929794f, 0.06853656f, -0.04996107f, 0.01910560f, 
    -0.07331159f, 0.02284406f, -0.04124763f, -0.00358148f, -0.08632246f, 0.04545978f, -0.06343751f, 0.08005738f, 
    -0.07343093f, 0.00011988f, -0.01196689f, 0.13267489f, -0.05781115f, -0.12430581f, -0.03768243f, -0.22288078f, 
    0.20578869f, 0.07661580f, 0.16811654f, 0.19860770f, -0.06503815f, 0.05915404f, -0.03416262f, -0.00907684f, 
    -0.01318404f, -0.00759479f, 0.09727928f, 0.00407568f, -0.14299966f, -0.09213808f, -0.13936119f, 0.00403185f, 
    0.02296970f, -0.05447953f, 0.07265168f, -0.08644112f, -0.11814393f, -0.03122444f, -0.18540499f, -0.04125728f, 
    0.27990952f, 0.02753300f, 0.11002204f, 0.18161792f, -0.09160340f, 0.02799008f, -0.03350836f, 0.02143618f, 
    -0.02721834f, -0.00303874f, -0.03350518f, -0.03174612f, 0.37404031f, -0.15345837f, 0.05820544f, 0.21176465f, 
    -0.03684733f, -0.13041843f, -0.08296255f, 0.01963253f, -0.12934273f, 0.04222689f, -0.00138678f, 0.04223887f, 
    0.30837023f, -0.16899155f, -0.03441520f, -0.09863770f, 0.01985027f, -0.00638085f, -0.05323191f, -0.00019669f, 
    0.19458815f, -0.06843174f, -0.13958745f, 0.02470953f, 0.10838871f, -0.52594239f, 0.02658754f, -0.18691909f, 
    -0.14358929f, -0.12516166f, -0.04659590f, 0.12843947f, -0.10702387f, 0.02883118f, -0.05287259f, -0.19185647f, 
    0.14601290f, -0.02667018f, 0.02126262f, -0.01247529f, -0.05899937f, -0.07550123f, -0.19582434f, 0.00588539f, 
    -0.01715205f, -0.09075721f, -0.11894125f, -0.04535518f, 0.23047660f, -0.01539807f, -0.13791342f, 0.02072933f, 
    0.08071240f, 0.00372338f, -0.09350981f, -0.02323679f, 0.08004894f, -0.14555229f, 0.00697236f, 0.11203293f, 
    0.05552407f, 0.11762457f, -0.05343265f, -0.00443281f, 0.06966312f, 0.15080081f, 0.00424421f, 0.07586141f, 
    0.08530577f, 0.06916636f, 0.03253697f, -0.01279522f, 0.36527935f, -0.37399605f, 0.07494418f, -0.07567953f, 
    0.03891680f, -0.06640621f, 0.05224819f, 0.08338150f, -0.16610526f, 0.09619837f, -0.08643533f, 0.05081242f, 
    -0.11128522f, 0.05977100f, -0.25662324f, -0.06836959f, -0.01430440f, 0.02330423f, -0.00156286f, 0.01115037f, 
    0.09734230f, 0.08008614f, 0.02845581f, 0.08283109f, 0.00733819f, -0.07661577f, -0.08514395f, 0.15597014f, 
    -0.00116510f, 0.05330014f, -0.06586099f, -0.00546403f, 0.03867904f, 0.02633690f, 0.01109101f, -0.00207057f, 
    0.12422948f, 0.10676462f, 0.04304243f, 0.12841964f, -0.04778289f, 0.01125895f, 0.05990666f, -0.06249000f, 
    -0.07596631f, 0.09691487f, -0.01815719f, -0.00495166f, 0.12677838f, 0.13111582f, 0.11759460f, 0.06111776f, 
    -0.07589969f, -0.05270176f, -0.11672585f, 0.04274438f, 0.01182142f, 0.00307478f, -0.03250986f, 0.08833508f, 
    0.17189603f, 0.09628204f, 0.05515366f, 0.26490110f, -0.08347931f, -0.06024362f, 0.00275948f, 0.04131480f, 
    0.07463514f, -0.12806126f, -0.04488738f, 0.08693815f, 0.35570571f, 0.11895887f, -0.20143132f, -0.02522319f, 
    0.00405679f, 0.03511637f, -0.07349680f, 0.03970287f, -0.04640119f, 0.02490132f, 0.06844427f, 0.11097953f, 
    0.28652886f, -0.19949621f, -0.05421813f, -0.01843253f, -0.03079893f, -0.07966901f, 0.00875158f, 0.07970630f, 
    -0.06744355f, -0.00535110f, 0.01273705f, 0.08982749f, -0.05316596f, -0.15151256f, 0.06903772f, -0.29986307f, 
    -0.03685827f, 0.04484754f, -0.07095300f, 0.00096279f, 0.05204085f, -0.12705918f, -0.06228078f, 0.06581768f, 
    0.11625144f, -0.02750358f, 0.12525053f, 0.05150735f, -0.01011308f, -0.03943281f, 0.06924324f, 0.04831984f, 
    -0.04276409f, 0.00863307f, 0.06406417f, -0.03653437f, 0.15414178f, -0.16837409f, 0.02310225f, -0.14582247f, 
    0.09122818f, -0.04738972f, -0.03291057f, -0.01589758f, -0.00754801f, 0.03969375f, -0.05301317f, -0.07245389f, 
    -0.07404623f, -0.10585792f, 0.03201281f, -0.12097343f, 0.10368817f, -0.07759988f, -0.05460311f, 0.02276850f, 
    0.07955216f, -0.05345588f, -0.06577463f, -0.03402259f, 0.30949664f, -0.00315865f, 0.05770518f, -0.21281895f, 
    -0.02398922f, -0.07974538f, -0.03358591f, 0.04415396f, 0.00501788f, 0.11336239f, -0.09276012f, -0.06971739f, 
    0.18910684f, 0.08001596f, -0.05141902f, 0.12076651f, -0.13988960f, 0.12192589f, 0.09239540f, -0.01080635f, 
    -0.04037121f, -0.23982573f, -0.01302434f, -0.08771297f, 0.04420406f, 0.26470998f, -0.02467837f, -0.10941966f, 
    0.02095690f, 0.03400982f, -0.00892000f, -0.00492316f, 0.00642491f, 0.00387390f, 0.04110179f, -0.02506177f, 
    0.12380066f, 0.01820443f, -0.20832673f, 0.01050974f, -0.01935862f, -0.24088019f, -0.04930125f, -0.05718802f, 
    -0.07279767f, 0.04707490f, -0.02514039f, 0.13465911f, 0.12582505f, 0.14285100f, -0.05416743f, 0.12032965f, 
    0.01068584f, 0.10299218f, -0.07238560f, -0.02655127f, 0.01876217f, -0.02938716f, 0.05504366f, 0.06047526f, 
    0.16077213f, -0.07626421f, 0.00189018f, 0.06398515f, -0.06789806f, -0.02624506f, -0.15209924f, 0.12099575f, 
    -0.15545389f, 0.00892705f, 0.02994732f, -0.02502475f, -0.38760921f, -0.02087548f, 0.03499744f, -0.01147248f, 
    -0.07530412f, 0.03779066f, -0.03958738f, 0.00460780f, 0.02419844f, 0.00385639f, -0.04427452f, -0.11100595f, 
    0.04723581f, -0.07909565f, 0.04094940f, -0.08164704f, 0.01788344f, 0.03066435f, 0.05948978f, -0.04084432f, 
    -0.09154361f, 0.10604486f, 0.04834118f, -0.03144414f, -0.16314887f, -0.11515234f, -0.15250400f, -0.20322196f, 
    -0.05414129f, 0.04472286f, -0.00743003f, -0.03330532f, -0.03889733f, -0.03277927f, -0.04365221f, 0.10989980f, 
    -0.06527320f, 0.04426808f, -0.06681017f, 0.19951677f, -0.04040784f, 0.00915308f, -0.00491971f, 0.00307145f, 
    0.00082851f, -0.01942077f, -0.07106797f, 0.07332480f, -0.00935780f, -0.01383447f, -0.01267971f, -0.16840771f, 
    0.02913865f, -0.05356359f, 0.01238521f, 0.00819058f, -0.08520952f, 0.04716084f, -0.02727188f, 0.10310794f, 
    -0.04103771f, -0.27836394f, -0.00135660f, 0.16834375f, -0.09355374f, -0.06402469f, -0.04745084f, 0.01023707f, 
    0.06334585f, 0.17401019f, -0.08896945f, 0.12193244f, 0.09146280f, -0.03179117f, 0.04305908f, 0.16974747f, 
    -0.01566472f, -0.02824900f, 0.02266680f, -0.05792481f, -0.03062701f, -0.01146859f, 0.03962000f, -0.10379194f, 
    -0.12278540f, -0.02119014f, 0.04072390f, -0.12151521f, -0.02743941f, -0.08831989f, -0.07012429f, -0.02498090f, 
    0.07397915f, 0.10487399f, 0.13315463f, -0.09243879f, 0.03832027f, 0.08636559f, 0.16923457f, 0.03756761f, 
    -0.05534577f, -0.09028637f, 0.03422798f, -0.03560110f, 0.01476728f, 0.03876289f, 0.16881664f, 0.02166170f, 
    0.16609602f, -0.17343430f, 0.05809953f, 0.03251719f, -0.01131564f, 0.03470428f, -0.01698336f, 0.13863721f, 
    -0.07794733f, -0.04478370f, 0.00777459f, 0.06257129f, -0.10856082f, 0.15673761f, -0.15213378f, 0.04174308f, 
    -0.15752490f, 0.05172441f, -0.02959921f, 0.03999671f, 0.12353004f, 0.09087260f, -0.11222015f, 0.08519664f, 
    0.17846985f, -0.12511115f, 0.04791070f, -0.54485136f, 0.00716486f, -0.02173489f, 0.02693808f, 0.09374953f, 
    -0.11630573f, -0.05381487f, -0.00240905f, -0.09890210f, -0.20700084f, -0.03097025f, -0.09410092f, -0.14139782f, 
    0.11083771f, -0.00734454f, -0.03746634f, 0.01462899f, -0.07223318f, 0.02243583f, -0.16297038f, 0.01616430f, 
    -0.22709984f, -0.03006305f, -0.00920853f, -0.03430416f, -0.00414766f, 0.02875157f, -0.08328989f, 0.11048400f, 
    0.05127961f, 0.09280989f, -0.14538777f, 0.09010766f, -0.05539849f, -0.05352124f, -0.11755190f, -0.00941629f, 
    -0.01287619f, 0.01668847f, 0.05305104f, 0.06322538f, -0.08477158f, -0.10362172f, -0.03127362f, 0.17962046f, 
    0.31837121f, -0.15843503f, 0.06905784f, 0.10285369f, 0.04687140f, 0.06350383f, -0.08485047f, -0.04508996f, 
    -0.00808133f, 0.18821958f, -0.09593024f, 0.02082102f, -0.12951957f, 0.11065244f, -0.17234914f, -0.17631954f, 
    -0.05811921f, 0.06656717f, 0.06739570f, -0.05172177f, 0.05274165f, 0.06777040f, 0.00795306f, 0.10138068f, 
    0.00405386f, -0.14467911f, 0.05273458f, -0.18982317f, -0.02898558f, 0.13908145f, 0.04865576f, 0.13994840f, 
    0.10144812f, 0.11484415f, 0.04570334f, 0.02730498f, 0.24819136f, 0.17603283f, 0.08187150f, 0.08215919f, 
    -0.07591028f, -0.04365844f, 0.03243174f, 0.01315196f, 0.05361123f, -0.10778181f, 0.01645840f, -0.09205610f, 
    0.11064457f, -0.18436483f, 0.01975362f, -0.13994122f, -0.03311463f, 0.07456137f, 0.04880241f, 0.04236351f, 
    -0.00093393f, 0.05664243f, -0.06651314f, 0.05557345f, -0.21095935f, -0.09320089f, -0.09413153f, -0.05161681f, 
    -0.01746863f, 0.04326265f, 0.06451296f, 0.05577293f, 0.09951323f, 0.03302408f, 0.10054354f, 0.08239418f, 
    -0.13363089f, 0.09570418f, 0.04262874f, 0.10346228f, 0.01968951f, -0.02091581f, 0.05909995f, 0.02954978f, 
    -0.02302286f, 0.00215849f, 0.00689081f, -0.03504719f, 0.18994287f, 0.08377904f, 0.03449221f, -0.03735152f, 
    -0.02282758f, -0.02198072f, -0.06217629f, -0.01938313f, -0.00533643f, 0.00600789f, -0.09663728f, -0.06211722f, 
    -0.28890118f, -0.12722917f, 0.06570866f, -0.09321572f, -0.15742411f, 0.01691265f, -0.20036773f, 0.04038196f, 
    -0.05006720f, -0.12654488f, -0.01384880f, -0.00433734f, 0.27046910f, -0.23661503f, -0.10219114f, -0.03407680f, 
    -0.02795983f, -0.04688871f, 0.00837782f, 0.01568735f, 0.03266995f, -0.06564361f, -0.00570707f, -0.06534778f, 
    0.33371344f, 0.09773679f, -0.04262460f, -0.02757544f, 0.06346284f, 0.06111651f, -0.08468635f, -0.01295393f, 
    -0.05786334f, 0.03236336f, 0.04174648f, -0.11050886f, -0.15778573f, 0.11102425f, -0.27567178f, -0.09819796f, 
    0.14716245f, 0.08947109f, -0.02611343f, -0.01537156f, -0.02794416f, 0.08988658f, 0.00642455f, -0.00898335f, 
    0.35321420f, 0.16685985f, 0.11716170f, 0.12549065f, 0.01386096f, -0.06820400f, 0.01340340f, 0.13752060f, 
    -0.05580966f, 0.01512981f, -0.04441734f, -0.11588745f, 0.03606559f, -0.06002403f, -0.02939039f, 0.02683417f, 
    -0.00245051f, -0.01414809f, 0.00184349f, 0.03062438f, -0.08825373f, 0.06789680f, 0.05964465f, 0.03415907f, 
    0.22536302f, -0.02127604f, -0.13587929f, 0.15375660f, -0.19073983f, 0.03824856f, -0.06571991f, -0.02523945f, 
    -0.04585126f, -0.00127218f, 0.06739520f, -0.00334217f, -0.21119355f, -0.00479851f, -0.05681236f, -0.04074237f, 
    0.09480965f, -0.02568350f, -0.05167713f, -0.01900320f, 0.07498883f, 0.00119987f, -0.05982858f, 0.08671424f, 
    0.00917071f, -0.04311831f, -0.08923238f, 0.05968082f, 0.01136153f, -0.02271915f, 0.07434088f, -0.17027688f, 
    0.01743368f, -0.05118660f, -0.10803422f, 0.02306558f, 0.11152373f, -0.02037472f, -0.14034541f, -0.01202594f, 
    -0.07099652f, 0.05906282f, 0.03216173f, -0.03130888f, -0.00834963f, 0.02481825f, 0.04170897f, 0.04225122f, 
    0.12581654f, -0.31384343f, -0.05088703f, -0.07711650f, -0.15066628f, -0.04301219f, 0.00140562f, 0.02209990f, 
    0.02557207f, -0.08638662f, 0.02367007f, -0.06548794f, 0.33071685f, -0.13105239f, 0.22660416f, -0.06846315f, 
    -0.03962161f, -0.13343112f, -0.06992513f, 0.03699042f, 0.04209681f, -0.01878611f, 0.04756676f, -0.01480414f, 
    -0.01480291f, -0.06865636f, -0.03457115f, -0.14010848f, 0.05270063f, -0.08314884f, 0.04749330f, -0.06735647f, 
    -0.03297314f, 0.01639098f, -0.00717818f, 0.04029032f, 0.21898830f, -0.05698159f, -0.11758365f, 0.04174867f, 
    -0.09601885f, 0.00857367f, 0.06058453f, -0.00905940f, 0.06780429f, 0.08718963f, -0.12979887f, 0.03709643f, 
    0.00083795f, -0.01776695f, 0.02737008f, 0.09260219f, 0.03358145f, 0.03525165f, 0.00001078f, -0.04764945f, 
    -0.00099125f, 0.00826135f, -0.09206282f, 0.01022447f, 0.22152151f, -0.08652426f, -0.04884336f, -0.23245914f, 
    -0.13682535f, 0.02587159f, -0.04667960f, 0.01959320f, 0.14701255f, -0.10011367f, -0.04501846f, -0.05813793f, 
    0.03146317f, -0.13830473f, -0.03283891f, -0.12578535f, 0.09381855f, -0.02739369f, 0.05557753f, 0.02423919f, 
    -0.11316864f, 0.00517668f, -0.01317111f, 0.02474221f, 0.16210984f, -0.06368862f, -0.02963038f, 0.01217711f, 
    0.08568854f, -0.11940983f, 0.09641498f, 0.03891492f, -0.02113494f, 0.06365702f, 0.11864084f, -0.10793255f, 
    0.21500897f, 0.10416558f, 0.11527973f, 0.23439212f, -0.08217924f, -0.10416820f, 0.08891219f, 0.00680147f, 
    -0.01678047f, -0.03091779f, 0.06194260f, 0.04968809f, -0.11358167f, -0.05922898f, -0.17396943f, 0.20735790f, 
    0.09570464f, -0.06356015f, 0.03438705f, -0.01798013f, -0.08089632f, -0.03705328f, 0.05979371f, 0.15020509f, 
    0.03166093f, -0.02734567f, 0.09487098f, -0.06930438f, -0.02771236f, 0.07370161f, 0.07796915f, 0.01652075f, 
    -0.04833339f, 0.05040811f, -0.04155798f, -0.03862046f, 0.21012472f, -0.18093783f, -0.00088380f, 0.08698905f, 
    -0.11428613f, 0.06879533f, -0.08534168f, 0.03060015f, -0.12921582f, -0.06437816f, 0.01181896f, -0.04362621f, 
    0.04587722f, -0.17334449f, -0.20346461f, -0.14818148f, -0.01943411f, -0.03191838f, 0.05479311f, -0.05775009f, 
    -0.04061853f, -0.02817082f, -0.05647099f, -0.08604119f, -0.19967891f, 0.17036857f, -0.02209844f, -0.16821684f, 
    0.00327197f, -0.02046221f, 0.14361244f, -0.05889457f, -0.02685107f, 0.00035080f, 0.04968371f, -0.07125329f, 
    -0.16946934f, 0.05400289f, -0.10536175f, -0.36976543f, -0.03150437f, 0.06263477f, 0.05882968f, -0.03968949f, 
    -0.05362800f, -0.03729248f, -0.05275108f, -0.01096819f, 0.37751719f, -0.03289530f, -0.08706782f, -0.09597724f, 
    0.00089593f, 0.07723459f, -0.11041647f, -0.00055069f, -0.03294051f, -0.04675442f, 0.03895169f, 0.04633677f, 
    0.05459609f, 0.03547217f, -0.18091178f, -0.04726915f, -0.18492004f, -0.10684626f, -0.08846883f, 0.00086718f, 
    0.02018133f, -0.09388178f, -0.13373525f, 0.00744645f, 0.09996979f, 0.02509777f, -0.02338170f, 0.03474099f, 
    0.02782277f, 0.07270832f, 0.07432560f, -0.10431449f, 0.01116524f, 0.03171231f, 0.02450044f, -0.11703064f, 
    0.04331233f, 0.03560019f, -0.01342247f, 0.04909365f, 0.05959219f, 0.02044955f, 0.04686487f, -0.11946675f, 
    -0.05136494f, 0.03919538f, -0.00595683f, -0.06877129f, 0.18382235f, -0.06528763f, 0.20418099f, 0.03674617f, 
    -0.09593718f, -0.07845735f, -0.11695848f, 0.09406852f, 0.04068929f, -0.02975288f, -0.07754961f, -0.08480943f, 
    0.14593047f, 0.04962849f, -0.03696314f, -0.10996864f, 0.09700786f, 0.02317089f, 0.04716113f, -0.03883324f, 
    -0.02393232f, 0.04624819f, -0.00487388f, -0.14900191f, -0.31060931f, -0.00334325f, 0.03428575f, 0.10006531f, 
    0.01932658f, -0.07603103f, -0.13269642f, -0.07570846f, -0.01195488f, 0.10771170f, -0.04519606f, 0.05384379f, 
    0.00006992f, 0.05765530f, -0.02957481f, -0.08637686f, 0.07636683f, 0.07753614f, -0.03810152f, 0.04092660f, 
    -0.01740720f, 0.06730981f, -0.04144997f, 0.01214717f, 0.02859528f, 0.00508250f, 0.03454538f, 0.08622229f, 
    -0.12489358f, 0.00055871f, -0.00784551f, 0.09224244f, -0.06796665f, -0.00569891f, -0.04700971f, 0.02747481f, 
    0.16098808f, 0.01601007f, 0.07827224f, 0.09882455f, -0.11963600f, 0.10149794f, 0.09150140f, 0.01195898f, 
    -0.08814993f, -0.00139565f, 0.00698860f, 0.10263420f, 0.03613492f, -0.01382638f, 0.03098809f, -0.08599406f, 
    0.02563700f, -0.02379033f, 0.09464057f, 0.04425987f, -0.09169072f, -0.04519764f, 0.00806863f, -0.04691430f, 
    0.10950524f, -0.04006105f, 0.09565526f, -0.04621309f, 0.09313536f, 0.05236920f, 0.04532750f, 0.06350546f, 
    -0.03133707f, 0.08366515f, 0.03803574f, -0.07240203f, 0.08609012f, -0.01742942f, -0.16476884f, 0.01213350f, 
    0.03451913f, 0.02778838f, -0.00718729f, 0.03461011f, -0.06578954f, 0.03445426f, 0.00698548f, 0.13986461f, 
    -0.09205186f, 0.05072690f, 0.10457604f, 0.06271145f, -0.09562851f, 0.05253894f, -0.03913842f, 0.06579299f, 
    -0.09264316f, -0.04445820f, 0.01347579f, -0.01205917f, 0.13642429f, -0.05268462f, 0.06879365f, 0.10082337f, 
    -0.11894585f, -0.03482591f, -0.12843448f, 0.10487866f, 0.02129740f, -0.01181434f, 0.02557979f, -0.05622201f, 
    0.47907078f, -0.05882096f, -0.11870930f, 0.03063420f, 0.00778709f, 0.10256784f, -0.01858650f, -0.02076149f, 
    -0.12476651f, -0.05450935f, 0.10495004f, -0.02445547f, 0.04274093f, 0.05054852f, -0.06059795f, -0.06817668f, 
    -0.14760309f, 0.11230479f, 0.08938479f, -0.01551929f, -0.09331512f, 0.01673977f, -0.01797004f, 0.02788662f, 
    -0.22650503f, 0.06287365f, -0.08978985f, -0.07279143f, 0.06628107f, -0.02117131f, 0.02781966f, -0.12769096f, 
    -0.07533787f, 0.02952410f, -0.02421343f, -0.14222522f, 0.21411954f, 0.10648794f, 0.01977437f, -0.04712025f, 
    0.04643756f, -0.16251816f, -0.10150927f, 0.00639828f, -0.08325900f, -0.09716754f, 0.07339567f, -0.10043045f, 
    -0.22643515f, 0.12530597f, -0.18495451f, -0.00444920f, 0.07650775f, 0.00007103f, -0.07609028f, 0.02536593f, 
    -0.05138089f, 0.05161266f, -0.08904409f, -0.12661430f, -0.27109349f, -0.04150866f, -0.07456265f, -0.18695267f, 
    0.04248039f, -0.04692740f, -0.02762516f, -0.10293735f, 0.00511756f, -0.01869722f, 0.01841929f, -0.04175836f, 
    -0.08964094f, -0.09526745f, -0.12080831f, -0.15648486f, -0.02490783f, -0.08776690f, 0.06408855f, -0.05706759f, 
    -0.05001610f, -0.05389890f, -0.03372018f, -0.07765077f, 0.04498860f, 0.12542284f, -0.01451225f, -0.02752823f, 
    -0.05330214f, 0.06855477f, 0.05592048f, 0.10233813f, -0.02312817f, -0.03590443f, -0.07645288f, -0.06502148f, 
    0.16822781f, -0.03511249f, -0.06022820f, -0.17847320f, 0.01351717f, -0.00261846f, -0.06108250f, -0.01988868f, 
    -0.06400530f, -0.02642325f, -0.06266665f, -0.01882543f, -0.17064011f, 0.14345537f, 0.02933330f, 0.00286281f, 
    0.08010772f, -0.00847670f, 0.04275875f, -0.02179516f, -0.04808787f, -0.01776565f, 0.02333043f, -0.12417283f, 
    0.25226972f, -0.04383619f, 0.09409272f, 0.04710086f, -0.03593355f, -0.13763052f, 0.02849875f, -0.07209118f, 
    0.00493148f, -0.10625790f, 0.08190677f, -0.01976032f, -0.26019874f, -0.23714156f, -0.07195584f, 0.11360307f, 
    -0.11445852f, -0.04940023f, -0.15843913f, -0.01433631f, 0.11560315f, -0.07260523f, -0.07243953f, -0.11644658f, 
    -0.01760759f, -0.13044332f, -0.06595685f, -0.05698053f, -0.02224760f, -0.02346271f, 0.10448777f, -0.07254931f, 
    0.05157774f, 0.05969342f, -0.00983456f, 0.00954460f, 0.19400042f, 0.15494654f, -0.25667360f, 0.05756077f, 
    0.09419160f, 0.06408334f, -0.01571155f, -0.11701871f, 0.01814868f, -0.01061326f, 0.13175415f, -0.20669661f, 
    0.23701657f, -0.07024893f, -0.01151872f, 0.04313699f, 0.11102878f, -0.01516572f, 0.06108790f, 0.05098935f, 
    -0.06428830f, -0.06273899f, -0.03023399f, -0.07848962f, 0.00615599f, 0.13510185f, -0.17826030f, -0.14665775f, 
    -0.08905726f, 0.06635118f, -0.04329619f, 0.00022564f, -0.00623231f, 0.07150347f, -0.01991706f, -0.00601210f, 
    0.02400213f, -0.17534865f, 0.02274458f, -0.02054896f, 0.07784728f, -0.03949262f, -0.03489788f, 0.08038727f, 
    0.12314525f, 0.03575750f, 0.08455414f, 0.00972596f, 0.18084674f, 0.08660039f, -0.28842527f, -0.03167661f, 
    0.08511662f, 0.05319385f, -0.01259974f, 0.01434593f, -0.05231467f, -0.07358437f, -0.03057245f, 0.02680734f, 
    -0.29771993f, 0.00218593f, 0.04143278f, 0.10390915f, 0.01628642f, -0.02286981f, 0.07793445f, 0.05194784f, 
    -0.06440608f, -0.03944446f, 0.02297555f, -0.06350462f, -0.07225400f, 0.05000723f, -0.06316803f, -0.11588828f, 
    -0.04606857f, 0.04000395f, -0.01572509f, 0.03333372f, -0.04537636f, 0.17134809f, -0.08159509f, -0.00465735f, 
    -0.03748289f, 0.09710983f, 0.04250528f, 0.23527038f, -0.10498497f, -0.06105363f, 0.07130551f, 0.06768156f, 
    0.02796668f, -0.01477955f, -0.02502217f, -0.05701449f, -0.30837160f, -0.11616752f, -0.01682427f, -0.46229741f, 
    -0.02248843f, 0.04063703f, -0.07258528f, 0.03322245f, -0.03136397f, -0.00786775f, -0.01902539f, -0.03027920f, 
    -0.12802893f, 0.00686458f, -0.01997370f, -0.16908403f, -0.05362856f, 0.04952889f, 0.04978742f, -0.05144314f, 
    0.04401314f, 0.09312022f, -0.07583962f, -0.12110160f, -0.08824217f, 0.11297095f, 0.02795409f, -0.10290652f, 
    0.01592021f, -0.09952347f, -0.05256848f, -0.01531463f, 0.05986853f, -0.04787110f, -0.03261164f, 0.05930129f, 
    0.24250548f, -0.03873786f, 0.01163953f, 0.10653640f, 0.06006224f, 0.02322072f, 0.05257975f, -0.08983983f, 
    -0.06376225f, -0.02927412f, -0.04325185f, 0.05596023f, -0.07390008f, 0.05187860f, 0.22390822f, 0.16540800f, 
    0.12744714f, 0.03000260f, 0.07019442f, 0.01329455f, 0.06395248f, 0.07491142f, -0.12663518f, 0.01787974f, 
    0.08904538f, 0.26133844f, 0.12195311f, -0.16590552f, 0.00322974f, -0.06401117f, -0.07727981f, 0.11705013f, 
    0.04501726f, -0.10706007f, -0.09029851f, 0.02462554f, 0.22385471f, 0.10544651f, 0.03829267f, 0.01877785f, 
    0.07399346f, 0.01166689f, -0.08438394f, 0.08156236f, 0.06356894f, 0.00558871f, -0.03952990f, -0.07590169f, 
    -0.44643295f, 0.08737884f, -0.09531316f, -0.30398488f, -0.01925734f, -0.03198238f, -0.01153575f, 0.03172720f, 
    0.02739813f, -0.04439138f, -0.03432542f, -0.01644824f, 0.16381250f, -0.28704563f, -0.07360089f, -0.08552960f, 
    -0.01989132f, 0.01084055f, 0.06150801f, 0.00177681f, -0.04390418f, -0.00526015f, 0.04256837f, -0.04421949f, 
    0.11631412f, 0.07979862f, 0.13570656f, -0.12152670f, 0.08282983f, -0.07906715f, 0.05135289f, 0.00564998f, 
    -0.00956082f, -0.10866303f, -0.06951875f, 0.02287821f, -0.01618823f, -0.10389386f, 0.10700627f, 0.10720279f, 
    0.00105722f, -0.04263894f, 0.08101121f, 0.05627613f, 0.05276933f, 0.03543984f, -0.05203042f, -0.06291540f, 
    0.20833263f, 0.00600699f, -0.00061438f, 0.21993013f, -0.00633487f, 0.07767414f, 0.03190027f, -0.17973447f, 
    0.02639329f, -0.02621549f, -0.02782321f, -0.11529627f, -0.09616173f, 0.32441568f, -0.05710052f, -0.02895225f, 
    -0.07567058f, -0.08246034f, -0.03677910f, 0.01864391f, -0.04726422f, 0.05726990f, 0.09385552f, -0.02801636f, 
    0.05804262f, 0.01357264f, 0.14847887f, -0.05525248f, 0.03062776f, -0.11510281f, 0.03851429f, -0.04518344f, 
    -0.05173060f, -0.07993294f, 0.03447654f, -0.08308209f, 0.05623215f, 0.00370287f, -0.17145909f, -0.01063196f, 
    -0.08345940f, -0.08835801f, 0.00138996f, 0.08930390f, 0.01260191f, -0.08197907f, 0.09254951f, -0.04468721f, 
    0.55671746f, 0.23931596f, -0.05818748f, -0.03641042f, 0.04046141f, 0.01098825f, -0.05568923f, 0.10865328f, 
    -0.05428615f, -0.05947128f, 0.07703090f, -0.03363380f, -0.01305069f, 0.10481241f, 0.04263566f, 0.00399969f, 
    0.04377152f, -0.05338462f, 0.07975589f, -0.02620172f, -0.03816463f, -0.05316648f, 0.04802024f, 0.13521759f, 
    -0.44685841f, -0.48384139f, 0.07417054f, 0.22510883f, 0.01994223f, -0.02145340f, 0.03095235f, -0.14832909f, 
    0.05956944f, -0.00597097f, -0.08858816f, -0.01969378f, 0.20471756f, 0.16919465f, 0.02602017f, 0.04031039f, 
    -0.06029483f, 0.00392759f, -0.09688609f, 0.04496647f, -0.05166908f, 0.01254404f, 0.01066057f, 0.00493372f, 
    -0.33346942f, -0.45345420f, -0.12931460f, -0.03632873f, -0.12663643f, -0.05083189f, 0.01628539f, -0.03765409f, 
    0.02542261f, -0.01434579f, 0.10134295f, 0.06064644f, -0.03077413f, -0.38191339f, -0.34401372f, -0.20871270f, 
    -0.11976235f, -0.09883323f, 0.04710857f, 0.08310736f, 0.01326510f, 0.04795130f, -0.09267059f, -0.07718845f, 
    -0.02415850f, -0.03857325f, -0.09732014f, -0.07503930f, -0.01263835f, -0.02867564f, -0.03362431f, -0.06968565f, 
    -0.07348008f, -0.06417320f, 0.03182558f, 0.00269540f, 0.02885006f, 0.00138621f, 0.15622160f, -0.06336631f, 
    -0.00791396f, 0.02241644f, 0.02713866f, -0.00130895f, -0.04299959f, -0.02570320f, -0.01394773f, -0.00907501f, 
    -0.05620501f, 0.12504146f, 0.02894298f, -0.00050282f, -0.02432530f, -0.06504050f, -0.08997542f, 0.03352498f, 
    0.03251771f, 0.04691751f, 0.09297025f, 0.10042147f, -0.07284075f, 0.08505719f, 0.06522352f, 0.02269044f, 
    -0.11386923f, 0.02704633f, -0.01360481f, 0.01086505f, -0.06112071f, 0.03800381f, -0.09882170f, 0.05098794f, 
    0.05372800f, -0.01909065f, 0.04317561f, 0.04920786f, -0.05838588f, -0.01565437f, 0.00961606f, -0.03437327f, 
    -0.06738779f, 0.04377896f, 0.00026380f, -0.11846381f, 0.14525576f, -0.19994065f, -0.10513192f, 0.01313899f, 
    -0.06233392f, -0.03961611f, -0.03273840f, 0.10715947f, -0.05897486f, 0.02534310f, -0.04653099f, 0.04098388f, 
    -0.04772388f, -0.02699218f, 0.00372099f, 0.09845107f, 0.05456829f, -0.01242327f, -0.01169607f, 0.01156987f, 
    -0.05193539f, 0.08029418f, 0.01013393f, 0.04262654f, -0.21568602f, 0.16453741f, 0.19411249f, 0.05234418f, 
    -0.09232838f, -0.09870304f, 0.09762008f, 0.01998986f, -0.07069977f, 0.03990069f, -0.14999582f, 0.01377107f, 
    0.08476337f, 0.02302365f, 0.04350538f, -0.01327807f, -0.10774630f, -0.14376776f, -0.00507745f, -0.04166341f, 
    0.06395013f, 0.00381946f, 0.14838301f, 0.08706645f, -0.29215154f, -0.30122966f, 0.04098478f, 0.14871883f, 
    0.05522625f, 0.04875099f, 0.05007550f, -0.13066205f, 0.06331415f, -0.00482066f, -0.03702236f, -0.03893511f, 
    0.10491937f, -0.24562298f, -0.25748858f, -0.00409445f, -0.07361636f, -0.02116619f, 0.05682724f, -0.01609364f, 
    -0.03023800f, 0.12126622f, 0.03000585f, -0.03505173f, 0.05558536f, 0.05052585f, -0.20617613f, -0.06913452f, 
    0.04807991f, -0.14187939f, 0.05090325f, -0.01048543f, -0.03714553f, -0.08846545f, 0.05677316f, -0.06416510f, 
    0.27170473f, -0.33915415f, -0.37567124f, 0.06299621f, -0.00378687f, -0.01379029f, 0.04596583f, -0.10861004f, 
    -0.02580149f, 0.00539910f, -0.01586783f, -0.05059234f, 0.05390600f, 0.00618320f, -0.04041510f, -0.02684703f, 
    -0.07662479f, -0.05280239f, 0.01592794f, -0.00472810f, -0.01708901f, 0.08423852f, 0.02330575f, -0.01912194f, 
    -0.18933380f, -0.07277690f, -0.19976908f, 0.06005796f, -0.03734610f, -0.06061037f, -0.01990047f, 0.02147964f, 
    0.00653185f, 0.01513614f, 0.08189040f, -0.05431913f, -0.06902780f, -0.00090768f, -0.01169626f, 0.05513318f, 
    -0.10796614f, -0.05646111f, 0.01979342f, 0.06572662f, -0.00150900f, 0.09297559f, -0.02999877f, 0.13338122f, 
    -0.05127211f, 0.06097614f, -0.00919056f, -0.15075158f, -0.05953475f, 0.00004093f, 0.05240515f, 0.02048789f, 
    -0.07242186f, -0.05105801f, 0.20467001f, 0.10236321f, -0.23286283f, -0.04287765f, -0.07068063f, -0.03021756f, 
    -0.00014696f, 0.06283826f, -0.06152008f, 0.06887300f, 0.03454802f, 0.00191235f, -0.03199754f, 0.07543273f, 
    -0.26266101f, -0.17032671f, 0.11364279f, -0.04477414f, 0.10420136f, 0.09203041f, -0.05566860f, 0.04060856f, 
    0.09881860f, 0.06731392f, -0.02754568f, 0.06489082f, -0.27107072f, -0.05891646f, -0.03821903f, -0.02715980f, 
    -0.02790461f, 0.05315586f, 0.03389486f, -0.07712373f, 0.04520416f, 0.06252453f, 0.04810741f, 0.11295445f, 
    0.02292352f, -0.10468115f, -0.04824245f, -0.09201061f, -0.01711619f, 0.08556293f, -0.03926251f, 0.17363165f, 
    0.07815456f, -0.05488653f, 0.01151407f, -0.04974428f, 0.10758107f, -0.09718459f, 0.03576138f, -0.00804608f, 
    -0.03697934f, -0.16989084f, 0.03507244f, -0.05230603f, 0.01987396f, -0.08945581f, 0.04331620f, -0.22580241f, 
    -0.15422560f, -0.02311681f, 0.33912617f, -0.00048375f, 0.03073436f, 0.01129230f, 0.05203942f, -0.03977432f, 
    0.04630238f, 0.07698955f, -0.11091170f, -0.01821708f, -0.06314301f, -0.03763702f, 0.11753488f, -0.08127209f, 
    0.04461595f, -0.01200955f, 0.07220607f, 0.08050597f, 0.07682050f, 0.01945131f, -0.08469547f, -0.00363043f, 
    0.20856442f, -0.03419629f, -0.01783827f, 0.19654271f, 0.03508215f, 0.06160339f, -0.10373449f, 0.20163034f, 
    0.04816156f, -0.03332007f, -0.07553747f, -0.08675020f, -0.10207105f, 0.10771184f, -0.04077508f, -0.04860782f, 
    -0.06842382f, -0.01112039f, -0.00479833f, 0.05743492f, 0.00342047f, -0.03703989f, -0.00049780f, 0.08921246f, 
    0.22339672f, -0.25347918f, 0.09186270f, 0.06835407f, -0.03665479f, 0.10844336f, 0.14172830f, -0.00532693f, 
    -0.06091923f, -0.16734011f, 0.05215098f, -0.11518010f, -0.00862263f, 0.09295704f, 0.13040742f, -0.03373161f, 
    0.06581679f, 0.00406524f, 0.02961669f, -0.04175391f, -0.04338907f, 0.00999447f, 0.09421448f, 0.06789172f, 
    0.23259230f, -0.12507497f, -0.28241870f, 0.05779205f, 0.03847788f, -0.02236462f, 0.08994912f, 0.05962492f, 
    0.02346022f, -0.03760557f, 0.07516752f, -0.05744300f, -0.61929727f, 0.00219770f, -0.08853740f, 0.00975897f, 
    0.00176617f, 0.01312377f, -0.00423074f, -0.03658311f, 0.03576661f, 0.03108496f, 0.00091934f, -0.02186386f, 
    -0.06707693f, 0.15742548f, 0.13608904f, -0.00755025f, 0.04889023f, 0.09629419f, -0.01136680f, -0.00133500f, 
    0.10772260f, -0.07757764f, -0.14738335f, -0.07963365f, -0.06466628f, -0.39658770f, -0.43154564f, 0.14176500f, 
    -0.08667438f, -0.00632552f, 0.02775475f, 0.08929550f, -0.02184876f, -0.02520348f, -0.02342114f, -0.08839032f, 
    0.08773780f, 0.00763259f, -0.02892764f, 0.02987388f, -0.00432962f, 0.04663872f, 0.02798815f, 0.02231443f, 
    0.02954417f, -0.00905137f, -0.03355306f, 0.00092601f, 0.08994178f, -0.12585470f, 0.00814935f, 0.13506700f, 
    -0.09303796f, -0.16797429f, -0.00259699f, 0.01859700f, -0.07625397f, 0.04202306f, 0.04658907f, -0.07418631f, 
    0.15729821f, -0.09543210f, 0.16735643f, 0.09763106f, -0.06338918f, 0.01879431f, 0.00340794f, 0.10136305f, 
    -0.04119991f, 0.12023637f, -0.06129345f, 0.05608733f, 0.23346075f, 0.02299140f, 0.27029327f, 0.25068691f, 
    0.10418336f, 0.05830373f, 0.02086778f, -0.12111924f, 0.05330187f, 0.08686920f, 0.05161430f, -0.16593185f, 
    -0.19182172f, 0.10863671f, 0.17245735f, 0.22123961f, 0.02141410f, 0.07739256f, 0.06623060f, -0.13038406f, 
    -0.01895780f, -0.06362110f, -0.06175609f, -0.11598854f, -0.33671820f, -0.01008111f, -0.07811321f, -0.09198762f, 
    0.01630884f, -0.00448232f, -0.01939185f, 0.02431587f, 0.03433288f, -0.08700112f, 0.01732097f, 0.06564526f, 
    -0.02738345f, -0.00337373f, -0.19097960f, -0.15220100f, -0.00673544f, 0.01562168f, 0.04795584f, -0.13192071f, 
    0.12451100f, 0.00919403f, 0.05418039f, -0.08949017f, -0.31395632f, 0.13633814f, 0.07163682f, -0.01900456f, 
    0.02627444f, 0.04301902f, 0.08981628f, 0.03471319f, -0.00538002f, -0.05559000f, 0.02345189f, 0.02537122f, 
    0.00756917f, -0.06140244f, -0.08583606f, -0.21630113f, -0.07106742f, 0.01332340f, -0.02970756f, 0.04418089f, 
    0.15450518f, -0.00379612f, 0.00703426f, -0.00956622f, -0.58314788f, -0.15516691f, -0.08504719f, 0.06767578f, 
    -0.05045689f, -0.05794950f, -0.01785817f, 0.08352571f, -0.09870077f, -0.12856486f, 0.04779655f, 0.10167094f, 
    0.04501486f, -0.15566485f, -0.01416804f, -0.11134765f, -0.08038234f, 0.04931545f, 0.00109809f, 0.03050663f, 
    0.00403267f, -0.02204324f, -0.03065767f, 0.07329080f, 0.19544503f, 0.02194198f, 0.05975973f, -0.00236708f, 
    0.07938068f, -0.03093137f, -0.03974844f, 0.03371347f, -0.05683675f, 0.03022924f, -0.11920681f, -0.07494781f, 
    -0.38611603f, -0.07796212f, 0.13633147f, 0.07500210f, 0.05737810f, -0.03703656f, -0.02795292f, -0.02500047f, 
    -0.01112069f, -0.02754264f, 0.03036558f, 0.10536896f, 0.09036525f, 0.06903791f, -0.00638416f, -0.00101631f, 
    0.06939369f, 0.04603602f, -0.02470764f, 0.06707818f, -0.11351504f, -0.04907913f, -0.09844960f, 0.04985125f, 
    -0.01051551f, 0.17650935f, 0.07693165f, -0.03329237f, -0.03983618f, -0.02815933f, 0.06453886f, -0.04019514f, 
    0.18945254f, -0.05577866f, 0.10480136f, 0.08033169f, -0.21083438f, 0.21652336f, -0.12969235f, -0.26596639f, 
    0.07009853f, -0.04242733f, 0.04938679f, 0.04539648f, 0.00704182f, 0.04757690f, -0.00960445f, 0.12171246f, 
    0.41229644f, 0.30474296f, -0.13822106f, 0.00334298f, 0.02474774f, -0.04042210f, 0.07855091f, 0.05674792f, 
    0.06951060f, -0.03021973f, -0.03332767f, 0.09987506f, -0.11624104f, 0.05163497f, 0.09882570f, 0.04750114f, 
    -0.06751585f, -0.02477682f, 0.05242805f, -0.06889144f, 0.00569301f, 0.04486931f, 0.03142497f, 0.01081777f, 
    -0.23555404f, -0.03434180f, 0.07182731f, 0.20944542f, 0.01412052f, -0.04726651f, 0.09412824f, 0.06474295f, 
    -0.06368032f, 0.07798345f, 0.03345386f, 0.13051556f, -0.16507894f, 0.10480671f, 0.06107813f, -0.06715130f, 
    -0.01024361f, 0.05953753f, 0.00845888f, -0.15306027f, -0.05817660f, -0.05723358f, -0.05462905f, -0.02421482f, 
    -0.10381638f, -0.17325902f, 0.00799996f, -0.06632510f, 0.09670807f, 0.06935178f, -0.01682409f, 0.10864265f, 
    -0.07495195f, -0.07879308f, -0.00902763f, -0.06148304f, 0.16330011f, 0.15524645f, -0.15856621f, -0.17631344f, 
    0.16707128f, -0.16675921f, 0.00032413f, -0.11325959f, -0.12058315f, -0.07237576f, 0.02265958f, 0.05160512f, 
    -0.20102629f, -0.03774939f, 0.10673130f, 0.24024189f, -0.08537636f, 0.10654092f, -0.03424464f, 0.04771704f, 
    -0.02629670f, 0.02068465f, 0.04564817f, -0.01423712f, 0.21087141f, 0.13460462f, -0.03045363f, 0.01493726f, 
    0.04068207f, 0.04587703f, 0.06897450f, 0.03723159f, 0.04080010f, -0.03722076f, -0.01462813f, 0.03292993f, 
    0.27447936f, 0.03032591f, 0.08757933f, -0.15007511f, 0.02774694f, 0.02707026f, -0.08386873f, -0.00232554f, 
    -0.02303554f, 0.07936157f, -0.04940311f, -0.03327732f, -0.29971272f, 0.01529094f, 0.03043855f, 0.14856015f, 
    0.04898876f, -0.00682132f, 0.06204268f, 0.11381257f, 0.04486210f, -0.05383226f, -0.02921263f, 0.04293184f, 
    0.10278998f, 0.11013093f, -0.08276523f, -0.28806099f, 0.10373094f, -0.07959373f, 0.02856586f, 0.04710216f, 
    -0.02069052f, -0.01411134f, 0.00856178f, -0.07938558f, 0.15248369f, 0.26863986f, -0.12534767f, -0.18021251f, 
    -0.08353937f, -0.20784454f, -0.04256105f, -0.04939622f, 0.09249333f, -0.09799283f, -0.01176572f, 0.05406497f, 
    -0.05443694f, 0.09428672f, -0.05397192f, -0.08209457f, -0.00656556f, 0.01111259f, -0.03857713f, 0.05251946f, 
    0.03121008f, -0.06808711f, -0.07454553f, -0.04885716f, -0.18728454f, 0.07996324f, -0.03787810f, -0.45580277f, 
    0.05190479f, -0.09909804f, -0.13549748f, 0.05022836f, -0.03272841f, -0.09386150f, -0.01877392f, -0.03141855f, 
    0.30391210f, 0.03818491f, -0.06949533f, 0.05791326f, 0.05288885f, -0.02361674f, 0.10428251f, 0.03873623f, 
    -0.03773533f, 0.02943511f, 0.06502455f, 0.03466726f, 0.16001652f, 0.06720757f, 0.07305875f, -0.02533803f, 
    -0.17936353f, -0.18397146f, 0.15004927f, -0.04897028f, 0.00268571f, -0.04691029f, -0.01832005f, -0.06923038f, 
    -0.59768981f, 0.11394577f, 0.03249079f, 0.12221389f, -0.06679818f, 0.13003857f, -0.04127942f, 0.04947611f, 
    -0.08151522f, 0.06779253f, 0.03824988f, 0.02499769f, 0.07015057f, 0.04477677f, -0.27336779f, 0.16094460f, 
    0.02100704f, 0.03044691f, -0.03481774f, 0.00474684f, 0.04393423f, -0.00980318f, 0.02274314f, -0.05914776f, 
    -0.01105279f, -0.10122743f, -0.07081785f, 0.11376910f, 0.01789133f, 0.07244848f, 0.02663680f, 0.16067068f, 
    -0.08572257f, 0.02705042f, 0.08147575f, -0.00260477f, 0.04113177f, 0.14138122f, -0.14021385f, -0.01702538f, 
    0.09709357f, 0.15203790f, 0.06589077f, -0.02075407f, 0.03855346f, -0.00059462f, 0.06273533f, -0.05924766f, 
    0.00935500f, 0.17984232f, 0.09660784f, 0.04176762f, -0.03479465f, -0.02101134f, -0.01928928f, 0.01075670f, 
    -0.05748618f, -0.05486893f, -0.06723038f, -0.02875920f, 0.03594194f, -0.09804940f, -0.11950278f, -0.01960726f, 
    -0.07322159f, -0.01154840f, -0.00760353f, -0.22653468f, -0.01957063f, 0.03269411f, -0.00485343f, 0.04301983f, 
    -0.15924942f, -0.33531743f, 0.24289842f, -0.05794397f, 0.01891389f, -0.11132244f, 0.13751552f, -0.09110998f, 
    0.13379486f, -0.04255239f, 0.01714035f, -0.08012643f, -0.26732680f, -0.01635738f, -0.08229879f, -0.21237239f, 
    -0.02230988f, -0.06073102f, -0.00382829f, -0.05187649f, -0.12117630f, 0.06343992f, 0.02442522f, -0.01305690f, 
    0.19516422f, -0.01942381f, 0.01607088f, 0.11036742f, 0.03979170f, -0.15568736f, 0.03552901f, 0.13885798f, 
    -0.02020591f, -0.08175819f, -0.03114401f, -0.05886466f, -0.31548774f, -0.16880496f, -0.12007191f, 0.08693862f, 
    0.04626667f, -0.14259829f, 0.04770588f, 0.12951829f, 0.05922763f, -0.06103133f, -0.01913331f, 0.07247651f, 
    -0.09402613f, -0.09105017f, 0.04407604f, 0.07823434f, -0.10608187f, 0.08309395f, -0.02286554f, 0.07404369f, 
    0.10177372f, 0.09069326f, -0.08947614f, 0.04991425f, -0.58177716f, 0.04359828f, -0.07712086f, -0.02053747f, 
    0.06243103f, -0.05066173f, -0.00103629f, -0.01679834f, 0.10808627f, 0.02736552f, -0.04703572f, -0.04442283f, 
    -0.05188932f, -0.21875672f, -0.03744494f, 0.02792631f, -0.11914787f, 0.12230445f, 0.07144521f, -0.13758571f, 
    0.05653060f, -0.08395539f, -0.08738977f, -0.17000611f, -0.10486976f, -0.12126908f, -0.00687129f, 0.18108454f, 
    0.03925699f, -0.05929654f, 0.04886689f, 0.06610844f, -0.07172351f, 0.01368006f, 0.07474689f, 0.02586003f, 
    -0.12595889f, 0.07148999f, 0.17207089f, 0.01944810f, 0.07067806f, -0.03848073f, -0.13127449f, -0.08982479f, 
    0.12146199f, -0.10533845f, -0.09988550f, -0.11453976f, -0.16681734f, 0.03565490f, 0.12849812f, 0.20820752f, 
    -0.04281624f, -0.08319169f, 0.06258650f, -0.02145048f, 0.10476373f, -0.00156047f, 0.04948383f, -0.00135657f, 
    -0.04295058f, -0.10865480f, 0.15229034f, 0.13848063f, -0.00141512f, -0.07641096f, 0.03733651f, 0.05449943f, 
    -0.00656614f, 0.07319810f, 0.08354320f, 0.00057445f, -0.04922888f, -0.07263651f, 0.18611722f, 0.03381816f, 
    -0.07035906f, -0.06695482f, -0.06475589f, -0.07932467f, 0.08039564f, -0.02941524f, 0.05787057f, -0.02190003f, 
    -0.44756684f, 0.03338258f, 0.03164896f, 0.03060271f, 0.01513559f, -0.04903471f, 0.01225364f, 0.04743605f, 
    -0.07203919f, 0.01344766f, -0.03727821f, 0.11686138f, -0.01500626f, 0.13416898f, 0.07116397f, 0.04529880f, 
    -0.06315341f, -0.03137562f, -0.03203873f, 0.11070425f, 0.00568153f, 0.01098848f, -0.03307707f, 0.04012126f, 
    0.02323079f, -0.17504595f, 0.08267150f, 0.03072296f, 0.08748086f, 0.08233216f, -0.05876398f, 0.01357697f, 
    0.06564898f, -0.03479972f, 0.00534952f, -0.02415240f, -0.35160592f, -0.04955365f, -0.15452546f, -0.08243982f, 
    0.02881660f, -0.03298917f, 0.02587535f, 0.02880610f, -0.03706858f, -0.04776815f, 0.03864833f, 0.08273159f, 
    -0.12855026f, -0.03475991f, -0.21159109f, 0.19197702f, 0.01513235f, -0.00955516f, 0.06321568f, -0.02917059f, 
    0.05389414f, 0.11629009f, -0.02853839f, 0.04740988f, 0.44960219f, 0.21472515f, -0.15029167f, -0.22914515f, 
    0.01384980f, 0.04857423f, -0.06001231f, -0.01389016f, -0.07517789f, -0.01684473f, -0.03376697f, -0.00037705f, 
    -0.25217927f, 0.11565001f, 0.23677400f, 0.00893941f, -0.09900703f, 0.02770691f, -0.02964746f, -0.02701016f, 
    -0.07169509f, -0.05863998f, 0.08816566f, 0.06876984f, -0.21102113f, -0.15184854f, 0.06294557f, 0.06798988f, 
    0.03447209f, -0.03727849f, 0.04143520f, 0.03450134f, 0.02358143f, -0.01502114f, -0.07567730f, 0.04841242f, 
    -0.03828137f, 0.09513228f, 0.14308855f, 0.08770628f, 0.06960810f, -0.02298632f, -0.00048045f, 0.01909722f, 
    0.05976062f, 0.05571688f, 0.01942831f, -0.05554920f, 0.07391811f, -0.03795198f, 0.06175107f, 0.04726955f, 
    -0.01844709f, -0.06178090f, 0.07991342f, -0.00539591f, 0.11915319f, 0.03661989f, -0.04356421f, -0.07210590f, 
    -0.02637771f, -0.03822109f, 0.00707970f, -0.06332172f, -0.04194112f, -0.01876536f, 0.08150294f, -0.10352481f, 
    -0.01516214f, -0.02550343f, 0.02223158f, -0.09730393f, -0.24799794f, 0.14852981f, 0.01520052f, -0.11239896f, 
    -0.05156203f, -0.00052938f, 0.01437049f, 0.03843394f, 0.04598211f, 0.04939156f, -0.05286302f, -0.12795790f, 
    -0.09097239f, 0.05000459f, 0.08933480f, 0.09883676f, -0.05459255f, -0.01975092f, -0.01680856f, -0.02625226f, 
    0.01410442f, -0.07271061f, -0.08001731f, 0.05250167f, -0.11394840f, -0.01526905f, 0.00535147f, 0.00474684f, 
    -0.19810303f, 0.09865872f, -0.19927546f, -0.10468839f, 0.09101564f, 0.06282596f, 0.04939037f, -0.05230809f, 
    -0.51294231f, 0.17921643f, -0.03215498f, 0.06263894f, 0.15039837f, -0.00781461f, 0.06086935f, 0.01456521f, 
    -0.02076901f, -0.01388030f, 0.00228894f, 0.08049612f, -0.16842446f, -0.03243557f, -0.13344775f, -0.17948441f, 
    -0.06163017f, 0.00148802f, -0.07697429f, -0.05213198f, 0.01822666f, -0.10871480f, 0.01469086f, -0.00766641f, 
    -0.05391963f, -0.17936346f, -0.08677141f, 0.07751761f, -0.01805090f, -0.06359821f, 0.16470975f, -0.02317254f, 
    -0.02122375f, 0.03542346f, 0.00420186f, 0.05344644f, -0.00638879f, -0.07123113f, 0.01399022f, 0.12109128f, 
    -0.06057853f, -0.03016544f, 0.07744090f, -0.04772861f, -0.05540736f, -0.02263393f, -0.05881235f, 0.03318116f, 
    -0.22172579f, -0.10238582f, 0.08167012f, 0.10677715f, 0.10203916f, -0.14145322f, 0.05705550f, -0.11931081f, 
    0.08540578f, 0.00468858f, -0.00042823f, -0.17792611f, -0.36719045f, -0.22857933f, 0.06100133f, -0.05539241f, 
    0.08708391f, -0.07247001f, 0.06744260f, -0.02730671f, -0.00725836f, -0.06841470f, -0.05514834f, 0.05843049f, 
    0.08544878f, -0.07468075f, -0.23925073f, 0.03897686f, 0.03503584f, 0.08163254f, 0.16455364f, 0.00025787f, 
    -0.09372451f, -0.08961397f, 0.06379381f, 0.13048847f, -0.04777306f, 0.09752651f, 0.19375783f, 0.06598418f, 
    -0.13029623f, -0.09883919f, 0.06385199f, -0.06972073f, 0.01962855f, -0.01463751f, 0.04425387f, -0.05111242f, 
    0.19196385f, 0.19220664f, 0.03493175f, 0.18749420f, -0.13685352f, 0.01011824f, 0.06748170f, -0.03177581f, 
    0.03007842f, 0.00477327f, -0.00717360f, -0.01455831f, -0.26304471f, 0.19696085f, 0.13908900f, -0.02308187f, 
    0.02862388f, -0.02793570f, 0.01107716f, -0.01345074f, 0.06187202f, 0.02105931f, 0.00734708f, -0.09654333f, 
    0.02900490f, 0.05359659f, 0.07927506f, 0.11535592f, -0.09534911f, 0.06650094f, -0.03602583f, -0.06547537f, 
    0.05165220f, 0.03602181f, 0.08782817f, -0.01113843f, 0.06683797f, -0.12819444f, 0.10639092f, -0.04468839f, 
    -0.02849363f, 0.10783631f, 0.00726055f, 0.04902930f, 0.05878248f, -0.09649698f, -0.11172312f, 0.03102574f, 
    0.21542010f, -0.12613642f, -0.01893133f, -0.00115066f, -0.00631477f, -0.14989844f, -0.09178752f, -0.04929516f, 
    0.09787759f, -0.04696256f, -0.04432353f, 0.03458894f, -0.27406594f, -0.21769059f, -0.00482942f, -0.02326466f, 
    0.00536704f, 0.04483644f, -0.04414592f, -0.04027148f, 0.01199068f, 0.04240586f, 0.14123371f, -0.01077916f, 
    -0.09251270f, -0.00024610f, -0.11885373f, -0.12899080f, 0.06887522f, -0.17258945f, -0.09899062f, 0.04206527f, 
    0.07335123f, 0.21107091f, 0.10782205f, -0.04372490f, -0.05728135f, 0.07834847f, -0.00012469f, 0.09729277f, 
    0.05282563f, 0.03609341f, 0.01283117f, 0.01442320f, -0.07890899f, 0.09705091f, 0.01432226f, 0.03463713f, 
    -0.16376787f, -0.37062144f, 0.20771569f, 0.21385576f, -0.01214983f, -0.14244984f, 0.06072927f, -0.06076514f, 
    -0.01151418f, -0.00079916f, -0.08298383f, -0.01761856f, -0.03532489f, -0.04180447f, 0.01377809f, 0.40310168f, 
    -0.11809096f, -0.10646974f, 0.04378710f, 0.00462044f, -0.12291697f, -0.06059610f, -0.01854401f, 0.06374002f, 
    -0.08972973f, 0.09681564f, -0.07699572f, -0.10649259f, 0.02964810f, 0.05964400f, -0.06529585f, -0.18282937f, 
    0.08393967f, -0.06219650f, 0.10583350f, -0.03867586f, 0.25866258f, 0.03528842f, -0.00801747f, -0.09507809f, 
    0.04542385f, 0.06870115f, -0.02392680f, 0.11074784f, 0.03909175f, 0.04505669f, 0.15460835f, -0.19896246f, 
    -0.27206686f, -0.10975455f, -0.07001498f, -0.02617308f, 0.17584307f, 0.00081707f, 0.09543106f, 0.10285771f, 
    0.13727297f, -0.03304585f, 0.14381951f, -0.09340545f, -0.05322380f, 0.02578744f, 0.25410911f, 0.15985258f, 
    -0.00148780f, 0.16322394f, 0.06693616f, 0.05951596f, 0.18202884f, 0.06955826f, 0.05354794f, -0.13612813f, 
    0.06645223f, 0.03563342f, -0.07614633f, 0.18835622f, -0.03776816f, -0.12653783f, 0.11059042f, 0.13176323f, 
    -0.04770150f, 0.11101642f, -0.03597963f, 0.07059076f, -0.07878486f, -0.02773576f, 0.19798413f, 0.07785819f, 
    -0.09532520f, -0.00388292f, 0.04971603f, -0.08220519f, 0.04816297f, -0.09051102f, -0.01232965f, -0.09488787f, 
    -0.15515237f, -0.14533399f, -0.22653389f, 0.05523067f, 0.00122731f, -0.02533265f, -0.00976211f, -0.08970793f, 
    0.14498068f, -0.04132848f, -0.06592923f, 0.09669043f, -0.49614009f, -0.11643318f, -0.18725169f, -0.21544248f, 
    0.00878122f, 0.15737903f, 0.08808027f, -0.07796946f, 0.02662716f, 0.05364998f, 0.04201460f, -0.10294046f, 
    0.03800201f, -0.08572308f, 0.27651858f, 0.11066324f, 0.07117676f, 0.02407377f, 0.00008983f, -0.12392624f, 
    0.12996036f, -0.00391227f, 0.05581847f, -0.03757551f, -0.07077282f, 0.03159254f, 0.08243846f, 0.10655633f, 
    0.12236029f, 0.05213811f, -0.02726958f, -0.07577115f, -0.10867237f, -0.12697574f, -0.00592739f, -0.22597517f, 
    0.01568233f, 0.01675200f, 0.14879028f, -0.05355952f, 0.00301427f, 0.06062697f, 0.05548603f, 0.04976971f, 
    0.01662361f, 0.05020902f, 0.10864521f, 0.11179674f, -0.37247822f, 0.02379703f, 0.09066042f, 0.24693477f, 
    -0.08835714f, 0.07065613f, 0.03742481f, 0.13145101f, 0.03231334f, 0.11588052f, -0.05616287f, 0.03845616f, 
    0.04018114f, 0.10322642f, 0.18093646f, -0.10409785f, -0.09668709f, -0.01334664f, -0.03777685f, -0.14063397f, 
    0.01018083f, 0.02531195f, 0.03129835f, 0.06858046f, 0.02998026f, 0.00292543f, -0.06582347f, -0.06575935f, 
    0.13604090f, 0.13567849f, -0.04261803f, -0.10119396f, -0.01178023f, 0.07942970f, -0.02852959f, 0.12257897f, 
    -0.19989921f, -0.14753217f, -0.09210945f, -0.10982721f, -0.05431300f, -0.00061530f, -0.06800896f, -0.01576492f, 
    0.01519337f, -0.03644981f, -0.07608414f, -0.02967418f, 0.13296586f, 0.09520107f, -0.00650702f, -0.13942949f, 
    0.07241318f, 0.11478524f, -0.10516749f, -0.18954664f, 0.00861144f, 0.13462916f, -0.03155948f, 0.07303473f, 
    -0.10549193f, -0.05598890f, -0.10143284f, 0.03553537f, 0.03217885f, -0.00236896f, 0.16327274f, -0.13688381f, 
    -0.10264645f, -0.05552623f, -0.07652959f, -0.18232918f, -0.27299333f, -0.18073940f, -0.03051699f, -0.14704652f, 
    0.04125856f, -0.08152681f, 0.07960613f, 0.05734748f, -0.01238299f, 0.12063680f, -0.05072923f, -0.02155325f, 
    -0.01763958f, -0.02089241f, -0.12774754f, 0.07690913f, 0.01550678f, -0.07258584f, -0.03420588f, 0.11829238f, 
    0.15111277f, 0.19785386f, 0.10275095f, 0.11750064f, 0.02307366f, 0.16968322f, -0.02474570f, 0.18108174f, 
    -0.01363802f, -0.22911121f, 0.12439207f, -0.03392248f, 0.05910494f, -0.05406500f, 0.08698884f, -0.04182059f, 
    -0.10514424f, 0.16216591f, -0.02076675f, 0.12290747f, -0.07094876f, 0.08283706f, -0.02699464f, 0.14691256f, 
    -0.02097216f, 0.04908344f, 0.06727345f, 0.04013554f, -0.25381705f, 0.08130784f, 0.04711955f, -0.41401780f, 
    0.05269720f, 0.03457157f, -0.09836254f, 0.06981231f, 0.08012722f, 0.04526099f, -0.01293178f, -0.07381888f, 
    -0.35270941f, -0.22820047f, -0.11282443f, -0.07537892f, 0.06973840f, 0.18209577f, -0.05320315f, 0.04085075f, 
    0.07680444f, 0.00369406f, 0.03459930f, 0.01696627f, 0.13007428f, 0.04873680f, 0.13203196f, -0.02905286f, 
    0.08354212f, 0.06625854f, 0.05420423f, 0.03942116f, -0.06608073f, -0.06567323f, -0.00269005f, 0.05653021f, 
    -0.08404548f, 0.00368489f, 0.04335622f, 0.08344608f, 0.03664766f, 0.04312335f, 0.00130552f, -0.05335768f, 
    0.03293516f, -0.14260352f, -0.12278634f, 0.01090915f, -0.76090658f, 0.00463747f, 0.00676105f, -0.22945414f, 
    0.02995750f, 0.15266235f, 0.03145311f, -0.09816245f, -0.01779031f, 0.02588985f, 0.06113463f, -0.02796572f, 
    -0.03944001f, 0.11331165f, 0.24368824f, -0.04011372f, -0.12989847f, -0.01875085f, -0.04011222f, 0.00487720f, 
    0.00248541f, -0.11915841f, 0.02666065f, 0.05785284f, 0.15199955f, -0.11246716f, -0.06813161f, 0.12469820f, 
    0.17239526f, 0.18099542f, 0.03519483f, -0.03398185f, 0.09813547f, -0.05777857f, 0.03788609f, -0.22638051f, 
    -0.13212721f, 0.01278684f, -0.04001629f, 0.17559366f, -0.01389246f, 0.05217439f, 0.08528899f, -0.00546500f, 
    -0.11532761f, 0.01543130f, 0.04604069f, 0.05012348f, 0.04756889f, -0.10962020f, -0.29793066f, -0.03128017f, 
    0.09091298f, 0.06049957f, -0.06549019f, -0.08096580f, 0.02664989f, 0.03154606f, -0.01267728f, 0.09404061f, 
    0.32971874f, -0.18041818f, -0.05751614f, -0.08311392f, 0.03631241f, 0.10396269f, -0.13372542f, -0.03566124f, 
    -0.03180192f, -0.09845879f, -0.03629478f, 0.03114522f, 0.22990529f, -0.03903256f, -0.12674162f, -0.04278129f, 
    -0.11495277f, 0.00204733f, -0.09224375f, -0.12212170f, -0.02083337f, -0.08448058f, 0.02277953f, -0.07327733f, 
    -0.13564257f, -0.01017854f, 0.12589520f, -0.05936059f, 0.02660676f, -0.19379380f, 0.03332298f, -0.07285824f, 
    0.00038868f, -0.13939342f, 0.03757738f, -0.25111529f, 0.17251332f, -0.01121565f, 0.05374296f, 0.02287629f, 
    -0.01537619f, 0.03214226f, -0.01727981f, -0.09026366f, -0.02948102f, 0.04232405f, 0.04766060f, -0.06676363f, 
    0.07195523f, -0.00654842f, -0.02302452f, -0.14515187f, 0.12453102f, -0.06291618f, 0.07890014f, -0.03384512f, 
    0.02189969f, 0.05626230f, -0.05881460f, -0.11289187f, -0.30584216f, 0.19402184f, 0.06365670f, -0.13075051f, 
    0.10051144f, 0.03614162f, 0.20773931f, -0.20413479f, 0.06157999f, 0.04782616f, -0.19731520f, 0.12998721f, 
    -0.13701004f, 0.04709486f, -0.13113074f, -0.39256567f, 0.04416171f, -0.07541972f, -0.00277846f, -0.10569856f, 
    0.03418503f, -0.04680524f, -0.12773369f, 0.02479170f, -0.24264005f, -0.07651692f, -0.01822300f, 0.07811356f, 
    -0.01108537f, -0.10025389f, 0.04878305f, 0.07756219f, 0.03832343f, -0.09689310f, -0.00664803f, -0.01046290f, 
    -0.04951079f, -0.07446139f, 0.00715692f, 0.22690058f, -0.12439918f, -0.00950615f, 0.06524736f, -0.07831138f, 
    -0.06462689f, -0.18444790f, -0.00514595f, 0.13237678f, -0.49485391f, -0.04897286f, -0.06152703f, -0.02253369f, 
    0.02944773f, -0.08408724f, 0.14042924f, 0.06251851f, 0.15093477f, 0.08306409f, 0.08204431f, -0.09287827f, 
    0.10483763f, -0.06415945f, -0.04405577f, -0.02195349f, -0.08212076f, 0.07170934f, -0.04600092f, -0.02975178f, 
    -0.06775357f, 0.00430519f, 0.15372865f, 0.12926854f, 0.05761459f, -0.07253660f, 0.11438986f, 0.05602184f, 
    -0.07372098f, -0.05269608f, 0.10320281f, 0.01454733f, -0.02767929f, 0.05116162f, 0.03644380f, 0.03900815f, 
    -0.06758107f, 0.20049433f, 0.13809112f, -0.03423669f, 0.08499187f, 0.02137076f, -0.09949698f, 0.02860742f, 
    -0.03458859f, -0.03952412f, -0.06612816f, 0.03980305f, -0.02140524f, -0.13473961f, 0.01673248f, -0.11032154f, 
    0.01526609f, 0.01610930f, 0.10208569f, 0.06445117f, 0.09308091f, -0.04882904f, 0.04888740f, -0.00199868f, 
    0.04051020f, -0.06981449f, -0.00666613f, -0.06932473f, 0.01030187f, -0.04953028f, 0.04790109f, 0.05245018f, 
    -0.06808868f, -0.15863812f, 0.02517709f, 0.13481121f, -0.08545350f, 0.13667768f, 0.00890177f, 0.21232769f, 
    -0.00626872f, 0.00136557f, 0.01857790f, -0.03547101f, 0.03707536f, -0.15041897f, -0.01613907f, 0.05922118f, 
    -0.53262007f, 0.07657273f, 0.02299292f, -0.08249432f, -0.00020561f, 0.00514170f, -0.07526430f, 0.01355282f, 
    -0.01371338f, 0.00051488f, -0.03905435f, 0.02562446f, -0.11720254f, -0.01348446f, -0.05300185f, -0.05919852f, 
    0.09550041f, 0.08847532f, 0.24608690f, -0.03321982f, 0.04762748f, 0.02758552f, -0.03102435f, -0.08631086f, 
    0.05102780f, -0.01002788f, -0.05281613f, 0.01784451f, 0.10015981f, 0.17395523f, -0.03524048f, 0.04874508f, 
    0.04093432f, -0.13207468f, -0.04839243f, -0.06543654f, 0.12026818f, -0.03863711f, 0.02947553f, 0.01931724f, 
    -0.06861896f, -0.04994816f, -0.01308854f, -0.05799938f, -0.08026852f, -0.07098071f, -0.05997208f, 0.23766799f, 
    0.13752200f, -0.02607760f, 0.09776361f, -0.07248028f, 0.03713444f, -0.00509792f, -0.09641271f, -0.04841936f, 
    -0.17755826f, -0.03532429f, 0.04244129f, 0.20591947f, 0.22101037f, 0.03591102f, 0.05277885f, 0.10317330f, 
    -0.18793781f, -0.04409333f, -0.09122059f, 0.17826633f, 0.04680408f, -0.02621019f, 0.05038388f, -0.06715961f, 
    -0.11934841f, 0.23126201f, 0.11979629f, -0.37016559f, -0.04139499f, -0.11469422f, 0.03489469f, -0.01670545f, 
    0.09929450f, -0.04612957f, -0.07073949f, -0.10621658f, 0.05253664f, -0.04249436f, 0.06497918f, 0.16575772f, 
    -0.10755137f, -0.02229032f, 0.00722396f, 0.09161253f, 0.09491005f, 0.14409205f, 0.03334991f, 0.03516834f, 
    -0.23201375f, -0.13470823f, -0.05156358f, -0.01425376f, 0.11296289f, -0.19756681f, -0.13873568f, -0.10220335f, 
    -0.00414122f, 0.08402970f, -0.01879210f, 0.10559623f, -0.04818929f, -0.17063174f, 0.07004450f, -0.02300249f, 
    0.00120012f, 0.06863959f, 0.02943200f, 0.00414316f, -0.00159284f, 0.02577998f, 0.02201016f, 0.05366940f, 
    -0.00511064f, -0.13511807f, -0.14253356f, 0.02127697f, 0.14394675f, -0.23099016f, -0.08910539f, -0.03258879f, 
    0.02845106f, 0.01233920f, -0.15109721f, 0.00533742f, -0.10598690f, -0.02112122f, 0.15793604f, 0.21182971f, 
    0.09290983f, -0.07117692f, -0.03916701f, -0.02414336f, -0.06317817f, -0.00585639f, 0.11784085f, -0.00082634f, 
    -0.36252168f, 0.11710578f, -0.03559348f, 0.08518940f, -0.07976367f, 0.01954518f, 0.04129806f, -0.05357483f, 
    -0.09937537f, 0.00949205f, 0.07795154f, -0.02683068f, -0.04701493f, -0.04732819f, -0.08574004f, 0.08856219f, 
    0.00220007f, 0.06539766f, 0.11473248f, 0.10380313f, -0.03939272f, -0.06525806f, -0.17110911f, 0.04157753f, 
    -0.05657678f, -0.05347840f, -0.01194117f, -0.23277307f, 0.06927542f, 0.07132710f, 0.01846735f, 0.12932418f, 
    -0.04987322f, 0.02709610f, -0.03077790f, 0.00932962f, 0.26558527f, 0.03797951f, -0.03065718f, 0.09662085f, 
    -0.15664439f, -0.03089663f, 0.07747909f, 0.05069542f, 0.11582289f, -0.04533708f, 0.02720940f, -0.02168486f, 
    0.19329658f, -0.20141229f, -0.08145405f, 0.06562733f, -0.10580204f, 0.02676741f, -0.04052565f, -0.03046556f, 
    -0.14718506f, 0.04876655f, 0.02374667f, 0.04295149f, 0.03122824f, -0.09358426f, -0.02563203f, -0.07305951f, 
    0.00001689f, -0.05270181f, -0.09756228f, -0.05897585f, 0.02838657f, -0.09688044f, -0.03178932f, 0.02258479f, 
    0.14467804f, -0.29720590f, -0.18793188f, 0.12597261f, -0.09953524f, 0.02915587f, -0.00957864f, -0.03581150f, 
    -0.06707210f, 0.05157671f, -0.07410824f, 0.06143710f, 0.02415294f, 0.01597242f, 0.08669052f, -0.02264237f, 
    -0.03694139f, -0.06746840f, 0.01625406f, -0.04871929f, -0.00714187f, 0.03799285f, -0.03656652f, 0.12912808f, 
    -0.09385146f, -0.01000953f, 0.04386839f, -0.30551773f, -0.04452761f, -0.07292724f, 0.06596843f, -0.32648826f, 
    -0.09780611f, -0.03165137f, 0.07252762f, -0.01161102f, -0.00896242f, 0.00890559f, -0.19355835f, 0.11616489f, 
    0.00874663f, -0.00552516f, -0.05601102f, -0.03738052f, -0.05676030f, 0.03919991f, -0.09396036f, -0.03851385f, 
    0.03936645f, 0.15823333f, 0.08528016f, -0.38874146f, 0.00063888f, 0.09630451f, -0.07535535f, 0.06785955f, 
    0.11363346f, -0.07030655f, -0.05719840f, 0.05554326f, -0.00129450f, -0.18572992f, 0.02248489f, -0.05141094f, 
    0.03766354f, 0.02666410f, 0.06066484f, -0.04528082f, -0.14186698f, 0.00615131f, 0.03992316f, 0.10283768f, 
    -0.15789630f, 0.11339872f, -0.12516393f, -0.16272956f, 0.05325608f, -0.08605959f, 0.10440981f, -0.01762095f, 
    -0.02445060f, -0.00477193f, -0.08335489f, -0.18016994f, 0.09920896f, -0.03522732f, -0.09707569f, -0.16967779f, 
    -0.05779385f, 0.01696268f, -0.04059279f, -0.14625315f, -0.01130912f, 0.03740489f, -0.02343338f, 0.09708519f, 
    -0.02665563f, -0.21405078f, -0.04604464f, 0.22320120f, 0.07333552f, 0.03772422f, -0.00581086f, 0.07301968f, 
    0.07217216f, -0.14823082f, -0.20215921f, 0.05661666f, 0.17791168f, -0.23809183f, -0.02275077f, 0.01192898f, 
    -0.04011468f, 0.09225085f, -0.02811031f, -0.00390878f, 0.08269736f, 0.18173379f, 0.07892238f, 0.08176914f, 
    0.16016540f, 0.10159849f, 0.07587357f, -0.39075387f, -0.09582841f, -0.03224701f, -0.05952286f, -0.00777770f, 
    0.10607675f, -0.01714775f, -0.03596977f, -0.14060295f, 0.14434311f, -0.14169376f, -0.04398724f, 0.08106004f, 
    0.17129233f, 0.02860510f, -0.00992892f, -0.07292343f, -0.15798418f, 0.03347087f, 0.08531486f, -0.05878591f, 
    -0.30191264f, 0.20517062f, 0.17708674f, -0.17401460f, -0.04045263f, -0.04268812f, 0.08455142f, 0.12345791f, 
    -0.01060014f, -0.00680467f, -0.06049094f, 0.02386105f, -0.62624770f, 0.29603079f, 0.03281857f, -0.01702845f, 
    -0.15614331f, 0.09698468f, 0.03328444f, 0.04366474f, 0.06119408f, -0.09261911f, 0.03508124f, -0.16381460f, 
    0.10252785f, -0.21138130f, 0.09044439f, -0.20234503f, 0.02872770f, 0.02123743f, 0.02406405f, -0.01945413f, 
    0.08551995f, -0.08312424f, 0.18214637f, 0.09889504f, -0.16584486f, 0.04423581f, -0.11138264f, 0.19198850f, 
    -0.17004828f, -0.00681197f, 0.06697714f, -0.14869611f, 0.03735945f, -0.09771850f, 0.00798445f, 0.05312098f, 
    -0.19935547f, 0.03919821f, -0.01639134f, -0.24191760f, 0.01445903f, -0.00636297f, -0.18044214f, -0.05508599f, 
    -0.14328830f, 0.05110429f, 0.13589422f, 0.20424367f, -0.11864429f, 0.04637256f, 0.05164682f, -0.04016846f, 
    0.05882388f, 0.15102002f, 0.09411418f, 0.02085030f, -0.08666926f, 0.04384587f, 0.01072841f, -0.02459469f, 
    -0.22569411f, -0.12020186f, -0.09954970f, 0.03739360f, 0.01115221f, 0.09473041f, 0.00490381f, -0.11051706f, 
    0.03484595f, -0.16553843f, 0.03459051f, -0.00313569f, -0.12585385f, -0.25276703f, 0.06991362f, 0.32559383f, 
    0.05519415f, 0.13346773f, -0.01680396f, 0.04646794f, 0.05622377f, -0.10865675f, -0.11299691f, 0.00826493f, 
    -0.17560339f, -0.02802295f, -0.07218719f, 0.07804487f, 0.12938647f, -0.10684051f, 0.04283106f, -0.01354590f, 
    -0.07343132f, 0.05538921f, -0.06642395f, -0.05759241f, 0.43801498f, -0.14351481f, 0.06179493f, 0.15848297f, 
    0.03414048f, 0.17253733f, 0.14796230f, -0.01192925f, 0.14052901f, -0.07749394f, 0.04954754f, 0.02969646f, 
    -0.12272534f, 0.06961358f, 0.05075043f, -0.30733892f, -0.09534751f, -0.06204239f, -0.01492776f, -0.15392312f, 
    0.03074992f, 0.04600987f, 0.05624147f, -0.01684506f, 0.04311837f, 0.05463373f, 0.03441970f, -0.16362591f, 
    -0.09920717f, -0.01379948f, 0.02360119f, 0.02265118f, 0.02494259f, 0.02021945f, -0.06735038f, -0.07842300f, 
    -0.19560370f, 0.26674885f, 0.04877602f, -0.04199858f, 0.04021669f, -0.03775198f, 0.03184456f, 0.08964233f, 
    -0.03077568f, 0.18876570f, 0.09861025f, 0.05638727f, -0.02742275f, -0.36299014f, 0.06128455f, -0.09608484f, 
    -0.10502739f, 0.09587020f, -0.00251045f, 0.04018498f, 0.05368101f, 0.04859596f, -0.09849918f, -0.06633720f, 
    -0.04961017f, 0.23569840f, 0.03046783f, 0.05653901f, 0.05871757f, 0.17271753f, -0.05506556f, 0.00515769f, 
    0.03479761f, 0.10858881f, -0.03973944f, -0.04493799f, -0.00468114f, 0.02132298f, -0.19122338f, -0.27566496f, 
    -0.13749146f, -0.08451647f, -0.03804625f, -0.07001261f, -0.01436135f, 0.12615322f, -0.03295337f, 0.03682417f, 
    -0.15722756f, 0.08255123f, -0.01365745f, -0.08783895f, 0.03089665f, -0.14506131f, -0.01999203f, 0.01306208f, 
    0.05268665f, -0.00019110f, 0.14116640f, -0.07251462f, -0.08250201f, 0.06707221f, -0.20383787f, -0.07788266f, 
    -0.05202106f, -0.04050256f, 0.09768379f, -0.02223799f, 0.06913864f, -0.08952942f, 0.10300418f, 0.15562139f, 
    -0.25978583f, -0.03208099f, -0.34676468f, 0.05449154f, 0.07530940f, 0.10358105f, 0.13562596f, -0.07692815f, 
    -0.05708598f, 0.12142713f, 0.01689694f, 0.12000608f, -0.39947766f, 0.06440830f, 0.11483264f, 0.20241101f, 
    0.06332655f, -0.04038016f, 0.04713924f, 0.07475103f, 0.04024966f, -0.00683849f, 0.08146524f, -0.06067757f, 
    0.10247751f, -0.27928960f, 0.05717206f, -0.02345066f, 0.05883736f, -0.01709595f, 0.05307864f, 0.08643112f, 
    0.10945781f, -0.00370010f, 0.09295206f, 0.16245033f, -0.22791202f, 0.09333685f, 0.13393135f, 0.23079154f, 
    -0.02662015f, -0.05511235f, 0.09685033f, -0.00233232f, 0.00713595f, -0.01692200f, -0.08505057f, 0.05746747f, 
    -0.24842568f, 0.11715692f, -0.04750102f, 0.13530886f, 0.00679446f, 0.21128672f, -0.07045200f, 0.10004579f, 
    0.04654842f, 0.03916607f, -0.00249170f, -0.06722655f, 0.10735980f, -0.51829588f, 0.00838474f, -0.07026226f, 
    -0.03526336f, 0.04421369f, -0.09294569f, 0.09915727f, 0.03902287f, 0.01647817f, 0.10164103f, -0.03002822f, 
    -0.00902166f, -0.02350649f, 0.09620103f, -0.02988621f, 0.00551648f, 0.03251110f, 0.02089380f, 0.10225075f, 
    -0.01253825f, 0.02133390f, 0.07596438f, -0.03694450f, 0.09159093f, -0.09361774f, -0.05430472f, 0.32009739f, 
    -0.03005099f, 0.02956753f, -0.01266183f, 0.06472442f, -0.05333129f, 0.04434516f, 0.03536672f, 0.00937452f, 
    0.06768499f, -0.09568554f, -0.13378350f, -0.11287319f, -0.00268692f, 0.03263228f, -0.00764107f, 0.05602124f, 
    0.07945146f, -0.02584924f, -0.00109633f, 0.01102705f, 0.01861153f, -0.01975691f, -0.06728955f, 0.14446034f, 
    0.02770091f, 0.10455769f, -0.00062537f, -0.08489572f, -0.10998271f, 0.07923931f, -0.02149349f, -0.06842321f, 
    0.12787887f, 0.12754491f, 0.25321153f, -0.36945093f, 0.03295283f, 0.02136678f, 0.06863209f, 0.07418633f, 
    0.01310499f, -0.09382812f, -0.12528566f, -0.12396083f, -0.14844665f, -0.13578294f, -0.16773789f, 0.15316512f, 
    0.09458217f, 0.07777417f, -0.04069901f, 0.06750630f, -0.06259482f, -0.04845932f, 0.08644327f, -0.07519805f, 
    0.04557190f, 0.10873970f, -0.05841937f, 0.28615752f, -0.06014727f, 0.00907507f, -0.02238861f, 0.01603918f, 
    0.03601743f, 0.04439245f, 0.04258649f, -0.04707331f, 0.18424216f, 0.07194526f, 0.06686109f, -0.00009878f, 
    -0.06341233f, 0.02231740f, -0.00373203f, -0.15752435f, -0.07641491f, -0.07233661f, 0.06442451f, 0.06969954f, 
    -0.04008240f, 0.07629127f, 0.06167049f, 0.14381979f, 0.02805848f, -0.08725730f, 0.04920652f, -0.00220881f, 
    -0.09136711f, -0.02005798f, -0.10218856f, 0.08254449f, -0.27103376f, 0.18668255f, -0.05291059f, 0.03899261f, 
    -0.14856516f, 0.02470411f, -0.00227995f, 0.01863582f, 0.05287352f, 0.08518858f, -0.10858651f, -0.22339718f, 
    0.26271269f, -0.00919389f, 0.00985573f, -0.14082317f, 0.01816641f, -0.04698181f, 0.03333344f, 0.00723256f, 
    0.05610842f, 0.05093135f, 0.02822340f, -0.01104571f, -0.07846927f, -0.24518794f, -0.04579285f, -0.17691107f, 
    -0.00791207f, 0.02881365f, -0.05074167f, -0.04546242f, -0.02550418f, -0.01846749f, -0.04882824f, 0.00004643f, 
    0.05339856f, -0.11602677f, -0.08435758f, 0.26941323f, 0.04513918f, -0.04018833f, -0.12704770f, -0.00367978f, 
    0.01403144f, -0.05857135f, -0.02029452f, 0.04973342f, 0.01050513f, 0.16398168f, 0.15197487f, -0.17402989f, 
    -0.03990948f, 0.19173661f, 0.08255994f, -0.04324321f, 0.12367187f, 0.01723726f, 0.08183488f, -0.09207530f, 
    0.21948026f, 0.01473484f, -0.00064861f, -0.04458786f, -0.08058700f, -0.00620230f, 0.01577584f, -0.02432958f, 
    0.02217447f, -0.07960009f, 0.01369925f, -0.12596172f, 0.13170794f, 0.10464089f, 0.24260369f, -0.13916463f, 
    0.06204444f, -0.26524386f, 0.08208680f, 0.02298280f, 0.01683049f, -0.00592521f, 0.08977962f, -0.25479472f, 
    0.02694725f, -0.29019487f, 0.05402345f, -0.11993313f, -0.10291759f, -0.02971675f, -0.01734208f, 0.09432615f, 
    -0.00660998f, -0.06707141f, 0.12526557f, 0.10443331f, 0.07728100f, 0.01340799f, -0.01574116f, 0.01412144f, 
    0.11639156f, 0.00192074f, 0.10428385f, -0.05563266f, -0.09976692f, -0.01179550f, -0.09753650f, 0.00332727f, 
    -0.05252401f, -0.07096747f, -0.17408681f, 0.24151166f, -0.04562540f, -0.02063088f, 0.15193583f, -0.08389501f, 
    -0.08238663f, -0.09059230f, 0.00573083f, 0.03854382f, -0.02277111f, 0.04659497f, 0.07535347f, -0.01538155f, 
    0.08214491f, -0.02239486f, 0.01001027f, -0.04837048f, -0.15631653f, 0.09477352f, 0.02557157f, -0.06825501f, 
    -0.42563799f, -0.07934402f, -0.09666365f, 0.08464491f, -0.02432407f, -0.05457002f, 0.10324030f, 0.01904221f, 
    0.05661800f, -0.05865907f, 0.15289403f, 0.04911652f, 0.09427358f, -0.11802408f, -0.24514070f, 0.12077412f, 
    -0.10670273f, -0.07497295f, -0.01957363f, 0.07413653f, -0.13064159f, 0.05279690f, -0.09604494f, -0.07269413f, 
    0.02387850f, -0.01409591f, -0.15011038f, -0.05288430f, -0.01970152f, -0.02329935f, -0.07333025f, 0.00325112f, 
    0.00491655f, -0.06199863f, -0.02806155f, -0.04521856f, 0.19192107f, -0.03317469f, 0.03712099f, 0.07631595f, 
    0.05623184f, -0.01295079f, 0.02222177f, -0.01615008f, 0.00436261f, -0.05335776f, -0.00921651f, -0.06342594f, 
    0.02187547f, 0.11134839f, 0.08236152f, 0.09063804f, -0.08860199f, -0.01158818f, -0.03932351f, 0.00886578f, 
    -0.08212306f, -0.02148337f, -0.00390457f, -0.08628097f, 0.02907468f, -0.15809752f, 0.11333033f, 0.04554587f, 
    -0.10937005f, -0.00291885f, 0.00747086f, -0.00408826f, 0.03344398f, -0.00893966f, -0.03196846f, -0.02851107f, 
    0.04921395f, 0.16946173f, 0.05372545f, 0.13904311f, 0.13195422f, 0.03259181f, -0.00408730f, -0.01120371f, 
    -0.02389959f, 0.03515218f, -0.00891299f, -0.07425714f, 0.05986960f, -0.12466410f, 0.03793882f, 0.24308883f, 
    -0.04779962f, -0.10495659f, -0.07772880f, -0.02952642f, -0.05248543f, -0.04234106f, -0.04511330f, -0.03999295f, 
    -0.07481454f, 0.16312917f, 0.00670862f, 0.12700659f, 0.14768103f, -0.02261235f, 0.07656627f, 0.06998192f, 
    0.08090565f, 0.03449015f, 0.04466284f, -0.05253392f, -0.13105772f, 0.08415749f, -0.09263310f, -0.10801190f, 
    -0.06671061f, 0.00709859f, 0.05777637f, -0.10150518f, -0.02121147f, 0.02875324f, -0.02944681f, -0.05254055f, 
    0.10726620f, 0.00736777f, 0.15569836f, 0.05994285f, 0.10005895f, 0.09934311f, 0.02988014f, -0.05120604f, 
    -0.04932908f, 0.05918458f, 0.03670641f, -0.06011413f, -0.06462888f, -0.07817757f, -0.01829501f, -0.00124624f, 
    -0.02297537f, -0.08929614f, -0.07362457f, -0.02478325f, 0.03001214f, -0.01721874f, -0.01744225f, -0.06107934f, 
    -0.23195082f, -0.10785896f, -0.01934224f, 0.02669835f, -0.05797891f, -0.01399695f, -0.02470434f, 0.00255535f, 
    -0.03342642f, 0.01170281f, 0.03215620f, -0.01979746f, -0.17251176f, -0.09945769f, 0.05194067f, -0.13841809f, 
    0.05063213f, -0.03659956f, -0.07109133f, -0.07273356f, -0.02987108f, -0.03325778f, 0.03872918f, -0.00721045f, 
    0.10998164f, 0.11728216f, 0.14565043f, 0.22684966f, 0.11968057f, 0.07260139f, 0.00845747f, -0.04676998f, 
    0.00796136f, 0.02727322f, -0.04256569f, -0.03289712f, -0.16731432f, 0.17310780f, 0.15759806f, 0.11787850f, 
    0.06772546f, 0.02903406f, 0.08050164f, 0.01403111f, -0.03407354f, -0.03198114f, -0.00012748f, 0.01274255f, 
    -0.14947514f, 0.12088767f, -0.00928272f, 0.07469749f, -0.05568964f, -0.10445616f, 0.02085466f, -0.03167228f, 
    0.03116987f, 0.01026362f, 0.00590713f, 0.04857177f, -0.06420788f, -0.12378899f, 0.04346454f, -0.09431060f, 
    0.05197873f, 0.00582476f, -0.01038941f, -0.05412612f, 0.00669661f, 0.03360829f, -0.03724095f, -0.03459528f, 
    -0.26775226f, -0.03235637f, -0.18314737f, -0.14432271f, -0.02739159f, -0.01868788f, -0.04829991f, -0.07916775f, 
    -0.01032903f, 0.02251924f, 0.04585474f, -0.06786560f, 0.09388068f, 0.03918498f, 0.04121523f, 0.08058695f, 
    0.03588525f, 0.05143322f, -0.05685331f, -0.04052320f, 0.05718381f, -0.08996718f, -0.07224589f, 0.02969133f, 
    -0.14431921f, 0.01697361f, -0.01827708f, -0.08831514f, -0.06747723f, -0.01568127f, -0.03372080f, -0.05735586f, 
    -0.01738759f, -0.05060709f, -0.01800598f, -0.01309203f, -0.14955884f, 0.07380710f, -0.11855461f, -0.00194547f, 
    0.01474787f, 0.03755199f, -0.06307799f, -0.04711944f, -0.02147051f, -0.00516953f, 0.06547992f, -0.00192474f, 
    0.02994901f, 0.16176960f, 0.11877146f, -0.04811482f, -0.04285301f, 0.01368869f, 0.06328058f, -0.00859768f, 
    -0.08469904f, 0.07809795f, 0.00023467f, -0.11312385f, 0.19689657f, 0.20198315f, -0.14775306f, 0.07848767f, 
    -0.02725164f, 0.02829238f, 0.03207831f, 0.03013815f, -0.05841364f, 0.02101526f, 0.00594035f, 0.01867125f, 
    -0.10053296f, 0.11854080f, 0.02805178f, 0.12036650f, 0.02571848f, 0.04526405f, 0.07233223f, -0.04715405f, 
    -0.07503791f, -0.04841734f, 0.02285437f, -0.05568628f, -0.02931809f, -0.03422869f, 0.08638412f, -0.06278764f, 
    0.11535555f, -0.02301127f, -0.00780082f, -0.03620285f, -0.07780074f, 0.04213907f, 0.01807469f, -0.05095182f, 
    0.05593972f, 0.12762716f, -0.01441249f, 0.04403248f, -0.14266226f, -0.01874022f, -0.08914891f, -0.03733762f, 
    0.08488212f, -0.00483792f, -0.00358495f, -0.04334936f, -0.06838035f, 0.08552071f, -0.04766331f, 0.02929808f, 
    -0.11761688f, -0.02357429f, -0.05816769f, 0.01006944f, 0.00881383f, 0.01769529f, 0.00824010f, 0.00104850f, 
    0.11372724f, -0.14281517f, 0.02042975f, 0.07811095f, 0.09117884f, -0.08049277f, -0.02644579f, -0.10590509f, 
    -0.02431437f, -0.01391073f, 0.00114031f, -0.04406355f, 0.24545389f, -0.35748565f, 0.15749331f, -0.12655067f, 
    0.00497203f, 0.02286761f, -0.02733632f, -0.02980592f, -0.01813613f, 0.05101837f, 0.00926787f, -0.02549543f, 
    0.05910132f, 0.12446263f, 0.17944781f, 0.18730219f, 0.14559117f, 0.03704222f, 0.03527314f, -0.06150195f, 
    -0.02154035f, -0.03771869f, -0.03220816f, -0.03214472f, -0.05395820f, 0.01167685f, -0.09849273f, -0.03865373f, 
    -0.01338687f, -0.00162125f, 0.00672635f, -0.04100267f, -0.01195421f, -0.00099209f, 0.01525693f, -0.09115111f, 
    -0.36656675f, -0.01442018f, -0.09445880f, -0.18228778f, 0.05330196f, 0.00880774f, -0.00651644f, -0.03456330f, 
    -0.11455536f, -0.01357998f, 0.09970361f, -0.07299460f, -0.11643405f, -0.13344133f, 0.15488103f, -0.01784152f, 
    0.08155367f, 0.03439164f, 0.03447784f, -0.00489058f, -0.08737867f, 0.03822527f, -0.05009805f, -0.04190359f, 
    -0.34546527f, 0.21929057f, -0.11743661f, -0.17966594f, -0.05887920f, -0.01688066f, -0.03836977f, -0.03139345f, 
    -0.04397006f, 0.00010476f, 0.02996376f, -0.08235517f, 0.11833690f, 0.17450231f, 0.04564357f, 0.14974479f, 
    0.04060002f, 0.04140920f, 0.03174798f, 0.06177573f, -0.03493092f, -0.02543196f, 0.02072464f, -0.05168809f, 
    -0.03984219f, -0.19906420f, -0.10975958f, -0.03077428f, -0.08891793f, -0.01794314f, 0.05466453f, -0.04110625f, 
    -0.05571758f, -0.02260553f, -0.06374455f, 0.08060540f, 0.08327217f, 0.11368871f, 0.08071186f, 0.09448177f, 
    0.04817333f, 0.08739882f, 0.03872349f, 0.01862874f, -0.03475180f, -0.00570943f, -0.00009534f, -0.03190802f, 
    0.08162529f, 0.14489478f, -0.03018434f, 0.10273122f, 0.02718928f, 0.00712426f, 0.09508570f, -0.06957801f, 
    0.07658662f, 0.09143728f, 0.02969901f, -0.02861492f, -0.12929869f, -0.04965002f, -0.11492956f, -0.06129213f, 
    -0.01128828f, -0.02109794f, -0.05686525f, -0.05784840f, 0.01811935f, 0.00464203f, -0.05055241f, 0.02241808f, 
    0.19512273f, -0.03551430f, -0.02244110f, -0.11383814f, 0.00980117f, -0.05003288f, -0.08173453f, -0.06349585f, 
    -0.00298052f, -0.00277917f, -0.02483601f, 0.01765195f, 0.15606506f, -0.25335327f, 0.03890166f, 0.01814107f, 
    -0.02579055f, -0.02771007f, -0.05985558f, 0.04322621f, -0.07408491f, -0.05059609f, -0.09734547f, -0.01678272f, 
    -0.22243075f, 0.03542408f, -0.01497371f, -0.00121875f, -0.08485579f, 0.06515157f, -0.03749519f, -0.01363151f, 
    -0.03079031f, -0.00694564f, 0.05011764f, -0.11583745f, 0.03937564f, -0.16095017f, 0.10256659f, -0.03462174f, 
    0.01704364f, -0.00156241f, 0.00669096f, 0.06881588f, -0.03901067f, 0.03003087f, 0.06509103f, -0.02622366f, 
    0.30007842f, -0.19187763f, 0.15774089f, -0.05574062f, -0.00956270f, 0.02192648f, -0.01527756f, -0.05272619f, 
    -0.02745995f, -0.02139008f, -0.05760358f, -0.03133327f, 0.07552283f, -0.13264807f, -0.04693194f, 0.11131270f, 
    0.01233488f, 0.02928387f, 0.00156154f, -0.02073041f, -0.00942241f, -0.01320467f, -0.06234212f, -0.05197406f, 
    -0.20112196f, -0.01931869f, -0.10940500f, 0.21037176f, -0.06693943f, -0.08938733f, -0.08499609f, 0.02666557f, 
    -0.14297521f, 0.03427875f, 0.04323459f, -0.04774274f, 0.14110661f, 0.17814364f, 0.09207889f, 0.12446240f, 
    0.10771233f, -0.01904844f, 0.06948600f, 0.03953250f, 0.04350410f, -0.01924665f, 0.02145058f, 0.02917071f, 
    0.06225597f, 0.08145708f, -0.01562146f, 0.03565476f, -0.04808902f, -0.05710914f, 0.07578514f, -0.08174989f, 
    -0.02886352f, 0.00231064f, 0.05201277f, -0.08768265f, -0.02116223f, 0.08011288f, -0.10479243f, 0.10908525f, 
    -0.05954295f, -0.02043013f, -0.06972986f, -0.00570028f, -0.06057172f, -0.08162867f, -0.02795289f, -0.09390994f, 
    -0.26771048f, 0.08383545f, -0.01708711f, 0.00712312f, -0.09715415f, -0.08498430f, -0.02709637f, -0.02702898f, 
    -0.06796850f, -0.02377854f, -0.00618667f, -0.08263598f, 0.15036409f, 0.01436091f, -0.13101001f, -0.19393341f, 
    -0.00488903f, -0.04044717f, -0.04565038f, -0.04671426f, -0.09360265f, -0.00446881f, 0.02260937f, -0.02780879f, 
    0.01208896f, -0.08142329f, -0.05916394f, 0.02884808f, -0.07302904f, -0.04666503f, -0.05323416f, 0.08718698f, 
    -0.04184734f, -0.07045199f, -0.05501335f, -0.01443854f, -0.15598516f, -0.02473898f, -0.13950267f, -0.13414530f, 
    -0.02908352f, -0.02176532f, -0.09022494f, 0.00008846f, -0.14076798f, 0.07203275f, -0.06632597f, -0.06490683f, 
    0.09971663f, 0.03685731f, 0.11935622f, 0.04651427f, -0.12525202f, 0.03385539f, -0.02591540f, -0.02420045f, 
    -0.03029947f, 0.03142412f, -0.11153883f, -0.03306984f, 0.03666594f, 0.09822406f, 0.14612035f, 0.09484970f, 
    0.06936412f, 0.08912958f, -0.03995964f, 0.01308668f, -0.04868450f, -0.00024333f, 0.10499505f, 0.05025236f, 
    0.04666953f, 0.05502184f, -0.06252079f, 0.14216511f, -0.03150058f, -0.01924609f, -0.08612453f, -0.07525447f, 
    -0.03412589f, 0.03334225f, -0.00313245f, -0.05341643f, 0.09050200f, -0.17908703f, -0.07640564f, 0.17069694f, 
    -0.08487703f, -0.07464017f, -0.02515788f, -0.03383934f, 0.04522689f, 0.03120350f, 0.06006476f, -0.00471010f, 
    -0.09592433f, -0.14672980f, -0.10752666f, 0.00835979f, -0.05433557f, -0.05411470f, 0.06533619f, 0.03420347f, 
    0.13302812f, 0.01071027f, 0.00827127f, -0.02430414f, 0.12613630f, -0.28230867f, -0.05743045f, -0.14504719f, 
    0.05495282f, 0.10001094f, -0.05112358f, -0.13369049f, -0.04885728f, -0.01012190f, 0.04907097f, -0.04274491f, 
    -0.17142078f, 0.05895220f, -0.03965005f, -0.13798930f, -0.09705820f, 0.00519927f, -0.06510662f, -0.09586618f, 
    -0.10752124f, 0.00328793f, -0.05544233f, -0.11739383f, 0.18500225f, -0.29582298f, 0.12471887f, -0.03519153f, 
    0.06649888f, -0.00522942f, -0.05763377f, -0.06038155f, -0.06644163f, 0.02080427f, -0.08646499f, 0.00231798f, 
    0.03424989f, 0.19442759f, -0.03326970f, 0.19136137f, 0.02390232f, -0.06886129f, -0.14405358f, -0.00595365f, 
    -0.00439582f, -0.05827533f, -0.00218300f, -0.14312837f, 0.18881282f, -0.26133367f, -0.06127585f, -0.08554134f, 
    -0.00583357f, -0.07428289f, 0.00484111f, -0.01678269f, -0.03822090f, -0.02455657f, -0.02070997f, 0.00425071f, 
    0.04829146f, 0.12954408f, -0.01213173f, 0.06192815f, -0.04119284f, 0.03964962f, -0.01611379f, -0.08799711f, 
    -0.02508726f, 0.00575478f, -0.00463382f, -0.08468367f, 0.14362593f, 0.11342815f, -0.03208700f, 0.17747647f, 
    0.03993925f, -0.05639885f, -0.02571276f, 0.01205124f, -0.01823016f, -0.04108572f, -0.02020075f, -0.10758504f, 
    0.07491809f, 0.07312201f, 0.08576267f, 0.09878778f, -0.14609411f, 0.08667370f, -0.04567110f, 0.04076882f, 
    0.04137618f, -0.05453645f, -0.01848938f, 0.00293991f, 0.07136367f, 0.06539205f, 0.10388200f, 0.03955669f, 
    0.07094076f, -0.03429975f, 0.02077847f, -0.00872199f, -0.02261078f, -0.04473342f, 0.15617427f, -0.01541498f, 
    -0.24473746f, -0.08507393f, -0.05153549f, -0.23814425f, -0.02932302f, -0.19072810f, 0.01751000f, -0.11536698f, 
    0.12356759f, 0.10125551f, 0.02563239f, 0.01044116f, -0.07758997f, -0.26566252f, -0.03159233f, -0.09131049f, 
    -0.01989716f, -0.06654710f, -0.09619164f, -0.20322677f, -0.12285560f, -0.05272561f, -0.03394319f, -0.13996896f, 
    0.06200257f, -0.02831783f, 0.01780435f, -0.04078078f, 0.06391067f, -0.11359333f, 0.12777650f, 0.05345853f, 
    0.14941710f, -0.06814246f, -0.05270030f, 0.02647179f, -0.14418998f, -0.02277829f, -0.14297441f, -0.26531160f, 
    0.02637859f, -0.01465955f, -0.04930753f, -0.01431886f, 0.01951659f, -0.00747154f, 0.02106161f, -0.01379206f, 
    0.08910614f, 0.05618493f, 0.05661525f, 0.10798249f, -0.17483218f, -0.07009503f, -0.01242582f, 0.02883851f, 
    -0.01718248f, -0.05694208f, -0.05426282f, -0.00865534f, 0.19704174f, 0.08601075f, -0.11424521f, 0.00560132f, 
    0.03828822f, 0.00364843f, 0.01099503f, 0.08840068f, 0.03829821f, -0.03463187f, 0.02023359f, -0.06300144f, 
    -0.10860357f, -0.16371007f, 0.17533016f, -0.09241425f, -0.02983921f, 0.02717572f, 0.05923598f, 0.08776785f, 
    -0.03701456f, -0.02655016f, 0.01994408f, 0.05791098f, 0.06013005f, 0.03824370f, -0.09000871f, -0.02223880f, 
    -0.02128818f, 0.03971568f, -0.04475982f, -0.01336380f, 0.00945864f, -0.05023669f, 0.06230848f, 0.02268640f, 
    -0.21819155f, -0.17997774f, -0.03277685f, 0.13394846f, 0.10695561f, 0.00256066f, -0.05141692f, 0.10183002f, 
    0.01633214f, 0.03422311f, 0.15322861f, -0.19199595f, 0.16012608f, 0.02989529f, 0.03709938f, 0.09565133f, 
    -0.01003415f, 0.01154567f, -0.13635734f, -0.18794379f, 0.07349133f, -0.08607752f, -0.03351646f, -0.01072258f, 
    -0.23161125f, -0.26081720f, 0.16346365f, -0.19411141f, -0.18927802f, 0.06785347f, -0.01087912f, -0.16892438f, 
    0.01115726f, -0.06778196f, 0.03083172f, 0.14303640f, -0.09368232f, -0.04831341f, 0.18145636f, -0.03174639f, 
    0.05262948f, -0.03390768f, -0.06637497f, -0.10709342f, 0.03733098f, -0.01583462f, 0.04695398f, 0.01280036f, 
    0.09052356f, -0.08879427f, -0.24637583f, 0.06208723f, -0.09199570f, 0.05521003f, -0.23602347f, -0.11194668f, 
    0.05513408f, -0.03533982f, 0.19044280f, 0.00514681f, 0.05967223f, -0.15047644f, 0.01100724f, -0.04253626f, 
    -0.06904078f, 0.06581610f, -0.08933502f, -0.07181875f, 0.03400960f, -0.07326842f, 0.06950337f, -0.07100765f, 
    0.14973281f, -0.05617726f, 0.01136547f, 0.18299468f, 0.01082179f, -0.03381632f, -0.00717918f, -0.02343251f, 
    0.05325751f, 0.00396243f, 0.05628228f, 0.00545678f, 0.05158053f, -0.05073987f, -0.03650475f, -0.17254080f, 
    -0.06372543f, -0.12320221f, 0.07126328f, -0.01661584f, 0.07677972f, 0.01589167f, -0.03597881f, 0.07630220f, 
    0.15494670f, 0.05875058f, 0.00024793f, 0.20202591f, 0.16960742f, -0.02104518f, -0.05252151f, -0.07041733f, 
    -0.07107467f, 0.01724187f, 0.06625690f, -0.02680159f, -0.04478254f, 0.05573487f, 0.07837032f, 0.12264831f, 
    0.02605644f, 0.14459881f, -0.14153671f, -0.02648940f, 0.02631105f, 0.00325384f, -0.07058815f, 0.09286598f, 
    -0.05417015f, 0.10871311f, 0.02691826f, 0.14741796f, -0.02692969f, 0.00664085f, -0.01463061f, 0.10473150f, 
    0.02373756f, -0.09543067f, -0.04817196f, -0.01292146f, -0.12165733f, 0.04120730f, -0.01041362f, -0.02841652f, 
    -0.01094560f, 0.06271105f, -0.16679993f, -0.02024416f, 0.06340239f, -0.01436476f, 0.00373416f, -0.15819933f, 
    -0.10821539f, 0.06109610f, 0.02965496f, 0.06257820f, 0.03140806f, 0.05395307f, -0.10699371f, -0.10045704f, 
    -0.02245398f, 0.04727138f, -0.08946946f, -0.11000121f, -0.15288268f, -0.03357830f, 0.14908002f, 0.01555487f, 
    0.03623137f, -0.00244739f, -0.16710383f, 0.03670780f, 0.09229194f, 0.01339992f, -0.04495529f, 0.07062681f, 
    -0.07710853f, 0.01220012f, -0.13953173f, -0.28887555f, 0.13556193f, -0.01718651f, 0.07033920f, 0.01133382f, 
    0.09444968f, 0.08736821f, -0.03736586f, 0.10621395f, 0.04728143f, 0.24389736f, -0.22959764f, -0.02248794f, 
    0.02775318f, -0.02605853f, -0.14404131f, -0.10134976f, 0.13063465f, 0.00365313f, 0.07302601f, -0.01258083f, 
    0.09987326f, -0.06199331f, -0.15281464f, -0.19076385f, -0.02694991f, -0.02987360f, -0.05107131f, -0.01983460f, 
    0.04957625f, -0.04375876f, 0.02136596f, 0.10084190f, -0.09264608f, -0.10360315f, 0.02054068f, -0.06800582f, 
    -0.00194045f, -0.02655053f, -0.05534943f, -0.02295563f, 0.02019100f, -0.04695445f, -0.11971282f, 0.08600271f, 
    -0.22120230f, -0.18923201f, 0.11273541f, -0.15635280f, 0.12578796f, 0.07163493f, -0.05561741f, -0.06239556f, 
    0.04751347f, -0.01301114f, 0.11598215f, 0.02249265f, 0.13399395f, 0.03558053f, -0.04089516f, 0.15657674f, 
    0.05955132f, -0.00882862f, -0.02595374f, -0.00630390f, -0.00671475f, -0.02356422f, 0.15231866f, 0.00996033f, 
    0.06988166f, -0.10992058f, -0.14829697f, 0.05326438f, 0.09306527f, 0.05895564f, -0.05656399f, 0.01761315f, 
    -0.05497720f, -0.05886360f, 0.05300992f, -0.01330049f, -0.09639702f, -0.04646949f, 0.16308963f, 0.16669425f, 
    -0.13443613f, -0.01710431f, -0.00266122f, -0.01113664f, 0.04491309f, 0.03508534f, -0.06723693f, -0.08321912f, 
    0.07182438f, -0.00418135f, -0.18879871f, 0.03362915f, 0.09722855f, -0.05265033f, -0.12046693f, -0.04722601f, 
    -0.02192686f, -0.00198856f, 0.12089227f, -0.01256805f, -0.19999611f, 0.06322155f, 0.00849735f, -0.10873237f, 
    -0.10325452f, 0.09188090f, -0.04650501f, 0.00818245f, -0.03648470f, -0.18680783f, -0.05392519f, 0.06344260f, 
    0.05033080f, -0.10645925f, -0.11398659f, 0.09576407f, 0.11085073f, 0.08652504f, 0.04166595f, -0.08567614f, 
    -0.04530351f, -0.00178639f, 0.04994849f, 0.04732652f, -0.29941720f, 0.03145315f, 0.03684338f, -0.06940131f, 
    -0.02864708f, -0.10367623f, -0.07561623f, -0.04786876f, 0.02583128f, -0.04409322f, 0.02291321f, -0.12236449f, 
    0.09475344f, 0.09997154f, -0.17418987f, 0.11705845f, -0.07266197f, -0.11385992f, -0.16924612f, 0.08768412f, 
    -0.03067589f, -0.07982072f, -0.03472038f, 0.11769160f, 0.07225350f, 0.10703706f, -0.23237717f, 0.05348616f, 
    -0.00362411f, 0.08657230f, -0.01250754f, -0.09599109f, 0.05159943f, 0.03108173f, -0.01935500f, -0.03837537f, 
    0.12164444f, -0.02642066f, -0.12703484f, 0.04096512f, 0.01642092f, -0.08650419f, -0.08168614f, -0.06292284f, 
    -0.12060454f, -0.09619036f, -0.10907695f, -0.01342845f, 0.11468407f, 0.01150507f, -0.05994058f, 0.11586097f, 
    0.01909473f, 0.00819050f, -0.13193291f, -0.04861056f, -0.05208227f, -0.01993248f, 0.04198303f, -0.02974219f, 
    0.09076127f, 0.07656448f, -0.02331348f, -0.04448804f, 0.05273379f, -0.15377453f, 0.12973043f, -0.08691571f, 
    -0.01602278f, -0.10051691f, -0.14456934f, 0.04358590f, -0.07622182f, -0.18814699f, 0.17980029f, 0.07760762f, 
    -0.14550486f, -0.07282879f, 0.00491595f, -0.09064327f, -0.06187569f, 0.03570848f, -0.18692110f, 0.01921054f, 
    -0.17673673f, 0.04632724f, 0.08842358f, 0.02438936f, -0.06821709f, -0.08016506f, 0.12100846f, -0.22708075f, 
    0.05104114f, 0.16823791f, -0.08903282f, 0.14337267f, 0.21164964f, 0.11161869f, -0.06043459f, -0.16455746f, 
    0.07222400f, -0.08515518f, 0.02192636f, 0.01377050f, 0.07128849f, -0.03870041f, 0.10372867f, 0.03675527f, 
    -0.11323778f, 0.05417868f, -0.14100102f, -0.00249660f, 0.02819507f, 0.07230722f, 0.01443108f, -0.02174116f, 
    0.03999738f, 0.09197304f, 0.00283818f, -0.01461774f, 0.05596301f, 0.03784498f, -0.03006463f, 0.08207310f, 
    -0.08780138f, -0.04219668f, 0.04408804f, 0.02467755f, -0.07217985f, 0.05325870f, 0.07649595f, 0.05430957f, 
    -0.11023646f, -0.30444673f, 0.06343935f, 0.19882421f, 0.07446691f, -0.00708819f, -0.06085688f, -0.08777166f, 
    0.07755020f, 0.11178127f, -0.00842636f, -0.00953677f, -0.05803867f, 0.05544157f, -0.26820713f, -0.24286130f, 
    -0.05285888f, -0.07990287f, -0.00066623f, -0.03465445f, 0.10354497f, 0.09083605f, -0.08842319f, -0.07132623f, 
    -0.04121647f, -0.07358543f, -0.13095506f, 0.05255608f, 0.00471959f, -0.06721008f, -0.06011369f, 0.06205492f, 
    0.02978063f, 0.00214593f, 0.02491697f, 0.01186878f, 0.09792918f, 0.01833912f, -0.06110868f, 0.02236683f, 
    0.06106369f, 0.03101726f, -0.01103775f, -0.06143053f, -0.04882875f, -0.01862254f, 0.01162151f, 0.06420650f, 
    0.00270447f, 0.10535887f, -0.18867020f, -0.09250536f, -0.07277904f, 0.11265914f, -0.13015020f, -0.01109286f, 
    0.03721314f, 0.12219407f, -0.03699740f, 0.06819090f, 0.07802106f, 0.20730647f, -0.01200545f, -0.03145439f, 
    0.08229123f, 0.03484583f, -0.06661316f, -0.07177615f, 0.03640595f, 0.04096638f, 0.02420627f, 0.10850457f, 
    -0.17748140f, 0.10844748f, -0.08446009f, -0.07461214f, -0.09180313f, 0.03279066f, -0.04467575f, -0.07989383f, 
    0.11172830f, 0.01666060f, 0.05096938f, 0.04237805f, -0.10630694f, 0.00103320f, 0.16742374f, -0.16198133f, 
    -0.02758399f, 0.02724353f, 0.04073349f, 0.01349039f, -0.09887067f, -0.00215572f, -0.12030610f, 0.06438821f, 
    -0.17425938f, 0.23651616f, -0.14360496f, -0.21674012f, 0.06067102f, 0.02257120f, -0.17841442f, 0.10197406f, 
    0.10570799f, -0.03579854f, -0.07030306f, 0.08015461f, -0.16988593f, -0.28247580f, 0.09235144f, -0.21054821f, 
    -0.02455504f, -0.05688768f, -0.07765681f, -0.03960347f, 0.02436468f, 0.05588730f, -0.00370031f, 0.08215095f, 
    -0.07269638f, 0.01766668f, -0.17254786f, -0.09358813f, -0.05316465f, -0.04728937f, -0.05856162f, 0.06884753f, 
    -0.04033899f, 0.04359211f, 0.10513484f, 0.06988016f, 0.16981888f, -0.31466067f, 0.01400321f, -0.05645520f, 
    0.11169472f, -0.01536279f, -0.00418285f, 0.00314565f, 0.08048818f, 0.06063354f, -0.00487342f, -0.11045200f, 
    0.25227085f, 0.07514391f, 0.14065021f, 0.13835520f, -0.05693106f, -0.12203254f, -0.01516894f, 0.01181245f, 
    0.01949171f, -0.04912593f, -0.05948573f, -0.10406911f, -0.01751113f, -0.07367215f, -0.02412055f, 0.03324360f, 
    0.04734895f, 0.10180291f, -0.07094236f, -0.02262985f, 0.08183435f, 0.02192090f, -0.04010524f, 0.05687322f, 
    -0.00426746f, 0.13683099f, -0.01753535f, -0.11361928f, -0.05505335f, 0.00697474f, -0.07491581f, -0.05493370f, 
    0.02419879f, -0.00399262f, 0.05443151f, 0.09167581f, 0.10993510f, -0.09054018f, -0.19000234f, 0.13689207f, 
    0.05171663f, -0.02985651f, -0.00608011f, -0.06620886f, 0.07264078f, 0.00144611f, 0.01587125f, 0.03214259f, 
    -0.12354255f, 0.18857642f, 0.02275194f, -0.03882102f, -0.02874999f, -0.02833067f, -0.06159761f, 0.15289661f, 
    0.02701581f, 0.02838845f, -0.03780091f, -0.03903566f, 0.03056947f, 0.03701922f, -0.22172543f, -0.19880776f, 
    -0.04135346f, -0.06409067f, 0.10803749f, -0.02015607f, -0.00451245f, -0.03674827f, 0.06902920f, 0.10002530f, 
    0.38913780f, 0.14593175f, 0.01423062f, -0.01091747f, 0.02552533f, 0.06704697f, 0.09705732f, 0.08518344f, 
    -0.07141151f, 0.07751030f, -0.01715922f, -0.00508529f, 0.02491598f, -0.13902822f, 0.02273899f, -0.09617866f, 
    0.00970276f, -0.08461562f, -0.05847128f, -0.16333193f, 0.04640604f, -0.00080028f, -0.02845505f, -0.03853123f, 
    0.00986273f, 0.17552315f, -0.13562594f, -0.15331480f, 0.11470265f, 0.04115326f, 0.05811224f, -0.01130804f, 
    -0.18153383f, -0.09250014f, -0.07132881f, -0.10429224f, 0.15190198f, -0.03143666f, -0.17317036f, 0.03178445f, 
    0.02308554f, -0.01671936f, -0.03099293f, 0.02973905f, 0.05778694f, 0.04918822f, 0.07267886f, 0.01628789f, 
    -0.22625104f, -0.32820427f, 0.02452857f, -0.06460311f, 0.03586240f, 0.01904873f, -0.10675327f, -0.00838214f, 
    0.02027404f, -0.12623984f, 0.10221884f, 0.03307520f, -0.02739667f, -0.19355348f, -0.10201474f, -0.24683385f, 
    -0.05942079f, -0.06526259f, 0.01945872f, -0.01856917f, 0.01477741f, -0.01705889f, 0.09475818f, 0.04753488f, 
    -0.08969542f, -0.22136948f, 0.08704519f, -0.13990349f, 0.01294954f, 0.06588577f, 0.05120885f, 0.00180807f, 
    -0.00388893f, -0.01306337f, -0.00571840f, 0.09430800f, -0.38028833f, 0.13389193f, 0.08693913f, 0.11482345f, 
    0.10433837f, 0.00957509f, 0.10769074f, -0.02644414f, -0.03997908f, -0.04106100f, 0.02798068f, 0.12144909f, 
    0.04942158f, -0.06395574f, -0.02154032f, 0.07604427f, -0.03710191f, -0.05499261f, -0.05080617f, -0.00015612f, 
    -0.07927454f, 0.17953628f, -0.16281015f, 0.06195714f, 0.08217624f, -0.06216437f, 0.08017789f, -0.02971565f, 
    0.05507353f, 0.02005719f, -0.02063434f, 0.00916921f, -0.02014657f, 0.01354598f, -0.12048883f, 0.03718338f, 
    -0.21035284f, -0.13415354f, 0.08668690f, -0.30136538f, -0.01290185f, -0.03831087f, -0.06661405f, -0.00171307f, 
    -0.05218597f, -0.10250244f, -0.06714872f, -0.01195796f, 0.18021649f, -0.36902481f, 0.07990064f, 0.04274794f, 
    -0.01073021f, -0.05715820f, 0.00794916f, -0.03046131f, -0.00979125f, 0.10919499f, 0.07215627f, 0.12678054f, 
    0.17799333f, -0.08648849f, -0.04309500f, -0.12446816f, 0.12491956f, -0.09029908f, 0.06747965f, -0.06148169f, 
    -0.04066118f, 0.05625066f, 0.08214333f, -0.01189811f, -0.37517783f, -0.08830597f, -0.07708265f, 0.07946487f, 
    0.03789288f, -0.03355434f, -0.04013395f, 0.02870238f, 0.08869608f, 0.12471662f, 0.01331057f, -0.08318004f, 
    -0.21166943f, 0.06010100f, 0.08026128f, 0.00216589f, 0.02877765f, -0.03038300f, -0.02798329f, 0.02726206f, 
    -0.04773503f, 0.05433989f, -0.03883810f, -0.11699494f, 0.00287880f, -0.21963055f, 0.08462606f, -0.14303376f, 
    0.05773749f, -0.14410028f, 0.04737761f, -0.04971268f, -0.01171468f, 0.06222096f, 0.04207416f, 0.23567086f, 
    -0.11035546f, 0.19338803f, -0.15537578f, -0.23093303f, 0.16778959f, -0.04822243f, 0.01707796f, -0.05068906f, 
    -0.05471792f, -0.09927199f, -0.17400701f, -0.10432486f, 0.30560952f, 0.13242632f, -0.09790271f, -0.00510194f, 
    0.08107702f, -0.08146030f, 0.00385403f, -0.03814960f, 0.06042703f, -0.00667396f, 0.03028705f, 0.10677465f, 
    -0.17129932f, 0.02539934f, -0.14515173f, -0.01468478f, 0.03208189f, 0.02048953f, 0.02610219f, -0.07567007f, 
    0.04259855f, 0.01304721f, -0.01237014f, -0.06798794f, -0.14637700f, 0.25477916f, 0.17805977f, -0.02097430f, 
    0.09222810f, 0.08554839f, -0.05755083f, -0.05091384f, -0.03548964f, -0.01155391f, 0.00135724f, -0.07398906f, 
    -0.02953999f, -0.10183388f, -0.12815018f, 0.05808473f, 0.08644893f, -0.06146593f, -0.13267827f, -0.00241607f, 
    -0.05277276f, 0.11823260f, 0.00263097f, -0.03355340f, -0.43286744f, 0.37411970f, 0.26874450f, 0.00484073f, 
    0.07844034f, -0.02230374f, -0.05010011f, 0.12708676f, 0.07290292f, -0.05705192f, -0.03280729f, 0.11644882f, 
    -0.07996955f, -0.04568446f, 0.03247786f, -0.07660959f, -0.02365209f, -0.07285562f, 0.11764716f, 0.00996057f, 
    0.17089020f, 0.00901389f, 0.07946663f, 0.05193995f, -0.11538269f, -0.38636026f, 0.19578348f, 0.01336668f, 
    -0.14320102f, 0.02113763f, -0.03602495f, -0.12052724f, 0.03848811f, -0.00883972f, 0.00372589f, -0.08140396f, 
    0.08906152f, -0.12735039f, 0.06126906f, 0.09282480f, 0.00245505f, -0.01950623f, 0.05127423f, -0.05712968f, 
    -0.12564275f, -0.13021338f, 0.10117272f, -0.18753615f, -0.24225296f, 0.11664105f, 0.26128599f, 0.01800971f, 
    -0.10365495f, 0.07499564f, 0.01267304f, 0.09733334f, 0.07094073f, 0.03264898f, 0.01835631f, -0.05443428f, 
    0.31755820f, -0.28177750f, 0.15239991f, -0.00344069f, -0.01597224f, 0.03151619f, -0.07509582f, -0.05726409f, 
    -0.16879484f, -0.09404729f, -0.00926549f, -0.13530843f, -0.06286348f, -0.11426996f, -0.10506274f, 0.21883520f, 
    -0.02664621f, -0.00391436f, 0.02612582f, 0.04694422f, -0.07188495f, 0.02581604f, 0.01706308f, -0.01446657f, 
    -0.09679241f, -0.24084646f, -0.09973842f, 0.07238448f, 0.00445706f, -0.00876786f, 0.00454321f, -0.08157437f, 
    0.02854365f, -0.13204429f, 0.03914585f, 0.08729681f, -0.09417556f, 0.34421736f, -0.05999978f, -0.35648209f, 
    0.07811209f, 0.03495818f, -0.02858341f, -0.12205579f, -0.10464750f, 0.10161121f, 0.00407917f, -0.14707963f, 
    -0.05855881f, -0.00523608f, 0.16810004f, -0.18617536f, 0.05148738f, 0.02911484f, -0.07922737f, -0.04628306f, 
    -0.04057702f, -0.06634472f, -0.02713281f, 0.01436485f, 0.07075600f, -0.05924708f, -0.10512177f, 0.14529327f, 
    0.05327962f, -0.05944268f, 0.00046039f, -0.04801561f, 0.01486793f, 0.04186508f, -0.05885291f, 0.05422578f, 
    -0.47133425f, 0.14997508f, 0.15807672f, -0.05505359f, -0.03492277f, -0.07559564f, 0.10197496f, -0.01371532f, 
    -0.09916021f, 0.01507625f, -0.14827915f, 0.02831307f, -0.25602958f, 0.03433544f, 0.04407463f, 0.09492809f, 
    0.06132939f, -0.14477298f, 0.00447161f, 0.06601503f, 0.05991358f, 0.03752694f, 0.09232073f, 0.12676597f, 
    0.03692372f, 0.09697068f, 0.00291507f, -0.24911204f, -0.04377984f, 0.05277249f, 0.02253233f, -0.06270580f, 
    -0.12589610f, 0.02511685f, -0.05923458f, 0.07856940f, -0.06254623f, -0.15683769f, -0.03670066f, 0.20648538f, 
    0.02112212f, 0.10574990f, -0.06859080f, 0.06303030f, -0.06407743f, 0.01666501f, -0.02433149f, -0.08155177f, 
    -0.36113349f, 0.11160436f, 0.13674253f, 0.08851878f, 0.12761328f, -0.06452667f, 0.01492558f, 0.13906033f, 
    -0.02556236f, 0.06994781f, 0.04664933f, -0.10421739f, 0.07833307f, 0.05166946f, -0.04572855f, 0.26322848f, 
    0.01926451f, 0.13580015f, 0.11240783f, 0.08631877f, -0.04190512f, -0.02086296f, -0.00880119f, 0.06526440f, 
    0.18849978f, -0.11378164f, -0.14745378f, -0.02579969f, -0.07076085f, 0.07928318f, -0.02488044f, -0.00226421f, 
    0.01761224f, 0.18229365f, 0.04766433f, 0.05194050f, 0.17133200f, -0.49728188f, 0.14001493f, -0.05969064f, 
    0.00339539f, 0.01095904f, -0.02692058f, -0.12864527f, -0.05529421f, 0.06411812f, 0.11969844f, 0.03483580f, 
    0.01702794f, 0.16680484f, 0.19385231f, -0.02041879f, 0.03500311f, -0.09101503f, -0.01512765f, 0.01915227f, 
    0.10998502f, -0.19936666f, 0.14877507f, 0.07010837f, 0.23908146f, -0.08569568f, -0.17875747f, 0.11592171f, 
    0.04534168f, -0.03260465f, 0.01074424f, -0.03932723f, 0.05945892f, -0.13580145f, -0.03387788f, -0.06980497f, 
    -0.07628693f, -0.17398632f, -0.07009177f, 0.08564528f, 0.04689923f, -0.02900083f, -0.01653956f, -0.00054890f, 
    0.09040353f, -0.11472108f, 0.10744567f, -0.11217736f, 0.06983005f, 0.02590094f, 0.17735067f, -0.18511456f, 
    0.08880506f, -0.10096721f, 0.01668874f, -0.07097809f, 0.04009574f, 0.08567567f, 0.10894447f, 0.10944314f, 
    -0.05177304f, 0.19285583f, -0.08294857f, -0.27562401f, -0.00024847f, -0.01172057f, -0.03223473f, 0.08385062f, 
    0.08790605f, 0.01971196f, -0.02950836f, -0.13074389f, 0.03029526f, -0.16081393f, 0.09614896f, 0.06700554f, 
    0.00124060f, 0.00033674f, -0.06905643f, -0.06888603f, -0.01829924f, -0.02480990f, 0.01868487f, 0.01525611f, 
    -0.00094630f, -0.05491173f, -0.13884526f, -0.19628161f, -0.04019368f, -0.08610604f, 0.13586536f, 0.02904038f, 
    0.03491405f, -0.02185329f, -0.00592396f, 0.00710776f, -0.01547406f, -0.03715614f, -0.02593168f, 0.16437885f, 
    -0.01185987f, 0.13142137f, -0.07036750f, -0.03985979f, -0.05829611f, -0.04040876f, -0.07570441f, 0.00977992f, 
    -0.19070084f, -0.09583478f, 0.15870214f, -0.21012115f, 0.08063783f, 0.05668583f, 0.06215634f, 0.01282049f, 
    -0.03784176f, -0.02909772f, 0.02300125f, -0.00204158f, -0.24403347f, -0.10200004f, 0.15066448f, -0.15246290f, 
    -0.00528486f, 0.03165270f, -0.04178920f, -0.04826955f, -0.00112886f, 0.01530883f, -0.12508617f, 0.04593549f, 
    -0.04665387f, -0.11295797f, 0.07069746f, -0.09508000f, 0.00293783f, 0.02053983f, 0.04588034f, 0.05589712f, 
    0.07710554f, 0.04962070f, 0.04670611f, -0.20542935f, 0.34015021f, -0.00367636f, 0.11348891f, -0.23657741f, 
    0.03326723f, 0.02436459f, 0.12691429f, 0.02391055f, -0.08733611f, -0.04445962f, -0.01896366f, -0.08243921f, 
    0.01432279f, -0.02344189f, -0.10542717f, 0.04216291f, -0.06377403f, 0.03866422f, 0.07991013f, -0.00830412f, 
    0.08012440f, 0.04255876f, 0.00744493f, -0.11106807f, 0.51170814f, 0.05717573f, -0.06599171f, 0.20207548f, 
    0.20254515f, -0.15820193f, -0.06658374f, 0.06391598f, -0.07929192f, 0.00301997f, 0.06897601f, 0.11902193f, 
    0.03000206f, 0.16024427f, 0.19594124f, 0.07398106f, -0.15147991f, -0.06297039f, 0.05856245f, 0.00227340f, 
    -0.04088577f, 0.08052853f, 0.10448474f, 0.06591912f, -0.04270544f, -0.08485191f, -0.14214851f, -0.10501459f, 
    -0.06497422f, -0.05187097f, 0.05127465f, 0.07472936f, 0.08497296f, 0.09958481f, 0.11681402f, -0.04110489f, 
    0.02666792f, 0.13759856f, -0.10993470f, -0.24605991f, -0.00669263f, 0.07454021f, -0.05404039f, -0.08239266f, 
    0.02441191f, -0.01206841f, 0.07125572f, -0.04983366f, 0.15511803f, 0.06747399f, 0.01969662f, 0.02264975f, 
    0.02451028f, 0.15099703f, -0.08226961f, -0.05317280f, 0.07551670f, -0.04619884f, -0.05940205f, 0.11018982f, 
    -0.42957422f, 0.38986489f, -0.11114486f, -0.04576862f, 0.11177047f, 0.01300445f, -0.05419369f, -0.06426088f, 
    -0.03117306f, -0.03612033f, 0.09263251f, 0.04514535f, 0.23423433f, -0.49671233f, 0.11375362f, -0.11580314f, 
    -0.00513752f, 0.07728961f, -0.10889335f, -0.00310830f, -0.02467363f, -0.10255604f, -0.00882009f, -0.08344728f, 
    0.01008659f, -0.14262965f, 0.17722392f, -0.07978936f, -0.04745603f, 0.10010339f, -0.10614102f, 0.19948117f, 
    0.07097252f, -0.09072106f, -0.07706307f, -0.05577574f, -0.17165127f, -0.03557479f, 0.11554804f, -0.10445570f, 
    0.01514470f, 0.07327127f, 0.06973197f, -0.00332902f, 0.02119477f, -0.08080918f, -0.05615804f, 0.04545647f, 
    0.05797296f, 0.05314699f, 0.05906033f, 0.05805051f, 0.06295752f, 0.02757873f, 0.00293790f, 0.13039970f, 
    -0.14778911f, -0.06923649f, 0.04702359f, -0.05338122f, -0.07590890f, 0.02418608f, 0.14226136f, -0.10565334f, 
    0.08026477f, -0.05372133f, 0.00670152f, -0.07719620f, -0.00025166f, -0.11695618f, 0.04474242f, 0.09352675f, 
    -0.14859976f, -0.20640612f, -0.06331584f, 0.12915421f, 0.13809282f, 0.06519217f, -0.01324591f, -0.02412149f, 
    0.00775932f, -0.11889845f, -0.03623569f, 0.03728982f, 0.01023305f, 0.04189278f, -0.04684621f, 0.01654157f, 
    -0.10587166f, 0.06714893f, -0.01554517f, 0.10472862f, -0.02224845f, 0.12163266f, 0.10338899f, 0.11947834f, 
    0.10270116f, 0.00700242f, 0.00924087f, 0.20321001f, 0.02839510f, -0.14732186f, 0.05260288f, -0.02418605f, 
    -0.02966758f, 0.19100387f, 0.01222986f, -0.03404228f, 0.12666509f, 0.20797259f, -0.03193878f, -0.02327954f, 
    -0.04531312f, -0.00003103f, -0.03650735f, -0.03598098f, 0.06062441f, -0.14293732f, -0.10056156f, -0.04715422f, 
    -0.23990165f, 0.02906212f, -0.14175279f, -0.02131209f, -0.01729755f, -0.02272556f, 0.00608223f, -0.03237224f, 
    -0.05081477f, 0.13365246f, 0.01892705f, -0.01279187f, 0.18455534f, 0.27711016f, 0.06581800f, 0.00542436f, 
    0.12860022f, 0.08298813f, 0.09252637f, -0.05392047f, 0.10925209f, 0.04910324f, -0.06068387f, -0.03224321f, 
    0.15024616f, 0.06543035f, -0.06840722f, -0.03576273f, -0.18140705f, 0.00112931f, 0.01967363f, -0.01389332f, 
    -0.08788719f, -0.09407619f, 0.03362642f, -0.04707148f, -0.30514708f, -0.10499559f, -0.03942091f, -0.01435587f, 
    -0.05378934f, 0.00052850f, -0.04235592f, 0.05651060f, 0.12924574f, 0.05047791f, 0.07771118f, 0.02822624f, 
    0.17651133f, -0.04369268f, 0.04311476f, 0.06201969f, -0.11287977f, 0.08882883f, -0.01220074f, 0.00709803f, 
    0.03455837f, 0.13283718f, 0.20309231f, 0.06360325f, 0.00813561f, 0.02922824f, -0.06867319f, -0.10960202f, 
    0.01086237f, 0.04781514f, -0.08012244f, -0.00458444f, 0.08235620f, 0.06644530f, 0.01906744f, 0.01238676f, 
    -0.22086136f, 0.10920320f, 0.01389951f, -0.15758586f, 0.12960155f, -0.04767001f, -0.00668705f, 0.07525948f, 
    0.03152933f, 0.10804646f, 0.09822058f, 0.03484860f, -0.07617170f, -0.11021513f, -0.14174907f, -0.05740364f, 
    0.02001554f, 0.08180092f, -0.09268939f, 0.06836190f, 0.06010336f, -0.01647990f, -0.12992482f, -0.09560880f, 
    0.03113896f, 0.10246457f, 0.07041803f, 0.11815024f, -0.02702219f, 0.01826114f, -0.05358076f, 0.09517061f, 
    0.03155978f, 0.06627571f, 0.07561817f, 0.06859569f, 0.20999634f, 0.07861968f, -0.06388760f, 0.09389579f, 
    -0.07059345f, -0.08595180f, 0.06816773f, -0.06084855f, 0.02425183f, -0.03306517f, -0.07562340f, -0.08472966f, 
    -0.34480450f, -0.28455335f, -0.15971650f, -0.03174557f, -0.07729565f, 0.03727864f, -0.00228429f, 0.05540987f, 
    0.03589026f, 0.08852766f, -0.00675692f, 0.03459943f, -0.04763719f, 0.12741421f, -0.08072253f, 0.07914817f, 
    -0.02260362f, 0.15040782f, -0.14390355f, 0.01346898f, 0.09687586f, -0.05451999f, -0.01166514f, -0.23339356f, 
    -0.33763307f, -0.15902820f, -0.11362047f, -0.27736357f, -0.04912489f, -0.03305902f, -0.10554979f, 0.07254954f, 
    0.01579775f, -0.00689621f, 0.23733713f, 0.08220000f, 0.00540651f, 0.06586716f, -0.04696307f, 0.09584621f, 
    0.03295641f, -0.06895502f, 0.10085586f, 0.02053199f, 0.07018552f, 0.07377915f, 0.05433079f, -0.04624374f, 
    -0.38991204f, -0.37438613f, -0.28691435f, -0.23990840f, 0.00256917f, 0.07016630f, -0.07663298f, -0.01673019f, 
    0.00018415f, 0.04043233f, -0.04842265f, -0.02720171f, -0.56971037f, -0.55723429f, 0.06948283f, 0.02281711f, 
    0.05566711f, 0.12644765f, 0.00194299f, 0.03259827f, 0.17354544f, -0.02857905f, 0.02133462f, 0.18635765f, 
    0.33619732f, -0.03447330f, -0.08459345f, 0.00875969f, -0.12787333f, -0.00007795f, 0.09971443f, -0.02817067f, 
    0.03004412f, -0.03445623f, -0.06364452f, -0.05401785f, -0.26769933f, -0.22656202f, 0.05372284f, 0.01859436f, 
    -0.05877338f, -0.00312761f, 0.04698052f, -0.05542598f, 0.04502488f, 0.04133397f, -0.00857232f, -0.05355277f, 
    0.18163025f, 0.03283632f, -0.03910223f, 0.11951455f, 0.01047513f, -0.08399880f, -0.03539255f, -0.03497098f, 
    0.07591482f, -0.10488410f, -0.21650922f, -0.16409555f, 0.07930074f, 0.05616967f, -0.04543492f, -0.04393110f, 
    0.11255436f, -0.03585827f, 0.01452582f, 0.07942621f, -0.02784522f, 0.08917937f, 0.10298261f, 0.15271951f, 
    -0.00139711f, -0.07500906f, 0.01932070f, -0.04226288f, -0.03370670f, 0.05204149f, -0.07473623f, 0.01890611f, 
    -0.07679004f, 0.08530963f, 0.04589821f, 0.08669572f, -0.22859138f, -0.15408397f, 0.06266748f, -0.05331827f, 
    -0.00772576f, 0.01939853f, 0.03681750f, -0.09046865f, 0.06001068f, 0.02687917f, 0.02187905f, -0.03978810f, 
    -0.25122115f, 0.17330325f, -0.07169301f, 0.04118985f, 0.00211830f, 0.05320736f, -0.04732816f, 0.02044866f, 
    0.08220795f, 0.06608690f, -0.11402310f, 0.06290233f, 0.20597577f, -0.00106224f, -0.14157523f, 0.17307213f, 
    -0.03631853f, 0.00288952f, -0.06568894f, 0.11606874f, -0.04664486f, -0.11179675f, -0.06015433f, 0.00252762f, 
    0.13288020f, 0.00128257f, -0.02100560f, -0.09492146f, -0.02432336f, 0.06881689f, 0.00148060f, 0.03593625f, 
    -0.11010632f, 0.04641653f, -0.03265891f, -0.09971777f, -0.23976478f, -0.23677614f, -0.08459782f, -0.12594007f, 
    0.02689695f, -0.02363103f, -0.09789567f, -0.04737781f, 0.02699377f, -0.04160490f, 0.09061232f, 0.03259290f, 
    -0.35399896f, -0.33836475f, -0.00749734f, -0.17166671f, 0.08465488f, 0.03296357f, -0.05827451f, -0.00399616f, 
    0.03172843f, -0.11771881f, -0.04201228f, -0.02622090f, 0.22829947f, 0.20166489f, -0.05789958f, 0.07376143f, 
    -0.05325405f, -0.10955922f, 0.03374988f, 0.10649172f, -0.04230918f, -0.09547404f, -0.00701364f, 0.07130131f, 
    -0.32139865f, -0.24480234f, -0.00659779f, 0.04970769f, 0.16090079f, 0.02768726f, -0.09583155f, 0.12343083f, 
    0.08900306f, 0.06822950f, 0.04796345f, 0.06971994f, 0.04685724f, 0.05107211f, 0.04661664f, 0.07491442f, 
    -0.07976609f, 0.05468117f, -0.03485762f, 0.00488134f, 0.09096815f, -0.09299333f, 0.04130181f, -0.09221010f, 
    -0.33576742f, -0.09307326f, 0.11059639f, 0.00993022f, 0.01785455f, 0.05875817f, 0.05594103f, -0.00411216f, 
    0.13637099f, 0.11969474f, 0.03313131f, 0.03770917f, 0.24956557f, 0.03722441f, -0.02515516f, -0.02889839f, 
    -0.06237583f, -0.01394236f, 0.05909840f, -0.03905955f, -0.10907421f, -0.07024481f, -0.09780992f, -0.19168591f, 
    0.00010940f, -0.03794600f, -0.01752354f, 0.07278652f, -0.10710956f, -0.04296819f, 0.02321248f, -0.01509373f, 
    0.00272642f, -0.16751342f, -0.22787197f, -0.09076019f, -0.19027315f, -0.24131709f, 0.03371431f, -0.05313961f, 
    0.07458939f, 0.07580056f, 0.01256605f, -0.08093362f, 0.07582676f, 0.04402994f, 0.04894002f, -0.02752938f, 
    0.23154299f, 0.05733141f, -0.18292250f, 0.01857178f, -0.06281192f, 0.01855530f, -0.07745294f, -0.00310064f, 
    -0.00154794f, -0.23989774f, -0.16598700f, -0.14254372f, -0.27977833f, 0.08651333f, -0.03768314f, 0.02308826f, 
    0.05428436f, 0.05952968f, -0.00618832f, -0.07022584f, 0.02303393f, 0.05459291f, 0.03325199f, -0.04956030f, 
    -0.11412006f, -0.03215427f, -0.05261813f, 0.14903618f, 0.05584950f, -0.07047781f, 0.07039610f, -0.16985092f, 
    0.01502032f, 0.11052685f, -0.00434312f, 0.20940524f, 0.19245639f, 0.08730194f, -0.03135842f, -0.00292235f, 
    -0.01701077f, -0.05519300f, 0.00435041f, 0.05332383f, -0.03155869f, 0.08053356f, -0.11278175f, 0.08737241f, 
    -0.08989004f, 0.08477338f, -0.09660280f, 0.02717578f, 0.13418008f, -0.04627025f, -0.15939946f, 0.09667468f, 
    -0.02713651f, -0.09258894f, -0.08665538f, 0.03029214f, -0.21111156f, -0.01389093f, -0.07101725f, -0.01905355f, 
    0.05830766f, -0.06167053f, -0.00728278f, -0.03250318f, -0.03366862f, 0.07210933f, 0.01394635f, -0.03094626f, 
    0.12674557f, 0.02023723f, 0.12680858f, -0.19754207f, 0.10390015f, -0.01555743f, 0.07830816f, -0.07932184f, 
    0.06097176f, 0.05003595f, -0.05546381f, -0.03302805f, 0.12379499f, -0.02985260f, -0.01011261f, -0.04111123f, 
    -0.06841078f, -0.09898254f, 0.00288065f, -0.06465689f, 0.03896925f, 0.08033751f, 0.01521853f, 0.00687215f, 
    -0.47469610f, -0.23922345f, -0.00984804f, -0.10477498f, 0.03395645f, -0.02002251f, -0.08066192f, -0.01739222f, 
    0.05749948f, 0.23164764f, -0.02658257f, 0.01221045f, 0.09229292f, -0.01074270f, 0.09998412f, 0.09169987f, 
    0.00965616f, 0.03431898f, -0.05298560f, 0.03263236f, -0.00934138f, 0.05492669f, -0.06212570f, -0.00490709f, 
    -0.21725920f, -0.17577681f, 0.07324270f, 0.05054227f, 0.07851893f, 0.00882527f, -0.02464340f, 0.04298137f, 
    0.04920744f, 0.08703103f, -0.05982759f, 0.12203964f, -0.13569058f, -0.18610294f, -0.02267081f, 0.00747033f, 
    -0.05190636f, 0.08879890f, 0.00043791f, 0.03939907f, 0.09333957f, 0.07128507f, 0.01047712f, 0.02777476f, 
    0.14239241f, 0.08874459f, -0.17199473f, -0.01988721f, 0.08833483f, 0.07343346f, -0.00769336f, -0.01960927f, 
    -0.02006031f, 0.08932666f, 0.12172619f, 0.14427321f, -0.50905764f, -0.29365119f, 0.05382613f, -0.13197365f, 
    0.12290404f, -0.02476606f, 0.07718600f, -0.03041212f, 0.09140062f, 0.09726847f, 0.01375121f, 0.21809556f, 
    0.12064907f, -0.01584218f, -0.03551949f, -0.04908658f, 0.00542233f, 0.01036204f, -0.04509054f, -0.00982793f, 
    0.02694351f, 0.05063481f, 0.02674575f, 0.02286746f, 0.17331073f, 0.04592140f, 0.01928631f, -0.07708217f, 
    0.03563029f, -0.01117150f, 0.02628907f, 0.08430654f, 0.05243596f, -0.06812455f, 0.03007486f, -0.09370169f, 
    -0.32821441f, 0.02905611f, 0.05575580f, -0.02023701f, 0.06096466f, 0.08193875f, -0.05325264f, -0.13483591f, 
    0.06377491f, -0.13449159f, -0.03658144f, -0.08065540f, 0.15232882f, 0.20268397f, 0.10570530f, -0.23258704f, 
    0.06596430f, -0.02356925f, -0.01166466f, 0.13530423f, -0.00396328f, -0.11952080f, -0.05820997f, 0.11459617f, 
    0.16291751f, 0.10950663f, 0.00138500f, -0.15166241f, 0.08545083f, -0.03104213f, -0.11294067f, 0.13598023f, 
    -0.09883891f, 0.01687359f, 0.04468018f, 0.14388159f, -0.35056135f, 0.01812077f, -0.00032939f, 0.09682457f, 
    0.01516950f, -0.06096109f, -0.03837661f, -0.01713836f, -0.00551617f, 0.02724328f, -0.03938799f, 0.06222885f, 
    0.08326918f, -0.14435986f, -0.18887851f, 0.02189394f, -0.06927083f, -0.14597566f, -0.04039402f, 0.08582893f, 
    -0.00953452f, -0.08361855f, -0.14476548f, 0.01099784f, -0.45165527f, 0.08965535f, -0.12953576f, -0.04059112f, 
    0.03882692f, -0.06507274f, -0.02627109f, 0.04837171f, 0.08478160f, 0.10270900f, 0.03502343f, 0.09372962f, 
    0.01296036f, 0.00804885f, 0.06218477f, -0.05138075f, 0.11061861f, -0.03816596f, 0.00715184f, -0.08896013f, 
    0.00937798f, 0.12104028f, -0.04764953f, -0.02192129f, -0.32587478f, -0.34316173f, -0.07630737f, -0.04389378f, 
    0.00749965f, 0.00550448f, 0.04072113f, -0.00778632f, 0.20565461f, 0.03382122f, 0.03319729f, 0.06716044f, 
    0.05162604f, -0.13131018f, 0.11969800f, -0.08989248f, -0.01006994f, 0.01858238f, 0.02356594f, -0.01762546f, 
    0.02303806f, 0.05270468f, 0.02251808f, 0.07074795f, 0.07404085f, 0.11311652f, -0.07013419f, 0.04314277f, 
    0.03109693f, 0.07161227f, -0.03762638f, -0.10444589f, -0.02214200f, 0.03850863f, 0.02106172f, 0.09166037f, 
    -0.23341370f, -0.05792664f, -0.04563984f, -0.20340644f, -0.04474913f, -0.04514039f, -0.02094466f, 0.10347638f, 
    -0.10944094f, 0.01259538f, 0.03197992f, -0.00249851f, -0.02160745f, 0.12214557f, -0.04520504f, 0.10926131f, 
    -0.00449532f, 0.10494386f, 0.00680312f, 0.01862555f, 0.04539945f, 0.03547226f, -0.01754177f, -0.02434266f, 
    0.13333885f, -0.20590232f, 0.09499583f, 0.05821859f, -0.07489327f, -0.00619347f, -0.03675918f, 0.15027493f, 
    0.02706053f, -0.12454784f, 0.04723080f, -0.02639105f, -0.10085708f, 0.01327228f, 0.06770502f, 0.07650294f, 
    -0.04628593f, 0.00638268f, 0.01637247f, -0.02193342f, -0.04590050f, 0.12687360f, 0.11523309f, 0.10611913f, 
    -0.29342887f, -0.03016520f, -0.11855210f, 0.15393299f, -0.04498047f, 0.15135412f, -0.16600306f, 0.07413656f, 
    0.02196730f, 0.02519783f, 0.03423876f, 0.02814923f, 0.09846424f, -0.11661112f, -0.06965612f, 0.19261749f, 
    -0.07701116f, 0.08158531f, -0.02421990f, 0.06027055f, 0.09082416f, 0.02640112f, 0.07096383f, -0.02813622f, 
    -0.22458063f, -0.27161226f, 0.03807549f, -0.02689609f, -0.05753127f, 0.04273878f, -0.07939192f, 0.09936825f, 
    -0.06376584f, 0.00709080f, -0.06272950f, -0.10605530f, -0.26135266f, -0.09926488f, 0.05326907f, -0.05890694f, 
    0.09029858f, -0.04100600f, -0.09266016f, 0.10147138f, -0.02311492f, -0.09114857f, -0.13230264f, -0.00806712f, 
    -0.17342602f, 0.16560894f, -0.07050052f, 0.06403757f, -0.09176299f, 0.00534661f, -0.16811182f, -0.22797900f, 
    -0.02579894f, -0.00882260f, -0.06802730f, -0.14660987f, -0.20465469f, -0.20566724f, 0.19629084f, 0.04682156f, 
    -0.03695229f, -0.02429304f, 0.07649809f, -0.06143752f, -0.03579176f, -0.05206612f, 0.15547742f, 0.02358735f, 
    0.29426920f, 0.04669125f, -0.22763234f, 0.08602119f, 0.09333606f, 0.05688991f, -0.04990558f, 0.05454938f, 
    0.09368325f, -0.00490620f, 0.01456840f, -0.02269249f, -0.54756099f, -0.00831311f, 0.01957389f, -0.21240678f, 
    0.04564200f, -0.09317674f, 0.03395611f, 0.08932356f, -0.00959694f, -0.04225777f, -0.01749348f, 0.11520956f, 
    -0.09915282f, 0.03082521f, -0.01489867f, 0.09681638f, -0.17267700f, 0.08641357f, -0.07254001f, -0.07744499f, 
    -0.10895362f, 0.00304088f, -0.03951972f, -0.16289878f, 0.25332487f, -0.16326089f, 0.00072959f, 0.04826620f, 
    -0.02714257f, 0.04654764f, 0.01861733f, -0.02396522f, -0.06177448f, -0.06978381f, -0.08553715f, 0.08364420f, 
    0.01654047f, -0.08056489f, -0.11550950f, 0.23918532f, -0.01330953f, -0.03560234f, -0.01771606f, -0.07012869f, 
    0.00695458f, -0.03177926f, -0.05496474f, 0.06397568f, -0.29948267f, -0.00426967f, 0.06402766f, -0.15067278f, 
    -0.05061427f, -0.01643301f, 0.06402368f, 0.09389406f, 0.08464698f, 0.05006551f, 0.04515200f, 0.09175517f, 
    0.17073734f, -0.10499967f, -0.14826514f, -0.04624340f, 0.01249419f, 0.07295864f, 0.04583098f, -0.04021731f, 
    -0.09237263f, -0.04930633f, -0.09016497f, -0.00081491f, -0.10745510f, -0.15826291f, 0.06409681f, 0.17531078f, 
    -0.01427124f, 0.08367322f, -0.02169890f, -0.02363588f, 0.07208182f, 0.05845801f, 0.08409438f, -0.03353809f, 
    -0.28404281f, -0.00911571f, -0.17477615f, -0.13893248f, 0.14760624f, 0.01396087f, 0.01568957f, 0.03376151f, 
    0.04395649f, -0.00796663f, -0.05329179f, -0.05909404f, 0.04675535f, 0.08531810f, -0.06851434f, 0.06062889f, 
    0.06929342f, 0.11105382f, 0.00061774f, 0.06117065f, -0.03878628f, 0.05419858f, -0.07778324f, -0.10102211f, 
    -0.24086055f, 0.12634647f, -0.10506696f, 0.07293703f, 0.08305563f, -0.03754735f, 0.04857827f, 0.06914575f, 
    -0.02108997f, 0.05325381f, 0.02409469f, -0.10522778f, -0.03000702f, -0.01683962f, -0.12014489f, 0.11871225f, 
    0.08084026f, -0.01351875f, -0.06025769f, -0.01702188f, -0.08620053f, -0.03523412f, 0.00179202f, -0.03153168f, 
    0.21282506f, -0.19098382f, 0.07007403f, 0.06232623f, -0.05094827f, 0.04760420f, -0.01485608f, 0.00642682f, 
    0.07862426f, 0.08771738f, 0.00285243f, 0.09512936f, 0.03553875f, 0.18650493f, -0.06800491f, -0.05729435f, 
    -0.05786947f, -0.06142650f, 0.01976363f, -0.00851406f, 0.04192131f, -0.00508647f, -0.05589940f, -0.11819378f, 
    -0.00039343f, -0.10398386f, 0.11636369f, -0.07419807f, 0.10094158f, -0.07776196f, -0.04420520f, 0.03432079f, 
    -0.15330097f, -0.14958085f, -0.14618048f, -0.00605912f, 0.00438753f, 0.06819306f, -0.11972816f, -0.03085051f, 
    0.22109805f, -0.02959649f, -0.11836632f, -0.07323710f, 0.04958273f, 0.01906854f, -0.05802963f, 0.01329731f, 
    0.41359699f, 0.03164694f, 0.07351527f, -0.04213604f, -0.19031666f, -0.10813555f, 0.00550076f, 0.02867667f, 
    0.11212714f, -0.08394588f, 0.07675102f, -0.00930578f, -0.29909557f, 0.07664283f, -0.00502277f, -0.14055935f, 
    0.07685793f, -0.04002808f, -0.01797609f, -0.19808091f, -0.01668405f, 0.02650822f, 0.08137963f, 0.02015345f, 
    -0.02084136f, 0.12370771f, -0.15966502f, -0.04297447f, -0.12630183f, -0.03031519f, 0.02456077f, 0.03825411f, 
    0.03268952f, -0.01295067f, 0.01155725f, 0.02242667f, 0.19356614f, -0.16979299f, -0.20599528f, 0.12162670f, 
    -0.06416502f, -0.00585221f, 0.00248252f, -0.01545031f, 0.01146185f, 0.00422387f, -0.07509243f, 0.07637406f, 
    0.30526626f, 0.03049077f, -0.19265908f, -0.08727197f, -0.07455313f, -0.00184071f, -0.05822694f, -0.00804244f, 
    0.02444291f, 0.04873723f, -0.00057002f, 0.01920884f, 0.20266759f, 0.05570186f, 0.04457508f, -0.02184888f, 
    0.03131967f, 0.05282021f, 0.00986367f, 0.07718680f, -0.00957154f, 0.06816559f, 0.03627674f, 0.15169291f, 
    0.13802820f, 0.09816914f, -0.05894940f, -0.10790266f, 0.16412361f, -0.00415556f, -0.04012100f, 0.10300634f, 
    -0.01377770f, 0.02783793f, -0.04289760f, 0.06856465f, 0.15611161f, 0.03172810f, -0.06521259f, 0.07827164f, 
    -0.01695827f, -0.11928923f, 0.02109834f, -0.09009223f, -0.03494131f, 0.01969797f, -0.06974123f, -0.02669291f, 
    0.35476434f, -0.07249310f, -0.12904520f, -0.02786593f, -0.00803967f, -0.11110388f, -0.21147376f, -0.04612404f, 
    0.01941628f, -0.00129653f, -0.02651016f, -0.04098418f, 0.08259291f, -0.00240660f, -0.02829338f, 0.06657067f, 
    0.04862090f, -0.12525779f, 0.00131514f, -0.06236731f, 0.02861481f, 0.05186705f, 0.03767323f, 0.03090708f, 
    -0.09134411f, -0.02139894f, -0.06283796f, 0.04638096f, -0.21721943f, 0.01061457f, -0.06108774f, -0.02796845f, 
    0.03757127f, 0.01847584f, -0.09068698f, -0.12435055f, -0.00567946f, 0.21611750f, -0.02308490f, 0.10005546f, 
    0.05652447f, 0.01403460f, 0.10833715f, 0.03435892f, 0.02260397f, 0.05153761f, -0.00114467f, 0.06464086f, 
    -0.24576786f, 0.00372863f, -0.20913638f, 0.01683454f, 0.02177278f, 0.04293749f, 0.08659495f, -0.02413470f, 
    0.01125607f, 0.06279839f, 0.07446069f, 0.05756915f, -0.15066138f, 0.09116209f, -0.17693996f, 0.01065577f, 
    -0.00674604f, -0.03596167f, 0.02710148f, 0.08353376f, 0.06017477f, -0.05487539f, -0.01684183f, -0.03595653f, 
    0.15066922f, -0.07813051f, 0.11231196f, -0.01972554f, -0.01028879f, 0.03479190f, -0.15304896f, -0.12309366f, 
    -0.09814660f, 0.07036628f, 0.00222782f, -0.06494795f, -0.14778590f, 0.01952915f, 0.10595611f, -0.07120271f, 
    -0.04377456f, -0.03021732f, -0.01942339f, 0.11240982f, -0.06044624f, 0.09316100f, 0.12875614f, -0.04757651f, 
    -0.42979562f, 0.24862902f, -0.17376897f, -0.07881255f, 0.09823498f, 0.03349848f, 0.08515573f, 0.06761016f, 
    0.00440321f, -0.00452629f, 0.01035860f, -0.01363458f, 0.02040523f, -0.24025637f, -0.05183036f, 0.06025281f, 
    -0.03213151f, 0.04196529f, -0.09817004f, 0.06649815f, 0.08630511f, -0.01444993f, -0.07586942f, 0.06680236f, 
    0.19332770f, -0.18509933f, -0.09282065f, 0.17567410f, 0.10671697f, -0.13611199f, 0.04115495f, -0.02634289f, 
    0.05836318f, 0.05560778f, 0.02551890f, 0.02085513f, 0.03571807f, -0.15232848f, -0.04047455f, 0.15343298f, 
    0.03732048f, 0.07805324f, -0.16770585f, 0.06284187f, -0.04686650f, 0.10971740f, -0.03896705f, -0.08767562f, 
    -0.23336321f, 0.07513200f, -0.10568940f, -0.15154286f, 0.02024139f, -0.10900324f, 0.00439262f, 0.10488521f, 
    0.04287901f, -0.03251487f, -0.07482824f, 0.06730929f, 0.25705129f, 0.08669749f, -0.05836097f, 0.10424054f, 
    -0.02963778f, 0.00964898f, 0.01073394f, -0.09495006f, 0.02282103f, -0.03634167f, -0.04876506f, 0.06370619f, 
    0.21787436f, 0.07895885f, -0.02525201f, -0.04884506f, 0.07291569f, 0.01108228f, -0.00735627f, -0.06737583f, 
    0.01937635f, -0.02718473f, -0.01821747f, 0.01415119f, 0.20665179f, 0.05250080f, -0.09543963f, 0.00116834f, 
    0.20180909f, -0.06803183f, -0.02878281f, 0.08966427f, -0.05801729f, -0.04604096f, 0.01427336f, 0.09248552f, 
    0.08242710f, -0.00092165f, -0.15060833f, 0.22674775f, 0.00407967f, 0.09347501f, 0.09028417f, 0.02668809f, 
    -0.05877659f, 0.06552421f, 0.05041846f, -0.19746429f, 0.27954882f, -0.16831625f, -0.02933686f, -0.10133879f, 
    0.10136454f, -0.13827085f, -0.05537511f, 0.06872138f, -0.04449237f, -0.02676093f, 0.02819288f, 0.11851702f, 
    -0.06185158f, 0.04494402f, -0.04647176f, 0.02729638f, 0.06099732f, 0.00924052f, 0.05104278f, -0.07811493f, 
    -0.01431438f, 0.01457581f, 0.02189161f, -0.03410804f, -0.08691384f, 0.00610837f, 0.20986357f, -0.10487168f, 
    -0.05989843f, -0.07575179f, -0.12877031f, 0.02190035f, -0.06262397f, -0.13272953f, 0.11792690f, -0.03972795f, 
    0.04943869f, 0.27931330f, -0.05855912f, -0.11786342f, 0.04227166f, -0.06260826f, 0.01602697f, -0.11024337f, 
    0.07783422f, 0.08373471f, 0.07667313f, 0.03686722f, -0.31217548f, 0.02014272f, -0.21227081f, -0.05341592f, 
    -0.09173097f, -0.04738766f, 0.03935942f, 0.09957620f, 0.00165524f, 0.02692479f, 0.03858692f, -0.14219581f, 
    -0.08244267f, -0.04395638f, -0.09740783f, 0.20270520f, 0.04142176f, 0.02345896f, 0.08620151f, 0.13218489f, 
    0.00214691f, -0.02822469f, -0.11795242f, -0.09841646f, 0.22813100f, 0.02168286f, 0.03365846f, 0.06008476f, 
    -0.07415141f, -0.00326441f, -0.07058574f, 0.04230459f, 0.02948735f, 0.10916566f, 0.01324285f, 0.06263356f, 
    -0.15033689f, -0.37618253f, -0.01803199f, -0.18708257f, 0.09219872f, -0.03576697f, 0.11914635f, 0.01190078f, 
    -0.01998019f, 0.04470572f, 0.01366164f, 0.03054136f, 0.25149837f, 0.06057106f, -0.14782108f, 0.10999856f, 
    -0.18542317f, -0.05017167f, -0.05723636f, 0.09691633f, -0.01251411f, -0.02624315f, 0.01209738f, -0.04568001f, 
    0.15848272f, -0.16574731f, 0.00482880f, 0.01396691f, 0.03858500f, -0.03026576f, -0.12753835f, -0.11411697f, 
    -0.14078455f, -0.04223109f, -0.11879835f, -0.10611020f, 0.44733390f, -0.00225963f, -0.16325468f, -0.05162790f, 
    0.11889931f, -0.08688311f, 0.00244097f, 0.00750089f, -0.01568841f, 0.00451734f, 0.00644225f, -0.12057050f, 
    -0.06905649f, 0.09958223f, 0.04506072f, 0.00962031f, 0.07739812f, -0.04813314f, -0.00921618f, -0.09390986f, 
    -0.05866898f, 0.04203922f, -0.04371959f, -0.01828479f, 0.07498619f, -0.12557808f, -0.16178896f, 0.05189683f, 
    -0.12822421f, 0.01878027f, 0.03645053f, -0.03060600f, 0.07783113f, 0.05476534f, 0.07053138f, -0.02052737f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07114715f, 0.00625545f, 0.00079335f, 0.01414940f, 0.04657843f, -0.01891870f, -0.00212378f, -0.06994507f, 
    -0.00455281f, 0.04462567f, 0.09941977f, -0.00147861f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
