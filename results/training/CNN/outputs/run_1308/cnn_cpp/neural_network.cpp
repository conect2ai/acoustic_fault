#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.48632374f, -0.51853478f, 0.29134405f, 0.83475870f, -0.53149545f, -0.36946005f, 0.24664842f, -0.05554268f, 
    0.31984138f, -0.74979669f, -0.22843647f, 0.37861463f, -0.39943066f, 0.27625379f, -0.62907779f, 0.53357232f, 
    0.41593140f, 0.45521426f, 0.28946933f, -0.21133207f, -0.48239571f, -0.71553946f, -0.31167248f, 0.96911961f, 
    -0.11929107f, -0.38848662f, -0.25023285f, -0.26905045f, 0.58298987f, 0.59861273f, -0.60691154f, -0.11247388f, 
    -0.50724012f, 0.53478420f, -0.62464339f, -0.39133337f, -0.17262159f, -0.90769398f, -0.71518081f, 0.50648087f, 
    0.28343147f, 0.00699658f, -0.58710629f, -0.22039680f, -0.11345097f, -0.88124698f, -0.23769262f, 1.03328586f, 
    -0.04416605f, -0.16080962f, -0.82048750f, -0.43851674f, -0.01845234f, -0.46602762f, 0.42309910f, -0.78517944f, 
    -0.12752114f, -0.66565371f, -0.43748036f, -0.87487692f, 0.24976934f, -0.02499679f, 0.35272536f, -0.35354084f, 
    0.26826057f, 0.85537982f, -1.03794336f, -0.83812189f, 0.59315944f, 0.13577820f, 0.07312440f, 0.40551317f, 
    0.82301790f, -1.13109636f, -0.64503795f, -0.20841947f, 0.36946788f, 0.60629541f, -0.14526750f, 0.19006114f, 
    0.26270485f, 0.51804638f, -0.04919902f, 0.16096134f, 0.75639915f, -0.27706379f, 0.70579231f, 0.14578748f, 
    0.25820723f, -0.43289313f, -0.92545754f, -0.34349737f, -0.30800733f, 1.17008734f, -0.29103807f, -0.15629019f, 
    -0.15779521f, -0.10073958f, 0.00424565f, -1.01952136f, -0.82091618f, 0.33074588f, 0.23930274f, -0.12475556f, 
    -0.48279625f, 0.09229044f, -0.17675984f, -0.27862251f, -0.22221975f, -0.33721340f, -0.88347358f, -0.49387196f, 
    -0.59519982f, 0.08563422f, 0.43170351f, 0.01164177f, 0.44466057f, -0.46822917f, 0.37356487f, -0.50641632f, 
    -0.27024958f, -0.65925521f, 0.35251516f, -0.68792713f, -0.13917156f, -0.53924727f, -0.25838783f, 0.15464048f, 
    -0.84670967f, -0.64619136f, -0.55360073f, -0.45920652f, -0.27023187f, -0.47831398f, -0.19840185f, 1.07852745f, 
    0.02805802f, -0.68544769f, 0.07238843f, 0.01471657f, -0.76813120f, -0.30766013f, 0.12833554f, -0.51752967f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05407903f, 0.00512158f, 0.34099409f, 0.03494166f, 0.18632917f, -0.41144300f, 0.42165413f, 0.15000719f, 
    0.25921714f, 0.00148666f, -0.10981827f, -0.06267951f, -0.01684883f, -0.00687612f, -0.38187951f, 0.32655194f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.08995626f, -0.05762667f, 0.23052791f, -0.08206703f, 0.12562023f, -0.09030026f, 0.02355254f, -0.11733943f, 
    0.07238363f, 0.01052137f, 0.11763525f, -0.02263304f, 0.03700807f, -0.08017693f, 0.00356176f, 0.03654394f, 
    0.17715389f, 0.03769190f, 0.10550668f, 0.21838802f, 0.27551168f, -0.14688240f, 0.10562262f, -0.10602533f, 
    -0.01024223f, -0.01057459f, -0.12278715f, -0.09399534f, -0.02524331f, -0.01172998f, 0.05295117f, -0.01405808f, 
    0.07767648f, -0.00865736f, 0.02507345f, 0.00131725f, 0.18813752f, 0.06912585f, 0.30759627f, 0.15743834f, 
    0.21078523f, -0.00532229f, -0.25543725f, 0.05760552f, 0.21901380f, -0.03821658f, 0.03519840f, -0.05792496f, 
    0.09296001f, 0.15842804f, 0.16339733f, -0.02054529f, 0.08183342f, 0.01453573f, -0.10407200f, -0.05584427f, 
    0.04621393f, 0.03344036f, -0.00010744f, -0.02586665f, -0.00759469f, 0.02616946f, 0.29025531f, -0.22308165f, 
    0.04023471f, 0.18442960f, 0.22407262f, 0.09299996f, 0.04740904f, -0.15782863f, -0.06804477f, 0.12531859f, 
    0.08600019f, 0.09171768f, 0.03721529f, -0.13897324f, 0.00001043f, -0.01854221f, -0.01010526f, -0.06343202f, 
    0.02884454f, -0.06169372f, -0.20625982f, -0.13157865f, 0.52961326f, -0.01852740f, 0.01520160f, 0.16220719f, 
    0.05119602f, 0.05847326f, -0.08813982f, 0.02610670f, -0.09426789f, 0.00867909f, 0.00409734f, -0.09390453f, 
    -0.07796971f, 0.07775193f, 0.01504613f, -0.14263429f, 0.36267129f, 0.60300773f, 0.21019389f, -0.29600841f, 
    0.16538824f, -0.16166866f, -0.00552780f, -0.36942679f, 0.20975229f, -0.10602817f, -0.13689040f, 0.01801414f, 
    -0.12902749f, 0.05525784f, 0.01458583f, 0.10210711f, 0.02644744f, -0.05507882f, 0.05423016f, -0.11811257f, 
    0.19983627f, -0.21995112f, -0.33338752f, -0.09193128f, 0.00614250f, 0.18826514f, 0.18375823f, -0.00727126f, 
    -0.02865443f, -0.21587071f, 0.06207300f, 0.06816196f, 0.05100076f, 0.04792667f, 0.08061644f, 0.07459933f, 
    0.02641944f, 0.07680035f, -0.05752968f, 0.17839295f, 0.47872490f, -0.01448079f, -0.51453853f, -0.02390815f, 
    -0.12729213f, -0.11312033f, -0.10784061f, -0.12631246f, -0.02727612f, -0.13225320f, 0.02017261f, 0.05705607f, 
    0.05426588f, -0.06151956f, -0.01714374f, -0.10536083f, -0.08834908f, 0.00176996f, 0.05026845f, 0.03288755f, 
    -0.13254973f, 0.27050278f, -0.10299006f, -0.00550911f, 0.45063123f, -0.04217097f, 0.05455017f, 0.12661560f, 
    -0.06591292f, 0.12705693f, 0.10053494f, 0.09527967f, -0.07707676f, 0.11364079f, 0.05588629f, 0.11017250f, 
    -0.03455837f, 0.09478766f, 0.18839711f, -0.00014332f, -0.45589602f, -0.04368208f, 0.17510760f, -0.13610631f, 
    -0.13041689f, 0.02073976f, 0.00961599f, 0.04515710f, 0.01877886f, 0.14180778f, 0.16671975f, 0.00383264f, 
    -0.02241383f, 0.19417803f, 0.12735543f, -0.04658915f, 0.17082480f, -0.00144694f, 0.00685411f, 0.11685573f, 
    -0.08560724f, -0.17176561f, -0.04736503f, -0.27578151f, 0.18227480f, 0.06570152f, -0.14245336f, 0.06765075f, 
    0.02552444f, -0.02928622f, -0.07868914f, 0.03680265f, -0.06827518f, 0.06643394f, 0.16810422f, -0.21556316f, 
    -0.03472014f, 0.05449827f, 0.02073669f, 0.03786037f, 0.02334865f, 0.10511155f, -0.01749777f, -0.19581725f, 
    -0.01456152f, 0.08464503f, 0.08793259f, -0.00854312f, 0.10970224f, -0.11192089f, -0.13679931f, -0.03316433f, 
    -0.13314204f, 0.08556596f, -0.01655416f, -0.06759848f, -0.08581254f, -0.08352069f, 0.04974568f, 0.03955296f, 
    0.02447950f, -0.20047174f, -0.51481652f, -0.24017072f, 0.15043463f, 0.10032164f, 0.22139350f, 0.11336065f, 
    0.01563219f, -0.04775483f, -0.05077095f, -0.08745238f, -0.13410679f, 0.00101320f, -0.01850466f, -0.01508441f, 
    0.08502757f, 0.10985828f, 0.00541976f, 0.08172819f, 0.29594213f, -0.07974569f, -0.08380543f, 0.00661137f, 
    0.10593574f, -0.09459522f, 0.08479126f, -0.05276195f, 0.18982874f, 0.01905580f, 0.05960454f, -0.12012237f, 
    0.02796273f, 0.05023371f, -0.04781261f, 0.07303442f, 0.06297959f, -0.15074727f, 0.01470332f, -0.09048069f, 
    0.20256324f, -0.29242566f, -0.25892746f, -0.14647515f, 0.12081319f, 0.05530312f, 0.10566893f, 0.02991008f, 
    0.11552836f, -0.23479779f, -0.01969294f, -0.03806109f, -0.04488905f, -0.11659782f, -0.02425848f, -0.04207030f, 
    -0.05396663f, -0.02625256f, 0.03741842f, -0.05484819f, -0.45758095f, -0.18410283f, 0.49519959f, 0.09367372f, 
    0.16535939f, -0.05842539f, 0.07490274f, 0.06327237f, -0.15721750f, -0.04573986f, 0.21496445f, -0.06806504f, 
    0.04592070f, -0.00736631f, 0.07039514f, -0.00954903f, -0.04847507f, -0.03059327f, -0.17305420f, -0.21132354f, 
    0.12419576f, 0.17037724f, -0.20719914f, 0.25847298f, -0.17107533f, 0.20925717f, -0.19626351f, 0.20194739f, 
    0.07626043f, 0.06492474f, -0.09452344f, 0.04342465f, -0.04362869f, 0.04060838f, 0.08349033f, 0.08316169f, 
    0.11151315f, 0.08347569f, -0.02301523f, 0.09349483f, -0.49845406f, -0.02662785f, 0.14892869f, -0.09992038f, 
    -0.07111548f, -0.12034741f, 0.13421898f, -0.11874405f, 0.01761417f, 0.07944212f, -0.04656925f, 0.02349636f, 
    -0.10074440f, -0.00393387f, 0.03729252f, -0.01250664f, -0.02014009f, 0.06035417f, 0.01073506f, -0.13733368f, 
    -0.00881491f, 0.18523286f, 0.02699120f, 0.07408587f, 0.04858086f, -0.00270416f, -0.00358444f, 0.08566908f, 
    0.25263023f, 0.12037576f, -0.01025405f, 0.02192824f, 0.13965529f, -0.02934569f, 0.12422224f, 0.08899587f, 
    0.12522762f, 0.02724557f, 0.21499529f, 0.09130177f, 0.09033606f, -0.20584121f, -0.45165315f, 0.01866526f, 
    0.25266716f, 0.08516516f, 0.20161280f, 0.19025980f, -0.09463775f, 0.14282854f, -0.02088443f, -0.02874915f, 
    -0.00143278f, -0.03622624f, 0.07849304f, 0.23196419f, -0.00818217f, 0.10605093f, 0.08718033f, 0.09142192f, 
    -0.23140253f, 0.33854789f, 0.08053949f, 0.30486467f, 0.10868692f, 0.05100317f, -0.05632792f, -0.05664324f, 
    0.09269404f, -0.11733048f, -0.02214791f, 0.03409162f, 0.02827518f, 0.22967303f, 0.01897165f, 0.12012611f, 
    0.01393301f, 0.08579325f, -0.04924332f, 0.01399109f, -0.30642879f, -0.22718026f, -0.32488981f, 0.26671705f, 
    0.13454732f, -0.01674344f, 0.26089439f, 0.05036319f, -0.10512006f, -0.18390469f, -0.11727987f, -0.15743455f, 
    0.02626305f, 0.06950354f, 0.12331884f, -0.14705445f, -0.06320821f, -0.02903341f, -0.14831537f, -0.16526029f, 
    -0.22563839f, 0.12255213f, -0.19993764f, 0.12308477f, -0.01013944f, 0.03639526f, -0.04638831f, 0.03780013f, 
    0.25018454f, 0.15736845f, -0.03430550f, -0.01257742f, -0.01673414f, 0.04979760f, 0.03376093f, -0.04986573f, 
    -0.07832186f, 0.07932279f, 0.03617142f, -0.01321345f, -0.14231238f, -0.02030802f, -0.03276495f, -0.19287625f, 
    0.24328303f, 0.07865059f, 0.12425891f, 0.16271961f, 0.20780037f, -0.06013031f, -0.09426962f, -0.09234751f, 
    0.10393160f, 0.03139469f, 0.08178642f, 0.09386088f, 0.00513955f, -0.09017031f, 0.38838065f, 0.03397830f, 
    0.01834615f, 0.60952890f, 0.31284136f, -0.00519332f, -0.04156303f, -0.06995779f, 0.06240913f, -0.18959470f, 
    0.11146461f, 0.13234992f, 0.21901746f, 0.06132748f, 0.04042719f, 0.02097153f, 0.10420674f, -0.02926449f, 
    0.01696756f, -0.09012394f, 0.14846054f, -0.00419958f, 0.18400480f, 0.01300510f, 0.03595360f, 0.35255399f, 
    0.12866938f, -0.02859718f, 0.00364696f, -0.06229234f, -0.13314496f, -0.04083300f, -0.00300572f, 0.27143902f, 
    0.36129186f, 0.05435737f, 0.13755061f, 0.08454292f, 0.07946059f, 0.05649286f, -0.13715656f, -0.00450995f, 
    -0.32737032f, 0.23596725f, -0.17856534f, 0.45697409f, 0.10330141f, 0.06862441f, -0.20884898f, -0.03483439f, 
    -0.24052659f, -0.00359103f, -0.10254285f, 0.06628453f, 0.07396076f, -0.00227562f, -0.16704015f, 0.07177248f, 
    0.08206306f, -0.04854175f, -0.03104797f, -0.02249563f, -0.44243097f, 0.15223414f, -0.28001973f, 0.39655718f, 
    0.11240374f, -0.04695797f, -0.07961521f, -0.00523850f, -0.07046400f, -0.05964094f, -0.12965505f, -0.02361684f, 
    0.14785521f, -0.00947406f, 0.02558028f, 0.01949822f, 0.03371745f, -0.00359023f, 0.01897003f, -0.03668832f, 
    -0.54915059f, 0.00664445f, 0.19785249f, 0.31375298f, 0.02919197f, -0.04734263f, -0.06299981f, -0.09297844f, 
    0.01027276f, 0.12830617f, 0.11602548f, 0.06014773f, -0.01588293f, -0.05723589f, 0.05451425f, -0.07645479f, 
    -0.12822498f, -0.16766164f, -0.01857919f, -0.11896910f, 0.04669672f, -0.16066547f, -0.09332597f, -0.01721573f, 
    0.12431455f, -0.02370360f, 0.17269504f, 0.25632393f, 0.18658732f, 0.09584059f, -0.02951679f, 0.00453641f, 
    0.05703006f, 0.03341684f, 0.08377955f, -0.01811669f, -0.00551624f, 0.23861474f, 0.14064437f, 0.00283788f, 
    -0.13837644f, -0.12316086f, -0.39072490f, 0.04025692f, 0.19186462f, -0.15461199f, -0.14687499f, 0.07836957f, 
    -0.04969606f, -0.03858085f, -0.09356709f, 0.05556050f, -0.02122599f, -0.02358824f, 0.12599172f, -0.01385095f, 
    -0.15947039f, -0.01786700f, 0.02353074f, -0.01590191f, 0.31377912f, 0.11806376f, -0.27288124f, 0.36570644f, 
    -0.00472066f, 0.20233737f, 0.07189613f, 0.19513974f, 0.21152139f, 0.11409102f, -0.05128105f, 0.07413224f, 
    -0.02428716f, 0.08281740f, 0.01058155f, 0.07130137f, 0.20171805f, 0.15398575f, -0.04014612f, 0.28575128f, 
    -0.04032036f, 0.02148130f, -0.05749395f, -0.01907557f, -0.00464890f, 0.00871894f, -0.05540754f, 0.00640403f, 
    0.00751940f, -0.05179465f, -0.04837231f, -0.05476138f, -0.05367242f, -0.02130878f, -0.02361504f, -0.01459511f, 
    0.00605334f, 0.03702400f, 0.03762859f, -0.01289337f, 0.01917205f, -0.02880784f, -0.00630032f, 0.03727950f, 
    0.01143133f, -0.05470718f, -0.00918392f, 0.02433751f, -0.04406372f, -0.01414322f, 0.03624204f, -0.05804351f, 
    -0.01107894f, -0.00467548f, -0.01303677f, -0.01736992f, 0.01897028f, -0.04631349f, -0.04749808f, -0.00653005f, 
    0.01009262f, 0.00262784f, -0.05770926f, -0.01273841f, 0.03815160f, -0.06016409f, -0.00183822f, -0.03800422f, 
    0.02242830f, -0.03646381f, -0.01811909f, 0.04036288f, 0.00105449f, 0.03479157f, 0.03108294f, -0.02135089f, 
    0.00311561f, 0.00582171f, 0.01176531f, 0.03396502f, -0.02236330f, 0.03277527f, -0.06067825f, -0.00702743f, 
    0.04432373f, 0.03007270f, 0.01928103f, -0.04833004f, -0.05141252f, -0.01054796f, 0.01684608f, 0.00403165f, 
    -0.05467437f, -0.05927220f, 0.00121468f, 0.04447734f, 0.02214724f, -0.00729627f, -0.03598753f, -0.06342261f, 
    0.04452253f, -0.00161237f, 0.01584741f, 0.02915800f, 0.00084478f, 0.01569769f, 0.04549743f, -0.02270664f, 
    -0.04809091f, -0.04228653f, -0.03281599f, 0.03197745f, 0.02379478f, 0.00773025f, -0.00763200f, -0.06494451f, 
    0.03434810f, -0.00344019f, -0.02894601f, 0.02121327f, 0.03024116f, -0.01293386f, 0.00757114f, 0.01555115f, 
    -0.01861109f, 0.00312535f, 0.00852394f, -0.03428818f, -0.04119712f, -0.03151653f, 0.04553693f, 0.02242087f, 
    0.03919103f, -0.05840098f, 0.04178269f, -0.05229235f, -0.03826210f, -0.04938956f, -0.00659445f, 0.03329753f, 
    -0.03655919f, -0.04157063f, 0.02072160f, 0.00799973f, 0.03241502f, 0.04769376f, 0.03023331f, -0.02782329f, 
    -0.01820667f, -0.02684410f, -0.00779720f, 0.00716630f, -0.06153072f, -0.04033142f, -0.03721115f, -0.03361140f, 
    0.03717510f, 0.00746213f, 0.01256097f, -0.01021525f, -0.04255638f, -0.05134239f, 0.03012537f, -0.04299176f, 
    -0.04778679f, -0.03636954f, 0.01860119f, 0.02040200f, -0.04922211f, -0.02209529f, -0.04605696f, -0.03815095f, 
    -0.04475724f, 0.03731512f, 0.03462207f, -0.02539210f, 0.02103103f, -0.00777200f, 0.00135673f, -0.05147306f, 
    0.01471506f, 0.00681234f, 0.01011318f, 0.01664563f, -0.02481395f, -0.02096062f, 0.02708895f, 0.02698583f, 
    -0.01860984f, -0.03953176f, 0.04411027f, 0.04231582f, -0.04395541f, 0.04563751f, 0.03223466f, -0.05163096f, 
    -0.05758764f, 0.02722052f, 0.04590801f, -0.03951872f, -0.00877532f, 0.04921551f, 0.02581733f, 0.01785559f, 
    -0.06076836f, 0.00083359f, -0.03499780f, -0.00077785f, -0.03233767f, -0.03247846f, 0.02772138f, -0.04629318f, 
    -0.04344260f, -0.05331449f, -0.05688681f, -0.05103641f, 0.02367132f, 0.02631037f, 0.03662460f, -0.01121769f, 
    -0.02723697f, -0.00080152f, 0.03549977f, -0.05165158f, -0.04012250f, -0.04954374f, 0.01094136f, 0.01356513f, 
    -0.03524467f, -0.01274653f, 0.02322026f, 0.00396437f, -0.01738584f, 0.02684109f, -0.00115691f, -0.03832952f, 
    -0.04569874f, -0.00628323f, -0.02520700f, 0.00742119f, 0.04486807f, -0.02861759f, -0.04227694f, -0.06427954f, 
    -0.03939577f, 0.03186679f, 0.04303333f, -0.03985542f, -0.00658422f, -0.03369628f, 0.04018358f, -0.01459680f, 
    -0.04090744f, -0.00129308f, -0.00001231f, 0.03161680f, -0.03905728f, -0.04793050f, -0.01318840f, -0.00143542f, 
    -0.05882120f, -0.02290695f, 0.00574541f, 0.02921255f, 0.02393608f, -0.02278545f, -0.05247119f, -0.01844991f, 
    -0.00431950f, -0.02268949f, -0.00372367f, -0.06098565f, 0.00425943f, 0.01818593f, -0.02326175f, -0.06065677f, 
    -0.02168617f, -0.06082915f, -0.05703291f, 0.02184299f, 0.03835909f, -0.03200258f, -0.04807842f, 0.03389522f, 
    -0.01782011f, 0.04059747f, 0.02081336f, 0.04152226f, -0.03240081f, -0.01583179f, 0.01780734f, 0.01682771f, 
    -0.02236563f, -0.04105917f, -0.05158913f, 0.02860520f, 0.03885284f, -0.05777158f, -0.05925308f, 0.02294269f, 
    0.03290821f, 0.02868682f, -0.04618951f, -0.02236491f, 0.03400011f, 0.02904664f, -0.02185719f, -0.03648666f, 
    -0.01190522f, 0.02344758f, 0.03641354f, -0.00616128f, -0.05129489f, -0.04347845f, -0.03965998f, -0.05553636f, 
    -0.06171113f, 0.03441671f, -0.04235670f, 0.02477316f, 0.03860685f, -0.01865142f, -0.03273803f, 0.01051260f, 
    0.02636089f, 0.02446584f, 0.02447435f, 0.00474030f, -0.04847993f, -0.02925347f, -0.03782985f, 0.02208832f, 
    -0.02459362f, 0.03189860f, -0.06149375f, -0.00146346f, -0.03754942f, -0.00801730f, 0.00680229f, -0.02989347f, 
    -0.15056624f, 0.10097780f, 0.11223163f, -0.07054015f, 0.02429220f, -0.05479378f, -0.00162819f, 0.02093445f, 
    0.00906391f, 0.08281732f, 0.08229731f, 0.09941579f, -0.14027506f, -0.05012824f, 0.07033023f, 0.21767586f, 
    0.07894868f, -0.00930138f, 0.04639573f, -0.16245219f, 0.06027065f, -0.16140643f, -0.34551123f, -0.14736186f, 
    -0.10335459f, 0.03747521f, 0.02674564f, 0.15699752f, 0.17222854f, 0.16633183f, -0.05773534f, 0.29276171f, 
    0.02465933f, 0.09285751f, -0.10664060f, -0.05273114f, 0.02831156f, -0.10846664f, 0.02122754f, -0.02705861f, 
    -0.06759921f, 0.01994851f, -0.03436184f, 0.03596714f, 0.14293423f, 0.09201270f, 0.00607173f, -0.07078473f, 
    0.13110539f, -0.13910058f, -0.07978558f, 0.04536748f, -0.05255347f, 0.11736558f, 0.13231625f, 0.01540481f, 
    -0.09077530f, 0.03135585f, 0.01302942f, 0.00412537f, 0.41963857f, 0.02298679f, 0.47456458f, 0.01959242f, 
    -0.15666175f, -0.23238365f, 0.03166457f, -0.17225049f, 0.07591783f, 0.21725158f, -0.02543447f, -0.10931690f, 
    0.08234234f, -0.03091487f, -0.04545695f, 0.07102531f, 0.04196059f, 0.12721820f, 0.05238197f, 0.07861014f, 
    -0.06055333f, -0.13566867f, -0.36536664f, -0.16926172f, 0.00394457f, -0.04467095f, 0.05004008f, -0.04056642f, 
    0.15229006f, -0.09005436f, -0.10663707f, -0.07380982f, 0.00289991f, -0.11715703f, 0.07429148f, 0.09658286f, 
    -0.01166206f, -0.04031728f, -0.08597976f, 0.00678326f, -0.12658015f, 0.17895311f, 0.02079658f, 0.04928135f, 
    0.06945483f, 0.13692859f, 0.01600142f, -0.01725972f, 0.14415555f, 0.16578564f, -0.00287298f, 0.03591767f, 
    0.06240483f, -0.00087489f, -0.10770471f, 0.06787190f, -0.13776009f, -0.03791812f, -0.05552287f, 0.07744958f, 
    -0.40186149f, -0.20451546f, -0.23141217f, 0.23337941f, 0.17884748f, -0.01530353f, -0.01787803f, -0.00505998f, 
    0.02895822f, 0.17200378f, 0.01985881f, 0.14555049f, 0.15609291f, 0.06606688f, 0.04353782f, 0.03918926f, 
    0.00395777f, 0.00212193f, -0.07616130f, -0.04272565f, -0.10577992f, -0.15417925f, 0.37642989f, -0.07506514f, 
    -0.21566659f, 0.12605961f, -0.16369665f, -0.24779430f, 0.15693900f, 0.03024492f, -0.06095045f, 0.00424606f, 
    0.07595524f, 0.16982734f, 0.10694384f, 0.12527269f, 0.11627710f, -0.00527001f, -0.06203094f, 0.06107644f, 
    0.24001539f, -0.33485138f, -0.43907404f, 0.00683078f, -0.16245158f, 0.04299777f, 0.03198856f, 0.12222273f, 
    0.06893290f, 0.15833271f, -0.16765653f, 0.10585919f, 0.00531614f, 0.08246717f, -0.11874667f, -0.06331292f, 
    -0.00250354f, -0.03892612f, -0.00651498f, -0.06080005f, 0.37278506f, 0.24310276f, 0.36091816f, 0.08325975f, 
    0.01424387f, -0.03053567f, 0.08981872f, 0.08801086f, 0.02349954f, -0.00219314f, 0.04447136f, -0.04663573f, 
    -0.10036765f, -0.02136703f, 0.05920224f, -0.17574793f, -0.01927861f, -0.08557693f, -0.19610542f, -0.11142418f, 
    0.32519469f, -0.13958713f, -0.39755318f, -0.12394579f, -0.00519543f, 0.03631267f, 0.26179558f, -0.07116657f, 
    0.26605257f, -0.08516096f, -0.15170725f, -0.10845632f, -0.04969926f, -0.10690611f, 0.12691943f, 0.00055265f, 
    0.05733534f, 0.03462040f, -0.07893226f, -0.02278486f, 0.00794682f, 0.05914335f, -0.15064178f, -0.09446981f, 
    0.31098658f, 0.10528763f, -0.02894727f, -0.15633328f, 0.37157473f, -0.02481056f, -0.00536760f, -0.01603626f, 
    -0.02256955f, -0.01622787f, 0.01897904f, -0.04599966f, -0.04335343f, 0.20149969f, 0.01164825f, 0.09482532f, 
    -0.10213855f, -0.50041503f, -0.46046001f, 0.26115298f, 0.28077129f, 0.02307887f, 0.00680265f, -0.10520810f, 
    -0.05441183f, -0.04680108f, 0.03208554f, 0.07338404f, 0.15961979f, -0.05003303f, -0.07941893f, 0.00242569f, 
    0.00820590f, 0.02444047f, -0.14169297f, 0.01173712f, -0.12738687f, -0.17759304f, -0.06213086f, -0.01940735f, 
    0.08160193f, 0.00392899f, 0.18053156f, -0.06785561f, 0.04072807f, 0.00840692f, 0.07591237f, 0.04723211f, 
    -0.00091548f, -0.05625790f, -0.05975184f, -0.03565530f, 0.04137613f, 0.07988305f, 0.07557974f, -0.01846741f, 
    -0.09718088f, -0.20358314f, -0.30020860f, 0.22875287f, 0.09042463f, 0.02024503f, -0.01572748f, -0.00610808f, 
    -0.03886287f, 0.04629815f, -0.05946600f, -0.01873565f, 0.04385141f, -0.12850653f, -0.05127749f, -0.10753386f, 
    0.14382748f, 0.08319052f, -0.04526477f, -0.08441027f, 0.08051588f, 0.38834363f, 0.31615403f, 0.22071962f, 
    -0.03307125f, -0.11399435f, -0.16147570f, -0.16582060f, 0.02817189f, 0.14130582f, -0.00469900f, 0.01926321f, 
    -0.04466762f, -0.02860607f, -0.07385940f, -0.04581694f, 0.01994219f, -0.01739360f, 0.03975485f, 0.05909308f, 
    0.23488717f, -0.04640137f, -0.09926993f, 0.02544304f, 0.10737923f, 0.15994228f, 0.11817541f, 0.13570063f, 
    0.01689197f, -0.07239363f, 0.01145739f, -0.08048842f, -0.11582228f, 0.07972215f, 0.07169437f, 0.05114831f, 
    0.00911337f, 0.02585396f, 0.06956107f, 0.14533861f, 0.11846932f, 0.23323739f, 0.20443100f, 0.15207575f, 
    0.05527811f, 0.08283344f, 0.16443273f, 0.00391788f, 0.07817921f, 0.02420761f, -0.00445818f, -0.01789363f, 
    0.23092878f, 0.19820473f, 0.06241376f, 0.10909231f, -0.04380931f, 0.04360335f, -0.06283764f, 0.15326066f, 
    -0.35642532f, 0.01222649f, -0.12778091f, -0.03944868f, -0.29956260f, -0.06561686f, -0.07422608f, 0.08159915f, 
    -0.08006510f, -0.04154623f, -0.04423236f, 0.08951188f, -0.02806361f, 0.05701062f, 0.05278244f, 0.06197597f, 
    -0.09368099f, 0.06904364f, -0.12716378f, 0.03820542f, -0.30924910f, -0.12939598f, -0.57038420f, 0.22894742f, 
    -0.05521370f, 0.06512898f, 0.03916487f, -0.06433539f, -0.02073702f, -0.04041421f, 0.10279741f, 0.02731842f, 
    -0.10376199f, 0.05576688f, -0.01211519f, 0.00533635f, -0.00483221f, -0.07843508f, -0.13791810f, -0.14057730f, 
    -0.01443345f, -0.15071198f, 0.27059537f, 0.11528234f, -0.30747643f, 0.00733569f, -0.10089923f, -0.12298568f, 
    0.00620723f, -0.01416875f, -0.01155149f, 0.06573610f, -0.02225685f, -0.04869589f, -0.13676341f, -0.08912437f, 
    0.16520093f, -0.07196307f, -0.03792055f, -0.08482753f, -0.08035875f, -0.57819659f, -0.20314263f, 0.21916081f, 
    -0.11488934f, -0.01880601f, 0.14270854f, -0.06229736f, 0.06018812f, -0.07875948f, -0.02138635f, -0.09455195f, 
    0.01003861f, -0.07088114f, -0.07148913f, 0.01790809f, -0.01301135f, -0.04863207f, 0.04855781f, -0.01770721f, 
    0.02968051f, 0.28337628f, 0.40330023f, -0.00654093f, -0.06719568f, 0.01355437f, 0.07585283f, -0.02529434f, 
    0.04266902f, 0.18417495f, -0.05029286f, -0.03621107f, -0.07906103f, 0.01633026f, -0.03238237f, 0.01048272f, 
    0.05437298f, -0.20687979f, 0.07222850f, -0.09373564f, -0.51196617f, 0.03547325f, -0.26882252f, 0.15893549f, 
    0.06800386f, 0.03757833f, 0.10401870f, 0.09471614f, 0.07253338f, 0.20199457f, 0.13541482f, -0.03609327f, 
    0.01744254f, 0.04441754f, -0.02259301f, 0.08805938f, 0.16591212f, 0.15450583f, 0.05089263f, -0.00498163f, 
    0.15329486f, -0.22417851f, 0.27619720f, -0.01905834f, -0.20807566f, 0.06787735f, -0.02605175f, -0.00930412f, 
    0.01570621f, 0.08611494f, -0.02711234f, -0.11160760f, 0.11201268f, 0.18664919f, -0.16959199f, 0.07878777f, 
    0.07494220f, 0.07684797f, -0.08931375f, 0.11466308f, 0.12197071f, 0.08673696f, -0.16212571f, -0.10490019f, 
    0.13100375f, 0.02197753f, 0.01006930f, 0.04879292f, 0.04845382f, -0.03008197f, 0.17344873f, 0.02388680f, 
    -0.02739609f, -0.15388574f, 0.00792671f, 0.19503102f, 0.06947638f, 0.03789441f, 0.16931228f, 0.21284533f, 
    0.09790786f, -0.18116497f, 0.11006024f, -0.04672258f, -0.11698727f, -0.24746878f, -0.07939680f, -0.25716260f, 
    0.01427930f, 0.09426150f, 0.21758738f, 0.02290904f, 0.00984842f, -0.06356463f, 0.08179290f, 0.00035909f, 
    0.10693045f, 0.00954343f, -0.01579135f, -0.14640799f, 0.01046359f, -0.20212835f, -0.02272195f, 0.16266789f, 
    -0.17252867f, -0.05853279f, 0.05268010f, 0.00089967f, -0.02700788f, 0.13252181f, 0.00746369f, -0.01307139f, 
    -0.01735467f, -0.16402331f, 0.05461576f, 0.04938849f, 0.01070227f, 0.01816674f, -0.12003304f, -0.02792415f, 
    0.09447554f, 0.39428112f, 0.42794096f, 0.11287308f, -0.23133563f, 0.01017675f, -0.05694040f, 0.05895269f, 
    0.24853984f, 0.11591628f, -0.01932862f, 0.00224679f, 0.11069039f, 0.07451033f, 0.06837629f, 0.05033538f, 
    0.08262357f, -0.00425172f, 0.02631178f, 0.04802876f, -0.22752677f, 0.10822353f, -0.10044798f, 0.23534782f, 
    -0.10557232f, 0.07995319f, -0.08013735f, 0.06237997f, -0.15851039f, -0.09680519f, -0.12687859f, 0.02197757f, 
    -0.10163587f, 0.02465604f, -0.05069390f, -0.14187334f, -0.03754770f, 0.07156906f, -0.07027823f, 0.05411697f, 
    -0.13374530f, 0.25458351f, 0.39532846f, 0.35135016f, -0.07117076f, 0.03856210f, 0.05296937f, 0.04173639f, 
    0.07365630f, 0.13468480f, 0.01625969f, 0.02080814f, 0.07619493f, 0.12481532f, -0.00519560f, 0.03576481f, 
    0.00216759f, 0.02145251f, -0.06995372f, -0.02764846f, 0.18201870f, -0.03608104f, -0.30787024f, -0.48984939f, 
    -0.12101425f, -0.03930496f, -0.06341802f, 0.11530150f, 0.04044068f, 0.06000705f, -0.02435920f, 0.03047927f, 
    0.04470344f, -0.02346334f, -0.02604725f, -0.06554594f, 0.09729344f, -0.00163131f, -0.09142252f, 0.10761837f, 
    -0.30715290f, 0.10536081f, -0.13282283f, 0.03651614f, -0.01432202f, -0.06601439f, -0.00542068f, -0.13331939f, 
    -0.02132227f, 0.07817037f, -0.16305973f, -0.01785737f, 0.06094165f, -0.02464920f, -0.03173693f, 0.16184685f, 
    0.08411759f, -0.02688611f, 0.12060353f, 0.09047426f, 0.33204049f, 0.04139629f, -0.15922882f, -0.23790552f, 
    -0.19408359f, 0.09504322f, 0.03967400f, 0.26988301f, 0.15067083f, 0.10799013f, -0.06333413f, 0.16006592f, 
    0.00794918f, -0.06268236f, 0.00934231f, -0.00552291f, 0.14603455f, 0.03037244f, 0.11457827f, 0.31427106f, 
    0.09878250f, 0.00273165f, 0.16266301f, -0.03785478f, 0.12050605f, 0.07621597f, 0.12242959f, -0.15168245f, 
    -0.05020620f, 0.04732552f, -0.02742496f, -0.02998727f, -0.10478982f, 0.07543930f, 0.09132480f, 0.01610292f, 
    -0.05760375f, 0.13291644f, -0.18160310f, -0.01010981f, -0.00685523f, -0.03265486f, 0.55150682f, 0.02775495f, 
    -0.02988808f, -0.08420205f, -0.02329963f, -0.10408578f, 0.07863763f, -0.03165821f, -0.05472148f, 0.00866619f, 
    -0.04375004f, 0.04306391f, -0.00443404f, 0.00921549f, -0.03013507f, 0.07538139f, 0.02847385f, 0.06873585f, 
    0.01805988f, 0.26144210f, -0.05034752f, 0.04752145f, 0.04490426f, 0.07665754f, 0.11075073f, 0.02154031f, 
    -0.07825474f, 0.12908852f, -0.05539003f, 0.01007832f, -0.03102966f, -0.16655616f, 0.11736435f, 0.06664264f, 
    0.04669177f, -0.03259976f, -0.00282387f, -0.02305822f, 0.10629695f, 0.44081497f, 0.46543956f, -0.01958531f, 
    0.01641640f, 0.07401178f, -0.08523287f, 0.13277033f, 0.06162904f, 0.14764975f, 0.09391770f, 0.10522053f, 
    -0.07297634f, -0.05792995f, 0.09557386f, 0.01060645f, 0.03310160f, 0.08791023f, -0.13415092f, 0.05722758f, 
    -0.10658554f, 0.17728950f, -0.03308194f, 0.16148877f, -0.00499773f, -0.00678899f, 0.12461480f, 0.04297393f, 
    0.05605540f, 0.16805020f, -0.02793921f, 0.08266718f, 0.10329422f, 0.03887644f, -0.06006177f, 0.06801892f, 
    -0.01923286f, -0.12166917f, 0.13105212f, 0.17314276f, -0.18378256f, -0.13732405f, 0.60956019f, 0.01962491f, 
    -0.16654968f, 0.08298262f, -0.03499880f, -0.05685136f, -0.06011480f, 0.18287145f, 0.01271488f, 0.07912166f, 
    -0.04056389f, 0.05496420f, 0.02285172f, -0.03244851f, 0.01014302f, 0.21520792f, -0.14221692f, 0.05453029f, 
    -0.06547886f, -0.31729782f, -0.15942797f, 0.02390238f, -0.00311944f, 0.05071104f, -0.00868278f, -0.04257142f, 
    0.18700780f, 0.13346314f, -0.04114558f, 0.02298084f, 0.00616423f, 0.00915500f, 0.01575836f, 0.00077742f, 
    0.08027269f, 0.11957724f, 0.16165093f, 0.01890891f, -0.15452294f, -0.21950623f, 0.00849506f, 0.12837714f, 
    -0.11401219f, -0.01546204f, -0.08701307f, -0.11411811f, 0.04248128f, -0.04219552f, -0.09228232f, -0.07845502f, 
    -0.03359094f, 0.10571564f, -0.02051141f, -0.07443328f, -0.02289761f, 0.11136575f, 0.04236126f, -0.04288378f, 
    0.19047707f, 0.29665259f, -0.06322327f, 0.15396272f, 0.28003648f, 0.23365343f, 0.44110328f, 0.03075359f, 
    0.08890514f, -0.15894604f, -0.20842957f, 0.02881236f, -0.06248295f, -0.02375911f, 0.13976225f, -0.08734813f, 
    -0.06573197f, -0.02215733f, 0.11994833f, 0.02903634f, -0.03254016f, 0.32084453f, 0.13769560f, -0.07720741f, 
    0.36449054f, 0.16156682f, 0.05931627f, 0.00207730f, 0.09028767f, -0.06297552f, 0.04652920f, -0.01644026f, 
    -0.10755094f, 0.02476441f, 0.09554124f, -0.01734328f, -0.09622744f, 0.02139700f, -0.04250843f, 0.09287547f, 
    0.38079637f, -0.18135533f, -0.22881070f, 0.31226692f, 0.32527232f, 0.18119390f, 0.24940029f, 0.10780373f, 
    -0.11611585f, 0.04238587f, -0.02597130f, -0.01616916f, 0.04247019f, 0.02284691f, -0.05690897f, 0.03417393f, 
    0.01537747f, -0.01094390f, -0.02408439f, 0.27127880f, 0.00351493f, -0.01619488f, 0.23236501f, 0.00161213f, 
    0.09184898f, -0.07090720f, 0.10635943f, -0.08109469f, -0.00028978f, 0.00312727f, -0.03390982f, 0.05646370f, 
    -0.04853939f, 0.00413583f, -0.13245191f, -0.02549596f, -0.02483652f, -0.02949077f, -0.03569908f, 0.01968975f, 
    0.00682164f, -0.11734185f, -0.26626047f, 0.21134225f, 0.07337292f, 0.11569285f, 0.05631301f, 0.20092186f, 
    0.03841501f, -0.06213063f, -0.05239397f, -0.01331150f, 0.02494480f, -0.02146333f, -0.04497708f, -0.09516601f, 
    0.02523352f, 0.05507272f, -0.05122049f, 0.03211653f, -0.29531789f, 0.20926665f, 0.28650236f, 0.06853437f, 
    0.26433024f, -0.16473140f, -0.12489208f, -0.14929397f, -0.12909642f, -0.00816858f, -0.04607763f, -0.01504486f, 
    0.01384504f, -0.03669837f, -0.05336206f, 0.01306681f, 0.01869867f, -0.12864082f, 0.16860262f, -0.06744737f, 
    -0.02568533f, 0.00855113f, -0.07242078f, 0.02704733f, 0.03180565f, -0.02018652f, -0.05082177f, -0.06529813f, 
    -0.04376575f, -0.01916899f, 0.04027563f, -0.02397664f, -0.01969796f, -0.04477176f, 0.01886271f, 0.03187303f, 
    -0.04895547f, -0.02446922f, -0.05633336f, -0.05538562f, 0.00872983f, -0.07091149f, -0.00352206f, 0.03562778f, 
    -0.03308794f, -0.00327613f, -0.02500873f, -0.03963275f, 0.03142888f, 0.05924785f, -0.02368223f, -0.00900813f, 
    0.00720822f, 0.01140249f, -0.02496822f, 0.01113577f, 0.01933597f, 0.03574414f, -0.03869097f, 0.02981345f, 
    0.00635396f, -0.03134534f, -0.00607530f, 0.02466553f, -0.03032458f, 0.04005145f, -0.06036586f, -0.05154430f, 
    -0.00668886f, 0.00594677f, 0.01948313f, 0.02710791f, 0.03718378f, -0.00429812f, -0.01300561f, -0.03198756f, 
    0.04669873f, -0.02636601f, -0.03146011f, 0.03598609f, -0.05203100f, 0.03284569f, 0.01811151f, 0.03806927f, 
    0.00490567f, -0.01969858f, -0.00793909f, -0.06133629f, -0.05908853f, -0.01313961f, 0.01651930f, -0.03307643f, 
    -0.00992198f, -0.04397191f, 0.00305125f, 0.02152879f, 0.04511810f, -0.01864458f, 0.01547625f, 0.03342940f, 
    -0.02457866f, 0.04831710f, -0.04552421f, -0.05213873f, 0.01512970f, -0.04608845f, -0.03941491f, 0.03630412f, 
    -0.00474201f, 0.00745017f, -0.02731711f, 0.00509187f, -0.02025993f, 0.03000818f, 0.00831011f, -0.04133942f, 
    -0.00579330f, 0.01199752f, 0.03865705f, 0.03365395f, 0.03213970f, 0.01414813f, 0.03228675f, -0.04590667f, 
    0.03515679f, 0.04549548f, -0.00756272f, 0.04829509f, -0.00862765f, 0.02370219f, -0.02947848f, -0.02538446f, 
    0.01274432f, -0.02936959f, -0.05034862f, -0.00335523f, 0.00265241f, 0.03371889f, 0.03375866f, -0.01253442f, 
    0.00152928f, -0.00684692f, 0.04656430f, -0.04439604f, 0.04880927f, -0.00820595f, 0.01353269f, 0.04202549f, 
    -0.06167339f, -0.04079121f, -0.00813500f, 0.02172267f, 0.01052776f, -0.05137707f, -0.00993469f, -0.01462990f, 
    0.04646537f, -0.01396731f, -0.03301168f, -0.05948399f, -0.05362054f, 0.02100340f, -0.03287457f, -0.05812988f, 
    -0.00761911f, 0.03884726f, 0.00827746f, -0.05386550f, 0.01336924f, 0.04654943f, -0.06827979f, 0.02631471f, 
    -0.03719410f, -0.04519041f, -0.05754288f, -0.06185533f, 0.03903511f, -0.03547583f, 0.02678872f, 0.04688283f, 
    -0.04388516f, 0.00549815f, 0.03865992f, -0.03809347f, 0.00595365f, 0.01170540f, -0.00907567f, -0.05007634f, 
    -0.05372870f, 0.01934379f, 0.03191987f, -0.04664974f, 0.01115143f, -0.06292636f, -0.05526983f, 0.02076614f, 
    -0.02007840f, -0.03048830f, 0.01356900f, 0.03658716f, 0.02239469f, -0.03365246f, 0.00587742f, 0.03033467f, 
    0.02372625f, 0.02701884f, -0.01064931f, -0.06456733f, -0.04973970f, -0.05872297f, -0.06290638f, -0.04629755f, 
    0.02028855f, -0.00311590f, 0.04609997f, -0.02138183f, -0.03772330f, 0.03827147f, -0.03390855f, 0.00683363f, 
    -0.02466018f, 0.04324793f, -0.04505033f, -0.00033083f, 0.02653166f, -0.01132373f, -0.02918083f, 0.04074533f, 
    0.05573587f, 0.00920457f, 0.02987948f, 0.03282946f, 0.02822862f, -0.01721103f, -0.04892683f, -0.05844523f, 
    -0.03160312f, 0.00316598f, -0.04364443f, 0.01402249f, -0.01402760f, -0.01813372f, 0.03812556f, -0.05478035f, 
    -0.04598022f, -0.03699199f, 0.05026197f, -0.02291321f, 0.03432420f, -0.06404798f, -0.06487569f, -0.05806302f, 
    0.02326696f, 0.02389552f, 0.05304165f, -0.00897030f, -0.01448874f, -0.00249626f, -0.04207714f, -0.01420786f, 
    0.03335501f, -0.02037770f, -0.01950939f, -0.02367162f, -0.05080453f, 0.01524873f, 0.03186062f, -0.00585608f, 
    0.04700258f, 0.03443178f, 0.03469685f, -0.02155621f, -0.05494582f, 0.01772723f, -0.03964834f, 0.00544139f, 
    -0.01006824f, 0.04051640f, 0.00896305f, 0.03978681f, -0.03762581f, -0.02869807f, 0.04100328f, 0.04003036f, 
    0.02301828f, -0.06351759f, -0.06160410f, -0.04573223f, -0.02814997f, -0.01768098f, 0.02076201f, -0.00090937f, 
    0.04064558f, 0.02789829f, 0.02499020f, -0.05095784f, -0.05045260f, -0.00528768f, -0.01155896f, -0.04876958f, 
    0.00238151f, -0.02642614f, -0.03861622f, 0.06157747f, -0.05551476f, 0.03512621f, 0.04990119f, 0.05089738f, 
    0.02601999f, -0.00255601f, 0.02557714f, 0.03319399f, -0.03778719f, -0.00946742f, -0.01666419f, 0.04017854f, 
    -0.00747288f, -0.05420615f, 0.01028242f, 0.02316148f, -0.05458085f, -0.03135993f, -0.00781956f, -0.05024936f, 
    -0.02118913f, -0.04244661f, 0.03886617f, -0.02067056f, 0.03391906f, -0.04232718f, -0.00507370f, 0.00262776f, 
    -0.00109567f, -0.01747386f, 0.03508240f, -0.03064634f, -0.01814243f, -0.05463165f, 0.04207235f, -0.03127111f, 
    0.07627708f, 0.06892624f, -0.04489266f, 0.21515384f, -0.22377625f, 0.10603137f, 0.09541326f, 0.27940139f, 
    0.06869581f, 0.12782760f, -0.22641434f, -0.01537102f, -0.14559253f, 0.02565929f, -0.05492788f, 0.05667239f, 
    0.04145754f, -0.15001859f, -0.05045247f, -0.16028087f, -0.03180613f, 0.29255837f, -0.01484918f, 0.11764799f, 
    -0.05372261f, 0.18243793f, 0.18775949f, 0.05759680f, -0.15239231f, 0.15113609f, 0.07049012f, 0.09142884f, 
    -0.11370561f, -0.09799507f, -0.07391495f, 0.13434443f, -0.05784947f, -0.02354306f, -0.20727649f, -0.02794716f, 
    -0.14980341f, -0.31533119f, 0.14716801f, -0.26464975f, -0.12260948f, -0.03180655f, -0.13308164f, -0.19573410f, 
    -0.07105801f, -0.29281151f, -0.11053921f, -0.01363764f, -0.21145730f, -0.05001644f, 0.09026750f, -0.00782891f, 
    0.05678558f, 0.08320948f, -0.07326785f, 0.07916375f, 0.22132269f, -0.12058061f, -0.03097031f, 0.22019227f, 
    -0.08840089f, -0.30058390f, 0.02447545f, -0.02735206f, -0.04104035f, 0.08589788f, 0.20222293f, 0.00158385f, 
    0.02651582f, -0.00345310f, 0.01990344f, -0.04564665f, -0.01156093f, 0.02220655f, 0.09663244f, 0.23706396f, 
    -0.14568967f, 0.18385391f, -0.09520252f, 0.13425313f, -0.18757717f, 0.02071603f, 0.04014731f, -0.19386616f, 
    -0.06371176f, -0.00913481f, -0.11903376f, 0.12415054f, 0.05264933f, 0.09777305f, 0.11876447f, -0.08751293f, 
    0.03575152f, 0.03076103f, 0.00109799f, 0.02381718f, -0.09389365f, -0.13588257f, 0.01840641f, 0.31387395f, 
    0.09357586f, 0.01041963f, 0.21642132f, 0.26641533f, -0.24617302f, 0.07049289f, -0.04179609f, 0.02233224f, 
    -0.05797148f, 0.06399249f, 0.02064879f, 0.10002079f, 0.09774657f, 0.11534869f, 0.01633761f, 0.04682918f, 
    -0.08896921f, 0.05740685f, 0.19280103f, 0.07438485f, 0.19245695f, -0.07764266f, -0.11359287f, 0.03492216f, 
    0.13859999f, 0.19584651f, -0.10230063f, 0.02926336f, -0.01990224f, -0.04623521f, -0.02037678f, -0.03830287f, 
    -0.15439342f, -0.21460429f, 0.09461853f, -0.04940752f, -0.09993497f, -0.00929684f, 0.23676145f, 0.01868916f, 
    -0.04411045f, 0.06187315f, 0.02539211f, 0.03994344f, 0.12687689f, 0.00745599f, 0.02975653f, -0.00615339f, 
    0.02143761f, 0.10941457f, 0.03573005f, 0.16660383f, -0.04100617f, -0.02052961f, -0.09049719f, 0.04860938f, 
    -0.41993755f, -0.11402543f, 0.19132863f, 0.01215021f, -0.16640875f, 0.04693373f, -0.12558730f, -0.20818384f, 
    0.29315430f, -0.20129313f, -0.14326827f, -0.07617955f, -0.05808680f, -0.03264751f, 0.00801737f, -0.03491567f, 
    -0.00049540f, -0.02068536f, -0.16885072f, -0.08356691f, 0.10205395f, 0.03881428f, -0.00914270f, 0.26342624f, 
    -0.04170981f, 0.14623085f, 0.08542525f, 0.13938665f, 0.03922856f, 0.03747823f, -0.18659626f, -0.02000449f, 
    0.02257138f, -0.13904013f, -0.14508697f, 0.21756405f, 0.15273766f, 0.03486576f, -0.14012715f, 0.01909974f, 
    0.17014791f, -0.05700018f, -0.28160524f, 0.28820068f, -0.02180297f, 0.12777536f, 0.14923568f, 0.00000171f, 
    -0.07619511f, -0.01644109f, -0.09370011f, 0.00067334f, 0.09759734f, -0.03667360f, 0.08510934f, -0.03023146f, 
    0.12298985f, 0.02892973f, 0.02919826f, -0.03173544f, -0.18215217f, 0.09696855f, -0.18721381f, 0.15105830f, 
    0.08598009f, -0.09294692f, -0.08309035f, -0.08500130f, -0.15131937f, 0.04861414f, -0.03806461f, 0.19044709f, 
    0.09601899f, 0.01156541f, 0.11829501f, -0.09225088f, -0.08803555f, 0.06460536f, 0.22752947f, 0.09701487f, 
    0.25246334f, -0.11317658f, 0.33215144f, 0.08809514f, 0.10760655f, 0.10824507f, -0.17080396f, -0.07232307f, 
    0.07628031f, -0.04969023f, 0.17551374f, 0.15537827f, -0.01893503f, -0.01340048f, 0.03162638f, -0.03461188f, 
    -0.02768627f, -0.04440272f, 0.12522414f, -0.08749323f, 0.22053368f, -0.20774403f, 0.04667689f, -0.09427995f, 
    -0.04413104f, -0.00504295f, -0.01872769f, 0.02753096f, -0.01155620f, -0.02271639f, -0.05592254f, 0.02221053f, 
    -0.10540280f, 0.06427336f, -0.05626966f, 0.19118345f, 0.18841618f, 0.19565399f, -0.02370512f, 0.17582747f, 
    0.09763816f, -0.04991866f, -0.08894518f, 0.18524587f, 0.28992444f, -0.27807766f, -0.06684484f, 0.05643569f, 
    0.14816818f, 0.11191876f, -0.01195730f, 0.14604399f, 0.00757462f, 0.20160505f, -0.05208062f, 0.13101612f, 
    -0.01508311f, -0.00184671f, -0.01562646f, 0.04735334f, -0.05678792f, 0.06006197f, -0.12186992f, 0.25205451f, 
    0.23607758f, -0.05635339f, -0.13796386f, -0.01189290f, 0.07509774f, 0.11314729f, -0.10486653f, -0.04440375f, 
    0.06447508f, 0.03125698f, -0.00362186f, -0.03924299f, 0.15958348f, 0.05258227f, -0.10951088f, 0.10828847f, 
    0.04197196f, -0.23089893f, 0.28673530f, -0.21236905f, 0.00222489f, -0.08428179f, 0.01962575f, -0.20173894f, 
    -0.02427945f, -0.13458952f, 0.08062859f, 0.12963279f, 0.15643376f, 0.02710798f, 0.09825394f, 0.03424499f, 
    -0.02952895f, 0.20593445f, -0.04074805f, 0.02353203f, -0.04757389f, -0.17380725f, -0.01220974f, -0.03413956f, 
    0.05800277f, 0.07290758f, -0.05638491f, -0.07293038f, 0.02758052f, -0.08526845f, 0.10576702f, -0.08059571f, 
    -0.05139029f, 0.11729494f, -0.00482971f, 0.09538069f, 0.06446769f, 0.04797300f, 0.18403564f, -0.01947154f, 
    0.14490774f, 0.04757385f, -0.18696623f, -0.07652080f, 0.03144372f, 0.06760485f, -0.03474505f, 0.08502910f, 
    0.15197709f, 0.10932471f, 0.01833422f, 0.08496476f, 0.05760009f, -0.06296188f, -0.00741036f, -0.05123600f, 
    0.02686048f, 0.03698279f, 0.06503858f, 0.02336641f, 0.06342813f, 0.03107783f, 0.09292034f, -0.11763852f, 
    0.07469593f, 0.09541350f, 0.14789732f, 0.17149031f, 0.14107902f, -0.03374597f, -0.01010169f, -0.01438660f, 
    0.07944259f, -0.10396290f, 0.00666467f, -0.09624575f, 0.07440644f, -0.05723553f, 0.10127185f, -0.10434476f, 
    0.12120347f, -0.10930435f, -0.10977791f, -0.09384356f, 0.18818319f, 0.07942080f, 0.05084259f, 0.09396236f, 
    0.17366141f, 0.08046181f, 0.10240851f, -0.10953512f, -0.05949173f, 0.11401086f, 0.06680442f, 0.10802063f, 
    -0.05668522f, 0.11789418f, 0.07809123f, 0.05673501f, 0.15342729f, 0.51617724f, -0.01885290f, -0.26268116f, 
    0.11517479f, -0.00908851f, -0.01503495f, -0.19368631f, 0.11508983f, 0.08328812f, 0.11172939f, 0.00729068f, 
    -0.03123057f, 0.01370288f, -0.02164765f, -0.06547994f, -0.00351877f, 0.07896539f, 0.12659271f, -0.08699989f, 
    0.22143482f, -0.12397926f, -0.23390512f, -0.12356045f, -0.07155389f, 0.05307393f, 0.01162287f, 0.09103539f, 
    -0.06212523f, -0.00436594f, 0.14382468f, -0.04553216f, -0.03557632f, -0.08976370f, 0.00729901f, -0.00033146f, 
    0.10165265f, 0.23060399f, -0.06159329f, 0.02351773f, 0.39605182f, 0.28599513f, -0.38111702f, -0.07846262f, 
    -0.06809670f, 0.04919114f, 0.03283563f, 0.07254320f, -0.00185877f, -0.18812574f, 0.21237770f, 0.05991192f, 
    -0.00735156f, -0.19574110f, -0.02758120f, -0.07824380f, 0.07313073f, -0.02281525f, 0.15869723f, -0.09916886f, 
    -0.07600295f, 0.21067193f, 0.18208680f, -0.01248514f, 0.16508242f, -0.00681659f, 0.00363394f, 0.17881876f, 
    -0.21058162f, -0.01601503f, 0.11183232f, 0.09159558f, 0.04384546f, 0.02867447f, 0.09463520f, 0.05694760f, 
    0.00275542f, 0.04565066f, 0.05388086f, 0.01155507f, -0.19700651f, 0.06020236f, 0.07223952f, -0.40286404f, 
    -0.03109061f, -0.06527951f, 0.03650521f, -0.04177890f, -0.03018133f, -0.02189755f, 0.06029812f, 0.09433994f, 
    0.05839666f, 0.12572226f, 0.03550152f, -0.02589952f, 0.02321199f, -0.01801584f, 0.01752577f, -0.00722235f, 
    -0.05799935f, 0.19251454f, 0.08074423f, -0.33424494f, -0.03958698f, 0.06401437f, 0.04263064f, -0.06976319f, 
    0.02406628f, 0.04414524f, 0.17709666f, -0.04181170f, -0.09301298f, 0.14927906f, 0.09888645f, 0.01629156f, 
    0.03622877f, 0.14307673f, -0.04560806f, 0.02711698f, -0.01174064f, 0.04685343f, -0.00912260f, -0.21857484f, 
    -0.08727901f, 0.09062674f, 0.03038881f, -0.05999122f, 0.24304806f, 0.04116032f, 0.10420512f, -0.04236618f, 
    -0.12951744f, 0.03799859f, -0.03008277f, -0.01467699f, 0.00627147f, -0.02379492f, -0.08626182f, -0.11598124f, 
    -0.11127135f, 0.02432008f, -0.22024103f, -0.23696344f, 0.03226772f, 0.17794387f, 0.12878212f, 0.15697584f, 
    0.09535825f, 0.07445142f, -0.11355238f, -0.13500787f, -0.02854200f, -0.04204988f, -0.00508658f, 0.06059758f, 
    -0.03113602f, 0.06297023f, -0.13985214f, -0.05545623f, 0.16284433f, -0.00791634f, -0.21009411f, -0.26558816f, 
    -0.04839164f, 0.04699498f, -0.05233452f, 0.03987386f, 0.09578048f, 0.08507419f, 0.16762905f, -0.04177424f, 
    0.00107945f, -0.00738308f, 0.10591190f, -0.12564248f, -0.05359839f, 0.04433553f, -0.05670504f, 0.05916073f, 
    0.01365654f, -0.11610951f, -0.02088434f, -0.22707026f, -0.00355182f, 0.15700880f, 0.00035063f, -0.19517250f, 
    -0.18346354f, -0.04635021f, 0.06123503f, -0.06795606f, -0.10142618f, -0.18819824f, 0.02382264f, -0.01017243f, 
    -0.02935942f, 0.04691253f, 0.03149392f, -0.07856774f, -0.03793235f, -0.21394397f, 0.04018055f, -0.01433394f, 
    0.01857436f, -0.00988283f, 0.05896061f, 0.03064911f, 0.11138836f, -0.14818633f, 0.03866687f, -0.04922310f, 
    -0.00727330f, -0.02807142f, -0.01515508f, -0.07869180f, 0.02686172f, -0.03205902f, -0.01441014f, -0.05132495f, 
    0.33454964f, -0.35479897f, 0.24890038f, -0.02147152f, -0.00253714f, -0.00170778f, 0.15073869f, -0.03493831f, 
    -0.02865709f, -0.15099339f, 0.12953040f, 0.07533475f, 0.02312989f, -0.11377174f, 0.09945247f, -0.02139577f, 
    0.03038862f, -0.03484656f, -0.08482777f, 0.05274810f, 0.06726486f, 0.32976723f, 0.15184014f, -0.11415255f, 
    -0.17771016f, -0.04512045f, 0.03539610f, 0.09507850f, 0.14967030f, -0.00296316f, 0.10876576f, 0.14326493f, 
    -0.05976690f, -0.08283146f, -0.10170335f, -0.14122659f, -0.13203816f, 0.05837346f, -0.00761047f, -0.07248461f, 
    -0.04531648f, -0.13596395f, -0.00140665f, -0.19355813f, -0.08511829f, 0.09176940f, -0.17373079f, 0.02500744f, 
    0.05669649f, -0.14719179f, -0.03287136f, -0.03288007f, -0.01113815f, -0.05076602f, 0.09152862f, 0.06614954f, 
    0.02526960f, -0.05129617f, 0.04638254f, 0.08733605f, 0.07557223f, 0.18363208f, -0.19181706f, 0.18796740f, 
    0.01326076f, 0.03580573f, 0.16737054f, 0.09950352f, -0.03154757f, 0.02892181f, -0.03928000f, 0.01333512f, 
    -0.01827021f, -0.10454652f, 0.00941747f, -0.02333690f, -0.03472925f, -0.05675091f, -0.04088008f, -0.03429292f, 
    0.30144596f, -0.08752329f, -0.43534091f, -0.01785374f, -0.16015229f, 0.13042830f, -0.00861792f, 0.03925330f, 
    0.03016598f, 0.06395307f, -0.10199262f, 0.00766665f, -0.01344483f, 0.09691658f, 0.10450059f, 0.07961960f, 
    -0.06137645f, 0.00796910f, 0.04323185f, 0.16742265f, 0.09461068f, 0.16399701f, -0.12783116f, -0.13693169f, 
    -0.06734456f, -0.04711239f, 0.15821859f, 0.12335175f, 0.19961251f, 0.21762742f, 0.06756625f, 0.04429024f, 
    0.12403429f, -0.14885181f, -0.09572139f, 0.14273708f, -0.02896027f, -0.01633357f, 0.12657119f, 0.09168904f, 
    0.33274847f, 0.40505287f, 0.32816815f, -0.05978305f, 0.01775942f, -0.06784334f, -0.06555278f, 0.11152135f, 
    0.00591422f, 0.16423488f, 0.01329345f, -0.00755484f, 0.03958790f, -0.10815425f, -0.02906043f, -0.13776568f, 
    -0.06393577f, -0.01388298f, -0.01022640f, -0.01520284f, -0.20329937f, 0.50055492f, 0.20083123f, 0.34684888f, 
    -0.20124157f, -0.07066537f, 0.07883761f, -0.13879861f, 0.07085685f, -0.21233915f, 0.14549892f, 0.01636312f, 
    0.07695257f, -0.07351461f, -0.16425347f, 0.10753325f, 0.03038255f, -0.16142632f, 0.20075125f, -0.02723643f, 
    -0.09763512f, -0.40923300f, -0.04984089f, -0.11991312f, -0.35523918f, 0.12479012f, -0.24445517f, 0.07323199f, 
    -0.15489098f, -0.17087984f, 0.03930874f, 0.02517302f, -0.11997066f, 0.02000109f, -0.06599721f, -0.12473273f, 
    0.03214189f, 0.00327620f, -0.05413102f, 0.01548016f, 0.15880865f, 0.27889076f, 0.15507753f, -0.14827707f, 
    0.25037426f, -0.02149948f, 0.04886116f, 0.10035263f, 0.02495256f, -0.17975913f, 0.18314941f, 0.20123750f, 
    0.07446637f, -0.03398665f, -0.02369842f, -0.05289556f, -0.00431430f, -0.10991815f, 0.02438136f, 0.07480566f, 
    0.51013201f, 0.21781883f, -0.50224698f, -0.41377911f, 0.10176524f, -0.22830150f, 0.25918677f, -0.06268488f, 
    0.06321122f, 0.02122597f, 0.06766916f, -0.02799615f, 0.04319693f, 0.05007897f, 0.11939652f, 0.08009250f, 
    0.04078424f, 0.09820585f, -0.02629472f, 0.08239640f, 0.25101539f, 0.09522330f, -0.23588164f, -0.35872740f, 
    -0.15155895f, 0.01663217f, -0.03826549f, 0.03632102f, 0.13869710f, 0.09433263f, 0.12649196f, -0.00017466f, 
    -0.05104762f, -0.00927495f, 0.04372590f, 0.04721524f, -0.05753886f, 0.00044779f, 0.09381732f, 0.04466610f, 
    0.21288753f, 0.28296307f, 0.24930547f, -0.23918012f, 0.05527500f, 0.09277838f, 0.00027098f, -0.03780972f, 
    0.20432033f, 0.13178322f, -0.11833935f, -0.04567413f, -0.06052588f, 0.00019211f, 0.03529467f, 0.01508748f, 
    -0.11374648f, -0.03126621f, 0.21031635f, 0.13000765f, 0.00249688f, 0.22598600f, 0.06173844f, -0.06998263f, 
    -0.04006158f, 0.06311883f, -0.09367076f, 0.05559786f, -0.10024378f, -0.04421964f, 0.00852888f, -0.08436988f, 
    0.01152711f, 0.02914167f, 0.06725327f, 0.06669313f, 0.05464208f, 0.08440031f, -0.20041808f, 0.09549212f, 
    0.17708009f, 0.26957163f, 0.36150694f, 0.02850341f, 0.01191342f, 0.15344715f, 0.13750482f, -0.06687526f, 
    0.02731475f, 0.13924265f, 0.02803301f, 0.05671290f, 0.06551211f, 0.11224663f, 0.10732023f, 0.07447152f, 
    0.01522395f, 0.10245614f, -0.03120529f, -0.06291442f, -0.01577350f, -0.19169626f, -0.10800147f, -0.19077964f, 
    0.27846399f, 0.01468925f, -0.08262525f, 0.13820776f, 0.06127518f, 0.21558891f, -0.02488363f, -0.07416620f, 
    -0.05824287f, -0.18594739f, -0.17125034f, -0.12017535f, 0.05666161f, 0.00955984f, -0.09729785f, 0.09748099f, 
    -0.07898810f, 0.10087631f, 0.29757580f, -0.01065253f, -0.06204642f, 0.01709844f, -0.06717604f, 0.09606899f, 
    0.09451330f, -0.02849651f, -0.03835983f, 0.08570142f, 0.02508200f, 0.16878006f, 0.01187768f, -0.15274584f, 
    -0.12076902f, 0.10315493f, 0.02514378f, -0.20598409f, -0.11797954f, -0.28105390f, -0.23686431f, 0.32578883f, 
    0.16298839f, 0.02812650f, -0.10354829f, -0.24706978f, -0.27894256f, -0.06687007f, 0.07240624f, 0.10249490f, 
    0.12977585f, 0.05726945f, 0.03944254f, 0.02151780f, -0.05799266f, -0.05325030f, -0.08548810f, -0.31698263f, 
    0.12752649f, -0.02631553f, 0.05653232f, 0.19880942f, 0.08775060f, 0.13711140f, 0.21000597f, 0.07698276f, 
    0.03127395f, 0.11683944f, 0.14195727f, 0.01529248f, 0.14822914f, 0.11909854f, -0.01969035f, -0.00054324f, 
    0.09862306f, 0.04066556f, 0.27034220f, 0.14119925f, 0.17735155f, -0.04708752f, 0.10626673f, -0.00978118f, 
    -0.00591298f, -0.07014096f, 0.04635284f, 0.29421216f, 0.17325315f, 0.17906609f, -0.01901699f, -0.00564014f, 
    -0.00873506f, -0.09267809f, -0.09774446f, -0.02226003f, 0.11247452f, 0.02019348f, 0.12759298f, 0.15763171f, 
    -0.19186309f, -0.07155577f, 0.30826661f, -0.05115878f, 0.07541803f, -0.02221377f, 0.07381689f, -0.01231725f, 
    0.09539200f, 0.00705894f, 0.07750379f, 0.03580049f, 0.10722070f, 0.05873014f, 0.07145119f, -0.05948521f, 
    -0.05613922f, 0.02580670f, 0.02459801f, 0.13792714f, -0.14228711f, -0.13695827f, 0.02888593f, 0.15960407f, 
    0.07541069f, 0.03465124f, -0.00713848f, -0.10073131f, -0.23499586f, -0.02586334f, -0.06095197f, -0.00388613f, 
    -0.01688230f, 0.09247595f, -0.06061754f, 0.11291208f, 0.04712788f, 0.06321833f, 0.00502468f, -0.02425921f, 
    -0.25302407f, -0.44954407f, -0.12594284f, 0.16659018f, 0.16808632f, 0.02212064f, 0.01276122f, 0.07452090f, 
    -0.12242686f, -0.20921084f, 0.05816451f, 0.07277841f, -0.07209462f, -0.06536341f, 0.03427024f, -0.02140738f, 
    0.00411686f, 0.14899983f, 0.03966071f, -0.00267513f, 0.45352143f, -0.08007589f, -0.46260229f, -0.02219078f, 
    0.10973276f, 0.11522159f, 0.02800099f, 0.08892117f, 0.01618013f, 0.13313000f, 0.04756588f, 0.05051767f, 
    0.11461968f, -0.02946531f, 0.04918979f, 0.09822041f, 0.00853588f, -0.08750673f, 0.03963417f, 0.13156773f, 
    -0.13995886f, 0.33245510f, 0.08732263f, 0.05697366f, 0.11844544f, -0.11121010f, 0.19088757f, 0.13468704f, 
    0.05214041f, -0.13614623f, 0.05920846f, 0.23441610f, 0.12387153f, 0.08358925f, 0.20205306f, 0.08643997f, 
    -0.14019990f, 0.04356850f, -0.02101160f, -0.03290158f, 0.01043395f, 0.12066105f, 0.10367510f, -0.07951571f, 
    -0.09543225f, 0.01878307f, 0.02185347f, 0.03397376f, -0.10331947f, 0.04539267f, -0.16800304f, -0.04420397f, 
    0.10340895f, 0.13397570f, 0.06976561f, 0.03505478f, 0.13123468f, 0.10254676f, 0.03298903f, 0.06808992f, 
    -0.36904246f, -0.42550951f, 0.35599720f, 0.18504414f, -0.15412179f, 0.16452850f, -0.20603961f, 0.04642622f, 
    0.09853411f, 0.10053760f, -0.01555585f, -0.04099043f, 0.03427465f, 0.13670070f, -0.06372002f, 0.07292159f, 
    -0.04661941f, -0.03484032f, 0.11330675f, 0.07238183f, -0.23975661f, -0.20937203f, 0.16736460f, 0.36385798f, 
    -0.00539578f, -0.11372573f, -0.05013210f, -0.05360789f, -0.12140799f, 0.03175258f, -0.09187457f, 0.06961075f, 
    0.10931146f, 0.08756062f, -0.06637164f, 0.03074023f, 0.03327717f, -0.05455058f, 0.09130966f, -0.13383766f, 
    -0.29599187f, -0.38118413f, -0.16565669f, 0.08822009f, -0.04359939f, -0.11670431f, -0.05088701f, 0.01814174f, 
    -0.11613656f, -0.11852713f, 0.02498976f, 0.18047948f, 0.06069928f, -0.07626436f, 0.02558924f, -0.02346100f, 
    -0.04244871f, -0.00311502f, -0.09229597f, -0.19076513f, 0.08255281f, -0.27043325f, -0.14020748f, -0.08964147f, 
    0.07908800f, 0.21245348f, 0.11082966f, 0.00298806f, 0.15864648f, 0.07163404f, 0.03767896f, -0.00846162f, 
    -0.02925259f, 0.06365090f, 0.05925306f, 0.09971701f, 0.09249425f, -0.04763925f, 0.15494145f, -0.03112626f, 
    -0.12888776f, -0.18320756f, -0.19457012f, -0.13539463f, -0.00338537f, -0.10418398f, -0.15702248f, -0.24739441f, 
    -0.05193116f, -0.01696236f, 0.03292239f, -0.09134346f, -0.01632706f, -0.05744095f, -0.05651663f, 0.03309812f, 
    -0.00987045f, -0.22615314f, 0.08238269f, 0.08776338f, 0.14910109f, 0.06953868f, 0.20172460f, 0.20812310f, 
    -0.11237287f, 0.24973920f, 0.21015978f, 0.11682997f, 0.20339885f, -0.03763503f, 0.04181743f, 0.03600610f, 
    0.06008812f, 0.11612538f, 0.16142946f, 0.15464248f, 0.07266395f, 0.20178300f, 0.06251463f, -0.09490237f, 
    0.03082432f, 0.02166264f, 0.00112431f, -0.04333771f, 0.03585471f, 0.01374431f, -0.01616774f, 0.01969789f, 
    -0.05943752f, -0.00542260f, 0.00459174f, 0.01697554f, -0.02913006f, -0.04400462f, -0.04212520f, 0.00839563f, 
    -0.00434418f, 0.04287889f, 0.04108151f, -0.03129691f, -0.01156442f, 0.04407136f, -0.01555938f, -0.05456709f, 
    -0.03301434f, -0.04961596f, 0.03011563f, -0.04251004f, 0.00260579f, -0.05639135f, 0.00154226f, 0.00523351f, 
    0.02265672f, 0.03955646f, 0.03474988f, -0.00426001f, -0.03322373f, -0.00555682f, -0.02022072f, -0.01269942f, 
    -0.03081168f, -0.02574721f, -0.05908746f, 0.03522877f, -0.06013745f, 0.04001207f, 0.03902321f, 0.01096309f, 
    0.02318787f, -0.05051422f, -0.03654206f, -0.00292968f, -0.03566137f, 0.02654011f, 0.00934589f, -0.05490429f, 
    -0.00461067f, 0.01903771f, 0.00186297f, -0.05423069f, -0.00622172f, -0.01654782f, -0.01679754f, 0.03674715f, 
    -0.04305387f, -0.02774864f, 0.04127602f, 0.04510517f, -0.04258352f, -0.03883243f, -0.04142646f, -0.01630769f, 
    -0.02985573f, 0.01322927f, -0.00473528f, -0.00768381f, -0.01366256f, -0.04396023f, 0.03681483f, 0.03988776f, 
    0.00835895f, -0.03343290f, -0.03560891f, 0.04017937f, 0.00556247f, 0.02735576f, 0.02789815f, -0.05601732f, 
    -0.06012946f, -0.03847741f, -0.03953486f, 0.04020721f, -0.02440190f, 0.00124075f, -0.03660749f, 0.01275092f, 
    0.05005135f, -0.01761433f, -0.00086949f, -0.04478364f, -0.05815583f, -0.01124823f, -0.02844783f, 0.04499214f, 
    -0.04497779f, 0.03546708f, -0.02269724f, -0.01112563f, 0.02033865f, 0.00616543f, 0.04385616f, -0.01612051f, 
    0.05166993f, 0.01877093f, -0.04745983f, 0.02909181f, -0.04266167f, -0.00745379f, -0.04696255f, 0.01813770f, 
    -0.01091228f, -0.01213324f, -0.04385071f, 0.02791577f, 0.02055395f, -0.04294058f, 0.01242833f, -0.04055981f, 
    -0.04151067f, 0.02862098f, 0.04864229f, -0.02243799f, -0.00289409f, 0.00476831f, -0.03342491f, -0.01042531f, 
    -0.02044754f, 0.00329861f, -0.02257894f, -0.03244621f, 0.01069923f, 0.01000994f, 0.02539021f, 0.00221603f, 
    -0.01899833f, -0.02187141f, 0.01242499f, -0.05747793f, 0.01101453f, -0.00969946f, -0.00989162f, 0.04872368f, 
    -0.00739377f, -0.01124563f, 0.01044878f, -0.04753079f, 0.04573242f, 0.00244120f, -0.01448815f, -0.02272790f, 
    -0.04394352f, 0.03051633f, -0.02013718f, 0.00846438f, -0.00469881f, -0.05202000f, -0.05738299f, -0.01509651f, 
    0.03092225f, -0.04741748f, 0.02419198f, 0.02128056f, -0.05089609f, 0.04677064f, 0.02494150f, -0.04832039f, 
    -0.01808788f, 0.01691582f, -0.04793370f, 0.02081044f, 0.03564010f, -0.03222710f, -0.05385350f, 0.04197534f, 
    -0.02157305f, -0.00556499f, -0.03127741f, 0.03106537f, -0.01973825f, 0.01886742f, 0.01695332f, 0.00930071f, 
    -0.00109410f, -0.03547917f, 0.01352554f, 0.04269269f, -0.02584085f, -0.02942584f, -0.03679991f, -0.01657760f, 
    -0.01992279f, -0.03618138f, -0.03589980f, 0.04568266f, -0.03168325f, -0.02887999f, 0.01058801f, -0.00000085f, 
    0.04273071f, -0.04269287f, -0.00064916f, 0.04378423f, 0.01266654f, -0.02371627f, 0.00900263f, -0.01787836f, 
    0.01015865f, 0.01864836f, -0.03349747f, -0.02054779f, -0.02569620f, -0.06029670f, -0.02607011f, 0.02413591f, 
    -0.03170441f, -0.06025649f, -0.00404587f, -0.05768016f, -0.00697568f, -0.00596901f, -0.04539763f, 0.00269720f, 
    -0.05285933f, -0.00464078f, 0.04597989f, -0.04102923f, -0.03749518f, -0.00489256f, 0.03748279f, -0.02021122f, 
    0.01378022f, -0.01720282f, 0.01102099f, 0.03764236f, -0.01902151f, -0.03202734f, -0.06038399f, 0.03253912f, 
    0.03913242f, -0.03172524f, -0.04761336f, 0.04202309f, -0.03553359f, -0.00018654f, 0.04290824f, -0.05587732f, 
    0.05474821f, 0.02578246f, -0.02455216f, 0.01062370f, -0.01299337f, 0.00744446f, 0.01493100f, -0.04633395f, 
    -0.03480753f, -0.04828605f, -0.04545797f, -0.04507236f, -0.03083520f, -0.05549954f, -0.03825022f, 0.02665247f, 
    -0.00120809f, -0.03451013f, -0.02796018f, 0.04091713f, -0.01779832f, 0.00659126f, 0.03443741f, -0.04847078f, 
    0.03032964f, 0.02596664f, 0.02956709f, 0.00480872f, -0.04621755f, -0.04992391f, -0.00436640f, 0.01122399f, 
    -0.00221282f, 0.04157495f, 0.02453734f, -0.04534395f, -0.02050603f, 0.00583575f, -0.04569815f, -0.01840313f, 
    -0.03066118f, 0.01560289f, -0.00993903f, 0.00269023f, -0.00982805f, 0.04087273f, -0.00449812f, -0.02929864f, 
    -0.01146900f, -0.00944191f, -0.04281206f, 0.03285326f, -0.01712525f, 0.01990925f, -0.02274509f, -0.05548853f, 
    -0.04021736f, 0.02397707f, 0.05046294f, 0.01542653f, 0.02394898f, -0.04653479f, 0.02658828f, 0.03912912f, 
    0.04738354f, 0.02175029f, -0.03206643f, 0.04131003f, 0.02061325f, 0.00049389f, 0.03523437f, 0.01266871f, 
    0.01224678f, 0.03446876f, 0.01262973f, 0.04407712f, 0.02238183f, -0.02329066f, -0.00464739f, -0.01998162f, 
    0.03155521f, 0.02466633f, -0.05012849f, -0.04157549f, -0.00936960f, -0.02354305f, -0.02175895f, 0.04442955f, 
    -0.05510100f, -0.05383067f, -0.02207953f, -0.02425606f, 0.03964421f, 0.02606272f, -0.04180213f, 0.00004290f, 
    -0.02947759f, -0.01443706f, -0.02325246f, -0.04117047f, -0.01111886f, 0.04069851f, -0.00825599f, 0.02779336f, 
    -0.05075280f, -0.00358448f, -0.02883299f, -0.05466019f, 0.00078776f, -0.02915497f, -0.03294447f, -0.04433967f, 
    0.00296605f, 0.00906602f, 0.01836836f, -0.01306736f, 0.01053644f, 0.05058687f, -0.01613815f, -0.02401144f, 
    -0.00705963f, -0.04833817f, -0.02254234f, 0.01785309f, 0.03135901f, -0.03161804f, 0.03065945f, 0.02168061f, 
    -0.02911346f, 0.01392342f, 0.03475503f, 0.01836916f, 0.02008309f, -0.04193781f, -0.04903378f, -0.00267910f, 
    0.00296287f, -0.04362691f, -0.04281009f, -0.03816211f, -0.03072578f, -0.02263339f, -0.04950237f, 0.00849421f, 
    -0.03468734f, -0.01410504f, 0.05534796f, -0.04309073f, -0.01617707f, 0.01499957f, -0.01806252f, -0.04692696f, 
    -0.01674388f, -0.04039912f, -0.00774758f, 0.00016831f, -0.04850010f, -0.03190131f, -0.02680982f, 0.04384856f, 
    0.02159963f, 0.03307815f, -0.03678111f, 0.00227206f, -0.03289522f, -0.01489966f, 0.00212085f, 0.04875551f, 
    0.04002376f, -0.05063446f, -0.04128397f, 0.02409351f, 0.02125685f, 0.00374835f, -0.05323183f, -0.02349598f, 
    -0.04752549f, -0.01620003f, -0.04490308f, -0.00900269f, -0.02902267f, -0.03818396f, -0.01168338f, 0.05254159f, 
    -0.03354721f, 0.02988387f, -0.03122708f, -0.04087250f, -0.05761793f, -0.05737131f, 0.00238845f, -0.01632161f, 
    0.01575356f, -0.04709607f, -0.00438052f, 0.00870380f, 0.04284362f, 0.02405546f, 0.04672503f, 0.03371190f, 
    0.01727919f, -0.05762256f, -0.04462844f, -0.01722327f, 0.01638881f, 0.04026164f, -0.01807418f, -0.05174500f, 
    -0.00056944f, -0.02769966f, 0.03094046f, 0.01811467f, -0.02459525f, 0.00417684f, -0.03549372f, -0.00695172f, 
    0.00660157f, 0.04067581f, -0.02330104f, -0.00825362f, 0.02134822f, -0.04548394f, -0.03589759f, -0.05434192f, 
    -0.01898410f, -0.02531369f, 0.04874433f, 0.03568676f, 0.02797492f, -0.04777052f, -0.03033677f, -0.05281737f, 
    -0.00269155f, -0.01843951f, -0.02173182f, 0.00588955f, -0.04828582f, -0.02843198f, 0.04076231f, 0.04933492f, 
    -0.00273648f, -0.00298092f, -0.04536505f, 0.03445445f, 0.00841092f, -0.00996172f, -0.05700410f, -0.01615310f, 
    0.02093492f, 0.02632402f, -0.05282101f, 0.01617318f, 0.03296456f, 0.02326268f, -0.02345007f, -0.02694088f, 
    -0.04661203f, -0.02340399f, -0.03161934f, -0.00927996f, 0.02150691f, -0.02645561f, -0.01419654f, 0.02044275f, 
    -0.00551050f, -0.00392214f, -0.04556383f, -0.04702487f, -0.01570067f, -0.02500454f, -0.05849143f, -0.05361049f, 
    -0.02803546f, -0.03928965f, 0.01260444f, -0.02615581f, -0.00735605f, 0.02031795f, -0.02608281f, 0.00246300f, 
    -0.00649448f, 0.01476951f, -0.05210090f, -0.03948869f, -0.02280857f, 0.00378419f, 0.02035145f, 0.01138124f, 
    0.00742346f, -0.02110857f, -0.01240354f, 0.03362399f, 0.02904141f, -0.03484603f, -0.03835453f, 0.01249383f, 
    0.04508211f, -0.06080271f, -0.05293150f, 0.01733304f, 0.04424801f, -0.03492709f, 0.05167835f, -0.00425495f, 
    0.00923435f, -0.00175318f, -0.03490242f, 0.03650967f, -0.01405460f, -0.01781156f, 0.01223455f, -0.03017363f, 
    -0.05297103f, 0.04069039f, -0.02008346f, -0.05661707f, -0.04050068f, -0.02253197f, -0.05202765f, 0.01913698f, 
    -0.01613011f, -0.02970932f, -0.05383381f, -0.04322491f, -0.02759386f, -0.00608037f, 0.00954442f, 0.04872078f, 
    0.00031648f, 0.01362726f, -0.03937109f, -0.01892419f, -0.05866850f, -0.02099001f, 0.04526665f, -0.05902786f, 
    0.02176430f, -0.03222547f, 0.00420207f, -0.01303149f, -0.02494429f, -0.01280502f, 0.00645907f, 0.01807499f, 
    0.00888715f, -0.03550225f, -0.04930082f, -0.01328469f, 0.03596218f, -0.03176763f, -0.00988710f, -0.05717174f, 
    -0.04649167f, -0.05311046f, -0.05468880f, -0.03174223f, 0.01627191f, -0.03856911f, 0.02545674f, 0.03872133f, 
    -0.01374299f, -0.00794110f, 0.01631035f, -0.00083745f, -0.01345780f, -0.03341850f, -0.05911141f, -0.00421886f, 
    0.04476789f, 0.02500353f, -0.05267992f, -0.05732081f, 0.00770895f, -0.02444656f, 0.04059049f, 0.02591542f, 
    -0.00562351f, -0.00602926f, 0.00610385f, -0.01301365f, -0.05429732f, 0.05150814f, 0.04707665f, -0.04229406f, 
    -0.06080100f, -0.04968217f, -0.01983452f, 0.04521752f, -0.03887886f, 0.00922596f, -0.02765672f, -0.03060729f, 
    0.02863983f, 0.01087817f, -0.04144245f, -0.04754992f, 0.02376203f, 0.04467443f, 0.04780011f, 0.03827225f, 
    -0.05504637f, 0.02970465f, -0.04257243f, 0.04265768f, -0.04934913f, -0.01792189f, 0.04442665f, -0.04128472f, 
    -0.05564262f, 0.03439214f, 0.03772546f, 0.01192278f, -0.04527396f, 0.02667905f, 0.01913055f, -0.05615745f, 
    0.04258991f, -0.00264019f, -0.00263212f, 0.00342930f, 0.01148133f, -0.01030786f, -0.00340422f, 0.00775952f, 
    -0.06139913f, 0.01083214f, -0.03426412f, -0.05652207f, -0.04191140f, 0.03299117f, -0.05019461f, -0.00765562f, 
    0.00689201f, 0.03740728f, -0.04662098f, 0.01683098f, 0.01632589f, -0.05533179f, -0.04280300f, 0.02293085f, 
    -0.01134000f, 0.01816753f, 0.02243565f, -0.00567372f, 0.02057021f, -0.00793923f, -0.01279206f, -0.05750125f, 
    0.00152870f, -0.06078602f, 0.03900810f, -0.02122955f, 0.00880642f, -0.03148894f, -0.00555590f, -0.05542099f, 
    -0.00996391f, -0.05904849f, 0.03619087f, 0.03920697f, 0.03263625f, 0.00559337f, 0.03676572f, -0.02525344f, 
    0.02231151f, -0.04480604f, -0.03802406f, -0.02344507f, -0.05346115f, -0.05365197f, -0.04979499f, 0.00629753f, 
    -0.02202347f, -0.02461700f, 0.00696191f, 0.04581446f, 0.04809399f, 0.00654532f, -0.02876441f, 0.00970150f, 
    -0.05295418f, -0.04725301f, -0.03940539f, -0.03358289f, -0.04537768f, -0.03697253f, 0.04130420f, 0.04234510f, 
    -0.02448211f, -0.03731440f, 0.03126626f, 0.02572448f, -0.05744362f, -0.02730669f, 0.02989197f, -0.02326137f, 
    0.00314181f, -0.01446995f, -0.04320059f, 0.01757640f, -0.01751194f, 0.04438308f, 0.02785836f, -0.04889602f, 
    0.01560863f, 0.01911740f, -0.05795655f, 0.03445287f, 0.00059895f, 0.00718058f, 0.01991798f, 0.02131005f, 
    -0.01117458f, -0.05707073f, -0.02925033f, -0.05501809f, -0.00273711f, -0.00843183f, 0.02221459f, -0.00443911f, 
    -0.05059734f, -0.00700910f, -0.02170258f, -0.04139775f, 0.01494472f, -0.05388371f, 0.02440613f, -0.02902727f, 
    0.00285072f, 0.01782604f, -0.04533536f, -0.01335327f, -0.04313450f, 0.00616846f, 0.02193429f, -0.04085523f, 
    0.01955094f, 0.01237458f, -0.05015248f, -0.02614698f, -0.04972284f, 0.03444054f, -0.05563250f, -0.03360241f, 
    -0.03367700f, -0.00991559f, 0.00926085f, 0.04009183f, -0.05814653f, -0.02364863f, 0.02413482f, -0.00409338f, 
    -0.05590496f, 0.02647636f, 0.01819147f, 0.02921419f, 0.01966446f, 0.00142860f, 0.02669212f, 0.01228194f, 
    -0.01406050f, -0.05677352f, 0.03925099f, -0.01775122f, 0.03497859f, -0.05497999f, -0.05200884f, -0.01800016f, 
    0.03583205f, -0.00776222f, -0.01454056f, -0.05304236f, -0.02216383f, 0.04332635f, -0.00493242f, -0.02443848f, 
    0.03736230f, 0.04701293f, 0.01607337f, 0.01991160f, -0.01787185f, -0.05485730f, 0.02970939f, -0.04435692f, 
    -0.03262771f, 0.02475285f, -0.05359080f, 0.00276705f, -0.01917115f, -0.00274268f, 0.03555056f, 0.02312287f, 
    0.04880696f, 0.00792932f, 0.02592435f, -0.00467536f, -0.04062618f, -0.00992352f, 0.00245724f, 0.04784199f, 
    -0.01055442f, 0.03168710f, -0.05206524f, 0.02774550f, -0.05357613f, 0.02534420f, -0.02640316f, 0.02263691f, 
    0.00444096f, 0.01392405f, 0.02418163f, 0.00742424f, -0.04047309f, -0.00259617f, 0.05399026f, -0.00560816f, 
    0.02849338f, 0.04520128f, -0.06021430f, -0.03620034f, 0.03178151f, 0.00793829f, 0.04693576f, -0.02564217f, 
    -0.05455308f, 0.05308121f, 0.03679014f, -0.03350970f, 0.01749718f, -0.00516171f, 0.02190059f, 0.03178626f, 
    0.04693354f, 0.04543739f, -0.01382142f, 0.00165152f, 0.02319542f, 0.01725259f, -0.05023160f, -0.05462050f, 
    0.00389706f, 0.04703085f, -0.00287908f, -0.03234759f, -0.04819253f, -0.03469186f, -0.02175166f, -0.01035936f, 
    -0.05711125f, 0.00789533f, -0.01595793f, -0.04667219f, -0.04181934f, 0.00628177f, 0.00081869f, -0.00764225f, 
    0.04891415f, 0.00113071f, 0.02707829f, -0.00077380f, -0.02164084f, -0.03795825f, -0.01368893f, -0.03244897f, 
    0.03417157f, 0.00758323f, -0.03570803f, -0.00587203f, 0.03294212f, 0.01256216f, -0.05090448f, -0.03161516f, 
    -0.04295843f, -0.05607761f, -0.05226719f, -0.00365499f, -0.02810787f, -0.05144910f, 0.04558329f, -0.03818754f, 
    -0.03482373f, 0.00768572f, -0.00073278f, 0.02609033f, 0.03937617f, -0.01875534f, -0.05737160f, 0.02535518f, 
    -0.05156634f, 0.00833215f, -0.06134623f, 0.03619555f, 0.03473934f, 0.02443384f, 0.00911687f, -0.02029422f, 
    -0.03762413f, -0.05296580f, 0.00165243f, 0.03837762f, -0.03737015f, -0.05533486f, 0.01042051f, 0.00244558f, 
    -0.04124709f, 0.30882517f, -0.27842659f, 0.00333051f, 0.09296881f, 0.01629133f, -0.18320000f, -0.01509974f, 
    0.08551817f, 0.02032559f, 0.03826246f, 0.04584089f, 0.09084624f, -0.02694247f, -0.05018344f, -0.16811541f, 
    -0.09696335f, -0.07988665f, 0.08151206f, 0.10251030f, -0.09702630f, 0.11206558f, 0.22053982f, 0.02075814f, 
    0.06654193f, -0.25650617f, 0.00562383f, -0.04045311f, 0.15714851f, -0.12604630f, -0.06367761f, -0.00244859f, 
    0.12862711f, 0.18782958f, 0.08602146f, -0.19646710f, -0.06514536f, -0.04823464f, -0.03392192f, 0.00098930f, 
    -0.07258822f, 0.44019684f, 0.11589597f, 0.20784333f, -0.01851360f, 0.00102683f, 0.18962342f, 0.15638916f, 
    -0.06899715f, 0.25602013f, 0.04407246f, 0.06986480f, 0.19670564f, 0.15481830f, -0.12195454f, 0.11115243f, 
    -0.03654124f, -0.11746947f, 0.17870629f, -0.11669645f, -0.24388495f, 0.08831754f, -0.23471020f, -0.19814174f, 
    0.05638178f, 0.22370841f, -0.16213953f, -0.04395925f, -0.04670795f, 0.02732451f, -0.04962968f, 0.09110226f, 
    -0.02185199f, 0.13560277f, 0.00155146f, 0.26588267f, -0.09482031f, -0.06569584f, -0.07095285f, -0.10996293f, 
    -0.04906049f, 0.05559942f, 0.40533307f, 0.16545327f, -0.13939829f, 0.08114592f, 0.03506447f, 0.06652042f, 
    -0.05839868f, -0.08552936f, 0.06318393f, -0.03746555f, 0.04797457f, -0.14436391f, -0.15181030f, -0.03996822f, 
    -0.04451660f, -0.04358065f, 0.05511436f, -0.08205170f, 0.06568892f, -0.41727132f, -0.22288549f, -0.08260459f, 
    -0.16418707f, 0.06383950f, -0.21166465f, -0.03787441f, 0.09237155f, -0.11625643f, 0.00717389f, -0.19031973f, 
    0.13139628f, 0.07312366f, 0.02396672f, -0.23458345f, -0.05370187f, -0.13072497f, 0.14105830f, 0.01104794f, 
    -0.21272735f, 0.09010186f, -0.09133143f, 0.02301820f, -0.15718479f, -0.02758805f, 0.07704992f, -0.13955905f, 
    -0.07594393f, -0.08075234f, -0.02817561f, -0.02670337f, 0.09725111f, 0.11044803f, 0.09068228f, -0.05601433f, 
    0.10902370f, 0.13542922f, 0.02769423f, -0.01406958f, -0.42801067f, -0.23244661f, 0.32698882f, -0.17709020f, 
    0.31299525f, -0.12244163f, 0.14151424f, 0.06760238f, -0.11043897f, 0.14389382f, -0.03673269f, -0.08779896f, 
    0.00577886f, 0.01927399f, -0.08651379f, -0.00737920f, 0.04030184f, -0.09731039f, 0.14339259f, 0.01280107f, 
    0.62512028f, 0.03817707f, -0.16577671f, 0.15308183f, -0.01344557f, -0.08034939f, 0.28867263f, -0.00946946f, 
    -0.08806413f, 0.09967621f, 0.29483292f, -0.12148685f, 0.14466639f, 0.00830259f, 0.04128371f, 0.00755427f, 
    0.06545822f, -0.00814422f, 0.10841050f, 0.04728314f, 0.25550020f, -0.11853023f, -0.07669969f, 0.23573206f, 
    0.19935696f, -0.10324883f, -0.08175845f, -0.07976743f, 0.04076336f, 0.02489455f, -0.01812430f, 0.09915673f, 
    -0.11897868f, -0.02336879f, 0.01742812f, -0.03214889f, -0.09212785f, 0.03186367f, 0.04294519f, -0.12634504f, 
    -0.29650491f, 0.07358240f, 0.39141330f, 0.35753456f, -0.09558287f, 0.03175388f, -0.22320779f, 0.03209742f, 
    0.02293881f, -0.04352266f, 0.09260020f, 0.07865424f, 0.09532270f, -0.17666954f, -0.24010852f, 0.05902076f, 
    -0.06697279f, -0.12439903f, 0.03284077f, -0.05012861f, 0.23432881f, -0.06997062f, 0.20033891f, 0.11681569f, 
    0.09155241f, 0.11962591f, 0.05716482f, 0.12106016f, 0.05998793f, 0.03402473f, 0.02042354f, -0.12819658f, 
    0.13530709f, -0.11025833f, -0.13627620f, 0.08657775f, 0.08933032f, -0.00735748f, -0.12930404f, -0.00993658f, 
    -0.33911362f, 0.24308527f, -0.06116036f, 0.20468909f, -0.16246732f, -0.20638274f, 0.13901708f, -0.04626262f, 
    -0.22289908f, 0.00713065f, 0.05465095f, -0.09569365f, 0.08094279f, 0.05789094f, 0.00792588f, -0.02933839f, 
    0.00464973f, -0.02865417f, 0.03960637f, 0.09946556f, -0.41218546f, 0.23885758f, 0.15159328f, 0.18566234f, 
    -0.02104994f, 0.07447203f, 0.08594290f, -0.02257771f, -0.19897977f, 0.01681093f, -0.18655281f, 0.01898428f, 
    0.03491291f, 0.01998579f, -0.00766344f, -0.29186147f, -0.21552499f, -0.06469628f, 0.09523360f, -0.12313001f, 
    -0.22218485f, 0.23712239f, 0.18113115f, 0.10669679f, -0.32180142f, 0.10769390f, -0.01804391f, 0.06575289f, 
    -0.09848988f, -0.09637208f, -0.14595053f, -0.00733494f, 0.00103789f, 0.08426327f, 0.12077571f, -0.15667871f, 
    -0.04356350f, -0.00647188f, 0.03151221f, 0.05863965f, 0.32621923f, 0.21355386f, -0.21133471f, -0.22007330f, 
    -0.59205490f, 0.17027681f, -0.00693413f, -0.07977942f, -0.08041975f, 0.06317782f, -0.03654450f, 0.15328099f, 
    -0.04033334f, 0.08121030f, 0.10458923f, 0.12455831f, -0.05926313f, 0.08568851f, 0.09300061f, 0.25682673f, 
    0.03271235f, 0.00298844f, -0.04898756f, 0.39644223f, -0.09456979f, -0.26771456f, -0.10722920f, -0.04911118f, 
    -0.10788681f, 0.09299418f, -0.11301747f, -0.03895376f, 0.13990360f, 0.01857312f, 0.03958925f, 0.04633224f, 
    0.30243069f, -0.02585920f, 0.12484010f, 0.35822102f, -0.15695179f, -0.32237294f, -0.10060045f, -0.05555882f, 
    -0.15206702f, -0.25197557f, -0.09153088f, -0.18157397f, -0.01922975f, -0.23212543f, 0.17195435f, -0.04534418f, 
    -0.10024784f, -0.13915080f, -0.02272677f, -0.10857845f, 0.10182740f, 0.13054430f, 0.22370832f, 0.10920411f, 
    0.21183175f, -0.20900191f, 0.13968363f, 0.25624123f, 0.24617742f, 0.09015705f, 0.20092916f, -0.11211225f, 
    0.09159262f, 0.05400588f, 0.03401170f, 0.00904409f, 0.00945822f, 0.06172747f, 0.05403183f, 0.04903995f, 
    0.14067760f, 0.00901583f, 0.08487120f, -0.00657548f, 0.07691763f, 0.12428980f, 0.12034874f, 0.06739452f, 
    0.07171244f, 0.19776350f, -0.00219069f, 0.12179158f, 0.15808323f, -0.07225114f, -0.12381569f, 0.09747762f, 
    0.03927539f, 0.00883629f, 0.03324694f, 0.08047411f, 0.04354492f, 0.15182278f, -0.06694672f, 0.02470335f, 
    -0.09523270f, 0.03897293f, -0.31427890f, -0.09896289f, -0.06389105f, 0.08220182f, -0.08201212f, -0.04229826f, 
    0.05828417f, 0.04658433f, -0.01114530f, 0.11506888f, -0.11614389f, -0.10565992f, -0.12461960f, -0.00362146f, 
    -0.02189976f, 0.05352027f, -0.04979589f, -0.07992805f, -0.07222829f, -0.14804664f, 0.15756109f, -0.16598499f, 
    -0.33292091f, -0.01401247f, -0.15116315f, 0.20046791f, 0.06843729f, -0.14395310f, -0.04126319f, 0.02560447f, 
    -0.05074050f, -0.02145323f, 0.09981340f, 0.13968958f, 0.06201807f, -0.05041188f, -0.09387530f, -0.12776108f, 
    0.23873849f, -0.08344051f, -0.00677962f, 0.05668667f, -0.16386484f, 0.07728682f, -0.06895245f, -0.08966590f, 
    0.13705988f, -0.07175157f, -0.02765370f, 0.12046044f, 0.05060273f, 0.01178187f, 0.00562022f, 0.12291378f, 
    0.03431717f, 0.07622226f, 0.21623224f, 0.23213018f, 0.34273249f, -0.11098390f, 0.16908140f, 0.18213439f, 
    -0.18854943f, 0.12544185f, -0.04980396f, 0.05198042f, 0.00809245f, -0.22184323f, -0.09581673f, 0.13433185f, 
    0.09020476f, 0.08193654f, 0.11801801f, -0.03808949f, -0.07898810f, 0.03580076f, 0.18677017f, 0.25601378f, 
    -0.20856713f, -0.09526225f, -0.23562023f, 0.04713608f, -0.12752353f, 0.03241448f, 0.03840674f, -0.13615750f, 
    0.37361056f, 0.14006783f, 0.06574302f, 0.13153160f, -0.01402322f, 0.15407339f, 0.02935699f, 0.00072418f, 
    0.01697454f, 0.02640311f, 0.13579360f, 0.12443545f, -0.21488039f, -0.00204925f, 0.14517821f, 0.28282276f, 
    -0.07765892f, -0.11743909f, -0.08909246f, -0.13722546f, -0.15713775f, -0.06095886f, -0.09748679f, -0.07001181f, 
    0.16241644f, 0.10696653f, 0.14043425f, -0.04203562f, 0.04344001f, 0.07237058f, 0.09171023f, 0.08335592f, 
    -0.41762844f, -0.14523217f, -0.36411774f, 0.07055487f, -0.04204750f, -0.10371587f, -0.15246111f, 0.19636600f, 
    -0.14406025f, 0.11455187f, 0.05733807f, -0.05798190f, -0.03723836f, -0.18323268f, 0.06559885f, -0.03530356f, 
    -0.01249599f, -0.07515515f, -0.04155196f, 0.03099443f, -0.09971808f, -0.08929146f, -0.02149035f, -0.00520662f, 
    -0.12814663f, 0.04085416f, -0.03794460f, 0.14159830f, -0.01869030f, -0.02173619f, 0.03503087f, -0.07841583f, 
    0.07794609f, 0.00012960f, 0.08493139f, 0.03272785f, -0.01532984f, -0.07544357f, 0.04980140f, 0.05181862f, 
    -0.20134604f, -0.31603402f, -0.17368887f, -0.09125964f, -0.34487700f, 0.00266480f, -0.09317745f, -0.02707904f, 
    -0.00738203f, -0.01209930f, -0.07336285f, -0.04013248f, -0.11849116f, -0.02360838f, -0.06880023f, -0.05770492f, 
    0.02297208f, -0.02878523f, 0.11244239f, 0.08053464f, 0.07026638f, 0.09747327f, 0.10611995f, 0.00223369f, 
    0.10918700f, 0.15750787f, 0.06188726f, -0.01057659f, 0.04713443f, -0.08832406f, 0.05478843f, 0.04479413f, 
    0.05653038f, 0.03209654f, -0.10598880f, 0.38441715f, 0.08251111f, -0.13800275f, 0.07988619f, -0.22677317f, 
    -0.05936075f, -0.09226314f, -0.22848363f, -0.15928464f, -0.17598450f, 0.10948317f, -0.17620473f, 0.23458703f, 
    0.04178850f, -0.23094524f, 0.05445952f, -0.00245563f, -0.07733071f, 0.06755317f, -0.11336132f, 0.19999479f, 
    0.14242549f, 0.02052185f, 0.01907451f, -0.05131436f, 0.17495775f, -0.02098189f, 0.26370502f, 0.23329583f, 
    0.21811710f, 0.21613111f, 0.30709457f, 0.23194852f, 0.12341222f, 0.09454644f, 0.05039026f, 0.01648276f, 
    0.03400580f, -0.07873262f, 0.18135288f, 0.16183400f, -0.01674560f, -0.01581657f, -0.08984324f, -0.13363728f, 
    -0.10198754f, 0.02799647f, 0.15906692f, -0.02992646f, -0.09015892f, 0.07516061f, -0.04919329f, 0.26481685f, 
    0.02728187f, 0.07936215f, -0.29578614f, -0.00325271f, -0.11130190f, -0.01118639f, -0.06616558f, -0.03675742f, 
    -0.05121863f, -0.08961581f, -0.11168411f, -0.20194018f, 0.12763946f, -0.25752899f, -0.43398210f, 0.48180616f, 
    0.29245415f, 0.07788637f, 0.01690019f, -0.06778854f, -0.18564956f, 0.05905000f, -0.06810569f, -0.02465389f, 
    -0.13545068f, -0.11202795f, -0.21228187f, 0.09296747f, -0.24796166f, -0.14928991f, -0.07484280f, -0.16999783f, 
    0.03205692f, -0.21856704f, 0.11979209f, 0.14785144f, -0.00526245f, 0.17991847f, 0.17432980f, 0.04340567f, 
    -0.12814949f, 0.03827566f, -0.11925397f, 0.00277936f, 0.11042254f, -0.04431505f, 0.07587577f, -0.01534874f, 
    0.17439078f, 0.01079141f, 0.08555792f, 0.11203518f, 0.27027822f, -0.04073487f, 0.05544418f, 0.16952428f, 
    -0.05854209f, -0.09552568f, -0.16647130f, -0.00456188f, 0.07602589f, 0.16528912f, 0.16031009f, -0.11184742f, 
    -0.08587869f, -0.20145492f, -0.15132757f, -0.04917265f, 0.08482789f, 0.01700087f, 0.13927031f, 0.19666497f, 
    -0.09281449f, -0.03780315f, 0.21155767f, 0.14649221f, -0.01277844f, -0.09952709f, 0.04007860f, 0.00229808f, 
    0.10399728f, 0.03070695f, 0.03369781f, -0.01026206f, 0.00523164f, 0.08056338f, 0.09111825f, -0.00141663f, 
    0.05804890f, 0.17166467f, -0.00649249f, 0.15147902f, -0.12480245f, -0.27984238f, 0.02616302f, 0.18274117f, 
    0.04019403f, 0.03800144f, 0.01850293f, 0.09800460f, -0.09688712f, 0.00461581f, 0.03089293f, 0.16567853f, 
    -0.05963165f, 0.04971235f, -0.00137327f, -0.00684260f, 0.18480718f, 0.01210369f, -0.15733531f, 0.05025940f, 
    -0.00609688f, -0.21098650f, 0.07409793f, 0.20444356f, 0.06606711f, 0.05398701f, -0.06791140f, 0.08738524f, 
    -0.02098806f, -0.00653225f, -0.06127883f, 0.00023922f, -0.08794594f, -0.06840367f, -0.02806573f, -0.05292349f, 
    -0.07581767f, 0.09884908f, -0.05550387f, -0.02099469f, 0.49482062f, 0.04543860f, -0.21252285f, 0.27783316f, 
    0.07928880f, 0.14080280f, 0.06952135f, 0.01277394f, 0.03798787f, -0.02655721f, 0.04648942f, -0.10300418f, 
    0.06723589f, 0.00188354f, -0.19074214f, -0.06534197f, -0.09044290f, -0.02199570f, -0.13473621f, -0.06710169f, 
    -0.20533866f, 0.12431102f, 0.43451715f, 0.26941559f, 0.14217116f, -0.05463898f, 0.05643601f, 0.13719371f, 
    -0.00316285f, -0.07750567f, -0.04677194f, -0.02366629f, 0.08821467f, 0.08501224f, 0.11531048f, -0.05272064f, 
    -0.08009969f, 0.03535174f, -0.07509640f, 0.00472908f, -0.22608730f, -0.10934919f, -0.18660571f, -0.00193528f, 
    0.02796397f, 0.03228055f, 0.22219208f, 0.29120964f, -0.01032612f, 0.11771554f, -0.11668841f, 0.00081954f, 
    0.08079655f, 0.05843030f, -0.05829444f, 0.02515778f, -0.02468810f, 0.08776096f, 0.01843528f, 0.08599582f, 
    -0.13600942f, -0.37853530f, 0.09763443f, 0.28531209f, -0.19362034f, 0.15998752f, -0.11696775f, 0.01917460f, 
    0.03070766f, -0.01603390f, 0.05316767f, -0.22261287f, -0.00992782f, 0.09238961f, -0.01675098f, 0.04005696f, 
    -0.00505583f, -0.01610195f, 0.07831050f, -0.00022484f, -0.09074408f, -0.11710088f, 0.05817191f, 0.48841208f, 
    -0.07853416f, -0.08439817f, -0.01200066f, -0.06152525f, -0.03553097f, 0.07984363f, -0.07509495f, 0.06280740f, 
    0.10233635f, 0.00148596f, 0.03505303f, 0.05721161f, 0.16611911f, 0.02183246f, 0.00175078f, -0.03877478f, 
    0.12460822f, -0.15414345f, 0.14154801f, 0.10421205f, 0.04376214f, -0.06955020f, -0.27294567f, 0.01582112f, 
    -0.07535446f, -0.01461534f, 0.01267686f, 0.13048671f, 0.05260969f, -0.29471982f, -0.12528180f, -0.03384741f, 
    0.01629414f, 0.02926996f, -0.03447917f, -0.17041068f, 0.17679203f, -0.22203495f, -0.10869799f, 0.01041958f, 
    -0.05372811f, 0.09702081f, -0.04002916f, -0.04626530f, 0.05694592f, 0.07413656f, -0.02854176f, -0.07740182f, 
    0.08384725f, 0.01730331f, -0.04777748f, 0.10868251f, 0.23461631f, 0.01261127f, 0.10447045f, 0.17309231f, 
    -0.08184947f, -0.19566992f, -0.16696392f, -0.10893384f, 0.00167330f, -0.10079776f, -0.15890478f, -0.02827505f, 
    0.09672474f, 0.14917326f, -0.14336047f, -0.06330493f, 0.04715023f, -0.10420821f, -0.17727052f, 0.05751084f, 
    -0.13494308f, -0.16528043f, -0.03227603f, 0.20579377f, 0.02031672f, -0.03169952f, 0.17660496f, 0.22747855f, 
    0.13599512f, 0.11612854f, 0.14422901f, -0.07127147f, 0.16394319f, 0.03557852f, -0.10742545f, -0.04635577f, 
    0.14816360f, 0.00544024f, 0.01563534f, 0.17345640f, 0.14706047f, 0.10600201f, 0.11374731f, 0.04656617f, 
    0.15281813f, -0.18120210f, 0.15065081f, -0.10858499f, -0.04035901f, -0.12618333f, 0.15512645f, -0.25626731f, 
    -0.21277371f, -0.02201703f, 0.23851620f, 0.05628955f, 0.07981037f, 0.03522342f, -0.02662591f, 0.27273783f, 
    0.14495610f, 0.00331354f, 0.06685384f, -0.14701129f, 0.34861690f, -0.00027793f, -0.14446716f, 0.01306381f, 
    -0.09567186f, 0.04917060f, -0.20064792f, -0.11983613f, 0.06487024f, -0.11331295f, 0.13807839f, 0.11090902f, 
    0.06562465f, -0.02424396f, 0.09357690f, -0.10218088f, 0.01444168f, 0.04728615f, -0.19171835f, 0.09666640f, 
    0.28817472f, -0.32672608f, 0.09863241f, -0.03097085f, -0.00421435f, 0.08866195f, -0.01185291f, -0.06765050f, 
    -0.01569271f, 0.14696847f, -0.04330553f, -0.07224183f, 0.04042151f, 0.03633256f, 0.12503225f, -0.15990511f, 
    0.07469380f, -0.03989103f, 0.08888715f, 0.07309998f, 0.03382221f, 0.25635049f, 0.36812410f, 0.41947633f, 
    -0.21391907f, 0.13596597f, 0.18411353f, 0.11219130f, 0.16949081f, 0.13555036f, -0.09798490f, 0.05795837f, 
    0.02885767f, -0.00213657f, -0.02501024f, -0.01781362f, -0.10857304f, 0.25975436f, -0.03713590f, -0.06684438f, 
    0.05327020f, -0.05175278f, -0.15536168f, -0.28042006f, -0.32793584f, 0.10174756f, 0.05860129f, -0.04965800f, 
    -0.02840431f, 0.15423928f, -0.21403825f, 0.06185938f, -0.10799336f, -0.12095463f, 0.05917260f, -0.00120800f, 
    0.01260133f, 0.01380875f, 0.13704583f, 0.07563432f, 0.08221488f, -0.07883535f, 0.68192071f, -0.08031439f, 
    -0.58604878f, -0.02785475f, 0.02033935f, 0.16008903f, 0.24377838f, 0.11706638f, -0.05359054f, 0.01079263f, 
    0.04447851f, -0.11308803f, -0.04433202f, 0.04323906f, 0.15032214f, 0.10009392f, 0.02538879f, 0.05844968f, 
    0.39251330f, 0.06817786f, 0.52771813f, 0.02095951f, -0.01596240f, 0.19412453f, 0.18136100f, 0.03837207f, 
    0.07397293f, 0.12116034f, -0.00802203f, 0.02372885f, 0.05147664f, -0.08763798f, -0.06333595f, -0.03640534f, 
    0.00161367f, -0.14463322f, -0.00168411f, 0.13877314f, -0.13638210f, 0.18971509f, 0.15447938f, 0.43490803f, 
    -0.45634195f, 0.20796214f, -0.05357745f, -0.22374113f, -0.12755254f, 0.13821487f, 0.09892660f, 0.04033691f, 
    -0.08496817f, 0.00991407f, 0.05658169f, 0.06450132f, -0.10534742f, 0.06174506f, -0.09911215f, 0.11196506f, 
    0.16577674f, -0.80799472f, -0.11772626f, -0.13346754f, -0.15909865f, 0.21802327f, -0.21438058f, -0.02457222f, 
    -0.12680322f, -0.12192173f, -0.00148614f, 0.25352815f, 0.12464247f, -0.10529045f, 0.00036499f, -0.05306661f, 
    0.02085082f, 0.00004060f, -0.08807996f, 0.22961244f, -0.18277667f, 0.10177238f, 0.04394362f, -0.23760009f, 
    0.35429612f, -0.14093862f, -0.05413407f, -0.33346403f, -0.20135009f, -0.18918210f, 0.11981570f, -0.08157178f, 
    -0.01964868f, 0.09263642f, 0.13366294f, -0.05725592f, 0.12997541f, 0.04974995f, 0.10217674f, -0.00228278f, 
    -0.42108715f, -0.06137441f, -0.01054353f, -0.56652087f, -0.16760737f, 0.01951548f, 0.17738280f, 0.04293690f, 
    0.00491039f, -0.11472273f, 0.07941649f, -0.06242081f, -0.08214983f, 0.07068246f, 0.15363981f, 0.01334699f, 
    -0.26049411f, 0.09089956f, -0.00108269f, 0.02128613f, 0.06344770f, -0.02019476f, 0.36377752f, -0.06459438f, 
    -0.17579126f, 0.11995833f, 0.08754475f, 0.13860504f, 0.03902169f, 0.05818477f, 0.09190080f, -0.08754487f, 
    -0.07612794f, 0.05347652f, 0.11247168f, -0.13229038f, -0.08947966f, 0.04481193f, 0.08138917f, 0.05966808f, 
    0.51368922f, -0.08057905f, 0.24471475f, -0.09070930f, -0.13690610f, 0.22950047f, 0.07600331f, 0.17467827f, 
    0.13076651f, 0.21819884f, -0.05877062f, 0.04419602f, -0.16077560f, -0.04686388f, -0.06147991f, -0.13421190f, 
    0.03468302f, -0.03785283f, 0.04742605f, 0.17089996f, 0.18041031f, 0.25937498f, 0.31564808f, 0.12131047f, 
    0.08535340f, 0.05959244f, 0.03443924f, 0.03699262f, -0.03518877f, 0.09707062f, -0.00258047f, 0.11188453f, 
    0.04589095f, 0.05337059f, -0.09976926f, 0.04992399f, -0.03880347f, -0.22504210f, -0.00567228f, 0.06556594f, 
    0.29140678f, 0.28449941f, 0.52321786f, 0.36652803f, -0.01699472f, 0.22649555f, 0.06722780f, 0.14050186f, 
    0.20209424f, 0.12587367f, 0.06130010f, -0.05209288f, 0.04707641f, -0.05002968f, -0.04970520f, 0.00573741f, 
    0.07357974f, -0.10258526f, -0.00501435f, -0.02110911f, 0.17399535f, 0.18268326f, 0.28123435f, -0.17353617f, 
    0.58769697f, 0.15063830f, 0.21282873f, 0.19465512f, 0.05005063f, 0.19628699f, 0.12023304f, 0.10395229f, 
    -0.12580098f, -0.21508931f, -0.09440635f, -0.07828378f, -0.02731993f, -0.13446772f, 0.08326414f, -0.24354084f, 
    0.20527050f, -0.34348944f, 0.29289073f, -0.29732978f, 0.13580184f, -0.03816179f, 0.10473070f, -0.25099650f, 
    0.15368955f, -0.17548309f, -0.08487777f, 0.16474617f, 0.06600475f, -0.02968048f, 0.01899846f, -0.15929785f, 
    -0.28159383f, -0.04518561f, 0.00536610f, -0.02705089f, 0.40701434f, -0.06575501f, 0.14986947f, -0.17555001f, 
    0.03583645f, 0.12968971f, -0.23131500f, -0.11241431f, 0.17024808f, 0.18715425f, 0.10335372f, 0.03175740f, 
    0.07868059f, 0.01289490f, -0.04767827f, 0.09991945f, -0.12808371f, -0.28868547f, 0.00235339f, -0.16610344f, 
    -0.07243113f, 0.07230335f, -0.29151055f, -0.05319686f, 0.01254049f, 0.11910268f, -0.14792308f, 0.11417837f, 
    -0.01872785f, -0.07464292f, 0.06319281f, 0.03766699f, -0.01052598f, -0.07798503f, 0.12608558f, 0.04414752f, 
    0.15151669f, 0.08959445f, 0.01710648f, 0.10618499f, -0.12877902f, -0.03268977f, -0.23400009f, -0.02661632f, 
    -0.07848905f, -0.01853330f, 0.25868437f, 0.22106041f, -0.09023225f, -0.00135652f, -0.03885797f, -0.16503355f, 
    0.00398924f, 0.05858977f, 0.04481916f, -0.07140811f, 0.06050044f, 0.09924762f, 0.06454076f, 0.06612999f, 
    0.26452616f, 0.06553022f, 0.06488875f, 0.10231006f, 0.15747978f, -0.08020691f, 0.02391604f, -0.01368447f, 
    0.17851429f, 0.06265669f, 0.07230237f, -0.10853522f, 0.07106298f, 0.18127644f, 0.08658194f, 0.02591943f, 
    0.03148303f, 0.04063363f, 0.11387935f, 0.21460445f, 0.08364798f, 0.41181546f, -0.24127427f, -0.00350418f, 
    0.13122305f, -0.15509097f, 0.20299020f, -0.20074530f, 0.11764382f, 0.18533002f, -0.15193990f, -0.00615051f, 
    -0.01526361f, -0.04766078f, -0.05567173f, 0.15876108f, 0.02908595f, 0.07895992f, -0.02404536f, 0.12865359f, 
    0.05933260f, 0.00012696f, -0.04341019f, -0.08302350f, 0.02614813f, -0.02254682f, -0.03076446f, 0.11663401f, 
    0.11622430f, 0.09959599f, 0.03707672f, 0.01325667f, 0.01140669f, -0.11547824f, -0.01120724f, -0.09494963f, 
    -0.01618576f, -0.02317641f, -0.08477526f, -0.03973106f, 0.07276729f, 0.37337372f, -0.79857343f, 0.26300988f, 
    -0.08067944f, 0.01677328f, 0.08865414f, 0.03803787f, -0.08008378f, -0.18938592f, 0.11924572f, -0.08314142f, 
    0.00089147f, -0.06187920f, -0.10227700f, -0.15411924f, 0.00264442f, -0.03245991f, -0.05711560f, -0.12798406f, 
    -0.14075147f, 0.49447203f, 0.50661159f, -0.08772075f, 0.13005324f, -0.03917355f, -0.39091063f, 0.05541485f, 
    -0.29028964f, -0.15740192f, -0.08840159f, 0.09652101f, -0.15863258f, 0.05657263f, 0.20179124f, -0.06836602f, 
    -0.12864552f, -0.08945929f, -0.08903626f, 0.06762192f, 0.04676070f, 0.06524454f, -0.06110001f, -0.33397010f, 
    0.11050577f, -0.05006346f, 0.08705008f, -0.00515318f, 0.00801602f, -0.12708612f, -0.03238640f, 0.07671896f, 
    -0.03286284f, 0.11922784f, 0.04886417f, 0.09396502f, -0.00593474f, 0.09215335f, -0.05962123f, -0.00281516f, 
    0.54176426f, 0.07000977f, 0.14483431f, -0.08715245f, 0.08604532f, -0.09952515f, 0.02378734f, -0.35312942f, 
    0.10734896f, 0.01719597f, 0.12804271f, 0.03886955f, 0.02647969f, 0.03754960f, -0.00307117f, 0.08346526f, 
    -0.07277235f, 0.11416996f, -0.02285585f, 0.09339369f, -0.05583265f, 0.06223543f, -0.13923037f, -0.02995639f, 
    -0.17002639f, -0.06838150f, 0.01483180f, -0.15896781f, 0.20481211f, 0.01311343f, 0.03052008f, -0.02813817f, 
    -0.08265907f, -0.02124808f, 0.00723618f, 0.05410888f, 0.14158778f, -0.01267897f, 0.02747227f, 0.01953988f, 
    -0.05853190f, 0.18459117f, -0.01301757f, -0.08859960f, -0.09012896f, -0.06243076f, -0.12436535f, -0.07334850f, 
    0.20514365f, 0.02746658f, -0.34351820f, -0.01499142f, 0.12396505f, -0.02967720f, 0.15159655f, 0.10451628f, 
    -0.19290553f, -0.01510066f, -0.05702927f, -0.15866964f, 0.17766714f, -0.19377017f, -0.41873500f, 0.01371875f, 
    -0.06108924f, 0.01362463f, -0.00702084f, 0.23262405f, 0.10241719f, 0.19338602f, 0.03704384f, -0.13063735f, 
    0.12242620f, -0.02386484f, 0.07145104f, 0.10581362f, 0.12764107f, 0.22384793f, 0.01040429f, 0.17805877f, 
    0.00344926f, -0.32472110f, -0.22665666f, -0.09522719f, 0.03368098f, 0.02170989f, 0.16133101f, 0.05588577f, 
    0.07586536f, 0.17786328f, -0.03467526f, -0.08370093f, -0.07064310f, -0.03223448f, 0.06993040f, 0.05022188f, 
    -0.05236048f, 0.26437294f, -0.02255242f, -0.01039125f, -0.42443982f, -0.20430343f, 0.15519418f, -0.17653893f, 
    0.03766558f, 0.05410176f, -0.06869232f, 0.03928176f, 0.10332970f, 0.05002747f, -0.06613389f, -0.14213203f, 
    0.10025816f, -0.02884800f, -0.04380186f, 0.12787272f, 0.22334805f, 0.01820545f, 0.04350213f, 0.04111826f, 
    -0.16145737f, 0.14918172f, -0.12530732f, -0.06058061f, 0.02665208f, -0.03874778f, 0.00694158f, -0.03958187f, 
    0.01471684f, 0.00192208f, -0.09171053f, 0.06985433f, 0.00450631f, 0.00452558f, 0.01104488f, 0.14236332f, 
    0.04240926f, -0.06324909f, 0.17102355f, 0.08499631f, 0.22767688f, -0.03734246f, -0.15723841f, -0.24561971f, 
    -0.23219891f, 0.08887289f, 0.04958073f, 0.19621021f, 0.26121554f, 0.11619679f, -0.11009036f, 0.05311670f, 
    0.00480575f, 0.02799105f, -0.06158433f, 0.00220196f, 0.04301406f, 0.04249426f, 0.08956191f, 0.17340964f, 
    -0.17039128f, 0.31924331f, 0.05389647f, 0.06824092f, 0.07326060f, 0.00312200f, 0.06300382f, -0.10063640f, 
    -0.01814904f, 0.07842065f, -0.09255622f, 0.08957719f, -0.09129202f, 0.07731057f, 0.17009965f, 0.07415161f, 
    0.00324161f, 0.03843948f, -0.16878794f, -0.12336588f, 0.00902952f, -0.02363441f, 0.35359251f, 0.01500309f, 
    0.08390104f, -0.04086882f, 0.05457689f, -0.10348976f, -0.04710339f, 0.01766686f, -0.05330469f, -0.05728879f, 
    -0.09964959f, -0.00470523f, 0.01576818f, 0.15936689f, -0.04081915f, -0.04858840f, -0.05906042f, 0.01194271f, 
    0.00884765f, 0.20893180f, 0.03466451f, 0.16023776f, 0.08618843f, 0.03320930f, 0.04559864f, 0.05170032f, 
    0.00236713f, 0.11592802f, -0.03807160f, -0.03153504f, -0.11841676f, -0.13872685f, 0.07443710f, 0.17251925f, 
    -0.00638377f, -0.15916243f, 0.03153374f, -0.16692495f, -0.04381181f, 0.21320593f, 0.12112246f, 0.20162936f, 
    0.09151106f, 0.15293433f, -0.02133713f, 0.04187248f, 0.15933867f, 0.13164762f, -0.02996816f, 0.07508615f, 
    0.01940420f, -0.11800280f, 0.04252450f, -0.00799431f, -0.13769370f, -0.05427910f, -0.12702930f, -0.07786487f, 
    -0.37123662f, 0.18939316f, -0.05155023f, 0.22201799f, -0.03631705f, -0.09239114f, 0.03441463f, -0.08204272f, 
    0.06381528f, 0.29452693f, -0.06474227f, 0.02247277f, 0.05682874f, 0.01802943f, -0.00503695f, -0.02508093f, 
    -0.07621700f, -0.12076487f, 0.01262021f, -0.01144661f, -0.42813823f, -0.04007553f, 0.41554874f, 0.10748502f, 
    -0.13578591f, 0.04588675f, 0.04114417f, -0.05670375f, 0.00756071f, 0.06216928f, -0.04151100f, -0.08791512f, 
    -0.03760547f, 0.07793729f, -0.00023872f, 0.02294633f, 0.03371916f, 0.14731809f, 0.00613719f, 0.03222952f, 
    0.25329745f, -0.15708430f, -0.19580649f, 0.00080519f, -0.13880830f, -0.06404094f, -0.06932778f, 0.04814699f, 
    0.02422580f, 0.08064722f, 0.04062256f, -0.04903658f, -0.02782937f, -0.03831822f, -0.09998451f, -0.11401476f, 
    0.06510334f, 0.02520506f, 0.17444357f, -0.11908951f, 0.31074214f, 0.10351626f, 0.23921478f, 0.14600272f, 
    0.00552789f, -0.06986946f, -0.16580668f, -0.08252858f, -0.09343525f, -0.17086647f, 0.06472090f, 0.15121536f, 
    -0.05366987f, 0.00141570f, 0.04597688f, -0.14102863f, -0.11608906f, -0.00800719f, -0.01568101f, -0.12082012f, 
    0.53557062f, 0.54156101f, 0.02463413f, 0.33643240f, 0.35924381f, 0.11647335f, 0.38046390f, -0.08897447f, 
    0.22555202f, -0.17536077f, -0.16254012f, 0.00782529f, -0.07696544f, -0.16964561f, 0.06638947f, 0.05092498f, 
    0.04600376f, -0.05691214f, 0.11458007f, -0.00706226f, 0.14038356f, 0.34807935f, 0.02310986f, -0.01140166f, 
    0.42404351f, 0.10755820f, -0.05704935f, -0.16655532f, 0.18784079f, 0.03044148f, -0.01644279f, 0.01133074f, 
    -0.04423138f, -0.01530979f, 0.05835485f, 0.03906455f, 0.03167234f, 0.04301204f, -0.07593382f, 0.04661903f, 
    -0.02982270f, -0.18693675f, -0.31830806f, 0.50237459f, 0.34700656f, 0.06493731f, 0.17919394f, -0.03580198f, 
    -0.16760826f, 0.06228223f, -0.03539180f, -0.04041603f, 0.06342348f, 0.06752481f, -0.01588188f, -0.03159852f, 
    -0.03819516f, -0.06740686f, -0.18569081f, 0.18358777f, -0.33214730f, 0.02417018f, 0.02309590f, 0.09078173f, 
    0.06118062f, 0.01370441f, 0.25306118f, 0.07914383f, -0.00077599f, -0.00084084f, -0.03891530f, 0.11782927f, 
    -0.03069345f, 0.03382126f, 0.02430504f, -0.03367113f, -0.02307697f, 0.05259884f, -0.04363506f, -0.09290445f, 
    -0.23060468f, -0.13408063f, -0.39662802f, 0.36339587f, 0.02892479f, -0.00381401f, 0.05623002f, 0.08992093f, 
    -0.06683823f, 0.12864383f, -0.09969677f, 0.05732781f, -0.06376746f, 0.02829110f, 0.05484983f, 0.00366299f, 
    0.07811415f, 0.06999423f, -0.18062446f, -0.04007428f, -0.10955803f, 0.27984396f, 0.19948184f, -0.01211494f, 
    0.06491765f, -0.04481676f, -0.19675680f, 0.00267076f, -0.11419421f, 0.22584258f, -0.02764981f, 0.00988559f, 
    -0.05587078f, -0.02691509f, -0.12531449f, 0.05002031f, -0.03060531f, -0.07143772f, 0.07708212f, 0.05413898f, 
    -0.03822126f, -0.02034139f, -0.00872874f, -0.06014992f, -0.02334091f, -0.05008696f, -0.04904460f, -0.02320242f, 
    0.00454756f, -0.02507299f, -0.01771182f, 0.02032258f, 0.00071617f, -0.05173684f, -0.05902060f, 0.02731565f, 
    -0.03056592f, 0.00010692f, -0.04760299f, -0.03150026f, -0.05987704f, -0.04642488f, 0.04735968f, -0.02192208f, 
    -0.00794835f, -0.04831384f, -0.03532710f, -0.04334936f, -0.03856417f, -0.02462943f, 0.04256986f, -0.02884810f, 
    -0.03533036f, -0.04580094f, -0.04875259f, 0.04481005f, -0.05916330f, 0.01069172f, -0.02591861f, 0.01703096f, 
    -0.06168241f, -0.04245478f, -0.02283164f, -0.04939179f, -0.05208961f, -0.05607663f, 0.04835015f, -0.05123809f, 
    -0.05887110f, 0.02765197f, -0.02025542f, -0.02227217f, -0.01284683f, 0.01382478f, -0.01661725f, -0.01294624f, 
    0.03735083f, 0.01398068f, 0.04411241f, -0.00480299f, -0.04614599f, 0.02885871f, -0.06221731f, -0.01429945f, 
    -0.00883778f, -0.04480069f, -0.01871001f, -0.02700356f, 0.02200344f, 0.00834605f, -0.00553278f, 0.03683709f, 
    -0.02763580f, -0.01528294f, 0.00090068f, -0.02155059f, 0.01942545f, 0.00647263f, 0.04843836f, -0.00342972f, 
    0.02036057f, 0.00635794f, 0.00224257f, 0.04146511f, 0.04247314f, 0.01674866f, 0.04490953f, 0.01146937f, 
    -0.01360371f, -0.00992494f, 0.03805580f, 0.02409437f, 0.01224793f, -0.02703485f, -0.05747172f, 0.03266878f, 
    0.03671076f, -0.03808826f, 0.04263421f, -0.04762219f, 0.03585894f, -0.00640432f, 0.04787906f, 0.02477822f, 
    0.02983135f, 0.02710236f, 0.03310892f, -0.01651582f, -0.04311898f, 0.00539471f, -0.02030044f, 0.02728748f, 
    0.03092903f, -0.01738990f, -0.01135238f, -0.02530041f, -0.04075574f, 0.02943330f, 0.01661788f, 0.02529675f, 
    -0.00844423f, -0.04501437f, -0.01906810f, -0.01965600f, 0.03952413f, -0.05143730f, 0.04650482f, -0.02811953f, 
    0.00707305f, -0.03112552f, -0.02950195f, -0.03130087f, 0.03770645f, 0.01049371f, 0.01329322f, 0.00819468f, 
    -0.01605050f, -0.00036127f, -0.02360794f, 0.00551612f, 0.02617537f, -0.03624412f, 0.02052535f, -0.01066563f, 
    0.02512373f, 0.04457523f, -0.05837355f, 0.00815049f, -0.00291970f, -0.02059061f, -0.02692872f, -0.01669946f, 
    0.02661281f, 0.00058191f, 0.03143958f, -0.05588595f, 0.01143782f, 0.03350274f, -0.04181839f, 0.02736059f, 
    -0.02088730f, -0.05117571f, 0.02055985f, 0.00098812f, 0.01402111f, -0.03165053f, -0.03150754f, 0.02891046f, 
    0.04579499f, -0.05058871f, 0.01957701f, 0.03439089f, -0.02006773f, -0.06024181f, -0.00032651f, -0.00863078f, 
    -0.02598036f, 0.02360288f, 0.01928299f, -0.01746560f, -0.04660136f, 0.03011123f, -0.02604109f, 0.02071959f, 
    -0.04776562f, 0.04924696f, 0.01923229f, -0.04422560f, -0.06257995f, 0.01017464f, -0.03459776f, 0.02591056f, 
    -0.01277679f, -0.02626315f, -0.05804655f, 0.00522456f, -0.01320286f, 0.03524466f, -0.03878322f, 0.02184592f, 
    0.02927914f, -0.00833733f, -0.00541534f, -0.02003721f, 0.03684505f, -0.02127276f, 0.04571120f, -0.03315812f, 
    -0.00739655f, 0.01022595f, -0.06099993f, 0.00948960f, -0.02870281f, -0.00987611f, -0.02170691f, 0.00344942f, 
    0.00300780f, 0.02145856f, -0.01643922f, -0.00224319f, -0.04563792f, -0.05182699f, 0.00078020f, 0.00559511f, 
    0.02019967f, -0.01514907f, -0.05446044f, -0.04442678f, 0.03993512f, 0.04380047f, -0.00670239f, 0.04142988f, 
    -0.01505356f, -0.01129999f, -0.05956573f, -0.00964653f, -0.01771331f, -0.02512506f, -0.04171550f, -0.04020006f, 
    0.04195348f, -0.03852887f, -0.02316589f, 0.02152336f, -0.05652854f, 0.00382093f, -0.00924395f, -0.02531722f, 
    -0.04879417f, 0.02723426f, -0.03789588f, 0.00289141f, -0.03458282f, -0.05807420f, -0.05980580f, 0.03189739f, 
    -0.03248202f, 0.01020903f, -0.00402954f, -0.00376913f, 0.00609813f, -0.02967240f, -0.00987678f, -0.00442687f, 
    -0.03946301f, 0.02476913f, -0.02700073f, 0.01199383f, 0.04533869f, -0.01658708f, -0.00923933f, -0.04928001f, 
    -0.04184896f, -0.01601813f, -0.01981620f, -0.02020791f, 0.00669338f, 0.00928222f, -0.04273007f, -0.02700354f, 
    -0.02854963f, -0.02109213f, 0.04769262f, 0.00864994f, 0.01432108f, -0.03733000f, -0.02797335f, -0.01915350f, 
    -0.02125109f, 0.02874729f, 0.04866995f, -0.01277970f, 0.00442342f, -0.00423639f, 0.00559049f, 0.01653641f, 
    0.03656505f, -0.01103803f, -0.06310495f, 0.03636065f, -0.00748996f, 0.01537236f, -0.06204525f, -0.03705570f, 
    0.00927362f, -0.04996727f, -0.05809858f, 0.00448348f, 0.02942298f, 0.02786828f, -0.04596407f, 0.00402181f, 
    0.03906138f, -0.00342767f, 0.01050183f, -0.00931455f, -0.00830553f, -0.00488339f, -0.00553913f, -0.04810873f, 
    -0.14129195f, -0.01748979f, 0.27452385f, -0.01814751f, 0.21485157f, 0.07336034f, 0.19641851f, -0.01921361f, 
    0.04019543f, -0.04904855f, 0.19276544f, 0.17832634f, 0.03366303f, 0.02566963f, -0.01459404f, -0.00243903f, 
    -0.05064728f, 0.07580501f, -0.04757354f, -0.06043144f, -0.06405091f, -0.39468855f, -0.06243420f, -0.03783710f, 
    -0.09745999f, 0.16333868f, 0.07525653f, 0.06751017f, -0.02141578f, 0.11271618f, 0.12826531f, 0.06286765f, 
    0.13990597f, 0.08190306f, -0.06547315f, 0.04006826f, -0.09892818f, -0.00013754f, -0.06866708f, -0.14058138f, 
    -0.56527203f, 0.24707890f, -0.10392172f, -0.09227543f, -0.08662792f, 0.17139308f, 0.15557131f, -0.02781474f, 
    -0.01900641f, 0.02653351f, -0.03206444f, 0.14676139f, -0.06876596f, 0.05145396f, 0.00593550f, 0.00415026f, 
    -0.01215998f, 0.26874679f, 0.12368146f, 0.09610379f, 0.29046255f, 0.24649231f, 0.12326302f, 0.04551294f, 
    -0.10393657f, -0.19383724f, 0.06130433f, 0.16283283f, 0.08993340f, 0.05927373f, 0.00657282f, 0.03386449f, 
    0.04646152f, 0.07073776f, -0.06954035f, -0.05119267f, -0.03450187f, -0.10651463f, -0.00410855f, -0.11156528f, 
    -0.14558204f, -0.87786007f, -0.89916158f, -0.69682539f, -0.06140964f, 0.08535387f, 0.09681717f, -0.07156071f, 
    0.15039176f, 0.04160475f, -0.12116995f, 0.09482010f, -0.01533572f, -0.06908957f, -0.02369280f, -0.07086348f, 
    0.03759363f, -0.18476294f, 0.20112503f, 0.06550927f, -0.11388092f, -0.09743791f, -0.19621330f, 0.12209830f, 
    0.06848355f, 0.12292782f, 0.11700418f, 0.03931995f, -0.02739582f, 0.22182269f, -0.06822670f, 0.01379992f, 
    -0.00265632f, -0.03146085f, -0.22446828f, 0.07525288f, -0.09057078f, 0.07306647f, 0.31998500f, -0.03071082f, 
    -0.82605773f, -0.40704852f, -0.02278798f, 0.18828508f, 0.32624775f, 0.02982322f, 0.27306965f, -0.06487737f, 
    0.01147531f, 0.07509506f, 0.12441363f, -0.02015408f, -0.03806168f, 0.04674491f, -0.01578097f, -0.08171526f, 
    0.11492911f, -0.08252069f, -0.01609397f, -0.03927426f, -0.22460270f, -0.32626367f, -0.16104008f, 0.02988444f, 
    -0.13766728f, -0.04479384f, 0.05332159f, 0.22917461f, 0.03767037f, 0.20393203f, 0.02004438f, 0.00483379f, 
    -0.06179559f, 0.03363338f, 0.06687383f, 0.08495273f, 0.15046510f, -0.02329486f, 0.08310968f, -0.07120390f, 
    0.30055737f, -0.15531552f, -0.06149688f, -0.19493334f, -0.19309394f, 0.08761118f, -0.02880453f, 0.14161438f, 
    0.12012517f, 0.12667975f, 0.01305272f, 0.09904088f, 0.05669075f, -0.11095871f, -0.17374448f, -0.00791760f, 
    0.01670561f, 0.04678278f, 0.05325848f, -0.05943606f, 0.46878219f, 0.34766969f, 0.36564380f, 0.08667962f, 
    -0.09126335f, 0.02035179f, -0.00577373f, 0.02838417f, 0.02909929f, -0.01980474f, 0.21829975f, -0.00997204f, 
    -0.11387165f, -0.12499228f, -0.00254826f, -0.06385231f, -0.08172446f, -0.18652159f, 0.06440527f, 0.01769944f, 
    0.49811020f, -0.66165310f, -0.09333671f, -0.50876802f, -0.25543788f, 0.01125542f, -0.00599787f, -0.33724475f, 
    0.15514140f, 0.04749919f, 0.04676454f, 0.07198533f, 0.01334181f, 0.00858823f, -0.03659584f, -0.12636934f, 
    0.06474872f, -0.00305190f, 0.15389541f, 0.08273286f, 0.36260861f, -0.36010215f, -0.12119035f, -0.71872121f, 
    -0.04427074f, -0.05185347f, -0.00782753f, -0.26550490f, 0.14734992f, 0.06344166f, -0.05627131f, 0.05149716f, 
    -0.00494179f, -0.02374135f, 0.03992139f, -0.07323770f, 0.00172052f, 0.07363512f, 0.18278326f, 0.00883652f, 
    -0.34814835f, -0.49413162f, -0.59090245f, -0.26043022f, -0.34034815f, -0.01745789f, 0.23899285f, -0.08883535f, 
    0.01893299f, 0.03623710f, -0.01452093f, 0.00270129f, -0.02468650f, -0.00053178f, -0.04488043f, -0.00382894f, 
    0.00749909f, 0.04498854f, -0.18173350f, -0.02657496f, -0.39135578f, -0.05345925f, -0.50864029f, -0.12234429f, 
    0.11885467f, 0.11431696f, 0.12423448f, -0.02399480f, 0.10620974f, 0.02693092f, 0.02984734f, -0.12755287f, 
    -0.15138794f, 0.03349366f, 0.11537720f, -0.11983678f, -0.11596043f, 0.06678991f, 0.08399382f, 0.00010432f, 
    -0.28405112f, -0.22522065f, -0.54753006f, 0.17459206f, -0.05698859f, 0.13146231f, 0.24135964f, -0.28877798f, 
    -0.07204358f, 0.12271278f, -0.00574484f, -0.08241126f, -0.06971221f, -0.02211967f, 0.02999700f, -0.24036032f, 
    0.06729277f, -0.05886880f, 0.11166142f, -0.15068690f, 0.30309677f, 0.69252086f, 0.19022287f, -0.09143922f, 
    -0.02056732f, -0.03257702f, -0.00495294f, -0.12397343f, 0.11249851f, -0.18768641f, 0.07947315f, 0.05191007f, 
    0.09123843f, 0.12461600f, -0.02984209f, -0.00128755f, -0.03680992f, 0.11724915f, -0.08887060f, -0.03100845f, 
    -0.24313655f, -0.17142178f, -0.15560406f, -0.39583272f, -0.01364300f, -0.04931125f, -0.13320330f, 0.18267022f, 
    -0.09113449f, -0.18500443f, 0.06124594f, 0.10471206f, 0.02840233f, -0.05682248f, 0.04971384f, -0.05965938f, 
    -0.16888873f, -0.08155898f, -0.05395213f, -0.27523804f, 0.10073321f, 0.61226481f, -0.10674772f, 0.07598303f, 
    0.05797450f, 0.03413297f, 0.02839364f, 0.13697794f, -0.01250189f, -0.03133792f, 0.02163719f, 0.10028613f, 
    -0.01947135f, 0.08603694f, -0.16364987f, 0.06403274f, -0.21077730f, -0.10299136f, -0.13908175f, -0.06360357f, 
    0.08088443f, 0.30132237f, 0.09363207f, -0.03648276f, 0.03401821f, -0.07718346f, -0.14131977f, 0.14360102f, 
    -0.02868937f, -0.18427785f, 0.01404294f, 0.03811214f, -0.04472497f, -0.08018487f, -0.02988359f, -0.00348985f, 
    -0.01718698f, -0.08241995f, -0.05983518f, -0.10202211f, -0.01396381f, 0.01847656f, 0.07493418f, -0.19215076f, 
    0.13239338f, -0.15057701f, 0.04774315f, -0.13390268f, 0.01418380f, 0.02317228f, 0.03549918f, -0.02384850f, 
    -0.02347421f, -0.07936021f, -0.01541079f, -0.01377432f, 0.17726867f, -0.05771492f, 0.02352398f, 0.04802216f, 
    0.23024985f, -0.01486646f, 0.18884788f, 0.15055822f, 0.13127410f, 0.18409109f, 0.20059232f, 0.16807729f, 
    -0.02061235f, 0.00218334f, 0.06768428f, -0.12082780f, 0.08058230f, 0.08579326f, 0.14040691f, -0.01010964f, 
    0.13218349f, 0.00019298f, 0.03666153f, 0.00905068f, 0.30165738f, 0.23667629f, -0.05335118f, 0.01985476f, 
    0.31136191f, 0.08476318f, -0.00213242f, 0.08789676f, 0.01291735f, 0.11493323f, 0.24378538f, -0.00136463f, 
    0.06489632f, 0.11364029f, -0.11549268f, -0.13583259f, -0.01222521f, 0.12496223f, -0.02982510f, 0.11528066f, 
    0.12936503f, 0.22917393f, 0.08200247f, -0.12062820f, 0.17309457f, -0.16637613f, -0.08995822f, 0.03135071f, 
    -0.16542731f, -0.02474192f, 0.12337694f, -0.10236546f, 0.05624319f, -0.00362755f, 0.02209989f, -0.04634904f, 
    -0.09019893f, 0.07218259f, -0.00233055f, -0.15998000f, -0.10775131f, 0.13978221f, 0.34616730f, -0.40473747f, 
    0.22948338f, -0.10588700f, 0.07584123f, -0.18124902f, 0.13139522f, -0.18730858f, 0.03577311f, 0.13426182f, 
    0.01097860f, 0.00832605f, -0.09080631f, -0.08437859f, 0.21202599f, -0.14031354f, -0.05685904f, -0.07306024f, 
    -0.05999888f, -0.19893098f, -0.40198562f, 0.32746226f, -0.03062009f, -0.09439643f, -0.03145062f, 0.08401207f, 
    -0.19916995f, -0.12124825f, -0.12287482f, -0.08754501f, -0.07586770f, 0.04263457f, 0.04959815f, 0.01207463f, 
    0.04733786f, -0.02894496f, -0.22327200f, -0.20225999f, -0.03276033f, -0.22988912f, -0.60471463f, -0.69985271f, 
    -0.43425912f, 0.01865370f, 0.01512116f, 0.34425491f, 0.13479182f, 0.04103097f, -0.05083728f, 0.05644873f, 
    -0.06771442f, 0.04953378f, -0.09646402f, 0.06917197f, -0.07616892f, -0.00062213f, -0.19319721f, -0.22230417f, 
    0.32238194f, 0.24004865f, 0.23073873f, -0.16119674f, 0.28336138f, 0.07402796f, 0.20506020f, 0.12903328f, 
    0.13699511f, -0.00404729f, 0.06550662f, 0.07680121f, 0.06904641f, -0.01926225f, 0.12358997f, 0.06094453f, 
    0.16192244f, 0.04292538f, -0.03783531f, -0.04288691f, 0.39162803f, 0.18426602f, 0.11468080f, -0.21947354f, 
    0.25104699f, 0.10741714f, -0.00446498f, 0.13559796f, 0.08328263f, 0.05469125f, 0.11948439f, 0.00515512f, 
    0.00588135f, 0.08277398f, -0.10925244f, 0.06982382f, -0.03015680f, 0.02976474f, -0.08505040f, 0.01240951f, 
    0.26739666f, 0.32702759f, 0.13670354f, 0.10536381f, 0.30566052f, 0.05008924f, 0.04169014f, 0.08863401f, 
    -0.00270533f, -0.04052749f, -0.00271108f, 0.11122634f, 0.20167448f, 0.13474086f, 0.06657062f, 0.07877430f, 
    -0.04337184f, -0.09429479f, -0.01047212f, -0.10923741f, -0.00117181f, 0.15358424f, 0.18538143f, -0.02495908f, 
    -0.01123823f, -0.02440837f, -0.06133475f, -0.03720083f, 0.05527119f, 0.00024291f, -0.02532102f, -0.12747857f, 
    0.00371960f, -0.07650708f, 0.04642279f, -0.17268616f, -0.03038219f, 0.17815687f, -0.18832792f, 0.05238451f, 
    0.06847744f, 0.27801412f, 0.38823858f, 0.10463045f, 0.18640390f, 0.00534264f, 0.08568485f, 0.02728520f, 
    0.00438472f, 0.17351827f, -0.01504188f, 0.05243387f, 0.06618417f, 0.06953818f, 0.14067842f, 0.02252388f, 
    0.02075903f, 0.09960410f, -0.09285250f, 0.07744139f, -0.00356197f, -0.12914091f, -0.30279854f, -0.04765093f, 
    -0.23935176f, -0.14557140f, -0.29372317f, -0.16062164f, -0.14360861f, 0.16624647f, -0.07619593f, -0.07296606f, 
    -0.08754217f, -0.02498583f, -0.02334202f, 0.01824226f, -0.08947126f, 0.00447967f, 0.12171277f, 0.17612523f, 
    -0.18037121f, 0.01042128f, -0.29027858f, -0.28688675f, 0.03458454f, 0.11142240f, 0.06095742f, -0.01325259f, 
    -0.04483770f, 0.09118275f, -0.05488952f, -0.07298629f, 0.04069194f, -0.03512543f, -0.03672414f, 0.10754348f, 
    -0.10106435f, -0.01438410f, -0.01893077f, -0.09705640f, 0.56340390f, 0.28319973f, 0.13414748f, 0.01952928f, 
    0.05457261f, 0.23949653f, 0.07532101f, 0.04963989f, 0.13576232f, 0.15548974f, -0.06605002f, 0.00219896f, 
    0.11901758f, 0.11273881f, 0.07040649f, 0.07820980f, -0.18187188f, -0.02483738f, -0.25764784f, -0.04328775f, 
    -0.23443621f, 0.01744038f, -0.10883278f, 0.02891426f, -0.14598703f, -0.04682784f, 0.03472282f, -0.00505007f, 
    -0.03717885f, 0.06097567f, 0.07810766f, -0.05520115f, -0.01983954f, 0.04087800f, 0.18034889f, 0.01818453f, 
    0.01936859f, -0.04387597f, -0.02970239f, 0.08492877f, -0.17270519f, -0.06440719f, -0.11607587f, 0.26651791f, 
    -0.19263393f, 0.08222827f, 0.07649572f, -0.12803577f, 0.04607859f, 0.08630951f, 0.01849823f, 0.01294476f, 
    -0.07152810f, 0.09653064f, -0.06680305f, 0.08380039f, -0.01758975f, -0.04624580f, -0.07977752f, 0.17141525f, 
    -0.02529870f, 0.03642631f, 0.39268667f, 0.30686226f, 0.08934277f, -0.07122298f, 0.02580819f, -0.19400004f, 
    -0.14204800f, -0.02827808f, -0.08938696f, 0.10603144f, 0.08707040f, 0.00039313f, 0.12454893f, -0.05609384f, 
    0.01778604f, -0.04473453f, -0.02905267f, -0.00096280f, -0.09019542f, -0.28361589f, 0.31104037f, 0.26453480f, 
    -0.26729318f, -0.09747058f, 0.10207185f, -0.16130321f, 0.05917661f, 0.01533141f, -0.02741058f, -0.01681724f, 
    0.00657566f, -0.12983908f, -0.05261795f, 0.00460263f, 0.03716183f, 0.13315558f, -0.15565455f, 0.14828824f, 
    -0.04716802f, 0.26319668f, 0.47201538f, 0.28426823f, 0.14704451f, 0.10144147f, 0.31511641f, 0.09957886f, 
    0.06368872f, 0.17916623f, 0.06606743f, 0.10258290f, -0.00660037f, -0.03885012f, -0.06637617f, -0.07359129f, 
    -0.07236575f, -0.20089623f, 0.04441087f, 0.07517353f, -0.73496920f, -0.09490260f, -0.12469655f, 0.35787097f, 
    -0.21067530f, -0.06340875f, -0.02491582f, -0.21434982f, 0.03463047f, 0.32404283f, 0.02508615f, 0.04427163f, 
    -0.04343468f, -0.04104285f, -0.05900972f, -0.01600840f, -0.11816995f, 0.11162939f, -0.16640779f, -0.03744891f, 
    0.07157584f, -0.15169920f, 0.19991592f, -0.02822622f, 0.05128336f, 0.01250709f, -0.08737765f, 0.02233878f, 
    -0.06880888f, -0.04902113f, 0.10815471f, -0.00956304f, -0.02597667f, -0.03432892f, -0.04475169f, -0.07560320f, 
    -0.02178199f, -0.14602539f, -0.08289064f, -0.12309794f, 0.06458701f, -0.23319831f, -0.49487063f, -0.22525296f, 
    0.05930671f, 0.07615973f, -0.09736518f, -0.13751090f, 0.03169421f, -0.03510106f, 0.09696524f, 0.12366404f, 
    0.00799022f, -0.04408774f, 0.04096149f, 0.09223514f, 0.04078202f, 0.21006303f, 0.15165699f, -0.00995730f, 
    0.01313745f, -0.09336045f, 0.38083836f, 0.37459767f, 0.22903907f, 0.18515679f, 0.06010917f, -0.11493196f, 
    0.00605611f, -0.20331384f, -0.11693373f, 0.12176982f, -0.06506656f, 0.12592927f, -0.01320366f, -0.04608004f, 
    -0.05500637f, -0.01838705f, 0.02249218f, -0.08847015f, -0.07273688f, -0.09430481f, 0.21985096f, 0.28593192f, 
    0.17270912f, -0.06576321f, -0.05916633f, -0.14779505f, -0.04325804f, -0.04755942f, -0.05826778f, 0.05462331f, 
    -0.06160958f, -0.00588499f, 0.03766796f, 0.07708225f, 0.08454551f, 0.20397691f, -0.11505120f, 0.13970129f, 
    0.32090405f, 0.21346824f, 0.27154478f, 0.57663822f, 0.36686271f, -0.00888986f, 0.06614604f, 0.13455461f, 
    -0.05836143f, 0.04924497f, 0.09732118f, 0.08655068f, 0.14524169f, -0.01414477f, 0.04801854f, -0.01988104f, 
    -0.01692706f, -0.20908250f, 0.03025876f, 0.07810339f, -0.09209033f, -0.05090505f, 0.01136617f, 0.24724697f, 
    -0.02051721f, -0.12382282f, 0.07677193f, 0.04285301f, -0.09859017f, -0.01598820f, 0.06180093f, 0.07169563f, 
    0.04161036f, 0.08373842f, 0.00722944f, 0.03777039f, 0.14279221f, -0.05637902f, -0.04396792f, 0.18488066f, 
    -0.08504792f, -0.12582606f, 0.10427094f, 0.52236432f, 0.02943127f, -0.08588940f, 0.04278784f, 0.07488326f, 
    0.12026115f, 0.05396332f, -0.01671034f, 0.03128174f, 0.15196760f, 0.14832893f, 0.13146770f, 0.07901482f, 
    0.09609907f, -0.03742098f, -0.02023248f, 0.07601729f, -0.12127915f, 0.30593067f, 0.04009701f, -0.33045468f, 
    0.06730063f, 0.07308424f, -0.07182707f, -0.03873412f, -0.18189582f, 0.17546456f, 0.02101242f, 0.02706349f, 
    -0.05538373f, -0.02866706f, -0.16842833f, 0.03430191f, 0.12223407f, -0.04868209f, 0.10864343f, 0.04315035f, 
    0.11198727f, -0.13300283f, 0.25305977f, -0.22740838f, 0.07551006f, 0.19105275f, 0.07299493f, -0.04928351f, 
    0.16804141f, 0.05161145f, -0.01708426f, -0.05905596f, -0.01130487f, 0.06042653f, 0.02959829f, -0.25783283f, 
    -0.18675122f, -0.03921947f, -0.37513268f, -0.21221200f, -0.14444131f, 0.06277450f, 0.24875234f, 0.12753870f, 
    0.18181527f, -0.09046125f, -0.12195477f, -0.06215712f, -0.25569806f, 0.18295771f, 0.08372913f, 0.10493259f, 
    -0.05207376f, 0.02167704f, -0.02432239f, -0.06128246f, -0.24372892f, -0.18167053f, -0.07969109f, -0.30731720f, 
    -0.02298452f, 0.06386197f, -0.07318801f, -0.19595283f, 0.04004915f, -0.18573013f, 0.00627951f, 0.09685460f, 
    0.07183611f, -0.07442181f, 0.14489298f, 0.02025892f, 0.08542143f, -0.06321251f, 0.00981081f, 0.04113814f, 
    0.14479162f, 0.06803834f, -0.01197789f, 0.06360979f, 0.14286938f, -0.06861691f, -0.15414673f, 0.00982784f, 
    0.16088577f, 0.09221441f, 0.15289794f, 0.08783654f, 0.04758884f, -0.05167003f, 0.14388680f, -0.03185591f, 
    -0.09475246f, -0.00983683f, 0.17601237f, -0.11325633f, 0.15806910f, -0.02934886f, 0.09808765f, 0.14805202f, 
    -0.13348840f, 0.05654332f, 0.12792405f, 0.20643893f, 0.46435714f, -0.14516382f, 0.13905682f, 0.04233366f, 
    -0.01973558f, 0.02057134f, -0.03889110f, -0.07125614f, -0.09909578f, 0.19585410f, 0.06522144f, -0.12750264f, 
    0.12126511f, 0.23710944f, -0.00305836f, 0.04147340f, 0.05117187f, 0.35567266f, -0.15123005f, 0.16748574f, 
    0.38108018f, 0.06588828f, 0.22648871f, -0.08268483f, -0.15124118f, 0.01394544f, -0.14735757f, 0.04116815f, 
    -0.16995221f, 0.09138943f, -0.22247425f, -0.01443247f, 0.02731378f, 0.22670008f, -0.01281950f, 0.13590650f, 
    -0.03778505f, 0.00150438f, -0.08241354f, 0.08278967f, 0.27377227f, -0.05495428f, 0.05742482f, 0.07266411f, 
    0.05644423f, 0.01420395f, 0.13355279f, -0.01901582f, -0.17551047f, -0.15865877f, 0.05070026f, -0.09668516f, 
    -0.08291759f, 0.04127264f, -0.07155360f, -0.18350169f, 0.05882988f, -0.22559741f, -0.52716428f, -0.16298269f, 
    0.38353705f, -0.20199113f, 0.02048644f, 0.06877179f, 0.13631463f, 0.08217455f, -0.03673407f, -0.14570658f, 
    -0.03559370f, 0.01590417f, 0.14627180f, -0.14872453f, -0.14129654f, -0.09019931f, -0.00578483f, -0.34926084f, 
    -0.19677079f, 0.71792012f, 0.33734050f, -0.09830161f, 0.46886852f, -0.24405885f, -0.14717253f, 0.03331155f, 
    -0.12330876f, -0.17895946f, 0.05085041f, -0.09572332f, -0.13986127f, -0.07925829f, 0.07292548f, 0.07523149f, 
    -0.12525038f, -0.13714962f, -0.05265879f, -0.36073324f, -0.12986527f, 0.03332952f, -0.11344743f, -0.11504002f, 
    -0.10115427f, 0.10769531f, 0.03130970f, -0.01551185f, -0.00499293f, 0.24194312f, -0.02897734f, 0.12885939f, 
    -0.03644943f, -0.14008060f, 0.01740596f, 0.15670848f, 0.02767172f, 0.03697466f, -0.10113540f, 0.05105326f, 
    0.07342895f, -0.12616368f, 0.15665092f, 0.10930268f, 0.33224386f, 0.07047679f, -0.08799750f, -0.01158561f, 
    -0.09570750f, 0.02086663f, -0.11226624f, 0.06109369f, -0.11335766f, 0.07609046f, 0.01434506f, -0.05327039f, 
    0.17604893f, 0.22221768f, -0.00237992f, 0.09025334f, -0.24865963f, 0.03363141f, -0.09327550f, 0.01246431f, 
    0.11683419f, -0.07501667f, 0.13302138f, 0.04641553f, -0.06600819f, -0.05348397f, -0.22775385f, 0.12735641f, 
    -0.14922683f, 0.16490673f, -0.06436339f, 0.04113393f, 0.15960003f, 0.10556348f, 0.07804351f, 0.05463364f, 
    0.09319387f, 0.21297269f, 0.20240854f, 0.10089140f, 0.27358076f, -0.18437088f, -0.09680851f, -0.07708361f, 
    -0.00781449f, -0.00756798f, 0.15618564f, 0.15553081f, 0.03698803f, -0.10909525f, -0.04210535f, -0.01551701f, 
    -0.03770999f, -0.11610055f, 0.07356722f, -0.20261072f, 0.22889312f, -0.32089317f, -0.20016347f, 0.01058607f, 
    0.08051708f, -0.12205625f, -0.01534183f, -0.00267854f, 0.20007549f, 0.07466678f, 0.03623082f, -0.12707174f, 
    0.07353773f, 0.02710094f, 0.09275419f, 0.11736160f, 0.26465914f, 0.09400117f, -0.02096197f, 0.23209317f, 
    0.07545197f, -0.25728938f, -0.10187507f, -0.13676170f, 0.30238482f, -0.23632093f, 0.25965494f, 0.09403578f, 
    0.16123076f, 0.01747674f, 0.02528802f, -0.02962477f, -0.10082779f, 0.00867661f, 0.07748394f, 0.11199000f, 
    -0.03673587f, 0.07513154f, 0.17135574f, 0.00022322f, -0.28654087f, -0.07784026f, 0.08035620f, 0.22011198f, 
    -0.00942604f, -0.03037275f, 0.19898915f, -0.02914445f, -0.02145441f, -0.19609311f, -0.01324105f, -0.07057497f, 
    0.03695614f, 0.13411580f, -0.09317127f, 0.14396973f, 0.17288999f, 0.12330914f, 0.05444419f, 0.24876790f, 
    0.12784012f, 0.19155636f, -0.16040894f, -0.02658953f, -0.12163343f, 0.04318084f, -0.12568386f, 0.18149440f, 
    -0.07379973f, -0.02176977f, 0.05195610f, 0.11073747f, 0.01402114f, 0.04777770f, -0.02419811f, -0.03774208f, 
    -0.05457738f, -0.04913797f, -0.12273201f, -0.16155860f, -0.30770981f, -0.02582600f, -0.16983061f, 0.14076060f, 
    -0.01236004f, -0.18304507f, -0.03030257f, -0.12065003f, -0.11063249f, 0.15352519f, 0.03645869f, 0.11677666f, 
    -0.07706465f, -0.12609033f, -0.11688852f, -0.21697800f, -0.17481422f, -0.21171248f, -0.10671096f, -0.29123974f, 
    0.13550095f, 0.06728117f, 0.19008988f, 0.25135583f, 0.04558869f, 0.07551725f, 0.09152863f, 0.06428417f, 
    0.04413721f, 0.09579516f, -0.07372312f, 0.00712127f, 0.13931866f, -0.06475856f, 0.02396713f, 0.11950532f, 
    0.19282059f, 0.09608159f, 0.24187888f, 0.14766639f, 0.40401027f, 0.16617119f, 0.00467136f, -0.09702876f, 
    0.13674420f, 0.00955623f, -0.21601893f, 0.07295516f, 0.10039648f, 0.13819487f, -0.03106530f, -0.09299377f, 
    0.00907732f, -0.09471273f, -0.07554483f, 0.12050939f, 0.20565385f, 0.09946202f, 0.23569982f, 0.16519555f, 
    -0.05274944f, 0.07928898f, 0.32267657f, 0.20207477f, -0.02134617f, -0.05961267f, -0.01402304f, -0.00038137f, 
    0.03420868f, 0.02905235f, 0.08372056f, -0.11553436f, 0.06431524f, 0.08973192f, 0.09636085f, 0.10723366f, 
    0.00790919f, 0.11470583f, 0.01432834f, 0.07974584f, -0.13103940f, -0.31306079f, -0.18286970f, 0.09738263f, 
    0.04986429f, 0.10225210f, -0.07489941f, 0.00547772f, -0.08834381f, -0.09535733f, -0.10879932f, -0.12517725f, 
    0.03119203f, 0.12038162f, 0.01038889f, -0.04491342f, 0.12912300f, 0.03192610f, -0.03947146f, -0.01029137f, 
    0.00420982f, -0.11720210f, -0.06265778f, 0.15448810f, 0.03096452f, -0.00258808f, -0.13445805f, 0.07675362f, 
    -0.03311053f, 0.10358881f, 0.02029370f, -0.11348544f, -0.01635989f, 0.06943166f, 0.06300892f, 0.01975531f, 
    -0.02723719f, 0.21302888f, -0.01547299f, -0.04796196f, 0.42203203f, 0.22107737f, 0.07717506f, -0.13106516f, 
    0.31246588f, 0.19720288f, 0.12482022f, 0.01524101f, 0.03617195f, -0.05194427f, 0.05706590f, 0.01323501f, 
    0.01337412f, 0.07235079f, -0.01505123f, -0.01100098f, 0.03421415f, -0.12819982f, 0.06393821f, 0.09130900f, 
    0.23896597f, 0.03685909f, 0.09150623f, 0.15930963f, -0.07008390f, -0.04355377f, 0.21097964f, -0.00345995f, 
    0.06523610f, -0.00756592f, 0.14091767f, 0.07894398f, 0.13270485f, 0.03424961f, 0.18159853f, 0.05599958f, 
    0.01702524f, -0.03517136f, -0.13692588f, -0.05673657f, 0.14028396f, -0.00073040f, -0.10078837f, 0.12288407f, 
    0.01556386f, -0.06905017f, -0.05180074f, 0.07188462f, 0.00611932f, -0.03030651f, -0.09983917f, 0.18485706f, 
    0.22147506f, 0.20660576f, 0.10725862f, 0.07222571f, 0.14645663f, -0.06288861f, -0.16577594f, -0.15931347f, 
    -0.42807400f, -0.12736546f, 0.21101615f, 0.35326758f, -0.19202125f, 0.02111931f, -0.28877383f, 0.14351457f, 
    -0.09844606f, -0.01655706f, 0.07596772f, -0.17520805f, 0.06187651f, 0.12669186f, -0.15417543f, 0.09821980f, 
    0.03972910f, 0.04322091f, -0.02687541f, -0.10927873f, -0.06328268f, -0.11218037f, 0.06434617f, 0.43978089f, 
    0.10448710f, -0.03095635f, -0.00468550f, -0.00593890f, -0.10242955f, 0.05765012f, -0.08415721f, -0.05973138f, 
    0.20772855f, 0.03470658f, -0.06111806f, 0.03209294f, 0.13880651f, 0.10175643f, 0.03782075f, 0.01733505f, 
    -0.19123770f, -0.16956562f, 0.16230838f, 0.07732007f, -0.00641892f, -0.08642285f, -0.15800613f, 0.00021017f, 
    -0.05343975f, 0.07802057f, 0.05564063f, 0.05542048f, 0.01044288f, -0.13744360f, -0.02406235f, -0.12050369f, 
    -0.03820895f, -0.15635496f, -0.11779554f, -0.25217822f, 0.07383494f, -0.10034712f, 0.01948337f, -0.01965590f, 
    -0.00604801f, 0.14016612f, -0.03712045f, 0.03834010f, 0.08681871f, 0.18852754f, -0.03153068f, 0.03216252f, 
    0.05135773f, 0.01690097f, 0.03362896f, 0.13134810f, 0.14514799f, 0.17302445f, 0.27034307f, 0.01285038f, 
    -0.08534725f, -0.07530304f, 0.00653661f, -0.07651912f, 0.05136566f, -0.06757537f, -0.36204746f, -0.07209038f, 
    -0.04667128f, 0.11513156f, -0.11296447f, -0.07756250f, -0.07896394f, -0.03972082f, 0.02765439f, 0.08699820f, 
    -0.00111867f, 0.02854939f, -0.02560978f, 0.17605121f, 0.41309994f, 0.08078799f, -0.24691039f, 0.37657100f, 
    -0.10578787f, 0.14246640f, 0.07512004f, 0.02612228f, 0.19215831f, 0.12139205f, -0.10249578f, -0.03003170f, 
    -0.00152108f, 0.04502386f, 0.12141702f, 0.18593952f, 0.21342243f, 0.17123947f, 0.20626931f, 0.21523741f, 
    -0.26600984f, 0.18393603f, -0.25460553f, -0.02634048f, 0.05640376f, 0.05246643f, -0.17280294f, -0.08816861f, 
    0.16176550f, -0.09773836f, -0.17276248f, 0.07040530f, 0.08647361f, -0.12800628f, -0.05955704f, -0.02647189f, 
    -0.02242080f, -0.00665893f, 0.14906417f, 0.09490703f, 0.11976358f, -0.00376263f, 0.09110095f, -0.28258011f, 
    -0.01314171f, -0.09658201f, -0.02601308f, 0.08738901f, 0.13463794f, -0.02773195f, -0.22970021f, 0.02165107f, 
    0.00948806f, 0.05890603f, -0.10079031f, -0.04255025f, -0.03306630f, -0.04822230f, 0.14804666f, 0.06541742f, 
    0.01599947f, 0.39639741f, 0.09547670f, 0.23780648f, 0.13900362f, 0.03897230f, 0.13042229f, 0.07163019f, 
    0.00432274f, 0.08758855f, -0.04098281f, 0.04827817f, -0.04890463f, 0.06623329f, -0.02212311f, 0.16850409f, 
    -0.02091037f, 0.02334831f, -0.15204155f, -0.07001840f, -0.04237598f, -0.12964793f, 0.16123590f, -0.38299617f, 
    0.26652622f, 0.08855206f, 0.04308952f, -0.08090766f, -0.05122006f, 0.10191649f, 0.00318550f, 0.05238523f, 
    -0.00686782f, 0.05665293f, -0.02509450f, 0.15579163f, -0.07105022f, 0.02616179f, -0.01338333f, 0.00395146f, 
    0.06352095f, 0.23444481f, 0.16334943f, 0.25405374f, 0.31533617f, 0.07207778f, 0.07993374f, 0.21170895f, 
    0.05237709f, -0.03661887f, 0.10113911f, 0.00069670f, -0.04155354f, 0.05279402f, -0.04709545f, 0.04420709f, 
    -0.00455206f, -0.04355939f, -0.07274285f, -0.10444840f, 0.14669865f, 0.46691859f, -0.30386859f, -0.15941238f, 
    0.30258095f, 0.01527332f, -0.05904486f, -0.08388413f, 0.08518596f, 0.13834463f, -0.03746295f, -0.06387722f, 
    0.00693280f, -0.09589405f, -0.02626691f, -0.06150194f, -0.19859985f, -0.02143952f, -0.14387001f, -0.06381693f, 
    -0.23730616f, 0.01584801f, -0.38615677f, -0.04661246f, -0.06926250f, -0.06102715f, -0.00950442f, -0.08550920f, 
    0.04786687f, -0.04475272f, -0.00140730f, -0.02794576f, 0.10286553f, 0.06168591f, 0.03539067f, 0.02121377f, 
    -0.01594793f, 0.08868458f, -0.05771856f, 0.12978309f, -0.04524630f, -0.03587276f, 0.33238366f, -0.43610430f, 
    0.13422400f, -0.14945303f, 0.00277425f, 0.09139351f, -0.01585172f, -0.16174813f, -0.05118490f, -0.06076191f, 
    0.01868409f, 0.01095950f, -0.10471378f, -0.02570943f, -0.01157491f, 0.05500999f, 0.05004226f, 0.07872313f, 
    0.04622463f, 0.56792337f, -0.00373133f, 0.15100747f, 0.14625220f, -0.07435539f, 0.14756845f, 0.03805800f, 
    -0.07137996f, 0.03889386f, 0.10016388f, -0.05025791f, 0.02806970f, 0.02756663f, 0.02418890f, -0.05180938f, 
    0.09346238f, -0.09904546f, 0.18163618f, -0.13829266f, 0.02976259f, -0.25921592f, 0.17321077f, 0.14162363f, 
    -0.07923815f, -0.10563205f, -0.13865043f, -0.00509772f, -0.01330115f, -0.03779710f, -0.06990657f, 0.01506774f, 
    -0.04897854f, 0.07511967f, -0.03970996f, -0.09816249f, -0.10701123f, 0.16466567f, 0.00682654f, -0.13576214f, 
    0.37040505f, 0.44310549f, 0.13683483f, 0.29955262f, 0.24882933f, 0.15109721f, 0.07091632f, 0.04882956f, 
    0.18003100f, -0.10908354f, -0.14188944f, 0.12323927f, -0.02517897f, -0.11261401f, -0.04007104f, -0.03497663f, 
    0.02309044f, -0.01380136f, 0.02632231f, -0.03783417f, 0.09123076f, 0.31886894f, -0.07847714f, -0.04133001f, 
    0.22632575f, 0.16785043f, 0.02614661f, -0.13378097f, 0.27157333f, 0.05244018f, -0.02867614f, -0.01988176f, 
    -0.08357622f, -0.03883811f, 0.00570017f, 0.05598264f, -0.07961327f, -0.01363579f, -0.23280017f, -0.05688324f, 
    -0.32013163f, 0.04794062f, -0.36750299f, 0.13377370f, 0.06769665f, 0.06238563f, 0.17500573f, 0.05490831f, 
    -0.23814575f, -0.06028028f, -0.04205150f, -0.07843063f, 0.14221367f, 0.05730960f, 0.05766849f, 0.06626903f, 
    -0.07898597f, -0.02383418f, -0.36985084f, 0.01087485f, -0.13012241f, -0.01971688f, -0.04149536f, 0.03370364f, 
    -0.01162284f, 0.01310756f, 0.14937285f, 0.16547762f, 0.07410866f, 0.01962794f, -0.04088681f, 0.05110041f, 
    0.00562256f, -0.06093399f, -0.00138501f, 0.02107057f, -0.03525124f, 0.15077882f, 0.03042365f, -0.03302869f, 
    -0.12886941f, -0.17885642f, -0.35439724f, -0.20483087f, -0.03668889f, 0.03180990f, 0.05874183f, 0.01125551f, 
    -0.10936134f, -0.01942042f, -0.10147034f, -0.01390380f, -0.04035801f, -0.17968893f, 0.06006898f, -0.13839130f, 
    -0.14931469f, 0.09972475f, -0.04016092f, 0.01385590f, -0.03179617f, -0.01660171f, 0.10848100f, 0.18821132f, 
    -0.28416544f, 0.02495568f, -0.27971891f, -0.14022551f, -0.03296437f, -0.00289190f, -0.08447091f, 0.00641138f, 
    -0.05378262f, 0.05882257f, 0.00410314f, 0.06899938f, 0.05336503f, -0.02322443f, 0.10065208f, 0.08217916f, 
    -0.00413005f, 0.02244885f, 0.01530528f, 0.02774663f, 0.00456246f, 0.03126509f, -0.01891172f, 0.02839648f, 
    0.03555846f, -0.04154737f, 0.05568548f, -0.05696509f, -0.04067452f, -0.00277305f, 0.03242652f, 0.03159209f, 
    0.04649030f, -0.06087605f, 0.00337830f, 0.03506598f, -0.01073353f, 0.03881761f, -0.06060139f, -0.01646879f, 
    -0.03474458f, -0.01208664f, -0.05236428f, -0.05252554f, 0.01515651f, 0.02283927f, 0.00229547f, -0.01040517f, 
    -0.05523548f, -0.04552528f, 0.03478519f, 0.01205604f, -0.03283564f, -0.04011729f, -0.01474927f, 0.03499106f, 
    -0.02778791f, -0.06085624f, 0.00899598f, -0.02499045f, -0.02993475f, -0.00284544f, -0.00203089f, 0.04748204f, 
    0.03688316f, -0.03864826f, 0.00681750f, -0.03481914f, 0.02708619f, -0.00699901f, -0.00172395f, -0.04563044f, 
    -0.03702101f, 0.02313214f, 0.03162218f, -0.02014543f, 0.02649895f, -0.01307858f, -0.01449834f, 0.00840023f, 
    0.04464033f, -0.04448674f, -0.01206220f, -0.05602505f, -0.05693665f, -0.00288719f, 0.01999402f, -0.05152977f, 
    -0.06002584f, -0.02050433f, -0.05733733f, 0.00129784f, -0.00690419f, 0.01095041f, -0.02278177f, -0.03399662f, 
    -0.01516451f, 0.00062367f, 0.02558268f, -0.03191689f, -0.06016503f, 0.01453795f, 0.02239959f, 0.02182731f, 
    -0.03948689f, 0.03189158f, 0.00527209f, -0.04260133f, 0.02865445f, 0.04811762f, -0.02941230f, 0.00556603f, 
    0.01608542f, -0.05315859f, 0.04904210f, 0.03637991f, 0.02270945f, -0.00211809f, 0.01526577f, -0.01638088f, 
    -0.03768217f, -0.04264363f, 0.01281544f, -0.04002564f, -0.00178138f, 0.02799282f, 0.03396363f, 0.02723473f, 
    0.03061674f, 0.03330432f, -0.02545753f, 0.02152858f, -0.05127344f, 0.02859545f, -0.05581383f, 0.04176655f, 
    -0.05273880f, 0.04253201f, -0.05203453f, 0.01963844f, 0.03855598f, -0.01079466f, 0.04729480f, -0.03692807f, 
    0.01443251f, -0.05332436f, -0.01791291f, -0.01955696f, 0.02576216f, -0.02970351f, -0.00957979f, -0.04273927f, 
    0.02587558f, -0.03813837f, -0.05354512f, -0.00540371f, -0.01624276f, -0.05594607f, 0.03016828f, 0.03557606f, 
    0.04191933f, 0.02011658f, 0.00326962f, -0.02984198f, 0.04991767f, -0.04015949f, 0.01658043f, -0.05152064f, 
    0.04268348f, 0.02542037f, -0.03692702f, 0.03141691f, -0.00751505f, 0.01347394f, -0.03048872f, -0.00241852f, 
    -0.05393201f, -0.01957018f, -0.02800021f, -0.02948123f, -0.02634902f, -0.05064205f, 0.01234042f, -0.00441453f, 
    0.02668960f, -0.02417914f, -0.02246322f, -0.03070781f, -0.02766929f, 0.02083154f, -0.05148753f, -0.03548063f, 
    -0.03902787f, -0.05261514f, -0.00847180f, -0.01129698f, -0.04432300f, -0.04608244f, -0.01584209f, 0.01775712f, 
    -0.03306727f, -0.01317793f, -0.01738929f, -0.00251477f, 0.04927680f, -0.05282502f, -0.04904507f, -0.00421879f, 
    -0.02183546f, 0.03107693f, -0.00416879f, -0.05542232f, -0.04613617f, -0.01650788f, 0.01559974f, -0.03555142f, 
    -0.02132133f, 0.01287208f, -0.06123480f, -0.04333703f, 0.03967291f, 0.02963622f, -0.04029036f, -0.00965593f, 
    0.00653754f, -0.03122199f, 0.04336037f, -0.04065973f, 0.01484366f, 0.03070522f, -0.05235929f, 0.01546139f, 
    0.01993279f, 0.03410942f, -0.01823291f, -0.04307361f, -0.05465574f, 0.04980486f, -0.02166153f, 0.01083571f, 
    -0.04210418f, 0.02110593f, -0.00229235f, -0.01834584f, -0.02064646f, 0.03598794f, -0.04658455f, -0.00176394f, 
    -0.04878363f, -0.00168011f, 0.04396153f, -0.05341328f, -0.06034633f, 0.01255731f, 0.04171903f, -0.02114581f, 
    -0.03105360f, 0.03733841f, 0.00014064f, 0.01367331f, 0.01218387f, -0.00322510f, 0.03459806f, -0.03280947f, 
    0.03468738f, 0.04610402f, -0.03368954f, -0.05251590f, -0.04015180f, 0.01732835f, 0.01470666f, -0.05703647f, 
    -0.00447915f, -0.01351873f, -0.04060255f, 0.01621021f, -0.00167492f, -0.01939131f, 0.04657676f, -0.00791481f, 
    -0.02647166f, 0.00508859f, 0.02197540f, 0.02751789f, -0.03514685f, 0.00272562f, -0.00043540f, -0.03868152f, 
    0.04111722f, -0.00718576f, -0.00092222f, -0.02753211f, 0.00021334f, -0.04674034f, 0.01956510f, -0.01654858f, 
    0.01015458f, 0.03095953f, -0.05106026f, 0.04012346f, 0.02184101f, -0.02739023f, -0.03213416f, 0.02243552f, 
    -0.04268044f, -0.01454486f, -0.02926800f, 0.03238048f, 0.00286475f, 0.02043610f, -0.01989382f, -0.05249575f, 
    0.01587052f, -0.06094903f, -0.03794321f, 0.03825963f, -0.02826382f, 0.03015326f, 0.02106965f, -0.03641044f, 
    -0.03219308f, 0.02106791f, -0.02378055f, 0.04946021f, 0.00496721f, 0.04843036f, -0.01688434f, 0.04226665f, 
    -0.05612830f, 0.04161521f, 0.01409985f, -0.04358168f, -0.02185715f, -0.05158248f, -0.02744411f, 0.00461397f, 
    -0.00683773f, 0.14801867f, -0.01282486f, -0.29606166f, 0.06959391f, -0.07038026f, 0.03142218f, -0.05418039f, 
    -0.13557842f, -0.07283989f, 0.17103392f, 0.09458217f, 0.11584268f, 0.05457584f, 0.06704626f, 0.08868173f, 
    -0.07244575f, 0.15105641f, 0.11274467f, -0.05635604f, 0.09125168f, -0.06165299f, -0.20078948f, -0.07681303f, 
    -0.08989348f, -0.11019556f, 0.03583888f, 0.18811849f, 0.33129743f, 0.04708002f, 0.01380646f, 0.05913855f, 
    0.03956198f, 0.02292082f, 0.03881602f, -0.05823199f, 0.03942708f, 0.00934583f, 0.15436928f, 0.04052029f, 
    0.02582013f, 0.36353651f, -0.06445155f, 0.18799028f, 0.01413360f, 0.08716618f, 0.10157567f, 0.09887596f, 
    -0.01797551f, 0.13877337f, -0.01055004f, 0.02493987f, 0.04825339f, 0.02554156f, 0.07085870f, 0.09891139f, 
    -0.04508215f, -0.02483908f, 0.00288641f, 0.00599660f, 0.04055431f, 0.20152488f, 0.24643128f, -0.27599150f, 
    0.09656164f, 0.17799313f, -0.25850338f, -0.19359660f, 0.09105180f, -0.00901453f, -0.02527193f, -0.00327194f, 
    0.00636024f, -0.04655729f, 0.05248035f, 0.08638511f, -0.01716091f, 0.04645146f, -0.08681330f, -0.23878634f, 
    0.11793020f, -0.11730006f, 0.26125863f, -0.13715598f, -0.05101321f, 0.11925866f, 0.06593096f, 0.17792334f, 
    0.14417046f, 0.09024677f, 0.10129598f, -0.17357671f, -0.01541557f, -0.13813038f, 0.05502735f, 0.11462465f, 
    -0.05374642f, -0.16088910f, 0.02999464f, 0.05234035f, 0.10027324f, 0.00212833f, 0.12381064f, -0.13625984f, 
    -0.18070681f, 0.11686884f, -0.29435503f, -0.18015949f, 0.30223960f, 0.17463790f, 0.13024972f, -0.01909615f, 
    0.04684171f, -0.02856129f, -0.04577056f, -0.14450215f, -0.11633760f, -0.08481060f, 0.02113999f, -0.05660420f, 
    -0.06104805f, 0.01795790f, -0.00382219f, 0.00851640f, -0.01212894f, -0.09195495f, -0.01607806f, -0.00046744f, 
    -0.11897629f, 0.04420798f, 0.03556510f, -0.04674184f, 0.12035067f, 0.05418827f, 0.09784268f, -0.03273251f, 
    0.08194058f, 0.15548797f, -0.11360393f, -0.04838666f, -0.02761645f, 0.02837501f, 0.24304476f, 0.11217548f, 
    0.08151332f, 0.11350705f, 0.08064292f, -0.08328176f, -0.12466989f, 0.19966316f, 0.04236751f, 0.02610206f, 
    -0.05056481f, 0.02447994f, -0.06437668f, -0.03252514f, 0.09984300f, -0.00654654f, -0.00375887f, 0.05756307f, 
    0.57793647f, -0.37758717f, -0.41123685f, -0.01923408f, -0.03778863f, 0.02312754f, 0.12849106f, 0.20841640f, 
    -0.29236045f, 0.21831527f, 0.07174255f, 0.04003404f, 0.05211688f, 0.00693639f, -0.15559633f, -0.08994391f, 
    0.04434753f, 0.03293260f, 0.01370926f, 0.11442480f, 0.37766117f, 0.14207131f, 0.08252370f, -0.09288025f, 
    0.07511750f, -0.05902445f, -0.07156540f, -0.00861606f, 0.06815635f, -0.06350748f, 0.11295001f, 0.07513148f, 
    0.02209857f, 0.15968339f, 0.03441909f, -0.14078461f, -0.14505185f, -0.04259487f, -0.00432356f, -0.09644134f, 
    -0.12940376f, 0.30749038f, 0.26868597f, -0.38386241f, -0.06736936f, 0.03549297f, 0.11025202f, 0.00275310f, 
    0.24925542f, -0.13102289f, 0.06088768f, -0.04930852f, -0.14341168f, -0.12974055f, -0.10275823f, 0.07317423f, 
    -0.09477773f, -0.06449065f, -0.00742151f, 0.09311271f, 0.23660626f, 0.02361339f, 0.22749652f, -0.06183087f, 
    0.04282634f, 0.15894444f, 0.07195122f, 0.04411058f, 0.24404764f, 0.04008836f, 0.17420621f, -0.06804849f, 
    -0.08333845f, -0.02596791f, -0.02285765f, 0.02045301f, 0.07712799f, 0.09001376f, -0.17978825f, 0.00155863f, 
    -0.21987204f, 0.01334811f, -0.23369668f, 0.13106720f, -0.04072036f, 0.05489071f, 0.16736349f, 0.08237058f, 
    -0.18014018f, 0.09126043f, -0.05199689f, -0.07816844f, -0.00587541f, -0.01566264f, 0.01676011f, 0.00034109f, 
    -0.00533651f, 0.00562365f, -0.14848858f, 0.18105632f, -0.24740362f, 0.33529359f, 0.06168039f, 0.02997102f, 
    -0.07485291f, 0.18347281f, -0.05664795f, -0.12053737f, -0.05048615f, 0.07954572f, -0.00406255f, 0.01191097f, 
    0.05495060f, -0.11426925f, 0.03620017f, -0.20195150f, -0.21877609f, -0.04113700f, -0.00312877f, -0.13020651f, 
    -0.13840334f, 0.19594042f, 0.33910877f, 0.17192410f, -0.13725747f, 0.26110512f, -0.02278078f, -0.06857411f, 
    -0.15612410f, 0.05344257f, 0.00998616f, -0.07063678f, 0.03445462f, -0.09900955f, 0.00878599f, -0.07691354f, 
    0.07624903f, 0.14640339f, -0.05138056f, -0.00195092f, 0.44619277f, 0.21366014f, -0.03166112f, -0.25277978f, 
    -0.24875976f, -0.07920475f, -0.04109981f, -0.14368293f, -0.06977487f, -0.12243543f, -0.00186864f, 0.00641011f, 
    0.01203005f, 0.08156390f, 0.05494279f, -0.01776430f, -0.14028457f, -0.06389327f, 0.18503299f, -0.01515553f, 
    0.11386188f, -0.22704750f, 0.28495067f, -0.15038979f, 0.13938290f, -0.03391340f, 0.11479578f, -0.14975500f, 
    -0.01257688f, -0.10650445f, 0.07263584f, -0.01050353f, 0.08866888f, 0.00933563f, -0.12378909f, -0.03163232f, 
    -0.23935278f, -0.15219347f, -0.09487207f, -0.08592481f, 0.23931900f, -0.02895184f, 0.15898092f, 0.30775198f, 
    0.01602731f, 0.01548845f, -0.15856640f, -0.01854891f, 0.04375637f, 0.03368914f, 0.16683471f, 0.05984760f, 
    0.01587436f, -0.12642671f, -0.05112870f, 0.01707152f, -0.21424969f, -0.11000528f, -0.12133260f, -0.20770124f, 
    -0.14287500f, -0.14079303f, -0.12835355f, 0.06073079f, -0.12239110f, 0.06962801f, 0.01315337f, 0.12737077f, 
    0.02239523f, 0.12558687f, -0.02682591f, 0.01104109f, 0.12444480f, 0.06598539f, 0.05644559f, 0.08435705f, 
    0.16190134f, -0.00925962f, 0.29768047f, 0.14116907f, -0.24005023f, 0.03538943f, -0.31550488f, 0.24789162f, 
    -0.22209609f, 0.23768772f, 0.23166783f, 0.20151943f, 0.16317667f, 0.04749450f, -0.02507772f, -0.05264215f, 
    -0.11709446f, 0.02507413f, -0.06776979f, -0.02127267f, 0.16648175f, 0.01972719f, 0.00594517f, 0.14978059f, 
    0.18137436f, -0.31517228f, 0.23917781f, 0.04312751f, -0.17703135f, -0.04480803f, -0.02073141f, -0.02672910f, 
    0.18564555f, 0.05627791f, 0.03561650f, 0.00938465f, 0.00390662f, 0.04683806f, 0.13611746f, -0.03654816f, 
    0.07540152f, 0.14577878f, 0.21355969f, 0.16809420f, 0.07373973f, -0.38240689f, 0.01866525f, 0.05488030f, 
    -0.35102737f, 0.08333214f, 0.12204213f, -0.07890562f, 0.09290180f, 0.09867698f, -0.01065049f, -0.08242756f, 
    -0.02653920f, -0.08648961f, -0.15106304f, 0.07595486f, 0.06841706f, 0.11884230f, 0.15189078f, 0.16833486f, 
    0.14211030f, 0.09859590f, 0.35219935f, 0.04473552f, -0.00834714f, 0.09989052f, 0.29167160f, 0.13142666f, 
    0.02274660f, 0.06790926f, 0.02833085f, -0.00118178f, -0.10180440f, -0.18284960f, -0.16253859f, -0.04177829f, 
    0.06259259f, -0.03945828f, 0.07883389f, 0.03420941f, -0.45270815f, -0.05836925f, -0.68314123f, 0.45856375f, 
    -0.19449764f, 0.00997609f, 0.05347198f, 0.05445148f, -0.17770691f, 0.01808723f, 0.05420021f, -0.00529557f, 
    -0.06692943f, -0.07325548f, -0.11758971f, -0.11133324f, -0.07065284f, -0.16554265f, 0.03019233f, -0.13282987f, 
    0.11327045f, 0.00891180f, 0.42317623f, -0.19499323f, -0.03441670f, 0.00487463f, -0.32552245f, 0.12932327f, 
    -0.09318079f, -0.14555565f, 0.07035924f, 0.11231196f, 0.03833260f, 0.02700215f, 0.09209592f, -0.05364995f, 
    -0.08833541f, -0.12324824f, -0.11392700f, -0.01519086f, -0.00778203f, 0.13609934f, -0.01518726f, -0.28310135f, 
    0.09197073f, -0.23800363f, 0.04436284f, -0.08623561f, -0.10319675f, -0.06847619f, 0.20921527f, 0.14824373f, 
    0.03282416f, 0.05929121f, 0.11161093f, 0.09603415f, 0.02993483f, -0.09114637f, 0.10057848f, 0.01845377f, 
    0.25214621f, -0.43093476f, 0.44407728f, -0.06539281f, -0.26149005f, -0.12717068f, -0.08313555f, -0.30934545f, 
    0.09276222f, 0.08126029f, 0.20377934f, -0.08988681f, -0.06183767f, 0.08459382f, 0.08223727f, 0.08564486f, 
    -0.00600107f, 0.14999636f, -0.04955098f, 0.12411445f, 0.14201796f, -0.36098811f, 0.19853456f, 0.18985319f, 
    -0.26212558f, -0.09178363f, 0.10616660f, 0.02445528f, 0.08144153f, 0.03738299f, 0.04759723f, 0.01301400f, 
    -0.09371696f, -0.00633192f, 0.00553875f, 0.05484095f, 0.10947608f, 0.12235413f, 0.14073429f, 0.17668308f, 
    0.25911891f, 0.29346019f, 0.36181149f, -0.12292916f, -0.23274472f, -0.09980553f, -0.12227445f, 0.01978117f, 
    0.17268805f, -0.00703175f, -0.14970346f, 0.07473867f, -0.10684814f, -0.06507371f, -0.05445950f, -0.11840873f, 
    -0.03186591f, -0.07858102f, 0.23888952f, -0.11490902f, -0.15069820f, 0.04019516f, -0.15443879f, 0.22126065f, 
    -0.12152246f, 0.09254259f, 0.00271743f, 0.06593127f, 0.06041163f, 0.16492456f, -0.01936747f, -0.12655711f, 
    0.05035361f, 0.04702862f, 0.03646003f, 0.05056008f, 0.08248767f, 0.03979475f, 0.02390037f, 0.15027121f, 
    -0.04036063f, 0.06587210f, 0.40727371f, 0.09062951f, -0.23986545f, 0.05629392f, 0.10334107f, -0.00994662f, 
    0.14003280f, 0.11926355f, 0.01177519f, -0.15716237f, 0.06968626f, 0.05980214f, 0.02680488f, 0.01653888f, 
    0.00529120f, 0.01312545f, 0.07560118f, 0.05846591f, -0.02075120f, -0.01515965f, 0.08396818f, -0.45069611f, 
    0.08828957f, 0.16948982f, 0.16375418f, 0.10839152f, 0.08827277f, 0.14906353f, 0.02037176f, -0.01592031f, 
    -0.01215210f, -0.03728763f, -0.12223593f, 0.04861782f, 0.19626686f, 0.08583596f, 0.10300019f, 0.02746410f, 
    -0.12742741f, -0.07548696f, 0.15139939f, 0.05033649f, 0.30531168f, 0.01063385f, 0.03105066f, -0.03153402f, 
    0.06243201f, -0.09942158f, 0.09258257f, 0.17044909f, -0.04804647f, -0.02062073f, 0.07211311f, -0.19764303f, 
    -0.28170547f, -0.08727675f, -0.20472874f, -0.09019529f, -0.02553695f, 0.23273015f, 0.39587393f, -0.31474507f, 
    0.05187618f, -0.12556700f, -0.15178077f, 0.11799320f, 0.06591982f, 0.07989536f, -0.00783915f, 0.10472467f, 
    -0.15293637f, -0.05539734f, -0.20950179f, -0.00929813f, -0.33340234f, -0.15971600f, -0.05209436f, -0.20057091f, 
    -0.03787313f, 0.22374527f, 0.00837853f, -0.15140089f, -0.09317289f, -0.05101999f, -0.08323947f, 0.05137464f, 
    0.11749374f, 0.00173993f, 0.04303047f, 0.03352856f, 0.02278348f, -0.05187215f, 0.02368535f, 0.22358623f, 
    0.10642142f, 0.00183432f, 0.14523065f, 0.01374618f, -0.08969784f, 0.03244103f, 0.03041915f, -0.22509313f, 
    0.07903653f, -0.06955721f, 0.27405381f, 0.10290442f, 0.05203263f, 0.05558688f, 0.04348199f, -0.01181423f, 
    -0.04243398f, -0.02691423f, 0.07922034f, 0.08736961f, 0.02528647f, -0.03403355f, 0.09882060f, 0.06901787f, 
    0.13306317f, -0.01161950f, -0.08153318f, 0.04564631f, -0.03886952f, 0.03378033f, 0.09344267f, 0.17640260f, 
    -0.10553616f, -0.05478901f, 0.03641329f, 0.03791060f, 0.02954745f, 0.12949425f, 0.03758106f, 0.12665290f, 
    0.12536791f, 0.08123258f, 0.06489276f, 0.09834170f, 0.23691177f, 0.31740028f, -0.36789152f, -0.30152839f, 
    0.12179085f, -0.02104960f, 0.01190502f, 0.11044105f, 0.06908253f, 0.18593888f, 0.08734167f, -0.04115471f, 
    -0.09346862f, -0.03963534f, -0.16753721f, 0.01565830f, -0.11009982f, 0.14264491f, 0.26928365f, 0.20701942f, 
    -0.00414161f, 0.21386111f, -0.15591668f, -0.25205418f, -0.08867425f, -0.06678893f, 0.11191915f, 0.06717351f, 
    0.06517610f, -0.02119656f, 0.02037926f, -0.04914909f, 0.10181640f, -0.02378223f, -0.12913623f, -0.01500269f, 
    -0.12733212f, 0.07361390f, 0.04490386f, -0.00332786f, -0.37388071f, -0.10227841f, 0.33142430f, -0.28063798f, 
    0.17084269f, -0.37257859f, 0.16324273f, 0.07061864f, 0.07094590f, 0.00798910f, -0.01427449f, -0.00448503f, 
    0.02373825f, -0.09600551f, -0.10074494f, -0.05615469f, -0.07150536f, -0.12711371f, 0.11556243f, -0.19185017f, 
    -0.18493190f, 0.54465097f, -0.05159776f, 0.06331021f, 0.12197365f, -0.22093749f, -0.21828687f, -0.00528082f, 
    0.01178439f, -0.06687264f, -0.00462148f, -0.01542946f, -0.14106916f, -0.07757365f, 0.11349362f, 0.08505931f, 
    -0.02821720f, -0.05387743f, -0.01692870f, -0.11751601f, 0.32290626f, 0.04117053f, 0.02859425f, -0.03463958f, 
    0.09579555f, 0.03831265f, -0.04344996f, 0.06271181f, -0.11233458f, 0.05169364f, 0.03089848f, 0.11228280f, 
    -0.05643285f, 0.01397016f, 0.05499781f, 0.04601181f, -0.14171210f, 0.02947438f, -0.07894590f, -0.06152202f, 
    0.41709301f, 0.25780451f, 0.08153546f, -0.05790797f, 0.07785609f, -0.03554922f, 0.19561657f, -0.05045369f, 
    0.00492755f, -0.03995102f, -0.00443171f, 0.10134559f, 0.03656402f, -0.04353079f, 0.16991602f, 0.00226928f, 
    0.25154963f, 0.13227269f, 0.00418560f, 0.10647377f, 0.22532657f, 0.07780116f, -0.09470051f, -0.36755419f, 
    -0.06044931f, 0.08568473f, 0.06801517f, 0.06287428f, 0.12925604f, 0.05830679f, 0.07853737f, 0.10317959f, 
    -0.07625867f, -0.09119597f, -0.04545128f, 0.07940625f, 0.05450391f, 0.07041563f, 0.05188606f, 0.00316892f, 
    0.09967460f, 0.38534626f, -0.02563063f, -0.22705092f, -0.07722028f, 0.02842351f, 0.18335971f, -0.00504937f, 
    -0.02364524f, -0.19515185f, -0.10945254f, -0.06935358f, 0.04229637f, -0.00709631f, 0.03011327f, 0.05951943f, 
    -0.26888496f, -0.14419624f, 0.11826378f, -0.15838431f, -0.12073371f, 0.01648933f, 0.04743868f, -0.08841771f, 
    -0.14029129f, -0.07711408f, 0.05957396f, 0.04949513f, 0.02661710f, 0.00391946f, -0.06668434f, -0.19391732f, 
    0.05280225f, -0.02735935f, 0.04345021f, 0.05664802f, 0.06277332f, 0.08773033f, -0.00347140f, 0.14790553f, 
    0.06700401f, 0.07898752f, 0.06731278f, -0.23287952f, -0.13668406f, 0.02930800f, 0.27603710f, 0.01829576f, 
    0.00505994f, -0.03377479f, -0.17549405f, -0.11155441f, -0.09449092f, 0.04587919f, -0.00849769f, -0.06603482f, 
    -0.09749447f, 0.13115710f, 0.09978317f, -0.02966770f, -0.18607517f, -0.02773942f, -0.13675915f, -0.04170679f, 
    -0.25483546f, -0.03760095f, -0.12627287f, -0.00140728f, 0.04943783f, 0.01664607f, -0.07160765f, -0.06127881f, 
    -0.04852606f, -0.02546266f, -0.03936817f, 0.09009379f, 0.08000273f, 0.06750481f, 0.07770464f, 0.33881888f, 
    0.08686163f, -0.11696330f, 0.09133653f, 0.22235473f, -0.15897176f, 0.09626297f, -0.07960901f, -0.01060022f, 
    -0.06699121f, 0.04083728f, 0.11102727f, 0.09185633f, 0.01154219f, 0.05296361f, 0.16013478f, 0.05507294f, 
    0.10350192f, 0.12717059f, -0.12742840f, 0.06886490f, -0.32562807f, -0.11783749f, 0.05789638f, 0.02537020f, 
    0.02582989f, -0.11994179f, -0.00676199f, -0.10102460f, -0.10500608f, 0.00815482f, 0.10016324f, 0.14100915f, 
    -0.12652209f, -0.17385733f, -0.04373693f, -0.08875648f, 0.04864747f, -0.03179680f, 0.22426692f, -0.04020257f, 
    0.35858226f, -0.22100036f, 0.04575327f, -0.15462469f, 0.17389786f, -0.00335247f, 0.00843902f, 0.02015483f, 
    0.32172379f, -0.06552385f, 0.08790077f, -0.12308484f, 0.02960619f, -0.03585624f, -0.02110225f, -0.05050333f, 
    0.10860875f, -0.11447526f, 0.06065017f, -0.02982961f, 0.31110677f, -0.01058646f, 0.13893704f, 0.14387849f, 
    0.28610849f, 0.03999613f, -0.01541804f, 0.20516744f, -0.01457040f, -0.10383586f, -0.05257864f, 0.04150584f, 
    0.06674922f, -0.07031248f, 0.08059626f, -0.02121150f, 0.13851111f, 0.16169736f, 0.21702351f, 0.04812101f, 
    -0.18044823f, 0.14431582f, -0.46019918f, -0.12932281f, 0.31677195f, 0.02794072f, 0.15372372f, 0.06856443f, 
    -0.08705807f, 0.03411374f, -0.11122121f, -0.00892720f, -0.02771919f, 0.19206710f, 0.03526783f, 0.02910874f, 
    -0.13668606f, 0.15801848f, -0.01147051f, 0.09043309f, -0.05636349f, 0.41044295f, 0.11829460f, -0.08420132f, 
    0.26414898f, -0.17106825f, 0.09176362f, 0.10240457f, -0.18673649f, -0.20514764f, -0.07937234f, -0.07163137f, 
    -0.06979138f, 0.11137834f, 0.07619432f, 0.08319466f, 0.01217383f, 0.13609722f, -0.01947593f, -0.14328653f, 
    0.32658133f, -0.10514680f, -0.18541120f, 0.04034102f, 0.17162712f, 0.19209203f, -0.05408778f, 0.04913023f, 
    0.08460644f, -0.12066956f, -0.00238488f, -0.01064014f, -0.08405842f, -0.05344304f, 0.12536469f, 0.01693899f, 
    -0.09065849f, 0.19834626f, 0.03821913f, 0.04570227f, 0.66197562f, -0.08072337f, 0.00197600f, -0.08138431f, 
    0.19676554f, 0.04829458f, -0.01504034f, 0.15216327f, 0.20765793f, -0.09037881f, -0.00817983f, 0.03067796f, 
    0.06774212f, -0.02998863f, 0.08074209f, 0.02519584f, -0.09935748f, -0.11213004f, 0.26519203f, 0.04222434f, 
    -0.32106799f, 0.25097263f, -0.07124121f, -0.12322722f, 0.24276350f, 0.03140233f, 0.07655571f, 0.02897334f, 
    0.18082421f, 0.07040836f, 0.13908133f, 0.12177304f, -0.06979372f, -0.06440063f, 0.04940018f, 0.00985314f, 
    -0.01711383f, 0.04879733f, 0.03244723f, 0.01118819f, -0.23527028f, 0.02841630f, 0.07455385f, 0.07039687f, 
    -0.09067787f, 0.04866510f, 0.08066462f, -0.02818962f, 0.00463284f, 0.02678212f, 0.05346930f, 0.11094143f, 
    0.21973392f, 0.12042423f, 0.12890127f, -0.05071085f, 0.11077864f, -0.03588342f, -0.19207489f, 0.02849733f, 
    -0.47234675f, 0.00644811f, -0.51884943f, -0.12466031f, 0.17608231f, 0.12521319f, -0.08858150f, 0.31744167f, 
    -0.31255752f, 0.17652877f, -0.17621566f, -0.06966048f, -0.00827054f, 0.10535265f, 0.03451541f, -0.02962668f, 
    -0.04099058f, 0.06665272f, -0.03203366f, -0.03418646f, -0.36342520f, 0.05428390f, -0.23135376f, -0.05643927f, 
    0.03949077f, -0.02521736f, -0.00975757f, 0.12201282f, -0.23747206f, -0.11140370f, -0.07785177f, -0.01175757f, 
    -0.04720711f, 0.13931942f, -0.05405335f, 0.03291235f, -0.08460394f, 0.05429572f, 0.21070708f, 0.01370849f, 
    -0.13822185f, -0.31079808f, -0.13857749f, -0.30876800f, 0.17877501f, 0.05193288f, 0.07446537f, 0.03615080f, 
    0.13860039f, 0.02901343f, 0.02881607f, -0.04013390f, -0.15016693f, -0.10399838f, -0.10672100f, -0.03485319f, 
    -0.05734836f, -0.01965881f, 0.13950993f, -0.08309735f, 0.47812769f, -0.14388107f, 0.08927162f, -0.36492324f, 
    0.25904098f, -0.08543582f, 0.02129772f, -0.07463638f, 0.24561393f, -0.08184414f, 0.02302582f, -0.10549298f, 
    0.05491228f, 0.06869379f, 0.02013624f, 0.21028216f, 0.16221938f, 0.07301990f, 0.06549527f, -0.04388089f, 
    0.30461475f, -0.17198934f, -0.20178133f, -0.26560932f, 0.33476809f, -0.11176313f, -0.07713119f, -0.06556833f, 
    0.01573737f, -0.23223494f, 0.01974286f, 0.00034442f, -0.05964597f, -0.00249147f, -0.00138044f, 0.12970895f, 
    0.01554342f, 0.03559440f, 0.13004947f, 0.04076438f, -0.17540091f, -0.16323692f, 0.00930524f, 0.49829304f, 
    0.28761700f, 0.12210410f, 0.24687028f, 0.15644002f, 0.05802846f, -0.16117948f, -0.01701527f, 0.02351678f, 
    0.02890362f, -0.02059795f, 0.09057382f, 0.03477466f, -0.01305292f, 0.12473100f, -0.10464134f, -0.03791941f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07359013f, 0.23192406f, -0.02495261f, 0.07933248f, -0.06313439f, -0.00005009f, -0.04980539f, -0.07901713f, 
    -0.00463271f, -0.10191533f, 0.17444584f, -0.05829119f, 0.01478305f, 0.01663729f, 0.13322598f, 0.11730481f, 
    0.05181862f, -0.04433870f, -0.05384794f, 0.02523761f, 0.01077773f, 0.11507225f, -0.17047568f, 0.04416703f, 
    0.03223282f, 0.22247067f, 0.05159968f, -0.04727851f, 0.05260335f, 0.08979767f, -0.09654264f, 0.07524992f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.50111872f, 0.06823507f, -0.01368237f, 0.22814506f, 0.11386871f, 0.27908367f, -0.05024474f, 0.35736492f, 
    -0.15951464f, 0.10973608f, 0.17218930f, 0.17164864f, -0.00344218f, -0.00143833f, -0.19427647f, -0.15886003f, 
    0.16545919f, 0.38917270f, -0.17181458f, 0.11602402f, -0.05162794f, 0.00070066f, 0.10715994f, 0.52640086f, 
    -0.25957912f, 0.04037485f, -0.35386711f, 0.04715880f, 0.24017115f, 0.07631863f, -0.30045867f, -0.20094199f, 
    -0.03454136f, 0.16431454f, 0.13730127f, -0.01169573f, -0.03852759f, 0.22030357f, 0.11615386f, 0.13507535f, 
    -0.20552151f, -0.27609438f, 0.01109897f, 0.09574486f, 0.03968698f, 0.11892878f, -0.10851800f, 0.12230946f, 
    0.02801488f, 0.09106097f, -0.29963639f, 0.27555186f, -0.00590438f, -0.23402236f, -0.21180791f, 0.12663607f, 
    -0.03039007f, 0.18864556f, -0.09716414f, 0.08285794f, -0.12794393f, -0.19769990f, -0.29686514f, 0.33211979f, 
    -0.38696924f, 0.23743831f, 0.00002392f, -0.05427376f, -0.04177245f, 0.17162947f, 0.12069479f, 0.28728154f, 
    -0.25101602f, -0.40417820f, 0.30513161f, 0.06897490f, -0.01768732f, -0.06089625f, 0.11695043f, 0.03666549f, 
    0.57763159f, -0.30005130f, 0.06666156f, 0.16577315f, -0.16183275f, -0.45251226f, -0.11338770f, 0.25305170f, 
    0.33974144f, 0.24509631f, 0.31562778f, -0.13729909f, -0.30933708f, -0.13882539f, -0.04549105f, -0.17593394f, 
    0.49329588f, -0.18548642f, -0.07866216f, 0.21383847f, -0.41589797f, 0.34483135f, 0.01475654f, 0.01100247f, 
    -0.08816452f, 0.27386245f, -0.21117431f, -0.11565636f, 0.08041421f, -0.10616534f, -0.23913758f, 0.21275245f, 
    -0.29698372f, 0.36324412f, -0.05732039f, 0.23020139f, -0.03630650f, -0.26382673f, -0.10184264f, 0.13348922f, 
    0.10964464f, -0.02837915f, 0.00086450f, -0.04268038f, -0.12863116f, -0.15709966f, 0.16028933f, 0.40080321f, 
    -0.16423583f, 0.35301408f, -0.10470926f, 0.02521510f, 0.00939427f, -0.28485370f, -0.01379222f, -0.30364808f, 
    0.03156978f, -0.13441704f, 0.31461319f, 0.01904635f, 0.14304757f, 0.13914180f, 0.36698967f, 0.27971920f, 
    -0.12479049f, -0.22526629f, -0.39128041f, 0.07495474f, 0.00928278f, 0.19654922f, -0.04905199f, -0.15088262f, 
    0.07039899f, 0.21770513f, 0.41159374f, 0.03693857f, 0.21292244f, 0.06145561f, 0.26295522f, 0.20675159f, 
    -0.47790515f, 0.21696694f, 0.05236834f, 0.07460767f, -0.00697099f, 0.05919068f, -0.16490774f, 0.28531349f, 
    0.15966608f, 0.37719953f, -0.29284650f, 0.17809866f, -0.17506145f, -0.08359245f, -0.15290585f, -0.26765794f, 
    -0.33270165f, 0.03724224f, 0.30774939f, 0.24222040f, 0.02088554f, 0.19459407f, 0.33032310f, 0.10679480f, 
    -0.10028890f, 0.01340818f, 0.01708420f, -0.01446039f, 0.10015905f, -0.05631552f, 0.24272764f, 0.08136460f, 
    -0.18262933f, 0.07971154f, -0.00459241f, -0.11991176f, 0.02861663f, -0.14790632f, 0.03352214f, -0.17743559f, 
    0.02296710f, -0.38179743f, 0.06981766f, -0.04322277f, 0.11939690f, 0.04914590f, 0.49511808f, -0.28414479f, 
    0.15926343f, -0.06059909f, -0.08056474f, -0.03248759f, 0.09134994f, 0.15097970f, 0.22004667f, 0.34412807f, 
    0.22641934f, 0.23895192f, -0.07546232f, 0.11052284f, 0.30800340f, 0.34953550f, 0.17886978f, -0.00906361f, 
    0.33526722f, 0.30416828f, 0.06850843f, -0.40938744f, -0.06227352f, -0.14549834f, -0.13948806f, 0.04836592f, 
    0.02981945f, -0.05049489f, 0.29450879f, -0.17461003f, -0.04926322f, -0.15217789f, -0.00912108f, 0.42806229f, 
    0.27946940f, -0.16121359f, 0.41952771f, -0.16541322f, -0.11579350f, -0.37609127f, -0.38999575f, -0.30979213f, 
    0.28951624f, 0.25936863f, 0.34670752f, -0.16114683f, -0.37428230f, 0.08811154f, 0.21019460f, 0.34399247f, 
    -0.12047821f, 0.20642041f, -0.01250628f, -0.07706381f, -0.25504693f, 0.03181934f, 0.06903496f, -0.14807500f, 
    -0.15723194f, -0.24901789f, -0.09888498f, 0.03685428f, 0.08096180f, 0.05755487f, 0.45416597f, 0.21010798f, 
    -0.20329274f, 0.17052671f, -0.26209721f, 0.04057690f, -0.17164582f, -0.09411127f, -0.00204230f, -0.13276476f, 
    -0.26142761f, 0.25795850f, 0.41010207f, 0.11984328f, 0.20055877f, -0.10575491f, 0.19311641f, -0.19630623f, 
    0.00761821f, -0.04337360f, 0.10556883f, -0.09742486f, 0.00954598f, -0.10494003f, -0.01042314f, -0.33132970f, 
    0.36839381f, -0.01277757f, 0.04660361f, -0.08331736f, -0.10927609f, 0.02548934f, -0.03582678f, 0.34601906f, 
    0.34116590f, 0.44902414f, 0.16659911f, -0.08280680f, -0.17292897f, -0.06351170f, -0.27039796f, 0.13824962f, 
    -0.69236922f, 0.21961479f, -0.35183412f, 0.06165957f, 0.37257549f, 0.37710515f, -0.55100465f, -0.09819999f, 
    -0.05539834f, 0.01049356f, 0.11983223f, -0.04799046f, 0.09434194f, -0.20506160f, -0.02997069f, -0.31069991f, 
    0.34056643f, -0.03851192f, 0.42467073f, 0.12661569f, -0.09011861f, 0.12330461f, -0.08760428f, 0.02989769f, 
    0.27361932f, 0.28173208f, 0.42704156f, -0.19926007f, -0.15059581f, 0.41266483f, 0.04697593f, -0.16199158f, 
    -0.10538837f, 0.26503211f, -0.22714873f, -0.04783566f, 0.29736677f, 0.34641194f, -0.45866749f, 0.16661556f, 
    0.36037076f, -0.09308328f, -0.07687014f, 0.29304928f, -0.17918940f, 0.12229925f, -0.13941363f, 0.01708863f, 
    -0.12111156f, 0.16333111f, 0.16994947f, -0.16680419f, 0.13336974f, -0.10056423f, -0.03992444f, 0.14803553f, 
    0.02425629f, 0.10965317f, -0.42334372f, 0.03424254f, -0.09573646f, 0.16847238f, 0.18526621f, -0.21437772f, 
    -0.28423104f, 0.21435840f, -0.10637827f, 0.12054985f, 0.32524356f, -0.42922804f, -0.46373579f, 0.24463326f, 
    0.25729439f, -0.13569793f, 0.03408233f, -0.26089954f, 0.14813286f, -0.01341358f, 0.07751170f, 0.16601607f, 
    -0.03322686f, -0.23310335f, -0.18290666f, -0.14558472f, 0.13426197f, -0.13294902f, -0.02148634f, -0.17057124f, 
    -0.09462000f, -0.25060090f, 0.07218908f, -0.34801388f, 0.16031893f, -0.50531328f, -0.25953826f, -0.12069088f, 
    -0.14392428f, -0.34343281f, -0.08028233f, 0.16952218f, -0.02189823f, 0.02724587f, -0.01841293f, -0.08836644f, 
    -0.13225149f, 0.04961695f, 0.06187529f, 0.41283089f, -0.20362115f, 0.06230781f, 0.15079913f, -0.17937297f, 
    0.08770325f, 0.19563006f, -0.05914594f, -0.11798751f, 0.00144614f, 0.02720611f, 0.08270730f, -0.10379917f, 
    -0.51656568f, 0.22079460f, -0.16090585f, 0.19246657f, 0.01716796f, 0.36042693f, 0.47766271f, -0.06123593f, 
    -0.19559269f, 0.03410473f, 0.28299665f, 0.00508015f, 0.30596688f, -0.23008919f, 0.36031449f, -0.09660498f, 
    -0.32019269f, 0.21456453f, -0.11610056f, 0.31177387f, -0.12381878f, 0.03251332f, -0.15520659f, 0.24708310f, 
    -0.23088463f, -0.26949477f, -0.05231357f, 0.11148638f, -0.06861214f, 0.01507872f, 0.16687575f, 0.05301549f, 
    -0.06113850f, 0.11596876f, -0.52239865f, 0.09983830f, -0.09826884f, -0.07560142f, -0.05611822f, 0.23720384f, 
    0.05911656f, 0.24353287f, 0.01915796f, 0.10797038f, 0.04725924f, -0.37492904f, -0.39184156f, 0.28919458f, 
    0.06242985f, -0.12084337f, -0.01072587f, 0.37671897f, -0.06563917f, -0.14075780f, 0.07786997f, 0.17783023f, 
    -0.06063752f, -0.25162196f, 0.13172621f, -0.13801369f, 0.07701667f, 0.12062053f, -0.07715661f, -0.04799117f, 
    0.28807664f, -0.09504811f, 0.05975682f, 0.07902688f, 0.00583089f, 0.39046970f, -0.23628923f, -0.18462865f, 
    0.19017889f, 0.07923669f, 0.19030882f, -0.17069018f, 0.05308250f, 0.00955790f, 0.28800145f, -0.20061664f, 
    0.07393400f, 0.09736243f, -0.04296924f, -0.01590245f, 0.20468684f, -0.11431357f, 0.00625744f, 0.18857235f, 
    -0.06792035f, -0.32397935f, 0.18795048f, 0.02447765f, 0.01895217f, -0.04442661f, -0.16116162f, -0.20965321f, 
    0.47487196f, -0.10837500f, 0.35336229f, -0.18314061f, 0.15150054f, 0.38449371f, 0.03232671f, 0.02644751f, 
    0.84603590f, 0.15304905f, -0.07028067f, -0.13738404f, -0.11979141f, 0.23626395f, 0.07926048f, -0.13201988f, 
    0.26059809f, 0.05095809f, -0.00246030f, 0.01229904f, -0.21485913f, 0.05642740f, -0.15934941f, 0.16970862f, 
    0.24080889f, -0.19030455f, 0.20709072f, -0.16325334f, -0.13756977f, 0.01920442f, -0.48964477f, -0.35107803f, 
    0.29358751f, -0.05989377f, 0.51533985f, -0.03115235f, -0.07763758f, -0.50567824f, 0.01713387f, 0.38811293f, 
    0.65302384f, 0.04768043f, 0.01736930f, 0.13218659f, -0.17514287f, 0.30961958f, 0.10263189f, 0.26036114f, 
    0.18441124f, 0.20797388f, 0.02362569f, 0.41348484f, 0.09971655f, 0.34370083f, -0.06481721f, 0.05869723f, 
    0.22697595f, 0.05576034f, -0.22961824f, -0.13357414f, 0.02922033f, -0.06681974f, -0.30008456f, -0.08993290f, 
    -0.27172995f, -0.03841660f, 0.31819919f, 0.36147711f, 0.16968147f, 0.26307184f, 0.07478090f, 0.15120280f, 
    -0.08859567f, -0.10049905f, 0.57295728f, -0.12937449f, 0.24673903f, -0.08926258f, 0.29888996f, -0.15503947f, 
    -0.06549972f, -0.06352428f, 0.00151859f, -0.03566886f, 0.00285888f, -0.03339472f, 0.14267416f, -0.14533956f, 
    -0.09026109f, -0.03703406f, -0.16648218f, 0.14317393f, -0.09228563f, 0.15224145f, -0.07233942f, -0.13595282f, 
    0.08998504f, 0.04015893f, -0.07770861f, 0.06281403f, 0.00938551f, -0.04017714f, -0.11732227f, -0.06562404f, 
    -0.03523411f, 0.03833611f, -0.08469653f, -0.13729924f, 0.00800853f, 0.01250316f, 0.03841529f, -0.18285939f, 
    0.00481500f, 0.29202893f, 0.05693737f, -0.19515322f, -0.11901771f, -0.05245169f, 0.00721137f, 0.17712793f, 
    0.30684632f, 0.10657290f, -0.04046819f, 0.16201919f, -0.15284060f, 0.14093596f, -0.31876621f, 0.24493718f, 
    0.03019885f, 0.08078679f, -0.16732702f, -0.34090886f, -0.06892195f, -0.22774965f, 0.28981799f, -0.28458896f, 
    0.05326229f, 0.25897115f, -0.21139053f, 0.16570927f, -0.00928539f, -0.33691922f, 0.31700912f, 0.62066835f, 
    -0.48277810f, 0.21165088f, 0.15193731f, 0.49695569f, -0.00046529f, -0.06696714f, 0.06565031f, 0.05320767f, 
    -0.09751189f, 0.14484967f, -0.03288290f, -0.14321525f, -0.11521509f, -0.03936752f, 0.05789100f, 0.18367752f, 
    0.31190220f, -0.27451491f, -0.31560978f, 0.16087760f, 0.15016462f, 0.07516297f, 0.02029129f, 0.02632117f, 
    -0.40507418f, 0.28424555f, 0.45806292f, -0.17877507f, 0.01406061f, -0.30379978f, -0.05080531f, -0.06055261f, 
    -0.53710365f, 0.09307773f, 0.11977693f, -0.20435773f, 0.19583681f, 0.13261646f, 0.12255576f, -0.09529353f, 
    -0.27906761f, 0.18874000f, -0.00849390f, 0.10336164f, 0.03501661f, -0.04194032f, -0.02490371f, 0.11206806f, 
    -0.13704640f, 0.17858419f, -0.02706653f, -0.01557812f, -0.11712041f, -0.08855300f, -0.05112205f, 0.31162339f, 
    0.04733989f, 0.04907711f, -0.51176327f, -0.16940273f, -0.13276181f, 0.24697426f, -0.10232875f, 0.03007953f, 
    -0.40207660f, -0.09871818f, 0.15654245f, 0.19540010f, -0.17899117f, 0.19963819f, -0.07543170f, 0.12515332f, 
    -0.10052671f, -0.21341869f, 0.20801710f, -0.09448215f, -0.13545239f, 0.11213902f, -0.14171480f, 0.12964687f, 
    0.40203586f, 0.15196885f, -0.18850319f, -0.23226239f, -0.03390576f, 0.08316426f, 0.09087609f, -0.21595560f, 
    -0.16186613f, 0.09244067f, -0.19282216f, 0.10166027f, -0.04411313f, -0.18444572f, 0.03190951f, 0.01664728f, 
    0.00944148f, -0.08921435f, 0.05842222f, -0.27088478f, 0.07755931f, 0.12233745f, -0.00811513f, -0.14186154f, 
    -0.20040727f, -0.06733873f, 0.03530941f, -0.00027640f, -0.16437313f, -0.03683875f, 0.41908830f, -0.03056796f, 
    -0.36674279f, 0.23709773f, -0.05649598f, 0.00626902f, 0.10249586f, 0.09878734f, 0.20861110f, 0.27321950f, 
    -0.24586432f, 0.14547835f, 0.17548263f, 0.06673387f, 0.19459203f, 0.41777194f, 0.37326035f, -0.27776650f, 
    -0.23292093f, -0.01043537f, 0.00321026f, -0.11423102f, 0.30902743f, 0.00164726f, 0.09410053f, 0.26583126f, 
    -0.31747308f, 0.12886196f, -0.04188085f, 0.04553301f, -0.14868705f, -0.10950359f, 0.06638829f, 0.29617965f, 
    0.12122845f, 0.33694568f, -0.23758748f, 0.07890049f, -0.09401848f, 0.13889064f, -0.17684042f, 0.06372628f, 
    -0.51547110f, 0.02402020f, -0.38680339f, 0.05074804f, -0.06748674f, 0.29125759f, 0.05348409f, -0.06503528f, 
    0.25419182f, 0.06865200f, -0.06081242f, 0.04114718f, -0.34541202f, 0.32768586f, -0.10964694f, -0.06032353f, 
    -0.02747991f, -0.31328890f, 0.07385290f, 0.04346240f, -0.06856062f, -0.13123696f, -0.10159210f, 0.32063219f, 
    0.19382286f, 0.24310531f, 0.18675430f, 0.12919356f, -0.08852416f, -0.55690974f, -0.33178863f, 0.04184623f, 
    -0.30692831f, -0.00847176f, 0.20809723f, 0.13570713f, -0.05811041f, -0.04798676f, -0.21120283f, -0.01959578f, 
    -0.27599663f, -0.13661124f, 0.13633598f, -0.32117087f, 0.25519016f, 0.15604575f, -0.13520512f, -0.04507677f, 
    0.15676743f, 0.03730664f, -0.15415373f, 0.04768428f, 0.13203254f, -0.00118782f, 0.15826426f, -0.16533813f, 
    -0.06046608f, -0.22076420f, 0.14694747f, 0.00953448f, 0.13874938f, -0.43047515f, 0.32736030f, -0.06322144f, 
    -0.27400443f, 0.16530471f, 0.34158903f, -0.04629128f, 0.15128568f, 0.18000446f, 0.37407401f, -0.24725710f, 
    0.22563878f, -0.21306293f, 0.05037510f, -0.02849486f, 0.07509718f, 0.07770829f, -0.05991298f, 0.01198129f, 
    0.22859059f, -0.06100002f, -0.00620785f, 0.04234486f, -0.09117878f, -0.16595893f, -0.11799454f, -0.19654082f, 
    0.42867863f, -0.05273257f, -0.25735009f, -0.14709921f, 0.06059109f, -0.60961133f, 0.01206456f, -0.08060027f, 
    -0.10681525f, 0.25516632f, 0.05046852f, 0.15646024f, -0.07797729f, -0.15792853f, 0.23966496f, 0.12027211f, 
    -0.44567549f, -0.07272670f, 0.13068868f, 0.13799085f, -0.54600388f, -0.11317277f, -0.07944158f, 0.38614526f, 
    0.05583101f, 0.08964670f, 0.27835912f, 0.13367061f, 0.15988237f, -0.05752806f, -0.49592584f, -0.02730357f, 
    0.40782726f, 0.07600181f, 0.10515421f, -0.13625711f, 0.12088116f, 0.29981062f, 0.29606470f, -0.28618076f, 
    0.37555772f, 0.24209030f, -0.42540729f, -0.15758944f, -0.20093533f, 0.31322846f, 0.18406543f, 0.06444433f, 
    -0.21414916f, -0.04780068f, -0.12810530f, -0.10350788f, 0.12326857f, -0.16323267f, -0.16593751f, 0.20882963f, 
    -0.01192309f, 0.49230686f, -0.36060226f, -0.07783847f, 0.13298452f, 0.04852077f, -0.54076248f, -0.33539063f, 
    0.16349499f, 0.27877548f, 0.52047068f, 0.09227075f, -0.10849171f, -0.19133271f, 0.35885972f, 0.21544124f, 
    0.33584672f, 0.10473794f, -0.45055145f, 0.00388977f, -0.24426602f, 0.36917877f, 0.25900486f, -0.01913036f, 
    0.21058623f, -0.20403536f, 0.15583226f, 0.36817181f, -0.37649179f, 0.35459498f, -0.07313410f, -0.14430389f, 
    0.04993188f, -0.18960111f, 0.21372342f, 0.15346915f, -0.09822340f, 0.06126527f, -0.24967630f, -0.09089401f, 
    0.15418085f, 0.05659582f, 0.01770616f, 0.35702741f, -0.10364892f, 0.39873955f, 0.02535735f, 0.10331081f, 
    -0.11378556f, 0.02493987f, 0.55709410f, -0.11060273f, 0.17711030f, -0.04048204f, 0.22698335f, 0.00663144f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.13624424f, 0.25365207f, 0.08610755f, 0.06299596f, 0.06708939f, 0.25636512f, 0.05413077f, 0.30883238f, 
    0.17835940f, 0.13298181f, 0.24399270f, -0.08126976f, -0.11275162f, 0.10032851f, 0.16087011f, -0.11103184f, 
    -0.10212379f, 0.20434891f, -0.00683630f, -0.17433104f, 0.08725533f, 0.22500764f, -0.05104773f, 0.01536228f, 
    -0.06415796f, 0.10679021f, 0.02151650f, -0.11921794f, 0.15113430f, 0.11492702f, 0.07160205f, -0.15724736f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.06414822f, -0.46936131f, -0.51042789f, 0.25766152f, -0.14203317f, 0.30455875f, -0.12486887f, -0.35279149f, 
    0.13272701f, -0.57023007f, -0.37608278f, -0.19239050f, 0.26140901f, 0.41255867f, -0.33812293f, -0.42207295f, 
    -0.21338278f, -0.13342777f, 0.19789562f, -0.14153980f, 0.16253114f, -0.41241112f, 0.04411280f, -0.34857014f, 
    0.22902547f, -0.03754008f, -0.51940548f, 0.31331575f, 0.15629849f, -0.21916446f, 0.29082453f, 0.15181966f, 
    0.08752275f, -0.02465895f, -0.04528724f, -0.30561984f, 0.28517935f, 0.21737234f, 0.20547886f, -0.45431554f, 
    0.31328490f, 0.01958549f, 0.00447254f, 0.16896218f, 0.07128118f, 0.48024896f, 0.11116297f, -0.10011467f, 
    -0.20824869f, -0.63549286f, 0.08790434f, -0.20186751f, -0.18146530f, 0.35940239f, -0.08027659f, -0.07384963f, 
    0.11302006f, -0.12337451f, -0.39450440f, 0.34013322f, -0.03261288f, 0.04743849f, -0.59315747f, 0.13203438f, 
    -0.16566592f, -0.10641452f, 0.43401006f, -0.36798730f, 0.10426053f, -0.58628362f, 0.31978023f, 0.14951438f, 
    0.31592795f, 0.17020203f, -0.05709088f, -0.47120923f, 0.12374504f, -0.53250915f, -0.17265953f, -0.01445994f, 
    0.01982675f, 0.24888389f, -0.02323077f, 0.08089146f, -0.63153261f, -0.06396432f, -0.42849526f, -0.48721987f, 
    0.22110043f, -0.30490735f, 0.38249737f, -0.02708244f, 0.24071243f, -0.25266999f, -0.12401827f, 0.32479790f, 
    0.06356869f, 0.09297347f, 0.00242576f, 0.27920204f, -0.34846255f, 0.16711210f, -0.13071002f, -0.02426713f, 
    -0.22363438f, -0.40733573f, -0.20704846f, 0.09769291f, -0.37063602f, 0.15821667f, 0.05069275f, -0.58234143f, 
    0.06827776f, 0.34323394f, 0.21435969f, 0.02898603f, 0.21950084f, -0.26287112f, -0.19972327f, -0.31676427f, 
    -0.24754141f, -0.67733270f, 0.02234628f, -0.37151808f, 0.09369524f, -0.09478901f, 0.12117960f, 0.28803238f, 
    0.21876244f, 0.08086589f, 0.10744265f, -0.04910337f, -0.09591708f, 0.16187261f, 0.22733189f, -0.51385826f, 
    -0.33107951f, -0.31106439f, -0.08182999f, 0.01854709f, -0.40689522f, -0.09069154f, 0.03216106f, 0.19035470f, 
    0.22726849f, 0.15134519f, -0.04816586f, -0.08663664f, -0.27364701f, -0.12180917f, 0.38831830f, -0.07978175f, 
    -0.00920078f, 0.26955125f, -0.62821603f, -0.08987886f, -0.05208335f, -0.03653558f, 0.26880649f, -0.32580391f, 
    0.23926882f, 0.14180326f, -0.37601954f, 0.13826156f, -0.17142405f, -0.07138190f, -0.01515645f, -0.12051351f, 
    0.12945709f, 0.38245931f, 0.01683150f, 0.06140241f, 0.11071425f, 0.04280435f, 0.07910901f, -0.30769598f, 
    -0.35586944f, -0.19669567f, -0.13332123f, -0.14944212f, 0.01286596f, -0.56074470f, 0.34764907f, 0.03655428f, 
    0.17115927f, 0.38173983f, 0.20460580f, -0.39871183f, -0.10267727f, -0.61425287f, 0.02647415f, -0.11682006f, 
    -0.89978462f, 0.02336105f, 0.08264948f, -0.37728098f, 0.44417679f, -0.49321377f, 0.20212944f, 0.36347011f, 
    0.09750774f, -0.17959987f, 0.16459525f, -0.31516069f, 0.07461345f, -0.45241410f, -0.13459347f, -0.11274419f, 
    0.22340617f, 0.12251522f, -0.51096582f, 0.11511609f, 0.35683638f, -0.20828064f, -0.22071937f, -0.33030868f, 
    -0.20317128f, -0.39195076f, -0.43580726f, -0.17049316f, -0.35117283f, 0.12536332f, -0.38456666f, -0.37110084f, 
    0.12351692f, -0.16911697f, -0.50967216f, 0.01556615f, -0.11067359f, -0.07230396f, -0.06162579f, -0.22223803f, 
    -0.53433102f, 0.16077311f, 0.19517611f, -0.11305749f, -0.30735797f, 0.13955247f, -0.45600829f, 0.17870049f, 
    0.15595351f, -0.11403463f, 0.07304399f, 0.03493302f, -0.85021842f, -0.30604666f, -0.04456186f, 0.14081109f, 
    -0.13339226f, 0.14262813f, -0.31755164f, -0.61326212f, -0.54388046f, 0.32365483f, 0.03209309f, 0.61746907f, 
    -0.60025412f, 0.08770777f, -0.56751573f, 0.33036795f, 0.07082450f, -0.29208294f, -0.60884440f, 0.15852647f, 
    0.06428163f, 0.23058079f, 0.17389089f, 0.37977365f, -0.45555305f, -0.04807403f, -0.05185415f, -0.31998351f, 
    -0.39686561f, -0.30790016f, 0.00729619f, 0.01687628f, 0.21805677f, -0.04158051f, -0.64286333f, -0.27164784f, 
    -0.50044626f, -0.31397405f, 0.32501620f, 0.12872252f, 0.23480967f, -0.41601297f, -0.25592080f, 0.18653095f, 
    -0.00953104f, -0.30360603f, 0.03930300f, -0.63197690f, 0.02386562f, 0.25044748f, -0.10534810f, 0.18651102f, 
    -0.39660969f, 0.31580704f, 0.19821520f, -0.54023075f, -0.55317312f, -0.39450642f, -0.43770128f, -0.30393144f, 
    0.04594830f, 0.12804762f, -0.18204123f, -0.12261450f, 0.05491680f, 0.08375870f, 0.13435629f, -0.15968026f, 
    -0.16867442f, 0.22448988f, -0.35576248f, 0.01974767f, -0.23169291f, 0.10487387f, 0.49459350f, -0.75159156f, 
    0.02938933f, 0.36487982f, 0.44935668f, 0.15142924f, 0.13084492f, 0.05401932f, -0.45174929f, 0.14405113f, 
    0.25747105f, -0.40920520f, -0.59023708f, -0.17534624f, -0.50549191f, -0.15273145f, 0.29174814f, -0.66261780f, 
    -0.41172433f, -0.38128719f, 0.27046207f, 0.05921232f, -0.23322985f, 0.40479526f, 0.03987851f, -0.16943841f, 
    -0.20661297f, 0.28513947f, 0.25323039f, -0.17855248f, -0.40652034f, -0.52936006f, -0.37677091f, 0.09615609f, 
    0.03553287f, 0.17480962f, 0.33172300f, -0.17065220f, 0.00990302f, -0.23040116f, -0.26668140f, 0.02744634f, 
    0.13093863f, -0.12739587f, -0.06340338f, 0.18293540f, -0.84446371f, -0.35011396f, 0.25297636f, 0.01405188f, 
    -0.12038723f, -0.11830891f, -0.64155382f, -0.13302147f, 0.39758414f, 0.27412891f, -0.30314335f, 0.48633859f, 
    -0.55620170f, 0.11721721f, 0.02031301f, 0.25408456f, 0.49173129f, 0.30311888f, 0.03909486f, -0.04858540f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.19614898f, 0.02402506f, 0.19677831f, -0.08606923f, -0.15014578f, 0.00004401f, -0.10956773f, -0.04769179f, 
    0.03135677f, 0.04483684f, -0.17846814f, -0.08808026f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
