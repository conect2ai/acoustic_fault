#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.37057820f, -1.02705276f, 0.11126371f, 0.79699552f, 0.55298024f, 0.94299603f, 1.27755439f, 0.04982621f, 
    0.51055878f, 0.30984625f, -0.09541724f, 0.31347671f, -0.15652454f, 0.08857052f, -0.06635522f, -0.17671904f, 
    -0.16540100f, -0.13174191f, -0.18514414f, -0.26270291f, -0.07430897f, -0.19409741f, -0.06012169f, -0.28826344f, 
    -0.30571842f, -1.50354803f, -0.16473714f, -0.53140789f, -0.27358210f, -0.81570357f, 0.09413625f, 0.14713088f, 
    -0.14253891f, 0.31931487f, 0.07729554f, 0.11938016f, -0.19971153f, 0.01028435f, 0.53911817f, 0.20398274f, 
    0.07555015f, -0.09163081f, -0.00383139f, 0.08177650f, -0.10284232f, 0.23699427f, -0.06824768f, -0.02686560f, 
    0.06697574f, 0.34163418f, -0.49114123f, -0.22399524f, -0.96807289f, 0.14144403f, 0.67124677f, -0.19212560f, 
    0.28862882f, 0.92832464f, 0.25445136f, 0.15999834f, 0.40132540f, -0.30182192f, -0.06593916f, -0.28938541f, 
    0.39012295f, -0.37625608f, -0.13397643f, -0.11282730f, -0.25904691f, -0.05212180f, 0.03939350f, -0.17789549f, 
    -0.30147457f, -0.06796303f, -0.05250385f, 0.55570060f, -0.51175600f, 0.48354122f, 1.07897663f, -0.33073252f, 
    0.35567778f, -0.97688502f, 0.02082676f, -0.45240071f, -0.42290461f, -0.11573613f, -0.34370813f, 0.18800870f, 
    -0.27201623f, -0.06946106f, -0.24083830f, 0.00463910f, 0.28811154f, -0.13699879f, 0.07548858f, 0.01429981f, 
    -0.29654777f, 0.22171508f, -0.31008217f, -0.23929924f, 0.64007664f, -0.92310125f, -0.69420511f, 0.62727088f, 
    0.47151953f, -0.76867354f, -0.58962584f, -0.04701376f, -0.16789256f, 0.07509606f, -0.30568090f, 0.17225839f, 
    0.26383567f, 0.16896090f, 0.24382652f, -0.16878600f, 0.22060795f, 0.11470246f, 0.24198034f, -0.01972235f, 
    0.08135649f, -0.08289511f, 0.14708258f, -0.30793834f, -0.17719992f, -1.13720500f, 0.67595130f, -0.30683208f, 
    -0.32608184f, 0.70048654f, -0.91026300f, 0.58337635f, 0.68822706f, -0.33406925f, -0.35298741f, -0.23292984f, 
    -0.36525643f, 0.18718149f, -0.50566792f, 0.13664894f, 0.34000063f, 0.00602370f, 0.16637871f, -0.07941370f, 
    -0.43711987f, -0.11824837f, 0.02994309f, -0.05332690f, 0.24595483f, -0.41636860f, 0.90274823f, 0.73010486f, 
    0.80243176f, 0.98709524f, 0.17648292f, -0.52473491f, -0.42226467f, -0.84683722f, -0.23889199f, 0.54919094f, 
    0.28893903f, 0.36716601f, -0.11084090f, 0.05531758f, -0.49215785f, -0.14115672f, -0.02603720f, 0.10839744f, 
    -0.29808906f, 0.07545242f, -0.17691040f, 0.48654208f, 0.17062548f, -0.08573256f, 0.07526190f, -0.41111195f, 
    0.87934977f, -0.62298602f, -0.62781698f, -0.31552875f, -0.60257745f, -0.27710238f, -0.59119916f, -0.57065529f, 
    -0.53560555f, 0.43963659f, 0.48070952f, 0.19180524f, 0.29268491f, -0.11132511f, -0.18682869f, -0.16751164f, 
    0.24853706f, -0.16977292f, -0.29301938f, 0.14761682f, 0.00108821f, 0.00114943f, 0.18221518f, 0.25092167f, 
    0.94637614f, 0.48248520f, 0.21979336f, 1.29224169f, 1.10785496f, 0.41148108f, 0.53187549f, 0.33436835f, 
    0.28013757f, 0.21277103f, -0.32047328f, -0.24328929f, 0.04277644f, -0.32843560f, -0.13809966f, -0.05929096f, 
    -0.19665109f, 0.10950073f, -0.08782443f, 0.23668538f, 0.13742338f, -0.22115019f, 0.25750235f, -0.03091567f, 
    -0.03618360f, -1.06686449f, -0.59207892f, 0.34903663f, -0.01376766f, -0.56780618f, -0.07689339f, -0.65375513f, 
    -0.51305008f, -0.10237157f, -0.26782706f, -0.00974165f, 0.14301865f, -0.02091801f, 0.30298820f, 0.35747331f, 
    0.08002312f, -0.18122382f, -0.40068272f, 0.15926841f, -0.15972808f, -0.04947500f, 0.26647750f, 0.16052070f, 
    0.02157429f, 0.17306776f, 0.81498140f, 0.75211680f, 0.71821386f, -0.08634970f, 0.25401017f, -0.61071366f, 
    -0.87900537f, -0.56223947f, -0.48179433f, -0.47733438f, -0.07118048f, 0.31781718f, 0.18011031f, 0.16973835f, 
    0.32600933f, -0.05975497f, -0.00291174f, 0.09051010f, 0.05302817f, 0.46815914f, 0.12593091f, 0.26774788f, 
    -0.01702810f, 0.24041158f, 0.36157054f, 0.30529541f, 0.65319806f, -0.45140651f, -0.95683384f, -0.64366406f, 
    -0.56142277f, -0.19245778f, 0.47096688f, 0.22811599f, -0.41081527f, -0.40503281f, 0.52175033f, -0.05906071f, 
    -0.18684566f, -0.21021940f, 0.14145605f, 0.08901401f, 0.04567436f, -0.05697453f, -0.24998845f, 0.18772735f, 
    -0.14383152f, 0.04616493f, -0.12423462f, 0.19910796f, -1.56465173f, 0.77041417f, 0.50040632f, -0.67810732f, 
    0.40139762f, 0.72447467f, 0.18275787f, -0.54603475f, 0.05173768f, -0.47991350f, 0.01736192f, 0.17807429f, 
    0.22402753f, 0.12102197f, -0.09036963f, -0.40719533f, -0.17409024f, -0.23949525f, -0.46048760f, -0.22210532f, 
    0.21881860f, 0.06947073f, 0.08208932f, 0.19639064f, -0.24056005f, -0.00458964f, -0.43408975f, 0.12778744f, 
    -0.07326841f, 1.09889734f, 0.54057086f, -0.09992026f, -0.03897474f, -0.82029176f, -0.08432896f, 0.17689630f, 
    0.30010632f, 0.56663907f, 0.27194855f, -0.12388121f, 0.27144492f, 0.35292184f, 0.44109580f, 0.50053883f, 
    -0.04647480f, 0.01495202f, 0.18484367f, 0.10718381f, -0.03510005f, -0.20271234f, -0.00829608f, -0.43136388f, 
    -0.12657647f, -0.19369654f, -0.26486081f, 0.23196606f, -0.64383674f, -0.52612841f, -0.12930210f, -0.30482557f, 
    0.15084864f, 0.56702167f, 0.39947900f, 0.13413469f, 0.27814108f, -0.28407606f, -0.12885703f, 0.20943648f, 
    0.37419432f, 0.66187435f, 0.03221465f, 0.10318010f, -0.13439089f, 0.18903555f, 0.07752386f, -0.37922248f, 
    -0.91048598f, -0.95821846f, -0.71132344f, -0.37971407f, 0.21277793f, 0.28787047f, 0.27084887f, 0.63265967f, 
    0.58866376f, -0.57984084f, -0.39856687f, 0.20557466f, -0.39310929f, -0.46442777f, -0.39995888f, -0.21136431f, 
    0.15500049f, 0.16797827f, -0.25812826f, -0.35417753f, 0.08391037f, -0.49988967f, 0.04780956f, 0.39547986f, 
    -0.44840547f, 0.32596377f, 0.74237651f, 0.36888635f, -0.78821522f, -0.92923737f, -0.29703093f, 0.55374366f, 
    0.25379345f, -0.04452656f, -0.19042984f, 0.32215226f, 0.02168739f, -0.08510940f, -0.17484921f, -0.32246464f, 
    0.19723251f, 0.26810250f, 0.25212902f, -0.11948492f, -0.11940261f, -0.37405300f, -0.41770467f, -0.48290336f, 
    -0.11000910f, -0.67455673f, 0.77141535f, -0.47980529f, -0.76210511f, -0.88506776f, 1.17195463f, 0.62463486f, 
    0.29052857f, 0.44539925f, 0.71659178f, -0.03720975f, -0.54466236f, -0.21707557f, 0.01553685f, 0.03810996f, 
    -0.03717140f, 0.19389401f, 0.14769231f, 0.06045467f, -0.03365494f, -0.05856329f, -0.44926631f, -0.03315037f, 
    -0.30525574f, -0.15675785f, 0.12007841f, -1.00774419f, -0.27066794f, 0.12906884f, 0.51057559f, -0.57727844f, 
    0.49602550f, -0.51504129f, -0.42296162f, 0.48244652f, -0.09564272f, 0.25266159f, -0.48647046f, -0.06569736f, 
    -0.35431656f, -0.17669889f, -0.12229701f, -0.44402537f, -0.51340580f, -0.56357366f, -0.19718106f, -0.30364439f, 
    0.32376742f, -0.08648980f, -0.06096782f, 1.21169221f, 0.00754845f, -1.23806322f, -0.93558317f, 0.05318566f, 
    -0.51223046f, 0.36419624f, 0.10730056f, 0.17585188f, 0.20807309f, -0.24741648f, -0.32617345f, 0.20347388f, 
    -0.27808434f, -0.13590254f, 0.28565019f, -0.12700868f, -0.05101764f, 0.05829541f, 0.43582588f, 0.01309982f, 
    0.17707017f, 0.35934988f, 0.19494699f, -0.47579852f, 1.05213642f, 0.33619347f, 0.29409164f, 0.32212004f, 
    0.05297057f, 0.14114256f, -0.34973073f, 0.48237947f, 0.31809857f, 0.19923203f, -0.58749044f, 0.11361087f, 
    -0.53583014f, -0.24956767f, -0.37945613f, 0.61720818f, 0.26415101f, -0.49224323f, -0.16874230f, 0.19941090f, 
    -0.42517525f, 0.12743565f, 0.55481225f, 0.24266770f, -0.28198695f, -0.34155056f, -1.20396101f, -0.07780736f, 
    -0.00699500f, 0.17135081f, -0.61384732f, 0.90244401f, 0.87471455f, -0.84808308f, 0.42756966f, -0.06481948f, 
    0.02654985f, 0.07935951f, -0.02027952f, 0.15803699f, -0.42984128f, -0.10182469f, -0.17358890f, 0.17113812f, 
    -0.06947246f, 0.50207794f, -0.01671276f, 0.02297023f, 0.39182830f, 0.01175199f, 1.24676335f, 1.07146287f, 
    -0.13631095f, 0.33121467f, -0.75032347f, 0.13787830f, 0.47206983f, -0.45161924f, 0.41765380f, 0.38165969f, 
    0.54952943f, 0.06061589f, -0.16833019f, -0.08485609f, -0.42513204f, 0.04648052f, -0.22129120f, 0.02527886f, 
    0.19253345f, 0.24751745f, -0.04259003f, -0.03675779f, 0.08464339f, -0.23159763f, 0.30599836f, -1.05939341f, 
    0.94854558f, 0.59989935f, -0.48392025f, 0.32168424f, -0.50140476f, 1.09422934f, 0.21893550f, 0.27895039f, 
    0.46044090f, -0.81240159f, 0.39309162f, -0.15771113f, -0.12706363f, 0.03409889f, 0.23050171f, -0.00767090f, 
    -0.20630643f, 0.17630005f, 0.22759123f, -0.08977097f, 0.02331037f, 0.12737595f, 0.15457407f, 0.19721891f, 
    -0.32909769f, -1.28018558f, 0.63025999f, 0.26548591f, -0.82791597f, 0.62366408f, 0.39584178f, 1.01412261f, 
    -0.36819270f, 0.06603235f, -0.08573926f, -0.36977094f, -0.36498302f, 0.21455148f, -0.17892827f, 0.18446042f, 
    0.21391939f, -0.03810808f, -0.21071033f, 0.02590080f, -0.23396212f, 0.16734149f, 0.35955173f, -0.05574927f, 
    -0.05813737f, -0.02363208f, -1.02200460f, -0.78134793f, -0.33652294f, -0.53420550f, -0.06921659f, 0.21125263f, 
    -0.25148484f, 0.62392300f, 0.37563911f, 0.43713024f, -0.08923694f, -0.40422955f, 0.09990609f, -0.28730565f, 
    0.12875457f, 0.28852093f, 0.00081928f, 0.20621839f, 0.18372720f, 0.16746585f, 0.30155423f, 0.15128212f, 
    -0.02642348f, 0.45173228f, 0.34067038f, 0.73979145f, -0.22971939f, 0.73219055f, 0.48820159f, -0.82380521f, 
    -0.19932434f, 0.34163192f, 0.26261181f, -0.22985843f, -0.65871710f, -0.08590644f, 0.15087700f, 0.74763298f, 
    -0.19064964f, 0.21787076f, 0.04000671f, -0.04965059f, -0.30277175f, -0.07188237f, -0.34521493f, -0.14920358f, 
    -0.39440998f, -0.18616939f, -0.29670990f, 1.45958078f, 0.27042142f, 0.38268325f, 0.52646482f, 0.19153327f, 
    -0.38053966f, -0.47467661f, 0.37714434f, -0.25735548f, -0.25051448f, -0.08398423f, -0.05446691f, 0.03428039f, 
    -0.23970415f, 0.17929620f, 0.46461478f, -0.36058974f, -0.09629937f, 0.34775415f, 0.02125829f, 0.19446412f, 
    -0.11647752f, -0.02829833f, -0.09194250f, 0.26143169f, 0.57980424f, 0.09515347f, -0.29640183f, 0.35059431f, 
    0.39725175f, 0.10306134f, 0.29390490f, -0.37967250f, 0.21517052f, 0.03780647f, -0.17470369f, 0.62757486f, 
    0.15034017f, 0.03373103f, 0.67055696f, 0.31478634f, -0.16799884f, -0.44277972f, -0.43428379f, -0.12754644f, 
    0.01860109f, 0.04192204f, 0.11739199f, 0.46377534f, -0.11948821f, -0.68191785f, -0.61000615f, 0.52307773f, 
    0.81506717f, 0.00499584f, -0.14358824f, 0.37959000f, 0.46293816f, -0.36395994f, -0.70078295f, 0.43756211f, 
    0.04708210f, 0.37859768f, 0.32349452f, 0.11614414f, 0.02349582f, 0.64468437f, 0.08053657f, -0.29956749f, 
    0.08400542f, -0.23639488f, 0.29748660f, -0.26679376f, 0.14037909f, 0.35249612f, 0.10206631f, -0.46836054f, 
    -0.61781174f, -0.96666688f, 0.24885105f, -0.29883555f, -0.81870943f, -0.23265864f, -0.43235588f, -0.23822027f, 
    0.00351352f, -0.19392002f, 0.25861388f, -0.12289787f, -0.45179176f, 0.43612355f, -0.35668132f, -0.37096789f, 
    0.36734945f, 0.32890752f, 0.15970051f, 0.45691660f, -0.00160208f, -0.05704596f, 0.40817162f, 1.00152242f, 
    -0.25146306f, -0.86481321f, -0.86311251f, -0.77984124f, -0.10877902f, 0.02461842f, -0.09282120f, -0.33918318f, 
    -0.52954227f, 0.26344809f, -0.14264780f, 0.46289223f, -0.12148257f, 0.35414472f, -0.02170798f, 0.44749993f, 
    0.18934830f, 0.03134934f, -0.15892750f, 0.00358091f, -0.03880581f, -0.19740200f, -0.09851362f, 0.25755039f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07097048f, 0.25927502f, 0.10497658f, 0.03026967f, 0.10498507f, 0.09867927f, -0.01764125f, 0.25598982f, 
    0.31960717f, 0.29000172f, 0.35467443f, 0.20401616f, 0.03507570f, 0.24888183f, 0.16711967f, 0.07335870f, 
    0.10844567f, 0.15779381f, 0.10726213f, 0.23117818f, 0.05740328f, 0.14026479f, 0.22730021f, -0.04578987f, 
    -0.03038934f, 0.10736682f, 0.06221229f, -0.06600319f, 0.06430045f, 0.16360523f, 0.25071907f, 0.15074158f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.28397745f, 0.21865779f, 0.12187564f, 0.15285808f, 0.03080775f, 0.05743335f, 0.09885491f, -0.04483504f, 
    -0.08101121f, 0.08916116f, 0.03726545f, 0.07041415f, 0.56484449f, 0.14695947f, -0.15745862f, -0.22416203f, 
    -0.05941440f, 0.00866038f, -0.12546022f, 0.13192466f, 0.12564985f, -0.14448011f, -0.13028249f, -0.04089561f, 
    -0.31424659f, 0.36410192f, 0.08745149f, -0.02955549f, -0.11170503f, -0.00950400f, 0.08940409f, -0.00658291f, 
    -0.05061316f, -0.07850166f, -0.09613682f, 0.10103751f, 0.21708758f, -0.11980465f, -0.28023875f, 0.38063285f, 
    -0.05054196f, 0.13333513f, 0.02664335f, 0.02795462f, -0.13371469f, -0.00914344f, -0.19884270f, -0.00327158f, 
    0.12286108f, -0.37056753f, 0.13788182f, 0.41150245f, -0.04969026f, 0.11476726f, 0.03633701f, 0.04516860f, 
    -0.13262439f, -0.03311271f, -0.04329275f, 0.07920035f, -0.25436914f, 0.25058109f, 0.13790743f, -0.09712443f, 
    0.03570208f, -0.10515343f, -0.03308598f, -0.09626551f, -0.06016482f, 0.00824244f, -0.05955472f, -0.00424848f, 
    0.15222479f, -0.05259002f, -0.04641422f, 0.31876439f, -0.23946993f, -0.12720330f, -0.08098900f, 0.03894211f, 
    -0.03207501f, 0.20012361f, 0.01345778f, -0.00722265f, -0.42097652f, -0.01761804f, 0.09095125f, -0.00948282f, 
    -0.05357533f, 0.00573757f, 0.03831116f, -0.08257386f, -0.06583833f, -0.04586896f, -0.04599275f, 0.09194889f, 
    0.12293405f, -0.03559289f, -0.17947401f, 0.43056488f, -0.31834814f, 0.05994049f, -0.08352526f, -0.01781739f, 
    0.01790478f, 0.08784759f, -0.14046356f, -0.03808428f, -0.65320295f, -0.03664079f, -0.10709026f, 0.11901542f, 
    0.02278625f, -0.04269192f, -0.00823107f, 0.09299583f, 0.04854220f, 0.04940814f, -0.10063522f, -0.07503737f, 
    0.12604141f, 0.15061943f, 0.17933749f, -0.17729495f, -0.06037228f, -0.03655293f, -0.06279066f, 0.05316432f, 
    0.04817405f, -0.12819900f, -0.09768594f, 0.03876621f, -0.18267035f, 0.16162401f, -0.07251161f, -0.46164384f, 
    0.06923852f, -0.10197839f, -0.10662270f, -0.11130972f, -0.04792314f, -0.04351371f, -0.05043207f, -0.10883258f, 
    -0.09737735f, -0.28753635f, 0.28294554f, -0.04567043f, -0.00302640f, -0.05536236f, 0.10662075f, -0.07486770f, 
    0.01857438f, -0.03204889f, 0.04186269f, 0.06058247f, -0.24865864f, -0.20806725f, 0.08321389f, -0.22122326f, 
    0.01524322f, 0.21842620f, -0.10112056f, -0.18816097f, -0.08771931f, 0.25176930f, -0.08243349f, -0.11649930f, 
    -0.21684912f, -0.22681557f, 0.09276769f, -0.13948697f, 0.01557058f, 0.05234587f, 0.13928689f, -0.10750460f, 
    0.14894962f, -0.04327191f, -0.09555376f, 0.02206776f, 0.22628653f, 0.25830883f, -0.22207217f, -0.29995674f, 
    0.15158616f, 0.06116568f, 0.19882450f, 0.05233721f, -0.05110334f, -0.00420691f, -0.02447198f, -0.00666504f, 
    -0.36986312f, 0.12488192f, -0.19659452f, 0.33186737f, -0.01838800f, -0.08469735f, 0.08025281f, -0.13583821f, 
    0.05465931f, -0.06483816f, -0.01347069f, 0.05852610f, 0.57580471f, -0.02429351f, 0.02474124f, -0.33891171f, 
    0.12058983f, 0.15359053f, 0.05928015f, 0.01631001f, 0.05538847f, -0.05503943f, -0.11066785f, -0.03108022f, 
    -0.11969583f, -0.13602483f, 0.15577255f, 0.21394208f, -0.12661155f, -0.04144144f, -0.05038152f, -0.10470103f, 
    -0.15794952f, 0.11473570f, 0.02164079f, -0.14977615f, -0.10359915f, 0.15756057f, 0.15284146f, -0.41301104f, 
    -0.13707539f, 0.03700142f, 0.04939170f, 0.01076716f, -0.14072205f, -0.03591136f, 0.19116379f, -0.02442142f, 
    0.34792534f, -0.13837674f, -0.13841636f, 0.04147634f, -0.18807413f, -0.04063118f, -0.26086745f, 0.12105596f, 
    -0.17869128f, -0.03934349f, 0.09136678f, -0.09129713f, -0.49097094f, 0.18543784f, -0.16826309f, -0.08237441f, 
    -0.00155589f, 0.02632320f, -0.29510245f, 0.03316318f, 0.09501012f, 0.05829054f, -0.04703226f, 0.04931890f, 
    -0.01979735f, 0.02651234f, -0.00011852f, 0.00995946f, -0.10790642f, 0.09650265f, -0.05487674f, 0.17880498f, 
    0.09231391f, 0.07566679f, -0.09669262f, -0.03195865f, 0.05134480f, -0.05960865f, 0.14335336f, -0.02456208f, 
    0.02637185f, 0.13672464f, -0.04635421f, -0.06071768f, -0.04630621f, -0.08162850f, -0.05907646f, 0.09970649f, 
    -0.23966289f, 0.29188085f, 0.15412451f, -0.04997609f, -0.08943849f, 0.15285891f, 0.15693952f, 0.00650852f, 
    0.07257956f, -0.02686504f, 0.04591646f, -0.15918310f, -0.00148080f, -0.04331635f, -0.21303520f, -0.21950161f, 
    0.07727680f, 0.05042012f, 0.15577288f, 0.07310677f, 0.04455653f, 0.14364089f, -0.04031586f, 0.00625475f, 
    0.21324885f, 0.15441062f, -0.13791153f, 0.04613556f, -0.12656392f, -0.03353173f, 0.02011742f, 0.03807891f, 
    0.07629476f, 0.02322474f, 0.02777014f, -0.12979397f, 0.24308394f, -0.10043731f, -0.10095154f, -0.04673744f, 
    -0.08366312f, -0.11239899f, -0.20284685f, 0.12420698f, -0.07196330f, 0.00453354f, 0.13151832f, -0.06592595f, 
    0.08860774f, -0.23529723f, 0.09391160f, -0.04278805f, -0.10955518f, -0.12103777f, 0.03021869f, 0.11382376f, 
    0.06035987f, 0.14466932f, 0.11932331f, -0.16137244f, -0.22351933f, 0.20286970f, -0.13316746f, 0.25407949f, 
    -0.04706356f, 0.02003000f, 0.09733266f, -0.05185610f, 0.05625149f, -0.06045681f, -0.12464539f, 0.00439186f, 
    -0.20626594f, -0.46145755f, 0.16364126f, -0.20668550f, -0.07055119f, -0.08443922f, 0.17100467f, 0.09100050f, 
    0.07576104f, -0.04356950f, 0.01242356f, -0.10141146f, -0.66907775f, -0.06910072f, 0.33653903f, -0.14528677f, 
    -0.01239264f, -0.06194973f, 0.14110737f, -0.13487275f, -0.11153190f, -0.04548148f, 0.00792877f, 0.07028694f, 
    0.56614357f, 0.01212088f, -0.00434630f, -0.01461376f, -0.00952439f, 0.12291884f, -0.06204715f, 0.03880294f, 
    -0.16040668f, 0.13755140f, 0.01273991f, 0.05976572f, -0.28916270f, 0.01268115f, 0.02458050f, 0.08115003f, 
    -0.03129290f, 0.05039711f, 0.02358231f, 0.16737925f, -0.03251698f, 0.09172165f, -0.04411122f, -0.01656123f, 
    0.46617460f, 0.10147256f, -0.07625020f, 0.03523495f, 0.16963550f, -0.01446780f, -0.26745120f, 0.07088376f, 
    0.01516661f, -0.02966884f, 0.09527432f, -0.17266019f, -0.29971391f, 0.04291733f, -0.22589536f, 0.05136229f, 
    0.01072546f, -0.07165779f, -0.00816739f, 0.01940808f, 0.17236334f, -0.06749306f, 0.15799886f, -0.07062710f, 
    -0.06030886f, -0.44325104f, 0.19258836f, -0.05800261f, -0.05883878f, -0.09929889f, -0.04154135f, 0.12467992f, 
    -0.13717416f, 0.11361474f, 0.01781968f, 0.07644289f, 0.24702734f, 0.05611163f, -0.13737606f, -0.58440357f, 
    0.09633455f, 0.26274112f, -0.19128598f, 0.07874556f, -0.01374423f, -0.06693053f, -0.06799098f, 0.04959922f, 
    0.28663051f, -0.09629007f, 0.18185011f, 0.05328040f, 0.05508626f, -0.12769637f, 0.14387663f, -0.00821837f, 
    0.01072657f, -0.13656794f, 0.07708900f, -0.12666929f, -0.15860678f, -0.18636177f, -0.16023071f, -0.28555429f, 
    -0.05424408f, 0.01828050f, 0.08270071f, 0.07107241f, 0.14383353f, 0.12555495f, 0.12440445f, 0.00798758f, 
    0.42437354f, -0.00551979f, 0.13892590f, 0.34193450f, -0.11847819f, 0.09799153f, 0.06752276f, 0.03115986f, 
    -0.08304568f, 0.11296155f, 0.05830039f, 0.10102409f, -0.34137625f, 0.20223504f, -0.00677850f, 0.06865595f, 
    -0.07279562f, -0.00941262f, 0.04300132f, 0.11335967f, -0.10632910f, 0.06141231f, -0.10319726f, 0.07908797f, 
    -0.02130982f, -0.04157694f, -0.09092771f, 0.06950872f, 0.01760661f, 0.09476679f, 0.12121045f, -0.02392294f, 
    0.01132820f, 0.10637616f, 0.03228394f, 0.14098363f, -0.05329975f, -0.17677559f, 0.00583409f, -0.50563049f, 
    -0.09466255f, 0.01595577f, -0.02123659f, 0.22166011f, -0.07484747f, -0.01420607f, 0.06479638f, 0.01882681f, 
    -0.54354203f, -0.01045190f, -0.18950142f, -0.11421816f, -0.06169228f, -0.03843996f, 0.01521464f, -0.04432440f, 
    -0.02931202f, -0.13912658f, -0.02124279f, -0.24183019f, 0.17531215f, 0.05944399f, -0.08859294f, -0.09163126f, 
    -0.09944003f, -0.09477177f, 0.00533678f, 0.09528691f, 0.10971311f, -0.19488545f, 0.10871723f, 0.02752377f, 
    -0.00824665f, -0.03026200f, 0.06538879f, -0.08572841f, -0.04760342f, 0.03840689f, -0.04790704f, -0.00937788f, 
    0.00053628f, 0.10870579f, 0.14014505f, -0.03595354f, 0.06380846f, -0.15178140f, 0.02971544f, -0.27300560f, 
    0.06520429f, -0.06257485f, -0.14293873f, 0.02931669f, 0.00349305f, -0.20065579f, -0.01000318f, -0.08120216f, 
    -0.29667601f, -0.16034803f, -0.33044803f, -0.19538751f, 0.15322532f, -0.06795838f, -0.19486450f, -0.11054854f, 
    -0.12061935f, -0.15418735f, -0.02775289f, 0.09280451f, -0.35509950f, -0.08428457f, 0.02262018f, -0.13687594f, 
    0.05411777f, -0.10333715f, -0.02795816f, 0.03144091f, 0.15736280f, 0.13060740f, 0.04115614f, -0.00095862f, 
    0.16277897f, -0.21131718f, 0.10910713f, -0.14397852f, -0.06635644f, 0.05153247f, 0.05430145f, -0.00170899f, 
    -0.08084089f, -0.35602561f, -0.14550973f, 0.02109216f, 0.52841705f, -0.36977309f, 0.20524432f, -0.53205281f, 
    0.02596657f, -0.21833488f, 0.01937455f, -0.04855245f, -0.15257035f, -0.03838462f, -0.06117771f, 0.04061933f, 
    0.27914992f, 0.03891969f, 0.11573739f, 0.20167243f, 0.00524461f, -0.16025001f, 0.06743027f, -0.01596351f, 
    -0.01078666f, -0.02719052f, -0.02036104f, -0.05873093f, 0.32973108f, -0.06305371f, -0.10961461f, 0.23931380f, 
    -0.07294132f, -0.00373397f, 0.06651377f, 0.03120086f, 0.18690829f, -0.04565047f, -0.01320735f, -0.00173364f, 
    0.50701576f, -0.14932755f, -0.04800769f, 0.08977225f, -0.21133319f, -0.22381668f, 0.01266709f, 0.09725286f, 
    -0.03931852f, -0.03046537f, -0.16479081f, 0.20205121f, -0.44420394f, 0.21364506f, -0.15819024f, -0.18442567f, 
    0.17198260f, 0.00091285f, 0.06302483f, -0.04957072f, 0.07170624f, 0.08367659f, 0.13681771f, -0.15424986f, 
    -0.38226557f, 0.05843206f, -0.37139925f, 0.19929315f, -0.10478175f, -0.13569607f, 0.06826912f, -0.06789365f, 
    0.08380717f, 0.06613708f, -0.08873013f, 0.06044557f, 0.12491079f, -0.14657839f, -0.30154133f, -0.10787319f, 
    -0.02627484f, -0.05489012f, -0.02211494f, 0.17544860f, 0.15446351f, 0.06559630f, 0.04936431f, 0.08004184f, 
    0.14571969f, -0.15123418f, -0.09576236f, 0.02134481f, 0.03998728f, -0.09914108f, -0.08055355f, -0.01588903f, 
    -0.09070946f, -0.15401892f, -0.18409252f, 0.04466610f, 0.29237735f, -0.01290031f, -0.00379122f, 0.24721758f, 
    -0.22365400f, -0.05295700f, 0.13945299f, 0.03260272f, 0.03725684f, -0.00068199f, -0.13773771f, 0.13311467f, 
    0.23819435f, 0.06256083f, 0.07320921f, -0.02438551f, -0.11430003f, 0.13814063f, -0.00027237f, -0.07994799f, 
    0.01680270f, -0.08183113f, -0.11501616f, 0.12484854f, -0.32537046f, 0.10210119f, -0.05798074f, 0.26173767f, 
    -0.09944775f, 0.13609336f, -0.13973945f, 0.01932481f, -0.03149339f, -0.00935542f, 0.06093921f, -0.08469957f, 
    -0.00297888f, -0.08814003f, 0.07022547f, -0.43377978f, 0.05969917f, -0.03313488f, 0.00915607f, -0.01456121f, 
    -0.18305998f, 0.16200249f, 0.00123242f, 0.11752925f, 0.44897321f, -0.22266883f, -0.00557356f, -0.13217680f, 
    0.08208200f, 0.13440350f, -0.13267711f, 0.02012467f, -0.03856563f, 0.09205713f, 0.12649065f, -0.01856168f, 
    0.32915366f, -0.24599716f, 0.21609850f, -0.01427346f, -0.09599818f, -0.02318687f, 0.05071726f, -0.03314449f, 
    0.08625714f, -0.04872618f, 0.02959504f, 0.04716253f, 0.32163453f, 0.22445370f, -0.08919437f, 0.04647071f, 
    -0.11099952f, -0.16569321f, -0.12879041f, 0.07153950f, -0.06296746f, 0.02729511f, -0.02529306f, -0.14896183f, 
    0.12065965f, 0.04328978f, 0.09512830f, 0.17697451f, -0.08455341f, -0.03139654f, 0.09044109f, -0.07887193f, 
    0.08354743f, 0.03546876f, 0.05702637f, 0.09355397f, -0.57758850f, -0.06328284f, -0.14582947f, -0.08610014f, 
    -0.13243733f, 0.19134708f, -0.24981900f, 0.02743162f, -0.10096806f, -0.09707297f, 0.03315403f, -0.12800649f, 
    0.41663060f, -0.36011446f, -0.04995301f, -0.24531248f, 0.02319475f, 0.04572420f, 0.05307557f, 0.06593380f, 
    -0.00888960f, -0.01774279f, -0.00535534f, -0.22398600f, 0.21635984f, -0.10319570f, -0.31171942f, -0.20538461f, 
    0.11478548f, 0.15800153f, -0.12906031f, -0.25356495f, 0.01645393f, -0.10157654f, 0.03539641f, -0.09398866f, 
    -0.16464366f, 0.23668365f, -0.06483233f, -0.01225680f, 0.05643814f, 0.09885776f, -0.04833322f, -0.05304427f, 
    -0.07700218f, 0.04680090f, -0.01923358f, 0.01994004f, -0.23713157f, 0.05648801f, -0.12334259f, -0.31309256f, 
    0.09838971f, 0.11218002f, 0.07405779f, -0.11962056f, -0.15878718f, 0.05789933f, 0.03635515f, -0.23088454f, 
    0.06017364f, -0.14834568f, 0.02564971f, -0.02096797f, 0.10027520f, 0.08563209f, 0.02491787f, -0.00197846f, 
    -0.03031075f, 0.03342255f, 0.11933722f, 0.12634052f, 0.30982772f, -0.02887793f, -0.22735260f, -0.39126509f, 
    -0.18666753f, 0.02187414f, -0.14699213f, -0.05508017f, 0.12985556f, -0.06809699f, -0.07322016f, -0.00631749f, 
    -0.24120848f, 0.18676651f, -0.14426658f, -0.10504166f, 0.10350448f, 0.03919113f, 0.10440287f, -0.03291992f, 
    0.00675503f, 0.01130763f, -0.07034604f, -0.18296085f, -0.34408158f, 0.26159698f, -0.17998928f, -0.05984126f, 
    -0.14576469f, -0.06116001f, -0.01814201f, -0.04626880f, -0.03430292f, -0.03043824f, 0.00226101f, 0.07096043f, 
    0.50959003f, -0.04430336f, -0.20178813f, -0.14111082f, -0.04480237f, 0.03862536f, 0.01433312f, -0.06009510f, 
    -0.18262510f, 0.03395438f, -0.08266951f, 0.03854734f, -0.10016473f, -0.15245011f, 0.14017197f, 0.08057454f, 
    -0.08739489f, 0.04268419f, -0.02787544f, -0.10450755f, -0.25650743f, -0.15979338f, -0.11951380f, 0.04270776f, 
    -0.32146752f, 0.03134109f, 0.17329888f, -0.25947854f, -0.08819849f, -0.05008036f, 0.08417941f, 0.01019153f, 
    -0.12775807f, -0.04118906f, 0.05354107f, -0.03074430f, 0.25521359f, 0.15365447f, 0.08610370f, 0.36719054f, 
    -0.08889987f, -0.19967680f, 0.06893726f, 0.05654915f, -0.03324887f, 0.03179137f, -0.04518239f, 0.00751999f, 
    -0.01480192f, 0.04076502f, -0.27193752f, 0.06099215f, -0.16659428f, -0.01500415f, 0.16332965f, 0.07667370f, 
    -0.10243390f, 0.02228322f, -0.03904213f, -0.06864609f, 0.36340499f, 0.30023265f, 0.10338884f, 0.08810367f, 
    0.03002519f, -0.03251797f, 0.09513742f, 0.06720126f, -0.20690458f, -0.06517502f, 0.01875392f, -0.06166510f, 
    0.37473920f, -0.28477147f, 0.07916205f, -0.12899508f, -0.07207765f, 0.11152505f, -0.05163418f, -0.08181421f, 
    -0.14306371f, 0.08648134f, 0.07520831f, 0.03039914f, -0.17864820f, -0.20629178f, -0.08987723f, 0.08770864f, 
    -0.17834243f, 0.03027982f, 0.12178317f, 0.04653011f, -0.13320616f, -0.01640185f, -0.04342442f, 0.03986903f, 
    -0.23200013f, -0.02419823f, -0.13810334f, 0.09466403f, 0.21473943f, 0.13369279f, 0.02325594f, 0.17760247f, 
    -0.07309069f, -0.04399223f, -0.00505500f, -0.21313551f, 0.62798041f, 0.00073463f, -0.05876082f, 0.31349286f, 
    -0.11126485f, -0.16648847f, -0.04760984f, 0.03023024f, -0.02053016f, -0.10235567f, -0.02276001f, 0.01345948f, 
    0.38219905f, -0.02763645f, 0.12262391f, -0.23247346f, 0.00477312f, 0.01701809f, 0.14568152f, 0.08329733f, 
    -0.13028008f, -0.01068632f, 0.10163523f, 0.04571806f, 0.55881453f, -0.09705111f, -0.29486698f, 0.08226201f, 
    -0.12348497f, -0.03092846f, 0.09487978f, 0.13709691f, -0.08996632f, 0.00223953f, 0.14632252f, -0.03598940f, 
    -0.07048294f, 0.07044044f, 0.15420115f, -0.21490653f, -0.08096333f, 0.03766758f, -0.11588316f, 0.04672335f, 
    0.01390701f, 0.02011061f, -0.06456462f, -0.11673706f, 0.08044726f, -0.26572946f, 0.29722789f, 0.30095017f, 
    -0.20779033f, -0.07510460f, 0.08109780f, -0.03955900f, -0.01151427f, -0.12166024f, 0.19072880f, 0.01772854f, 
    -0.15778334f, -0.01911293f, -0.19409549f, -0.12428453f, 0.07048383f, 0.13669981f, 0.10318941f, -0.05935134f, 
    -0.05956055f, 0.11516830f, -0.03924523f, -0.08699909f, -0.14843664f, 0.23942770f, -0.09666083f, -0.19459794f, 
    0.06662067f, -0.05435298f, 0.00760226f, 0.09127416f, -0.04964810f, 0.07535949f, 0.01542115f, -0.22095932f, 
    0.05226430f, -0.04802379f, 0.10948800f, -0.23722421f, 0.16047782f, 0.11390375f, -0.02617258f, -0.07294866f, 
    0.14994951f, -0.02145443f, 0.14502186f, -0.36576518f, 0.38514787f, 0.03314077f, -0.08784613f, 0.00624815f, 
    -0.16499832f, 0.03917526f, 0.05803462f, -0.12141289f, 0.04759297f, 0.01681093f, -0.09014332f, -0.18988924f, 
    -0.70425493f, -0.29276109f, -0.00315620f, -0.18713002f, 0.04579407f, -0.07938227f, -0.00285455f, -0.14452422f, 
    0.03316508f, 0.14487633f, 0.02190552f, 0.09218612f, 0.00886932f, -0.22944102f, -0.12097039f, -0.30053633f, 
    -0.08168443f, -0.20399301f, 0.13088173f, -0.15045576f, -0.15677336f, 0.06524754f, -0.08482011f, -0.04297837f, 
    -0.28123176f, 0.03389208f, -0.36669376f, 0.04590230f, 0.01897987f, 0.06372367f, -0.06781212f, -0.04228910f, 
    0.01956975f, 0.00114659f, 0.16738760f, -0.00285008f, -0.21566662f, 0.20717081f, -0.07108330f, -0.27196860f, 
    -0.03313482f, -0.07376650f, 0.04693038f, -0.05760512f, 0.01770075f, -0.04598239f, -0.00690104f, -0.03859260f, 
    -0.03096185f, -0.08048809f, 0.06542987f, -0.07052341f, -0.20940362f, -0.03232138f, 0.27105752f, -0.24340448f, 
    -0.03992661f, 0.15620349f, 0.00250161f, -0.03394121f, 0.58498985f, -0.29576245f, -0.06903248f, 0.31964096f, 
    0.15065439f, -0.01157687f, 0.01089427f, -0.00618090f, -0.03177141f, 0.06273142f, 0.02514407f, 0.05077537f, 
    0.18773890f, 0.26138273f, 0.20609616f, 0.13558519f, 0.05523377f, 0.16843036f, 0.02131657f, -0.01774651f, 
    0.15967426f, -0.06715038f, 0.00168653f, -0.09349120f, -0.72005278f, 0.31032422f, 0.23193485f, 0.20185548f, 
    0.13613486f, -0.08886601f, -0.01744875f, 0.03940060f, -0.02286930f, 0.16283408f, -0.11888302f, -0.02542633f, 
    -0.13125776f, -0.38649058f, -0.44867474f, 0.50543481f, -0.07303931f, 0.06809196f, -0.04944315f, -0.00670657f, 
    0.02079506f, 0.08566033f, 0.03896987f, -0.05896552f, 0.10187700f, 0.24667075f, 0.14979257f, 0.03227579f, 
    -0.05463765f, 0.00220572f, 0.00729207f, -0.08963978f, 0.02499815f, 0.04918458f, 0.00874608f, 0.02204732f, 
    -0.69062436f, -0.53579253f, -0.15886356f, -0.16990568f, -0.05647406f, -0.14258702f, -0.05755443f, -0.09077086f, 
    0.04926730f, 0.00008467f, 0.04010264f, -0.03502696f, 0.11613663f, 0.11118835f, 0.03909872f, -0.08738327f, 
    -0.03855375f, -0.09883016f, -0.17664312f, 0.13989441f, 0.06664142f, -0.07088798f, 0.06401710f, -0.01412559f, 
    0.07446639f, -0.31394187f, -0.00613815f, 0.18002401f, 0.05253377f, -0.04219516f, 0.01707922f, -0.01777776f, 
    0.02777135f, -0.05158810f, -0.07809116f, -0.14527377f, 0.00826208f, -0.24687500f, 0.08363169f, 0.02045809f, 
    -0.10979021f, -0.03590480f, 0.10756200f, 0.04944304f, -0.03439392f, 0.17364256f, -0.11408161f, 0.08759821f, 
    0.62149572f, 0.36026657f, 0.22272417f, 0.03716298f, -0.00603458f, -0.01935534f, -0.00520540f, -0.03446880f, 
    0.13696951f, -0.03583008f, -0.07186386f, -0.04984160f, -0.13602892f, -0.09844109f, 0.24026005f, 0.10528766f, 
    0.01239478f, 0.13295335f, 0.06956027f, -0.08044592f, 0.03704727f, -0.06828704f, -0.11004272f, -0.02819018f, 
    0.03173707f, 0.04163693f, 0.02959642f, 0.06551708f, 0.06253351f, -0.00069465f, 0.04590652f, 0.09174386f, 
    -0.00943228f, -0.09433147f, -0.19516599f, 0.02524611f, -0.08570453f, 0.07582559f, -0.10244422f, -0.12839857f, 
    -0.20985956f, -0.06316300f, 0.13687344f, -0.08701994f, -0.08610572f, -0.08214194f, -0.06661566f, 0.03642087f, 
    -0.21392101f, 0.33696032f, 0.02736705f, 0.23980613f, -0.09709959f, 0.07993729f, 0.11395136f, 0.05746975f, 
    -0.04028115f, 0.08282614f, 0.02940450f, 0.08594624f, -0.41875604f, 0.20089373f, -0.02969455f, -0.30997694f, 
    -0.20941305f, 0.06018670f, -0.01063836f, 0.01315533f, 0.02732934f, -0.21523240f, -0.02983248f, -0.00447418f, 
    0.01425803f, 0.15045469f, 0.11879820f, 0.26625031f, -0.05187949f, 0.07049065f, -0.13282014f, 0.05555352f, 
    0.11982467f, 0.10286728f, 0.18909000f, 0.08576731f, -0.05584916f, -0.12478832f, 0.01228676f, -0.04423646f, 
    -0.13960814f, 0.15288183f, -0.02414036f, 0.18650842f, -0.06235906f, 0.09744380f, -0.06184752f, 0.03645247f, 
    -0.22787155f, -0.45977661f, -0.19398206f, 0.02429479f, -0.27377927f, -0.03316734f, -0.04063878f, 0.02543317f, 
    -0.05553930f, -0.04034202f, -0.18622747f, 0.06318214f, 0.22380407f, -0.03421967f, 0.14300871f, 0.04293336f, 
    0.01146486f, -0.08086487f, 0.12865740f, 0.02113729f, -0.10419895f, 0.03339190f, -0.12101372f, 0.02787072f, 
    -0.07224198f, -0.37043351f, -0.48995140f, -0.21801342f, -0.15192966f, 0.10899339f, -0.17719971f, 0.03788551f, 
    -0.05808780f, 0.13305308f, -0.03695514f, -0.03034093f, -0.69255549f, 0.31288821f, 0.11681441f, -0.14321789f, 
    -0.03664378f, 0.03789726f, -0.14878194f, 0.18201014f, -0.09798944f, -0.17642060f, 0.07518195f, 0.06538951f, 
    0.37479094f, -0.21996912f, 0.16771951f, -0.22960836f, 0.05036264f, 0.08415040f, 0.03962295f, 0.13094904f, 
    -0.05170709f, -0.07544857f, -0.00446978f, -0.15678973f, 0.08612998f, -0.00753658f, -0.07401878f, -0.16194735f, 
    -0.30008444f, -0.10447821f, 0.05147235f, -0.06481664f, 0.08052640f, -0.01217495f, -0.07882848f, 0.02768711f, 
    0.06124352f, -0.09217397f, 0.18269537f, 0.27596328f, -0.21954359f, -0.14427391f, 0.11130569f, -0.06694980f, 
    0.04908520f, -0.09350169f, -0.00797850f, 0.05177972f, 0.14450966f, -0.52148139f, 0.00759448f, 0.13091491f, 
    -0.01263390f, 0.08015977f, 0.05635961f, -0.03766384f, 0.04027073f, -0.15785110f, 0.10025876f, -0.10759085f, 
    -0.05757838f, -0.19102097f, -0.22750765f, 0.09463342f, -0.07732929f, 0.08437608f, -0.06217758f, -0.04369899f, 
    0.02772416f, 0.07948468f, 0.07962047f, -0.08533572f, -0.14526609f, 0.06110840f, 0.18181327f, -0.08002505f, 
    -0.00845159f, -0.14673728f, 0.18053196f, 0.03379814f, -0.12170348f, -0.06943983f, -0.11632439f, -0.03190739f, 
    0.24456905f, 0.09375611f, -0.06435277f, 0.10535074f, -0.19834059f, 0.08539888f, -0.01474357f, -0.13150993f, 
    0.01470834f, 0.02153028f, 0.10971233f, -0.01802107f, 0.19238181f, -0.26497343f, 0.07350719f, 0.04670182f, 
    -0.25973973f, -0.10635988f, -0.01486850f, 0.02682213f, 0.07016794f, 0.01277445f, -0.08267801f, 0.07964971f, 
    -0.66009963f, 0.16419168f, -0.11677529f, -0.00755237f, 0.03652364f, 0.01034900f, 0.02378247f, 0.17157406f, 
    0.09838594f, 0.11437871f, 0.01932727f, -0.00748826f, 0.24674110f, -0.11325459f, -0.01286088f, -0.07251822f, 
    0.19693482f, -0.01588291f, -0.00068446f, 0.09407875f, 0.07869980f, -0.13891467f, -0.02078210f, -0.07812799f, 
    0.16352323f, -0.19769748f, -0.37812918f, 0.04800776f, -0.01102891f, -0.01995097f, 0.12498648f, -0.05146162f, 
    -0.03645532f, -0.09241489f, 0.11435151f, 0.14338714f, -0.07510364f, 0.34789443f, 0.02925238f, -0.18658930f, 
    -0.10629070f, 0.10961658f, -0.02505266f, -0.00894608f, 0.00235609f, -0.13138199f, -0.05381234f, 0.13689594f, 
    -0.11898491f, 0.09175059f, -0.21811366f, 0.29072565f, 0.07332347f, -0.06039711f, 0.01033436f, -0.12587284f, 
    0.13092455f, -0.08231808f, 0.05114482f, 0.08065869f, 0.10328945f, 0.23109193f, 0.15558228f, 0.14717379f, 
    -0.25715235f, 0.00265096f, 0.15818544f, -0.21583675f, 0.03729579f, 0.00063648f, -0.07983410f, -0.00705444f, 
    -0.40533355f, -0.13892221f, 0.29533860f, 0.15843670f, -0.26983750f, 0.02720931f, -0.11511724f, 0.06091108f, 
    0.03999903f, -0.10030296f, -0.01801414f, 0.03261943f, 0.00773449f, -0.05376992f, 0.11591107f, -0.05673584f, 
    0.05121718f, 0.03734322f, 0.08560639f, 0.04450546f, 0.16197482f, -0.03327106f, -0.10350049f, 0.05104028f, 
    0.39494410f, 0.02929490f, -0.13150778f, 0.02627243f, 0.04154561f, -0.02319363f, 0.12777065f, 0.08389191f, 
    -0.03374489f, -0.01554622f, 0.04930240f, -0.01936990f, 0.11435757f, -0.20659177f, 0.09782496f, -0.12777710f, 
    0.03447561f, 0.07998995f, -0.02420192f, -0.03726511f, 0.01683716f, -0.07820710f, -0.02142294f, 0.10955362f, 
    -0.41301966f, -0.34158039f, 0.26798475f, 0.20009921f, -0.08349324f, -0.01026733f, -0.18310721f, -0.11554623f, 
    0.14504749f, 0.03180156f, 0.00949972f, -0.21751347f, 0.10212730f, -0.31852511f, 0.03662354f, -0.14236765f, 
    -0.07746769f, 0.01711314f, 0.09158056f, 0.03326391f, -0.04740486f, -0.05316130f, 0.04914051f, 0.05318316f, 
    0.18814851f, 0.54149264f, -0.14887691f, -0.43706608f, -0.01382499f, 0.07272498f, 0.02848577f, -0.03401119f, 
    0.08986101f, 0.08852560f, -0.02614712f, 0.12601049f, -0.25353706f, 0.01663818f, -0.10535238f, 0.04533652f, 
    0.04777638f, -0.12453043f, -0.08022709f, -0.04023058f, 0.13186568f, 0.04659467f, -0.18409362f, 0.00782841f, 
    -0.06394990f, 0.08924980f, 0.13500638f, 0.12769572f, 0.07405335f, 0.19495302f, -0.01320747f, 0.04959328f, 
    -0.05868690f, -0.13825181f, 0.02510021f, 0.03169077f, -0.58535427f, -0.21747614f, 0.14456883f, 0.37718993f, 
    -0.00674015f, -0.04315892f, -0.00064064f, 0.00214543f, -0.09745513f, 0.05236252f, 0.02802256f, 0.02053773f, 
    0.00680714f, -0.44110367f, 0.07728728f, -0.25261036f, 0.05515742f, 0.03636735f, 0.10881688f, 0.07628592f, 
    0.02144372f, -0.04179288f, -0.05916099f, -0.00521979f, -0.06022080f, -0.11556276f, 0.11937652f, 0.30780661f, 
    -0.08929634f, -0.00587370f, 0.22101855f, 0.10908741f, -0.03160156f, 0.11745838f, 0.06490552f, 0.15154578f, 
    -0.44213271f, 0.13618273f, 0.01068328f, -0.07234849f, 0.24253508f, -0.16455385f, -0.01140613f, 0.10402226f, 
    -0.08402420f, 0.14553888f, 0.01630060f, 0.06772021f, 0.15456009f, -0.19873841f, -0.16530648f, 0.02191161f, 
    -0.07140802f, 0.08198945f, -0.04795781f, 0.00685760f, 0.17345826f, 0.10931513f, -0.08589692f, -0.08870257f, 
    0.02040784f, 0.09863591f, 0.04788734f, 0.00596382f, 0.00272224f, 0.22265753f, -0.01022551f, 0.01328813f, 
    0.16209817f, 0.04181299f, 0.09116827f, 0.06649023f, -0.82260996f, 0.13795047f, -0.00356712f, -0.14855172f, 
    0.08027914f, -0.04859360f, -0.07034662f, 0.02001790f, -0.16557272f, -0.16849212f, -0.05149051f, -0.05150555f, 
    -0.35984567f, -0.02376867f, 0.12589049f, -0.24059844f, -0.08052028f, -0.10564770f, 0.08837848f, -0.03786102f, 
    -0.08214816f, -0.01702555f, 0.07210292f, -0.27863824f, -0.06272426f, 0.36681175f, 0.02761602f, -0.04734709f, 
    -0.00601501f, -0.12182699f, 0.08442156f, -0.10232610f, -0.01593623f, -0.02258668f, -0.08978829f, -0.01992778f, 
    -0.55753142f, -0.25249928f, -0.05375683f, -0.07539535f, 0.05666317f, 0.11296561f, -0.31318250f, 0.02981648f, 
    -0.01785164f, -0.06641259f, -0.03546507f, 0.10164136f, -0.25919622f, 0.23859811f, 0.17133000f, 0.16570862f, 
    -0.01675701f, 0.05978441f, -0.03444490f, 0.10382557f, -0.23278318f, -0.06203733f, 0.14840478f, -0.15103008f, 
    0.19657782f, -0.08593336f, -0.10199168f, 0.34383520f, -0.08347262f, 0.07019442f, 0.17882329f, -0.03303155f, 
    -0.02937721f, 0.03889554f, -0.00477207f, -0.02822355f, 0.11846541f, 0.13472345f, 0.24277787f, -0.00323746f, 
    -0.11335868f, -0.11701091f, 0.03929394f, -0.07181177f, 0.08319537f, -0.00454760f, -0.04876051f, -0.32556516f, 
    -0.14033325f, 0.14356916f, -0.01368087f, 0.18744855f, -0.08441212f, -0.11516027f, -0.14025345f, 0.03474073f, 
    -0.18496564f, 0.02985968f, 0.12263025f, -0.12895399f, -0.20581426f, -0.11167925f, -0.18819480f, -0.24206141f, 
    0.05498268f, -0.10959148f, -0.00275642f, -0.01671487f, -0.17009391f, 0.01372737f, -0.00041551f, -0.03056337f, 
    0.04074701f, -0.09805788f, -0.07652286f, 0.11150872f, -0.02844041f, -0.10873308f, 0.07401991f, 0.08207391f, 
    -0.00150320f, -0.04364366f, -0.01619733f, -0.04234967f, 0.12996452f, 0.25484622f, 0.17472512f, 0.07788447f, 
    -0.01477136f, 0.09575255f, 0.08801383f, 0.03446535f, 0.01523200f, -0.06834494f, 0.04402256f, 0.09294211f, 
    -0.62075746f, 0.30046082f, 0.07610398f, -0.14618751f, 0.06507472f, -0.07891440f, 0.00533965f, -0.16619812f, 
    0.10390519f, -0.14654386f, -0.03850123f, -0.10378525f, -0.62265551f, -0.50658059f, -0.13957183f, 0.10404155f, 
    0.19896479f, 0.11492194f, 0.14640695f, -0.24325898f, 0.18714339f, 0.00495915f, 0.11166301f, -0.02531633f, 
    -0.49228200f, 0.25762203f, -0.07753300f, -0.34075934f, 0.05473589f, 0.00584860f, -0.20937248f, -0.11041599f, 
    -0.03978842f, -0.09543244f, -0.21968366f, -0.05294064f, 0.10389391f, -0.16593383f, 0.01000391f, 0.00645380f, 
    -0.01544596f, -0.04454659f, 0.00952476f, 0.08568493f, -0.07838800f, 0.03923364f, 0.10029990f, 0.00668640f, 
    -0.30097535f, -0.20756646f, -0.19110170f, -0.23350587f, 0.01259500f, -0.15960626f, -0.17072964f, 0.09574651f, 
    0.12088215f, -0.09590728f, 0.15160555f, 0.09531116f, -0.19739765f, -0.06294042f, -0.07484705f, 0.14506553f, 
    -0.00356085f, -0.05180195f, 0.10502914f, -0.03408629f, 0.25031325f, -0.15081231f, -0.01965727f, -0.05626122f, 
    0.02996308f, 0.06400876f, -0.04698667f, 0.02605631f, 0.04006035f, -0.03556304f, 0.06187530f, 0.01262715f, 
    0.01882665f, -0.05094779f, -0.05648733f, 0.11135524f, -0.12230874f, 0.11501174f, -0.01754173f, 0.48301730f, 
    -0.10312949f, -0.03364291f, -0.09601013f, 0.15994549f, -0.08178777f, -0.13262364f, 0.05663951f, 0.06286050f, 
    -0.12872528f, 0.18408358f, 0.38223314f, -0.34398857f, -0.00712314f, -0.08975036f, -0.06309538f, -0.07736199f, 
    0.22577105f, 0.00509977f, -0.11714067f, -0.00207605f, 0.01237210f, -0.17780778f, -0.15732236f, 0.10692093f, 
    0.02730242f, 0.00011452f, 0.11056633f, 0.09289534f, -0.09800252f, 0.06262013f, 0.09116329f, 0.06586541f, 
    0.19672744f, 0.11788756f, 0.05969115f, 0.22837542f, -0.17580646f, 0.05372031f, 0.04264254f, 0.03001783f, 
    -0.16537671f, 0.01555189f, 0.18970568f, 0.14600760f, 0.05019484f, -0.09463891f, -0.13308161f, 0.15579650f, 
    0.20285931f, 0.07114717f, 0.03212060f, -0.12672956f, 0.07193603f, -0.06223151f, -0.08115409f, 0.15749848f, 
    -0.54250014f, -0.53269881f, 0.41362637f, 0.34521061f, -0.09058103f, 0.00260907f, 0.00159935f, 0.08243904f, 
    -0.04177048f, 0.04291983f, 0.01385631f, -0.06758644f, -0.06960995f, -0.00582937f, 0.21651378f, -0.02055062f, 
    0.08944219f, -0.00120865f, -0.02268925f, 0.06644748f, 0.15371713f, 0.03453369f, 0.24962395f, 0.26273873f, 
    -0.09399781f, -0.04153186f, -0.14002810f, 0.23220226f, -0.08087772f, -0.15992855f, 0.07640628f, 0.07054210f, 
    -0.08478845f, 0.12017491f, 0.22721425f, 0.30967537f, 0.10964905f, -0.11264587f, -0.56545568f, -0.08007404f, 
    0.10980989f, 0.29515815f, -0.15415432f, -0.10474815f, -0.03218525f, -0.13397476f, -0.00386202f, -0.09559005f, 
    0.21633634f, 0.03469494f, -0.00711883f, 0.20329510f, -0.11425621f, 0.05313439f, -0.13895816f, 0.21544157f, 
    -0.05735320f, 0.01021505f, 0.06130714f, -0.02733062f, 0.08316910f, 0.24376249f, -0.20904620f, -0.14759013f, 
    0.08783238f, -0.13937585f, -0.18920748f, -0.14468531f, 0.10757037f, -0.06406214f, 0.00415526f, -0.14400306f, 
    0.04075393f, -0.00870230f, -0.06402392f, -0.13652943f, -0.06039865f, 0.03087055f, 0.08571046f, -0.07493961f, 
    0.08663790f, -0.24036363f, -0.11202418f, -0.12922752f, 0.02168193f, -0.30286184f, -0.12328406f, -0.18186277f, 
    0.13287047f, -0.09446214f, -0.04034660f, -0.04945175f, 0.16734371f, 0.04430194f, -0.12842883f, -0.04240478f, 
    -0.13972308f, 0.14532349f, 0.09372076f, 0.14897764f, 0.00632308f, -0.09365689f, 0.17056300f, -0.23903860f, 
    0.01728174f, 0.08628964f, -0.26991612f, 0.12865916f, -0.46253118f, 0.09791756f, -0.10300820f, -0.28982902f, 
    0.06975302f, -0.03193695f, 0.09514318f, 0.26742610f, -0.11386964f, 0.08515451f, 0.10961690f, -0.33302942f, 
    0.08996020f, -0.00533382f, -0.01025637f, 0.01821091f, 0.00406089f, -0.01141270f, -0.04703335f, -0.11086254f, 
    -0.09288393f, -0.07738752f, 0.14239989f, 0.05140720f, 0.08656219f, -0.12094083f, 0.09454474f, -0.07196914f, 
    -0.02840455f, 0.04090009f, -0.06434210f, -0.00406407f, 0.05247122f, 0.11569893f, 0.00551754f, 0.15421797f, 
    -0.41177458f, 0.14999013f, -0.22323449f, 0.04949961f, 0.18407179f, -0.22892800f, 0.20647152f, -0.20372303f, 
    0.01547616f, 0.04393517f, -0.11644436f, -0.05308583f, -0.41658482f, -0.18047996f, -0.10255256f, 0.24907243f, 
    0.15605573f, 0.15279683f, -0.02714097f, -0.12246266f, 0.07146183f, -0.02759799f, -0.06868553f, 0.18244740f, 
    0.14738454f, 0.03656055f, 0.29627672f, 0.04515540f, -0.01477892f, -0.00061427f, 0.06717610f, -0.08151533f, 
    -0.15369278f, -0.07236287f, 0.17065464f, 0.03684119f, -0.01343287f, 0.00806493f, 0.03637203f, 0.14709282f, 
    -0.01902828f, 0.13863988f, -0.07363953f, -0.10495175f, 0.02061588f, -0.03879180f, -0.05026273f, 0.09066720f, 
    0.03145190f, 0.02549542f, 0.27227068f, -0.18574864f, -0.19013755f, 0.01639218f, 0.01948186f, 0.06162118f, 
    -0.05576656f, -0.04564759f, -0.17331745f, 0.08029956f, -0.18599519f, -0.03357917f, 0.16736645f, -0.12070065f, 
    -0.00973012f, 0.02890449f, 0.06313322f, 0.07260037f, -0.04414052f, -0.04702245f, 0.03963973f, 0.24222776f, 
    0.05708889f, -0.08203281f, 0.03430775f, 0.20639844f, 0.18628740f, 0.08442442f, -0.12275781f, 0.14705084f, 
    -0.03981040f, -0.00368817f, -0.01605170f, -0.05412847f, -0.02375206f, 0.05674861f, -0.05310138f, 0.09625186f, 
    -0.01721452f, -0.20013827f, 0.02679439f, 0.22318619f, 0.03546046f, 0.14774279f, 0.05379907f, 0.07699014f, 
    0.38961211f, -0.88270146f, -0.12372796f, 0.13345744f, -0.09054378f, 0.04404373f, -0.02411592f, 0.14386840f, 
    0.15071535f, 0.00374523f, 0.10065306f, 0.12049541f, 0.06545492f, -0.08910570f, 0.00339943f, -0.09344527f, 
    -0.02761376f, 0.02182843f, -0.18534710f, -0.06790671f, -0.19232292f, 0.01854048f, -0.08613939f, -0.04875401f, 
    -0.38051096f, -0.28144470f, 0.12679675f, 0.14039525f, -0.00882038f, 0.07233137f, 0.12225939f, -0.02605570f, 
    0.04589281f, -0.02619922f, 0.10344882f, 0.02645541f, 0.02682237f, 0.12829836f, 0.22816029f, -0.47554198f, 
    0.11579533f, 0.20359339f, 0.06765324f, -0.07784531f, -0.04158342f, 0.02475957f, -0.07849760f, 0.15046704f, 
    0.28921837f, 0.08169903f, -0.02593232f, -0.41521287f, -0.07648803f, 0.03746924f, 0.13937876f, -0.01789564f, 
    -0.09567298f, -0.00501502f, -0.05702261f, -0.06682495f, -0.29862413f, -0.02942394f, 0.10617468f, -0.01018317f, 
    -0.01338202f, -0.07091392f, 0.00207287f, -0.00040627f, -0.19846399f, 0.04536430f, -0.07879543f, 0.11351629f, 
    -0.03224638f, 0.37019390f, -0.03203938f, -0.34613732f, -0.14430945f, 0.08980184f, -0.08534425f, -0.00692405f, 
    -0.14743087f, 0.15975647f, 0.01265090f, 0.02992578f, 0.04104234f, -0.27018932f, -0.08203861f, 0.18187264f, 
    0.12037884f, -0.07020129f, -0.12796812f, 0.07029001f, -0.04815470f, 0.06832846f, -0.16631240f, -0.04111804f, 
    -0.05173109f, 0.28358459f, 0.19730024f, -0.43727520f, -0.13408841f, -0.05392730f, 0.05383304f, 0.15049002f, 
    -0.09646053f, -0.11191515f, 0.04933282f, 0.06699764f, -0.04508332f, 0.06720827f, 0.04450661f, -0.17030011f, 
    0.10047691f, -0.08100655f, -0.08347572f, -0.08446930f, 0.06743585f, 0.04898765f, 0.12939939f, -0.20893480f, 
    -0.04610014f, 0.15324636f, 0.02155771f, -0.08560157f, 0.02283589f, -0.02767378f, -0.04295851f, 0.05358742f, 
    0.11221514f, -0.14968506f, -0.05222847f, -0.04155024f, -0.01336219f, -0.12909088f, -0.09192961f, 0.47677901f, 
    0.00686185f, -0.10158932f, 0.12238546f, -0.09638004f, 0.06975407f, 0.12453125f, 0.09069676f, -0.13264990f, 
    0.35307571f, -0.26939023f, 0.02917345f, 0.08210781f, -0.05021024f, -0.12724410f, -0.07927696f, 0.05529325f, 
    -0.03209886f, 0.09307861f, -0.20409428f, 0.21610044f, 0.15470973f, -0.07692159f, -0.06342196f, 0.05958591f, 
    -0.00865397f, 0.15026428f, 0.02783581f, -0.02503184f, -0.16122834f, 0.03139602f, -0.27357683f, -0.07605544f, 
    -0.05281352f, -0.00101108f, -0.08905999f, -0.15264262f, 0.11514328f, -0.06965102f, 0.00243457f, -0.08458696f, 
    0.07738464f, -0.35663468f, -0.24080360f, -0.16515362f, -0.21844123f, -0.20312591f, -0.09726893f, -0.37091786f, 
    -0.12225656f, 0.01743964f, 0.06867935f, -0.22533807f, -0.02122930f, 0.16186793f, 0.07862595f, 0.28147578f, 
    0.01264240f, -0.05705855f, 0.25685835f, -0.12569851f, 0.17690313f, -0.10738755f, 0.11496685f, -0.00213167f, 
    0.15202080f, -0.00425590f, -0.14798135f, -0.06231068f, 0.14685419f, -0.18358438f, -0.24753645f, 0.27451819f, 
    -0.18225585f, 0.08912221f, 0.02125817f, 0.05821791f, -0.05822092f, 0.04553043f, 0.01039949f, 0.15058033f, 
    0.38848290f, -0.07027936f, 0.02679959f, -0.17125477f, 0.00003719f, 0.10852985f, -0.03790065f, 0.13052949f, 
    0.12924050f, -0.04090145f, 0.10107009f, 0.15306108f, -0.37095505f, -0.03446903f, -0.05981516f, 0.07623911f, 
    0.05492395f, 0.00325424f, 0.06280444f, 0.05967381f, -0.01105003f, -0.12216751f, 0.14820273f, 0.12528643f, 
    -0.38705549f, 0.18665959f, 0.27098826f, -0.11600704f, -0.04136286f, 0.10197499f, -0.05777725f, 0.11943043f, 
    0.00928604f, 0.17926960f, -0.04965574f, 0.07247441f, 0.37429437f, -0.25843409f, 0.09659018f, -0.07827523f, 
    0.08119553f, 0.08785608f, 0.01364798f, -0.16250324f, 0.07179100f, -0.06875121f, -0.01167615f, 0.18049948f, 
    -0.41446817f, 0.26732421f, 0.08866295f, 0.33955896f, 0.12910865f, 0.08810047f, 0.05999092f, 0.02762397f, 
    0.11169384f, 0.02470771f, -0.01011860f, -0.09194756f, -0.02069096f, -0.27558371f, 0.05247174f, 0.21237198f, 
    -0.08354314f, 0.13973336f, 0.01675677f, 0.04221867f, -0.07053018f, -0.00398456f, 0.01841362f, -0.06097202f, 
    0.09677427f, -0.58365464f, 0.08692903f, 0.01254496f, -0.09219861f, 0.25197968f, 0.03411296f, -0.06237642f, 
    -0.06488325f, -0.07180436f, 0.10142483f, 0.04272515f, -0.13429067f, -0.09444518f, -0.20723785f, -0.18919070f, 
    -0.07892379f, -0.17324328f, -0.08597968f, -0.13203646f, -0.06255119f, -0.03451511f, 0.08267424f, -0.06384620f, 
    -0.08002955f, 0.43558985f, 0.21449797f, -0.13682383f, 0.04840717f, 0.04520493f, 0.09296022f, 0.02565730f, 
    -0.03187661f, 0.16083522f, -0.05782230f, -0.02290166f, 0.10947664f, 0.14355379f, 0.23173426f, -0.36842987f, 
    -0.14357249f, 0.16444984f, 0.06530450f, 0.06949060f, -0.19076659f, 0.08366591f, 0.14753692f, 0.01709531f, 
    -0.17614016f, -0.03924761f, -0.01348742f, -0.00399559f, 0.08004243f, 0.10085738f, 0.01244102f, -0.06903800f, 
    -0.08797457f, -0.02717016f, 0.05942607f, -0.08776936f, 0.28460896f, -0.39037845f, 0.08571491f, -0.07976472f, 
    0.07634245f, -0.04898332f, 0.17587936f, -0.14646435f, 0.17351298f, 0.05331281f, -0.03943298f, -0.31376532f, 
    -0.03484070f, -0.17256060f, -0.21660753f, -0.24243209f, -0.11145853f, 0.09051597f, 0.05731759f, -0.05452483f, 
    -0.04805174f, -0.38178048f, 0.09735301f, -0.09964202f, -0.07897476f, -0.22463126f, -0.49055845f, 0.25653732f, 
    0.13030237f, -0.06088054f, -0.09937239f, -0.20513628f, 0.15133847f, -0.20368777f, 0.07003200f, -0.05640675f, 
    -0.22446458f, 0.15008764f, 0.12234598f, -0.11292414f, -0.01735364f, 0.04212513f, -0.07233404f, -0.12828133f, 
    -0.04278719f, -0.00219962f, -0.11076192f, -0.12237025f, 0.16267987f, 0.10251355f, 0.13415182f, 0.24713281f, 
    0.22459383f, 0.00847440f, 0.11929132f, -0.13312581f, -0.05777840f, -0.01271470f, -0.02795403f, -0.06914095f, 
    0.18587449f, -0.23033054f, 0.07831419f, -0.12954846f, -0.05654368f, 0.01012629f, -0.09733226f, -0.04647355f, 
    0.04492608f, 0.05856907f, -0.02478030f, -0.13947709f, 0.02312049f, 0.19576804f, 0.00782312f, 0.06027013f, 
    -0.06925249f, -0.03677658f, 0.08210808f, 0.01496368f, -0.08778705f, -0.04274548f, -0.00807817f, -0.13351560f, 
    0.16929273f, 0.31989005f, 0.07155024f, -0.22020927f, -0.09315466f, 0.04994382f, -0.00725457f, -0.06240886f, 
    -0.12980722f, -0.06444564f, -0.08168935f, -0.13993202f, 0.28340471f, -0.53949720f, 0.30247322f, 0.11572589f, 
    0.07990395f, -0.04907143f, -0.12801638f, 0.01519888f, 0.01264387f, -0.10971817f, -0.02913453f, 0.04988470f, 
    -0.21276906f, -0.01449864f, -0.23325193f, -0.14479712f, 0.00461236f, -0.03341518f, -0.15995806f, -0.01124559f, 
    -0.21493638f, -0.00157874f, 0.04964260f, -0.03042728f, 0.09246242f, 0.13862547f, 0.10778129f, 0.19712199f, 
    0.10062151f, -0.14586242f, -0.02668768f, -0.07193235f, -0.00979307f, -0.05317688f, 0.06450256f, 0.03136484f, 
    -0.40360931f, 0.00847493f, -0.04194860f, -0.14777173f, -0.13612996f, -0.04054917f, -0.10755333f, -0.16978388f, 
    -0.11424547f, -0.09541606f, -0.07828738f, -0.18392572f, 0.25655332f, 0.05364752f, 0.08052097f, 0.24257393f, 
    0.14009804f, -0.00562558f, 0.02474079f, -0.15797900f, -0.11289909f, 0.00554835f, -0.01694132f, -0.07289145f, 
    -0.10550683f, -0.27253661f, -0.33033538f, 0.04216258f, -0.12720549f, -0.12331195f, -0.09997468f, -0.02561113f, 
    -0.15206259f, -0.05892951f, 0.06035290f, -0.14054582f, 0.15931650f, 0.10061492f, -0.09483446f, 0.22653389f, 
    -0.00796627f, -0.06461874f, -0.14052776f, -0.10351125f, 0.09194697f, -0.01578320f, 0.06074523f, -0.11583547f, 
    -0.00954561f, 0.13736761f, 0.13668530f, 0.16239356f, 0.10669697f, -0.01986667f, 0.03174241f, -0.04507398f, 
    -0.09463485f, 0.02381402f, 0.01882994f, -0.02481474f, -0.28771371f, -0.29014757f, -0.12550230f, -0.03937298f, 
    -0.08185483f, -0.07351458f, -0.02036501f, 0.02855692f, -0.06752068f, -0.02760615f, -0.01350617f, -0.15175611f, 
    0.05931165f, 0.10019614f, -0.03218886f, 0.09987164f, -0.09208352f, -0.08641067f, -0.05954241f, -0.12847422f, 
    -0.01572313f, -0.06970350f, -0.13627410f, -0.02550133f, 0.14160934f, 0.28068715f, 0.13824192f, 0.18765695f, 
    0.03884534f, 0.08377963f, 0.11613966f, -0.03122412f, -0.00960730f, 0.07238879f, -0.02986482f, -0.09420819f, 
    0.26523268f, -0.27097964f, 0.00277869f, -0.10268751f, 0.11253253f, -0.05679680f, -0.01977644f, -0.15816982f, 
    -0.01298264f, -0.03610877f, -0.03354245f, -0.04139352f, -0.14769156f, 0.19881627f, -0.01112642f, 0.16549195f, 
    0.09406976f, -0.03659450f, -0.03338581f, 0.02441379f, 0.00923774f, -0.03432562f, 0.02220479f, 0.00813036f, 
    0.03636543f, -0.06670497f, 0.03186259f, -0.15186332f, -0.11913056f, -0.04470039f, -0.06725155f, 0.03526304f, 
    0.02766456f, 0.00031829f, -0.03291956f, -0.05332898f, 0.12296860f, 0.16223522f, -0.07014010f, 0.21213222f, 
    0.15604407f, -0.00994665f, -0.08468738f, -0.06664835f, -0.04098699f, 0.07067790f, -0.05339014f, -0.14511079f, 
    0.05443482f, -0.09334882f, -0.07913300f, -0.17996372f, -0.11058192f, 0.12530461f, -0.07798099f, -0.04306645f, 
    -0.04909211f, 0.02953449f, 0.00227511f, -0.06844959f, 0.29524150f, -0.15308000f, 0.14547750f, -0.14121990f, 
    -0.02391003f, 0.01004024f, -0.01077147f, -0.02442831f, 0.02438330f, 0.12412569f, -0.13436192f, -0.06857254f, 
    -0.72378564f, 0.12141381f, -0.04606632f, -0.19066738f, -0.23662199f, 0.01915811f, -0.02547102f, -0.03217809f, 
    -0.01726825f, -0.09082727f, -0.06575182f, -0.06913088f, 0.24846877f, -0.36794606f, 0.06703671f, 0.01849405f, 
    0.09218973f, 0.09188348f, -0.01259621f, -0.05005326f, 0.03541255f, 0.00806058f, -0.06483349f, 0.03337657f, 
    0.18740676f, 0.00744757f, 0.13062796f, 0.20275299f, 0.01841334f, -0.04944023f, -0.02947430f, 0.17964685f, 
    -0.01770760f, 0.12054310f, 0.03750217f, 0.03543596f, -0.05190384f, 0.35488188f, 0.18660592f, 0.16167951f, 
    0.09116209f, 0.08468779f, 0.14521709f, -0.12636770f, 0.01333567f, 0.06658898f, 0.06931057f, -0.11155824f, 
    -0.00790758f, -0.12671874f, -0.05401728f, -0.20366810f, -0.01115231f, 0.08417979f, 0.02041483f, -0.10453318f, 
    -0.22873020f, -0.05193120f, 0.04307497f, -0.24840568f, -0.16249648f, 0.16284083f, -0.23651235f, 0.10851729f, 
    0.02548350f, -0.07663479f, 0.06958066f, -0.01784901f, -0.09157827f, -0.08569753f, 0.11703188f, -0.06690197f, 
    -0.21243475f, 0.15488513f, -0.09323125f, -0.10054541f, 0.01928197f, -0.09637211f, -0.07421225f, -0.06595028f, 
    0.00837861f, 0.02159434f, -0.04072979f, -0.10844714f, 0.33212626f, -0.42089972f, 0.13146655f, -0.02083451f, 
    0.00230579f, -0.09013423f, -0.04626334f, -0.19481283f, 0.00675986f, 0.00506825f, -0.03299583f, -0.00479535f, 
    0.03335361f, 0.08690998f, 0.16226578f, 0.39329401f, -0.09808899f, -0.06456961f, -0.14424200f, -0.03648997f, 
    0.05155398f, -0.06131445f, -0.07255524f, -0.06170961f, -0.05256693f, 0.19285981f, -0.05247650f, 0.05093864f, 
    -0.05447264f, 0.04780614f, -0.02903716f, -0.03380079f, -0.09958583f, 0.05859539f, -0.04459154f, -0.14306213f, 
    0.20671386f, -0.09533229f, 0.14712967f, 0.12565251f, -0.13981231f, -0.07364982f, -0.00795951f, -0.07772925f, 
    -0.01564608f, -0.07021956f, -0.08568689f, -0.12432103f, -0.12506622f, -0.15417701f, 0.31154779f, 0.04921346f, 
    -0.12831306f, 0.03135924f, -0.04985059f, -0.16643512f, -0.07439188f, 0.06120771f, 0.18219723f, -0.02083557f, 
    -0.07580250f, -0.07472781f, 0.13720128f, 0.10362445f, -0.07975505f, -0.04449023f, -0.17347978f, -0.02142913f, 
    -0.05257354f, 0.14858520f, -0.17610155f, -0.01257119f, -0.39223713f, -0.08527534f, 0.03477710f, 0.04195921f, 
    0.03134446f, -0.15575862f, -0.04884395f, -0.05142769f, 0.14997108f, 0.11983408f, 0.08129955f, -0.11251742f, 
    -0.46257246f, 0.10458406f, -0.04605749f, -0.21153259f, -0.11444421f, -0.14205931f, -0.05566234f, -0.05127588f, 
    0.03541971f, 0.00040282f, 0.01381987f, -0.16828501f, -0.10755616f, 0.03539074f, -0.09092845f, -0.02884535f, 
    -0.08674937f, -0.14655039f, 0.04098577f, -0.30305168f, 0.07828861f, 0.11401430f, 0.06994568f, 0.07308908f, 
    -0.26289546f, -0.33348653f, -0.05214217f, 0.05369456f, 0.19306107f, 0.02751023f, 0.02451579f, 0.04265086f, 
    0.12481821f, -0.04401652f, 0.02543127f, -0.01977353f, 0.08577603f, 0.21093135f, -0.21015210f, -0.22891948f, 
    -0.02794795f, -0.12752742f, -0.14609939f, -0.00336359f, 0.01774237f, -0.05226313f, 0.13331041f, 0.18869847f, 
    0.37004963f, -0.08602893f, 0.19004594f, 0.31175557f, 0.20797105f, -0.05888188f, -0.01317754f, -0.13328376f, 
    0.04127365f, 0.04702916f, 0.01129316f, -0.19177555f, -0.16852085f, -0.28163663f, 0.16206092f, -0.30545339f, 
    -0.04256883f, -0.18210691f, 0.10260160f, -0.09353410f, 0.07118864f, 0.00316920f, 0.05110656f, 0.08635949f, 
    -0.11707179f, -0.26293263f, -0.25535348f, -0.25417963f, 0.04984917f, 0.00778252f, 0.02801331f, -0.05563296f, 
    0.17015718f, 0.04836259f, 0.15296473f, 0.02133689f, 0.03640367f, 0.21677944f, -0.21994671f, -0.13391168f, 
    0.02485209f, -0.08005834f, -0.16406901f, 0.12389042f, -0.01156460f, -0.05752327f, -0.01377525f, 0.15609567f, 
    -0.12919639f, -0.18254912f, -0.11422867f, -0.11246937f, 0.04554964f, -0.11957998f, -0.09747827f, 0.06537363f, 
    0.18708029f, -0.06450779f, 0.04347565f, -0.21671906f, -0.17086779f, 0.05743358f, -0.04420225f, -0.02769672f, 
    -0.12741807f, -0.06483280f, 0.01503253f, -0.05191251f, 0.03327578f, -0.05839458f, 0.07815053f, 0.03613744f, 
    0.10472733f, 0.06906246f, -0.13845967f, -0.20647964f, -0.04190738f, -0.03675009f, 0.08229952f, -0.04813925f, 
    -0.02378058f, 0.18630639f, 0.09235332f, 0.04988967f, -0.16486773f, 0.17294303f, 0.28255701f, 0.10652543f, 
    0.00553178f, 0.12456227f, -0.08176459f, 0.02532584f, 0.06300135f, -0.04625000f, -0.02314832f, -0.19014432f, 
    0.17888474f, 0.00143956f, 0.16307676f, -0.14324722f, 0.05382610f, 0.02302201f, -0.17375939f, -0.11702470f, 
    -0.12021492f, 0.09399219f, 0.10611302f, 0.02110991f, 0.06196292f, 0.21715340f, -0.01348664f, 0.04630844f, 
    -0.07918032f, -0.14414659f, -0.13679433f, -0.02552978f, -0.08133806f, -0.03477109f, -0.01277174f, -0.20023985f, 
    -0.30922592f, 0.02044817f, -0.18011954f, -0.12462355f, -0.18760559f, 0.03515654f, -0.01902265f, -0.17514087f, 
    0.03680377f, -0.08482166f, -0.04231933f, 0.07731516f, -0.29459071f, 0.26291731f, -0.26692739f, -0.07503976f, 
    -0.20805316f, 0.07134826f, 0.09774797f, -0.01852781f, 0.14336941f, 0.10100424f, 0.00170488f, -0.02453220f, 
    0.16726795f, 0.08696830f, -0.02615192f, -0.07231937f, 0.02136320f, -0.04752443f, -0.01893058f, -0.05736115f, 
    0.00646068f, 0.04165557f, -0.15724447f, 0.35921842f, 0.05869669f, -0.04451436f, 0.13198759f, 0.13594896f, 
    -0.08695625f, -0.00094794f, 0.06637313f, 0.08722012f, 0.09636723f, 0.01641612f, 0.03631049f, -0.04199757f, 
    0.20354256f, 0.10879071f, -0.26161236f, 0.21155216f, 0.17021103f, 0.01745043f, -0.10597996f, -0.03501395f, 
    -0.04519479f, 0.06073621f, 0.04815146f, 0.09721369f, 0.22927590f, 0.24079891f, 0.04547833f, 0.25641212f, 
    -0.00723179f, -0.06539825f, -0.09600028f, -0.18243283f, 0.06852422f, 0.07188544f, -0.23295954f, 0.05944454f, 
    0.01025694f, 0.08527322f, 0.11781098f, -0.23666747f, -0.04481401f, -0.31191060f, 0.11541560f, -0.15304312f, 
    -0.09424460f, 0.02722348f, -0.23831804f, 0.09318560f, -0.09199395f, 0.00765355f, 0.27531829f, 0.10140258f, 
    -0.03299635f, 0.03602819f, -0.16131648f, 0.12743641f, 0.03947965f, -0.06034779f, -0.10192898f, -0.00962544f, 
    -0.07133956f, -0.31131932f, -0.05024736f, 0.03057928f, 0.16077383f, -0.10653737f, -0.19601287f, 0.03548440f, 
    0.04299416f, -0.04033510f, -0.00801261f, -0.16660959f, -0.12159960f, -0.04780177f, -0.06184541f, -0.18302120f, 
    0.10180043f, 0.08304751f, -0.05857699f, -0.07550322f, 0.12572475f, 0.07002052f, 0.08016036f, 0.19819470f, 
    0.14186589f, 0.01151415f, -0.14125274f, 0.08762805f, 0.09790978f, 0.08376544f, -0.02629014f, -0.06627952f, 
    0.06622593f, 0.00283807f, -0.12387681f, 0.04502507f, 0.11350487f, -0.27519798f, 0.06463338f, -0.03144766f, 
    -0.03368952f, -0.06116795f, -0.03358683f, 0.01193757f, -0.04080260f, 0.04925159f, 0.05455505f, 0.18300395f, 
    -0.34562981f, 0.20879871f, 0.03728943f, -0.28876948f, -0.10340254f, 0.16507754f, -0.01138273f, 0.09521233f, 
    0.09886366f, -0.10404775f, -0.02205163f, 0.00435051f, -0.24736589f, 0.27000368f, -0.37172487f, -0.43050545f, 
    -0.03889334f, 0.06350920f, -0.10121473f, -0.04557002f, 0.19631495f, 0.08514940f, 0.03610498f, 0.05774073f, 
    -0.10982157f, 0.15915929f, -0.09109748f, 0.05041005f, 0.16393441f, -0.07933812f, 0.04761676f, -0.16183673f, 
    -0.02635072f, 0.09197835f, -0.02124513f, -0.02142181f, -0.29158527f, -0.13585173f, -0.04511797f, 0.08681148f, 
    -0.02986903f, -0.10502169f, 0.06405604f, -0.03222880f, -0.05200778f, -0.05190786f, -0.09245569f, 0.07545502f, 
    0.16266629f, -0.07779308f, -0.00502097f, -0.05271911f, 0.06173572f, -0.08738198f, -0.04194471f, 0.21063335f, 
    0.03372849f, -0.06221680f, 0.02476838f, -0.04207666f, 0.07758668f, 0.18834619f, -0.11618123f, -0.29712880f, 
    0.06516472f, -0.16423459f, 0.04864505f, 0.09236116f, -0.09506633f, 0.05660642f, -0.07668696f, -0.11554078f, 
    -0.26407522f, 0.10121553f, -0.11558318f, 0.17568974f, -0.02971799f, 0.00592577f, 0.12181772f, -0.13318925f, 
    -0.03305654f, -0.00901412f, -0.09197684f, 0.14602028f, 0.65976399f, -0.44191825f, -0.50116336f, 0.13922566f, 
    -0.06630278f, 0.08421665f, 0.16602650f, 0.26531491f, -0.10684710f, 0.05540042f, 0.22495653f, -0.08591101f, 
    -0.35782981f, 0.06614220f, 0.20815325f, -0.58034831f, 0.13468952f, 0.06413659f, -0.09902942f, -0.16656430f, 
    -0.04379146f, -0.02168943f, -0.05322899f, -0.07389640f, -0.14411940f, -0.25560254f, 0.23851769f, -0.16342737f, 
    0.01186195f, -0.04736008f, 0.01347073f, -0.05311236f, -0.16517052f, -0.06339277f, 0.04685019f, -0.09562225f, 
    -0.28700981f, 0.13606919f, -0.40550584f, -0.03982421f, 0.12381598f, 0.05214509f, 0.02498763f, 0.00877304f, 
    -0.10669454f, -0.03917406f, 0.02108683f, -0.09670589f, 0.00451197f, -0.18030991f, -0.13275315f, 0.13379125f, 
    0.00346374f, 0.02166370f, 0.14493513f, -0.07604814f, 0.06352484f, 0.00003237f, -0.10338768f, -0.08456773f, 
    0.03284984f, -0.01075823f, -0.06516187f, -0.46139467f, 0.00442384f, 0.11560261f, -0.00795666f, 0.01876727f, 
    -0.15372871f, -0.07136235f, -0.02434637f, -0.13070317f, 0.10199931f, -0.05842273f, 0.31369174f, 0.15591516f, 
    -0.14966464f, -0.00051491f, -0.06024896f, 0.10391038f, -0.04759704f, 0.02196077f, 0.02430323f, 0.03451587f, 
    -0.19713984f, -0.30581403f, -0.29256061f, 0.01078112f, 0.01888507f, -0.00203445f, 0.00986092f, 0.09677804f, 
    -0.04862389f, -0.03428774f, 0.24022709f, 0.03986590f, 0.20625648f, 0.29987481f, -0.41581434f, -0.21397234f, 
    0.12338865f, 0.07060248f, 0.00775229f, -0.01123296f, -0.10532057f, 0.14025003f, -0.15736045f, -0.08475851f, 
    0.04014965f, 0.11995937f, -0.12704889f, -0.14225331f, 0.01199346f, -0.14365910f, -0.04622078f, -0.01154986f, 
    -0.05011557f, -0.00302000f, -0.14859076f, -0.14381874f, -0.23701799f, -0.06959569f, 0.23997192f, 0.07813853f, 
    0.10476515f, -0.06043081f, 0.00164937f, 0.03974139f, 0.10306271f, 0.18502867f, 0.01506197f, 0.08855656f, 
    0.16439959f, 0.06633818f, 0.08578767f, 0.17861472f, -0.15636058f, 0.00588129f, -0.07875743f, 0.03042860f, 
    0.08627743f, 0.17334773f, 0.10472250f, -0.05899034f, -0.36464721f, -0.32458386f, 0.32288146f, -0.20072562f, 
    -0.06059029f, 0.06346737f, 0.10683145f, 0.09454231f, 0.10744971f, -0.04211115f, -0.02690705f, 0.05554371f, 
    -0.44101590f, 0.02870751f, -0.00276302f, 0.02804546f, 0.06513759f, 0.08985648f, -0.02391200f, -0.08621667f, 
    0.03955639f, 0.09339505f, 0.04790436f, -0.07411332f, -0.21469931f, 0.38554278f, 0.06592112f, 0.25953361f, 
    0.07511510f, 0.13777180f, -0.22701895f, 0.08745870f, -0.11565841f, -0.08359850f, 0.09377503f, 0.16889043f, 
    0.13025062f, 0.01687918f, -0.02546320f, 0.02192334f, 0.04342351f, 0.01945023f, -0.05614102f, -0.00785314f, 
    0.07028000f, -0.33937210f, 0.30299667f, -0.05837650f, 0.06015250f, -0.36037245f, -0.08904789f, 0.06481943f, 
    -0.00347404f, 0.00893236f, -0.01966417f, -0.12602808f, -0.16075036f, 0.13332425f, -0.20742540f, -0.05973572f, 
    -0.10065103f, 0.25769597f, 0.37108418f, -0.03448046f, 0.05643441f, -0.03209263f, 0.06543099f, -0.02725767f, 
    0.08103976f, 0.04684927f, -0.08564649f, -0.08053686f, 0.43126461f, -0.68911165f, 0.28308558f, -0.10028914f, 
    0.07971093f, -0.12982672f, 0.01912801f, -0.08470828f, -0.07433237f, -0.21916831f, 0.10710234f, -0.00452670f, 
    0.88808531f, 0.36904472f, 0.00524824f, -0.09751412f, 0.05979953f, -0.11041602f, -0.04974449f, 0.01377382f, 
    -0.05108431f, 0.00892841f, 0.07906250f, 0.20263781f, 0.01331440f, -0.35195342f, -0.03593403f, -0.12027168f, 
    0.17727390f, 0.05056906f, -0.08546778f, 0.10849398f, -0.10478042f, 0.12404961f, -0.03545189f, -0.10598207f, 
    -0.07435561f, -0.22586177f, 0.11857963f, -0.07191853f, -0.01599606f, 0.03483412f, -0.06853007f, 0.05328608f, 
    0.13381115f, 0.07479052f, -0.03642943f, 0.15116465f, -0.13039307f, -0.14341049f, -0.25847274f, 0.06973521f, 
    0.11956675f, -0.07390867f, 0.05267496f, -0.08877937f, -0.12220974f, 0.00012821f, -0.01463789f, -0.05515005f, 
    -0.23261681f, 0.24517725f, -0.39049715f, 0.02423704f, 0.06382390f, 0.04386613f, -0.04900398f, -0.03090702f, 
    0.17440979f, -0.03866920f, 0.10329446f, -0.02846140f, 0.39104667f, 0.24835183f, -0.33128113f, 0.11723596f, 
    -0.02493699f, 0.02332494f, -0.15731055f, 0.17455414f, 0.01195198f, 0.00830197f, -0.00655384f, 0.11320522f, 
    -0.23556437f, -0.04064104f, 0.00536402f, 0.20858602f, -0.01777974f, 0.08471680f, 0.05571122f, -0.17271008f, 
    -0.05753939f, 0.10413381f, -0.09860060f, 0.05777244f, -0.20157015f, -0.03363835f, 0.13304777f, 0.24265000f, 
    0.01453902f, 0.02374351f, -0.03101645f, 0.00782423f, -0.15764526f, -0.16847803f, -0.20632997f, -0.06018455f, 
    0.29188889f, 0.22666214f, -0.11673392f, 0.00214561f, -0.09583916f, -0.27748403f, -0.10708512f, 0.04290416f, 
    -0.06445470f, -0.14781865f, -0.18325885f, -0.12790446f, 0.18631767f, 0.00130273f, 0.08111582f, -0.00604328f, 
    -0.26836443f, 0.07688371f, 0.07899009f, 0.16873625f, -0.07277422f, 0.10311111f, 0.13131894f, 0.13447055f, 
    0.27213049f, -0.06201284f, 0.02341447f, 0.08168279f, 0.05420549f, -0.07938706f, -0.13599859f, 0.28131136f, 
    0.00868696f, -0.07028460f, -0.21678121f, 0.09401355f, -0.26266953f, -0.03077569f, 0.22504497f, -0.00410039f, 
    -0.02261937f, -0.04511783f, 0.11228878f, -0.11323874f, 0.02942307f, 0.06011748f, -0.03849421f, -0.07481999f, 
    0.03139275f, -0.17122617f, -0.07655197f, -0.01501078f, 0.00937257f, -0.04062981f, -0.02566114f, 0.17347144f, 
    -0.04997470f, 0.06940416f, 0.06887038f, 0.11284193f, 0.12814967f, -0.21493277f, -0.14918913f, -0.05387583f, 
    -0.07864759f, 0.12807065f, -0.03654762f, 0.13803440f, 0.02217717f, 0.02330994f, -0.00915377f, 0.04947060f, 
    -0.21789512f, -0.23136219f, 0.07747619f, -0.26552185f, 0.14459813f, -0.08844446f, 0.11057567f, 0.01839013f, 
    -0.01234574f, 0.09082606f, -0.08169947f, 0.03645395f, 0.29912037f, 0.06084953f, -0.06308585f, -0.10550787f, 
    0.07807095f, 0.17773950f, 0.10524680f, 0.10886744f, -0.04484762f, 0.04111526f, 0.04001354f, -0.03722925f, 
    -0.56883967f, -0.40626758f, -0.46418422f, -0.28885302f, 0.03851414f, -0.06152853f, -0.11843739f, 0.07650065f, 
    -0.03272904f, 0.03345810f, -0.03799663f, -0.02413805f, 0.26840037f, 0.16012760f, -0.08410316f, 0.11209563f, 
    0.08185472f, 0.04380372f, 0.12089027f, -0.10307178f, -0.09731853f, 0.14226365f, 0.07980207f, -0.05209557f, 
    -0.08948040f, 0.25378749f, 0.18695849f, -0.14205179f, 0.06385225f, 0.06167583f, 0.07027268f, 0.07311775f, 
    0.11721098f, 0.21237507f, 0.04108250f, 0.24669832f, -0.02937577f, 0.03168340f, 0.10701947f, -0.07938615f, 
    -0.07515734f, 0.12725219f, -0.05411636f, 0.10236866f, 0.01604457f, -0.08252972f, -0.03234633f, -0.05240596f, 
    -0.11556584f, 0.20498763f, -0.45087188f, -0.18303449f, 0.15664950f, -0.01706753f, -0.03750032f, -0.09993961f, 
    0.09802083f, 0.00383363f, 0.02678329f, -0.15827274f, 0.26910281f, 0.27618265f, -0.06541853f, -0.02764561f, 
    -0.11270458f, -0.14096498f, 0.01092760f, 0.24811175f, -0.04565204f, 0.15370661f, 0.32061821f, 0.02061421f, 
    0.30553001f, 0.06089842f, -0.09559253f, 0.02785366f, -0.01544666f, 0.05880097f, 0.04980971f, 0.03325516f, 
    0.12820631f, 0.17433040f, 0.14190556f, -0.02946994f, 0.23687030f, 0.01712948f, -0.02728216f, -0.08078381f, 
    -0.12348285f, 0.10400493f, 0.02009336f, -0.04495424f, 0.13726513f, -0.14995959f, -0.04269172f, -0.23712245f, 
    -0.24793759f, 0.14087735f, 0.02169141f, -0.14134009f, 0.11125527f, -0.17631274f, -0.17938726f, -0.07534830f, 
    -0.16212729f, -0.08766846f, 0.11426251f, 0.04092804f, 0.01570064f, 0.01807559f, -0.21176434f, -0.07060064f, 
    0.00185671f, -0.00329048f, 0.00786053f, -0.10634276f, -0.18159331f, -0.00020389f, -0.01115843f, -0.13925833f, 
    0.42508018f, -0.03089173f, -0.12440549f, 0.12710875f, -0.00848384f, 0.00313931f, 0.09991922f, 0.05918149f, 
    0.07107195f, -0.26184642f, -0.27869779f, -0.29735973f, -0.20888218f, -0.42199680f, 0.19001572f, 0.05236047f, 
    -0.02321600f, 0.17840856f, 0.22311565f, -0.18314862f, 0.17764664f, -0.00774180f, 0.00822176f, -0.08893131f, 
    -0.75366068f, -0.50643438f, -0.04272068f, -0.09058408f, 0.04636354f, -0.07957271f, 0.18798201f, -0.17696173f, 
    0.08389700f, 0.02890882f, -0.06642646f, 0.06354614f, 0.33290428f, -0.03488719f, -0.08212116f, 0.00948772f, 
    -0.22729130f, 0.10053550f, 0.02095752f, -0.04044826f, 0.09504476f, 0.09953526f, 0.11568515f, 0.18857861f, 
    -0.90544647f, -0.58576804f, -0.10423537f, 0.04445072f, 0.24032326f, 0.03406966f, -0.11349285f, -0.03120555f, 
    0.21111426f, 0.02605146f, -0.07873089f, 0.14494954f, -0.59458214f, 0.02572298f, -0.35690930f, -0.08915114f, 
    -0.01755037f, -0.03724026f, -0.02738218f, -0.04739795f, 0.10857486f, 0.13054536f, -0.06504764f, 0.01096429f, 
    0.10262283f, -0.08033849f, 0.12384780f, 0.14153898f, -0.12370979f, -0.15267955f, 0.09681916f, -0.05182597f, 
    0.04696111f, 0.07349370f, -0.05476168f, -0.01033158f, 0.16597044f, -0.04257935f, -0.00280944f, -0.06671277f, 
    0.02270475f, 0.03365445f, -0.04862988f, -0.09947499f, 0.01242014f, 0.00480650f, 0.01854661f, 0.12502761f, 
    -0.52088147f, -0.42934778f, -0.00059357f, -0.10471029f, 0.16225131f, -0.07368420f, -0.20492376f, -0.05026667f, 
    -0.12898132f, -0.06781480f, 0.00915267f, 0.02098805f, -0.83471698f, -0.41366723f, 0.18335675f, -0.22035760f, 
    0.05224977f, 0.00982274f, -0.10385030f, 0.01859764f, 0.13632093f, 0.07126445f, 0.00192147f, 0.25893143f, 
    -0.09534947f, -0.27592534f, -0.02178887f, 0.13918754f, 0.09930535f, -0.12568064f, 0.16048326f, 0.09714429f, 
    0.04462405f, -0.00927923f, 0.01319415f, 0.14398286f, -0.14413473f, 0.04045626f, -0.02870330f, 0.02544180f, 
    0.10515912f, 0.16404594f, -0.00810533f, -0.00987825f, -0.00373573f, -0.07858979f, 0.13200994f, 0.01540598f, 
    0.30722013f, 0.23930457f, 0.19063979f, -0.09236117f, 0.26378551f, 0.01126173f, -0.00142287f, -0.03465676f, 
    0.01080361f, 0.06259203f, -0.06251290f, 0.00996097f, -0.12362483f, -0.13424534f, 0.08466277f, -0.10330827f, 
    0.02369560f, 0.10494356f, -0.10781581f, 0.05727937f, -0.06509358f, -0.02115408f, 0.00928998f, -0.04570653f, 
    -0.21608607f, -0.23807126f, -0.11713905f, -0.22425441f, -0.06615710f, 0.10324708f, 0.11160012f, 0.14025888f, 
    -0.16624349f, 0.03767829f, -0.08439054f, 0.16787152f, -0.00653994f, 0.08119654f, -0.12504157f, 0.00205394f, 
    -0.11891386f, 0.03743098f, -0.04245697f, -0.07087811f, -0.03383527f, -0.00329489f, 0.04358899f, 0.07000571f, 
    -0.19702502f, -0.04928973f, 0.12294403f, -0.04890658f, -0.00064553f, -0.01265188f, 0.19463572f, 0.07697282f, 
    -0.03403157f, 0.06722671f, 0.19760644f, -0.03568625f, -0.09116288f, -0.18867062f, 0.16053632f, -0.10456884f, 
    0.01502426f, -0.17263989f, -0.00301653f, 0.02263035f, 0.16357240f, 0.00006561f, 0.16835922f, -0.02667438f, 
    -0.14911641f, 0.27580464f, -0.04018051f, 0.05194065f, 0.18260975f, -0.05643190f, -0.00564468f, -0.07658688f, 
    0.13308096f, 0.06028383f, -0.04058132f, -0.02359575f, -0.50633705f, 0.13946320f, 0.06978778f, -0.04706815f, 
    0.04871644f, -0.11206757f, -0.03228088f, 0.13239087f, -0.14219096f, -0.09710144f, 0.04814688f, -0.07176484f, 
    0.66482860f, 0.06001496f, -0.27787015f, -0.25344810f, 0.16381915f, -0.19956617f, 0.03845083f, 0.00870050f, 
    0.07673992f, 0.02723444f, 0.08716984f, 0.05034128f, 0.20733291f, -0.10253061f, -0.20280255f, 0.13296904f, 
    -0.04794202f, 0.13823797f, -0.06758206f, -0.07442199f, 0.11013257f, -0.02956376f, -0.13754573f, -0.12569308f, 
    -0.26358217f, -0.34265620f, -0.15945329f, -0.25690404f, 0.16582589f, 0.00860923f, 0.06141584f, 0.03618699f, 
    -0.03397920f, -0.02507457f, 0.02772477f, -0.03104715f, -0.17391184f, 0.08085929f, -0.10623246f, -0.06449688f, 
    -0.09423248f, 0.15313706f, 0.09869237f, -0.11325226f, 0.08359300f, -0.13949434f, 0.03110499f, 0.12061070f, 
    0.38887477f, 0.21047218f, -0.19614486f, 0.26529837f, 0.02526617f, -0.10907634f, 0.00555191f, 0.10296880f, 
    0.00497297f, -0.02265382f, -0.04090636f, -0.12006180f, -0.16451313f, 0.35742623f, 0.02265477f, 0.02433513f, 
    -0.09824584f, 0.16032711f, -0.06964328f, -0.18001039f, -0.01296982f, 0.08713185f, -0.08108653f, -0.16723257f, 
    -0.30864418f, -0.05939657f, 0.09475550f, 0.42882785f, 0.07377871f, 0.17226103f, -0.04923293f, -0.03934709f, 
    0.02897186f, -0.08654823f, 0.13020208f, 0.30272421f, 0.00922954f, -0.03356338f, -0.04366139f, 0.38688591f, 
    0.02463699f, -0.10535056f, 0.01996722f, -0.00491008f, -0.09490494f, -0.07746814f, -0.09193327f, -0.05777765f, 
    0.04669560f, -0.13790613f, -0.05541495f, 0.07786532f, -0.00980041f, 0.03906062f, -0.14445366f, 0.07229695f, 
    -0.00659999f, 0.03016715f, -0.12744546f, -0.04426238f, 0.02627160f, -0.02655038f, -0.01405218f, 0.03443022f, 
    -0.17939082f, -0.22358847f, -0.02814949f, 0.11456490f, 0.15973137f, 0.00094053f, 0.03961486f, 0.04841733f, 
    -0.19373485f, 0.16665512f, 0.10354509f, -0.03571248f, -0.27269477f, 0.08807831f, -0.07679884f, -0.05176250f, 
    0.15970530f, -0.09902763f, -0.02722105f, 0.02657405f, -0.07642724f, -0.58306503f, -0.03283880f, 0.03463966f, 
    -0.13949007f, 0.13495326f, -0.02022084f, 0.10763866f, -0.07644176f, 0.06229995f, -0.06299932f, 0.04096795f, 
    -0.05817815f, 0.29689118f, -0.28076133f, 0.11658964f, 0.00326228f, -0.15665762f, 0.10040644f, 0.08380283f, 
    -0.00909704f, 0.04338000f, 0.10929547f, 0.00364324f, 0.04896306f, 0.35397378f, -0.09315557f, 0.28104442f, 
    0.18275419f, -0.11461882f, -0.19657584f, -0.12017481f, 0.06042155f, 0.05128771f, -0.00884596f, 0.05845586f, 
    0.02087905f, 0.19200596f, -0.12722327f, -0.29873243f, 0.17849278f, -0.12687100f, -0.14450318f, 0.19963077f, 
    -0.08606308f, -0.09045316f, 0.03659604f, -0.25313231f, -0.63162881f, 0.20516647f, -0.19210622f, 0.12246844f, 
    0.07186285f, -0.01578083f, 0.15192282f, -0.03933646f, -0.04215835f, -0.14096476f, -0.02317118f, 0.07394230f, 
    0.48942590f, -0.16829084f, -0.03835496f, -0.13495846f, 0.13554947f, -0.03189468f, -0.05328440f, 0.01892872f, 
    -0.02208796f, 0.08931399f, 0.02584860f, 0.12609765f, -0.58553725f, 0.31508037f, -0.21102513f, -0.04862390f, 
    -0.04098555f, -0.09248520f, -0.01425484f, 0.24808653f, -0.03498416f, -0.00570541f, -0.02923908f, -0.03499954f, 
    -0.40931875f, -0.07968720f, 0.09174628f, -0.08309415f, 0.01745623f, 0.04539096f, -0.15064001f, 0.10552540f, 
    0.00871984f, 0.00444286f, 0.00432566f, -0.24086875f, 0.29901797f, 0.19419278f, 0.02043241f, -0.22761086f, 
    -0.04584190f, -0.15814359f, -0.00446194f, -0.14085820f, -0.07652856f, -0.02380167f, -0.01430152f, -0.17243396f, 
    -0.45047751f, 0.20665392f, -0.11817624f, -0.38592455f, -0.16607644f, 0.00246260f, -0.03137958f, 0.13243194f, 
    0.14267322f, 0.02644835f, -0.13700168f, -0.01523476f, -0.05040921f, 0.30822834f, -0.27655864f, -0.18859777f, 
    0.17854075f, -0.03399296f, 0.06927800f, 0.01849227f, 0.12977463f, -0.03773646f, -0.12261508f, -0.08898270f, 
    0.13293231f, -0.15734853f, -0.00753496f, 0.11388726f, 0.17559023f, -0.26245371f, 0.05353103f, -0.01181592f, 
    -0.01358771f, -0.04538674f, -0.03305122f, 0.07908341f, -0.21695791f, 0.20452659f, 0.23475914f, -0.14779930f, 
    0.09311841f, -0.05017872f, -0.10440179f, -0.06772157f, 0.03181424f, 0.12501290f, 0.01726053f, 0.05314987f, 
    0.07567212f, 0.19504155f, -0.37747365f, 0.18475625f, -0.01129114f, -0.40142745f, -0.09199180f, 0.04560933f, 
    0.07679986f, 0.04821235f, -0.05058513f, -0.04209587f, 0.09630381f, 0.10806048f, -0.15126976f, -0.01457879f, 
    0.17374006f, 0.13165650f, 0.08195687f, -0.15255292f, -0.00979648f, 0.12830096f, -0.16765423f, -0.02081920f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02897647f, 0.04451896f, -0.01630218f, 0.02526947f, -0.02278516f, -0.02040496f, -0.00538641f, -0.08384037f, 
    -0.06782776f, 0.01642001f, 0.15678641f, 0.01676750f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
