#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.83196855f, 0.36860490f, -0.37751076f, -0.74236298f, -0.34451902f, -0.12619644f, 0.16048037f, 0.48104545f, 
    0.04532946f, -0.45524487f, -0.31808430f, 0.21915519f, -0.09183010f, -0.14841822f, 0.08804973f, -0.10187020f, 
    -0.11990720f, -0.00564151f, 0.15304478f, -0.18211290f, -0.22088394f, 0.01555470f, -0.25115293f, -0.58928162f, 
    -0.55680025f, -0.67775941f, -0.31587851f, -0.00467925f, -0.45930329f, -0.06101154f, -0.53436339f, -0.18902014f, 
    -0.32215992f, -0.53757101f, -0.29005578f, -0.05290499f, 0.61934894f, -0.42143825f, -0.26642656f, -0.11475860f, 
    0.12429043f, -0.37794542f, -0.31263632f, -0.24730916f, -0.42448783f, -0.03636399f, 0.01842402f, 0.06031166f, 
    -0.13849069f, 0.37265390f, -0.04402526f, 0.65446836f, 0.19496727f, -0.41469377f, 0.10098933f, -0.13293362f, 
    0.45423901f, -0.33071128f, -0.27912596f, -0.29390180f, -0.07727087f, 0.27322042f, -0.17618515f, 0.20004377f, 
    -0.27092072f, 0.18202023f, -0.11097713f, -0.20083416f, 0.30184680f, -0.16321945f, -0.04046001f, 0.03333150f, 
    0.10561536f, -0.16953546f, 0.16565126f, 0.47494286f, 0.59790784f, -0.42197177f, -0.09598707f, -0.09979025f, 
    -0.29497665f, -0.26086077f, -0.28913668f, -0.39767757f, 0.13665241f, 0.09697450f, 0.30293083f, 0.28891200f, 
    0.11172295f, -0.06742275f, -0.24496935f, 0.12509850f, -0.15341289f, 0.16343898f, 0.08943277f, 0.21494493f, 
    -0.29042158f, -0.21200065f, 0.12892522f, -0.24797559f, -0.14237323f, -0.46299452f, 0.31714851f, 0.08047844f, 
    0.17911132f, -0.36844033f, -0.39136660f, 0.03603636f, 0.44642842f, 0.30466175f, -0.17692727f, -0.26892427f, 
    -0.16556644f, 0.12528962f, 0.27661866f, -0.20389017f, -0.13077615f, 0.29614553f, 0.23062268f, -0.41678894f, 
    0.15944318f, -0.05868581f, -0.05481145f, 0.24784824f, 0.03564543f, 0.11845439f, 0.41222531f, 0.36996564f, 
    0.28634468f, 0.35635346f, -0.48089606f, -0.38227350f, -0.09370896f, -0.12816453f, -0.32146651f, 0.06242720f, 
    0.00358911f, 0.01220905f, -0.17289776f, -0.06616670f, 0.20146914f, 0.34192502f, -0.17771663f, -0.12302285f, 
    0.19377775f, -0.10000063f, 0.04618960f, -0.19900005f, -0.28321907f, -0.33197293f, -1.05651581f, -0.32314262f, 
    -0.13371561f, -0.95934719f, -0.89987749f, 0.60341221f, 0.04437085f, -0.20270823f, 0.13314803f, 0.48939791f, 
    -0.24675989f, -0.30497229f, -0.09988905f, -0.18063369f, -0.20512576f, -0.00715142f, -0.13978888f, -0.18119878f, 
    -0.18286218f, -0.03878394f, -0.04970748f, 0.07046283f, 0.06753783f, 0.05297835f, -0.00164312f, -0.43066424f, 
    0.02728706f, -0.49614111f, 0.04687826f, 0.42845723f, -0.21519117f, -0.11668164f, 0.45290825f, -0.51579964f, 
    -0.25583541f, 0.30132103f, -0.36093423f, 0.32049474f, 0.01820242f, -0.11154976f, -0.28903490f, 0.28040507f, 
    -0.02486638f, -0.13445422f, 0.03841624f, 0.17220066f, -0.18624315f, 0.10704783f, 0.34715188f, 0.25223863f, 
    -0.49147829f, -0.87077552f, 0.38581806f, 0.67909455f, 0.24932534f, -0.66823715f, -0.51930618f, 0.25195953f, 
    0.18226346f, -0.46129346f, 0.07582124f, 0.17517567f, -0.15070483f, 0.47612751f, -0.47351602f, -0.20129073f, 
    0.16692634f, 0.26673210f, -0.24813947f, -0.16211769f, 0.09403277f, 0.32080704f, -0.04373348f, -0.23272145f, 
    -0.15678301f, 0.86525679f, -0.93060052f, -0.43626747f, 0.29920983f, -0.53350592f, 0.25546837f, -0.33032975f, 
    -0.40211704f, -0.04669292f, 0.16549477f, -0.38893098f, -0.31254685f, -0.26529494f, -0.04785316f, 0.01598273f, 
    0.30846885f, -0.14840958f, -0.11720300f, -0.13770030f, -0.42372745f, -0.14004368f, -0.19946736f, -0.20425312f, 
    -0.27711776f, -0.02430492f, -0.14103436f, -0.74963260f, -0.01265302f, 0.51727241f, -0.62323368f, 0.41693610f, 
    -0.23229866f, -0.66156673f, -0.47451523f, -0.43167233f, 0.55100876f, -0.09242627f, 0.04768333f, 0.26595655f, 
    0.53541553f, -0.28592607f, -0.10984688f, -0.15617247f, -0.13406719f, -0.19706048f, -0.06594983f, -0.04745542f, 
    0.13152871f, -0.07601980f, -0.07081284f, 0.18221214f, -0.20434408f, -0.29345962f, 0.06144919f, 0.08230770f, 
    0.29789680f, 0.39087677f, 0.46087733f, 0.12085421f, -0.21087520f, -0.26071349f, 0.05661869f, -0.20080884f, 
    -0.31663924f, -0.02760062f, -0.06396770f, 0.00896197f, -0.23121771f, 0.10974053f, -0.31306323f, 0.31884483f, 
    0.17773852f, -0.32315788f, -0.06914461f, 0.33959430f, 0.51385576f, -0.36634257f, -0.25571081f, 0.42275852f, 
    0.54531896f, -0.12875421f, 0.34400821f, -0.27863136f, -0.45902711f, -0.13884374f, 0.03898947f, 0.31563619f, 
    -0.01139304f, -0.07663857f, -0.12541449f, -0.14193349f, -0.00416413f, 0.08879627f, 0.04485331f, -0.05557472f, 
    0.23150681f, -0.21248157f, -0.06417007f, 0.13100338f, -0.22294822f, -0.07436797f, 0.76156002f, 0.01256444f, 
    -0.25878680f, 0.14632212f, -0.40704104f, -0.28082511f, 0.09479759f, 0.18299936f, -0.44316530f, -0.27015337f, 
    -0.59927499f, 0.78434044f, -0.54626536f, -0.07349887f, 0.35782593f, 0.33763304f, -0.07335586f, -0.17890628f, 
    -0.19299056f, -0.05103452f, -0.08184490f, -0.24434265f, 0.21649785f, 0.30685499f, 0.20968059f, -0.18634348f, 
    0.12675461f, 0.00095879f, 0.23715867f, 0.14268853f, 0.51724213f, 0.10653430f, -0.02541639f, 0.13067949f, 
    0.01727154f, -0.02000778f, 0.08027369f, 0.08582541f, -0.09661708f, 0.13666984f, 0.01065575f, -0.00639573f, 
    0.18253805f, 0.01331438f, 0.16335528f, -0.27534539f, -0.16177210f, -0.10495424f, 0.33915943f, -0.59747124f, 
    -0.35357076f, 0.02311388f, -0.41168883f, 0.20600235f, -0.15619333f, -0.52844638f, -0.72594106f, -0.48965898f, 
    -0.08335435f, -0.07270478f, -0.18225655f, -0.25016940f, 0.06299254f, -0.46043631f, 0.32609278f, -0.13673735f, 
    0.13218071f, 0.01125222f, 0.21762796f, 0.06908266f, 0.04649649f, -0.30178574f, -0.14705272f, -0.35989228f, 
    -0.03431641f, -0.27058271f, -0.52933127f, -0.64333063f, -0.67878032f, -0.14424965f, -0.57374269f, -0.61658734f, 
    -0.77955616f, -0.65768379f, -0.09198314f, -0.08303177f, 0.23986472f, 0.34269276f, 0.28225160f, 0.20748289f, 
    0.11249857f, -0.06376263f, 0.01955025f, -0.15503207f, -0.23685175f, 0.21001507f, 0.38967717f, 0.14811498f, 
    0.02731806f, -0.34258643f, -0.23077981f, -0.52899820f, -0.41595146f, -0.10125861f, 0.19524662f, 0.28705910f, 
    -0.20322645f, -0.09877454f, 0.61935145f, -0.04238704f, 0.25605601f, 0.31902850f, 0.44784740f, 0.27162746f, 
    -0.24322191f, -0.14577970f, -0.21077429f, -0.23437628f, -0.57183748f, 0.07040932f, 0.29940018f, 0.15381703f, 
    0.01941308f, 0.00786174f, 0.44306880f, 0.76109827f, 0.29742870f, -0.32225430f, -0.10224354f, -0.36696830f, 
    -0.33708921f, -0.15933569f, 0.04403644f, 0.57034934f, -0.16024244f, 0.08217410f, -0.08501582f, -0.42703506f, 
    -0.34675381f, -0.02910228f, 0.15728229f, -0.16429348f, 0.09644532f, -0.07912466f, -0.12604274f, -0.03303324f, 
    0.15752123f, -0.15951365f, 0.01860751f, 0.49339417f, -0.80120808f, -0.77627069f, 0.05915550f, 0.21713457f, 
    0.48519206f, 0.14853792f, -0.18354590f, 0.56773698f, -0.26189223f, -0.23338978f, 0.35061297f, -0.03816157f, 
    -0.09166905f, -0.19130172f, -0.28334266f, -0.07068356f, 0.21884607f, 0.16212459f, 0.20671479f, 0.04684206f, 
    -0.03721835f, -0.11630328f, 0.07950194f, 0.03421489f, 0.02174778f, 0.01515409f, -0.26629323f, -0.31173530f, 
    -0.00297431f, -0.20966117f, 0.18624870f, 0.21111146f, 0.25183234f, -0.12608337f, 0.29332605f, 0.30152699f, 
    -0.19651741f, -0.15109952f, -0.06606490f, -0.02963446f, -0.32948709f, -0.28012493f, -0.22812204f, -0.33517480f, 
    -0.33756426f, -0.20401415f, -0.22770065f, -0.16724230f, -0.48449564f, 0.02085010f, -0.62372696f, -0.55681413f, 
    -0.41872802f, -0.07883925f, -0.55361754f, -0.55186826f, -0.27810305f, 0.14096251f, -0.04969835f, 0.31531170f, 
    0.24606779f, 0.08152281f, 0.01192355f, 0.25090516f, -0.04499711f, -0.17407641f, -0.24622670f, 0.01794741f, 
    -0.17891441f, -0.46352005f, -0.15630195f, -0.06613248f, -0.06367922f, -0.21296227f, -0.61547601f, 0.29866830f, 
    0.56264585f, -0.46735853f, -0.61244959f, -0.08225758f, 0.29190972f, 0.29258898f, 0.01283600f, -0.03308087f, 
    -0.02490579f, 0.41702491f, 0.05038215f, -0.43354282f, -0.18465419f, -0.31600663f, -0.01081003f, -0.07051723f, 
    -0.13606015f, 0.10556264f, 0.04025861f, 0.22959997f, 0.14331588f, -0.17657843f, 0.38784489f, 0.08784264f, 
    -0.10027850f, -0.00645857f, 0.01363263f, 0.05218377f, -0.11347981f, 0.15283760f, 0.28244093f, -0.25216064f, 
    -0.36776730f, -0.03715268f, 0.07906229f, -0.19069202f, 0.08111088f, -0.27966309f, 0.13291165f, 0.28219900f, 
    0.31242654f, 0.08372076f, 0.09095256f, 0.11264799f, 0.05309929f, 0.10814642f, -0.37861854f, -0.36301473f, 
    0.66125751f, 0.47060755f, 0.27027580f, -0.51047146f, 0.08188074f, 0.16676508f, 0.10202862f, -0.07476939f, 
    -0.51141059f, -0.65355062f, -0.16172734f, -0.08120704f, 0.13276398f, 0.19623363f, -0.00483866f, 0.25045496f, 
    0.21311185f, 0.05122447f, -0.17865922f, -0.09888420f, -0.32627186f, -0.22493176f, -0.06265967f, 0.39353067f, 
    0.01452409f, -0.41190445f, -0.32877487f, -0.31508058f, -0.28317437f, -0.05617612f, -0.18376665f, -0.36389244f, 
    0.20717491f, 0.33056998f, -0.31016874f, -0.18607055f, -0.21810776f, -0.16628313f, 0.32653850f, -0.36454913f, 
    0.22673240f, 0.06592808f, 0.27981606f, 0.07481865f, -0.09330084f, -0.16266581f, 0.26102248f, -0.14606631f, 
    -0.30342096f, -0.22541194f, -0.26059183f, -0.31330109f, -0.05840665f, 0.39783597f, -0.38665140f, 0.36598137f, 
    -0.40481433f, 0.07077506f, -0.05129325f, 0.14405119f, 0.07678083f, 0.15774547f, -0.15740944f, 0.48493659f, 
    -0.18893886f, -0.17567201f, -0.07162824f, -0.02917174f, -0.04665763f, -0.28232098f, -0.05905227f, 0.33973739f, 
    0.29278430f, 0.00681644f, 0.19102067f, -0.57142550f, -0.77118033f, 0.32910675f, 0.39423770f, 0.12788665f, 
    0.62010086f, 0.24219699f, -0.19127998f, 0.05111751f, -0.19803376f, -0.13289563f, -0.21742776f, 0.04003868f, 
    -0.23344071f, -0.34346822f, -0.08991684f, 0.07680240f, -0.01424204f, 0.08133594f, 0.15350959f, 0.17371942f, 
    0.04102156f, -0.15711455f, 0.03258916f, 0.10124138f, 0.21374993f, 0.56226742f, 0.41459107f, -0.28103381f, 
    0.07148650f, -0.10200213f, -0.11701930f, -0.06765508f, 0.04048961f, 0.06172109f, 0.16434634f, 0.05249104f, 
    -0.12646604f, 0.01375106f, -0.20004492f, -0.19405961f, -0.17863142f, 0.01658889f, -0.04553086f, -0.10852024f, 
    -0.12106040f, 0.43010351f, -0.13225812f, -0.05004683f, -0.41678935f, -0.10819591f, -0.23952991f, -0.07770597f, 
    0.47299558f, 0.13782920f, -0.02383510f, 0.31646737f, -0.36796525f, -0.27530941f, -0.11762622f, 0.31187382f, 
    0.08218873f, 0.34121761f, -0.52661502f, 0.23499230f, -0.03133324f, -0.03723546f, 0.20796046f, -0.15568934f, 
    -0.10927581f, -0.14812666f, -0.13119456f, 0.09651744f, 0.16817613f, 0.07250510f, 0.59509861f, 0.48620471f, 
    -0.27464741f, -0.07403243f, -0.86858392f, -0.24914761f, -0.12447561f, 0.34138530f, 0.18427248f, 0.09553962f, 
    0.03809854f, -0.40307191f, -0.00144676f, 0.16431797f, 0.06328949f, 0.09869729f, 0.07510921f, 0.02325028f, 
    -0.28815994f, 0.20358755f, -0.07843316f, -0.08067864f, -0.30932134f, 0.11158255f, 0.30372214f, -0.86123431f, 
    -0.42886609f, 0.11566878f, 0.41301671f, 0.47169301f, 0.75357306f, -0.10150434f, -0.72145909f, -0.26675782f, 
    0.04439269f, 0.12326839f, -0.25810587f, -0.05711658f, -0.08405111f, 0.03182706f, -0.22742859f, -0.13858768f, 
    0.10678007f, 0.41705552f, 0.19278106f, 0.18679284f, -0.31300098f, -0.26799285f, 0.14651488f, -0.12465420f, 
    0.23674135f, -0.03496205f, -0.24026059f, -0.02924812f, 0.03080210f, -0.28106892f, 0.14798713f, 0.18185589f, 
    -0.24568562f, -0.18464358f, -0.30729333f, 0.00719622f, 0.12199498f, -0.29052496f, -0.25100636f, -0.14326006f, 
    0.07825197f, 0.17196439f, 0.19051634f, -0.07677516f, -0.00077218f, 0.04731639f, -0.19476652f, 0.16642292f, 
    0.35746345f, -0.07796140f, -0.19738905f, -0.17596656f, 0.11748940f, -0.00571503f, 0.34473455f, 0.31841052f, 
    0.17277165f, 0.15185855f, -0.23202087f, 0.00266015f, 0.05876168f, 0.03057185f, -0.22218183f, 0.25703415f, 
    -0.47655708f, 0.11945126f, -0.04800481f, -0.28263074f, -0.08388180f, 0.15993653f, 0.06307743f, -0.02655541f, 
    0.15025115f, 0.38798791f, 0.52443439f, 0.13017993f, -0.08066007f, -0.17786384f, -0.26755989f, -0.14081080f, 
    0.00015150f, -0.36768726f, -0.25051972f, -0.21672699f, -0.09800833f, 0.46321654f, -0.00204200f, 0.15094568f, 
    0.39141560f, 0.15208673f, -0.08734683f, -0.05300396f, -0.14445134f, -0.03607964f, 0.00777333f, -0.41848406f, 
    0.14058851f, 0.30385655f, -0.28422645f, -0.37166342f, 0.07125818f, 0.39556935f, 0.46569002f, 0.03758683f, 
    -0.07386695f, -0.32430372f, 0.16368726f, -0.16501328f, 0.19140200f, -0.28447822f, -0.09136282f, -0.22840887f, 
    0.31390870f, 0.06978660f, -0.08930032f, 0.22682197f, -0.20663205f, -0.04671472f, 0.18890390f, -0.06744716f, 
    -0.08278599f, -0.08980523f, -0.00344731f, 0.01545106f, -0.29902717f, -0.14229305f, 0.23271832f, 0.34980014f, 
    0.23693390f, -0.86206239f, -0.31630141f, -0.30974385f, -0.35961416f, 0.22621422f, 0.44138080f, -0.35148251f, 
    -0.25894609f, 0.11888023f, -0.35068890f, 0.23034525f, -0.35060617f, 0.01450747f, -0.27200624f, -0.83844471f, 
    -0.00262270f, -0.14172086f, -0.19911928f, -0.01181308f, 0.15007909f, -0.25221440f, -0.26863179f, 0.06513383f, 
    0.29756862f, 0.25977492f, 0.28685239f, -0.40675354f, -0.37270015f, 0.28375772f, 0.39647704f, -0.12609784f, 
    0.21997450f, -0.00376901f, -0.02884968f, 0.14542694f, -0.30136889f, -0.21183026f, -0.06627250f, 0.19777018f, 
    0.02098374f, 0.25356761f, -0.19331774f, -0.23076224f, 0.26294503f, -0.11199080f, 0.42184511f, 0.35702345f, 
    0.00144866f, 0.27441993f, 0.36046201f, 0.31988731f, 0.42436618f, 0.15121134f, -0.04652429f, -0.08411013f, 
    -0.03031185f, 0.13675629f, 0.23276007f, -0.14088584f, -0.17219296f, -0.09537199f, 0.01438316f, -0.19989455f, 
    0.00065325f, -0.19727743f, 0.19461063f, -0.02794889f, 0.01812920f, -0.06702021f, -0.13544349f, 0.03890149f, 
    0.14541659f, 0.24565922f, -0.03124345f, -0.09351808f, -0.49842688f, 0.06935456f, 0.24065992f, 0.17038377f, 
    -0.01974205f, -0.16679193f, 0.36169785f, -0.04128075f, 0.09853039f, -0.27203938f, -0.00018285f, -0.13261902f, 
    -0.36749819f, 0.05505450f, 0.28989697f, 0.05925852f, 0.24694669f, 0.18693751f, -0.29281488f, -0.04145744f, 
    -0.14672206f, -0.03403294f, 0.12827981f, 0.26545218f, -0.06693786f, -0.60744900f, -0.07980812f, 0.48141250f, 
    0.14452849f, 0.21796694f, 0.12331656f, 0.18422742f, -0.01777652f, 0.00312574f, -0.15871182f, 0.12704568f, 
    0.10972214f, -0.11777484f, -0.46522281f, 0.06514829f, 0.14715907f, -0.32510263f, -0.23510517f, -0.05502105f, 
    0.48579124f, -0.95629638f, -0.68571448f, -0.22523125f, 0.31037295f, 0.44804904f, 0.53955030f, 0.45851707f, 
    0.01870471f, -0.34576803f, -0.37532982f, 0.09257289f, -0.10283305f, 0.17024264f, 0.16754951f, 0.14931670f, 
    0.02813801f, 0.07028589f, -0.28056368f, 0.19421594f, -0.12353995f, 0.46838126f, -0.26767895f, 0.01003536f, 
    0.24395248f, -0.07823524f, 0.49615744f, 0.01112506f, 0.10703859f, -0.17168041f, -0.41625389f, 0.12916054f, 
    -0.09713019f, -0.13935609f, 0.09575456f, 0.18032797f, 0.10345148f, -0.21426828f, 0.18353711f, -0.07807046f, 
    0.02994401f, -0.02608797f, 0.20474997f, -0.03151190f, 0.03959725f, -0.29993320f, 0.00438315f, 0.35913873f, 
    -0.20726268f, -0.27245528f, 0.32032961f, 0.13446230f, -0.76667291f, -0.08671553f, 0.32085052f, 0.46784881f, 
    -0.32806548f, -0.30789325f, -0.20783699f, 0.52125520f, 0.34942666f, 0.04461307f, -0.12761879f, -0.62279528f, 
    0.07397079f, 0.25505003f, 0.00685450f, 0.49597880f, -0.05215389f, -0.02726923f, -0.34711066f, -0.10818784f, 
    -0.07220862f, -0.32938188f, -0.24073200f, 0.02799574f, -0.79667163f, -0.21621247f, -0.56810254f, -0.86173505f, 
    -0.86580658f, 0.39279750f, 0.18839091f, 0.18208571f, 0.18905309f, 0.42069831f, 0.25322428f, -0.16015810f, 
    0.29351991f, -0.34416541f, 0.31726137f, -0.44212973f, -0.17651890f, 0.01046462f, -0.41122195f, -0.07646815f, 
    -0.06500602f, -0.21730436f, 0.24879950f, 0.03156463f, 0.36641818f, -0.83429259f, 0.46826035f, 0.24499825f, 
    0.35866347f, -0.33016410f, -0.34605664f, -0.63297170f, -0.05141375f, -0.08028856f, 0.35977152f, 0.22174111f, 
    0.18147714f, 0.12121192f, 0.09717901f, -0.15561165f, 0.14573909f, -0.04057040f, -0.11527825f, -0.08497550f, 
    0.02262185f, 0.10005286f, -0.31413642f, -0.15033364f, -0.15805723f, -0.47371101f, -0.47710752f, -0.52846658f, 
    -0.26510820f, -0.38806933f, -0.22739010f, 0.08753093f, -0.09655423f, -0.71863323f, -0.55576009f, 0.46510834f, 
    -0.05452590f, 0.11420552f, -0.15950271f, -0.52183950f, 0.15197943f, -0.08623981f, 0.01635644f, -0.24473828f, 
    0.05553001f, 0.11819169f, 0.02565654f, -0.24025032f, -0.17472713f, -0.12895226f, 0.04919922f, -1.19175863f, 
    -0.19947188f, -0.06027830f, 0.22502075f, 0.64256072f, 0.14524278f, 0.01421686f, -0.30306819f, 0.00413689f, 
    0.39194015f, -0.14319411f, -0.06015635f, -0.37751791f, 0.27407926f, -0.53550375f, 0.25534794f, -0.23371589f, 
    -0.37034115f, -0.04499331f, -0.27058285f, -0.47877073f, -0.14133997f, -0.46894297f, -0.49971467f, -0.63779902f, 
    -0.94751602f, -0.34208965f, -0.75220609f, -0.58053100f, 0.04115453f, 0.17579000f, 0.08845821f, 0.24039105f, 
    0.48016495f, 0.72648513f, 0.06302278f, 0.06733115f, -0.02994596f, 0.00034286f, -0.05133257f, 0.14212817f, 
    0.13898456f, 0.07887676f, 0.12138936f, 0.01946419f, -0.05456071f, -0.15193729f, 0.07929009f, -0.08774350f, 
    0.04201003f, -0.57582396f, -0.31787819f, 0.21365710f, 0.42453900f, 0.29927081f, 0.41021529f, 0.14540157f, 
    -0.21405193f, 0.05679322f, 0.09257966f, -0.21101469f, 0.17802078f, -0.11684780f, -0.16297041f, 0.06434114f, 
    -0.00268366f, -0.12597553f, -0.02516611f, -0.33279166f, 0.24500372f, -0.18554227f, -0.08684207f, 0.12558922f, 
    0.31583655f, -0.19557695f, 0.75880182f, 0.30640930f, 0.07477370f, -0.28074068f, -0.73544693f, 0.34681705f, 
    -0.42983198f, 0.19452123f, -0.07642120f, -0.68773925f, -0.01788112f, -0.36527130f, 0.09386770f, 0.01598489f, 
    -0.24499382f, 0.13690619f, 0.11432042f, -0.16950358f, 0.10944272f, 0.16808526f, -0.27454439f, -0.03526486f, 
    0.07647669f, 0.08659406f, 0.11282039f, 0.42220223f, 0.21703985f, -0.03776069f, 0.12909673f, -0.57788599f, 
    -0.29972529f, 0.03568488f, 0.35468906f, 0.25022253f, -0.26835108f, -0.29815921f, -0.24211104f, -0.13397461f, 
    0.19307661f, 0.00740053f, 0.41799307f, 0.05542035f, 0.07935333f, -0.08458126f, -0.37450469f, -0.20100062f, 
    -0.22501920f, -0.38427094f, -0.21559499f, -0.51491022f, -0.19104309f, -0.47630107f, -0.54263902f, -0.13353224f, 
    -0.08766195f, -0.17781992f, 0.39500001f, -0.20277308f, 0.28501678f, -0.55264610f, -0.10545902f, 0.04840611f, 
    -0.02142536f, -0.29919606f, -0.14719778f, -0.16299230f, -0.40388924f, -0.34454378f, 0.57509279f, 0.30210349f, 
    0.21876231f, -0.02852031f, 0.15753283f, -0.18454736f, -0.08300017f, 0.71482790f, 0.27515504f, 0.02001039f, 
    -0.76619339f, -0.69968277f, 0.70889407f, 0.08658031f, -0.06457015f, -0.24436474f, -0.01067786f, 0.33758247f, 
    -0.07816210f, -0.00030553f, -0.00540135f, -0.24865508f, -0.27762973f, -0.10100952f, 0.12085806f, 0.28595030f, 
    -0.02811173f, 0.19844988f, 0.16206235f, -0.22607429f, -0.12411156f, -0.00341548f, -0.07603588f, 0.78800350f, 
    0.41362062f, -0.39343184f, -0.56356269f, -0.56332308f, 0.05343697f, 0.03606898f, 0.03132905f, -0.17538245f, 
    -0.07655783f, -0.01948980f, 0.18592645f, -0.34148586f, -0.03371885f, 0.36450100f, 0.30794996f, -0.23524405f, 
    0.17949478f, -0.24164915f, 0.23175427f, 0.24505973f, -0.13050796f, -0.15953232f, -0.36918324f, -0.53755844f, 
    -0.75577480f, -0.66223776f, -0.22021858f, -0.87942898f, 0.46273330f, 0.08034695f, -0.05212178f, -0.00937934f, 
    0.34556797f, -0.35592863f, -0.37956017f, -0.15847135f, 0.05735838f, -0.08742815f, 0.24280235f, 0.20400998f, 
    -0.00725222f, -0.14559539f, -0.03885141f, -0.31844467f, -0.11199792f, 0.10561000f, -0.09289483f, -0.19365253f, 
    -0.98025095f, -0.63026065f, -0.28049242f, -0.26803234f, 0.43586591f, 0.30626532f, -0.14391722f, 0.06273536f, 
    0.68926364f, 0.50360197f, 0.32795903f, 0.06014240f, -0.21022418f, -0.30738428f, -0.35896736f, -0.42569417f, 
    0.19510776f, -0.04887628f, -0.02002337f, 0.12776981f, -0.05503512f, 0.27206853f, 0.16432309f, -0.13254097f, 
    0.02674204f, 0.95840907f, -0.37283340f, -0.58799690f, -0.75108582f, -0.65260112f, 0.16947910f, -0.29756406f, 
    0.32128111f, 0.32943621f, 0.01738599f, 0.34338358f, 0.16008152f, 0.41493532f, -0.02097835f, 0.18077457f, 
    0.10352010f, -0.18971744f, 0.24312791f, -0.28556833f, -0.11598025f, 0.08799300f, 0.00623080f, -0.02911960f, 
    0.08433024f, -0.19189507f, -0.54309064f, 0.08091424f, 0.18953396f, 0.21843968f, -0.38992256f, 0.32118967f, 
    -0.15484351f, -0.49516791f, -0.20717958f, 0.55773336f, -0.04054718f, -0.20845264f, 0.15770899f, 0.19714400f, 
    -0.16046211f, 0.12400387f, 0.13584858f, -0.25977626f, -0.23899621f, -0.13876195f, 0.24269851f, 0.05113491f, 
    0.36144534f, -0.28014690f, 0.06001614f, 0.05664733f, 0.53268045f, 0.00933237f, -0.27815124f, -0.04191207f, 
    -0.51065373f, -0.64602095f, -0.73173541f, -0.73975712f, -0.58770782f, 0.36658102f, 0.50364190f, -0.00217922f, 
    0.10265215f, -0.07626346f, -0.28700829f, 0.00251793f, 0.04085999f, -0.44060341f, -0.27123231f, 0.10094155f, 
    0.16524634f, -0.17753837f, -0.26817104f, -0.38848102f, -0.42740890f, -0.32695904f, -0.58395118f, -0.36980456f, 
    0.27284649f, -0.50895351f, -0.35156798f, -0.31179836f, -0.54702014f, -0.43804416f, -0.26666319f, -0.20876209f, 
    0.03887036f, 0.02097814f, -0.23389654f, -0.02638081f, -0.46828210f, 0.05255648f, -0.34604350f, -0.33852473f, 
    0.20782161f, 0.07254086f, -0.17077048f, 0.20333377f, 0.15541077f, 0.13533039f, -0.49969077f, -0.25292811f, 
    0.31724396f, 0.57971919f, -0.10910834f, 0.29481077f, -0.16174600f, 0.05328000f, -0.21233891f, -0.21722201f, 
    -0.12526146f, -0.14673793f, -0.12943082f, 0.05624313f, 0.15915349f, -0.05953843f, -0.19189170f, 0.35362923f, 
    0.10425854f, 0.05415002f, -0.35429418f, 0.01802972f, -0.07078917f, 0.13978444f, -0.20874019f, 0.61800593f, 
    0.28947952f, -0.35334855f, 0.15725188f, 0.09517089f, 0.04517381f, -0.15795965f, -0.29637074f, -0.14945252f, 
    -0.42988092f, 0.22189403f, -0.34528384f, -0.26128209f, 0.46749121f, 0.15695640f, -0.34078181f, 0.13517776f, 
    0.22420226f, -0.19549519f, -0.08486849f, 0.14867549f, 0.08103123f, 0.14781106f, -0.13361916f, 0.09850687f, 
    0.27750856f, -0.20911072f, -0.10997656f, 0.02424761f, 0.12744996f, -0.33082452f, 0.00083234f, -0.01021844f, 
    -0.30480006f, -0.23788758f, 0.07600449f, 0.11770186f, 0.21999337f, -0.14579958f, -0.07793661f, -0.05634880f, 
    0.24637632f, 0.26870650f, 0.06996170f, 0.09610249f, -0.06151870f, -0.17455198f, -0.07419620f, 0.29171127f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04744562f, 0.01167560f, 0.18202125f, 0.06480177f, 0.28059024f, 0.08107529f, -0.32698551f, 0.13977413f, 
    0.20688769f, 0.34079283f, 0.20965999f, 0.14481242f, 0.15512861f, 0.14833719f, -0.20802200f, -0.32384548f, 
    -0.24190457f, 0.05778583f, 0.35935295f, 0.16734460f, -0.13929206f, -0.10906631f, 0.13548444f, -0.21017978f, 
    0.14227302f, -0.40686116f, 0.02657912f, -0.07655023f, 0.14874615f, 0.01562985f, 0.26948059f, 0.33245045f, 
    0.10280386f, 0.22933315f, 0.06859785f, 0.20937890f, 0.09668747f, 0.40537170f, -0.16533929f, 0.34799409f, 
    0.44445524f, -0.00045637f, 0.38184723f, 0.05633840f, 0.50287580f, 0.01944025f, 0.19255385f, -0.04411991f, 
    0.30322129f, 0.43867570f, 0.10515130f, -0.09811434f, 0.21274766f, 0.40710390f, 0.17352480f, -0.30745745f, 
    0.14281823f, 0.21363410f, 0.09784680f, -0.06342715f, -0.27565062f, 0.07897036f, 0.00549236f, 0.13758147f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03025789f, -0.29321581f, -0.05329079f, 0.11971859f, 0.04269426f, -0.07114022f, -0.07225236f, -0.03305184f, 
    0.00827090f, 0.07478046f, -0.12995876f, 0.02921904f, 0.21843220f, 0.18748130f, -0.05312034f, -0.09496753f, 
    0.00992998f, 0.04793015f, 0.03865427f, 0.01982755f, -0.08211280f, -0.07776041f, -0.08274430f, -0.12216830f, 
    -0.21820186f, -0.20216104f, -0.46672058f, 0.21313289f, -0.03274608f, 0.01710934f, -0.09252843f, 0.00228700f, 
    -0.05754927f, 0.02272754f, -0.00521742f, -0.05943816f, 0.07371690f, 0.09369310f, -0.23071702f, -0.00041666f, 
    -0.04998746f, -0.04149130f, -0.20907736f, -0.09898311f, -0.03819855f, -0.01511941f, -0.00755778f, 0.00053395f, 
    -0.02978256f, 0.21302249f, 0.15922768f, -0.21754496f, -0.07202115f, -0.06752533f, -0.04066900f, -0.05674328f, 
    0.01120842f, -0.10236000f, -0.07147326f, -0.09515484f, -0.13748422f, -0.00055773f, 0.06428503f, -0.06443201f, 
    0.00649133f, -0.05385278f, -0.27998531f, -0.06290806f, 0.01560736f, 0.02729553f, 0.02766320f, 0.03807416f, 
    0.12962094f, 0.04737673f, 0.06272502f, -0.13376634f, 0.07160331f, 0.31796086f, 0.06982585f, 0.15161136f, 
    -0.00204314f, -0.03025230f, 0.01872751f, 0.01124381f, 0.07789589f, 0.18720248f, 0.01409949f, -0.11849833f, 
    0.12101518f, -0.01189443f, -0.00307806f, -0.12893242f, 0.01337218f, -0.01492904f, -0.07014648f, -0.09388624f, 
    0.24138878f, 0.12759879f, 0.27631491f, -0.40056393f, -0.14399594f, -0.07272483f, -0.02036600f, -0.00205085f, 
    -0.03224151f, -0.14372614f, -0.15967408f, -0.06737096f, 0.08166676f, 0.04056961f, 0.03240655f, -0.09162415f, 
    -0.06818566f, -0.07921487f, -0.04519518f, -0.13627477f, -0.12870541f, -0.07434811f, -0.01485153f, 0.10601982f, 
    0.21060920f, 0.01112271f, -0.26249668f, -0.26941976f, -0.08819526f, -0.05555638f, -0.05292104f, 0.00488329f, 
    -0.00653466f, 0.00008095f, 0.00341751f, 0.06110263f, -0.14505951f, -0.32160643f, -0.48072466f, 0.03929174f, 
    0.00305285f, -0.01100722f, 0.02258140f, 0.00607200f, -0.02698084f, 0.01327331f, -0.05993431f, -0.08734377f, 
    -0.05129122f, -0.06047244f, -0.17902926f, -0.08073579f, -0.14699408f, -0.08447412f, -0.03771513f, -0.08268810f, 
    0.00533895f, 0.01556380f, 0.01992853f, 0.01910459f, -0.07231461f, 0.05298956f, 0.02517385f, -0.03385966f, 
    -0.07166071f, -0.05933690f, -0.03898971f, 0.05244876f, -0.04454271f, 0.01323821f, -0.06654692f, 0.05147682f, 
    -0.00087061f, 0.03826606f, 0.01281783f, 0.05324598f, 0.00956975f, 0.00490085f, 0.02098230f, -0.01209328f, 
    -0.26734120f, -0.17732266f, -0.11783153f, -0.02848915f, 0.31527627f, 0.20611976f, -0.09005758f, -0.12540846f, 
    0.06359296f, 0.34023592f, 0.05643116f, 0.07878599f, -0.01657665f, -0.01422548f, 0.01276049f, -0.02874161f, 
    0.35908970f, 0.05028964f, -0.18420789f, -0.10455923f, 0.06059239f, 0.18650137f, -0.04605722f, -0.01709509f, 
    -0.04995639f, 0.01801592f, 0.01179116f, 0.07765430f, 0.14532396f, 0.08992032f, -0.11248013f, 0.00820960f, 
    0.03646278f, 0.07085028f, 0.06831424f, -0.03023418f, -0.08397259f, -0.07962023f, -0.09735269f, -0.01248355f, 
    -0.78014630f, 0.13534273f, -0.35991970f, -0.00326506f, -0.00114926f, 0.01508956f, -0.04507562f, 0.07267199f, 
    -0.05450099f, -0.03049529f, 0.03274480f, 0.01674350f, 0.12409793f, 0.08066373f, -0.23989287f, 0.08851982f, 
    0.05974844f, -0.07797861f, -0.00803006f, -0.12896092f, 0.04279750f, -0.00357359f, 0.01631407f, -0.04186856f, 
    -0.09375646f, -0.24318948f, -0.16727033f, 0.08759268f, 0.00847102f, 0.02715149f, -0.00203223f, 0.05866331f, 
    -0.05745351f, -0.01704066f, 0.13164657f, 0.16431941f, 0.28606367f, 0.14490159f, -0.02217339f, -0.14701660f, 
    0.02251833f, -0.06204970f, -0.15301049f, -0.08336912f, -0.05110104f, -0.05306700f, -0.14754857f, 0.05721341f, 
    -0.04521443f, -0.15045264f, 0.13662545f, -0.09839340f, -0.15470338f, -0.12084199f, 0.00844976f, 0.01231989f, 
    -0.01005598f, -0.11325108f, 0.09049433f, -0.16649891f, 0.11263128f, -0.06812716f, 0.04686394f, -0.00906630f, 
    0.06559927f, -0.05201785f, 0.07374344f, 0.02841698f, 0.02290743f, 0.19977593f, 0.07040630f, 0.02576103f, 
    0.10074507f, -0.28203407f, -0.28007391f, 0.04515338f, 0.01331276f, 0.00042731f, -0.12647544f, 0.02012011f, 
    -0.06251693f, 0.08359814f, 0.02134367f, 0.00558285f, 0.25260270f, 0.19185033f, 0.13636817f, -0.01153088f, 
    0.06280249f, 0.23175046f, 0.14890629f, 0.23410173f, 0.00966889f, 0.04166620f, 0.01212435f, 0.06616889f, 
    -0.08032425f, 0.01181189f, 0.15780814f, -0.03201777f, -0.00035185f, 0.07097357f, 0.00223769f, -0.13386697f, 
    0.00697380f, -0.11264745f, -0.10594615f, -0.02977522f, 0.45696434f, 0.07701888f, -0.27423730f, -0.42119417f, 
    -0.12453303f, -0.12567072f, 0.14340726f, 0.04285152f, 0.02384708f, 0.01089723f, -0.10143668f, -0.02549202f, 
    -0.41853532f, -0.39430165f, -0.13550490f, 0.15341121f, 0.02997483f, 0.04467495f, 0.04254717f, 0.03815849f, 
    0.00375136f, -0.01212975f, 0.00721768f, 0.06002920f, 0.01742304f, 0.08937393f, 0.01957766f, -0.07869850f, 
    0.06074361f, 0.02024516f, -0.00830082f, -0.06455164f, 0.01330067f, -0.17243987f, -0.00919640f, -0.06672469f, 
    -0.16225535f, -0.27542785f, 0.12598316f, 0.02401432f, 0.01390729f, 0.12255187f, -0.12848385f, -0.16832118f, 
    -0.13497460f, -0.01649207f, 0.01637108f, -0.17996338f, 0.44706604f, 0.14631830f, -0.18269227f, -0.28794003f, 
    -0.08580749f, -0.12524065f, -0.02948245f, -0.03094053f, -0.00090139f, -0.11641027f, -0.09583868f, -0.04305104f, 
    0.06399840f, 0.07162118f, -0.08059499f, -0.02314265f, 0.00635508f, -0.04977267f, -0.05974381f, 0.05213436f, 
    0.00514920f, 0.04440058f, 0.03269947f, -0.01837276f, -0.08128736f, -0.06282059f, -0.13357696f, -0.00413612f, 
    0.03805032f, 0.03252610f, -0.00738201f, -0.01268996f, -0.08677237f, -0.15967268f, -0.14434567f, -0.24891329f, 
    0.18226252f, 0.03231523f, -0.12625870f, -0.08948395f, -0.14755490f, -0.10471128f, -0.15795676f, -0.01797124f, 
    0.02489053f, 0.08752783f, -0.09871211f, -0.02475170f, -0.38920140f, -0.23632863f, 0.10995815f, -0.19524500f, 
    0.01969112f, -0.02940356f, 0.05218145f, 0.06579718f, 0.01318463f, -0.01861623f, -0.02489081f, -0.00929546f, 
    0.11336852f, 0.27346697f, 0.17283611f, -0.26149243f, -0.12839480f, 0.03118823f, -0.09825190f, -0.01679852f, 
    -0.04979649f, -0.04741733f, -0.15011743f, -0.03229447f, -0.08996506f, 0.12109534f, 0.08344027f, -0.04273537f, 
    -0.03979398f, -0.00335699f, -0.01600622f, 0.01671126f, 0.02421362f, 0.01984092f, -0.06185358f, -0.06545778f, 
    -0.23338412f, -0.23008882f, -0.29472718f, 0.06088366f, 0.05300374f, 0.03860520f, 0.05227096f, 0.01379514f, 
    -0.02667919f, 0.02402977f, 0.05022769f, 0.05023089f, -0.37236494f, -0.30823883f, 0.15036321f, -0.09947222f, 
    -0.10861265f, -0.07622262f, -0.09230873f, 0.06871559f, -0.03614265f, -0.08069236f, -0.00056436f, 0.00765768f, 
    -0.24457932f, -0.13009715f, 0.13872463f, -0.00010476f, -0.07860099f, -0.02335501f, 0.06890693f, 0.10341878f, 
    -0.32235539f, -0.05892924f, -0.02129199f, -0.10541593f, 0.21880467f, 0.04116572f, -0.07024451f, -0.05400138f, 
    -0.00313005f, 0.06526545f, 0.02904794f, -0.15280506f, -0.20678101f, -0.09767356f, -0.04310474f, 0.01010124f, 
    -0.13361014f, -0.55334860f, -0.09738956f, 0.00383183f, -0.05053736f, 0.02017530f, 0.01793589f, -0.06444891f, 
    -0.12769905f, -0.24690031f, -0.07317857f, -0.13955480f, -0.12293024f, 0.19687676f, 0.19752638f, -0.03311408f, 
    -0.01069424f, 0.00007656f, 0.07228474f, 0.00297664f, -0.05605119f, -0.00675965f, -0.07226799f, -0.02933986f, 
    0.13886483f, -0.09928291f, -0.01570529f, -0.06757616f, 0.11955564f, 0.11608966f, -0.09641978f, -0.20022981f, 
    -0.05417541f, -0.10279468f, -0.07359020f, 0.00255507f, 0.02054266f, 0.12450647f, 0.14973545f, -0.09544590f, 
    -0.08207764f, -0.18940401f, -0.03050032f, 0.08941040f, 0.04223756f, -0.04184212f, -0.12590542f, 0.00743139f, 
    0.31850550f, 0.26783726f, -0.04023461f, -0.12840562f, 0.12119278f, 0.08863524f, 0.08883774f, -0.03209264f, 
    -0.04614411f, 0.02203864f, 0.00919716f, -0.17950189f, 0.28566200f, 0.06292325f, -0.08721542f, -0.05036432f, 
    -0.06972409f, 0.08279566f, 0.06080000f, 0.01392506f, 0.04732729f, 0.13672256f, 0.00502358f, 0.11392458f, 
    0.10057789f, 0.13771747f, 0.09523449f, -0.00482631f, 0.06447779f, 0.17878076f, 0.09760337f, -0.12988193f, 
    -0.02501513f, 0.01775232f, -0.00279077f, 0.01252778f, 0.11041415f, -0.06048201f, 0.04035490f, -0.10283143f, 
    -0.02424296f, -0.07119490f, 0.04749312f, -0.01483836f, -0.12505890f, -0.05724003f, 0.05114810f, -0.19191478f, 
    0.04469710f, -0.03141803f, -0.08478117f, -0.07979740f, -0.02445040f, 0.17538217f, -0.21340597f, 0.05749809f, 
    0.02424424f, 0.07609212f, -0.02861980f, 0.00256374f, -0.18659484f, -0.16093773f, 0.20566557f, 0.07426386f, 
    0.00528658f, 0.04607230f, -0.19866732f, -0.05963962f, 0.08033692f, 0.06547591f, 0.01276477f, 0.14327481f, 
    0.30865011f, 0.11427918f, -0.02073202f, -0.12387221f, 0.12634824f, -0.02199238f, 0.14240754f, 0.02789102f, 
    0.04293091f, -0.00975700f, -0.02837982f, 0.06312165f, -0.01347862f, -0.48511282f, -0.83972126f, -0.01368015f, 
    -0.01482238f, -0.01753654f, 0.04666060f, -0.02285171f, -0.04865236f, -0.15498565f, -0.17409395f, -0.09800912f, 
    -0.08726843f, -0.05609451f, 0.02673259f, 0.08895797f, -0.12761107f, 0.00729063f, -0.12059017f, -0.10182253f, 
    0.03114916f, 0.04419329f, -0.07311975f, 0.01078320f, 0.23532765f, 0.11246738f, 0.01918207f, -0.09027653f, 
    0.18486983f, 0.17542371f, 0.00308048f, -0.04586318f, -0.02920743f, 0.05100914f, 0.07457979f, 0.11058936f, 
    0.23135322f, 0.22696009f, 0.17774320f, -0.15407236f, -0.03042206f, 0.18352570f, 0.05289042f, -0.10002996f, 
    0.07833172f, 0.06874918f, 0.03026523f, -0.26564017f, 0.23363844f, -0.10248017f, -0.14331093f, 0.01945322f, 
    0.05441843f, 0.06734902f, -0.05235758f, -0.09218990f, -0.11844213f, -0.06216201f, -0.01312732f, 0.03474717f, 
    0.15369934f, -0.03141234f, -0.07534795f, -0.14271007f, 0.01542167f, -0.23321581f, -0.24407992f, -0.11632770f, 
    -0.02857191f, -0.03031627f, 0.09709164f, -0.04391754f, 0.19840084f, 0.14417276f, -0.22239695f, -0.07858995f, 
    -0.07207920f, 0.07812104f, -0.04417674f, 0.08669183f, -0.00185018f, 0.02557747f, 0.02348274f, -0.01585493f, 
    0.27784982f, 0.24071768f, -0.11423019f, -0.21506299f, 0.08441022f, 0.11533108f, 0.01009735f, -0.09966114f, 
    -0.04330127f, -0.05810090f, -0.04386212f, -0.13380657f, 0.14035113f, -0.17339477f, -0.01720019f, -0.12051308f, 
    -0.00670059f, -0.02738125f, 0.10279973f, 0.00017528f, -0.07294986f, 0.03545732f, -0.00823743f, 0.06325667f, 
    -0.25221169f, 0.26829568f, -0.23664051f, 0.20564784f, -0.11613820f, -0.12150148f, 0.11774583f, 0.04873475f, 
    -0.00827110f, 0.01246383f, 0.04634271f, -0.04498436f, 0.03109565f, -0.03166864f, -0.04844151f, 0.01765949f, 
    -0.07686548f, -0.14955860f, -0.09411135f, -0.07447226f, 0.01689561f, -0.01913295f, 0.00008631f, -0.05029068f, 
    0.25292093f, -0.04937827f, -0.05642166f, -0.12394486f, 0.03968178f, 0.07445859f, -0.18017673f, -0.07787783f, 
    -0.30699944f, 0.01426942f, -0.23817512f, -0.06483034f, -0.09803202f, 0.02694683f, -0.03539767f, 0.05577801f, 
    -0.12277002f, 0.20226151f, -0.07542996f, 0.20060940f, 0.02712109f, 0.06480044f, -0.08042862f, -0.00974272f, 
    0.28328016f, -0.20552592f, 0.02950903f, 0.00802738f, -0.13085699f, -0.02012223f, 0.00034489f, -0.03404903f, 
    0.03352396f, -0.07638831f, -0.00387981f, 0.05483830f, -0.08930513f, 0.00548556f, -0.06378211f, -0.04314799f, 
    0.12429246f, -0.04551243f, -0.03575528f, 0.04498593f, 0.04906458f, -0.15593399f, 0.03743672f, 0.22887987f, 
    -0.41566205f, 0.30924478f, 0.06165586f, -0.21007214f, -0.01815069f, 0.09625868f, 0.04214037f, 0.00634707f, 
    -0.01641632f, 0.05654170f, 0.01509852f, -0.12968376f, -0.03285630f, 0.07837393f, 0.01733275f, -0.01308296f, 
    0.02314178f, -0.08693189f, 0.11929988f, 0.12160875f, -0.05676004f, 0.04338001f, 0.00066714f, 0.01289196f, 
    0.43947440f, 0.40882441f, 0.19628656f, 0.01744651f, -0.09001399f, 0.10542702f, -0.04795214f, 0.02042834f, 
    -0.07261346f, -0.01433768f, -0.02443546f, -0.14069982f, -0.29871708f, -0.04997587f, 0.01413109f, 0.06491164f, 
    0.12230657f, -0.00766558f, 0.37937132f, -0.16815457f, -0.04868191f, 0.03846524f, 0.08054894f, 0.01036486f, 
    -1.05607522f, 0.08117846f, -0.36961132f, -0.15892003f, -0.15765876f, -0.00233408f, 0.13808022f, 0.09102723f, 
    0.02497265f, 0.03440646f, -0.17623244f, 0.03008782f, 0.32274872f, 0.09146895f, -0.09978023f, 0.04247128f, 
    0.16952713f, 0.00679972f, -0.08170708f, -0.08749436f, 0.13910787f, 0.05629072f, 0.13241729f, 0.06172898f, 
    -0.31387272f, -0.12511183f, 0.13866937f, -0.30384064f, 0.02066419f, -0.04801751f, 0.18192387f, -0.08399574f, 
    0.03061556f, -0.00591086f, 0.11766326f, -0.04027770f, 0.25452155f, 0.18821220f, 0.05063298f, 0.31314114f, 
    -0.08803748f, -0.01699759f, 0.00563885f, -0.00168155f, 0.06631563f, 0.05943412f, -0.25883329f, -0.10181914f, 
    0.11553840f, 0.26976463f, -0.04740345f, -0.04652398f, -0.04013689f, -0.10911789f, -0.03734406f, -0.08468045f, 
    0.00444940f, -0.03362988f, 0.02214454f, 0.07402605f, 0.04849928f, -0.15317762f, -0.21837264f, -0.00284333f, 
    0.05158802f, 0.01465133f, 0.12357636f, -0.27562240f, -0.03862749f, 0.06089525f, -0.04812114f, 0.04337009f, 
    0.11209138f, 0.01960109f, 0.04371747f, 0.08971510f, -0.04880880f, 0.03212509f, -0.05378187f, -0.08608455f, 
    0.12780750f, -0.06582760f, 0.03729770f, -0.04092199f, 0.11426404f, 0.04645113f, -0.04700958f, 0.16912304f, 
    0.08332113f, -0.19559401f, -0.22964168f, -0.08724081f, 0.00513653f, -0.02483102f, 0.00471750f, -0.04434519f, 
    0.11712339f, 0.12533820f, 0.31739450f, 0.16695267f, 0.04716027f, -0.11211005f, -0.14877315f, -0.02643578f, 
    -0.02332547f, 0.03437888f, -0.00510500f, -0.05597888f, -0.23337965f, -0.49363273f, -0.05695508f, -0.12435742f, 
    -0.04949024f, 0.05958193f, -0.01744561f, 0.03912688f, -0.06091747f, -0.04964598f, 0.05148752f, -0.08102548f, 
    0.18278326f, 0.22087553f, 0.42507517f, 0.13156863f, 0.05764619f, 0.02340987f, -0.04714584f, -0.00441675f, 
    0.00092432f, 0.02467653f, -0.01945351f, -0.00126055f, 0.42738634f, -0.07841922f, -0.33685574f, 0.09410977f, 
    -0.00610792f, -0.10760736f, 0.07640817f, -0.00758324f, 0.05557351f, -0.03818451f, 0.02991646f, -0.05557627f, 
    -0.07555278f, -0.19081187f, 0.05847815f, -0.08667751f, -0.04614066f, -0.04177975f, 0.00243040f, 0.02926598f, 
    -0.14177833f, -0.20977139f, -0.17331132f, -0.21955900f, -0.11451939f, 0.07729681f, -0.05705690f, -0.04031172f, 
    0.02702143f, 0.14189354f, -0.00666934f, 0.07416247f, 0.24310051f, 0.02869853f, 0.06127448f, 0.03224977f, 
    -0.04486240f, 0.00949118f, -0.02993000f, -0.12948680f, 0.16855587f, 0.06178178f, -0.00758875f, -0.02950877f, 
    -0.12400633f, 0.08220875f, -0.14484707f, 0.08205375f, -0.01488742f, 0.02765906f, -0.10935965f, -0.02171136f, 
    0.06135478f, -0.05461854f, -0.07298193f, 0.14973488f, -0.05007888f, -0.20397164f, 0.01453289f, 0.01631629f, 
    0.28325653f, -0.15147913f, -0.13859068f, -0.01261716f, 0.13594443f, -0.20693833f, 0.17033207f, -0.24264739f, 
    0.02775741f, 0.10024425f, -0.04628811f, 0.07378508f, -0.39355922f, 0.19374950f, -0.01548305f, 0.12670714f, 
    -0.09285776f, -0.11585051f, -0.13230199f, -0.18889652f, -0.07133236f, -0.05776392f, -0.00496853f, -0.06386175f, 
    -0.11733793f, -0.01649075f, -0.04879145f, -0.02218054f, -0.06508615f, -0.00559382f, 0.12300739f, 0.03184793f, 
    -0.19386359f, -0.06488957f, 0.01054943f, -0.00865182f, 0.00810196f, -0.06276121f, -0.09260189f, -0.07654769f, 
    -0.19500314f, -0.05176987f, 0.00121598f, 0.01882029f, 0.12479417f, -0.08046629f, 0.01278058f, 0.06079420f, 
    0.42249927f, 0.23724130f, 0.14088851f, 0.17011455f, 0.02624055f, -0.04798178f, 0.01011406f, 0.06347575f, 
    0.04291962f, 0.06432547f, 0.01086386f, -0.00113545f, -0.00564645f, -0.08493262f, -0.07084763f, 0.10602643f, 
    -0.01011815f, 0.04128433f, 0.02310091f, -0.00413223f, 0.00643233f, 0.03220100f, -0.06518088f, 0.02769959f, 
    0.17533627f, -0.07901055f, 0.13246183f, -0.12905014f, 0.04463968f, -0.02005546f, 0.12995662f, -0.11168496f, 
    0.10130494f, 0.02478019f, -0.07054408f, 0.04394487f, 0.15049525f, -0.01026061f, -0.12278936f, 0.00727094f, 
    -0.09662049f, 0.08369143f, 0.06616598f, 0.08014219f, 0.19518961f, -0.08319260f, 0.10428608f, -0.01217251f, 
    0.13033561f, 0.09141182f, -0.06507888f, -0.10687147f, -0.02175435f, 0.06093707f, 0.08793728f, -0.04103830f, 
    -0.02896150f, -0.02704678f, 0.01153152f, 0.01293235f, 0.05155479f, 0.03732071f, 0.02183148f, 0.08350094f, 
    0.02620182f, -0.01307116f, 0.07181484f, -0.01737942f, 0.11211064f, 0.07034357f, -0.05268964f, -0.06372643f, 
    0.06571269f, -0.16455325f, 0.02544979f, -0.11396749f, 0.00819386f, 0.12127320f, 0.13812241f, -0.05594710f, 
    0.10634702f, 0.12267154f, -0.02149432f, 0.07312341f, -0.09129752f, 0.16232497f, 0.01360565f, 0.00416129f, 
    -0.01162575f, 0.02344694f, -0.00285155f, 0.01500193f, 0.07024647f, 0.01095996f, 0.01771003f, 0.02312787f, 
    -0.42033699f, -0.14497516f, -0.15368986f, -0.36933547f, 0.10059984f, -0.00992330f, -0.05085264f, 0.00061653f, 
    -0.01865193f, 0.04550050f, -0.05492086f, -0.15269232f, -0.00683220f, 0.14966987f, 0.02440299f, 0.14700375f, 
    -0.03856499f, -0.06957074f, 0.00716711f, 0.01546506f, -0.01162836f, -0.03056712f, 0.09380017f, 0.08072945f, 
    0.23949793f, 0.12756760f, 0.22067587f, 0.18514200f, -0.02447313f, -0.02529051f, -0.03303665f, -0.00897092f, 
    -0.00815404f, 0.02843051f, 0.00394097f, 0.13724163f, 0.16247453f, 0.01242857f, 0.06277143f, -0.01112611f, 
    0.02474584f, -0.04312890f, -0.04927849f, -0.00939570f, 0.07353861f, 0.01487330f, -0.06588946f, 0.01561211f, 
    -0.09415448f, 0.13499676f, 0.09720903f, -0.00835576f, -0.03056192f, 0.11918187f, 0.03223753f, -0.09190100f, 
    0.16624929f, -0.03911295f, 0.02083611f, 0.21810053f, -0.09556926f, -0.25008112f, 0.10238545f, 0.05214024f, 
    0.03940364f, 0.10697979f, 0.12311904f, -0.02390535f, 0.08297525f, -0.08883858f, 0.06979350f, 0.02140557f, 
    0.16890952f, 0.01971392f, 0.10990290f, -0.16657500f, 0.01041531f, 0.11429998f, -0.00680572f, -0.01606463f, 
    -0.00603197f, 0.21887019f, 0.03626646f, -0.09227481f, -0.22137253f, 0.07910020f, 0.01621366f, 0.02314759f, 
    0.03061690f, -0.01142660f, -0.06421316f, -0.01281448f, -0.07948008f, -0.01808467f, -0.37906739f, 0.06139014f, 
    -0.18377832f, -0.04707371f, -0.12228894f, -0.39080015f, 0.02415434f, 0.11194868f, 0.08564184f, -0.00457363f, 
    0.01750665f, 0.07253730f, -0.00959509f, -0.12487843f, -0.25976735f, -0.02406466f, 0.00955110f, -0.13184746f, 
    0.12251454f, -0.02990752f, -0.02487428f, 0.06152858f, -0.22726063f, -0.12520616f, 0.08035506f, -0.07488304f, 
    0.21801375f, 0.08211681f, 0.03166657f, 0.01926737f, -0.03114451f, 0.17127988f, -0.26582447f, -0.09110550f, 
    0.02471000f, -0.01713626f, -0.05821332f, -0.01691949f, 0.06763243f, -0.07315491f, -0.14799625f, 0.21433735f, 
    0.02990258f, 0.00148278f, 0.01834417f, -0.00604754f, -0.30457142f, -0.24085528f, -0.35850352f, -0.25670588f, 
    -0.10983301f, 0.01695198f, -0.05985217f, -0.07901621f, -0.07308872f, 0.00265928f, -0.01294970f, -0.31778818f, 
    -0.01500025f, -0.04738472f, -0.01760664f, -0.01036228f, 0.22354294f, 0.03247505f, 0.09917906f, 0.11511991f, 
    -0.07211315f, 0.03144100f, 0.00404774f, 0.04328731f, 0.02450500f, 0.11517853f, 0.02318806f, -0.07905561f, 
    0.27906862f, -0.06019874f, -0.08975583f, -0.23625785f, -0.21594882f, 0.00847335f, 0.13833958f, -0.14280705f, 
    -0.01817279f, -0.03523262f, -0.03887009f, -0.03205439f, 0.07344469f, -0.13088018f, 0.11121415f, -0.04329642f, 
    0.04308114f, -0.01938899f, -0.10757750f, -0.00792370f, -0.21400093f, -0.15798119f, -0.30963075f, -0.06886606f, 
    -0.07177610f, -0.06546434f, -0.22051711f, -0.01294415f, -0.03350458f, 0.08898871f, -0.14564452f, 0.01454053f, 
    -0.00466077f, -0.04904008f, 0.00464209f, -0.03989871f, 0.40348631f, -0.18883130f, -0.07927363f, -0.29871422f, 
    -0.00262815f, 0.02382818f, -0.07321698f, 0.17036197f, -0.16733582f, 0.23298471f, 0.16070434f, 0.08017328f, 
    -0.01529655f, -0.08852372f, 0.23114669f, -0.13955085f, 0.03215223f, -0.07479168f, -0.00561541f, 0.09190373f, 
    -0.09504642f, -0.02986399f, 0.01610966f, 0.02798256f, 0.34480530f, 0.28871357f, 0.25466651f, 0.05563407f, 
    0.03592909f, -0.01685079f, -0.04023754f, -0.36368173f, 0.01767088f, -0.00950849f, -0.00271968f, -0.21419021f, 
    -0.06282753f, 0.19710049f, -0.38516143f, 0.03368732f, -0.06192837f, -0.03024187f, -0.08287048f, 0.04968401f, 
    -0.19342643f, 0.02824092f, -0.21813853f, 0.03085554f, 0.15729359f, -0.20962833f, 0.03480149f, -0.18854947f, 
    -0.02924122f, 0.05390807f, 0.00026620f, 0.01095124f, 0.15661311f, 0.14317147f, 0.04328077f, -0.02416008f, 
    -0.15396106f, 0.13509771f, -0.02094820f, -0.04275825f, 0.11459086f, 0.01647394f, 0.14486323f, 0.04820195f, 
    -0.07389739f, -0.04927626f, 0.13164908f, -0.06820736f, -0.07126392f, -0.16699749f, -0.36259559f, -0.13991542f, 
    -0.08093274f, -0.04316727f, 0.03934251f, 0.33928055f, -0.07537764f, 0.00114448f, -0.07956100f, 0.12028188f, 
    -0.19168529f, 0.05921397f, 0.30087179f, 0.23457779f, -0.09676150f, 0.09909384f, 0.09025124f, 0.03646979f, 
    -0.00348980f, 0.04255581f, 0.02752084f, -0.01846977f, -0.01726019f, -0.00360121f, -0.08249644f, 0.17626877f, 
    -0.09793045f, 0.06722054f, -0.02996295f, -0.16140361f, 0.15355507f, 0.03571687f, 0.00018333f, -0.03667374f, 
    0.10605694f, -0.23017146f, 0.10544912f, 0.04722355f, 0.02958751f, -0.15761954f, 0.11207043f, -0.00950301f, 
    -0.03690246f, 0.02578965f, 0.06352405f, -0.07521934f, 0.03019502f, -0.03939516f, -0.01375015f, 0.03316720f, 
    -0.10256118f, 0.01854562f, -0.00510442f, -0.03120331f, -0.03003261f, -0.08428309f, 0.04890769f, 0.01514332f, 
    -0.10182153f, 0.06676018f, 0.02605044f, -0.00528816f, -0.12765095f, -0.05677696f, 0.01791178f, -0.07061668f, 
    -0.01932102f, 0.09378003f, -0.04426384f, 0.12997423f, 0.02959083f, -0.18395965f, -0.36107934f, -0.24619369f, 
    0.10441906f, 0.10133661f, -0.06532665f, 0.00773754f, -0.03984781f, -0.03849327f, -0.12318695f, 0.05090738f, 
    0.17266250f, -0.28836367f, 0.10284455f, -0.35265085f, 0.02940700f, -0.04525223f, -0.00561452f, 0.07121468f, 
    -0.00142032f, -0.06829885f, 0.04485446f, -0.00371388f, -0.11144074f, -0.03497404f, 0.08798364f, -0.02114250f, 
    0.10300408f, 0.01395904f, -0.16463499f, -0.13739046f, 0.07863601f, -0.01669899f, -0.03562006f, 0.06771859f, 
    -0.12695694f, 0.03151336f, -0.06146329f, 0.19380428f, -0.06546716f, 0.17357071f, 0.03246529f, 0.00182649f, 
    0.01588015f, -0.01881898f, 0.04436091f, -0.13691682f, -0.07777546f, -0.01593833f, -0.03220487f, -0.05775107f, 
    0.03144985f, 0.06008435f, -0.15686245f, 0.01186368f, 0.01066900f, -0.00907773f, -0.07104228f, 0.10666268f, 
    -0.05597797f, 0.49790102f, 0.44788480f, 0.72640622f, -0.06560794f, 0.02141568f, -0.12896927f, 0.03912182f, 
    -0.03105105f, -0.04334358f, -0.07653237f, -0.03656922f, -0.00213585f, 0.00160621f, -0.08769958f, 0.02987242f, 
    -0.06181113f, -0.00415999f, 0.14742197f, -0.11529113f, -0.02198467f, -0.01736928f, 0.01971356f, -0.04983964f, 
    -0.17730060f, 0.20458405f, -0.56314152f, 0.07186068f, -0.04707055f, -0.05419003f, -0.13499573f, 0.02996651f, 
    0.01841151f, -0.04638773f, 0.09091526f, -0.08034804f, -0.18486641f, 0.38163200f, 0.25491431f, 0.04574253f, 
    -0.00128731f, 0.03609791f, 0.00027131f, -0.11353914f, -0.05602365f, -0.02822151f, -0.03518843f, -0.01243490f, 
    -0.23336115f, -0.00128136f, 0.26687205f, -0.20612676f, 0.00537146f, -0.10964036f, -0.10483286f, -0.02602117f, 
    -0.09450001f, 0.03036151f, 0.00509811f, 0.00324875f, -0.18470137f, -0.17610267f, 0.05460741f, -0.09546973f, 
    0.01007972f, 0.01459121f, -0.01170363f, 0.01087747f, 0.06199056f, -0.07332782f, -0.03853202f, -0.05643610f, 
    -0.08183587f, 0.05873731f, -0.13010888f, -0.00351799f, 0.02342173f, -0.17741287f, 0.00773611f, 0.09441731f, 
    0.01947948f, -0.06677582f, -0.01481660f, 0.02661321f, 0.15630563f, -0.32370332f, 0.05073075f, -0.02146674f, 
    0.01842807f, 0.05385463f, 0.05111826f, -0.11182922f, -0.01174919f, 0.00136358f, -0.02177308f, -0.04032862f, 
    -0.03466842f, -0.03276582f, -0.01575680f, 0.00620031f, -0.00081828f, 0.00632678f, -0.03455510f, 0.07156021f, 
    -0.02183411f, -0.05422056f, 0.04847130f, -0.13721751f, -0.66759509f, -0.49538168f, -0.16727445f, -0.24260476f, 
    -0.01106072f, -0.10852943f, -0.07659838f, 0.16087754f, 0.02996095f, -0.02267239f, 0.00701192f, -0.04029361f, 
    -0.94921243f, -0.74986202f, -0.00453288f, -0.33616656f, -0.09163693f, 0.13816106f, 0.09046115f, -0.34732682f, 
    0.03423456f, -0.02345114f, -0.01563651f, -0.03935319f, 0.04225633f, -0.35858402f, 0.04116035f, 0.21414369f, 
    -0.00371613f, -0.00060238f, 0.02167143f, 0.00606450f, -0.00971275f, -0.20874003f, -0.01190034f, -0.01035490f, 
    -0.21674421f, -0.18169747f, 0.45329237f, -0.23025317f, 0.02726525f, 0.03855582f, -0.07553672f, 0.07489336f, 
    0.02987669f, -0.00118972f, -0.02049443f, 0.01165669f, -0.15287277f, 0.23660551f, 0.05613425f, 0.10773579f, 
    -0.04511153f, -0.10236136f, -0.00496008f, -0.01638845f, 0.05512412f, 0.05717016f, 0.13452494f, -0.10878118f, 
    0.00453800f, -0.01310158f, -0.00436645f, 0.04103490f, -0.01799157f, -0.01765037f, 0.05695509f, -0.02116276f, 
    0.12575975f, 0.23907980f, -0.11379062f, 0.27199215f, -0.21164878f, -0.00794409f, -0.13569409f, 0.17326580f, 
    -0.06028279f, 0.02043230f, 0.03359631f, -0.15174842f, -0.05966777f, 0.10811602f, -0.07507115f, 0.07840286f, 
    0.15273991f, 0.13685146f, -0.06896537f, -0.16383228f, 0.09819221f, 0.07239065f, -0.26289949f, 0.11663633f, 
    -0.06500324f, -0.07101836f, 0.02685625f, -0.06896850f, 0.02715567f, -0.02617854f, -0.12592439f, -0.07026463f, 
    -0.02412067f, -0.22445337f, 0.20059335f, -0.22795750f, 0.06443892f, 0.01194311f, -0.01620101f, 0.02475216f, 
    -0.14163403f, -0.10619350f, 0.01975603f, -0.18120976f, -0.01244435f, -0.19984831f, 0.04295689f, -0.15063010f, 
    -0.00432829f, -0.00301237f, -0.01808269f, -0.02414339f, -0.70789385f, -0.01214110f, -0.21010472f, -0.16451867f, 
    0.05591422f, -0.05798920f, -0.05154701f, -0.02475962f, -0.01036080f, -0.00669099f, 0.09412069f, -0.01804124f, 
    -0.11856248f, -0.02620806f, -0.09746406f, -0.01015050f, 0.07523927f, -0.11995710f, -0.03959712f, -0.02478669f, 
    -0.03688101f, -0.31455478f, 0.02858183f, 0.05664214f, -0.06828697f, 0.16094920f, -0.03811156f, 0.02337182f, 
    0.12669301f, -0.03560628f, -0.17429687f, 0.05599856f, 0.01026686f, 0.03057893f, 0.01198786f, -0.08050708f, 
    -0.11348353f, -0.03722184f, 0.20275813f, -0.23175573f, -0.00705510f, 0.01143593f, 0.00920216f, 0.02292624f, 
    0.02985010f, -0.02820409f, -0.02277315f, 0.09822837f, 0.00176227f, -0.11001991f, -0.02496973f, 0.04094137f, 
    -0.16810510f, 0.06240313f, -0.10343041f, 0.04553995f, -0.07104240f, -0.03593801f, 0.04433946f, -0.11447921f, 
    -0.23192748f, 0.28855169f, -0.02982863f, -0.03237692f, 0.00893919f, 0.09991761f, -0.03177722f, -0.01859134f, 
    -0.04867399f, 0.00581486f, 0.04370609f, 0.02692889f, 0.06126518f, 0.08428892f, -0.08727977f, 0.00358149f, 
    0.07873034f, -0.08966747f, 0.00826077f, 0.25649327f, -0.01081073f, 0.09816507f, -0.00831080f, -0.08537289f, 
    -0.03877492f, 0.01819362f, 0.08097357f, -0.12772663f, -0.12849179f, 0.13991840f, 0.02701314f, 0.03167432f, 
    0.00892261f, -0.05245806f, 0.06512817f, -0.06053038f, -0.02360554f, -0.05146585f, -0.01073070f, -0.00688206f, 
    -0.02459542f, 0.04613144f, 0.01566820f, 0.00593477f, -0.03828621f, 0.06216516f, -0.17155634f, -0.09917485f, 
    -0.18244115f, -0.09102031f, 0.09949378f, -0.05532126f, -0.01898705f, 0.02337076f, -0.10400199f, -0.30249429f, 
    0.01986149f, -0.00635407f, -0.06364658f, 0.02776880f, -0.06655728f, 0.14505580f, -0.30778420f, 0.00599280f, 
    -0.01837235f, -0.03286071f, -0.01471688f, 0.07339974f, -0.02778401f, 0.04905875f, -0.02687329f, 0.06144973f, 
    -0.13248916f, -0.09271171f, 0.02136214f, 0.01174505f, 0.15922761f, 0.07304191f, -0.03789255f, 0.03542834f, 
    0.02549913f, -0.02321210f, 0.07510298f, 0.00220886f, 0.07045156f, 0.08331154f, -0.08999136f, 0.11078245f, 
    0.02104008f, -0.02107142f, 0.01525160f, 0.07962334f, -0.04253669f, -0.03194592f, 0.04944911f, -0.09607805f, 
    -0.06395517f, -0.19945011f, -0.24609149f, -0.02865251f, -0.03915842f, -0.03836688f, 0.01950254f, 0.03886171f, 
    0.00842610f, -0.07353130f, 0.06764534f, -0.02751902f, 0.16403475f, -0.03655905f, -0.16667007f, 0.06596228f, 
    -0.04725070f, 0.13535166f, 0.00776873f, -0.00595204f, 0.00805494f, 0.00205448f, -0.01012015f, 0.07287233f, 
    0.03311812f, 0.02849867f, -0.11194093f, -0.02325826f, 0.00175132f, 0.07337619f, -0.03704146f, 0.07204545f, 
    -0.05413376f, 0.01933896f, -0.10372206f, 0.13861747f, -0.02904727f, -0.05167732f, 0.14405990f, 0.08382364f, 
    -0.09545600f, -0.12293513f, 0.05482506f, 0.20944928f, 0.05149129f, -0.03738381f, 0.07678153f, -0.03945925f, 
    -0.28963238f, 0.18941893f, 0.10830197f, 0.00979871f, 0.02156841f, 0.00557112f, -0.17114550f, 0.09369028f, 
    0.04223638f, -0.02937289f, -0.03642877f, 0.14801012f, -0.05258390f, -0.03438672f, -0.03837036f, 0.09022488f, 
    0.07272671f, 0.04717331f, -0.05297319f, 0.08185119f, -0.00567757f, 0.11575942f, -0.17634520f, 0.17997731f, 
    0.25039962f, 0.32646409f, 0.28479946f, 0.32236812f, -0.05005017f, 0.12213811f, 0.06813662f, -0.07301033f, 
    -0.06013579f, 0.06842953f, -0.00062072f, 0.00657491f, 0.15287885f, 0.05616536f, -0.07365940f, 0.09418225f, 
    0.05802447f, -0.04017558f, -0.12567826f, -0.11075068f, 0.00748697f, 0.06688856f, 0.01606121f, -0.01142378f, 
    0.03309659f, -0.31102315f, 0.24811834f, 0.23210937f, -0.04733912f, 0.07868651f, -0.12800382f, 0.10519809f, 
    0.02241976f, 0.01641331f, -0.06899031f, 0.02595929f, 0.05896774f, -0.20724308f, 0.08252782f, 0.15223330f, 
    0.00620954f, -0.02104022f, 0.00983484f, -0.00398549f, 0.01333302f, 0.01900969f, 0.16911367f, 0.11049614f, 
    0.01274633f, 0.25141153f, 0.17389083f, 0.27461693f, -0.04234748f, 0.01515011f, 0.04506006f, 0.09664926f, 
    0.02161940f, 0.13503790f, 0.04337816f, 0.09495045f, -0.06563957f, 0.04338794f, -0.09537527f, 0.07673367f, 
    0.06189962f, -0.07507209f, 0.04650014f, 0.04232566f, -0.06146314f, 0.06519261f, -0.11006840f, 0.01911615f, 
    -0.49439821f, 0.20618702f, -0.02701633f, -0.39526731f, -0.01576423f, -0.07321150f, -0.05311579f, -0.17129578f, 
    0.01181734f, -0.00416539f, 0.02251900f, 0.00368051f, -0.13702458f, 0.02498215f, -0.09619315f, 0.00391737f, 
    0.00123203f, 0.02937237f, -0.01393484f, -0.14532350f, 0.05816234f, -0.00430707f, 0.10744549f, -0.02458402f, 
    -0.08366039f, 0.16858354f, 0.29668850f, 0.27083933f, 0.06456301f, -0.01010100f, 0.08266106f, 0.15063611f, 
    0.03438872f, -0.02691572f, 0.00394558f, -0.07104202f, -0.11887927f, 0.26255959f, 0.08778643f, -0.19333024f, 
    0.11610274f, -0.06170724f, -0.26244020f, 0.25885963f, 0.13442235f, 0.01375902f, 0.02237215f, -0.00092327f, 
    0.11695220f, -0.30010852f, 0.16069099f, -0.15173197f, 0.02626253f, -0.08058577f, -0.04970872f, -0.11116783f, 
    0.01943502f, -0.06792822f, -0.05731772f, 0.02987565f, -0.28013873f, 0.26537612f, 0.67822492f, 0.36323315f, 
    -0.10759304f, 0.05494018f, 0.05698036f, -0.05745159f, 0.02543350f, 0.00065458f, -0.00061391f, -0.04490523f, 
    -0.25518483f, 0.33845171f, -0.07240130f, 0.27781656f, 0.08966985f, -0.05432737f, -0.03524997f, 0.04009814f, 
    0.05628619f, 0.01782615f, -0.15154830f, 0.01239619f, -0.24543282f, 0.31627044f, -0.01842436f, 0.08198280f, 
    -0.03390891f, -0.03909630f, 0.06064624f, -0.31676665f, 0.00270604f, 0.14478706f, -0.00935511f, 0.05950213f, 
    0.18855099f, -0.28972530f, 0.08877058f, 0.14977944f, 0.12402891f, -0.08817140f, -0.13154989f, 0.08800740f, 
    0.07806657f, -0.09580955f, -0.06658059f, 0.09782197f, -0.40882093f, -0.42277905f, 0.00026597f, -0.37951112f, 
    0.08969129f, -0.05591708f, -0.12839414f, -0.10652107f, 0.01997062f, -0.01626158f, -0.00009065f, 0.02734802f, 
    -0.28757381f, -0.64097959f, -0.30209804f, -0.34384981f, 0.08110915f, -0.08703053f, 0.11437345f, -0.06300148f, 
    -0.07457675f, -0.04434722f, -0.04430839f, -0.06573622f, 0.08402681f, 0.05710923f, -0.03487379f, 0.14354745f, 
    -0.01330723f, 0.06596188f, 0.01994400f, 0.05617607f, -0.00238563f, 0.01375474f, 0.01368728f, -0.00072099f, 
    0.18675946f, -0.11910083f, 0.01923823f, -0.19024508f, -0.03410797f, 0.00192558f, 0.00809838f, 0.07281379f, 
    0.00737483f, -0.06312505f, 0.02644036f, 0.01986895f, -0.07214354f, -0.01680985f, 0.02640218f, -0.01401406f, 
    0.03729887f, 0.04560560f, -0.05795770f, 0.00386189f, -0.00516492f, 0.00948774f, 0.06570963f, -0.03769767f, 
    -0.00716578f, -0.00108229f, 0.21533254f, 0.21882528f, -0.06501768f, 0.04105843f, -0.14933203f, 0.06018949f, 
    0.05716165f, 0.03285631f, 0.00128280f, 0.09053011f, 0.13306157f, -0.03453808f, -0.02812827f, 0.07996152f, 
    0.02271572f, 0.09047382f, -0.05057162f, -0.11585838f, -0.06151614f, -0.00868756f, -0.03741486f, -0.09225800f, 
    -0.02225463f, 0.13321707f, 0.12833793f, 0.01525369f, -0.21128352f, 0.16234575f, -0.36029270f, -0.10104218f, 
    -0.10928635f, -0.16994055f, 0.12664777f, 0.00597974f, -0.16906133f, 0.02424853f, 0.15606363f, 0.19765928f, 
    0.01146172f, -0.00843355f, 0.10352118f, -0.10357714f, 0.00244226f, 0.08517411f, -0.09697605f, 0.21290755f, 
    0.00477455f, -0.04722518f, -0.00862410f, -0.28208300f, -0.12215994f, -0.06953462f, -0.06566262f, -0.14611486f, 
    -0.06064370f, -0.02209247f, -0.02814544f, -0.00841936f, 0.03937009f, -0.23866141f, 0.27177939f, 0.08141003f, 
    -0.10051199f, -0.00945469f, 0.02719994f, 0.14423302f, 0.14398909f, 0.08558360f, -0.05065459f, 0.06832428f, 
    0.31588128f, -0.07753535f, 0.06227902f, 0.23969971f, 0.08992280f, -0.03665657f, 0.01437580f, 0.03809351f, 
    -0.03286155f, 0.03432754f, -0.00188424f, 0.14673378f, 0.09662239f, 0.00579057f, -0.20517510f, 0.11331972f, 
    -0.08476268f, 0.07860702f, 0.04500454f, -0.13929999f, 0.12375908f, -0.16279311f, 0.09267498f, -0.05231506f, 
    -0.00398912f, 0.04646437f, -0.12167186f, -0.15490609f, -0.20512845f, -0.04025689f, -0.12209073f, 0.28771341f, 
    -0.11577623f, -0.02533540f, -0.01465645f, 0.11110714f, -0.38586023f, 0.05376638f, -0.07282855f, 0.19763370f, 
    -0.04258776f, -0.07235511f, -0.05140806f, -0.03716970f, 0.00413351f, 0.14354213f, 0.07034479f, -0.02661718f, 
    -0.12235911f, -0.06486886f, 0.01088405f, 0.27613616f, 0.06368026f, 0.05324388f, 0.03917750f, 0.12366287f, 
    -0.09512252f, -0.04196949f, -0.05190865f, -0.00856040f, 0.35190737f, 0.42934054f, 0.04286986f, 0.00795316f, 
    0.32513809f, 0.05126355f, 0.20684664f, 0.05805798f, -0.10679901f, -0.01402205f, -0.03067496f, 0.04356751f, 
    -0.14199433f, 0.54406679f, -0.03209268f, 0.44615519f, 0.05068173f, -0.14105548f, 0.19600756f, -0.12760966f, 
    0.01257659f, -0.01312542f, -0.02801665f, 0.07313934f, 0.21622550f, -0.10862320f, -0.01955596f, 0.00805284f, 
    -0.12407757f, -0.04356249f, -0.09981705f, -0.03514791f, -0.03098779f, 0.13558479f, 0.01136480f, -0.14691681f, 
    -0.04644266f, 0.04276080f, -0.12213883f, 0.07115551f, 0.25835195f, -0.19393097f, 0.30107144f, 0.02147175f, 
    -0.15413654f, -0.12353010f, -0.06370078f, -0.29856700f, -0.06600526f, -0.05685680f, -0.06106522f, 0.10453129f, 
    -0.00134302f, 0.05028558f, 0.03702080f, -0.05107948f, -0.00796389f, 0.16249341f, -0.01536376f, 0.02955015f, 
    -0.08655865f, -0.28653833f, -0.06736130f, 0.27752876f, -0.04654078f, 0.02358509f, 0.04609333f, 0.00599300f, 
    0.03494358f, -0.02801501f, -0.09126750f, -0.09642383f, 0.08290941f, -0.12232384f, -0.04480381f, 0.15482166f, 
    0.06743500f, -0.04015666f, 0.05241505f, 0.00113070f, 0.05480787f, -0.05717277f, -0.06022067f, -0.01996007f, 
    0.00854817f, 0.09208924f, 0.02296677f, -0.30408528f, -0.23776698f, -0.04665233f, -0.18375356f, -0.01989609f, 
    -0.02928124f, -0.05005850f, -0.22537774f, 0.03977044f, -0.09553967f, 0.13482644f, -0.09231158f, -0.09294825f, 
    0.13021837f, -0.02586043f, -0.08649032f, -0.08609413f, -0.03417920f, -0.09853251f, -0.00479398f, 0.04492540f, 
    0.09095497f, 0.03975943f, -0.07257607f, 0.03616545f, 0.00239106f, 0.00591260f, 0.00240366f, -0.03143702f, 
    -0.05845682f, 0.18154344f, -0.00091857f, 0.10427921f, -0.09564260f, -0.04790818f, -0.17301680f, 0.08001165f, 
    0.08788889f, 0.07306264f, 0.07989247f, 0.05893601f, -0.11762936f, 0.07254022f, 0.13511996f, 0.05533193f, 
    0.39367250f, -0.03111368f, 0.01917678f, 0.24227992f, 0.00228813f, -0.01470228f, -0.19798441f, -0.10188846f, 
    -0.09485757f, 0.13631052f, -0.03301933f, -0.00174114f, 0.24514256f, 0.25425223f, 0.17892824f, 0.31091821f, 
    -0.07514411f, 0.14798185f, -0.09383827f, -0.12883754f, -0.01380039f, -0.05445885f, 0.00041032f, 0.02257258f, 
    -0.11796028f, -0.21695040f, 0.30810744f, 0.31605583f, -0.08524439f, -0.11124752f, 0.04343683f, -0.03814106f, 
    0.03341498f, 0.04868722f, -0.01393472f, -0.09694090f, 0.15280633f, -0.23476392f, -0.00115201f, 0.06734541f, 
    0.03353562f, -0.03323575f, -0.10579105f, 0.04663723f, 0.10275216f, 0.03138591f, 0.11079466f, 0.05064811f, 
    0.10667258f, -0.14769414f, 0.08565921f, -0.13540339f, 0.11698256f, -0.06678445f, -0.18696493f, -0.04981000f, 
    0.02462915f, 0.17266442f, 0.06186309f, -0.15358832f, -0.53093070f, 0.53763711f, 0.01157094f, -0.38256994f, 
    0.22449462f, 0.09801908f, 0.03035754f, 0.02626421f, -0.22756617f, 0.05329141f, 0.06441068f, -0.03764587f, 
    -0.25470448f, -0.03258131f, 0.18579723f, -0.23188111f, -0.09770937f, -0.02994780f, -0.10988360f, -0.03002606f, 
    0.12025956f, -0.00951337f, -0.00530767f, -0.03819657f, 0.04659275f, 0.26223513f, -0.36610389f, 0.21993661f, 
    0.08543104f, -0.03286467f, 0.14543287f, -0.03534312f, -0.00377646f, 0.15991199f, -0.03696413f, -0.11461729f, 
    -0.21639608f, -0.15017658f, 0.01227579f, 0.14291209f, -0.15954112f, -0.11232379f, -0.07649083f, 0.02142660f, 
    0.02796883f, 0.04170914f, -0.00136442f, -0.17366366f, -0.34109849f, 0.34622332f, -0.09066207f, -0.17663084f, 
    0.03206216f, 0.13407865f, -0.00609501f, -0.21709590f, -0.18367662f, -0.14336014f, 0.04596270f, -0.04624074f, 
    0.12268826f, 0.18680510f, 0.03286961f, 0.18692985f, -0.13604000f, -0.13303447f, -0.00862800f, -0.02359760f, 
    -0.08437202f, -0.04604527f, -0.05763702f, 0.01063529f, -0.04616703f, 0.22918418f, 0.08660633f, -0.02029996f, 
    0.15566109f, -0.09987620f, 0.00712436f, 0.02132091f, -0.22426189f, 0.05604307f, -0.12112875f, 0.05436337f, 
    -0.22202237f, -0.09801742f, 0.01223917f, 0.14044112f, 0.00404870f, -0.07274933f, 0.19116797f, 0.09228531f, 
    -0.03907964f, 0.00780765f, 0.07725962f, -0.04127572f, 0.19687618f, 0.50226402f, -0.05868217f, -0.20916052f, 
    -0.12481505f, -0.03292992f, -0.08434862f, -0.11338416f, 0.05240773f, 0.04712749f, 0.01933128f, 0.06512292f, 
    0.14849938f, 0.01794417f, -0.08749921f, 0.10847776f, -0.05119852f, -0.08971025f, 0.00464503f, -0.07540371f, 
    -0.03572267f, 0.04227332f, 0.18382581f, 0.04234186f, -0.19354944f, 0.03099614f, -0.28275281f, -0.54636705f, 
    0.09379997f, -0.05639430f, -0.19462897f, -0.16503908f, -0.16159278f, -0.05094957f, -0.21877714f, 0.11460944f, 
    -0.33079764f, -0.41009945f, -0.28790721f, -0.12769689f, 0.13175176f, 0.00515724f, -0.11386810f, -0.12675987f, 
    -0.04037893f, 0.07022934f, 0.01683651f, -0.02367008f, 0.16677898f, -0.00482173f, 0.01468984f, -0.40228263f, 
    -0.15089096f, -0.11431787f, -0.27690256f, -0.01759941f, -0.06646810f, -0.15740412f, 0.01617085f, -0.14260545f, 
    0.18031730f, -0.21284445f, -0.05790119f, -0.34854347f, -0.03434290f, -0.08255386f, -0.12807010f, -0.08705971f, 
    0.04853369f, 0.07271273f, -0.15171224f, -0.23805617f, -0.36412650f, 0.66508919f, -0.30984119f, -0.27612245f, 
    0.20626567f, 0.12146730f, -0.07413376f, -0.06541115f, -0.14551033f, -0.05338008f, 0.17616493f, 0.07667912f, 
    -0.48430982f, -0.09156502f, -0.00520502f, 0.00414931f, -0.07052343f, -0.00305293f, -0.19735403f, -0.09960870f, 
    0.00844587f, -0.06296857f, 0.01774854f, -0.03507837f, -0.12188871f, 0.01301910f, -0.09935180f, 0.00192507f, 
    -0.13034305f, -0.11408992f, -0.18581572f, -0.00153166f, -0.06767965f, 0.12863344f, 0.12837872f, 0.05986572f, 
    0.17423680f, -0.12392557f, 0.04683413f, 0.20933582f, 0.15612322f, -0.10640153f, -0.08724537f, -0.04968430f, 
    0.07842048f, 0.02782970f, -0.01313275f, 0.01827310f, 0.17187929f, 0.18654276f, -0.02182688f, -0.08344031f, 
    0.00524688f, 0.09633669f, 0.08016175f, -0.13621700f, -0.05607146f, 0.06082702f, -0.02601993f, 0.01327217f, 
    -0.11386029f, -0.21099058f, -0.18225566f, 0.09805269f, 0.05769938f, -0.05382746f, 0.00035450f, 0.00282149f, 
    0.00019057f, 0.00353921f, -0.07656799f, 0.11227182f, 0.16031341f, 0.15964352f, -0.33548051f, -0.12804936f, 
    0.10080435f, 0.09365157f, -0.05092748f, -0.04487513f, -0.24316265f, -0.13105008f, 0.06427885f, -0.05572262f, 
    0.47663933f, -0.20983309f, -0.24357834f, 0.03372129f, 0.18518291f, 0.00106199f, 0.06573889f, -0.14047550f, 
    -0.05239194f, -0.09570038f, -0.05971795f, 0.00937432f, -0.55963784f, 0.48931283f, -0.21969122f, -0.66550589f, 
    0.19196013f, 0.24627103f, -0.04539498f, 0.05534812f, -0.17766209f, 0.08937440f, -0.11176173f, -0.01764981f, 
    -0.13308291f, -0.16297518f, 0.18113624f, 0.15077336f, -0.08330106f, 0.06940751f, -0.00739431f, 0.06207706f, 
    0.08518068f, 0.03611757f, -0.04976561f, -0.01775382f, 0.06574000f, -0.03813337f, 0.14977783f, -0.02898740f, 
    -0.06431189f, -0.04070843f, 0.07836646f, 0.14183795f, -0.01345930f, 0.12776624f, 0.16272756f, -0.01293208f, 
    0.01319655f, -0.00671953f, -0.06055520f, 0.05547132f, 0.05086898f, -0.03961835f, -0.08691605f, -0.01757919f, 
    0.04604299f, -0.08713134f, 0.09300601f, -0.06131120f, -0.42617366f, 0.08466260f, 0.08186069f, 0.45723191f, 
    -0.08301645f, 0.04980489f, -0.06541052f, -0.09155916f, -0.03638397f, -0.08111692f, 0.05211745f, -0.01988480f, 
    0.14864817f, 0.00275230f, 0.16623929f, -0.09464432f, -0.14423233f, -0.04788685f, 0.03146552f, 0.03373424f, 
    -0.01808215f, -0.03593484f, 0.11296690f, 0.04381409f, -0.15588464f, -0.15721308f, 0.02825380f, 0.14828014f, 
    0.02510709f, 0.00348692f, -0.00784619f, -0.06868112f, -0.03589579f, 0.06315490f, -0.07131898f, 0.14421141f, 
    0.26522553f, -0.22811238f, -0.06474927f, -0.18578216f, 0.22921279f, 0.09292023f, 0.07350414f, 0.14243448f, 
    -0.04540582f, -0.00092717f, -0.08631484f, 0.03786856f, -0.56373292f, -0.01858545f, 0.05276271f, 0.34691590f, 
    -0.09155881f, 0.04030057f, -0.02561566f, 0.01841797f, -0.07544787f, 0.06181986f, 0.11956327f, -0.02026775f, 
    0.14617863f, 0.07404943f, 0.05656141f, 0.07233574f, -0.00289867f, 0.03845442f, 0.00213377f, -0.15552968f, 
    -0.10022663f, 0.06519628f, -0.09353989f, 0.14943147f, 0.04513057f, -0.05524420f, 0.17352985f, 0.09343413f, 
    0.08485226f, 0.08675366f, 0.01488215f, 0.11705334f, -0.00399922f, -0.03479875f, -0.03178445f, 0.04082367f, 
    0.08139325f, -0.03667004f, -0.07154934f, 0.15726085f, -0.01306144f, -0.00960618f, 0.11686968f, 0.09770969f, 
    -0.03388725f, 0.00294932f, -0.06344910f, -0.09751403f, 0.01372048f, 0.54537886f, -0.46376520f, 0.28075016f, 
    0.09074286f, -0.13852827f, -0.00221760f, 0.00161873f, 0.07228227f, -0.06220522f, -0.00027518f, 0.03702529f, 
    0.28142503f, -0.23408756f, 0.20401885f, -0.14293127f, 0.00382376f, 0.01195995f, -0.23717314f, -0.01622162f, 
    -0.06437401f, -0.05526425f, -0.05532843f, 0.14346884f, 0.19885789f, -0.23601159f, 0.24185957f, 0.12912883f, 
    0.05398675f, 0.03628880f, -0.12832391f, -0.13562751f, 0.19744307f, 0.01058690f, 0.00983480f, -0.09486917f, 
    -0.14967249f, 0.05291685f, -0.11862259f, -0.06159442f, 0.08057816f, -0.05873960f, 0.10979313f, -0.17620881f, 
    0.11107543f, -0.14341742f, 0.09379241f, 0.23363687f, 0.08957738f, 0.05686229f, 0.11202557f, 0.14339994f, 
    0.02145769f, -0.13531077f, 0.10036715f, -0.06790936f, 0.00251210f, -0.05098128f, 0.13603300f, -0.02436589f, 
    0.18907140f, -0.00976380f, -0.23728350f, 0.16381156f, 0.14922969f, -0.11426859f, 0.15414876f, 0.03200576f, 
    0.01960928f, -0.00815481f, -0.14106727f, -0.08935102f, -0.01578389f, 0.00495322f, 0.01571919f, 0.12584600f, 
    0.11019194f, -0.08840158f, -0.10731591f, 0.04569447f, 0.09902856f, 0.12320335f, -0.01220862f, -0.13443899f, 
    -0.25291517f, -0.16770235f, -0.14675125f, 0.01509008f, -0.07150798f, 0.00020801f, 0.00811728f, -0.02987719f, 
    -0.24958372f, 0.04187161f, -0.04272099f, -0.00016298f, 0.24422228f, 0.06579061f, 0.10642095f, 0.27008200f, 
    -0.15700451f, -0.03990404f, 0.04442932f, -0.05004480f, 0.13155599f, -0.03165079f, 0.10723990f, 0.04380162f, 
    -0.10156180f, 0.08673479f, 0.01323016f, 0.13226859f, -0.05173406f, -0.11526149f, -0.03461954f, -0.12774646f, 
    0.03984248f, -0.07315674f, 0.04676512f, 0.03190317f, 0.07593033f, -0.09422442f, 0.12915446f, -0.02702390f, 
    -0.12005812f, -0.11968739f, -0.32769409f, 0.05277085f, 0.00583265f, 0.00772267f, -0.05548586f, -0.03807096f, 
    -0.07161293f, -0.43210939f, 0.23129152f, 0.07480172f, -0.12645784f, -0.02551465f, -0.14417693f, -0.30572692f, 
    -0.06772020f, -0.14416774f, 0.09772263f, 0.00657248f, 0.05697463f, -0.11366330f, -0.05417845f, -0.10508966f, 
    -0.03952589f, 0.04306971f, -0.04561260f, -0.03605528f, -0.05796531f, -0.06965619f, -0.07366984f, 0.11952846f, 
    0.19013236f, 0.20933905f, 0.12626536f, 0.01484031f, -0.02360252f, -0.16936554f, -0.09592889f, 0.04009727f, 
    0.10326087f, -0.01366925f, -0.09762727f, -0.03126926f, -0.06522931f, -0.02379043f, 0.01341907f, -0.17184147f, 
    0.09945659f, 0.11812362f, -0.01159832f, 0.06545066f, -0.04124290f, -0.07832990f, -0.20030719f, -0.29885659f, 
    0.00393877f, -0.39904156f, 0.08663888f, -0.15719707f, 0.06383375f, 0.02910542f, -0.10641015f, 0.04507364f, 
    -0.02531656f, 0.00557229f, -0.01621243f, -0.03758134f, 0.00919430f, 0.13672185f, 0.22670206f, -0.03680256f, 
    -0.15573226f, 0.00425836f, -0.12230873f, 0.12904692f, 0.04959870f, -0.11834875f, -0.07256702f, -0.09881943f, 
    0.06718643f, 0.02735471f, 0.06420269f, 0.04118715f, 0.09655974f, 0.09198625f, 0.02903292f, 0.04242584f, 
    -0.04067472f, -0.04739512f, -0.00817234f, 0.04169455f, -0.01080357f, 0.02055475f, 0.19663513f, 0.11110236f, 
    0.02969596f, -0.07064384f, -0.05796300f, -0.03128428f, 0.02688767f, -0.02416974f, -0.01409661f, 0.04696795f, 
    0.13655829f, 0.26741841f, 0.17676049f, 0.12902293f, -0.09450749f, -0.09284405f, -0.00148926f, 0.26846889f, 
    0.04617670f, -0.00785358f, 0.05437189f, 0.03315039f, 0.22491771f, 0.30207005f, 0.05971043f, 0.11384408f, 
    0.00664670f, 0.03643137f, 0.02123050f, 0.08291558f, 0.18882453f, -0.28486741f, 0.07906263f, 0.01664270f, 
    0.33601600f, -0.52943647f, -0.48734009f, 0.01643172f, 0.04334575f, 0.00914689f, 0.04071743f, 0.05530255f, 
    0.12554695f, 0.00493493f, 0.05172669f, -0.05162429f, -0.03506396f, -0.24149927f, 0.24635381f, -0.00302446f, 
    -0.26790568f, 0.09940492f, -0.16022137f, 0.00970625f, -0.09330115f, -0.09499833f, -0.15537405f, -0.06566355f, 
    0.05054089f, 0.14810905f, -0.01620558f, 0.00207992f, -0.01580218f, -0.01116930f, -0.00386659f, -0.02861240f, 
    0.18381073f, -0.03359117f, 0.11375035f, 0.20164412f, 0.08485054f, 0.05877023f, 0.24889828f, 0.15068357f, 
    -0.09918615f, 0.08137251f, 0.02347361f, -0.01516259f, 0.22220100f, 0.04908834f, 0.11386224f, 0.04744229f, 
    0.06963570f, 0.04457273f, -0.10576101f, -0.09341783f, 0.04517856f, -0.10514964f, -0.05393250f, -0.07580841f, 
    0.04039715f, -0.13156959f, 0.05084902f, -0.20511103f, -0.03151681f, 0.09479949f, 0.04497219f, 0.13111067f, 
    0.00595024f, -0.10777237f, 0.00506270f, -0.10178512f, 0.05948145f, 0.02703079f, -0.04396281f, -0.10979947f, 
    -0.00431984f, 0.43139127f, -0.06743316f, 0.09221927f, 0.04733212f, 0.25263223f, -0.08154660f, 0.02923256f, 
    -0.02929226f, 0.01955373f, -0.01574628f, 0.00068880f, -0.08290935f, 0.04265479f, 0.11119273f, -0.00141672f, 
    -0.16374400f, 0.05931919f, -0.12259262f, 0.00190816f, 0.03552212f, -0.00341898f, 0.01534564f, 0.08174711f, 
    0.24917324f, 0.04697681f, -0.08446398f, 0.05209586f, -0.00366125f, 0.12133706f, 0.11435919f, -0.12435255f, 
    0.14406553f, -0.04746972f, -0.10236885f, -0.02798519f, 0.16321748f, -0.49912772f, 0.01095155f, 0.09582379f, 
    0.01523618f, 0.04836389f, 0.02618042f, -0.01396009f, -0.05870819f, -0.02650343f, 0.01211543f, -0.07897177f, 
    0.30815098f, -0.34791163f, -0.43826330f, 0.12089388f, 0.01684472f, 0.01069220f, 0.07850972f, -0.10144200f, 
    0.01746080f, 0.01343082f, 0.06567664f, 0.06462152f, 0.04620619f, 0.11479453f, 0.01574483f, -0.11454315f, 
    0.12747115f, -0.03834331f, -0.01424513f, -0.00658549f, -0.12404171f, 0.01939594f, -0.11712456f, 0.02000686f, 
    -0.27627832f, -0.05600055f, -0.04419237f, -0.00109579f, -0.00803598f, -0.06650560f, -0.20710835f, 0.12311880f, 
    -0.12357791f, 0.09306025f, -0.03904747f, -0.02104523f, 0.03198146f, -0.35074615f, 0.01619722f, 0.22863017f, 
    -0.04266651f, -0.09618595f, -0.06708146f, -0.09530716f, -0.31367958f, -0.07819664f, -0.16809160f, 0.07852887f, 
    -0.09440125f, -0.11317942f, 0.03413443f, -0.06568086f, 0.02459810f, 0.01219299f, -0.04769561f, 0.01522462f, 
    0.03788808f, -0.01968939f, -0.02361748f, -0.11095957f, 0.21473397f, -0.01299786f, -0.01796331f, 0.05330383f, 
    0.02298748f, -0.01226494f, 0.00466103f, 0.04214809f, -0.01126730f, -0.23984095f, -0.06525960f, -0.13111947f, 
    0.05217225f, 0.19916809f, 0.02449239f, 0.07994782f, 0.04662976f, 0.03899083f, -0.12967518f, -0.07944521f, 
    -0.07814948f, 0.00553690f, 0.07434895f, 0.03939985f, -0.01884671f, -0.28081560f, 0.00051276f, 0.11196888f, 
    0.02529969f, 0.01619003f, -0.00464365f, 0.02916461f, 0.03922020f, -0.01314421f, -0.00582929f, 0.03330683f, 
    -0.03158232f, 0.02116862f, 0.14568171f, 0.20091125f, -0.05585188f, -0.09942877f, -0.08187325f, -0.02478545f, 
    -0.04021185f, -0.05716707f, -0.08812508f, -0.01034119f, -0.08354819f, -0.09802647f, -0.14153577f, 0.04292827f, 
    0.02182000f, -0.05574932f, 0.01234263f, 0.00261680f, -0.15782142f, -0.09543309f, -0.22099812f, -0.04081130f, 
    -0.04030196f, -0.04114863f, -0.05347971f, -0.00424100f, 0.09638348f, 0.02898035f, 0.08030938f, 0.06162849f, 
    0.08788998f, 0.04601702f, 0.00485616f, 0.04026623f, -0.08456635f, -0.06578714f, -0.11876834f, -0.13118736f, 
    0.12290988f, -0.03508110f, 0.10036109f, -0.10052365f, -0.00421872f, -0.04039476f, -0.08825076f, -0.08851529f, 
    -0.03541814f, 0.02916015f, -0.01914991f, -0.05168368f, -0.08581515f, -0.00621389f, -0.00741711f, 0.04785243f, 
    -0.11868226f, -0.05364173f, -0.03697642f, -0.14927524f, 0.24635324f, -0.38856539f, -0.01372451f, 0.04423922f, 
    -0.07084733f, -0.14316846f, -0.09432732f, 0.01258092f, 0.00427778f, 0.13225767f, -0.10610563f, 0.03100661f, 
    -0.02610761f, -0.03638607f, -0.03186912f, -0.07925142f, -0.01583998f, -0.01076822f, 0.00817338f, -0.05197179f, 
    -0.07323531f, 0.02327470f, -0.07434992f, -0.04730911f, 0.15342921f, -0.01233551f, -0.12676919f, -0.14811929f, 
    -0.10085465f, 0.07934400f, 0.02630151f, -0.07825942f, 0.00746958f, -0.08055244f, -0.15350288f, 0.10716024f, 
    0.10471589f, 0.19896749f, 0.06325272f, 0.10839695f, -0.14244735f, -0.15927055f, -0.07414277f, 0.03070410f, 
    -0.10371331f, -0.11884075f, 0.01265194f, 0.05373644f, 0.03583278f, -0.06323814f, -0.08295529f, 0.15702130f, 
    -0.07127220f, 0.07180062f, -0.09429885f, -0.20870896f, 0.11173185f, 0.16001405f, 0.12827423f, 0.21530822f, 
    -0.04247453f, 0.00164386f, 0.02493409f, 0.05572487f, -0.11021265f, -0.06203597f, -0.09940237f, -0.11819878f, 
    -0.04438489f, -0.03060150f, -0.00404781f, 0.04293428f, -0.05379519f, -0.16666432f, 0.12353192f, 0.03798370f, 
    -0.03040326f, -0.09333324f, -0.01646273f, -0.05456730f, 0.18106639f, 0.26005965f, 0.11761852f, 0.28041434f, 
    -0.20944309f, 0.10454861f, 0.06717559f, 0.12645999f, -0.15917847f, 0.00184860f, -0.04238028f, 0.13719288f, 
    -0.01607427f, 0.07162822f, -0.02095926f, -0.03630840f, 0.15256312f, -0.43777153f, -0.08800412f, -0.05341576f, 
    0.03067434f, 0.06116599f, 0.02862078f, -0.02947698f, -0.11511172f, -0.11207304f, -0.26094720f, 0.01556008f, 
    -0.01751403f, 0.16667520f, -0.02914509f, 0.18881665f, 0.12079450f, -0.13763848f, -0.10338938f, 0.06227965f, 
    -0.04329228f, -0.08002277f, 0.05713665f, -0.05644298f, -0.01891690f, 0.19514826f, -0.09034329f, -0.06943929f, 
    0.00165839f, 0.01846805f, -0.08949209f, -0.02986718f, 0.08231921f, 0.09113575f, -0.12505843f, 0.32269138f, 
    -0.10084786f, 0.03409992f, 0.08874980f, 0.07400627f, -0.15175600f, -0.05690671f, -0.16123369f, -0.16772062f, 
    0.01899227f, 0.01594400f, -0.16381526f, 0.02392076f, -0.00713017f, 0.01336143f, -0.06681160f, -0.04579385f, 
    0.14922073f, -0.01322101f, -0.21247064f, -0.20481023f, -0.01951263f, -0.09368295f, -0.11456954f, -0.04760170f, 
    0.16377552f, 0.03385875f, -0.12081284f, 0.05004334f, 0.05144244f, -0.04835228f, -0.06194179f, -0.24488097f, 
    0.09922991f, -0.06043302f, -0.00701786f, -0.09934656f, -0.09692200f, -0.01526326f, 0.07291947f, 0.07339367f, 
    -0.07324282f, -0.11596450f, 0.08738725f, -0.02088655f, 0.02455634f, -0.03831059f, -0.00665649f, 0.10809100f, 
    0.02058072f, 0.05491123f, -0.07212163f, 0.05304058f, -0.10544115f, 0.01143711f, 0.03471982f, -0.07917935f, 
    0.10441273f, 0.02196088f, -0.03603586f, -0.08063072f, 0.03419398f, 0.00562424f, 0.16178805f, 0.08053467f, 
    -0.03205393f, 0.00956768f, 0.05823312f, -0.08436575f, -0.01419641f, -0.11993091f, -0.08363197f, -0.01033077f, 
    0.07314644f, 0.12047598f, -0.32680035f, 0.06668404f, -0.19667873f, -0.02689422f, 0.02426025f, -0.08820509f, 
    0.03845883f, 0.03841735f, -0.02532120f, -0.15086962f, 0.07490546f, 0.21675625f, 0.09618817f, 0.21625370f, 
    0.08501595f, -0.05135730f, 0.01264766f, -0.03646091f, -0.00611174f, -0.01893162f, 0.11543174f, -0.01227463f, 
    -0.04191710f, 0.04376109f, 0.15438500f, 0.11789310f, -0.02206232f, 0.05142142f, -0.09999208f, 0.04704051f, 
    -0.02838779f, -0.05391473f, 0.03363524f, 0.08587521f, -0.07090996f, -0.24315216f, 0.32857066f, -0.11960405f, 
    -0.01944687f, 0.08170793f, -0.07821895f, 0.09075443f, -0.13967972f, 0.02331224f, -0.06534045f, -0.02647293f, 
    0.20244761f, -0.09056247f, -0.30592859f, 0.46865612f, 0.08911838f, -0.02889596f, 0.03377519f, -0.04393274f, 
    0.01183712f, 0.05335169f, -0.00469326f, -0.03155603f, 0.02493644f, 0.02972243f, 0.06646550f, 0.03217515f, 
    -0.15110168f, -0.06769211f, 0.07277965f, 0.13526322f, 0.01489124f, -0.00175022f, -0.08284750f, -0.08116627f, 
    -0.00219435f, 0.02880828f, -0.30136102f, -0.01645917f, -0.00049001f, 0.01043425f, 0.02066659f, 0.13514039f, 
    0.02426841f, -0.24213231f, 0.12883519f, -0.51726145f, -0.04934383f, 0.16220246f, 0.18231091f, 0.00586323f, 
    0.18961512f, 0.01729501f, 0.07774004f, 0.00430982f, 0.13203092f, -0.07514919f, 0.07828815f, 0.12846863f, 
    -0.37951690f, 0.28099021f, -0.30554283f, 0.03043873f, 0.17555448f, -0.10149264f, 0.10340767f, 0.05239052f, 
    0.08877032f, 0.07154586f, -0.01598985f, 0.03390003f, 0.13536596f, -0.04340323f, 0.00053553f, -0.09272794f, 
    -0.15554318f, 0.01855500f, 0.03734817f, -0.04172808f, -0.08901263f, -0.07797682f, -0.00784515f, -0.33078015f, 
    0.20422153f, -0.32033521f, 0.14607628f, 0.18135440f, 0.08201107f, -0.10032669f, -0.05945561f, 0.06125188f, 
    0.11211389f, -0.03790517f, -0.02519228f, 0.11602736f, -0.10150775f, -0.12741578f, 0.02841500f, 0.07884900f, 
    0.11909331f, -0.07535661f, -0.13702706f, -0.00379790f, 0.07075368f, -0.07598968f, 0.02067810f, -0.08471192f, 
    -0.40632871f, -0.19889213f, -0.18226627f, -0.33023942f, 0.07318445f, -0.08983287f, 0.03768236f, -0.04992267f, 
    0.05619156f, -0.01226657f, -0.06962962f, -0.01923203f, 0.18954821f, 0.06784480f, -0.02990620f, -0.04509626f, 
    -0.05073012f, 0.23961833f, -0.03230010f, 0.17718156f, 0.01396380f, -0.01866077f, -0.05642951f, 0.05741057f, 
    0.69373637f, -0.19851407f, 0.18350056f, 0.18469736f, 0.15498571f, -0.01612255f, 0.10371209f, -0.12750401f, 
    0.16096063f, 0.11390865f, -0.03934494f, -0.06318028f, 0.12140779f, 0.06566692f, 0.18289141f, -0.06628714f, 
    -0.09510409f, 0.05337314f, -0.04987457f, 0.17254286f, 0.00241578f, -0.15531294f, -0.23187904f, -0.21864264f, 
    0.25660121f, 0.19307695f, -0.02920147f, 0.02666089f, 0.09583414f, 0.17907026f, -0.10511137f, -0.11531349f, 
    0.06433064f, 0.02778561f, -0.06074015f, -0.01673837f, -0.30719048f, -0.33527389f, -0.02186329f, -0.24722043f, 
    -0.05515246f, 0.01388766f, -0.00930591f, -0.11212143f, 0.01367933f, -0.01422563f, 0.31121919f, 0.22982794f, 
    0.12743330f, -0.13862897f, 0.05936049f, -0.35922155f, 0.06983407f, 0.09232542f, 0.04987048f, 0.18736547f, 
    0.04722564f, -0.02089753f, 0.06793111f, -0.08242572f, -0.03943855f, 0.18102832f, -0.04363832f, 0.08528057f, 
    0.15713333f, 0.16782139f, -0.12337091f, 0.00754554f, -0.00744953f, -0.05915364f, 0.13264506f, 0.17810707f, 
    -0.01071775f, -0.04913831f, -0.03476037f, -0.03629998f, -0.05863117f, -0.13165504f, 0.02146468f, -0.03367304f, 
    0.00773563f, 0.21267885f, -0.01637236f, 0.34531704f, -0.10314981f, 0.07547071f, 0.25854301f, -0.06561670f, 
    0.07464900f, -0.07352922f, 0.19614117f, 0.04218772f, -0.01808240f, -0.02527525f, 0.01892115f, 0.05294945f, 
    0.00959928f, 0.17197503f, -0.09067369f, -0.19082178f, 0.23167081f, 0.11669101f, 0.18949160f, -0.05270443f, 
    0.00957661f, -0.01896909f, 0.02873044f, 0.04383824f, -0.14060509f, -0.06696819f, -0.03248658f, -0.21483365f, 
    0.00429426f, -0.06831647f, -0.01692387f, -0.00995186f, 0.04996684f, 0.22658327f, 0.00727550f, -0.08642051f, 
    0.19742730f, 0.01694644f, -0.25232583f, 0.16214259f, 0.03879897f, -0.03313073f, 0.04067544f, 0.05339410f, 
    0.10865177f, -0.03567852f, 0.04612545f, 0.01061366f, -0.00893328f, -0.06441811f, 0.19103560f, -0.39135656f, 
    -0.07938810f, 0.14910755f, -0.08699598f, -0.22565621f, -0.06952561f, 0.09276961f, 0.14079009f, -0.00603505f, 
    0.04117290f, 0.04076673f, -0.22411588f, 0.00331566f, 0.06148542f, 0.05125784f, 0.00279781f, -0.05281444f, 
    -0.06590132f, -0.14129423f, -0.17768534f, -0.23060000f, 0.17664962f, -0.08419420f, 0.14516175f, -0.06408515f, 
    -0.03383352f, -0.01686115f, -0.02138218f, -0.12356015f, -0.17714016f, -0.11050439f, -0.15130639f, -0.10440108f, 
    -0.29275572f, -0.07439081f, -0.15100828f, 0.16453926f, -0.02179109f, -0.06016437f, 0.17227022f, 0.00854673f, 
    0.19319603f, 0.02371058f, 0.08606172f, 0.14660907f, -0.00007926f, -0.02606951f, -0.09017540f, -0.04222676f, 
    -0.08809561f, -0.13320819f, -0.02903975f, 0.09263512f, -0.04857458f, 0.14596164f, 0.09308404f, -0.12352314f, 
    -0.24269566f, 0.09898267f, -0.38717589f, -0.09965587f, -0.02386446f, 0.26222926f, -0.22339118f, -0.04655103f, 
    0.04015555f, -0.14069735f, 0.14688723f, -0.01347888f, 0.13059086f, 0.06019252f, 0.01899004f, -0.16092008f, 
    0.09288443f, -0.13418855f, 0.12017851f, -0.04761852f, 0.04389839f, 0.01169053f, -0.00499008f, 0.00367754f, 
    0.02466938f, -0.06839690f, 0.07571669f, -0.07298402f, -0.10192862f, -0.02899151f, -0.17800511f, 0.04585309f, 
    0.23598212f, 0.03863231f, 0.02667569f, -0.13074763f, -0.08233624f, -0.02454586f, 0.11455052f, 0.38243943f, 
    -0.04669662f, -0.05387263f, 0.10490548f, -0.04891932f, -0.08588397f, 0.01392861f, -0.06808221f, -0.06311850f, 
    -0.56431508f, -0.18047324f, -0.10380895f, 0.13034578f, 0.07022705f, 0.03142800f, 0.00745932f, -0.02332419f, 
    0.05691354f, -0.02627873f, 0.01567655f, -0.06291317f, 0.13408168f, -0.03121455f, -0.01838981f, -0.14981964f, 
    0.01252067f, -0.02031126f, 0.06431850f, 0.00113786f, 0.03937507f, -0.14610153f, 0.07859676f, 0.05764942f, 
    0.32088256f, -0.13810445f, -0.29921633f, 0.10543303f, 0.02756051f, -0.04246224f, -0.09081668f, 0.03288731f, 
    0.10019404f, -0.15619564f, -0.10850105f, 0.15406153f, -0.09730749f, 0.07688479f, 0.33343053f, -0.14809817f, 
    -0.00524839f, -0.13732262f, -0.03650780f, 0.10755254f, 0.12215503f, 0.19308530f, -0.05166096f, -0.03548267f, 
    -0.05793296f, -0.06305049f, -0.05768031f, 0.12668219f, 0.08598734f, 0.01448613f, -0.06597102f, 0.03826539f, 
    0.05198493f, 0.07184748f, 0.01646837f, 0.04595631f, -0.07601240f, -0.23599954f, 0.05618359f, 0.01197187f, 
    -0.13988616f, -0.01670333f, -0.04043724f, -0.05398939f, 0.07896654f, -0.02777077f, 0.15057646f, 0.06156069f, 
    -0.02293855f, 0.08063708f, -0.13227135f, -0.00752282f, 0.02013858f, -0.09725814f, -0.07445060f, 0.01993560f, 
    -0.07925037f, -0.01343036f, 0.10685912f, -0.08795185f, -0.14801846f, -0.30983737f, 0.14104292f, 0.22354956f, 
    -0.03186938f, -0.07907525f, -0.03110236f, 0.03149198f, -0.07868161f, -0.04167109f, -0.00047126f, -0.04316511f, 
    0.03849017f, 0.15987344f, 0.20265393f, 0.13723627f, 0.02069346f, 0.05502197f, 0.01063165f, -0.01344864f, 
    0.10398692f, -0.04977515f, 0.01662027f, 0.18334366f, 0.03881001f, -0.27479395f, 0.13799666f, -0.03765677f, 
    -0.08853413f, 0.04105369f, 0.01541384f, 0.03363782f, 0.14133202f, 0.06219584f, 0.17550112f, -0.06834080f, 
    0.04591170f, -0.10226595f, -0.13671626f, -0.00671570f, -0.00073320f, 0.01027289f, -0.05347155f, -0.04510207f, 
    0.02209468f, -0.03581747f, 0.07519920f, -0.16461468f, -0.29887778f, -0.16844499f, -0.12338245f, 0.26330346f, 
    -0.03167302f, -0.06400339f, 0.07059658f, -0.03871906f, 0.03430450f, 0.06518561f, 0.02340809f, 0.12839171f, 
    0.04798947f, -0.24165554f, -0.04770371f, 0.21880622f, 0.11767819f, -0.15488485f, -0.06077174f, 0.05367740f, 
    -0.05176829f, 0.06070594f, -0.05247851f, 0.13965599f, 0.07854602f, 0.32597917f, -0.13978857f, -0.06907155f, 
    -0.06983667f, -0.20947705f, -0.02287878f, 0.11306188f, 0.13516866f, 0.11183548f, -0.10400090f, -0.07039932f, 
    0.19220355f, -0.07260748f, -0.16197877f, 0.13643512f, 0.05026653f, -0.06711435f, 0.06013436f, 0.09791038f, 
    0.07977717f, -0.09503694f, 0.04041402f, 0.12685469f, 0.02484733f, -0.32326376f, 0.12118851f, 0.05940563f, 
    -0.01161105f, -0.06372419f, 0.07035416f, -0.01304954f, 0.00500810f, -0.21910694f, 0.37001169f, -0.17448126f, 
    -0.20302181f, -0.13693482f, -0.15696649f, -0.07923809f, -0.03662394f, 0.09440468f, 0.04144210f, -0.05123966f, 
    0.09540304f, 0.02477134f, -0.05077088f, 0.03924994f, -0.05525923f, -0.07104715f, 0.08208470f, 0.11338204f, 
    -0.09762550f, -0.17277917f, -0.06796589f, 0.09513361f, -0.00122463f, -0.09597135f, -0.09774619f, -0.24628946f, 
    -0.08844969f, 0.08396617f, 0.21690220f, -0.05755078f, 0.09858475f, -0.01456787f, -0.08281600f, 0.19907050f, 
    0.05758535f, 0.00891562f, 0.06987697f, 0.00554963f, -0.56317472f, -0.10256813f, 0.26586828f, -0.24708170f, 
    0.07669066f, -0.05747925f, 0.03237782f, 0.01944425f, 0.04306873f, -0.36364964f, -0.35713583f, -0.30354410f, 
    -0.56211823f, -0.29421937f, -0.04359771f, -0.09669488f, 0.05204870f, -0.04807856f, 0.01234089f, 0.09768941f, 
    -0.00750490f, -0.15758583f, 0.01246937f, 0.01628511f, -0.14142850f, -0.15582617f, 0.17792654f, 0.28312340f, 
    -0.11228701f, 0.02702477f, -0.05164325f, -0.01978360f, 0.20023428f, -0.18913755f, 0.04162644f, 0.10388713f, 
    0.19580568f, 0.10494504f, -0.22902428f, -0.11625594f, 0.13610767f, 0.06502529f, 0.00602200f, 0.05147421f, 
    0.02541040f, -0.00163765f, 0.07091480f, 0.02342840f, 0.16304874f, -0.08485252f, -0.17199153f, 0.05218889f, 
    -0.01100630f, 0.06584179f, 0.04799984f, -0.01487392f, 0.06309368f, -0.23730958f, -0.03484747f, -0.39769661f, 
    0.04838345f, 0.16370408f, 0.02024389f, -0.01843349f, -0.04862180f, 0.03625199f, 0.11801430f, -0.05839209f, 
    -0.02150074f, 0.13164113f, 0.11494028f, 0.01562072f, -0.04709315f, 0.04473118f, -0.37231287f, -0.21134490f, 
    -0.00342149f, 0.05898718f, -0.06446629f, -0.16561882f, 0.19470625f, -0.02780667f, 0.04598477f, -0.06773154f, 
    -0.05444867f, 0.18314169f, -0.20279282f, 0.05132443f, 0.28642353f, 0.02186637f, 0.05500343f, 0.30040115f, 
    -0.04114503f, 0.02863420f, 0.11366224f, -0.08991487f, -0.01270985f, -0.08970820f, -0.16263562f, -0.19274954f, 
    0.04346947f, 0.01757630f, -0.17438816f, 0.14517298f, -0.06075610f, -0.05093555f, -0.03806454f, -0.01958173f, 
    -0.39535844f, -0.31949216f, 0.09970340f, -0.06848019f, -0.15044840f, -0.02457907f, 0.05883019f, -0.07876568f, 
    0.05620134f, -0.11370220f, 0.17001595f, 0.14530207f, 0.04932093f, -0.14458843f, -0.17451663f, -0.13357222f, 
    -0.00065675f, 0.00772945f, -0.04907884f, 0.12720457f, -0.00311069f, -0.15079564f, 0.03650142f, -0.08758239f, 
    -0.16626652f, -0.09619997f, 0.06624886f, -0.02463589f, 0.07185604f, -0.05489431f, -0.08959898f, 0.26145798f, 
    0.01524215f, -0.00619424f, -0.17220068f, 0.07650957f, 0.11001692f, 0.10459866f, 0.15869747f, 0.00498688f, 
    -0.04015037f, -0.05909327f, -0.08697748f, -0.35968301f, -0.05275793f, -0.10680068f, 0.00038411f, -0.11424305f, 
    0.10118111f, 0.23691282f, 0.03962424f, -0.14856052f, 0.25927636f, -0.00814061f, 0.01026269f, 0.00742275f, 
    0.08954200f, 0.04133864f, 0.03928026f, 0.16355784f, -0.01904518f, 0.07187323f, 0.22004017f, -0.24285030f, 
    -0.01857119f, -0.08854166f, 0.02740815f, 0.09660615f, -0.14467828f, -0.06924372f, 0.00456683f, 0.03984497f, 
    -0.41752708f, 0.33216670f, 0.01341425f, -0.26585269f, 0.09619711f, 0.05693061f, -0.11011884f, 0.08784474f, 
    0.13617104f, 0.06841746f, -0.06654166f, 0.14317089f, -0.03717526f, -0.01231679f, -0.20737371f, -0.01200711f, 
    0.10898755f, 0.14872152f, 0.08312030f, 0.00940541f, -0.03360329f, 0.13030834f, 0.07305486f, 0.05107106f, 
    0.16276409f, 0.16113630f, 0.08349635f, -0.10702150f, -0.02900838f, 0.01644018f, 0.14932294f, -0.04639506f, 
    0.07742616f, 0.02372370f, 0.20066202f, 0.14229351f, -0.61611384f, -0.62319130f, -0.16140875f, -0.28075445f, 
    -0.09973696f, -0.33297044f, 0.00365526f, -0.25689334f, -0.06339621f, -0.04502345f, -0.00301646f, -0.10650006f, 
    -0.10041567f, -0.16481920f, 0.00608066f, 0.17556491f, 0.10571270f, 0.10677730f, 0.13878597f, -0.08487068f, 
    -0.04095840f, -0.05688309f, -0.09654820f, -0.02328289f, 0.18935956f, -0.04905471f, -0.11171804f, -0.08135706f, 
    -0.07556757f, 0.07241730f, 0.10321952f, 0.06972024f, 0.06213802f, 0.00830167f, -0.03885645f, 0.00810397f, 
    0.02731061f, -0.01472650f, -0.30910185f, 0.01446860f, -0.02440032f, -0.01617147f, 0.04402481f, 0.06532551f, 
    -0.06285529f, 0.03378027f, -0.05451478f, 0.16787820f, -0.07255160f, -0.17057864f, -0.11935125f, -0.02950308f, 
    -0.01783014f, 0.04549830f, 0.12681827f, 0.05259453f, 0.03271239f, -0.00757045f, 0.07325638f, -0.00412088f, 
    -0.62505889f, -0.67474967f, 0.04116500f, -0.08059616f, 0.05360650f, -0.21110974f, -0.00093952f, -0.05226574f, 
    -0.03184485f, -0.01147537f, -0.03003840f, 0.01675372f, -0.15758920f, -0.11681148f, 0.12634338f, -0.07813071f, 
    -0.06621636f, -0.28975698f, -0.32020807f, -0.07731757f, -0.03139181f, -0.04644147f, -0.08878691f, -0.02825421f, 
    -0.06395761f, -0.12208651f, 0.13886680f, -0.37896889f, 0.03130703f, 0.13844913f, -0.20310479f, -0.21258785f, 
    -0.06253161f, 0.03231965f, -0.01106069f, 0.08802354f, -0.10326998f, -0.15845685f, -0.36417437f, -0.05680891f, 
    -0.01288145f, 0.03268466f, 0.18974565f, -0.11111602f, 0.06639945f, 0.03362808f, 0.14947136f, 0.02454925f, 
    -0.71207637f, -0.36469424f, 0.11715807f, 0.21756689f, -0.08071700f, 0.01614457f, -0.01673688f, -0.15845735f, 
    -0.00993680f, -0.10204485f, 0.07226250f, 0.06320511f, -0.19246571f, 0.07818671f, -0.02043092f, -0.20573647f, 
    0.01821404f, -0.12460098f, -0.01339731f, -0.07529871f, -0.01005193f, 0.03133854f, 0.01866310f, 0.10936360f, 
    -0.28622633f, -0.29158860f, -0.00356568f, 0.23315629f, 0.12926230f, 0.11761948f, -0.00792808f, -0.15168348f, 
    0.00642212f, 0.09492236f, -0.04863014f, 0.04577965f, -0.30947000f, -0.34923694f, -0.50854170f, -0.49941841f, 
    -0.11255467f, 0.03367204f, 0.11899526f, 0.06471710f, -0.02806878f, 0.03626901f, -0.09295151f, 0.01243171f, 
    -0.00694205f, -0.00983072f, -0.00516686f, -0.06172908f, 0.02329286f, -0.07368827f, 0.00533494f, -0.05514994f, 
    -0.08483145f, -0.20147786f, -0.20346545f, -0.17647181f, -0.13855304f, -0.48755416f, -0.52635145f, 0.12070931f, 
    -0.03456840f, 0.11207320f, -0.03669058f, -0.21136121f, 0.02214645f, 0.02545364f, -0.00185917f, -0.00686378f, 
    -0.50498986f, -0.54732859f, -0.53630513f, -0.28123552f, -0.07160997f, -0.28883147f, -0.28964600f, -0.21865095f, 
    -0.02767489f, -0.01199326f, -0.01901437f, 0.02055766f, 0.05340696f, 0.31973085f, 0.23218164f, -0.03500352f, 
    -0.06219622f, -0.08087772f, -0.03698958f, 0.12788208f, -0.04806567f, 0.12560117f, 0.11687308f, 0.11234261f, 
    0.16949268f, -0.25557470f, -0.49876043f, -0.21851560f, -0.08674923f, 0.06832259f, 0.10250539f, 0.01703623f, 
    -0.05541625f, 0.05876383f, -0.01483446f, -0.05467348f, -0.38555831f, 0.27537400f, 0.08672366f, 0.12628320f, 
    -0.06452352f, 0.00853418f, -0.02511231f, 0.02959621f, 0.04188346f, 0.13322909f, -0.15256529f, 0.14524199f, 
    0.04544993f, 0.19577214f, 0.08823256f, -0.06005865f, 0.00737116f, -0.00714324f, -0.03469406f, 0.10327085f, 
    0.03238000f, 0.14394343f, 0.21930817f, -0.05291966f, -0.39600012f, -0.01765578f, -0.28738210f, -0.06911612f, 
    -0.16834734f, -0.00749917f, -0.17421126f, 0.16038133f, -0.01616687f, -0.07290775f, 0.00646121f, -0.00921324f, 
    -0.11579841f, -0.05897903f, 0.17021053f, 0.18801361f, 0.01462802f, -0.06272893f, 0.10836162f, -0.08030155f, 
    0.03708858f, -0.08040515f, -0.07638074f, 0.04573757f, -0.07728571f, -0.05943239f, 0.04673702f, -0.02708252f, 
    0.01036293f, 0.07859362f, -0.07598292f, -0.16828623f, 0.09096750f, 0.05908835f, -0.07199537f, -0.02417678f, 
    0.00242200f, -0.11414184f, 0.11408050f, -0.12483036f, 0.01068090f, 0.10760458f, 0.06678812f, -0.13903511f, 
    -0.00516845f, 0.00166264f, -0.08565480f, 0.07472929f, -0.08555148f, -0.43112108f, -0.26280344f, -0.28604755f, 
    -0.11501701f, -0.00418973f, 0.16630499f, -0.09185977f, -0.01173807f, 0.06006854f, -0.02972987f, -0.00830848f, 
    -0.22499418f, 0.00780132f, 0.16787939f, 0.07299700f, -0.17409611f, -0.19248581f, -0.03797629f, 0.01588201f, 
    0.03329900f, 0.05518801f, 0.00009725f, -0.12117349f, -0.09137250f, -0.06475262f, 0.10625557f, 0.05953949f, 
    0.09898391f, 0.05038787f, -0.16116063f, -0.09711760f, 0.00509994f, 0.09288295f, 0.02718789f, 0.07443801f, 
    0.12241862f, -0.00747639f, -0.16412342f, -0.12250588f, -0.00826894f, 0.04974426f, -0.03461434f, 0.06445207f, 
    -0.03112310f, -0.02399331f, 0.04595323f, -0.12830704f, -0.16361853f, -0.10443497f, 0.16898760f, 0.11236279f, 
    -0.18472022f, 0.15639524f, -0.02827468f, 0.03246754f, 0.03333484f, 0.06388868f, -0.15949759f, -0.08026892f, 
    0.45056596f, 0.24544422f, -0.06768473f, 0.10422432f, -0.12975958f, -0.02448956f, 0.23611203f, 0.16912900f, 
    0.17859307f, -0.02187081f, 0.03972596f, -0.11539086f, -0.04868697f, -0.20074157f, 0.13329002f, 0.20880190f, 
    0.09390498f, 0.05320382f, 0.11636495f, 0.01999171f, 0.03639466f, 0.03626812f, 0.04690011f, 0.10004313f, 
    -0.14788391f, -0.06900298f, -0.05291757f, -0.11665123f, -0.04113552f, 0.02033668f, 0.12686889f, -0.04257310f, 
    -0.04108853f, -0.01141558f, -0.07347342f, 0.02646608f, -0.22106396f, -0.00498687f, 0.12452771f, -0.02195156f, 
    0.03714538f, -0.04715572f, -0.01000219f, 0.01024495f, 0.07714218f, 0.09847654f, -0.03180141f, 0.17180645f, 
    0.17138696f, 0.03368191f, -0.18372226f, -0.00216418f, -0.01066067f, -0.07658450f, -0.02290818f, 0.01977678f, 
    0.08427381f, -0.18265642f, 0.02114168f, 0.02837456f, -0.04753694f, 0.00366116f, -0.15622678f, 0.16585033f, 
    0.02616645f, 0.07345118f, -0.00929602f, 0.03165720f, -0.11037429f, -0.11275534f, 0.06432436f, 0.02781270f, 
    0.04642662f, -0.57133746f, -0.47669736f, -0.35587993f, -0.05265814f, -0.05779009f, 0.12398389f, 0.03183611f, 
    -0.04721406f, 0.09469832f, -0.03713316f, -0.02608198f, 0.04122191f, -0.02261285f, -0.04068578f, 0.09259491f, 
    0.01848648f, 0.05819872f, 0.00369324f, 0.04269480f, 0.13564123f, -0.02951328f, 0.06169303f, 0.03156774f, 
    -0.10024040f, -0.06474181f, -0.03126853f, -0.05252957f, 0.03463929f, -0.04091768f, 0.00385527f, -0.04294988f, 
    -0.11788259f, -0.02477507f, -0.21971759f, -0.08972590f, 0.08515565f, 0.06050444f, -0.00744493f, -0.04551008f, 
    0.02909447f, -0.00705765f, -0.02322759f, -0.02217483f, -0.01058172f, -0.06613814f, 0.13289614f, -0.09610500f, 
    0.07788479f, 0.06212416f, -0.08351784f, 0.01442408f, -0.02761779f, -0.05035310f, 0.12418131f, 0.00455043f, 
    0.02331022f, -0.03413603f, 0.01516979f, -0.05796855f, -0.29899609f, -0.02100408f, 0.02257789f, -0.02802547f, 
    -0.12895742f, -0.16648914f, 0.05567979f, -0.22218770f, -0.11032222f, 0.06546632f, -0.03039668f, -0.06651269f, 
    0.28259009f, 0.13739297f, -0.06057381f, -0.04108901f, 0.02770595f, -0.02065307f, 0.21328649f, 0.03783045f, 
    0.05813557f, 0.07032798f, -0.01067744f, -0.05331529f, -0.01894268f, 0.04421526f, -0.16727865f, 0.05261458f, 
    -0.01984169f, 0.09514021f, 0.04765343f, 0.09105412f, 0.14934005f, 0.07303368f, 0.19927983f, 0.02825806f, 
    -0.08876714f, 0.24001056f, 0.47304145f, 0.58549792f, -0.00549991f, -0.13678364f, -0.06088784f, 0.04295632f, 
    -0.02829765f, 0.03011367f, 0.07387470f, 0.05686532f, 0.01739991f, -0.17229454f, -0.05105874f, 0.04306801f, 
    -0.12824997f, 0.13339178f, 0.08969989f, 0.05502517f, 0.14873837f, 0.03886211f, 0.08800272f, 0.01075075f, 
    -0.69293129f, -0.55066544f, -0.08108966f, 0.13929316f, -0.20933545f, 0.09321442f, 0.18710138f, -0.02975492f, 
    -0.00393382f, -0.06289803f, 0.09028078f, 0.00422246f, 0.06702155f, -0.12826772f, 0.15787679f, -0.07646058f, 
    -0.04016842f, -0.05620099f, 0.06845327f, 0.10564192f, 0.12775263f, 0.15875965f, 0.18049219f, 0.08165731f, 
    -0.37960020f, 0.22486925f, 0.24480037f, 0.16709115f, -0.13221072f, -0.11201391f, 0.01871347f, 0.31239173f, 
    0.02471526f, 0.10488237f, 0.07327475f, 0.00809369f, 0.06056402f, -0.09704794f, -0.03122602f, 0.11504266f, 
    -0.05213877f, 0.04309803f, -0.04604895f, 0.03087091f, 0.17213446f, -0.04574102f, 0.07502384f, 0.05740475f, 
    0.06244706f, -0.10414515f, 0.49138072f, -0.52689469f, 0.11811904f, -0.09555824f, 0.06396988f, -0.17425594f, 
    0.03265580f, 0.01044495f, -0.00596595f, 0.07840437f, 0.06943822f, 0.06019419f, -0.02465719f, -0.13590299f, 
    -0.05657055f, 0.06581309f, 0.08639453f, 0.01497681f, 0.02059098f, 0.10839224f, 0.23907062f, 0.10828336f, 
    -0.54314172f, -0.14899300f, 0.18603648f, 0.28862548f, -0.13316277f, 0.15266769f, -0.06284143f, -0.19863309f, 
    0.00074740f, 0.00357540f, -0.06136893f, 0.08268300f, 0.30338725f, 0.07838871f, 0.22637647f, -0.08920366f, 
    0.13729589f, -0.01553467f, 0.06047093f, -0.03927661f, 0.05529975f, 0.12888417f, -0.01803853f, 0.07162245f, 
    0.15802555f, -0.33139819f, -0.28678194f, -0.31699544f, -0.09472001f, 0.04935123f, 0.10972069f, 0.02007708f, 
    0.03502173f, 0.03058472f, -0.00410663f, -0.05905837f, -0.39205784f, -0.26951528f, -0.39680725f, -0.34516758f, 
    -0.03050359f, 0.05379381f, -0.00638566f, 0.00220784f, -0.00828059f, 0.03642752f, 0.00893792f, 0.05341841f, 
    -0.30961457f, 0.03278130f, 0.27977759f, 0.17064109f, -0.13374521f, -0.03583284f, -0.20639563f, 0.17655857f, 
    -0.06188682f, 0.09009428f, 0.19878796f, -0.08019660f, 0.39440691f, 0.53500074f, -0.28878245f, -0.01503434f, 
    -0.02749035f, -0.04149935f, -0.17371103f, 0.16568030f, 0.13984713f, -0.08142360f, -0.04306160f, 0.02758211f, 
    -0.10598221f, -0.31502810f, 0.03063203f, 0.10507796f, -0.01326331f, -0.10966694f, 0.06716371f, -0.04901560f, 
    0.00103749f, 0.02231132f, -0.03619928f, -0.02028073f, -0.19133684f, -0.57999146f, -0.20406286f, -0.07026257f, 
    0.09160422f, 0.12189052f, 0.02742104f, -0.17532489f, 0.00349868f, 0.02180514f, 0.07581483f, 0.04050215f, 
    -0.49214929f, -0.50146210f, -0.59040332f, -0.11883280f, -0.21665524f, -0.36387357f, -0.21274669f, -0.26172575f, 
    -0.05749579f, 0.02558368f, -0.04876266f, 0.01042321f, -0.11872054f, -0.12726367f, -0.02865433f, 0.40686941f, 
    0.08855268f, 0.01250694f, 0.02225528f, 0.11199941f, 0.06283670f, -0.02189315f, 0.11639823f, -0.04042247f, 
    -0.14028026f, -0.28451660f, 0.00303907f, 0.04965358f, 0.06149507f, 0.07955780f, 0.03242229f, -0.03395017f, 
    -0.01259572f, -0.02624486f, -0.02152774f, -0.00800919f, -0.05457094f, 0.00062395f, -0.03171870f, 0.01788554f, 
    -0.03447514f, -0.04577806f, 0.08606059f, -0.03585114f, -0.00720151f, -0.04380312f, -0.04970442f, 0.09858775f, 
    -0.22698314f, 0.17477593f, -0.31037194f, 0.27016076f, -0.04109208f, -0.06634644f, 0.14972067f, -0.09596425f, 
    0.04427230f, 0.15165770f, 0.05303955f, -0.07323707f, -0.28817144f, -0.27015349f, -0.04854964f, 0.58645511f, 
    0.01185542f, -0.05602551f, -0.03929641f, -0.01831583f, -0.06350560f, -0.09503297f, 0.09680395f, 0.01024127f, 
    -0.13012554f, 0.07928658f, 0.03271506f, 0.05183941f, -0.12781143f, -0.10101973f, 0.02713789f, -0.05839541f, 
    -0.01901056f, 0.06004325f, -0.02513778f, -0.00477143f, -0.10098253f, 0.01549083f, 0.04016758f, -0.06786796f, 
    0.03083432f, -0.08940860f, -0.03879691f, 0.22131626f, 0.07035716f, 0.05455657f, 0.07506064f, -0.01493014f, 
    0.20133935f, -0.32358062f, -0.00555352f, 0.02619135f, -0.04578289f, 0.07842297f, -0.18736151f, 0.03883066f, 
    0.05275949f, 0.01859279f, -0.04527831f, -0.04737347f, 0.09398813f, 0.00641946f, -0.11230275f, -0.02392627f, 
    -0.04115961f, -0.09155550f, 0.00589462f, -0.04344387f, 0.01696974f, 0.05218998f, 0.01652872f, 0.02908445f, 
    -0.03125335f, -0.34584790f, -0.32135674f, -0.35357583f, 0.08381300f, 0.26299331f, -0.23502871f, 0.20919529f, 
    0.03011596f, -0.00638405f, -0.03085453f, 0.09812137f, 0.03838610f, 0.15881310f, -0.07163100f, 0.00741867f, 
    -0.05323946f, -0.14539814f, -0.11255931f, -0.06800894f, 0.01441959f, 0.03285306f, -0.02920525f, 0.00991345f, 
    0.19718760f, 0.15174386f, -0.12777229f, 0.16035973f, -0.10408150f, 0.27772576f, -0.01129351f, -0.08349893f, 
    -0.07050171f, -0.01694145f, -0.06537881f, -0.16485260f, -0.10650513f, -0.29814005f, 0.33126271f, -0.16713776f, 
    -0.12361647f, -0.12950458f, 0.00110527f, 0.00386030f, -0.05473458f, -0.08174712f, -0.00628659f, 0.02362069f, 
    -0.34001625f, -0.44075489f, 0.35918441f, -0.09901214f, 0.14635681f, -0.04307334f, 0.05649732f, 0.13251626f, 
    0.03096622f, -0.00772782f, 0.02465728f, -0.01024321f, 0.14212872f, 0.03882549f, -0.01226440f, -0.10078190f, 
    0.04878815f, 0.00918362f, 0.11339411f, 0.04523861f, -0.04696883f, -0.06097384f, -0.11692128f, -0.10974169f, 
    -0.11890484f, -0.02756101f, 0.18018186f, -0.12524863f, 0.01496122f, 0.01966367f, 0.11077581f, -0.00677948f, 
    0.03587263f, -0.01344248f, 0.01618522f, -0.02575329f, -0.48661235f, 0.40955654f, -0.22318909f, 0.11642235f, 
    0.04285007f, 0.00195061f, -0.01768579f, -0.01000449f, 0.05485071f, 0.00272567f, -0.02512655f, -0.00708767f, 
    0.02120644f, 0.09023447f, 0.03632915f, 0.00376203f, 0.04388253f, -0.00888404f, 0.03943393f, -0.02072353f, 
    -0.17063412f, -0.16825810f, -0.10759298f, -0.00921494f, -0.18903297f, -0.31275707f, 0.02933767f, -0.11971055f, 
    0.05787142f, 0.15409356f, -0.03122259f, 0.11038888f, -0.04828481f, -0.05249684f, -0.10179021f, 0.05010539f, 
    -0.34421748f, -0.16633537f, -0.06764538f, 0.08612856f, 0.02736839f, 0.05432769f, 0.14925189f, 0.03255798f, 
    0.01542417f, 0.00286888f, 0.00650446f, 0.02761177f, 0.15901770f, -0.55211866f, 0.19434747f, -0.16067708f, 
    0.03193310f, 0.00548902f, 0.00163305f, -0.03737524f, 0.03620925f, -0.04810594f, 0.09571867f, -0.04187670f, 
    -0.11784848f, 0.00704178f, 0.03636074f, -0.08620933f, 0.09599742f, 0.08724571f, -0.02967009f, -0.04234926f, 
    0.10952007f, 0.08527863f, 0.03340406f, 0.05890302f, -0.01707155f, -0.09880240f, 0.11541355f, -0.15304540f, 
    -0.02541976f, 0.06590501f, 0.03773191f, 0.06589063f, -0.02499535f, -0.06847752f, 0.01350244f, -0.08195923f, 
    0.24046114f, -0.07203137f, 0.02402858f, 0.13194536f, 0.03952174f, -0.02130828f, 0.00841056f, -0.02556368f, 
    0.14473528f, 0.05555380f, 0.09667113f, -0.01036906f, -0.42119914f, -0.44919279f, -0.09241976f, 0.39095628f, 
    0.03026309f, 0.19675873f, 0.09529499f, -0.02342374f, 0.03421978f, 0.07099650f, 0.03773373f, -0.10978901f, 
    0.00387257f, 0.09265892f, -0.09098802f, 0.06421822f, -0.08294538f, 0.06975466f, -0.04741366f, 0.04520893f, 
    0.06408346f, -0.05397521f, 0.07055746f, -0.04788819f, 0.00753035f, 0.08641171f, 0.07596886f, 0.01689663f, 
    0.11579873f, -0.05510587f, -0.03060051f, -0.23276970f, -0.00530329f, -0.04610448f, 0.07595854f, 0.08749995f, 
    -0.06069912f, 0.14162430f, 0.12618470f, 0.03659134f, -0.11958495f, 0.00011434f, 0.00964097f, 0.21357363f, 
    -0.01748145f, 0.00435692f, 0.01883440f, -0.01073944f, -0.24658787f, -0.22167709f, -0.19488697f, 0.05092157f, 
    0.00073947f, 0.23459934f, 0.06162041f, -0.02432909f, 0.04776915f, -0.02195983f, -0.12169228f, -0.00170721f, 
    0.05306787f, -0.01991134f, 0.12304474f, -0.10882914f, -0.11634855f, 0.08664625f, 0.04487313f, 0.05864685f, 
    -0.10412751f, 0.09038328f, 0.00867650f, 0.04190423f, 0.24692857f, -0.08205980f, 0.01274969f, -0.26473460f, 
    0.08421294f, -0.04572708f, -0.05507087f, 0.12933761f, 0.01257830f, -0.02338325f, -0.01903217f, -0.05929898f, 
    -0.04456191f, -0.00887644f, -0.01902472f, -0.06863559f, 0.00472616f, 0.03866507f, -0.03999856f, -0.02370577f, 
    0.06590763f, 0.01332671f, -0.00054931f, -0.05607065f, 0.01124335f, 0.08324330f, 0.01993186f, -0.16211154f, 
    -0.01579912f, 0.02186150f, 0.08064274f, 0.04145921f, -0.00129434f, -0.05018036f, 0.00617023f, 0.03410841f, 
    -0.02440855f, 0.08409180f, 0.00017808f, 0.06368957f, -0.14867838f, 0.13998255f, -0.01164268f, -0.08986477f, 
    -0.04117130f, 0.08397862f, -0.04580822f, -0.08275025f, 0.17765875f, -0.28280696f, 0.06440224f, -0.46879682f, 
    -0.20528558f, 0.23068215f, -0.15347341f, 0.06315937f, -0.07410251f, -0.03209513f, -0.05133837f, -0.09970257f, 
    -0.00053887f, 0.03784192f, 0.02152715f, -0.02786897f, 0.03726733f, -0.09761141f, 0.05765048f, -0.01022842f, 
    -0.01881600f, 0.02168813f, 0.02017712f, 0.00564888f, 0.13313715f, 0.04349772f, -0.07813305f, -0.14472854f, 
    0.00062722f, 0.08895689f, 0.03455660f, 0.01363997f, -0.07408499f, 0.00920249f, -0.09045334f, -0.01915210f, 
    -0.30345577f, 0.09229971f, 0.02166310f, 0.08552260f, -0.03758216f, -0.05394830f, 0.01043265f, 0.12932314f, 
    -0.04712619f, -0.04599420f, 0.02554265f, -0.05218806f, 0.11927238f, -0.09665685f, -0.01233443f, -0.04422346f, 
    0.00983875f, 0.00722043f, -0.03809485f, -0.05434643f, -0.02317867f, 0.08297730f, -0.00055916f, -0.01887516f, 
    -0.28885597f, -0.36422881f, 0.04990805f, 0.29973614f, -0.15333870f, -0.07487150f, -0.06612673f, -0.02265781f, 
    -0.01902849f, -0.13292153f, -0.11330802f, 0.03159375f, 0.08174240f, -0.05115598f, 0.08500337f, -0.19489689f, 
    -0.01233714f, 0.06985573f, -0.06194076f, -0.00098167f, -0.10634294f, 0.07454018f, -0.11119861f, -0.21834278f, 
    0.07644141f, 0.12145482f, 0.02572474f, 0.00485146f, 0.05438103f, -0.04745739f, 0.01981660f, -0.03700937f, 
    0.08000116f, 0.03189174f, -0.03571044f, -0.05261135f, -0.03813695f, 0.00438921f, -0.07935525f, 0.03760698f, 
    -0.02926929f, 0.02687893f, 0.02714339f, -0.04871187f, 0.03279478f, 0.07157257f, -0.08527138f, -0.03471947f, 
    0.06119417f, 0.05053329f, -0.04320035f, 0.00644971f, 0.01374861f, -0.01352330f, -0.01795324f, -0.02735419f, 
    -0.14588208f, -0.04547601f, -0.13255422f, -0.07168546f, 0.23728311f, 0.03556966f, -0.01850363f, -0.07886490f, 
    0.07632986f, 0.14502814f, -0.11061962f, 0.01378543f, -0.00463793f, 0.09305698f, 0.08940853f, 0.06546680f, 
    -0.08314664f, -0.07773963f, 0.07121223f, -0.06631760f, -0.10008088f, 0.02796606f, -0.02863837f, -0.10743329f, 
    -0.04237473f, -0.15455043f, -0.07124117f, 0.05129971f, 0.19548154f, -0.24722309f, 0.17778172f, -0.13041241f, 
    0.00854451f, 0.02375565f, -0.03240885f, -0.10037911f, -0.02596755f, 0.04044573f, -0.09353078f, -0.02630497f, 
    0.09346075f, -0.69759971f, -0.63429630f, -0.47525820f, -0.08327536f, -0.00396622f, -0.07719684f, -0.01362194f, 
    0.06637208f, 0.03328459f, 0.02232498f, 0.04509721f, 0.19524164f, -0.19063912f, -0.15969236f, 0.12148289f, 
    -0.00194043f, 0.03769039f, -0.01866750f, 0.01873044f, 0.05637685f, -0.00845665f, -0.02070958f, 0.12403699f, 
    -0.15102886f, -0.41534072f, 0.31690091f, -0.26521507f, 0.07140405f, -0.03294775f, 0.01562290f, 0.08964594f, 
    0.02280566f, -0.00778528f, -0.02806200f, -0.04168196f, 0.39361578f, 0.15968578f, -0.16819209f, -0.19345048f, 
    -0.00166962f, -0.06955511f, -0.10588186f, -0.04960890f, 0.16260312f, -0.03048352f, 0.03149772f, -0.03636116f, 
    0.63063622f, -0.22576420f, -0.18150625f, -0.33629534f, -0.15352711f, -0.22678801f, -0.19099605f, 0.02864004f, 
    0.11816735f, 0.00915164f, -0.02815356f, -0.07613578f, 0.17619558f, -0.04014566f, 0.04012000f, -0.23298840f, 
    0.00611394f, -0.02179724f, 0.00865253f, 0.04565550f, -0.02784750f, 0.05721870f, -0.00200774f, -0.27932400f, 
    -0.31706017f, 0.44805485f, 0.08683800f, 0.02956560f, 0.06524254f, -0.00951282f, 0.12896280f, 0.04029208f, 
    -0.01339120f, -0.03934832f, -0.00135908f, -0.01631376f, 0.00490441f, 0.06119840f, 0.05510632f, 0.18843873f, 
    0.00558172f, -0.01176673f, 0.02446688f, -0.15733512f, 0.02181923f, -0.06501846f, -0.01718369f, -0.00987744f, 
    -0.36237168f, -0.04359455f, -0.20188378f, -0.45592865f, 0.07276443f, -0.08861765f, 0.07735074f, 0.04430103f, 
    -0.02628324f, -0.06670898f, -0.00614644f, 0.05759557f, -0.17264052f, 0.08547586f, 0.21633787f, 0.01756779f, 
    -0.10074034f, -0.05631837f, 0.20013647f, 0.02057508f, 0.02413379f, -0.06717265f, 0.04549404f, -0.02038363f, 
    -0.36988500f, 0.41836068f, -0.41187784f, 0.25584489f, -0.02452112f, 0.10997173f, 0.07853302f, -0.12179350f, 
    0.01268731f, -0.03640905f, -0.06465977f, 0.01862557f, -0.01984459f, -0.32452640f, -0.22001517f, -0.32358560f, 
    -0.05332917f, 0.02824494f, 0.02464327f, 0.26663986f, 0.05685693f, -0.00649903f, -0.00073973f, -0.02501032f, 
    0.62251008f, -0.49747440f, -0.07399555f, -0.69343460f, -0.01364379f, -0.12294620f, -0.20689818f, 0.12360099f, 
    0.00561662f, -0.06487031f, -0.08985910f, -0.16409057f, -0.05964158f, -0.11963143f, -0.11845905f, -0.03093896f, 
    0.04256951f, 0.00493828f, -0.00417158f, -0.05580381f, -0.18681434f, -0.00776664f, 0.04359073f, 0.07347735f, 
    0.25586274f, -0.13509262f, 0.15446661f, -0.05509235f, -0.26083091f, 0.08386810f, -0.31875077f, 0.02660715f, 
    0.00512407f, 0.05280273f, 0.06704848f, -0.03056767f, -0.52862960f, 0.29268077f, -0.06908268f, 0.32659492f, 
    0.07323075f, 0.01805452f, -0.00221991f, 0.10135031f, 0.04215527f, -0.08440739f, 0.09857995f, -0.08503460f, 
    -0.42285836f, -0.14119929f, 0.18756023f, 0.41274628f, 0.17878707f, -0.20953250f, 0.02966385f, 0.00599963f, 
    -0.05574860f, -0.06438653f, -0.08155102f, 0.00410907f, 0.00794140f, -0.22160552f, -0.04725203f, -0.15479879f, 
    0.16951226f, -0.08338331f, 0.03051675f, -0.06135104f, -0.09252613f, 0.02052211f, -0.02634262f, 0.00825536f, 
    -0.04973175f, 0.31045392f, -0.00583229f, -0.04171275f, 0.04024859f, -0.06259693f, -0.03183965f, -0.04185167f, 
    0.04916790f, -0.01658754f, 0.00386790f, 0.00194361f, -0.01295272f, 0.03694555f, 0.06464839f, -0.11531942f, 
    -0.11383022f, -0.12301700f, -0.08868872f, 0.14082611f, 0.01094269f, 0.00072241f, 0.01673781f, 0.01255806f, 
    -0.23316726f, -0.14379439f, 0.15050861f, 0.06715398f, 0.00779872f, 0.11211544f, -0.09476028f, 0.10978847f, 
    -0.22490388f, -0.03288085f, -0.19792368f, -0.13507546f, -0.01126323f, -0.53986186f, -0.49837968f, -0.39872161f, 
    -0.01989095f, -0.11722743f, -0.06215876f, 0.04742010f, 0.06517792f, 0.08197240f, -0.00534601f, 0.05519984f, 
    -0.24193446f, 0.04549984f, 0.09486093f, -0.07464924f, 0.02920449f, 0.04547290f, -0.04255849f, 0.06465989f, 
    -0.00178524f, 0.03481527f, 0.01559720f, 0.01523073f, -0.17465106f, -0.09638789f, -0.06793644f, 0.10944750f, 
    -0.04547816f, -0.07410467f, 0.01850996f, -0.03866859f, -0.17330121f, 0.00892253f, 0.08470733f, 0.02860900f, 
    0.44850969f, 0.17155232f, -0.08859845f, -0.06405483f, 0.18997794f, -0.02376492f, -0.09626611f, -0.00514270f, 
    0.12671369f, 0.04046983f, 0.09809365f, 0.09857217f, -0.14321616f, 0.09050164f, 0.04763422f, -0.01352969f, 
    -0.03639359f, 0.03878067f, -0.03166060f, -0.24962826f, -0.06752470f, -0.02401315f, -0.11644878f, -0.11907601f, 
    -0.57560867f, -0.58428425f, -0.45992973f, 0.21283472f, 0.04642812f, 0.01583528f, 0.13105337f, 0.11399508f, 
    -0.04978380f, -0.01671632f, 0.09134371f, 0.10494886f, 0.10667825f, -0.03943211f, -0.09640731f, -0.06554215f, 
    -0.01595528f, -0.15251513f, 0.04365251f, 0.00239916f, 0.13821267f, 0.07864054f, 0.10307574f, 0.09717370f, 
    0.39445233f, 0.19054219f, -0.21813981f, -0.12344377f, 0.04704028f, 0.05713040f, 0.05901894f, 0.00397038f, 
    0.06703747f, 0.07146768f, 0.07119675f, 0.08752688f, 0.27290848f, -0.28549054f, 0.07920077f, -0.02306531f, 
    0.03901385f, 0.07292902f, 0.17325102f, -0.04195826f, 0.08467805f, -0.08307537f, 0.04165560f, -0.23166826f, 
    0.22284432f, -0.20265973f, -0.28355336f, -0.24744396f, -0.05677477f, -0.01193811f, 0.13996507f, 0.07704728f, 
    0.06125097f, 0.00960620f, -0.03669389f, 0.02857113f, -0.14861056f, -0.06971700f, 0.03200596f, -0.02320357f, 
    -0.14140654f, -0.03240995f, -0.04099469f, -0.02967817f, 0.09180422f, 0.16854000f, 0.09796173f, 0.11020578f, 
    0.02383740f, 0.10182527f, 0.02342312f, 0.01049871f, -0.23640954f, -0.07643659f, 0.02067536f, -0.33395478f, 
    -0.01329277f, 0.10680875f, -0.04297205f, 0.01047317f, -0.07112804f, 0.16082464f, 0.09374639f, 0.36937308f, 
    0.03875266f, -0.10938386f, 0.14926207f, 0.04551438f, 0.11099758f, -0.07208946f, 0.04443037f, -0.01994707f, 
    -0.07718436f, -0.10458862f, -0.06662896f, -0.06270144f, -0.06167108f, 0.02362966f, -0.01563716f, 0.07786061f, 
    0.04902350f, 0.12161985f, 0.07334055f, 0.03674813f, 0.16482902f, -0.02404218f, -0.12111982f, -0.16088511f, 
    -0.13097543f, -0.05781889f, -0.05443550f, -0.12825508f, -0.07024726f, 0.00537485f, -0.04461311f, -0.11386830f, 
    -0.51296413f, -0.57466090f, -0.25254780f, -0.00142277f, 0.01774296f, -0.09340455f, -0.14747657f, -0.14070703f, 
    -0.03797468f, 0.01792950f, -0.03355311f, 0.06168095f, -0.39674902f, -0.39855585f, -0.23756076f, -0.19207259f, 
    0.07462015f, 0.09237053f, 0.02284966f, 0.04347276f, 0.00415647f, 0.12624104f, -0.06003289f, 0.06990544f, 
    -0.32135391f, 0.23916785f, 0.03206407f, 0.03899821f, -0.05119148f, -0.08117648f, -0.03596325f, -0.02638467f, 
    -0.07430725f, 0.01205996f, 0.02310180f, -0.01657911f, -0.02589346f, 0.08398700f, -0.11843970f, -0.00420872f, 
    0.04547887f, -0.12626946f, 0.18742213f, 0.00379728f, 0.06495953f, -0.12267873f, 0.07470057f, 0.12626532f, 
    -0.22838254f, -0.05574020f, -0.05555782f, -0.06274861f, 0.00874653f, -0.02351698f, 0.05438581f, -0.04268505f, 
    -0.02452463f, -0.16294622f, -0.34351531f, -0.49295321f, 0.27689105f, -0.16826916f, -0.06135863f, -0.13650024f, 
    0.16883986f, 0.05707321f, 0.04626617f, 0.13308100f, -0.09817713f, -0.28624678f, 0.00669862f, -0.13704722f, 
    -0.06563282f, 0.00893433f, 0.01959566f, 0.20713921f, -0.02727118f, 0.01748602f, 0.00217569f, -0.08198148f, 
    -0.01187873f, 0.06377713f, 0.13547957f, 0.09755543f, -0.07851957f, -0.03073844f, -0.04812470f, 0.01074231f, 
    0.02452516f, 0.00269721f, -0.09415305f, -0.02231664f, -0.04663279f, -0.07376827f, -0.15654901f, -0.00963155f, 
    -0.40110046f, 0.03148831f, 0.18409285f, 0.17319214f, 0.02775415f, -0.21283209f, -0.01290246f, 0.09973425f, 
    0.08265322f, -0.11510614f, 0.02107652f, -0.01046109f, 0.05487011f, -0.11852827f, -0.15381794f, -0.15163080f, 
    0.03166898f, 0.09829024f, 0.09754916f, 0.08096808f, -0.07563762f, -0.07127658f, -0.11002190f, -0.09205418f, 
    -0.04376519f, -0.07426976f, -0.14504112f, -0.09828563f, 0.07206079f, 0.11198058f, -0.01291348f, 0.01325469f, 
    0.03235215f, 0.11276317f, 0.04520748f, 0.22590269f, 0.13241766f, 0.25351775f, -0.17444910f, -0.07992880f, 
    -0.13242492f, -0.17252412f, -0.10464650f, -0.04030034f, -0.01914875f, 0.03489682f, 0.06301518f, 0.07113421f, 
    -0.11006582f, 0.19362405f, -0.05181199f, -0.15629910f, -0.02832868f, -0.04427725f, -0.05090174f, 0.01733014f, 
    -0.16292296f, 0.01591951f, -0.10074977f, -0.07644206f, 0.07206837f, -0.12060520f, -0.00623072f, 0.04428756f, 
    -0.14387849f, -0.11998009f, 0.00795655f, 0.02699532f, 0.13395140f, 0.02787375f, 0.08522074f, 0.10310604f, 
    -0.48971111f, 0.10273914f, 0.15668662f, 0.11628713f, 0.04809679f, 0.00478110f, -0.01918023f, 0.03818022f, 
    -0.07400236f, -0.02259970f, 0.16729328f, 0.05719417f, 0.15915297f, 0.15312962f, -0.17547980f, -0.29206789f, 
    0.17028849f, -0.16308060f, 0.08997658f, -0.05947851f, 0.06237915f, 0.08774450f, 0.07135452f, 0.09661234f, 
    0.02943263f, 0.05977506f, 0.09738918f, 0.15664695f, -0.00326506f, -0.03543007f, -0.02900518f, -0.05630124f, 
    0.03517880f, 0.03532233f, 0.08883324f, 0.07592189f, -0.17802572f, -0.07725716f, 0.00269532f, -0.00750097f, 
    -0.00657279f, 0.01422931f, 0.06033453f, 0.03908830f, 0.07306106f, 0.10653032f, 0.18947341f, 0.19961159f, 
    -0.23817077f, -0.14013457f, 0.12275372f, 0.11860703f, 0.01379269f, -0.06534038f, -0.08409544f, 0.00451703f, 
    0.06900280f, -0.08454444f, -0.07252375f, -0.04243573f, 0.10736009f, 0.11322013f, -0.02066288f, -0.16129963f, 
    -0.02212042f, -0.06788456f, -0.01598798f, -0.03084132f, -0.00280785f, -0.10856986f, 0.01428462f, -0.04005674f, 
    0.45055661f, -0.07404118f, -0.06400202f, -0.20824994f, 0.05420033f, -0.04036950f, 0.16269715f, 0.08265035f, 
    0.10741013f, 0.11391427f, 0.15316100f, 0.02099409f, 0.22838815f, -0.08327819f, -0.07538147f, -0.27158311f, 
    0.07853322f, 0.03609015f, 0.04254185f, -0.03039996f, 0.04619190f, 0.07013926f, 0.09586374f, 0.04688181f, 
    -0.36133471f, -0.02985992f, 0.03522461f, -0.14927922f, -0.08975892f, -0.00240264f, -0.00714636f, -0.00390675f, 
    -0.14875330f, -0.00676791f, -0.10758240f, 0.05446882f, 0.09565207f, 0.13053817f, 0.06394827f, 0.04577706f, 
    0.00095354f, 0.07849737f, 0.00346236f, 0.04581235f, -0.07296672f, -0.00473863f, 0.07618008f, 0.05248906f, 
    0.09406632f, 0.02056913f, -0.08303339f, -0.06188788f, 0.01203501f, 0.00563436f, 0.01139176f, 0.01798454f, 
    0.14081028f, 0.04666220f, 0.09105330f, 0.20046473f, 0.11687319f, -0.10656053f, -0.12058958f, -0.15345779f, 
    -0.25717437f, -0.05429469f, 0.06526510f, -0.00304480f, -0.00545239f, -0.04251736f, -0.07292364f, 0.01301368f, 
    -0.25016916f, 0.17093088f, -0.03046508f, 0.18353814f, 0.11440247f, -0.02191487f, -0.05255531f, -0.03980505f, 
    0.01019833f, 0.12432940f, 0.01159080f, 0.01534526f, 0.27628419f, -0.04284379f, -0.07101042f, -0.20814404f, 
    0.04645810f, 0.01095466f, 0.12120462f, -0.05692027f, 0.09006193f, 0.07041621f, 0.07462075f, -0.10730516f, 
    -0.38518676f, -0.34942085f, -0.18553598f, 0.32656553f, 0.10453935f, 0.15100293f, 0.10805926f, 0.11613780f, 
    0.01347829f, -0.00985288f, 0.05074116f, -0.00434797f, 0.20004360f, -0.03577800f, -0.06559386f, 0.02169253f, 
    0.17242579f, 0.01974647f, 0.06808775f, 0.08106734f, -0.18103343f, -0.15370470f, -0.17545395f, -0.21823989f, 
    0.15365228f, -0.11775181f, -0.27339441f, -0.21203470f, 0.10691334f, -0.03258440f, 0.09186320f, -0.11433844f, 
    -0.08669385f, -0.07234435f, 0.02576975f, -0.03859935f, 0.00829526f, -0.02938648f, -0.12595089f, -0.11422097f, 
    0.02122023f, 0.00922566f, 0.01285302f, 0.04172717f, -0.10427120f, -0.03397673f, -0.07818103f, -0.29781732f, 
    -0.08580410f, -0.34796670f, -0.35586035f, -0.08181872f, -0.00645369f, 0.12577252f, 0.12839025f, 0.09965789f, 
    0.07871822f, 0.03097711f, -0.09168760f, -0.10222084f, 0.14968120f, 0.09590274f, -0.09840377f, -0.16720802f, 
    -0.02590754f, -0.08091960f, -0.03896850f, -0.02408124f, 0.13318779f, -0.01146961f, 0.01731270f, 0.19633038f, 
    -0.67018098f, 0.04858948f, 0.15665975f, 0.26923311f, 0.01367273f, 0.10786889f, -0.04843492f, -0.19419999f, 
    0.03486351f, -0.00782816f, 0.07165921f, 0.03138074f, -0.35693410f, -0.08708847f, 0.07216053f, 0.03984535f, 
    -0.02695790f, 0.01769032f, -0.02316346f, -0.04298211f, -0.08024770f, -0.09621792f, -0.07490394f, -0.52145576f, 
    0.35237449f, -0.22558686f, -0.26226124f, 0.11441784f, 0.00277522f, 0.12253025f, 0.21931109f, 0.05808773f, 
    -0.00020999f, -0.05156632f, 0.05217962f, -0.05432239f, -0.50649941f, -0.09367827f, 0.12784289f, 0.32872814f, 
    0.05163025f, 0.15241472f, 0.03674356f, 0.12326166f, -0.05379438f, 0.03065330f, 0.01531936f, -0.03785396f, 
    -0.23797800f, -0.01030882f, 0.15817684f, 0.33268362f, -0.03634533f, 0.09889854f, -0.14067934f, 0.10156769f, 
    -0.12283071f, 0.06900614f, -0.03671041f, -0.04218939f, -0.05884968f, -0.31558591f, -0.35687238f, -0.10960504f, 
    -0.02314671f, 0.02163884f, 0.16369759f, -0.04352431f, -0.01839667f, -0.07144732f, -0.11299621f, 0.01660248f, 
    -0.12108050f, -0.11630827f, -0.39332232f, -0.02830159f, 0.01856691f, -0.06755089f, 0.21568409f, 0.05052811f, 
    0.06431416f, 0.08813209f, -0.00688530f, 0.11886249f, -0.23706900f, -0.09070578f, -0.01869189f, 0.04467684f, 
    0.10162733f, 0.02947120f, -0.00669219f, 0.09240810f, -0.06414647f, 0.05623088f, -0.23304728f, -0.01826023f, 
    -0.02575007f, -0.14110574f, 0.02806309f, 0.02137763f, -0.00519982f, 0.03341737f, 0.03656378f, -0.01527525f, 
    -0.00601070f, 0.01616264f, 0.05971266f, 0.02688267f, 0.03385970f, -0.01483266f, -0.08506130f, -0.18192938f, 
    -0.06152935f, 0.02796544f, 0.09845135f, 0.07071628f, -0.03800655f, 0.13066396f, -0.06418471f, -0.02823250f, 
    0.04570513f, -0.42812908f, -0.38994902f, -0.50851393f, -0.21382588f, -0.14367099f, -0.13633850f, -0.10214007f, 
    0.01090086f, 0.06089461f, 0.08166046f, 0.12348896f, 0.32629666f, -0.04609913f, -0.03485110f, -0.12861164f, 
    -0.06780460f, -0.02746573f, -0.05302896f, -0.12651025f, -0.06720860f, -0.05614465f, 0.04600314f, -0.04220307f, 
    -0.10730562f, -0.05460382f, 0.25157207f, -0.09228995f, -0.01235520f, -0.01226750f, -0.14091553f, 0.01192483f, 
    0.03999234f, -0.00025571f, 0.00591569f, -0.02576424f, -0.10297337f, 0.05411232f, 0.05861239f, 0.00664537f, 
    0.10112958f, 0.06153208f, 0.04214453f, -0.00146820f, -0.00367380f, 0.00160269f, 0.01089413f, 0.08609198f, 
    -0.23855482f, 0.00103220f, 0.15462886f, -0.23994395f, 0.13534124f, -0.16249621f, 0.07539437f, 0.00230887f, 
    0.07518463f, 0.03350020f, -0.01284715f, 0.27933192f, -0.56857049f, -0.00747670f, 0.07250369f, -0.24903949f, 
    -0.00874542f, 0.05059836f, -0.02662335f, 0.06437407f, 0.09309687f, 0.02859319f, 0.00055514f, -0.02517039f, 
    -0.24635121f, 0.14516279f, -0.10444349f, -0.38750389f, -0.00979966f, -0.03341135f, 0.05360816f, 0.07658211f, 
    0.06114148f, -0.05843273f, -0.06413817f, -0.04741338f, 0.01566846f, 0.37917361f, 0.03768943f, -0.23069510f, 
    0.03239743f, 0.07273060f, 0.02297449f, 0.06092303f, 0.02688203f, 0.03360784f, -0.04677776f, -0.01911379f, 
    0.16860546f, -0.01458938f, -0.08926886f, 0.06006795f, 0.08738986f, -0.10781939f, 0.07449929f, 0.04433385f, 
    0.07906584f, -0.03723301f, -0.03309327f, 0.05222500f, -0.00690260f, -0.07857054f, -0.32290462f, 0.03029404f, 
    0.21080619f, 0.25051594f, 0.17358515f, 0.07769332f, -0.00265104f, 0.02144274f, 0.00414590f, 0.01839793f, 
    -0.34294915f, -0.13063227f, -0.27796540f, -0.53963488f, -0.32730713f, -0.01290768f, 0.10372261f, -0.01130789f, 
    0.07396214f, -0.04671732f, 0.02566186f, -0.06137986f, -0.10348593f, -0.11655025f, -0.00145861f, -0.02753336f, 
    0.14817427f, -0.23573495f, -0.14016755f, 0.06321443f, -0.12161925f, -0.12287779f, -0.12287106f, -0.12691195f, 
    -0.38976833f, -0.13178664f, -0.44371808f, 0.45002380f, 0.09007873f, -0.04910626f, 0.04452643f, 0.14090446f, 
    0.08799406f, -0.05468551f, 0.05699718f, -0.07837085f, 0.10184970f, -0.19310898f, 0.02467733f, -0.01607365f, 
    0.05844978f, -0.04240941f, -0.10594811f, 0.15562452f, -0.11649436f, 0.05879497f, 0.00238981f, 0.10641247f, 
    0.38780060f, -0.35133597f, 0.03358695f, -0.23729327f, -0.09036736f, -0.07946334f, -0.08359957f, 0.08058900f, 
    -0.07727160f, 0.06709477f, 0.00427673f, -0.04060903f, 0.18397260f, 0.03690923f, 0.16417044f, 0.13324361f, 
    0.07211197f, -0.03442512f, -0.10066824f, 0.06803571f, -0.11091005f, 0.05671748f, 0.03501078f, -0.00322091f, 
    0.06612039f, -0.64755678f, 0.12986542f, -0.42026871f, 0.02127011f, 0.04510691f, -0.10045307f, 0.11743549f, 
    -0.01365747f, 0.00500306f, -0.06943745f, -0.10313407f, -0.53731412f, 0.33963349f, -0.62024081f, 0.01602051f, 
    0.04087498f, -0.24828950f, 0.20493530f, -0.05518871f, 0.00300844f, -0.07354659f, -0.12969570f, -0.08371682f, 
    0.02258047f, -0.14567366f, 0.10567284f, 0.09256978f, 0.04138342f, -0.03582312f, -0.00894101f, 0.04803901f, 
    0.10782030f, 0.19025089f, -0.00582528f, 0.01656485f, -0.06649183f, 0.04576362f, 0.25090891f, 0.06003677f, 
    -0.12430756f, 0.00236360f, 0.02198851f, -0.01442980f, 0.07105889f, 0.04823655f, 0.05835584f, -0.00925660f, 
    0.00282058f, 0.27987283f, 0.09185401f, -0.26171258f, -0.23418812f, 0.05093970f, 0.06806342f, 0.28352833f, 
    -0.00448086f, 0.04522270f, 0.05169784f, -0.02204302f, 0.35369968f, 0.25583637f, 0.32175604f, -0.00714538f, 
    -0.06800474f, -0.12128508f, -0.07240950f, -0.12611093f, -0.06543427f, -0.09011726f, -0.03583659f, 0.09647207f, 
    -0.29164445f, -0.08211643f, -0.34059575f, 0.11450697f, 0.04861812f, 0.00878187f, 0.14408946f, -0.03061445f, 
    0.01150522f, -0.00666153f, -0.01526674f, -0.02493175f, 0.13036790f, -0.40261501f, 0.20905577f, -0.31402916f, 
    0.11734556f, -0.23970458f, -0.04439164f, 0.06698975f, -0.02331566f, -0.02951807f, -0.10762067f, 0.21054983f, 
    0.04250935f, 0.07295608f, 0.24858464f, 0.11124875f, 0.01264154f, -0.03576974f, -0.01434084f, -0.11082216f, 
    0.09180880f, 0.17043786f, 0.07491829f, 0.12860958f, 0.09721471f, -0.01615682f, 0.43773654f, -0.03296056f, 
    -0.00972930f, -0.27269918f, 0.07482041f, 0.04726432f, -0.09449676f, -0.03543140f, 0.01771445f, 0.07797501f, 
    -0.34957483f, 0.10202395f, -0.15405336f, -0.09282854f, 0.04013403f, -0.07355563f, -0.00956573f, 0.09767821f, 
    0.04788850f, -0.01483926f, -0.11157346f, -0.00015077f, -0.01794392f, -0.11592557f, -0.01833324f, -0.03844288f, 
    0.04487030f, 0.15324450f, -0.04779918f, 0.19528332f, 0.09804433f, 0.00754548f, -0.03009875f, 0.00477709f, 
    0.08269437f, 0.00158050f, -0.03253061f, -0.09579034f, 0.14575098f, -0.01146964f, 0.13765752f, 0.17755261f, 
    -0.02667768f, -0.03423163f, -0.04937271f, -0.13121283f, 0.01791645f, 0.13306433f, -0.08242997f, 0.40141878f, 
    -0.02127290f, -0.00483587f, -0.02563564f, 0.08788910f, 0.09779476f, -0.02602332f, 0.04628104f, 0.03600705f, 
    0.34087315f, -0.01363976f, -0.04668828f, -0.12633444f, -0.02035920f, 0.04293030f, -0.07955221f, 0.08230254f, 
    -0.02082930f, -0.06361805f, -0.13389646f, -0.09666041f, -0.43854061f, -0.23864999f, 0.05445620f, 0.06595459f, 
    -0.01565919f, 0.17651534f, -0.23640892f, 0.17349793f, 0.12627745f, -0.06294510f, -0.00700800f, 0.13709626f, 
    -0.12064342f, -0.00804766f, -0.11722267f, 0.10813544f, -0.02944713f, 0.07073866f, 0.12715426f, -0.07777292f, 
    0.07619135f, 0.02484655f, -0.04217003f, -0.03485006f, 0.16828741f, -0.65436238f, -0.04306447f, -0.16522489f, 
    0.19744942f, 0.01003836f, -0.10202151f, -0.02425029f, -0.06200418f, -0.07768437f, -0.06666601f, 0.00202480f, 
    -0.26460916f, 0.20666911f, -0.40064296f, -0.33105528f, 0.00413890f, -0.17481871f, 0.07698957f, -0.15807949f, 
    -0.06693315f, 0.10815743f, 0.04530059f, 0.02438313f, -0.22212970f, -0.54952359f, 0.03657473f, 0.11626881f, 
    -0.08502252f, 0.11872174f, -0.25410825f, -0.14493969f, -0.01803919f, -0.03220969f, -0.01019736f, -0.04553825f, 
    -0.10448525f, -0.29636848f, -0.09414282f, -0.22427630f, 0.07529688f, -0.09791359f, 0.07556194f, 0.13221678f, 
    -0.04220187f, -0.02594292f, -0.06722737f, -0.02080019f, 0.20576388f, 0.04138313f, 0.14119232f, 0.02625170f, 
    0.09090276f, -0.12106789f, -0.15037195f, -0.01885917f, -0.08580405f, -0.05072689f, 0.06350963f, -0.03993998f, 
    0.14136916f, 0.01629758f, 0.06456847f, -0.30016142f, -0.07552520f, 0.02202300f, 0.06587289f, -0.02242463f, 
    0.08563600f, -0.01854025f, -0.05110925f, 0.04054414f, -0.03642894f, -0.14725830f, -0.09715114f, -0.03879579f, 
    0.11310329f, 0.08599521f, 0.05490996f, -0.00160761f, -0.04096829f, -0.02310123f, -0.06507760f, 0.01964226f, 
    -0.31052360f, -0.28340062f, -0.27596688f, 0.14126311f, 0.07726831f, 0.06796152f, 0.06348675f, 0.04977203f, 
    0.02208254f, 0.02848156f, -0.04064627f, -0.15005811f, -0.00245646f, -0.15734091f, 0.20824851f, 0.10037959f, 
    0.03270153f, 0.03216229f, -0.10282296f, -0.12792046f, -0.12171444f, 0.04887246f, -0.05800408f, 0.00887003f, 
    -0.05231947f, -0.18031609f, 0.18689215f, -0.02990319f, 0.08343796f, 0.05660441f, 0.05084588f, 0.00260629f, 
    0.08531443f, 0.03849555f, 0.05645331f, 0.08763653f, -0.27325696f, 0.10950460f, -0.13382259f, 0.07561134f, 
    0.08198475f, 0.00441631f, 0.08076502f, 0.00831321f, 0.16980812f, -0.02501860f, -0.03384087f, -0.01426422f, 
    -0.15531515f, 0.08132338f, -0.10904304f, 0.20907462f, -0.02089769f, 0.07107233f, -0.05175523f, -0.06695987f, 
    0.06922412f, 0.08670686f, 0.10746305f, -0.13263927f, 0.05155136f, -0.20425703f, 0.05740250f, 0.24151082f, 
    0.01070758f, 0.18832736f, -0.35524425f, 0.03527854f, 0.00038386f, -0.10994678f, -0.00068259f, -0.07527778f, 
    0.14079213f, 0.09912066f, -0.13062015f, -0.19836560f, -0.01377445f, -0.11278294f, -0.00780661f, 0.00236481f, 
    0.04331535f, 0.05615507f, -0.02758628f, -0.09414081f, 0.21157666f, -0.04942383f, 0.24848603f, 0.26846659f, 
    -0.03799440f, -0.07412868f, 0.04162670f, -0.14013086f, 0.07592402f, 0.10206439f, 0.07636894f, -0.06826245f, 
    0.23584928f, 0.11886401f, 0.10801557f, -0.49266872f, -0.07193601f, -0.23877665f, -0.09852590f, -0.01989363f, 
    0.00473245f, -0.07957037f, 0.06164744f, 0.00692437f, -0.06066032f, 0.14579567f, -0.08972495f, -0.06205033f, 
    -0.14351901f, 0.01059006f, -0.12146451f, -0.09409992f, 0.05181451f, 0.07796329f, 0.04211658f, 0.00036269f, 
    -0.11301816f, 0.00821861f, 0.09389278f, -0.25436050f, -0.07937021f, -0.11594757f, 0.08384941f, 0.00354748f, 
    0.07747448f, -0.00141170f, 0.07572341f, 0.08168305f, -0.10138025f, -0.02676818f, 0.19670331f, 0.38750544f, 
    0.01481243f, 0.08284853f, -0.05453215f, -0.08874322f, 0.13659252f, 0.06608777f, 0.13932748f, 0.02720572f, 
    0.25564885f, -0.00069267f, 0.34554332f, 0.14271764f, 0.04203100f, -0.19775771f, -0.24962975f, -0.21913582f, 
    0.09466433f, -0.00720792f, 0.00943433f, 0.07968397f, -0.24061120f, 0.07067637f, 0.11331910f, 0.16599381f, 
    0.04136067f, 0.02661428f, -0.15947272f, -0.00250525f, -0.18323274f, -0.12617165f, 0.09101203f, 0.02200473f, 
    -0.28934911f, 0.02625317f, -0.49345616f, -0.03321088f, -0.12057178f, -0.17298257f, 0.14887488f, 0.13030082f, 
    -0.05816094f, 0.06797048f, -0.06055785f, -0.04302689f, -0.11124501f, 0.08508021f, -0.33010206f, -0.01460559f, 
    0.09497695f, -0.12461821f, 0.11858559f, 0.06173803f, 0.06014169f, 0.09593169f, 0.06951916f, 0.19073479f, 
    -0.27444655f, 0.03677970f, 0.05541696f, -0.44263297f, 0.02371835f, -0.17786439f, -0.16481876f, 0.16875996f, 
    0.04679824f, -0.04283378f, 0.04413988f, 0.08064888f, 0.01110579f, 0.14304397f, 0.06082537f, -0.41612935f, 
    -0.18353160f, -0.12407225f, 0.26028493f, -0.03995964f, 0.05686584f, 0.00359627f, -0.09581400f, 0.12144140f, 
    -0.24409665f, 0.39000842f, -0.48307338f, -0.09189817f, -0.01617782f, -0.02933869f, 0.06164026f, -0.15188076f, 
    0.05717520f, -0.06332720f, -0.09778310f, 0.01814772f, 0.04366525f, -0.07123992f, -0.14031026f, 0.13552186f, 
    -0.14596057f, 0.02636580f, -0.05968307f, 0.14892370f, 0.11108796f, -0.01769171f, 0.02833990f, 0.04907334f, 
    0.01603035f, 0.02572214f, 0.49015978f, 0.28580701f, 0.16773969f, -0.19256890f, -0.05772026f, -0.09504287f, 
    0.09586888f, -0.08221763f, -0.01263045f, 0.16485700f, 0.07424943f, 0.19141373f, 0.63414240f, -0.27261007f, 
    0.07934018f, -0.17307101f, -0.05032331f, -0.11660671f, -0.12444153f, 0.06129198f, 0.08128274f, -0.00030239f, 
    0.05362402f, -0.04687843f, -0.09191884f, -0.11763471f, -0.05036122f, 0.23580679f, -0.11559138f, -0.02085819f, 
    0.11344453f, -0.00447001f, -0.04614675f, -0.21598478f, 0.15154061f, 0.40762603f, -0.20354605f, -0.18046349f, 
    -0.10358684f, 0.01302822f, 0.20371902f, 0.07345352f, 0.03910232f, 0.07159951f, -0.09586555f, -0.09707414f, 
    -0.41831386f, -0.05680582f, 0.12785122f, -0.04790543f, -0.07293492f, -0.06081195f, 0.19385333f, 0.08460285f, 
    0.02110319f, 0.04026222f, 0.00305873f, -0.02594481f, -0.25979191f, -0.18002151f, 0.05423298f, -0.28029028f, 
    0.12443303f, -0.02495830f, -0.05359569f, 0.07770051f, 0.08792750f, 0.02282135f, 0.02487029f, 0.05797260f, 
    -0.08022308f, -0.38532579f, -0.08337758f, -0.20664302f, -0.13426878f, -0.01921936f, 0.04281302f, 0.06446524f, 
    0.02677978f, -0.16957177f, -0.10476643f, 0.04735222f, -0.08668018f, 0.17169940f, -0.15175015f, -0.09059307f, 
    0.13838415f, -0.04948977f, 0.10370614f, -0.12739167f, -0.03077229f, -0.01344217f, -0.10963639f, -0.02867014f, 
    0.03036435f, 0.04604280f, 0.11421813f, 0.04601734f, 0.06062089f, -0.12353642f, 0.05448226f, 0.02040758f, 
    -0.19535248f, -0.01686553f, -0.22507107f, -0.39769745f, -0.02225047f, -0.24264586f, 0.20806418f, 0.11253052f, 
    -0.09193549f, -0.01852602f, 0.16589203f, 0.11397983f, 0.04760592f, 0.11511708f, 0.08742565f, 0.08131926f, 
    0.13415278f, -0.04832142f, 0.36354420f, -0.05265722f, -0.12908261f, -0.06718303f, 0.09516373f, 0.18517824f, 
    -0.00023143f, 0.10994618f, 0.06013821f, 0.08417692f, -0.23090841f, -0.04478215f, -0.02929141f, -0.04371506f, 
    0.04538247f, 0.06865823f, 0.08640450f, -0.01681019f, -0.11614706f, -0.05200314f, 0.02629150f, -0.09709205f, 
    -0.33142471f, 0.08942661f, -0.05990660f, -0.07434686f, -0.00001394f, 0.08116588f, 0.14382456f, 0.05470080f, 
    0.11041240f, -0.02512243f, -0.01810483f, 0.06140086f, -0.07448908f, -0.20148122f, -0.16207196f, -0.13074158f, 
    -0.17721489f, -0.12003869f, -0.01643119f, -0.07109085f, -0.17519146f, -0.03601589f, -0.10777834f, -0.17306809f, 
    0.15034139f, -0.30244812f, 0.03013985f, -0.06212528f, -0.09726433f, -0.06588000f, -0.02159857f, -0.01876013f, 
    0.01320591f, 0.02115448f, -0.07864333f, -0.09196600f, -0.04520279f, -0.30843359f, 0.14127661f, 0.26794222f, 
    -0.10861983f, 0.08037981f, 0.02524772f, 0.13343024f, 0.08224211f, 0.03482828f, 0.12603371f, 0.20010582f, 
    -0.50340790f, 0.47833031f, 0.05533312f, 0.05719064f, -0.05074661f, 0.08604995f, -0.01156803f, 0.01830509f, 
    -0.09251550f, 0.05170862f, 0.01458697f, 0.14846008f, -0.25291064f, 0.15755831f, -0.23128860f, 0.16182411f, 
    0.01241506f, -0.01682607f, -0.02507609f, 0.04689888f, 0.06839845f, -0.09718096f, -0.23333496f, -0.20827363f, 
    -0.20792590f, 0.27590099f, -0.31599236f, 0.22229658f, 0.02333868f, 0.16556527f, -0.09246110f, -0.09326728f, 
    0.01760358f, 0.11124083f, -0.02846630f, -0.01371995f, -0.06686093f, 0.17292891f, 0.15208031f, 0.06017433f, 
    0.01823284f, -0.09578522f, -0.00615804f, -0.01557289f, 0.10849664f, -0.12820509f, -0.02138987f, -0.00684347f, 
    -0.43490520f, -0.12193233f, 0.19993784f, 0.16575950f, -0.03191447f, 0.19809015f, -0.27399030f, -0.05106153f, 
    0.02283057f, -0.10095912f, 0.04757522f, -0.08050340f, 0.13416232f, -0.19836424f, 0.25343862f, 0.21606070f, 
    -0.14306849f, 0.11249945f, 0.14527816f, -0.09391293f, -0.08522899f, 0.04883123f, 0.01932181f, 0.01539441f, 
    -0.12043002f, -0.16145617f, -0.00317261f, -0.12720022f, -0.00279134f, -0.09710471f, -0.07696739f, -0.02490186f, 
    -0.02757463f, -0.09385287f, -0.00522246f, -0.03393665f, -0.02953080f, -0.00692737f, -0.46023965f, -0.09242284f, 
    0.06827571f, -0.12903357f, -0.18234715f, -0.11823743f, -0.00333036f, -0.00198869f, -0.08061775f, 0.04163332f, 
    -0.15298226f, -0.13274556f, -0.21399507f, 0.19555242f, 0.03086535f, -0.08240210f, 0.04687766f, 0.00011758f, 
    0.11281602f, 0.02756646f, 0.04038672f, 0.05988193f, 0.01438526f, 0.30122095f, -0.03588820f, -0.14876178f, 
    0.02256820f, -0.01777983f, 0.00009372f, -0.08774760f, -0.20819181f, 0.02651670f, 0.01588186f, 0.07751673f, 
    0.00257924f, 0.26059330f, -0.19164598f, -0.11344987f, -0.19971302f, -0.15409112f, 0.06159237f, -0.00827844f, 
    -0.07239318f, 0.09524310f, 0.03365921f, 0.06951903f, -0.43176359f, 0.32807744f, 0.02491699f, 0.19182065f, 
    0.00358535f, -0.11425998f, -0.00481183f, 0.08962549f, -0.12937732f, 0.06915842f, 0.10027675f, -0.04776450f, 
    -0.07097985f, 0.01662302f, 0.06439338f, -0.05407991f, 0.04835451f, -0.02710155f, -0.06173896f, 0.02836536f, 
    -0.16905472f, -0.46905190f, -0.39969301f, -0.33640420f, -0.49121258f, 0.16270685f, -0.13976528f, -0.04731654f, 
    0.10881451f, -0.06267717f, 0.02632080f, 0.09155436f, -0.04972231f, -0.00414788f, -0.17510393f, -0.21974985f, 
    0.32156172f, -0.16335414f, 0.28799054f, -0.04089085f, -0.31490093f, 0.06925355f, 0.17046936f, 0.10864341f, 
    -0.05226477f, -0.10188630f, 0.12757798f, 0.11922085f, -0.11384627f, -0.16272834f, 0.04806533f, -0.04135879f, 
    0.02351981f, -0.08892032f, -0.16458820f, -0.05374039f, -0.27017605f, 0.06782334f, 0.00954143f, 0.00164874f, 
    0.00197508f, -0.32025030f, 0.03918985f, -0.15260005f, -0.03087932f, 0.06781039f, -0.06939380f, 0.22747470f, 
    -0.07496179f, 0.07452871f, 0.02347476f, -0.01000718f, -0.10043165f, 0.16060954f, -0.34493572f, -0.02588960f, 
    -0.07784708f, -0.10101255f, -0.06725923f, -0.07985374f, -0.05153927f, 0.03242252f, -0.14895400f, -0.05164556f, 
    -0.03650154f, 0.43785855f, -0.06904042f, 0.17225155f, -0.01932338f, 0.12659574f, 0.07744666f, -0.13322367f, 
    -0.05756225f, 0.17689215f, 0.12671255f, 0.21001576f, -0.11650834f, 0.01101063f, 0.07902190f, -0.06068204f, 
    -0.00246187f, -0.04255018f, -0.00840312f, -0.04593309f, -0.12075397f, -0.04426083f, 0.00684889f, 0.03250562f, 
    0.05466570f, -0.03207220f, -0.25010625f, -0.02487151f, -0.15774433f, -0.07768688f, 0.11511916f, -0.02189552f, 
    -0.09537630f, 0.05241536f, -0.10946681f, -0.06602862f, -0.23447242f, 0.29358089f, 0.27082008f, 0.37971157f, 
    -0.06298097f, 0.11965996f, -0.22037312f, -0.07769202f, -0.02310867f, 0.03994984f, 0.07139821f, 0.28557828f, 
    0.01128675f, -0.13675089f, 0.04764118f, 0.12120996f, 0.04325113f, 0.04985541f, 0.22524415f, -0.16018824f, 
    0.08918554f, 0.03220463f, 0.06534564f, -0.08327348f, -0.35959271f, 0.04439492f, -0.12425405f, 0.00176334f, 
    0.07475398f, 0.12265742f, 0.01653498f, -0.10957447f, -0.03344706f, 0.05980844f, -0.10319312f, -0.08304777f, 
    -0.06436206f, -0.19443986f, 0.06003790f, 0.16158277f, -0.02321808f, 0.10371581f, -0.05668225f, 0.02456650f, 
    -0.03579983f, 0.00041767f, 0.15993887f, 0.12719604f, 0.11665811f, 0.22874734f, 0.09423380f, -0.03933185f, 
    -0.09642436f, 0.03062638f, 0.01355165f, 0.03827518f, 0.15440759f, 0.09923465f, 0.17549413f, 0.15851913f, 
    -0.23981303f, 0.01492286f, 0.17963131f, 0.02665115f, 0.16577469f, 0.12704112f, -0.16090330f, 0.01530999f, 
    -0.14838156f, 0.04332524f, 0.02359102f, -0.00850396f, -0.10408943f, 0.08639877f, 0.23049088f, -0.03632794f, 
    -0.12588380f, 0.04851686f, 0.06665552f, -0.06594259f, 0.03127325f, 0.03677431f, -0.03430406f, -0.10332854f, 
    -0.17410737f, 0.04011085f, -0.25281429f, 0.01599201f, -0.02899172f, 0.11519162f, 0.06073283f, -0.06570240f, 
    -0.05126438f, 0.11673235f, -0.07156821f, 0.04191707f, -0.46079046f, 0.13714735f, -0.10601237f, -0.07062111f, 
    -0.08331050f, 0.10793632f, -0.08358157f, -0.01192612f, 0.08376319f, 0.04764704f, -0.02248268f, -0.03020285f, 
    -0.20254946f, -0.22400831f, -0.39687914f, -0.32219851f, -0.07174157f, -0.08371952f, -0.08559199f, 0.01339590f, 
    -0.00796104f, -0.19619559f, -0.02607124f, -0.06353736f, -0.13153557f, 0.05974322f, 0.19183566f, -0.05161282f, 
    0.00039985f, -0.08521007f, 0.12395197f, 0.17451921f, -0.10063666f, 0.06092602f, 0.13071837f, 0.04603449f, 
    -0.06519957f, -0.10841472f, 0.20206469f, -0.15501724f, -0.05938527f, 0.06572195f, -0.12105792f, 0.05752520f, 
    0.02853028f, -0.07643177f, 0.10162459f, -0.03182648f, -0.23166618f, 0.08997773f, -0.02654659f, 0.09383201f, 
    0.04025149f, 0.08696605f, -0.32541841f, 0.09142277f, -0.08283528f, 0.15970039f, 0.10573929f, 0.01256863f, 
    -0.02854936f, 0.03851084f, 0.18067831f, 0.10930650f, -0.02944931f, -0.12258624f, 0.15227735f, 0.04966749f, 
    -0.14856759f, -0.10626733f, 0.12754603f, -0.05762783f, -0.40603697f, 0.23710790f, -0.26805690f, -0.12549873f, 
    -0.01664023f, 0.10085526f, 0.09148561f, 0.10793284f, -0.22784701f, -0.22492391f, -0.17785016f, -0.30412015f, 
    0.20729424f, 0.09136961f, 0.25418720f, 0.08226756f, -0.10234047f, -0.06413224f, 0.10306249f, 0.14640822f, 
    0.03288981f, 0.12457608f, 0.02627295f, -0.02195716f, 0.02988204f, 0.05239031f, 0.13332945f, -0.18038933f, 
    -0.00806658f, 0.12977129f, 0.08576588f, 0.12321290f, -0.07420371f, 0.01843544f, -0.15968174f, 0.01694133f, 
    -0.18289825f, 0.13407241f, -0.16537198f, 0.03848000f, -0.00412240f, -0.09614121f, 0.11139584f, -0.04479257f, 
    0.00215944f, 0.01456698f, 0.01687364f, -0.00519954f, -0.03900360f, 0.41024944f, 0.04718236f, -0.22745474f, 
    -0.06444339f, 0.09089428f, -0.03500950f, 0.08240164f, -0.15211079f, -0.11028381f, -0.40526620f, -0.35563684f, 
    -0.05045673f, 0.04438342f, 0.00538058f, -0.15080872f, -0.04308390f, -0.11481090f, -0.02424549f, -0.01766407f, 
    -0.06545409f, 0.02312746f, -0.04737923f, -0.22356182f, -0.23818429f, 0.07848970f, 0.00985905f, 0.00458374f, 
    -0.03369764f, 0.07920901f, 0.03433343f, -0.05012136f, -0.01785271f, 0.08167297f, 0.09750576f, 0.05894941f, 
    0.09633569f, -0.27189448f, -0.12938125f, 0.32782856f, 0.01003721f, 0.02959891f, -0.05119539f, 0.05039163f, 
    -0.01976904f, 0.01693906f, -0.07486843f, 0.00840448f, -0.07627335f, 0.07879323f, -0.00117094f, -0.17275529f, 
    -0.03972401f, -0.03521965f, -0.16155326f, 0.05902552f, -0.25298321f, -0.12053613f, -0.16891116f, -0.12206665f, 
    -0.07546063f, 0.13352236f, 0.31929347f, 0.14026041f, 0.00944905f, -0.00906384f, -0.05833322f, 0.13192971f, 
    -0.03911562f, 0.05670135f, -0.02138684f, -0.09764112f, 0.21448693f, -0.02729817f, -0.04702409f, 0.39293823f, 
    -0.02339739f, -0.13761446f, 0.11454056f, -0.04207003f, -0.09418003f, -0.01251697f, -0.27168736f, -0.11865491f, 
    0.17904101f, -0.38713306f, 0.18561800f, 0.10203496f, -0.10571412f, 0.02595329f, -0.03336478f, 0.07028137f, 
    -0.13083018f, 0.04346079f, -0.13520060f, 0.08180645f, -0.29067302f, -0.08718147f, -0.16104694f, 0.14197065f, 
    0.07616411f, -0.03215540f, 0.03743693f, -0.00947390f, -0.06648532f, 0.04347428f, -0.11996090f, -0.17443702f, 
    -0.19531511f, 0.16417530f, -0.11483545f, -0.06061534f, -0.00891159f, -0.01756856f, 0.11182154f, -0.00585135f, 
    -0.12401691f, 0.05212912f, -0.14137664f, -0.11700319f, -0.24564964f, 0.01764022f, -0.09376964f, 0.42262074f, 
    -0.04729062f, -0.11008587f, -0.01532381f, 0.12353086f, -0.04678891f, -0.17167723f, -0.03162499f, 0.02923689f, 
    -0.06949943f, 0.25113979f, 0.00319252f, -0.01924658f, 0.00054240f, 0.14590071f, 0.18702514f, 0.14189063f, 
    -0.11304568f, 0.11565308f, 0.08435733f, 0.22320525f, -0.03500778f, -0.37003624f, 0.04064804f, 0.06480321f, 
    -0.01861419f, 0.02536550f, 0.09489033f, -0.04475813f, 0.03386386f, 0.01700801f, 0.02740304f, -0.02747979f, 
    -0.13721165f, -0.27772057f, -0.39420035f, 0.06888828f, -0.18320297f, 0.19864194f, 0.05601282f, -0.01125123f, 
    0.04727782f, 0.09011453f, 0.09813185f, 0.05601127f, -0.23906268f, 0.07785898f, 0.17947173f, -0.09383049f, 
    -0.03310506f, 0.08859899f, -0.10810331f, -0.09888683f, 0.01615499f, -0.10054499f, 0.03069756f, -0.06213993f, 
    0.06197924f, -0.11890304f, 0.21716824f, 0.09428733f, -0.20099249f, 0.15227123f, 0.17983459f, -0.08554938f, 
    0.05739885f, -0.02546139f, 0.02598056f, 0.14385176f, -0.05427592f, 0.04775881f, 0.02562852f, 0.12073946f, 
    0.07155303f, -0.07960314f, 0.12319195f, -0.03159949f, 0.06831913f, 0.12337221f, 0.02966888f, -0.13845085f, 
    0.16030861f, -0.08263551f, 0.01248846f, -0.05301591f, -0.00909061f, 0.18962148f, -0.17043194f, 0.06615729f, 
    0.00598146f, 0.11776575f, 0.09139516f, -0.02756106f, -0.26116994f, -0.24346165f, -0.10781489f, -0.03035326f, 
    -0.13821413f, -0.12867714f, -0.17980607f, -0.31304461f, -0.03886148f, 0.04205713f, -0.01298327f, 0.02582458f, 
    0.20265079f, 0.12885441f, 0.22941445f, 0.04011076f, -0.07047933f, 0.05633765f, -0.25245696f, -0.01316096f, 
    0.01359330f, -0.00208001f, 0.11924472f, -0.05322621f, 0.29673338f, -0.07410734f, 0.24189146f, 0.07695269f, 
    -0.00652792f, 0.00872542f, 0.05198743f, -0.04336664f, -0.10084421f, 0.09805372f, -0.03145853f, 0.02836124f, 
    0.19752689f, -0.13936187f, -0.06498125f, 0.09193597f, 0.18499903f, 0.01475836f, 0.15744142f, -0.17392556f, 
    -0.07136001f, 0.12555015f, 0.03759165f, -0.07513711f, 0.35197222f, 0.20127182f, 0.11244206f, -0.20460773f, 
    -0.08594181f, 0.06734120f, -0.08481577f, 0.01420581f, -0.00962292f, 0.01854975f, -0.00405824f, -0.04259368f, 
    -0.09460993f, 0.20592050f, -0.05309860f, -0.55313784f, -0.08052402f, -0.15944974f, 0.07800049f, -0.11298759f, 
    0.03171543f, 0.00742116f, 0.01059717f, -0.03689431f, 0.08140264f, 0.06747629f, 0.17483875f, -0.18953465f, 
    0.01031919f, 0.06550117f, -0.20559575f, 0.22027421f, -0.12719618f, -0.08365471f, -0.19972411f, -0.24949707f, 
    0.23869088f, -0.34298456f, 0.23838128f, 0.35342094f, 0.27629420f, -0.02409147f, 0.06346107f, 0.18237825f, 
    0.06231743f, -0.03506328f, 0.20360264f, 0.01625994f, -0.39728522f, 0.02505245f, 0.03088338f, 0.08711255f, 
    -0.01808360f, -0.07566281f, 0.05452158f, 0.13914180f, -0.02257306f, 0.05573508f, 0.13245809f, 0.07299278f, 
    -0.47911707f, -0.18606173f, -0.20806330f, 0.44535512f, -0.15724215f, 0.00986783f, 0.09775326f, -0.02849890f, 
    0.03443648f, -0.03836513f, 0.04369499f, 0.10045217f, -0.29556859f, -0.15002720f, -0.16499382f, 0.03791185f, 
    -0.05630973f, 0.01223169f, -0.08394780f, -0.02653973f, -0.16349202f, -0.09483031f, 0.09089204f, -0.03021187f, 
    0.19983763f, 0.34006673f, -0.36003849f, 0.27719510f, -0.03522702f, 0.18264045f, 0.11872057f, 0.17493567f, 
    0.03009281f, 0.06523909f, -0.07544628f, 0.01944350f, 0.38350749f, -0.33906472f, 0.48816803f, -0.27992269f, 
    -0.03177394f, -0.00541278f, -0.28759393f, 0.26516351f, -0.05537101f, 0.10850605f, -0.06849283f, -0.00159212f, 
    -0.22308238f, 0.03442927f, -0.15999128f, -0.07318917f, -0.01886360f, 0.02147197f, 0.08327099f, 0.01754118f, 
    -0.01154140f, 0.06803758f, 0.01392937f, 0.04355045f, 0.00107178f, -0.19953591f, -0.06297899f, 0.00265550f, 
    -0.22178632f, -0.23500761f, 0.19507740f, -0.06569719f, -0.02359989f, -0.02817788f, 0.04884833f, -0.07076673f, 
    -0.17123225f, -0.07492488f, 0.21191362f, -0.28047895f, -0.23527470f, -0.11400305f, -0.32687137f, -0.16646983f, 
    0.00996563f, -0.08602112f, -0.06699033f, -0.01102731f, -0.39916390f, 0.06556866f, -0.27374077f, 0.18460396f, 
    0.01887869f, -0.04952998f, -0.01437265f, 0.04463121f, -0.00830481f, -0.05237543f, -0.13569482f, 0.00987719f, 
    0.32733390f, 0.01648059f, 0.49041066f, 0.12980746f, 0.05700709f, 0.01226150f, -0.11003648f, -0.05318707f, 
    -0.23575757f, -0.00058783f, -0.00095417f, -0.00924179f, -0.39959842f, -0.13382238f, 0.12573710f, 0.50834626f, 
    0.09518518f, 0.19802780f, -0.05185159f, 0.18771021f, -0.08966967f, 0.01187563f, -0.09431419f, -0.13318051f, 
    -0.10878507f, -0.16872314f, -0.16992082f, -0.03715390f, -0.01329147f, 0.05017125f, -0.12959416f, 0.01908228f, 
    -0.10491852f, 0.02097775f, 0.12949938f, 0.05795338f, -0.10196848f, -0.49797881f, -0.11018957f, -0.11109250f, 
    0.04967248f, -0.10017746f, -0.19015439f, -0.07802662f, 0.03596525f, 0.10171561f, 0.07112755f, 0.06861740f, 
    -0.07024558f, -0.02976390f, 0.00550237f, -0.24560386f, 0.01418049f, 0.14328107f, 0.04715164f, 0.02666449f, 
    -0.08121489f, 0.10655864f, -0.02458097f, -0.21426767f, 0.09822670f, 0.06201313f, 0.18887904f, -0.00441065f, 
    -0.20734410f, 0.18770561f, 0.18387094f, -0.02977805f, -0.00078186f, 0.03705680f, -0.02441747f, -0.12283342f, 
    0.30836657f, 0.08499610f, 0.34605828f, -0.20766471f, -0.05371184f, 0.05606625f, -0.09770687f, 0.06289052f, 
    0.00064289f, 0.06546710f, -0.01716692f, 0.08243006f, 0.43234131f, -0.13794012f, 0.31023934f, -0.23437275f, 
    0.03112527f, -0.09790777f, 0.07026032f, 0.07060970f, -0.02491761f, 0.04768910f, 0.11155999f, 0.05626591f, 
    -0.17942728f, -0.09567429f, -0.01197989f, 0.21390128f, 0.14400961f, -0.11501878f, 0.05617708f, 0.09844361f, 
    -0.11885981f, -0.20862509f, -0.13791266f, -0.08579918f, -0.40662932f, -0.13662589f, -0.01403272f, 0.15382618f, 
    0.14046954f, 0.03408343f, 0.07644640f, -0.11540446f, -0.04277842f, -0.08643163f, 0.04631230f, 0.07988792f, 
    0.26961181f, 0.14064674f, 0.23522675f, 0.02080729f, -0.04059202f, 0.11062229f, 0.02025723f, 0.06991480f, 
    -0.13525271f, -0.08208907f, 0.07900665f, 0.05113126f, -0.17292228f, 0.27914542f, -0.09744493f, 0.09211924f, 
    0.08499409f, -0.15825306f, 0.13626400f, -0.03430167f, 0.01184688f, 0.03760256f, 0.05037297f, -0.19299927f, 
    0.19226190f, -0.18332760f, 0.20036362f, -0.07207178f, 0.13735542f, -0.08581454f, -0.02649682f, 0.12599075f, 
    -0.14537928f, -0.10159123f, -0.18820997f, -0.07068869f, -0.54978222f, 0.06196335f, -0.09613504f, 0.26971978f, 
    0.09521504f, -0.07505303f, 0.11480176f, -0.09759720f, 0.01212771f, -0.05238014f, 0.09299410f, 0.07634380f, 
    0.03393473f, 0.10942897f, 0.13509054f, -0.03726990f, -0.15868236f, 0.00369310f, -0.22693859f, 0.04560552f, 
    -0.12752718f, -0.03608832f, -0.16071968f, -0.05376555f, -0.21495678f, -0.00956223f, -0.19778623f, -0.09421232f, 
    0.02356474f, 0.00016465f, -0.02962719f, 0.01235885f, -0.21998848f, -0.11191338f, -0.06665424f, -0.06036208f, 
    0.18893605f, 0.05192311f, -0.06602906f, 0.23890477f, -0.03894442f, 0.03821123f, -0.05076509f, 0.13188982f, 
    -0.07711702f, 0.11462355f, -0.00875513f, 0.15816289f, 0.15263768f, 0.05914431f, 0.11742369f, -0.16517343f, 
    0.09358873f, -0.00881736f, 0.08220413f, 0.02653810f, 0.08913098f, 0.05630818f, -0.05594077f, -0.06279162f, 
    0.26111832f, -0.06948936f, 0.09743690f, 0.15397115f, -0.00157368f, -0.12071920f, 0.00616903f, -0.08495063f, 
    0.04475354f, 0.01071928f, 0.15148062f, -0.08483111f, -0.07907505f, 0.05723348f, -0.17273812f, 0.19123782f, 
    0.06858855f, -0.04119614f, 0.05310056f, -0.11351047f, 0.10148515f, 0.00267479f, -0.20782605f, 0.09552707f, 
    0.15628445f, 0.17882431f, 0.00611954f, -0.09845748f, -0.04335890f, 0.06690221f, -0.02453649f, 0.06710111f, 
    -0.02939232f, 0.05546429f, -0.01398826f, -0.05149384f, 0.16576909f, 0.01645966f, 0.14694698f, -0.06385761f, 
    -0.06737943f, 0.13932820f, -0.00442369f, 0.02185003f, -0.08604959f, -0.06434785f, 0.04108512f, -0.04219403f, 
    0.07234238f, -0.08197657f, 0.07035065f, -0.10779478f, 0.17925529f, -0.08289228f, 0.14980949f, 0.02165371f, 
    0.06642718f, 0.07931945f, 0.12873597f, -0.12134059f, -0.45237479f, 0.12916447f, -0.08611190f, 0.26147673f, 
    0.18941037f, -0.01142822f, 0.07145789f, 0.05504860f, -0.17624462f, -0.14357090f, -0.10420204f, 0.02203078f, 
    -0.10952787f, 0.06205766f, 0.13173886f, 0.13946328f, -0.07150985f, 0.12656994f, 0.08270290f, -0.08967578f, 
    -0.11749995f, -0.01565532f, 0.15343794f, -0.03287707f, 0.05861254f, 0.07337648f, -0.16820088f, 0.24468434f, 
    0.17919032f, -0.00855980f, 0.04629425f, 0.12578484f, 0.11291807f, 0.15135157f, 0.06678463f, -0.02234353f, 
    -0.26407048f, -0.01699473f, -0.13494390f, -0.31326073f, -0.08352610f, -0.09795003f, 0.00609849f, -0.04592921f, 
    -0.05767434f, 0.01531565f, -0.10442824f, -0.13391608f, 0.02900314f, -0.23502646f, 0.03119292f, -0.21302906f, 
    0.11234488f, -0.03524286f, 0.10591290f, -0.02053067f, 0.04375879f, -0.01382407f, 0.03844419f, 0.16976926f, 
    0.02591804f, 0.27163324f, -0.22871126f, -0.06454736f, -0.10473443f, -0.12653889f, 0.16770652f, -0.10228667f, 
    0.01131945f, 0.07751327f, -0.04010257f, -0.02794788f, -0.29735667f, -0.04490636f, -0.33851275f, -0.00142029f, 
    0.08780430f, 0.01629902f, -0.04745974f, -0.07225568f, 0.05379434f, 0.03828879f, 0.17679052f, 0.10456465f, 
    -0.26987970f, 0.13157587f, -0.15938389f, -0.25545824f, 0.14405282f, 0.03251935f, -0.02074746f, 0.04595397f, 
    -0.01953638f, -0.00751562f, 0.03474334f, -0.08143849f, -0.24563889f, -0.03006652f, -0.16174254f, 0.04220674f, 
    0.14477421f, -0.12958924f, 0.02806949f, -0.01294538f, -0.05906724f, -0.01910993f, 0.08995765f, 0.05605354f, 
    0.25865361f, -0.33133039f, 0.45063594f, 0.23037861f, -0.20797445f, 0.02537063f, -0.10779989f, 0.00312446f, 
    0.01189635f, 0.04331034f, -0.04024457f, 0.05007500f, 0.30593264f, -0.03216114f, 0.10871254f, 0.00285249f, 
    -0.03905301f, -0.06582090f, 0.09178881f, 0.24468911f, 0.03802164f, 0.05742155f, -0.00924231f, 0.03963157f, 
    0.11481039f, -0.35719135f, 0.01440958f, -0.14509894f, 0.04560786f, 0.05424543f, 0.01978444f, -0.03044322f, 
    0.07222349f, 0.00345442f, 0.05499104f, 0.01030845f, -0.23284876f, 0.02494216f, 0.38923931f, 0.07896288f, 
    -0.32033893f, -0.00716444f, 0.07846541f, 0.02748165f, -0.10905726f, -0.01649486f, 0.20650834f, 0.14523593f, 
    0.01304896f, -0.00215542f, 0.21280949f, -0.19744664f, -0.02767988f, 0.07176763f, -0.07070313f, -0.06204313f, 
    0.03598942f, -0.01126251f, 0.04916427f, 0.06564867f, 0.04550894f, 0.20288825f, 0.02006014f, -0.07215560f, 
    -0.07795663f, -0.00508316f, 0.03180140f, 0.15837477f, -0.01818511f, 0.01508990f, 0.08365110f, 0.05407719f, 
    -0.03636013f, -0.26354507f, -0.19328581f, -0.07656700f, 0.06282687f, 0.12350780f, -0.07519104f, -0.01360145f, 
    -0.05167523f, -0.03327940f, 0.10084424f, -0.05971636f, -0.34623170f, -0.44203973f, 0.23935947f, 0.10875282f, 
    -0.10434280f, -0.03571310f, 0.07031102f, -0.06336919f, -0.04499539f, 0.11828418f, -0.14836420f, -0.16829856f, 
    -0.43766961f, 0.24367473f, 0.00788631f, 0.15681554f, 0.04369425f, 0.03366548f, 0.13428691f, -0.22788657f, 
    0.04985421f, -0.06801778f, 0.02238112f, 0.08617324f, -0.08502869f, -0.10272612f, 0.12663007f, -0.09968884f, 
    -0.15301834f, 0.07809274f, -0.14697155f, -0.17466220f, 0.03956286f, 0.06646434f, 0.04098977f, -0.02802419f, 
    -0.22037147f, -0.46396193f, 0.04396135f, -0.04257540f, -0.24341495f, -0.10834496f, -0.27223918f, -0.04728521f, 
    -0.01330332f, 0.04217158f, 0.02951358f, -0.13858639f, -0.25081933f, 0.04794855f, -0.29453468f, 0.18456049f, 
    -0.03748336f, 0.05624636f, 0.10350031f, -0.04728648f, 0.08628185f, 0.07395628f, -0.11232530f, 0.09516407f, 
    0.20272672f, 0.29385921f, -0.08374239f, -0.08161794f, 0.07091520f, 0.06253938f, -0.08960980f, -0.13005991f, 
    0.01339208f, 0.08087751f, 0.03942407f, 0.01032540f, 0.09314418f, -0.05402339f, 0.19988993f, 0.05106506f, 
    0.07563474f, -0.01020067f, -0.23697844f, 0.02670887f, -0.06530531f, -0.00001912f, -0.16851419f, -0.06159015f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12525083f, 0.11932326f, 0.02582321f, -0.07599774f, -0.07381473f, 0.02118520f, 0.03347232f, -0.11214116f, 
    0.04372998f, 0.00896273f, 0.00539442f, -0.01234548f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
