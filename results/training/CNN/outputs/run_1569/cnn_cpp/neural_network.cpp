#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.98241758f, -1.01715088f, -0.69607168f, -0.20407537f, 0.09933386f, 0.77294523f, 0.30132142f, -0.26817828f, 
    -0.06057450f, -0.22986920f, 0.14780593f, -0.38695619f, 0.07760322f, 0.16317494f, 0.46575204f, -0.17185880f, 
    0.16847894f, -0.25257143f, -0.31761748f, 0.07083433f, -0.10833883f, -0.45035139f, -0.00248390f, 0.12322073f, 
    -0.00760723f, -0.75845969f, -0.64469475f, -0.38462675f, -0.42910126f, -0.05589635f, 0.14157690f, 0.25039077f, 
    0.12687567f, 0.35957760f, 0.08498350f, -0.68697256f, -0.40149420f, 0.07097900f, 0.33388358f, 0.03297925f, 
    0.00707684f, -0.03105552f, -0.31233308f, -0.53322452f, -0.54985607f, -0.01731662f, 0.22284415f, 0.34645671f, 
    0.14775358f, -0.24563079f, -1.04830754f, -0.61356026f, -0.65982777f, 0.17383340f, -0.43848068f, 0.48915440f, 
    0.08779813f, 0.16626957f, 0.26001102f, 0.75801450f, 0.15143253f, 0.25255674f, 0.08952634f, 0.19297341f, 
    -0.11664338f, -0.11683624f, -0.15394343f, -0.26914865f, -0.01771854f, -0.25611028f, -0.09118545f, -0.05054371f, 
    -0.14478682f, -0.11911768f, -0.22018795f, -0.38056415f, -0.70679134f, -0.52456653f, 0.11511348f, 0.04403540f, 
    0.43437117f, 0.50706798f, 0.02683256f, 0.37893179f, -0.12933977f, 0.35855061f, 0.32098618f, 0.18806826f, 
    0.16576099f, 0.03010520f, -0.09805922f, -0.05458729f, 0.03691032f, 0.08465394f, -0.15219919f, 0.09237666f, 
    0.12666427f, 0.12712589f, 0.19236751f, -0.04348661f, 0.79480100f, 0.42621571f, 0.23978561f, 0.02554356f, 
    -0.52966207f, 0.53081930f, 0.52444780f, 0.26695266f, -0.25971863f, -0.22927782f, -0.12732844f, -0.04704838f, 
    -0.06372726f, -0.32520765f, -0.53675693f, 0.09862827f, -0.33413929f, 0.04475076f, 0.03138907f, -0.22282963f, 
    -0.11922870f, 0.01014904f, -0.26971611f, 0.04729658f, 0.37764761f, -1.31798196f, 0.48258042f, 1.25551760f, 
    -0.99566942f, -0.73534691f, 0.15018252f, 0.17010902f, 0.08982661f, 0.28317919f, 0.07206464f, -0.07822452f, 
    -0.34144625f, 0.02494820f, -0.62056386f, 0.06283978f, 0.05934619f, 0.14645433f, -0.26152787f, -0.01653754f, 
    0.37446350f, 0.01735443f, -0.06934393f, 0.18640231f, -0.18153569f, -0.04986323f, 0.09223942f, -0.04856414f, 
    0.11696201f, 0.30993587f, -0.03411853f, -0.18769270f, -0.08324149f, 0.10031861f, -0.27225807f, 0.14700507f, 
    0.48011431f, 0.18219265f, -0.14705652f, -0.35115999f, 0.11451554f, 0.27761713f, 0.45911977f, 0.26717210f, 
    -0.14914292f, -0.73575193f, 0.21104600f, 0.23583776f, -0.40205863f, 0.29561877f, 0.10561569f, 0.66053408f, 
    0.70853794f, -0.01218400f, -0.01900602f, -0.55817878f, -0.80664331f, 0.11085518f, 0.32004237f, -0.02412929f, 
    0.07268916f, 0.46677235f, 0.31941825f, 0.06485614f, -0.27531829f, -0.41348475f, -0.18088818f, -0.20514537f, 
    0.16113490f, -0.11987275f, -0.20088351f, -0.03327345f, -0.04788468f, -0.01623574f, 0.01039545f, 0.30100501f, 
    -1.45387459f, 1.00330138f, -0.70871538f, -0.72615641f, 0.02584441f, -0.10131358f, 0.80469632f, 0.32875821f, 
    0.00579189f, 0.24519624f, 0.19223404f, 0.46078691f, -0.27108982f, 0.05264608f, 0.02119516f, 0.12318663f, 
    -0.47164220f, -0.43274516f, -0.20278990f, -0.55798006f, 0.34599972f, 0.13866815f, 0.28633624f, 0.11753245f, 
    0.07558710f, 0.38133690f, -0.23952959f, 0.21153849f, -0.06318168f, 0.06073998f, 0.36337665f, 0.26819289f, 
    0.06606609f, 0.27220204f, -0.10923461f, 0.05447860f, 0.26188147f, 0.05757005f, -0.34930709f, -0.03445457f, 
    -0.04751222f, -0.06177409f, -0.13538930f, -0.04196903f, -0.19626963f, -0.03753085f, 0.43680686f, -0.09335728f, 
    -0.36167240f, -0.24183817f, 0.62223262f, 0.24191853f, -1.07308555f, -0.42604473f, -0.88732332f, -0.41883045f, 
    -0.11273541f, -0.03534082f, 0.41209334f, 0.59048206f, 0.02233276f, 0.09921272f, 0.17825823f, 0.33524343f, 
    0.09628066f, -0.02979924f, -0.35400069f, 0.24975367f, 0.01862943f, 0.04043074f, -0.08331325f, -0.07459687f, 
    -0.17724366f, 0.07095801f, -0.44877875f, 0.93051064f, -1.03427279f, -0.21988088f, 0.25268862f, -0.28785121f, 
    0.23478216f, -0.12681143f, -0.26565838f, -0.18233895f, -0.08601291f, 0.51115143f, 0.13288338f, -0.20451337f, 
    -0.33684948f, -0.15205544f, 0.14898500f, -0.19037633f, -0.24351634f, -0.06117244f, -0.25875676f, -0.59532034f, 
    -0.09744958f, -0.41783947f, -0.37468567f, -0.34064436f, -1.37929177f, -0.76550496f, -0.62955052f, -0.47250879f, 
    -0.31104794f, 1.31565690f, 0.17215350f, -1.00615895f, -0.38414276f, 0.07371520f, -0.45836565f, -0.21480323f, 
    -0.41842753f, -0.26898560f, -0.36685529f, -0.07463799f, 0.13091797f, -0.07079113f, 0.30159402f, -0.31994146f, 
    0.10366882f, 0.07068005f, -0.17452343f, -0.04985594f, -0.09564338f, 0.38049248f, -0.57740891f, -0.53825784f, 
    -0.17758478f, 0.91001284f, -0.41576079f, -0.37483698f, -0.03805571f, -0.06128955f, 0.31079209f, 0.22420947f, 
    0.09003228f, 0.06530942f, -0.21502782f, -0.26650399f, -0.09926760f, 0.12243270f, -0.37638554f, 0.30848888f, 
    -0.23798607f, 0.32787997f, -0.10373359f, -0.02575994f, 0.35656461f, 0.18597427f, -0.69719428f, -0.37529317f, 
    -0.32221559f, -0.26264676f, 0.39965346f, -0.27508080f, -0.23500647f, -0.62109476f, -0.09553571f, 0.78709453f, 
    0.48827082f, 0.59052938f, 0.19206010f, 0.23623608f, -0.08116668f, 0.05819860f, 0.10623764f, -0.12253527f, 
    0.20254196f, -0.07908127f, 0.42190164f, -0.42931837f, 0.08820701f, -0.00380671f, -0.16918187f, 0.63744509f, 
    0.12541056f, -0.71114457f, -0.29141638f, 0.79287159f, -0.16599305f, -0.11595172f, -1.26624370f, -0.92534357f, 
    -0.82087040f, -0.13466658f, -0.36683699f, 0.10274716f, 0.51115739f, -0.06974929f, 0.12711708f, 0.18838869f, 
    -0.06792620f, 0.15780392f, -0.06873347f, -0.37305656f, -0.11928578f, 0.27718759f, 0.13976298f, -0.07604385f, 
    -0.97271955f, 0.41195089f, -0.42796388f, -0.33376849f, 0.52709019f, -0.38565823f, -0.03813590f, 0.75330853f, 
    0.21194370f, -0.37836149f, -0.36049777f, -0.57542259f, 0.01348097f, 0.21114701f, 0.31016055f, 0.44540054f, 
    -0.19701812f, -0.00357525f, -0.01341078f, 0.08417217f, -0.43633181f, -0.22310475f, -0.07866508f, -0.14219543f, 
    -0.41227219f, -0.51332182f, -0.49110398f, -0.63479108f, -0.11160115f, -0.31224141f, -0.22622322f, -0.11983173f, 
    0.21775189f, -0.13085672f, -0.10357200f, -0.10599249f, 0.33803409f, 0.20964779f, -0.42325756f, -0.33958918f, 
    0.29048526f, -0.16045605f, -0.21586832f, 0.57771713f, 0.65904295f, -0.16179885f, -0.27148944f, -0.24479309f, 
    -0.12414233f, -0.06563278f, -0.03337836f, -0.76649016f, -0.34046566f, -0.15915629f, -0.65324080f, -0.99198914f, 
    -0.60625780f, -0.56446773f, -0.87141621f, -0.67368525f, 0.92294741f, -0.01605964f, 0.57880360f, 0.45167896f, 
    0.40303332f, -0.02959604f, -0.44597998f, 0.01883867f, -0.25706157f, -0.62331933f, 0.02268917f, 0.16115172f, 
    0.14560492f, -0.10156170f, -0.07892873f, 0.53841221f, 0.10829020f, -0.73217076f, -1.11627734f, -0.60792625f, 
    0.05985610f, 0.04775571f, 0.34489015f, -0.08285383f, -0.21002415f, 0.28813976f, 0.60596114f, 0.75862420f, 
    -0.36439198f, -0.28788149f, 0.42281213f, -0.14910352f, -0.31190699f, -0.19492841f, -0.37928799f, -0.29688728f, 
    -0.34581047f, -0.12373678f, 0.57493615f, 0.52834141f, 1.05333853f, -0.51515609f, -0.60408920f, -0.69102848f, 
    -0.86295319f, 0.91043019f, 0.04521583f, 0.42891961f, 0.14605545f, 0.13494454f, 0.04767864f, 0.28666976f, 
    -0.08225735f, -0.15746747f, -0.03604389f, -0.37698713f, 0.06129057f, 0.47313604f, -0.34058687f, -0.12002281f, 
    0.01528884f, -0.10368042f, 0.10964413f, 0.21908417f, 0.04790222f, -0.70860308f, -0.30183128f, -1.05706441f, 
    -0.14054081f, 0.06351695f, -0.24064180f, -0.88993680f, -0.23805617f, -0.24616067f, -0.18966518f, -0.41322282f, 
    0.01933098f, 0.45573878f, -0.27353653f, -0.34398377f, 0.34036413f, -0.40001294f, -0.27356055f, 0.05061451f, 
    -0.15616472f, 0.16285607f, 0.27285692f, -0.34075394f, -0.39995256f, -0.12848760f, 0.75686616f, 0.60356063f, 
    0.03235209f, 0.18949869f, -0.32192236f, 0.18049794f, -0.01035719f, -0.09655961f, -0.07303814f, -0.10464191f, 
    -0.18971947f, -0.39455086f, -0.10745949f, 0.54257756f, -0.11970735f, 0.42003563f, -0.12885873f, 0.02882555f, 
    -0.15802802f, -0.33348110f, -0.26120752f, -0.07226639f, -0.30913097f, -0.29154900f, -0.40892422f, -0.01079459f, 
    -0.16868289f, -0.12569797f, -0.05745037f, 0.40412563f, 0.08250947f, -0.00086315f, 0.03695974f, 0.26993579f, 
    -0.45848575f, -0.21603099f, 0.49009970f, 0.02209679f, -0.05724118f, -0.06513969f, -0.25522459f, 0.47097367f, 
    0.07247325f, -0.25037077f, 0.11818299f, -0.16846091f, 0.22712228f, 0.30970559f, 0.17828633f, 0.08384117f, 
    -0.45555511f, -0.51848620f, -0.48673522f, -0.43539390f, -0.57466471f, -0.70226228f, -0.21593001f, -0.69949657f, 
    -0.48262358f, -0.10610318f, -0.14825340f, 0.16996214f, -0.02010164f, -0.24197137f, -0.30107206f, 0.00608759f, 
    0.23079190f, 0.15672152f, -0.05256625f, 0.20201123f, 0.26002395f, 0.20940974f, -0.03142174f, 0.43795577f, 
    0.10158195f, 0.29916069f, 0.83456141f, 0.32005659f, -0.31387830f, -0.23729813f, -0.19314134f, -0.71678483f, 
    0.12706132f, 0.66815364f, -0.20351729f, -0.45629147f, -0.01761976f, -0.26879856f, -0.09911545f, -0.35989809f, 
    0.13694443f, 0.11776543f, -0.21985132f, 0.09019449f, 0.11808465f, -0.31093261f, 0.06257674f, -0.01598113f, 
    0.18027291f, -0.35704273f, 0.06820270f, 0.36522192f, -0.15729286f, -0.83289891f, -0.09662210f, -0.00521201f, 
    0.10140248f, -0.08415913f, 0.08050498f, 0.40069610f, -0.03730007f, -0.26467946f, 0.37165731f, -0.21075565f, 
    0.03299841f, -0.18881682f, -0.34345874f, -0.22663270f, 0.13676909f, 0.50721294f, -0.30899832f, 0.54351896f, 
    -0.13304803f, -0.22597727f, 0.35957262f, -0.80210376f, 0.59895545f, 0.95194471f, 0.83238065f, 0.39719659f, 
    -0.21307907f, -0.61176920f, -0.23716693f, -0.51953417f, -0.16713259f, -0.11573897f, -0.45810521f, 0.08457973f, 
    0.18165837f, 0.20324790f, -0.17145945f, 0.14045517f, 0.05427184f, -0.15978001f, 0.55578715f, -0.05233353f, 
    -0.17129937f, -0.07033032f, 0.20669121f, -0.25436535f, -0.83168948f, -0.33881250f, -0.54407322f, 0.24858665f, 
    0.12291808f, 0.03721545f, 0.55920017f, -0.23580241f, -0.01456767f, 0.38054153f, -0.08502258f, -0.27877304f, 
    -0.33571681f, -0.16242231f, -0.35729530f, -0.10078110f, 0.03080622f, -0.01961431f, -0.17068437f, -0.52841336f, 
    -0.54598391f, -0.10845456f, -0.66166556f, -0.59296304f, -0.70590955f, 1.56170917f, -0.96583164f, -0.98490602f, 
    -0.10091569f, -0.62843847f, 0.29519001f, 0.26583451f, 0.27087322f, 0.31145802f, -0.14119102f, -0.22759043f, 
    0.14366525f, -0.30179685f, -0.04479242f, 0.28608283f, 0.12201244f, 0.00544074f, 0.06639647f, -0.04663519f, 
    -0.10575671f, 0.14028867f, -0.20103084f, -0.03469065f, -0.28092867f, 0.30981949f, -0.78472233f, -0.56840253f, 
    0.09351139f, -0.32492906f, -0.37939003f, -0.15332188f, -0.49218065f, -0.58056200f, -0.75507641f, -0.61138338f, 
    -0.09145610f, -0.42617342f, -0.44057715f, -0.42559135f, -0.04894255f, -0.17162734f, -0.08080442f, -0.44798172f, 
    -0.13741934f, -0.53319246f, -0.02237104f, -0.19639343f, 0.23784870f, -0.17099379f, 0.50740671f, -0.41540635f, 
    -0.14261980f, 0.27944610f, 0.37685683f, 0.04056024f, 0.30537859f, 0.26410630f, -0.47946548f, -0.19242205f, 
    0.73421532f, 0.38813373f, 0.31908077f, -0.26876014f, -0.59338576f, 0.22208828f, 0.17369446f, -0.25654578f, 
    -0.02013881f, -0.17395732f, 0.04432197f, 0.07520848f, 0.17840543f, -0.31147227f, 0.00979888f, 0.30551797f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.57914537f, -0.24322477f, 0.06627320f, -0.05138053f, 0.35107088f, 0.31418589f, 0.15654561f, 0.57661831f, 
    0.40884069f, 0.66604352f, 0.27361232f, 0.21864100f, -0.49005413f, 0.24616976f, 0.12292442f, 0.30162507f, 
    0.16768765f, -0.04151068f, 0.09381276f, 0.75962305f, 0.36164722f, 0.15634899f, 0.11793908f, 0.38709101f, 
    -0.11301521f, 0.46376276f, 0.30489868f, 0.42666808f, -0.09593541f, 0.47612840f, -0.17798586f, 0.32626966f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.44324210f, -0.04490238f, -0.30269635f, -0.21741484f, 0.00821702f, 0.11954293f, -0.00788879f, -0.20528775f, 
    -0.14188732f, -0.08481570f, 0.01386312f, 0.04362702f, 0.19363578f, -0.00159036f, -0.02755006f, -0.03147875f, 
    0.07048506f, 0.15256734f, -0.00507075f, -0.35100645f, -0.19272879f, -0.01503037f, -0.11310693f, 0.16834384f, 
    0.14412533f, 0.11319111f, 0.08214096f, -0.06686186f, 0.11351018f, 0.12525378f, 0.08855677f, 0.00671932f, 
    0.13977525f, 0.09519313f, -0.03518045f, 0.07149463f, 0.12813756f, 0.16814643f, -0.04908775f, 0.07778108f, 
    0.07556911f, 0.06898467f, 0.02530921f, 0.04854639f, -0.18386760f, -0.04642054f, -0.08257127f, 0.08242392f, 
    -0.52911597f, -0.31404066f, -0.86755639f, 0.34901330f, 0.04231340f, 0.03966052f, 0.04969636f, 0.01126885f, 
    -0.02199174f, -0.05112227f, 0.02366976f, 0.03884584f, -0.25915855f, 0.12470716f, 0.08874854f, -0.48554751f, 
    -0.12005408f, 0.31625682f, 0.01095530f, 0.20579678f, 0.04426896f, -0.03710813f, 0.00911849f, -0.22227196f, 
    -0.09195879f, -0.04613499f, -0.02022170f, -0.04903099f, -0.31288287f, -0.08703975f, -0.13311696f, -0.02219321f, 
    -0.07271181f, -0.18295522f, 0.07419693f, 0.02389009f, -0.31939742f, -0.53434473f, -0.20627373f, 0.02997384f, 
    -0.04895331f, 0.06978060f, -0.04461341f, -0.02457665f, -0.09494668f, -0.08544756f, -0.03409299f, 0.02868725f, 
    -0.15834983f, -0.09693556f, -0.04229959f, -0.00214209f, 0.07636234f, 0.18928596f, -0.04898341f, -0.09471442f, 
    -0.23922487f, -0.23000626f, -0.26617223f, -0.00244277f, -0.36460078f, -0.28944030f, -0.20160843f, 0.07151767f, 
    0.00743473f, 0.00165205f, 0.00045547f, 0.01810109f, -0.31753042f, -0.01518621f, 0.01404830f, 0.05376955f, 
    -0.05993435f, -0.11395414f, 0.02160198f, 0.13526645f, 0.02015965f, -0.04215831f, -0.04241007f, -0.25303495f, 
    -0.03576909f, -0.19109108f, -0.07019632f, 0.16374101f, 0.07742623f, -0.05753072f, -0.21332663f, 0.00072506f, 
    -0.06252681f, -0.23455907f, 0.00188860f, -0.10700978f, -0.24911630f, 0.16898057f, 0.03551279f, 0.08284333f, 
    0.48906195f, 0.36720029f, -0.18952176f, -0.20186494f, 0.11076082f, 0.16671295f, 0.21107568f, 0.11172068f, 
    0.02419879f, -0.02781929f, -0.10636909f, 0.01145161f, -0.04007350f, 0.49678424f, -0.14822969f, -0.21133542f, 
    0.02738756f, -0.07266706f, -0.33196133f, -0.22827291f, -0.10648099f, -0.15630209f, 0.03530362f, 0.00314338f, 
    0.21021330f, 0.29735297f, 0.14150913f, -0.07405031f, -0.09371020f, 0.02317292f, -0.01149093f, 0.15153340f, 
    0.18761255f, 0.03486833f, -0.00869194f, 0.02737236f, 0.30675945f, 0.06138381f, -0.12465935f, -0.22058940f, 
    0.15350895f, -0.22081414f, -0.09761952f, -0.02830107f, -0.01267179f, 0.02830056f, -0.04003318f, 0.00261340f, 
    -0.08864728f, -0.13277879f, 0.28695202f, 0.05917922f, -0.10090929f, 0.06987882f, -0.12203299f, -0.03766094f, 
    -0.08862010f, -0.04540902f, 0.09018254f, 0.01226036f, 0.35018837f, 0.27185199f, 0.04468786f, -0.04166822f, 
    0.25001565f, 0.10959462f, 0.18745874f, -0.13103910f, -0.04368468f, -0.04798348f, 0.11032273f, 0.06950506f, 
    0.39194679f, 0.30175209f, -0.16301642f, -0.39283150f, -0.01349445f, -0.08090639f, 0.04620350f, -0.02585669f, 
    -0.02358544f, 0.05131996f, -0.06213634f, 0.06464145f, 0.26343316f, -0.06934802f, -0.15151770f, -0.11358077f, 
    -0.02410603f, -0.18364562f, -0.12966758f, -0.07578526f, -0.18312103f, -0.13566810f, -0.14135312f, 0.06136165f, 
    0.11314195f, -0.69450408f, -0.57641590f, 0.11320451f, 0.10624957f, 0.12540901f, -0.35337260f, -0.11082674f, 
    0.07358170f, -0.01416080f, -0.18412113f, 0.04404423f, 0.37356541f, 0.31803250f, -0.01361266f, -0.08676138f, 
    0.17932527f, 0.12432421f, 0.08814348f, 0.02368383f, -0.08260838f, -0.09694922f, -0.06660044f, 0.05772579f, 
    -0.37839806f, -0.39666343f, 0.12099227f, 0.02197650f, -0.03361133f, 0.00805881f, -0.04257262f, 0.04707528f, 
    -0.12775104f, 0.09195150f, 0.02714524f, 0.06892911f, 0.03090768f, 0.02859043f, 0.01596743f, 0.00414598f, 
    -0.12590276f, -0.03962039f, -0.07349580f, -0.03263086f, -0.15804179f, -0.15429239f, -0.01497092f, -0.20540294f, 
    0.35701856f, 0.31396917f, -0.08516404f, -0.21719360f, 0.15006316f, 0.11703825f, 0.09501869f, 0.01109498f, 
    -0.00747134f, -0.04909727f, 0.04012908f, 0.04777714f, -0.95010078f, 0.20807537f, -0.10839382f, 0.06878645f, 
    0.01673138f, -0.00145635f, 0.05402140f, 0.09983576f, 0.02938662f, -0.10261237f, -0.04014839f, 0.04258749f, 
    -0.18882187f, 0.10591082f, -0.05817650f, -0.02603890f, -0.12565948f, 0.02199996f, -0.07338377f, -0.01189720f, 
    0.06201334f, -0.23698936f, -0.09444427f, -0.02952063f, -0.23099853f, -0.05468684f, 0.09303665f, -0.27002162f, 
    -0.04308043f, -0.30307087f, -0.11639159f, -0.12637088f, 0.00700117f, -0.02350663f, 0.04008545f, 0.00473006f, 
    0.27306113f, 0.19308871f, -0.09619397f, -0.05990558f, 0.00055607f, 0.00079292f, 0.02563054f, 0.00314351f, 
    0.00984976f, 0.08011261f, 0.06255966f, 0.13854592f, -0.14524321f, -0.26610136f, -0.42449504f, -0.00325152f, 
    -0.04594872f, -0.13691710f, 0.12745866f, 0.05532656f, -0.12416453f, -0.00043851f, -0.13769674f, -0.03819443f, 
    0.40035102f, 0.26475444f, -0.23622006f, -0.30806732f, 0.10831460f, 0.01797604f, 0.05776727f, 0.05285955f, 
    -0.04378793f, -0.13477342f, -0.04466455f, -0.14325327f, -0.08021627f, -0.06587339f, -0.02094793f, -0.21056871f, 
    -0.05774614f, 0.00690346f, 0.08148464f, -0.02255249f, -0.13030392f, -0.01061941f, -0.15742415f, -0.17425302f, 
    0.06180186f, -0.17666803f, 0.10164849f, -0.05029532f, 0.11909636f, 0.04723816f, 0.21276014f, -0.37001184f, 
    0.31182939f, 0.01236286f, 0.09529367f, -0.16492820f, -0.19622140f, 0.15868017f, 0.32562995f, -0.01418248f, 
    0.02166796f, -0.09952691f, 0.07532482f, 0.21036239f, 0.02829282f, 0.03492995f, -0.04665428f, -0.44146201f, 
    -0.04721853f, 0.00385937f, -0.30437344f, -0.05827723f, -0.08178233f, -0.03229899f, 0.01018803f, -0.08802029f, 
    -0.12221686f, -0.15600704f, -0.02774070f, -0.05819822f, 0.03618390f, -0.10234959f, -0.08332667f, -0.04900273f, 
    0.00475721f, -0.02043278f, 0.00489488f, 0.06175903f, -0.08988508f, -0.01936010f, -0.01047095f, 0.05606331f, 
    0.86049384f, 0.16561006f, 0.48430514f, 0.13949879f, -0.07717022f, 0.00826754f, 0.01209664f, -0.00235363f, 
    -0.04318605f, 0.01955106f, 0.08108752f, 0.13803503f, -0.07214189f, 0.11321764f, -0.08275307f, -0.54458946f, 
    -0.04224794f, 0.06798726f, -0.17767763f, -0.08968800f, -0.06341228f, 0.02035225f, -0.14182764f, -0.09597289f, 
    -0.13189794f, 0.03790383f, 0.06031520f, -0.01198084f, 0.05308745f, 0.04542150f, 0.06695922f, 0.14960183f, 
    -0.07434542f, -0.15924630f, -0.04621572f, 0.05185580f, 0.18814440f, -0.03083334f, 0.61619872f, -0.33758163f, 
    -0.00718023f, 0.11477136f, -0.05766440f, 0.03262540f, -0.01592535f, -0.04013900f, -0.07160851f, 0.23159540f, 
    -0.59767622f, -0.60033560f, 0.05169747f, -0.30972981f, -0.04045442f, 0.07644365f, -0.08040328f, 0.09886748f, 
    0.06369764f, -0.00921432f, 0.00975807f, 0.02145912f, 0.25841093f, 0.09366898f, 0.08010484f, 0.15797760f, 
    0.01012141f, -0.02199084f, -0.07625999f, 0.04712291f, -0.14445069f, 0.12847757f, -0.17801772f, -0.03908101f, 
    -0.16159651f, -0.14292665f, 0.06207221f, -0.07305337f, 0.10351156f, 0.02326950f, -0.14075872f, 0.03428641f, 
    0.23852810f, -0.11391261f, -0.02588880f, 0.04500708f, 0.10156411f, -0.01888829f, -0.15807289f, -0.05961556f, 
    0.01664894f, 0.02523341f, -0.08307435f, -0.02200893f, -0.00982780f, -0.41911942f, 0.05879387f, 0.01351999f, 
    0.60966164f, 0.30679157f, 0.31217134f, 0.21710528f, 0.16136487f, -0.06311470f, -0.16648141f, 0.19229482f, 
    -0.00423364f, -0.09852387f, -0.04292472f, -0.06675641f, -0.17456800f, 0.15859501f, -0.44590870f, 0.16174033f, 
    0.10741210f, 0.04175477f, -0.03616096f, -0.02600018f, 0.00871649f, -0.14245163f, -0.00348679f, 0.12898606f, 
    -0.30310997f, -0.08382055f, -0.03049425f, 0.04847557f, -0.01567782f, 0.13338877f, -0.07365800f, 0.04490488f, 
    0.09360321f, -0.09782843f, -0.13542129f, 0.07197474f, 0.11440079f, -0.08825430f, -0.21746266f, -0.09161443f, 
    -0.17377600f, -0.28189164f, 0.19552654f, -0.02651353f, 0.00648501f, 0.02664171f, 0.07013781f, -0.02655873f, 
    -0.55242968f, -0.25530320f, 0.03323830f, -0.01531614f, 0.20584722f, 0.02349469f, -0.04196674f, 0.00867183f, 
    -0.18153466f, 0.23755956f, -0.06514720f, -0.32198632f, -0.03487736f, 0.12316870f, -0.17621352f, 0.13550197f, 
    -0.31769291f, 0.04425060f, -0.08069836f, -0.44033617f, 0.04097516f, -0.10446352f, -0.07538132f, -0.05214512f, 
    -0.40442875f, -0.04092009f, 0.00994835f, -0.19673243f, -0.09056839f, 0.02521852f, -0.05259826f, 0.16717772f, 
    -0.07248379f, 0.00131758f, 0.08027729f, 0.03875981f, 0.12015019f, -0.54540545f, -0.26307473f, -0.18628564f, 
    0.06806508f, 0.18665436f, 0.20852451f, -0.05986306f, 0.19752966f, 0.03618301f, -0.04545560f, 0.08763129f, 
    0.85472947f, -0.00970742f, -0.02209271f, -0.37604216f, -0.04358286f, 0.01566290f, 0.05780960f, 0.18450256f, 
    0.07121406f, 0.19643258f, -0.03959486f, -0.15516549f, -0.22425014f, 0.01828109f, -0.17971639f, 0.35024750f, 
    -0.22204050f, 0.01963583f, -0.19719385f, -0.41837227f, -0.04272940f, 0.00739380f, 0.05019662f, -0.03053723f, 
    0.21577464f, 0.05873759f, 0.00186089f, 0.06624475f, 0.02170219f, 0.01120883f, -0.02737777f, -0.00348023f, 
    0.02421192f, 0.20446943f, -0.22627364f, 0.01327803f, -0.00186057f, -0.07481534f, -0.04612499f, 0.13008316f, 
    0.21289788f, 0.00945272f, 0.10319290f, 0.02624078f, -0.09599306f, 0.03860294f, -0.08738349f, 0.02140214f, 
    0.18670239f, 0.11855623f, 0.10027852f, 0.09841911f, -0.10211078f, 0.05309479f, -0.21781595f, -0.13016567f, 
    -0.03550263f, -0.05096018f, -0.06943893f, 0.03281390f, 0.03702055f, 0.17446634f, 0.29974252f, 0.00004229f, 
    -0.02331702f, -0.09054131f, 0.02677427f, 0.01539925f, -0.02432224f, -0.03275873f, 0.05313785f, 0.01298336f, 
    0.25243762f, -0.15030330f, -0.04343946f, 0.07457624f, 0.09991685f, 0.05888681f, -0.11615109f, 0.14199212f, 
    -0.07413074f, 0.19310910f, -0.06603601f, -0.17784289f, -0.08927776f, 0.17770667f, -0.31537938f, -0.23988301f, 
    -0.06496590f, -0.09735866f, 0.03465786f, 0.04701522f, -0.04571062f, 0.01967784f, 0.06848737f, 0.03321905f, 
    0.14589465f, 0.01700718f, -0.00079570f, -0.02139036f, 0.03317242f, 0.14270259f, -0.04442532f, -0.06259275f, 
    -0.30456018f, -0.28395942f, -0.44501662f, -0.22496061f, 1.01394451f, 0.05695167f, -0.42627850f, 0.03993018f, 
    -0.05097485f, 0.06247915f, -0.20926675f, -0.41453171f, 0.14035644f, -0.18632729f, -0.02856530f, -0.03496839f, 
    0.11366439f, 0.16564509f, 0.21204859f, -0.07796595f, 0.12036271f, 0.04321555f, -0.00881736f, 0.11546312f, 
    0.06990033f, 0.07690857f, 0.01322232f, -0.04899535f, 0.11002740f, 0.07299143f, 0.05662550f, 0.22705269f, 
    -0.10207637f, 0.07098673f, 0.02085628f, 0.04111174f, 0.08901776f, 0.03713436f, 0.02348224f, 0.14505067f, 
    0.14352466f, -0.07487118f, 0.62803596f, 0.30662876f, -0.08674880f, -0.05286793f, 0.11218458f, 0.23869477f, 
    -0.08033687f, 0.10855348f, 0.00954057f, -0.04853149f, -0.17536238f, 0.12750629f, 0.60752881f, 0.37541494f, 
    -0.01198585f, 0.10729863f, 0.04178936f, -0.12194837f, 0.04452492f, -0.19020733f, -0.02923079f, -0.10553417f, 
    0.17422895f, 0.07321632f, 0.29438442f, 0.33394837f, -0.03773952f, -0.04720211f, 0.05428870f, 0.04805981f, 
    -0.07344409f, -0.09129983f, 0.13427150f, 0.04161217f, -0.03553173f, -0.05847464f, 0.06572267f, 0.08974186f, 
    -0.00418064f, -0.08849367f, 0.02796715f, 0.13478097f, 0.01596980f, -0.12065217f, 0.03206820f, 0.00987298f, 
    -0.25181675f, -0.25394118f, -0.12555681f, -0.75561810f, -0.02552370f, 0.00585506f, -0.03291637f, 0.02939542f, 
    0.00333561f, -0.05854931f, 0.03305114f, -0.19256997f, 0.59509397f, 0.35304558f, 0.07717471f, 0.27261958f, 
    0.07519283f, -0.07792450f, -0.06569598f, 0.19253993f, -0.05931561f, 0.07683481f, -0.10200835f, 0.07884836f, 
    -0.21223718f, -0.14852105f, -0.07055011f, 0.11341894f, 0.00209655f, 0.00595654f, -0.18999651f, 0.02929992f, 
    0.16391636f, -0.14780255f, 0.20806792f, -0.05400364f, -0.40413067f, -0.14146093f, -0.13482958f, -0.32805389f, 
    0.10595658f, 0.04845962f, -0.05363714f, 0.00468978f, 0.08351795f, -0.04607788f, 0.05324493f, -0.02625145f, 
    0.37074897f, 0.04005476f, 0.29455858f, 0.03324814f, 0.01185170f, 0.05832485f, 0.06479362f, -0.12040135f, 
    -0.12899373f, -0.22677264f, -0.27216116f, 0.10800228f, 0.03823824f, -0.03873951f, -0.18031533f, 0.01693143f, 
    -0.04441912f, -0.06398635f, 0.03071574f, 0.04200740f, 0.12822816f, 0.03779945f, -0.02597876f, 0.09333976f, 
    -0.11074375f, 0.28712916f, 0.03236441f, 0.20603871f, -0.04371970f, 0.05840708f, 0.04492974f, -0.20160562f, 
    -0.05160020f, 0.19380651f, 0.05074079f, -0.00026049f, -0.06167353f, 0.06068984f, -0.04501886f, -0.10185359f, 
    -0.03152127f, -0.04275778f, -0.09136964f, -0.09125043f, 0.12273224f, 0.09354294f, -0.01083940f, 0.16976659f, 
    -0.53294921f, -0.63439554f, 0.76421130f, 0.39603662f, -0.07352243f, -0.18625389f, -0.16152650f, 0.16389991f, 
    0.00856632f, -0.03663899f, -0.06418962f, -0.01399313f, 0.02081177f, -0.16478227f, -0.13399696f, 0.18814753f, 
    -0.06360698f, 0.10280570f, -0.01141453f, -0.07014292f, 0.02830914f, -0.09656569f, 0.03618866f, -0.15334681f, 
    0.20952310f, -0.05507236f, -0.13799159f, 0.17643954f, 0.14244586f, -0.07737266f, -0.31262299f, 0.06049239f, 
    0.12833081f, 0.06743161f, -0.00559655f, 0.03393840f, -0.49284315f, -0.30430585f, 0.14994717f, -0.22789223f, 
    -0.15733324f, -0.00118726f, 0.05400217f, -0.10412199f, 0.03605817f, -0.05957268f, -0.01074798f, -0.00083873f, 
    0.06397938f, -0.07029860f, -0.32451457f, 0.06913296f, 0.01269065f, -0.07527865f, 0.12432612f, -0.08402238f, 
    -0.05004435f, 0.06882688f, 0.03233951f, -0.03935466f, -0.08343894f, 0.24278107f, 0.07105748f, 0.29377940f, 
    0.21164767f, 0.15877649f, 0.12444330f, 0.12958035f, -0.00289413f, 0.00407851f, 0.04605934f, -0.03220824f, 
    -0.70291299f, -0.64243507f, -0.22678335f, -0.39303330f, 0.01893756f, 0.02459040f, -0.13266864f, -0.26571158f, 
    0.02567071f, -0.00284621f, -0.00333559f, 0.00485210f, 0.14880309f, 0.06578889f, -0.19799457f, -0.32481503f, 
    -0.03764782f, 0.05146531f, 0.07407778f, -0.20088163f, 0.05665016f, 0.17651969f, -0.01696722f, 0.03512652f, 
    -0.45028374f, 0.66150653f, 0.36109814f, -0.04849466f, -0.03959185f, 0.04873966f, -0.01188937f, -0.27766508f, 
    0.02460438f, -0.03334124f, -0.12954965f, -0.09377579f, -0.00159246f, -0.21991117f, -0.20466182f, 0.25958440f, 
    0.15551215f, 0.04059818f, 0.01717340f, -0.04608583f, 0.04770597f, -0.00290569f, 0.11886092f, 0.00948475f, 
    -0.22247995f, -0.13162109f, -0.04245865f, -0.17336954f, 0.00146931f, -0.03345060f, -0.09282950f, -0.08291551f, 
    -0.02034691f, -0.16915356f, 0.10904757f, 0.11201683f, 0.01023112f, -0.00255390f, -0.04154321f, 0.03161329f, 
    -0.35004532f, 0.02005205f, 0.09749180f, -0.08194754f, -0.00156117f, -0.04521427f, -0.11825506f, -0.06335887f, 
    -0.35449699f, -0.15432212f, -0.05874055f, -0.35692266f, -0.12271293f, -0.07948693f, 0.14132862f, 0.07251695f, 
    -0.05224602f, -0.06959710f, -0.07172909f, -0.00931458f, -0.24325852f, -0.05910796f, 0.09637894f, -0.15259051f, 
    0.01688731f, 0.02610954f, -0.02344749f, 0.04037903f, 0.01128172f, -0.00777987f, -0.03250727f, 0.10938789f, 
    0.10312286f, 0.02480464f, 0.02867620f, 0.14566883f, 0.13197961f, 0.09143713f, -0.21275750f, 0.10580373f, 
    0.02202927f, 0.11398007f, -0.00720513f, -0.12701960f, -0.08359183f, 0.29401657f, -0.30434069f, -0.17019528f, 
    0.04023035f, -0.15529333f, 0.01373334f, 0.17252405f, -0.06298382f, 0.04459206f, 0.03680059f, 0.02713961f, 
    -0.02956408f, -0.06007192f, 0.19368687f, 0.05821278f, -0.05794149f, -0.05219733f, 0.01775016f, -0.00194276f, 
    0.07764401f, -0.01623742f, -0.02062125f, 0.05677659f, -0.50017625f, 0.70526469f, 0.30141360f, -0.10131095f, 
    -0.08418284f, 0.13598332f, -0.20804355f, -0.23011947f, 0.12071182f, 0.08315664f, -0.09011591f, 0.07781140f, 
    -0.47078967f, -0.24138929f, -0.08570722f, -0.37153566f, -0.19527636f, 0.16648076f, -0.03030826f, -0.09698082f, 
    -0.06418845f, -0.03461758f, -0.04351931f, 0.00232964f, -0.02505486f, -0.21746947f, -0.03621735f, -0.01634288f, 
    0.08491506f, 0.10047817f, -0.10297800f, 0.11220668f, -0.15388945f, -0.04759172f, -0.00900749f, 0.13528512f, 
    -0.26851669f, 0.25674078f, -0.30765891f, -0.00990866f, 0.12770894f, 0.06800754f, 0.01241946f, -0.03557561f, 
    -0.07479779f, -0.03061674f, -0.05886120f, -0.04047993f, 0.24559271f, -0.03487798f, -0.04746622f, 0.11530233f, 
    0.04626634f, 0.11706124f, -0.01491329f, 0.05616847f, -0.08702771f, 0.07554148f, -0.05994497f, 0.25659680f, 
    -0.01557387f, -0.21014997f, 0.00422373f, 0.07029922f, 0.28202397f, 0.15210465f, 0.06975507f, -0.09833492f, 
    -0.21534485f, -0.07912145f, 0.01323887f, -0.08689459f, -0.12603480f, 0.10263509f, -0.33967727f, -0.11857825f, 
    0.22299409f, 0.23043932f, -0.00430601f, 0.01807273f, -0.07715180f, 0.16803202f, 0.00970886f, -0.09069981f, 
    -0.55802310f, -0.13738276f, -0.06661885f, 0.07174660f, 0.33036268f, 0.10726663f, 0.02718806f, -0.02313627f, 
    0.04402403f, 0.11352483f, 0.19803104f, -0.04043784f, 1.01346684f, -0.14880003f, 0.43975127f, 0.39536279f, 
    -0.00555015f, -0.02625896f, -0.24808459f, -0.17719203f, -0.12034900f, 0.14809979f, 0.06261287f, 0.05256798f, 
    0.07143743f, -0.15297751f, 0.05643576f, -0.08329993f, -0.09633467f, -0.46499476f, 0.01719697f, -0.25215626f, 
    -0.08156759f, 0.26336163f, -0.09107479f, 0.08994739f, -0.46221739f, 0.30919540f, -0.16004521f, 0.10874477f, 
    -0.26929983f, -0.15631044f, -0.32408547f, -0.09077281f, -0.12275759f, 0.04840231f, -0.02709780f, -0.26707211f, 
    0.68416166f, 0.13801551f, -0.08940664f, 0.24544181f, 0.04282762f, -0.18159124f, 0.08697648f, -0.19947073f, 
    -0.19520372f, -0.00500406f, 0.17056951f, 0.11987556f, -0.59058183f, -0.05020841f, -0.30477273f, -0.10943728f, 
    0.12991779f, 0.19631861f, -0.06089343f, -0.03991999f, -0.16153792f, -0.04847428f, -0.08533267f, -0.15699279f, 
    -0.35850161f, 0.04801905f, -0.01314156f, 0.29814655f, -0.28917930f, 0.11819105f, -0.01794678f, -0.04778337f, 
    0.05780914f, -0.06684655f, 0.19380705f, -0.09997118f, -0.54588127f, 0.19358717f, -0.12885538f, 0.32977265f, 
    0.00770707f, 0.04692394f, -0.06892799f, -0.03323040f, 0.03235944f, 0.11896918f, -0.06580680f, 0.18399991f, 
    0.05465039f, 0.06710236f, -0.04713635f, 0.14148816f, 0.17797570f, 0.11542808f, 0.05452615f, 0.06142886f, 
    -0.21708216f, 0.11873528f, 0.05267235f, 0.11580715f, -0.23827261f, 0.29451993f, -0.13853575f, 0.33666450f, 
    -0.14778922f, -0.13341314f, 0.13949260f, -0.39016634f, -0.16396135f, 0.14141902f, -0.00092535f, -0.01708053f, 
    -0.05985251f, -0.25874805f, -0.34214583f, -0.21830980f, 0.16996449f, 0.03475125f, 0.18137763f, -0.17439136f, 
    -0.04132768f, 0.07142480f, -0.05840984f, 0.14211023f, 0.06849775f, -0.36532408f, -0.15940630f, 0.57018429f, 
    -0.12604272f, -0.03624934f, 0.06102822f, -0.12831287f, -0.09202949f, -0.05637437f, -0.07190782f, -0.10796762f, 
    0.98690015f, 0.17220612f, -0.27977163f, -0.18037376f, -0.11712535f, -0.17617448f, 0.07909728f, -0.18601112f, 
    -0.19445266f, -0.07177659f, 0.20293917f, 0.04427234f, -0.06968231f, 0.00148088f, -0.09512063f, 0.11850432f, 
    0.16329795f, -0.09624267f, -0.04203716f, -0.10396904f, -0.10108656f, -0.15335616f, -0.05523105f, 0.00959738f, 
    0.02923071f, -0.17984453f, -0.11753863f, 0.11297517f, 0.05721890f, 0.13087510f, 0.08361942f, 0.17106092f, 
    0.05353833f, -0.08127790f, 0.24440560f, -0.07196429f, -0.27894440f, 0.08361176f, -0.06177566f, 0.34996712f, 
    0.01064587f, -0.01757812f, 0.01372560f, -0.05136789f, 0.01911396f, 0.06884326f, 0.17890082f, -0.03423885f, 
    -0.57900608f, -0.13771047f, 0.12872563f, 0.25000328f, 0.17216885f, -0.01575928f, 0.12140799f, -0.03949546f, 
    -0.03520196f, 0.02301270f, 0.06540091f, 0.14290395f, 0.03444021f, -0.22822033f, -0.31818524f, 0.08320484f, 
    0.09624084f, -0.06642249f, -0.00444445f, 0.04615109f, 0.03294583f, -0.01038052f, -0.06371288f, 0.00849684f, 
    -0.27570981f, -0.14415364f, 0.25845253f, 0.27754679f, -0.13771071f, 0.06503479f, -0.16096374f, 0.22338541f, 
    0.08137138f, -0.09126312f, 0.21401948f, 0.07146098f, -0.18244320f, -0.32874292f, -0.08705385f, -0.16706710f, 
    -0.02148477f, -0.27590311f, -0.11257578f, 0.00657520f, -0.10573819f, -0.03271950f, -0.22451955f, -0.12365618f, 
    -0.00822412f, -0.11761323f, -0.12987019f, 0.14411327f, -0.04420020f, -0.05261152f, -0.02196445f, -0.11058459f, 
    -0.07749002f, 0.20363608f, -0.24726696f, 0.10935336f, 0.05840456f, -0.39646745f, 0.53807884f, -0.50076759f, 
    -0.56232339f, -0.08235137f, -0.19907871f, 0.13890189f, -0.04559531f, 0.10621949f, 0.04735458f, 0.00127435f, 
    0.27655131f, -0.05673245f, -0.30242690f, 0.36315620f, 0.06417184f, -0.03730661f, -0.43333462f, 0.05561355f, 
    0.03732263f, -0.13523164f, 0.09555130f, -0.22553213f, -0.04317639f, 0.71661842f, 0.40206283f, -0.02711883f, 
    -0.12386183f, 0.10580546f, -0.06821437f, -0.30516329f, 0.07894071f, -0.10852979f, -0.06735826f, 0.09933287f, 
    0.13135056f, 0.12491363f, -0.07463838f, 0.06099268f, 0.10913953f, 0.08533503f, -0.00052605f, -0.02615458f, 
    -0.05039015f, 0.05711803f, 0.09106995f, -0.02611838f, -0.45077845f, 0.10515942f, -0.01720922f, 0.28044197f, 
    -0.09222899f, -0.02471675f, -0.08713975f, -0.06470827f, -0.21639833f, 0.00289849f, 0.05614853f, -0.00699288f, 
    -0.21411872f, -0.10510805f, 0.09391980f, 0.22719841f, 0.03368048f, 0.10618184f, -0.13986939f, 0.02777009f, 
    -0.08487523f, -0.07047893f, -0.11521477f, -0.04229255f, 0.05945363f, -0.09287319f, -0.29619443f, -0.50342023f, 
    0.03389722f, -0.27876031f, -0.15064897f, -0.16174778f, -0.04291278f, 0.15789932f, -0.05468690f, -0.27738750f, 
    0.09249704f, -0.14734653f, 0.07137384f, 0.16387458f, -0.15214907f, -0.11701084f, -0.10310902f, -0.09006044f, 
    -0.05732523f, 0.00086622f, -0.02593319f, 0.04275277f, -0.06100638f, 0.06437515f, 0.06614609f, 0.11421903f, 
    -0.22311677f, -0.06057703f, -0.06497548f, 0.05879990f, 0.01674569f, -0.19374417f, 0.17705515f, -0.04608636f, 
    0.36666402f, 0.23664710f, 0.00409549f, 0.05159207f, -0.05666257f, -0.05781080f, 0.08075937f, 0.05444961f, 
    0.09319451f, 0.02550683f, -0.14268103f, 0.13822193f, 0.22126381f, 0.01032947f, 0.06817900f, 0.03242364f, 
    -0.01844494f, 0.10089006f, 0.06873573f, 0.08324631f, 0.26634157f, -0.00418649f, 0.00496895f, 0.02311348f, 
    -0.07739847f, 0.06991328f, -0.36196083f, -0.34765565f, 0.09787543f, 0.08528521f, 0.06084424f, 0.07394617f, 
    -0.07598840f, -0.04293529f, -0.03535153f, -0.20893230f, -0.18485688f, -0.19769561f, -0.53871703f, -0.01352846f, 
    0.05023152f, -0.08134852f, 0.16586211f, -0.30963439f, 0.05597349f, -0.10627336f, 0.13835073f, 0.04977886f, 
    0.21840677f, -0.00608845f, 0.28775996f, 0.01938286f, 0.01774805f, 0.06197498f, -0.04417022f, -0.15205573f, 
    -0.01973346f, 0.08628994f, -0.34237516f, -0.14278656f, -0.44594502f, -0.24501754f, -0.08794453f, -0.19001114f, 
    0.08238254f, -0.08239295f, -0.04140889f, 0.08759461f, 0.06558594f, 0.03244328f, 0.02801630f, -0.17233688f, 
    0.17659357f, 0.04439434f, 0.03912073f, 0.16716889f, 0.03319905f, -0.04355006f, 0.03086250f, 0.05788058f, 
    0.22673987f, -0.22542119f, -0.20984961f, -0.08192525f, 0.07856299f, -0.12767589f, 0.01111652f, -0.08136077f, 
    0.06556724f, -0.06232594f, 0.04362087f, -0.01144210f, 0.08129811f, -0.23536333f, -0.12088636f, 0.07765785f, 
    -0.37005728f, -0.13890304f, -0.01318143f, 0.04102314f, 0.13332351f, -0.01850979f, 0.15144676f, -0.02568547f, 
    -0.11245606f, 0.11898536f, -0.14800297f, 0.02801401f, 0.18344544f, -0.15407999f, 0.01784654f, -0.09816598f, 
    0.07702512f, -0.04026731f, -0.04709633f, -0.09186991f, 0.24239722f, 0.05708617f, 0.00455654f, 0.07773963f, 
    -0.22753988f, -0.30051807f, -0.02948120f, 0.24872887f, -0.13398941f, -0.02006840f, -0.09591680f, -0.26727471f, 
    0.02970871f, -0.01685340f, 0.07663978f, -0.01005215f, 0.19950590f, -0.18376309f, 0.07954859f, -0.43662122f, 
    -0.25151068f, -0.02088647f, -0.39065725f, -0.08469914f, -0.12910555f, 0.01919362f, -0.31058642f, -0.27265653f, 
    0.04276859f, 0.19661015f, -0.03035013f, 0.22462900f, -0.06576534f, 0.05125234f, -0.04910989f, -0.07497335f, 
    0.00280550f, 0.15192735f, -0.00158746f, -0.00409962f, 0.04485641f, 0.44419199f, 0.40734378f, 0.11976571f, 
    0.03592810f, 0.19685303f, -0.27292687f, 0.19554411f, -0.05380218f, -0.01303040f, -0.06187558f, -0.08769780f, 
    -0.45960543f, -0.07151992f, 0.09284772f, -0.01392279f, -0.22229232f, -0.03948480f, -0.24848719f, -0.04292000f, 
    -0.09453517f, -0.06743909f, -0.11677625f, 0.25017723f, -0.09162055f, -0.12435269f, 0.16028430f, 0.16746652f, 
    -0.10385577f, -0.17591584f, -0.10159478f, 0.21929359f, -0.02276278f, 0.06984104f, -0.03040788f, -0.02890259f, 
    0.24524125f, 0.19562094f, 0.39521646f, 0.36778495f, -0.16525817f, -0.01805103f, 0.08830601f, 0.22253527f, 
    0.11744530f, -0.03451269f, -0.01443450f, 0.01058970f, 0.15736677f, 0.09842569f, -0.01977218f, 0.10389850f, 
    -0.02511368f, 0.03812210f, -0.31252831f, -0.26680318f, -0.01099898f, -0.19187117f, 0.12666693f, -0.15556407f, 
    -0.15582737f, 0.00229135f, 0.07494997f, 0.05669184f, 0.10582713f, -0.10267973f, -0.08001212f, -0.22896245f, 
    -0.20503157f, -0.18177168f, -0.14677636f, 0.07763810f, -0.00119912f, -0.03816290f, 0.25355890f, -0.01423984f, 
    -0.24331130f, -0.00046450f, -0.12759894f, 0.02833741f, -0.00689876f, -0.01336139f, 0.07397040f, 0.03340444f, 
    -0.02352687f, 0.29471925f, -0.06639785f, 0.12144119f, 0.04195350f, -0.04990406f, -0.06092054f, -0.09803392f, 
    0.12612681f, 0.15036722f, -0.14658214f, 0.20590624f, 0.16482654f, -0.00111627f, 0.08869650f, -0.01005670f, 
    -0.05049293f, -0.05479803f, -0.18718106f, -0.07758838f, 0.04176662f, -0.14177197f, -0.07597088f, -0.16294430f, 
    -0.00538856f, 0.11933310f, 0.15452079f, 0.23491953f, -0.02831294f, -0.05806559f, 0.06444991f, 0.04979653f, 
    0.05899300f, 0.01063219f, 0.03075081f, 0.04507139f, 0.22624843f, -0.35831922f, -0.87789822f, 0.16815960f, 
    0.11211266f, 0.01206704f, 0.00980523f, -0.01114353f, 0.06227601f, -0.02532683f, -0.00341830f, -0.08470780f, 
    -0.16323534f, -0.02399795f, -0.09926143f, -0.20091243f, -0.17396963f, -0.02752056f, -0.00834979f, -0.16579983f, 
    -0.04042460f, -0.23107442f, 0.02550967f, -0.00024665f, 0.16891281f, -0.19976272f, -0.11015404f, 0.55406296f, 
    -0.15093669f, 0.11075172f, -0.27382180f, -0.11873810f, 0.06623493f, -0.02717340f, 0.02286022f, 0.04274666f, 
    -0.07519934f, -0.06915358f, 0.13247308f, 0.03801674f, -0.08067186f, -0.04832559f, 0.06273505f, -0.13687025f, 
    0.15641481f, 0.19965434f, 0.15304388f, 0.23912130f, -0.18726258f, -0.30257875f, 0.01466295f, -0.18041500f, 
    -0.18885700f, -0.13804252f, -0.16170162f, -0.10782613f, 0.02470306f, -0.07211051f, -0.09615181f, 0.23420841f, 
    0.04275295f, 0.00632936f, 0.04469782f, 0.22601974f, 0.10003989f, 0.03844861f, 0.13399896f, 0.05662646f, 
    -0.02352690f, -0.06019004f, 0.02825586f, 0.04800526f, 0.15759769f, 0.10099911f, -0.12715122f, 0.00877213f, 
    0.02472937f, 0.06092031f, -0.00672571f, 0.03256885f, -0.42660427f, -0.04111082f, -0.10413183f, 0.06105103f, 
    -0.09651141f, 0.27149445f, -0.02484846f, -0.07862410f, -0.01420096f, 0.13872790f, -0.03243507f, 0.16528018f, 
    0.09736782f, -0.00541133f, -0.20118263f, 0.04703905f, -0.07034384f, -0.05167448f, -0.20171216f, -0.20384094f, 
    0.15889713f, -0.10927463f, 0.02205004f, -0.16339202f, 0.10457724f, 0.07274731f, -0.16140166f, -0.07995626f, 
    -0.77458692f, -0.41841811f, -0.03021539f, -0.13025819f, 0.00826512f, 0.01565316f, 0.00987394f, 0.17157064f, 
    0.02782607f, 0.03963067f, 0.16950166f, -0.02087945f, 0.00011163f, -0.03032662f, 0.02934751f, -0.10012325f, 
    -0.07375012f, -0.04837647f, -0.11550644f, -0.11095184f, 0.02679780f, -0.02167648f, -0.12207246f, -0.12714243f, 
    -0.22947243f, -0.10030688f, -0.87162930f, 0.04718817f, 0.04918161f, 0.01186079f, -0.07895927f, -0.11178221f, 
    0.15891016f, -0.04458918f, -0.10322414f, 0.13161710f, -0.57015169f, 0.15192547f, -0.10589116f, 0.24536578f, 
    0.10214210f, -0.22413546f, 0.18025985f, 0.30521023f, 0.05345748f, 0.04374738f, -0.04953343f, 0.04794186f, 
    0.15895818f, -0.02387459f, -0.19866394f, -0.01578945f, 0.16528407f, 0.11876509f, -0.06146001f, -0.12807560f, 
    -0.14551897f, 0.13096389f, 0.32320780f, 0.16657400f, 0.43855160f, 0.00626408f, -0.56026065f, 0.60265791f, 
    0.13229023f, -0.17028871f, 0.01561278f, -0.09233408f, -0.01278483f, 0.09049914f, -0.03188258f, 0.09110580f, 
    -0.63760108f, 0.47253779f, -0.16473630f, -0.07787681f, -0.00765153f, -0.17853573f, -0.04302903f, -0.07704231f, 
    0.10015742f, 0.18672062f, -0.03475152f, -0.10176031f, -0.07283272f, -0.12175237f, -0.28879884f, 0.01601592f, 
    0.05056135f, 0.02335211f, 0.01638603f, -0.04841888f, 0.19461095f, -0.01896186f, 0.18990396f, -0.07476496f, 
    0.46010265f, -0.24138755f, -0.06540360f, -0.09064490f, -0.05964758f, -0.05068595f, -0.02065032f, 0.06578514f, 
    -0.16684757f, 0.06854193f, 0.12339547f, -0.21017620f, 0.18675804f, -0.00892270f, 0.05329728f, -0.17849340f, 
    -0.00888070f, 0.06255571f, 0.06789985f, -0.05783720f, -0.19968256f, -0.32411739f, -0.43024242f, -0.10166182f, 
    -0.55319852f, 0.03048920f, 0.19458540f, -0.55342978f, -0.04766691f, -0.03941342f, -0.01390400f, -0.08345325f, 
    0.04767258f, 0.05025226f, 0.00565552f, 0.01701937f, 0.00319890f, -0.12894475f, 0.32515773f, -0.33841795f, 
    0.01069540f, 0.21266368f, 0.14057855f, 0.20937151f, 0.17598161f, -0.02836471f, -0.00386395f, 0.23518807f, 
    0.06763787f, -0.06145351f, 0.18019889f, -0.26271361f, -0.00860709f, -0.05619464f, 0.11139689f, 0.26136056f, 
    -0.15499578f, -0.15615402f, 0.14827695f, -0.07436066f, -0.20518748f, 0.24586031f, 0.05210642f, -0.48662969f, 
    0.04716454f, 0.09388986f, 0.15965357f, -0.00662377f, 0.01743182f, -0.01033018f, 0.04120260f, 0.09925538f, 
    -0.11415360f, 0.36015221f, 0.10348781f, 0.04328515f, -0.12137955f, -0.16923778f, -0.19380786f, -0.11008655f, 
    0.29246736f, -0.23303911f, -0.14994672f, -0.22630438f, 0.08389214f, 0.03896614f, -0.06439477f, -0.15227576f, 
    0.02816986f, 0.14545536f, 0.01758724f, 0.14352053f, -0.06231767f, 0.12117589f, -0.06154854f, 0.10290790f, 
    0.16614278f, 0.08867871f, 0.13048118f, -0.10455222f, 0.16242769f, -0.00629063f, -0.11323293f, -0.29884064f, 
    -0.06480858f, -0.09611630f, -0.06384423f, -0.04525029f, 0.04785373f, 0.28061536f, -0.00804835f, -0.02279701f, 
    -0.05893993f, 0.16749151f, -0.04478643f, 0.17683692f, 0.08539037f, -0.05709514f, -0.21757811f, 0.03694298f, 
    -0.24920462f, -0.32894742f, -0.45591712f, -0.27284053f, -0.09503457f, 0.07700241f, -0.05808968f, -0.13409707f, 
    0.13472423f, -0.16241851f, 0.27796105f, -0.06249644f, 0.05590127f, 0.12257330f, 0.30031869f, -0.17107122f, 
    0.41217819f, 0.09153318f, 0.08392601f, 0.16435871f, 0.03223633f, -0.00366000f, 0.03287259f, 0.01055291f, 
    0.10567614f, -0.21346189f, -0.31442606f, -0.08291660f, 0.00143108f, 0.09997259f, 0.16726336f, -0.04866101f, 
    0.02256831f, -0.19814396f, 0.01781260f, -0.49230170f, -0.04617042f, -0.03655149f, -0.15339167f, 0.00914173f, 
    -0.12083438f, 0.00725931f, 0.11275578f, -0.15462708f, 0.09257825f, 0.00612668f, 0.16868633f, 0.08254898f, 
    -0.08220880f, 0.08325350f, 0.11361863f, -0.11716912f, 0.28194594f, 0.18474154f, 0.16099359f, 0.25043437f, 
    0.05502604f, 0.01508190f, 0.08727692f, 0.00487198f, 0.23069334f, 0.03664970f, -0.27777702f, 0.10793202f, 
    -0.01341187f, 0.11539174f, 0.00587204f, -0.00253214f, 0.07219137f, -0.07195523f, -0.19552475f, -0.08440007f, 
    -0.45323756f, -0.07124906f, 0.00955072f, 0.01890554f, 0.10074222f, -0.05912531f, 0.16055790f, -0.14746004f, 
    0.11688302f, 0.12364257f, 0.03229287f, 0.33101106f, -0.29455498f, -0.53698730f, 0.41593841f, 0.36441642f, 
    0.06205823f, -0.08407760f, -0.12032489f, 0.25122619f, 0.06808962f, -0.06932796f, 0.04195322f, -0.07060646f, 
    -0.31291154f, -0.06618915f, 0.01744287f, -0.22506350f, -0.07101639f, -0.04558576f, 0.06985646f, 0.02672819f, 
    0.02357335f, -0.36962107f, -0.36225152f, -0.21804044f, -0.15020542f, -0.21544568f, 0.06258846f, -0.31596637f, 
    0.07425226f, 0.00931338f, 0.14024159f, 0.24042878f, 0.15414244f, 0.04666815f, -0.04135768f, -0.15341234f, 
    0.06639072f, 0.19641057f, 0.14249927f, -0.00716386f, -0.01325001f, 0.07300040f, 0.19018048f, 0.11058243f, 
    0.15058161f, -0.01225940f, -0.01299255f, 0.16045021f, -0.09576853f, 0.02779647f, 0.00757465f, -0.00558570f, 
    0.11322854f, -0.27857879f, -0.06810561f, 0.09110892f, 0.21662289f, -0.14018911f, -0.01834440f, 0.16532883f, 
    -0.60921979f, 0.25075269f, 0.21179578f, -0.02198447f, -0.06996665f, -0.02222790f, 0.01840767f, 0.04608150f, 
    -0.06150747f, -0.00108358f, 0.15499023f, 0.13689227f, -0.01356917f, -0.39817804f, -0.18294859f, -0.61629105f, 
    -0.09155601f, 0.01702398f, -0.10159235f, 0.12685189f, -0.05285943f, 0.17294309f, 0.11224362f, 0.17393506f, 
    -0.55940884f, 0.30821109f, 0.37385327f, 0.17747645f, -0.08062593f, 0.00040323f, -0.00369207f, -0.03584999f, 
    0.09132034f, 0.06900246f, 0.01964739f, 0.06746580f, -0.37064537f, 0.28191790f, 0.25697055f, -0.11504467f, 
    -0.05977567f, -0.03353136f, -0.15917407f, -0.10692634f, -0.05158001f, -0.10834599f, -0.06796193f, 0.04445053f, 
    -0.30454510f, 0.02638804f, 0.17272738f, -0.47994834f, 0.04412564f, -0.07149880f, 0.05708055f, -0.06852347f, 
    0.05887825f, -0.02496996f, -0.18346548f, -0.00537870f, -0.22437124f, -0.36647898f, 0.15344307f, 0.72289258f, 
    -0.05319782f, 0.17929180f, -0.03384113f, -0.25909525f, 0.06386306f, -0.11443064f, 0.06218017f, -0.11843666f, 
    0.11001392f, -0.01574055f, 0.00346343f, -0.13151647f, -0.04138551f, -0.09753308f, 0.02168872f, -0.16856149f, 
    -0.07227930f, -0.00662990f, -0.41484281f, -0.13383473f, 0.37756374f, -0.16999239f, -0.23309052f, -0.42612073f, 
    0.07034882f, -0.06339324f, 0.25248763f, -0.09573164f, 0.00236828f, 0.16222379f, -0.13358209f, -0.23679256f, 
    -0.35949787f, 0.07203682f, 0.57102615f, 0.03934820f, -0.04930051f, -0.13980266f, -0.10694508f, 0.13384676f, 
    0.02011803f, 0.10999538f, 0.16105722f, -0.17510132f, 0.10853343f, 0.17263888f, 0.08840457f, -0.12857933f, 
    0.04025770f, -0.00438318f, 0.01186906f, 0.00473704f, 0.03535575f, 0.11103266f, 0.18182386f, 0.11253881f, 
    0.50373989f, 0.26874760f, -0.17028214f, 0.00961548f, -0.07575386f, -0.06157007f, -0.04920714f, 0.18616535f, 
    0.15088886f, -0.01267779f, -0.11634934f, 0.14133476f, -0.03317429f, 0.09257977f, 0.00080478f, -0.06359036f, 
    0.03788478f, 0.07665106f, 0.16077083f, 0.00982652f, 0.22834627f, 0.11449946f, 0.30460629f, -0.08018836f, 
    -0.63209760f, -0.89455646f, -0.45494395f, 0.12925766f, 0.01731975f, -0.19988292f, 0.00402882f, -0.19738272f, 
    -0.06145862f, 0.05620119f, 0.01378779f, -0.01237663f, 0.04420957f, -0.20405725f, -0.28874043f, -0.02367059f, 
    -0.11629439f, -0.06710158f, -0.10675264f, 0.30037320f, -0.00237787f, 0.20162824f, 0.05288161f, -0.26095760f, 
    -0.18621789f, -0.10831862f, 0.13837960f, 0.02020507f, -0.29249623f, -0.06369708f, -0.06138553f, -0.02448795f, 
    -0.02344462f, 0.08274481f, 0.06145518f, -0.06851751f, -0.67615718f, -0.87565672f, -0.43715566f, 0.45646593f, 
    -0.01668538f, 0.14872466f, -0.18984605f, -0.12850063f, 0.09590917f, -0.02464448f, -0.06589185f, 0.04464256f, 
    -0.12374977f, -0.04172444f, -0.11741529f, 0.02342616f, -0.17864576f, -0.02128517f, 0.14076243f, 0.04397000f, 
    0.03956844f, -0.01630020f, 0.20212115f, -0.01386838f, -0.79616064f, 0.00398816f, 0.17100351f, 0.18654908f, 
    -0.23965584f, 0.06356088f, 0.04107851f, -0.08302170f, 0.07453783f, 0.05327518f, -0.00579136f, 0.04780079f, 
    -0.29133189f, -0.17523001f, -0.29614419f, -0.41077527f, -0.12835656f, -0.23844492f, -0.14002305f, -0.20921047f, 
    -0.04827011f, 0.00694473f, 0.02650273f, 0.02796158f, 0.24532890f, 0.31109816f, 0.00881957f, -0.05428534f, 
    0.09167334f, -0.26987371f, -0.14165504f, -0.02314492f, -0.15961166f, 0.04136017f, -0.02548475f, -0.14140840f, 
    0.16292882f, 0.54263002f, -0.04319579f, 0.30855989f, 0.01459075f, -0.18421423f, 0.06357561f, 0.18442425f, 
    0.04674881f, 0.13440706f, -0.08094381f, 0.10602582f, -0.69362020f, -0.69946480f, -0.01621355f, -0.20669422f, 
    0.05924388f, -0.07910386f, 0.07031102f, -0.25918117f, 0.02702118f, 0.12442940f, -0.01710869f, 0.00319351f, 
    0.18792522f, -0.06343999f, -0.11758694f, -0.08580250f, -0.00106382f, 0.09265227f, 0.16172579f, 0.10439973f, 
    0.02830490f, 0.03751783f, 0.05187885f, -0.03781890f, -0.08801273f, -0.01956268f, 0.05704244f, -0.06818070f, 
    -0.03496324f, -0.05956591f, -0.16673419f, 0.11488558f, -0.06315222f, -0.08259308f, -0.06376458f, -0.04895517f, 
    -0.61267239f, -0.70260715f, -0.54488945f, 0.05185163f, -0.26436177f, -0.11378920f, -0.16903473f, -0.36564547f, 
    -0.05533251f, -0.04167846f, -0.08804181f, -0.06636798f, 0.03988706f, 0.21927921f, 0.02772342f, -0.27797982f, 
    -0.02140212f, 0.10078729f, -0.01088169f, 0.04425568f, -0.06580159f, 0.08740542f, 0.08519147f, -0.03755683f, 
    0.20987889f, 0.04592746f, 0.11533862f, 0.28002691f, 0.02672393f, -0.17163984f, 0.07823246f, 0.12789117f, 
    -0.02305460f, -0.11868731f, -0.14934754f, 0.14117385f, -0.28109765f, -0.44530371f, -0.19341180f, 0.43321136f, 
    0.02502197f, 0.30927870f, 0.00513401f, 0.03452294f, -0.04064814f, -0.13488600f, 0.00092650f, 0.07771187f, 
    -0.21981671f, -0.07789122f, 0.04036612f, -0.05576438f, -0.12079918f, 0.01472299f, 0.07753053f, 0.02688928f, 
    -0.00524971f, 0.27653646f, 0.18480809f, 0.20927528f, 0.25786301f, 0.74404770f, -0.16562875f, 0.05490456f, 
    0.11261614f, 0.16099715f, 0.03289331f, 0.13080727f, 0.18400957f, -0.00229687f, 0.23378657f, -0.01060525f, 
    -0.75081432f, -0.70561016f, -0.46371201f, -0.33075300f, -0.22422564f, -0.45327950f, -0.02618083f, -0.45772997f, 
    -0.03906782f, -0.02071718f, 0.01900832f, -0.13051969f, 0.18230288f, -0.23411821f, 0.10347116f, 0.09522097f, 
    0.01657920f, -0.09863979f, 0.13747710f, 0.01400250f, 0.00347056f, -0.02403909f, -0.01181626f, -0.08702336f, 
    0.46067256f, -0.97659212f, -0.32358423f, -0.43055439f, -0.24963249f, -0.03016317f, -0.21398953f, 0.17998853f, 
    0.08988609f, 0.20917112f, 0.03507438f, 0.05471249f, 0.58836740f, -0.37597185f, -0.42493340f, -0.30072090f, 
    0.09722505f, 0.11950254f, -0.04001163f, 0.04994468f, 0.13647543f, 0.13591808f, 0.06451095f, 0.06460675f, 
    0.70825231f, -0.40812159f, -0.16655599f, -0.48617575f, 0.02729263f, -0.03043121f, -0.09695899f, 0.00801827f, 
    0.17786725f, -0.01646850f, -0.19842714f, 0.01460876f, 0.20203587f, 0.06835895f, -0.11080011f, -0.06243197f, 
    0.08306133f, 0.05836815f, 0.03861319f, -0.05174548f, -0.16057292f, 0.04443833f, 0.16685130f, 0.14085697f, 
    0.03186784f, 0.14577229f, -0.10158779f, 0.14677337f, 0.04052507f, 0.08791269f, 0.07897285f, 0.01678296f, 
    -0.03532982f, 0.02919220f, 0.03446027f, -0.06332229f, 0.02130369f, 0.32705811f, -0.57653356f, 0.46804386f, 
    -0.14027184f, 0.37634116f, -0.24701613f, -0.03141496f, -0.01275827f, 0.04618591f, -0.01924605f, 0.04326297f, 
    0.14470784f, -0.00987597f, 0.08700296f, -0.04730376f, 0.05423717f, -0.03086910f, -0.02536427f, -0.04346221f, 
    -0.09414551f, 0.01254441f, -0.09927113f, 0.07817727f, -0.23936154f, 0.08232351f, -0.12975611f, 0.02122336f, 
    -0.09950145f, 0.00689595f, -0.13257518f, -0.05437702f, 0.12060343f, 0.06366569f, 0.04820835f, -0.12121972f, 
    1.02551150f, -0.11032610f, -0.78289831f, -0.02493231f, 0.02942313f, -0.21364324f, 0.09864162f, -0.02221460f, 
    -0.05908412f, -0.15970179f, 0.10787508f, 0.16823584f, 0.10658161f, 0.03852411f, 0.09808148f, -0.03810600f, 
    0.00856091f, -0.04361372f, -0.03675381f, -0.05239846f, 0.10695281f, -0.32315540f, -0.07276978f, -0.40965706f, 
    -0.07537712f, -0.00841145f, -0.02194749f, -0.12337156f, -0.07685205f, 0.01767151f, -0.08998086f, 0.19620000f, 
    -0.30670112f, 0.12073478f, 0.10709772f, -0.15758292f, -0.04938200f, -0.12635458f, 0.21446076f, -0.17545176f, 
    -0.04249919f, -0.11826588f, 0.11263069f, 0.01244832f, -0.02342751f, 0.09640339f, 0.19848542f, -0.02290429f, 
    0.04693225f, -0.62892956f, 0.47982964f, -0.71592212f, -0.28305852f, 0.15008114f, 0.03696490f, 0.44823417f, 
    0.09434677f, -0.07262577f, 0.00720763f, -0.06790734f, -0.10396423f, -0.38812917f, 0.11519490f, 0.13945150f, 
    -0.07520278f, -0.08330091f, 0.11162587f, -0.09904671f, 0.09895319f, 0.05232265f, -0.18920724f, -0.03968597f, 
    0.40137312f, -0.23215196f, -0.19181213f, -0.18822137f, 0.13081908f, 0.13442141f, -0.02294150f, 0.04058478f, 
    -0.02887543f, 0.01319745f, 0.03753663f, -0.03381263f, -0.74013162f, 0.02607206f, 0.58609682f, -0.28349361f, 
    -0.00662354f, 0.17551132f, -0.04904828f, 0.14901210f, 0.00728039f, 0.07802603f, 0.01169302f, -0.02105493f, 
    0.26151124f, -0.03559038f, -0.35078198f, 0.28587377f, 0.02593878f, -0.04013824f, 0.14266831f, -0.41006270f, 
    0.07794245f, -0.01636543f, -0.17942733f, -0.06112982f, 0.04776260f, -0.38347232f, -0.30626398f, -0.07204309f, 
    0.10032399f, -0.26096413f, 0.00554324f, 0.25237143f, -0.05745082f, -0.15116984f, -0.06497951f, 0.14604796f, 
    -0.57853079f, -0.13486530f, -0.05224797f, 0.56286299f, 0.18899976f, 0.03735135f, 0.07314917f, 0.01647898f, 
    -0.07940748f, -0.01096468f, 0.00722053f, 0.06916075f, -0.63580471f, -0.11506778f, -0.31775257f, 0.24658066f, 
    -0.17055908f, -0.06208999f, 0.10224400f, 0.01392881f, -0.10438681f, 0.03276043f, 0.03771011f, 0.02022272f, 
    -0.09312212f, -0.33351395f, -0.06957255f, 0.02050905f, -0.14946057f, 0.08256506f, 0.09043229f, 0.08536033f, 
    -0.04250382f, -0.08739435f, 0.03621697f, -0.09309119f, -0.35720959f, -0.36277205f, 0.27602220f, -0.04880390f, 
    -0.05125087f, 0.04029295f, 0.05997948f, 0.05593970f, -0.05706845f, -0.12309626f, -0.10076759f, -0.02440819f, 
    0.08943967f, 0.11785614f, 0.06638270f, 0.02824981f, -0.04363104f, -0.01854093f, -0.03154157f, 0.04635292f, 
    0.04673902f, -0.14548498f, 0.10926037f, 0.13893232f, -0.00437000f, 0.11500704f, 0.02845040f, -0.11727089f, 
    -0.19554003f, -0.06648502f, 0.09762154f, 0.08329038f, -0.03957156f, -0.02611665f, 0.00912825f, -0.03375138f, 
    -0.28993121f, -0.29137707f, -0.33278954f, -0.13861041f, -0.07093711f, -0.34235981f, -0.10514727f, 0.07283892f, 
    0.02448196f, -0.02083501f, 0.01892515f, -0.03752103f, -0.16636215f, 0.24924952f, 0.04493500f, -0.05576415f, 
    0.06681392f, 0.08512690f, -0.08069214f, -0.04104369f, 0.00844581f, -0.00636590f, 0.08162850f, 0.01758503f, 
    -0.20346494f, -0.12602873f, -0.03692634f, -0.01533527f, 0.07064084f, -0.03313357f, 0.19383478f, -0.26885062f, 
    0.03415159f, -0.16516320f, 0.13932271f, -0.03571867f, 0.21295540f, -0.15725781f, -0.11371716f, -0.09757908f, 
    -0.07703750f, -0.18180226f, 0.01366759f, -0.04833591f, 0.02318739f, 0.05316302f, -0.01477387f, 0.00412582f, 
    0.29127938f, -0.45917979f, -0.19100314f, -0.17157963f, -0.02400890f, -0.16611432f, -0.10717080f, 0.02622749f, 
    0.16967753f, -0.02341492f, 0.12950584f, 0.02029130f, -0.15360405f, -0.23605083f, -0.04150309f, -0.03200484f, 
    -0.03801605f, -0.19577169f, 0.22766009f, -0.22326086f, -0.21738885f, 0.15096560f, -0.05568824f, -0.07933697f, 
    -0.31895232f, -0.25567561f, 0.28394634f, 0.39262512f, -0.11788656f, -0.15387036f, -0.15360172f, 0.05727659f, 
    -0.00616494f, 0.01856082f, -0.06143864f, -0.06075800f, 0.10335071f, 0.01139142f, 0.17434393f, -0.20376053f, 
    0.04635959f, 0.05423117f, 0.01191222f, -0.10113043f, -0.04525230f, 0.05325077f, -0.23999812f, -0.18126364f, 
    0.12187797f, -0.66649705f, -0.43850380f, -0.29021692f, 0.08586951f, 0.16876444f, 0.25979257f, 0.18816897f, 
    -0.03938176f, -0.31070653f, 0.10529520f, -0.04915159f, -0.33512178f, -0.79040313f, -0.27926317f, -0.05420434f, 
    0.10170063f, 0.14122461f, 0.04466700f, 0.14342241f, -0.05250627f, 0.07025195f, -0.14980775f, -0.00731423f, 
    -0.16845524f, -0.26413170f, -0.21940820f, -0.13863318f, 0.05337951f, 0.02674848f, 0.11891121f, -0.01747254f, 
    -0.04780812f, 0.09677748f, -0.09336101f, -0.22226307f, -0.26354083f, -0.23622636f, -0.17406435f, -0.12953354f, 
    -0.18452775f, 0.05261100f, 0.03399024f, -0.01277211f, 0.12707563f, -0.00615125f, 0.01580045f, 0.03965295f, 
    -0.72356331f, 0.09243385f, 0.23415114f, 0.16590060f, -0.20194517f, -0.08512773f, -0.16069227f, 0.00365751f, 
    -0.07828169f, 0.05075711f, 0.05974262f, -0.00319840f, -0.15231261f, 0.15053628f, -0.04392958f, 0.44223025f, 
    0.12542395f, -0.00543747f, -0.06795439f, 0.18725230f, 0.04959197f, -0.01190744f, 0.06486250f, 0.08844881f, 
    -0.09139674f, 0.01462143f, -0.03961027f, -0.00337137f, -0.07238175f, -0.04771846f, -0.06095875f, 0.07572952f, 
    0.12676376f, 0.13489950f, 0.04748797f, 0.13538688f, -0.26437035f, 0.33130845f, -0.02017541f, 0.09376087f, 
    -0.06239920f, 0.09409489f, -0.02306978f, 0.14517531f, -0.01479029f, 0.06419943f, 0.16642545f, 0.13855363f, 
    -0.24710092f, -0.42751610f, -0.19552180f, -0.02707534f, -0.04608170f, 0.29265401f, 0.07836379f, 0.10756653f, 
    0.02927623f, 0.24522538f, 0.05758651f, -0.04518959f, -0.35113060f, 0.09215164f, 0.03980603f, -0.07839371f, 
    -0.11055601f, -0.04907800f, -0.01405262f, -0.07091685f, 0.09592103f, 0.07847263f, -0.28063914f, 0.10995283f, 
    -0.45397025f, -0.27003807f, 0.03081666f, -0.12875912f, 0.09413937f, 0.04929452f, 0.08002502f, 0.10838040f, 
    -0.15462311f, -0.19883925f, -0.06393460f, 0.04953826f, 0.08282652f, 0.06932914f, -0.10832948f, 0.13104427f, 
    0.07674202f, 0.07807425f, 0.02676806f, -0.03012865f, -0.04102056f, -0.22726443f, -0.03616755f, -0.53995055f, 
    0.30020386f, 0.02887902f, -0.72424412f, -0.13105749f, 0.16691032f, -0.24002308f, 0.31163940f, -0.06736321f, 
    -0.06432620f, -0.03482874f, -0.04352011f, 0.07168097f, 0.53728360f, -0.32929844f, -0.41817972f, 0.08665232f, 
    0.04112540f, -0.23897350f, 0.14080144f, -0.19066986f, 0.04828859f, 0.07874771f, 0.26178446f, 0.14867112f, 
    0.07782738f, -0.25412610f, -0.22364849f, -0.06308853f, -0.19922659f, -0.07884508f, 0.09362200f, -0.11077495f, 
    -0.12009002f, -0.20397252f, -0.12432369f, -0.15785305f, -0.07512406f, -0.04923447f, 0.11489276f, 0.13787165f, 
    0.31269357f, 0.08973115f, 0.22545667f, -0.20216864f, 0.08940692f, 0.01760303f, 0.01474851f, 0.00923148f, 
    0.44575664f, -0.17269550f, -0.18487747f, 0.01056957f, 0.26990733f, 0.23129129f, 0.18309532f, 0.24905241f, 
    0.28344545f, -0.08032214f, 0.05736521f, -0.27425903f, 0.26776987f, -0.44452456f, -0.29846218f, 0.21042289f, 
    0.16797225f, 0.17229044f, 0.09149459f, 0.12343199f, -0.01775601f, -0.18832530f, 0.01682133f, -0.31941563f, 
    0.02626567f, -0.43254727f, -0.39102849f, -0.25921503f, -0.03509036f, 0.12047957f, 0.08379056f, 0.20220365f, 
    -0.05943834f, 0.07657177f, 0.01326508f, -0.06423724f, -0.31612647f, -0.35190547f, -0.02370236f, 0.39425895f, 
    -0.10222128f, 0.01528769f, 0.13352139f, 0.06489856f, 0.01244746f, -0.09946867f, 0.06541780f, 0.06632957f, 
    -0.72215408f, -0.22721808f, 0.24489951f, 0.45182240f, 0.00277218f, 0.12226795f, 0.13416103f, 0.03225219f, 
    0.05717211f, 0.07435437f, 0.02831459f, 0.14836374f, 0.50431204f, -0.49055141f, -0.61631334f, -0.29635289f, 
    -0.03392766f, 0.16750899f, -0.13493942f, -0.04754055f, -0.03558731f, -0.01431936f, -0.04135461f, -0.01688521f, 
    -0.66994870f, 0.00525535f, 0.08121017f, -0.03751713f, -0.05202761f, -0.12276171f, -0.10287945f, -0.08306988f, 
    -0.25777498f, -0.46944007f, -0.26318678f, -0.45231310f, -0.03345117f, 0.01690218f, -0.09141121f, -0.04115611f, 
    0.04824990f, 0.00407315f, -0.00652023f, 0.02794334f, 0.12019714f, 0.21749046f, 0.18188341f, 0.29645273f, 
    -0.13262162f, -0.33289284f, -0.37735909f, 0.18622012f, 0.25075865f, 0.01713639f, 0.02981170f, -0.06000135f, 
    -0.06681773f, -0.01676270f, 0.06201412f, 0.08738479f, -0.18559723f, 0.25869817f, 0.12445784f, 0.02132700f, 
    -0.04453228f, -0.14885199f, -0.05265288f, -0.04329240f, -0.12874997f, -0.07950690f, -0.12047197f, -0.00774485f, 
    0.12347656f, -0.23447891f, -0.18887395f, 0.07347593f, -0.06943969f, 0.15426348f, 0.10995660f, 0.01771202f, 
    -0.17224094f, 0.04449560f, 0.00142532f, -0.03848976f, 0.35597098f, 0.27137703f, 0.01648713f, -0.14896543f, 
    0.14672779f, -0.10615466f, 0.15727511f, -0.19261709f, -0.00089955f, 0.00542230f, 0.01793770f, 0.06395987f, 
    0.06295075f, -0.01070243f, -0.00315227f, -0.01568437f, 0.10637020f, 0.04561456f, 0.11206458f, 0.04213842f, 
    -0.00347654f, -0.05294177f, -0.14191698f, -0.69244671f, -0.15848611f, -0.47979605f, 0.19582397f, 0.06971991f, 
    0.14844584f, 0.17419803f, 0.07919443f, -0.07536411f, 0.01875630f, 0.21732017f, 0.00695375f, 0.20654145f, 
    -0.32939219f, -0.43706045f, -0.54119641f, -0.70371395f, -0.12403636f, -0.30830956f, -0.11677814f, -0.12781200f, 
    0.06926717f, 0.04323134f, 0.05528490f, 0.02115615f, 0.00379628f, -0.08601165f, -0.01327772f, -0.07997609f, 
    -0.04492616f, -0.10219615f, -0.00520014f, 0.00287166f, 0.02642894f, 0.07538879f, 0.14909177f, 0.01228247f, 
    0.12713237f, 0.04172751f, 0.03493200f, 0.13470380f, -0.04816842f, 0.13732085f, -0.24316244f, 0.05228256f, 
    -0.03732415f, -0.07793124f, 0.10566868f, 0.04924014f, -0.05803963f, 0.39844912f, -0.24120019f, 0.53956419f, 
    -0.05086398f, -0.12011579f, -0.02018639f, -0.00399297f, -0.02446854f, -0.04585654f, 0.08399916f, -0.15222894f, 
    0.28606710f, 0.00980176f, 0.26444307f, 0.24151023f, -0.01619398f, -0.10122437f, -0.19272111f, -0.15299639f, 
    0.01385062f, 0.04724092f, -0.07150490f, 0.16013177f, 0.32875651f, 0.06885797f, 0.27016997f, 0.28678769f, 
    0.22236009f, -0.09929707f, -0.14122328f, -0.04896461f, -0.02976089f, 0.12445791f, 0.11937920f, 0.26458111f, 
    -0.01000148f, -0.29149884f, 0.06772552f, 0.05724838f, 0.02214225f, 0.02864173f, 0.07432558f, 0.04301840f, 
    -0.02905632f, 0.07554954f, -0.10960975f, -0.21949337f, -1.07789779f, 0.11075837f, -0.60145515f, -0.33508161f, 
    -0.05651201f, -0.07307786f, -0.13385507f, -0.07086275f, 0.06879190f, -0.15069960f, -0.01510407f, -0.03238899f, 
    0.01905590f, -0.35638925f, -0.21902351f, 0.00719109f, 0.11355188f, 0.09542523f, 0.05030321f, -0.05088052f, 
    0.22354221f, 0.15361878f, -0.12680526f, -0.12895487f, -0.32303023f, 0.25055388f, -0.01779681f, 0.04988629f, 
    -0.10562915f, 0.04571526f, 0.06863639f, -0.02163740f, 0.10743896f, 0.06166492f, -0.06195190f, -0.08637420f, 
    -0.19538775f, 0.37188068f, 0.23398367f, -0.12858659f, 0.04686770f, -0.12861417f, -0.05412029f, -0.43112090f, 
    -0.22094002f, -0.04364877f, 0.04673106f, -0.05565841f, 0.06571678f, -0.01609081f, 0.22888216f, 0.14006416f, 
    -0.00840709f, 0.01297839f, -0.17614727f, -0.05965733f, 0.11101656f, 0.08673042f, 0.13942109f, 0.12539540f, 
    -0.01161168f, 0.38977537f, 0.56591964f, -0.70317364f, -0.06414650f, -0.17068979f, -0.04937530f, -0.19921945f, 
    0.00915317f, -0.04656124f, 0.03194491f, 0.13648148f, 0.15728271f, -0.14890657f, 0.30200797f, -0.14405452f, 
    -0.09933564f, 0.02132582f, -0.07851554f, 0.11910339f, 0.02963709f, 0.21234603f, 0.19275174f, 0.00786433f, 
    0.12141150f, -0.63828868f, -0.34291288f, -0.29158998f, -0.20189126f, 0.13862768f, -0.21069700f, -0.05875271f, 
    0.15226395f, -0.04687586f, -0.01988084f, 0.13017616f, 0.08002953f, -0.18307492f, 0.54489613f, -0.21796095f, 
    0.23167156f, -0.49096814f, 0.27098480f, -0.03512825f, -0.06210430f, 0.02311441f, -0.27786845f, -0.05402222f, 
    -0.15008368f, -0.02090610f, 0.34912366f, -0.10770940f, 0.06231324f, -0.04028326f, -0.13242507f, -0.14032546f, 
    -0.07612226f, 0.03665017f, 0.04847186f, 0.11391952f, 0.38311499f, -0.56164080f, -0.12568279f, -0.36608037f, 
    0.04316146f, -0.05807948f, -0.02136974f, 0.13491684f, -0.00404357f, 0.06904521f, -0.11041543f, -0.06875043f, 
    -0.51076871f, 0.21592009f, -0.07318825f, 0.31313363f, 0.26916090f, -0.05192223f, -0.00738609f, -0.04165976f, 
    0.14669238f, 0.20149948f, 0.06384221f, 0.27473551f, -0.52837789f, 0.12178931f, 0.22346751f, -0.46256930f, 
    -0.00928331f, -0.25221545f, -0.01805159f, 0.09105723f, 0.03355369f, -0.03001931f, 0.15353754f, 0.02118702f, 
    0.21370853f, 0.16007194f, 0.10201297f, -0.15050794f, -0.00301801f, -0.22237517f, 0.14854853f, 0.15871118f, 
    0.01514696f, 0.07078186f, -0.01706417f, -0.08037090f, -0.19158041f, 0.31231281f, 0.45652741f, -0.60320121f, 
    -0.00060578f, -0.27537966f, 0.00292308f, 0.08865271f, -0.24063317f, 0.03348327f, 0.03275320f, 0.04356164f, 
    0.34418610f, 0.02542773f, 0.61698371f, -0.75642169f, 0.12536448f, -0.07947261f, -0.08221126f, -0.12052015f, 
    -0.10941421f, -0.04033836f, 0.00755927f, 0.05467259f, -0.39553055f, 0.12451378f, 0.07107196f, -0.17969657f, 
    -0.37804568f, -0.11751527f, 0.04224911f, 0.17297760f, -0.00666950f, 0.14419878f, 0.00408334f, -0.12816779f, 
    0.05709509f, -0.00400009f, -0.29026097f, -0.07671048f, 0.08580481f, -0.00204331f, 0.12885477f, 0.07627244f, 
    0.16112606f, 0.18674295f, 0.08849110f, 0.20423700f, -0.09925406f, -0.07525098f, -0.09232846f, 0.03336891f, 
    0.37454018f, -0.13788104f, 0.00416636f, 0.08519833f, 0.00545470f, -0.21955174f, -0.08295482f, -0.07377839f, 
    -0.34352297f, 0.00106969f, 0.34855255f, -0.27437684f, -0.14205015f, -0.23087150f, 0.08021473f, 0.11258076f, 
    0.03473846f, 0.00204593f, 0.04436334f, -0.08852157f, -0.43375427f, -0.19252323f, -0.63663256f, 0.11365172f, 
    0.13988774f, -0.06173451f, 0.19659786f, -0.13686675f, 0.06392776f, -0.00198504f, 0.19195226f, 0.07637747f, 
    -0.09393133f, 0.34056953f, -0.03089949f, -0.94847745f, -0.05180948f, -0.21142945f, 0.07543731f, -0.26664925f, 
    -0.10835144f, -0.07206263f, -0.00486809f, 0.06828298f, 0.07851717f, -0.47072920f, -0.19642791f, -0.10678264f, 
    0.17086650f, 0.13800690f, 0.22349273f, 0.03596566f, -0.02796579f, -0.15139438f, -0.07067680f, -0.08943401f, 
    0.00546499f, -0.05326068f, 0.22701661f, 0.21439797f, 0.06655743f, 0.04170522f, -0.00784555f, 0.01847817f, 
    0.09509359f, 0.09735712f, 0.14336815f, 0.23249695f, -0.02389922f, -0.36020133f, 0.24431068f, -0.56362224f, 
    0.00955255f, -0.35053331f, -0.09587724f, -0.09167324f, -0.21539456f, 0.06564768f, 0.02040055f, -0.01618816f, 
    -0.51948065f, -0.09195283f, 0.01875508f, -0.12816447f, -0.02848797f, 0.01670818f, -0.09360045f, 0.16021757f, 
    0.13702278f, 0.00409956f, 0.15002052f, -0.04061668f, -0.13023461f, -0.57847100f, 0.01529930f, 0.05113704f, 
    -0.25693855f, 0.22034656f, -0.27079302f, -0.24411632f, 0.02729423f, 0.17167912f, 0.08954700f, -0.05380816f, 
    -0.17731836f, 0.48505226f, -0.14199471f, 0.16554418f, 0.24758489f, -0.04996124f, -0.12572904f, 0.13753058f, 
    -0.05920456f, 0.18048377f, 0.03225869f, -0.07939652f, -0.07508899f, 0.45713267f, -0.07030986f, -0.11980488f, 
    0.01423183f, 0.04546109f, -0.00805524f, 0.04029483f, -0.06459741f, 0.01566806f, -0.28287938f, -0.14786512f, 
    -0.20729981f, 0.33953065f, -0.01289915f, -0.36933324f, 0.06351311f, 0.09608782f, -0.12814488f, 0.02028338f, 
    -0.04905101f, -0.07981481f, -0.29789534f, -0.22970642f, -0.17508630f, 0.34467292f, 0.02898204f, -0.12841736f, 
    -0.05607311f, 0.00825735f, -0.23078051f, -0.28599125f, -0.06593212f, 0.07637794f, 0.10831378f, -0.00001170f, 
    0.07688052f, -0.40774059f, 0.19297422f, 0.15357594f, -0.08464066f, -0.05312172f, -0.17225045f, -0.13124286f, 
    0.07736523f, -0.13663091f, -0.07977732f, 0.20334744f, 0.63062102f, -0.78786075f, 0.63378745f, -0.17191778f, 
    -0.10303456f, 0.15927555f, 0.21372554f, 0.14192566f, -0.16383618f, 0.16048048f, 0.03675294f, 0.05442047f, 
    -0.32652301f, -0.32336938f, -0.17453533f, -0.03967825f, -0.17542569f, 0.14383127f, -0.02486913f, -0.00323515f, 
    0.08808970f, -0.32545665f, 0.05953715f, 0.08515701f, 0.06785219f, -0.37057739f, 0.09132060f, 0.01889384f, 
    -0.11293420f, 0.01625896f, 0.13338242f, -0.09562503f, -0.00047062f, -0.21701609f, 0.18046173f, 0.25779551f, 
    0.54257673f, 0.03344035f, 0.44843665f, -0.38317776f, -0.10723636f, -0.03502723f, 0.19262046f, 0.30746588f, 
    -0.06166976f, 0.06697235f, 0.06400968f, 0.18558407f, -0.10251551f, 0.11287334f, 0.29338819f, -0.04811898f, 
    0.01346259f, -0.20522104f, 0.12451625f, -0.05254783f, -0.17995690f, -0.18341778f, -0.13920246f, -0.13205926f, 
    -0.05579807f, 0.19262940f, -0.06776962f, 0.03092481f, 0.01162062f, 0.11685868f, 0.29437470f, -0.02661181f, 
    0.15218371f, -0.12098058f, -0.21448252f, -0.15460254f, -0.08561415f, 0.25419018f, -0.19346242f, 0.12256548f, 
    0.08684786f, -0.09043188f, -0.22003737f, 0.07753803f, -0.33847305f, -0.31659731f, -0.29564878f, -0.52473450f, 
    0.04719103f, -0.31514606f, -0.54752034f, 0.23701505f, -0.01821701f, -0.09222350f, 0.03639944f, -0.05664751f, 
    -0.13368706f, 0.16219437f, -0.04309291f, -0.19477798f, -0.43023568f, 0.21886490f, -0.13872810f, 0.15125993f, 
    -0.16467868f, 0.15966113f, -0.00484438f, 0.18344724f, 0.13419759f, 0.00245651f, 0.20736656f, 0.19284526f, 
    -0.65581310f, 0.21969560f, 0.05110808f, -0.36874792f, 0.06952769f, 0.03882687f, 0.20483573f, 0.03207607f, 
    -0.13220423f, -0.03866178f, -0.09261972f, 0.15298277f, -0.05868009f, -0.11579456f, -0.26113912f, 0.17626441f, 
    0.00092036f, 0.29512584f, -0.22571525f, 0.10837333f, 0.20984419f, -0.06106782f, -0.02295833f, 0.05493956f, 
    0.20107695f, -0.13676316f, 0.14813137f, -0.33092177f, -0.18363260f, 0.19273360f, 0.16644962f, 0.21730259f, 
    -0.06137446f, -0.05258555f, -0.34860900f, -0.12058879f, -0.12221500f, -0.45856810f, 0.09609982f, -0.27030119f, 
    -0.06653789f, 0.28404948f, -0.37033570f, 0.06263699f, -0.20897338f, 0.05251193f, -0.10060123f, -0.44320154f, 
    -0.28437057f, -0.17909268f, -0.05863544f, 0.39047840f, 0.05286561f, 0.08986532f, -0.02544315f, -0.05437842f, 
    0.00165202f, 0.12446032f, -0.06763455f, 0.19198678f, 0.15787587f, -0.33901903f, 0.19939916f, 0.09309050f, 
    -0.05354213f, -0.05172329f, -0.02072602f, 0.03469427f, 0.13134466f, -0.21530294f, 0.12338621f, 0.02624074f, 
    0.09119110f, 0.06341931f, -0.02931021f, 0.57118839f, -0.15595527f, 0.04753964f, -0.11499124f, -0.02106747f, 
    -0.00862435f, -0.04340646f, 0.08695003f, -0.11782774f, -0.22016196f, -0.12043516f, -0.02727512f, -0.07382207f, 
    -0.14800341f, -0.03787023f, 0.11359409f, 0.17717913f, -0.02314832f, 0.07492442f, 0.02614862f, -0.05280329f, 
    -0.08705401f, 0.15411037f, -0.35531682f, -0.17943084f, -0.17380480f, -0.25388545f, 0.05764058f, -0.12890761f, 
    -0.36040857f, -0.09975730f, -0.73901212f, -0.03646435f, 0.02822863f, 0.24180892f, 0.19535010f, 0.08000271f, 
    -0.21485603f, 0.03333150f, -0.00216169f, 0.18450150f, -0.00391132f, 0.16567434f, 0.26883802f, 0.27155283f, 
    -0.19101025f, -0.16377072f, 0.00082705f, 0.34462070f, -0.22501136f, 0.09676901f, -0.01973060f, -0.01713452f, 
    0.02426840f, 0.06805578f, 0.06924872f, 0.09667403f, 0.04019666f, 0.17499150f, 0.13615851f, 0.15918526f, 
    -0.13979886f, -0.12365624f, 0.13362819f, -0.21814436f, -0.11429285f, 0.06519622f, 0.07641159f, -0.15826939f, 
    -0.02900932f, 0.08620998f, 0.32245722f, -0.13375723f, -0.18245812f, -0.19710781f, 0.37652242f, 0.10497651f, 
    0.06483511f, 0.11656219f, 0.08501823f, -0.05725739f, -0.51386571f, -0.53507477f, 0.20414118f, -0.18122676f, 
    -0.27609053f, 0.25273451f, -0.03041917f, -0.15192087f, -0.09324920f, 0.03639770f, -0.03829350f, -0.25522777f, 
    -0.16989227f, 0.21559310f, 0.03193365f, -0.15916549f, -0.03953817f, -0.06366958f, -0.03750614f, 0.04913545f, 
    -0.10616153f, -0.27435121f, -0.41592452f, -0.73610008f, -0.28598773f, 0.44468072f, -0.03886511f, 0.21569321f, 
    0.08301527f, -0.05628357f, -0.03213926f, 0.18623763f, -0.04485909f, -0.00285659f, 0.05012617f, -0.26536092f, 
    -0.07876914f, -0.12229062f, -0.30763018f, 0.13877261f, -0.13905524f, -0.02780918f, 0.06001758f, 0.09585174f, 
    0.05528964f, 0.16403250f, 0.02524514f, 0.11461788f, -0.41871518f, 0.08396267f, 0.04932017f, -0.22691165f, 
    -0.31101334f, 0.01404668f, 0.09088842f, -0.01755742f, -0.04027811f, -0.10074658f, 0.25545663f, 0.11562860f, 
    -0.57984579f, -0.10537042f, 0.36436027f, 0.25656468f, 0.06779339f, -0.13400201f, 0.08063149f, 0.00905200f, 
    -0.10549977f, 0.00847670f, -0.04240720f, 0.00937572f, -0.32663909f, -0.05049231f, 0.19029276f, -0.36321548f, 
    -0.16476308f, -0.14515798f, -0.11542566f, -0.05191329f, -0.11115309f, -0.07505312f, 0.06897260f, 0.05762807f, 
    -0.21497357f, 0.09893601f, -0.44788465f, -0.16962171f, 0.11945718f, -0.24858306f, 0.07038639f, -0.05902251f, 
    -0.07454612f, 0.04103716f, -0.01503229f, -0.03986282f, -0.36989057f, -0.12721629f, -0.10348820f, 0.22259514f, 
    -0.01646581f, -0.01521450f, -0.01144624f, 0.03601445f, 0.01189433f, 0.02689142f, -0.06351719f, -0.15912165f, 
    0.05420084f, -0.05123425f, -0.00942644f, -0.00375831f, -0.10480505f, -0.02971480f, -0.12516919f, -0.10498769f, 
    -0.20498414f, 0.11039288f, 0.14198302f, -0.06233519f, -0.14201173f, -0.27117765f, 0.33388609f, -0.98517430f, 
    0.20138691f, -0.03500658f, 0.23305590f, -0.27563959f, 0.02606863f, 0.00897677f, -0.10043824f, 0.02401732f, 
    -0.02406881f, 0.28293648f, -0.13972098f, 0.02225588f, 0.01542656f, -0.05532365f, 0.22106488f, 0.24704470f, 
    -0.03609436f, 0.09670009f, 0.03213270f, -0.40244132f, 0.40042177f, 0.06014269f, 0.31603563f, -0.03501655f, 
    -0.00096610f, -0.01286851f, 0.07605767f, 0.04352247f, -0.34465116f, 0.06122379f, 0.05347945f, -0.16631097f, 
    -0.71687961f, -0.12605745f, -0.54968631f, 0.11550497f, 0.00703308f, 0.02023374f, -0.21751508f, 0.21427813f, 
    -0.16659972f, 0.09484876f, -0.01793283f, 0.02169090f, -0.11755089f, -0.09779161f, -0.11732381f, -0.07357144f, 
    -0.00850508f, 0.16008978f, -0.01441070f, 0.04544741f, -0.05079594f, 0.10618328f, 0.23870569f, -0.02361608f, 
    0.09116207f, -0.33688563f, 0.05396819f, 0.00780503f, -0.01818608f, 0.10118852f, 0.04221574f, 0.00481899f, 
    -0.04132298f, 0.27076089f, -0.04170655f, -0.00730076f, -0.33963355f, 0.14116658f, -0.05259089f, 0.13479814f, 
    0.04641268f, -0.04084466f, 0.19704926f, 0.28417587f, 0.04476142f, 0.25426921f, 0.05456641f, 0.18007532f, 
    -0.29152596f, 0.22065745f, -0.34207934f, 0.50077063f, -0.20884657f, 0.15834366f, 0.33362955f, -0.16325475f, 
    -0.05797794f, 0.01509631f, -0.01711269f, -0.05600492f, 0.00814854f, -0.05647258f, 0.26641029f, 0.10686218f, 
    0.30207494f, 0.36237755f, 0.01566391f, 0.26468363f, -0.11732884f, -0.07546227f, 0.12569430f, -0.13139960f, 
    -0.07992644f, 0.14475006f, -0.38421121f, 0.19082424f, 0.34685731f, -0.16590463f, 0.02838600f, -0.30736735f, 
    0.09470023f, 0.10561003f, -0.04786896f, -0.00194350f, 0.20133239f, 0.15220287f, 0.18971354f, 0.12335933f, 
    -0.22033551f, -0.03965769f, -0.22391471f, -0.04077228f, -0.00781489f, -0.02225324f, 0.10671398f, -0.04565046f, 
    0.32622311f, -0.14761406f, 0.36678779f, -0.26790154f, -0.16540787f, 0.13397531f, -0.03544531f, 0.27726170f, 
    -0.08935399f, 0.08335349f, 0.15791190f, 0.30058348f, 0.07302997f, -0.25707686f, 0.15797876f, -0.43219593f, 
    -0.03251252f, -0.11816010f, 0.01414358f, -0.18460329f, 0.18143143f, 0.17272232f, 0.01651869f, 0.09245770f, 
    -0.58565164f, -0.45875430f, -0.03636833f, 0.02519363f, -0.19207972f, -0.16574736f, -0.04683757f, -0.15012982f, 
    -0.05338243f, -0.10073307f, -0.07682700f, -0.02990022f, -0.13849895f, -0.20286609f, 0.45280549f, -0.31668761f, 
    0.03696336f, 0.04921173f, 0.11696556f, 0.18067929f, -0.03053026f, 0.27745855f, -0.06221024f, -0.23147646f, 
    -0.47681662f, -0.01221770f, -0.03720741f, 0.03769356f, -0.11898448f, -0.02426855f, 0.15156540f, 0.20123631f, 
    -0.25452888f, -0.06358962f, -0.09160202f, -0.16768932f, -0.17794241f, -0.17096372f, 0.23256223f, -0.05374590f, 
    -0.01184658f, -0.24264824f, -0.13691072f, 0.05635061f, 0.10607626f, 0.13651681f, 0.05890536f, -0.07712452f, 
    0.46119800f, 0.09115223f, 0.31435850f, -0.02411796f, 0.08202389f, 0.00209754f, -0.05749380f, 0.06497841f, 
    0.05002435f, 0.00389726f, 0.28493726f, 0.07867917f, 0.05943172f, 0.04068667f, 0.05564920f, -0.02017897f, 
    0.06209224f, 0.26855570f, -0.12228899f, 0.04609901f, -0.15068054f, -0.09050633f, -0.14935899f, -0.24665451f, 
    0.16951817f, 0.19203994f, -0.15352483f, -0.41678709f, -0.22157234f, -0.16370867f, -0.17052254f, -0.18659458f, 
    0.01962288f, 0.04705804f, -0.12610619f, -0.15853857f, 0.66259825f, -0.46857050f, 0.26254985f, 0.32925180f, 
    0.09997987f, 0.02762366f, -0.16595031f, 0.02708471f, -0.22419421f, 0.08886847f, -0.03787293f, 0.16394530f, 
    0.20087217f, 0.03569945f, 0.49394709f, -0.18883757f, 0.07141219f, 0.22877477f, -0.18922909f, 0.15872268f, 
    0.21267927f, -0.16058859f, -0.07190973f, -0.21000236f, 0.39862859f, 0.29943922f, 0.31234217f, -0.36505654f, 
    0.12420490f, -0.01777020f, 0.03718036f, 0.00456860f, 0.00711408f, 0.03781985f, -0.01502012f, -0.08617491f, 
    -0.31373346f, 0.04582408f, -0.45131642f, 0.29862571f, 0.15293241f, -0.04548772f, -0.07662326f, -0.01480975f, 
    0.03899471f, 0.19624345f, 0.26824668f, 0.21655160f, -0.50008196f, -0.28616273f, 0.18580849f, 0.47778293f, 
    0.04082315f, 0.22122487f, 0.13074853f, 0.41454089f, -0.14265420f, -0.20368743f, -0.03037239f, -0.12306509f, 
    -0.15301225f, -0.46556124f, 0.04784038f, -0.05528329f, -0.37480706f, -0.08672946f, -0.20344216f, -0.46417281f, 
    0.01584199f, -0.06446243f, -0.00468044f, -0.03329456f, -0.46586660f, 0.29770812f, -0.45500612f, 0.12986152f, 
    0.00620338f, -0.16140907f, 0.22819494f, -0.03023166f, 0.10734683f, -0.01393570f, 0.01997028f, -0.13620315f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.22997095f, 0.10732858f, 0.06660366f, -0.11056881f, -0.13927186f, 0.07855159f, -0.00120970f, -0.11730616f, 
    0.08707622f, -0.00959309f, 0.04705474f, -0.01244840f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
