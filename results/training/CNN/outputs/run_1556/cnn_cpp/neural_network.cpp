#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.65264428f, 0.25055194f, 0.22686172f, 0.10499409f, -0.41447490f, -0.37287468f, -0.15289688f, 0.31242427f, 
    0.13158745f, -0.71174651f, -0.22446109f, 0.39299676f, 0.26853111f, 0.42685542f, 0.50055838f, 0.14808390f, 
    0.38697916f, 0.52936167f, -0.19834603f, -0.37573937f, 0.63271391f, 0.30354282f, -0.24213313f, 0.58024508f, 
    -0.28840858f, -0.13677426f, -0.43354034f, 0.56017292f, 0.65159976f, 0.25078624f, -0.42172965f, -0.01112892f, 
    0.20347275f, -0.01821978f, -0.31717122f, -0.13272542f, 0.98472309f, -0.73374373f, 0.20065758f, 0.21549441f, 
    -0.38036546f, 0.05922591f, 0.32168022f, -0.06368000f, -0.28030083f, 0.49649006f, -0.12855084f, 0.02597505f, 
    -0.67333764f, -0.39130697f, -0.59329838f, -0.29485562f, 0.97855234f, -0.43027118f, 0.01626335f, -0.94186455f, 
    -0.74344933f, 0.76863855f, 0.82860500f, -0.26315650f, -0.25016266f, -0.05158047f, -0.32946882f, 0.40235451f, 
    0.85107905f, -0.42768022f, -0.64073670f, 0.00921599f, 0.35086414f, -0.06135816f, 0.12126553f, 0.50742549f, 
    0.06168207f, -0.05353910f, 0.27996799f, -0.02664767f, -0.29189530f, -0.75862652f, -0.37312967f, -0.46348727f, 
    -0.37859091f, -0.51686054f, -0.52091813f, 0.84673548f, -0.18289047f, -0.63054490f, -0.57115036f, 0.53009480f, 
    -0.15483740f, 0.06773107f, -0.87753409f, 0.97484279f, -0.21889237f, -0.11903763f, 0.37849876f, -0.16711771f, 
    -0.44254819f, 0.08433639f, -0.01791861f, -0.71732688f, -0.69701618f, -0.76686597f, 0.21810721f, 0.55645877f, 
    0.49754626f, 0.11365274f, 0.57853943f, -0.03923918f, -0.86364251f, 0.21358374f, 0.03046754f, -0.27960515f, 
    -0.38611171f, -0.02177069f, 0.02953230f, -0.18160148f, -0.26393539f, 0.45354298f, -0.32059312f, 0.72103947f, 
    -0.62743551f, 0.15782785f, -0.04242285f, -0.04784660f, 0.19976337f, 0.54637158f, 0.21436536f, 0.24150698f, 
    0.42507380f, 0.35775864f, 0.18080734f, -0.10520200f, 0.16991974f, -0.42744315f, -0.35418969f, -0.54061848f, 
    0.52607358f, 0.76033145f, -0.01373809f, 0.13827263f, -0.56204098f, 0.07936221f, -0.17177404f, 0.39682776f, 
    -0.23848829f, -0.25333396f, -0.36480352f, -0.05698173f, 1.16158950f, -0.03115101f, -0.20912799f, -0.50393689f, 
    -0.18873081f, -0.28155699f, 0.50642854f, 0.44737700f, -0.00561558f, 0.19318895f, 0.59561765f, 0.00325404f, 
    0.49210489f, -0.02370741f, -1.30971062f, 0.89052862f, -0.18821819f, -0.91177839f, -0.06737643f, 0.88882470f, 
    0.09858818f, -0.06203838f, -0.08552312f, -0.35343936f, 0.27960652f, -0.00719710f, 0.61168772f, 0.64579147f, 
    0.50512642f, 0.11985332f, 0.04442048f, 0.04081973f, -0.77976298f, -0.61256814f, -0.32748434f, -0.08447327f, 
    -0.04223917f, -0.30474538f, 0.17302640f, -0.43557730f, -0.37901458f, -0.56613106f, -0.39505357f, -0.05091187f, 
    -0.44489643f, -0.54618996f, -0.39186040f, -0.11160969f, 0.49133375f, -0.18917190f, -0.29463646f, 0.10347530f, 
    -0.76876009f, 0.09501408f, -0.39775249f, -0.57085621f, -0.52033943f, -0.05125656f, -0.02809844f, -0.21954316f, 
    -0.49288335f, -0.08592589f, -0.24632305f, 0.91806817f, -1.20928574f, -0.00144888f, -0.24445252f, 0.01065818f, 
    0.68454266f, -0.36828417f, -0.28202614f, 0.13996097f, 0.04065424f, 0.23045398f, -0.33812514f, -0.14437796f, 
    -0.57427824f, 0.15725546f, 0.17651556f, 0.43777207f, 0.33644769f, -0.57540298f, -0.64968711f, -0.28941202f, 
    0.30705085f, -0.27407917f, 0.32121485f, 0.25112185f, -0.23666219f, -0.77610296f, -0.49787945f, -0.26997432f, 
    -0.15644710f, -0.47417784f, -0.36189353f, 0.13085556f, -0.16420820f, 0.16806762f, -1.02111816f, 1.10144448f, 
    -0.13738519f, -0.33214104f, 0.43040183f, -0.36684868f, 0.05843712f, -0.15809928f, -0.29227501f, -0.31357199f, 
    -0.22254835f, -0.36414930f, 0.57267183f, -0.27656800f, 0.72560298f, -0.07693781f, 0.02468398f, 0.12635696f, 
    0.11112694f, 0.08173610f, 0.43780148f, 0.59201872f, -0.57887250f, -0.48793355f, -0.23383515f, 0.12773748f, 
    -0.10063213f, -0.50348759f, -0.40860888f, -0.43324634f, 0.53285539f, 0.58783883f, 0.58578801f, 0.28370407f, 
    -0.30162179f, 0.25053594f, 0.01365863f, 0.63695216f, -0.50863379f, 0.33466431f, -0.30760816f, 0.38023862f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12835769f, 0.07309334f, 0.05143492f, 0.08681998f, 0.28180686f, -0.18793093f, -0.09956428f, 0.49263257f, 
    -0.00599822f, 0.30274215f, 0.40345916f, 0.15532486f, -0.00377050f, 0.03249228f, 0.10283233f, 0.20075063f, 
    -0.27299249f, -0.06795491f, 0.20215793f, 0.24308810f, -0.23767869f, -0.30638340f, 0.46029696f, 0.48308966f, 
    0.09390325f, 0.02166742f, -0.16098320f, -0.15937223f, 0.10858101f, 0.08441582f, -0.04168542f, 0.14677812f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.05102706f, -0.02758308f, 0.01313922f, 0.01394233f, -0.02838414f, -0.01729076f, 0.00743505f, -0.01389467f, 
    0.02470878f, 0.03714081f, -0.00898436f, -0.04217198f, 0.04481518f, -0.04145985f, 0.03418675f, -0.03238484f, 
    0.00247470f, -0.06443146f, -0.01289845f, -0.03901114f, 0.05944078f, -0.04028338f, -0.00973675f, -0.05915735f, 
    0.04399506f, 0.02721227f, -0.03560799f, -0.01408890f, -0.04233158f, 0.00968341f, -0.01407998f, 0.01736667f, 
    -0.03111759f, -0.05248085f, 0.04092083f, 0.00311954f, 0.00827683f, -0.03071917f, 0.05600706f, -0.03461117f, 
    -0.04174421f, 0.04683452f, 0.00845606f, 0.02722745f, 0.00286353f, -0.04683824f, -0.01242005f, 0.05659013f, 
    -0.00743614f, -0.04100540f, 0.05014575f, -0.00565075f, -0.03532356f, -0.02647600f, -0.03425007f, -0.01004457f, 
    0.00426021f, -0.06663081f, -0.04120021f, -0.05193739f, 0.02490026f, -0.03203113f, -0.00784074f, -0.01867975f, 
    -0.06275508f, 0.00706501f, 0.03054447f, 0.03756713f, 0.00403299f, 0.03995040f, 0.02104464f, -0.01987703f, 
    -0.06305465f, 0.00620865f, -0.04961615f, 0.04814205f, 0.01176861f, -0.05814211f, -0.05197282f, 0.02462173f, 
    0.02255145f, 0.00218322f, -0.01359588f, -0.02732993f, 0.01159318f, 0.03810061f, 0.01877117f, -0.03919005f, 
    -0.04295804f, -0.03607275f, -0.02008808f, -0.03675791f, -0.01118364f, 0.02643100f, -0.00242974f, -0.02603955f, 
    0.04361411f, -0.06250786f, 0.03125004f, 0.04450899f, 0.02192749f, -0.05059315f, -0.05347462f, -0.00924406f, 
    -0.00998273f, 0.01041848f, -0.01191310f, -0.03064432f, -0.02662356f, -0.06536824f, -0.00045507f, 0.03904701f, 
    0.00028509f, 0.04355412f, 0.04045330f, -0.03857765f, -0.03672733f, -0.02005282f, -0.05288097f, -0.01902668f, 
    -0.06144377f, -0.06749124f, 0.04199165f, -0.00628948f, 0.01427195f, 0.04123097f, 0.02203953f, -0.04513549f, 
    0.01627819f, -0.05406306f, 0.00021759f, 0.02334899f, -0.02227904f, -0.06236675f, 0.02339701f, -0.05606178f, 
    0.00392825f, -0.00059916f, 0.00474657f, -0.04359487f, -0.05725750f, -0.01664837f, -0.01293723f, -0.02058283f, 
    0.02143530f, 0.01424210f, 0.00111641f, -0.06608482f, -0.05979268f, -0.04957371f, 0.02873454f, -0.03472304f, 
    -0.01402528f, -0.04285175f, -0.00701468f, 0.00559831f, 0.02431232f, -0.00142865f, 0.03281610f, -0.06518184f, 
    -0.03272082f, 0.01231517f, 0.00483647f, -0.03326809f, 0.01814634f, 0.02529141f, -0.04707032f, -0.05992053f, 
    -0.06460010f, 0.01928524f, 0.01354081f, 0.02437384f, -0.06980192f, -0.04686804f, -0.02262085f, -0.02009933f, 
    -0.05112245f, -0.02571981f, 0.01574916f, 0.04240201f, 0.03520567f, 0.03829324f, -0.05298437f, 0.00891761f, 
    -0.01293282f, -0.05281053f, 0.03501372f, 0.02552651f, 0.01012458f, -0.06963237f, -0.04869263f, -0.03819912f, 
    -0.06469342f, -0.01889414f, -0.01213650f, 0.01449341f, 0.02914136f, -0.01911881f, 0.01317398f, -0.00470792f, 
    0.03286557f, -0.05038947f, 0.02888598f, 0.03746023f, -0.01473468f, -0.01081828f, -0.03019334f, -0.03030640f, 
    -0.00755190f, -0.00290893f, 0.02951942f, 0.00242259f, 0.02599702f, 0.00729850f, -0.05115755f, -0.04568132f, 
    -0.02828882f, 0.03853136f, -0.00099029f, 0.00006196f, 0.02898661f, -0.01062926f, 0.02212861f, 0.00810609f, 
    -0.04094929f, -0.03725615f, 0.02731357f, 0.05466090f, 0.02777239f, -0.03790185f, -0.05104802f, 0.03956725f, 
    0.04025250f, -0.04923636f, -0.04991999f, -0.00430280f, 0.01933281f, -0.01384815f, -0.03543754f, 0.00811543f, 
    -0.01418654f, 0.04523108f, 0.00322194f, -0.02852215f, -0.06208987f, -0.04344476f, 0.02909756f, -0.03943934f, 
    0.04797458f, -0.06280174f, -0.06114294f, -0.02319171f, 0.01509423f, -0.06053043f, 0.03643649f, -0.05371906f, 
    0.04174946f, -0.02981915f, -0.04784177f, -0.03414711f, 0.04656677f, -0.01167284f, 0.02304828f, 0.04620998f, 
    0.02106100f, 0.03201395f, -0.06578523f, 0.04123396f, 0.02486189f, 0.00653659f, 0.03278253f, -0.04395901f, 
    -0.03850355f, -0.03244175f, -0.00379863f, -0.05523787f, 0.03215465f, 0.01043882f, -0.03767844f, 0.04264751f, 
    0.04343034f, -0.01403485f, -0.00111955f, 0.04090001f, -0.00036970f, -0.01375698f, 0.01871264f, 0.02746880f, 
    0.01851987f, -0.09482593f, 0.05726402f, -0.05218731f, 0.02811758f, 0.02388687f, -0.21646500f, -0.05638109f, 
    -0.07379310f, 0.04944945f, 0.00836457f, 0.08267177f, 0.07716776f, -0.07466419f, -0.20809014f, -0.00963268f, 
    -0.00273429f, 0.07007735f, -0.10898416f, -0.05816126f, 0.08090829f, 0.24101019f, 0.11299246f, 0.08549054f, 
    -0.21437640f, -0.42288858f, -0.34462643f, 0.08702294f, -0.08425331f, 0.00074983f, 0.06635354f, 0.03297674f, 
    0.12713845f, -0.30873454f, -0.04469318f, -0.20406289f, 0.28152749f, 0.10442148f, -0.15739392f, 0.20825544f, 
    -0.09456339f, 0.13368751f, -0.11437878f, -0.01858784f, 0.03425536f, -0.18348770f, 0.03101479f, -0.09742843f, 
    0.01511820f, 0.14041059f, 0.08866495f, 0.00552552f, -0.02014567f, 0.04758076f, 0.00170043f, -0.00195660f, 
    -0.30292374f, 0.14937173f, 0.02507375f, 0.02308009f, -0.10931443f, -0.23014992f, -0.04154992f, 0.07050247f, 
    -0.05643317f, 0.10125404f, -0.07616369f, 0.08786011f, 0.00334322f, -0.07896020f, -0.11297371f, -0.00637914f, 
    0.07646544f, -0.00207920f, -0.15760621f, -0.00045744f, 0.00095988f, 0.02240762f, 0.01895281f, -0.05994077f, 
    -0.43542704f, 0.07691580f, 0.11853429f, -0.14720789f, 0.17290017f, 0.04119417f, 0.14537922f, 0.02384432f, 
    0.07354045f, -0.03937480f, -0.14320634f, 0.08726461f, 0.18300939f, 0.00409306f, 0.00090235f, 0.06668730f, 
    0.00414633f, -0.07637443f, -0.06915770f, 0.13389550f, 0.14709225f, -0.00338732f, 0.00761013f, 0.06437513f, 
    -0.10841949f, -0.09293392f, 0.02392132f, 0.00086104f, -0.08570105f, 0.00370905f, 0.11951987f, -0.00763883f, 
    0.02164921f, 0.12876302f, 0.05104557f, 0.04725256f, -0.22114560f, -0.05360496f, -0.03722879f, 0.20913334f, 
    0.03442977f, 0.05100376f, -0.06137691f, 0.05293991f, -0.03898220f, 0.05463101f, 0.03135878f, -0.03845824f, 
    -0.00860452f, 0.03125074f, 0.02676102f, 0.06752663f, -0.22993834f, -0.24725734f, -0.21549024f, 0.00104007f, 
    -0.15439421f, 0.12716812f, 0.08350339f, -0.14875405f, 0.11821981f, -0.13448013f, 0.02439226f, -0.18791161f, 
    -0.03635952f, 0.01140701f, 0.04064215f, 0.05781726f, 0.07044209f, -0.03322975f, -0.26933777f, -0.38765246f, 
    -0.13220976f, 0.02626680f, -0.09707056f, -0.00668810f, -0.09995202f, -0.16552629f, -0.00063755f, -0.06631164f, 
    0.02820142f, -0.12627122f, -0.03463929f, -0.01382537f, 0.15463166f, 0.16180666f, -0.06447429f, 0.15934339f, 
    0.00725705f, 0.06985594f, -0.12012836f, -0.01284077f, -0.02140929f, -0.02995339f, 0.32275808f, 0.18937111f, 
    0.10535731f, -0.02166096f, -0.09962920f, -0.03002578f, -0.09986952f, -0.06245780f, -0.02975500f, 0.00963931f, 
    -0.09540667f, -0.04209894f, -0.01757088f, 0.06067444f, 0.14507574f, -0.08188021f, -0.02792778f, -0.15039916f, 
    0.02374480f, 0.05033090f, 0.05772882f, 0.09779433f, -0.01833685f, -0.02181329f, 0.05293136f, 0.19592115f, 
    0.07106739f, 0.02708901f, -0.03797352f, 0.01941596f, 0.03804442f, -0.00069613f, 0.15633346f, 0.20940557f, 
    -0.01879567f, 0.11696593f, 0.03051164f, 0.03542328f, -0.04894918f, 0.01676258f, -0.00302412f, 0.21230896f, 
    -0.01708604f, -0.00327284f, 0.04397776f, 0.04924414f, 0.12430528f, 0.13800119f, -0.23521651f, -0.20617823f, 
    -0.22230870f, -0.02480677f, -0.04852545f, -0.09000528f, 0.11408313f, 0.07910614f, 0.09313187f, -0.07621912f, 
    -0.07577054f, -0.32408485f, 0.16115698f, 0.10221680f, 0.01516940f, 0.10438624f, 0.07197610f, 0.01545312f, 
    -0.01694076f, 0.00464596f, -0.15975866f, 0.10657106f, 0.09358381f, 0.17507486f, 0.21258219f, 0.21505825f, 
    0.12475525f, -0.12036111f, -0.00249890f, 0.06110428f, -0.00742397f, -0.13049653f, 0.05136427f, -0.04362854f, 
    0.00529857f, 0.04926889f, 0.13342544f, 0.07069815f, 0.04517238f, 0.05535243f, -0.03193177f, -0.07619672f, 
    0.07228558f, 0.01241862f, 0.03280654f, -0.27316609f, -0.30555561f, -0.22338417f, -0.17980902f, 0.04402424f, 
    0.13233536f, -0.24833944f, 0.03076962f, -0.15636842f, 0.12057155f, 0.14844377f, 0.04380518f, 0.04498703f, 
    -0.07384048f, 0.04437374f, -0.13576953f, -0.09738298f, 0.12748668f, -0.03477190f, 0.03772917f, 0.17694795f, 
    -0.26735806f, -0.25238368f, -0.15378606f, 0.01313950f, 0.14938211f, 0.02695705f, 0.02270591f, 0.00356468f, 
    -0.05865793f, -0.08228193f, -0.15735769f, -0.27084425f, 0.12376809f, 0.02693821f, -0.00440046f, 0.10522832f, 
    0.08304869f, 0.04597113f, 0.11493395f, 0.00129233f, -0.12253236f, -0.01076403f, 0.07617307f, -0.12907249f, 
    -0.05521113f, -0.02873061f, 0.06822585f, -0.11374842f, -0.07878543f, -0.00824670f, 0.14560334f, 0.06318501f, 
    -0.11698167f, 0.05354415f, 0.08681413f, 0.20232019f, -0.36806816f, 0.16350126f, -0.13266647f, 0.23182020f, 
    0.08075792f, -0.09017587f, 0.09984366f, -0.02492285f, 0.02126423f, -0.25874826f, 0.20013441f, 0.27553320f, 
    0.07969784f, -0.09362910f, -0.09600708f, 0.01116163f, -0.03583793f, 0.05343853f, 0.14211093f, 0.27464369f, 
    -0.14296886f, 0.00475834f, -0.04068049f, 0.03330554f, -0.10160622f, -0.06923002f, 0.02465993f, 0.02100959f, 
    -0.06473623f, -0.37731346f, -0.09691335f, -0.00882547f, -0.01141707f, 0.05577710f, 0.06600949f, 0.02360263f, 
    -0.00454627f, -0.01696129f, 0.12548286f, -0.11131154f, -0.00767534f, 0.00350287f, -0.08104408f, -0.01081707f, 
    -0.04130457f, 0.20974234f, 0.24007653f, 0.24592313f, -0.02762386f, -0.16956946f, -0.04973849f, 0.16524042f, 
    -0.02844651f, 0.09279228f, 0.09524129f, 0.13401337f, -0.06895433f, -0.11513551f, -0.12434088f, 0.09546128f, 
    -0.04384681f, -0.20567434f, -0.11646426f, -0.27002937f, -0.26885211f, -0.21328202f, 0.28373981f, 0.20335622f, 
    0.23086785f, 0.02121840f, -0.04113994f, 0.14667705f, 0.04477088f, 0.11389973f, 0.24641527f, 0.09121452f, 
    -0.22329733f, -0.03146166f, 0.02743884f, 0.01958284f, -0.05547867f, 0.08245680f, -0.16897790f, -0.42600730f, 
    0.07825421f, -0.09518152f, 0.01178833f, 0.08154408f, 0.20667572f, 0.05864207f, 0.09289441f, -0.04719463f, 
    0.05797326f, 0.07801106f, 0.04064301f, -0.15270451f, -0.00746595f, -0.09173054f, 0.09163345f, 0.15399483f, 
    0.21790461f, -0.00673392f, -0.04731485f, -0.06070502f, -0.04996269f, 0.09422826f, 0.07782523f, 0.07571162f, 
    0.23204316f, -0.14070946f, -0.03039205f, -0.03172604f, -0.09770072f, 0.22690149f, -0.08230455f, 0.21643309f, 
    -0.07159234f, 0.03736978f, -0.12905589f, -0.27217004f, 0.00617683f, -0.08600470f, -0.06873749f, -0.08429211f, 
    -0.01257332f, 0.13402154f, 0.20211722f, -0.04747839f, -0.12182431f, 0.11792026f, -0.09716220f, 0.16762009f, 
    -0.01573431f, 0.01444364f, -0.08232056f, -0.02374836f, -0.12686594f, -0.34496462f, 0.05541864f, 0.01967042f, 
    0.10047997f, -0.09733430f, -0.07255214f, 0.06910830f, -0.02452640f, -0.15808158f, 0.21950425f, 0.25336248f, 
    -0.10096462f, -0.03352110f, -0.00716188f, -0.01574520f, 0.00306692f, -0.04555282f, 0.11004596f, 0.24876574f, 
    0.20368305f, -0.06989699f, 0.01372757f, 0.12016786f, 0.02661351f, 0.05345613f, 0.18692826f, 0.04468116f, 
    0.07261722f, -0.16612071f, -0.08256000f, -0.13530521f, -0.06331652f, -0.09480484f, -0.14550434f, -0.02111335f, 
    0.06111155f, 0.13448532f, -0.11680367f, 0.02906399f, -0.06712084f, 0.02886195f, -0.03786651f, -0.13403152f, 
    0.11083817f, 0.19727513f, 0.07922865f, -0.06168065f, 0.06997827f, -0.21354796f, 0.04560835f, -0.01479181f, 
    0.01955183f, -0.23125975f, -0.23638214f, 0.11865035f, -0.11602147f, -0.03801123f, 0.06394096f, 0.04228050f, 
    -0.02453900f, 0.03835690f, -0.05638275f, -0.08534632f, -0.00994848f, -0.04141303f, -0.07697111f, -0.01678337f, 
    -0.02393739f, -0.04502559f, 0.00140234f, -0.05085604f, -0.12300621f, 0.04027054f, -0.03723900f, -0.06603168f, 
    0.10724879f, -0.19567856f, 0.01102031f, 0.08384036f, 0.26716146f, 0.18015932f, 0.18708827f, 0.01907058f, 
    -0.05178236f, 0.06863096f, 0.30360946f, 0.09031224f, 0.02342260f, -0.15470208f, 0.00135631f, -0.26416054f, 
    0.08953784f, 0.03050260f, -0.08873426f, 0.01640119f, 0.01735412f, 0.16955337f, 0.26344758f, 0.24194156f, 
    0.05868595f, 0.02259941f, 0.04659010f, 0.17877491f, 0.08975995f, 0.05290635f, 0.00503612f, 0.01684179f, 
    -0.11557959f, -0.20109211f, 0.12063406f, 0.02162489f, -0.05098717f, 0.16903624f, 0.03033969f, 0.00252725f, 
    -0.10554218f, -0.23199096f, -0.12218354f, -0.05802753f, -0.12416299f, -0.03996312f, 0.02900519f, 0.10820769f, 
    0.03207231f, -0.04118308f, -0.14835690f, -0.04740513f, 0.04001045f, -0.02295082f, 0.05705218f, -0.00753028f, 
    0.02981739f, 0.00358768f, -0.06824178f, -0.04249802f, 0.14490126f, -0.11017787f, -0.04209650f, -0.08364192f, 
    0.14443757f, -0.01787967f, -0.05968932f, 0.08514713f, -0.19613482f, 0.02175276f, 0.08114681f, -0.08065080f, 
    -0.02704710f, 0.09696089f, 0.04054292f, 0.14311622f, 0.04596072f, -0.17339253f, -0.20102955f, -0.02560959f, 
    0.07275379f, 0.09276477f, -0.00916791f, 0.04594345f, 0.06961865f, -0.11791562f, -0.01345328f, -0.00742478f, 
    -0.38134933f, -0.02717113f, -0.22032133f, -0.01770815f, 0.02906490f, 0.17919649f, 0.29730475f, -0.19430113f, 
    -0.31617233f, -0.01873939f, -0.09706479f, -0.15853822f, 0.11819036f, 0.04163468f, 0.00425082f, 0.01859987f, 
    -0.23296049f, -0.13124423f, -0.06816895f, 0.00156525f, 0.07880280f, 0.01442925f, 0.10790163f, 0.08245731f, 
    -0.15692188f, 0.07028051f, -0.01310930f, -0.02877477f, -0.02268930f, -0.08758938f, 0.08997293f, 0.03370160f, 
    -0.01542453f, 0.04413265f, 0.17168906f, -0.00631834f, -0.10969101f, 0.12716185f, 0.00083437f, -0.06352630f, 
    0.11591446f, 0.15454347f, -0.61086792f, 0.07745097f, -0.10368221f, -0.07623187f, 0.08774573f, -0.02610864f, 
    0.06171481f, 0.05858092f, 0.11315977f, 0.05313283f, -0.23395595f, -0.14461617f, 0.11889971f, 0.13998808f, 
    0.10347001f, -0.02919749f, 0.08151619f, 0.05179204f, -0.11519369f, 0.09118284f, 0.13052218f, 0.06315363f, 
    -0.03083463f, 0.08357646f, 0.09836107f, 0.06965887f, -0.03070995f, -0.05712634f, -0.06071664f, -0.17694519f, 
    -0.22054945f, 0.03134995f, -0.03951317f, -0.03776327f, 0.01087287f, 0.03299551f, 0.00152693f, -0.01659544f, 
    -0.03533445f, 0.04601816f, 0.00170338f, -0.13681173f, 0.04846811f, -0.07045177f, -0.00156191f, -0.33061206f, 
    0.07072161f, -0.13619483f, -0.06333078f, -0.09012324f, -0.05777018f, -0.00847100f, 0.13071124f, -0.04738377f, 
    0.18045205f, 0.01497677f, -0.07776617f, 0.00080791f, -0.13354740f, -0.09972169f, 0.01816729f, 0.02942605f, 
    -0.03519734f, -0.15433861f, -0.10836312f, -0.10747981f, -0.02457052f, -0.06036840f, 0.02161056f, -0.07206737f, 
    -0.04785864f, 0.15225559f, -0.80650544f, -0.07094360f, 0.17760633f, -0.05897665f, -0.17817546f, 0.07688495f, 
    0.06714107f, 0.07720999f, -0.03336029f, -0.02780090f, -0.07465532f, -0.03617737f, 0.01965865f, -0.02708360f, 
    -0.07765134f, 0.06516100f, 0.07052813f, 0.13456327f, 0.32369131f, 0.14599277f, -0.02094900f, -0.04078374f, 
    0.08285348f, -0.01784441f, 0.11927305f, -0.02764402f, 0.06016312f, 0.01677921f, 0.10636438f, 0.25085184f, 
    -0.15677455f, -0.08149512f, -0.10490040f, 0.15796478f, 0.07543394f, 0.13128382f, 0.03507904f, 0.18813019f, 
    0.09026425f, -0.00479743f, 0.16842590f, 0.12418097f, 0.00877045f, -0.05790601f, -0.05333113f, 0.21049963f, 
    0.01962323f, 0.03042206f, -0.03928382f, -0.04242979f, 0.09501722f, 0.09179740f, 0.00499947f, 0.02627972f, 
    0.34733218f, 0.09992192f, 0.21203567f, -0.06662861f, 0.00664226f, -0.02439630f, 0.07118512f, 0.03450069f, 
    0.04950074f, -0.22492148f, -0.04547789f, -0.00517372f, -0.12773640f, -0.12718378f, 0.02806382f, 0.04132537f, 
    0.12772632f, 0.06929947f, -0.12453432f, 0.08241060f, 0.01664144f, 0.09652168f, 0.01570768f, 0.04815827f, 
    -0.04154783f, -0.00207936f, 0.12430426f, -0.04334896f, -0.07193649f, 0.32125697f, -0.21148954f, -0.08451656f, 
    -0.04988412f, -0.38307369f, 0.21619691f, 0.07953837f, 0.07233340f, 0.33822373f, 0.05571744f, -0.15011077f, 
    -0.06425190f, -0.17259516f, -0.09869057f, 0.06676028f, 0.02547774f, -0.28257048f, 0.04411827f, 0.02260425f, 
    0.04497988f, -0.04829916f, -0.18438181f, -0.00621226f, 0.16771249f, 0.05149625f, 0.25184149f, 0.12020555f, 
    0.08554580f, 0.00704089f, 0.06724561f, 0.06673271f, 0.03790920f, -0.03707374f, 0.03932301f, -0.13102217f, 
    0.02813740f, -0.03074534f, -0.00862125f, -0.00381006f, 0.02918071f, -0.01351587f, 0.05575522f, 0.05542893f, 
    -0.00646132f, 0.04126080f, 0.01616856f, -0.05775259f, -0.01106909f, -0.04620823f, 0.00124374f, -0.05839171f, 
    0.04875788f, -0.03701274f, -0.02417514f, -0.05738081f, -0.04818610f, -0.00795924f, -0.00347272f, 0.04527580f, 
    -0.01692498f, 0.03373432f, -0.04268388f, -0.01328063f, 0.00936712f, -0.00871795f, -0.01057842f, 0.00257083f, 
    -0.01908934f, -0.04084215f, -0.06252569f, -0.03406762f, -0.00881788f, -0.03516611f, 0.02357050f, -0.01185596f, 
    -0.05837607f, 0.04579221f, 0.03715182f, -0.05313097f, -0.03762836f, -0.04125804f, -0.05043785f, -0.06160165f, 
    0.01332379f, -0.06202762f, 0.00029736f, -0.04417490f, 0.03875539f, 0.03171835f, -0.00095972f, 0.04394080f, 
    -0.00167606f, -0.02948323f, -0.00122260f, 0.01645159f, -0.02671309f, 0.04279209f, -0.05919591f, 0.01892675f, 
    0.01893951f, -0.01761418f, 0.00999487f, 0.00851615f, -0.03618691f, 0.00114557f, 0.04841699f, -0.02335662f, 
    0.03061419f, -0.04840697f, -0.05457216f, -0.06208508f, 0.02685799f, -0.05922546f, 0.00123549f, 0.03126226f, 
    -0.06221805f, -0.04912895f, 0.01200723f, -0.00271837f, 0.03182814f, -0.02368234f, -0.02188815f, -0.05016914f, 
    -0.03655071f, 0.00045859f, 0.02757453f, 0.00829100f, 0.00836941f, -0.00425312f, -0.04941300f, 0.03335463f, 
    -0.03279499f, 0.04763659f, 0.03036763f, -0.01396750f, -0.05894091f, -0.05638139f, -0.06486668f, -0.02622583f, 
    -0.00303134f, 0.00987969f, -0.05949808f, 0.03155616f, -0.02416794f, 0.01966189f, 0.01463985f, -0.03922446f, 
    0.04610692f, -0.03467898f, -0.04588840f, 0.02206407f, 0.04062574f, 0.04816951f, -0.01135990f, -0.04926071f, 
    0.00919652f, 0.02651266f, -0.05091808f, 0.02474073f, 0.00486993f, -0.00442052f, -0.03547191f, 0.01619452f, 
    -0.04797265f, 0.01447933f, 0.03322422f, 0.02322413f, -0.00280656f, -0.05444466f, -0.04599071f, -0.06361234f, 
    -0.04320978f, -0.01281619f, -0.05558627f, -0.05520745f, -0.01122612f, -0.01789940f, 0.01032338f, -0.04249922f, 
    0.02612825f, 0.00407181f, 0.02792944f, 0.03720453f, 0.03561589f, 0.00798774f, -0.02299221f, -0.06389195f, 
    -0.00610109f, 0.00369534f, -0.00867109f, -0.05023188f, -0.02182288f, 0.04532179f, 0.03791752f, 0.02806406f, 
    -0.04188236f, -0.04112592f, -0.01772113f, 0.02168741f, -0.01455494f, -0.05541605f, 0.00638000f, 0.03438736f, 
    -0.02261425f, -0.03754061f, -0.03177622f, -0.02045583f, -0.04656738f, 0.01480155f, -0.00435470f, 0.03861462f, 
    -0.05669849f, 0.05078183f, -0.00575171f, 0.01050089f, -0.03431905f, -0.03855981f, 0.03540164f, 0.02827412f, 
    0.04611723f, -0.00066270f, -0.02546722f, -0.04708811f, -0.06345477f, 0.03338931f, -0.04031932f, 0.03332863f, 
    -0.04017164f, -0.03873474f, 0.00097382f, 0.00793442f, -0.04636300f, 0.02925782f, 0.01618304f, 0.03194773f, 
    -0.01297622f, 0.04648975f, 0.04420295f, -0.04565512f, -0.05342492f, -0.02230042f, -0.03756954f, -0.05178354f, 
    -0.02421012f, -0.03160329f, 0.04092262f, 0.02534064f, -0.05118135f, -0.04347324f, 0.04494294f, -0.02987340f, 
    0.05209567f, -0.01139129f, -0.04326528f, -0.01166112f, 0.01811703f, 0.02949440f, -0.03185239f, 0.01860029f, 
    0.02608606f, -0.01989699f, -0.02843924f, -0.01041021f, -0.02398730f, 0.02279277f, -0.01988256f, -0.03183788f, 
    -0.02249036f, 0.04949627f, 0.01211778f, 0.03844739f, -0.04705398f, -0.02338195f, 0.01490239f, 0.02824616f, 
    -0.05113716f, -0.05703881f, -0.06004017f, 0.00279138f, 0.01246510f, -0.05521892f, -0.03026872f, -0.04315840f, 
    0.00550478f, 0.02691738f, -0.04651102f, 0.02772300f, -0.05381025f, 0.04982162f, -0.00553529f, -0.04313171f, 
    -0.05009830f, 0.02464753f, 0.00974332f, 0.04688986f, -0.03866135f, -0.02411582f, -0.00779232f, -0.00490651f, 
    -0.03734885f, -0.03260671f, -0.04543772f, -0.02322580f, -0.04046815f, -0.05625700f, -0.00602606f, 0.02573612f, 
    -0.00079329f, -0.02609576f, -0.00362137f, -0.04098450f, 0.00006723f, -0.00798385f, 0.01636207f, 0.03828075f, 
    0.01581280f, 0.04076225f, 0.02067871f, -0.05068636f, -0.01389493f, 0.02373122f, -0.00889083f, -0.03468960f, 
    0.00950435f, 0.04141446f, 0.04033883f, -0.00800512f, 0.03872373f, 0.01564244f, -0.01756136f, -0.05427358f, 
    0.14424562f, -0.07659407f, -0.03175860f, -0.11407784f, 0.11120769f, -0.11442577f, 0.07495432f, 0.04537367f, 
    0.14982200f, -0.04370590f, 0.00650508f, -0.27314189f, -0.02000812f, -0.01997038f, 0.02753896f, 0.10156906f, 
    0.15068683f, 0.10607672f, 0.11827846f, -0.14957023f, -0.10864943f, 0.03325144f, -0.07158111f, 0.26660159f, 
    -0.16829498f, -0.11162944f, -0.24994785f, 0.11523747f, -0.08375736f, -0.22639710f, 0.05367645f, 0.13413286f, 
    -0.08566834f, 0.04597354f, -0.16418806f, 0.06177821f, 0.43559799f, -0.02046849f, -0.23967391f, -0.05536538f, 
    0.05252913f, 0.06976877f, 0.08175506f, -0.17091939f, 0.27846962f, 0.05374752f, -0.16683391f, -0.14529577f, 
    -0.01651034f, 0.04368490f, 0.07422832f, 0.00180586f, 0.05350101f, 0.09107256f, -0.35809264f, 0.00378877f, 
    0.22248913f, -0.08459780f, 0.15881312f, 0.14381260f, -0.01175611f, 0.08933751f, -0.01568575f, 0.50116831f, 
    0.10424274f, -0.43514895f, 0.02583593f, 0.02561568f, 0.18430731f, 0.16513553f, 0.18595238f, -0.00510110f, 
    0.04320972f, -0.08170687f, 0.13197798f, 0.04254628f, 0.05198265f, 0.00890332f, 0.01832550f, 0.03868881f, 
    -0.11944138f, 0.15232396f, -0.04640727f, 0.15617199f, 0.07008490f, 0.00342045f, 0.12068043f, 0.15205804f, 
    0.08236373f, 0.03540318f, -0.28085434f, 0.36417517f, -0.14968376f, 0.01055761f, 0.08676726f, 0.21440005f, 
    0.07590423f, -0.05464637f, -0.03362379f, -0.09353868f, 0.04565962f, 0.01545797f, -0.03381757f, 0.11146411f, 
    0.23315132f, 0.07911582f, 0.05411350f, 0.05712625f, -0.32951689f, -0.04553093f, 0.24812545f, -0.04233721f, 
    0.07152896f, 0.12532818f, 0.08852391f, 0.10506345f, 0.04300102f, 0.19849393f, -0.17999563f, -0.59264821f, 
    -0.02826495f, -0.03717474f, -0.00949212f, 0.06592318f, 0.13869956f, 0.05423969f, 0.00606278f, 0.00095349f, 
    -0.09294045f, -0.08398889f, -0.09884002f, -0.08209249f, 0.06319404f, -0.08778009f, -0.02616118f, -0.09961976f, 
    -0.58067662f, 0.02117041f, -0.00105139f, -0.03068811f, -0.12637894f, 0.16364238f, -0.08360496f, -0.20852350f, 
    -0.63575864f, -0.21706429f, -0.00204631f, -0.14640163f, 0.10402635f, 0.00880369f, -0.11529891f, -0.02553064f, 
    0.10299271f, 0.07170197f, -0.07084893f, -0.32291672f, -0.00482093f, -0.00836487f, -0.19312263f, -0.09275819f, 
    0.12804487f, -0.04568226f, -0.37331435f, -0.15822688f, 0.02242460f, 0.09899641f, -0.04979148f, -0.01542640f, 
    0.09114665f, -0.10983344f, -0.08463081f, -0.01436388f, 0.14671983f, -0.15462376f, 0.01439746f, 0.13749085f, 
    0.09228190f, 0.13090731f, 0.13240403f, 0.17944843f, -0.34773469f, -0.12167145f, 0.07375224f, -0.06483450f, 
    -0.11631069f, 0.09102339f, -0.05420230f, 0.03995577f, -0.01725010f, -0.08083913f, -0.31213102f, 0.06317889f, 
    -0.02534424f, -0.02669236f, -0.07588512f, -0.07988661f, -0.03831849f, 0.00402675f, -0.06257305f, -0.05462988f, 
    0.03484306f, 0.05739744f, 0.07873372f, 0.14318934f, 0.14403361f, -0.06519923f, -0.07041748f, -0.22763774f, 
    -0.21503410f, 0.36525771f, -0.07394443f, 0.07681455f, 0.08806130f, 0.15831441f, 0.03493348f, 0.18267161f, 
    0.01790895f, -0.07314973f, 0.05317060f, -0.05763480f, 0.06023656f, -0.02456481f, 0.21085195f, -0.30941716f, 
    -0.03055971f, -0.02915573f, -0.36879355f, 0.21211964f, -0.05346206f, 0.03259680f, -0.17015329f, 0.30900526f, 
    0.03667535f, -0.11996100f, -0.06200157f, -0.11631867f, 0.03189043f, 0.08589016f, 0.09710768f, -0.04148028f, 
    0.07911813f, 0.08812209f, -0.00720769f, 0.09926258f, -0.57631612f, 0.01140270f, 0.23501429f, 0.02704954f, 
    0.18091622f, -0.08029343f, -0.10627555f, -0.12810607f, 0.07321715f, 0.01367807f, -0.12085929f, -0.07365911f, 
    -0.06806391f, 0.17966639f, 0.02616839f, 0.10138386f, -0.11881937f, 0.10039478f, 0.00150876f, -0.03534730f, 
    -0.15157376f, 0.09752629f, -0.07417844f, 0.00110148f, -0.07716731f, 0.04344266f, -0.09327614f, -0.04710058f, 
    -0.17827749f, -0.14604843f, -0.24660473f, -0.03589370f, 0.10203915f, 0.20724723f, -0.02823188f, 0.10869095f, 
    -0.08296394f, -0.17252567f, 0.04629013f, 0.01612949f, -0.05082821f, 0.26027009f, 0.02321383f, -0.05188709f, 
    0.10068434f, 0.11200689f, -0.01303314f, -0.01693763f, -0.07094038f, 0.01745074f, 0.08297478f, -0.01779575f, 
    -0.01578096f, 0.02571546f, -0.18224563f, -0.15885825f, -0.02700102f, 0.06119362f, 0.02599156f, -0.12766442f, 
    -0.33200052f, -0.35497019f, -0.10462958f, -0.11704827f, -0.12514500f, 0.05364175f, -0.05856125f, -0.05450860f, 
    -0.02060378f, 0.15816343f, -0.02029727f, 0.10171124f, 0.13769495f, 0.03680368f, 0.00106094f, -0.04664200f, 
    -0.07642218f, -0.03546948f, 0.06772511f, 0.02914769f, -0.22569764f, 0.02143604f, -0.00620435f, -0.01193477f, 
    -0.05363818f, 0.09792650f, -0.06815298f, 0.15604128f, 0.04557165f, 0.04956027f, 0.24019761f, -0.14783119f, 
    0.20070659f, 0.12589084f, 0.10330430f, 0.07529525f, -0.03868466f, 0.15051728f, -0.34092656f, -0.12334972f, 
    -0.01577389f, 0.01573909f, 0.18674785f, 0.15537925f, -0.03866731f, 0.09228805f, 0.40578797f, -0.05375932f, 
    -0.10055017f, -0.04733471f, 0.04273264f, 0.10750786f, -0.16782632f, 0.01966905f, -0.03329238f, -0.11449958f, 
    0.22988603f, 0.12190270f, 0.20834526f, -0.12040734f, -0.01151822f, 0.00806478f, 0.04236869f, 0.10227534f, 
    0.09327565f, 0.25176141f, -0.19072649f, 0.16071454f, 0.19896677f, 0.13878085f, 0.06450413f, -0.01270668f, 
    0.01536550f, -0.00509670f, 0.21776183f, -0.12108788f, -0.06002747f, -0.00473466f, 0.20502232f, -0.01578674f, 
    0.10487880f, 0.02754088f, 0.06539562f, 0.04324518f, -0.37661013f, 0.05041998f, -0.02025828f, 0.06158802f, 
    -0.00163351f, -0.20027243f, -0.19914466f, 0.08896042f, 0.17762600f, 0.00562627f, 0.20996268f, 0.01922121f, 
    0.00447437f, 0.08033960f, 0.02421786f, -0.06011396f, 0.14625213f, -0.02572230f, -0.09023704f, -0.09165692f, 
    -0.00074806f, -0.00979525f, -0.04468656f, 0.06230897f, -0.20575798f, -0.29437783f, 0.01889779f, 0.09420761f, 
    -0.14396872f, -0.00697936f, 0.02383350f, 0.01909216f, 0.06573694f, 0.02946990f, -0.01072577f, 0.12178994f, 
    0.01289188f, -0.24598023f, -0.07891620f, 0.06215578f, -0.00857233f, -0.00100791f, -0.00745751f, -0.14444229f, 
    -0.28749549f, -0.17239811f, -0.06113181f, 0.10177321f, 0.09116369f, -0.01220594f, -0.03223892f, 0.04777498f, 
    0.23300992f, -0.02028532f, 0.07700843f, -0.10462464f, 0.06113637f, -0.04921442f, 0.06981102f, -0.07583463f, 
    0.01091760f, -0.00035005f, 0.54344743f, -0.13533638f, -0.18364409f, 0.17816594f, 0.10484917f, 0.12318520f, 
    0.01917504f, -0.06712178f, 0.13949344f, -0.03802487f, 0.01000046f, -0.06967308f, 0.02505055f, 0.13497394f, 
    0.04552454f, -0.11661153f, -0.04404229f, -0.06591725f, -0.00879814f, -0.06391834f, -0.02063034f, -0.08937185f, 
    0.06119172f, 0.06740786f, -0.10027324f, -0.05483712f, 0.08940733f, 0.02057351f, 0.01739090f, -0.10592384f, 
    0.22856003f, -0.14850724f, 0.13130866f, 0.03485692f, -0.06675982f, -0.05502824f, -0.03602679f, -0.10191994f, 
    0.14698984f, 0.01911621f, -0.04612575f, -0.03631431f, 0.00326067f, 0.01751831f, 0.13121527f, -0.00468883f, 
    0.09356657f, 0.00171970f, -0.01519197f, 0.10960381f, -0.03219654f, 0.00553269f, -0.08762722f, 0.08046870f, 
    -0.17340885f, 0.08405093f, -0.01289049f, 0.02923385f, 0.05268024f, 0.09906694f, 0.00492080f, 0.17970075f, 
    0.15178412f, 0.26094431f, 0.18219849f, 0.08230196f, 0.19180933f, -0.05432112f, 0.02158648f, 0.05282801f, 
    0.04253729f, 0.00296995f, 0.32145417f, 0.04922284f, 0.23235779f, 0.00878040f, 0.06727932f, 0.11077397f, 
    0.08804536f, 0.02672203f, 0.13398467f, 0.03873381f, 0.03412847f, -0.27297258f, 0.11289629f, -0.00922498f, 
    0.15902553f, 0.02497532f, 0.06198873f, 0.03359240f, -0.01293328f, -0.18426681f, -0.11974123f, 0.22972934f, 
    0.09744321f, -0.02118008f, 0.05247435f, 0.18623868f, -0.19236149f, 0.00894649f, 0.13242283f, -0.04558827f, 
    0.09411930f, 0.07162501f, -0.00603456f, 0.03043586f, 0.15921535f, 0.05465279f, -0.05547121f, -0.00458049f, 
    -0.01552237f, 0.03888378f, 0.01287460f, -0.09717855f, -0.02477548f, -0.25052691f, -0.39292637f, 0.08745690f, 
    -0.08048577f, -0.16592781f, 0.07956745f, 0.06608386f, -0.08063351f, 0.05631585f, -0.21964577f, -0.07303333f, 
    -0.01983136f, -0.06594922f, -0.05999420f, 0.02870731f, -0.02719844f, 0.05401717f, -0.00413770f, -0.01894183f, 
    -0.00598136f, -0.04308867f, 0.01302847f, -0.01544496f, 0.04379307f, -0.01096558f, -0.01163235f, 0.01440815f, 
    -0.04461688f, -0.00403401f, 0.01184055f, 0.04113184f, 0.00494426f, -0.03553776f, -0.00840101f, -0.02203927f, 
    0.05473436f, 0.03874396f, -0.05949574f, -0.05286761f, -0.04062549f, -0.00721010f, -0.03955694f, 0.02216963f, 
    0.00050886f, -0.05006985f, -0.05316458f, -0.01832733f, -0.00737131f, 0.00048054f, -0.01018305f, 0.04337107f, 
    0.03448682f, -0.01661581f, 0.02587009f, -0.03683318f, -0.04551274f, 0.02758354f, 0.00050777f, -0.01920139f, 
    0.04665022f, -0.02108459f, 0.01260083f, 0.03680586f, -0.04327656f, 0.04237340f, -0.03931769f, -0.06780861f, 
    0.02034486f, -0.02953764f, 0.03411784f, -0.02845539f, 0.00500368f, 0.05378679f, -0.03765545f, 0.02105586f, 
    0.01071221f, 0.05424171f, 0.01165790f, -0.06485160f, -0.04347109f, 0.00095710f, -0.01705080f, 0.01906676f, 
    0.02228193f, -0.06361111f, -0.02788099f, -0.02549736f, -0.04905888f, 0.02824700f, -0.02672207f, 0.04341622f, 
    0.04544580f, 0.02121946f, 0.04015976f, -0.04380108f, -0.03255629f, -0.02225029f, 0.03855394f, -0.00380829f, 
    0.01661509f, -0.02275048f, -0.00325190f, 0.04780597f, -0.05818313f, -0.01937798f, 0.01260092f, 0.00797333f, 
    0.02223415f, 0.05063242f, -0.00026666f, -0.04665234f, -0.05929515f, -0.02924232f, 0.02387277f, -0.03254167f, 
    -0.00189494f, 0.02588636f, -0.06247317f, 0.01541965f, -0.04330560f, -0.05591238f, 0.00175607f, -0.00834386f, 
    -0.05888070f, -0.03004031f, -0.02114159f, -0.02660690f, -0.04760979f, -0.02587261f, 0.00499139f, -0.05728561f, 
    0.00105243f, -0.00786124f, 0.03858148f, 0.05874535f, -0.02823422f, 0.02147229f, -0.03317046f, 0.05262140f, 
    -0.02869728f, -0.00371123f, 0.03457971f, 0.02142429f, 0.00884411f, 0.01791009f, 0.02870579f, -0.04205899f, 
    -0.04633467f, -0.02534231f, 0.04988693f, -0.01952587f, 0.01905778f, -0.01749318f, -0.03643937f, -0.06028019f, 
    0.03139571f, -0.01078629f, 0.00160479f, 0.01089666f, -0.01761661f, -0.04586453f, -0.04528585f, -0.03428608f, 
    0.01875638f, 0.03139824f, -0.02551367f, -0.05288535f, -0.01609800f, -0.03495089f, 0.01807177f, -0.04638049f, 
    0.02728272f, 0.00286634f, 0.00496138f, -0.04265737f, 0.02166107f, -0.03125802f, 0.04944520f, 0.00967993f, 
    -0.06036747f, -0.04006992f, -0.03401354f, 0.01789763f, -0.00500531f, 0.00204039f, -0.00411262f, 0.00005798f, 
    -0.03613792f, -0.05405908f, -0.06623073f, 0.03277654f, 0.01440483f, -0.00752391f, -0.03085395f, -0.00510824f, 
    -0.02696216f, 0.02853286f, 0.01280461f, 0.01513951f, -0.00987572f, -0.00609526f, 0.03920729f, -0.01301876f, 
    -0.04549550f, 0.02387762f, -0.04965709f, -0.00841525f, 0.04113203f, -0.01514620f, 0.01611830f, -0.04237477f, 
    -0.06443175f, 0.02224663f, 0.01267603f, -0.05225862f, -0.04378986f, -0.00111869f, -0.00124944f, -0.00561961f, 
    -0.03689194f, -0.01392977f, -0.03329847f, -0.02823362f, 0.04422940f, -0.02036238f, -0.00880886f, 0.03022384f, 
    0.01893810f, 0.00531679f, 0.04164847f, 0.02328891f, -0.00528730f, 0.01049304f, -0.05488448f, 0.04228340f, 
    -0.03748787f, -0.06290878f, -0.02271299f, 0.02254264f, -0.05786607f, 0.02822747f, -0.03627387f, -0.02324967f, 
    -0.04477664f, -0.02240513f, 0.01335865f, 0.02207116f, -0.00145982f, 0.01540905f, 0.00339710f, -0.03305877f, 
    -0.02133623f, 0.04981209f, 0.03157615f, 0.03536642f, 0.01110012f, 0.02738649f, -0.01706927f, -0.04788656f, 
    0.02982137f, 0.02047675f, 0.02846788f, 0.03087185f, 0.00484364f, -0.05535826f, 0.01965778f, 0.01930359f, 
    0.03098709f, -0.03130391f, -0.03632279f, -0.02074326f, -0.00005135f, -0.00285489f, -0.00519115f, 0.03315707f, 
    0.05961563f, 0.02739234f, 0.00713188f, -0.02292736f, 0.01370164f, -0.02191428f, -0.05849698f, 0.05223522f, 
    -0.02526820f, 0.00831238f, -0.06379820f, -0.00645222f, 0.02572469f, -0.03559384f, 0.04957767f, -0.03877667f, 
    0.01664825f, 0.01359845f, -0.01485207f, -0.04858695f, 0.03001214f, -0.02303867f, -0.06641047f, -0.01353793f, 
    -0.05241071f, -0.00777081f, 0.04919500f, -0.03858142f, 0.04747344f, 0.03999686f, -0.03376226f, 0.00249843f, 
    -0.05355742f, 0.00940002f, -0.01605487f, -0.04930368f, -0.03993420f, -0.00091825f, 0.03487143f, -0.03687860f, 
    -0.00869666f, -0.04742767f, 0.01102107f, -0.06156423f, 0.00728012f, 0.00148993f, -0.04069592f, 0.00813612f, 
    0.04252631f, 0.00879850f, 0.02482866f, -0.02257087f, -0.01279410f, 0.03490186f, 0.01627599f, -0.05601681f, 
    -0.00669007f, 0.05231983f, -0.05500008f, 0.04595890f, 0.02000509f, 0.04731195f, -0.05152376f, -0.04195205f, 
    -0.04096111f, 0.04814703f, -0.01104443f, 0.03074662f, -0.02263462f, 0.05499944f, -0.05455216f, 0.02738659f, 
    -0.01901249f, 0.01564840f, -0.00069057f, -0.05658391f, -0.04737277f, -0.03601569f, -0.02455905f, 0.02113938f, 
    -0.02734271f, 0.04803159f, 0.00906077f, 0.03743701f, 0.02072069f, 0.03790321f, 0.02034689f, 0.00942535f, 
    0.04175571f, -0.03744086f, -0.01292827f, 0.03579511f, -0.02765388f, -0.04551857f, -0.00773433f, -0.02097529f, 
    0.04365116f, 0.04446847f, -0.04671219f, -0.02763715f, -0.02561148f, -0.04812804f, 0.01649159f, -0.04486340f, 
    -0.03975979f, -0.06229138f, 0.02411991f, -0.05205840f, -0.01287405f, 0.03017087f, 0.04216200f, 0.03035025f, 
    -0.01466817f, 0.00359245f, 0.04154478f, -0.00071517f, 0.02811093f, 0.02172625f, -0.02061381f, -0.00971270f, 
    -0.04053187f, -0.03089332f, -0.03555274f, 0.03942810f, -0.04825304f, 0.03138320f, -0.02614955f, -0.02736466f, 
    -0.06375665f, -0.00971495f, -0.02811688f, 0.00880126f, 0.03118192f, -0.02023995f, -0.05234116f, -0.00546110f, 
    -0.06039019f, 0.03020715f, -0.01682833f, -0.05658803f, -0.04913245f, -0.04237339f, -0.00361024f, -0.03861902f, 
    -0.03340491f, -0.04977363f, 0.02260420f, 0.03608934f, 0.01965502f, -0.03432938f, -0.00813768f, 0.02828069f, 
    -0.00614813f, -0.03716716f, -0.03558677f, -0.03557694f, -0.04323904f, -0.01192201f, -0.06398066f, -0.02702711f, 
    -0.04160301f, -0.02110293f, 0.02894221f, 0.00510003f, 0.00557725f, 0.04624387f, -0.00875035f, -0.03347695f, 
    0.03732735f, -0.04849327f, 0.00044612f, 0.03182220f, -0.01525699f, -0.05921191f, -0.03239803f, -0.05054189f, 
    0.01103192f, 0.05032296f, 0.02089808f, 0.05110414f, -0.02160736f, 0.00512630f, 0.01998673f, -0.02051086f, 
    0.04948429f, -0.02621552f, 0.00993525f, -0.03600297f, -0.05076974f, -0.02539846f, -0.00035488f, 0.04634584f, 
    -0.01310374f, 0.04555469f, 0.02471077f, 0.01964968f, -0.01624612f, -0.01434161f, 0.00221053f, -0.03092973f, 
    -0.02418862f, -0.06152046f, 0.00920870f, 0.04616262f, 0.01382328f, -0.05954164f, -0.01228769f, 0.03069806f, 
    0.03439235f, 0.01220643f, -0.05860782f, -0.04308604f, -0.02485847f, 0.04448690f, -0.00158285f, -0.00401389f, 
    0.02571094f, -0.02107257f, -0.06071382f, -0.06167860f, 0.04857542f, -0.02209737f, -0.00461787f, -0.01449327f, 
    0.04793344f, 0.00809581f, -0.03799045f, 0.00628956f, -0.04135699f, 0.03098747f, -0.03617180f, 0.00110864f, 
    -0.00274680f, -0.03467460f, -0.04213051f, 0.04229826f, -0.06134144f, -0.05729450f, -0.05980287f, 0.02351888f, 
    -0.03233244f, 0.02624823f, -0.04339013f, -0.02059839f, -0.04482617f, -0.01855894f, -0.04368917f, -0.04464604f, 
    -0.04033171f, -0.05738826f, 0.02453592f, 0.02904983f, -0.03725519f, -0.00850774f, 0.02395920f, -0.00058411f, 
    0.02919527f, -0.06228670f, 0.04300645f, 0.01519317f, -0.00427653f, -0.01502843f, 0.02796574f, 0.02627438f, 
    -0.00074833f, 0.04982229f, 0.03442791f, -0.01955441f, -0.04964371f, -0.00796507f, -0.01124492f, -0.05439524f, 
    0.04454113f, -0.02761642f, -0.04565416f, -0.02576634f, -0.03911942f, 0.02844561f, 0.03401677f, 0.00256973f, 
    -0.00358396f, -0.03638371f, -0.03331356f, 0.01153644f, 0.05289004f, 0.00943619f, -0.01430547f, -0.03958800f, 
    0.00423844f, -0.02346048f, -0.01281362f, -0.04282134f, 0.01815531f, -0.02088660f, -0.01326498f, 0.00762780f, 
    -0.04415947f, -0.04782605f, 0.03020145f, -0.04646238f, -0.03064921f, -0.01937699f, -0.00519274f, 0.00174124f, 
    -0.00154437f, -0.02142799f, -0.05247449f, 0.05068176f, -0.00477237f, -0.00489245f, -0.03768065f, -0.03898517f, 
    -0.09009489f, -0.00219917f, -0.00949416f, 0.02575252f, -0.04930658f, -0.03110718f, -0.08410791f, -0.00472005f, 
    0.15964645f, 0.35210675f, 0.11262826f, -0.05716703f, -0.03795180f, -0.02444471f, 0.04667054f, 0.00401050f, 
    0.08588875f, 0.05697454f, 0.01730212f, 0.11153574f, 0.04481620f, -0.01713268f, -0.17491439f, 0.08073609f, 
    0.11569574f, 0.03411465f, -0.03612785f, 0.22203553f, 0.14086118f, 0.11523181f, 0.06489988f, -0.13780768f, 
    -0.05954476f, -0.09600873f, -0.06899112f, -0.08459377f, 0.22781371f, 0.26161292f, 0.10185855f, 0.00049825f, 
    0.03126651f, 0.00865877f, -0.16215086f, -0.07272157f, -0.01858523f, -0.58390653f, -0.23713958f, 0.27690637f, 
    0.08971246f, 0.02516393f, -0.07090401f, 0.03631584f, -0.18720736f, 0.34180844f, -0.06806988f, 0.18853405f, 
    0.21912888f, 0.04721185f, -0.04159046f, 0.01947603f, -0.06983136f, 0.07432460f, -0.01420594f, -0.05580294f, 
    -0.22081296f, -0.08878792f, 0.04092062f, -0.07302785f, -0.01059738f, -0.04630380f, 0.05868861f, 0.08017088f, 
    -0.10407896f, -0.06933903f, -0.19849333f, 0.11315019f, -0.03517611f, -0.06735519f, 0.07102036f, 0.04357902f, 
    -0.00068711f, -0.41445106f, 0.12236633f, 0.08375454f, -0.13367772f, -0.03744164f, 0.06662405f, 0.08472278f, 
    0.18686634f, -0.10464379f, 0.17937915f, 0.14874943f, -0.04494124f, 0.05878765f, -0.05419176f, -0.00003880f, 
    0.03937351f, 0.14245304f, -0.00434553f, 0.26666903f, 0.14629908f, 0.17407317f, -0.28693423f, 0.13124648f, 
    -0.00750000f, 0.09698952f, -0.02234940f, 0.06785716f, -0.28696731f, -0.07845191f, -0.09146719f, -0.05220199f, 
    0.03455558f, -0.10971793f, -0.02949227f, -0.09784684f, -0.15946957f, -0.28051776f, -0.01380492f, 0.13453481f, 
    -0.08953561f, -0.00386269f, 0.10791089f, 0.04019102f, 0.06940807f, 0.23170224f, 0.15776542f, 0.17056105f, 
    -0.04413765f, 0.04817386f, -0.12698150f, -0.00077862f, 0.06088368f, -0.07527709f, -0.11727083f, -0.04836947f, 
    0.14523900f, 0.14296511f, 0.01228588f, 0.03686080f, -0.28764254f, 0.02559473f, 0.03474967f, 0.08079148f, 
    -0.21362522f, 0.13528810f, 0.04361950f, 0.05670196f, 0.07062754f, -0.06037697f, -0.06434777f, 0.24620686f, 
    -0.03992753f, 0.09061806f, 0.06957603f, 0.01056730f, -0.14109808f, -0.20478056f, -0.18164186f, 0.03179915f, 
    0.04955037f, 0.04705313f, 0.12537317f, 0.26399580f, 0.20605363f, -0.19928716f, -0.04379714f, 0.06548243f, 
    -0.04290712f, 0.09078266f, 0.01500236f, 0.11293892f, -0.03923436f, -0.06275011f, -0.11554443f, -0.32906663f, 
    -0.06573362f, 0.07925921f, 0.04719994f, 0.07457414f, -0.39659014f, -0.03601614f, -0.15913980f, -0.00513753f, 
    -0.02552355f, -0.15337217f, 0.08436017f, -0.02642177f, -0.07403564f, -0.50059170f, -0.26333323f, -0.09168643f, 
    0.01991232f, 0.02673302f, -0.09389880f, 0.05140651f, -0.18969466f, -0.09738246f, -0.37794572f, 0.09478536f, 
    -0.00991908f, 0.05611332f, -0.00594874f, -0.00976450f, -0.08689038f, -0.02876871f, -0.06110591f, -0.32237726f, 
    0.09964106f, 0.27901229f, 0.03582616f, 0.11484145f, -0.13871175f, -0.17110237f, 0.12340316f, -0.06740120f, 
    0.16594650f, 0.09034119f, 0.00948662f, 0.13796917f, 0.03910498f, -0.09203273f, 0.02960015f, -0.01556649f, 
    -0.17364149f, -0.23161867f, -0.04972593f, -0.08774623f, -0.00584661f, -0.04599009f, -0.00483904f, -0.01999690f, 
    0.10122605f, 0.23724939f, -0.22676766f, -0.07293466f, -0.24495032f, 0.11987912f, 0.06185763f, -0.06372485f, 
    0.03627642f, -0.00775504f, -0.02341394f, -0.00568210f, -0.12805809f, 0.38650155f, -0.02515137f, 0.22944053f, 
    -0.07936123f, -0.04269053f, 0.11182566f, -0.07101420f, -0.41418287f, -0.15862930f, 0.20372374f, 0.07661723f, 
    0.15115875f, 0.03980218f, 0.05431897f, -0.12896711f, 0.00837748f, 0.15527637f, 0.11889413f, 0.01478315f, 
    -0.35549664f, -0.05072458f, 0.11286215f, 0.04068502f, -0.01267725f, 0.12802896f, -0.22672233f, -0.20904090f, 
    -0.15426528f, 0.01512808f, 0.03928428f, -0.01190115f, 0.12949459f, -0.07858165f, -0.04102730f, 0.10099740f, 
    0.07046590f, 0.07751248f, -0.21304862f, -0.03751361f, 0.00889760f, -0.21741481f, 0.12525579f, 0.20643198f, 
    -0.11154870f, -0.55912650f, -0.20313704f, -0.01309607f, 0.11412379f, -0.00884806f, 0.23998411f, -0.03881644f, 
    0.05807031f, -0.11087868f, -0.08575948f, 0.25782290f, -0.11815895f, -0.27668574f, -0.18883918f, -0.07528684f, 
    0.07196552f, 0.08963897f, 0.04199651f, -0.15614496f, -0.45984313f, -0.21066462f, 0.06255563f, -0.24411051f, 
    0.01523774f, 0.10278312f, 0.17060742f, 0.14116091f, -0.28889477f, 0.00804581f, 0.08646016f, -0.35501930f, 
    -0.13313822f, 0.03476335f, -0.03521832f, 0.02726931f, -0.26350042f, 0.06042306f, -0.09792034f, 0.17981572f, 
    -0.04920435f, -0.01260099f, 0.02267263f, 0.16431688f, 0.21353891f, -0.28899106f, -0.12329424f, 0.20247580f, 
    0.13833725f, 0.10889518f, -0.00645611f, -0.13717996f, -0.31670684f, -0.24513568f, -0.24781531f, 0.14324388f, 
    0.28074545f, -0.05459889f, -0.00838314f, 0.04475054f, 0.10167638f, -0.08166758f, 0.12123159f, 0.13140802f, 
    -0.02460454f, -0.54644293f, -0.13977093f, -0.05666968f, -0.07077165f, 0.10276467f, 0.19942957f, -0.10524518f, 
    0.19153686f, 0.13932285f, 0.32305002f, 0.04157445f, -0.06100488f, -0.03344751f, 0.20328562f, -0.17191528f, 
    -0.29570672f, 0.14094575f, 0.13288800f, 0.12504479f, 0.10620402f, 0.03669329f, 0.04655880f, -0.06667187f, 
    0.12160049f, 0.08420501f, 0.23338974f, 0.01214652f, -0.05805840f, -0.17623816f, -0.03328452f, 0.06384847f, 
    -0.03579009f, 0.31998312f, 0.05759479f, -0.28878361f, 0.29545510f, 0.53158879f, -0.00561736f, -0.01256742f, 
    -0.02163888f, 0.05044739f, 0.00616147f, 0.16684155f, 0.10290317f, 0.05847953f, 0.34067047f, 0.02537566f, 
    -0.10908110f, -0.05896893f, 0.18660662f, -0.10018402f, 0.10308108f, -0.45512947f, -0.33333638f, -0.42706674f, 
    -0.26941830f, -0.04611395f, -0.16124813f, 0.00880981f, -0.08443704f, -0.21532570f, 0.03418047f, -0.00287430f, 
    0.14921419f, 0.05667156f, -0.00152132f, -0.07592631f, 0.03159336f, -0.25821102f, -0.04271781f, -0.08783004f, 
    -0.14538300f, 0.00731245f, 0.15949596f, 0.04046951f, 0.16606537f, -0.20194761f, -0.04748323f, -0.17021103f, 
    -0.37614045f, -0.08898111f, 0.01407342f, 0.09122013f, -0.07134543f, -0.04494132f, 0.15110466f, 0.11338907f, 
    -0.02338395f, 0.01338288f, -0.15686905f, -0.08955574f, -0.07325521f, -0.09441546f, -0.20330870f, -0.12043962f, 
    -0.04241855f, 0.11915303f, 0.19424160f, 0.18879466f, 0.01228693f, -0.03967851f, -0.02120371f, -0.08549917f, 
    -0.01506734f, 0.20383589f, 0.13054042f, 0.09017286f, -0.01542985f, 0.14680809f, -0.12417568f, -0.11080148f, 
    0.09321527f, 0.03206112f, 0.01563199f, 0.20977397f, -0.36905932f, -0.05938494f, 0.11147534f, 0.02982034f, 
    -0.28367493f, 0.10285099f, 0.17395572f, -0.19372880f, -0.01730325f, -0.13991292f, 0.05740036f, 0.35893029f, 
    0.09690683f, -0.09107962f, -0.13379711f, -0.10576197f, -0.19523945f, -0.18280619f, 0.09961703f, 0.12352156f, 
    0.32875481f, 0.00856873f, 0.10715994f, 0.09763599f, 0.12743442f, -0.00354601f, -0.05055556f, -0.22711423f, 
    0.18747084f, 0.09901634f, 0.16389666f, 0.13633592f, 0.11070020f, 0.11163738f, 0.06887555f, -0.00003135f, 
    -0.01198376f, 0.00477311f, -0.11168109f, 0.02188830f, 0.07202586f, 0.10563926f, 0.26405337f, 0.02124367f, 
    -0.05754781f, -0.06356967f, -0.21885258f, 0.17299746f, -0.12539659f, 0.09101898f, 0.11605841f, -0.01686980f, 
    0.02555982f, 0.05480221f, 0.12125751f, 0.07011701f, 0.25578937f, 0.26261601f, -0.14462438f, 0.00301249f, 
    0.00092505f, 0.00010895f, 0.08432812f, -0.42515844f, -0.00005171f, -0.12870739f, 0.01488501f, 0.06305942f, 
    0.05566253f, -0.00381494f, 0.19579600f, 0.01706143f, 0.07409961f, 0.17607082f, -0.02539070f, 0.01527173f, 
    0.14560746f, 0.09142450f, -0.17887843f, -0.10204573f, -0.18524881f, -0.15311433f, -0.14178671f, -0.25093275f, 
    0.17146440f, 0.06207712f, -0.07246461f, 0.19457290f, 0.10485897f, 0.25408098f, 0.20137550f, -0.03567386f, 
    0.11369024f, 0.01246063f, -0.12105492f, 0.00145275f, -0.13394041f, -0.32966626f, -0.37349397f, -0.22326209f, 
    -0.17098095f, -0.20894411f, 0.07319005f, -0.03776639f, 0.21575156f, 0.13871986f, -0.14446463f, 0.12440433f, 
    -0.27019957f, -0.18674970f, 0.05718025f, -0.06704883f, 0.02825574f, 0.13854896f, 0.07230303f, -0.09055756f, 
    0.01251979f, 0.02876317f, 0.05698723f, -0.07943887f, 0.00496240f, 0.01523532f, -0.29701406f, -0.00798626f, 
    0.00522385f, 0.00601989f, -0.09903552f, -0.06141235f, -0.01784960f, 0.22006735f, 0.08250073f, -0.09160644f, 
    -0.29969242f, -0.16075175f, -0.36996722f, -0.30854610f, -0.09118903f, -0.02706427f, -0.03958894f, 0.06031150f, 
    0.02419398f, -0.07783677f, -0.13511804f, -0.03708282f, -0.16808945f, -0.02956353f, -0.01590118f, -0.06599846f, 
    0.06629720f, 0.10456789f, -0.14656977f, 0.30019337f, -0.07400032f, -0.08747346f, -0.13155630f, -0.06157321f, 
    -0.00251206f, -0.03378072f, 0.24603023f, -0.05155287f, 0.13533662f, 0.24200891f, 0.30927083f, -0.04757271f, 
    -0.33053550f, 0.01808982f, -0.04876861f, -0.02258704f, -0.07775430f, -0.18339601f, 0.13533272f, -0.28249517f, 
    -0.03644346f, 0.09539063f, -0.02221287f, 0.05762177f, -0.01931270f, 0.04263156f, -0.03735795f, 0.17826098f, 
    -0.04806580f, -0.05136410f, 0.01835343f, -0.00757896f, 0.00114385f, 0.07726680f, -0.14117171f, -0.17160748f, 
    -0.25739676f, 0.17910446f, 0.10157301f, 0.12080400f, 0.06524337f, 0.03549689f, 0.02952882f, -0.05451600f, 
    0.15730251f, -0.17205067f, 0.02227343f, 0.09836546f, -0.06147563f, -0.10558992f, 0.01119684f, -0.04472884f, 
    0.09357236f, 0.04896806f, -0.17277631f, 0.11168731f, -0.08763038f, -0.19773550f, 0.01182971f, 0.04317291f, 
    -0.09207365f, 0.03153642f, 0.00593102f, 0.11192088f, 0.37875524f, 0.19459933f, -0.16281317f, 0.13286181f, 
    -0.11212831f, 0.10034369f, 0.05680193f, 0.01735396f, -0.22373438f, -0.03849191f, 0.03556012f, 0.06644628f, 
    0.05629358f, 0.00273040f, -0.01414230f, 0.09535095f, 0.25219989f, 0.14135449f, -0.20825587f, -0.04357551f, 
    0.05326670f, -0.07591625f, 0.06890742f, 0.15476936f, -0.12257960f, -0.20130426f, -0.14110376f, -0.07259411f, 
    0.15768719f, -0.01286833f, 0.02720129f, 0.10136103f, 0.06051904f, 0.18595073f, 0.13697825f, -0.07380393f, 
    0.35098553f, -0.00868047f, 0.09849737f, -0.04386389f, -0.14956580f, -0.18962795f, -0.17861578f, -0.09782746f, 
    -0.03203889f, -0.09505325f, 0.07529102f, 0.04129384f, -0.04541902f, -0.06965679f, -0.23395932f, -0.10469484f, 
    -0.01218077f, -0.05543183f, 0.66605312f, 0.18219513f, 0.01513012f, 0.14669488f, 0.02623660f, 0.06763373f, 
    0.09330988f, 0.05548836f, -0.13825402f, -0.02367288f, 0.01520966f, -0.00904427f, 0.23113313f, -0.06465061f, 
    -0.13344951f, -0.19552734f, -0.02504216f, -0.06471746f, 0.37909415f, -0.04312868f, -0.11977310f, 0.05296792f, 
    -0.10131420f, 0.06483787f, -0.00886187f, 0.04024854f, 0.09848214f, 0.26595569f, 0.01161527f, -0.29116505f, 
    0.08364446f, 0.01974407f, 0.07181915f, 0.04948134f, 0.06333670f, 0.08822444f, 0.30655533f, -0.06728156f, 
    0.02339599f, -0.04486553f, -0.01163734f, -0.07257170f, 0.10237267f, -0.11449193f, -0.04141636f, 0.10978241f, 
    0.19798049f, -0.06154755f, -0.05179361f, -0.05023264f, -0.01995012f, 0.04064762f, 0.08656139f, 0.14249516f, 
    -0.06905902f, 0.04155374f, 0.01364429f, 0.10391952f, 0.06343505f, 0.12139306f, -0.20234700f, -0.10012087f, 
    -0.17350595f, -0.24791665f, -0.17348823f, -0.00335950f, 0.01855248f, 0.11405664f, 0.14575399f, 0.05669998f, 
    -0.04383134f, -0.04796046f, -0.00327034f, 0.09656372f, 0.00219451f, 0.01108436f, -0.05078689f, 0.00897512f, 
    -0.12724973f, 0.13218047f, -0.15135993f, 0.05828635f, 0.05861918f, 0.14036636f, 0.23817949f, 0.05419957f, 
    0.08721797f, 0.05567374f, 0.11170772f, -0.05238152f, 0.27943900f, 0.09591699f, 0.03357101f, -0.11326948f, 
    0.02936607f, -0.02951423f, 0.02744393f, 0.04124530f, 0.19543803f, -0.04847015f, -0.08850233f, 0.05502260f, 
    -0.02548509f, -0.03051228f, -0.06443157f, -0.13629472f, -0.20293552f, -0.13305865f, 0.05297496f, 0.10313420f, 
    0.13420603f, -0.03335719f, 0.05263774f, 0.04244367f, 0.08864363f, 0.07007724f, 0.12532495f, 0.02881003f, 
    -0.04501214f, -0.08069205f, -0.14946951f, -0.04480975f, -0.00940390f, 0.03814964f, 0.16258213f, 0.01213710f, 
    0.28322762f, 0.09594794f, -0.01494457f, -0.04078645f, -0.13463560f, -0.25691310f, 0.07466356f, 0.18555021f, 
    0.02408229f, 0.01631609f, 0.03125461f, -0.19010246f, -0.06660975f, -0.00592589f, 0.06430274f, 0.08734394f, 
    -0.08594621f, -0.01075229f, 0.04480708f, -0.06790210f, 0.18125017f, -0.07846740f, -0.06052941f, -0.06499403f, 
    0.03453311f, 0.09553257f, 0.02124056f, 0.24442084f, 0.12834528f, 0.16676079f, -0.05664780f, -0.09493053f, 
    -0.00525310f, 0.00917250f, 0.06364554f, 0.07901669f, 0.69780284f, 0.02808813f, -0.00853212f, 0.07482231f, 
    -0.01379980f, -0.03992401f, 0.04823668f, 0.13764906f, 0.16145076f, 0.12420639f, -0.20284317f, -0.05369367f, 
    -0.14086168f, -0.05308339f, -0.15661581f, 0.03958878f, 0.08769944f, -0.02878508f, 0.04685321f, -1.07618797f, 
    -0.55735964f, -0.36844277f, 0.00189238f, 0.04883853f, -0.03223152f, -0.26380590f, -0.16817249f, 0.17246157f, 
    0.19687721f, -0.04458772f, 0.02284921f, 0.07144496f, 0.19252731f, 0.08119874f, 0.05530654f, 0.01046144f, 
    0.21021469f, 0.00066287f, 0.20661025f, 0.10523883f, -0.09040648f, -0.00301951f, 0.00523642f, -0.06002723f, 
    0.07911775f, -0.34247196f, -0.25674403f, -0.03429839f, 0.17801495f, 0.07299490f, 0.08067710f, 0.08272285f, 
    0.11913566f, 0.07088783f, 0.22243263f, 0.08917096f, -0.16174601f, 0.03107503f, 0.28641132f, 0.18623418f, 
    0.10583499f, -0.04011441f, 0.01092573f, -0.12735027f, -0.72619927f, -0.69190329f, -0.07669892f, 0.02473266f, 
    0.08980621f, 0.07871787f, -0.05241499f, -0.10593551f, 0.20510182f, -0.20720352f, -0.62838149f, 0.07821792f, 
    -0.06264667f, 0.14764464f, 0.04065536f, 0.04913371f, -0.11289688f, 0.27239221f, -0.00724426f, -0.06561431f, 
    -0.25273928f, -0.05060424f, -0.08127486f, -0.00965286f, 0.10037925f, -0.15833277f, 0.15996099f, 0.10789763f, 
    0.19746172f, -0.02763069f, -0.05674092f, 0.00885961f, 0.20921350f, 0.00097039f, 0.25275859f, 0.28725111f, 
    -0.04115565f, -0.04086388f, 0.04233590f, 0.03495898f, 0.06703436f, 0.11204645f, -0.06608411f, 0.05870127f, 
    -0.41968435f, -0.46518257f, -0.29899973f, -0.38561341f, 0.06393785f, -0.08996194f, -0.09815707f, -0.24762358f, 
    -0.15326904f, 0.22707610f, 0.23809244f, 0.13176988f, -0.10288321f, 0.00762591f, -0.08547194f, 0.05672793f, 
    -0.24897769f, -0.07606570f, 0.38535121f, -0.56365591f, -0.22019280f, 0.18051139f, 0.07976441f, 0.01240638f, 
    0.09261594f, 0.05401592f, 0.01090256f, 0.21673745f, 0.13737954f, -0.05664819f, -0.14126118f, 0.02977563f, 
    -0.08850640f, -0.04129513f, -0.19822787f, -0.04022096f, 0.63167530f, -0.35775819f, -1.28236735f, -0.18190017f, 
    -0.17230427f, 0.13205065f, 0.08611654f, -0.02949174f, -0.04320564f, 0.43431517f, -0.36775205f, -0.48381093f, 
    -0.17771088f, -0.12697189f, 0.04121265f, -0.07877884f, 0.01593519f, 0.00528347f, 0.01034146f, -0.59625953f, 
    -0.42024332f, 0.18419154f, 0.08271262f, 0.17446537f, -0.00054223f, 0.00014579f, 0.06541553f, -0.08143932f, 
    -0.44717425f, -0.01311537f, 0.08488093f, 0.18198878f, 0.07203743f, 0.06273831f, 0.11000505f, 0.05061974f, 
    0.26645896f, -0.10462697f, 0.07532915f, 0.02128773f, 0.02555025f, 0.02052593f, 0.00737028f, -0.07216131f, 
    0.20461680f, 0.23722503f, 0.13587330f, 0.20376988f, 0.10753030f, -0.20301108f, -0.04865881f, -0.02433070f, 
    0.11726756f, 0.11496834f, -0.12885681f, -0.26398969f, -0.00967310f, 0.08499219f, -0.07012776f, 0.02298458f, 
    -0.03825803f, 0.06320413f, 0.06995838f, -0.46090186f, -0.17624252f, 0.19201834f, -0.17935647f, 0.23610662f, 
    -0.10247262f, 0.14354058f, 0.00549989f, 0.11182112f, -0.30360574f, -0.45646667f, -0.19316968f, 0.20830837f, 
    -0.00585090f, -0.13250239f, -0.10385689f, 0.00585002f, 0.00765498f, 0.05140040f, 0.08803841f, 0.17296439f, 
    0.06250046f, -0.04617066f, 0.04480663f, 0.02929934f, 0.03306699f, 0.20428342f, -0.32029396f, -0.28277034f, 
    -0.13406192f, 0.12418494f, 0.02130109f, -0.10300168f, -0.00775957f, 0.01010930f, 0.00817675f, 0.13441983f, 
    0.02676180f, 0.13078040f, -0.07321426f, 0.06281793f, 0.03580054f, 0.05536788f, -0.04805297f, -0.12193862f, 
    -0.14069690f, -0.04762770f, 0.26624611f, 0.00802180f, 0.06511186f, 0.00389089f, 0.05075783f, 0.09825034f, 
    0.02053794f, 0.02597228f, -0.00524237f, 0.19833106f, 0.02886889f, 0.00927489f, 0.04908771f, -0.06173426f, 
    -0.01044020f, -0.01170261f, -0.10332832f, -0.07898519f, -0.12018608f, 0.01257172f, -0.08469350f, 0.13301551f, 
    0.05388411f, -0.16171214f, -0.20398520f, -0.02912375f, 0.03669134f, 0.18154140f, 0.01979101f, -0.03458433f, 
    0.05426297f, -0.18959786f, -0.09388731f, -0.17057566f, 0.00753726f, 0.16611332f, 0.12880865f, 0.19135368f, 
    -0.05146866f, 0.14356731f, -0.08742881f, 0.02514412f, -0.00500713f, 0.05576757f, -0.35326433f, -0.08795810f, 
    0.04567503f, 0.00136568f, -0.00480603f, 0.15400933f, 0.17265570f, 0.19577052f, -0.10287774f, 0.10580408f, 
    -0.18120223f, -0.03951480f, -0.05545191f, -0.05977757f, -0.13278677f, -0.23875804f, -0.03491618f, 0.22587696f, 
    0.07280513f, 0.20550507f, 0.12874638f, 0.17602468f, 0.07623757f, 0.11213908f, 0.00804932f, 0.11351822f, 
    0.02587946f, 0.03493306f, -0.02547419f, -0.00931925f, -0.00987948f, 0.04950386f, -0.10161737f, -0.23235643f, 
    -0.23220906f, 0.00012251f, 0.20571272f, -0.15876089f, -0.04433671f, 0.09057441f, -0.02083709f, -0.04018574f, 
    0.21253565f, -0.08363889f, -0.13189542f, 0.25071216f, 0.28428054f, 0.21799372f, -0.01811404f, 0.29118472f, 
    0.20407578f, 0.08174417f, -0.04033157f, -0.20398903f, -0.16667429f, 0.12417048f, 0.02165020f, -0.03587491f, 
    0.00770653f, -0.04060157f, -0.18927206f, 0.03375976f, -0.03610721f, -0.21671140f, 0.13987964f, 0.01979209f, 
    0.08856842f, 0.03054855f, -0.00928432f, 0.08065868f, -0.01543779f, 0.07376719f, 0.07513153f, 0.08149239f, 
    0.14149515f, -0.06254086f, 0.10917187f, -0.01210029f, 0.16292058f, 0.05078921f, -0.08376983f, -0.05633236f, 
    0.04475955f, 0.01764961f, -0.16243334f, -0.01501306f, -0.05443621f, -0.09683831f, -0.08753354f, 0.23002481f, 
    0.20445247f, 0.31356952f, -0.00065429f, 0.07264792f, -0.07575324f, 0.03105044f, 0.17498378f, 0.08837726f, 
    -0.01262161f, 0.01085717f, 0.03105785f, -0.01671629f, -0.02453769f, -0.11880653f, 0.03103848f, -0.28325352f, 
    -0.39316878f, 0.02094006f, 0.05939195f, 0.21734902f, 0.10657069f, -0.02135737f, 0.01762245f, -0.16093037f, 
    -0.16805811f, 0.02066690f, -0.00450905f, 0.02168142f, 0.03123400f, 0.08065347f, 0.01592445f, -0.15342818f, 
    -0.07241064f, 0.04455459f, 0.17247382f, 0.02174352f, 0.07490068f, -0.03504185f, 0.13725868f, -0.02270909f, 
    0.04808884f, -0.02019253f, 0.00693485f, -0.00437659f, -0.33792907f, -0.12763160f, 0.13234021f, 0.04773994f, 
    0.06345981f, -0.04118540f, -0.22726721f, -0.05139978f, 0.11378461f, -0.16673701f, -0.15126902f, -0.07368068f, 
    0.04155668f, 0.00615562f, 0.01660092f, -0.00949369f, 0.00853681f, 0.09649727f, 0.15285406f, 0.06723831f, 
    0.01354475f, 0.00793992f, -0.00509862f, -0.00378112f, 0.05058990f, -0.04037887f, 0.17016724f, 0.27409744f, 
    0.13269845f, 0.12434074f, 0.05376114f, 0.10105980f, -0.02675340f, 0.05443679f, 0.17270105f, -0.03854307f, 
    -0.05017611f, -0.17158686f, -0.15481779f, -0.00858725f, 0.00576452f, -0.06572691f, -0.00383556f, -0.17233112f, 
    -0.29619262f, -0.04924380f, 0.01409499f, 0.22327001f, 0.01779060f, -0.02223528f, 0.00108041f, 0.14772148f, 
    -0.07731317f, -0.07268582f, -0.11518861f, -0.15137047f, -0.26808411f, -0.07512384f, -0.04789259f, 0.04013335f, 
    -0.17234516f, -0.06274022f, -0.09840044f, 0.49595082f, -0.09848095f, -0.01239723f, 0.20964603f, 0.30939603f, 
    0.12058109f, 0.05578285f, 0.01125871f, -0.09576636f, -0.03090673f, -0.17136541f, -0.13348076f, -0.04664266f, 
    -0.03789092f, -0.04857681f, 0.03284243f, -0.00960500f, -0.09543338f, 0.08249604f, 0.14861116f, -0.11174521f, 
    -0.12691522f, -0.14811523f, 0.09557913f, -0.11913920f, 0.00920619f, -0.13351551f, 0.00733469f, -0.06334285f, 
    -0.33759508f, -0.15983121f, -0.18674548f, -0.04654637f, 0.10966395f, 0.09100460f, 0.02426794f, 0.11035232f, 
    -0.00686518f, 0.08265913f, 0.08966027f, 0.09213002f, 0.07090168f, -0.08037663f, 0.02111615f, 0.08192024f, 
    0.13366017f, -0.22958714f, 0.14529401f, -0.00400646f, 0.11635105f, 0.00875545f, -0.00063150f, 0.11544103f, 
    -0.03986939f, -0.08174051f, 0.17803279f, 0.07103014f, -0.17754325f, -0.15321113f, -0.19596685f, 0.09001688f, 
    0.04472446f, -0.00911323f, -0.03225759f, 0.23002484f, 0.03354225f, -0.02519462f, 0.00258259f, -0.12555592f, 
    0.15200736f, -0.00026748f, 0.02443830f, -0.00844370f, -0.19695531f, -0.09036814f, 0.01561021f, 0.05035643f, 
    -0.01155292f, 0.00853375f, -0.05780621f, 0.12490471f, 0.41438124f, -0.32418019f, 0.02709904f, -0.11145551f, 
    0.03079794f, 0.06367522f, 0.07971551f, 0.08527379f, 0.02889654f, 0.50905848f, -0.04470930f, -0.29975155f, 
    -0.09482062f, -0.01518627f, -0.03911450f, 0.01075580f, -0.01436649f, 0.12521654f, -0.00141793f, -0.34881884f, 
    -0.17776114f, -0.32152575f, -0.05862174f, -0.29909188f, -0.13103195f, -0.11424774f, 0.00155644f, -0.02814286f, 
    0.26722077f, -0.10110921f, 0.14252390f, -0.00193212f, 0.22656094f, 0.15525572f, 0.07582732f, 0.07228366f, 
    0.02493535f, -0.55174387f, 0.01363476f, 0.02705301f, 0.03815761f, 0.09168565f, 0.07307857f, 0.04261952f, 
    -0.03335666f, 0.16467111f, 0.09979340f, -0.17860149f, 0.06047923f, -0.05212395f, 0.14864352f, -0.12952141f, 
    -0.07775024f, -0.06122167f, -0.40408471f, 0.14804344f, 0.15683892f, 0.16414332f, 0.18466569f, 0.18380076f, 
    0.22814938f, -0.02704160f, -0.01108976f, 0.02472997f, -0.10778347f, 0.03846650f, 0.07191028f, -0.13776717f, 
    -0.18176897f, 0.04857107f, 0.05739751f, 0.07952577f, -0.53586590f, 0.07494697f, 0.13803834f, 0.02630693f, 
    -0.11325042f, -0.04614758f, 0.04289969f, -0.02161670f, -0.01251707f, 0.02370902f, 0.01424145f, -0.27109164f, 
    0.20156468f, 0.05649009f, 0.17682567f, 0.17337441f, -0.03126757f, 0.04008254f, -0.00363589f, -0.02248294f, 
    0.14452271f, -0.01578893f, 0.06471058f, 0.00471276f, 0.01438804f, -0.01965143f, 0.11316483f, -0.21379167f, 
    -0.09961292f, 0.07640171f, -0.03705420f, 0.16656283f, 0.04914822f, 0.04826656f, 0.11739897f, 0.14745890f, 
    0.01947918f, 0.05650437f, -0.20680189f, -0.25804380f, -0.07957297f, 0.09560770f, 0.03715241f, -0.34517491f, 
    0.03929721f, -0.23887129f, 0.01646081f, 0.02681533f, -0.06632708f, -0.04290624f, -0.17306261f, -0.03746612f, 
    0.05987632f, -0.06707558f, -1.51594341f, -0.23631975f, -0.07397213f, 0.20287141f, -0.13456444f, -0.02752290f, 
    0.13015009f, -0.01090705f, -0.00499067f, 0.08229189f, 0.19080277f, 0.11463082f, -0.25367847f, 0.02392680f, 
    -0.10649283f, 0.01400566f, -0.00710206f, -0.04421642f, -0.03383855f, 0.03593359f, 0.42143977f, -0.12490799f, 
    -0.10028809f, -0.08150589f, 0.01045165f, 0.05169874f, -0.07288238f, -0.36117008f, 0.19593835f, 0.35923147f, 
    -0.12943384f, -0.23038894f, -0.02581047f, -0.01577385f, 0.03942892f, -0.11174011f, -0.03159479f, -0.26356277f, 
    -0.33444899f, -0.06293230f, -0.02018812f, 0.04054762f, 0.06359597f, -0.00193741f, 0.03236873f, -0.10094412f, 
    -0.12353635f, -0.10211291f, -0.11610145f, 0.24716267f, 0.00655418f, 0.02348579f, -0.05133125f, -0.00225410f, 
    0.17961946f, -0.17115292f, 0.04844559f, 0.06149519f, -0.10930698f, 0.13792162f, 0.02546567f, 0.09779166f, 
    0.06917250f, 0.05732835f, -0.30709851f, 0.42388692f, 0.10876961f, 0.09620414f, 0.09032549f, 0.06569903f, 
    -0.06998452f, 0.06343588f, 0.26259157f, -0.35189134f, -0.89776498f, -0.16219182f, -0.08104435f, 0.04989970f, 
    0.02451461f, 0.16820914f, 0.03151821f, -0.58075911f, -0.15344971f, 0.00977852f, 0.03338736f, 0.09600555f, 
    -0.19788282f, 0.08478700f, -0.03455327f, -0.05392525f, 0.16012330f, 0.43201080f, -0.13198350f, 0.07731989f, 
    -0.02590290f, 0.16511941f, 0.04442681f, 0.02040190f, 0.05229448f, 0.01153752f, 0.16027002f, 0.05939206f, 
    0.00246092f, -0.12543364f, -0.05574230f, -0.07050693f, 0.23101963f, 0.14234777f, -0.07922908f, 0.10758708f, 
    -0.15489498f, 0.25258577f, -0.06764478f, 0.11409029f, 0.05766261f, 0.10326762f, 0.08269330f, 0.08075181f, 
    -0.05649496f, 0.13262446f, -0.03307498f, 0.28075105f, -0.01837092f, 0.04091354f, 0.00232516f, -0.09886179f, 
    0.16592139f, 0.19544348f, -0.05119231f, 0.04306734f, -0.06067307f, 0.22702642f, -0.04771622f, 0.07278314f, 
    -0.04239274f, 0.02380495f, 0.04526532f, -0.07487240f, 0.03965657f, 0.07918924f, 0.00686857f, -0.09336210f, 
    -0.27663612f, -0.25002283f, -0.00913894f, 0.08891517f, -0.09602451f, 0.05907127f, 0.04316605f, 0.06436129f, 
    -0.02789422f, 0.07992749f, -0.06175531f, 0.06021501f, 0.24795948f, 0.03035473f, -0.04371202f, -0.04577952f, 
    -0.13088854f, 0.12156507f, 0.13658755f, -0.00903923f, -0.01535013f, 0.10582678f, 0.06303518f, -0.12873693f, 
    -0.13073887f, 0.11652351f, 0.10862434f, -0.00893772f, -0.02245630f, -0.08535265f, 0.18140085f, 0.18445037f, 
    0.11339840f, -0.22314563f, 0.10258968f, -0.01246344f, 0.00109636f, 0.20998585f, 0.08796400f, -0.13693015f, 
    0.02485708f, -0.16320728f, 0.15707414f, 0.22743014f, -0.09652558f, 0.17178860f, 0.24411654f, 0.00267647f, 
    0.04581111f, -0.02337815f, 0.15699579f, 0.02371012f, -0.00835608f, 0.11199861f, -0.02324636f, -0.08747845f, 
    0.10951906f, -0.07719408f, 0.00266553f, 0.18854176f, 0.03468098f, 0.16465785f, 0.11061938f, -0.01747702f, 
    -0.01024021f, 0.02619358f, -0.03531359f, 0.08118109f, 0.04985541f, -0.04688932f, 0.02338109f, -0.08763477f, 
    -0.17100443f, 0.02741013f, -0.01250493f, 0.03480727f, -0.01788943f, -0.05583837f, 0.01728354f, 0.02936054f, 
    0.05464347f, 0.03817523f, 0.08229543f, 0.26084298f, 0.00857226f, 0.11150094f, -0.09298681f, -0.10936225f, 
    -0.02714181f, -0.07560805f, -0.04545375f, 0.07307082f, 0.01376812f, -0.18615837f, -0.03925927f, 0.02272980f, 
    0.01959374f, 0.17502087f, -0.01146257f, -0.10078369f, 0.14346479f, -0.00451055f, 0.16060971f, -0.01028241f, 
    0.13172466f, 0.05993290f, -0.05730035f, -0.00149861f, -0.13502650f, -0.14651859f, 0.05103144f, 0.10878205f, 
    -0.01453191f, 0.00015815f, 0.11330225f, 0.00687999f, 0.09449772f, 0.12427753f, -0.09676544f, 0.00441495f, 
    0.24609964f, -0.20267710f, 0.04659430f, 0.12830004f, 0.16324981f, 0.00111874f, -0.01854217f, -0.21594629f, 
    0.10171159f, -0.18799525f, 0.01335827f, 0.01599113f, 0.06418114f, -0.07111385f, -0.07774321f, 0.03856525f, 
    0.32016623f, 0.09793401f, 0.06320839f, -0.12785746f, 0.08191228f, 0.19886872f, 0.16230625f, 0.07548572f, 
    -0.02450856f, 0.03018720f, 0.14932187f, 0.00936566f, 0.01334008f, 0.08004106f, 0.08946452f, 0.16702309f, 
    0.09741104f, 0.00682841f, -0.01315818f, 0.06371649f, 0.06180014f, -0.01588874f, -0.01510454f, 0.07100838f, 
    0.12945794f, -0.06666476f, -0.07080727f, 0.01160598f, -0.05063814f, -0.21967657f, -0.16982420f, 0.12059186f, 
    -0.03705688f, 0.15294701f, 0.01304935f, -0.08139917f, 0.07180149f, -0.22524673f, -0.23777513f, -0.12114765f, 
    0.09489312f, -0.11203678f, 0.16101611f, 0.08878469f, -0.08474807f, 0.08007771f, -0.19371307f, -0.14055334f, 
    0.04355986f, 0.11312233f, 0.01324377f, 0.12215377f, -0.01884128f, -0.00920939f, 0.19739290f, -0.01126042f, 
    -0.01400371f, 0.02592900f, -0.05841837f, -0.08444639f, -0.00804906f, 0.08950493f, 0.09781129f, 0.04379447f, 
    -0.14410760f, 0.01529399f, -0.05802808f, 0.04149280f, -0.00981509f, 0.01308932f, 0.01186144f, 0.07036245f, 
    0.05359843f, 0.20193249f, 0.10017133f, -0.16213325f, -0.01771450f, -0.12077042f, 0.13379969f, 0.09459612f, 
    0.16622078f, 0.03073924f, 0.01716560f, 0.06897911f, -0.05759795f, 0.32415402f, -0.11624543f, 0.15073785f, 
    -0.00044416f, -0.05391148f, 0.04604213f, 0.26398095f, 0.20107840f, -0.12458250f, -0.01734046f, -0.08251011f, 
    0.24201599f, -0.04838322f, 0.23028520f, 0.07941459f, -0.08429758f, -0.16562822f, -0.01203003f, -0.07576855f, 
    0.07215936f, -0.14112009f, 0.01723041f, 0.06062200f, -0.16548063f, -0.01777810f, 0.14503329f, 0.07831905f, 
    -0.02144921f, 0.12399825f, -0.06318321f, 0.09301712f, -0.00286827f, 0.03726309f, -0.14105360f, 0.04355277f, 
    0.01371201f, 0.09725162f, 0.11101943f, -0.26272961f, -0.18430334f, -0.09976792f, -0.30424422f, 0.00893883f, 
    0.06547282f, -0.04438707f, 0.12102922f, -0.07145931f, 0.00088660f, 0.09867247f, 0.13442595f, -0.18223669f, 
    0.38045472f, -0.04359850f, -0.06321938f, 0.01101397f, 0.04855483f, -0.02284398f, 0.11887349f, 0.03938401f, 
    -0.08392024f, -0.12082893f, 0.10488901f, 0.22192135f, -0.05281916f, -0.00001124f, 0.04859960f, 0.00331326f, 
    -0.00242679f, -0.13147038f, 0.03553208f, 0.18433847f, 0.04047237f, 0.06513752f, 0.00152819f, 0.09323939f, 
    0.16778734f, 0.06239761f, 0.18552804f, 0.14531612f, -0.08862872f, -0.19814850f, 0.02394170f, 0.01689157f, 
    0.00780094f, 0.05905242f, 0.14138125f, 0.10604004f, 0.34640792f, 0.22712347f, -0.10870869f, 0.34925130f, 
    0.10059136f, 0.10016786f, 0.19319977f, -0.04578748f, 0.08168595f, -0.08743300f, -0.21331556f, -0.97445953f, 
    0.27339450f, 0.02329137f, 0.01350985f, -0.00408273f, -0.14091624f, -0.08312710f, -0.46561012f, 0.05529836f, 
    0.21257496f, 0.06124444f, -0.01976581f, -0.13922894f, 0.05419049f, 0.00995280f, 0.26113915f, 0.39444783f, 
    -0.00761195f, -0.04332777f, -0.06253826f, -0.05204580f, 0.25326416f, 0.08507274f, 0.02987901f, -0.08646899f, 
    0.01190405f, -0.14104934f, -0.21078154f, 0.10044344f, 0.08734511f, 0.00605641f, -0.02141295f, 0.02978142f, 
    0.06991475f, -0.45012227f, -1.00157320f, -0.04523757f, 0.14392801f, 0.13357106f, -0.10831764f, -0.02535837f, 
    -0.11381416f, -0.10376469f, 0.00207205f, 0.09432957f, 0.37858677f, 0.22588244f, 0.07036392f, 0.18471263f, 
    0.10543107f, 0.20029880f, 0.01527224f, -0.49129575f, 0.52706778f, 0.55199635f, -0.03444146f, 0.06927822f, 
    -0.04204001f, -0.09659585f, 0.09959358f, 0.06134514f, -0.30929494f, -0.33834335f, -0.21018288f, -0.10764867f, 
    -0.01029219f, 0.15453725f, -0.04409035f, 0.00453154f, 0.01455283f, 0.36308289f, -0.15993409f, -0.40101659f, 
    0.03436609f, -0.06741868f, 0.18768841f, -0.07341016f, -0.01071257f, -0.12699941f, 0.00373922f, 0.03413372f, 
    -0.02516303f, 0.10648940f, -0.01956195f, -0.09343833f, 0.04858741f, 0.05410451f, 0.32120335f, -0.04501420f, 
    -0.30389911f, 0.01250895f, -0.02595247f, 0.03209331f, -0.15524761f, 0.12249093f, -0.08734708f, -0.08709542f, 
    -0.28341845f, -0.36281365f, -0.20930994f, -0.16364850f, 0.23550920f, -0.07734782f, 0.26173127f, -0.02605111f, 
    0.26475298f, -0.05748760f, -0.15935299f, 0.02791699f, -0.11843912f, -0.01313540f, 0.00100735f, 0.07746201f, 
    -0.07575829f, -0.09903246f, -0.43829867f, -0.22788520f, -0.18565108f, -0.25517145f, 0.04621406f, 0.04001147f, 
    0.01501140f, 0.01768469f, 0.16689435f, -0.17929299f, -0.00560151f, 0.12830196f, -0.03580298f, -0.09562126f, 
    -0.03761340f, 0.04975972f, 0.10476034f, 0.15074763f, -0.09080137f, 0.39374033f, 0.08352751f, 0.00360264f, 
    -0.04055906f, -0.08320422f, -0.16201439f, 0.02157275f, 0.06157846f, -0.79491258f, -0.44946009f, 0.19191690f, 
    -0.29563281f, -0.08687337f, -0.28167483f, -0.15482120f, -0.10338122f, -0.02458857f, -0.13444534f, -0.39294952f, 
    -0.46922287f, 0.19230290f, -0.00853886f, -0.05543165f, -0.00432534f, 0.10223607f, 0.09420096f, -0.04008926f, 
    -0.23744568f, -0.06903730f, 0.12068947f, 0.23965965f, 0.06214572f, 0.16306192f, -0.03964123f, 0.16995282f, 
    -0.14044626f, 0.11676210f, -0.10302805f, 0.12865134f, 0.05842384f, 0.00387182f, 0.26791245f, -0.01892024f, 
    0.11228650f, 0.13026579f, -0.41227633f, -0.18818538f, 0.05529743f, 0.23673624f, 0.00151830f, 0.16929929f, 
    0.00050334f, -0.06299993f, -0.44057113f, -0.16446547f, -0.72678196f, -0.02092245f, 0.00607611f, 0.09524364f, 
    0.02904907f, 0.06612632f, 0.06868704f, -0.04285883f, -0.29530385f, 0.15729494f, -0.02750279f, -0.05740033f, 
    0.04879485f, 0.25753051f, 0.03221837f, 0.06304494f, -0.03031645f, 0.30495507f, 0.04228334f, 0.04601294f, 
    -0.05058530f, -0.20240390f, -0.01030954f, -0.08090718f, -0.23362365f, 0.03676684f, 0.12648931f, 0.01038095f, 
    0.05547388f, 0.05648571f, -0.09801111f, 0.22784089f, 0.12660496f, 0.39943844f, -0.06264920f, -0.03379814f, 
    -0.25080371f, -0.25247672f, 0.05388711f, -0.24635489f, -0.19426814f, -0.23167078f, -0.20796441f, 0.13460992f, 
    -0.04667174f, 0.06145044f, 0.01994163f, -0.01881442f, 0.07672200f, 0.03673708f, -0.09731943f, -0.07101050f, 
    0.04256243f, 0.01694786f, -0.00373603f, -0.01665702f, -0.06048450f, -0.05152919f, 0.01510147f, -0.01096713f, 
    -0.01225452f, -0.05716005f, -0.04466317f, -0.06168600f, 0.03377696f, 0.03690224f, 0.01194014f, -0.01317626f, 
    0.01318020f, -0.00867597f, -0.02818037f, -0.04556382f, -0.01743942f, -0.00331900f, -0.03332061f, -0.03380219f, 
    0.01091655f, -0.04858077f, -0.06104396f, 0.03324611f, -0.00991663f, -0.06233347f, -0.01393526f, -0.04472293f, 
    -0.00748070f, 0.01055777f, 0.03727441f, -0.04452246f, 0.02948158f, 0.05382031f, 0.02700625f, 0.01168160f, 
    -0.06369404f, -0.05879255f, -0.06065877f, -0.01931373f, -0.00740459f, -0.00887957f, -0.05529821f, -0.05741458f, 
    -0.04933830f, -0.04461184f, -0.01633236f, -0.02030648f, 0.03944200f, -0.00018999f, -0.01953279f, 0.00363804f, 
    0.03689934f, -0.03190186f, -0.04277186f, -0.04645912f, 0.00138722f, -0.03586905f, 0.00690539f, -0.03369734f, 
    0.00393505f, -0.01182767f, 0.02158920f, -0.05460199f, -0.02597169f, -0.06308312f, 0.01670457f, 0.00475914f, 
    -0.00757120f, 0.02275219f, -0.01989155f, 0.04545155f, 0.03847416f, -0.03254109f, -0.05256618f, -0.05241948f, 
    0.04413703f, -0.04431251f, 0.01517492f, 0.02014165f, 0.05196083f, 0.01368937f, 0.03423769f, 0.04447329f, 
    -0.03916422f, 0.04169978f, -0.01314118f, -0.03709390f, -0.04114449f, -0.01933180f, -0.00803120f, -0.06083933f, 
    -0.06069863f, 0.02601287f, -0.00857680f, -0.03698884f, 0.02619893f, -0.02737069f, -0.02288270f, -0.03483924f, 
    -0.06326383f, -0.06354232f, -0.03933954f, 0.02558338f, -0.00719078f, 0.01248634f, 0.04795222f, 0.01325755f, 
    -0.05268722f, -0.03239881f, 0.01096139f, -0.02627556f, 0.05094045f, -0.02728027f, -0.06231368f, 0.00899510f, 
    0.02179039f, 0.01052029f, 0.00995176f, 0.00436546f, 0.01968240f, -0.00837282f, -0.04690744f, 0.01643708f, 
    -0.00333337f, 0.01188922f, 0.01427834f, -0.01737940f, -0.02625339f, -0.01509221f, -0.03213181f, 0.02978981f, 
    0.00520968f, -0.04358191f, 0.03302989f, 0.04400187f, -0.00521284f, 0.05037394f, 0.01416701f, -0.00729695f, 
    -0.01175721f, 0.01895721f, 0.00181037f, 0.05226049f, 0.03991973f, -0.01104022f, -0.05771707f, -0.03524492f, 
    -0.01889911f, 0.03333821f, -0.01504977f, -0.03526034f, -0.00004331f, 0.04203281f, -0.01215949f, -0.01990947f, 
    0.03319574f, -0.05785938f, 0.04541862f, 0.04041407f, -0.05678095f, 0.01742987f, 0.01244214f, -0.03282936f, 
    -0.04921144f, -0.04556756f, 0.01541255f, 0.00538753f, -0.01860681f, 0.02350151f, 0.04320865f, -0.05317830f, 
    -0.04468487f, -0.01584916f, 0.04297670f, -0.00585019f, 0.01546821f, 0.04259608f, -0.01804711f, -0.05372407f, 
    -0.00899954f, 0.01542472f, 0.02524732f, 0.00724647f, 0.03408589f, -0.02766931f, -0.02850650f, 0.04096514f, 
    -0.03475946f, -0.03894942f, 0.03579137f, 0.03498564f, -0.00880614f, 0.01696173f, -0.05391615f, -0.05926179f, 
    -0.00754855f, -0.01171088f, -0.00459715f, 0.03817625f, -0.05951323f, -0.01898391f, 0.04030339f, 0.00586287f, 
    -0.04159078f, 0.04121410f, -0.00740667f, -0.00755617f, -0.01948572f, -0.01686205f, -0.06039387f, 0.04906217f, 
    0.01083552f, -0.05760841f, 0.01398888f, -0.02408970f, -0.03460402f, -0.03233821f, 0.03671722f, -0.02110279f, 
    0.01909602f, -0.00782197f, 0.02853280f, 0.01232126f, -0.03490349f, 0.01747415f, 0.03534991f, 0.04824224f, 
    -0.02973207f, 0.04140763f, -0.04915221f, -0.06699805f, 0.03612332f, 0.01020040f, -0.04063969f, -0.01308289f, 
    -0.02715677f, -0.02054321f, -0.00146862f, 0.04725144f, -0.07216015f, 0.05282925f, 0.04755258f, -0.01405548f, 
    -0.02154769f, 0.05168900f, -0.06026842f, -0.05973311f, 0.03991548f, 0.04563238f, -0.04477603f, -0.03619694f, 
    0.03493316f, -0.00215365f, 0.01925053f, 0.00893926f, -0.01277987f, -0.01235667f, -0.02926175f, -0.03354859f, 
    0.01468797f, 0.00943389f, 0.01994080f, -0.07085910f, -0.07074679f, 0.00808839f, 0.01922226f, -0.06828283f, 
    -0.05920181f, -0.05904177f, -0.05771393f, -0.03582048f, 0.04451798f, 0.03953749f, -0.03667045f, 0.01843652f, 
    0.02998388f, 0.00201478f, 0.01164470f, 0.02592359f, -0.00517864f, 0.00623040f, -0.04881037f, 0.01147301f, 
    -0.16475441f, 0.14608282f, -0.00814435f, 0.02934567f, 0.10871364f, -0.08369251f, 0.12902544f, -0.17950256f, 
    -0.00479302f, 0.01058744f, -0.09893184f, -0.12495056f, 0.00153121f, 0.00315002f, -0.05046084f, 0.10270024f, 
    0.11149289f, 0.12793048f, -0.02991032f, -0.11592854f, -0.25082883f, -0.02679401f, -0.01614534f, -0.11549594f, 
    -0.27061507f, 0.00154753f, -0.02283691f, -0.03389208f, 0.01728002f, -0.10678990f, -0.05282276f, -0.14360161f, 
    -0.10043090f, -0.16512163f, -0.07957112f, -0.02480698f, -0.23654924f, 0.12727278f, -0.03650894f, -0.00739780f, 
    -0.09382287f, 0.13596351f, 0.34902662f, -0.10786148f, 0.27035818f, -0.14384440f, 0.00338381f, 0.32559630f, 
    -0.08755191f, -0.11139022f, 0.02817069f, -0.06859635f, 0.07280447f, 0.17805651f, -0.04232012f, 0.22221169f, 
    0.24683432f, 0.01728063f, -0.16535215f, -0.06229520f, 0.12155809f, -0.05875857f, 0.01209373f, 0.07157817f, 
    0.02145240f, -0.15422806f, -0.00373313f, -0.02596485f, -0.15072487f, 0.10713790f, 0.25620684f, 0.13685657f, 
    0.02588543f, 0.07046861f, 0.30510792f, -0.00553836f, 0.07655591f, -0.00096951f, 0.15912488f, 0.13105568f, 
    -0.12971516f, 0.06808423f, -0.04246842f, 0.06354342f, 0.12378453f, -0.09066647f, 0.12333141f, -0.05327665f, 
    0.08579887f, 0.01141826f, 0.34790662f, -0.17228226f, 0.03345038f, 0.01596077f, -0.11653124f, 0.01052353f, 
    0.08543230f, 0.05453864f, 0.12797979f, -0.20366429f, 0.05794225f, 0.22566099f, 0.15630521f, 0.05648188f, 
    -0.06678652f, -0.06442447f, -0.03961369f, 0.08877529f, -0.03759107f, 0.11352349f, -0.06057492f, 0.08460683f, 
    -0.12441396f, 0.09463485f, -0.04943483f, 0.02858532f, -0.05199150f, -0.01593974f, -0.23929985f, -0.29589242f, 
    -0.12332263f, 0.06877873f, -0.04075880f, 0.03087860f, 0.23825590f, 0.07369759f, -0.06940667f, -0.07071835f, 
    -0.03260888f, -0.04194324f, -0.02450798f, -0.07174640f, 0.12396035f, 0.10541790f, 0.01215954f, 0.24639373f, 
    0.06827477f, -0.01840105f, -0.02821351f, -0.02391957f, -0.08879909f, -0.04088903f, 0.19180918f, 0.11906634f, 
    -0.02727336f, -0.15833612f, 0.03412398f, -0.15597332f, -0.28768799f, -0.23186961f, 0.13112283f, -0.22869736f, 
    -0.17467403f, 0.09200370f, 0.00529501f, -0.06156600f, 0.03365536f, -0.01290342f, 0.08270540f, 0.13498805f, 
    0.12737399f, 0.08675189f, 0.31978318f, -0.03498197f, -0.36346033f, -0.14864717f, -0.12894759f, -0.16911182f, 
    -0.09012932f, 0.11986309f, -0.01676850f, 0.08558805f, -0.01810665f, 0.02560795f, 0.15265994f, 0.01445296f, 
    0.11191346f, 0.12716107f, 0.14851587f, 0.19808094f, -0.33667266f, -0.01801650f, 0.08673535f, 0.01886481f, 
    -0.08937143f, 0.01259539f, 0.05490174f, 0.00494621f, 0.00217592f, -0.24817726f, -0.08389001f, -0.00788406f, 
    0.02126474f, -0.15685064f, 0.00543840f, -0.03919818f, -0.01021740f, 0.01052345f, 0.00724670f, -0.02773620f, 
    0.24909358f, 0.08266806f, -0.10287695f, 0.06261021f, 0.08560514f, 0.10754192f, 0.10142057f, -0.01307735f, 
    0.16062415f, 0.25287664f, -0.06690911f, 0.00826868f, -0.03734493f, 0.06802670f, 0.04147829f, 0.16867311f, 
    -0.06051157f, 0.02903128f, 0.03631603f, -0.12763429f, -0.13856328f, 0.06904792f, 0.07650163f, 0.05503338f, 
    -0.07628574f, -0.00840697f, 0.01626628f, 0.09990587f, -0.00123085f, 0.13706669f, -0.25700769f, 0.06014808f, 
    -0.09821584f, 0.00973674f, -0.13993359f, -0.17395473f, 0.17717648f, -0.00297391f, 0.00482001f, 0.06684903f, 
    -0.00221573f, 0.02219144f, -0.05284490f, -0.09926533f, -0.37295797f, -0.16819249f, -0.17257938f, -0.26410672f, 
    0.11259294f, -0.08386945f, -0.06419329f, -0.01084999f, -0.11866137f, -0.14630051f, 0.22326529f, 0.06943883f, 
    0.14510727f, -0.04917251f, -0.00571599f, 0.17972964f, 0.07141748f, -0.13097061f, -0.05406795f, -0.15992025f, 
    0.04565987f, 0.00122022f, -0.11443682f, 0.22220328f, 0.10990871f, 0.18738621f, -0.21698530f, -0.26625854f, 
    -0.12366113f, -0.19645749f, 0.00175500f, -0.15102762f, 0.07374266f, 0.17229468f, 0.05371501f, 0.05202841f, 
    -0.09233282f, -0.20206134f, 0.07553650f, -0.11949301f, 0.05278947f, 0.12036663f, 0.20977341f, 0.16719848f, 
    -0.00436072f, 0.01163199f, -0.00184522f, -0.01771937f, 0.03828806f, -0.05317993f, -0.05575961f, -0.00206227f, 
    -0.03495169f, -0.05178626f, -0.02978373f, 0.02270391f, -0.04100640f, 0.02216009f, -0.01984828f, -0.05692971f, 
    0.02712190f, 0.04328938f, 0.04579122f, 0.04254840f, -0.03031356f, 0.03411566f, 0.03314298f, 0.01384487f, 
    0.02153433f, -0.03376681f, -0.02884725f, 0.00328252f, -0.02234087f, -0.02554364f, -0.02467003f, -0.00178699f, 
    0.02677427f, 0.00024115f, 0.00932432f, -0.06023855f, 0.02615157f, 0.01769427f, 0.00501427f, 0.01132757f, 
    0.01124526f, 0.00533364f, 0.04047256f, 0.00710366f, -0.06124830f, 0.02479954f, -0.02073126f, 0.04579370f, 
    0.00019388f, -0.04449890f, -0.00475494f, -0.03568111f, 0.01114947f, -0.03085589f, -0.01298201f, 0.03041109f, 
    -0.03929180f, 0.02311016f, 0.01319750f, -0.02661461f, 0.01872198f, -0.02641606f, -0.04629880f, 0.01006886f, 
    -0.02266771f, -0.03204046f, -0.01406309f, 0.02520194f, -0.00273419f, -0.04770439f, 0.05113955f, -0.05893287f, 
    -0.02112280f, 0.01692083f, 0.03937499f, -0.05106799f, 0.03433961f, 0.00694863f, 0.02160710f, -0.05526433f, 
    0.05040453f, -0.03183454f, 0.04822405f, -0.04614257f, 0.00789167f, -0.02520563f, 0.03437978f, -0.03193353f, 
    -0.00421105f, -0.01362610f, -0.00109415f, -0.00802813f, -0.01364590f, 0.03026046f, 0.01580334f, -0.01817303f, 
    0.02972453f, -0.03864351f, 0.03498324f, 0.04299589f, -0.03744784f, -0.02735394f, -0.03037177f, -0.05164063f, 
    0.00237333f, 0.01292779f, -0.04764774f, -0.04511051f, -0.01109118f, 0.03191917f, -0.02880064f, -0.00909627f, 
    -0.05370850f, -0.04117021f, 0.04272362f, -0.01471159f, 0.03990304f, -0.01309023f, -0.04595203f, 0.03801658f, 
    -0.01231244f, 0.02964066f, 0.05785627f, -0.01694035f, -0.05109873f, -0.04587203f, -0.06461207f, -0.04005991f, 
    0.02115099f, 0.02327854f, 0.00057106f, -0.00703653f, -0.03819083f, -0.00918937f, -0.05661264f, -0.01545568f, 
    -0.05151521f, -0.05837025f, 0.02362295f, -0.01268217f, 0.01175501f, 0.04981691f, 0.00280991f, 0.02726806f, 
    -0.02798600f, 0.04503861f, 0.02470147f, -0.02390084f, -0.02082225f, 0.00248002f, 0.04263777f, 0.00072179f, 
    0.02980208f, -0.03922904f, -0.05488810f, 0.00587342f, 0.00927779f, -0.03236702f, 0.00660656f, 0.00194229f, 
    -0.02442032f, -0.00965927f, 0.05081108f, 0.03695593f, 0.02381408f, -0.06129188f, -0.03322491f, 0.02760236f, 
    -0.04679467f, -0.01568374f, -0.03056212f, 0.00633902f, 0.04790643f, -0.05056634f, -0.05871550f, -0.00700684f, 
    0.01560342f, -0.06358621f, -0.05139023f, -0.04076022f, -0.02756003f, 0.00192105f, 0.01660138f, 0.01702331f, 
    0.03624069f, 0.03207447f, 0.05230770f, -0.04199940f, -0.02147939f, 0.00524734f, 0.03600249f, 0.01716734f, 
    -0.01791734f, -0.02874941f, -0.02580472f, -0.03507943f, 0.03964008f, 0.00498435f, -0.04015753f, 0.01555126f, 
    -0.05121676f, -0.04055016f, -0.05981994f, 0.00022074f, -0.03118952f, -0.00148023f, -0.03704077f, -0.00455659f, 
    -0.05927050f, 0.01533375f, -0.05071346f, -0.01028951f, 0.01575892f, 0.03101058f, 0.03478497f, -0.01748522f, 
    -0.01949232f, -0.03932950f, -0.02303234f, -0.04118894f, -0.01349927f, -0.04141217f, -0.04554255f, 0.00810027f, 
    -0.06350133f, -0.05359958f, -0.04053772f, -0.04106851f, 0.03390095f, -0.00170647f, 0.05208907f, 0.01524626f, 
    -0.06117568f, 0.03703646f, -0.02949362f, -0.05855197f, -0.02570315f, 0.04638357f, -0.01238453f, 0.03168763f, 
    0.00090631f, 0.00714335f, 0.02188720f, -0.03452007f, -0.00541593f, 0.01424109f, 0.04038771f, -0.05038158f, 
    0.04805873f, -0.01714367f, 0.02660079f, -0.01140010f, -0.05504507f, 0.03302977f, -0.02474084f, -0.00165349f, 
    -0.05297485f, -0.03575653f, 0.01138428f, -0.02957585f, -0.02255286f, -0.01428431f, -0.00709232f, -0.00798596f, 
    -0.03736357f, 0.03760303f, -0.04849993f, -0.02951068f, -0.06459841f, -0.06220657f, -0.00167585f, 0.01672741f, 
    0.01997550f, -0.03302372f, 0.03918255f, -0.03547751f, -0.04052905f, 0.03468588f, 0.04948604f, -0.03245214f, 
    0.03807472f, 0.00965705f, 0.03400315f, 0.04974968f, -0.05950408f, 0.04745663f, 0.00565944f, -0.02054928f, 
    -0.20121108f, 0.00265339f, 0.17515938f, -0.04859205f, -0.09882633f, -0.06577355f, 0.07400937f, 0.00060320f, 
    -0.14506812f, 0.31250077f, -0.10414086f, -0.01003482f, -0.07329494f, -0.16070345f, -0.13283284f, 0.10630796f, 
    0.01355818f, 0.05380805f, 0.07919165f, 0.07352995f, 0.11894483f, 0.06575289f, -0.17083313f, 0.00163382f, 
    -0.02396824f, -0.16286342f, -0.05226390f, -0.03122095f, 0.11804014f, 0.26699993f, 0.09490454f, 0.05459130f, 
    -0.01192029f, 0.07958122f, -0.10712574f, 0.15838751f, -0.51730543f, -0.16858625f, -0.33571824f, 0.01721478f, 
    0.16094522f, 0.12497983f, -0.01381285f, -0.03331708f, 0.02317003f, -0.17426366f, 0.34445903f, 0.41222343f, 
    0.03280372f, -0.06127947f, -0.01532518f, -0.02377043f, 0.15445411f, -0.14865978f, 0.11147293f, -0.04877485f, 
    -0.75798631f, -0.08515129f, 0.15926865f, -0.04191656f, -0.03690794f, -0.07586065f, -0.12352992f, -0.12147674f, 
    -0.11379705f, 0.19324303f, -0.18660948f, 0.07364108f, -0.16307381f, -0.00922713f, 0.18662477f, -0.08421986f, 
    -0.20611995f, 0.14305010f, -0.02264887f, -0.04689610f, -0.17773417f, -0.03162475f, -0.04095516f, -0.06868745f, 
    0.27924800f, 0.16249162f, 0.10648172f, 0.24641567f, -0.14827217f, 0.02559174f, -0.07739091f, 0.15102117f, 
    -0.03365858f, 0.08777441f, 0.37329751f, -0.23994355f, -0.01707763f, -0.18095560f, -0.08153749f, 0.18147571f, 
    -0.02926561f, 0.17836249f, -0.03875111f, 0.11991073f, -0.52074987f, -0.33109918f, 0.05046222f, 0.00799856f, 
    -0.00978456f, -0.03019409f, 0.07778224f, 0.09178519f, 0.51891029f, 0.26243591f, 0.16259757f, -0.04028596f, 
    -0.05787181f, 0.04867142f, 0.02205367f, 0.01781535f, 0.10645206f, -0.16605398f, -0.10435651f, 0.11862006f, 
    -0.14118434f, 0.07732777f, -0.01859763f, 0.12098487f, -0.00744721f, -0.00182353f, -0.07939115f, 0.14926277f, 
    0.20178016f, 0.17295581f, -0.00022500f, 0.07240090f, -0.05716676f, -0.17572501f, -0.00813232f, 0.03127946f, 
    0.01011791f, 0.13930392f, -0.06349275f, 0.06317085f, 0.03878058f, 0.04648103f, 0.06672003f, 0.04835613f, 
    0.25739402f, -0.17527929f, -0.06083771f, -0.25334424f, -0.01062897f, -0.16049610f, 0.08315416f, 0.07437956f, 
    0.03697740f, 0.15505984f, 0.27767050f, 0.15823036f, -0.09137648f, -0.14099292f, -0.28810841f, 0.11888083f, 
    0.19109395f, 0.06290369f, 0.70977980f, -0.14838406f, 0.39111215f, -0.24216156f, 0.20622109f, -0.14182687f, 
    0.05229068f, -0.04615927f, -0.01577137f, 0.24174689f, 0.08202214f, 0.18174843f, -0.14883788f, -0.27288759f, 
    -0.40215215f, 0.09293157f, -0.00712700f, 0.06801411f, 0.53098810f, -0.07862882f, -0.09268394f, 0.04908759f, 
    -0.08528945f, 0.01534787f, -0.06825106f, -0.05059998f, 0.07703844f, 0.49664637f, 0.39191788f, -0.03783073f, 
    -0.10317008f, -0.11715740f, -0.04810298f, -0.06962693f, -0.03816640f, -0.04519622f, -0.07795452f, 0.15621231f, 
    -0.56831586f, -0.00774904f, 0.00494638f, 0.03161381f, -0.14540052f, -0.02731766f, -0.07863452f, -0.32835588f, 
    0.30011180f, -0.55317128f, -0.07793416f, -0.09166114f, 0.09133580f, 0.07516265f, -0.08532227f, -0.01234279f, 
    -0.02901894f, -0.02083736f, -0.00664772f, -0.11995526f, -0.04323902f, 0.00630375f, 0.18126179f, 0.01627892f, 
    0.06960852f, -0.14080979f, 0.30795991f, 0.15332352f, -0.06324355f, -0.02445330f, 0.00194630f, 0.06218713f, 
    0.07445078f, 0.02568054f, -0.24134168f, 0.01609479f, 0.31925410f, -0.14966570f, 0.02750352f, -0.04213642f, 
    0.17369638f, 0.03573903f, 0.08810670f, -0.71421659f, -0.31041005f, 0.33352160f, -0.15048546f, 0.09764739f, 
    0.01186250f, 0.01231448f, 0.07148666f, 0.13957830f, 0.08160613f, -0.02351953f, -0.01214408f, 0.12030789f, 
    -0.19210970f, -0.04053449f, -0.00992333f, 0.10297035f, 0.05499545f, 0.02243933f, 0.20742455f, 0.19472523f, 
    0.06150209f, 0.03225992f, -0.13853662f, 0.05305700f, -0.19435439f, 0.13842779f, 0.07079776f, 0.11681779f, 
    0.14364980f, 0.03949270f, -0.00870794f, 0.00452145f, 0.00159240f, 0.03775797f, -0.07761655f, 0.04669207f, 
    0.22878598f, 0.02005498f, 0.09998325f, -0.19036970f, -0.10614857f, 0.17802939f, -0.10394948f, -0.05554366f, 
    0.03968361f, -0.05946722f, -0.04490333f, -0.04776677f, 0.01159573f, 0.02030321f, -0.01575174f, 0.03300902f, 
    0.01570274f, -0.03231646f, 0.01481778f, 0.00587170f, 0.04465160f, 0.00744047f, -0.05272128f, 0.02527992f, 
    -0.00426640f, -0.04239345f, -0.01845622f, 0.03878345f, -0.00341470f, 0.02916254f, 0.01286739f, -0.01018822f, 
    -0.03671011f, 0.05207841f, -0.05667171f, -0.06216152f, 0.04691918f, -0.05577966f, 0.03393713f, 0.01401587f, 
    0.01923706f, -0.02695662f, 0.01685988f, 0.03389096f, 0.04455626f, -0.00693614f, 0.00576807f, 0.01873400f, 
    -0.01438520f, -0.00345560f, 0.04711500f, 0.02809846f, 0.01990269f, -0.05652721f, -0.05389553f, 0.03939360f, 
    -0.00101909f, -0.00167733f, 0.03772533f, 0.04639893f, 0.04614843f, -0.03708471f, -0.03688639f, 0.00197608f, 
    -0.01852119f, 0.04203304f, 0.03724157f, 0.02655261f, 0.05276956f, 0.05423374f, -0.04768965f, 0.01351703f, 
    -0.04558478f, 0.04566263f, 0.01379634f, -0.03331022f, -0.05379416f, 0.00230855f, -0.00600905f, 0.00100947f, 
    -0.05958216f, -0.04398439f, -0.01051191f, 0.02784488f, -0.02182940f, -0.00007602f, -0.06172812f, 0.04167651f, 
    -0.01247583f, -0.06439116f, -0.04899161f, -0.02012897f, 0.00740885f, -0.00123881f, -0.00616228f, 0.00609111f, 
    -0.05546185f, 0.02057588f, 0.02447246f, -0.00532456f, -0.04834654f, -0.02843362f, -0.05171006f, -0.01777469f, 
    -0.02111772f, 0.03757331f, 0.04215212f, -0.05483812f, -0.04472957f, -0.04288421f, 0.01394602f, -0.00650971f, 
    0.00743234f, -0.05534332f, 0.01990294f, 0.03664368f, -0.01288948f, -0.04843684f, 0.03626366f, -0.01347852f, 
    -0.03385436f, -0.00635803f, -0.04591062f, -0.01661661f, -0.05180034f, 0.00150445f, -0.05133702f, 0.03370902f, 
    0.00506610f, 0.01304738f, 0.03017857f, 0.02840061f, -0.06576524f, 0.04153619f, -0.04819578f, 0.01470938f, 
    -0.04832718f, 0.03342398f, -0.00442436f, -0.04159955f, -0.00463848f, 0.00771457f, -0.00027442f, -0.06004291f, 
    -0.02351777f, 0.01410539f, 0.03256355f, -0.04399349f, 0.03516806f, -0.03911388f, 0.00664691f, -0.03926001f, 
    0.02490578f, 0.03505995f, 0.00391856f, 0.01825985f, 0.00458968f, -0.05064143f, 0.01501274f, 0.03286405f, 
    0.03716336f, -0.05756680f, 0.03218048f, -0.02101149f, 0.03419780f, 0.00183470f, 0.01209068f, -0.03884633f, 
    0.03300372f, -0.01440120f, 0.02050807f, -0.01356675f, 0.02306009f, -0.03820849f, 0.04214225f, -0.04227946f, 
    0.00365439f, 0.00453620f, 0.02618744f, -0.02790996f, 0.00798458f, -0.02487381f, 0.02439286f, -0.06179891f, 
    -0.03680069f, -0.03129757f, -0.01331237f, -0.05619581f, 0.01747932f, -0.05451170f, -0.03047034f, -0.06487539f, 
    0.02762426f, -0.05077470f, -0.05256327f, 0.03546312f, 0.02498106f, 0.02781853f, 0.04333507f, -0.01341963f, 
    0.01796565f, 0.04237630f, -0.00331100f, 0.03377083f, -0.00072463f, -0.04138826f, 0.03208350f, -0.05062694f, 
    0.04669623f, 0.03618452f, 0.01172687f, -0.02797510f, 0.01857911f, -0.05270090f, -0.01974609f, 0.01424707f, 
    -0.02629549f, 0.03626166f, -0.03058816f, -0.05600530f, -0.04908997f, -0.05806598f, 0.00244376f, 0.04972371f, 
    -0.00301955f, 0.00533536f, -0.02364632f, 0.02727377f, -0.00483419f, -0.05625794f, 0.05114907f, -0.00210787f, 
    0.00725810f, 0.02112978f, 0.03344706f, -0.06309647f, -0.04038799f, 0.05768447f, 0.02966962f, 0.01090894f, 
    -0.00163315f, -0.04562839f, 0.00492749f, -0.06412233f, 0.00260712f, -0.00487731f, -0.02358011f, -0.05183339f, 
    -0.02005937f, -0.03507617f, 0.02578254f, 0.03059464f, -0.04607943f, -0.02033769f, 0.03033187f, 0.03144196f, 
    -0.00548514f, -0.02910553f, -0.03519877f, 0.03361592f, -0.04392131f, -0.02814516f, -0.04895969f, 0.02158385f, 
    0.05061717f, 0.05045879f, -0.00441197f, 0.00340218f, 0.05326211f, -0.03838561f, 0.04858875f, 0.03257784f, 
    -0.04861708f, -0.05105895f, -0.02712633f, -0.04460556f, -0.02032288f, 0.00664797f, 0.00186889f, 0.04351991f, 
    -0.02070946f, 0.02267688f, -0.02610080f, -0.05791692f, -0.05147803f, 0.04653193f, 0.02122752f, 0.05199813f, 
    -0.04678785f, 0.02671331f, -0.04996768f, 0.03049796f, -0.03115019f, 0.01271901f, -0.01124774f, -0.04169076f, 
    -0.04181514f, 0.00704500f, -0.05681315f, -0.05903856f, -0.01627394f, -0.03962643f, 0.01746088f, -0.05077963f, 
    -0.03984033f, 0.00965468f, 0.03815771f, -0.05890927f, -0.03841666f, 0.02712643f, -0.00159343f, -0.00258340f, 
    0.00001076f, -0.00480945f, 0.00002762f, -0.05379464f, -0.01596208f, -0.03912405f, -0.05084269f, 0.01617687f, 
    -0.00831017f, -0.02400168f, -0.05157781f, -0.03445131f, -0.01782652f, -0.04643464f, 0.04849118f, -0.00289686f, 
    0.01717974f, -0.01816028f, 0.02972570f, -0.00607785f, -0.06222885f, 0.01227496f, -0.05484462f, -0.05653814f, 
    0.00238101f, 0.00358228f, -0.00174681f, 0.00130239f, -0.05510207f, -0.01193487f, 0.04470869f, -0.04891657f, 
    -0.03288548f, 0.04156715f, 0.04110741f, -0.00402663f, 0.03950779f, -0.00598871f, -0.00620860f, -0.01389639f, 
    -0.02939222f, -0.06427252f, 0.03427649f, 0.02534332f, 0.04193063f, -0.04962330f, 0.03942120f, -0.06066933f, 
    0.01480916f, 0.03003048f, -0.01293417f, 0.02445741f, -0.01843510f, -0.04017740f, -0.02142624f, 0.00906872f, 
    0.01000612f, -0.00233218f, 0.02603575f, 0.01056199f, -0.02362913f, -0.05486244f, -0.01052548f, 0.01216722f, 
    -0.03280935f, -0.02109667f, -0.02740424f, -0.04724619f, -0.06457463f, 0.00697492f, -0.05765521f, -0.05309478f, 
    -0.01539446f, 0.03553132f, -0.05136228f, -0.06417365f, -0.05382305f, 0.04516809f, 0.00164804f, -0.01387157f, 
    -0.01522743f, 0.02409433f, 0.02565505f, -0.00714733f, -0.00987715f, -0.03951493f, -0.03297408f, -0.02335135f, 
    0.02880291f, 0.03403605f, -0.01490660f, 0.04166879f, -0.03952493f, -0.03840886f, -0.03184589f, -0.00019057f, 
    0.00983652f, -0.01617497f, -0.01968362f, 0.02839389f, -0.01184544f, -0.00533927f, 0.03949613f, -0.02537924f, 
    0.01293707f, -0.04916922f, 0.01323808f, -0.03046851f, -0.06135442f, 0.00572035f, -0.06453105f, -0.00135302f, 
    -0.04090973f, -0.00294841f, -0.02823037f, -0.01525652f, 0.02040490f, 0.04941788f, 0.01101238f, -0.02845061f, 
    0.01018796f, -0.06424814f, -0.04217227f, 0.01893529f, -0.05794203f, -0.04935344f, -0.00720335f, -0.06177044f, 
    -0.01906695f, -0.04033476f, -0.03429944f, -0.00405827f, 0.05718490f, 0.04765708f, 0.02486788f, 0.02182239f, 
    -0.03239470f, -0.00327454f, 0.03561792f, 0.00410266f, 0.03918786f, 0.03845723f, -0.02682663f, -0.05484066f, 
    -0.02662585f, -0.05082018f, 0.01819268f, 0.04147140f, -0.05360738f, -0.04709165f, 0.00797439f, -0.04358253f, 
    0.02116209f, 0.04803396f, -0.03624381f, -0.01450934f, -0.02972241f, -0.01100755f, 0.03085575f, 0.01633161f, 
    0.02962670f, 0.00984239f, 0.02764358f, -0.04389630f, -0.00078069f, 0.03289402f, -0.03624367f, -0.05531695f, 
    0.04834624f, -0.02129797f, 0.05535853f, -0.03137220f, -0.02931045f, -0.01998224f, -0.05078596f, -0.03958438f, 
    -0.04562243f, 0.02104808f, 0.04111155f, 0.03917152f, 0.00305912f, 0.01102358f, -0.05069486f, -0.03835535f, 
    -0.02827195f, -0.03487107f, -0.05520551f, 0.02155459f, -0.03108951f, -0.06834157f, -0.01036031f, 0.03729504f, 
    0.04018117f, -0.05886173f, 0.01823390f, 0.02365624f, -0.01140855f, -0.00604233f, -0.01725110f, -0.03512048f, 
    0.02653592f, 0.02818433f, -0.01125249f, 0.00058739f, -0.04044586f, 0.02359337f, 0.04718188f, 0.01977675f, 
    -0.03227315f, -0.04738024f, 0.03883991f, 0.00530341f, 0.04327918f, -0.00358964f, -0.06719088f, 0.01991728f, 
    -0.00944448f, -0.01291733f, -0.00034211f, 0.04789516f, -0.05321516f, -0.01711760f, 0.03150909f, -0.01883130f, 
    0.01833932f, -0.01797522f, 0.04068094f, -0.03987105f, -0.06208331f, -0.04304500f, -0.02509451f, 0.03304010f, 
    0.00976022f, 0.02895903f, -0.05354654f, -0.04109797f, 0.04371456f, -0.01094825f, -0.00969082f, 0.03557006f, 
    0.00583185f, 0.00880647f, 0.02679613f, 0.03557032f, 0.03235888f, -0.01613645f, 0.04983642f, -0.02224685f, 
    0.00778658f, -0.04287446f, 0.01640268f, -0.00722487f, -0.04423849f, -0.02721137f, 0.02839816f, -0.01683312f, 
    0.01928580f, -0.05982274f, 0.05015596f, -0.05007824f, -0.00539860f, 0.02073777f, 0.02837374f, 0.03017582f, 
    -0.00794989f, 0.01730908f, -0.06609900f, -0.04753566f, 0.00274785f, -0.05841369f, -0.00448533f, -0.06528746f, 
    -0.14951006f, -0.19273442f, 0.06750743f, -0.04895774f, -0.13321085f, -0.03878114f, 0.04650255f, 0.10392538f, 
    0.03500384f, -0.23482963f, -0.24744792f, -0.28629017f, 0.02502856f, -0.03499348f, 0.11418563f, -0.09537771f, 
    0.10618911f, 0.11144052f, -0.07443028f, -0.20775130f, 0.03903716f, -0.01259238f, 0.02037173f, 0.04265921f, 
    0.07695863f, -0.03968009f, -0.14295031f, -0.21275070f, -0.54833961f, 0.14894843f, -0.00613950f, -0.11492848f, 
    -0.01612066f, 0.09969468f, 0.05072696f, 0.01797191f, 0.07961748f, 0.01757889f, -0.03768937f, -0.15434937f, 
    0.06315295f, -0.03773270f, -0.03012862f, 0.30994853f, -0.05188393f, 0.05090428f, -0.08793233f, -0.03961264f, 
    -0.16989942f, -0.02469064f, -0.13680603f, 0.04774706f, 0.05740907f, -0.03590009f, 0.79278994f, -0.09425824f, 
    0.24877959f, 0.10598238f, -0.09747779f, 0.11877086f, 0.11266710f, 0.06679747f, -0.05559717f, -0.22832072f, 
    -0.42583477f, -0.08990023f, 0.03151137f, -0.01459464f, -0.04166743f, 0.09276898f, -0.04121089f, -0.02455950f, 
    -0.04426144f, 0.04577188f, -0.07040490f, 0.06996913f, 0.04792025f, -0.06947613f, 0.09674191f, -0.01984009f, 
    0.04055426f, 0.04183685f, 0.24505633f, -0.02794837f, -0.23200850f, -0.15516649f, -0.03818951f, -0.07205173f, 
    -0.11986870f, 0.07594638f, -0.38550398f, -0.19778945f, -0.31615919f, 0.06085434f, -0.05104516f, -0.25625053f, 
    0.15087539f, -0.00240489f, -0.03752455f, 0.19612175f, -0.14476725f, -0.15188457f, -0.01822994f, -0.02276905f, 
    0.11990310f, -0.01939729f, -0.03323366f, -0.02071449f, 0.01597297f, 0.23968400f, 0.08702105f, 0.05467441f, 
    -0.04215615f, -0.24695541f, 0.03495155f, 0.00864754f, -0.04047453f, 0.17724584f, 0.23824719f, -0.12550376f, 
    -0.27475727f, -0.04820487f, -0.03754170f, -0.01449242f, -0.09103245f, -0.02076673f, -0.13704948f, -0.35958782f, 
    -0.26583630f, 0.04975140f, 0.10958730f, 0.00024290f, -0.15212463f, -0.01423783f, -0.08828688f, -0.13600229f, 
    0.21895216f, 0.01784532f, -0.08871116f, -0.00336630f, -0.21916299f, 0.13296254f, 0.14145046f, -0.01198568f, 
    0.58626759f, -0.42559883f, 0.40152422f, 0.13202204f, -0.01814224f, 0.01838127f, 0.15173642f, 0.14735900f, 
    0.26087692f, -0.24692409f, -0.56335181f, -0.13288543f, -0.07638177f, 0.01038282f, 0.09796619f, 0.13186701f, 
    0.07836233f, -0.02847167f, -0.71177286f, -0.24364524f, 0.14501175f, 0.04116058f, 0.09426185f, -0.27234232f, 
    0.00255487f, 0.07294896f, 0.12472229f, -0.07042654f, -0.28059223f, -0.24255720f, -0.08718845f, -0.12648788f, 
    -0.07585711f, -0.00444340f, -0.00985692f, 0.06810387f, 0.56692696f, 0.20176736f, 0.41523102f, 0.11782604f, 
    0.01512625f, 0.03599193f, 0.06701323f, 0.14089771f, 0.04738760f, 0.16867366f, 0.19823998f, 0.08382013f, 
    -0.31012762f, 0.08988423f, 0.00470739f, 0.03325136f, 0.03100437f, -0.04045179f, 0.03549622f, 0.24028949f, 
    0.11901322f, -0.00736977f, 0.09504914f, -0.05333801f, 0.03838992f, 0.05340058f, -0.04124479f, 0.38843736f, 
    -0.23828422f, 0.00100709f, 0.00506492f, -0.12374867f, 0.03576799f, 0.13266936f, 0.14010847f, 0.00086364f, 
    0.51576364f, 0.12628900f, 0.26019695f, -0.04194758f, -0.02837671f, 0.14316107f, 0.06272306f, -0.07328788f, 
    -0.07152510f, -0.08266771f, -0.15496521f, -0.06313763f, -0.05136677f, 0.03310224f, -0.13330652f, 0.00798222f, 
    -0.03736925f, -0.05908127f, -0.27046689f, 0.18960354f, 0.18021800f, -0.05252175f, -0.09301795f, -0.20551290f, 
    -0.18537261f, -0.08778552f, 0.06342189f, 0.09649894f, -0.55698574f, -0.32577711f, -0.24571392f, -0.03935274f, 
    0.02821526f, -0.00275700f, 0.15488364f, -0.12435963f, -0.05510427f, 0.34154612f, -0.10392983f, 0.07525752f, 
    -0.01650443f, 0.02796308f, 0.07935954f, -0.03047025f, 0.01419898f, -0.11926712f, -0.16616838f, 0.09784155f, 
    -0.08605799f, -0.11323592f, -0.07785758f, -0.07693707f, -0.10745981f, -0.02814819f, 0.10884763f, 0.31190839f, 
    0.06998462f, 0.09106416f, 0.17159000f, 0.03105665f, -0.10054492f, 0.03194154f, 0.10061108f, -0.24414536f, 
    0.03443681f, 0.06657742f, -0.16149372f, -0.08248684f, -0.03385366f, -0.12883012f, 0.20387624f, 0.02204323f, 
    0.10617436f, -0.63830483f, -0.35031155f, -0.02029204f, 0.00165579f, 0.05184814f, 0.02003962f, 0.06363154f, 
    0.05670182f, 0.23628561f, -0.03980952f, 0.00625538f, -0.17064776f, 0.03145055f, 0.04805002f, 0.05724830f, 
    0.11400846f, -0.02287127f, -0.25332147f, -0.30186534f, 0.25290221f, -0.07298562f, -0.14737050f, 0.04615457f, 
    0.19341899f, -0.09946225f, 0.06530065f, 0.11063045f, -0.23869756f, -0.30363047f, -0.01999317f, -0.09970903f, 
    -0.01032102f, -0.17374092f, 0.09181363f, -0.03101365f, 0.11939080f, -0.29741818f, -0.35548466f, 0.09066923f, 
    -0.08570223f, 0.10382599f, 0.03478821f, 0.15718174f, 0.07550382f, -0.17605780f, -0.13375010f, 0.10163329f, 
    -0.03797235f, -0.05900738f, -0.19309597f, -0.08075552f, 0.03718438f, 0.08329009f, 0.21325098f, -0.27498505f, 
    0.06639336f, 0.10946447f, -0.13064270f, -0.20884579f, 0.00254384f, 0.00345295f, 0.05961175f, -0.28636670f, 
    -0.05081799f, -0.25826472f, 0.01032956f, 0.10004019f, 0.12956938f, -0.12110360f, 0.10786750f, 0.09678016f, 
    0.08937249f, -0.11388393f, -0.23817064f, -0.01582220f, -0.01752056f, -0.04857846f, 0.04637562f, 0.01384472f, 
    0.09478658f, -0.02070067f, 0.06188773f, -0.18849376f, -0.00922165f, 0.09580233f, 0.14903367f, -0.12184140f, 
    -0.03338772f, -0.02981432f, -0.26415405f, -0.29620814f, -0.02582344f, -0.07173890f, 0.13388705f, 0.10190743f, 
    0.22149989f, 0.13908443f, -0.08132202f, 0.37487453f, -0.19470139f, -0.02150850f, -0.06136607f, -0.02113266f, 
    -0.10113620f, -0.02297884f, 0.10678220f, 0.02905281f, -0.02507011f, 0.10101786f, 0.06530555f, -0.03942232f, 
    0.05831762f, 0.03840221f, 0.00707963f, 0.05871443f, 0.05363270f, -0.28241578f, 0.01683275f, -0.16083035f, 
    -0.09738374f, 0.15313525f, -0.02948456f, -0.11984637f, 0.08946776f, 0.03996020f, 0.11934294f, -0.23758698f, 
    -0.07905524f, -0.07768331f, -0.08566919f, -0.01910555f, 0.10511804f, -0.09453918f, -0.12233769f, 0.03398435f, 
    -0.67350811f, -0.18811996f, -0.01702497f, 0.09618804f, -0.02067849f, 0.17167994f, -0.03030094f, 0.05364146f, 
    -0.35335520f, -0.30031916f, 0.34069368f, 0.06796228f, 0.05615619f, -0.11965755f, 0.09085739f, 0.07870528f, 
    -0.24372755f, 0.07026976f, 0.00419549f, -0.03505712f, -0.19683897f, 0.08114494f, 0.07348458f, 0.14004546f, 
    0.15460703f, 0.14237578f, -0.78346908f, -0.22477162f, 0.13307479f, -0.15090773f, 0.01693442f, 0.07953476f, 
    0.06293834f, 0.11141956f, 0.04755993f, 0.34576443f, -0.02301685f, 0.14106043f, -0.13010280f, -0.03655996f, 
    0.02897617f, 0.02961916f, 0.04368048f, 0.08977667f, 0.15545344f, 0.16638015f, -0.00563657f, 0.05430625f, 
    0.06234602f, 0.01014238f, 0.05277603f, -0.04240270f, 0.05444775f, 0.09988972f, 0.24997927f, 0.26951727f, 
    -0.22172065f, 0.00158537f, -0.01108352f, -0.00722811f, 0.13582149f, 0.16968560f, 0.04811866f, 0.16253535f, 
    0.10556537f, 0.02062161f, 0.11890580f, 0.12667187f, 0.03252658f, 0.01777445f, -0.05759697f, -0.00030991f, 
    -0.07788443f, 0.15283225f, 0.06627987f, 0.02177420f, -0.02859113f, 0.04435340f, 0.11780544f, -0.03096354f, 
    0.05276147f, 0.00966527f, -0.05974758f, -0.00787378f, 0.06052620f, 0.01484275f, 0.10164130f, -0.00579603f, 
    0.03591782f, 0.00348031f, -0.49334860f, -0.06476980f, -0.04944518f, -0.08975619f, -0.02161768f, -0.00379966f, 
    -0.03852200f, -0.06242416f, 0.13067409f, 0.15730365f, -0.06262640f, -0.01743998f, -0.09801805f, -0.00126060f, 
    -0.00797513f, -0.00203401f, 0.12959523f, -0.68510199f, -0.17508976f, 0.45320383f, 0.34140059f, -0.00450303f, 
    -0.18453924f, 0.10996372f, 0.20960130f, -0.17228736f, -0.07924566f, 0.12508889f, 0.17027269f, -0.12655035f, 
    0.05220563f, -0.09809934f, 0.08972307f, -0.16583601f, 0.16746221f, -0.05336704f, -0.16538323f, 0.18048950f, 
    -0.09082813f, -0.22252588f, 0.07244591f, -0.06971266f, -0.07868174f, -0.02856105f, 0.00609103f, 0.13395442f, 
    0.17232524f, -0.08928327f, 0.06810397f, -0.09196134f, 0.06565244f, 0.09417700f, 0.07138144f, -0.04249011f, 
    -0.02164030f, 0.27842635f, -0.23461063f, 0.03718591f, 0.01582110f, 0.08715544f, -0.01598241f, 0.01379555f, 
    -0.04574355f, -0.31322691f, 0.00292630f, -0.19723368f, 0.18447711f, 0.08283567f, 0.16719392f, 0.03765949f, 
    0.15083255f, -0.12346221f, -0.37289301f, -0.02926728f, -0.13272330f, -0.23718703f, 0.02126076f, 0.11118763f, 
    -0.07785226f, -0.03503601f, 0.20136635f, -0.30054247f, 0.06599575f, -0.14195168f, 0.03523109f, -0.05412495f, 
    0.10226602f, -0.26544192f, -0.01356377f, 0.25824159f, -0.17783362f, -0.08994404f, 0.01993915f, -0.26553342f, 
    0.08749877f, 0.04175291f, -0.02365491f, -0.08663784f, 0.05072299f, -0.21825889f, -0.39724356f, -0.14131042f, 
    0.28113616f, 0.03458225f, 0.07880577f, -0.02893299f, 0.10877093f, -0.11375581f, 0.05161127f, 0.11472321f, 
    -0.12546863f, 0.19013399f, 0.01270266f, -0.05107753f, -0.05836862f, -0.03040390f, 0.12140831f, -0.23877047f, 
    -0.42458710f, 0.11921281f, 0.02557595f, 0.00951539f, 0.00983002f, 0.11068653f, -0.12422861f, 0.14360154f, 
    -0.32491070f, -0.32684502f, -0.20298794f, 0.16032547f, 0.10382678f, 0.10414577f, 0.02841048f, 0.01164390f, 
    0.06848196f, 0.15024349f, -0.10432119f, -0.07349521f, -0.05177315f, 0.01436167f, 0.04735406f, -0.03268537f, 
    -0.23602070f, 0.10045751f, 0.15322846f, 0.07290846f, 0.11191292f, 0.09588654f, 0.07838406f, -0.16813438f, 
    0.02131231f, 0.09591141f, -0.49477962f, 0.06825110f, -0.26475433f, -0.06679552f, 0.04811670f, 0.04876371f, 
    0.25610816f, 0.04256646f, 0.04847630f, 0.07419803f, -0.11454957f, -0.34929684f, 0.10878186f, -0.08685176f, 
    0.10372654f, -0.01248756f, -0.00212811f, 0.00352273f, -0.02516687f, 0.09624204f, 0.29175249f, -0.02188441f, 
    0.02452018f, 0.02258208f, 0.07228757f, 0.13800192f, -0.06028548f, -0.15995981f, 0.00616607f, 0.10983992f, 
    -0.12554373f, 0.12603685f, -0.02120604f, 0.01468097f, -0.08324458f, 0.16771087f, 0.15162672f, 0.07190788f, 
    -0.05292627f, -0.03586809f, -0.09423207f, -0.15198715f, 0.08796979f, -0.15710604f, -0.09942137f, -0.40063712f, 
    -0.15501374f, -0.16424981f, 0.20724578f, 0.11698989f, 0.12656510f, -0.02848040f, 0.06033016f, 0.00935417f, 
    -0.03737715f, -0.27102387f, -0.24287945f, 0.07345803f, -0.01028088f, -0.10746881f, 0.15460981f, 0.09551077f, 
    0.09535731f, -0.05852051f, -0.28941011f, -0.30974007f, -0.08388291f, -0.01434263f, -0.09403930f, 0.14748938f, 
    -0.02779173f, 0.06464250f, -0.42779726f, 0.00793796f, 0.26334006f, -0.06297629f, -0.08748122f, -0.00567012f, 
    0.06438007f, 0.10197744f, -0.05707169f, 0.03609898f, 0.09224391f, -0.22615999f, -0.19954199f, -0.14674073f, 
    0.00406017f, 0.17867488f, -0.04653466f, 0.04764295f, 0.21495320f, 0.02632815f, 0.03362790f, 0.05840360f, 
    0.02818870f, -0.19666921f, -0.06316485f, -0.02928933f, -0.04202251f, 0.09247103f, 0.21349059f, 0.35246965f, 
    -0.07200374f, 0.10215889f, -0.08158398f, 0.14180063f, 0.07719632f, -0.01334851f, 0.08000240f, 0.29985741f, 
    0.16827688f, 0.05261632f, -0.02076803f, 0.09099789f, 0.01457890f, -0.08995052f, -0.07812589f, 0.21806265f, 
    0.05311315f, 0.07334664f, -0.01019633f, 0.03439449f, -0.10435868f, 0.00356257f, 0.09095526f, 0.00757602f, 
    0.10619387f, -0.16199280f, 0.11436369f, -0.10426642f, -0.09485815f, 0.03038946f, 0.11475197f, -0.12949090f, 
    -0.12004909f, -0.18086836f, -0.01195727f, -0.03251833f, -0.04825468f, 0.06643800f, 0.02305678f, 0.08137976f, 
    0.07999898f, 0.03098372f, 0.07219504f, 0.20588586f, 0.19601886f, -0.01312536f, -0.02370958f, -0.01424741f, 
    0.07335483f, -0.06745893f, -0.11177388f, -0.30135256f, -0.33789149f, 0.30746639f, 0.07127266f, -0.13855675f, 
    0.11790739f, 0.04883571f, 0.17727000f, 0.12244793f, 0.09576066f, 0.31384620f, 0.17353071f, -0.09680374f, 
    -0.21725865f, 0.03142560f, 0.05902788f, 0.09179293f, 0.04972088f, -0.09209452f, -0.25781468f, -0.08156730f, 
    0.02714846f, -0.13697767f, -0.25667614f, -0.08700567f, -0.02459062f, 0.00612866f, 0.19662307f, 0.29341772f, 
    0.30368930f, -0.11848509f, -0.07218245f, 0.05839379f, 0.12485664f, 0.07504176f, 0.12995735f, -0.39140409f, 
    0.08857537f, -0.01941490f, -0.08303012f, -0.25694576f, -0.03839446f, 0.11896280f, 0.02230191f, 0.14269662f, 
    -0.17444490f, -0.14851116f, -0.18145891f, 0.08439647f, -0.01730121f, 0.08545960f, -0.07730055f, 0.09035934f, 
    0.03300730f, -0.01812070f, -0.01676840f, 0.03768804f, 0.02791346f, 0.15681039f, -0.00816884f, -0.00079218f, 
    -0.01693653f, 0.01214751f, -0.14562865f, -0.24968769f, -0.00092841f, -0.01742089f, -0.10750663f, -0.03728712f, 
    0.15137962f, 0.13924029f, -0.09706040f, -0.17776208f, -0.30582258f, 0.02813054f, -0.08760444f, -0.04207591f, 
    0.03696938f, -0.16613758f, -0.03438802f, -0.15657902f, -0.05585721f, -0.01642377f, -0.04732280f, 0.13273469f, 
    -0.08380461f, 0.04857610f, -0.08209422f, 0.33919010f, 0.25681251f, -0.18937001f, -0.51583058f, -0.38583285f, 
    -0.01514099f, 0.16765848f, 0.15152904f, 0.08387899f, 0.12535632f, 0.19046365f, -0.13646366f, 0.20409924f, 
    0.04485648f, -0.04505154f, -0.10354853f, 0.04897629f, -0.11696269f, -0.23183236f, -0.03112599f, -0.05885162f, 
    -0.13543516f, 0.13060556f, -0.06744971f, 0.11995239f, 0.17840719f, 0.04528213f, 0.08389952f, 0.18705045f, 
    -0.00562696f, -0.09608404f, 0.05316221f, 0.07902440f, 0.06928669f, 0.16867492f, 0.11268473f, -0.01668603f, 
    -0.29203245f, -0.04165588f, 0.17161019f, 0.03567986f, -0.02316182f, 0.28379199f, 0.27802658f, 0.17489426f, 
    0.35814711f, 0.09587577f, -0.02107083f, 0.13835402f, 0.37700161f, 0.25534287f, -0.06955726f, 0.03961235f, 
    0.26508072f, 0.05794473f, 0.09540921f, 0.00859394f, 0.20502008f, 0.12246879f, 0.10687127f, 0.10539584f, 
    -0.04864320f, -0.10300120f, -0.18136945f, -0.01896940f, -0.07116508f, 0.05788552f, 0.14482468f, 0.11476299f, 
    0.04024720f, 0.10463163f, -0.01716697f, 0.00918178f, -0.07577061f, -0.10002519f, -0.08896182f, -0.07116786f, 
    0.01123077f, 0.15285859f, 0.14806993f, 0.08722355f, 0.27483514f, 0.19670156f, -0.06956180f, -0.33742118f, 
    -0.02092453f, -0.16633704f, -0.00623444f, 0.03835101f, -0.12338059f, 0.11427397f, -0.07072072f, -0.06425729f, 
    -0.06573484f, 0.10953389f, 0.19776201f, 0.13784261f, 0.19083411f, 0.10152797f, 0.27263987f, 0.28452200f, 
    -0.08446299f, -0.14506072f, 0.07985729f, 0.03291094f, -0.25669479f, -0.10500643f, 0.01452852f, -0.21211186f, 
    -0.20344579f, -0.19850031f, -0.27188095f, 0.01055080f, -0.03149847f, -0.07659739f, -0.00165916f, -0.01815801f, 
    -0.10582536f, 0.05093789f, 0.25214541f, 0.15845968f, 0.16744301f, -0.12206077f, 0.06124297f, 0.01764953f, 
    -0.04697039f, 0.13402231f, 0.21827777f, -0.12222867f, -0.12929173f, -0.07874493f, 0.12328590f, 0.09169230f, 
    0.11434396f, 0.04135253f, -0.03761657f, -0.02807363f, -0.18664044f, 0.20327765f, 0.07152820f, -0.07259237f, 
    0.02584367f, 0.05010851f, -0.09019475f, 0.03832991f, -0.13304518f, -0.12599289f, -0.32173648f, -0.31456485f, 
    0.03533439f, 0.01191115f, 0.03677737f, 0.03609762f, 0.01018659f, -0.04101421f, 0.20040439f, 0.04253895f, 
    0.09227785f, 0.06458275f, 0.09250902f, -0.05651287f, 0.12428924f, 0.05045386f, 0.05957425f, 0.20149466f, 
    0.14418559f, 0.19301224f, 0.22189413f, 0.13646543f, 0.17874144f, 0.16862257f, 0.22503032f, 0.08357444f, 
    -0.08505383f, -0.11862203f, -0.04769549f, -0.05871522f, -0.08656734f, -0.05047711f, -0.00785759f, -0.03454392f, 
    -0.01641646f, -0.21594413f, -0.07926018f, -0.07265998f, 0.04237252f, 0.06968746f, 0.17496379f, 0.03362273f, 
    0.02472935f, -0.00803495f, -0.04661152f, -0.05295203f, -0.16581367f, 0.04921635f, 0.06175805f, 0.07648858f, 
    0.12728846f, 0.00019371f, -0.21164121f, 0.18829468f, -0.34821215f, -0.12148082f, 0.14958422f, 0.02294777f, 
    0.03642960f, 0.20324729f, -0.10611285f, 0.16113320f, 0.03682775f, 0.03135502f, 0.09915985f, 0.09270996f, 
    0.17145759f, 0.10658709f, 0.02822264f, 0.11380254f, 0.19075839f, -0.07527070f, -0.11427560f, -0.00891935f, 
    -0.08592790f, 0.03902416f, 0.06469602f, 0.00328429f, 0.07783537f, -0.23203887f, -0.11790756f, -0.11794373f, 
    -0.00100173f, -0.22162248f, 0.06162896f, -0.01082653f, 0.00762495f, 0.18935938f, 0.18348134f, 0.06276149f, 
    -0.15457219f, -0.15187378f, -0.02743777f, 0.01162364f, 0.25838077f, -0.00252932f, 0.25110111f, 0.30549803f, 
    0.21026018f, 0.10203729f, 0.01567084f, -0.12484042f, -0.06993948f, -0.17725478f, 0.03040274f, 0.03283532f, 
    -0.01232455f, -0.15311591f, -0.18081124f, -0.08724309f, 0.05965463f, -0.01409753f, 0.12230136f, -0.03339170f, 
    -0.28994820f, -0.17485531f, -0.16612054f, 0.12848848f, -0.06761058f, 0.10128702f, 0.15699649f, 0.04532660f, 
    0.07376418f, 0.16903645f, -0.02911347f, -0.00445768f, 0.03243221f, 0.17263879f, -0.11823525f, -0.07515734f, 
    0.00210069f, 0.25531954f, 0.01310472f, -0.06512836f, -0.11844840f, 0.10618713f, 0.08722213f, 0.08129109f, 
    0.05496790f, 0.02827521f, 0.06523501f, 0.28231412f, 0.00711667f, 0.00295357f, 0.04290510f, 0.02197478f, 
    0.10089158f, 0.15446104f, -0.24194700f, 0.15355398f, -0.12982106f, -0.05123028f, 0.14747533f, -0.05285614f, 
    0.07799568f, 0.16420703f, 0.03762117f, 0.09401613f, 0.21314672f, 0.17164546f, 0.07300345f, -0.10874181f, 
    0.10785332f, -0.01946874f, -0.08412310f, -0.00778828f, -0.05224363f, 0.24817888f, -0.19454929f, -0.07301547f, 
    -0.02566431f, 0.00795919f, 0.21263406f, 0.22313756f, 0.24604203f, 0.05501051f, 0.00482448f, 0.00635638f, 
    0.09289294f, -0.08151709f, 0.05104107f, -0.11294733f, 0.15142417f, 0.00860996f, -0.07825633f, -0.08158543f, 
    -0.00271073f, -0.14058058f, 0.12294944f, 0.07235246f, -0.22385681f, 0.28844506f, 0.04792948f, 0.12071797f, 
    0.18311912f, 0.19050571f, -0.07278991f, 0.07262404f, -0.29576012f, 0.20702001f, -0.04685762f, -0.03599774f, 
    -0.04996984f, 0.27608117f, -0.14197971f, 0.12537037f, -0.01633720f, 0.12923853f, -0.05929218f, 0.02074402f, 
    0.00076429f, -0.05999310f, 0.06748707f, -0.02493634f, 0.13044071f, -0.12160157f, 0.09915554f, 0.02182173f, 
    -0.15458384f, -0.05566663f, -0.15966852f, 0.02294255f, -0.09424267f, -0.06805730f, -0.00751633f, 0.11313843f, 
    0.09536284f, 0.04069578f, 0.04251516f, 0.02711074f, 0.10032626f, 0.05370539f, -0.14720021f, 0.27125564f, 
    0.23156765f, 0.05380283f, 0.11731394f, -0.04564268f, -0.02391732f, 0.01206049f, -0.01634511f, -0.09727994f, 
    0.18623754f, -0.00206450f, -0.12237955f, 0.21044399f, 0.15497765f, -0.06057747f, 0.11659452f, 0.14335321f, 
    0.14765629f, -0.01618879f, -0.07988582f, -0.08581870f, 0.13400847f, -0.06412508f, 0.10281080f, -0.05578919f, 
    -0.06142959f, -0.13282117f, 0.26261768f, 0.23586392f, 0.02476691f, -0.16593696f, 0.18804967f, 0.15839523f, 
    0.02494348f, 0.08874077f, 0.21450897f, -0.06687820f, -0.22856647f, -0.02832155f, 0.07594847f, 0.04967114f, 
    0.12735277f, -0.01876004f, -0.18992347f, -0.16386759f, 0.14067136f, -0.08701373f, -0.10512093f, 0.02538139f, 
    0.03961195f, -0.06996163f, 0.07132800f, 0.03149359f, 0.00529345f, -0.17410460f, -0.22517510f, -0.15075220f, 
    0.10143933f, 0.14093210f, -0.04131832f, -0.01480341f, 0.03776721f, -0.05732513f, -0.04726345f, -0.12342671f, 
    0.13839397f, 0.14003389f, 0.11937869f, -0.10528810f, 0.03280598f, 0.09681161f, 0.04459233f, 0.11702468f, 
    0.03072193f, 0.01750077f, 0.14166132f, 0.06246243f, 0.14308299f, 0.08928926f, 0.11872637f, -0.08662937f, 
    -0.21891436f, 0.10036907f, 0.02316049f, 0.22436720f, 0.11922976f, 0.10524768f, 0.11164740f, 0.13500804f, 
    -0.05018159f, 0.31578702f, 0.10113209f, 0.14595708f, -0.20975345f, -0.03122958f, -0.03492115f, -0.02546844f, 
    0.10174918f, 0.02893267f, -0.04620678f, -0.03929329f, 0.04254565f, 0.09851695f, 0.12746751f, 0.16064785f, 
    0.10621227f, -0.05988225f, -0.00152928f, 0.07585632f, 0.35399035f, -0.08814087f, 0.16273230f, 0.02655585f, 
    0.10569458f, 0.00602687f, -0.08784484f, -0.02024909f, -0.11272193f, 0.02561998f, -0.08305725f, 0.09302852f, 
    0.28262949f, 0.03690464f, 0.02997429f, -0.08223408f, -0.24062982f, -0.08629826f, -0.04668701f, 0.09125026f, 
    0.16705766f, 0.13079792f, 0.03941075f, 0.18312286f, 0.10274770f, -0.00295763f, -0.06108128f, -0.16233166f, 
    -0.09174857f, 0.11505858f, 0.12783979f, -0.10770446f, -0.40499213f, -0.25628242f, -0.31594825f, 0.06618289f, 
    0.01856201f, 0.00833283f, 0.20162578f, 0.00513304f, 0.15037146f, -0.11565347f, 0.04222428f, -0.17789648f, 
    -0.17301786f, -0.12489748f, 0.23804972f, -0.09541738f, 0.12123087f, -0.09085279f, 0.06527621f, 0.08768892f, 
    -0.02155365f, -0.06838851f, 0.12041843f, -0.10139071f, -0.07096052f, -0.06308485f, -0.17086315f, 0.08421410f, 
    -0.13596852f, 0.06512813f, -0.08750074f, 0.10625380f, 0.00100041f, -0.06129831f, 0.05534933f, -0.03154989f, 
    -0.12337074f, 0.12550901f, 0.17851695f, -0.01944353f, 0.05530434f, 0.09967389f, 0.08625223f, 0.02044414f, 
    -0.13742752f, 0.13083346f, -0.01038874f, 0.11006247f, -0.13892020f, -0.06425912f, -0.10690016f, -0.30321512f, 
    -0.06677346f, 0.18834676f, 0.08586501f, -0.06185945f, -0.20968211f, 0.11185152f, 0.40778312f, 0.57028985f, 
    -0.37938097f, -0.06526484f, -0.24628453f, 0.00360618f, 0.29562476f, -0.15972903f, 0.00555485f, -0.04742268f, 
    0.40703791f, -0.01690240f, -0.18610685f, -0.11746125f, 0.03340894f, 0.13811758f, 0.27378696f, -0.44652790f, 
    -0.01790572f, -0.23178016f, 0.20088126f, 0.00685243f, -0.13297060f, 0.01537868f, 0.01039257f, 0.00203386f, 
    0.16179414f, 0.14889196f, 0.11267623f, 0.10013086f, -0.08748712f, -0.10887837f, 0.02150698f, -0.14936325f, 
    0.05263660f, 0.12762487f, -0.03439441f, 0.20918368f, -0.05600402f, -0.07320487f, -0.17835300f, 0.00430810f, 
    -0.05881098f, 0.05161391f, -0.21006981f, 0.03342801f, -0.01670949f, -0.11829147f, 0.11816722f, 0.10792385f, 
    -0.12158091f, -0.13098332f, -0.08400697f, -0.07724798f, 0.37346604f, 0.18614137f, -0.13818730f, -0.19962937f, 
    -0.19132255f, 0.12577616f, 0.08556058f, 0.03478255f, 0.05524423f, -0.11923496f, 0.07387210f, -0.14425381f, 
    -0.00574793f, -0.00068634f, 0.00500877f, -0.08055146f, 0.10276815f, -0.16343792f, -0.02015160f, -0.05693745f, 
    -0.02527604f, -0.05212036f, -0.01844111f, -0.19239499f, -0.09881645f, -0.26573172f, -0.00285282f, -0.07100492f, 
    0.06008399f, -0.11927237f, 0.03997270f, -0.08375037f, 0.18509081f, -0.08807872f, -0.02129021f, 0.11420191f, 
    0.09287371f, -0.02391113f, 0.05016081f, -0.00955545f, -0.37564647f, 0.03726487f, -0.10710483f, -0.14983772f, 
    -0.01973233f, 0.19116387f, 0.41224107f, 0.03137586f, -0.28747505f, -0.13435452f, -0.09185456f, 0.07573488f, 
    0.12993218f, -0.00313138f, 0.12005129f, -0.13374938f, -0.02255840f, 0.04772803f, -0.04808404f, 0.03295366f, 
    0.01492819f, 0.02822591f, -0.26956055f, 0.14242437f, -0.31433097f, -0.08926866f, 0.12388749f, 0.15313947f, 
    -0.07414924f, 0.03805040f, -0.09143016f, 0.01374082f, 0.21724154f, 0.00366860f, -0.12758701f, -0.07754380f, 
    -0.03552796f, -0.03241588f, -0.16317967f, 0.02565457f, -0.06352200f, -0.26667339f, 0.14560610f, 0.15993716f, 
    -0.19286582f, -0.22595477f, 0.06869545f, -0.08229505f, 0.15154110f, 0.19880052f, 0.31788072f, 0.26971990f, 
    -0.15737554f, -0.12603095f, -0.01096346f, 0.09695955f, 0.14662507f, 0.05973115f, -0.03489563f, 0.06789996f, 
    0.13276336f, 0.00494568f, -0.07521710f, -0.10404721f, 0.02798711f, 0.09691275f, -0.04269039f, 0.11108407f, 
    0.21964416f, 0.26185426f, -0.10316028f, -0.10536262f, -0.17810778f, -0.01141309f, 0.12517847f, 0.01701127f, 
    -0.07096703f, -0.10470136f, -0.11250985f, 0.04935470f, -0.08653715f, 0.09234341f, 0.05917962f, -0.02775012f, 
    0.22682451f, -0.06654937f, 0.09111776f, 0.33740470f, -0.23784095f, 0.12586743f, -0.19482908f, -0.05770179f, 
    0.11889870f, -0.06575932f, 0.10590966f, 0.09316386f, 0.29924449f, 0.00024744f, -0.12163928f, -0.15206690f, 
    0.02049974f, 0.06930648f, 0.15440677f, -0.09353720f, 0.30380201f, -0.17812121f, -0.15915002f, -0.10373747f, 
    -0.11507611f, 0.02555249f, 0.03861967f, 0.02087671f, 0.11884857f, 0.31608188f, 0.37127042f, 0.14046757f, 
    -0.02261188f, -0.12184489f, 0.03254362f, 0.12969978f, -0.00816675f, -0.15694524f, 0.14608516f, 0.12432744f, 
    -0.15719865f, -0.06154341f, 0.10316429f, -0.11319540f, -0.03231264f, 0.11329485f, 0.27359372f, 0.18458542f, 
    0.09148253f, 0.08117516f, -0.09740399f, 0.01500872f, 0.05464885f, -0.24659941f, -0.18292667f, 0.05514165f, 
    0.01409603f, 0.16771927f, -0.02545102f, -0.00627892f, -0.12969480f, -0.03519591f, 0.09427130f, -0.04078829f, 
    -0.03733822f, 0.00524561f, 0.03150921f, -0.02965572f, 0.03807102f, 0.03767845f, -0.05101121f, 0.00876263f, 
    0.02741862f, 0.01761160f, 0.01789832f, -0.07598346f, 0.01615240f, 0.04669912f, -0.03754541f, 0.01431110f, 
    -0.00750873f, -0.02743592f, -0.00037219f, 0.01199432f, 0.04211998f, 0.04370021f, -0.02135466f, 0.01365400f, 
    0.02327908f, 0.03585163f, -0.03326020f, 0.03349721f, -0.01522498f, 0.03173462f, -0.04310799f, 0.03936569f, 
    0.00441731f, -0.01597883f, -0.01215891f, 0.01112331f, 0.04041437f, 0.01059488f, -0.04528901f, -0.05119790f, 
    -0.04417654f, -0.05576278f, -0.04528234f, 0.04326253f, 0.02945410f, -0.02775675f, 0.03072763f, -0.03415068f, 
    -0.04956340f, -0.05258511f, 0.00757913f, -0.06511161f, -0.03148422f, -0.00483010f, 0.00783462f, -0.02338173f, 
    -0.03925402f, 0.02693277f, 0.04110661f, 0.04026879f, 0.01991202f, 0.02645929f, -0.00062306f, 0.00133639f, 
    -0.01361767f, -0.00355031f, 0.03148511f, -0.01317570f, -0.02187871f, 0.03921470f, -0.01560601f, 0.00827940f, 
    -0.05173025f, -0.04344316f, -0.03807212f, -0.00554529f, -0.06771345f, 0.01387703f, 0.00559631f, 0.04352270f, 
    0.01580597f, 0.02249004f, -0.01711262f, 0.00648990f, 0.02962320f, 0.03938236f, -0.00722356f, 0.04450586f, 
    0.04686145f, 0.02936248f, -0.04188338f, -0.01425188f, 0.03895568f, -0.05789451f, 0.00377312f, -0.05460673f, 
    0.04606361f, 0.00508694f, 0.01923102f, 0.00026204f, 0.02174935f, 0.00832928f, -0.05155255f, -0.02526164f, 
    0.00457964f, -0.05482916f, 0.02885962f, -0.02474738f, -0.02343000f, 0.02897213f, -0.01160350f, -0.03738209f, 
    0.01357111f, 0.01882132f, -0.02195436f, 0.00490235f, 0.00063798f, 0.03638089f, 0.01619023f, -0.00908243f, 
    0.04743791f, -0.05679230f, -0.00547001f, -0.03985388f, 0.00732382f, -0.02266681f, 0.04375819f, -0.04009276f, 
    0.01678158f, 0.04049359f, -0.02521836f, -0.04958044f, -0.02140667f, -0.04582878f, 0.04577329f, -0.03946707f, 
    0.00587097f, -0.06543384f, -0.02781364f, 0.01176019f, -0.02065362f, 0.03207203f, -0.06249230f, -0.00345416f, 
    0.02674759f, -0.04214161f, -0.01932671f, -0.01144089f, -0.02815533f, 0.03498952f, -0.03993867f, 0.04295391f, 
    -0.03561297f, 0.00292426f, -0.03322282f, 0.05140907f, -0.02152577f, -0.02348267f, -0.06037249f, 0.03590149f, 
    0.01913057f, -0.06095365f, -0.05620148f, 0.00431968f, 0.03746062f, -0.01119317f, -0.05932435f, -0.04198059f, 
    -0.06173274f, -0.00121049f, -0.05375757f, 0.01386135f, -0.04319914f, -0.02604190f, 0.03359764f, -0.03775675f, 
    -0.05921581f, -0.01263873f, 0.01697434f, 0.01845726f, -0.06299816f, -0.02169955f, -0.01560609f, 0.04988727f, 
    0.02983314f, 0.04996943f, -0.01450588f, 0.00375034f, 0.03674996f, 0.02381742f, -0.00398031f, -0.00167127f, 
    0.02370274f, -0.04333135f, -0.01685027f, 0.02429699f, -0.03106939f, 0.05274220f, -0.05877557f, 0.02236367f, 
    0.00075971f, -0.02473496f, 0.03810656f, 0.00096021f, -0.01168412f, -0.01321273f, 0.00015484f, -0.00461988f, 
    0.00337223f, 0.00078581f, 0.02797843f, -0.00819567f, 0.02523849f, -0.04894500f, -0.03117872f, -0.01093335f, 
    0.02807810f, -0.06486776f, 0.05127772f, 0.03881631f, -0.06905696f, -0.06217252f, 0.04334195f, -0.04261527f, 
    -0.00389653f, -0.00841698f, -0.05588711f, 0.04854558f, -0.07073011f, -0.05934723f, -0.01148505f, -0.05534345f, 
    0.00991065f, 0.05091619f, -0.05549885f, 0.03800922f, -0.03049219f, 0.01781687f, -0.07342781f, -0.03739644f, 
    -0.02595919f, 0.00576268f, 0.01952481f, 0.01497205f, 0.02449763f, 0.02020786f, 0.04217263f, 0.01243099f, 
    -0.00255403f, -0.02654244f, 0.01212872f, 0.02346302f, -0.05156278f, -0.08005584f, -0.00838900f, -0.00925959f, 
    0.00760216f, -0.04242848f, 0.02298087f, -0.00921821f, 0.01720088f, -0.02469392f, -0.02640801f, 0.05272746f, 
    -0.05652954f, -0.02531360f, -0.02024534f, 0.05059629f, 0.03934630f, -0.00928768f, -0.02789484f, 0.03370403f, 
    -0.05763703f, -0.02951049f, 0.00340312f, -0.01859363f, 0.03352194f, -0.02115174f, -0.05283320f, -0.06255275f, 
    0.00412092f, 0.01665877f, 0.04135140f, -0.01551912f, 0.04283065f, -0.02014390f, 0.02243379f, -0.00192906f, 
    -0.41401625f, -0.18236588f, 0.04799906f, -0.17847574f, 0.03203447f, -0.10324217f, 0.18394637f, 0.02979552f, 
    0.05284958f, -0.00861009f, 0.27340269f, -0.09532228f, -0.04241881f, 0.12585196f, 0.06804197f, 0.12329235f, 
    0.13673444f, 0.01660944f, -0.43358162f, 0.18449214f, 0.15927620f, 0.20890968f, -0.02961457f, 0.01638084f, 
    -0.04679202f, 0.02569195f, 0.10738620f, -0.22192252f, -0.23116438f, -0.16096015f, -0.05677894f, -0.07405870f, 
    -0.14077470f, 0.01205995f, 0.04497149f, 0.06473318f, 0.19511019f, -0.16560306f, 0.20826298f, 0.05364591f, 
    0.08222764f, 0.16583692f, 0.12208813f, 0.08871825f, -0.08595209f, -0.19037019f, 0.35141298f, 0.17635486f, 
    -0.12203208f, 0.00520165f, -0.10863275f, -0.03435446f, 0.04311489f, -0.02429411f, 0.01562733f, 0.17852925f, 
    0.17433764f, -0.03080098f, -0.07454085f, -0.02956613f, 0.08911540f, -0.02363789f, -0.01652796f, -0.25047892f, 
    -0.25451648f, -0.00254145f, 0.11549092f, 0.11939818f, -0.04401204f, -0.20247634f, 0.03411238f, -0.06803616f, 
    -0.06365575f, -0.08353720f, 0.04405267f, 0.08444083f, -0.08671106f, -0.00984612f, -0.08331931f, 0.01046451f, 
    0.01830223f, -0.14775328f, -0.11203045f, -0.04652558f, 0.09208929f, 0.10034956f, -0.12858579f, 0.02015308f, 
    0.10378116f, 0.06738843f, -0.32590130f, 0.02215715f, 0.03870047f, 0.10487051f, 0.13968374f, 0.11406909f, 
    -0.13469324f, -0.01710136f, -0.05097306f, 0.09738326f, 0.35101917f, -0.03658814f, -0.04361087f, -0.11113965f, 
    0.16335432f, 0.18487781f, -0.09390714f, -0.08128357f, 0.05251736f, -0.33738407f, 0.03616965f, 0.05458452f, 
    -0.03345191f, 0.15346073f, 0.03331704f, 0.04373580f, -0.11490824f, -0.38942507f, -0.02597950f, -0.04516197f, 
    -0.17763811f, 0.14009739f, 0.19237459f, 0.25256097f, 0.08601380f, 0.06968850f, -0.07462642f, -0.13085645f, 
    -0.10009828f, 0.00504530f, -0.16145730f, 0.03097805f, 0.17353392f, 0.04651665f, 0.06066578f, -0.38518518f, 
    0.04700382f, -0.02736651f, 0.16897133f, -0.10362227f, -0.20413679f, -0.00338102f, -0.05182237f, 0.18281509f, 
    -0.39598218f, 0.33991969f, 0.19237529f, 0.10874017f, 0.03333430f, -0.08697540f, -0.07260104f, -0.25177047f, 
    -0.01846272f, -0.11503475f, -0.05319073f, -0.15259577f, -0.13066083f, -0.04410154f, 0.14870352f, -0.05905905f, 
    0.02156272f, -0.08959023f, -0.46765503f, 0.22663967f, -0.28249919f, 0.10538781f, 0.19399977f, 0.18633947f, 
    0.11130243f, -0.18297921f, 0.14028910f, -0.18028545f, -0.06897649f, -0.10971545f, -0.00147369f, 0.03155118f, 
    0.08911382f, 0.10814608f, -0.15980956f, 0.12966725f, 0.17624763f, -0.32290876f, -0.10291564f, -0.05928922f, 
    -0.06242021f, 0.19861417f, -0.00203217f, 0.06057828f, -0.13189740f, 0.18965538f, 0.09561320f, 0.06008903f, 
    0.04862045f, -0.09916498f, 0.08272760f, 0.02628971f, 0.01327233f, 0.03680784f, -0.03322450f, 0.03774753f, 
    0.14450684f, 0.00103139f, 0.04092190f, 0.14459783f, 0.06844257f, 0.00316319f, 0.03389866f, 0.20109063f, 
    0.36820757f, 0.37960485f, 0.08580723f, -0.03462050f, 0.12097570f, 0.01583583f, 0.02358331f, 0.02854496f, 
    0.06067529f, -0.07080008f, 0.08557950f, 0.13464715f, -0.08634373f, 0.01052585f, 0.05596181f, 0.11023169f, 
    0.21654008f, -0.36665392f, 0.09724115f, 0.09986617f, -0.06569850f, -0.09253696f, -0.18216486f, -0.12166112f, 
    0.01119240f, -0.04656256f, -0.05077168f, -0.25182104f, 0.18802106f, -0.08060068f, 0.03788992f, -0.00515440f, 
    0.01538045f, -0.10972442f, -0.08289305f, 0.18868707f, 0.35184094f, 0.37062034f, 0.07436834f, 0.02008208f, 
    -0.23306568f, 0.03097354f, -0.05266181f, -0.01558467f, -0.14938533f, 0.13471355f, 0.24416058f, 0.20615408f, 
    0.03032511f, -0.10325674f, 0.05924782f, 0.05823304f, 0.08562049f, -0.19383600f, -0.04265941f, 0.17707349f, 
    -0.06299829f, -0.10745843f, 0.17045292f, 0.10422412f, -0.01843462f, 0.15063693f, -0.26393092f, -0.18115899f, 
    -0.17099021f, 0.08821690f, 0.02024595f, -0.07074646f, 0.06879334f, 0.15588640f, 0.16217116f, 0.07746004f, 
    0.22145626f, 0.16811576f, -0.06585264f, 0.06355233f, 0.17558759f, 0.08851301f, -0.04814523f, 0.24409477f, 
    0.27746025f, 0.18353027f, 0.22485101f, -0.18306920f, -0.03246487f, 0.02549488f, 0.20552611f, 0.04719595f, 
    0.07975265f, -0.15037261f, 0.00864313f, -0.23527767f, -0.00708488f, 0.01146966f, -0.04718113f, -0.00663856f, 
    0.00304242f, 0.04444817f, -0.29135808f, 0.15363249f, 0.17747124f, -0.01500146f, 0.15242116f, -0.20120528f, 
    -0.28190365f, -0.15328281f, 0.13295783f, 0.15806283f, 0.20339687f, 0.07791185f, -0.06437633f, -0.10475812f, 
    -0.20663722f, 0.00951369f, 0.08733932f, 0.01509980f, 0.30365953f, -0.04374404f, 0.39400187f, -0.08327150f, 
    0.19431797f, 0.12365550f, -0.05338017f, 0.04023641f, -0.03387517f, -0.09807719f, -0.20009744f, 0.66491902f, 
    -0.04955297f, 0.04145965f, 0.05759240f, 0.04654681f, 0.03241681f, 0.06456944f, -0.04472551f, -0.35398299f, 
    -0.31931928f, 0.03116016f, 0.03506307f, 0.15541348f, -0.19325353f, 0.05403290f, 0.12237050f, 0.11446346f, 
    0.22644947f, -0.15535246f, 0.12891139f, -0.00559091f, 0.14455301f, 0.12912181f, 0.04837528f, 0.03812652f, 
    -0.01347215f, 0.07904786f, 0.09660324f, -0.17005071f, 0.17630553f, 0.01698106f, 0.15254727f, 0.07154550f, 
    0.04133297f, -0.40692002f, -0.24900055f, 0.46474311f, -0.10483988f, -0.00910817f, -0.14262566f, -0.01288977f, 
    0.11278343f, 0.05376836f, -0.31753281f, 0.05391258f, 0.13050245f, 0.11692090f, 0.18100931f, 0.18747663f, 
    0.15462191f, -0.02553685f, 0.07490018f, -0.23058952f, -0.34782937f, -0.30305088f, -0.02559938f, -0.10275520f, 
    -0.07509810f, 0.06617141f, 0.08967667f, 0.05657221f, -0.38548639f, -0.00911396f, -0.02772033f, -0.23818876f, 
    0.01264163f, 0.07611760f, -0.02003643f, 0.19804749f, 0.01883553f, 0.28549463f, 0.20297235f, -0.28622434f, 
    0.03522758f, 0.13992594f, -0.10076394f, 0.02074657f, 0.04976539f, -0.09878074f, -0.13125736f, 0.14646636f, 
    0.35707471f, -0.10125291f, -0.01714358f, -0.32409272f, 0.06172272f, 0.19970368f, 0.13623266f, -0.13560380f, 
    -0.00260991f, -0.11436305f, 0.10772727f, 0.00739434f, 0.05667103f, 0.26088515f, 0.04190079f, 0.11196067f, 
    -0.24662802f, -0.47587842f, 0.30975774f, -0.00940655f, 0.08112691f, -0.18568750f, -0.07831450f, 0.06232148f, 
    0.09854311f, -0.10965995f, 0.09899057f, -0.03291132f, 0.11065049f, -0.07247978f, -0.01934418f, -0.02781950f, 
    0.04084451f, -0.10730470f, -0.71934795f, 0.36069682f, -0.46388450f, 0.14303668f, -0.28062037f, 0.02272781f, 
    0.07632741f, 0.11960597f, 0.16058280f, -0.17197022f, -0.06897822f, -0.22526607f, -0.00461099f, -0.25025904f, 
    -0.05876438f, 0.01409786f, -0.05618974f, 0.14945975f, -0.17593695f, 0.13787606f, -0.28761289f, -0.09371363f, 
    -0.12190360f, 0.09027269f, -0.06456766f, 0.10978466f, -0.03204307f, 0.08576762f, 0.07850207f, 0.15973255f, 
    -0.02524894f, -0.18207240f, -0.21121433f, 0.01122705f, 0.04476345f, 0.06564046f, 0.03450351f, 0.23312132f, 
    -0.00584323f, -0.07100555f, 0.10175211f, 0.04502885f, 0.05014021f, -0.02409316f, -0.03187881f, -0.04500770f, 
    -0.09063275f, 0.50976038f, 0.04720656f, 0.09282787f, -0.07585892f, -0.14046220f, 0.08839584f, 0.08266791f, 
    0.24899526f, -0.14793822f, 0.14936356f, 0.05622452f, -0.08244514f, 0.00769506f, -0.05346088f, -0.06554043f, 
    0.27572241f, -0.16643842f, 0.11951987f, 0.29914591f, 0.03113251f, -0.05707515f, -0.19296889f, 0.11272063f, 
    0.03599722f, 0.14443304f, 0.03592843f, -0.03259109f, 0.01594098f, -0.22560404f, -0.05173121f, -0.03777630f, 
    0.01432543f, 0.12348081f, 0.14420840f, -0.34137717f, -0.80613399f, 0.56909758f, 0.04912002f, 0.09940506f, 
    -0.21092960f, 0.14900006f, 0.05208300f, 0.05276154f, -0.29692310f, 0.17494117f, 0.09080477f, -0.05340097f, 
    -0.11833026f, -0.28635487f, 0.01703500f, 0.09444994f, 0.08226933f, 0.06719880f, 0.11604796f, 0.43575442f, 
    -0.05389489f, -0.18508828f, -0.12475678f, -0.12063254f, 0.16171162f, 0.19203249f, -0.24120009f, -0.20124058f, 
    -0.05058233f, 0.09197669f, -0.04056527f, -0.06747036f, 0.24128127f, 0.14877498f, -0.04360535f, 0.01251164f, 
    -0.00513328f, 0.10790225f, -0.17242914f, -0.02312485f, -0.19325633f, 0.00019465f, -0.12126837f, -0.01095248f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.06561700f, 0.07865795f, -0.07722108f, 0.12147626f, -0.05065331f, 0.22660264f, 0.06733269f, -0.03187830f, 
    -0.05490974f, -0.07273666f, 0.14944525f, -0.02439244f, 0.28032508f, 0.12484699f, 0.38660756f, 0.04007141f, 
    0.18901518f, -0.05011299f, 0.19610743f, -0.03288156f, -0.06450244f, -0.05422780f, 0.03805410f, -0.11753098f, 
    0.13170943f, -0.01136331f, 0.15738514f, 0.03746076f, -0.05869525f, -0.05957006f, 0.05219097f, 0.20435792f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.06334142f, 0.15951793f, 0.12795614f, 0.17496425f, -0.08241034f, 0.15959440f, -0.02989833f, -0.17604679f, 
    -0.01686801f, 0.07364652f, 0.22105053f, -0.24946395f, 0.16615033f, -0.04483797f, 0.31626678f, -0.03692622f, 
    0.23712912f, 0.04575559f, -0.18333994f, -0.04724364f, -0.11532006f, 0.10473336f, 0.09294783f, 0.31137022f, 
    0.20840316f, 0.24036613f, -0.15682650f, 0.20524663f, -0.10165673f, -0.06422325f, -0.07431759f, 0.03002151f, 
    0.03561809f, -0.33152702f, 0.05160799f, 0.07655168f, 0.01817128f, 0.07255311f, -0.04237116f, -0.06795277f, 
    0.02851061f, -0.12730677f, -0.18447727f, -0.16287526f, 0.27355704f, 0.06505638f, 0.08456719f, 0.00551973f, 
    0.47872731f, -0.07477409f, -0.18246230f, 0.09043780f, -0.25336421f, -0.12002578f, 0.00387864f, 0.36424041f, 
    -0.38338020f, 0.18435520f, -0.03758504f, 0.01555451f, 0.02109287f, 0.10639410f, 0.16802530f, 0.42105418f, 
    0.14410475f, -0.02239137f, -0.02145935f, -0.16172624f, 0.06779326f, 0.11192677f, 0.06246911f, -0.16788818f, 
    -0.15321410f, -0.13003504f, -0.16158523f, -0.19374864f, 0.04445573f, 0.02770562f, -0.04161875f, 0.06776906f, 
    -0.11818857f, 0.01129019f, -0.07791377f, 0.01489120f, -0.06933907f, -0.14157869f, -0.16089353f, 0.09269121f, 
    -0.01706364f, -0.08579449f, -0.24425624f, 0.07242048f, 0.03374618f, 0.09959716f, -0.18036005f, -0.16104656f, 
    -0.11229870f, -0.07792016f, -0.17228886f, -0.03093035f, 0.12817268f, -0.23856300f, -0.05093424f, 0.16124587f, 
    -0.12170082f, -0.25852674f, -0.10944075f, -0.03964658f, 0.39314619f, 0.23106618f, -0.26507801f, 0.21486604f, 
    -0.04808896f, -0.03746901f, 0.12652749f, -0.00373282f, -0.29302371f, 0.05221723f, 0.08475883f, 0.19847658f, 
    -0.17219280f, -0.39104596f, 0.24947773f, 0.05130880f, -0.26389757f, 0.07316447f, 0.23739074f, 0.44937047f, 
    -0.09136363f, 0.30343184f, -0.01092739f, 0.17710708f, -0.14812842f, 0.42586789f, -0.05992854f, -0.07962995f, 
    -0.05951447f, -0.19889073f, 0.00383004f, -0.00837018f, 0.00038536f, 0.20271631f, 0.16717748f, -0.00828980f, 
    -0.16662115f, 0.15945345f, 0.00840525f, 0.12094495f, -0.00924247f, -0.04005147f, -0.11343054f, -0.16132136f, 
    0.56478035f, 0.40038249f, 0.14972655f, -0.21353200f, 0.12085607f, -0.15544839f, -0.00268662f, -0.10996617f, 
    -0.06209524f, -0.10240980f, -0.09863696f, -0.15155986f, -0.01307374f, -0.19346090f, -0.21746460f, 0.09697855f, 
    0.09583984f, 0.10746340f, -0.03823352f, 0.05329913f, 0.24693274f, 0.21543132f, 0.04288223f, 0.03959053f, 
    0.02103584f, -0.00182434f, -0.04509012f, -0.01842846f, 0.09620755f, 0.03871741f, -0.10309733f, 0.20015918f, 
    -0.12012978f, 0.07704683f, -0.17755640f, -0.02943514f, -0.35589263f, 0.03413793f, 0.14333196f, -0.10995266f, 
    -0.14972660f, 0.19325975f, 0.21472375f, 0.26731378f, 0.15632275f, 0.14290696f, 0.05656812f, 0.07920333f, 
    0.10846059f, -0.26962325f, -0.15481524f, 0.36736250f, 0.16283029f, 0.31745005f, -0.00471007f, -0.37554532f, 
    -0.11562693f, 0.03713721f, 0.08777624f, -0.16836914f, 0.16741586f, -0.02275376f, 0.09104414f, 0.47667488f, 
    -0.05558029f, 0.21782024f, 0.05503589f, -0.35160342f, -0.44621310f, -0.00377042f, 0.16591099f, 0.33804053f, 
    -0.12361255f, -0.04741257f, 0.31409928f, -0.23478878f, 0.04418160f, 0.32312405f, 0.11442240f, -0.11200425f, 
    0.08167173f, -0.26376349f, -0.07125727f, 0.34452164f, 0.28305081f, -0.07860551f, -0.37118125f, 0.06416223f, 
    -0.35665518f, 0.15624684f, 0.37703910f, -0.16044851f, 0.35184497f, 0.13412519f, -0.16547972f, -0.11581334f, 
    -0.62564152f, -0.21353798f, 0.23477685f, -0.15108947f, 0.16177940f, 0.16627263f, -0.11800350f, -0.04477308f, 
    -0.02515277f, 0.00721043f, 0.00843147f, 0.08073787f, -0.04806501f, -0.30001599f, -0.18464215f, -0.15647261f, 
    0.09864406f, -0.23086263f, -0.42361897f, 0.13617720f, 0.35109571f, 0.19656932f, -0.08742022f, -0.12370490f, 
    -0.07472403f, -0.16303413f, -0.15976952f, -0.14280123f, -0.11390009f, 0.13381541f, -0.09004711f, 0.26714548f, 
    0.33603001f, 0.18833825f, 0.12648779f, 0.00963346f, 0.04938724f, 0.03746356f, 0.27457002f, 0.44394159f, 
    -0.00133267f, -0.13906462f, 0.15662757f, -0.05589408f, -0.10286445f, -0.03936870f, 0.04334176f, 0.03928799f, 
    0.10504231f, -0.12995346f, -0.01051174f, 0.33242390f, 0.57045567f, 0.05727347f, -0.17613529f, -0.05390473f, 
    -0.49247521f, -0.03149762f, 0.31000945f, 0.05435884f, -0.07335991f, -0.05913616f, 0.05958750f, 0.02875295f, 
    -0.27568820f, -0.37207448f, 0.33253416f, -0.06036519f, -0.13343960f, 0.16051500f, -0.08183052f, 0.41588238f, 
    -0.09035981f, 0.06235793f, 0.43177998f, 0.16280666f, 0.10370565f, -0.20696412f, -0.17570418f, -0.03534307f, 
    -0.10349140f, 0.16928190f, 0.48410568f, -0.21532862f, -0.75445604f, 0.15239440f, 0.05268406f, 0.13424256f, 
    -0.34273207f, 0.03901474f, 0.19996369f, 0.03700807f, -0.33123621f, -0.12280479f, -0.07572927f, -0.09230053f, 
    0.33664197f, -0.00667212f, 0.01991599f, 0.04101471f, 0.29539403f, 0.01861498f, 0.26070723f, 0.02515779f, 
    0.03300110f, -0.12983361f, -0.25508064f, 0.10910774f, -0.05256555f, -0.12526536f, 0.04839733f, 0.04203457f, 
    0.06899320f, 0.05116569f, -0.33443627f, 0.09280919f, -0.28956202f, 0.21204990f, 0.16309680f, -0.12861986f, 
    0.34074125f, 0.12194742f, -0.07381795f, -0.09599514f, -0.27247831f, -0.06567618f, -0.05092898f, 0.38165706f, 
    0.21151108f, -0.28873360f, 0.20012234f, 0.19150540f, -0.21092343f, -0.03412339f, 0.43494725f, -0.13249636f, 
    -0.15420927f, -0.15933159f, -0.05352866f, 0.21232645f, 0.12354621f, -0.73000640f, 0.31425744f, 0.07797611f, 
    0.02917445f, -0.34807983f, 0.04821784f, 0.07829412f, -0.13563366f, -0.66562015f, -0.26389927f, 0.09143957f, 
    0.42211750f, -0.14260480f, 0.02539058f, -0.05183684f, 0.57002538f, 0.02742215f, 0.02973365f, 0.20082334f, 
    0.26778755f, 0.35416114f, -0.25727397f, 0.25829628f, 0.33961654f, 0.03350962f, 0.09206372f, -0.31310588f, 
    -0.13291334f, -0.21482770f, 0.07404409f, 0.25976494f, 0.17549196f, -0.17601672f, -0.08362952f, 0.13842233f, 
    -0.03902582f, -0.10839034f, -0.10487920f, -0.21000643f, 0.31710836f, 0.19011210f, 0.26574326f, -0.08502586f, 
    0.21569960f, -0.12936002f, -0.03421033f, 0.07463250f, -0.57531345f, 0.10269161f, 0.16278256f, 0.46043804f, 
    0.22925393f, 0.16164571f, -0.06500438f, 0.11206500f, 0.18920027f, -0.07758079f, -0.00490594f, 0.33142102f, 
    -0.17757390f, 0.17851737f, -0.21840046f, 0.17778501f, 0.16951902f, -0.01414407f, 0.06933928f, 0.16123071f, 
    0.09676329f, 0.06127897f, 0.04829723f, -0.28324041f, -0.34690779f, 0.14173669f, -0.16889101f, 0.04231703f, 
    0.34554547f, -0.12426367f, 0.19709635f, -0.04017465f, -0.35929650f, 0.02080160f, 0.07284033f, -0.85547787f, 
    -0.46703571f, 0.22206378f, 0.23938696f, 0.00017262f, -0.24180348f, -0.04769629f, 0.37117636f, 0.20093399f, 
    0.14260760f, -0.16414188f, -0.15366274f, -0.08546169f, -0.10464814f, 0.10094479f, 0.10299914f, 0.15597011f, 
    -0.09480935f, -0.04050996f, 0.25537607f, -0.44124353f, -0.34128773f, 0.13582474f, -0.32109419f, 0.23301719f, 
    0.28827643f, -0.15712292f, 0.03101857f, 0.16813950f, -0.88725787f, -0.04687623f, -0.07399330f, -0.26900664f, 
    0.21465528f, 0.10701574f, 0.03844805f, 0.06119777f, 0.26992878f, 0.13028756f, 0.21224912f, 0.54372466f, 
    0.06743249f, -0.15204984f, 0.36127719f, 0.24821752f, -0.03498491f, -0.24146782f, 0.15764841f, 0.08085980f, 
    0.00455141f, -0.21311410f, 0.24660738f, 0.23556827f, -0.12564388f, 0.06215988f, 0.38904735f, 0.03550844f, 
    -0.35569602f, -0.06226330f, 0.03242404f, -0.10269322f, 0.24902418f, 0.12313806f, 0.01904738f, 0.44770959f, 
    0.40185317f, 0.07172493f, 0.11990415f, 0.24054752f, 0.01336337f, 0.09157815f, -0.20131648f, -0.33658728f, 
    -0.00884450f, -0.02685385f, 0.08358261f, -0.20692699f, 0.03182898f, 0.11699213f, -0.15064219f, 0.14692290f, 
    0.02091723f, 0.05484336f, -0.04146798f, -0.14571577f, -0.07043123f, -0.15626465f, -0.06508074f, 0.00141511f, 
    -0.08383317f, -0.04237133f, 0.07276930f, -0.17067507f, -0.17551793f, -0.03100154f, 0.01994692f, 0.14546795f, 
    -0.10468746f, 0.13117239f, -0.15374967f, -0.17086378f, -0.14531060f, -0.06905945f, 0.07397120f, 0.10014661f, 
    0.01967431f, 0.24060386f, -0.14847909f, -0.07456422f, 0.10121428f, 0.10562034f, -0.16538970f, 0.18069135f, 
    -0.02163267f, 0.21029973f, 0.12950070f, 0.20387752f, 0.22587031f, 0.32571945f, -0.40010417f, -0.18403354f, 
    -0.32802051f, 0.02778889f, 0.18879716f, 0.14218442f, -0.10243633f, -0.02103350f, -0.15642655f, -0.37262893f, 
    -0.05539522f, 0.07338422f, 0.31099728f, -0.17918691f, 0.00543222f, 0.00518561f, 0.42695642f, 0.29170886f, 
    0.00949399f, 0.12040277f, 0.23348612f, 0.02568656f, 0.06292415f, 0.18722272f, -0.16803491f, 0.09088576f, 
    -0.12558211f, -0.09214706f, -0.42942813f, -0.15814795f, 0.03791639f, 0.18430910f, -0.10044659f, 0.25694928f, 
    0.18985350f, 0.18033835f, 0.12643899f, 0.13705347f, -0.19495146f, 0.12987006f, 0.00394432f, 0.19348463f, 
    -0.22672245f, 0.00469454f, -0.16005057f, 0.07312707f, 0.03754344f, 0.12471234f, -0.03799678f, 0.15479316f, 
    -0.05633490f, 0.27326220f, -0.08145052f, -0.05283924f, 0.12660627f, 0.23594381f, 0.15183890f, 0.03626944f, 
    -0.12559099f, -0.02885397f, 0.17569503f, -0.07126793f, -0.06494546f, -0.11977341f, -0.14107239f, -0.25433496f, 
    0.42004669f, 0.12802422f, 0.16141160f, -0.02338319f, 0.16476530f, -0.11335916f, -0.14678052f, -0.01182067f, 
    -0.18137102f, 0.24497877f, 0.27158579f, 0.01654412f, -0.23314185f, 0.15642753f, 0.35301557f, -0.38263881f, 
    -0.13698353f, -0.12942933f, -0.00085811f, 0.09812985f, -0.07465857f, -0.03598053f, -0.20143750f, -0.02071855f, 
    0.03843967f, 0.06600416f, -0.14915037f, -0.16734703f, -0.01183695f, -0.21707065f, -0.15489121f, -0.01381482f, 
    0.06422298f, 0.03869359f, 0.05075584f, 0.08895946f, -0.07886906f, 0.04011488f, -0.06754662f, -0.01867015f, 
    -0.08912495f, -0.16244298f, -0.02797524f, 0.04820898f, -0.15864010f, -0.07640853f, 0.05376947f, -0.08431717f, 
    0.10003904f, -0.10698514f, 0.07149769f, -0.11302655f, 0.11507217f, -0.15217234f, 0.00563976f, 0.15903547f, 
    0.10451080f, -0.03605125f, -0.16652648f, 0.08764821f, 0.06940176f, -0.07314890f, 0.07965507f, -0.18463601f, 
    -0.08374172f, -0.02093878f, -0.06456675f, 0.04994991f, -0.03480530f, 0.09771100f, 0.15825795f, -0.05927873f, 
    0.11198504f, -0.12832788f, -0.05836034f, -0.01095017f, 0.04582507f, 0.13731447f, 0.05645379f, -0.14328560f, 
    0.13776776f, 0.15071352f, 0.07984988f, 0.30034682f, -0.07988560f, -0.22024904f, -0.14510714f, -0.02858502f, 
    -0.05203530f, -0.07040387f, 0.32858515f, 0.09078559f, 0.01684622f, -0.09049398f, 0.52378291f, -0.01587792f, 
    -0.19828780f, -0.17114036f, 0.19857174f, -0.00877917f, -0.11696375f, -0.05170921f, -0.16096181f, 0.33727103f, 
    0.48114440f, 0.37004533f, 0.01597943f, 0.19434373f, 0.12733023f, 0.02911898f, -0.14122967f, -0.09484187f, 
    0.02251116f, -0.23450059f, -0.34567800f, 0.19630069f, 0.13915700f, 0.10081280f, 0.19206488f, 0.15732491f, 
    -0.04713269f, -0.03267644f, 0.05245164f, -0.45566097f, 0.04497794f, 0.08941851f, 0.28271273f, 0.27878335f, 
    0.26246688f, 0.09627756f, -0.05794030f, 0.03155251f, -0.30764577f, -0.08700846f, 0.15952058f, 0.38081577f, 
    0.31710449f, -0.12463952f, 0.00714243f, -0.02047104f, 0.04615403f, -0.11298258f, 0.11473217f, 0.12799518f, 
    0.14126825f, -0.42264414f, 0.13104789f, -0.36999920f, -0.06831578f, -0.15538189f, 0.34501415f, -0.12259127f, 
    -0.04539540f, -0.09952763f, 0.34381157f, -0.22425248f, -0.31647652f, -0.41334358f, -0.05548343f, 0.17185651f, 
    0.43424377f, 0.02762425f, 0.04873351f, -0.00864350f, -0.13712612f, -0.15579620f, -0.10829923f, -0.15820754f, 
    -0.29937360f, -0.36308458f, 0.00679450f, 0.33065942f, 0.50122404f, -0.08516430f, -0.01227766f, -0.08774400f, 
    -0.09965559f, -0.11705009f, 0.09271046f, 0.00519708f, -0.01596459f, 0.06020582f, -0.11392771f, -0.07029812f, 
    -0.09703585f, 0.05734269f, -0.06900708f, 0.14582658f, -0.09359515f, 0.01083224f, -0.17581470f, -0.17835413f, 
    -0.05829642f, 0.03988189f, -0.11201656f, -0.09469941f, -0.04901883f, -0.09269679f, -0.08483133f, 0.02482459f, 
    0.07066394f, -0.11854488f, -0.16804507f, 0.15532115f, 0.07334858f, -0.09893135f, 0.00487621f, -0.05823917f, 
    0.14646247f, 0.00954884f, 0.05328763f, -0.19237655f, -0.01853412f, 0.06079544f, -0.07517411f, -0.12121484f, 
    -0.09770010f, -0.09044612f, -0.05284638f, -0.02255011f, -0.06140243f, -0.12436219f, -0.05865641f, 0.15758887f, 
    0.00486797f, 0.14547452f, 0.16711377f, 0.15620138f, 0.05077556f, 0.15677671f, -0.02392335f, -0.04055425f, 
    -0.16285533f, -0.22412679f, 0.02284142f, -0.18315457f, -0.10233153f, 0.05877454f, -0.14774387f, -0.17145459f, 
    0.09864620f, -0.06865861f, -0.02306307f, -0.05210749f, -0.13403787f, -0.25891882f, -0.16556294f, -0.03770396f, 
    -0.04807708f, -0.15640396f, 0.44402748f, -0.21996525f, 0.11739829f, 0.19744261f, 0.26893827f, 0.16789411f, 
    0.02886789f, 0.03690500f, -0.16066891f, -0.01298426f, 0.17473197f, -0.00615359f, 0.03262968f, -0.38558275f, 
    0.12996511f, 0.15850070f, -0.20687735f, 0.06416612f, -0.08364692f, 0.12380822f, -0.13007022f, 0.35327154f, 
    0.06568824f, -0.15275791f, 0.10038222f, -0.01215688f, 0.12208302f, -0.23006020f, 0.22657752f, -0.03042141f, 
    0.16639493f, 0.15993139f, -0.09267372f, -0.19658971f, -0.01965777f, -0.01089292f, -0.09696820f, 0.16323705f, 
    0.09302463f, -0.04981472f, -0.26090416f, 0.00506402f, 0.26075611f, -0.10313806f, 0.10440192f, 0.26700291f, 
    0.24926843f, -0.00051757f, -0.29499918f, 0.17029783f, 0.53600430f, 0.18159506f, 0.17333220f, 0.22729746f, 
    -0.12824732f, -0.14787042f, -0.15610515f, -0.15017448f, -0.07639095f, -0.03345360f, -0.02660619f, 0.05852115f, 
    0.08479699f, -0.13726078f, 0.10074911f, -0.17337091f, 0.06642215f, -0.12337063f, 0.16684945f, -0.09832680f, 
    -0.17659304f, -0.04793317f, -0.11584164f, 0.12588559f, -0.12956592f, -0.06405569f, 0.06889952f, -0.00354232f, 
    0.10607601f, -0.13485838f, -0.01897569f, -0.06600451f, -0.08724804f, -0.16486490f, 0.00122076f, -0.10433425f, 
    0.02249014f, 0.16201770f, 0.08549956f, 0.28291273f, -0.14454518f, -0.28159493f, -0.17350134f, -0.03980717f, 
    0.08491375f, 0.30406317f, 0.18896410f, 0.05952507f, 0.19189890f, 0.27958447f, -0.18264861f, -0.15123351f, 
    -0.37055704f, 0.01979069f, -0.12211308f, -0.08613966f, 0.20419146f, -0.10719787f, -0.14820477f, 0.00790478f, 
    0.13170850f, 0.30517009f, 0.26890543f, -0.21070248f, 0.05795358f, -0.00454416f, 0.40186957f, 0.40399098f, 
    0.04004043f, -0.19345915f, 0.05198830f, -0.01004021f, 0.10490783f, -0.08013366f, 0.01042036f, 0.11869949f, 
    -0.05448873f, 0.19550735f, 0.49624249f, -0.07371457f, -0.44110811f, -0.09271002f, -0.60080534f, -0.15438586f, 
    -0.09761639f, -0.01509010f, 0.32047322f, 0.02055091f, -0.65701181f, -0.09252095f, 0.04236032f, 0.12928648f, 
    0.03666284f, -0.10397402f, 0.09660600f, 0.28427073f, 0.33399254f, -0.14741540f, 0.09908513f, -0.11129031f, 
    0.04977583f, 0.15908679f, 0.30462313f, 0.23732427f, -0.11880115f, -0.02015600f, 0.00689999f, -0.16809410f, 
    0.02596284f, 0.09382416f, 0.02966098f, -0.04643649f, -0.01851786f, 0.17132643f, 0.06016779f, 0.22120984f, 
    -0.10664042f, -0.01890888f, -0.00446580f, 0.00018009f, 0.09781443f, 0.03039989f, -0.07252193f, 0.29581228f, 
    -0.11196548f, 0.40889019f, -0.22366340f, -0.10296708f, -0.26273176f, -0.10118760f, -0.21718906f, 0.45453009f, 
    -0.15037628f, -0.17888054f, -0.23235425f, -0.16071196f, 0.06153598f, 0.17887677f, 0.11249507f, 0.00873580f, 
    -0.03363906f, 0.10649963f, 0.09323484f, -0.27280310f, -0.37988871f, 0.11668467f, -0.20809123f, 0.14735454f, 
    -0.03406725f, -0.17166115f, 0.08504551f, -0.13533182f, 0.06748109f, 0.12094305f, -0.07736851f, -0.66220260f, 
    0.11185005f, -0.32608283f, 0.23495416f, 0.04113054f, 0.01739449f, -0.03181168f, 0.15639316f, 0.18387195f, 
    -0.14998657f, -0.36685720f, 0.13205165f, -0.31671029f, -0.04518656f, 0.34044200f, 0.22597794f, -0.05685472f, 
    0.13786921f, 0.16992640f, -0.34153825f, -0.25672618f, 0.22884350f, -0.03606896f, 0.04503186f, 0.21515252f, 
    0.20006128f, 0.14070459f, 0.00299304f, 0.08413915f, 0.37181634f, -0.13597076f, 0.10253120f, -0.16836473f, 
    0.11574347f, -0.17517036f, -0.07051541f, 0.07703527f, 0.10237843f, -0.04339583f, -0.21386731f, 0.07847455f, 
    -0.15513296f, 0.13992879f, -0.18123321f, 0.09726371f, -0.10791953f, 0.63046527f, 0.08047654f, -0.00966201f, 
    -0.15058948f, -0.02804800f, 0.31563759f, -0.18001391f, 0.06092025f, 0.02157478f, 0.21325034f, -0.07650797f, 
    0.23751676f, 0.15670927f, 0.07230807f, -0.06815387f, -0.38505614f, -0.11634658f, 0.00897047f, -0.03815404f, 
    0.20147112f, 0.12610415f, 0.12949294f, -0.06637475f, -0.09978159f, 0.07396532f, -0.11440478f, 0.14903015f, 
    0.03257258f, 0.26003435f, 0.56992209f, -0.02065635f, 0.14635721f, -0.18012594f, -0.10541905f, -0.01755944f, 
    0.10695561f, 0.19984396f, -0.08317790f, 0.50480437f, 0.51370329f, -0.17477195f, -0.12921943f, -0.00376921f, 
    -0.40472856f, -0.01690241f, -0.07891763f, -0.01198233f, 0.21253784f, 0.02265626f, -0.18084592f, -0.33914480f, 
    -0.32994089f, 0.20986521f, -0.13098015f, 0.04334569f, 0.39566249f, 0.13962689f, 0.29990968f, 0.27579576f, 
    -0.15185136f, -0.06267941f, -0.00109117f, -0.01563788f, -0.09101399f, 0.02972703f, -0.04452434f, 0.11304444f, 
    -0.02661960f, -0.11504874f, -0.11616551f, -0.01689233f, 0.02414479f, -0.07399264f, 0.06057010f, -0.16572252f, 
    -0.06289940f, -0.01143407f, 0.00247363f, 0.04411028f, 0.00492462f, -0.10547049f, -0.05187084f, 0.01577731f, 
    0.03784087f, -0.00004549f, -0.16845462f, 0.11016674f, -0.11407513f, -0.15115125f, -0.04964561f, -0.01262818f, 
    0.05730205f, -0.15487370f, -0.10573789f, -0.00207793f, 0.00439099f, -0.31294498f, 0.20943062f, 0.00173502f, 
    -0.02891872f, -0.22256412f, 0.16944773f, 0.05484654f, 0.18051676f, -0.49426979f, -0.33667895f, 0.21266282f, 
    -0.35172263f, 0.15705530f, 0.10226266f, -0.10870972f, 0.68936348f, 0.11635254f, -0.13195372f, 0.16356246f, 
    0.07407083f, 0.31612703f, -0.33898655f, 0.31211007f, 0.23185907f, 0.09977829f, 0.07437443f, 0.06794479f, 
    0.07352619f, 0.27982754f, 0.19185010f, 0.21996360f, -0.07803754f, 0.14964248f, -0.16397217f, -0.15544178f, 
    0.12123311f, 0.22477803f, 0.13844566f, 0.12609938f, 0.44042674f, 0.00586216f, 0.02170213f, -0.11016545f, 
    -0.12831065f, -0.13742036f, -0.08003041f, 0.08783595f, 0.06135944f, -0.17647363f, 0.03947289f, -0.14050920f, 
    0.11057746f, 0.47173992f, -0.02027061f, -0.22853774f, 0.27480781f, 0.06024241f, 0.24001026f, 0.00782721f, 
    -0.13586172f, -0.11163548f, 0.15342624f, 0.14849262f, 0.06953713f, -0.17876074f, 0.09742782f, -0.15967886f, 
    -0.00942418f, -0.14885639f, -0.03283247f, -0.11384989f, 0.10889637f, -0.05567097f, -0.17428419f, -0.10150861f, 
    0.05429288f, 0.05502297f, -0.16311865f, -0.01149583f, -0.05213854f, -0.11328932f, 0.10596800f, -0.15693210f, 
    0.14331165f, -0.14898732f, -0.15759745f, 0.09921251f, -0.14825943f, 0.01624178f, -0.03423704f, 0.05385684f, 
    0.13986683f, 0.06037322f, -0.00157521f, -0.18272237f, 0.13654116f, 0.12268450f, -0.03751047f, 0.01282060f, 
    0.07458002f, 0.00319282f, -0.13316222f, 0.01345362f, -0.16681974f, -0.11883662f, 0.00462676f, 0.09802473f, 
    -0.12436052f, -0.00566484f, 0.05985536f, 0.08749366f, -0.16356371f, -0.06983625f, -0.05684419f, 0.10168517f, 
    -0.08977035f, -0.03990634f, -0.10899117f, -0.14805184f, 0.10089155f, -0.17645293f, 0.03113251f, 0.06537447f, 
    0.06308975f, 0.09853256f, -0.21986899f, -0.05313239f, 0.11666515f, 0.45643997f, 0.19763395f, 0.18223292f, 
    0.09954007f, 0.10519033f, 0.13183108f, -0.17924966f, -0.09815572f, 0.23678738f, -0.17530599f, 0.26726428f, 
    0.06237342f, 0.01347764f, 0.24024779f, -0.04079966f, -0.43273005f, -0.06491027f, -0.11856948f, -0.32366866f, 
    0.15273373f, 0.22536999f, -0.11007803f, 0.01916827f, 0.02816765f, 0.13709904f, 0.15066980f, 0.42826846f, 
    -0.00319838f, 0.12506822f, 0.14747728f, 0.09218025f, -0.10940444f, -0.25279787f, 0.13478288f, -0.02737075f, 
    0.13230138f, 0.01733146f, 0.29596666f, 0.03920731f, -0.17995815f, -0.10988303f, -0.22491398f, -0.11215359f, 
    0.09972241f, 0.13901569f, 0.35215071f, -0.00805215f, -0.38582236f, 0.06559196f, 0.00375308f, 0.35620105f, 
    -0.38764882f, -0.13975862f, 0.30826265f, 0.27324465f, -0.31914648f, 0.06107793f, 0.22606277f, -0.39628077f, 
    -0.05601148f, -0.16653730f, -0.11804599f, 0.07591631f, 0.05689289f, -0.08369177f, 0.07974410f, -0.05346275f, 
    0.06041582f, -0.03563943f, -0.08760156f, 0.00868054f, -0.01973336f, -0.13259152f, 0.10849793f, -0.06821777f, 
    0.08245911f, 0.05981175f, 0.09646670f, -0.17386892f, -0.22729358f, 0.05759339f, -0.11398714f, -0.00279034f, 
    -0.14633325f, -0.16446365f, -0.05897315f, -0.11219470f, -0.10084962f, 0.07137274f, 0.08617293f, -0.08075109f, 
    -0.05993657f, 0.04150799f, 0.11197305f, -0.08024541f, 0.06136775f, -0.08320152f, -0.12053568f, -0.03869894f, 
    0.01176860f, -0.07993933f, -0.14018828f, -0.00975086f, -0.17319676f, 0.02367756f, 0.03238054f, -0.01051881f, 
    -0.15192963f, 0.11259889f, -0.00715969f, -0.14214851f, -0.11957723f, 0.07176993f, -0.07365288f, 0.02322854f, 
    0.08018543f, 0.03641087f, -0.14485359f, 0.01205815f, -0.13192724f, 0.04258473f, -0.10404452f, 0.03721850f, 
    -0.11872178f, -0.09741244f, -0.05846559f, -0.20951155f, -0.03642326f, 0.04835846f, 0.07836033f, 0.02681939f, 
    0.04631349f, 0.16352670f, 0.35189432f, -0.34304407f, 0.26372364f, -0.26701128f, 0.08051223f, 0.16871278f, 
    0.17989774f, -0.09902234f, -0.13980919f, 0.01060138f, 0.21149120f, 0.11911260f, 0.09330833f, -0.35889122f, 
    -0.04004801f, -0.04581252f, -0.22368108f, 0.20441532f, 0.10105067f, -0.00695397f, -0.20499410f, 0.30818138f, 
    -0.15337875f, 0.10165371f, 0.12425764f, 0.23236507f, 0.11439647f, -0.24287379f, -0.12315134f, 0.16544898f, 
    0.08180770f, -0.26026157f, -0.30312645f, 0.20692679f, 0.18296872f, 0.09297138f, 0.07174338f, -0.28759891f, 
    -0.45140761f, 0.13903426f, 0.15827766f, 0.08656448f, -0.03908357f, -0.01567302f, 0.01490858f, 0.38692707f, 
    -0.26611599f, -0.05351484f, 0.36298615f, 0.08492414f, -0.11831509f, -0.06113221f, -0.06211243f, -0.01662735f, 
    -0.15623571f, 0.06497985f, 0.24559614f, 0.10049831f, -0.07803436f, -0.00076631f, 0.24873959f, -0.10741408f, 
    -0.16076659f, -0.47210643f, 0.12030643f, 0.34392139f, -0.39637139f, -0.02119558f, -0.00049229f, 0.16903400f, 
    -0.20012483f, 0.04620686f, -0.11743640f, 0.10799291f, 0.47264493f, -0.09896248f, -0.08668462f, 0.04354526f, 
    -0.05815745f, 0.35289851f, -0.18109900f, 0.12857515f, 0.05395025f, 0.09691565f, -0.24730045f, 0.23614307f, 
    0.12561190f, 0.05158156f, -0.22617607f, -0.05730848f, 0.02644068f, 0.20481148f, 0.07651218f, 0.00158087f, 
    0.17327456f, -0.06847293f, -0.23676966f, -0.14279865f, 0.07972516f, -0.01849484f, -0.09225083f, -0.02085916f, 
    -0.03172039f, -0.04828313f, 0.08970203f, 0.08798936f, 0.10491353f, 0.14871359f, -0.03533750f, -0.15025289f, 
    -0.06629920f, -0.06281273f, -0.10355718f, -0.15319593f, 0.04998295f, 0.00070170f, -0.19643304f, 0.05197119f, 
    -0.05444804f, -0.21629508f, -0.07337239f, 0.13464202f, 0.12987581f, -0.09504683f, -0.15870354f, 0.02018687f, 
    -0.05563000f, -0.04872469f, 0.05335259f, -0.13291281f, -0.11833899f, -0.17925437f, 0.12227457f, 0.12277908f, 
    0.02328931f, 0.17093988f, -0.13620374f, 0.04752930f, -0.05055451f, -0.06934366f, 0.14650643f, -0.15378100f, 
    -0.09565476f, 0.14676657f, -0.04556765f, -0.14364368f, -0.02171715f, -0.16139735f, -0.12454890f, -0.18144192f, 
    -0.04141616f, -0.05191625f, 0.15285453f, -0.35695106f, 0.12546340f, -0.07926678f, 0.03660843f, -0.03027248f, 
    0.14555854f, -0.13019370f, 0.07514203f, -0.02128791f, -0.19669247f, 0.09805460f, 0.12086014f, 0.20342942f, 
    -0.18729258f, 0.11007456f, 0.30401951f, 0.14275193f, -0.03572361f, 0.06866042f, 0.02361173f, -0.26165330f, 
    0.01614662f, -0.33833712f, -0.01412547f, 0.21060027f, 0.51154238f, -0.16510615f, 0.02713271f, -0.03154781f, 
    0.02848071f, -0.20515192f, 0.39219847f, 0.14744446f, 0.00806708f, 0.23701729f, 0.11940151f, 0.01461408f, 
    0.01346809f, -0.05690581f, 0.49359816f, 0.07593041f, -0.26681787f, -0.20575112f, -0.39137653f, 0.05937865f, 
    -0.46327516f, 0.03401845f, 0.40667087f, -0.01303876f, 0.11591464f, 0.11695485f, 0.03854970f, -0.31684092f, 
    -0.49467793f, 0.01069879f, 0.05908787f, 0.08347840f, -0.13229790f, -0.16517249f, -0.26961929f, 0.13498174f, 
    0.01065776f, -0.10383026f, -0.14569052f, 0.23308483f, 0.04814066f, 0.21547551f, -0.02381076f, -0.07649534f, 
    0.13706769f, -0.06577493f, -0.07018044f, -0.24075869f, 0.16514055f, 0.17440604f, 0.41587287f, -0.16472448f, 
    0.16677399f, -0.00009712f, -0.23914045f, -0.11396184f, -0.24421090f, 0.12129193f, 0.08023050f, 0.52262449f, 
    0.64583522f, 0.29778945f, 0.10762752f, 0.08072682f, -0.00464907f, -0.03840972f, 0.15962088f, -0.11975576f, 
    -0.15353452f, -0.05815077f, -0.25648931f, -0.04855142f, -0.10173636f, 0.16270812f, 0.26970559f, -0.04045483f, 
    -0.01935377f, -0.12898144f, 0.21161470f, -0.23503344f, -0.41085064f, -0.07642744f, 0.07845300f, 0.07419271f, 
    0.18739590f, -0.07987208f, 0.23719922f, -0.08416343f, 0.04318892f, -0.05517901f, -0.16943994f, -0.51852727f, 
    -0.27183241f, -0.13648430f, 0.16386262f, 0.35573259f, 0.21054707f, -0.03965632f, -0.06187709f, 0.11428642f, 
    -0.14661191f, 0.09060404f, -0.11593197f, 0.15326938f, 0.10676915f, -0.16499987f, 0.12620211f, 0.13504270f, 
    -0.10235644f, -0.04685460f, -0.09267369f, -0.06745785f, 0.12171625f, -0.10805567f, -0.13937515f, -0.14892697f, 
    0.01871109f, -0.01953150f, -0.10397987f, -0.17333671f, 0.04750456f, -0.15324876f, -0.17025976f, 0.04223385f, 
    -0.09184040f, 0.06712031f, -0.12594938f, -0.01175769f, -0.10703918f, 0.14519250f, -0.09554817f, 0.00906917f, 
    -0.14644764f, -0.33160189f, 0.13574687f, -0.30031618f, -0.14860378f, -0.18359834f, 0.27064490f, -0.03619675f, 
    0.16537781f, 0.10184319f, 0.13987781f, -0.14271648f, 0.14802077f, -0.28293836f, 0.10247587f, 0.27463424f, 
    0.17637458f, -0.02739464f, 0.14051485f, 0.12597147f, 0.03081214f, -0.01596756f, -0.01335922f, 0.13877855f, 
    -0.40131423f, -0.33079755f, 0.01290791f, 0.19913915f, 0.26968640f, -0.13687576f, 0.16441120f, -0.15061429f, 
    -0.11877652f, 0.13877723f, 0.27267510f, 0.31345001f, 0.10488794f, 0.20823790f, 0.22550158f, 0.05296610f, 
    -0.02068833f, -0.40524876f, 0.46304289f, 0.03048597f, -0.28234524f, -0.15881656f, 0.35593387f, 0.03998816f, 
    -0.36146814f, -0.01577574f, 0.14991353f, -0.13048881f, 0.10471943f, -0.06818698f, -0.10233498f, -0.17910360f, 
    -0.17477450f, 0.32914788f, 0.08635590f, 0.04447293f, -0.12171219f, -0.01877146f, -0.39445314f, -0.06653360f, 
    0.03399027f, 0.08673168f, 0.28541464f, 0.06223888f, -0.09194044f, -0.04773580f, -0.00376747f, -0.04844606f, 
    0.11925399f, -0.35342002f, 0.32458970f, 0.06554498f, -0.63196802f, -0.04227884f, 0.34909353f, 0.08315208f, 
    -0.28532019f, 0.10487165f, 0.25093973f, -0.11284277f, 0.38540122f, -0.07069066f, 0.12219156f, -0.01725160f, 
    -0.20888795f, 0.22397654f, 0.01382992f, 0.19795299f, 0.30974659f, 0.15541516f, -0.36315504f, -0.02731857f, 
    -0.07282870f, 0.12864226f, 0.51358849f, 0.20319042f, 0.11565146f, -0.23903814f, -0.14538144f, -0.02859428f, 
    -0.00118022f, 0.13533773f, 0.07703448f, 0.11030871f, 0.27707425f, -0.08430748f, 0.15032342f, -0.04260820f, 
    0.06626235f, -0.05924147f, -0.23886599f, -0.11477006f, 0.58021671f, 0.02105878f, -0.00674056f, 0.55623209f, 
    0.10592664f, 0.12781860f, -0.04516640f, -0.15187439f, -0.27564520f, 0.03647215f, -0.17273834f, 0.13338792f, 
    0.15160348f, -0.09814186f, -0.10381529f, -0.09717647f, -0.09640965f, -0.09076275f, 0.06308424f, -0.10199770f, 
    -0.02246993f, -0.05604343f, -0.55392015f, 0.21872312f, -0.07503334f, 0.14067908f, -0.16236085f, 0.15416989f, 
    -0.34203029f, 0.12833619f, 0.19400120f, -0.15490122f, -0.11966743f, 0.17240191f, -0.01048189f, -0.48868173f, 
    -0.25846791f, -0.13754687f, 0.16236699f, 0.11633309f, -0.05663661f, 0.05506346f, 0.32966879f, 0.39397863f, 
    0.12445229f, -0.08456869f, -0.24675719f, -0.10562802f, -0.15564190f, 0.26857600f, 0.15409976f, 0.15890078f, 
    -0.11511496f, -0.02653494f, -0.11986476f, -0.26135409f, -0.30574843f, -0.11698768f, 0.31174695f, 0.32827097f, 
    0.04687410f, -0.13679428f, -0.06659558f, 0.05721541f, -0.22197707f, 0.14323816f, 0.08237581f, 0.10410577f, 
    0.02295540f, -0.22375706f, -0.23174071f, 0.01833186f, 0.46232161f, -0.10019772f, 0.01424887f, 0.50737911f, 
    -0.13288034f, -0.13574225f, -0.10664853f, -0.01461406f, -0.13199277f, -0.12415883f, -0.03911675f, -0.14592583f, 
    0.11057550f, 0.03127480f, 0.04187689f, 0.07880286f, 0.01377413f, -0.19405591f, 0.02572697f, -0.08252794f, 
    0.14256907f, 0.16979878f, -0.09782882f, 0.12433967f, -0.17435946f, 0.14893478f, -0.16491516f, -0.10559697f, 
    -0.11331485f, 0.09077071f, -0.11219738f, -0.02825252f, -0.13498420f, -0.10473033f, 0.04323328f, -0.03994253f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12701890f, -0.13884145f, -0.07555090f, 0.46179888f, 0.14267260f, 0.03398656f, 0.22028823f, 0.09643886f, 
    0.25342384f, 0.14585364f, 0.36657557f, 0.01206872f, -0.04273493f, 0.02297332f, 0.25849521f, -0.05510568f, 
    0.19017628f, -0.07701539f, 0.23926362f, -0.13468580f, 0.15144292f, -0.13035639f, -0.18966290f, 0.19368052f, 
    0.43128449f, 0.12735683f, 0.09570257f, -0.18070088f, 0.47389871f, -0.22449017f, -0.04080599f, 0.19197318f, 
    0.09251860f, -0.14332430f, -0.02498564f, 0.35204741f, 0.20048416f, -0.24477373f, -0.01049506f, -0.23831132f, 
    -0.06017947f, 0.15214574f, -0.01094364f, 0.28477147f, -0.00901965f, -0.18923375f, -0.02299915f, 0.30597359f, 
    0.01502289f, 0.04362093f, -0.09783226f, 0.08947893f, 0.23796073f, -0.00908714f, 0.13595124f, 0.27219179f, 
    -0.09611820f, -0.01662322f, 0.04142488f, 0.22292365f, -0.33280507f, 0.06064577f, 0.24318223f, -0.04157258f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.19937749f, 0.11413650f, -0.09303734f, 0.03777516f, 0.00220172f, -0.40084696f, 0.20690051f, -0.50165522f, 
    0.24452837f, -0.62723327f, -0.08164213f, 0.08809815f, 0.38186291f, 0.03931843f, -0.05544381f, -0.48106322f, 
    0.14153390f, -0.09809399f, -0.32175541f, -0.28585669f, 0.11383679f, 0.02847992f, -0.07577477f, 0.16826008f, 
    -0.14057435f, -0.34331954f, 0.11024138f, -0.04156867f, -0.44492051f, 0.22567062f, 0.08008455f, 0.00901367f, 
    -0.19046220f, 0.11345916f, 0.10702300f, -0.05540344f, -0.28040993f, -0.03392993f, -0.01643112f, 0.27520090f, 
    -0.02601187f, 0.09927573f, 0.00810549f, -0.35693088f, -0.05078740f, 0.03153404f, -0.08633243f, -0.03018931f, 
    -0.17857040f, 0.22987624f, -0.03316071f, 0.10725068f, -0.48373351f, -0.60516638f, 0.14776288f, -0.31450835f, 
    -0.01071133f, -0.23024678f, 0.02560437f, 0.07037029f, 0.20579462f, -0.03281112f, 0.15117943f, -0.11991948f, 
    0.07644409f, 0.20794399f, 0.05291415f, 0.15716422f, 0.03624995f, -0.01795306f, 0.27686772f, -0.19498232f, 
    0.27546233f, 0.17475919f, 0.01554022f, 0.10385084f, -0.53047371f, 0.54450697f, -0.17266724f, -0.38058579f, 
    0.11030861f, -0.01252590f, 0.05240054f, -0.09771317f, 0.07414024f, 0.03663824f, -0.06379507f, 0.18960071f, 
    0.09478771f, -0.21705982f, -0.11830904f, -0.13490658f, 0.17580716f, -0.18191770f, 0.05544965f, 0.11178825f, 
    0.07170528f, -0.04166300f, -0.27861011f, -0.07011856f, 0.12431841f, -0.10299205f, -0.02716305f, -0.68596137f, 
    0.02235070f, 0.06063997f, -0.05566211f, -0.09302627f, 0.21932264f, -0.06526072f, -0.08364854f, 0.16168216f, 
    0.50354236f, -0.32188216f, -0.10379551f, -0.04726337f, -0.40583450f, -0.35848573f, 0.29393643f, -0.33051503f, 
    0.00239933f, -0.09026290f, -0.07651203f, -0.26375377f, 0.03000161f, -0.39802819f, -0.25880679f, 0.05466620f, 
    -0.05382020f, -0.50432873f, -0.07820921f, 0.12120376f, -0.22472809f, -0.02642147f, -0.62533480f, -0.13523996f, 
    -0.59106976f, -0.07170872f, 0.05602665f, 0.11778209f, -0.13747121f, -0.50816488f, 0.32370028f, 0.34927040f, 
    -0.15627718f, -0.05834722f, 0.09165502f, -0.36922017f, 0.23519580f, 0.03157522f, 0.01111500f, -0.28559390f, 
    -0.11051677f, 0.29614896f, 0.08107061f, 0.04592277f, 0.29040870f, -0.16206607f, -0.11199726f, -0.06162056f, 
    0.57500929f, -0.19598839f, 0.22065797f, -0.03372863f, -0.01184625f, -0.37458932f, 0.00084500f, -0.84667414f, 
    -0.13368590f, 0.09647982f, -0.03147475f, 0.07546971f, 0.38024887f, 0.07809684f, -0.01649023f, 0.00982687f, 
    -0.39889079f, -0.46855620f, -0.03861738f, -0.16613460f, -0.04703342f, 0.37671453f, -0.13319324f, 0.22195460f, 
    0.07924179f, 0.07854321f, -0.04445188f, -0.27944961f, 0.15668666f, -0.10962735f, -0.35292420f, -0.00219550f, 
    -0.28799513f, -0.42559794f, -0.06908678f, 0.12723500f, -0.22804074f, -0.51792687f, -0.13571617f, 0.35102147f, 
    -0.40112907f, 0.28712213f, 0.03954230f, -0.14793561f, 0.14354137f, -0.29654586f, -0.23018105f, -0.49549723f, 
    0.19312719f, -0.03434119f, -0.20530213f, -0.54640657f, 0.02617076f, -0.11196329f, -0.02386918f, 0.01868608f, 
    -0.71833986f, 0.40457889f, -0.10839679f, 0.06236246f, -0.43637797f, -0.10785411f, -0.09799863f, -0.20009442f, 
    0.14709517f, -0.14936407f, -0.04222354f, -0.58809763f, -0.42094800f, 0.13896821f, -0.07374491f, 0.02500831f, 
    -0.27343231f, -0.09348648f, -0.07180880f, -0.41670841f, 0.25703412f, -0.06783210f, -0.07512687f, -0.52805722f, 
    0.32251465f, 0.15570536f, -0.07860941f, 0.10902570f, 0.30125374f, 0.28045806f, -0.41884997f, 0.06633628f, 
    -0.09607242f, 0.41643226f, 0.16613203f, 0.25282255f, 0.17213437f, 0.17969452f, -0.16780573f, -0.15411951f, 
    0.24321668f, 0.00931330f, -0.00291755f, -1.12475753f, 0.03317962f, -0.03110054f, -0.41308081f, -0.27674422f, 
    -0.25679573f, -0.41955274f, 0.28935465f, -0.12271723f, 0.14004630f, 0.16724604f, -0.24817601f, 0.44888806f, 
    -0.03277192f, -0.04261230f, -0.08544294f, 0.10279108f, -0.20369832f, 0.08595822f, 0.09266803f, 0.02968237f, 
    -0.16524413f, 0.05814404f, -0.04378434f, -0.26882982f, 0.02746721f, 0.20343007f, -0.11603068f, -0.07249053f, 
    0.26827648f, 0.09958789f, -0.51671720f, -0.03104807f, 0.05524334f, 0.17869219f, -0.01739821f, 0.17195570f, 
    0.11519544f, -0.03568894f, -0.00270582f, 0.17673986f, 0.00891335f, -0.07811252f, -0.12430481f, -0.03817530f, 
    -0.88927138f, -0.05804013f, 0.05692545f, 0.04214757f, 0.13929184f, -0.18361764f, 0.08717982f, -0.16976081f, 
    -0.05637067f, 0.20399179f, 0.06046040f, -0.00229558f, -0.09004775f, -0.24609308f, -0.10301506f, 0.02466254f, 
    0.01026630f, -0.34663767f, 0.04338184f, -0.50870651f, 0.23152882f, -0.68431747f, 0.25729963f, 0.17552438f, 
    -0.30771971f, 0.01073388f, 0.09477665f, -0.35660863f, -0.18636361f, -0.41745171f, 0.09463620f, -0.14245927f, 
    -0.03688691f, -0.02192483f, 0.09842698f, -0.01228638f, 0.10029741f, 0.02960906f, 0.09042773f, -0.01765521f, 
    -0.25484502f, -0.78295171f, -0.08665885f, 0.02874509f, 0.11676016f, -0.22424063f, -0.06412064f, 0.08449220f, 
    -0.07846241f, 0.15517850f, -0.08615325f, -0.06171694f, 0.20261806f, 0.05670590f, 0.02157729f, -0.25745267f, 
    0.16798247f, 0.08637671f, -0.00854225f, 0.14938384f, -0.13832161f, -0.03130034f, -0.03895109f, 0.06471986f, 
    -0.24954078f, 0.16441554f, -0.08651797f, 0.00470232f, -0.20169121f, 0.37858364f, -0.02919863f, -0.00169824f, 
    0.09922361f, -0.39757961f, 0.32393458f, 0.18913162f, -0.00223615f, -0.14569797f, -0.12483481f, 0.01097759f, 
    0.02136457f, 0.30682570f, 0.03935232f, -0.11683558f, -0.19338933f, -0.11635411f, -0.49577862f, -0.25519085f, 
    -0.25386792f, -0.56318510f, -0.68325251f, 0.23923241f, -0.26494369f, 0.21902420f, 0.33812135f, 0.38742515f, 
    -0.75992614f, 0.07973327f, -0.23641647f, 0.12042458f, 0.34871727f, -0.01526083f, 0.06594861f, -0.62774414f, 
    0.24015908f, 0.42891294f, 0.05611270f, -0.07231621f, -0.32304299f, 0.08901022f, 0.01908256f, -0.55347294f, 
    -0.28807759f, -0.20425144f, 0.08247514f, 0.02068220f, 0.18455935f, -0.39189753f, -0.10879802f, -0.11098211f, 
    -0.27698171f, -0.08557195f, 0.10065436f, 0.17634974f, 0.05077551f, 0.03583315f, -0.09870199f, 0.05813608f, 
    -0.23008829f, -0.42779681f, -0.12493043f, 0.00859511f, -0.00437813f, -0.58386171f, 0.08510271f, 0.21165474f, 
    -0.13004187f, 0.20363905f, -0.63842952f, -1.11105466f, -0.28730789f, -0.21467187f, 0.32480156f, 0.04121930f, 
    -0.08874082f, -0.25543246f, 0.04079835f, -0.03006247f, -0.14160526f, -0.17479931f, -0.30906841f, 0.35970655f, 
    -0.08258000f, 0.27239412f, -0.64680719f, -0.25731176f, -0.01591227f, -0.31953436f, -0.52329820f, -0.31649747f, 
    -0.08043533f, -0.08258222f, 0.04005552f, -0.06168313f, -0.18208954f, -0.06355839f, -0.00202696f, -0.24487488f, 
    -0.22152133f, 0.17098837f, -0.07266065f, 0.12254956f, -0.26398727f, 0.25648573f, -0.04308347f, 0.14957078f, 
    -0.14528446f, -0.19788057f, 0.08761375f, 0.20889394f, -0.13589215f, 0.34702960f, -0.01282613f, 0.61607844f, 
    0.03497579f, 0.07723586f, -0.03545493f, -0.09947478f, -0.61846310f, -0.00134149f, -0.07273109f, 0.22162487f, 
    -0.31922486f, 0.12000863f, -0.04373902f, 0.04265089f, -0.00129674f, 0.30530003f, -0.20068777f, -0.09490762f, 
    0.07346203f, 0.17769478f, -0.49475986f, -0.53873098f, 0.02622087f, -0.01892649f, -0.14916305f, 0.07847250f, 
    -0.27019656f, 0.01874358f, 0.05602802f, 0.25037354f, 0.17371576f, -0.07335307f, 0.37555319f, 0.43830571f, 
    0.26120752f, 0.32222462f, -0.72960013f, 0.17033124f, -0.24635805f, -0.26354191f, 0.23809882f, -0.91762424f, 
    -0.21180654f, 0.06361223f, 0.26824969f, 0.17002857f, 0.30239823f, -0.02844089f, 0.09107997f, -0.55535078f, 
    -0.15104099f, -0.30208915f, 0.07213801f, 0.06904966f, -0.35635689f, -0.62238955f, -0.02325647f, 0.00563102f, 
    -0.71101570f, -0.16474313f, 0.05086057f, 0.08818829f, 0.11406001f, 0.06531426f, -0.10570925f, -0.41361007f, 
    0.02877588f, 0.04267132f, -0.06754010f, 0.12112050f, 0.07807401f, -0.03555422f, 0.03616253f, -0.34657115f, 
    0.40537837f, -0.26597530f, -0.26199132f, -0.11078784f, 0.06065658f, -0.09033173f, -0.06069792f, 0.01872693f, 
    -0.09976357f, -0.04937654f, -0.20388788f, -0.87393743f, -0.26758748f, 0.23900253f, -0.34733143f, -0.03445978f, 
    0.02683051f, -0.12151305f, -0.03952204f, -0.14815287f, 0.23927034f, -0.28780395f, -0.40800998f, -0.14341994f, 
    -0.15443943f, -0.05785628f, -0.12482029f, 0.11455386f, -0.04525037f, 0.05810376f, -0.22281246f, -0.14920098f, 
    0.34496874f, 0.07460614f, -0.43627807f, -0.08768691f, -0.21587302f, -0.06251113f, 0.09850773f, 0.39114660f, 
    0.21753891f, 0.24301341f, -0.07535035f, -0.06891609f, 0.21493497f, 0.03450306f, -0.06077771f, -0.54636037f, 
    -0.43119085f, -0.22483663f, 0.03994520f, 0.23640357f, 0.15739463f, -0.58646619f, -0.00105699f, -0.52116311f, 
    -0.34364131f, -0.11435080f, 0.00784431f, 0.07195286f, -0.33076265f, -0.09857652f, -0.07466039f, 0.11383630f, 
    -0.39604285f, 0.12289470f, -0.01089453f, 0.07737233f, 0.26607567f, -0.15680905f, 0.32419813f, 0.22902519f, 
    0.01001116f, 0.03638290f, 0.21078348f, 0.32404450f, -0.36491010f, -0.12961283f, 0.32631955f, -0.03666331f, 
    -0.43488976f, -0.18780461f, 0.06317037f, 0.00052954f, 0.17577310f, -0.03549164f, -0.18203373f, -0.25408253f, 
    0.26704708f, -0.03417976f, 0.21852699f, 0.13942605f, -0.07498261f, -0.00202426f, 0.20230767f, 0.14216128f, 
    -0.17378666f, 0.02245244f, 0.35214594f, -0.09055904f, 0.13891570f, 0.03562854f, -0.09781093f, 0.07603786f, 
    -0.28688359f, -0.24673171f, 0.00685732f, 0.05129972f, -0.10345246f, 0.08154584f, -0.00216836f, 0.36400014f, 
    0.02761811f, -0.69448358f, 0.20071077f, -0.52491695f, -0.20678261f, 0.25098523f, 0.07443829f, -0.32760513f, 
    0.26121384f, 0.08236230f, 0.05770865f, 0.05897065f, -0.10176342f, 0.01549797f, -0.10471252f, -0.71385926f, 
    -0.37958416f, -0.43330440f, -0.18505397f, -0.11862331f, 0.19448066f, -0.59544116f, 0.03559790f, -0.06213820f, 
    -0.06590760f, -0.36975139f, -0.49739942f, -0.34247035f, -0.74607944f, 0.11514962f, -0.08186494f, 0.05936969f, 
    -0.27178794f, 0.21603966f, 0.02183209f, 0.42753470f, -0.39458159f, -0.31285065f, -0.16730593f, -0.21143839f, 
    0.36100104f, 0.25652462f, -0.04649486f, -0.00780836f, -0.27182880f, 0.31858116f, 0.21211061f, 0.50303477f, 
    -0.61214286f, -0.07528677f, 0.11365402f, 0.27661866f, -0.85759795f, 0.00811709f, -0.01210768f, -0.56198394f, 
    -0.01113156f, -0.17263785f, 0.01118606f, -0.00974235f, -0.02965291f, 0.05166304f, 0.11593902f, 0.01322755f, 
    -0.31000495f, 0.07258148f, 0.07861096f, -0.10674821f, -0.07801658f, -0.09106987f, -0.05718166f, -0.28140545f, 
    -0.43349686f, -0.05859961f, -0.09645481f, 0.21959750f, -0.29980004f, 0.05469262f, 0.05729079f, -0.01750761f, 
    -0.00288760f, 0.24174978f, -0.01211607f, -0.17116386f, 0.00659169f, 0.03002896f, -0.33729187f, 0.01701610f, 
    0.09519976f, -0.10755897f, -0.38173154f, 0.08349023f, -0.45974392f, 0.37755615f, 0.31890583f, 0.06676780f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.22175956f, 0.10777739f, 0.12286799f, -0.20615391f, -0.02614832f, 0.06308837f, 0.06795432f, 0.00377021f, 
    0.18379326f, 0.24871016f, 0.11958260f, -0.11264969f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
