#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.14941201f, 0.10977913f, -0.39628485f, 0.13521548f, 0.19345045f, 0.00626907f, -0.35870349f, 0.36350605f, 
    0.19313470f, -0.10433061f, 0.16043937f, -0.25031483f, -0.15586928f, 0.16713487f, 0.08073129f, -0.08417450f, 
    0.11639527f, -0.28763348f, -0.23518801f, 0.47244105f, 0.05698755f, 0.02643353f, -0.06352343f, -0.02163659f, 
    0.25390509f, -0.41784456f, 0.34878573f, 0.23632583f, -0.05455658f, 0.17047235f, -0.41210988f, 0.01309155f, 
    -0.42224991f, 0.31799957f, -0.24258491f, -0.07586507f, 0.37368277f, -0.47237471f, 0.23644528f, -0.16382602f, 
    -0.04818982f, -0.19039930f, -0.12357998f, -0.17623258f, 0.18402085f, -0.33015680f, -0.13444620f, -0.08168403f, 
    -0.27595061f, -0.53688592f, 0.14053813f, 0.02293907f, -0.56375390f, -0.63274509f, -0.23989794f, -0.45547831f, 
    -0.29411682f, -0.63317466f, -0.55507267f, -0.03302178f, 0.44892359f, 0.56827104f, 0.46723366f, -0.14427045f, 
    -0.00241238f, -0.37780872f, 0.24339600f, -0.11434355f, 0.00985031f, 0.20088552f, 0.08117524f, -0.33970106f, 
    -0.14330342f, -0.14589715f, -0.14726293f, 0.02902655f, -0.03786984f, 0.48538631f, -0.03910873f, -0.39789692f, 
    -0.16621301f, -0.00613828f, 0.24462032f, 0.02744845f, -0.07271714f, 0.23124981f, -0.00750966f, 0.12149932f, 
    -0.29847494f, -0.18127669f, 0.24313825f, -0.29269719f, -0.14756955f, -0.36128712f, 0.12378923f, 0.30399060f, 
    0.37468088f, 0.18530793f, 0.17810076f, -0.03198331f, 0.80055213f, 1.06350040f, 0.27220386f, -0.03584623f, 
    -0.42945582f, -0.57906812f, 0.04702147f, -0.04220191f, -0.40766472f, -0.02613023f, 0.34958708f, 0.01383618f, 
    -0.16186412f, 0.08325949f, -0.24881759f, 0.29859978f, 0.02542647f, 0.09680115f, -0.01920879f, -0.22722867f, 
    -0.08021396f, 0.10121252f, 0.08509945f, -0.19694474f, 0.11131131f, 0.13917339f, -0.67802441f, -0.08138571f, 
    0.16197947f, 0.28328496f, -0.09918593f, 0.22293086f, -0.25518465f, -0.06777962f, -0.00780401f, 0.09186311f, 
    0.16813387f, -0.20931961f, -0.16359925f, 0.16360804f, -0.55494708f, 0.58290040f, -0.23815900f, -0.15438159f, 
    -0.17980145f, 0.34230062f, 0.13021779f, 0.18568712f, -0.07905358f, -0.02634434f, -0.31292132f, -0.12779185f, 
    -0.70597231f, -0.82232291f, -0.34974253f, -0.00967159f, 0.16261832f, 0.68318236f, 0.33813268f, -0.26466125f, 
    0.10233574f, -0.15006128f, -0.23062086f, -0.17065006f, 0.05147254f, -0.01388732f, 0.02897987f, 0.11836329f, 
    -0.15165746f, -0.13944732f, 0.04766339f, 0.03807680f, -0.11237698f, 0.09526660f, 0.02962478f, 0.58370852f, 
    0.41779989f, 0.11398869f, -0.22703038f, 0.08914056f, 0.15975362f, 0.36244428f, 0.11268955f, -0.53089565f, 
    -0.45872808f, -0.36859971f, 0.16489723f, 0.25182793f, -0.23421790f, -0.11829115f, -0.05980218f, 0.11988715f, 
    0.00981730f, -0.08240776f, 0.19051600f, 0.03439213f, 0.06360370f, -0.15301131f, -0.35542440f, -0.33017656f, 
    0.17705481f, -0.10925652f, -0.44424343f, -0.31063679f, -0.56091642f, 0.25871196f, 0.24727215f, -0.13631122f, 
    0.14346747f, 0.16217929f, -0.06641214f, -0.33705023f, -0.32005432f, 0.30731267f, -0.18547384f, -0.15537097f, 
    -0.05205710f, -0.02110933f, -0.24302311f, -0.59658813f, -0.00706049f, -0.39485669f, -0.09848665f, -0.21076281f, 
    -0.40717834f, -0.52094674f, -0.57483935f, -0.32341996f, 0.00777182f, -0.58545488f, 0.76845312f, -0.22888611f, 
    0.44982481f, 0.05925620f, 0.67118174f, -0.11851901f, 0.04487689f, 0.19667068f, 0.12475722f, 0.00428455f, 
    -0.18415998f, -0.00635957f, -0.16378167f, -0.01053254f, 0.28137255f, -0.10028266f, 0.19211534f, 0.22099099f, 
    -0.17968242f, -0.28034163f, 0.71821505f, 0.46448576f, 0.05312825f, -0.10818532f, -0.36742270f, 0.27946407f, 
    0.04212889f, 0.01486252f, 0.27170810f, 0.17875800f, 0.32736263f, -0.26126289f, -0.32831571f, 0.12695381f, 
    0.20154533f, 0.07719664f, -0.24071659f, -0.28912130f, -0.15021913f, 0.10734700f, 0.31260538f, 0.23881115f, 
    -0.15566081f, -0.07540881f, 0.07466714f, 0.51783514f, -0.37172562f, 0.23734689f, 0.23464936f, 0.15653066f, 
    0.33986863f, -0.06031736f, 0.05268498f, -0.20473495f, 0.23016788f, 0.26175821f, -0.05729710f, -0.12165717f, 
    -0.22053613f, -0.27847633f, -0.21493998f, 0.13419043f, 0.18915376f, -0.12242440f, -0.15708804f, 0.24573931f, 
    -0.29595751f, -0.24917269f, -0.21667589f, -0.32425284f, -0.73530543f, -0.53267926f, 0.13485658f, -0.17739765f, 
    -0.02634751f, 0.73635179f, 0.45184320f, -0.51616347f, -0.08035568f, 0.27787998f, 0.19330473f, -0.09050812f, 
    -0.13568638f, -0.05315493f, -0.45424116f, -0.24111623f, 0.22540648f, -0.22455958f, -0.03200363f, -0.24119988f, 
    -0.04549159f, 0.05664163f, 0.02157145f, 0.18160394f, 0.14892492f, -1.09218228f, -0.45587775f, -0.25825498f, 
    0.39125594f, 0.77250803f, -0.08242775f, -0.10324461f, -0.01814426f, 0.18842886f, -0.37094709f, 0.07820019f, 
    0.04893689f, -0.30170751f, 0.55192667f, -0.24231462f, 0.37374026f, -0.29260710f, -0.23874071f, 0.29769570f, 
    0.15043326f, 0.04250165f, -0.11304278f, 0.03192016f, -0.22220829f, -0.20715462f, 0.06737821f, 0.34172997f, 
    0.20124143f, 0.46560982f, 0.13718040f, 0.28967509f, 0.08006793f, 0.02781191f, 0.16934648f, 0.27135849f, 
    -0.22440223f, 0.23820764f, -0.13696043f, -0.32857022f, -0.15813969f, 0.13417554f, 0.12204188f, -0.13509244f, 
    -0.11667049f, -0.06111094f, -0.26410639f, -0.20815715f, -0.24580903f, -0.26610076f, -0.17755681f, -0.82500172f, 
    -0.51005751f, -0.04298090f, -0.55128235f, -0.41157392f, 0.14783721f, -0.01867732f, 0.23169433f, 0.41671151f, 
    0.84901428f, 0.24313970f, 0.17556012f, 0.34342524f, 0.12473825f, 0.22394434f, 0.04943328f, -0.18431200f, 
    0.00848966f, -0.19647412f, -0.25369871f, 0.01460973f, 0.00561929f, 0.07012276f, -0.21853229f, 0.14164519f, 
    -0.00002461f, -0.47904512f, -0.48484400f, -0.11316785f, -0.11776339f, 0.13520432f, 0.06656960f, 0.32645011f, 
    -0.26460049f, 0.00927252f, -0.06231584f, 0.00194073f, 0.01425522f, -0.18843222f, 0.26525649f, -0.34553236f, 
    -0.09033272f, -0.00671074f, -0.29478300f, -0.40463546f, -0.26926050f, -0.04995878f, -0.33581692f, 0.23306720f, 
    0.71648169f, 0.27797678f, 0.33418587f, -0.22108951f, -0.08666044f, -0.28613952f, 0.29507187f, -0.54753399f, 
    -0.21364307f, 0.38561201f, 0.29738209f, 0.32924485f, -0.15670447f, -0.39328840f, 0.45592690f, -0.26719102f, 
    -0.29323822f, -0.02124226f, 0.25421152f, 0.01444914f, -0.04695426f, 0.17225899f, -0.20009714f, 0.18844232f, 
    0.09787644f, -0.02881596f, -0.40912464f, 0.35643932f, 0.18936126f, -0.17298155f, 0.44738623f, 0.12427361f, 
    -0.11779117f, -0.15243757f, -0.10049739f, 0.06656336f, -0.36421511f, 0.32240778f, 0.23391300f, -0.18389890f, 
    0.24401920f, 0.05212826f, -0.42536139f, -0.02379903f, 0.02459776f, 0.08489314f, -0.42899507f, 0.07927900f, 
    0.00052720f, 0.38510519f, -0.06599516f, -0.36528990f, -0.40174049f, 0.21326973f, 0.32665390f, 0.00875328f, 
    -0.36138102f, -0.69686455f, -0.60355467f, -0.44490743f, -0.56848282f, 0.47791186f, 0.40225807f, -0.12731926f, 
    -0.00638995f, 0.18191040f, -0.20909268f, -0.11831471f, 0.35237107f, -0.21820198f, 0.06719567f, -0.25097302f, 
    0.05012344f, 0.15980387f, -0.03224077f, 0.15823828f, -0.92719460f, 0.06320038f, -0.24700518f, -1.04442775f, 
    -0.71725386f, 0.27384806f, 0.45807821f, 0.01225355f, -0.37890258f, -0.00260515f, -0.26287407f, -0.26521561f, 
    -0.10821403f, -0.39206621f, -0.06218608f, 0.38240281f, 0.15216742f, -0.24085408f, -0.14453597f, 0.07768872f, 
    -0.10512591f, -0.04532828f, -0.06520319f, -0.12498381f, -0.22245358f, 0.69454747f, -0.07011421f, 0.04282094f, 
    0.01087821f, 0.57633996f, -0.06831408f, -0.25273758f, -0.22584289f, -0.53066480f, -0.73792648f, -0.22560006f, 
    -0.10364858f, -0.03286805f, -0.36642247f, -0.23866421f, 0.11759018f, -0.41325018f, -0.11708352f, 0.02060805f, 
    -0.25875115f, -0.01908702f, -0.02533048f, 0.21322738f, 0.21973181f, 0.09161954f, -0.75130582f, 0.38701370f, 
    -0.06792013f, 0.28959197f, -0.23695679f, -0.44831613f, -0.10765012f, 0.22951281f, 0.40632471f, 0.40883851f, 
    0.24514395f, 0.32713965f, -0.11459761f, -0.55983615f, 0.35060036f, -0.05272517f, -0.29792413f, -0.36505306f, 
    -0.03979067f, 0.08004735f, -0.16875274f, 0.22758111f, 0.16781937f, 0.19788185f, -0.20135151f, 0.48869836f, 
    0.60576785f, 0.06893378f, -0.71219283f, -0.02772978f, 0.29002169f, -0.32560688f, 0.24840394f, -0.41198018f, 
    -0.02415635f, 0.06796140f, -0.35599875f, 0.58287662f, -0.19430113f, -0.14381291f, 0.01907449f, 0.34800434f, 
    0.33704525f, -0.18990567f, -0.29921433f, -0.03417259f, -0.33995843f, -0.27732465f, 0.40250975f, -0.06830185f, 
    -0.00847926f, 0.39367107f, -0.40309834f, -0.39638391f, 0.55359763f, -0.39718023f, 0.09336197f, 0.23520514f, 
    0.20640025f, 0.12605171f, -0.02266769f, -0.01015038f, -0.17166102f, -0.27369568f, 0.28401509f, 0.31473836f, 
    -0.17046055f, 0.10657582f, -0.29193500f, -0.15239277f, 0.31449002f, -0.02776143f, 0.00808400f, 0.03703020f, 
    0.12013871f, -1.03078997f, -0.12624112f, 0.31750828f, 0.18891528f, -0.38692680f, -0.45087060f, -0.32171038f, 
    -0.26231170f, 0.46925583f, 0.29386374f, 0.17498356f, 0.10399769f, -0.01092499f, -0.17620984f, 0.15498988f, 
    -0.09298601f, 0.30774811f, -0.26472545f, 0.14960864f, -0.25769916f, 0.22829816f, 0.05239583f, 0.11888025f, 
    0.03557810f, 0.33080363f, 0.86030149f, -0.18196036f, 0.14952447f, -0.16705586f, -0.49108565f, 0.63574481f, 
    -0.33272594f, -0.39901063f, 0.03309843f, 0.00081384f, 0.05723108f, -0.16956137f, -0.00331301f, 0.03079405f, 
    0.22714838f, 0.02289957f, -0.25787348f, -0.19117978f, -0.03395681f, 0.11802226f, -0.31019321f, 0.10842130f, 
    0.10998478f, -0.14312346f, -0.17783998f, 0.90816885f, -0.19206327f, -0.35174736f, -0.07305991f, 0.12766035f, 
    -0.09319505f, 0.28041840f, -0.03891519f, -0.31004801f, -0.07763212f, 0.00482984f, 0.17970870f, -0.00640409f, 
    0.14544971f, 0.12815721f, -0.13583116f, -0.02068508f, -0.10884763f, 0.15743020f, -0.31643003f, 0.00097350f, 
    0.08968817f, 0.43572053f, 0.16259904f, -0.14223699f, -0.35431069f, 0.23138076f, 0.19308652f, -0.46295089f, 
    -0.33753291f, 0.11961988f, 0.22214864f, -0.19747388f, -0.34928814f, -0.28909069f, 0.40384483f, -0.34235582f, 
    0.17971405f, -0.21291171f, -0.15134536f, 0.10329571f, -0.29932222f, -0.13790342f, -0.13393126f, -0.49338093f, 
    0.04126937f, 0.42064273f, 0.15250376f, 0.38934758f, -0.01764136f, 0.21888742f, 0.02678047f, 0.09782044f, 
    0.52864188f, -0.14885364f, 0.25291577f, -0.77956659f, 0.06502660f, 0.48757976f, 0.08599891f, 0.26168507f, 
    -0.46707106f, -0.23679961f, 0.01579125f, -0.11255921f, 0.06225359f, 0.27283171f, 0.10283580f, -0.04993057f, 
    -0.24216826f, -0.34652996f, 0.21289526f, -0.06358018f, 0.09758088f, 0.10363413f, -0.12628826f, -0.79558104f, 
    -0.68694711f, 0.40037760f, 0.36087161f, 0.14115928f, 0.16891071f, -0.31716681f, -0.70406318f, -0.39971706f, 
    0.07461756f, -0.25865987f, -0.12591520f, -0.37735316f, -0.31165707f, 0.13514385f, 0.23324405f, 0.45166647f, 
    -0.28179279f, 0.15437725f, -0.03711277f, 0.16927646f, 0.34890774f, -0.37442175f, -0.39484718f, -0.54408216f, 
    0.76338279f, 0.60415065f, -0.69680572f, -0.44076940f, -0.24515103f, 0.20510089f, 0.08429596f, 0.19112755f, 
    0.22449262f, -0.08366255f, -0.46776688f, -0.12950742f, -0.01597844f, 0.24623661f, 0.17046149f, 0.14767228f, 
    0.16825730f, 0.23619792f, 0.21247277f, -0.12176513f, 0.11786433f, -0.29496226f, -0.11720427f, -0.49044237f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28876892f, 0.00602060f, 0.17620046f, -0.00203024f, 0.34363574f, 0.30844417f, -0.13747422f, 0.10651790f, 
    0.21423721f, 0.11280993f, -0.04530405f, 0.04845986f, 0.08406111f, 0.01492417f, -0.18869974f, 0.09810827f, 
    0.16528301f, 0.06668970f, 0.17412664f, 0.04376904f, -0.14618047f, -0.06844532f, 0.17994852f, 0.07866642f, 
    0.13300180f, -0.10318740f, 0.11925095f, 0.14132577f, -0.00578647f, 0.14977522f, -0.12776424f, 0.20644014f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.17159542f, 0.05113216f, 0.01534311f, 0.19019872f, 0.20826636f, 0.14266805f, 0.02814574f, -0.06295323f, 
    0.01854529f, 0.03702227f, 0.10113367f, 0.08939847f, -0.15419845f, 0.07137857f, 0.31093645f, -0.00218670f, 
    0.04334253f, 0.01715082f, 0.04293332f, 0.24357165f, -0.08497176f, 0.01173581f, -0.07433999f, -0.27021018f, 
    0.23110864f, 0.10009670f, -0.01870535f, -0.12828903f, 0.02541477f, 0.03824301f, 0.05316804f, 0.20025185f, 
    0.02760364f, -0.07671402f, -0.06587858f, -0.04637235f, -0.06654121f, -0.14501694f, 0.01868860f, 0.01240021f, 
    0.08477612f, 0.12897708f, -0.03809157f, -0.11180447f, -0.04107853f, -0.01438883f, 0.07666569f, 0.06027365f, 
    0.39112142f, 0.04063682f, -0.06803555f, 0.06736112f, 0.14142361f, 0.00284781f, 0.06088056f, -0.07401568f, 
    -0.07766483f, 0.08092913f, -0.03667242f, 0.08064373f, 0.02980517f, 0.04948608f, -0.05776642f, -0.01668297f, 
    0.07874987f, 0.20471406f, 0.17958124f, 0.11966605f, 0.03271937f, 0.11331351f, 0.14089781f, -0.03979540f, 
    0.08011436f, -0.03462568f, -0.00466336f, -0.23250128f, -0.02239185f, 0.15938787f, -0.05388945f, -0.01540356f, 
    -0.03178602f, -0.09587155f, 0.09200785f, -0.03808117f, 0.15672307f, -0.21531647f, -0.11797898f, 0.29466268f, 
    -0.08120633f, 0.04201925f, -0.04187382f, 0.06480379f, -0.02269828f, -0.07891524f, -0.00378065f, 0.00192360f, 
    0.18960650f, 0.05854058f, -0.09034506f, -0.10441722f, 0.10211416f, 0.19234024f, -0.01801611f, 0.17760035f, 
    -0.06543539f, -0.02804915f, -0.00790861f, -0.20045213f, -0.14125015f, -0.03545454f, -0.25668842f, -0.19421229f, 
    -0.02727785f, 0.03297802f, -0.12866718f, -0.05538516f, 0.03185971f, 0.20591542f, 0.05067960f, -0.04840916f, 
    0.23253672f, 0.07650948f, -0.04948304f, 0.20120947f, -0.04571511f, -0.05894553f, -0.03542657f, -0.09567194f, 
    -0.03779585f, 0.02657530f, 0.07843796f, -0.04412776f, 0.19470772f, 0.05445199f, 0.04557046f, 0.23321143f, 
    -0.01412732f, -0.09172463f, 0.02174076f, 0.01662893f, -0.00241947f, -0.06381684f, 0.16186275f, 0.05424730f, 
    0.05277478f, -0.02960955f, -0.20391543f, -0.14324649f, -0.11155757f, 0.01186223f, 0.16218522f, 0.07440799f, 
    0.10049829f, 0.01865538f, 0.03660158f, 0.02221564f, 0.06132456f, -0.03249263f, 0.13703665f, -0.01126140f, 
    0.18042170f, 0.14613777f, 0.27448991f, 0.02621042f, 0.16520873f, -0.03890613f, 0.16188771f, -0.09661682f, 
    0.00768313f, 0.06744663f, 0.12961003f, 0.22815758f, -0.03030875f, -0.01651408f, -0.07639343f, -0.06225003f, 
    -0.10456310f, -0.00153061f, -0.12615789f, -0.04578189f, -0.75990802f, -0.23027362f, -0.12085871f, -0.36454311f, 
    -0.06085661f, -0.04803286f, -0.00195524f, -0.02062851f, -0.00401277f, 0.20216846f, -0.04112229f, -0.12013972f, 
    0.02486836f, -0.09700877f, -0.07299564f, -0.09828132f, 0.09434117f, 0.17137343f, 0.09006439f, -0.03861194f, 
    0.27072230f, -0.15157607f, 0.03718505f, 0.14997317f, 0.19743149f, 0.01864300f, -0.00404363f, 0.02736206f, 
    0.02766301f, -0.05373659f, -0.04581778f, 0.04507672f, 0.10965928f, 0.03741641f, 0.10691142f, -0.06359486f, 
    0.08082574f, 0.04319982f, 0.01160130f, 0.37705764f, -0.07236379f, 0.02439638f, 0.06679483f, 0.01280419f, 
    -0.01385793f, 0.07601577f, -0.01943203f, 0.01959830f, 0.19548374f, 0.24720305f, -0.02744376f, -0.22322975f, 
    -0.05125269f, -0.04594569f, -0.01530333f, -0.11408488f, -0.02174963f, 0.00398895f, -0.04161589f, 0.04729097f, 
    0.05421487f, 0.28553876f, -0.05813260f, -0.26188791f, 0.08539559f, 0.19067396f, -0.03517638f, -0.00874369f, 
    -0.01371365f, 0.05460903f, 0.03466599f, -0.10659644f, 0.42021495f, -0.13860385f, -0.40839583f, -0.10366304f, 
    -0.12842789f, 0.06055241f, -0.02192477f, -0.11731122f, 0.00529128f, 0.05753008f, 0.03102230f, 0.13412638f, 
    -0.39314094f, 0.08796072f, 0.29490265f, 0.24399130f, -0.18697792f, -0.01195056f, -0.00194894f, 0.09858490f, 
    0.18483874f, -0.00447699f, 0.09896389f, 0.08433027f, 0.08063734f, -0.15004767f, 0.04138631f, 0.00238811f, 
    0.19822234f, 0.02149007f, -0.14706403f, 0.08992927f, 0.12910479f, 0.01417665f, -0.08044710f, 0.06538413f, 
    -0.15598361f, 0.12581098f, 0.08327946f, 0.05493307f, -0.01192039f, 0.02025561f, -0.03659669f, -0.00949493f, 
    0.10419343f, -0.11908762f, 0.04140388f, -0.03917212f, -0.37737745f, 0.06977749f, 0.12820204f, -0.25317067f, 
    0.13011506f, 0.13254791f, 0.02242148f, 0.15771832f, -0.00172778f, -0.09407339f, 0.02859145f, -0.11227977f, 
    0.51744038f, 0.00564296f, -0.21305345f, 0.18512215f, -0.05397350f, -0.00729078f, 0.02925933f, 0.08231458f, 
    0.04207099f, 0.03829759f, 0.20686534f, -0.05010391f, 0.22120738f, 0.00381352f, -0.09791844f, -0.01279449f, 
    0.03404034f, 0.06683701f, -0.05690759f, -0.01585302f, -0.03182345f, 0.07820955f, 0.03923134f, -0.07687946f, 
    -0.03723240f, 0.01100490f, -0.06351392f, -0.16624726f, 0.04518858f, 0.11554565f, 0.18580823f, 0.08161430f, 
    -0.05681579f, 0.04196184f, 0.05641896f, -0.03620199f, 0.10796893f, 0.15212947f, -0.02737237f, 0.26945245f, 
    0.01455778f, -0.05933268f, -0.08093085f, -0.02740679f, -0.02724182f, -0.02530374f, -0.02394713f, 0.08505225f, 
    0.37076694f, 0.09832201f, 0.07315442f, -0.02815906f, 0.18476464f, -0.01024370f, 0.19036101f, -0.02973859f, 
    -0.04708672f, 0.02314827f, 0.08992918f, -0.02133762f, -0.55815548f, -0.09025511f, -0.06969671f, -0.08581742f, 
    -0.08387507f, 0.09784309f, -0.01264460f, 0.16025253f, 0.04794149f, 0.02241760f, -0.02190287f, -0.22524874f, 
    -0.00954825f, 0.02731822f, -0.04222446f, 0.01771248f, 0.03945757f, -0.02421457f, -0.04789327f, -0.04286069f, 
    0.03907808f, -0.04990941f, -0.04275768f, 0.00290604f, -0.01374693f, -0.00058223f, -0.04774414f, -0.01212472f, 
    0.03790495f, 0.01318728f, -0.03739304f, -0.03912824f, 0.04891725f, 0.01764319f, -0.05322849f, -0.02113763f, 
    0.03402414f, -0.05378118f, 0.03853783f, -0.00189500f, -0.04002193f, -0.05524094f, 0.00191637f, -0.02606894f, 
    0.00733665f, -0.03667982f, -0.01656016f, 0.00296265f, -0.03158713f, -0.00044542f, -0.03091947f, -0.01418076f, 
    0.04655070f, 0.02938794f, -0.04648005f, -0.03699312f, -0.01215570f, -0.05122288f, 0.00605645f, -0.00441853f, 
    -0.03435419f, -0.02034440f, 0.04461189f, -0.01661190f, 0.01819717f, 0.03651118f, -0.02018684f, 0.01704730f, 
    -0.00664696f, -0.02190690f, -0.03975048f, 0.03452367f, -0.01442460f, 0.03102020f, -0.02590423f, -0.03530411f, 
    -0.04435601f, -0.03749008f, -0.04973421f, -0.00675079f, 0.03815374f, -0.02302819f, -0.04562706f, -0.01557205f, 
    0.00839626f, -0.02020201f, -0.04161111f, -0.02445146f, 0.01361972f, -0.02089330f, 0.03149991f, -0.03715361f, 
    -0.01774563f, -0.02446844f, 0.01687025f, 0.03864450f, -0.01462295f, 0.03682083f, -0.03820197f, -0.02596821f, 
    -0.01055005f, -0.01311179f, -0.01136722f, -0.00149517f, -0.01317640f, 0.00489045f, -0.04523332f, 0.00161723f, 
    0.02709180f, -0.00893316f, -0.03457774f, -0.00383911f, -0.02884590f, 0.00697785f, -0.02272701f, -0.00422291f, 
    0.00724105f, -0.03455358f, -0.00230953f, -0.01084124f, -0.02850917f, -0.04602459f, 0.01028042f, -0.02694519f, 
    0.03732213f, 0.03247077f, -0.02795638f, -0.00759870f, -0.02807726f, 0.04585055f, 0.04164114f, -0.00685107f, 
    -0.03659392f, 0.02055973f, -0.04118893f, -0.04930073f, 0.00171968f, -0.01772518f, 0.00121587f, -0.02286889f, 
    -0.03733752f, -0.00525671f, 0.01015479f, 0.00951006f, -0.04256216f, 0.01247600f, 0.01834287f, -0.01804193f, 
    0.01576832f, -0.04460784f, 0.01759064f, -0.05824778f, -0.00084184f, 0.03588677f, 0.00035245f, 0.01632716f, 
    0.02393236f, 0.00488554f, 0.04333412f, 0.00765319f, 0.01317045f, -0.04245585f, -0.03873838f, -0.02980464f, 
    -0.04398090f, 0.04900697f, 0.02166427f, 0.04315466f, -0.01880125f, -0.00606682f, -0.04978772f, -0.04930075f, 
    -0.00967308f, 0.03205707f, 0.03511292f, 0.01676614f, -0.04441825f, 0.03371507f, -0.02225221f, -0.02474194f, 
    -0.00763320f, -0.02284840f, 0.00281409f, 0.01933687f, 0.03450213f, -0.04944740f, 0.00997285f, -0.00976243f, 
    -0.01893686f, -0.05172908f, 0.01004696f, -0.04232170f, 0.03033474f, -0.01683125f, -0.03696971f, -0.02190022f, 
    -0.04916484f, 0.04320948f, -0.03465484f, 0.00918577f, 0.04424891f, 0.02856225f, 0.04412102f, -0.03986860f, 
    0.03259641f, 0.02642014f, -0.04587358f, 0.03914781f, 0.03194350f, 0.00631623f, -0.03202553f, -0.03667093f, 
    0.02108692f, 0.04032232f, -0.04080186f, 0.01655956f, -0.02214993f, -0.00510247f, -0.04269261f, 0.02302543f, 
    -0.03279469f, -0.01697994f, -0.02365102f, -0.00669441f, 0.02877926f, -0.03699531f, -0.01815945f, -0.00976138f, 
    -0.02620053f, -0.02370075f, 0.04180011f, -0.02781052f, -0.04158165f, -0.05573145f, -0.03966024f, 0.01276518f, 
    0.00960457f, 0.00667669f, -0.03620837f, 0.00888017f, 0.00881018f, 0.02787640f, -0.00663461f, -0.01497652f, 
    -0.01169736f, -0.00565168f, -0.00968830f, -0.01707290f, -0.03104721f, 0.02856087f, 0.02662782f, -0.02272227f, 
    0.01681145f, -0.01090806f, -0.03000235f, 0.03516871f, -0.00019471f, 0.00483191f, -0.04769663f, -0.01695756f, 
    0.02965817f, 0.01264075f, -0.03599317f, 0.02491890f, 0.00076414f, 0.03803650f, -0.03173053f, 0.00947003f, 
    0.04799278f, 0.04125213f, 0.03411491f, -0.04782310f, 0.02276694f, 0.00900969f, 0.01396436f, -0.05578613f, 
    0.02037536f, -0.02833276f, -0.04614064f, -0.02283314f, -0.03098534f, 0.00798643f, 0.01459165f, 0.02531368f, 
    -0.02640372f, -0.05062151f, -0.00564233f, 0.02827492f, -0.05608133f, -0.02361910f, 0.01976711f, 0.01588551f, 
    0.02153550f, -0.02631722f, 0.00311756f, 0.01504378f, 0.03627035f, 0.01484127f, 0.01607414f, -0.04082628f, 
    -0.04212963f, -0.03337516f, 0.03429845f, -0.00275244f, 0.04241196f, -0.02965051f, -0.02954213f, 0.00771092f, 
    -0.03214912f, 0.01460865f, -0.02382609f, -0.05349216f, -0.02613792f, 0.02553813f, 0.03282337f, -0.02528646f, 
    0.00476063f, 0.01986618f, -0.05185390f, 0.04346327f, -0.00347942f, 0.04365404f, -0.01978886f, -0.02449658f, 
    -0.04799904f, -0.01005863f, -0.01733864f, 0.04166565f, -0.04475266f, -0.00076796f, -0.03360751f, 0.01345335f, 
    -0.02921374f, -0.04215403f, 0.00543536f, -0.01223175f, -0.03393339f, 0.03763290f, 0.03813848f, 0.02325495f, 
    0.01424730f, 0.03651622f, -0.00658285f, 0.01970709f, -0.00313877f, -0.02866414f, -0.02762712f, -0.05532729f, 
    0.00669581f, -0.02182253f, -0.02672003f, -0.02234299f, 0.01993682f, -0.00310761f, 0.00362699f, 0.02507178f, 
    0.00725959f, 0.00506554f, -0.05144372f, -0.01178995f, 0.01190181f, 0.00072497f, -0.00717585f, -0.04527136f, 
    -0.00833122f, 0.03075178f, 0.03674565f, -0.01623290f, -0.03417509f, 0.00955283f, 0.00309273f, -0.00718795f, 
    -0.02882431f, -0.02555114f, 0.02733744f, 0.00681313f, 0.04233746f, 0.03861873f, 0.01871774f, -0.03605413f, 
    -0.05728851f, 0.03084932f, 0.00781335f, -0.02695707f, -0.00259031f, -0.03910555f, 0.04330812f, -0.01155722f, 
    0.00832750f, -0.02323093f, -0.05126798f, -0.00967014f, 0.03320117f, 0.00768926f, -0.02078078f, 0.02825044f, 
    0.03388597f, 0.00920194f, -0.00245819f, -0.02484803f, -0.03744937f, -0.03497449f, -0.00622647f, -0.05212707f, 
    -0.06255154f, -0.03684708f, -0.07159463f, 0.02629572f, -0.05168325f, 0.03598594f, -0.02981249f, 0.01654876f, 
    -0.05741365f, -0.06547722f, -0.00358778f, -0.07052457f, -0.04935917f, 0.02915676f, 0.01549654f, -0.00362927f, 
    -0.04501712f, 0.03228215f, -0.05436013f, -0.02700279f, 0.02303112f, -0.02104623f, -0.00777104f, 0.00098676f, 
    -0.01252878f, -0.02308471f, -0.01568656f, -0.03022913f, -0.05269090f, -0.06019592f, -0.04719160f, -0.05254002f, 
    -0.04658323f, -0.01154275f, -0.01164432f, -0.02811566f, 0.00861024f, -0.06646312f, 0.02065264f, 0.04188441f, 
    0.03574873f, -0.03610725f, 0.02118874f, -0.03012871f, 0.03801640f, 0.01674215f, 0.04911691f, -0.01469439f, 
    -0.03527036f, -0.05020488f, -0.01945648f, 0.01400504f, 0.02924407f, -0.00858337f, -0.02382002f, 0.03291553f, 
    -0.01966746f, 0.01736723f, -0.06408827f, 0.02022747f, -0.03926008f, -0.02779573f, 0.00596339f, 0.01722802f, 
    -0.00520892f, -0.04818516f, 0.01015489f, 0.05299940f, -0.00801979f, 0.01736460f, -0.03025822f, -0.02693190f, 
    -0.03820938f, 0.00593070f, 0.01004525f, 0.03141972f, 0.01814945f, -0.04047062f, 0.04391338f, -0.01491615f, 
    -0.00654188f, -0.04060008f, 0.01276263f, -0.02820907f, -0.05674154f, -0.02423735f, -0.06506831f, 0.02951620f, 
    -0.05622334f, -0.00893573f, -0.03479582f, -0.03185496f, -0.00553280f, -0.02882566f, 0.02653077f, 0.02814597f, 
    -0.02484753f, -0.02327609f, -0.04907467f, -0.02247665f, 0.01747781f, -0.03273001f, 0.01243670f, 0.00048124f, 
    -0.06779563f, 0.00552617f, -0.03243195f, 0.01491303f, 0.00208510f, -0.01623744f, -0.05440197f, 0.02728197f, 
    -0.03232927f, 0.00260441f, 0.03643325f, -0.00826617f, -0.00678345f, 0.03070927f, 0.02103662f, -0.00984959f, 
    0.01800646f, -0.04345660f, -0.03521676f, -0.05899139f, -0.03545536f, 0.00544171f, -0.02522099f, 0.03406601f, 
    0.00107408f, -0.03376560f, -0.03946530f, -0.02323002f, 0.02059463f, -0.04908974f, -0.05513550f, 0.04450296f, 
    -0.01015028f, -0.03361499f, -0.04285774f, 0.02243957f, -0.05165908f, 0.01198150f, -0.00946610f, -0.00277485f, 
    0.01280784f, -0.00408451f, -0.02164775f, 0.01209106f, -0.05028141f, 0.01528119f, -0.05025377f, 0.03089208f, 
    -0.05892286f, -0.01562390f, -0.03969523f, -0.00444991f, 0.02742102f, -0.03158170f, -0.04132324f, -0.04232302f, 
    -0.01938219f, 0.03877348f, 0.03171830f, 0.02302978f, 0.01309522f, -0.01896631f, -0.00777203f, 0.01317030f, 
    0.00776908f, -0.00641938f, 0.03855104f, -0.00890820f, 0.03656492f, 0.00665740f, -0.01695541f, 0.01424710f, 
    -0.07248670f, -0.04669496f, -0.01471397f, -0.01902934f, -0.00401732f, -0.02576523f, -0.03707470f, -0.00140347f, 
    -0.07128648f, 0.00445715f, -0.05098405f, -0.06071649f, -0.04957525f, -0.00228589f, -0.01341968f, -0.03325644f, 
    -0.06936142f, -0.03089250f, 0.02999483f, 0.03223699f, 0.00845511f, 0.01588342f, -0.01546689f, 0.03231909f, 
    -0.01167271f, -0.02850615f, 0.00163680f, -0.06807006f, -0.01248604f, -0.03848938f, 0.00300693f, -0.07285317f, 
    -0.04268506f, -0.02682693f, -0.01413873f, -0.01503083f, 0.00664944f, -0.02952083f, -0.01277201f, -0.06544261f, 
    -0.00810825f, 0.02111975f, 0.00791358f, -0.06009169f, 0.00553573f, -0.02952608f, -0.00746878f, -0.05380521f, 
    0.03224109f, -0.05132179f, -0.00594224f, 0.03235805f, -0.05306426f, -0.04514358f, 0.02807600f, -0.04115178f, 
    -0.04167061f, -0.06166916f, -0.00355092f, -0.03402847f, -0.05104638f, -0.03145875f, 0.01984975f, 0.02770793f, 
    -0.04281593f, -0.05055230f, 0.03934804f, 0.00524356f, -0.00206362f, -0.05183394f, 0.05051344f, 0.06827842f, 
    -0.04241907f, 0.04886734f, -0.02267851f, -0.01184749f, -0.05189282f, -0.04033532f, -0.01478501f, -0.04661497f, 
    0.01685482f, -0.01356405f, -0.04192657f, 0.00989664f, 0.01986189f, -0.01746486f, 0.01656262f, -0.02529759f, 
    0.03379180f, 0.01672569f, -0.00434515f, 0.00776172f, -0.02865332f, 0.01324532f, 0.04683238f, 0.00535423f, 
    -0.05170271f, 0.02459931f, -0.04768654f, -0.03273679f, -0.03670274f, -0.05842260f, -0.02005333f, -0.06370208f, 
    -0.04026727f, 0.01028344f, -0.03923727f, -0.02259998f, 0.00815757f, 0.03083096f, -0.04448961f, -0.03970481f, 
    -0.05306212f, -0.00548465f, -0.01156319f, -0.00157399f, -0.03148746f, 0.01870296f, 0.01509836f, 0.01097493f, 
    -0.01583515f, 0.01651357f, 0.01337686f, 0.02617867f, 0.02188969f, -0.01713905f, 0.02131455f, -0.01207187f, 
    -0.04740995f, -0.00824271f, -0.05404810f, 0.01497737f, -0.02981635f, -0.02218743f, 0.03611650f, -0.04368085f, 
    -0.00665278f, 0.02300339f, -0.00758148f, 0.02713350f, 0.02911460f, -0.04477276f, -0.02627124f, 0.01789676f, 
    -0.02902304f, -0.00989869f, -0.04664591f, -0.03519158f, -0.00419583f, 0.00823859f, 0.02079606f, 0.01244017f, 
    0.00771762f, 0.00597433f, 0.01193603f, 0.02478040f, -0.02297540f, -0.06302264f, 0.00048473f, 0.01259183f, 
    -0.02754380f, -0.07647700f, -0.03412602f, 0.04773804f, 0.03356196f, 0.00999821f, -0.02072016f, -0.04334426f, 
    -0.02245355f, -0.01713367f, 0.01945071f, 0.01088991f, 0.02635321f, -0.02555743f, -0.05385626f, -0.01759089f, 
    -0.03677445f, -0.02833792f, 0.00399563f, 0.01619693f, 0.01811135f, 0.02434891f, -0.05066301f, 0.00368266f, 
    -0.05649414f, -0.04992842f, -0.04062234f, -0.04592749f, 0.00392323f, -0.03299650f, 0.01675492f, 0.02050214f, 
    -0.06643281f, -0.00222441f, -0.00976521f, 0.00389246f, 0.03939962f, 0.02656577f, -0.05846993f, -0.01452810f, 
    0.01289829f, -0.07846035f, -0.10124015f, -0.16326448f, 0.16944809f, 0.02161556f, 0.18214610f, -0.03447257f, 
    0.07163412f, 0.27722353f, 0.08286150f, 0.15368077f, 0.15490144f, 0.18009353f, -0.02314856f, -0.11150938f, 
    -0.00191509f, -0.04188901f, -0.07792338f, -0.03170124f, -0.10132571f, -0.05052639f, -0.07698357f, -0.17197029f, 
    -0.16728483f, -0.20272353f, -0.04002429f, 0.26935974f, 0.14079846f, 0.05118520f, 0.10830607f, 0.15734313f, 
    -0.06326064f, -0.18302846f, -0.08793664f, 0.12343943f, 0.05669863f, 0.03797527f, 0.03542604f, 0.24029206f, 
    0.16447048f, 0.12260941f, 0.03192369f, -0.01687201f, 0.07174728f, 0.21662799f, 0.04519916f, 0.26242587f, 
    -0.40922526f, 0.14209729f, 0.14204103f, 0.12723264f, -0.00254037f, -0.01903988f, -0.13023552f, 0.01164391f, 
    0.05650923f, 0.10869715f, 0.08241723f, 0.06637039f, -0.01372180f, 0.21529309f, -0.03816689f, -0.04681018f, 
    -0.04196519f, -0.08921911f, 0.15384300f, 0.17577115f, 0.09365801f, 0.20343487f, 0.05892112f, 0.15998182f, 
    0.26646164f, -0.09171633f, -0.08953272f, 0.18316965f, 0.11329717f, 0.09651295f, -0.04710920f, 0.04471517f, 
    -0.05610520f, -0.03435688f, -0.14461805f, 0.08688489f, 0.12541720f, 0.06794612f, 0.12144874f, 0.06708460f, 
    -0.09564172f, -0.16978188f, -0.02910133f, 0.05781823f, -0.04003529f, -0.06395838f, -0.00439033f, -0.04412206f, 
    0.06610173f, -0.06859428f, 0.03971549f, 0.16533108f, 0.08644675f, 0.06133316f, 0.02276609f, 0.02571258f, 
    0.02024844f, -0.16174434f, -0.12792113f, -0.17568450f, -0.16491574f, -0.29861519f, -0.14556110f, -0.23847929f, 
    0.05435651f, 0.04708040f, 0.00214405f, 0.00197486f, -0.10782855f, 0.08347433f, 0.01847613f, -0.07117960f, 
    -0.36802533f, 0.10283144f, -0.03695476f, 0.09936731f, -0.03457138f, -0.03592865f, -0.05508431f, -0.04242389f, 
    0.06094663f, 0.13450962f, 0.11306981f, 0.14573859f, -0.13018453f, -0.04036593f, -0.07266165f, -0.01928704f, 
    -0.12810460f, -0.05700766f, -0.08119132f, -0.08863629f, 0.02437777f, -0.04519842f, -0.00773288f, -0.10812566f, 
    0.02783987f, 0.16710645f, -0.06731834f, 0.01953526f, 0.07181536f, 0.17866981f, 0.11267163f, 0.11816238f, 
    0.06942669f, -0.03455408f, 0.13264620f, 0.08560736f, -0.04724091f, 0.24088109f, -0.29560319f, -0.00541987f, 
    0.02174745f, 0.07102501f, 0.07979995f, 0.09182408f, -0.13805722f, -0.05215080f, -0.00264781f, -0.08162403f, 
    -0.08890514f, -0.07894783f, -0.07486048f, 0.01097586f, -0.01937264f, 0.00066656f, -0.09483663f, -0.11241297f, 
    -0.08067384f, -0.12227657f, -0.06004670f, -0.02955350f, 0.09017427f, -0.44415912f, -0.34002465f, 0.00613278f, 
    0.06110661f, 0.02796292f, -0.09204613f, 0.07212586f, 0.00007692f, 0.11885376f, 0.08603314f, -0.00228611f, 
    -0.01696817f, -0.01348477f, 0.01320674f, 0.15795620f, 0.06323436f, 0.19546548f, 0.12428679f, 0.08949573f, 
    0.24881156f, 0.03821252f, 0.06105961f, 0.10362943f, -0.20441033f, 0.00112499f, 0.10282237f, -0.16189082f, 
    -0.09777021f, 0.04826709f, -0.08905770f, 0.01712442f, 0.05071317f, 0.04715002f, 0.03657876f, 0.18015358f, 
    0.20416377f, -0.00611458f, 0.02504080f, -0.11501729f, -0.13381538f, 0.09897290f, -0.07192282f, -0.03496311f, 
    0.04843811f, 0.01659146f, -0.08244657f, -0.01258211f, 0.11879618f, 0.15126213f, 0.17680191f, 0.15664847f, 
    0.11243394f, 0.11937203f, 0.06204171f, 0.27282038f, 0.09351777f, 0.11195627f, 0.05330048f, 0.13380116f, 
    0.35306895f, -0.05892259f, 0.15270549f, 0.24467777f, 0.06831057f, -0.11473253f, 0.01427100f, -0.11239900f, 
    -0.05906099f, -0.02484885f, -0.15062881f, -0.04828185f, -0.05116265f, 0.32256511f, 0.12578849f, 0.32820809f, 
    -0.08858993f, -0.12073592f, -0.03258536f, -0.05746481f, 0.02445916f, -0.00928987f, -0.07493773f, 0.04900924f, 
    0.24290283f, -0.17310436f, -0.01514866f, -0.11676370f, 0.15172742f, -0.01033375f, -0.14377569f, -0.10182585f, 
    0.11184464f, 0.14572224f, -0.03805864f, 0.11869093f, -0.21811019f, -0.14647830f, -0.02816631f, 0.11279947f, 
    -0.02005024f, -0.06744788f, 0.03557206f, -0.04056695f, 0.25345686f, -0.05005131f, 0.28310111f, -0.02536002f, 
    0.07008116f, -0.06501530f, 0.03330477f, -0.08064880f, 0.04744137f, -0.02712275f, 0.09178056f, -0.00583733f, 
    0.04502735f, 0.19830701f, 0.13111408f, 0.23472729f, 0.15028490f, -0.09467326f, 0.05205022f, 0.10104185f, 
    0.10231818f, -0.02237807f, -0.01760744f, 0.15736105f, -0.10834560f, 0.08309855f, 0.10596934f, 0.19762443f, 
    -0.34943652f, -0.00302304f, 0.10401440f, 0.04663036f, 0.04517428f, -0.00509733f, -0.11618240f, -0.01563586f, 
    0.14454065f, 0.00597991f, -0.09511198f, -0.27573293f, -0.20200349f, 0.10634849f, -0.07486270f, -0.00919780f, 
    -0.02207968f, 0.06377073f, 0.01303475f, 0.01654331f, 0.13260676f, 0.03244149f, 0.08913260f, 0.18680038f, 
    0.25209540f, 0.09587840f, 0.15417944f, 0.39815333f, -0.00704245f, 0.04098597f, 0.07602996f, 0.12013342f, 
    0.07080505f, 0.09515465f, 0.10340578f, 0.09125070f, -0.18874466f, -0.05071378f, 0.11826535f, 0.00250830f, 
    -0.09218134f, -0.03497931f, -0.01668771f, -0.14531600f, -0.04195589f, 0.08006269f, -0.03133041f, 0.13683717f, 
    -0.00364912f, 0.33047706f, 0.05803757f, 0.17448397f, -0.04761143f, 0.03983469f, 0.02659119f, 0.12943713f, 
    -0.00113145f, -0.10996358f, -0.19631863f, -0.03539098f, 0.27721334f, -0.01159509f, 0.05458141f, -0.16490413f, 
    0.04443411f, 0.02130432f, 0.05919238f, -0.02978821f, -0.09854747f, 0.03721112f, 0.00180998f, -0.05838452f, 
    -0.10686494f, -0.09244939f, -0.05986430f, -0.10487052f, -0.14127190f, 0.09115563f, 0.01970333f, -0.13309443f, 
    -0.03697906f, -0.09035146f, -0.14017211f, -0.12869608f, -0.09361239f, 0.20534004f, 0.06806415f, 0.26648933f, 
    0.01226491f, -0.00904105f, 0.04407658f, -0.04486143f, 0.08374974f, 0.07829364f, 0.15833919f, 0.30859810f, 
    0.27391395f, 0.44503468f, 0.21750356f, 0.14624545f, 0.24156202f, 0.01351449f, -0.01510395f, -0.01221637f, 
    0.09057236f, 0.17024232f, 0.06441290f, -0.05455516f, 0.00776170f, 0.00960904f, -0.05144969f, -0.15906256f, 
    0.15036349f, 0.08206115f, 0.01306732f, 0.13498576f, 0.08489531f, -0.23482817f, -0.01248825f, -0.06284765f, 
    -0.08019244f, -0.14163451f, -0.38623264f, 0.17720549f, 0.05099576f, 0.06251422f, 0.04187695f, -0.12879844f, 
    0.03773568f, 0.07358675f, -0.07742155f, -0.06226440f, 0.08075613f, -0.04039402f, 0.07601715f, 0.03354969f, 
    -0.05132275f, -0.00987260f, 0.05494207f, -0.06477984f, -0.08351403f, -0.08589315f, -0.18466355f, -0.12795657f, 
    0.05820517f, 0.08089711f, 0.04841411f, -0.02520751f, 0.19859909f, 0.21528301f, 0.04127311f, 0.13234752f, 
    0.06011636f, 0.00176884f, 0.15158235f, 0.19336495f, -0.16132154f, -0.07793541f, -0.14152175f, -0.16552490f, 
    0.00836300f, -0.12288903f, -0.12073068f, -0.05082108f, 0.19252330f, 0.10043267f, -0.06887366f, 0.13006651f, 
    0.08427154f, 0.23116751f, 0.12412678f, 0.04798662f, 0.19903949f, 0.05573509f, 0.08070222f, 0.18370152f, 
    0.05867312f, 0.00993296f, 0.08522978f, 0.28341606f, -0.17424563f, -0.00063607f, 0.26615912f, 0.13396971f, 
    0.06506607f, -0.06396919f, 0.07246241f, 0.07719378f, 0.02382449f, 0.04685224f, -0.04810549f, 0.07665100f, 
    0.06776138f, -0.26141235f, -0.37213993f, -0.09913264f, -0.02073752f, 0.01718718f, 0.07511624f, -0.06876723f, 
    -0.01504553f, -0.07343064f, -0.01834449f, -0.02217397f, -0.08512851f, -0.27205667f, -0.15212275f, -0.06186846f, 
    0.00583688f, 0.00961586f, -0.13659352f, 0.05366724f, -0.08722349f, 0.10010898f, -0.07527333f, 0.22761460f, 
    -0.05978230f, 0.18308705f, 0.17857037f, 0.04309160f, 0.23754650f, 0.03514113f, -0.12164929f, -0.15924244f, 
    -0.14736155f, -0.01476344f, -0.06925040f, 0.01306769f, -0.01763386f, 0.03057353f, 0.31132793f, 0.12326144f, 
    -0.00109885f, 0.15743630f, 0.03625135f, 0.12078489f, 0.05777654f, 0.05273020f, 0.03638913f, 0.19768360f, 
    -0.07438299f, -0.28967118f, -0.22425389f, -0.09979278f, 0.03751246f, 0.05553572f, -0.05667533f, -0.07061188f, 
    0.06969573f, 0.09455090f, 0.11436524f, 0.23075397f, 0.10793585f, 0.27172679f, 0.26590291f, 0.12146442f, 
    -0.03193119f, 0.01940236f, 0.09408785f, -0.02871598f, -0.01614158f, -0.01423240f, -0.00590076f, 0.11536450f, 
    0.17419237f, 0.18397994f, 0.12287774f, 0.06454168f, 0.01379507f, 0.09698237f, -0.03697107f, 0.12178455f, 
    -0.14660072f, 0.04966230f, -0.03594105f, -0.19181480f, -0.06657716f, 0.06032018f, -0.26689187f, -0.15907961f, 
    -0.10222620f, 0.10585419f, 0.06232011f, -0.13036525f, 0.09513418f, 0.01041952f, -0.12539868f, 0.05006744f, 
    -0.31210846f, -0.03508706f, -0.23605078f, -0.06151003f, 0.07171722f, 0.04050499f, -0.20490763f, -0.02509941f, 
    -0.07263745f, -0.09919830f, 0.10724556f, 0.04069577f, 0.12988397f, 0.13368759f, 0.20974383f, -0.01305028f, 
    0.13880982f, 0.10475487f, 0.18046421f, 0.04875892f, 0.06255510f, 0.03449060f, -0.02837424f, -0.02295134f, 
    -0.06630998f, 0.09883894f, 0.04946144f, 0.06867103f, 0.13493913f, 0.16164276f, 0.15559982f, 0.24294209f, 
    -0.03847916f, 0.00500401f, 0.04859933f, 0.14620918f, -0.06533922f, -0.04169058f, 0.08791523f, 0.05957625f, 
    0.06003837f, -0.01405233f, 0.02515244f, 0.17333233f, 0.01820082f, -0.06303888f, 0.01290358f, -0.05445739f, 
    -0.14823103f, -0.17674558f, -0.04184069f, -0.03459042f, -0.10863078f, -0.03449029f, 0.04673404f, 0.02587721f, 
    -0.06485847f, 0.00797535f, -0.00544286f, 0.07591945f, 0.10423864f, 0.06299479f, -0.29009256f, 0.13014661f, 
    -0.09269574f, 0.00228958f, -0.20035094f, -0.25320280f, 0.00359155f, 0.08435395f, 0.02989152f, 0.08282055f, 
    -0.19322734f, -0.10164857f, -0.17624694f, 0.07149035f, -0.06785499f, -0.15173022f, 0.07054280f, 0.00406338f, 
    0.05701048f, 0.02013039f, 0.08563500f, -0.01123673f, 0.09850200f, 0.14710465f, 0.24634825f, 0.06108313f, 
    -0.17160857f, -0.01328325f, 0.06399863f, -0.03525902f, 0.00737039f, -0.00870874f, -0.09638242f, -0.09635186f, 
    -0.14073615f, 0.03641773f, -0.10713142f, -0.14549409f, -0.08525980f, -0.07079131f, 0.04367325f, -0.07566860f, 
    0.06902201f, -0.05189897f, 0.01678978f, 0.14644042f, -0.06262606f, -0.25424591f, -0.15562586f, -0.21930270f, 
    0.08219001f, -0.13162217f, 0.12578908f, 0.05911088f, -0.06114398f, 0.01768360f, -0.18966264f, -0.10778074f, 
    0.25039002f, 0.24101971f, 0.01370058f, 0.01961512f, 0.18521512f, 0.07441472f, -0.03244222f, -0.03169987f, 
    -0.00804249f, -0.18949112f, -0.06675736f, 0.06009861f, -0.10774384f, -0.31461680f, -0.10772344f, -0.07612330f, 
    -0.10276655f, 0.07146251f, -0.01272492f, -0.05315283f, -0.00119078f, -0.05486292f, 0.07482684f, -0.15931690f, 
    0.17954962f, -0.01462664f, 0.12482763f, -0.06569742f, 0.02420587f, -0.02415171f, 0.04778891f, 0.12154906f, 
    0.05159214f, -0.00107104f, 0.07385468f, 0.24914762f, -0.02041553f, 0.03656412f, -0.11916157f, 0.02980856f, 
    -0.07781532f, -0.03270162f, -0.04610305f, 0.03081397f, 0.14950055f, -0.04236202f, -0.05997418f, 0.27629471f, 
    0.00280425f, 0.01968611f, -0.04492547f, -0.03064326f, -0.02947867f, -0.00389722f, -0.05113348f, 0.00949099f, 
    0.02080799f, -0.04498994f, -0.05078356f, 0.00485926f, -0.05187104f, -0.01569257f, 0.04217306f, -0.04998146f, 
    -0.01568851f, 0.03030600f, 0.03426781f, -0.02637133f, 0.03298626f, 0.03892876f, 0.00450289f, -0.05593368f, 
    0.01137158f, -0.00943339f, -0.02184108f, 0.01547625f, -0.04893318f, -0.02586009f, 0.03765628f, 0.02931301f, 
    0.00163103f, 0.00116951f, -0.04842607f, -0.01843405f, -0.05602402f, 0.01236159f, -0.03293137f, 0.03880752f, 
    -0.01349161f, 0.02385579f, -0.03547445f, 0.03733823f, -0.02370363f, -0.01002116f, -0.01807821f, -0.03172276f, 
    -0.02265783f, 0.00255633f, -0.04174552f, 0.00724412f, -0.04101947f, -0.01343877f, 0.01030355f, -0.02569802f, 
    0.00705107f, 0.01114094f, -0.05518334f, 0.01040482f, 0.03116981f, -0.00380423f, -0.05110977f, -0.05682491f, 
    -0.01594163f, -0.04668017f, -0.02957799f, -0.04680014f, 0.02960646f, -0.02278014f, -0.04288825f, 0.00108895f, 
    -0.02511665f, -0.04753837f, 0.00746668f, -0.01139500f, -0.01740627f, 0.02613910f, 0.01177921f, 0.03097661f, 
    -0.02555420f, -0.00794803f, -0.04059539f, 0.00430076f, 0.02482728f, 0.04185405f, -0.05114257f, 0.03878716f, 
    -0.03629318f, -0.00341811f, 0.00872870f, -0.00967070f, 0.03923154f, -0.04215800f, -0.01462879f, 0.02147415f, 
    0.00052246f, 0.02000349f, 0.04312618f, -0.01628005f, -0.01172197f, -0.01152150f, -0.05272003f, 0.01553972f, 
    0.01219957f, -0.04581434f, 0.01762555f, -0.04639680f, 0.00270806f, 0.00213429f, -0.03249532f, -0.03960752f, 
    -0.05653740f, -0.02306517f, 0.00252231f, 0.00637615f, -0.02021589f, 0.04004649f, -0.04383324f, 0.03011145f, 
    0.02656776f, -0.04631852f, -0.01030231f, 0.03228009f, -0.05505329f, 0.03916168f, 0.00540103f, -0.02487560f, 
    0.03459419f, -0.04919166f, 0.01317691f, 0.01263430f, -0.01584242f, 0.03316296f, 0.02446316f, 0.04050418f, 
    -0.00893775f, -0.02046132f, 0.04359100f, -0.04000562f, -0.02674921f, 0.01523787f, -0.00741157f, 0.01685862f, 
    -0.00410290f, -0.01773610f, 0.02802022f, 0.04225269f, 0.02259189f, 0.04365618f, -0.01475318f, -0.02288043f, 
    -0.01877726f, -0.02793166f, 0.04501658f, 0.01897421f, -0.01493616f, 0.00967121f, -0.01592571f, 0.01709983f, 
    0.01344674f, 0.02190292f, -0.00392469f, -0.03784627f, 0.02358308f, -0.05203226f, 0.03050236f, -0.02986847f, 
    0.01286105f, 0.04192051f, -0.01403366f, 0.01326845f, -0.05409879f, -0.01085389f, 0.01598966f, -0.01425684f, 
    -0.02216442f, -0.02087082f, 0.03306317f, -0.04446586f, 0.00687437f, -0.04288514f, 0.00590062f, 0.01944309f, 
    0.00916032f, -0.04130806f, -0.03813668f, 0.00243222f, -0.03713083f, -0.00772561f, 0.00519851f, -0.04040949f, 
    0.01000937f, -0.03033035f, -0.04855189f, -0.02821428f, 0.01160772f, 0.04220106f, -0.04503993f, -0.05534649f, 
    -0.04632497f, -0.03168223f, -0.01218540f, 0.01905994f, 0.02037989f, -0.04111259f, 0.01890206f, 0.02813141f, 
    -0.03770497f, 0.01579973f, -0.02384081f, -0.01248713f, 0.01828213f, 0.03994409f, -0.02438759f, 0.03274694f, 
    -0.04885431f, -0.00910363f, -0.00344771f, 0.02713136f, 0.01128270f, -0.05132709f, -0.03308904f, -0.04743881f, 
    -0.05569465f, 0.00397958f, -0.05252679f, 0.02110624f, -0.04136608f, -0.00414836f, -0.03958008f, 0.02958369f, 
    -0.05941804f, 0.02957947f, -0.03578883f, -0.01876864f, 0.03217709f, 0.01815013f, 0.01969362f, -0.05363702f, 
    0.01460344f, -0.03861500f, 0.02385709f, 0.02708229f, -0.04291474f, 0.01243402f, 0.00743284f, 0.03455679f, 
    -0.01009184f, 0.01201829f, 0.00849984f, -0.04147689f, 0.02025417f, 0.03379279f, -0.05618213f, -0.04557109f, 
    -0.03716173f, -0.05112732f, 0.01888562f, -0.05582694f, 0.03116133f, -0.02089194f, 0.01177928f, -0.02578065f, 
    0.00193928f, -0.05481557f, -0.04150109f, 0.01321667f, 0.00455422f, -0.04897916f, -0.04958776f, -0.02952396f, 
    0.02486190f, -0.03802220f, -0.05764934f, 0.02658048f, -0.03346301f, 0.01614797f, 0.03135049f, -0.02061317f, 
    0.00405860f, 0.02867350f, -0.01886077f, 0.00012271f, 0.01213509f, -0.01639200f, -0.04178871f, 0.01349652f, 
    -0.04598880f, -0.02726807f, -0.02309866f, 0.01822329f, -0.01764313f, -0.00322557f, 0.02807638f, -0.01860108f, 
    -0.00702526f, 0.01452366f, -0.00282996f, -0.03013857f, 0.02521936f, 0.00724667f, -0.02781245f, 0.03057122f, 
    0.04151973f, 0.02596048f, 0.00895303f, 0.00402109f, 0.02318596f, -0.04442156f, -0.00773122f, 0.02412324f, 
    0.00594278f, -0.00259964f, 0.00965637f, -0.02436202f, -0.01873516f, 0.03688155f, 0.02218668f, 0.02397708f, 
    0.04287480f, 0.02681077f, -0.03538253f, 0.04210535f, -0.04642464f, -0.05781071f, -0.00510988f, -0.03122413f, 
    -0.00089514f, 0.02808863f, -0.03662081f, -0.03871633f, 0.01526394f, 0.04276463f, -0.00495918f, -0.03934780f, 
    -0.02384134f, 0.01621906f, 0.01948579f, 0.03758345f, -0.03726022f, 0.03797074f, 0.01667923f, -0.00574792f, 
    -0.04484890f, 0.01113949f, -0.03178558f, 0.01091205f, -0.01926913f, 0.00357822f, -0.05003244f, 0.00492504f, 
    -0.05276049f, 0.01407579f, -0.03981222f, 0.00806092f, 0.00700682f, -0.00624099f, -0.03707667f, 0.01531770f, 
    -0.01526748f, -0.03492411f, 0.02358543f, 0.01008009f, -0.02474981f, 0.01153290f, -0.00031861f, 0.03966198f, 
    -0.03252812f, -0.04884186f, -0.01154881f, -0.04613021f, -0.01257914f, -0.00944022f, -0.01505695f, -0.04089452f, 
    -0.04757633f, 0.02559325f, 0.02731881f, 0.04052646f, 0.02354461f, -0.01569332f, -0.03465981f, -0.04506623f, 
    0.05699819f, -0.15551154f, 0.09165607f, -0.14086419f, 0.08080355f, 0.05170715f, 0.07695172f, -0.06568145f, 
    0.04138654f, 0.13875774f, 0.12213033f, 0.08631708f, 0.10598505f, 0.28844854f, 0.23305658f, -0.11905976f, 
    0.05556265f, 0.12642609f, -0.05418230f, 0.01310547f, 0.06909658f, -0.08852804f, -0.10364425f, -0.09760297f, 
    -0.08949845f, -0.08153640f, 0.04967549f, 0.08464588f, -0.02383533f, -0.09008630f, 0.03231043f, 0.04706488f, 
    -0.18603903f, -0.10354566f, 0.00117642f, -0.05694040f, -0.13418014f, -0.12587260f, 0.08075552f, 0.13481621f, 
    -0.01452308f, 0.12711184f, 0.03457304f, -0.05071266f, -0.04388865f, 0.14150532f, 0.17584693f, 0.06349370f, 
    -0.35272202f, 0.16909111f, 0.21744341f, 0.24545954f, 0.01671781f, 0.02417861f, 0.01253824f, 0.03482246f, 
    -0.19418751f, 0.02505434f, -0.00560268f, 0.00040333f, -0.07240139f, 0.20106959f, -0.08177669f, -0.03266830f, 
    -0.13846864f, -0.13560118f, 0.09769049f, 0.01871388f, -0.03702149f, 0.15523626f, 0.11811421f, 0.14929266f, 
    0.40043950f, -0.19267553f, -0.15946895f, 0.03105793f, 0.11148660f, 0.08251589f, -0.06174773f, 0.06594922f, 
    -0.09734410f, -0.04085369f, 0.02968903f, -0.01606409f, -0.13199227f, -0.03316082f, 0.21666513f, 0.25925678f, 
    -0.18457609f, 0.05310429f, -0.01363156f, 0.04807455f, -0.11118262f, -0.09037613f, -0.08308075f, -0.14684881f, 
    -0.00006689f, -0.08425611f, -0.12049342f, 0.07837594f, 0.01280676f, 0.11512116f, 0.03380265f, 0.10079090f, 
    0.00426522f, -0.06667071f, -0.06954402f, -0.25094566f, -0.31292343f, -0.38773617f, -0.01818017f, 0.03301157f, 
    0.12376003f, 0.15625294f, 0.02165607f, 0.08642254f, 0.08804483f, 0.21956471f, 0.04289719f, -0.09024772f, 
    -0.37743059f, 0.10980034f, 0.01364822f, 0.08891737f, -0.06479756f, 0.00647271f, -0.00417870f, -0.08215835f, 
    -0.08724382f, -0.02633755f, 0.03524423f, 0.19441092f, -0.34280625f, 0.04860633f, -0.02801973f, 0.09176189f, 
    -0.08676014f, 0.03886046f, -0.08984274f, -0.07004397f, -0.06150797f, -0.05681387f, 0.07338840f, -0.17661853f, 
    -0.31255665f, 0.21113203f, -0.17973262f, 0.01495259f, 0.08987714f, 0.00542208f, -0.03009118f, 0.03149271f, 
    0.07408817f, -0.02409616f, 0.09008335f, 0.11030143f, 0.19983310f, 0.46046028f, -0.25352001f, -0.18177538f, 
    0.08176614f, 0.11902522f, 0.11131241f, 0.00272888f, -0.15154491f, -0.11747295f, -0.06557667f, -0.02917609f, 
    -0.18519476f, -0.01543904f, -0.09779841f, -0.04793913f, -0.01527162f, 0.03476137f, -0.04800005f, -0.03123142f, 
    -0.09779319f, -0.07570464f, -0.08181157f, -0.16111623f, -0.11187039f, -0.34080485f, -0.06797227f, -0.18154797f, 
    0.02589064f, 0.04166675f, 0.04861381f, -0.09464799f, 0.01100520f, 0.00417398f, -0.03915775f, -0.14513732f, 
    -0.13939421f, -0.09301555f, -0.04528416f, 0.11063927f, 0.08799978f, 0.10503444f, -0.01559217f, 0.09058985f, 
    0.15562308f, 0.02060212f, 0.11545628f, 0.20176543f, 0.02465537f, -0.19931258f, 0.10514923f, 0.15136367f, 
    -0.11573330f, 0.05481863f, -0.09377570f, -0.11400945f, -0.05705906f, 0.10400023f, 0.02068071f, 0.23157798f, 
    0.11741510f, 0.21511753f, 0.20885611f, -0.10897262f, -0.18421763f, 0.06585084f, 0.06998461f, -0.00921218f, 
    0.06817833f, 0.00835202f, 0.02711855f, 0.17004786f, 0.27255061f, 0.12765834f, 0.05601520f, 0.05024183f, 
    0.06706764f, 0.08540809f, 0.03442154f, -0.04521058f, 0.15816842f, 0.13097246f, 0.13257591f, 0.03674433f, 
    0.43199661f, -0.10234642f, 0.03445615f, 0.07949480f, -0.03810332f, 0.00951590f, 0.00192504f, -0.08765510f, 
    -0.03370259f, 0.04113051f, -0.04700654f, 0.05051659f, -0.00884288f, 0.24120319f, 0.04689544f, 0.33768448f, 
    -0.01446750f, 0.05911149f, -0.04603906f, 0.12038179f, -0.02173883f, -0.02643558f, 0.03952390f, 0.05124388f, 
    0.27772349f, 0.00951202f, 0.26761320f, -0.00966270f, -0.05510839f, 0.06354699f, 0.02393863f, -0.06401094f, 
    0.07620230f, -0.00914222f, 0.11938675f, 0.02195254f, -0.23745143f, -0.09935880f, 0.12907766f, 0.23461036f, 
    -0.02566483f, 0.01741771f, -0.03916854f, 0.16322505f, 0.01667679f, -0.14250506f, 0.09513006f, -0.02130213f, 
    -0.10846056f, 0.03036758f, -0.02534896f, -0.09710532f, -0.10293096f, -0.04460824f, 0.09371544f, 0.00392926f, 
    -0.10662083f, -0.06776932f, 0.13915837f, 0.12243950f, 0.12553163f, -0.07191774f, 0.16737735f, -0.00010599f, 
    0.12432887f, -0.02000951f, -0.06394196f, 0.15267830f, -0.10789128f, -0.09270739f, 0.06091242f, 0.11673576f, 
    -0.20951393f, 0.06241501f, 0.11770158f, 0.23583958f, -0.05171530f, 0.03518449f, 0.04330284f, 0.05429998f, 
    0.03896302f, -0.05188130f, -0.12242038f, -0.24150178f, -0.22803330f, 0.05922691f, -0.09124181f, 0.06723306f, 
    -0.00434313f, 0.07757353f, -0.12124553f, 0.09238141f, -0.01076089f, 0.10399229f, -0.00619609f, 0.20167068f, 
    0.11162352f, 0.03629221f, 0.14168744f, 0.33701858f, -0.05724918f, 0.10483450f, -0.00161471f, -0.07853668f, 
    0.10483933f, 0.11951018f, 0.05658441f, 0.14410830f, -0.00733425f, -0.01508314f, 0.07437846f, 0.38074926f, 
    -0.06942026f, -0.08482730f, 0.01039383f, -0.16227670f, -0.09454439f, -0.02323247f, 0.00796031f, 0.14216222f, 
    0.09989920f, 0.36078092f, -0.27008381f, 0.23100686f, 0.05873319f, 0.08005972f, 0.21068950f, -0.00214590f, 
    -0.05517777f, 0.06234338f, -0.02215074f, 0.03925170f, 0.07890616f, -0.20885277f, 0.06598722f, -0.14707023f, 
    -0.02537065f, -0.02189417f, 0.25039971f, 0.13008125f, 0.02796207f, 0.04678573f, -0.10356626f, -0.18633153f, 
    -0.04799923f, 0.03402030f, 0.04008877f, -0.18580727f, 0.05754416f, -0.00436769f, 0.22426531f, -0.11552715f, 
    -0.09469819f, 0.08579154f, 0.00745104f, 0.00105771f, 0.16135600f, 0.37386927f, 0.05748947f, -0.21670212f, 
    -0.15380427f, -0.00667343f, -0.03926340f, 0.05466129f, 0.08413318f, -0.07243637f, -0.08353736f, 0.10102257f, 
    -0.07644851f, 0.10372464f, -0.22568800f, 0.23160483f, 0.10823834f, 0.02998207f, 0.17569214f, 0.22278614f, 
    -0.02990811f, -0.04035941f, 0.00576655f, 0.02279631f, -0.09080163f, -0.04964383f, 0.13927381f, 0.17865488f, 
    0.04338156f, 0.18062435f, 0.05887348f, 0.08947613f, -0.07985377f, -0.06042910f, 0.02376841f, 0.25323161f, 
    -0.37886107f, 0.19326669f, 0.39441493f, 0.21537375f, -0.15792261f, 0.01936857f, -0.03424293f, 0.12364943f, 
    -0.07736840f, 0.06856292f, 0.09572375f, 0.11769242f, -0.06869061f, 0.17839703f, -0.03295196f, -0.02531578f, 
    -0.04632928f, -0.01903694f, 0.15728717f, 0.02033153f, -0.02430047f, 0.07094108f, -0.04324636f, 0.09524301f, 
    0.42973790f, -0.18319342f, -0.13678789f, -0.05299119f, 0.06486192f, 0.23885703f, 0.01696839f, -0.02083188f, 
    -0.08046100f, 0.00276102f, -0.10615323f, 0.05484042f, 0.07291371f, -0.01273402f, 0.15643051f, 0.19413389f, 
    -0.09218060f, -0.21042566f, 0.01963347f, 0.18376939f, 0.00569498f, 0.02533108f, 0.03499550f, 0.05517759f, 
    0.12430778f, -0.13212977f, -0.02355744f, 0.22443490f, 0.06404519f, 0.01040164f, -0.04254577f, 0.00807487f, 
    -0.00464959f, -0.11516353f, -0.02308157f, -0.02059577f, 0.38689485f, 0.06481630f, 0.02230462f, -0.19223404f, 
    -0.05052867f, -0.00911005f, 0.00952518f, -0.07531658f, -0.06403882f, 0.01489502f, 0.01383140f, -0.16229406f, 
    -0.16973041f, 0.04196598f, 0.08155705f, 0.12839261f, -0.03795287f, 0.05569298f, 0.06306893f, -0.03387330f, 
    -0.11431152f, -0.00420785f, 0.02743817f, 0.10200950f, -0.00190960f, -0.02132208f, 0.03885803f, 0.12155259f, 
    -0.09995949f, 0.02453805f, -0.04501047f, -0.10282370f, 0.06724369f, -0.05782975f, 0.01787779f, 0.06123952f, 
    0.53379607f, 0.22473983f, -0.29012206f, 0.03024944f, 0.09868207f, 0.18231094f, 0.04843687f, 0.10416277f, 
    -0.02514737f, 0.07029507f, 0.01342230f, 0.05732173f, 0.26138395f, 0.27460212f, -0.34002331f, -0.06048479f, 
    -0.16366480f, 0.27415490f, 0.14277381f, 0.09584252f, 0.09048019f, -0.07887194f, -0.00406496f, -0.03950510f, 
    -0.10939109f, 0.03226583f, 0.13070378f, 0.07822529f, -0.04047087f, 0.03929496f, -0.05837637f, -0.01270451f, 
    0.06125338f, 0.11479517f, -0.06359512f, 0.02177695f, 0.41077924f, -0.07685889f, -0.04348425f, -0.21337603f, 
    0.08091062f, 0.04610479f, -0.03123529f, -0.14669544f, -0.01545456f, 0.01056557f, 0.01150298f, -0.01443452f, 
    0.07645843f, -0.04013873f, -0.16693892f, 0.11036060f, 0.13555102f, 0.10450581f, 0.09836201f, -0.00199711f, 
    0.16262703f, 0.04778093f, 0.02921225f, -0.01357479f, -0.19256404f, -0.04823613f, 0.19805349f, -0.01104333f, 
    -0.12247267f, 0.00452262f, 0.14369299f, -0.09521380f, -0.18314752f, -0.02948709f, -0.10290774f, 0.05349517f, 
    0.15104637f, 0.21577410f, 0.02499521f, 0.04239941f, -0.09298666f, 0.02581834f, 0.12409932f, -0.00479777f, 
    -0.12020049f, 0.02058993f, -0.00374327f, -0.05706934f, 0.12095342f, 0.31461272f, -0.02146180f, -0.17505765f, 
    0.13131903f, -0.10257701f, 0.15853217f, 0.46169755f, -0.08772789f, 0.12556195f, 0.12604953f, -0.01682633f, 
    0.44349420f, -0.15035465f, -0.00706324f, 0.04809859f, 0.05353797f, 0.12295711f, -0.09522820f, 0.04621824f, 
    -0.08068114f, 0.04415384f, -0.11567888f, -0.02016795f, 0.05276711f, 0.09758242f, -0.07459924f, 0.39166838f, 
    -0.21135134f, -0.11880691f, -0.04170811f, -0.00023669f, -0.03257474f, -0.03031407f, -0.00345377f, 0.03040846f, 
    0.20504719f, -0.06592125f, 0.39445385f, -0.18231276f, -0.01163357f, 0.02616690f, -0.00022804f, -0.15529156f, 
    0.06781054f, -0.05672498f, -0.03797944f, -0.02635866f, -0.13329661f, -0.08124756f, 0.10074330f, 0.35813352f, 
    -0.03840784f, -0.19695410f, 0.17466697f, 0.02745077f, 0.14393552f, 0.13129361f, 0.20268227f, 0.12518720f, 
    -0.04897941f, 0.12893946f, 0.16142909f, -0.11521152f, -0.05304333f, 0.22579411f, 0.08480987f, -0.26265487f, 
    -0.03460595f, 0.03197905f, 0.01727793f, 0.04787768f, 0.18700548f, 0.23197885f, 0.20568033f, -0.32209110f, 
    0.00718870f, 0.03075058f, 0.00078395f, 0.08894461f, -0.15474242f, -0.08855641f, 0.03207028f, 0.00496715f, 
    -0.18804692f, 0.07674561f, 0.02182664f, 0.12654769f, -0.09659977f, -0.11688421f, -0.08231188f, 0.18224299f, 
    -0.01594315f, 0.13812684f, 0.02611145f, -0.05828837f, -0.17320471f, 0.16786562f, 0.07334760f, 0.10943036f, 
    -0.03161404f, -0.07705385f, -0.00799026f, 0.09120531f, -0.02386267f, -0.01265928f, 0.03227725f, 0.14411497f, 
    0.24734844f, -0.14211549f, 0.07259993f, 0.37395284f, 0.06999006f, 0.24309528f, 0.07195068f, 0.03473341f, 
    -0.17986943f, -0.04400784f, 0.00740243f, 0.18928786f, -0.21477889f, 0.10612126f, 0.09918269f, 0.20929810f, 
    -0.07545462f, -0.04042068f, -0.04600559f, -0.08573244f, -0.03433063f, 0.04172319f, -0.00745707f, 0.09843682f, 
    0.25086552f, 0.01344876f, -0.20113342f, 0.05449092f, 0.16775754f, -0.03666344f, 0.02791017f, 0.09519736f, 
    -0.07879864f, -0.04591682f, -0.16213280f, 0.02549252f, -0.01363549f, 0.03376024f, 0.09425636f, -0.08412967f, 
    0.01468352f, 0.14322007f, -0.01872602f, -0.16085871f, 0.04856854f, 0.05796491f, -0.09523184f, 0.13779527f, 
    0.00103479f, -0.12864304f, 0.04045910f, 0.12068715f, -0.21980615f, 0.13049832f, -0.00000460f, 0.04522368f, 
    0.05548099f, -0.02554839f, -0.19921513f, -0.03933533f, 0.12185423f, -0.15175198f, 0.24326330f, 0.23052245f, 
    0.03279402f, 0.03140293f, -0.00846341f, -0.19768038f, 0.03922631f, 0.12653667f, -0.00319390f, 0.23927058f, 
    -0.04212676f, -0.05912025f, 0.23911537f, 0.21275368f, -0.02807726f, -0.07627420f, 0.01401432f, -0.07326656f, 
    0.01749487f, 0.14488542f, -0.04868735f, -0.01166181f, 0.13763589f, 0.03288535f, 0.21558957f, -0.36015823f, 
    -0.00604808f, -0.01036019f, 0.03320830f, -0.02897912f, 0.01341270f, -0.10402559f, -0.01442820f, -0.21838185f, 
    0.41257530f, 0.01360694f, 0.41224515f, 0.09412163f, 0.08957347f, -0.02691085f, -0.03970437f, -0.07689118f, 
    -0.03220207f, -0.12003427f, 0.03693681f, 0.00111567f, -0.14257635f, 0.21827173f, -0.09766801f, 0.24280179f, 
    0.03055106f, 0.01898950f, 0.09896870f, -0.04702003f, -0.02503108f, -0.10814515f, 0.15689808f, 0.02180930f, 
    -0.30050233f, 0.20573084f, 0.22628829f, 0.02352604f, -0.14267012f, -0.17773858f, 0.12307425f, 0.23600772f, 
    0.06318898f, 0.02030726f, -0.01654101f, 0.02426081f, 0.26065177f, 0.18276598f, -0.03871103f, -0.27602857f, 
    -0.06193708f, 0.01675835f, -0.00273401f, -0.07708742f, 0.00331904f, -0.02675914f, -0.00429570f, -0.03570792f, 
    -0.26059058f, 0.25500277f, -0.00719138f, -0.05808116f, 0.01271420f, -0.15200152f, 0.18737045f, 0.08140031f, 
    0.01902663f, -0.01882225f, 0.00593110f, 0.19670379f, -0.06540833f, 0.08751713f, 0.19977657f, 0.25839958f, 
    0.09236059f, 0.03178406f, 0.12962863f, 0.03204426f, 0.02510965f, 0.08555566f, -0.19140862f, -0.08215606f, 
    0.23218720f, -0.02993780f, 0.01368027f, 0.12880093f, -0.15207617f, -0.03271749f, -0.07181831f, -0.01443323f, 
    0.06080214f, -0.01188713f, -0.18878984f, 0.13316461f, -0.08047554f, 0.29626897f, -0.11371565f, 0.11061554f, 
    -0.02641174f, -0.05613104f, 0.05120244f, 0.12704884f, -0.00919604f, -0.03109440f, 0.02388430f, 0.01934520f, 
    -0.39159527f, 0.08248716f, 0.09168726f, 0.23128039f, 0.20963670f, -0.04379359f, -0.02951216f, -0.27804929f, 
    -0.09655150f, -0.12682313f, -0.07241612f, -0.02989267f, -0.34912810f, -0.03084131f, 0.18616237f, 0.07228763f, 
    0.04204132f, -0.08595332f, -0.26562580f, 0.02055834f, -0.01631700f, 0.16290234f, -0.16942693f, 0.26383930f, 
    -0.13506293f, -0.07633556f, -0.15149903f, -0.06272770f, -0.04527573f, -0.08922878f, -0.11255381f, -0.09126593f, 
    0.18905100f, -0.00432462f, 0.05622763f, 0.10714280f, 0.00036685f, 0.28809822f, -0.05227447f, -0.02689574f, 
    -0.12885413f, -0.02465443f, 0.14847335f, -0.08988348f, 0.00951376f, -0.14288335f, 0.10616779f, -0.02534741f, 
    -0.16516964f, 0.11074365f, 0.24081086f, 0.02359428f, -0.04079603f, 0.04655363f, -0.10452028f, 0.07079343f, 
    -0.07546942f, 0.02018344f, -0.04659934f, 0.00705473f, 0.06786459f, 0.17446057f, 0.19597931f, 0.36925191f, 
    0.08620542f, -0.07198208f, -0.02892380f, 0.05940277f, -0.10696481f, 0.02289107f, -0.05671369f, -0.02555028f, 
    0.26159757f, 0.13401188f, 0.27698296f, 0.14169759f, -0.09305283f, 0.01620349f, 0.02601385f, -0.16193068f, 
    -0.08418223f, 0.14777872f, 0.01464220f, 0.04066527f, -0.29934338f, -0.04486242f, 0.23407593f, 0.16157421f, 
    -0.22842349f, -0.00444304f, -0.01869794f, -0.13491873f, -0.01689080f, -0.07133774f, -0.09668594f, -0.04990942f, 
    -0.14739954f, -0.07207764f, 0.20233288f, 0.06922475f, 0.02030360f, -0.10808005f, 0.21279135f, 0.05112665f, 
    0.08669827f, -0.03232611f, 0.04197922f, -0.01199743f, 0.31089363f, 0.15547666f, 0.19947271f, -0.17407997f, 
    -0.15094493f, 0.06455632f, -0.13675946f, 0.10370467f, -0.03773838f, -0.19859675f, -0.06005726f, -0.09293357f, 
    0.02635754f, 0.28460655f, -0.07563817f, -0.05567069f, -0.01954946f, 0.12449260f, 0.07378140f, -0.07895518f, 
    0.01825785f, 0.15194316f, -0.08157690f, 0.03875211f, 0.19771190f, 0.01891155f, 0.32603514f, -0.05312850f, 
    0.00759486f, 0.18902090f, -0.09068029f, -0.07327560f, 0.09662680f, 0.11240630f, 0.19102001f, -0.02079030f, 
    -0.06304787f, -0.04370893f, -0.05150592f, 0.02488511f, -0.18464091f, 0.25410044f, -0.07274202f, 0.31605184f, 
    0.04046550f, -0.11232764f, 0.09075649f, -0.06443362f, 0.08902249f, -0.01022057f, -0.09439949f, 0.23268907f, 
    -0.10244454f, 0.08036274f, 0.12662001f, -0.01637202f, -0.11409424f, 0.02531171f, -0.15653636f, 0.01333085f, 
    -0.16550355f, 0.29541793f, 0.00959686f, 0.23645133f, 0.03806561f, 0.03713074f, -0.02020942f, 0.03321895f, 
    0.03300520f, 0.12663510f, -0.13085303f, 0.15242103f, 0.24823263f, 0.19671218f, -0.25209942f, -0.01365894f, 
    -0.07288482f, 0.15388909f, -0.05870163f, 0.17080261f, -0.15849748f, -0.06950163f, 0.18127698f, -0.20173331f, 
    0.02849899f, -0.02725198f, 0.17649844f, 0.18121873f, -0.09157126f, -0.13160658f, 0.07545053f, -0.13832293f, 
    0.12784636f, -0.16468658f, -0.06928752f, 0.13990444f, 0.16379920f, -0.04658763f, -0.14378442f, 0.39026746f, 
    -0.06285474f, -0.10094723f, -0.07670420f, -0.08594558f, 0.02444187f, 0.02847362f, -0.02434207f, -0.10555726f, 
    -0.41630417f, -0.05663538f, 0.17699757f, 0.20020196f, -0.16709001f, 0.06415319f, -0.00170040f, -0.08108000f, 
    -0.06977239f, -0.00068171f, 0.23581207f, 0.01420573f, 0.30126739f, -0.04446158f, -0.13419478f, -0.02618670f, 
    0.18304539f, -0.17467493f, 0.28104255f, 0.11407661f, -0.00312017f, 0.08824422f, -0.02258725f, 0.05938684f, 
    -0.03493703f, -0.00133604f, 0.14676949f, -0.06390531f, 0.06185248f, 0.06998668f, 0.13951087f, -0.04672235f, 
    0.08255895f, 0.14619485f, 0.07029672f, 0.23385331f, -0.03755110f, 0.14655280f, 0.35757691f, -0.03283534f, 
    -0.02568623f, -0.02187427f, 0.00754476f, 0.04392257f, -0.11281365f, -0.08815230f, -0.18977100f, -0.31113642f, 
    0.01386087f, -0.11913868f, 0.13480307f, 0.01281814f, 0.04025842f, 0.04088989f, 0.03696424f, 0.11502293f, 
    -0.17533660f, -0.17021482f, -0.05957592f, -0.05839514f, 0.02809804f, -0.07589803f, 0.07351417f, 0.05201483f, 
    0.08340684f, -0.06626583f, -0.07281734f, -0.10507979f, 0.01892773f, 0.04150828f, 0.04290357f, 0.09080584f, 
    -0.02465658f, 0.09562460f, -0.10764118f, 0.06079424f, 0.02983479f, -0.11559709f, 0.10446030f, 0.03160566f, 
    -0.02042919f, 0.03420322f, -0.01152724f, 0.01458514f, 0.02522003f, 0.15544428f, 0.01858478f, -0.03624978f, 
    -0.07192016f, -0.10528972f, 0.08411109f, 0.06180467f, -0.02720881f, 0.16713303f, 0.23939489f, 0.15076360f, 
    0.18349621f, -0.03214075f, -0.16128671f, -0.03546619f, -0.02191180f, 0.02917875f, -0.13923851f, 0.05135148f, 
    0.00565294f, -0.18720825f, -0.07550845f, -0.07994346f, -0.04387520f, -0.16919591f, 0.05404262f, 0.11203489f, 
    -0.14879341f, -0.00128620f, -0.02503635f, 0.01527352f, -0.05804330f, -0.19281793f, -0.05863256f, -0.23159073f, 
    -0.02459398f, -0.03777206f, -0.07565307f, -0.02604645f, -0.03619667f, 0.06352538f, 0.02788867f, 0.09684457f, 
    -0.07510231f, -0.09169836f, -0.16671355f, -0.48779929f, -0.27969119f, -0.26101628f, 0.05861740f, 0.03244498f, 
    0.06828810f, 0.04637215f, -0.08881678f, 0.00061175f, -0.05003683f, 0.26519054f, 0.05511788f, -0.21259205f, 
    -0.13519533f, 0.22021523f, -0.03803058f, 0.14788415f, -0.05480147f, -0.06128948f, -0.04614918f, -0.07438724f, 
    0.03214528f, 0.11818830f, 0.13521756f, 0.26753911f, -0.13979876f, -0.03378387f, -0.05691475f, 0.09287591f, 
    -0.03643130f, -0.03966691f, -0.08912350f, -0.06320207f, 0.00862375f, -0.05193442f, 0.07920197f, -0.25441596f, 
    -0.28547940f, 0.00976691f, 0.07240964f, -0.08983953f, -0.04233864f, 0.00500155f, 0.09327313f, 0.05351311f, 
    0.08412206f, -0.00075341f, 0.03966738f, 0.16891350f, -0.08020627f, 0.44201183f, -0.15809533f, -0.05171466f, 
    0.08303539f, 0.18121988f, 0.16089441f, 0.09280985f, -0.16686173f, -0.09845944f, -0.13719003f, -0.10823651f, 
    -0.07816716f, 0.05783792f, -0.07212232f, -0.04404451f, -0.03854780f, -0.02940503f, -0.10316388f, -0.05726410f, 
    -0.10043670f, -0.19202152f, -0.15577285f, -0.15388933f, -0.13481449f, -0.22425228f, -0.03515396f, -0.12216774f, 
    0.03520472f, -0.00769194f, 0.10452476f, 0.10167418f, 0.01610471f, 0.04702878f, -0.01840973f, -0.12787892f, 
    -0.06908298f, -0.10826726f, 0.08119503f, 0.09637317f, 0.06428283f, 0.08149889f, -0.08388699f, 0.09109709f, 
    0.23796256f, -0.02624293f, -0.02082716f, 0.29154232f, 0.00723242f, 0.15472229f, -0.03795123f, 0.06414524f, 
    -0.09391173f, 0.00750520f, -0.06336650f, -0.05847630f, 0.03196365f, 0.15863426f, 0.17562954f, 0.08121553f, 
    0.07023553f, -0.01016224f, 0.20562924f, -0.00115415f, -0.22340031f, 0.13390100f, -0.01980248f, -0.03281517f, 
    0.08042023f, -0.07589772f, 0.03985631f, 0.09818094f, 0.14580114f, 0.02994656f, 0.07247298f, -0.00149771f, 
    0.02408251f, 0.00750720f, 0.14088127f, -0.11284226f, 0.05148273f, 0.04700955f, 0.04829181f, 0.09471720f, 
    0.27820879f, 0.05333063f, 0.01161190f, 0.02175154f, 0.04295831f, -0.05681239f, 0.00898936f, -0.10066907f, 
    -0.09293204f, -0.02587616f, -0.04570103f, -0.09457312f, -0.04582535f, 0.09578177f, -0.16756888f, 0.05417888f, 
    -0.00408104f, -0.02811230f, -0.00682718f, 0.01099401f, -0.02829950f, -0.10666098f, -0.06389699f, 0.09965686f, 
    0.21041207f, -0.03266228f, 0.19778803f, 0.19266841f, -0.13959898f, 0.03239667f, -0.07627805f, 0.03405952f, 
    0.09393908f, -0.01449598f, 0.14969805f, 0.01189705f, -0.19812162f, -0.08105554f, -0.09421095f, 0.18665671f, 
    0.06975601f, 0.09929264f, -0.09371373f, 0.02860907f, 0.14088155f, -0.25686577f, 0.14261793f, -0.06214319f, 
    -0.07943962f, 0.03509446f, 0.07336777f, -0.06547030f, -0.00931909f, -0.13082317f, 0.07494832f, 0.03622895f, 
    -0.00145346f, -0.02204955f, 0.15510842f, 0.12039917f, 0.08598680f, -0.09202568f, 0.05991120f, 0.04454843f, 
    -0.00457979f, -0.04140200f, -0.02558017f, 0.26076141f, -0.14324415f, -0.15342139f, 0.07552409f, 0.00074482f, 
    -0.02463968f, 0.17912735f, 0.02024468f, 0.22463770f, 0.05135685f, 0.02978476f, 0.03196688f, 0.00388422f, 
    0.00159668f, -0.05011881f, -0.21620688f, -0.23192322f, -0.18655762f, 0.09248015f, -0.01427168f, -0.04644040f, 
    0.15778598f, 0.06648690f, -0.18299280f, -0.03951702f, 0.01381394f, 0.11557391f, 0.07218127f, 0.05895071f, 
    0.14602683f, 0.02654677f, 0.10905138f, 0.20163596f, -0.08992092f, 0.00715456f, 0.06960917f, -0.13173130f, 
    0.12285706f, 0.08637228f, 0.07712651f, 0.20230672f, 0.13890974f, 0.18338743f, -0.04977500f, 0.26892233f, 
    -0.17476457f, -0.02982101f, -0.00771027f, -0.14229921f, 0.03451176f, 0.00760694f, 0.13266090f, 0.13697948f, 
    -0.00093320f, 0.25605050f, -0.13733080f, 0.11077643f, -0.01745399f, 0.01877549f, 0.06156199f, 0.02097727f, 
    -0.11242223f, -0.07639758f, -0.00007918f, -0.01351717f, -0.00576666f, -0.18016142f, -0.02011252f, -0.13865286f, 
    0.07186696f, -0.13179432f, 0.09886055f, 0.13684045f, -0.16583036f, -0.00723728f, -0.22525547f, -0.26334953f, 
    -0.00424565f, -0.04321319f, -0.05750202f, 0.02077190f, 0.00310945f, -0.03633779f, 0.03052888f, -0.04763781f, 
    -0.04750626f, 0.01561681f, -0.04023682f, -0.03476490f, 0.02969644f, 0.00660055f, 0.02685086f, 0.03806670f, 
    0.02063863f, -0.01977009f, 0.01964940f, 0.00945613f, -0.03015504f, 0.02423734f, 0.01393973f, -0.01753380f, 
    -0.05946758f, -0.03210113f, 0.00943532f, -0.06118607f, 0.03469402f, -0.01459265f, -0.02096160f, 0.04346720f, 
    -0.04507042f, 0.00795019f, -0.01328904f, -0.05915141f, -0.00086456f, -0.03482558f, 0.03639516f, 0.03117483f, 
    -0.01177821f, 0.02468679f, -0.01072737f, 0.01486925f, -0.03786609f, -0.00268250f, 0.02682297f, -0.03410102f, 
    -0.01047678f, 0.00973545f, 0.01075073f, -0.04908380f, -0.04104921f, 0.01884379f, 0.04022324f, 0.03791912f, 
    0.02750147f, -0.04687426f, 0.03257820f, 0.00393812f, -0.01162785f, 0.02809936f, -0.01383999f, -0.05284546f, 
    -0.04995673f, -0.01231321f, -0.05957175f, -0.03885760f, 0.04721937f, -0.01948743f, 0.02943827f, -0.00176293f, 
    -0.03753148f, 0.00645997f, 0.03603284f, 0.02580440f, -0.00556336f, 0.02703066f, -0.00997496f, -0.05508884f, 
    0.00866832f, 0.00782074f, 0.03054047f, -0.04588584f, 0.00729186f, -0.04366013f, 0.01989103f, -0.05203323f, 
    -0.05679888f, 0.01935826f, -0.00439355f, 0.01078652f, -0.00270367f, 0.02714244f, -0.05879430f, 0.02126777f, 
    0.00682485f, 0.02861342f, -0.03456252f, 0.03589990f, -0.02806004f, 0.01423398f, 0.00966341f, 0.01956881f, 
    0.01475684f, -0.00201422f, 0.00475500f, -0.04587727f, 0.04437201f, -0.01004353f, -0.01583092f, -0.01427255f, 
    0.02277568f, 0.01503476f, -0.02984834f, 0.02529857f, -0.04818229f, -0.04310262f, 0.05176156f, -0.00174539f, 
    -0.03909939f, 0.02561807f, 0.01339112f, 0.03962434f, -0.01922762f, 0.03359236f, -0.01178446f, 0.00657333f, 
    -0.01763089f, 0.03229348f, -0.00616667f, -0.03249125f, -0.01396169f, -0.01665968f, 0.00254985f, 0.01390907f, 
    -0.03439017f, -0.01502161f, -0.04260815f, -0.05664269f, -0.02504233f, -0.03220483f, -0.03800103f, -0.00669113f, 
    -0.01900835f, -0.00422414f, -0.04030337f, -0.00375079f, 0.03530542f, -0.00638798f, -0.00314061f, -0.00023558f, 
    -0.02119154f, -0.02188890f, -0.02218284f, 0.03695760f, -0.03670701f, 0.03330946f, 0.01517729f, 0.00619925f, 
    0.03844418f, 0.02736017f, -0.00690959f, -0.05078268f, 0.00185739f, -0.01909821f, -0.01868019f, 0.01100933f, 
    -0.01773630f, 0.03359156f, 0.00493526f, 0.00087030f, -0.03934641f, 0.03941706f, -0.01566064f, -0.03343583f, 
    -0.00158735f, -0.02516564f, 0.04368463f, -0.03200211f, -0.02754011f, -0.03152887f, -0.04968161f, -0.01603521f, 
    0.04045019f, -0.03490112f, -0.04003000f, -0.00997784f, 0.02018299f, -0.00346639f, 0.00862875f, 0.00430731f, 
    -0.03224024f, 0.02285887f, -0.03781676f, 0.00619555f, 0.02284485f, -0.00580457f, -0.02029043f, -0.00070510f, 
    -0.03370292f, 0.02519936f, -0.00198319f, -0.03768558f, -0.04354197f, -0.00526450f, -0.03864647f, -0.03333828f, 
    -0.00301297f, 0.03611992f, 0.00710262f, 0.04815495f, 0.03053527f, -0.04897713f, -0.02564999f, -0.04622245f, 
    -0.01936215f, -0.03584417f, -0.04954686f, -0.00951578f, 0.03017078f, -0.05906021f, -0.05401781f, -0.00619765f, 
    -0.04072377f, -0.02833535f, -0.04697875f, -0.01181731f, -0.02373490f, -0.00119804f, 0.02453667f, -0.01845138f, 
    0.04086126f, -0.03185903f, -0.05872227f, 0.04295352f, 0.02943521f, 0.02010072f, -0.03398445f, 0.01020326f, 
    0.00634204f, -0.01208908f, 0.02524356f, 0.00802999f, 0.03108646f, -0.05201053f, 0.03903981f, -0.03665379f, 
    -0.04292010f, -0.03177038f, 0.04117440f, 0.00919935f, -0.03644890f, -0.00492180f, 0.00625298f, -0.02915835f, 
    0.02984972f, -0.00910432f, -0.05456234f, -0.00143671f, 0.04213163f, -0.04480527f, 0.02211444f, 0.03156056f, 
    -0.02642119f, -0.04539193f, -0.02434708f, 0.01780408f, 0.01885497f, -0.05884345f, -0.03126594f, -0.05323289f, 
    0.00640989f, -0.04699777f, 0.02964177f, -0.00085108f, 0.00593997f, -0.03359303f, -0.00106179f, -0.00131136f, 
    -0.02209397f, -0.05447315f, -0.04402447f, -0.00737144f, -0.02489090f, 0.04009116f, -0.02087944f, 0.01662677f, 
    0.02791092f, -0.05879162f, -0.02722058f, 0.02663371f, 0.01933072f, -0.02988494f, -0.04203872f, 0.00192652f, 
    0.03374027f, 0.04319685f, -0.01825776f, -0.00922859f, -0.05123256f, 0.02256577f, -0.00298691f, 0.00462840f, 
    -0.03280459f, -0.02779549f, 0.03217643f, -0.03206058f, 0.03642257f, -0.02730568f, 0.02582612f, -0.01911217f, 
    0.00823244f, -0.05512930f, -0.01733710f, -0.01253805f, -0.04770057f, -0.00764326f, -0.02013212f, 0.00752835f, 
    0.03210441f, 0.01499829f, 0.01691334f, -0.00015539f, 0.02738210f, -0.02416772f, -0.03515967f, 0.01119714f, 
    -0.00722679f, -0.01222477f, 0.01982578f, 0.02577153f, -0.02372314f, -0.01585991f, -0.01195000f, -0.03009191f, 
    -0.02892518f, 0.02143805f, -0.03701867f, -0.02074295f, -0.04363728f, -0.00216256f, -0.03498300f, -0.05094998f, 
    -0.01988733f, -0.01032052f, -0.00795280f, -0.00552346f, 0.01853623f, 0.02709740f, -0.00649252f, -0.03396474f, 
    0.02175670f, -0.02703629f, 0.03771931f, 0.00497577f, 0.03379892f, -0.05528335f, -0.02109534f, -0.01543936f, 
    -0.03944305f, 0.03044022f, -0.01998933f, -0.05307989f, -0.05289764f, -0.02776937f, 0.01210122f, -0.02761040f, 
    0.00079495f, -0.02143976f, 0.01350822f, -0.05986419f, -0.02594399f, -0.00748177f, 0.00999571f, 0.03094953f, 
    -0.01893778f, -0.02496113f, -0.04313348f, -0.02461591f, 0.00725754f, -0.02306862f, 0.00018373f, -0.04873909f, 
    -0.21421163f, 0.08809039f, -0.05217829f, 0.30135590f, -0.02379879f, 0.10657199f, 0.14128383f, 0.02731043f, 
    -0.00109471f, 0.11746156f, 0.16815390f, 0.05762884f, -0.19702373f, -0.02464924f, 0.13264880f, -0.00450141f, 
    -0.05176770f, -0.08592265f, -0.04333344f, 0.08657593f, -0.22743189f, 0.01925437f, -0.01000163f, -0.22433242f, 
    -0.07106329f, -0.24255608f, -0.02177047f, 0.09690705f, 0.00599374f, 0.20643285f, -0.02463199f, -0.02761154f, 
    0.04012320f, -0.09686613f, -0.07919377f, 0.11982486f, 0.20531543f, 0.01061540f, -0.06452978f, -0.04267346f, 
    -0.03060750f, -0.04919042f, -0.02598030f, 0.05505503f, 0.00616347f, -0.06209102f, 0.04769432f, 0.22082505f, 
    0.43505508f, -0.42577690f, -0.10707648f, -0.32506943f, 0.02711555f, -0.06921550f, 0.09781127f, -0.21912207f, 
    -0.00455747f, 0.05086603f, -0.07609850f, 0.24799192f, -0.13122085f, 0.09709765f, 0.13857503f, 0.19528596f, 
    0.09773806f, 0.05859110f, 0.18273000f, 0.28005075f, -0.00636885f, 0.08872960f, 0.11163780f, 0.06773490f, 
    -0.32636613f, 0.47371513f, 0.27868268f, 0.11211813f, -0.11976144f, 0.08773790f, 0.10278349f, 0.01016527f, 
    0.10255597f, 0.03485018f, -0.17912413f, -0.15814905f, 0.39839461f, 0.01782593f, -0.21516909f, -0.14829545f, 
    0.08986232f, -0.16895066f, -0.11931407f, -0.12059475f, -0.03256365f, 0.00154632f, -0.04620737f, 0.01457045f, 
    0.25493452f, 0.34642345f, 0.24273829f, -0.11011002f, 0.00137240f, -0.07520811f, -0.08705144f, 0.00635353f, 
    0.00985505f, 0.03717126f, -0.05300280f, 0.05067430f, -0.06519213f, 0.35934669f, 0.16513643f, 0.09370295f, 
    -0.06453942f, 0.03966337f, -0.00970146f, -0.07373735f, -0.18396729f, 0.08329010f, 0.14901209f, -0.00213982f, 
    0.49769235f, -0.05508417f, -0.15213627f, 0.00447895f, -0.06952643f, -0.14081883f, 0.01402923f, -0.01255846f, 
    0.03881118f, 0.04595893f, 0.02740529f, -0.13797623f, 0.34683719f, 0.23518735f, -0.00738014f, 0.05242595f, 
    -0.02059885f, -0.12002616f, -0.14720765f, 0.06016332f, 0.01350708f, -0.25695154f, -0.08429456f, -0.07090835f, 
    0.41558686f, -0.07293712f, 0.45659029f, -0.14241713f, -0.17699608f, -0.20419675f, 0.13034153f, 0.07282870f, 
    0.03136773f, -0.01797686f, 0.03244389f, -0.00529333f, -0.47048983f, -0.14968516f, -0.00390237f, -0.01349686f, 
    -0.07671636f, 0.12485160f, 0.12225277f, 0.10388723f, 0.04121495f, 0.11375751f, 0.12904090f, -0.21112981f, 
    0.12485777f, 0.08456562f, 0.14970519f, 0.04714040f, -0.01965808f, -0.13181636f, -0.09985907f, -0.15962358f, 
    -0.01452852f, -0.05367190f, 0.04441818f, -0.10129901f, -0.10958890f, 0.23606899f, 0.04730105f, -0.14496876f, 
    -0.18311422f, -0.03594342f, -0.03835311f, 0.14909422f, -0.16027418f, 0.03535993f, 0.10955349f, -0.03185974f, 
    0.09120344f, 0.29731497f, 0.11285019f, 0.07886353f, -0.10808308f, 0.11616097f, 0.17521134f, 0.04658154f, 
    0.19199504f, 0.04284621f, -0.12826240f, -0.05064296f, -0.12501107f, 0.40546551f, 0.00397733f, -0.14626250f, 
    0.15286635f, -0.08841768f, 0.14618751f, 0.14605778f, 0.23105358f, 0.07293555f, 0.25362113f, -0.07526536f, 
    0.07718319f, -0.17350365f, -0.03185255f, 0.49110723f, 0.05439255f, -0.08662973f, 0.02611530f, -0.01841478f, 
    0.08907587f, 0.17767633f, 0.17044815f, -0.31895545f, -0.67014438f, -0.10036897f, -0.12875375f, -0.02207894f, 
    0.01573959f, 0.12791125f, -0.09254476f, 0.01695482f, -0.24122931f, -0.08694584f, 0.09718545f, 0.17015417f, 
    -0.10608999f, 0.11103531f, 0.27305606f, 0.05717260f, 0.16049007f, 0.03716258f, -0.04611599f, 0.06508857f, 
    -0.03387059f, 0.04995655f, -0.14707625f, -0.21796419f, -0.14369868f, -0.33440709f, -0.39856666f, -0.14997603f, 
    -0.12446979f, -0.06813069f, -0.00064244f, -0.26523283f, -0.02496255f, 0.03527825f, 0.02037614f, 0.08278123f, 
    -0.23068136f, -0.01915681f, 0.00559737f, 0.10742097f, -0.08506270f, 0.10024359f, -0.05432257f, 0.21566567f, 
    0.02907102f, 0.27595130f, 0.08473559f, -0.05178598f, 0.30544192f, -0.23857830f, 0.02199084f, 0.01481068f, 
    0.11860960f, -0.12020908f, 0.08616582f, -0.14108506f, 0.13686116f, 0.19474214f, 0.06417501f, 0.24453619f, 
    0.00164426f, 0.01036441f, 0.01420734f, 0.07394534f, 0.02286194f, 0.02606549f, 0.00104932f, 0.12885262f, 
    0.18684283f, 0.12349787f, -0.03084176f, 0.12388988f, -0.43109405f, 0.06067074f, -0.12958707f, 0.10179015f, 
    -0.06244688f, 0.24630959f, -0.10454295f, 0.15195245f, -0.07830305f, 0.10098545f, 0.02157674f, 0.02173929f, 
    0.23746535f, 0.24683495f, -0.13850106f, -0.03960603f, 0.06274252f, -0.05053286f, -0.03268361f, -0.01858953f, 
    -0.04505664f, 0.19403122f, 0.10726126f, -0.19043308f, 0.14999546f, -0.03454575f, -0.03521750f, -0.00620648f, 
    -0.02701052f, 0.04068245f, 0.07606160f, 0.00167950f, -0.10706528f, -0.03347518f, 0.11322825f, 0.01310984f, 
    -0.01745968f, -0.21320911f, 0.12704070f, -0.19916101f, 0.07753216f, -0.09409322f, 0.04987419f, 0.26059827f, 
    -0.02207702f, -0.14218920f, -0.03147967f, 0.17326115f, -0.15983008f, 0.35008222f, -0.00866847f, -0.00917969f, 
    0.03747603f, 0.03447096f, -0.01332807f, -0.09649549f, -0.04231944f, -0.00060508f, 0.04184552f, 0.17806168f, 
    -0.29535970f, -0.30516493f, 0.16832036f, 0.02461737f, 0.08927683f, -0.09518728f, -0.05162127f, -0.02910026f, 
    -0.03035906f, -0.14211142f, 0.01408705f, -0.02272085f, 0.00880730f, -0.11040869f, 0.06220507f, -0.02338826f, 
    0.00632995f, -0.00852052f, -0.08227820f, 0.16853155f, -0.03942852f, 0.13408148f, -0.03889047f, -0.16212007f, 
    0.04261663f, -0.09231306f, 0.08674446f, -0.19456778f, 0.06959212f, 0.02285938f, -0.00072605f, 0.02957302f, 
    0.02861145f, 0.12116748f, 0.15387434f, -0.06471732f, 0.31761542f, 0.10059223f, 0.15198360f, -0.10330489f, 
    0.04996301f, 0.14778228f, 0.01780927f, 0.08598256f, 0.09998800f, -0.01710593f, 0.04738136f, -0.06799775f, 
    -0.23919421f, -0.23549829f, -0.09499042f, 0.18437745f, -0.10488614f, 0.06216878f, 0.06390440f, 0.05999834f, 
    -0.01764858f, -0.02244995f, -0.07522612f, 0.09687225f, -0.07269473f, -0.06855444f, 0.12260184f, 0.03694150f, 
    -0.08353490f, 0.05509927f, -0.05738512f, -0.03703189f, -0.01159838f, 0.21177703f, 0.11301155f, 0.04220325f, 
    -0.19681448f, 0.02793262f, 0.42681766f, -0.02269209f, -0.03350151f, -0.09728543f, -0.15159689f, 0.06237664f, 
    -0.14449321f, -0.04139411f, 0.02204805f, 0.06108713f, -0.22643679f, 0.30218226f, -0.27829018f, 0.15221952f, 
    -0.06440352f, -0.08916420f, 0.18206909f, 0.03303985f, -0.00604204f, 0.06937632f, 0.03752837f, 0.24247220f, 
    0.21031529f, -0.08539012f, -0.01379256f, 0.11543726f, 0.04135293f, 0.00597343f, -0.04614039f, 0.09479397f, 
    -0.03521213f, 0.09233668f, 0.03383696f, 0.04065011f, -0.01117712f, 0.17597666f, 0.21357545f, 0.11606203f, 
    -0.13529693f, 0.03412766f, -0.07481476f, -0.06552785f, -0.26423785f, -0.05105106f, -0.05611595f, -0.02791391f, 
    -0.08638133f, -0.06595108f, -0.09625360f, 0.08939766f, 0.02957453f, 0.06793168f, 0.12216969f, 0.07038478f, 
    -0.02077546f, 0.04010195f, 0.00275950f, -0.14765385f, -0.24478853f, -0.16114160f, 0.05680686f, 0.12871891f, 
    0.06913511f, 0.14410549f, 0.07252547f, -0.07232201f, 0.00276013f, 0.10161787f, -0.06708328f, -0.09332725f, 
    -0.31766638f, 0.10487849f, 0.09860522f, 0.09925073f, -0.08984354f, -0.03487999f, -0.17725430f, -0.02292959f, 
    -0.13650252f, -0.04606660f, -0.00106112f, 0.11962494f, -0.19716400f, 0.20833084f, -0.06006771f, 0.09213109f, 
    -0.14687933f, -0.00270181f, -0.07110881f, -0.11886032f, -0.10506126f, -0.00129698f, 0.03143397f, -0.14155020f, 
    -0.11483940f, 0.14656976f, -0.10850509f, 0.11953253f, 0.04851306f, 0.03665170f, -0.04263170f, 0.04319801f, 
    0.03962465f, -0.00101007f, 0.06714169f, 0.11501039f, 0.15175582f, 0.28476641f, -0.40282336f, -0.19982208f, 
    0.16132179f, 0.06586864f, 0.20163603f, 0.08129381f, -0.06089268f, -0.02994867f, 0.09979568f, -0.12259334f, 
    -0.18791077f, 0.04266813f, -0.15349863f, -0.07667121f, -0.09176549f, -0.12888707f, -0.06788298f, -0.09058527f, 
    -0.13622262f, -0.04160203f, -0.11679686f, -0.10224959f, -0.06548066f, -0.21704839f, -0.19739141f, -0.02040462f, 
    0.06686093f, 0.04529367f, -0.00190921f, 0.06173022f, 0.01119579f, 0.02425971f, -0.11879211f, -0.11377250f, 
    -0.20825231f, -0.00266567f, 0.05130439f, 0.13192610f, 0.25498399f, 0.05075482f, 0.16821754f, 0.03139455f, 
    0.15635557f, 0.03416183f, 0.11860118f, 0.24806523f, -0.09087348f, -0.11186808f, 0.28694764f, 0.05510139f, 
    -0.04929631f, 0.02733085f, 0.10287564f, 0.05750298f, -0.02195901f, -0.02647240f, 0.05720048f, 0.16218594f, 
    0.40376464f, 0.19789670f, 0.20349365f, -0.17601797f, -0.07611487f, 0.01133911f, 0.08738536f, -0.01428763f, 
    0.12157166f, 0.22221699f, 0.00335362f, 0.08157789f, -0.07099089f, -0.14266413f, -0.17114729f, 0.09754636f, 
    -0.11225167f, 0.04919642f, -0.03073097f, 0.08006816f, 0.14104074f, 0.02807887f, 0.02436328f, 0.11003041f, 
    0.36919942f, -0.23684284f, 0.09358761f, 0.15048029f, -0.08746888f, -0.02504253f, -0.07639736f, -0.16591528f, 
    -0.03083402f, 0.04237665f, 0.03765777f, 0.04669293f, -0.02394911f, 0.19325472f, 0.06682406f, 0.16907693f, 
    -0.09204013f, 0.00674482f, 0.00404708f, 0.02305235f, -0.11202060f, -0.03257597f, -0.02131224f, 0.11325862f, 
    0.34990674f, 0.12131069f, 0.14048280f, -0.15522996f, 0.06246562f, 0.09533633f, -0.02579272f, -0.11751833f, 
    0.17386612f, 0.08572637f, 0.08236924f, 0.08627368f, -0.03373253f, -0.26156905f, 0.23718351f, -0.02758936f, 
    -0.08345616f, -0.08299103f, 0.21797782f, 0.15071881f, 0.10209621f, 0.08516195f, 0.13433963f, -0.01147534f, 
    0.02892731f, -0.05468924f, 0.05233625f, -0.11145117f, -0.16436154f, 0.05277467f, 0.02132079f, 0.02052130f, 
    -0.02934847f, 0.07478528f, 0.18308124f, -0.03691664f, 0.18494920f, -0.03676418f, -0.13035224f, 0.05237743f, 
    0.16530529f, -0.07494611f, 0.01230150f, 0.08978510f, -0.07381426f, -0.01872967f, 0.07739830f, 0.13545255f, 
    -0.30318344f, 0.16832781f, 0.29778031f, 0.26426679f, 0.05213099f, 0.06685739f, -0.07918230f, -0.05181536f, 
    0.08216428f, 0.12693033f, 0.02407342f, -0.16078064f, -0.16186303f, 0.14597356f, -0.09926083f, 0.05806215f, 
    -0.21394831f, 0.15162401f, -0.08413353f, 0.10346147f, -0.08637206f, 0.06435840f, 0.10789017f, 0.20789599f, 
    0.10363159f, -0.20316283f, 0.09625560f, 0.26124349f, -0.17721924f, 0.05646886f, -0.02725382f, 0.11049908f, 
    0.02616385f, 0.16524316f, 0.08314716f, 0.19645089f, -0.13370830f, 0.15982841f, 0.11532483f, 0.24811253f, 
    -0.06038995f, -0.12466760f, -0.05224140f, -0.10273618f, -0.08705987f, 0.10946042f, -0.13211128f, 0.13030615f, 
    -0.20036221f, 0.25592047f, -0.28440818f, 0.29269361f, 0.00285615f, 0.09183118f, 0.10607143f, -0.07856624f, 
    0.02634408f, 0.09743296f, -0.10451110f, 0.03110241f, 0.38705987f, -0.27435550f, 0.18574138f, -0.14192542f, 
    0.06759931f, 0.02929245f, 0.13646993f, 0.11724323f, -0.09474231f, 0.01756663f, 0.02948013f, -0.20164455f, 
    -0.15409006f, -0.06107482f, -0.02477142f, 0.10737123f, -0.03576028f, 0.08966682f, 0.07706409f, 0.07144502f, 
    0.06926801f, -0.06550261f, -0.03394150f, -0.00772037f, 0.08652296f, 0.14564286f, 0.12773959f, 0.13130163f, 
    -0.02453433f, 0.03294261f, 0.03098677f, -0.14169960f, 0.12723082f, 0.00187100f, 0.11046898f, 0.36439925f, 
    0.06516133f, 0.23164469f, 0.09816675f, 0.28464612f, -0.01829513f, 0.01413364f, 0.05643821f, 0.04608135f, 
    0.10998929f, 0.16670923f, -0.05534565f, -0.06650182f, 0.04663040f, -0.02829884f, 0.12426066f, -0.25479475f, 
    0.00615829f, 0.05271602f, 0.04163462f, 0.14965118f, 0.04527498f, -0.11439493f, 0.07971662f, -0.01514515f, 
    -0.02659396f, -0.23775339f, 0.14547141f, -0.07158238f, 0.00772760f, 0.17268232f, 0.23474999f, -0.08482441f, 
    -0.02799059f, 0.01895664f, -0.04348214f, -0.06926999f, -0.10511436f, 0.14596194f, -0.03426764f, 0.24164122f, 
    0.02870350f, 0.03016943f, -0.05474791f, -0.05831332f, -0.07508291f, -0.17893387f, -0.04168940f, -0.05119053f, 
    0.00225103f, 0.21833055f, 0.18256661f, 0.07241467f, 0.08261952f, 0.07208442f, 0.05032738f, 0.01918749f, 
    0.07188448f, 0.16150397f, 0.01341569f, 0.05603734f, 0.16724886f, -0.14644614f, -0.02149649f, -0.30523136f, 
    0.12555774f, -0.05804241f, 0.10915492f, -0.04749707f, 0.02749616f, -0.08511075f, -0.08283396f, 0.03371772f, 
    0.06461225f, 0.19477737f, 0.04668579f, -0.03016628f, 0.09440647f, -0.01679298f, 0.15665881f, 0.13486856f, 
    0.15193030f, -0.02993972f, -0.03622437f, 0.23186824f, 0.00913428f, 0.61118090f, 0.40744436f, 0.25923929f, 
    -0.04426511f, -0.07573536f, 0.07746632f, -0.07585388f, 0.02546189f, 0.02361474f, -0.01020212f, 0.06254341f, 
    0.22018610f, -0.14944628f, -0.17643127f, -0.03170557f, -0.08056501f, -0.02548751f, 0.06380134f, -0.06546681f, 
    -0.03361501f, -0.05513205f, -0.12147287f, 0.01865393f, 0.04371998f, -0.02201034f, -0.13927069f, 0.18287328f, 
    -0.02572901f, -0.02648039f, -0.08277202f, 0.09721857f, -0.15541318f, -0.03408356f, -0.04592247f, 0.09703992f, 
    0.31168172f, 0.26628831f, 0.22473271f, 0.25667018f, 0.19786553f, -0.05478982f, -0.05490822f, -0.27298805f, 
    -0.14536715f, 0.00156602f, -0.08695848f, -0.11896686f, -0.31130862f, -0.03050230f, 0.08363272f, 0.21851069f, 
    -0.14460976f, 0.13440336f, -0.29792827f, 0.06327891f, 0.07772099f, 0.14576264f, -0.12453602f, 0.13334356f, 
    -0.04511376f, -0.07720620f, -0.12095316f, -0.06155280f, 0.01745845f, -0.04615776f, -0.06367948f, -0.10536166f, 
    0.09496976f, 0.12539281f, 0.18911982f, 0.16302221f, 0.31498116f, 0.64513189f, 0.24329713f, 0.07927148f, 
    -0.14453968f, -0.12230368f, 0.01083004f, -0.10682762f, -0.08384696f, -0.08289351f, 0.08440702f, 0.19373612f, 
    0.14629774f, 0.17520292f, 0.13371147f, 0.14773421f, 0.02096531f, -0.03859621f, -0.02450808f, 0.12239009f, 
    -0.18593596f, -0.01595894f, 0.05602562f, -0.10363822f, -0.14791684f, 0.23499727f, -0.13297908f, 0.18042812f, 
    -0.00277842f, -0.05719516f, 0.20370132f, 0.01814342f, -0.04196872f, 0.06824026f, -0.17588586f, -0.01496660f, 
    -0.04183748f, 0.03546240f, -0.00801898f, 0.15603931f, 0.05741550f, 0.06647770f, -0.02103218f, -0.11423282f, 
    -0.04035187f, 0.11991586f, -0.01806232f, -0.00021973f, -0.10944417f, 0.08838456f, 0.15461233f, 0.09077442f, 
    -0.04531156f, -0.02179010f, 0.09901757f, 0.18338075f, -0.20545079f, -0.05735230f, -0.04489651f, -0.07702871f, 
    -0.05421654f, -0.08454028f, 0.17514317f, 0.15516505f, 0.02859422f, -0.00868590f, 0.05128534f, 0.07072962f, 
    0.10756901f, 0.10434877f, 0.12072755f, 0.00531870f, -0.05521509f, -0.29186037f, -0.00238245f, 0.07092252f, 
    0.03321334f, 0.21769480f, 0.08629607f, 0.13170534f, -0.04701938f, -0.07824295f, -0.01546752f, -0.08120441f, 
    -0.26833364f, 0.19303431f, 0.13605641f, -0.19831556f, 0.05379767f, 0.08280645f, 0.02556220f, -0.15797319f, 
    0.02677114f, 0.04907683f, -0.13190083f, 0.13879725f, 0.30377072f, -0.05726634f, 0.11025166f, 0.24611047f, 
    -0.07249812f, -0.11908814f, 0.15421805f, -0.23632191f, -0.03647959f, 0.18362579f, -0.03578279f, 0.13386291f, 
    -0.14042313f, 0.01194697f, -0.05915810f, 0.01258324f, -0.03927607f, 0.12729017f, 0.11376633f, 0.03097696f, 
    0.06350917f, 0.04676413f, 0.10351431f, 0.13813992f, -0.14255850f, 0.24913287f, -0.00473459f, 0.04969719f, 
    -0.17526866f, -0.07268906f, 0.05068161f, -0.06431427f, -0.07328287f, -0.02231466f, -0.04082755f, 0.11509879f, 
    -0.11547379f, 0.19539697f, -0.12896118f, 0.16741826f, -0.11946665f, -0.13959955f, 0.15803364f, -0.06381044f, 
    -0.14256255f, 0.15810679f, -0.12074670f, 0.09490830f, 0.02459957f, -0.00243834f, -0.21681501f, -0.00896116f, 
    -0.00558669f, 0.00123122f, 0.15393357f, 0.04960454f, -0.03073850f, -0.06796025f, -0.02846660f, -0.06579929f, 
    0.22739656f, -0.01173161f, 0.27640891f, 0.12013081f, -0.04630047f, -0.09476012f, -0.01148644f, 0.08720649f, 
    -0.00811859f, -0.14810155f, -0.04804237f, 0.12079068f, -0.14395580f, -0.06120415f, -0.39575121f, 0.25877801f, 
    -0.00075026f, 0.12670724f, 0.01302000f, 0.01725298f, -0.01482804f, 0.00737702f, -0.07759376f, -0.16665912f, 
    -0.16640581f, -0.39075863f, 0.14262538f, 0.04242952f, -0.01689405f, -0.04254415f, -0.20841056f, -0.02217975f, 
    0.09294922f, 0.05149892f, 0.06725343f, 0.18462297f, 0.23079166f, -0.04906218f, -0.03483394f, -0.03256252f, 
    0.10276738f, -0.13155316f, 0.08532645f, -0.05655919f, 0.23466678f, 0.14689754f, 0.06511150f, 0.22929230f, 
    0.09934118f, -0.02913683f, -0.03213373f, 0.11479422f, 0.02068220f, 0.01092493f, -0.02132648f, 0.10342363f, 
    0.20633908f, -0.00319138f, 0.04031608f, -0.03185638f, -0.08862170f, -0.11324523f, -0.14027154f, 0.24611479f, 
    0.09492295f, 0.14808796f, -0.01979134f, -0.17624451f, 0.21841909f, 0.09668051f, 0.20856439f, 0.30755511f, 
    0.02570405f, 0.26506770f, 0.41835520f, -0.08192360f, 0.00938468f, -0.00285025f, 0.10169513f, -0.00517329f, 
    0.01303733f, 0.10204690f, -0.08335842f, -0.11458964f, -0.10484429f, 0.06062729f, -0.06666563f, -0.16191469f, 
    0.14948192f, 0.05455118f, 0.00361179f, 0.05758426f, 0.18900983f, -0.08328903f, 0.06951678f, -0.14458807f, 
    0.04899322f, 0.06083367f, -0.17813072f, -0.00895590f, 0.05214182f, 0.13178864f, 0.11623795f, 0.03704884f, 
    0.13839263f, 0.00353053f, -0.00615685f, -0.13036552f, 0.15636165f, -0.12019444f, 0.27559784f, 0.02749981f, 
    0.13726932f, 0.11416353f, -0.22970761f, -0.03596278f, 0.04858870f, -0.10231308f, -0.04039274f, 0.04234650f, 
    -0.13595669f, 0.16056731f, 0.14128070f, 0.08892134f, 0.18097964f, -0.17136066f, 0.00321108f, 0.19672573f, 
    0.00072514f, -0.06082137f, 0.09989780f, 0.11362711f, -0.29069537f, 0.08032596f, 0.12795551f, -0.27777967f, 
    0.00285299f, 0.14901112f, 0.25648910f, 0.05576615f, 0.25065273f, 0.17004433f, -0.02203883f, 0.13025711f, 
    -0.04674943f, 0.13335471f, 0.11250940f, 0.02345730f, -0.08419586f, -0.03220540f, 0.15492602f, 0.07286543f, 
    0.09343594f, 0.14699306f, 0.11366206f, 0.13158917f, -0.04150797f, -0.03026358f, 0.17256460f, 0.20726018f, 
    -0.03315394f, -0.13875565f, -0.04870955f, 0.16304430f, 0.19214973f, -0.04790485f, 0.12171928f, 0.20301878f, 
    0.01343898f, -0.00938461f, -0.04961631f, -0.14816166f, -0.02743309f, 0.01643685f, 0.06512263f, -0.10236128f, 
    0.09094428f, 0.03077961f, 0.00748504f, 0.18336913f, -0.10828517f, -0.19184469f, 0.01109609f, -0.10912866f, 
    -0.00590614f, 0.13133945f, -0.02698241f, 0.03563462f, 0.03875353f, 0.33391237f, 0.10698821f, 0.15938386f, 
    -0.39614961f, -0.02409247f, 0.38310188f, 0.20999710f, 0.17169997f, 0.10108151f, -0.28678074f, -0.11418207f, 
    -0.00199141f, 0.09544134f, 0.00918972f, 0.00708262f, -0.22046307f, -0.03552470f, 0.23516515f, 0.38504037f, 
    0.17717625f, -0.12263113f, -0.18504959f, 0.09183563f, 0.04762626f, 0.05127697f, 0.08644798f, 0.10384244f, 
    -0.10082521f, -0.15792908f, -0.13353050f, -0.15075491f, -0.02459399f, 0.00032578f, 0.01774281f, -0.04016756f, 
    0.21841741f, 0.11129149f, 0.16944747f, 0.19144364f, 0.09488533f, 0.35004097f, 0.26743472f, 0.28859431f, 
    -0.14646369f, -0.23435789f, -0.13878904f, 0.00476507f, 0.09347887f, 0.08817426f, -0.02129094f, 0.07513750f, 
    0.11792587f, 0.12967411f, 0.28030777f, 0.07269091f, -0.09177282f, -0.12350072f, -0.08044016f, 0.22759771f, 
    -0.16521415f, 0.18048503f, 0.05669870f, 0.05813242f, 0.13128342f, 0.10400581f, -0.22459218f, 0.05159755f, 
    0.01064080f, 0.08998057f, 0.06015999f, -0.21247290f, 0.09450574f, 0.07717200f, 0.05234114f, 0.03640575f, 
    0.01909617f, -0.04716820f, 0.14407896f, -0.16303134f, 0.15739611f, 0.17275730f, -0.12098368f, -0.10239360f, 
    0.17127807f, -0.02525222f, 0.10018800f, 0.24105243f, 0.12066446f, -0.22558211f, 0.11185673f, 0.10075770f, 
    -0.00294529f, -0.01871773f, 0.12004790f, 0.01910812f, 0.09351759f, -0.07396526f, -0.06722549f, -0.16443475f, 
    -0.17943501f, 0.11717081f, -0.02037233f, -0.02243830f, -0.07763305f, -0.01419205f, 0.17799844f, 0.17629279f, 
    0.03222471f, -0.07419068f, 0.05633644f, 0.04461818f, -0.23736855f, -0.20454760f, 0.42151305f, -0.09624434f, 
    0.37393323f, 0.11951777f, 0.07032897f, 0.12564524f, -0.04237313f, -0.09331533f, -0.03085213f, -0.21294960f, 
    0.04479183f, 0.28978553f, -0.17229748f, 0.14761029f, 0.05240124f, -0.03566502f, -0.13656503f, -0.08507878f, 
    0.18781126f, 0.05423920f, 0.17243177f, 0.13748772f, -0.08441866f, 0.22353132f, -0.01177916f, -0.28864720f, 
    -0.08530413f, 0.04624203f, -0.06190443f, -0.14351584f, 0.04420532f, 0.09331921f, 0.00287280f, 0.03642129f, 
    -0.09252462f, -0.10514250f, -0.21764548f, -0.03751226f, 0.05453589f, -0.14827098f, 0.05376565f, -0.02726655f, 
    0.07195932f, 0.10764101f, 0.08199291f, 0.08231381f, 0.11190940f, -0.06443700f, 0.02371815f, 0.27449346f, 
    -0.01133386f, -0.17066023f, -0.00771293f, 0.04689819f, 0.05757121f, 0.04494489f, -0.05325060f, 0.00771524f, 
    -0.03468410f, -0.08674818f, 0.10091145f, -0.08458998f, -0.00326321f, 0.07651734f, 0.03850119f, -0.19443455f, 
    0.06768178f, -0.05595497f, 0.00635274f, 0.21666576f, -0.06900088f, -0.28481525f, 0.05687967f, -0.25333020f, 
    0.24927123f, 0.12922902f, 0.01235744f, -0.05480501f, 0.03086620f, 0.00478574f, -0.13061273f, -0.05904642f, 
    -0.06259374f, 0.27025914f, 0.08381063f, -0.12381562f, -0.00235796f, -0.09434587f, 0.00337607f, -0.10222558f, 
    0.16065072f, 0.05387438f, -0.05597213f, -0.00745547f, 0.11190781f, -0.20894958f, -0.15450580f, 0.14534357f, 
    -0.06118222f, 0.03123517f, -0.10716891f, 0.04275565f, 0.04693768f, 0.03540986f, 0.07505268f, -0.25287700f, 
    -0.15529960f, 0.05993346f, 0.14716455f, -0.02999855f, -0.06418934f, 0.05716832f, -0.13172001f, 0.09925231f, 
    -0.01173169f, -0.01702394f, 0.16521734f, 0.11430669f, 0.06588089f, 0.14512374f, -0.22536987f, 0.10749630f, 
    0.01965905f, 0.08868819f, 0.21021043f, 0.20910569f, 0.18144812f, 0.08627975f, 0.16681449f, 0.36952519f, 
    -0.02497535f, 0.08274107f, 0.01098278f, 0.24418093f, 0.06064885f, 0.11104823f, -0.02693169f, -0.03391013f, 
    0.13350590f, 0.07959490f, 0.03988212f, 0.21625787f, -0.20791182f, -0.21839948f, 0.04200104f, 0.05640332f, 
    0.16875595f, -0.00718450f, 0.11278699f, -0.09342174f, 0.04559244f, 0.21196258f, -0.08277708f, 0.02601536f, 
    0.44510177f, 0.37627855f, 0.32382548f, -0.14806725f, -0.19001687f, -0.02525659f, 0.00228842f, 0.14827102f, 
    -0.04276418f, 0.03080218f, -0.07277440f, -0.06388765f, -0.12495704f, 0.00345682f, -0.00588335f, -0.14803399f, 
    0.10772054f, 0.05316969f, -0.01205217f, 0.02581278f, -0.03633932f, -0.12850408f, 0.04225701f, 0.12931959f, 
    0.19529283f, -0.00835663f, -0.16660269f, 0.00048242f, 0.08485412f, 0.13119453f, 0.11063064f, 0.03026966f, 
    -0.04323850f, 0.09003654f, -0.01087314f, 0.02487368f, 0.16961728f, 0.04569610f, 0.11598667f, 0.10355058f, 
    0.07945947f, 0.16811688f, 0.00457920f, 0.07732785f, 0.10513135f, 0.08127226f, 0.03747426f, 0.08230858f, 
    -0.12807783f, 0.29865623f, 0.21856205f, -0.11139964f, 0.09738048f, 0.00811448f, -0.02265671f, 0.04299834f, 
    -0.07023024f, -0.15404497f, 0.02317452f, -0.15521099f, -0.30243421f, -0.17847548f, -0.27820894f, -0.27690086f, 
    -0.05826065f, 0.10446601f, -0.04647357f, 0.07713128f, 0.11417796f, 0.17245914f, -0.01734136f, -0.03851807f, 
    0.14456142f, 0.34399325f, 0.09181254f, -0.19923122f, 0.09227053f, -0.03898209f, 0.05479517f, 0.15478691f, 
    -0.02333392f, 0.04345952f, -0.00724614f, -0.02686310f, -0.28299433f, -0.03999151f, -0.07525209f, 0.15823872f, 
    0.00697477f, -0.01491050f, -0.03319569f, 0.00485768f, 0.18644145f, 0.08291425f, 0.07732841f, 0.01787792f, 
    -0.13148965f, -0.09762432f, -0.05729073f, -0.06624050f, -0.11321202f, -0.07928436f, -0.01653680f, -0.07416899f, 
    -0.03831375f, 0.14583908f, 0.17030117f, 0.16103527f, -0.06977930f, -0.23466812f, -0.20277488f, -0.01083528f, 
    0.07938772f, -0.11175705f, -0.08792073f, 0.07476033f, -0.02833809f, -0.03090817f, 0.15094449f, 0.05948861f, 
    -0.12338269f, 0.19933888f, 0.20964925f, 0.11584371f, 0.05370272f, -0.02768447f, -0.01499331f, -0.14774226f, 
    0.14131935f, -0.05750166f, 0.04523205f, 0.10292834f, -0.07587733f, -0.29584250f, 0.50018835f, 0.12484915f, 
    0.17160682f, -0.16430889f, 0.10079642f, 0.06380171f, -0.03268613f, 0.13772541f, 0.03414600f, -0.00024790f, 
    -0.25309715f, -0.17922994f, -0.23336659f, -0.12868392f, 0.02326920f, -0.07119286f, -0.14619520f, -0.08358593f, 
    0.00810168f, -0.07028103f, 0.04953569f, 0.01804899f, -0.46810576f, 0.12593958f, 0.20368949f, -0.04878800f, 
    -0.11154903f, 0.00549047f, 0.02481871f, 0.00432591f, 0.00862743f, 0.10036334f, -0.00694954f, -0.07332754f, 
    0.28077811f, 0.01476695f, 0.14035256f, -0.08350862f, 0.01635061f, 0.07372727f, 0.08939841f, 0.11967508f, 
    0.10791185f, -0.01232059f, 0.09956267f, 0.08169273f, 0.23804522f, -0.09817123f, 0.15369630f, 0.15013923f, 
    0.16572899f, -0.08711938f, 0.00128006f, -0.01082157f, 0.10615513f, 0.14857537f, 0.27746207f, 0.03805970f, 
    -0.05507008f, -0.19857888f, -0.05945533f, 0.21752857f, 0.08493543f, 0.08715052f, 0.03777812f, 0.05073522f, 
    0.21177515f, 0.10216022f, 0.00960733f, 0.13793555f, 0.21378280f, 0.22746338f, 0.06942934f, -0.10153508f, 
    -0.24400540f, -0.07463345f, 0.07655825f, -0.17688017f, 0.10596340f, -0.05254896f, -0.01606065f, 0.00369358f, 
    -0.18504697f, 0.47196290f, 0.14795722f, -0.14783964f, -0.00075006f, 0.07407236f, 0.06201647f, 0.09993850f, 
    -0.00690557f, -0.03889964f, -0.04017261f, -0.10789631f, 0.07285809f, -0.45158535f, -0.25522897f, -0.35489270f, 
    -0.11232295f, 0.13559107f, 0.09208996f, 0.11762104f, 0.01493438f, -0.07609911f, -0.06992358f, -0.05367425f, 
    -0.23805787f, 0.07022751f, -0.17714940f, 0.31993496f, -0.14212215f, -0.09457341f, -0.00492489f, 0.15476613f, 
    0.16247173f, 0.10112941f, 0.03064276f, 0.19500880f, -0.08401076f, -0.07012792f, 0.01621382f, -0.11882173f, 
    0.05696891f, 0.03744840f, -0.18652910f, 0.15880086f, -0.01662679f, -0.05335901f, -0.07625352f, 0.32618204f, 
    -0.15920462f, 0.01833829f, -0.06911542f, 0.12017695f, -0.02493775f, -0.00828301f, -0.15804970f, 0.21202841f, 
    0.11604939f, 0.03585207f, 0.16054066f, 0.24423307f, -0.27478299f, 0.12700658f, 0.09883816f, 0.03911254f, 
    0.01801337f, -0.00746486f, 0.12231199f, 0.14151958f, -0.00997980f, 0.02334967f, -0.09686717f, -0.15271677f, 
    0.10527566f, -0.22509652f, -0.18139400f, -0.08104686f, 0.01048760f, 0.06069864f, 0.13289951f, -0.04586012f, 
    -0.01063953f, 0.03890160f, 0.00394916f, 0.08882216f, 0.11217380f, -0.24669565f, -0.10591220f, -0.35272074f, 
    0.05073262f, 0.28265616f, -0.04587038f, 0.15537560f, 0.07238010f, 0.02844923f, 0.07221729f, -0.09290992f, 
    -0.15580060f, 0.26598635f, 0.02058042f, -0.11462916f, -0.02598582f, -0.06151893f, 0.12139964f, 0.15504105f, 
    0.11550457f, 0.05303381f, 0.01648180f, 0.04771107f, 0.00836464f, -0.08178311f, -0.26393276f, 0.26777166f, 
    0.00694515f, -0.10790244f, -0.03872055f, -0.15266138f, 0.14751795f, -0.04151562f, 0.14234754f, -0.02957213f, 
    0.22308691f, 0.00678913f, 0.31876513f, -0.00125921f, -0.17694874f, -0.09789737f, 0.04923339f, -0.00746104f, 
    -0.01483440f, -0.03121668f, 0.11949419f, 0.11091878f, -0.48969921f, 0.06473993f, -0.32533401f, -0.08116957f, 
    0.12217053f, -0.04035723f, 0.14245120f, 0.37456301f, 0.12757005f, 0.07546621f, 0.06441550f, 0.03269140f, 
    -0.00360226f, -0.00453186f, 0.01235187f, 0.01034234f, 0.00946224f, -0.01447605f, -0.03598568f, -0.03918222f, 
    -0.04693044f, 0.03297085f, 0.03085577f, 0.01223060f, 0.03517050f, 0.03750498f, -0.02935997f, 0.00146316f, 
    -0.04260510f, -0.04364658f, 0.03955822f, -0.03696625f, -0.00996278f, -0.03556911f, -0.04515604f, 0.03443581f, 
    0.03012016f, -0.01007187f, 0.03284691f, -0.00368510f, 0.00781734f, -0.03049700f, 0.01090904f, -0.01035195f, 
    -0.05262656f, -0.01714821f, 0.01997707f, 0.01782759f, -0.01929853f, -0.03166188f, 0.03848746f, 0.01039440f, 
    -0.02289663f, 0.00970710f, -0.03291829f, 0.01052473f, -0.03931931f, -0.03529719f, 0.04136909f, -0.02165007f, 
    0.03847564f, -0.06162631f, -0.01677215f, 0.02757387f, 0.04242079f, 0.03759981f, 0.00358170f, -0.02402498f, 
    0.03073109f, -0.01817936f, -0.02467653f, -0.02528386f, -0.04258154f, 0.04735995f, 0.03464928f, -0.00866520f, 
    -0.04312354f, -0.00187396f, 0.03305068f, -0.00402890f, -0.04736005f, 0.03945799f, -0.02660872f, -0.03167027f, 
    -0.01946366f, -0.05617741f, -0.02500174f, -0.04579170f, 0.04479555f, -0.04058352f, -0.05597391f, -0.02090123f, 
    -0.03488625f, -0.05440250f, 0.03708422f, 0.01407574f, 0.03167722f, 0.01046043f, -0.03078928f, -0.02303581f, 
    -0.04476997f, -0.02272676f, 0.01454650f, 0.04243610f, 0.01733615f, 0.04000396f, 0.02814694f, 0.02479503f, 
    -0.01052372f, -0.03822751f, -0.05186049f, 0.03117547f, -0.02983579f, -0.03730385f, -0.00445820f, -0.02223090f, 
    0.02483706f, -0.01094634f, 0.02051459f, -0.00979573f, -0.02961380f, -0.02928767f, 0.01556829f, 0.01393661f, 
    -0.02729283f, 0.02102040f, -0.01932064f, -0.05163674f, -0.01215170f, 0.00267827f, 0.02742787f, -0.05102303f, 
    -0.05476110f, -0.06457492f, -0.05552881f, -0.04726616f, -0.03735650f, -0.02435848f, 0.04020098f, -0.02806609f, 
    -0.04416572f, -0.04717252f, -0.04170504f, 0.02585816f, -0.02506187f, -0.04176002f, -0.01834906f, -0.03830954f, 
    0.03211434f, -0.00278363f, 0.00378278f, 0.04615906f, -0.03878155f, -0.02020821f, -0.04167864f, -0.05534420f, 
    0.04395815f, 0.03036059f, 0.01089883f, 0.03593254f, -0.01200989f, -0.02448769f, -0.00160424f, 0.04536379f, 
    0.02128710f, -0.03112198f, -0.04761695f, 0.01423240f, 0.03314879f, 0.03358809f, 0.03964274f, -0.00727290f, 
    -0.05220385f, -0.03740045f, -0.05061774f, -0.01928821f, -0.01773855f, 0.02850055f, -0.00707453f, 0.03739163f, 
    0.03508450f, -0.04781757f, 0.00839163f, 0.01610398f, -0.03252299f, 0.04097189f, 0.00302779f, 0.02974547f, 
    -0.05227796f, 0.03752405f, 0.01740973f, 0.02100209f, -0.00635584f, -0.03285858f, 0.00572505f, 0.03009884f, 
    0.02395226f, -0.02919019f, -0.00494236f, -0.02087023f, -0.01218843f, 0.04458891f, 0.04068564f, 0.04804247f, 
    0.01338637f, -0.01901021f, -0.00244234f, -0.02895717f, -0.04512881f, 0.02603471f, 0.01577594f, -0.01091438f, 
    0.01855517f, 0.03475845f, 0.03534821f, -0.02723365f, -0.06541649f, -0.02553852f, 0.03045612f, -0.04975080f, 
    0.00045387f, 0.02383531f, -0.05317724f, -0.03657871f, 0.04662178f, 0.02979187f, -0.01598565f, -0.01022933f, 
    -0.03929764f, -0.02861471f, -0.04527429f, -0.01422097f, 0.02137997f, 0.02576404f, 0.01345425f, -0.03588776f, 
    -0.01928331f, -0.00563330f, 0.01192062f, 0.02895006f, -0.05598399f, 0.00542938f, -0.02357859f, -0.05326443f, 
    0.01563675f, 0.00807998f, -0.04344421f, -0.01507825f, 0.02200987f, 0.03274148f, -0.02027401f, -0.03208242f, 
    -0.05141484f, 0.00875919f, -0.05633297f, -0.05312555f, -0.00163044f, -0.05307761f, 0.01373382f, 0.01248265f, 
    0.01667211f, 0.02388601f, 0.00697629f, 0.01101662f, -0.05248366f, -0.00511270f, -0.05791418f, -0.00671616f, 
    0.01262303f, 0.00213662f, -0.02533989f, 0.04050375f, -0.04961256f, 0.03567985f, 0.01599502f, -0.00344834f, 
    0.04030280f, 0.01256751f, -0.03749370f, -0.00258118f, -0.03496032f, -0.02368999f, -0.04350255f, -0.01648876f, 
    -0.03018121f, -0.03509156f, 0.02904331f, -0.00317596f, -0.01256298f, -0.01153023f, 0.00555054f, -0.01514432f, 
    0.01051055f, -0.01658836f, -0.00229397f, 0.00914713f, -0.01867681f, -0.03656786f, -0.03342384f, 0.00818631f, 
    -0.05478641f, -0.00859136f, -0.04244883f, -0.01880275f, -0.03446753f, 0.01351916f, 0.03984597f, 0.00602489f, 
    0.04422455f, -0.03494644f, -0.02642870f, 0.00684029f, 0.03569104f, 0.00567685f, -0.04088412f, -0.00883517f, 
    0.04940901f, -0.03212576f, 0.03498675f, 0.02317299f, 0.01302296f, -0.05075729f, 0.00725247f, -0.01260594f, 
    -0.05214887f, 0.01483332f, 0.03645989f, 0.01411327f, 0.01311168f, -0.03857110f, -0.00586131f, -0.02848411f, 
    -0.01224595f, -0.00357462f, -0.01413005f, -0.01697615f, 0.04037764f, 0.00133785f, -0.00497474f, -0.04550643f, 
    -0.00154892f, 0.04688460f, -0.03056068f, -0.02424912f, -0.02515337f, 0.04694421f, -0.04178438f, -0.04193993f, 
    0.02442861f, 0.01557852f, 0.00339304f, -0.00194239f, -0.03484917f, 0.03303637f, -0.01546306f, -0.01116997f, 
    0.00766994f, 0.03876460f, 0.01494675f, 0.04840789f, 0.02513028f, -0.02557898f, -0.04909895f, 0.02167464f, 
    0.03935594f, -0.02291913f, 0.03500500f, -0.00423893f, -0.01326842f, 0.02199923f, 0.03052874f, -0.04165938f, 
    -0.03854063f, 0.00996460f, -0.00607685f, 0.02877233f, 0.02979383f, 0.02921216f, 0.04392020f, -0.00052546f, 
    -0.05902387f, 0.00313660f, 0.00650705f, -0.00144791f, -0.00303085f, -0.02658811f, 0.02790780f, 0.01006156f, 
    0.03384805f, -0.02007352f, -0.01764184f, 0.01847144f, -0.00717814f, -0.00428423f, -0.00940952f, -0.01665575f, 
    0.20342097f, 0.05734491f, 0.07912062f, 0.01941743f, 0.08915294f, 0.23219100f, -0.02645015f, -0.01870007f, 
    0.14667910f, 0.02721682f, 0.03576305f, 0.07234459f, 0.01758847f, -0.06908670f, 0.19390900f, 0.02506127f, 
    0.01449626f, 0.10033275f, -0.09880199f, 0.00604107f, 0.11500669f, 0.18527761f, 0.03141544f, -0.12521699f, 
    -0.05927341f, -0.20692347f, -0.02861400f, -0.27154446f, 0.15938002f, 0.10002932f, -0.03837843f, -0.02252354f, 
    -0.05041485f, -0.02336966f, -0.01526141f, 0.00473968f, 0.00266331f, 0.01244724f, -0.06660184f, 0.09831526f, 
    -0.02288374f, -0.14052899f, 0.10598326f, -0.08147582f, 0.03007329f, -0.00889865f, -0.05828200f, -0.03522578f, 
    0.45683414f, 0.23049311f, 0.07554315f, 0.00750116f, -0.03217033f, -0.08466615f, 0.07394010f, 0.06147971f, 
    -0.01257561f, -0.00049681f, 0.09613344f, 0.08233531f, 0.04293779f, 0.00044661f, 0.03176710f, -0.13950403f, 
    0.06457946f, 0.13521583f, 0.15065129f, 0.01806511f, 0.08753028f, 0.10678161f, 0.10390227f, 0.06164586f, 
    -0.34818420f, -0.12111425f, -0.20181075f, -0.01953325f, -0.13840915f, -0.09232247f, -0.00223245f, 0.10277185f, 
    0.06653216f, -0.12301738f, -0.04332251f, 0.07238173f, 0.00889274f, 0.09284924f, 0.26082602f, 0.33966771f, 
    -0.03957185f, 0.02843469f, 0.07327612f, -0.06392857f, 0.14990999f, 0.03424135f, 0.21895990f, 0.05076305f, 
    -0.20560604f, -0.07358009f, -0.10194609f, -0.16500677f, -0.01816174f, 0.01045419f, 0.01650999f, 0.05068643f, 
    0.05404210f, 0.16617908f, 0.07587976f, -0.13781531f, -0.11642417f, -0.31504890f, -0.04255669f, -0.02959194f, 
    -0.02180997f, 0.05953820f, -0.10159213f, 0.13319181f, 0.07107161f, 0.21233386f, 0.11846562f, -0.06321997f, 
    0.14341690f, 0.35388610f, 0.30462316f, 0.16883489f, 0.00133736f, -0.11237971f, 0.02064437f, -0.04786788f, 
    0.01725967f, 0.03699945f, -0.02578305f, 0.06729970f, 0.08387453f, 0.18271418f, 0.09378994f, 0.03318818f, 
    0.01214049f, -0.06189389f, -0.00391765f, -0.05207758f, 0.46055567f, 0.06114766f, 0.20127630f, -0.01760466f, 
    -0.36483589f, -0.25993130f, -0.03506400f, -0.15379491f, -0.00339857f, -0.05720900f, -0.00478852f, 0.09119263f, 
    -0.04808448f, 0.09670272f, 0.07176205f, -0.00946992f, 0.35579252f, -0.03314681f, 0.04671827f, -0.31257975f, 
    0.11863666f, 0.01972838f, 0.14432421f, 0.02704803f, -0.12222309f, 0.10251744f, 0.01594540f, -0.07252539f, 
    0.08334215f, 0.13556899f, 0.07293348f, -0.01742101f, -0.10615262f, -0.10208176f, -0.01757788f, -0.02271822f, 
    0.19696884f, 0.01978816f, 0.02538895f, 0.00496412f, -0.01790906f, -0.21944033f, -0.09102246f, -0.15601259f, 
    -0.04800230f, -0.01210386f, 0.03893807f, 0.00182111f, 0.14686327f, -0.10385158f, 0.09961071f, -0.19064726f, 
    -0.24381873f, 0.01882337f, -0.02623971f, -0.23436311f, -0.03727322f, 0.02177403f, -0.11624202f, 0.04163759f, 
    0.33223310f, 0.04021760f, 0.05148295f, 0.13453239f, 0.14353712f, 0.18444258f, 0.05909820f, 0.11148529f, 
    0.15597188f, -0.04793591f, -0.09709237f, 0.05133280f, 0.06579167f, 0.18231766f, 0.17746960f, -0.07711843f, 
    0.12318631f, 0.13771060f, 0.28317705f, 0.14635220f, 0.02358381f, 0.11575144f, -0.04888355f, -0.02123491f, 
    0.15112925f, 0.12153470f, -0.03931650f, 0.10068850f, -0.12783313f, -0.12544696f, -0.12949900f, -0.16918956f, 
    0.05573219f, 0.12862110f, -0.09457428f, -0.40520379f, -0.02154976f, -0.07810000f, 0.07188731f, -0.04769713f, 
    -0.30324599f, -0.12061556f, -0.19770950f, -0.22992940f, -0.00154998f, -0.00690197f, 0.02659875f, -0.02522206f, 
    -0.13859035f, 0.00038989f, -0.02646477f, 0.05247409f, 0.21838330f, 0.26757881f, -0.02239372f, -0.23143643f, 
    0.10594237f, -0.05056449f, -0.02985828f, -0.12874775f, -0.01469978f, -0.03910081f, -0.06332658f, 0.06193039f, 
    0.28767774f, 0.22055477f, 0.15679832f, 0.24526170f, -0.06789657f, 0.10552102f, 0.01981065f, 0.05343817f, 
    0.07802847f, 0.01273106f, 0.22735713f, -0.00334389f, -0.02471295f, 0.17005637f, 0.10194245f, 0.04982085f, 
    0.05835614f, 0.16536200f, -0.06855464f, 0.23959246f, 0.08111838f, -0.05411437f, 0.09418673f, 0.07059525f, 
    0.17626964f, -0.01472849f, 0.08156058f, -0.03415143f, 0.10913369f, 0.00803470f, 0.03028738f, 0.08762810f, 
    -0.03189463f, -0.11123662f, 0.09829897f, -0.08550791f, 0.07317415f, -0.36999333f, -0.21198373f, -0.05806849f, 
    0.18518910f, 0.04420697f, 0.05967993f, 0.03917913f, -0.03962561f, -0.11989105f, 0.05637250f, -0.12314790f, 
    0.07576241f, 0.14311264f, 0.01657349f, 0.03974348f, 0.02731950f, -0.02894470f, -0.05757112f, -0.06267343f, 
    0.29889101f, 0.13180012f, 0.11827228f, 0.08152705f, 0.03016624f, 0.13729504f, 0.15711746f, 0.04014164f, 
    0.07883659f, 0.13361508f, -0.10533248f, -0.03343874f, 0.03906086f, 0.09571625f, -0.01304202f, 0.00427715f, 
    -0.26932806f, -0.14049950f, -0.28347296f, -0.16886464f, 0.17074876f, -0.03563181f, 0.10751053f, -0.03258241f, 
    0.05219949f, 0.07733390f, 0.07171838f, 0.04771097f, 0.35273474f, 0.31646019f, 0.30943710f, 0.08971597f, 
    0.10056274f, 0.00062427f, -0.08163149f, -0.05612642f, -0.05381003f, 0.12872137f, 0.05361386f, 0.08152764f, 
    -0.07684881f, 0.18987042f, -0.02380219f, -0.15474577f, 0.01683093f, 0.16340858f, 0.07389314f, -0.13223650f, 
    -0.18670008f, 0.05809538f, 0.00168614f, -0.04402639f, -0.02706992f, -0.11081538f, -0.07169229f, 0.06709078f, 
    0.03942136f, 0.03284278f, 0.10530966f, 0.27468088f, -0.18841256f, -0.03157821f, -0.03390034f, -0.05323940f, 
    0.00916488f, -0.03795181f, -0.03865563f, 0.02194662f, -0.03312859f, -0.01232574f, -0.00654095f, 0.03183205f, 
    0.00671713f, -0.01470226f, 0.00174582f, -0.06021683f, 0.04255557f, -0.00047917f, 0.00897505f, -0.02991050f, 
    0.04764405f, -0.00996143f, 0.03191890f, 0.05163464f, 0.02682730f, -0.01193122f, -0.04364132f, 0.04168392f, 
    -0.01415922f, 0.00989642f, -0.04278525f, -0.01796485f, 0.02621549f, 0.02716007f, 0.03642258f, -0.04385836f, 
    -0.01467168f, -0.05586772f, 0.00737388f, 0.00640167f, 0.00065725f, 0.04033121f, 0.01436666f, -0.01733375f, 
    0.03032671f, -0.02236881f, 0.00724195f, -0.02947815f, -0.03459042f, -0.01277834f, -0.03428909f, -0.00103083f, 
    -0.04996830f, -0.05389694f, -0.03576909f, 0.01687793f, 0.03272081f, 0.01642281f, -0.03223243f, -0.00676857f, 
    -0.01919507f, 0.03242807f, -0.05096820f, 0.03778577f, -0.01328578f, -0.02455416f, -0.04807680f, 0.03018734f, 
    0.00830873f, -0.02970695f, 0.01003488f, -0.04121660f, 0.00575624f, 0.02593845f, 0.01693122f, -0.03638997f, 
    -0.03604050f, -0.04462058f, -0.02855059f, 0.03099670f, -0.01123294f, -0.01138859f, -0.03382984f, -0.00235106f, 
    0.01465645f, 0.02512370f, -0.01962524f, 0.02182808f, 0.03851608f, -0.04813766f, -0.02628829f, -0.02987650f, 
    -0.03241979f, -0.03196935f, 0.01091175f, -0.00291707f, -0.04982729f, 0.01453115f, -0.00201456f, -0.03253249f, 
    -0.02873808f, -0.03505267f, -0.03935180f, -0.02377795f, -0.03837397f, -0.04271449f, -0.01082316f, 0.03982990f, 
    0.01763319f, -0.04607059f, -0.05998488f, 0.00069082f, -0.05444991f, -0.01092224f, -0.01456394f, 0.04390512f, 
    0.00472386f, -0.03242581f, 0.00585336f, 0.03351627f, -0.05502913f, -0.03049549f, -0.03785149f, 0.00089350f, 
    0.00584295f, -0.00219637f, 0.04428183f, 0.01375183f, -0.02019788f, 0.02147539f, 0.03877772f, 0.03479487f, 
    -0.03465480f, -0.00244660f, 0.00964835f, -0.05660802f, 0.02015412f, -0.04717254f, -0.03742593f, -0.00330968f, 
    0.04802071f, -0.01036147f, 0.00677918f, 0.00506011f, -0.04191226f, 0.00490394f, 0.00241428f, 0.00042912f, 
    -0.00890562f, 0.01665785f, 0.03349827f, 0.05084201f, 0.03581129f, -0.04829133f, -0.04437046f, -0.01654050f, 
    -0.03370211f, -0.05695292f, -0.01127293f, 0.00032077f, 0.02713658f, -0.02658000f, 0.01981814f, -0.05591356f, 
    -0.00790632f, -0.00851489f, 0.00034046f, -0.02400368f, 0.02824673f, -0.00186692f, 0.02764710f, 0.03853180f, 
    0.04560919f, 0.02322522f, 0.03717862f, 0.04170872f, -0.01698711f, 0.01070934f, -0.04666651f, 0.00639551f, 
    0.01071322f, -0.00203901f, 0.01891839f, 0.02063772f, -0.04641878f, -0.03056455f, -0.02365196f, -0.02300411f, 
    -0.05697041f, -0.04239113f, 0.01575075f, -0.04202912f, 0.03823121f, -0.04931819f, -0.04085710f, -0.05470614f, 
    0.02695461f, -0.04146663f, -0.01529298f, 0.01092359f, -0.00122093f, -0.01835967f, 0.00726838f, -0.02433344f, 
    -0.01793269f, 0.00883100f, 0.00120311f, -0.05509824f, -0.05366204f, -0.03419635f, -0.00061937f, 0.04774965f, 
    0.02110350f, -0.00368535f, -0.04084932f, -0.02237339f, 0.01535725f, 0.01457060f, -0.01262890f, 0.01707349f, 
    -0.03225205f, 0.02353263f, 0.03334728f, 0.00723515f, -0.01823739f, -0.02139417f, -0.01578933f, 0.03149801f, 
    0.00940488f, -0.00589860f, -0.02311775f, 0.00187544f, -0.04368566f, 0.00145263f, -0.00204288f, 0.03415178f, 
    -0.05493261f, 0.00653631f, -0.00290737f, -0.03337800f, -0.04399185f, -0.02417283f, -0.04136419f, 0.02462299f, 
    0.03052708f, -0.01114219f, 0.01801972f, 0.02758462f, -0.02011936f, 0.02854580f, -0.01147489f, 0.03964873f, 
    -0.00809595f, -0.01262828f, -0.00788756f, 0.01750593f, 0.00824759f, 0.00471834f, 0.00424269f, -0.04161417f, 
    -0.03422001f, -0.04638207f, -0.00138063f, 0.03389855f, -0.01504953f, -0.02752231f, -0.04319924f, -0.03782767f, 
    0.00359487f, 0.01066812f, -0.03212669f, -0.03001667f, 0.03100491f, -0.00004787f, -0.00067453f, -0.00860686f, 
    -0.02757503f, -0.03873043f, 0.04068660f, 0.00090637f, 0.02126043f, 0.02664715f, -0.03296292f, 0.02394726f, 
    0.02536823f, 0.02125937f, 0.00217215f, -0.02683901f, 0.00660373f, -0.05170330f, -0.00322695f, -0.02950558f, 
    -0.00626017f, 0.03952926f, -0.03482686f, 0.04289905f, -0.02213616f, 0.01381786f, 0.02309153f, 0.00229351f, 
    -0.01722979f, 0.02156059f, 0.01336239f, 0.01039955f, -0.03696932f, -0.03765903f, 0.01082930f, 0.02152202f, 
    -0.03743478f, 0.01642126f, -0.01165019f, 0.02490352f, 0.02058950f, -0.04907891f, -0.05815533f, -0.05621636f, 
    -0.02342608f, 0.02993152f, 0.00440518f, -0.04119342f, -0.03765982f, 0.04586048f, 0.04340150f, 0.04133410f, 
    -0.04556108f, -0.02054419f, -0.05269732f, -0.04916759f, -0.03072133f, -0.01656089f, 0.02383498f, 0.00133522f, 
    -0.02702496f, 0.00501964f, 0.01174758f, -0.02592493f, 0.00211386f, -0.05459917f, 0.03156481f, -0.06178316f, 
    0.02481000f, 0.03374655f, 0.00957663f, 0.04287238f, -0.01544414f, 0.01396252f, -0.00958145f, 0.03997533f, 
    0.01812501f, -0.03277540f, 0.01950100f, -0.01629677f, 0.02215926f, -0.01932766f, 0.00503865f, -0.01742658f, 
    0.03555204f, 0.00502840f, -0.00966170f, 0.00648138f, -0.04171254f, -0.04999861f, 0.03247404f, 0.02919307f, 
    0.04249731f, -0.01446866f, -0.00748535f, -0.02229391f, -0.01103505f, -0.00924997f, 0.03686180f, 0.01288031f, 
    0.04839388f, -0.00915289f, -0.00970360f, -0.04759794f, -0.04964129f, -0.00860757f, 0.02608199f, -0.04615385f, 
    -0.05963484f, -0.06327918f, 0.03127866f, -0.03758332f, -0.02154702f, 0.03665607f, -0.01516730f, -0.04828387f, 
    0.21677285f, -0.01609850f, 0.03558752f, -0.08959118f, -0.08844049f, 0.01368288f, -0.05760961f, 0.03846114f, 
    0.11265128f, 0.02864414f, 0.09107439f, -0.18100031f, 0.06330345f, -0.22301635f, -0.08212414f, 0.17323053f, 
    0.04405743f, 0.19845133f, 0.01246905f, -0.16168937f, 0.19208691f, 0.05061236f, 0.26324585f, 0.04129599f, 
    -0.14456148f, -0.25486770f, 0.04736390f, -0.03095471f, 0.19249569f, 0.17243695f, -0.08519168f, -0.13594747f, 
    0.06675535f, -0.00179969f, 0.00878277f, -0.07989776f, -0.00503663f, 0.05951250f, -0.15582302f, -0.09115365f, 
    0.01175854f, -0.11207590f, -0.09338997f, -0.17307298f, 0.11008879f, 0.00427437f, -0.00832844f, -0.16972646f, 
    0.03975886f, -0.08723561f, -0.28662154f, -0.12113506f, 0.01608060f, -0.11223844f, -0.08796007f, -0.06675684f, 
    0.03829429f, -0.14892243f, 0.05391410f, -0.09821529f, 0.08331430f, -0.13748728f, 0.13046293f, -0.04633019f, 
    0.05024181f, 0.07036219f, 0.08212601f, 0.02373206f, 0.00659045f, -0.00309902f, 0.03875281f, 0.07871017f, 
    -0.15749773f, 0.11610925f, -0.03988857f, 0.23349759f, -0.02116886f, -0.16196978f, 0.04185990f, 0.23665844f, 
    0.09145904f, -0.07426213f, -0.01384141f, 0.04507119f, -0.21458802f, 0.16647375f, 0.13764618f, 0.09487218f, 
    0.06712688f, 0.13817702f, 0.09332542f, -0.07335395f, 0.00814751f, 0.01225509f, 0.07571474f, 0.03945200f, 
    -0.22961764f, 0.02681897f, 0.08850598f, -0.00054769f, -0.08220820f, -0.00107317f, 0.07344458f, 0.04086458f, 
    0.13301121f, 0.18666956f, 0.12967436f, 0.17403330f, 0.01055869f, -0.23565875f, 0.10439781f, 0.12868732f, 
    -0.03340266f, 0.07369840f, -0.00252058f, 0.31575096f, 0.06345974f, 0.03909322f, 0.00891590f, 0.12121468f, 
    -0.13217521f, 0.05849489f, 0.09277838f, -0.13817060f, -0.04743845f, -0.14381215f, -0.13286945f, -0.02395363f, 
    0.02395882f, -0.14672132f, -0.03242294f, -0.03711669f, -0.21508865f, 0.04264476f, -0.02960501f, -0.22648019f, 
    0.04617054f, 0.03643147f, 0.10294245f, 0.00512146f, 0.17281321f, 0.18020289f, -0.07214060f, 0.02766932f, 
    -0.23121412f, -0.11769217f, 0.46499568f, 0.14310355f, 0.05373531f, -0.12519252f, -0.10382999f, -0.02571763f, 
    -0.03322319f, 0.19185548f, 0.19865358f, 0.17333278f, 0.09060231f, 0.04310125f, 0.10090164f, -0.09507689f, 
    0.14151496f, 0.03260119f, -0.03107606f, 0.13794030f, -0.11805438f, 0.10412770f, 0.09802465f, 0.01302371f, 
    -0.00252371f, -0.06567764f, -0.14711875f, -0.34101132f, -0.09845051f, -0.06470324f, -0.10361250f, -0.05398520f, 
    0.14835769f, 0.03785906f, 0.10173928f, 0.09283324f, 0.32188803f, 0.00450256f, -0.01838930f, 0.28616515f, 
    -0.05051186f, -0.01479502f, 0.08165824f, 0.20188822f, 0.16215813f, -0.04122018f, -0.04895936f, -0.07083970f, 
    -0.11285348f, 0.22117764f, 0.26448312f, 0.03873777f, -0.04635201f, -0.04557831f, -0.09005497f, 0.06350776f, 
    0.04245569f, 0.11847703f, -0.00306473f, 0.15434815f, 0.00569305f, 0.07368065f, -0.12089849f, -0.07453282f, 
    0.01935022f, 0.10212406f, -0.15136626f, 0.06592797f, 0.07227182f, -0.05354172f, 0.06233979f, -0.04634554f, 
    0.04165554f, 0.01552930f, 0.04359486f, -0.13841455f, 0.02786678f, -0.03362006f, -0.09313406f, -0.01407747f, 
    0.06109168f, -0.01962879f, 0.15743889f, 0.17300844f, -0.12479626f, -0.26047972f, 0.16591343f, 0.32796672f, 
    0.14242743f, 0.14930688f, -0.02634234f, -0.30892450f, 0.15025389f, -0.21039574f, 0.00438296f, 0.03309389f, 
    -0.23557016f, -0.11004034f, -0.00385251f, 0.15789957f, 0.03905255f, -0.16862004f, 0.16914180f, 0.01291125f, 
    -0.03420037f, -0.18358997f, -0.05891890f, 0.07226315f, -0.24726845f, 0.20356786f, 0.34210080f, -0.03747904f, 
    0.39136508f, 0.01898076f, -0.02568148f, -0.03402144f, -0.11043248f, -0.08532123f, -0.08765053f, -0.00093076f, 
    0.43377283f, 0.14379710f, -0.24436200f, 0.01824490f, -0.08834484f, 0.01387424f, -0.00078092f, 0.15186788f, 
    0.00067815f, 0.13560146f, 0.21026064f, -0.04460206f, 0.00227620f, 0.12774010f, -0.00708537f, -0.24026857f, 
    -0.11407773f, 0.21126661f, -0.07589779f, 0.07807606f, 0.00411388f, 0.08976957f, 0.05472863f, 0.04253784f, 
    0.03073569f, -0.23934731f, -0.33344138f, -0.16161601f, -0.03138439f, -0.32718134f, -0.02941130f, 0.21454412f, 
    -0.07854022f, 0.00844259f, 0.03573770f, -0.15322651f, 0.32445592f, -0.30701494f, -0.14764933f, 0.44377968f, 
    0.08390959f, 0.02609104f, 0.13488141f, 0.02828815f, 0.10883454f, 0.03673258f, -0.09684380f, -0.08326272f, 
    -0.16076462f, 0.07282689f, 0.06018059f, 0.04022757f, 0.08810718f, 0.05832793f, -0.04197991f, -0.09498208f, 
    0.13759218f, -0.03081041f, 0.08676688f, 0.21287841f, -0.29515263f, -0.08933955f, 0.12286390f, -0.12226972f, 
    0.05500758f, -0.00401268f, -0.00645140f, -0.07648204f, -0.16349371f, -0.07386611f, -0.12889664f, 0.01140193f, 
    -0.09215946f, 0.09421133f, 0.04515606f, 0.02851562f, 0.19472353f, -0.07119821f, -0.01291814f, -0.17448282f, 
    0.11721949f, 0.10834020f, -0.00739962f, -0.05661084f, 0.18786532f, -0.05108010f, 0.16829778f, -0.32521266f, 
    -0.05049790f, -0.04875513f, -0.09006773f, 0.06965113f, -0.06695540f, 0.11800015f, 0.11611536f, -0.02771845f, 
    -0.33894318f, 0.14711779f, 0.14093857f, 0.13357429f, 0.00363198f, 0.20198227f, 0.00177090f, -0.06713964f, 
    0.05358035f, -0.00803504f, 0.10375851f, 0.00701838f, 0.38057739f, -0.16030617f, -0.03089342f, 0.20779400f, 
    0.15353458f, 0.13850604f, 0.17511514f, 0.25245667f, -0.16339108f, 0.06524234f, 0.15339063f, 0.03839060f, 
    -0.08089009f, 0.07555996f, -0.01291075f, 0.04231936f, -0.04655560f, 0.08140153f, 0.13087656f, 0.07771832f, 
    -0.18734416f, 0.05107817f, -0.08142539f, -0.09388036f, 0.09985746f, 0.16311535f, -0.21005684f, -0.15650113f, 
    -0.16394226f, -0.26145154f, -0.06294855f, -0.09993688f, -0.15402465f, -0.06405388f, -0.00203864f, 0.16350900f, 
    0.19729339f, 0.06224592f, -0.37043229f, 0.19234344f, 0.04179180f, 0.04719880f, -0.03810775f, -0.02447332f, 
    0.10309954f, 0.00020186f, 0.02674720f, 0.00514835f, 0.09548170f, 0.06098435f, -0.01030439f, -0.06010191f, 
    0.07677235f, 0.12122656f, -0.01622872f, 0.02785331f, -0.05572726f, 0.05330042f, -0.00832460f, 0.09117308f, 
    -0.45969099f, -0.27766556f, 0.03975943f, -0.08087928f, 0.04053928f, 0.01476170f, -0.15523095f, -0.11303538f, 
    -0.02081700f, 0.10050652f, 0.11403730f, 0.09596004f, -0.15581124f, 0.27037460f, -0.18016170f, 0.04988391f, 
    -0.03556855f, -0.09340356f, 0.07952203f, -0.13716455f, -0.03568188f, -0.08713303f, -0.12366503f, 0.05307304f, 
    0.26853561f, 0.13369913f, 0.06235136f, 0.13733332f, 0.06079285f, 0.15896508f, 0.13316680f, -0.11937829f, 
    -0.13403130f, 0.08941436f, -0.01289962f, -0.00903734f, -0.01644759f, -0.06023170f, -0.11648548f, -0.24868506f, 
    0.06554522f, -0.06688325f, -0.26817259f, -0.04364286f, -0.13535555f, 0.05441756f, 0.01558800f, 0.00973949f, 
    0.10806949f, 0.00291737f, 0.18703666f, 0.16703516f, -0.03815127f, -0.05891250f, -0.19779536f, -0.19212553f, 
    0.13195722f, 0.00883687f, 0.10654265f, 0.22326468f, 0.10757737f, 0.10553707f, 0.14817832f, 0.12479267f, 
    0.17551440f, 0.04601898f, 0.20206803f, 0.00468342f, 0.01836083f, 0.13810030f, -0.10210592f, -0.00100509f, 
    -0.27068639f, -0.19313082f, -0.22124502f, -0.00720672f, 0.09287924f, 0.11380056f, -0.01443915f, 0.11958566f, 
    -0.06786498f, 0.06327188f, -0.00302057f, 0.04902091f, -0.12946813f, 0.00298929f, -0.17067315f, -0.12919556f, 
    -0.07551961f, 0.06218378f, -0.02409326f, -0.02662085f, -0.07199624f, -0.07649355f, -0.06229006f, 0.10648769f, 
    0.34852624f, 0.24005862f, 0.02997353f, -0.02841330f, 0.03146960f, 0.10754229f, 0.02883950f, -0.13994521f, 
    -0.02232143f, -0.06635857f, 0.09064950f, 0.01093685f, 0.15306103f, 0.14308488f, -0.20468301f, -0.16368677f, 
    -0.07610246f, 0.09087189f, -0.04044358f, -0.01034201f, 0.01878564f, -0.05210340f, 0.03280405f, 0.00794451f, 
    -0.18628214f, -0.20985115f, -0.08439914f, -0.09192680f, -0.06190502f, 0.06123113f, 0.06475988f, 0.06756053f, 
    -0.06036634f, 0.14758305f, 0.00159133f, 0.11066870f, 0.26744923f, 0.13723400f, 0.11508995f, 0.21781731f, 
    0.07498680f, 0.19062883f, 0.10488385f, 0.10044559f, -0.01464691f, 0.07694742f, -0.06517302f, 0.09443215f, 
    0.04189248f, 0.17590232f, 0.06315050f, 0.26838604f, 0.11613809f, -0.00959637f, 0.01289740f, -0.11647289f, 
    -0.13339372f, 0.01463605f, -0.01180639f, -0.21595509f, -0.29043266f, -0.11270528f, 0.05043164f, -0.15626034f, 
    0.01029815f, 0.04166730f, 0.05649860f, 0.02443808f, -0.08701478f, -0.06731078f, 0.01987944f, 0.04176620f, 
    -0.01678164f, 0.05642923f, -0.28411993f, -0.06345149f, 0.06985716f, -0.04571013f, 0.02449339f, 0.00053016f, 
    -0.08520846f, 0.14343491f, 0.05871408f, -0.05731606f, -0.01331524f, 0.18508193f, -0.09517604f, -0.12993434f, 
    0.12332208f, 0.11013044f, -0.06665102f, 0.34927139f, -0.08912422f, 0.00965031f, -0.03599703f, 0.01111955f, 
    0.37738085f, -0.09344923f, 0.17779952f, 0.28376085f, 0.12067389f, 0.11994812f, -0.01543401f, -0.02180842f, 
    -0.03613220f, -0.00613155f, 0.00084372f, 0.02968580f, -0.19017930f, 0.17743161f, -0.02860437f, 0.25137204f, 
    -0.25438070f, -0.09250080f, -0.05653795f, -0.09450006f, -0.02812126f, -0.03993068f, 0.07366601f, 0.02266265f, 
    -0.06097124f, -0.10247440f, 0.00516349f, -0.06850989f, 0.00681320f, -0.00216150f, 0.11164709f, 0.05796631f, 
    -0.03593313f, 0.06105206f, -0.09793147f, 0.05072008f, 0.03855668f, -0.16564776f, -0.10672110f, 0.03736492f, 
    -0.02926520f, -0.09324982f, 0.04310781f, -0.22261743f, 0.07768318f, 0.28900561f, 0.20107548f, -0.02163746f, 
    0.00953348f, 0.00865113f, -0.01047507f, 0.01721257f, 0.04473959f, 0.13697097f, 0.11471907f, 0.06308317f, 
    0.01647663f, 0.16773313f, 0.04002817f, 0.17878079f, 0.26229769f, 0.33650526f, 0.18077648f, 0.02232258f, 
    -0.01789662f, 0.14850140f, -0.02045167f, 0.00326769f, -0.03773048f, -0.00908774f, -0.03720014f, 0.05065386f, 
    -0.46922290f, -0.06934088f, 0.02321672f, -0.02606786f, -0.06821220f, -0.13928372f, -0.15762322f, -0.01454541f, 
    -0.19083978f, 0.07863860f, -0.00644302f, -0.13674092f, -0.11661789f, 0.04144005f, -0.12473282f, 0.13599747f, 
    -0.14204653f, 0.01143158f, 0.11594169f, -0.06486277f, -0.07486922f, -0.04110595f, 0.05491826f, 0.09033769f, 
    0.20484467f, -0.04000508f, 0.04614863f, 0.09810954f, 0.05054357f, 0.01007978f, -0.11792535f, -0.26671895f, 
    -0.16320188f, -0.10166486f, -0.02123508f, 0.00502311f, -0.31844726f, -0.12203623f, -0.00119569f, -0.30278292f, 
    0.04555979f, 0.05176357f, 0.08895835f, 0.02474714f, -0.04688285f, 0.03952831f, 0.02062168f, 0.02450567f, 
    0.01270048f, 0.00426561f, -0.05470169f, 0.01427785f, 0.09168456f, -0.09953614f, 0.02412669f, -0.07706256f, 
    -0.00953735f, -0.03943803f, -0.14881934f, -0.03424434f, 0.22202872f, 0.00271597f, 0.19715507f, 0.08012649f, 
    0.07840240f, 0.16946827f, -0.10810075f, -0.15671931f, 0.01130878f, 0.14652020f, 0.12670301f, 0.04443613f, 
    -0.05682631f, -0.04541189f, 0.00145356f, -0.05195867f, -0.00641257f, 0.03855818f, 0.01409638f, -0.02159167f, 
    -0.05204533f, 0.01458806f, -0.00284719f, 0.02204968f, -0.04875688f, -0.01605405f, 0.03602437f, 0.01227209f, 
    0.03251329f, 0.03778709f, -0.00266187f, -0.02239743f, 0.01023624f, 0.00802079f, 0.03948915f, -0.02144861f, 
    0.01420837f, -0.04527387f, 0.04086028f, -0.00414463f, 0.00227306f, -0.04055818f, 0.00673872f, -0.00709788f, 
    -0.05323371f, 0.04279142f, 0.00506178f, -0.03359953f, 0.02585536f, 0.02510685f, -0.02792130f, 0.02622558f, 
    -0.03151652f, 0.00951081f, -0.03566767f, 0.00587963f, -0.03007399f, -0.04806785f, -0.04965038f, -0.01546004f, 
    -0.01217124f, 0.02630697f, -0.03845251f, -0.03396232f, 0.01572138f, 0.00984589f, -0.04523285f, -0.00782610f, 
    0.03355018f, -0.04151537f, -0.01641791f, 0.00894893f, -0.00830072f, 0.03152076f, 0.03107262f, -0.03781543f, 
    -0.03424276f, -0.02836593f, -0.01460745f, 0.00906319f, -0.04037292f, -0.01319605f, -0.00721044f, -0.05211801f, 
    0.04153613f, -0.00355334f, -0.00915746f, 0.04327054f, -0.03996189f, -0.05556862f, -0.04966877f, 0.00564551f, 
    -0.00658638f, -0.04635134f, -0.03878183f, -0.00661482f, 0.03570901f, -0.02756142f, -0.02667389f, 0.03746965f, 
    0.05026634f, 0.03666543f, -0.02595267f, -0.01802837f, -0.03809449f, -0.02057095f, -0.02025543f, 0.04529056f, 
    -0.02277468f, 0.04157716f, -0.04163204f, -0.01528467f, 0.00673012f, -0.02786935f, -0.04309713f, 0.00811980f, 
    -0.00047404f, 0.04846023f, -0.04842853f, 0.01737743f, -0.00147803f, -0.04023612f, -0.01549981f, 0.03071917f, 
    -0.03587528f, -0.00928377f, -0.04127678f, -0.04146096f, 0.02118412f, 0.02339299f, 0.03401067f, -0.02723365f, 
    -0.03922236f, -0.05064140f, -0.05595800f, 0.02099109f, 0.04628259f, 0.02147041f, -0.00339014f, 0.01707410f, 
    -0.02053995f, 0.02067889f, 0.03702757f, 0.04248769f, -0.04253015f, 0.02714568f, 0.02426659f, -0.00819135f, 
    -0.04604921f, 0.03185586f, 0.00927807f, -0.04285255f, 0.00342610f, -0.04968484f, 0.02374899f, 0.01603532f, 
    0.00581866f, 0.04582916f, -0.02024398f, 0.01658679f, -0.01092866f, -0.00764182f, 0.00593366f, 0.00366552f, 
    0.03849830f, 0.01860129f, 0.00380161f, -0.03052670f, 0.00966266f, 0.01766146f, -0.00629362f, -0.01270524f, 
    -0.03417818f, -0.05313610f, 0.02596378f, -0.03340187f, 0.01330257f, -0.04644749f, 0.00702700f, -0.01341930f, 
    -0.02447851f, -0.00978157f, 0.00246026f, 0.03324131f, -0.02074203f, 0.00895340f, 0.03546762f, -0.02118936f, 
    0.01680186f, -0.02232242f, 0.02363743f, 0.02292328f, 0.04150717f, 0.04241874f, -0.01122841f, -0.03188742f, 
    -0.04371946f, -0.00319438f, 0.03189120f, 0.04719760f, -0.00233817f, -0.03684555f, 0.01643775f, 0.00047304f, 
    -0.02891272f, 0.01408007f, -0.01408422f, 0.01983819f, 0.04179289f, 0.01149976f, 0.02256880f, -0.02944764f, 
    -0.02845349f, -0.02342672f, -0.02888460f, 0.00022281f, 0.02008758f, -0.05249967f, -0.04591959f, -0.02982150f, 
    0.03857639f, -0.05382377f, 0.01888492f, -0.04705384f, -0.05141309f, 0.00320891f, -0.05385174f, 0.02011870f, 
    -0.04241980f, -0.04438580f, -0.04595151f, -0.03084869f, 0.00796947f, -0.03247348f, -0.04942676f, -0.04416080f, 
    0.02467679f, -0.00949179f, -0.03958491f, -0.01458981f, 0.02178552f, -0.03776983f, 0.01420223f, -0.03997586f, 
    -0.01174881f, -0.02694458f, 0.03442394f, 0.01744653f, 0.03592631f, -0.03251770f, -0.01505182f, -0.00228987f, 
    -0.00695825f, -0.00505115f, 0.01569905f, 0.02381049f, -0.02601709f, 0.03350787f, -0.01093226f, -0.01848074f, 
    -0.02141833f, 0.00447061f, -0.03646029f, -0.04133803f, 0.04074052f, -0.03175569f, 0.04666927f, 0.03300450f, 
    0.02067341f, -0.04552958f, -0.01913097f, 0.00891538f, 0.02627837f, 0.02872317f, -0.05846201f, -0.01452874f, 
    -0.04526981f, 0.00020037f, 0.03568424f, -0.00417990f, -0.02877127f, -0.01987861f, 0.02952679f, 0.04206903f, 
    -0.04181360f, -0.03462067f, -0.05293617f, -0.03448120f, -0.01172645f, -0.03318372f, 0.02480434f, -0.03103242f, 
    -0.04524533f, 0.03809134f, 0.01573619f, -0.04284246f, 0.00570905f, -0.03950049f, -0.01290264f, -0.00437004f, 
    -0.02794458f, -0.02362951f, 0.03799018f, 0.02459291f, -0.03321401f, -0.00872862f, -0.00163159f, -0.04830475f, 
    0.00991142f, 0.04026133f, -0.02932335f, -0.04394996f, -0.04455286f, -0.02926032f, -0.00620473f, -0.02193314f, 
    -0.01036814f, 0.00071202f, -0.01163790f, 0.00645924f, 0.00471446f, -0.03107358f, 0.02083663f, 0.02890207f, 
    0.02800017f, -0.04180107f, -0.01920269f, -0.05830192f, 0.00834460f, -0.04408325f, 0.02325223f, -0.01865971f, 
    -0.05495818f, 0.01405192f, -0.01620877f, -0.02887847f, -0.04041130f, -0.01751138f, 0.02028467f, 0.00231610f, 
    -0.01227039f, -0.01252060f, 0.00587329f, 0.01747149f, 0.02228533f, -0.04546740f, 0.00475587f, 0.03183749f, 
    -0.04624094f, -0.03861310f, 0.01809583f, -0.02205270f, 0.00306318f, 0.02221126f, 0.00022832f, -0.04173851f, 
    0.02436863f, 0.00580740f, -0.03511603f, -0.01134676f, 0.03597376f, 0.02882144f, -0.02885898f, 0.00976187f, 
    -0.05052148f, 0.00711599f, 0.04084463f, 0.03810797f, -0.01682454f, -0.04546202f, -0.03481473f, 0.02936390f, 
    0.01003843f, 0.01552493f, 0.05023729f, 0.01355614f, -0.02312273f, -0.00999067f, 0.00078477f, -0.00387773f, 
    -0.01243656f, -0.00362221f, -0.05387758f, -0.00627916f, -0.02833322f, 0.02834480f, -0.03641186f, -0.02085551f, 
    0.03544680f, 0.03956205f, 0.04345785f, -0.03538878f, 0.03884406f, -0.04173204f, -0.00976394f, -0.02607807f, 
    -0.02497971f, 0.06538769f, -0.17324652f, 0.13410515f, 0.08788277f, 0.08314127f, 0.12237502f, 0.07490371f, 
    0.11209794f, 0.15897518f, -0.04878569f, 0.17898870f, 0.13207664f, -0.15037706f, 0.00632581f, 0.03248349f, 
    0.14183888f, -0.12564196f, 0.00349804f, 0.00977849f, -0.11662523f, 0.20012482f, -0.05818049f, -0.01599487f, 
    0.30164659f, -0.24843848f, -0.24260576f, -0.11664589f, 0.04260366f, 0.03977967f, -0.08606761f, 0.06423002f, 
    -0.00787820f, 0.00904057f, -0.09689324f, 0.08280201f, 0.00026879f, -0.12947048f, -0.20248705f, -0.05235830f, 
    0.06828032f, 0.11310834f, 0.00684709f, -0.10658807f, -0.00426098f, 0.05324635f, -0.02580941f, 0.11677118f, 
    -0.13576558f, 0.04890130f, 0.26608235f, 0.09329440f, 0.20824441f, 0.02703093f, -0.26430783f, 0.02445513f, 
    -0.00411776f, -0.09993987f, 0.11003191f, 0.15761949f, 0.06729297f, 0.02258598f, -0.01388316f, 0.14755850f, 
    -0.00524763f, 0.17506886f, 0.19338505f, 0.11708822f, 0.18895377f, 0.12065482f, -0.00068501f, 0.17456372f, 
    -0.10665618f, 0.46705857f, 0.32101431f, 0.00297693f, -0.07345445f, 0.11785091f, 0.09688066f, -0.04475728f, 
    -0.06708573f, 0.00148461f, -0.04091603f, 0.09662932f, 0.16874827f, 0.08843260f, -0.17805499f, -0.19886982f, 
    0.05872461f, -0.00704286f, -0.12030809f, -0.01954846f, -0.06778394f, -0.01531570f, 0.03725906f, -0.14008322f, 
    0.13181634f, 0.20649230f, 0.22401072f, -0.01116349f, 0.05913883f, -0.01358733f, -0.05206225f, 0.05907081f, 
    0.14130798f, -0.07450328f, 0.05124891f, -0.03555450f, -0.23865989f, -0.11057723f, -0.24862973f, 0.11313034f, 
    -0.08576115f, 0.01415878f, 0.11331852f, -0.17032987f, 0.11600829f, 0.13921970f, 0.10773227f, 0.09358460f, 
    -0.28755552f, -0.00528363f, -0.01744942f, 0.04653633f, -0.00683751f, 0.02222245f, -0.32298630f, -0.01057228f, 
    0.07683056f, 0.09703270f, 0.01836675f, 0.22657391f, -0.04957065f, 0.02514026f, -0.15733460f, 0.08239979f, 
    -0.06031315f, -0.14616573f, -0.05636540f, -0.13862137f, 0.02410000f, -0.19647211f, 0.11012026f, 0.08250839f, 
    -0.06106103f, 0.13173644f, -0.14534180f, 0.03976738f, 0.00692527f, 0.09294535f, 0.04865924f, 0.14657028f, 
    0.11052272f, -0.22347176f, -0.00123015f, 0.05538343f, 0.04160126f, -0.36202836f, -0.02961095f, 0.06929951f, 
    0.20926073f, -0.10740634f, 0.26224914f, 0.01813202f, 0.10327251f, 0.10144330f, 0.15018883f, 0.00386320f, 
    -0.29797605f, -0.15267417f, -0.15123112f, 0.07629528f, -0.09651126f, -0.21961384f, -0.21881372f, -0.11334780f, 
    -0.07568204f, -0.08445709f, -0.09787147f, 0.02554195f, -0.33770290f, -0.29573965f, -0.49823910f, 0.24252871f, 
    -0.13927825f, 0.15692502f, -0.08976429f, 0.04365499f, 0.07328543f, 0.07691496f, 0.16826439f, -0.04722294f, 
    0.21854591f, 0.04492418f, -0.07570083f, -0.03125565f, 0.17612150f, 0.13215408f, 0.10353655f, -0.03118446f, 
    0.12140130f, 0.00230996f, 0.10425260f, 0.07196777f, -0.05761523f, -0.17543736f, 0.46069059f, -0.14671518f, 
    0.24856898f, -0.08583450f, -0.16099399f, 0.28123090f, 0.02429679f, -0.00438280f, 0.15224096f, 0.10066818f, 
    0.45490319f, 0.02125594f, 0.06508486f, 0.13582163f, 0.06251202f, -0.13952969f, 0.07988337f, 0.06903739f, 
    -0.08968295f, 0.27553225f, -0.10633343f, -0.10402162f, 0.14208037f, 0.34795180f, -0.14139736f, -0.33131289f, 
    -0.17055541f, 0.14290200f, -0.04828878f, 0.12447335f, -0.00525712f, 0.00912013f, 0.02192209f, 0.03845438f, 
    0.13706636f, 0.49738654f, 0.19933833f, 0.00688570f, 0.13554317f, 0.08575659f, 0.04599317f, -0.05931494f, 
    -0.03349993f, 0.02470068f, -0.06553193f, 0.00572550f, 0.29029679f, 0.13479216f, -0.18550780f, -0.24409705f, 
    -0.14914045f, 0.07783989f, 0.12098327f, -0.05244753f, -0.14635175f, -0.11402462f, -0.02163964f, 0.06424391f, 
    -0.03755940f, 0.02878303f, -0.10022097f, 0.26822582f, 0.18475291f, -0.07721543f, -0.07787602f, -0.01756950f, 
    0.21178903f, 0.10301280f, -0.03555738f, 0.15869215f, -0.15786341f, -0.34078413f, 0.16094939f, -0.33277875f, 
    0.21688360f, -0.09688817f, 0.00417905f, 0.18412405f, 0.21409391f, 0.02741154f, 0.02768545f, 0.05001336f, 
    0.02233006f, -0.01422965f, 0.07512587f, 0.17828740f, -0.12728162f, 0.17290419f, -0.17241052f, 0.05567495f, 
    0.08059963f, 0.08238511f, 0.00965681f, 0.12691323f, -0.02792569f, 0.01216239f, -0.19141912f, -0.07182878f, 
    0.10410655f, 0.16213332f, -0.04616412f, 0.11078081f, 0.03143949f, -0.04294492f, 0.06415034f, -0.07493555f, 
    -0.14309002f, -0.02348304f, 0.06068022f, -0.10158480f, 0.11239294f, 0.08022077f, -0.17872939f, -0.09419546f, 
    0.11615036f, 0.28730866f, 0.19128028f, 0.00814976f, 0.02054847f, -0.04273066f, -0.25759965f, -0.07468746f, 
    -0.08018915f, 0.18787812f, 0.00226830f, 0.01354227f, 0.04278360f, 0.00480213f, 0.05284201f, -0.05042771f, 
    -0.16668272f, 0.07625808f, -0.19303757f, -0.24830906f, 0.07053600f, 0.03814203f, 0.21845867f, 0.25547892f, 
    0.04502769f, 0.12163980f, 0.03712662f, -0.05462387f, -0.26209408f, 0.04940550f, 0.10603941f, 0.13903062f, 
    0.08061844f, -0.15589744f, -0.03180651f, -0.05635355f, 0.01291172f, -0.03967494f, -0.04420963f, 0.02713451f, 
    0.27139249f, 0.22508569f, 0.22759371f, -0.18818340f, -0.12284167f, -0.03928354f, 0.28272006f, 0.04490126f, 
    0.02114571f, -0.09076749f, -0.07012309f, -0.01997467f, -0.24350560f, -0.01958274f, 0.05795441f, -0.07742583f, 
    0.23939781f, 0.05172199f, -0.05434126f, 0.17023842f, 0.02105601f, 0.17089510f, 0.08192901f, -0.09863997f, 
    0.11186956f, -0.10467112f, -0.11344260f, -0.33886304f, -0.01238800f, -0.02020940f, -0.04232171f, -0.17401093f, 
    -0.00888974f, 0.02860428f, -0.11538316f, -0.22014467f, 0.05659354f, 0.09074187f, -0.15070847f, 0.20606878f, 
    0.03256659f, -0.02209716f, -0.05242218f, -0.12007546f, 0.12673561f, -0.01577793f, 0.08952052f, 0.25154430f, 
    0.11144523f, 0.28968588f, 0.20438902f, 0.05032655f, 0.25765654f, 0.09801373f, 0.05338203f, -0.00372644f, 
    0.08496864f, 0.11934818f, 0.11322257f, 0.05574417f, -0.17681122f, 0.09236407f, -0.25442564f, 0.03505046f, 
    0.17876436f, 0.09842053f, 0.00686592f, 0.07386568f, 0.04092796f, -0.17191760f, -0.19959678f, -0.12704687f, 
    -0.45839426f, 0.08963027f, -0.28994438f, 0.23627838f, 0.07478859f, 0.03064834f, -0.28467864f, 0.07764254f, 
    0.12660748f, -0.00471689f, -0.02626554f, -0.06893173f, 0.22255556f, -0.34107611f, 0.19214010f, -0.19052258f, 
    -0.01918778f, 0.04468684f, 0.04432043f, 0.00450369f, -0.00609348f, -0.07593909f, -0.27846935f, -0.11742680f, 
    0.15835783f, -0.05330741f, -0.10989862f, 0.14436027f, 0.17616944f, 0.14760563f, 0.09589987f, 0.06390344f, 
    -0.05340854f, -0.02909172f, 0.09654781f, 0.24187434f, -0.18412119f, 0.20874670f, 0.07972749f, 0.18839419f, 
    0.08742862f, 0.01034798f, 0.02542754f, 0.19492733f, 0.19928065f, 0.07054285f, 0.02440185f, 0.02245156f, 
    0.02578938f, -0.11991648f, 0.14007406f, 0.22926900f, 0.08459896f, 0.15131120f, 0.07320955f, 0.08748882f, 
    0.09543025f, 0.00179075f, 0.12635070f, 0.22229807f, 0.20877714f, -0.37002632f, -0.11148217f, -0.32772252f, 
    0.05234181f, -0.14793389f, -0.08653139f, 0.07373951f, 0.11399508f, -0.04906050f, 0.11082892f, 0.12670898f, 
    -0.19373354f, -0.05603687f, -0.07649966f, -0.16779737f, 0.03755716f, 0.01031738f, -0.02005221f, 0.00635754f, 
    -0.03056970f, -0.09469946f, -0.07216602f, -0.07339700f, -0.01561374f, -0.22031371f, 0.12192180f, -0.23396389f, 
    -0.15687416f, 0.15263902f, 0.02027660f, -0.06887418f, 0.09507985f, 0.17231525f, 0.00693877f, 0.16825989f, 
    -0.05062684f, 0.03007537f, 0.10234866f, -0.03983473f, -0.00933081f, 0.20290425f, -0.10589433f, 0.09923802f, 
    0.09045473f, 0.10574024f, -0.10580019f, 0.00443754f, 0.18411231f, 0.26426288f, 0.10108635f, 0.24163170f, 
    0.11397944f, -0.00980847f, 0.13587198f, 0.08158585f, 0.18182270f, -0.11644860f, 0.05345887f, 0.15470299f, 
    0.11243850f, -0.18092960f, 0.09577332f, 0.00046244f, -0.08866401f, 0.06805727f, 0.06442716f, 0.07676668f, 
    0.11514407f, 0.06226832f, 0.05474789f, 0.10288465f, 0.45826727f, -0.18041185f, 0.08901663f, 0.23628466f, 
    -0.05549387f, 0.09333477f, -0.17719628f, 0.01016184f, 0.16281013f, 0.06981815f, -0.08534835f, 0.02938021f, 
    0.22323129f, 0.06065658f, 0.01520350f, 0.03924876f, 0.05386538f, 0.11766299f, 0.05383887f, 0.00426723f, 
    -0.11071232f, 0.12042261f, -0.06829640f, -0.08116570f, -0.01616400f, -0.21737026f, -0.14082764f, -0.39376587f, 
    -0.09836529f, 0.17567974f, -0.10234687f, -0.33785224f, 0.09356572f, -0.19037464f, -0.12155962f, 0.00066780f, 
    -0.15523224f, 0.00518515f, 0.04624008f, -0.26433364f, 0.13008673f, -0.07415772f, -0.13814707f, -0.13221195f, 
    -0.12670727f, -0.17968544f, 0.06710394f, -0.01828922f, 0.25943142f, 0.06984645f, 0.17624307f, 0.12474480f, 
    0.33689868f, 0.14571017f, 0.27042213f, 0.21910042f, 0.00920237f, 0.01042858f, -0.00661201f, -0.14629567f, 
    0.02261427f, 0.00755067f, -0.07020109f, 0.18885602f, 0.10029227f, -0.01402189f, -0.00894259f, 0.21586633f, 
    0.02222357f, -0.07994360f, 0.04136425f, 0.33121064f, -0.12705484f, 0.31567067f, 0.39113575f, 0.26089939f, 
    0.36074647f, -0.12755057f, 0.09899956f, 0.20122910f, -0.14195491f, -0.14776859f, -0.11548547f, -0.17039803f, 
    0.14069019f, -0.10252226f, -0.09427531f, 0.03089930f, 0.02260938f, -0.17066631f, -0.12495587f, -0.23624133f, 
    -0.08256059f, 0.08230814f, 0.00267680f, -0.06178152f, -0.21833655f, 0.25273159f, -0.31405815f, -0.15267102f, 
    -0.11193615f, -0.02580009f, 0.02474636f, -0.22000328f, 0.11228652f, 0.01011812f, 0.16901363f, -0.04461532f, 
    -0.03990293f, -0.16167460f, -0.15436921f, -0.04294588f, 0.04968357f, -0.35696876f, 0.07365467f, -0.44623879f, 
    -0.02815541f, 0.07898508f, -0.18672985f, -0.11927681f, 0.19255184f, -0.01837274f, 0.14632899f, 0.16041593f, 
    0.01996862f, 0.07589211f, 0.00521244f, 0.13614962f, 0.10014768f, -0.07388408f, -0.18792003f, -0.03837188f, 
    -0.08296765f, -0.06802037f, 0.20117278f, -0.16559994f, -0.06629422f, 0.09098338f, -0.09038188f, -0.17735188f, 
    0.01583569f, -0.09396557f, 0.05040926f, 0.09360214f, -0.21310057f, -0.17437622f, 0.12426463f, -0.16475217f, 
    0.12471246f, -0.27722567f, 0.18526481f, -0.10030751f, 0.02421577f, -0.24813683f, -0.21373902f, -0.01514840f, 
    0.12314593f, 0.21251076f, -0.03973755f, 0.07823230f, 0.19064553f, 0.13386138f, 0.04881303f, 0.15131073f, 
    -0.14260846f, -0.05814746f, -0.16087444f, -0.09035056f, 0.12349932f, -0.28609043f, 0.34236774f, -0.28733107f, 
    -0.10422577f, 0.01140533f, -0.04499480f, 0.09258913f, -0.05124001f, -0.16093291f, 0.09010376f, -0.23235872f, 
    0.04564781f, 0.30974028f, 0.07469264f, -0.14152367f, 0.02677761f, 0.03426038f, 0.14421743f, 0.25642297f, 
    0.13480143f, -0.02490733f, 0.04198120f, 0.16634472f, -0.05892187f, 0.17673652f, -0.03181821f, -0.02452626f, 
    -0.02369807f, 0.07966979f, -0.07987739f, -0.07089933f, 0.05015877f, 0.06542038f, 0.08294152f, 0.31273419f, 
    -0.05406097f, 0.00727668f, -0.01108353f, -0.00121624f, 0.03336854f, -0.03466378f, -0.03750607f, -0.00879693f, 
    -0.00322752f, -0.02689236f, -0.02852955f, -0.01621964f, -0.05058099f, 0.02049347f, -0.00337359f, -0.03291344f, 
    -0.02621363f, 0.00869268f, -0.05631379f, 0.01901821f, -0.05755376f, -0.04124032f, 0.02241571f, 0.03621447f, 
    -0.02254663f, -0.00645422f, -0.01538186f, 0.03770946f, -0.00476905f, 0.03211093f, -0.03173181f, -0.05719934f, 
    -0.02690625f, 0.00190348f, 0.00012336f, 0.01564806f, -0.01713471f, 0.00008193f, -0.01712469f, -0.01768738f, 
    0.02116953f, -0.00934440f, -0.04705410f, 0.00480474f, -0.00769031f, 0.01583288f, -0.04661440f, -0.00079917f, 
    -0.04110011f, 0.01156166f, 0.03220372f, 0.02629163f, -0.00955464f, 0.04118117f, -0.05251684f, -0.01634449f, 
    0.01011942f, -0.01343627f, -0.03773727f, 0.00652928f, 0.03329983f, -0.05159938f, -0.00387038f, -0.03753974f, 
    -0.04638756f, 0.03945290f, 0.04256422f, 0.02089230f, -0.04455464f, 0.03702695f, 0.03427543f, -0.03617566f, 
    0.03888793f, 0.03591114f, -0.00420638f, -0.00332120f, -0.04848863f, -0.00714170f, -0.00409439f, -0.03055228f, 
    0.03044484f, 0.03411031f, 0.00831828f, -0.00069507f, 0.00069430f, -0.04647916f, -0.04202570f, -0.01303276f, 
    0.00751545f, -0.04806494f, 0.00393881f, -0.00239837f, 0.01065321f, -0.02409985f, -0.02279067f, 0.00607716f, 
    -0.03631166f, 0.01075530f, -0.03074836f, -0.03952025f, 0.01000832f, -0.01471150f, -0.04129256f, -0.04544744f, 
    -0.05517554f, 0.03347652f, 0.03258181f, -0.01899518f, -0.03952040f, 0.01068040f, 0.01013036f, -0.05414206f, 
    -0.03084117f, -0.05243847f, 0.01503117f, -0.04730079f, -0.02882017f, 0.03261390f, 0.01850319f, -0.02926689f, 
    -0.03645989f, 0.01767970f, -0.03536276f, 0.02632815f, -0.00305290f, 0.03351828f, -0.02380571f, 0.00403984f, 
    0.03838110f, -0.00672589f, -0.01266172f, -0.04274518f, 0.02601909f, 0.02428809f, 0.03131338f, 0.03828738f, 
    -0.03287635f, -0.02326494f, -0.01280619f, -0.04068844f, 0.01364944f, -0.00393020f, -0.03316776f, 0.02928876f, 
    -0.02857505f, 0.01655906f, 0.03988307f, -0.03206693f, 0.02997798f, -0.04391406f, -0.04159758f, 0.00602640f, 
    0.00744720f, -0.01408047f, -0.00154123f, 0.03044108f, -0.01397546f, -0.04106892f, 0.01084326f, 0.03704237f, 
    -0.01598728f, -0.01714076f, 0.02747988f, 0.03070866f, 0.02499336f, -0.03292134f, 0.02678243f, 0.02649456f, 
    -0.04253019f, -0.00392838f, 0.00305947f, -0.05867405f, -0.04990864f, 0.02702694f, 0.00101951f, -0.04131329f, 
    -0.04433481f, -0.00809334f, 0.00413699f, 0.00235208f, 0.03816962f, -0.03071760f, -0.04558751f, -0.01847149f, 
    0.01190381f, 0.01406067f, -0.04508397f, -0.03808754f, -0.01333557f, 0.00759207f, 0.02193435f, -0.02662412f, 
    -0.03361997f, 0.01101894f, -0.03464205f, -0.01309353f, 0.04232294f, -0.00538128f, -0.02425387f, 0.02847664f, 
    -0.00164172f, -0.04864066f, -0.00677237f, -0.00743017f, -0.04033092f, 0.04020382f, -0.03189523f, -0.01828738f, 
    0.00353391f, 0.02217291f, -0.01599301f, -0.01251540f, 0.03709792f, 0.03539497f, 0.00029011f, 0.03586817f, 
    -0.04929076f, -0.05061645f, -0.01817670f, 0.00099555f, 0.02260985f, -0.01680259f, -0.01851031f, 0.03936200f, 
    0.01606755f, 0.00479234f, -0.00898208f, 0.03698851f, -0.00410818f, 0.01381570f, 0.01937478f, 0.01949683f, 
    0.00879856f, -0.02875862f, -0.05771451f, 0.02490199f, -0.01640853f, 0.02969792f, 0.03426668f, 0.02178831f, 
    0.03452236f, -0.04789338f, -0.01513009f, -0.05490518f, 0.03665352f, 0.01142621f, -0.05317321f, -0.03120249f, 
    0.02741792f, 0.01401064f, -0.03441993f, 0.02717860f, -0.01425834f, 0.03803048f, 0.00002786f, 0.02642333f, 
    0.03662940f, 0.03540637f, -0.02471346f, 0.03037547f, -0.02782775f, -0.05644490f, -0.04451694f, -0.04237962f, 
    -0.01307792f, -0.00750714f, -0.00164333f, -0.05635282f, 0.01513716f, -0.04290471f, 0.00758050f, 0.00925596f, 
    -0.02208621f, -0.00094344f, -0.01717280f, 0.03152973f, -0.05699960f, -0.03376464f, -0.01099191f, 0.00037360f, 
    -0.02531500f, 0.03450422f, 0.02279568f, -0.01370909f, 0.01263529f, 0.00032271f, -0.03776187f, -0.00849937f, 
    0.03039043f, -0.04270706f, -0.00844149f, -0.02405551f, -0.05781300f, 0.03809427f, 0.00599965f, -0.01478306f, 
    -0.01672578f, -0.04734875f, -0.02238480f, -0.01959417f, 0.00147745f, 0.03065004f, -0.04450570f, 0.00239048f, 
    -0.01255390f, -0.01773282f, 0.03536436f, 0.02523742f, -0.05693281f, 0.02460311f, -0.04533114f, -0.03417833f, 
    0.00147295f, -0.04607684f, -0.03375838f, 0.03768161f, -0.00937179f, -0.00206919f, 0.02557469f, 0.00039778f, 
    -0.00002187f, -0.05400813f, 0.02192272f, -0.04565569f, -0.02270924f, -0.02731221f, 0.00665361f, 0.03330474f, 
    0.03689822f, 0.00703230f, -0.04503796f, -0.01165096f, 0.00265748f, 0.00195114f, 0.03934129f, -0.01431604f, 
    -0.01925788f, -0.05129628f, -0.00477093f, 0.03782552f, 0.03688966f, -0.00349132f, -0.03471946f, -0.00711190f, 
    -0.03769526f, 0.03325283f, 0.01698331f, -0.01899000f, -0.05137422f, 0.00901905f, -0.04280327f, -0.03466229f, 
    0.01060960f, -0.00995991f, -0.04280395f, -0.03673918f, -0.01137411f, -0.05189390f, 0.00809514f, -0.00552344f, 
    -0.05399716f, 0.04466093f, -0.04988607f, -0.01293980f, -0.01883946f, -0.05594310f, -0.01175146f, -0.04569256f, 
    0.01743834f, -0.03954259f, -0.05498859f, -0.02937185f, 0.02914372f, -0.04224760f, 0.04231454f, -0.05693302f, 
    0.02181489f, -0.00294503f, 0.01055810f, 0.04101468f, -0.05783129f, -0.02999496f, 0.01705202f, -0.04093117f, 
    -0.05076378f, 0.01362279f, -0.05317209f, 0.03469197f, -0.04080839f, -0.00282877f, -0.05447492f, -0.05341605f, 
    0.02842434f, -0.00653367f, 0.02483062f, -0.03820428f, -0.03204883f, -0.03855394f, -0.01583717f, 0.03337505f, 
    -0.04227017f, -0.05086859f, 0.03516135f, -0.05414086f, -0.02884700f, -0.04678274f, -0.04801972f, -0.00708742f, 
    0.01671416f, 0.04067701f, -0.00241219f, -0.01723026f, -0.00261581f, -0.02308312f, -0.02115500f, -0.01927510f, 
    -0.01548028f, -0.03504312f, 0.01749122f, -0.02473315f, -0.05630218f, -0.05262776f, 0.00965950f, 0.00344951f, 
    0.01762674f, -0.03152786f, 0.03918764f, 0.01644416f, -0.04230890f, 0.04000926f, -0.02978219f, 0.00533615f, 
    -0.04881725f, 0.02735904f, -0.01666204f, -0.00543678f, -0.03619001f, 0.01733475f, -0.05672098f, -0.02853585f, 
    0.02941418f, 0.00883324f, -0.02225046f, 0.03064198f, -0.01668595f, 0.00229275f, -0.00164691f, -0.00207793f, 
    0.02879258f, 0.04243719f, 0.00419091f, -0.01536704f, 0.04081940f, -0.04524528f, 0.02895729f, -0.01899200f, 
    0.03650386f, -0.03989615f, -0.02792540f, -0.02830425f, 0.01437938f, -0.03715111f, -0.01629463f, 0.00130991f, 
    -0.02631608f, 0.03033634f, -0.00886772f, 0.02003041f, -0.03004210f, -0.02355481f, -0.02005725f, -0.03553703f, 
    -0.00013682f, 0.00794675f, -0.05352133f, -0.03117488f, -0.05048660f, -0.01519033f, -0.01298603f, 0.03028204f, 
    0.02880308f, -0.04801383f, -0.02733949f, -0.01310707f, -0.04118025f, -0.03028264f, -0.00567009f, 0.02533002f, 
    0.01654261f, -0.00478281f, 0.04413839f, 0.02760963f, 0.00200385f, -0.02546380f, -0.01400347f, 0.03748251f, 
    -0.04590731f, -0.05592247f, 0.03820530f, -0.01433816f, -0.00119927f, -0.02463795f, -0.04011694f, 0.02912427f, 
    -0.02182299f, -0.01592137f, -0.01245048f, -0.04885733f, -0.02251873f, -0.01671480f, 0.04112044f, 0.04405063f, 
    0.00312410f, 0.01135506f, 0.01082753f, -0.03949387f, 0.01578673f, -0.03277955f, -0.02936479f, -0.02684493f, 
    0.00340424f, -0.02220996f, -0.02437755f, -0.03069010f, 0.01424279f, -0.03998113f, -0.05500024f, 0.01736156f, 
    -0.02256101f, -0.00800371f, 0.00287194f, -0.02253156f, -0.00515454f, -0.01173407f, -0.02547629f, -0.00296381f, 
    -0.04187075f, 0.03207953f, -0.02560708f, 0.01432295f, 0.01656858f, 0.03932905f, 0.00067926f, -0.03755753f, 
    0.01387321f, -0.04976958f, 0.04370956f, -0.04395759f, -0.01045819f, -0.04483955f, 0.00472851f, 0.04383157f, 
    0.01979756f, 0.01650411f, 0.00869625f, 0.03884323f, 0.00539160f, 0.00770023f, -0.05026139f, -0.01453479f, 
    -0.00028383f, -0.00749051f, 0.02236339f, -0.03289259f, -0.02560256f, -0.04238021f, 0.00532956f, -0.05142902f, 
    -0.05178576f, 0.00964122f, -0.03282204f, 0.01382436f, 0.00267919f, -0.05676452f, -0.05175231f, -0.02498025f, 
    0.00427198f, 0.01512043f, -0.00132113f, -0.02126351f, -0.04617716f, -0.00464236f, -0.01598448f, 0.02358599f, 
    -0.00589982f, 0.03952263f, -0.02885194f, -0.01779585f, -0.03835518f, 0.04333306f, -0.01692395f, -0.03218495f, 
    -0.01444563f, 0.00994969f, -0.04252584f, 0.01507329f, -0.05694976f, 0.02387182f, 0.03714189f, 0.00977993f, 
    -0.05429358f, -0.02835037f, 0.03223768f, -0.05624743f, -0.04574916f, -0.00303785f, 0.00394413f, -0.02753846f, 
    0.00511354f, -0.03189968f, -0.00907194f, -0.02407325f, -0.01713753f, 0.00447322f, -0.05529162f, 0.01787766f, 
    0.01523478f, 0.01912889f, -0.05448337f, 0.03680399f, -0.03650222f, 0.03351821f, 0.03674392f, 0.04498638f, 
    0.01377619f, -0.05030781f, -0.05226914f, -0.00687692f, -0.00159308f, 0.01773867f, 0.01979031f, -0.01865336f, 
    -0.01442959f, 0.00997588f, -0.01675429f, 0.02552361f, -0.01274384f, -0.01947430f, 0.00301461f, 0.02618533f, 
    0.00205606f, 0.02325046f, -0.02884461f, -0.04102002f, 0.03782091f, -0.04001841f, 0.01861688f, 0.00415082f, 
    -0.04610921f, -0.05137463f, 0.02203090f, -0.02017719f, -0.03119853f, 0.01413681f, -0.02165446f, 0.02053971f, 
    -0.03324654f, -0.05007350f, -0.01076183f, -0.03103792f, -0.04214085f, 0.01983744f, -0.03528577f, -0.04631345f, 
    -0.02863620f, 0.02821578f, 0.02100488f, -0.03051455f, -0.01408980f, 0.01783316f, 0.00982802f, -0.00599130f, 
    -0.03235815f, -0.04826785f, 0.03527620f, 0.00706683f, -0.00338751f, 0.03487009f, -0.03833264f, 0.03428616f, 
    0.02506462f, 0.03522147f, 0.01022803f, -0.05585402f, -0.03707109f, 0.00288163f, -0.05474722f, -0.00383760f, 
    -0.04577540f, -0.00006318f, 0.02557382f, 0.01844554f, 0.03070253f, 0.03657973f, -0.00508715f, -0.02970232f, 
    -0.05246449f, 0.03047314f, -0.03506076f, 0.00276131f, 0.03725483f, 0.03694117f, -0.02704501f, -0.03807558f, 
    0.01758782f, 0.01279018f, -0.01015704f, -0.01492806f, 0.01040224f, 0.02316207f, -0.02965281f, 0.03049268f, 
    0.03962819f, 0.00526390f, -0.02625488f, 0.03711915f, 0.01210721f, -0.01198110f, 0.04310895f, 0.02423664f, 
    -0.04865840f, -0.00183710f, -0.04238971f, -0.03156594f, 0.02810517f, 0.01057989f, -0.00409820f, -0.01995995f, 
    0.00680336f, -0.01247156f, -0.01006221f, 0.00984196f, -0.03723149f, -0.01643437f, -0.01105708f, -0.03215170f, 
    0.01541476f, 0.02897948f, 0.01410068f, -0.02286016f, -0.02918845f, -0.05403484f, -0.00315452f, -0.01278708f, 
    0.03419609f, -0.04097359f, -0.05693394f, 0.00241090f, 0.02506667f, -0.01358998f, -0.00743656f, 0.01730985f, 
    0.03963253f, -0.05470282f, -0.02415181f, 0.04066180f, -0.00073489f, -0.01475999f, -0.05224407f, -0.04839756f, 
    0.03221818f, -0.02738581f, 0.03565787f, -0.02998005f, 0.03482734f, 0.04177773f, 0.01000650f, 0.01727572f, 
    -0.04236541f, -0.02855940f, 0.02328167f, 0.03919591f, 0.00836741f, 0.02295719f, -0.03194381f, 0.01113686f, 
    0.00370893f, 0.02129917f, 0.00405592f, 0.00111706f, 0.01966390f, 0.02016370f, -0.03249769f, 0.02347885f, 
    -0.01386042f, -0.01648963f, -0.03675948f, -0.00741799f, -0.03485651f, 0.03173928f, 0.04962493f, 0.02812792f, 
    -0.01681506f, -0.02741655f, -0.03752914f, 0.03808887f, 0.04752118f, -0.02643161f, -0.00517689f, 0.01247724f, 
    -0.01342542f, -0.03468870f, -0.04866159f, 0.02940851f, -0.02271657f, 0.03417985f, -0.03449503f, -0.03338785f, 
    -0.05491143f, -0.02340602f, 0.04045403f, -0.04385941f, -0.00631668f, -0.02354776f, 0.02696575f, 0.01099939f, 
    -0.02924689f, -0.04123522f, 0.02946251f, 0.00453856f, -0.01324925f, 0.00844901f, -0.03453514f, -0.01162588f, 
    0.02887667f, -0.02719473f, -0.01856952f, -0.01366730f, -0.05433007f, -0.02413606f, 0.04786041f, -0.02115633f, 
    -0.00575541f, 0.00943291f, 0.00167593f, -0.01378271f, -0.00148030f, 0.00153750f, -0.00465798f, -0.01806069f, 
    0.04850324f, -0.00499185f, -0.03978151f, -0.00374480f, -0.03478042f, 0.04416225f, 0.04353029f, -0.03259587f, 
    0.00572392f, 0.00782373f, 0.01709524f, 0.00115756f, -0.04387651f, -0.00774262f, -0.01409397f, -0.04559309f, 
    -0.01962235f, -0.02221078f, 0.00363684f, -0.04482877f, -0.04477443f, 0.03140662f, -0.00468383f, 0.01408198f, 
    -0.02105137f, -0.02591989f, 0.03437437f, 0.01891045f, 0.03823112f, 0.00217655f, 0.00571764f, 0.02381000f, 
    -0.00302498f, -0.00002958f, -0.04113578f, 0.02882354f, -0.00055179f, 0.04741748f, -0.02048808f, 0.02767350f, 
    -0.03066028f, 0.00016941f, -0.03736747f, -0.04273771f, -0.02918170f, 0.03627058f, -0.03519006f, 0.01278427f, 
    -0.04302018f, -0.03939921f, 0.01702151f, -0.05090538f, -0.00050134f, -0.03989010f, -0.04705612f, 0.02241477f, 
    -0.04747418f, 0.00122245f, 0.00401227f, -0.03669391f, -0.05574039f, 0.02878784f, 0.04626717f, -0.05423542f, 
    -0.02649234f, 0.03997383f, -0.03567038f, 0.01547133f, 0.01053971f, 0.00334112f, -0.03861835f, -0.04067237f, 
    -0.02121218f, -0.01096984f, -0.05223281f, 0.02191662f, -0.01215043f, 0.00941572f, -0.01931771f, 0.04197619f, 
    0.00969671f, -0.04389858f, 0.00749693f, 0.01846567f, 0.00293997f, 0.01851105f, -0.02058794f, -0.04078614f, 
    0.04675187f, 0.04513224f, 0.02335514f, -0.01403334f, 0.03790685f, 0.04191924f, -0.05604060f, 0.01842564f, 
    0.00848721f, 0.00748667f, -0.02636113f, 0.01620969f, -0.02002284f, -0.04264716f, -0.01127507f, -0.03045456f, 
    0.00932182f, -0.02758045f, 0.03717147f, 0.02421325f, -0.04467874f, 0.04455383f, 0.03143367f, -0.04316762f, 
    -0.02157523f, 0.04514386f, 0.01758910f, 0.01930544f, 0.00794420f, 0.00714995f, -0.02790044f, -0.01580738f, 
    0.03360530f, -0.01190234f, -0.01954985f, 0.03697200f, -0.01762713f, -0.01783619f, -0.00241536f, 0.03980547f, 
    -0.02378856f, -0.03351367f, 0.00703613f, 0.02283870f, 0.00475975f, 0.01277325f, 0.02443097f, -0.02256088f, 
    -0.00543413f, 0.05648655f, 0.02663038f, 0.00532627f, 0.01948630f, 0.00876122f, 0.01538704f, -0.00025697f, 
    0.02398953f, 0.01950138f, -0.02474505f, -0.03691657f, 0.02064440f, 0.00869140f, 0.03198781f, 0.00636738f, 
    -0.03970762f, 0.00412906f, -0.01887527f, 0.04051591f, -0.01248848f, -0.00569892f, -0.00077157f, -0.01674579f, 
    -0.02895996f, -0.03290761f, -0.03792148f, 0.01468210f, 0.03899388f, -0.05185196f, -0.05361718f, 0.04546428f, 
    -0.04247250f, -0.03360571f, -0.04944579f, -0.01269720f, 0.04725676f, -0.04666158f, 0.04434726f, 0.03754415f, 
    0.02794077f, 0.04436991f, 0.01843585f, -0.01100065f, -0.01877872f, -0.03952707f, -0.00969545f, 0.00118492f, 
    -0.03577790f, -0.00857658f, -0.05344481f, 0.00914831f, -0.03350044f, 0.02386088f, 0.05160420f, 0.03751382f, 
    0.00815492f, 0.03214309f, 0.00197752f, 0.02334038f, 0.02201296f, -0.01013569f, -0.01795853f, -0.04645523f, 
    0.03974070f, -0.05160665f, -0.01183441f, -0.03987100f, -0.01340096f, -0.03867485f, 0.02482942f, -0.01315890f, 
    0.01599127f, -0.01645215f, -0.00516617f, 0.02152373f, 0.02773668f, 0.03050100f, -0.03012228f, -0.00016397f, 
    -0.05836137f, 0.01252633f, -0.04710837f, -0.03063351f, -0.01531717f, 0.00564867f, -0.00610964f, 0.01081734f, 
    -0.05308229f, -0.03388890f, 0.04467500f, 0.00407489f, -0.02371872f, -0.03964745f, -0.00036257f, 0.01810900f, 
    0.00401595f, -0.04865901f, -0.05030452f, 0.02893686f, -0.03492837f, -0.03755723f, 0.03280908f, -0.01743314f, 
    0.03775941f, -0.03299215f, -0.03495483f, -0.05722548f, 0.03944215f, 0.03434179f, -0.00508596f, 0.00001178f, 
    -0.04638342f, -0.04010094f, 0.02408742f, -0.00925868f, -0.04607074f, -0.03378506f, 0.02949211f, 0.01161476f, 
    0.02368003f, -0.03555604f, -0.03988638f, 0.00388132f, -0.05123509f, 0.01736279f, -0.04089984f, -0.01094636f, 
    0.00842481f, 0.01094897f, -0.02055183f, -0.03253907f, -0.02553468f, -0.04335230f, 0.00068205f, -0.02158277f, 
    -0.02646884f, 0.02263270f, -0.03559045f, 0.02871875f, -0.04854716f, 0.04727374f, -0.02150899f, 0.02372242f, 
    -0.03202193f, -0.03247438f, 0.00603174f, 0.03411796f, -0.02600423f, 0.00185951f, -0.01028199f, -0.03151071f, 
    -0.05641947f, 0.04690090f, -0.01560641f, -0.01304615f, -0.01360995f, -0.01663910f, -0.04376878f, -0.04400961f, 
    -0.04174743f, 0.00904269f, 0.02699255f, 0.02918120f, 0.00104403f, -0.01466907f, -0.00085347f, -0.04371529f, 
    -0.04007682f, 0.02337248f, -0.01671941f, -0.01407574f, -0.03040916f, -0.04376552f, 0.00933155f, 0.02433185f, 
    -0.04282687f, -0.03300458f, -0.02996845f, 0.12926494f, 0.02954123f, -0.10910405f, 0.03835188f, -0.00649480f, 
    0.00667517f, 0.08511581f, -0.07903658f, 0.33411255f, -0.00337159f, 0.03405553f, 0.04029883f, -0.07254700f, 
    0.08051351f, -0.13481395f, 0.02103018f, 0.01710822f, -0.17736030f, 0.07608359f, -0.20474914f, -0.21762821f, 
    0.20062324f, -0.09067308f, -0.04328941f, 0.10603891f, 0.12098639f, 0.09867626f, -0.08570204f, 0.17559096f, 
    0.08920311f, -0.10502420f, 0.08625491f, -0.05595299f, -0.05002053f, 0.00995113f, -0.10035528f, 0.10985432f, 
    0.14364471f, -0.01197388f, 0.09717347f, -0.13228534f, 0.00803068f, 0.06977227f, 0.06037170f, 0.21358140f, 
    -0.32986784f, 0.00189665f, -0.17126565f, 0.08454654f, 0.19950776f, 0.05852851f, -0.05809839f, -0.09786223f, 
    0.06691267f, 0.07493081f, -0.01034429f, 0.11310548f, 0.11618714f, 0.07563682f, 0.01886600f, -0.02946831f, 
    -0.07087632f, -0.06177324f, 0.19367236f, -0.06809910f, 0.03075268f, 0.05883691f, 0.09497711f, 0.06181199f, 
    -0.06141963f, 0.22373079f, -0.18163222f, 0.05050804f, 0.06161812f, 0.18757068f, -0.12571289f, 0.08427873f, 
    0.09752534f, -0.10863644f, -0.09080098f, 0.04975958f, 0.08535093f, 0.03171632f, -0.20215484f, 0.03751387f, 
    -0.00740723f, -0.02909010f, -0.19747271f, -0.19884564f, 0.04154807f, 0.03095955f, 0.00506867f, -0.30044097f, 
    0.04318662f, 0.04949357f, 0.17267656f, -0.04195714f, -0.00818632f, 0.06984146f, 0.05445461f, 0.00571925f, 
    0.00225890f, -0.08531960f, -0.07382666f, -0.35538965f, -0.30344978f, -0.40124667f, -0.09856844f, -0.02169398f, 
    0.12345652f, 0.11462554f, 0.02548197f, 0.04598504f, 0.07729334f, 0.26140791f, -0.06975388f, -0.08190994f, 
    -0.23453188f, 0.03781205f, -0.04829445f, -0.00028715f, 0.03741609f, 0.02386673f, -0.04028519f, -0.04184841f, 
    -0.00196910f, 0.08097089f, 0.19075705f, 0.22177351f, 0.00747689f, -0.00759196f, -0.03718652f, -0.03526113f, 
    0.06080249f, -0.06863634f, -0.05849840f, -0.02948197f, -0.07300083f, -0.19017482f, 0.05317319f, -0.30512074f, 
    -0.24549805f, 0.05427709f, 0.20127793f, -0.16219178f, -0.09697839f, 0.01214395f, 0.19454995f, 0.07771438f, 
    0.33611816f, -0.03670622f, 0.08712654f, 0.20844847f, -0.10482742f, -0.10520799f, 0.11718255f, -0.12692513f, 
    0.14774059f, -0.09380335f, 0.18453464f, 0.08918572f, -0.05944476f, 0.06241988f, 0.01601924f, 0.00170280f, 
    0.04888451f, -0.00003271f, -0.00204505f, -0.00929440f, -0.01605949f, -0.04611512f, 0.03743976f, -0.04033228f, 
    -0.24624118f, -0.35340977f, -0.12862325f, -0.25559571f, -0.17439911f, -0.44610673f, -0.15544601f, 0.05150541f, 
    0.10661544f, 0.05918197f, 0.04620399f, 0.15573364f, 0.02036393f, 0.13897671f, -0.03433661f, -0.08791834f, 
    0.08276436f, -0.00268386f, 0.06146817f, 0.02091035f, -0.04761835f, 0.16539004f, 0.04644169f, 0.03268657f, 
    0.19100648f, 0.03977572f, -0.12046672f, 0.18605474f, -0.05828970f, 0.03316567f, -0.03029810f, -0.21355306f, 
    0.15298957f, -0.05562074f, -0.14394248f, 0.05143455f, 0.13396935f, 0.04422121f, 0.02081852f, 0.09367058f, 
    -0.00141049f, -0.06253112f, -0.07147057f, 0.10698286f, -0.01302261f, 0.01434342f, -0.06342271f, 0.14177136f, 
    0.06768133f, -0.03078868f, -0.09731025f, 0.20218925f, 0.17655805f, 0.39897057f, 0.24138370f, 0.12163661f, 
    0.21504138f, 0.17208761f, 0.22786267f, -0.15984222f, 0.12120935f, 0.12873603f, 0.04055078f, 0.11263242f, 
    0.04658787f, 0.26772815f, 0.02859618f, 0.05891916f, 0.13450439f, -0.03828714f, -0.10362831f, -0.10395882f, 
    -0.06875110f, -0.01849567f, -0.04032251f, -0.07698333f, -0.28985941f, 0.21267316f, 0.07562966f, 0.15812200f, 
    0.05129253f, 0.02310486f, -0.04015386f, -0.13060950f, 0.10311027f, 0.04548894f, 0.05683863f, 0.17728381f, 
    0.07056711f, -0.26146623f, -0.26578516f, 0.12925124f, 0.04592099f, -0.14884205f, -0.04692221f, 0.20351638f, 
    0.00504125f, -0.04894976f, -0.02839071f, 0.00814042f, -0.07253805f, 0.02455659f, -0.15529530f, 0.06733629f, 
    0.11487315f, 0.17487970f, -0.21291356f, -0.24730618f, -0.10382387f, -0.34008560f, 0.07167190f, -0.07377350f, 
    -0.02598615f, 0.00742047f, -0.08168498f, 0.04644842f, -0.05489337f, -0.12437808f, 0.00879020f, 0.02734416f, 
    -0.04829778f, 0.09681904f, 0.13873349f, 0.19097821f, -0.05995652f, -0.21895333f, 0.16338898f, 0.14473133f, 
    0.07780989f, 0.14666824f, -0.05854901f, 0.43722221f, 0.05121608f, 0.03433527f, 0.10301436f, 0.04618158f, 
    -0.17326875f, -0.07329046f, 0.02192522f, -0.05520055f, 0.04972801f, 0.08780170f, -0.00876413f, -0.01416668f, 
    0.08625032f, -0.04753707f, -0.21445391f, -0.36650303f, -0.23159359f, -0.09410644f, -0.07443566f, 0.00442984f, 
    0.02651060f, 0.09636815f, -0.01672326f, -0.03026914f, 0.03666589f, 0.00826573f, 0.07558197f, 0.02160778f, 
    -0.02611760f, 0.27234778f, 0.04598787f, 0.07702916f, 0.12363995f, 0.05712702f, 0.12057745f, -0.09007901f, 
    0.03281264f, 0.03629529f, 0.17599545f, 0.10819758f, 0.04153742f, 0.11973812f, 0.20348205f, -0.06691666f, 
    0.06806383f, -0.10650609f, 0.02630438f, -0.11343415f, 0.15187198f, -0.11767903f, 0.07124509f, 0.17309144f, 
    0.01740743f, 0.39940768f, 0.12590161f, -0.08286510f, 0.00851136f, -0.06833085f, 0.17520428f, 0.03287132f, 
    0.00694451f, -0.08151937f, 0.00230301f, -0.07160965f, -0.11484205f, -0.05312942f, 0.05407776f, 0.02108575f, 
    0.19865604f, -0.08903167f, -0.12493836f, 0.08401929f, -0.19792901f, -0.01359570f, -0.09360222f, -0.25750872f, 
    -0.16063693f, 0.11021923f, -0.03392953f, 0.03605038f, -0.00538114f, 0.12903768f, 0.14481489f, -0.05140636f, 
    -0.07644507f, -0.10630377f, 0.02623432f, 0.04675037f, -0.07322352f, -0.00348354f, -0.00896615f, -0.06194275f, 
    -0.02790693f, -0.14520083f, 0.02927050f, 0.11361686f, -0.12248770f, 0.05117877f, -0.10873353f, -0.25954139f, 
    0.32330886f, 0.22039860f, 0.01319259f, 0.10997256f, -0.01548381f, 0.01142122f, -0.00095201f, 0.02125251f, 
    0.12332589f, -0.03218933f, -0.02811155f, -0.02178160f, -0.11332982f, -0.11087325f, -0.01897186f, -0.01954827f, 
    -0.04056804f, 0.17645440f, 0.02682405f, 0.00827103f, -0.21104565f, -0.09009416f, 0.01177275f, 0.19187711f, 
    -0.33925581f, -0.54337680f, -0.15574846f, -0.16650636f, -0.15138133f, -0.06170655f, 0.01364185f, -0.10649303f, 
    -0.13191761f, 0.07163812f, 0.01677396f, 0.05271458f, -0.05582358f, -0.00093115f, -0.01036352f, -0.03365533f, 
    0.02531997f, 0.07993948f, 0.18551968f, -0.05773268f, -0.00510771f, -0.04861376f, -0.11800635f, -0.19024111f, 
    0.13326001f, 0.25844106f, 0.14725819f, -0.08729336f, 0.03971178f, 0.25610569f, 0.14947064f, -0.13063177f, 
    0.04034864f, 0.02107991f, 0.02833677f, -0.04236777f, 0.06543400f, -0.23582944f, -0.48580557f, -0.00092179f, 
    -0.03140384f, -0.28829604f, -0.19953983f, -0.02634527f, -0.15687867f, 0.04812161f, -0.02833053f, -0.01655636f, 
    0.20292385f, 0.09410402f, 0.11950032f, -0.03757269f, 0.08458417f, -0.03128374f, -0.06825820f, 0.04449828f, 
    0.02383806f, -0.06615955f, -0.03357242f, -0.02864800f, 0.22760952f, 0.22631678f, -0.06234147f, -0.09095444f, 
    -0.00763666f, 0.02219190f, -0.04298478f, -0.11901832f, 0.00065216f, -0.00783287f, -0.05405300f, -0.04081671f, 
    0.05756121f, -0.59061009f, -0.26870170f, -0.25731415f, -0.17915645f, 0.03858106f, 0.10315381f, -0.00582078f, 
    -0.08841465f, -0.00423692f, 0.11840384f, 0.04250320f, 0.11001515f, -0.13717809f, -0.14242302f, 0.02814878f, 
    -0.05012448f, -0.19185488f, -0.10127967f, -0.01476584f, -0.22346736f, -0.12893698f, -0.13057829f, -0.00205471f, 
    0.65585482f, 0.19532949f, 0.05907398f, -0.02158440f, -0.06525790f, -0.04242440f, 0.13571477f, 0.16612111f, 
    0.05067171f, 0.00436265f, -0.08136724f, -0.04160766f, 0.18795142f, -0.13677838f, 0.28556427f, 0.01979629f, 
    0.01523635f, 0.16731626f, 0.14138168f, -0.05302335f, 0.10957193f, 0.02588504f, -0.07852115f, -0.07702924f, 
    -0.14347668f, -0.05295582f, -0.05124107f, 0.03636385f, -0.03404528f, -0.05564651f, -0.00189410f, -0.06685285f, 
    -0.26275221f, -0.05337800f, 0.02259479f, -0.15902697f, -0.13455652f, 0.01907963f, 0.02228598f, -0.20738527f, 
    0.02035984f, 0.14791411f, 0.04133779f, -0.08866502f, 0.03370791f, -0.02683221f, 0.08139782f, 0.03444535f, 
    0.31864351f, 0.18639296f, 0.04266402f, -0.06956331f, 0.10260137f, 0.07678381f, 0.13256720f, -0.06936191f, 
    0.03576205f, -0.08472298f, -0.02643314f, -0.10978413f, 0.05708560f, -0.31182891f, 0.27528775f, -0.17099442f, 
    0.00992610f, -0.14785407f, 0.09093495f, 0.13394322f, 0.01879730f, 0.12752007f, 0.12383065f, -0.01746540f, 
    -0.10940155f, -0.08217589f, -0.43755722f, 0.34533444f, 0.05523934f, -0.04390761f, 0.05648451f, 0.12606728f, 
    -0.09030586f, 0.11427217f, -0.00940070f, -0.19963813f, 0.14397623f, 0.35686985f, 0.26825753f, -0.01021022f, 
    -0.14352766f, 0.00188881f, -0.00486101f, 0.15608865f, 0.11525337f, 0.05012665f, 0.10176242f, 0.04514818f, 
    0.09609679f, 0.28001991f, 0.08204176f, -0.02220988f, 0.15406494f, 0.26927894f, -0.10356438f, 0.16706175f, 
    -0.00714764f, 0.02776744f, -0.04271016f, -0.15012753f, 0.00460094f, -0.27501723f, -0.43988857f, -0.30549470f, 
    -0.39296177f, -0.09414208f, 0.00960769f, 0.04458163f, 0.04728009f, 0.12254334f, 0.01073366f, 0.07131524f, 
    -0.31902719f, -0.29843184f, -0.03528111f, -0.09133782f, 0.00917237f, 0.06962542f, 0.01783595f, 0.06022603f, 
    -0.06870118f, -0.02528795f, -0.02092373f, -0.01650003f, -0.00598545f, -0.38894123f, 0.01016773f, 0.04373014f, 
    0.12772804f, -0.04863933f, -0.11423194f, -0.01629643f, -0.11064556f, 0.07428404f, -0.07560005f, 0.18165335f, 
    -0.12451090f, -0.04286296f, 0.02959831f, 0.01093309f, -0.01117303f, 0.10865720f, -0.06356184f, -0.08506697f, 
    0.09349550f, 0.06653173f, 0.10169283f, -0.02506357f, -0.06802043f, 0.26216125f, 0.24099921f, -0.11863292f, 
    -0.05164717f, 0.22086383f, 0.03200146f, 0.07165708f, 0.01398325f, 0.02239189f, 0.05141904f, -0.12893817f, 
    0.23706475f, -0.19611979f, -0.20192282f, -0.02398557f, -0.01409022f, -0.18752213f, 0.00758063f, -0.01565726f, 
    -0.18612683f, 0.03758121f, 0.16069329f, 0.10165152f, 0.02349951f, -0.06237581f, -0.19079824f, -0.13948169f, 
    -0.13583030f, 0.00273051f, 0.11654042f, 0.06695819f, -0.05704648f, 0.07412610f, 0.00601711f, 0.03424221f, 
    0.04142305f, 0.14439593f, 0.10626025f, 0.01382817f, 0.03067897f, 0.13416755f, 0.02367265f, 0.17895576f, 
    -0.19492799f, 0.01444447f, 0.14389358f, 0.13612029f, -0.55947798f, -0.13402890f, -0.10607477f, -0.11953747f, 
    0.03700962f, -0.01186234f, -0.00241329f, 0.00952843f, 0.07385249f, -0.03817153f, -0.06649143f, -0.01900969f, 
    0.35415992f, -0.04325197f, 0.28031603f, 0.01589743f, 0.13970959f, -0.09111904f, 0.08969849f, 0.06932239f, 
    0.06815629f, -0.02364267f, -0.04790749f, -0.00321436f, -0.47751459f, 0.00439835f, 0.08961501f, -0.03004665f, 
    0.08666261f, 0.20431212f, -0.21028580f, -0.05881847f, 0.00977276f, 0.09356316f, -0.03793146f, 0.06916610f, 
    0.03711329f, 0.04901265f, 0.14799020f, -0.00227560f, 0.13289073f, -0.02979574f, 0.01474396f, -0.09806383f, 
    0.03843012f, 0.09147334f, 0.07447041f, 0.12869582f, -0.25033328f, 0.10349950f, 0.03362479f, 0.12482134f, 
    0.06454212f, 0.14371882f, 0.06098629f, 0.00028840f, -0.01874949f, -0.06550089f, 0.03117155f, -0.04727341f, 
    0.07962371f, 0.42894918f, 0.54431081f, -0.24524392f, 0.08978564f, 0.03236230f, 0.17198476f, 0.23966369f, 
    0.00956337f, -0.01404376f, 0.07368368f, -0.16911207f, -0.20450422f, -0.02884579f, -0.18916069f, 0.18395308f, 
    0.15727212f, 0.01478945f, 0.03436659f, 0.08193858f, 0.11717051f, -0.16631998f, -0.00018771f, -0.01628947f, 
    0.09824637f, 0.18168354f, -0.44247648f, 0.08108860f, -0.05494485f, -0.00577035f, 0.21000162f, 0.14391816f, 
    0.06428435f, 0.04478993f, -0.14154266f, -0.07886487f, 0.31494820f, -0.38703632f, 0.34209585f, -0.19391397f, 
    0.07436907f, 0.08950740f, -0.10081104f, 0.16654487f, -0.06713612f, -0.00359500f, 0.15032527f, -0.08968814f, 
    -0.00785211f, -0.30800363f, -0.25742468f, -0.20900573f, 0.11669038f, -0.08797956f, -0.06075665f, 0.13948797f, 
    -0.06108972f, -0.20834592f, 0.05025566f, -0.00207303f, -0.34456018f, -0.14952199f, 0.03975402f, 0.24633855f, 
    0.02337654f, 0.13945873f, 0.21166363f, 0.15973566f, 0.14542489f, -0.09543150f, 0.08034417f, -0.04003155f, 
    0.07374033f, -0.12375539f, -0.05289584f, -0.08105176f, -0.05128555f, 0.01925531f, 0.04672520f, 0.06851190f, 
    0.00409133f, -0.00109482f, -0.01078412f, -0.10735537f, 0.24930283f, -0.04740173f, -0.10684241f, -0.24659023f, 
    -0.11573609f, -0.07228694f, -0.23855180f, 0.13214721f, 0.11043900f, 0.00380931f, 0.19613545f, 0.04671484f, 
    0.07702012f, 0.04761397f, -0.04174695f, -0.08113581f, -0.00256786f, -0.13899563f, 0.05113696f, -0.04147137f, 
    -0.01282708f, 0.07980101f, 0.01299407f, -0.05200945f, 0.10349945f, -0.24812317f, 0.20571566f, -0.10878673f, 
    0.03039560f, 0.04815919f, 0.01920332f, -0.02341348f, 0.10755707f, 0.05949507f, 0.00542472f, 0.03098638f, 
    0.00458085f, -0.27342317f, 0.10458757f, -0.16184640f, -0.29488739f, 0.13948525f, -0.13714902f, 0.05437997f, 
    0.17762692f, 0.06890029f, 0.04343036f, 0.02252509f, 0.04503007f, 0.10540649f, 0.32443699f, 0.29268324f, 
    0.05842441f, 0.10945530f, -0.01999889f, 0.10956854f, 0.21093164f, 0.01773122f, -0.09635437f, -0.04097961f, 
    0.14579795f, 0.02859560f, 0.18210366f, 0.11658590f, -0.12294227f, -0.00676657f, 0.05422463f, 0.00692589f, 
    0.09436581f, -0.02155991f, 0.02789031f, 0.07375123f, 0.08634076f, 0.08367306f, 0.32605642f, -0.20666277f, 
    -0.09136006f, -0.21334910f, -0.11894263f, -0.04305892f, 0.18821029f, 0.08216862f, -0.04638806f, 0.02730073f, 
    0.18176486f, -0.13775557f, -0.06450050f, -0.13731700f, -0.08035827f, 0.07469015f, -0.12075472f, 0.10893685f, 
    0.09449609f, 0.02662060f, 0.01106991f, 0.09901510f, 0.23107976f, 0.01060060f, -0.42565331f, -0.06140103f, 
    -0.20330946f, 0.11378042f, 0.01382793f, -0.39840037f, 0.06862941f, 0.13335790f, 0.01122542f, 0.00088162f, 
    -0.22553621f, 0.00802622f, 0.03268123f, -0.07260700f, -0.02431829f, 0.14883547f, -0.08040154f, -0.17194168f, 
    0.14142990f, -0.32532781f, 0.04299933f, 0.10267863f, 0.40999910f, -0.05189650f, 0.37536713f, 0.03748131f, 
    0.20168661f, -0.07286530f, 0.32409886f, -0.01156242f, 0.01648508f, -0.07554480f, -0.02708588f, -0.10667994f, 
    -0.40640119f, 0.20931293f, -0.32734564f, -0.44133261f, 0.05385114f, -0.02387588f, 0.02228584f, 0.27188706f, 
    0.07512134f, -0.04029796f, 0.05068008f, 0.00341065f, -0.04949997f, -0.08729639f, 0.16147447f, 0.07204090f, 
    0.26601240f, 0.04860694f, 0.13138518f, 0.17026800f, 0.05759079f, -0.10891014f, -0.11042264f, -0.10751838f, 
    -0.07645708f, -0.01778845f, 0.09816326f, 0.03587438f, -0.21885714f, -0.02870444f, -0.02205045f, -0.02847421f, 
    0.08605674f, -0.11939330f, 0.13377894f, 0.00604655f, -0.21173215f, 0.27091461f, -0.42722985f, 0.14414430f, 
    -0.07552133f, 0.13290404f, -0.06412493f, -0.02752423f, -0.05778190f, -0.19303076f, 0.03059595f, 0.00315715f, 
    -0.17420897f, 0.03640512f, -0.08300139f, -0.17212453f, 0.18440188f, -0.31792727f, 0.10747147f, -0.27506202f, 
    0.08117002f, -0.00006418f, 0.00238088f, 0.10352504f, -0.13807149f, 0.04164192f, 0.16730514f, 0.06609518f, 
    0.04058098f, 0.00063189f, 0.06610106f, 0.22070485f, 0.12523834f, -0.13529737f, -0.01679614f, -0.14138284f, 
    0.45876721f, -0.07785301f, -0.11876433f, -0.07921231f, -0.06540639f, -0.02943226f, 0.05326033f, 0.07903799f, 
    -0.04471525f, -0.17307498f, -0.07039119f, 0.08423790f, -0.03373681f, -0.19790378f, 0.24799836f, -0.26354247f, 
    0.27655387f, -0.16147935f, 0.03653137f, -0.10606045f, 0.16222687f, 0.08296125f, -0.06335779f, 0.03176221f, 
    -0.06614762f, 0.21081467f, -0.03981680f, -0.04787225f, 0.05422901f, 0.14938091f, 0.04704650f, -0.02813181f, 
    0.05304443f, -0.07980992f, -0.12542638f, -0.11905967f, 0.24261326f, -0.14720944f, 0.00840161f, -0.01061058f, 
    -0.08464141f, 0.17636418f, -0.05879962f, 0.01615134f, 0.01399899f, -0.04734174f, 0.15365623f, -0.02813398f, 
    0.25181031f, -0.01492387f, 0.03995363f, -0.16663404f, 0.13877295f, 0.03488807f, 0.05395615f, 0.21871048f, 
    0.00018688f, -0.05531799f, 0.19774497f, 0.09817394f, -0.54559958f, 0.24924310f, -0.33504197f, -0.04028379f, 
    -0.22063833f, 0.03819788f, 0.05249391f, 0.07535712f, 0.06499751f, 0.04693501f, 0.03780212f, 0.17676440f, 
    0.01419242f, 0.01966837f, 0.04550455f, 0.04024824f, -0.00706003f, 0.13787720f, -0.18975867f, -0.01237969f, 
    0.01168326f, -0.21176824f, 0.05278844f, -0.22012244f, 0.05220579f, -0.33158574f, -0.04552955f, 0.17019242f, 
    0.06291978f, 0.24970688f, -0.05849274f, -0.06327317f, 0.13948856f, 0.10372629f, 0.28175393f, 0.25010633f, 
    -0.01973185f, 0.03206630f, 0.26780185f, 0.04593899f, -0.03016370f, -0.09243704f, 0.03884298f, -0.00877433f, 
    0.10332651f, 0.13417667f, -0.12352195f, -0.01130245f, 0.00154723f, 0.02225840f, 0.04409138f, -0.02729671f, 
    0.10861069f, -0.06218705f, -0.03210226f, -0.09018689f, -0.04566364f, 0.01039838f, -0.11865659f, -0.30596241f, 
    0.56833535f, 0.21168114f, 0.13672350f, 0.14972869f, -0.06714378f, -0.10760263f, 0.04330239f, 0.17242946f, 
    0.05956934f, -0.01900197f, 0.02685011f, -0.01838912f, 0.07295178f, 0.00492322f, -0.00979241f, -0.00858908f, 
    0.22293872f, 0.24361706f, -0.09874395f, 0.10720223f, 0.06166142f, -0.10068750f, -0.03987095f, -0.12727287f, 
    -0.18748026f, -0.23943837f, 0.20023330f, -0.08552333f, 0.07259291f, -0.03086100f, 0.15867488f, 0.05974118f, 
    -0.08531349f, -0.11223468f, 0.13690515f, 0.02181673f, 0.02317465f, 0.05882143f, 0.07982111f, 0.10255225f, 
    -0.00923763f, 0.11043137f, 0.21182151f, 0.05248338f, -0.02295797f, 0.07483856f, 0.10866994f, 0.26489410f, 
    -0.21475503f, -0.13413391f, -0.13870701f, -0.04860320f, 0.03327820f, 0.00368525f, 0.06514675f, 0.13514656f, 
    -0.06499234f, 0.10211477f, 0.15346298f, 0.25146744f, -0.01763666f, 0.11081551f, -0.23659337f, -0.19328493f, 
    0.00864445f, -0.00477328f, 0.05249890f, 0.10272192f, 0.12495517f, -0.19408940f, -0.26441672f, 0.00180308f, 
    0.18783234f, 0.11891291f, 0.12940939f, 0.17753276f, 0.01244536f, 0.09423639f, 0.00181075f, 0.08169768f, 
    0.07186855f, -0.11403080f, -0.02358272f, -0.08332124f, -0.11177742f, -0.03256878f, -0.06704719f, 0.03356629f, 
    -0.00279757f, 0.08302204f, 0.17428431f, 0.03907233f, 0.11671769f, 0.13692303f, 0.18397091f, 0.24485281f, 
    -0.25297591f, -0.07681689f, -0.37056643f, 0.21411721f, 0.08352211f, 0.11380590f, 0.00012868f, -0.26490229f, 
    -0.01648959f, 0.10073416f, 0.08289571f, -0.11692905f, 0.10717823f, -0.29003286f, 0.40566286f, 0.05150342f, 
    0.16624002f, -0.12981266f, -0.05753628f, -0.05045639f, 0.26416072f, -0.05769159f, 0.15195192f, 0.00201762f, 
    -0.04686693f, -0.07532471f, -0.05115987f, -0.02933023f, -0.04399293f, 0.00864229f, 0.01994758f, 0.04732587f, 
    0.11948185f, 0.22724040f, 0.15872256f, 0.26693133f, -0.43536028f, -0.01546266f, -0.08540664f, -0.07724128f, 
    -0.02136158f, 0.00556880f, 0.09033480f, -0.03194867f, 0.12450512f, 0.03789236f, -0.20824841f, -0.23496169f, 
    -0.24613857f, -0.05647111f, -0.00525771f, -0.10959129f, 0.07064120f, -0.16616835f, 0.10098697f, -0.07463262f, 
    -0.03451588f, -0.08009813f, 0.04124663f, 0.11597249f, 0.17152235f, -0.13535537f, 0.12574349f, 0.24819322f, 
    0.11332368f, 0.03289555f, -0.09616720f, 0.10678140f, -0.00998186f, -0.05864836f, -0.01426917f, -0.04524015f, 
    0.17500496f, 0.06514340f, 0.21019293f, -0.02976191f, -0.00444962f, -0.03229647f, 0.17280863f, -0.05347409f, 
    0.01152949f, 0.05578258f, 0.06529499f, 0.07298160f, 0.17854261f, 0.10046329f, 0.13930574f, 0.22963983f, 
    -0.27102056f, -0.04318482f, -0.12032992f, -0.12227812f, 0.02244304f, -0.12537034f, -0.12554230f, -0.15842153f, 
    -0.32547179f, 0.09189375f, -0.05723358f, -0.06578377f, 0.10377268f, 0.00885707f, 0.20821740f, 0.05040186f, 
    -0.01786943f, -0.04189378f, 0.12666233f, 0.05625971f, 0.70445299f, 0.25268736f, 0.29355654f, -0.16458757f, 
    -0.03522595f, -0.07625030f, -0.16195475f, -0.09412546f, -0.17824335f, -0.07938751f, -0.02034946f, -0.10268796f, 
    -0.14061846f, 0.34056991f, -0.13452959f, 0.07558557f, 0.06120007f, 0.04612651f, 0.14656773f, 0.03645677f, 
    0.10735433f, 0.06804115f, 0.08415213f, 0.00534063f, 0.18247746f, 0.00559698f, 0.27884057f, -0.30577779f, 
    0.08917852f, -0.01391491f, 0.02239327f, 0.34391123f, 0.16930003f, 0.35973671f, -0.11069133f, -0.11554026f, 
    -0.07432675f, 0.04519349f, -0.03383392f, 0.04618559f, 0.12837708f, 0.12288253f, -0.04447236f, 0.15411562f, 
    0.03372775f, -0.05581544f, 0.03499110f, -0.16372105f, -0.12919238f, 0.16605079f, -0.02570307f, 0.04300594f, 
    0.19239169f, -0.19020231f, 0.18281874f, -0.41463473f, -0.06960961f, -0.06372425f, -0.24062200f, -0.23299253f, 
    0.24336784f, -0.17154156f, -0.04452142f, 0.14972533f, -0.02743851f, 0.03673061f, -0.05063926f, 0.07345658f, 
    -0.01380140f, -0.05209818f, 0.21795733f, 0.34334701f, 0.44807094f, 0.03510868f, -0.02364026f, 0.05040189f, 
    0.03460034f, 0.12012786f, -0.02881588f, 0.14751908f, -0.11038103f, -0.06056566f, -0.03051425f, -0.10092532f, 
    -0.20986129f, 0.09114603f, -0.08591846f, -0.05373697f, 0.02038183f, -0.08911326f, 0.09709212f, 0.04462784f, 
    0.01257111f, 0.01665375f, -0.12599249f, -0.20530893f, 0.24230535f, -0.08640766f, 0.05969039f, 0.07976899f, 
    -0.04413429f, -0.01812989f, -0.04765516f, 0.14996761f, 0.00651427f, 0.11629669f, -0.06606629f, -0.10772830f, 
    0.07369959f, 0.17839563f, 0.19939220f, 0.08981632f, -0.08647177f, 0.15076742f, 0.06653055f, -0.04094954f, 
    -0.04392073f, 0.10303846f, 0.11629342f, -0.20338550f, -0.07955458f, 0.04802060f, -0.06603987f, 0.08159113f, 
    0.07028547f, 0.08717593f, 0.23422168f, 0.13525569f, -0.09032595f, -0.07389730f, 0.19047391f, 0.02329897f, 
    0.07648990f, 0.02888812f, -0.02580101f, -0.01614434f, 0.21919943f, -0.04174975f, -0.07473894f, 0.06194239f, 
    0.05105462f, -0.00645736f, 0.11838127f, -0.09505618f, 0.06005447f, -0.12006314f, 0.00456517f, 0.10280456f, 
    -0.09493304f, 0.09285268f, -0.00600734f, 0.02451502f, 0.15738696f, 0.14627551f, 0.27875990f, 0.05156337f, 
    -0.31241962f, -0.25570980f, 0.13074319f, -0.17254552f, -0.15931176f, 0.06824226f, 0.15560833f, -0.04693549f, 
    0.02875504f, 0.16510534f, 0.03370760f, 0.03190434f, 0.02538625f, 0.00939844f, -0.01830993f, 0.00324324f, 
    0.03810652f, 0.00212531f, 0.09773891f, 0.12041619f, 0.00699674f, 0.03193923f, -0.06851123f, -0.11976188f, 
    0.32994521f, 0.03184411f, 0.24834646f, -0.24922831f, -0.01003028f, 0.06627809f, 0.11315133f, 0.13853361f, 
    0.05762355f, -0.00283474f, 0.01290723f, 0.05717398f, -0.15775424f, -0.12693372f, -0.05501800f, 0.14211577f, 
    0.23430505f, 0.06757851f, -0.13950548f, 0.02655672f, 0.00539983f, 0.02419996f, 0.07227245f, 0.05988241f, 
    -0.18157119f, 0.05585160f, 0.13066106f, 0.15736240f, -0.07345359f, -0.21005814f, 0.05952005f, -0.02681888f, 
    0.10986003f, 0.10052303f, 0.13847084f, 0.02122093f, 0.14091302f, 0.07800290f, 0.40185878f, 0.00530051f, 
    -0.01643194f, 0.02195683f, 0.19073617f, 0.03998774f, 0.11605076f, 0.03735017f, 0.04442438f, 0.21671136f, 
    -0.11614842f, -0.05139997f, 0.07633197f, -0.04709188f, -0.15221842f, -0.07906233f, 0.12181997f, 0.02977478f, 
    0.07220059f, 0.20161553f, 0.16132675f, 0.22498621f, 0.09763274f, 0.22124416f, 0.11669032f, -0.01130059f, 
    -0.06787771f, -0.11951026f, -0.10418884f, -0.11499154f, 0.09024739f, -0.14048611f, 0.18340501f, 0.15440188f, 
    0.29068214f, 0.20165740f, 0.10703017f, -0.05487370f, -0.01106284f, -0.06901480f, 0.04996723f, -0.07069684f, 
    -0.01995163f, -0.00726397f, -0.09561133f, -0.05411206f, 0.12645897f, 0.19528230f, 0.10602137f, 0.06178005f, 
    -0.01033520f, 0.00388937f, -0.00161966f, -0.02652073f, 0.06789020f, 0.22562096f, 0.13151586f, 0.05936871f, 
    -0.12030040f, -0.19541278f, 0.18807924f, 0.15330637f, 0.05753604f, -0.01330919f, -0.15429944f, 0.05684334f, 
    -0.08666456f, 0.00274639f, -0.03576079f, -0.03976511f, -0.13453659f, -0.13152614f, -0.18202040f, 0.10144319f, 
    0.08810592f, -0.12571342f, -0.08925183f, 0.03423616f, -0.03145049f, 0.13681406f, 0.23249379f, -0.03847691f, 
    0.17021483f, 0.21732996f, 0.11347812f, 0.02382689f, -0.12698843f, -0.10313437f, -0.02723884f, -0.12928201f, 
    0.21323615f, 0.18985514f, 0.14294958f, 0.06908461f, 0.21128266f, 0.29332152f, 0.04768646f, 0.07481050f, 
    -0.02815822f, -0.15034527f, -0.17257534f, -0.10600754f, -0.01357254f, 0.10474982f, 0.13634227f, 0.14267786f, 
    -0.18689759f, 0.06947908f, 0.11577786f, 0.04394773f, -0.03386258f, -0.10472371f, 0.06057846f, 0.05615253f, 
    -0.07106031f, 0.10571777f, 0.11931035f, 0.05982504f, 0.11859605f, 0.18773232f, 0.00953004f, 0.06417388f, 
    0.07242823f, -0.02504607f, 0.21213600f, -0.08747447f, 0.09006028f, 0.08061755f, -0.01308097f, -0.14181791f, 
    0.05304733f, -0.11583213f, 0.26583645f, -0.04500556f, 0.02245385f, 0.07576694f, -0.01929462f, -0.01855227f, 
    0.20538647f, 0.00972668f, 0.01919107f, 0.03064348f, -0.33662966f, -0.41822952f, -0.30960694f, 0.04283322f, 
    -0.07343543f, -0.06248707f, -0.14064480f, -0.01655738f, -0.15869635f, -0.08409014f, -0.05306491f, -0.06535815f, 
    -0.11131872f, -0.16019453f, 0.05538927f, 0.12422057f, -0.06774130f, -0.04250160f, 0.00093242f, -0.00728546f, 
    0.01436165f, 0.04328417f, 0.12140004f, 0.13561819f, -0.09019573f, -0.27374130f, 0.21984993f, 0.08163255f, 
    0.24255407f, 0.10422364f, 0.09008860f, -0.05012769f, -0.04698386f, 0.01067986f, -0.06806351f, -0.09780490f, 
    0.13906114f, 0.24735068f, 0.12333108f, -0.02245292f, 0.09604298f, 0.08098356f, -0.03642848f, -0.10852627f, 
    -0.02581102f, 0.13136241f, 0.13288227f, -0.01727996f, 0.08710555f, 0.15095903f, 0.17727186f, -0.14793789f, 
    -0.11969021f, -0.14305773f, 0.22920161f, 0.06318427f, 0.18521076f, 0.20908427f, 0.03426553f, 0.10599068f, 
    0.08838228f, -0.00851723f, 0.01102428f, -0.06489033f, 0.12369619f, -0.00061927f, -0.03634799f, -0.01503173f, 
    -0.02190657f, 0.07209042f, -0.01527222f, -0.12716939f, -0.14138322f, -0.25664434f, -0.27839959f, 0.08318880f, 
    0.09702287f, -0.15126170f, -0.13589902f, -0.09664605f, -0.05671438f, 0.05208346f, 0.06432873f, 0.08131208f, 
    0.16427127f, 0.08634400f, 0.28409144f, 0.04504793f, 0.00127015f, -0.05517121f, 0.15396623f, -0.12151460f, 
    0.13928528f, 0.09408017f, 0.18478408f, 0.14251763f, 0.07718524f, 0.02857218f, 0.07234149f, -0.01862084f, 
    0.14734286f, 0.19007961f, 0.07824542f, 0.04602685f, 0.00044573f, -0.04237231f, -0.07462046f, 0.00319364f, 
    -0.26113155f, -0.14782497f, 0.03181793f, -0.09594836f, -0.04332468f, -0.05669005f, 0.00540377f, 0.18919887f, 
    0.00885781f, 0.10760568f, 0.04723326f, 0.06711535f, 0.17635851f, 0.16031595f, 0.05057661f, 0.09124953f, 
    0.02758469f, 0.05646034f, 0.04404337f, -0.02684055f, -0.02094891f, 0.03313075f, -0.06916558f, -0.00019025f, 
    -0.44776943f, -0.07260361f, -0.12654607f, 0.07804589f, -0.05906474f, 0.05224200f, -0.09828027f, 0.08930384f, 
    -0.01546069f, -0.00460929f, 0.00742922f, 0.09036864f, 0.30337322f, -0.01979605f, 0.00152193f, 0.03101240f, 
    -0.09595412f, 0.05646124f, 0.13578065f, -0.03554462f, 0.10539914f, -0.04092257f, 0.17694776f, 0.13451838f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.15839984f, 0.00255664f, -0.00784265f, 0.00979184f, 0.03949200f, 0.02266014f, 0.04562781f, -0.02869802f, 
    0.15620050f, 0.12938625f, -0.00857711f, 0.14308719f, 0.10138050f, 0.08049181f, 0.18462098f, 0.25683814f, 
    0.03753598f, 0.10829496f, -0.03722063f, 0.04444550f, -0.11815614f, -0.02915009f, 0.18738964f, -0.04661811f, 
    -0.04888404f, -0.01627968f, -0.02603638f, 0.02480633f, -0.10583938f, 0.03532358f, 0.09135245f, 0.09110511f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04541552f, -0.01211120f, 0.14582686f, 0.26135832f, -0.01548005f, 0.04630939f, 0.48218217f, -0.15764534f, 
    0.33042124f, 0.46561807f, 0.12133715f, -0.27664998f, 0.28517750f, -0.03092895f, 0.10537383f, 0.20122397f, 
    0.03245367f, 0.24999472f, -0.09532741f, 0.11175794f, -0.15930425f, -0.07110832f, 0.05604350f, -0.14541908f, 
    0.13841346f, -0.07252524f, 0.01411193f, 0.26452506f, -0.39164981f, -0.18176988f, -0.02895837f, 0.00475072f, 
    -0.21775481f, 0.04504706f, 0.09861530f, 0.23187201f, -0.07886794f, -0.08064722f, 0.02342469f, 0.03570053f, 
    -0.18320455f, -0.34863272f, -0.12734321f, 0.17313924f, 0.26264536f, 0.14213639f, 0.10187958f, -0.05461592f, 
    0.17145877f, -0.10584819f, -0.01425841f, 0.26447371f, 0.23110995f, -0.00953128f, 0.27505499f, 0.19623502f, 
    -0.03892256f, 0.05998558f, 0.04784884f, -0.03294411f, -0.16017538f, -0.58347487f, -0.28568229f, 0.05394344f, 
    -0.05272732f, 0.08479189f, -0.05049565f, 0.11403902f, -0.40880907f, -0.07213277f, 0.25438127f, 0.08105246f, 
    0.17459847f, -0.00790050f, -0.11119702f, -0.48777959f, 0.31812629f, -0.27668560f, 0.04550137f, 0.02694987f, 
    0.09092536f, 0.03421696f, -0.01776250f, 0.24035221f, -0.25721344f, 0.01737114f, 0.19882101f, -0.07525411f, 
    -0.12669359f, -0.12821400f, 0.09219956f, -0.25666443f, -0.46610737f, -0.15285309f, 0.32304692f, -0.04944676f, 
    0.22094639f, 0.11576490f, -0.06099307f, -0.17815858f, 0.18572426f, -0.14454740f, -0.22970732f, -0.38170901f, 
    0.41689262f, -0.16826329f, 0.07882679f, 0.19885808f, -0.20683810f, 0.23038897f, 0.15336981f, 0.30701056f, 
    -0.09941112f, 0.01516280f, -0.03059055f, 0.16553192f, -0.04303257f, 0.14338891f, 0.14243937f, -0.20150331f, 
    -0.04041319f, -0.05436211f, -0.15821442f, -0.00836669f, -0.00357562f, -0.16528137f, 0.28191069f, 0.11992163f, 
    0.33029217f, 0.06044854f, 0.12116055f, 0.04435347f, -0.13933612f, 0.05747864f, 0.26500383f, 0.23492500f, 
    0.01324339f, 0.08375062f, -0.07487784f, 0.16830255f, 0.31993577f, 0.16114073f, -0.05019562f, 0.26406401f, 
    0.05284480f, -0.23028047f, -0.10540483f, -0.39245450f, -0.15774781f, 0.16841915f, -0.09398691f, -0.39880911f, 
    -0.17259601f, -0.09520362f, -0.06128423f, -0.27836394f, 0.42686030f, -0.09499353f, 0.18626902f, 0.17532749f, 
    -0.56529588f, 0.16742991f, 0.07758202f, 0.09449671f, 0.21666358f, -0.00911572f, 0.17738251f, 0.11288738f, 
    0.53640032f, -0.10038028f, -0.14042434f, -0.33635482f, 0.23858193f, 0.35866082f, 0.21681550f, -0.23672436f, 
    -0.04144406f, -0.05634582f, -0.14217564f, 0.48712608f, 0.15232457f, 0.09930921f, -0.10069405f, 0.17276831f, 
    -0.10542154f, -0.13826187f, -0.11719353f, -0.30332661f, -0.46947831f, -0.35585916f, 0.10608817f, 0.03681313f, 
    -0.09886379f, -0.09122885f, 0.14476191f, 0.17404519f, 0.03638569f, -0.04185016f, 0.11473189f, 0.30916479f, 
    0.10816535f, 0.35926065f, 0.02115478f, 0.12136538f, -0.13306081f, 0.35424194f, 0.06147094f, -0.02537501f, 
    -0.08830197f, -0.06886514f, 0.01200059f, -0.27358732f, -0.08669268f, 0.02609487f, -0.33207467f, -0.04112884f, 
    0.15743153f, -0.01014703f, 0.02412017f, -0.15229250f, 0.07358890f, 0.45304206f, -0.32167092f, -0.08242075f, 
    0.31056052f, -0.01464870f, 0.11741677f, -0.05847736f, 0.11355764f, -0.01688492f, 0.30502009f, -0.11730223f, 
    -0.30817762f, 0.20926030f, -0.11129440f, -0.48094678f, 0.08061454f, -0.34258729f, 0.15954435f, 0.07830170f, 
    0.14118254f, -0.02013493f, 0.05382948f, 0.30330956f, -0.22764178f, -0.15561861f, 0.05344890f, 0.20231774f, 
    0.04981685f, 0.12428597f, -0.01484762f, 0.04192799f, 0.01466246f, 0.55320549f, -0.01830554f, -0.08042004f, 
    0.07033211f, 0.15831240f, 0.04408915f, 0.34382525f, 0.32031024f, 0.14709105f, 0.19695592f, 0.16141385f, 
    -0.15667529f, -0.16262767f, 0.03712459f, -0.39943305f, -0.15033846f, 0.14970212f, -0.03537739f, -0.04106091f, 
    -0.09157891f, -0.29812935f, 0.04795934f, 0.02627028f, 0.23686922f, 0.17244221f, -0.05281336f, 0.31446856f, 
    -0.11789228f, -0.11131100f, -0.14908281f, 0.17508583f, 0.29717988f, -0.15174708f, 0.31160834f, -0.45698568f, 
    -0.04339630f, 0.13605954f, 0.02234552f, -0.17546640f, -0.27659851f, -0.00731220f, -0.08942656f, 0.24168272f, 
    -0.08697180f, -0.15850155f, -0.08669408f, 0.18733272f, 0.12948695f, 0.29917762f, -0.09433918f, -0.08418085f, 
    0.11193164f, -0.15913385f, -0.06375971f, -0.06974029f, 0.07986671f, 0.04647890f, -0.42417553f, -0.11039129f, 
    -0.02472153f, 0.11820046f, 0.05812293f, 0.07762432f, -0.00718575f, 0.20296061f, 0.08575158f, -0.01492983f, 
    0.28273487f, 0.03727233f, 0.16259126f, -0.05790144f, -0.11276434f, -0.08209205f, -0.19606489f, -0.08287376f, 
    -0.07039982f, 0.04098472f, 0.08644037f, 0.29085582f, 0.08785581f, -0.21725306f, -0.16394401f, -0.29091835f, 
    -0.01700594f, 0.39833128f, -0.01606674f, -0.02050011f, -0.11679044f, -0.16805898f, -0.17986356f, 0.07782371f, 
    0.02119395f, 0.03312788f, -0.17241442f, -0.08183118f, -0.07353417f, 0.45178950f, 0.15468405f, 0.11471685f, 
    -0.07682347f, -0.13760243f, -0.12238356f, 0.01361028f, -0.50989997f, 0.16016556f, -0.06333111f, 0.22049330f, 
    -0.32351196f, 0.19310044f, 0.05844796f, -0.03894756f, -0.11025053f, -0.10397083f, 0.05471490f, -0.12892190f, 
    -0.15052438f, 0.27270961f, 0.11032546f, 0.12652634f, -0.14704959f, 0.18195225f, 0.14645839f, -0.18212472f, 
    0.13407950f, 0.16445455f, 0.16486913f, 0.00858692f, -0.17363055f, 0.25456044f, 0.05073160f, 0.13956706f, 
    0.25320399f, -0.06535298f, 0.11411281f, 0.06296688f, -0.28672597f, 0.06626290f, 0.07529100f, 0.13506837f, 
    0.35464707f, -0.05267384f, -0.08912782f, -0.28593200f, 0.23488623f, -0.04216342f, -0.15998861f, -0.15246277f, 
    -0.01487145f, 0.23473991f, 0.15469252f, -0.33860025f, 0.16010979f, -0.04984457f, 0.18952426f, -0.34996969f, 
    0.05365341f, -0.15734169f, -0.17360130f, -0.39302945f, -0.54204071f, -0.19458346f, 0.49201360f, -0.04302917f, 
    -0.06450941f, -0.16372840f, -0.12690151f, 0.12512837f, 0.20990959f, 0.08866552f, -0.10188351f, 0.27009752f, 
    0.01074293f, -0.11150713f, -0.14094561f, 0.21661747f, 0.00855190f, 0.08244590f, 0.05249775f, 0.02103246f, 
    -0.10245560f, -0.31037605f, 0.05614544f, -0.28429300f, 0.32292831f, -0.16545531f, 0.14933141f, 0.24375790f, 
    0.10569494f, 0.10634924f, -0.06029460f, 0.08579160f, 0.38010019f, -0.36821228f, -0.03287762f, -0.05263260f, 
    -0.09302811f, 0.10618987f, 0.06117313f, 0.08114237f, 0.20128104f, -0.15101433f, 0.22011535f, 0.33339137f, 
    -0.21666999f, -0.14877518f, -0.00961752f, -0.62420595f, -0.13601908f, 0.10680144f, 0.23378681f, -0.00799413f, 
    0.15828152f, -0.22545014f, -0.12924244f, -0.31647369f, 0.13593616f, 0.14990413f, -0.21064295f, 0.30350831f, 
    0.16791654f, 0.18190166f, 0.05957437f, -0.32584625f, -0.21548080f, 0.51761174f, -0.02205903f, 0.04902951f, 
    0.08724140f, 0.13155343f, -0.05762180f, -0.18334219f, -0.08079293f, -0.12348111f, -0.26074433f, -0.26197076f, 
    0.10587572f, -0.23338366f, 0.08542180f, -0.05103771f, 0.02921337f, -0.01528286f, 0.29797128f, -0.08732010f, 
    -0.09405585f, 0.11621260f, -0.09508945f, 0.00307533f, -0.22697516f, 0.11858955f, 0.11450838f, 0.19655435f, 
    0.16450851f, 0.00152870f, -0.06773737f, -0.50605243f, -0.49287623f, 0.12171964f, 0.36198953f, 0.35436538f, 
    0.48955673f, -0.15185231f, -0.12080132f, 0.33400735f, -0.16131663f, 0.10151355f, 0.42293370f, 0.24423079f, 
    0.04282446f, 0.46143416f, 0.01631541f, 0.20816894f, 0.32220867f, -0.11162944f, -0.03377637f, 0.11896960f, 
    0.04148744f, 0.04897425f, -0.14881706f, -0.17785101f, 0.11938025f, -0.02510550f, 0.25012276f, -0.09371077f, 
    -0.12420417f, -0.05018835f, 0.02319664f, 0.29781193f, 0.25202194f, 0.09858560f, -0.09795218f, -0.38320845f, 
    0.48202533f, -0.14028884f, -0.11053278f, -0.11274228f, 0.15419635f, 0.09850661f, -0.14466862f, 0.21947822f, 
    -0.23665830f, -0.35832447f, 0.09470004f, -0.15205565f, -0.42949039f, 0.06055740f, -0.05316648f, 0.28769651f, 
    -0.13442901f, -0.00796675f, -0.12551953f, -0.25463110f, 0.11238854f, 0.14160836f, 0.25202405f, 0.08230836f, 
    -0.06212942f, 0.08862399f, -0.03627274f, -0.11894934f, 0.26000959f, 0.52286553f, 0.06289176f, -0.22688605f, 
    -0.21239173f, -0.07105271f, -0.10461565f, 0.12189858f, -0.11881223f, 0.15399697f, -0.03743244f, -0.34856161f, 
    0.02204968f, 0.04125073f, -0.02784842f, -0.04253507f, -0.14095522f, -0.15022826f, 0.24109931f, 0.20815836f, 
    -0.11826872f, 0.03739888f, -0.13638687f, 0.44565535f, -0.08815724f, 0.12244120f, 0.07236325f, 0.25573203f, 
    -0.04822711f, 0.14735860f, 0.05150340f, 0.06621957f, -0.31608251f, 0.44044858f, 0.12461148f, 0.11526111f, 
    -0.03475805f, -0.04248528f, 0.09422180f, -0.14287063f, 0.10017396f, 0.03981489f, 0.17149378f, 0.25777432f, 
    0.13631664f, 0.03120240f, 0.04084756f, 0.10552244f, 0.20740366f, 0.12878975f, 0.07146657f, 0.18818994f, 
    0.17288272f, -0.07199963f, -0.01094777f, -0.21404558f, 0.34499782f, 0.02555572f, 0.35344413f, 0.03647979f, 
    0.02900855f, -0.01894771f, 0.15642333f, -0.06354620f, -0.00730187f, -0.40902007f, -0.00612272f, -0.17430618f, 
    0.00902325f, 0.17106961f, 0.06332526f, -0.09460273f, -0.34952155f, -0.11371192f, -0.01084956f, 0.51840013f, 
    0.09548568f, -0.05181605f, -0.08819319f, -0.07485596f, -0.11314858f, -0.23348239f, -0.13749290f, -0.47500965f, 
    -0.08127951f, 0.08364732f, -0.12367272f, -0.13183059f, -0.00044728f, -0.09549944f, -0.25159299f, 0.37712267f, 
    -0.02428929f, -0.00772678f, 0.03008802f, -0.01247734f, -0.32256800f, 0.45030004f, 0.11852324f, 0.16755283f, 
    0.04784985f, -0.18009755f, 0.04818996f, 0.19095175f, -0.18817161f, 0.08293076f, -0.12181287f, 0.11916355f, 
    -0.00389754f, 0.21849257f, 0.03841704f, 0.24891651f, -0.17624730f, -0.20014711f, -0.17279474f, -0.16385223f, 
    -0.01296044f, 0.18973821f, 0.00393012f, -0.04310171f, -0.09893754f, 0.12660684f, -0.09237359f, 0.09608471f, 
    -0.11509522f, 0.10584248f, -0.11283160f, -0.04917158f, -0.32372665f, 0.29578653f, 0.17978182f, -0.09396176f, 
    -0.29926538f, 0.06939055f, 0.16749762f, 0.35339680f, -0.06116324f, -0.13639458f, 0.18759111f, 0.36479920f, 
    -0.27907339f, 0.09188309f, 0.03975493f, -0.38644555f, 0.34583354f, -0.00094886f, -0.09405315f, -0.25981522f, 
    -0.02823034f, 0.07717291f, -0.16131000f, 0.20216280f, 0.04494605f, 0.07191430f, -0.06380878f, 0.13515325f, 
    0.17547083f, 0.12871535f, 0.11765543f, 0.12450383f, -0.28154197f, -0.09617933f, 0.00961395f, 0.07578328f, 
    -0.10452100f, 0.13595413f, 0.08844208f, -0.07842365f, -0.25265321f, -0.09456364f, -0.15765592f, -0.01491384f, 
    0.00767007f, 0.04087935f, 0.10029233f, 0.12967190f, 0.00283628f, -0.05140093f, -0.07028274f, 0.15033442f, 
    0.07895545f, 0.17643514f, 0.15066437f, -0.09407390f, -0.12218844f, -0.05223735f, -0.00493428f, -0.29757273f, 
    -0.10667527f, 0.07804136f, 0.17622596f, 0.02064782f, 0.19441511f, -0.34417289f, -0.27385315f, 0.18721023f, 
    0.13242476f, -0.08712979f, -0.10310176f, -0.28206563f, 0.03661151f, -0.10631082f, -0.34966761f, -0.28351370f, 
    0.00517109f, -0.21260244f, 0.06117581f, -0.02370556f, -0.11634336f, 0.38130930f, 0.22868426f, 0.43622535f, 
    0.13631557f, 0.05034578f, 0.01098824f, -0.01616006f, -0.21197534f, 0.10910714f, -0.11386516f, -0.23356909f, 
    -0.02228407f, 0.10625258f, 0.15487981f, 0.08919632f, -0.00521028f, 0.31103015f, 0.24836926f, 0.21094482f, 
    -0.03166765f, -0.01609178f, 0.05197736f, -0.13543263f, 0.31920487f, 0.03245453f, 0.08689656f, -0.06483757f, 
    0.03036036f, -0.22558093f, -0.15252569f, -0.31820959f, -0.30834222f, 0.02964579f, 0.22895090f, 0.14217941f, 
    0.03201677f, 0.07225554f, 0.18130362f, 0.36697626f, -0.00820782f, -0.09782880f, -0.26784813f, 0.35992786f, 
    0.01930471f, -0.12558228f, -0.13658144f, -0.13973427f, -0.08088060f, 0.45523980f, 0.15809277f, -0.16007814f, 
    -0.17790389f, 0.09259234f, -0.01998197f, 0.09896675f, -0.10768847f, -0.01272561f, -0.16322361f, -0.16480295f, 
    0.13438241f, -0.13312033f, -0.10802821f, -0.06569711f, -0.12184457f, -0.00582940f, -0.11713615f, -0.06246308f, 
    0.16644986f, -0.14100194f, -0.16724883f, 0.00923945f, -0.17741215f, 0.06503294f, -0.08494081f, -0.15741654f, 
    -0.08026873f, -0.02983986f, -0.02302225f, 0.01565907f, -0.16383994f, -0.07387685f, 0.06915878f, -0.08888657f, 
    -0.19916964f, -0.16602464f, 0.04746174f, 0.06072256f, 0.17160445f, 0.03458694f, -0.35395768f, -0.29951936f, 
    0.16336714f, 0.07680786f, -0.09695812f, 0.49307463f, -0.06612142f, 0.05072887f, 0.26238683f, 0.02241462f, 
    -0.02736926f, 0.13552685f, -0.13659136f, 0.43897974f, -0.26063719f, -0.11926080f, -0.07924490f, -0.14863169f, 
    -0.06914810f, 0.03774659f, -0.15416509f, -0.17776428f, 0.08659372f, 0.20148590f, -0.14175667f, 0.04265756f, 
    0.16658117f, 0.06367713f, 0.02115524f, 0.20129415f, 0.09309699f, 0.12815954f, 0.00324449f, -0.12161350f, 
    0.05827196f, 0.09088422f, -0.01083548f, 0.12172964f, -0.21625830f, 0.08337294f, 0.07542975f, 0.26040438f, 
    -0.10268471f, -0.07050110f, 0.01437324f, -0.22472617f, -0.12338843f, 0.05151920f, 0.38348722f, 0.16565691f, 
    0.07188535f, -0.09175612f, 0.00400291f, 0.33867019f, 0.31682265f, 0.33551633f, -0.23432897f, -0.21576233f, 
    -0.20630212f, -0.11213501f, -0.06555245f, 0.17548433f, 0.22959088f, -0.14308642f, -0.33193958f, -0.00383085f, 
    -0.03142001f, -0.40406734f, -0.00418215f, -0.32602492f, -0.15811013f, 0.05441234f, 0.27488354f, 0.22863397f, 
    -0.15985775f, -0.25488737f, -0.01307882f, -0.21594821f, -0.02955422f, 0.03560960f, 0.40460676f, 0.34986019f, 
    -0.06186282f, 0.09599044f, 0.14060776f, 0.09219449f, 0.31790021f, 0.18827485f, 0.20328961f, -0.23493524f, 
    -0.20842367f, -0.00256995f, 0.01845486f, 0.12373629f, -0.42780930f, 0.01499125f, -0.08981735f, 0.12010093f, 
    -0.42330998f, -0.14709029f, 0.17605013f, 0.25276524f, -0.07754540f, 0.01087073f, -0.11052385f, -0.16353241f, 
    -0.10651294f, 0.11096896f, -0.10569078f, -0.07253344f, 0.37109652f, 0.17562573f, 0.11250367f, -0.09261012f, 
    -0.09627622f, -0.13966928f, 0.06059673f, 0.12873536f, -0.22706482f, 0.05952774f, -0.52562249f, -0.00114963f, 
    0.23654667f, -0.05826056f, -0.09374395f, 0.09132119f, -0.33249113f, -0.03323260f, -0.16851242f, -0.10849683f, 
    0.25284508f, 0.23678923f, 0.01359712f, 0.13519235f, -0.23050413f, -0.04341864f, -0.08402781f, -0.13391335f, 
    0.12383859f, 0.15884809f, 0.03203309f, -0.12733746f, 0.12489184f, -0.15438130f, 0.05320110f, -0.33454627f, 
    -0.04877503f, -0.08040462f, -0.07533360f, 0.06778134f, -0.08307355f, -0.02603106f, 0.20829621f, -0.09110552f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.04755870f, 0.04076997f, -0.08186802f, 0.17060357f, 0.14491349f, 0.11399082f, 0.21750547f, 0.16825467f, 
    -0.22034329f, 0.23880449f, 0.07143743f, -0.00839913f, -0.03090019f, -0.09899522f, 0.11456411f, 0.32539514f, 
    -0.07331903f, -0.09139267f, 0.13917989f, 0.04827432f, -0.08314090f, 0.18633318f, -0.12625074f, -0.16138987f, 
    0.24990934f, 0.00390253f, 0.04339090f, 0.21528308f, -0.02830017f, -0.10695457f, -0.01563463f, -0.16453922f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.46610120f, -0.21284954f, -0.22343549f, -0.15345907f, -0.16185470f, -0.28768766f, 0.07201406f, 0.14079966f, 
    0.25281620f, 0.00666400f, -0.16620164f, -0.22901446f, -0.04810072f, 0.11145294f, 0.17757691f, -0.26393464f, 
    0.06458818f, 0.36357722f, -0.51265001f, 0.08170236f, -0.43734607f, -0.24811502f, -0.16016613f, 0.10310382f, 
    -0.18660291f, 0.14198914f, -0.04309708f, -0.51696306f, -0.02427626f, 0.09007354f, 0.31382626f, 0.23764361f, 
    -0.16630235f, 0.21715789f, -0.09702070f, 0.13519263f, 0.22082451f, -0.59441817f, -0.07609061f, -0.57522863f, 
    0.07411812f, -0.15909426f, 0.30638838f, 0.06674354f, 0.38509455f, 0.32550400f, -0.31985325f, 0.08655080f, 
    0.19483252f, -0.01154556f, -0.25997141f, 0.01093810f, -0.00544894f, 0.12343591f, -0.33598036f, -0.00898707f, 
    -0.12663932f, -0.84396482f, -0.08890405f, 0.02852064f, 0.18003371f, 0.09043222f, -0.25641516f, 0.10012141f, 
    -0.01768100f, 0.50969034f, -0.32439515f, 0.30802697f, -0.50514674f, 0.32524449f, -0.18252911f, -0.54809844f, 
    -0.66612333f, 0.05209066f, -0.30554059f, -0.21162808f, -0.41958135f, 0.11406238f, -0.33237526f, 0.07190757f, 
    -0.09128129f, -0.52197218f, 0.09094253f, 0.27993584f, -0.17060241f, -0.35408953f, -0.16405867f, 0.04219490f, 
    -0.04182697f, -0.12387990f, -0.15214005f, 0.20169021f, -0.06494363f, -0.02337395f, -0.18702130f, 0.07511304f, 
    0.12570766f, 0.17673843f, -0.29896966f, -0.27002177f, -0.37343907f, 0.33385488f, -0.06120452f, 0.04230740f, 
    0.15125804f, -0.85446632f, -0.22672772f, -0.22484320f, 0.02242870f, 0.15035167f, 0.22991647f, -0.10533419f, 
    0.01381263f, -0.52141708f, 0.06278450f, -0.06377532f, -0.39562064f, -0.16389163f, 0.49450171f, -0.34385952f, 
    -0.47777587f, -0.03074446f, -0.08049273f, -0.39541841f, -0.19098783f, -0.04043618f, -0.25280890f, -0.41769558f, 
    -0.13646728f, -0.12409274f, 0.22045447f, 0.17296626f, -0.40567845f, 0.29349843f, 0.10205250f, -0.37373418f, 
    0.15662684f, -0.56639081f, 0.19274370f, 0.15160017f, -0.04328363f, 0.06007202f, 0.00803185f, -0.51400685f, 
    -0.19870482f, -0.08565328f, 0.08799438f, -0.13346596f, -0.06306297f, 0.21529682f, -0.22725692f, 0.21495421f, 
    0.13582571f, 0.20927572f, -0.19275008f, -0.09648429f, 0.02394453f, 0.22939616f, -0.07914231f, 0.20935087f, 
    0.27882123f, -0.25664926f, -0.37182021f, 0.10350047f, -0.23406769f, -0.41375270f, 0.04171717f, 0.32898456f, 
    0.01888730f, -0.22945097f, 0.20819393f, -0.07996325f, -0.31760004f, -0.12562816f, -0.07352017f, -0.39531767f, 
    0.23729506f, -0.03042096f, 0.31772009f, -0.10345823f, 0.12260379f, -0.30788350f, -0.29572186f, 0.00989143f, 
    0.01123203f, -0.11666929f, 0.06993369f, -0.02498496f, 0.21480943f, 0.01411994f, -0.19417061f, -0.18643743f, 
    -0.09782144f, -0.03124536f, -0.10563827f, 0.41095939f, 0.05292256f, -0.10368045f, -0.38400131f, -0.01939539f, 
    -0.10018034f, -0.14182375f, 0.05543052f, 0.01436367f, -0.35595942f, -0.58624208f, -0.75433779f, 0.21288148f, 
    -0.30665937f, -0.59164470f, 0.27478242f, -0.43408486f, -0.66096163f, -0.28233039f, -0.50845182f, -0.01664994f, 
    0.36414373f, 0.22708997f, 0.14339595f, 0.40112099f, -0.80182534f, -0.38884643f, -0.04126174f, -0.13979441f, 
    -0.22574653f, -0.03461755f, 0.15454882f, -0.35941595f, -0.37279743f, 0.05467959f, -0.10852475f, 0.42479932f, 
    -0.37058663f, -0.28720248f, 0.24388075f, 0.17195950f, -0.30394626f, -0.27535790f, 0.12996146f, -0.03767308f, 
    -0.10127398f, -0.19642559f, 0.17528878f, -0.54328209f, 0.25933090f, 0.18448144f, 0.35644388f, 0.18293706f, 
    -0.54331076f, 0.26464009f, -0.04875996f, 0.15061456f, -0.35876665f, -0.49351117f, 0.03731516f, -0.09862341f, 
    0.24684067f, 0.11024156f, 0.41723183f, -0.45959833f, 0.01330475f, -0.35725605f, -0.34005544f, 0.34303215f, 
    -0.36494488f, 0.09296685f, -0.12415010f, 0.23248921f, 0.25129798f, -0.46574268f, -0.45026666f, -0.27224383f, 
    0.26505867f, -0.49964038f, 0.07914153f, 0.05665176f, -0.33775771f, -0.20562564f, 0.34196165f, -0.20122749f, 
    -0.20097426f, -0.40604645f, -0.00907308f, -0.32616457f, -0.21454979f, -0.49794501f, -0.29694378f, -0.12343241f, 
    -0.25298649f, -0.26911348f, -0.08673864f, 0.12977616f, -0.04033523f, -0.19667062f, 0.27480838f, 0.09484087f, 
    -0.59953010f, 0.25880811f, -0.23857521f, 0.01177709f, -0.17451549f, -0.09749544f, 0.47265661f, 0.19841100f, 
    -0.52086705f, -0.05214047f, 0.13508217f, -0.12019010f, 0.06758533f, -0.26329461f, -0.37994316f, 0.12734440f, 
    0.27337891f, 0.17446284f, -0.05286962f, 0.10523175f, -0.01540390f, 0.26811233f, 0.13650955f, -0.21703419f, 
    0.24128214f, -0.08669633f, -0.27175108f, -0.02299963f, 0.29821467f, 0.24079666f, 0.62564409f, -0.52670419f, 
    -0.22643186f, -0.22493944f, -0.15103702f, -0.38601154f, -0.25443089f, 0.02254917f, -0.10478585f, -0.36184976f, 
    0.25607669f, -0.59869450f, -0.48161599f, 0.15348640f, -0.50111413f, -0.44779053f, -0.12434738f, -0.12534082f, 
    -0.22248369f, -0.28005347f, -0.13247617f, 0.29115462f, -0.07134321f, -0.63784158f, -0.69700402f, 0.11329007f, 
    0.23250405f, -0.33726898f, 0.46958405f, 0.33615732f, 0.18887234f, 0.14522575f, -0.43759742f, -0.02881860f, 
    -0.26143533f, -0.19415297f, -0.24056157f, -0.26476952f, 0.48354626f, -0.17640088f, -0.23711433f, 0.20615573f, 
    -0.13398923f, -0.43752015f, -0.13041513f, 0.13451937f, -0.34548736f, -0.85911924f, -0.11649537f, 0.16248888f, 
    -0.01257454f, -0.11302742f, -0.05250004f, -0.15004519f, -0.41110396f, -0.12170791f, -0.44431973f, -0.09485368f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.31797320f, 0.00166476f, 0.30396527f, -0.13758780f, 0.00527993f, -0.03853723f, 0.18430656f, 0.00081417f, 
    0.26114449f, -0.01455409f, 0.01964287f, -0.14802305f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
