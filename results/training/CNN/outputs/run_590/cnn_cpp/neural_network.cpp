#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.63811052f, 0.02039576f, 0.25560161f, 0.10706667f, -0.16743165f, 0.07196683f, 0.06365927f, 0.47793797f, 
    -0.27956322f, -0.69710171f, 0.37367466f, 0.28456047f, -0.09411518f, 0.48318464f, 0.51641989f, -0.13355634f, 
    -0.04105468f, 0.47452679f, -0.13820194f, 0.36521262f, -0.01052389f, 0.60349613f, 0.77470958f, 0.07514540f, 
    0.26475695f, 0.13183191f, -0.26198950f, 0.42937738f, 0.13676117f, -0.73662025f, -0.32650864f, -0.83803624f, 
    -0.07573257f, 0.32145464f, 0.02524327f, 0.07757895f, 0.39915377f, 0.20797141f, 0.04891551f, -0.38738939f, 
    -0.49704087f, -0.14365740f, -0.38885620f, 0.26020220f, -0.14103155f, 0.59179217f, -0.53674245f, -0.48311955f, 
    -0.24461776f, 0.09917853f, 0.02338300f, -0.32398862f, 0.01141706f, 0.38103873f, 0.59865040f, -0.26042631f, 
    0.41427413f, 0.35360020f, 0.33463812f, -0.56831127f, -0.33076963f, -0.04601173f, 0.32371730f, 0.45089173f, 
    0.58388203f, -0.81283271f, 0.24537174f, 0.28893873f, -0.01371663f, 0.38563275f, -0.17689757f, 0.00980125f, 
    -0.64396399f, -0.43188411f, -0.51821351f, 0.47858942f, 0.23667003f, 0.21113770f, 0.40153775f, 0.00289371f, 
    0.26597747f, -0.41251206f, -0.49187881f, -0.12670758f, 0.41248539f, -0.15210538f, 0.30574808f, -0.29454893f, 
    -0.20508665f, -0.15358077f, 0.52942133f, 0.25835553f, 0.24198009f, -0.54333472f, -0.16211197f, -0.53056669f, 
    -0.17486192f, -0.41512680f, -0.39447910f, -0.28339666f, -0.52157885f, 0.43751448f, -0.59848827f, 0.04899076f, 
    -0.42067599f, 0.06808329f, 0.37310284f, 0.20706163f, 0.56738883f, 0.59624553f, 0.22699687f, -0.30189741f, 
    0.44521645f, -0.39282170f, 0.05865307f, -0.10917510f, 0.20937705f, -0.00471096f, -0.82248837f, -0.41167673f, 
    -0.27516109f, -0.47215807f, -0.48895663f, -0.38952225f, 0.32896832f, -0.13381633f, -0.31386217f, 0.67662895f, 
    -0.62117493f, 0.62268126f, 0.42948058f, -0.44178516f, -0.14094102f, 0.33059686f, 0.16968040f, -0.61155397f, 
    0.31411076f, 0.67549694f, 0.57522529f, 0.00647550f, 0.30847546f, 0.34666848f, 0.11274009f, 0.06546004f, 
    0.39688629f, -0.21222734f, 0.59750086f, 0.36460960f, -0.26442972f, 0.47421440f, 0.31878334f, -0.40591395f, 
    -0.28331190f, -0.59912801f, -0.12309108f, 0.55942965f, -0.02474783f, 0.58434582f, 0.27133206f, -0.39964095f, 
    -0.42933574f, -0.27804282f, -0.07321086f, 0.55097073f, -0.04197833f, 0.17682843f, 0.48188630f, 0.35927805f, 
    -0.32938799f, -0.35222980f, 0.08137785f, -0.46433297f, -0.31300592f, -0.59442139f, -0.27508280f, 0.50598711f, 
    0.70441759f, 0.00692333f, -0.20627387f, 0.14493644f, -0.28925121f, 0.08435016f, -0.46826124f, -0.39374521f, 
    0.66936862f, -0.26248541f, 0.06315036f, -0.48612344f, 0.12432798f, -0.08448523f, -0.44190419f, 0.25330740f, 
    0.05611939f, 0.34548911f, -0.61211061f, -0.20155269f, -0.50303227f, -0.43753886f, -0.29130661f, -0.43480450f, 
    -0.04987942f, -0.47769174f, 0.62612373f, -0.43433920f, 0.13610998f, 0.19329475f, -0.20622450f, -0.57768577f, 
    -0.21103437f, -0.20381476f, -0.49657691f, -0.19726002f, 0.47049725f, 0.34108400f, 0.33257550f, -0.23153722f, 
    0.30036274f, 0.20881629f, -0.08269241f, -0.36490741f, 0.48684400f, 0.37658349f, 0.21806352f, -0.40417382f, 
    -0.52144456f, -0.09887766f, 0.15271030f, -0.44770205f, 0.67449611f, -0.24947397f, 0.11061796f, -0.32219660f, 
    -0.40974638f, 0.05342088f, -0.45438749f, -0.38411653f, -0.51251292f, 0.26856050f, 0.38532642f, -0.24760693f, 
    -0.13631345f, 0.04668084f, -0.20393395f, 0.38906190f, 0.49651229f, 0.53946418f, 0.48260182f, -0.23996940f, 
    0.49162912f, -0.35534394f, 0.07833353f, -0.01328032f, 0.41288203f, 0.44152892f, 0.62124389f, 0.22913873f, 
    -0.13610101f, -0.22241932f, 0.41675150f, 0.24431024f, -0.02826689f, 0.45594555f, 0.47486377f, -0.00213731f, 
    -0.30613393f, -0.22161260f, 0.26464498f, 0.24199340f, -0.15381500f, 0.28783453f, 0.16341411f, 0.14249611f, 
    0.19249319f, -0.42535955f, -0.62455904f, -0.45969206f, 0.02414325f, 0.33425471f, 0.40740100f, -0.40047592f, 
    0.34930840f, 0.06188073f, -0.38905495f, -0.43408981f, -0.33538991f, -0.22266167f, 0.19369422f, -0.21800902f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.23215814f, 0.12281413f, -0.05883067f, -0.24334471f, 0.28819510f, -0.18308993f, -0.17788731f, -0.13498867f, 
    0.09075858f, 0.07935918f, 0.07384826f, -0.19875349f, -0.03124265f, -0.21197505f, -0.25849521f, -0.43981746f, 
    -0.17103398f, -0.14216709f, -0.00266240f, 0.13688365f, -0.28752014f, -0.06785596f, -0.18632910f, 0.15544155f, 
    -0.07715531f, -0.13481137f, 0.02956047f, -0.11151099f, -0.14648524f, 0.21940325f, -0.00154264f, 0.04700844f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04598533f, -0.09460551f, 0.10056784f, -0.04238823f, -0.11354812f, -0.14470358f, -0.03355807f, 0.01459292f, 
    0.01125188f, 0.02391696f, 0.25077829f, -0.02046604f, 0.06282361f, 0.08532804f, -0.05885347f, 0.00980983f, 
    -0.03983119f, 0.02944542f, 0.20329544f, 0.09671166f, 0.08638592f, 0.04626691f, 0.04810501f, -0.01875250f, 
    0.00409605f, 0.07546832f, -0.06101470f, -0.07868839f, -0.08296666f, -0.02782912f, 0.03573976f, 0.01430601f, 
    -0.01465950f, 0.06128917f, -0.10586426f, 0.10209663f, 0.02000503f, 0.10345817f, 0.11579110f, 0.05494463f, 
    0.05289304f, 0.01039863f, -0.01626837f, -0.02651805f, 0.10659426f, -0.24922618f, -0.42478770f, -0.13185582f, 
    -0.13913292f, -0.05384369f, -0.03160111f, -0.01351837f, 0.02130443f, 0.01968949f, 0.19342402f, 0.05029847f, 
    -0.04772015f, -0.05509647f, 0.04581570f, 0.02199752f, 0.13771370f, -0.01967311f, 0.08029044f, 0.05500396f, 
    -0.30990097f, -0.22587934f, 0.06731799f, -0.04322138f, 0.04947019f, -0.06622038f, 0.06119705f, 0.08700031f, 
    0.10789446f, 0.31403422f, -0.23587179f, 0.14467680f, 0.08084126f, -0.06091651f, 0.00913310f, 0.03237237f, 
    -0.06259011f, -0.03018922f, 0.19534414f, -0.04822087f, 0.07395622f, 0.08106581f, -0.09541590f, 0.13164826f, 
    0.00026383f, -0.03896415f, -0.01320360f, -0.01762215f, -0.02771763f, 0.01113541f, 0.00564614f, -0.08818364f, 
    0.07778245f, 0.08558682f, 0.08205384f, -0.18179496f, -0.34507298f, -0.03131695f, 0.00819736f, 0.16987509f, 
    -0.01623745f, -0.02629261f, 0.05612553f, 0.10253948f, -0.00278672f, 0.17569797f, -0.02451260f, -0.03724618f, 
    -0.07053633f, -0.13264014f, -0.00357436f, 0.05247653f, 0.06598352f, -0.22832732f, -0.55528742f, 0.16890411f, 
    -0.05843875f, 0.05088647f, -0.10838733f, -0.04002462f, 0.00999928f, -0.08208079f, 0.06647553f, -0.25314999f, 
    -0.23461913f, 0.01980106f, 0.03332807f, 0.00050630f, -0.03315615f, -0.07260984f, 0.00624092f, -0.10337768f, 
    0.16793753f, 0.00245183f, -0.03691781f, 0.08873678f, -0.10150427f, -0.05442516f, -0.02099674f, -0.00620107f, 
    -0.07630161f, 0.00343634f, 0.00012364f, 0.10120244f, 0.00082541f, -0.06279837f, 0.05001351f, -0.00874865f, 
    0.02243063f, -0.12502404f, 0.18912132f, 0.02368362f, -0.04983508f, -0.07538728f, -0.01193200f, 0.08896996f, 
    0.05339484f, -0.00786826f, 0.07657260f, 0.20446865f, -0.01316115f, 0.02539429f, 0.01599673f, -0.12105544f, 
    0.12622380f, 0.01867055f, -0.00776988f, 0.00343024f, 0.34710145f, -0.27947998f, 0.14062040f, 0.02694775f, 
    0.00991317f, 0.06414200f, -0.11020753f, 0.06094613f, 0.23563565f, -0.12264714f, -0.15190342f, 0.03769565f, 
    -0.06784705f, 0.03092041f, 0.06655248f, -0.08512329f, -0.11237674f, -0.07923102f, -0.20998676f, -0.05073657f, 
    0.08564112f, 0.03495612f, 0.13443933f, 0.04990296f, -0.07216826f, -0.02702030f, -0.38200644f, -0.05499099f, 
    0.08532164f, 0.03506933f, 0.13330367f, -0.02981730f, 0.04372871f, -0.09773401f, -0.09616970f, -0.16915578f, 
    0.10981252f, -0.28928250f, 0.03449651f, -0.06784115f, 0.08430719f, 0.04112853f, 0.05527894f, -0.01749088f, 
    -0.11816597f, -0.03047275f, -0.06985521f, -0.06274659f, 0.07507393f, 0.04272813f, 0.05033308f, 0.08171424f, 
    0.05447797f, 0.00916946f, -0.09980146f, -0.11014555f, 0.01193444f, -0.04152134f, 0.08270172f, 0.10882287f, 
    0.11545511f, -0.16301228f, -0.06318748f, 0.05353405f, -0.14157966f, 0.14752063f, 0.10382612f, -0.04419900f, 
    -0.02974297f, 0.00093308f, -0.01327463f, 0.00572598f, 0.04878575f, 0.02688043f, -0.00128326f, -0.11097579f, 
    -0.01228731f, 0.05648710f, 0.06712747f, -0.09940051f, -0.11129446f, 0.08385412f, 0.21836382f, 0.11809479f, 
    0.00821611f, -0.13424541f, -0.03954713f, -0.08086404f, 0.00275153f, 0.12101951f, 0.04605194f, -0.04613252f, 
    -0.01090902f, -0.12910202f, -0.00935798f, -0.07244159f, -0.04600087f, 0.03391993f, -0.03355606f, -0.12020112f, 
    0.07742900f, -0.08089171f, 0.04901879f, -0.01897884f, -0.04010466f, 0.07497031f, 0.10827027f, -0.14982563f, 
    0.10460313f, -0.07122248f, 0.01831549f, -0.01605723f, 0.02537586f, 0.12565510f, 0.01553597f, 0.06714130f, 
    0.02323100f, -0.16291808f, 0.03383594f, 0.03267652f, -0.14087838f, -0.15474840f, 0.00306549f, -0.22118860f, 
    0.05229872f, -0.16610947f, 0.05980187f, 0.04189545f, 0.01837846f, -0.09173521f, -0.08115585f, 0.04310257f, 
    0.04716639f, 0.10003276f, 0.12544997f, -0.06478795f, 0.07443243f, 0.07573444f, 0.05590650f, -0.08045694f, 
    0.02177157f, -0.02493526f, 0.04662581f, -0.02527599f, 0.01120237f, -0.03979674f, -0.07321043f, -0.09050914f, 
    0.06026963f, 0.12692040f, 0.05521107f, -0.08648987f, -0.00405602f, -0.16174659f, 0.02391919f, -0.14580388f, 
    -0.03043498f, -0.03949996f, 0.02694955f, 0.01947321f, -0.15825137f, 0.06838769f, 0.07900127f, 0.01490583f, 
    0.14972274f, 0.02600863f, 0.15685867f, -0.21454336f, 0.03360063f, 0.02538560f, 0.06725281f, 0.06527501f, 
    -0.01950344f, -0.11389162f, -0.01478047f, -0.02764951f, -0.06211696f, -0.01331368f, 0.07189011f, -0.17369090f, 
    -0.06123894f, -0.02659135f, 0.01303332f, -0.00470285f, -0.01637971f, 0.03377381f, 0.05090930f, -0.02291681f, 
    0.19426417f, 0.16550645f, 0.09467673f, -0.00133812f, 0.08225810f, -0.03646893f, 0.07971776f, 0.05230214f, 
    0.09921949f, 0.17702758f, 0.19238746f, 0.17045924f, 0.13820539f, -0.01506898f, -0.05537752f, -0.07604843f, 
    0.09265015f, 0.04963225f, -0.12889159f, -0.17267524f, 0.19836064f, -0.00984822f, -0.01957774f, -0.05016898f, 
    -0.10683472f, 0.01927666f, -0.07804533f, -0.02485981f, 0.06405792f, -0.13251893f, 0.10681607f, 0.04457829f, 
    0.02205713f, -0.03733934f, -0.11956777f, -0.05942537f, -0.10472714f, -0.10566166f, 0.01909393f, 0.00714078f, 
    -0.13412328f, 0.12995830f, -0.03026070f, 0.05285251f, 0.07595129f, 0.17097783f, -0.04561386f, 0.18969983f, 
    0.05353148f, -0.10729723f, 0.07392787f, -0.06765350f, 0.03993682f, -0.09384077f, -0.01678488f, -0.06773065f, 
    0.08373996f, -0.03849068f, 0.08484012f, 0.02680013f, 0.04286507f, 0.08442905f, -0.05727980f, -0.21269062f, 
    -0.07013886f, 0.12539817f, 0.01525461f, -0.04514012f, 0.05218284f, 0.04902201f, 0.13915832f, 0.18642226f, 
    0.03001944f, -0.10091671f, 0.03703081f, 0.00572134f, 0.02391947f, 0.01041051f, 0.01599277f, -0.06971941f, 
    0.14095213f, -0.06424750f, 0.10825446f, -0.05954107f, 0.00507511f, 0.01315820f, 0.01159606f, -0.01458535f, 
    -0.00126592f, -0.04871453f, 0.08530080f, -0.23489106f, -0.00885362f, -0.02756570f, -0.03422771f, 0.00404616f, 
    0.02692321f, 0.02305819f, 0.14680751f, 0.15883401f, 0.07985679f, 0.06510228f, 0.16256070f, -0.07255684f, 
    -0.05700774f, 0.03979281f, 0.00591291f, -0.04572697f, 0.20956011f, 0.05406936f, 0.13369638f, 0.14904641f, 
    0.09100550f, 0.04641454f, -0.13264000f, -0.09577625f, -0.29968297f, 0.14667931f, 0.21139942f, -0.06048901f, 
    0.05998971f, 0.05670096f, 0.05332121f, -0.08709643f, 0.16263708f, 0.03931498f, 0.11062159f, 0.10536392f, 
    0.12749064f, 0.08627795f, -0.00642185f, 0.05123362f, -0.09543573f, -0.00797907f, -0.03690524f, 0.09588060f, 
    0.07955740f, 0.06039655f, 0.08347992f, -0.05904453f, -0.08557926f, 0.00194799f, -0.01250070f, 0.02710016f, 
    -0.01918845f, -0.11561482f, 0.05433584f, 0.12485738f, 0.06911836f, -0.04655159f, -0.01959656f, 0.10622690f, 
    0.01791657f, 0.13669752f, -0.03437696f, 0.00744521f, 0.02580016f, 0.13598870f, -0.12418927f, 0.04750675f, 
    0.01275146f, -0.03748082f, 0.18586330f, 0.15999421f, 0.17015353f, 0.05390742f, -0.07918396f, -0.04240755f, 
    0.00531997f, 0.05524709f, -0.05407102f, 0.26214084f, -0.07787132f, 0.00778252f, -0.12922615f, 0.00796136f, 
    -0.02508593f, -0.01903804f, 0.00104726f, 0.13265446f, -0.02410599f, -0.08645623f, -0.07134908f, -0.00395165f, 
    -0.06348513f, -0.00392951f, 0.02688261f, 0.01334679f, 0.03913184f, -0.09918127f, -0.05402236f, -0.02721121f, 
    -0.06832150f, -0.18642814f, 0.01220178f, 0.05878285f, 0.02655655f, 0.11571705f, -0.13687573f, -0.29440951f, 
    -0.07210110f, -0.08635818f, 0.05971703f, -0.00415442f, 0.05271900f, -0.00906709f, -0.11551492f, -0.03131586f, 
    -0.10241828f, -0.00337572f, -0.22532409f, -0.12441418f, -0.07935916f, -0.08193538f, 0.06217811f, -0.13689683f, 
    -0.05151280f, 0.06761987f, -0.19977486f, -0.01892402f, 0.04778115f, 0.11633442f, -0.03731352f, -0.05961256f, 
    -0.03044138f, 0.01893488f, 0.03122106f, -0.08045304f, 0.03554000f, -0.08322912f, -0.00722723f, 0.04617922f, 
    0.08183181f, -0.19938099f, -0.14263350f, 0.18734725f, 0.11998198f, 0.06417704f, 0.06589811f, -0.01735846f, 
    0.16968364f, 0.00323994f, -0.04174398f, 0.07062638f, 0.18581113f, 0.01764203f, -0.14241339f, 0.19817422f, 
    0.01670599f, -0.03071066f, -0.03194649f, 0.09969231f, -0.00860515f, 0.12648390f, 0.07312241f, -0.16531679f, 
    0.07149577f, -0.14048216f, 0.07869577f, -0.01537351f, 0.07556370f, 0.17165999f, 0.05739444f, 0.17571418f, 
    -0.06924882f, 0.15973917f, -0.03893378f, -0.12495521f, 0.03732331f, -0.06778008f, -0.00022004f, 0.05892867f, 
    -0.30556616f, -0.25145182f, 0.03686490f, 0.15456793f, -0.01941438f, -0.04303136f, 0.03331801f, -0.35065025f, 
    0.15249872f, 0.09142633f, -0.06925466f, 0.06227616f, -0.11793055f, 0.12396424f, -0.06127271f, 0.05885619f, 
    -0.11202411f, -0.15266681f, 0.08378822f, 0.10872842f, 0.07084473f, 0.15906115f, 0.10391537f, 0.02219834f, 
    0.03336998f, 0.20465453f, 0.02797975f, 0.07551609f, -0.02581285f, -0.02970618f, 0.02757137f, 0.08241583f, 
    0.09301290f, 0.04085905f, -0.11417713f, -0.00764967f, -0.03719188f, 0.10581585f, -0.00985939f, 0.02489731f, 
    0.06088918f, 0.00476003f, 0.04104638f, 0.05349612f, -0.12383823f, 0.13795033f, 0.02064872f, -0.13757697f, 
    -0.00774240f, -0.11732478f, 0.03570463f, 0.02742049f, -0.30750698f, 0.06745850f, -0.17434621f, -0.14908865f, 
    -0.03815546f, 0.04181659f, -0.01330225f, 0.05136136f, 0.04140442f, 0.16970332f, -0.17833133f, 0.20893236f, 
    0.00192154f, -0.04281301f, 0.12833062f, -0.09331163f, -0.12093814f, 0.01740302f, -0.12995853f, -0.01267901f, 
    -0.01965328f, -0.06699532f, -0.01161186f, -0.07824948f, 0.18575275f, -0.06397389f, 0.12909703f, 0.02231614f, 
    0.08156235f, -0.22151254f, -0.00644696f, 0.09040995f, 0.07605636f, -0.09127878f, -0.02481858f, -0.21150914f, 
    0.17294627f, 0.11496564f, -0.19130349f, 0.01548936f, 0.15730914f, 0.07876167f, 0.14920866f, -0.09726972f, 
    -0.09625952f, 0.14857325f, 0.06879584f, -0.07498523f, 0.05744345f, 0.06782613f, -0.02976224f, 0.06942569f, 
    -0.04456238f, -0.09258504f, -0.07069995f, -0.01948962f, 0.01467036f, 0.00844915f, -0.06530543f, 0.03936845f, 
    0.25240141f, 0.04358641f, -0.04458355f, 0.01565248f, -0.19899634f, 0.02559104f, 0.02773295f, 0.01173071f, 
    0.03914400f, 0.03234970f, 0.10865964f, 0.03634754f, -0.06990461f, 0.06881211f, -0.05861035f, -0.02327909f, 
    0.01079367f, 0.04231907f, 0.01545213f, 0.09005596f, 0.06947585f, 0.06286847f, 0.14303055f, -0.03287084f, 
    -0.00470614f, -0.00530348f, 0.17278779f, -0.13396956f, -0.05601460f, 0.08521481f, -0.02421163f, 0.07642122f, 
    0.22270693f, -0.02526008f, -0.15873766f, -0.06040169f, -0.04920265f, -0.08416122f, 0.02347935f, 0.11933515f, 
    -0.18368106f, 0.07042319f, 0.07325304f, 0.00972096f, 0.07525977f, -0.14979871f, 0.02258861f, 0.09658884f, 
    0.02145069f, -0.08256627f, -0.02378578f, -0.14673474f, -0.02203513f, 0.03109076f, 0.06705168f, 0.10509807f, 
    -0.08027440f, 0.17872456f, 0.08871070f, 0.02326418f, -0.14768796f, 0.11077543f, -0.02257277f, 0.18484463f, 
    -0.08966306f, -0.02436717f, -0.11698948f, -0.05675129f, 0.14519539f, 0.19036783f, 0.03589256f, 0.11508929f, 
    -0.03907795f, 0.09774409f, 0.10302942f, 0.11004570f, 0.10959712f, -0.02216798f, 0.05700422f, -0.05561960f, 
    0.02282858f, 0.00658183f, -0.03215432f, -0.04374784f, -0.30994365f, 0.05095350f, -0.16656490f, 0.14912756f, 
    -0.00177440f, -0.02644197f, 0.00396757f, -0.01470727f, -0.01764829f, -0.06479949f, -0.02376239f, -0.03346615f, 
    -0.01653011f, 0.00871737f, -0.04574615f, -0.03679911f, 0.02995487f, -0.13670316f, 0.13346560f, -0.08378693f, 
    -0.09505334f, -0.06237833f, -0.05142575f, -0.19712760f, -0.03994258f, 0.00206052f, 0.01946167f, 0.20385538f, 
    0.04924604f, -0.01313502f, 0.01916606f, -0.05282139f, -0.06091581f, -0.01173463f, 0.05099071f, -0.12143093f, 
    -0.01548774f, -0.13273413f, 0.05181098f, -0.00752468f, -0.04488355f, -0.02685818f, 0.11119360f, -0.03085139f, 
    0.06996010f, -0.20222154f, 0.15263614f, -0.06949173f, -0.04037746f, 0.05617542f, 0.12426413f, 0.08815844f, 
    -0.10831203f, 0.06986654f, -0.04303619f, -0.09999008f, 0.13925883f, -0.01489379f, -0.04170356f, -0.10123794f, 
    -0.06319337f, 0.00791509f, -0.01283377f, 0.00783101f, -0.15996073f, -0.13926959f, 0.05717324f, -0.08786833f, 
    0.05872782f, 0.08192727f, -0.05985962f, 0.05309917f, 0.13392274f, 0.00933024f, -0.11326866f, 0.09708548f, 
    -0.04979015f, 0.15181750f, 0.08489137f, 0.01888252f, 0.12118877f, -0.19245972f, -0.53950077f, -0.21941522f, 
    -0.01877342f, 0.05122462f, -0.04948401f, 0.03073533f, -0.05195278f, 0.06091560f, -0.12435494f, -0.03460859f, 
    0.12593772f, -0.11060102f, 0.12246080f, 0.04106451f, 0.03828578f, -0.09280052f, -0.05375332f, 0.23555726f, 
    -0.17740481f, 0.15271780f, 0.00518690f, 0.06072626f, -0.05478629f, 0.05443066f, -0.02135583f, -0.05596907f, 
    -0.14118311f, 0.05089433f, -0.23961835f, -0.03498043f, 0.02418865f, 0.00575090f, 0.02379967f, 0.04565563f, 
    -0.16661131f, -0.21542142f, 0.07839816f, -0.10589158f, 0.03858281f, -0.06081258f, -0.15383217f, 0.05881998f, 
    -0.05783311f, -0.02190027f, 0.18257694f, 0.13344623f, -0.04789489f, -0.05513719f, 0.13692302f, 0.08225197f, 
    0.03464434f, -0.03086116f, 0.02371108f, -0.14893189f, 0.04088736f, -0.07000753f, 0.07301462f, -0.08491153f, 
    0.08727989f, 0.04180978f, -0.05390256f, -0.03953544f, 0.28427210f, 0.06294764f, 0.06818327f, 0.10892040f, 
    0.02922271f, 0.09178153f, -0.12581712f, 0.02907005f, 0.03201653f, -0.14492342f, -0.01419363f, -0.08088592f, 
    -0.04065410f, 0.10666591f, -0.06870732f, -0.11157458f, -0.04728797f, 0.04538846f, -0.28139949f, -0.13564482f, 
    0.03688191f, -0.05892122f, 0.06842341f, 0.11601936f, -0.02269774f, -0.05778077f, 0.06123642f, -0.13765293f, 
    -0.14074588f, 0.07339256f, 0.08850538f, 0.04118038f, 0.00862625f, 0.04540072f, -0.15067254f, -0.17206907f, 
    -0.11427879f, 0.05958099f, 0.16834073f, 0.07077363f, 0.00279377f, 0.02736042f, 0.14767580f, 0.03382083f, 
    0.02765293f, -0.35325274f, -0.12132005f, -0.48134506f, 0.02296438f, -0.02179383f, 0.02024054f, -0.05212881f, 
    0.09473605f, -0.01069840f, -0.03934893f, 0.05339592f, -0.09349501f, 0.04348254f, -0.13786799f, -0.01717015f, 
    -0.00717894f, 0.12565807f, -0.02633549f, 0.03577857f, -0.00800963f, -0.11326759f, -0.00944667f, 0.06326368f, 
    0.02446002f, 0.12424905f, 0.03610091f, -0.00512872f, -0.24413471f, -0.41922635f, -0.08283318f, -0.05669031f, 
    0.03234645f, -0.05591207f, -0.00674014f, 0.09671947f, -0.14708301f, 0.01654771f, -0.06673905f, -0.13493779f, 
    -0.00810675f, 0.02026414f, 0.02554499f, -0.00995096f, -0.04610921f, -0.01335051f, 0.11885723f, -0.05146670f, 
    -0.23252629f, -0.07846727f, 0.14131302f, 0.15910853f, -0.03217912f, -0.10485855f, -0.03821271f, -0.05532549f, 
    0.20335892f, -0.21924609f, 0.02199221f, -0.02810716f, 0.02270149f, -0.05765007f, -0.02056889f, 0.10819747f, 
    0.19038409f, 0.09551671f, 0.01868880f, -0.01192203f, 0.12559965f, 0.00245798f, 0.10131913f, 0.05491817f, 
    0.03101357f, -0.11680984f, -0.05954929f, -0.08549562f, -0.10033814f, -0.02031561f, -0.08368333f, 0.14422937f, 
    -0.11513836f, -0.07010674f, -0.16402952f, -0.03461083f, -0.39714435f, -0.07066860f, -0.03111884f, 0.07172664f, 
    0.00645489f, -0.02559829f, -0.13412228f, 0.22995149f, 0.11151637f, 0.20694634f, -0.04522694f, 0.14724621f, 
    0.03783417f, 0.11385716f, 0.06230374f, 0.01654861f, 0.19886655f, 0.00559428f, 0.21492164f, -0.00156198f, 
    0.07072779f, -0.00741771f, 0.20253640f, 0.05903267f, -0.06972592f, 0.19468983f, -0.03462319f, 0.00853550f, 
    0.05823691f, -0.07207754f, 0.08220451f, 0.00963288f, 0.00227517f, 0.03254298f, 0.08157957f, 0.01815965f, 
    0.11019163f, 0.07204630f, -0.13130216f, 0.09086132f, -0.12451348f, -0.01025266f, 0.14588875f, 0.00882827f, 
    -0.01136820f, -0.30196568f, 0.10504092f, 0.06693716f, 0.02283490f, 0.16756257f, -0.02316599f, 0.03306504f, 
    -0.06356944f, -0.02060770f, -0.03632465f, -0.04909072f, 0.05819940f, -0.05780069f, 0.04025267f, -0.03690027f, 
    0.00011512f, -0.05532153f, -0.04962550f, -0.03673424f, -0.02048112f, -0.03552769f, 0.02471749f, -0.03813648f, 
    0.02993069f, -0.06448508f, -0.06487615f, -0.05602265f, -0.05069292f, 0.05432296f, -0.00990712f, 0.00961117f, 
    -0.03173525f, 0.00984157f, 0.02213411f, -0.04913095f, 0.04831722f, -0.04194600f, -0.00319377f, -0.03169625f, 
    0.05356168f, 0.02987338f, 0.02086562f, 0.02124047f, 0.01166325f, 0.02034637f, -0.05010241f, 0.02578391f, 
    -0.02259532f, -0.04518265f, 0.04928631f, -0.02901832f, 0.03598825f, 0.03869557f, 0.02893877f, 0.04683649f, 
    -0.01495468f, 0.00084147f, 0.02730245f, 0.01523939f, 0.04738209f, 0.02579121f, 0.03480083f, 0.00213324f, 
    -0.03715426f, -0.03020613f, -0.04352394f, -0.00190405f, -0.01298052f, -0.01285097f, -0.05075187f, -0.01896879f, 
    -0.00552338f, 0.05388968f, -0.06583471f, 0.00846107f, 0.01676039f, 0.03842897f, 0.00877638f, 0.00731203f, 
    -0.01571165f, -0.01162063f, 0.04712640f, 0.02143388f, 0.03308430f, -0.02442344f, 0.04681237f, -0.06689065f, 
    -0.05245677f, -0.04670795f, -0.04564163f, -0.05987332f, 0.03294147f, 0.02113754f, -0.04657512f, 0.02608146f, 
    0.00888805f, -0.00759750f, -0.00154808f, -0.01169227f, -0.02334916f, 0.02154547f, 0.04239577f, -0.02469124f, 
    0.04429435f, 0.01002493f, -0.03951775f, -0.05113492f, -0.03464473f, 0.04642766f, 0.04831036f, -0.05216611f, 
    0.04491018f, -0.06044568f, -0.02037411f, -0.04419481f, -0.00417258f, -0.04423046f, -0.02359614f, -0.03550517f, 
    0.00462313f, -0.00638125f, -0.03347391f, -0.00558929f, -0.01436647f, -0.02775702f, -0.04639906f, -0.03302892f, 
    0.03386253f, -0.06565061f, -0.02610973f, -0.05768009f, -0.01203994f, -0.00551258f, -0.05439857f, 0.04661646f, 
    0.03764358f, -0.02468109f, 0.01908276f, -0.04477064f, 0.04474081f, -0.04476286f, -0.03462470f, 0.03549664f, 
    -0.01757622f, -0.00987238f, 0.03985741f, 0.00219309f, 0.05019392f, -0.02456164f, 0.03969212f, 0.03080337f, 
    -0.06201034f, -0.04355865f, 0.04592774f, -0.02789262f, 0.05648513f, -0.00410446f, -0.03957994f, -0.03971999f, 
    -0.05117692f, -0.04229203f, 0.01102425f, -0.04601384f, -0.02092417f, 0.04647171f, -0.03515887f, -0.06038512f, 
    -0.04144291f, -0.04510743f, -0.00325998f, -0.03386721f, 0.04841634f, 0.03027530f, -0.02280133f, 0.04092035f, 
    0.04988574f, 0.01973242f, 0.02018978f, -0.02157409f, 0.00280761f, -0.03440148f, -0.03735192f, -0.04895829f, 
    -0.06096790f, -0.01581228f, 0.00639704f, 0.02862794f, -0.03161748f, 0.01577237f, 0.04981657f, 0.00819397f, 
    0.01922059f, -0.00519548f, -0.03748025f, -0.04910570f, -0.01497840f, 0.02775172f, -0.03430439f, 0.04993064f, 
    -0.00109640f, 0.04715329f, -0.03354154f, 0.00548860f, -0.05523185f, 0.01479690f, -0.06574005f, 0.06184514f, 
    -0.02726993f, -0.00595336f, -0.02680834f, -0.03863558f, 0.02324571f, -0.04542570f, 0.04592969f, 0.04438322f, 
    -0.01371714f, -0.06177510f, 0.05446921f, -0.02377513f, -0.05691275f, -0.06628024f, 0.05270668f, -0.05624056f, 
    0.00960252f, -0.05361200f, 0.04237127f, -0.01149584f, -0.03984088f, -0.03669645f, -0.00054115f, 0.04554127f, 
    0.00845471f, 0.02203211f, 0.01021373f, 0.00061560f, -0.04619467f, -0.00738560f, -0.06430233f, -0.05514927f, 
    0.00797136f, 0.02458711f, 0.00787891f, 0.00868044f, -0.00328157f, -0.02655378f, 0.04771676f, -0.01143790f, 
    -0.00746946f, -0.06187274f, -0.06736780f, -0.03567489f, -0.04913490f, 0.02028883f, -0.01384370f, -0.05418166f, 
    0.00566914f, -0.03155381f, -0.05339771f, 0.00122514f, -0.04251329f, 0.02404503f, -0.00828729f, 0.00124545f, 
    0.02639197f, -0.03129971f, -0.04422283f, 0.04601501f, 0.04171550f, -0.03652985f, 0.03753405f, -0.00113425f, 
    0.02678557f, 0.01035677f, 0.01743804f, 0.00739580f, 0.00673350f, 0.04429205f, -0.04383972f, -0.05662783f, 
    -0.03930529f, -0.01570107f, -0.01602885f, -0.05662272f, 0.03008979f, -0.02540191f, 0.00923221f, 0.04628166f, 
    -0.06223996f, -0.03989599f, 0.04675549f, -0.00520906f, -0.03832388f, 0.03986885f, 0.04217882f, -0.00005064f, 
    0.04697199f, -0.06200273f, -0.02126726f, 0.04448700f, -0.01396462f, -0.05270616f, -0.01194616f, -0.05672657f, 
    0.00498349f, 0.03163397f, -0.03571397f, -0.05677013f, -0.00755065f, 0.04486389f, 0.01303380f, 0.02186849f, 
    -0.03886004f, -0.02093577f, -0.00417324f, 0.00152134f, 0.03936842f, 0.03590324f, 0.02252557f, -0.01083593f, 
    0.04253904f, 0.05002463f, -0.04970641f, 0.03453016f, -0.04220578f, -0.04628514f, -0.05478756f, -0.06173375f, 
    -0.05718943f, 0.00407331f, -0.03943197f, -0.00855831f, 0.05040109f, 0.04614766f, -0.03170869f, -0.00608074f, 
    -0.02493221f, 0.04975641f, -0.04923564f, 0.04871871f, 0.00882869f, 0.00728053f, 0.03444476f, -0.00617985f, 
    0.03767959f, -0.01790129f, -0.03919213f, 0.00691050f, -0.04082525f, 0.01348588f, 0.02813493f, -0.05530347f, 
    0.02701898f, -0.02862588f, -0.05762606f, -0.00303132f, -0.03681886f, -0.02675317f, 0.02613347f, 0.01074529f, 
    -0.04283557f, 0.04219784f, -0.05374928f, -0.02575708f, -0.02837384f, -0.01056392f, 0.04843828f, -0.02747693f, 
    0.00162811f, -0.01288129f, 0.01716188f, -0.03133272f, -0.06189189f, -0.06810747f, -0.00068740f, 0.02174346f, 
    -0.01144417f, 0.03360312f, -0.03357731f, -0.00475630f, 0.00839572f, -0.00777483f, 0.01225386f, -0.05880935f, 
    0.02709036f, 0.03140164f, -0.05924647f, 0.03410058f, -0.00892125f, 0.00445151f, -0.05225533f, 0.02003891f, 
    -0.05229947f, 0.01890564f, 0.03987804f, -0.00607691f, -0.05191243f, -0.05862790f, 0.02803697f, -0.02286132f, 
    -0.01512960f, 0.04915714f, 0.03265754f, 0.02734753f, -0.00969168f, 0.00100327f, 0.00891290f, -0.04602863f, 
    -0.01275755f, -0.05902295f, 0.01014479f, -0.02500774f, 0.02400977f, 0.03413547f, -0.00322733f, 0.03726229f, 
    0.00996307f, -0.06484812f, -0.05082595f, -0.02112970f, -0.05477693f, 0.01440664f, -0.05385357f, 0.01277178f, 
    0.01430376f, 0.01527461f, -0.03057074f, -0.03203620f, 0.01314167f, -0.03658064f, 0.04534230f, 0.02565448f, 
    0.03698565f, 0.01052069f, 0.03866792f, -0.03976384f, -0.03897110f, 0.04806775f, -0.05431938f, -0.03687034f, 
    0.02454141f, 0.00395503f, -0.04583641f, -0.04982039f, 0.01744799f, 0.01139165f, -0.00173769f, 0.02781921f, 
    -0.05234200f, -0.05234607f, 0.00407348f, 0.04241296f, 0.02244831f, 0.03042028f, 0.01159809f, 0.03247771f, 
    0.01628182f, -0.01011722f, -0.00789909f, -0.06360222f, 0.01673439f, -0.00703630f, -0.01941929f, 0.05599129f, 
    0.02997869f, -0.05665707f, -0.05247452f, -0.01674124f, -0.05838989f, -0.01371426f, -0.00574215f, -0.06286111f, 
    0.00034939f, 0.00844067f, 0.03412406f, 0.00445213f, 0.01917328f, -0.03811210f, -0.05000902f, 0.05782130f, 
    -0.00393989f, 0.04105950f, -0.04156659f, -0.04555400f, 0.01255115f, 0.01580962f, 0.01819716f, 0.01785554f, 
    -0.03064954f, -0.05348124f, -0.00172309f, -0.05367741f, -0.04546404f, -0.05833764f, 0.04001874f, -0.03922325f, 
    -0.02157936f, -0.02274488f, 0.00904911f, -0.06124828f, 0.03000002f, 0.01677551f, 0.02423443f, -0.00392550f, 
    -0.03941816f, -0.02739912f, 0.03909159f, -0.06454285f, -0.04022644f, -0.00683062f, 0.03985083f, -0.00252885f, 
    0.01494827f, -0.05632904f, -0.06472474f, -0.05681220f, -0.01739712f, 0.05122092f, -0.02821970f, -0.01847285f, 
    -0.00924799f, 0.01377660f, 0.01072994f, 0.02861062f, 0.01960190f, -0.05089251f, 0.04066858f, -0.01990433f, 
    -0.02061527f, -0.02120132f, -0.02083751f, -0.01644630f, -0.02910835f, 0.03226407f, 0.01387849f, -0.05632506f, 
    -0.01569908f, -0.06163439f, 0.04476537f, -0.04483224f, -0.04944265f, 0.01497816f, 0.00280140f, -0.04975463f, 
    -0.03933102f, 0.04417042f, 0.01144246f, -0.04124901f, 0.00583958f, -0.02064616f, -0.00417340f, -0.03607252f, 
    -0.04003871f, 0.01088439f, 0.02060685f, -0.01030322f, -0.01121922f, 0.03963131f, -0.04387233f, -0.01479950f, 
    0.03084617f, 0.00444531f, -0.02080174f, 0.03368173f, 0.01158954f, 0.00786823f, -0.06199102f, 0.00940944f, 
    -0.01104148f, -0.01809985f, -0.04215696f, 0.01439300f, 0.03544982f, -0.05524343f, 0.02089847f, -0.02452253f, 
    -0.02791470f, -0.03827909f, -0.00980576f, -0.05117521f, -0.00532987f, 0.04355240f, -0.00828340f, 0.00468081f, 
    -0.05251533f, 0.02354371f, -0.06281997f, 0.02537849f, -0.05560838f, -0.04569190f, 0.02402647f, 0.01688978f, 
    0.04212086f, -0.01081235f, -0.02084668f, -0.01892061f, 0.00112800f, -0.06724876f, 0.01795160f, -0.03043685f, 
    0.04263464f, -0.05717996f, 0.01576731f, 0.03858674f, -0.02499717f, -0.01006966f, 0.05113574f, -0.02677633f, 
    0.04284041f, -0.03100323f, -0.01919372f, 0.04274119f, -0.06085098f, -0.01534371f, -0.05415660f, -0.01314264f, 
    -0.06265789f, -0.03095531f, -0.06088698f, 0.03518095f, 0.02649812f, 0.05186507f, 0.02506723f, 0.04207947f, 
    0.03093401f, -0.03479925f, -0.03792610f, -0.06146544f, -0.02520051f, 0.03054812f, 0.04178697f, -0.04568809f, 
    0.00404610f, 0.01410245f, 0.02282263f, 0.03138207f, 0.04540687f, 0.04615512f, -0.01320159f, 0.01697783f, 
    0.02281021f, 0.03098796f, -0.00408080f, -0.05873290f, -0.01771856f, -0.00703546f, -0.06273110f, 0.00048814f, 
    0.00263057f, 0.01528585f, -0.04596066f, 0.03600452f, -0.02599218f, -0.00636907f, -0.03445303f, -0.06483950f, 
    0.00586556f, 0.02507507f, -0.06479277f, -0.03988114f, 0.05371790f, -0.01285903f, -0.00660068f, -0.04877402f, 
    0.00493198f, 0.02453309f, -0.05821631f, 0.02130404f, 0.01832086f, -0.01933877f, -0.02385651f, -0.00904013f, 
    -0.04116126f, -0.05038428f, 0.01355453f, 0.00322767f, 0.00150644f, 0.02820976f, -0.04865976f, -0.03653841f, 
    0.01261887f, -0.00236398f, -0.05558100f, 0.00356972f, 0.03673153f, -0.03531344f, -0.05935996f, 0.01725192f, 
    0.01468124f, 0.03402225f, -0.01313784f, -0.02538199f, -0.03510378f, 0.03932732f, 0.03819729f, -0.05408489f, 
    0.01781941f, 0.02157282f, 0.01347258f, -0.04355608f, 0.03463703f, -0.04812486f, 0.01642194f, -0.04846812f, 
    0.02232622f, -0.01954508f, 0.04562386f, -0.03189141f, -0.06094699f, 0.00064873f, 0.03670621f, -0.06158011f, 
    0.05142858f, -0.05914205f, 0.03429626f, 0.03184401f, -0.03183417f, -0.02092651f, -0.05756275f, -0.03791133f, 
    0.02427110f, 0.02261916f, 0.04969423f, -0.00240237f, -0.04975219f, -0.04473057f, -0.02909642f, 0.03076206f, 
    -0.04891028f, 0.03899064f, -0.04185088f, -0.00173348f, -0.01917881f, -0.06410414f, -0.05718992f, 0.03881376f, 
    0.03409307f, -0.05683206f, 0.00982210f, -0.06115866f, 0.01613588f, -0.01321987f, -0.02821145f, -0.05928886f, 
    0.02262579f, -0.04148304f, -0.06820622f, 0.03430728f, -0.00622807f, -0.05603058f, -0.04427680f, -0.06551785f, 
    -0.01394043f, 0.01710036f, 0.02257038f, -0.02545185f, -0.03711301f, 0.02517620f, -0.03435105f, 0.02433308f, 
    -0.03167976f, -0.05154573f, -0.06551486f, 0.03255507f, -0.03041614f, -0.02351283f, -0.02928181f, 0.03723058f, 
    -0.06163112f, -0.02096306f, -0.05623560f, -0.05334621f, -0.01871936f, -0.04314881f, -0.01278699f, 0.01159084f, 
    0.04327371f, 0.03915614f, 0.04793574f, -0.03137146f, 0.01610688f, 0.01299966f, 0.01959584f, -0.02078318f, 
    -0.04610295f, 0.04807424f, 0.02286481f, -0.00246254f, -0.05040678f, 0.02070998f, 0.04429738f, 0.04126727f, 
    0.02370886f, -0.01013837f, -0.02446983f, -0.06536042f, 0.04675504f, 0.01939686f, 0.04048405f, 0.01140646f, 
    0.02486286f, -0.00154326f, 0.04845451f, -0.02916290f, -0.02866836f, -0.01754926f, -0.04300092f, 0.00122822f, 
    -0.02370481f, -0.01741263f, -0.05426658f, 0.03992433f, 0.02709361f, 0.01418708f, -0.01278056f, -0.03520283f, 
    -0.00612619f, 0.04927299f, -0.05012606f, 0.05103043f, -0.04627264f, 0.03062007f, 0.01347877f, 0.00193375f, 
    0.00504192f, -0.01758687f, -0.02274453f, -0.06104675f, 0.04910069f, -0.05942517f, -0.05939447f, 0.01923021f, 
    0.02989347f, -0.00187534f, -0.03666531f, -0.00863584f, -0.01477280f, -0.01671020f, -0.03644631f, -0.04860246f, 
    0.00747356f, 0.00721734f, -0.04301790f, -0.02458013f, -0.02082738f, -0.03547142f, -0.02115965f, -0.06462521f, 
    -0.03181556f, 0.04405108f, -0.06140864f, -0.04675194f, 0.04794480f, -0.06154403f, -0.00940196f, 0.00801565f, 
    -0.01673988f, -0.06333657f, 0.04401611f, -0.06284184f, 0.04219386f, -0.06815406f, 0.00982261f, -0.06463478f, 
    -0.00684134f, -0.05042805f, -0.01034748f, 0.04133650f, -0.02539733f, -0.02053260f, 0.03540464f, 0.02544008f, 
    -0.21752313f, -0.25993192f, -0.04687575f, -0.09020901f, -0.05786191f, 0.06630675f, 0.17521048f, 0.03988197f, 
    0.08434123f, 0.00258652f, 0.05122746f, -0.11418763f, -0.02332957f, 0.01457354f, -0.03052537f, 0.10424674f, 
    0.13930166f, 0.07732863f, 0.08173850f, 0.11386446f, -0.03179090f, -0.02597107f, -0.04780833f, -0.07151355f, 
    0.19607350f, 0.05869142f, 0.01396507f, 0.01992809f, 0.03797266f, -0.16035891f, -0.08215985f, -0.11877476f, 
    0.18333727f, -0.05579636f, -0.01586914f, -0.00315579f, 0.08191862f, -0.01141716f, 0.11548977f, 0.07518331f, 
    0.02818970f, -0.00126345f, 0.09169738f, 0.05239145f, -0.02507153f, -0.16219203f, -0.08376551f, 0.23758097f, 
    -0.08223958f, 0.00972477f, 0.09484281f, 0.13573729f, 0.05213593f, -0.00027212f, -0.40254876f, -0.19104038f, 
    -0.01923374f, 0.05676113f, 0.10161129f, 0.08960377f, 0.02796940f, 0.02405786f, -0.04737619f, -0.31154266f, 
    -0.11302128f, 0.05981283f, 0.14594184f, -0.06497245f, 0.00151763f, 0.10743695f, 0.06693116f, 0.01540678f, 
    0.22670563f, 0.11771380f, 0.08309750f, -0.06263021f, 0.01101176f, -0.03783223f, 0.06046789f, -0.02891020f, 
    0.10744669f, 0.14827189f, 0.10539965f, 0.06628449f, -0.11818036f, 0.03527950f, -0.00011325f, -0.00480055f, 
    0.08374214f, -0.00248330f, 0.03962845f, 0.04606372f, 0.11336000f, 0.09939834f, 0.05716721f, 0.08222342f, 
    -0.10578236f, -0.07719246f, -0.07675590f, 0.03601545f, 0.08939771f, -0.02420099f, 0.07463598f, -0.09831408f, 
    -0.04209343f, 0.00738211f, 0.19103187f, 0.05879693f, -0.10041755f, -0.19909815f, 0.08641759f, 0.15314795f, 
    -0.01179327f, 0.13109413f, -0.06448156f, -0.02102158f, -0.05012153f, 0.07464182f, -0.14132825f, -0.11204880f, 
    -0.04728740f, -0.01194959f, -0.09159258f, 0.00584544f, -0.06657387f, 0.01538967f, -0.04650479f, -0.08500988f, 
    -0.12675826f, -0.04228454f, -0.12511289f, -0.01388884f, 0.04344788f, 0.06713439f, 0.07548663f, -0.45662907f, 
    0.03237366f, -0.14320076f, 0.03040974f, 0.02961028f, 0.00913994f, 0.07004055f, -0.05719842f, 0.16490828f, 
    -0.15328304f, -0.11562408f, -0.03577938f, 0.14469883f, 0.03648136f, 0.00899040f, -0.01794529f, 0.02132418f, 
    -0.04957879f, -0.13184959f, -0.02961539f, -0.18394464f, -0.03488439f, -0.09403741f, 0.02268304f, 0.05577113f, 
    -0.03939710f, 0.05653503f, -0.12968329f, -0.14401722f, -0.02979499f, 0.09275223f, -0.00428063f, -0.04312096f, 
    -0.14144106f, 0.01363261f, -0.06471422f, 0.14635441f, 0.00513330f, 0.00187615f, -0.09127875f, 0.14441472f, 
    -0.13509811f, -0.08643848f, 0.10183217f, -0.06408182f, 0.00228858f, -0.19732082f, 0.06515107f, -0.01725051f, 
    0.13717847f, 0.14334394f, 0.04846291f, -0.03477584f, -0.09402102f, -0.35176510f, -0.17783570f, -0.10785618f, 
    -0.05598819f, 0.04531710f, 0.02904650f, 0.02869060f, 0.01540806f, 0.19834235f, -0.21804918f, -0.00259765f, 
    -0.12146215f, -0.12109909f, 0.00766280f, -0.05677439f, 0.06325813f, 0.16272917f, 0.08128180f, -0.03511434f, 
    0.06041935f, -0.16298950f, 0.20947669f, -0.00568709f, -0.08685130f, 0.09190544f, 0.06265915f, -0.10164637f, 
    -0.02340318f, -0.20869598f, -0.00304607f, 0.08490027f, 0.01491931f, -0.02948627f, 0.01616349f, -0.02559135f, 
    0.04537925f, 0.06836323f, -0.04050430f, -0.19879094f, 0.05298747f, 0.02495870f, 0.08189623f, 0.06550028f, 
    -0.01340547f, 0.05356005f, 0.05529934f, 0.08243430f, 0.08700959f, -0.21794224f, -0.11479064f, -0.00234394f, 
    -0.01149839f, 0.07989613f, -0.03987025f, -0.29723147f, -0.32264778f, -0.17272961f, 0.10297755f, -0.01635600f, 
    -0.04106556f, -0.02375717f, -0.06319287f, -0.06810054f, -0.02879575f, -0.17074406f, -0.12248790f, -0.05752256f, 
    0.03836622f, -0.07702270f, 0.01881133f, -0.00083385f, 0.10118802f, -0.00058635f, 0.15338677f, -0.01350950f, 
    0.13332638f, 0.01314497f, 0.16239001f, -0.08291266f, -0.00057783f, 0.03034476f, 0.20145537f, 0.04763934f, 
    -0.09022464f, -0.00797029f, -0.03411620f, -0.02261012f, 0.01126441f, 0.10429496f, 0.09239096f, 0.05134864f, 
    -0.10115646f, -0.01051859f, 0.04110704f, 0.01096025f, 0.15183085f, -0.05984399f, 0.00833709f, -0.10919274f, 
    0.04797782f, -0.01709047f, -0.06377509f, 0.00991807f, 0.02425855f, 0.02453608f, 0.01735386f, -0.00528195f, 
    -0.00502130f, -0.05977266f, -0.03530410f, -0.06210194f, 0.03858649f, -0.05790566f, -0.04642427f, -0.00657060f, 
    0.00752125f, -0.00987210f, -0.02664397f, -0.05218651f, -0.00738950f, 0.05495755f, -0.03742976f, -0.05505185f, 
    0.00544210f, -0.05242431f, 0.03322962f, -0.02281589f, 0.02270129f, -0.00056876f, 0.04553238f, -0.05215383f, 
    -0.00488540f, -0.06091229f, -0.06061406f, 0.00924522f, -0.00674432f, -0.05356543f, -0.01120390f, 0.01822800f, 
    -0.06174298f, 0.03323071f, -0.02920550f, 0.00937396f, -0.03070939f, 0.00112241f, 0.03406543f, -0.03790040f, 
    0.03508899f, -0.06167039f, 0.00617607f, 0.01002528f, 0.03387172f, -0.02873525f, 0.01654253f, 0.03383042f, 
    0.04399467f, 0.03857566f, 0.03187562f, -0.06583481f, -0.01543359f, 0.01047181f, 0.00783098f, 0.05657401f, 
    -0.02601872f, 0.00428261f, -0.00613192f, 0.01013944f, 0.03228455f, -0.04426017f, -0.03401146f, -0.05533819f, 
    -0.02466941f, 0.04735704f, -0.03117982f, 0.04428424f, -0.03219528f, -0.05743834f, -0.03971152f, 0.03971916f, 
    0.01773610f, 0.03349276f, 0.00843766f, -0.04766285f, -0.02706958f, -0.01273133f, -0.03585882f, -0.02812301f, 
    -0.02675303f, 0.00820749f, -0.04552776f, -0.03851702f, -0.00451676f, -0.06342528f, 0.04882822f, -0.03371800f, 
    -0.03995626f, 0.00125632f, -0.01850156f, -0.05818291f, 0.00312071f, -0.03327611f, -0.00920002f, 0.02110979f, 
    0.00335069f, 0.00883000f, 0.03637038f, 0.01222617f, -0.04506364f, 0.05778760f, -0.02401645f, 0.05247726f, 
    -0.02245126f, 0.05098067f, -0.06660176f, 0.03951760f, -0.03213101f, -0.05774801f, -0.04889988f, -0.06006464f, 
    -0.06657840f, -0.02993446f, 0.00539323f, -0.06015620f, 0.03670867f, -0.05593585f, -0.04241528f, -0.02586433f, 
    -0.00836637f, -0.05351981f, -0.01265843f, -0.03957396f, 0.04032904f, -0.03561161f, -0.00174630f, -0.04088365f, 
    -0.01060766f, 0.02856559f, -0.01106408f, 0.00718309f, -0.01924431f, 0.01779534f, 0.01400190f, 0.03539653f, 
    0.00330597f, 0.04308101f, 0.03878260f, -0.03516690f, -0.04382268f, -0.04666408f, -0.02343652f, 0.01800445f, 
    -0.00999896f, 0.01268978f, -0.00640537f, 0.03373683f, -0.01378708f, -0.03081991f, -0.02276067f, -0.06341304f, 
    0.01042881f, 0.02551449f, -0.00610620f, -0.04381047f, -0.06093952f, 0.04280473f, -0.00168415f, 0.01193131f, 
    -0.03782320f, -0.04311562f, -0.03843077f, -0.02777207f, -0.02275403f, 0.00176378f, 0.03935529f, 0.03411050f, 
    -0.00219684f, 0.02135995f, -0.03817079f, -0.03965428f, -0.04853937f, 0.01068507f, 0.03847056f, -0.00410173f, 
    -0.05464451f, -0.05138813f, 0.00583260f, 0.00923640f, -0.02769011f, -0.05389053f, 0.00751307f, -0.01396847f, 
    -0.01174294f, 0.01169223f, -0.03360477f, 0.00687647f, -0.00805828f, -0.01972843f, -0.02581972f, -0.00419669f, 
    -0.05806972f, -0.06441127f, 0.02279495f, 0.02675545f, 0.04868133f, 0.00306504f, 0.00131014f, 0.03050230f, 
    0.01416207f, 0.02111266f, 0.01285223f, 0.02434008f, 0.01893352f, -0.04809368f, 0.02462976f, 0.00158304f, 
    -0.05999631f, -0.00708017f, 0.00154639f, 0.04008701f, -0.06380106f, -0.05191583f, 0.03452220f, -0.05459524f, 
    -0.00740484f, -0.02966683f, -0.02547460f, 0.03510270f, 0.02601140f, -0.03855723f, -0.05170110f, 0.00821838f, 
    -0.02431356f, 0.00262055f, 0.02875266f, -0.02543750f, 0.04477348f, 0.03138324f, 0.00601859f, -0.00619523f, 
    0.05047027f, 0.00531711f, -0.04356096f, -0.00110224f, -0.01659532f, -0.02935467f, 0.03334386f, 0.02740188f, 
    -0.01965783f, -0.02495563f, 0.03060559f, 0.03801543f, -0.04529930f, 0.00113382f, -0.06539051f, 0.04008012f, 
    0.04817341f, -0.06559608f, -0.04415130f, -0.01718764f, -0.06197088f, -0.02570027f, -0.05225855f, 0.01523824f, 
    0.03841647f, -0.03124730f, -0.00048700f, -0.00490860f, -0.04448668f, 0.00358782f, 0.03912443f, 0.04868067f, 
    0.00247711f, -0.04581412f, -0.01773345f, -0.02474282f, -0.04185970f, -0.02333989f, -0.05880256f, -0.03186856f, 
    0.01185435f, 0.04892847f, 0.04131268f, -0.00579112f, 0.00957933f, -0.05453380f, 0.00694750f, -0.02265064f, 
    -0.09276704f, -0.14878774f, 0.02077688f, 0.05402086f, -0.00518749f, 0.02016872f, -0.03629690f, 0.10588117f, 
    -0.15757230f, 0.03335603f, 0.08889329f, -0.06586650f, -0.03929280f, 0.01282911f, -0.00416057f, 0.01236662f, 
    -0.10561917f, -0.06966498f, -0.28460062f, 0.07065606f, 0.07078977f, 0.07895837f, 0.06002263f, 0.11619123f, 
    0.00519481f, 0.06780360f, 0.00420536f, 0.12673217f, -0.15488079f, -0.00336166f, -0.12719885f, 0.00539864f, 
    -0.14136064f, -0.05590123f, 0.12612219f, 0.02581840f, 0.03487628f, -0.01010219f, 0.02870791f, 0.04193798f, 
    0.00945423f, 0.03304866f, 0.04213433f, 0.02107029f, -0.03921391f, 0.10508862f, 0.01964324f, 0.00858002f, 
    -0.08428423f, -0.05138412f, 0.00300288f, 0.06256383f, -0.00790784f, 0.01103402f, 0.00124564f, -0.07702824f, 
    -0.23100297f, 0.07471455f, 0.00412920f, 0.06339529f, 0.06229920f, 0.01391490f, 0.02830660f, -0.14412604f, 
    -0.00251970f, 0.01836437f, -0.10723342f, 0.02994595f, -0.02403659f, -0.15332627f, 0.02692719f, -0.01896032f, 
    -0.03944837f, -0.00038420f, 0.02031243f, 0.02236030f, 0.17419623f, -0.10296944f, 0.00517771f, 0.00455388f, 
    0.01786136f, -0.14898054f, -0.07892666f, 0.15481475f, 0.04963028f, 0.02215499f, 0.01808042f, -0.14468998f, 
    -0.01745949f, 0.09137350f, 0.26890221f, 0.02265383f, 0.01079438f, 0.22167961f, 0.11826336f, -0.00879459f, 
    0.06673373f, 0.02570488f, 0.02621276f, -0.11260910f, 0.18548663f, 0.01635654f, -0.08069370f, -0.11461399f, 
    -0.00952692f, 0.00462285f, -0.00714146f, -0.00364764f, 0.07850625f, 0.05774136f, -0.08238187f, 0.03759410f, 
    -0.08694164f, -0.01773147f, 0.02858419f, 0.08782472f, 0.04315973f, -0.02280620f, -0.01316496f, 0.11648814f, 
    -0.14659713f, -0.15417179f, -0.06462055f, 0.14150368f, 0.05792242f, 0.08234133f, 0.18210800f, 0.09696253f, 
    0.09119959f, 0.09000197f, 0.08316885f, -0.11137645f, 0.05417759f, -0.06717312f, -0.04788209f, 0.08787975f, 
    -0.01892481f, -0.08926321f, -0.01005086f, 0.14809343f, 0.21268259f, 0.12689947f, -0.08806142f, -0.15905178f, 
    0.07555614f, -0.02585585f, -0.16612852f, -0.01646005f, 0.13303714f, 0.15208314f, -0.07623506f, -0.05724316f, 
    -0.06493776f, -0.05371672f, -0.08806273f, 0.02302958f, -0.07196780f, 0.06420816f, 0.13605721f, -0.11024372f, 
    -0.04048155f, -0.12516055f, -0.12021900f, 0.03066725f, 0.04590682f, 0.14984408f, -0.10355081f, 0.10183521f, 
    -0.14247373f, -0.00134778f, 0.05633198f, -0.12296609f, 0.01827805f, 0.08870887f, -0.05542937f, -0.05382225f, 
    -0.12583365f, -0.06179025f, 0.05673190f, -0.01383565f, -0.21099681f, 0.08030165f, 0.05518699f, -0.03510315f, 
    -0.02099589f, -0.07149098f, -0.03210740f, -0.00661864f, -0.00367398f, -0.09559498f, 0.00014855f, 0.08082259f, 
    0.00171497f, 0.01823473f, 0.02711134f, 0.08870997f, 0.01920618f, -0.06085450f, -0.05449970f, 0.08390214f, 
    0.06352991f, -0.07215823f, -0.00152372f, 0.09186359f, -0.02185456f, 0.04072900f, -0.05292772f, 0.03248733f, 
    -0.01290101f, -0.05912275f, -0.05219618f, -0.03326437f, -0.03818842f, -0.00103222f, 0.16640237f, 0.00267167f, 
    -0.25204661f, 0.05852950f, 0.13289960f, -0.11969289f, 0.06304134f, 0.08252891f, 0.06678790f, -0.07726178f, 
    -0.04098212f, 0.03021838f, -0.02481561f, 0.13600323f, 0.10784873f, -0.06927504f, 0.11824612f, -0.22027658f, 
    -0.04823840f, 0.09825680f, -0.09537265f, -0.02827807f, 0.14326715f, -0.15663710f, -0.06018951f, 0.04447002f, 
    0.01424188f, 0.03325759f, 0.10087801f, -0.04614723f, 0.02331596f, -0.12079614f, 0.16324602f, 0.14954253f, 
    0.05357357f, -0.02086174f, -0.04372618f, -0.07470586f, -0.16269015f, -0.13470098f, -0.04169959f, 0.03507460f, 
    0.03483576f, -0.00242999f, 0.03291899f, 0.00124344f, -0.21322596f, 0.06842938f, -0.08983235f, -0.12224457f, 
    -0.02372294f, 0.12634526f, 0.01081368f, 0.00238605f, -0.02383638f, -0.04076365f, 0.09753201f, -0.02336508f, 
    0.16197574f, 0.20001094f, -0.13044877f, -0.17086802f, 0.06848332f, 0.04572598f, -0.05501860f, 0.11883637f, 
    -0.06288697f, 0.04169837f, -0.00489969f, 0.11533969f, 0.02614039f, -0.12023864f, 0.02961047f, 0.04115792f, 
    0.08027332f, -0.09080927f, -0.03449566f, -0.02399022f, 0.02553615f, 0.06761447f, 0.13897778f, -0.05435285f, 
    0.15316281f, 0.00623118f, 0.02347632f, -0.05387209f, -0.05749683f, 0.01597500f, -0.09370021f, 0.06348327f, 
    -0.09208005f, -0.01045521f, -0.17365636f, -0.35577583f, -0.09108775f, -0.03032074f, 0.00562358f, -0.12765877f, 
    0.13158324f, -0.05123549f, 0.05144960f, 0.06388196f, -0.02800181f, -0.11383413f, 0.10178234f, 0.02139965f, 
    0.06815606f, -0.09407800f, 0.04636986f, 0.05934391f, 0.11626496f, 0.02015455f, -0.03006783f, 0.00201086f, 
    -0.08755078f, 0.12829421f, 0.02904539f, 0.05974887f, 0.03585473f, 0.08008938f, -0.11096314f, 0.08867770f, 
    0.20555910f, -0.02361425f, 0.04937598f, -0.10546103f, -0.16386911f, -0.00982601f, -0.24807677f, 0.02013653f, 
    -0.08970480f, 0.16357626f, 0.00710076f, -0.06687871f, -0.13514911f, -0.01556905f, -0.07966541f, 0.14914049f, 
    -0.10959218f, -0.19386671f, -0.01767951f, -0.11644924f, -0.00453557f, 0.04473368f, 0.00095101f, 0.14729153f, 
    0.13630152f, 0.07257093f, 0.11808763f, 0.04644223f, -0.06537889f, 0.11864280f, 0.02264426f, -0.04912765f, 
    -0.00591322f, 0.03365239f, 0.23474050f, 0.02708467f, 0.02083651f, 0.14919735f, -0.00312171f, -0.01097469f, 
    0.07933555f, -0.00799297f, 0.20912215f, 0.06922390f, -0.13196953f, 0.00393915f, -0.02813850f, 0.01845397f, 
    -0.01958569f, -0.02479437f, -0.03076864f, 0.28909126f, -0.05148701f, -0.25715685f, 0.08243451f, 0.08638763f, 
    0.19121535f, -0.04125377f, -0.07600942f, -0.04394896f, 0.25333670f, -0.05576765f, -0.14251053f, 0.06313319f, 
    0.03424419f, 0.00549711f, 0.13865560f, 0.04563472f, -0.11785673f, 0.10681441f, 0.04813559f, 0.02397650f, 
    -0.01448625f, -0.00611438f, 0.09165370f, -0.21266642f, 0.02442456f, -0.03602612f, -0.25039127f, -0.26948565f, 
    0.00064944f, 0.04839996f, 0.13382861f, -0.00797440f, -0.04632747f, -0.09386107f, 0.01324254f, -0.07807432f, 
    0.11070488f, -0.08213037f, -0.06733178f, -0.12499849f, -0.23201980f, 0.10149102f, -0.03182610f, 0.00905824f, 
    -0.09368499f, 0.06742875f, 0.02898474f, -0.01068532f, -0.05711759f, -0.01184073f, -0.01976133f, 0.09194095f, 
    -0.08977921f, 0.02297977f, 0.02736413f, -0.17656778f, 0.04230995f, -0.00482683f, 0.09234194f, 0.00103382f, 
    0.08525546f, 0.05951362f, -0.09688137f, -0.08291400f, -0.03718413f, -0.07285126f, 0.07405191f, -0.06726051f, 
    -0.13801476f, 0.02002701f, -0.05241520f, 0.23475930f, 0.14610755f, 0.08554559f, -0.00284396f, 0.09417123f, 
    -0.03353561f, -0.04237537f, 0.03158794f, 0.03565045f, 0.14445928f, -0.19225751f, -0.06265920f, 0.06579781f, 
    0.08492590f, 0.11522592f, 0.10418979f, -0.06235769f, -0.20678978f, 0.03919941f, 0.00950949f, -0.03183262f, 
    -0.10404529f, 0.16831747f, 0.00066083f, 0.02563739f, 0.01221535f, 0.06173072f, 0.19033943f, -0.09786636f, 
    -0.13218017f, -0.01129512f, 0.10192560f, 0.09957366f, 0.04953694f, -0.13127813f, 0.03277279f, 0.02954215f, 
    0.14152788f, -0.17710572f, 0.16571768f, -0.05371851f, 0.03835157f, -0.03718073f, -0.10426372f, 0.01792752f, 
    0.21138228f, -0.02678467f, -0.04375400f, 0.05989545f, -0.15021837f, -0.02145698f, 0.09179302f, 0.08320039f, 
    0.06833231f, -0.27937454f, 0.06341444f, -0.01447474f, 0.02391540f, 0.14017928f, -0.04703584f, -0.04953222f, 
    -0.06045985f, 0.00157666f, 0.20968549f, -0.12167450f, 0.07669438f, 0.09518492f, 0.09865128f, 0.08578392f, 
    0.01423339f, -0.01719586f, 0.03531478f, 0.03398865f, -0.04850002f, -0.14723109f, -0.03612885f, -0.13624036f, 
    -0.03258528f, -0.08489273f, 0.00847261f, 0.08364330f, 0.14278890f, -0.05148291f, 0.02513430f, -0.03268563f, 
    0.02657795f, -0.18203150f, 0.11549272f, 0.00023202f, 0.17143334f, 0.22340821f, 0.06161745f, 0.01119278f, 
    0.00925101f, -0.00224933f, 0.01574818f, 0.08689806f, 0.07146674f, 0.07476704f, -0.05844120f, 0.03143105f, 
    -0.18644328f, 0.05952962f, 0.08761553f, 0.11416402f, 0.05396104f, 0.03320124f, -0.14183146f, -0.00757765f, 
    -0.09153470f, -0.00105449f, 0.06304955f, -0.03516697f, 0.05410905f, -0.14286536f, 0.04698589f, -0.00765386f, 
    0.27020824f, 0.16234273f, 0.05198484f, -0.02318101f, -0.08832671f, 0.02609023f, -0.02889835f, 0.10503442f, 
    -0.00929417f, 0.32077929f, 0.04857789f, 0.01450643f, -0.07802371f, -0.07835914f, 0.04908846f, -0.01224435f, 
    -0.05442272f, 0.09552372f, 0.07742812f, 0.19910359f, -0.08450406f, 0.07475869f, -0.02753851f, 0.01444920f, 
    -0.02853156f, 0.03899043f, 0.00356577f, -0.16881347f, -0.06107458f, 0.19618225f, -0.01414184f, 0.08843505f, 
    -0.00943758f, -0.18977347f, -0.04648062f, -0.14396024f, -0.00242972f, -0.00689655f, -0.09373900f, -0.01179028f, 
    -0.06908476f, 0.01683457f, 0.02216851f, 0.07464466f, 0.00664435f, -0.08566366f, -0.08298234f, 0.12550700f, 
    0.00462395f, -0.07361840f, -0.02778935f, -0.01995882f, 0.02505133f, 0.02882961f, -0.00130067f, 0.04987938f, 
    -0.01622166f, 0.01187498f, -0.04593729f, 0.06300777f, -0.09442265f, 0.02106866f, 0.05477433f, -0.02619152f, 
    0.16947913f, 0.12541521f, -0.02159673f, -0.05150963f, 0.06363469f, 0.01615611f, 0.08973718f, -0.18031217f, 
    -0.06652640f, 0.04962470f, -0.02094557f, 0.03943753f, -0.00856511f, 0.06171172f, 0.06026733f, 0.05840240f, 
    0.11511123f, 0.12465534f, 0.15062200f, -0.04650625f, 0.04878255f, -0.05636806f, -0.12234218f, -0.06405748f, 
    0.00571568f, -0.05049972f, -0.03499084f, -0.00044439f, -0.15656173f, 0.02388464f, 0.05288438f, 0.13640532f, 
    0.11051603f, 0.08845098f, 0.03543117f, -0.06952668f, -0.26388651f, -0.16258857f, 0.10909221f, -0.04848143f, 
    0.08409671f, -0.10293069f, -0.06101507f, -0.08182045f, 0.02095057f, 0.04355324f, -0.12615028f, 0.09905610f, 
    -0.07128336f, -0.02148142f, -0.12420160f, 0.03618935f, 0.10285131f, -0.27900165f, -0.16789840f, 0.07185955f, 
    0.07329332f, -0.15839581f, 0.08340019f, 0.00006320f, -0.00104311f, -0.07592484f, 0.11954385f, -0.08170503f, 
    -0.03400222f, 0.12520060f, 0.09627862f, 0.09144506f, 0.01023877f, -0.14765604f, 0.01258983f, -0.31175119f, 
    0.21491174f, -0.05113139f, -0.00610091f, 0.00195233f, -0.04138379f, -0.07830966f, -0.01395489f, 0.12772095f, 
    0.12639967f, 0.07062680f, -0.10446811f, -0.06324978f, -0.01692252f, -0.01819483f, 0.05684287f, 0.04169530f, 
    0.04349374f, 0.18586728f, 0.07793677f, 0.17932609f, -0.12931201f, 0.08479770f, -0.02481453f, -0.01410236f, 
    0.11303291f, -0.06475247f, 0.21539158f, -0.04300439f, -0.11181881f, -0.09220709f, -0.03324486f, -0.03049967f, 
    0.07175507f, -0.00459962f, 0.14605989f, 0.09528191f, 0.02822821f, -0.13412267f, 0.06873885f, -0.03045221f, 
    0.06510610f, 0.00796575f, -0.04619127f, -0.05863370f, 0.10495591f, 0.00561839f, -0.03466476f, 0.16319758f, 
    -0.05811872f, -0.11732221f, -0.13848211f, 0.01545850f, -0.09675945f, 0.04475484f, -0.10293066f, -0.06076334f, 
    0.04851185f, 0.06356704f, -0.00478684f, -0.05207778f, 0.05934383f, 0.02430313f, -0.12738703f, -0.11230945f, 
    -0.08274738f, 0.01356637f, 0.03576604f, 0.02431389f, -0.02031401f, -0.00163528f, -0.02808955f, -0.23479827f, 
    -0.05138671f, -0.12481461f, -0.03848453f, 0.05390184f, 0.00162485f, 0.04766751f, -0.01624203f, 0.04205696f, 
    0.11236972f, 0.01650405f, -0.08462001f, -0.02291979f, -0.05133730f, -0.12573308f, 0.11652285f, 0.01702880f, 
    0.08643476f, -0.08251078f, 0.10616475f, -0.02089342f, 0.00948717f, 0.00038666f, -0.01472336f, 0.03037181f, 
    0.03578176f, -0.06389312f, 0.04429037f, -0.18013336f, -0.00926588f, 0.16747990f, -0.04944563f, -0.09665990f, 
    -0.01195389f, 0.04470066f, -0.03881168f, -0.02867468f, 0.14359562f, -0.00594452f, 0.01052541f, -0.01717770f, 
    -0.00842860f, -0.06526519f, -0.12262847f, 0.05641094f, 0.07451069f, 0.22831133f, -0.07727490f, 0.10904081f, 
    -0.11366038f, 0.09845962f, 0.02040488f, 0.08943165f, 0.09695569f, 0.05618270f, 0.09725365f, 0.06024382f, 
    -0.08175772f, -0.04271303f, -0.02291288f, 0.05722926f, 0.09363420f, 0.04290325f, -0.03450879f, 0.04884320f, 
    -0.14739838f, -0.08148203f, -0.02122923f, -0.01972586f, -0.02089800f, 0.03938234f, -0.03538962f, -0.06067561f, 
    -0.12139315f, 0.00828470f, -0.04770463f, -0.07075235f, 0.06044638f, -0.04993181f, 0.09344600f, -0.03611306f, 
    -0.09793701f, -0.11372440f, 0.20007662f, 0.26381540f, 0.06434024f, -0.09024116f, -0.00653386f, 0.03878075f, 
    -0.09986528f, 0.03608755f, 0.04434257f, 0.21912760f, -0.06374221f, 0.00026236f, 0.06811293f, -0.01726878f, 
    0.05828008f, 0.08109172f, 0.07900488f, -0.03034417f, -0.24270949f, -0.11858279f, -0.03401554f, -0.02611796f, 
    -0.04713602f, -0.04194545f, 0.00916936f, -0.00936558f, 0.16825218f, 0.10178501f, 0.11308851f, 0.18117808f, 
    0.08693908f, -0.02786655f, -0.07034098f, -0.23042452f, -0.16168201f, -0.19625066f, -0.11944436f, 0.14642650f, 
    0.08456591f, 0.02219023f, 0.01043353f, 0.03695864f, 0.00974900f, -0.26558340f, 0.25627661f, -0.05503751f, 
    0.12766241f, -0.12691520f, 0.00152961f, 0.02452192f, -0.13072664f, 0.04962458f, 0.01563063f, 0.08102410f, 
    0.02091469f, 0.10950958f, -0.04707892f, -0.05959434f, -0.05743941f, -0.11747325f, 0.01843776f, -0.06503405f, 
    0.01239612f, -0.12076478f, 0.11432949f, 0.03031628f, 0.10718348f, -0.06633829f, -0.04289071f, 0.01333338f, 
    -0.00302642f, 0.13314638f, 0.23379774f, -0.15896592f, -0.04191365f, -0.06041910f, -0.07532271f, 0.00874946f, 
    -0.07750950f, 0.15392074f, 0.09717350f, 0.14603505f, -0.16332655f, 0.02264888f, -0.11092702f, -0.08227260f, 
    0.01446461f, -0.05393599f, 0.09327419f, -0.09249738f, -0.16665944f, 0.02141392f, 0.00894647f, 0.06694411f, 
    -0.05803071f, -0.08660740f, -0.01538445f, -0.08418467f, 0.00009108f, -0.03751405f, -0.05513611f, -0.03219059f, 
    0.11763527f, 0.02965619f, 0.03901363f, 0.14963770f, 0.05199479f, -0.13486204f, -0.06012892f, 0.08890451f, 
    -0.04469177f, -0.02996692f, -0.00508354f, -0.02319897f, 0.11977042f, -0.19508152f, 0.15999219f, -0.20926811f, 
    0.09236015f, 0.10595251f, -0.04331683f, 0.06921984f, 0.03355852f, 0.08812828f, 0.03873845f, -0.02938018f, 
    -0.22032432f, -0.03504678f, -0.05637947f, 0.03484556f, -0.04908565f, -0.01571278f, 0.13473043f, -0.00946349f, 
    0.03326993f, 0.12609729f, -0.04171345f, -0.07542523f, -0.08312128f, -0.01123804f, 0.01838004f, 0.15103021f, 
    -0.00777706f, 0.29571143f, 0.09266839f, 0.05678254f, 0.00194011f, -0.11071941f, 0.02930747f, 0.05913335f, 
    -0.12977341f, 0.02108288f, 0.05072408f, 0.06795664f, -0.05902848f, 0.04952107f, 0.06724760f, -0.00948778f, 
    -0.03920674f, -0.05496461f, 0.15055342f, 0.12656166f, 0.12576826f, 0.03191837f, -0.04765747f, -0.15106653f, 
    -0.01562842f, 0.15934245f, -0.02309003f, 0.04659583f, 0.06518086f, 0.13242690f, -0.14096928f, 0.00266723f, 
    -0.07239165f, -0.07449197f, -0.01106044f, 0.08111434f, 0.12373488f, -0.06813256f, -0.15490849f, -0.09195480f, 
    0.01854392f, 0.02116146f, 0.09694683f, 0.07099205f, -0.00795038f, -0.17073759f, -0.07170694f, -0.17752124f, 
    0.01507752f, 0.08509969f, 0.05379437f, 0.12198644f, -0.07390878f, -0.02221485f, -0.13211754f, -0.01371145f, 
    -0.13838468f, -0.02858501f, -0.01222497f, 0.07165387f, 0.16297792f, 0.01867302f, 0.00250265f, 0.00103513f, 
    0.00863790f, -0.03464193f, -0.04169313f, -0.01946940f, -0.09876785f, -0.04529638f, 0.03741386f, -0.08013885f, 
    0.10396414f, -0.04803067f, -0.20315582f, 0.02527396f, -0.11225261f, -0.06795309f, -0.05565794f, -0.03932673f, 
    0.01989876f, 0.18313774f, -0.01105848f, -0.02437501f, -0.03960677f, 0.10250985f, 0.04564662f, 0.02097032f, 
    0.05254233f, -0.14139251f, 0.02208417f, -0.05495052f, -0.11083992f, -0.03156115f, 0.05943746f, 0.11782788f, 
    0.06087399f, -0.07139794f, -0.04033205f, -0.12474672f, -0.00752058f, 0.06201022f, 0.15175545f, 0.00991983f, 
    -0.13025059f, -0.03709605f, 0.02589663f, 0.08511741f, 0.21575642f, -0.05887339f, 0.14714535f, 0.14322187f, 
    0.11507262f, -0.04196476f, 0.03927455f, -0.07623529f, 0.00028231f, 0.10245151f, 0.00234649f, 0.06906369f, 
    0.10530134f, 0.00231423f, 0.00255523f, -0.01462523f, -0.08553085f, 0.10887711f, 0.12401201f, -0.22771446f, 
    -0.05360632f, 0.05049072f, 0.09051027f, -0.01762077f, 0.11035479f, -0.02840590f, 0.11937488f, -0.07545567f, 
    -0.18645935f, -0.06413682f, 0.20604047f, 0.01490973f, 0.08439798f, 0.06209517f, -0.06381600f, 0.02536627f, 
    0.14089508f, 0.12663981f, -0.04765185f, -0.15346867f, -0.02471027f, 0.04055857f, -0.11911345f, 0.00755037f, 
    0.04897868f, 0.24112573f, -0.18282850f, 0.12239211f, -0.12090638f, -0.01279246f, -0.00524992f, 0.00690854f, 
    -0.00394743f, 0.03289453f, 0.07061500f, -0.08385520f, -0.19346637f, -0.01051975f, 0.05667353f, 0.02504859f, 
    0.06820484f, -0.06387543f, 0.08202437f, -0.13841118f, -0.00591267f, 0.19462137f, 0.04462430f, 0.04345116f, 
    0.04291634f, -0.00789853f, 0.06184745f, 0.12139243f, 0.03553064f, -0.00863719f, -0.00096088f, 0.00615605f, 
    0.09686210f, 0.09143604f, -0.14037357f, 0.12604436f, 0.05741675f, -0.36437538f, -0.09958182f, -0.19736952f, 
    -0.02064256f, -0.00077466f, -0.04429550f, -0.02945616f, 0.00242532f, 0.04190386f, -0.08517047f, 0.02812441f, 
    0.06779340f, -0.16251129f, -0.07587293f, -0.07766902f, 0.11113853f, 0.08799952f, 0.02681539f, -0.19682147f, 
    0.08054028f, 0.15517773f, 0.01259339f, -0.11292697f, 0.01922619f, 0.02431107f, 0.08515275f, 0.09648901f, 
    -0.08969540f, -0.08564531f, -0.14115770f, 0.01210589f, 0.00463397f, 0.07182654f, 0.09053061f, -0.14946219f, 
    -0.01835955f, 0.22083642f, 0.15958630f, -0.09159444f, 0.03819687f, -0.05627751f, -0.04116279f, 0.06651591f, 
    -0.10003196f, 0.00872394f, 0.01864291f, -0.09167419f, 0.14390603f, 0.01639181f, 0.04706350f, 0.00872234f, 
    0.04512756f, 0.10262130f, 0.01211265f, -0.10573383f, -0.10861447f, 0.01386385f, 0.10791714f, 0.12645769f, 
    0.04807032f, -0.11914147f, -0.07947857f, 0.01145571f, -0.03485750f, -0.03542995f, 0.04972829f, 0.10179292f, 
    -0.18651971f, 0.09062790f, 0.00107255f, -0.01902725f, -0.05370919f, -0.15334709f, 0.13200085f, -0.17805731f, 
    -0.02849098f, 0.04694743f, 0.13566914f, -0.00333587f, -0.03559983f, -0.04463016f, -0.14349517f, -0.26232198f, 
    -0.00956470f, 0.03077282f, 0.13594398f, -0.11403607f, 0.03019100f, -0.04023969f, 0.07017621f, -0.23411171f, 
    -0.08033431f, -0.14622952f, -0.01388345f, 0.02168237f, -0.09630957f, -0.06950595f, -0.04143232f, 0.03543052f, 
    0.34023762f, -0.08612885f, 0.09072176f, -0.25151914f, -0.04345371f, 0.04402268f, 0.11913292f, 0.07992505f, 
    0.08718777f, 0.05252575f, -0.08624827f, 0.26383245f, -0.07524621f, -0.09015051f, -0.09221635f, 0.02569689f, 
    0.06403012f, -0.06475100f, 0.27033973f, -0.07633470f, 0.04655806f, -0.06388260f, -0.01045472f, -0.05014509f, 
    0.11863556f, 0.18725343f, 0.00891588f, 0.10510147f, -0.12336858f, -0.10334373f, 0.07606475f, 0.01518321f, 
    -0.02274743f, -0.12257402f, 0.01840850f, -0.08214547f, 0.07111984f, -0.13692316f, -0.02346431f, 0.02008917f, 
    -0.03340563f, 0.02223814f, 0.12183422f, -0.03290293f, -0.15369618f, 0.00974839f, -0.04848897f, -0.03591315f, 
    0.09262080f, 0.03250284f, -0.03538815f, -0.00990117f, 0.09318489f, 0.09717327f, -0.24323738f, -0.07408620f, 
    0.03364271f, 0.01190281f, 0.22746386f, -0.02060365f, -0.10638447f, -0.05839886f, -0.11203162f, -0.03538163f, 
    -0.22306426f, 0.01290573f, -0.02728403f, -0.00428534f, 0.05207607f, 0.09310113f, 0.10909693f, 0.04906458f, 
    -0.02872235f, 0.00174518f, -0.10083881f, -0.08646428f, -0.15853035f, -0.08045989f, 0.08432304f, 0.04947611f, 
    0.05437222f, -0.03297880f, 0.00895598f, -0.03512198f, -0.03462552f, 0.03904691f, -0.06355281f, 0.12514870f, 
    -0.01452673f, 0.03946254f, -0.07086775f, -0.09139146f, -0.24737523f, 0.15993634f, 0.12887725f, 0.04205212f, 
    0.00707609f, -0.08739060f, -0.16910993f, 0.01639402f, -0.03205448f, 0.14389300f, -0.14696313f, 0.04065415f, 
    -0.09543967f, -0.07382192f, 0.17112793f, -0.12260719f, 0.10050917f, 0.09314869f, 0.02843867f, -0.08402042f, 
    -0.00051171f, 0.00766913f, -0.03118084f, 0.05624159f, 0.00896093f, -0.13985382f, 0.05198049f, 0.01393055f, 
    -0.09419765f, 0.00675132f, 0.02040094f, 0.07492702f, 0.13407613f, -0.02015082f, -0.03836866f, 0.06406298f, 
    0.10133060f, -0.07325770f, -0.02748232f, 0.09394310f, -0.10428058f, 0.07727597f, -0.06357053f, -0.05942577f, 
    -0.09011418f, 0.04440590f, 0.11894412f, -0.09318017f, 0.03740024f, 0.00837564f, 0.03969385f, 0.17255795f, 
    0.05091880f, 0.07951922f, 0.08546333f, -0.17328615f, 0.05293828f, 0.00961678f, 0.08546287f, 0.04093908f, 
    -0.01229745f, 0.05927005f, -0.12107557f, 0.06227812f, -0.12227155f, 0.09907122f, 0.11359682f, 0.11750845f, 
    0.00265577f, -0.09921581f, -0.05333358f, -0.08061608f, -0.05272592f, 0.05059398f, 0.16519375f, 0.11713210f, 
    -0.14353429f, 0.01772961f, -0.23997688f, -0.04100421f, -0.11558236f, 0.05361338f, -0.03219115f, -0.02531562f, 
    -0.09695248f, -0.03642197f, -0.01363578f, 0.02956918f, 0.08330151f, 0.06264245f, 0.20907959f, 0.00947936f, 
    -0.01431315f, -0.03808213f, 0.17786978f, 0.09061141f, 0.06318387f, -0.02874269f, 0.10261288f, 0.14029589f, 
    0.12173582f, -0.15222463f, -0.21895491f, 0.04736776f, -0.04079089f, 0.02929988f, 0.09046633f, 0.01348748f, 
    -0.15112418f, -0.08743306f, -0.11956452f, 0.02852880f, -0.00186275f, -0.05742548f, -0.02390900f, -0.11639965f, 
    0.03159047f, 0.08508325f, 0.03121055f, 0.00836718f, 0.01514648f, -0.00396061f, 0.05787593f, -0.18405329f, 
    -0.19348858f, -0.05640199f, 0.12110233f, 0.12460631f, -0.01585924f, 0.02699338f, 0.10376615f, -0.09816419f, 
    -0.00307099f, -0.04954270f, -0.02359310f, -0.12867832f, 0.15462714f, 0.07515392f, -0.05539289f, 0.11516934f, 
    -0.04959205f, 0.09995004f, 0.16399530f, 0.14488143f, 0.00622209f, -0.23345339f, -0.15121473f, -0.08164369f, 
    0.18283679f, 0.14325820f, 0.14007609f, -0.18829428f, -0.00876197f, -0.01406001f, 0.10865524f, -0.01283737f, 
    -0.00554565f, 0.01199998f, 0.03742263f, -0.07213821f, 0.11325190f, 0.13201730f, 0.08101984f, -0.16840531f, 
    -0.11136397f, 0.07158425f, -0.00612676f, 0.01550309f, -0.08657578f, -0.06144329f, 0.19822347f, 0.06806674f, 
    0.13003644f, 0.08209722f, 0.02662449f, 0.11451086f, -0.00586970f, 0.00929667f, -0.06571972f, 0.05759181f, 
    -0.09175323f, -0.03933614f, 0.07907302f, 0.04650916f, 0.00435364f, -0.07961889f, -0.03659467f, -0.20537789f, 
    -0.03427424f, -0.14810275f, -0.20615390f, 0.05291949f, -0.01953925f, -0.03584900f, -0.13587631f, -0.31473511f, 
    0.28990141f, -0.24901144f, -0.04275291f, 0.04020641f, 0.08490364f, 0.16307649f, 0.03197915f, -0.06593547f, 
    -0.03619518f, -0.01635442f, 0.02565982f, -0.04353591f, 0.00866948f, 0.09792010f, -0.03737202f, -0.07201127f, 
    0.00111744f, 0.09569451f, 0.13339143f, -0.09771703f, 0.06365064f, -0.00351606f, -0.00124204f, 0.04221745f, 
    -0.06898393f, 0.01006007f, 0.07494371f, -0.04909098f, -0.00338151f, -0.01270714f, 0.12746692f, 0.10901740f, 
    0.03765821f, -0.06598508f, -0.03917999f, 0.06915827f, -0.02484678f, -0.18895537f, -0.14172322f, 0.06431091f, 
    -0.10799278f, 0.12088218f, -0.10919348f, 0.00440296f, 0.03544969f, 0.13300420f, -0.10612729f, -0.30678892f, 
    0.03953884f, -0.09299437f, 0.03251387f, -0.02998880f, 0.05858243f, -0.05844026f, -0.18244594f, -0.08165416f, 
    -0.00272713f, 0.06517569f, 0.03449639f, 0.11990832f, -0.08377901f, -0.06766459f, 0.04736451f, -0.05280541f, 
    -0.10559728f, 0.09646737f, 0.05666015f, 0.02435159f, 0.02136263f, 0.15326504f, -0.02847072f, 0.01189698f, 
    0.04003188f, -0.12393130f, 0.16673420f, -0.06601971f, -0.02904147f, 0.01445562f, 0.04009790f, -0.04636648f, 
    0.03652300f, -0.23339123f, 0.13698545f, -0.06992208f, 0.14455970f, 0.12293167f, 0.07181446f, -0.11353379f, 
    -0.02052105f, -0.07818679f, -0.15330006f, -0.00150359f, 0.06211976f, 0.08453894f, 0.13510159f, 0.00666245f, 
    0.06741467f, -0.08967515f, 0.03340539f, -0.04654733f, 0.18752995f, 0.19494319f, 0.04037753f, 0.10158063f, 
    0.03622409f, 0.05720040f, 0.04590079f, -0.10762510f, 0.14221428f, 0.06962848f, -0.15942878f, -0.25967345f, 
    -0.13139482f, -0.05985074f, 0.05928859f, -0.01881503f, -0.09906185f, 0.01007880f, 0.05276389f, 0.22023460f, 
    -0.02354853f, -0.05804273f, -0.01806992f, 0.04687374f, -0.00953354f, -0.15970786f, 0.02659262f, 0.11358683f, 
    -0.02114083f, -0.04044236f, 0.03097453f, -0.07905935f, 0.09938489f, -0.09413544f, 0.05377598f, -0.02909770f, 
    0.06652007f, -0.01473891f, 0.01071267f, 0.08024150f, -0.07590138f, 0.01716021f, 0.15746738f, 0.22665688f, 
    -0.11325556f, 0.13987644f, 0.10437381f, -0.03649951f, 0.10466421f, 0.04618406f, -0.05334745f, 0.08792115f, 
    -0.04388350f, 0.12782457f, -0.16742139f, -0.00961797f, -0.00269269f, 0.11486507f, 0.10509776f, -0.05588746f, 
    -0.01189798f, -0.03599676f, -0.05193221f, -0.16894659f, 0.04482452f, 0.06744932f, -0.04841079f, -0.00419533f, 
    0.02007364f, -0.13292649f, -0.01592786f, -0.25443250f, -0.25707912f, -0.01552614f, -0.07877301f, 0.04553893f, 
    -0.17955999f, 0.00928429f, 0.05329128f, 0.07228064f, 0.03056864f, 0.08743346f, 0.03995288f, 0.00953475f, 
    0.05925712f, -0.01554822f, 0.00666466f, 0.08012981f, 0.13573565f, -0.07742128f, -0.28800717f, -0.15736425f, 
    -0.02649673f, -0.19280227f, -0.19727612f, -0.14242613f, -0.05616524f, 0.02576608f, -0.12364844f, 0.01492286f, 
    -0.05950786f, 0.11242712f, 0.05473869f, 0.01935420f, 0.02000624f, 0.09192701f, 0.21282567f, -0.18801869f, 
    -0.03710007f, 0.25994992f, 0.01628631f, 0.03976710f, -0.13893445f, 0.04343946f, -0.00059611f, 0.11124220f, 
    -0.25119480f, -0.15604867f, -0.14981668f, 0.02862919f, 0.03393054f, 0.07177141f, 0.02755721f, 0.02811631f, 
    -0.09564437f, -0.00275931f, -0.14506641f, -0.18506257f, 0.00915818f, -0.00732255f, 0.00458178f, 0.08394815f, 
    -0.00667038f, -0.05338821f, -0.09940073f, 0.12176263f, 0.12332841f, -0.03202010f, 0.03838352f, 0.00667890f, 
    0.06896966f, 0.05673756f, 0.05136086f, -0.03417122f, -0.02533566f, -0.33021107f, 0.01521514f, 0.00217938f, 
    -0.03468923f, -0.02615824f, 0.03846975f, 0.01142563f, -0.08943520f, 0.24982214f, 0.28371239f, 0.10902020f, 
    0.08187532f, 0.11473792f, 0.02208496f, -0.02356348f, 0.00186651f, -0.06822877f, 0.12845191f, -0.33370924f, 
    0.03757329f, -0.05325232f, -0.05363173f, 0.08119317f, 0.02890586f, -0.01112280f, -0.30241296f, -0.00665905f, 
    0.19429050f, -0.11860044f, 0.07708262f, -0.08223234f, 0.05254412f, -0.03311195f, -0.10487276f, 0.30881763f, 
    -0.43898526f, 0.01005490f, -0.03903515f, -0.05710870f, 0.04412905f, 0.00859423f, -0.09025295f, -0.08660612f, 
    0.00988613f, 0.06852856f, 0.06804745f, 0.16381899f, 0.10763370f, 0.04613563f, 0.13708735f, -0.21163769f, 
    0.09824923f, 0.18772922f, -0.14454684f, -0.30365935f, -0.05653327f, 0.01585979f, -0.08926066f, -0.12906753f, 
    -0.03256027f, -0.09373606f, 0.04703250f, 0.01775661f, 0.02267232f, 0.03014234f, 0.05109151f, -0.04838601f, 
    0.06082337f, -0.03212504f, 0.08663316f, -0.18433045f, -0.20380029f, -0.04344709f, 0.13580824f, 0.04874729f, 
    -0.04854426f, 0.04080598f, -0.03413090f, 0.09184822f, -0.37478420f, -0.19423278f, -0.02868068f, -0.01532386f, 
    -0.16988696f, 0.12077143f, 0.05000718f, -0.05247783f, 0.04538914f, 0.16846859f, 0.06054119f, -0.22143245f, 
    -0.11415000f, 0.06219526f, -0.08069009f, 0.04116006f, 0.02816706f, 0.02739207f, -0.03860592f, 0.05073701f, 
    -0.32783973f, 0.10044064f, -0.01365210f, 0.02964221f, -0.06987444f, 0.00732497f, -0.04517689f, -0.23683593f, 
    0.07340349f, -0.11421660f, 0.06238355f, 0.05405372f, 0.05777199f, 0.02656084f, -0.09240468f, 0.07486516f, 
    -0.06333355f, 0.16943273f, -0.02488427f, -0.03496493f, 0.11336941f, -0.08746647f, 0.15303747f, 0.11113602f, 
    0.08276527f, -0.10846040f, -0.06217091f, 0.16981722f, -0.07624748f, 0.08830047f, -0.08734001f, -0.02995365f, 
    -0.00408750f, -0.03739543f, -0.15240656f, 0.00252678f, -0.03903935f, 0.08371817f, -0.03110829f, -0.07984710f, 
    -0.00837207f, -0.04392277f, -0.08775209f, -0.05809524f, 0.16991310f, 0.21097879f, 0.26647940f, 0.21286876f, 
    0.11077425f, 0.14560290f, 0.03524956f, -0.05586777f, 0.08914486f, 0.11472546f, 0.30894408f, 0.10881053f, 
    0.08316702f, -0.04907226f, 0.03453658f, 0.10683303f, -0.04660936f, -0.11758813f, 0.18871950f, 0.07385737f, 
    0.05870642f, 0.04380837f, -0.04282765f, 0.07188249f, 0.03800764f, 0.02927139f, 0.07423473f, -0.03675006f, 
    0.00499878f, 0.01029321f, 0.16092540f, 0.02605847f, 0.00721583f, 0.05754518f, 0.09950426f, -0.01313186f, 
    0.03779314f, 0.03396820f, -0.03055576f, 0.09547475f, 0.01086253f, 0.01653920f, 0.20897466f, 0.09638104f, 
    0.00812305f, -0.00793084f, -0.03143177f, 0.03765963f, 0.00878171f, -0.03134334f, -0.06057442f, -0.02943401f, 
    -0.00741110f, -0.04977837f, -0.02533128f, 0.00622626f, -0.06026025f, 0.02990662f, 0.05207355f, 0.03797925f, 
    -0.04621444f, -0.02448250f, 0.00147243f, -0.02698185f, 0.04135732f, 0.02974290f, -0.01520060f, -0.01992680f, 
    0.05186922f, -0.04342058f, -0.05735775f, 0.05072300f, 0.04604655f, 0.00898006f, -0.06332572f, -0.04905998f, 
    -0.01710963f, -0.02043502f, -0.04897603f, -0.03923514f, -0.00197506f, 0.02630895f, 0.00139445f, 0.02238609f, 
    -0.00264404f, -0.00150436f, 0.02259521f, -0.00246142f, 0.02749786f, 0.05211340f, -0.01457743f, -0.01566715f, 
    -0.04047167f, -0.03563806f, 0.01870879f, -0.06157629f, -0.03016753f, 0.05225827f, -0.04145891f, 0.04968159f, 
    0.01242670f, 0.02287363f, 0.02986149f, 0.00849091f, -0.00738530f, -0.04038291f, -0.02704419f, -0.04333608f, 
    -0.04946992f, 0.02683235f, 0.03029341f, -0.00136183f, -0.00508790f, -0.04215107f, -0.04772327f, 0.02364565f, 
    -0.03887476f, -0.01892390f, 0.00207943f, -0.03279101f, 0.02897910f, -0.03114315f, 0.01797668f, -0.02390905f, 
    -0.05350854f, -0.00387057f, 0.04718192f, -0.02041882f, -0.03786359f, 0.01172360f, 0.04824677f, 0.01766271f, 
    0.03444465f, -0.04831461f, 0.04613409f, 0.04419098f, -0.05698484f, 0.01341335f, -0.06406803f, 0.03573172f, 
    0.00315123f, -0.01764097f, -0.03229172f, -0.03845444f, 0.01162346f, 0.01648077f, -0.05148105f, -0.03627409f, 
    0.02760319f, -0.04412409f, -0.05621479f, 0.01795877f, 0.04606875f, 0.01336113f, 0.03075322f, 0.03121705f, 
    0.01682427f, -0.00839588f, -0.04478404f, -0.00303092f, -0.05549605f, -0.05145758f, -0.04564983f, -0.02607378f, 
    0.02802130f, -0.06265488f, -0.00622325f, -0.00326318f, 0.02163869f, -0.02935160f, -0.05093193f, 0.06128581f, 
    0.04789887f, 0.05201422f, 0.01261373f, -0.01414222f, -0.06214153f, 0.01738974f, 0.02514264f, 0.01952861f, 
    -0.03816744f, -0.02795670f, -0.01584202f, 0.00568080f, -0.06474958f, 0.01106372f, -0.02212785f, 0.00280001f, 
    0.05054353f, 0.03576516f, -0.04836106f, 0.01316899f, 0.01843731f, 0.02709519f, -0.00655676f, -0.04393609f, 
    0.01861526f, -0.05458279f, -0.03240516f, 0.02205600f, 0.00000370f, -0.05182178f, 0.01254481f, -0.03461586f, 
    0.00756815f, -0.03718172f, 0.06051126f, 0.01302589f, 0.00069259f, -0.04551579f, 0.02179482f, -0.04184438f, 
    -0.04607776f, -0.04195185f, 0.03630929f, -0.04267063f, -0.06460177f, 0.04250233f, -0.06320505f, -0.02084449f, 
    0.01728467f, -0.06380071f, -0.01443792f, -0.06325030f, 0.01110866f, 0.01321220f, 0.03423567f, 0.01986864f, 
    -0.06174910f, 0.03571085f, 0.00692171f, -0.03788641f, 0.01514516f, 0.03002219f, 0.03261544f, 0.03352113f, 
    -0.03609313f, -0.04345422f, 0.01219182f, -0.00107569f, -0.03123483f, 0.00385975f, 0.05057325f, -0.06277519f, 
    0.04647857f, -0.04680447f, -0.01119474f, -0.05413327f, -0.03488703f, 0.03467115f, -0.05461850f, -0.04644804f, 
    -0.02120657f, -0.00850213f, 0.03394894f, -0.05702719f, -0.05703570f, -0.03370756f, -0.05153589f, -0.00137457f, 
    0.03140398f, -0.00879648f, 0.00284447f, -0.02248902f, -0.06115120f, 0.04609270f, -0.04469453f, -0.05011076f, 
    -0.05840532f, -0.06289352f, 0.04064201f, -0.02057815f, -0.01144058f, -0.03159975f, 0.03752466f, 0.02829618f, 
    -0.05005225f, 0.00548990f, 0.04319194f, -0.03801639f, 0.02824142f, -0.01660103f, -0.04784303f, 0.03616683f, 
    0.05054184f, -0.04984628f, 0.01303192f, -0.01293612f, 0.00052017f, -0.00090870f, 0.03878845f, -0.03680486f, 
    -0.03727073f, 0.02482145f, -0.03617863f, -0.02596953f, -0.05909615f, -0.01498132f, -0.02915626f, 0.02069249f, 
    -0.04564106f, -0.04818175f, 0.01280256f, 0.03269316f, -0.03931436f, 0.01679183f, -0.01993362f, 0.05090323f, 
    0.02867678f, 0.00526171f, 0.00511329f, -0.00240491f, 0.01051608f, -0.05327972f, -0.04420611f, -0.01226258f, 
    -0.04469705f, 0.02137004f, -0.00432747f, 0.00511977f, -0.02366312f, 0.00691688f, 0.01658586f, 0.00062328f, 
    -0.00489308f, -0.04131127f, 0.02767306f, -0.02517107f, 0.04789555f, 0.02929831f, -0.04622925f, 0.03347379f, 
    0.10047845f, 0.06340183f, -0.16059810f, 0.14802070f, 0.22636041f, 0.16508655f, -0.01159257f, 0.02000440f, 
    -0.10777523f, 0.24899185f, 0.01378615f, -0.03862069f, -0.11072850f, 0.08339388f, 0.18259576f, 0.09280928f, 
    0.07782665f, 0.08607028f, 0.15532039f, 0.03823017f, -0.03095040f, 0.02421965f, -0.00418115f, 0.08759087f, 
    -0.11467478f, 0.15266232f, 0.03531405f, 0.11580630f, -0.03113465f, 0.16579652f, 0.18884747f, -0.15738945f, 
    -0.04863774f, -0.09936334f, 0.04187510f, -0.14359273f, -0.02116713f, 0.11616389f, 0.06867957f, 0.04589632f, 
    0.04780202f, 0.02972876f, 0.01514662f, 0.06190038f, 0.05810052f, -0.02197204f, -0.27544972f, -0.16447894f, 
    -0.08208302f, 0.05899447f, -0.02741058f, -0.12269108f, -0.04012081f, -0.04946847f, -0.12170590f, -0.05801527f, 
    -0.01513367f, 0.15797324f, 0.06944069f, 0.14241003f, 0.03263927f, -0.02609518f, -0.02143122f, 0.19298668f, 
    -0.05030643f, -0.06930456f, 0.01088976f, -0.04667275f, -0.04079014f, -0.04312653f, 0.15558231f, 0.07639302f, 
    0.14881767f, 0.02000252f, -0.00620221f, -0.01673670f, 0.01103023f, 0.01324883f, -0.11225417f, -0.03627279f, 
    -0.03317666f, 0.04199423f, 0.08639990f, -0.02136871f, 0.00977396f, 0.00613932f, -0.02087351f, -0.14225401f, 
    -0.00262977f, 0.11466884f, -0.09638201f, 0.06802771f, 0.01830538f, 0.02417993f, 0.06868958f, -0.07376603f, 
    0.00999677f, -0.03636682f, -0.06164998f, 0.20665088f, 0.01859983f, 0.00708137f, 0.07903246f, -0.11039913f, 
    -0.04952112f, -0.06229016f, -0.04778057f, -0.06573403f, 0.02941677f, 0.10180773f, -0.07273106f, 0.15490136f, 
    0.12555093f, -0.07667133f, 0.00091053f, 0.01877612f, 0.01388457f, -0.01057868f, -0.07542188f, -0.01468755f, 
    0.00556156f, 0.02904177f, -0.03391676f, 0.08297729f, 0.03488917f, 0.02694837f, 0.13094309f, -0.04525230f, 
    0.06062124f, -0.04043042f, -0.19753693f, 0.03463509f, 0.04410869f, -0.14814681f, 0.08615990f, 0.25678930f, 
    0.13028158f, -0.20231102f, -0.07903782f, -0.02721061f, 0.02055090f, 0.00113063f, -0.15149926f, 0.22032680f, 
    0.03032823f, -0.01821802f, -0.02079822f, 0.07464896f, 0.10858107f, 0.00515696f, 0.11268312f, 0.03196088f, 
    -0.04004694f, 0.20260598f, -0.03439609f, 0.09557080f, -0.01951916f, -0.12531197f, 0.17267148f, -0.09979178f, 
    0.07434704f, 0.08793674f, 0.26275849f, 0.05670780f, 0.02448713f, 0.01162905f, -0.01772515f, 0.04430114f, 
    -0.06002884f, 0.06179278f, -0.00250160f, 0.08021900f, 0.04812663f, 0.05895977f, -0.05506350f, 0.04152889f, 
    0.06166211f, -0.14810841f, -0.01838612f, -0.07873689f, -0.05113677f, 0.08234809f, -0.02237219f, 0.09044597f, 
    -0.16148160f, -0.11880220f, -0.09651960f, 0.06974179f, 0.05693521f, -0.10378393f, -0.11787809f, -0.10035043f, 
    0.08192563f, -0.08800600f, 0.11084531f, 0.07741939f, 0.00818596f, 0.13768081f, 0.01836952f, -0.08802789f, 
    -0.23519196f, 0.15569149f, -0.10510369f, 0.08160738f, -0.08213574f, -0.08522184f, 0.01895528f, 0.00299430f, 
    0.00199488f, 0.03845439f, 0.01290969f, -0.00223111f, -0.05590941f, 0.04028079f, 0.01526199f, 0.09371197f, 
    0.00694092f, 0.01979998f, -0.03784437f, -0.08015192f, 0.02642687f, 0.06590699f, -0.00989673f, 0.08428135f, 
    0.01090166f, 0.01605183f, 0.00066077f, 0.03648143f, 0.12994280f, -0.11850728f, -0.06741864f, -0.19012237f, 
    0.05429210f, 0.05568606f, -0.15143016f, -0.03070467f, -0.03024361f, -0.01713261f, 0.02963752f, -0.04781982f, 
    -0.00700034f, 0.01583550f, 0.04300112f, -0.04600986f, -0.08998934f, -0.15336122f, 0.25808886f, 0.10637339f, 
    0.11760331f, -0.03906624f, -0.11813543f, -0.03223750f, -0.05915555f, 0.04932597f, -0.01776411f, 0.16595522f, 
    0.21066184f, -0.04593375f, -0.03111229f, -0.06447788f, 0.00620053f, 0.01631066f, 0.10765009f, 0.08827357f, 
    0.11140136f, 0.20060593f, 0.04136108f, 0.12725185f, 0.05163834f, -0.02603216f, 0.03715406f, 0.30438623f, 
    0.08060075f, 0.09224311f, -0.07393628f, -0.10124034f, -0.01433014f, -0.12676920f, -0.05665290f, 0.04087664f, 
    0.17069508f, 0.10407808f, 0.07639038f, 0.05117029f, -0.00455373f, -0.08149121f, -0.04327284f, 0.11968290f, 
    -0.30415586f, -0.31083590f, 0.17632967f, -0.01572204f, 0.01388820f, -0.02403204f, 0.09555667f, -0.15377828f, 
    0.04183942f, -0.14377183f, 0.09161772f, 0.06181975f, -0.01255862f, 0.06283947f, -0.00692821f, 0.09222324f, 
    -0.01137655f, -0.08098489f, 0.15076724f, 0.07112219f, -0.00388893f, 0.01828016f, 0.04118090f, -0.01632095f, 
    -0.04375070f, -0.15570213f, 0.02492088f, 0.27231517f, -0.04893817f, -0.20567252f, 0.00529148f, -0.01686873f, 
    -0.01566834f, -0.07350154f, -0.03262851f, 0.02230159f, 0.08613191f, -0.11664657f, 0.01853684f, 0.00980679f, 
    0.01396533f, 0.11111536f, 0.03484355f, -0.01080404f, -0.14515528f, 0.05622701f, 0.03586968f, -0.03329438f, 
    0.02779757f, -0.06705980f, 0.06510146f, 0.07621349f, 0.02545551f, 0.06281559f, -0.06899085f, -0.06031546f, 
    -0.07713597f, -0.02068307f, 0.03540995f, 0.00086093f, 0.03354214f, 0.02559743f, 0.05312445f, -0.04393923f, 
    0.05763550f, -0.09358047f, -0.12403640f, -0.04393364f, -0.10948196f, -0.06405815f, 0.01432275f, 0.04037724f, 
    0.16904449f, 0.12684026f, 0.13196242f, -0.04213907f, 0.00740097f, -0.07489920f, 0.01069732f, 0.08127036f, 
    0.02846905f, 0.22144006f, 0.11748050f, 0.14710009f, 0.02805541f, 0.13987465f, -0.09883972f, 0.01988813f, 
    0.13923222f, -0.01915940f, -0.18829180f, -0.16422716f, 0.15468583f, 0.04355527f, 0.18292946f, 0.09533962f, 
    -0.00976419f, -0.04556482f, -0.04493729f, -0.03424231f, 0.15316938f, -0.03100083f, -0.07659420f, 0.09145502f, 
    0.01292999f, 0.03052802f, 0.05121079f, -0.05160266f, -0.34824309f, -0.21093836f, 0.08962464f, 0.11360712f, 
    0.08989940f, 0.07993511f, -0.07064264f, -0.05234838f, -0.08809060f, 0.10612026f, 0.13609822f, -0.08710860f, 
    0.02689053f, -0.04189281f, -0.00344798f, 0.01487695f, 0.00376729f, -0.06064124f, 0.29160601f, 0.08548494f, 
    -0.02972874f, -0.29242909f, -0.09093574f, -0.02353530f, 0.00753583f, 0.13438049f, -0.01175568f, -0.06296129f, 
    0.12790920f, -0.07512344f, 0.15423495f, -0.00748009f, -0.06143222f, 0.05620559f, -0.10294855f, 0.03188922f, 
    -0.12427191f, -0.03054087f, -0.00147031f, 0.20697069f, 0.13833006f, -0.02258609f, -0.13209099f, 0.06146544f, 
    0.06331870f, -0.02461732f, 0.04396680f, 0.04252491f, -0.05103027f, 0.03692577f, -0.00439047f, -0.08755269f, 
    -0.00303839f, 0.09187400f, -0.11890207f, -0.10521247f, -0.03575076f, -0.01699641f, 0.05852073f, -0.09264968f, 
    -0.07864738f, 0.05959631f, -0.01908934f, 0.16398042f, 0.10123498f, -0.09296874f, 0.10967452f, -0.07501378f, 
    -0.03327024f, 0.09137686f, 0.08055687f, 0.02691410f, 0.11421935f, -0.01059579f, -0.04191602f, 0.17963390f, 
    -0.17562060f, 0.00227961f, -0.15148571f, -0.03288244f, -0.19047676f, -0.03421913f, 0.15606862f, -0.06863852f, 
    -0.05464376f, 0.13190244f, 0.02526691f, -0.08566865f, 0.04261560f, 0.08812071f, -0.08281333f, 0.10471455f, 
    0.06289975f, -0.00701925f, -0.08150570f, -0.13436890f, -0.04436710f, -0.02262817f, -0.12469146f, -0.05960770f, 
    0.08495659f, 0.04075118f, -0.16691676f, -0.08827584f, -0.05678313f, 0.04446981f, -0.06966405f, 0.05239642f, 
    0.06349259f, -0.19717987f, -0.03995628f, -0.05711639f, -0.00591777f, -0.08173884f, 0.07971732f, -0.03034910f, 
    -0.02217915f, 0.25984642f, 0.17228051f, 0.01357107f, -0.08034712f, -0.02708412f, 0.03761846f, 0.15389967f, 
    0.01823590f, -0.02210174f, 0.06652838f, 0.20375481f, -0.01309826f, 0.05924431f, 0.04027718f, 0.01537831f, 
    0.11123333f, 0.05000659f, -0.10432661f, -0.00784867f, -0.16375233f, 0.06971216f, 0.07095328f, 0.02933414f, 
    0.08997718f, -0.08739217f, -0.10997260f, -0.02800610f, -0.34150985f, -0.07518096f, -0.06910034f, 0.21368358f, 
    -0.01224928f, 0.04795682f, -0.09627409f, -0.07255655f, -0.07517745f, 0.03698703f, -0.06704678f, -0.07634395f, 
    0.04525793f, -0.03253163f, 0.07083301f, 0.00967242f, -0.12412159f, -0.04352868f, 0.24649964f, -0.06527661f, 
    -0.02989846f, -0.01460240f, 0.00125732f, -0.02936697f, 0.06981941f, 0.03424445f, 0.00540326f, 0.00493318f, 
    -0.13531078f, -0.00745816f, 0.01015680f, -0.03251264f, -0.06636462f, -0.04451064f, 0.00055815f, -0.04460207f, 
    -0.16597685f, 0.00067198f, 0.08845562f, -0.10864077f, 0.00086057f, -0.05825434f, -0.04425995f, 0.07400032f, 
    -0.06266874f, -0.06153893f, -0.09585994f, 0.00977833f, 0.02677785f, 0.00481023f, 0.15830526f, 0.03137073f, 
    0.05891575f, 0.08302576f, 0.03820643f, 0.04644496f, -0.13560233f, 0.14762560f, 0.08431678f, -0.08616079f, 
    0.16672489f, 0.04507967f, 0.03720066f, -0.03378557f, 0.16832012f, 0.13840818f, -0.21057157f, 0.05571495f, 
    -0.04868753f, 0.06392698f, 0.07565820f, 0.00129360f, 0.06888513f, 0.00631450f, 0.07148527f, -0.06258038f, 
    0.01053388f, 0.05331263f, -0.01473493f, 0.00933013f, 0.17690697f, 0.07160316f, -0.25131181f, -0.10688633f, 
    -0.08972567f, -0.14222352f, -0.08541778f, 0.08857047f, 0.02653308f, -0.04073048f, 0.05099226f, -0.00359357f, 
    0.02529696f, -0.20216696f, 0.13767922f, 0.10051470f, 0.12713107f, 0.02835990f, -0.00721380f, 0.07370932f, 
    0.10922097f, -0.10560439f, -0.03580431f, -0.02686633f, -0.15353835f, 0.06446323f, -0.01891119f, -0.10016055f, 
    -0.27014011f, 0.02038401f, -0.20486610f, 0.12589613f, 0.07597681f, -0.05341067f, 0.06604619f, 0.08452478f, 
    0.08145359f, 0.05071580f, 0.25250950f, 0.00519478f, 0.16352187f, 0.08289538f, 0.15506235f, 0.12452849f, 
    0.03528184f, 0.04615280f, 0.00581130f, -0.00651598f, 0.16321173f, -0.01533077f, 0.10506077f, -0.03840490f, 
    -0.04251389f, 0.08408257f, 0.13559827f, -0.06101222f, -0.16638172f, 0.14129396f, -0.05682274f, 0.03100069f, 
    0.03718639f, 0.00522005f, 0.03237350f, 0.08327329f, -0.20934244f, 0.05611448f, 0.11904065f, -0.08022522f, 
    -0.00783182f, -0.00465759f, -0.10833312f, -0.02455876f, 0.02258356f, 0.08091792f, 0.06076091f, 0.05378623f, 
    -0.01926293f, 0.00676559f, 0.08381119f, 0.18446934f, 0.19455437f, -0.07106112f, -0.19083343f, 0.01362240f, 
    -0.01125839f, 0.13053331f, 0.08029833f, -0.18909939f, -0.02276792f, 0.05987029f, -0.10672589f, -0.15603346f, 
    -0.20318428f, -0.00298547f, 0.25824550f, -0.00350413f, -0.03137815f, -0.10908168f, 0.09941734f, -0.06730209f, 
    -0.12096404f, -0.09949526f, -0.14234444f, -0.04630221f, 0.03430474f, 0.07609060f, 0.03969455f, 0.03035978f, 
    0.16343383f, 0.11366738f, 0.13005503f, -0.17691919f, -0.01613910f, 0.04891906f, 0.07618459f, 0.00557144f, 
    -0.10237794f, 0.01124205f, 0.09348539f, 0.16318014f, 0.08430418f, 0.07901209f, 0.01586660f, 0.13871245f, 
    0.23176917f, 0.01292995f, 0.13178930f, 0.00061485f, 0.05176046f, -0.13643764f, 0.17829908f, 0.13981017f, 
    0.07033610f, -0.01108473f, -0.08193369f, 0.11543475f, -0.20692858f, 0.06625900f, -0.02555610f, 0.03266553f, 
    -0.06227928f, 0.14824788f, 0.00775692f, -0.09280796f, -0.17757648f, 0.05750220f, 0.19913486f, 0.02009279f, 
    -0.19714572f, -0.03009540f, -0.03009665f, -0.01414144f, -0.02992651f, 0.01857639f, -0.46120039f, -0.13180369f, 
    0.20560956f, 0.08068077f, 0.04766849f, 0.05097234f, -0.00719305f, -0.19766775f, -0.00650086f, -0.14799264f, 
    -0.32864025f, -0.04523538f, 0.11381427f, 0.18613335f, -0.04640499f, 0.03948388f, 0.03108082f, 0.04817244f, 
    0.08592980f, 0.13373101f, -0.11976293f, 0.04733565f, -0.05358991f, 0.07385614f, 0.00900896f, -0.00168869f, 
    0.15890527f, 0.20960629f, 0.28724799f, 0.09402765f, 0.13564226f, -0.16187242f, 0.21299815f, 0.21416426f, 
    -0.02417508f, 0.01037825f, -0.24387042f, 0.18404041f, -0.03164383f, 0.13032576f, 0.11278369f, 0.05438333f, 
    -0.06624838f, -0.00424507f, -0.06655658f, 0.03609489f, -0.04303801f, 0.12431300f, 0.07193011f, 0.02256546f, 
    0.01030531f, 0.04932199f, -0.03055527f, -0.03924480f, -0.16125232f, -0.06059128f, 0.15709773f, 0.12888639f, 
    0.14686680f, -0.00739098f, -0.20010687f, 0.00027409f, 0.11974167f, -0.09657075f, 0.00961568f, 0.05257712f, 
    -0.17072278f, -0.10299983f, -0.02242784f, -0.06370185f, -0.04573489f, -0.03151683f, 0.14901987f, 0.20775506f, 
    0.03216949f, -0.29821321f, -0.06162478f, 0.03064186f, -0.03772676f, 0.03990038f, -0.00581565f, 0.08003510f, 
    0.02282018f, 0.17187868f, -0.13256648f, 0.01688775f, -0.04723820f, 0.05683055f, 0.08503147f, 0.08504047f, 
    -0.14552611f, -0.21464568f, -0.08930674f, 0.08867275f, -0.01803743f, 0.03610877f, -0.05027081f, 0.06966623f, 
    -0.00522628f, -0.20467697f, 0.15590824f, 0.04183196f, 0.02107645f, 0.00599806f, -0.10045719f, 0.01348754f, 
    -0.01778820f, -0.04898175f, -0.13230498f, -0.06238782f, -0.04417117f, 0.08554108f, 0.06045175f, -0.00840975f, 
    -0.18680178f, 0.09339803f, 0.12892172f, 0.21282914f, 0.09841940f, -0.15517928f, 0.07769976f, -0.11390730f, 
    -0.16073377f, -0.06849110f, 0.05017710f, -0.08877102f, 0.14419793f, 0.08205128f, -0.02615923f, 0.07052706f, 
    -0.02280516f, -0.04121723f, 0.05787953f, -0.10828102f, -0.04943666f, -0.07680574f, 0.05629444f, -0.10179880f, 
    -0.01668472f, -0.11297549f, -0.03191183f, 0.11977231f, 0.05144900f, -0.11661422f, -0.19822702f, -0.01244009f, 
    -0.18037046f, -0.03505448f, -0.05223721f, 0.09920862f, 0.03753203f, -0.04590992f, 0.07393952f, 0.09289637f, 
    -0.23819120f, 0.05003005f, 0.02894969f, 0.08123636f, -0.03395442f, -0.05738339f, 0.06677996f, -0.09612552f, 
    0.02509768f, -0.00831424f, 0.00405425f, -0.04071745f, 0.05709210f, -0.01791697f, 0.03361233f, 0.05666343f, 
    0.08735177f, 0.11980193f, -0.00219846f, -0.00042013f, 0.00373416f, 0.10727773f, 0.07238866f, -0.02657293f, 
    0.04164284f, 0.06930505f, 0.29308647f, 0.16151741f, -0.11393020f, 0.09508640f, 0.06400893f, 0.01048495f, 
    0.00795640f, -0.04495364f, -0.03413699f, -0.06241081f, 0.17658070f, -0.04159994f, -0.11026036f, -0.00739501f, 
    0.06342191f, 0.13998172f, -0.08853780f, -0.00743294f, 0.23553610f, -0.06874164f, -0.03288744f, 0.11974246f, 
    -0.03879096f, 0.11405747f, -0.11502600f, 0.07993746f, 0.06657774f, 0.14604460f, 0.03956607f, -0.19693932f, 
    0.01773894f, -0.07391708f, -0.03518109f, 0.04018140f, -0.04642820f, -0.10372207f, 0.15348610f, -0.05603089f, 
    -0.07331771f, 0.05040191f, -0.05316366f, -0.15131609f, 0.03749726f, 0.05665949f, -0.01932000f, -0.12384326f, 
    -0.11913446f, -0.03511393f, 0.00608538f, -0.00142017f, -0.04852979f, 0.04836712f, -0.03554463f, -0.06107094f, 
    -0.04540485f, -0.30981904f, -0.13704172f, 0.08764284f, 0.09669416f, 0.06688496f, -0.08524995f, 0.11735423f, 
    -0.04133106f, -0.21300049f, 0.11497970f, 0.07692815f, -0.07248075f, -0.07954103f, 0.02118922f, -0.14592063f, 
    0.08822265f, 0.05510989f, -0.19722551f, 0.04714945f, 0.01632298f, -0.01159969f, -0.01939458f, 0.03504693f, 
    -0.08460684f, -0.01227352f, -0.03712767f, -0.09103374f, 0.02808830f, -0.00709886f, -0.08020005f, 0.02830794f, 
    0.00354436f, 0.07220306f, 0.02751290f, 0.06054866f, 0.02650424f, -0.03172110f, 0.06618499f, -0.00514054f, 
    -0.00130248f, -0.04901109f, -0.01430184f, -0.05088991f, -0.16859831f, -0.15588729f, -0.01373335f, 0.00838515f, 
    -0.09373359f, -0.03824018f, 0.06802913f, -0.12379760f, -0.10844878f, 0.06567296f, -0.13502778f, 0.12743236f, 
    0.01382591f, -0.09867195f, -0.01913408f, 0.00006846f, -0.09022716f, 0.11828471f, -0.07637867f, -0.14105767f, 
    0.03544978f, -0.00670078f, -0.03250142f, 0.04695222f, 0.01026181f, -0.06488834f, 0.07866188f, 0.02556426f, 
    0.03912888f, -0.10431485f, -0.10828865f, 0.03702980f, 0.09421296f, 0.02318114f, 0.05328555f, -0.03727993f, 
    0.03144332f, 0.22864039f, -0.19844638f, 0.07313861f, -0.00483235f, 0.11752720f, 0.02721629f, -0.12716566f, 
    -0.03856381f, -0.05083565f, -0.09684356f, -0.02344529f, -0.02225716f, -0.08826777f, 0.02259314f, 0.02413926f, 
    -0.07910202f, 0.09363401f, 0.00598044f, -0.10284294f, -0.14481474f, -0.01717831f, -0.04844848f, 0.10434967f, 
    0.05007272f, 0.00962218f, 0.02039004f, 0.08948566f, 0.16894387f, -0.30205190f, 0.03610110f, -0.07051723f, 
    0.05789193f, 0.06537482f, -0.10916011f, 0.15828949f, 0.01563534f, 0.17815058f, -0.02246946f, -0.03000861f, 
    -0.03550199f, 0.04643312f, 0.00224397f, 0.08833325f, 0.04816760f, -0.08296057f, 0.09333948f, 0.16452593f, 
    -0.00872855f, 0.15372801f, 0.02156109f, 0.05627751f, 0.23182009f, 0.01342485f, -0.06807022f, 0.01780604f, 
    0.01202586f, 0.01074201f, 0.03958528f, 0.09794521f, 0.15913942f, 0.05965597f, -0.03847671f, -0.01604954f, 
    0.04514363f, -0.04671234f, 0.04295288f, -0.05693240f, 0.01532296f, 0.03880984f, -0.06529390f, -0.00254417f, 
    -0.06446077f, 0.05503727f, -0.03604570f, 0.04273289f, -0.04453519f, -0.03137644f, 0.00856759f, -0.02764936f, 
    -0.03439625f, -0.03069059f, -0.01659481f, 0.00489586f, -0.00100366f, -0.04695963f, -0.01294102f, 0.01145632f, 
    -0.04859247f, 0.02900192f, 0.00377511f, -0.04175393f, -0.05345830f, 0.00976038f, 0.02885378f, -0.06873285f, 
    -0.01818470f, -0.06537905f, 0.03570718f, 0.01732615f, -0.04340873f, 0.01430240f, -0.08339689f, -0.03486066f, 
    0.04155511f, 0.03034054f, 0.04541802f, 0.02458962f, -0.03853081f, -0.02340752f, -0.05374705f, -0.00991084f, 
    -0.03619367f, -0.09323044f, 0.01339564f, -0.07064960f, -0.05610781f, -0.08916160f, -0.02326869f, -0.02541535f, 
    0.03824418f, -0.01935668f, -0.06951146f, -0.01918877f, 0.02012847f, 0.03986266f, 0.00928136f, 0.01443145f, 
    -0.04742228f, 0.04866410f, 0.00811031f, -0.06001882f, -0.01374051f, -0.05894658f, 0.00911766f, -0.01047669f, 
    -0.04550974f, -0.05802437f, 0.04734088f, -0.02441800f, -0.06132255f, 0.01977638f, 0.00640972f, -0.08445496f, 
    -0.10693224f, -0.05241587f, -0.00149544f, -0.06661310f, -0.05141566f, -0.07886889f, -0.08610585f, -0.03176716f, 
    -0.08429258f, -0.00479877f, 0.01394649f, -0.00976978f, -0.07718848f, -0.06221277f, 0.00565107f, -0.06181978f, 
    -0.02895324f, -0.03552080f, 0.05415737f, 0.01637071f, -0.02791809f, -0.05366337f, 0.00312331f, -0.01770730f, 
    -0.05944898f, 0.01937546f, -0.00518734f, 0.01355490f, -0.06687862f, -0.03125686f, -0.05122710f, -0.01682705f, 
    0.05892280f, -0.01267333f, -0.05323217f, 0.03142970f, 0.02948466f, 0.03281510f, 0.00320410f, -0.02981118f, 
    -0.07305984f, -0.00122993f, -0.05627780f, -0.08011965f, -0.06659453f, 0.04076168f, -0.04545459f, -0.06645703f, 
    -0.06008026f, -0.01826717f, 0.04103621f, 0.03193098f, 0.01264261f, -0.03050984f, -0.00909478f, 0.04737404f, 
    0.06537953f, -0.05169049f, 0.01500302f, -0.04608005f, -0.05979113f, 0.00223542f, 0.02064623f, -0.02679948f, 
    0.05182341f, 0.02141517f, -0.03557067f, 0.00380603f, -0.07972764f, -0.04931918f, -0.02718957f, -0.01633086f, 
    -0.00908062f, 0.01731257f, 0.02069112f, -0.04907907f, -0.03839610f, 0.03086497f, 0.00691968f, -0.02632241f, 
    -0.01742635f, -0.05262092f, -0.03261541f, 0.03728602f, 0.04666244f, -0.01289750f, -0.03552280f, 0.00806736f, 
    -0.03843493f, 0.00869641f, 0.02719780f, 0.05495994f, -0.04757790f, -0.01216539f, -0.05199806f, 0.02601385f, 
    0.01287144f, -0.06405731f, -0.03825594f, -0.04775481f, 0.01720642f, 0.02013035f, -0.05739776f, -0.02730416f, 
    -0.04650144f, -0.07530252f, -0.06511854f, -0.05914493f, -0.01736295f, -0.02666817f, -0.08984148f, 0.01124181f, 
    0.00293289f, 0.02426776f, -0.08724687f, -0.04968813f, -0.02863721f, 0.01256084f, 0.01690313f, -0.07607280f, 
    -0.02429702f, 0.05400254f, -0.03459851f, -0.04394871f, -0.02355605f, -0.03159783f, 0.03798206f, -0.06399048f, 
    -0.04127320f, -0.06271853f, 0.01742421f, -0.04108411f, 0.00170748f, -0.06584723f, 0.03123630f, -0.04969880f, 
    -0.04501398f, 0.01116711f, -0.05134638f, -0.02260185f, 0.01149347f, 0.02615598f, -0.06062793f, -0.06078483f, 
    -0.05382045f, -0.06463550f, 0.03238426f, -0.01091861f, 0.01306289f, -0.02204020f, 0.00140848f, -0.00168676f, 
    -0.00313904f, 0.02129113f, 0.02876825f, -0.09431177f, 0.02620623f, -0.00094427f, 0.02011617f, -0.06916649f, 
    -0.06334309f, -0.06530111f, 0.01969264f, -0.01511927f, -0.02479257f, -0.03742458f, -0.02906455f, 0.03019105f, 
    0.03206612f, -0.04069659f, -0.03513727f, -0.00726698f, 0.02694122f, -0.02119163f, -0.01997459f, -0.04341334f, 
    0.07771191f, 0.00784549f, -0.02684265f, -0.06053435f, -0.08071610f, -0.03450498f, -0.00806987f, -0.00376277f, 
    -0.00084792f, -0.07833335f, 0.00181353f, -0.05138205f, -0.07340126f, 0.02558838f, -0.02674929f, -0.03153337f, 
    -0.09407061f, -0.07010692f, -0.01281760f, -0.01666787f, -0.04924941f, -0.04248193f, -0.03903890f, -0.05340239f, 
    -0.06626366f, -0.00678616f, -0.01811044f, -0.00806908f, -0.07355792f, 0.03510942f, -0.00450963f, -0.05022001f, 
    -0.03201554f, -0.05791117f, -0.01085644f, -0.02386808f, -0.00459901f, -0.00320579f, -0.04165960f, -0.02744372f, 
    0.01738296f, -0.01621587f, -0.03720042f, -0.02194659f, -0.04265609f, -0.04642055f, -0.04293904f, 0.03560253f, 
    0.00941101f, -0.01788095f, -0.05528929f, -0.00602737f, -0.02501303f, -0.04838016f, 0.01675272f, 0.02893248f, 
    0.04661052f, 0.03468540f, 0.03062334f, -0.05292369f, -0.00228515f, 0.01625793f, 0.03551972f, 0.03515936f, 
    -0.04043118f, -0.02671783f, -0.00821324f, -0.03469364f, 0.00109679f, 0.03631578f, -0.02449611f, -0.05356741f, 
    0.04525473f, 0.01534390f, 0.02459129f, -0.05586435f, 0.04803352f, -0.01783988f, -0.01227464f, 0.02881617f, 
    -0.05774531f, 0.01318285f, 0.04938247f, -0.00654013f, -0.05541353f, 0.00238446f, -0.01081602f, 0.04624885f, 
    -0.03122761f, -0.01789865f, -0.06307369f, 0.04279022f, 0.02567929f, 0.00769628f, 0.04360833f, 0.05117034f, 
    0.03668365f, -0.04724331f, 0.01905971f, -0.05030278f, -0.03590020f, 0.01810911f, -0.02364494f, 0.01110571f, 
    -0.03549255f, 0.01060385f, -0.01249443f, -0.06235087f, -0.06479946f, 0.04642967f, -0.02315330f, -0.05233597f, 
    0.03654616f, 0.05133315f, -0.03966307f, 0.02608609f, -0.04710852f, -0.04692081f, -0.03534904f, -0.04801180f, 
    0.00456722f, -0.02567814f, -0.06142098f, 0.01922712f, -0.02484265f, -0.03202741f, 0.05023299f, -0.04515243f, 
    -0.04191194f, -0.04618219f, -0.00816438f, 0.00904806f, 0.04177338f, 0.01492086f, -0.00686227f, -0.04165566f, 
    0.01742681f, -0.00546934f, -0.05217255f, -0.03231965f, -0.00537337f, -0.01933488f, -0.01752199f, -0.02490304f, 
    0.04164958f, 0.01860585f, -0.01453287f, 0.04146994f, 0.00071509f, 0.00141916f, -0.00860532f, -0.04073492f, 
    -0.06453957f, 0.04707792f, -0.02209648f, 0.03529182f, -0.05798917f, 0.04130966f, -0.06414475f, -0.02068397f, 
    0.00970146f, -0.04108524f, 0.01417780f, 0.01323175f, 0.01733133f, 0.03983632f, -0.06315615f, 0.01829178f, 
    -0.05398505f, -0.06178908f, -0.05728705f, -0.00066988f, -0.02552653f, 0.00472909f, -0.01429190f, -0.05945016f, 
    0.03579759f, 0.01813619f, 0.01781018f, -0.02578857f, -0.04731664f, 0.01222921f, -0.03741741f, 0.04674098f, 
    -0.01660438f, -0.02963690f, -0.05253732f, 0.01156550f, 0.05181766f, -0.01413158f, -0.04562712f, -0.05367832f, 
    0.00337041f, -0.02608234f, 0.05061175f, 0.04732616f, -0.03376476f, 0.05313610f, -0.05553622f, 0.04758819f, 
    -0.01570940f, 0.02994163f, 0.02271698f, 0.02229881f, -0.06015165f, 0.02515144f, -0.04857233f, 0.02976540f, 
    0.00246046f, -0.04153291f, -0.04635955f, -0.03615556f, 0.02991937f, 0.03416474f, -0.03356713f, -0.06419670f, 
    -0.03053401f, -0.03876530f, 0.00239228f, 0.02374622f, -0.02061285f, 0.04344931f, 0.02895877f, -0.00266097f, 
    0.02475392f, -0.05457301f, 0.04445044f, -0.04901735f, 0.02275225f, -0.01105292f, -0.03270829f, 0.03256796f, 
    -0.01114245f, -0.05776478f, -0.04757091f, 0.03331938f, -0.01215535f, 0.02375581f, 0.02415017f, -0.03678730f, 
    0.04106758f, 0.01983232f, -0.03174533f, 0.01807558f, 0.04403290f, 0.01186533f, -0.03692314f, -0.04423159f, 
    -0.05184148f, -0.02288530f, -0.02023209f, -0.02146082f, -0.00031458f, -0.06361653f, -0.01585242f, -0.04757700f, 
    0.01523892f, -0.06364138f, 0.03034563f, 0.02833648f, -0.06036226f, 0.02454493f, 0.02686121f, -0.02142810f, 
    0.00292628f, 0.05289961f, -0.00977571f, 0.01645889f, 0.04377397f, 0.04165208f, 0.03123265f, -0.04220483f, 
    -0.06130074f, -0.05762098f, -0.05546953f, -0.06162111f, -0.03950107f, 0.03203592f, 0.00583892f, -0.03870538f, 
    0.01928027f, 0.05047775f, -0.00185436f, -0.03266654f, -0.01204100f, 0.04806753f, 0.03387778f, 0.03696885f, 
    -0.04514342f, -0.01194147f, 0.01975864f, 0.00876988f, 0.02628095f, -0.01968763f, 0.02330723f, 0.04903613f, 
    0.04377639f, -0.04771567f, 0.02740190f, -0.05462585f, -0.05099825f, -0.04070437f, -0.04367067f, -0.04616502f, 
    -0.03843405f, 0.02888102f, 0.01465153f, -0.04645960f, -0.05470692f, 0.00814558f, -0.00954433f, 0.02717507f, 
    0.00033061f, -0.00988355f, -0.01256617f, -0.03132268f, -0.06114995f, 0.01418975f, 0.00006581f, -0.04567836f, 
    -0.01646179f, -0.11925586f, 0.14158714f, 0.04104190f, 0.02184408f, 0.02654994f, -0.06582036f, 0.13237365f, 
    -0.10843515f, 0.12101537f, 0.02066191f, 0.14402774f, 0.02339004f, -0.01295873f, 0.02799581f, -0.03732244f, 
    0.01122845f, 0.07788875f, 0.08910369f, 0.11606780f, -0.19568199f, 0.06332735f, -0.02672690f, -0.00361263f, 
    0.00221316f, -0.05811286f, 0.02615768f, -0.26761186f, 0.18258134f, -0.12306850f, -0.02956261f, 0.01982899f, 
    0.07345222f, -0.06972624f, 0.03499176f, -0.13140325f, -0.14025137f, -0.19279471f, -0.12135570f, 0.19173466f, 
    0.10760343f, 0.03146401f, 0.00656334f, 0.16920513f, -0.00972169f, -0.34422681f, 0.30005765f, -0.09109248f, 
    -0.02942224f, -0.15460107f, 0.07991985f, -0.00068042f, -0.04822440f, -0.06133725f, 0.04450360f, -0.03563646f, 
    0.06352503f, 0.07671256f, -0.12075544f, -0.01837823f, -0.06277140f, 0.03630410f, 0.09619936f, -0.04076428f, 
    0.10634352f, -0.05316667f, 0.07137635f, -0.14583959f, -0.10470139f, 0.05517361f, 0.06840546f, 0.08488373f, 
    -0.18884492f, -0.00339133f, 0.22138080f, -0.14881237f, -0.04187967f, -0.03085523f, -0.02374304f, -0.06767226f, 
    0.00929840f, -0.17437780f, -0.04479586f, 0.18914659f, -0.15682207f, -0.13908698f, -0.06624999f, -0.02070276f, 
    -0.03411198f, -0.01178953f, -0.25486347f, -0.24359801f, -0.10021094f, 0.10889925f, 0.13394396f, 0.06576036f, 
    0.05466367f, -0.05356115f, 0.21608181f, -0.23005685f, -0.10713218f, -0.15220731f, 0.06381458f, -0.04024664f, 
    -0.00232705f, -0.00477089f, 0.02116943f, 0.11672213f, -0.03103612f, -0.06797239f, -0.17670383f, 0.13767497f, 
    0.17522207f, 0.02794826f, -0.02207166f, 0.01111573f, 0.13168168f, -0.10787439f, 0.16719775f, 0.14254867f, 
    0.00653307f, 0.01759667f, 0.03420315f, -0.04679887f, 0.06344682f, -0.06188845f, -0.05484733f, 0.00559473f, 
    -0.43728521f, 0.08044630f, -0.03043516f, -0.05029759f, -0.03755914f, 0.00990306f, 0.07174152f, -0.05362001f, 
    0.02638567f, 0.12196741f, 0.07905419f, -0.06709389f, -0.05797454f, 0.04299997f, -0.06191018f, 0.02885060f, 
    -0.05643347f, 0.16255666f, 0.02716149f, -0.03573693f, 0.05230839f, -0.00890415f, 0.15758878f, 0.00815075f, 
    0.00532892f, -0.06153022f, -0.15830366f, 0.11198585f, -0.05370186f, -0.00661016f, -0.01715426f, 0.09330777f, 
    0.06472667f, -0.12128642f, 0.05848485f, -0.12538308f, -0.10132772f, 0.07080144f, -0.07269235f, 0.04300652f, 
    0.08324619f, 0.14606875f, 0.00747819f, -0.04078001f, -0.00327418f, 0.15409669f, -0.05930888f, 0.04858208f, 
    0.05075651f, -0.03538818f, 0.01233735f, -0.03610893f, -0.28798932f, 0.00146812f, -0.37207973f, 0.08937035f, 
    -0.11254173f, 0.04251768f, -0.01894745f, 0.02352843f, -0.06987765f, -0.25872168f, -0.20109718f, -0.03284324f, 
    0.03088379f, 0.03078749f, 0.02670845f, 0.04226131f, 0.00469425f, 0.12131389f, -0.39230692f, -0.13868530f, 
    -0.04651884f, 0.09619986f, 0.16537069f, 0.00181797f, 0.13974689f, -0.09255657f, 0.02789679f, 0.03822161f, 
    -0.12297305f, 0.19275908f, -0.03093301f, 0.01740045f, -0.03207344f, 0.04053213f, 0.05565493f, 0.03549335f, 
    0.06384153f, 0.02616693f, -0.39512613f, 0.08286473f, 0.05111462f, -0.15378335f, 0.09283722f, 0.09452090f, 
    -0.05313052f, -0.17373109f, -0.07548322f, -0.12680551f, -0.14937682f, -0.02178511f, 0.01159167f, 0.03950305f, 
    0.00566798f, -0.04661563f, -0.22872227f, -0.19697346f, 0.11801571f, -0.03665857f, 0.00998952f, -0.06517209f, 
    -0.04406787f, -0.00049496f, -0.01557121f, -0.02839933f, 0.03119676f, 0.06804327f, 0.10274603f, 0.11414024f, 
    0.03796642f, 0.00781083f, 0.06991724f, 0.01768328f, 0.07310980f, 0.08891689f, 0.06356319f, 0.09109109f, 
    0.08278672f, 0.05092819f, 0.07080275f, -0.06021534f, -0.01375818f, 0.02663126f, 0.15811011f, -0.07523876f, 
    0.07039776f, -0.08718231f, -0.01976651f, 0.09907895f, 0.07555871f, 0.07227412f, 0.02623714f, -0.13505165f, 
    -0.21511494f, 0.03297719f, 0.09274498f, -0.10254600f, 0.06307216f, -0.00738498f, 0.13622117f, -0.13363254f, 
    -0.49052709f, -0.13212042f, 0.13034852f, 0.07351572f, -0.06310873f, 0.14841178f, 0.02635519f, 0.08809209f, 
    -0.36390656f, 0.07904934f, 0.09996992f, 0.08271042f, 0.08318607f, -0.04525797f, -0.15905544f, 0.09696947f, 
    -0.05840415f, 0.02837184f, 0.22276990f, -0.18615386f, 0.01198814f, 0.11733638f, 0.00589126f, -0.06958693f, 
    -0.15823932f, 0.04349209f, 0.18878257f, -0.11218826f, 0.12848847f, -0.17754610f, -0.02730667f, -0.07617863f, 
    0.05614335f, 0.09074849f, 0.10556144f, -0.29216474f, -0.15314026f, 0.08397853f, -0.08640051f, 0.04925457f, 
    0.02118951f, -0.12638085f, -0.02008110f, 0.03496819f, -0.18095681f, 0.05081019f, -0.05825471f, 0.10161661f, 
    0.09392037f, 0.03787829f, -0.16077375f, -0.00373388f, 0.01389061f, -0.04211953f, -0.25311735f, 0.02205534f, 
    -0.04377455f, 0.02049139f, -0.04538588f, 0.01713945f, 0.11220520f, -0.12455946f, -0.19647221f, -0.23782763f, 
    0.08178262f, -0.09069735f, 0.05555287f, 0.05481097f, 0.01854086f, 0.12036566f, 0.02331808f, 0.12819052f, 
    -0.35593677f, -0.13832583f, -0.12025152f, 0.00729402f, -0.10875360f, -0.04916036f, -0.02955152f, 0.12667356f, 
    0.22391468f, 0.21558681f, 0.05442618f, 0.06420857f, 0.03374785f, -0.09013306f, 0.04429952f, 0.05747128f, 
    -0.08136384f, 0.12977462f, 0.06385546f, 0.20206572f, 0.12437023f, -0.06096551f, -0.13979359f, 0.03611680f, 
    0.13404828f, 0.11461242f, 0.01642358f, 0.08856688f, -0.23370752f, -0.02129295f, 0.03606332f, 0.06562437f, 
    0.08184744f, 0.07899459f, -0.00627990f, 0.07626296f, -0.07922421f, -0.08395095f, -0.06633883f, -0.01368712f, 
    0.12504612f, -0.01524836f, 0.00528292f, -0.16554813f, 0.11954498f, 0.20014720f, -0.12016693f, -0.13424174f, 
    -0.01335234f, 0.06466980f, -0.02111282f, 0.02206969f, -0.06782866f, -0.36961818f, -0.01675199f, 0.07160656f, 
    0.02725009f, 0.13569161f, 0.22685380f, -0.04697599f, 0.01900928f, 0.01834493f, -0.05423994f, -0.15487058f, 
    -0.04213015f, 0.00130102f, -0.02013358f, -0.09109789f, 0.03544569f, 0.06912548f, -0.05102940f, 0.31316862f, 
    0.29565352f, -0.12420952f, -0.19640703f, 0.09757905f, -0.08963359f, -0.04414462f, -0.09501696f, 0.05145273f, 
    -0.51178038f, 0.21372961f, 0.18072131f, 0.01316422f, -0.01825329f, 0.05964695f, 0.00259257f, 0.04742012f, 
    0.04185788f, 0.09351701f, 0.07821257f, -0.14320441f, 0.05635608f, 0.17161173f, 0.03823711f, -0.00682884f, 
    0.03529134f, -0.12329470f, 0.02010570f, 0.13389257f, 0.07377916f, 0.02535097f, 0.09338117f, 0.02812907f, 
    -0.17198731f, -0.01437892f, 0.01140760f, 0.46433324f, 0.12395122f, -0.07515992f, 0.04896984f, -0.12395024f, 
    -0.01542822f, -0.00003575f, -0.01331314f, 0.15476245f, 0.29710662f, -0.14370362f, 0.15064961f, -0.01372830f, 
    -0.02221592f, 0.01913682f, -0.02412782f, -0.06275051f, -0.17358731f, -0.11062764f, -0.16233937f, -0.17495844f, 
    0.04612632f, 0.06012723f, 0.02760953f, 0.05283237f, -0.09171132f, -0.00549687f, 0.25957185f, -0.13397962f, 
    0.09101900f, 0.11747899f, 0.06808809f, 0.04640743f, 0.12877847f, -0.04774766f, -0.02210543f, 0.05087710f, 
    -0.00314456f, 0.02173363f, 0.04419159f, -0.00504619f, 0.03829290f, 0.00406816f, 0.09691832f, 0.12507781f, 
    -0.13270319f, 0.12937067f, -0.15925963f, 0.08609065f, -0.17357418f, 0.01187281f, 0.05038367f, 0.14260487f, 
    0.04503662f, -0.09058084f, 0.02823881f, 0.05770153f, -0.01724049f, 0.06815505f, -0.08754127f, -0.07030091f, 
    0.06331935f, -0.00247971f, 0.15064037f, -0.24273542f, -0.04837006f, 0.10168493f, 0.05978715f, -0.05695345f, 
    0.09320992f, 0.04816496f, 0.01648413f, -0.19194229f, -0.02287658f, 0.07007699f, -0.05955959f, 0.11749855f, 
    0.15663457f, -0.05548663f, 0.00314421f, -0.04587507f, -0.27415118f, 0.04648305f, 0.12580043f, -0.14147156f, 
    0.02010521f, -0.04047016f, 0.02239065f, 0.05321522f, -0.01050502f, 0.04005840f, -0.02104898f, -0.09732428f, 
    -0.01572160f, -0.12599424f, 0.12082756f, 0.03272408f, 0.01798501f, -0.02016480f, -0.09571572f, 0.02503894f, 
    -0.19486906f, 0.11404677f, 0.06471745f, 0.02114589f, -0.02557345f, -0.02949742f, 0.03940739f, -0.04761438f, 
    0.03269374f, -0.32191402f, -0.00774600f, 0.21230112f, -0.05046631f, 0.07040872f, 0.05030361f, -0.02686131f, 
    -0.02856632f, 0.06192568f, -0.08906344f, 0.04696707f, 0.16586068f, 0.01500972f, -0.01887421f, -0.06509060f, 
    0.05034557f, 0.13458371f, 0.13283662f, -0.00129518f, -0.05180538f, -0.04909223f, 0.10936172f, -0.01482291f, 
    0.13500369f, -0.14351624f, 0.07269661f, -0.07563511f, 0.13022634f, -0.03287365f, -0.02102455f, 0.19835831f, 
    -0.07436957f, 0.08571875f, -0.00716229f, 0.09510697f, -0.09017862f, 0.00300711f, -0.00878753f, 0.02815523f, 
    -0.06944642f, 0.03478080f, 0.08897580f, -0.02039806f, -0.01996434f, 0.03737426f, 0.11258788f, 0.07971661f, 
    0.13190401f, -0.11308336f, 0.07472087f, 0.13367334f, 0.09827843f, 0.07711085f, -0.10572363f, 0.06276557f, 
    -0.01661087f, 0.07199666f, 0.06334535f, 0.15469128f, 0.08504553f, -0.22961791f, -0.05649313f, -0.00688674f, 
    -0.08152296f, 0.13652162f, 0.01722772f, 0.09104687f, 0.13670304f, 0.09797130f, 0.01606089f, 0.05287061f, 
    -0.09347365f, 0.10407145f, 0.09197740f, 0.09538402f, 0.00148472f, -0.02817371f, -0.04369514f, -0.07802659f, 
    0.20799844f, -0.15392384f, 0.00667741f, 0.01041613f, 0.11834901f, -0.03572796f, -0.04426035f, -0.02112525f, 
    0.00353846f, -0.07125553f, -0.08003978f, -0.01395601f, -0.06996179f, 0.04363524f, -0.03477316f, 0.03809379f, 
    -0.06393722f, 0.11011501f, 0.08590740f, 0.11919429f, 0.17173012f, 0.11020496f, -0.03198853f, -0.18857001f, 
    -0.02081877f, 0.11293191f, 0.16480337f, 0.28568417f, -0.05773843f, 0.03826237f, -0.13675790f, -0.00538804f, 
    -0.18318835f, 0.06148034f, -0.02805900f, 0.11286966f, -0.22607657f, 0.16579457f, 0.09594422f, 0.14866100f, 
    -0.06806511f, 0.00481787f, 0.06438665f, -0.08051533f, -0.02573808f, 0.05915846f, -0.11787013f, 0.06079041f, 
    0.06407725f, 0.14602256f, -0.07617146f, 0.04476978f, -0.16734324f, 0.19089574f, 0.35244849f, -0.04271617f, 
    0.12504904f, -0.01594828f, 0.01619377f, -0.09396505f, -0.07190304f, 0.01417425f, -0.05978263f, 0.22993450f, 
    0.03674770f, -0.07111137f, 0.04476275f, 0.03690787f, 0.01864829f, -0.05055631f, -0.00001401f, -0.23992617f, 
    -0.07062741f, 0.00288806f, -0.11090919f, 0.05553598f, 0.04272536f, 0.13288184f, -0.00553200f, -0.19680342f, 
    -0.11007920f, 0.16921780f, -0.05197477f, -0.08351137f, -0.15008204f, -0.08064003f, 0.22152551f, 0.10567745f, 
    0.05419730f, -0.07883296f, 0.01528347f, 0.06452041f, -0.02010530f, 0.08675467f, 0.07211761f, 0.08770788f, 
    -0.03379669f, 0.03467787f, -0.23098363f, 0.03633833f, -0.10427135f, 0.08376795f, -0.03418669f, 0.01003612f, 
    0.09773838f, 0.03600798f, 0.11244906f, 0.03206444f, -0.15109956f, 0.01825396f, -0.04812996f, 0.00601859f, 
    -0.14950220f, -0.02488312f, 0.13585982f, 0.01797835f, 0.11135545f, 0.09856082f, 0.05975331f, 0.02567241f, 
    -0.03684571f, -0.11981229f, 0.09944251f, 0.07981744f, -0.02696773f, 0.05736298f, 0.19039497f, -0.00364738f, 
    -0.03273842f, -0.06134268f, 0.11023503f, -0.14772499f, -0.14926971f, 0.17755847f, -0.00545106f, 0.11145123f, 
    0.03933534f, -0.03032534f, -0.07614147f, 0.12414458f, 0.01350875f, -0.07241101f, 0.07457981f, -0.07542477f, 
    -0.18106724f, 0.15007502f, -0.03708663f, 0.07063170f, 0.02210501f, 0.06204660f, -0.01163508f, 0.13786283f, 
    -0.09403685f, 0.03539692f, 0.06342202f, 0.03173762f, 0.00783226f, 0.06681424f, 0.00535265f, -0.08340006f, 
    -0.03844922f, 0.05516481f, -0.03395104f, -0.09080601f, 0.06733158f, -0.06962015f, -0.03446743f, -0.05039823f, 
    -0.00456761f, 0.03320647f, 0.21903951f, -0.17283097f, -0.00877285f, -0.07436761f, 0.05118556f, 0.13498431f, 
    0.19045740f, -0.04857075f, 0.00262455f, -0.01348738f, -0.19469333f, -0.06263989f, 0.09225979f, 0.05508351f, 
    -0.01900481f, 0.04435284f, -0.04647136f, 0.01257689f, 0.07033934f, -0.15697964f, 0.09729388f, -0.03145091f, 
    0.11691672f, 0.12237631f, 0.01773377f, 0.01368403f, 0.08953995f, -0.07955540f, 0.12130249f, -0.00980524f, 
    0.14632519f, 0.09483179f, -0.00496688f, -0.10138522f, -0.00923994f, -0.00270724f, -0.00055558f, 0.14562649f, 
    0.11914331f, 0.16595998f, 0.03958384f, 0.12672508f, -0.02493372f, 0.04758199f, -0.17981170f, 0.14874399f, 
    0.02915144f, -0.03652167f, 0.02227259f, -0.02157837f, -0.04011007f, 0.00574935f, -0.06423750f, 0.00836195f, 
    0.00025914f, -0.06401013f, -0.05960321f, 0.01599589f, 0.01024925f, 0.01144437f, -0.05553217f, -0.00838544f, 
    -0.00969524f, -0.05451165f, -0.03241713f, 0.03361189f, 0.01498143f, -0.02216841f, -0.02724820f, 0.01699707f, 
    -0.01011359f, -0.02355598f, -0.02124317f, 0.00321486f, 0.04317840f, -0.01920955f, -0.05601899f, 0.00145607f, 
    -0.07029752f, -0.04075685f, 0.04833212f, -0.00203490f, -0.06451762f, 0.00938626f, 0.01270055f, 0.03002933f, 
    -0.02274258f, -0.06328119f, -0.03285378f, 0.00367451f, -0.02494355f, -0.00372820f, 0.02736897f, -0.00662541f, 
    -0.00948931f, -0.00104434f, -0.05494548f, 0.03457177f, 0.02402599f, -0.06695076f, -0.00438979f, 0.02171500f, 
    -0.06629711f, -0.05855831f, 0.02886637f, -0.00866835f, -0.02432937f, -0.03953128f, 0.04587485f, 0.04284930f, 
    -0.02237557f, 0.02173283f, 0.01922763f, -0.05175456f, -0.06825309f, 0.04033942f, -0.01101918f, -0.03424305f, 
    0.00874467f, -0.01109351f, 0.04072274f, 0.01413909f, 0.04494723f, -0.06752620f, 0.03822792f, 0.00508473f, 
    0.04182746f, 0.00613924f, 0.00480423f, -0.00307515f, -0.02627874f, -0.00633659f, -0.00016058f, -0.03618079f, 
    0.02673938f, 0.03238050f, -0.01424468f, -0.04953425f, 0.02379461f, -0.05017798f, 0.02085436f, 0.04325081f, 
    -0.05509887f, 0.02561413f, 0.00654681f, -0.05242588f, -0.04838407f, 0.04338438f, 0.01484206f, -0.01675977f, 
    0.03715958f, 0.00859978f, -0.04566825f, -0.01689413f, 0.02351450f, -0.02523050f, -0.02912292f, 0.04462216f, 
    -0.00595889f, -0.02110085f, -0.04168367f, 0.02797881f, 0.03033437f, -0.01741808f, 0.01250546f, -0.03131706f, 
    0.00068146f, -0.00679471f, -0.00803921f, -0.05186509f, -0.00173760f, -0.02667530f, -0.03183809f, -0.02597915f, 
    -0.02034314f, 0.00074652f, -0.03875824f, -0.05972161f, 0.00196573f, -0.00330696f, -0.01824923f, 0.04697751f, 
    -0.06219552f, -0.03892575f, 0.01215459f, -0.01465970f, -0.06140379f, -0.02243007f, -0.03857910f, 0.00992259f, 
    -0.06060231f, -0.00813149f, -0.04244376f, 0.02596529f, -0.02524013f, 0.02524762f, 0.02605257f, 0.03792894f, 
    -0.01700701f, -0.05054934f, 0.04499439f, -0.06155602f, 0.01563301f, 0.00058118f, -0.00118254f, -0.02829949f, 
    -0.03081311f, -0.02869561f, 0.04547876f, -0.03010671f, -0.05266119f, 0.04876058f, 0.03043872f, -0.06027949f, 
    -0.05888112f, 0.02284935f, -0.02817659f, -0.02864478f, 0.00264107f, 0.01136174f, -0.03517127f, 0.00055345f, 
    -0.04901459f, -0.04679259f, -0.04061763f, 0.02860346f, -0.06139524f, 0.04253314f, 0.03505154f, -0.03222324f, 
    -0.02238142f, 0.02617625f, 0.01404988f, 0.04650595f, -0.05724073f, -0.05582653f, -0.03714701f, 0.01559681f, 
    0.04142158f, 0.04444451f, -0.03141160f, 0.03819868f, -0.04687586f, 0.00350555f, -0.02790610f, -0.02345357f, 
    -0.02470321f, 0.01702801f, -0.02619325f, -0.01293456f, 0.00251218f, -0.05819206f, 0.04496501f, 0.01852974f, 
    -0.02309670f, -0.01080367f, 0.00936420f, -0.02043136f, -0.06751779f, -0.02631448f, -0.01694562f, -0.01246923f, 
    0.04575532f, -0.06022712f, 0.03716525f, -0.02823681f, -0.03830459f, 0.03038720f, 0.04022880f, -0.03588575f, 
    0.00923048f, -0.04580248f, 0.04566370f, -0.06070918f, 0.01192911f, 0.02770685f, -0.01553316f, 0.01583398f, 
    0.02089357f, 0.01543461f, 0.02256910f, 0.01972597f, -0.01247481f, 0.03103081f, 0.03715178f, -0.05441375f, 
    -0.03974187f, 0.00867563f, -0.00244150f, 0.03437037f, 0.04175758f, 0.04251852f, 0.03545561f, -0.06550962f, 
    -0.05951013f, 0.02827007f, -0.00452891f, 0.01552372f, 0.04450065f, -0.01281326f, -0.00524596f, 0.01502043f, 
    0.02289366f, 0.00386582f, -0.03144734f, -0.00601480f, 0.04648114f, 0.02640357f, -0.06233246f, 0.03373508f, 
    0.00322557f, -0.04132511f, 0.01743047f, -0.04351050f, -0.05175236f, 0.03716969f, -0.01391952f, -0.03990298f, 
    -0.05201013f, -0.04759057f, -0.03050749f, 0.04414012f, 0.04307301f, -0.00962682f, -0.03544478f, -0.03831735f, 
    -0.02540742f, -0.04772756f, -0.02560882f, 0.02793294f, -0.02946303f, 0.01803069f, -0.05651238f, -0.06210050f, 
    -0.03034757f, 0.02432054f, -0.02334098f, -0.00713418f, 0.04959257f, 0.02221359f, -0.03235520f, 0.01560928f, 
    0.05268801f, -0.01104136f, -0.04126808f, 0.04801157f, 0.03944503f, 0.03945362f, -0.03288248f, -0.01700791f, 
    -0.00999363f, 0.01523114f, -0.02576362f, 0.02842571f, -0.02900521f, 0.01040504f, 0.04169610f, -0.06366032f, 
    -0.03001414f, -0.02316135f, -0.04997832f, -0.02417027f, 0.02058892f, -0.05689985f, 0.01990162f, 0.03380588f, 
    -0.02943968f, 0.04576474f, -0.03855507f, 0.00057236f, 0.01748498f, -0.02837581f, 0.00933087f, 0.05161330f, 
    -0.06120883f, 0.00577994f, -0.00845273f, -0.01722276f, -0.00342251f, -0.05929172f, -0.04177832f, -0.04868198f, 
    -0.06422957f, 0.03294472f, -0.05720288f, -0.04185930f, 0.04193797f, -0.01713272f, -0.02676153f, 0.00285141f, 
    0.03510325f, -0.03832277f, 0.04607846f, 0.00127456f, -0.04003717f, -0.01191702f, -0.02126245f, -0.03219770f, 
    -0.02402135f, 0.03261288f, -0.03115145f, 0.04018461f, -0.04390633f, -0.02906177f, -0.01481522f, -0.00838947f, 
    -0.02600672f, -0.00274677f, 0.02879578f, -0.01525668f, -0.04948732f, 0.04077681f, 0.02284839f, -0.02816933f, 
    -0.05401535f, -0.06106760f, -0.03991954f, -0.06388388f, -0.01651423f, -0.01652952f, 0.03869440f, -0.06024550f, 
    0.02437689f, -0.00253458f, 0.04427772f, -0.03602999f, -0.02323915f, -0.02794262f, 0.03622919f, 0.01534150f, 
    0.00224699f, -0.03999857f, 0.00022431f, 0.01116575f, -0.03940723f, -0.02423685f, -0.00876456f, 0.01278098f, 
    -0.00421998f, 0.02392081f, 0.01668512f, -0.02827337f, -0.02315624f, -0.06406669f, 0.05209404f, 0.00952723f, 
    -0.02118983f, -0.02507825f, -0.03427025f, -0.04383726f, -0.00509203f, -0.00631126f, -0.06454290f, 0.01629953f, 
    -0.04334683f, 0.00305741f, 0.02950364f, 0.04405573f, 0.01854234f, -0.01962610f, 0.04481366f, -0.04925294f, 
    0.02365447f, 0.01394806f, -0.05801373f, -0.03655576f, 0.04635854f, -0.01803219f, -0.05815868f, 0.05257955f, 
    0.00575257f, -0.04563698f, -0.03873205f, -0.05642221f, -0.06218936f, -0.03590150f, -0.04224133f, 0.05606766f, 
    0.01574573f, -0.02063430f, -0.03813761f, 0.02565429f, -0.01326474f, -0.01604217f, -0.05557682f, -0.03822990f, 
    0.02758498f, -0.02661348f, -0.00828489f, -0.06297403f, 0.05136626f, -0.02685530f, 0.03748837f, -0.04719698f, 
    -0.00392384f, -0.00919234f, -0.01356691f, -0.03161518f, -0.00999475f, 0.04683018f, -0.00890183f, -0.04306690f, 
    0.03492729f, 0.02962968f, -0.01402863f, -0.00285581f, 0.02716300f, 0.02240622f, -0.02729803f, 0.04824346f, 
    -0.01458033f, -0.02216322f, -0.05043687f, -0.03464364f, 0.00502856f, 0.01150274f, 0.04648661f, 0.00444417f, 
    0.03433309f, -0.05582854f, -0.02592054f, -0.02285663f, -0.05526627f, 0.01753178f, 0.02655580f, 0.01430010f, 
    0.00883575f, -0.06388972f, -0.04699803f, 0.05262402f, 0.00696202f, 0.01436529f, -0.00738259f, -0.00885748f, 
    0.00691464f, -0.00000382f, -0.05373557f, -0.06137631f, -0.00343256f, -0.00913460f, -0.03135690f, -0.01388828f, 
    0.00202892f, 0.00190872f, 0.00946562f, -0.05931519f, -0.03223787f, -0.01504702f, 0.00757164f, -0.02570763f, 
    0.04100688f, 0.00520981f, -0.05932859f, 0.02967895f, -0.01035383f, -0.04391057f, -0.01051765f, 0.04963941f, 
    -0.00102774f, 0.00370769f, 0.05749510f, -0.00829293f, -0.01718200f, -0.06134926f, -0.01880142f, -0.03757425f, 
    -0.05148244f, 0.04455066f, -0.06205873f, 0.01584044f, -0.02578902f, 0.04605582f, 0.02125360f, -0.05487525f, 
    -0.05431723f, 0.01122865f, 0.04136096f, -0.05218559f, -0.04268134f, 0.04236538f, -0.05543555f, -0.03823228f, 
    -0.06375246f, 0.04684179f, -0.05075000f, 0.04277200f, -0.03401957f, 0.00495488f, -0.03371606f, 0.00106672f, 
    -0.03241190f, 0.04262779f, -0.05383427f, 0.03296348f, -0.04428422f, -0.04682163f, -0.00848985f, -0.01803513f, 
    -0.04412268f, 0.04913180f, -0.05483181f, 0.04167257f, -0.03471933f, 0.05034664f, -0.01889859f, 0.02979162f, 
    -0.02946371f, 0.02747302f, 0.00536896f, 0.00693735f, -0.06060220f, -0.05528253f, 0.04855154f, -0.03995221f, 
    -0.00485153f, -0.03425658f, 0.00714890f, -0.03601534f, -0.02848697f, -0.03536338f, 0.02334147f, -0.00194847f, 
    -0.23109376f, -0.25521845f, -0.01473868f, 0.16763218f, -0.19337839f, 0.07132345f, 0.03606180f, -0.01555999f, 
    0.09443233f, -0.05609333f, -0.03836919f, -0.08930919f, -0.00804277f, -0.04953281f, 0.07657164f, 0.03063232f, 
    0.11357454f, -0.01949671f, 0.03405971f, 0.09780250f, -0.17227755f, 0.07149433f, -0.10629610f, -0.01619312f, 
    -0.03554563f, -0.01959577f, 0.11258727f, -0.05843746f, 0.06028468f, -0.08774645f, -0.08601036f, 0.15800449f, 
    -0.07841081f, -0.00667283f, 0.10664535f, -0.01315158f, -0.07035949f, 0.03057932f, 0.10819475f, 0.05375034f, 
    -0.01201822f, -0.06801713f, 0.00909468f, -0.02936049f, 0.15664287f, -0.09642199f, -0.03426263f, 0.14023037f, 
    0.12389650f, 0.01076837f, -0.01637658f, 0.13656507f, 0.11938462f, 0.09201680f, -0.17882325f, -0.10246012f, 
    0.06108044f, 0.04090919f, 0.01951319f, 0.08610915f, 0.11398115f, 0.03234326f, 0.13389851f, -0.06357890f, 
    -0.00574724f, -0.16491067f, 0.07686421f, 0.02255545f, 0.01745377f, -0.04481758f, 0.13141491f, 0.03873893f, 
    0.09093213f, 0.05219893f, 0.05198644f, -0.14627333f, 0.02342495f, 0.15124497f, -0.03824927f, 0.10195789f, 
    -0.01272857f, 0.07673544f, -0.09685685f, 0.05614094f, -0.02881909f, -0.06650307f, 0.04467155f, 0.05080868f, 
    0.09711356f, -0.05696153f, -0.18014629f, 0.05737273f, 0.12841901f, 0.01822014f, 0.12216908f, 0.05269662f, 
    0.10950916f, 0.01195098f, 0.03348842f, 0.24551648f, 0.10812015f, -0.00209333f, 0.07795724f, -0.06055139f, 
    0.01721673f, -0.01450234f, -0.15407583f, -0.03213934f, -0.39633667f, 0.01405957f, 0.07091273f, 0.02696169f, 
    0.06765413f, -0.01263799f, 0.05397448f, -0.12040827f, 0.05547646f, 0.14195234f, -0.07767257f, 0.07384690f, 
    0.08326099f, -0.20987600f, -0.04628585f, -0.06024936f, -0.01576317f, -0.02029740f, 0.04487951f, 0.18102537f, 
    -0.28223246f, -0.14158033f, 0.03495156f, -0.00257469f, 0.04786356f, 0.03852297f, -0.01186630f, -0.04173805f, 
    -0.13849087f, -0.09577059f, -0.00673341f, 0.08607884f, -0.03481913f, -0.01778959f, 0.06650028f, 0.03253771f, 
    -0.18660669f, -0.12956485f, 0.00024585f, 0.00514582f, 0.11461723f, -0.10324141f, -0.08397061f, 0.01086416f, 
    -0.05834286f, -0.00904781f, -0.00401690f, -0.02773682f, 0.00938367f, -0.01258716f, 0.00135473f, 0.01844610f, 
    -0.04500095f, -0.11060630f, -0.12311663f, -0.19211701f, -0.07618158f, -0.08262803f, -0.04238550f, 0.01399899f, 
    0.10852904f, 0.00573688f, 0.00913207f, 0.02632612f, 0.06277591f, 0.00424970f, 0.08295415f, 0.01220937f, 
    -0.04581584f, 0.12014785f, 0.16133527f, 0.12860440f, -0.00089473f, 0.01679424f, -0.20081523f, 0.06808282f, 
    0.02586870f, -0.06209576f, 0.05644867f, 0.00310865f, 0.03917033f, -0.05103740f, 0.08459464f, -0.03436416f, 
    -0.09263361f, -0.06987024f, 0.02374962f, -0.05317046f, 0.06514812f, -0.00616459f, 0.07766754f, 0.11355078f, 
    0.04438281f, -0.08529235f, -0.26079661f, 0.07101998f, 0.01940241f, -0.15721841f, 0.00109671f, -0.05130756f, 
    0.09768292f, 0.15270552f, 0.00219667f, 0.07007409f, -0.01131026f, 0.07034697f, 0.01825457f, 0.06040974f, 
    -0.26122093f, -0.10174801f, -0.11574207f, -0.08601102f, 0.06406181f, -0.09319192f, -0.02446056f, 0.09553302f, 
    -0.02837317f, 0.15040512f, -0.08768683f, -0.05829139f, 0.10748401f, 0.12605850f, 0.12108876f, 0.10353678f, 
    0.04210325f, -0.18105708f, -0.00666677f, 0.03376702f, -0.03904953f, -0.09845392f, 0.04919671f, 0.13744225f, 
    0.09909003f, 0.06223975f, -0.09218869f, -0.07706581f, -0.00936571f, 0.15848160f, -0.03288026f, -0.06530982f, 
    -0.01189128f, -0.11651991f, 0.02690287f, 0.02803501f, -0.49532971f, -0.00233390f, -0.05005484f, 0.08941467f, 
    -0.01453991f, 0.01221974f, -0.09352576f, -0.02250068f, -0.00862345f, -0.25971866f, -0.14247458f, -0.02094055f, 
    -0.05008532f, 0.08425052f, -0.17260918f, 0.01812624f, 0.01089298f, -0.02119155f, 0.07494248f, 0.00836422f, 
    -0.02600832f, 0.07318721f, 0.12843889f, -0.07496109f, -0.04559474f, -0.01097575f, 0.11326779f, 0.24043809f, 
    -0.06887762f, 0.00265218f, -0.02198233f, -0.02957320f, -0.11449800f, 0.09713085f, -0.04343460f, 0.02775245f, 
    -0.01116086f, -0.09789062f, -0.02681114f, -0.08444083f, -0.10315417f, -0.02265163f, -0.07977433f, -0.12896436f, 
    0.07328967f, -0.10199628f, 0.16832744f, 0.03476994f, -0.03900946f, 0.02769231f, -0.03661165f, 0.01495860f, 
    -0.02257259f, -0.03224667f, -0.04758773f, 0.18333741f, 0.00561282f, 0.10464505f, -0.11416453f, -0.01890451f, 
    -0.03363731f, -0.05764345f, 0.16137072f, 0.16654891f, 0.04576377f, -0.28052369f, -0.02556741f, -0.00328384f, 
    -0.16366997f, 0.08301698f, 0.11190615f, -0.12035425f, 0.04008126f, -0.03476852f, -0.03440008f, -0.05643681f, 
    -0.01710737f, 0.05583758f, 0.04458687f, -0.09703053f, 0.06631313f, 0.23174191f, 0.10740795f, -0.11791840f, 
    -0.03037534f, -0.00204261f, 0.13699046f, -0.06450262f, 0.01772885f, 0.15951082f, 0.02845669f, -0.08251786f, 
    -0.04441521f, -0.07068716f, 0.12289129f, 0.05879534f, 0.08021357f, 0.10429804f, 0.11164207f, 0.01910883f, 
    0.26616773f, -0.18570527f, -0.00900923f, -0.19762577f, 0.02134429f, -0.01031865f, 0.10017888f, -0.02907498f, 
    0.00102486f, 0.06649740f, -0.04407948f, 0.13232037f, 0.01769622f, 0.06167134f, 0.02452980f, -0.06162461f, 
    0.01190616f, 0.11080444f, 0.14948735f, 0.02128839f, 0.19779545f, -0.01789449f, 0.15919192f, 0.00823264f, 
    0.01588899f, 0.00276768f, 0.10346594f, -0.12904191f, -0.06018990f, 0.03930642f, -0.02385169f, -0.05783428f, 
    0.01274363f, 0.02084473f, 0.06587829f, -0.23015712f, 0.08683265f, 0.05338769f, 0.02154610f, 0.12397899f, 
    0.00636092f, -0.00317894f, 0.01713108f, -0.02221438f, -0.12122950f, -0.09650970f, 0.02081426f, -0.05449118f, 
    -0.09394029f, 0.01684687f, -0.09977715f, -0.01388007f, -0.01839725f, -0.01676797f, 0.07143548f, 0.16566350f, 
    0.10209855f, 0.00332638f, -0.04533943f, 0.08826600f, -0.01690057f, -0.03676264f, 0.38003743f, 0.15739933f, 
    -0.10902429f, 0.05467613f, -0.05364450f, 0.02118609f, 0.19425586f, -0.01146938f, -0.12634094f, 0.07728344f, 
    -0.12989065f, 0.01637693f, 0.03341733f, 0.00779919f, -0.05903290f, 0.01222982f, -0.03611125f, 0.04474599f, 
    0.05849651f, -0.17510036f, -0.17355208f, -0.11481042f, 0.01119893f, 0.12035071f, 0.09221444f, 0.02190956f, 
    -0.02468706f, 0.02089991f, -0.00343907f, 0.09623984f, 0.00299188f, -0.05104667f, 0.07481294f, -0.04489496f, 
    -0.00186714f, 0.12916462f, -0.21124364f, 0.13062352f, 0.03204335f, -0.03994697f, -0.04990067f, -0.14673322f, 
    0.06342071f, 0.04075490f, 0.00728994f, 0.15292545f, -0.00053574f, -0.14585218f, -0.02145067f, 0.07684541f, 
    0.05302852f, 0.03626418f, -0.00951170f, 0.08621488f, 0.01402824f, 0.17000270f, -0.04151114f, -0.05662712f, 
    -0.13440688f, 0.07742403f, -0.02662794f, -0.22864816f, -0.21261233f, -0.03598891f, 0.12499361f, 0.16566221f, 
    0.02451729f, 0.09017370f, -0.02772770f, -0.02778568f, 0.07490581f, -0.04316242f, 0.00079529f, 0.13828251f, 
    0.16429122f, 0.06876190f, 0.09171940f, -0.00177400f, -0.01798331f, 0.02330227f, 0.02787488f, 0.09961171f, 
    -0.09040851f, 0.07211962f, 0.12902109f, 0.05417881f, 0.03900793f, -0.04749786f, 0.05609833f, -0.08385959f, 
    0.00333723f, 0.09080371f, -0.05218109f, 0.04518730f, 0.04385123f, 0.04392282f, 0.05326987f, -0.01216468f, 
    0.06305435f, 0.15825748f, 0.20943621f, -0.02309196f, -0.00580114f, 0.13040133f, 0.25153542f, 0.00073086f, 
    0.05804045f, -0.03652437f, -0.06689595f, 0.21293133f, 0.12906770f, 0.02775966f, 0.13544297f, 0.05232962f, 
    0.10085350f, 0.01217205f, -0.08876388f, 0.07656457f, -0.05404123f, -0.08228035f, -0.10349395f, 0.05351543f, 
    -0.00790290f, -0.00544580f, 0.05997984f, -0.03257972f, -0.21841343f, -0.13510175f, 0.01761594f, -0.14693648f, 
    0.07438641f, 0.04340588f, -0.14875627f, 0.01598830f, -0.04587688f, 0.06140931f, -0.12756266f, -0.03911074f, 
    -0.10654142f, -0.02344861f, -0.03869114f, -0.02424979f, 0.00079410f, -0.10065909f, 0.03124188f, -0.08364801f, 
    0.06600378f, -0.09845491f, 0.09100787f, -0.05054658f, -0.02318951f, -0.01827469f, -0.00158647f, 0.13157994f, 
    -0.09712801f, 0.03740468f, -0.05542864f, -0.00261341f, -0.05816590f, 0.03591708f, 0.01821155f, 0.03767208f, 
    -0.00810260f, -0.20706585f, 0.11467917f, -0.01024382f, -0.10210340f, -0.01509417f, -0.06537753f, -0.03567076f, 
    0.21276322f, -0.08538095f, 0.03889236f, -0.14026384f, -0.06479316f, -0.02173962f, -0.03115815f, -0.06372118f, 
    -0.00680688f, 0.01258294f, -0.01389749f, 0.08164508f, 0.02787290f, 0.03265234f, -0.07646863f, -0.05748298f, 
    0.08392322f, 0.10063103f, 0.03913299f, -0.17929159f, -0.01093146f, 0.09553470f, -0.06240104f, 0.04365883f, 
    0.09277774f, -0.09174673f, -0.02824359f, -0.14758316f, 0.13491504f, -0.19055104f, 0.05196960f, -0.07340430f, 
    -0.02420636f, 0.13421717f, -0.13160944f, 0.02514256f, 0.03744307f, 0.00116775f, 0.16811474f, -0.09415931f, 
    -0.06516434f, 0.01536965f, -0.06845202f, -0.06688091f, -0.13139760f, 0.05412463f, -0.02253917f, 0.00422270f, 
    0.08879998f, 0.00408669f, -0.09783812f, -0.10684906f, 0.09984939f, 0.03534184f, -0.03064819f, -0.28060141f, 
    -0.01633866f, 0.02183197f, 0.10214590f, -0.10570667f, -0.01852919f, 0.01123909f, 0.01281533f, -0.00271376f, 
    0.11661902f, 0.04490232f, -0.02891370f, -0.06664935f, 0.03023981f, 0.01990439f, 0.12901920f, -0.00410684f, 
    0.00172004f, 0.14421682f, 0.19606666f, 0.07676256f, 0.04058232f, -0.01104030f, -0.05887571f, -0.00027535f, 
    0.10818447f, -0.04576128f, -0.00212876f, -0.11793267f, 0.01187782f, -0.04125635f, 0.00774611f, 0.01860146f, 
    -0.14640777f, 0.04953014f, -0.14159362f, 0.01981806f, 0.04367118f, 0.01429608f, 0.12577502f, 0.00771200f, 
    0.01519592f, 0.01841856f, -0.05540047f, 0.04187664f, -0.20406626f, 0.08812083f, -0.01649678f, -0.02750722f, 
    -0.03924119f, 0.12885696f, -0.04216618f, 0.09782517f, 0.06909960f, -0.03966123f, 0.23532528f, -0.02000292f, 
    -0.14391159f, 0.02040342f, 0.10984415f, -0.05778987f, -0.05316078f, -0.12772568f, -0.14960653f, 0.01118989f, 
    0.03229030f, -0.04569314f, 0.04543274f, -0.03251233f, -0.06573626f, 0.11659726f, -0.06439095f, -0.10829082f, 
    -0.01809509f, 0.04143373f, -0.01445986f, 0.07953356f, 0.00857980f, -0.02463217f, 0.18232797f, 0.06700673f, 
    0.06649182f, -0.00778196f, 0.11816327f, -0.06961790f, -0.02665398f, -0.01402767f, 0.02420207f, -0.06783348f, 
    0.12340333f, 0.03421625f, -0.00781532f, 0.03485119f, 0.10523906f, 0.05117988f, -0.19152224f, 0.05269760f, 
    0.02912106f, 0.00002724f, -0.03520213f, -0.04334359f, 0.07545725f, -0.10555507f, -0.01581724f, 0.00509784f, 
    0.03527552f, 0.03028926f, 0.00340348f, 0.13549535f, 0.06013172f, -0.05337535f, 0.12778081f, 0.05677971f, 
    0.03273568f, 0.03822630f, 0.02097409f, -0.02407825f, 0.13725640f, 0.00847474f, -0.03921934f, 0.15833516f, 
    0.11784256f, 0.02276634f, 0.07850941f, -0.18735814f, -0.06851820f, -0.06768024f, 0.23436968f, -0.05207458f, 
    -0.01366871f, 0.08234589f, 0.05019639f, -0.08267467f, -0.00465220f, -0.00755385f, 0.02811163f, 0.04653995f, 
    0.06266381f, 0.09193379f, -0.08774747f, 0.08788489f, 0.06479874f, -0.11344051f, -0.04332319f, -0.12734118f, 
    -0.10221309f, 0.11516800f, 0.06362966f, -0.03634783f, -0.02810118f, 0.05225236f, 0.02834812f, -0.01523424f, 
    0.11893616f, -0.04292572f, -0.02795428f, 0.14548463f, 0.03706979f, 0.00516635f, 0.02953420f, 0.07171077f, 
    -0.18646060f, 0.25556365f, 0.08768328f, 0.02328035f, 0.04653807f, -0.05465010f, -0.01484323f, -0.02704040f, 
    0.03885024f, -0.00935049f, 0.19291374f, 0.20666955f, -0.04696410f, 0.04091835f, 0.01693238f, 0.01566189f, 
    -0.05566256f, 0.02266354f, -0.04008375f, 0.14740865f, -0.01566754f, 0.01768948f, -0.01729152f, -0.01363575f, 
    -0.01652581f, -0.08792495f, 0.01895190f, 0.11563608f, -0.11570784f, 0.04542796f, -0.13129388f, -0.06628810f, 
    0.05546192f, 0.01936058f, -0.05997795f, 0.10626630f, 0.19719714f, -0.11415044f, 0.08304844f, -0.11019284f, 
    -0.07226338f, -0.12257355f, 0.12592006f, -0.04853555f, -0.03543324f, 0.02907383f, 0.00369705f, -0.02147651f, 
    -0.05666338f, -0.17580265f, 0.01211830f, 0.07662196f, -0.11100032f, -0.01842478f, 0.02530184f, 0.10373738f, 
    -0.24493034f, -0.08301205f, 0.00089566f, 0.00231419f, -0.00756044f, -0.06816021f, 0.00837913f, -0.00180485f, 
    0.14532645f, 0.06506043f, 0.08330947f, -0.01300886f, -0.07100736f, -0.00696238f, 0.11310263f, 0.05209713f, 
    -0.02509435f, -0.02501290f, -0.03158324f, 0.09018568f, -0.08402389f, 0.00233279f, 0.18888295f, 0.07056648f, 
    -0.01254615f, -0.02121745f, -0.04465363f, -0.23422411f, -0.03099007f, -0.18201277f, 0.07407616f, -0.17843533f, 
    0.02398049f, 0.04613794f, -0.00676859f, 0.00204068f, 0.02335099f, -0.15242015f, 0.07877745f, 0.03095672f, 
    0.05948990f, -0.04987882f, -0.08718114f, -0.08143639f, 0.05306559f, 0.08778573f, -0.12437982f, -0.03184852f, 
    0.08167324f, 0.12352133f, 0.15423694f, -0.04241153f, 0.05101965f, -0.14552966f, -0.08881164f, -0.23190343f, 
    0.13128236f, -0.02130021f, 0.02240146f, 0.01633286f, -0.00155003f, 0.10979904f, -0.25243345f, -0.03933302f, 
    -0.03666508f, 0.05711477f, 0.07524086f, 0.04720037f, 0.01291720f, 0.03179057f, 0.13456692f, 0.20157669f, 
    -0.17011409f, 0.34522465f, 0.14537506f, -0.08114952f, 0.02100568f, 0.06087232f, 0.08827048f, 0.09170893f, 
    -0.11031450f, -0.04599671f, 0.00500333f, -0.10535439f, -0.00172218f, -0.01405224f, 0.05496174f, 0.08917614f, 
    -0.04682816f, -0.09009888f, 0.03740312f, -0.13029051f, 0.01539964f, -0.00564365f, -0.06785709f, 0.06179913f, 
    -0.04802281f, -0.09030599f, 0.14218071f, 0.09712567f, -0.10757823f, -0.11453912f, -0.04695434f, -0.06512826f, 
    -0.13388385f, -0.06664646f, 0.03031140f, 0.06519473f, 0.00992399f, 0.14223498f, -0.05847405f, 0.11071651f, 
    0.05290893f, 0.04620111f, -0.06304481f, -0.15529364f, 0.30303743f, 0.20377535f, -0.03262737f, 0.01262540f, 
    -0.12417232f, 0.07061514f, -0.10587891f, 0.05945107f, -0.06023555f, 0.03759426f, 0.11126769f, -0.37015006f, 
    -0.05677571f, 0.07254811f, 0.09943858f, -0.07116310f, -0.03778644f, -0.11620996f, -0.12580357f, 0.03065049f, 
    0.15138848f, 0.07247358f, 0.04690281f, 0.04249419f, -0.03272762f, 0.02432152f, 0.15650669f, -0.38625345f, 
    -0.08480345f, -0.05000163f, -0.01465570f, -0.02899877f, 0.00207463f, -0.05197709f, 0.01389920f, 0.00196424f, 
    0.34606475f, 0.10463180f, 0.00097619f, -0.04999768f, -0.04313855f, 0.14023571f, 0.17417251f, 0.08312523f, 
    0.01081210f, -0.17061275f, -0.21417756f, -0.07023440f, 0.16657887f, 0.05763358f, -0.03402079f, 0.13707390f, 
    0.01531113f, -0.06984494f, 0.03902932f, -0.04749787f, 0.00052848f, -0.07465285f, -0.03139383f, -0.01224054f, 
    0.06527511f, 0.02522041f, 0.08910868f, 0.03852640f, -0.00392545f, -0.15178278f, -0.07663900f, 0.06482843f, 
    0.13201493f, -0.06110347f, -0.02553876f, -0.20573454f, -0.11474785f, -0.11195389f, 0.02967223f, 0.08333252f, 
    -0.11685321f, 0.19793054f, 0.00859272f, 0.02289665f, -0.04849978f, -0.01760433f, -0.03539287f, -0.11259782f, 
    0.06350694f, 0.08759078f, 0.02197399f, 0.06962001f, -0.14202464f, 0.11432368f, 0.00034261f, -0.01238470f, 
    -0.09188246f, -0.05487969f, 0.07333284f, 0.06293449f, 0.10597349f, -0.06724622f, -0.04639909f, 0.01574828f, 
    0.16153018f, 0.02563343f, -0.09458338f, -0.01459167f, 0.10187229f, -0.05030215f, 0.01484374f, 0.03833848f, 
    0.10433553f, -0.04668466f, 0.06480044f, 0.07265708f, 0.09678742f, -0.05949413f, -0.08522147f, -0.05927314f, 
    -0.04749685f, -0.32028514f, 0.03332932f, 0.07668094f, 0.04093160f, 0.02890994f, -0.20467865f, 0.08407532f, 
    0.03970401f, -0.08128859f, -0.09057136f, -0.05363789f, -0.16831112f, 0.00764399f, 0.04412426f, 0.06146946f, 
    0.03889624f, -0.06824434f, -0.16719353f, 0.17000142f, 0.16568188f, 0.23705010f, 0.06919014f, 0.01777868f, 
    -0.02345371f, -0.01784288f, 0.00687443f, 0.11849362f, 0.34516689f, 0.21887651f, -0.16390882f, -0.00501771f, 
    -0.17008048f, 0.05425455f, 0.08009972f, 0.02371404f, -0.13177483f, 0.19876660f, 0.03267028f, 0.03081595f, 
    0.06377213f, -0.01355589f, 0.10493754f, 0.13347614f, -0.00507894f, 0.05562839f, 0.24662921f, 0.15523472f, 
    -0.20283397f, 0.04231732f, 0.07606523f, 0.01763097f, 0.04217698f, -0.01582471f, 0.05500856f, 0.07994230f, 
    -0.07414117f, -0.07008348f, 0.02342425f, 0.13215877f, -0.01608980f, -0.06117335f, -0.02390642f, 0.01232851f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.02906694f, 0.02981794f, 0.02621220f, 0.08444726f, -0.04646974f, -0.05394645f, -0.03599674f, 0.07126112f, 
    -0.00822041f, 0.01994290f, -0.03001588f, 0.11187201f, 0.04290213f, 0.03461114f, 0.06902503f, 0.08553810f, 
    -0.02710851f, 0.15020430f, 0.00527869f, 0.11973203f, -0.02574842f, -0.03641476f, -0.02157037f, 0.12088557f, 
    -0.02256955f, 0.04074656f, -0.01827532f, 0.01136383f, 0.00574925f, 0.08134791f, -0.09288210f, 0.03915267f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.22150797f, 0.19927564f, -0.18046811f, 0.41613203f, -0.07426663f, -0.07787080f, -0.10522985f, -0.03165630f, 
    0.09581244f, -0.10683387f, 0.23464876f, 0.09728169f, 0.19131027f, 0.43671075f, 0.25241268f, 0.07908619f, 
    0.16797194f, 0.10514484f, -0.15149122f, -0.12109798f, -0.10521933f, -0.00951112f, 0.16676763f, 0.23613876f, 
    0.20480028f, -0.16553642f, 0.06276849f, -0.10237296f, -0.07122080f, -0.01748078f, 0.20916902f, 0.18815087f, 
    -0.04424629f, -0.08443996f, -0.06113265f, -0.11324030f, 0.02462137f, 0.14090650f, -0.16865829f, -0.05309555f, 
    0.01092954f, -0.07334736f, -0.01308240f, -0.03719021f, 0.17627512f, 0.06134273f, -0.09543309f, 0.10229879f, 
    0.10033812f, -0.17391182f, -0.02949028f, -0.03599653f, -0.05428379f, -0.14079630f, 0.05746986f, 0.02489536f, 
    -0.14865606f, -0.12553056f, -0.04325415f, 0.13835040f, -0.04187296f, -0.10658080f, -0.10468662f, -0.16561106f, 
    -0.04536748f, 0.00636096f, -0.15091662f, 0.06275719f, -0.05271948f, 0.12926857f, -0.02702338f, -0.11344404f, 
    0.01331819f, 0.09853209f, -0.06149446f, -0.12121310f, -0.02463814f, 0.10126099f, 0.05416526f, -0.09457786f, 
    -0.06764822f, -0.09875621f, 0.11808414f, -0.14745659f, 0.02551980f, 0.00314409f, 0.11884955f, 0.09813298f, 
    -0.00343957f, 0.04295694f, 0.16091563f, 0.02668083f, -0.00589887f, -0.14997220f, 0.04126580f, 0.03354434f, 
    0.05831439f, -0.16081700f, -0.16576697f, -0.07691982f, 0.02225807f, 0.04754757f, 0.03727908f, -0.11408596f, 
    0.05796889f, -0.06880449f, -0.16464341f, 0.07131087f, 0.08709124f, -0.11025110f, -0.12768732f, -0.08447518f, 
    -0.09106028f, -0.09481981f, -0.13275750f, -0.11265349f, 0.06786467f, 0.05724712f, 0.06396653f, -0.11106241f, 
    -0.07239441f, 0.08218449f, 0.04264635f, -0.02836771f, -0.04900743f, 0.12301347f, 0.05344748f, -0.01827851f, 
    -0.32440415f, 0.04885792f, 0.26366481f, -0.27475476f, 0.10515966f, -0.03043680f, -0.02910592f, 0.03842774f, 
    0.09768574f, 0.07466196f, -0.11023384f, -0.15288757f, 0.11449047f, -0.25410295f, -0.07447177f, -0.29071853f, 
    0.15457761f, -0.13860367f, 0.15155287f, 0.07621969f, 0.08267418f, 0.02798823f, -0.15325445f, -0.09365938f, 
    -0.13726199f, -0.00528528f, -0.04745826f, -0.10063190f, 0.30439907f, 0.27543271f, 0.06770515f, -0.27825284f, 
    -0.02204396f, 0.09809829f, -0.12534626f, -0.15136261f, -0.01992326f, -0.04813111f, -0.01520766f, 0.03103255f, 
    -0.02196818f, -0.06788342f, -0.02072557f, -0.05031583f, 0.11313894f, 0.06731128f, 0.04536076f, -0.02902028f, 
    0.06757307f, 0.03825789f, -0.17189021f, -0.15188517f, 0.08660332f, -0.07942946f, -0.08689523f, 0.03696173f, 
    0.10772058f, -0.12820399f, 0.16260648f, -0.10332593f, 0.02741155f, -0.17161961f, -0.01886908f, -0.11694945f, 
    -0.10823953f, 0.00050679f, 0.00639987f, 0.13624021f, 0.05174322f, -0.05992778f, -0.08276655f, 0.05773347f, 
    -0.15244062f, 0.07196172f, 0.10357002f, -0.11727992f, -0.17038025f, 0.11249953f, -0.04457859f, 0.10460321f, 
    0.08370950f, 0.04867386f, -0.12308123f, -0.09945510f, -0.09019887f, -0.15077335f, -0.08517878f, -0.12027977f, 
    -0.06451850f, -0.13662133f, -0.06373721f, -0.16162762f, -0.06952312f, -0.02724615f, -0.14552458f, -0.07625256f, 
    0.37732825f, 0.21046722f, 0.23845917f, -0.31068525f, 0.11682203f, -0.13618976f, -0.14288153f, -0.02165898f, 
    -0.07256480f, -0.06944274f, -0.17590173f, 0.30681798f, -0.28066736f, -0.03007906f, 0.07977275f, 0.22682007f, 
    0.16872256f, 0.15201053f, -0.35897496f, 0.33240944f, -0.15190376f, -0.01464092f, 0.15235002f, -0.20981549f, 
    -0.12433813f, 0.14192200f, -0.15371327f, 0.02023166f, 0.32098389f, 0.07055168f, 0.04659552f, -0.21424194f, 
    0.06112902f, 0.04659041f, 0.06348927f, 0.06462535f, 0.14305238f, -0.08100938f, 0.00376258f, -0.11880653f, 
    -0.09746756f, -0.05977742f, 0.04722974f, -0.16750570f, 0.02646402f, -0.14953558f, -0.02473622f, -0.15598114f, 
    -0.15293391f, 0.02907424f, 0.02071648f, 0.06860899f, -0.16983749f, 0.08430155f, 0.02003446f, -0.11680768f, 
    -0.00490204f, -0.18332346f, -0.11814573f, 0.10597475f, -0.00329800f, -0.10811113f, 0.10371988f, -0.11506269f, 
    -0.09334487f, -0.01739836f, -0.01305461f, 0.12680157f, -0.14888962f, -0.12970926f, -0.00305404f, -0.04953409f, 
    0.08147947f, -0.00294064f, 0.16094522f, -0.12843779f, -0.14365783f, -0.14744732f, -0.15656367f, 0.15125239f, 
    -0.10892756f, -0.04992637f, -0.07830867f, 0.07096948f, 0.07641725f, -0.09912317f, -0.01360032f, 0.06426172f, 
    -0.06267115f, -0.10498094f, -0.15554826f, 0.15095945f, 0.02887533f, -0.19016138f, -0.12069118f, -0.06022519f, 
    -0.10169968f, -0.30185899f, -0.16764221f, 0.39362279f, -0.10579114f, 0.06238951f, -0.16253328f, -0.22459231f, 
    -0.10401428f, -0.12198155f, 0.03688997f, 0.24708824f, -0.44915858f, 0.23749539f, 0.22590835f, 0.33517826f, 
    -0.03746570f, 0.03411914f, 0.03664002f, -0.02572138f, 0.09998474f, 0.06618849f, 0.13247526f, -0.37305209f, 
    0.07682207f, 0.08135733f, -0.11585470f, -0.01141297f, 0.32225308f, 0.02292923f, 0.21835014f, 0.29463416f, 
    0.39960378f, 0.14286518f, 0.14627302f, 0.05040939f, 0.09950135f, 0.12350298f, -0.06040723f, -0.15740070f, 
    -0.15949894f, -0.06292773f, -0.09416966f, -0.12658860f, -0.13316761f, 0.19544256f, -0.14515533f, 0.26279318f, 
    -0.01741868f, -0.10678545f, 0.24728811f, 0.22084154f, 0.06852126f, 0.00249977f, 0.12882456f, -0.05763015f, 
    -0.09945729f, -0.08735648f, -0.17726229f, 0.08459179f, 0.13485391f, 0.25192288f, 0.24675383f, -0.02912712f, 
    0.16840550f, -0.13699330f, 0.38867813f, -0.61640388f, -0.01302875f, -0.03078523f, 0.08929083f, -0.06757848f, 
    0.05844143f, -0.12751353f, -0.30269909f, 0.11579054f, -0.31320548f, 0.41822052f, 0.22989266f, -0.15318853f, 
    0.00218397f, 0.12681614f, -0.17378192f, 0.11288826f, -0.42109269f, 0.04149582f, 0.13974649f, 0.13252619f, 
    0.37915277f, 0.10111649f, -0.09635938f, 0.04947977f, 0.00984725f, -0.00971156f, 0.09861401f, 0.08954015f, 
    0.31957075f, 0.10402148f, 0.07146672f, -0.35441256f, 0.13401328f, 0.11017355f, -0.01057072f, -0.02957905f, 
    0.05237154f, -0.21584487f, 0.26498160f, 0.29374933f, 0.24179853f, 0.16146231f, 0.24473463f, -0.20400237f, 
    0.17036858f, 0.14236861f, -0.31410772f, 0.12201435f, -0.24754798f, 0.02813089f, 0.15927540f, 0.45223826f, 
    0.16777468f, 0.13392431f, 0.04156603f, 0.13172236f, -0.30511767f, -0.10643547f, -0.06511493f, -0.08130656f, 
    0.37414822f, 0.24849120f, 0.13252504f, -0.22811358f, -0.15725389f, -0.09702694f, 0.12862150f, 0.33132350f, 
    -0.11773372f, -0.01129359f, -0.24534477f, -0.06877159f, -0.06026850f, -0.17334598f, -0.04461251f, -0.07828578f, 
    0.12341701f, 0.00240360f, 0.34310013f, 0.24082744f, 0.03709139f, 0.02962336f, -0.15256864f, -0.16892982f, 
    -0.01149950f, 0.05155394f, 0.03772476f, 0.08451576f, 0.51489967f, 0.12513264f, 0.24332547f, -0.35199040f, 
    0.07421324f, 0.08726039f, -0.01480840f, -0.14844781f, 0.16904818f, -0.00138771f, -0.10375439f, -0.14847648f, 
    -0.04931019f, -0.08298519f, -0.11682352f, -0.10885142f, 0.01123422f, 0.08458609f, -0.04959782f, 0.03276622f, 
    -0.16456243f, -0.16763660f, -0.14208829f, -0.14945798f, 0.01041634f, 0.10646517f, 0.09007776f, 0.08738523f, 
    0.01486309f, -0.02952113f, -0.08289137f, -0.14845046f, -0.14847828f, 0.05360708f, -0.07138047f, 0.06531864f, 
    -0.22316505f, -0.25933564f, -0.11984209f, -0.00517609f, 0.06946478f, -0.16838580f, -0.07438529f, -0.09379790f, 
    0.13402070f, 0.25999942f, -0.13775745f, -0.15972942f, -0.28804079f, -0.12304808f, 0.19364858f, 0.41088787f, 
    0.09969909f, -0.11928476f, 0.07559039f, 0.12882234f, 0.21544175f, 0.04268325f, 0.08036906f, -0.24745896f, 
    -0.28695861f, 0.29140869f, 0.00456749f, -0.16167703f, 0.20351227f, 0.20985575f, -0.12409367f, 0.28462014f, 
    -0.44592452f, -0.08565135f, -0.17435536f, 0.44067860f, -0.04493739f, 0.11203430f, 0.16601896f, -0.00382255f, 
    -0.08280715f, -0.11207945f, 0.33219323f, -0.26333201f, -0.30415931f, -0.11285477f, 0.21830745f, 0.18501684f, 
    -0.13504876f, 0.04084893f, -0.00398109f, 0.10579391f, 0.10541969f, 0.02257820f, -0.16197999f, -0.19813842f, 
    0.21473438f, 0.11020160f, -0.06391299f, -0.10431037f, 0.19388205f, 0.16968384f, -0.04466348f, 0.12596026f, 
    0.61538190f, 0.30372480f, 0.16640060f, 0.24630298f, 0.07044727f, -0.14835364f, -0.12832446f, -0.21829170f, 
    -0.06203038f, 0.09184872f, -0.09524255f, 0.14062451f, -0.17108026f, 0.22132023f, -0.11986527f, 0.06589583f, 
    0.02064152f, -0.13366705f, -0.06873807f, 0.05529062f, -0.22550879f, -0.18717113f, 0.05351375f, 0.13916777f, 
    0.18829542f, -0.09686374f, 0.13829689f, 0.11608648f, -0.08895376f, 0.23138955f, 0.01163782f, -0.01555812f, 
    -0.50656021f, -0.29643196f, 0.09699660f, -0.38985789f, 0.15886097f, -0.00829306f, -0.08366626f, 0.48042864f, 
    -0.02191773f, 0.09933996f, -0.23343918f, 0.36216193f, 0.25664189f, 0.07634469f, 0.06100257f, 0.18043308f, 
    0.08626120f, 0.23987125f, 0.12137289f, 0.17913200f, -0.15162508f, 0.16133592f, 0.05571106f, 0.26792273f, 
    -0.21984379f, 0.18794778f, -0.15157466f, -0.01421302f, 0.27335152f, 0.10568585f, -0.18092290f, 0.04517667f, 
    -0.17923257f, -0.14686795f, 0.27423286f, -0.26463020f, -0.07296339f, 0.15845498f, 0.14076266f, 0.18673681f, 
    0.05759044f, 0.40204087f, 0.01711200f, -0.18769330f, -0.08348127f, -0.34794655f, 0.11790285f, 0.07087747f, 
    0.04593912f, 0.04795891f, 0.07302787f, 0.04936272f, 0.29101154f, -0.10890028f, -0.02170506f, -0.19467205f, 
    -0.12038486f, 0.24186784f, 0.13945694f, 0.16169265f, 0.23874266f, 0.26120111f, -0.24069132f, 0.11021955f, 
    -0.52484858f, 0.09852960f, -0.01025803f, -0.33002642f, 0.11310716f, -0.18098690f, -0.17271940f, 0.40118781f, 
    0.16565551f, -0.04803237f, 0.17909761f, -0.13409816f, 0.01003293f, 0.00692676f, 0.02931391f, 0.03710969f, 
    -0.03501406f, 0.26056001f, -0.02882330f, 0.05342842f, -0.34730455f, -0.16311151f, -0.11546968f, -0.16950417f, 
    0.32858443f, -0.06635617f, -0.03720568f, -0.01335726f, 0.25689167f, -0.33635205f, 0.15781750f, 0.20706552f, 
    0.34438246f, 0.34230888f, -0.08291396f, 0.05440551f, 0.16898401f, -0.16889223f, 0.16796237f, 0.08178720f, 
    -0.03216181f, 0.00379360f, 0.27555734f, 0.06192899f, 0.36357623f, -0.12406559f, -0.10524376f, -0.26041985f, 
    0.06869338f, -0.20483807f, 0.31601629f, 0.14231080f, 0.21885838f, 0.07386216f, -0.03597477f, 0.39961663f, 
    -0.14389583f, 0.02584591f, 0.10356512f, -0.01182981f, 0.04085240f, 0.16074160f, 0.32376119f, 0.04974861f, 
    0.03385285f, -0.16519752f, -0.05137999f, 0.13266046f, -0.16431725f, -0.01184463f, -0.09533163f, 0.13107714f, 
    -0.06804162f, 0.02294263f, -0.11607158f, -0.11147042f, -0.08195300f, -0.00031208f, -0.19420284f, 0.00698343f, 
    -0.00407095f, -0.05053790f, -0.00218864f, -0.03187226f, -0.18628818f, 0.01927575f, -0.01187605f, -0.18424976f, 
    -0.02423377f, 0.02885010f, 0.04974927f, -0.05169092f, -0.07191967f, -0.03383619f, 0.10365647f, -0.19674738f, 
    0.06802112f, -0.01835752f, 0.04273409f, 0.12455969f, 0.11333150f, -0.16748594f, -0.03976128f, -0.00039519f, 
    0.01307377f, 0.20491049f, -0.19091788f, -0.24416842f, -0.26589611f, -0.19142209f, 0.17778499f, 0.27237296f, 
    -0.11985637f, 0.01360556f, -0.11234380f, 0.18471989f, 0.11395922f, -0.03548281f, 0.11146029f, -0.42894578f, 
    -0.16919278f, 0.28321937f, -0.00323093f, -0.12866139f, 0.35618323f, 0.24622366f, -0.15298165f, 0.01255027f, 
    -0.17652452f, 0.17305209f, -0.23502080f, 0.42558694f, 0.06655911f, -0.17446661f, -0.05317440f, 0.26016140f, 
    -0.02754915f, -0.15925412f, 0.50149852f, -0.26678154f, 0.26564613f, -0.08355855f, 0.14170814f, 0.10906943f, 
    -0.01337908f, -0.10511814f, 0.21973202f, 0.02571278f, 0.42857864f, -0.05462550f, -0.12943862f, 0.46420276f, 
    0.14641680f, -0.08716266f, -0.11492109f, 0.16786711f, -0.35122073f, 0.15599607f, -0.09822554f, 0.16454005f, 
    0.07333270f, 0.25443009f, 0.16338739f, 0.27082765f, 0.07870812f, -0.12619755f, -0.17276587f, -0.33827665f, 
    0.10021707f, 0.27541134f, -0.16482352f, -0.20560998f, -0.09567731f, -0.12234142f, 0.10787801f, 0.26090437f, 
    -0.13375348f, -0.19841062f, 0.12314036f, 0.17467745f, 0.03809663f, 0.11829669f, 0.01146601f, -0.08592375f, 
    -0.03772669f, 0.20021702f, -0.18355775f, -0.04087842f, 0.04335248f, 0.17326756f, -0.20530237f, -0.26795733f, 
    -0.12168596f, -0.17250814f, -0.10998084f, 0.03870352f, -0.14693911f, -0.09687366f, -0.14712949f, -0.32104027f, 
    0.08057370f, 0.02363326f, 0.12478773f, 0.05756973f, -0.24383338f, 0.35505545f, 0.32358000f, 0.11884420f, 
    0.05797832f, 0.11915375f, -0.49436164f, 0.22265302f, -0.22835852f, 0.07452107f, 0.05143344f, -0.24465404f, 
    0.27172965f, 0.20804819f, 0.02963726f, 0.14645214f, -0.11305623f, 0.03485132f, -0.19755991f, 0.16988012f, 
    0.03476037f, 0.00420938f, -0.00576097f, 0.15240265f, 0.13645470f, 0.12855403f, 0.01044001f, 0.35455811f, 
    -0.04239569f, 0.18960723f, 0.36205536f, -0.07959039f, 0.17803334f, -0.14349559f, -0.09574790f, -0.24753921f, 
    0.08485425f, 0.03555495f, -0.11705461f, -0.11804546f, 0.29497811f, 0.11036094f, 0.11326208f, -0.41640118f, 
    0.39325672f, 0.15315017f, 0.02689733f, -0.05465757f, -0.16484712f, -0.10482617f, -0.22561768f, 0.16414499f, 
    -0.15553848f, -0.03439422f, -0.04269870f, -0.26966158f, -0.02353735f, -0.11018834f, 0.08682715f, -0.09201041f, 
    0.05356175f, -0.14773677f, 0.18907875f, -0.09916381f, -0.07788938f, 0.06623975f, 0.15395777f, -0.11538465f, 
    0.08736612f, 0.34207752f, -0.23876597f, -0.08643351f, -0.30700469f, -0.04440708f, -0.02757957f, 0.07842123f, 
    0.45591637f, 0.18914308f, 0.06456712f, -0.04808736f, -0.13865001f, -0.08843305f, -0.09268414f, 0.25041541f, 
    0.18960577f, -0.16996019f, 0.13240695f, -0.41851693f, 0.00402870f, 0.01221290f, 0.04291561f, -0.09220584f, 
    0.12831791f, 0.11037493f, 0.09338129f, 0.26194635f, 0.00546305f, 0.30936503f, 0.26936206f, -0.18859281f, 
    0.00604277f, -0.10726199f, 0.10702541f, -0.27184483f, 0.20160204f, -0.03625909f, -0.17319903f, 0.19815007f, 
    -0.11179907f, 0.07658386f, 0.16421528f, 0.08727616f, 0.16138086f, 0.16415559f, -0.10389644f, 0.06128258f, 
    0.00165900f, -0.16705328f, 0.06770910f, 0.12123429f, -0.10537641f, 0.03862846f, 0.12218662f, -0.09952132f, 
    0.02108614f, 0.06639662f, 0.01361640f, 0.01351077f, 0.08590066f, -0.17197469f, 0.04811099f, -0.15491651f, 
    0.06435490f, -0.11542104f, -0.12796649f, 0.04906297f, -0.11789414f, -0.03093469f, 0.08795183f, 0.01043386f, 
    -0.17018442f, -0.01100317f, -0.09931187f, 0.15571237f, 0.03943795f, -0.06439593f, -0.06322765f, 0.03328066f, 
    0.01851711f, 0.04056996f, -0.16950980f, 0.00091994f, -0.00644522f, 0.12967464f, -0.13245182f, 0.14339970f, 
    -0.02823870f, -0.02211125f, 0.16222292f, -0.01060663f, -0.13856339f, -0.10323329f, 0.02705042f, -0.06828211f, 
    0.04589431f, -0.14547929f, -0.09426752f, -0.04316084f, 0.10193419f, -0.05928648f, 0.07230563f, 0.16463046f, 
    -0.15541965f, -0.11215523f, -0.04900321f, 0.11882421f, -0.16645768f, -0.01750087f, -0.14629012f, 0.04778646f, 
    0.06134666f, 0.28580186f, 0.21311598f, -0.36172661f, 0.15673837f, 0.13455243f, 0.00414735f, 0.44708928f, 
    0.10035945f, 0.14261973f, -0.15130325f, 0.10396508f, 0.02380741f, -0.14457317f, -0.13881367f, -0.14118858f, 
    -0.09547780f, 0.11946882f, 0.41619453f, -0.04769200f, 0.10571742f, -0.16273277f, 0.08245002f, 0.03086243f, 
    -0.12086898f, 0.05199523f, 0.09990326f, -0.06675517f, 0.20325685f, -0.05816834f, 0.19002797f, -0.04890435f, 
    -0.49470431f, -0.08833634f, 0.24006675f, -0.09384871f, 0.14262196f, -0.08400132f, -0.12175840f, -0.15644588f, 
    0.02203715f, 0.06573219f, -0.00524949f, 0.16867840f, -0.39123473f, 0.12836818f, 0.31499055f, 0.27338248f, 
    0.00258666f, 0.01534754f, -0.07382938f, 0.01747750f, 0.09413745f, 0.07364046f, 0.04853574f, -0.25459164f, 
    -0.29507211f, 0.11593127f, -0.04614684f, -0.15276526f, 0.01447151f, 0.19159581f, -0.24199650f, 0.29421487f, 
    0.60199827f, 0.31036234f, 0.29949376f, -0.15474369f, 0.12062624f, -0.16625454f, -0.04816708f, -0.09153158f, 
    0.12375486f, -0.18677410f, 0.01752782f, 0.10100036f, 0.16566743f, 0.31445521f, 0.19143890f, -0.23767316f, 
    -0.02563715f, -0.10201850f, -0.04587682f, 0.21005109f, -0.29692379f, 0.00499541f, -0.02900236f, 0.32457158f, 
    0.07357657f, -0.17629278f, -0.04406999f, -0.14121719f, -0.05638273f, 0.05641599f, 0.17168777f, -0.28158104f, 
    0.33663008f, 0.09304649f, -0.07213385f, 0.49094883f, -0.10179662f, -0.04930034f, 0.01950448f, -0.32337323f, 
    0.13497150f, 0.06151037f, -0.06247461f, -0.02372172f, -0.30030856f, 0.10571633f, 0.10858456f, 0.27743849f, 
    -0.14110656f, -0.05185303f, 0.04321178f, 0.19406623f, -0.01881513f, -0.10418378f, -0.04760882f, -0.31504074f, 
    0.15857230f, -0.03161734f, 0.17078154f, -0.12141640f, 0.34590730f, 0.23869684f, -0.16385984f, -0.17855670f, 
    0.30911249f, 0.24838999f, -0.25720230f, 0.22070783f, -0.16266499f, -0.14095694f, -0.05637134f, 0.14698359f, 
    -0.07748143f, -0.35974199f, 0.20659105f, 0.25779277f, 0.09960022f, 0.38136733f, -0.06647891f, 0.06836218f, 
    -0.13966979f, -0.10632949f, -0.16650678f, 0.26263189f, -0.15221761f, 0.04841988f, 0.04076460f, 0.36156532f, 
    -0.00470851f, -0.10590976f, -0.06280685f, 0.07614423f, 0.08693098f, 0.09617221f, 0.23402445f, 0.20340951f, 
    0.30511114f, 0.32439104f, 0.23719968f, -0.20384604f, 0.14285280f, -0.03821395f, -0.12211138f, 0.31976894f, 
    0.13205774f, -0.19106825f, -0.25303692f, 0.28437573f, -0.02240566f, 0.13129291f, -0.10942487f, -0.16264965f, 
    -0.13965172f, -0.02006209f, 0.34485829f, 0.09668723f, 0.02313086f, -0.16047753f, -0.11017732f, 0.37519118f, 
    -0.22847892f, 0.04228889f, 0.07598407f, 0.10647780f, 0.31622261f, 0.22124641f, 0.15287657f, -0.19919157f, 
    -0.14110827f, -0.10876536f, -0.07109502f, -0.04816831f, -0.01971387f, -0.16402897f, -0.08252766f, -0.14609337f, 
    -0.17106344f, 0.12902740f, -0.09397197f, -0.01391350f, -0.13821416f, 0.14259855f, -0.07660347f, 0.06119246f, 
    0.02659135f, -0.07745032f, -0.09450089f, 0.01397539f, -0.16102558f, -0.12286147f, 0.15605542f, 0.04275704f, 
    -0.01423466f, -0.15829717f, 0.17477398f, -0.00335845f, 0.06245336f, 0.13872442f, -0.18386263f, 0.00982472f, 
    0.10337212f, -0.03541875f, 0.26412335f, -0.12209577f, 0.16982940f, -0.06218630f, 0.13215567f, -0.05543360f, 
    -0.09530696f, 0.22106408f, -0.12022962f, -0.21110338f, -0.09880861f, -0.26083145f, -0.03210212f, 0.08326414f, 
    -0.14128618f, 0.17364600f, 0.23015846f, 0.15731952f, -0.10413665f, -0.11985341f, 0.17532440f, -0.27666974f, 
    0.30058852f, 0.18235721f, 0.07648734f, 0.16142361f, 0.32721633f, 0.21174346f, -0.13287324f, -0.28428489f, 
    0.34345588f, 0.07797740f, 0.08340989f, 0.20701753f, 0.00725115f, -0.04666026f, 0.11125764f, -0.18552275f, 
    -0.14640181f, -0.19235343f, 0.20786266f, 0.07272950f, 0.08257442f, 0.40672418f, -0.04505473f, 0.18911408f, 
    0.03124839f, 0.14931519f, -0.04758739f, 0.06424449f, -0.36100608f, -0.02981419f, -0.01634963f, 0.46614462f, 
    0.28062335f, -0.14237186f, -0.12189548f, 0.10222258f, 0.03651325f, -0.08003207f, 0.23800908f, 0.11217833f, 
    -0.21076275f, 0.23223546f, -0.08712032f, -0.25316834f, 0.08827841f, 0.09474845f, 0.14010723f, 0.44064203f, 
    0.08240632f, 0.33336672f, 0.22387111f, 0.07999464f, 0.32658863f, -0.34707049f, -0.05216767f, -0.23531289f, 
    -0.11507931f, 0.32117924f, 0.12653278f, -0.07365786f, 0.33897343f, -0.07706599f, -0.02722176f, -0.02870935f, 
    0.24466768f, 0.14569788f, -0.08765843f, 0.05111412f, -0.16494939f, -0.07609302f, -0.31085941f, 0.00588378f, 
    -0.03616568f, -0.19734004f, 0.30004716f, -0.40292165f, -0.06120363f, -0.12831131f, -0.02687274f, 0.26005757f, 
    0.16324869f, 0.32745987f, -0.14348575f, 0.16758567f, -0.14281642f, 0.02315049f, 0.05696921f, -0.07384143f, 
    0.05729448f, 0.29540673f, -0.04100664f, -0.13158675f, 0.11291946f, -0.00278328f, -0.15691340f, -0.15538062f, 
    0.14251547f, 0.13301758f, 0.05548894f, -0.02875521f, 0.07186210f, -0.11564498f, -0.25911027f, 0.03003247f, 
    -0.22906376f, -0.25918674f, 0.25210649f, -0.10367829f, 0.14943478f, -0.09854475f, -0.04417989f, -0.17346118f, 
    -0.09403392f, -0.18067168f, -0.14871760f, 0.28843099f, -0.10707051f, 0.39842612f, 0.33673501f, 0.05900129f, 
    -0.12879957f, 0.18601528f, -0.18657972f, 0.06291089f, -0.15404621f, -0.01992993f, -0.05814919f, 0.04653424f, 
    -0.22698963f, -0.00581339f, 0.03333129f, -0.04844976f, 0.19676718f, -0.07822903f, -0.15955263f, 0.27686226f, 
    0.06197137f, 0.18811028f, -0.07316084f, 0.74004352f, -0.01318450f, -0.05593770f, -0.05149405f, -0.06645396f, 
    0.03563202f, 0.05457476f, -0.08895355f, -0.17735921f, 0.28942913f, -0.10583648f, -0.24609391f, 0.16498037f, 
    -0.02464470f, -0.02828442f, 0.30438727f, 0.21413785f, 0.01480075f, -0.11208164f, 0.05538224f, 0.04609425f, 
    0.03190030f, -0.14535271f, 0.07696362f, 0.12706596f, 0.18072587f, -0.05616185f, 0.35342041f, 0.18395391f, 
    -0.03919335f, -0.06231801f, -0.07594746f, 0.30178487f, 0.09032205f, 0.04885775f, 0.03860512f, -0.30419266f, 
    0.09433046f, 0.01778796f, 0.15011752f, -0.28709441f, -0.11781679f, 0.04330922f, 0.23503090f, 0.24694549f, 
    0.00903886f, 0.26980719f, -0.39559847f, 0.02047145f, 0.11510284f, 0.16427279f, 0.08049601f, -0.37045193f, 
    0.34854314f, 0.25302124f, 0.11136383f, 0.16570044f, -0.13332769f, -0.08026349f, 0.01320946f, 0.21484832f, 
    0.11638326f, -0.19913185f, -0.07709727f, 0.28596720f, -0.08145127f, -0.05802447f, -0.11574682f, 0.38736218f, 
    -0.06578869f, 0.17903727f, 0.01715159f, -0.13796064f, -0.03249941f, -0.03981380f, -0.10062391f, -0.11504625f, 
    0.09107801f, 0.12478546f, 0.16477016f, -0.23991229f, 0.12182172f, 0.15799063f, 0.14737175f, -0.09850100f, 
    0.50679183f, 0.03858256f, 0.09360468f, 0.16778828f, 0.26073828f, -0.03126030f, 0.05920213f, 0.30516014f, 
    0.21003447f, 0.22936662f, 0.08789180f, -0.17317888f, -0.04482050f, 0.12560667f, -0.04354639f, -0.04624027f, 
    0.16940431f, 0.46618000f, -0.01967014f, 0.11562580f, 0.30645370f, -0.18032116f, -0.21151130f, 0.07820667f, 
    0.03557576f, 0.04417686f, -0.16820669f, -0.11528344f, 0.44585961f, -0.13901496f, 0.00799249f, 0.27284119f, 
    0.10950489f, 0.06482898f, 0.01849862f, -0.05638772f, -0.44897562f, 0.07310471f, -0.26872629f, -0.07378416f, 
    -0.35247555f, -0.02036491f, 0.37778407f, -0.31325638f, -0.13982299f, 0.02722250f, -0.08142229f, -0.18373656f, 
    -0.15429279f, 0.03650872f, -0.05809293f, -0.23459738f, 0.04526059f, -0.05297184f, -0.26707274f, -0.06832404f, 
    0.12519124f, -0.02858509f, 0.07901518f, -0.00480828f, 0.09767777f, 0.12606753f, -0.15574966f, 0.38478923f, 
    0.01065733f, -0.11087883f, -0.14100984f, 0.14030623f, 0.16683406f, 0.19598708f, 0.31636244f, -0.13949123f, 
    0.09090161f, 0.04840310f, 0.18862353f, 0.00108856f, 0.13693087f, 0.09157591f, 0.13110374f, 0.23300402f, 
    -0.08076508f, -0.29091281f, 0.21055603f, 0.17241284f, 0.20643435f, 0.43409464f, 0.24367209f, -0.15993591f, 
    -0.11373139f, 0.11280958f, -0.03180136f, -0.05190456f, -0.08284969f, -0.16184819f, -0.06123081f, 0.52689052f, 
    0.09375808f, -0.10211299f, -0.11532006f, -0.11957291f, -0.26546681f, -0.15792184f, 0.14259210f, 0.13892530f, 
    0.06226629f, -0.03093507f, -0.01514340f, -0.05684213f, -0.13421695f, -0.16698998f, 0.10841469f, -0.00152917f, 
    -0.09573566f, -0.15204160f, 0.10940421f, 0.04278243f, 0.11290663f, 0.05349948f, -0.17044821f, -0.08238999f, 
    0.16766571f, -0.03445073f, 0.01401417f, -0.11666393f, 0.09782042f, 0.01102179f, 0.08327606f, -0.17334542f, 
    -0.09842076f, -0.08663102f, -0.03183588f, 0.12326901f, 0.09832537f, -0.12368795f, 0.06238881f, -0.12191384f, 
    -0.41933012f, 0.11347697f, -0.05993087f, -0.22513746f, -0.04008532f, -0.18166314f, 0.15111051f, 0.14934589f, 
    0.16256444f, -0.23614134f, 0.24568607f, 0.28680861f, 0.19686757f, 0.22286658f, 0.28365934f, 0.25969741f, 
    -0.07695698f, -0.05745740f, -0.07546061f, 0.29875228f, 0.01937369f, 0.03331221f, -0.07277355f, 0.14204089f, 
    -0.33032805f, -0.16728291f, 0.09841010f, -0.12721874f, -0.24381664f, -0.06849789f, 0.19457681f, 0.16118756f, 
    0.07797760f, -0.01769535f, -0.16053258f, -0.03837739f, 0.02477997f, 0.16465601f, -0.11222851f, -0.10386753f, 
    0.11293684f, -0.00968820f, 0.01927445f, -0.06898252f, -0.06990553f, 0.00887437f, -0.09018250f, -0.03428898f, 
    0.06085425f, -0.15059964f, 0.05741642f, 0.04290835f, -0.11260726f, 0.17241025f, 0.07524034f, -0.13921045f, 
    0.03271177f, -0.02828320f, -0.07632362f, -0.09879434f, -0.16972417f, 0.11832458f, -0.11008767f, 0.11553218f, 
    -0.23999907f, -0.05539481f, 0.16536359f, -0.46042565f, 0.03689633f, 0.06413448f, 0.02017883f, 0.33068886f, 
    -0.10492846f, 0.30094683f, 0.03832310f, -0.11988510f, 0.32302049f, -0.16631144f, 0.11411398f, -0.14014485f, 
    0.00230514f, 0.17529111f, -0.10494832f, -0.09777937f, 0.23161930f, 0.10708675f, -0.15539104f, 0.23267443f, 
    -0.16525662f, 0.20708756f, 0.11060985f, 0.05756894f, 0.11131503f, 0.17068176f, -0.38844186f, -0.05746124f, 
    -0.29744548f, -0.15513524f, 0.03745835f, -0.03383275f, -0.15811782f, 0.14946692f, -0.14488339f, 0.10714389f, 
    0.11549920f, -0.12004095f, -0.00671814f, 0.15933286f, 0.39594626f, 0.04970206f, 0.17820942f, 0.36901629f, 
    0.16248137f, 0.20838705f, -0.01561477f, 0.19837236f, -0.05112025f, -0.13732296f, 0.16273795f, 0.43230700f, 
    -0.25702244f, 0.09058630f, 0.09747682f, 0.05887691f, -0.09168243f, -0.13522857f, -0.09965364f, 0.34595248f, 
    -0.15046127f, -0.07699995f, -0.03093246f, 0.06031972f, 0.09556887f, 0.12332299f, 0.13422707f, -0.14157467f, 
    -0.04947118f, -0.10703293f, 0.03057925f, -0.08115885f, 0.03412758f, 0.15103766f, -0.07250039f, -0.14625478f, 
    0.09752449f, -0.01168678f, -0.01398245f, -0.06430219f, 0.06443293f, 0.03001755f, 0.16252066f, -0.01211884f, 
    0.03740513f, -0.01907751f, 0.12596406f, 0.07981378f, 0.02847417f, 0.06570607f, -0.10987084f, -0.17659019f, 
    0.02461423f, -0.19015422f, -0.08300867f, -0.04849985f, 0.13552395f, -0.17092073f, 0.06712187f, 0.00411004f, 
    0.11995754f, -0.11068210f, 0.08976326f, -0.15247527f, 0.06798333f, -0.10560504f, -0.10635918f, -0.00406682f, 
    0.14208311f, -0.13856284f, -0.15502273f, -0.13924141f, -0.10730558f, 0.01234422f, -0.08692575f, -0.07682034f, 
    -0.18137860f, 0.11944047f, -0.06264567f, -0.12485270f, 0.07626478f, -0.07443028f, 0.04028306f, 0.02508466f, 
    -0.04468073f, 0.03038145f, -0.26704213f, 0.40796250f, 0.03788383f, -0.15247254f, -0.03162657f, -0.11546998f, 
    -0.04123674f, 0.31759757f, 0.32042772f, -0.36432186f, 0.06945208f, -0.38387883f, 0.23122400f, -0.08981159f, 
    -0.03077860f, 0.14442769f, -0.33938432f, 0.09782147f, 0.39075252f, 0.06095678f, -0.13244863f, -0.25093198f, 
    0.13008265f, 0.15077753f, -0.01236225f, 0.15151033f, -0.21642452f, 0.13334976f, -0.14767465f, 0.17180622f, 
    -0.07716496f, 0.06606857f, -0.05202183f, 0.13162647f, -0.05853453f, 0.01706962f, -0.04946120f, 0.12134092f, 
    -0.12685141f, -0.04497163f, -0.07587203f, 0.08619776f, 0.07493550f, 0.05524448f, -0.20840152f, -0.08158743f, 
    0.09340106f, 0.02882328f, -0.03218881f, -0.04841800f, -0.03763801f, -0.03954189f, 0.05632970f, -0.05150185f, 
    0.06387886f, -0.07743963f, -0.00725314f, -0.07126541f, 0.10649101f, -0.21114051f, -0.17393520f, 0.05549175f, 
    0.40011090f, 0.18705791f, 0.25723344f, 0.28537896f, 0.06897796f, 0.06989040f, -0.15344779f, 0.35504311f, 
    -0.02175464f, 0.10797454f, 0.19776551f, 0.05086076f, 0.09884734f, -0.06617572f, -0.02042999f, -0.25232935f, 
    0.04581604f, -0.13877435f, 0.21427612f, -0.21103336f, -0.06129486f, 0.12984024f, 0.11469945f, 0.30793953f, 
    0.15939096f, -0.13372624f, -0.10917179f, -0.03072271f, 0.23382370f, -0.13003443f, 0.19270912f, -0.01671188f, 
    0.30217272f, 0.29800487f, 0.35135713f, -0.23594891f, 0.00185309f, -0.04341549f, 0.09896922f, 0.13747263f, 
    0.00149256f, 0.08964683f, -0.05689141f, 0.02986435f, -0.31883410f, 0.02785625f, 0.04412025f, -0.11001684f, 
    0.02412460f, -0.12571231f, -0.07611834f, 0.24687569f, -0.03887309f, 0.07137401f, -0.10060126f, -0.20077647f, 
    -0.04917684f, -0.02840193f, 0.06144371f, -0.04382225f, 0.04139700f, 0.19990619f, -0.02923083f, -0.07936701f, 
    -0.33207685f, 0.02117834f, 0.17115581f, -0.29446441f, -0.14045948f, -0.03899744f, 0.15034467f, 0.28345558f, 
    0.06831821f, -0.09221169f, -0.00777516f, 0.48511779f, 0.02543952f, 0.05913858f, 0.08143996f, 0.39631456f, 
    -0.07731762f, -0.02478600f, -0.24624065f, 0.23053707f, -0.18252243f, 0.04969887f, -0.14405589f, 0.29967126f, 
    -0.51499039f, 0.05439175f, 0.14534393f, 0.05786032f, 0.12836230f, -0.06231456f, 0.14796196f, 0.15233919f, 
    -0.12740652f, 0.23457201f, 0.23408841f, 0.00954449f, -0.05261264f, -0.14911215f, 0.00954178f, 0.26208317f, 
    0.09433691f, -0.24228893f, -0.13697508f, 0.03171155f, 0.10713162f, -0.15349837f, -0.34414032f, -0.33333191f, 
    0.10545801f, 0.14202693f, 0.26464751f, -0.09638897f, -0.13567118f, -0.05994393f, -0.14897849f, -0.17952265f, 
    0.02034959f, 0.09874963f, -0.01871073f, 0.12025585f, 0.34364930f, -0.02280111f, 0.35821387f, -0.08253243f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.06227375f, -0.03215328f, -0.02135636f, 0.05020332f, -0.15506129f, 0.02993349f, 0.02487018f, 0.18850625f, 
    0.04054759f, -0.02377804f, -0.08139453f, -0.09938910f, -0.06920340f, 0.19345447f, 0.26461384f, -0.17640947f, 
    0.24565111f, 0.07673422f, -0.07889047f, 0.22506069f, 0.25159597f, -0.08417102f, -0.22346300f, 0.11037324f, 
    0.01960226f, 0.04088074f, -0.12966011f, -0.00424109f, 0.09842137f, 0.03377610f, -0.06644992f, 0.05508680f, 
    0.02552278f, 0.03079661f, -0.07811872f, -0.12533177f, 0.14314616f, 0.06239845f, 0.05570294f, 0.07462818f, 
    0.06733441f, -0.09877414f, -0.02773499f, 0.28247920f, -0.00038376f, 0.03169030f, 0.08346956f, -0.13256693f, 
    -0.13006192f, -0.04025809f, -0.06000435f, 0.09101851f, 0.23393102f, -0.09971543f, 0.23410523f, -0.01291126f, 
    0.01990192f, -0.06968623f, 0.19885781f, -0.17245096f, 0.00084279f, 0.01792383f, 0.06960033f, 0.02966636f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04334268f, 0.09339575f, 0.05793076f, 0.07496923f, -0.17351454f, -0.04837362f, 0.05170089f, -0.10167953f, 
    0.00834958f, -0.11564700f, -0.04112205f, -0.06577058f, -0.17303029f, 0.22111776f, -0.17159472f, -0.07301569f, 
    -0.12996177f, -0.27396804f, 0.31026369f, 0.00414143f, -0.17670409f, -0.25847316f, 0.16973400f, -0.03677759f, 
    -0.13686013f, -0.02588862f, 0.14641652f, -0.02637682f, 0.02282330f, 0.19244184f, -0.05543885f, -0.14450736f, 
    -0.05228026f, -0.04373384f, -0.39782545f, 0.14357793f, 0.11787095f, 0.15437691f, -0.09363716f, 0.00156942f, 
    -0.00892618f, 0.32072943f, 0.19177940f, 0.02339150f, -0.24264567f, 0.18610552f, 0.09804891f, 0.11279624f, 
    0.63962436f, 0.20607740f, 0.07550175f, -0.04966781f, -0.22179513f, 0.16144244f, 0.04647575f, 0.17101328f, 
    -0.09179056f, 0.03811661f, 0.16891718f, -0.01282681f, 0.06840649f, -0.23718379f, 0.07184225f, -0.56773233f, 
    0.01527059f, -0.08484642f, 0.08778401f, 0.01517156f, -0.10766981f, -0.02900055f, -0.11530881f, -0.05350043f, 
    0.09310458f, -0.04591290f, 0.00252720f, -0.00337676f, 0.05815801f, -0.01554841f, -0.12414007f, 0.03823487f, 
    0.03161889f, -0.14990285f, -0.05626866f, -0.07731772f, 0.07639360f, -0.03848049f, 0.01392744f, 0.07064393f, 
    -0.06935681f, -0.06508306f, 0.07962294f, 0.01400952f, -0.10721494f, 0.09580649f, 0.04090913f, 0.01481838f, 
    -0.12335913f, -0.07586929f, -0.03524832f, 0.04733076f, -0.04038821f, 0.08719107f, -0.08646375f, 0.05377879f, 
    0.07938565f, -0.11048647f, 0.04596741f, -0.01527085f, -0.02388468f, 0.02073156f, -0.01423679f, 0.07169025f, 
    0.04090573f, 0.04221456f, -0.02211161f, 0.06502806f, 0.04748794f, -0.05181094f, -0.04660045f, 0.00170324f, 
    0.06493904f, 0.11366270f, -0.01340354f, 0.05538834f, -0.03835634f, -0.11583573f, -0.10516021f, -0.00162794f, 
    -0.14651030f, 0.02160057f, 0.10267925f, -0.00456617f, -0.06013847f, -0.08690780f, -0.12059204f, -0.05701843f, 
    -0.06889205f, -0.07903537f, -0.01498577f, 0.00535408f, -0.10062693f, -0.10718990f, -0.05573136f, -0.08183680f, 
    -0.01497445f, 0.09361179f, 0.08411302f, -0.00076327f, -0.04136535f, 0.04031069f, 0.12237591f, -0.10932461f, 
    0.06225032f, 0.05422650f, 0.05627268f, -0.03352310f, -0.04232007f, 0.02913401f, -0.09638850f, 0.02705173f, 
    -0.02589899f, -0.14798661f, -0.09432226f, 0.01937800f, -0.08640625f, -0.04795564f, -0.17624113f, -0.00149353f, 
    -0.13810199f, -0.10872711f, -0.04155210f, -0.00329052f, -0.09091690f, 0.04526084f, -0.06385481f, 0.01770007f, 
    0.01175333f, 0.03227527f, 0.07673669f, -0.07581107f, -0.02415811f, -0.07521658f, -0.14436238f, 0.02680234f, 
    0.02907601f, 0.11630076f, 0.04945970f, -0.04024336f, -0.10680746f, -0.03335255f, -0.12832604f, 0.03308107f, 
    -0.14320102f, 0.02085710f, 0.03111249f, -0.08575787f, 0.02451254f, -0.06911874f, 0.07413426f, -0.10495307f, 
    0.02695993f, -0.05418327f, 0.08035357f, -0.14498423f, -0.08046430f, -0.08787080f, 0.05296107f, -0.05046985f, 
    -0.10578285f, -0.12009567f, 0.05812625f, 0.06975213f, -0.05245425f, -0.02567315f, 0.01876399f, -0.02883579f, 
    -0.13299501f, -0.06942490f, -0.07696758f, 0.05539973f, 0.07793386f, 0.06825545f, -0.09354211f, 0.02826734f, 
    -0.00616042f, -0.05061004f, -0.04093155f, -0.11300490f, -0.02292572f, 0.04018242f, 0.10109809f, 0.03067671f, 
    -0.11281202f, -0.05703162f, -0.12398554f, -0.01216818f, -0.11954574f, 0.10836422f, -0.02921528f, 0.06422126f, 
    -0.07055007f, 0.01781441f, 0.08786717f, 0.08689930f, -0.08830660f, -0.07950477f, -0.10898920f, 0.02081768f, 
    -0.05416395f, -0.02697524f, -0.08559322f, -0.02786890f, 0.08080561f, -0.02402904f, -0.00069288f, 0.00942865f, 
    0.23044956f, 0.11017133f, 0.07334314f, 0.04295495f, 0.09748615f, -0.08639157f, 0.05213596f, 0.11253125f, 
    0.02324402f, -0.12910245f, 0.06725682f, 0.27857029f, 0.22374101f, 0.14390986f, -0.00172179f, 0.05933505f, 
    -0.08527301f, 0.04657513f, 0.23619127f, 0.03551532f, -0.11603907f, 0.07558054f, 0.05558224f, -0.14744599f, 
    -0.10734466f, 0.24393469f, -0.04307682f, 0.17586973f, -0.28308097f, -0.11550815f, -0.10582665f, -0.12058675f, 
    -0.09804197f, -0.15024845f, -0.00970307f, 0.53576303f, 0.03321872f, 0.38864946f, 0.10851504f, -0.03714811f, 
    -0.11282311f, 0.26764888f, -0.17626847f, -0.15962259f, 0.24462800f, 0.08060517f, -0.13090083f, -0.40326729f, 
    -0.26963878f, 0.16267951f, 0.28343308f, 0.00223137f, 0.42318460f, -0.04405373f, -0.14822657f, 0.24241443f, 
    -0.07456157f, -0.04802900f, -0.09868826f, -0.10067206f, 0.04580052f, 0.18816470f, 0.30302715f, 0.15554416f, 
    0.02488381f, -0.08874097f, 0.07358573f, 0.03638317f, -0.00659989f, -0.00737366f, 0.10413523f, 0.04442905f, 
    0.02231968f, -0.06040134f, -0.10544425f, 0.02503661f, -0.02601918f, 0.06522885f, 0.07360583f, -0.01049018f, 
    -0.00008989f, 0.01345820f, -0.16711594f, -0.05578741f, -0.10142612f, 0.14003706f, -0.06684037f, 0.10651591f, 
    0.02295459f, -0.08058021f, -0.03744387f, 0.06483202f, -0.14240538f, -0.12148020f, -0.05442873f, 0.05791207f, 
    0.08240753f, 0.05991484f, 0.04460130f, -0.04385679f, -0.11620643f, -0.06940492f, 0.06295706f, 0.09767161f, 
    -0.01418453f, -0.08032606f, 0.03039294f, -0.14780299f, -0.06771707f, 0.07163741f, -0.14193445f, -0.07979642f, 
    0.02590722f, -0.10261850f, 0.07979308f, -0.03814267f, 0.00775143f, -0.02324218f, -0.03314124f, 0.05285936f, 
    0.00110722f, 0.03259103f, -0.11318890f, -0.07953170f, -0.11112383f, 0.05713657f, 0.12722442f, -0.01479434f, 
    -0.03363745f, -0.01602523f, -0.13408783f, 0.12553865f, -0.26270717f, -0.08756116f, 0.11027128f, 0.09785508f, 
    0.03164598f, 0.05215636f, 0.10825197f, -0.14744715f, 0.27231312f, 0.15191434f, -0.02099739f, -0.11720261f, 
    0.23328528f, 0.23115782f, -0.14778343f, -0.00021795f, 0.24012242f, 0.36014399f, -0.18646987f, -0.03456283f, 
    0.27644354f, -0.02047816f, -0.08922651f, 0.39962280f, 0.26361915f, 0.33131528f, 0.08934360f, 0.01658517f, 
    -0.04257093f, -0.08503155f, 0.13329306f, -0.17427769f, 0.02478277f, -0.07672783f, -0.20937927f, -0.07805621f, 
    0.07801570f, -0.12172359f, 0.31111756f, 0.35037965f, 0.13609372f, -0.27686131f, 0.32020038f, -0.05678181f, 
    0.12854086f, -0.35693571f, 0.05735127f, -0.11042801f, 0.04597675f, 0.00191569f, 0.24198651f, 0.16639711f, 
    -0.11404019f, 0.10059919f, 0.20223919f, -0.00670469f, -0.24732240f, 0.08179380f, 0.12951395f, -0.37639755f, 
    0.20776498f, -0.02716979f, -0.02493555f, -0.12160932f, -0.17121847f, -0.08170068f, 0.07496706f, -0.14384983f, 
    -0.06926710f, -0.02810345f, 0.16700020f, -0.10134406f, 0.19967850f, 0.14724626f, -0.18985255f, 0.04745881f, 
    0.01682163f, 0.20982589f, -0.15866895f, -0.05455932f, -0.01496316f, 0.59629375f, -0.19512650f, -0.09799513f, 
    -0.11795434f, 0.22019739f, -0.21055941f, 0.23165737f, 0.14892700f, 0.31348664f, 0.05899325f, -0.04681232f, 
    0.12335433f, -0.06304175f, 0.08914725f, -0.14829208f, -0.07607582f, 0.17287014f, -0.07025883f, -0.02272437f, 
    -0.04402426f, 0.21610466f, -0.07538833f, 0.07488230f, 0.26773050f, 0.03813159f, 0.15826598f, 0.15010796f, 
    -0.32395452f, -0.12049025f, 0.25601390f, 0.06733718f, 0.27806711f, 0.13143383f, 0.01884096f, 0.10898843f, 
    0.00073316f, 0.06592203f, 0.10871624f, 0.00102475f, 0.19557631f, -0.10954276f, -0.03159953f, 0.14136490f, 
    0.11335730f, 0.11384085f, 0.09126784f, 0.00560182f, -0.00710870f, 0.06533243f, -0.00983012f, 0.10822558f, 
    -0.03894773f, -0.08825624f, 0.17888118f, -0.20041807f, -0.41782194f, -0.17268087f, 0.10332907f, 0.11017375f, 
    0.30992743f, 0.36241716f, -0.29639456f, 0.15327236f, 0.18773589f, 0.45098406f, 0.05087012f, -0.03633830f, 
    0.08826157f, 0.25235182f, -0.12955916f, 0.08786120f, 0.32021523f, 0.17855479f, -0.32278508f, -0.08613029f, 
    0.04993978f, 0.00549425f, -0.02702510f, -0.59096158f, 0.00678892f, 0.10937867f, -0.19607486f, -0.09183343f, 
    -0.06021001f, -0.02723253f, 0.35626706f, 0.07763983f, -0.15370816f, 0.27879432f, 0.26494300f, 0.33317637f, 
    -0.05100095f, -0.41031429f, -0.09481293f, -0.08809694f, -0.00325987f, 0.08779355f, 0.03747163f, 0.20225601f, 
    0.07357348f, 0.00600824f, 0.36155972f, 0.10079697f, -0.10465929f, -0.23673451f, 0.10835647f, 0.03808988f, 
    0.21333912f, -0.06615363f, -0.08973813f, -0.00291565f, -0.27946934f, 0.09649889f, 0.01083562f, 0.13813059f, 
    0.01179864f, -0.00261401f, 0.18722273f, -0.04443372f, 0.14779601f, 0.23806730f, -0.02364556f, 0.04368404f, 
    0.03152415f, 0.37885174f, -0.03241194f, 0.06868718f, -0.21451084f, 0.11350815f, 0.03526898f, 0.01222266f, 
    0.06274721f, 0.04817423f, -0.11727237f, 0.16202562f, 0.14926724f, 0.27774024f, -0.16251242f, 0.02785237f, 
    0.02765538f, -0.19435637f, 0.24098340f, 0.05735094f, 0.02025406f, 0.24547730f, -0.11871002f, -0.04240927f, 
    -0.08756038f, 0.29465675f, -0.12229068f, -0.11004951f, 0.27354753f, -0.10607348f, 0.32187834f, 0.09078002f, 
    -0.29173309f, -0.23121700f, 0.18112674f, 0.11727341f, 0.29938835f, 0.01665319f, -0.45659795f, 0.10496002f, 
    0.03282602f, 0.14214745f, 0.24224384f, -0.07464564f, -0.00942297f, 0.01527193f, 0.05167312f, 0.05367453f, 
    0.03305942f, -0.03512296f, 0.07093692f, 0.08542359f, 0.46083832f, -0.10372131f, -0.00932986f, 0.15247886f, 
    0.11985721f, 0.09265804f, 0.22752029f, 0.31909397f, 0.03305114f, -0.22161360f, 0.18352166f, -0.11816132f, 
    0.35453036f, 0.15216102f, 0.04797257f, 0.17365758f, 0.06055791f, 0.05962071f, -0.19107498f, -0.09696540f, 
    0.32676929f, -0.29295099f, 0.24029271f, 0.08322329f, -0.41774300f, -0.13304687f, -0.11993859f, -0.03754819f, 
    -0.08161482f, 0.12249254f, 0.22979081f, 0.03432469f, 0.19697739f, 0.05014594f, 0.20778109f, 0.04883137f, 
    0.05190578f, -0.00859260f, -0.24017915f, 0.06582613f, 0.36173704f, 0.28638458f, 0.07061146f, -0.29065096f, 
    -0.18319850f, 0.34214208f, -0.02963864f, -0.02035966f, 0.25225529f, -0.06311869f, -0.15239388f, 0.12267121f, 
    0.00741866f, 0.06762898f, -0.20286766f, 0.08184877f, -0.16823372f, 0.22197740f, 0.36285824f, 0.26882797f, 
    -0.12257312f, 0.02974427f, 0.11962314f, 0.04682408f, -0.06653129f, 0.07097571f, 0.00683674f, 0.09609391f, 
    0.01017185f, 0.11249614f, 0.05269627f, -0.03857954f, -0.04872779f, -0.05402743f, -0.09247094f, -0.04464428f, 
    0.09199409f, -0.05451852f, -0.09443671f, -0.10874660f, -0.03687809f, 0.03324346f, -0.12028815f, 0.01523444f, 
    -0.12603287f, -0.13465945f, -0.03483696f, -0.08179145f, -0.03261283f, 0.07698869f, 0.08592167f, 0.10041121f, 
    -0.08055499f, 0.00629738f, -0.02562603f, -0.10753656f, 0.10586509f, 0.07856605f, -0.03571345f, 0.04341047f, 
    -0.04628891f, -0.05652297f, 0.03925194f, -0.10444269f, 0.03358429f, 0.01523445f, 0.06846070f, 0.01574659f, 
    0.05054319f, -0.02822499f, 0.10400733f, -0.07738025f, 0.08021618f, -0.09272864f, 0.08027069f, -0.00090273f, 
    0.09629959f, 0.04368569f, 0.01444966f, -0.00751486f, 0.04522789f, -0.03727642f, -0.02087542f, -0.04374863f, 
    0.06345712f, -0.05794859f, -0.09592886f, -0.01730922f, -0.27220696f, -0.09877101f, -0.09414448f, 0.09228804f, 
    -0.13137902f, 0.06556809f, 0.32788092f, 0.07334180f, -0.07136010f, 0.14209998f, 0.10463729f, -0.07990815f, 
    0.24506614f, 0.25933444f, 0.23061511f, -0.11035852f, 0.16920954f, -0.43558460f, 0.09762934f, -0.10047216f, 
    0.10123499f, -0.02313757f, 0.21045639f, 0.24009670f, 0.00337490f, 0.06743598f, 0.22793484f, -0.07339562f, 
    0.01616500f, -0.18364787f, 0.15481843f, -0.01782041f, 0.35944629f, 0.10950099f, 0.00095482f, -0.00593032f, 
    0.11719228f, -0.12310984f, 0.08557283f, -0.05555899f, 0.06802060f, -0.24929290f, 0.26189324f, -0.15144283f, 
    0.13953479f, -0.37602341f, -0.08608085f, -0.06337778f, 0.00580994f, 0.07903324f, -0.08936244f, -0.10750014f, 
    0.08897080f, 0.01514391f, 0.36434963f, -0.03783188f, -0.34288406f, 0.26062712f, -0.16213632f, -0.33258432f, 
    0.09603160f, 0.11668640f, -0.11648167f, -0.12836638f, -0.16819860f, -0.05932486f, -0.06434537f, 0.01135726f, 
    -0.17421454f, 0.14537533f, -0.11999642f, -0.10191858f, 0.28709424f, 0.18270297f, -0.01389609f, -0.04883699f, 
    -0.25829899f, 0.08339668f, -0.10136187f, 0.07333581f, 0.08246776f, 0.32592031f, 0.01312719f, -0.09962204f, 
    -0.19553491f, -0.01758206f, -0.21060902f, -0.06391719f, 0.31913745f, 0.33937904f, 0.40936822f, -0.14584713f, 
    -0.01661219f, 0.24835941f, -0.20839503f, 0.08641012f, -0.09679012f, -0.12672085f, 0.02771630f, -0.03489699f, 
    0.03351439f, 0.03321210f, 0.32302999f, 0.41817939f, -0.07780956f, -0.17551883f, -0.05130813f, 0.52166492f, 
    0.08247427f, 0.08742362f, 0.27879596f, -0.11519805f, -0.10155523f, -0.11852250f, 0.25315189f, 0.06165383f, 
    -0.07154600f, -0.00360042f, -0.18511967f, 0.01056601f, 0.44220006f, -0.13220975f, -0.14142458f, 0.35050654f, 
    -0.12139145f, -0.09472719f, -0.03970372f, 0.05152505f, 0.17123097f, -0.04819611f, 0.00628713f, 0.30019251f, 
    0.12716568f, 0.08128104f, 0.14225563f, 0.12937738f, 0.35355964f, -0.00599183f, 0.21111813f, 0.07522385f, 
    0.19929831f, -0.31736949f, -0.06264655f, 0.30458543f, 0.12382058f, 0.28813812f, -0.01739583f, -0.03459484f, 
    0.16891664f, -0.40377951f, 0.09115260f, 0.01806002f, -0.34329990f, 0.03761176f, -0.23308165f, 0.04890032f, 
    0.02595745f, 0.13569765f, 0.04175765f, 0.21114656f, 0.02732852f, 0.11934437f, 0.06122392f, -0.05463035f, 
    0.26124761f, -0.02019814f, -0.12956665f, 0.04737529f, 0.24511349f, -0.05960379f, 0.04859845f, -0.08908024f, 
    -0.18353395f, 0.03161192f, -0.15293537f, 0.09432550f, 0.19084792f, -0.10981025f, -0.12928154f, 0.21667454f, 
    -0.03453283f, -0.15145312f, -0.18104491f, 0.02954123f, -0.20313279f, 0.10808437f, 0.28966177f, 0.27978781f, 
    -0.11503346f, -0.12164621f, -0.00008391f, -0.03318492f, 0.11264285f, -0.07620773f, 0.10744378f, 0.01737200f, 
    0.10987359f, -0.10052632f, -0.07446213f, -0.01165497f, -0.00203728f, -0.12348513f, -0.00109491f, 0.11181602f, 
    0.01364096f, 0.11495727f, -0.00133543f, -0.08406959f, 0.09848462f, -0.08091136f, 0.09808017f, 0.08415417f, 
    -0.03258582f, -0.08154710f, 0.01613743f, -0.07967643f, 0.09592733f, 0.10158328f, -0.08980523f, 0.01528081f, 
    -0.08110255f, -0.03979641f, -0.10730451f, 0.09941078f, 0.01591345f, 0.07137924f, -0.12091628f, -0.07654473f, 
    -0.09782529f, -0.00087807f, -0.12054345f, -0.03307877f, -0.11193115f, 0.06734366f, 0.04924162f, -0.10550861f, 
    0.05380039f, 0.02145994f, 0.01963058f, 0.02715661f, -0.07948739f, -0.09501186f, -0.10515894f, 0.07340088f, 
    -0.04851043f, -0.09656377f, 0.01170443f, 0.01934966f, -0.02403203f, -0.13199785f, -0.11564606f, -0.11147706f, 
    -0.09397216f, 0.05889861f, -0.08148362f, 0.10964105f, 0.01669377f, 0.06229922f, 0.03812636f, -0.10703193f, 
    -0.00612973f, -0.11521335f, 0.01622290f, -0.04048710f, -0.12065866f, -0.10555401f, 0.09131245f, -0.08283114f, 
    -0.02488123f, -0.01878540f, -0.00066876f, 0.05916126f, -0.14921546f, 0.00011814f, 0.03980318f, -0.10215151f, 
    -0.09595506f, 0.01801148f, 0.00990820f, 0.11089775f, 0.00569471f, -0.11619964f, 0.00320064f, 0.12060121f, 
    -0.05703211f, -0.03182018f, 0.08854875f, -0.04789265f, -0.04639815f, 0.01670443f, -0.05634267f, -0.01063193f, 
    -0.12378684f, 0.02924146f, -0.04506629f, 0.08106952f, -0.04561907f, 0.04244414f, -0.10773243f, 0.05446413f, 
    0.04829127f, 0.05364345f, -0.07806217f, -0.11495037f, -0.11390875f, 0.09641443f, -0.03801720f, -0.07102095f, 
    -0.06382109f, 0.03972220f, -0.13570270f, 0.06645522f, -0.08834996f, -0.11036932f, -0.10216849f, -0.01902360f, 
    -0.05003968f, -0.11220120f, 0.10550026f, -0.07655919f, 0.02700513f, -0.02220538f, -0.10697056f, -0.01646622f, 
    -0.08447148f, -0.02782713f, -0.00214885f, -0.05676114f, 0.03281252f, 0.01945801f, -0.11454198f, -0.10002558f, 
    0.03863601f, -0.10644174f, 0.03913355f, -0.09435031f, -0.00661367f, -0.05254215f, 0.04372643f, -0.08519831f, 
    0.01602009f, 0.09934404f, 0.01834452f, 0.04389608f, -0.01785234f, -0.12434043f, -0.09540490f, -0.08504073f, 
    0.08736190f, 0.00632595f, -0.16000952f, -0.13451470f, 0.06893905f, 0.04010435f, -0.03330289f, 0.01542504f, 
    -0.06520092f, -0.11691009f, -0.02425781f, -0.07787886f, 0.00085770f, -0.08479848f, -0.11718478f, -0.10373081f, 
    -0.11040512f, 0.08560459f, -0.10775790f, -0.11401196f, -0.03902969f, -0.07051598f, 0.03336474f, 0.10189649f, 
    -0.02367720f, 0.11610313f, -0.07391921f, 0.08057639f, -0.13523400f, -0.05138839f, -0.10867871f, 0.02758667f, 
    -0.04648092f, 0.05089730f, 0.11775173f, -0.03714843f, 0.06022595f, 0.10153267f, -0.03035778f, -0.12770972f, 
    0.08859538f, 0.11106201f, -0.06106938f, -0.06491387f, -0.04327666f, -0.07650888f, -0.12596844f, 0.05957541f, 
    -0.12091922f, 0.00875318f, 0.08000830f, -0.08889028f, -0.01524190f, 0.02573876f, -0.04167780f, -0.06050937f, 
    -0.03778693f, -0.09910110f, -0.01143331f, -0.10887033f, 0.10702820f, -0.08947940f, -0.13203719f, 0.03161116f, 
    -0.06346071f, 0.02616716f, -0.06273650f, 0.02970076f, -0.05667643f, -0.11255464f, 0.08287438f, 0.10094346f, 
    -0.00595346f, 0.01906210f, -0.02131604f, 0.05388983f, -0.07812907f, -0.10202621f, 0.11116938f, 0.03808867f, 
    -0.06140673f, 0.04481446f, -0.04868041f, -0.04006087f, -0.02867127f, -0.06046842f, 0.08232156f, -0.02572978f, 
    -0.10129463f, 0.07970715f, 0.08905959f, 0.07959805f, 0.03594862f, -0.00695443f, 0.10670186f, 0.03427247f, 
    -0.15699117f, -0.09579554f, 0.05062713f, 0.07105226f, 0.13038847f, -0.11330990f, -0.05479160f, 0.13647877f, 
    0.08292390f, -0.09251911f, -0.17438322f, -0.08653352f, 0.42524558f, 0.19580437f, 0.07351037f, -0.08816375f, 
    0.08165634f, -0.31105810f, 0.05174490f, 0.24145480f, 0.29366535f, -0.28554982f, -0.09196073f, -0.04851452f, 
    0.10274847f, -0.26946497f, 0.12044811f, 0.14141248f, -0.18576239f, 0.03958013f, 0.41224915f, -0.07972468f, 
    -0.01818499f, 0.16892897f, 0.28232640f, 0.29308233f, -0.00273162f, -0.28844097f, 0.20521320f, -0.03502154f, 
    0.25954300f, -0.21290748f, 0.02949348f, 0.45575717f, 0.26821351f, -0.52928555f, -0.00400186f, -0.49818569f, 
    0.14149714f, -0.07754166f, 0.01550563f, -0.07645460f, 0.02828302f, 0.05442652f, 0.46636620f, 0.10793430f, 
    0.03670431f, -0.06036964f, -0.25311750f, -0.00891177f, -0.03932061f, 0.15097310f, 0.20559615f, -0.21357767f, 
    -0.16829441f, 0.02997231f, 0.04759063f, 0.06066653f, 0.27577832f, 0.03905529f, 0.07093553f, 0.08227014f, 
    -0.11732649f, -0.11964427f, -0.27796841f, 0.17376423f, -0.19077715f, -0.11459789f, 0.28290102f, -0.04942544f, 
    0.21475501f, 0.18247801f, -0.04403891f, 0.01018768f, 0.25774080f, -0.11653902f, 0.11481594f, -0.08628414f, 
    0.19583838f, 0.17183353f, 0.46119806f, -0.15759896f, 0.05075795f, -0.25359574f, -0.19530118f, -0.11548225f, 
    0.02952503f, 0.01560683f, -0.14256257f, 0.05722873f, 0.24441324f, -0.20102185f, 0.12191129f, 0.09815582f, 
    0.35447529f, -0.26431197f, 0.22886555f, -0.06347304f, -0.32504177f, 0.15755232f, 0.05492615f, -0.19191121f, 
    0.47139254f, 0.00539467f, -0.35733092f, -0.06983438f, -0.14105034f, -0.02611314f, 0.31004691f, -0.00808564f, 
    -0.00398615f, 0.06207280f, 0.14536010f, 0.09493033f, -0.21668303f, 0.22219613f, -0.16019262f, -0.12803656f, 
    -0.02041939f, -0.04614617f, 0.07965575f, 0.03294674f, 0.11704011f, 0.08776639f, 0.12421818f, -0.12458282f, 
    -0.03939591f, 0.06588238f, -0.13410828f, -0.09800430f, -0.12093129f, -0.12663588f, 0.01345753f, -0.09272043f, 
    0.10213476f, 0.06156998f, -0.07147978f, -0.08994149f, -0.00852257f, 0.01959297f, -0.06451278f, 0.10855260f, 
    -0.02594256f, -0.14321704f, 0.03829129f, 0.11178489f, -0.12152287f, -0.16191310f, 0.01735610f, -0.11875206f, 
    0.07640159f, -0.06611716f, 0.00044674f, -0.09266520f, -0.06967346f, 0.06933548f, -0.11738443f, -0.12810856f, 
    -0.07362736f, -0.02932153f, 0.02050213f, 0.08652084f, 0.14105730f, 0.04928769f, 0.00870610f, -0.06812829f, 
    -0.00467463f, -0.02463235f, 0.05806225f, -0.02021259f, -0.02625375f, -0.04218695f, -0.00206623f, -0.08297467f, 
    -0.07079807f, -0.02466442f, 0.09041460f, 0.04928159f, 0.07658890f, -0.03254014f, -0.01664993f, 0.02162822f, 
    0.02409019f, 0.07971296f, -0.10678980f, 0.10638727f, 0.49573857f, 0.09057325f, -0.03621799f, -0.01687336f, 
    0.01782953f, -0.07577164f, 0.18597631f, 0.17494729f, -0.44554636f, -0.06266761f, 0.11304652f, -0.04260093f, 
    0.03924911f, 0.07052351f, 0.10568041f, 0.04703378f, 0.08632582f, -0.33595091f, 0.27900282f, -0.02886322f, 
    0.19297667f, 0.31828761f, -0.04782819f, -0.25147334f, 0.27430317f, -0.16986974f, 0.06764418f, -0.04627449f, 
    -0.06368156f, 0.14143090f, -0.10459252f, -0.08888565f, 0.18756235f, 0.21252552f, 0.10168388f, -0.03258225f, 
    0.11875355f, -0.12602349f, 0.14813583f, -0.09899396f, -0.13903095f, 0.22071357f, -0.00952120f, 0.42424747f, 
    -0.14292496f, 0.04828554f, -0.02078548f, 0.07922855f, -0.12843181f, 0.07058819f, 0.07343760f, 0.04664339f, 
    0.03660323f, 0.13046601f, 0.21909636f, -0.14228907f, 0.47015259f, 0.13355593f, -0.05512558f, 0.45351559f, 
    -0.09929332f, -0.01473035f, 0.02087060f, -0.00362872f, -0.06206664f, -0.06532936f, -0.07431683f, 0.08391547f, 
    -0.07116249f, 0.03949896f, -0.11075437f, 0.00565633f, 0.05767784f, -0.05952578f, 0.00379210f, -0.01282142f, 
    0.05073683f, -0.02018133f, 0.05708939f, -0.13173878f, -0.07645778f, 0.06755807f, -0.13401830f, 0.01028726f, 
    -0.03891613f, -0.05042018f, 0.04869646f, -0.07520501f, -0.05250947f, -0.02830443f, 0.07762529f, -0.00535794f, 
    -0.08566445f, 0.00059548f, -0.11751707f, 0.00615397f, -0.04187869f, -0.06593374f, 0.04382234f, -0.08862625f, 
    0.08817894f, -0.01172012f, -0.01586980f, -0.09940436f, 0.10230833f, -0.03989469f, -0.04302847f, -0.09676830f, 
    0.05429459f, -0.04462371f, 0.09124850f, -0.10600172f, -0.05972506f, -0.01996876f, 0.05298148f, 0.02249501f, 
    -0.10887878f, 0.11258696f, 0.06200156f, -0.03164221f, -0.08733810f, 0.01559193f, 0.06748626f, 0.00582284f, 
    0.31951189f, 0.11324583f, -0.05337098f, -0.12172946f, 0.20595622f, 0.01588745f, -0.10345963f, -0.00591121f, 
    -0.00733686f, -0.13890766f, -0.12728851f, 0.02027565f, -0.07286190f, 0.18192458f, 0.14535809f, -0.00971934f, 
    -0.27690041f, -0.16490187f, 0.10067176f, -0.04838418f, -0.21063964f, 0.14977922f, 0.32673156f, -0.04759237f, 
    -0.11159424f, 0.26355025f, -0.14765714f, -0.20689586f, 0.07219489f, 0.02636292f, -0.10269637f, -0.01082191f, 
    -0.06673844f, 0.04095474f, -0.45179939f, 0.42333281f, 0.00030168f, 0.32784688f, 0.05047793f, 0.10973786f, 
    -0.15131767f, 0.32239938f, -0.04064247f, -0.27606425f, -0.26982468f, 0.28236431f, -0.02767968f, 0.19701980f, 
    -0.21457586f, 0.41352227f, 0.29539409f, 0.11267292f, 0.00478601f, 0.08977593f, 0.01196471f, 0.01803584f, 
    0.06918647f, -0.00429539f, -0.14381103f, -0.02900170f, 0.38235143f, -0.10817256f, 0.09470771f, 0.33832628f, 
    0.19146937f, 0.02303877f, 0.05909284f, 0.09236730f, 0.26631728f, -0.11654243f, -0.06418535f, 0.14161798f, 
    -0.06146894f, 0.04371342f, -0.07191270f, 0.21621096f, 0.08257139f, 0.22603631f, 0.11870509f, 0.00385819f, 
    -0.34183785f, -0.10989836f, 0.24809442f, -0.02183600f, -0.25080445f, -0.11743832f, 0.23414822f, -0.01867628f, 
    -0.24971732f, 0.11554265f, 0.06599624f, -0.00487494f, -0.34998077f, 0.07339481f, -0.13160986f, 0.07593927f, 
    -0.06486596f, 0.11905795f, -0.19439822f, 0.62968564f, 0.07643447f, 0.32765904f, 0.27862865f, -0.06656204f, 
    -0.13556606f, 0.24139048f, -0.06808569f, -0.41324770f, 0.14463341f, 0.13431211f, -0.07425360f, -0.41271535f, 
    -0.08286702f, 0.37252429f, 0.37306923f, 0.01082356f, 0.30085626f, 0.12235840f, -0.15368882f, 0.09188868f, 
    -0.00244036f, 0.03147953f, -0.13877705f, -0.05989968f, 0.19629447f, 0.15653072f, 0.14741760f, 0.43782344f, 
    -0.13470556f, 0.02291121f, 0.09960437f, 0.00948706f, -0.08627255f, -0.02400488f, 0.05502796f, -0.02745970f, 
    0.17540704f, 0.11752570f, 0.00727918f, 0.10966209f, -0.02536390f, 0.02201014f, -0.04924928f, 0.00504816f, 
    0.02314863f, -0.12457338f, -0.03178572f, -0.10043319f, 0.08077382f, 0.02121705f, -0.00168785f, -0.04150185f, 
    -0.09766694f, -0.10062476f, -0.03432174f, -0.08921289f, 0.05347564f, 0.04224233f, -0.02846010f, -0.02727799f, 
    0.09320524f, -0.10513753f, 0.11489955f, 0.11867935f, 0.11724862f, 0.05685540f, -0.06534979f, -0.01606183f, 
    -0.08861788f, -0.00563512f, 0.09417322f, -0.02274034f, 0.04410549f, -0.07522898f, -0.08998189f, -0.15306646f, 
    -0.11511656f, 0.12359539f, 0.03158078f, -0.05616193f, 0.00451994f, -0.01864104f, 0.04026340f, 0.03298836f, 
    0.11215955f, -0.09625036f, 0.07577969f, -0.11443840f, -0.08520707f, 0.10605929f, -0.03299459f, 0.06614934f, 
    0.01428661f, -0.10241307f, -0.02696831f, -0.02528124f, -0.23689219f, 0.11257285f, -0.00988284f, 0.08009866f, 
    0.04308022f, -0.05428914f, 0.36479425f, 0.04213019f, 0.32297257f, 0.04630992f, 0.11590895f, -0.07256672f, 
    0.48241439f, 0.27729160f, -0.10823887f, 0.18835451f, 0.33502209f, 0.21323201f, -0.27262017f, -0.04345656f, 
    0.31746167f, -0.20511967f, 0.12008277f, 0.27600032f, 0.19553500f, 0.22151257f, 0.28519571f, -0.03514396f, 
    0.04709816f, -0.13142851f, 0.39744341f, -0.20606630f, 0.25483224f, -0.14542721f, -0.16424900f, -0.03605187f, 
    0.27599251f, 0.07704961f, -0.06106210f, 0.50143403f, 0.13218388f, -0.07184908f, 0.20231272f, 0.30136570f, 
    -0.13186376f, -0.22234291f, -0.12076607f, 0.04199738f, -0.14820400f, -0.06580199f, 0.17900306f, -0.00559353f, 
    -0.09635892f, 0.08425733f, 0.06440150f, 0.09006824f, -0.14375541f, 0.10143638f, 0.20418994f, -0.29056767f, 
    -0.09286663f, -0.08398734f, 0.06763899f, -0.08107602f, 0.21763529f, 0.06602773f, -0.08169006f, 0.15615052f, 
    -0.01240055f, -0.01953633f, 0.11700965f, 0.12208240f, -0.32727936f, -0.19855405f, 0.22507980f, 0.07207203f, 
    0.41495508f, 0.19631739f, 0.03373460f, 0.10318768f, 0.22617753f, -0.11322139f, -0.08317790f, 0.06906030f, 
    0.35567757f, -0.04824858f, 0.37412202f, -0.02409418f, -0.11061122f, -0.09856746f, -0.29636529f, -0.01628497f, 
    -0.11321355f, 0.14846003f, 0.20870186f, -0.32902676f, 0.07934213f, -0.10090073f, -0.00698078f, -0.11649380f, 
    0.22680286f, -0.10367678f, -0.11497932f, -0.01279818f, -0.05499483f, 0.20768061f, 0.16054964f, -0.09027181f, 
    0.05949268f, -0.22664581f, -0.25878409f, -0.10672603f, 0.20580101f, -0.08580844f, 0.15451810f, 0.14356832f, 
    -0.10469238f, -0.01834109f, 0.03599662f, 0.12846459f, -0.21777025f, 0.17834789f, 0.30471748f, -0.12470859f, 
    0.22149724f, 0.11638594f, 0.14131013f, -0.05667581f, -0.58809143f, -0.00679632f, -0.03484584f, -0.08867785f, 
    0.01883323f, -0.02002808f, 0.31654936f, 0.00426132f, -0.13479954f, -0.08976198f, -0.13142358f, 0.10025139f, 
    0.21591708f, 0.19415411f, -0.16485341f, 0.17738350f, -0.17205755f, -0.03857672f, 0.06638733f, -0.06057365f, 
    -0.04395057f, 0.36438972f, -0.17809990f, -0.01975288f, -0.32917580f, -0.11593869f, 0.18859679f, 0.03227726f, 
    -0.02371320f, -0.15563820f, 0.25534630f, -0.02685966f, 0.03259171f, 0.31406692f, 0.16047491f, -0.06819372f, 
    -0.34079805f, 0.13553946f, -0.23345600f, -0.28732413f, 0.33276832f, 0.22921680f, 0.02847650f, -0.12998833f, 
    -0.30339980f, -0.31964207f, 0.26066148f, 0.11928172f, 0.58897585f, 0.05355814f, -0.31463137f, 0.23116991f, 
    0.05676716f, 0.10986529f, -0.15582626f, 0.11282807f, -0.11817165f, -0.08221740f, 0.35249844f, -0.16367333f, 
    -0.02857258f, -0.02499366f, -0.04472169f, 0.03977723f, 0.23661695f, -0.05495159f, -0.10074352f, 0.31510216f, 
    0.13088138f, 0.02018745f, 0.11693065f, 0.34949458f, 0.22902542f, -0.03239157f, 0.24054036f, 0.08808059f, 
    0.02312408f, -0.03464017f, 0.44174656f, -0.06305782f, 0.07548709f, -0.35825574f, -0.07028566f, -0.00184350f, 
    0.16099861f, -0.26218724f, 0.33671173f, 0.21704718f, -0.02067866f, 0.05442187f, 0.19975738f, 0.02558354f, 
    -0.09004088f, 0.11034888f, -0.05090959f, 0.36752272f, 0.31465587f, 0.13512540f, 0.22875881f, 0.00237640f, 
    0.26351359f, 0.00089401f, -0.35467604f, -0.02672650f, 0.01121867f, 0.02896747f, 0.04363680f, -0.09923138f, 
    -0.11887786f, 0.21616623f, -0.13539697f, 0.12000376f, -0.22833003f, 0.03167300f, -0.26065728f, -0.17365822f, 
    0.09417452f, 0.13710652f, -0.05984217f, 0.03216905f, 0.17424920f, 0.43142855f, 0.03569104f, 0.04141283f, 
    -0.22376274f, 0.01511110f, 0.00573479f, -0.07445574f, 0.58834797f, -0.07853599f, 0.04953662f, -0.06726924f, 
    0.18879758f, -0.03425279f, -0.19085659f, 0.14496985f, -0.21955666f, -0.15024562f, 0.14222263f, 0.01414001f, 
    -0.18540940f, 0.18007636f, -0.19941077f, 0.05733634f, 0.22314389f, 0.23079388f, 0.14758210f, 0.10461085f, 
    0.09280367f, 0.10988721f, 0.20594691f, -0.51333374f, 0.03465959f, -0.16347761f, -0.24081236f, 0.10215468f, 
    0.03625196f, 0.35871065f, -0.08826011f, 0.09900922f, -0.16615169f, -0.26395172f, 0.27596816f, -0.10875490f, 
    0.08335530f, -0.11490446f, 0.22022812f, -0.05196010f, -0.50822228f, 0.23568283f, -0.16948958f, 0.04167218f, 
    -0.15600553f, 0.55629146f, 0.04002686f, -0.04332095f, -0.08464918f, 0.07662965f, 0.01155389f, 0.03292191f, 
    -0.00726030f, 0.12164614f, -0.00966062f, 0.14479759f, 0.15786649f, -0.00197238f, -0.02569445f, 0.68584841f, 
    -0.08417933f, -0.11883536f, -0.01238622f, -0.10450916f, -0.00202822f, -0.01899882f, -0.01291084f, -0.06108546f, 
    0.06507307f, -0.11656126f, -0.00079834f, 0.06038550f, -0.01352861f, -0.06410524f, -0.14986907f, -0.07929215f, 
    -0.10865437f, -0.02340342f, 0.09873772f, -0.01999255f, 0.06003638f, -0.10284628f, -0.08387838f, 0.02797418f, 
    -0.05364845f, 0.00561813f, -0.00225271f, 0.09467874f, 0.00773877f, -0.00941738f, 0.13031940f, -0.03663546f, 
    0.12357728f, 0.08703218f, -0.06895506f, -0.01387602f, -0.10583653f, -0.03847437f, 0.05046735f, 0.00877316f, 
    -0.07423658f, 0.06522638f, 0.04523576f, -0.12981440f, 0.00351129f, 0.01717233f, 0.05889625f, 0.03125102f, 
    0.01604156f, 0.10972530f, 0.01898411f, 0.00789073f, -0.11053836f, -0.02257023f, 0.03484605f, -0.08085869f, 
    -0.10969922f, -0.07179396f, -0.13286857f, -0.10564252f, -0.04368544f, -0.01459805f, 0.04130571f, 0.05740988f, 
    -0.11274328f, -0.03849959f, 0.07343917f, -0.05675818f, 0.32639843f, 0.00128567f, 0.06068991f, 0.05295741f, 
    0.06191412f, 0.08991440f, -0.32993215f, -0.08901399f, -0.32901916f, -0.04694275f, 0.15332200f, 0.04362617f, 
    -0.11487161f, 0.02147818f, -0.22778569f, -0.02547391f, 0.20586036f, 0.09078869f, 0.29587179f, -0.00359384f, 
    -0.08346406f, 0.28601074f, -0.00542710f, -0.21965545f, 0.29534575f, -0.01488065f, -0.34664083f, 0.09831199f, 
    0.02768090f, 0.25815165f, -0.16604939f, 0.04780725f, -0.09799235f, -0.17128304f, -0.06241479f, -0.04821860f, 
    0.16383950f, -0.30112123f, 0.40317917f, -0.02393711f, -0.70517033f, 0.10322807f, -0.00873915f, -0.12166761f, 
    0.29120904f, 0.41892698f, -0.12708464f, 0.09119808f, 0.21435659f, 0.08064508f, 0.29347882f, -0.11526996f, 
    -0.07778950f, 0.10769688f, 0.19175881f, 0.02330535f, 0.22728303f, 0.19716771f, -0.09435309f, 0.31123018f, 
    0.03557898f, -0.04838866f, -0.00415777f, 0.04629850f, -0.12543400f, 0.06269132f, -0.03022194f, -0.15244703f, 
    0.14607847f, -0.00117900f, -0.10148927f, -0.04445834f, 0.28903240f, 0.24632722f, -0.07636593f, 0.03528522f, 
    -0.46498483f, -0.21011017f, 0.09782018f, -0.05166321f, 0.00015614f, 0.10565326f, 0.22782032f, 0.02965789f, 
    -0.18221803f, 0.08852774f, -0.18619592f, -0.00438660f, 0.26075473f, 0.20415558f, 0.31910250f, -0.06938283f, 
    -0.08702740f, 0.16132663f, -0.14695041f, 0.48728719f, -0.16563390f, 0.11961811f, 0.13509671f, -0.04114871f, 
    0.08851518f, -0.00158657f, 0.11633523f, 0.10153272f, 0.03790141f, -0.05091112f, -0.01468773f, 0.13859789f, 
    0.27257964f, 0.19247718f, 0.37298298f, 0.08456668f, 0.07246307f, -0.19447374f, 0.21922460f, -0.03380162f, 
    -0.02699656f, 0.02866630f, -0.05045762f, -0.03716715f, 0.31477180f, 0.17049761f, -0.13140433f, 0.11135304f, 
    -0.03519706f, -0.05626659f, 0.01853174f, -0.10370217f, -0.05544019f, -0.07532364f, 0.08458225f, -0.01237964f, 
    -0.08830228f, -0.08554603f, 0.01001192f, 0.07113020f, -0.06147519f, -0.03289498f, -0.07460108f, -0.07016888f, 
    0.03295034f, -0.02912258f, 0.05592571f, 0.08744516f, -0.00368847f, -0.06614383f, 0.08680741f, -0.13536772f, 
    -0.01591722f, -0.02982843f, 0.05548852f, -0.04296127f, 0.00469180f, -0.09333232f, 0.07132918f, 0.09017090f, 
    0.03742336f, -0.13291174f, 0.03154878f, -0.08430374f, -0.06879956f, -0.10465152f, -0.10270299f, -0.12606181f, 
    0.07944012f, -0.05606837f, -0.14069101f, -0.08783242f, -0.02323534f, 0.07430358f, -0.14045008f, -0.09941053f, 
    -0.02490004f, -0.06911692f, 0.08357754f, -0.04358083f, -0.04654978f, 0.11860034f, -0.02065450f, 0.03543900f, 
    0.02454686f, 0.11388434f, 0.00453186f, -0.00365010f, 0.04767846f, 0.03784638f, -0.13582063f, 0.08510084f, 
    -0.09905937f, 0.03895594f, 0.10374904f, -0.03952805f, 0.40170825f, -0.05808222f, -0.06120259f, 0.13902065f, 
    -0.05279575f, 0.02933321f, 0.05300810f, 0.11771782f, 0.03785741f, -0.11999208f, 0.14537543f, -0.02286802f, 
    0.18502854f, -0.11017326f, 0.01677740f, 0.04954057f, 0.12440196f, -0.24895345f, 0.08814298f, 0.02363088f, 
    0.17909211f, -0.18267176f, 0.04201672f, -0.27682626f, 0.02746268f, -0.11730759f, 0.28385779f, 0.06739690f, 
    0.10486396f, 0.27670825f, -0.13377771f, 0.03497035f, 0.19412683f, -0.02990445f, 0.32224020f, 0.00610237f, 
    0.24930550f, 0.01411024f, 0.06490719f, 0.25785750f, -0.08006722f, 0.06584129f, -0.13505501f, 0.31615305f, 
    -0.02663454f, 0.26597074f, -0.10896312f, 0.04342191f, -0.39141750f, -0.10823147f, 0.24289426f, -0.00120165f, 
    -0.04677873f, 0.04048660f, 0.00185932f, -0.17212273f, 0.40951598f, 0.01307721f, -0.05246458f, 0.33876759f, 
    0.00312362f, 0.04896264f, 0.02328795f, 0.09345318f, -0.01508378f, 0.07956208f, 0.08043021f, -0.05219410f, 
    -0.00026692f, -0.09999339f, 0.26872328f, 0.07665170f, 0.07949992f, -0.13319786f, -0.12128736f, -0.04691638f, 
    0.36155564f, 0.38622603f, -0.09284853f, 0.15069549f, 0.25613090f, 0.04234482f, -0.21795952f, -0.09874921f, 
    0.20470554f, 0.06915136f, 0.32991919f, 0.20380841f, 0.03594850f, 0.16004334f, 0.07954875f, -0.06842832f, 
    -0.06973830f, -0.09823105f, 0.11875301f, -0.45795235f, 0.20530939f, -0.28876978f, -0.19467670f, 0.06163485f, 
    0.28662965f, 0.09496037f, -0.00870626f, 0.05507861f, 0.19355771f, 0.01060348f, 0.23359625f, 0.21932603f, 
    0.34157267f, 0.11220127f, -0.09902738f, -0.02812695f, -0.08401279f, 0.10420386f, 0.26482525f, 0.04294881f, 
    0.01180316f, 0.11827269f, 0.28129870f, 0.02467045f, -0.33440372f, -0.16698325f, -0.08386131f, -0.43644944f, 
    -0.12003544f, -0.04473342f, 0.11170496f, 0.11551018f, 0.00201990f, 0.11582503f, -0.01927343f, 0.05105147f, 
    0.09189861f, -0.02029152f, -0.06201975f, -0.09165952f, 0.03381317f, 0.10622983f, 0.05660162f, -0.09962396f, 
    -0.10131470f, 0.01382813f, 0.03183599f, 0.05850314f, -0.04795363f, -0.07880977f, -0.04297052f, 0.08387178f, 
    -0.08490843f, -0.07484607f, -0.01689856f, -0.02627014f, 0.10886465f, -0.08205135f, 0.08321570f, -0.10112088f, 
    -0.08079602f, -0.09959708f, 0.06240751f, -0.08102979f, -0.01281458f, 0.06068746f, -0.01396233f, 0.02506886f, 
    -0.08622675f, -0.08180039f, -0.03008263f, 0.09795811f, -0.11603913f, -0.04883082f, -0.04840508f, 0.09464498f, 
    -0.12143298f, -0.09200224f, -0.00241081f, -0.11051842f, 0.08462369f, -0.03902182f, -0.07184596f, -0.07463861f, 
    0.04310653f, 0.04477742f, -0.08169384f, -0.08797076f, 0.04719194f, -0.05367766f, 0.05439027f, 0.10382344f, 
    -0.29519191f, -0.02397592f, 0.04881394f, -0.08154387f, 0.47371778f, 0.04234429f, -0.08039732f, -0.03431990f, 
    0.05245681f, 0.01600501f, 0.05104538f, 0.17950110f, 0.18090889f, -0.35580707f, 0.22021498f, -0.02244005f, 
    0.19981371f, -0.01292053f, -0.17852035f, 0.13818380f, 0.21516353f, 0.08422490f, 0.11572140f, -0.01601821f, 
    0.10305990f, 0.05920251f, 0.21744095f, -0.27460018f, -0.29305524f, -0.20266473f, 0.12991683f, -0.03330334f, 
    0.04193196f, 0.16981719f, 0.18908179f, -0.06451058f, 0.15221985f, -0.24601276f, 0.29814950f, -0.07718910f, 
    0.21252309f, -0.10175729f, -0.08953128f, 0.11752452f, 0.16546498f, 0.05695982f, -0.24874485f, 0.06359491f, 
    -0.18955398f, 0.42833620f, -0.23013535f, -0.10977137f, -0.24667762f, -0.00435528f, 0.03786469f, -0.08727467f, 
    0.01569554f, -0.01801728f, -0.15389244f, 0.03711297f, 0.06239130f, 0.11400470f, -0.09737356f, 0.26433596f, 
    -0.01699433f, 0.07487702f, -0.08436398f, 0.03925209f, 0.04413699f, -0.11132398f, -0.08736704f, -0.10624674f, 
    -0.08026931f, 0.05024311f, -0.10548437f, -0.06749800f, 0.09376973f, -0.00310882f, -0.07110511f, -0.04956269f, 
    -0.05605932f, 0.12021616f, -0.05412870f, -0.11985154f, -0.10013039f, -0.10976554f, 0.06895923f, 0.08690599f, 
    -0.07565653f, -0.00468710f, -0.11719412f, -0.12094146f, -0.10197628f, 0.02184133f, 0.04804211f, -0.09916855f, 
    -0.06013158f, -0.11388738f, 0.03929746f, -0.06690305f, -0.05814545f, 0.08715679f, -0.12017693f, 0.04646301f, 
    0.09798816f, -0.01354583f, 0.04995517f, -0.12275468f, -0.00583309f, -0.09525970f, -0.03161973f, 0.09783116f, 
    0.03698023f, -0.00780499f, -0.01767715f, 0.03532936f, -0.06726374f, -0.01846229f, -0.03283091f, -0.11496437f, 
    -0.05644612f, -0.05323629f, 0.02611505f, 0.08656363f, 0.09023291f, -0.02120519f, -0.06289395f, 0.04332465f, 
    0.02210378f, 0.01215778f, 0.01854904f, 0.12894160f, -0.29489768f, 0.05520177f, -0.03613745f, 0.19012876f, 
    -0.05205800f, -0.03645569f, -0.17278212f, -0.24818626f, 0.09415394f, 0.33230603f, 0.05906474f, 0.04932261f, 
    0.13064748f, -0.30462351f, -0.27924082f, 0.27335486f, 0.13842435f, 0.18611360f, -0.04084837f, -0.04830750f, 
    0.03200345f, -0.10666115f, -0.21681289f, -0.06540959f, -0.14261408f, 0.10185912f, 0.00834106f, 0.00092832f, 
    -0.11357248f, 0.18412223f, 0.18807811f, 0.14011803f, -0.21321444f, 0.07946458f, 0.19534546f, 0.05003606f, 
    -0.11194707f, -0.02649816f, 0.25040996f, 0.29435498f, 0.08002552f, -0.34210423f, -0.13512400f, -0.22051713f, 
    0.26076168f, -0.56944954f, 0.18830530f, 0.05988409f, 0.28616464f, -0.09766968f, 0.32985941f, 0.16685203f, 
    -0.08794565f, -0.08046675f, 0.09173542f, -0.10981268f, -0.13997620f, 0.14719762f, 0.34241462f, -0.05121664f, 
    0.08703693f, -0.02209733f, 0.11065114f, -0.08432105f, -0.41422954f, 0.10684200f, 0.00288655f, -0.04131960f, 
    0.09491890f, -0.05057999f, 0.03995834f, -0.08383440f, 0.04152268f, 0.11580174f, -0.12168805f, 0.09674039f, 
    0.15739727f, 0.20419881f, 0.01279897f, 0.07257144f, 0.12693760f, -0.00661903f, -0.20231333f, -0.07563584f, 
    0.06725007f, 0.28353256f, 0.21338312f, 0.36641988f, 0.14001636f, 0.29369670f, 0.07664119f, 0.04066790f, 
    0.06561281f, -0.37862593f, 0.31674740f, -0.14106041f, 0.03882372f, -0.14234254f, -0.32279024f, 0.03075797f, 
    -0.09843762f, 0.03565729f, 0.05172268f, 0.02010347f, 0.11645211f, -0.08298191f, 0.30915025f, -0.02044840f, 
    0.15862884f, -0.20410125f, 0.03594200f, 0.09717489f, 0.15823837f, 0.02225036f, 0.22800268f, 0.18656532f, 
    -0.07092951f, -0.07284535f, 0.17306462f, -0.01722916f, -0.11945564f, -0.02195831f, -0.07540245f, -0.79348087f, 
    0.21012276f, -0.03078893f, 0.07779908f, -0.05925203f, -0.15430471f, 0.09048292f, 0.04459815f, 0.20219438f, 
    0.12433297f, 0.02428189f, 0.01173027f, -0.06058246f, 0.62004286f, 0.41990685f, 0.19912468f, 0.01750213f, 
    -0.21704893f, -0.16668279f, 0.31008291f, 0.11633254f, -0.25304371f, 0.26306042f, -0.13985550f, -0.06255627f, 
    -0.20440304f, -0.04829645f, 0.03959699f, 0.10654207f, -0.21994819f, 0.28033647f, 0.06159490f, -0.06867004f, 
    -0.07540514f, -0.05563807f, -0.25908774f, 0.63267416f, -0.05002305f, 0.18339582f, 0.20210099f, -0.04154798f, 
    0.13386901f, 0.37478259f, -0.15424481f, 0.08660201f, 0.26907399f, -0.18748584f, 0.04919132f, -0.05014265f, 
    -0.04583034f, 0.14834706f, 0.30611882f, 0.07710239f, 0.12129135f, -0.04742060f, -0.12078227f, 0.05682991f, 
    -0.11301628f, -0.05578079f, -0.25726256f, -0.06357133f, 0.21562363f, 0.18268079f, 0.06032278f, 0.16898228f, 
    -0.09193712f, -0.12359685f, -0.05144000f, 0.11715018f, 0.19511904f, -0.02673098f, 0.09896523f, -0.04446940f, 
    -0.01531294f, 0.07446079f, -0.21607384f, -0.10153419f, -0.32956645f, -0.01483689f, 0.22447452f, -0.08143292f, 
    -0.00032847f, 0.18983120f, -0.12953781f, 0.11103220f, 0.15417634f, -0.02990901f, 0.13609099f, 0.01652653f, 
    0.11568637f, 0.32668015f, 0.26687524f, -0.25791016f, 0.34417468f, 0.09865674f, -0.07154576f, -0.06851699f, 
    0.11955711f, 0.10786271f, -0.15833272f, -0.21382929f, 0.05463254f, -0.09284300f, 0.04455681f, -0.02217178f, 
    0.28471103f, 0.05513304f, 0.43438447f, 0.09465979f, -0.37306413f, 0.11847582f, 0.11507029f, 0.22906108f, 
    0.48652145f, 0.15315717f, -0.18817775f, -0.03324850f, -0.16060528f, -0.10830453f, 0.29675713f, 0.03329980f, 
    -0.08055203f, 0.03006471f, 0.20346509f, 0.08459273f, 0.22147730f, -0.15797509f, -0.13360721f, 0.00975428f, 
    0.08234458f, -0.00349660f, 0.09135710f, -0.12047623f, -0.16969265f, -0.01835693f, -0.12469664f, -0.18621311f, 
    0.00709880f, 0.03610246f, 0.06663631f, -0.08213935f, 0.07841813f, -0.11192544f, 0.03301790f, -0.10732363f, 
    -0.25845450f, -0.01701521f, 0.07958160f, -0.12477585f, -0.15943080f, 0.37413675f, -0.07209349f, 0.02401308f, 
    -0.02336787f, -0.00719551f, -0.02746884f, 0.00567519f, 0.29282570f, 0.17283040f, 0.13053764f, -0.11348704f, 
    -0.01249076f, 0.02384506f, -0.34433627f, 0.00387397f, 0.04996867f, 0.09092960f, -0.16704841f, 0.05585580f, 
    0.11891343f, 0.14226052f, 0.22227265f, 0.10776170f, 0.04341158f, 0.23475416f, 0.19894487f, 0.50895840f, 
    0.13925055f, 0.18412171f, 0.06280404f, -0.07119939f, -0.27284563f, -0.02499382f, -0.04586180f, -0.00190232f, 
    0.07702072f, -0.08902560f, -0.03747012f, 0.00495315f, 0.24242112f, -0.11630124f, -0.32157528f, -0.05863526f, 
    -0.10521451f, 0.01110920f, 0.03503602f, -0.02074431f, 0.03698885f, 0.06317364f, 0.11104184f, 0.00472534f, 
    -0.05968642f, 0.02377972f, 0.09272503f, 0.06774399f, -0.12697087f, 0.08124378f, 0.05242578f, 0.05374436f, 
    -0.03518701f, -0.06545740f, 0.00216662f, -0.13318646f, -0.05184262f, -0.10128510f, 0.08211689f, -0.07853284f, 
    -0.05432182f, 0.04840539f, 0.06945322f, -0.12744296f, -0.10844064f, 0.05066544f, 0.00100113f, 0.06034683f, 
    0.10329439f, -0.07760400f, 0.07282019f, -0.09962712f, -0.06475767f, 0.01274906f, 0.07492478f, -0.01406716f, 
    -0.15085262f, 0.01906761f, -0.02395303f, 0.05899630f, 0.02238776f, -0.03633967f, 0.08499237f, -0.06068321f, 
    0.06746456f, 0.04795104f, 0.03280351f, 0.11518073f, -0.00361877f, 0.03846290f, 0.07371800f, -0.15487981f, 
    -0.02340806f, -0.04875749f, -0.15043046f, -0.05716858f, -0.04048070f, -0.13805149f, -0.04797609f, 0.05133093f, 
    0.08600239f, -0.07892470f, -0.05376569f, -0.06318936f, 0.39888990f, 0.10595483f, 0.00591290f, 0.10075658f, 
    0.04942509f, 0.09162056f, 0.34389314f, 0.18106253f, -0.25389543f, -0.21947967f, 0.05113345f, -0.00779085f, 
    0.34602872f, 0.20229770f, 0.00109614f, -0.17010152f, 0.23287411f, -0.51720697f, 0.14169177f, 0.10018294f, 
    0.17305076f, 0.32562166f, 0.13428424f, -0.03313035f, 0.09581492f, -0.09158901f, 0.00012858f, -0.05780027f, 
    0.08171192f, 0.13417333f, 0.11596663f, -0.44927752f, 0.12315632f, -0.02869135f, 0.00063497f, -0.04903720f, 
    0.07604557f, -0.00728471f, 0.06669515f, -0.06132570f, -0.19643660f, 0.14425324f, -0.01685416f, 0.16544157f, 
    -0.15069884f, 0.14440578f, -0.02165551f, -0.04642156f, -0.03984711f, 0.05997859f, -0.04569818f, -0.10666250f, 
    -0.04822044f, 0.12208699f, 0.20690852f, 0.07606074f, 0.24224772f, 0.11286438f, -0.03224532f, 0.09784574f, 
    -0.10810976f, -0.03476267f, -0.05566218f, 0.07002778f, -0.26581642f, 0.01489960f, 0.02043748f, 0.14498742f, 
    -0.02519964f, 0.13797939f, 0.02629321f, -0.20061535f, 0.30112484f, 0.19069135f, 0.19676977f, 0.04568456f, 
    -0.20246844f, -0.12158425f, -0.15378466f, 0.19104068f, 0.07185911f, 0.28640389f, -0.09548974f, 0.09710561f, 
    -0.16082658f, -0.15587726f, -0.27860036f, -0.13433583f, 0.20196964f, 0.23005289f, 0.18532546f, 0.05372907f, 
    0.09850642f, 0.31645310f, -0.00189066f, 0.01958026f, -0.18194550f, -0.15865278f, 0.21594974f, 0.05043021f, 
    0.10840955f, -0.03446627f, 0.37234402f, 0.35647830f, 0.09089503f, -0.19269012f, -0.03446962f, 0.15983643f, 
    0.17404556f, -0.40077755f, 0.18931288f, -0.09829067f, -0.08375454f, -0.06467046f, 0.34166107f, 0.07918631f, 
    0.09324491f, -0.04952990f, -0.10810123f, -0.10606142f, 0.00164466f, -0.02915596f, 0.13235120f, 0.04350686f, 
    0.06518891f, -0.03897730f, 0.06770689f, -0.00883635f, -0.29427639f, 0.00824741f, 0.00932048f, 0.17083973f, 
    0.03386803f, -0.06621050f, 0.18357724f, -0.07868303f, 0.09597280f, 0.11224787f, -0.03958735f, -0.06763022f, 
    0.22335674f, 0.20920028f, -0.23662122f, 0.09888419f, 0.04221333f, 0.40125588f, -0.14617245f, 0.10103603f, 
    0.14844745f, 0.06495158f, -0.03823242f, 0.40700102f, 0.16175991f, 0.27835104f, -0.20439172f, 0.13461448f, 
    -0.00749578f, -0.04274350f, 0.26176929f, -0.28622085f, -0.01809964f, -0.17422646f, -0.25530031f, 0.03229330f, 
    0.08535633f, -0.07606436f, 0.28355277f, 0.27817905f, 0.29532731f, -0.13670248f, 0.14749053f, 0.08033554f, 
    0.19948244f, -0.28498361f, 0.15601422f, -0.08488159f, 0.18205638f, -0.07522975f, 0.13324919f, 0.23345262f, 
    0.05751652f, 0.05056746f, 0.27096885f, 0.03007736f, -0.34527373f, -0.07391916f, 0.21205872f, -0.13155052f, 
    0.13369222f, 0.03176589f, 0.06991042f, -0.00752344f, 0.17276494f, 0.06107917f, -0.04123791f, 0.12013371f, 
    -0.09486064f, -0.05807767f, 0.19268149f, 0.41438696f, -0.16978937f, 0.02809204f, 0.29401675f, 0.07520016f, 
    0.27354968f, -0.12821113f, 0.16642010f, 0.08954360f, -0.08043880f, -0.40219653f, 0.14203823f, 0.02603386f, 
    0.25293294f, -0.11249145f, 0.23920223f, 0.00856249f, -0.23633511f, -0.20844732f, 0.14738733f, -0.08849291f, 
    -0.03202774f, 0.14472236f, 0.11575594f, 0.11172906f, 0.35246772f, 0.23785044f, 0.31246221f, -0.06197758f, 
    0.06296615f, 0.10196102f, -0.35930356f, -0.15184428f, 0.02465685f, 0.24209242f, -0.05224824f, -0.30208766f, 
    -0.11707051f, 0.03617149f, -0.05357516f, 0.05876061f, 0.04164759f, 0.03804973f, -0.23098980f, 0.16932929f, 
    -0.02442036f, 0.03488594f, -0.15953256f, -0.03572239f, 0.00086172f, 0.21586096f, 0.21553707f, 0.23998229f, 
    -0.18680529f, -0.00381039f, -0.07960268f, 0.07089676f, 0.31838867f, 0.02301638f, -0.10709904f, 0.19175741f, 
    0.12490342f, -0.08608092f, -0.23414150f, 0.24327902f, 0.27243191f, -0.00537703f, 0.32615715f, -0.06166546f, 
    -0.05110693f, -0.10471745f, 0.11699088f, 0.13273855f, 0.07484695f, 0.01436530f, 0.03409354f, 0.03040202f, 
    0.04579991f, -0.17376891f, 0.15926397f, -0.12522151f, 0.02629466f, -0.07829732f, 0.00737729f, 0.00276599f, 
    -0.02505136f, 0.35518402f, 0.13888128f, 0.24928080f, -0.07375407f, 0.01820099f, 0.35719031f, -0.07606649f, 
    0.00052977f, -0.02105441f, 0.14663419f, 0.17567189f, -0.07994273f, -0.11616309f, -0.15020724f, -0.09927159f, 
    0.10998517f, 0.06888927f, -0.09390256f, -0.07296741f, 0.14421487f, 0.03105680f, -0.00942244f, -0.11046227f, 
    0.09418334f, -0.02320996f, -0.10455282f, -0.13089715f, 0.03913176f, 0.42786109f, 0.20240428f, 0.21422963f, 
    0.13515666f, -0.06810451f, -0.10062367f, 0.12896307f, -0.12905157f, -0.10248095f, 0.07639781f, -0.09335475f, 
    -0.08589445f, 0.11088783f, 0.13922383f, 0.05650102f, -0.07810189f, 0.05042287f, 0.01587495f, -0.05517809f, 
    -0.06622896f, 0.25004295f, 0.26822945f, -0.14805634f, -0.22155425f, -0.12900014f, 0.08021744f, 0.05024934f, 
    0.05762731f, 0.36460727f, 0.14630805f, 0.21742979f, 0.01944052f, 0.16707624f, -0.20933741f, -0.05819661f, 
    0.10370266f, -0.24342221f, -0.24175915f, 0.18863139f, 0.26952529f, 0.26054791f, -0.07344826f, 0.08549803f, 
    0.08428229f, 0.20519285f, -0.17154868f, -0.19834365f, -0.03690628f, 0.33073479f, 0.16491315f, 0.03916621f, 
    -0.16888984f, 0.22729032f, 0.02995936f, 0.04711761f, -0.02306269f, -0.02241501f, -0.44191641f, 0.07530261f, 
    0.00486487f, -0.03066628f, 0.13165495f, 0.06237575f, 0.05411942f, -0.13096212f, -0.19110571f, -0.09809618f, 
    0.20534319f, -0.07726245f, 0.00553760f, 0.03911628f, 0.05868528f, -0.08219334f, 0.12426515f, 0.16687125f, 
    -0.02824092f, -0.11180913f, -0.16985449f, 0.03041157f, 0.30241412f, 0.19894223f, 0.08578798f, 0.03779253f, 
    -0.29339305f, -0.10344724f, 0.26963481f, -0.15337697f, -0.14098571f, 0.09680230f, 0.15927738f, 0.12104709f, 
    0.02198046f, -0.11135015f, 0.12656723f, 0.18935587f, -0.12347778f, 0.12406490f, -0.09067080f, 0.01878266f, 
    -0.10918935f, -0.00636742f, -0.26199704f, 0.54247546f, 0.11582365f, 0.25293139f, 0.13070062f, -0.00189458f, 
    0.13406046f, 0.29473200f, -0.14107870f, -0.08036911f, -0.09932142f, 0.00007918f, 0.06059280f, -0.14031133f, 
    0.15526250f, 0.19389340f, 0.15385197f, -0.01344926f, -0.11819528f, -0.08655830f, -0.09484889f, -0.15094127f, 
    -0.05683406f, 0.06691640f, 0.06519158f, -0.06832340f, 0.09358788f, 0.26657459f, -0.10314654f, -0.11683020f, 
    0.22832382f, 0.00136428f, -0.08997106f, 0.09629629f, -0.14634185f, 0.09661409f, 0.10955881f, -0.09946860f, 
    -0.06900857f, 0.01035111f, -0.04600788f, -0.02027212f, -0.11371785f, 0.25613770f, 0.04539061f, 0.06614242f, 
    -0.34066084f, -0.02477608f, -0.22381398f, 0.14456786f, -0.10503231f, 0.34958342f, 0.23671944f, 0.07388308f, 
    -0.20626986f, 0.13614361f, -0.30761290f, -0.21165960f, 0.23378864f, 0.18748111f, -0.10675488f, 0.00131776f, 
    0.06224552f, 0.10556112f, -0.44577044f, -0.03106259f, -0.05913674f, 0.30110168f, 0.17289084f, -0.11289077f, 
    -0.07787044f, 0.10154804f, 0.36361191f, 0.01365794f, -0.09500004f, 0.13993207f, 0.06806059f, 0.26971334f, 
    -0.23300362f, -0.21379679f, 0.17913085f, -0.09693731f, -0.00626649f, -0.09169137f, 0.05583541f, 0.15518118f, 
    -0.09837870f, 0.05702889f, -0.02753669f, 0.10183964f, 0.22110336f, -0.18592517f, -0.07864893f, 0.13255252f, 
    -0.06936286f, -0.00304954f, 0.11580065f, -0.08061855f, -0.07507668f, 0.02830695f, -0.05646391f, -0.03413779f, 
    -0.17915824f, 0.02852147f, -0.11032882f, -0.02805344f, -0.12508534f, 0.06950288f, -0.19280559f, 0.07149492f, 
    0.28408363f, 0.19083552f, -0.37294456f, 0.08384752f, 0.28264010f, -0.06247789f, -0.02818341f, -0.05672740f, 
    0.13448593f, 0.27503204f, 0.01133966f, -0.08201332f, 0.15733615f, 0.04814846f, 0.29013798f, 0.03247475f, 
    0.00308447f, 0.13596249f, 0.46883920f, -0.29647517f, -0.20549873f, -0.02316583f, -0.12942979f, 0.05428499f, 
    -0.13826866f, -0.15596370f, 0.19263452f, 0.22701730f, 0.27610987f, -0.38106793f, 0.03160146f, -0.19087228f, 
    0.43628529f, -0.25647888f, 0.08060985f, -0.05038410f, 0.19968213f, 0.00846771f, 0.38061810f, 0.24305020f, 
    -0.01804993f, -0.09138940f, 0.17312415f, 0.04713370f, -0.22390719f, 0.03095879f, 0.09137870f, -0.26132014f, 
    -0.05706637f, 0.10873407f, 0.06712316f, 0.05002666f, -0.03985088f, 0.00160404f, -0.06482345f, -0.06407586f, 
    0.06993958f, -0.05032441f, -0.05203064f, 0.04166132f, 0.00895044f, -0.07693513f, -0.00118781f, 0.11835484f, 
    -0.04664182f, -0.11923497f, 0.03609746f, 0.02926011f, -0.11663450f, -0.03730167f, -0.11022737f, 0.03374520f, 
    -0.12269256f, -0.10520183f, -0.02352360f, 0.07817776f, -0.12469158f, -0.04236934f, 0.08814115f, -0.00777821f, 
    0.01588014f, 0.06547605f, -0.06966665f, -0.04018265f, -0.00162595f, -0.00307784f, -0.01776599f, -0.10588537f, 
    0.05761998f, 0.00502087f, 0.01423779f, -0.07636005f, -0.04648326f, -0.07241831f, -0.01208229f, -0.14701694f, 
    -0.14266939f, -0.05441031f, 0.02722439f, -0.10717738f, 0.01688419f, -0.00733048f, 0.03973202f, 0.03363243f, 
    -0.03050876f, 0.00876594f, -0.04942923f, -0.08124837f, 0.00211712f, 0.09080584f, -0.06346817f, 0.04153113f, 
    0.09888969f, -0.11775127f, 0.04379409f, -0.05422314f, -0.09286574f, 0.08711138f, -0.05174337f, 0.04243048f, 
    0.08558889f, -0.10750915f, 0.10076929f, 0.03392316f, 0.07434844f, 0.09764443f, -0.11784879f, -0.09311549f, 
    -0.10387511f, 0.10402521f, -0.07929981f, -0.11856440f, 0.05278852f, 0.00798231f, -0.10530993f, 0.07214330f, 
    -0.13535058f, -0.11204899f, -0.03037447f, -0.02852329f, -0.01862947f, -0.08487662f, 0.01839943f, 0.10836338f, 
    0.09323400f, 0.10873763f, 0.09584715f, 0.07079554f, 0.09869470f, -0.10781882f, -0.10514440f, 0.05740622f, 
    -0.02021709f, -0.06075095f, 0.01922428f, 0.01947757f, -0.04960620f, 0.05864335f, -0.10091811f, -0.07002831f, 
    -0.09329525f, 0.03571801f, 0.00019277f, -0.10890965f, -0.00188058f, -0.08129325f, 0.09001778f, -0.10280177f, 
    0.06606122f, -0.11272375f, 0.10365286f, 0.03919873f, -0.07668649f, -0.00478258f, 0.06751092f, -0.03681426f, 
    0.04602149f, 0.08961447f, -0.05173035f, 0.10203425f, 0.04976378f, -0.10552922f, 0.02948894f, -0.04929406f, 
    0.00670803f, 0.08423566f, 0.00933290f, -0.01007742f, -0.32907656f, -0.02652115f, 0.05934781f, 0.05173945f, 
    0.25622821f, -0.04403825f, -0.23231649f, 0.25544387f, 0.14450456f, -0.11253538f, 0.33733135f, -0.11934977f, 
    -0.17016537f, 0.31932268f, -0.04363899f, -0.14725651f, -0.14111832f, -0.23724060f, 0.09182689f, 0.09285577f, 
    -0.00018762f, 0.11582554f, 0.20010151f, -0.15119343f, -0.23568666f, 0.23076411f, 0.15209725f, -0.00056993f, 
    -0.22726271f, -0.04748206f, -0.00187621f, -0.11351978f, 0.14159091f, 0.09650881f, -0.14068009f, -0.34024245f, 
    0.44128728f, -0.39126852f, 0.09775978f, -0.04717777f, 0.54206002f, 0.10055812f, 0.19415802f, 0.24343063f, 
    0.01508961f, 0.07702838f, -0.08178590f, 0.11206021f, -0.06811418f, -0.09167834f, 0.39292088f, -0.01449902f, 
    0.13174838f, 0.01449047f, 0.04256548f, 0.00312635f, -0.13383761f, 0.03239775f, -0.00707032f, 0.12709609f, 
    -0.03406816f, 0.10436761f, -0.30799365f, 0.20251341f, -0.35376507f, 0.20827730f, 0.00285900f, 0.09413505f, 
    -0.08168396f, -0.29486239f, 0.35910037f, -0.11303388f, 0.01353878f, -0.56583261f, 0.34847778f, -0.01889440f, 
    0.02117013f, 0.29975414f, 0.31968683f, 0.00093628f, 0.04147019f, -0.21039715f, 0.10549495f, 0.01106567f, 
    -0.11276986f, 0.03886198f, -0.25479156f, 0.42532912f, -0.03181405f, 0.14010333f, 0.18167450f, 0.07087843f, 
    0.04560332f, 0.12897404f, 0.21927679f, -0.14220478f, -0.25073633f, 0.13026649f, -0.11487827f, -0.25807866f, 
    0.66719270f, -0.14106791f, 0.14584941f, -0.09357177f, 0.18691707f, 0.12552430f, 0.25272018f, -0.01031023f, 
    -0.10157122f, -0.02831956f, 0.27348119f, -0.06735102f, 0.08551734f, 0.05692591f, 0.06991930f, -0.27342874f, 
    -0.12018882f, -0.03046879f, 0.06098067f, -0.01189615f, -0.12416873f, 0.03879718f, -0.01124609f, -0.13705309f, 
    -0.08735234f, -0.06123225f, -0.08289196f, -0.01517161f, 0.04907695f, 0.09696405f, 0.05283974f, 0.09008671f, 
    -0.01193472f, -0.12154377f, -0.09691385f, -0.11674558f, -0.00627701f, -0.06024452f, -0.04467915f, 0.10380249f, 
    -0.07423949f, 0.01922937f, -0.11268362f, -0.09322441f, -0.06480208f, -0.07280207f, 0.11357498f, -0.01239437f, 
    -0.12181054f, -0.08390878f, 0.02781891f, -0.11976446f, -0.04323803f, -0.14624391f, -0.00928582f, 0.02571011f, 
    -0.08345293f, -0.09364086f, 0.00909528f, 0.03845566f, 0.08794168f, 0.09809162f, -0.10154366f, 0.10032024f, 
    0.03753917f, 0.10015900f, 0.00162275f, 0.10334003f, 0.04760043f, -0.10281676f, 0.06342363f, -0.10766904f, 
    -0.04180136f, 0.11081310f, -0.01812943f, 0.05189975f, -0.05181563f, 0.07819623f, 0.05340102f, -0.00350120f, 
    0.01492049f, -0.01708484f, 0.05655955f, 0.12160456f, -0.32941082f, -0.11733416f, 0.06001213f, 0.29766977f, 
    -0.13969617f, 0.08657497f, 0.02355551f, -0.02911958f, 0.09498218f, 0.34953031f, 0.05585061f, -0.05830052f, 
    -0.08588292f, 0.16493745f, -0.06609985f, 0.09117784f, -0.09419181f, 0.49848568f, -0.12635358f, 0.00134591f, 
    0.14956886f, -0.02341499f, -0.07566572f, 0.27641210f, -0.10909522f, 0.22826551f, -0.41366976f, -0.04994922f, 
    0.05684507f, 0.05823977f, -0.15467989f, 0.19866516f, 0.12207885f, 0.37543756f, -0.09019683f, 0.07036404f, 
    -0.03565120f, 0.35551396f, -0.04856599f, 0.05655807f, 0.25541720f, -0.05099695f, 0.12002255f, -0.28293523f, 
    -0.40009540f, -0.38320416f, 0.07250066f, -0.10517971f, 0.37189049f, 0.00117131f, -0.02797910f, 0.23787677f, 
    0.04156874f, 0.03458594f, 0.16938682f, 0.14607702f, -0.17065310f, -0.04392793f, 0.30653709f, -0.14410044f, 
    0.17996807f, -0.04395790f, 0.04371830f, 0.05830991f, -0.02348712f, -0.08198659f, 0.05039601f, -0.14238207f, 
    -0.00147417f, -0.11222746f, -0.08915865f, -0.07714712f, -0.09026442f, 0.04028742f, 0.05242585f, -0.08135678f, 
    -0.30479220f, -0.05420957f, 0.03402187f, -0.03870111f, 0.13230424f, 0.11195827f, 0.21816085f, -0.06846891f, 
    -0.16112562f, 0.12623213f, -0.01596287f, -0.07656526f, 0.41133958f, -0.02024331f, 0.13354187f, -0.06666413f, 
    -0.00609832f, 0.18473934f, -0.30202243f, 0.25162569f, -0.09495223f, -0.07089864f, 0.16256963f, -0.00682358f, 
    0.03078624f, 0.08437906f, 0.27764761f, 0.07150389f, -0.33029127f, 0.11645535f, 0.12204484f, 0.35437992f, 
    0.07131606f, 0.18055458f, 0.24306850f, -0.09366676f, -0.27131677f, -0.04770927f, 0.14161785f, -0.04073060f, 
    0.12335090f, 0.03748621f, 0.13061729f, 0.00205565f, 0.54201716f, 0.01126543f, -0.19164614f, 0.18334033f, 
    0.05178664f, 0.11977401f, -0.10290509f, 0.10570262f, 0.01423396f, 0.00395437f, 0.00836568f, -0.06182392f, 
    -0.03136947f, -0.08696185f, 0.01479706f, 0.02210165f, -0.11164019f, 0.02202788f, 0.01010892f, -0.11195952f, 
    -0.01873565f, 0.11121689f, 0.04691130f, -0.00892471f, -0.07918928f, -0.02232927f, -0.00698593f, 0.03825334f, 
    0.07796648f, -0.13583428f, -0.03292483f, 0.09013002f, -0.01157114f, -0.00693060f, 0.12344278f, -0.03076242f, 
    0.06230693f, -0.02189768f, 0.00541657f, -0.08733617f, -0.13362227f, -0.08694017f, -0.08653592f, 0.03978481f, 
    -0.02362628f, 0.04838656f, 0.04373089f, -0.11247125f, -0.09526852f, 0.09166165f, 0.08105244f, -0.02541819f, 
    0.05159513f, 0.08112743f, 0.02085303f, -0.08684728f, -0.14394003f, 0.00047080f, -0.06202349f, -0.02426164f, 
    0.05161914f, 0.08481395f, -0.13822976f, 0.06740556f, -0.13117681f, -0.12175898f, -0.14298338f, 0.06132210f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.05964679f, 0.10596584f, -0.01624962f, 0.00173209f, 0.02480407f, -0.06462378f, 0.22163446f, 0.05162495f, 
    0.11653914f, -0.01475908f, 0.07576652f, -0.12896946f, 0.10147280f, -0.01073362f, 0.03784019f, -0.11556350f, 
    -0.04437847f, 0.02311529f, 0.10574602f, 0.11156880f, -0.07350433f, 0.06662483f, 0.19165149f, -0.12615511f, 
    0.12145400f, -0.09817745f, -0.13797301f, 0.11262566f, 0.22246449f, -0.02123824f, 0.03043125f, -0.01863839f, 
    0.05470737f, 0.17739232f, -0.08620789f, -0.09841463f, 0.12990873f, 0.10135297f, -0.04747225f, 0.02525833f, 
    0.03224045f, 0.08447620f, 0.15857035f, -0.01207582f, 0.08946713f, -0.03045657f, 0.09456543f, 0.19964150f, 
    -0.00894740f, 0.04703040f, 0.20010109f, -0.01506848f, 0.02956960f, 0.11062372f, 0.15210266f, 0.07919628f, 
    0.09838589f, -0.03676381f, -0.04861734f, -0.08578000f, -0.03373441f, 0.14285803f, -0.01985452f, -0.06293022f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.11359895f, -0.08799326f, -0.13936561f, -0.08664912f, -0.00832559f, 0.03660580f, 0.01643956f, -0.21443368f, 
    -0.48919079f, -0.01102384f, -0.05405593f, 0.09054888f, 0.14859608f, 0.09867080f, 0.17862406f, -0.05462259f, 
    0.02461270f, -0.00693365f, -0.06972100f, 0.32401097f, -0.27945548f, 0.07991684f, -0.04995793f, 0.10116742f, 
    0.01099118f, 0.04597900f, 0.09466983f, -0.01959998f, -0.11858531f, -0.55610722f, 0.22756323f, -0.64836282f, 
    -0.13493015f, -0.42706165f, 0.26448554f, -0.02814693f, 0.17865354f, -0.37913170f, 0.04929973f, -0.09906141f, 
    0.05789335f, 0.16798955f, -0.39545783f, 0.26671919f, -0.28483817f, -0.06971336f, -0.02873839f, -0.19642463f, 
    0.24761014f, -0.18176560f, 0.13819022f, 0.19274503f, -0.18197848f, 0.27650586f, 0.01600699f, -0.38342723f, 
    0.02239991f, 0.09067061f, -0.39840990f, 0.12178319f, -0.07650228f, 0.08594250f, 0.09406070f, 0.06374023f, 
    0.09820098f, 0.06551541f, 0.09150416f, -0.09994976f, 0.11690403f, 0.07860496f, -0.15685658f, 0.19682279f, 
    -0.17300428f, 0.17566995f, -0.14424472f, 0.03055898f, 0.02627902f, 0.02820474f, -0.27710581f, -0.08745927f, 
    -0.11903091f, -0.07159656f, 0.07372871f, -0.54264271f, -0.17242987f, 0.07744705f, 0.00392331f, 0.04909164f, 
    0.28364742f, 0.22317445f, -0.01109240f, -0.15334922f, -0.30114701f, -0.01255185f, 0.06465677f, 0.30140173f, 
    -0.10196592f, 0.18365249f, 0.10117967f, 0.03433973f, -0.13081057f, -0.20539695f, -0.04338388f, -0.04200605f, 
    0.00823882f, -0.45835525f, 0.14674565f, 0.21481767f, -0.10192089f, 0.20671844f, 0.01122195f, -0.03002478f, 
    -0.23826168f, -0.11485834f, -0.07854608f, -0.21457583f, 0.26745528f, 0.22505376f, 0.05616510f, -0.45489988f, 
    -0.13565132f, -0.02178960f, -0.44754806f, 0.04947671f, -0.00451489f, 0.10836992f, 0.21754339f, -0.09094933f, 
    0.22438116f, -0.07592426f, -0.15397246f, 0.01785541f, -0.24254334f, -0.02236406f, 0.26023906f, 0.24017185f, 
    0.23475415f, 0.15617862f, -0.39082068f, -0.07459780f, 0.00421589f, 0.38509345f, -0.02166735f, -0.08170740f, 
    0.04521274f, 0.09929430f, 0.07177363f, -0.06284498f, -0.37326786f, 0.05247214f, -0.37491423f, 0.01393891f, 
    -0.16317537f, -0.31473833f, -0.03348183f, 0.10068028f, -0.33526638f, -0.28761464f, -0.37787414f, -0.63034099f, 
    0.03211717f, -0.44975331f, 0.10749763f, -0.01766333f, -0.34091097f, 0.20471913f, 0.09171592f, -0.18182363f, 
    0.04759364f, -0.01419549f, 0.25112838f, 0.12648523f, 0.04267468f, 0.38552213f, -0.01726084f, -0.34439427f, 
    0.31543255f, 0.28642038f, -0.68607318f, -0.44342771f, 0.03849845f, -0.04405701f, 0.19532208f, -0.04125876f, 
    -0.11909533f, 0.11885425f, -0.56003565f, -0.52610338f, 0.01172677f, 0.11144187f, 0.03994664f, 0.11408918f, 
    0.11389180f, -0.00308943f, -0.08421056f, -0.05023348f, -0.57619089f, 0.05471047f, -0.17883752f, -0.51327091f, 
    0.05339043f, -0.41679829f, 0.08045353f, -0.02813881f, 0.12502711f, -0.00427388f, -0.04431770f, -0.10679945f, 
    -0.07764150f, 0.09367024f, 0.05458494f, 0.08384465f, 0.26875180f, 0.10530658f, 0.19889449f, 0.03360250f, 
    -0.44505161f, -0.54991555f, -0.08474313f, 0.09394234f, 0.20319088f, -0.01265724f, -0.03934658f, 0.16131456f, 
    -0.04667580f, 0.05035337f, -0.32599834f, 0.08517870f, 0.23713496f, 0.27338669f, 0.00198101f, 0.30564490f, 
    -0.06089401f, -0.17075649f, -0.50134939f, -0.44890279f, 0.26008743f, -0.09975605f, 0.09191742f, 0.24758075f, 
    0.06228660f, -0.23213080f, 0.08447358f, 0.02343365f, -0.00643010f, -0.46301654f, -0.17146376f, 0.12974153f, 
    -0.07605920f, -0.09140588f, 0.08007877f, 0.01855864f, 0.02795460f, -0.35804275f, -0.03251647f, 0.02596601f, 
    0.29186884f, -0.04048603f, -0.12409226f, -0.08828790f, -0.11715058f, 0.14637437f, 0.13707307f, -0.17936371f, 
    0.05354264f, -0.10899401f, 0.16549470f, -0.02047461f, 0.03709349f, -0.20304643f, 0.20597318f, -0.08919443f, 
    0.05088679f, -0.04589216f, 0.09417118f, 0.21019709f, 0.27105236f, -0.10073218f, -0.15420713f, -0.08834875f, 
    -0.20368765f, -0.25439617f, 0.08038058f, 0.13484363f, 0.26346490f, -0.61328340f, 0.06002934f, -0.30761310f, 
    -0.08515614f, -0.33981475f, -0.34154302f, -0.07221702f, 0.01259782f, 0.19947869f, -0.05428207f, 0.04784028f, 
    -0.01741023f, 0.08230489f, 0.08078064f, 0.04250640f, 0.01236106f, -0.11855478f, -0.09724133f, -0.11255629f, 
    -0.05786221f, 0.05515403f, 0.06957103f, -0.04129337f, -0.14701952f, 0.06261025f, -0.21690051f, -0.04136486f, 
    0.11506096f, -0.05819768f, -0.14164080f, 0.07355988f, -0.04375480f, 0.15622754f, -0.22908366f, 0.01281959f, 
    -0.11160988f, -0.02950023f, -0.04645988f, -0.10351650f, 0.18381965f, 0.13934484f, -0.09642547f, -0.10271252f, 
    -0.00765520f, 0.19582735f, 0.19198157f, -0.04876334f, 0.19546019f, -0.54871792f, 0.18555897f, -0.12433022f, 
    -0.06055053f, -0.11645107f, -0.08672352f, -0.31984845f, 0.18956783f, 0.07196132f, -0.01430175f, 0.01398266f, 
    0.01781519f, 0.24765049f, 0.11460505f, -0.15599297f, 0.09988713f, 0.31624237f, 0.04137567f, 0.05251018f, 
    0.02447643f, 0.23231918f, -0.34868869f, 0.08571291f, -0.22363871f, -0.22040865f, -0.04697476f, -0.23335361f, 
    0.04893011f, -0.17929272f, -0.10721973f, 0.09456914f, -0.32056311f, -0.67495078f, 0.04561074f, 0.00164549f, 
    -0.36988381f, -0.02298355f, 0.21298696f, 0.09511735f, 0.12240095f, 0.09356184f, -0.04232906f, -0.39134377f, 
    -0.04782043f, 0.03865746f, 0.15075682f, 0.09821298f, 0.10070503f, 0.21500906f, -0.40429518f, 0.08881788f, 
    -0.68532199f, 0.06083625f, 0.08336302f, 0.04980417f, -0.05070100f, -0.00456417f, 0.18991931f, 0.19215915f, 
    0.29043686f, 0.19582844f, 0.22155851f, -0.03474844f, 0.25113249f, -0.35567364f, -0.00080195f, 0.00780473f, 
    -0.06522233f, 0.11662646f, -0.02443337f, -0.25026816f, -0.29873115f, 0.01383448f, 0.06965330f, -0.03305571f, 
    -0.43391541f, -0.43073002f, 0.05410250f, 0.32030711f, 0.19620098f, 0.12162540f, 0.03365689f, -0.35262915f, 
    -0.04836985f, -0.46354517f, -0.71762258f, 0.03922563f, -0.07938351f, 0.21897943f, 0.01144817f, -0.51574779f, 
    -0.09127599f, -0.34920889f, 0.24654631f, -0.15838909f, -0.36274406f, -0.07574632f, 0.04145046f, 0.20057319f, 
    -0.46511975f, 0.12310933f, 0.10191314f, -0.44135731f, 0.08907262f, -0.24336936f, -0.27370691f, 0.04762652f, 
    -0.03087375f, 0.04469806f, -0.16614012f, -0.59503376f, -0.07058915f, 0.06782806f, -0.40010592f, 0.08978031f, 
    0.20388624f, -0.02763512f, -0.02846437f, -0.11105912f, 0.00179395f, -0.12091772f, -0.57087356f, -0.42403135f, 
    -0.46727976f, -0.31075040f, 0.23766512f, 0.03424151f, -0.34074551f, -0.06166572f, 0.13335723f, -0.10439922f, 
    -0.03640893f, -0.05220610f, 0.10125814f, 0.15698963f, 0.13409750f, -0.04439894f, 0.14416514f, -0.07696680f, 
    0.11825865f, 0.18247549f, 0.11863291f, -0.18776412f, 0.05300186f, -0.04566609f, 0.16360402f, 0.31014636f, 
    0.05781327f, 0.11327569f, 0.04965494f, -0.07405837f, 0.16375750f, -0.24457616f, -0.06905580f, 0.24058552f, 
    -0.10292055f, -0.32752106f, -0.23217390f, 0.04650543f, -0.01566859f, 0.05027995f, -0.07553242f, 0.03833018f, 
    -0.18722118f, -0.63821507f, 0.12131736f, 0.16936393f, -0.04328199f, 0.08238773f, -0.36925194f, -0.46607780f, 
    -0.12112555f, -0.07760481f, -0.06034612f, 0.06419228f, 0.05041671f, -0.36794671f, 0.02786116f, 0.08087169f, 
    0.10470635f, 0.00251569f, -0.09520406f, 0.01048079f, 0.19522806f, 0.11256915f, -0.28813931f, 0.03306325f, 
    0.00204268f, -0.01998431f, -0.27917004f, -0.09805612f, -0.32935348f, 0.01788562f, -0.28937250f, 0.05619561f, 
    0.10418686f, -0.11753719f, 0.05137685f, -0.23115556f, -0.34887958f, 0.03056188f, 0.06550451f, -0.09995937f, 
    0.33374819f, 0.28217626f, 0.11514377f, -0.81248343f, -0.35061878f, 0.35210326f, -0.44771713f, -0.34856746f, 
    -0.08971768f, -0.14400865f, 0.24606332f, 0.07124147f, -0.19389527f, -0.62879199f, -0.08084127f, -0.45484969f, 
    0.01134458f, 0.16130160f, -0.17401461f, 0.02039257f, -0.03349929f, 0.02878697f, -0.03416238f, -0.21796459f, 
    -0.06771702f, -0.23428422f, 0.10325977f, -0.25203580f, 0.07753205f, -0.05670093f, 0.31800833f, 0.20555207f, 
    -0.10740005f, 0.05275952f, 0.43725497f, 0.29713005f, -0.09272434f, 0.01939166f, 0.08919102f, -0.07096874f, 
    -0.40781564f, 0.06200845f, 0.02269669f, 0.09470473f, 0.13487485f, 0.02232551f, 0.11091790f, 0.15384883f, 
    -0.25285718f, 0.07422469f, 0.17437032f, -0.13458177f, -0.08520450f, 0.00405737f, 0.16559069f, -0.03273858f, 
    -0.00826132f, -0.04284211f, 0.09599057f, 0.33080271f, -0.56259149f, -0.03058828f, -0.47219214f, 0.02945588f, 
    -0.36943096f, 0.00821325f, -0.01103693f, 0.14970119f, -0.05133503f, 0.24966411f, -0.13367365f, -0.45816624f, 
    0.07482213f, -0.32992673f, 0.01375108f, -0.11250011f, -0.27611810f, -0.04011460f, -0.08254752f, -0.26936617f, 
    -0.11374737f, 0.33833078f, 0.14743719f, 0.16606319f, -0.62118685f, -0.83902764f, -0.05406531f, -0.28560120f, 
    0.16163677f, 0.15929447f, -0.07564092f, 0.11200012f, -0.37270308f, -0.15056454f, -0.26409486f, 0.31059301f, 
    -0.08205009f, 0.05913682f, 0.37290275f, -0.27803314f, 0.06922031f, 0.12899433f, -0.36800930f, -0.03200952f, 
    -0.37281045f, -0.03186347f, 0.08164106f, 0.02857480f, -0.17407194f, 0.10510286f, -0.07776269f, 0.13849957f, 
    0.25583124f, -0.07409301f, 0.03837269f, 0.03490677f, -0.59534919f, 0.23053840f, 0.09610032f, -0.01650693f, 
    -0.06966053f, 0.08454936f, -0.04484973f, -0.16258101f, -0.15862474f, -0.10212685f, 0.18668118f, 0.09778750f, 
    0.22312677f, -0.17718755f, 0.00721216f, -0.03316774f, 0.07377439f, 0.05322140f, -0.20406501f, 0.12819287f, 
    0.00053437f, 0.11984489f, -0.01683627f, -0.03069071f, 0.15833496f, -0.30613387f, -0.02426441f, -0.12536618f, 
    0.00152466f, 0.15158005f, -0.65117645f, 0.00676382f, 0.08476217f, 0.15543614f, 0.11062123f, -0.00164513f, 
    0.30676839f, -0.05317714f, -0.11076820f, 0.07405544f, -0.39411113f, -0.32980651f, 0.29680517f, -0.13796563f, 
    -0.00929379f, -0.07278100f, 0.08053543f, -0.42998105f, 0.03937329f, 0.09610781f, 0.22553173f, 0.07340382f, 
    0.10031931f, -0.09236462f, -0.01461127f, 0.06356427f, -0.38255522f, 0.09475248f, 0.17068107f, -0.14244741f, 
    0.15541673f, -0.10178683f, -0.36087570f, 0.07586359f, 0.18173985f, -0.01629395f, -0.38121235f, -0.13338308f, 
    0.03601683f, -0.04429493f, -0.07618076f, -0.02402959f, 0.19627963f, -0.08162646f, 0.14122744f, 0.06981241f, 
    -0.17931722f, -0.43181771f, 0.08157957f, -0.04992033f, 0.10045630f, -0.30165341f, -0.27086106f, -0.32176942f, 
    0.06123870f, 0.22824772f, 0.10458907f, -0.02642261f, -0.15473075f, -0.01958898f, -0.10999537f, -0.56136423f, 
    -0.00536356f, 0.18522757f, 0.17516769f, -0.37408194f, 0.25185260f, -0.19288287f, 0.08449095f, 0.09011740f, 
    0.05646322f, 0.10198131f, -0.37065205f, 0.02261802f, -0.29611039f, -0.23860539f, -0.06293018f, 0.39945468f, 
    -0.08420884f, -0.07180735f, 0.19459066f, 0.39401749f, -0.05101982f, -0.08214442f, 0.20066383f, -0.02455529f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.01020409f, 0.11429667f, -0.14622486f, -0.02216946f, -0.04263565f, 0.02090126f, -0.00577990f, -0.20725241f, 
    -0.16339447f, -0.11586071f, 0.17364384f, 0.07906303f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
