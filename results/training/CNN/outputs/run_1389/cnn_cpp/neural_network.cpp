#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.48124114f, -0.59000051f, -0.52931774f, -0.38948917f, 0.03525347f, 0.34634990f, 0.17149146f, -0.14265810f, 
    -0.23588863f, 0.35569981f, 0.16544072f, -0.11282924f, 0.09496371f, -0.01486905f, -0.20208873f, 0.09525070f, 
    0.00166271f, -0.11103241f, 0.05758132f, 0.02556120f, -0.31352651f, -0.28399915f, -0.43975282f, -0.35023975f, 
    -0.16355476f, 0.63803643f, 0.11243690f, -0.54966146f, -0.88671303f, -0.74568158f, -0.10530720f, -0.26347482f, 
    0.16942193f, 0.23105109f, 0.47786832f, 0.17223100f, 0.21705197f, 0.27650744f, 0.03541102f, 0.06132970f, 
    -0.05369334f, -0.06673712f, 0.06065757f, 0.05823261f, -0.09918695f, 0.06541900f, -0.21812643f, -0.10223237f, 
    0.01025497f, -0.07405224f, 0.68896550f, 0.14427322f, -0.08587413f, -0.33747429f, -0.57176924f, 0.13566256f, 
    -0.02469148f, 0.03273206f, 0.07841838f, 0.01546793f, -0.15530871f, -0.11934840f, -0.06262337f, -0.00392538f, 
    -0.08022418f, -0.21576004f, 0.14169140f, 0.05454096f, -0.33549199f, -0.06428294f, -0.35229865f, -0.25828949f, 
    -0.21752815f, -0.38467652f, -0.46393996f, 0.60990781f, 0.62660486f, 0.11992899f, 0.06404512f, -0.60917765f, 
    -0.44944572f, -0.30687889f, -0.04272966f, -0.04480986f, -0.16056007f, 0.07185785f, 0.15024087f, -0.05233772f, 
    0.22380830f, 0.21064293f, 0.17294079f, -0.18728708f, -0.01232007f, 0.32121509f, -0.47824228f, 0.12637846f, 
    -0.03023061f, -0.08795875f, -0.16388376f, -0.17620115f, -0.94599873f, 0.26500943f, 0.48927948f, 0.32467991f, 
    -0.17294152f, 0.26163572f, -0.76985097f, 0.00348818f, 0.00264424f, 0.07175159f, 0.22901693f, -0.44778761f, 
    -0.35241398f, -0.27826214f, 0.40744647f, 0.07446441f, -0.10603545f, 0.17512529f, 0.07844137f, 0.05929098f, 
    0.15459853f, -0.13987115f, 0.08949970f, 0.06235289f, -0.18561257f, 0.52278185f, -0.24119702f, 0.09403703f, 
    -0.01251460f, -0.38009650f, -0.09814129f, -0.58358753f, 0.08158346f, 0.25566933f, -0.16630472f, -0.24587820f, 
    -0.17406607f, -0.06173226f, 0.04064038f, 0.03632931f, 0.27243373f, 0.24439213f, -0.13213909f, -0.04536152f, 
    0.06066827f, 0.11156905f, -0.27821594f, -0.09653697f, -0.42182392f, -0.33510330f, -0.16534188f, -0.41703439f, 
    -0.31758907f, 0.27555063f, 0.44963509f, 0.29293987f, 0.60753453f, 0.05026339f, -0.30748919f, -0.19652137f, 
    0.09806667f, -0.29009810f, -0.07488300f, -0.29262134f, 0.02444153f, 0.09852365f, -0.10292029f, -0.11261817f, 
    -0.29331967f, 0.07725988f, -0.07717473f, -0.04558872f, 0.12956044f, -0.05871973f, 0.11804853f, -0.74871129f, 
    -0.63643479f, 0.29050151f, 0.27109969f, -0.05971845f, 0.31419361f, 0.11500602f, 0.21221860f, -0.30807516f, 
    0.20283347f, 0.18429676f, -0.35742798f, 0.17707162f, 0.15271543f, -0.01426738f, -0.32642534f, -0.04931819f, 
    0.02697471f, -0.23632777f, 0.30168030f, 0.21988046f, 0.10905195f, 0.20503210f, -0.22600633f, 0.13873512f, 
    0.28774688f, -0.13189273f, 0.00496300f, 0.16093303f, -0.36145082f, 0.09875207f, 0.18341014f, 0.09434141f, 
    -0.08105791f, -0.17727622f, -0.03659899f, -0.10160187f, 0.03915841f, -0.13766985f, 0.04029899f, -0.20946606f, 
    0.11966616f, 0.21095383f, 0.05773652f, -0.17034252f, 0.07446802f, 0.00630652f, 0.02685142f, -0.23940121f, 
    -0.31834483f, -0.83764607f, 0.26928619f, 0.28430837f, -0.10095204f, -0.47834158f, -0.15291075f, 0.19492830f, 
    0.04347017f, 0.55099994f, -0.41698018f, -0.17038830f, -0.09740800f, -0.40369296f, 0.57372361f, 0.09714895f, 
    -0.05655722f, -0.29124773f, -0.14071105f, -0.32296190f, -0.16062987f, 0.10012762f, 0.17152740f, 0.36797509f, 
    -0.19340450f, -0.44009569f, 0.70253122f, -0.16265459f, 0.16391146f, 0.23477696f, -0.55550814f, 0.07603241f, 
    0.12012969f, 0.43953395f, 0.33774227f, -0.33627349f, -0.14812261f, 0.11425730f, -0.18196824f, -0.08560112f, 
    -0.26690745f, 0.25070688f, 0.11874442f, -0.20848839f, -0.20472208f, -0.17527777f, 0.22829856f, -0.10672455f, 
    0.01795999f, -0.00620297f, -0.02587702f, -1.01776171f, -0.16901252f, 0.09457050f, -1.07806444f, -0.79575711f, 
    0.18695186f, 0.29996377f, -0.25753698f, 0.19184315f, 0.31691384f, 0.03794281f, -0.32175040f, -0.29431784f, 
    -0.47935322f, -0.20439057f, 0.17060718f, 0.31407288f, 0.16215259f, -0.03350509f, -0.09865009f, -0.06725962f, 
    0.02665932f, 0.14014471f, -0.12813275f, 0.07885782f, -0.25633213f, -0.03761648f, 0.34379551f, 0.38597667f, 
    0.11990815f, 0.01820213f, 0.06020396f, -0.31271666f, 0.00465950f, 0.07356877f, -0.17296694f, 0.26895940f, 
    -0.20119737f, -0.15643811f, 0.21075338f, -0.26243192f, 0.00836569f, -0.13198210f, -0.08958603f, 0.42650691f, 
    -0.09227292f, -0.08693505f, 0.04810789f, 0.17569080f, -0.27474058f, -0.85264826f, -0.07093149f, -0.48337153f, 
    -0.84799099f, -0.55292523f, 0.57309276f, 0.11484680f, -0.31985843f, 0.21987292f, 0.17186850f, -0.39625606f, 
    -0.22645366f, -0.13407931f, -0.50003415f, -0.41809815f, -0.04955830f, -0.13984750f, -0.08427039f, 0.01322886f, 
    0.01917068f, 0.07290933f, 0.06883373f, -0.00770048f, 0.01518849f, 0.12720905f, -0.05443868f, 0.12831011f, 
    -0.07202502f, 0.12086567f, -0.34804597f, 0.12432775f, 0.17287602f, 0.12110461f, 0.03829133f, 0.16264327f, 
    -0.13119310f, 0.40958500f, -0.06272183f, -0.15949047f, -0.15909360f, -0.19368376f, -0.17155880f, -0.33941877f, 
    0.34426239f, 0.23994012f, 0.36992186f, -0.23671852f, 0.23120505f, -0.14666067f, -0.19874759f, 0.45918325f, 
    -0.16956609f, 0.13293852f, 0.12216116f, 0.20066717f, 0.10021877f, -0.11636977f, -0.12611333f, 0.25548658f, 
    0.06050991f, 0.09371144f, 0.20486821f, 0.11190961f, -0.22562742f, -0.29832077f, -0.13187343f, -0.13118628f, 
    -0.07260419f, -0.04447671f, -0.29038072f, -0.27172855f, 0.16435353f, -0.22007659f, -0.05568140f, -0.16918807f, 
    0.01800284f, -0.18057860f, 0.09455859f, 0.10454923f, 0.18458176f, -0.43881014f, -0.22265181f, 0.20794992f, 
    0.48417264f, 0.07459901f, 0.30170664f, -0.04008272f, -0.31510043f, 0.16174200f, -0.25581673f, 0.16622223f, 
    0.16266613f, -0.30368629f, -0.29146999f, 0.27549914f, 0.07512658f, 0.15479758f, 0.04767630f, 0.02920136f, 
    -0.15847401f, -0.17266750f, 0.03875214f, -0.39049554f, -0.44790941f, -0.51813412f, -0.39949831f, -0.15827215f, 
    -0.38849384f, -0.36012706f, -0.18451408f, 0.42336014f, 0.16026601f, 0.24995387f, 0.13443789f, -0.08530343f, 
    -0.27020189f, -0.05681397f, -0.25119969f, -0.18286872f, -0.29803693f, -0.27477446f, -0.29556805f, -0.19787972f, 
    0.08498851f, -0.33527136f, -0.24711826f, 0.29359731f, -0.09824943f, -0.14762050f, 0.22380783f, 0.03730362f, 
    -0.09354961f, 0.12585329f, 0.03663569f, -0.03803422f, -0.03907650f, -0.09312595f, -0.22744298f, 0.21941729f, 
    -0.00220957f, 0.18079020f, 0.00539167f, -0.32698238f, 0.15103933f, -0.11647618f, -0.22312620f, 0.32343835f, 
    -0.10790471f, 0.02826746f, 0.06642610f, -0.23848595f, -0.46523279f, 0.20062220f, 0.10584528f, 0.01256943f, 
    -0.11719482f, -0.05309367f, 0.12567298f, 0.33541799f, 0.35662428f, -0.19189928f, 0.01084832f, 0.00718470f, 
    -0.14821526f, 0.23794316f, -0.51074308f, -0.08390172f, 0.32114750f, -0.25649422f, -0.27218467f, -0.14589527f, 
    0.32801431f, 0.10401353f, 0.25637949f, 0.34324953f, 0.02229772f, 0.52537423f, -0.19872980f, -0.43554127f, 
    -0.05436959f, -0.05698305f, -0.00167554f, 0.41837725f, 0.03032460f, -0.32643217f, -0.27684090f, -0.54546899f, 
    0.36882609f, 0.32234469f, -0.36061153f, -0.02215831f, 0.26404092f, 0.07135059f, -0.40085638f, -0.21745379f, 
    0.07207533f, -0.16811092f, 0.19923210f, 0.30245915f, 0.15276931f, -0.72650409f, -0.66921169f, -0.37382832f, 
    0.25705805f, 0.21994135f, 0.45945865f, 0.59756935f, 0.34559920f, -0.16176423f, -0.18139848f, 0.10749629f, 
    0.22593158f, -0.07967313f, 0.25871223f, -0.08587289f, 0.18930584f, 0.09078785f, -0.31569541f, -0.17506351f, 
    -0.12577294f, 0.05745239f, 0.04105261f, -0.01868541f, 0.20981246f, 0.01754334f, 0.02609088f, 0.53400707f, 
    -0.24184924f, -0.20320371f, 0.11713544f, -0.46623179f, -0.44722992f, 0.21091034f, 0.54943186f, 0.10956450f, 
    -0.27062607f, -0.43897408f, -0.27281049f, 0.04341562f, -0.17244963f, 0.20402610f, -0.03640097f, 0.14279887f, 
    -0.14568865f, 0.11906333f, -0.06557327f, 0.20537519f, -0.11695910f, -0.05943862f, -0.17405076f, 0.21165591f, 
    0.10703520f, 0.13313127f, -0.58393276f, -0.14455569f, -0.30336022f, -0.08844033f, 0.19021221f, 0.03835602f, 
    0.24420819f, -0.21165720f, -0.13399850f, -0.07319737f, -0.07696851f, -0.17147082f, 0.19207789f, 0.07435300f, 
    0.05059174f, -0.22534361f, -0.43947926f, -0.52304673f, -0.51220602f, -0.44340956f, -0.49271995f, -0.65514362f, 
    -0.65132850f, -0.51528037f, -0.60160130f, -0.19142485f, -0.38628131f, 0.37889102f, 0.28583089f, -0.15603064f, 
    0.13759866f, 0.67959762f, -0.00524955f, 0.35700232f, -0.09118820f, 0.08961551f, -0.24177435f, -0.08233400f, 
    0.13996705f, -0.13912955f, -0.12181149f, 0.26878965f, -0.09611809f, 0.00367076f, -0.02479470f, 0.19609363f, 
    -0.33100849f, 0.13932711f, -0.72894424f, 0.01161884f, 0.76405150f, 0.28596982f, -0.51565444f, -0.68752855f, 
    -0.69399238f, 0.35606748f, 0.26918384f, -0.12161706f, 0.39133522f, -0.02843298f, 0.15801813f, 0.14515387f, 
    0.29577041f, -0.13799195f, -0.09163488f, -0.07893072f, -0.15799466f, -0.04482824f, 0.08996638f, -0.14070165f, 
    0.02234115f, -0.08916899f, -0.11650503f, -0.46247610f, -0.16641152f, 0.03069381f, 0.67691338f, -0.61386937f, 
    -0.47288805f, 0.45675412f, 0.22536351f, 0.16080563f, -0.05756396f, -0.29350585f, -0.13814028f, 0.35082260f, 
    0.06467465f, 0.17147847f, 0.06433073f, -0.20074473f, -0.09370452f, 0.09325323f, 0.19217882f, -0.21352665f, 
    -0.06417466f, 0.34861445f, -0.28948864f, 0.14062861f, 0.56828016f, 0.31557110f, -0.24619906f, -0.16089831f, 
    0.37137598f, -0.05309841f, -0.02922387f, -0.42798337f, -0.43248039f, -0.03536960f, 0.02688546f, -0.05998090f, 
    0.09242998f, 0.34585834f, 0.09448235f, -0.35642588f, 0.07197610f, -0.02122494f, 0.30146354f, -0.00693093f, 
    0.28388336f, 0.18144350f, -0.39431742f, -0.21794498f, 0.26320490f, 0.62994021f, 0.30920464f, -0.08776877f, 
    -0.06226318f, -0.37526512f, -0.16070107f, 0.24498998f, -0.34447449f, -0.47673765f, -0.06178688f, 0.24674983f, 
    0.16533625f, -0.34118742f, -0.35039958f, -0.23924667f, 0.07693315f, -0.04195160f, 0.04411751f, -0.08379516f, 
    -0.03434601f, 0.08888067f, -0.18846469f, -0.10229617f, -0.06727577f, -0.13412674f, -0.56138611f, -0.49597275f, 
    0.04893623f, -0.08090382f, 0.20005961f, 0.28293255f, 0.00219786f, 0.23660208f, 0.05798462f, 0.35610563f, 
    0.06693553f, 0.11609972f, -0.35714716f, 0.14512716f, -0.25659987f, -0.27762669f, 0.19260554f, 0.39250287f, 
    -0.40248802f, -0.12926881f, 0.27725840f, 0.05976811f, -0.05547703f, 0.41014102f, 0.45790061f, 0.21373005f, 
    0.32094365f, 0.07860674f, 0.09651720f, 0.15955447f, 0.27364150f, 0.13703084f, 0.22556722f, -0.18177481f, 
    0.12058213f, 0.11416673f, 0.01773541f, -0.03609229f, 0.12970994f, 0.06773883f, -0.07339251f, 0.07403997f, 
    -0.07563715f, -0.19122258f, -0.14641136f, 0.19740103f, -0.08592746f, -0.04019113f, 0.14815228f, -0.88261604f, 
    -0.49836567f, -0.09825632f, 0.25170815f, 0.43215773f, -0.30887246f, -0.50669664f, 0.52173996f, 0.27900052f, 
    -0.11015141f, 0.01108290f, 0.23425907f, -0.06029521f, 0.25072411f, -0.07493491f, 0.04770054f, -0.08055252f, 
    -0.13049874f, -0.32139412f, -0.05207482f, 0.33557960f, -0.04751103f, -0.07809143f, 0.03244423f, 0.23085047f, 
    -0.99683684f, -0.33840975f, 0.10559759f, -0.19973570f, 0.78165114f, 0.37086955f, 0.81569511f, -0.73179567f, 
    -0.54851246f, -0.02928562f, 0.03427485f, -0.23593184f, -0.41136634f, -0.23258980f, -0.42361972f, -0.14802301f, 
    -0.07062113f, -0.19200316f, 0.08168799f, 0.09280150f, 0.21844120f, -0.21683794f, -0.08091303f, 0.03145747f, 
    -0.13473803f, 0.14203173f, -0.06024487f, -0.73874021f, -0.22734155f, 0.69564384f, -0.05277945f, 0.81193519f, 
    -0.73478496f, -0.27581474f, -0.07399128f, -0.05974694f, -0.00358210f, -0.00645640f, -0.40073225f, -0.03452821f, 
    -0.23213650f, 0.08362336f, -0.18957601f, -0.17747332f, 0.03315942f, 0.02297153f, 0.24174510f, -0.06723128f, 
    -0.09270274f, -0.18460724f, 0.32970878f, 0.42517716f, -0.11603694f, -0.21431750f, -0.09238499f, 0.19076180f, 
    -0.19710734f, 0.28489348f, -0.01863507f, -0.42089972f, -0.08591106f, 0.20956723f, 0.04813341f, -0.17246369f, 
    -0.29135862f, 0.25600031f, -0.35446617f, -0.03804253f, 0.00989413f, 0.06863800f, -0.21876726f, 0.21268374f, 
    -0.24657802f, 0.14413023f, -0.02430727f, 0.29069877f, 0.04745260f, -0.02439646f, 0.53301692f, -0.12519406f, 
    -0.17580402f, -0.05341543f, 0.17065805f, -0.10742231f, -0.02679570f, -0.16429120f, 0.02390756f, 0.06975137f, 
    0.25430369f, -0.31674188f, -0.16270660f, -0.06267571f, -0.10255703f, -0.06366918f, 0.10278462f, 0.07310250f, 
    -0.24200650f, -0.21696675f, -0.26488513f, 0.21412928f, -0.40826803f, -0.43885460f, -0.10412756f, -0.37685123f, 
    0.33355001f, 0.22157286f, -0.65093952f, -0.83227563f, -0.54089171f, -0.14560394f, -0.27976349f, -0.21940833f, 
    -0.18999927f, -0.32035330f, -0.48721147f, -0.07611251f, 0.14521056f, -0.04823913f, -0.24036238f, -0.12581471f, 
    0.00348772f, -0.02783667f, -0.02679593f, -0.37363684f, -0.24714491f, 0.51008099f, -0.22038975f, -0.45034871f, 
    -0.31032914f, -0.49183959f, 0.13260780f, 0.24874918f, 0.38652396f, -0.06704503f, -0.18892714f, 0.26535559f, 
    0.26799873f, 0.16546983f, -0.19580010f, -0.10044585f, -0.26387650f, -0.40919167f, 0.08066678f, -0.10921805f, 
    0.00649030f, -0.10661580f, 0.15785544f, 0.28154054f, 0.43886697f, -0.24828854f, -0.22366418f, -0.20132430f, 
    -0.60540146f, -0.25140595f, -0.17992246f, -0.43251655f, 0.04841118f, -0.38360500f, -0.46824583f, -0.40664801f, 
    0.16414471f, -0.26646000f, 0.32983536f, -0.24338180f, -0.27206665f, 0.06175074f, 0.04218450f, 0.19558655f, 
    -0.12113358f, 0.03135737f, -0.10408160f, 0.23429245f, 0.02088540f, 0.31665707f, 0.34668288f, -1.02056491f, 
    -0.05762877f, -0.11926626f, -0.20849060f, -0.48966026f, 0.27635112f, -0.01382600f, -0.33500102f, 0.23660986f, 
    0.57551867f, 0.00299342f, 0.00118286f, -0.08959427f, 0.02706799f, -0.39568314f, -0.08289843f, -0.11712607f, 
    -0.24993283f, -0.17677179f, -0.34242010f, -0.24129139f, -0.21225615f, -0.39239162f, -0.32219133f, -0.26104924f, 
    -0.66030008f, -0.54571074f, -0.51379395f, -0.45341179f, -0.54190135f, 0.20677789f, 0.04926393f, -0.13932753f, 
    0.04135769f, 0.21267390f, 0.02101151f, 0.03551375f, -0.03614226f, 0.17098896f, 0.26737425f, -0.22202827f, 
    -0.14638186f, -0.29275700f, -0.38110441f, 0.05293182f, -0.11169530f, 0.17837414f, -0.15840715f, 0.26247615f, 
    0.09966542f, 0.09992655f, 0.08194689f, 0.07992981f, 0.10324821f, 0.15543285f, 0.28785455f, 0.09721700f, 
    -0.07973977f, -0.29180157f, -0.08290700f, 0.08228767f, 0.03666547f, -0.05348241f, 0.18014866f, 0.11805526f, 
    -0.04937378f, -0.13412699f, -0.14874186f, 0.15116975f, -0.24929315f, 0.02526868f, -0.03872322f, 0.11218562f, 
    0.03944788f, 0.20862652f, 0.36450770f, -0.23166876f, -0.02426543f, -0.09120812f, 0.37421352f, -0.36898732f, 
    0.05520312f, -0.08425459f, 0.25037742f, -0.01680044f, 0.25581068f, 0.21670432f, 0.09306698f, -0.18757822f, 
    -0.12946214f, 0.16140226f, -0.06895784f, -0.04026277f, -0.23398440f, -0.14677048f, 0.18440141f, 0.12367448f, 
    0.23839763f, 0.05726156f, -0.18694663f, -0.56050670f, 0.81997484f, 0.15204372f, -0.54487491f, 0.19415723f, 
    -0.28824160f, -0.38597557f, 0.03265760f, 0.19159386f, -0.34873104f, 0.07500017f, 0.35121763f, -0.05301839f, 
    0.19186895f, -0.20924613f, -0.01047440f, 0.29082277f, 0.08296321f, -0.47581711f, -0.38649601f, 0.03860927f, 
    0.25246716f, -0.07886276f, -0.14971165f, -0.01737088f, -0.67300153f, -0.52456254f, -0.37526885f, -0.62621415f, 
    -0.12719880f, -0.17921439f, -0.51144254f, -0.34193033f, -0.35802266f, -0.14131716f, 0.07864904f, 0.02101772f, 
    0.04831400f, 0.27270421f, -0.15439749f, -0.03606362f, -0.17644551f, -0.22781961f, 0.03902241f, -0.02775334f, 
    -0.26755649f, -0.07602236f, 0.25419825f, -0.23569584f, -0.34740373f, -0.82251281f, 0.23040397f, 0.75640535f, 
    -0.43848598f, -0.20435798f, -0.49558529f, 0.20867001f, -0.23542906f, 0.15082277f, -0.43700847f, 0.22425993f, 
    0.00739079f, -0.38670221f, -0.09430847f, -0.28912511f, 0.05030261f, -0.36315814f, -0.08541444f, -0.25998276f, 
    -0.33339229f, -0.01927879f, -0.25661075f, 0.00914384f, -0.12963152f, 0.04968454f, 0.36904854f, -0.34845954f, 
    -0.29787743f, -0.42868081f, -0.54899782f, 0.10036214f, -0.10141701f, -0.47052380f, -0.73775482f, -0.63307375f, 
    0.04275465f, -0.56806862f, -0.26068738f, 0.07680662f, -0.29501963f, -0.46843746f, -0.48249492f, -0.00922910f, 
    -0.55965406f, -0.32248300f, -0.32157287f, -0.12216473f, 0.00669326f, 0.27041480f, -0.11383728f, 0.20834886f, 
    0.68278563f, 0.51847053f, -0.15327752f, 0.11752243f, 0.05959532f, -0.14860117f, -0.01277093f, -0.25265661f, 
    -0.46167144f, -0.32453430f, 0.01099044f, -0.24360235f, -0.08769025f, 0.00100125f, 0.06483113f, 0.04139295f, 
    0.12721565f, -0.13297062f, 0.24315274f, -0.00650196f, 0.02637029f, -0.18128993f, -0.26633257f, -0.22875874f, 
    -0.67589355f, -0.48784328f, 0.01274273f, -0.66253012f, -0.43119210f, -0.26407689f, -0.06297240f, -0.23293555f, 
    0.13315448f, 0.08191303f, 0.18377095f, 0.22064875f, -0.12600814f, -0.27562445f, -0.07837436f, -0.11051024f, 
    -0.13771093f, 0.04327800f, -0.25878215f, -0.17457676f, 0.17772508f, 0.18092096f, -0.25908777f, 0.12818867f, 
    -0.12606931f, 1.26320815f, -0.93403298f, -0.76442593f, 0.16038160f, -0.47998446f, 0.56259191f, 0.04389446f, 
    0.04766469f, 0.03146853f, 0.13120639f, -0.23086436f, 0.13027391f, -0.10898734f, -0.01747059f, 0.43799117f, 
    0.15777013f, -0.10501172f, -0.06947757f, -0.01432054f, -0.22444585f, 0.08832456f, -0.29997575f, 0.09889810f, 
    0.10144928f, 0.13968718f, -0.79547048f, -0.32061303f, -0.45070478f, -0.26708013f, -0.47480112f, 0.43912774f, 
    0.03438739f, 0.07341393f, 0.35801664f, 0.61014241f, 0.16710694f, 0.12820755f, 0.22844577f, -0.10669854f, 
    0.09715965f, 0.00131714f, -0.09551954f, -0.01388229f, -0.12007625f, -0.03768491f, 0.01003617f, 0.13179344f, 
    0.04807137f, 0.02194677f, -0.06965633f, 0.03928963f, -0.13819712f, 0.17338639f, 0.22481661f, -0.12214632f, 
    -0.21092148f, 0.09516943f, 0.46018910f, -0.40808600f, 0.15763885f, 0.03580379f, 0.51937348f, -0.12973194f, 
    0.03897511f, -0.33936211f, -0.16601105f, 0.34584576f, -0.16874047f, -0.27741173f, 0.15436417f, 0.40579790f, 
    -0.16180348f, -0.07699703f, -0.18180522f, 0.01601850f, 1.17112482f, -0.90675282f, -0.79772156f, -0.41987133f, 
    -0.13501465f, 0.63801247f, 0.69788349f, 0.49696139f, -0.15501252f, -0.27311945f, -0.20571600f, -0.15588407f, 
    0.00019730f, -0.31938341f, 0.06380156f, 0.01043505f, 0.01603002f, 0.08154707f, 0.12029947f, -0.12852073f, 
    0.16697274f, -0.12413227f, -0.21559751f, 0.11755757f, 0.13754258f, 0.57610017f, 0.01135287f, 0.10643677f, 
    -0.37637058f, -0.27448156f, -0.01620906f, 0.10577388f, 0.30277604f, -0.30135611f, -0.44837552f, 0.03034731f, 
    -0.06283342f, 0.28657362f, -0.17032918f, -0.13081375f, -0.05675871f, -0.21245205f, -0.36702433f, 0.08331145f, 
    -0.29210263f, -0.42977604f, -0.27565491f, -0.20543055f, -0.28187886f, -0.34401223f, -0.67070842f, 0.00867663f, 
    -0.21153100f, 0.26498583f, 0.05420842f, 0.37390712f, 0.56008977f, 0.22468214f, 0.11832916f, 0.26639956f, 
    -0.36039361f, -0.41255656f, -0.25335449f, 0.20165852f, 0.36470446f, -0.04172038f, 0.05228223f, -0.10924953f, 
    -0.20715600f, -0.13013494f, 0.01289204f, -0.17844632f, 0.33950952f, -0.07035176f, -0.19268288f, -1.07524371f, 
    0.62094527f, -0.29316139f, -0.70385247f, -0.14118086f, 0.29300264f, 0.22776824f, 0.38207719f, 0.41850236f, 
    0.14152741f, 0.12206085f, -0.15723674f, -0.01558179f, -0.46611959f, -0.04612593f, 0.05184574f, -0.16672330f, 
    -0.20621546f, -0.14490774f, 0.18034175f, 0.05861059f, 0.12434386f, 0.07826722f, -0.00165789f, -0.01805126f, 
    0.72685504f, -0.00847262f, -0.01635429f, -0.07178698f, -0.39232823f, -0.58088952f, -0.65309513f, -0.59424061f, 
    -0.77621901f, -0.86865890f, 0.09881253f, 0.53887075f, -0.24390684f, 0.18425326f, -0.01131124f, -0.02944157f, 
    0.10041131f, 0.09493269f, 0.04899244f, -0.05951587f, -0.14008087f, -0.02951105f, -0.03350607f, 0.03623831f, 
    0.10518286f, -0.13556711f, -0.73356187f, -0.27763718f, 0.35931417f, 0.30083802f, -0.43557665f, -0.43072882f, 
    0.19485669f, -0.05398296f, -0.55380410f, 0.20811839f, 0.28681496f, 0.34838709f, 0.36972818f, -0.30451748f, 
    0.05647145f, -0.24537405f, -0.23984566f, -0.16893937f, -0.09316021f, -0.16686769f, 0.03958173f, 0.19373797f, 
    -0.06810971f, 0.07783968f, -0.04704611f, -0.56481010f, 0.46662289f, 0.07586105f, 0.36730945f, 0.45115116f, 
    0.31226397f, -0.46727780f, -0.45029131f, -0.35894603f, -0.11811688f, 0.25340417f, -0.13151224f, 0.00217653f, 
    0.33203763f, -0.37776661f, 0.22310415f, 0.10533933f, -0.14982858f, 0.13259014f, 0.31315586f, -0.14973640f, 
    0.04230824f, -0.24324550f, -0.04112572f, 0.63426489f, 0.54670042f, -0.33988374f, -0.40028846f, -0.05346430f, 
    -0.09186397f, 0.09000888f, 0.11955990f, 0.15833829f, -0.11411761f, -0.17547747f, 0.21078660f, -0.16337125f, 
    0.24949132f, 0.16448414f, -0.09358320f, 0.12834379f, -0.25538895f, -0.10875286f, 0.11297902f, -0.04897350f, 
    0.38100535f, 0.15503356f, -0.36549729f, -0.24880841f, -0.29903612f, -0.58593148f, -0.41497484f, -0.02728363f, 
    -0.15060069f, -0.68711746f, -0.45524639f, -0.19830899f, -0.28408942f, -0.45517659f, 0.32974118f, 0.55719537f, 
    0.27131996f, 0.18931936f, -0.22603762f, 0.15892652f, 0.04935545f, -0.14842926f, -0.22217250f, -0.00699905f, 
    0.29952469f, 0.04560250f, -0.28517145f, -0.06717298f, 0.20241697f, 0.85525554f, 0.51769537f, -0.19436458f, 
    -0.28060064f, -0.27198881f, 0.26848841f, -0.07034419f, 0.01392604f, 0.10016643f, -0.14707811f, -0.06686249f, 
    -0.04802543f, -0.26576692f, -0.28057337f, -0.15499130f, 0.09582613f, 0.23025483f, 0.07875495f, -0.08925654f, 
    -0.24408254f, -0.31338498f, 0.08643559f, 0.24792279f, 0.07281671f, -0.04067167f, 0.36928359f, 0.27272761f, 
    0.06052732f, -0.35847446f, -0.39825732f, 0.02193973f, -0.04296280f, 0.37886217f, -0.15266512f, -0.34529945f, 
    -0.18741114f, -0.14803246f, 0.28760183f, -0.03423952f, -0.33561593f, 0.21367651f, -0.09129465f, -0.25086522f, 
    0.01665891f, -0.08510537f, 0.08263685f, 0.02408863f, 0.18460417f, 0.17838682f, 0.16109997f, 0.37966618f, 
    -0.22755432f, 0.00279397f, 0.49054563f, -0.18363121f, 0.09266619f, -0.17758401f, -0.40582925f, -0.43070236f, 
    -0.41661954f, 0.01761392f, 0.01352350f, 0.01850618f, 0.14163505f, -0.23476738f, 0.14646395f, -0.22333086f, 
    -0.16140489f, -0.00499249f, -0.20093764f, 0.07660288f, 0.12185788f, -0.30553219f, -0.28482571f, -0.37789640f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03268942f, 0.36630002f, 0.09383261f, 0.03301761f, 0.00865824f, -0.09203434f, 0.31254166f, 0.12989879f, 
    0.13856220f, 0.25524914f, 0.10666621f, -0.35610339f, 0.30160347f, -0.33148569f, 0.04160529f, -0.09135530f, 
    0.24019347f, -0.13222884f, 0.16481647f, 0.24158974f, 0.09546692f, 0.25339627f, 0.07078636f, -0.10822330f, 
    0.24422507f, 0.30377081f, 0.21250814f, 0.16004685f, 0.08829593f, 0.19435662f, -0.15059879f, 0.11308178f, 
    0.12621841f, 0.07536168f, 0.19514865f, 0.23390219f, -0.00153863f, 0.24519952f, -0.10108888f, -0.13127086f, 
    -0.05542702f, -0.05469575f, 0.01641171f, 0.22779576f, -0.08838889f, 0.10071427f, -0.16079429f, -0.01399738f, 
    -0.17503749f, 0.31755206f, 0.13855620f, 0.06689363f, 0.22604227f, -0.13314368f, 0.18564261f, 0.15249716f, 
    -0.01096863f, 0.18516403f, 0.03877263f, 0.15655893f, 0.10861117f, 0.38978675f, -0.07346775f, -0.31585267f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.19818455f, 0.11521029f, -0.10550030f, 0.03941927f, 0.06811222f, 0.15670671f, 0.05340832f, -0.10952957f, 
    0.08753373f, 0.01654430f, 0.06840273f, 0.02914386f, 0.15091117f, -0.05500164f, -0.04727802f, 0.03013789f, 
    0.05314458f, 0.03995432f, -0.08157761f, -0.18539467f, -0.00906713f, -0.14416492f, 0.03486818f, 0.04759275f, 
    -0.19510216f, -0.19632050f, -0.06139819f, 0.07719798f, 0.01878124f, 0.02291291f, -0.05532303f, -0.00751353f, 
    -0.02964871f, 0.01452714f, -0.03656198f, 0.06902584f, -0.02392301f, -0.11300537f, 0.01616128f, -0.01842337f, 
    -0.03599126f, 0.01493874f, 0.09607111f, -0.03305595f, -0.03722400f, 0.06258523f, 0.03965497f, 0.09206637f, 
    -0.02346900f, 0.29937920f, 0.17708024f, -0.53766310f, -0.17521572f, 0.09519742f, -0.10232939f, -0.01045329f, 
    -0.00392097f, 0.01980495f, -0.11189931f, 0.03722473f, 0.01775941f, -0.02937874f, 0.08832081f, -0.20511976f, 
    -0.01246124f, 0.15635778f, -0.01723506f, 0.03707993f, -0.02508814f, 0.02351902f, 0.00357943f, 0.11747669f, 
    0.30865088f, -0.21158616f, -0.15353413f, -0.04676568f, -0.06590166f, -0.03958281f, 0.06341750f, 0.01691503f, 
    0.06108383f, 0.05704309f, -0.05882891f, 0.00949505f, 0.10972987f, 0.00428691f, 0.09945900f, -0.09099128f, 
    0.01659005f, -0.00168492f, 0.01651983f, -0.06819166f, 0.03251414f, -0.11284747f, -0.09853562f, -0.11255776f, 
    -0.00587593f, -0.13315396f, -0.01157794f, -0.02002304f, -0.00670217f, -0.03041402f, 0.00973421f, 0.02367245f, 
    -0.06865297f, -0.06349104f, -0.12017005f, 0.14717820f, -0.00621300f, -0.27809140f, -0.01317612f, -0.09761848f, 
    -0.00033661f, -0.01865510f, -0.09925769f, -0.00664018f, -0.12079659f, -0.09981831f, -0.14950104f, 0.07215142f, 
    -0.39878342f, -0.23131645f, -0.20322472f, -0.06218015f, 0.01223593f, 0.04642937f, 0.05683615f, 0.06662785f, 
    -0.02682337f, 0.01815486f, 0.05210269f, 0.00698467f, 0.16520950f, 0.18598190f, 0.08018720f, -0.12814112f, 
    0.11871745f, 0.31802168f, 0.01969569f, 0.22995394f, 0.04258946f, 0.03859512f, -0.00527102f, 0.04693861f, 
    -0.40208337f, 0.05305772f, 0.03496658f, -0.31131458f, -0.01972949f, -0.03494298f, 0.05082296f, -0.00696614f, 
    -0.04852824f, -0.00607790f, 0.01754016f, -0.06724525f, 0.17522976f, 0.23196906f, -0.06827652f, -0.06863974f, 
    0.07034247f, 0.27783552f, 0.07000455f, 0.10675589f, 0.00612467f, 0.01723391f, 0.01613569f, -0.05894675f, 
    -0.12568377f, -0.22488549f, 0.03082673f, 0.02118908f, 0.00984877f, -0.10008154f, -0.03416110f, -0.02789191f, 
    -0.05223209f, -0.00984731f, -0.02694875f, -0.13673082f, -0.58095098f, -0.24480052f, -0.24759659f, 0.05831902f, 
    0.04649504f, 0.03202158f, 0.00578624f, 0.05525263f, -0.07067299f, -0.01210030f, 0.13609816f, 0.06728278f, 
    -0.29537702f, 0.03268574f, 0.05379298f, -0.05636713f, -0.00191813f, -0.00251578f, -0.02324294f, 0.01149089f, 
    -0.06134662f, -0.03604257f, -0.15418468f, 0.09437677f, 0.21290030f, 0.06693894f, -0.08829486f, -0.11475486f, 
    -0.00446831f, -0.10963015f, -0.09388942f, 0.07258320f, -0.00888782f, 0.00262782f, -0.02408206f, -0.01594274f, 
    -0.11183420f, 0.03177329f, 0.01107255f, 0.01797272f, -0.07289911f, 0.02116749f, 0.04734866f, 0.00109728f, 
    -0.07539210f, 0.01371391f, -0.17766464f, -0.05289410f, -0.09180507f, 0.02616036f, 0.17338124f, -0.03797984f, 
    -0.02350855f, 0.05172524f, 0.03448516f, -0.01741073f, 0.00798374f, -0.14278120f, -0.08791308f, -0.21981150f, 
    -0.03549800f, -0.13930495f, 0.10208543f, 0.00272475f, -0.03571861f, 0.01722069f, -0.01771687f, 0.01945899f, 
    -0.05008862f, 0.02156131f, 0.03655668f, -0.09600757f, 0.08923136f, -0.00899596f, -0.30104369f, 0.01732241f, 
    0.00195213f, 0.00364010f, 0.03968867f, 0.01771730f, -0.18104120f, -0.15347512f, -0.16721110f, -0.00718532f, 
    -0.15457240f, 0.18751089f, 0.19167808f, 0.06642867f, -0.08390681f, 0.06057487f, -0.01700872f, 0.01953644f, 
    0.02130252f, -0.09048893f, -0.03849647f, -0.02278288f, -0.13071275f, 0.04097921f, 0.05278004f, -0.00064786f, 
    -0.00884196f, 0.05658812f, -0.06943549f, -0.06847605f, -0.01746256f, 0.03517282f, 0.02814578f, 0.18712157f, 
    0.27818224f, 0.11332723f, -0.04240803f, -0.01630956f, 0.10397841f, 0.07516269f, 0.02747534f, -0.18721506f, 
    -0.05508574f, 0.02253165f, 0.02359290f, 0.00547565f, 0.04137739f, 0.26963326f, 0.09035122f, -0.49849746f, 
    -0.12923291f, -0.00628011f, -0.13303925f, -0.24983892f, 0.04008733f, -0.05142980f, -0.07045517f, -0.05492983f, 
    0.02638821f, 0.22616293f, 0.13746129f, -0.22872977f, 0.04426824f, -0.00124548f, -0.10133306f, -0.14282098f, 
    -0.05154037f, -0.05895128f, -0.08035837f, 0.00229525f, 0.05144065f, -0.11964630f, -0.09654061f, 0.05686278f, 
    -0.04446307f, -0.23223862f, 0.13123553f, -0.06195700f, -0.12860073f, 0.02693914f, 0.02704042f, -0.04806449f, 
    -0.30215135f, -0.05555475f, -0.16569757f, 0.08426514f, -0.00565258f, -0.01692759f, -0.05254494f, 0.05578940f, 
    0.03445534f, 0.04328682f, -0.00534619f, 0.01255314f, -0.00368281f, 0.07994452f, -0.09416613f, 0.00732040f, 
    0.15255550f, 0.03710818f, 0.01653248f, -0.25962907f, 0.10715890f, -0.16323952f, -0.20458619f, 0.04334681f, 
    -0.05309653f, -0.07072604f, 0.00108074f, 0.03952409f, 0.04973567f, 0.03621247f, 0.05539371f, 0.06246637f, 
    -0.09225356f, -0.01143239f, 0.04513427f, -0.04848237f, 0.06691777f, 0.25654411f, 0.26948631f, -0.20465976f, 
    -0.03825005f, 0.03860243f, 0.12764448f, -0.04188305f, -0.10794339f, -0.12399826f, -0.01663942f, -0.14135712f, 
    0.49383748f, 0.27604261f, -0.20880367f, -0.12915656f, -0.12793979f, 0.01459762f, 0.10534188f, -0.10428531f, 
    -0.06258356f, -0.03291878f, -0.02759843f, -0.06610209f, 0.16848192f, 0.06765173f, -0.27710199f, 0.13998337f, 
    -0.05732280f, -0.06764100f, 0.20606449f, -0.24860394f, -0.11586622f, 0.04202199f, -0.06181475f, 0.09462662f, 
    -0.54330486f, -0.27348873f, -0.67333561f, 0.24809425f, 0.00729547f, -0.00808821f, 0.00925713f, 0.04350965f, 
    -0.03689716f, 0.01622854f, 0.03092922f, 0.03082899f, -0.48816520f, -0.14507784f, 0.14583640f, -0.21712579f, 
    -0.02103923f, 0.01606154f, 0.01185219f, 0.03196184f, 0.03047598f, -0.00728606f, 0.02917871f, 0.05146877f, 
    0.24288376f, 0.20056611f, -0.05115690f, -0.05455123f, 0.05821028f, 0.19831713f, 0.04640301f, -0.01544557f, 
    -0.01278489f, -0.02108720f, -0.06203696f, -0.13377458f, 0.06847069f, -0.24064198f, -0.43005133f, 0.09502273f, 
    0.09197675f, -0.09778447f, 0.05110918f, -0.09706736f, -0.01298263f, -0.17028566f, -0.42398503f, -0.04806307f, 
    0.30407619f, 0.19532627f, -0.22866575f, -0.28323811f, 0.16308121f, -0.03509805f, -0.01966958f, 0.02949189f, 
    0.02161439f, -0.03013756f, -0.01287988f, -0.01632262f, 0.13324980f, 0.18852216f, 0.03441621f, -0.15797335f, 
    0.03974418f, 0.08507870f, 0.00960286f, 0.04497007f, 0.10839987f, 0.15190637f, 0.07528667f, 0.06593457f, 
    0.19194199f, 0.05126509f, 0.01062312f, -0.13493063f, 0.11634879f, 0.08896037f, -0.13227287f, -0.06243681f, 
    -0.08173987f, -0.06753026f, -0.00045255f, 0.02648054f, -0.04542533f, 0.01055570f, 0.04540356f, 0.01443630f, 
    0.02513421f, -0.00116000f, 0.02013882f, -0.00205691f, -0.05739575f, -0.00974342f, 0.04162460f, 0.02536081f, 
    -0.19152804f, 0.01253627f, -0.17481540f, -0.05961499f, 0.01370925f, 0.04481860f, -0.01496162f, -0.03516256f, 
    -0.07109560f, -0.02296512f, 0.08737653f, 0.04819763f, 0.04551729f, 0.04818811f, -0.06089631f, -0.01891751f, 
    -0.15297486f, 0.10424150f, -0.09752388f, -0.04173625f, -0.02608522f, -0.00891472f, 0.00588048f, -0.15024836f, 
    0.28490964f, 0.17170385f, -0.02156893f, -0.16746010f, 0.13974507f, 0.24862690f, 0.03801401f, 0.05768539f, 
    -0.04794835f, -0.02779261f, -0.02230398f, 0.02921154f, 0.07007471f, 0.17910710f, 0.04249729f, -0.07326284f, 
    -0.17129640f, 0.09649005f, 0.03665142f, 0.19506866f, -0.10361941f, -0.13230370f, -0.12894362f, -0.11122340f, 
    0.24697235f, 0.02860553f, -0.10867215f, -0.15769240f, 0.13897137f, -0.03163883f, -0.04985682f, -0.10900573f, 
    -0.14676178f, -0.09718045f, -0.10350502f, 0.06651098f, -0.53542084f, -0.19345650f, -0.33972678f, 0.36957988f, 
    0.01204567f, 0.01094081f, -0.10061622f, 0.04969435f, 0.02934593f, 0.05490885f, 0.07504898f, -0.00136784f, 
    0.20087937f, 0.12857260f, 0.05387168f, -0.11171817f, 0.14667809f, 0.22535704f, 0.03578671f, 0.00225710f, 
    -0.01438629f, -0.07871719f, -0.00046251f, 0.08617400f, -0.14209270f, -0.11245307f, -0.24236652f, 0.09092164f, 
    0.00147152f, -0.01649464f, -0.02132511f, -0.13554035f, -0.09522791f, -0.13500625f, -0.03933434f, 0.03263987f, 
    0.13461728f, 0.04055525f, 0.06275048f, -0.00081646f, 0.09580941f, 0.08772416f, 0.01836071f, 0.00195582f, 
    -0.00494130f, 0.02128222f, -0.05007564f, 0.02770874f, -0.19717069f, -0.12619232f, 0.05969889f, -0.08639976f, 
    -0.09891190f, -0.03468719f, 0.04679382f, 0.06304920f, -0.00475464f, -0.03723571f, -0.21968225f, 0.01759162f, 
    0.11285356f, -0.52034771f, -0.73521638f, 0.06550450f, 0.01997781f, 0.06043196f, 0.01321238f, -0.03706560f, 
    -0.01727183f, -0.01204818f, -0.19607829f, 0.02060784f, -0.00600082f, -0.16718882f, -0.02451817f, -0.00499129f, 
    -0.02983813f, -0.07419556f, -0.16276579f, -0.09890701f, -0.02832821f, -0.01483726f, 0.05579510f, 0.15435910f, 
    0.16497476f, -0.47275332f, -0.13121317f, 0.07662376f, 0.00082818f, 0.00624932f, -0.00594593f, 0.00225867f, 
    -0.00429851f, 0.01249907f, 0.02285739f, 0.10619501f, -0.31718725f, -0.28602424f, 0.03888111f, -0.12615205f, 
    0.00586358f, 0.10185929f, 0.03666084f, -0.00924579f, 0.00962777f, -0.08921903f, -0.03212718f, -0.22628152f, 
    0.23376030f, 0.04818204f, -0.22959806f, -0.27591693f, 0.03829432f, -0.09925510f, 0.02445636f, 0.12942967f, 
    0.01662036f, 0.10035679f, 0.01584520f, 0.01588477f, 0.25264001f, 0.27455491f, 0.00727866f, -0.22097602f, 
    -0.05846868f, -0.01844113f, -0.01455615f, -0.03878150f, -0.01713532f, -0.03926786f, -0.10390949f, -0.07933418f, 
    0.09826557f, 0.02879995f, -0.04389037f, -0.05609656f, -0.17874679f, -0.08692604f, 0.04699257f, -0.13588460f, 
    -0.03942098f, -0.13091533f, 0.03938915f, -0.11468004f, -0.04318814f, -0.27612478f, -0.10394353f, 0.08026137f, 
    0.00150584f, -0.05839209f, 0.00299171f, 0.05551999f, -0.15276402f, 0.02884601f, -0.24158587f, -0.28879014f, 
    0.17807856f, 0.21936278f, -0.10597834f, -0.22621746f, -0.01591874f, -0.10052626f, 0.01891874f, 0.05191834f, 
    -0.01889983f, -0.06774373f, 0.00082129f, 0.02302894f, -0.22441858f, -0.13179207f, -0.79854697f, 0.13517204f, 
    -0.02858542f, 0.01856766f, -0.04613007f, 0.04312888f, -0.00349852f, 0.01457292f, 0.04392060f, 0.02306387f, 
    0.00167981f, -0.00754174f, -0.01654241f, 0.03181285f, -0.03825426f, 0.01783060f, -0.10395014f, -0.03794485f, 
    -0.03570538f, 0.03438465f, -0.04275719f, -0.00399043f, 0.10986654f, -0.15329704f, -0.14275606f, -0.12555751f, 
    -0.09501764f, -0.12615073f, 0.06974039f, -0.04822453f, -0.03380633f, 0.04308553f, 0.11344895f, 0.04605187f, 
    0.04860334f, -0.05356279f, -0.07607685f, 0.07911137f, 0.03348365f, 0.01317086f, -0.08355825f, -0.09456263f, 
    0.05152635f, -0.20817615f, 0.04219452f, -0.15646647f, -0.07068042f, -0.31722128f, 0.12900764f, -0.21619989f, 
    0.03300472f, 0.09267027f, -0.06976598f, -0.01406181f, 0.25502709f, 0.03883053f, 0.04870198f, -0.02075749f, 
    0.18863535f, 0.00360144f, 0.11541930f, -0.07698750f, 0.00684279f, 0.02376708f, -0.06196208f, -0.00475951f, 
    -0.06149687f, -0.11621938f, -0.08289529f, -0.29920042f, -0.02623745f, -0.11829377f, 0.06371314f, -0.11938340f, 
    0.01757863f, 0.09754711f, 0.04174769f, 0.00214436f, 0.03936275f, -0.12964207f, 0.08250052f, -0.04474405f, 
    -0.49508378f, 0.06346508f, -0.15842651f, -0.43488267f, 0.14334786f, -0.00910491f, 0.14704913f, 0.07180519f, 
    -0.04818829f, 0.00256766f, 0.07819267f, -0.11498888f, 0.06638758f, 0.02400819f, 0.01988111f, -0.10220362f, 
    0.12973191f, -0.03080410f, -0.13639684f, 0.01733096f, -0.09625643f, 0.02115735f, -0.01506512f, -0.03568986f, 
    0.07991966f, -0.35062984f, 0.20490310f, 0.15432014f, -0.03628945f, 0.01762607f, 0.03989111f, -0.02613839f, 
    0.12889151f, 0.13707037f, 0.04971400f, 0.05922781f, -0.11116750f, -0.00733796f, 0.03026594f, -0.06036555f, 
    -0.03679530f, -0.02434498f, 0.09649435f, 0.02185237f, -0.01892962f, -0.07862847f, 0.13417169f, 0.04282761f, 
    0.04098513f, 0.00743908f, 0.05457696f, -0.01544432f, -0.03189752f, 0.00148496f, -0.01164624f, -0.05604398f, 
    0.07052854f, -0.06392702f, 0.19093260f, -0.01467906f, -0.59317607f, -0.23005657f, 0.12387829f, -0.32290983f, 
    -0.03023035f, -0.05358699f, -0.01720333f, 0.14638297f, 0.00128010f, -0.15431565f, 0.12898894f, -0.11898553f, 
    0.64764595f, -0.03371893f, 0.16650283f, 0.20423298f, -0.05479815f, -0.03366585f, 0.02861676f, 0.00110206f, 
    0.01503201f, -0.03474030f, -0.04657065f, 0.08960214f, 0.44469795f, 0.30642635f, 0.14904252f, -0.23356685f, 
    0.10254984f, -0.10919525f, -0.18505818f, -0.13371387f, -0.07570744f, 0.00110600f, -0.14976636f, 0.01707542f, 
    0.16558875f, 0.08770639f, 0.02561705f, 0.09128022f, -0.00254579f, -0.02729944f, -0.04254203f, -0.01509749f, 
    0.04407946f, 0.02661064f, -0.00036192f, -0.01230633f, 0.31326127f, 0.41756946f, 0.16242224f, -0.02215868f, 
    -0.10412650f, 0.15508881f, 0.08603096f, 0.16107747f, -0.01451043f, -0.01813099f, -0.06410635f, -0.13900097f, 
    0.01245427f, 0.10137045f, 0.01812518f, -0.07833808f, 0.00006884f, -0.06075462f, 0.01741900f, -0.04399082f, 
    -0.09166268f, 0.15030248f, -0.00738088f, -0.06622912f, 0.14867891f, 0.24187303f, 0.04106227f, 0.12942535f, 
    0.01330866f, 0.03666430f, 0.01372152f, 0.03924329f, -0.00511515f, 0.23237662f, -0.11217449f, 0.03694470f, 
    -0.11336005f, -0.00788539f, 0.10406614f, 0.18507718f, 0.08120525f, -0.04829888f, -0.03291909f, -0.00419944f, 
    0.10194541f, -0.01734510f, -0.12976946f, 0.08572659f, 0.03598202f, -0.16761686f, -0.02870774f, -0.16338177f, 
    0.08781967f, 0.03645018f, -0.06058592f, 0.22345337f, 0.03463281f, -0.02260813f, 0.05649082f, 0.05620089f, 
    -0.04856794f, -0.04061579f, 0.03031242f, 0.13746202f, 0.06260697f, -0.01941424f, -0.02730437f, -0.01428017f, 
    -0.09216108f, 0.00622102f, 0.03979940f, 0.05089197f, -0.23582336f, 0.20720126f, 0.08002468f, -0.07126646f, 
    -0.02148120f, 0.09665100f, -0.04448746f, 0.09108099f, -0.01677186f, 0.11123250f, -0.04372640f, 0.03730152f, 
    -0.02510684f, -0.12706517f, 0.15343100f, -0.08686180f, 0.08458768f, -0.05016943f, 0.21558534f, -0.07770047f, 
    -0.00023450f, 0.03175372f, 0.01266783f, -0.11856586f, 0.05346775f, -0.36143899f, 0.09190411f, 0.01904485f, 
    -0.03436159f, 0.00983467f, 0.03363942f, -0.06465568f, 0.06256921f, -0.05322703f, 0.08473695f, 0.00724920f, 
    -0.48124257f, 0.09780769f, 0.07812981f, -0.08167255f, 0.02153487f, -0.04627090f, -0.16427545f, -0.02970389f, 
    0.00759420f, 0.07127033f, -0.07848755f, 0.00051363f, 0.04831014f, -0.08308688f, 0.11564942f, 0.01750258f, 
    0.06500316f, -0.01943713f, -0.07538684f, 0.02682915f, -0.19427073f, -0.14223324f, -0.35041201f, -0.17643137f, 
    0.21603097f, 0.05356507f, -0.25663769f, -0.13295972f, -0.05450895f, -0.03655687f, 0.01176850f, -0.20806026f, 
    0.04265448f, -0.17992499f, -0.06294947f, -0.08153520f, -0.50175673f, 0.17534365f, -0.14307261f, -0.00151052f, 
    0.04173202f, -0.19205473f, 0.03667690f, 0.16123846f, -0.07677189f, 0.03114822f, 0.05723341f, 0.08056983f, 
    -0.46966407f, 0.16086039f, 0.03059818f, 0.22378819f, -0.06649537f, 0.07588694f, 0.05585009f, -0.11137553f, 
    -0.00589154f, 0.01581623f, 0.10382521f, -0.05161945f, 0.15594174f, -0.00701899f, -0.02712248f, -0.08437889f, 
    0.02242572f, -0.10798215f, -0.08108981f, 0.02121923f, -0.10900316f, -0.00207436f, 0.08469595f, -0.05661986f, 
    0.18564676f, 0.04013960f, 0.01196597f, -0.29881606f, 0.01119278f, -0.04639130f, -0.06071951f, -0.06847435f, 
    -0.03780650f, -0.02282067f, -0.00240742f, 0.09245180f, -0.01440505f, 0.11534034f, -0.13056451f, -0.08891349f, 
    -0.02254016f, 0.07411975f, 0.02382253f, 0.03112706f, -0.03910470f, 0.04029488f, 0.00196035f, -0.00833141f, 
    0.18080828f, 0.08653384f, 0.12164056f, 0.10854171f, -0.03300640f, -0.03254603f, -0.03119325f, -0.04660787f, 
    -0.00276978f, 0.12096377f, -0.03370038f, 0.01431943f, -0.53968614f, -0.05729561f, -0.15448169f, 0.02301380f, 
    -0.04623226f, 0.07743137f, 0.09239136f, 0.05466202f, -0.05798628f, -0.01131284f, 0.02775786f, 0.06350802f, 
    0.42490417f, -0.47217864f, 0.02516487f, -0.17605948f, -0.01058216f, -0.08287486f, 0.01724705f, 0.01279677f, 
    0.14501335f, 0.03517824f, -0.00204296f, -0.02281667f, 0.17571524f, -0.46190071f, -0.47841707f, -0.08108696f, 
    -0.01412206f, 0.00614090f, -0.01563682f, 0.09722160f, 0.03880798f, 0.08650433f, -0.23385121f, -0.02687117f, 
    0.24856491f, -0.00403972f, 0.30413565f, 0.08387680f, -0.07951386f, -0.05857416f, -0.00287720f, -0.01012814f, 
    -0.05360312f, 0.02867994f, -0.02317955f, 0.01189987f, 0.21686807f, 0.24558365f, 0.05108328f, -0.07334912f, 
    0.03793285f, -0.01054543f, -0.03688951f, -0.06309413f, 0.06499036f, -0.06394909f, 0.02621015f, 0.04217181f, 
    0.10437289f, 0.01750837f, -0.12454288f, 0.16121116f, 0.06928746f, -0.20884614f, -0.01867617f, 0.12542893f, 
    0.03227486f, 0.01716934f, -0.01959743f, -0.01351738f, 0.18626538f, -0.09587109f, -0.01466290f, -0.24924016f, 
    -0.01738757f, -0.06114348f, 0.09188472f, 0.13727579f, -0.07462684f, 0.18205397f, -0.09051284f, 0.00575912f, 
    0.11811168f, 0.09979878f, 0.14721143f, -0.00341613f, -0.13050148f, 0.15243240f, 0.14591485f, -0.06133781f, 
    -0.01737591f, -0.00099426f, -0.05139559f, -0.02337283f, 0.08704937f, -0.01882977f, -0.19631353f, -0.01200511f, 
    -0.00060747f, 0.01305207f, -0.02772856f, -0.04659497f, -0.23559596f, -0.19082727f, -0.20709838f, -0.34398127f, 
    -0.08815306f, 0.06065929f, 0.06993078f, 0.00691736f, 0.07772239f, 0.13160037f, 0.04951230f, 0.01409908f, 
    -0.02860553f, 0.00721556f, 0.09510561f, -0.08373463f, 0.09471323f, -0.00891622f, 0.00624935f, 0.07552096f, 
    -0.01587572f, -0.02809368f, -0.04648287f, -0.03469406f, 0.02815709f, -0.03326683f, 0.01512598f, -0.02480977f, 
    0.13678218f, 0.00937568f, 0.12161924f, 0.01095899f, -0.00947568f, -0.06053833f, 0.01698075f, -0.00626224f, 
    0.00593048f, -0.00439554f, -0.13582602f, 0.08322731f, -0.33090365f, -0.31745505f, -0.19397862f, -0.04746757f, 
    0.07804702f, 0.00024939f, 0.10882193f, 0.15463267f, 0.02085732f, 0.04525637f, -0.02000395f, 0.16903470f, 
    -0.04540819f, 0.13712505f, 0.13493636f, 0.35559240f, -0.00623840f, 0.17018040f, -0.07313417f, -0.09466767f, 
    -0.03233195f, 0.01092993f, 0.03084753f, -0.01420470f, -0.11196779f, -0.36748147f, -0.01932826f, -0.32964623f, 
    0.05256946f, 0.08839269f, -0.20248063f, 0.11894576f, 0.03210385f, 0.03655019f, -0.06196767f, 0.04783949f, 
    0.19021694f, -0.07891576f, 0.25925723f, -0.02196693f, -0.07162965f, -0.11478934f, 0.03575797f, 0.18285082f, 
    -0.01637852f, -0.00750035f, -0.04885661f, 0.01914876f, 0.17777218f, 0.08010666f, 0.07470481f, -0.02406354f, 
    -0.01253408f, -0.12591062f, -0.08602090f, 0.04130848f, -0.02031099f, 0.02024184f, 0.01854946f, -0.01009258f, 
    -0.00455835f, 0.09286471f, 0.04570201f, 0.13225348f, -0.09663856f, 0.14513247f, -0.17653002f, 0.09782183f, 
    -0.08943783f, -0.02496274f, -0.07339995f, 0.02794588f, 0.74886370f, -0.05044697f, -0.07903806f, -0.06184988f, 
    -0.00199620f, 0.05154722f, 0.01651213f, -0.20089027f, 0.09669494f, 0.09464116f, 0.13540934f, -0.13100870f, 
    -0.17593551f, 0.02364208f, -0.17753942f, -0.12006228f, 0.00673587f, -0.04038997f, -0.03693133f, 0.01023106f, 
    -0.04856431f, 0.02527145f, 0.08804362f, -0.05251348f, 0.01021419f, 0.14910612f, 0.01301556f, -0.15268634f, 
    -0.01223587f, 0.01017555f, 0.09606550f, -0.08619246f, 0.11840715f, -0.04757115f, -0.04661403f, 0.13859616f, 
    0.96508604f, -0.09277450f, -0.05641308f, 0.04330049f, -0.05619058f, -0.08489354f, 0.05646698f, -0.14800054f, 
    0.10511365f, -0.15121731f, -0.08351385f, -0.17971563f, 0.19434232f, -0.15526727f, 0.12562259f, -0.04027746f, 
    -0.01004071f, 0.00883204f, -0.07486970f, 0.05457259f, -0.18671504f, -0.30879319f, -0.30921805f, -0.07094577f, 
    -0.13762279f, -0.11713351f, 0.34550795f, 0.10096149f, 0.02033157f, -0.02923998f, -0.00803951f, -0.02093590f, 
    0.05201303f, -0.00070227f, -0.12604475f, -0.19778007f, -0.40139207f, 0.08201213f, -0.18764238f, -0.18100031f, 
    0.00702641f, -0.03114111f, -0.03909624f, -0.05806162f, -0.09795327f, 0.09786849f, -0.01241717f, 0.05895264f, 
    0.10518428f, 0.01710583f, -0.27381629f, -0.30185536f, -0.22101238f, -0.09130115f, -0.14989959f, -0.11077555f, 
    -0.02062069f, -0.01744372f, -0.03716726f, 0.13279819f, -0.45970190f, -0.10623759f, -0.23238586f, 0.00780109f, 
    -0.10305005f, 0.18855533f, 0.13613674f, 0.01790462f, -0.11126108f, 0.03162837f, 0.09995466f, 0.11625081f, 
    0.02988281f, -0.06115440f, 0.13192163f, -0.03340312f, 0.06932566f, -0.01178308f, 0.01267136f, 0.03251309f, 
    0.11267608f, -0.03709098f, -0.00050395f, 0.02170127f, 0.05800676f, 0.12189203f, 0.04676493f, 0.01955901f, 
    -0.02722631f, 0.01004333f, -0.03210936f, 0.04352592f, 0.01162246f, 0.06444586f, -0.13250680f, 0.11404245f, 
    -0.21400987f, 0.03563739f, -0.04146501f, 0.06755276f, 0.01264669f, 0.02822686f, -0.02264356f, -0.04701254f, 
    -0.03111903f, -0.03631957f, 0.02478020f, 0.07518221f, 0.32672560f, 0.07669150f, 0.19378923f, 0.19907822f, 
    -0.09397490f, -0.10135031f, 0.06601181f, -0.03222005f, -0.06267337f, 0.09627158f, -0.03542004f, 0.08164087f, 
    0.18407384f, -0.08684947f, 0.05780451f, -0.04296362f, -0.25799930f, -0.08689404f, 0.10816146f, -0.06002303f, 
    -0.07034677f, -0.09753766f, -0.02745729f, -0.04104340f, 0.02285419f, -0.12569180f, -0.36039013f, -0.29865915f, 
    0.01114811f, -0.22369906f, -0.00262421f, 0.12946624f, -0.04209462f, -0.07789290f, 0.02720273f, -0.08910140f, 
    0.06693784f, -0.04366367f, 0.17050357f, 0.09255918f, 0.00990436f, -0.06529446f, 0.03361133f, 0.03310782f, 
    -0.04816695f, -0.04381704f, 0.01909487f, 0.06591565f, -0.00611474f, 0.33296198f, -0.01103135f, 0.11007889f, 
    -0.06270774f, 0.09519612f, -0.01601611f, -0.11953969f, -0.01587216f, 0.13573000f, -0.03794769f, 0.06135848f, 
    -0.08797593f, 0.13448745f, 0.03224286f, -0.00344915f, 0.01910871f, 0.02497281f, 0.02394643f, -0.08729447f, 
    0.13213716f, 0.14541461f, 0.04444207f, 0.17130880f, -0.22832291f, -0.03552861f, 0.08047293f, -0.00276214f, 
    -0.02384829f, -0.12662093f, -0.25528824f, -0.19343549f, 0.10089520f, -0.14870632f, 0.00533534f, 0.05261812f, 
    0.11769685f, 0.09525502f, -0.25083497f, 0.01264010f, 0.04465825f, -0.17531648f, 0.06671261f, 0.09723904f, 
    -0.05937185f, 0.01857355f, -0.05534863f, 0.00907955f, -0.17595865f, 0.17481180f, -0.18015999f, 0.08367830f, 
    0.07742463f, 0.06749295f, 0.01132687f, -0.07641176f, 0.02685220f, 0.08934264f, 0.00702263f, -0.02749332f, 
    0.15888751f, 0.04918583f, 0.08577521f, 0.02320901f, 0.04198623f, 0.03621596f, -0.01070713f, -0.03374656f, 
    -0.00212800f, 0.04858817f, -0.10992141f, -0.00989472f, 0.13038057f, 0.04562576f, 0.07523342f, 0.03940490f, 
    0.05178454f, 0.05227159f, -0.00925975f, 0.05873289f, 0.04974430f, -0.00183924f, 0.03943866f, -0.14881220f, 
    -0.01916189f, 0.06208533f, -0.06213276f, 0.00628689f, 0.03773005f, -0.04450568f, 0.01463795f, 0.00810998f, 
    0.06477951f, 0.07399396f, 0.06790798f, 0.05514924f, 0.21699768f, 0.05632390f, -0.06616922f, 0.16299927f, 
    0.01599680f, 0.05064085f, 0.16381367f, -0.16898647f, -0.00686623f, -0.08951972f, -0.00949125f, -0.10702340f, 
    -0.27378753f, 0.13565823f, -0.25929415f, -0.08962317f, -0.05575532f, 0.05394165f, 0.02474182f, 0.00937576f, 
    0.00475530f, -0.07311012f, -0.13192613f, 0.10180166f, -0.26501507f, 0.36334634f, 0.28297392f, 0.30450347f, 
    -0.08037349f, 0.00482810f, -0.08625174f, 0.06048043f, -0.00138691f, -0.01187058f, -0.03614520f, 0.06577814f, 
    0.00373057f, 0.22949106f, -0.17274316f, -0.08958229f, 0.02504229f, -0.04904113f, 0.03291187f, 0.04956398f, 
    0.00136332f, 0.06483217f, -0.09083165f, 0.07881562f, -0.46391097f, 0.18179595f, 0.26971155f, 0.59005141f, 
    0.01765370f, -0.08699150f, -0.05014348f, -0.01314679f, -0.02569749f, -0.03659733f, -0.06956828f, -0.02462145f, 
    0.09969340f, 0.02466722f, -0.09606064f, 0.05629099f, 0.02483178f, -0.03335671f, -0.02063408f, 0.08398836f, 
    0.08938166f, -0.10847033f, 0.11144331f, 0.05222265f, -0.41844636f, -0.02493339f, -0.07632783f, -0.02143068f, 
    0.00674885f, -0.02236264f, -0.01206020f, -0.00163269f, 0.00569189f, -0.18507221f, 0.08141066f, -0.01251146f, 
    -0.01121309f, -0.17785969f, -0.22460361f, 0.10106862f, -0.06444521f, 0.03596085f, 0.03979643f, 0.01035877f, 
    -0.02823583f, 0.02412874f, -0.14061403f, 0.20903806f, -0.05071345f, -0.15209797f, -0.07037595f, -0.34369010f, 
    0.00176852f, 0.01654508f, 0.02404950f, -0.18363543f, 0.00437075f, -0.00460636f, -0.02294347f, 0.11195136f, 
    0.00692736f, -0.13301823f, -0.01723521f, 0.10691686f, 0.08652247f, 0.03767947f, -0.00011669f, 0.01326696f, 
    -0.01947571f, -0.01874623f, 0.03390894f, 0.18020667f, -0.08939763f, -0.03219581f, -0.07164813f, 0.02467950f, 
    0.01930542f, 0.07491358f, -0.05520340f, 0.01507972f, -0.07476469f, -0.03459376f, 0.12828502f, -0.28752023f, 
    0.04690683f, -0.29017836f, -0.14584540f, -0.15740772f, -0.00497735f, -0.06983043f, 0.08685707f, -0.07696760f, 
    -0.01629337f, -0.09240640f, 0.06326362f, -0.10027172f, 0.01619289f, -0.34079680f, 0.37749332f, -0.01257415f, 
    -0.04085527f, 0.00760857f, 0.07051448f, 0.07210043f, 0.02573114f, -0.09384914f, -0.01736942f, 0.03510943f, 
    0.01081899f, -0.15965790f, 0.14201756f, 0.13508339f, 0.02656560f, 0.00558289f, -0.01948808f, 0.03650252f, 
    -0.02221925f, -0.01341613f, -0.02226747f, -0.01756060f, -0.04278842f, 0.05218334f, 0.03892921f, -0.00324208f, 
    -0.01758776f, -0.02569223f, 0.01709071f, -0.07520813f, 0.06979929f, 0.14555308f, 0.06696371f, 0.09839927f, 
    0.10164261f, 0.11781370f, 0.23564878f, 0.23011446f, 0.02296508f, -0.06281367f, 0.11419121f, 0.15160173f, 
    0.14429647f, 0.04757154f, 0.01045696f, 0.05042573f, -0.15730655f, 0.09787332f, -0.07241436f, 0.10320920f, 
    -0.14778784f, -0.01502042f, -0.15662414f, 0.10371554f, 0.04742261f, -0.00332534f, -0.03934035f, 0.01315164f, 
    -0.00309099f, -0.09497603f, -0.17761749f, 0.26399922f, -0.04496268f, -0.03431323f, 0.02188374f, 0.01132298f, 
    -0.00868941f, 0.04012506f, 0.04531503f, 0.06634559f, -0.00828054f, 0.06878207f, 0.00662959f, -0.13161138f, 
    0.10188669f, -0.20037539f, -0.10325785f, -0.08075064f, 0.00493867f, 0.04418004f, 0.00006775f, -0.00392054f, 
    0.01505643f, 0.02883814f, 0.24825270f, -0.36564243f, 0.01526269f, 0.03121101f, -0.03939497f, 0.03260652f, 
    -0.02139531f, -0.04958158f, -0.00056047f, -0.00574654f, -0.17515086f, 0.12613656f, 0.12511867f, -0.01836077f, 
    0.02838424f, 0.09378030f, -0.09126714f, 0.05433070f, -0.05074491f, 0.00057166f, 0.03412351f, -0.01086550f, 
    -0.20275195f, -0.13895728f, -0.09656918f, -0.03105700f, -0.01250188f, -0.02630861f, -0.04631528f, 0.02276430f, 
    -0.10210278f, -0.03978259f, -0.05242836f, -0.04095871f, -0.09007387f, -0.13420272f, -0.38811406f, 0.17015490f, 
    -0.05551067f, 0.03450612f, -0.03819105f, 0.13279136f, -0.02567239f, 0.06612208f, -0.13930437f, 0.01439723f, 
    -0.09004620f, -0.19502263f, -0.03229011f, -0.05578979f, 0.10336044f, -0.03391113f, -0.04175274f, 0.10079379f, 
    -0.01027489f, -0.00264087f, 0.00902152f, -0.05899115f, 0.27630967f, -0.18530042f, 0.03824944f, -0.21278471f, 
    0.10101839f, -0.07906861f, 0.06200072f, -0.00085165f, 0.04214647f, -0.07210921f, -0.06027343f, -0.09479873f, 
    -0.05301607f, -0.14157724f, 0.04101431f, -0.21447809f, -0.01494773f, 0.01233727f, -0.02960107f, 0.03069204f, 
    -0.02232612f, -0.06089240f, -0.00927929f, 0.02041487f, -0.20876731f, 0.19457678f, -0.16649637f, -0.08340819f, 
    0.00871066f, -0.02254644f, -0.03128625f, 0.02315191f, -0.03306891f, -0.01285604f, 0.07247928f, -0.06654397f, 
    -0.50318170f, -0.30566120f, -0.04760555f, 0.00801608f, -0.04765993f, -0.09987049f, -0.00005163f, 0.04710659f, 
    -0.01518493f, -0.00764721f, 0.00335787f, -0.01438031f, -0.21447419f, 0.16400379f, 0.18440646f, -0.15946744f, 
    -0.01775640f, -0.11258639f, 0.06462038f, -0.12639391f, -0.00192222f, -0.00160901f, -0.05000977f, -0.10172568f, 
    -0.40499285f, -0.35095215f, -0.12206203f, -0.33556053f, 0.03885814f, -0.00204641f, 0.12739697f, -0.05134799f, 
    -0.01765073f, -0.04383064f, 0.01218342f, -0.01373363f, 0.31570902f, 0.06493894f, 0.19449832f, 0.29077962f, 
    -0.02609414f, -0.01393531f, 0.04259733f, 0.00786413f, 0.01056784f, -0.11795112f, 0.10423189f, 0.13568416f, 
    0.04474098f, 0.08382939f, 0.33139423f, 0.37770316f, -0.05915898f, 0.00802855f, 0.06174391f, 0.04308968f, 
    -0.06364252f, -0.02263888f, -0.07070675f, 0.04634241f, -0.18702954f, -0.05547314f, -0.04992938f, -0.02878390f, 
    -0.00097451f, -0.04359059f, 0.00337918f, 0.03129778f, -0.07723602f, -0.05720605f, 0.00503749f, -0.02855624f, 
    0.00597367f, -0.37550613f, -0.20794401f, 0.03401743f, -0.02767443f, -0.03079409f, 0.03989875f, -0.03441471f, 
    0.04874594f, -0.00288258f, -0.00858432f, 0.07268237f, 0.10939223f, -0.21338782f, -0.00522513f, -0.13954675f, 
    -0.01654070f, 0.01159162f, -0.06059634f, 0.02042141f, 0.05975809f, 0.02508715f, -0.11349283f, 0.13547805f, 
    -0.33275035f, -0.03890416f, 0.01806723f, 0.06105480f, 0.00550354f, -0.09566841f, 0.04697273f, 0.01914169f, 
    0.04928118f, 0.01576391f, 0.01957559f, -0.06291372f, 0.47068173f, -0.04180815f, -0.13807705f, -0.17734496f, 
    0.15600158f, 0.03650595f, -0.05289195f, -0.03681077f, -0.10034208f, 0.03550583f, -0.02324907f, 0.10045436f, 
    -0.74286658f, -0.20613302f, -0.01228117f, -0.42042917f, 0.05494362f, -0.04946108f, 0.03924111f, -0.22851081f, 
    -0.02153360f, 0.01785745f, 0.00050565f, -0.06770504f, -0.02376977f, -0.00731988f, -0.03654020f, -0.52066046f, 
    0.03475603f, -0.02924087f, -0.08906688f, 0.04186241f, -0.00431241f, 0.04470520f, -0.10861933f, 0.03918150f, 
    0.01527738f, 0.28155273f, 0.07383902f, 0.16848688f, -0.21521288f, -0.04728797f, -0.05915671f, 0.09534134f, 
    0.00881273f, 0.00774217f, -0.01452986f, 0.01844114f, -0.21579866f, 0.30869544f, 0.30660102f, -0.09114481f, 
    -0.01808593f, 0.05191309f, 0.00506859f, -0.23015352f, 0.04253463f, 0.08261469f, -0.10944989f, 0.11554397f, 
    0.17518993f, 0.18379278f, 0.14958726f, 0.22295420f, -0.01055574f, -0.00161550f, 0.08180168f, -0.03055909f, 
    -0.05713771f, 0.01680320f, 0.03927572f, 0.08285569f, 0.20477444f, 0.02390919f, -0.15143487f, -0.07277659f, 
    -0.03946734f, 0.01118246f, 0.00241426f, 0.04928542f, 0.04776232f, 0.01274120f, -0.12324640f, 0.15232615f, 
    -0.22596030f, 0.39997694f, 0.60688835f, -0.07956680f, -0.09577011f, -0.03502484f, -0.00778781f, -0.06853971f, 
    0.06499173f, 0.04030458f, 0.09403639f, -0.10333282f, -0.06741902f, 0.05672579f, -0.05641769f, 0.01487245f, 
    -0.05063608f, -0.03089452f, 0.04410978f, -0.12228762f, 0.02634463f, -0.02600652f, 0.21343754f, 0.02577871f, 
    -0.06027183f, -0.22510785f, 0.34675515f, 0.06037221f, 0.02778937f, 0.03884913f, 0.06633359f, -0.00284504f, 
    0.03986851f, 0.06632363f, 0.05668554f, -0.05202968f, 0.17182152f, 0.25271276f, 0.07063868f, 0.18989885f, 
    0.08087793f, 0.00163143f, -0.00701599f, -0.02405359f, 0.01137654f, 0.04223606f, -0.15600413f, 0.14386760f, 
    -0.95012993f, -0.40553102f, -0.21955468f, -0.35243246f, 0.01723466f, -0.04868748f, -0.23691894f, -0.26185668f, 
    0.05593748f, -0.02037317f, -0.08290696f, -0.02057038f, -0.08275537f, -0.09092674f, -0.43055975f, 0.14835562f, 
    0.02454700f, -0.02916201f, 0.03675956f, -0.14800191f, -0.07150859f, -0.01835467f, -0.02954560f, -0.09089021f, 
    0.33131731f, 0.14074090f, -0.08016147f, -0.05434413f, -0.06293254f, -0.22475880f, -0.04967382f, 0.14950407f, 
    0.01744216f, 0.10778239f, -0.11180905f, -0.08572003f, -0.04517286f, -0.11183412f, 0.02122340f, 0.00734366f, 
    0.01580219f, -0.06300879f, -0.01568103f, -0.08120447f, -0.00544707f, -0.05026991f, -0.24599320f, 0.20817658f, 
    -0.11214097f, -0.31741136f, -0.48966926f, -0.06995915f, 0.03472823f, 0.07629597f, -0.03042141f, 0.02723831f, 
    0.09117870f, 0.00863052f, -0.01897396f, 0.05466219f, -0.21748148f, -0.06370290f, 0.31465024f, -0.35014808f, 
    0.04058429f, 0.00428590f, -0.01852335f, -0.03922467f, 0.00160374f, -0.02346044f, -0.06164578f, 0.02964626f, 
    -0.04615734f, -0.03643703f, -0.04605262f, -0.11119678f, -0.12532160f, 0.02955755f, -0.01539611f, 0.01070905f, 
    -0.04106530f, -0.06792129f, 0.01321720f, 0.00015012f, -0.34461349f, 0.14352137f, -0.12508710f, -0.15052408f, 
    0.03755667f, 0.01676840f, -0.10103503f, -0.03992951f, 0.02347542f, 0.00614136f, 0.07830865f, -0.02456401f, 
    -0.15884501f, -0.01274777f, -0.11352556f, 0.05228083f, 0.12240495f, -0.05830652f, 0.03897211f, -0.05346392f, 
    -0.07728901f, 0.02199356f, -0.03074728f, -0.00805224f, -0.30591422f, -0.00989290f, -0.08720781f, 0.36589682f, 
    -0.13609342f, -0.08129860f, -0.00690078f, -0.02652781f, -0.06666256f, 0.02042051f, 0.07233468f, 0.02789800f, 
    -0.21199514f, -0.25658631f, 0.09865300f, -0.02966949f, -0.09125832f, 0.03091544f, -0.09909081f, 0.00462621f, 
    0.08168226f, 0.10343552f, -0.06709547f, 0.04219913f, -0.27367952f, -0.00011475f, 0.23936759f, 0.03138509f, 
    0.00099860f, 0.14187309f, -0.15106033f, 0.13196377f, 0.04748079f, -0.02739843f, 0.14197521f, -0.06710473f, 
    0.25904158f, 0.11922196f, 0.24708040f, -0.27796263f, 0.03139981f, -0.03386749f, 0.01051381f, -0.08984056f, 
    -0.00825920f, 0.06194167f, 0.02600977f, -0.00637461f, -0.17024601f, -0.15750836f, 0.06190746f, 0.07765622f, 
    -0.07764120f, 0.11304528f, 0.13838793f, 0.07652171f, 0.01918080f, 0.13526221f, -0.11698778f, 0.07205370f, 
    -0.11044790f, 0.51209390f, -0.44280535f, -0.45069960f, 0.10035387f, 0.03599430f, -0.04147271f, 0.03023813f, 
    -0.10218491f, -0.12036780f, -0.00939121f, -0.06673545f, -0.29207188f, 0.09797235f, 0.05622190f, -0.17194384f, 
    0.19248776f, 0.10246722f, -0.12757340f, 0.03203308f, -0.07286654f, 0.08083843f, 0.03958776f, -0.07567064f, 
    -0.23406032f, -0.02537871f, -0.03632631f, 0.13349429f, -0.10633320f, 0.07203445f, -0.06631558f, -0.05389151f, 
    0.01102085f, 0.15567946f, -0.12478025f, -0.04682699f, 0.33717889f, 0.11949323f, 0.04819214f, 0.15842190f, 
    -0.10760819f, -0.04227625f, 0.00386522f, -0.00608275f, -0.08094310f, -0.10819864f, 0.02567182f, -0.01057220f, 
    -0.42821664f, -0.47839457f, 0.30553228f, -0.32836312f, 0.08665016f, 0.18263754f, 0.19698334f, 0.08228371f, 
    -0.27264324f, 0.02163160f, -0.08333759f, 0.04632015f, 0.46196648f, -0.20600702f, 0.08689141f, 0.16567490f, 
    0.10757968f, -0.05121114f, -0.04413580f, -0.06788070f, 0.08739018f, 0.08681042f, 0.02554599f, 0.15024605f, 
    -0.23362660f, 0.24521057f, -0.09726869f, -0.19880146f, -0.04052706f, -0.09177984f, -0.06764177f, 0.00880046f, 
    -0.05655335f, 0.05276712f, -0.06800953f, 0.03187736f, 0.33848205f, -0.15074092f, -0.00877157f, 0.21905734f, 
    0.12249517f, -0.01958791f, -0.01285636f, 0.03586238f, 0.03993087f, 0.01150683f, 0.07912767f, 0.15778854f, 
    -0.08734176f, 0.03839887f, -0.21110681f, 0.01202912f, 0.07247609f, 0.04700425f, 0.08092988f, -0.15441531f, 
    -0.13936466f, -0.03122805f, 0.06692892f, 0.05621867f, -0.52648556f, -0.10320570f, -0.05387281f, -0.08883851f, 
    0.05058179f, -0.07284006f, -0.07092072f, -0.16544218f, -0.03068528f, 0.17760654f, -0.01097882f, 0.07945678f, 
    0.02819183f, -0.29774034f, 0.00101324f, -0.46131894f, 0.01095687f, -0.09801373f, -0.05523117f, 0.01263000f, 
    0.00335522f, 0.10918646f, -0.07344863f, -0.23641866f, -0.03692217f, -0.13787818f, 0.01770640f, 0.11187202f, 
    0.02053104f, 0.07485143f, 0.09043798f, 0.08631627f, -0.02906573f, 0.07074954f, -0.02493668f, 0.03251681f, 
    0.30307353f, -0.01833035f, -0.20540744f, -0.15422104f, -0.10561328f, 0.09330717f, 0.03393375f, -0.01019217f, 
    -0.13742125f, -0.19094245f, 0.08905176f, -0.18267728f, 0.06890279f, 0.08885600f, 0.12268927f, -0.14637025f, 
    0.15535291f, -0.23716420f, -0.05525639f, -0.04020817f, -0.02656634f, 0.05482385f, -0.01199692f, 0.07008475f, 
    0.33551633f, -0.31108022f, -0.05322647f, 0.20860855f, -0.19007076f, -0.14179750f, -0.03547342f, -0.09296334f, 
    -0.15672007f, 0.05688475f, 0.06873342f, 0.01066573f, -0.19118521f, 0.26545101f, -0.20614274f, -0.21879528f, 
    0.19689593f, 0.04325927f, -0.00037875f, -0.04627674f, -0.31823888f, 0.02607503f, -0.07587696f, 0.06044314f, 
    0.24997279f, -0.24687888f, 0.09170538f, -0.05956715f, -0.08564536f, -0.01305259f, -0.05292078f, 0.10176956f, 
    -0.08026791f, -0.10659803f, 0.03928801f, -0.01751015f, 0.17822106f, -0.06594667f, 0.05006373f, -0.02568708f, 
    -0.04884783f, -0.01137968f, -0.07504719f, 0.05188688f, -0.07178088f, 0.03559692f, 0.07775867f, 0.03497786f, 
    -0.16065091f, -0.19437742f, -0.00970669f, 0.02342020f, 0.06991049f, 0.13247663f, 0.04052854f, -0.00232298f, 
    0.00901760f, -0.02527112f, -0.12812066f, 0.01734806f, -0.02486763f, 0.05599552f, -0.33719209f, 0.05768234f, 
    -0.02290966f, -0.21312983f, 0.01424942f, 0.04621269f, -0.07090417f, -0.00688578f, 0.01708220f, 0.05047558f, 
    0.07878389f, -0.08428825f, -0.10399857f, -0.34546807f, -0.24410976f, -0.06440087f, -0.11627831f, 0.04551467f, 
    -0.07989089f, -0.05089759f, -0.01561899f, -0.02668988f, -0.24039496f, -0.09507331f, 0.46853593f, 0.00991125f, 
    0.04653985f, 0.14992833f, -0.16730604f, -0.00474669f, 0.08368453f, -0.21313220f, -0.03309964f, -0.09522955f, 
    -0.00035900f, -0.14856336f, 0.35979068f, 0.09259255f, -0.14411671f, -0.09019758f, -0.16963841f, 0.02439887f, 
    0.16357848f, 0.10044062f, -0.05355054f, 0.10884055f, -0.13792056f, 0.03915517f, -0.07686063f, 0.04950606f, 
    0.08516051f, -0.17069063f, -0.10259846f, -0.11558945f, 0.02142218f, 0.05043167f, 0.13329661f, -0.14590926f, 
    -0.58899540f, -0.49184644f, -0.26977724f, -0.10180224f, 0.02435380f, -0.07756180f, 0.02151530f, -0.14533214f, 
    -0.07735410f, 0.14010379f, -0.03147417f, -0.05537591f, 0.11024795f, -0.00323639f, -0.19532014f, -0.36960888f, 
    -0.05274915f, -0.04012569f, -0.07225120f, 0.17539600f, -0.01490760f, 0.09107532f, -0.11530588f, 0.05606569f, 
    -0.11428684f, 0.19922924f, -0.33933997f, -0.21495120f, 0.07958041f, -0.02606368f, -0.08026624f, -0.03202556f, 
    -0.17818530f, -0.04196358f, -0.00847536f, -0.00214314f, 0.08398562f, 0.29241633f, -0.30433640f, -0.05342619f, 
    0.02951742f, -0.25914964f, -0.17553674f, -0.04606981f, 0.00468214f, -0.05617196f, -0.12358385f, -0.05633490f, 
    -0.06869030f, -0.27511153f, 0.37544137f, -0.15123421f, -0.03091520f, 0.03079830f, -0.25639161f, 0.01115539f, 
    -0.01125381f, 0.09613215f, 0.20480885f, 0.04002474f, 0.04779632f, -0.07289457f, -0.17068468f, 0.07135618f, 
    -0.09448303f, -0.05957336f, -0.06781874f, -0.13937886f, 0.03131256f, 0.01338725f, 0.07514291f, -0.07483793f, 
    -0.05128265f, -0.07607602f, -0.09152482f, 0.12761658f, 0.07429010f, -0.01704236f, -0.01952699f, 0.04531385f, 
    -0.04875939f, 0.07602009f, -0.11419657f, 0.01525040f, -0.30188155f, 0.01612378f, 0.04204516f, 0.20924720f, 
    0.06390792f, -0.13356009f, -0.00018907f, -0.01784481f, -0.01774713f, 0.07928721f, 0.11341481f, 0.04430729f, 
    -0.02209901f, -0.02857799f, -0.15484911f, 0.18449807f, 0.03001007f, -0.03590539f, 0.00508193f, -0.04772861f, 
    0.02402317f, 0.11617407f, -0.04896879f, -0.07189345f, 0.08177587f, -0.06059135f, 0.08128323f, 0.13102113f, 
    0.13911028f, 0.02956774f, -0.07550589f, -0.17854927f, -0.05696518f, -0.01610887f, 0.07617215f, -0.01030230f, 
    -0.01462884f, -0.05953258f, -0.02733053f, 0.18046935f, -0.00920477f, -0.03337643f, 0.05557076f, 0.06957582f, 
    0.01207056f, 0.07549432f, 0.03222805f, 0.01631030f, -0.37846726f, -0.00568597f, -0.08062513f, 0.03507756f, 
    0.11486173f, -0.10451175f, -0.07564260f, -0.07922697f, 0.01098674f, -0.06969735f, 0.02544382f, -0.08744046f, 
    -0.08494840f, 0.18787789f, -0.19064677f, -0.03362069f, 0.04576169f, 0.02579738f, 0.11042735f, -0.08210219f, 
    -0.15433721f, 0.14718451f, 0.05571787f, -0.13405846f, 0.20613399f, -0.09350631f, 0.21908684f, -0.12869050f, 
    -0.00379872f, -0.07141040f, -0.00830572f, -0.03187530f, -0.00936937f, 0.01598076f, -0.09091112f, -0.02627757f, 
    -0.00066792f, -0.15616511f, -0.11876296f, 0.09757486f, 0.06337448f, -0.05983980f, -0.01540102f, -0.04576571f, 
    -0.06430459f, -0.01300193f, 0.04175435f, 0.08968355f, 0.23462488f, -0.03555532f, 0.10825022f, -0.04180871f, 
    -0.03766139f, 0.06629247f, -0.08526297f, -0.13130239f, -0.04517184f, 0.02230096f, 0.01437845f, -0.13720685f, 
    -0.17752670f, -0.08673094f, -0.02634757f, 0.25615346f, -0.09948832f, -0.02587573f, 0.04146823f, -0.01267413f, 
    -0.06796362f, -0.00780167f, 0.05173435f, 0.00274684f, 0.10015081f, -0.01425639f, 0.60508126f, -0.09033420f, 
    -0.30178449f, 0.02393709f, -0.01544322f, 0.03353778f, 0.22251223f, 0.02882610f, 0.05568916f, 0.06443383f, 
    0.15810917f, -0.03713313f, 0.02626221f, 0.09759554f, 0.02386976f, -0.10787111f, -0.03837994f, 0.06088125f, 
    0.00850662f, 0.16239671f, -0.01136263f, 0.10294744f, -0.75677383f, 0.05220929f, 0.01945225f, 0.11836770f, 
    -0.04579664f, 0.03482274f, 0.04390637f, -0.21649584f, -0.03881352f, 0.05722693f, 0.11073837f, -0.13426593f, 
    0.10659464f, -0.21114586f, 0.00129611f, -0.04625003f, 0.16031326f, 0.08670671f, -0.01356555f, -0.07370700f, 
    -0.01918557f, -0.02524188f, -0.06794561f, 0.06709861f, -0.04791446f, -0.02731912f, -0.28171712f, -0.11169270f, 
    -0.14448296f, 0.04489448f, -0.00821136f, -0.13366766f, -0.06134242f, -0.02454792f, -0.18332160f, -0.01948602f, 
    -0.25369874f, 0.87072909f, -0.04444522f, 0.27491307f, 0.24362032f, 0.02324148f, 0.24879222f, -0.04731173f, 
    -0.06787509f, -0.03917251f, 0.05012668f, -0.05669164f, -0.17594545f, -0.01370729f, 0.07915533f, 0.17207132f, 
    -0.04111997f, -0.02217368f, 0.01245551f, 0.02443280f, 0.11233492f, 0.02868098f, 0.02938958f, 0.00978996f, 
    0.26215014f, 0.41845316f, -0.10253703f, -0.24620795f, 0.21597433f, 0.16114721f, 0.14369597f, 0.02384413f, 
    -0.22454245f, -0.10197930f, -0.00378062f, -0.07768957f, 0.80806369f, -0.17780861f, -0.04532379f, 0.03738772f, 
    0.11055368f, 0.01954125f, 0.00011292f, 0.01843684f, -0.06013354f, 0.04974709f, 0.01793592f, 0.03281964f, 
    -0.08823821f, -0.15001705f, 0.12041097f, 0.19712576f, 0.06199634f, 0.09999220f, 0.12025022f, 0.04596750f, 
    0.06270152f, 0.02619142f, -0.04085136f, -0.07952502f, 0.01674660f, -0.04831959f, -0.10896632f, 0.12341797f, 
    0.08350977f, 0.01262109f, -0.06837589f, 0.07303812f, -0.15755755f, -0.02141540f, -0.00976674f, -0.15963040f, 
    -0.45760393f, 0.47003332f, -0.24350470f, 0.13611206f, 0.06071978f, 0.09333016f, 0.02709478f, -0.08426842f, 
    -0.21049079f, 0.01638556f, -0.16116080f, 0.15666306f, -0.32756153f, 0.17181636f, 0.19953616f, 0.06214533f, 
    -0.08060826f, -0.02872274f, -0.24682191f, -0.08255546f, -0.02411096f, -0.20461576f, -0.10059700f, -0.07337963f, 
    -0.00961201f, -0.09554336f, -0.15924624f, 0.00748049f, 0.07365081f, -0.00599532f, 0.01264801f, 0.11759549f, 
    0.02294133f, 0.09160375f, 0.03248537f, -0.09168755f, -0.33959976f, -0.20740272f, 0.19555508f, 0.09867788f, 
    0.00100250f, 0.05520852f, -0.16215120f, -0.14102323f, -0.14873011f, 0.07525276f, 0.01496505f, 0.04223803f, 
    0.10314099f, 0.11741687f, 0.03777301f, 0.26407942f, -0.04916540f, 0.03373203f, -0.16224378f, 0.01645279f, 
    -0.04783800f, 0.06765632f, 0.19261771f, 0.05910855f, -0.07111722f, 0.06876183f, 0.07319183f, 0.38107944f, 
    0.11837764f, 0.06346314f, 0.02271768f, 0.18481265f, 0.07968729f, -0.03637678f, 0.12628312f, 0.08508097f, 
    -0.08675721f, -0.03901527f, 0.04703855f, 0.03799271f, -0.12695792f, -0.02389533f, 0.00078227f, 0.04136212f, 
    -0.03063677f, 0.09420837f, 0.02388442f, 0.06433441f, -0.17695032f, 0.05304909f, 0.02000746f, 0.02723619f, 
    0.05664871f, -0.03709094f, -0.05324618f, -0.11183526f, -0.01847557f, -0.11894376f, -0.06756883f, -0.01322166f, 
    -0.06009587f, 0.03374759f, -0.08367442f, -0.01762036f, 0.05877186f, -0.07346704f, 0.02218614f, -0.05167112f, 
    0.01328486f, -0.01958842f, 0.10406958f, 0.28110284f, -0.01131616f, 0.06303170f, 0.03756672f, 0.14890935f, 
    0.07099468f, -0.04877141f, 0.06311229f, -0.06497887f, 0.09627005f, 0.09374598f, -0.13079667f, 0.06556889f, 
    0.15403026f, -0.29493624f, -0.42698553f, 0.31777248f, 0.03617052f, -0.16285528f, -0.03833137f, -0.19099158f, 
    -0.09640362f, -0.03811398f, -0.06332217f, 0.12674004f, 0.09691873f, 0.08968975f, 0.02070566f, -0.04125835f, 
    -0.12203638f, 0.13641590f, -0.12156288f, -0.29698637f, 0.03713959f, -0.12127709f, 0.10173072f, 0.09872609f, 
    -0.14440098f, -0.39269766f, 0.02319958f, -0.10927206f, 0.02006406f, 0.06832960f, -0.01978725f, 0.01285576f, 
    -0.08861349f, -0.06674492f, 0.02019188f, -0.09494065f, 0.14475645f, 0.05375543f, -0.06040045f, -0.09460231f, 
    -0.11707165f, -0.06038080f, 0.08864845f, -0.19555835f, -0.02801952f, 0.07491820f, -0.04008330f, -0.06292130f, 
    -0.01320723f, 0.04226840f, -0.00421659f, -0.01136185f, 0.07756662f, -0.08444218f, 0.04409727f, -0.14059351f, 
    0.03150728f, -0.14461276f, -0.01940406f, 0.12592697f, -0.06122429f, -0.15708168f, -0.05723171f, -0.07537384f, 
    -0.08605905f, -0.01229848f, -0.10665374f, -0.00638539f, 0.06956214f, -0.02956550f, -0.19182570f, 0.08686259f, 
    0.01392766f, 0.11609583f, -0.21657038f, -0.13709246f, 0.06983056f, -0.03246375f, 0.01267961f, 0.06406964f, 
    0.08098914f, 0.10257998f, -0.05963019f, -0.23018979f, -0.19072704f, -0.09923181f, -0.01775020f, 0.15956248f, 
    -0.05967249f, -0.14981514f, 0.00248337f, -0.19150534f, 0.02501792f, -0.05445546f, 0.12802145f, -0.03039552f, 
    -0.06375918f, -0.22751646f, 0.10470083f, 0.23788610f, 0.04196302f, -0.01547654f, -0.05900056f, -0.02263940f, 
    -0.04588170f, -0.10338846f, -0.01745754f, 0.09949560f, -0.09628983f, -0.09369586f, -0.00488458f, 0.14592706f, 
    -0.05525913f, -0.14196678f, -0.15372969f, -0.04110952f, 0.01727471f, -0.06088685f, 0.05871115f, 0.00868737f, 
    0.05951329f, 0.22025579f, -0.11133798f, -0.10218946f, 0.03292830f, -0.02778923f, 0.02184223f, 0.02955692f, 
    0.00533722f, 0.00400258f, -0.39067477f, -0.07279162f, 0.29979160f, -0.51717913f, -0.08962193f, -0.25634390f, 
    0.00546964f, -0.01305031f, 0.00020830f, -0.00291328f, -0.00864567f, -0.01866402f, -0.03961586f, 0.07657830f, 
    0.08341003f, -0.04866141f, -0.08658560f, -0.18605264f, -0.05480978f, -0.05141744f, 0.09736281f, 0.08786659f, 
    -0.02282873f, -0.06428490f, 0.04425535f, -0.02316934f, 0.08292633f, 0.24366005f, 0.11883844f, 0.25242239f, 
    0.02366213f, -0.03608944f, 0.00418826f, -0.03687767f, 0.12902614f, 0.07357682f, 0.09691615f, 0.02307914f, 
    0.01843252f, 0.05314582f, -0.04101704f, 0.04702772f, 0.08804184f, -0.03452593f, -0.05594135f, 0.05255968f, 
    0.05894024f, 0.02372930f, -0.14119142f, -0.14354277f, 0.03168798f, 0.05993085f, -0.12481819f, 0.11267654f, 
    0.05256106f, -0.06854425f, 0.13398442f, -0.00907710f, -0.24462621f, -0.23088759f, -0.24232771f, -0.26001918f, 
    -0.14810081f, 0.03762243f, -0.06289466f, 0.07295173f, -0.11645981f, 0.11785910f, -0.21211579f, 0.07006638f, 
    -0.00192105f, -0.14106089f, 0.07423776f, -0.19141693f, 0.30093476f, -0.35937747f, 0.00791323f, 0.03165407f, 
    -0.07186849f, 0.03594350f, -0.01870957f, -0.03702288f, 0.07630879f, -0.11039763f, 0.00056452f, -0.09822073f, 
    -0.02868507f, -0.08164474f, -0.12758204f, 0.00357274f, 0.02222898f, -0.02545790f, 0.00641941f, 0.02198189f, 
    0.03360544f, -0.10371689f, -0.00220685f, -0.01427994f, -0.00999720f, 0.05807131f, -0.10401654f, -0.00328082f, 
    0.01747177f, -0.02955521f, 0.04580308f, -0.06081655f, 0.07110658f, 0.09364289f, 0.16990431f, 0.37658796f, 
    0.20502414f, 0.17953824f, 0.02001195f, 0.02593193f, -0.08963052f, -0.06939013f, 0.02853820f, 0.06747873f, 
    -0.04971852f, -0.10868080f, -0.01927051f, 0.02289267f, -0.00045804f, -0.17422192f, 0.21763891f, -0.05861862f, 
    -0.19406295f, 0.10473460f, -0.13494726f, -0.05790882f, -0.12527564f, -0.01025951f, -0.00188655f, 0.01996803f, 
    -0.08502728f, -0.09999188f, -0.01057135f, -0.14190426f, -0.39144218f, 0.02706727f, -0.04187889f, 0.00137058f, 
    -0.08285448f, -0.04352945f, -0.09768084f, -0.02441550f, 0.07137297f, 0.03743513f, -0.10014606f, 0.15048894f, 
    0.02059600f, 0.10212138f, -0.16110529f, -0.02662648f, 0.10182836f, -0.01983641f, -0.06525753f, 0.04256081f, 
    0.25575095f, 0.30908045f, -0.14659376f, 0.09985252f, -0.01301980f, -0.07928102f, 0.11211958f, -0.01001026f, 
    0.04180145f, -0.02769697f, 0.03058977f, -0.06388121f, 0.13782217f, -0.03214295f, 0.06067022f, -0.08300624f, 
    -0.11486188f, 0.04078088f, -0.12244707f, -0.01638335f, 0.00548146f, -0.00313332f, -0.16208458f, -0.07894749f, 
    -0.01416108f, 0.01069451f, 0.00100024f, 0.00677644f, 0.06446434f, 0.01699079f, 0.02188483f, 0.03542596f, 
    0.07377888f, 0.03219105f, 0.00315239f, 0.01411349f, 0.06265516f, -0.05824626f, 0.13442910f, 0.10659996f, 
    -0.25160709f, -0.03777895f, -0.10263085f, -0.05750811f, 0.01284641f, -0.02896300f, -0.06887156f, 0.00449182f, 
    -0.20272624f, -0.20184299f, 0.18166329f, 0.19331323f, 0.00347161f, 0.00520568f, 0.06894549f, -0.17794301f, 
    -0.16336194f, 0.03670231f, -0.07147000f, -0.02663673f, -0.13303190f, -0.34058172f, 0.12698172f, -0.02651406f, 
    0.05365942f, 0.04237045f, -0.12684546f, -0.08057797f, -0.03511901f, -0.14883186f, 0.07435862f, -0.05886789f, 
    0.00937611f, 0.01613816f, -0.54776108f, -0.19775586f, 0.00772082f, -0.03105279f, -0.00703570f, 0.00643483f, 
    0.04525504f, -0.10945624f, -0.02928640f, -0.14355235f, -0.37469906f, -0.22489706f, 0.09186139f, 0.01085450f, 
    0.06023568f, 0.03443997f, -0.01791755f, 0.06967873f, -0.07057782f, 0.08538219f, 0.00347924f, 0.08671969f, 
    -0.07206608f, -0.05713205f, 0.14453873f, -0.05380194f, -0.03002547f, -0.04790336f, -0.09000839f, -0.00593057f, 
    0.02627618f, -0.09130663f, 0.05672432f, 0.04349792f, 0.01866771f, -0.02481096f, 0.10707626f, 0.03450346f, 
    -0.01953920f, 0.05297586f, -0.07941379f, -0.11995535f, -0.13286366f, -0.26933429f, -0.12207104f, -0.01401943f, 
    0.01501527f, 0.02474789f, 0.21132536f, 0.16501389f, -0.05630491f, -0.04027170f, -0.08233055f, -0.02384049f, 
    0.00964217f, 0.03232880f, -0.02175420f, 0.00749286f, 0.06155671f, 0.01283660f, -0.08202057f, 0.15288113f, 
    -0.08462255f, -0.02698944f, 0.07291126f, -0.04480743f, 0.12623353f, 0.01394010f, 0.01651017f, 0.16367292f, 
    0.04452699f, 0.11594289f, 0.05896158f, 0.12798972f, -0.09085063f, -0.07867023f, 0.04517029f, -0.15681149f, 
    -0.11470779f, -0.04760124f, -0.02570208f, 0.06585692f, 0.09856619f, 0.00588037f, 0.02821037f, 0.03319341f, 
    0.14830798f, 0.02902395f, 0.02981274f, 0.09247577f, 0.03092905f, 0.05176698f, -0.01704804f, -0.01675743f, 
    -0.04366845f, 0.10514556f, 0.16133799f, -0.05868601f, -0.03515475f, -0.03030326f, -0.01746623f, -0.00907745f, 
    0.05292134f, -0.02915224f, 0.03885260f, -0.11413177f, 0.08661376f, 0.03823994f, -0.11019662f, 0.18863682f, 
    -0.13061036f, -0.05229333f, -0.01076461f, -0.17098387f, 0.02393727f, -0.32150823f, 0.03355616f, -0.28420794f, 
    -0.05035963f, 0.08826499f, 0.12494861f, 0.08999791f, -0.06836987f, -0.13376397f, -0.04283746f, 0.02592816f, 
    0.05866989f, 0.01505858f, -0.02685909f, 0.01986329f, -0.05270324f, 0.00970015f, -0.10758142f, 0.17006759f, 
    0.01732030f, -0.09821452f, 0.02133930f, -0.29895717f, 0.04237321f, -0.06516187f, 0.07660581f, 0.04670779f, 
    -0.01762365f, 0.21830837f, 0.08046990f, 0.02310993f, 0.04214323f, -0.01816850f, 0.09152052f, 0.11282860f, 
    -0.02990833f, -0.07266214f, 0.00934554f, -0.13683003f, 0.49658346f, 0.22464469f, -0.33724192f, 0.45691311f, 
    0.08512691f, 0.04676795f, 0.09306821f, -0.08588639f, 0.12744711f, 0.03502286f, 0.05316394f, 0.03374463f, 
    -0.00999519f, 0.05250048f, 0.06995791f, 0.13619892f, -0.00498887f, -0.04450704f, -0.01324277f, -0.27852014f, 
    0.02820962f, 0.04482714f, 0.01772857f, -0.00106963f, 0.18429822f, -0.17126010f, -0.13008149f, 0.01855985f, 
    -0.04345918f, -0.09298994f, -0.06245059f, -0.01527111f, -0.04978656f, -0.12004302f, -0.08507114f, 0.29101196f, 
    0.21889128f, 0.14440671f, -0.05056844f, 0.09788082f, -0.01866416f, -0.03809148f, 0.00730757f, 0.05216345f, 
    0.09633564f, -0.08932854f, -0.01830758f, 0.08218979f, -0.02921477f, -0.02065754f, 0.04631271f, 0.05026338f, 
    0.02689506f, -0.04860644f, -0.02256582f, -0.07972872f, -0.10952238f, 0.04809983f, 0.03224585f, -0.08137540f, 
    -0.28862947f, -0.28493229f, 0.09159350f, -0.18201254f, 0.02817769f, 0.16642131f, -0.21727049f, 0.09639917f, 
    -0.01860983f, 0.00760511f, -0.04429587f, 0.14375600f, 0.03089401f, 0.14469551f, -0.04283029f, 0.04737784f, 
    0.02276114f, -0.05170460f, 0.02631734f, -0.06611325f, -0.08515954f, -0.02601139f, -0.00827828f, 0.23867175f, 
    -0.02129736f, -0.37906489f, -0.18180080f, -0.29110208f, -0.01482759f, -0.01183095f, 0.04336995f, 0.07170572f, 
    0.02499468f, -0.06287352f, 0.01516518f, 0.04852688f, 0.09937869f, -0.10535261f, -0.04932120f, 0.08176579f, 
    -0.09776027f, -0.00729695f, -0.07752057f, 0.12450553f, 0.05039625f, -0.12036800f, -0.06928153f, 0.01564617f, 
    0.09780626f, 0.33252832f, 0.31415203f, 0.22936469f, 0.10596960f, 0.09918045f, 0.14148752f, 0.05696825f, 
    0.08179521f, -0.03151657f, 0.02537307f, -0.11432204f, 0.15713997f, -0.07082614f, 0.24637383f, 0.11491297f, 
    -0.12095566f, -0.01911583f, -0.07540096f, -0.02538216f, -0.01258318f, -0.08064655f, 0.01072666f, 0.06172481f, 
    0.07772823f, -0.26151645f, 0.06128063f, 0.04101681f, 0.18880996f, -0.15362024f, 0.00702403f, 0.03950194f, 
    0.03629417f, -0.11849800f, 0.11367671f, -0.00001556f, 0.03853717f, -0.03024637f, -0.15943155f, -0.02529652f, 
    -0.00821169f, 0.14670584f, 0.06882682f, -0.06414969f, 0.04926671f, -0.05121561f, 0.11823835f, -0.10203540f, 
    0.19407052f, 0.14656368f, 0.32257098f, 0.15683028f, -0.07399000f, -0.07950588f, -0.06933880f, -0.07777702f, 
    0.07595909f, 0.02793740f, 0.01348150f, 0.04346722f, -0.08096679f, -0.00210128f, -0.41783789f, -0.03759282f, 
    0.11452237f, 0.00951381f, 0.05666891f, 0.02012133f, 0.04392705f, -0.01174896f, -0.00071631f, -0.07021707f, 
    0.02210122f, 0.07985257f, -0.08700471f, 0.00282499f, 0.10291744f, 0.03774311f, -0.08412719f, 0.01306813f, 
    0.04693243f, -0.02883837f, -0.01790001f, -0.09019429f, 0.22318791f, 0.04666702f, 0.27224895f, 0.12152883f, 
    -0.04168779f, 0.04061624f, -0.02420701f, -0.18304525f, 0.04571141f, 0.05144398f, -0.08111276f, 0.13807407f, 
    -0.01131474f, 0.03966901f, 0.07445721f, -0.23573676f, -0.00457448f, 0.04461730f, 0.00924133f, 0.07661472f, 
    -0.03515352f, -0.01221498f, -0.11606510f, 0.18810810f, 0.21425807f, -0.17762581f, -0.11010425f, -0.07512825f, 
    -0.10189495f, -0.00898283f, 0.01288013f, 0.21502887f, -0.08198982f, -0.04556359f, 0.00676750f, -0.15346070f, 
    0.03130829f, -0.06894322f, -0.22349435f, -0.01475600f, 0.00919011f, 0.08177823f, 0.11131642f, 0.06576696f, 
    -0.04852724f, -0.26161885f, -0.05796450f, -0.33652663f, 0.05451223f, -0.01712159f, -0.16093640f, 0.09748576f, 
    0.03346935f, 0.04734677f, 0.02908410f, 0.02287828f, -0.11592834f, 0.13953014f, 0.01215536f, -0.15209846f, 
    -0.15895298f, 0.05424152f, 0.26690108f, 0.19452412f, -0.15266037f, 0.03242840f, -0.08162265f, 0.19151518f, 
    0.09653611f, -0.01150797f, 0.02412923f, -0.08350205f, 0.07554083f, -0.17374875f, -0.03277257f, 0.01310605f, 
    -0.05744878f, -0.22266258f, -0.20980054f, 0.18675794f, -0.04434867f, -0.26678872f, 0.02184475f, -0.19837919f, 
    0.02704796f, 0.18042372f, 0.02071546f, 0.06656703f, -0.06018485f, -0.00866470f, -0.03226211f, 0.07183518f, 
    -0.00854641f, -0.03245032f, -0.20569229f, 0.14145687f, 0.05149644f, -0.09645467f, -0.04608011f, 0.23414670f, 
    0.06781466f, 0.00621139f, -0.09662415f, 0.10166138f, 0.08318554f, 0.11593302f, -0.06838232f, -0.02373476f, 
    0.04760234f, -0.07885376f, -0.12878889f, 0.03397695f, 0.01252270f, 0.07600284f, -0.00362724f, 0.13161874f, 
    -0.13206118f, 0.03158524f, -0.02354700f, -0.22281623f, 0.02246609f, 0.13362302f, -0.05604577f, 0.21588047f, 
    0.10185224f, 0.04570794f, -0.06337810f, -0.09493013f, -0.06023779f, 0.26940268f, -0.11380543f, -0.29443747f, 
    0.06344002f, -0.37418717f, -0.33710191f, -0.09872556f, 0.02388083f, 0.00162321f, -0.02115841f, -0.05701933f, 
    0.04371269f, -0.08020589f, -0.09010252f, 0.02712554f, -0.36832410f, 0.06975432f, -0.12325026f, -0.10158857f, 
    -0.10134937f, -0.10979947f, 0.10828537f, 0.13914278f, -0.08101352f, -0.05656647f, 0.08089828f, 0.00751723f, 
    -0.10006568f, -0.44830716f, 0.11997299f, 0.22998744f, -0.01670383f, -0.03473479f, 0.00846052f, 0.06032476f, 
    0.01738821f, -0.07400423f, 0.04036311f, -0.03275559f, -0.37685919f, -0.02807042f, -0.01166506f, -0.25427431f, 
    0.05748665f, -0.14531887f, 0.01353827f, -0.23999818f, 0.00231916f, -0.00255812f, 0.05641034f, 0.15978813f, 
    -0.09589019f, -0.43073720f, -0.34227052f, 0.14581469f, -0.01538452f, -0.00961124f, -0.01243438f, 0.00637571f, 
    0.15518968f, -0.08337678f, 0.20516834f, 0.11461835f, 0.09397530f, -0.13085529f, -0.00223233f, 0.15459149f, 
    0.05762378f, -0.02149088f, 0.07866011f, -0.02030356f, 0.07671320f, -0.19071956f, 0.23925491f, -0.10151367f, 
    0.02967670f, -0.03704528f, -0.02333159f, 0.09524266f, -0.00043068f, -0.05274219f, -0.01528451f, -0.14879629f, 
    0.01085754f, 0.02852336f, 0.12112388f, 0.05733080f, -0.00786785f, 0.12199481f, 0.06426471f, -0.05099251f, 
    -0.05879324f, 0.06848696f, -0.10054307f, -0.30717087f, -0.15658553f, -0.18225124f, -0.10525724f, -0.10356431f, 
    -0.19995841f, -0.06199294f, 0.02459637f, -0.17354394f, 0.02230528f, 0.03059677f, 0.07828748f, -0.05137048f, 
    0.18554544f, 0.03414476f, 0.02085457f, 0.03239563f, 0.12210801f, -0.40851370f, 0.07264911f, 0.08136802f, 
    -0.17228757f, -0.03672971f, -0.01398124f, -0.01351018f, 0.18121226f, -0.00257184f, 0.08834258f, 0.09026944f, 
    0.14868517f, 0.21911563f, -0.27445334f, 0.02286963f, 0.20366414f, 0.11795570f, -0.09956393f, -0.01167777f, 
    0.00268957f, -0.04502267f, -0.10552176f, 0.31209168f, -0.17701441f, 0.26882449f, -0.06817923f, 0.03170326f, 
    0.02428439f, -0.04623068f, -0.08882979f, -0.02731970f, 0.07096464f, 0.05908233f, -0.08214303f, 0.03005653f, 
    0.32816976f, 0.18809813f, -0.07454612f, -0.01537387f, 0.12441149f, -0.04689231f, -0.01774437f, -0.07875971f, 
    0.00606656f, -0.00631760f, 0.09581269f, 0.01085752f, 0.05132897f, -0.06687527f, -0.04447073f, 0.04968847f, 
    -0.05158214f, 0.02032717f, 0.07016149f, 0.00345155f, 0.04105675f, -0.49185121f, -0.28297850f, -0.54617184f, 
    -0.47658995f, -0.26452455f, 0.01458605f, -0.08742496f, 0.06389109f, 0.01998703f, -0.04908206f, 0.03876874f, 
    -0.06369897f, 0.11063065f, 0.10351288f, -0.03001059f, 0.20714670f, -0.26471296f, 0.28047696f, 0.01146458f, 
    0.15207034f, 0.11440011f, 0.12704779f, -0.06952480f, 0.10473183f, -0.06373321f, -0.02249332f, -0.07275782f, 
    0.04382766f, -0.21042702f, 0.14520839f, 0.03610805f, 0.30864736f, -0.08184886f, 0.07026341f, 0.12934336f, 
    -0.03477845f, -0.02700537f, -0.14003940f, 0.13190454f, -0.20533976f, 0.00818140f, -0.31229469f, 0.04304600f, 
    0.03906251f, 0.06448618f, 0.18765761f, 0.03643193f, 0.11955685f, 0.05753605f, -0.15010214f, 0.02600908f, 
    -0.02325139f, -0.35155371f, -0.37354162f, 0.43141261f, 0.09217412f, 0.09296115f, 0.07872332f, 0.09394293f, 
    -0.00243708f, -0.03477099f, 0.03978852f, -0.11844012f, 0.06096492f, -0.14292346f, -0.04551462f, -0.10185404f, 
    -0.03882719f, 0.02207074f, 0.16593917f, -0.05845620f, -0.02250851f, 0.06505033f, 0.07130171f, 0.10740650f, 
    -0.09673119f, -0.13053121f, -0.07013686f, 0.02913185f, 0.01562221f, -0.00376178f, -0.00507876f, -0.00165822f, 
    0.08925865f, -0.13456735f, -0.10066918f, 0.04588246f, 0.11442722f, -0.18574394f, 0.08230058f, 0.05701438f, 
    0.11957467f, -0.03646166f, 0.04623044f, -0.02532954f, 0.08413877f, 0.02799627f, 0.00039131f, 0.02362618f, 
    -0.42050985f, 0.41663229f, 0.12262847f, -0.01097894f, 0.02658771f, -0.12569757f, 0.07840824f, 0.19049841f, 
    0.06547720f, -0.03481118f, -0.05733906f, -0.00106313f, -0.16614415f, 0.53403413f, 0.07561345f, -0.30908665f, 
    -0.04495014f, -0.05899610f, 0.03092859f, 0.10405052f, 0.07213061f, -0.13513668f, 0.04983331f, -0.00262331f, 
    0.15113272f, 0.09242788f, -0.52696347f, -0.02282800f, 0.04565815f, 0.13015999f, 0.06497037f, -0.02196758f, 
    0.11621080f, -0.09771077f, -0.01611926f, 0.01239390f, 0.17109105f, -0.23856735f, -0.02983430f, 0.28874025f, 
    -0.03032998f, 0.02347648f, 0.06364522f, 0.04100088f, -0.02212069f, 0.03823337f, -0.02207554f, -0.03906278f, 
    0.03475834f, 0.17837265f, 0.30544886f, -0.14325441f, 0.03431066f, 0.07848664f, 0.03811953f, 0.11491137f, 
    -0.00269881f, -0.03326011f, 0.09317390f, 0.01001771f, 0.17661005f, -0.08149385f, -0.23899284f, -0.15772240f, 
    0.09688119f, 0.09276055f, -0.19824167f, -0.07068298f, 0.25994402f, 0.03150817f, 0.26394555f, -0.20130534f, 
    0.00826244f, 0.14396255f, 0.07806592f, -0.08418184f, 0.16032262f, 0.17578669f, 0.17247507f, 0.07759286f, 
    0.05525120f, -0.00825432f, 0.10023862f, 0.15180425f, -0.48802036f, -0.08599258f, 0.13439626f, -0.18285054f, 
    -0.02993193f, -0.01876145f, 0.01906345f, 0.08231667f, 0.04113420f, -0.14757137f, -0.06128683f, -0.04178764f, 
    -0.06671002f, -0.17234036f, 0.00676561f, -0.16463515f, -0.04616129f, 0.01199131f, -0.09051071f, 0.02238242f, 
    0.06986329f, 0.01666134f, -0.10016845f, -0.02807152f, -0.07805941f, -0.01798495f, -0.08133668f, -0.02721250f, 
    -0.04364763f, -0.00068872f, -0.03385843f, 0.02328159f, 0.02769856f, 0.06327251f, -0.04982768f, 0.12585115f, 
    0.02108175f, -0.03175964f, -0.03350442f, -0.03749051f, 0.03938291f, -0.04134385f, -0.03674834f, -0.03620273f, 
    0.00410228f, 0.01583808f, 0.09240419f, 0.00177280f, -0.13010344f, 0.18462519f, 0.11829043f, 0.06641757f, 
    0.02750376f, 0.03260555f, -0.06052253f, -0.01332425f, -0.01004509f, 0.00072274f, 0.09248991f, 0.03870755f, 
    -0.02750468f, 0.06985865f, 0.09079605f, -0.17514497f, 0.16407849f, -0.03511019f, 0.07733443f, -0.07726492f, 
    0.07470213f, -0.00967129f, -0.01463872f, -0.00456727f, -0.08836368f, 0.27889273f, 0.07492132f, 0.30512753f, 
    -0.02617924f, -0.05564215f, 0.11502910f, 0.01989757f, 0.06294286f, -0.08815309f, -0.10233140f, 0.06399001f, 
    0.19378494f, 0.22383162f, -0.03359230f, -0.10250159f, 0.07805140f, 0.19218661f, -0.08114298f, -0.07569886f, 
    0.03819750f, 0.02467384f, 0.04747345f, 0.04927475f, -0.36720225f, -0.27209681f, -0.20764925f, 0.09294436f, 
    0.01457498f, 0.06322943f, 0.04541140f, 0.04843687f, -0.05710774f, -0.00681988f, -0.00876579f, -0.08141594f, 
    -0.05031186f, -0.04106805f, -0.03473791f, -0.11575065f, 0.02998295f, -0.02392256f, 0.06722504f, 0.14403689f, 
    0.04408194f, -0.09181465f, 0.07082286f, -0.10812337f, -0.12695064f, -0.12443293f, -0.02393478f, -0.29105276f, 
    0.06656863f, -0.01182359f, -0.03996302f, 0.28643337f, 0.14630744f, 0.08700696f, -0.10808749f, -0.21046764f, 
    -0.57737148f, -0.32000375f, -0.09708236f, -0.11506701f, -0.04206026f, -0.01922088f, -0.00278219f, 0.06630154f, 
    0.03015567f, 0.02163971f, -0.00425325f, -0.06673223f, 0.18486153f, -0.32938278f, -0.17259771f, 0.29042849f, 
    0.14377779f, -0.06264251f, -0.14578307f, 0.11415181f, -0.13872381f, 0.02359916f, 0.32153106f, -0.11312800f, 
    -0.19910033f, -0.26308540f, -0.30604595f, -0.40399638f, -0.05677596f, -0.02529059f, -0.04817460f, 0.01565871f, 
    0.00414135f, -0.01168807f, -0.00594793f, 0.00178945f, 0.09107441f, 0.06632532f, -0.16763246f, -0.14328647f, 
    0.04053415f, 0.11818086f, 0.05797002f, -0.04801597f, 0.05334919f, 0.11362161f, -0.00082583f, -0.57213980f, 
    -0.32242811f, 0.20033093f, -0.14937434f, 0.05367557f, -0.04371319f, -0.04879881f, -0.03385517f, 0.01436839f, 
    0.01045601f, -0.07773091f, -0.09334438f, -0.05367412f, -0.62618297f, 0.15848237f, -0.33733749f, 0.06926786f, 
    -0.03413735f, 0.00070173f, 0.04036878f, -0.08101476f, 0.11286870f, -0.03254968f, -0.00610019f, 0.12501965f, 
    0.09555013f, 0.15434854f, -0.03493791f, -0.01003892f, 0.11532611f, 0.05176407f, -0.08063860f, -0.05194198f, 
    -0.00694611f, -0.05603638f, 0.07694693f, 0.02508016f, 0.20605828f, 0.12731023f, 0.14304815f, 0.01403253f, 
    0.03668452f, -0.08707483f, 0.06782839f, -0.08162781f, 0.07090186f, 0.05956312f, -0.09553804f, 0.03849825f, 
    0.28572392f, -0.14895824f, -0.09380537f, 0.01944936f, -0.20695129f, -0.01255626f, 0.02515821f, 0.11071146f, 
    0.03181250f, 0.11414189f, -0.05470695f, -0.02413298f, 0.07069175f, -0.13675903f, -0.08426012f, 0.04566955f, 
    0.03990065f, -0.06431472f, 0.11426546f, -0.05184527f, 0.06635022f, 0.04541281f, 0.07509302f, -0.10188516f, 
    0.27284509f, 0.04239910f, 0.01636280f, 0.01227561f, 0.18325463f, 0.18593040f, 0.07493355f, 0.06952696f, 
    -0.02006914f, -0.02077350f, 0.00186801f, 0.01626828f, 0.32680732f, 0.05923591f, -0.27918041f, -0.34609878f, 
    0.04588101f, 0.15607317f, -0.07274418f, 0.02421631f, 0.14588508f, -0.15067780f, 0.01679529f, 0.01678561f, 
    -0.07484480f, 0.07931164f, -0.17207211f, -0.03537275f, 0.32452023f, -0.04032456f, -0.11972097f, 0.01667315f, 
    0.07050068f, 0.06786410f, -0.00878748f, 0.09613809f, 0.00293934f, 0.09903044f, 0.05159385f, -0.04133085f, 
    -0.07255135f, 0.07348476f, -0.03655891f, -0.06358567f, -0.01965979f, -0.04084023f, -0.13767944f, -0.21397735f, 
    -0.12195711f, 0.11127912f, 0.16988245f, -0.00841649f, -0.08567671f, -0.06950323f, 0.09832368f, 0.01585932f, 
    -0.01027098f, 0.06680068f, -0.00327646f, -0.00144998f, 0.57566720f, 0.18964460f, -0.21832117f, 0.15123849f, 
    0.05050140f, -0.04214447f, -0.03280880f, 0.23649746f, 0.15054145f, 0.07132658f, -0.06527588f, -0.05024842f, 
    0.12725206f, 0.11319186f, -0.02345510f, 0.05451777f, -0.02926544f, -0.03145193f, -0.00478709f, 0.04632026f, 
    0.00752053f, 0.17124304f, 0.08509683f, 0.12667102f, 0.39101216f, -0.04240967f, -0.21925016f, -0.19318734f, 
    -0.06028390f, 0.03103697f, 0.08551772f, 0.05067982f, 0.01972323f, -0.04900087f, -0.01755995f, -0.05188885f, 
    -0.05266289f, -0.16336793f, -0.10991485f, 0.47055444f, -0.00505874f, 0.22507901f, 0.08893342f, -0.19818443f, 
    0.01344689f, -0.07251253f, 0.01999895f, -0.05062322f, 0.05179812f, 0.02672565f, -0.07961393f, -0.11934573f, 
    -0.18873581f, 0.23799127f, 0.00459041f, -0.03700029f, 0.13875753f, 0.02073292f, 0.04141435f, -0.00121064f, 
    0.01124495f, -0.12274448f, 0.10457863f, 0.03759892f, 0.04806116f, 0.02457953f, -0.02825000f, 0.09398374f, 
    0.00806063f, -0.06304130f, 0.19896759f, 0.02730518f, -0.32306659f, -0.07752451f, 0.30244070f, 0.09661610f, 
    -0.01119071f, -0.05693566f, -0.00172024f, -0.07067138f, -0.14769088f, -0.10267191f, -0.07106601f, 0.11123731f, 
    0.08194199f, 0.02308531f, -0.00811652f, -0.01307022f, 0.01559746f, 0.01071112f, -0.04456502f, 0.00058710f, 
    0.05850123f, 0.09575378f, -0.03113510f, 0.10313829f, -0.22603919f, 0.07563547f, 0.18862413f, -0.31721577f, 
    0.02795622f, 0.06964681f, -0.01521414f, -0.00895741f, 0.09449943f, 0.07330246f, 0.09805800f, 0.03850771f, 
    -0.02846613f, 0.05002782f, 0.04204579f, -0.31242204f, 0.02637434f, 0.03947891f, 0.01243208f, -0.12354861f, 
    -0.01470654f, 0.07201841f, 0.09498104f, -0.14331083f, -0.75420195f, -0.67434251f, -0.12964708f, 0.42119879f, 
    -0.00125712f, -0.13478184f, -0.03077887f, -0.00046168f, -0.03868340f, 0.00375124f, 0.03839711f, -0.11576689f, 
    -0.17237386f, -0.09560747f, -0.00878650f, 0.17114899f, 0.07890172f, 0.11448222f, 0.04595163f, 0.04992856f, 
    -0.01712886f, -0.06931992f, 0.10673825f, 0.03770803f, -0.58285230f, -0.74037641f, -0.10962777f, 0.08718807f, 
    0.06056158f, -0.16333064f, -0.02916025f, -0.11216955f, -0.04228888f, 0.01207144f, -0.03791645f, -0.02680749f, 
    0.08828562f, -0.04995460f, 0.16457109f, 0.20656297f, -0.03702902f, 0.07147397f, -0.00250327f, -0.07133754f, 
    -0.00372637f, -0.06646710f, 0.06579170f, -0.00215525f, 0.03492972f, -0.01230779f, -0.04059213f, -0.12664144f, 
    0.00122274f, -0.02412921f, -0.01439373f, 0.04010158f, -0.05956877f, 0.03490302f, -0.15546632f, 0.03917895f, 
    0.11226229f, 0.07541105f, -0.08436452f, -0.03267994f, -0.02234694f, 0.04865920f, -0.11447404f, -0.01078545f, 
    0.02096356f, -0.10339390f, 0.17173016f, -0.40830511f, -0.30590585f, -0.18281049f, 0.02133480f, -0.18580428f, 
    -0.08710372f, -0.07218448f, -0.15129139f, -0.12173172f, 0.06039822f, 0.04081726f, -0.03495912f, 0.00191917f, 
    0.09697834f, 0.05436147f, -0.02451310f, -0.05544790f, 0.04628998f, -0.00034797f, -0.04935959f, 0.05389160f, 
    -0.04290940f, -0.04879366f, 0.09852510f, -0.14171897f, -0.08654769f, -0.08213080f, -0.01192918f, 0.11409822f, 
    -0.04932214f, -0.09557261f, 0.03354735f, 0.10924843f, 0.00323443f, -0.02407954f, 0.02359334f, 0.12686680f, 
    -0.09267446f, 0.07349893f, 0.07653093f, -0.39479372f, -0.17822014f, -0.01936684f, -0.04727290f, 0.10826531f, 
    0.00282010f, 0.10182100f, -0.09100341f, 0.20855525f, -0.30507797f, 0.11053034f, 0.40508598f, -0.09379225f, 
    -0.04356781f, -0.02759756f, -0.06377797f, 0.01327148f, -0.10764661f, 0.08293381f, 0.11826371f, -0.09008362f, 
    -0.15911838f, 0.06407150f, -0.32418650f, -0.08873282f, -0.14804623f, 0.07847577f, 0.03238298f, 0.12853818f, 
    0.03091794f, -0.02236326f, 0.07447412f, -0.03650221f, 0.09707803f, 0.02103531f, -0.14308861f, -0.05730879f, 
    -0.04335657f, 0.00858324f, 0.01189270f, 0.12548739f, -0.00476124f, 0.19131476f, 0.16560937f, 0.16154926f, 
    -0.27782539f, 0.12285395f, 0.40571377f, 0.31028879f, -0.04883543f, 0.06859259f, -0.09149183f, 0.15158996f, 
    -0.06072120f, 0.10069378f, 0.06311205f, 0.04766406f, -0.06262886f, -0.17738447f, -0.40274444f, 0.03997581f, 
    -0.08763839f, 0.12239234f, 0.07951337f, 0.06213300f, 0.09717979f, 0.01211549f, -0.02671787f, -0.02309708f, 
    0.12022884f, 0.06863636f, -0.25940797f, -0.06730016f, -0.00962421f, -0.04044363f, -0.03384004f, 0.26415718f, 
    0.15696828f, -0.07478400f, 0.15955272f, -0.00522823f, -0.07059635f, -0.22375473f, 0.03905623f, 0.13999632f, 
    0.13481680f, 0.01048846f, 0.11932857f, -0.03353474f, 0.02833040f, -0.06824724f, 0.01512452f, -0.04132336f, 
    -0.19959575f, -0.27276409f, -0.16826698f, -0.43946469f, 0.08253250f, 0.12806511f, 0.07517426f, -0.08462223f, 
    -0.05714002f, 0.07017113f, -0.04994480f, 0.03896772f, -0.30903631f, 0.22040679f, 0.34948775f, 0.12665522f, 
    -0.17120190f, -0.13491569f, 0.05250571f, 0.08619774f, 0.01664393f, 0.06324145f, -0.04763224f, -0.06028622f, 
    0.08198966f, -0.04982984f, 0.01393854f, -0.11117223f, 0.01360393f, -0.01466237f, 0.01075053f, -0.04224323f, 
    -0.09848533f, -0.15990630f, -0.24649835f, -0.26334518f, -0.11926651f, -0.03697795f, 0.03812685f, -0.13980913f, 
    -0.13730288f, -0.21185775f, -0.01119469f, -0.02999567f, -0.13563058f, -0.05285764f, 0.05751258f, -0.09077062f, 
    0.27374944f, -0.36256716f, -0.09213048f, 0.24404424f, 0.09602471f, 0.02667659f, 0.00216626f, -0.03868076f, 
    -0.08305498f, 0.01243013f, 0.13604350f, 0.11100428f, -0.45089716f, -0.22441533f, 0.02660454f, 0.40777886f, 
    0.08229770f, 0.08469798f, -0.16336185f, 0.00068866f, 0.03984919f, 0.12450557f, 0.10968900f, 0.15734358f, 
    0.04234409f, 0.00481518f, 0.03112308f, -0.24507128f, 0.08822118f, 0.02137533f, 0.02149547f, -0.07448667f, 
    0.05818990f, 0.08446774f, 0.00164280f, -0.10483222f, -0.08865615f, 0.02625837f, -0.04975042f, -0.08771793f, 
    -0.01393252f, 0.00214577f, 0.02142118f, 0.00342691f, -0.05399669f, 0.00584582f, -0.11957573f, 0.06433963f, 
    -0.30458507f, -0.49171942f, -0.06549509f, 0.03572425f, -0.04221836f, 0.01714727f, -0.01023009f, -0.07889752f, 
    -0.02907051f, -0.02728117f, 0.01959831f, 0.09430166f, -0.04153605f, 0.44818121f, -0.00378873f, 0.11233057f, 
    -0.10959496f, 0.00994399f, -0.13901457f, 0.05835786f, -0.10931292f, -0.11524415f, -0.04037769f, 0.11303069f, 
    -0.47754756f, -0.70257831f, -0.43603012f, -0.13816233f, -0.29948995f, -0.32235846f, -0.19144039f, -0.22920060f, 
    0.01936787f, -0.02366001f, -0.10306553f, -0.06076318f, -0.22507228f, -0.14552872f, 0.15419281f, -0.02961620f, 
    -0.04466360f, -0.04103939f, 0.01536816f, 0.08324467f, 0.09540293f, 0.19075705f, -0.01295072f, 0.10140285f, 
    -0.41198537f, 0.12175430f, 0.05806891f, 0.09730424f, -0.04327860f, 0.00040972f, -0.09940459f, 0.11724271f, 
    -0.08075108f, -0.03315876f, 0.05952034f, 0.05730157f, -0.04266729f, -0.08209005f, 0.01247998f, 0.00435820f, 
    0.04775016f, 0.01187186f, 0.05140836f, 0.00309161f, -0.08759754f, -0.07150292f, -0.12583198f, -0.07821843f, 
    0.08892410f, -0.09891538f, -0.26635149f, -0.01657597f, -0.01034275f, -0.02719250f, -0.14571169f, 0.01243992f, 
    -0.05863140f, 0.00846608f, 0.02357345f, -0.37477550f, 0.03878583f, -0.05008242f, -0.02229625f, -0.55061001f, 
    0.07681136f, 0.00527797f, 0.03225404f, 0.05683919f, 0.07107978f, -0.01867311f, -0.02762182f, -0.08786365f, 
    -0.59505725f, -0.71270120f, -0.01431966f, -0.31266409f, -0.10697407f, 0.12975143f, -0.16739525f, -0.20867200f, 
    -0.05476131f, 0.01708234f, 0.00554409f, 0.06182586f, -0.65724945f, -0.40853921f, 0.09462234f, -0.41157222f, 
    -0.07060719f, -0.04841329f, -0.06989630f, -0.23482390f, 0.03915166f, -0.02426138f, 0.12313085f, 0.02050900f, 
    -0.57094467f, -0.66938287f, 0.03137287f, -0.44117057f, 0.11231115f, -0.09135666f, -0.01779891f, -0.15893777f, 
    -0.01650814f, 0.06730689f, 0.03879667f, 0.06498291f, -0.17711236f, -0.26473898f, -0.05011092f, -0.03969881f, 
    0.03339087f, 0.09375019f, 0.12840226f, -0.21943077f, 0.03540512f, -0.07512501f, 0.05482595f, 0.01397268f, 
    -0.61998326f, -0.27767703f, -0.00622661f, -0.06741679f, 0.00482785f, 0.08508768f, -0.06682176f, -0.21905717f, 
    -0.02810168f, 0.01123749f, 0.00705019f, -0.02325054f, 0.17960800f, 0.52230918f, -0.24613763f, 0.03572676f, 
    0.06568865f, 0.04200603f, 0.04133894f, 0.07596599f, 0.07931670f, -0.01067363f, 0.27599153f, 0.05107463f, 
    -0.22581393f, 0.25801942f, 0.30384809f, 0.15951094f, -0.01531292f, 0.02036490f, -0.08548263f, 0.07739833f, 
    -0.06643741f, 0.02970660f, 0.06049974f, 0.10998265f, 0.07671690f, -0.02092398f, 0.16745444f, 0.03221595f, 
    0.01572231f, 0.09707600f, -0.00336797f, -0.12274393f, 0.10147807f, -0.11753209f, -0.00552318f, 0.02120503f, 
    -0.24882972f, 0.41643411f, -0.11400950f, 0.02670474f, -0.03221413f, -0.05417145f, 0.03153066f, 0.11230965f, 
    0.13499369f, 0.12192343f, 0.04038728f, 0.03609908f, -0.06183384f, 0.12604821f, -0.06395126f, -0.13246301f, 
    0.00623799f, -0.00098611f, 0.05037553f, 0.02535983f, 0.03681852f, 0.09988463f, 0.08535366f, 0.05851415f, 
    -0.02986273f, -0.02345692f, -0.04395007f, -0.07967985f, -0.04141872f, -0.00488269f, 0.03357440f, 0.05268573f, 
    0.01928464f, 0.05802216f, 0.11719009f, 0.27659991f, -0.01364076f, 0.02045888f, 0.14870967f, 0.28086400f, 
    -0.02604617f, -0.04332794f, -0.01093344f, 0.00381315f, 0.01878558f, 0.01018039f, 0.16401619f, -0.05950741f, 
    -0.21942711f, -0.80975765f, -0.42870900f, -0.22107677f, 0.09460250f, 0.06612112f, 0.14174959f, -0.45093867f, 
    0.04730430f, -0.08333188f, -0.08935902f, -0.03736623f, -0.34418342f, 0.12254794f, 0.15076767f, -0.27906561f, 
    -0.04340285f, -0.05813378f, -0.21580791f, -0.10008025f, -0.05970213f, 0.01457385f, -0.03079524f, 0.05076553f, 
    -0.16916563f, -0.42003793f, 0.03764296f, 0.24845755f, 0.18156111f, 0.19529787f, -0.00289013f, -0.05492422f, 
    0.05322883f, -0.16471542f, 0.08005422f, 0.08841386f, 0.32743621f, 0.22503969f, -0.04316734f, -0.17275158f, 
    -0.01575707f, 0.05167232f, -0.01973448f, 0.04066119f, -0.02286052f, -0.19876191f, 0.12145803f, -0.12219596f, 
    -0.64913368f, -0.21769615f, -0.03235571f, -0.26644644f, -0.21108337f, -0.21774980f, -0.21547696f, -0.29066995f, 
    0.02533822f, -0.01891389f, -0.01075451f, -0.04347907f, -0.04922504f, -0.07011265f, 0.05115136f, -0.32454437f, 
    0.04792896f, 0.03169592f, 0.00142893f, 0.01501123f, -0.00412551f, 0.01183300f, -0.08310398f, -0.12441480f, 
    0.02482679f, 0.02002956f, -0.03481207f, -0.21071294f, 0.05905970f, 0.02929640f, 0.04515081f, 0.06025565f, 
    -0.03956262f, 0.01431800f, -0.06786384f, -0.02774296f, 0.03530605f, -0.26008931f, -0.01340911f, 0.06448766f, 
    0.08438554f, 0.17311615f, 0.14688028f, -0.25625417f, 0.05911500f, 0.05486070f, 0.03541208f, 0.01345033f, 
    0.03972415f, -0.26293966f, -0.18695834f, -0.15326509f, -0.08119434f, -0.07205249f, 0.00237831f, 0.04903257f, 
    0.11125580f, -0.01179255f, 0.00061023f, -0.02140928f, -0.22333117f, -0.15549128f, -0.11896591f, -0.00440610f, 
    -0.02802196f, -0.01095994f, 0.01888001f, -0.00288269f, -0.15062886f, 0.03173722f, -0.04292483f, 0.02422695f, 
    0.00341277f, -0.04975097f, 0.02383913f, 0.07065154f, -0.01434528f, 0.00828827f, 0.00998682f, 0.01786577f, 
    -0.01341619f, -0.05776450f, 0.05157387f, -0.01884284f, -0.07997983f, 0.11073668f, -0.04753602f, 0.00319975f, 
    -0.02901004f, -0.06353769f, -0.04462085f, 0.01969005f, -0.00169628f, -0.04793864f, -0.00400332f, 0.06895175f, 
    0.33700758f, -0.22460322f, 0.07007163f, -0.01785282f, -0.09096558f, 0.15601322f, -0.07069672f, -0.00893207f, 
    0.01772819f, 0.00633368f, -0.02499243f, 0.03394879f, -0.14082399f, 0.01291495f, 0.04735427f, 0.05077066f, 
    -0.02734973f, 0.06837650f, 0.24945824f, -0.09396779f, -0.04875594f, -0.11382341f, -0.15722920f, 0.14028132f, 
    0.07104464f, -0.05859135f, -0.04623745f, -0.14753090f, 0.03024727f, -0.03996838f, 0.04715333f, -0.03105685f, 
    0.02992572f, 0.01249897f, -0.01304973f, -0.22231284f, 0.21262653f, 0.09417210f, -0.11168856f, -0.16210894f, 
    0.00906676f, 0.01836013f, -0.14983140f, 0.02447983f, -0.01495383f, 0.05234878f, 0.01441130f, -0.00424649f, 
    0.02536064f, 0.07788602f, 0.03554097f, 0.02133232f, -0.03294046f, 0.00351640f, 0.00701004f, -0.02800773f, 
    -0.12630208f, -0.12130108f, 0.06312286f, -0.15761769f, 0.06985411f, 0.16761889f, -0.23568341f, 0.24123314f, 
    -0.06534515f, -0.03480884f, 0.02155053f, -0.09408192f, -0.07129622f, 0.09039110f, 0.00059547f, -0.03195944f, 
    -0.05369542f, 0.02714186f, -0.06085246f, 0.16698197f, 0.00237227f, 0.03931540f, 0.04655421f, -0.04861964f, 
    -0.00657328f, -0.05500093f, -0.09095584f, -0.02043837f, -0.28992778f, -0.40925440f, -0.38736296f, -0.47628453f, 
    -0.05992001f, 0.14587758f, -0.14016344f, 0.11010611f, 0.12615739f, 0.02115414f, -0.10676093f, -0.04017921f, 
    0.05733943f, -0.07431020f, -0.00220498f, -0.17223941f, 0.00702485f, -0.03928588f, -0.01994226f, 0.01026346f, 
    -0.01439546f, 0.03608029f, 0.03549214f, -0.13330545f, -0.30623975f, -0.31977934f, -0.31399262f, -0.50783384f, 
    -0.00603278f, 0.12407071f, 0.01385829f, 0.15969589f, 0.06935403f, -0.02144238f, -0.02534088f, 0.03646376f, 
    0.02217595f, 0.03904465f, 0.02948073f, 0.07068565f, 0.03280253f, -0.06398517f, -0.03232875f, -0.04218085f, 
    -0.09511860f, -0.00854749f, -0.15322423f, 0.03249970f, -0.00235401f, -0.01207906f, 0.14203081f, -0.13831758f, 
    0.05610270f, 0.00927487f, -0.01202598f, -0.04842365f, 0.08010463f, -0.11358096f, -0.05383645f, -0.10217471f, 
    0.04900080f, -0.00895375f, 0.08138721f, -0.06284721f, -0.01498186f, 0.03449048f, -0.05937901f, -0.04800744f, 
    0.02564655f, 0.06297443f, -0.09154677f, -0.06931434f, -0.26174492f, -0.32360160f, -0.12975703f, 0.22531900f, 
    0.11723346f, 0.00414766f, 0.04104783f, 0.12110345f, 0.08583206f, -0.04830888f, 0.07974816f, -0.06485942f, 
    0.01608733f, 0.05066235f, -0.03862375f, 0.01170833f, -0.07263790f, -0.01918274f, 0.03914388f, -0.01710265f, 
    0.00581628f, -0.04253527f, -0.13434868f, -0.08849477f, 0.20217349f, -0.15719303f, -0.08774430f, -0.15730394f, 
    0.04815616f, 0.04877677f, -0.01193437f, 0.01661577f, 0.01877735f, 0.05421672f, 0.02570455f, -0.12106885f, 
    -0.28174031f, 0.21795397f, -0.17586195f, 0.19249459f, -0.01255014f, 0.15980752f, 0.14995182f, 0.02148700f, 
    0.00987697f, -0.00989135f, 0.02274920f, 0.01774654f, 0.16285168f, 0.15533087f, -0.24168266f, -0.08538841f, 
    0.01539595f, 0.01430427f, 0.03499236f, -0.04304777f, -0.01585689f, 0.10468421f, 0.10564728f, 0.00194247f, 
    -0.26923937f, 0.04322229f, 0.12039252f, 0.06868066f, 0.05756303f, 0.01687075f, 0.05248761f, -0.05360948f, 
    0.03955379f, -0.02399338f, 0.03531156f, 0.03759563f, -0.03423575f, -0.11806875f, -0.04617723f, 0.06922500f, 
    -0.00749329f, -0.01651995f, 0.00831092f, -0.03925718f, 0.09305115f, 0.03021004f, 0.06533947f, 0.03049159f, 
    0.41255033f, -0.45185372f, -0.18230622f, -0.27970678f, -0.15676966f, -0.11570306f, -0.14659922f, 0.10988985f, 
    0.00293301f, -0.02332810f, 0.06274623f, -0.02570348f, -0.18587312f, -0.66272944f, 0.19288820f, -0.05445486f, 
    -0.11188909f, 0.06601237f, -0.07114066f, -0.05015702f, 0.04404745f, 0.00774331f, -0.05020583f, -0.01391441f, 
    0.20889983f, -0.16525368f, 0.01827384f, -0.09554401f, 0.12786195f, -0.09029974f, -0.00045819f, -0.14825866f, 
    -0.11021292f, 0.12160351f, -0.07803766f, -0.09679870f, -0.10910442f, 0.16630477f, 0.05587678f, -0.09635972f, 
    -0.17060240f, -0.01237367f, 0.10306534f, 0.13544659f, -0.01844935f, -0.00798466f, 0.03572602f, -0.03627761f, 
    -0.11532354f, 0.09861331f, -0.19562000f, 0.00246196f, -0.01752860f, -0.06661447f, -0.00454873f, -0.05885488f, 
    0.07650567f, 0.02240593f, 0.06145801f, -0.05193720f, 0.11832663f, -0.21540008f, -0.09136472f, -0.16131204f, 
    -0.03075791f, -0.15514839f, 0.12298297f, 0.05188535f, 0.05873905f, -0.02000604f, 0.04352518f, 0.03391861f, 
    0.05073797f, 0.08188275f, 0.02195184f, -0.03460016f, -0.01590170f, -0.02412374f, -0.00978649f, -0.01625811f, 
    0.01837538f, -0.13911167f, -0.05252701f, -0.05900117f, 0.44078726f, 0.22344396f, -0.03959844f, 0.03439924f, 
    0.09118993f, 0.07499987f, 0.00900006f, -0.08445247f, -0.08845044f, 0.08344473f, 0.06122344f, -0.01585854f, 
    0.17145595f, -0.36893842f, 0.19789650f, -0.01732242f, -0.05192968f, -0.07135769f, -0.13984776f, 0.11381415f, 
    -0.04586954f, -0.02947053f, -0.02877455f, -0.20471607f, -0.03446805f, -0.07556571f, 0.43691495f, 0.00065388f, 
    0.01135384f, -0.01747692f, 0.01017716f, -0.00329813f, 0.07564004f, -0.08032987f, 0.04087944f, -0.15655357f, 
    -0.18361241f, 0.08924253f, -0.02968953f, -0.02517569f, 0.04425117f, 0.01412234f, 0.04185365f, -0.01375578f, 
    0.01922030f, 0.01182198f, 0.02201034f, -0.05889593f, 0.05598094f, 0.01335818f, -0.08520942f, -0.12171359f, 
    -0.02714909f, -0.02587131f, -0.02784353f, 0.00058219f, -0.00729317f, 0.04526778f, 0.01122200f, -0.04627425f, 
    -0.15417998f, -0.33185270f, 0.19699536f, -0.16172025f, -0.05706007f, -0.01602583f, -0.03326104f, 0.04176269f, 
    -0.00001461f, -0.06872217f, 0.02898873f, -0.06194767f, -0.15157983f, 0.09222757f, -0.24091674f, 0.11679412f, 
    0.02306696f, -0.05469234f, 0.08108877f, 0.01630122f, -0.13182382f, 0.03453669f, -0.01567711f, 0.02774665f, 
    -0.53679675f, -0.34181398f, 0.00105815f, -0.00473233f, 0.04781209f, -0.33073479f, -0.06025381f, 0.04335075f, 
    0.06841908f, -0.01318534f, -0.01791964f, 0.02285026f, 0.41314876f, -0.59100282f, -0.13028857f, -0.39170989f, 
    -0.06968306f, -0.09295392f, -0.12382399f, 0.04629822f, 0.16628265f, 0.07448205f, 0.03918246f, 0.02508480f, 
    0.23016760f, -0.33341157f, -0.28934982f, -0.28587481f, 0.01571875f, -0.04547324f, -0.05499112f, -0.00877916f, 
    0.07954895f, 0.12913778f, 0.02157073f, 0.05687741f, -0.03590136f, 0.09251875f, 0.03046460f, -0.06477968f, 
    -0.05719830f, -0.00678322f, 0.00025118f, -0.01064904f, -0.00216586f, 0.04758492f, -0.04489502f, -0.05351915f, 
    -0.03335219f, -0.07072100f, 0.01395542f, 0.03711519f, 0.00612868f, -0.09479830f, 0.02195478f, -0.03778099f, 
    0.03979994f, 0.02985364f, -0.07401212f, -0.06486982f, -0.06294902f, 0.04106586f, -0.23791195f, 0.44774207f, 
    -0.04030690f, 0.02709912f, -0.00174107f, -0.10688522f, -0.00991796f, -0.15125149f, 0.06953298f, -0.06252922f, 
    0.09698435f, -0.37043989f, -0.22180611f, -0.12252689f, -0.00655139f, 0.11534271f, 0.01103648f, 0.09796353f, 
    0.01619182f, -0.05980416f, -0.02719703f, 0.00454321f, -0.35727188f, 0.26071608f, -0.49464810f, 0.44881386f, 
    -0.19157161f, 0.01129935f, 0.03244267f, 0.05596655f, -0.10077011f, -0.06189159f, -0.00942691f, -0.04129087f, 
    -0.22412439f, 0.28471321f, 0.43549839f, 0.23088792f, -0.05677160f, -0.06801611f, -0.01832027f, -0.04828226f, 
    -0.03279673f, -0.09537462f, -0.06123566f, -0.05353004f, 0.05262665f, 0.16341886f, -0.09743584f, -0.04461605f, 
    0.01453759f, -0.08761594f, -0.02124653f, 0.01346609f, 0.04850486f, 0.04068207f, 0.07851299f, 0.02687459f, 
    0.04058930f, -0.23661102f, -0.33360520f, -0.20366886f, 0.04459898f, 0.08766463f, 0.05756898f, 0.02974270f, 
    0.04450702f, 0.07511023f, 0.01851422f, 0.00119720f, -0.08744400f, -0.36187580f, 0.32990563f, -0.10475105f, 
    -0.08958722f, -0.00816115f, 0.01587430f, -0.01630393f, -0.14799300f, 0.02934746f, 0.03874616f, -0.02754837f, 
    0.42725006f, -0.29220250f, -0.16310124f, -0.21166807f, -0.04336113f, 0.02109646f, -0.03264828f, -0.02568739f, 
    0.07071635f, -0.08236399f, 0.06638002f, 0.01887632f, -0.00533265f, 0.16351466f, -0.04918691f, -0.00966633f, 
    -0.03770296f, -0.04943077f, -0.00195938f, -0.01944934f, -0.02766418f, 0.03283596f, -0.07606722f, -0.10266596f, 
    -0.33882275f, -0.06863724f, 0.02621677f, 0.21985678f, 0.04017567f, 0.03690408f, 0.23322709f, -0.02262738f, 
    -0.09407526f, 0.02324866f, -0.02923743f, 0.02184659f, -0.14215232f, 0.19553003f, -0.27926487f, 0.23253892f, 
    -0.06958804f, -0.03748000f, 0.04623924f, 0.04073505f, 0.05469970f, 0.05411997f, 0.05473065f, 0.00438594f, 
    0.22992107f, -0.19026870f, -0.12401163f, -0.00407343f, 0.05242563f, 0.01984925f, -0.02323955f, -0.08118299f, 
    0.02634266f, 0.03650377f, -0.04860582f, 0.01170434f, 0.34697703f, -0.00509740f, -0.20322259f, -0.21899232f, 
    0.05588684f, 0.04434921f, 0.06225459f, -0.01772434f, -0.04937927f, -0.17110732f, -0.01524486f, -0.10355537f, 
    -0.70445383f, 0.19392546f, 0.05983857f, 0.16484857f, 0.05759896f, -0.07450513f, 0.02121256f, 0.00553782f, 
    0.01105855f, -0.02070946f, 0.01197928f, -0.07652529f, -0.16996898f, -0.25010070f, 0.00856026f, 0.06354272f, 
    0.16594437f, 0.02939044f, 0.09868992f, 0.09153847f, -0.05555381f, -0.04438384f, 0.02644213f, -0.00752842f, 
    -0.10671113f, -0.05544991f, 0.12213683f, -0.13938065f, 0.01430455f, 0.10686857f, -0.02241890f, 0.05807424f, 
    -0.05238509f, 0.07483809f, 0.01998151f, -0.10308523f, -0.07685837f, 0.04274853f, 0.00756737f, 0.07124642f, 
    0.02029286f, -0.02539630f, 0.05284957f, -0.01204319f, 0.04566748f, -0.08742613f, 0.04941568f, -0.20754772f, 
    -0.41964629f, -0.32687652f, -0.28345412f, 0.14657739f, 0.08385293f, -0.05400446f, 0.00621621f, 0.10948623f, 
    0.01798336f, 0.03265761f, 0.05375896f, 0.05711492f, -0.10020689f, 0.16121025f, 0.06421553f, -0.05721845f, 
    0.05103120f, 0.03339340f, 0.03416497f, -0.02909538f, 0.04556098f, -0.05161662f, 0.06085461f, -0.02748876f, 
    -0.14981055f, 0.17855766f, -0.04760662f, 0.11855494f, 0.08721372f, 0.10822579f, 0.09254926f, 0.03701748f, 
    0.02630858f, 0.02656857f, -0.02518894f, -0.00630340f, -0.08724266f, -0.01485344f, 0.07259187f, -0.18136205f, 
    -0.04330223f, -0.09179424f, 0.08608750f, 0.08333481f, 0.04719336f, 0.08243056f, 0.10726005f, 0.09300352f, 
    0.02625870f, -0.14558813f, -0.09610751f, -0.05025982f, 0.05119657f, 0.09224955f, 0.06974112f, 0.08974528f, 
    -0.19640788f, -0.23556088f, -0.08641110f, -0.41350147f, -0.34639612f, -0.23771362f, -0.10912909f, 0.14051111f, 
    0.08438421f, 0.05432247f, 0.08428239f, 0.13760146f, -0.12495623f, -0.06029912f, -0.04566589f, -0.02003571f, 
    -0.21496974f, 0.00975302f, -0.00366986f, 0.07724831f, 0.00328548f, 0.01965377f, -0.02651406f, -0.02412133f, 
    -0.11360710f, 0.07781900f, -0.10450692f, -0.27814651f, -0.24744639f, -0.06143346f, 0.09161565f, 0.05152445f, 
    0.06725509f, -0.06402759f, -0.25084913f, -0.01521345f, -0.08592208f, -0.05200871f, 0.01765570f, -0.12537995f, 
    0.32231644f, 0.09703282f, 0.06812666f, -0.10485714f, 0.17169385f, -0.09899600f, 0.02976287f, 0.05508791f, 
    -0.00234289f, 0.06186468f, -0.02626844f, -0.02037738f, -0.10090132f, -0.05385880f, -0.00044967f, 0.17443123f, 
    0.05464580f, 0.04238574f, 0.08868970f, -0.18059349f, -0.05352092f, -0.11833646f, 0.01533037f, -0.25023988f, 
    0.17639917f, 0.02858010f, 0.04059207f, -0.09277605f, -0.07817464f, -0.03535039f, -0.01140618f, -0.00678076f, 
    0.02213266f, 0.01432783f, 0.10705464f, 0.09993652f, -0.01124302f, -0.11984468f, -0.13198908f, -0.22010015f, 
    0.00210378f, 0.03259140f, 0.06504745f, 0.03116686f, 0.08882334f, 0.01379499f, 0.05916313f, 0.05839422f, 
    -0.12957186f, 0.00634277f, 0.00254850f, 0.01055508f, -0.05502429f, -0.01915757f, -0.03317254f, 0.02997520f, 
    -0.05384597f, -0.00202962f, -0.11998411f, -0.05647555f, 0.19004637f, -0.11442293f, -0.16137247f, -0.16873677f, 
    0.17181505f, 0.14041676f, 0.11971686f, 0.16068500f, 0.05483141f, 0.11364564f, 0.15938266f, 0.15516481f, 
    -0.50393009f, 0.04322635f, 0.13541314f, 0.08340523f, -0.03158161f, -0.01414710f, -0.05522232f, -0.08928140f, 
    -0.00878746f, 0.10851797f, 0.02194912f, 0.16072838f, -0.51776606f, -0.49838963f, -0.46145651f, 0.12009467f, 
    0.23322524f, 0.12607810f, -0.04408142f, 0.07512394f, -0.06255818f, -0.03916150f, -0.08625943f, -0.02562032f, 
    0.17802230f, 0.17157590f, 0.11304075f, -0.21354133f, -0.04073779f, -0.00136031f, 0.03581635f, -0.03759881f, 
    0.03161637f, -0.03887565f, -0.01753768f, -0.00096716f, -0.13205150f, -0.40792599f, -0.44180524f, 0.19073984f, 
    0.04635035f, -0.07671464f, 0.12589224f, -0.07136241f, 0.00692113f, -0.02209860f, 0.06281561f, 0.07550165f, 
    0.04276492f, 0.09287153f, 0.14662853f, 0.09469625f, -0.09599623f, 0.07030262f, 0.04249234f, 0.00139503f, 
    -0.05510860f, -0.09444887f, 0.08212955f, -0.08702558f, -0.03814661f, 0.01438346f, -0.21300904f, -0.06727149f, 
    0.00043740f, -0.03042129f, -0.06892190f, -0.10642176f, -0.00343980f, -0.03507955f, -0.17764993f, -0.07456910f, 
    0.14743437f, 0.13819526f, 0.03120879f, -0.17405298f, 0.06064114f, -0.02941791f, 0.07424410f, -0.03494151f, 
    0.07281066f, -0.06474570f, 0.10509066f, 0.06936096f, -0.07749032f, -0.13805319f, -0.16673945f, -0.12276991f, 
    0.04964272f, 0.00043037f, 0.11682060f, 0.09886833f, -0.07262570f, -0.10763566f, -0.06915177f, -0.11176486f, 
    -0.01789575f, 0.12372702f, -0.03716517f, -0.06201559f, 0.00509996f, -0.04273206f, -0.01837143f, 0.02141395f, 
    0.02047640f, 0.06660987f, 0.05447563f, 0.09095129f, 0.07750985f, 0.07852896f, -0.08367342f, 0.00592673f, 
    0.17266028f, -0.04001848f, -0.04669956f, -0.04708966f, 0.15037119f, 0.10574587f, 0.14331141f, 0.29482529f, 
    -0.52216065f, 0.04005007f, 0.13431162f, 0.19637871f, 0.11130381f, -0.07723193f, -0.08040423f, 0.00041488f, 
    0.12506719f, 0.03384539f, 0.02166796f, 0.10310499f, -0.05590325f, -0.20188504f, -0.16005893f, -0.22757961f, 
    -0.10113986f, 0.06582677f, 0.02069912f, 0.06775650f, 0.07750037f, 0.03162829f, 0.01022585f, 0.03610184f, 
    -0.02910298f, -0.06084546f, 0.07028101f, 0.02727810f, 0.03004648f, 0.04067736f, 0.09993750f, 0.00380265f, 
    -0.02002130f, -0.01326070f, -0.02201527f, 0.01316508f, -0.06729348f, -0.01202727f, 0.05558112f, 0.01193246f, 
    0.04313820f, -0.01675749f, -0.00099343f, 0.06534209f, -0.19152629f, -0.02841881f, -0.11989152f, -0.47110012f, 
    -0.15124039f, -0.18517837f, -0.15264592f, 0.16278517f, 0.06908513f, 0.12544394f, 0.10652024f, 0.03153959f, 
    0.04715112f, -0.00636050f, -0.03479737f, -0.01734482f, 0.72436577f, -0.08141602f, 0.07588972f, -0.20311417f, 
    0.21796903f, 0.06559732f, 0.04360643f, -0.14768080f, 0.00779813f, 0.10878342f, 0.03972789f, -0.06621418f, 
    0.42695996f, -0.02830407f, -0.19956611f, -0.03585790f, 0.19959508f, -0.02543411f, 0.09766342f, -0.14080290f, 
    0.14356269f, -0.02443501f, 0.10481177f, -0.00527949f, -0.10843644f, -0.07534005f, 0.14719948f, -0.05203822f, 
    -0.06384593f, -0.03294976f, -0.08120586f, 0.02290518f, -0.08846723f, 0.07343128f, -0.00990995f, 0.09009629f, 
    -0.19916266f, 0.27474314f, -0.03106550f, 0.13664249f, -0.05151449f, 0.01790581f, -0.04791817f, -0.00218262f, 
    -0.11521661f, 0.00400206f, -0.00339179f, -0.00930836f, 0.00538475f, -0.15066268f, -0.17678717f, 0.08431177f, 
    0.01492093f, -0.01300260f, 0.09227249f, 0.06283410f, 0.01375192f, 0.02127213f, 0.01340421f, -0.00322538f, 
    -0.20512743f, 0.00657999f, -0.02661660f, -0.05875038f, -0.00203129f, -0.00545011f, 0.01425529f, -0.01227412f, 
    -0.03853833f, -0.05720409f, 0.05086652f, 0.09197281f, 0.21276625f, -0.19941957f, -0.45169118f, -0.19786814f, 
    0.13065268f, -0.00185485f, 0.05940876f, -0.10900410f, 0.06793986f, -0.00307844f, 0.03657930f, 0.06752829f, 
    0.33467126f, 0.12717456f, -0.20818937f, -0.32231763f, -0.08261871f, -0.07733519f, 0.10338698f, -0.04809149f, 
    -0.01797181f, 0.04370007f, 0.09132712f, 0.14429861f, -0.04793391f, -0.28120798f, -0.03562377f, 0.04367661f, 
    -0.04584428f, 0.02920655f, 0.10225388f, -0.07342208f, -0.08546786f, 0.15516973f, 0.02821646f, -0.00205499f, 
    -0.30921778f, 0.02933821f, 0.02842863f, 0.03102838f, -0.11103267f, -0.08715641f, -0.03465537f, 0.00303455f, 
    -0.06906295f, -0.02702421f, -0.03032637f, -0.02326663f, -0.04168514f, 0.11441391f, 0.10064851f, 0.10432954f, 
    -0.04554964f, -0.02209936f, -0.00827034f, -0.11911283f, -0.08729283f, -0.06569201f, 0.06513140f, -0.07963680f, 
    0.17765063f, 0.05049779f, -0.07702370f, -0.25632346f, -0.06968849f, -0.16117936f, -0.01245100f, -0.08705827f, 
    0.04084277f, 0.00083587f, -0.08713811f, 0.03592215f, -0.38473034f, -0.11967935f, 0.03056313f, 0.16304766f, 
    -0.09017306f, 0.10682476f, 0.09986852f, 0.00192707f, 0.14541283f, 0.01028213f, 0.10210362f, 0.11533858f, 
    -0.19298252f, -0.30788931f, -0.14299119f, 0.08429983f, -0.04949320f, -0.04693031f, -0.00952378f, -0.12086229f, 
    0.03627342f, 0.05102301f, 0.03413795f, 0.05689374f, -0.26188335f, -0.15544124f, -0.02686069f, -0.01108626f, 
    0.06587293f, 0.04791889f, 0.05550442f, 0.01736221f, -0.06674968f, 0.05262186f, -0.09235973f, -0.39911518f, 
    -0.35752726f, -0.49030542f, -0.34075454f, -0.13636342f, 0.12270264f, 0.19155508f, 0.19962271f, 0.06969120f, 
    0.02912953f, 0.02877273f, 0.05823034f, -0.00688577f, -0.06171015f, -0.01471765f, -0.01258719f, -0.12074117f, 
    -0.07372399f, -0.06417511f, -0.01225183f, -0.00441194f, 0.09817087f, 0.02456872f, 0.02073626f, 0.07205036f, 
    0.03208074f, 0.06405281f, -0.05704213f, -0.03952024f, -0.00837660f, -0.02880245f, 0.03840813f, -0.09642951f, 
    0.06978509f, 0.07911682f, 0.03559697f, 0.13893901f, 0.29971424f, 0.11519454f, 0.04085862f, 0.00369481f, 
    0.23769042f, -0.03114196f, 0.05008404f, 0.09261773f, -0.01665943f, 0.13498892f, 0.07086521f, 0.14679277f, 
    0.08304054f, -0.39848751f, -0.51558208f, -0.20600651f, -0.11598127f, -0.10601094f, 0.07087614f, 0.08698668f, 
    -0.08196951f, -0.03684485f, -0.04908173f, -0.08300302f, 0.12662525f, 0.07146245f, -0.23176531f, -0.29164779f, 
    0.15455329f, -0.05057800f, 0.01629319f, 0.09831531f, 0.12838247f, 0.10070035f, 0.10424867f, 0.04947693f, 
    -0.30136150f, -0.33598331f, -0.27987781f, -0.26467410f, -0.00440807f, -0.02215056f, 0.04764683f, 0.00818059f, 
    0.05614181f, 0.00295819f, 0.05557853f, 0.02883726f, -0.43542504f, 0.07473476f, 0.20220171f, -0.10739120f, 
    -0.07706074f, -0.08943204f, -0.16941835f, -0.02859216f, -0.13701673f, -0.07143116f, -0.08372707f, -0.07003070f, 
    -0.35357001f, -0.42123082f, -0.49096590f, -0.11996665f, 0.17887788f, 0.02398639f, -0.06170113f, -0.01178795f, 
    -0.01598070f, -0.02489507f, -0.06856214f, -0.06351309f, 0.04030843f, -0.33933261f, 0.15647580f, -0.01661653f, 
    0.08514972f, 0.09137542f, 0.04016633f, 0.00135026f, 0.06113966f, 0.04907362f, 0.04502429f, 0.07361001f, 
    -0.26580119f, -0.30634490f, -0.24735004f, -0.06920081f, 0.03046179f, 0.04983533f, 0.10762059f, 0.06131135f, 
    0.10201418f, 0.09938134f, -0.10692304f, -0.07201433f, -0.08467021f, 0.06057956f, -0.01486226f, -0.02356286f, 
    -0.06168434f, 0.03170955f, 0.01558923f, -0.04208219f, -0.02403935f, -0.11472578f, -0.06506307f, -0.10621431f, 
    -0.22132272f, -0.38005862f, 0.19004619f, 0.14293048f, -0.10499388f, 0.03223582f, -0.05554903f, -0.12864824f, 
    0.07015312f, 0.00123280f, -0.00585825f, 0.16729280f, -0.13845241f, 0.01000543f, -0.05750876f, 0.14393698f, 
    0.04174566f, 0.08970390f, -0.01562963f, 0.02227529f, -0.10291627f, -0.03648246f, -0.10972079f, -0.18458228f, 
    -0.05673824f, -0.02598715f, -0.03045930f, -0.24586561f, -0.04513460f, 0.05229959f, -0.08743022f, -0.03952594f, 
    0.08398296f, -0.00758408f, 0.11947365f, -0.05886073f, -0.05315559f, -0.01428812f, 0.05973959f, 0.08174576f, 
    -0.13710976f, 0.09165027f, 0.04208440f, -0.02975202f, -0.01373959f, 0.07883988f, 0.04731971f, -0.04243898f, 
    -0.07980414f, -0.04520072f, -0.02571760f, 0.13378219f, -0.09268720f, 0.04865612f, -0.07608131f, -0.04117507f, 
    -0.00285014f, 0.07200377f, 0.05693633f, 0.04859382f, 0.34342250f, -0.21616110f, -0.51463652f, -0.11744171f, 
    -0.12605849f, 0.10952377f, 0.01465501f, -0.14117652f, 0.13846689f, 0.16506042f, 0.06910893f, 0.05930445f, 
    -0.02948315f, 0.12384344f, -0.02969814f, -0.23145531f, -0.25959790f, -0.04421531f, -0.10237567f, -0.04085031f, 
    -0.00421067f, -0.12699060f, -0.05338799f, 0.09094288f, -0.24138442f, 0.01322654f, 0.14798985f, 0.05426934f, 
    0.02386979f, 0.06944723f, -0.07048115f, 0.04606199f, -0.23117580f, 0.09597153f, 0.05850350f, 0.16244131f, 
    0.11988187f, -0.31958601f, -0.43314424f, 0.04622283f, -0.28295049f, 0.12089674f, -0.00326279f, -0.01760366f, 
    -0.01319975f, -0.02185047f, -0.00664993f, -0.00973362f, -0.64691174f, 0.06382043f, 0.14501727f, 0.27582666f, 
    -0.12709129f, -0.03505114f, -0.06513456f, -0.03837667f, 0.04340705f, 0.00627037f, 0.02703486f, 0.06585734f, 
    -0.29460266f, -0.06965873f, 0.05899075f, 0.14908683f, 0.08961536f, 0.03168198f, -0.02207532f, -0.03444567f, 
    0.00668804f, 0.06336401f, 0.06521854f, 0.05207306f, 0.08064758f, 0.07407618f, -0.09545136f, -0.11385810f, 
    0.00796467f, 0.09852354f, -0.00823273f, -0.07333311f, -0.06615439f, -0.08580178f, -0.03418420f, -0.12585683f, 
    0.03971555f, -0.05349634f, 0.17946416f, -0.01905608f, -0.04779193f, -0.03099288f, -0.11015635f, -0.00965207f, 
    0.14812474f, 0.06927096f, 0.01283560f, 0.05689808f, -0.06487133f, 0.38502640f, 0.64343101f, -0.60505438f, 
    0.02592673f, -0.17277813f, 0.05464999f, -0.21701340f, -0.07888650f, 0.10479955f, 0.13749211f, 0.15103884f, 
    0.09645285f, 0.09150909f, 0.02810880f, -0.15460865f, -0.05230588f, -0.06989604f, 0.08387940f, 0.02835447f, 
    0.06948149f, 0.02710803f, 0.14803214f, 0.13647844f, 0.07621086f, 0.40643358f, -0.29220161f, -0.11431909f, 
    -0.05683980f, -0.10014100f, 0.09708647f, 0.03290761f, 0.06915518f, -0.08234900f, -0.09829275f, -0.02190685f, 
    -0.20671055f, -0.55087548f, -0.21442965f, -0.05353240f, -0.17431755f, 0.03318771f, -0.21378994f, -0.08070499f, 
    0.15406010f, -0.07311364f, 0.07210886f, 0.01869204f, -0.02630225f, 0.04541531f, -0.27315769f, -0.10634440f, 
    0.13510579f, -0.19059403f, 0.03993639f, 0.03891252f, -0.04167927f, 0.13580337f, 0.08231775f, 0.13785611f, 
    -0.20094977f, 0.06509314f, 0.08476188f, 0.14570878f, 0.06285357f, 0.05095020f, -0.11274471f, -0.01658046f, 
    -0.02620349f, 0.00666986f, 0.05267832f, -0.07075905f, -0.00110386f, 0.07383686f, 0.04420407f, 0.23039325f, 
    0.09024943f, -0.00568574f, -0.13446015f, -0.02527204f, 0.01031701f, -0.10257772f, 0.04512920f, 0.02426731f, 
    0.01225953f, -0.08954160f, 0.01735333f, 0.02163945f, 0.00927153f, 0.04064957f, 0.01304779f, 0.08023771f, 
    0.13024984f, 0.01977752f, -0.03737344f, 0.17544378f, -0.15095061f, 0.23104048f, -0.48214445f, 0.29495847f, 
    -0.07081582f, -0.07115059f, -0.04763849f, -0.06192414f, 0.08013499f, -0.16526037f, 0.16804275f, 0.04467494f, 
    -0.25585988f, 0.04137468f, -0.14330910f, 0.00889099f, -0.02276807f, -0.09479234f, -0.07234892f, 0.04373856f, 
    0.06047159f, 0.04201239f, 0.09551249f, -0.14975591f, -0.36149505f, -0.17903596f, -0.11198641f, -0.37431282f, 
    -0.11751455f, 0.01181448f, 0.07123723f, 0.04282142f, 0.09438122f, 0.02863747f, 0.08369573f, -0.07633951f, 
    0.02450890f, -0.31587616f, -0.04172003f, -0.02535799f, -0.02243375f, 0.08391146f, -0.01258100f, -0.00091706f, 
    -0.15768790f, -0.14074717f, 0.05853068f, -0.01170454f, -0.06028400f, -0.11391997f, -0.01938967f, -0.64244545f, 
    -0.26462251f, -0.16185603f, -0.01092340f, -0.08917931f, 0.04289996f, 0.02264294f, -0.01180249f, -0.07945982f, 
    -0.06511900f, 0.13054627f, 0.10779300f, -0.24000584f, 0.02221171f, 0.02773435f, -0.11284292f, -0.08449521f, 
    0.00402428f, -0.11848735f, -0.17018615f, 0.07205765f, 0.00956394f, -0.40448114f, 0.07023188f, 0.06593467f, 
    0.06292551f, 0.06057056f, -0.02060617f, -0.06664485f, 0.08075991f, 0.07652085f, 0.02643467f, -0.01224726f, 
    -0.22025834f, -0.02250527f, -0.12240992f, 0.23752412f, 0.11697221f, 0.07849499f, 0.02208088f, -0.04810156f, 
    0.06851779f, 0.07005697f, -0.04667154f, -0.03920266f, 0.04210461f, 0.31635022f, 0.12106095f, -0.13888067f, 
    0.02548889f, -0.03184208f, 0.01432208f, 0.04766593f, -0.00129310f, 0.05965649f, 0.06114494f, 0.06979892f, 
    -0.17785253f, -0.07031030f, -0.12364168f, 0.14393207f, -0.12993871f, -0.09870393f, 0.03819099f, -0.13047634f, 
    -0.01071041f, -0.10648280f, 0.06060065f, -0.01386651f, 0.10513169f, 0.13343936f, 0.04548743f, 0.02254758f, 
    0.03488973f, -0.15829392f, -0.02282763f, -0.06918319f, 0.02667376f, -0.13044120f, -0.08559065f, -0.01376827f, 
    -0.27305165f, 0.15248673f, -0.25152254f, 0.02330091f, 0.09374101f, -0.21286564f, 0.05548245f, -0.13735551f, 
    0.03848995f, -0.00493013f, -0.15517810f, -0.24206805f, 0.11695553f, 0.18413509f, 0.01990520f, 0.51946104f, 
    0.02305894f, 0.02503634f, -0.21280944f, -0.04095541f, -0.06680291f, 0.06117234f, 0.00116787f, -0.02019027f, 
    -0.11572982f, -0.04378776f, -0.51023912f, 0.08225486f, 0.07447124f, -0.09352264f, 0.14035404f, -0.09624774f, 
    -0.02040456f, 0.02038824f, -0.02438978f, 0.11629228f, 0.00506215f, 0.01364791f, 0.01875371f, 0.04586754f, 
    0.06761601f, -0.05520339f, 0.04657038f, -0.03951043f, 0.15893409f, 0.14391908f, 0.12618187f, 0.16861953f, 
    0.13828945f, 0.04834606f, 0.24719000f, -0.11336704f, -0.04994524f, 0.03432825f, -0.24163713f, -0.13641173f, 
    0.12947804f, -0.03489107f, 0.01706895f, 0.14541236f, 0.31120089f, -0.24099927f, -0.05098441f, 0.09713001f, 
    0.11214157f, 0.02949851f, 0.09817706f, -0.10529555f, 0.04700010f, -0.15425220f, -0.02163702f, -0.05677581f, 
    -0.13804360f, 0.14995895f, -0.07842991f, 0.25360495f, 0.10321125f, -0.31649667f, 0.09563769f, -0.19128443f, 
    0.04922584f, 0.00958769f, -0.05902023f, -0.07364986f, 0.16264623f, 0.08367319f, -0.01488271f, -0.15851025f, 
    -0.06268141f, 0.11376878f, -0.03418441f, 0.08060005f, 0.09449589f, -0.10006671f, -0.02650204f, 0.05099277f, 
    -0.56167531f, -0.14470662f, -0.35735741f, 0.20815274f, -0.03252400f, 0.10905415f, 0.21050234f, 0.13729164f, 
    0.07068463f, -0.00354409f, -0.03065794f, -0.00732624f, 0.34352514f, -0.00379624f, 0.31820512f, -0.11811205f, 
    0.19998375f, -0.21675001f, -0.25149903f, -0.02580504f, 0.02608828f, -0.07137979f, -0.16827516f, 0.10118814f, 
    -0.08645045f, -0.11175944f, -0.02365364f, 0.03189361f, 0.08042541f, 0.04452850f, 0.07936927f, 0.05036554f, 
    0.15541947f, 0.08818370f, 0.13888638f, 0.04739856f, -0.18809862f, 0.19823073f, -0.00574839f, 0.35741043f, 
    0.07477327f, -0.13603878f, -0.11318903f, -0.11883259f, 0.02794503f, -0.13225652f, -0.02926855f, -0.04758929f, 
    -0.67555243f, -0.37744865f, 0.19771163f, -0.00148589f, -0.01759262f, 0.10374136f, -0.25405726f, -0.01842092f, 
    0.06374743f, -0.05301446f, 0.05714649f, 0.00505719f, 0.14387457f, -0.37955436f, 0.12191635f, -0.49614716f, 
    0.03819902f, 0.00527505f, -0.00222505f, 0.07405480f, 0.04444459f, 0.11815750f, 0.05850727f, 0.03449493f, 
    -0.27263892f, -0.05814531f, -0.06650873f, 0.11526437f, 0.08883752f, -0.02436726f, 0.04153894f, 0.05788595f, 
    0.00141961f, 0.03474079f, -0.04843777f, -0.17639045f, -0.09166791f, -0.25718465f, -0.10196280f, 0.12411138f, 
    0.12495924f, 0.04729513f, 0.04864575f, 0.07810002f, -0.00039666f, -0.03523248f, -0.06058780f, 0.02629407f, 
    -0.05228643f, -0.10678405f, 0.08334645f, 0.01643190f, -0.03439921f, 0.04096886f, 0.02410150f, 0.01832306f, 
    0.06230932f, 0.12349021f, -0.01736244f, 0.03624953f, 0.06452621f, 0.09109776f, 0.34439075f, -0.27101070f, 
    0.21710476f, -0.18625262f, -0.01439537f, 0.04465009f, -0.05199464f, 0.03253728f, 0.04688067f, 0.03796446f, 
    -0.20453393f, 0.00076201f, -0.00326836f, -0.42554411f, 0.00216764f, -0.00026106f, -0.10725302f, 0.26187870f, 
    0.00351990f, -0.00918440f, 0.00754698f, -0.01893961f, -0.16441055f, 0.02274014f, 0.08192366f, 0.04059488f, 
    -0.04863797f, 0.04681544f, -0.03671505f, -0.13437885f, -0.02961965f, 0.10440394f, 0.05471066f, 0.07586931f, 
    0.10494523f, 0.07111105f, 0.05650615f, -0.14012380f, -0.12433568f, -0.10615785f, 0.02619859f, -0.06108023f, 
    -0.04808892f, -0.00510717f, 0.03814732f, 0.06387763f, 0.06188127f, -0.16338563f, 0.09867905f, -0.12780368f, 
    0.10853936f, 0.09302232f, -0.05017662f, -0.07738139f, -0.03692378f, -0.01174242f, -0.02566639f, -0.09838174f, 
    -0.05916300f, -0.20106083f, 0.13697188f, 0.12574318f, 0.24646248f, 0.04337720f, 0.10579301f, -0.05717224f, 
    0.14784825f, -0.00471901f, -0.15091026f, -0.19323477f, -0.60786110f, 0.22955042f, -0.46287423f, 0.18822095f, 
    -0.04136944f, -0.17571056f, -0.04150757f, -0.23956075f, 0.02512776f, -0.01805807f, -0.09597938f, -0.16573803f, 
    -0.27022806f, 0.02438226f, 0.07791909f, -0.10381029f, -0.10758702f, -0.13778469f, 0.06222882f, 0.09124255f, 
    0.07283021f, -0.02880181f, 0.02014042f, 0.03182683f, -0.82183266f, 0.06351705f, -0.35335189f, 0.05774689f, 
    -0.04460188f, 0.05687952f, -0.03020062f, -0.01951848f, 0.03747297f, 0.11897487f, -0.06464102f, -0.03600053f, 
    0.20820865f, -0.07461495f, -0.02820314f, 0.02455118f, -0.11571883f, 0.13287206f, 0.07011367f, 0.07041322f, 
    0.06132264f, 0.08394392f, 0.07777530f, -0.04981691f, -0.16260408f, -0.16877580f, -0.22389743f, 0.02551074f, 
    0.07470794f, 0.14522445f, 0.17783727f, 0.13858552f, -0.06227511f, -0.17072257f, -0.03027360f, 0.01134438f, 
    -0.18052490f, 0.04093222f, 0.28280413f, -0.06543205f, 0.11128663f, -0.22934176f, 0.05107594f, 0.06923499f, 
    0.06181302f, 0.01178562f, -0.04490722f, 0.00860829f, 0.18004285f, -0.33272746f, 0.22299318f, -0.38031936f, 
    -0.10219453f, -0.27745926f, -0.18686591f, -0.04422496f, -0.18221664f, 0.05565376f, -0.01004115f, 0.03930134f, 
    0.18008533f, 0.17422706f, 0.24658793f, -0.00219112f, 0.00445041f, -0.03124899f, -0.10723950f, -0.27586433f, 
    0.06118735f, 0.00525186f, -0.01499162f, 0.07510412f, -0.25530368f, -0.02110820f, -0.11768132f, 0.02294492f, 
    -0.04170258f, 0.23679300f, -0.00575883f, 0.07331096f, 0.12039395f, 0.05455134f, -0.18741104f, 0.03289665f, 
    0.16401812f, -0.42778972f, 0.16830671f, -0.28801924f, 0.14141433f, -0.10001711f, -0.02121237f, 0.00978508f, 
    -0.07768339f, 0.10528918f, -0.04864484f, 0.10804200f, -0.07535894f, 0.05068163f, 0.05191194f, -0.25189283f, 
    0.00014705f, -0.02631306f, 0.05504319f, 0.07679328f, 0.06104659f, 0.09599585f, 0.03702953f, 0.26494065f, 
    0.03868306f, 0.35210854f, -0.00335141f, 0.38207722f, 0.01586268f, -0.10689109f, -0.11997736f, -0.08763567f, 
    -0.02510935f, -0.06921811f, 0.11047028f, -0.01956762f, -0.17531109f, 0.17107929f, 0.18998554f, -0.00456941f, 
    -0.03622425f, -0.09144681f, -0.02051736f, -0.12972468f, -0.00138290f, 0.00110975f, 0.04662595f, -0.02078072f, 
    0.31874546f, 0.13645121f, -0.26249421f, -0.19353159f, -0.05741450f, 0.01379863f, 0.19173287f, 0.24987286f, 
    -0.04639759f, 0.05673278f, -0.08139646f, -0.08682284f, -0.31927529f, -0.04931241f, -0.11165670f, 0.19159983f, 
    0.02399178f, -0.24127427f, -0.18161412f, 0.01569530f, 0.11306409f, 0.04550803f, 0.06393570f, -0.05776694f, 
    -0.09792616f, -0.30309972f, 0.15962075f, -0.29231158f, 0.08309203f, 0.05434497f, -0.26257643f, -0.10420130f, 
    -0.09887347f, -0.00280939f, -0.05210973f, 0.03832898f, -0.20703723f, 0.14180265f, -0.10062239f, -0.42766836f, 
    0.08522960f, -0.11151565f, 0.03966979f, 0.04389622f, 0.22541456f, -0.00081017f, 0.09670403f, 0.04539484f, 
    -0.43763050f, 0.24760999f, 0.11923554f, -0.05911042f, -0.07373264f, -0.08970381f, 0.12957501f, 0.17523792f, 
    -0.03888696f, -0.03652943f, 0.05642069f, -0.06942604f, -0.04533357f, -0.12809101f, -0.17069419f, -0.06512042f, 
    0.02827528f, -0.04926924f, 0.16199589f, 0.06817729f, -0.05767818f, -0.03601317f, -0.01106359f, -0.14154975f, 
    -0.24869534f, 0.04649272f, -0.11074008f, -0.11100818f, -0.05438659f, -0.12833209f, 0.15314925f, 0.00216130f, 
    -0.02652095f, -0.01474319f, -0.08988331f, -0.12986250f, 0.07083724f, -0.16691829f, -0.00806753f, -0.11720853f, 
    0.01673057f, 0.01286998f, 0.09143846f, 0.17816091f, 0.07790621f, 0.02030873f, -0.07607227f, -0.07603853f, 
    -0.05602235f, 0.05549520f, -0.05996212f, 0.04417143f, 0.03276023f, -0.04894578f, -0.07650284f, 0.00932885f, 
    -0.07798320f, -0.04928010f, -0.13963108f, -0.34360197f, -0.17764069f, 0.09349173f, -0.08799236f, 0.18552849f, 
    -0.05115774f, -0.11791642f, 0.01951294f, -0.03417265f, 0.05206987f, -0.04733760f, -0.08175497f, -0.10218078f, 
    -0.07939038f, 0.09907946f, -0.09898825f, 0.10304209f, -0.00096537f, -0.08275415f, -0.03146058f, 0.02717634f, 
    -0.14161716f, -0.13109376f, -0.16768777f, -0.25628769f, -0.14817846f, -0.33741465f, 0.01367059f, -0.10678348f, 
    0.02614583f, -0.06704213f, 0.05404297f, -0.06354374f, -0.29978549f, -0.06667437f, -0.19638896f, 0.00939495f, 
    -0.09269299f, -0.45105144f, 0.09644721f, 0.17219402f, 0.03723253f, 0.12957042f, -0.06374273f, 0.01566624f, 
    -0.23533809f, -0.08334091f, -0.22668141f, 0.02267897f, -0.00388663f, 0.10927414f, -0.19925420f, 0.01370977f, 
    -0.01301101f, -0.09053689f, -0.23660992f, 0.08254205f, -0.11915394f, -0.06459694f, -0.20515953f, -0.19870400f, 
    -0.08108184f, 0.04941702f, 0.06510140f, 0.15277719f, -0.02883741f, 0.01624753f, -0.01998456f, -0.00329699f, 
    0.03855133f, -0.05697662f, 0.03962808f, 0.11820251f, -0.01906230f, -0.03788574f, 0.18431360f, 0.06795845f, 
    -0.16749126f, -0.11685640f, 0.09592680f, 0.12228435f, -0.00613461f, 0.11420237f, 0.09655207f, 0.12079427f, 
    -0.07641827f, 0.03773670f, 0.04893311f, -0.04448838f, -0.02695354f, -0.05096116f, -0.02794292f, 0.04849342f, 
    -0.17399527f, -0.04225003f, -0.04167505f, -0.16461998f, 0.32538089f, 0.22804791f, 0.28743628f, -0.06750526f, 
    -0.05060710f, -0.00563108f, 0.08438494f, 0.12859312f, -0.03670611f, -0.00044688f, -0.10503994f, -0.02588487f, 
    -0.19228469f, 0.36336470f, -0.03342371f, -0.16548835f, -0.00731238f, -0.06160383f, -0.24629013f, 0.12795006f, 
    -0.03138523f, -0.14274533f, 0.09448521f, -0.04433401f, 0.10237331f, -0.34430644f, 0.03651088f, 0.00267311f, 
    0.06223930f, -0.07651588f, 0.00840914f, 0.04154453f, 0.00754223f, 0.01502694f, -0.04653746f, -0.01892659f, 
    -0.20951656f, 0.01835685f, 0.15684108f, -0.07586689f, -0.06962648f, 0.11185283f, -0.01965586f, -0.02059893f, 
    0.10927527f, 0.11470687f, 0.08857281f, -0.11253458f, 0.08660232f, -0.38360476f, 0.12986441f, 0.00159466f, 
    -0.07252619f, -0.05656325f, 0.08545341f, 0.04644201f, -0.01961514f, 0.09915078f, -0.00662842f, -0.13918602f, 
    -0.09720429f, -0.03080997f, 0.30099523f, -0.17763330f, 0.00482693f, 0.13380757f, -0.06144938f, 0.16237475f, 
    -0.05914846f, -0.07527509f, -0.02387387f, -0.12207854f, -0.29134706f, 0.28718850f, -0.19771855f, -0.14769906f, 
    -0.06055835f, -0.06391226f, 0.07748131f, 0.11638361f, -0.05225596f, -0.05543609f, -0.05634527f, -0.15880558f, 
    -0.17467207f, 0.24857461f, 0.01525455f, -0.26458448f, -0.18375877f, 0.02235449f, -0.01647249f, 0.00443744f, 
    -0.16262339f, -0.01373966f, 0.12490800f, -0.04225949f, -0.11793074f, -0.04433422f, -0.07146231f, 0.11332215f, 
    0.01866527f, 0.08022398f, 0.07542570f, -0.04546488f, -0.12467987f, -0.07291806f, -0.11843043f, -0.19205731f, 
    0.06249354f, 0.09634766f, 0.04390438f, -0.05085715f, -0.16149695f, 0.01413871f, 0.11357917f, 0.01003974f, 
    0.02268003f, 0.12122666f, -0.00917657f, 0.06896328f, -0.08669912f, 0.17696807f, 0.03036862f, -0.06613380f, 
    -0.13502707f, -0.00359405f, 0.02438840f, -0.06665903f, 0.00694859f, 0.11059272f, 0.20105459f, 0.13699333f, 
    0.07753459f, 0.06556351f, 0.00410640f, 0.12062590f, -0.19778214f, 0.08257776f, 0.08799203f, -0.01858014f, 
    0.13561034f, 0.11495430f, -0.10366314f, 0.17106763f, 0.10563830f, 0.21184501f, 0.01809492f, -0.09168462f, 
    0.05427438f, 0.01825419f, -0.15439154f, 0.08833023f, 0.03710524f, 0.12380641f, 0.11020797f, 0.07272337f, 
    0.02905744f, 0.02223412f, -0.19991766f, 0.09772267f, -0.14216863f, 0.03061272f, 0.14613262f, -0.06322657f, 
    0.03869919f, 0.09553382f, -0.11825997f, 0.06366814f, -0.01539624f, 0.17236909f, 0.02406282f, -0.03190763f, 
    -0.02522805f, -0.02041068f, 0.01915348f, 0.06596836f, -0.15380304f, -0.19335185f, -0.38658333f, -0.15777627f, 
    -0.18759017f, 0.08249949f, 0.03444996f, -0.04076891f, 0.09380675f, -0.02347149f, -0.06749273f, -0.01570925f, 
    -0.07201098f, 0.04980259f, 0.06316562f, -0.12407053f, -0.77484888f, 0.15814701f, -0.20829400f, 0.11468781f, 
    -0.03351726f, 0.09294975f, -0.01469240f, -0.01404240f, -0.09478106f, -0.00163515f, 0.00137085f, -0.02200946f, 
    -0.36338022f, 0.05743705f, 0.11465744f, -0.08471000f, -0.12886409f, 0.25865895f, -0.13105541f, 0.01907121f, 
    -0.02153705f, -0.05556320f, -0.13229844f, -0.08159000f, 0.03956769f, -0.34246653f, -0.08331676f, 0.13714616f, 
    -0.05940972f, -0.23176762f, 0.01781947f, -0.08478950f, -0.00537666f, 0.02649190f, 0.00597508f, 0.04716778f, 
    -0.12159567f, -0.16563651f, 0.07845590f, -0.09832706f, -0.19220525f, -0.04824485f, -0.00072838f, -0.05114542f, 
    -0.00607234f, 0.00840054f, 0.02438757f, -0.03369230f, -0.05557702f, 0.09237099f, 0.21745916f, 0.16476649f, 
    0.01478185f, 0.01651480f, 0.07689608f, -0.05648005f, 0.03584991f, 0.05223279f, 0.08729727f, 0.10532570f, 
    -0.11004537f, -0.26515225f, -0.17372578f, -0.40382591f, -0.02551606f, -0.17611896f, -0.04027548f, 0.00618497f, 
    -0.12769122f, 0.05841019f, 0.09335948f, -0.06245221f, -0.15158457f, 0.23230213f, 0.17143226f, 0.02523895f, 
    -0.09997661f, 0.10904519f, -0.06855411f, 0.10642404f, 0.06816228f, 0.04699983f, 0.10323863f, 0.01980841f, 
    -0.00644607f, -0.30423430f, 0.16491345f, 0.02545831f, 0.08868413f, 0.16849555f, 0.12367740f, -0.05365117f, 
    0.01548682f, -0.04700188f, 0.04978775f, -0.00735596f, -0.12199418f, 0.05599780f, 0.32239288f, 0.30825275f, 
    -0.04402656f, 0.14718658f, 0.02044166f, -0.00995287f, -0.03592692f, -0.10733107f, -0.04059485f, 0.09370686f, 
    0.05226678f, -0.08588324f, 0.12359783f, 0.21264426f, -0.08424488f, -0.01353772f, 0.12536591f, -0.00648706f, 
    0.03691502f, -0.03533581f, 0.02004978f, 0.04606043f, -0.15428545f, 0.14717755f, 0.11297359f, -0.00261494f, 
    -0.03930070f, -0.03007901f, 0.05571743f, 0.00424720f, 0.06507476f, 0.04435347f, -0.07819293f, -0.11162133f, 
    -0.11278671f, -0.08932339f, -0.44526750f, 0.11756978f, -0.00396892f, 0.11633310f, -0.02075565f, -0.00400655f, 
    0.02862858f, 0.01014847f, -0.05961736f, -0.01699694f, 0.09063144f, -0.14095414f, 0.09995457f, 0.10876350f, 
    -0.14816472f, 0.19027454f, -0.07478844f, 0.06081308f, -0.03044402f, -0.04718500f, 0.01484483f, 0.09529613f, 
    -0.10742310f, -0.22834460f, 0.06553220f, 0.23565356f, -0.20638427f, 0.18790236f, 0.07980021f, 0.12049881f, 
    0.07898404f, -0.01412799f, 0.19067922f, 0.15322800f, 0.04426152f, 0.17131317f, -0.23138666f, -0.21282139f, 
    0.05894154f, 0.03802061f, -0.02926982f, 0.10041419f, -0.19127996f, -0.16744465f, -0.44230935f, -0.37929216f, 
    -0.18016817f, 0.04240111f, -0.15062779f, -0.17938522f, -0.03523346f, 0.03550474f, 0.05845856f, -0.04014572f, 
    -0.04776591f, 0.12385085f, -0.02606999f, -0.20342036f, -0.07140096f, -0.28360510f, -0.23765764f, -0.07439040f, 
    -0.10808722f, -0.00923254f, -0.07447090f, -0.11441123f, 0.16491412f, 0.12407886f, 0.11418734f, 0.05263653f, 
    -0.43011034f, 0.06286700f, -0.11888047f, -0.03361357f, -0.08428598f, 0.04653775f, 0.05323458f, 0.11337023f, 
    -0.06554230f, -0.11401755f, 0.14201745f, 0.09974164f, 0.26025745f, 0.12255794f, 0.16022672f, -0.00004625f, 
    -0.06922641f, 0.04434058f, 0.13965330f, -0.08651150f, -0.10579568f, 0.11353423f, -0.00025923f, 0.12255244f, 
    -0.11934298f, -0.03729667f, -0.09719168f, 0.00846061f, -0.00182451f, -0.20093372f, 0.00802110f, 0.07102743f, 
    -0.05579989f, 0.14980002f, -0.01072607f, -0.03049450f, 0.35830656f, 0.01640083f, 0.28083649f, -0.19394824f, 
    -0.09533429f, -0.07252124f, 0.06257524f, 0.07212368f, -0.01109144f, -0.00209670f, -0.03991434f, 0.06432702f, 
    -0.08687685f, -0.26587909f, -0.34196070f, 0.20398854f, 0.05709204f, 0.19438770f, -0.10155819f, 0.14993525f, 
    0.13564810f, 0.12328657f, -0.02085375f, -0.05183597f, 0.19508946f, -0.35867721f, 0.05112147f, 0.01293089f, 
    -0.17633791f, -0.42727181f, 0.10657819f, -0.16780949f, 0.00093104f, -0.11991823f, -0.10930111f, -0.09137519f, 
    -0.05580504f, -0.17153810f, -0.07339556f, -0.07909218f, -0.19891059f, -0.03382070f, 0.08510841f, -0.10731686f, 
    -0.02790477f, 0.02611810f, 0.02542520f, 0.00971803f, -0.39912686f, 0.48213974f, -0.28700930f, 0.16287223f, 
    0.15419157f, 0.11903144f, -0.05156111f, 0.06161269f, -0.09467132f, -0.07245631f, -0.14247631f, -0.14490809f, 
    -0.02392187f, 0.05569994f, 0.05838293f, 0.00237389f, 0.02498080f, -0.01003122f, -0.03626495f, -0.04304619f, 
    -0.17161913f, 0.03552218f, 0.02188776f, -0.07847083f, -0.08589907f, -0.06970137f, 0.35132903f, -0.06226096f, 
    0.08108300f, -0.06102515f, -0.08204451f, 0.13567366f, 0.04775017f, 0.07002573f, 0.13104144f, -0.08938430f, 
    -0.15246403f, 0.17351630f, 0.01173045f, 0.23358230f, 0.01510529f, 0.00840321f, -0.13170011f, 0.20084807f, 
    0.08494387f, 0.00883478f, 0.08285037f, -0.00526380f, -0.00745575f, -0.14309651f, 0.09137581f, 0.09351686f, 
    0.14697304f, -0.08502737f, 0.02115247f, 0.13619149f, -0.08305001f, -0.25029150f, -0.43424904f, -0.30965251f, 
    0.03233912f, 0.14853071f, 0.07061375f, -0.20338599f, -0.02279875f, -0.02120726f, 0.06518932f, 0.02558345f, 
    -0.00134735f, 0.12356213f, -0.05127008f, -0.10262490f, 0.39201510f, -0.23314101f, 0.20357344f, 0.00534446f, 
    -0.09653664f, -0.00321671f, 0.05549772f, 0.00077363f, -0.03580967f, 0.00518865f, -0.12629214f, -0.10666168f, 
    -0.22845256f, -0.41682586f, 0.24481837f, -0.04056849f, -0.01452532f, -0.11632207f, -0.16957341f, 0.05495596f, 
    0.04391258f, 0.12372939f, 0.13963151f, -0.10092436f, -0.35595554f, 0.22194551f, -0.01412271f, 0.08547976f, 
    0.05872937f, 0.08404271f, -0.01363384f, 0.08268508f, 0.10149624f, 0.08678651f, -0.02533950f, 0.05364575f, 
    -0.33638373f, 0.21228652f, -0.02335390f, 0.04923172f, -0.01499893f, -0.06485520f, 0.10462318f, 0.06485167f, 
    -0.01265575f, 0.14657943f, 0.10887607f, -0.09458259f, -0.04813298f, -0.16870424f, 0.10927717f, 0.10959758f, 
    -0.01928964f, -0.26400527f, 0.02612718f, -0.07719526f, -0.18064311f, 0.07185524f, 0.15421118f, 0.00197939f, 
    -0.39683408f, -0.07445774f, 0.03885362f, 0.18372677f, -0.05476702f, 0.13453761f, -0.05778618f, -0.11011033f, 
    0.00651208f, 0.06041552f, -0.01418815f, -0.00669769f, 0.07351977f, 0.07012370f, -0.08110225f, 0.06923226f, 
    -0.06620401f, -0.02679940f, -0.08943225f, 0.00932600f, -0.04819073f, 0.06184660f, -0.01595856f, 0.14642586f, 
    0.14272177f, -0.06412147f, 0.15647668f, 0.06175775f, -0.19887455f, 0.05472304f, -0.01970763f, 0.16504274f, 
    0.04950496f, 0.06034784f, 0.06067812f, 0.16422482f, 0.10907441f, 0.05264184f, -0.32891646f, -0.06748714f, 
    -0.00892567f, 0.17167822f, -0.08463473f, 0.00446457f, -0.02428547f, -0.01514466f, -0.34128106f, -0.16676912f, 
    -0.07459493f, 0.13874587f, -0.11706710f, -0.01384882f, -0.02116257f, -0.05365331f, 0.00583894f, -0.01149075f, 
    0.01442580f, 0.08397572f, 0.08079147f, 0.07198433f, -0.08008853f, -0.18981156f, 0.22027455f, -0.06267398f, 
    0.06258563f, 0.04349742f, 0.10622212f, 0.03908234f, -0.04917784f, 0.08771390f, 0.01347966f, -0.00666123f, 
    -0.03765348f, -0.04026445f, 0.01283078f, 0.01691934f, -0.01010683f, -0.03359893f, -0.00827260f, 0.00039257f, 
    0.03628066f, 0.06236091f, 0.04323932f, 0.02496253f, 0.21577960f, 0.15006766f, 0.28853264f, 0.10644449f, 
    0.04111946f, 0.05159143f, -0.04319665f, 0.11963503f, -0.19008160f, -0.01300244f, 0.07786072f, 0.18756932f, 
    -0.13134168f, 0.13067953f, -0.01184358f, -0.06789898f, 0.05579896f, -0.09902293f, 0.15844725f, -0.00066313f, 
    0.10518565f, 0.00039001f, 0.11465685f, 0.01960013f, 0.19416448f, -0.02298356f, 0.24496567f, 0.17209090f, 
    -0.07517874f, -0.25429261f, 0.13320583f, 0.12908722f, 0.14126450f, 0.15843314f, 0.11959019f, 0.09009272f, 
    -0.52408445f, 0.11491852f, -0.22106725f, 0.12846452f, 0.03860939f, 0.06926475f, -0.03432564f, -0.07721660f, 
    0.01761369f, 0.00252377f, 0.10338654f, -0.14509447f, -0.29924569f, -0.03102286f, -0.23803750f, 0.17760842f, 
    0.06314588f, 0.09945253f, 0.07598501f, -0.13489264f, 0.03740367f, -0.17966883f, -0.01785991f, -0.09180930f, 
    -0.02968042f, 0.02389874f, -0.10389350f, -0.00919851f, 0.01507042f, 0.02913283f, 0.11313701f, 0.04571191f, 
    0.06391304f, 0.04601099f, 0.05611609f, 0.10798808f, -0.08746971f, -0.34293658f, 0.27174750f, -0.04319096f, 
    0.03171568f, 0.00768710f, 0.04804445f, -0.00970955f, 0.05355645f, 0.01032256f, 0.00499689f, 0.16843104f, 
    0.00035940f, -0.24735294f, 0.08572431f, 0.19977009f, 0.00022807f, -0.06352915f, 0.04970877f, 0.06676343f, 
    -0.04373597f, 0.00000681f, 0.11710091f, 0.11000981f, -0.09025425f, 0.15974011f, -0.02864101f, -0.33354408f, 
    -0.12778129f, 0.09761346f, 0.23335938f, -0.20495456f, 0.03044234f, 0.05625111f, 0.01964303f, -0.05717338f, 
    0.06064229f, 0.25080335f, -0.14144769f, -0.02428054f, -0.02889898f, 0.01061045f, 0.04335569f, -0.07230169f, 
    0.02745410f, 0.05759118f, -0.19752941f, 0.07098006f, -0.12501059f, 0.03091717f, 0.00834577f, -0.45758864f, 
    0.07308035f, 0.04895903f, 0.04178207f, -0.08197666f, 0.08008984f, 0.03482731f, -0.06506125f, -0.05142826f, 
    0.00232987f, -0.04107945f, -0.13184373f, 0.05943083f, 0.01374764f, 0.00084069f, 0.05755381f, 0.00185417f, 
    -0.01595541f, 0.12270167f, 0.09869576f, 0.13357694f, 0.08029843f, 0.18065269f, 0.03827494f, 0.14201050f, 
    -0.05112935f, 0.05161908f, -0.05424367f, 0.03152661f, -0.12227578f, 0.16818799f, 0.06943296f, -0.01226635f, 
    0.14149059f, -0.07592890f, 0.17128754f, 0.13065991f, -0.04253506f, 0.08824258f, -0.03628206f, 0.10976089f, 
    -0.02713779f, 0.02127739f, 0.11220369f, -0.05820525f, -0.29753214f, -0.29773924f, -0.05096691f, -0.03852849f, 
    -0.03006277f, -0.06220907f, -0.06336297f, -0.06170328f, 0.05307110f, 0.05498991f, -0.04298575f, 0.13123046f, 
    0.10689781f, -0.09068411f, -0.02732198f, -0.02352549f, 0.04816350f, -0.00632339f, -0.10997619f, 0.02794885f, 
    -0.03186999f, -0.05602486f, 0.00883362f, 0.05109145f, -0.05895796f, -0.04301186f, -0.29243556f, -0.01116757f, 
    0.05900548f, -0.03538148f, 0.13498662f, -0.02553922f, -0.18565714f, -0.09441710f, -0.10487277f, -0.16991954f, 
    0.37040102f, -0.13732432f, 0.21848565f, -0.28560486f, -0.05459782f, -0.05229307f, -0.18620451f, 0.23304109f, 
    -0.04162968f, -0.01409483f, -0.04534186f, -0.14663701f, -0.48727170f, 0.09896658f, -0.25266421f, 0.14713599f, 
    0.03360434f, -0.02601749f, 0.02523058f, 0.04478218f, -0.07048232f, -0.02631340f, -0.00607772f, -0.02731360f, 
    0.36523017f, -0.52787101f, 0.21461599f, -0.09959307f, 0.05607475f, 0.01875087f, -0.13038048f, 0.10850797f, 
    -0.04842789f, 0.04714954f, 0.09417327f, -0.00027167f, 0.05028877f, 0.02261362f, -0.01936959f, -0.19411124f, 
    0.01857961f, -0.05479483f, -0.03814875f, 0.04188669f, 0.09528632f, 0.11550244f, 0.16598041f, -0.04247201f, 
    -0.16687977f, 0.29772139f, -0.36631289f, -0.00459386f, 0.05932409f, -0.05977442f, 0.13041294f, -0.05989265f, 
    -0.02460846f, 0.06731061f, -0.05046342f, 0.00965427f, 0.14423950f, 0.15832870f, -0.00111588f, 0.41169363f, 
    0.15295535f, -0.20133039f, 0.04075446f, 0.24523956f, -0.06429849f, 0.13150328f, 0.05995405f, 0.08081673f, 
    0.24404360f, -0.22212066f, 0.21336818f, -0.04452695f, 0.08109317f, 0.27073574f, 0.07704693f, 0.10226347f, 
    0.01276839f, 0.12908666f, 0.09276804f, 0.07487889f, 0.07344392f, 0.11714301f, 0.23221973f, -0.23362297f, 
    0.00823281f, 0.07676107f, -0.10592090f, -0.04701214f, 0.04077166f, -0.10333483f, 0.10494068f, 0.05018558f, 
    0.38388911f, 0.19643384f, 0.41229266f, -0.24601023f, -0.11656828f, 0.05014387f, -0.32863581f, 0.00818670f, 
    -0.10183884f, 0.01773860f, -0.04675340f, -0.01129588f, -0.24701937f, -0.03466429f, -0.25389573f, 0.26145813f, 
    0.00920306f, -0.00493494f, -0.00514021f, 0.15365165f, -0.12364731f, -0.10419254f, -0.00986759f, -0.18958752f, 
    0.14197190f, 0.04381824f, -0.10271102f, -0.11524422f, -0.03188483f, 0.07389712f, 0.00322476f, 0.08028577f, 
    -0.12227277f, -0.02993782f, 0.08017521f, -0.07577892f, -0.06130103f, -0.33490524f, 0.14936486f, -0.06727222f, 
    0.26701513f, 0.00033682f, -0.07926680f, -0.01152332f, -0.00108062f, -0.01823655f, 0.12072250f, -0.05753518f, 
    -0.72463357f, 0.27030724f, -0.25262827f, 0.32734171f, 0.01822691f, 0.14355505f, -0.01770215f, -0.18221930f, 
    -0.00154927f, 0.01250685f, 0.08133230f, 0.09776022f, -0.73155755f, 0.34864852f, -0.20328335f, 0.34557703f, 
    -0.01355967f, 0.28363100f, 0.04819769f, -0.07555702f, -0.08747132f, 0.11964322f, 0.13482964f, -0.01410600f, 
    0.20012785f, 0.01126920f, 0.20822445f, 0.02266568f, -0.05405232f, 0.10301285f, -0.16440193f, 0.06353229f, 
    -0.08989514f, 0.24437061f, -0.00111080f, 0.10558432f, 0.20930254f, 0.07034960f, 0.17584692f, -0.11145622f, 
    0.00824098f, -0.09641457f, 0.03584733f, 0.03030105f, 0.05752127f, 0.12651403f, -0.01801204f, -0.00628357f, 
    -0.23050001f, -0.08541781f, -0.18331148f, 0.11605684f, -0.16363992f, -0.00645166f, 0.02183235f, -0.23547947f, 
    -0.00198812f, 0.06143112f, 0.00112652f, -0.02698434f, 0.00790224f, -0.14424405f, 0.08079039f, 0.11687741f, 
    -0.11053295f, -0.04127827f, 0.10801939f, 0.24802913f, -0.19233777f, 0.10139797f, -0.02126570f, -0.09812164f, 
    -0.05751362f, 0.04158784f, 0.05931142f, 0.09651933f, -0.07699709f, -0.03057370f, -0.50334245f, -0.07858067f, 
    -0.02951322f, -0.05742578f, -0.15036635f, -0.21339183f, -0.22074296f, 0.06302825f, -0.23307309f, -0.16260575f, 
    0.04655871f, -0.08625896f, -0.03433711f, -0.10583951f, 0.00464449f, 0.05647796f, 0.04293396f, 0.09314357f, 
    -0.11734029f, -0.18847343f, -0.11409305f, -0.33318847f, 0.01500519f, -0.31278077f, -0.05936940f, -0.04932840f, 
    0.12116001f, 0.04810734f, -0.05283935f, -0.02806465f, 0.08278845f, 0.16499849f, -0.08171901f, -0.10087074f, 
    -0.02000005f, 0.03424854f, -0.05160708f, -0.06873797f, -0.12225766f, -0.01582245f, 0.05787727f, -0.04446268f, 
    0.18126313f, 0.11695408f, 0.03534896f, 0.06270076f, -0.16655546f, 0.19346420f, -0.06228802f, 0.17987299f, 
    -0.13215920f, 0.05117370f, 0.09784556f, -0.14780243f, 0.11355785f, -0.20464619f, 0.18778640f, -0.25885028f, 
    -0.04678432f, 0.14667247f, -0.08285387f, 0.21254659f, -0.04059833f, 0.03733327f, 0.11815470f, -0.09931286f, 
    0.06900460f, -0.21998458f, -0.07485414f, -0.16721684f, -0.07441811f, -0.16626392f, -0.07944296f, -0.14652409f, 
    0.07839328f, 0.00621192f, 0.02621959f, -0.02918443f, -0.08009186f, -0.44314158f, 0.11307206f, -0.06040038f, 
    0.07168104f, -0.01376534f, 0.11703643f, -0.01631594f, 0.04177746f, 0.13567591f, 0.05839014f, -0.05429980f, 
    -0.32023811f, -0.39812958f, -0.16599616f, 0.11257955f, -0.17832087f, -0.14809601f, -0.06147065f, -0.16866739f, 
    0.06050580f, 0.01240158f, 0.05052958f, 0.04867354f, 0.33871186f, 0.14411958f, 0.14865099f, -0.20051086f, 
    -0.10936339f, 0.02141267f, -0.07242904f, -0.00493683f, -0.09380403f, 0.02605333f, -0.03045459f, 0.01423936f, 
    0.04291377f, -0.16264915f, -0.06548624f, -0.18960424f, -0.04887885f, -0.23656680f, 0.12488673f, -0.09891330f, 
    0.02770613f, 0.04997288f, 0.03560317f, -0.05691978f, -0.65210283f, -0.12835170f, -0.06101661f, 0.38008267f, 
    -0.01884301f, -0.03414520f, 0.11563604f, 0.28390434f, -0.17305452f, -0.06721792f, -0.10632945f, 0.06416329f, 
    -0.23311427f, 0.09103519f, -0.07138118f, -0.00506851f, -0.02793662f, -0.06257094f, 0.02271003f, -0.06461282f, 
    -0.02181219f, -0.00511860f, -0.02877588f, -0.17944092f, -0.01022089f, 0.02736054f, 0.15790369f, -0.10243905f, 
    -0.06706628f, 0.04690928f, 0.09955981f, 0.07349192f, 0.00156612f, 0.00668741f, 0.16599356f, 0.09304404f, 
    -0.64951432f, 0.04142032f, 0.03519720f, -0.00949756f, -0.00823112f, 0.09682357f, -0.04183276f, 0.20845717f, 
    -0.41550922f, -0.01352112f, 0.08089381f, -0.03465012f, -0.02600054f, -0.08399383f, 0.24046016f, -0.33760616f, 
    -0.00072904f, 0.10438883f, -0.05750825f, -0.02772411f, 0.05917558f, 0.13587089f, 0.12722896f, 0.07709501f, 
    -0.25645158f, 0.06924716f, -0.31179249f, 0.05343337f, 0.03954861f, -0.02884379f, 0.04393837f, -0.08175821f, 
    -0.02248126f, -0.06181142f, 0.03441187f, 0.13374425f, -0.18402185f, -0.26541606f, 0.13740450f, -0.40225452f, 
    0.14749886f, 0.06602862f, -0.07544667f, 0.06361871f, -0.14038356f, -0.01723485f, 0.07175245f, -0.04934147f, 
    0.16071269f, -0.13811833f, 0.21412414f, 0.16451135f, -0.25642654f, -0.13314357f, -0.19950224f, -0.05524974f, 
    -0.04982918f, -0.04160174f, 0.01990228f, -0.03509622f, 0.03537127f, -0.23035447f, 0.18813227f, 0.06482105f, 
    0.10315508f, -0.09686605f, -0.27227205f, 0.14971246f, 0.07502036f, -0.07919701f, 0.02534846f, -0.07326951f, 
    -0.34970331f, 0.37888655f, -0.15507782f, 0.06519817f, -0.00166889f, 0.12443695f, 0.11156992f, -0.13141294f, 
    -0.03727525f, 0.02220398f, -0.11526112f, 0.17137635f, 0.12470171f, -0.18881145f, 0.14729416f, 0.05418938f, 
    -0.07330763f, 0.19071762f, -0.20408930f, 0.11660920f, -0.04329781f, 0.00396368f, 0.13091286f, -0.01660691f, 
    -0.17026824f, -0.15731578f, 0.07665195f, -0.03637974f, 0.01876630f, -0.16922639f, 0.03471822f, -0.10791333f, 
    0.00982151f, 0.01348099f, -0.04822680f, -0.10475579f, 0.15168574f, -0.13407549f, 0.06236137f, 0.14151278f, 
    -0.07564546f, -0.06586414f, -0.18554671f, -0.05276766f, -0.17232193f, -0.08244672f, 0.00914405f, -0.13089338f, 
    0.11958998f, -0.19301599f, 0.26471940f, -0.14157929f, -0.00374197f, 0.03716073f, -0.05411312f, 0.10014333f, 
    -0.07972283f, -0.05646085f, -0.18273365f, -0.14849247f, -0.34289062f, 0.09015111f, 0.11649705f, -0.10091360f, 
    -0.04674004f, -0.03171265f, -0.04114933f, 0.14146531f, -0.00716446f, -0.00584948f, 0.11287957f, 0.15120271f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15890278f, 0.05961223f, 0.08374242f, -0.07048996f, -0.09279887f, 0.04222250f, 0.00919685f, -0.10125969f, 
    0.08229028f, 0.00354705f, 0.03589072f, 0.02594267f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
