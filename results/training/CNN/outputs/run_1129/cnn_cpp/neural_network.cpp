#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.19714917f, -0.23401870f, 0.24267618f, 0.46856675f, 0.13461977f, 0.01372894f, 0.17193910f, 0.27670974f, 
    0.54770422f, 0.05885888f, 0.32523105f, 0.22701730f, 0.18246548f, 0.31928644f, 0.35567600f, 0.01333223f, 
    0.68900347f, -0.09972654f, -1.04393518f, -0.77907217f, -0.51324862f, 0.27328312f, 0.53425509f, 0.08540326f, 
    -0.00861658f, -0.59016192f, 0.15565231f, -0.61969036f, 0.58338106f, 0.02904524f, -0.36757421f, -0.05410346f, 
    -0.49013054f, 0.70716304f, 0.39734489f, 0.10312449f, -0.38700250f, 1.15044522f, -0.65974319f, 0.28385341f, 
    0.09378606f, 0.08432567f, 0.04340406f, 0.44105616f, -0.22321275f, -0.64747018f, 0.02820902f, 0.77142650f, 
    0.28721032f, -0.14044304f, 0.24160767f, -0.39481837f, -0.55415225f, 0.37450305f, 0.57928252f, -0.12988491f, 
    0.62649161f, 0.65121049f, 0.16645893f, -0.16899538f, -0.31999004f, -0.37955779f, -0.28728232f, 0.81677550f, 
    0.06509589f, 0.56527692f, 0.39530563f, -0.20989318f, 0.31927976f, 0.54910129f, 0.51887196f, -0.14354637f, 
    -0.71117383f, -0.13952760f, -0.70568860f, 0.08299302f, 0.64889157f, 0.25920725f, -0.05261462f, 0.71687073f, 
    0.24212164f, 0.56102139f, -0.43800378f, 0.58700359f, 0.22515786f, 0.35243282f, 0.25741282f, 0.16534381f, 
    0.21374097f, 0.20614715f, -0.61532927f, -0.05602552f, -0.26530045f, -0.54732823f, 0.11136724f, 1.23337650f, 
    -0.11809585f, -0.08294111f, -0.22414906f, 0.32836258f, -0.54834998f, -0.57509452f, 0.03808709f, 0.45249000f, 
    0.85329115f, -0.52982539f, -0.41887420f, -0.28084639f, 0.15195934f, -0.56540918f, 0.58312923f, 0.30358306f, 
    0.17700672f, 0.59420055f, -0.38633752f, 0.44562125f, 0.06816584f, 0.46835116f, 0.72499526f, 0.41661796f, 
    -0.96529049f, 0.59754223f, -0.16346513f, 0.24705581f, -0.05267218f, -0.28048366f, -0.11583747f, 0.34834629f, 
    0.58349329f, -0.23736337f, -0.73158568f, 0.89105105f, 0.02654682f, -0.28314790f, -0.34947166f, 0.64724064f, 
    0.54216343f, 0.47112629f, 0.15166058f, 0.55028814f, -0.00415189f, 0.33087867f, -0.37233043f, 0.07096054f, 
    0.46396267f, -0.58503330f, 0.62145805f, 0.56044948f, -0.38638467f, -0.51191527f, 0.47822502f, 0.40347341f, 
    -0.34623477f, -0.23445456f, -0.19291115f, 0.04567317f, -0.47578931f, -0.27936786f, -0.64084953f, -0.01260889f, 
    -0.58435243f, 0.66546696f, 0.48178837f, 0.58092439f, -0.24156636f, -0.12512520f, -0.49303091f, -0.64783686f, 
    0.14813349f, 0.42084479f, 0.45131657f, -0.35090610f, -0.26059803f, -0.28584173f, 0.52311486f, 0.42439359f, 
    0.17831515f, 0.43319589f, 0.35871592f, -0.87553668f, 0.05930541f, 0.54594940f, 0.74874067f, -0.55792248f, 
    -0.72446692f, -0.47819227f, -0.08322347f, 0.17763452f, -0.43015003f, 1.23310673f, -0.33099523f, -0.30215248f, 
    -0.14699815f, 0.12809689f, 0.27479848f, -0.18880782f, 0.49405661f, -0.14538434f, 0.29550335f, -0.61571193f, 
    -0.57004684f, -0.25575095f, -0.27633226f, -0.37725288f, -0.10522261f, -0.44604126f, -0.17234452f, 0.24959208f, 
    1.26245224f, -0.81901425f, 0.21712367f, -0.37398964f, -0.17363149f, -0.06602217f, -0.11245670f, 0.17654233f, 
    0.39096981f, -0.19077529f, -0.18671460f, -0.04171227f, 0.39079151f, 0.02472204f, 0.33160067f, 0.13462578f, 
    0.60863650f, 0.12034225f, 0.37781930f, -0.42985833f, -0.40056491f, 0.36094612f, 0.16064051f, 0.41540030f, 
    0.36490932f, 0.17813985f, -0.37954038f, -0.16235098f, -0.42910573f, -0.36972922f, -0.67608649f, -0.50535643f, 
    -0.00301251f, 0.25851053f, 0.47725087f, -0.41315234f, -0.64174825f, -0.30523267f, 0.87669629f, -0.12432249f, 
    -0.40636802f, -0.09606777f, -0.28346765f, 0.49893567f, 0.39772335f, -0.02671394f, 0.65832639f, -0.01048134f, 
    -0.66845411f, 0.33887070f, 0.08956349f, -0.32548386f, 0.27095771f, 1.24159133f, -0.74516630f, -0.73061526f, 
    0.02431942f, 0.05782333f, -0.48927256f, 0.33053076f, 0.18276922f, 0.49690431f, -0.66465402f, 0.06445302f, 
    0.65723902f, 0.28868780f, -1.05985916f, -0.36368212f, 0.02257068f, 0.15190506f, 0.03636409f, -0.50777644f, 
    0.12212506f, -0.65100485f, 0.14336568f, 0.04776162f, -0.75393009f, -0.09628069f, -0.17398305f, -0.43994924f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10907266f, -0.20833257f, 0.19008271f, -0.08854043f, 0.00402001f, 0.08731403f, -0.26970804f, -0.02773301f, 
    0.30153921f, 0.29889309f, -0.26627755f, -0.07553043f, 0.37730524f, -0.14187028f, 0.20890477f, -0.12450135f, 
    -0.17432596f, 0.18476100f, -0.01647511f, 0.38227922f, -0.09715123f, 0.28938428f, 0.22119485f, -0.04414122f, 
    0.13614868f, 0.53720325f, 0.12192308f, 0.46932083f, 0.38178992f, -0.09761745f, 0.22661896f, -0.00446881f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.06696067f, 0.00005494f, 0.04692985f, -0.09878079f, 0.13755232f, -0.08883921f, -0.02868772f, -0.00683795f, 
    0.13825598f, 0.00485562f, -0.04162966f, -0.21804550f, -0.17065689f, -0.21925154f, -0.04907057f, 0.12632437f, 
    0.03466422f, 0.09943994f, 0.15082259f, 0.27087122f, 0.50699097f, -0.23453009f, 0.04229228f, -0.03540332f, 
    -0.03398389f, 0.03201732f, 0.05669159f, -0.29924005f, -0.18354300f, -0.11555803f, 0.05034975f, -0.02336577f, 
    -0.08071361f, -0.05505087f, -0.07683719f, -0.03969598f, -0.15888900f, -0.02366828f, -0.21898362f, -0.05882976f, 
    -0.21191390f, -0.00502413f, 0.14802374f, -0.08860012f, 0.02706692f, -0.03512552f, 0.17893723f, -0.19878656f, 
    -0.11175326f, -0.11977484f, 0.03382631f, 0.04653590f, -0.00643708f, 0.08465210f, -0.37745893f, 0.16598970f, 
    -0.19336148f, -0.00965259f, -0.06877796f, -0.19834799f, 0.03704291f, -0.13258137f, 0.33080277f, 0.05648720f, 
    -0.05106369f, -0.25398231f, -0.10725392f, 0.12297366f, 0.04180751f, 0.12461060f, -0.05841446f, -0.15269020f, 
    -0.07618072f, 0.38899672f, 0.44191208f, 0.00721559f, 0.12791446f, -0.07747328f, -0.00683987f, 0.12419669f, 
    0.23367147f, 0.08118441f, 0.01154501f, -0.05858417f, 0.04096454f, 0.03674095f, 0.02500341f, 0.12431142f, 
    -0.10087606f, -0.02481764f, -0.07183250f, -0.40952441f, 0.03841245f, -0.28867197f, -0.17454612f, -0.08339341f, 
    -0.08284353f, -0.17706504f, 0.02947956f, -0.25538868f, -0.40451458f, 0.07798242f, -0.40648237f, 0.04054826f, 
    -0.05876113f, -0.10047416f, -0.00438799f, 0.13773389f, 0.23380113f, 0.13539506f, -0.04776539f, 0.06054064f, 
    0.04431731f, 0.07646116f, 0.04552957f, 0.05532644f, 0.08455919f, -0.11864258f, -0.38959643f, -0.31720665f, 
    -0.03402906f, 0.09192747f, -0.05769620f, 0.08224787f, 0.01871840f, 0.01190591f, -0.19436841f, -0.02813797f, 
    -0.07209910f, 0.12259533f, 0.18065889f, -0.03970074f, -0.01410100f, 0.04598629f, 0.21256948f, -0.15750009f, 
    -0.09277029f, 0.06883737f, -0.00793035f, -0.05115101f, -0.01535907f, 0.08261798f, 0.13394807f, -0.02558628f, 
    -0.26636007f, -0.50789756f, -0.13863005f, -0.17213801f, 0.07055852f, -0.13349426f, 0.05433916f, 0.01667161f, 
    -0.00934567f, -0.14689116f, -0.44970557f, -0.30492869f, -0.00156628f, 0.01769815f, -0.00790828f, 0.03367362f, 
    0.07184391f, -0.06095475f, 0.18128976f, -0.05430358f, -0.26111844f, -0.05005898f, -0.09730999f, 0.16455543f, 
    0.01577573f, 0.02920992f, -0.17174816f, 0.25945154f, 0.17581555f, 0.47739246f, -0.03068482f, 0.00308405f, 
    0.05943489f, -0.15897150f, 0.01672857f, 0.28963599f, -0.25385207f, -0.43746400f, -0.40204585f, -0.02243657f, 
    0.07939675f, -0.17491536f, 0.15317252f, 0.07691949f, 0.03232908f, -0.08265039f, 0.24621330f, -0.18016446f, 
    -0.06414210f, 0.11184957f, 0.10715786f, -0.07920049f, -0.22143263f, 0.19778748f, -0.00546102f, -0.14724950f, 
    -0.10773743f, -0.07456987f, 0.07157009f, -0.09858562f, 0.01702625f, -0.06747883f, -0.01080293f, 0.05450930f, 
    0.07757115f, -0.30705443f, 0.12164992f, -0.13168623f, -0.15131927f, 0.21359891f, -0.04419183f, 0.03073075f, 
    0.09370679f, 0.22968622f, -0.01374321f, -0.11691359f, -0.10728335f, -0.05127989f, 0.11885029f, -0.00046507f, 
    0.12940125f, 0.14920427f, 0.32992515f, 0.06357042f, -0.04562253f, 0.13938211f, 0.23486406f, 0.09563139f, 
    0.05153193f, 0.14672856f, -0.21332921f, -0.14599304f, -0.24151972f, 0.02658734f, -0.11198307f, -0.05558575f, 
    -0.05195665f, 0.11089404f, -0.07168182f, -0.04549340f, 0.09372567f, 0.17861061f, -0.11712129f, 0.18086703f, 
    -0.04860498f, 0.08487099f, 0.12383217f, 0.00516780f, 0.04024549f, 0.08387037f, 0.00392398f, 0.10938350f, 
    0.18675293f, 0.16038376f, 0.11266841f, -0.03268015f, 0.15557005f, 0.12959205f, 0.41275352f, -0.21285731f, 
    -0.10100478f, 0.00472044f, -0.28429538f, 0.02803950f, -0.02215698f, 0.12978631f, -0.36034125f, -0.52409327f, 
    -0.11245432f, -0.08276702f, 0.06090877f, -0.10769103f, 0.37262249f, -0.01220643f, 0.03471098f, -0.26831567f, 
    -0.06665447f, -0.13557041f, -0.16754211f, -0.16193731f, 0.01897988f, -0.16394700f, 0.03653622f, -0.01276940f, 
    -0.02365716f, -0.00559161f, -0.02176584f, -0.00815185f, 0.02695379f, 0.00650232f, -0.01481252f, 0.04989197f, 
    0.02781290f, -0.01933950f, -0.02155778f, 0.01674281f, 0.04947687f, 0.01559496f, -0.01588955f, -0.03047790f, 
    -0.03660949f, -0.04679067f, -0.04655984f, -0.04086051f, -0.06289358f, -0.04013085f, -0.04766279f, -0.05268572f, 
    -0.04714679f, 0.02292535f, -0.05212292f, 0.05193707f, 0.02344724f, 0.03767270f, 0.04097813f, -0.05650944f, 
    -0.02566409f, 0.00416513f, 0.03327074f, -0.02296141f, -0.05958676f, -0.01937851f, -0.00136298f, -0.05149975f, 
    0.04207560f, -0.03623373f, 0.01975260f, -0.02205502f, -0.01536923f, -0.05325390f, -0.00039449f, -0.03508969f, 
    -0.02421899f, -0.05824240f, 0.01456783f, -0.02813659f, -0.01004755f, 0.02945350f, -0.03995928f, -0.05063687f, 
    0.01549671f, -0.02474084f, 0.02385731f, 0.03184935f, -0.01534543f, 0.02124937f, -0.03652906f, 0.04441831f, 
    0.03583283f, -0.01168550f, 0.04055924f, -0.05458380f, -0.05982045f, -0.04086005f, -0.00976277f, -0.01202309f, 
    0.01568088f, 0.02245904f, 0.03886285f, -0.00136976f, 0.01389754f, -0.06364139f, 0.03002527f, -0.00490944f, 
    -0.04605426f, -0.05859200f, 0.00415628f, -0.04902887f, -0.01793474f, 0.04235734f, -0.04393559f, -0.05181103f, 
    0.05212862f, 0.03535628f, 0.01100653f, -0.03611687f, -0.04955509f, -0.05678058f, 0.03135218f, 0.00275722f, 
    -0.03229983f, -0.04734604f, 0.05089919f, 0.05365361f, 0.03432120f, -0.01663385f, -0.06053820f, 0.00397215f, 
    0.01912007f, -0.03374537f, 0.04197320f, 0.02794161f, 0.00047922f, 0.04013538f, 0.01574206f, -0.03493930f, 
    0.01213482f, -0.01840703f, -0.05517273f, 0.03699974f, 0.03641176f, 0.03880225f, -0.05318456f, -0.03953022f, 
    0.03602142f, -0.04491608f, 0.02158847f, -0.06259532f, -0.02312290f, -0.03569376f, 0.00484037f, 0.05480937f, 
    0.04015156f, 0.02430815f, -0.02577653f, -0.01772261f, 0.01850387f, -0.02769625f, 0.02639692f, 0.01310996f, 
    -0.03467720f, -0.05590071f, 0.01058618f, 0.04876641f, -0.05072550f, -0.00014815f, 0.03394732f, -0.01341813f, 
    -0.02650185f, 0.01849111f, -0.00750925f, -0.04956969f, -0.03330042f, -0.00447927f, 0.00605195f, -0.06350409f, 
    0.01767167f, -0.04140260f, 0.05339934f, -0.00799561f, -0.02861924f, -0.04525071f, -0.02525474f, 0.04088456f, 
    -0.03132031f, 0.03108111f, -0.04528191f, -0.02472708f, -0.01965781f, 0.03121038f, -0.01858938f, 0.04453220f, 
    -0.03534195f, 0.04517129f, 0.00982325f, -0.02580432f, 0.01655785f, -0.04597072f, 0.01996641f, -0.06191339f, 
    0.02778614f, -0.05711725f, 0.04636779f, -0.03406018f, -0.02728003f, -0.04120762f, -0.05014466f, 0.03303534f, 
    -0.05084484f, 0.00702004f, 0.03795564f, -0.05647710f, -0.04483600f, 0.00668973f, -0.04345965f, 0.03181617f, 
    -0.02204165f, -0.02215433f, 0.00643910f, 0.02361492f, -0.04930472f, 0.02463005f, -0.02904497f, 0.04852888f, 
    0.05327022f, -0.01050461f, 0.00374540f, -0.01787773f, 0.00773656f, -0.03696154f, 0.06641520f, -0.01832325f, 
    0.04168691f, -0.01286865f, -0.03524061f, 0.04174084f, -0.00870067f, 0.04326200f, 0.05190647f, -0.05930326f, 
    -0.06342035f, -0.01751774f, -0.05739562f, 0.02062125f, 0.02307486f, 0.02795304f, 0.02026982f, -0.00035884f, 
    0.00921393f, -0.04767463f, -0.00542264f, -0.02869234f, 0.04105326f, 0.00332392f, -0.00988491f, 0.02231436f, 
    -0.00896687f, -0.05315521f, -0.01708865f, -0.04254674f, -0.04297238f, 0.05529156f, 0.01594072f, 0.00777099f, 
    -0.04136091f, -0.01480193f, -0.00707705f, -0.04233911f, -0.05242998f, 0.00619877f, -0.02558168f, -0.03076536f, 
    -0.03512998f, 0.03415718f, -0.04471884f, -0.00095299f, -0.03905394f, -0.05268792f, 0.04692242f, 0.02987652f, 
    0.04033225f, 0.00850695f, -0.01099835f, -0.04185940f, 0.04549979f, -0.04852619f, -0.06201440f, 0.01013481f, 
    0.00485911f, 0.03911562f, 0.00263901f, 0.03680784f, -0.01932220f, -0.03985779f, 0.01175215f, 0.01304466f, 
    -0.01319138f, 0.00444433f, -0.05072785f, 0.02752895f, 0.03500320f, 0.04695877f, 0.03944141f, -0.00067912f, 
    -0.00096880f, -0.04816811f, 0.02631933f, -0.00188269f, 0.06339929f, -0.04784371f, -0.02556076f, 0.00049457f, 
    -0.13042036f, -0.07111872f, -0.05751266f, 0.02602762f, -0.02804052f, 0.09144626f, -0.04870550f, -0.02990482f, 
    0.04925602f, -0.21458438f, -0.06783509f, -0.15529168f, -0.03244246f, -0.19691110f, -0.07542808f, 0.08970551f, 
    0.07458769f, 0.03417271f, 0.19566834f, -0.07657426f, 0.05256384f, 0.03304967f, 0.18314108f, 0.03534938f, 
    0.13363557f, 0.11990043f, -0.03421264f, 0.06550120f, 0.25027969f, -0.10897420f, -0.08474170f, 0.14318572f, 
    0.07905073f, -0.28376490f, 0.03978859f, 0.20324038f, 0.10290256f, -0.02545167f, -0.28185540f, -0.12123163f, 
    0.11513763f, 0.08761651f, -0.01842989f, 0.22971101f, -0.06168218f, -0.36823380f, -0.06039438f, -0.17703050f, 
    0.16817610f, 0.01396475f, -0.10771421f, 0.14680845f, 0.08440697f, 0.06411722f, -0.33889806f, -0.18524915f, 
    0.08187680f, 0.13924234f, -0.18121491f, -0.15865763f, -0.08096766f, -0.01149252f, -0.18598738f, -0.35526991f, 
    -0.15856545f, 0.12852763f, 0.05249804f, 0.05443288f, 0.01244747f, -0.03348855f, -0.10144907f, 0.09174164f, 
    -0.09621620f, -0.07472871f, -0.11545934f, 0.01568953f, 0.10992608f, 0.16115357f, 0.02358703f, 0.13927631f, 
    0.15576683f, -0.02289181f, -0.14160118f, -0.09451935f, -0.14134580f, -0.01573359f, 0.00934271f, 0.02557395f, 
    0.06365607f, 0.06075463f, -0.22964267f, -0.23797891f, 0.13877603f, 0.07803677f, -0.07995808f, -0.22764134f, 
    0.00328877f, 0.09860083f, 0.09225862f, 0.19875547f, -0.05695981f, -0.07792181f, -0.05565450f, -0.10014355f, 
    0.12239105f, 0.06806062f, 0.27173099f, -0.03654243f, 0.09001178f, -0.18684690f, 0.00360363f, -0.14239359f, 
    -0.03895716f, 0.03556366f, 0.03632635f, 0.13871875f, 0.04656231f, -0.23091680f, -0.24863064f, 0.56455016f, 
    -0.03389267f, -0.02761073f, -0.21929042f, 0.22388206f, 0.02559387f, 0.05903160f, -0.34662142f, -0.14752533f, 
    0.06827188f, -0.04885044f, 0.12086025f, -0.21911426f, 0.13187765f, 0.04618501f, 0.09474980f, -0.18419528f, 
    -0.15595125f, 0.27095583f, 0.10859931f, -0.11599594f, -0.00387369f, -0.02222588f, -0.12000950f, 0.11427034f, 
    -0.47771826f, 0.19976625f, -0.10583107f, 0.06637923f, -0.03258215f, 0.01332266f, 0.01485046f, -0.14151309f, 
    0.22050476f, 0.10506479f, 0.28087065f, 0.09442740f, -0.03047463f, 0.09348938f, -0.15698940f, 0.02290544f, 
    0.05280307f, -0.16959427f, 0.07152973f, 0.09880668f, -0.31937584f, 0.12946580f, -0.01075862f, -0.11108337f, 
    -0.09928823f, -0.05032402f, 0.10346890f, 0.09839200f, -0.13587284f, -0.00894536f, 0.11877986f, 0.17182235f, 
    -0.05254164f, 0.10838350f, 0.04506242f, -0.10053190f, -0.31686980f, 0.02714089f, -0.05627155f, 0.01893611f, 
    0.05861143f, -0.10926953f, -0.17701280f, -0.07712419f, 0.10446911f, 0.11571318f, 0.11489795f, -0.22543713f, 
    0.08943564f, 0.00934435f, -0.04138083f, 0.07020036f, 0.14067584f, 0.09237720f, 0.08048385f, 0.08998845f, 
    0.18361914f, -0.18204026f, -0.00420078f, -0.08305559f, 0.14260219f, 0.04854343f, -0.23323631f, 0.03770621f, 
    -0.11342920f, -0.38678643f, 0.05723568f, 0.12998134f, -0.09117464f, 0.06241628f, 0.08807353f, -0.10259075f, 
    0.08259913f, -0.17533770f, 0.06826480f, -0.08794211f, 0.01990823f, -0.04066592f, 0.11360240f, -0.02616650f, 
    0.06228349f, 0.06882001f, -0.17195697f, -0.03457836f, -0.06386810f, 0.13119331f, 0.15891825f, 0.16340761f, 
    0.01682036f, 0.07244961f, 0.04187907f, 0.26278770f, 0.24038057f, 0.00221945f, 0.07368272f, -0.04996685f, 
    0.12679598f, -0.05487860f, -0.02991064f, 0.24512777f, 0.13632876f, 0.10086790f, 0.09336471f, 0.20723261f, 
    -0.05595241f, 0.01105529f, 0.02054002f, 0.07046242f, -0.18152349f, -0.09214715f, 0.14282261f, -0.26237512f, 
    0.13878496f, 0.07920483f, -0.02757036f, 0.04939745f, 0.06018407f, 0.07836307f, 0.01671445f, -0.02730650f, 
    -0.09171384f, 0.06768328f, 0.01373820f, 0.05227100f, 0.07059332f, 0.06483267f, 0.00737851f, 0.18895994f, 
    -0.27838454f, -0.13207361f, 0.13891722f, -0.04734356f, -0.02192882f, -0.07063175f, 0.02601762f, 0.05415519f, 
    0.25162101f, 0.02596134f, -0.05100074f, -0.00125674f, 0.00843836f, 0.17250194f, 0.00998792f, -0.15653503f, 
    0.03188565f, 0.02751439f, -0.04247966f, 0.00421870f, -0.00669167f, -0.03531530f, -0.03356965f, -0.02542228f, 
    0.01657916f, 0.04141279f, -0.01900964f, -0.01378998f, -0.05088755f, -0.02137492f, 0.03032956f, -0.00654972f, 
    -0.03131311f, -0.02524738f, -0.04743573f, 0.00671205f, -0.05255704f, -0.03690812f, 0.03499004f, -0.04633561f, 
    -0.01384824f, 0.00404592f, 0.03892112f, -0.04007307f, -0.00789147f, 0.00737543f, -0.00650151f, -0.03783475f, 
    0.02314798f, 0.00334756f, 0.04376626f, -0.00729885f, -0.00260197f, -0.02313644f, -0.02865504f, -0.01430537f, 
    -0.06238254f, -0.01693881f, 0.04728936f, -0.01247433f, 0.04224819f, -0.01022658f, -0.05564907f, 0.03145121f, 
    0.02794170f, -0.04961835f, -0.03315717f, -0.04051263f, 0.00539312f, 0.04158965f, 0.00056665f, -0.06090907f, 
    -0.02083959f, -0.05165121f, 0.01764655f, -0.03472396f, -0.01912720f, 0.04455498f, -0.03447785f, 0.02655794f, 
    0.01577494f, -0.02696513f, 0.04014288f, 0.00843548f, -0.02346734f, -0.03793053f, -0.01210667f, -0.02350083f, 
    -0.00608181f, -0.02552023f, 0.01593865f, -0.04303062f, 0.02845959f, 0.00016775f, -0.03665377f, 0.04207069f, 
    0.04682701f, -0.04150802f, -0.01560870f, -0.00233859f, -0.06220755f, 0.04178911f, -0.03611894f, -0.03167260f, 
    -0.04922935f, -0.03843660f, 0.03400744f, -0.04374325f, 0.04922481f, 0.01807574f, -0.06304196f, -0.02929179f, 
    -0.05914694f, 0.04792253f, 0.04231147f, 0.01572878f, 0.04391214f, 0.01336202f, -0.02432989f, -0.03361544f, 
    0.00741839f, -0.03027048f, 0.04287503f, -0.03344872f, -0.00072177f, 0.04484499f, 0.03789242f, -0.01442889f, 
    0.04601504f, 0.01628333f, -0.05816051f, 0.03708179f, 0.00413775f, -0.01442343f, -0.03217992f, -0.01398942f, 
    -0.05759046f, -0.05076619f, -0.05692244f, 0.05260796f, 0.04794309f, -0.02393899f, -0.03611906f, 0.04779098f, 
    -0.01603765f, -0.05851636f, -0.01628023f, -0.02413135f, 0.04921320f, -0.06440061f, 0.00156126f, -0.03066968f, 
    -0.04641911f, 0.03146462f, -0.06031175f, 0.03007702f, -0.04341790f, -0.01175785f, 0.03704181f, 0.04786048f, 
    -0.04434279f, 0.01335221f, -0.02281553f, 0.02639654f, -0.00302594f, -0.05988479f, -0.03193566f, -0.05021819f, 
    0.02624597f, 0.01508100f, -0.04445057f, -0.04983261f, 0.03955513f, 0.01519089f, -0.00453097f, -0.05934713f, 
    -0.02414617f, -0.00097249f, 0.00380863f, 0.04542925f, -0.02727894f, 0.03760260f, -0.04332035f, -0.01774800f, 
    0.03388211f, -0.04452548f, -0.00913467f, -0.03488053f, 0.01590292f, 0.03785734f, -0.02950548f, -0.05876300f, 
    -0.05864187f, 0.02051735f, -0.03043828f, -0.05815241f, 0.00468867f, 0.04770458f, -0.05701578f, -0.01094347f, 
    -0.05099039f, -0.03950742f, 0.01961412f, -0.04752146f, -0.00123797f, -0.03833385f, -0.00500642f, 0.00626084f, 
    -0.01863405f, -0.02111532f, 0.00511468f, -0.01051997f, 0.04969725f, -0.02015768f, -0.03351016f, -0.01395371f, 
    -0.03778439f, 0.01877031f, -0.05710495f, -0.06113310f, -0.06172434f, 0.05202327f, -0.04054000f, 0.02947223f, 
    -0.04734757f, -0.04236769f, 0.04877685f, -0.04932142f, -0.06007954f, 0.00570990f, 0.02461066f, -0.04169068f, 
    0.04578212f, -0.00990562f, -0.00449251f, 0.04827009f, 0.00876841f, 0.02672351f, -0.05158222f, -0.03516897f, 
    0.00950125f, 0.01587736f, 0.03722042f, -0.02547298f, 0.02944081f, -0.05123080f, 0.01442015f, -0.03169433f, 
    0.04526697f, -0.03420733f, -0.03519237f, -0.05352406f, 0.02154564f, 0.00132959f, 0.00310082f, -0.02841966f, 
    -0.01162060f, 0.01021335f, 0.02901995f, -0.05715286f, 0.01822594f, -0.05480799f, 0.02039683f, 0.02320440f, 
    0.01776894f, -0.06051959f, -0.05417401f, -0.03206031f, -0.01442368f, 0.03710261f, 0.01846562f, -0.05400451f, 
    0.01126819f, -0.01018706f, -0.04064659f, 0.02074654f, -0.00140612f, 0.00238370f, -0.03671904f, -0.03553145f, 
    -0.00927399f, -0.01138950f, 0.00612868f, -0.04939239f, 0.00514749f, 0.03323673f, -0.01162499f, -0.05718063f, 
    0.00248571f, -0.01947306f, -0.04142799f, 0.01236624f, -0.00407369f, -0.00613239f, 0.00733837f, -0.05757676f, 
    0.04127195f, -0.01333639f, 0.00530950f, 0.00399730f, 0.02885658f, 0.03062642f, -0.03017708f, -0.04694181f, 
    0.03939793f, -0.00265268f, -0.02816826f, -0.03205591f, 0.01765708f, -0.04285299f, -0.03198430f, 0.04155368f, 
    -0.06265344f, 0.04897536f, -0.00754148f, -0.00485529f, -0.05173723f, 0.01164230f, 0.01399812f, 0.00750712f, 
    0.03806404f, 0.03409407f, -0.05329059f, 0.04551304f, 0.01700300f, -0.05090282f, -0.06269182f, -0.01549341f, 
    -0.02013579f, -0.06446431f, 0.01778635f, 0.02609087f, 0.02955027f, -0.00727090f, -0.02364072f, -0.02085282f, 
    -0.04153666f, -0.03968425f, 0.03840831f, 0.04857147f, -0.02144739f, -0.04348228f, 0.03087584f, -0.05831047f, 
    -0.06398036f, 0.00323006f, 0.05062805f, -0.06460916f, 0.04640658f, -0.00261765f, 0.03810406f, 0.01991989f, 
    -0.06051833f, -0.04469895f, 0.02578490f, -0.05522554f, 0.02792283f, -0.04010738f, 0.00810682f, -0.02273291f, 
    0.05845328f, 0.03143879f, -0.05300405f, 0.01839109f, -0.01423800f, -0.01978588f, -0.03709565f, -0.02097296f, 
    0.01216344f, -0.02292353f, -0.04876753f, -0.00378009f, -0.04984483f, 0.03290522f, 0.04318797f, -0.02796946f, 
    -0.03546790f, -0.02404467f, 0.04021890f, -0.02587825f, -0.02786607f, -0.02523898f, 0.00083816f, -0.04356084f, 
    -0.02967774f, -0.02169093f, -0.02666970f, 0.04418273f, -0.05719067f, -0.03181509f, -0.00457341f, -0.05446035f, 
    -0.01800699f, -0.03184072f, -0.01131679f, -0.05442274f, 0.04231140f, 0.03920242f, 0.00844945f, -0.03139710f, 
    -0.02180461f, 0.04130941f, -0.02806591f, -0.03553361f, -0.02990515f, 0.00038372f, -0.00462892f, -0.02310165f, 
    -0.02419517f, 0.03995719f, -0.05942110f, -0.05728845f, 0.05068099f, 0.00374164f, 0.00258990f, -0.03326662f, 
    -0.02296948f, 0.04046504f, 0.00835375f, 0.02512187f, -0.01565274f, 0.03775539f, 0.03465341f, -0.04176378f, 
    -0.06115960f, -0.02657126f, -0.04146598f, 0.03608922f, -0.01433714f, -0.02602520f, -0.06137615f, 0.04363279f, 
    0.00225418f, -0.02919317f, 0.03548438f, 0.01865912f, -0.06018955f, -0.01162321f, 0.05084100f, 0.05061678f, 
    0.04998078f, -0.01496166f, 0.00843180f, -0.02572323f, 0.02247842f, 0.01249379f, -0.00587835f, 0.04757066f, 
    0.01934345f, -0.03845439f, -0.03952367f, -0.03682537f, -0.03145595f, 0.00931684f, 0.03721209f, 0.03577491f, 
    -0.06159859f, -0.01556038f, -0.03184856f, 0.03839437f, 0.01253727f, -0.02873457f, -0.00130385f, 0.01570031f, 
    0.03623985f, 0.02571273f, 0.00664662f, 0.01724350f, 0.03042573f, 0.05236294f, -0.00662453f, -0.05507979f, 
    -0.03775272f, -0.05522439f, 0.01781858f, 0.01666849f, -0.04208439f, 0.03014165f, 0.01252092f, -0.01144870f, 
    -0.06446219f, -0.01580813f, 0.03965878f, -0.01179366f, -0.05874594f, -0.06046642f, 0.00468738f, -0.02356133f, 
    -0.01313975f, -0.00699958f, -0.04371160f, -0.04442970f, -0.01852596f, -0.05601066f, 0.03976303f, -0.00388976f, 
    -0.01677514f, -0.05177350f, -0.05856821f, -0.03842554f, 0.01303003f, -0.04902709f, 0.02484298f, -0.04147843f, 
    0.00128929f, -0.05383001f, -0.00383266f, 0.03983358f, -0.05910030f, -0.01939472f, -0.04418072f, -0.05763579f, 
    -0.05513065f, -0.02039562f, -0.05472828f, 0.02347876f, -0.02902937f, -0.05770747f, 0.02188823f, -0.00219442f, 
    -0.04643989f, 0.00682091f, 0.03572506f, 0.01429576f, -0.04429898f, -0.01991213f, 0.01209454f, -0.03593638f, 
    -0.05801843f, -0.04252008f, 0.01170270f, -0.04776001f, -0.00610148f, 0.04134117f, -0.06457968f, -0.00087834f, 
    -0.06519879f, 0.00994308f, -0.00675137f, 0.02858200f, -0.05333885f, -0.05028018f, 0.03564126f, -0.01188304f, 
    -0.00478082f, 0.04679834f, -0.00822622f, 0.02677444f, -0.00161948f, 0.02253622f, -0.01470764f, -0.04696791f, 
    0.04135511f, -0.06202827f, 0.03626095f, -0.04751284f, -0.02806114f, 0.05684502f, 0.03884515f, -0.04630094f, 
    -0.02246646f, -0.03658286f, -0.01002923f, 0.00208922f, -0.05987704f, -0.05487624f, -0.03232159f, -0.04728367f, 
    0.05211178f, -0.00936989f, -0.03304020f, 0.02726306f, -0.05050599f, -0.04209793f, 0.03154454f, 0.01268982f, 
    -0.05111691f, -0.05358996f, 0.04399333f, 0.03226998f, 0.02193924f, -0.06262914f, -0.02480505f, 0.01330524f, 
    0.04449503f, 0.03923262f, -0.04576790f, -0.00689582f, -0.04654172f, 0.04635629f, 0.03711361f, -0.05832954f, 
    -0.02983795f, -0.03917002f, 0.01351509f, -0.01727617f, 0.03832289f, -0.03170408f, -0.01686043f, -0.02024125f, 
    -0.04549856f, -0.04473921f, 0.00082337f, -0.00521691f, -0.03410091f, 0.01058645f, 0.03786720f, -0.06327387f, 
    0.01500958f, -0.01914824f, -0.00352023f, -0.05799150f, -0.05157901f, -0.03079875f, 0.04771792f, 0.04577828f, 
    -0.00723270f, -0.02118138f, -0.00899143f, -0.00634675f, 0.00722149f, 0.01157270f, -0.05603573f, -0.04798748f, 
    -0.05028895f, 0.02672499f, -0.02242784f, 0.02838090f, -0.03943111f, -0.02270559f, 0.02748069f, -0.01078700f, 
    -0.06247343f, -0.00242018f, 0.02197738f, -0.01736337f, 0.04398239f, 0.01000865f, 0.02325851f, -0.05359101f, 
    -0.01950355f, 0.03855959f, 0.03705361f, 0.00349854f, 0.03852516f, 0.01156951f, 0.03301566f, 0.03449025f, 
    0.01450894f, -0.04293385f, -0.05172233f, -0.05572090f, 0.04357617f, 0.04876112f, 0.04147198f, -0.00480748f, 
    -0.05790389f, -0.02485157f, -0.03604313f, -0.06215243f, -0.03227161f, 0.01284370f, -0.02797159f, -0.03402388f, 
    -0.05440167f, -0.01110623f, -0.06282553f, -0.03984753f, -0.00869355f, -0.02555795f, -0.06675182f, 0.01613257f, 
    -0.01272877f, 0.02198809f, -0.05473399f, -0.00747843f, -0.06074189f, -0.06737661f, -0.05884759f, -0.05272031f, 
    -0.05058533f, -0.04756419f, 0.02339995f, 0.02429450f, 0.01911324f, 0.02354092f, -0.01750993f, -0.04721551f, 
    0.05095739f, 0.01719876f, 0.00675031f, -0.05330411f, -0.04392804f, -0.06497209f, 0.03753945f, -0.05627913f, 
    -0.01885178f, -0.04463034f, -0.01102227f, -0.06572583f, -0.06056508f, -0.00682477f, -0.04188938f, 0.02273299f, 
    -0.01666190f, -0.05977423f, 0.03760806f, 0.01274177f, -0.04736585f, 0.00613653f, 0.04232217f, 0.00740738f, 
    -0.03662331f, 0.01234931f, 0.03848826f, 0.03917671f, 0.03643921f, -0.01402423f, 0.03452352f, 0.01112771f, 
    -0.03112107f, -0.01583446f, -0.05579823f, 0.00493967f, 0.03993957f, -0.05964906f, -0.04889156f, 0.04465851f, 
    -0.05726888f, 0.03287777f, 0.02873608f, 0.00676528f, 0.03860527f, 0.05019889f, -0.05634532f, 0.00080867f, 
    0.04736498f, -0.00400745f, -0.04844944f, 0.02740027f, 0.04245796f, 0.01736812f, 0.00916120f, -0.04155693f, 
    -0.04241854f, -0.01810605f, -0.01715392f, 0.00387260f, 0.01661897f, 0.05104971f, -0.01648968f, 0.03489677f, 
    -0.05673690f, -0.06274537f, -0.00215841f, -0.02290541f, -0.03798153f, 0.00090060f, -0.01643852f, -0.02649684f, 
    0.01121929f, 0.00646887f, -0.03291051f, 0.01420231f, 0.02840287f, -0.00906753f, 0.03560190f, 0.01615978f, 
    0.03373865f, 0.03118842f, 0.03526895f, -0.00315793f, -0.02262068f, 0.00771351f, 0.04521488f, -0.03851867f, 
    0.00077933f, 0.02707258f, -0.03306660f, -0.02979841f, 0.02519476f, 0.01293507f, -0.00631403f, 0.01347261f, 
    -0.02317984f, 0.03278055f, -0.03649870f, -0.05713623f, 0.03233271f, 0.00964390f, -0.00291747f, 0.01356218f, 
    0.03513601f, -0.02045195f, -0.04057858f, -0.06539068f, 0.02767097f, 0.01252812f, -0.01991864f, -0.02134382f, 
    -0.00234160f, -0.00079909f, 0.03329010f, -0.02179208f, 0.00647165f, -0.06110046f, -0.00954507f, 0.03368181f, 
    -0.03856109f, -0.02965959f, -0.00450086f, -0.00303632f, 0.00483966f, -0.01309629f, 0.03773494f, 0.00481404f, 
    -0.00074759f, 0.01945324f, 0.00140611f, 0.00703304f, -0.03446400f, 0.00876231f, 0.01817318f, 0.00292494f, 
    0.02583469f, 0.02287036f, -0.04667468f, -0.06626838f, 0.04836236f, 0.02196909f, -0.04032005f, -0.02879669f, 
    0.04627126f, -0.00661874f, 0.03371216f, -0.01324589f, 0.04456324f, 0.00559480f, -0.03198365f, 0.02008584f, 
    -0.02895030f, -0.06110904f, 0.03485561f, 0.04615533f, -0.03966069f, -0.01708454f, 0.04068446f, -0.05502415f, 
    0.04380484f, -0.01754549f, -0.04532147f, -0.05448454f, -0.04413446f, 0.01408238f, -0.04864829f, -0.01447989f, 
    0.03412614f, -0.05897615f, -0.05865616f, 0.02776025f, -0.03388599f, 0.00283026f, 0.03507937f, 0.00017825f, 
    0.02933157f, -0.06337380f, 0.02282849f, -0.04012204f, 0.00625431f, -0.04509956f, 0.05022969f, -0.04351994f, 
    -0.01605936f, -0.03607380f, -0.04573672f, 0.03830783f, 0.03170013f, 0.04334432f, -0.03833266f, 0.02220802f, 
    -0.03049167f, -0.00629364f, 0.01534090f, -0.01897908f, 0.03731099f, 0.01280722f, -0.00077363f, 0.02024111f, 
    -0.05868915f, 0.02125149f, -0.06024450f, 0.04255074f, -0.05707499f, -0.00521291f, -0.04040826f, 0.03438161f, 
    -0.06110522f, -0.02368846f, 0.03070095f, 0.02495079f, -0.05967252f, -0.01766974f, -0.00318758f, -0.05223525f, 
    -0.01207358f, 0.01951613f, -0.06658945f, 0.04007103f, -0.03666472f, 0.01951882f, 0.01149318f, -0.05623794f, 
    -0.04818276f, -0.00313131f, 0.00629149f, -0.06692059f, -0.02575873f, 0.01556304f, -0.04616273f, -0.02840243f, 
    -0.02864086f, 0.00963215f, 0.04842872f, 0.03773694f, -0.02066151f, -0.03033014f, 0.04744494f, 0.03212588f, 
    -0.06253178f, -0.00339226f, 0.01154450f, 0.00448945f, 0.00191285f, -0.06603925f, 0.01269551f, -0.03878896f, 
    0.04571668f, -0.00831337f, -0.04068291f, 0.03409350f, 0.02986132f, -0.04361381f, -0.00310592f, -0.03305338f, 
    -0.01282789f, 0.00911933f, -0.00263669f, -0.05184254f, 0.02063670f, -0.04735763f, -0.01214804f, -0.06231014f, 
    0.03318753f, -0.02669656f, -0.04687921f, 0.00673255f, 0.01450519f, -0.02237980f, 0.00400633f, 0.01501754f, 
    -0.02801142f, -0.00491884f, 0.00544735f, -0.01119551f, 0.02931496f, 0.00561488f, -0.06075906f, 0.00423634f, 
    -0.01978322f, 0.03745827f, -0.01340340f, -0.01725655f, 0.04150846f, -0.01775637f, 0.04548596f, 0.03200402f, 
    0.00832755f, -0.04591281f, -0.04287577f, -0.04692096f, -0.02131402f, 0.01536397f, -0.00252391f, 0.02153471f, 
    -0.04055424f, -0.00887509f, -0.06055932f, -0.00632969f, 0.02303161f, 0.01107699f, 0.04332410f, 0.01949706f, 
    0.04499821f, -0.02804027f, -0.00548540f, -0.01217058f, -0.04678870f, -0.02462941f, 0.04234418f, 0.04234256f, 
    -0.01346809f, -0.02476526f, -0.00021788f, -0.03336949f, -0.03706802f, -0.03494953f, 0.00618010f, 0.00416058f, 
    -0.04975278f, -0.06645484f, 0.02348546f, -0.03216130f, 0.01674362f, -0.05795692f, 0.04062281f, -0.06661163f, 
    -0.02629052f, -0.05565546f, -0.04904331f, -0.02591318f, 0.01665943f, -0.06683235f, 0.00564543f, -0.02893954f, 
    0.03777954f, -0.00320129f, 0.03652187f, 0.04414864f, -0.05588293f, 0.04542685f, -0.06722622f, 0.03296166f, 
    0.02420530f, -0.03343226f, -0.02760114f, -0.04863071f, -0.05400209f, 0.00355523f, 0.01199741f, 0.00765829f, 
    0.00940762f, -0.04324488f, 0.00898472f, -0.01359821f, 0.01468033f, 0.03848201f, 0.04396001f, -0.00056017f, 
    0.04961034f, 0.03876278f, 0.01519001f, 0.00078842f, 0.03667849f, -0.04024933f, -0.02087744f, -0.06796607f, 
    -0.01840355f, -0.02925419f, -0.03613820f, -0.03381271f, -0.01670641f, 0.01358943f, -0.05249248f, -0.04474936f, 
    0.03104522f, 0.01079886f, 0.01447381f, 0.02283484f, 0.01252481f, -0.00312310f, -0.04088837f, -0.03732393f, 
    -0.06650535f, -0.03275747f, -0.03411071f, 0.04483117f, -0.00451620f, 0.04703073f, -0.05652341f, -0.03158608f, 
    -0.04503016f, -0.00394747f, -0.04276846f, 0.02726260f, 0.01706685f, -0.05446279f, -0.05322817f, 0.02788921f, 
    0.01386078f, 0.03111566f, 0.00894064f, 0.01605206f, -0.05384734f, -0.05234075f, -0.02196201f, -0.05937448f, 
    -0.03439444f, -0.04391831f, -0.03904240f, -0.05714734f, 0.00490002f, -0.00193076f, 0.00698856f, 0.02039207f, 
    0.03623556f, -0.02104049f, 0.03734457f, -0.03765406f, 0.03910540f, -0.00226576f, -0.03704832f, 0.01437892f, 
    0.00719440f, 0.01465899f, 0.04627362f, 0.01373646f, -0.00485393f, 0.00735570f, -0.05448497f, 0.01366671f, 
    -0.01670653f, -0.00732052f, 0.00394646f, -0.01330797f, -0.06045014f, 0.03881310f, 0.03818000f, 0.03988127f, 
    0.00776042f, 0.00013788f, 0.03019916f, -0.02565149f, 0.01899756f, -0.05355082f, -0.03666174f, -0.06882888f, 
    -0.03561177f, -0.06090743f, 0.02262362f, -0.00313144f, 0.01906260f, 0.01663096f, 0.03909263f, -0.04637412f, 
    -0.00152601f, -0.00842119f, -0.03801988f, -0.04264833f, -0.05541790f, -0.01554387f, -0.04581620f, -0.03999407f, 
    0.03504976f, 0.01797782f, 0.02962424f, -0.01685026f, 0.02381489f, -0.05834262f, 0.02405405f, 0.03709473f, 
    -0.02419319f, 0.03750954f, 0.01416462f, -0.05624693f, 0.00438419f, -0.06219349f, 0.00577350f, -0.04549632f, 
    0.17285897f, 0.07413501f, -0.10088072f, 0.07067950f, 0.05024843f, -0.03768410f, 0.12088490f, 0.00632911f, 
    0.06140464f, -0.76126856f, 0.38083589f, -0.65023607f, 0.12322113f, 0.01547979f, 0.03718719f, -0.08849178f, 
    0.00090522f, 0.02685804f, 0.37111801f, 0.07265350f, -0.07763351f, -0.00661080f, -0.02432425f, 0.07255727f, 
    0.01825985f, 0.10447116f, -0.03899217f, 0.13707228f, -0.11295429f, -0.12799938f, 0.04283015f, 0.03145367f, 
    -0.16468655f, 0.10787439f, 0.01150219f, 0.07080493f, -0.12317592f, -0.33261308f, -0.71250510f, 0.04757298f, 
    -0.25010428f, 0.17518279f, -0.02415720f, 0.04803535f, -0.06915755f, 0.13351706f, 0.11617266f, 0.04669998f, 
    0.02662003f, 0.10934282f, -0.12417369f, 0.17250434f, 0.10430145f, -0.21873035f, 0.04541384f, -0.51896620f, 
    0.08458953f, 0.23546481f, 0.22640195f, 0.04146155f, -0.01676609f, -0.08810941f, -0.00584615f, -0.42479667f, 
    0.34679538f, -0.08704595f, -0.00454209f, 0.03525054f, -0.04113093f, -0.15139076f, 0.11480822f, 0.11091354f, 
    0.09011815f, -0.09746037f, -0.23308575f, 0.07310066f, -0.00434278f, 0.16290651f, -0.00892913f, -0.05309618f, 
    -0.11781140f, -0.21323189f, 0.08366251f, -0.01374297f, 0.06276633f, 0.04338544f, 0.10532136f, 0.03036507f, 
    0.03763019f, 0.16000210f, 0.34736076f, -0.51343423f, 0.11775157f, 0.05359511f, 0.17430635f, 0.04810965f, 
    -0.09559566f, 0.16875754f, 0.09169389f, 0.25906143f, -0.11002386f, -0.09961795f, -0.00526778f, 0.01880011f, 
    -0.01446353f, 0.07775202f, 0.11819953f, -0.00842320f, 0.03469920f, 0.22162597f, 0.22536083f, 0.12637644f, 
    0.01821625f, 0.03660465f, -0.06854878f, -0.07408406f, -0.01025322f, -0.22194472f, -0.33382338f, -0.04147731f, 
    -0.35659581f, -0.04340197f, -0.03933282f, 0.04603329f, -0.04659049f, 0.17279989f, -0.30008379f, -0.01279674f, 
    0.34205702f, -0.09893182f, -0.00439152f, 0.03127400f, -0.08531652f, -0.14495486f, -0.32007539f, 0.16388862f, 
    -0.02477807f, -0.39237660f, -0.00173169f, -0.04337417f, 0.09969235f, 0.04137646f, 0.00074329f, -0.05692478f, 
    0.01251925f, -0.69576252f, -0.01861195f, 0.00610478f, 0.07446698f, -0.11558879f, 0.01919094f, 0.09640520f, 
    0.23525381f, 0.25389355f, 0.28974351f, -0.02253624f, -0.12358126f, -0.08185723f, -0.10887416f, 0.01328336f, 
    0.07937215f, 0.03182057f, -0.06668820f, -0.33780742f, -0.41811663f, 0.11500477f, -0.02411084f, 0.00113246f, 
    -0.06742355f, 0.14070888f, 0.06360523f, -0.00442194f, -0.36880484f, -0.14213762f, -0.12968330f, -0.09127981f, 
    0.10780350f, 0.08918136f, -0.10850306f, 0.08307578f, -0.34947407f, -0.06752744f, -0.09090909f, -0.35213894f, 
    0.08438095f, -0.14492312f, 0.13690066f, 0.06720652f, 0.06552459f, -0.33683622f, -0.18899578f, -0.13346572f, 
    0.03051121f, -0.24546109f, 0.11886875f, -0.06539711f, 0.14347258f, -0.11521709f, 0.19565123f, 0.14098395f, 
    0.07758474f, -0.03450713f, -0.01070207f, 0.03519455f, -0.02140375f, -0.04259957f, 0.05717272f, -0.05270214f, 
    -0.50801164f, -0.53713745f, -0.15099110f, -0.15103178f, 0.15659104f, 0.01037669f, 0.09399638f, -0.18376009f, 
    0.04564557f, -0.02725291f, -0.01627507f, -0.00942193f, -0.04754803f, 0.03502336f, 0.06876900f, 0.10286121f, 
    -0.01974880f, -0.12897682f, -0.12245700f, -0.18386410f, -0.03522857f, 0.02592201f, -0.05037855f, 0.03637900f, 
    0.12245292f, 0.05903309f, 0.32257229f, 0.23832099f, 0.04830324f, 0.06896983f, 0.07141649f, 0.02306315f, 
    0.09561918f, -0.11639775f, -0.00229996f, 0.26194376f, 0.11826178f, -0.14148289f, -0.20054626f, -0.00181745f, 
    -0.11404248f, -0.09476051f, 0.03966079f, -0.04304183f, -0.35602263f, -0.19929312f, 0.42416215f, -0.09174398f, 
    0.13824488f, -0.03428941f, -0.02104944f, -0.05156765f, -0.08232414f, 0.14251532f, 0.29238367f, -0.35092354f, 
    -0.16275670f, -0.17155677f, -0.03242895f, 0.00440042f, 0.00207844f, 0.07450178f, 0.25801888f, 0.44816118f, 
    -0.09999365f, -0.05181582f, -0.03632837f, -0.08831351f, 0.12323240f, -0.00313231f, -0.07981124f, 0.23925294f, 
    0.07465309f, -0.21203025f, -0.18347584f, -0.00709708f, -0.06747770f, 0.04992575f, 0.01134195f, -0.04632052f, 
    -0.02291110f, 0.02076475f, 0.02989326f, 0.02547072f, -0.06658652f, -0.05379296f, 0.04591323f, 0.02559597f, 
    0.02887382f, 0.00604142f, -0.06574294f, 0.01123149f, -0.03706535f, 0.01249296f, -0.05031558f, 0.00813379f, 
    -0.05676749f, 0.03409100f, 0.03422747f, -0.05412144f, 0.04347417f, 0.03259091f, 0.00527307f, -0.01144524f, 
    0.00921601f, -0.01831482f, -0.02041619f, -0.02045985f, -0.03794083f, -0.03823913f, -0.03835039f, 0.00144153f, 
    0.03676966f, -0.02306944f, -0.02938740f, -0.05502483f, -0.03117150f, -0.03324619f, -0.04425244f, -0.04540370f, 
    -0.05307910f, -0.07255921f, 0.00226978f, -0.01530726f, 0.04525525f, 0.03444781f, -0.04822541f, -0.06216422f, 
    -0.02675121f, -0.01406830f, -0.05434242f, 0.02367811f, 0.00336167f, 0.01998997f, -0.01356011f, -0.00845763f, 
    -0.05420450f, 0.01672211f, -0.00410692f, 0.03631395f, 0.00438944f, -0.03897595f, -0.01280976f, 0.00149870f, 
    -0.05043216f, 0.03828226f, 0.00891546f, 0.03383773f, -0.02473526f, -0.02025942f, -0.05978320f, -0.00346124f, 
    -0.03735184f, -0.04731798f, -0.01750445f, 0.02282383f, -0.04600969f, -0.01081790f, 0.01277314f, 0.02339907f, 
    0.04343078f, -0.05858399f, 0.03609980f, 0.03704490f, 0.04274107f, 0.00850004f, -0.02698787f, -0.00258052f, 
    0.01511906f, 0.02663892f, -0.01219125f, -0.02123719f, 0.02101579f, 0.04895902f, 0.03609772f, -0.02550371f, 
    -0.02174074f, -0.00827440f, -0.01228100f, -0.05287092f, -0.02147655f, 0.01423538f, 0.00987802f, -0.05463999f, 
    -0.03336244f, -0.05513123f, -0.02670302f, -0.05716391f, 0.04925980f, -0.06363057f, -0.00712621f, 0.01918039f, 
    -0.01178116f, -0.05262002f, 0.02686233f, 0.01356428f, -0.03219621f, 0.02841632f, 0.00780714f, 0.02423036f, 
    0.01231538f, 0.02451645f, 0.01082533f, 0.02185442f, -0.05735658f, -0.06252203f, 0.03465611f, -0.06316632f, 
    -0.04676645f, -0.06335004f, 0.02803024f, -0.03407292f, -0.04985243f, -0.03345015f, -0.03687767f, 0.01207600f, 
    0.02161418f, 0.01960817f, 0.04161904f, 0.02116544f, -0.04749753f, 0.02844042f, 0.01817697f, 0.01002834f, 
    0.02790854f, -0.04123972f, -0.02236658f, 0.00080697f, 0.04738733f, -0.05119457f, 0.01300722f, -0.02997007f, 
    -0.04296879f, -0.00358040f, 0.03031555f, 0.00468406f, -0.02255425f, -0.02884308f, 0.03645897f, -0.00689651f, 
    0.04345815f, -0.04719925f, -0.02625500f, -0.00204331f, 0.04910742f, -0.01458599f, -0.03514901f, -0.05011817f, 
    -0.02167793f, 0.00669027f, -0.05460332f, 0.02947080f, -0.00323968f, -0.03303540f, -0.01857899f, 0.04285583f, 
    0.04385616f, -0.03949231f, -0.04554902f, -0.02952020f, -0.05963756f, -0.04977895f, -0.03492145f, -0.06027130f, 
    0.04703740f, -0.00905005f, -0.01343719f, 0.02578591f, -0.02343963f, -0.01819859f, -0.02230767f, -0.02815288f, 
    -0.06258517f, 0.02220288f, -0.05650187f, -0.04970125f, -0.06381962f, -0.01178863f, -0.05915635f, 0.02383992f, 
    0.05204780f, 0.00526759f, -0.01068655f, 0.03341668f, 0.05394486f, -0.02793629f, -0.04930281f, 0.04919938f, 
    -0.05796897f, -0.02056087f, -0.03545406f, -0.05763245f, 0.01252884f, 0.00000956f, -0.00724349f, 0.00643375f, 
    -0.01170729f, -0.03828108f, -0.06038166f, 0.03435249f, 0.04545648f, 0.00793229f, 0.00799609f, -0.03614721f, 
    0.02518283f, 0.02798291f, 0.01566624f, -0.00886509f, -0.00001688f, -0.06752300f, -0.02619304f, -0.02425099f, 
    -0.03683025f, 0.02448654f, -0.03187608f, -0.03530895f, -0.04308392f, -0.02061179f, -0.01822703f, -0.04049902f, 
    0.00401610f, -0.00807279f, 0.00545162f, -0.06115979f, 0.02995166f, -0.05285283f, -0.01753247f, 0.03828639f, 
    0.01508197f, 0.00853195f, 0.01076103f, 0.01869605f, 0.01925842f, -0.01966992f, 0.01442025f, 0.02095623f, 
    -0.05241454f, 0.03905499f, -0.02527921f, -0.05853453f, -0.06371193f, 0.04013275f, 0.04444265f, 0.00760079f, 
    0.00008548f, -0.00999145f, 0.03730061f, 0.01920988f, -0.00207025f, 0.02712835f, -0.03431654f, -0.01502039f, 
    -0.06329387f, 0.02857915f, 0.03126786f, 0.04747198f, -0.00055551f, -0.02495282f, -0.00850868f, -0.00184258f, 
    0.01790446f, 0.02609434f, 0.02631118f, -0.02723541f, 0.02555704f, 0.01180008f, -0.02178511f, -0.06244339f, 
    -0.00553932f, 0.13576803f, -0.11203393f, -0.10888175f, -0.00586832f, -0.02636135f, -0.00983525f, -0.00635525f, 
    0.10004195f, -0.24310128f, 0.09742557f, -0.17030367f, -0.01072761f, 0.01256766f, 0.03829596f, -0.07550101f, 
    0.04191733f, -0.03345701f, -0.18403259f, 0.12977581f, 0.03504466f, -0.07904070f, 0.08849375f, 0.10562364f, 
    0.02399187f, 0.04186011f, -0.07546536f, -0.06363104f, 0.05935134f, -0.04203167f, 0.05269755f, 0.23606984f, 
    -0.04241262f, 0.03190133f, 0.39285055f, 0.15585318f, -0.16899604f, 0.42867076f, 0.05156325f, 0.17142478f, 
    0.31925419f, 0.07005674f, -0.15410529f, -0.09837648f, -0.05902277f, -0.30565074f, -0.00466776f, 0.05911488f, 
    -0.08735444f, 0.12867223f, 0.02991756f, -0.02318426f, -0.15087399f, 0.01499076f, -0.14693888f, -0.02042456f, 
    -0.10132413f, -0.20395559f, -0.02581371f, 0.13490456f, 0.07519419f, -0.09107158f, -0.02497883f, -0.26712659f, 
    -0.21955211f, -0.14521244f, -0.01790677f, 0.01514948f, 0.02823546f, -0.12791163f, 0.14166555f, -0.15966536f, 
    0.10838289f, 0.06768877f, 0.01231355f, -0.09788572f, -0.11393125f, 0.13714470f, 0.12517755f, 0.04007753f, 
    -0.10096327f, -0.12563397f, -0.03082570f, -0.10096552f, -0.09078988f, 0.04736228f, 0.15715744f, -0.21499412f, 
    -0.05559722f, 0.02155042f, -0.32989633f, 0.45519280f, -0.17056701f, -0.00613015f, -0.13803300f, 0.02791628f, 
    -0.10633266f, -0.19295055f, -0.03625829f, -0.28278059f, 0.17192440f, 0.00778188f, 0.13955358f, 0.06641365f, 
    -0.00582419f, -0.05041405f, -0.01116504f, 0.12041164f, -0.13640271f, 0.04346164f, 0.09503437f, -0.12800680f, 
    -0.11313296f, 0.11026297f, -0.06938180f, 0.07049610f, 0.03715916f, -0.16585568f, 0.22320195f, -0.24676703f, 
    0.16667663f, -0.08843174f, 0.01228098f, 0.03223256f, -0.06942824f, -0.05221190f, -0.12678809f, 0.09819729f, 
    -0.08997868f, -0.17476149f, 0.03393137f, 0.06308948f, 0.02951122f, -0.11492836f, -0.08303796f, -0.22283094f, 
    -0.12182803f, -0.13619585f, -0.05534625f, -0.00884348f, -0.06466088f, 0.02796467f, -0.13620877f, 0.04141697f, 
    0.14115965f, 0.18072456f, -0.01116519f, 0.05195262f, 0.14296848f, -0.07012693f, 0.01039030f, 0.14306857f, 
    -0.12197428f, -0.06564672f, 0.27623427f, 0.25456846f, -0.01905486f, -0.00707123f, 0.03098123f, 0.09176455f, 
    0.02256002f, 0.04431336f, -0.11723179f, -0.18586120f, -0.23362072f, 0.10824528f, 0.05628617f, -0.12718721f, 
    0.00718221f, 0.20210798f, 0.26553059f, -0.02219574f, 0.10565759f, -0.01484993f, 0.13377655f, -0.06189971f, 
    0.16466068f, 0.11030051f, 0.08404428f, -0.21876337f, -0.37591967f, -0.19278935f, -0.08706610f, 0.04680716f, 
    0.03170804f, -0.23084170f, -0.04546536f, 0.10769838f, -0.05053241f, 0.10773784f, 0.14897041f, -0.14181110f, 
    0.20259438f, 0.08566271f, 0.26287648f, -0.21010812f, -0.07396407f, -0.02825461f, 0.24815413f, -0.07467748f, 
    0.14089112f, 0.00486524f, 0.01814174f, -0.01200760f, 0.04902715f, 0.01722065f, -0.15059656f, 0.05095170f, 
    -0.41803548f, 0.37529346f, 0.00178930f, 0.20569411f, 0.00822007f, -0.19032793f, 0.08318686f, -0.06280790f, 
    -0.04062968f, 0.09434975f, 0.08639076f, 0.12769468f, -0.08487280f, 0.16353613f, -0.08064402f, -0.09503412f, 
    0.19504558f, -0.17005478f, 0.07996483f, -0.00975483f, 0.02633317f, 0.07909622f, 0.03574765f, -0.01829043f, 
    0.14531270f, 0.13698447f, -0.02885475f, 0.09519463f, 0.18044795f, -0.06032897f, 0.09431401f, 0.08430348f, 
    0.11396196f, 0.07500235f, 0.04390017f, 0.09564941f, 0.18262848f, 0.21736540f, -0.05511918f, 0.01393585f, 
    0.03277230f, 0.03171024f, -0.00785533f, -0.12933727f, -0.06593360f, -0.06638252f, -0.08763046f, 0.02805900f, 
    0.01437744f, 0.03800122f, -0.01626556f, -0.16461724f, -0.00749184f, 0.03820363f, -0.29175237f, 0.35715383f, 
    0.08700307f, -0.04345227f, 0.33385533f, -0.09241841f, 0.05801720f, 0.03859027f, -0.09190420f, -0.24874330f, 
    0.37979057f, -0.02848476f, 0.24393277f, -0.01059837f, 0.08681712f, -0.00078488f, 0.10079064f, -0.00315263f, 
    0.31079075f, 0.17110315f, 0.00159083f, 0.28616235f, 0.05440442f, 0.02427428f, -0.00715646f, -0.18535414f, 
    -0.06701319f, -0.19746117f, -0.00609559f, 0.01365362f, 0.01534332f, 0.05532211f, -0.11262303f, -0.27090830f, 
    -0.23514174f, -0.06462599f, -0.15297177f, -0.08178489f, 0.03798194f, 0.05953577f, 0.11642703f, -0.06497786f, 
    -0.31410539f, 0.02883986f, -0.03392916f, -0.22661732f, 0.20687693f, 0.02346845f, 0.05202355f, 0.12885231f, 
    -0.04165537f, 0.07059207f, 0.09646381f, 0.08532233f, -0.14138924f, -0.14392416f, 0.11721999f, 0.00488234f, 
    -0.07693532f, -0.27396101f, -0.02490362f, -0.18219791f, 0.00438442f, 0.63078356f, -0.14852278f, -0.03671949f, 
    0.01319278f, 0.23228496f, -0.02066645f, 0.19781128f, -0.00840614f, 0.12749386f, 0.04788708f, 0.04752191f, 
    -0.03902388f, 0.02536664f, 0.14121632f, 0.07640437f, 0.27149731f, -0.02701701f, 0.06415488f, -0.34243065f, 
    0.05425121f, -0.11960509f, 0.01273394f, 0.11913433f, 0.08319241f, 0.06499305f, -0.15832138f, 0.07776768f, 
    -0.15963420f, -0.04542864f, -0.04296183f, -0.04524066f, -0.03486650f, 0.07360871f, -0.02438501f, 0.20369044f, 
    -0.21810171f, -0.09248346f, 0.19880579f, -0.04224918f, 0.08008136f, 0.00100150f, -0.11533580f, -0.01287436f, 
    -0.03146955f, 0.05268697f, -0.13212369f, -0.04757312f, -0.06550344f, -0.09791311f, 0.00887846f, -0.03102422f, 
    0.01811511f, -0.12345415f, -0.21864101f, 0.10975230f, 0.15768233f, 0.06026183f, 0.32236177f, 0.14750357f, 
    0.00372385f, 0.14122961f, 0.11360560f, -0.24210447f, 0.32210293f, 0.07957018f, 0.11441268f, -0.00182361f, 
    0.01225328f, 0.01216706f, 0.14222738f, 0.02121374f, -0.12109569f, -0.03588577f, -0.01468575f, -0.11359560f, 
    0.00159757f, 0.08667544f, -0.17447203f, -0.00099550f, -0.15633267f, 0.16263963f, 0.24200961f, -0.12840554f, 
    0.05675449f, -0.08562285f, -0.05765775f, -0.00588131f, -0.07554057f, 0.12297779f, 0.14041050f, 0.12105120f, 
    -0.38510606f, -0.06466272f, 0.03147832f, 0.01605821f, 0.07425912f, -0.05770374f, 0.03072554f, 0.02184793f, 
    -0.01463100f, 0.04125882f, 0.08041839f, 0.01811319f, 0.08056998f, 0.12078223f, 0.06047370f, 0.15333278f, 
    -0.04325390f, -0.46068364f, 0.05999609f, 0.10132180f, 0.23305392f, 0.20387921f, -0.17471963f, -0.12326790f, 
    -0.21734449f, 0.06566456f, 0.14977174f, 0.16787699f, 0.11200041f, -0.14529847f, 0.11951789f, -0.07762818f, 
    0.04281638f, -0.05825094f, -0.04445158f, -0.03464281f, 0.23394470f, 0.12187172f, -0.06262185f, 0.01040038f, 
    -0.11963224f, -0.07186871f, -0.17530175f, -0.12358675f, -0.31575656f, 0.06162020f, -0.04155096f, 0.04592814f, 
    -0.14042333f, 0.02292765f, -0.17265408f, 0.03164884f, 0.22612792f, 0.11017471f, -0.09343307f, -0.01113505f, 
    0.13008201f, -0.07242658f, -0.03739180f, 0.03701640f, -0.01896303f, -0.34948969f, 0.18763259f, -0.02885886f, 
    0.02045005f, -0.07551906f, -0.02691761f, 0.10728388f, 0.12298737f, -0.01178319f, 0.11385923f, 0.28682345f, 
    0.31287670f, 0.14736637f, 0.00976705f, -0.00244326f, -0.06383432f, -0.09299655f, 0.07501367f, 0.03400619f, 
    0.78493565f, -0.01364121f, 0.01491048f, 0.02854332f, 0.08416071f, -0.07108432f, -0.02625296f, -0.08222625f, 
    -0.11325370f, -0.19200757f, -0.08920667f, -0.03556663f, 0.06949072f, -0.04174889f, -0.19602109f, -0.06897670f, 
    -0.26593003f, -0.07727727f, 0.02061223f, -0.15976457f, -0.07643893f, -0.11796066f, -0.02372118f, -0.13660586f, 
    -0.23411767f, -0.17917076f, 0.04856566f, 0.07650181f, 0.12657437f, 0.15082663f, 0.02117633f, -0.02578959f, 
    -0.01067723f, -0.01893100f, -0.07294481f, 0.17358127f, -0.10809041f, 0.13703994f, 0.08874757f, 0.01778878f, 
    0.00425699f, 0.06502577f, 0.04255318f, 0.08589064f, -0.02543122f, -0.00037438f, -0.12034085f, -0.17026283f, 
    -0.02788204f, -0.02399388f, -0.01182736f, 0.10999130f, -0.05099339f, -0.12695445f, 0.38613713f, 0.27816942f, 
    0.01833950f, 0.20613506f, 0.07266186f, -0.01412769f, 0.09374091f, -0.17059913f, 0.36419219f, 0.20926534f, 
    0.02362519f, -0.07691515f, 0.11452267f, 0.10731612f, -0.01013397f, 0.07134394f, 0.02334374f, 0.18852314f, 
    0.02977013f, 0.02262831f, 0.14548083f, 0.07621304f, -0.03194519f, -0.15957172f, 0.04761490f, 0.13668366f, 
    -0.20386408f, -0.01308736f, -0.08533261f, -0.03486591f, -0.01481351f, 0.10316503f, 0.07172152f, 0.05614674f, 
    -0.28407514f, 0.12519042f, 0.01144903f, 0.00670450f, -0.13563643f, 0.08566254f, 0.07136081f, -0.02426033f, 
    0.15595397f, 0.14927986f, 0.25351840f, -0.30335337f, -0.33577284f, 0.16909285f, 0.02715695f, 0.10148637f, 
    -0.26153401f, 0.00730123f, 0.19045199f, -0.39974391f, -0.15452731f, -0.27830535f, 0.10577285f, -0.04186805f, 
    -0.21683164f, -0.11084958f, 0.20042410f, -0.01178114f, -0.21594484f, 0.12566656f, -0.12006734f, -0.10971913f, 
    0.06328202f, 0.11924826f, 0.13867696f, 0.01956300f, -0.02160162f, 0.06866375f, 0.05564065f, -0.24150355f, 
    -0.13448866f, 0.17256573f, 0.08500515f, 0.09149480f, 0.07836462f, -0.10433818f, -0.08321562f, -0.00503072f, 
    0.02969597f, -0.21683232f, 0.00754287f, 0.05696340f, 0.08316630f, 0.08182177f, -0.05919465f, 0.44088560f, 
    0.06041915f, 0.05668588f, -0.12385207f, -0.00701497f, 0.06542968f, -0.04899584f, 0.01886516f, 0.02691702f, 
    -0.14212231f, -0.18557236f, 0.05985085f, -0.02565710f, 0.13376766f, -0.06722406f, -0.18924585f, -0.04815917f, 
    -0.00870194f, 0.15446623f, 0.15010968f, 0.11808551f, -0.05298786f, -0.01573392f, 0.13542128f, -0.06187773f, 
    -0.00806733f, -0.25280479f, 0.10289595f, -0.42997989f, 0.04891204f, 0.00433598f, 0.34068641f, 0.26618269f, 
    -0.22773977f, 0.08810969f, -0.13064836f, -0.34320363f, -0.34297383f, -0.20116548f, 0.07499446f, 0.01927963f, 
    0.09129411f, -0.17832793f, 0.15698832f, 0.24081603f, -0.03595346f, 0.12305078f, -0.02200427f, 0.01033000f, 
    0.09848736f, 0.12287137f, 0.02235926f, 0.09510542f, -0.28830880f, 0.27537146f, 0.09808473f, 0.11441186f, 
    -0.15945895f, -0.13293612f, 0.04376838f, 0.00430017f, 0.22587973f, 0.00249777f, 0.23746896f, 0.27332133f, 
    0.10213383f, -0.15638061f, 0.05391847f, 0.19025682f, 0.12150749f, 0.11112847f, -0.06559290f, 0.39824396f, 
    0.06473242f, 0.00330598f, -0.12825520f, 0.06152919f, -0.02777660f, 0.02389208f, 0.14065333f, -0.06163212f, 
    0.13265991f, -0.13569495f, 0.04230981f, -0.16301954f, 0.08808102f, -0.12253345f, 0.13223191f, 0.15982723f, 
    0.15962701f, -0.01553180f, -0.18055297f, -0.07804441f, 0.03367837f, -0.02174694f, -0.04805532f, -0.05786260f, 
    -0.07963584f, 0.00690761f, -0.06555966f, 0.02359480f, -0.08974189f, 0.16842601f, -0.00933030f, -0.08467671f, 
    -0.11901093f, 0.11474953f, -0.07472272f, 0.17044245f, -0.19176131f, -0.14632146f, -0.07755770f, 0.19697210f, 
    0.22677982f, -0.08679872f, -0.05408840f, 0.26980436f, 0.33663902f, 0.08178195f, 0.01928961f, -0.10166971f, 
    -0.05942998f, -0.17957841f, 0.02552452f, -0.03714341f, -0.10064277f, -0.06925169f, 0.07282919f, 0.24776103f, 
    0.10088365f, 0.00430695f, 0.11368717f, -0.21319251f, 0.22185476f, 0.08178294f, 0.16752638f, -0.06483802f, 
    0.07225504f, -0.04135506f, 0.03073407f, 0.04076258f, -0.10029501f, -0.15357344f, 0.09567044f, 0.07104546f, 
    0.03200435f, 0.31113642f, -0.18202610f, -0.29994616f, 0.02329761f, 0.17282818f, 0.00919480f, -0.03047463f, 
    0.00045191f, 0.02679473f, -0.02294642f, -0.07524551f, 0.01592277f, 0.08192644f, 0.12279413f, 0.24898645f, 
    -0.26986384f, 0.01668784f, 0.02760596f, -0.00814276f, -0.06420384f, 0.11545484f, 0.06637958f, 0.07274599f, 
    0.26552233f, 0.11404392f, 0.00713317f, -0.35081184f, -0.22767548f, -0.01130667f, 0.07984484f, -0.01212710f, 
    0.06950310f, -0.00987045f, 0.04292770f, 0.06347200f, -0.21616316f, 0.02847653f, 0.00906537f, -0.07285189f, 
    -0.05474603f, 0.00613143f, 0.12507148f, 0.15644789f, 0.24172921f, 0.10354377f, 0.21637461f, -0.09239168f, 
    0.05996674f, -0.01898533f, 0.11878572f, 0.08743927f, -0.02784284f, -0.42869383f, -0.05798752f, 0.21058956f, 
    -0.17158280f, 0.05149612f, -0.06403996f, 0.06421537f, 0.06473818f, -0.33201927f, -0.01073622f, -0.11563020f, 
    0.05511944f, -0.09717800f, 0.03590913f, -0.17570831f, 0.19740732f, 0.03268917f, 0.02792440f, 0.30803776f, 
    -0.06736619f, -0.21602213f, -0.17209302f, 0.03589736f, -0.05599035f, -0.08319667f, 0.00891247f, 0.29973042f, 
    -0.01333459f, -0.12594527f, -0.12351196f, -0.16129385f, -0.04759429f, 0.04662484f, -0.05396108f, 0.07014425f, 
    -0.10921559f, 0.59777266f, -0.14599679f, 0.20355064f, -0.15237576f, -0.15370806f, 0.05706342f, 0.13182476f, 
    -0.02081349f, -0.05205230f, 0.23441140f, 0.05426047f, 0.13455935f, -0.06650680f, 0.21830513f, -0.01404168f, 
    0.00562150f, -0.03499201f, 0.07677322f, -0.28913155f, 0.22144316f, 0.19981468f, 0.07093079f, -0.04299930f, 
    0.14756985f, 0.30503604f, 0.17651196f, 0.20167212f, 0.11057948f, -0.42556965f, -0.25760067f, -0.00115430f, 
    -0.05965946f, 0.32374716f, 0.03262722f, 0.14414622f, -0.14213899f, -0.45849210f, -0.66631424f, -0.31711853f, 
    0.14734308f, 0.01299805f, 0.12153984f, 0.21454406f, -0.02570130f, 0.10353579f, 0.32101217f, 0.03053394f, 
    0.07566066f, -0.14809625f, 0.08563216f, -0.03412264f, 0.01626884f, 0.12463888f, -0.09476338f, 0.15599850f, 
    -0.24560262f, 0.19755302f, -0.02832636f, 0.08208005f, 0.13768849f, -0.08127575f, 0.01354184f, -0.06784628f, 
    0.26863742f, -0.02184352f, 0.13862270f, -0.07777391f, -0.03101327f, 0.02571128f, -0.05617333f, 0.01896485f, 
    -0.01275237f, -0.14714922f, 0.10983114f, -0.35754210f, 0.03899018f, 0.03485880f, -0.00462786f, -0.05765405f, 
    -0.05019708f, -0.04615248f, -0.98252672f, 0.23702368f, 0.21262193f, -0.03675774f, 0.05661036f, -0.26383743f, 
    0.16328257f, 0.23212476f, 0.04357387f, -0.36759102f, 0.19102244f, 0.23352565f, -0.00327610f, 0.26366687f, 
    -0.19177815f, -0.01082094f, 0.01922717f, -0.01421889f, -0.10256542f, -0.11909376f, -0.11259265f, 0.10390732f, 
    -0.09471344f, -0.14530425f, 0.05143182f, 0.07829161f, -0.11785410f, -0.10983267f, -0.25566751f, 0.49240535f, 
    0.15280832f, -0.26601201f, -0.18922523f, 0.18048429f, 0.10146632f, -0.17204072f, 0.09734694f, 0.08618034f, 
    -0.04076938f, -0.17231970f, -0.12244078f, -0.18361326f, 0.17139600f, -0.00790008f, 0.04484592f, 0.12039071f, 
    -0.05815185f, 0.16746549f, 0.23501679f, 0.13589148f, -0.02457444f, -0.15006351f, 0.05362651f, -0.02864268f, 
    -0.21366592f, 0.09408799f, -0.46803284f, -0.32377154f, -0.01387896f, -0.04511749f, 0.22799020f, -0.07955546f, 
    0.00496883f, 0.11723680f, 0.12490100f, 0.08632284f, -0.06012615f, 0.12047859f, -0.09142792f, -0.11796203f, 
    0.05246944f, 0.00394899f, -0.37322268f, -0.75472802f, -0.08237668f, 0.07104444f, 0.08199286f, -0.05063594f, 
    0.07833872f, -0.12398391f, 0.13717495f, 0.08916268f, -0.33145681f, 0.20718183f, -0.00466188f, 0.01551097f, 
    -0.04286945f, -0.01720295f, -0.05539403f, 0.03085102f, 0.29613909f, -0.44922078f, -0.25484174f, -0.02842534f, 
    0.14177552f, 0.07405572f, -0.15801603f, -0.10801133f, 0.13494352f, -0.04752972f, -0.08305097f, 0.14047767f, 
    0.05775332f, -0.04121311f, -0.08663471f, -0.26564899f, -0.23893766f, 0.02991841f, -0.05239364f, 0.18895938f, 
    -0.07101944f, -0.04072844f, 0.08662934f, -0.25333509f, -0.09256637f, -0.07091327f, -0.10975827f, -0.36539176f, 
    -0.64259011f, -0.44172835f, -0.01576887f, -0.32924199f, 0.22516429f, -0.02572765f, 0.03354015f, 0.04421084f, 
    -0.01907569f, -0.37285605f, 0.00218993f, -0.03044589f, -0.06108814f, -0.01943109f, 0.03522233f, -0.10198693f, 
    0.07156751f, -0.28678149f, -0.30628386f, 0.01819102f, -0.04367177f, -0.11156397f, 0.06727898f, 0.12036336f, 
    -0.05190728f, 0.10313646f, 0.06251799f, 0.31008267f, 0.19926205f, -0.06342009f, -0.00871205f, -0.09132728f, 
    0.00129304f, 0.04912539f, 0.08428542f, 0.30979395f, 0.16630885f, 0.18950588f, -0.05789940f, 0.18051447f, 
    0.05341196f, 0.04850085f, 0.10734605f, 0.12156013f, 0.09687579f, 0.04265635f, -0.07749575f, -0.13110520f, 
    -0.06280266f, 0.03917221f, -0.18920879f, -0.05908697f, -0.05508877f, 0.33121884f, -0.43537381f, 0.00694705f, 
    0.07059354f, -0.19524325f, -0.34711003f, 0.16861023f, -0.04956634f, 0.21836947f, 0.11637092f, -0.09459549f, 
    -0.25001243f, -0.20940922f, -0.00779864f, -0.00213172f, -0.07089621f, 0.03366980f, 0.02159389f, 0.19439071f, 
    0.07638066f, 0.10903401f, 0.03021482f, -0.10219710f, -0.20425901f, -0.01288766f, 0.20707917f, -0.12006968f, 
    -0.05021351f, 0.01619197f, 0.01225604f, 0.04150429f, 0.01647882f, -0.02749180f, -0.05688502f, 0.01427601f, 
    -0.05595530f, -0.05124860f, -0.04412685f, 0.00821302f, 0.02170906f, -0.04089676f, -0.00426992f, -0.03607076f, 
    -0.05696662f, -0.00918955f, 0.00913280f, 0.04277567f, -0.00638338f, 0.00223664f, -0.02965540f, -0.04719342f, 
    0.04608411f, 0.02812659f, 0.00963595f, 0.02629294f, -0.06253881f, -0.01326168f, 0.03158469f, 0.02393952f, 
    -0.00447260f, 0.01534635f, 0.01742244f, 0.02333699f, -0.01424262f, 0.01784591f, -0.00988783f, -0.03119798f, 
    0.02039859f, 0.03415751f, -0.00530846f, -0.05029587f, 0.05182713f, -0.01891618f, -0.01894959f, 0.00597593f, 
    0.00128324f, -0.00179567f, -0.02778273f, 0.04087604f, -0.06088666f, 0.02424825f, -0.03833674f, -0.02174386f, 
    0.04561898f, 0.05142147f, -0.06202615f, -0.06190163f, 0.00991645f, 0.02810727f, -0.05285249f, 0.03005022f, 
    -0.01380572f, 0.00933371f, 0.00029151f, -0.05986235f, 0.00515843f, -0.05251589f, -0.02043563f, -0.02726245f, 
    -0.05369671f, -0.00749620f, -0.02380469f, 0.01231379f, 0.03905402f, -0.01160265f, -0.01533623f, 0.02955271f, 
    -0.05643875f, -0.03585913f, -0.05732530f, -0.06322619f, 0.01339166f, 0.00279210f, 0.02016795f, -0.05230218f, 
    -0.04756188f, -0.00889389f, -0.02515010f, 0.00124401f, 0.02743744f, -0.02370327f, -0.03228805f, 0.04431366f, 
    -0.06254100f, -0.01008506f, -0.01362467f, 0.01344062f, -0.06543126f, -0.03704770f, -0.06291425f, -0.05447075f, 
    0.03323188f, -0.06932303f, 0.02855355f, -0.06940304f, 0.04725424f, -0.01646015f, -0.06641112f, -0.01561690f, 
    -0.01174166f, -0.05527707f, -0.01964539f, -0.02226698f, 0.01758751f, -0.04483753f, 0.03144634f, -0.01561517f, 
    0.05267033f, -0.06696767f, 0.01203742f, 0.00609452f, 0.00843344f, -0.02694867f, 0.02730816f, -0.03430616f, 
    -0.01187879f, 0.03943149f, 0.00699324f, -0.06064285f, -0.01565300f, -0.00505189f, -0.04125840f, 0.03953461f, 
    0.02594674f, -0.05649301f, 0.03927248f, -0.05210363f, 0.01497823f, -0.01906603f, -0.04262959f, -0.01200808f, 
    0.01003297f, -0.02186318f, -0.05081660f, -0.05342967f, 0.01055658f, -0.05512887f, -0.05356352f, -0.05760857f, 
    0.04293876f, -0.04674539f, -0.02301240f, 0.03336355f, -0.00561339f, 0.00113475f, -0.01225898f, 0.02871696f, 
    0.01671495f, -0.03598794f, 0.00309647f, -0.04596635f, 0.04282274f, -0.02556808f, -0.05548496f, -0.05932073f, 
    -0.01892979f, 0.03017456f, -0.04110431f, -0.00535185f, -0.04338278f, 0.00113949f, 0.00896453f, -0.04426520f, 
    -0.01486723f, 0.04277201f, 0.03330678f, 0.04771268f, 0.04702242f, -0.02499539f, -0.05059245f, 0.01180474f, 
    -0.02993765f, 0.00724847f, -0.04382468f, -0.05007247f, -0.00135384f, -0.03402947f, 0.03347296f, -0.00285955f, 
    0.03437722f, 0.04063126f, -0.01571759f, 0.01846019f, -0.05009484f, -0.01491565f, 0.01526813f, 0.00462770f, 
    -0.02833581f, 0.01445122f, 0.00875503f, -0.03290771f, -0.02772444f, 0.01637188f, 0.00964401f, -0.05025094f, 
    0.03590189f, -0.07033543f, 0.04413383f, -0.01719447f, -0.00379345f, -0.04941717f, -0.01000595f, -0.04174077f, 
    -0.06003914f, -0.04374194f, 0.00612677f, -0.02938816f, -0.01137381f, -0.05039839f, -0.04217815f, -0.04984700f, 
    -0.04405878f, -0.03537115f, 0.02843375f, 0.01097427f, -0.01764733f, 0.03198058f, 0.01613550f, -0.00379854f, 
    -0.07494860f, 0.01072684f, -0.06434142f, -0.06567777f, 0.00906515f, -0.04555750f, 0.02168743f, 0.00739184f, 
    0.01198388f, 0.04956122f, 0.02563218f, -0.03292125f, -0.01646359f, -0.01440376f, 0.02465306f, -0.02819382f, 
    -0.05832947f, -0.02896743f, 0.04207738f, 0.03919348f, -0.04478383f, -0.00607696f, 0.00715533f, -0.06096612f, 
    -0.01648140f, -0.02285824f, -0.04078698f, -0.06401808f, -0.01951156f, -0.04022299f, -0.01902640f, 0.03592579f, 
    -0.03707296f, 0.02700699f, 0.00870942f, 0.04098482f, 0.00803051f, -0.02016814f, 0.02384275f, -0.03253901f, 
    -0.01153297f, -0.04815032f, -0.04153258f, -0.05248726f, -0.01381140f, -0.03606899f, -0.00313037f, 0.04248490f, 
    0.02687183f, 0.03120899f, -0.06131850f, 0.00625444f, -0.00192213f, 0.00524056f, -0.05608127f, 0.01647930f, 
    0.00774086f, -0.06987441f, -0.10506222f, -0.08570535f, -0.14603768f, 0.01270860f, 0.05116183f, 0.15805194f, 
    0.06165854f, 0.05175591f, -0.00820671f, -0.13561848f, -0.08900405f, -0.17439020f, -0.04805715f, 0.32175544f, 
    -0.10282022f, 0.11204465f, 0.29207030f, -0.02440577f, -0.01332999f, 0.08573947f, -0.04384469f, 0.01077305f, 
    0.00662846f, 0.01209404f, -0.02994866f, 0.18177721f, 0.09523101f, 0.16191004f, -0.19438955f, 0.05160739f, 
    0.03582793f, -0.00398031f, 0.13135625f, 0.05273032f, -0.13990512f, 0.11764824f, -0.56334460f, -0.31976911f, 
    0.09919614f, 0.15293539f, 0.04028406f, 0.17443918f, -0.02383292f, -0.05510696f, -0.22562677f, -0.15770051f, 
    -0.09060659f, 0.06748308f, -0.10797657f, 0.35446176f, 0.06311312f, 0.06232105f, -0.04347309f, -0.07690356f, 
    0.05374456f, 0.00081199f, 0.15146309f, -0.25097251f, 0.06235676f, -0.24838163f, -0.09606270f, -0.09123909f, 
    0.01638328f, -0.17621282f, 0.09467918f, -0.02210407f, 0.04295867f, 0.12905307f, -0.07839006f, 0.04058481f, 
    -0.12861578f, -0.02178181f, -0.13476428f, 0.09125759f, -0.00682637f, 0.16386402f, 0.05786286f, -0.02582925f, 
    -0.03326123f, 0.02896800f, -0.11388688f, -0.17511812f, -0.12280497f, 0.03593402f, 0.12292205f, 0.06101996f, 
    0.08729004f, 0.06614430f, -0.07074995f, -0.21440269f, -0.13261090f, 0.08840657f, -0.09171581f, 0.09522495f, 
    -0.20410581f, 0.08222024f, -0.08323331f, 0.25690439f, 0.10359936f, 0.09522778f, -0.11266324f, -0.21916543f, 
    0.14108679f, -0.18189071f, -0.02900846f, 0.12829110f, -0.03232837f, 0.06880379f, -0.14199691f, 0.09137109f, 
    -0.09352343f, 0.01616565f, -0.03670796f, 0.10731182f, 0.09388569f, -0.09108950f, -0.16514900f, 0.06843484f, 
    0.12565978f, -0.16325594f, 0.11468623f, 0.04646941f, -0.04505748f, -0.03913003f, -0.16253896f, -0.05066004f, 
    -0.18644787f, 0.05969690f, 0.02737771f, -0.09309700f, -0.03719697f, 0.10174344f, 0.06137100f, -0.08078951f, 
    0.02685264f, -0.03924365f, 0.16457595f, -0.00554732f, 0.21223126f, -0.02758863f, -0.00565038f, 0.18106329f, 
    -0.09165952f, -0.22076960f, -0.06616566f, -0.04967540f, 0.03992923f, 0.06593504f, 0.15959334f, -0.07735357f, 
    0.04444988f, 0.18548360f, 0.30596083f, 0.15004706f, -0.01762891f, 0.14586312f, -0.10033900f, 0.00608573f, 
    -0.10531959f, 0.03765475f, 0.05707237f, 0.02865038f, -0.00483528f, 0.05023175f, -0.02543987f, -0.14480403f, 
    0.07750709f, -0.03361815f, 0.04039993f, 0.19214174f, -0.28356692f, -0.03718809f, -0.07947168f, 0.14440186f, 
    0.07069642f, -0.06010030f, -0.04457902f, 0.10312412f, -0.17726220f, -0.14081009f, -0.12787241f, 0.15001196f, 
    0.04964329f, 0.01294312f, -0.09060027f, 0.02101094f, 0.06938899f, -0.29959950f, 0.07778975f, -0.15281963f, 
    0.04380785f, -0.05581194f, -0.08068492f, 0.04039563f, 0.16697204f, 0.00402415f, 0.09904502f, 0.19029206f, 
    0.22077657f, -0.12045620f, -0.04390660f, -0.05029232f, 0.00054984f, -0.17962296f, 0.05312634f, -0.17131272f, 
    0.03067242f, -0.67111212f, -0.01069794f, 0.07145099f, 0.17683798f, 0.03778051f, 0.07647000f, -0.00898165f, 
    0.04902027f, -0.01672546f, 0.05273535f, -0.02704590f, -0.12894867f, 0.06938393f, 0.06378593f, 0.03080598f, 
    0.11043509f, -0.08180771f, -0.02617160f, -0.09289626f, 0.05420445f, 0.05063523f, 0.11608640f, 0.22685713f, 
    -0.01164317f, -0.08165232f, 0.07881057f, 0.21726209f, 0.47971648f, -0.05461679f, 0.02508079f, -0.02058377f, 
    0.02964938f, 0.04690507f, 0.02495125f, 0.38626367f, 0.23163483f, 0.01439740f, -0.00652969f, 0.13389643f, 
    -0.09070822f, -0.03875664f, 0.07421023f, 0.04205197f, -0.18699998f, -0.20757468f, -0.26534235f, -0.03315619f, 
    0.15300953f, 0.17120044f, -0.00407935f, -0.06386987f, -0.00381269f, -0.15877301f, 0.47536698f, 0.16883969f, 
    0.04080286f, 0.15840040f, 0.08460695f, -0.09040792f, -0.04525292f, 0.07958096f, 0.02919973f, 0.13919602f, 
    -0.05454049f, -0.19489039f, -0.16730747f, -0.04604674f, 0.15708429f, 0.05963176f, 0.08177773f, 0.21051531f, 
    0.10310440f, 0.07957483f, -0.10925648f, -0.02979749f, 0.00100827f, 0.00822490f, 0.01645203f, -0.04555075f, 
    0.07805412f, 0.07950684f, -0.13167971f, -0.24215989f, -0.12617651f, -0.02845711f, 0.01493333f, -0.03258196f, 
    0.02786824f, 0.03564248f, 0.15266629f, 0.05749459f, 0.02107571f, -0.06231457f, -0.20997615f, 0.00911637f, 
    -0.17453848f, -0.06910741f, 0.46500817f, -0.34050894f, -0.09528550f, 0.11894836f, -0.07590311f, -0.07890773f, 
    -0.07453968f, 0.08283509f, -0.13106872f, 0.60862589f, -0.01453076f, 0.01046792f, 0.13399285f, 0.25545448f, 
    -0.02693651f, 0.10412297f, 0.28073925f, 0.06325984f, 0.57750744f, 0.53486687f, 0.02467664f, -0.08367714f, 
    -0.03670388f, -0.02292091f, -0.04304913f, 0.12888756f, -0.06268813f, -0.02457336f, -0.23678686f, -0.05563436f, 
    -0.21919458f, 0.09835204f, 0.07134567f, 0.03018692f, 0.01190664f, 0.07572072f, -0.10300004f, -0.17180696f, 
    0.11955644f, -0.19535825f, -0.13317046f, -0.11505698f, -0.02081244f, -0.07626145f, 0.07406034f, -0.15552500f, 
    0.00665380f, 0.13515118f, -0.11572845f, 0.04681963f, -0.21547855f, 0.02871302f, -0.06212303f, 0.00270617f, 
    0.45757517f, 0.07235838f, -0.12094726f, 0.11996303f, -0.02046113f, -0.25115156f, 0.18064310f, -0.02323858f, 
    0.08319086f, -0.03304230f, 0.01777954f, 0.14780362f, -0.04630575f, -0.02781877f, -0.06505457f, -0.02962638f, 
    -0.02481247f, 0.27537555f, 0.42622018f, -0.37929764f, 0.10879555f, 0.24125117f, -0.23963846f, -0.12308565f, 
    -0.16484387f, -0.04299480f, -0.24444167f, -0.23213471f, -0.19423249f, -0.13535365f, 0.28192785f, 0.04253455f, 
    0.17144741f, -0.20095475f, 0.01791210f, -0.29632398f, -0.02083101f, 0.05366048f, 0.18194774f, -0.02809620f, 
    0.02530419f, -0.11983845f, 0.13242534f, -0.05916950f, -0.00589559f, -0.34010345f, 0.03703269f, 0.02204975f, 
    -0.10538196f, 0.05524973f, -0.04274826f, 0.06922280f, 0.12966473f, -0.06300198f, -0.14818135f, 0.02648647f, 
    0.08778869f, 0.09513228f, -0.02900200f, -0.00868292f, 0.04799340f, 0.14254297f, 0.02423683f, -0.19293410f, 
    -0.00648569f, 0.18510330f, -0.19550361f, -0.07273198f, -0.02467447f, 0.09914047f, 0.03574708f, 0.08411645f, 
    -0.13888714f, -0.21682045f, 0.13010478f, 0.05181764f, 0.15212530f, -0.44627964f, 0.05084403f, 0.13840756f, 
    -0.04999401f, -0.04485802f, -0.17908108f, 0.19045888f, 0.12824421f, 0.00973214f, -0.09637596f, -0.01362839f, 
    -0.15614820f, 0.00966450f, -0.59493726f, -0.04736533f, 0.05775505f, -0.28095043f, 0.19114661f, 0.02814139f, 
    0.20124440f, 0.25500262f, 0.32670596f, 0.16915064f, -0.17350549f, 0.27072427f, 0.05894939f, 0.18053183f, 
    -0.09882484f, -0.14518315f, -0.27120960f, -0.00961992f, -0.33862764f, 0.03333971f, -0.21055092f, -0.01483132f, 
    0.09104411f, -0.02725162f, -0.02985912f, 0.00135899f, 0.04464801f, -0.18666917f, -0.19695751f, 0.04417407f, 
    0.02740750f, 0.00194156f, 0.08450837f, 0.19874835f, -0.07529891f, 0.04189300f, -0.40696901f, -0.10737416f, 
    -0.22437476f, -0.07692694f, -0.34268680f, 0.08460174f, -0.00837610f, -0.00874394f, 0.00245534f, -0.08507215f, 
    0.55192924f, -0.05571697f, -0.32609960f, 0.07964855f, 0.12181973f, 0.05547210f, 0.19642590f, 0.34965008f, 
    -0.18690366f, -0.01806979f, -0.01174534f, -0.06138342f, -0.23458856f, 0.06727640f, -0.01307820f, -0.13623528f, 
    0.18866046f, 0.06951027f, 0.08041670f, 0.01994737f, -0.03394748f, -0.03165912f, -0.04706303f, 0.25623471f, 
    -0.00764624f, 0.23380050f, -0.02099433f, -0.18671179f, 0.19125107f, -0.22388799f, 0.05177371f, -0.04780704f, 
    0.04176683f, -0.13692778f, 0.08351616f, 0.16080923f, -0.20725779f, 0.05367704f, -0.04368870f, 0.13857931f, 
    -0.06216752f, 0.01845801f, -0.20208989f, -0.01542450f, -0.07727832f, 0.05167431f, 0.18752773f, 0.02613173f, 
    0.05493942f, 0.06096347f, -0.05495542f, -0.00357879f, 0.13328929f, -0.36491781f, -0.23636286f, 0.52684397f, 
    -0.29412118f, -0.03465843f, 0.15771522f, 0.00906084f, 0.04905359f, 0.21845256f, 0.17991549f, -0.13995157f, 
    0.38729990f, 0.07187682f, 0.22512855f, 0.13110355f, 0.15171367f, 0.23424345f, 0.01951281f, -0.13750210f, 
    0.11564174f, -0.09104620f, -0.15378043f, -0.26339284f, -0.14492233f, 0.11279190f, -0.21377964f, -0.09215743f, 
    -0.00102645f, 0.01282152f, -0.00092752f, -0.02541898f, 0.03458936f, -0.00623351f, -0.00892109f, -0.06103540f, 
    0.00301594f, -0.01075426f, -0.07057216f, -0.07017081f, 0.01020982f, 0.01058048f, 0.02078897f, -0.05572727f, 
    -0.00171319f, 0.03222805f, -0.01257760f, -0.00115295f, 0.01082279f, -0.04692411f, -0.02634142f, -0.00187965f, 
    -0.05834007f, 0.00817247f, -0.04800808f, -0.01035442f, 0.04384540f, -0.04051747f, 0.04453856f, -0.06766136f, 
    0.01350124f, -0.05203164f, -0.04940560f, -0.07022796f, -0.01896502f, -0.03377571f, -0.03509293f, -0.02400982f, 
    -0.03653365f, 0.02660651f, -0.03311496f, 0.04592997f, 0.02663849f, 0.00175991f, 0.00061936f, -0.05273665f, 
    0.03553120f, 0.02292954f, 0.01642665f, -0.03684199f, -0.01226891f, -0.00817089f, -0.03403174f, -0.06231982f, 
    0.03791834f, -0.04956134f, -0.00638777f, 0.01765311f, -0.03775121f, -0.05421468f, 0.03398230f, 0.02634872f, 
    -0.05812195f, -0.02901565f, 0.00155110f, 0.00840712f, 0.04904443f, 0.04037457f, -0.01736086f, 0.03379016f, 
    0.02705517f, 0.02296911f, -0.06631672f, 0.00600864f, -0.01996481f, 0.01950391f, -0.04976076f, -0.04322285f, 
    -0.01376600f, -0.06836022f, 0.03226510f, 0.03191592f, -0.00051928f, 0.00618873f, 0.02383566f, 0.00348176f, 
    -0.00572012f, 0.03107107f, -0.01332376f, -0.05045229f, -0.06552831f, 0.03473488f, 0.02056292f, 0.02122598f, 
    -0.04318672f, -0.01811855f, -0.04738668f, -0.03111209f, 0.04003363f, -0.05137753f, -0.04577245f, 0.01127600f, 
    0.00164627f, -0.03727563f, -0.05438878f, 0.05280904f, -0.05623869f, -0.01185039f, 0.00269858f, 0.01052505f, 
    0.03541986f, -0.00877247f, 0.02992663f, -0.03579469f, 0.01063724f, -0.05899258f, -0.00176523f, -0.00070021f, 
    -0.01481498f, -0.00290295f, -0.03212908f, -0.04732626f, -0.06773608f, -0.02355591f, -0.02923896f, 0.00274025f, 
    -0.01666726f, 0.03855890f, -0.03017013f, 0.00327582f, 0.00669463f, 0.03480273f, -0.04294454f, 0.04481392f, 
    -0.00709141f, 0.00371788f, -0.03034691f, -0.03918283f, -0.04259570f, 0.01647069f, 0.04133117f, 0.02952333f, 
    -0.06116338f, 0.01446428f, 0.04550534f, 0.03512356f, -0.04953374f, -0.01743991f, 0.00937499f, -0.03622802f, 
    -0.05242677f, -0.00132501f, 0.00066769f, -0.01732946f, -0.06182926f, -0.00996886f, 0.03793805f, 0.02191332f, 
    0.04919023f, -0.01234249f, 0.02119262f, 0.03686483f, -0.03657783f, -0.01068597f, -0.00191034f, 0.05000852f, 
    0.02920714f, -0.04524146f, -0.04517370f, -0.01373740f, 0.02350293f, -0.01590205f, 0.04896959f, 0.00394118f, 
    -0.06101757f, 0.00044113f, -0.02852813f, 0.04173828f, -0.01887746f, 0.04934168f, -0.03329121f, -0.05040519f, 
    -0.02371171f, -0.05474452f, 0.01435642f, -0.06073741f, -0.04237327f, -0.06033529f, 0.00767582f, -0.04437962f, 
    -0.01256393f, -0.03540239f, -0.06123644f, 0.02505440f, -0.03268861f, 0.02015905f, 0.01512858f, -0.00503516f, 
    0.01626629f, -0.07269567f, 0.02872979f, -0.00376748f, -0.03168161f, -0.05848254f, 0.02638210f, 0.03576166f, 
    0.00733379f, 0.05680979f, -0.02374968f, 0.01588243f, -0.01046259f, -0.01600019f, -0.06657709f, -0.03623975f, 
    -0.02271763f, 0.04956719f, 0.02241824f, -0.01245217f, 0.03873229f, -0.01500312f, 0.05393143f, 0.04712716f, 
    0.01403185f, -0.03946948f, -0.01906503f, -0.05524549f, 0.00601356f, -0.00188625f, -0.03941419f, 0.01830919f, 
    0.03915740f, 0.00252602f, -0.00180323f, -0.00254144f, -0.05202158f, -0.00213416f, -0.01333934f, 0.00388475f, 
    -0.01398688f, -0.05600194f, -0.00594187f, 0.02922572f, -0.01268669f, 0.03459435f, -0.01260498f, -0.05520706f, 
    -0.02829828f, -0.00750922f, -0.02361916f, -0.04250878f, 0.00908611f, -0.03231261f, 0.04838577f, -0.01644086f, 
    -0.04517579f, -0.02394477f, 0.03031059f, 0.01389754f, 0.02033705f, 0.02308540f, 0.03507522f, -0.01677101f, 
    0.02540046f, 0.04181011f, 0.04200874f, 0.00353178f, -0.02247195f, -0.03527003f, -0.04468429f, -0.04569482f, 
    -0.02242176f, 0.02436904f, -0.01880153f, 0.02833548f, 0.00132730f, -0.00990495f, -0.05923581f, -0.04536860f, 
    -0.02887443f, 0.00227368f, 0.02397494f, -0.00716256f, 0.00415892f, 0.01340064f, -0.03393912f, -0.02368497f, 
    -0.00637284f, -0.11434814f, 0.14111167f, 0.00359003f, -0.01857439f, -0.08142958f, -0.12627585f, 0.06815201f, 
    0.03362420f, -0.32103261f, 0.30081841f, -0.35919845f, -0.27068576f, -0.27081719f, -0.31809273f, 0.28894672f, 
    0.11039648f, -0.04503521f, -0.15557662f, 0.22179170f, 0.33048201f, -0.10398018f, -0.02154408f, -0.07688446f, 
    0.11262591f, 0.11125644f, 0.11462632f, 0.33563375f, -0.20809479f, -0.07032210f, 0.03528231f, -0.09574836f, 
    0.13224436f, -0.05652414f, -0.04931593f, 0.05521449f, -0.04177688f, -0.13544056f, -0.33404216f, 0.04605881f, 
    0.29410988f, -0.01203092f, -0.20555998f, -0.04126029f, -0.11485464f, -0.50635189f, -0.16099523f, 0.03311398f, 
    -0.18671332f, 0.05809117f, -0.22146243f, -0.00399632f, 0.14165661f, -0.05337141f, -0.15601292f, -0.17136817f, 
    0.06803027f, 0.04368481f, 0.24043489f, 0.06389916f, 0.12064987f, -0.11905766f, -0.04953465f, -0.24018151f, 
    0.18628852f, 0.19391540f, 0.01668977f, -0.05842230f, -0.12019261f, 0.26306355f, -0.02918933f, 0.01603056f, 
    -0.03398426f, 0.20534055f, 0.19491108f, -0.01843669f, -0.01932005f, 0.08235145f, 0.03337105f, 0.12802793f, 
    0.18691511f, -0.06824778f, 0.02580412f, -0.11423787f, -0.23063301f, 0.01384800f, 0.06556774f, 0.17496897f, 
    0.04972013f, -0.02860156f, -0.90553421f, 0.44383964f, -0.02913631f, -0.15675364f, -0.24683084f, -0.23207930f, 
    0.18340531f, 0.07316287f, -0.17684452f, 0.10208438f, 0.08931318f, -0.11945082f, -0.08849929f, -0.09596366f, 
    -0.06338306f, 0.12486912f, -0.05610340f, -0.10452272f, 0.02268851f, 0.07380229f, -0.19982634f, -0.40332338f, 
    -0.03229225f, 0.12051222f, 0.07254790f, 0.05907778f, -0.01008627f, -0.05318108f, 0.14010668f, 0.00410170f, 
    0.04117959f, -0.05249361f, -0.26172897f, -0.00010116f, -0.02842449f, 0.06399429f, -0.52445364f, -0.33502811f, 
    0.00713764f, 0.16078836f, -0.07556183f, -0.16208754f, 0.11317448f, 0.04579392f, 0.05849257f, -0.35980070f, 
    0.12356538f, 0.28159544f, 0.11529067f, -0.01953733f, -0.18731439f, 0.04235295f, -0.18343903f, 0.28565902f, 
    -0.01711033f, 0.07298358f, -0.11039112f, -0.25886968f, 0.01614305f, -0.15046465f, 0.02973012f, 0.00541670f, 
    -0.02507128f, -0.19394787f, 0.20696774f, 0.19484805f, -0.06633305f, -0.07953181f, 0.00870447f, 0.07685772f, 
    0.09582148f, -0.00775715f, -0.19608921f, -0.33802247f, 0.01265433f, 0.03507093f, -0.15965362f, -0.03973621f, 
    0.01217042f, -0.08541390f, -0.01513319f, 0.15282221f, 0.20139326f, 0.30819371f, -0.23479147f, -0.01281133f, 
    -0.03448005f, 0.14236490f, -0.21164820f, 0.02517838f, -0.31294960f, -0.17792225f, 0.05315052f, -0.05005632f, 
    -0.19161782f, -0.27679926f, -0.10861463f, -0.02851903f, 0.08693162f, 0.58865297f, 0.13124371f, -0.15096900f, 
    -0.07214691f, -0.08294927f, -0.19450313f, -0.19524117f, 0.11655080f, 0.00352346f, 0.10228901f, -0.04327597f, 
    -0.03955619f, -0.00425688f, -0.04632521f, 0.01002600f, 0.05974465f, -0.03543776f, 0.11917397f, 0.11707511f, 
    -0.88206667f, 0.08095434f, 0.26177418f, 0.07669050f, -0.15555224f, -0.12642767f, -0.11630324f, 0.09605456f, 
    -0.21425077f, 0.08517495f, 0.08510546f, -0.06547080f, -0.11659131f, 0.01040041f, 0.04621255f, -0.12280090f, 
    0.11761890f, -0.11293235f, 0.12136310f, 0.03531287f, -0.03204733f, 0.11936830f, 0.15642963f, 0.00500066f, 
    -0.01078566f, -0.09600098f, -0.11612265f, 0.10564978f, 0.18308945f, 0.03765852f, 0.03718256f, 0.09099819f, 
    0.20826299f, 0.04656313f, -0.08812541f, 0.08279220f, 0.23004444f, 0.41178274f, -0.08660194f, -0.15866725f, 
    0.10727214f, 0.18555436f, 0.15425369f, 0.23517068f, -0.26315957f, -0.08092292f, -0.03329219f, -0.02101167f, 
    -0.01228652f, 0.06916316f, 0.04980702f, 0.08507380f, 0.00148779f, -0.06613869f, -0.17165922f, -0.21540040f, 
    -0.14688499f, -0.11558739f, 0.20407781f, -0.12266780f, -0.00696286f, 0.17319478f, -0.17385456f, -0.35322475f, 
    -0.17180908f, 0.03939006f, 0.00212919f, 0.12585460f, -0.06468674f, 0.05422098f, 0.11283136f, -0.09136325f, 
    0.36814138f, 0.06017860f, 0.06435048f, 0.04588510f, 0.10095264f, 0.24552584f, -0.06726355f, -0.06933992f, 
    0.12254232f, -0.11427161f, -0.19847563f, -0.12941378f, -0.01163167f, 0.06521513f, -0.07836138f, 0.09045251f, 
    0.05870645f, -0.29146788f, -0.19515480f, -0.32156268f, -0.33928737f, -0.22244811f, -0.26399189f, -0.04067545f, 
    -0.07612145f, -0.14673615f, -0.00211066f, 0.37382409f, 0.31398907f, 0.07798538f, 0.12026489f, 0.00129600f, 
    0.24508539f, 0.06040302f, 0.03568820f, -0.21667482f, 0.01293250f, 0.00954504f, 0.07725263f, 0.09425982f, 
    -0.08608700f, -0.31415430f, -0.14817509f, 0.15697259f, -0.18857892f, -0.06736601f, 0.17534794f, -0.00028105f, 
    -0.24513121f, -0.13422538f, -0.00087697f, -0.07055857f, 0.12199489f, 0.21224150f, 0.17874172f, 0.00350396f, 
    -0.00034384f, 0.17269358f, -0.17568831f, 0.18770806f, -0.02928424f, -0.00962382f, -0.27379793f, 0.02765250f, 
    -0.14592046f, 0.03294274f, -0.04771494f, -0.19390561f, 0.13832951f, -0.01565134f, -0.12779756f, -0.18108115f, 
    -0.13552551f, -0.29834670f, -0.20008129f, -0.16380545f, 0.03326089f, 0.26569429f, 0.03518910f, 0.07043763f, 
    -0.08995187f, 0.32765633f, 0.33000657f, 0.00114322f, -0.07968117f, 0.00026767f, 0.20609896f, 0.00204988f, 
    0.03221156f, -0.11898991f, -0.24914069f, -0.06861344f, 0.00027294f, 0.00458311f, 0.06628693f, -0.00795597f, 
    0.23890382f, 0.06653593f, 0.23526154f, 0.07901399f, 0.30561635f, 0.14452015f, -0.17571110f, -0.03452971f, 
    -0.00071932f, -0.00951516f, -0.12734516f, 0.39887336f, 0.17669560f, 0.07734164f, 0.12761612f, 0.05268718f, 
    -0.12973754f, 0.05692168f, -0.08513424f, -0.08198527f, 0.06825631f, -0.21496160f, 0.08571345f, 0.17883436f, 
    0.27309281f, 0.05529632f, 0.09637647f, -0.02943285f, 0.10896261f, -0.49445194f, -0.33090943f, -0.20902762f, 
    -0.24566078f, -0.31599975f, 0.04256460f, -0.04550998f, 0.03273840f, 0.09572161f, -0.01664368f, -0.04459601f, 
    -0.17138684f, 0.04280814f, -0.18813707f, 0.01052655f, 0.11822999f, -0.03704487f, 0.05416381f, -0.33140939f, 
    -0.20394167f, -0.13398692f, -0.15386356f, -0.35024685f, -0.09615438f, 0.07077383f, 0.13789955f, -0.10503019f, 
    -0.02993623f, 0.04184697f, -0.19665855f, -0.18371443f, -0.08426460f, 0.00226802f, 0.09641030f, 0.15297799f, 
    0.09376188f, -0.01167943f, 0.01904241f, 0.22154011f, 0.11724616f, 0.02137889f, 0.04729795f, 0.09330847f, 
    0.06448048f, 0.06676963f, -0.23315427f, -0.14557113f, 0.01561785f, -0.09856271f, 0.00322563f, -0.08664440f, 
    -0.05193808f, 0.02815431f, 0.06609577f, -0.20670410f, 0.43177474f, 0.25183818f, 0.09516093f, 0.14282621f, 
    0.21034688f, 0.18637794f, 0.28068379f, 0.06342251f, -0.51166052f, -0.13323198f, -0.00394664f, -0.22436859f, 
    -0.31880119f, 0.04903454f, -0.13732392f, -0.01973171f, 0.16721420f, 0.65293294f, 0.00919216f, 0.04448372f, 
    0.00379281f, 0.34243166f, 0.21246873f, -0.09675094f, 0.21020068f, 0.28675088f, 0.10802636f, -0.05012452f, 
    0.05510470f, 0.04352294f, 0.20240498f, -0.03422996f, 0.18522346f, 0.18782368f, 0.01222491f, -0.25947845f, 
    0.19128090f, 0.18431824f, 0.03596758f, -0.03205366f, -0.14257784f, 0.06799655f, 0.11898637f, 0.17802230f, 
    -0.11613975f, -0.17155167f, -0.03478599f, 0.02159828f, 0.17226644f, 0.06006117f, 0.01029510f, -0.01440891f, 
    0.08739106f, -0.23037648f, 0.06930432f, 0.23844564f, 0.19981827f, 0.14457169f, 0.11088904f, 0.10747825f, 
    0.13451910f, 0.20087273f, 0.12365590f, -0.05383035f, 0.24755286f, 0.12772655f, -0.01323891f, -0.04415174f, 
    -0.05199472f, -0.07040105f, -0.19344820f, 0.02278568f, 0.31206563f, 0.39164206f, 0.14310199f, 0.08667475f, 
    -0.08482046f, 0.16111510f, 0.04667152f, 0.17228992f, -0.06088638f, 0.09593713f, -0.27651331f, 0.07466342f, 
    0.07956655f, 0.00902399f, 0.15413643f, 0.20337789f, 0.08024295f, 0.48472768f, -0.36573839f, 0.17795785f, 
    0.00101896f, 0.18010972f, -0.10588256f, 0.16684489f, -0.00113228f, -0.00909737f, 0.24531655f, -0.00571432f, 
    0.32238448f, 0.21728092f, 0.20973542f, 0.23153049f, 0.11635318f, 0.10975226f, 0.13842647f, -0.02500978f, 
    0.11444484f, 0.09345368f, 0.03298259f, 0.16110663f, 0.05120895f, 0.18896902f, 0.17222984f, 0.18602188f, 
    0.08178479f, -0.16172805f, 0.02964109f, 0.05541803f, 0.05582907f, -0.03762949f, 0.04650788f, -0.31452471f, 
    -0.20470007f, -0.01767427f, 0.02401928f, -0.02550392f, -0.19932537f, -0.03240243f, -0.11168670f, 0.10955368f, 
    0.12501860f, 0.05476201f, 0.03589412f, -0.02874678f, -0.12234129f, 0.02519077f, -0.12992902f, 0.11253916f, 
    -0.00403605f, -0.14146109f, 0.08151535f, -0.02964484f, 0.11379416f, -0.05657067f, 0.01535132f, -0.06345185f, 
    -0.07993430f, 0.02493089f, -0.18701035f, -0.30053237f, -0.07114780f, -0.30748871f, -0.02727999f, 0.04760285f, 
    0.25331816f, -0.07382651f, 0.10842622f, -0.02517786f, -0.11207560f, 0.04349713f, -0.05255276f, -0.08987007f, 
    -0.00514252f, 0.03343567f, 0.00216940f, 0.06128361f, -0.10550218f, 0.01331414f, -0.43297222f, -0.31736577f, 
    -0.10613690f, -0.10498641f, 0.05608709f, -0.08837824f, -0.00610943f, 0.25593248f, -0.03735588f, 0.01707654f, 
    0.07884638f, 0.03851627f, -0.21823847f, -0.08669507f, 0.09523449f, 0.06198118f, 0.03474125f, -0.07034368f, 
    -0.09857963f, 0.16757354f, -0.02284259f, 0.09827571f, 0.11811161f, 0.06730279f, -0.17168467f, -0.36947018f, 
    -0.11523129f, 0.01540747f, -0.10227706f, 0.06127407f, -0.07979057f, 0.03841827f, 0.02418659f, 0.06604146f, 
    0.10171088f, -0.06453238f, 0.12022046f, -0.17752044f, -0.07410160f, -0.10488658f, 0.15918262f, 0.17341577f, 
    0.14285839f, 0.17793760f, 0.32686678f, -0.27859670f, -0.12963709f, 0.01179931f, 0.19685780f, -0.12310249f, 
    0.04693762f, -0.14350966f, 0.26438665f, 0.29825717f, 0.00476173f, -0.10539315f, 0.01002560f, 0.31601554f, 
    0.21769708f, 0.24826750f, 0.06558640f, 0.18921351f, -0.02527026f, -0.35144031f, 0.05107388f, 0.19701619f, 
    -0.02256816f, -0.02441225f, 0.04929966f, -0.05369997f, 0.03548972f, 0.01865090f, 0.21323289f, 0.07531585f, 
    0.05645908f, -0.01265021f, 0.13315263f, -0.08737847f, 0.07064456f, 0.03252914f, -0.02312790f, -0.29724795f, 
    0.00561777f, -0.12858839f, 0.00293616f, 0.02859814f, -0.08993963f, 0.00601409f, 0.02269535f, -0.01542123f, 
    0.33537462f, -0.00764430f, -0.10258444f, -0.17671281f, -0.01481466f, 0.23348351f, 0.27006611f, 0.22970007f, 
    -0.18750723f, 0.05947520f, 0.02841073f, -0.07337393f, -0.15304999f, 0.12039417f, 0.06001793f, -0.04302138f, 
    0.02059627f, 0.11378255f, -0.17673475f, 0.12701154f, -0.01997923f, 0.07254144f, 0.09179591f, 0.10266054f, 
    0.07354166f, -0.14090756f, -0.19011535f, -0.30552796f, 0.13970435f, -0.08327139f, 0.05927217f, 0.28626147f, 
    0.09350519f, 0.11499593f, -0.02286152f, -0.00927013f, -0.04070562f, 0.06988207f, 0.15767390f, -0.06260308f, 
    0.14007059f, 0.22689655f, 0.15697530f, 0.05638642f, -0.09481862f, -0.20782611f, -0.09277449f, 0.13038102f, 
    0.07871168f, -0.07064320f, 0.08052448f, 0.04054287f, 0.13756096f, 0.11517718f, 0.21989413f, -0.01271861f, 
    0.03667712f, -0.07337223f, 0.05642095f, 0.01460386f, -0.08851878f, 0.23713534f, 0.07542534f, 0.01397466f, 
    0.17555517f, -0.08727545f, 0.22463727f, 0.18496254f, -0.01216647f, 0.11301016f, 0.11593335f, -0.21474901f, 
    -0.12558375f, -0.03253228f, 0.04424349f, 0.00307515f, 0.05030377f, -0.11061970f, 0.21054550f, -0.11453466f, 
    0.05656958f, -0.12522896f, 0.09752221f, 0.15716492f, -0.05629785f, -0.02912520f, -0.15879947f, -0.00827255f, 
    -0.05205189f, 0.04269359f, 0.11196431f, -0.07457366f, -0.27731690f, 0.18983191f, 0.11800718f, 0.15780658f, 
    -0.03397930f, -0.07722337f, -0.08795450f, 0.21539189f, -0.10839038f, -0.20009902f, 0.05221299f, -0.15756135f, 
    0.03561316f, -0.01111022f, 0.03204874f, 0.12067593f, -0.05514315f, 0.09397958f, 0.01088436f, -0.03223271f, 
    0.21148650f, -0.00526708f, 0.03637219f, -0.01534266f, -0.00713101f, 0.00090759f, 0.03733205f, -0.13443750f, 
    -0.10710591f, -0.07672728f, -0.18235558f, 0.11913449f, 0.11536136f, -0.05666016f, 0.39926159f, -0.00960642f, 
    0.20307012f, 0.23348266f, 0.11355579f, 0.12720987f, 0.24747407f, -0.15820171f, 0.05921983f, 0.09849215f, 
    -0.10278246f, -0.09054934f, -0.36287197f, -0.13146693f, -0.03108285f, 0.05838206f, 0.01948458f, 0.18232663f, 
    0.02852854f, 0.03313270f, -0.03432497f, 0.05664269f, -0.07191388f, -0.06124398f, -0.12766388f, -0.02823324f, 
    -0.22666228f, 0.12992476f, -0.03720520f, 0.07702155f, 0.19751914f, 0.07171969f, 0.09819693f, 0.09648836f, 
    0.11959968f, -0.22686404f, -0.29946262f, 0.12941399f, 0.14882486f, -0.12951379f, -0.05268013f, 0.06344722f, 
    0.18879487f, 0.30238563f, 0.04605589f, 0.00198113f, -0.00565369f, -0.21429159f, 0.30786273f, -0.02848806f, 
    -0.02046050f, -0.48888072f, -0.42269483f, -0.44597876f, 0.16631453f, 0.01436166f, 0.28318846f, -0.06274391f, 
    -0.04417788f, 0.19899675f, 0.06328085f, -0.06098432f, 0.03747306f, -0.34076905f, 0.27675864f, 0.05838713f, 
    0.06005491f, 0.20566325f, -0.11865687f, -0.16442065f, 0.01880108f, -0.07416244f, 0.12380479f, 0.05774682f, 
    0.15968560f, 0.20274322f, 0.25980496f, -0.03093076f, 0.17097804f, 0.07568464f, 0.00153074f, 0.13627401f, 
    0.02845654f, 0.19954640f, 0.12438650f, 0.15622202f, 0.10198565f, 0.02069138f, 0.09422145f, -0.18237482f, 
    -0.03993275f, 0.01157393f, -0.04038903f, -0.06343015f, -0.21198747f, -0.15808342f, 0.08952244f, 0.05929189f, 
    0.09077449f, 0.08707903f, -0.02617363f, 0.13628149f, 0.10317494f, 0.19796994f, 0.17666171f, 0.04532911f, 
    -0.01625087f, -0.31244600f, -0.03672922f, 0.52583957f, -0.24946503f, -0.20441614f, -0.02035461f, -0.27561244f, 
    0.05745336f, 0.19995987f, 0.00154367f, -0.02898577f, 0.15914530f, 0.22601186f, -0.05379765f, -0.08636781f, 
    -0.03332352f, 0.15930742f, 0.13758303f, 0.13083860f, 0.01969047f, 0.23889208f, 0.28986946f, -0.03412583f, 
    -0.08069029f, -0.06729124f, -0.10697061f, 0.01828480f, -0.17352714f, 0.29210231f, 0.38951030f, -0.08806806f, 
    0.23774096f, 0.01634615f, -0.08595200f, 0.12048790f, -0.12914976f, 0.03713738f, -0.10329592f, 0.18756914f, 
    -0.02161133f, 0.08541093f, -0.13591065f, 0.10442117f, 0.13311391f, 0.14165874f, 0.08387832f, 0.28998321f, 
    0.11486159f, -0.01976656f, 0.02920238f, 0.11765278f, -0.00555173f, 0.15762675f, 0.12420752f, 0.12220092f, 
    -0.00666744f, -0.05655307f, 0.36498889f, -0.00809400f, 0.08942774f, 0.15117842f, -0.25664094f, -0.04221335f, 
    -0.31383160f, -0.03111894f, 0.17444019f, 0.00626179f, -0.17396645f, 0.15622982f, 0.04843718f, -0.11955918f, 
    0.05827686f, 0.05326695f, 0.21599156f, 0.05859112f, -0.05096325f, 0.22484426f, 0.12565379f, -0.02308930f, 
    -0.16763148f, -0.34684634f, -0.45947224f, 0.09556700f, 0.20193844f, 0.14919133f, -0.01306496f, -0.08467633f, 
    0.01681590f, 0.20902184f, -0.06972008f, -0.11004864f, 0.08543947f, 0.24617630f, -0.06541437f, 0.10390898f, 
    0.09462471f, 0.00633043f, -0.14069276f, -0.11860371f, -0.01055669f, -0.01556372f, -0.32372791f, 0.41822854f, 
    0.03712242f, 0.27429804f, 0.25893903f, 0.11351252f, 0.07055650f, -0.05273968f, 0.13529663f, 0.03355432f, 
    0.15607877f, 0.08392948f, 0.18724652f, 0.08330084f, -0.02738579f, 0.12527442f, 0.14327936f, 0.07926627f, 
    0.13224703f, 0.45322710f, 0.12551305f, -0.01552369f, -0.05126011f, 0.03810748f, 0.03501415f, 0.20828873f, 
    0.09959105f, -0.00108754f, 0.06318100f, -0.00619026f, 0.03981123f, 0.04210523f, 0.06207099f, -0.12872949f, 
    -0.42517406f, 0.01766128f, 0.01647890f, -0.01502915f, 0.06532759f, 0.00771920f, 0.06474885f, -0.08352494f, 
    -0.22107323f, -0.38282061f, -0.03497648f, 0.16491288f, -0.15149294f, 0.00793504f, 0.01636899f, -0.00908265f, 
    0.02261660f, -0.04199133f, -0.07857925f, -0.05001217f, 0.17423083f, 0.15415317f, -0.07309940f, -0.02095984f, 
    0.07269610f, 0.08923292f, 0.07988292f, -0.04625631f, -0.15477042f, 0.19724369f, -0.02786982f, -0.12240458f, 
    -0.02195817f, -0.11744075f, 0.12393936f, -0.07675747f, 0.06315152f, -0.05473075f, 0.02141308f, 0.22075482f, 
    0.04887933f, 0.05435166f, 0.27456018f, -0.30546841f, -0.12966231f, -0.20149364f, -0.15715872f, 0.05619647f, 
    -0.08934763f, -0.19038954f, 0.16170561f, 0.00994701f, -0.13220717f, 0.04613318f, 0.18495533f, 0.10630848f, 
    -0.07546532f, 0.02674357f, 0.16195105f, 0.27839881f, 0.20082463f, 0.12588829f, 0.15416338f, 0.27840555f, 
    -0.01101696f, -0.01623565f, -0.04297110f, -0.05176011f, -0.04507374f, -0.03296503f, -0.06522395f, -0.04319446f, 
    -0.03987946f, 0.01659127f, -0.03866005f, 0.00579965f, -0.03140820f, -0.04708623f, 0.06297164f, -0.04239149f, 
    0.03853954f, 0.02844476f, -0.01028140f, -0.05752587f, 0.02883676f, 0.00911939f, -0.05948986f, 0.00478617f, 
    0.02106352f, -0.04117656f, -0.01509534f, -0.00518533f, -0.02900097f, -0.03958682f, -0.03989678f, -0.05885613f, 
    -0.00986915f, -0.04310158f, -0.00092583f, 0.01970193f, -0.01183865f, -0.03563347f, -0.00832865f, 0.00927642f, 
    0.02212494f, -0.02336127f, -0.02988968f, 0.01745623f, -0.04956806f, 0.01526606f, 0.00672220f, -0.02178928f, 
    0.02195247f, -0.03431949f, -0.05710454f, -0.03658098f, 0.00937445f, 0.03026466f, -0.03201073f, -0.03421190f, 
    -0.05740694f, 0.04224898f, 0.01062924f, 0.04996203f, 0.03459457f, -0.03671787f, -0.02100357f, 0.00291119f, 
    0.04777595f, -0.05885391f, -0.05258493f, -0.01531636f, -0.03978254f, 0.02543545f, 0.04188773f, -0.02910201f, 
    -0.04350934f, -0.02626151f, -0.00945541f, -0.02333498f, -0.02560346f, -0.05026050f, -0.02071464f, 0.00283416f, 
    0.05020038f, 0.01583982f, -0.02515840f, 0.06025067f, 0.04300177f, -0.05781160f, -0.03930050f, 0.00895850f, 
    0.02525592f, -0.01317190f, 0.00098508f, 0.05134529f, 0.03295285f, -0.01903732f, -0.00390550f, 0.00788647f, 
    0.03736618f, -0.05798167f, 0.01748198f, -0.06186733f, 0.03161868f, 0.00494971f, -0.02300858f, 0.03878767f, 
    0.03118008f, -0.00278532f, -0.03066126f, -0.01216568f, -0.00626732f, -0.05417543f, -0.04690310f, -0.03700667f, 
    -0.01732581f, -0.01365502f, 0.01722377f, 0.03379308f, -0.01861602f, -0.05127072f, 0.02643732f, -0.02457535f, 
    -0.00908950f, 0.04785229f, 0.00096713f, 0.03692193f, -0.05712872f, 0.00320369f, -0.01322015f, -0.00078874f, 
    0.02141673f, -0.02476509f, 0.01542909f, -0.04902575f, 0.03028284f, 0.00119325f, 0.02213781f, -0.05770940f, 
    -0.04722854f, -0.02772844f, -0.01944490f, -0.06429905f, 0.03465958f, -0.02634596f, -0.08087744f, 0.00209679f, 
    0.02105802f, 0.01686895f, 0.02118852f, -0.02759731f, -0.02433991f, 0.00410244f, 0.04310215f, 0.03994051f, 
    0.05229306f, -0.03348012f, -0.06163127f, -0.05897640f, 0.03480317f, 0.00416307f, -0.04360008f, -0.03155978f, 
    0.02633125f, 0.02242105f, -0.02385630f, 0.01201661f, 0.04867669f, 0.02985684f, 0.01752517f, 0.03544885f, 
    0.03861354f, 0.00845349f, 0.04238772f, -0.00864516f, -0.02479948f, -0.04328610f, -0.05747014f, 0.01330208f, 
    0.03116770f, 0.02627991f, -0.04118562f, -0.01873884f, -0.01342536f, 0.04842447f, 0.02059763f, -0.04371146f, 
    0.00838844f, 0.03203101f, -0.04775776f, 0.01089533f, 0.03675674f, -0.00528097f, -0.00966826f, -0.05180724f, 
    -0.04836528f, -0.01606452f, -0.02830442f, -0.01583891f, 0.02159403f, 0.02590276f, 0.04987601f, 0.02403627f, 
    -0.02721654f, 0.00644759f, -0.06711926f, -0.04651424f, 0.00925199f, -0.03678786f, 0.04011417f, 0.00469629f, 
    -0.04963660f, 0.04368696f, 0.02779136f, -0.03024948f, 0.00835131f, -0.02813308f, 0.00162239f, -0.05092344f, 
    0.01462929f, 0.04535376f, -0.00094728f, 0.03233453f, 0.01166409f, -0.00115021f, -0.02730894f, 0.02722627f, 
    0.01304770f, -0.05758673f, -0.00612939f, 0.00656247f, -0.06172752f, -0.02811584f, -0.00205285f, 0.02585152f, 
    0.04293622f, -0.01992917f, 0.01709336f, -0.01959158f, -0.05544417f, -0.01038201f, 0.04940752f, 0.05065076f, 
    -0.01106399f, -0.04594115f, 0.01160581f, -0.02514860f, 0.00705614f, 0.01164368f, 0.03950974f, 0.04754997f, 
    0.04713826f, -0.01906713f, 0.00269455f, -0.04858250f, -0.05890859f, -0.06475845f, 0.02113137f, -0.01030587f, 
    0.02681929f, -0.05538452f, 0.03606455f, -0.02554160f, -0.02950001f, -0.02684805f, -0.06971844f, 0.04068623f, 
    0.00857019f, -0.04509466f, -0.03648686f, 0.01961058f, -0.06221714f, -0.02885153f, 0.03895905f, -0.04193588f, 
    0.02681852f, 0.02905798f, -0.01952727f, 0.04911477f, -0.01217337f, 0.01050349f, 0.01157622f, 0.00642647f, 
    0.00446145f, -0.00957513f, 0.01731182f, -0.00442467f, -0.00877713f, 0.00898844f, -0.04499021f, 0.03784365f, 
    -0.03894572f, -0.03405010f, -0.06408443f, 0.00160582f, -0.00127487f, 0.00825063f, 0.04513360f, -0.01741835f, 
    -0.05950709f, -0.01107518f, -0.03393956f, -0.05901824f, -0.06240838f, 0.02201837f, -0.02106551f, 0.01407035f, 
    -0.00569333f, 0.02495255f, -0.00266865f, 0.01121343f, 0.00414534f, -0.00876147f, -0.04708264f, -0.06269467f, 
    0.03586145f, 0.03782253f, -0.05820810f, -0.02169596f, 0.01326422f, -0.02464258f, -0.01501720f, -0.01815871f, 
    -0.00532815f, 0.00712454f, -0.04311951f, 0.02267818f, -0.05447049f, -0.02148934f, 0.02643219f, -0.06110702f, 
    0.03179786f, 0.00245593f, 0.01036846f, 0.00497758f, 0.01090348f, 0.00129927f, -0.02674772f, -0.01564350f, 
    0.01648537f, 0.03947235f, 0.01525736f, -0.01027373f, -0.06150036f, -0.00470538f, -0.03070316f, -0.00982499f, 
    0.02155625f, 0.00755936f, -0.04381193f, 0.02633228f, 0.04687751f, 0.00624861f, -0.03539149f, -0.01680246f, 
    0.02053366f, 0.04335268f, -0.06143031f, -0.05101801f, 0.02938277f, -0.00612014f, 0.00683438f, -0.02367727f, 
    0.01611619f, 0.03147556f, 0.01025255f, -0.02076322f, 0.02008320f, -0.02208907f, -0.04298657f, -0.02760163f, 
    0.01783064f, 0.03962817f, 0.04300551f, -0.04753263f, -0.05635386f, 0.01302578f, 0.01951494f, 0.03035660f, 
    -0.03075161f, -0.01653974f, -0.00779510f, -0.05519905f, 0.02466931f, 0.04844383f, -0.01878196f, -0.06052146f, 
    -0.00243208f, 0.02349727f, -0.02479279f, -0.00639950f, 0.00739195f, -0.05385611f, -0.00292664f, -0.05493634f, 
    0.02736566f, 0.02957303f, -0.05353818f, -0.06414565f, -0.05485778f, 0.00523675f, -0.05448934f, -0.03614723f, 
    0.03942339f, 0.03116477f, -0.04700948f, 0.04709673f, 0.02438985f, -0.00836112f, -0.01648737f, 0.02614061f, 
    0.01184266f, 0.02304360f, 0.04144484f, 0.03994622f, -0.04158390f, 0.02468520f, -0.02442844f, 0.02027926f, 
    0.02148166f, 0.01055751f, -0.00744979f, 0.00884710f, 0.03037385f, -0.01749725f, -0.00314266f, -0.04890483f, 
    0.03667466f, -0.06308443f, -0.04650585f, 0.04809251f, 0.02923258f, 0.02311310f, 0.04722529f, 0.00407083f, 
    -0.05711068f, -0.06104311f, -0.00805366f, -0.04071371f, -0.02263613f, -0.01790869f, -0.05191558f, -0.04433440f, 
    -0.01352170f, 0.00138901f, -0.03874187f, -0.00671148f, -0.03870204f, -0.00056821f, -0.03645150f, -0.04271673f, 
    -0.02835024f, -0.04395846f, -0.00217153f, -0.02322624f, -0.03484309f, -0.02536490f, 0.02973483f, -0.00730635f, 
    -0.02981412f, -0.04162851f, 0.03030724f, 0.04359680f, 0.03865122f, -0.03278461f, -0.05616893f, -0.01420092f, 
    0.00099142f, 0.01359681f, -0.01160817f, -0.02113083f, 0.00519960f, 0.03158989f, -0.05884088f, 0.00360283f, 
    -0.02879060f, 0.00380916f, 0.03489994f, -0.05429982f, 0.00315957f, 0.03925727f, 0.01813192f, -0.06750344f, 
    -0.03479407f, -0.03523117f, -0.02400273f, -0.00472570f, -0.05565188f, 0.03266012f, 0.06181094f, 0.00848187f, 
    0.00962780f, -0.05302964f, 0.02730105f, 0.02659543f, 0.02720234f, -0.04068746f, 0.03874823f, -0.02510200f, 
    -0.00441918f, 0.01863050f, 0.04600133f, -0.02550005f, -0.00782510f, -0.05228155f, -0.00496610f, 0.02007978f, 
    -0.06035260f, 0.04759424f, 0.00904672f, -0.01811932f, -0.04686891f, -0.05775573f, -0.00564065f, 0.03771390f, 
    -0.02147837f, -0.01025132f, -0.03686222f, 0.04258567f, -0.00970002f, -0.05532614f, 0.01054000f, -0.04959632f, 
    -0.02739602f, -0.01020094f, 0.01587140f, -0.01994882f, 0.00832474f, 0.01937133f, 0.01393882f, 0.02370992f, 
    0.01929765f, 0.00513490f, -0.00628379f, -0.05249220f, -0.01822368f, -0.05048048f, 0.01732789f, -0.01090468f, 
    0.04677231f, 0.01944013f, 0.00573526f, -0.01882103f, -0.04972813f, -0.06304377f, -0.04403739f, -0.03309670f, 
    -0.05140802f, 0.02180950f, -0.03138359f, 0.04038757f, 0.02255537f, 0.02403381f, 0.01017006f, 0.01149540f, 
    0.03807881f, -0.03362158f, 0.02539453f, -0.04295151f, 0.03795235f, -0.03533063f, 0.03759975f, 0.03614161f, 
    0.01179042f, -0.03774953f, 0.03951711f, -0.05349652f, -0.02686615f, 0.01878615f, 0.02553833f, 0.02238025f, 
    -0.01657591f, 0.01265325f, -0.03741403f, -0.00285427f, 0.01748293f, 0.05213344f, -0.03970074f, 0.03953064f, 
    -0.02620929f, -0.00531772f, 0.01694342f, -0.02712081f, -0.00750271f, -0.04410383f, 0.01017006f, 0.04629287f, 
    -0.03849898f, -0.03925831f, -0.06179131f, 0.00085593f, 0.03059302f, 0.01209415f, 0.02348887f, -0.03985138f, 
    0.02484634f, 0.03440498f, -0.04673398f, 0.01146027f, 0.01250193f, 0.02021841f, 0.02487444f, 0.04564533f, 
    0.03764922f, -0.02211713f, 0.03783688f, -0.03222257f, 0.05644739f, -0.03958633f, -0.00696857f, 0.03742798f, 
    -0.04738396f, -0.01627582f, -0.04547907f, -0.04258565f, -0.02773205f, 0.01835570f, -0.02275851f, -0.05951612f, 
    0.04538834f, 0.02006215f, 0.00519793f, -0.01525565f, -0.06412628f, -0.06360984f, 0.02472823f, -0.04125359f, 
    0.03649803f, 0.02700836f, -0.05475634f, -0.05785602f, 0.04079688f, -0.05989808f, 0.02349058f, -0.04396074f, 
    -0.00135290f, 0.01108446f, -0.01976872f, -0.01170576f, 0.04745341f, 0.03090517f, 0.05520444f, 0.03491337f, 
    0.04829123f, 0.03049502f, -0.03317065f, -0.06577760f, -0.05473979f, 0.02756125f, -0.00471776f, 0.00220136f, 
    0.04623324f, 0.02272891f, -0.01389857f, -0.05883233f, -0.01496049f, 0.00591484f, -0.06541409f, -0.06331156f, 
    0.04377755f, 0.02195744f, -0.05943356f, 0.03868649f, -0.01680750f, 0.00309699f, 0.03862402f, 0.00774731f, 
    0.00347318f, 0.00732317f, -0.04605850f, 0.04191550f, 0.02542714f, 0.01365504f, -0.02864838f, -0.03131860f, 
    0.04721645f, -0.01359485f, -0.00475131f, -0.01944394f, -0.02383076f, -0.02219263f, -0.00553519f, -0.01763085f, 
    -0.02035220f, 0.04063617f, -0.03778417f, 0.02393781f, -0.02154140f, -0.02945478f, -0.00746040f, -0.00941012f, 
    -0.05646911f, 0.03584372f, 0.03770130f, -0.01584274f, -0.06859725f, -0.04702529f, -0.02504698f, -0.00408049f, 
    -0.05701485f, -0.01303207f, -0.02381867f, -0.06046159f, 0.01567980f, 0.02670982f, 0.04051955f, 0.02832529f, 
    -0.02084306f, -0.01831315f, 0.03564059f, 0.02378109f, -0.02655537f, -0.01124367f, -0.04690236f, -0.06082651f, 
    0.02716254f, -0.02572639f, -0.05469278f, -0.05752208f, -0.00791385f, -0.01675968f, 0.02162726f, 0.00769499f, 
    0.01869811f, -0.04404077f, 0.05285145f, 0.01273156f, 0.00561776f, -0.04687234f, -0.01748246f, -0.03930382f, 
    -0.02107568f, 0.03759721f, 0.02195489f, -0.01592317f, 0.04563753f, -0.00000200f, -0.04122731f, 0.00795394f, 
    0.03898615f, 0.01951565f, -0.00354083f, 0.03803696f, 0.02315108f, -0.04816020f, 0.04678944f, 0.00918514f, 
    0.02005939f, 0.02186043f, -0.01934844f, 0.04740265f, -0.02579293f, -0.03177332f, -0.01519020f, 0.01480306f, 
    -0.01231135f, -0.02215590f, 0.00181091f, -0.03394238f, 0.04690188f, -0.05104614f, 0.02969108f, -0.01384222f, 
    0.00098570f, 0.04619344f, -0.04171469f, 0.04623696f, 0.02175464f, 0.02247835f, 0.03265912f, -0.03295567f, 
    0.05180167f, -0.03288471f, -0.05395701f, -0.04900365f, 0.04471153f, 0.04469046f, -0.04334206f, -0.03796576f, 
    0.01753003f, 0.03257902f, -0.06009641f, 0.00024863f, -0.02355022f, 0.01197062f, -0.05067132f, -0.03466154f, 
    0.04882286f, -0.04831113f, -0.00818902f, 0.03568060f, -0.06379183f, -0.01524934f, -0.00947026f, -0.03822307f, 
    0.01778202f, 0.00822494f, 0.05031423f, -0.02576512f, -0.06130052f, -0.05278853f, 0.00485854f, -0.00343041f, 
    -0.05046436f, -0.03675895f, -0.03992016f, 0.04617041f, -0.02222905f, -0.06264788f, -0.04383801f, -0.02549718f, 
    0.00883791f, -0.01057847f, -0.01195051f, -0.01004524f, -0.06087310f, -0.04770947f, -0.00994657f, -0.05003345f, 
    -0.06260452f, -0.01005699f, -0.06390793f, -0.03634817f, -0.00295478f, -0.00694282f, 0.04508368f, -0.05641650f, 
    -0.06436751f, -0.06284025f, 0.00911957f, -0.03360300f, 0.03240178f, -0.00421828f, -0.02743894f, -0.04717403f, 
    0.04885883f, -0.02384089f, -0.01204941f, -0.01306292f, 0.00116827f, -0.06089949f, -0.01318273f, 0.03282772f, 
    0.03031077f, -0.06168137f, -0.05417364f, -0.00006037f, -0.05337527f, 0.01346943f, -0.04615128f, -0.02864416f, 
    0.00510248f, 0.03685326f, 0.01912399f, -0.01552251f, 0.04689989f, 0.02772260f, -0.04016626f, 0.02641381f, 
    0.04602381f, -0.01156747f, 0.01426224f, -0.04079128f, 0.01446486f, -0.04260124f, 0.00215582f, 0.02111520f, 
    0.14139225f, -0.00217866f, 0.09106977f, -0.15845081f, -0.00969107f, -0.01803511f, 0.22351351f, 0.08033913f, 
    0.07709020f, 0.24058442f, 0.09560841f, 0.37023664f, -0.14098452f, -0.19741802f, -0.27504870f, 0.12392917f, 
    -0.00709851f, 0.15581335f, 0.26129037f, -0.32499057f, -0.40386853f, -0.24852830f, -0.28376424f, -0.12208188f, 
    0.15613025f, 0.01758143f, -0.05029348f, 0.51953340f, 0.12010433f, 0.31631562f, 0.04826708f, 0.16103955f, 
    0.08902447f, 0.08702383f, 0.22468700f, 0.19005898f, 0.37009180f, 0.16453075f, -0.00348935f, -0.19210793f, 
    -0.02859863f, -0.05128430f, 0.16870885f, 0.11119031f, -0.10933435f, 0.03419745f, -0.21036716f, 0.23437159f, 
    -0.16549447f, 0.10327902f, -0.01416916f, 0.10294975f, 0.08436164f, -0.42266908f, 0.19644192f, -0.00425654f, 
    0.13907190f, 0.08854859f, 0.01992103f, 0.06191896f, -0.20621942f, -0.04125293f, -0.46487027f, 0.11403161f, 
    -0.04506643f, 0.27828884f, -0.02102949f, -0.15228392f, -0.05035153f, -0.03758485f, 0.05471675f, 0.16108753f, 
    0.33455396f, -0.17999803f, -0.27648360f, 0.11969831f, 0.00161414f, -0.13655646f, 0.19007520f, -0.04586105f, 
    0.01117891f, 0.12628369f, 0.06448904f, 0.16370374f, -0.13456500f, -0.16888572f, -0.11916316f, -0.07314906f, 
    0.05292068f, 0.03839789f, 0.17183942f, -0.19493006f, 0.07951896f, -0.00866010f, -0.25309068f, -0.12690566f, 
    0.00759825f, -0.10189547f, -0.05929664f, -0.12845024f, -0.15940191f, -0.11114404f, 0.08491573f, 0.07696822f, 
    0.19962731f, -0.04723076f, -0.22579326f, -0.32152975f, 0.01142370f, -0.00719935f, 0.18064660f, 0.02333315f, 
    -0.15014946f, -0.23704611f, 0.12952717f, -0.14642239f, -0.11461855f, -0.27593991f, 0.19504106f, 0.21633488f, 
    0.15850884f, 0.11489926f, 0.15936337f, -0.05643435f, 0.06806116f, 0.11476129f, -0.11693069f, 0.20914805f, 
    0.17158125f, 0.12899534f, 0.02801226f, 0.03735124f, 0.03713184f, 0.03606945f, -0.09670496f, 0.05719617f, 
    0.11476266f, 0.19032304f, -0.00249277f, -0.04894901f, 0.01546365f, -0.00831818f, -0.01586988f, 0.06273705f, 
    0.33492213f, -0.03287783f, 0.17009102f, -0.25529370f, -0.05000089f, -0.13601625f, 0.04255857f, 0.06296363f, 
    -0.04781725f, 0.22153224f, 0.06722408f, -0.10367557f, 0.24128504f, 0.04846974f, 0.00131222f, 0.05922763f, 
    -0.00916174f, 0.00599786f, -0.21279956f, -0.13394535f, 0.19225019f, -0.18023239f, 0.05011558f, 0.01675300f, 
    0.03994870f, 0.16937146f, 0.24990556f, 0.13510142f, -0.14883518f, 0.08783527f, -0.07491755f, -0.09713170f, 
    -0.09148806f, 0.00953253f, -0.15836243f, -0.14629458f, 0.13640183f, 0.00540888f, 0.04415134f, 0.15213093f, 
    0.03099816f, 0.10949502f, 0.06615064f, 0.02117518f, 0.29164615f, -0.09242009f, -0.30084538f, -0.03581890f, 
    0.02062625f, -0.07086300f, 0.05493435f, 0.02194003f, 0.01133986f, -0.03203871f, 0.08427927f, 0.00564816f, 
    -0.25764498f, -0.07979049f, -0.06965201f, -0.01816564f, 0.16638516f, 0.03616361f, 0.06736360f, -0.18246196f, 
    -0.11727685f, -0.13232136f, -0.11307682f, -0.06640314f, 0.03791097f, -0.05247203f, 0.03563597f, 0.10220008f, 
    -0.07287853f, 0.02246198f, 0.16808625f, -0.01541949f, -0.06556715f, -0.00955560f, 0.01542573f, 0.13520084f, 
    0.19235404f, 0.07154900f, -0.08829095f, -0.02915718f, 0.03515700f, -0.09490775f, -0.13079306f, 0.18472531f, 
    0.10480230f, 0.07961690f, 0.11904215f, -0.00645955f, -0.11406334f, 0.04478372f, 0.10702050f, 0.04913574f, 
    -0.00937317f, 0.03216672f, 0.13008118f, 0.20646712f, -0.26569080f, -0.42495477f, -0.13483047f, 0.06685282f, 
    0.03458302f, 0.09164454f, -0.04023061f, -0.03648590f, 0.06057587f, -0.03480284f, 0.09185644f, 0.23036230f, 
    -0.13930687f, 0.06238210f, 0.04390688f, -0.03373782f, -0.06327660f, 0.06561112f, -0.31564310f, 0.05426203f, 
    -0.11591232f, 0.00876254f, 0.02373592f, 0.12051024f, -0.07936379f, 0.08937944f, 0.00366482f, -0.00260353f, 
    0.34226954f, -0.11565214f, 0.07079987f, -0.08022090f, -0.07525231f, 0.21720184f, -0.04843653f, 0.14608994f, 
    0.24197982f, -0.28437254f, -0.07253031f, -0.23896164f, -0.12850900f, 0.14526531f, -0.00340480f, 0.05108811f, 
    -0.03020098f, -0.03837560f, 0.03935398f, -0.06030281f, 0.01608913f, -0.12320509f, 0.06220828f, 0.03827799f, 
    -0.06574959f, 0.16954245f, -0.03506535f, -0.08865472f, 0.04658493f, 0.01994479f, 0.10697445f, -0.03249262f, 
    0.08769463f, -0.12600566f, 0.01107425f, 0.11617581f, 0.19129917f, -0.07661699f, 0.04379877f, 0.03217285f, 
    0.06437608f, 0.22669137f, -0.03515922f, 0.26789957f, -0.27968776f, 0.15161386f, -0.02392821f, -0.03322792f, 
    -0.09003098f, -0.10613724f, -0.08158018f, 0.24985340f, 0.07953924f, -0.25136045f, 0.05106553f, 0.03690523f, 
    0.06602576f, 0.20203590f, -0.32973495f, -0.11494989f, 0.23439579f, -0.02660336f, -0.26256302f, -0.24827132f, 
    0.01862322f, 0.04466620f, -0.25762868f, 0.09148081f, 0.04806476f, -0.06253890f, -0.33668327f, 0.08961857f, 
    0.09058577f, 0.18353805f, -0.00605556f, 0.04985720f, 0.12270959f, 0.08910844f, -0.02689869f, -0.19989386f, 
    0.06783991f, 0.01293036f, 0.05208432f, 0.03977895f, 0.02983408f, 0.11401227f, 0.06403305f, -0.00160787f, 
    0.23104857f, -0.05397173f, 0.21975751f, -0.14930305f, -0.14099088f, 0.05946542f, 0.12442225f, 0.06464681f, 
    -0.06235126f, -0.11959058f, 0.16495343f, 0.16641167f, -0.06771089f, 0.16436207f, -0.03235182f, 0.11958093f, 
    -0.04513825f, -0.04810045f, 0.07161859f, 0.25079128f, -0.54191369f, -0.42109233f, -0.10039800f, 0.31386384f, 
    0.21699497f, 0.11651075f, -0.34540284f, -0.07307952f, -0.07048387f, 0.08348652f, -0.07997192f, -0.22496825f, 
    0.15465529f, 0.02309314f, 0.15021572f, 0.08306386f, -0.11752663f, 0.12195079f, 0.11354820f, -0.16555983f, 
    -0.00626915f, 0.05890445f, 0.07643965f, 0.16893734f, 0.03189656f, -0.35058892f, -0.21154082f, -0.15221627f, 
    0.02238503f, -0.07619613f, 0.03675307f, -0.03695776f, -0.16405940f, -0.04828720f, -0.17572176f, -0.26931319f, 
    -0.21921757f, 0.10037326f, -0.16337429f, 0.04807205f, 0.28688335f, 0.31620103f, -0.00488497f, -0.23600516f, 
    0.08162608f, 0.01270522f, 0.19197352f, 0.00250134f, 0.03209594f, -0.09957010f, 0.04732021f, -0.02333662f, 
    -0.17265013f, -0.17920788f, 0.13924584f, -0.20507985f, -0.07519512f, 0.00177703f, -0.02799977f, -0.01257392f, 
    0.19314395f, 0.16120288f, 0.44302973f, 0.55313742f, 0.11774372f, 0.10292926f, 0.05335473f, -0.18236290f, 
    -0.17232808f, -0.00496530f, -0.15858486f, -0.13356945f, -0.01360054f, 0.02393000f, -0.03201252f, -0.04571301f, 
    -0.20174910f, 0.14816301f, -0.01956141f, 0.05979804f, 0.25755531f, 0.07685550f, -0.29245314f, -0.02608885f, 
    0.27005365f, 0.04176906f, -0.11114059f, 0.15286480f, -0.26314029f, -0.10232003f, 0.48120466f, 0.07520863f, 
    0.09223687f, 0.11929995f, -0.29154250f, -0.17728806f, -0.14267893f, -0.35116291f, -0.10312027f, 0.03493452f, 
    -0.16504292f, 0.09630350f, 0.16627082f, 0.16943944f, 0.08839933f, 0.04000739f, 0.06690764f, 0.04138951f, 
    0.30540916f, 0.03768655f, 0.07544655f, 0.05480126f, -0.02412817f, -0.06477223f, 0.21953523f, -0.29807150f, 
    -0.22432950f, 0.17733121f, 0.22685423f, -0.17119849f, -0.18295354f, -0.17982732f, -0.08343190f, 0.04533467f, 
    0.13219838f, -0.01374981f, 0.03111805f, -0.10063709f, 0.09083975f, -0.11605003f, 0.02459473f, 0.10296873f, 
    -0.14924896f, 0.22624315f, -0.18928942f, 0.03905672f, -0.20768064f, 0.03484088f, -0.02976031f, 0.09788989f, 
    0.04536311f, 0.00943969f, 0.27641386f, 0.25353944f, 0.38982716f, 0.07434561f, 0.15114069f, 0.20933273f, 
    0.09477649f, -0.10979541f, 0.01998518f, 0.20172696f, 0.21703534f, 0.30112839f, 0.01242079f, 0.03963802f, 
    -0.13035113f, 0.16666776f, -0.08235133f, -0.08845726f, -0.43653783f, -0.18541421f, -0.18438712f, 0.11699292f, 
    0.03650377f, -0.05750576f, 0.15394573f, 0.11722539f, -0.08038844f, -0.40546963f, 0.05931330f, 0.47968262f, 
    -0.19497375f, -0.04422702f, 0.00352380f, -0.02859785f, 0.09674609f, 0.03079541f, 0.11389219f, 0.09170733f, 
    0.18433119f, 0.02343983f, -0.09388112f, -0.05913232f, 0.08778671f, -0.02535058f, 0.03801472f, 0.12981495f, 
    0.11110420f, 0.30814412f, 0.07651293f, 0.09894002f, -0.00474903f, -0.02368907f, -0.05830905f, 0.10003071f, 
    0.04831319f, 0.11793692f, 0.06497452f, -0.09131236f, -0.09661283f, 0.06606802f, 0.07897530f, -0.05226427f, 
    -0.02584452f, 0.14664103f, 0.09924702f, 0.04902419f, -0.12083755f, -0.10503072f, -0.05590194f, -0.07288335f, 
    -0.06497565f, 0.04020439f, 0.22321814f, -0.43595999f, -0.69699806f, 0.09171772f, -0.06141432f, -0.16765016f, 
    0.02628090f, 0.06801926f, -0.12445230f, 0.35428190f, 0.24552065f, -0.03991683f, -0.08374558f, 0.18599226f, 
    0.08267295f, 0.07154616f, 0.11559226f, 0.09135911f, 0.20870881f, 0.51531440f, 0.00377391f, -0.53936380f, 
    -0.00263602f, 0.21555111f, 0.14119066f, 0.08822712f, -0.00977404f, 0.02369296f, -0.01209618f, 0.22448619f, 
    -0.23305622f, 0.05175266f, -0.10240153f, -0.02993873f, 0.13787749f, -0.03552118f, 0.26758775f, 0.09907583f, 
    0.11403521f, 0.12363694f, 0.00416140f, -0.02972643f, 0.06286320f, -0.15155111f, -0.00231459f, 0.28773013f, 
    0.01752046f, 0.16392434f, -0.01655443f, -0.09494546f, -0.05421405f, 0.06296185f, -0.02708779f, 0.06603552f, 
    0.14038163f, -0.21545048f, -0.46815923f, 0.23838916f, 0.16395603f, -0.06826482f, -0.06054902f, -0.08282213f, 
    -0.02282692f, 0.30371356f, 0.19261721f, 0.14960486f, -0.17655674f, -0.06862468f, 0.01204845f, -0.04892156f, 
    0.01956080f, -0.00735133f, -0.26743969f, -0.65619791f, -0.68221748f, -0.16748650f, 0.04244794f, 0.10720985f, 
    -0.16482060f, -0.01183668f, -0.06701101f, -0.06367949f, -0.30489126f, -0.10103903f, -0.05974989f, -0.19774002f, 
    0.23529758f, -0.03908949f, -0.03410374f, -0.13529199f, 0.06683785f, 0.18109150f, 0.03146500f, -0.10385405f, 
    -0.12225556f, -0.05528990f, -0.05046207f, -0.07003269f, -0.11550793f, 0.13816796f, 0.04334858f, 0.10028332f, 
    0.03054756f, 0.08580440f, -0.02584650f, 0.02094893f, 0.08294015f, 0.07878151f, 0.05442487f, 0.03079651f, 
    0.25371256f, 0.02716849f, 0.14366178f, 0.06248051f, 0.10435649f, 0.09213454f, 0.09589975f, 0.23478436f, 
    0.06830530f, 0.14186494f, 0.06001880f, 0.03228189f, -0.05332996f, 0.02889380f, -0.08127736f, 0.08871003f, 
    0.11345736f, -0.08249327f, 0.14316329f, -0.09242969f, -0.01657844f, 0.09141425f, -0.10005497f, 0.14920461f, 
    -0.19186556f, -0.08314620f, -0.18523230f, 0.07404763f, 0.02119938f, 0.02670153f, -0.07098137f, -0.05743263f, 
    0.09577246f, -0.09315392f, 0.02338985f, -0.02933908f, 0.00067679f, -0.23095867f, -0.13012415f, 0.02419888f, 
    0.09168374f, 0.18044299f, 0.10827952f, 0.23651518f, -0.12351131f, 0.03112974f, -0.06616839f, 0.11619817f, 
    0.06153698f, 0.07473358f, -0.16461493f, -0.15008424f, -0.13972297f, 0.21689504f, -0.20338044f, -0.07250578f, 
    0.02414965f, -0.05172804f, 0.00167209f, -0.02635236f, 0.14865884f, 0.34501696f, -0.16986544f, 0.33671716f, 
    -0.01455270f, -0.13349646f, 0.14095065f, 0.09969099f, -0.11170314f, 0.06332625f, -0.19310836f, -0.16230185f, 
    0.12941161f, -0.00588927f, -0.03405857f, 0.06934252f, 0.08679813f, -0.05607896f, -0.08103825f, 0.21363585f, 
    0.26868150f, 0.03155712f, -0.10810240f, 0.00319756f, 0.21677975f, 0.02227714f, 0.17557538f, 0.07613107f, 
    0.12054472f, 0.05755483f, 0.01853405f, -0.09000173f, -0.04476388f, 0.01793933f, 0.02825506f, -0.06333880f, 
    0.14039506f, 0.22312187f, 0.04677270f, -0.10760555f, -0.05417635f, 0.15172453f, -0.05076453f, 0.18861040f, 
    0.03777988f, 0.13484405f, 0.15264037f, -0.11392949f, -0.01093615f, -0.10209540f, -0.05609580f, 0.02620730f, 
    -0.00244660f, -0.17970982f, 0.14115457f, 0.02612766f, -0.35329559f, -0.15703547f, 0.10241966f, 0.09671882f, 
    -0.00635513f, -0.01926556f, -0.03877869f, -0.09566765f, 0.20202680f, -0.08361106f, 0.14629009f, 0.03492409f, 
    0.03123478f, -0.05831860f, 0.13991694f, -0.05266668f, -0.02534380f, 0.28284138f, -0.30836570f, 0.35904816f, 
    -0.05396861f, 0.00903535f, 0.16629258f, 0.09721650f, -0.25408432f, 0.01220212f, -0.56750065f, -0.10884204f, 
    0.12834191f, 0.02366735f, 0.13245633f, 0.13807939f, -0.04802328f, 0.13952753f, 0.15517625f, -0.02464149f, 
    0.03663380f, -0.16394210f, -0.13202529f, 0.02727441f, -0.01258806f, 0.11377729f, -0.06525131f, 0.03825339f, 
    0.05109649f, -0.06342856f, -0.04844547f, -0.04925814f, 0.04757792f, -0.05112642f, -0.05390156f, -0.04442327f, 
    0.04506240f, 0.02835485f, -0.01724233f, -0.02373635f, 0.05081693f, 0.00770429f, -0.01853289f, 0.05803153f, 
    -0.03493819f, -0.05918785f, -0.00177464f, 0.00673038f, -0.02949778f, -0.03544695f, 0.02235016f, 0.04642537f, 
    -0.04969321f, 0.03065513f, 0.00707106f, -0.03920091f, -0.00885919f, 0.04364612f, 0.02761514f, 0.02486797f, 
    -0.03956646f, -0.00227114f, -0.01795126f, -0.05531034f, 0.05108466f, 0.04077422f, 0.00827450f, 0.01955784f, 
    -0.00393180f, 0.00744417f, -0.04807220f, -0.01248153f, -0.01332074f, -0.02924308f, -0.02381858f, -0.01017317f, 
    0.03498974f, -0.00506944f, 0.01729436f, 0.02324259f, 0.01374769f, 0.04056729f, -0.02358016f, -0.04155682f, 
    0.02252121f, -0.01483630f, 0.01297968f, -0.00627154f, -0.04938627f, 0.02709016f, 0.05298845f, -0.05426111f, 
    -0.06042324f, 0.01326390f, -0.05955162f, 0.00032972f, -0.05052936f, -0.06013149f, 0.03443263f, 0.04663920f, 
    0.04613512f, 0.05313656f, 0.03429279f, -0.00680127f, 0.02861949f, 0.02937730f, 0.03676957f, -0.06088406f, 
    -0.02452938f, -0.04893153f, -0.02496581f, -0.00725782f, -0.01161217f, -0.02207315f, -0.05039638f, 0.00598970f, 
    -0.00345371f, -0.03679527f, 0.04158526f, 0.03025305f, 0.03995396f, -0.00924272f, 0.00939241f, -0.01717150f, 
    -0.05538186f, 0.00802232f, 0.04232956f, -0.06264216f, -0.04511529f, -0.05395288f, 0.01506757f, -0.00066094f, 
    0.03071897f, -0.03915664f, -0.04727672f, 0.04625496f, 0.03836392f, -0.04860722f, -0.03359113f, -0.06185497f, 
    -0.03411010f, 0.00290152f, -0.01019643f, 0.02624284f, -0.05714922f, -0.04950778f, -0.00258743f, 0.04158559f, 
    0.00418159f, 0.02932680f, -0.01230104f, 0.00606756f, 0.00684411f, -0.02642323f, 0.02995012f, 0.01484737f, 
    0.00516742f, 0.04983684f, 0.01823844f, -0.05402854f, 0.02780540f, -0.05000216f, -0.02287811f, -0.05728209f, 
    0.05635715f, -0.04412021f, 0.01695573f, -0.03169697f, -0.03987182f, 0.03078826f, -0.04110658f, 0.03704834f, 
    0.05777336f, 0.02578893f, -0.02566035f, -0.01650273f, -0.03011250f, 0.03432701f, -0.05472381f, 0.01995575f, 
    -0.00982468f, -0.05860059f, -0.03137036f, -0.01272264f, -0.01233596f, -0.04134660f, -0.06233507f, -0.00692288f, 
    0.02073774f, 0.01460211f, 0.03322946f, 0.03921892f, -0.02431804f, 0.01858425f, -0.04367470f, 0.00668675f, 
    0.03368446f, 0.00809677f, -0.00746056f, 0.04475196f, -0.01498901f, 0.00926476f, -0.02930103f, -0.00967886f, 
    -0.00045122f, 0.00796488f, -0.01286554f, -0.06083443f, 0.00690793f, 0.00381183f, -0.05011120f, -0.00513664f, 
    0.02302654f, -0.05664439f, 0.00307555f, -0.03026936f, -0.03618203f, -0.02055356f, -0.05522320f, -0.01782661f, 
    -0.06166099f, 0.04002871f, 0.01060633f, -0.03063976f, -0.03033486f, -0.01081303f, -0.02116672f, -0.00192210f, 
    0.04928689f, -0.01000027f, 0.01276677f, -0.05579024f, -0.05760841f, -0.01061407f, -0.04003996f, -0.04952084f, 
    0.01416591f, -0.01949576f, -0.01335451f, 0.03748267f, -0.00928200f, -0.05403807f, 0.00938320f, -0.02504718f, 
    -0.01712202f, -0.01521612f, -0.04366773f, 0.04532488f, -0.05664906f, -0.03686449f, 0.01936473f, 0.05512811f, 
    -0.02295541f, -0.03792367f, -0.02876537f, 0.04594611f, -0.04559946f, 0.02997243f, -0.03317916f, 0.01024759f, 
    -0.06057351f, 0.04202174f, 0.01830053f, -0.06162041f, 0.03184070f, 0.03350090f, 0.02908068f, -0.03020398f, 
    -0.06109240f, 0.01383936f, -0.03427059f, 0.01743080f, 0.00853230f, -0.04337068f, -0.03362823f, -0.00498858f, 
    0.03024442f, -0.06104277f, -0.05105424f, 0.00196090f, -0.02500959f, -0.04013104f, -0.04027446f, -0.01663311f, 
    -0.01716658f, 0.03023192f, -0.03511278f, -0.04224155f, 0.04117884f, 0.04087344f, -0.02809523f, 0.02077286f, 
    -0.04629080f, 0.01929246f, -0.03912523f, -0.00973543f, 0.01231919f, -0.00657640f, -0.02921797f, -0.01395754f, 
    -0.02541966f, -0.06286982f, -0.03301490f, 0.00881752f, -0.00614251f, -0.04569167f, -0.00008168f, -0.00681210f, 
    -0.04221659f, 0.05138117f, 0.01201622f, -0.05936989f, -0.03552559f, 0.04308347f, -0.00620259f, 0.03284496f, 
    0.08143940f, -0.09333216f, 0.00080402f, -0.02054030f, -0.19814420f, -0.10292685f, -0.02185609f, 0.09101511f, 
    0.20936918f, 0.12550291f, 0.12990732f, 0.08166253f, -0.01452618f, -0.07244417f, -0.04596423f, 0.00349318f, 
    0.04388093f, -0.01562950f, 0.28734148f, 0.02920275f, -0.00797884f, -0.00184540f, -0.09626635f, 0.03733948f, 
    0.07272081f, -0.10897756f, 0.03527731f, -0.02167823f, 0.23600826f, 0.32196659f, -0.06723840f, 0.00814564f, 
    0.21351907f, -0.12267664f, 0.16707529f, -0.14655456f, -0.04673803f, 0.06692597f, -0.07254128f, -0.04675135f, 
    -0.02190467f, -0.03647520f, -0.27372387f, 0.15672772f, -0.03228047f, -0.16663034f, -0.10834922f, 0.10314722f, 
    0.01492316f, 0.03032291f, -0.09577978f, 0.11905195f, -0.13991989f, -0.27829894f, -0.25599021f, -0.22008760f, 
    0.07783128f, 0.12590808f, -0.05782225f, 0.02306572f, -0.08718049f, -0.30829853f, -0.26382640f, -0.16611356f, 
    -0.12798682f, 0.04131212f, 0.20869319f, 0.07288671f, -0.02899011f, -0.03745205f, -0.02772125f, 0.05501756f, 
    -0.05992829f, -0.18454525f, -0.24494526f, -0.03387596f, 0.10472925f, -0.03035535f, 0.08319176f, -0.06813553f, 
    0.23770149f, -0.07167503f, 0.04856022f, -0.12245544f, 0.11754265f, 0.06173097f, -0.12501590f, 0.01626284f, 
    0.01601535f, 0.15393992f, 0.22822766f, -0.09090695f, 0.29928732f, -0.17279729f, -0.11256407f, -0.22507399f, 
    -0.22137581f, -0.06370073f, -0.00008178f, 0.28569916f, -0.06495036f, 0.03299074f, 0.06019209f, 0.00253647f, 
    0.02357924f, 0.03074542f, -0.11492421f, -0.16223639f, -0.05951946f, 0.02364510f, -0.08589902f, 0.07241102f, 
    0.09888158f, -0.19366156f, -0.00940149f, -0.11672599f, -0.02188158f, -0.29979506f, -0.19066799f, 0.12021527f, 
    0.24221748f, -0.01989485f, 0.13375120f, -0.12247166f, -0.07019541f, 0.05309585f, -0.41169709f, -0.07500631f, 
    0.11413247f, -0.00288049f, 0.04257675f, -0.12843090f, -0.25651315f, 0.04767499f, -0.11920387f, -0.23745312f, 
    -0.08444353f, 0.06947470f, 0.12205249f, 0.07195019f, 0.14839841f, -0.11169314f, -0.20337148f, 0.00386477f, 
    -0.10026583f, 0.06689803f, 0.22398001f, 0.02220679f, 0.06872213f, 0.05246379f, -0.08227640f, 0.33810532f, 
    0.03541778f, 0.11425298f, 0.28483137f, 0.10795432f, 0.18116559f, 0.06338620f, -0.02203103f, 0.06798550f, 
    0.10850407f, 0.12514822f, 0.02568498f, 0.13021374f, -0.08793560f, -0.05620848f, 0.05516235f, -0.02647611f, 
    0.03307274f, -0.15575017f, 0.11977392f, 0.11965925f, 0.06348684f, -0.09296793f, 0.08458666f, -0.02665737f, 
    0.04705036f, -0.05257321f, -0.04305291f, -0.14531583f, -0.41593248f, -0.33100665f, -0.35454583f, 0.14020950f, 
    0.10648074f, 0.03327295f, -0.00825211f, 0.03340233f, -0.10635576f, -0.13615745f, -0.03247526f, -0.14491223f, 
    0.37846720f, 0.02625050f, -0.00535750f, -0.03856792f, -0.11320521f, -0.01715616f, 0.21898125f, 0.19831206f, 
    0.04004178f, 0.02149654f, 0.09676836f, 0.07055113f, 0.12599865f, 0.01586654f, -0.07015483f, -0.08238465f, 
    -0.07052841f, -0.18497005f, -0.00009592f, 0.10167561f, 0.01273248f, -0.03476232f, 0.00040844f, -0.16797699f, 
    0.11567395f, -0.00186803f, 0.10519136f, -0.08554238f, -0.03238074f, -0.04456061f, 0.01564795f, 0.04942024f, 
    0.25294274f, 0.02025847f, -0.02903471f, 0.07240402f, -0.19076216f, -0.05316788f, 0.00209626f, 0.10207199f, 
    -0.03665582f, 0.18525580f, -0.06416415f, 0.21112837f, 0.17166406f, 0.04609495f, 0.09368120f, 0.03406946f, 
    0.05451774f, -0.00400521f, 0.04151987f, 0.18421885f, 0.14307852f, -0.01924758f, -0.04550519f, -0.04637330f, 
    0.08784582f, 0.09205001f, 0.04738845f, 0.16780405f, -0.17368735f, -0.26136839f, 0.02874970f, 0.14864932f, 
    0.05042798f, 0.00809991f, -0.09096873f, -0.13013506f, 0.04152760f, 0.10865438f, 0.14736828f, -0.34341937f, 
    0.04902286f, 0.24791239f, 0.21126477f, 0.01721737f, -0.02637230f, -0.07534768f, -0.06854342f, 0.21205014f, 
    0.18431471f, -0.10311072f, -0.00045235f, 0.11181805f, 0.07631496f, 0.02698858f, -0.06280905f, 0.11271873f, 
    0.45674291f, 0.03455547f, 0.01997848f, 0.06458574f, 0.08189333f, 0.09217644f, -0.01640356f, 0.03240580f, 
    -0.21911676f, 0.04732058f, -0.14344402f, -0.07874010f, -0.07214860f, 0.02714921f, 0.16368155f, -0.14429848f, 
    0.10648436f, -0.05185602f, 0.01519010f, 0.02339827f, -0.27555919f, -0.23069146f, -0.06599399f, 0.00869771f, 
    -0.05128305f, 0.08590399f, -0.17170461f, 0.01477354f, 0.15540785f, 0.01488984f, 0.10357852f, 0.04313530f, 
    -0.09340584f, 0.09404820f, 0.07982718f, -0.25686491f, -0.38895151f, -0.09403600f, 0.06354209f, 0.04616204f, 
    0.00913582f, -0.16406159f, -0.15220262f, -0.03392207f, 0.27675360f, -0.16179214f, -0.10382240f, 0.22714674f, 
    -0.05237444f, 0.10143942f, 0.11742310f, -0.04737278f, 0.11244802f, 0.17265767f, 0.24219966f, -0.15489239f, 
    -0.17477860f, 0.10108398f, -0.05293609f, 0.05882217f, 0.00029099f, 0.00474465f, -0.31543526f, 0.09867106f, 
    -0.05669873f, -0.19476241f, -0.02454000f, -0.15328133f, 0.08966250f, -0.14578530f, 0.01174010f, 0.08382245f, 
    0.30066010f, -0.08167726f, -0.31657231f, -0.07381073f, -0.04575660f, -0.09632695f, -0.05878419f, 0.12421466f, 
    -0.37534788f, 0.07296973f, 0.19820866f, 0.07557401f, 0.07844826f, 0.04717231f, 0.08368238f, -0.05693841f, 
    -0.02235580f, 0.23996679f, 0.21398069f, -0.04847660f, -0.05973828f, -0.02754641f, 0.20051746f, 0.15441130f, 
    0.09345707f, 0.04915293f, -0.42006323f, -0.39933896f, 0.00680189f, 0.05906568f, -0.30283639f, -0.10541822f, 
    -0.01153251f, 0.01147084f, 0.14574365f, -0.09546056f, -0.10569105f, -0.03159629f, 0.02029607f, 0.08285756f, 
    -0.06422452f, 0.09118634f, 0.09802341f, 0.07302654f, -0.12915011f, -0.06726743f, -0.28425393f, 0.07707697f, 
    0.20123316f, 0.21028483f, 0.17600550f, -0.03952514f, 0.02998472f, 0.06956267f, 0.09484072f, 0.13610891f, 
    0.01943379f, -0.14831945f, -0.06132643f, -0.05526990f, 0.00042638f, 0.08534242f, 0.15128087f, 0.10912424f, 
    -0.10702105f, -0.03638497f, 0.01970080f, 0.14534795f, 0.05015307f, 0.01745081f, 0.13451663f, 0.09539363f, 
    0.19894443f, 0.08925895f, -0.30950132f, -0.20221628f, -0.13658762f, -0.21295370f, 0.02861631f, -0.03090961f, 
    -0.19484140f, -0.33052817f, -0.27740580f, -0.14869735f, 0.03525517f, -0.13156766f, -0.08124198f, 0.03419095f, 
    0.13652189f, -0.19013119f, -0.34532520f, 0.09070925f, 0.04339651f, -0.05189392f, -0.12213576f, 0.24581125f, 
    0.10203188f, 0.10915641f, -0.12747033f, -0.17207855f, 0.05575644f, 0.03354622f, -0.04116262f, -0.06787518f, 
    -0.00098881f, -0.03943323f, -0.05608305f, -0.16846076f, 0.09077713f, 0.26742214f, 0.05753353f, 0.12058923f, 
    0.16059989f, 0.18337308f, 0.16249444f, 0.15349065f, -0.10328849f, -0.40698755f, -0.39420429f, -0.31454417f, 
    -0.03324420f, -0.27091339f, 0.12967202f, -0.13943595f, 0.14168958f, 0.39615655f, 0.31650758f, -0.17845599f, 
    0.01220426f, 0.11168846f, 0.08563778f, -0.01285760f, 0.08424219f, 0.05513802f, -0.17807280f, -0.12396435f, 
    -0.27380952f, 0.00167808f, 0.13654189f, -0.04145581f, 0.18531556f, 0.01554979f, 0.13662568f, 0.17014048f, 
    -0.45275164f, 0.05839493f, -0.05196568f, -0.03751396f, 0.10067332f, 0.11781885f, 0.02244150f, -0.05237792f, 
    -0.18910494f, 0.13826311f, -0.01786453f, -0.08446831f, 0.07153149f, 0.06196807f, 0.01359878f, -0.11599442f, 
    -0.04247389f, 0.14893799f, -0.01071375f, 0.12724882f, 0.09900152f, 0.12683831f, 0.04646121f, 0.13741820f, 
    0.05156793f, -0.03458380f, -0.20251325f, -0.21604300f, -0.14090493f, -0.01102189f, 0.05034058f, -0.05653200f, 
    0.04664892f, -0.00068533f, 0.02963323f, -0.08853960f, 0.08938396f, 0.38051444f, -0.00165744f, 0.02551027f, 
    0.07674558f, 0.12311528f, -0.04282869f, 0.14849666f, 0.44253412f, 0.08076735f, 0.03506408f, 0.03383399f, 
    0.00713347f, 0.06926717f, -0.02020800f, 0.27664021f, -0.03134857f, -0.18851934f, 0.18568031f, -0.51642066f, 
    0.04128066f, -0.02474170f, -0.13824841f, 0.02185112f, -0.10907736f, -0.07665718f, -0.12691653f, -0.28165069f, 
    -0.14013137f, -0.05739402f, 0.08044939f, -0.13648127f, 0.20000003f, 0.08681134f, 0.06225886f, -0.10113373f, 
    -0.02062090f, 0.01231507f, -0.23751512f, -0.00948638f, -0.00983974f, 0.02195593f, 0.02454639f, 0.26158038f, 
    0.05899722f, 0.15235235f, 0.17732747f, 0.17013426f, 0.00872965f, 0.08393170f, 0.01098690f, -0.02528682f, 
    0.38135794f, 0.01132974f, 0.00620587f, 0.10907093f, 0.09987822f, 0.15154862f, 0.08306674f, -0.05243813f, 
    -0.10109082f, 0.19785254f, -0.17293398f, 0.15978995f, 0.22234495f, -0.16354583f, -0.01481925f, -0.00550922f, 
    -0.11066353f, -0.16007005f, -0.08632828f, -0.15741138f, -0.08909375f, -0.04184870f, 0.08072849f, -0.03482742f, 
    -0.12192984f, 0.16884629f, 0.30674729f, 0.20517246f, 0.13841774f, 0.01643689f, 0.15087745f, 0.32278678f, 
    -0.01624495f, 0.15786457f, -0.13999537f, 0.12600863f, -0.09498581f, -0.03259751f, 0.03197182f, 0.07484590f, 
    -0.02658499f, -0.02356582f, -0.02560501f, -0.21648714f, -0.07953452f, -0.17006467f, -0.29700401f, -0.12883213f, 
    -0.09850951f, 0.02306576f, -0.16022426f, -0.09727775f, -0.03159174f, -0.20935880f, -0.13870755f, 0.10436271f, 
    0.33800051f, 0.00714575f, 0.09316942f, -0.07333169f, -0.08365793f, -0.06220077f, 0.00772411f, 0.14664319f, 
    -0.02153194f, 0.24276991f, 0.34955719f, -0.02471221f, -0.09181959f, -0.07689118f, 0.12694873f, -0.12569124f, 
    0.07550687f, 0.02612303f, 0.15177342f, 0.06107477f, 0.04336829f, 0.10518802f, 0.15637687f, 0.01394678f, 
    -0.10191465f, 0.28285092f, -0.20425169f, 0.04543722f, 0.07943192f, -0.03455498f, -0.00154131f, 0.02774859f, 
    -0.21476363f, -0.10820872f, 0.02387453f, -0.20665149f, -0.03601006f, -0.07849596f, 0.01025752f, -0.03627573f, 
    -0.20962074f, -0.23798913f, -0.31171158f, -0.27267191f, -0.10903783f, 0.08210553f, 0.02828375f, 0.24144469f, 
    0.26183653f, 0.14407763f, -0.10772496f, -0.14089073f, -0.04015811f, 0.19962922f, 0.01251620f, 0.27031574f, 
    0.03563011f, -0.02695933f, -0.06879669f, -0.17204638f, -0.00507615f, 0.00286678f, -0.17205024f, 0.02559911f, 
    -0.02013560f, 0.05692604f, -0.04045024f, -0.02837261f, -0.28367326f, -0.05578845f, -0.04263138f, 0.05145316f, 
    -0.03096705f, 0.09804355f, 0.02191226f, -0.22959183f, -0.08173603f, -0.06007508f, -0.00376572f, -0.02191385f, 
    0.05307075f, 0.43574068f, -0.07354851f, 0.07039832f, -0.00809225f, -0.00473154f, 0.05294972f, 0.24156204f, 
    0.14191742f, -0.34264749f, -0.11155351f, 0.02819668f, -0.07120360f, 0.04167032f, -0.03743274f, 0.14758286f, 
    0.13794267f, 0.14234748f, -0.06359199f, -0.35221672f, -0.22282286f, 0.19487864f, 0.05485492f, 0.20181787f, 
    0.21841887f, 0.12383543f, 0.23299260f, -0.11123075f, 0.13515586f, -0.02535844f, 0.11729772f, 0.14628534f, 
    0.06256270f, -0.22699176f, 0.10703036f, -0.14483276f, -0.26303646f, 0.09984264f, -0.00603652f, 0.11359903f, 
    0.10033965f, -0.12930022f, -0.02441873f, -0.12357788f, 0.00956223f, 0.19315025f, -0.03892522f, 0.25781909f, 
    0.07696042f, 0.15609646f, 0.17088716f, -0.05712039f, -0.24778350f, -0.00145901f, -0.22550629f, -0.00632779f, 
    -0.21337450f, 0.08802618f, 0.03521026f, -0.13492228f, -0.07853016f, 0.13210906f, 0.01010101f, 0.05140150f, 
    -0.23811637f, 0.07067852f, 0.27520928f, 0.00650024f, 0.04751262f, -0.07371474f, 0.20776455f, -0.05418446f, 
    0.02235894f, 0.02770372f, 0.05538658f, 0.07489355f, -0.00478060f, 0.30374914f, -0.04344047f, 0.05239322f, 
    0.21589337f, 0.15010402f, -0.03111568f, 0.12863541f, 0.05919863f, 0.10045366f, 0.12224004f, 0.00895809f, 
    0.22957124f, 0.20009252f, -0.28450936f, -0.25898415f, -0.19579387f, -0.00537372f, -0.01546085f, -0.01860872f, 
    0.23584530f, 0.10552064f, 0.09007173f, -0.08244832f, 0.12453506f, 0.35842118f, 0.03605853f, 0.04593858f, 
    -0.10992275f, 0.20115505f, -0.14264512f, -0.01860940f, 0.05327098f, 0.27272734f, 0.01965150f, 0.11585782f, 
    -0.00014588f, -0.04374784f, -0.00449309f, 0.00137939f, -0.10260931f, -0.22319159f, -0.31107178f, -0.36690217f, 
    0.04548320f, 0.08585031f, 0.14718238f, -0.03289160f, 0.09243383f, 0.26183236f, -0.22310783f, -0.00965449f, 
    -0.17284045f, 0.08077806f, 0.18418184f, 0.14262287f, -0.02757506f, 0.16627517f, -0.00969341f, -0.31164241f, 
    0.09747117f, 0.15773837f, 0.05564905f, -0.14865878f, 0.03280770f, -0.11279583f, -0.06217816f, -0.13702163f, 
    -0.07056975f, -0.20591874f, -0.05673003f, 0.10520334f, -0.14803714f, -0.12356400f, -0.15858662f, 0.11557300f, 
    0.18363145f, 0.00992004f, 0.08802077f, -0.07536595f, 0.09453213f, -0.14491002f, -0.07703589f, 0.01373311f, 
    -0.04883874f, -0.02288304f, -0.17814428f, -0.05825700f, 0.01857741f, 0.24237134f, -0.05237111f, 0.18052296f, 
    0.08801749f, 0.06867699f, 0.06005175f, 0.42013952f, -0.06417516f, -0.34882683f, -0.06101008f, -0.10244273f, 
    0.12939411f, -0.07988801f, -0.04157203f, -0.03429158f, -0.18862931f, 0.17125995f, -0.28407863f, -0.05970405f, 
    0.00538393f, -0.19802825f, 0.14412794f, 0.05834939f, 0.21921153f, 0.06808171f, 0.04799705f, 0.26310205f, 
    0.05495470f, -0.09603225f, -0.03521756f, 0.01768349f, 0.11212040f, 0.18041770f, -0.33550751f, -0.08442558f, 
    -0.25746602f, 0.09068151f, -0.08388325f, -0.31638917f, 0.13021371f, -0.02673023f, -0.06632750f, 0.03643071f, 
    0.17051090f, 0.08296777f, 0.16659647f, -0.43287820f, -0.10377243f, -0.06776547f, -0.01579522f, 0.00436522f, 
    -0.18877472f, -0.13579321f, -0.11963437f, 0.17471820f, 0.02134070f, 0.00877713f, -0.01500491f, -0.02225417f, 
    0.07091455f, 0.16044655f, 0.07246570f, -0.12888813f, 0.09511525f, -0.15242401f, -0.05368444f, 0.08857634f, 
    0.01850070f, 0.09969575f, 0.33259973f, -0.62745136f, -0.05333222f, 0.20284690f, 0.17740192f, 0.01235187f, 
    0.05591233f, -0.03117670f, -0.17244671f, 0.09900651f, 0.01343157f, 0.04762672f, 0.03170534f, 0.25492784f, 
    -0.01856847f, 0.20103593f, 0.17974168f, 0.10149048f, 0.22156480f, 0.07050350f, -0.26036152f, 0.19108617f, 
    0.15594047f, -0.04359517f, -0.06855354f, 0.14127621f, 0.12664464f, -0.18214692f, 0.05319445f, 0.03720962f, 
    0.27069524f, -0.32067800f, -0.28466615f, -0.01489006f, -0.15850770f, 0.09707801f, -0.08678071f, -0.00725652f, 
    0.07150465f, -0.00227636f, -0.09542756f, -0.35241750f, -0.06056863f, 0.13597775f, 0.05241478f, -0.05856800f, 
    0.22630724f, -0.04755101f, 0.19655503f, -0.20008509f, -0.08488722f, 0.14237168f, -0.16369638f, 0.17892547f, 
    -0.08330778f, -0.20096594f, -0.41074494f, 0.12382203f, 0.11102882f, 0.07472630f, 0.20724331f, -0.10607234f, 
    0.00802739f, 0.14595833f, 0.11677669f, 0.06560683f, 0.10817021f, -0.08876451f, 0.02296184f, 0.23680544f, 
    0.07133888f, 0.21610887f, -0.02022784f, -0.06760199f, 0.17733379f, -0.07939640f, -0.04437541f, 0.14980806f, 
    0.07461794f, -0.06895048f, -0.13447416f, -0.34282720f, 0.13380538f, -0.07451168f, 0.02685651f, 0.12447777f, 
    -0.09745853f, 0.15929003f, 0.03445278f, -0.08358005f, -0.11290984f, -0.18308105f, 0.11443209f, -0.08383422f, 
    -0.20667635f, -0.07560191f, -0.00572845f, -0.07942615f, -0.03611142f, -0.42939252f, 0.13355884f, 0.04428857f, 
    0.05704948f, -0.06731246f, -0.00764700f, 0.21028267f, -0.04752726f, -0.12820438f, 0.03342697f, 0.20572969f, 
    0.07199383f, 0.04924996f, 0.16886948f, 0.11594959f, 0.24692276f, 0.11568320f, 0.00886351f, 0.12324403f, 
    0.10107628f, -0.09403542f, 0.08675662f, 0.13402569f, -0.09018238f, 0.11057473f, -0.02959223f, -0.05834171f, 
    0.16593684f, -0.17899409f, -0.06771034f, 0.07114211f, -0.31611937f, -0.02348754f, -0.03255723f, 0.03516798f, 
    -0.00230756f, 0.11899583f, 0.12893550f, -0.08023308f, -0.03840306f, -0.07165247f, -0.00510703f, -0.11349903f, 
    0.11263391f, 0.02796973f, 0.17170180f, -0.06590620f, 0.06293150f, 0.15067382f, 0.06464311f, 0.06470543f, 
    0.07505455f, 0.00427401f, 0.17293857f, -0.34091920f, 0.05532132f, -0.16425076f, 0.06233014f, -0.02067006f, 
    0.04033472f, 0.03516638f, 0.19499554f, 0.04349735f, -0.15790364f, 0.12008614f, 0.08007685f, -0.03822093f, 
    0.02897716f, -0.03390630f, 0.12646031f, 0.10421070f, 0.00712603f, -0.50719327f, 0.45562470f, -0.28081238f, 
    -0.05429513f, 0.03048354f, -0.16902007f, -0.01691970f, 0.03483080f, -0.24364111f, 0.18544388f, 0.25416392f, 
    0.19895707f, 0.05381501f, -0.14798699f, 0.04351509f, 0.19353083f, -0.12814976f, 0.13101053f, 0.02411081f, 
    0.08372621f, -0.00074575f, 0.07750347f, 0.16178583f, 0.22948813f, 0.15313430f, 0.06931777f, 0.08327194f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.26012629f, -0.00918319f, 0.09511935f, -0.00549126f, -0.02568801f, -0.04222101f, 0.02212602f, -0.10472275f, 
    -0.06330360f, -0.00639285f, -0.11785395f, 0.12032729f, 0.00462208f, 0.02263348f, 0.04389224f, 0.03627371f, 
    -0.03354410f, 0.05844080f, 0.30975565f, 0.04081944f, 0.01345387f, -0.05711373f, -0.05007034f, -0.04623363f, 
    -0.06382798f, 0.13587214f, 0.11285366f, -0.00410539f, 0.07849605f, 0.25376329f, 0.05915496f, 0.11136045f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.09296612f, 0.09066081f, 0.29700896f, -0.15344407f, -0.05928474f, 0.10604898f, 0.06933875f, 0.66033763f, 
    -0.01794868f, -0.27983916f, 0.13170347f, -0.29216138f, -0.16455775f, 0.07524973f, 0.21166205f, 0.18078537f, 
    0.05995039f, 0.27839509f, 0.00877815f, 0.06567760f, -0.21320149f, 0.03309990f, 0.10089174f, 0.02214835f, 
    -0.26660550f, 0.21733113f, -0.46940795f, 0.10608212f, 0.21019305f, -0.11013944f, 0.18638904f, 0.29802644f, 
    0.35357216f, 0.05146037f, -0.01499006f, -0.14525028f, -0.09518500f, 0.02101481f, 0.12094437f, -0.62687474f, 
    -0.14960076f, 0.52983677f, -0.29917139f, -0.19115105f, 0.08860492f, -0.09987547f, -0.19535013f, 0.20684613f, 
    -0.00882288f, 0.57705194f, 0.09188791f, 0.17760049f, -0.13883807f, 0.03046879f, -0.04267474f, -0.15708193f, 
    -0.15230618f, 0.05785805f, -0.34168476f, -0.02515307f, -0.00859484f, 0.39618254f, 0.12690520f, 0.03848029f, 
    0.43633664f, -0.10553253f, -0.13715732f, -0.15359956f, 0.10845888f, -0.00459348f, 0.14342572f, 0.39357668f, 
    0.07669809f, -0.27988023f, 0.01615888f, 0.25354192f, -0.11018709f, -0.03113035f, 0.11338440f, -0.19807947f, 
    0.11793298f, -0.24441735f, -0.04507045f, 0.24054173f, 0.23217541f, -0.06862204f, -0.16218607f, -0.09670123f, 
    -0.19398762f, 0.30911836f, -0.30481815f, -0.03763772f, 0.07175801f, -0.33845824f, -0.03466785f, 0.31396368f, 
    -0.43540409f, -0.06943756f, 0.06962647f, -0.14634614f, -0.14795792f, 0.11427552f, -0.08265094f, -0.27409336f, 
    0.13597164f, 0.48291641f, -0.09918010f, 0.14706378f, 0.57001513f, 0.01236157f, -0.12649459f, 0.28080758f, 
    0.18766224f, 0.04096147f, 0.06472486f, -0.29609045f, -0.09128091f, 0.13741733f, -0.07694029f, 0.11951176f, 
    0.19653042f, 0.18278079f, 0.24949765f, 0.06270638f, 0.09870777f, 0.35698193f, 0.09412948f, -0.33192271f, 
    -0.23702875f, -0.16179636f, 0.16576010f, 0.12463674f, -0.13759901f, 0.11556482f, 0.16366930f, -0.20953320f, 
    0.12220050f, 0.00523716f, -0.04114959f, 0.22679441f, -0.04027459f, 0.11465871f, -0.31650949f, -0.50053829f, 
    0.06799234f, -0.09760465f, 0.15142499f, 0.18770200f, 0.11986203f, -0.13251202f, 0.05122393f, -0.16312268f, 
    -0.25893468f, 0.09003443f, -0.03032048f, 0.09718835f, -0.55014759f, 0.51806074f, 0.07415834f, -0.05902346f, 
    0.05692297f, -0.01140875f, -0.18124790f, -0.13559161f, -0.08408619f, 0.08935708f, 0.11032394f, -0.08745623f, 
    -0.04265948f, -0.00546630f, -0.13465706f, -0.13259751f, 0.08600485f, -0.07947906f, 0.02788127f, -0.09040803f, 
    0.00241185f, -0.14866929f, -0.02103757f, -0.06144751f, -0.06187044f, -0.01756690f, 0.13206105f, -0.01464826f, 
    -0.02992949f, -0.13383275f, -0.01481456f, -0.01233914f, -0.11666068f, -0.09544624f, -0.05047094f, 0.11092076f, 
    -0.20795296f, 0.17338291f, 0.09980878f, -0.14164841f, 0.01492265f, 0.15264833f, -0.13564093f, 0.32506609f, 
    -0.04685530f, 0.05949065f, 0.46829778f, 0.26200774f, -0.43275949f, 0.13186303f, 0.00846835f, 0.54494011f, 
    -0.03720640f, -0.41626966f, 0.12298335f, 0.07518099f, -0.14894344f, 0.06008463f, -0.08273984f, 0.14856373f, 
    0.10137427f, -0.03594117f, 0.13429745f, -0.00354904f, 0.28613129f, 0.00334933f, -0.44762412f, 0.18074466f, 
    -0.26141781f, 0.16098233f, 0.53544331f, 0.12979822f, -0.13449971f, -0.16279012f, -0.07673037f, -0.06295962f, 
    -0.13939360f, 0.08571131f, 0.18993779f, -0.14647907f, 0.72355241f, -0.14945802f, 0.44467857f, 0.34851968f, 
    -0.13299853f, 0.34593272f, 0.18037018f, -0.33560988f, 0.13309436f, 0.05616531f, 0.06256810f, -0.05131862f, 
    0.04368797f, 0.06583109f, 0.23652492f, 0.06481871f, 0.28508940f, -0.26211008f, -0.10632992f, 0.03446810f, 
    -0.06523801f, -0.09467623f, -0.15659666f, -0.12731707f, 0.12091467f, -0.07686935f, -0.02988210f, -0.04868539f, 
    0.02824950f, -0.16606358f, 0.09088308f, -0.13592368f, 0.02879489f, 0.10982792f, -0.11206235f, -0.16874027f, 
    0.10421566f, -0.06552356f, -0.05192638f, -0.15454432f, -0.18203039f, -0.16157636f, -0.02106133f, 0.15215248f, 
    0.03202285f, 0.14518395f, -0.06774703f, 0.13804123f, -0.09282222f, 0.09920527f, 0.04857857f, 0.10836115f, 
    0.39355886f, -0.13193639f, 0.03180982f, -0.09321044f, 0.02717738f, -0.02413882f, -0.12976152f, -0.17199904f, 
    -0.01223573f, -0.04712826f, -0.21302913f, -0.38792920f, -0.18578404f, 0.14075473f, -0.11444068f, 0.10790204f, 
    0.10204171f, 0.09493119f, 0.41052780f, -0.03646844f, -0.26372170f, 0.09482802f, -0.10995799f, 0.11074358f, 
    -0.03034451f, -0.12264897f, -0.30787945f, 0.15387875f, 0.07145852f, 0.47589242f, 0.23839901f, 0.09397905f, 
    0.45004550f, -0.09993324f, -0.32054165f, -0.05310625f, -0.03281457f, 0.00817050f, 0.08655448f, 0.09645516f, 
    0.10457455f, 0.14233340f, 0.15311775f, 0.35402358f, -0.44464776f, 0.08603990f, -0.26997048f, -0.17045689f, 
    -0.09534208f, -0.14898148f, 0.04255662f, 0.15221544f, 0.27050582f, 0.00153178f, -0.13494216f, -0.01212390f, 
    -0.19537528f, 0.09449109f, 0.03530572f, -0.06227767f, -0.18821388f, 0.21056049f, 0.04810896f, 0.25516790f, 
    0.04502008f, -0.08031722f, -0.07365695f, 0.05690295f, 0.14619112f, -0.08197889f, -0.03253954f, -0.14230198f, 
    0.04330534f, -0.09512393f, 0.09361596f, 0.11146170f, 0.09223281f, -0.12595467f, -0.16926672f, -0.02961454f, 
    0.07808667f, -0.01296454f, -0.06232357f, 0.04727351f, -0.08524364f, -0.04361299f, 0.00862373f, -0.09647843f, 
    -0.01584858f, 0.02749392f, -0.10797564f, -0.12948218f, 0.07655188f, -0.18004134f, -0.13778767f, 0.06376092f, 
    0.04088895f, -0.02386118f, -0.10504076f, 0.11004443f, 0.10164760f, 0.07856601f, 0.11341301f, 0.14635228f, 
    0.07229021f, 0.04219168f, 0.08676337f, -0.07954241f, -0.00961767f, 0.09390993f, 0.11157767f, -0.07557969f, 
    0.13488580f, 0.10993566f, -0.09075277f, -0.08740591f, -0.02117981f, 0.18498266f, 0.08470988f, -0.16162047f, 
    -0.02333922f, -0.18207479f, -0.00644561f, -0.05122610f, -0.01808739f, -0.06072937f, -0.08657862f, -0.16864714f, 
    0.58253527f, 0.05373727f, 0.15720542f, -0.11159841f, -0.12553328f, 0.13692306f, 0.12514700f, 0.00803566f, 
    -0.10610402f, -0.30933070f, 0.58119524f, 0.08622724f, -0.16900755f, 0.08035693f, 0.24434356f, 0.00879553f, 
    0.03063606f, 0.26289579f, -0.16670512f, 0.35699818f, 0.17393205f, -0.04055679f, -0.12222727f, -0.07113376f, 
    -0.18955547f, 0.06241740f, -0.06952282f, -0.10368221f, -0.08800276f, -0.13193437f, -0.40500280f, 0.15554939f, 
    -0.18757392f, 0.04052399f, 0.51580286f, 0.08389311f, -0.06375349f, -0.15486445f, 0.11288145f, -0.63651013f, 
    0.04692720f, 0.06405998f, -0.12206350f, -0.41403633f, 0.47030613f, -0.10658447f, 0.12077478f, 0.03017809f, 
    0.11599122f, 0.68562859f, 0.21339171f, -0.27903667f, 0.22772741f, -0.07364009f, 0.13422005f, 0.07521981f, 
    -0.18339241f, 0.17304775f, -0.27373022f, -0.06372915f, 0.02587742f, 0.05362772f, 0.22446857f, 0.02667987f, 
    -0.49590829f, 0.17557929f, -0.07168232f, 0.13221635f, -0.06509738f, 0.05642517f, -0.07734636f, -0.39358199f, 
    -0.06638923f, 0.03821581f, -0.37063169f, 0.21772936f, -0.15766512f, -0.07096122f, -0.19704074f, -0.34881756f, 
    -0.14821573f, 0.22837278f, 0.18781666f, 0.16408125f, 0.09264342f, 0.14668582f, -0.14294040f, -0.00972399f, 
    -0.22024180f, 0.29651842f, -0.24888410f, -0.03784408f, 0.03122972f, 0.34776157f, 0.48655373f, 0.01882318f, 
    0.03622815f, 0.09847838f, -0.01432411f, 0.17343533f, -0.11038059f, -0.11707474f, 0.00289319f, -0.08597761f, 
    -0.02600239f, 0.03507707f, -0.00306715f, 0.01158356f, -0.13215855f, -0.08798810f, 0.02224205f, -0.06476266f, 
    -0.08593611f, -0.05800108f, -0.09841331f, 0.03854844f, -0.01083161f, -0.12189787f, 0.04355723f, -0.01108865f, 
    -0.00856734f, -0.16420284f, -0.16889369f, -0.05473695f, 0.07744645f, -0.15134127f, 0.01521598f, -0.13960026f, 
    -0.58484459f, 0.04649246f, -0.11271603f, -0.15902190f, -0.01696190f, 0.01529524f, 0.01213971f, -0.39112154f, 
    0.04606722f, 0.40481785f, -0.22953251f, 0.07956655f, 0.42500803f, 0.01495754f, 0.09729858f, 0.30689755f, 
    0.06004455f, -0.20743154f, 0.03473122f, 0.03789679f, 0.23311830f, -0.00565029f, -0.15545419f, 0.16787693f, 
    -0.03020871f, 0.30959105f, 0.00503610f, 0.04469686f, -0.12798482f, 0.18108004f, -0.08303262f, -0.28273731f, 
    -0.37056249f, -0.02456917f, 0.24468771f, -0.16355301f, -0.13834356f, 0.10092733f, 0.12084777f, 0.70421493f, 
    0.16161406f, -0.21256272f, -0.03701398f, -0.19769603f, 0.24509381f, -0.10531493f, 0.24939561f, 0.23434617f, 
    -0.10307770f, -0.00617256f, 0.27170199f, 0.26440048f, 0.01116740f, 0.15551469f, 0.08915045f, 0.14372021f, 
    0.14472975f, 0.28726026f, -0.09499954f, -0.06256054f, 0.06699962f, -0.54767543f, -0.06631719f, 0.29098862f, 
    0.01237614f, 0.03368058f, 0.04294876f, -0.03281305f, -0.09314017f, 0.01990425f, -0.01192334f, -0.15755957f, 
    -0.17479442f, 0.04885190f, -0.09051416f, -0.06132134f, -0.02825914f, -0.04455463f, -0.11362313f, 0.03001081f, 
    -0.03509083f, 0.02042183f, -0.03449852f, -0.12133976f, 0.02003712f, 0.08708607f, -0.02425551f, -0.15597236f, 
    0.02318591f, -0.04261294f, -0.12124356f, 0.06649034f, -0.22094575f, -0.07964282f, -0.07370099f, 0.00983701f, 
    0.11532827f, -0.17369059f, -0.08550631f, 0.00369879f, -0.04868273f, 0.12884733f, 0.09133326f, -0.14177561f, 
    0.10303423f, -0.15521145f, 0.50765353f, 0.34611502f, -0.53761548f, -0.14223416f, 0.17684504f, -0.07069051f, 
    0.04252765f, -0.19625652f, 0.24874881f, 0.36884040f, -0.11359680f, 0.13381994f, -0.15732512f, 0.15903126f, 
    -0.28181618f, 0.12074268f, -0.05890710f, 0.16616298f, -0.20955096f, 0.26580852f, -0.36469817f, 0.32470679f, 
    -0.20126967f, -0.01857458f, 0.32918227f, 0.15640466f, 0.07098136f, -0.07393254f, -0.11757545f, 0.20432913f, 
    0.10270084f, 0.07777870f, -0.04126049f, 0.01468365f, 0.38482216f, -0.03283171f, 0.52156645f, -0.20309876f, 
    -0.08216570f, -0.05636089f, -0.18799646f, -0.20222241f, -0.03748524f, -0.07352836f, -0.05596013f, 0.06723431f, 
    0.15458982f, 0.18437417f, 0.30463597f, -0.14173734f, 0.40491641f, -0.01652248f, 0.00474719f, 0.05545682f, 
    0.02779045f, 0.00275956f, 0.02628230f, 0.04762521f, -0.02216330f, 0.11925741f, 0.01452423f, 0.02545926f, 
    -0.07143916f, 0.07708370f, 0.08044036f, -0.08917602f, -0.01547359f, -0.14951570f, -0.12846650f, -0.14795217f, 
    -0.13713658f, -0.15477617f, -0.07512476f, 0.09562600f, -0.01660714f, 0.06203077f, -0.07682785f, 0.16090529f, 
    -0.01417253f, -0.10401840f, -0.15658022f, 0.02946728f, 0.08419103f, -0.00220180f, -0.10192734f, -0.23010017f, 
    -0.15555818f, -0.13421793f, -0.13583589f, -0.02816834f, 0.08947705f, -0.03314177f, -0.16192146f, -0.60381699f, 
    0.03034460f, 0.27192518f, 0.05704961f, 0.09378258f, 0.02957395f, 0.05232482f, 0.07409620f, 0.21724673f, 
    0.07431208f, 0.18454759f, 0.27143484f, -0.13034596f, 0.12197041f, 0.09802557f, -0.06040451f, 0.02097013f, 
    -0.25048891f, 0.30816340f, 0.03805620f, 0.04240226f, -0.34847209f, 0.01632724f, 0.09918864f, -0.36688513f, 
    0.68270141f, -0.00541955f, -0.14070980f, -0.04493281f, 0.06217976f, 0.04403970f, -0.15255092f, -0.59533697f, 
    0.05879847f, 0.21301827f, 0.26988176f, 0.19205473f, -0.23174144f, 0.03814165f, -0.29321188f, 0.24669723f, 
    0.15605222f, 0.49971637f, 0.17891337f, 0.01045915f, 0.10155889f, 0.08960182f, 0.03674653f, -0.07848427f, 
    -0.28530735f, -0.09570344f, -0.00031312f, -0.18172300f, -0.10212328f, 0.37616789f, 0.10797723f, 0.10960647f, 
    -0.23702104f, -0.10655146f, 0.15386711f, 0.06268588f, -0.06138055f, -0.04821404f, -0.09878488f, 0.12983488f, 
    0.15888046f, 0.43854800f, -0.39220732f, -0.13448599f, -0.35638407f, 0.08214448f, 0.12163497f, 0.20391074f, 
    0.08936349f, 0.16480534f, 0.11400880f, 0.22170903f, -0.46530569f, -0.11603054f, -0.02757905f, -0.12034222f, 
    -0.05905532f, 0.08857302f, -0.55528706f, -0.03913670f, 0.41354322f, 0.05146227f, 0.28522220f, 0.22741537f, 
    -0.13394798f, -0.17290041f, -0.41257688f, 0.11062379f, 0.10903510f, 0.11905118f, 0.03232951f, -0.16181849f, 
    -0.11404958f, 0.01343318f, -0.11959373f, 0.33330762f, -0.51811808f, 0.15815879f, -0.13733207f, 0.42270425f, 
    0.02043891f, -0.28414175f, 0.32184693f, 0.28598827f, -0.17632234f, 0.02641475f, -0.03577491f, -0.15848081f, 
    0.09084451f, 0.11497819f, -0.18962443f, 0.08039787f, 0.05808902f, 0.17493027f, -0.17466660f, 0.20794298f, 
    0.13655376f, 0.01345055f, -0.08474589f, -0.08175204f, -0.05557410f, -0.13922480f, 0.11896688f, -0.25542369f, 
    0.02536698f, 0.15499136f, -0.46722358f, -0.27697283f, -0.22456940f, -0.06779908f, -0.33296171f, -0.19429298f, 
    0.15384048f, 0.35573304f, -0.33402884f, 0.10404649f, 0.16575262f, 0.13260294f, -0.09370035f, -0.06738613f, 
    0.25202981f, 0.20230711f, 0.03868454f, 0.05399182f, 0.05700287f, -0.01261095f, 0.11602042f, -0.01080749f, 
    -0.02899726f, 0.18121731f, 0.36646828f, 0.12010981f, -0.10689581f, -0.07305153f, -0.15977651f, 0.32588229f, 
    0.02518141f, -0.26960838f, 0.05930620f, -0.29041165f, 0.74707574f, -0.14996462f, 0.01056655f, 0.08623035f, 
    -0.14375611f, 0.48854688f, 0.09893180f, 0.04818900f, 0.12334190f, 0.10699061f, -0.09717156f, -0.07818398f, 
    -0.39425406f, 0.06911284f, -0.26310593f, -0.05323528f, 0.16272160f, 0.03880651f, -0.08937626f, -0.07492328f, 
    0.08065738f, -0.00283474f, -0.07049748f, -0.10955700f, -0.15464404f, 0.01014610f, -0.01337836f, -0.01311439f, 
    -0.13206294f, 0.08622215f, -0.12083506f, -0.03779872f, -0.16650645f, 0.07603721f, -0.04965916f, -0.05380123f, 
    -0.06045907f, -0.19084999f, -0.06098824f, -0.22380829f, -0.13946424f, -0.13556795f, -0.15002955f, 0.09133155f, 
    -0.04029946f, 0.03404422f, -0.19401534f, -0.01784790f, -0.12251902f, -0.14409700f, 0.11504488f, -0.11927748f, 
    -0.17439085f, 0.03736495f, 0.13161699f, 0.11567805f, 0.12469225f, -0.07481512f, -0.14699367f, 0.11572015f, 
    -0.00566454f, 0.28502569f, -0.39833391f, -0.21789928f, -0.13633209f, 0.11379185f, 0.07514459f, 0.17163320f, 
    -0.10572832f, -0.12664235f, 0.07370548f, 0.22290148f, -0.42948741f, 0.02710025f, -0.07046101f, -0.07284379f, 
    0.28359303f, -0.20038782f, 0.01181031f, 0.17579842f, 0.24517104f, 0.18125838f, 0.33027330f, 0.10842296f, 
    0.21063945f, -0.04829158f, -0.54862565f, -0.17366280f, -0.14246081f, -0.02400152f, -0.13579780f, 0.00366383f, 
    0.02660508f, -0.35416842f, 0.20590657f, 0.03854416f, -0.12370829f, -0.00852650f, -0.30969137f, 0.47841966f, 
    0.02909264f, -0.29863796f, -0.41944450f, -0.19478552f, 0.12364251f, 0.05138028f, -0.17626809f, -0.08858969f, 
    -0.11115917f, -0.17585567f, 0.00250698f, -0.07049280f, -0.10175455f, 0.11002839f, 0.16383354f, -0.52283293f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03886694f, 0.31948420f, 0.23731269f, -0.03820707f, 0.07356714f, 0.14255621f, 0.16110173f, 0.17096040f, 
    -0.08925266f, 0.18967114f, 0.18001062f, -0.15727316f, 0.09672342f, 0.03753882f, 0.21927054f, 0.29795399f, 
    -0.16701660f, 0.09809677f, 0.24823853f, -0.21073708f, 0.01705863f, 0.08790928f, -0.04262434f, 0.17149022f, 
    0.41898680f, 0.06195345f, 0.09945933f, -0.27950042f, 0.15502530f, 0.07682778f, -0.06230672f, 0.78160948f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.01636459f, 0.01158964f, 0.39097869f, -0.39487982f, 0.63591623f, 0.08775476f, -0.00768834f, -0.18092129f, 
    0.15087698f, -0.14552495f, 0.23394766f, -0.14931144f, 0.06885031f, 0.31429821f, 0.12503059f, 0.19876969f, 
    -0.03662104f, 0.16385525f, 0.12511292f, -0.12998800f, 0.30134410f, -0.53036040f, -0.15818255f, 0.52193195f, 
    0.14861879f, -0.20214370f, 0.30449644f, -0.19217585f, 0.02157278f, -0.05529997f, -0.99769032f, -0.14287025f, 
    0.03060791f, -0.01356017f, -0.02341320f, 0.05672034f, 0.08236372f, -0.17364322f, -0.27783221f, -0.08287231f, 
    -0.17977995f, 0.15546028f, 0.16796921f, 0.08438747f, 0.13414727f, 0.08401372f, -0.20948999f, -0.06017699f, 
    -0.05704340f, 0.07684328f, -0.30859280f, -0.14225246f, -0.28878587f, -0.16727570f, -0.07081950f, 0.03160940f, 
    -0.02541867f, 0.01488986f, -0.52392817f, 0.05959759f, -0.13522343f, 0.07314444f, -0.12597857f, 0.66485250f, 
    -0.69904214f, -0.18060145f, -0.28622726f, -0.11774948f, 0.01075742f, 0.12421220f, 0.63961244f, 0.17153889f, 
    0.16932453f, -0.00000893f, 0.07911715f, -0.13197780f, -0.09555848f, 0.59788263f, 0.07546999f, -0.35597888f, 
    0.15249524f, -0.29421529f, -0.14561073f, 0.16881903f, 0.41190630f, 0.02741151f, 0.05597152f, 0.13657054f, 
    0.11562397f, -0.48758242f, 0.11650084f, -0.12443372f, -0.21536970f, -0.16611244f, 0.03794005f, -0.06688998f, 
    0.21596518f, -0.15030891f, -0.30927333f, -0.02931335f, -0.20641918f, 0.06934929f, 0.24394281f, 0.13111567f, 
    0.10565059f, 0.67042863f, 0.09547000f, 0.08331672f, 0.04095257f, -0.23473307f, 0.05121532f, -0.24623477f, 
    -0.14808805f, -0.38838780f, 0.08111765f, 0.03113794f, -0.12247144f, -0.17930451f, 0.11798852f, 0.16429098f, 
    0.16121264f, 0.15989803f, 0.32142606f, -0.14327450f, -0.04267776f, 0.08896340f, 0.28708315f, -0.02726797f, 
    -0.29253879f, -0.11584634f, 0.25462869f, 0.03850684f, 0.48912382f, 0.03917655f, -0.16223849f, -0.10824680f, 
    0.00685763f, 0.25449556f, 0.22806498f, 0.11215536f, 0.07991387f, 0.33465004f, 0.06489208f, -0.05993271f, 
    0.12744345f, -0.33492142f, -0.16990988f, -0.08603909f, 0.10719817f, -0.12656693f, 0.15180881f, 0.02506683f, 
    0.39665228f, -0.25364521f, -0.09228019f, 0.14513047f, -0.24259922f, 0.01513998f, 0.16403019f, 0.10771994f, 
    0.11395036f, 0.01545029f, -0.13754718f, -0.16848439f, 0.05242765f, -0.12125129f, 0.08830678f, -0.03145018f, 
    0.06084331f, -0.00968149f, -0.14575455f, 0.02869054f, 0.03320118f, 0.09199982f, 0.09140500f, 0.08205859f, 
    0.12313541f, -0.16686045f, -0.05356133f, 0.02951019f, 0.09805099f, -0.12344894f, -0.07940129f, -0.10281267f, 
    -0.16074669f, -0.06406566f, -0.09276398f, 0.01359960f, -0.10923136f, 0.12806599f, 0.11000812f, -0.06961872f, 
    0.12763321f, -0.32941139f, 0.43777403f, -0.47097853f, -0.29248250f, 0.01807605f, 0.21343586f, 0.22696681f, 
    0.07429133f, -0.70090806f, 0.24330607f, -0.18332420f, 0.07522662f, 0.58475983f, 0.11570510f, -0.14353873f, 
    0.15993544f, -0.52790087f, 0.14778191f, 0.01190742f, 0.02897438f, 0.15343657f, -0.13797244f, -0.25428227f, 
    0.26788923f, -0.12670182f, -0.48162124f, -0.04700574f, 0.15942450f, 0.17047848f, -0.64517909f, -0.06263740f, 
    -0.06093758f, -0.05646310f, -0.13697399f, -0.13857324f, -0.02060869f, 0.07029795f, -0.12463164f, -0.12524541f, 
    -0.11799879f, -0.01121913f, 0.00390883f, -0.08958190f, 0.06971055f, -0.09571427f, -0.04483756f, -0.09281507f, 
    -0.06129494f, -0.04423257f, 0.00325468f, 0.03717607f, -0.00476308f, 0.05524898f, 0.00567486f, -0.16766214f, 
    -0.12573159f, -0.08327307f, 0.13166887f, -0.09541528f, -0.15154809f, 0.01030090f, -0.06729058f, -0.14349739f, 
    0.07443649f, -0.49384597f, 0.00416154f, 0.15422319f, -0.06400482f, -0.09254359f, 0.12920807f, 0.33796918f, 
    -0.08172607f, -0.46761838f, -0.04648315f, 0.08069962f, 0.11621470f, 0.22739284f, -0.19517425f, -0.16285361f, 
    -0.02884199f, -0.00800522f, 0.37208095f, -0.12940997f, 0.19522786f, 0.27211758f, -0.14651901f, 0.04385173f, 
    0.07059062f, -0.23149067f, 0.05487628f, -0.06226390f, 0.23451492f, -0.04634881f, 0.03802526f, 0.04536948f, 
    0.14067978f, -0.06749112f, 0.50892442f, 0.08613916f, -0.39510196f, -0.11408239f, -0.17017831f, 0.08617716f, 
    0.01817444f, -0.26487786f, 0.27725390f, 0.09891333f, -0.14955853f, 0.46577770f, -0.04952335f, 0.10647903f, 
    0.11380292f, -0.11214231f, 0.00779206f, -0.08151307f, 0.10931235f, 0.08456104f, -0.09984200f, -0.12924904f, 
    -0.10129355f, -0.16434003f, -0.01563902f, -0.06034881f, -0.08682642f, 0.12563343f, 0.16213323f, -0.46571338f, 
    0.23543091f, -0.45766300f, 0.34085310f, -0.34117007f, -0.26922816f, 0.01819281f, 0.44629449f, 0.27400720f, 
    0.12498454f, -0.11943319f, -0.17335787f, -0.02687151f, 0.05375352f, 0.04529979f, 0.06880837f, -0.11186885f, 
    -0.11799558f, -0.14530869f, 0.40365967f, 0.02068278f, 0.19200151f, 0.25282669f, -0.12185911f, -0.19631770f, 
    -0.21033445f, 0.27871183f, -0.03677266f, -0.24904887f, 0.16660789f, -0.05452566f, 0.02494757f, -0.24862297f, 
    -0.49075472f, -0.39879405f, -0.43652776f, 0.12050345f, 0.05133612f, 0.13880938f, 0.37440187f, 0.34090745f, 
    -0.13816293f, -0.47809127f, 0.02818917f, 0.00464690f, -0.04412454f, 0.28219500f, -0.16045119f, -0.30713949f, 
    -0.08945513f, 0.02159785f, 0.08226462f, 0.08239654f, 0.33527452f, 0.25982913f, 0.10663161f, -0.27536035f, 
    0.06618580f, -0.47112140f, -0.15943968f, -0.05723896f, -0.49210688f, -0.11482877f, -0.10518027f, 0.01391368f, 
    0.26707429f, 0.09064726f, 0.05721413f, -0.35680336f, -0.08319354f, 0.09182847f, 0.02510861f, 0.17194726f, 
    0.06785189f, 0.64599890f, -0.22312517f, -0.11787993f, -0.17137668f, 0.02208586f, 0.10868631f, -0.04367284f, 
    -0.11516919f, -0.71749550f, 0.27589279f, -0.18838693f, 0.04882641f, -0.06175767f, -0.17195353f, -0.34518817f, 
    0.03951190f, -0.04778600f, -0.00963587f, -0.43864885f, -0.00039559f, 0.10139573f, 0.20459388f, 0.08513258f, 
    -0.11424165f, -0.05571683f, -0.06880168f, -0.11533883f, 0.03151118f, 0.08094892f, -0.03445102f, -0.02610022f, 
    -0.02807652f, -0.18390311f, 0.07473975f, 0.04907811f, -0.13619678f, 0.04689216f, -0.01730983f, -0.00553992f, 
    -0.01295240f, -0.04010902f, 0.01388303f, -0.15907545f, -0.03159882f, -0.10533419f, -0.14698164f, -0.05524255f, 
    -0.22419471f, 0.11115101f, -0.09470695f, 0.02933820f, -0.07783589f, -0.12869424f, -0.05371608f, 0.06942017f, 
    -0.22714642f, 0.38730115f, 0.14421563f, -0.26956430f, 0.05645407f, 0.14308557f, 0.08713767f, -0.27486798f, 
    -0.13957402f, 0.34347880f, 0.35437292f, 0.14886685f, -0.11533014f, 0.50178468f, 0.01840779f, -0.14602114f, 
    0.01206531f, -0.71212077f, -0.19195668f, 0.05317713f, 0.25149369f, -0.44139993f, 0.14527310f, -0.11927944f, 
    0.29877645f, -0.42683706f, 0.14538169f, 0.27302769f, 0.10904621f, 0.03835990f, -0.34521869f, -0.18652686f, 
    0.08192088f, 0.49343687f, 0.02640834f, -0.40172952f, 0.05161021f, -0.07758536f, 0.14163755f, -0.32657981f, 
    -0.09010227f, 0.46279314f, -0.17950301f, 0.07594936f, -0.11448825f, 0.21731672f, 0.13469760f, 0.11081830f, 
    0.11488067f, -0.37294587f, -0.10613816f, 0.05270229f, 0.45780569f, -0.43381917f, -0.09727675f, -0.01165544f, 
    0.24554543f, 0.30801517f, 0.25651020f, -0.07475806f, 0.19130830f, -0.16000913f, 0.09144384f, -0.20567210f, 
    -0.07272025f, 0.28789681f, 0.21619199f, -0.09660005f, -0.92412317f, 0.03579841f, 0.42792347f, -0.02077192f, 
    0.14189468f, 0.00293872f, 0.12817563f, -0.09717629f, -0.06781451f, 0.16451403f, -0.32623076f, -0.13804156f, 
    -0.05331515f, -0.06598563f, -0.03459311f, -0.13533334f, 0.12342029f, -0.16146377f, -0.03600234f, -0.05381758f, 
    0.33560452f, 0.32670107f, 0.52536964f, -0.10758397f, -0.40012226f, 0.06860361f, 0.30411410f, 0.27325842f, 
    0.13489190f, 0.05556816f, 0.47133270f, -0.11137161f, -0.24108446f, 0.07732634f, -0.00346197f, -0.10739823f, 
    0.15039700f, -0.46844780f, 0.00343159f, 0.00963307f, -0.02307969f, 0.47812992f, -0.05286973f, 0.06601223f, 
    0.04078717f, 0.10095911f, -0.01397998f, -0.07088002f, 0.34110245f, 0.04213595f, -0.04314074f, 0.41064206f, 
    0.15741016f, -0.28459948f, -0.05272806f, -0.28846037f, 0.11758465f, -0.01370750f, -0.56132650f, -0.06392703f, 
    0.18296051f, 0.41919026f, 0.00615591f, -0.15892977f, 0.55742997f, -0.05883200f, -0.30233607f, 0.13099831f, 
    -0.06748182f, 0.46457332f, 0.05129343f, -0.22194129f, 0.06576678f, 0.04701922f, 0.36800984f, 0.00074528f, 
    0.10169813f, -0.10567132f, -0.16647457f, -0.10975540f, -0.12219757f, -0.23970686f, -0.13291951f, 0.25805578f, 
    0.40499404f, -0.10085066f, -0.30214220f, 0.07763225f, 0.36269692f, -0.02883856f, -0.32641140f, 0.27167636f, 
    0.11379527f, -0.09442157f, -0.18921302f, 0.04576825f, -0.04843643f, -0.10669039f, -0.04019716f, -0.07604215f, 
    -0.05837507f, -0.05369633f, -0.18904118f, -0.16896339f, 0.07118407f, 0.02578839f, 0.12132265f, -0.08961413f, 
    -0.00660007f, 0.01003399f, -0.10186667f, 0.02738201f, 0.00731534f, -0.00645734f, -0.14029381f, 0.01499939f, 
    -0.00792341f, -0.18356805f, 0.02798649f, -0.07161359f, 0.06825770f, 0.13952020f, 0.03956256f, -0.05201491f, 
    -0.21087649f, 0.08988570f, -0.30204886f, 0.35606042f, 0.30877256f, 0.16513029f, 0.22991024f, 0.36033505f, 
    0.07976186f, -0.36420092f, -0.19957814f, 0.13122001f, -0.02107165f, -0.17319393f, 0.28952464f, 0.01050877f, 
    0.08970691f, 0.78423268f, 0.36264351f, -0.03646588f, 0.07697684f, -0.11495298f, -0.01651794f, 0.58532333f, 
    0.03560648f, -0.21794054f, -0.10646103f, -0.28488958f, 0.11076317f, 0.10915081f, -0.17268187f, -0.12733212f, 
    0.14580327f, 0.20646557f, 0.12898725f, 0.06890547f, 0.55244839f, -0.06278176f, 0.17323346f, -0.32191259f, 
    -0.00854843f, 0.48066410f, 0.16647740f, -0.10405341f, 0.01304103f, -0.13966003f, -0.15460926f, 0.41552347f, 
    0.10575807f, -0.06127971f, 0.08244126f, 0.05211582f, 0.27412322f, -0.13678642f, -0.15820076f, -0.13735227f, 
    0.06969122f, 0.31182280f, 0.36016646f, 0.11105013f, -0.25998384f, -0.13345207f, 0.28676888f, 0.00489240f, 
    0.05213324f, -0.01543364f, 0.29526982f, -0.05925502f, -0.27519518f, 0.11582119f, -0.15935323f, 0.37138024f, 
    0.14960550f, -0.06092266f, -0.18806803f, -0.03365042f, 0.04390403f, 0.13403308f, 0.35085800f, 0.05732070f, 
    0.12983780f, -0.30383074f, 0.25004563f, -0.04301828f, -0.09688236f, 0.16009739f, -0.07475399f, 0.06301071f, 
    0.16026856f, -0.07424918f, -0.14645950f, -0.71318638f, 0.20272474f, -0.01567933f, 0.00814526f, -0.15725827f, 
    0.32609028f, -0.21017148f, 0.46659589f, -0.48535526f, -0.03354038f, -0.05600442f, -0.14271316f, 0.04990359f, 
    0.12272092f, 0.17521423f, -0.15040620f, -0.14827569f, 0.07239085f, 0.18698233f, 0.25759917f, 0.13894540f, 
    -0.07155818f, -0.31074986f, 0.49359256f, -0.15228204f, -0.02436424f, -0.13883635f, 0.10931584f, -0.04921123f, 
    -0.21769375f, 0.01732381f, 0.06659370f, -0.31640798f, 0.55396509f, -0.08769826f, -0.25494030f, 0.00709356f, 
    0.39546037f, -0.26224953f, 0.29056099f, -0.27939680f, -0.14655487f, 0.01030910f, 0.20052785f, -0.00377656f, 
    -0.13389538f, 0.05457869f, -0.09845357f, 0.12075430f, 0.08401996f, 0.18519580f, 0.13574703f, 0.39503464f, 
    0.13521783f, -0.41805643f, 0.29381615f, 0.14645450f, 0.17315614f, 0.24423522f, 0.10407692f, -0.40750092f, 
    -0.29247609f, 0.27354026f, -0.00295224f, -0.17929658f, 0.13992554f, 0.15287228f, 0.14539754f, -0.16962118f, 
    -0.55275488f, -0.02357398f, 0.35588256f, 0.01802067f, 0.51350325f, 0.14254121f, 0.08614946f, -0.07001075f, 
    -0.08054212f, -0.05956111f, 0.34099862f, 0.00040605f, -0.05670503f, -0.06079209f, -0.20373186f, 0.39779031f, 
    -0.10241389f, 0.12063387f, -0.06976162f, -0.13395122f, 0.34588638f, -0.11422808f, 0.02043595f, 0.20100415f, 
    0.00748771f, -0.35927173f, 0.13009943f, -0.32250175f, -0.72682667f, 0.17003548f, -0.22837441f, 0.19113512f, 
    -0.09065054f, 0.00335884f, 0.08262673f, 0.12648267f, -0.26087669f, 0.12780482f, 0.30062938f, 0.10353246f, 
    0.08639830f, -0.22559337f, 0.10261204f, -0.16214690f, -0.02176141f, -0.12552743f, -0.38695541f, 0.10020322f, 
    -0.16189578f, 0.01993840f, -0.25446364f, -0.06260157f, 0.33972505f, 0.14145012f, 0.05508957f, 0.22480886f, 
    -0.02646068f, 0.07052720f, 0.36508828f, -0.20951743f, -0.64724183f, 0.14199382f, -0.14911702f, -0.07498146f, 
    0.05840834f, 0.21334077f, -0.02791409f, -0.10403942f, 0.75416595f, 0.09637729f, -0.14126290f, -0.08994563f, 
    -0.07204810f, 0.84185940f, 0.02434822f, -0.21632247f, 0.06536826f, -0.24042501f, 0.32840165f, 0.35711342f, 
    -0.00957372f, -0.37693825f, -0.08905251f, -0.01914207f, 0.20252040f, 0.07285598f, -0.13183415f, 0.17090203f, 
    0.22443505f, 0.13448182f, -0.06951705f, 0.00934528f, -0.11057863f, 0.05419824f, 0.15849437f, -0.01325816f, 
    -0.00643676f, 0.37766397f, 0.25688702f, -0.12433188f, 0.17863478f, 0.14540350f, -0.01695671f, -0.07755764f, 
    0.05592426f, 0.19550808f, 0.29804361f, 0.01362638f, 0.11251090f, 0.15899254f, 0.09303413f, 0.32066011f, 
    0.09773266f, 0.28326106f, -0.09294397f, 0.00090980f, 0.30857995f, -0.08098363f, -0.16058111f, 0.26772460f, 
    0.17887129f, 0.06401213f, 0.64660752f, 0.05479278f, -0.23276617f, 0.11038534f, 0.01088393f, -0.19358379f, 
    0.05404287f, 0.01284107f, -0.16924869f, -0.19687964f, -0.15111144f, 0.11835670f, -0.15882112f, -0.05935232f, 
    -0.00651430f, 0.12986456f, -0.05224881f, -0.14976750f, -0.12406188f, -0.12289666f, -0.01003788f, 0.07627098f, 
    0.07238072f, -0.05899863f, -0.06273013f, -0.07155882f, -0.04031523f, -0.16416518f, 0.16924872f, -0.04981740f, 
    -0.07529910f, -0.10394720f, 0.08671577f, -0.14925550f, -0.05523270f, 0.01207760f, -0.17345627f, -0.14068975f, 
    -0.06361213f, 0.61984718f, -0.39795071f, 0.24624287f, 0.26152104f, 0.04018285f, -0.31397384f, 0.25561568f, 
    -0.05622823f, 0.29665384f, -0.02570140f, 0.00013048f, 0.01841938f, -0.17635541f, 0.44216818f, 0.45068777f, 
    -0.03606232f, 0.02382288f, -0.10532364f, -0.10223109f, -0.22189103f, 0.01273714f, 0.15654904f, 0.40252882f, 
    0.10049158f, 0.07573853f, -0.30573285f, -0.23403932f, -0.04989710f, -0.05560972f, -0.17253546f, 0.11549799f, 
    -0.06527641f, 0.34568951f, -0.21489604f, 0.12122120f, 0.09449539f, 0.17171410f, -0.00281846f, 0.12073799f, 
    -0.05273202f, -0.19740930f, -0.25470817f, 0.02284648f, 0.15133829f, -0.03607656f, 0.37311080f, 0.54749095f, 
    -0.10943882f, 0.17007034f, 0.18977131f, 0.02995956f, -0.13564993f, 0.09847386f, -0.11572527f, 0.32460243f, 
    0.19752376f, 0.47077614f, 0.08606375f, -0.34856197f, -0.11030389f, 0.14282282f, 0.13618723f, 0.16296233f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.13648240f, -0.02094460f, 0.22435978f, 0.11284127f, 0.25024262f, -0.00383579f, 0.26493448f, -0.04375439f, 
    0.25370681f, -0.25136983f, 0.05062333f, 0.26944473f, 0.01751354f, -0.16052476f, 0.16627380f, 0.08973458f, 
    0.20827655f, -0.14109574f, 0.11013846f, 0.08918711f, 0.11876117f, 0.05624394f, 0.22686669f, 0.08433884f, 
    0.21458152f, 0.37399805f, 0.36169741f, 0.43377951f, 0.21664292f, -0.20101081f, 0.27308214f, 0.23089117f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.78268689f, -0.27492556f, -0.87484580f, -0.22609664f, 0.06641805f, 0.02594832f, 0.45899853f, 0.13632706f, 
    0.31333685f, 0.16598350f, 0.32481408f, 0.03344038f, 0.14285447f, -0.09756586f, -0.04381143f, -0.96638995f, 
    -0.10708288f, -0.11592232f, -0.31252721f, -0.09670547f, -0.02141860f, -0.00398479f, 0.06026867f, 0.11963324f, 
    0.13820547f, -0.26721397f, -0.23755126f, -0.80885285f, -0.92611474f, 0.03314481f, -0.43729988f, -0.02622876f, 
    -0.75122076f, -0.07236888f, 0.58175856f, 0.21530589f, 0.21169415f, 0.15693131f, -1.05074453f, -0.15492798f, 
    0.00271929f, -0.25994909f, 0.00996384f, 0.20139828f, 0.26407576f, -0.09811419f, -0.54116505f, -0.42828467f, 
    -0.67014843f, -0.56286788f, 0.35433882f, -0.09834518f, 0.05241394f, -0.12722254f, 0.11641298f, 0.06359778f, 
    0.04580156f, 0.40294996f, 0.05539523f, 0.18304470f, -0.19617920f, -0.12911014f, 0.23934348f, 0.10961460f, 
    0.30794019f, 0.26061681f, -0.46939960f, -0.03462191f, 0.00337467f, 0.00086065f, -0.32842803f, 0.04364511f, 
    -0.09957022f, -0.24179015f, -0.87666965f, 0.18467093f, 0.15905429f, -0.19760932f, 0.29084900f, 0.38689393f, 
    -0.02823448f, 0.03946241f, 0.39336616f, -0.05814772f, -0.18590677f, 0.15329622f, -0.08475628f, 0.15549162f, 
    -0.07432497f, -0.53810585f, -0.52095962f, 0.03616541f, 0.08890192f, 0.01027600f, -0.01032274f, -0.18431158f, 
    0.50337851f, -0.77379572f, -0.37141493f, 0.19339570f, -0.93067265f, 0.04716378f, 0.06445473f, 0.14529952f, 
    0.15520602f, 0.12800828f, 0.18492983f, -0.37588701f, 0.13342202f, -0.05615387f, -0.86757761f, -0.05983461f, 
    0.40219384f, 0.10114429f, -0.39892358f, -0.14735195f, -0.06215564f, 0.05129524f, -0.10748767f, 0.09707709f, 
    0.22819631f, -0.23869815f, -0.00707567f, -0.38227990f, 0.13765416f, 0.07355099f, -0.69428509f, -0.17334107f, 
    -0.21489924f, 0.11549017f, -0.91956812f, -0.69254315f, -0.07628192f, -0.11502358f, 0.20221546f, 0.02896300f, 
    0.20131505f, 0.26036713f, -0.07401793f, -0.06839423f, -0.21590741f, 0.06165811f, -0.50943112f, -0.38051388f, 
    -0.51285875f, 0.27802938f, 0.19673063f, -0.15288934f, 0.13621576f, -0.58854276f, 0.07872469f, -0.01459471f, 
    0.16417454f, -0.62680995f, 0.00791224f, -0.39658046f, 0.02562949f, -0.16455847f, 0.09757500f, 0.20245200f, 
    -0.63208753f, -0.47081771f, 0.17562358f, -0.02979910f, -0.47137308f, 0.16311575f, 0.06774861f, -0.07896802f, 
    -0.08811159f, 0.13035843f, 0.09787179f, 0.25424677f, 0.22716577f, -0.21207140f, -0.67127132f, 0.14778863f, 
    0.09933626f, -0.09997461f, 0.12493495f, -0.03813253f, -0.23870879f, 0.12909633f, -0.10964970f, -0.06183516f, 
    0.25202432f, -0.04237173f, -0.01628187f, -0.07589203f, 0.09731194f, 0.00143057f, 0.02938460f, 0.15922180f, 
    0.17552716f, 0.04064188f, 0.20823045f, -0.14571443f, 0.30512753f, 0.02107977f, -0.17647909f, 0.02506298f, 
    -0.54566199f, 0.14346310f, -0.70258451f, -0.37428099f, -0.11550437f, -0.09379378f, 0.45149061f, 0.38511574f, 
    -0.14224157f, -0.06460378f, 0.28389964f, -0.17337693f, -0.72355628f, 0.23070604f, -0.76700169f, -0.67236453f, 
    -0.75217116f, 0.18734069f, -0.16275232f, 0.09382909f, 0.04894796f, -0.01079895f, -0.06631693f, -0.60771286f, 
    -0.28562543f, -0.01170834f, 0.51509595f, 0.32995674f, -0.42807999f, 0.06171700f, -0.06924444f, 0.00060734f, 
    0.32499108f, -0.19712199f, -0.07444127f, 0.31809995f, -0.22255471f, 0.05003002f, 0.23542750f, 0.06863180f, 
    0.23062812f, 0.01909304f, -0.97517854f, -0.11759467f, 0.21175003f, -0.41006535f, -0.50076264f, -0.70402145f, 
    -0.61498773f, -0.29561245f, 0.27504909f, -1.12844718f, -0.05926917f, 0.08315796f, -0.09376059f, -0.24246278f, 
    -0.51973742f, -0.09292231f, -0.11889251f, 0.20273261f, -0.30175951f, -0.09605798f, -0.53170413f, 0.15180306f, 
    -0.25098264f, -0.36318141f, -0.51429391f, -0.34781384f, -0.09321672f, -0.26597884f, -0.25776169f, 0.18075447f, 
    0.49277258f, -0.51993179f, -0.81147534f, -0.14966749f, -0.25735322f, 0.50474179f, -0.35374221f, -0.75702637f, 
    -0.18996049f, -0.00828788f, 0.33660871f, 0.15846193f, 0.16841061f, 0.14065076f, -0.03632359f, 0.29539290f, 
    0.05381229f, -1.12001097f, 0.03229582f, 0.27105233f, 0.15489049f, -0.07304687f, 0.47513336f, 0.13075790f, 
    -0.05727369f, 0.13807879f, -0.20059319f, -0.34261683f, 0.30406755f, -0.12329615f, 0.21291487f, -0.14783183f, 
    0.39226487f, 0.23396073f, 0.09273835f, 0.06163447f, -0.55475169f, -0.22823209f, 0.28143719f, 0.00789925f, 
    -0.21895249f, -0.11803376f, 0.00478390f, -0.10196417f, -0.00146103f, -0.02507675f, -0.16924933f, -0.23018123f, 
    -0.27193353f, -0.91868424f, -0.38377282f, 0.14646511f, -0.17505017f, -0.02411408f, -0.12057581f, -0.02228249f, 
    -0.23852304f, -0.31864139f, -0.28470472f, -0.32782000f, -0.12165976f, -0.00045983f, -0.39011419f, -0.14330152f, 
    0.20396443f, -0.39789453f, 0.17051865f, -0.10495247f, 0.56031716f, -0.24334782f, 0.07789907f, -0.89593250f, 
    -0.48435938f, -0.71337634f, -0.49103799f, -0.13733511f, -0.04890205f, 0.12976590f, 0.39956081f, 0.37673220f, 
    0.48709548f, -0.77790940f, -0.40321997f, -0.44102287f, -0.04111332f, 0.13420270f, -0.77808118f, -0.08225136f, 
    -0.16566060f, -0.18180366f, -0.01248936f, -0.65229642f, -0.81088793f, -0.18547752f, -0.19910696f, -0.26567402f, 
    -0.34529445f, 0.23514606f, -0.12631169f, 0.16516030f, 0.17264841f, 0.17349473f, -0.18507683f, -0.08835810f, 
    -0.24758665f, 0.44373372f, 0.08449882f, -0.07446297f, 0.26703432f, 0.16187674f, -0.04117249f, -0.03355594f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.26946467f, 0.25642309f, -0.02790515f, -0.10112080f, 0.03748555f, 0.25846684f, -0.41531923f, -0.03423813f, 
    -0.01807048f, 0.29703292f, 0.13466334f, -0.00889438f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
