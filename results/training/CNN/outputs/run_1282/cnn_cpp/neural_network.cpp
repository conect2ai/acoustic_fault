#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.58728361f, -0.50504941f, -0.40432599f, -0.30435959f, 0.05756847f, 0.67234927f, 0.18761049f, -0.62983847f, 
    -0.07280456f, 0.29507792f, -0.12379848f, 0.30543458f, -0.34105635f, -0.07551512f, -0.58439714f, 0.04308397f, 
    0.16380943f, 0.21318647f, 0.18076327f, -0.18552580f, 0.14550214f, 0.19860043f, -0.01897144f, -0.01242516f, 
    0.15317337f, 0.05359095f, -0.30268309f, 0.02572019f, 0.26975590f, 0.31777751f, 0.15512668f, 0.27266383f, 
    0.09177748f, -0.30344766f, -0.28418905f, -0.16254458f, -0.19330764f, 0.07467088f, -0.12620659f, 0.09189474f, 
    0.02227331f, -0.28625596f, 0.13886741f, 0.01811850f, 0.04606020f, 0.38982034f, -0.33063963f, -0.29468760f, 
    0.26847652f, -0.27341285f, 0.36801895f, 0.39980260f, -0.27542683f, -0.62115008f, -0.23889443f, -0.02061747f, 
    0.17555676f, -0.13482435f, 0.17352743f, 0.00876684f, 0.16112860f, 0.32180125f, -0.38463604f, 0.24580742f, 
    -0.17125995f, -0.01946205f, 0.07059108f, -0.06774128f, -0.22337131f, -0.08196412f, -0.08535825f, 0.08592203f, 
    -0.02694339f, 0.16218157f, 0.05970277f, -0.35096866f, -0.08429528f, -0.65518767f, -0.61437482f, -0.49989885f, 
    0.24037975f, 0.21344204f, 0.31931943f, 0.08095837f, -0.18234792f, -0.25758359f, -0.16166176f, -0.29652029f, 
    -0.06724254f, -0.18004203f, -0.08427419f, -0.46720409f, -0.05768078f, -0.40979889f, -0.42351118f, -0.07899986f, 
    -0.17501312f, 0.06864844f, -0.13271528f, 0.03934963f, 0.47552595f, 0.55983984f, 0.20981351f, -0.15756071f, 
    -0.19962160f, 0.04952546f, 0.00541846f, 0.00044205f, -0.33393553f, -0.44245508f, 0.27104905f, -0.02574472f, 
    0.06419262f, -0.16874243f, -0.08406512f, 0.32358354f, -0.28219324f, 0.19367084f, 0.23780195f, -0.25725457f, 
    0.23602465f, -0.31820276f, -0.02758883f, -0.15187088f, -0.31325436f, 0.72179419f, -0.09335527f, -0.16490151f, 
    0.18998414f, -0.25404534f, 0.57984132f, 0.50628883f, -0.24951865f, -0.64309448f, -0.12440198f, -0.26391304f, 
    0.09268865f, -0.34447241f, -0.29144657f, -0.05967581f, 0.24441379f, 0.28316379f, 0.08695523f, 0.11323544f, 
    0.06682048f, 0.05270844f, -0.23225573f, -0.16595843f, -0.15758477f, -0.21468261f, -0.04908445f, -0.61849028f, 
    -0.51539350f, -0.78004581f, -0.61231774f, -0.25299567f, -0.51261771f, -0.21107431f, -0.47885144f, -0.08188666f, 
    -0.15530965f, 0.04942197f, 0.15607531f, -0.34734121f, -0.12875000f, 0.11963172f, -0.08807838f, -0.01996471f, 
    -0.17748298f, 0.05493783f, 0.18527319f, 0.14974438f, -0.08735999f, 0.01492123f, -0.10323517f, -0.58060509f, 
    -0.53360057f, -0.26433107f, -0.40431362f, -0.42841005f, -0.25744408f, -0.42478749f, -0.59805483f, -0.16317439f, 
    0.41321898f, 0.21945362f, 0.12552556f, 0.03260737f, 0.05975259f, -0.14189908f, -0.18123281f, -0.09697006f, 
    -0.09051145f, 0.05483991f, 0.08146497f, -0.13551530f, -0.39793876f, -0.44239974f, -0.01075106f, -0.20397004f, 
    -0.33838236f, -0.79507560f, -0.25694686f, -0.05368240f, -0.06676885f, -0.07036619f, -0.04642331f, 0.50705135f, 
    0.27987832f, 0.65116394f, -0.03049918f, -0.11896506f, -0.22408190f, -0.30923021f, 0.07292169f, -0.39612734f, 
    -0.19588692f, -0.31833369f, 0.29445001f, 0.18239012f, -0.02094117f, 0.16938369f, 0.07321032f, -0.06207875f, 
    0.54094505f, 0.04225004f, -0.10301544f, -0.10148326f, 0.39137107f, 0.17062746f, 0.31325820f, -0.50022846f, 
    -0.45052201f, -0.17359211f, 0.06017629f, -0.06472472f, 0.21219319f, 0.08366592f, 0.07248334f, 0.22214195f, 
    -0.12087454f, 0.05392225f, -0.13386054f, 0.20677857f, -0.24250917f, 0.12054970f, 0.00645667f, -0.19089189f, 
    0.12308241f, -0.18870318f, -0.68474144f, -0.07296576f, -0.17364779f, -0.51313102f, -0.32488742f, -0.39144254f, 
    -0.26227021f, -0.10546041f, 0.12241230f, -0.11938666f, -0.29530823f, 0.03214344f, 0.40349114f, -0.11103206f, 
    -0.02903972f, -0.17663842f, -0.55523938f, -0.43925050f, -0.03235961f, -0.18465570f, 0.16308062f, 0.06259846f, 
    0.05415003f, 0.12236616f, 0.26078063f, -1.13765860f, -0.83707333f, -0.09353897f, 0.60592633f, 0.02722491f, 
    0.87606180f, 0.27462572f, -0.35075751f, -0.16210780f, 0.00781329f, -0.06869412f, -0.32758605f, -0.17586990f, 
    0.35507610f, -0.33914307f, 0.00746197f, -0.02433563f, -0.01037768f, -0.08372074f, -0.34447142f, -0.07222243f, 
    -0.12258273f, -0.01065768f, 0.10716020f, -0.24635407f, -0.28057882f, 0.54010797f, 0.39621291f, -0.53134024f, 
    0.04295103f, 0.01476320f, -0.06724942f, 0.27675894f, -0.22429317f, -0.47966152f, 0.26844838f, -0.08498432f, 
    -0.04577835f, 0.06441575f, -0.25954804f, 0.27718920f, -0.08232424f, -0.32488319f, 0.03496827f, 0.04468856f, 
    -0.13746986f, 0.20243399f, 0.23526789f, -0.03669646f, 0.10060077f, 0.39154145f, 0.29559055f, -0.42503631f, 
    -0.65808725f, -0.00091222f, 0.20461339f, 0.35926723f, 0.38358960f, -0.27155787f, -0.30700195f, -0.41920972f, 
    -0.34527650f, -0.00776420f, 0.50028980f, -0.28816515f, -0.07383858f, -0.15597330f, -0.05899268f, 0.17388451f, 
    -0.23438555f, -0.04369973f, -0.05157321f, 0.11296963f, 0.20859689f, -0.11708740f, -0.55197895f, 0.07429124f, 
    -0.09446830f, -0.22243418f, -0.08881316f, 0.49263522f, 0.16176872f, -0.04624897f, -0.07581940f, 0.04647355f, 
    -0.06362537f, -0.10799886f, 0.22053553f, -0.20824559f, -0.01842639f, 0.42727339f, 0.12604184f, -0.25788280f, 
    0.15553726f, -0.19788493f, -0.02253236f, 0.31327280f, -0.03335059f, 0.04419173f, -0.21755302f, -1.19939828f, 
    -0.45740846f, -0.00401473f, -0.02552478f, 0.73697263f, -0.43693617f, -0.63914597f, -0.20213321f, 0.41829884f, 
    0.02452715f, 0.49502769f, 0.09649330f, 0.67145663f, -0.21403722f, -0.18077928f, 0.06760292f, 0.00230723f, 
    -0.21151726f, -0.25899950f, -0.11219338f, 0.35409302f, 0.05245204f, -0.24411041f, 0.05634045f, 0.18280110f, 
    -0.99078995f, -0.36430076f, 0.00295622f, 0.47420740f, 0.61756831f, 0.63064307f, 0.39315534f, -0.22428206f, 
    -0.26871949f, -0.34624866f, -0.38245994f, 0.04123264f, -0.12340734f, 0.24287143f, -0.25305411f, 0.14244132f, 
    -0.14928105f, -0.00641199f, 0.05115851f, 0.13171892f, 0.13517910f, -0.19466610f, -0.14724256f, 0.28441149f, 
    -0.07095484f, 0.25033623f, 0.50066084f, -0.35896143f, 0.05470936f, -0.29577273f, -0.28565362f, -0.12708320f, 
    0.32144314f, -0.37571400f, 0.05245563f, -0.01618091f, -0.20756853f, 0.37875137f, 0.02807396f, -0.19414452f, 
    0.10298799f, 0.06343047f, 0.28648722f, -0.16465442f, -0.12830146f, -0.20000014f, -0.35674530f, -0.30096963f, 
    0.36694667f, 0.18667850f, 0.81854713f, -0.02435889f, -0.55435431f, -0.44107199f, -0.32807535f, 0.32810169f, 
    0.58672249f, 0.40175128f, -0.10527086f, -0.21657608f, -0.19403976f, -0.14635400f, -0.28720763f, -0.27369386f, 
    0.34242842f, -0.13539797f, 0.19122662f, 0.18444318f, 0.11141634f, -0.20335306f, 0.21289353f, -0.11132551f, 
    0.00301225f, 0.03391390f, -0.14495414f, 0.07640225f, -0.27294314f, -0.20986965f, -0.61306918f, -0.39349177f, 
    0.06610829f, -0.00582856f, 0.12260880f, 0.11629118f, 0.05105093f, -0.22051628f, -0.00903380f, 0.13904008f, 
    0.01772897f, 0.02030952f, 0.14319666f, -0.01304067f, -0.10148375f, -0.27409837f, -0.15723473f, -0.05576362f, 
    -0.38106602f, -0.25882572f, -0.34213886f, -0.49060380f, 0.42975324f, 0.52182692f, -0.58304340f, -0.22495320f, 
    -0.15475483f, -0.45907602f, 0.09534688f, 0.25009578f, 0.05716792f, 0.13847484f, -0.25416601f, 0.03269712f, 
    -0.11457450f, 0.13091871f, -0.15539758f, 0.04767001f, 0.07228047f, -0.29834822f, 0.20512755f, -0.23905464f, 
    -0.27949238f, 0.01206472f, 0.13354507f, -0.09298023f, -0.13034713f, -0.23315459f, 0.35373363f, 0.17266084f, 
    0.14989722f, 0.11947976f, 0.35051805f, 0.47095540f, 0.42055956f, 0.36776307f, 0.11986109f, -0.01474092f, 
    0.23474415f, -0.00754205f, -0.08575822f, 0.05834907f, 0.26751176f, -0.06254835f, -0.16371310f, -0.02606841f, 
    -0.08353182f, 0.10636409f, -0.01079530f, 0.10395210f, -0.15394220f, 0.03590927f, 0.20685086f, 0.37857535f, 
    0.26723635f, -0.15303952f, 0.04462171f, -0.14931700f, 0.06553267f, -0.21459225f, -0.02527382f, 0.20441511f, 
    0.11822293f, -0.32359222f, 0.03678865f, 0.15030065f, -0.11731335f, 0.08601673f, -0.08852971f, -0.16257179f, 
    0.20190437f, -0.08379663f, 0.19538516f, -0.01243139f, -0.12472623f, -0.25347599f, -0.25726950f, -1.10993946f, 
    -0.14917026f, 0.01314681f, -0.75240338f, -0.51604599f, 0.22117858f, 0.41520646f, 0.39221939f, 0.34972212f, 
    0.23764430f, 0.10158658f, 0.07699963f, 0.14361402f, 0.10247282f, -0.09141824f, 0.10636508f, 0.02585507f, 
    -0.03590763f, -0.11861023f, 0.04574521f, -0.02486833f, 0.07817674f, 0.04659541f, -0.06222250f, -0.16517498f, 
    0.03355680f, 0.17558436f, 0.24889766f, -0.21566938f, -0.43610442f, -0.07670314f, 0.24838307f, -0.07190553f, 
    0.01403862f, -0.06849232f, -0.11255434f, -0.11152123f, 0.25017670f, -0.10085957f, 0.11397813f, -0.20508268f, 
    -0.09579360f, 0.04229773f, 0.11177688f, 0.00870393f, 0.12134939f, -0.15768380f, 0.08604358f, 0.27073115f, 
    -0.02432124f, 0.52092081f, 0.43083915f, 0.18815060f, -0.55585623f, -0.45684209f, 0.01915977f, 0.36737812f, 
    0.01531127f, -0.10836163f, 0.07244668f, 0.17220102f, -0.01120021f, -0.05653802f, 0.15580656f, -0.40156814f, 
    -0.04111131f, -0.29755098f, -0.23287393f, -0.00858531f, 0.43434441f, 0.12442242f, 0.04945937f, -0.20191631f, 
    -0.07750934f, 0.20662600f, 0.47719505f, -0.80420327f, -0.75344163f, -0.23029709f, -0.85838562f, 0.76309079f, 
    0.53711593f, 0.08803740f, 0.14800882f, 0.11102721f, 0.08194233f, 0.10227226f, 0.21318515f, -0.12192713f, 
    0.00058927f, -0.18808742f, 0.00810254f, 0.24901189f, -0.15281188f, -0.13014244f, 0.04590423f, 0.02943513f, 
    -0.08078731f, -0.07944046f, 0.21578728f, 0.39759007f, 0.28046983f, -0.17670323f, 0.11414877f, 0.15346044f, 
    0.24169157f, 0.16952935f, -0.02803645f, 0.07632887f, 0.04386887f, -0.17195125f, -0.20395079f, -0.15901817f, 
    -0.09770846f, -0.01846528f, -0.10268714f, 0.05078184f, 0.05720261f, -0.16333984f, 0.05532596f, -0.15083994f, 
    -0.20998675f, -0.18894987f, -0.36897063f, -0.50380945f, -0.07152109f, 0.72055328f, 0.15265356f, 0.22150160f, 
    -0.34968942f, -0.67788154f, -0.44021326f, 0.29641438f, 0.25348133f, 0.03328298f, -0.05399807f, -0.27017173f, 
    -0.10544664f, -0.01865502f, -0.33182019f, 0.27256772f, 0.15317428f, -0.11801694f, 0.00976576f, 0.07707267f, 
    -0.08095626f, -0.04154573f, -0.11823029f, 0.21252789f, -0.27639046f, 0.01229368f, 0.24377103f, -0.30038342f, 
    0.04295173f, -0.18421306f, -0.27232507f, -0.48050791f, -0.25133714f, 0.14934714f, -0.33141521f, -0.06595536f, 
    0.01962498f, 0.05201406f, 0.18282434f, 0.28900099f, -0.05777886f, 0.06253049f, -0.11173779f, 0.14473242f, 
    -0.34316972f, -0.32563430f, -0.08279400f, -0.18752816f, -0.22530228f, -0.45236495f, -0.17600429f, -0.54064310f, 
    -0.32808164f, -0.06748001f, -0.30412376f, -0.58336735f, -0.40363091f, 0.11623198f, -0.36198246f, -0.48191273f, 
    -0.04460875f, 0.17453708f, -0.15056464f, 0.26957881f, -0.28368118f, -0.02288150f, 0.11390774f, 0.17717615f, 
    -0.00077623f, 0.05205273f, 0.05096438f, 0.23547710f, 0.02317404f, -0.09474893f, 0.23863763f, -1.07298458f, 
    -0.81700438f, 0.63984591f, 0.75992340f, 0.71411800f, -0.51096481f, -0.07826775f, -0.60757053f, -0.43233138f, 
    -0.30467409f, 0.25392064f, -0.30869362f, -0.27650684f, 0.02639711f, -0.05190828f, -0.18246707f, -0.34069410f, 
    0.24528067f, -0.05844571f, 0.17338839f, -0.08460595f, -0.01844728f, 0.21313918f, -0.12984940f, -0.03146177f, 
    -0.94753534f, -0.59171718f, -0.00877506f, 0.15312663f, 0.31890079f, 0.10168742f, 0.25071445f, 0.09971063f, 
    0.35599697f, 0.21984211f, -0.32026181f, 0.30428329f, -0.31243011f, 0.40222889f, -0.17129944f, -0.04874467f, 
    0.13072254f, -0.04417313f, -0.39876425f, -0.32208082f, 0.24139446f, 0.26838946f, 0.28507018f, 0.12113442f, 
    -0.24642105f, -0.31458393f, -0.54917061f, -0.49017298f, -0.41867885f, -0.22404017f, -0.35387018f, -0.08698792f, 
    -0.00561604f, 0.27616623f, -0.23899052f, 0.17787896f, 0.22895154f, 0.39911094f, 0.33059087f, 0.21802637f, 
    0.16108020f, -0.30336887f, -0.14698477f, 0.07723913f, -0.04663289f, -0.08105926f, -0.19387467f, -0.17624022f, 
    -0.18470992f, 0.09549358f, 0.11136017f, -0.00204228f, -0.11268437f, 0.16005102f, -0.53344011f, -0.60125428f, 
    -0.55551946f, -0.39392355f, -0.33400843f, -0.16805553f, -0.09998672f, -0.35342458f, 0.18438691f, -0.04848681f, 
    0.03773344f, -0.27323738f, -0.32863283f, 0.23791540f, -0.21070573f, -0.27005890f, -0.06715096f, 0.23644224f, 
    -0.32558495f, -0.08038605f, 0.20298024f, -1.16437638f, -0.03088767f, 0.51603615f, -0.16529414f, 0.07731309f, 
    -0.14991668f, -0.15977730f, 0.24640270f, 0.15099540f, 0.60782439f, -0.27862698f, -0.37047142f, 0.01196352f, 
    -0.42189151f, 0.41251665f, 0.22116514f, -0.07765152f, -0.19846606f, 0.23186068f, 0.22891623f, -0.13051584f, 
    -0.12688038f, -0.06852988f, 0.03669299f, 0.11141196f, -0.60164195f, -0.37634310f, -0.65695673f, -0.39230958f, 
    -0.71063024f, 0.35333458f, 0.49648321f, 0.18445982f, -0.15815653f, 0.24048828f, -0.07609884f, -0.10290454f, 
    -0.38111490f, -0.34800833f, 0.10590631f, -0.22207300f, 0.44042283f, -0.02451465f, -0.25398874f, -0.09347299f, 
    -0.07035141f, -0.30923137f, -0.18442449f, -0.11325462f, -0.27220482f, 0.17651521f, -0.96592492f, -0.45659566f, 
    0.71303511f, 0.59187949f, 0.03822018f, 0.34834760f, -0.36447841f, -0.43438405f, -0.10227065f, -0.08015976f, 
    -0.08664959f, -0.05705787f, -0.43136457f, -0.18017517f, 0.12162149f, 0.17187631f, 0.19775948f, 0.25526053f, 
    0.20901859f, -0.23155294f, -0.24422720f, -0.26896060f, -0.27282742f, -0.18428889f, 0.50980711f, -0.11355818f, 
    0.12018627f, 0.37246579f, 0.32303470f, -0.42267379f, 0.09094982f, -0.28046328f, -0.18414968f, -0.13998914f, 
    -0.21560045f, -0.11146142f, 0.31361604f, -0.15822774f, 0.09872879f, 0.18335305f, 0.09070312f, 0.05625561f, 
    0.20573220f, -0.36684430f, 0.00724103f, -0.07572876f, -0.15214618f, 0.06953507f, -0.09127371f, 0.48583525f, 
    0.14669590f, 0.04739602f, 0.28850782f, -0.08025115f, -0.18773551f, -0.05364923f, -0.26602578f, -0.32507408f, 
    -0.09764182f, -0.14852886f, -0.14521521f, 0.01141540f, 0.33643365f, -0.14864130f, 0.15488252f, -0.27371663f, 
    -0.12230377f, 0.13683201f, -0.16844882f, -0.26201755f, -0.15123412f, -0.15388153f, -0.21417755f, -0.09573062f, 
    0.60415798f, 0.45507017f, 0.05444443f, -0.29919857f, -0.69726956f, 0.17262976f, 0.05064436f, 0.19160987f, 
    -0.35208839f, -0.36747712f, 0.17908107f, 0.30682939f, -0.13463217f, 0.14171076f, 0.01398635f, -0.06294703f, 
    -0.18863283f, -0.31345189f, -0.04325955f, -0.10390801f, 0.12865016f, 0.18990268f, -0.23554781f, 0.10754375f, 
    0.26237160f, -0.40037087f, 0.18296236f, -0.16113159f, -0.45656836f, -0.34453920f, 0.38464737f, -0.07904542f, 
    -0.20910557f, 0.41264644f, 0.06798979f, 0.05458293f, 0.38298935f, -0.07605674f, -0.15685956f, -0.28325668f, 
    -0.31217301f, -0.32449713f, -0.10105309f, -0.10593382f, 0.16787322f, 0.12473544f, 0.30168614f, 0.28312317f, 
    0.18538761f, 0.26770699f, 0.70196760f, 0.15801889f, 0.09102081f, 0.14221250f, -0.31915313f, 0.06107796f, 
    -0.25963587f, -0.15781267f, 0.13311414f, 0.38936707f, 0.05167249f, 0.16431752f, -0.10587299f, -0.30101717f, 
    -0.23236428f, 0.14646305f, 0.04841964f, -0.05097452f, -0.26818216f, -0.25874901f, -0.02350470f, -0.11245885f, 
    0.08941130f, 0.00169713f, 0.04997537f, -0.39896938f, -0.38382411f, -0.35298216f, -0.40131238f, -0.23084250f, 
    -0.43162084f, -0.32894173f, -0.12141089f, -0.21453205f, -0.62284893f, 0.26500735f, -0.08470408f, -0.31338474f, 
    -0.17165375f, 0.10521568f, -0.31644684f, -0.27830875f, -0.22379412f, -0.41269490f, -0.22240707f, -0.23867384f, 
    0.01194426f, 0.02171013f, -0.19460818f, -0.42633244f, 0.89446431f, -0.36274692f, -0.34046245f, -0.28349322f, 
    -0.32807827f, -0.19407496f, -0.24129893f, 0.41205797f, 0.24570149f, -0.02865986f, 0.44429377f, -0.39170599f, 
    -0.26280618f, -0.10347751f, 0.20916678f, -0.18719238f, -0.05094681f, -0.08196925f, 0.10779719f, 0.19471699f, 
    -0.17534181f, -0.14675200f, 0.30695781f, -0.10030480f, 0.21902204f, 0.89410543f, -0.66139841f, -0.59625775f, 
    -0.06574871f, -0.78853059f, 0.32942685f, -0.08427406f, 0.22863321f, -0.17118473f, 0.20208567f, 0.16737616f, 
    -0.04442021f, 0.02886927f, 0.02543194f, 0.19045176f, 0.15096194f, -0.05817202f, -0.03922017f, -0.23001967f, 
    0.09306744f, -0.16534083f, -0.01879461f, -0.01090396f, 0.19185652f, -0.08340309f, -0.05200102f, 0.09436574f, 
    0.11169805f, 0.38612357f, -0.18037136f, 0.29018193f, -0.55875438f, -0.22721614f, 0.17864731f, 0.19720553f, 
    -0.20424224f, 0.02986624f, 0.08263836f, -0.03392732f, 0.07098855f, 0.05983385f, -0.11478268f, 0.01478336f, 
    0.17266995f, -0.13577509f, -0.12845203f, 0.18616980f, 0.21958660f, -0.16501036f, -0.20383291f, -0.24551217f, 
    -0.34055766f, 0.05390935f, 0.48612157f, -0.02521436f, -0.32551163f, -0.16771427f, 0.08101565f, 0.36955202f, 
    0.21727590f, 0.09678902f, -0.23061609f, -0.05439691f, 0.11232635f, 0.21568750f, 0.02122013f, 0.00574283f, 
    0.15855774f, -0.40059829f, -0.08666740f, 0.07924774f, 0.04800630f, -0.16837776f, 0.32369363f, -0.09563430f, 
    -1.17334664f, 1.06213486f, -0.41765866f, -0.73777503f, 0.46738413f, -0.05415794f, 0.12187580f, 0.47334850f, 
    0.07892743f, -0.29365191f, -0.03229120f, -0.21691693f, 0.24395308f, -0.20408207f, -0.25320685f, 0.30832207f, 
    -0.13469554f, -0.16463366f, -0.07918135f, -0.27421898f, 0.00795310f, -0.11521293f, -0.31093323f, -0.04588249f, 
    -0.40854782f, 0.34830463f, -0.52511656f, -0.30666995f, 0.37012839f, 0.42762211f, -0.61324382f, -0.18948349f, 
    -0.31331095f, 0.33804902f, 0.05937333f, 0.06859008f, 0.38581115f, -0.01755203f, -0.30935147f, 0.14316633f, 
    -0.26243284f, 0.17067760f, -0.02878601f, -0.28128681f, -0.29712442f, -0.21720429f, -0.14453521f, -0.05449769f, 
    0.11377623f, 0.09668703f, -0.02998473f, 0.65798688f, 0.13058081f, -0.28175914f, -0.19767807f, -0.27467248f, 
    0.38648310f, 0.16596635f, -0.45792335f, -0.43560714f, 0.18776308f, 0.22009826f, 0.27098769f, -0.35024732f, 
    -0.24900320f, -0.34040776f, 0.06230097f, 0.27464783f, 0.37101176f, -0.24847732f, -0.20079173f, 0.00962642f, 
    -0.00143892f, -0.27803436f, 0.09346968f, -0.41882071f, -0.11917361f, 0.29340586f, -0.32424888f, -0.38175386f, 
    -0.39897388f, -0.33417940f, -0.00570866f, 0.04669446f, -0.18795076f, 0.83140552f, 0.19715029f, 0.20803596f, 
    0.07785127f, -0.10370938f, 0.12268240f, -0.32915443f, 0.18619381f, -0.46425951f, -0.53999192f, 0.28134635f, 
    0.27850646f, -0.00655500f, -0.18094696f, -0.00051231f, -0.16717841f, -0.31219518f, -0.57529503f, -0.28917000f, 
    -0.38509113f, -0.60360408f, -0.93060911f, -0.56469780f, -0.76496017f, -0.81646359f, 0.21735206f, 0.59283614f, 
    0.12137588f, 0.18256162f, 0.25122577f, -0.10806716f, 0.00361332f, 0.01843270f, 0.23662993f, -0.22896220f, 
    -0.24107280f, 0.11325362f, 0.05300556f, 0.16222678f, 0.06409053f, -0.91162658f, 0.65558213f, 0.08712681f, 
    -0.36604095f, -0.14073336f, 0.08800761f, 0.37197897f, 0.32326728f, 0.10875231f, -0.38097134f, -0.37821659f, 
    -0.13640620f, 0.16736078f, -0.18938540f, 0.19180934f, -0.03007163f, 0.40821159f, -0.15716989f, -0.14952409f, 
    -0.04175745f, -0.06071603f, 0.07487334f, 0.12633002f, -0.32182094f, -0.23252204f, -0.34597972f, -0.29487318f, 
    -0.09941969f, -0.13884178f, 0.27049738f, 0.07048831f, 0.11259118f, -0.10114922f, -0.24923646f, 0.24178615f, 
    0.22042188f, 0.00430317f, -0.19417934f, 0.45206708f, -0.08420549f, -0.04837668f, -0.39324278f, -0.15318941f, 
    0.22437762f, -0.41343811f, 0.01556735f, 0.31621227f, 0.20801575f, 0.25854617f, 0.14459300f, -0.78186578f, 
    -0.43364099f, -0.40535229f, -0.08867388f, -0.41088706f, 0.41504523f, 0.05912857f, 0.10838581f, 0.37704632f, 
    0.49861211f, 0.18087275f, 0.35284334f, -0.31968921f, -0.08755060f, -0.18916091f, -0.36763668f, -0.03097662f, 
    0.03703570f, -0.07217722f, -0.00179016f, -0.01143008f, 0.12847713f, -0.10442957f, 0.13141868f, 0.23831080f, 
    -0.72490889f, 0.13859297f, 0.65231723f, -0.29536298f, -0.17239346f, 0.44958374f, -0.18464683f, -0.28034618f, 
    0.38557222f, -0.16612194f, -0.02490556f, -0.27614355f, 0.02731098f, 0.32622495f, -0.03110492f, 0.10186660f, 
    -0.29200864f, -0.41695437f, 0.13121268f, 0.34790531f, 0.00040674f, 0.09160253f, 0.14642119f, -0.03466645f, 
    -0.00034478f, 0.37243804f, 0.21583115f, 0.03654805f, 0.04503486f, -0.56460679f, -0.44403464f, -0.55831361f, 
    -0.24230789f, 0.19158986f, 0.18088026f, 0.15605532f, -0.24061456f, -0.21107940f, -0.09641905f, -0.02334139f, 
    -0.14888211f, 0.20570748f, -0.26072350f, -0.16091339f, -0.53505361f, -0.12670909f, -0.09799507f, 0.17311768f, 
    -0.13387837f, -0.18170033f, 0.64482546f, 0.02133805f, 0.07820846f, 0.35213721f, -0.27150860f, 0.09974958f, 
    -0.12009323f, -0.10077760f, -0.54129624f, -0.61893809f, -0.06867512f, -0.16138121f, 0.53250194f, -0.54338950f, 
    -0.06557793f, -0.00376043f, 0.06934574f, -0.05258843f, -0.02034416f, 0.21613438f, -0.02916553f, 0.15177271f, 
    -0.08408397f, -0.24038641f, 0.25111973f, -0.36072743f, -0.56303203f, -0.49785408f, -0.13943619f, -0.43888012f, 
    0.14708427f, -0.23636101f, -0.28305778f, 0.09254323f, 0.61546350f, -0.24937376f, -0.24611984f, -0.26965627f, 
    0.00493629f, 0.16730279f, 0.27362120f, 0.05697427f, 0.13177121f, -0.08034588f, -0.14978538f, -0.01331551f, 
    -0.39738402f, -0.33402693f, -0.05507400f, -0.23521830f, -0.41580051f, -0.11278279f, -0.06050675f, 0.29461181f, 
    0.01428196f, 0.20949848f, -0.28338104f, 0.30975497f, -0.16719788f, -0.47849190f, 0.08571182f, 0.04505628f, 
    -0.33126926f, -0.02047960f, 0.30153608f, -0.07325286f, -0.30805910f, -0.02864002f, 0.08485033f, 0.37784183f, 
    -0.33226222f, 0.24900801f, 0.24903788f, -0.14414594f, -0.32921660f, -0.07462380f, 0.31829858f, 0.56327498f, 
    -0.38531482f, -0.45396239f, -0.36320579f, -0.34165692f, 0.26022822f, 0.02821618f, 0.31962299f, -0.13340358f, 
    0.01034993f, 0.36566707f, 0.04710115f, -0.08243416f, -0.19686459f, -0.14277719f, 0.16660976f, -0.22124599f, 
    0.05348168f, 0.26919213f, -0.23331156f, 0.12835471f, -0.04177065f, 0.05326396f, -0.01505651f, -0.87749809f, 
    -0.22356418f, 0.42323789f, -0.14079541f, 0.47118518f, 0.52041763f, 0.42536238f, -0.26921561f, -0.47663084f, 
    0.22418892f, -0.16354397f, 0.03056247f, 0.16261092f, 0.06450823f, -0.34993738f, -0.09614836f, -0.00797180f, 
    -0.05419284f, 0.18318719f, 0.05844561f, -0.16789989f, -0.11035229f, 0.24810374f, 0.11817105f, 0.35886860f, 
    0.56803852f, 0.00144726f, -0.39079505f, -0.24105759f, 0.08210115f, 0.26695690f, -0.06920593f, -0.64816201f, 
    -0.95179355f, -0.21056569f, 0.26177630f, -0.40375179f, -0.30727074f, 0.04507191f, -0.19631115f, -0.24367517f, 
    0.03399096f, -0.25089008f, -0.16979977f, -0.05575220f, -0.34574392f, -0.28545493f, 0.02635072f, -0.27798608f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.01833515f, -0.04643532f, 0.12132699f, -0.18142930f, 0.20497149f, 0.13641445f, -0.37143737f, -0.17412411f, 
    0.12753892f, -0.01227878f, -0.07511486f, 0.18564110f, 0.11802968f, 0.05405562f, 0.04498162f, 0.23213641f, 
    0.23163258f, 0.17922896f, 0.08041186f, -0.07369112f, 0.16001998f, -0.07094656f, 0.05213665f, 0.05867007f, 
    -0.12131090f, 0.30534989f, 0.27864200f, -0.09166739f, 0.28093016f, -0.22753073f, 0.04106030f, 0.16396721f, 
    0.02965995f, 0.19795813f, -0.05762148f, 0.10433260f, 0.04339408f, -0.09764972f, 0.12726729f, -0.10422582f, 
    0.17358768f, -0.03211610f, 0.35445818f, -0.03182995f, 0.19839597f, 0.28276438f, 0.05487010f, 0.33134937f, 
    -0.02406070f, 0.10773537f, 0.39412603f, 0.33058974f, -0.19452865f, 0.15591067f, 0.21867032f, 0.04269171f, 
    0.16960965f, 0.00017198f, -0.05510655f, 0.01868954f, 0.14026782f, 0.11656812f, 0.34055310f, -0.20211741f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.29569376f, 0.14762506f, -0.21728174f, -0.15446870f, 0.00677257f, 0.13350524f, 0.11806256f, 0.01031547f, 
    0.03457441f, -0.00285830f, -0.00147048f, -0.08502660f, -0.00898538f, -0.30935821f, -0.09255039f, 0.11131652f, 
    -0.00173721f, -0.04354310f, 0.02559011f, -0.05444672f, -0.09573910f, -0.03842139f, 0.05539586f, 0.03821864f, 
    0.04356166f, -0.12128057f, -0.08189569f, 0.06369802f, -0.01830636f, 0.00316127f, -0.03936923f, -0.05701280f, 
    -0.25655282f, -0.10968098f, -0.14276823f, -0.07552150f, 0.14160284f, 0.01203821f, -0.01089505f, -0.00619714f, 
    0.05264271f, 0.01331869f, -0.13346452f, -0.06043618f, -0.14076929f, -0.15571795f, 0.01644560f, 0.08711734f, 
    -0.12229044f, -0.17772946f, -0.47283590f, 0.19893089f, -0.00857112f, -0.01859106f, -0.05981698f, -0.10827532f, 
    -0.05810208f, 0.03302615f, -0.01026717f, 0.04498587f, 0.04008098f, -0.07262360f, -0.24505430f, 0.07361878f, 
    0.00498093f, -0.04978016f, -0.03920054f, -0.12230776f, -0.07056659f, -0.00539495f, 0.10098150f, 0.01095156f, 
    0.27479792f, 0.18454272f, -0.09010726f, -0.08764209f, 0.14978185f, 0.18042277f, 0.05766997f, -0.02745475f, 
    0.00056254f, -0.05356181f, 0.01295209f, 0.08193700f, 0.21272896f, 0.17395891f, 0.05919891f, -0.14127603f, 
    0.19340214f, 0.19500548f, 0.05025649f, 0.15145299f, -0.01662622f, -0.03931155f, -0.04857326f, -0.00589654f, 
    0.17058480f, 0.09695677f, 0.08485614f, -0.05267356f, 0.10161916f, -0.05419419f, 0.12784530f, -0.04730753f, 
    0.01375736f, 0.01633763f, -0.05196692f, -0.15534134f, -0.00049402f, 0.07524229f, -0.05050418f, 0.04188091f, 
    -0.13731338f, 0.12022159f, 0.05000377f, -0.01880272f, -0.00236169f, -0.04182289f, -0.00253516f, -0.04599334f, 
    0.11613762f, 0.10973653f, 0.08224922f, -0.10541415f, 0.10509053f, 0.04147466f, 0.09311444f, 0.01749104f, 
    -0.05976686f, -0.15645289f, -0.05081693f, -0.03109141f, 0.42768708f, -0.03047662f, -0.11852527f, -0.20188567f, 
    -0.00633071f, -0.01339339f, 0.04450316f, -0.04984229f, 0.01896839f, -0.04903815f, 0.01798734f, 0.07160989f, 
    -0.05851357f, -0.06073251f, -0.07169476f, 0.01493995f, -0.08336246f, 0.02362553f, -0.01851288f, 0.08345288f, 
    -0.05989545f, 0.01983030f, -0.03878242f, -0.02667265f, 0.00072501f, -0.16592687f, -0.23631124f, 0.26222011f, 
    0.01388390f, 0.02817449f, -0.01922636f, 0.01754414f, 0.00298046f, -0.05328058f, -0.06072346f, 0.03986236f, 
    0.06078167f, 0.01285944f, -0.24896473f, -0.10019131f, -0.08774184f, 0.08491170f, -0.06640675f, -0.06258060f, 
    -0.10870720f, 0.01413493f, -0.09766531f, 0.08116108f, 0.21007369f, 0.38178870f, 0.16027096f, -0.26922819f, 
    -0.14600140f, 0.06928109f, 0.07863623f, 0.10050634f, 0.06707607f, -0.19732256f, 0.01968607f, -0.04768294f, 
    0.40013948f, 0.09828246f, -0.22897284f, -0.19748712f, -0.12091970f, -0.11903272f, 0.10003889f, -0.00109198f, 
    -0.12312988f, -0.07935930f, 0.04092751f, -0.11214444f, 0.05865728f, -0.09414338f, -0.16398355f, -0.10412280f, 
    0.12745038f, -0.00603528f, -0.09461188f, -0.03561354f, -0.07342018f, -0.11837609f, -0.06245213f, 0.08224314f, 
    -0.04787578f, -0.26045883f, -0.19758542f, 0.13240959f, 0.01738149f, -0.01540159f, -0.11305358f, -0.00066570f, 
    0.09510314f, -0.00716851f, -0.15075950f, 0.06704960f, -0.06193056f, -0.12087797f, 0.02889717f, 0.04600853f, 
    0.05786427f, 0.07404785f, -0.00366160f, 0.01734539f, 0.00409168f, 0.03279734f, 0.07840421f, 0.16462374f, 
    -0.58214343f, -0.08172684f, -0.09731950f, 0.08513068f, 0.00188061f, 0.04304014f, 0.00446951f, 0.01361255f, 
    -0.10646840f, -0.00530773f, -0.20118277f, -0.06377523f, 0.01760727f, -0.01476528f, 0.05586931f, 0.07169512f, 
    -0.00763051f, 0.06908205f, 0.08291239f, 0.04902353f, -0.30136889f, -0.14254203f, -0.15252748f, -0.14221790f, 
    -0.11373170f, -0.07742583f, 0.00926311f, 0.09393755f, 0.05146438f, 0.05900059f, 0.03916522f, -0.00425175f, 
    0.03490881f, -0.05113992f, 0.01148942f, 0.02412150f, -0.02034668f, -0.13133453f, 0.08910395f, -0.00626919f, 
    0.09325127f, 0.14618500f, 0.02362603f, 0.07498822f, -0.09418628f, -0.01701576f, 0.00656919f, -0.01001219f, 
    0.00282600f, -0.00929462f, 0.08694839f, 0.05429843f, -0.18149866f, -0.12339719f, -0.15397571f, -0.10820261f, 
    -0.04596446f, -0.04426559f, 0.00330372f, -0.00543849f, -0.41134903f, -0.54016078f, -0.40346161f, 0.22970131f, 
    0.02773037f, 0.04238364f, -0.02005798f, 0.07054345f, -0.07016973f, -0.09555618f, -0.01608659f, -0.15898031f, 
    0.09793270f, -0.18674159f, -0.37513599f, 0.06964268f, 0.12223422f, 0.11468413f, -0.07181620f, -0.14228576f, 
    -0.04028703f, -0.08490375f, -0.10009520f, 0.06998346f, -0.28359297f, -0.14875634f, -0.02808828f, 0.10458905f, 
    0.01872864f, 0.04990603f, 0.03085835f, 0.04112311f, 0.06410541f, 0.02124136f, -0.07985822f, 0.16350852f, 
    -0.62735111f, 0.16572057f, 0.34604526f, -0.02957627f, -0.03600761f, -0.07063147f, 0.02243069f, 0.02319966f, 
    -0.00058716f, -0.04254495f, -0.00175852f, 0.03136408f, 0.16290130f, 0.03503410f, 0.05489084f, -0.02426780f, 
    -0.13607842f, -0.09740349f, 0.02992735f, -0.11512487f, 0.12928015f, -0.03273878f, -0.08660417f, 0.07510387f, 
    0.22950450f, 0.13482484f, -0.00705560f, -0.25105369f, 0.10989943f, 0.03120812f, 0.04954533f, -0.00449024f, 
    0.00737965f, 0.00691065f, -0.01961789f, 0.03643479f, 0.47926441f, 0.12988991f, 0.06967981f, -0.40739128f, 
    0.01292590f, -0.03830427f, 0.03165253f, -0.02387088f, -0.04954308f, -0.06534255f, -0.05144370f, 0.03164351f, 
    -0.12198164f, 0.09999673f, 0.05474897f, -0.12876618f, 0.02145454f, 0.03359001f, 0.08295456f, 0.02084933f, 
    -0.19871505f, 0.02343369f, -0.11686891f, -0.14169340f, 0.25232390f, 0.13006918f, 0.07030531f, -0.04801124f, 
    0.08179588f, 0.05211940f, -0.00775897f, -0.12958950f, -0.02573371f, -0.04470349f, -0.03589538f, 0.01297914f, 
    0.12694806f, 0.10286901f, 0.01284556f, -0.23304930f, 0.07923210f, 0.05957713f, 0.00420977f, -0.02171594f, 
    -0.04357506f, -0.08994278f, 0.03777396f, -0.05810930f, -0.03560962f, 0.30537447f, 0.21295853f, -0.17043097f, 
    -0.01938107f, 0.12148976f, 0.06927917f, -0.02389443f, 0.04993411f, -0.02354457f, 0.04268846f, -0.17617336f, 
    0.19316909f, 0.09951513f, -0.07742098f, -0.06375916f, 0.12175228f, 0.17027266f, 0.03801066f, 0.02433398f, 
    -0.08716214f, 0.05721648f, 0.08618976f, -0.00417414f, 0.32579613f, -0.01024825f, 0.05738935f, 0.00048622f, 
    0.04581918f, -0.07671592f, 0.12796517f, -0.10781422f, 0.02844915f, 0.15057923f, 0.08386105f, 0.00489891f, 
    -0.20947899f, -0.09638308f, 0.02443501f, 0.01825194f, 0.02269273f, -0.07778172f, -0.02455087f, 0.01058244f, 
    -0.01232835f, 0.00976604f, -0.02763363f, 0.05745312f, -0.19742724f, -0.14685833f, -0.00805392f, -0.15600096f, 
    0.03423129f, -0.02200772f, -0.03893241f, -0.00486632f, 0.00410685f, 0.01428727f, 0.04323775f, 0.05023884f, 
    0.04757443f, -0.30853298f, -0.39717844f, 0.14164530f, 0.03948620f, 0.02733001f, -0.15407141f, -0.13736463f, 
    -0.01544118f, -0.00433149f, -0.01012777f, -0.20999645f, 0.11659903f, -0.05373107f, -0.07730380f, -0.11176331f, 
    0.02294797f, 0.17276275f, -0.05204213f, 0.06542991f, -0.03917445f, -0.15986943f, 0.02051669f, -0.02325883f, 
    -0.45601627f, -0.10572532f, -0.32292527f, 0.08990354f, -0.03111406f, 0.01679854f, 0.03780779f, 0.04029517f, 
    -0.13502043f, -0.07960374f, -0.00963262f, 0.07796866f, 0.22733566f, 0.10901273f, -0.00685217f, -0.09165861f, 
    0.06505299f, 0.11672722f, -0.01873051f, 0.07625838f, -0.10591600f, -0.14078024f, -0.12808661f, -0.03609031f, 
    -0.13237973f, -0.19920115f, -0.31520858f, -0.05581396f, -0.04612873f, -0.02738648f, -0.04392847f, 0.11409965f, 
    -0.06135873f, 0.07906280f, -0.11208643f, -0.12830968f, 0.03974439f, -0.01336460f, -0.21979995f, 0.08925584f, 
    0.05660977f, -0.01674708f, -0.04074125f, -0.10375818f, -0.06799447f, 0.14570883f, -0.08262147f, 0.04390567f, 
    -0.01575962f, -0.01054307f, 0.04596405f, 0.01296284f, 0.06658258f, -0.05536246f, 0.01042291f, 0.00128921f, 
    -0.02612473f, -0.03756949f, 0.02086831f, -0.06139648f, -0.27041057f, -0.01322980f, 0.13998015f, -0.04149320f, 
    -0.04469444f, -0.03305677f, -0.01040458f, 0.05034630f, -0.15115821f, -0.24734862f, -0.13781551f, -0.16980983f, 
    -0.41172218f, 0.09326159f, -0.07471264f, 0.11373495f, -0.04881486f, 0.11731765f, -0.00130876f, 0.07698923f, 
    0.03897378f, 0.04089537f, 0.06525189f, 0.06759262f, -0.30421862f, 0.29785421f, -0.06444574f, -0.25385004f, 
    -0.11287969f, 0.08094294f, -0.00287420f, -0.14117353f, -0.03209033f, -0.00355488f, -0.01750450f, 0.03405375f, 
    -0.05188669f, -0.11829910f, -0.26121667f, 0.10901409f, -0.00290074f, -0.29065603f, -0.10752433f, -0.01031398f, 
    0.05505944f, 0.11335587f, 0.04918594f, 0.01135273f, 0.15526709f, 0.04333783f, 0.06618585f, -0.14406981f, 
    -0.04243819f, 0.10745864f, -0.07974444f, -0.05682023f, -0.06462209f, -0.04781047f, -0.00697023f, -0.02831119f, 
    0.39754030f, 0.21221629f, -0.18467927f, -0.13201451f, 0.09251098f, -0.00353820f, -0.00120637f, 0.04258860f, 
    0.00483657f, 0.03838246f, 0.02459007f, 0.00179895f, -0.25686821f, -0.22905599f, 0.05977507f, -0.09659043f, 
    -0.09252349f, 0.07023916f, -0.08916061f, -0.05133774f, -0.15349497f, 0.03599696f, 0.04123087f, 0.01752596f, 
    -0.02510575f, 0.15692849f, -0.03505074f, 0.02997187f, -0.00003639f, 0.11634392f, -0.00988206f, -0.19014072f, 
    -0.12768205f, -0.04838167f, -0.18746524f, -0.07795187f, 0.06210569f, -0.01637778f, 0.05650257f, -0.08609907f, 
    0.08148362f, 0.09884792f, 0.05153617f, -0.01510324f, -0.04408121f, 0.08719482f, 0.01880625f, -0.11196460f, 
    0.05848677f, 0.02643046f, -0.13074191f, -0.28072146f, -0.19762078f, 0.00999713f, -0.15052950f, 0.13634461f, 
    -0.07199301f, -0.04203065f, -0.10255203f, -0.14093189f, 0.01439170f, 0.09422004f, 0.11659351f, -0.07175782f, 
    -0.06348456f, -0.07870181f, -0.21393010f, -0.05217244f, -0.04838420f, -0.19921912f, -0.03637716f, -0.01330552f, 
    0.05301206f, -0.26343691f, -0.27988514f, -0.00900810f, 0.05553817f, -0.02082740f, -0.02466441f, 0.07547166f, 
    0.03373660f, 0.05833881f, 0.04638132f, 0.02387544f, 0.13791679f, 0.20865667f, 0.10505259f, -0.16878144f, 
    0.12233616f, 0.15346524f, 0.01643830f, 0.11229587f, 0.03311534f, 0.04891089f, 0.04419958f, 0.10627631f, 
    0.08236708f, -0.05062720f, -0.02245531f, -0.11391091f, -0.17302163f, -0.06807255f, 0.10284043f, -0.04596099f, 
    -0.07803916f, 0.01091419f, 0.08401424f, 0.01111158f, -0.00779765f, -0.27271962f, 0.14629242f, -0.03683149f, 
    -0.21156125f, -0.07965964f, -0.07886562f, -0.03213236f, -0.01457709f, -0.05353573f, 0.01118769f, -0.09028028f, 
    0.02823756f, -0.36722434f, -0.24430358f, -0.00549183f, 0.07339127f, 0.00630810f, -0.02849858f, -0.11823893f, 
    -0.09564494f, -0.18032028f, -0.19595402f, 0.01659788f, 0.07032911f, -0.02551214f, -0.22891515f, 0.15010959f, 
    -0.13492331f, -0.18094873f, -0.20456085f, -0.05286039f, -0.05418988f, 0.03466966f, 0.05488728f, -0.02471640f, 
    0.15903158f, 0.14261180f, -0.19838259f, -0.09684291f, -0.00612577f, -0.03127326f, 0.02596151f, 0.07855336f, 
    -0.04834719f, -0.05314660f, -0.10689636f, 0.02921060f, 0.15082642f, 0.09783576f, 0.27548078f, 0.15394625f, 
    -0.01290675f, -0.06422610f, 0.01712819f, -0.01831305f, 0.08765800f, 0.08316723f, 0.06076989f, -0.14524066f, 
    0.08817361f, -0.04210714f, 0.03967285f, -0.01619438f, -0.03671055f, 0.03282976f, 0.08179536f, 0.02790540f, 
    0.10445189f, 0.04756844f, 0.00403599f, -0.01400503f, 0.07974076f, 0.13425080f, 0.07281947f, -0.10172988f, 
    0.05830768f, 0.01764634f, 0.04005511f, 0.03349132f, 0.10011216f, -0.00552287f, -0.23991774f, -0.10818921f, 
    0.07186386f, 0.03158357f, 0.03417107f, -0.05216427f, -0.04278810f, -0.00178436f, -0.00853333f, -0.08577548f, 
    0.00629163f, -0.02185138f, 0.02158592f, 0.05378592f, 0.39950943f, -0.00784010f, -0.10431582f, -0.05909353f, 
    -0.01497636f, -0.02111657f, -0.00335089f, 0.04760491f, 0.12637262f, -0.05852697f, -0.01041268f, 0.00257024f, 
    0.19753750f, 0.26345190f, 0.20785224f, 0.24978508f, -0.15884960f, 0.13394558f, -0.34523061f, -0.26287678f, 
    -0.01297782f, -0.02617808f, -0.01011165f, 0.04684256f, 0.19216798f, 0.11087015f, -0.03256294f, 0.10515635f, 
    -0.21184576f, 0.03307099f, -0.13649291f, -0.06973384f, 0.05177337f, -0.05934469f, -0.00611871f, -0.03228971f, 
    -0.16888061f, 0.33156386f, -0.42451704f, -0.30689019f, -0.01001483f, 0.18010482f, -0.03935254f, -0.03318526f, 
    -0.03696938f, 0.08914814f, -0.07214908f, 0.10292952f, -0.02324474f, 0.09592039f, -0.07000542f, 0.05751316f, 
    0.01783593f, -0.07639595f, 0.01269920f, 0.01706292f, -0.07148044f, -0.03156360f, 0.05267219f, 0.03764235f, 
    -0.10948179f, 0.07751415f, 0.04323134f, 0.14413998f, -0.04153148f, 0.10827403f, 0.18417108f, 0.22720596f, 
    0.01933906f, 0.12210026f, 0.03452335f, -0.02551385f, 0.35813725f, -0.17361370f, 0.08217472f, 0.01469335f, 
    0.04050978f, -0.13668567f, 0.05969199f, 0.05256353f, 0.03148017f, -0.15077889f, -0.03431562f, -0.14444333f, 
    0.16898061f, -0.12628166f, -0.01116399f, 0.05794277f, -0.17359269f, -0.07052669f, 0.12465637f, -0.04395533f, 
    -0.07502934f, 0.01809370f, -0.00774265f, 0.04808993f, 0.37032798f, -0.05688708f, 0.20855334f, 0.13381553f, 
    0.03426475f, -0.14586851f, 0.10284022f, -0.01719768f, -0.05104348f, -0.12364972f, 0.08424116f, -0.03604451f, 
    0.02006894f, -0.08840590f, 0.10079772f, -0.01957628f, 0.03584498f, 0.00463138f, -0.02234200f, 0.06238803f, 
    -0.12634577f, -0.07302070f, -0.07951243f, -0.11315463f, -0.65744138f, -0.05809816f, -0.38235381f, 0.25322023f, 
    0.07619529f, 0.05290530f, -0.02010009f, -0.02400092f, -0.09076429f, 0.07373211f, 0.01568017f, 0.07971933f, 
    -0.01548629f, -0.26411700f, 0.19900000f, 0.20487161f, -0.07622556f, -0.03889268f, 0.17243530f, -0.02246696f, 
    0.20715535f, -0.01988036f, 0.03008690f, -0.07527755f, -0.02086163f, -0.13166407f, 0.08898984f, -0.01536925f, 
    0.16738988f, -0.10935859f, 0.04496467f, -0.07741384f, 0.16845116f, 0.05788460f, -0.07571866f, 0.10055296f, 
    0.55440027f, -0.08150560f, 0.07327232f, 0.03084725f, -0.05458232f, -0.10001030f, 0.08147082f, -0.09143249f, 
    -0.06493822f, -0.00990382f, -0.16007353f, -0.16447835f, 0.02963518f, -0.14684641f, -0.02919930f, -0.09411371f, 
    0.03187388f, -0.00053581f, -0.04778533f, -0.02401116f, -0.21518432f, -0.16153653f, 0.03748566f, -0.19454628f, 
    -0.00089233f, -0.04451621f, 0.14302737f, 0.05095580f, 0.03251042f, -0.00465680f, 0.01340756f, 0.01399496f, 
    0.02154402f, -0.04016896f, -0.07679706f, 0.12056628f, 0.13149963f, 0.13692440f, 0.16653869f, 0.11945522f, 
    -0.01717351f, -0.06522056f, -0.05339229f, -0.05436601f, 0.11482803f, 0.04388859f, 0.04399590f, 0.01447409f, 
    0.10824896f, 0.07644739f, 0.03713784f, 0.10061533f, 0.03647862f, 0.03344504f, -0.10034374f, 0.05933945f, 
    0.08511535f, -0.00985228f, 0.16754167f, -0.02704443f, -0.01217379f, -0.09588028f, -0.14858137f, -0.07406045f, 
    0.00843470f, 0.02992596f, -0.08171222f, 0.02682983f, -0.09523376f, -0.01422135f, 0.06584994f, -0.05996486f, 
    0.00677832f, 0.03612419f, -0.02518817f, -0.01436928f, 0.10424332f, -0.00677755f, -0.00460818f, -0.07928360f, 
    -0.04023028f, -0.00414838f, -0.00608750f, 0.04281025f, 0.41266736f, 0.06730928f, 0.13911894f, -0.10554113f, 
    0.00154285f, -0.04070354f, 0.02276479f, 0.06605828f, -0.00549185f, -0.01090013f, -0.00381397f, -0.19252189f, 
    0.56152618f, -0.31511122f, -0.43721741f, -0.23097424f, -0.01212387f, -0.01475198f, 0.07971808f, -0.09092645f, 
    0.02666909f, 0.06204872f, 0.08494690f, -0.11802115f, 0.12041918f, 0.15827103f, 0.14512374f, 0.07874957f, 
    -0.02853308f, 0.00056259f, -0.02782895f, 0.04234681f, -0.26258209f, -0.05904833f, 0.07069580f, 0.04701810f, 
    -0.16330031f, 0.02253490f, 0.29652143f, -0.01815792f, 0.00461095f, -0.04409103f, 0.01166674f, -0.02237304f, 
    -0.00160843f, 0.00747988f, 0.00951545f, 0.05030720f, -0.13743052f, -0.03380041f, 0.05761022f, -0.18697535f, 
    0.02910418f, 0.04515037f, -0.09618977f, 0.11221379f, -0.24883515f, -0.02526519f, -0.06937600f, 0.01809485f, 
    -0.05827019f, 0.16283014f, 0.05935023f, 0.09471975f, -0.01356608f, 0.01331564f, 0.06545070f, -0.19560851f, 
    -0.04498646f, -0.05079125f, -0.04579522f, 0.02347508f, -0.19184780f, -0.10621376f, -0.31994203f, -0.60806453f, 
    -0.02560741f, -0.09197980f, 0.16855232f, 0.13560499f, 0.02190466f, 0.04716131f, -0.01141022f, -0.09307661f, 
    -0.05923406f, -0.10366534f, 0.11773951f, -0.05674188f, -0.11333741f, 0.02058645f, 0.01055680f, 0.06715318f, 
    -0.06155251f, -0.06636528f, -0.08230890f, 0.12234239f, -0.21779457f, -0.09229046f, -0.06307981f, -0.03713842f, 
    0.06319760f, 0.12782586f, 0.08473088f, -0.06910063f, 0.16837053f, -0.01694812f, 0.09108102f, -0.00454881f, 
    0.02054081f, 0.04478104f, -0.13512427f, -0.01344538f, -0.14025144f, 0.01920427f, -0.16215737f, -0.00360199f, 
    -0.05936889f, 0.02855801f, -0.00500682f, -0.03932966f, -0.44338873f, 0.21432872f, -0.07710876f, 0.14733672f, 
    0.00407819f, -0.04597462f, 0.02618223f, -0.24974212f, 0.11135800f, -0.01333810f, -0.07119795f, -0.13571939f, 
    0.23102260f, -0.06826799f, 0.18678105f, -0.07663263f, 0.07876340f, 0.02536378f, -0.04309661f, -0.16653439f, 
    0.14214708f, -0.00529658f, -0.18270808f, -0.16732810f, -0.05825065f, -0.02364237f, -0.18725255f, -0.07917830f, 
    0.01803675f, -0.08900796f, 0.02907982f, -0.10264996f, 0.09615141f, -0.26060808f, -0.01920904f, 0.03422109f, 
    0.08261586f, 0.09646355f, -0.02578497f, -0.01210176f, 0.00437399f, 0.01417126f, -0.03543339f, -0.05752659f, 
    0.00058137f, -0.00378771f, 0.05974062f, 0.03098088f, 0.08436698f, 0.05770296f, -0.06113688f, 0.08260814f, 
    0.05177351f, -0.01514285f, -0.04834309f, -0.05514074f, -0.01594939f, 0.04264124f, -0.02102016f, -0.01395491f, 
    0.41331002f, -0.15995228f, 0.07823057f, -0.14508131f, -0.01591857f, 0.03738560f, -0.01530990f, 0.07840776f, 
    -0.02424477f, -0.02956617f, 0.02007257f, 0.16978744f, -0.06101353f, 0.18315195f, -0.06292763f, 0.04988372f, 
    0.08908978f, 0.01529698f, -0.02956804f, 0.09405925f, -0.14476958f, 0.16734110f, -0.08250875f, -0.01640819f, 
    0.31259018f, 0.14334342f, 0.24589239f, 0.06990799f, 0.01063038f, 0.04814431f, -0.04026889f, -0.00421815f, 
    0.02057861f, -0.02585139f, -0.04282599f, 0.10239851f, 0.00348456f, 0.09532830f, 0.14010437f, -0.01963628f, 
    0.05783571f, 0.09129377f, 0.07033949f, 0.26342228f, 0.00528511f, 0.01454128f, 0.01635059f, 0.05498476f, 
    0.19560538f, 0.17576051f, 0.04438309f, 0.10043810f, 0.03060103f, 0.01698568f, 0.15675417f, -0.16084214f, 
    0.06337336f, 0.08616243f, -0.04851289f, -0.06308509f, 0.33309677f, -0.07256849f, -0.18319234f, -0.11779798f, 
    -0.04542878f, 0.04892661f, -0.03021375f, -0.03254933f, 0.17887439f, 0.00280437f, -0.00390789f, -0.15562087f, 
    0.01595959f, 0.11585911f, 0.02067474f, -0.03557138f, 0.06462644f, -0.01505015f, -0.01739678f, 0.01978672f, 
    -0.13097753f, 0.09741215f, 0.15458766f, -0.11022159f, -0.17067443f, 0.19841795f, 0.02968587f, 0.00404435f, 
    -0.05930531f, 0.06843249f, -0.01337054f, -0.00883104f, 0.00702417f, -0.04837869f, -0.00536946f, 0.01736977f, 
    -0.58374029f, -0.51382190f, 0.10120801f, -0.04665045f, 0.01397172f, -0.02157076f, -0.04314455f, -0.07874970f, 
    -0.25311825f, -0.16931327f, -0.21665898f, -0.02032023f, -0.31373283f, 0.11164080f, -0.13211580f, 0.15506981f, 
    -0.08888978f, 0.09796155f, 0.01225808f, -0.07330582f, 0.03414595f, 0.06201465f, -0.09164476f, 0.23268060f, 
    0.16641118f, -0.14344591f, 0.08139710f, -0.18698458f, 0.05600938f, 0.09677515f, -0.02968814f, -0.06506860f, 
    0.05445135f, -0.12272774f, 0.05273195f, 0.12412369f, -0.57791221f, -0.27196094f, -0.17001241f, -0.17820247f, 
    -0.02184968f, 0.10726310f, -0.12867144f, 0.27449703f, -0.03286048f, 0.00499375f, -0.04695274f, 0.10279264f, 
    0.04185611f, 0.05520477f, 0.01394898f, 0.20035194f, -0.28536627f, 0.14650080f, -0.07226827f, 0.11889448f, 
    -0.10052609f, -0.03569863f, -0.03471875f, 0.06054486f, -0.34342581f, -0.13206160f, 0.19636871f, -0.09926309f, 
    0.16025849f, -0.08464848f, -0.21555249f, 0.07537676f, 0.02515317f, 0.01041635f, -0.05905733f, -0.05266348f, 
    0.00007969f, -0.05142267f, -0.02120644f, 0.07848054f, -0.10247165f, 0.08514092f, 0.08633082f, 0.03084864f, 
    -0.04053037f, -0.01477549f, 0.07419317f, -0.02871944f, -0.03567056f, 0.10882463f, -0.17786446f, -0.18090837f, 
    -0.05271080f, -0.02375300f, -0.02893341f, -0.03204791f, -0.03352149f, 0.03515814f, -0.02267902f, -0.08518814f, 
    -0.11747512f, -0.04189745f, -0.07801396f, -0.00857945f, 0.05041451f, -0.01174121f, 0.05208581f, 0.05559443f, 
    -0.04566525f, -0.05128444f, 0.10794336f, -0.03610744f, -0.16692133f, -0.02421736f, 0.14373915f, -0.36465338f, 
    0.07835530f, 0.00298367f, -0.08377476f, 0.11926233f, 0.00649533f, 0.07651049f, -0.26671183f, -0.13773507f, 
    0.45693097f, -0.00667156f, -0.35426649f, -0.19172931f, -0.28009892f, 0.02329716f, -0.02726715f, -0.16926509f, 
    -0.02499922f, -0.02849835f, -0.04455992f, 0.00557331f, 0.04058143f, 0.12365469f, 0.07372869f, 0.03028282f, 
    0.01242582f, -0.03613317f, -0.20497236f, -0.21668951f, 0.00360141f, -0.01747934f, 0.00719366f, -0.19408545f, 
    -0.01643754f, 0.00426403f, -0.05178710f, -0.09373441f, 0.01581932f, -0.10203904f, 0.15779050f, 0.12660134f, 
    -0.05863184f, 0.15120634f, 0.10090643f, -0.04813161f, -0.10894432f, -0.15530217f, 0.08051053f, -0.13828863f, 
    0.05379768f, 0.06184511f, -0.02272212f, 0.09270123f, 0.17729415f, -0.11537788f, 0.09645778f, 0.06923238f, 
    0.18129173f, -0.12685110f, 0.05993245f, -0.03372209f, -0.00374852f, -0.01281218f, 0.09201016f, -0.12038759f, 
    0.24275526f, 0.04559731f, 0.19243854f, -0.00539139f, 0.42742187f, -0.57659239f, 0.25722492f, -0.37303305f, 
    -0.02914564f, -0.01752033f, 0.02028356f, 0.00442534f, -0.01757699f, -0.00996690f, -0.05355063f, 0.05555152f, 
    -0.17666557f, -0.08845814f, 0.36741596f, 0.16968353f, -0.02672732f, -0.15709558f, -0.10386908f, 0.14001247f, 
    0.00327384f, -0.05435211f, -0.01479375f, 0.01100056f, 0.02793053f, 0.03922197f, -0.20894596f, 0.01238192f, 
    0.04279799f, -0.10781213f, 0.08062277f, 0.13474114f, -0.12162098f, 0.09608482f, 0.05653041f, -0.04580389f, 
    -0.01356839f, 0.02301539f, -0.08060495f, -0.01851584f, -0.03710039f, -0.03066249f, -0.02961564f, 0.02893414f, 
    -0.01494562f, -0.07543213f, -0.12702584f, 0.19227153f, -0.15137844f, 0.34476882f, 0.34623092f, 0.12032613f, 
    -0.05119779f, 0.00915875f, 0.00706582f, -0.01560381f, -0.10894693f, -0.14256173f, -0.05682274f, -0.05860237f, 
    -0.07423799f, -0.13439673f, 0.27335200f, -0.38181996f, 0.00706098f, 0.01655764f, -0.09865198f, -0.02271397f, 
    0.06821810f, -0.07077624f, 0.09070055f, -0.00503804f, -0.14307539f, -0.04226304f, -0.02718133f, -0.40000427f, 
    0.10031917f, 0.01161393f, -0.04103064f, -0.04630431f, 0.07572082f, 0.09825651f, -0.10952532f, 0.04823045f, 
    -0.52641058f, -0.13768335f, -0.09937571f, 0.00818285f, -0.23707528f, -0.06609622f, 0.11090803f, -0.08966400f, 
    0.00384070f, -0.04833586f, -0.01461827f, -0.00627471f, -0.07277047f, -0.06054865f, 0.07673611f, 0.17714484f, 
    -0.04212072f, 0.02996256f, 0.01197469f, 0.04694097f, -0.00954161f, 0.00968385f, 0.02019993f, 0.00429608f, 
    -0.21332319f, 0.13527973f, -0.02428715f, 0.10545750f, 0.05686549f, 0.13660987f, -0.12842703f, -0.04626609f, 
    0.01194085f, -0.05976092f, 0.05349594f, -0.23948695f, -0.14530051f, 0.00212828f, -0.08565412f, 0.02158980f, 
    -0.01209337f, -0.17639560f, -0.06834681f, 0.10978384f, 0.00011496f, -0.06520059f, 0.00858734f, -0.00831239f, 
    0.07921172f, 0.03727097f, -0.23579830f, 0.10519648f, 0.03960262f, 0.08283471f, -0.00738980f, -0.14456786f, 
    -0.09165864f, -0.08281769f, -0.09878116f, 0.00086516f, -0.09423941f, 0.01642127f, 0.48632362f, 0.10492080f, 
    0.00459664f, -0.02309407f, -0.01153709f, 0.12654251f, -0.02979835f, -0.03028293f, 0.07947371f, -0.13628477f, 
    0.02542375f, -0.13164420f, -0.03305167f, -0.42821929f, 0.08303194f, 0.02903217f, 0.08590724f, -0.01828506f, 
    0.02234860f, 0.01255108f, -0.02357505f, 0.03647598f, -0.00399608f, -0.07422438f, 0.10972049f, -0.12402090f, 
    0.02800029f, -0.06637848f, 0.01856084f, -0.06051824f, -0.03923370f, -0.12829320f, 0.03492939f, -0.25994110f, 
    0.05666847f, -0.20333928f, 0.22716618f, 0.15513310f, 0.18178688f, -0.10869139f, -0.00680325f, 0.02024340f, 
    0.10338085f, -0.01631957f, 0.03514405f, 0.13504244f, -0.04483531f, -0.05896777f, -0.61380386f, 0.22052057f, 
    0.12336427f, 0.00417117f, -0.08313310f, 0.15833142f, 0.01930991f, 0.01143958f, -0.03653783f, 0.07950057f, 
    -0.00962883f, 0.01998684f, -0.08381306f, 0.14601786f, 0.16488715f, -0.11603070f, 0.03802062f, 0.09834375f, 
    0.06683778f, 0.02382237f, 0.09075736f, -0.02124361f, -0.03725414f, -0.06372017f, 0.12140817f, -0.10239884f, 
    -0.01515531f, 0.00826654f, 0.06032539f, -0.09704337f, 0.03220644f, -0.12359279f, 0.23924115f, -0.01823122f, 
    -0.22173718f, 0.16445822f, 0.24819399f, -0.08340374f, 0.07264415f, -0.08173436f, -0.02411913f, -0.02666773f, 
    0.05423414f, 0.04220647f, -0.05093113f, -0.01781983f, 0.05698312f, 0.11700315f, 0.02501793f, 0.09958927f, 
    -0.00871373f, 0.00941553f, 0.01441517f, -0.02302468f, 0.07709849f, 0.12865092f, 0.06163751f, 0.09308315f, 
    0.03762990f, -0.06626177f, 0.04633868f, -0.06592988f, -0.01711098f, 0.03861924f, 0.01895078f, 0.00144948f, 
    0.00172088f, -0.04592875f, 0.02183655f, 0.14153397f, -0.07574238f, -0.13035838f, -0.04796864f, 0.01532843f, 
    0.00237909f, 0.04185157f, 0.04931805f, 0.03828062f, -0.14307833f, -0.09184846f, -0.11660022f, 0.07787044f, 
    -0.01031838f, -0.04820131f, 0.05420367f, -0.09053375f, 0.04045692f, -0.00785319f, 0.00535287f, 0.01045440f, 
    -0.06688164f, -0.04421187f, -0.03756975f, 0.06823990f, 0.17698449f, 0.33111808f, 0.13944958f, 0.21374741f, 
    -0.02402736f, -0.00022501f, 0.06985203f, -0.11693797f, 0.05396263f, -0.01985446f, 0.07357257f, 0.06473443f, 
    0.01521743f, -0.00023772f, 0.04296855f, -0.02211618f, -0.08000368f, -0.15168087f, -0.04417709f, 0.10964541f, 
    -0.07660241f, -0.01687303f, -0.03526299f, -0.04879598f, 0.09066759f, 0.07178738f, -0.07614657f, -0.28072560f, 
    -0.03051809f, -0.02512113f, -0.04569755f, 0.08078708f, -0.03488367f, 0.01445247f, -0.03866224f, 0.01044471f, 
    -0.17684834f, 0.43681675f, 0.49651816f, 0.16072252f, -0.06298240f, 0.02603755f, -0.03339109f, -0.07276230f, 
    0.01649674f, 0.03088079f, 0.08431419f, 0.04882514f, -0.05963232f, -0.05343881f, -0.11689848f, -0.06425989f, 
    0.04298380f, -0.04332904f, -0.04076531f, -0.03327748f, 0.08949722f, 0.10465872f, 0.04206809f, 0.08305534f, 
    -0.16161947f, -0.09600186f, 0.04080500f, -0.10157699f, 0.04921380f, 0.01101928f, 0.03697416f, 0.11162584f, 
    -0.06339888f, -0.02868642f, -0.02524457f, 0.05547845f, -0.22022727f, -0.13359770f, 0.02876653f, 0.14332056f, 
    0.02523920f, 0.06079814f, 0.07943538f, -0.13479492f, 0.17426476f, 0.01847041f, -0.00041629f, 0.04098458f, 
    -0.24901119f, -0.02929809f, -0.11710348f, -0.11304095f, -0.07666510f, -0.01162954f, 0.02541423f, 0.00040605f, 
    0.00855942f, -0.00316875f, 0.00516132f, -0.00609975f, -0.21562296f, 0.45699614f, -0.30363569f, 0.05958399f, 
    0.06572957f, -0.01201688f, -0.02077227f, 0.14741015f, -0.09809599f, 0.03232905f, -0.00880935f, -0.03486509f, 
    -0.04463158f, -0.25831375f, 0.01866640f, 0.19523877f, 0.00933912f, 0.02564659f, 0.05119063f, -0.04090854f, 
    -0.00204512f, -0.16286527f, -0.19626573f, 0.08049379f, 0.03272023f, 0.10880381f, 0.03642508f, 0.13839896f, 
    -0.09154218f, -0.00661274f, 0.00844370f, -0.03495475f, -0.10047644f, 0.05574188f, 0.00203051f, 0.03070432f, 
    -0.58485383f, -0.24533148f, -0.02528493f, -0.25922659f, 0.10723504f, 0.09202050f, -0.24548338f, -0.07504869f, 
    0.05290867f, -0.04020186f, 0.03612969f, -0.07136470f, 0.37601179f, -0.11593680f, -0.20155513f, 0.25850156f, 
    -0.02176297f, 0.18242632f, -0.28769279f, -0.05252127f, -0.09022013f, 0.03945563f, 0.07094561f, 0.04651086f, 
    0.05212374f, 0.20078224f, 0.52543080f, 0.10084329f, -0.08045042f, 0.00933562f, 0.07861923f, -0.03878472f, 
    0.02907707f, 0.04893940f, -0.11252698f, 0.06043363f, -0.05794472f, -0.06291769f, -0.07758634f, 0.02500536f, 
    0.02840570f, 0.06023839f, -0.09015600f, 0.00371116f, 0.04341031f, 0.05975073f, -0.06821274f, -0.01286052f, 
    -0.23245075f, 0.01044512f, -0.02577321f, 0.06118938f, -0.05724661f, 0.01990187f, 0.01752989f, 0.00677947f, 
    0.00630525f, -0.07660290f, 0.01237097f, -0.02378684f, -0.24837554f, -0.01817039f, 0.10037273f, -0.10655224f, 
    -0.01505457f, 0.02241697f, -0.05982845f, -0.06435186f, -0.04464062f, -0.07805328f, 0.07507609f, -0.01566632f, 
    -0.45077130f, -0.07445978f, -0.03271806f, -0.38206634f, 0.03980394f, -0.15907398f, -0.27010402f, 0.11985838f, 
    0.03764950f, 0.00455848f, -0.11891145f, 0.02867946f, 0.03809091f, 0.03239113f, -0.05981900f, -0.01646548f, 
    0.19146125f, -0.05051978f, -0.17796832f, 0.10450423f, -0.03236396f, -0.11721236f, -0.09042398f, -0.07851063f, 
    -0.43810782f, 0.14923576f, 0.08952998f, -0.23146312f, -0.01139187f, 0.01515813f, -0.03530326f, 0.00213765f, 
    0.03140491f, 0.00463250f, -0.03879873f, 0.06912345f, -0.41614816f, 0.10949264f, 0.05931336f, -0.03932234f, 
    -0.01846960f, -0.07357867f, 0.02250342f, -0.07747891f, -0.01365844f, 0.06819259f, -0.04725045f, -0.01360538f, 
    -0.46465325f, 0.44009781f, -0.03244505f, -0.00022583f, 0.03528680f, 0.01771155f, -0.00612388f, -0.15793398f, 
    0.08869393f, 0.09044519f, -0.12267246f, 0.16972381f, -0.07574876f, 0.17211661f, 0.20491070f, 0.01061827f, 
    -0.02571300f, 0.00151184f, 0.08943618f, -0.19964264f, -0.01938302f, 0.00918706f, -0.04684637f, 0.20405807f, 
    -0.13417858f, 0.02543000f, -0.03078631f, -0.02187816f, -0.00266109f, -0.05477104f, 0.01964008f, 0.03173574f, 
    -0.01079156f, 0.01018668f, 0.07996812f, 0.01157867f, -0.08653679f, -0.09593022f, -0.03742889f, 0.09513887f, 
    0.02496937f, 0.03074429f, 0.04199078f, 0.05411691f, -0.02258000f, 0.00950236f, 0.06930097f, -0.02917883f, 
    0.13187301f, 0.10246014f, -0.09865911f, 0.25820756f, -0.04098640f, -0.08046329f, 0.09348572f, -0.11671496f, 
    -0.06930981f, 0.00107488f, 0.03069898f, 0.04269726f, -0.31825647f, -0.17711303f, -0.04524541f, 0.25021195f, 
    -0.04948255f, -0.00593033f, -0.07952974f, -0.04480069f, 0.03226467f, -0.00213787f, 0.05117821f, 0.05528953f, 
    0.01751291f, -0.12596886f, 0.19027956f, -0.19745183f, 0.00623285f, 0.07409779f, -0.10328482f, -0.01732964f, 
    0.07856720f, -0.11934068f, 0.10499537f, -0.01116286f, 0.01662488f, 0.04732663f, -0.26638055f, -0.15626234f, 
    0.04630236f, 0.06500245f, -0.12294310f, -0.03342228f, 0.14879827f, -0.05803738f, -0.02490322f, 0.08142552f, 
    -0.77466148f, -0.61541522f, -0.48004183f, -0.32225975f, -0.04330743f, -0.06556119f, -0.01566204f, -0.19741149f, 
    -0.00834755f, 0.00590875f, -0.00378437f, -0.01979643f, 0.22182995f, 0.02949892f, -0.07237183f, 0.02437240f, 
    -0.01478607f, -0.02707530f, 0.16369985f, -0.20021854f, 0.07367115f, 0.06781577f, -0.00764235f, 0.01826319f, 
    0.02223758f, -0.16322802f, 0.00249507f, 0.01494416f, 0.14031705f, -0.00057465f, -0.06929373f, -0.01445131f, 
    -0.08783917f, -0.21374150f, 0.06788132f, -0.08542833f, -0.09917276f, 0.22986397f, 0.12577023f, 0.12460837f, 
    0.02168545f, 0.02779068f, 0.01606835f, 0.01828305f, -0.01981749f, -0.02747056f, -0.12987709f, 0.12771441f, 
    0.26949656f, -0.13074566f, -0.07749004f, 0.19802471f, 0.14998475f, -0.09324124f, 0.00568229f, 0.05722027f, 
    -0.04121007f, 0.08386267f, -0.01868656f, -0.02576028f, -0.42953169f, 0.23370281f, 0.18940036f, -0.11656924f, 
    -0.01230596f, 0.00476171f, 0.07731015f, -0.07831797f, 0.03768517f, 0.00426368f, -0.13471846f, 0.12932284f, 
    -0.53198969f, 0.19410023f, -0.29100642f, -0.35184550f, 0.00653250f, 0.03909989f, -0.19267644f, -0.15321261f, 
    0.02913564f, 0.02034114f, 0.00251467f, -0.07918113f, 0.07171504f, -0.02391541f, 0.19422263f, 0.26156414f, 
    0.05190701f, 0.13086678f, 0.09152354f, 0.05507941f, -0.00259112f, 0.02351505f, 0.06375665f, 0.09030803f, 
    -0.03843449f, 0.04982279f, -0.12484382f, 0.00868317f, 0.09054899f, -0.07259268f, 0.12096474f, 0.03272029f, 
    0.04936696f, 0.14330810f, -0.03153251f, 0.00355427f, 0.27294648f, 0.08913111f, -0.04084367f, -0.03922636f, 
    0.10077567f, 0.04961452f, 0.01782900f, 0.06063016f, 0.03285640f, -0.05328304f, 0.01049296f, -0.01351884f, 
    0.01605204f, -0.02822634f, 0.20876914f, -0.13656323f, -0.00153302f, -0.05904338f, 0.03911187f, 0.11331485f, 
    -0.05147563f, 0.03540518f, 0.03092782f, -0.16899489f, -0.17349905f, -0.07779764f, 0.06001737f, -0.57877159f, 
    -0.03959041f, -0.04425982f, -0.03014988f, -0.10931414f, -0.00199043f, 0.01699409f, -0.11085846f, 0.08930154f, 
    0.03486764f, -0.04076810f, -0.27669421f, 0.01932014f, 0.10375866f, -0.10080784f, -0.07703424f, -0.10159279f, 
    -0.09801841f, 0.13790138f, -0.04836943f, 0.02227270f, -0.14637974f, 0.61360604f, -0.23492639f, 0.12346375f, 
    -0.00315431f, 0.15646631f, -0.01305872f, -0.06733536f, -0.00327551f, 0.04022472f, 0.12749696f, -0.01065423f, 
    -0.14506732f, 0.11068653f, -0.27893546f, 0.31576118f, -0.05016392f, -0.20069703f, -0.17327194f, -0.03897012f, 
    -0.02420398f, -0.01698814f, 0.03805488f, -0.01455794f, 0.19827066f, -0.14441068f, 0.07259867f, 0.23068817f, 
    0.07112472f, -0.01395323f, -0.02735201f, -0.02396749f, -0.02652575f, 0.13186562f, 0.12180883f, 0.12064710f, 
    -0.15833244f, 0.01539145f, 0.34093866f, 0.16752012f, -0.12395188f, 0.11312231f, -0.06193656f, 0.04169453f, 
    0.09767711f, 0.16779172f, 0.14847115f, 0.08803647f, -0.15521550f, 0.31464458f, 0.03256201f, 0.31100333f, 
    -0.04791712f, -0.08298901f, 0.04983253f, -0.01496464f, -0.02270827f, 0.03121444f, -0.14123601f, -0.01029572f, 
    -0.03644013f, -0.12410221f, -0.05565837f, 0.22218394f, -0.05426246f, -0.03657169f, -0.01998599f, -0.03225008f, 
    -0.03209421f, 0.10603290f, -0.06777839f, 0.04631303f, -0.10625844f, -0.09035946f, -0.08906417f, 0.14271255f, 
    0.03233046f, -0.02711242f, -0.00357467f, -0.02041266f, -0.05402046f, 0.02645513f, -0.02008585f, 0.07093056f, 
    -0.03780331f, 0.05410346f, -0.15041105f, -0.03671757f, 0.15342225f, 0.14678575f, 0.06122578f, -0.03889749f, 
    0.04363659f, 0.00116926f, 0.11592427f, 0.04466754f, -0.32490876f, -0.06463055f, -0.27474234f, 0.08788755f, 
    -0.09068041f, 0.01117641f, -0.06542736f, -0.04976899f, 0.00910031f, 0.00838094f, -0.12634802f, 0.18471318f, 
    0.21701631f, 0.00651171f, -0.01032882f, 0.13553794f, 0.01406896f, -0.00398390f, 0.00458784f, -0.02160579f, 
    -0.08901784f, 0.01415505f, 0.05888032f, -0.00635778f, -0.28534001f, 0.37158364f, -0.15112500f, -0.09481400f, 
    0.18517072f, 0.12954108f, 0.00439787f, -0.01907516f, -0.33768997f, -0.03940041f, 0.00940426f, -0.05625633f, 
    0.18417825f, 0.01702910f, 0.16351332f, 0.04575086f, -0.02280930f, 0.03257909f, -0.19823827f, -0.04362410f, 
    0.03128712f, -0.02928234f, 0.11100642f, -0.03992512f, 0.32455447f, -0.27817091f, -0.11404405f, 0.14955260f, 
    -0.00663556f, 0.03481863f, 0.09367768f, 0.01942506f, 0.01505353f, -0.14606316f, 0.10555512f, 0.04818583f, 
    0.24424218f, 0.04770958f, -0.08378287f, 0.09223274f, 0.12687044f, 0.05419016f, -0.11213867f, -0.02352264f, 
    -0.14758565f, -0.08501178f, 0.03523183f, 0.05482551f, 0.08032885f, -0.12127715f, -0.16059422f, -0.23627366f, 
    0.06096974f, -0.13930990f, -0.03987734f, 0.05823763f, -0.03644283f, 0.03017905f, -0.06231283f, -0.00189383f, 
    -0.28109697f, 0.53128964f, -0.37406999f, -0.49952772f, 0.06079997f, 0.19762196f, -0.10279683f, -0.01705908f, 
    -0.20750099f, -0.05030242f, 0.03677402f, 0.13941024f, -0.18339293f, -0.04964858f, 0.01229160f, 0.20980032f, 
    -0.14775722f, -0.07047716f, 0.02804032f, -0.15528275f, -0.05124006f, 0.09389190f, -0.00017981f, -0.23457289f, 
    -0.06204649f, 0.14782858f, -0.12431838f, 0.29039216f, 0.03312264f, -0.00175871f, 0.07555955f, 0.00352752f, 
    -0.10050012f, -0.04903306f, -0.05467624f, 0.04097422f, -0.01634769f, -0.05716387f, -0.01693731f, 0.16199282f, 
    0.00334902f, 0.05617883f, 0.07035466f, -0.02832583f, -0.03898387f, 0.01359063f, -0.02957658f, 0.05766237f, 
    0.08000068f, -0.04656964f, -0.09211164f, -0.04868939f, -0.21840891f, -0.00193883f, -0.22177981f, 0.00029083f, 
    -0.10269338f, -0.07438320f, 0.06911092f, 0.03411578f, -0.49301857f, -0.26184517f, -0.25180933f, -0.28027791f, 
    0.26696563f, 0.11585002f, 0.02469803f, 0.00900152f, -0.17850617f, -0.14825851f, -0.03807756f, -0.10464794f, 
    -0.16602680f, -0.07039183f, -0.03230606f, -0.17422706f, -0.26035362f, -0.00185158f, 0.05995341f, -0.00451343f, 
    0.03407760f, -0.01725009f, 0.14091557f, -0.12302186f, 0.51675236f, -0.13651149f, 0.13824034f, 0.14617532f, 
    0.13847326f, 0.06815295f, -0.08026996f, -0.05756348f, -0.11614603f, 0.05991985f, -0.06226182f, 0.02387431f, 
    0.01859717f, 0.08839511f, -0.11228105f, 0.05406392f, 0.13898468f, -0.09838048f, -0.07445160f, -0.02229058f, 
    0.02950315f, -0.02454009f, 0.02187795f, 0.04060966f, -0.50041759f, 0.06759518f, -0.11625832f, 0.14675525f, 
    0.15586381f, -0.12254661f, -0.07022081f, -0.07651179f, -0.00387329f, 0.07548639f, 0.07701965f, -0.10737652f, 
    -0.28603828f, 0.06366995f, 0.02107225f, 0.18802233f, 0.17213671f, 0.03872775f, -0.03447648f, 0.01511390f, 
    0.02054617f, 0.01472728f, -0.00587263f, -0.01311673f, -0.23949598f, -0.07289764f, -0.15916950f, -0.03372044f, 
    -0.02378685f, 0.15924320f, -0.06986453f, 0.09251259f, 0.06257931f, 0.13239665f, 0.05540567f, -0.03393632f, 
    0.12926894f, 0.08711065f, 0.14774984f, -0.36512205f, -0.12368701f, -0.21571116f, -0.09314334f, 0.05016219f, 
    -0.00425227f, -0.00866961f, -0.01916974f, -0.03780401f, 0.01811182f, -0.07866316f, -0.09101058f, 0.16033687f, 
    -0.03039272f, 0.04235320f, -0.04172549f, 0.08844940f, 0.09760604f, 0.13139386f, 0.10975032f, 0.04537738f, 
    -0.02367652f, -0.14764757f, -0.07917358f, 0.03204535f, -0.03961348f, 0.01235928f, -0.15013009f, 0.01139712f, 
    0.04962460f, 0.00323345f, -0.08705296f, -0.11073006f, -0.23387192f, 0.36039168f, -0.16169925f, 0.13644546f, 
    0.05414578f, 0.15039609f, -0.10620036f, 0.01852654f, -0.06699435f, 0.00840843f, 0.04916164f, 0.08862710f, 
    0.01218502f, 0.20766850f, -0.13642074f, -0.39974585f, 0.13529254f, 0.08669850f, -0.01400610f, 0.06247019f, 
    -0.17839450f, 0.04782592f, -0.24417038f, 0.11329601f, -0.05036389f, -0.13510202f, -0.16067618f, 0.14008977f, 
    0.04910322f, 0.03269379f, -0.00266378f, -0.00659484f, -0.01741988f, -0.04861628f, 0.06326446f, -0.05760100f, 
    0.00775271f, -0.09228397f, 0.04760942f, 0.12597649f, -0.10222508f, -0.00220268f, -0.04420241f, 0.12131899f, 
    -0.04177656f, -0.11182814f, 0.01521691f, -0.08639377f, 0.69454843f, 0.08695941f, 0.00848749f, -0.26204634f, 
    0.14232615f, 0.01799318f, -0.10071106f, -0.20090939f, -0.09531670f, -0.11440193f, 0.05118692f, -0.02655130f, 
    -0.01297994f, -0.07224475f, 0.00252859f, 0.20265438f, 0.12299282f, 0.01458838f, 0.02658230f, -0.08066892f, 
    -0.09330139f, 0.07656738f, 0.00104024f, 0.09230059f, -0.04941804f, 0.56035352f, -0.25788170f, 0.33649236f, 
    0.07232796f, 0.02386627f, 0.06381446f, 0.00470110f, 0.02921599f, 0.09405370f, -0.06484863f, 0.02782369f, 
    -0.25833485f, 0.39642596f, -0.16309486f, 0.15959378f, -0.14203340f, -0.20276824f, 0.06826679f, -0.12773317f, 
    0.07299438f, 0.08550571f, -0.00925998f, -0.02697353f, -0.08522663f, -0.05357135f, 0.05544907f, 0.25741890f, 
    0.03892156f, -0.07984967f, -0.02789742f, -0.03131946f, 0.05541192f, -0.09639724f, 0.10980853f, 0.04771688f, 
    -0.14494191f, 0.10783063f, 0.22354639f, 0.28552401f, 0.08553557f, -0.06703327f, 0.04798191f, 0.13807370f, 
    -0.00560153f, -0.00551155f, -0.00425324f, 0.01871318f, 0.21499480f, -0.06105235f, 0.04740549f, 0.14612691f, 
    0.03157856f, -0.01832287f, -0.17723423f, -0.05723641f, 0.03936563f, 0.11037711f, -0.13223313f, 0.02655978f, 
    -0.42259404f, -0.22201364f, 0.01347779f, -0.21284769f, -0.16421139f, 0.02688095f, -0.09488139f, -0.26776639f, 
    -0.12649828f, 0.11706050f, -0.09351095f, 0.03242746f, 0.00415506f, -0.08910611f, 0.00008178f, 0.08593830f, 
    -0.01445501f, -0.01686996f, 0.05475882f, 0.02556995f, -0.04754070f, -0.02803450f, 0.00380564f, -0.06695248f, 
    -0.65282178f, -0.08824031f, -0.12775186f, -0.15931565f, 0.01552996f, 0.02968062f, -0.21622093f, -0.25844574f, 
    -0.14803803f, -0.04015009f, -0.10798022f, 0.04237087f, -0.62891400f, -0.21455719f, 0.15161288f, 0.16158687f, 
    -0.05275202f, -0.06244804f, -0.00911772f, -0.04480952f, -0.00006996f, -0.04035152f, -0.00642150f, -0.04144357f, 
    -0.22229493f, -0.04020564f, -0.03607765f, -0.20075354f, -0.20803905f, -0.14677340f, -0.23506965f, -0.01195547f, 
    0.02943670f, 0.00028626f, -0.02376398f, -0.12061294f, 0.12447383f, -0.04105502f, 0.00117477f, -0.46771130f, 
    -0.05544108f, -0.17147832f, -0.16761024f, 0.03854450f, -0.03040785f, 0.02347464f, -0.03558790f, -0.07975255f, 
    0.68766510f, -0.29758146f, -0.08314525f, 0.02053087f, 0.13284574f, -0.01779078f, 0.01032343f, -0.05194370f, 
    -0.03382346f, 0.05130351f, 0.20771040f, 0.12168724f, -0.11880658f, 0.11739597f, -0.13457584f, 0.02005797f, 
    -0.12443827f, -0.21867034f, 0.03596303f, 0.02600901f, -0.13480237f, 0.20504978f, -0.16412273f, -0.02954390f, 
    -0.16772941f, -0.14185189f, 0.10330240f, 0.10864472f, -0.14122930f, -0.01110466f, -0.21473581f, -0.06192041f, 
    -0.01775069f, 0.05923407f, 0.02693702f, 0.06916519f, 0.10696141f, -0.02996959f, 0.10879932f, 0.12987709f, 
    0.01278954f, 0.01704786f, -0.01013238f, 0.08234774f, 0.00233322f, 0.11646957f, 0.00646052f, -0.01092016f, 
    -0.04613962f, -0.18649384f, -0.02457980f, 0.10425960f, 0.08145447f, 0.13892299f, 0.06291373f, 0.04374675f, 
    0.06670044f, -0.07050165f, 0.09305810f, -0.05654987f, 0.56533164f, -0.03329151f, 0.00503419f, 0.04344022f, 
    0.09642307f, 0.02014639f, -0.13130370f, -0.02316867f, -0.11143352f, -0.02272235f, 0.01484411f, 0.03912646f, 
    0.07399584f, -0.02172613f, -0.19840866f, 0.02675508f, -0.01692498f, -0.08236958f, -0.03656041f, -0.08279172f, 
    0.02849478f, -0.08391453f, 0.12061214f, -0.04344139f, 0.14335316f, -0.23242123f, -0.06062022f, -0.03367466f, 
    0.24318138f, 0.01299027f, 0.07476235f, 0.04606325f, -0.03296178f, 0.02884310f, -0.00849897f, -0.04633017f, 
    0.18199013f, 0.09481809f, 0.30491841f, -0.13570234f, -0.23703739f, 0.07215156f, -0.15720969f, -0.01585113f, 
    -0.04944595f, -0.02231835f, 0.01132364f, -0.17506623f, -0.01598312f, -0.00535622f, 0.13340148f, 0.08021670f, 
    -0.11491695f, -0.02085984f, -0.08217598f, -0.10713620f, -0.01704993f, 0.07701988f, -0.04429854f, 0.01150972f, 
    -0.23960157f, 0.24050298f, 0.02545059f, 0.46566114f, 0.10432164f, 0.05466296f, -0.14231218f, 0.03813563f, 
    0.07554147f, -0.01722099f, -0.06308272f, 0.07758548f, -0.03923804f, -0.11211816f, -0.01217374f, 0.09257616f, 
    -0.06025165f, -0.07486963f, -0.04208988f, -0.11232802f, -0.01083343f, 0.02034223f, -0.00193370f, 0.05879814f, 
    -0.07840192f, -0.03855370f, -0.08419068f, 0.01289691f, 0.10120860f, -0.03047286f, -0.13216144f, 0.10436399f, 
    0.05799683f, -0.25156626f, -0.00014488f, -0.03158387f, 0.19724533f, 0.09672794f, -0.08113418f, -0.02516423f, 
    -0.06725487f, -0.02193553f, 0.00683127f, -0.10199146f, -0.06832186f, 0.17094566f, -0.14554210f, 0.00719083f, 
    -0.50533825f, 0.50205505f, -0.06861670f, -0.14696600f, 0.09807707f, -0.15739532f, -0.08100412f, 0.00191786f, 
    -0.19386999f, -0.03542484f, 0.00221752f, -0.07106205f, -0.07882021f, -0.08844443f, 0.42241859f, 0.27371904f, 
    -0.03206757f, -0.01015482f, 0.10107586f, 0.07107711f, 0.05332090f, -0.04156425f, -0.12014850f, 0.07466879f, 
    -0.11065729f, -0.17955826f, 0.06035945f, 0.17422803f, -0.13924767f, 0.04521799f, -0.14220974f, -0.21484445f, 
    0.06555863f, 0.01482951f, 0.09585921f, -0.05731768f, -0.12988257f, -0.25662744f, 0.02454584f, -0.09918232f, 
    0.02642078f, 0.01520867f, 0.03183043f, 0.02352470f, 0.02383011f, -0.02699202f, -0.09098017f, 0.12127897f, 
    0.01672019f, -0.00548203f, -0.01693682f, 0.03412799f, 0.07615449f, 0.06561308f, -0.00153300f, -0.03649793f, 
    -0.12148728f, -0.14453952f, 0.04190256f, -0.10119167f, -0.12645155f, -0.06990410f, 0.07193134f, 0.15338109f, 
    -0.04748025f, -0.03423156f, 0.01294992f, -0.02566541f, 0.04516582f, -0.03619402f, 0.09009010f, 0.02017932f, 
    0.15446861f, 0.19577910f, -0.06957370f, 0.22601743f, 0.12460260f, -0.22428901f, -0.00973681f, -0.16488005f, 
    0.06986317f, -0.08508708f, 0.01068110f, 0.01083602f, 0.06956215f, 0.12089288f, -0.01509395f, 0.02179272f, 
    0.14609271f, 0.13058773f, 0.03379930f, -0.05095308f, -0.01340842f, -0.00218711f, -0.01072936f, 0.00662178f, 
    -0.06698425f, 0.02871148f, 0.12487572f, 0.04735041f, -0.03116192f, -0.08953477f, 0.04440073f, -0.03369019f, 
    0.06172138f, 0.00670550f, 0.01564110f, 0.02723504f, 0.06930868f, 0.12509127f, 0.11635329f, 0.17946211f, 
    -0.09443539f, -0.01991799f, -0.06037139f, -0.05638060f, -0.02178273f, 0.08311988f, -0.01501824f, 0.08738870f, 
    -0.03421685f, 0.06990287f, 0.04192844f, -0.00126265f, -0.16421050f, -0.03850385f, -0.01629615f, 0.11035058f, 
    0.08110340f, -0.04900963f, -0.20513371f, -0.07631008f, 0.04458872f, -0.03179267f, 0.10962236f, 0.06195889f, 
    0.11851265f, -0.08660825f, -0.01778478f, 0.09810681f, 0.04758836f, -0.00740941f, 0.00080613f, 0.08164547f, 
    0.04840799f, 0.07864812f, 0.05827777f, 0.06921685f, -0.12990798f, -0.02793349f, -0.04812928f, 0.02982438f, 
    0.01483890f, -0.01134910f, -0.02422550f, -0.02338442f, 0.02696508f, -0.33971485f, 0.01211424f, 0.05382188f, 
    -0.12878269f, 0.00151851f, 0.01090963f, -0.08895309f, -0.02271626f, 0.04371837f, -0.03349004f, 0.03695033f, 
    0.12358791f, 0.05086011f, -0.05575624f, 0.20035844f, 0.19215176f, 0.08169180f, 0.02388432f, -0.04171932f, 
    0.00810140f, -0.11453413f, -0.02694598f, -0.12215751f, -0.46039551f, 0.17080776f, -0.08613860f, -0.10775301f, 
    0.06639292f, 0.10835725f, -0.09503770f, 0.05917886f, -0.09767447f, -0.02262199f, 0.00920234f, -0.12285532f, 
    0.09567734f, -0.15782781f, -0.07248324f, -0.04559484f, -0.05902112f, -0.16890919f, -0.01197298f, -0.06632632f, 
    0.12480545f, 0.00063558f, 0.10501608f, -0.12357216f, 0.16350460f, 0.10184397f, 0.04911930f, 0.11521944f, 
    -0.04120491f, -0.08560804f, -0.16290694f, -0.15234001f, 0.00374643f, 0.02155028f, -0.00069510f, -0.06901743f, 
    0.02553308f, -0.59700608f, 0.37137797f, 0.11992028f, 0.02389929f, 0.16580792f, -0.13957098f, -0.01559865f, 
    -0.13257635f, 0.12755571f, -0.13034068f, 0.04473541f, -0.11936741f, 0.05459180f, 0.07432237f, 0.03193528f, 
    -0.19179085f, -0.03485458f, -0.18400529f, 0.08445635f, 0.02170786f, 0.10401346f, -0.13542482f, -0.16291058f, 
    -0.30088699f, 0.14478923f, -0.05705543f, -0.14150307f, 0.20373157f, 0.03082042f, -0.10491622f, 0.00355448f, 
    -0.06590183f, 0.14731848f, 0.12053388f, 0.15233973f, -0.02644302f, 0.12308564f, 0.03176923f, -0.03463264f, 
    0.00345588f, -0.10067697f, -0.03897855f, 0.00162527f, 0.17554757f, 0.10495938f, 0.01888216f, 0.23779476f, 
    -0.35872555f, -0.16310027f, -0.32686761f, -0.18355531f, 0.04704752f, 0.01881332f, -0.00567955f, -0.04292598f, 
    0.03008026f, -0.04955102f, 0.02221150f, 0.01586241f, 0.13861714f, 0.05054381f, -0.04035379f, 0.00614545f, 
    0.07349158f, 0.07084783f, 0.08638521f, 0.12721244f, 0.05582667f, -0.06011174f, -0.07742069f, -0.16514105f, 
    0.04488732f, -0.02001730f, -0.12105613f, 0.07491130f, 0.03572150f, -0.06846888f, 0.04525850f, -0.02895328f, 
    0.16479471f, 0.03944956f, -0.05405210f, 0.09071812f, -0.00658608f, 0.04678294f, 0.07997612f, 0.02409123f, 
    -0.03189616f, -0.10052846f, 0.07886646f, 0.07341474f, 0.01179024f, -0.14392602f, 0.04048896f, -0.01831354f, 
    0.00537352f, 0.08569846f, -0.04311405f, 0.05128850f, -0.06257174f, 0.11646794f, 0.00062909f, -0.01452848f, 
    0.09278312f, 0.02310687f, -0.03693220f, -0.05757969f, 0.03523791f, 0.05943947f, -0.42355949f, -0.21124171f, 
    0.07333330f, 0.08404379f, -0.09165313f, -0.00794615f, 0.03418048f, -0.06272855f, -0.07859538f, -0.04218971f, 
    -0.02967589f, 0.07563539f, 0.24833736f, 0.03093466f, -0.04006014f, -0.09337669f, -0.00881353f, -0.07273738f, 
    -0.06641386f, -0.05181009f, -0.01311143f, 0.03500958f, 0.05091529f, -0.01638347f, -0.07948112f, -0.10422529f, 
    0.06110125f, 0.02306173f, -0.00904736f, 0.05441472f, 0.19150117f, -0.01116398f, 0.19847324f, 0.29002392f, 
    0.25488114f, -0.26075965f, -0.48015183f, 0.07725766f, -0.03529540f, 0.09344273f, -0.02103321f, 0.12642817f, 
    0.16004814f, -0.01736677f, 0.06604323f, -0.07406840f, 0.01876630f, 0.12192092f, 0.07449038f, 0.16911297f, 
    0.03450930f, 0.16512114f, -0.10752447f, -0.00343515f, 0.01819013f, 0.04434639f, 0.09196303f, 0.16009098f, 
    0.01927630f, 0.01669235f, 0.20411165f, 0.07693257f, -0.15363957f, -0.08432358f, 0.00672943f, -0.01732947f, 
    0.05560302f, 0.00503110f, 0.06341983f, 0.01261990f, -0.04494087f, -0.14641291f, 0.25122342f, 0.22744687f, 
    0.03980117f, -0.07965832f, 0.00515173f, -0.13351952f, -0.14346369f, -0.05455381f, 0.00252064f, -0.00827955f, 
    0.16802008f, -0.14605629f, -0.08118389f, -0.01090147f, -0.06740811f, 0.02067105f, 0.01969557f, 0.01539818f, 
    0.16931690f, -0.06088396f, -0.03240628f, -0.19458091f, 0.09606856f, 0.02289021f, 0.14424971f, 0.17456621f, 
    -0.09514809f, -0.11234304f, -0.04044764f, 0.03970264f, 0.11705034f, 0.07523980f, -0.08580500f, 0.02143937f, 
    -0.07812691f, 0.13662963f, 0.15830228f, 0.05778066f, 0.00729442f, -0.00689648f, 0.09666849f, 0.06021128f, 
    -0.08802460f, -0.04340458f, -0.05927900f, -0.03230512f, -0.46065396f, -0.21701042f, -0.25040686f, 0.06540934f, 
    -0.20655613f, -0.13532354f, 0.19812308f, -0.20007692f, -0.13855293f, -0.03006289f, 0.00041379f, 0.00705712f, 
    -0.11332294f, -0.09329926f, 0.07154983f, 0.10630099f, -0.08370803f, -0.13928008f, 0.03722347f, -0.04839216f, 
    -0.12765664f, 0.02478776f, 0.02908439f, 0.12223789f, 0.05868588f, -0.20010586f, 0.22085685f, 0.13034812f, 
    -0.12667081f, 0.06551672f, -0.17804225f, 0.07498144f, -0.17012182f, 0.02641051f, 0.02353975f, -0.00196426f, 
    0.16371876f, -0.03966284f, 0.18271780f, 0.05784026f, -0.01992622f, 0.08588628f, 0.00502853f, -0.01761367f, 
    0.07336500f, -0.02370862f, -0.01853887f, 0.02754335f, 0.02338843f, 0.10230386f, 0.16144647f, 0.16960561f, 
    -0.02415174f, 0.02021478f, -0.04761817f, 0.00434484f, 0.03134503f, 0.08973490f, 0.00325517f, 0.12425411f, 
    -0.08936774f, 0.08600644f, -0.02860573f, -0.02989082f, 0.02034175f, 0.00637540f, -0.02176225f, -0.02049901f, 
    -0.04388646f, 0.04905306f, -0.07117549f, -0.15382054f, 0.10911311f, 0.06457376f, -0.06149586f, 0.09320584f, 
    0.00389585f, -0.10643724f, -0.06059171f, -0.05460345f, 0.00891415f, -0.22875752f, -0.04679264f, -0.01846630f, 
    -0.16889831f, -0.44868013f, -0.45488778f, -0.28391293f, 0.03447692f, -0.04162746f, 0.02980842f, 0.10529797f, 
    0.03255496f, 0.02026714f, -0.05737574f, -0.01507739f, -0.02510734f, 0.08705114f, 0.13077407f, 0.11915979f, 
    0.00021361f, -0.02524152f, 0.01540798f, -0.05203376f, 0.09614273f, 0.00436506f, 0.05099830f, 0.16494963f, 
    -0.14443085f, -0.19049661f, 0.14338864f, -0.22752160f, -0.05929028f, 0.00682702f, -0.09616535f, 0.07514141f, 
    -0.06670390f, -0.13180140f, -0.01271408f, -0.05946768f, -0.00818484f, -0.02417404f, 0.10636996f, 0.04082545f, 
    0.04895759f, -0.02999855f, 0.02685794f, 0.01379799f, -0.11168078f, -0.10995564f, -0.11935294f, 0.07628146f, 
    -0.04757405f, -0.08934454f, -0.01275042f, -0.01786387f, -0.00107406f, 0.02626834f, 0.04904194f, -0.03423791f, 
    0.03380562f, 0.03001421f, -0.01000477f, 0.06626213f, 0.02658680f, -0.12653697f, -0.06348404f, -0.07515141f, 
    0.03599073f, -0.02200701f, 0.04165710f, -0.04419908f, -0.22891688f, 0.06266644f, -0.15607609f, -0.06476294f, 
    0.12122642f, -0.31696028f, -0.03529079f, -0.11624322f, -0.02134044f, -0.06423154f, -0.14615142f, 0.06108477f, 
    0.16095921f, -0.03611254f, 0.02990749f, 0.00652430f, 0.17076585f, -0.08368130f, 0.29136413f, -0.33841178f, 
    -0.02723217f, -0.10610839f, -0.05574366f, -0.09108029f, -0.07534570f, -0.09609812f, 0.09317327f, -0.18212552f, 
    0.17079207f, 0.07040858f, -0.13671073f, 0.06826810f, -0.03132350f, -0.06882445f, 0.17588718f, -0.08516484f, 
    -0.00103952f, -0.14833634f, 0.02750893f, -0.25521359f, 0.06290050f, 0.16016090f, 0.18260817f, 0.10620179f, 
    -0.00528086f, -0.01161845f, -0.01149307f, -0.23721717f, 0.05108640f, -0.04917507f, -0.00646736f, -0.10633799f, 
    0.12350788f, 0.15892029f, 0.37424827f, 0.23728678f, -0.15634818f, -0.04673703f, 0.11267990f, 0.17443351f, 
    0.09548590f, 0.00688551f, 0.01335773f, -0.02369670f, 0.22124252f, -0.33815661f, -0.15766637f, -0.24943282f, 
    -0.00159092f, -0.16040486f, -0.02249403f, 0.05022158f, -0.02481353f, -0.07238023f, 0.00451501f, -0.10348163f, 
    0.06605936f, 0.03731908f, -0.06795830f, 0.03614364f, -0.02192527f, -0.02531163f, 0.00078804f, 0.00163873f, 
    0.03951519f, -0.05018804f, -0.09707846f, -0.01108051f, 0.25364193f, 0.30355820f, 0.03631311f, 0.05028314f, 
    -0.06683480f, -0.02187488f, 0.06192892f, -0.04195484f, -0.12354513f, -0.11828987f, -0.14251107f, 0.01357273f, 
    0.03562213f, 0.01559678f, -0.23309629f, 0.06178646f, 0.00528926f, -0.10678193f, -0.05849539f, -0.21705486f, 
    -0.11737119f, -0.07088340f, -0.15577917f, 0.09328476f, 0.04630735f, 0.03206226f, -0.20156865f, 0.14595379f, 
    -0.04656744f, -0.04610059f, 0.01744728f, -0.05903430f, -0.03315328f, -0.06302638f, 0.12176364f, 0.14821573f, 
    0.16346517f, 0.13476737f, 0.34263453f, -0.13340709f, 0.12861925f, -0.04604084f, 0.17156410f, 0.20917343f, 
    0.04627034f, -0.03334125f, -0.00924687f, -0.06966022f, -0.02914203f, -0.06443992f, -0.08110094f, 0.04051118f, 
    -0.07617032f, 0.00727481f, -0.08769977f, -0.09715436f, -0.10272048f, -0.03546822f, -0.08019084f, 0.14568651f, 
    0.01841792f, -0.04579357f, 0.13982445f, 0.10022681f, -0.14130346f, -0.02474156f, -0.18170351f, -0.20827164f, 
    -0.02615042f, -0.07392159f, -0.14131270f, 0.08389307f, -0.25189900f, 0.09280594f, -0.09910172f, 0.04241730f, 
    0.06970828f, 0.06959558f, -0.20633003f, -0.00838263f, -0.04811645f, -0.10291533f, 0.05823579f, -0.12760168f, 
    0.11444748f, -0.38055870f, 0.06053361f, -0.13240606f, -0.03191015f, -0.03986935f, 0.05460689f, -0.02712176f, 
    -0.11985361f, 0.04027732f, -0.09188582f, -0.03927786f, 0.12881586f, 0.31177571f, -0.27559641f, 0.20324636f, 
    0.12183066f, -0.09494574f, 0.11453684f, -0.00894695f, -0.03868410f, 0.01444658f, 0.02927835f, -0.13354158f, 
    -0.26202306f, 0.05198780f, 0.21690804f, -0.32214841f, 0.08232588f, 0.03621397f, 0.09333728f, -0.07674390f, 
    -0.00244936f, -0.02021277f, 0.07878725f, 0.06529959f, -0.02571241f, -0.21227437f, -0.07906302f, -0.17518124f, 
    -0.03861116f, 0.01549395f, -0.00364770f, 0.10706108f, -0.01963656f, -0.10129967f, -0.04592329f, -0.07069086f, 
    -0.08478457f, 0.08897065f, -0.06717469f, -0.10846826f, 0.06290379f, 0.04635208f, -0.21893226f, -0.00379114f, 
    0.06328309f, 0.07893228f, -0.00576724f, 0.09647954f, 0.00187048f, 0.10423004f, -0.21431175f, -0.24610431f, 
    0.00786217f, 0.06270342f, 0.09283230f, 0.00813931f, 0.07029161f, -0.08332174f, -0.06049248f, -0.08793515f, 
    0.04414508f, 0.10550900f, -0.33908671f, -0.12529115f, 0.06007412f, -0.03817517f, 0.09760150f, 0.22460577f, 
    -0.00417578f, 0.01097463f, -0.01311280f, -0.14109094f, -0.12275099f, 0.01916003f, -0.01504007f, -0.16201201f, 
    -0.10428344f, -0.08126523f, -0.03998973f, 0.16744974f, 0.00420326f, -0.00653663f, 0.01484694f, -0.17806260f, 
    0.09323782f, -0.00622071f, 0.11102040f, -0.15191914f, 0.16734883f, 0.02543921f, 0.08173218f, 0.16453134f, 
    0.02089930f, 0.01003461f, 0.06427665f, 0.00904697f, -0.03935803f, -0.04421049f, 0.17306344f, -0.10657356f, 
    0.11127899f, 0.03277102f, -0.01864449f, 0.05070645f, -0.03098976f, -0.02752078f, -0.00889844f, -0.09707008f, 
    -0.09705556f, -0.56445324f, 0.19282301f, 0.20551752f, -0.15352152f, -0.07024895f, -0.04356039f, -0.06124956f, 
    0.02255175f, 0.03989542f, 0.00968616f, 0.06989191f, 0.06776521f, -0.12535736f, 0.05512104f, -0.09620856f, 
    -0.18993749f, 0.07204973f, 0.07155321f, -0.03853948f, 0.08212648f, 0.04543485f, 0.07819294f, -0.06857873f, 
    -0.08482427f, 0.03163521f, 0.05607688f, -0.04522815f, 0.09823254f, 0.11094525f, -0.06751425f, -0.08393616f, 
    0.10717943f, 0.09685256f, -0.01344118f, 0.02261187f, -0.36374202f, 0.18644029f, 0.01371760f, -0.06049545f, 
    -0.08531664f, -0.01059116f, -0.02756463f, -0.04361055f, 0.06708841f, -0.00766701f, -0.21332735f, 0.03262509f, 
    -0.23095502f, 0.17086959f, -0.00032277f, -0.02764738f, 0.16341461f, -0.03526287f, 0.06493249f, -0.03955448f, 
    0.07632243f, 0.04726990f, 0.00703110f, 0.03871335f, 0.01359537f, 0.24386659f, -0.38150257f, -0.33403683f, 
    0.01817754f, 0.07422660f, -0.04220208f, -0.01113956f, 0.10538717f, 0.10942148f, -0.16417296f, -0.07081832f, 
    -0.32982871f, 0.20638420f, -0.15739127f, -0.19595115f, 0.08564784f, -0.08438522f, 0.12251731f, -0.03675952f, 
    0.08539200f, 0.01723572f, -0.02358852f, 0.11875142f, 0.15157294f, -0.02773977f, 0.29596993f, -0.08585777f, 
    -0.02967113f, 0.09487378f, 0.13324165f, 0.15019949f, 0.04146751f, -0.03977314f, -0.01230376f, 0.03680881f, 
    -0.14032744f, 0.24661762f, -0.07045950f, 0.03218819f, -0.01420444f, -0.14714988f, -0.07532065f, 0.02279923f, 
    -0.00251779f, 0.01562106f, -0.15047768f, -0.00431945f, 0.20296644f, 0.10538601f, -0.20302048f, 0.07943091f, 
    0.00064515f, 0.18295196f, -0.12997730f, -0.00767542f, -0.05684752f, -0.20506480f, 0.06243025f, 0.10949134f, 
    -0.15847066f, 0.00970331f, -0.29898649f, -0.18124466f, -0.08225952f, -0.00290085f, -0.06989232f, 0.18577360f, 
    0.17959054f, -0.20780370f, 0.06038566f, 0.00404543f, 0.03042329f, -0.07751805f, -0.11328778f, -0.10018805f, 
    0.01428764f, 0.04713051f, -0.01221071f, 0.04484888f, -0.01706155f, -0.17824848f, -0.03898340f, -0.33877969f, 
    0.51919150f, -0.04122857f, -0.05714067f, 0.09030113f, 0.01066513f, 0.06557401f, 0.06110041f, 0.00500795f, 
    0.14820993f, 0.00952764f, -0.15042071f, -0.25683546f, -0.12015006f, -0.10427985f, -0.08954976f, -0.00048797f, 
    0.08836008f, -0.03399766f, -0.10287452f, -0.03719857f, 0.09972005f, 0.01155728f, 0.06364217f, 0.16592808f, 
    -0.11881921f, -0.11357298f, -0.02358612f, -0.05492940f, 0.00944226f, -0.04963478f, 0.01946964f, 0.01563869f, 
    0.01907349f, 0.00765972f, -0.23366742f, -0.03638965f, -0.53134912f, -0.12970662f, -0.31758907f, -0.10771292f, 
    0.03406134f, -0.01888211f, -0.01747528f, 0.08881351f, 0.06782804f, -0.08242179f, -0.03930537f, -0.09376329f, 
    -0.02243117f, -0.07933205f, -0.06235889f, 0.05892074f, -0.07239425f, 0.01162850f, -0.00138492f, 0.00596944f, 
    0.02782877f, 0.04374602f, 0.03438761f, -0.02593823f, -0.22831331f, -0.15815899f, -0.50829875f, 0.42273986f, 
    -0.01515378f, 0.03579655f, 0.02158472f, -0.14889272f, 0.07159408f, 0.04126007f, -0.00515476f, 0.38241008f, 
    -0.24900660f, -0.21034190f, -0.14731556f, -0.32932585f, -0.00536766f, 0.06030080f, -0.07723854f, 0.04317783f, 
    0.05381723f, -0.10637921f, 0.01854358f, -0.00906948f, -0.01288194f, -0.08133970f, -0.03536622f, 0.00655564f, 
    0.01354016f, 0.02032070f, 0.04385409f, 0.03726063f, -0.02865745f, -0.36299896f, -0.35907388f, -0.53415751f, 
    0.19108322f, 0.00917715f, -0.27139854f, 0.25556424f, 0.05457843f, -0.02740277f, -0.00429318f, 0.03835463f, 
    0.02562650f, 0.05062820f, 0.00312189f, 0.03247947f, 0.12383456f, 0.05964218f, -0.03237471f, 0.00048824f, 
    -0.15341233f, -0.11391841f, 0.13748945f, -0.09208602f, -0.11250110f, -0.20690839f, -0.06034499f, -0.37253213f, 
    0.17093208f, 0.01789607f, 0.01947294f, 0.02626566f, 0.16424383f, 0.12220705f, 0.11334996f, 0.12172291f, 
    0.00915770f, 0.04752629f, 0.08847748f, 0.02273891f, 0.20914622f, -0.06733328f, 0.34962034f, 0.17971890f, 
    0.05394319f, -0.00236160f, 0.11058141f, 0.02430480f, 0.15182902f, -0.03208649f, -0.08668581f, 0.01271319f, 
    -0.15995844f, -0.21685465f, 0.16976120f, 0.18000253f, 0.10902076f, -0.23248860f, -0.02588669f, -0.10652915f, 
    0.19543500f, 0.06927599f, 0.18982153f, -0.09011442f, 0.08002969f, 0.02444504f, -0.06070710f, -0.04054050f, 
    0.02753558f, 0.01427888f, -0.00624714f, 0.10720598f, -0.10206152f, -0.13182080f, -0.05878367f, 0.04278594f, 
    0.16210546f, 0.04029953f, 0.10077344f, 0.05644856f, 0.08474218f, 0.07530216f, 0.07170876f, 0.05296920f, 
    0.03620471f, 0.01415233f, 0.02080101f, 0.06738962f, -0.37576538f, -0.21230468f, 0.25574630f, 0.06049250f, 
    0.00085716f, -0.14306067f, -0.21005380f, 0.37224755f, -0.15442431f, 0.05331211f, -0.14978079f, 0.06337109f, 
    -0.12044594f, 0.17029318f, -0.18580261f, -0.16390137f, -0.06894883f, 0.00433151f, -0.09071919f, 0.13273537f, 
    -0.04990557f, -0.19769415f, 0.03635403f, -0.06289349f, 0.03754395f, 0.09572842f, 0.21692303f, -0.26006189f, 
    -0.12203407f, -0.21413772f, -0.08794729f, 0.08748204f, -0.11779584f, 0.03959217f, -0.14370769f, -0.01772237f, 
    -0.07917295f, -0.22554529f, 0.03682829f, 0.05531223f, -0.06669549f, -0.02581702f, -0.07970434f, -0.03044662f, 
    0.04224305f, 0.05985798f, 0.04154109f, 0.00984020f, 0.15913233f, -0.04449803f, -0.15983003f, 0.05149950f, 
    -0.01441224f, 0.05333060f, 0.07027223f, 0.02288978f, 0.05156374f, 0.00865966f, -0.10238353f, -0.08671436f, 
    0.09153596f, -0.02040007f, -0.23732653f, 0.07896825f, 0.06111652f, 0.10514852f, 0.04441366f, -0.03537598f, 
    0.03659620f, 0.00231056f, -0.05123413f, -0.00530778f, -0.11817452f, -0.09192483f, -0.01833323f, -0.11903340f, 
    -0.14997217f, 0.06817519f, 0.05788169f, -0.23969458f, 0.15950356f, 0.05567631f, 0.11780448f, 0.03239254f, 
    0.12622930f, -0.07436408f, -0.30740276f, 0.14457908f, 0.05009567f, -0.04054526f, 0.00180878f, -0.01515887f, 
    0.17410032f, -0.06260841f, 0.12662289f, -0.02210915f, 0.06908282f, 0.13097790f, 0.05005658f, 0.11711394f, 
    -0.10330766f, -0.01568564f, -0.04636364f, -0.12865567f, 0.07367335f, 0.03944432f, -0.02075901f, -0.09134464f, 
    0.22934453f, -0.25655112f, -0.14345831f, -0.12059020f, 0.06192859f, 0.05044805f, -0.14459856f, 0.15110984f, 
    0.18129191f, -0.03871384f, -0.06214353f, 0.11430562f, -0.01362280f, -0.19453791f, -0.09673790f, -0.07708530f, 
    0.06265036f, 0.08718443f, -0.03870983f, 0.14394413f, 0.08026728f, 0.05410592f, 0.04785022f, -0.02534407f, 
    -0.11617080f, -0.20512129f, 0.05366452f, 0.05049046f, -0.07783169f, -0.08967097f, -0.00369824f, 0.06051658f, 
    0.13524818f, -0.02231915f, -0.04513131f, 0.01378000f, 0.15530375f, -0.32441339f, -0.01720879f, 0.13425261f, 
    0.08506498f, -0.03368848f, 0.00737963f, 0.03660998f, 0.15416050f, 0.05443769f, 0.03974580f, 0.01058508f, 
    -0.62938184f, 0.53225452f, -0.04820593f, -0.16655250f, -0.01803550f, 0.03530036f, 0.07804109f, 0.00997316f, 
    -0.04799428f, -0.24347644f, 0.00137512f, -0.17255647f, 0.24876605f, -0.09289049f, 0.19415462f, -0.02221277f, 
    0.12830678f, -0.06894054f, 0.11356789f, 0.08725737f, 0.06678215f, -0.03076199f, 0.12839863f, 0.09508045f, 
    -0.05258741f, 0.16598018f, -0.34485334f, 0.20867431f, 0.32038966f, -0.08967516f, 0.06370941f, 0.10211380f, 
    0.00392153f, 0.11170501f, -0.01202825f, 0.08017200f, 0.21809651f, 0.13859105f, -0.01474374f, 0.06394427f, 
    -0.04085431f, -0.06276053f, 0.16621393f, -0.05836177f, -0.09486643f, -0.18255080f, 0.03210438f, -0.07321907f, 
    0.07044895f, 0.16907239f, 0.03511929f, -0.12475098f, 0.30875245f, 0.08577861f, 0.02463122f, -0.35289392f, 
    0.02673473f, -0.00199284f, 0.01860473f, 0.06831788f, -0.14621735f, 0.33123523f, -0.13225400f, 0.20411938f, 
    -0.05518781f, 0.02312254f, 0.14641723f, -0.06254828f, 0.10728755f, 0.00012911f, 0.05836829f, 0.04431989f, 
    -0.12570947f, 0.01947928f, 0.17455009f, -0.14902617f, -0.02458739f, -0.10416865f, 0.02802555f, -0.10598493f, 
    0.10583583f, 0.21043791f, -0.00460048f, 0.05543866f, -0.55838186f, -0.45830813f, -0.02563367f, -0.01784984f, 
    -0.12582463f, 0.05009386f, -0.04181664f, 0.00170412f, 0.17485468f, -0.11712357f, 0.19072582f, 0.06890656f, 
    -0.26519600f, -0.11071029f, 0.00526299f, 0.10349244f, 0.07468901f, -0.10384196f, 0.05072159f, 0.11049022f, 
    0.20422842f, 0.03855511f, -0.09499232f, 0.01472866f, 0.31868720f, -0.03572690f, 0.03061908f, 0.01545965f, 
    0.02987387f, 0.02409684f, 0.03092099f, 0.09115245f, 0.07397298f, 0.03899669f, 0.06689674f, -0.14020880f, 
    -0.00235264f, -0.16068918f, -0.42531464f, 0.28636843f, 0.05788161f, -0.06403182f, 0.10016306f, 0.02653764f, 
    0.01452881f, 0.04117423f, 0.07066406f, 0.08258524f, -0.07583208f, -0.07761923f, 0.14748375f, -0.16360360f, 
    -0.04814793f, -0.16706572f, -0.03607181f, 0.15452617f, -0.09852092f, -0.12270530f, -0.04128792f, 0.00628983f, 
    -0.02392638f, 0.07853915f, -0.08103495f, 0.07576282f, -0.01125947f, -0.03891031f, 0.04540590f, -0.02367999f, 
    0.19164738f, 0.03830188f, -0.11706453f, -0.00710589f, -0.01650120f, -0.03481469f, -0.04949668f, 0.03371102f, 
    0.00718613f, -0.08429410f, 0.01428189f, -0.07220700f, -0.19809623f, 0.06026156f, -0.10326366f, -0.08420280f, 
    0.09358100f, 0.00728585f, -0.22701745f, 0.05568144f, 0.02347455f, 0.10476980f, -0.01624407f, 0.06035913f, 
    -0.02923567f, 0.07389455f, -0.11246133f, -0.02011817f, -0.11941999f, 0.17834890f, -0.39968610f, -0.07510125f, 
    0.00748602f, 0.15531863f, -0.09531958f, 0.11498281f, -0.00481449f, 0.00357634f, 0.07619848f, -0.00118204f, 
    -0.24178328f, -0.30953312f, 0.24869272f, 0.34668919f, -0.11505545f, -0.17078885f, -0.10476594f, -0.14166978f, 
    -0.06486319f, 0.08402698f, -0.05316914f, -0.10523821f, -0.01837534f, -0.00712973f, -0.00538856f, 0.19158082f, 
    0.07408230f, -0.00888868f, 0.04160922f, -0.09999013f, 0.07471442f, -0.01919939f, -0.07750321f, 0.11270252f, 
    0.27814654f, 0.13140242f, -0.03149455f, 0.10194056f, 0.08535150f, -0.12406486f, -0.03430161f, 0.11040190f, 
    0.07186420f, -0.09082304f, -0.07590940f, -0.29376754f, -0.30915895f, -0.17648706f, 0.18251064f, -0.13462517f, 
    -0.12043770f, -0.09978042f, 0.00716248f, -0.04686007f, -0.07761664f, 0.09991511f, 0.01742642f, 0.13804698f, 
    0.12629469f, -0.11965948f, -0.05263468f, -0.17351179f, 0.14919232f, 0.09821130f, 0.14106074f, 0.01168421f, 
    0.06469978f, 0.06693146f, -0.03807432f, -0.03898013f, -0.00292400f, -0.20554036f, 0.05255445f, 0.03007960f, 
    0.10589550f, 0.11274087f, 0.11905666f, -0.18196358f, 0.04452369f, 0.06096038f, 0.06596970f, 0.03053251f, 
    -0.49123466f, -0.35277775f, -0.40430984f, -0.27537557f, 0.07884502f, 0.00370706f, -0.08920842f, -0.04670505f, 
    0.06152002f, -0.03258127f, -0.01506923f, -0.00124525f, -0.45260987f, -0.42992151f, -0.10758953f, -0.07434678f, 
    -0.21174933f, 0.14804925f, 0.17194213f, 0.00673006f, 0.01566530f, 0.06954898f, -0.02070842f, -0.01633254f, 
    -0.11480529f, 0.01609433f, -0.09964803f, 0.46720007f, -0.10762437f, -0.19743671f, -0.00515664f, 0.15639660f, 
    0.02004072f, -0.04227495f, 0.07219473f, 0.09173556f, -0.01243016f, -0.15578312f, -0.06659454f, 0.09832104f, 
    -0.01466761f, 0.08708020f, 0.03029966f, -0.02642665f, 0.02507769f, -0.08190262f, 0.03691893f, 0.05139621f, 
    -0.63598561f, -0.34407997f, -0.10617411f, -0.27344590f, -0.01077038f, -0.29601130f, -0.05647634f, -0.15945981f, 
    -0.10177942f, -0.01603525f, -0.01249586f, 0.04645142f, -0.15790828f, -0.16451120f, 0.27620482f, -0.21670729f, 
    -0.05772622f, 0.01559460f, 0.02777638f, 0.02795668f, 0.06999487f, 0.22550870f, 0.03164622f, 0.14406061f, 
    -0.10785530f, -0.18023480f, 0.01624058f, -0.22759229f, 0.12992935f, 0.11582180f, -0.03333875f, 0.08425146f, 
    0.00051625f, -0.01577471f, 0.02792014f, -0.06627161f, -0.17542383f, -0.00008941f, 0.23729596f, -0.41150931f, 
    0.01549915f, 0.02162809f, -0.02147540f, 0.01806010f, -0.02309640f, 0.06272734f, -0.07788814f, 0.09951802f, 
    0.01255528f, 0.08819588f, 0.17850706f, -0.12753406f, 0.08272829f, -0.05981538f, 0.05467502f, 0.10207696f, 
    0.01922056f, 0.06921130f, -0.01874470f, 0.04108796f, -0.31475428f, -0.03607471f, 0.37714431f, -0.19141646f, 
    -0.13826202f, -0.21036501f, -0.01690265f, -0.08627390f, -0.04031608f, 0.01213212f, 0.03385125f, -0.00995167f, 
    -0.01306271f, -0.20579703f, 0.05358963f, 0.08709266f, 0.08652328f, -0.06059728f, 0.01365765f, -0.06516188f, 
    -0.01012692f, 0.11647527f, 0.01149542f, 0.00933667f, 0.14966051f, 0.02444108f, -0.18899877f, -0.27733466f, 
    -0.24175815f, -0.00791172f, 0.14669085f, 0.13177465f, 0.11673690f, 0.18160251f, -0.30110812f, -0.01143536f, 
    0.14569871f, 0.10674038f, 0.00870741f, 0.01468702f, 0.02554743f, -0.00229610f, 0.08456918f, -0.07787021f, 
    0.11708598f, 0.02431494f, 0.14051463f, 0.04421408f, 0.18115030f, 0.16347359f, -0.02844678f, -0.03890308f, 
    -0.03033460f, -0.00539443f, 0.03295166f, 0.05516103f, 0.09249214f, 0.08082107f, -0.06197180f, 0.05084180f, 
    0.16300723f, 0.20744808f, -0.11040121f, 0.00367622f, -0.00381517f, 0.00374414f, 0.03983427f, 0.13921414f, 
    -0.05488376f, 0.10439002f, 0.18555133f, 0.00918606f, -0.00681908f, -0.05954847f, 0.00191712f, -0.07190409f, 
    -0.03246316f, -0.05408129f, -0.03390013f, -0.00763013f, -0.06941945f, -0.06690791f, 0.01843852f, -0.14959446f, 
    0.13335505f, -0.07266319f, -0.11832000f, -0.06596290f, -0.02723050f, 0.02175381f, 0.10296424f, 0.06761713f, 
    -0.04711160f, -0.06934029f, 0.03054350f, -0.09748116f, -0.13005440f, 0.14169653f, 0.23659657f, 0.05045221f, 
    -0.05757710f, -0.00195635f, -0.03566445f, -0.09897385f, -0.11137679f, 0.13968866f, 0.01717183f, 0.06893470f, 
    0.09515336f, -0.06564285f, -0.08414272f, 0.01700302f, -0.06102752f, -0.12811756f, 0.16204993f, 0.01659751f, 
    -0.02222759f, -0.11546671f, -0.07741046f, -0.00115322f, 0.19789606f, 0.06399345f, 0.06281030f, -0.05466907f, 
    0.09297003f, -0.07425126f, 0.01705950f, -0.06935845f, 0.04276467f, 0.01214540f, 0.01922965f, -0.25178984f, 
    -0.27407372f, 0.56232756f, 0.28149673f, 0.12575951f, 0.00949308f, -0.16745910f, 0.08707761f, -0.05626152f, 
    0.03758253f, 0.09895273f, -0.08819009f, 0.08104485f, 0.05715472f, 0.02289556f, -0.01760220f, -0.05270358f, 
    -0.02076879f, -0.01709273f, 0.02946284f, 0.00789488f, -0.01390531f, 0.04693915f, 0.10362365f, 0.06334483f, 
    -0.07357644f, -0.06013650f, -0.42287919f, -0.28745300f, -0.07024498f, 0.12074450f, 0.09660469f, 0.03636447f, 
    -0.11854334f, 0.00932198f, 0.09531233f, -0.02439722f, -0.04254957f, -0.04620618f, -0.18972990f, -0.01643991f, 
    -0.10257510f, 0.12527138f, 0.02778793f, -0.02498822f, 0.10980288f, -0.06517947f, 0.02384689f, 0.08569764f, 
    -0.57274961f, -0.59741801f, -0.32905030f, -0.24798314f, -0.06313452f, -0.09708477f, -0.09862524f, -0.28118709f, 
    0.02887907f, 0.00980719f, -0.05159449f, -0.04700702f, -0.28161955f, -0.70480984f, -0.37358749f, 0.26824349f, 
    0.10257450f, 0.10727856f, -0.22495118f, -0.28724167f, -0.00061523f, -0.00993453f, 0.06648239f, 0.09752255f, 
    -0.09006832f, -0.06384190f, 0.19177262f, -0.04411499f, -0.00517222f, 0.04792896f, -0.09636957f, 0.01662293f, 
    -0.00989465f, 0.16934469f, 0.03517803f, 0.00195651f, -0.14487289f, 0.30438241f, 0.08781981f, -0.14803122f, 
    -0.09467079f, -0.06829603f, -0.10376445f, -0.02664234f, -0.01092840f, 0.08020735f, 0.05881549f, 0.05501768f, 
    -0.14985898f, -0.52510548f, -0.43606761f, -0.14455782f, -0.01645604f, -0.03219583f, 0.22665699f, -0.11455941f, 
    0.01253845f, 0.01206603f, -0.10035735f, 0.04654821f, -0.02775523f, -0.05097511f, 0.00407366f, 0.29472721f, 
    -0.11258689f, 0.16209084f, 0.14831574f, 0.12613496f, -0.00672009f, -0.06965733f, 0.11128803f, 0.09206415f, 
    -0.55911517f, 0.04417331f, 0.02650052f, 0.14867242f, -0.12092791f, -0.01395057f, 0.06136611f, -0.09621469f, 
    -0.04651313f, 0.04775951f, 0.17080882f, 0.09734304f, -0.23258679f, -0.10703682f, 0.03064844f, 0.24709633f, 
    0.11019060f, 0.00843603f, 0.01315829f, -0.01562843f, 0.06066089f, 0.09069266f, 0.11699314f, 0.07303642f, 
    -0.05072937f, -0.16029109f, -0.30230382f, 0.05639319f, 0.00985016f, 0.10252184f, 0.08647755f, 0.06310077f, 
    -0.01689482f, 0.00056287f, -0.10839448f, 0.01528360f, 0.02691438f, -0.09392913f, -0.31397563f, -0.16441500f, 
    0.05729609f, 0.02600309f, 0.11883023f, 0.04406951f, -0.05815608f, 0.00360900f, -0.03562330f, 0.09666334f, 
    0.59690708f, 0.02530710f, 0.10356273f, -0.32809168f, 0.04158832f, -0.15345441f, 0.15070722f, -0.10186225f, 
    0.05250598f, 0.01846947f, 0.04713070f, -0.06155724f, -0.26870176f, -0.02508784f, 0.16494761f, 0.21205433f, 
    0.01921790f, -0.26077539f, -0.04701202f, 0.01088602f, -0.01078873f, -0.05483321f, -0.01488232f, -0.08648216f, 
    0.14073461f, -0.15495299f, -0.16801488f, -0.13524970f, -0.01591238f, 0.04346986f, 0.06875677f, 0.02404620f, 
    0.00778488f, 0.11316200f, -0.17695330f, -0.22937600f, -0.65047067f, -0.59125096f, -0.28122559f, -0.27304092f, 
    -0.12194280f, 0.16318041f, -0.16356486f, -0.28788239f, -0.05327365f, -0.12712421f, 0.08550086f, -0.02703839f, 
    0.28571197f, 0.23846067f, -0.14015946f, 0.35494259f, 0.01181752f, 0.04721471f, 0.02521469f, 0.19443017f, 
    0.20197178f, -0.04659818f, 0.16183899f, -0.16002445f, 0.18243915f, 0.43066084f, -0.05951200f, 0.06643912f, 
    -0.01164846f, 0.03334988f, -0.03070321f, 0.00348832f, 0.04049341f, -0.11894569f, 0.18969646f, 0.00979859f, 
    0.01871727f, -0.06836251f, -0.08857264f, 0.03915562f, -0.08586039f, 0.04140878f, 0.03417206f, 0.00262639f, 
    0.00718716f, -0.08457752f, -0.08950366f, -0.01518132f, 0.04114748f, 0.06383345f, -0.04757515f, 0.02763771f, 
    -0.04543269f, 0.08555339f, 0.01313215f, 0.05853420f, -0.01357988f, -0.03495417f, 0.00128100f, 0.06769387f, 
    0.00337113f, 0.07124888f, -0.03459950f, -0.20765519f, 0.02049333f, -0.05001815f, 0.13706690f, 0.10839238f, 
    0.07161340f, 0.25032368f, 0.11150590f, -0.03325831f, -0.16907169f, -0.04251106f, -0.27753329f, -0.17387491f, 
    0.02649127f, -0.00945653f, 0.00343522f, 0.10240553f, -0.06062829f, 0.09351350f, -0.12323433f, -0.11038504f, 
    0.01757030f, -0.20137160f, 0.05877535f, -0.21413031f, 0.07190342f, 0.01300472f, 0.04408482f, 0.03071119f, 
    0.00031086f, 0.06457530f, -0.08500244f, 0.11876044f, -0.05433839f, -0.02245095f, 0.25838223f, -0.24723835f, 
    0.00311115f, -0.01996677f, -0.07738768f, -0.11781173f, -0.06385899f, -0.02209639f, 0.01562851f, -0.04102638f, 
    -0.67760408f, -0.67740613f, -0.55448395f, -0.27768123f, -0.14273019f, -0.07834494f, -0.31686425f, -0.41539890f, 
    0.01905167f, -0.00981859f, -0.04104825f, -0.00354133f, -0.10124451f, -0.02095481f, 0.10662699f, -0.05815282f, 
    -0.01802288f, 0.16822894f, 0.12366399f, -0.07679562f, 0.10739633f, -0.00250846f, 0.12534676f, 0.07737464f, 
    -0.17254473f, -0.10950812f, 0.15452346f, -0.04398716f, -0.05972517f, -0.16521755f, -0.00864349f, 0.08113129f, 
    -0.00334202f, 0.09259348f, -0.00795339f, -0.06128496f, -0.24112290f, 0.06747556f, 0.21867812f, 0.34492618f, 
    -0.02522900f, -0.15709272f, -0.05530752f, 0.00496099f, -0.13396512f, 0.10869708f, -0.11052746f, -0.00753588f, 
    -0.21514629f, 0.06776484f, 0.05402781f, 0.09344441f, 0.09571771f, 0.08510641f, -0.17744984f, -0.13781801f, 
    0.11779251f, -0.14252461f, 0.04025149f, 0.06379069f, 0.45343766f, -0.20777425f, -0.47636831f, -0.24161693f, 
    -0.06231849f, 0.02532535f, 0.06276667f, -0.10026096f, 0.06979886f, 0.13307820f, 0.00833600f, -0.10409033f, 
    -0.21137847f, -0.32001689f, -0.01639921f, 0.01485005f, 0.12489810f, 0.04633126f, 0.16232130f, -0.27697128f, 
    0.05160958f, -0.00396541f, -0.00695498f, 0.12382086f, -0.04777316f, -0.28672543f, -0.30348757f, 0.10876896f, 
    -0.12767778f, -0.02688273f, 0.19833732f, 0.12826683f, 0.03546730f, 0.07879724f, 0.03509047f, 0.01648179f, 
    -0.28466547f, -0.09885096f, -0.07094321f, 0.20887826f, 0.02605219f, 0.11705444f, 0.03654043f, -0.03861919f, 
    0.03023988f, -0.11034917f, 0.09105271f, 0.03706860f, 0.39067817f, -0.19233502f, -0.38286436f, 0.19390891f, 
    -0.11378054f, 0.10134467f, 0.05392124f, 0.13125238f, -0.03429591f, 0.01637423f, -0.12582789f, 0.01021434f, 
    -0.33564821f, 0.23004761f, 0.15613352f, -0.12202260f, -0.06639074f, -0.05847968f, -0.03471831f, -0.12046117f, 
    -0.01606918f, -0.11215070f, 0.06600888f, 0.05015573f, -0.45940271f, -0.58407515f, 0.15366134f, -0.17224497f, 
    0.10347515f, 0.02712340f, 0.07016098f, -0.32382923f, 0.04136948f, 0.02112521f, 0.08957183f, 0.06318654f, 
    0.06638739f, -0.45559528f, 0.12952165f, -0.23383227f, -0.19603266f, 0.01086203f, -0.16883127f, 0.23199025f, 
    0.04790981f, 0.04865791f, -0.01025179f, -0.02597634f, -0.00054390f, -0.01470259f, -0.07613622f, 0.01566997f, 
    0.04364661f, -0.00813936f, -0.06558432f, -0.09601860f, -0.06796911f, 0.02248758f, 0.03493471f, -0.01089506f, 
    -0.02397669f, -0.05054886f, -0.00873350f, 0.01099762f, 0.00891962f, -0.05788600f, 0.09058890f, -0.02989094f, 
    -0.00856254f, -0.02877571f, 0.03262358f, -0.02064789f, -0.30094364f, -0.05611673f, -0.41165000f, -0.04457350f, 
    -0.01138497f, -0.09751254f, 0.01612543f, -0.01237115f, 0.08912271f, 0.00551463f, 0.04080123f, 0.07100306f, 
    -0.10699704f, 0.15188214f, -0.07490204f, -0.02561599f, -0.09928805f, -0.06410669f, -0.06147546f, 0.16440386f, 
    -0.00007437f, -0.01198691f, 0.03803089f, 0.00778614f, 0.00372986f, 0.05228384f, 0.07890103f, 0.05498011f, 
    0.07497341f, -0.09781192f, 0.00811545f, 0.03894505f, -0.13064121f, -0.03711789f, 0.10344931f, 0.07618693f, 
    -0.27166504f, -0.29262677f, -0.28187150f, -0.01656097f, 0.05024602f, -0.08195461f, 0.11022107f, 0.04594046f, 
    0.01290268f, 0.00109732f, -0.02915803f, -0.02502089f, -0.09165113f, -0.24550115f, -0.10748975f, -0.00049170f, 
    -0.10145140f, -0.01610036f, 0.02425706f, 0.08936981f, 0.02206799f, -0.01765616f, -0.03328219f, 0.00861342f, 
    0.46486777f, -0.43188027f, -0.33795559f, -0.57167369f, 0.11863969f, 0.01429102f, 0.08696070f, 0.01374148f, 
    0.01250470f, 0.02299866f, -0.02549787f, -0.11535326f, -0.06551122f, -0.06622589f, 0.15872115f, -0.14480287f, 
    0.01308172f, 0.08674150f, -0.02954519f, -0.03110401f, -0.02550922f, 0.00198595f, 0.04468421f, 0.00357009f, 
    -0.19733104f, -0.21610613f, -0.22631335f, 0.28246751f, 0.02725636f, 0.03009884f, -0.13169628f, -0.04957995f, 
    -0.04670891f, -0.10281725f, -0.01922210f, 0.01507632f, 0.46175128f, -0.19807267f, 0.05811875f, -0.53462565f, 
    -0.00218567f, -0.01438501f, -0.09646460f, 0.12111289f, 0.08159102f, 0.16803043f, -0.00980733f, -0.00424768f, 
    -0.29932156f, 0.24183662f, -0.13975385f, 0.18110892f, -0.12423978f, -0.04110609f, -0.04546432f, 0.03548154f, 
    0.00636802f, 0.02988291f, -0.04374082f, -0.07937042f, -0.26657650f, 0.14100428f, -0.02733948f, 0.17313221f, 
    -0.00737325f, 0.03706318f, 0.08444037f, -0.01001851f, -0.01026990f, -0.01508994f, 0.02488655f, 0.05092488f, 
    0.08174676f, 0.08869649f, -0.09801743f, -0.10565210f, -0.16840982f, 0.06340822f, -0.11122028f, -0.07458654f, 
    0.11474118f, -0.06578541f, 0.02498298f, -0.03396033f, 0.45835736f, -0.27028608f, -0.03074588f, 0.20150638f, 
    -0.03939577f, 0.16605221f, -0.00587922f, -0.12128323f, -0.02119742f, -0.06557011f, -0.08322404f, 0.03693688f, 
    0.20621203f, 0.02476983f, -0.14896277f, -0.17506096f, 0.00024916f, 0.02733100f, -0.05933112f, 0.07246544f, 
    -0.09630952f, 0.07317166f, -0.01738096f, -0.10396380f, -0.05215939f, 0.07420702f, -0.13383743f, -0.15911593f, 
    -0.07458802f, 0.06512886f, -0.11908773f, 0.07709543f, -0.05681477f, -0.15848358f, 0.01399024f, 0.00651277f, 
    -0.07277742f, 0.15778781f, 0.01015168f, 0.15166900f, 0.00136035f, 0.07403037f, 0.09935912f, -0.05411644f, 
    -0.05147859f, -0.01530391f, 0.01040452f, -0.00887196f, -0.07769926f, -0.14451960f, -0.14952715f, -0.01577414f, 
    -0.05888846f, 0.04079406f, -0.01673613f, -0.00525174f, 0.18014386f, 0.12165830f, 0.01759677f, 0.02874058f, 
    -0.11928291f, -0.00189078f, -0.01445828f, 0.07335387f, -0.00405209f, -0.00751807f, 0.03874245f, -0.11462130f, 
    0.00822276f, 0.06737409f, -0.06654190f, -0.12658884f, 0.16321155f, 0.09895408f, -0.03999302f, -0.06592182f, 
    0.02503185f, -0.00624795f, 0.02986144f, -0.04547138f, -0.09727367f, -0.28857860f, -0.14807311f, -0.15688604f, 
    0.00093735f, 0.07294893f, 0.10920661f, 0.01305127f, -0.01769477f, 0.02156164f, -0.03516016f, 0.00420654f, 
    0.01272533f, 0.09043626f, -0.02530085f, 0.00229668f, 0.32200566f, -0.05139540f, -0.11520413f, -0.12690674f, 
    -0.04673537f, -0.00674818f, -0.08346891f, -0.02215995f, 0.05686822f, 0.00393852f, -0.00958541f, 0.07867103f, 
    0.02141413f, 0.11758494f, -0.01446118f, -0.02672208f, -0.18273062f, 0.04995703f, -0.01228420f, 0.01907158f, 
    -0.01490396f, -0.02144959f, 0.05291389f, 0.00421991f, -0.18794999f, 0.04788536f, -0.00133026f, 0.15152906f, 
    0.01316321f, 0.04000288f, 0.00418621f, -0.00066762f, -0.02333500f, 0.08371807f, 0.02184937f, -0.03682564f, 
    -0.09185974f, -0.61304319f, -0.34515911f, -0.13827902f, -0.13368994f, -0.06992042f, -0.04773826f, 0.09741951f, 
    0.05119250f, -0.00474363f, -0.01323672f, 0.01385724f, 0.07217803f, 0.06422328f, 0.09569603f, -0.00432417f, 
    -0.00389638f, 0.00938210f, -0.00576727f, -0.05519979f, 0.16306862f, 0.06919894f, 0.12658301f, -0.07417506f, 
    -0.14028892f, 0.01161427f, 0.08582844f, -0.09750848f, 0.00637383f, 0.08317903f, -0.05386291f, -0.12440374f, 
    0.01681025f, 0.03189181f, -0.01062483f, 0.03385920f, -0.24504404f, -0.14357355f, -0.10531273f, 0.07295179f, 
    -0.00314336f, 0.10971639f, -0.01566598f, -0.08461002f, 0.05454276f, -0.06297967f, 0.06021384f, -0.08810715f, 
    -0.27646804f, -0.18248637f, -0.28176978f, 0.02523654f, 0.11465655f, -0.16728632f, -0.09034229f, -0.02703323f, 
    0.03746112f, 0.03204273f, -0.03820527f, -0.01361910f, 0.08083756f, -0.60388851f, 0.01453871f, 0.22036856f, 
    -0.05273543f, -0.14742441f, -0.02603728f, 0.06054728f, 0.03374618f, 0.00228888f, -0.00173732f, -0.06807557f, 
    0.28527957f, 0.11135516f, -0.15512131f, -0.23872411f, 0.04175011f, 0.04977356f, -0.03705224f, 0.02833756f, 
    -0.05662005f, 0.03134010f, 0.06466852f, -0.20367321f, 0.07524815f, -0.36451539f, -0.21596210f, -0.17339598f, 
    -0.00066746f, -0.02576550f, 0.02875194f, 0.03017368f, 0.01709805f, 0.15257397f, 0.02276837f, 0.05481568f, 
    -0.44218659f, -0.23325551f, 0.20378397f, 0.35443807f, -0.04465414f, -0.00737521f, 0.01245709f, 0.03071889f, 
    -0.00532776f, -0.05856753f, -0.08582658f, -0.02048649f, 0.56730485f, -0.30515704f, -0.33835486f, -0.09927957f, 
    0.14541234f, 0.07790529f, -0.17397666f, -0.03721188f, -0.04786576f, 0.07060260f, -0.01483812f, -0.00982817f, 
    -0.06809461f, -0.49852046f, -0.42840749f, -0.31379411f, -0.01069630f, -0.11060576f, 0.07995959f, 0.11222091f, 
    0.02226414f, 0.02961397f, -0.00756552f, -0.07988111f, -0.02524533f, -0.07000529f, 0.11679483f, -0.23085234f, 
    0.00566099f, -0.16425839f, 0.11895645f, 0.06493062f, -0.05950557f, -0.01075323f, 0.06562629f, 0.06316017f, 
    0.01608347f, 0.04229197f, 0.04530228f, -0.02985906f, -0.01261119f, -0.10718990f, -0.07056595f, -0.00648082f, 
    0.00187754f, 0.02460653f, 0.01092037f, -0.00478775f, -0.03495619f, -0.02440785f, 0.01456806f, -0.10400596f, 
    -0.05541033f, -0.09836770f, -0.09857901f, 0.06184473f, 0.05861271f, -0.00402080f, -0.00853866f, 0.01521710f, 
    -0.32366461f, 0.44160903f, -0.11373336f, 0.11119667f, -0.01803151f, -0.09151141f, 0.10328498f, 0.01181034f, 
    0.02712977f, 0.01502188f, -0.02333886f, -0.05461652f, 0.08142605f, -0.04813300f, 0.05420606f, -0.06301621f, 
    -0.13602157f, 0.04244328f, 0.14548506f, 0.13803102f, 0.02818936f, -0.08994431f, 0.01639271f, 0.00421864f, 
    -0.00140687f, 0.01123091f, 0.13794117f, -0.08640368f, 0.01770360f, 0.01524054f, -0.03557112f, 0.00882092f, 
    0.03540511f, -0.08445139f, -0.02810871f, -0.01318474f, -0.17153814f, -0.17991634f, -0.21052667f, 0.34341225f, 
    0.08743798f, -0.10194857f, 0.09059186f, 0.03125007f, 0.00660707f, -0.00031546f, -0.05007976f, 0.01190072f, 
    0.04674770f, -0.07566994f, 0.10352063f, -0.03555695f, 0.05622283f, -0.00882442f, 0.05299582f, -0.13964455f, 
    -0.22445042f, 0.12026223f, 0.02080587f, -0.01376456f, -0.06750976f, -0.19708532f, -0.03055695f, -0.12180511f, 
    -0.03926162f, 0.05669002f, 0.02675056f, -0.01390441f, -0.14040457f, -0.05300490f, 0.00630019f, 0.05034007f, 
    0.07750018f, 0.03303287f, 0.10058555f, -0.04155584f, -0.02666031f, 0.00095053f, -0.04042832f, -0.07876532f, 
    0.05986627f, 0.00605575f, -0.03328071f, -0.02532368f, 0.13184814f, -0.04257234f, 0.04458301f, -0.08613009f, 
    -0.03317220f, 0.02264071f, -0.00294753f, -0.04933950f, -0.09381312f, 0.04884464f, -0.08999389f, -0.11194200f, 
    0.39889115f, 0.20596923f, -0.28591639f, 0.22986536f, 0.02352838f, -0.08728853f, 0.05244393f, -0.12075783f, 
    0.11881513f, -0.02434278f, -0.06683344f, -0.08214200f, 0.00212221f, -0.25256974f, 0.06526342f, -0.17753354f, 
    0.01748594f, -0.06366085f, -0.00589344f, -0.08222412f, 0.06619862f, -0.05812072f, -0.04190191f, -0.10739789f, 
    -0.13972592f, 0.22878003f, -0.11940400f, 0.04937260f, -0.02873277f, -0.03436385f, -0.08953170f, 0.04051693f, 
    -0.13182339f, 0.04958856f, 0.09633895f, -0.04909209f, -0.14263853f, -0.31379583f, -0.35337281f, 0.47839999f, 
    0.08031360f, 0.01621489f, -0.00431540f, -0.02176336f, 0.02237933f, -0.03034321f, 0.08877190f, 0.07917573f, 
    -0.35378259f, -0.31533450f, -0.18399443f, 0.27980796f, 0.14790535f, 0.03012446f, 0.01730153f, 0.05576156f, 
    0.04213061f, -0.04311550f, 0.01508179f, -0.01932101f, 0.08467475f, 0.17437893f, -0.25161421f, 0.19069198f, 
    -0.07399004f, 0.03838067f, 0.04327409f, -0.05789225f, -0.05223441f, -0.05953539f, -0.01060865f, -0.09072194f, 
    0.13903408f, -0.00614743f, -0.01561422f, -0.07534100f, -0.07887420f, -0.03363463f, 0.10130226f, 0.03503605f, 
    -0.04622278f, -0.01404831f, -0.01251002f, 0.01640109f, 0.38890705f, -0.09880666f, -0.11288448f, -0.33133802f, 
    -0.03692288f, 0.00808049f, -0.05420842f, 0.04435765f, 0.07837604f, -0.01224095f, -0.04307767f, -0.00711662f, 
    0.12671158f, 0.27295163f, 0.02480529f, -0.07936472f, -0.16717951f, 0.16899286f, -0.20852834f, 0.01054300f, 
    -0.06256378f, 0.10636731f, 0.07625085f, 0.08165585f, -0.20993163f, -0.15972158f, 0.13557440f, 0.22372064f, 
    -0.15552589f, -0.00058639f, -0.04982563f, -0.08736880f, 0.00251197f, -0.18327737f, 0.00557981f, 0.15249600f, 
    -0.12428797f, 0.18284774f, 0.10261094f, -0.26631129f, 0.09318291f, -0.18854998f, 0.04952482f, 0.01630896f, 
    0.02267491f, 0.02390157f, 0.03978466f, -0.00504278f, -0.12507719f, -0.29999092f, -0.04694536f, -0.37961635f, 
    -0.02131845f, 0.16020253f, 0.09123679f, 0.06617763f, 0.07243817f, 0.02903129f, -0.05892987f, -0.06945674f, 
    0.02448411f, 0.05517216f, -0.03856298f, -0.06761887f, 0.03305348f, -0.02695859f, -0.02118478f, -0.00198997f, 
    -0.04477428f, -0.04786773f, -0.01101353f, -0.02961465f, -0.28282717f, -0.14678808f, -0.20189814f, 0.23039035f, 
    -0.01408956f, 0.09947371f, -0.08871911f, 0.08729035f, 0.00328578f, 0.03543838f, 0.00737951f, 0.00324937f, 
    0.11624987f, 0.12528281f, -0.18477131f, -0.11255487f, -0.00762369f, -0.02802332f, -0.01473014f, -0.04917341f, 
    -0.10441716f, 0.09471738f, -0.14835823f, 0.02539744f, -0.15073122f, 0.43169561f, 0.01070012f, 0.17808302f, 
    -0.16141760f, -0.24575770f, -0.01082807f, 0.12100744f, -0.00378621f, -0.00831186f, 0.01924786f, -0.06322113f, 
    0.06904443f, 0.02927553f, -0.14787988f, 0.16183348f, 0.07126064f, -0.08790293f, 0.03225436f, 0.03243821f, 
    -0.05112972f, 0.05889958f, -0.03127376f, 0.09047923f, 0.12843053f, 0.03279527f, 0.16843162f, 0.01433605f, 
    -0.07458276f, -0.06668235f, 0.03534690f, -0.14637795f, -0.03179102f, -0.01938888f, -0.20925629f, 0.02511015f, 
    -0.29167527f, 0.02027740f, -0.03962051f, 0.06292740f, 0.03731605f, 0.03199129f, 0.05427905f, 0.04309079f, 
    0.01599534f, 0.05693829f, -0.01313493f, 0.04733205f, -0.15901686f, -0.37699634f, -0.02698494f, 0.18302150f, 
    0.04818150f, 0.10772195f, -0.01210613f, 0.04124084f, -0.04299997f, 0.06328404f, -0.03746867f, -0.15800951f, 
    -0.23676465f, -0.07912432f, 0.16537292f, 0.14214942f, 0.11324032f, 0.06785896f, -0.20460315f, -0.18292531f, 
    -0.19710873f, -0.02008397f, -0.20323376f, -0.11268385f, -0.35377657f, -0.08520872f, 0.06884115f, 0.02977403f, 
    -0.12682329f, 0.12128692f, -0.10766132f, -0.09823487f, -0.01374719f, -0.02991155f, -0.14273547f, -0.07891745f, 
    -0.20952986f, -0.45652783f, -0.47892711f, 0.01576650f, 0.05941247f, 0.02155373f, 0.07852886f, -0.08595693f, 
    -0.02518558f, -0.05063496f, 0.02637402f, 0.02502289f, 0.02599272f, -0.16110802f, -0.31123990f, -0.29526982f, 
    0.09861445f, -0.18258744f, 0.06564848f, -0.00791005f, -0.07750052f, -0.11307485f, -0.03817450f, -0.06826799f, 
    0.10980996f, -0.16855641f, -0.23259920f, 0.11752821f, -0.03689602f, -0.21868105f, 0.05666244f, -0.03648083f, 
    0.08432309f, -0.02854640f, 0.11953150f, 0.11520279f, -0.00264524f, -0.09683435f, 0.02019020f, -0.20137697f, 
    -0.02596036f, -0.05619312f, -0.07612824f, -0.08697292f, 0.01612497f, 0.06012751f, -0.05018664f, -0.01077111f, 
    -0.05863029f, -0.56966305f, -0.47671035f, 0.02518255f, 0.04573608f, 0.05173948f, 0.07775666f, 0.09452438f, 
    0.11591154f, 0.10079604f, 0.07085778f, 0.02268532f, 0.02559713f, -0.15614393f, -0.54923373f, -0.42558455f, 
    -0.00747689f, 0.06924862f, 0.15160522f, 0.05779548f, 0.05978611f, -0.00205076f, -0.02465899f, -0.06831183f, 
    -0.01383358f, 0.10085207f, -0.02630063f, 0.00986885f, 0.04884738f, -0.11120214f, -0.04829990f, -0.01791661f, 
    0.04783289f, 0.09313700f, 0.10213516f, 0.10875748f, -0.36305115f, -0.04913078f, 0.34788984f, 0.17174390f, 
    -0.07735923f, -0.06494407f, -0.06198255f, -0.00345616f, -0.02331793f, 0.07383446f, 0.13721901f, 0.16276903f, 
    -0.07161908f, -0.10602908f, -0.14903541f, 0.24493568f, -0.03709093f, -0.00873465f, 0.01010501f, 0.14237140f, 
    0.00283898f, 0.15627496f, -0.07696182f, -0.14788200f, 0.24919616f, -0.19714336f, -0.42984706f, -0.05573125f, 
    0.14454998f, -0.11997359f, 0.06397256f, -0.16441955f, -0.09727084f, 0.08028001f, 0.08196422f, -0.01144098f, 
    0.24523763f, 0.15384063f, -0.13413845f, -0.28196236f, -0.05074412f, -0.19351289f, 0.02431272f, -0.06096672f, 
    0.06244799f, 0.00110863f, 0.03734817f, 0.06911071f, -0.30763325f, -0.10173391f, 0.01936312f, 0.15215977f, 
    -0.02701639f, -0.04411745f, 0.04114088f, 0.00299653f, 0.10539691f, -0.07365390f, 0.15079276f, -0.01069724f, 
    -0.37826684f, -0.21829812f, 0.23609437f, 0.06894843f, -0.12933961f, 0.08969638f, -0.14512177f, -0.04311845f, 
    0.01750681f, 0.02273927f, 0.11334965f, 0.07730222f, -0.04317715f, -0.11063164f, 0.02921739f, 0.10075443f, 
    0.05381525f, 0.04912991f, 0.02437359f, 0.06472987f, -0.33797854f, -0.21689413f, -0.13476713f, -0.38324729f, 
    -0.35178953f, 0.18079342f, 0.12493762f, 0.02588997f, -0.04459376f, 0.00476334f, -0.05399460f, 0.01857130f, 
    -0.03138787f, -0.06807029f, 0.01228099f, -0.00220491f, -0.17413613f, -0.07818071f, -0.05296771f, -0.17274091f, 
    -0.07236963f, -0.01250650f, 0.01971685f, -0.05921661f, 0.07278976f, 0.15298790f, 0.08841248f, 0.08383496f, 
    -0.17634438f, 0.00457480f, 0.02009790f, -0.03430215f, -0.06476246f, -0.03104721f, -0.03383457f, -0.02901352f, 
    -0.19149221f, -0.10491730f, -0.12634939f, -0.14545789f, -0.30862653f, -0.28148189f, -0.18588759f, -0.06812588f, 
    -0.03782601f, 0.17061973f, 0.10920279f, 0.12475210f, 0.03289238f, 0.01433383f, -0.03246778f, -0.10554633f, 
    -0.14156964f, 0.00809823f, -0.06591048f, 0.02324234f, 0.00178060f, 0.06066911f, 0.05122134f, 0.06448621f, 
    0.09130064f, -0.00019049f, 0.09550711f, 0.06814802f, -0.32769868f, 0.15072300f, 0.18583125f, 0.09800860f, 
    -0.14826274f, 0.07112531f, -0.00364874f, 0.05413687f, -0.10294412f, 0.04958846f, 0.14167435f, -0.02092368f, 
    -0.40924084f, -0.39593512f, -0.11924335f, 0.35606784f, 0.03366540f, 0.10090059f, 0.23732540f, 0.08737905f, 
    0.12090000f, -0.01649498f, -0.05976348f, 0.12829822f, -0.38033906f, -0.04655362f, -0.00975635f, -0.07811513f, 
    -0.05268882f, -0.09250636f, -0.06677143f, -0.04768922f, -0.14022458f, -0.13398309f, -0.31584278f, -0.38320115f, 
    0.18566114f, 0.29874954f, 0.14209157f, 0.07328201f, 0.00387003f, 0.00436991f, 0.02286422f, 0.00726447f, 
    -0.04002630f, -0.02922625f, 0.00657842f, 0.02758314f, 0.02172366f, -0.01730079f, 0.07980850f, 0.03425991f, 
    0.24640368f, 0.12075780f, 0.03111142f, 0.15220232f, -0.17197362f, -0.13411736f, -0.14750516f, -0.05456703f, 
    -0.08392321f, -0.41267213f, -0.24836364f, 0.23417099f, 0.00692476f, -0.01558523f, -0.03004755f, 0.10196114f, 
    -0.01972181f, -0.01735132f, 0.01729608f, 0.04735917f, 0.64635044f, 0.28067449f, 0.03026550f, -0.23472339f, 
    -0.15316063f, -0.30742168f, -0.10415468f, -0.02791156f, 0.08000100f, 0.07505483f, 0.04295267f, 0.10131598f, 
    -0.09703083f, -0.14140813f, -0.16560568f, -0.09411878f, -0.04122159f, 0.09834145f, 0.04223540f, 0.03160304f, 
    0.05717170f, 0.12518542f, 0.00773125f, 0.10110943f, 0.06065502f, -0.23049119f, -0.17023529f, -0.03644068f, 
    0.01519281f, 0.04733390f, -0.00290664f, 0.15738648f, -0.10491858f, -0.18652233f, -0.12300844f, -0.07062010f, 
    0.20377283f, -0.27271518f, -0.20235625f, -0.06444982f, 0.16794433f, -0.04789671f, -0.10154643f, -0.10069352f, 
    -0.00078969f, 0.09269138f, 0.12062122f, 0.03254111f, 0.28567314f, -0.01288081f, -0.18786633f, -0.21087253f, 
    0.12221870f, -0.01276608f, -0.02267275f, 0.19002077f, 0.17136571f, -0.01527917f, 0.08845368f, -0.15115067f, 
    -0.12000190f, -0.31006151f, -0.16440095f, 0.23953827f, 0.03790552f, 0.19953975f, 0.10461316f, 0.00033843f, 
    -0.02753105f, -0.06121352f, -0.04742395f, -0.13919190f, 0.17351140f, -0.01384956f, -0.15050928f, -0.03951487f, 
    -0.01102073f, 0.15970239f, 0.08196174f, -0.18963823f, 0.07444932f, -0.11064517f, -0.01672083f, -0.05947207f, 
    -0.06300799f, 0.01562484f, 0.07026595f, 0.03054081f, 0.02738908f, 0.05048860f, 0.00162330f, -0.09353100f, 
    -0.03987972f, 0.03756255f, -0.02479303f, 0.00326558f, -0.07909213f, 0.01008777f, 0.17756046f, 0.03692237f, 
    -0.00232538f, 0.00318268f, 0.00516061f, -0.12273008f, -0.05428337f, -0.11394937f, -0.04327692f, -0.11690575f, 
    -0.58244127f, -0.04108490f, 0.06529273f, 0.07811242f, -0.01130421f, 0.02858244f, -0.04115620f, -0.00938036f, 
    0.01974487f, 0.00124051f, 0.20731436f, 0.07212370f, -0.12507997f, -0.15761155f, -0.18233301f, 0.19379428f, 
    -0.07894195f, 0.01228816f, 0.14411329f, -0.06225738f, 0.00731003f, 0.09264436f, 0.18605801f, 0.09545784f, 
    -0.23225778f, 0.12501356f, -0.01068791f, 0.05074390f, 0.00293236f, -0.04273484f, -0.06246602f, 0.01063332f, 
    -0.00748696f, 0.02283620f, -0.00798353f, -0.05176958f, 0.00641317f, -0.40274948f, -0.45285437f, -0.44732764f, 
    0.01503753f, -0.03303766f, -0.01992290f, -0.08508482f, 0.02577597f, -0.00056161f, -0.03192315f, -0.03583397f, 
    0.11559951f, 0.13421862f, 0.24383661f, -0.09676980f, 0.08738681f, -0.00517697f, -0.05290066f, 0.01686213f, 
    -0.01045114f, -0.02954745f, 0.05513114f, 0.04794529f, -0.21258765f, -0.06933006f, -0.00295025f, 0.02502101f, 
    0.09921228f, 0.02732174f, 0.08948252f, -0.02118224f, 0.07257366f, 0.01672706f, -0.00413679f, -0.06674214f, 
    0.02564154f, 0.04244676f, 0.07766333f, -0.05678790f, 0.08100396f, -0.07126665f, -0.08047948f, 0.00697482f, 
    -0.04042632f, 0.00120823f, -0.06057004f, 0.02603524f, 0.07774279f, -0.01746689f, -0.11197776f, -0.19882651f, 
    0.03918039f, 0.06561604f, -0.01704966f, 0.02539582f, 0.12438596f, 0.00653934f, 0.01321133f, 0.11169560f, 
    0.33346856f, -0.07162529f, -0.16547722f, -0.06809776f, -0.06307247f, 0.08498026f, 0.04635107f, 0.02128608f, 
    -0.16854471f, 0.06120382f, -0.20616066f, -0.28066024f, 0.43543017f, 0.10675307f, -0.13511615f, -0.17327759f, 
    0.10466687f, -0.08572216f, 0.03023094f, -0.01514676f, 0.10986257f, 0.04937728f, 0.05477369f, 0.07199217f, 
    -0.02866114f, 0.03562655f, -0.02260100f, 0.09086516f, -0.18210706f, 0.13271303f, 0.09026829f, 0.13979103f, 
    0.02726427f, -0.01126982f, -0.10732155f, 0.01838985f, 0.06681768f, -0.19289908f, -0.33186609f, -0.00160472f, 
    0.09350280f, 0.09159666f, 0.00391796f, 0.20669380f, -0.05800088f, 0.09365733f, 0.02741774f, -0.00288258f, 
    -0.49328083f, -0.30211502f, -0.13640359f, -0.02859125f, -0.03192757f, -0.00758618f, -0.11403052f, 0.21419831f, 
    0.03046509f, 0.04115310f, -0.00363277f, 0.06278022f, -0.02411712f, 0.03209912f, -0.02696361f, -0.02927716f, 
    -0.09130742f, 0.07489277f, 0.09471666f, 0.01951270f, -0.10797351f, 0.10841633f, 0.00432189f, -0.02265499f, 
    0.00508664f, -0.13509187f, -0.12289730f, -0.11778340f, 0.02233502f, 0.07499055f, -0.00233566f, 0.07485924f, 
    0.11249647f, 0.14937203f, 0.05897533f, 0.14156204f, -0.17695190f, -0.06801365f, -0.21193969f, 0.12535995f, 
    0.05466698f, -0.00684186f, 0.12839000f, 0.06698150f, 0.07763538f, 0.09018239f, 0.11080412f, 0.13742489f, 
    0.20408060f, -0.03455601f, 0.03262632f, -0.20158142f, -0.06091341f, 0.06076967f, 0.13521120f, 0.13396931f, 
    -0.01890120f, 0.08950035f, 0.08914239f, -0.08594102f, -0.27416626f, 0.08959324f, -0.05097476f, -0.09064974f, 
    0.15506904f, -0.04689350f, -0.01205292f, 0.12960362f, 0.05925572f, 0.07913536f, -0.07222793f, -0.12732142f, 
    -0.24126062f, 0.09577814f, -0.03721253f, 0.20004550f, -0.08504884f, 0.15044639f, -0.25728545f, -0.39894804f, 
    -0.15066925f, 0.03571654f, 0.01050162f, 0.00602250f, 0.07173326f, -0.13158129f, -0.16897261f, 0.13384791f, 
    0.14124420f, 0.05485678f, 0.15255162f, 0.04826607f, 0.01572743f, 0.00134366f, -0.06149786f, -0.21596763f, 
    0.17063874f, -0.01361891f, 0.00529826f, -0.13198608f, -0.04926550f, 0.03162705f, 0.00977639f, 0.10552941f, 
    -0.01694427f, -0.00973444f, 0.04927258f, 0.07946486f, 0.14765240f, -0.04181643f, -0.12275633f, 0.21167950f, 
    0.12954582f, -0.03559786f, 0.07101227f, 0.04668136f, -0.06610972f, -0.05152204f, 0.10282436f, 0.12100741f, 
    -0.04602765f, -0.17411074f, 0.09092623f, -0.12212381f, -0.12564886f, 0.03470932f, 0.13231409f, 0.05002108f, 
    0.15384686f, -0.03329023f, 0.03286785f, 0.08575908f, -0.73503476f, -0.04963122f, -0.18965653f, -0.13699213f, 
    -0.00446652f, 0.00769770f, -0.01053436f, 0.04385436f, -0.01948274f, -0.03247445f, 0.06281877f, 0.03562589f, 
    0.27226818f, -0.29981339f, 0.06456435f, -0.47177136f, -0.01333523f, 0.15181340f, -0.12215749f, 0.08071623f, 
    0.10456267f, 0.05667508f, -0.13530745f, 0.05556183f, -0.21999629f, -0.26792857f, 0.11021257f, -0.12827931f, 
    0.01842683f, 0.12376246f, 0.01880427f, 0.13037093f, -0.11319711f, -0.02936121f, 0.01136077f, 0.05505719f, 
    -0.07953309f, 0.12092654f, 0.12132077f, -0.37138185f, 0.05885554f, -0.04139844f, 0.14435044f, -0.05667432f, 
    0.08981206f, 0.02830884f, -0.01816425f, -0.05150750f, 0.08657303f, -0.03360429f, -0.10673914f, 0.04315165f, 
    -0.00015631f, -0.02166363f, 0.01358662f, -0.01417131f, -0.02151820f, 0.04961449f, 0.10005938f, 0.00005901f, 
    0.04315674f, 0.02362539f, -0.06726583f, 0.00624940f, -0.08109268f, 0.11020411f, 0.10292740f, 0.03347656f, 
    0.01555133f, 0.08550383f, -0.01958577f, -0.02268503f, 0.02665026f, -0.26572019f, 0.11404382f, -0.20998663f, 
    -0.05164763f, 0.09057728f, 0.00027501f, 0.17179573f, 0.13903233f, 0.02988704f, 0.05216349f, 0.13358913f, 
    -0.28892416f, 0.08843790f, 0.21650882f, -0.55018610f, -0.10221150f, -0.06887816f, 0.06874676f, 0.14632550f, 
    0.00712262f, 0.02112353f, 0.04516358f, -0.01114913f, -0.26773342f, -0.11453652f, 0.16799298f, -0.18801320f, 
    -0.07601574f, -0.15703037f, 0.05943911f, 0.06515788f, 0.01348240f, 0.03309839f, 0.08967976f, 0.03491274f, 
    0.23201801f, -0.05494243f, 0.35633525f, 0.08562949f, 0.08563767f, -0.14840081f, -0.03590601f, -0.00801568f, 
    -0.15655044f, -0.14698373f, 0.00670147f, -0.09236935f, 0.33360490f, -0.28251502f, 0.08478024f, 0.04644142f, 
    0.01411573f, 0.14275283f, 0.04375098f, 0.01093579f, 0.01127895f, 0.03456598f, -0.07868700f, -0.08658402f, 
    -0.29929453f, 0.14307687f, -0.23759118f, -0.23409769f, -0.21522164f, -0.25613853f, 0.01028435f, 0.03453762f, 
    0.07494844f, 0.07505731f, 0.06481511f, 0.02309881f, -0.01112413f, 0.03724961f, -0.13394596f, 0.46283332f, 
    -0.00532808f, 0.11897039f, -0.16759859f, 0.03425977f, -0.02523678f, -0.11135967f, 0.05347329f, 0.00366912f, 
    -0.43891180f, -0.03846092f, -0.22663777f, 0.02248491f, -0.11032578f, -0.02430190f, 0.02256261f, 0.03732697f, 
    -0.07970343f, -0.11767283f, 0.02001805f, -0.15924923f, -0.04296363f, -0.14437050f, -0.10853079f, -0.09725366f, 
    0.04095306f, -0.22641455f, 0.16468666f, -0.02431181f, 0.03716975f, 0.10066762f, 0.02822653f, 0.07137614f, 
    0.01378288f, 0.12124404f, -0.23623335f, 0.11491081f, -0.31565788f, 0.24717912f, -0.07578396f, -0.03761597f, 
    0.21967858f, 0.07594234f, -0.01182290f, -0.06967242f, -0.55434930f, -0.07610287f, 0.00539337f, 0.31103989f, 
    0.00798195f, -0.24009675f, 0.05064015f, -0.09694367f, 0.11117962f, -0.05366875f, -0.19468378f, -0.12571301f, 
    -0.33591437f, -0.11312370f, 0.11960416f, 0.13406219f, -0.05713526f, 0.13249044f, -0.17589664f, 0.17737660f, 
    0.05927256f, -0.05427989f, -0.02065578f, 0.01175779f, -0.16723913f, 0.23221669f, -0.10833447f, 0.12229013f, 
    0.04095867f, -0.12088785f, 0.08782574f, 0.00620760f, -0.18914604f, 0.03737539f, -0.01866843f, -0.02782490f, 
    0.13341932f, -0.35837522f, 0.01697934f, -0.35117641f, 0.04684939f, 0.01055554f, 0.04449083f, 0.06413136f, 
    0.03797838f, -0.01968279f, -0.07204455f, 0.05180461f, 0.06036223f, 0.15239739f, 0.25368732f, -0.00989116f, 
    -0.03809734f, -0.09733319f, -0.11936069f, -0.05032017f, -0.01692930f, 0.13154796f, 0.09776396f, 0.10758912f, 
    -0.18961732f, -0.02626841f, 0.00740724f, -0.15933378f, 0.15233470f, -0.05760019f, 0.08389891f, -0.07172301f, 
    -0.00879022f, -0.00545359f, 0.03059596f, 0.11113269f, -0.22410399f, 0.21296909f, 0.00868757f, 0.29727590f, 
    0.01396997f, 0.01022780f, 0.06215330f, -0.01602303f, 0.03962517f, 0.10961649f, 0.07401405f, -0.02763312f, 
    -0.04898784f, -0.03535324f, -0.15516275f, -0.02211651f, 0.08279528f, 0.09092810f, 0.15586844f, -0.01593148f, 
    0.08227439f, 0.03649047f, -0.02780387f, 0.13172461f, -0.08052529f, 0.18635041f, 0.00746244f, 0.08024164f, 
    -0.01775023f, -0.12267885f, -0.10626528f, -0.19559182f, 0.09899122f, -0.03803660f, 0.04034654f, 0.12259039f, 
    -0.03653845f, 0.12630959f, -0.14000899f, -0.08967321f, 0.07428555f, -0.04943179f, 0.06648055f, 0.06633388f, 
    0.18075150f, -0.02194323f, -0.06087569f, 0.06864049f, -0.24223091f, 0.15879998f, -0.11312037f, -0.45530921f, 
    0.02636450f, 0.04243695f, 0.08650364f, 0.04476182f, 0.05959157f, 0.04485342f, 0.03572427f, 0.07004667f, 
    0.31240991f, 0.05021879f, 0.07394254f, -0.37281308f, 0.00180256f, -0.05350450f, -0.24635506f, 0.03480415f, 
    0.05254230f, -0.06294797f, 0.03024787f, 0.10037551f, 0.02695427f, -0.16574991f, 0.06895818f, -0.01954154f, 
    0.02807586f, 0.09759568f, 0.12711330f, 0.02069584f, 0.07426410f, 0.10267705f, 0.13649131f, 0.21316254f, 
    -0.48665509f, -0.01602587f, -0.81902277f, 0.26929125f, 0.17933200f, -0.01753921f, 0.09011507f, -0.08413740f, 
    0.05221099f, -0.00350729f, 0.02500497f, -0.00979848f, 0.17863773f, 0.15105496f, -0.02923381f, -0.14827685f, 
    0.06942916f, -0.17280535f, 0.00217048f, 0.09365694f, 0.04928135f, 0.00706180f, 0.03393620f, -0.01186430f, 
    -0.43681487f, 0.05238482f, -0.19637348f, 0.01666912f, -0.01968613f, -0.06404734f, -0.04171954f, 0.15570083f, 
    -0.01564438f, -0.03470549f, -0.00490159f, -0.01260538f, -0.60271311f, -0.85148561f, -0.03186471f, -0.14643182f, 
    0.03315094f, 0.08808428f, -0.16236605f, 0.20592791f, -0.08238035f, -0.05112145f, 0.05356453f, -0.13884965f, 
    0.11007122f, 0.32941720f, -0.04378976f, 0.47323123f, 0.10506683f, -0.04858244f, -0.17551014f, -0.04366874f, 
    -0.08272239f, -0.11503302f, -0.06997322f, -0.08380628f, -0.11003315f, 0.12579510f, 0.24943784f, 0.09243280f, 
    -0.06417062f, -0.29891849f, -0.13565214f, -0.02284872f, -0.07875848f, 0.03904685f, 0.07325415f, 0.07807370f, 
    0.16151737f, 0.25812578f, -0.34602010f, -0.13786112f, -0.08733930f, -0.12010816f, 0.05495815f, 0.03224291f, 
    0.09426684f, 0.05222589f, 0.02651741f, 0.02722119f, -0.69341385f, -0.00721716f, -0.21250699f, 0.22140972f, 
    -0.12024737f, -0.08230750f, -0.14417106f, -0.10923972f, 0.20017561f, -0.03128095f, 0.03160812f, 0.00254861f, 
    0.14245994f, -0.09634629f, 0.00013466f, -0.07548481f, 0.02093538f, 0.04109942f, -0.06721747f, 0.08871016f, 
    0.17783254f, 0.01882423f, 0.03376566f, -0.01331723f, -0.06152190f, -0.43142706f, 0.15073112f, -0.15109071f, 
    0.06903327f, 0.10263892f, -0.12181455f, 0.15851459f, 0.14783877f, 0.09584089f, 0.05912520f, 0.02909517f, 
    0.00687525f, -0.38511187f, -0.20873480f, -0.18969734f, 0.31252983f, 0.07113110f, 0.20216683f, -0.00387804f, 
    0.01575935f, -0.09238048f, -0.00036955f, -0.02247778f, 0.06903701f, -0.22978185f, -0.05963738f, -0.07388926f, 
    0.13466476f, 0.05449965f, 0.14702116f, 0.16680831f, 0.06012383f, 0.01051397f, -0.00364481f, 0.01545372f, 
    -0.27874619f, 0.12076303f, -0.31158051f, -0.05378666f, -0.04161497f, 0.05108156f, 0.05885036f, 0.01828292f, 
    0.09373847f, 0.01897677f, -0.09444578f, -0.10688572f, -0.08482826f, 0.04477606f, -0.00173841f, -0.32631755f, 
    -0.08305133f, -0.04440697f, 0.07750902f, -0.03516118f, -0.08082693f, 0.11500712f, -0.13442507f, 0.07751753f, 
    -0.03967489f, -0.15931420f, -0.07496750f, 0.06960373f, 0.04472215f, 0.11762561f, 0.07154317f, -0.02880733f, 
    0.02412231f, 0.05849198f, 0.04639684f, -0.04727779f, -0.17644693f, 0.03804099f, 0.02382746f, -0.04277422f, 
    0.08680619f, -0.17006482f, 0.04158872f, 0.15153325f, 0.07022427f, 0.00719722f, 0.07827377f, -0.01757620f, 
    -0.06017189f, -0.27607635f, 0.14836021f, -0.71971434f, 0.00554000f, -0.16461727f, 0.05318271f, -0.07289173f, 
    -0.19954836f, -0.02326460f, 0.10216774f, -0.26880923f, 0.14842862f, 0.00894120f, 0.33980328f, -0.38302916f, 
    -0.06007782f, -0.16032463f, -0.05815401f, -0.00743363f, -0.08650547f, 0.05849139f, 0.12288112f, -0.01480683f, 
    0.28206384f, -0.19508187f, -0.16054551f, -0.05234443f, 0.07992756f, 0.15913075f, 0.03671886f, -0.01534842f, 
    0.12310620f, -0.10636539f, -0.07813930f, 0.07551061f, 0.20733523f, 0.22283100f, 0.01464281f, 0.24445595f, 
    0.03462749f, -0.05247755f, -0.10896777f, -0.17921078f, 0.11354639f, -0.01276763f, 0.00257474f, -0.03756822f, 
    -0.33613187f, 0.12724583f, 0.14424622f, 0.32450485f, 0.07270712f, -0.06923364f, -0.11350703f, -0.26120466f, 
    0.09003056f, 0.06546897f, -0.07523549f, 0.05982663f, -0.00367048f, -0.49641111f, 0.25065130f, -0.02607841f, 
    0.12067778f, -0.15730937f, 0.03783530f, 0.03169399f, 0.04151198f, -0.08218192f, -0.10016165f, -0.13259374f, 
    -0.22469683f, 0.11625530f, -0.01208579f, -0.11615742f, -0.09925167f, 0.00921299f, 0.01141859f, 0.01849337f, 
    0.06629547f, -0.01711840f, -0.07934435f, -0.05001338f, -0.05462060f, 0.36043307f, 0.05659509f, 0.02927031f, 
    -0.01213832f, -0.20326357f, -0.05452048f, -0.05826472f, 0.17899388f, 0.13714837f, 0.00546802f, -0.01608993f, 
    -0.05901454f, 0.10777526f, 0.03408454f, -0.30848411f, 0.04491555f, -0.23819013f, 0.21180038f, 0.26417965f, 
    -0.01826753f, 0.06030075f, -0.00457144f, -0.03469669f, -0.54003209f, 0.18255150f, -0.15073715f, 0.30701730f, 
    -0.01949903f, -0.07458786f, -0.10211577f, 0.04313558f, 0.10464066f, -0.11293206f, -0.01594405f, 0.10624547f, 
    0.15343189f, 0.06146869f, 0.15774061f, 0.12378871f, 0.06365681f, -0.01224652f, -0.17479114f, -0.02396232f, 
    -0.05218836f, -0.31317183f, -0.18025695f, -0.07554504f, 0.32118794f, 0.10683575f, 0.41206670f, -0.00944722f, 
    0.09533906f, -0.05401696f, -0.14650846f, -0.14674841f, 0.06379447f, 0.05400774f, -0.14701933f, 0.11103556f, 
    -0.21271016f, 0.18828788f, -0.28693599f, -0.17198551f, -0.21550190f, -0.01393699f, -0.07912025f, 0.01566173f, 
    -0.02070676f, -0.15392600f, 0.03223413f, -0.01489419f, 0.01579116f, 0.02971060f, -0.26263767f, 0.09407453f, 
    -0.06310751f, 0.00134879f, 0.02648801f, -0.01690976f, -0.00118390f, 0.08640750f, 0.07199757f, 0.02340221f, 
    -0.11059449f, -0.27042937f, -0.02497249f, -0.21226569f, 0.11890733f, 0.00314159f, -0.00252591f, 0.14921871f, 
    0.01956030f, -0.11402724f, -0.07026732f, 0.00555668f, 0.23920341f, -0.16018148f, 0.09699292f, -0.02127473f, 
    -0.07653960f, 0.02843991f, -0.12078943f, -0.10419501f, 0.15894701f, -0.02021851f, 0.04221466f, 0.03561080f, 
    0.20604660f, -0.05519538f, 0.09646206f, -0.14756438f, 0.16650763f, 0.02245857f, -0.24187154f, 0.01134735f, 
    0.01237886f, -0.07851493f, 0.02899051f, 0.03034544f, -0.14504948f, 0.53852922f, -0.36127838f, -0.16134755f, 
    -0.09277061f, -0.08363605f, 0.07773745f, -0.10579027f, 0.06718497f, 0.07521670f, -0.10595261f, 0.03785999f, 
    0.12978944f, -0.02967960f, 0.15031365f, 0.16674367f, 0.08805247f, 0.01239620f, -0.29129940f, 0.07959991f, 
    -0.03385333f, -0.08599196f, 0.01430131f, 0.06932753f, -0.14859919f, -0.08216126f, 0.03499049f, -0.07140178f, 
    0.02666541f, 0.10956416f, 0.09216752f, 0.03939509f, 0.10903728f, -0.00029541f, -0.01126742f, -0.01095035f, 
    -0.10902622f, 0.08207775f, 0.07018812f, 0.24558631f, 0.06628370f, -0.07249478f, 0.05335031f, -0.00997932f, 
    -0.04023271f, 0.00838022f, 0.09488626f, 0.02380474f, -0.27144173f, 0.05494038f, -0.08768192f, -0.18407370f, 
    -0.18024310f, 0.12280180f, -0.35788095f, -0.03994063f, 0.07980281f, -0.28189015f, -0.02191580f, 0.01610380f, 
    0.09755532f, -0.02332694f, 0.31816515f, 0.00200871f, -0.09057326f, -0.09911595f, 0.10003679f, -0.03021647f, 
    -0.02530022f, 0.03042981f, 0.17096142f, 0.05366099f, 0.11581306f, -0.13531852f, -0.14216308f, -0.10504965f, 
    -0.01667974f, 0.03991465f, 0.10215092f, 0.07338274f, 0.05883811f, -0.00680811f, -0.23951386f, -0.25543240f, 
    0.04360696f, -0.33175337f, 0.06398973f, 0.03596909f, -0.12134141f, -0.19806799f, -0.03116679f, 0.01931337f, 
    -0.10201571f, -0.10975192f, -0.13300441f, 0.06804580f, 0.03976497f, -0.15067703f, 0.13107757f, 0.11805867f, 
    0.00217543f, 0.01778494f, -0.12824069f, -0.06632145f, -0.12922476f, -0.13184427f, -0.03745981f, -0.01992641f, 
    -0.16172057f, -0.17418557f, -0.03066608f, 0.06404547f, -0.06636632f, -0.20164892f, -0.14957036f, 0.10809676f, 
    0.07071261f, 0.06675685f, 0.02572080f, 0.08614464f, -0.15364656f, -0.04166064f, -0.27726921f, -0.13066915f, 
    -0.03708325f, -0.04002546f, -0.05947102f, -0.02123425f, -0.02599956f, 0.02832979f, -0.03325446f, -0.07695670f, 
    -0.27804846f, 0.14219387f, 0.25757384f, -0.08208674f, -0.12735870f, -0.07353032f, 0.02218856f, -0.09038770f, 
    0.03377711f, 0.07539587f, -0.08661191f, -0.12592606f, -0.34010929f, -0.01370949f, -0.10361341f, 0.02321020f, 
    0.05487705f, 0.05789352f, 0.00583559f, -0.10277785f, 0.04257838f, -0.00218731f, 0.08989514f, -0.02223178f, 
    0.07444874f, -0.12538803f, 0.32031485f, -0.09259642f, -0.13896605f, 0.12868974f, 0.05086107f, 0.13758442f, 
    0.03254887f, 0.04047535f, 0.18186530f, 0.10057101f, -0.08721950f, 0.49233800f, -0.27981222f, 0.04527836f, 
    0.11486506f, 0.08306019f, 0.05641087f, 0.01133776f, 0.01437326f, 0.03723131f, -0.08516153f, -0.05144121f, 
    0.24629059f, -0.18020487f, 0.05278380f, 0.08044057f, -0.24624865f, -0.04040515f, 0.13311879f, 0.03951282f, 
    0.09677909f, 0.08114166f, 0.01762807f, 0.15035473f, 0.02867944f, -0.22733240f, -0.08067862f, 0.15208136f, 
    -0.13892913f, 0.07709916f, -0.04939763f, -0.06482425f, 0.11915101f, 0.10468008f, -0.28997588f, 0.13204151f, 
    0.18156634f, -0.17311044f, 0.08227079f, 0.07163697f, -0.04539810f, -0.02386396f, -0.02746985f, -0.05395451f, 
    -0.17166366f, 0.14940152f, -0.00819432f, -0.02751038f, -0.10085861f, -0.08161693f, 0.28617817f, 0.10624497f, 
    -0.12620550f, 0.20863900f, 0.08784228f, -0.04914445f, -0.15627939f, -0.05132816f, 0.02828442f, 0.06921610f, 
    -0.05817750f, 0.12703608f, -0.02678012f, 0.03919464f, -0.05946837f, 0.04303554f, -0.16768417f, -0.02103920f, 
    0.00706859f, -0.04828301f, 0.03475410f, 0.02235224f, 0.04837212f, -0.05850200f, 0.07187713f, 0.21773423f, 
    0.03736887f, 0.08105410f, 0.14894159f, -0.05525623f, 0.02317602f, 0.06334215f, 0.15023194f, 0.04820552f, 
    -0.12013590f, 0.19765179f, 0.12993395f, 0.08923256f, 0.05917971f, -0.13059339f, -0.04151648f, 0.03035138f, 
    -0.03789866f, 0.08266589f, -0.06209627f, -0.04721259f, 0.02425062f, -0.00709244f, -0.11800803f, -0.09153455f, 
    0.05247071f, -0.18047500f, -0.07466937f, 0.09740841f, -0.11228066f, -0.19456966f, -0.33805045f, -0.24087334f, 
    -0.12954220f, 0.12531404f, 0.16223429f, -0.04974738f, -0.04742388f, -0.04446640f, 0.00680353f, -0.05961901f, 
    -0.01133648f, 0.08413380f, 0.02693133f, -0.06018550f, 0.07150696f, -0.37983572f, -0.05895494f, -0.40174621f, 
    -0.02532057f, -0.11697678f, -0.03342640f, -0.00449879f, 0.01051297f, 0.05234623f, 0.00094351f, 0.01676612f, 
    0.00218209f, -0.00411127f, -0.03980275f, -0.05636299f, -0.14729327f, -0.18852073f, -0.00764752f, -0.08107828f, 
    -0.17559206f, 0.09038434f, -0.17116988f, 0.03534266f, 0.40237704f, -0.14675474f, 0.07925405f, -0.28834435f, 
    0.01134006f, -0.20428064f, -0.02255365f, 0.02839061f, -0.15540391f, 0.12980124f, -0.04814395f, -0.10808858f, 
    0.06048531f, -0.07394041f, 0.30497450f, -0.01550231f, -0.05043554f, 0.00012912f, -0.11099353f, -0.02423747f, 
    0.02676745f, 0.12772439f, 0.18350962f, 0.14794053f, 0.19050786f, -0.21507792f, 0.17765009f, -0.16303287f, 
    -0.07865930f, -0.10272588f, 0.09619019f, 0.03025130f, 0.11754869f, -0.13213596f, 0.03480532f, -0.02290380f, 
    -0.11666742f, 0.08244821f, 0.14571713f, 0.10314801f, -0.06820433f, -0.00326924f, -0.04859000f, 0.08074932f, 
    -0.10607303f, 0.06832989f, 0.04318225f, -0.02324637f, -0.02482043f, 0.05606893f, -0.09455612f, -0.08481088f, 
    -0.07512125f, -0.11033961f, 0.00533091f, -0.04071015f, -0.15741211f, -0.15002163f, -0.03903483f, -0.17554681f, 
    0.07901817f, -0.12521747f, 0.01138979f, -0.08497847f, -0.16655715f, 0.14754502f, 0.00041586f, -0.08526034f, 
    -0.04954644f, 0.11719336f, 0.03288053f, 0.01987419f, -0.13116845f, 0.17309156f, -0.19879635f, -0.13512567f, 
    -0.01374745f, 0.03300966f, 0.18451187f, -0.08274878f, -0.07500267f, -0.00111923f, -0.18073034f, -0.10317459f, 
    -0.24893709f, 0.10740881f, 0.16345470f, 0.19639668f, -0.02526471f, 0.10908080f, -0.06869815f, 0.07850914f, 
    0.01401518f, 0.13793077f, 0.08911307f, 0.07955526f, -0.38792220f, -0.06608871f, -0.22570632f, 0.15950061f, 
    -0.02035590f, 0.12640342f, 0.08709200f, 0.06552745f, -0.02060226f, 0.05344972f, -0.04835544f, 0.10261753f, 
    -0.17662886f, 0.43579927f, 0.00325135f, 0.02561250f, 0.10669415f, -0.07556447f, 0.02190601f, -0.02908386f, 
    -0.03959723f, 0.19306748f, 0.16215023f, 0.11885174f, -0.24517295f, 0.05976749f, 0.04405647f, 0.00045408f, 
    0.04033160f, 0.03074900f, -0.12072477f, 0.00062773f, -0.01054763f, -0.05159163f, -0.05533738f, -0.13160916f, 
    -0.25043446f, -0.08372555f, 0.03997986f, 0.13085359f, -0.03617412f, 0.01400016f, -0.06289529f, -0.14572914f, 
    0.01666261f, 0.14278010f, 0.05337569f, 0.09142783f, 0.08179750f, -0.16357847f, 0.41940328f, -0.29714921f, 
    -0.18307512f, 0.04814032f, 0.14451018f, 0.04541409f, -0.09849943f, 0.06695512f, 0.04404279f, -0.09019079f, 
    -0.02096424f, -0.06968483f, -0.05578336f, -0.04643250f, 0.00311537f, 0.02059183f, -0.08889384f, 0.08875038f, 
    -0.05874517f, 0.07828891f, -0.16431129f, -0.44462848f, -0.29040128f, 0.04335104f, -0.02014849f, -0.07096863f, 
    0.02408227f, 0.15591288f, -0.26264119f, -0.07130423f, -0.14056827f, -0.18795440f, -0.04693267f, -0.17689200f, 
    -0.21197137f, -0.06070600f, 0.08149614f, -0.18834706f, -0.08185954f, 0.06948347f, -0.12475845f, 0.05991299f, 
    -0.05316003f, -0.03402293f, 0.11545116f, -0.05552693f, -0.05511903f, 0.13040318f, -0.07919892f, -0.17654066f, 
    -0.14081642f, -0.04923183f, -0.01382160f, 0.01757306f, -0.01975887f, -0.03103119f, -0.27569020f, -0.20879395f, 
    0.10502250f, -0.42998213f, 0.20032449f, 0.07025447f, -0.15207151f, 0.06514064f, 0.06235500f, -0.02269946f, 
    0.07657617f, 0.02979706f, 0.10129221f, 0.01444611f, 0.20814937f, 0.11263803f, 0.19257726f, -0.10388946f, 
    -0.15710394f, 0.04907654f, 0.09216715f, 0.02431063f, -0.00460480f, 0.05571240f, 0.16712321f, 0.06712749f, 
    -0.17998590f, 0.03877531f, -0.23132974f, -0.04151357f, -0.10195543f, -0.02917841f, -0.01602783f, 0.00585229f, 
    -0.11189775f, -0.07024550f, 0.11192439f, 0.03273950f, -0.09546848f, -0.05684342f, -0.25974110f, 0.10366640f, 
    0.04632977f, -0.00071385f, -0.02928706f, -0.00838737f, 0.03019628f, 0.09054388f, -0.00218547f, -0.04891291f, 
    -0.04649342f, 0.10840698f, -0.08755417f, 0.29678160f, -0.25037351f, -0.03321563f, -0.04970411f, 0.22004452f, 
    0.05894502f, 0.00204623f, -0.15502433f, -0.08729209f, -0.28149810f, 0.14316984f, 0.02274309f, 0.13261621f, 
    0.10284678f, 0.06429965f, -0.11091815f, 0.09700828f, -0.17455201f, -0.01731350f, -0.15202719f, -0.14825973f, 
    -0.26814452f, -0.02457264f, -0.13884166f, 0.07106311f, -0.12104297f, 0.12899075f, 0.00673794f, -0.07340416f, 
    -0.02556349f, 0.02676693f, -0.02021592f, 0.09857095f, -0.20714702f, 0.10963859f, 0.04272734f, -0.18293028f, 
    0.00398063f, 0.10242804f, 0.04560661f, -0.07424327f, -0.07005479f, -0.05265591f, 0.03983433f, -0.02208865f, 
    0.59554601f, -0.24422441f, 0.09222027f, -0.03523280f, -0.07596644f, 0.11685064f, 0.06905840f, -0.00130936f, 
    -0.08608895f, -0.02721791f, -0.29744929f, -0.08663508f, -0.48922172f, 0.37045649f, 0.03164817f, 0.05880515f, 
    -0.00450189f, -0.02486255f, -0.07007749f, 0.16462016f, -0.12629840f, -0.06246218f, 0.04949616f, -0.05878803f, 
    0.05953759f, -0.30250478f, 0.21430281f, -0.00044219f, -0.05683776f, 0.06738125f, 0.10967737f, 0.03727219f, 
    -0.01490486f, -0.13453256f, -0.07901052f, -0.00574864f, 0.04373457f, -0.12704752f, 0.12009092f, 0.12695995f, 
    -0.07958982f, 0.01240233f, 0.03002316f, -0.10757042f, 0.02919401f, -0.11436540f, -0.05917488f, 0.12942463f, 
    -0.27118257f, -0.27455887f, 0.05152657f, 0.02463014f, -0.07606113f, -0.01526559f, 0.01218920f, -0.02491229f, 
    0.01842912f, 0.15082306f, 0.10867474f, 0.01147169f, 0.49372622f, -0.18064846f, 0.22987895f, -0.05165732f, 
    -0.13767087f, -0.05271899f, 0.03835690f, 0.07678578f, -0.18076445f, 0.02266863f, -0.09693199f, -0.09703939f, 
    -0.05501987f, 0.16819483f, -0.02653445f, -0.02468988f, -0.10563302f, 0.07704537f, 0.09283726f, -0.02685398f, 
    0.11241110f, 0.17075494f, 0.04000380f, 0.15725651f, -0.06108229f, 0.04777456f, 0.05465716f, -0.05889945f, 
    -0.01396680f, -0.01466191f, -0.07663553f, -0.05415757f, -0.08177008f, 0.00765469f, 0.13627669f, -0.05815261f, 
    0.26449153f, 0.22421345f, 0.06836107f, -0.01230501f, -0.10595365f, 0.02949529f, 0.08802167f, 0.05937085f, 
    -0.04944811f, 0.16415696f, -0.09024439f, 0.00386236f, -0.06360935f, 0.03066585f, -0.30559316f, -0.02136104f, 
    0.02433942f, -0.03293233f, 0.20857508f, 0.06826732f, -0.17769037f, -0.13705349f, -0.01857741f, -0.07999609f, 
    -0.20682061f, -0.18768056f, 0.40727881f, 0.11226841f, -0.23808873f, 0.14066301f, -0.14908201f, 0.09307607f, 
    0.08075985f, -0.09529062f, 0.21477695f, 0.06346177f, -0.21354596f, 0.13274515f, -0.29692331f, 0.02130318f, 
    0.09400674f, 0.06964925f, -0.06945039f, 0.06590788f, 0.03620638f, -0.06698716f, -0.14111309f, -0.30894917f, 
    -0.06152620f, -0.14519089f, 0.04688290f, 0.05204439f, -0.07662677f, 0.17864782f, 0.01277849f, 0.05435070f, 
    -0.08955775f, 0.11167264f, -0.03659369f, 0.00638841f, -0.02625185f, -0.04231743f, 0.26421919f, 0.00753280f, 
    -0.13232970f, 0.07913408f, -0.00445979f, 0.17126340f, 0.00668859f, -0.05081352f, 0.17703244f, 0.16751595f, 
    0.03081673f, 0.13422352f, 0.04319378f, 0.11068594f, -0.08487351f, 0.01512200f, -0.26798812f, 0.08444628f, 
    0.11456046f, -0.05650460f, 0.05378107f, 0.06769641f, -0.00059877f, -0.25275862f, 0.26200819f, -0.05353921f, 
    -0.02959380f, -0.06933914f, 0.02016741f, 0.07306810f, 0.06236117f, -0.08678307f, -0.02759091f, -0.13228677f, 
    -0.22699417f, 0.31547144f, -0.15907836f, 0.15405081f, 0.05642537f, 0.12218203f, 0.04363643f, -0.15613578f, 
    -0.04688542f, -0.06000186f, 0.00002873f, -0.10774267f, -0.16856924f, 0.16505291f, -0.24185631f, -0.16610314f, 
    0.03246671f, 0.01977826f, 0.12842883f, 0.05469991f, 0.03905916f, 0.01322386f, 0.04836923f, 0.08976921f, 
    -0.01138689f, -0.15061085f, 0.14000766f, 0.02965819f, -0.07707885f, 0.12263720f, -0.14029464f, 0.06948064f, 
    -0.13847616f, -0.04999274f, 0.08369014f, 0.03337011f, -0.07945660f, -0.07713578f, -0.00204012f, -0.37720338f, 
    0.02292541f, -0.01643405f, -0.07872716f, -0.08122291f, 0.01678281f, -0.01982089f, 0.05580283f, 0.11423614f, 
    0.10387261f, 0.15596797f, 0.23165092f, -0.10675910f, -0.15038317f, 0.06500103f, -0.02458113f, -0.03052901f, 
    -0.02506045f, -0.03715478f, 0.05153190f, 0.08031881f, -0.25032452f, 0.26650947f, -0.23423898f, 0.10878391f, 
    -0.16184665f, -0.07836345f, 0.12360522f, 0.12486771f, -0.07350432f, -0.00363338f, -0.03204539f, 0.05423289f, 
    -0.04708016f, -0.05815684f, -0.09821234f, -0.22602122f, -0.13727728f, -0.15968622f, 0.13761686f, -0.05599921f, 
    0.04777040f, 0.11323120f, -0.03591117f, -0.14035599f, -0.03960964f, -0.24476561f, -0.29895258f, -0.23535238f, 
    0.01744251f, -0.27301961f, 0.00195360f, -0.11668555f, 0.02574981f, 0.05296006f, -0.03311555f, 0.03258995f, 
    -0.03575977f, -0.15229020f, -0.03874524f, -0.25802445f, 0.20408951f, 0.16733532f, -0.03957554f, -0.01299602f, 
    -0.06998599f, 0.03033676f, -0.00650820f, -0.03197273f, 0.14320952f, 0.33771119f, -0.11787224f, 0.10551856f, 
    0.05971152f, -0.03030574f, -0.05057727f, -0.05398241f, -0.10529268f, 0.08933484f, -0.11545645f, 0.10221242f, 
    0.00385244f, -0.41690993f, 0.12424731f, -0.38269347f, 0.04113412f, -0.36623371f, -0.12030928f, -0.08420094f, 
    0.00567651f, 0.06379469f, 0.01076700f, -0.00379479f, -0.65471447f, -0.17083873f, -0.44471359f, 0.50503767f, 
    0.15605991f, -0.00716074f, 0.01099154f, -0.06195943f, -0.06150712f, 0.05768641f, 0.21073526f, 0.11195981f, 
    0.11474480f, -0.06244674f, 0.25467277f, -0.28636950f, -0.07429060f, 0.00221264f, -0.22463761f, 0.04146620f, 
    0.02793144f, -0.05340568f, 0.00277257f, -0.05331443f, 0.07728501f, -0.01829190f, 0.11257390f, -0.19848645f, 
    -0.05543162f, 0.07467675f, -0.09661482f, 0.08730088f, -0.11698481f, -0.07400364f, 0.06026670f, 0.08881831f, 
    -0.24561620f, 0.10845972f, 0.06725550f, 0.03508072f, -0.05483708f, -0.05645994f, 0.00334288f, -0.07922317f, 
    -0.05083520f, -0.17923895f, 0.10283463f, 0.01550122f, 0.15952797f, -0.46883842f, 0.03736433f, -0.09479272f, 
    0.07619336f, 0.01440138f, 0.03790169f, 0.08227899f, 0.04420429f, -0.03921606f, 0.13489442f, -0.16606787f, 
    -0.40402842f, 0.00018046f, -0.16701378f, -0.01558048f, 0.15169401f, 0.11404589f, 0.14464490f, -0.05739489f, 
    -0.07040585f, -0.09554786f, 0.08763944f, 0.12833674f, 0.29429787f, 0.06184569f, 0.32123247f, -0.09064880f, 
    0.18765081f, -0.13434929f, 0.04750365f, 0.09949711f, -0.19684489f, 0.10203031f, -0.05092445f, -0.01611177f, 
    -0.17762610f, -0.02170050f, -0.15199940f, 0.12694047f, -0.03414267f, 0.11716596f, -0.02470269f, 0.04142163f, 
    -0.23388885f, -0.01458419f, 0.00113447f, -0.02045844f, -0.20886035f, 0.03855623f, 0.00498780f, -0.08918472f, 
    0.00839718f, -0.05257196f, -0.03444301f, -0.02395036f, -0.04837332f, -0.05682925f, 0.03420359f, -0.08221869f, 
    0.33769426f, -0.16844521f, 0.07333062f, 0.03461258f, -0.01065040f, 0.04233709f, -0.14669584f, 0.19624135f, 
    -0.04238433f, -0.04221044f, 0.13685672f, -0.01977852f, -0.24998017f, -0.11349899f, -0.15060650f, -0.04897004f, 
    -0.00884626f, 0.05387757f, 0.04116987f, 0.03288901f, -0.01232658f, 0.12225272f, 0.03353282f, 0.02422699f, 
    0.15268977f, 0.01391442f, 0.14772108f, 0.01252778f, 0.02108961f, 0.02996774f, 0.01458908f, 0.00657160f, 
    -0.05672530f, 0.02225714f, 0.11190865f, 0.00951899f, -0.18442982f, -0.17651050f, -0.05276439f, -0.17843652f, 
    -0.03676205f, -0.01199172f, 0.11962818f, -0.11377712f, -0.06981156f, 0.01720174f, -0.04698650f, -0.03227330f, 
    0.02229716f, 0.01749889f, 0.13700846f, -0.05294888f, 0.12845419f, 0.08906537f, 0.04173775f, -0.05757054f, 
    -0.17416075f, -0.00637046f, -0.17668585f, -0.07979695f, 0.04056474f, -0.19639327f, 0.44097686f, -0.12006854f, 
    -0.07497244f, 0.05231033f, -0.07694411f, 0.02156425f, -0.02352329f, 0.06819876f, 0.10663280f, 0.02871458f, 
    -0.49267143f, 0.03686971f, -0.13683981f, 0.19301464f, -0.00600821f, 0.00577907f, 0.01236321f, 0.06172513f, 
    -0.14240780f, -0.05757732f, -0.07751693f, -0.12022106f, -0.04213157f, 0.11163428f, -0.08913884f, 0.00911458f, 
    -0.01595669f, -0.00746015f, 0.01342085f, 0.06775373f, 0.04599362f, 0.18518263f, 0.06480029f, 0.04942449f, 
    0.38982502f, -0.16699429f, 0.30543101f, 0.00243130f, -0.00141429f, -0.12594981f, -0.07888149f, 0.02945974f, 
    -0.13097237f, 0.13617276f, -0.06558771f, -0.02762217f, 0.07025877f, -0.14058216f, 0.07954344f, -0.09166805f, 
    0.13412225f, -0.12795265f, -0.36645845f, 0.09860060f, 0.02505853f, 0.24826951f, 0.07696538f, 0.16669595f, 
    0.31128660f, 0.02830772f, 0.25682378f, -0.07474053f, -0.04052999f, -0.08726693f, -0.12989575f, 0.05098955f, 
    -0.02646344f, -0.08771333f, -0.06838446f, -0.11666221f, -0.54517126f, -0.03375093f, -0.19949141f, 0.22242810f, 
    -0.20331605f, -0.05191405f, 0.04891505f, -0.21034628f, -0.01857571f, 0.00693056f, 0.04270256f, -0.06330702f, 
    -0.33097148f, -0.18235506f, -0.27360407f, -0.05878260f, 0.16058446f, -0.00913456f, 0.02547683f, -0.09087542f, 
    -0.11184790f, -0.02822230f, -0.02740378f, 0.02621566f, -0.04093120f, -0.24454619f, 0.04938306f, -0.02803778f, 
    0.03327145f, -0.08931953f, -0.14998873f, -0.10635823f, 0.04411970f, -0.01450971f, -0.00142925f, -0.02041855f, 
    -0.02793119f, -0.01740006f, -0.00306562f, 0.04122413f, -0.12111140f, -0.31761035f, -0.05887670f, -0.08157280f, 
    -0.03967794f, 0.05322058f, 0.10151415f, -0.01506698f, 0.11951757f, -0.07812384f, 0.12404315f, -0.50612557f, 
    0.14671345f, 0.07048975f, 0.30757889f, -0.09519376f, 0.06595817f, 0.05079565f, 0.04118913f, 0.24985471f, 
    -0.16069919f, 0.30695239f, -0.14805104f, -0.18084791f, -0.02287641f, -0.04188444f, 0.00741305f, 0.00738343f, 
    -0.00543483f, 0.02564224f, 0.01832702f, 0.14969997f, -0.24673197f, 0.09072339f, -0.22661257f, 0.20496798f, 
    -0.01300548f, 0.10758747f, 0.20481165f, 0.00763256f, 0.01640665f, 0.21394345f, 0.04429254f, 0.00590468f, 
    0.31184494f, 0.21821879f, 0.12795559f, -0.08230458f, -0.02191916f, 0.00261571f, 0.06920949f, 0.19410495f, 
    -0.00462467f, 0.04237323f, -0.00587695f, -0.06622756f, 0.37958747f, 0.17888810f, 0.20581947f, 0.02786086f, 
    0.02028807f, 0.02601453f, 0.03749299f, 0.19128437f, 0.04318671f, 0.05416707f, 0.15401725f, 0.09201146f, 
    0.04738235f, 0.02734684f, 0.28508139f, 0.02286447f, -0.06601642f, 0.07320166f, -0.02733989f, 0.07697339f, 
    -0.11336005f, 0.04744890f, 0.02478873f, 0.09567373f, -0.10036003f, -0.25865790f, 0.26330468f, -0.04066632f, 
    0.11299771f, 0.11532310f, 0.02563206f, 0.04602549f, -0.05076160f, -0.03640670f, -0.18901141f, -0.23280817f, 
    0.09037202f, 0.08569997f, 0.10045768f, 0.21340497f, 0.00676735f, -0.02984687f, 0.05419070f, 0.03522068f, 
    -0.17320320f, 0.07363362f, 0.00680272f, -0.13701567f, -0.20750579f, -0.46543252f, 0.05629515f, -0.04088222f, 
    -0.21426587f, -0.09743904f, -0.19668494f, -0.16494130f, -0.03632301f, 0.01990251f, 0.00124691f, 0.12044272f, 
    0.10837135f, -0.28454450f, 0.13670120f, 0.31560668f, -0.12923957f, 0.07465646f, 0.07011480f, 0.10814264f, 
    -0.15695715f, -0.11196941f, 0.11337635f, 0.08465674f, -0.45920467f, -0.02229684f, 0.04604424f, 0.25769424f, 
    -0.09254739f, -0.06208984f, 0.09323794f, 0.14230308f, -0.00728357f, -0.02117178f, -0.14563057f, 0.05116438f, 
    0.05358716f, 0.19518842f, 0.03571616f, 0.06723971f, 0.10586818f, -0.00041238f, 0.04033540f, 0.07219326f, 
    -0.08865649f, -0.00869901f, -0.04823723f, -0.05904024f, -0.10886487f, -0.02195391f, -0.14272213f, 0.17237547f, 
    0.10284162f, -0.17457168f, 0.05290329f, 0.01388723f, -0.02721368f, 0.16723166f, 0.06782777f, 0.03253001f, 
    0.02193060f, -0.16660874f, 0.28381389f, -0.39253831f, 0.07728215f, 0.12674476f, -0.05948760f, 0.28773829f, 
    0.03718730f, 0.09543157f, 0.22363737f, 0.14286247f, 0.26829967f, 0.10928069f, -0.24967405f, 0.38461095f, 
    -0.00665512f, 0.15193297f, 0.00496399f, 0.27659300f, -0.05106394f, -0.03952129f, -0.02136361f, -0.07728439f, 
    0.07524130f, 0.09675764f, 0.27877858f, -0.03206502f, -0.19460647f, 0.01511036f, -0.17639685f, -0.14493853f, 
    -0.04987473f, 0.05960077f, 0.04490389f, -0.06277181f, -0.16397475f, -0.29974073f, -0.05041382f, 0.06773857f, 
    0.00331174f, -0.00995428f, 0.07322102f, -0.07083556f, -0.08031674f, 0.12387566f, 0.10822882f, -0.03948233f, 
    -0.00548730f, -0.21458702f, 0.10351402f, -0.14450532f, -0.14037383f, -0.14010945f, -0.19430862f, -0.15453012f, 
    -0.07906708f, -0.02578659f, -0.11212830f, -0.08619983f, 0.05998347f, -0.00863476f, 0.09869108f, -0.36980361f, 
    -0.01179432f, 0.14855810f, 0.07005979f, -0.02895026f, 0.02989435f, -0.01632692f, -0.02870929f, 0.01835171f, 
    -0.13562369f, 0.11145982f, -0.23128393f, 0.12311110f, 0.07415836f, -0.12073488f, 0.00351311f, -0.02320661f, 
    -0.13812710f, -0.12172269f, -0.14479336f, -0.10823800f, -0.19154806f, -0.05741241f, -0.24707548f, 0.00762796f, 
    0.10918240f, -0.06245018f, 0.00450366f, 0.04350317f, -0.13937239f, -0.04649685f, -0.03576906f, -0.14976187f, 
    -0.09173610f, -0.58019996f, 0.31004697f, 0.21853670f, 0.19759533f, -0.05413877f, 0.21783349f, -0.15966582f, 
    0.13435955f, -0.06780820f, 0.05348392f, 0.11461431f, 0.00506387f, -0.13975956f, 0.08336311f, 0.10284731f, 
    -0.02233684f, 0.03765969f, 0.06742691f, 0.00311513f, -0.00341175f, 0.07412589f, 0.06774101f, 0.10547461f, 
    0.14094332f, 0.30486971f, 0.43991351f, -0.16694759f, -0.19412400f, -0.07117489f, 0.06377269f, 0.12891631f, 
    -0.01423149f, 0.00367989f, -0.01891852f, -0.03812788f, -0.01984767f, 0.20177782f, -0.09292289f, -0.09940431f, 
    -0.01679166f, -0.15660773f, 0.14549445f, 0.11786164f, -0.00538469f, 0.08405042f, 0.13808331f, 0.16514651f, 
    0.00109302f, 0.13610472f, 0.25442237f, 0.02832656f, 0.11595402f, 0.04851319f, -0.07707960f, -0.12046315f, 
    0.01009794f, -0.07941350f, 0.06487043f, 0.02322376f, 0.13045609f, -0.18231030f, 0.52954459f, -0.26610348f, 
    0.15780841f, -0.04932358f, 0.21359329f, -0.11653085f, -0.10736063f, 0.13980196f, -0.02660747f, 0.03682074f, 
    -0.37646452f, 0.15742722f, -0.07949995f, 0.34071171f, 0.04678119f, -0.02159881f, 0.05725049f, 0.18016191f, 
    -0.05721861f, -0.09075476f, -0.11804531f, 0.00506549f, -0.11095390f, 0.05743016f, -0.06498674f, -0.14522144f, 
    -0.01992510f, 0.15485990f, -0.06540509f, -0.04789539f, 0.08212353f, 0.18504913f, 0.06176696f, 0.03886326f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15468433f, 0.09917276f, 0.08734404f, -0.07064088f, -0.09367405f, 0.04386192f, -0.00700215f, -0.10722329f, 
    0.06528039f, -0.00359254f, -0.01378681f, 0.02268102f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
