#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.65788108f, -1.08231270f, -0.17479323f, 0.78510767f, 0.58940804f, 0.08694155f, 1.09928608f, -0.69380152f, 
    -0.67061538f, -0.42848888f, -0.18340546f, -0.13315691f, 0.01292643f, -0.09791436f, -0.23631626f, -0.21718906f, 
    -0.27712050f, 0.25294128f, 0.36666110f, 0.06140700f, 0.07773961f, -0.24198814f, 0.09135028f, -0.10088979f, 
    0.02406355f, -1.03333807f, 0.08166750f, -0.63360775f, 0.42240080f, -0.20053864f, 0.00237336f, 0.09367960f, 
    0.17313568f, 0.21969704f, 0.57437938f, 0.24070966f, 0.24640630f, 0.19341369f, 0.23863618f, -0.20802088f, 
    -0.27085340f, -0.33933842f, -0.07154389f, 0.18736243f, 0.05779776f, 0.28176248f, -0.16953655f, -0.02667872f, 
    -0.05517976f, -0.00048774f, 0.64848220f, 0.23237722f, -0.16549048f, 0.07027949f, -0.34510049f, -0.09572034f, 
    -0.33332011f, -0.34339330f, -0.08173335f, -0.38245729f, 0.18343566f, 0.17671895f, -0.35817391f, -0.03534966f, 
    0.41620898f, -0.20184419f, 0.47407913f, 0.14744659f, -0.18616825f, 0.01361517f, -0.05778456f, -0.18983822f, 
    -0.22043626f, -0.20470718f, -0.47343838f, 0.43359882f, 0.42189807f, 0.41445547f, 0.01809764f, -0.39106420f, 
    0.12535550f, 0.03933457f, 0.31397137f, -0.44850248f, -0.41948518f, -0.10149471f, -0.26350150f, 0.10272799f, 
    -0.09302089f, -0.18285763f, 0.01033371f, -0.16078097f, 0.18814430f, 0.31948367f, -0.26713291f, 0.00102065f, 
    -0.11815321f, -0.30339837f, -0.30411062f, -0.53928804f, 0.48908055f, 0.44486937f, -0.11495131f, -0.43590295f, 
    -0.28325281f, 0.20962822f, 0.16687328f, -0.06253359f, 0.01995362f, -0.00869982f, 0.08924710f, -0.36316180f, 
    0.03329707f, -0.18800163f, -0.10939271f, -0.07034306f, 0.04668976f, -0.06305942f, -0.20211488f, -0.22466312f, 
    -0.38356760f, -0.01765600f, -0.28084996f, -0.36052421f, -0.63418442f, 0.95900577f, -0.34749946f, -0.23968758f, 
    0.39016491f, -0.48659104f, -0.18823524f, -0.24680589f, 0.27221850f, 0.25412565f, -0.24050304f, 0.45112905f, 
    -0.16743699f, -0.02080255f, 0.03408554f, -0.36920255f, 0.16444884f, 0.14885348f, -0.29112440f, -0.12739092f, 
    -0.26852822f, 0.04703172f, 0.25647652f, -0.05988335f, -0.03876072f, -0.12199835f, -0.93340689f, -0.90602595f, 
    -0.61967814f, 0.50268632f, 1.05835700f, 0.39727119f, -0.20439485f, -0.20618445f, 0.22279187f, 0.51141113f, 
    -0.31148562f, 0.08157860f, -0.31245452f, -0.15586738f, -0.28645024f, 0.12478894f, 0.04393183f, 0.16666922f, 
    0.19117157f, 0.00045647f, -0.06204814f, -0.18513577f, 0.03948592f, -0.48495272f, -0.11926242f, 0.29836312f, 
    0.31046456f, 0.20389555f, 0.15934363f, -0.05228275f, -0.08340609f, -0.15588631f, 0.02311374f, 0.04791177f, 
    -0.09184135f, 0.01279053f, 0.30261192f, -0.16687091f, 0.05514075f, 0.36928335f, 0.12490868f, 0.22210595f, 
    -0.09555267f, 0.04016204f, -0.15160894f, 0.13600101f, -0.19904469f, 0.24986292f, 0.15443797f, 0.06260945f, 
    0.60741174f, 0.23224494f, -0.21249773f, 0.14646946f, 0.54169178f, 0.07938246f, -0.28030217f, -0.03213428f, 
    -0.12403628f, -0.51096553f, -0.37491521f, 0.06679269f, 0.13555953f, -0.11647032f, -0.20829053f, -0.08412772f, 
    -0.26436076f, 0.00716743f, -0.07812680f, 0.00050842f, 0.03977731f, 0.04392045f, -0.07136074f, 0.08891995f, 
    0.17832693f, -0.09044261f, -0.64830565f, -0.45155340f, -0.21094742f, 0.00626395f, -0.83506668f, -0.31840131f, 
    -0.62647688f, -0.59552133f, -0.08708312f, 0.65054560f, 0.29173285f, 0.67888409f, 0.19194317f, 0.04790796f, 
    -0.15425225f, 0.14294876f, -0.13998552f, -0.36257732f, -0.30085906f, 0.12022208f, -0.04673004f, -0.08201914f, 
    0.04303949f, 0.06698234f, -0.21469095f, 0.02546777f, 0.13955532f, -0.15361378f, 0.32638675f, 0.23423097f, 
    0.27586487f, 0.04349128f, 0.20694818f, -0.27129886f, -0.21232797f, -0.11046475f, 0.44138262f, -0.18430315f, 
    -0.11168963f, -0.13928047f, -0.10696176f, -0.38182980f, 0.17565688f, 0.06575927f, -0.30245095f, -0.16985917f, 
    0.25611776f, 0.13101625f, 0.20999828f, 0.71348554f, 0.30584121f, -0.12945315f, 0.03423990f, -0.72093350f, 
    -0.15056866f, 0.33854631f, 0.56810397f, -0.38157031f, -0.43648472f, -0.50930917f, 0.12170241f, 0.15199122f, 
    -0.06139624f, -0.32248634f, -0.08652565f, 0.03168360f, -0.09264355f, -0.08478136f, 0.08588859f, 0.16323352f, 
    0.12314241f, -0.10001007f, -0.17927018f, 0.31993079f, -0.24931905f, -0.33946609f, -0.30675077f, 0.54598784f, 
    0.11996286f, -0.77884430f, -0.47237894f, 0.26143527f, 0.21916585f, -0.37970403f, -0.23782745f, -0.28607127f, 
    -0.18341453f, 0.01439171f, -0.14102681f, -0.36024201f, 0.20126890f, -0.28453881f, -0.29690161f, -0.46115226f, 
    0.05891881f, 0.36150807f, -0.00534372f, -0.36109963f, -0.36913255f, 0.19867292f, -0.11320826f, -0.42180198f, 
    -0.22697636f, 0.01803071f, 0.55932516f, 0.00122481f, 0.66218406f, -0.67419493f, 0.22022182f, -0.28348380f, 
    -0.06320152f, -0.12396637f, 0.00527579f, -0.09277161f, -0.25672120f, 0.38619170f, 0.20376594f, -0.38458210f, 
    0.13115610f, 0.32502106f, -0.14796221f, -0.30603915f, -0.18331780f, 0.08240476f, -0.58284307f, -0.63689268f, 
    0.03341704f, 0.04290529f, -0.44197881f, 0.08574759f, -0.25129932f, -0.59927481f, -0.36314994f, -0.47449279f, 
    0.12149442f, -0.14395964f, -0.24511215f, -0.37608084f, -0.43802792f, -0.11890705f, 0.11593261f, -0.21371059f, 
    0.01911327f, -0.19644718f, -0.06000051f, 0.06228819f, 0.09037648f, 0.23313016f, 0.40276524f, -0.87020516f, 
    0.32965448f, 0.33631620f, -0.00337907f, 0.20398758f, -0.81774694f, -0.54975873f, 0.36432338f, 0.91847157f, 
    0.22226413f, -0.04959920f, 0.14664838f, -0.04319441f, -0.43898746f, 0.16905460f, -0.05584123f, 0.06367596f, 
    -0.08207933f, -0.10685398f, 0.17614378f, 0.06982400f, -0.18620116f, -0.04182140f, 0.28006944f, -0.09028792f, 
    -0.69477516f, 0.38675618f, 0.11241363f, -0.73527050f, 0.10704783f, -0.31893831f, -0.31901366f, -0.60900605f, 
    -0.56405938f, -0.37709129f, 0.03870197f, 0.17738707f, 0.18498044f, -0.36831927f, -0.10528453f, 0.16001023f, 
    -0.69871396f, -0.33347979f, -0.07384694f, -0.28860107f, 0.02165048f, -0.14619456f, -0.26263687f, -0.34929070f, 
    -0.18725795f, -0.18009065f, -0.22686654f, 0.42725560f, 0.34183222f, -0.31313542f, -0.24120267f, 0.03552487f, 
    -0.36508927f, -0.12478418f, -0.40835375f, 0.29849720f, -0.56319064f, 0.29326826f, 0.25527227f, 0.09697158f, 
    0.33557534f, -0.25176153f, -0.14181525f, -0.04032023f, -0.04835864f, -0.10195671f, 0.44348559f, 0.28552943f, 
    -0.06086392f, -0.05293199f, 0.17773089f, 0.47959256f, 0.51902223f, -0.39394584f, -0.52024925f, -0.60832244f, 
    -0.31907424f, -0.54294389f, -0.52019626f, -0.29191637f, 0.33341363f, 0.15652131f, -0.18324155f, 0.01499693f, 
    0.34039688f, -0.16512722f, 0.30824754f, 0.06438336f, 0.17099658f, 0.07778649f, -0.24241963f, 0.09720274f, 
    -0.22580683f, -0.20048310f, -0.09247442f, 0.04180350f, -0.06371583f, 0.18698455f, 0.22355005f, 0.32212022f, 
    0.15295799f, -0.52655476f, -0.36016399f, 0.07384173f, 0.00126220f, -0.00904069f, -0.04154117f, -0.06907578f, 
    0.15754180f, 0.14727764f, 0.27600241f, -0.04688967f, -0.33569607f, 0.01724876f, -0.19736277f, 0.34166956f, 
    -0.30277553f, -0.40630677f, 0.12738711f, 0.22959006f, 0.49952981f, -0.39261574f, 0.14048821f, 0.38057992f, 
    0.12779011f, 0.49966818f, 0.46316797f, -0.39429241f, -0.56874144f, 0.02349388f, -0.35889333f, 0.31947744f, 
    -0.07994299f, -0.15379116f, 0.35162556f, -0.08324315f, -0.09483171f, 0.17175357f, -0.16211002f, -0.19999684f, 
    0.13340430f, -0.34153381f, 0.14089411f, -0.22416124f, -0.28940305f, 0.38019654f, 0.05523151f, -0.38825679f, 
    -0.55131263f, 0.22656000f, -0.28493708f, 0.08028843f, 0.48090369f, -0.04398922f, 0.15194517f, 0.06773962f, 
    0.11515312f, 0.15094784f, 0.24392393f, -0.07557231f, 0.25481921f, 0.01687382f, -0.73121470f, -0.16945346f, 
    -0.18034410f, 0.05121754f, 0.11359886f, 0.15525730f, 0.36918199f, 0.10197588f, -0.98389250f, -0.59350032f, 
    -0.35232025f, -0.42493796f, -0.76566041f, 0.59564960f, 0.38459477f, -0.23930262f, -0.67854917f, 0.21096782f, 
    -0.04790257f, -0.27311167f, -0.19212259f, -0.01944456f, 0.22218291f, 0.16072588f, 0.22834353f, 0.14718020f, 
    0.01514626f, -0.22943434f, 0.01161164f, -0.08532057f, 0.19846807f, -0.03719379f, 0.30004996f, 0.56419426f, 
    -0.59287220f, -0.86876673f, -0.69483668f, -0.15899266f, -0.26223233f, 0.42753023f, 1.01929486f, 0.01927152f, 
    -0.68256700f, -0.36372983f, -0.03198598f, -0.28600124f, -0.14948305f, 0.41350508f, -0.06216744f, 0.03869492f, 
    0.27636036f, -0.08645930f, -0.05940697f, 0.03579945f, -0.13588467f, -0.21821457f, -0.01995951f, 0.02876186f, 
    -1.19577110f, -0.38224873f, 0.42685220f, -0.38878250f, -0.09091797f, -0.00917061f, -0.24510987f, 0.06845044f, 
    0.57498872f, 0.43694887f, -0.36730626f, -0.23875642f, 0.00746391f, 0.53375256f, 0.09487478f, 0.02348522f, 
    -0.13289435f, -0.27292544f, -0.31184685f, -0.31092328f, 0.00204921f, 0.40915170f, 0.61978835f, -0.22688369f, 
    -0.08087937f, -0.13526934f, -0.18366461f, -0.27714306f, -0.21756358f, 0.41917986f, -0.01818435f, -0.03894532f, 
    0.00535747f, 0.26706246f, 0.30236569f, 0.24834192f, 0.17418209f, -0.01248105f, -0.38236991f, -0.04149998f, 
    0.04450391f, 0.07549893f, 0.18566181f, 0.06571002f, -0.47044754f, -0.23859099f, 0.00033393f, -0.28345942f, 
    -0.21550374f, 0.51397038f, -0.22525285f, -0.40676120f, -0.77294493f, -0.22100149f, -0.45407835f, -0.00153936f, 
    0.04964924f, -0.19993620f, -0.65425533f, -0.53582573f, -0.25653434f, -0.13070354f, 0.14218642f, -0.11931774f, 
    -0.20647442f, -0.14212622f, -0.43502906f, -0.25460935f, 0.11490581f, -0.27114686f, -0.21873921f, 0.03486891f, 
    0.00200029f, -0.06238301f, -0.43258968f, 0.27251628f, 0.42939979f, 0.04551770f, -0.26775762f, -0.54093546f, 
    -0.23202839f, -0.15316218f, -0.02760962f, -0.26469555f, -0.27664429f, 0.35536516f, -0.36230630f, 0.66743821f, 
    -0.48884901f, -0.09027392f, 0.24719818f, 0.32248339f, 0.33457425f, -0.08444949f, -0.38558733f, 0.09458210f, 
    0.01048211f, -0.21265717f, 0.17775528f, 0.27654442f, 0.11311018f, 0.30127820f, 0.24022622f, -0.19007258f, 
    -0.01594384f, 0.01774430f, -0.34583887f, -0.18845749f, 0.01740218f, 0.34194231f, 0.22440542f, 0.29556790f, 
    -0.20299441f, -0.45084858f, -0.00501731f, -0.01897496f, 0.09380782f, -0.09499194f, -0.08619653f, -0.10843919f, 
    -0.22420408f, -0.16591318f, -0.27272296f, -0.05104187f, -0.37369838f, -0.51555061f, -0.07845759f, 0.17244251f, 
    0.14896925f, 0.32787281f, -0.19212285f, 0.36887413f, 0.30161986f, -0.47955266f, 0.27062416f, -0.30307013f, 
    0.09579064f, 0.07574115f, 0.08453850f, 0.16276933f, 0.26607528f, -0.16988470f, -0.19892266f, -0.04572697f, 
    -0.15626910f, -0.00834059f, 0.23540020f, -0.25833011f, -0.16114475f, 0.31511810f, -0.67174929f, -1.02831161f, 
    -0.82093227f, -0.68535244f, -0.51509798f, 0.62715727f, 0.44959697f, 0.49424851f, 0.42906991f, 0.40546799f, 
    0.27270052f, 0.06854044f, 0.01730899f, 0.28807518f, 0.23808016f, -0.08951820f, -0.11494739f, -0.02893663f, 
    -0.20668167f, 0.09620403f, -0.37673026f, -0.24934301f, 0.19569460f, 0.32135326f, -0.30286580f, 0.03782302f, 
    0.94847041f, 0.08526292f, -0.02885149f, -0.32017511f, -0.33744988f, -0.48184028f, 0.13174278f, 0.81079197f, 
    -0.68256462f, -0.16027263f, 0.03693162f, 0.07344750f, 0.05509435f, -0.34929016f, 0.05649260f, 0.20729610f, 
    0.02054726f, -0.04298788f, 0.05279893f, 0.00536807f, -0.01355283f, -0.20155472f, 0.09743727f, -0.05017016f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11356363f, 0.12170114f, 0.13832435f, -0.10228552f, -0.04787212f, 0.22929782f, 0.01193823f, -0.02473384f, 
    0.22383156f, 0.08579841f, 0.34016407f, 0.24386303f, 0.20780486f, 0.27143714f, -0.10630367f, 0.21671751f, 
    -0.07368574f, -0.08018308f, 0.23268573f, 0.26209667f, -0.07426902f, 0.18612896f, -0.02203262f, 0.06339113f, 
    0.30144271f, 0.29208857f, -0.19726621f, 0.19177148f, 0.01505488f, 0.45369184f, 0.09945925f, 0.34313110f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.50995070f, -0.14413583f, 0.03300425f, -0.04829254f, -0.00915570f, 0.21107711f, 0.01411645f, 0.07310231f, 
    0.01151297f, 0.02937686f, 0.12701075f, -0.10051996f, 0.19129205f, 0.05455132f, -0.31348956f, -0.07724489f, 
    -0.03175749f, -0.12335818f, -0.11247115f, 0.04468012f, -0.21574701f, 0.01070828f, -0.15018573f, 0.08937217f, 
    -0.13970239f, 0.09035986f, -0.00893002f, -0.00787389f, -0.04284312f, 0.04459418f, -0.05846680f, -0.11688866f, 
    0.19178802f, 0.13945059f, -0.29625058f, 0.20068313f, 0.18602797f, 0.14405577f, 0.10493211f, -0.08723445f, 
    -0.08107363f, -0.04408687f, -0.08275242f, 0.01847806f, 0.24129999f, 0.04758573f, 0.23169544f, 0.15297170f, 
    0.02953522f, 0.16471501f, 0.18161789f, -0.02859132f, -0.01272128f, 0.01544659f, -0.14577420f, -0.07973780f, 
    0.02330420f, -0.01241654f, 0.02927078f, 0.06066789f, -0.31013343f, -0.03871636f, 0.22261450f, 0.25025722f, 
    -0.00640917f, 0.03473638f, 0.01312254f, -0.01119299f, -0.07358421f, -0.00008516f, -0.11988689f, 0.16380024f, 
    -0.21260490f, 0.00646889f, -0.33459279f, 0.15764260f, -0.09396457f, 0.18312913f, -0.17608428f, 0.05925366f, 
    0.01398690f, -0.06394512f, -0.19460608f, -0.05330043f, 0.10289621f, 0.05718410f, -0.00610129f, 0.08117308f, 
    0.03114118f, 0.03232411f, 0.10268762f, -0.02641452f, 0.08023545f, 0.03062670f, -0.02136657f, -0.03277285f, 
    0.51523143f, 0.23443854f, 0.08507425f, 0.11522396f, -0.11081807f, -0.09608090f, -0.04795038f, 0.04353597f, 
    -0.02829518f, -0.03683506f, -0.04113467f, -0.01611441f, -0.36741427f, -0.38436982f, 0.01073092f, 0.45022145f, 
    0.03603791f, -0.00085493f, 0.05625939f, -0.00712589f, 0.08706805f, -0.05583375f, 0.04974804f, -0.00766254f, 
    0.15304747f, 0.07306296f, 0.02704466f, 0.04456448f, 0.00797772f, 0.07548897f, 0.06067045f, -0.05290103f, 
    -0.02499204f, -0.04188201f, 0.07524622f, -0.29988775f, 0.43994212f, 0.15168178f, -0.01012655f, -0.09844507f, 
    -0.02366208f, 0.02602936f, -0.04257572f, 0.02504803f, -0.12728359f, -0.12216196f, -0.06665570f, -0.01764461f, 
    -0.39280182f, 0.09028789f, -0.17599329f, 0.07890000f, 0.09029437f, 0.10063097f, -0.01958334f, 0.13600376f, 
    -0.00916365f, -0.03061051f, 0.01315829f, -0.01440240f, 0.39335284f, -0.00688222f, 0.10965086f, 0.10289806f, 
    -0.01774260f, 0.11038876f, 0.01148628f, 0.08113398f, 0.08133013f, -0.07733732f, -0.00974845f, -0.02209314f, 
    -0.15651275f, 0.03952095f, 0.12375846f, 0.26686889f, -0.19972064f, 0.15005246f, -0.13912830f, 0.18793574f, 
    -0.11295286f, 0.04042360f, -0.18070601f, -0.07593440f, -0.31256428f, 0.18619709f, -0.01586075f, 0.09942013f, 
    0.13496827f, -0.01886294f, 0.12940395f, -0.16108945f, -0.02835837f, 0.22171751f, -0.13729230f, 0.24252206f, 
    0.00909314f, -0.32687381f, 0.09830635f, 0.09542650f, 0.03815461f, -0.00976658f, -0.01911251f, -0.01503947f, 
    0.09786396f, 0.09387518f, -0.06915474f, 0.02274297f, -0.07247905f, 0.03498831f, 0.08237077f, 0.13883223f, 
    -0.16486154f, -0.04993030f, -0.09444346f, 0.12116130f, -0.03718171f, -0.09351602f, 0.12176583f, -0.05701384f, 
    -0.21212232f, -0.02736750f, 0.11384560f, -0.00148502f, -0.00767371f, -0.05300265f, -0.17609431f, -0.05911032f, 
    0.12026630f, 0.03744495f, -0.16242084f, 0.03974699f, -0.11495207f, 0.17033613f, -0.06640401f, 0.14958273f, 
    0.04276038f, 0.02714955f, -0.02825572f, -0.02648503f, -0.00173249f, 0.01550898f, -0.06655029f, 0.06956140f, 
    0.17391008f, 0.40184832f, 0.02355424f, -0.00619747f, -0.03115952f, -0.13497752f, -0.06251523f, 0.00638670f, 
    0.05304583f, 0.28043145f, -0.02122466f, 0.07656603f, 0.27293774f, -0.18481570f, 0.06026895f, 0.03310393f, 
    -0.09604536f, 0.15905294f, 0.08222649f, 0.04152585f, -0.14092807f, -0.14974643f, -0.00625945f, 0.04644806f, 
    0.21697347f, -0.01908411f, 0.39425191f, 0.33636284f, 0.02507559f, -0.02601483f, 0.04658987f, -0.07101607f, 
    -0.00963243f, 0.07352382f, -0.03940030f, -0.12603937f, 0.02251135f, 0.41920763f, 0.44145766f, 0.15265775f, 
    -0.05091377f, 0.08078846f, 0.12126240f, -0.18237014f, -0.07716768f, 0.04494597f, -0.03991542f, -0.13826653f, 
    0.12605560f, 0.31240201f, 0.07174590f, 0.19747774f, -0.11063382f, 0.01288853f, 0.04233874f, 0.07614658f, 
    -0.06751975f, -0.27781579f, 0.08987745f, -0.03204044f, 0.08371200f, 0.18261485f, 0.00996550f, -0.01168384f, 
    0.04021940f, 0.09067196f, -0.11395577f, -0.10175800f, 0.00113500f, 0.02455219f, -0.02106269f, -0.14632797f, 
    -0.17823730f, -0.09630747f, 0.21610253f, 0.17246762f, -0.15368736f, -0.07905080f, 0.08668310f, 0.03430101f, 
    0.09842831f, 0.07215383f, -0.00274104f, -0.06362262f, -0.12765940f, -0.07280354f, 0.25109482f, -0.09615233f, 
    -0.06080161f, -0.05989537f, 0.05733178f, -0.13062042f, -0.00323763f, -0.07851299f, -0.05660939f, -0.00772940f, 
    0.07634240f, 0.13662897f, 0.18124078f, -0.10082580f, -0.06191595f, -0.01434444f, -0.09307031f, -0.07464450f, 
    0.13539524f, 0.01003637f, -0.14133795f, 0.01203430f, 0.09465566f, 0.01092944f, -0.11637510f, 0.28885084f, 
    0.04343464f, 0.06177043f, 0.01143611f, -0.07276497f, 0.07022839f, -0.06230011f, 0.01709215f, 0.01179331f, 
    0.23768559f, 0.22408096f, 0.11453383f, 0.00767907f, -0.03913162f, -0.11269772f, 0.16546938f, -0.08742161f, 
    -0.12217837f, 0.08687308f, 0.11313823f, -0.04054668f, -0.02177336f, -0.22566506f, 0.24988082f, 0.11218028f, 
    -0.05240034f, -0.13723046f, -0.03284191f, 0.00204970f, -0.07075682f, 0.05096179f, -0.00709957f, -0.03059735f, 
    -0.26671821f, 0.05409430f, 0.19605099f, -0.02070022f, -0.05738501f, 0.09141654f, -0.01937556f, -0.06568643f, 
    -0.09582595f, 0.16580947f, 0.06016015f, -0.13025939f, 0.42513186f, 0.23688027f, 0.05482479f, 0.30162129f, 
    -0.06037371f, -0.03738452f, -0.16776596f, -0.00711144f, 0.02131614f, 0.15238835f, -0.04578988f, 0.10051830f, 
    -0.06788112f, -0.06774051f, 0.08100038f, 0.22608727f, 0.13006258f, 0.18762058f, 0.02675154f, -0.08256537f, 
    0.27071777f, 0.01845682f, 0.12834044f, 0.13924608f, -0.00053582f, 0.25648832f, -0.06185737f, 0.24637425f, 
    0.09045428f, -0.07502297f, 0.05363765f, 0.02478372f, 0.23520063f, -0.01142664f, 0.16167662f, -0.01441597f, 
    0.23981674f, 0.13838845f, 0.00433427f, 0.03663567f, 0.00020955f, -0.12410294f, 0.03688903f, -0.06600312f, 
    0.23629974f, -0.04439149f, 0.13582246f, 0.19557837f, -0.11420276f, 0.14628209f, 0.06097049f, -0.26510617f, 
    0.03720020f, -0.00514612f, -0.11539973f, -0.11746844f, 0.26000708f, 0.03327931f, 0.00260102f, 0.11773107f, 
    0.01601732f, -0.23366371f, 0.10572115f, -0.16481073f, -0.10473739f, 0.01730559f, -0.28874224f, 0.07051459f, 
    0.05059879f, 0.18625711f, 0.01808715f, 0.10750697f, -0.39814976f, -0.43008837f, -0.09958415f, -0.05244114f, 
    0.17454158f, 0.07177372f, 0.17572768f, -0.19681089f, -0.02522291f, -0.26687339f, -0.25804272f, -0.03329247f, 
    -0.24397931f, 0.10289940f, 0.53324950f, -0.02194199f, 0.13591963f, -0.10047428f, -0.02562211f, -0.08784465f, 
    -0.21952246f, -0.18291633f, 0.02022892f, -0.03184247f, 0.10465497f, -0.17668229f, 0.18852787f, 0.16691643f, 
    -0.07028099f, -0.11025489f, -0.11267755f, 0.07966261f, 0.07719612f, -0.04078179f, -0.00282544f, -0.03400847f, 
    -0.08915415f, 0.14009577f, -0.17064050f, -0.03150087f, -0.10898100f, -0.14264351f, -0.20357506f, -0.03638280f, 
    -0.11129041f, -0.05600727f, -0.01620889f, -0.28684366f, -0.34262657f, 0.37163404f, -0.13856216f, -0.21694198f, 
    0.20358279f, -0.08432212f, -0.01812333f, -0.04946001f, -0.08980205f, -0.15177701f, -0.04084092f, -0.21220960f, 
    -0.02270069f, 0.01783534f, -0.09896491f, 0.03118386f, -0.01752378f, 0.02710663f, 0.02622228f, 0.05407126f, 
    -0.09984090f, 0.01720476f, 0.08907316f, 0.14896302f, -0.03598889f, -0.06586871f, 0.13416728f, -0.08134175f, 
    0.09232663f, 0.15235963f, 0.00548424f, 0.01983687f, 0.17042398f, 0.04479473f, -0.01465010f, 0.13059542f, 
    -0.25024134f, -0.06121768f, 0.11049008f, 0.29268128f, 0.00402507f, 0.05425148f, -0.00314782f, 0.07853059f, 
    -0.11927536f, 0.12590128f, -0.02282897f, -0.02175051f, 0.34254488f, 0.00399720f, -0.51456708f, 0.11279293f, 
    -0.06092352f, -0.04758937f, 0.12842371f, -0.23907420f, -0.00762348f, 0.02882223f, -0.30882925f, 0.09079508f, 
    0.08179879f, -0.12405512f, 0.07057730f, 0.20632224f, 0.08973058f, -0.09635666f, 0.07085245f, -0.05433832f, 
    0.09234029f, -0.08352563f, 0.07140880f, 0.09167768f, -0.02658558f, 0.11065586f, -0.20911834f, 0.26788428f, 
    0.03962023f, -0.04052094f, -0.03796218f, -0.01359796f, -0.02726547f, -0.18101551f, -0.03842199f, -0.33767778f, 
    -0.17909244f, 0.10527126f, 0.06049078f, 0.32577133f, 0.14079741f, 0.19511057f, 0.01855143f, -0.00903518f, 
    0.25825161f, 0.03502586f, -0.01086840f, -0.00138507f, -0.09120589f, -0.13928679f, 0.10538905f, 0.20554590f, 
    -0.12258701f, -0.05967038f, -0.23483022f, 0.03119620f, -0.21163617f, 0.02011531f, -0.19749510f, 0.14780353f, 
    0.00689085f, -0.17359649f, -0.16067392f, 0.05773079f, 0.13949829f, -0.28817526f, 0.00319346f, 0.09159692f, 
    0.02309626f, 0.05927916f, -0.02482631f, 0.17190909f, 0.02863035f, -0.15828733f, -0.28974688f, 0.00622918f, 
    -0.07883018f, -0.02604238f, -0.06815772f, 0.03474933f, -0.06135023f, -0.13070560f, -0.08272161f, -0.04953741f, 
    -0.23287885f, -0.15812287f, 0.12267463f, 0.28564262f, -0.05542199f, -0.08514355f, 0.00798206f, -0.11901473f, 
    -0.08778066f, -0.00175392f, -0.02341917f, 0.07382020f, -0.25346312f, 0.12773393f, 0.09493969f, 0.08754446f, 
    0.01097009f, 0.10416722f, 0.14987919f, -0.16267213f, 0.06819966f, 0.04504037f, 0.04873636f, 0.09938908f, 
    0.19538341f, 0.01476580f, -0.04332156f, 0.19963935f, -0.08589818f, 0.07678539f, -0.17253241f, 0.06871257f, 
    0.01476478f, -0.18937942f, -0.02288842f, 0.19950341f, 0.16230059f, -0.06465001f, -0.13062374f, -0.18837988f, 
    -0.04253627f, -0.06976692f, -0.10289160f, 0.08674927f, -0.11983987f, 0.05193918f, -0.09146766f, -0.04126203f, 
    -0.28853568f, -0.01932878f, 0.02928425f, 0.02655422f, -0.02696126f, -0.06461082f, 0.03509628f, 0.07768966f, 
    0.09313693f, 0.05659194f, 0.20102690f, 0.01432255f, -0.12284344f, 0.02653179f, -0.02267085f, 0.02552845f, 
    -0.00747072f, 0.02968407f, 0.11322041f, -0.01341042f, 0.02038046f, 0.02781714f, -0.19337179f, -0.26605347f, 
    0.20094845f, -0.27997100f, -0.07675369f, 0.01854706f, -0.00476008f, -0.02277649f, -0.01389451f, -0.09474529f, 
    0.26788002f, 0.18522346f, 0.05467717f, 0.25459918f, 0.30886376f, -0.14259240f, -0.09780968f, -0.25133389f, 
    -0.08310585f, -0.06896265f, -0.09310494f, 0.04240206f, 0.00756585f, -0.08278901f, 0.05817274f, 0.05542517f, 
    -0.04178115f, 0.43348551f, 0.51389569f, 0.32558373f, -0.25524610f, -0.20024437f, 0.10335749f, 0.13181223f, 
    0.09751337f, 0.02735733f, 0.03858174f, 0.24789383f, 0.17555590f, -0.09332352f, 0.13141781f, -0.26990467f, 
    -0.08814660f, 0.10597434f, 0.03138450f, 0.19879054f, 0.02550174f, -0.02040219f, 0.20478886f, -0.10313261f, 
    -0.21341947f, -0.38762262f, 0.03537330f, -0.08562585f, -0.05075275f, 0.05457212f, -0.25947750f, 0.25767007f, 
    0.06461984f, -0.09728024f, 0.16617498f, 0.03822812f, 0.25505012f, 0.25992739f, 0.25805277f, 0.23321727f, 
    0.01875764f, 0.00212093f, -0.02222122f, -0.13956283f, 0.10588929f, -0.10974777f, 0.01754549f, 0.30230513f, 
    -0.04783462f, 0.05849573f, -0.09790154f, -0.08099612f, 0.03052833f, 0.08725732f, 0.03933574f, -0.00892932f, 
    0.03145364f, 0.11889791f, 0.04187286f, 0.23288752f, -0.17077526f, -0.11447003f, 0.12154213f, -0.06133220f, 
    0.00322405f, -0.03621049f, 0.14405239f, 0.07995487f, -0.08421478f, -0.14609651f, -0.05181452f, 0.04082429f, 
    0.04758168f, 0.09556339f, 0.12503599f, 0.06840614f, -0.08885218f, -0.02422275f, 0.05190890f, -0.02604831f, 
    0.14501770f, 0.22426504f, 0.16642877f, 0.14981554f, -0.10335004f, 0.39968795f, 0.03762988f, 0.23297991f, 
    0.07107245f, -0.00445204f, 0.04122537f, -0.07398626f, 0.13341288f, 0.05686651f, 0.23047169f, 0.04927942f, 
    0.19270606f, -0.19407953f, 0.22254838f, 0.44746113f, 0.02735218f, -0.00943753f, 0.02603018f, 0.14486194f, 
    0.15849720f, 0.21972699f, 0.11328708f, 0.02777596f, -0.08813479f, -0.05968847f, -0.01850412f, -0.12455267f, 
    -0.06878310f, -0.02214184f, 0.10850702f, -0.01065294f, 0.05652745f, -0.08054299f, 0.04099436f, 0.02621272f, 
    0.08262505f, -0.07183892f, 0.22392839f, -0.09778504f, 0.06137018f, 0.04745425f, 0.07041147f, -0.01193411f, 
    -0.02119137f, -0.06346958f, -0.03769856f, -0.07749447f, -0.41096422f, -0.41203478f, -0.30748031f, -0.29103461f, 
    -0.09289279f, -0.23319088f, 0.00369654f, 0.03638969f, -0.12309534f, 0.03929034f, 0.02232747f, -0.03923681f, 
    -0.06724987f, 0.21761714f, 0.05091427f, 0.00144008f, 0.03212832f, -0.06284828f, -0.04884654f, -0.06222630f, 
    0.05364212f, -0.00607382f, 0.02146882f, 0.08885989f, -0.51222062f, 0.08294261f, 0.28969455f, -0.06612079f, 
    -0.02370505f, -0.00710296f, 0.10252448f, 0.07893666f, 0.02674985f, -0.03324128f, -0.00065709f, 0.01522580f, 
    -0.14832386f, 0.01795978f, -0.37572512f, 0.19265078f, 0.18000473f, 0.09728289f, 0.13468264f, 0.07377813f, 
    0.03767110f, -0.03266817f, 0.00922566f, 0.08081517f, 0.03412751f, -0.01079909f, 0.06056703f, 0.33306405f, 
    0.08328131f, -0.11647694f, 0.28234071f, -0.05056822f, 0.37366325f, 0.19839369f, 0.06874197f, 0.24304216f, 
    -0.55518430f, -0.46144637f, -0.42611793f, -0.45498964f, -0.19619909f, -0.11516610f, -0.21032828f, 0.21430132f, 
    -0.00011945f, -0.02769386f, 0.00368480f, -0.10836900f, 0.47299829f, -0.14146109f, -0.16257465f, 0.14732544f, 
    0.12142029f, 0.06767810f, 0.11625075f, -0.13053888f, 0.13404962f, 0.03697946f, 0.07722247f, 0.10879541f, 
    -0.40712875f, -0.24170922f, -0.12824723f, -0.12415008f, 0.02120215f, 0.13582480f, 0.21045959f, 0.10862704f, 
    0.01659642f, 0.03699705f, 0.07825909f, -0.08332162f, 0.03147290f, 0.06826292f, -0.05389314f, -0.04308843f, 
    0.09314390f, 0.02352480f, -0.09508073f, -0.11980373f, 0.06260476f, -0.01425743f, -0.08239245f, -0.01351276f, 
    0.02895602f, -0.01690697f, -0.15606366f, -0.16681793f, 0.09905557f, 0.01640693f, 0.05881949f, 0.04941372f, 
    -0.02279787f, -0.00703234f, 0.01593578f, 0.05357886f, 0.08552988f, 0.10345980f, -0.00590970f, -0.03572058f, 
    0.12430283f, 0.05257564f, 0.14431262f, 0.03485842f, -0.01682175f, 0.09274904f, -0.06154131f, -0.05673286f, 
    0.09250335f, -0.18663539f, 0.01047817f, -0.15522371f, -0.08498555f, -0.00178280f, -0.02246957f, -0.00530722f, 
    -0.14726274f, -0.08062354f, 0.02299758f, 0.18633261f, -0.10182329f, 0.06034440f, -0.01512949f, -0.07367142f, 
    0.00631441f, -0.07826638f, 0.03400749f, -0.08597968f, 0.09646861f, 0.08189386f, 0.14092848f, 0.10125048f, 
    -0.45579514f, -0.46141109f, -0.11304662f, 0.04096540f, -0.19062598f, 0.08486830f, 0.03715910f, 0.24665733f, 
    0.04501424f, -0.03158107f, -0.00135510f, 0.01135202f, -0.31466120f, -0.45389682f, 0.08789139f, -0.11642841f, 
    0.09608513f, -0.16332795f, 0.15735820f, 0.18566291f, 0.07193965f, 0.03660319f, 0.00392766f, -0.00496559f, 
    0.05995436f, 0.04986581f, -0.28022969f, 0.22996227f, 0.12824938f, 0.13423266f, 0.03528945f, -0.03064882f, 
    -0.06715851f, 0.00263132f, 0.14538592f, 0.09443140f, 0.05228638f, -0.01232567f, 0.14868334f, 0.00762176f, 
    0.11089448f, -0.05358168f, 0.00794191f, -0.01652483f, 0.10408430f, 0.24544078f, -0.04206782f, 0.04699707f, 
    -0.15303722f, -0.19008008f, -0.05871914f, -0.14959270f, -0.14753667f, -0.00597145f, 0.17972791f, 0.32231280f, 
    -0.04480512f, 0.00848672f, 0.04275652f, -0.01992661f, -0.04110565f, 0.03881021f, -0.07007030f, 0.14790833f, 
    0.08139598f, -0.00439651f, 0.05197648f, 0.13887788f, 0.08000518f, -0.02413901f, -0.07432076f, -0.01581062f, 
    -0.01998990f, 0.03373763f, 0.04636870f, -0.02646901f, -0.04527506f, 0.03368236f, 0.03059919f, -0.06561038f, 
    0.07302178f, 0.10240299f, 0.08359431f, 0.00101269f, 0.05578015f, 0.03036974f, 0.02299672f, 0.09783220f, 
    -0.08113983f, 0.09548367f, -0.00686296f, 0.01344516f, -0.00383057f, 0.18955415f, 0.07081025f, -0.01941929f, 
    0.15912426f, 0.38300493f, 0.44789094f, 0.15305538f, -0.06182421f, -0.10521261f, -0.09182029f, -0.09447516f, 
    -0.03994174f, 0.23321120f, 0.37378427f, 0.23138240f, -0.24606544f, 0.31358659f, -0.38051978f, 0.09383500f, 
    0.20219034f, 0.19568291f, 0.16397403f, 0.14005543f, 0.04404034f, 0.03617388f, -0.05230443f, 0.09821225f, 
    -0.21152531f, -0.31179211f, 0.25151110f, 0.33940712f, -0.06786217f, 0.32817793f, 0.04783062f, -0.08892997f, 
    -0.00935399f, -0.07187112f, -0.01325220f, -0.01946806f, -0.06389248f, 0.20251808f, -0.07897837f, -0.22617327f, 
    0.01128734f, -0.04494264f, 0.05207149f, 0.14051421f, 0.14299525f, 0.15017925f, -0.14617841f, 0.06132485f, 
    0.05977152f, 0.28631988f, -0.00881589f, 0.06816430f, 0.20102957f, -0.00924132f, 0.02438453f, 0.02360648f, 
    0.02203222f, -0.05558618f, 0.00242740f, -0.04738157f, 0.14617242f, 0.00300771f, -0.01044948f, 0.05274976f, 
    -0.08064647f, -0.07690442f, -0.02976573f, -0.04619882f, -0.05741648f, -0.10851628f, -0.10391874f, -0.01470978f, 
    0.04207613f, 0.15613554f, 0.04208060f, 0.07237094f, -0.00032530f, -0.12445927f, -0.09456787f, -0.08069582f, 
    0.03504623f, -0.04657527f, -0.03542012f, 0.05832888f, 0.16896822f, 0.14827541f, 0.17093252f, 0.41270483f, 
    -0.04729775f, -0.04256787f, -0.01562851f, 0.15788691f, 0.00054054f, -0.19058782f, 0.10536385f, 0.18556395f, 
    -0.31848210f, -0.17753789f, -0.08223657f, 0.18327734f, 0.00502703f, 0.12476879f, -0.02355564f, 0.02020019f, 
    -0.04123927f, -0.05491639f, 0.12511051f, -0.05196748f, -0.04136231f, -0.03681521f, -0.10428055f, -0.14303753f, 
    0.11446738f, 0.01652153f, -0.03665842f, -0.02602616f, -0.06601547f, 0.03222309f, -0.01121525f, -0.03324990f, 
    0.05604317f, -0.05050369f, 0.02494255f, -0.02547427f, -0.13133964f, -0.02592586f, -0.02515919f, 0.05258702f, 
    0.01369153f, -0.05373570f, -0.05388704f, 0.04511159f, -0.05619304f, -0.11971852f, 0.22855853f, 0.41007650f, 
    0.00863313f, 0.05184794f, -0.08060429f, -0.15662798f, 0.11108764f, -0.03448017f, 0.00184112f, 0.01461024f, 
    0.05873566f, 0.11399052f, 0.27712366f, 0.01642817f, -0.08931833f, 0.03848796f, -0.14256753f, 0.02510392f, 
    0.04553184f, 0.08813205f, -0.03460168f, 0.17164259f, -0.12018532f, -0.18909788f, 0.20493783f, -0.12337491f, 
    -0.08076842f, -0.02912160f, 0.10928662f, 0.03966059f, -0.02243817f, -0.08346234f, -0.02842230f, -0.05141635f, 
    -0.17048249f, -0.08254156f, -0.06295048f, -0.01316443f, 0.06236882f, 0.09348069f, 0.13347094f, 0.05528041f, 
    0.04926119f, 0.01703092f, 0.17977157f, 0.15917982f, -0.15106297f, 0.06794333f, 0.29654858f, 0.21778439f, 
    0.00649287f, 0.00526801f, -0.06528887f, 0.00015947f, -0.05494121f, 0.04649524f, 0.28940544f, 0.00608924f, 
    -0.05878858f, -0.08668464f, -0.11046951f, 0.18770958f, -0.09000710f, 0.05109369f, -0.01664640f, -0.05061136f, 
    0.04803066f, 0.07797832f, -0.01575905f, 0.06607967f, -0.23748070f, 0.14407000f, 0.01038095f, 0.10195155f, 
    0.04427230f, 0.14152983f, 0.05390367f, -0.06516070f, 0.02317208f, 0.00934809f, 0.24553244f, 0.03821657f, 
    -0.00106486f, -0.27178806f, 0.09304820f, -0.04744063f, -0.00588457f, -0.17444785f, 0.07695879f, -0.02283864f, 
    0.19802433f, 0.09383670f, 0.03845646f, 0.05053037f, -0.06857865f, 0.04756339f, -0.00740252f, 0.06303269f, 
    0.06049088f, 0.04480706f, -0.02143096f, 0.17828520f, -0.14987673f, -0.03137578f, -0.10046676f, 0.08244713f, 
    -0.04325841f, 0.11960728f, 0.07272895f, 0.16850874f, 0.06757552f, -0.08713331f, 0.18932521f, -0.00116421f, 
    -0.02261564f, 0.06400307f, -0.08279588f, -0.06675950f, 0.22534622f, -0.03698779f, -0.00422104f, 0.17545557f, 
    -0.01918169f, 0.16319782f, -0.14045747f, 0.01217835f, -0.00546370f, 0.12515037f, -0.08918475f, -0.07348608f, 
    -0.24886468f, 0.24687421f, -0.19832754f, 0.03508309f, -0.05131160f, -0.06535544f, -0.05840598f, 0.03727382f, 
    0.05207253f, -0.06765360f, -0.07281876f, 0.12251002f, 0.01843418f, -0.23537257f, 0.07224272f, -0.21450426f, 
    -0.11834147f, 0.19144961f, -0.00465922f, 0.07880225f, -0.01510102f, 0.07099171f, 0.12620318f, 0.06285748f, 
    0.04384241f, 0.05332506f, 0.02816948f, 0.15924250f, -0.12244286f, 0.05192072f, 0.22012202f, 0.12238342f, 
    0.03817536f, 0.00200771f, -0.00073676f, -0.13524835f, -0.26837870f, 0.07216855f, 0.06798688f, 0.03785349f, 
    0.04784419f, 0.13055897f, -0.14440827f, 0.23023683f, 0.03255184f, -0.03012763f, 0.00823301f, -0.01685197f, 
    -0.08608452f, 0.28977516f, -0.13369153f, 0.08788415f, 0.06815989f, -0.10956127f, 0.16600069f, -0.02095802f, 
    0.06922931f, 0.00034219f, -0.10324380f, 0.04683286f, -0.09180246f, 0.02875694f, -0.12474059f, -0.05653732f, 
    -0.04597537f, -0.01206063f, -0.01128884f, -0.01819647f, 0.12930892f, -0.00278050f, 0.12029594f, 0.02501540f, 
    -0.17405958f, -0.23107642f, 0.08306944f, -0.09270890f, -0.23292239f, 0.05223591f, -0.06092149f, 0.14061497f, 
    0.17122252f, 0.09519518f, 0.09410713f, -0.06129523f, -0.08046877f, -0.04345304f, 0.40885115f, 0.17143734f, 
    -0.01167545f, 0.08253618f, 0.15410315f, 0.14381659f, -0.08678242f, -0.13196397f, 0.02842851f, -0.05433104f, 
    0.02427149f, 0.10928179f, -0.22094694f, -0.01462810f, -0.04419119f, -0.05461842f, -0.05359270f, -0.09608696f, 
    -0.01437993f, 0.03909715f, 0.06104963f, 0.10213500f, -0.04767821f, 0.02513533f, 0.29188034f, -0.04767152f, 
    -0.01760421f, -0.05128952f, -0.01538904f, -0.02687089f, 0.18332310f, 0.02639249f, 0.18670395f, 0.22671312f, 
    -0.05370248f, 0.13668710f, -0.04576153f, -0.15668306f, -0.09430190f, -0.12183235f, -0.08697259f, 0.09741176f, 
    0.03639713f, 0.10513524f, -0.12950175f, -0.09790467f, 0.55890256f, 0.28185859f, -0.01985552f, 0.27817756f, 
    0.05648192f, 0.08064988f, 0.11726546f, 0.01400478f, -0.12444676f, -0.04928468f, 0.02175838f, -0.03329485f, 
    0.00656515f, 0.85344994f, -0.28727069f, 0.23890059f, 0.06804169f, 0.01909200f, 0.27707723f, 0.02619994f, 
    -0.01683055f, 0.20755701f, 0.10068704f, 0.03716443f, -0.28402510f, -0.24266180f, 0.10610445f, 0.20622762f, 
    -0.04723571f, 0.09741808f, 0.00339072f, -0.01621847f, 0.05801119f, -0.00211932f, 0.33456969f, -0.40104520f, 
    -0.20954141f, -0.06287605f, 0.10386678f, 0.08072660f, 0.08249064f, 0.05273508f, -0.04060614f, 0.05822122f, 
    0.04981951f, 0.20620394f, -0.22466587f, 0.06959555f, -0.17014451f, -0.15537412f, 0.09245145f, -0.07821521f, 
    -0.10409644f, 0.05301017f, -0.10674843f, -0.02054394f, -0.04516833f, -0.20171921f, -0.08175088f, -0.22720201f, 
    -0.01299864f, -0.02015269f, -0.01410169f, 0.06184722f, 0.00774115f, -0.02771201f, 0.02797924f, 0.00978187f, 
    -0.06394531f, 0.09241869f, -0.05738122f, -0.33429930f, -0.19970413f, 0.44329643f, -0.17266475f, 0.26082116f, 
    0.04978246f, -0.00280691f, -0.01570057f, 0.00632058f, -0.07268895f, 0.15993470f, 0.08329068f, 0.20234573f, 
    -0.42564791f, 0.35434195f, -0.46670771f, -0.06833100f, 0.07696772f, -0.10138797f, 0.34844792f, 0.11439098f, 
    0.08902453f, 0.09332801f, 0.10459596f, 0.13280347f, -0.21258038f, -0.13983193f, -0.08282926f, -0.07598165f, 
    -0.11193161f, -0.07879515f, -0.10655795f, 0.03450004f, -0.13294345f, 0.04891836f, 0.06351671f, -0.03006669f, 
    -0.04564815f, 0.20318356f, 0.19883981f, 0.17736939f, -0.07527173f, 0.07630952f, -0.04503523f, -0.00424170f, 
    -0.10784770f, -0.04075428f, -0.01610350f, 0.05525604f, 0.02037043f, -0.23066421f, -0.27401772f, -0.07116225f, 
    -0.03678220f, 0.21556196f, 0.09270138f, 0.14215897f, 0.09792839f, 0.12879002f, 0.04143510f, 0.03716991f, 
    0.10008823f, -0.23892061f, 0.12922998f, -0.04320607f, -0.06431898f, -0.03489843f, -0.04520971f, 0.00011872f, 
    0.20251065f, 0.02195247f, 0.24479318f, 0.25973582f, -0.10172975f, -0.13710633f, 0.28032383f, 0.18642010f, 
    -0.07086735f, 0.01223355f, -0.08884822f, 0.00997578f, -0.05783005f, -0.07740686f, 0.06562469f, 0.13212791f, 
    0.12028652f, 0.16101207f, -0.05986699f, 0.01906764f, 0.03814517f, 0.01789097f, 0.05788505f, 0.16653605f, 
    -0.05151355f, 0.19044229f, 0.05181228f, 0.10493023f, -0.01382716f, 0.11081538f, 0.14953296f, 0.25848544f, 
    0.03651885f, -0.09024637f, 0.19044463f, 0.06932818f, 0.04046736f, 0.03700768f, 0.14760140f, 0.00759096f, 
    -0.20884554f, -0.06207438f, -0.06572624f, 0.10210439f, 0.08789143f, 0.05753824f, 0.21684214f, -0.07662643f, 
    -0.01817754f, 0.02828135f, 0.06686376f, 0.14193234f, 0.53048760f, 0.17493196f, 0.01627398f, 0.04735738f, 
    0.09630857f, -0.03130658f, 0.10111875f, 0.02579862f, 0.03946937f, 0.10489000f, 0.09234858f, 0.03917444f, 
    0.11201701f, -0.22499605f, 0.05314278f, -0.09904194f, 0.04121063f, 0.01993986f, 0.05469833f, -0.00051158f, 
    0.03570838f, 0.12422287f, 0.11288740f, 0.05050272f, -0.04899964f, -0.20125054f, -0.02226962f, -0.02080263f, 
    0.21455492f, 0.03704440f, 0.14186038f, -0.07135713f, -0.14550723f, -0.05287702f, -0.01874066f, 0.08803847f, 
    -0.13597225f, -0.24490705f, 0.37198433f, 0.00027910f, 0.16746452f, 0.16042154f, 0.03752490f, 0.14334379f, 
    0.06548957f, 0.01426954f, 0.01530332f, 0.06350568f, 0.01465745f, 0.19257934f, -0.10288049f, -0.12641193f, 
    0.05372382f, -0.03108400f, 0.04187494f, 0.14357190f, 0.04410530f, 0.10796860f, 0.23971273f, -0.04110837f, 
    -0.25771338f, 0.34341535f, -0.17798078f, 0.02948750f, -0.02762808f, 0.11791849f, 0.02299819f, -0.01420008f, 
    0.11192662f, -0.12846409f, -0.13949384f, -0.14899074f, -0.10646270f, -0.14644764f, -0.06699064f, -0.07429893f, 
    0.01554055f, -0.02991839f, 0.03772004f, -0.02530634f, 0.02498682f, 0.14224139f, -0.02382191f, 0.12716433f, 
    -0.16668440f, 0.00778725f, 0.14806795f, 0.19696949f, 0.10110755f, 0.16506842f, 0.02233793f, 0.03673944f, 
    -0.08968879f, -0.05267616f, 0.02530594f, 0.07415473f, 0.18564837f, 0.15040225f, 0.04216496f, 0.26060927f, 
    0.07049328f, 0.10785826f, -0.16446649f, 0.29569617f, 0.16040282f, -0.05505388f, 0.10036979f, -0.03650510f, 
    -0.02672726f, 0.08849357f, 0.13317883f, 0.14797348f, 0.25464639f, 0.15263084f, 0.15383831f, 0.04196306f, 
    0.17653030f, 0.17029527f, -0.07994308f, 0.25456455f, -0.09438377f, -0.06931317f, -0.14010432f, 0.05779114f, 
    0.08433849f, -0.08369876f, 0.04819046f, 0.08107298f, -0.00494798f, -0.00446977f, 0.24771550f, 0.40308845f, 
    -0.11422603f, -0.10083474f, -0.12425803f, 0.09119434f, 0.03576503f, 0.03667877f, 0.02288297f, -0.09849578f, 
    0.08023581f, 0.16644947f, 0.04076082f, -0.05102887f, -0.04944317f, -0.18636857f, 0.14374831f, 0.13172799f, 
    0.04316859f, 0.16657378f, -0.00881245f, 0.04632396f, -0.11662159f, 0.01494970f, 0.16714624f, 0.11822225f, 
    -0.12959592f, 0.03455309f, -0.12743303f, -0.10536356f, -0.01408996f, -0.06244563f, -0.08595650f, -0.01707692f, 
    -0.05981378f, 0.03115332f, -0.27156585f, -0.08997385f, -0.11642203f, 0.00599257f, -0.03925116f, -0.14959624f, 
    -0.00404187f, 0.00285146f, 0.03182013f, 0.08020068f, -0.06914733f, 0.07778677f, 0.13298766f, 0.28511471f, 
    -0.52471387f, 0.02593010f, 0.06490160f, 0.06986506f, 0.01712092f, 0.14769819f, 0.10922408f, -0.01072141f, 
    0.14370541f, -0.01922663f, -0.06926766f, -0.24694088f, 0.36338562f, -0.07400576f, 0.52318573f, -0.17283314f, 
    0.06031387f, 0.15887339f, 0.20726703f, 0.11035277f, -0.06066666f, 0.02889740f, 0.04215954f, 0.04486214f, 
    -0.12820038f, -0.03959247f, -0.20025279f, 0.16405657f, -0.01955541f, 0.15695025f, 0.04619269f, 0.05650787f, 
    -0.03175874f, -0.05858330f, 0.16078155f, 0.10115720f, -0.28671575f, -0.29338655f, -0.29006779f, -0.07850732f, 
    -0.04517525f, -0.09887464f, -0.01023440f, -0.05797129f, 0.09564440f, -0.00151807f, -0.03539785f, 0.07188371f, 
    -0.17545424f, -0.10573514f, 0.05631834f, 0.09371506f, 0.02840173f, 0.13904455f, 0.08737007f, -0.11096542f, 
    0.16354001f, 0.03031805f, -0.29184979f, 0.14390907f, 0.04504891f, 0.08038364f, 0.35918820f, -0.18556315f, 
    -0.08980036f, -0.13411622f, -0.10127627f, -0.09620374f, 0.05560001f, 0.07536813f, 0.13387644f, 0.12653397f, 
    -0.08860827f, 0.30688962f, 0.24920124f, -0.09400290f, -0.03291447f, -0.06822543f, -0.12319195f, 0.01113052f, 
    -0.09482110f, 0.36206850f, 0.10305492f, -0.01880307f, -0.21962649f, 0.39506295f, 0.13353319f, 0.12839438f, 
    0.02837406f, 0.00869845f, 0.08703864f, -0.04410021f, 0.07983141f, 0.05734709f, 0.00489384f, 0.17471159f, 
    -0.04158630f, 0.20948304f, -0.50118351f, 0.00780104f, -0.09675533f, -0.05085636f, 0.11175463f, -0.01326119f, 
    0.04124070f, 0.02085502f, -0.00648551f, 0.11067937f, 0.20136231f, 0.12278225f, 0.11410099f, -0.00586050f, 
    0.06791729f, 0.07517209f, 0.07126541f, -0.02181144f, 0.13297856f, 0.09018760f, 0.00379467f, 0.02538898f, 
    0.20007026f, 0.20481941f, 0.16738237f, 0.14524914f, -0.11484981f, -0.14166859f, -0.08132061f, -0.19114079f, 
    -0.11956863f, -0.02205482f, -0.02282625f, 0.04760310f, -0.25115708f, -0.27071977f, -0.26298723f, 0.01239578f, 
    -0.14347361f, 0.00490837f, 0.17825103f, -0.05001161f, 0.11342640f, 0.08313528f, 0.04072435f, -0.07419834f, 
    0.10398126f, 0.01683580f, 0.02967323f, -0.06298602f, -0.05791660f, -0.07048717f, 0.03529429f, 0.08384242f, 
    0.05673845f, 0.19012927f, 0.12615776f, -0.06555756f, 0.23179992f, 0.19885242f, 0.27423170f, -0.17843157f, 
    -0.20584965f, -0.00465905f, -0.05983276f, -0.08066581f, -0.25069126f, -0.09603070f, 0.03538859f, 0.13887808f, 
    -0.29166102f, 0.03242023f, -0.18765935f, -0.21713123f, 0.09158750f, -0.03949710f, 0.07939551f, 0.12064748f, 
    0.01114252f, 0.01453570f, 0.09092475f, 0.13199316f, 0.32760331f, 0.03616989f, 0.13437767f, 0.08559260f, 
    -0.00704705f, 0.01295662f, 0.12134867f, -0.05534386f, 0.16808806f, 0.03747533f, 0.02226938f, 0.12356801f, 
    -0.06942517f, -0.18830511f, -0.15080358f, -0.04315642f, -0.01639697f, -0.10909372f, -0.15053251f, 0.06343317f, 
    -0.11453228f, -0.08751033f, -0.06056693f, -0.03489806f, 0.43253464f, 0.03169599f, -0.08592766f, 0.02816685f, 
    0.32220650f, 0.00907913f, 0.06004166f, -0.03590414f, 0.18097334f, 0.00736031f, 0.13707530f, 0.21655993f, 
    0.01751555f, -0.35180229f, -0.05642156f, 0.00699210f, 0.01437590f, -0.04768033f, 0.16415618f, -0.09928580f, 
    -0.01994362f, 0.22473961f, 0.02425762f, 0.05227640f, 0.01239435f, -0.15358095f, -0.00338570f, 0.08181527f, 
    -0.10186815f, 0.12836899f, 0.00440015f, 0.16880913f, -0.03332867f, -0.01452911f, 0.05106864f, -0.05338914f, 
    0.07298419f, -0.10465430f, 0.15347406f, -0.13633038f, -0.11032332f, 0.02333547f, -0.13456304f, -0.00228348f, 
    -0.04121985f, -0.00212826f, -0.05407444f, 0.04459190f, 0.10967325f, 0.16295850f, 0.01242674f, 0.05549048f, 
    0.08864095f, -0.11928339f, -0.05044666f, -0.09660418f, 0.03961016f, 0.00316324f, 0.11479032f, -0.06484909f, 
    -0.07266006f, 0.24114719f, 0.02787677f, 0.02154594f, -0.08992598f, -0.04720380f, -0.14424235f, -0.09978859f, 
    -0.12371677f, 0.10735812f, -0.09106950f, 0.05940818f, 0.14237297f, -0.06892774f, -0.05336611f, -0.06393539f, 
    -0.09676714f, 0.15065503f, 0.13177152f, 0.18006544f, 0.03536714f, 0.01961028f, 0.13465603f, 0.10917564f, 
    0.06180159f, -0.15642069f, 0.18072227f, 0.18108772f, 0.03013377f, -0.09001679f, 0.05209997f, -0.03323566f, 
    -0.12992866f, -0.07717896f, -0.07173696f, -0.07077468f, 0.25895813f, 0.10204387f, 0.13993783f, 0.14379428f, 
    0.04112233f, 0.22150362f, 0.16549090f, -0.09891971f, -0.05192061f, -0.07119704f, -0.02079865f, -0.12187945f, 
    -0.11542593f, 0.13936587f, -0.07462613f, -0.04851139f, 0.05128921f, 0.12599641f, 0.13463207f, 0.15023386f, 
    -0.09036344f, -0.04369404f, 0.20904997f, 0.10680579f, 0.05264877f, 0.16586982f, 0.03564132f, -0.00966202f, 
    0.10188998f, -0.08206463f, 0.03584702f, -0.09464382f, 0.03650719f, 0.32385522f, 0.02069772f, -0.01052149f, 
    0.03203400f, -0.15077117f, 0.06508291f, 0.09913650f, -0.09785099f, -0.07582331f, 0.05424077f, 0.06584708f, 
    0.08524943f, 0.08858388f, -0.01256773f, 0.05616310f, 0.02304905f, -0.03886423f, 0.08707626f, -0.00042890f, 
    -0.05896425f, -0.11255460f, 0.12707961f, -0.09133343f, -0.00307442f, -0.07895622f, -0.13839993f, -0.09859457f, 
    -0.06093170f, 0.00373358f, 0.00454958f, -0.15994893f, 0.01185935f, -0.05336606f, -0.08602998f, -0.01891318f, 
    -0.19182138f, 0.08037200f, -0.16165525f, -0.14431292f, 0.01503750f, 0.07437662f, -0.21566780f, 0.00809106f, 
    -0.01913734f, 0.01974036f, 0.16003416f, -0.09039786f, 0.13994387f, 0.09496606f, 0.18722521f, 0.09326957f, 
    -0.04601219f, 0.09724735f, 0.15895124f, -0.06868365f, 0.02593057f, 0.06627375f, 0.11203517f, 0.17943421f, 
    0.04734005f, 0.04129400f, 0.12108094f, -0.10869601f, -0.06784520f, -0.29409149f, 0.50898558f, 0.01523457f, 
    0.14479573f, -0.22247054f, -0.09253442f, 0.08584236f, -0.12227648f, 0.08133251f, -0.08790989f, 0.04487516f, 
    0.00619599f, 0.46317825f, -0.31838068f, 0.08528374f, 0.11740384f, 0.06609807f, 0.07595230f, 0.14457287f, 
    0.04072504f, -0.02177906f, 0.27044669f, 0.14431611f, 0.25007117f, -0.29402700f, -0.29902419f, -0.17983948f, 
    -0.04586313f, -0.05066757f, -0.10189186f, -0.16209875f, -0.07322215f, -0.06855513f, 0.06854811f, -0.05323812f, 
    -0.09131759f, -0.24508084f, 0.09548159f, 0.15536216f, -0.02672397f, 0.21102126f, 0.18411256f, 0.13130268f, 
    0.13414803f, 0.01085217f, 0.02733994f, 0.08320750f, 0.00104776f, 0.13727002f, 0.38009429f, 0.02788905f, 
    -0.10371043f, -0.00497385f, -0.06384419f, 0.09960251f, -0.01217267f, 0.16636986f, 0.27485624f, 0.06944078f, 
    -0.15215932f, 0.06507483f, 0.20944183f, -0.00466968f, -0.05044352f, 0.02755575f, -0.05933682f, 0.03376591f, 
    0.02138288f, 0.23268962f, 0.04662667f, -0.24618927f, -0.15460533f, 0.15318663f, 0.26439017f, 0.08992597f, 
    -0.00234425f, 0.01270985f, 0.15368205f, -0.01438817f, 0.02820726f, 0.15159978f, -0.03925402f, 0.07308597f, 
    0.34531277f, 0.28656033f, -0.47459808f, -0.32523456f, 0.29093727f, 0.06826033f, 0.07466740f, 0.11123195f, 
    0.05162239f, 0.06639908f, 0.06508098f, 0.09860278f, 0.04249848f, 0.02409716f, 0.07350393f, -0.03948677f, 
    -0.14179417f, -0.03497922f, -0.10580011f, -0.13279641f, 0.00554440f, -0.13717486f, -0.07911894f, -0.06692903f, 
    0.34077320f, 0.21019067f, 0.16872717f, 0.10887104f, -0.02847110f, -0.07447466f, -0.11793948f, -0.14575675f, 
    -0.00701023f, 0.10564235f, -0.08222666f, -0.04631334f, -0.15701488f, -0.25325838f, -0.31390363f, -0.01589895f, 
    0.09396920f, 0.09188347f, 0.18438365f, 0.22444956f, 0.03051217f, 0.02916643f, -0.04313064f, 0.06424814f, 
    0.19786349f, 0.07359106f, 0.01962476f, -0.18708995f, 0.03371983f, 0.00816482f, 0.03282661f, 0.01275582f, 
    0.04476497f, 0.03717965f, 0.14418769f, -0.10213189f, 0.26115412f, 0.25703156f, 0.13175112f, 0.09260847f, 
    -0.08887127f, -0.09228775f, -0.03334409f, -0.03453396f, -0.04157109f, 0.09015214f, 0.05776463f, 0.17877601f, 
    -0.00244490f, 0.07056284f, -0.12544686f, -0.00634995f, 0.07305238f, 0.04652119f, 0.05345418f, 0.14079377f, 
    0.00434360f, 0.06584702f, 0.01888236f, -0.05226985f, 0.26020476f, 0.21312395f, -0.02075278f, 0.12645251f, 
    0.01680896f, 0.00323017f, 0.13804415f, 0.03238786f, -0.03982349f, -0.00408190f, -0.08619896f, 0.11076652f, 
    -0.08848441f, -0.06268112f, 0.02168871f, 0.07072712f, 0.01525526f, -0.17964898f, -0.11363895f, 0.06228219f, 
    -0.00708961f, -0.04849007f, -0.03880326f, 0.07597084f, 1.05090821f, -0.14006126f, -0.14822729f, -0.30392465f, 
    0.26420906f, -0.00755114f, 0.08677057f, -0.02661357f, 0.08896918f, 0.20714201f, -0.03706916f, 0.02968122f, 
    0.03420749f, -0.20677766f, 0.06295750f, 0.08423190f, 0.04529582f, 0.05370852f, 0.09566262f, -0.05312925f, 
    -0.08886628f, 0.08955520f, -0.05955563f, 0.01595852f, 0.01334291f, -0.23870686f, -0.02426885f, 0.03666101f, 
    -0.07612383f, -0.01241621f, 0.11600661f, -0.01224903f, -0.05506134f, 0.05421133f, 0.12489112f, -0.05047557f, 
    -0.05417418f, -0.22850414f, 0.07218277f, 0.09488658f, -0.06361043f, 0.14375535f, -0.02847960f, 0.13415647f, 
    -0.13016418f, -0.05605548f, 0.01013680f, 0.06291647f, 0.04991123f, 0.19529414f, 0.08308209f, -0.15989351f, 
    0.20979315f, -0.12183081f, 0.09200224f, -0.12111721f, 0.05707563f, -0.09838191f, 0.11406889f, -0.09032331f, 
    0.00279127f, 0.21229054f, 0.10987113f, 0.09753332f, -0.00420754f, 0.03155821f, -0.06801517f, -0.05732885f, 
    -0.06191917f, 0.06468558f, 0.10340033f, -0.04749665f, -0.02279538f, 0.04885974f, -0.10100502f, 0.00495700f, 
    -0.10272697f, -0.13551094f, 0.13745530f, 0.04908137f, 0.01914618f, 0.11129142f, 0.12448914f, 0.13727430f, 
    0.02840303f, -0.12441485f, -0.02190167f, 0.04884119f, 0.13256592f, -0.07896820f, -0.11795686f, -0.13397168f, 
    -0.02752884f, 0.05340759f, -0.06354701f, 0.00439966f, 0.26158890f, 0.12146657f, -0.07077985f, 0.13570981f, 
    0.12493990f, 0.09873674f, 0.16628096f, 0.03867945f, -0.04619194f, -0.02862794f, -0.00321556f, -0.00765237f, 
    0.30532157f, -0.07057050f, 0.05905141f, -0.05073552f, -0.04095688f, 0.06162567f, 0.03211498f, 0.18227984f, 
    -0.00192105f, 0.23009045f, 0.17254207f, 0.03926844f, 0.01389875f, 0.07034488f, -0.08458370f, -0.12406682f, 
    0.00500491f, 0.00761231f, 0.02161480f, -0.06697328f, -0.12018947f, 0.13764018f, 0.00103668f, -0.01227526f, 
    0.06377674f, -0.03981030f, 0.00945407f, 0.18533330f, 0.08717447f, -0.03384331f, 0.04350554f, -0.03118051f, 
    -0.02458908f, -0.02173081f, -0.02338486f, 0.06517692f, -0.15868720f, -0.06465359f, -0.04464900f, 0.00956529f, 
    -0.08545467f, -0.05135177f, -0.00626806f, -0.06816420f, 0.05592325f, 0.08610048f, -0.08602633f, 0.01490200f, 
    -0.02135027f, 0.04122644f, 0.11781474f, -0.11945446f, -0.03823107f, 0.04932263f, -0.08344720f, 0.05760711f, 
    0.05380315f, 0.06640108f, -0.15573354f, -0.24419716f, 0.14489883f, 0.18454248f, -0.39656797f, -0.14637959f, 
    -0.09570676f, -0.00605448f, 0.08369756f, -0.15518914f, -0.03716633f, 0.06207020f, -0.02209737f, 0.04515416f, 
    -0.09715046f, -0.23610440f, -0.14705564f, -0.14792283f, -0.00234584f, 0.00062840f, 0.06573815f, 0.18228918f, 
    0.01881120f, -0.04707031f, 0.03459859f, -0.08587791f, 0.07478719f, -0.26018193f, 0.55930269f, -0.21023864f, 
    -0.08627568f, -0.12318716f, -0.06384599f, -0.01158236f, -0.04890825f, 0.09950603f, 0.01994312f, 0.03953150f, 
    -0.01349235f, 0.00981013f, -0.02413220f, -0.01456044f, -0.03679096f, -0.02782115f, -0.05275516f, 0.04952464f, 
    -0.00198715f, 0.02944459f, 0.01893130f, -0.03289378f, 0.04358061f, -0.01461703f, 0.00182371f, 0.04598858f, 
    -0.04945327f, -0.04816549f, -0.02197360f, -0.03138099f, -0.01052674f, 0.01071209f, 0.03473959f, 0.01458256f, 
    0.00567094f, 0.00820383f, -0.01244200f, -0.04836352f, 0.03963682f, -0.01136175f, -0.00917908f, 0.03768067f, 
    -0.02441064f, -0.01403923f, 0.01980193f, -0.00061969f, -0.04473976f, -0.03402777f, -0.01245124f, 0.03180822f, 
    0.00364333f, 0.03810931f, 0.00108470f, -0.03082648f, 0.03739075f, -0.00288630f, -0.01434532f, 0.01920050f, 
    -0.02563274f, -0.02470500f, 0.00081809f, -0.04562101f, 0.03503010f, 0.02791955f, -0.02529690f, -0.01623954f, 
    -0.01547072f, -0.01951725f, 0.01410039f, -0.00481463f, -0.03628156f, -0.04479123f, 0.03212572f, -0.02459347f, 
    -0.04047862f, -0.00571709f, 0.03864066f, -0.04937354f, -0.00810831f, -0.01535095f, 0.03799715f, 0.02470697f, 
    0.04829438f, 0.00098690f, -0.00397493f, -0.04232684f, -0.02722017f, -0.02743789f, 0.04246958f, 0.00739720f, 
    0.03265136f, 0.04559786f, -0.05799444f, 0.02366194f, -0.01034173f, 0.01180659f, 0.03105522f, -0.00695189f, 
    -0.03467391f, 0.03177543f, -0.01168147f, 0.00577887f, -0.06016299f, 0.03021934f, -0.01907678f, -0.04053307f, 
    -0.01687577f, -0.01495857f, 0.03604536f, -0.02294184f, -0.03008899f, -0.03660493f, -0.00705350f, -0.05387505f, 
    0.00901023f, -0.03141765f, 0.01317163f, -0.03865180f, 0.00276448f, 0.03801027f, 0.01377587f, 0.03171840f, 
    -0.03392178f, 0.03351101f, -0.01817599f, 0.01955035f, 0.00988119f, 0.00761809f, 0.04173480f, -0.03800166f, 
    -0.05323642f, 0.01283002f, 0.03610032f, 0.04381023f, 0.00932697f, -0.03830088f, -0.05826137f, -0.01358917f, 
    -0.05198457f, -0.00431386f, -0.01730269f, -0.03227013f, -0.04104955f, 0.03403208f, -0.02924881f, -0.05615104f, 
    0.01353010f, -0.00392364f, 0.00687216f, -0.03419895f, -0.01518237f, -0.01691702f, 0.03033760f, 0.04589897f, 
    0.04622484f, -0.02024294f, 0.02857210f, 0.01806713f, -0.00021674f, -0.04875600f, 0.01534813f, 0.00911149f, 
    -0.02907722f, -0.05331101f, 0.04344663f, -0.03184750f, 0.02952967f, 0.03910388f, 0.02857372f, -0.04735097f, 
    0.00134781f, -0.04875584f, 0.02054817f, 0.01665148f, -0.03877142f, -0.05830960f, 0.02957031f, 0.03788336f, 
    0.01376288f, -0.03633042f, 0.00454893f, 0.02245926f, -0.05491214f, -0.01568268f, -0.02703815f, 0.03292004f, 
    -0.00625700f, 0.00882219f, -0.04721056f, 0.01922739f, 0.02507910f, 0.01018894f, -0.00279135f, -0.03185226f, 
    -0.03266409f, -0.01101533f, -0.03032855f, -0.03778044f, -0.02271835f, -0.05306596f, 0.02514066f, -0.02056820f, 
    -0.02229748f, -0.04262346f, -0.04730472f, -0.01028519f, 0.01494447f, 0.02774155f, 0.04332446f, -0.01407979f, 
    -0.03962572f, -0.01540576f, 0.00951315f, 0.03115511f, -0.05236838f, -0.01885072f, -0.02176404f, 0.00620167f, 
    0.00119016f, 0.03372205f, 0.01867690f, -0.05357712f, -0.03253303f, -0.05196615f, 0.00516449f, 0.00158687f, 
    0.04156529f, -0.03239263f, -0.02514454f, -0.03780408f, 0.01846104f, -0.04925989f, 0.04685872f, -0.03796411f, 
    -0.04962735f, -0.03621408f, 0.01316837f, 0.04085826f, -0.01841893f, -0.02931061f, -0.00540456f, -0.00585344f, 
    -0.02089489f, 0.00062790f, -0.02732131f, 0.02601957f, -0.01824427f, 0.01438290f, -0.01118233f, 0.00288365f, 
    0.04522825f, -0.01933067f, 0.00850235f, -0.02533671f, 0.00895777f, 0.01173643f, 0.01493765f, -0.03539817f, 
    0.00951000f, -0.00293816f, 0.01310750f, -0.01348836f, -0.03650871f, -0.00010124f, 0.03016925f, -0.02823783f, 
    0.02622764f, -0.05097611f, 0.01392806f, 0.03150674f, -0.04262136f, -0.02412278f, -0.00442418f, -0.03938197f, 
    -0.03328748f, -0.04892532f, -0.00172562f, -0.03188087f, -0.03511381f, 0.00699729f, 0.00080404f, -0.02444607f, 
    -0.00541665f, -0.05049019f, 0.03459345f, -0.00871813f, 0.01429313f, 0.03537857f, 0.01537873f, -0.00871880f, 
    0.01760872f, 0.01524520f, -0.02318861f, 0.00523093f, 0.04609068f, -0.04125004f, 0.02572420f, -0.04251868f, 
    0.01581445f, 0.00478831f, 0.01133802f, 0.02031149f, 0.00286175f, 0.00481705f, -0.03051231f, 0.01811621f, 
    0.03458367f, -0.01277194f, -0.02285793f, 0.02623944f, -0.02773738f, 0.00377369f, 0.01314005f, -0.01003530f, 
    -0.04939385f, 0.02718013f, 0.02003729f, -0.02329424f, -0.00202263f, -0.03609905f, -0.04215620f, 0.00280448f, 
    -0.03998993f, -0.00422635f, -0.01214527f, -0.04325234f, -0.04364954f, -0.04345835f, -0.00502113f, -0.03008070f, 
    0.02221895f, 0.01147384f, -0.00160789f, -0.04201172f, -0.02216425f, -0.00670531f, -0.05822378f, 0.00418140f, 
    0.00874616f, 0.03923139f, -0.03288936f, 0.00204863f, 0.01106749f, -0.04988768f, 0.00409650f, 0.00490611f, 
    -0.01699781f, 0.03823661f, 0.00979114f, 0.00714158f, 0.00079247f, 0.01852823f, 0.01345392f, -0.01381226f, 
    -0.00234539f, 0.03950462f, 0.03788074f, -0.00353349f, -0.05786059f, -0.03421847f, 0.01976990f, -0.00701097f, 
    -0.05275247f, -0.05003576f, 0.03706823f, 0.00633463f, -0.00261518f, -0.01445509f, 0.01493810f, 0.01569668f, 
    -0.03958746f, -0.05339874f, 0.03159923f, 0.00893335f, -0.02931269f, 0.00660730f, 0.01138772f, -0.01505884f, 
    0.00744923f, 0.00307971f, -0.03647957f, -0.02308839f, -0.00313332f, -0.04391192f, -0.00974637f, -0.00341459f, 
    0.02150989f, -0.03917538f, 0.03361331f, -0.05840970f, -0.01867598f, 0.04428554f, -0.00911544f, -0.02327199f, 
    0.67052585f, -0.07432216f, 0.24757548f, -0.34200308f, -0.02656412f, -0.13000295f, 0.22689810f, 0.07320360f, 
    0.06034042f, 0.07192650f, -0.19194500f, -0.04491552f, -0.05819196f, -0.16170166f, -0.09271257f, -0.02182702f, 
    0.03218452f, -0.03569694f, 0.03496366f, 0.13207008f, -0.03808530f, 0.09414957f, 0.05649216f, 0.06320628f, 
    0.08304562f, 0.10573789f, 0.07815350f, -0.20552425f, -0.00462318f, -0.11700882f, 0.04618870f, -0.00443684f, 
    -0.03206859f, -0.12902561f, 0.06921087f, -0.15926145f, -0.04882481f, -0.06497084f, -0.42851073f, -0.06363685f, 
    0.10327735f, -0.02002252f, -0.07467359f, -0.14329055f, -0.05728836f, 0.15332571f, 0.11382782f, -0.04533044f, 
    -0.03032111f, -0.26419300f, -0.26977578f, -0.12840141f, 0.03242294f, 0.08232308f, -0.00006005f, -0.00797007f, 
    0.01233422f, -0.28828979f, -0.16694342f, -0.01906432f, 0.39013970f, -0.39809808f, -0.07807916f, -0.35994273f, 
    0.11093713f, -0.00869666f, 0.00160002f, 0.01769668f, 0.17698605f, -0.11987237f, -0.00013165f, 0.07612383f, 
    0.14956984f, -0.05535151f, 0.56264269f, -0.20156698f, -0.19681688f, 0.00427738f, 0.17931099f, -0.08332792f, 
    0.18145847f, -0.23148963f, -0.18545710f, 0.01259878f, -0.00995901f, -0.03281438f, 0.04127814f, 0.09649692f, 
    0.06723303f, -0.01079299f, -0.08311697f, 0.01799371f, 0.01843002f, -0.00231653f, 0.01449307f, 0.01404036f, 
    -0.09921144f, 0.03394056f, -0.18130583f, 0.08074940f, -0.09299778f, 0.01268759f, -0.02734912f, -0.02095264f, 
    0.07686788f, 0.06717595f, 0.04849344f, 0.08566919f, 0.45375514f, 0.39932281f, 0.35944420f, -0.15662135f, 
    -0.08645286f, 0.09068885f, 0.11341870f, 0.03501047f, 0.15047975f, -0.14443702f, 0.03876381f, 0.02393363f, 
    -0.01287312f, -0.01689651f, -0.16098945f, 0.21522644f, 0.00006600f, 0.01592047f, 0.07805849f, 0.08571281f, 
    0.06420200f, 0.04627598f, 0.07492474f, -0.03185105f, 0.19026643f, 0.06325135f, -0.35083586f, 0.29391316f, 
    0.10325425f, 0.00822602f, -0.09577816f, -0.09088539f, 0.06055196f, 0.08541292f, 0.07777290f, 0.05297776f, 
    0.31074622f, 0.14544739f, 0.37151492f, 0.00492365f, -0.13945186f, -0.11255021f, -0.05313769f, 0.05423621f, 
    0.04813367f, 0.02559452f, -0.13419278f, 0.01880642f, -0.20365891f, -0.11404277f, -0.26001149f, -0.27065414f, 
    -0.00479933f, 0.06433404f, -0.14047346f, 0.12272722f, -0.04480490f, -0.08046748f, 0.00532432f, -0.18726394f, 
    0.35932735f, 0.33463085f, 0.37122604f, -0.00008876f, 0.17901132f, 0.22245006f, 0.35524008f, 0.16008325f, 
    0.02994594f, 0.01050103f, -0.05840758f, 0.12152209f, -0.73749650f, 0.24418689f, 0.30189970f, 0.21130562f, 
    -0.10532815f, -0.04925638f, -0.14208348f, 0.29097250f, 0.05069257f, -0.04173836f, -0.07861204f, 0.20954753f, 
    0.11419988f, 0.48881102f, 0.14350496f, 0.12957656f, 0.04728071f, 0.09050711f, -0.05108669f, 0.27775460f, 
    -0.12507296f, -0.17419527f, 0.00772322f, 0.08032934f, -0.06106921f, 0.05855560f, 0.01208973f, -0.02650522f, 
    -0.02229041f, -0.04728762f, 0.06568465f, 0.06567784f, -0.01347114f, 0.10266972f, 0.00509322f, -0.01664395f, 
    0.08997639f, 0.35202006f, 0.01894257f, 0.06630372f, 0.09501012f, -0.05341994f, -0.10477118f, 0.03013782f, 
    0.00192854f, 0.01425799f, 0.05241383f, 0.00230569f, -0.11158855f, -0.18720306f, 0.12731616f, 0.01459324f, 
    -0.01645697f, -0.08344094f, -0.04741863f, 0.14999391f, 0.08783487f, -0.00505292f, 0.00901969f, 0.18910776f, 
    0.04540604f, -0.31856066f, 0.01091207f, -0.16838807f, 0.04772614f, -0.04559394f, -0.08732918f, 0.01746689f, 
    0.17463399f, -0.07231242f, 0.14192486f, -0.13052875f, 0.01567408f, 0.01402918f, -0.03651218f, 0.05914237f, 
    0.06678285f, 0.00164756f, -0.02829941f, -0.05398374f, 0.12109789f, -0.06878566f, -0.16170497f, -0.12051050f, 
    0.24691188f, 0.33950144f, 0.01723199f, -0.20268270f, 0.10873451f, 0.17654604f, 0.13999394f, 0.24590948f, 
    0.06863208f, -0.04186267f, -0.01656779f, 0.03762730f, 0.12906156f, -0.03150906f, -0.08714914f, -0.02663387f, 
    0.02009062f, -0.01821828f, 0.17656350f, -0.06303789f, 0.00189987f, -0.01640402f, -0.09276956f, 0.06768856f, 
    -0.24320079f, -0.21006875f, 0.12096994f, -0.02554410f, 0.04732775f, 0.07851919f, -0.03540882f, 0.12502709f, 
    0.03517385f, 0.03530182f, -0.04286069f, -0.08534139f, 0.02114375f, 0.02482803f, -0.01696346f, -0.01893068f, 
    -0.05870302f, 0.10046306f, 0.01977842f, 0.08047663f, 0.01372387f, -0.21355169f, -0.00879576f, 0.08270229f, 
    0.30487135f, 0.43098700f, 0.18752876f, -0.04157923f, 0.17282006f, 0.02628084f, 0.08403597f, -0.02163276f, 
    -0.03617111f, -0.11761338f, 0.02300194f, 0.09146453f, 0.16092341f, 0.17979720f, -0.09317334f, -0.05258790f, 
    0.21116258f, 0.11942211f, -0.02396401f, 0.08787431f, -0.01930650f, 0.02567931f, 0.05524642f, 0.07115441f, 
    -0.09784422f, -0.06998603f, 0.02900073f, 0.03011055f, 0.07084641f, 0.04457183f, -0.02368193f, 0.02281502f, 
    0.10162672f, -0.12276886f, 0.14449866f, 0.11721271f, -0.12594317f, -0.15261915f, 0.08118302f, 0.13428274f, 
    0.03268515f, -0.03374973f, -0.07551517f, 0.09137832f, 0.10304412f, 0.03784559f, -0.12330656f, -0.01502804f, 
    0.08954895f, -0.29412630f, -0.31164354f, 0.03029622f, 0.11000638f, 0.11073328f, 0.11021976f, 0.00781133f, 
    0.15739283f, -0.06860972f, -0.16796152f, -0.07543499f, -0.12753293f, 0.14607252f, -0.17841433f, 0.24821173f, 
    0.16243938f, 0.02304607f, -0.18101159f, -0.07051741f, 0.01483832f, -0.02045317f, 0.00687865f, 0.01130923f, 
    0.69481635f, -0.26261920f, 0.21020259f, -0.08024704f, -0.03503956f, -0.09690963f, 0.13345288f, 0.02012516f, 
    0.19392121f, 0.00874084f, 0.10847706f, -0.08223434f, 0.07760142f, 0.06274617f, -0.06579859f, -0.22304936f, 
    -0.17171881f, -0.03913567f, 0.13702126f, 0.12558952f, 0.14859711f, -0.09166973f, 0.06837193f, 0.10432967f, 
    0.00659482f, 0.05887834f, 0.01916661f, -0.11713571f, 0.21591289f, 0.00437045f, 0.08572519f, -0.01030635f, 
    -0.04232293f, -0.10109216f, -0.03400112f, -0.06766400f, 0.10015485f, 0.07843883f, -0.09842186f, -0.00309669f, 
    0.03727921f, -0.11370888f, -0.19674428f, -0.21918313f, -0.25067174f, -0.10233545f, -0.18099682f, -0.00098231f, 
    -0.01372997f, -0.00070632f, 0.01050924f, 0.02032954f, 0.08482958f, -0.09241103f, -0.06768201f, 0.00846196f, 
    -0.14175096f, -0.12737441f, -0.06330246f, -0.01752984f, 0.44705275f, 0.23030680f, -0.21277696f, -0.10719258f, 
    0.05966584f, 0.00513219f, -0.06072829f, -0.14259195f, 0.18016827f, -0.09894004f, -0.10320061f, 0.10893061f, 
    0.21295333f, -0.07992007f, -0.00332762f, -0.03955735f, -0.11556803f, 0.01111072f, 0.09330275f, 0.00993938f, 
    0.18718748f, -0.04246786f, -0.04261955f, -0.14139220f, 0.00788942f, -0.04016590f, 0.19009025f, 0.10507751f, 
    -0.11840875f, -0.08196192f, -0.01084444f, 0.06793430f, 0.00838150f, -0.00563196f, -0.03777059f, 0.00962872f, 
    -0.13556439f, 0.18993968f, -0.24923378f, -0.07402944f, -0.14529066f, -0.07419052f, 0.10545781f, -0.05630764f, 
    -0.05891485f, 0.08269081f, 0.11285464f, 0.15238777f, -0.06527633f, -0.06399341f, -0.01830689f, -0.14526252f, 
    -0.11189849f, 0.07500630f, -0.06053643f, -0.24365216f, 0.06952878f, -0.08981020f, -0.02827662f, 0.08731695f, 
    0.12537536f, 0.08688710f, -0.13937688f, 0.14364181f, -0.06098139f, -0.11885469f, 0.20135911f, 0.02187290f, 
    0.22486471f, 0.12775135f, 0.01378296f, 0.11077351f, 0.31341916f, 0.33040076f, 0.00544527f, 0.07797515f, 
    -0.13904504f, -0.00294119f, 0.04031517f, -0.01711979f, -0.01774557f, 0.06082391f, -0.07458233f, 0.08659226f, 
    -0.02218245f, 0.15672708f, 0.12215264f, -0.11500205f, -0.03797038f, 0.04775464f, 0.05264544f, -0.15334162f, 
    0.14750560f, 0.06700561f, -0.18057932f, 0.05672856f, -0.07223963f, -0.07305153f, 0.14115115f, 0.06618559f, 
    0.08426572f, -0.03389991f, -0.10164753f, 0.00051848f, 0.19047253f, 0.14862563f, 0.10384361f, -0.03371716f, 
    0.27678221f, 0.08772235f, 0.05627808f, -0.11340892f, 0.01859619f, -0.01588258f, 0.07984642f, 0.02420290f, 
    -0.00229965f, -0.09173264f, 0.01202547f, -0.01956736f, -0.27042112f, 0.18666151f, 0.18130438f, 0.20933437f, 
    -0.00892232f, 0.27953863f, 0.12968680f, 0.13289501f, 0.17065546f, -0.03909908f, 0.22246031f, 0.01308727f, 
    -0.04389666f, 0.10978847f, -0.05962639f, 0.20584589f, 0.14407340f, 0.09160455f, -0.12253857f, 0.18726915f, 
    -0.05956950f, -0.08590114f, -0.02667698f, -0.02645778f, -0.22764514f, -0.06870389f, -0.00250159f, -0.14982660f, 
    -0.09540623f, -0.07568997f, 0.05057143f, -0.01707976f, -0.22301038f, 0.21228081f, -0.08779702f, 0.09378922f, 
    -0.08785781f, -0.08074254f, -0.02164444f, -0.09656715f, 0.04711229f, -0.07323208f, -0.00687078f, -0.04091597f, 
    0.02917117f, 0.00895730f, 0.04907124f, -0.04585529f, 0.07205861f, 0.05078164f, 0.03471840f, 0.01677933f, 
    -0.04930028f, -0.10042813f, -0.15706939f, 0.08979896f, 0.07755031f, -0.02615792f, 0.09137188f, -0.03553137f, 
    0.14808419f, -0.19874701f, 0.24936216f, -0.15047963f, -0.02372075f, -0.02232929f, -0.11403219f, -0.03977048f, 
    0.11212082f, -0.09096130f, 0.06616241f, -0.25065428f, 0.00802383f, -0.08554779f, -0.07859504f, 0.07274287f, 
    0.07441105f, -0.00397968f, 0.16539791f, 0.06389077f, 0.11759546f, 0.02542903f, -0.04820904f, 0.01876537f, 
    0.12002093f, 0.06625087f, 0.28492326f, -0.11974692f, 0.09538889f, -0.01461332f, 0.07702605f, 0.14038055f, 
    -0.04879287f, -0.06909152f, 0.00812636f, -0.04639614f, 0.01155140f, 0.20794734f, 0.06991912f, -0.06802998f, 
    -0.04558418f, 0.08360559f, 0.11769019f, -0.13883100f, 0.14061347f, 0.02496435f, -0.07433597f, -0.08884221f, 
    -0.21262616f, -0.15688142f, 0.00827532f, -0.19914094f, 0.16387577f, -0.01041936f, 0.01749770f, 0.07832550f, 
    -0.06079618f, -0.03241652f, 0.06886323f, 0.01420709f, -0.13965458f, -0.00169018f, 0.05348429f, -0.14830528f, 
    0.03488844f, 0.17873314f, -0.01915305f, -0.04939304f, 0.14266965f, 0.00254304f, 0.08479659f, 0.22495244f, 
    0.23318774f, 0.09846057f, 0.14042275f, -0.02709211f, 0.12485832f, 0.01496063f, 0.12531540f, -0.07502745f, 
    -0.02511325f, -0.03384047f, -0.05820350f, 0.08026107f, -0.06258561f, -0.19125180f, 0.01266238f, -0.00438235f, 
    0.09118780f, 0.00354011f, 0.01504440f, 0.03328187f, 0.01165149f, -0.09355474f, -0.06501951f, 0.23454992f, 
    0.04079078f, 0.03704950f, 0.20409742f, 0.03979279f, 0.14338602f, -0.08933264f, -0.02430458f, 0.09194795f, 
    -0.12106326f, -0.13016912f, -0.02826308f, -0.00351299f, 0.10362960f, -0.06852808f, 0.13955374f, 0.14719541f, 
    -0.02655220f, 0.00528674f, 0.09580491f, 0.03907671f, 0.06864811f, 0.28987092f, -0.01954948f, 0.04630655f, 
    -0.00222009f, 0.06941661f, -0.10073940f, -0.18338372f, -0.19249456f, 0.04279292f, 0.01642186f, 0.06926393f, 
    0.06341950f, -0.03926172f, -0.01821062f, 0.00802961f, -0.24651173f, 0.44175756f, 0.25933239f, -0.21993196f, 
    0.07339868f, 0.15966359f, 0.06508819f, 0.01124916f, 0.03955549f, 0.02436916f, -0.01538298f, 0.07218829f, 
    -0.23712142f, -0.22147898f, 0.36728847f, -0.16403200f, -0.05480406f, 0.05559923f, -0.05649547f, 0.14450914f, 
    0.08427078f, 0.08575862f, -0.03925071f, -0.17979130f, 0.25090846f, 0.09792545f, 0.29381761f, 0.08514258f, 
    -0.00384520f, -0.02401554f, -0.10563865f, 0.02731226f, -0.00531731f, 0.02799940f, 0.16265959f, 0.11203490f, 
    -0.03224961f, 0.08800771f, -0.10820672f, -0.28794324f, 0.00508133f, -0.06894370f, 0.11377829f, 0.13828449f, 
    0.02425620f, 0.02540937f, 0.20767774f, -0.16027507f, -0.11197685f, -0.01332388f, -0.46191272f, -0.16439158f, 
    0.03123936f, 0.11632677f, 0.20598811f, 0.09328402f, 0.00250040f, -0.11083668f, -0.07557973f, -0.26278117f, 
    0.29099029f, -0.04351230f, -0.17495154f, -0.06536011f, 0.00927818f, 0.10885099f, 0.26791874f, -0.01356088f, 
    0.25150752f, -0.11110085f, -0.09814710f, 0.02283912f, 0.31283888f, 0.09991108f, -0.16315098f, -0.02180689f, 
    -0.00528220f, 0.04235701f, -0.03178847f, 0.04196392f, 0.07640394f, -0.06744543f, 0.17133605f, -0.00172516f, 
    -0.28380990f, -0.46788445f, 0.61759740f, 0.22772577f, -0.07711103f, -0.08671913f, -0.15814120f, 0.15524861f, 
    0.04955170f, -0.04840885f, -0.04322290f, -0.09255771f, -0.19125110f, -0.11383633f, -0.13955948f, -0.07960202f, 
    0.11284019f, 0.08672672f, 0.02668887f, 0.04517773f, 0.01537891f, 0.10218796f, 0.14353478f, 0.13027099f, 
    0.11645038f, -0.04620467f, -0.08681748f, 0.02733117f, 0.06560532f, 0.18671018f, 0.14950332f, 0.12910302f, 
    0.00981935f, -0.13762324f, 0.04612438f, 0.00836677f, -0.15599434f, -0.06917500f, 0.37755215f, 0.00706064f, 
    0.11857132f, -0.00495555f, -0.12362121f, 0.03021805f, -0.04282058f, -0.17927130f, -0.04872795f, -0.04326527f, 
    0.02499202f, 0.12064114f, 0.04295256f, 0.25555077f, -0.00989859f, 0.01730137f, -0.10434026f, -0.19591270f, 
    0.09179290f, -0.04485848f, -0.03500244f, 0.25956947f, 0.07197705f, -0.03397620f, -0.35017616f, 0.00169254f, 
    0.03024432f, -0.14363945f, 0.08618830f, 0.05553599f, 0.27417499f, -0.05082866f, 0.00031655f, -0.13557683f, 
    0.00883731f, 0.03169673f, 0.02491639f, 0.43156987f, 0.11178666f, 0.04504697f, 0.08628795f, -0.09033901f, 
    0.10247228f, 0.05434172f, 0.05818311f, 0.00627044f, -0.08932925f, 0.11075061f, -0.02803671f, 0.03482013f, 
    0.03562451f, -0.02578541f, 0.04525439f, 0.17449336f, 0.05843125f, 0.19963112f, 0.07039807f, 0.16049190f, 
    -0.24562703f, 0.06473880f, 0.18748547f, 0.00921849f, -0.09910331f, 0.16999820f, 0.00260946f, 0.05686756f, 
    0.09119827f, 0.05559753f, 0.03328595f, 0.06244880f, -0.65957898f, -0.10603534f, -0.24079335f, 0.43191707f, 
    -0.04954042f, 0.13438749f, -0.22953677f, -0.00098331f, 0.02297661f, 0.06789424f, -0.08049075f, -0.08750499f, 
    -0.35375184f, 0.09777574f, 0.17483510f, -0.05541471f, 0.10954840f, 0.07187896f, -0.00916320f, 0.12344451f, 
    0.10339938f, -0.06069205f, -0.01350675f, 0.09474895f, -0.08353299f, 0.19927698f, -0.28788388f, -0.10174146f, 
    0.15602982f, 0.05198781f, 0.15189078f, -0.12764820f, 0.14398551f, -0.11045884f, -0.07031747f, 0.04133439f, 
    -0.19946395f, 0.09034959f, -0.15990400f, -0.06572017f, 0.13469341f, -0.01505260f, 0.18743926f, -0.05541461f, 
    -0.06279904f, -0.03505613f, -0.04323424f, 0.02990463f, -0.01832326f, -0.21161664f, 0.07392593f, 0.08246987f, 
    -0.03138885f, 0.11166897f, 0.06949642f, 0.13847026f, -0.04931995f, 0.08597238f, 0.00395549f, 0.13517900f, 
    0.30889562f, -0.40526053f, 0.18169308f, -0.32066765f, 0.04489499f, 0.12836455f, -0.03314214f, -0.01727907f, 
    0.06316067f, 0.07123286f, 0.10762374f, -0.11329854f, 0.00182750f, 0.13807736f, 0.15247789f, -0.01329718f, 
    0.13695277f, -0.16958676f, -0.01467673f, -0.18797830f, 0.08479153f, 0.23919170f, -0.01620704f, -0.05734739f, 
    -0.26794362f, 0.06184129f, 0.07720990f, -0.06162744f, -0.03407152f, 0.15132552f, 0.00924254f, 0.14966883f, 
    0.11547907f, -0.08898041f, 0.04684240f, 0.04259165f, -0.27036020f, 0.02510458f, -0.07266314f, -0.22146091f, 
    0.09588226f, -0.17613909f, -0.00759202f, 0.12746160f, 0.10328031f, 0.02324395f, 0.06472803f, 0.05771010f, 
    -0.16920552f, 0.01894207f, -0.05443601f, 0.41605920f, 0.00173238f, -0.09559048f, 0.07114096f, -0.04505859f, 
    0.14330460f, -0.01438635f, -0.03550655f, -0.07862376f, 0.10744650f, -0.22787619f, 0.09728095f, 0.04381272f, 
    -0.00260427f, -0.02819307f, -0.08170816f, 0.10221981f, 0.16993006f, -0.11719661f, 0.16101821f, 0.28428480f, 
    -0.17482935f, 0.17534150f, 0.07197519f, -0.21451582f, -0.03483558f, 0.05902714f, 0.09019808f, 0.05423987f, 
    -0.01064400f, 0.09192046f, 0.09366942f, -0.11269145f, -0.18023713f, 0.05644810f, -0.25593367f, -0.13877128f, 
    0.28951198f, 0.23029813f, 0.00280317f, -0.03985731f, -0.10442241f, 0.01245713f, 0.16694528f, 0.12096510f, 
    0.02887829f, -0.22909313f, -0.04783237f, 0.07701185f, -0.04271544f, 0.12023260f, 0.03959285f, -0.01357562f, 
    0.23616911f, 0.04915274f, 0.21681355f, 0.12379260f, 0.16450720f, -0.15714261f, 0.23926373f, 0.28546652f, 
    0.12148042f, -0.00336157f, -0.21362993f, 0.09950097f, 0.10928416f, 0.13822325f, 0.06330848f, 0.24294709f, 
    0.17402817f, 0.12437490f, 0.19313313f, 0.02105086f, -0.16914259f, -0.21050237f, -0.20767710f, -0.08487663f, 
    0.04661010f, 0.08708730f, 0.08336228f, 0.06070761f, 0.03113937f, 0.51512951f, -0.85556358f, 0.33905926f, 
    0.22902919f, 0.16529329f, 0.18913904f, -0.19150354f, -0.02217062f, -0.05293824f, 0.09668712f, 0.01074447f, 
    -0.07777843f, -0.43366230f, 0.19899766f, 0.05234946f, 0.06861436f, 0.14535977f, -0.06152337f, -0.02900963f, 
    -0.09522994f, -0.18015961f, -0.01980794f, 0.20078710f, 0.07456009f, 0.39049941f, 0.01924054f, -0.30728492f, 
    0.00106665f, 0.04631405f, 0.02395427f, -0.00221281f, -0.04063516f, -0.03792181f, -0.24357302f, 0.16681622f, 
    0.19815491f, 0.18149450f, -0.04924157f, 0.00901752f, 0.06127597f, 0.01871350f, 0.04033769f, 0.08102334f, 
    -0.08722531f, -0.00529129f, -0.00591085f, -0.02878497f, 0.11277989f, -0.00287963f, 0.12336402f, 0.20477507f, 
    -0.13519944f, -0.13303649f, 0.05257414f, 0.07178113f, 0.00540865f, 0.07250835f, -0.18481708f, 0.36553210f, 
    -0.01301557f, 0.12005838f, 0.02118228f, 0.18811594f, -0.08045532f, -0.10020962f, 0.05057250f, -0.04646508f, 
    -0.08684688f, 0.05318558f, 0.01271107f, 0.23638844f, -0.19981009f, -0.16776872f, 0.14992088f, 0.30826905f, 
    -0.16181055f, 0.00689646f, -0.08449716f, 0.14228806f, -0.25963292f, -0.12784702f, -0.06600153f, -0.13322853f, 
    0.12181851f, 0.12947819f, -0.00573366f, 0.29505619f, 0.14181055f, 0.17882083f, 0.02352376f, 0.03959221f, 
    -0.01840471f, 0.06378001f, 0.12084195f, -0.03999193f, 0.22144914f, 0.05365529f, -0.08196059f, -0.16152953f, 
    0.06109484f, 0.05434543f, 0.07434144f, 0.00839054f, -0.06588034f, 0.06422909f, 0.09278855f, -0.12505783f, 
    -0.02896948f, -0.28661636f, -0.19349666f, -0.02351373f, 0.01108685f, -0.10585988f, -0.05574344f, 0.11533624f, 
    0.09044435f, -0.03890964f, 0.02251740f, -0.05146491f, 0.01543757f, 0.37188518f, 0.09267911f, 0.25648221f, 
    0.02976904f, -0.04826254f, 0.09671889f, -0.00265744f, -0.02089103f, 0.11009831f, -0.03103818f, -0.04696492f, 
    0.02591474f, 0.17526649f, 0.16577828f, -0.00661812f, 0.05090525f, -0.00927270f, -0.07956264f, 0.02209982f, 
    -0.01537417f, -0.02478879f, 0.05380623f, 0.07389305f, -0.22619691f, -0.12637223f, 0.23319978f, 0.06750546f, 
    -0.10257353f, 0.04234299f, 0.10899288f, 0.04780582f, -0.04561399f, -0.10302456f, -0.02801343f, 0.05645456f, 
    -0.16580696f, -0.09821613f, -0.04758349f, -0.05722927f, 0.05125403f, 0.15561643f, 0.06103820f, -0.05774314f, 
    -0.04323823f, -0.08574171f, 0.06395919f, 0.04494047f, 0.10447596f, -0.14798547f, 0.16295654f, 0.13514008f, 
    -0.03625703f, 0.00085626f, 0.06856608f, -0.04191970f, 0.05116282f, 0.01475925f, 0.03245558f, 0.03864334f, 
    0.22903974f, 0.00011372f, -0.21773855f, -0.12303247f, 0.04888168f, 0.09063558f, -0.14058688f, 0.03701652f, 
    -0.09315731f, 0.00809591f, 0.11144583f, 0.03128540f, -0.61782992f, 0.14037551f, 0.36767519f, -0.12464878f, 
    -0.18725358f, 0.10225191f, -0.06950510f, -0.11827262f, 0.08182477f, -0.12892845f, 0.32570586f, 0.04922136f, 
    0.02584506f, 0.00216023f, -0.03326466f, -0.04311310f, -0.09605510f, -0.01665564f, 0.11053814f, 0.17309463f, 
    0.20023459f, 0.21139523f, 0.03955745f, -0.06203622f, 0.09639670f, 0.16281791f, 0.17162226f, -0.09828511f, 
    -0.04307792f, 0.07767775f, -0.16801691f, 0.10025880f, -0.19941622f, 0.06109596f, -0.13069293f, -0.15331067f, 
    0.20165697f, 0.21002828f, -0.10791624f, -0.03345272f, -0.01674814f, -0.02853931f, 0.19350289f, -0.07629687f, 
    -0.03232748f, 0.15128885f, 0.01422791f, -0.05428833f, -0.01988720f, -0.16307980f, -0.16430344f, -0.06844104f, 
    0.04925571f, 0.11146711f, -0.01948562f, -0.20809945f, 0.06126870f, -0.04313466f, -0.17826405f, -0.22600834f, 
    0.09092254f, 0.17456754f, 0.09776537f, -0.05894237f, -0.10545677f, -0.05122804f, -0.07453391f, 0.02484601f, 
    -0.09713462f, 0.13292316f, 0.08759020f, 0.26902959f, 0.14019449f, 0.03359684f, 0.06600745f, 0.02991222f, 
    -0.02952171f, 0.09789811f, 0.03532682f, -0.00778203f, -0.19117786f, -0.13811305f, 0.07550880f, -0.05437011f, 
    0.24491772f, 0.00724716f, -0.18772045f, 0.08583859f, -0.05130440f, 0.00229620f, 0.12063950f, 0.03273728f, 
    -0.08995159f, 0.04773145f, 0.03660594f, -0.00695703f, -0.00919717f, -0.18081872f, 0.00742933f, 0.00409064f, 
    0.15332942f, -0.00686586f, -0.01374833f, 0.01693509f, 0.08205846f, 0.06654505f, -0.01666561f, 0.06913657f, 
    0.16350007f, 0.37965840f, -0.10019432f, -0.07352503f, -0.01785887f, -0.00751052f, -0.05719133f, -0.11852640f, 
    -0.16354971f, -0.11112721f, -0.19198301f, -0.02724993f, 0.00638166f, 0.12239870f, 0.04350963f, -0.08234119f, 
    -0.05992559f, 0.02026264f, 0.09999216f, -0.06281985f, 0.14776793f, -0.01421561f, -0.07095000f, -0.27938706f, 
    0.15169553f, -0.10148225f, -0.05539629f, 0.08320297f, 0.07531705f, 0.13166101f, -0.05662781f, 0.13031533f, 
    0.15966007f, 0.06499166f, -0.07741934f, 0.04471762f, 0.01131364f, 0.06226455f, 0.17552155f, 0.16672082f, 
    -0.09920242f, -0.02566675f, 0.03417293f, 0.11588217f, -0.01577557f, -0.15647568f, -0.12906338f, -0.06868252f, 
    -0.03635229f, 0.07054835f, -0.14193480f, -0.06291731f, -0.00605344f, -0.00307280f, 0.15917489f, -0.24397895f, 
    0.00525140f, 0.08039431f, 0.08482583f, 0.16892207f, -0.03425331f, 0.08239501f, 0.19172882f, -0.00706523f, 
    -0.11889782f, 0.01721021f, 0.06895408f, -0.16931385f, 0.01085818f, 0.04517521f, 0.00533262f, -0.03943545f, 
    0.50312746f, 0.03975747f, -0.21546575f, -0.10111029f, 0.09401093f, -0.07687432f, -0.08101410f, -0.02457426f, 
    -0.07072972f, 0.09382431f, -0.07949816f, -0.03767279f, -0.17832120f, 0.17806935f, -0.37632886f, 0.34062824f, 
    -0.12344120f, 0.02339574f, 0.01635823f, -0.08048313f, -0.03462121f, -0.02812338f, -0.12999368f, 0.04073638f, 
    -0.04571809f, -0.02222769f, 0.03970275f, -0.04314170f, -0.03902507f, 0.00958209f, -0.04777931f, -0.05688615f, 
    -0.02050221f, 0.00974745f, -0.04553150f, -0.00847812f, -0.02060414f, -0.02578546f, -0.02424159f, -0.05482330f, 
    0.04325301f, -0.05263965f, -0.01481351f, 0.02264998f, 0.01779905f, 0.03282237f, 0.03663303f, 0.02950325f, 
    0.00709414f, 0.01194474f, -0.03955042f, -0.01704517f, 0.00146841f, -0.02869688f, 0.04122299f, 0.03238914f, 
    0.00169213f, -0.00530040f, 0.04259747f, -0.03359985f, -0.01830712f, -0.00627356f, -0.04884230f, 0.03165059f, 
    0.02094085f, 0.01565637f, -0.00872750f, 0.03258864f, 0.03822533f, -0.02390169f, -0.01984558f, -0.03933007f, 
    -0.02742482f, 0.01492300f, -0.00497024f, -0.03849195f, -0.04172280f, -0.03527361f, -0.01630070f, -0.05043657f, 
    -0.00515522f, 0.04342782f, 0.05049982f, -0.04688509f, 0.02542988f, 0.01282363f, -0.03206344f, 0.02088188f, 
    -0.02877959f, -0.02979352f, 0.00190785f, -0.01483468f, 0.00652686f, 0.03092095f, 0.01890873f, -0.05183143f, 
    -0.02775552f, 0.00640518f, 0.02975468f, -0.04013888f, 0.03937218f, 0.04971697f, -0.03691260f, -0.02182239f, 
    -0.01232883f, 0.00310333f, -0.02221903f, -0.00735580f, 0.04727575f, -0.03476286f, -0.04635040f, -0.04493008f, 
    0.01570904f, -0.01443738f, -0.01996247f, 0.00972316f, -0.02939563f, 0.02838613f, -0.05503367f, -0.02170540f, 
    -0.00527960f, 0.03832151f, 0.01931847f, -0.02611287f, -0.05086742f, -0.00851915f, 0.03349385f, -0.00764014f, 
    0.00719646f, -0.02012664f, 0.00039752f, -0.01455552f, -0.03986423f, -0.01344725f, -0.02589622f, -0.00926731f, 
    0.02411614f, 0.04470259f, 0.02237672f, 0.02625928f, -0.02186474f, -0.05598882f, -0.02447999f, -0.03927694f, 
    0.04025317f, 0.00055674f, -0.05664944f, -0.04620589f, -0.03907369f, -0.02861530f, -0.02708672f, 0.02731888f, 
    -0.00164246f, -0.04177421f, -0.04235362f, 0.04052003f, -0.02909002f, 0.01663613f, 0.00556422f, -0.02919683f, 
    0.02579334f, 0.00543319f, -0.01830953f, -0.04579267f, -0.05468448f, -0.04032708f, -0.00230870f, -0.01132093f, 
    -0.04481957f, -0.04215713f, -0.00151676f, -0.00881268f, -0.05076434f, -0.02041497f, -0.01401591f, 0.03923883f, 
    -0.00293508f, -0.03499256f, -0.01520794f, 0.03676803f, 0.00539902f, -0.01566718f, 0.00421699f, 0.03709330f, 
    -0.00035165f, 0.01614007f, -0.00354382f, -0.02773690f, 0.01117398f, -0.04031446f, -0.01966238f, 0.02822904f, 
    -0.00641244f, -0.02147995f, -0.00173955f, -0.04181962f, 0.00034083f, 0.03879671f, -0.03130339f, 0.01575204f, 
    -0.02436432f, 0.02001887f, 0.04353432f, -0.02468780f, -0.04374379f, -0.01292508f, -0.00170028f, -0.02809050f, 
    0.03214864f, 0.01321215f, -0.01862002f, -0.03124975f, -0.04149442f, -0.03195449f, 0.03290927f, -0.01180624f, 
    -0.05247415f, 0.00708550f, -0.02078811f, 0.03397068f, -0.03392045f, -0.05199082f, 0.03121772f, -0.00448100f, 
    0.04204898f, -0.01568287f, -0.01828216f, -0.03981878f, -0.01896340f, 0.01782391f, 0.00418421f, -0.00119836f, 
    0.02886445f, 0.00611944f, 0.01723052f, -0.00507878f, 0.04854817f, 0.01177600f, -0.05440257f, 0.00261589f, 
    0.02828391f, -0.04766329f, 0.01769872f, -0.00075415f, -0.02908888f, -0.01403329f, 0.01730137f, -0.05560457f, 
    -0.02487907f, -0.01719982f, 0.03692225f, -0.00158707f, 0.02997370f, 0.02821496f, 0.01852083f, -0.02201214f, 
    -0.02970605f, 0.02677452f, -0.05041222f, -0.00793175f, 0.04088214f, 0.01429006f, -0.02020118f, -0.00010397f, 
    -0.05157436f, -0.00281632f, -0.00060539f, -0.02282757f, 0.00341679f, 0.03375808f, -0.02217173f, -0.01186653f, 
    -0.02288398f, -0.03954512f, -0.04902793f, -0.03399095f, -0.04586220f, 0.01698261f, -0.02464540f, -0.00626366f, 
    -0.01322367f, 0.01421690f, 0.00190672f, -0.01842139f, -0.00556756f, -0.01043217f, -0.01952721f, 0.00074940f, 
    0.04201082f, 0.02840852f, 0.04184475f, 0.03754903f, -0.04717651f, -0.00096623f, -0.03805266f, 0.01333262f, 
    -0.01165590f, 0.01705300f, -0.03619250f, -0.00996826f, -0.01445048f, -0.00613031f, 0.04305476f, -0.05620822f, 
    -0.02048439f, -0.02086302f, -0.03912896f, -0.00337531f, 0.02967413f, -0.04848066f, -0.02007026f, -0.02032405f, 
    -0.01235601f, 0.00508006f, -0.05078062f, -0.00041642f, 0.02403428f, 0.00524471f, -0.01027381f, -0.05421649f, 
    -0.01157542f, 0.00293751f, -0.02910158f, -0.04985617f, -0.03070273f, -0.02526924f, 0.00903800f, 0.04428898f, 
    -0.02416928f, -0.00810491f, -0.04118531f, -0.02621182f, -0.04697265f, 0.01363500f, -0.04071727f, -0.04061994f, 
    0.03122290f, 0.01960317f, 0.03661884f, -0.02720350f, 0.04322742f, -0.05269614f, 0.00283848f, -0.03592198f, 
    0.01136722f, -0.03562482f, 0.02076069f, 0.02468332f, -0.03269174f, 0.01280568f, 0.03686964f, -0.03805239f, 
    -0.01810734f, -0.02268794f, 0.02438697f, -0.01766163f, 0.02269535f, -0.01671435f, -0.05323431f, 0.02186774f, 
    -0.05477123f, -0.02493661f, -0.04578657f, 0.04406344f, -0.00371963f, -0.02528416f, 0.00519384f, -0.00110273f, 
    -0.03410014f, 0.02207564f, 0.01940183f, -0.01733433f, 0.02059084f, -0.02311936f, -0.02784610f, -0.04927345f, 
    0.03329085f, 0.00737680f, -0.01249352f, -0.00597320f, 0.01384306f, -0.04210652f, -0.02255771f, 0.01439594f, 
    0.01969002f, 0.02261123f, -0.01315871f, 0.03460880f, -0.05577144f, -0.01336469f, -0.05445544f, 0.00444664f, 
    0.00755865f, 0.03349841f, -0.02786844f, 0.03518046f, 0.03549130f, -0.02149201f, 0.01547752f, -0.00241316f, 
    0.02591071f, 0.02243205f, -0.02929829f, -0.01595054f, -0.04734569f, -0.04340134f, -0.03216107f, 0.00819710f, 
    0.01752784f, 0.02921112f, 0.01180511f, -0.03102408f, 0.02613807f, 0.00420476f, 0.01612825f, -0.03544364f, 
    -0.04388815f, 0.03376427f, -0.05137976f, 0.03685624f, -0.02893117f, 0.05135012f, 0.00518639f, -0.00882705f, 
    -0.03963222f, -0.02104575f, -0.05096709f, -0.05264504f, -0.05245665f, -0.05237152f, -0.01161929f, -0.05035752f, 
    -0.00381327f, -0.02733631f, -0.01751273f, -0.02592132f, 0.02598643f, 0.00175882f, -0.03320874f, -0.01006407f, 
    -0.05236948f, 0.03860690f, -0.01147062f, -0.00123064f, 0.01157329f, -0.03734694f, -0.02198004f, -0.04913072f, 
    0.00114578f, 0.03329091f, 0.01640556f, 0.03561109f, -0.03147143f, -0.04491262f, 0.03244514f, -0.05106819f, 
    -0.02180229f, 0.03025015f, -0.03463441f, -0.04533392f, 0.00645460f, 0.03046487f, 0.01894204f, 0.01155972f, 
    -0.04372368f, -0.00607833f, -0.04376414f, 0.03394227f, -0.01739924f, 0.02128380f, 0.00921596f, -0.05335402f, 
    0.00399921f, -0.04136598f, 0.00504727f, -0.03291275f, -0.05788949f, -0.02983494f, 0.01879677f, -0.00614199f, 
    0.01620207f, -0.00335776f, 0.03752926f, -0.01406806f, 0.00651140f, -0.00528903f, 0.02680214f, 0.01307369f, 
    -0.02742320f, -0.03150482f, 0.02298815f, -0.01073945f, 0.01401340f, 0.00721518f, 0.02664454f, -0.04965363f, 
    0.00955311f, 0.04026335f, 0.01422793f, -0.05705827f, -0.05749987f, -0.03183530f, 0.04144698f, -0.01923040f, 
    -0.00643140f, 0.01163149f, -0.05400221f, -0.00598192f, 0.00169433f, -0.02298736f, -0.03640432f, -0.01801188f, 
    -0.03400747f, 0.03197598f, -0.04696525f, 0.00933302f, 0.00389170f, -0.00051131f, 0.02023085f, 0.00510415f, 
    -0.05130818f, -0.01873675f, -0.02727668f, -0.04122402f, -0.00458145f, -0.03046486f, -0.04800784f, 0.01098721f, 
    0.00514673f, -0.02028066f, 0.01828999f, 0.02090450f, -0.04432076f, 0.01132884f, 0.01196924f, 0.01505915f, 
    0.00483385f, 0.00797218f, -0.01712720f, 0.01828167f, -0.01593076f, 0.01432109f, 0.03677714f, -0.02036055f, 
    -0.05622680f, -0.03060167f, -0.01975001f, -0.05744804f, 0.02505441f, -0.03737552f, 0.03141288f, 0.00785015f, 
    0.04079737f, -0.00909446f, -0.00804737f, 0.04258020f, -0.02228363f, 0.02335766f, -0.03862261f, 0.01371206f, 
    0.02427074f, 0.02110903f, -0.01082709f, -0.00076336f, 0.02267154f, -0.01526723f, -0.01023192f, 0.01036715f, 
    -0.00542117f, 0.01578259f, 0.02525350f, 0.01953433f, -0.02908332f, 0.03468578f, -0.01143381f, -0.04025135f, 
    -0.02032647f, -0.05754661f, 0.02557020f, 0.02859625f, 0.01258166f, -0.02939088f, 0.03857748f, -0.00501617f, 
    0.02129555f, -0.04253070f, -0.02824580f, 0.01377835f, -0.03952055f, -0.00266206f, -0.02585891f, -0.00227730f, 
    -0.01302198f, 0.01228591f, -0.05227832f, 0.01272061f, -0.04267078f, -0.00536251f, -0.02403889f, -0.00856224f, 
    -0.05544664f, -0.04613388f, 0.01109531f, -0.00297521f, -0.05336703f, 0.03755404f, 0.02534044f, -0.01650542f, 
    0.00125612f, 0.00071118f, -0.00167048f, -0.03702416f, 0.02916048f, -0.03945537f, 0.02889906f, -0.01358058f, 
    0.02219972f, 0.03947854f, 0.00112121f, -0.00365767f, -0.01937044f, 0.00453361f, -0.02269293f, 0.02566278f, 
    0.02856119f, -0.00999120f, 0.03310088f, -0.05140328f, 0.02842633f, -0.03654253f, -0.04531336f, 0.00642147f, 
    -0.03741075f, 0.04249642f, 0.01378336f, -0.01501561f, -0.01139851f, -0.02783518f, -0.02676442f, -0.03834721f, 
    0.03952126f, -0.02723518f, -0.05285057f, -0.01509207f, -0.04876502f, 0.02540400f, 0.01441049f, -0.04218077f, 
    -0.00280073f, -0.05315713f, -0.01432786f, -0.00763037f, -0.02613788f, 0.02400298f, 0.04131161f, 0.01639742f, 
    -0.05073677f, 0.03770167f, -0.05130190f, 0.01714782f, 0.02170604f, -0.01107690f, -0.03587189f, 0.03724482f, 
    -0.02443507f, 0.00967897f, 0.00840356f, 0.02696519f, 0.03162206f, -0.02055500f, -0.03245010f, 0.04853877f, 
    -0.04030600f, 0.00739881f, -0.04847699f, -0.04863814f, -0.04871104f, 0.00151808f, 0.04095906f, 0.00285469f, 
    -0.03928980f, -0.00207004f, -0.00038937f, -0.03425636f, 0.00583646f, 0.03239114f, 0.03794318f, -0.00454760f, 
    -0.01575035f, -0.05806134f, -0.01839097f, 0.04129570f, -0.00418498f, 0.01886886f, 0.03787987f, 0.03845166f, 
    -0.04658337f, 0.04013513f, 0.02608943f, 0.02594404f, -0.00753109f, -0.05197731f, -0.03729603f, 0.02534607f, 
    -0.04540696f, -0.02191165f, -0.00230389f, 0.01253592f, -0.02160110f, 0.03488977f, -0.02284466f, 0.00182087f, 
    -0.02958561f, 0.03377559f, -0.05357170f, -0.05192357f, 0.00618856f, 0.03488363f, 0.03235105f, 0.03530737f, 
    -0.04889642f, -0.03032809f, 0.03094696f, -0.05334938f, 0.01882556f, -0.04170485f, 0.01726190f, -0.03373281f, 
    0.00160424f, 0.00063093f, 0.01868081f, 0.03581263f, 0.01098908f, 0.00447237f, -0.04836068f, 0.02647375f, 
    0.02843273f, 0.01687505f, 0.02774508f, 0.02068944f, -0.00424759f, 0.00084733f, -0.02216259f, -0.04610636f, 
    -0.01134551f, 0.02238488f, 0.00748091f, 0.02767653f, -0.01423264f, 0.01873380f, 0.00293038f, -0.05453854f, 
    -0.02254555f, 0.03586970f, -0.01088658f, 0.02558563f, -0.00556598f, 0.01126534f, -0.03951731f, -0.05689627f, 
    -0.02362642f, -0.04006091f, -0.02244449f, -0.05499154f, -0.03405208f, -0.03966177f, -0.00721626f, 0.02079237f, 
    0.00350246f, -0.00358938f, 0.01837205f, -0.05537695f, 0.01926305f, -0.04316633f, -0.04004722f, -0.00093335f, 
    0.00935766f, 0.00323498f, -0.05489870f, 0.04447892f, 0.02555462f, -0.01757916f, 0.01916499f, 0.00903698f, 
    0.03850906f, -0.03357347f, 0.00578448f, 0.03915831f, 0.02867979f, -0.05166078f, -0.01251898f, -0.01029215f, 
    0.00923007f, -0.05602420f, 0.03810333f, -0.03374453f, 0.01984082f, 0.02970568f, -0.02771442f, -0.03139285f, 
    -0.00713086f, -0.02744296f, -0.00481568f, -0.00032250f, -0.01250239f, 0.03808797f, -0.03330408f, -0.00479489f, 
    0.03909126f, 0.00640201f, -0.00299661f, 0.01613916f, 0.02688721f, -0.02305724f, 0.03716586f, 0.01481694f, 
    -0.05668181f, -0.01445803f, 0.01207083f, -0.01714571f, -0.00784015f, -0.03866051f, 0.03403169f, 0.01589738f, 
    0.02806895f, -0.02836595f, 0.00338160f, 0.00090193f, -0.01742706f, -0.03341965f, 0.03302708f, 0.03966308f, 
    0.04292297f, 0.03274665f, -0.03904693f, -0.05048687f, -0.04756143f, -0.02188864f, 0.03746164f, 0.02641789f, 
    0.01346547f, -0.00025413f, -0.02406501f, -0.03813186f, 0.03467909f, -0.04032223f, 0.00828084f, -0.03273534f, 
    0.00446884f, 0.04280345f, 0.01479022f, 0.01249260f, -0.05226830f, 0.00144938f, 0.03815243f, 0.03618103f, 
    -0.05873250f, -0.01046948f, -0.00992440f, 0.02734410f, 0.01152650f, -0.02515151f, -0.00594016f, 0.00778049f, 
    0.04067858f, -0.01196656f, 0.00384877f, -0.00475138f, -0.01105247f, 0.02269371f, -0.03488989f, 0.00291427f, 
    0.00560399f, 0.02551631f, 0.00121901f, -0.02746718f, -0.01350006f, -0.03096165f, -0.00317848f, -0.04234241f, 
    -0.00898418f, -0.04495807f, -0.03497857f, 0.00206959f, -0.04197124f, -0.04652104f, 0.02748942f, -0.01621469f, 
    0.04860622f, 0.01630066f, 0.00424396f, 0.04249261f, -0.04920162f, -0.00231141f, 0.03168402f, 0.03436944f, 
    0.01526006f, 0.01052477f, -0.03036958f, 0.00610439f, 0.00711399f, 0.02643699f, -0.03927431f, -0.01384532f, 
    -0.00932802f, 0.01715380f, -0.03177452f, 0.03964350f, 0.02843007f, -0.03876251f, -0.00923390f, -0.02634042f, 
    0.00682888f, 0.02653507f, -0.03243839f, 0.01710941f, 0.03550528f, -0.05330028f, 0.03865029f, 0.04089651f, 
    -0.00209381f, -0.04544656f, 0.00228265f, 0.02834882f, 0.04487620f, 0.01201424f, 0.02005923f, -0.01286171f, 
    0.00756599f, 0.02949892f, 0.01918250f, 0.01011400f, 0.03622690f, 0.02112594f, -0.00667198f, 0.01186072f, 
    -0.01877781f, -0.04499303f, 0.00012058f, -0.00778761f, -0.00504254f, -0.01003326f, -0.01568075f, -0.04741861f, 
    0.03522564f, -0.05754664f, -0.00120019f, -0.02354319f, -0.00390736f, 0.03809574f, -0.00588005f, -0.04189860f, 
    -0.04465906f, 0.03217068f, 0.03101718f, -0.05082086f, 0.03150329f, -0.02077864f, 0.04035058f, 0.02507002f, 
    -0.01239451f, -0.04702063f, -0.04711169f, 0.01895918f, -0.01144481f, 0.03007654f, -0.00831267f, -0.05826500f, 
    0.01187764f, 0.00901369f, -0.05286384f, -0.05395171f, -0.01019954f, -0.03986923f, -0.05313904f, -0.04425536f, 
    0.01084082f, -0.00948070f, 0.03455114f, -0.03620711f, -0.05693159f, -0.02341742f, 0.00174440f, -0.03529490f, 
    0.01528696f, 0.01221935f, -0.02911413f, -0.01890958f, 0.03929420f, 0.02345351f, -0.01715583f, 0.02027736f, 
    0.04065074f, -0.04171492f, -0.02669598f, -0.05154676f, -0.02576469f, -0.03399407f, -0.03413736f, -0.04583672f, 
    -0.01843940f, -0.02937767f, 0.02556226f, 0.01480265f, 0.01661479f, -0.00238783f, 0.01934749f, -0.00158917f, 
    -0.04918473f, 0.00946472f, -0.01495791f, -0.00995758f, 0.01544158f, 0.03080531f, -0.00796453f, 0.00937914f, 
    -0.04621739f, 0.03564290f, -0.03055442f, -0.00228652f, 0.03203455f, 0.01738064f, 0.05298458f, -0.04590641f, 
    0.02113380f, -0.02476626f, 0.00694580f, 0.03971701f, -0.02049928f, -0.02103074f, -0.04925334f, -0.04193944f, 
    0.03333401f, 0.03838977f, -0.02448796f, -0.00378313f, 0.02363926f, -0.02119577f, -0.01716376f, 0.03090532f, 
    -0.02766998f, -0.02355039f, -0.01182569f, 0.03247789f, -0.03215097f, 0.01196899f, -0.03931344f, 0.00775520f, 
    -0.05390176f, -0.03936631f, -0.05823848f, -0.04152225f, -0.02133464f, 0.00423756f, -0.02443637f, 0.03535951f, 
    -0.06072931f, -0.03724337f, -0.03869474f, 0.01493003f, 0.03338137f, 0.01127836f, 0.00983357f, -0.03981744f, 
    -0.04573376f, -0.02209046f, -0.00609367f, 0.03741212f, -0.00641546f, 0.02638611f, 0.01982996f, 0.00138752f, 
    0.01456392f, -0.04967031f, 0.04477924f, -0.01219106f, 0.00481287f, 0.00867123f, 0.00054201f, 0.02985379f, 
    0.01045802f, -0.00608010f, -0.04087381f, -0.03752762f, -0.04858556f, 0.03587770f, -0.01756650f, -0.05997653f, 
    0.01325320f, -0.01399029f, 0.03558144f, 0.01942443f, 0.02646665f, -0.03969263f, -0.03651978f, -0.04424402f, 
    -0.02924921f, -0.00020953f, 0.02028469f, 0.00771722f, -0.02260640f, 0.01925462f, -0.03215706f, -0.05394929f, 
    0.00304397f, -0.00786826f, -0.01688050f, 0.03722600f, -0.05100735f, -0.02793495f, -0.05010678f, -0.01822168f, 
    -0.05148337f, -0.02041706f, 0.02143874f, 0.03663845f, -0.03890129f, 0.01287330f, 0.04510202f, -0.04768454f, 
    -0.05336455f, -0.03330023f, -0.00314447f, -0.00441921f, -0.05467091f, 0.02359774f, -0.02573988f, -0.02783236f, 
    -0.01662428f, 0.01236296f, 0.00496100f, -0.04321814f, -0.05363281f, -0.01337424f, -0.01095247f, 0.04081360f, 
    0.00289688f, -0.01258924f, -0.01913375f, 0.01907780f, -0.01524283f, -0.03214766f, 0.02506930f, 0.02033709f, 
    -0.05483463f, 0.00715019f, 0.02328265f, -0.03248145f, -0.05042533f, -0.02748530f, 0.05327338f, -0.04707316f, 
    0.03278876f, -0.05384779f, -0.00989800f, -0.02751946f, -0.05564541f, 0.03869346f, -0.05067245f, -0.00523167f, 
    -0.03168809f, -0.03612123f, 0.00509244f, -0.02699977f, -0.00389481f, 0.01603155f, 0.04973613f, -0.01938519f, 
    0.03189104f, -0.03619131f, 0.04118429f, 0.04439078f, -0.04918552f, -0.00770445f, -0.01972646f, 0.00868714f, 
    -0.40213639f, -0.33731657f, 0.04970072f, 0.53275615f, 0.12210632f, 0.12999442f, -0.10433342f, -0.25646678f, 
    -0.05436308f, -0.01361901f, 0.03111741f, 0.03583485f, -0.39166027f, 0.06938583f, 0.00837301f, 0.07344724f, 
    0.04502564f, -0.07702153f, 0.00124538f, 0.08736381f, 0.16979469f, 0.29466775f, -0.19344059f, 0.25075608f, 
    0.22479978f, 0.11672334f, 0.00092770f, 0.31892887f, -0.08958393f, -0.03343512f, -0.01176699f, -0.17355971f, 
    0.05427216f, -0.02712643f, 0.23677395f, 0.09988026f, 0.27907196f, 0.06033234f, 0.20652008f, -0.02818413f, 
    0.10297864f, 0.01983295f, 0.06856503f, -0.06026644f, 0.11054139f, 0.07458108f, 0.05003403f, 0.15477431f, 
    0.10596190f, 0.06535619f, 0.05678984f, 0.00291427f, 0.00939050f, -0.01921078f, -0.00185859f, -0.02666889f, 
    -0.03086198f, 0.14776352f, 0.32798383f, 0.37726259f, 0.04693380f, -0.11644889f, 0.16594689f, -0.00289824f, 
    -0.16305816f, 0.07140061f, 0.15986690f, 0.09302179f, -0.03851478f, 0.18091905f, 0.17643277f, -0.01275852f, 
    -0.17285599f, -0.20431310f, -0.09405720f, 0.24982895f, 0.08560577f, 0.09171220f, -0.20573106f, 0.05455777f, 
    -0.17263451f, 0.14024195f, 0.30460849f, 0.06191314f, 0.25259131f, 0.11102010f, -0.03174668f, 0.04043985f, 
    0.06960905f, 0.10595722f, 0.03441064f, 0.00390653f, 0.01468281f, 0.03545228f, -0.07477675f, 0.01798624f, 
    0.03558578f, -0.06657516f, -0.02114573f, -0.13842882f, 0.02583597f, 0.02181864f, -0.03196326f, 0.10417073f, 
    -0.04859318f, -0.02094251f, -0.01170665f, -0.05089793f, -0.04568492f, 0.08080862f, 0.13571039f, 0.20977321f, 
    0.00363961f, -0.02051543f, -0.04648376f, -0.01217830f, -0.07531030f, 0.07597512f, 0.02367094f, -0.01692523f, 
    -0.06188409f, -0.03466596f, 0.17490265f, -0.05963024f, 0.12613222f, 0.03724132f, -0.03779434f, 0.08973014f, 
    -0.10108083f, 0.05425915f, -0.22998029f, -0.13948770f, 0.00426310f, -0.06893673f, 0.06133309f, -0.35002443f, 
    0.05027417f, 0.05503026f, 0.10726436f, 0.14031473f, -0.04185145f, 0.03780536f, -0.09336425f, -0.10214410f, 
    -0.14463535f, -0.17366643f, 0.16559269f, -0.19553481f, -0.04578255f, 0.07195741f, 0.00793978f, 0.01236269f, 
    -0.06341243f, -0.10167508f, 0.22855496f, 0.04227636f, -0.11890730f, 0.14922832f, 0.31493425f, -0.15517129f, 
    0.06869919f, 0.14591826f, -0.13338953f, -0.00321613f, -0.09466122f, 0.08495159f, 0.12016058f, 0.10669894f, 
    0.05243796f, 0.00819649f, -0.02840051f, 0.18862662f, -0.01238941f, -0.03970842f, -0.13326861f, -0.11378945f, 
    -0.07676055f, 0.00736784f, -0.01102930f, -0.10568593f, 0.00285994f, -0.08702780f, -0.07633833f, -0.03169361f, 
    0.09155709f, -0.11871614f, 0.14202099f, 0.09014911f, -0.07117561f, -0.02927632f, -0.06240591f, -0.07141697f, 
    0.08652662f, -0.12808624f, 0.03679163f, 0.06772058f, 0.11485138f, -0.14263757f, 0.17018852f, -0.29622391f, 
    0.05109286f, -0.00028528f, 0.12377882f, 0.06187442f, 0.05438450f, -0.04369339f, 0.03722065f, 0.12486330f, 
    0.02226297f, 0.01019489f, -0.00434317f, -0.00081491f, 0.23239027f, -0.10751409f, -0.01171105f, -0.03601550f, 
    0.07751809f, 0.02388934f, -0.05493079f, 0.17389183f, 0.01246077f, 0.18694133f, 0.02813256f, -0.12868592f, 
    0.16478921f, -0.06680204f, -0.01340295f, 0.07618879f, 0.11937892f, 0.03168184f, -0.00604355f, 0.12020236f, 
    -0.07640111f, 0.15200172f, -0.00295843f, 0.03482863f, -0.00640519f, 0.01581557f, -0.03867089f, 0.07619191f, 
    -0.07628927f, 0.23975775f, -0.27192575f, 0.25019568f, 0.09858661f, 0.02491074f, 0.05017779f, 0.03516288f, 
    -0.06943665f, 0.12163343f, 0.08477493f, 0.32169163f, 0.25289586f, 0.02508906f, 0.04570239f, 0.00564581f, 
    -0.03788058f, 0.10929092f, -0.12654874f, 0.17455932f, -0.07802773f, -0.04885620f, 0.19285287f, -0.00517662f, 
    0.02524575f, 0.06019638f, -0.06862038f, 0.14148650f, -0.15037124f, -0.11163369f, 0.12190273f, -0.26601779f, 
    -0.04858486f, 0.05544101f, 0.05684233f, 0.02942334f, -0.18589593f, 0.06010968f, 0.25979197f, -0.15040666f, 
    -0.13809936f, 0.12916547f, -0.04092912f, 0.00122168f, -0.05495416f, 0.05837534f, 0.00372537f, -0.04987288f, 
    0.02562034f, 0.02760901f, 0.13374910f, -0.01874414f, -0.11516102f, -0.03456261f, 0.04460630f, -0.09947806f, 
    0.02497306f, -0.21195224f, -0.05362327f, 0.05655988f, -0.04410677f, 0.05718761f, -0.08377331f, 0.08365487f, 
    -0.05977297f, 0.07298263f, -0.01467167f, 0.14900272f, 0.08630648f, 0.20787579f, -0.07262702f, -0.34540132f, 
    -0.14247978f, -0.11624283f, 0.08011148f, 0.07572197f, -0.12773301f, 0.07864165f, -0.13523521f, -0.02033263f, 
    -0.06375663f, 0.04663254f, 0.07226739f, 0.04784616f, 0.05669958f, -0.04841979f, 0.25997439f, -0.16787663f, 
    -0.14245632f, -0.17832550f, 0.02926500f, -0.01497377f, 0.09035446f, 0.08609356f, -0.06256288f, -0.20278808f, 
    0.16226389f, 0.02860487f, -0.10486436f, 0.01430221f, -0.02328499f, 0.00105686f, -0.03595646f, 0.01429051f, 
    -0.13750048f, 0.15429404f, 0.13064209f, 0.09179101f, -0.08036347f, 0.05948799f, 0.03544110f, -0.08921403f, 
    0.05701318f, -0.04763140f, 0.02290874f, 0.01551780f, 0.16005133f, -0.22995122f, 0.13315274f, -0.07814883f, 
    -0.22733091f, 0.26269740f, 0.15752533f, 0.13899405f, 0.03179536f, -0.07151091f, -0.04252171f, 0.08630990f, 
    -0.17383638f, -0.00115835f, -0.11662328f, 0.22987936f, 0.56593537f, -0.39477894f, 0.15669443f, -0.14417621f, 
    -0.17358844f, -0.01047852f, -0.00210123f, 0.24874645f, 0.02926957f, 0.06817416f, -0.00914041f, 0.02018289f, 
    -0.03401278f, -0.05001811f, -0.04959834f, 0.01570524f, -0.02027194f, 0.01413500f, -0.03380511f, -0.01065940f, 
    -0.01573879f, -0.03011258f, 0.00885525f, -0.04743845f, -0.01495518f, 0.01758496f, 0.04054640f, 0.03839026f, 
    -0.00063576f, -0.03689913f, -0.02163555f, -0.04937676f, 0.00902920f, 0.00140397f, -0.05504755f, -0.01931719f, 
    -0.05506197f, 0.03892456f, -0.05375640f, -0.02040589f, -0.00177222f, 0.00983012f, -0.01705330f, 0.03009471f, 
    -0.02683634f, 0.02871170f, 0.00246791f, -0.03758052f, -0.01079984f, -0.00327619f, -0.05239555f, -0.00841179f, 
    -0.04880054f, -0.05677534f, -0.04312616f, -0.02672533f, -0.04145751f, -0.00702894f, 0.00769962f, -0.02061285f, 
    0.03292925f, -0.03288992f, -0.00106756f, 0.03066598f, -0.04268986f, -0.03774601f, -0.04281104f, -0.04316664f, 
    -0.05574622f, 0.02218909f, -0.02059944f, -0.03382898f, 0.00029863f, 0.04013216f, 0.03977169f, -0.05129026f, 
    0.03497517f, 0.03199285f, 0.03416687f, 0.02982305f, -0.02130100f, -0.03536510f, 0.01644299f, -0.03315496f, 
    -0.04093653f, 0.02605390f, -0.02063389f, -0.00598792f, -0.04113977f, 0.03678747f, 0.00081224f, -0.05448036f, 
    0.02454207f, -0.01245210f, 0.00649348f, 0.01651726f, -0.04329672f, -0.03132823f, -0.02639042f, -0.04206337f, 
    -0.00081083f, 0.00870799f, -0.00875083f, 0.03929755f, 0.03204065f, 0.04469253f, 0.00031988f, 0.02482074f, 
    -0.03007173f, -0.02684702f, -0.02751351f, 0.00395278f, -0.01257255f, 0.00540733f, -0.05172594f, 0.00076232f, 
    -0.04834501f, 0.00526352f, -0.03288404f, -0.00398093f, -0.04498230f, -0.00621355f, -0.02420325f, 0.01937589f, 
    -0.03867484f, 0.02438743f, -0.03686324f, -0.02311320f, 0.01172800f, 0.00551585f, 0.00676849f, -0.03768805f, 
    -0.02247292f, -0.03417652f, 0.01251702f, -0.00479920f, 0.03502069f, 0.00025475f, -0.04481344f, 0.02479963f, 
    -0.04858516f, 0.01276656f, 0.02484090f, -0.02594984f, 0.00616954f, -0.00632809f, -0.02592519f, -0.03508872f, 
    -0.00679744f, -0.00927164f, -0.04199922f, -0.01598436f, -0.02037641f, 0.03611762f, 0.02566120f, 0.01083141f, 
    -0.01917311f, -0.05860923f, -0.04868174f, -0.01293929f, -0.00792826f, -0.04661966f, 0.01493298f, -0.00959323f, 
    -0.05877044f, 0.03180890f, -0.00665568f, 0.03603606f, -0.04630058f, 0.00173209f, -0.03638342f, 0.00899279f, 
    -0.03651182f, 0.00049481f, 0.02620498f, 0.03919589f, 0.00111446f, 0.02867359f, -0.00290555f, 0.02752898f, 
    0.02121662f, 0.01763777f, -0.00171365f, -0.04626742f, 0.01576647f, -0.01718970f, -0.00442556f, 0.03398311f, 
    0.01598590f, -0.05409217f, 0.01966710f, -0.04185949f, 0.00295224f, 0.00911552f, -0.01316709f, 0.00049951f, 
    -0.01017540f, 0.05235269f, -0.04220361f, 0.00757897f, -0.04614938f, -0.00614500f, -0.00916854f, 0.03128136f, 
    0.02521454f, 0.02388120f, -0.05305990f, -0.03069516f, 0.01667923f, 0.02475983f, -0.04821435f, 0.04395514f, 
    0.00829438f, 0.03748668f, -0.00463475f, 0.03821135f, -0.05268645f, -0.04815145f, -0.01641946f, -0.03974997f, 
    0.00054214f, 0.00038503f, -0.03422438f, 0.02402058f, -0.01655791f, 0.00567440f, -0.03495697f, -0.05850989f, 
    0.03152381f, 0.02647221f, 0.03218870f, 0.03127166f, -0.04036811f, -0.00973935f, 0.00555602f, -0.02814214f, 
    0.04183649f, -0.05199521f, 0.04102230f, -0.00860991f, -0.01972594f, 0.01817392f, -0.04532437f, -0.02213943f, 
    0.00856705f, -0.04580170f, 0.00807880f, -0.02065268f, -0.01838731f, -0.01306233f, 0.02694153f, 0.02582012f, 
    -0.03987485f, 0.03460605f, -0.00752170f, -0.02952607f, -0.01631984f, -0.02427965f, 0.03548915f, 0.02836802f, 
    0.02577537f, 0.03363810f, -0.04578577f, -0.03648496f, 0.02987042f, 0.04444913f, 0.02090764f, -0.03842827f, 
    -0.02646691f, -0.01501301f, 0.03550901f, -0.01881169f, 0.04525033f, 0.01748444f, 0.03016698f, 0.00052579f, 
    0.01503364f, -0.01879327f, -0.05515730f, -0.00150421f, 0.03027122f, -0.02997524f, -0.02156655f, -0.03172431f, 
    0.02121319f, 0.00189080f, 0.04375122f, 0.00602501f, -0.01519265f, -0.04951180f, -0.02470468f, 0.00486684f, 
    -0.01913895f, -0.04783680f, -0.02679999f, -0.03449090f, -0.03914749f, -0.01539237f, -0.00773518f, 0.00740683f, 
    0.01723829f, 0.00662386f, -0.01154929f, -0.02077511f, -0.00264111f, -0.04648118f, -0.00693457f, 0.02044936f, 
    0.03303189f, -0.03729391f, 0.01721371f, 0.01997959f, -0.00883116f, 0.02626187f, 0.02473880f, 0.00354097f, 
    -0.00641349f, -0.03869604f, -0.05126521f, -0.03403269f, -0.04352058f, 0.01843342f, -0.00886926f, 0.00746755f, 
    -0.01339180f, -0.00647583f, -0.03098895f, 0.04330473f, 0.03102154f, 0.03147777f, 0.00314770f, 0.01058288f, 
    0.03268380f, 0.02521250f, 0.03392116f, -0.00626204f, 0.02096737f, 0.02601260f, -0.01668553f, -0.02213819f, 
    -0.03855994f, -0.04918401f, -0.04123728f, -0.02666176f, -0.02960184f, 0.00347830f, -0.04159975f, -0.02356139f, 
    -0.04511904f, -0.02668294f, 0.03607382f, -0.03496776f, -0.00048213f, -0.05451644f, -0.01083148f, -0.05963233f, 
    -0.04920890f, 0.02936582f, 0.01734407f, -0.00941536f, 0.03233938f, -0.00408321f, -0.02743286f, 0.03076572f, 
    -0.03813762f, 0.02105990f, -0.05708525f, 0.00992660f, 0.00886723f, 0.01829876f, 0.02272979f, -0.01359358f, 
    -0.03220704f, 0.03458594f, -0.05797340f, -0.01461702f, -0.04272820f, 0.01653727f, -0.05149412f, -0.04621700f, 
    -0.04218274f, -0.02712683f, -0.05242347f, -0.00612632f, 0.04919763f, -0.03622478f, -0.00952322f, -0.04208425f, 
    0.02948109f, -0.04591825f, -0.01508404f, -0.04878248f, -0.04091183f, -0.00301333f, 0.04486563f, -0.04963113f, 
    -0.25281566f, -0.27479079f, -0.15652697f, -0.02190600f, 0.21279740f, 0.18048105f, -0.12879378f, -0.03420466f, 
    -0.05732491f, 0.21458890f, 0.13510133f, -0.01555634f, -0.31604078f, 0.38083628f, -0.00798512f, -0.08727521f, 
    -0.14878519f, -0.02343695f, 0.07647753f, -0.08608633f, -0.06803453f, 0.24831863f, 0.10898846f, -0.03974043f, 
    0.21943730f, -0.11592356f, 0.00086568f, 0.12770544f, -0.07275839f, 0.23978429f, 0.27625242f, -0.00914111f, 
    0.07477359f, 0.04461620f, 0.03581077f, 0.12119570f, 0.23200089f, 0.07749707f, 0.07838993f, -0.03188911f, 
    -0.05123090f, 0.04731705f, 0.17457809f, -0.06000344f, 0.16198480f, 0.05975089f, 0.11893468f, 0.15416645f, 
    0.34508100f, 0.09431382f, 0.18572250f, 0.11272268f, -0.02796230f, 0.04322708f, -0.00137026f, -0.06929670f, 
    -0.18654294f, 0.02590547f, 0.00630962f, 0.05262149f, 0.58408743f, 0.11675830f, 0.16951786f, -0.21594372f, 
    0.02908951f, 0.05898246f, 0.13614909f, 0.05209893f, 0.13851385f, 0.28534508f, 0.08715971f, -0.13386790f, 
    0.13324861f, 0.06485822f, -0.04492461f, -0.17476998f, -0.15570585f, 0.27172777f, -0.10733536f, 0.19425315f, 
    0.09075978f, -0.03239546f, 0.05738389f, 0.09663215f, 0.16249080f, 0.08188634f, 0.00528574f, 0.03273657f, 
    -0.05987132f, -0.01279268f, -0.00135970f, 0.00992143f, -0.01303692f, 0.02165145f, -0.08744713f, -0.05438167f, 
    0.57652682f, 0.49431831f, 0.20602293f, 0.27371800f, 0.04944403f, 0.01548284f, -0.01501201f, -0.03813994f, 
    -0.06327497f, -0.07652273f, -0.07558191f, 0.04514869f, -0.55161244f, 0.15515526f, -0.22233693f, -0.30622151f, 
    0.12469099f, -0.08719158f, -0.00306674f, 0.09573423f, 0.08985630f, -0.07871894f, -0.08682879f, -0.04594966f, 
    0.08346236f, 0.21218608f, 0.46942717f, 0.06292951f, 0.06726499f, 0.00798375f, -0.09257841f, 0.06975203f, 
    -0.03810488f, 0.09919713f, 0.06328672f, 0.06621455f, 0.55000061f, 0.21855167f, 0.16181624f, 0.01035859f, 
    0.00730074f, -0.13481896f, 0.13340451f, -0.07034447f, 0.06515915f, -0.06246405f, -0.05678924f, 0.05624840f, 
    -0.17685167f, 0.04678012f, -0.14977783f, -0.44220757f, 0.01169869f, 0.12349648f, -0.00268849f, 0.00723654f, 
    -0.01801574f, 0.09385125f, 0.12245878f, 0.03110536f, 0.05898968f, 0.23369034f, 0.11535177f, -0.10480011f, 
    0.06205859f, 0.01971632f, 0.18216917f, 0.07396977f, 0.09146281f, 0.01232890f, 0.12196375f, 0.22275710f, 
    -0.27338135f, -0.68424183f, -0.49484965f, -0.18219577f, 0.12827763f, -0.22200710f, -0.23427391f, -0.26627287f, 
    -0.16731347f, -0.05222577f, -0.01488337f, -0.05773913f, -0.59979254f, 0.18101229f, 0.15336694f, -0.02549979f, 
    -0.09450216f, 0.21522924f, 0.09850732f, 0.07793957f, 0.09750786f, 0.02816482f, 0.01539747f, -0.14347495f, 
    -0.07775142f, -0.39743179f, -0.07648543f, 0.02754291f, 0.07301676f, 0.10524058f, 0.10991821f, 0.11654390f, 
    0.03633288f, 0.02410540f, 0.07895187f, 0.15394229f, -0.10620836f, -0.13994649f, -0.03443696f, -0.02396164f, 
    0.04682409f, 0.04024258f, 0.06126151f, -0.03503390f, -0.07433773f, -0.18145786f, -0.05872241f, -0.18050961f, 
    0.26541105f, -0.19604744f, -0.15053201f, 0.15132537f, -0.25518700f, 0.14740127f, 0.05601639f, -0.09173270f, 
    0.07023671f, -0.05452560f, -0.05534243f, 0.01938286f, 0.15681872f, 0.21678092f, -0.03401541f, 0.17522442f, 
    0.11394671f, 0.02816369f, 0.09733116f, -0.04097022f, -0.00013942f, 0.00168925f, -0.03029806f, 0.09376552f, 
    0.22897907f, 0.15123945f, 0.07907628f, 0.27874476f, -0.04087038f, 0.09698786f, 0.05466751f, -0.03356866f, 
    0.16070256f, 0.30598432f, 0.04744402f, 0.05345445f, 0.16989590f, 0.05353211f, 0.03758840f, 0.00865642f, 
    0.01352142f, -0.08003424f, -0.00477597f, 0.20764317f, 0.10032944f, 0.03678546f, -0.03217003f, -0.18116899f, 
    -0.47683710f, -0.25385278f, -0.65650487f, -0.66478324f, 0.02215199f, -0.33142847f, -0.13225664f, -0.16231067f, 
    -0.23722219f, -0.11683945f, -0.11441838f, -0.07074808f, -0.01939213f, -0.32569590f, -0.53157783f, -0.37085330f, 
    -0.09480263f, -0.13509467f, 0.05308247f, -0.22821018f, 0.04097592f, -0.15830420f, 0.03753573f, 0.04303802f, 
    -0.33341572f, -0.19036385f, -0.24935433f, -0.51226389f, -0.04940495f, 0.04850681f, -0.04073140f, 0.02343741f, 
    -0.01536219f, -0.01954176f, -0.05058391f, 0.00081175f, 0.00726176f, 0.18118632f, 0.11780071f, 0.05177685f, 
    0.10922403f, 0.01367490f, 0.03157713f, 0.07267209f, -0.00412257f, -0.03399653f, 0.07634579f, 0.02504637f, 
    0.02191718f, -0.46582735f, -0.18374602f, -0.14369550f, 0.03388193f, -0.14266388f, -0.05670345f, -0.06977753f, 
    -0.16975653f, 0.05780451f, 0.04176053f, 0.12127013f, 0.26560119f, -0.04030399f, -0.06507945f, -0.13182810f, 
    0.13441306f, 0.04834392f, 0.15851042f, -0.23956375f, -0.06417920f, -0.06210955f, -0.11116983f, -0.10114341f, 
    0.06967787f, -0.04813278f, -0.02178321f, 0.05030939f, -0.02480653f, 0.06091636f, 0.02658091f, -0.00606120f, 
    0.19831280f, 0.20552315f, 0.04691602f, 0.17274588f, 0.05823331f, 0.25565523f, 0.10620034f, 0.12314050f, 
    -0.02912577f, 0.00429221f, 0.08575307f, -0.00189105f, 0.04809798f, 0.18213551f, 0.06089875f, 0.05661165f, 
    -0.05734361f, 0.04445896f, -0.23656438f, -0.17966045f, -0.06600660f, 0.01440151f, -0.14612913f, -0.02508353f, 
    -0.02193576f, -0.00167238f, 0.08947805f, -0.07039420f, 0.43995315f, 0.24096122f, 0.28904667f, -0.18084717f, 
    0.04622544f, 0.00305562f, 0.14695679f, 0.03308991f, 0.02902578f, 0.12914121f, -0.02562509f, -0.02086535f, 
    0.10354548f, 0.27746007f, -0.01713705f, 0.15446031f, 0.01249835f, 0.00594715f, -0.02839234f, 0.16406713f, 
    -0.04114166f, 0.14971963f, 0.00984773f, 0.10232302f, -0.03024849f, -0.30879197f, 0.30939624f, 0.05755204f, 
    0.01213416f, -0.00585844f, -0.03298437f, -0.00661768f, 0.29484585f, 0.09146377f, 0.29696062f, 0.04773324f, 
    -0.03413552f, -0.00645945f, -0.03876950f, -0.06526163f, 0.10731157f, 0.08414549f, 0.14716570f, -0.03039001f, 
    0.00828794f, -0.00273586f, 0.18233429f, -0.14138438f, -0.14414605f, -0.06566410f, -0.00596243f, -0.04244791f, 
    -0.00480779f, 0.10893221f, 0.05458477f, 0.07450909f, -0.07079219f, -0.06708898f, -0.13131432f, -0.31398720f, 
    0.10821518f, 0.06892188f, -0.11252294f, 0.04678613f, -0.09018647f, 0.01384291f, 0.01977903f, -0.02664801f, 
    0.20005472f, 0.07392982f, -0.04534344f, -0.27097827f, 0.34003016f, 0.37977937f, -0.11567441f, 0.00311901f, 
    0.08521168f, 0.04073121f, 0.05810191f, -0.06722306f, 0.11991788f, 0.13211083f, 0.18099666f, -0.00840869f, 
    0.04580540f, -0.07788639f, 0.35600719f, -0.07543515f, 0.05672872f, -0.18372466f, 0.10133476f, 0.12562662f, 
    -0.04524807f, 0.13300389f, 0.30301100f, 0.17525347f, -0.07453196f, -0.07368967f, -0.05861748f, -0.05774000f, 
    0.04763979f, -0.01056127f, -0.08243000f, 0.01265691f, 0.00894420f, 0.01432865f, 0.04401407f, 0.08766019f, 
    -0.06803975f, -0.11132596f, 0.21271582f, -0.05508563f, 0.13263190f, 0.04739144f, 0.07781311f, -0.03020443f, 
    -0.00992336f, -0.04623834f, -0.06474138f, 0.04173134f, 0.19348805f, -0.01047998f, 0.09024429f, -0.23984767f, 
    0.04774127f, -0.06833716f, -0.02980278f, -0.04356456f, 0.02765273f, 0.12740085f, -0.08232678f, -0.07151775f, 
    -0.05749568f, -0.00274508f, 0.14013395f, 0.09663475f, -0.01257621f, -0.02942676f, -0.09821026f, 0.03370997f, 
    0.12081194f, 0.07941245f, -0.05622682f, 0.36716923f, -0.29425409f, -0.11019557f, 0.16608214f, 0.14145878f, 
    -0.00908300f, -0.04447426f, -0.02721002f, 0.03403319f, 0.12431440f, 0.00560165f, 0.03315596f, 0.07468069f, 
    0.26801202f, -0.00051486f, -0.04295497f, 0.09598681f, 0.04979784f, 0.02903762f, 0.08391316f, 0.06339689f, 
    0.01072186f, 0.02214125f, 0.20211162f, 0.12191205f, -0.29001135f, 0.26427221f, 0.03529514f, 0.03362295f, 
    0.05780174f, -0.14866637f, 0.06358244f, 0.04904046f, -0.04949348f, 0.17705232f, 0.20726326f, 0.19960840f, 
    -0.23059988f, -0.13502824f, 0.00477838f, -0.08989924f, -0.03219429f, -0.10116711f, 0.13383770f, -0.26136893f, 
    0.00975363f, -0.03538852f, 0.14655893f, 0.07592072f, 0.58281583f, -0.27809039f, -0.14796616f, 0.20966309f, 
    0.10684226f, -0.00396651f, -0.01234113f, 0.04499247f, -0.04506365f, 0.02344496f, 0.16455929f, -0.05222298f, 
    -0.22784474f, -0.00551465f, 0.05030885f, -0.20825295f, -0.01939525f, 0.03136577f, 0.07318430f, -0.07819088f, 
    0.04683308f, -0.01953910f, 0.10886316f, 0.02086254f, -0.02029512f, -0.10244726f, -0.20481065f, -0.07512662f, 
    0.29594150f, 0.05841835f, 0.15453283f, -0.10271813f, 0.10740313f, -0.00017989f, -0.12569483f, 0.07702349f, 
    0.02119988f, -0.10097049f, -0.03310006f, 0.06307483f, 0.09993526f, 0.09118909f, 0.25202778f, 0.15976422f, 
    0.00460736f, -0.08510817f, 0.09759031f, -0.01708573f, 0.26422364f, -0.07547869f, 0.17228787f, -0.10130807f, 
    0.11193117f, -0.06711867f, 0.19570827f, 0.07701123f, -0.02984947f, 0.05495508f, 0.02360080f, 0.02384401f, 
    -0.04174549f, -0.22038989f, -0.00266311f, 0.08265778f, -0.04823023f, 0.06001534f, 0.08604433f, -0.00096371f, 
    0.00718155f, -0.18808228f, -0.05713548f, -0.13974023f, -0.22542618f, 0.14999554f, 0.01870609f, -0.06765697f, 
    0.19413798f, -0.12443994f, -0.02255659f, -0.07823345f, 0.06912486f, 0.24039076f, 0.12044635f, 0.09388053f, 
    -0.41021007f, -0.07022631f, -0.29535890f, -0.22952653f, 0.02777739f, 0.04143744f, 0.01483725f, 0.13378911f, 
    0.00794217f, -0.08356774f, 0.03427881f, 0.04118706f, -0.13878822f, -0.38242424f, -0.30300564f, -0.08647171f, 
    0.04670378f, -0.02092983f, -0.11437020f, 0.36245358f, 0.06164048f, -0.15107940f, 0.03040177f, 0.11141776f, 
    -0.19819792f, -0.24518287f, -0.16138563f, 0.12862922f, 0.28015301f, -0.02696364f, 0.04671600f, 0.03081079f, 
    0.22366181f, 0.19455245f, -0.06043858f, 0.27158633f, 0.02544863f, -0.14621492f, -0.01666538f, 0.07566671f, 
    0.08272992f, -0.21591051f, 0.00947819f, 0.15698420f, 0.15922666f, 0.07869785f, 0.11336020f, 0.31949434f, 
    -0.16011593f, -0.00774955f, -0.10782134f, -0.24129653f, 0.01005619f, 0.09061439f, -0.03897942f, -0.00068532f, 
    -0.02213973f, 0.14368474f, 0.06980509f, 0.03412562f, -0.03261925f, 0.00871012f, -0.24759603f, 0.12999234f, 
    0.18651031f, 0.18375421f, 0.08795073f, 0.15627798f, -0.04366414f, -0.01680224f, 0.12088473f, -0.03309202f, 
    -0.03505626f, -0.13834523f, -0.08667933f, -0.02110237f, -0.04853363f, 0.03056034f, -0.01251499f, 0.04250323f, 
    -0.02295836f, 0.04586801f, 0.12270024f, -0.12261847f, -0.05343194f, 0.05143612f, 0.06971157f, -0.11601202f, 
    0.10048756f, -0.09958844f, -0.04409177f, 0.10413179f, 0.04458758f, 0.08379234f, 0.21525289f, 0.14094597f, 
    -0.36167341f, -0.17308648f, -0.12523119f, -0.04499648f, -0.01675530f, 0.00087875f, -0.15589328f, 0.09086608f, 
    0.19117372f, -0.10876074f, 0.05690586f, 0.03549188f, 0.25829449f, 0.21973239f, -0.27030349f, 0.08630135f, 
    0.29037705f, 0.19717188f, 0.23677079f, 0.00197130f, -0.06691742f, 0.03041047f, -0.09541199f, 0.02171047f, 
    0.03178299f, 0.00322423f, -0.01694117f, 0.02551275f, 0.02334601f, -0.01630254f, 0.00117841f, 0.00094727f, 
    -0.03845859f, -0.02608970f, 0.01667744f, -0.00015815f, -0.05316555f, 0.01099806f, 0.01126012f, 0.03997269f, 
    0.02171773f, 0.04144145f, -0.02407672f, -0.05619755f, -0.03896475f, -0.04947003f, 0.00724702f, 0.03959585f, 
    -0.02980903f, -0.05421495f, -0.03954801f, -0.01786366f, -0.03538359f, -0.04405142f, -0.00918331f, 0.01885831f, 
    -0.01995915f, 0.01267911f, -0.00652785f, -0.03757519f, 0.00938568f, 0.00749362f, -0.04409347f, -0.03190551f, 
    0.00960959f, 0.02352105f, 0.03252501f, -0.03653111f, -0.04575182f, -0.01760835f, 0.00939256f, -0.02760637f, 
    -0.01277868f, -0.04107855f, 0.02740104f, 0.02035944f, 0.01576972f, -0.02528208f, -0.03747322f, 0.03869820f, 
    0.00413712f, 0.01564316f, 0.01696816f, 0.02970224f, -0.03042431f, 0.03202906f, 0.01934450f, -0.00933058f, 
    -0.04110541f, -0.05332348f, 0.01432546f, 0.02564172f, -0.01659745f, -0.01655965f, 0.01642281f, -0.04527357f, 
    -0.01877865f, -0.01776305f, -0.00705595f, -0.03600476f, -0.05898413f, -0.02418744f, 0.02660787f, -0.01097042f, 
    -0.03056407f, 0.00463765f, -0.01113065f, 0.01657947f, -0.02914821f, 0.00467473f, 0.05187054f, -0.02256928f, 
    -0.02296359f, 0.00814690f, 0.02170419f, -0.00674208f, 0.04631862f, 0.00539868f, 0.03704089f, -0.01075301f, 
    -0.03736606f, -0.00243615f, -0.02152665f, 0.01897111f, 0.01922577f, 0.01295923f, -0.04770586f, -0.01880242f, 
    -0.03447572f, -0.05437611f, -0.02929595f, -0.05293596f, -0.02297287f, -0.05174218f, -0.00116486f, -0.01897642f, 
    -0.00450352f, -0.03281647f, 0.00744450f, 0.03958409f, 0.03793260f, -0.05456237f, -0.03382767f, -0.01360559f, 
    0.01667150f, -0.04187617f, -0.05440685f, -0.00450938f, -0.02546029f, 0.05037871f, -0.05658268f, 0.00979191f, 
    -0.04559086f, -0.03574410f, 0.03902955f, 0.02851857f, -0.01777462f, -0.02527154f, 0.01115199f, -0.04872316f, 
    0.03692656f, 0.00695447f, 0.02127154f, -0.03707673f, 0.02880946f, -0.00058376f, -0.03412963f, -0.03643027f, 
    0.02491965f, -0.03881223f, 0.02323158f, 0.01046289f, -0.01433372f, -0.05263796f, -0.01344781f, 0.03375805f, 
    0.03379865f, -0.03951163f, 0.00640757f, 0.02360370f, -0.03290784f, 0.00979019f, 0.01498068f, -0.02350771f, 
    -0.02607559f, -0.04961688f, -0.01236964f, -0.02490601f, -0.01572775f, -0.01015128f, 0.00951061f, -0.00271111f, 
    -0.00322775f, 0.02488157f, -0.02642723f, 0.01233664f, -0.02323728f, 0.02097989f, -0.03727968f, -0.03802688f, 
    0.00248753f, -0.00536585f, 0.01275385f, -0.02225528f, 0.00087179f, -0.03516179f, -0.02292299f, -0.00846475f, 
    0.02297188f, -0.03571950f, 0.04269791f, -0.04858841f, -0.02852583f, -0.03400032f, 0.01648042f, 0.01587028f, 
    -0.02046786f, -0.02657439f, 0.01870404f, 0.04043959f, 0.00226050f, -0.02353016f, 0.00906228f, -0.05733914f, 
    -0.04970185f, 0.03421598f, 0.01754905f, -0.04665134f, 0.00665751f, 0.04154736f, -0.03837443f, -0.00220473f, 
    -0.04125711f, 0.02745367f, -0.03417992f, -0.03953808f, -0.02703045f, -0.04351679f, -0.00725137f, -0.01909584f, 
    0.03858965f, -0.02179122f, -0.04550064f, -0.05012617f, 0.03910747f, -0.00987344f, -0.04190856f, 0.01218672f, 
    -0.01762495f, -0.00900726f, -0.00320526f, -0.01704173f, 0.00378951f, -0.04175649f, 0.04636108f, -0.04165668f, 
    -0.03524160f, 0.00285309f, 0.01739678f, 0.01751008f, 0.00132958f, -0.02839663f, -0.01478117f, 0.03616139f, 
    -0.05103380f, 0.01612514f, -0.01482527f, 0.00750765f, 0.02024045f, 0.02035245f, -0.00541962f, 0.00120154f, 
    0.01001056f, -0.05769474f, -0.02712115f, -0.04317617f, 0.00877424f, -0.04428187f, -0.03214017f, -0.01797191f, 
    -0.02811168f, -0.04471204f, -0.01110547f, -0.01241167f, 0.02032111f, -0.00154518f, -0.05381415f, -0.03491231f, 
    0.01459497f, 0.00768421f, 0.03142905f, -0.00603205f, -0.02181141f, -0.01799369f, 0.02463518f, 0.04087902f, 
    0.01279406f, -0.04909392f, -0.05638632f, -0.04529072f, -0.03381103f, -0.03976708f, -0.05557984f, -0.02929238f, 
    -0.05254356f, -0.05920438f, 0.02342732f, 0.01573901f, 0.02368353f, -0.02976422f, -0.00855349f, -0.03202744f, 
    -0.00188630f, 0.01364304f, -0.02109264f, -0.03917956f, -0.00339642f, -0.00152559f, -0.04929735f, -0.04037605f, 
    -0.00414953f, -0.00167565f, -0.04485556f, -0.00187014f, 0.03708610f, 0.02522098f, -0.04265317f, -0.02596591f, 
    0.01836855f, 0.00535618f, 0.02154670f, 0.02111615f, 0.03194392f, -0.02241105f, 0.02777965f, 0.04261257f, 
    0.00540008f, -0.01109937f, 0.01972951f, -0.04636281f, -0.02106358f, 0.02567445f, 0.00250881f, 0.03852548f, 
    -0.01694035f, -0.03802350f, -0.01051230f, 0.04164624f, -0.00963412f, -0.03428273f, 0.01635583f, -0.04444197f, 
    -0.01474623f, 0.02959477f, -0.05750815f, -0.04731172f, -0.02418481f, -0.00082141f, 0.04204760f, 0.02388684f, 
    -0.01295638f, 0.00449568f, 0.00814322f, -0.05440378f, 0.01270393f, -0.00453939f, -0.03790414f, 0.00694737f, 
    0.03627925f, 0.03271132f, -0.05379984f, -0.05652899f, 0.02038923f, 0.02687258f, -0.02782962f, 0.01350117f, 
    0.04533211f, 0.01081961f, 0.01091169f, 0.04275870f, -0.04226313f, 0.03440810f, 0.03956991f, 0.03961667f, 
    0.03325818f, -0.00362077f, -0.03025286f, -0.05385751f, 0.01012724f, 0.00492660f, -0.05891875f, -0.03289245f, 
    -0.00150034f, -0.04707106f, 0.02773693f, -0.04995421f, 0.03059165f, 0.00485344f, -0.04022536f, -0.04719802f, 
    -0.03553595f, 0.01538654f, 0.04270367f, 0.01304942f, -0.01817077f, -0.02630146f, 0.02984402f, -0.01099797f, 
    -0.09069543f, -0.47028744f, 0.11592173f, -0.12306214f, -0.02062022f, -0.04425007f, -0.05987442f, -0.10889846f, 
    0.00047420f, -0.09765969f, -0.00404439f, 0.03405171f, 0.35459110f, 0.07672802f, 0.03691779f, -0.21894200f, 
    -0.03591031f, -0.06325716f, -0.11399717f, -0.10667573f, -0.07417016f, 0.04972018f, 0.07705408f, 0.26376075f, 
    0.13925736f, -0.10131097f, -0.08359676f, -0.11202950f, -0.00157241f, -0.02304761f, 0.14644110f, 0.12784526f, 
    0.00910572f, -0.08593432f, 0.32801867f, -0.11427856f, 0.21209829f, 0.11825889f, -0.09447107f, 0.18865931f, 
    -0.05922353f, -0.07332019f, 0.04590323f, 0.04646428f, 0.08997853f, 0.12916814f, 0.00961528f, 0.14405316f, 
    0.19849874f, 0.10018445f, 0.05868107f, 0.05219480f, -0.02848817f, -0.05739276f, -0.00666690f, 0.02195999f, 
    0.03357236f, -0.17079988f, -0.01349790f, -0.04966220f, 0.36282912f, 0.00483336f, 0.00286499f, -0.17239074f, 
    0.00591198f, -0.02076850f, 0.00886173f, -0.07581862f, -0.03532460f, -0.10191499f, -0.01883706f, -0.06718060f, 
    0.24069443f, -0.31048766f, 0.43530402f, -0.20880127f, -0.08711567f, -0.17567755f, -0.08083207f, -0.02701329f, 
    -0.09054644f, -0.09740737f, -0.03095882f, -0.07775831f, 0.01525542f, -0.03704950f, 0.02894119f, -0.05325958f, 
    0.07364208f, 0.01291797f, -0.05977040f, -0.09059652f, -0.12372199f, -0.05158393f, -0.02932804f, -0.04490500f, 
    -0.06165377f, -0.14459890f, -0.05042492f, -0.02677507f, 0.05327861f, -0.07503557f, -0.04596771f, -0.05905269f, 
    0.00352827f, -0.03621018f, -0.03232576f, -0.07987136f, -0.17287186f, 0.26947674f, 0.36077020f, 0.04091478f, 
    0.05921385f, 0.09954455f, -0.01137961f, -0.01260176f, 0.06349408f, -0.00729934f, -0.07767123f, 0.00768670f, 
    0.05371141f, 0.24307479f, -0.03514627f, 0.07391587f, 0.00205621f, -0.07146478f, -0.03977571f, -0.03962992f, 
    -0.03122660f, -0.08051181f, -0.22331575f, -0.07447450f, 0.17379366f, 0.11172855f, -0.21116367f, 0.11891533f, 
    0.07208017f, -0.00491870f, 0.15792155f, -0.06016419f, 0.01968322f, -0.07749855f, -0.03627100f, -0.02096552f, 
    -0.19623159f, 0.00496740f, -0.06968109f, 0.07000422f, -0.10362352f, 0.01151823f, 0.03464873f, -0.02373021f, 
    -0.06883513f, -0.09576868f, -0.03853688f, -0.02985077f, 0.04956825f, -0.01517693f, -0.02285742f, -0.01667807f, 
    -0.05222813f, 0.05570526f, 0.13720755f, -0.00816450f, -0.09251075f, 0.03950404f, -0.14428768f, -0.03542878f, 
    -0.11759944f, -0.02990769f, 0.20036726f, 0.07480378f, -0.04723961f, -0.03114159f, -0.07398482f, -0.00067652f, 
    -0.02383631f, -0.09820078f, -0.00670653f, -0.04442657f, -0.29422262f, -0.27326339f, -0.05596155f, -0.00269130f, 
    -0.22453526f, 0.10061565f, -0.11964384f, -0.04297133f, -0.09461680f, 0.12015033f, 0.02817489f, -0.20453276f, 
    -0.44381523f, 0.12258250f, -0.08985656f, 0.03299216f, -0.03596099f, 0.10425419f, 0.01731142f, 0.16361015f, 
    -0.00848037f, -0.10719071f, -0.07248673f, -0.02475287f, -0.08916463f, 0.13762155f, 0.00609802f, -0.07839262f, 
    -0.02810943f, -0.00249520f, 0.17656881f, -0.02394886f, -0.02874777f, 0.08950214f, -0.05356681f, -0.01269280f, 
    -0.08071838f, -0.04629739f, -0.36858916f, 0.03727854f, -0.04946825f, -0.01108555f, 0.19064991f, 0.07416794f, 
    -0.08706701f, -0.07697446f, 0.12335592f, -0.10841218f, -0.02599259f, -0.06522838f, 0.07541011f, -0.07662037f, 
    0.10045701f, -0.03062582f, -0.04306341f, -0.13294916f, -0.04916857f, -0.04583801f, -0.10876188f, 0.00741261f, 
    0.29186416f, -0.19763993f, 0.25228474f, 0.06645789f, 0.00260460f, -0.02270515f, -0.00759646f, -0.08104464f, 
    0.01931042f, 0.00867910f, 0.14776213f, 0.02231834f, 0.02278414f, 0.21294135f, 0.03054105f, 0.06419072f, 
    0.06557943f, -0.23459509f, 0.02668973f, -0.05155367f, -0.03962667f, -0.10343754f, 0.09165126f, -0.02183492f, 
    -0.30724233f, -0.20425859f, -0.46759313f, -0.45525992f, 0.07511050f, -0.21947761f, -0.10380016f, 0.08917161f, 
    0.05786976f, 0.00790585f, 0.00624547f, 0.05298828f, -0.39240271f, -0.22354177f, -0.49873498f, -0.07093804f, 
    0.10677221f, -0.07752615f, 0.05069544f, -0.12061585f, 0.06769406f, 0.01475943f, -0.09479120f, -0.00461186f, 
    0.07530743f, 0.12645845f, -0.02844048f, -0.22313116f, -0.17227399f, -0.18047875f, -0.19506517f, 0.01348677f, 
    -0.07357703f, 0.02809416f, -0.03857796f, -0.03809450f, 0.19017795f, 0.07858453f, 0.17352211f, -0.00431263f, 
    0.01892948f, -0.08784427f, -0.03211755f, -0.09387070f, -0.05013220f, -0.06365527f, -0.03295830f, -0.06624370f, 
    -0.08448629f, 0.17394710f, -0.12368629f, -0.11832106f, 0.13351408f, 0.04888580f, -0.05669192f, -0.06803285f, 
    -0.10874540f, 0.01169452f, -0.02537880f, 0.01254598f, 0.08513897f, -0.02267474f, -0.32193723f, -0.14342660f, 
    0.07591091f, 0.11493389f, 0.05541688f, 0.05466543f, 0.02500569f, -0.04398835f, -0.03532012f, 0.02705899f, 
    0.12111674f, 0.02673038f, 0.07625846f, 0.05341062f, -0.03563265f, 0.01594973f, -0.03012695f, 0.03227928f, 
    0.21898383f, 0.03254158f, 0.11085188f, 0.09961026f, 0.21697123f, -0.00678849f, 0.08678542f, 0.10178909f, 
    -0.04891645f, -0.03373636f, 0.02636454f, -0.10568551f, -0.07489084f, 0.09242237f, -0.04773763f, -0.07522681f, 
    0.25134209f, -0.12456168f, -0.24005374f, -0.15132870f, -0.06581713f, -0.09503073f, -0.22750033f, -0.04097574f, 
    0.11466068f, 0.17960240f, 0.24912681f, 0.07245806f, -0.23756310f, 0.25645167f, -0.34557590f, 0.08669050f, 
    0.06867895f, -0.00032745f, 0.07929951f, -0.19492300f, 0.04671856f, 0.07932092f, 0.09073626f, 0.04634823f, 
    0.17205223f, -0.00208518f, -0.16855097f, -0.31867298f, -0.07507253f, -0.06509371f, -0.01356723f, 0.21316412f, 
    0.12040238f, -0.10348737f, 0.13249737f, -0.02146127f, 0.29131857f, 0.08153218f, -0.03537974f, 0.19338416f, 
    0.03754424f, -0.04936760f, -0.00586528f, -0.03245912f, 0.03608927f, -0.08997016f, 0.04358960f, -0.14451933f, 
    -0.15589316f, -0.09786142f, 0.05302919f, -0.19596533f, 0.03565408f, 0.12123204f, -0.07150324f, 0.15985702f, 
    0.14049199f, 0.22107343f, -0.30532235f, 0.21854401f, -0.29593468f, -0.08860330f, 0.02427946f, -0.20662370f, 
    -0.03842735f, -0.09177390f, 0.02536118f, 0.06814411f, -0.07134254f, -0.07191357f, 0.08249985f, 0.03913128f, 
    -0.24876860f, 0.01442357f, 0.07425274f, -0.05823525f, -0.02156659f, 0.01315074f, -0.00764399f, -0.02296709f, 
    -0.03132055f, 0.22366437f, -0.00820389f, 0.02130688f, -0.35063145f, 0.15088402f, 0.06015606f, 0.11952669f, 
    0.09643843f, -0.07482253f, -0.06086262f, -0.01632075f, 0.04430170f, 0.00919367f, 0.00415798f, 0.15211757f, 
    0.11224303f, 0.12102188f, -0.26175198f, 0.19217707f, 0.06376930f, 0.10753839f, -0.01741951f, -0.03353348f, 
    0.28127187f, 0.06006446f, -0.12771428f, 0.01753449f, -0.01129733f, 0.10513111f, 0.04093130f, 0.03207124f, 
    -0.10247700f, 0.01810104f, 0.10250135f, -0.03036548f, 0.06124275f, -0.07075931f, 0.07380686f, 0.01761402f, 
    0.32017154f, 0.23927456f, 0.18803880f, 0.15879224f, 0.05697989f, -0.04792132f, 0.04689804f, -0.07482281f, 
    -0.05837326f, 0.03075011f, -0.05852935f, 0.00482214f, -0.13299723f, -0.34404734f, -0.41346478f, -0.24330911f, 
    -0.09473620f, -0.12765230f, 0.12979417f, 0.01311925f, -0.06145029f, -0.04910241f, 0.00261692f, 0.05788794f, 
    0.08620168f, 0.04222211f, -0.21915711f, -0.18275081f, -0.02236984f, 0.01102036f, 0.04529427f, -0.03017859f, 
    0.06851723f, 0.09926049f, 0.33805138f, -0.09819851f, 0.02272054f, 0.17169547f, 0.17862977f, -0.01129755f, 
    -0.08576077f, -0.08663530f, -0.08329288f, 0.05689945f, -0.06006481f, -0.04572359f, -0.03783954f, 0.03592565f, 
    -0.07659323f, 0.15046294f, -0.16569826f, -0.00268366f, 0.18219848f, -0.09207303f, -0.00215156f, -0.00735059f, 
    0.09445136f, 0.11369821f, -0.19373506f, -0.05841257f, 0.26960975f, -0.14107105f, -0.19294821f, 0.06083021f, 
    0.00190574f, -0.11719540f, 0.09339935f, 0.00866358f, 0.25717074f, 0.07063989f, -0.07140195f, 0.03932527f, 
    -0.12563089f, -0.02556769f, -0.08846221f, -0.21774819f, -0.04849990f, -0.02045860f, -0.03063161f, 0.20251237f, 
    -0.05542637f, 0.01365694f, -0.12129986f, 0.02747989f, 0.39007556f, 0.10883608f, 0.05222975f, -0.05670537f, 
    0.16002096f, 0.12782852f, 0.10335459f, -0.12139090f, 0.25865576f, 0.01295319f, 0.09732246f, 0.19635932f, 
    -0.00537729f, -0.06696018f, -0.12284724f, -0.06845071f, -0.05406500f, -0.00468395f, 0.00133730f, 0.05716569f, 
    -0.04550395f, 0.09083690f, -0.08822013f, -0.06773645f, 0.00428948f, -0.13862784f, -0.03512829f, -0.01106594f, 
    -0.00187903f, 0.08285335f, -0.00590550f, 0.03517980f, -0.12155173f, -0.04075526f, 0.10897048f, -0.06147265f, 
    0.00488446f, 0.01240528f, 0.09562289f, -0.31075364f, -0.02057979f, -0.02098791f, -0.22562630f, 0.03433088f, 
    -0.07928225f, 0.13927987f, -0.05486263f, 0.11894237f, -0.03317008f, 0.21744089f, -0.02388766f, -0.03403253f, 
    0.12483390f, 0.00165750f, -0.00662678f, -0.07608551f, -0.01531672f, 0.01024047f, 0.11620037f, -0.07906749f, 
    0.04366212f, -0.01497700f, -0.00959031f, -0.32723299f, -0.01514687f, 0.04071591f, -0.11675785f, 0.01105115f, 
    -0.05843078f, 0.15253983f, -0.10089741f, -0.10213251f, -0.05155199f, -0.04737457f, -0.03513856f, 0.04613233f, 
    -0.09694307f, 0.06430387f, 0.12362753f, -0.00657233f, 0.04445226f, 0.03359295f, -0.02191392f, 0.03161800f, 
    0.05246354f, -0.09937457f, 0.23632389f, 0.02882855f, 0.07830212f, 0.15739498f, -0.04058272f, 0.05215456f, 
    0.00977968f, -0.00323799f, -0.03595255f, -0.06163398f, 0.19497921f, -0.01802338f, 0.13636728f, -0.04924307f, 
    -0.01431605f, 0.09801845f, 0.17245856f, -0.13977847f, -0.00475073f, -0.02014805f, -0.02662349f, -0.18280269f, 
    -0.05760259f, -0.13101992f, -0.04739146f, 0.02790614f, 0.12022407f, 0.17718273f, -0.01164176f, 0.00390659f, 
    0.00562220f, -0.09513973f, 0.15227345f, -0.13444914f, -0.01630593f, -0.02818239f, 0.08282799f, 0.04107603f, 
    0.08653630f, 0.03277090f, -0.07265369f, -0.07434489f, -0.05678093f, 0.14847742f, 0.01423905f, 0.01522179f, 
    0.08458118f, 0.04996577f, 0.02874449f, 0.10577344f, -0.06011953f, -0.00768219f, 0.20693387f, 0.07164202f, 
    0.06033021f, 0.00020037f, -0.06747647f, -0.01234002f, -0.06921921f, 0.06131388f, 0.04442776f, 0.02031792f, 
    0.12753108f, -0.02752830f, 0.05246348f, -0.02217062f, -0.01280914f, 0.01704347f, -0.03772821f, -0.01454830f, 
    -0.07607317f, -0.03140112f, 0.04719158f, -0.08108742f, -0.00448824f, 0.03824130f, -0.03148118f, -0.03148655f, 
    -0.15036911f, -0.04573683f, -0.19086075f, -0.12746781f, 0.09929352f, -0.01658701f, -0.14159878f, 0.18085374f, 
    -0.02039219f, 0.15411164f, -0.00435686f, 0.01730061f, -0.00870397f, 0.10591672f, 0.04840801f, -0.04926509f, 
    0.27966800f, -0.06929142f, 0.21753001f, 0.10668814f, 0.01309385f, 0.04768170f, 0.21772292f, -0.05080931f, 
    -0.04345810f, 0.04500907f, 0.11779946f, -0.17440878f, -0.61566430f, -0.24543993f, 0.33562699f, -0.12069131f, 
    0.06419694f, 0.08617292f, -0.07003695f, 0.09159382f, 0.02427223f, -0.10399781f, 0.02862350f, 0.07050185f, 
    -0.22698447f, -0.10656830f, 0.05920701f, 0.02481683f, 0.05364821f, 0.20317797f, 0.17679210f, 0.14591463f, 
    0.17959088f, 0.07068121f, 0.00650995f, -0.00885112f, -0.19997855f, -0.23935093f, -0.23188660f, -0.18917644f, 
    -0.04121155f, -0.16290443f, -0.13086174f, -0.02082840f, 0.01134047f, -0.04594114f, 0.12823793f, 0.03612177f, 
    -0.00798625f, 0.07740589f, -0.02360600f, -0.17785718f, 0.01659929f, -0.01943881f, 0.16255130f, 0.13290240f, 
    -0.14463568f, 0.01879910f, -0.03200652f, -0.12005609f, 0.16579884f, -0.04528720f, 0.06681107f, -0.04347156f, 
    -0.04084948f, 0.02525835f, 0.07977546f, 0.01539695f, -0.14298473f, 0.02357408f, -0.03021836f, -0.13328834f, 
    0.10317413f, 0.02631870f, 0.10173248f, 0.03884735f, -0.02739984f, 0.01538258f, 0.04618031f, -0.00112167f, 
    -0.05346535f, -0.08362928f, -0.17399722f, -0.30650994f, 0.39518610f, -0.16677220f, 0.19102193f, 0.35417366f, 
    0.17371050f, 0.06186501f, 0.09061509f, 0.14657232f, -0.04090130f, -0.09257355f, 0.09932975f, 0.06004321f, 
    -0.23752764f, -0.16496144f, 0.13919431f, 0.21880987f, -0.10981075f, 0.13385306f, -0.01495687f, 0.01786042f, 
    0.20098938f, -0.19935559f, 0.01385558f, -0.04011706f, 0.11625951f, 0.12824903f, 0.01493911f, -0.04003802f, 
    0.00334136f, 0.04661560f, -0.03832070f, -0.03733564f, -0.02757086f, 0.04596135f, 0.02859212f, -0.00519532f, 
    0.64662093f, 0.12686472f, -0.06365556f, 0.11941262f, -0.04155539f, 0.05446301f, -0.01307436f, -0.03066577f, 
    -0.02647444f, -0.05278941f, -0.03187200f, -0.04686508f, -0.17547747f, 0.01179083f, 0.20444192f, 0.11518008f, 
    0.04748445f, 0.00433657f, 0.04020154f, -0.02625818f, -0.07066892f, -0.09584276f, 0.03338534f, -0.05917517f, 
    0.14827204f, 0.06570251f, 0.31223878f, 0.35252288f, 0.00523015f, 0.09403398f, -0.02786924f, -0.04542319f, 
    0.05266958f, 0.08747690f, 0.02873927f, 0.20553628f, 0.54314804f, -0.18330523f, 0.01016774f, 0.20673816f, 
    -0.07923710f, -0.08468319f, 0.00182586f, -0.02938632f, 0.05018090f, 0.07933075f, 0.01562669f, 0.11301978f, 
    -0.05358668f, 0.12689899f, 0.12388267f, 0.21662317f, 0.10670105f, -0.04377103f, 0.01654401f, 0.06701001f, 
    0.07396520f, 0.10954112f, 0.09745252f, -0.10658745f, 0.10691937f, 0.22301088f, -0.04982290f, 0.01358660f, 
    -0.05401031f, -0.08367828f, -0.03939886f, 0.14369650f, 0.04657499f, -0.03765740f, 0.21138911f, -0.03401935f, 
    0.17594397f, 0.16197136f, 0.34525725f, 0.13030782f, -0.11569022f, 0.05876744f, 0.02930207f, -0.00289332f, 
    0.03732306f, -0.04259422f, 0.04703312f, 0.09312452f, -0.74014199f, -0.03852751f, 0.22478218f, 0.19005349f, 
    0.20188068f, 0.01545137f, -0.11704656f, -0.01016067f, 0.06675675f, 0.18038869f, -0.01071401f, 0.00638488f, 
    -0.20233893f, 0.01868435f, 0.23891330f, -0.05054941f, -0.02347546f, 0.01970366f, -0.11051514f, 0.13765393f, 
    0.05030025f, 0.00440720f, -0.06313777f, -0.00807373f, -0.18800846f, -0.00057988f, -0.15514821f, -0.09967373f, 
    0.01774250f, 0.14117666f, 0.29226181f, 0.07305899f, -0.04604070f, -0.07188096f, -0.01940621f, -0.01383314f, 
    0.01779989f, 0.15976040f, -0.00045770f, -0.15773171f, -0.14575785f, -0.26536691f, 0.05507936f, 0.06162526f, 
    -0.06363972f, -0.02102994f, -0.11694997f, 0.02220150f, 0.19496123f, 0.12085556f, 0.09556237f, 0.08190546f, 
    0.06775154f, 0.16458511f, 0.08697245f, -0.01597422f, 0.04010174f, -0.06190771f, 0.05677405f, 0.12678319f, 
    0.26033548f, 0.03975929f, 0.11596344f, 0.09113780f, -0.08271109f, 0.01803050f, -0.08974502f, -0.06567890f, 
    0.00989532f, 0.05776719f, 0.09059341f, -0.26876223f, 0.03473022f, 0.00819538f, 0.18421003f, -0.17417854f, 
    0.00581773f, 0.00501005f, 0.01793263f, -0.08347257f, 0.04776971f, 0.17118093f, 0.01067793f, -0.05574251f, 
    0.12181622f, 0.26209861f, 0.02521745f, -0.11292444f, 0.04883974f, 0.00137833f, 0.11125831f, 0.06451829f, 
    0.05460497f, -0.09639052f, -0.05694457f, -0.02696177f, 0.24429113f, 0.05912542f, 0.06690437f, -0.04627078f, 
    0.15611504f, -0.08745147f, -0.03408675f, 0.02045098f, -0.10009855f, -0.08745662f, 0.04242631f, 0.08532484f, 
    -0.47920072f, -0.04967606f, -0.03883322f, 0.10378519f, 0.02055446f, -0.17003414f, 0.17945133f, -0.00472926f, 
    0.10167319f, 0.02118715f, 0.03942753f, -0.15381166f, 0.06538356f, 0.01156385f, 0.05215849f, 0.05861996f, 
    0.00089341f, -0.06038110f, -0.11407130f, -0.12023950f, 0.16071340f, -0.07307043f, 0.13428167f, 0.18411881f, 
    0.11186136f, 0.18476218f, 0.16806269f, -0.03658389f, -0.05501754f, 0.06148338f, 0.02657178f, 0.04599859f, 
    0.07232171f, 0.02388306f, -0.01296080f, -0.13291618f, 0.00039563f, 0.01484257f, -0.05902204f, -0.18218683f, 
    0.18959880f, 0.14577067f, -0.05384570f, 0.05225874f, -0.10269961f, -0.05760346f, 0.05854718f, 0.04902195f, 
    0.04995204f, 0.07771841f, 0.13166189f, 0.04341615f, 0.02181277f, 0.04236082f, -0.02272760f, -0.01304101f, 
    0.01077186f, -0.14795187f, 0.00736575f, -0.17637146f, -0.04217865f, 0.05571508f, 0.14824104f, 0.39222834f, 
    0.06681278f, -0.05246796f, -0.15524715f, -0.03112414f, 0.17799826f, 0.19140147f, 0.08627592f, 0.22728401f, 
    0.13890123f, -0.34329444f, -0.36085272f, -0.33763462f, -0.09360103f, -0.16540200f, -0.25400794f, -0.17308892f, 
    -0.00619062f, -0.06966169f, -0.04347109f, -0.16658312f, 0.09550651f, 0.09477656f, -0.11725894f, 0.37417305f, 
    0.22631565f, -0.01670895f, 0.06822192f, -0.15957479f, -0.16036947f, -0.00088807f, -0.11033311f, 0.04496898f, 
    0.00769144f, -0.42188656f, 0.03000003f, -0.25293592f, 0.07349706f, 0.08389556f, -0.09962974f, 0.03574864f, 
    0.20928197f, 0.02057541f, 0.04180270f, 0.04107356f, -0.23595862f, 0.23252925f, 0.29110852f, 0.23234805f, 
    -0.06563337f, -0.19403556f, -0.04539179f, -0.09446990f, -0.03837786f, 0.03105344f, 0.01470316f, 0.28555965f, 
    0.01075832f, -0.03255305f, -0.09805796f, -0.07436429f, -0.08439189f, 0.00688599f, -0.00282760f, -0.01034425f, 
    0.12668751f, 0.25942791f, -0.11390996f, 0.11967357f, -0.12488355f, -0.12595654f, 0.10483460f, -0.12205639f, 
    -0.00175041f, -0.04951372f, -0.06159686f, -0.10016665f, 0.08380968f, 0.00932095f, 0.01239479f, 0.29607689f, 
    0.10231617f, 0.05354581f, 0.10355327f, -0.06439375f, 0.02891375f, -0.04179223f, -0.02819593f, -0.02744344f, 
    -0.12746559f, 0.19371083f, 0.04973495f, 0.34850058f, -0.12393613f, 0.08281457f, -0.02677415f, -0.24379098f, 
    -0.05122687f, 0.07789291f, -0.10895798f, -0.02016514f, 0.13395514f, 0.04279970f, 0.09861919f, 0.06462272f, 
    0.06135712f, 0.05049101f, 0.22085334f, 0.42325151f, -0.11183992f, -0.00399179f, -0.04105115f, -0.15182808f, 
    0.20579091f, 0.06077258f, -0.14257838f, 0.14300233f, -0.01498574f, 0.01882181f, -0.03201871f, 0.07606725f, 
    0.01135117f, 0.02827621f, 0.12406300f, -0.02080215f, 0.11810914f, -0.03226535f, -0.02932592f, 0.01979255f, 
    0.01590813f, -0.10991055f, -0.13644989f, 0.14684239f, 0.02065349f, 0.03002644f, 0.03377679f, 0.06340726f, 
    -0.00319412f, 0.01198575f, -0.05805231f, 0.00088616f, 0.07815167f, 0.16293864f, -0.08288867f, -0.25060180f, 
    -0.00877049f, -0.14743741f, 0.05722413f, 0.03901848f, 0.06142644f, -0.02415844f, 0.07530877f, 0.05323029f, 
    0.00813772f, 0.00369201f, 0.08992410f, 0.26315355f, -0.00412392f, -0.08527245f, 0.07294818f, 0.01064912f, 
    -0.13026452f, 0.06078261f, 0.05808714f, -0.11755693f, 0.20640524f, -0.15786998f, -0.13380475f, -0.24108171f, 
    -0.02533306f, -0.08351897f, -0.05610862f, 0.05523385f, -0.02426630f, -0.10942169f, -0.11155592f, -0.05110649f, 
    -0.10985564f, 0.05680688f, 0.02905702f, -0.03126683f, 0.07515022f, 0.02094520f, -0.01293994f, -0.01062947f, 
    0.05611167f, 0.05779820f, 0.00471822f, -0.03326538f, 0.41922548f, -0.18814600f, -0.11231118f, -0.16133232f, 
    0.01897459f, 0.09312345f, -0.13901167f, 0.04397045f, 0.43051857f, 0.04686436f, -0.08348832f, 0.09161101f, 
    0.25307849f, 0.11186142f, 0.00976691f, -0.21774273f, 0.19001922f, 0.13672274f, 0.11487342f, 0.23817831f, 
    -0.05365338f, -0.04033801f, -0.06256513f, -0.10769194f, -0.96909440f, 0.10250434f, 0.12337667f, 0.08475314f, 
    0.11720851f, 0.01963972f, 0.08099908f, -0.01046326f, 0.14679562f, -0.10151003f, -0.05222457f, 0.11847729f, 
    0.06502008f, 0.18585202f, -0.18950540f, 0.04909882f, 0.11427993f, 0.08295748f, -0.01896140f, 0.16494113f, 
    0.01685978f, 0.10168374f, -0.00333215f, -0.05795257f, 0.05807826f, -0.07818055f, -0.07031363f, -0.16936783f, 
    -0.02744575f, 0.10397086f, -0.06472345f, 0.08548537f, -0.01588393f, -0.11936824f, 0.01738033f, -0.18822612f, 
    0.24065650f, 0.15485606f, -0.10740873f, -0.43735585f, 0.02168179f, 0.03810511f, -0.19748279f, 0.04335047f, 
    0.05665231f, 0.14800650f, -0.03955904f, 0.11410199f, -0.09679645f, -0.01291175f, -0.23151417f, 0.13655731f, 
    0.09250421f, 0.10619975f, -0.00745328f, 0.02918922f, 0.06095196f, -0.12236958f, -0.00857992f, -0.06256443f, 
    0.27675152f, -0.18409036f, 0.19125424f, -0.20028624f, -0.01508590f, 0.01624252f, -0.16054322f, -0.06450433f, 
    -0.02001368f, 0.05570415f, 0.14587706f, 0.09194086f, 0.23534292f, 0.04067556f, 0.09148552f, 0.01366432f, 
    -0.07797749f, -0.00831133f, 0.02177234f, 0.00724026f, -0.06653649f, -0.12286241f, -0.08270681f, -0.14204310f, 
    0.27841198f, 0.01533540f, 0.21533108f, 0.05388929f, 0.07590272f, 0.12112918f, 0.00431018f, 0.03717861f, 
    0.02440041f, 0.02202322f, -0.00285789f, -0.06618177f, 0.25734457f, -0.05602459f, 0.28632343f, -0.08981469f, 
    0.05340702f, 0.03398348f, 0.10006290f, -0.14314547f, 0.10415623f, 0.01565152f, -0.00192975f, -0.00957676f, 
    -0.29394981f, 0.09071776f, 0.06421767f, 0.08596799f, -0.01068021f, 0.08478320f, -0.09107665f, -0.02490805f, 
    -0.09980696f, -0.28145906f, 0.04827711f, -0.03501806f, 0.03956842f, 0.04777849f, 0.12963617f, 0.08595935f, 
    -0.07555429f, 0.00253489f, -0.06988241f, -0.08150491f, 0.09363894f, 0.13274622f, -0.03654614f, -0.05554621f, 
    0.19849187f, 0.16913272f, 0.16845556f, 0.09626607f, 0.15116127f, 0.12791969f, 0.16123326f, 0.14562055f, 
    -0.02866276f, -0.04401917f, 0.04134164f, 0.12863091f, 0.03460127f, 0.10075070f, -0.29502493f, -0.37536433f, 
    0.01818281f, 0.02346503f, 0.19149078f, 0.07829347f, -0.03289266f, -0.00652502f, -0.15667610f, -0.01592523f, 
    0.03829563f, -0.14438489f, -0.02010169f, 0.05295921f, -0.01084314f, 0.01319421f, -0.01875793f, 0.00220622f, 
    -0.05771048f, 0.03735258f, 0.10196657f, 0.18481843f, -0.03492778f, -0.09906879f, 0.04778590f, 0.31817347f, 
    -0.03753944f, 0.04726699f, -0.02884544f, -0.01453390f, -0.00534165f, 0.05895130f, -0.02347180f, -0.12894844f, 
    0.57610196f, 0.40858915f, 0.36559540f, 0.22259156f, -0.12030870f, -0.12736294f, 0.00401658f, -0.18733722f, 
    -0.15327026f, 0.03471431f, 0.15860970f, 0.19071433f, -0.60635751f, -0.42258200f, -0.13108334f, 0.06826045f, 
    0.14299978f, -0.00997079f, -0.01113880f, 0.12252840f, 0.01790700f, -0.03978697f, -0.04098883f, 0.06761453f, 
    -0.04520128f, -0.29564053f, 0.28631464f, 0.09483857f, 0.07674933f, 0.06189087f, 0.04517340f, 0.07405887f, 
    0.04261427f, -0.09684505f, 0.07692488f, 0.01872589f, 0.23425050f, 0.24996038f, -0.04206051f, -0.29730019f, 
    -0.02446988f, 0.03250182f, 0.06926835f, 0.10250031f, -0.11551821f, -0.11610255f, -0.06499302f, 0.02091309f, 
    0.06505708f, -0.00691439f, -0.07108144f, -0.04748025f, 0.06069103f, 0.12241779f, 0.05072143f, 0.07935592f, 
    0.04029578f, -0.02018312f, 0.07016137f, -0.00072815f, 0.14151853f, 0.12304492f, -0.19832458f, -0.01508344f, 
    -0.08612747f, -0.10864774f, -0.06579520f, -0.08002890f, -0.04320752f, -0.02114517f, -0.12152968f, 0.13264522f, 
    0.05599464f, 0.05068544f, 0.06212509f, 0.03827345f, -0.02169824f, -0.13587652f, -0.01035857f, -0.01199897f, 
    -0.17488992f, -0.07437497f, -0.01936112f, 0.02381045f, 0.19008824f, 0.21796228f, -0.06113810f, 0.06312829f, 
    -0.04129256f, 0.05063917f, -0.07981953f, -0.05420455f, -0.04154763f, 0.01264784f, -0.05682727f, 0.00611457f, 
    -0.07993776f, 0.08921471f, -0.26468566f, 0.08063711f, 0.05030838f, 0.06116852f, -0.13374320f, 0.16991052f, 
    -0.02864536f, -0.13629332f, -0.06016063f, -0.12523568f, 0.01186558f, -0.04552073f, 0.09339800f, -0.04544917f, 
    -0.01826738f, -0.01977394f, 0.05262002f, -0.07851891f, -0.00248876f, 0.01715369f, 0.02391335f, -0.04298358f, 
    -0.33496821f, 0.09578958f, -0.20722541f, -0.09227139f, 0.00529418f, -0.05914814f, 0.08377437f, -0.11074433f, 
    0.01816711f, 0.05386887f, 0.01592867f, 0.03320286f, -0.60450369f, -0.31576753f, -0.00657335f, 0.28776827f, 
    -0.09704935f, 0.17173143f, -0.00686392f, -0.07107019f, -0.05243098f, -0.02105373f, 0.00968685f, 0.07379333f, 
    0.12237097f, 0.07568153f, -0.00874750f, -0.07632124f, -0.00430196f, 0.00861364f, 0.01461038f, 0.05745234f, 
    0.13789776f, -0.05431597f, -0.00555012f, -0.01678062f, 0.28975859f, 0.21992928f, 0.07455918f, -0.07575879f, 
    -0.10975924f, 0.01558211f, 0.26671371f, -0.12521189f, 0.01212354f, -0.04962933f, -0.01995927f, 0.07679728f, 
    -0.40344602f, 0.13777691f, -0.13448821f, -0.21339212f, -0.05270366f, 0.11275685f, 0.07557867f, -0.09985879f, 
    -0.08249027f, 0.01301269f, -0.08635981f, -0.01446422f, 0.10333598f, -0.02076886f, 0.28976405f, 0.30689982f, 
    0.10541385f, -0.08399180f, 0.08098863f, -0.02391126f, -0.01131182f, 0.03260228f, 0.05180040f, 0.02046801f, 
    -0.14928634f, -0.02633038f, -0.13844600f, 0.10231820f, -0.01466153f, 0.02304468f, -0.06476212f, 0.03565298f, 
    -0.04446777f, 0.00917918f, -0.02009129f, -0.01910305f, 0.01241195f, 0.05942988f, -0.03403989f, 0.06825324f, 
    -0.21688250f, 0.39538613f, -0.04087616f, -0.05354276f, 0.10287894f, 0.07882889f, 0.29307374f, -0.18382809f, 
    0.04960001f, -0.44734222f, -0.04776451f, 0.22333939f, 0.15723552f, 0.10079421f, 0.06276310f, 0.09809493f, 
    0.05526367f, -0.00114986f, -0.03954452f, 0.05361677f, -0.21143049f, 0.00567254f, 0.14205307f, 0.01085505f, 
    -0.12552926f, -0.11048183f, -0.14933684f, -0.04415341f, -0.15995626f, 0.12117028f, 0.06369606f, 0.12467479f, 
    -0.16643748f, -0.37476787f, 0.02077782f, -0.16034997f, 0.01939534f, 0.05589212f, 0.15175141f, -0.09869519f, 
    -0.05836373f, 0.02055650f, 0.03381397f, 0.07874439f, -0.09030374f, 0.06156428f, 0.01247856f, 0.02943216f, 
    0.05826214f, 0.03742513f, -0.11795332f, -0.02645544f, 0.06603646f, 0.03606050f, 0.06865741f, -0.10243706f, 
    0.11543175f, 0.11474508f, 0.07537703f, -0.03426601f, 0.03537416f, -0.06936097f, 0.06162677f, 0.03263723f, 
    0.04125056f, -0.06824148f, -0.06905366f, -0.10272072f, 0.16042626f, -0.04617400f, -0.00370784f, 0.05811642f, 
    -0.02434037f, 0.05286027f, 0.18851076f, 0.12641366f, 0.08708583f, 0.01399741f, 0.14772664f, -0.04171665f, 
    0.08772357f, -0.06952047f, 0.47597998f, 0.25423145f, 0.14141239f, -0.14043197f, 0.09772946f, 0.06973290f, 
    -0.08017290f, 0.06734744f, 0.04530325f, 0.00851442f, -0.21732162f, 0.65230012f, 0.19531052f, 0.10501037f, 
    -0.00196457f, 0.15829654f, 0.07884112f, -0.15314166f, 0.13821176f, 0.12248156f, -0.05355192f, -0.16798612f, 
    0.22701578f, 0.36871773f, 0.07775640f, -0.01406646f, -0.12162923f, -0.04911888f, -0.07153492f, 0.29955015f, 
    -0.09754133f, 0.07225512f, 0.05870688f, 0.00691668f, -0.05034777f, 0.11039332f, 0.14788817f, -0.09099787f, 
    0.12027898f, 0.15123960f, -0.09939449f, -0.06658895f, 0.03919408f, -0.07582397f, 0.04190072f, 0.01691033f, 
    -0.10422631f, -0.18307240f, 0.09503431f, 0.17617027f, 0.07403591f, -0.07140344f, 0.05803172f, -0.02422342f, 
    0.05607375f, -0.01868322f, -0.00597294f, 0.02693163f, -0.05098696f, -0.27575251f, 0.16757755f, 0.06359631f, 
    -0.11270630f, -0.00637700f, 0.07244158f, -0.09302229f, 0.08391061f, -0.07276611f, 0.01246898f, 0.17948954f, 
    0.07404619f, 0.04932314f, 0.11771838f, -0.13038193f, -0.01557801f, -0.03245315f, -0.02855387f, 0.04432770f, 
    -0.01694554f, 0.00920723f, -0.06833287f, -0.03182060f, 0.28385928f, 0.02448124f, 0.13059898f, 0.03389299f, 
    -0.05412572f, 0.04671624f, 0.06576363f, -0.08838559f, -0.12364282f, 0.20326409f, 0.07583847f, 0.04388033f, 
    -0.05910803f, 0.18180135f, 0.05231447f, -0.18017791f, -0.15900645f, -0.06498392f, -0.00662942f, 0.06855826f, 
    0.01956571f, 0.20547499f, 0.12716912f, -0.09239282f, -0.19616152f, 0.39989150f, 0.25649223f, -0.39251646f, 
    -0.16052254f, 0.22365573f, 0.13706937f, -0.14133197f, 0.04683198f, 0.09664579f, 0.14640170f, -0.01738298f, 
    0.27681717f, -0.02250207f, 0.24678649f, 0.04267076f, 0.06117583f, -0.02953285f, -0.03885985f, -0.11044188f, 
    -0.13818505f, -0.16041511f, -0.03903592f, 0.02275470f, -0.02471341f, 0.63055110f, 0.53588027f, -0.01989807f, 
    -0.03129004f, 0.03824561f, 0.18580528f, 0.34424487f, -0.05204178f, 0.09591226f, 0.02556249f, -0.04493447f, 
    -0.05825585f, 0.13261335f, -0.07276629f, 0.10600913f, 0.22209324f, 0.11234631f, -0.04417725f, 0.00221161f, 
    0.08970909f, 0.00986637f, 0.21345304f, 0.06879377f, -0.02173914f, -0.16439725f, -0.19146161f, 0.09023452f, 
    -0.11805408f, -0.20562977f, -0.06224027f, -0.27071211f, 0.03055914f, -0.10635632f, -0.17477590f, 0.00791369f, 
    0.12274304f, -0.05948180f, -0.19579369f, 0.05000170f, -0.05385302f, -0.12494648f, 0.08552945f, -0.04448996f, 
    0.10332985f, -0.03845193f, 0.03564605f, 0.24611470f, 0.12344988f, 0.20508674f, -0.31096867f, -0.30255958f, 
    -0.12161227f, -0.01915173f, -0.14312170f, -0.09443534f, 0.05605204f, -0.00946092f, 0.06191742f, 0.09534128f, 
    -0.08796355f, 0.03238000f, 0.21726255f, -0.02566088f, 0.00639070f, 0.09530453f, 0.00678368f, 0.03670514f, 
    -0.05661899f, 0.13785653f, 0.13283168f, -0.06778840f, -0.31217304f, -0.55244982f, -0.18432407f, -0.16525619f, 
    -0.17599970f, -0.10681975f, -0.13932610f, -0.04525271f, -0.20346735f, 0.00870335f, -0.07184094f, -0.04314805f, 
    -0.58159816f, -0.07117990f, 0.02404434f, 0.08115587f, -0.08078526f, -0.02671018f, -0.03572163f, -0.02963994f, 
    0.09237198f, -0.07998724f, 0.16083610f, 0.21039991f, 0.03729953f, 0.21317908f, 0.02249716f, -0.08574238f, 
    0.00305979f, 0.04553405f, -0.10199199f, -0.03435594f, 0.02662677f, 0.10506015f, -0.02050151f, 0.08250561f, 
    0.04434915f, 0.07387494f, 0.04584363f, -0.02420731f, -0.06434622f, 0.00846182f, -0.02686044f, 0.07658770f, 
    -0.01759156f, -0.06946420f, 0.01765857f, 0.23154290f, -0.37154993f, -0.03166937f, 0.22103548f, 0.04622751f, 
    -0.00293683f, 0.09215718f, 0.13962138f, -0.04165361f, 0.11169435f, -0.11969101f, -0.01227449f, -0.01655949f, 
    0.09013283f, 0.01235347f, 0.11254326f, -0.06661765f, -0.14656849f, 0.13655655f, 0.08705587f, -0.04534232f, 
    -0.01481242f, 0.05876157f, -0.02424490f, 0.19854219f, -0.17539456f, -0.09356713f, 0.34358430f, 0.17967527f, 
    0.02265179f, 0.01270479f, -0.11463235f, 0.07988539f, -0.00889893f, 0.10498113f, 0.04547412f, 0.11338886f, 
    0.01964139f, 0.02088282f, -0.18468603f, -0.02969168f, 0.15020907f, 0.04068295f, 0.09794860f, -0.05062798f, 
    -0.05374376f, -0.01114820f, 0.03319524f, -0.05647869f, -0.08792118f, 0.33387572f, -0.04369420f, -0.01761438f, 
    -0.30331436f, 0.27471280f, 0.05086839f, 0.04206688f, -0.02480130f, -0.17367427f, 0.08823308f, -0.09517152f, 
    0.14703825f, 0.05908213f, -0.03815981f, 0.02019502f, 0.06348370f, 0.04398660f, 0.04934700f, -0.02033009f, 
    0.08973573f, -0.07462122f, 0.06331377f, 0.02775331f, -0.15062830f, -0.02313513f, -0.11573762f, -0.25328586f, 
    0.17573166f, 0.00195517f, -0.12475737f, -0.12926155f, -0.14770646f, 0.15282997f, -0.18678427f, 0.02234071f, 
    -0.06752092f, -0.23925163f, -0.05430578f, 0.12501951f, 0.27668455f, 0.13849036f, 0.18358880f, -0.11810516f, 
    0.16700877f, 0.15258464f, 0.05399033f, -0.04749255f, -0.21004286f, -0.22471111f, -0.16856810f, -0.08241111f, 
    -0.04060337f, -0.03522879f, -0.20775919f, 0.13404487f, 0.01321125f, 0.09005661f, -0.06742345f, -0.08607464f, 
    -0.29875314f, -0.00895357f, -0.00673450f, 0.01781916f, -0.09075635f, -0.04832587f, 0.05435650f, -0.01925388f, 
    0.16486761f, -0.00751733f, 0.09589662f, 0.20085292f, 0.16280189f, 0.20969747f, -0.14874662f, 0.06497068f, 
    -0.08499496f, 0.06226195f, -0.01157716f, 0.04815390f, 0.06871053f, -0.10289737f, -0.04613105f, -0.07529930f, 
    -0.13784818f, -0.08326370f, -0.09323525f, 0.02028801f, -0.05120486f, 0.02802755f, -0.03409041f, 0.10179019f, 
    -0.23093091f, -0.01223705f, 0.00932120f, -0.02037678f, -0.28856924f, 0.07023881f, -0.00429433f, -0.07868522f, 
    0.01404011f, 0.04103998f, -0.03361188f, 0.19597606f, 0.05871687f, 0.07995450f, -0.04566406f, 0.05286599f, 
    0.24168262f, 0.27637079f, 0.05668302f, -0.07147265f, -0.06073231f, 0.08598072f, 0.01596586f, 0.05437426f, 
    -0.14301485f, 0.06241929f, -0.17738533f, 0.05466918f, -0.03689179f, 0.00294293f, -0.14709318f, 0.03655735f, 
    -0.02345411f, 0.14570954f, 0.05991012f, 0.18142110f, 0.07910439f, -0.01082771f, 0.13453262f, 0.10860153f, 
    0.00100188f, -0.13002406f, -0.16562098f, -0.04845576f, 0.12616111f, 0.10391513f, -0.01854268f, -0.08704381f, 
    -0.01289313f, -0.11579309f, 0.01742680f, 0.15394163f, 0.07004893f, -0.33838794f, 0.22995165f, 0.18396011f, 
    0.05558295f, 0.05437798f, 0.15008715f, 0.10632104f, 0.06674653f, -0.14769554f, -0.03208783f, 0.11998997f, 
    -0.04081027f, -0.22411573f, -0.38292021f, -0.02000318f, -0.05565515f, -0.11248539f, 0.01797528f, -0.08883895f, 
    0.09243140f, 0.18250488f, 0.14933446f, 0.22582568f, 0.13512817f, 0.08586878f, 0.36091721f, -0.35148028f, 
    -0.08841976f, -0.00476995f, 0.02207109f, 0.23170152f, -0.04535756f, 0.12919645f, 0.07416242f, 0.06284671f, 
    -0.10508195f, 0.43479386f, 0.18424979f, 0.19332871f, -0.15964040f, 0.02385833f, -0.07800961f, 0.18023682f, 
    -0.02361099f, 0.09124521f, -0.10962505f, -0.02912532f, 0.08902600f, 0.57667488f, 0.05612029f, -0.23452057f, 
    -0.24760583f, 0.21479148f, 0.17008385f, 0.03590350f, 0.08582536f, -0.06776999f, 0.02041947f, -0.06730638f, 
    0.04872773f, -0.05540903f, 0.18215805f, 0.01377986f, 0.07458048f, 0.04028456f, -0.12412342f, 0.13778323f, 
    0.01172648f, -0.07931067f, -0.04306051f, 0.04209904f, 0.49974954f, 0.23169638f, 0.25506446f, 0.07306657f, 
    -0.00156470f, -0.09783753f, -0.12990922f, -0.10215712f, 0.12434702f, 0.20680101f, -0.08031896f, 0.09208424f, 
    0.16264734f, 0.00313305f, -0.04634450f, 0.01126503f, -0.08423699f, 0.11765358f, 0.11481049f, 0.03691133f, 
    0.15991203f, 0.07618818f, 0.12137420f, 0.13958704f, -0.11361870f, 0.16741411f, 0.06129980f, 0.11209396f, 
    -0.07311415f, -0.02898091f, 0.28852537f, 0.23789203f, 0.17978372f, 0.19257231f, 0.17101198f, 0.23206207f, 
    0.04021224f, 0.09848149f, -0.03411141f, 0.02645843f, -0.16928352f, -0.03718073f, 0.07323161f, -0.15529561f, 
    0.15520184f, 0.13071470f, 0.30034247f, 0.46970174f, -0.09011701f, -0.10064287f, 0.07784112f, -0.09191859f, 
    -0.05411760f, 0.01595349f, 0.01454484f, -0.09714203f, -0.06388598f, 0.15927482f, 0.13886781f, -0.04472765f, 
    0.54228741f, 0.02338560f, 0.39669016f, 0.20434660f, 0.21728209f, 0.02081160f, -0.03668153f, 0.13260691f, 
    0.14593999f, 0.31946710f, 0.29535392f, 0.21888214f, -0.00311997f, -0.06354507f, -0.15780327f, -0.17924169f, 
    -0.09592155f, 0.07297447f, 0.03745454f, -0.04348266f, -0.27798826f, -0.39005142f, -0.06516010f, -0.39626127f, 
    -0.03893130f, -0.11194154f, 0.17711462f, -0.03181606f, 0.26850939f, -0.09481391f, -0.14567818f, -0.04461735f, 
    -0.23365487f, -0.10484917f, -0.17021795f, -0.28950498f, 0.15115859f, 0.35845807f, 0.15473774f, -0.06195224f, 
    0.01707226f, -0.10955768f, 0.06913023f, 0.13029808f, 0.12014006f, 0.14264117f, -0.05375672f, -0.25180942f, 
    -0.04265782f, 0.23593123f, -0.08588154f, -0.08967932f, 0.10771041f, -0.17550178f, -0.37620002f, -0.02044083f, 
    -0.20995094f, -0.18772960f, -0.00231558f, -0.07171639f, -0.41488546f, 0.15784000f, 0.01522344f, 0.00089830f, 
    0.20854470f, -0.04057592f, -0.03747490f, -0.01977044f, -0.09787334f, -0.11219244f, -0.24014661f, -0.26804611f, 
    0.10956627f, -0.07467404f, 0.11307742f, 0.18270899f, 0.15168969f, 0.08455540f, 0.00380186f, -0.11333326f, 
    -0.05910424f, 0.03351298f, 0.17944238f, 0.21140459f, -0.02329885f, 0.01412322f, 0.05215856f, -0.07772292f, 
    -0.02273578f, -0.01213386f, 0.23045206f, -0.08978329f, 0.00209076f, -0.01958579f, -0.00915181f, 0.19851308f, 
    0.05833589f, -0.05904388f, -0.08010308f, -0.15191557f, 0.08387531f, -0.04249202f, -0.06359676f, 0.19727196f, 
    -0.07670636f, -0.05794323f, 0.00940573f, -0.17834142f, 0.29747450f, -0.05070343f, -0.04647361f, -0.02397450f, 
    -0.07605216f, -0.06489740f, 0.18937567f, -0.13526186f, 0.08294197f, -0.04314983f, -0.01881909f, 0.01528003f, 
    -0.01688360f, 0.18489592f, -0.05847723f, 0.08015574f, -0.04524724f, 0.07532950f, 0.11921385f, -0.01849660f, 
    0.16275997f, 0.09322653f, 0.13005818f, 0.09504176f, -0.01092376f, 0.03020232f, 0.10079242f, -0.21455620f, 
    0.09769937f, 0.04906958f, -0.15487522f, -0.24463956f, -0.01380742f, -0.40502930f, -0.38345328f, -0.55253452f, 
    0.17739522f, 0.19199854f, -0.20712888f, 0.21422666f, -0.01182448f, 0.08741407f, 0.09249837f, -0.01467948f, 
    0.15147343f, 0.07605647f, 0.00125257f, -0.07135579f, -0.11139795f, -0.20292172f, 0.00213056f, -0.03658936f, 
    0.02246561f, -0.00224524f, 0.03657128f, -0.04773799f, -0.17658976f, -0.03016617f, -0.11275275f, -0.22912730f, 
    -0.01066394f, -0.12416872f, 0.11163265f, 0.03585039f, -0.06784713f, -0.03827170f, 0.04405382f, -0.10146608f, 
    -0.06872655f, 0.18498270f, 0.10542407f, 0.28876549f, -0.17065951f, 0.15368059f, -0.29083815f, -0.00716516f, 
    -0.03188187f, -0.21174370f, -0.10003304f, -0.26293370f, -0.23269643f, -0.20305148f, -0.20398647f, -0.40774927f, 
    0.01844831f, -0.06089236f, -0.12410086f, -0.02112723f, -0.02376472f, 0.05958478f, 0.05854284f, 0.10416436f, 
    -0.00977057f, -0.11669599f, -0.13619596f, 0.04693901f, -0.10045327f, -0.26573724f, -0.06957106f, -0.01999061f, 
    0.16182663f, 0.01806791f, 0.16584148f, 0.14776176f, -0.04066096f, 0.04053583f, 0.01189770f, 0.09528531f, 
    0.37244496f, 0.06584325f, 0.08012259f, 0.01408050f, -0.01710447f, 0.18840295f, -0.24304010f, -0.20083991f, 
    0.03734302f, -0.19883311f, -0.09142574f, 0.16617981f, 0.12831034f, -0.00742245f, 0.09022886f, -0.10487362f, 
    -0.09184047f, -0.17416480f, 0.03067493f, 0.09378622f, 0.03224380f, 0.13333111f, 0.01678834f, -0.35176790f, 
    0.06433474f, 0.09456447f, 0.01543561f, 0.07393235f, 0.05088962f, 0.11919979f, 0.07140753f, 0.16107556f, 
    0.07771139f, 0.04984286f, 0.08020772f, 0.16628978f, -0.07950467f, 0.30599773f, -0.16309421f, -0.02357879f, 
    0.00091439f, -0.13474290f, 0.04413391f, 0.19262543f, -0.09480754f, 0.04158740f, -0.23958264f, -0.45722470f, 
    0.12505764f, -0.15380947f, -0.07052884f, -0.06421604f, -0.12320317f, 0.07645629f, 0.08012853f, -0.27185446f, 
    0.21604417f, 0.24018668f, 0.28088382f, 0.35888335f, 0.14222173f, 0.12454654f, -0.12712543f, -0.05520371f, 
    -0.08447809f, -0.04430142f, 0.01816612f, -0.20391943f, -0.00598645f, -0.05590387f, -0.01346215f, -0.12496545f, 
    0.37149882f, 0.06656983f, 0.19206491f, 0.27210557f, -0.10051838f, -0.01434829f, 0.10148307f, 0.05532278f, 
    -0.02520181f, 0.01555887f, -0.05670433f, 0.15428892f, -0.29416937f, 0.16893248f, -0.11487829f, 0.13010351f, 
    -0.12073828f, -0.02559258f, 0.04408979f, 0.04500604f, 0.15820605f, -0.03852288f, 0.08775019f, -0.04626819f, 
    0.03678935f, 0.68215495f, -0.24042515f, -0.33725792f, 0.15779883f, 0.04897639f, 0.35611632f, 0.10921965f, 
    -0.01037518f, 0.06528474f, -0.03799108f, 0.13432688f, 0.44948056f, -0.11162756f, -0.40193549f, -0.13361809f, 
    -0.04256717f, 0.01101104f, -0.06343688f, -0.14806822f, -0.11176174f, 0.03121562f, 0.14991745f, -0.12024464f, 
    -0.04879954f, 0.01666150f, 0.07785286f, -0.02478747f, -0.01415629f, -0.03077975f, -0.08624283f, 0.12266254f, 
    0.12966990f, 0.12890509f, -0.04060171f, 0.09683149f, 0.06884865f, 0.01458752f, 0.15659049f, 0.15917616f, 
    -0.01953925f, -0.08175486f, -0.12767005f, -0.02517854f, 0.20089385f, 0.11523823f, 0.18498217f, -0.04677609f, 
    -0.08958949f, -0.06412605f, 0.12052909f, 0.10679373f, -0.02469892f, -0.01202756f, -0.19439359f, -0.04485742f, 
    -0.02772693f, -0.12781531f, -0.09514632f, -0.15242457f, -0.19742192f, -0.39493513f, 0.14262243f, 0.28320915f, 
    -0.02832252f, -0.03369739f, 0.02022654f, 0.07929911f, -0.27764744f, 0.02280209f, -0.14932764f, 0.17893153f, 
    0.10553589f, 0.34677893f, -0.26105931f, -0.21559118f, 0.14527860f, 0.14495884f, 0.12181951f, 0.03096591f, 
    -0.00443493f, 0.03447127f, -0.10711864f, 0.03124892f, -0.08468805f, 0.07142373f, 0.06004938f, 0.08920304f, 
    -0.05791904f, -0.10933467f, -0.15360461f, -0.04364189f, -0.03306425f, 0.09081545f, 0.05798081f, 0.03196421f, 
    0.46476647f, 0.25785547f, 0.03011397f, 0.29759449f, -0.07474730f, -0.13494068f, -0.10188802f, 0.01561554f, 
    0.01640690f, -0.02409503f, -0.06317105f, -0.11614112f, 0.22264381f, 0.03036497f, -0.07932543f, 0.14869282f, 
    0.32316381f, 0.30462581f, 0.18345885f, 0.30418500f, 0.07555649f, 0.17404531f, 0.06133500f, 0.03726491f, 
    0.18098360f, -0.05182180f, -0.05512781f, -0.06086968f, -0.04863954f, 0.07703850f, 0.03231571f, -0.16589755f, 
    -0.10126630f, -0.11276770f, 0.06225867f, -0.14186408f, 0.48875231f, -0.12930672f, 0.01088936f, 0.43235800f, 
    0.05059946f, 0.06420464f, -0.15537691f, -0.02090746f, 0.02479960f, -0.05539208f, 0.03881420f, -0.09723235f, 
    0.16881654f, 0.06250492f, 0.16916476f, 0.23823947f, -0.03107670f, -0.02958598f, 0.02448458f, 0.11095282f, 
    -0.08930103f, -0.02473823f, 0.01397083f, -0.06607109f, 0.21255624f, 0.12558095f, -0.23960042f, 0.01071162f, 
    -0.11132768f, 0.08529875f, -0.07981058f, 0.11415491f, -0.04913895f, -0.08715785f, 0.09266947f, -0.12606364f, 
    0.24667823f, 0.34726229f, 0.26611659f, 0.16599600f, 0.08554960f, 0.24533117f, 0.20227994f, 0.21383157f, 
    -0.05697211f, -0.09103713f, -0.14245793f, 0.00829873f, 0.21464621f, 0.13949656f, 0.38712043f, -0.22058626f, 
    0.01184912f, -0.11659972f, -0.04494850f, 0.01786291f, -0.13374183f, 0.17980506f, -0.19122861f, 0.18036860f, 
    0.33624387f, 0.21040823f, 0.13579088f, 0.11713403f, 0.00550513f, 0.12307857f, -0.09600568f, 0.15754376f, 
    -0.03141164f, 0.02054655f, -0.02480012f, 0.01201483f, -0.02724185f, 0.00786104f, 0.21161948f, 0.00096282f, 
    0.00135414f, 0.14870034f, 0.18134159f, 0.23573473f, 0.08737034f, 0.01238999f, 0.23121519f, 0.03023234f, 
    -0.14070614f, 0.03331016f, 0.25608051f, 0.11361824f, 0.04945165f, -0.05416998f, -0.03685169f, 0.14985088f, 
    0.05786352f, 0.03190587f, 0.08612772f, 0.12354936f, -0.23563452f, 0.38516760f, 0.18244267f, -0.15637663f, 
    0.01376281f, -0.09074518f, -0.02085910f, -0.04236791f, -0.01529431f, 0.00251122f, 0.09535753f, 0.14629248f, 
    0.00212185f, 0.43880710f, 0.01492110f, 0.21024708f, -0.06628101f, -0.13352241f, -0.04565311f, -0.07011548f, 
    0.03021595f, 0.16009121f, 0.19066836f, -0.08601013f, -0.08869898f, -0.16479832f, -0.08666919f, 0.20815094f, 
    -0.06402793f, 0.03939750f, 0.08167280f, -0.21719071f, 0.00307678f, -0.10053933f, -0.01424849f, 0.22797365f, 
    0.37748286f, 0.22041979f, 0.20477486f, 0.09047431f, 0.20248063f, 0.13665482f, -0.10466446f, 0.02704717f, 
    0.05260782f, 0.02383032f, -0.04409217f, 0.04553306f, 0.42059654f, 0.29531205f, 0.11724713f, 0.21880597f, 
    0.07024843f, 0.01015273f, 0.15261358f, -0.00695265f, -0.02310803f, 0.01326710f, 0.00087820f, -0.04945305f, 
    0.38049793f, 0.07536423f, 0.35710427f, -0.00978813f, -0.00300102f, 0.13022278f, 0.16361755f, -0.00261124f, 
    0.03223465f, 0.23934467f, 0.02098416f, 0.00056465f, -0.08393192f, -0.01899116f, -0.15463264f, -0.09909789f, 
    -0.11708049f, 0.06754546f, -0.07597197f, -0.15629406f, -0.05258778f, -0.07648224f, 0.18167441f, 0.05320231f, 
    0.24786125f, 0.23058483f, 0.01529052f, 0.19717209f, 0.20131151f, 0.06993628f, 0.09274971f, -0.03447211f, 
    -0.03273310f, 0.06159052f, -0.11038590f, -0.05555612f, -0.04855150f, -0.14281541f, 0.15285255f, 0.13124579f, 
    0.11306965f, 0.12994532f, -0.12751864f, 0.08336271f, -0.00100206f, 0.01638751f, 0.21132155f, 0.07413204f, 
    -0.07778701f, 0.24874020f, 0.21597362f, 0.04266885f, -0.11507469f, -0.11827985f, -0.13875879f, -0.09549804f, 
    0.15706421f, -0.03544027f, -0.02164375f, 0.04278331f, 0.04869566f, 0.13592036f, -0.17136160f, 0.11507883f, 
    -0.02752157f, -0.09242194f, -0.01973345f, -0.12771147f, -0.14408949f, 0.01091304f, -0.00478999f, 0.21584526f, 
    0.15220205f, -0.46105745f, -0.41274658f, -0.14615349f, 0.24893425f, 0.02115463f, 0.18385057f, -0.20649986f, 
    0.21636683f, 0.17514828f, 0.00595901f, 0.02367334f, 0.07466458f, -0.26039156f, 0.31710425f, 0.25902310f, 
    -0.03081922f, -0.24023923f, -0.12984727f, -0.10212176f, 0.00789193f, -0.04105273f, 0.01551669f, -0.01111297f, 
    -0.25347325f, 0.35232130f, 0.02461400f, 0.21219702f, 0.04656228f, 0.00425043f, 0.07041676f, 0.01640437f, 
    -0.14147604f, 0.07256728f, -0.05201474f, -0.07953911f, 0.57699561f, 0.01684211f, -0.26299539f, 0.15448704f, 
    0.19897179f, 0.00350342f, -0.04044387f, 0.17352296f, 0.04571297f, 0.21758334f, 0.07168405f, 0.03130257f, 
    0.04435154f, 0.10377432f, 0.02287845f, 0.13958795f, -0.00412225f, 0.05226322f, -0.15893023f, -0.01639172f, 
    0.13324125f, 0.01974272f, 0.22831643f, 0.11361623f, -0.01038318f, 0.22843125f, -0.17077208f, 0.14582318f, 
    0.12178021f, 0.11303455f, 0.19124728f, 0.30942714f, 0.30558151f, 0.14842655f, 0.18767406f, -0.05060592f, 
    0.09281394f, -0.05942377f, -0.04882068f, 0.03853443f, -0.05697050f, 0.10151319f, -0.03782537f, -0.06442270f, 
    0.32546422f, -0.09679841f, 0.18133520f, 0.10348102f, -0.06269068f, -0.33595034f, 0.31039608f, 0.01525915f, 
    0.04296835f, 0.02713050f, 0.04635552f, 0.01638567f, -0.04326244f, 0.14579619f, 0.11742524f, 0.00452440f, 
    0.16177349f, -0.16669071f, 0.17864572f, -0.15800376f, 0.16850173f, 0.10550489f, -0.04763319f, 0.06506202f, 
    0.05579313f, 0.22387587f, 0.14568581f, 0.11275307f, -0.07979678f, -0.03413066f, -0.14415644f, -0.06630449f, 
    0.15363503f, -0.01571977f, -0.11043525f, -0.05514548f, -0.10037981f, -0.09394177f, -0.01354755f, -0.00016923f, 
    0.16396607f, 0.08166487f, 0.34050369f, -0.15860128f, 0.21346571f, -0.05063272f, -0.10738599f, 0.14849548f, 
    -0.07511800f, -0.05585548f, -0.08755223f, -0.14381960f, 0.21634492f, -0.12434199f, 0.17928477f, 0.23901610f, 
    0.11141118f, -0.01555618f, -0.05615263f, 0.08920346f, 0.04194784f, 0.04855644f, -0.07159151f, -0.17478386f, 
    -0.02984015f, 0.08325496f, -0.15567142f, -0.29437497f, 0.01637231f, 0.01161598f, -0.30481538f, -0.06205629f, 
    -0.14510426f, 0.00054053f, 0.01777280f, -0.06535060f, -0.25070709f, 0.08430105f, -0.12701610f, 0.01423553f, 
    0.23377801f, -0.08125608f, -0.15017132f, -0.03312377f, 0.04227600f, -0.00563884f, -0.02601313f, -0.19692768f, 
    0.17924431f, -0.06392645f, 0.15980719f, 0.29090333f, 0.06204216f, -0.02904284f, -0.09553618f, 0.05757444f, 
    -0.07665332f, 0.06534014f, 0.18842927f, 0.06034897f, -0.27128685f, 0.23286763f, -0.10760652f, -0.02185427f, 
    -0.06722271f, -0.05023728f, 0.12677930f, -0.05444456f, -0.23170917f, -0.07129318f, 0.08164410f, 0.13867806f, 
    -0.18389246f, -0.02044793f, 0.23312990f, 0.29722977f, 0.02730361f, -0.02287600f, -0.07784700f, 0.07601205f, 
    0.02545574f, -0.03209398f, -0.16872890f, -0.02320085f, 0.72333807f, -0.10877249f, -0.30200928f, 0.01776424f, 
    -0.03050445f, -0.09762751f, 0.02221370f, -0.06231159f, -0.01828231f, 0.06810129f, -0.24208504f, -0.03581064f, 
    0.06596904f, 0.08692984f, 0.20416948f, 0.09256592f, -0.02638942f, -0.03148001f, 0.03829212f, -0.14804322f, 
    0.14539668f, -0.11624066f, 0.17533700f, 0.11495509f, 0.15314946f, 0.16752897f, 0.13596353f, 0.41421410f, 
    0.13268064f, 0.00519670f, -0.00638168f, -0.02313972f, 0.21138257f, -0.35212624f, -0.20661104f, -0.17984557f, 
    -0.12295477f, 0.20302965f, 0.11311504f, 0.46892229f, 0.02457321f, 0.01838117f, 0.06263437f, 0.00464072f, 
    0.13076517f, -0.04469253f, 0.07883440f, 0.07072015f, -0.02449649f, -0.12907210f, 0.24401881f, -0.05439499f, 
    -0.08901580f, -0.03414622f, -0.05692140f, 0.06364364f, -0.13125940f, 0.14069986f, -0.09391245f, 0.05245691f, 
    -0.17940003f, 0.02335662f, -0.28141409f, 0.18881084f, 0.12467488f, -0.12388624f, 0.27698654f, 0.05750238f, 
    -0.08076124f, 0.18902977f, 0.07542796f, 0.18239479f, -0.26515585f, -0.21880016f, -0.17675756f, -0.01845928f, 
    -0.04445371f, 0.03922521f, -0.17940234f, -0.26212755f, -0.04670819f, 0.00025049f, -0.14251909f, -0.17248058f, 
    -0.25830781f, -0.02412680f, -0.15444797f, 0.08522372f, 0.00643170f, 0.02941853f, 0.03834813f, -0.01554934f, 
    0.04298785f, -0.17871337f, -0.11080374f, 0.07268789f, -0.22572617f, -0.03333045f, -0.10603907f, 0.02544461f, 
    0.12224682f, -0.13394013f, -0.01158863f, 0.20220837f, -0.20260854f, -0.02151334f, 0.15751633f, 0.09413017f, 
    0.45913479f, -0.13734345f, -0.01532336f, 0.20768113f, 0.01627141f, 0.02792155f, -0.09077808f, -0.15409744f, 
    0.15095694f, -0.04842135f, -0.15937483f, 0.04922606f, 0.12166625f, -0.21597499f, -0.20643905f, -0.14422955f, 
    -0.06543646f, -0.12598947f, -0.00869123f, 0.19621503f, -0.07291628f, 0.01631366f, -0.03537945f, -0.19123361f, 
    -0.20440559f, 0.07705422f, 0.02808934f, 0.05580586f, 0.01251763f, -0.00302824f, 0.01167913f, 0.12612644f, 
    0.09046323f, 0.03805317f, 0.07250485f, -0.06510317f, -0.12005040f, 0.26320067f, 0.26177186f, 0.21019523f, 
    0.06579706f, 0.14464457f, -0.09025556f, 0.05872806f, -0.08040563f, 0.02667157f, 0.01697217f, -0.31615135f, 
    0.07202736f, -0.05891517f, -0.04370483f, -0.08128013f, -0.16150717f, 0.12801515f, 0.01073783f, -0.15777473f, 
    0.32081181f, 0.21252805f, 0.22930431f, 0.23914069f, 0.00904471f, 0.14415738f, -0.31218958f, -0.28542310f, 
    0.13284457f, -0.06751557f, -0.21646343f, 0.00464873f, -0.01954498f, -0.15941049f, 0.02568116f, 0.10210423f, 
    0.00090813f, -0.36100522f, -0.05479732f, 0.16054033f, -0.00931496f, -0.03948116f, -0.00155508f, -0.01815433f, 
    0.10548077f, 0.01476838f, -0.05629575f, 0.11895377f, 0.52434391f, -0.00336659f, -0.12028355f, 0.06886951f, 
    -0.12198397f, -0.01909396f, -0.23853388f, 0.01934497f, 0.09514818f, -0.00769914f, 0.13277441f, 0.03225539f, 
    -0.11719399f, -0.41088411f, 0.16531737f, 0.43038669f, 0.09561221f, 0.06885131f, 0.11264572f, -0.12815738f, 
    0.07382224f, 0.07068588f, 0.04346378f, -0.03124138f, -0.17701045f, 0.06527281f, -0.04110382f, 0.24042296f, 
    -0.00222953f, -0.20033917f, 0.01919213f, 0.08355489f, 0.17819285f, 0.19389319f, -0.03149331f, 0.27099606f, 
    0.15816286f, 0.06590736f, -0.00714121f, 0.08291446f, 0.10352979f, 0.03439738f, 0.07571231f, -0.15667883f, 
    0.24662243f, -0.01949809f, 0.19153164f, 0.20372456f, 0.23254366f, 0.19516523f, -0.13683502f, -0.30358067f, 
    0.06328949f, 0.00606730f, -0.00930866f, -0.02841388f, -0.05073948f, 0.07088774f, 0.04387464f, 0.19311963f, 
    0.13122302f, 0.04548790f, -0.00385107f, -0.14001119f, -0.03513010f, 0.00131533f, -0.04905336f, -0.04150636f, 
    0.02664859f, 0.06083052f, 0.27355704f, 0.34111425f, 0.36582127f, 0.06980430f, 0.06170257f, -0.05283811f, 
    -0.11877695f, 0.05098174f, 0.07874587f, 0.02467674f, 0.16161917f, 0.02572341f, 0.22580373f, 0.15735041f, 
    -0.06728110f, -0.34724775f, 0.13891020f, 0.29098588f, 0.02133575f, 0.02196914f, -0.05451015f, 0.11595964f, 
    0.10199634f, 0.12259058f, 0.26272279f, 0.09037808f, 0.20933671f, 0.02154115f, -0.10757315f, 0.07604349f, 
    0.06188545f, 0.06153315f, 0.04042563f, -0.01738502f, -0.02917434f, -0.08141967f, -0.09888528f, -0.04662754f, 
    0.13783604f, 0.16689497f, -0.11021446f, -0.31696582f, 0.01996166f, 0.01154562f, 0.03348622f, 0.05531857f, 
    -0.08137761f, -0.06187758f, -0.08701082f, -0.02349014f, -0.18330483f, -0.06554720f, 0.12522298f, -0.03915021f, 
    -0.18913461f, -0.21161707f, -0.13492481f, -0.25047907f, 0.07123311f, -0.04254563f, -0.04597574f, -0.03439991f, 
    -0.08013041f, -0.03350113f, -0.02766609f, -0.05210975f, 0.03023761f, -0.06259641f, -0.05374519f, 0.13589291f, 
    -0.12719181f, 0.03920890f, -0.10036508f, -0.00703472f, 0.38179019f, 0.14467667f, -0.13070783f, -0.46948934f, 
    -0.04749191f, -0.04968593f, 0.05414206f, -0.04312350f, -0.10980713f, 0.02146910f, -0.14013396f, -0.12176604f, 
    -0.10822963f, -0.00902209f, 0.14149420f, -0.09924670f, 0.03413580f, 0.02946971f, 0.00652031f, -0.00401410f, 
    0.08893865f, 0.02281216f, 0.19428559f, 0.14239396f, -0.18011633f, 0.06535390f, 0.21846652f, -0.09538382f, 
    0.08447212f, 0.07713447f, 0.05429316f, 0.00021420f, 0.04737251f, 0.12677695f, 0.16939943f, 0.33005562f, 
    -0.10543337f, 0.00724793f, 0.09190286f, -0.03435504f, -0.08707681f, -0.12411601f, -0.06949029f, -0.24258392f, 
    -0.06442171f, -0.06649461f, -0.09997877f, -0.09636062f, -0.20150308f, -0.19059205f, -0.12992111f, 0.39878157f, 
    0.27294534f, 0.10316300f, 0.11749788f, 0.09167121f, -0.05253153f, 0.08649526f, 0.04122500f, -0.09036635f, 
    -0.14887895f, -0.14980337f, 0.01631027f, 0.00674727f, 0.14858642f, -0.05035281f, 0.04789161f, -0.17903316f, 
    0.02825829f, 0.04893647f, 0.12052786f, 0.11672881f, -0.24588194f, 0.05952581f, -0.13670804f, 0.16391799f, 
    0.03275047f, -0.08365254f, 0.08704994f, -0.18975045f, 0.05907085f, -0.17346962f, -0.10356553f, 0.02326901f, 
    0.06903777f, -0.00958169f, -0.01540359f, 0.06102633f, 0.10224641f, 0.05747984f, -0.05843842f, -0.20088866f, 
    0.19139236f, -0.06987812f, -0.07010362f, 0.01402172f, 0.25096777f, 0.02184390f, 0.04946246f, 0.08716989f, 
    0.09303629f, 0.12400795f, 0.05351099f, 0.08241275f, -0.10918447f, -0.02837594f, 0.01904679f, 0.01270958f, 
    0.04378486f, -0.14637840f, -0.41242498f, 0.03632206f, 0.05636056f, -0.03513205f, -0.00506697f, 0.03009961f, 
    0.04238752f, 0.11195862f, 0.04168923f, 0.14124896f, 0.25378776f, -0.12097882f, -0.02817770f, -0.06229378f, 
    -0.00874724f, 0.14721259f, -0.06047476f, 0.22585087f, -0.14871408f, -0.12693046f, 0.08171595f, -0.22072937f, 
    -0.05779964f, 0.08314065f, 0.29217437f, 0.03154061f, -0.16432905f, -0.00483212f, 0.17143404f, -0.14660868f, 
    -0.03702848f, -0.06544966f, 0.00138171f, -0.10773425f, -0.15825830f, 0.13407597f, 0.33419600f, -0.23032171f, 
    -0.16697778f, 0.22173679f, 0.15577589f, -0.05407565f, -0.02945121f, 0.04661485f, 0.04883996f, 0.02823471f, 
    -0.36133865f, -0.29278213f, 0.12485860f, 0.02314324f, 0.05581525f, -0.04914028f, -0.00150897f, -0.00307233f, 
    0.08128981f, -0.23879454f, 0.05883975f, -0.00651579f, -0.07803240f, -0.00110880f, 0.03934666f, -0.07546255f, 
    -0.05344148f, 0.07155483f, -0.06045753f, 0.13747247f, 0.16734861f, 0.20348270f, 0.00001889f, -0.06110825f, 
    -0.13095066f, 0.01852529f, 0.20674399f, -0.12934281f, -0.14402887f, -0.03120797f, -0.01687597f, 0.02121242f, 
    0.02165378f, 0.04729205f, 0.07914087f, -0.04089017f, 0.11565638f, -0.00217569f, 0.18430504f, -0.28039125f, 
    -0.05695360f, -0.12459568f, 0.03389858f, -0.06612788f, 0.01776105f, -0.00778670f, -0.21633489f, -0.09508558f, 
    0.19208454f, -0.08385298f, -0.09671486f, 0.03858131f, 0.01868430f, -0.00574858f, -0.06802064f, 0.02807151f, 
    -0.04282345f, 0.10235234f, 0.27169028f, 0.12501439f, -0.02569915f, -0.07019085f, -0.04206630f, 0.04660140f, 
    0.05637433f, -0.03998819f, 0.04773181f, 0.02062471f, 0.17066567f, 0.07976066f, 0.19933324f, 0.05078415f, 
    -0.19945921f, 0.39789826f, 0.35871425f, 0.13289398f, -0.13929932f, -0.10545567f, -0.01087227f, 0.05707260f, 
    -0.10075285f, 0.00470886f, -0.02628889f, 0.04074822f, 0.39159670f, -0.27156413f, 0.19485080f, -0.26158345f, 
    0.07278673f, 0.08823951f, -0.06905314f, 0.24309805f, -0.06015481f, 0.02428283f, 0.03166606f, -0.02441997f, 
    -0.00809020f, -0.02774852f, -0.02899115f, -0.01834193f, 0.01507588f, 0.00326656f, 0.04389934f, -0.04832853f, 
    -0.02339011f, 0.02903538f, 0.00149805f, -0.03497347f, -0.04625104f, 0.00369241f, -0.05342227f, -0.04804484f, 
    -0.02470491f, -0.03573419f, -0.02483335f, -0.05609887f, 0.02418682f, -0.02438818f, -0.01016013f, 0.00617948f, 
    0.01802872f, 0.00270522f, 0.03757374f, -0.02994159f, -0.00607566f, 0.03962500f, -0.02641922f, -0.03286741f, 
    0.02929222f, -0.04991186f, 0.00839457f, -0.01691900f, -0.01915623f, -0.01516616f, 0.03234270f, -0.03110926f, 
    -0.03664069f, 0.00800116f, 0.01236608f, 0.01612076f, -0.01879486f, 0.04274420f, -0.04912305f, -0.02755158f, 
    0.02464946f, 0.03481711f, -0.04885076f, -0.04341739f, -0.05332292f, -0.03636594f, -0.03032578f, 0.01755980f, 
    -0.03421495f, -0.05651930f, 0.03594587f, -0.01643799f, 0.03767896f, 0.00192094f, 0.03001553f, 0.00259399f, 
    -0.04440987f, 0.01145379f, 0.03106979f, 0.00362287f, 0.02173055f, -0.01139397f, -0.04946901f, 0.02115255f, 
    -0.00524110f, 0.00330216f, 0.03942621f, 0.01749501f, -0.01162772f, 0.00886169f, 0.01977456f, -0.01690152f, 
    -0.04922282f, -0.03951474f, -0.01004923f, 0.02253404f, -0.00351639f, 0.00716157f, -0.04024313f, -0.04077107f, 
    0.01117045f, 0.02987041f, 0.00377795f, 0.02706495f, 0.03065492f, 0.02711664f, 0.02790804f, -0.02350193f, 
    -0.03315613f, -0.03356542f, -0.03948643f, 0.03349251f, 0.02780686f, -0.04527915f, 0.03934763f, -0.00429194f, 
    -0.03764192f, -0.02934611f, -0.00165273f, 0.00565189f, -0.00521544f, -0.05078405f, -0.02443573f, -0.03917972f, 
    0.01200083f, -0.00947984f, 0.03802374f, 0.00014838f, -0.04855224f, -0.02771664f, 0.02146236f, 0.00425813f, 
    -0.03085923f, 0.04339307f, 0.01756167f, -0.02969085f, -0.03960124f, -0.04300112f, -0.02381812f, -0.01219857f, 
    -0.00903595f, 0.02044924f, 0.00866409f, 0.04276723f, 0.03338594f, 0.01591483f, 0.01509333f, -0.04015077f, 
    0.03503058f, 0.03589024f, 0.00479848f, -0.03899567f, -0.02549334f, 0.03745843f, -0.01748534f, 0.02127209f, 
    0.04126463f, 0.00383073f, 0.02210984f, 0.00528931f, -0.04652470f, 0.00188566f, -0.02849476f, 0.02399199f, 
    -0.04497881f, -0.03533135f, 0.00806448f, -0.01360735f, -0.04287971f, 0.00321791f, -0.04739204f, -0.00934467f, 
    -0.04618426f, -0.02377212f, -0.00239582f, -0.03497776f, 0.01761779f, -0.05573355f, -0.05293735f, -0.01534171f, 
    0.00238842f, 0.04132298f, -0.01952698f, -0.01821383f, -0.01601750f, -0.01873631f, 0.01984677f, -0.05697583f, 
    0.03975756f, -0.03884939f, 0.01531826f, -0.03226465f, -0.03427325f, -0.00443655f, -0.00673784f, 0.00412224f, 
    0.00493570f, 0.01443505f, 0.01477882f, 0.02988518f, 0.01359778f, 0.02486191f, 0.01014505f, 0.00347778f, 
    0.02719836f, -0.03677628f, 0.01202731f, 0.04495777f, -0.01702092f, 0.02391473f, -0.00990886f, 0.01105817f, 
    0.02973658f, -0.02408339f, 0.04212657f, 0.03561502f, 0.00104988f, 0.00825821f, -0.03133731f, -0.00965193f, 
    0.01766418f, 0.04434920f, -0.02055509f, -0.04570234f, -0.01817131f, 0.04978287f, 0.01241085f, -0.03035723f, 
    -0.00934007f, 0.01531202f, -0.00651602f, -0.03087204f, -0.05344448f, -0.01476054f, -0.02902195f, -0.01541451f, 
    -0.00812132f, -0.04703450f, -0.04496144f, 0.00170907f, -0.04928135f, 0.01810353f, 0.03282247f, -0.04308578f, 
    -0.04007836f, -0.00604871f, 0.02967335f, -0.04449791f, -0.04984581f, 0.01737540f, -0.02647742f, 0.02370306f, 
    0.04137072f, -0.04551126f, -0.02386953f, -0.01479100f, -0.01418054f, 0.04240018f, 0.00625730f, -0.05322970f, 
    -0.04997693f, -0.05156750f, -0.04345486f, -0.00251211f, -0.04965150f, 0.04939242f, -0.02109644f, -0.00986299f, 
    -0.02689672f, 0.02467695f, -0.00150880f, 0.04900479f, 0.00696468f, 0.02759616f, 0.02766760f, -0.03451265f, 
    0.03203631f, -0.02237516f, -0.03956119f, 0.03295004f, 0.02212303f, 0.02155248f, -0.05601439f, -0.02345125f, 
    -0.05058859f, -0.05043989f, 0.02513743f, -0.03287571f, 0.00404513f, 0.02726620f, -0.00107712f, 0.00441160f, 
    -0.00181223f, 0.01580591f, -0.00881834f, -0.05639907f, -0.02033592f, 0.03385145f, 0.00745228f, -0.01916157f, 
    -0.03446402f, -0.02099847f, -0.02649864f, 0.03615122f, -0.00163757f, 0.02433392f, -0.03134334f, -0.02438877f, 
    0.04396566f, 0.02672384f, 0.01526329f, -0.03841279f, -0.01024294f, 0.01743996f, 0.02537652f, -0.03821656f, 
    -0.03920806f, -0.00984707f, -0.05203264f, 0.01355036f, -0.03426957f, -0.04445072f, -0.05002505f, 0.00976800f, 
    -0.00503411f, 0.04428393f, 0.02050292f, -0.02341940f, -0.05576643f, -0.00329535f, -0.02629590f, -0.01091706f, 
    0.01100792f, -0.02861473f, 0.01430549f, 0.02896847f, 0.02356530f, -0.04166145f, -0.01029102f, -0.01554126f, 
    -0.00297343f, -0.04965132f, -0.00080267f, 0.01643528f, -0.04314949f, 0.01840250f, -0.04999613f, -0.02530202f, 
    -0.00600504f, 0.02978155f, 0.02803669f, -0.01999540f, -0.01843065f, -0.03496920f, -0.02812167f, -0.00280301f, 
    -0.04180560f, -0.05675709f, -0.02620203f, -0.02797782f, -0.04252533f, 0.04160321f, 0.04214259f, -0.05334880f, 
    -0.02882004f, -0.00728127f, 0.00460631f, -0.04290067f, -0.02990535f, 0.04021486f, -0.03932707f, -0.01149601f, 
    0.01344530f, 0.04178344f, -0.05497870f, -0.01577648f, -0.04068867f, 0.01533987f, 0.01283656f, 0.01541413f, 
    -0.00401936f, -0.03293881f, 0.01280710f, 0.02275919f, 0.02967712f, -0.00217433f, -0.02059793f, -0.04197484f, 
    0.01784037f, 0.01821233f, -0.05277449f, 0.02038149f, -0.04784471f, 0.03622155f, -0.05268352f, -0.00387994f, 
    -0.19684318f, 0.18409359f, 0.34525669f, 0.03952964f, 0.01234055f, 0.19311270f, -0.13527931f, 0.06276476f, 
    0.01766825f, -0.02091592f, -0.03425981f, 0.06344127f, -0.27185744f, -0.14137085f, 0.05076625f, -0.01591915f, 
    0.00710774f, 0.02949470f, -0.06279825f, -0.12378217f, -0.13186516f, 0.02622135f, 0.11162975f, 0.07437185f, 
    0.20882250f, 0.08774222f, 0.07986563f, -0.01953206f, -0.04925190f, -0.09966791f, -0.09147617f, -0.03877103f, 
    -0.07786587f, -0.03125184f, -0.02782478f, -0.05818533f, -0.22776878f, -0.20704272f, -0.16670427f, -0.02472798f, 
    0.00920332f, 0.01210110f, 0.11063999f, 0.07229296f, 0.03344786f, 0.08483507f, -0.07681930f, -0.07456671f, 
    -0.06559864f, -0.14274926f, -0.20222759f, -0.11030940f, 0.02742467f, 0.00484777f, 0.01992258f, -0.00126525f, 
    0.15624475f, 0.00139553f, -0.14251833f, -0.01156225f, -0.09364869f, -0.35966957f, 0.11362602f, -0.16096386f, 
    -0.03664248f, -0.07789261f, -0.02294451f, -0.01770044f, 0.05673568f, -0.01461615f, 0.03191400f, -0.02119802f, 
    0.09708029f, 0.07918757f, 0.40594342f, -0.00495765f, 0.04134227f, 0.06510065f, -0.03363212f, -0.04095189f, 
    -0.04794714f, -0.08467896f, -0.11807327f, 0.01707034f, -0.17814516f, -0.18054074f, -0.20675871f, -0.06364533f, 
    0.12289129f, 0.06794930f, 0.06130753f, 0.01253779f, 0.13454027f, 0.04542143f, 0.09737589f, 0.07154952f, 
    -0.12033314f, -0.51545542f, -0.11286368f, -0.09228133f, 0.02194146f, -0.06058333f, -0.01241649f, 0.04810276f, 
    0.06693266f, -0.05666647f, 0.03049035f, 0.00426773f, 0.60150647f, 0.58558565f, 0.40437466f, 0.33129752f, 
    0.22498356f, 0.16950223f, 0.03742225f, 0.29649514f, 0.02580220f, 0.00826219f, 0.07084687f, 0.03415674f, 
    -0.21258348f, -0.13262235f, -0.00246328f, 0.02018653f, 0.04669254f, -0.01067608f, -0.04236524f, -0.00226202f, 
    -0.11298205f, 0.02413318f, 0.01041372f, 0.03614696f, -0.27619198f, -0.35329118f, -0.23974849f, -0.05004966f, 
    0.07198770f, -0.05960010f, 0.01216325f, -0.01593509f, 0.14025545f, -0.02353344f, -0.01190438f, -0.01890030f, 
    0.11115519f, 0.00442684f, 0.13817574f, 0.20653780f, 0.07739015f, 0.06487395f, 0.04981901f, 0.06712071f, 
    0.08130184f, -0.00479046f, 0.05453703f, -0.03169218f, 0.19744393f, 0.02267665f, -0.20107771f, -0.07275397f, 
    0.08620200f, -0.04198703f, 0.02705643f, 0.04142333f, 0.01984040f, -0.10665507f, -0.07043639f, -0.05032010f, 
    0.28795731f, 0.30903891f, 0.37371758f, 0.30891144f, 0.04339271f, 0.16735832f, 0.05268277f, -0.00570447f, 
    0.06757080f, 0.07070152f, 0.04735343f, 0.07937382f, -0.54758394f, 0.05792211f, 0.18403193f, -0.13682285f, 
    -0.05277552f, -0.11460590f, -0.11711658f, -0.06702694f, 0.12226201f, -0.02692227f, -0.10882581f, 0.12909776f, 
    0.10394295f, 0.43417272f, 0.14923026f, 0.01890733f, -0.09875602f, -0.02245237f, 0.06257141f, 0.15079261f, 
    0.11082973f, 0.07020981f, -0.06735989f, 0.05405426f, 0.22464015f, 0.03705571f, -0.06142815f, -0.11048962f, 
    0.11441744f, 0.20239943f, 0.05714176f, 0.42330354f, 0.17628941f, -0.00685738f, -0.04395014f, -0.07944988f, 
    0.29169810f, 0.38097563f, -0.01452218f, 0.28077501f, -0.00284859f, -0.07945276f, 0.04280287f, 0.04474801f, 
    -0.05476471f, -0.02691533f, -0.01501132f, -0.04547086f, -0.08433509f, -0.33290803f, -0.04904226f, -0.00368161f, 
    -0.13813253f, -0.03076795f, -0.01494798f, -0.08533915f, 0.06641011f, 0.06277316f, 0.02040477f, 0.00544769f, 
    -0.08500063f, -0.37607777f, -0.07141338f, -0.12249140f, 0.00248779f, -0.04506278f, -0.07725028f, -0.08198369f, 
    -0.07082748f, 0.08879175f, -0.03277918f, 0.08960231f, -0.16176517f, -0.08061872f, -0.00749185f, -0.03255951f, 
    -0.00374725f, -0.16331136f, -0.06038295f, -0.02887030f, 0.11915246f, 0.10289788f, 0.08193135f, 0.15378377f, 
    0.42312723f, 0.45287523f, -0.20713557f, 0.20677978f, 0.01981786f, 0.08423459f, 0.01636057f, 0.04815290f, 
    0.03456504f, -0.03101561f, 0.03635010f, -0.01250115f, 0.31526873f, -0.15506552f, -0.05259872f, 0.33849642f, 
    0.22417714f, -0.09252658f, -0.05866340f, 0.07699299f, 0.01266158f, -0.05680384f, 0.05923289f, 0.13007525f, 
    0.14055862f, 0.38397658f, 0.05472232f, 0.24580880f, -0.02199099f, -0.00995921f, 0.00625069f, 0.03948529f, 
    0.20455973f, 0.11240876f, -0.00036480f, 0.05848064f, -0.00748809f, -0.12021303f, -0.17211971f, -0.04757017f, 
    -0.06303956f, -0.07658307f, 0.00127447f, -0.04616418f, -0.08194721f, -0.03176297f, 0.02925088f, -0.02768977f, 
    0.12367669f, 0.22870028f, 0.07379200f, 0.18529740f, 0.01688670f, 0.10212165f, -0.09054285f, 0.06001088f, 
    0.02833577f, 0.08768467f, 0.00367746f, 0.08547631f, 0.13851781f, 0.24250385f, -0.15966652f, 0.06328818f, 
    0.12733787f, 0.18854408f, 0.17455602f, 0.13575925f, -0.04445721f, 0.01010459f, 0.01851596f, -0.03359769f, 
    -0.18844306f, -0.14528078f, -0.21636444f, -0.10284535f, -0.04201256f, 0.01769044f, 0.00363308f, -0.12168105f, 
    0.17885712f, -0.01939863f, 0.10086360f, 0.04630323f, -0.19666812f, -0.00329178f, -0.07841823f, 0.00436197f, 
    0.00451860f, -0.01517340f, -0.07006445f, -0.00901778f, -0.00276951f, 0.00357368f, 0.04473439f, 0.03424003f, 
    0.25777984f, -0.09645376f, -0.06214723f, 0.01755531f, 0.06532988f, 0.00413691f, -0.02523422f, -0.06849985f, 
    0.05724925f, 0.00850997f, 0.13457379f, 0.14317004f, -0.19803330f, -0.21422347f, -0.59491587f, 0.16380779f, 
    -0.04957103f, -0.11853165f, 0.02794882f, -0.15820885f, 0.03203834f, -0.01383445f, -0.06228213f, 0.00729957f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03048372f, 0.06552796f, 0.13950971f, 0.11156960f, 0.13981093f, 0.12375963f, 0.03366790f, 0.03334769f, 
    -0.03043768f, 0.13835357f, 0.13052204f, -0.10078027f, 0.01336584f, -0.05224642f, 0.02036753f, -0.06718713f, 
    0.03441692f, 0.08419715f, 0.15548420f, -0.00729635f, -0.02214240f, 0.04056120f, 0.15516792f, 0.00453622f, 
    0.06994348f, 0.07698984f, -0.11913531f, -0.04837276f, -0.10526620f, 0.07919185f, -0.05020714f, -0.02779301f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.75711679f, -0.49901634f, -0.09737966f, -0.40698963f, -0.15986085f, -0.45790312f, -0.17794740f, 0.12391399f, 
    0.30301839f, 0.21913426f, -0.51832926f, 0.32900444f, 0.06137218f, 0.10529876f, 0.11404936f, -0.14544499f, 
    -0.11762844f, -0.54378688f, -0.40985900f, -0.05608074f, -0.17127414f, 0.03002891f, -0.27355844f, 0.28751028f, 
    -0.28089058f, 0.30275142f, 0.35074791f, 0.19475736f, -0.12905884f, -0.37680119f, 0.12165044f, 0.07543083f, 
    0.39682928f, -0.35161579f, -0.20627141f, -0.10577171f, -0.03853906f, 0.14925669f, 0.07790203f, -0.09206085f, 
    0.15462382f, 0.31963596f, -0.12461389f, -0.01911649f, 0.13821718f, 0.00057237f, -0.13213648f, -0.25848445f, 
    -0.15510370f, 0.66943461f, -0.36090764f, 0.03034397f, 0.06055116f, 0.11626890f, 0.27812561f, 0.31103903f, 
    0.10201129f, -0.37147942f, -0.64336395f, 0.08590537f, -0.76999265f, -0.02847743f, -0.06292362f, 0.07726264f, 
    0.32790226f, 0.48293209f, 0.13595156f, -0.13344423f, 0.12564772f, 0.05153971f, -0.10688272f, 0.14952464f, 
    -0.22187780f, 0.14158660f, 0.21505700f, -0.79789203f, -0.05463919f, 0.12916294f, -0.02735671f, -0.06125391f, 
    -0.01851023f, -0.85816908f, -0.20744954f, -0.08141715f, -0.35725278f, 0.17675190f, -0.27843887f, 0.23210746f, 
    0.03785263f, 0.14677814f, -0.07640244f, -0.13426340f, -0.00287986f, 0.17174059f, -0.00002243f, -0.24271108f, 
    0.13929871f, 0.26041588f, -0.26633015f, -0.23741911f, 0.24450926f, 0.12690410f, 0.41522792f, 0.07759713f, 
    -0.17091998f, -0.70128375f, -0.60245514f, -0.18502186f, 0.07268547f, 0.14710030f, 0.14147346f, 0.04355858f, 
    0.07455273f, -0.29487699f, -0.13403770f, -0.16492729f, -0.41688874f, -0.03055158f, -0.35232642f, -0.17616834f, 
    -0.14227837f, -0.02952012f, -0.02251398f, 0.26957712f, 0.30769533f, -0.51954532f, 0.10363583f, 0.18078527f, 
    -0.02484347f, 0.50530869f, -0.50973159f, 0.12913561f, -0.22519830f, -0.23179768f, -0.50114477f, 0.11918537f, 
    0.14480793f, -0.08888679f, -0.02925929f, 0.15056738f, 0.16178274f, -0.08184796f, 0.01168560f, 0.32853842f, 
    -0.04482820f, -0.11726823f, -0.16866572f, -0.12058167f, 0.06677734f, -0.32598653f, -0.27158257f, -0.00418677f, 
    -0.07835801f, 0.16645639f, 0.06420657f, -0.14515841f, 0.28636697f, 0.18131380f, -0.01930319f, 0.14032637f, 
    -0.52667832f, -0.28802425f, -0.22305585f, -0.04934920f, 0.13831811f, -0.47423282f, -0.17014772f, -0.05350081f, 
    0.23114325f, 0.13722481f, 0.53179169f, -0.44438913f, -0.06429418f, -0.04015720f, -0.07249743f, -0.32924235f, 
    0.11727531f, -0.22834495f, 0.31942031f, 0.06435659f, 0.11230755f, -0.21967596f, 0.30197948f, -0.23484387f, 
    -0.22173642f, -0.03630783f, -0.46280390f, 0.06669459f, 0.08581403f, -0.14060742f, 0.10880100f, 0.12765054f, 
    -0.40968430f, 0.18074358f, 0.19043115f, -0.11183085f, -0.03851828f, 0.06106980f, 0.00301152f, 0.06291088f, 
    -0.37533346f, 0.10627980f, -0.04991270f, -0.27908447f, -0.06367385f, -0.02976731f, 0.16049249f, 0.16443788f, 
    0.08332451f, 0.20562182f, 0.17947888f, 0.11934950f, 0.11707918f, -0.18175723f, -0.32010382f, -0.01360298f, 
    0.23927821f, 0.40869990f, 0.17268789f, -0.87620056f, -0.19155987f, 0.46176323f, -0.14126319f, -0.50194889f, 
    0.09308345f, 0.15814546f, 0.10050713f, -0.12883750f, -0.35672316f, -0.07367959f, 0.30182111f, -0.03308553f, 
    0.04116985f, 0.32460186f, -0.01161599f, -0.03415615f, -0.16979177f, 0.06277493f, 0.15491162f, -0.21043406f, 
    -0.06753714f, -0.07613309f, -0.17410639f, 0.11651956f, 0.32644838f, -0.01568689f, -0.08770291f, -0.68663132f, 
    0.26325017f, -0.27292502f, 0.33476779f, 0.11087036f, 0.39934039f, -0.12179938f, -0.01702980f, -0.55190468f, 
    -0.56121731f, -0.15739724f, 0.18802877f, 0.01888737f, 0.34045440f, 0.41659158f, 0.41449067f, 0.15805975f, 
    -0.11087030f, 0.22558758f, -0.59744751f, -0.31614617f, -0.10821912f, 0.14704019f, -0.03116959f, -0.47320339f, 
    -0.04400816f, -0.38158348f, 0.38595739f, -0.09235870f, -0.32082227f, 0.22999360f, -0.17466851f, -0.59372622f, 
    -0.11983864f, -0.07696936f, -0.32536969f, -0.12045986f, -0.16091707f, -0.63279009f, 0.14055763f, -0.18701699f, 
    -0.00385451f, -0.02619953f, 0.37539279f, -0.08200900f, -0.39751408f, -0.07597699f, -0.26305893f, 0.05739773f, 
    -0.28736076f, -0.38801080f, 0.50609088f, 0.43042871f, 0.04945948f, -0.00260867f, -0.09698015f, -0.20480238f, 
    -0.17167583f, -0.11157675f, 0.06209165f, -0.15873417f, 0.21161769f, 0.07817663f, 0.17068262f, 0.46781409f, 
    -0.35852525f, -0.19619796f, 0.39352590f, -0.53840774f, -0.00893484f, -0.11218575f, 0.00381363f, 0.30105814f, 
    0.23393035f, -0.45612100f, -0.06265256f, 0.49338230f, 0.19426134f, 0.00234086f, -0.28373343f, 0.12254152f, 
    -0.32729280f, 0.10572356f, 0.05595292f, 0.66425800f, -0.15412088f, -0.06771686f, 0.04076337f, -0.19854780f, 
    0.10473107f, -0.57043684f, -0.15396327f, -0.16256389f, -0.08206452f, -0.29727530f, 0.03653340f, -0.54043877f, 
    0.48899621f, 0.45164782f, -0.62443244f, 0.00135643f, -0.45018327f, -0.42460164f, 0.05036850f, -0.01304847f, 
    0.29454738f, -0.50433260f, -0.05808507f, 0.21678939f, 0.06033707f, 0.32736474f, 0.22297551f, -0.16854946f, 
    -0.47265196f, -0.34078199f, -0.45307088f, -0.00830994f, 0.06733152f, -0.10399203f, 0.05124279f, 0.43958887f, 
    -0.14333518f, -0.01095403f, -0.05902376f, -0.04383969f, -0.35215673f, 0.00651934f, 0.27348545f, -0.32949114f, 
    -0.29209015f, -0.69650155f, -0.13776644f, -0.01031391f, 0.17228454f, 0.53754848f, 0.07711066f, -0.16956110f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.24951825f, 0.12162895f, -0.04535893f, 0.14836134f, -0.04427529f, -0.06471975f, -0.02104291f, -0.07190194f, 
    0.22612850f, 0.00876560f, -0.02591985f, 0.02024690f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
