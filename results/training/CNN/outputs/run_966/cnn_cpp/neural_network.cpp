#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.71786559f, -0.16702172f, -0.00450941f, -0.57477021f, 0.58419251f, 0.55222881f, 0.07130796f, 0.48005718f, 
    0.48929760f, 0.14429472f, -0.21374603f, 0.11477939f, -0.37076971f, -0.04872497f, 0.10967564f, 0.00573605f, 
    -0.07574410f, 0.13427462f, 0.05273035f, 0.00290534f, -0.14398056f, -0.15374097f, -0.15993302f, -0.16682401f, 
    -0.24642244f, 0.08243968f, -0.97511768f, 0.43737924f, 0.69527900f, -0.39489356f, -0.27891594f, 0.05200485f, 
    0.62007385f, -0.33085608f, 0.00356812f, 0.20092089f, 0.02568129f, -0.04160991f, 0.08176798f, -0.07684390f, 
    -0.16171332f, -0.16607670f, -0.27047879f, -0.11494784f, -0.26933372f, -0.06703741f, 0.12695417f, 0.20905627f, 
    0.08842228f, 0.10063011f, 0.08551172f, -0.16692185f, -0.13308026f, -0.22578728f, 0.38911042f, -0.19165623f, 
    -0.61965537f, -0.17283100f, 0.42528421f, -0.45731753f, 0.15845293f, 0.35354415f, -0.00243303f, -0.04567613f, 
    -0.01461047f, 0.23748326f, 0.14028762f, 0.06344651f, -0.01460878f, 0.15158309f, -0.24545586f, -0.14326189f, 
    -0.25568953f, 0.10766248f, 0.39679170f, -0.36510837f, -0.49808887f, -0.41377899f, -0.35549626f, -0.19434409f, 
    -0.30794585f, -0.33044356f, -0.04069003f, 0.21528047f, 0.32901064f, -0.25352597f, 0.34023345f, -0.21838218f, 
    -0.00818327f, 0.11641528f, 0.22187479f, 0.02136358f, -0.11631937f, -0.31137815f, -0.04326702f, -0.21862867f, 
    -0.19526587f, 0.29675478f, 0.36438513f, -0.13436769f, 0.70476502f, 0.36432055f, 0.29212075f, 0.70204669f, 
    0.54618078f, -0.03196415f, 0.20902061f, 0.12179431f, -0.11994870f, -0.05030423f, -0.20810534f, -0.13633640f, 
    -0.08593752f, 0.08355146f, 0.04445449f, -0.28581914f, -0.09154160f, 0.17551291f, 0.10943287f, 0.12965108f, 
    -0.06295441f, 0.05289145f, -0.21355318f, 0.22209644f, -0.13989334f, 0.40867499f, 0.52006018f, -0.10671978f, 
    -0.28128302f, 0.18003453f, -0.14373212f, 0.38473141f, 0.23787320f, -0.12522991f, 0.20487785f, 0.25053403f, 
    -0.23175322f, -0.14074761f, -0.36070287f, -0.11346157f, -0.11206907f, -0.17854585f, -0.36717749f, -0.24044874f, 
    -0.04780095f, 0.02221010f, 0.19206420f, -0.21341634f, -0.12348431f, 0.10113552f, -0.28286448f, -0.60713673f, 
    -0.60448986f, -0.23600665f, 0.10851409f, -0.08197986f, 0.68175715f, -0.11683427f, 0.01227505f, 0.39873931f, 
    0.21335083f, -0.12481738f, -0.14365534f, 0.06088608f, 0.31736377f, -0.10137571f, 0.23246220f, 0.04081118f, 
    0.08382393f, -0.07014407f, 0.04467142f, -0.04892065f, 0.32888666f, -0.13642074f, 0.20733576f, 0.32105798f, 
    -0.23002020f, 0.45757428f, 0.53713959f, 0.62910128f, 0.42120811f, 0.16237931f, -0.25203753f, 0.11147685f, 
    -0.31319168f, 0.10636362f, 0.16954754f, -0.11868386f, 0.07910506f, -0.06425533f, 0.14853115f, 0.02551928f, 
    -0.13118368f, 0.03858986f, 0.07554162f, 0.12312288f, 0.26648065f, 0.16982949f, 0.02766585f, 0.25767329f, 
    0.44401738f, -0.81868947f, -0.58552545f, -0.06475361f, 0.15493229f, -0.45603436f, 0.51440394f, 0.49965945f, 
    -0.20252588f, 0.29946855f, -0.32440934f, 0.25676408f, -0.42586875f, -0.15445349f, -0.01809108f, 0.21868151f, 
    -0.02516297f, -0.31680968f, 0.16554433f, -0.08316393f, 0.03677328f, -0.04341443f, 0.16930577f, 0.16746601f, 
    0.18697721f, 0.36202309f, 0.52308124f, 0.43121070f, 0.35146961f, 0.12572569f, -0.67897892f, 0.17405954f, 
    -0.55163789f, -0.39135301f, 0.20508169f, 0.33305955f, 0.08692079f, -0.14593625f, 0.04731109f, -0.23951472f, 
    0.02223796f, -0.11730460f, 0.00446904f, -0.14351438f, -0.27092317f, -0.20997147f, -0.08103102f, -0.12317552f, 
    -0.22526589f, -0.14207777f, 0.00303950f, 0.27379948f, 0.43386611f, 0.41299814f, -0.45179945f, -0.00036535f, 
    -0.46584481f, -0.54312080f, -0.15523411f, -0.25747871f, 0.18587457f, -0.08349162f, -0.17987125f, -0.21749227f, 
    0.16211839f, 0.34525049f, -0.26194704f, -0.35925153f, 0.00267878f, -0.16802227f, 0.11626576f, 0.11962894f, 
    0.04726324f, -0.27789232f, 0.12501493f, 0.64489341f, 0.64190125f, -0.31880167f, -0.50958037f, 0.21750753f, 
    0.08109144f, -0.48291025f, -0.08928730f, -0.51298773f, -0.12066566f, 0.10492906f, -0.03170342f, 0.36714801f, 
    0.25981688f, -0.35871273f, 0.02148590f, 0.00754100f, 0.24796888f, 0.22985737f, 0.29128772f, -0.03066139f, 
    -0.12683874f, -0.11325371f, -0.04286553f, -0.17288966f, -0.45551080f, -0.11632913f, 0.48401040f, 0.42672116f, 
    0.25426218f, 0.37902713f, 0.20045051f, 0.28274396f, 0.13702473f, -0.14426076f, 0.08285102f, 0.37043479f, 
    0.20557116f, -0.30857068f, -0.32900104f, -0.29408550f, -0.14300337f, 0.19462968f, 0.29106101f, 0.05377559f, 
    -0.17781700f, -0.30113184f, -0.13909914f, 0.31011698f, -0.14324081f, -0.26941350f, 0.57161772f, -0.17435518f, 
    -0.78248721f, -0.38065612f, 0.17249244f, 0.54200989f, 0.46456271f, 0.37925130f, 0.18399660f, -0.32491663f, 
    0.06566995f, -0.19643329f, -0.36296630f, -0.01644103f, -0.00545076f, -0.02965382f, 0.09164979f, 0.24623406f, 
    0.02622925f, 0.06733089f, -0.31129700f, -0.13952488f, -0.40635189f, 0.26136753f, 0.05494473f, 0.26282892f, 
    -0.52638060f, -0.37129885f, -0.01799810f, -0.34714270f, -0.42080086f, 0.22228561f, 0.00277232f, 0.16257316f, 
    -0.19071373f, -0.10720246f, -0.04706137f, -0.20047341f, -0.27275696f, 0.15940149f, -0.13682127f, -0.08761682f, 
    0.07508466f, 0.25484082f, 0.19051053f, 0.41722625f, -0.08381517f, -0.34661597f, -0.08953241f, -0.17436826f, 
    0.36433500f, -0.55421388f, -0.42640704f, -0.25926852f, 0.02611446f, -0.32410166f, -0.18662128f, -0.20917287f, 
    -0.27361304f, -0.24239829f, -0.11209175f, -0.12650062f, 0.08823154f, 0.03863784f, -0.02158056f, 0.08566540f, 
    -0.04547069f, 0.02419274f, -0.15641546f, 0.20792244f, 0.22491728f, 0.33001465f, 0.20300296f, 0.25361130f, 
    0.65594620f, 0.16264078f, -0.28927162f, 0.23005980f, -0.75549865f, 0.07193431f, -0.15525283f, -0.06512879f, 
    -0.14015374f, 0.12259227f, 0.08743037f, 0.25482899f, 0.13617426f, -0.03149441f, -0.03578257f, 0.34345701f, 
    -0.18004586f, -0.04543754f, -0.19161616f, 0.21343330f, -0.38613728f, 0.00331868f, 0.09488972f, -0.08899277f, 
    -0.13050245f, 0.57042158f, -0.19056727f, 0.37789348f, 0.69684178f, 0.49433914f, -0.04474698f, -0.17299446f, 
    0.06605379f, 0.09962253f, 0.28298461f, 0.31021634f, 0.05342219f, 0.06593066f, -0.12741628f, -0.42160508f, 
    -0.02888549f, -0.06171251f, -0.08683611f, 0.07858945f, -0.14640369f, 0.24966837f, -0.05243191f, 0.12991190f, 
    -0.20130761f, -0.05407135f, 0.35980183f, 0.76643407f, 0.77103013f, -0.12458878f, -0.66367853f, -0.54419458f, 
    -0.33313939f, 0.07813092f, -0.05854998f, 0.06439365f, 0.22030933f, 0.25851572f, -0.31157014f, -0.02994826f, 
    0.01883338f, 0.21403387f, -0.08976372f, -0.14787400f, 0.11425474f, 0.01344728f, -0.16792214f, -0.07404467f, 
    0.05203291f, -0.16845648f, -0.02766715f, -0.45993063f, -0.06895331f, -0.19289953f, -0.15970944f, -0.14887479f, 
    -0.28747997f, 0.47270861f, -0.04072769f, -0.38660035f, -0.40385455f, -0.20635229f, 0.15362816f, -0.29311231f, 
    0.36179730f, 0.01004011f, -0.23417319f, 0.10743599f, 0.01974063f, -0.41321173f, -0.22061454f, 0.31342170f, 
    -0.00733873f, -0.10244921f, -0.02728515f, 0.11239815f, -0.17752576f, 0.34362128f, -0.16729692f, -0.53338015f, 
    -0.12121940f, 0.29337987f, -0.45718962f, -0.41795957f, 0.05008229f, -0.11139710f, -0.18491712f, -0.12424791f, 
    0.26743755f, 0.24668214f, 0.07898744f, -0.10624874f, 0.36143324f, 0.20131017f, -0.03334418f, -0.22013749f, 
    -0.20110786f, 0.02705871f, 0.28733304f, -0.08818886f, 0.23791836f, -0.39937821f, 0.64256310f, -0.01306046f, 
    -0.58916295f, 0.56062400f, -0.51515847f, 0.02008763f, 0.14592537f, -0.48696798f, -0.15842889f, -0.03049990f, 
    0.20312020f, 0.23735857f, 0.02937416f, 0.23521565f, 0.31167462f, -0.07965791f, -0.07121960f, 0.08471479f, 
    -0.07914484f, 0.02688823f, 0.00881030f, 0.10498498f, 0.30252963f, 0.29770800f, -0.70061886f, -0.17057554f, 
    -0.00942982f, 0.33510795f, 0.49743733f, -0.78597665f, -0.05609526f, 0.09523048f, -0.36848152f, 0.15246099f, 
    0.08337399f, 0.08465342f, 0.10457327f, 0.03321303f, 0.05425030f, 0.30702779f, -0.09055461f, 0.01674295f, 
    0.02278268f, 0.23310976f, -0.15796910f, -0.33583421f, -0.06013965f, 0.23239847f, -0.13394909f, -0.23668920f, 
    -0.22088389f, 0.29361033f, -0.29733488f, -0.61408144f, 0.17644820f, -0.80478644f, -0.42119554f, 0.09089047f, 
    0.34258196f, 0.04959345f, -0.06460711f, 0.13905710f, 0.12154904f, -0.01450646f, -0.04279875f, 0.24332282f, 
    -0.01241354f, 0.14177769f, 0.45505038f, 0.19846162f, 0.02851653f, 0.09295891f, -0.05642166f, 0.15648538f, 
    0.41223019f, 0.38782293f, 0.47477129f, 0.02963217f, 0.20946158f, 0.27197021f, 0.32273754f, 0.01263056f, 
    -0.10633400f, -0.29448190f, 0.14560799f, 0.49724725f, -0.05399439f, -0.20647210f, -0.20868154f, 0.08534542f, 
    0.11181362f, 0.05300844f, -0.19030245f, -0.13282894f, 0.03706443f, 0.05080774f, 0.36195940f, 0.13022852f, 
    0.00473946f, 0.49561331f, -0.00006276f, 0.15652572f, 0.54975700f, 0.23844293f, 0.41604036f, 0.30002937f, 
    0.17219330f, 0.28525135f, 0.39678818f, -0.44048369f, -0.16733630f, 0.13659954f, 0.17173585f, -0.23120721f, 
    -0.17615300f, -0.13329257f, 0.00598878f, -0.22499898f, -0.06833234f, -0.15614314f, -0.06651860f, 0.04986458f, 
    0.23960483f, -0.03296793f, -0.68880624f, -0.47930324f, -0.59325862f, -0.10319071f, 0.04845969f, -0.03259055f, 
    -0.27320528f, 0.26820835f, 0.09163285f, 0.05455192f, -0.15891595f, -0.04739826f, 0.17124222f, 0.13091598f, 
    0.06724139f, 0.25561661f, 0.21625689f, 0.35460785f, 0.20186634f, -0.06149885f, -0.23692529f, -0.23812507f, 
    -0.39761037f, -0.01688381f, 0.18418087f, -0.22147271f, -0.51283032f, 0.39281380f, 0.13940278f, -0.34549820f, 
    0.27106625f, -0.62683249f, 0.45610827f, 0.40357208f, -0.29679626f, -0.25713816f, -0.33979297f, -0.00263973f, 
    -0.27111697f, -0.14736770f, -0.05649967f, 0.23355418f, -0.16005163f, -0.03102183f, -0.04082350f, 0.22804423f, 
    0.12523937f, 0.13029397f, 0.08772735f, -0.02363590f, 0.34619823f, 0.36397958f, -0.05360857f, -0.43840829f, 
    -0.46588731f, 0.23314016f, -0.39373887f, -0.21327564f, -0.22407076f, 0.43726063f, 0.41676828f, 0.18061407f, 
    0.16697554f, -0.23738839f, -0.10361928f, -0.28690746f, -0.21825093f, 0.22559737f, -0.09151509f, 0.05857905f, 
    0.23137210f, 0.08721601f, -0.21130133f, 0.25513339f, -0.31558481f, -0.03473786f, 0.21361589f, -0.28516194f, 
    -0.51167315f, -0.35583597f, -0.01898006f, -0.60854334f, 0.00130269f, 0.40115908f, 0.34782529f, -0.09729982f, 
    -0.23590189f, -0.07432584f, 0.24772592f, 0.00278013f, 0.07175400f, 0.27163136f, 0.12913777f, 0.21634495f, 
    0.18002370f, 0.32366627f, -0.06817827f, 0.16504815f, 0.09597624f, -0.25118583f, -0.04590379f, -0.50600070f, 
    -0.48657933f, -0.46555042f, 0.06993564f, 0.40989271f, 0.54786378f, -0.41078743f, 0.08851998f, 0.25380552f, 
    0.07370955f, -0.19262247f, 0.20432292f, -0.20329900f, -0.06793640f, -0.45914128f, -0.03791088f, 0.12246776f, 
    0.09905258f, -0.26968619f, -0.07187141f, -0.10634051f, -0.30381137f, -0.10174719f, -0.06419896f, -0.27719837f, 
    0.12159641f, 0.18030684f, -0.06607887f, -0.19223592f, -0.50525522f, -0.34422907f, -0.44695657f, -0.53571904f, 
    -0.34476432f, -0.05581494f, 0.33207545f, 0.07954377f, -0.20259136f, -0.25240266f, -0.27575225f, -0.29206255f, 
    0.16877331f, -0.11518925f, 0.17823979f, 0.18463142f, -0.04422817f, -0.20987512f, 0.10184678f, 0.10718483f, 
    0.55523062f, -0.09515958f, 0.29491231f, 0.48668492f, 0.52507216f, -0.03497023f, -0.18503553f, 0.25138801f, 
    0.25344303f, -0.45315164f, 0.00000500f, -0.33940592f, -0.29469490f, -0.03162627f, 0.14134577f, 0.00696384f, 
    0.00645957f, 0.40597948f, 0.16004300f, 0.16566470f, 0.22526528f, 0.15904126f, 0.00846230f, -0.04978360f, 
    -0.14662504f, -0.59086072f, -0.56312931f, -0.29498318f, 0.23188184f, -0.35829222f, 0.21119763f, 0.49204314f, 
    0.25071666f, 0.07085861f, -0.29466161f, -0.05683338f, -0.09988873f, -0.16358411f, -0.27202651f, -0.00966191f, 
    -0.11706413f, 0.31065834f, -0.07233600f, -0.20891605f, 0.00511829f, -0.07793136f, -0.03900247f, -0.00076383f, 
    -0.32055494f, -0.04657052f, -0.48191974f, -0.63692433f, 0.17654577f, 0.27298632f, 0.25869545f, 0.46302289f, 
    0.40802330f, 0.25816861f, -0.23312111f, 0.01024650f, -0.23517729f, -0.17644221f, 0.16343433f, 0.35909525f, 
    0.28279600f, -0.09382612f, 0.07862349f, -0.42922270f, 0.08039323f, 0.31536311f, 0.05772278f, 0.11437363f, 
    -0.08268131f, 0.23823886f, -0.32145539f, -0.23427574f, -0.39427653f, -0.62810558f, -0.47153842f, -0.54296494f, 
    0.47990471f, 0.42448261f, 0.19357277f, 0.60055566f, 0.58126056f, 0.11851719f, -0.33676705f, -0.22612900f, 
    -0.18469468f, 0.06851681f, 0.08344759f, -0.24175726f, -0.09219532f, -0.05529349f, -0.00736535f, 0.02718393f, 
    -0.01611949f, -0.16113709f, 0.22771154f, 0.04833794f, 0.29686579f, 0.00404703f, -0.68450409f, -0.14231485f, 
    -0.42669323f, -0.31749043f, 0.16471161f, -0.43195087f, -0.36036861f, 0.00125249f, 0.07451373f, 0.23708342f, 
    0.38069040f, 0.41669720f, -0.04202304f, 0.02014678f, -0.01869643f, 0.09942602f, -0.03885409f, -0.00970692f, 
    0.05517131f, -0.12411241f, 0.18708153f, 0.10327698f, 0.19402190f, 0.61895168f, 0.34045550f, 0.39752048f, 
    0.18822259f, 0.42322946f, 0.16639425f, -0.69942570f, -0.48931286f, -0.46531871f, -0.46486855f, -0.06395603f, 
    0.37643433f, 0.04847525f, -0.00494496f, -0.16800751f, 0.16804257f, 0.16254051f, -0.18042101f, 0.09707832f, 
    -0.03827234f, 0.04294753f, 0.10473739f, 0.13715349f, -0.04653571f, 0.09212470f, 0.26486680f, -0.61479229f, 
    0.16784337f, 0.05521929f, -0.06827703f, -0.69571626f, -0.04926797f, -0.06496345f, 0.17205888f, -0.56935412f, 
    -0.22103751f, 0.15451603f, 0.26968887f, -0.06086021f, 0.11223811f, -0.39425462f, 0.08269531f, -0.15599510f, 
    0.08692188f, -0.12162410f, 0.05741478f, 0.37051415f, -0.10357444f, 0.12309477f, 0.22160712f, -0.39958239f, 
    -0.26650974f, 0.70488536f, -0.02073350f, -0.21435644f, -0.02769379f, 0.75194454f, -0.47839832f, 0.04178204f, 
    -0.10541048f, -0.02217570f, -0.01583575f, 0.09297905f, 0.10904311f, -0.04479308f, 0.34185314f, 0.21853222f, 
    -0.09432852f, -0.05255215f, -0.18493442f, -0.13653655f, -0.07978385f, 0.29133824f, 0.16260807f, 0.17622364f, 
    -0.05555478f, -0.10390447f, 0.19557405f, -0.20935988f, 0.69092673f, -0.25191161f, -0.33510688f, -0.29949790f, 
    -0.63249457f, 0.11425613f, -0.01580860f, 0.40307254f, 0.20044333f, 0.08886208f, 0.22102153f, 0.34283358f, 
    0.02575013f, -0.15208308f, -0.00025672f, -0.26125151f, 0.08636355f, -0.06163132f, 0.02372034f, -0.10729197f, 
    0.09366571f, 0.02053447f, 0.12506393f, -0.46633461f, -0.60968685f, -0.26713812f, -0.15655956f, -0.31208175f, 
    -0.31063059f, -0.47160918f, -0.33667529f, 0.00879723f, 0.39785376f, 0.28030923f, 0.13543947f, 0.20873021f, 
    -0.16558279f, 0.13254523f, -0.17771997f, 0.16934158f, 0.24191409f, 0.12315407f, 0.09528191f, 0.24590942f, 
    -0.06785164f, 0.06918113f, 0.23207285f, 0.27542475f, 0.38318276f, 0.16665962f, 0.18533976f, -0.23642267f, 
    0.30825058f, -0.28036690f, 0.44235355f, -0.02148272f, -0.21562965f, 0.00627445f, -0.38350108f, -0.09155547f, 
    -0.25663617f, 0.26103586f, 0.25454819f, -0.29820007f, 0.21304323f, 0.12754253f, 0.41499782f, 0.23568563f, 
    0.13402312f, -0.13209274f, -0.01854088f, 0.10927242f, -0.65367645f, 0.45221978f, 0.38756511f, 0.20205875f, 
    -0.68089515f, -0.51296741f, 0.00834951f, -0.20126125f, -0.36362171f, 0.42709410f, 0.19190891f, -0.28259423f, 
    0.01390248f, 0.18310417f, -0.06300890f, 0.10958491f, 0.14074992f, 0.02077756f, 0.11813878f, 0.19084334f, 
    -0.02014145f, 0.07403090f, -0.06983396f, 0.10064320f, -0.31746542f, -0.34614980f, -0.16327508f, -0.41016749f, 
    -0.52414632f, -0.06762866f, -0.05595483f, 0.02601269f, -0.31519425f, 0.13325524f, 0.00842181f, 0.25629735f, 
    -0.22076161f, -0.03945683f, 0.03206219f, 0.24850729f, 0.03781518f, -0.06827402f, 0.01243407f, 0.09152593f, 
    -0.09705027f, 0.00545994f, -0.09716044f, -0.15391456f, 0.10462453f, -0.24043809f, 0.40796989f, 0.41246989f, 
    -0.62535048f, 0.19007951f, 0.52675027f, -0.15324996f, -0.58832103f, -0.06717578f, -0.26716796f, -0.16248463f, 
    -0.16148508f, -0.21655405f, 0.23506473f, -0.17263663f, -0.20433258f, -0.08890098f, 0.01851093f, -0.26481345f, 
    -0.13453373f, -0.13791229f, -0.09162933f, -0.26260066f, -0.13781637f, -0.01906434f, 0.31679118f, 0.35470602f, 
    -0.10105637f, 0.51240742f, 0.52399194f, 0.15923655f, 0.36957371f, 0.02631892f, 0.18054220f, 0.19950993f, 
    -0.21218283f, -0.09380731f, -0.11200245f, -0.04791437f, 0.08608248f, -0.17820844f, 0.11899190f, -0.05250012f, 
    -0.11342452f, 0.07432672f, 0.31483939f, -0.27767077f, 0.21802108f, 0.07484034f, 0.07711724f, -0.59260988f, 
    0.16205588f, -0.39215291f, -0.40857962f, -0.29564434f, 0.05259362f, 0.06478965f, 0.16005102f, 0.42590758f, 
    -0.28283459f, -0.30628020f, 0.22310326f, -0.23735245f, 0.00968325f, -0.03346650f, -0.00509374f, 0.13816600f, 
    -0.36335626f, -0.07059363f, -0.07298239f, 0.11700749f, 0.03859502f, 0.28815728f, 0.10430386f, 0.35302842f, 
    -0.41166985f, 0.30246770f, 0.04974471f, 0.31820068f, -0.31923050f, 0.34334832f, -0.38738039f, -0.15117706f, 
    -0.24264567f, -0.20226935f, -0.55956125f, -0.00923677f, 0.09219003f, 0.22253959f, -0.24886304f, -0.31420851f, 
    0.13339490f, -0.19105884f, -0.12874436f, -0.32856494f, 0.05815991f, -0.18674849f, -0.30325577f, -0.06534357f, 
    -0.18874179f, -0.31805503f, 0.08991922f, -0.35880727f, 0.29500946f, -0.16670685f, 0.06380422f, 0.16280122f, 
    -0.10512373f, 0.03104829f, -0.49178362f, 0.05199760f, -0.23639646f, 0.07810076f, -0.30369592f, 0.02882126f, 
    -0.20726930f, 0.13822396f, -0.05209636f, 0.23609179f, -0.08114156f, -0.06620370f, -0.05999295f, 0.22622205f, 
    0.21390054f, 0.17103571f, 0.22179067f, 0.27786979f, 0.46868360f, 0.67202771f, 0.14868620f, -0.01887832f, 
    -0.29934189f, -0.17708600f, 0.30452245f, 0.09995982f, -0.07256280f, 0.33406642f, -0.19178851f, -0.23105136f, 
    0.12290448f, -0.25474957f, -0.21407253f, -0.30318642f, -0.18883419f, -0.33950934f, -0.13241962f, -0.10366940f, 
    0.03129091f, -0.33822119f, 0.06885798f, -0.11578442f, 0.06883209f, -0.00397401f, -0.05715411f, 0.01526412f, 
    0.15561599f, 0.14827827f, 0.05300035f, -0.25187361f, 0.50935090f, 0.11608617f, 0.26854891f, 0.29593813f, 
    0.20146602f, -0.30466312f, -0.40366912f, -0.04110610f, 0.11747483f, 0.34523758f, -0.27638641f, 0.02861526f, 
    0.25535086f, -0.00575777f, 0.16669688f, 0.22930482f, -0.22936893f, 0.72987044f, -0.20658129f, -0.47420126f, 
    0.32901019f, -0.26757210f, -0.08546404f, -0.33992136f, -0.02537973f, -0.08156818f, 0.28492293f, 0.05023346f, 
    -0.36797157f, -0.12560156f, -0.10840552f, -0.08796400f, 0.15719095f, -0.32589996f, -0.06439092f, -0.01789560f, 
    -0.07867362f, -0.21513014f, 0.14756961f, -0.09673733f, 0.25470462f, -0.56989902f, -0.50898689f, -0.00694650f, 
    0.14162052f, -0.36643004f, 0.03791798f, 0.61804062f, -0.43383172f, -0.30938041f, -0.10346127f, -0.20045727f, 
    0.37719268f, 0.16736026f, 0.08278081f, 0.09164700f, -0.42249265f, -0.13448012f, 0.26752594f, -0.29137161f, 
    -0.21787694f, 0.09809204f, -0.03838527f, -0.04777950f, 0.12697224f, -0.03990678f, 0.44594142f, 0.49138337f, 
    0.04807558f, 0.52597970f, 0.72200876f, -0.21655738f, -0.41217810f, 0.30571496f, -0.06491254f, 0.21189728f, 
    -0.18172754f, -0.26033384f, 0.19012770f, 0.03246721f, 0.29985252f, 0.12716833f, 0.08642954f, -0.02448505f, 
    0.20692956f, 0.16085948f, 0.38443393f, 0.17721230f, 0.03200549f, -0.23391698f, -0.09369367f, 0.37869444f, 
    0.57818341f, 0.03775519f, 0.54334539f, 0.45502535f, -0.02788602f, 0.20102018f, 0.20044434f, -0.14753869f, 
    0.03261112f, 0.23440696f, -0.24963796f, 0.17478946f, -0.00425023f, -0.15977095f, 0.05997257f, 0.07500922f, 
    0.04233691f, -0.08619461f, 0.00574011f, -0.24470343f, -0.31044251f, 0.16012321f, -0.12957416f, 0.11281028f, 
    -0.19211222f, 0.67800379f, 0.28725520f, 0.14537907f, 0.31599900f, -0.38329068f, 0.39949590f, -0.20436074f, 
    0.16954596f, -0.05920045f, -0.18452571f, 0.04784657f, -0.33977252f, -0.09398026f, -0.14103748f, -0.38527703f, 
    -0.21366744f, -0.19792795f, -0.33308718f, -0.33751655f, 0.18857846f, 0.06546851f, -0.15683851f, 0.29285923f, 
    0.32664129f, 0.19206186f, 0.31233779f, 0.26807740f, 0.39318654f, 0.50410253f, -0.14004442f, -0.23851003f, 
    0.07359486f, 0.13275084f, -0.29682240f, -0.35438025f, -0.03773832f, 0.13760164f, -0.00241637f, 0.33928666f, 
    -0.01371141f, -0.13476212f, 0.32756093f, -0.02773924f, 0.32273212f, 0.16683105f, -0.13657872f, 0.05620133f, 
    0.06823574f, -0.23490453f, 0.42070457f, -0.24104339f, 0.15818830f, 0.39284971f, -0.08984179f, 0.28412905f, 
    0.19890037f, 0.40502211f, 0.14233102f, -0.45304915f, -0.24892798f, -0.19663876f, 0.04408413f, -0.14552341f, 
    0.20461653f, 0.37467763f, 0.02707905f, -0.18465400f, -0.40324244f, 0.26272348f, -0.19831036f, -0.08403008f, 
    -0.23642471f, -0.30711588f, 0.36562234f, 0.26887807f, -0.40254653f, -0.36839873f, -0.14997338f, 0.14946845f, 
    -0.11060133f, -0.20461589f, 0.00925813f, -0.39686617f, -0.23677315f, -0.25064695f, -0.14934680f, -0.03963895f, 
    0.08330964f, 0.17129484f, -0.08577295f, -0.11788835f, -0.11396319f, -0.22118320f, -0.14002253f, 0.23738988f, 
    -0.11661520f, -0.11163210f, 0.53304917f, -0.04146025f, 0.86558646f, -0.06594273f, -0.48778316f, 0.34706667f, 
    0.35372797f, 0.14655741f, -0.40538517f, -0.06734942f, 0.27390298f, -0.17046055f, -0.39432228f, -0.30342925f, 
    0.25779468f, -0.06368531f, 0.14841394f, 0.19857045f, -0.08630326f, -0.25029096f, -0.21553479f, -0.02940446f, 
    0.14610672f, 0.06921230f, 0.20387462f, -0.25194991f, -0.17297450f, 0.73920405f, 0.30934113f, 0.28097135f, 
    -0.12182553f, -0.42196372f, -0.18255949f, 0.20287253f, -0.00162365f, -0.11910234f, -0.09677570f, 0.27537712f, 
    -0.04238597f, -0.04612785f, -0.32138246f, -0.07851899f, -0.17668204f, -0.06928102f, 0.03893002f, -0.02094017f, 
    0.18619576f, -0.39440578f, 0.08215445f, -0.15271103f, -0.17990017f, 0.22416399f, -0.31362396f, -0.98875111f, 
    -0.30200717f, 0.27992803f, 0.45452845f, -0.13702294f, 0.79818237f, -0.05515360f, -0.35138038f, 0.24370801f, 
    0.22881083f, -0.07950959f, -0.10206027f, -0.03340747f, 0.12577991f, 0.02594098f, -0.09265566f, 0.03386428f, 
    -0.01811124f, -0.19831525f, 0.08652548f, 0.07787404f, -0.05049466f, -0.08193371f, -0.16822024f, -0.26712129f, 
    -0.48082408f, -0.27731994f, -0.18794250f, -0.29727969f, -0.37174672f, 0.22591704f, 0.39237034f, -0.23510645f, 
    0.25756535f, -0.18071873f, 0.12667473f, -0.27730462f, -0.28798050f, -0.34208530f, -0.11148550f, 0.29728153f, 
    0.18388036f, -0.14003389f, -0.22004433f, -0.00091721f, -0.03347361f, 0.10692231f, -0.13544986f, 0.01951427f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12645058f, 0.09444059f, -0.03646547f, 0.08616458f, -0.01444332f, 0.01550117f, 0.16810672f, 0.17363407f, 
    0.06914148f, 0.26954699f, 0.18573673f, 0.36961624f, 0.24050204f, -0.00380767f, 0.14382225f, 0.10421233f, 
    0.15002419f, 0.03364932f, 0.00518317f, 0.07835893f, -0.00978119f, 0.24955261f, 0.14088911f, -0.12015153f, 
    0.11909155f, 0.15320908f, 0.19048502f, -0.12087262f, 0.11595791f, 0.18755546f, 0.01568403f, -0.00860146f, 
    -0.02565924f, 0.09796774f, 0.17038567f, -0.05894524f, 0.29610747f, -0.01152675f, 0.06561547f, -0.00495348f, 
    0.17221440f, 0.16561583f, -0.10112191f, 0.09888177f, 0.08993504f, -0.03408160f, 0.07517168f, 0.00742850f, 
    0.06741029f, 0.02899687f, 0.18716946f, 0.12680283f, 0.17236397f, 0.22283620f, -0.07301698f, 0.00309696f, 
    -0.07107289f, -0.03722940f, -0.06418142f, 0.28200239f, -0.05671180f, 0.09165750f, 0.24407832f, -0.09955744f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00897266f, 0.01940001f, -0.03195783f, -0.03676122f, -0.02657236f, -0.01020446f, -0.01045433f, -0.00540391f, 
    -0.00245876f, -0.00373486f, 0.02136831f, -0.00575213f, -0.01301279f, -0.03680596f, -0.00617949f, -0.03217394f, 
    -0.03840109f, 0.02458748f, -0.03706814f, -0.00189854f, -0.00327560f, -0.00828516f, -0.01558681f, -0.00944486f, 
    0.01351839f, 0.00326657f, 0.00150062f, 0.00076610f, -0.01184616f, -0.01970406f, 0.02240049f, 0.02964232f, 
    -0.01319057f, -0.00728558f, -0.00656624f, -0.02747229f, 0.02618160f, 0.00824766f, 0.00388420f, 0.02419666f, 
    0.02500899f, 0.02854034f, 0.02254634f, 0.00850993f, -0.03958664f, -0.01923183f, 0.01069712f, -0.03174092f, 
    -0.03660183f, 0.00606724f, 0.01870148f, -0.00362094f, 0.02165321f, -0.01051315f, -0.00788751f, 0.02493916f, 
    -0.02758824f, 0.02241447f, -0.03264058f, -0.00696031f, -0.02849425f, -0.01698612f, 0.03064856f, 0.02990912f, 
    0.01640472f, 0.02452516f, -0.02673628f, 0.02274649f, 0.02480021f, -0.03042153f, -0.00489051f, 0.02490782f, 
    0.02067780f, -0.01876163f, 0.02995134f, 0.02152978f, 0.02703093f, -0.03569207f, -0.00469515f, -0.02256159f, 
    -0.02833433f, 0.00941058f, -0.02952839f, 0.00477397f, 0.02294692f, 0.00072600f, 0.02228617f, 0.01468884f, 
    0.02785283f, -0.03753239f, 0.02652240f, -0.02722489f, -0.02060620f, -0.01338244f, 0.00501426f, -0.03280186f, 
    0.00982669f, -0.00879115f, 0.03137144f, 0.00042632f, 0.02212384f, 0.03211011f, -0.04360690f, -0.03947299f, 
    -0.01194228f, -0.00015738f, 0.01356570f, 0.02194515f, -0.00029448f, 0.02904307f, 0.01636250f, -0.03022703f, 
    0.00599674f, 0.00502204f, -0.03352910f, 0.02205089f, -0.03064484f, -0.01554954f, -0.03536015f, -0.03693461f, 
    0.00292510f, 0.00484019f, 0.01928096f, -0.01233844f, 0.02526620f, -0.01873181f, -0.02728318f, -0.03592910f, 
    0.03433030f, 0.02897734f, -0.01236519f, -0.02215792f, -0.00985680f, -0.00035660f, -0.03114175f, 0.00596998f, 
    0.02655529f, -0.01722363f, 0.00520144f, 0.00387640f, -0.01330971f, 0.01256665f, -0.02718929f, 0.02420987f, 
    -0.02450213f, -0.03845398f, -0.00092906f, 0.00008740f, 0.02902278f, -0.02202505f, 0.02291469f, -0.00616452f, 
    0.02841251f, 0.02976849f, -0.00459503f, 0.03046411f, 0.02653375f, 0.03435507f, -0.00043120f, -0.03000745f, 
    -0.03801041f, 0.01155165f, -0.02243264f, -0.02472143f, -0.02690184f, -0.01919775f, -0.00847490f, -0.01466316f, 
    0.02602481f, 0.02587494f, 0.02678862f, 0.02692247f, 0.01484959f, 0.02703999f, 0.02435391f, -0.00406288f, 
    0.01618904f, -0.03452913f, -0.00778807f, -0.03330333f, 0.02908855f, -0.01802257f, -0.00302849f, -0.00133993f, 
    -0.01914800f, -0.00931750f, 0.01698843f, -0.00332871f, 0.02607289f, 0.03115263f, -0.03167817f, 0.02066819f, 
    0.00763759f, 0.01953665f, -0.00173492f, -0.00520880f, -0.01907879f, -0.02626674f, -0.03623488f, -0.03631655f, 
    -0.02106075f, -0.02378987f, 0.02180147f, -0.00862526f, 0.00307150f, -0.03238711f, -0.03852468f, -0.00945198f, 
    -0.03766610f, -0.03900807f, -0.03773240f, -0.01166964f, -0.00594578f, -0.03437688f, -0.02836461f, 0.00719717f, 
    0.00033274f, -0.02888931f, -0.01951637f, 0.00437914f, -0.02436926f, -0.01381792f, -0.00721014f, -0.03643797f, 
    0.01266355f, -0.00114277f, 0.00423392f, -0.03104546f, -0.02221998f, 0.00914505f, -0.02868295f, -0.01627043f, 
    -0.00525317f, -0.01450196f, -0.02428599f, -0.03805390f, 0.00615416f, -0.00380633f, 0.00387186f, -0.02557302f, 
    -0.01380428f, 0.01821796f, -0.01470482f, -0.02938490f, -0.01590266f, 0.01314804f, 0.03005525f, 0.01012946f, 
    0.01762436f, -0.00739779f, 0.02946128f, -0.01524814f, 0.00398891f, -0.02057814f, -0.03773227f, -0.00767584f, 
    0.00304593f, 0.02621669f, -0.01722162f, -0.00496842f, 0.01883171f, -0.00114422f, 0.03448285f, -0.01524447f, 
    -0.01242330f, 0.02956879f, -0.03221182f, -0.00300636f, -0.02960619f, 0.00848224f, 0.02671639f, -0.02301495f, 
    0.03286568f, 0.00876352f, -0.01091754f, -0.01281496f, -0.00038127f, 0.02631894f, 0.01581688f, 0.01437019f, 
    0.00203252f, -0.02665939f, 0.01238694f, 0.02900705f, 0.01520560f, -0.02605942f, 0.01769572f, 0.03465402f, 
    0.02376509f, 0.02347772f, -0.01403220f, 0.02539673f, -0.02356951f, 0.02045471f, -0.02426804f, 0.01831835f, 
    -0.01687446f, -0.04058899f, 0.03080579f, 0.00269422f, -0.01259034f, -0.02807096f, -0.01980518f, 0.01716059f, 
    0.00241382f, -0.00413383f, 0.02524648f, 0.01016159f, 0.01816003f, 0.03010169f, -0.02628696f, -0.02688318f, 
    -0.03423154f, -0.01515836f, 0.02557685f, -0.03607843f, -0.01018313f, 0.00596970f, 0.02182519f, 0.00795967f, 
    -0.02360597f, -0.02370305f, -0.02304491f, -0.00476562f, 0.03504099f, -0.00246353f, -0.00030107f, 0.00164455f, 
    -0.02177654f, 0.00831514f, -0.02484431f, -0.02829113f, -0.03513429f, 0.00644174f, -0.03464540f, -0.00440822f, 
    -0.02962221f, -0.01217076f, -0.03189959f, -0.03522251f, 0.01403894f, -0.03241188f, 0.02652704f, 0.00598954f, 
    -0.02680541f, -0.01617580f, 0.00549527f, 0.03850199f, -0.02843974f, -0.00990228f, 0.02112035f, -0.01277158f, 
    -0.03545625f, 0.00931449f, 0.02435347f, 0.02133050f, -0.03899333f, 0.03373371f, -0.00626433f, 0.02088692f, 
    -0.03175408f, -0.03002408f, 0.01487351f, -0.00842569f, 0.00742423f, -0.04214113f, -0.02433343f, -0.02639442f, 
    0.02218910f, -0.00664611f, 0.02045863f, -0.01313423f, 0.01845207f, -0.04037942f, 0.01433907f, -0.02489693f, 
    0.01562068f, 0.02143111f, -0.00288366f, -0.01006969f, 0.02787095f, 0.01938598f, -0.01443881f, -0.00011623f, 
    -0.00308133f, 0.01632914f, -0.01544001f, -0.01471815f, 0.01619729f, -0.02646498f, 0.01196341f, 0.00817977f, 
    -0.02105074f, 0.00663495f, 0.00085695f, -0.02884848f, 0.01514542f, -0.02739287f, 0.00267321f, -0.00373730f, 
    -0.01887365f, -0.00439532f, 0.01764103f, -0.01337946f, 0.01686919f, 0.00017910f, -0.02288265f, -0.01058912f, 
    -0.01801815f, 0.01138222f, -0.02235357f, -0.02805152f, -0.02885266f, -0.03671171f, 0.01765119f, 0.00817067f, 
    -0.03228376f, -0.00099932f, 0.00744249f, -0.03424904f, -0.01968696f, 0.02035593f, -0.02328198f, -0.01109158f, 
    -0.03258184f, -0.01362228f, -0.00853061f, -0.03732531f, -0.03738586f, -0.03607864f, 0.00521644f, 0.00645621f, 
    -0.03532682f, -0.03317148f, -0.03030922f, -0.02582184f, -0.00896088f, 0.00622641f, -0.03574537f, -0.00072642f, 
    0.02277046f, 0.02390694f, 0.01390416f, 0.01517740f, -0.01136639f, 0.00461878f, -0.02998680f, -0.02172170f, 
    -0.02776915f, -0.00993193f, 0.03335724f, -0.03367415f, -0.01157677f, -0.02773136f, -0.02891104f, 0.00575514f, 
    -0.00736484f, 0.00860392f, -0.03430447f, -0.01440018f, 0.02661385f, 0.03129657f, 0.00425595f, -0.02242623f, 
    -0.03819362f, -0.04251271f, -0.03547305f, -0.03799378f, -0.03598347f, -0.01162175f, 0.01925677f, -0.02160923f, 
    -0.03873473f, 0.00778045f, 0.02002463f, 0.02263529f, -0.01719398f, -0.00171030f, -0.01277353f, 0.03251752f, 
    0.02053077f, -0.03901315f, 0.02361689f, -0.04083436f, -0.01769627f, 0.00521592f, -0.01438396f, -0.01326432f, 
    -0.02666423f, -0.01831158f, 0.00424555f, 0.01769851f, -0.02645831f, -0.03189739f, 0.01506795f, -0.03861184f, 
    0.00822958f, 0.01216749f, 0.02518612f, 0.03094272f, -0.03364301f, -0.01648930f, -0.01626305f, 0.02234913f, 
    0.02749789f, -0.03924517f, 0.02219564f, 0.02315481f, 0.01594519f, 0.00780084f, -0.03395478f, -0.00881306f, 
    -0.01743759f, -0.01721155f, -0.03178032f, 0.01145215f, 0.01470979f, -0.03301019f, -0.03266495f, 0.01087645f, 
    0.00297819f, 0.01386723f, -0.03094881f, -0.01000362f, 0.00991042f, -0.01545089f, -0.03194432f, -0.00780551f, 
    0.00443284f, -0.03624206f, -0.01500017f, 0.02224707f, -0.02423325f, 0.03616258f, 0.02436101f, -0.01600726f, 
    -0.03624457f, -0.00773165f, 0.00211097f, -0.00445649f, 0.01310517f, 0.00729032f, -0.01047385f, -0.02651036f, 
    0.03122703f, -0.00802324f, -0.00867121f, -0.00937442f, -0.03294944f, 0.01502100f, -0.02564218f, 0.01637346f, 
    -0.02725173f, 0.00919892f, 0.02872920f, 0.00405806f, -0.00545925f, -0.02993185f, -0.03651536f, -0.00746541f, 
    -0.01854665f, -0.01627438f, 0.01453920f, -0.03080973f, -0.00227488f, -0.03537314f, 0.03163343f, -0.00018691f, 
    0.02752918f, -0.01187611f, -0.02564462f, -0.02422592f, -0.01939400f, -0.01793824f, -0.01250852f, -0.00232800f, 
    0.00659111f, -0.02311773f, 0.01537139f, -0.02816427f, -0.01239817f, 0.02176187f, 0.01230681f, 0.02133806f, 
    -0.03646920f, -0.04063717f, -0.03613162f, 0.02084957f, 0.00444354f, 0.02478587f, -0.02306806f, -0.00461289f, 
    0.03011474f, -0.01606478f, -0.03257025f, -0.00511996f, -0.02862862f, 0.00104231f, -0.02786308f, 0.01404473f, 
    0.01255177f, 0.01665992f, -0.00221824f, -0.02651155f, 0.01512651f, 0.01952489f, -0.03159627f, 0.02868859f, 
    -0.02529263f, 0.01484284f, 0.01457996f, 0.00876122f, 0.00063309f, 0.00834463f, -0.01239233f, -0.02731528f, 
    0.00471847f, -0.01357747f, 0.01638585f, 0.02348278f, 0.01568823f, 0.00331650f, -0.02349160f, 0.01665406f, 
    0.00222137f, 0.01546714f, 0.00569111f, 0.03343364f, -0.02904891f, -0.02767882f, 0.01192376f, 0.00447357f, 
    -0.02208446f, -0.02231479f, -0.02751451f, -0.02306910f, -0.00364640f, 0.02616323f, -0.01874112f, -0.03690392f, 
    -0.02935604f, -0.01999427f, 0.02444045f, -0.00139842f, -0.01647852f, 0.00808650f, -0.03038988f, -0.00640261f, 
    -0.02047247f, 0.01281451f, -0.03046048f, 0.02787053f, 0.02483256f, 0.02484370f, -0.02125525f, 0.01427329f, 
    -0.01930275f, 0.02688712f, -0.02938543f, 0.02593797f, -0.01828786f, 0.01176652f, -0.03294227f, -0.02576599f, 
    -0.00191227f, -0.03359057f, -0.03068279f, -0.00509107f, 0.01899065f, -0.02939779f, 0.01524958f, -0.02343118f, 
    0.00348437f, -0.00887225f, -0.01677274f, 0.02040881f, -0.01584512f, 0.03131428f, 0.02365894f, 0.00659425f, 
    -0.00747026f, -0.01230097f, -0.00821270f, -0.00297625f, -0.03183283f, 0.02485816f, -0.03722103f, -0.04301967f, 
    -0.01349280f, 0.00347982f, 0.00302532f, 0.00050463f, -0.03108201f, 0.01472387f, 0.02061900f, 0.02267562f, 
    -0.01875446f, -0.02113224f, -0.00939369f, 0.01514690f, 0.02279772f, 0.03077577f, -0.00157325f, 0.00214869f, 
    0.01718281f, -0.02104570f, -0.00545947f, 0.01851451f, -0.00928582f, 0.02795668f, -0.01717208f, 0.00668034f, 
    0.02399215f, 0.02411455f, -0.00093890f, -0.03407480f, 0.01212210f, 0.01122694f, -0.01233363f, -0.01375689f, 
    0.00075674f, -0.02446545f, -0.00909725f, 0.00221094f, 0.03151688f, 0.02048958f, -0.02335861f, 0.00190276f, 
    -0.00814308f, -0.02970271f, -0.03550353f, 0.03039692f, -0.00034546f, 0.02229708f, -0.02942524f, -0.01413805f, 
    -0.02909567f, 0.00134977f, -0.02659829f, 0.01679160f, 0.00207576f, -0.00831878f, -0.02555638f, 0.02529711f, 
    -0.00953463f, 0.00103621f, 0.00842046f, -0.00219127f, -0.02790092f, -0.01394108f, -0.02009249f, -0.01057568f, 
    -0.03395367f, 0.02595094f, 0.01295704f, -0.01652190f, -0.01716120f, 0.03056216f, -0.02133153f, -0.02801065f, 
    0.00822264f, -0.03918603f, 0.00625176f, -0.02769259f, 0.03311997f, -0.04019319f, -0.01806621f, -0.00432194f, 
    -0.32423988f, 0.20249917f, -0.07349512f, 0.02461522f, -0.11100090f, -0.02218636f, 0.06258774f, -0.04599846f, 
    0.04599157f, 0.08418231f, 0.08201887f, 0.00510517f, 0.49590105f, -0.11066367f, 0.18855517f, -0.12354906f, 
    0.18336202f, -0.03552934f, 0.03855152f, 0.11552794f, 0.06659643f, 0.05203342f, 0.04843189f, 0.07109866f, 
    0.16938347f, 0.26679298f, -0.01990313f, 0.02095469f, 0.07029326f, -0.10071103f, 0.15501940f, -0.03009890f, 
    -0.03173118f, -0.02479583f, -0.14488374f, 0.00245832f, -0.06748938f, 0.05043905f, -0.11398196f, 0.00460324f, 
    -0.01106316f, -0.00173718f, -0.05112449f, -0.00805852f, 0.08535411f, -0.02834299f, 0.04744214f, 0.00738781f, 
    -0.40007243f, -0.08973537f, -0.03706901f, -0.40585804f, 0.08925968f, 0.00900656f, -0.01472914f, -0.07217325f, 
    -0.07842762f, -0.01733336f, 0.07515870f, -0.10244777f, -0.25549218f, -0.11970183f, -0.16189800f, 0.12592699f, 
    0.17919873f, 0.17067093f, -0.14953904f, -0.09985431f, -0.03706905f, 0.05930063f, 0.03038898f, 0.05429608f, 
    -0.22879012f, -0.04033000f, 0.01837844f, -0.06941006f, 0.01966226f, -0.00503727f, 0.07575355f, 0.03581439f, 
    0.06188028f, 0.01238199f, 0.09778765f, -0.02883030f, -0.23164991f, 0.12841913f, -0.10668723f, -0.21165845f, 
    0.21866657f, 0.00132489f, -0.00176417f, 0.04392177f, 0.00261287f, -0.06101862f, 0.01372192f, 0.00052988f, 
    -0.21310645f, 0.09455509f, -0.05051228f, 0.09994993f, 0.04710211f, -0.01775461f, 0.04342049f, -0.00441687f, 
    0.03345042f, -0.01071159f, -0.06292486f, -0.02036367f, -0.19746041f, 0.03643395f, 0.09335496f, -0.03121162f, 
    0.14363331f, 0.12178459f, -0.00002009f, 0.01061889f, -0.04870474f, 0.01037962f, 0.08437585f, 0.04482117f, 
    0.11309216f, -0.00147615f, 0.15961096f, 0.09994622f, 0.08144435f, 0.04111189f, 0.03690520f, 0.04216662f, 
    0.03051298f, 0.05822368f, 0.04162101f, -0.05065932f, -0.18952312f, -0.05713487f, -0.08378495f, 0.27447107f, 
    0.03879574f, 0.06966624f, -0.07791166f, 0.09125935f, 0.04247835f, -0.01812896f, -0.01634724f, -0.01517966f, 
    0.26560998f, -0.04186628f, 0.17278230f, -0.11612406f, 0.14195402f, -0.07252975f, -0.02213078f, 0.11192620f, 
    0.04535110f, 0.05544316f, 0.05434770f, 0.02298272f, -0.14120302f, -0.07862052f, 0.03874233f, 0.10802521f, 
    -0.11531030f, 0.09149124f, 0.01280774f, 0.07170186f, -0.01177746f, 0.02958932f, -0.04030001f, -0.00562923f, 
    0.06221755f, 0.09890706f, -0.02482974f, 0.26157448f, -0.02913489f, 0.09634947f, -0.10062533f, -0.04051387f, 
    -0.06194224f, 0.08382701f, -0.01354405f, -0.02020101f, 0.13040102f, -0.02613704f, 0.09241474f, 0.29725865f, 
    -0.03904693f, 0.09790280f, -0.11402564f, -0.01307580f, -0.01312245f, -0.05346285f, -0.01826036f, 0.09567580f, 
    -0.17252024f, 0.12276576f, -0.05221864f, 0.07691810f, 0.12276911f, 0.10940407f, -0.03863703f, 0.01662453f, 
    0.02695950f, 0.00307235f, 0.06271951f, 0.07956636f, -0.14453878f, -0.03878585f, -0.07895479f, -0.28094190f, 
    0.12487557f, 0.00467251f, 0.02355367f, -0.04876545f, -0.02071884f, 0.00401617f, 0.06584369f, 0.07440456f, 
    0.22644916f, -0.11643331f, 0.29998276f, 0.00717016f, 0.13783425f, 0.07524515f, -0.06175670f, 0.06718644f, 
    0.07766733f, 0.00549176f, -0.00740564f, 0.05571924f, 0.03973361f, -0.15843762f, 0.15775909f, 0.15752070f, 
    0.03119605f, -0.02673265f, 0.06084624f, 0.00742671f, -0.08014085f, 0.16652186f, 0.08972611f, 0.12590761f, 
    0.22173932f, -0.07688995f, -0.07701867f, 0.17512333f, 0.02797568f, 0.03024572f, -0.16618472f, 0.01631679f, 
    0.00759445f, 0.05901908f, -0.09858046f, 0.01356393f, 0.16799089f, -0.23854758f, -0.00594698f, 0.21742591f, 
    -0.03707754f, 0.01934780f, 0.06804394f, -0.00912762f, -0.01307453f, -0.06437956f, -0.02425439f, 0.06363623f, 
    0.04489702f, 0.11869954f, 0.14791511f, 0.00897802f, 0.05991406f, -0.03543349f, 0.09224372f, 0.08316336f, 
    0.09747259f, -0.03031681f, 0.05943532f, 0.05680394f, 0.33663434f, -0.08109081f, -0.26407671f, -0.07988676f, 
    0.06746992f, -0.10335261f, -0.04121496f, 0.02873313f, 0.03256645f, -0.02156486f, -0.08728218f, -0.05745059f, 
    -0.12540895f, -0.18215649f, -0.07549669f, -0.01506057f, 0.17895468f, 0.08578417f, -0.07284334f, 0.03083918f, 
    -0.04214831f, 0.06184046f, -0.01159608f, 0.05547695f, -0.25868037f, 0.03671028f, 0.00451978f, -0.25418440f, 
    0.11570404f, -0.02170886f, 0.02973660f, -0.10817534f, 0.03222491f, 0.01487906f, -0.09849866f, -0.01423934f, 
    -0.01796056f, -0.12912457f, 0.02868962f, -0.02978078f, -0.15112585f, -0.06885092f, 0.03261825f, -0.08047321f, 
    -0.04502971f, 0.02163649f, -0.03048673f, 0.02173368f, 0.51529783f, -0.27007011f, 0.01685314f, -0.09993064f, 
    0.10762246f, 0.05394762f, 0.01240692f, 0.10714719f, -0.14240479f, -0.01022853f, 0.04525080f, -0.08580183f, 
    0.04402029f, 0.14694002f, -0.10717302f, 0.23322222f, 0.16366751f, 0.03940641f, -0.10094288f, 0.03671319f, 
    -0.04058667f, 0.07570768f, 0.01071294f, 0.05196033f, 0.00525886f, 0.00023234f, 0.00679325f, 0.16869928f, 
    0.05760117f, 0.01932895f, -0.02380943f, -0.00208652f, 0.00832532f, 0.01343663f, 0.03047837f, 0.06026408f, 
    -0.10616738f, 0.20186926f, -0.16051733f, 0.20676735f, -0.06299584f, 0.07579730f, 0.05861882f, -0.01062174f, 
    0.10645574f, 0.07971957f, 0.09284644f, 0.09285951f, 0.39035425f, 0.20559786f, 0.07476825f, 0.13781236f, 
    0.03516467f, -0.07899712f, 0.09210547f, 0.06235598f, -0.04404579f, -0.04171669f, -0.07218453f, 0.13816802f, 
    -0.13554925f, -0.04775174f, 0.04586193f, -0.26909435f, 0.06405123f, 0.03897290f, 0.04857911f, -0.04361052f, 
    -0.08598875f, 0.07081021f, 0.05350953f, -0.01005438f, 0.03474338f, -0.20099805f, 0.10110527f, 0.03244425f, 
    -0.00484074f, -0.08459365f, 0.02914230f, -0.05730708f, -0.02175569f, 0.07332678f, 0.06135416f, 0.05296317f, 
    0.11281309f, -0.16836269f, 0.00877803f, -0.00728373f, 0.06267720f, -0.01879861f, 0.05320296f, 0.18500781f, 
    0.00907502f, -0.00877711f, 0.00396029f, 0.06257010f, -0.33214325f, -0.02570768f, -0.06013927f, -0.02404293f, 
    -0.10152218f, -0.03499060f, 0.01266749f, 0.00267494f, 0.00823213f, -0.03453832f, 0.02452047f, -0.12098029f, 
    -0.13316962f, 0.07080938f, 0.03754467f, 0.12981312f, 0.11386291f, -0.04075234f, -0.01248843f, -0.08004963f, 
    0.01103904f, -0.03881020f, 0.04053031f, 0.08568889f, 0.01341061f, -0.09528904f, -0.21470027f, -0.00153165f, 
    0.06621023f, 0.03489140f, 0.00651967f, -0.00956166f, -0.09707475f, -0.00989589f, -0.06262162f, 0.03656672f, 
    -0.04294506f, 0.18924300f, 0.08858230f, 0.12905344f, -0.03358909f, 0.01214660f, 0.07338551f, 0.03060846f, 
    -0.05257827f, -0.09984913f, 0.13955356f, 0.08547647f, 0.19395192f, 0.03232182f, 0.05870061f, 0.19867469f, 
    0.08966280f, 0.02725185f, -0.00084659f, 0.11108235f, -0.17742942f, 0.15030187f, 0.04403884f, -0.06222508f, 
    0.15104601f, 0.09864468f, -0.09069918f, 0.09283736f, 0.02563717f, 0.01296868f, 0.05969348f, -0.04442303f, 
    -0.06395110f, 0.00759302f, 0.06026517f, 0.05900008f, 0.28592157f, 0.01370627f, -0.14576615f, 0.17668323f, 
    -0.04939349f, -0.05138408f, -0.16064750f, -0.06605404f, 0.10505016f, 0.01979033f, -0.09008834f, 0.11698870f, 
    -0.22161290f, 0.05011405f, 0.07632411f, -0.06106034f, 0.12097143f, 0.12720525f, 0.01690951f, 0.00575355f, 
    -0.19097041f, 0.03885083f, 0.09585958f, -0.00267231f, 0.11958060f, 0.17572196f, 0.16895565f, -0.06107013f, 
    0.04675471f, -0.01480552f, 0.09423932f, 0.06135230f, 0.08192622f, -0.04388947f, -0.04849543f, -0.05153656f, 
    0.12032471f, -0.02750835f, -0.07766803f, -0.03387023f, 0.00678097f, -0.10129784f, -0.03544582f, -0.04585963f, 
    0.08299823f, -0.04584721f, 0.08632501f, 0.04704130f, 0.04867984f, -0.08010036f, -0.06630766f, 0.19556980f, 
    0.12811737f, 0.02322611f, -0.07719178f, 0.06190156f, 0.08185960f, -0.00217540f, 0.04601746f, 0.07774382f, 
    -0.31499219f, -0.01076641f, -0.04267514f, -0.23988257f, 0.07534952f, -0.03191460f, 0.00687478f, -0.03725536f, 
    0.08485382f, -0.01345432f, 0.06051882f, -0.02388176f, -0.05922050f, -0.07015631f, 0.15184663f, 0.30632830f, 
    -0.08569920f, 0.02338518f, -0.02420684f, -0.05019605f, -0.07463450f, 0.11451674f, 0.04664607f, 0.11420997f, 
    0.18856534f, -0.04879339f, 0.03394724f, 0.12708035f, 0.10778348f, -0.01416683f, 0.06902364f, 0.09500846f, 
    0.03451763f, 0.11159785f, 0.09940188f, 0.17892073f, 0.08132488f, 0.03741195f, 0.13864721f, 0.25722471f, 
    0.00142804f, 0.03332109f, 0.14177786f, -0.01806007f, -0.04637831f, -0.03923261f, 0.03450934f, 0.00965733f, 
    -0.06789342f, -0.01591555f, 0.02628332f, -0.23019244f, 0.17775971f, 0.12525366f, 0.04275287f, 0.02832656f, 
    0.00401438f, 0.05499820f, -0.01762431f, 0.11804551f, -0.07152808f, -0.02452438f, 0.06237685f, 0.04807203f, 
    -0.02370249f, -0.00933313f, 0.08346628f, -0.03481527f, 0.04042906f, 0.06850391f, 0.13149454f, 0.08771574f, 
    0.18813911f, 0.03193577f, 0.09338256f, 0.34210271f, 0.07121360f, 0.03430499f, 0.00190236f, 0.15899694f, 
    -0.02632377f, 0.04796888f, -0.06198099f, 0.06457931f, 0.13265426f, 0.02717896f, 0.10762406f, 0.02914751f, 
    0.07695121f, 0.01886518f, 0.04208414f, -0.10315872f, -0.06548363f, 0.16033995f, 0.02549482f, 0.02522773f, 
    -0.25630856f, -0.00773206f, -0.09023860f, -0.16995056f, 0.02675984f, 0.10265195f, 0.07449542f, -0.06805550f, 
    -0.04855065f, -0.03126074f, 0.01865746f, -0.05687233f, -0.28835911f, -0.07317682f, -0.06549052f, -0.25893545f, 
    0.02361733f, 0.00516963f, 0.00249704f, -0.10661849f, 0.14157419f, -0.05594327f, 0.00725937f, 0.02056759f, 
    -0.11849723f, -0.16834523f, -0.04093293f, 0.00123193f, 0.09929919f, -0.02603060f, -0.13993131f, 0.02460529f, 
    0.00683191f, 0.04311975f, 0.01164591f, 0.07763869f, -0.11065734f, -0.13147511f, 0.26900369f, -0.23821267f, 
    0.04684018f, 0.01327848f, 0.03504983f, 0.01673336f, 0.08450448f, 0.09364482f, 0.14796923f, -0.11528270f, 
    -0.10371250f, 0.01835077f, 0.05039057f, -0.13391370f, 0.11052086f, -0.03708093f, 0.03711609f, -0.11430351f, 
    -0.07778941f, 0.01206765f, -0.00756820f, 0.15049699f, 0.02169449f, 0.06210232f, 0.02472384f, 0.20295316f, 
    0.04939756f, 0.10352870f, 0.01623317f, 0.04290786f, 0.03585700f, 0.00640358f, 0.02518993f, 0.05205306f, 
    -0.24878162f, 0.25283495f, -0.15764280f, 0.05258739f, 0.15943913f, 0.03114885f, 0.02595421f, -0.06516910f, 
    0.00978161f, -0.08827619f, 0.08468278f, 0.08138964f, -0.25225505f, -0.02925861f, 0.01486278f, 0.07023564f, 
    0.19460578f, 0.05671604f, 0.03011017f, 0.00981321f, 0.08642653f, 0.07662904f, 0.03281034f, 0.10022823f, 
    -0.12250140f, 0.00601415f, 0.00375460f, 0.05554682f, 0.13182816f, -0.03828095f, -0.01538107f, 0.00813049f, 
    -0.00875294f, -0.02196468f, 0.05590774f, -0.01889148f, 0.04116613f, -0.05319576f, 0.05048506f, -0.13604906f, 
    -0.05462134f, 0.03006965f, 0.09143064f, 0.01339352f, -0.09933573f, 0.07811385f, 0.01390933f, 0.03976122f, 
    0.00024588f, 0.00317905f, -0.03923616f, -0.03270366f, -0.00564242f, -0.03477760f, 0.00002492f, -0.01111957f, 
    -0.02460327f, 0.00938608f, -0.03876017f, 0.02951618f, 0.02505358f, -0.03411685f, 0.00226080f, -0.01497322f, 
    -0.00356985f, -0.03738946f, 0.02972903f, 0.01420040f, -0.01001274f, -0.00296106f, -0.02394496f, 0.00495341f, 
    -0.02298255f, 0.02609565f, -0.00533406f, -0.00070498f, -0.02361497f, -0.01790874f, -0.01724871f, -0.01945460f, 
    -0.00052439f, -0.02683307f, -0.01853060f, -0.03185141f, -0.03538953f, 0.02321921f, -0.02351682f, 0.01290349f, 
    0.01886101f, -0.02831499f, -0.02401952f, -0.03515162f, 0.00051206f, 0.00925481f, 0.00428218f, 0.01526348f, 
    0.01798559f, -0.01897955f, -0.02721928f, 0.00002311f, -0.00686168f, -0.03477791f, 0.01629270f, -0.00426551f, 
    -0.02751666f, 0.00097314f, -0.02766574f, -0.03001010f, 0.02540940f, -0.01182014f, -0.00153343f, 0.02887109f, 
    0.01024786f, -0.00837105f, -0.03467775f, -0.03111296f, -0.00516265f, -0.00351579f, -0.00431328f, -0.01496110f, 
    -0.00603361f, 0.01333428f, -0.00262399f, 0.01407087f, 0.01095125f, 0.02231896f, -0.02700569f, -0.01337871f, 
    -0.01595197f, 0.02230212f, -0.01876009f, 0.02847531f, -0.01973924f, -0.02106343f, -0.01897463f, 0.01610263f, 
    0.01526709f, -0.03884989f, 0.01471121f, -0.02450266f, -0.00561007f, 0.01265840f, 0.01100339f, -0.00088572f, 
    0.00339734f, -0.03196710f, -0.00399904f, 0.00009537f, 0.02409173f, 0.00115492f, -0.01299398f, 0.00648509f, 
    0.00075505f, -0.03960603f, -0.00642705f, 0.02383074f, -0.03983060f, -0.01396917f, 0.02007302f, 0.01056178f, 
    -0.04042627f, -0.01458000f, -0.04045177f, 0.02250030f, -0.02984387f, -0.02453805f, 0.00321536f, 0.00000022f, 
    0.01544677f, 0.01223100f, 0.00169867f, -0.03844567f, 0.00588588f, 0.02483387f, -0.00394792f, -0.03673466f, 
    0.00626855f, 0.00482153f, -0.01887965f, 0.01624312f, 0.02137638f, 0.01376974f, -0.01967524f, -0.00115999f, 
    -0.00928937f, 0.01699578f, -0.02573603f, -0.03029995f, -0.02781089f, -0.01832590f, -0.02383939f, -0.00441587f, 
    -0.00954462f, -0.01474695f, -0.01312991f, -0.00254940f, -0.02515438f, -0.00982358f, -0.02884242f, -0.01363206f, 
    -0.00502146f, -0.02691649f, -0.04047480f, 0.00469792f, 0.02300722f, 0.00484079f, 0.00206071f, -0.00223076f, 
    0.01478126f, -0.02715221f, -0.00970604f, -0.02177784f, -0.03914219f, 0.01898945f, 0.02303191f, 0.01416331f, 
    -0.02224723f, -0.04205268f, 0.00057028f, -0.01222458f, -0.03234827f, -0.00711594f, 0.02919412f, -0.02766897f, 
    -0.00810272f, -0.02404277f, -0.02836722f, -0.02983265f, -0.01210615f, -0.02167825f, -0.01739362f, -0.00027013f, 
    -0.03575676f, -0.01723823f, -0.00511647f, -0.03751779f, -0.02773551f, 0.02251142f, -0.01542797f, 0.00365579f, 
    0.02217221f, -0.01298804f, 0.00642796f, 0.00792884f, 0.02240947f, 0.02639290f, -0.01245054f, 0.01789786f, 
    -0.01350386f, -0.00925375f, -0.03537885f, 0.00738788f, -0.00061583f, -0.01640183f, 0.00847671f, -0.02211547f, 
    0.00671540f, -0.02702582f, 0.02709356f, 0.02220177f, 0.02230233f, 0.00218217f, -0.01646930f, 0.02832643f, 
    -0.01724949f, 0.02218384f, -0.01278551f, 0.02811962f, 0.02056461f, 0.00081346f, -0.01080338f, 0.01025455f, 
    0.03832685f, -0.03919075f, 0.02933663f, -0.00248793f, 0.00820358f, 0.02286298f, -0.00541575f, 0.00042688f, 
    -0.00103086f, 0.02595783f, 0.02842551f, -0.00951979f, 0.02470649f, 0.01667233f, 0.01951488f, -0.03254971f, 
    0.02009503f, -0.00428400f, 0.00268490f, 0.00786389f, -0.00244627f, -0.01052456f, -0.02054759f, 0.02463020f, 
    -0.00246194f, 0.01782267f, -0.02005476f, -0.00662696f, 0.00796069f, 0.02353387f, -0.03338087f, -0.02358656f, 
    -0.03790355f, -0.03764838f, 0.02006998f, 0.01114346f, 0.01576134f, -0.03548559f, -0.03582929f, -0.03922796f, 
    0.02892796f, -0.03581292f, 0.02151273f, -0.03164490f, 0.01667200f, -0.03941211f, 0.01173007f, 0.01334037f, 
    -0.03356212f, -0.03635800f, 0.01624904f, -0.03703114f, 0.00831171f, 0.00390934f, -0.03717225f, 0.01159889f, 
    0.02742099f, 0.02859483f, 0.00244459f, 0.02631363f, 0.02585720f, -0.01915399f, 0.00632365f, -0.02352631f, 
    0.01117564f, -0.02747987f, 0.00603129f, -0.00749987f, 0.00141198f, 0.02740342f, 0.00348312f, -0.03640956f, 
    0.01934299f, 0.00373686f, -0.02327297f, 0.00770206f, -0.02621567f, 0.00714055f, -0.00499963f, -0.03239603f, 
    0.01377742f, -0.02761170f, -0.00913528f, -0.02593680f, -0.04072779f, -0.02625923f, -0.01085796f, -0.02497136f, 
    -0.01439973f, 0.00276373f, -0.04028917f, -0.01933540f, -0.03730433f, 0.00130864f, -0.00159437f, 0.02178099f, 
    0.01761693f, -0.03691038f, 0.01563060f, -0.03339098f, 0.00593158f, 0.02004533f, 0.00125058f, -0.02506542f, 
    0.02979484f, 0.01299554f, 0.01556360f, -0.02701943f, -0.00003896f, 0.00721541f, -0.00168248f, 0.00601724f, 
    -0.03781993f, -0.02289841f, 0.00312534f, 0.00719526f, 0.01156212f, 0.01800774f, 0.01829862f, -0.00473648f, 
    0.00770493f, 0.01565057f, 0.01536605f, 0.02196001f, -0.00398941f, -0.01205091f, 0.00251905f, -0.01878792f, 
    -0.00390916f, -0.04080104f, 0.02857270f, -0.03062529f, -0.00051079f, 0.00067637f, -0.03413488f, 0.01778421f, 
    0.00765333f, -0.01557442f, -0.01960535f, 0.01051624f, 0.02677398f, 0.02634053f, 0.02322168f, -0.03470327f, 
    -0.04032782f, 0.02058147f, -0.01738373f, 0.00496061f, 0.02553606f, -0.00426149f, -0.02772913f, 0.00914413f, 
    -0.04035829f, -0.02100602f, 0.00215303f, -0.03492757f, -0.00002815f, -0.02825995f, 0.00341420f, 0.00361136f, 
    0.02371407f, -0.00185518f, 0.02724511f, -0.02920331f, 0.00507764f, -0.02499782f, -0.00183450f, -0.02433432f, 
    0.00085934f, 0.01786773f, -0.03961065f, 0.02533124f, -0.00973020f, 0.00055107f, 0.00929675f, 0.02491705f, 
    -0.01896995f, -0.02149674f, -0.00007393f, 0.02843515f, -0.03610415f, -0.03325048f, -0.01489045f, 0.01360585f, 
    0.02614486f, -0.01290902f, -0.03257949f, 0.00974434f, -0.03772533f, 0.02128317f, -0.03020454f, -0.02976819f, 
    0.01254314f, -0.00284753f, 0.01531697f, 0.02643866f, 0.00517342f, -0.04024905f, -0.03048495f, -0.00994545f, 
    -0.03837056f, 0.02327120f, -0.03870034f, -0.02060775f, 0.00553283f, 0.01623172f, -0.00509194f, 0.02546168f, 
    -0.03876111f, 0.00565383f, -0.01481817f, -0.03433908f, -0.03014012f, 0.00111949f, 0.00381205f, 0.02710430f, 
    0.01768259f, -0.02806265f, -0.02745694f, 0.00073635f, -0.00727245f, 0.00864062f, -0.03780486f, -0.02090850f, 
    -0.00875443f, -0.00368186f, -0.00287851f, -0.02383737f, -0.00350829f, -0.01244613f, -0.02464207f, 0.01955738f, 
    0.00235372f, 0.00157515f, -0.03600201f, -0.01859919f, 0.00121233f, 0.01333311f, -0.02800147f, 0.02142339f, 
    0.01975048f, -0.03247910f, 0.01744098f, -0.03240556f, -0.00676922f, -0.01824014f, -0.02862793f, -0.00135926f, 
    0.01931395f, -0.01771702f, 0.03005748f, -0.00338761f, 0.00675708f, -0.03009808f, 0.01357127f, -0.01870346f, 
    -0.01944319f, -0.01526727f, 0.00690055f, -0.03277154f, -0.00858120f, -0.01685560f, -0.01778711f, -0.02970134f, 
    0.02548576f, -0.00783362f, -0.00407489f, 0.01213002f, -0.01413666f, -0.02109892f, -0.02582588f, 0.00291095f, 
    -0.03399936f, 0.01898731f, -0.03721876f, -0.00677049f, -0.00816936f, -0.02660543f, 0.00177558f, 0.00153247f, 
    -0.01289493f, -0.00785792f, 0.02355535f, -0.03137970f, -0.00341809f, -0.03080598f, -0.02940160f, 0.02798399f, 
    -0.01618550f, -0.02769143f, 0.00680309f, -0.01758007f, -0.01207300f, -0.02512774f, -0.01051807f, 0.02450504f, 
    -0.01595044f, 0.01453323f, -0.03858410f, 0.00542631f, 0.02852819f, 0.01978496f, 0.01856699f, -0.03301129f, 
    0.02590253f, -0.00548974f, 0.00723258f, 0.00761281f, 0.01538662f, -0.00439190f, -0.03373603f, 0.01764992f, 
    -0.00204549f, -0.01794502f, -0.03282410f, -0.03779220f, 0.02022442f, 0.01034268f, 0.02489511f, -0.00306265f, 
    -0.00213588f, 0.01819179f, -0.02040343f, 0.02197078f, -0.00445866f, -0.00597726f, 0.02881652f, -0.00446013f, 
    -0.00480564f, 0.00672781f, -0.03469408f, 0.00785737f, 0.00390383f, 0.00220918f, -0.02363140f, 0.00970839f, 
    0.01527298f, -0.01126460f, 0.01634244f, -0.01837217f, 0.01554427f, -0.01214585f, -0.01939577f, -0.01170512f, 
    -0.00518789f, -0.01186216f, -0.04202649f, -0.01400708f, 0.01383834f, 0.01004888f, -0.01568625f, -0.02004814f, 
    -0.01887257f, 0.02739511f, -0.03515307f, 0.00215669f, 0.02089915f, -0.01212515f, 0.01145990f, 0.00546977f, 
    0.02863377f, 0.02906175f, 0.00232942f, -0.00372099f, -0.01526604f, -0.02201656f, 0.01047339f, -0.02384375f, 
    -0.03177426f, 0.01411480f, 0.01053437f, -0.03908416f, 0.02051357f, -0.02102942f, 0.01352115f, 0.00094090f, 
    0.01756866f, -0.03007682f, -0.00587179f, -0.03953198f, -0.04100129f, -0.01253900f, 0.00612013f, 0.01454872f, 
    -0.01902058f, 0.01999154f, 0.00638183f, -0.00257068f, -0.02361859f, 0.01281470f, 0.01019406f, -0.03914430f, 
    -0.00753173f, 0.02761235f, 0.02918001f, -0.01940374f, -0.02372309f, 0.02309269f, -0.00389680f, 0.00799900f, 
    -0.03426690f, -0.00178629f, 0.00679810f, 0.00410784f, -0.02811062f, -0.04175801f, -0.03966785f, -0.02009425f, 
    -0.02791263f, -0.03462577f, 0.00628148f, -0.02160466f, -0.01795691f, -0.02078982f, 0.01165651f, 0.00977615f, 
    0.02683585f, -0.01050154f, 0.02168054f, -0.03937577f, -0.03947078f, -0.00455886f, 0.01253890f, -0.01573700f, 
    -0.00912353f, -0.02017925f, 0.01771401f, -0.04082485f, 0.01948396f, 0.01292913f, -0.02395338f, -0.02240969f, 
    -0.04175036f, -0.00684387f, 0.00704863f, 0.00988872f, -0.02448413f, -0.03334570f, -0.00179047f, -0.01746874f, 
    -0.03958156f, -0.02851941f, -0.01767342f, -0.04074183f, 0.01712256f, -0.02078992f, -0.02030817f, -0.03970051f, 
    0.01500624f, -0.03149693f, 0.02915283f, -0.03010282f, -0.03183820f, -0.02802934f, 0.00023451f, -0.00541783f, 
    0.00362456f, 0.02689519f, -0.02814731f, 0.02425023f, 0.01014328f, -0.02827277f, 0.01014458f, 0.01425074f, 
    0.00548682f, -0.01808936f, -0.00530729f, 0.01803569f, -0.03549592f, -0.00307654f, -0.00552408f, -0.04207027f, 
    0.01856258f, 0.00121535f, -0.01792037f, -0.00562365f, 0.01325084f, -0.00732034f, -0.00146766f, -0.03904637f, 
    0.00215422f, -0.02080325f, -0.02801546f, -0.00938936f, 0.01264623f, 0.00169472f, -0.00354329f, 0.02318501f, 
    -0.00841942f, 0.01633229f, -0.02899527f, 0.02602018f, -0.02318043f, -0.00246093f, -0.00841726f, -0.00653071f, 
    -0.01159432f, -0.00884222f, -0.01098124f, 0.00857410f, -0.02835064f, -0.02335154f, -0.00229461f, 0.02478896f, 
    -0.03877147f, -0.03799715f, -0.01912099f, -0.01599786f, -0.00194197f, -0.02665672f, -0.02942705f, 0.01730086f, 
    -0.03653979f, 0.02264253f, -0.01425042f, -0.02803751f, 0.01981937f, 0.02923653f, 0.01214703f, -0.01922124f, 
    0.01458906f, -0.02028218f, -0.02474365f, 0.00991000f, -0.00012848f, -0.02153267f, 0.01670323f, -0.01588630f, 
    0.02774214f, -0.00769201f, 0.01298147f, -0.00728050f, -0.03642072f, 0.00324070f, -0.03880065f, -0.02721596f, 
    -0.01921740f, -0.01804448f, 0.01062775f, -0.00685269f, 0.01300227f, -0.01089061f, -0.03523259f, -0.02704176f, 
    -0.10738128f, -0.28377551f, 0.02885272f, -0.04188380f, 0.00117703f, -0.00052263f, -0.01570270f, -0.05222486f, 
    -0.03749010f, -0.00886700f, 0.02264581f, 0.02162452f, -0.42842531f, -0.00685213f, 0.03937868f, 0.13785429f, 
    0.01029957f, -0.00736673f, -0.04710481f, -0.00466204f, 0.04052969f, -0.03945612f, -0.03148340f, -0.06160918f, 
    0.07648112f, -0.16448836f, 0.23757032f, 0.17758173f, 0.09063865f, 0.00325393f, 0.01571693f, -0.07289916f, 
    -0.06681225f, 0.03676971f, -0.11872096f, 0.05400060f, 0.25913638f, 0.26307470f, 0.07548893f, 0.05981031f, 
    -0.02013551f, -0.06267107f, 0.02609732f, -0.01861295f, -0.04560104f, 0.07729775f, -0.01435454f, 0.15081738f, 
    0.10798057f, -0.22488898f, -0.01649760f, 0.19974387f, -0.07291722f, 0.02279004f, 0.00976022f, 0.00354406f, 
    0.11784678f, 0.04216167f, 0.09100808f, 0.05221430f, -0.03346314f, 0.01917513f, -0.08885136f, -0.05447446f, 
    -0.10282624f, 0.13180174f, -0.04633372f, 0.05036069f, 0.06543269f, 0.08683435f, 0.00505638f, -0.11798810f, 
    0.34901816f, 0.18051772f, -0.13752005f, 0.02537206f, -0.03100911f, -0.10023287f, 0.01887182f, 0.04549076f, 
    -0.01468122f, 0.02450073f, 0.06903794f, -0.02573536f, -0.00200162f, -0.31198576f, 0.15815915f, 0.22533755f, 
    -0.22289097f, 0.07565873f, -0.03083203f, 0.00453887f, -0.03882294f, 0.08092697f, 0.03282014f, 0.02618188f, 
    0.08704709f, -0.00257043f, 0.14593413f, 0.07587062f, 0.03407761f, -0.01528109f, 0.04902239f, -0.00655763f, 
    0.01995850f, -0.03212017f, -0.06989706f, 0.04927482f, 0.09070694f, 0.03493061f, -0.22305278f, 0.19081986f, 
    0.01286072f, 0.09885910f, 0.04761363f, 0.02753719f, 0.04706160f, -0.01488303f, 0.13882762f, -0.02936130f, 
    0.20908256f, -0.17325467f, -0.19569628f, 0.07037141f, 0.12370073f, -0.04873160f, 0.10205013f, 0.07299186f, 
    -0.05013576f, -0.10076376f, -0.04810396f, 0.11570299f, 0.24554703f, 0.03328486f, -0.13809240f, 0.12983644f, 
    0.02584233f, -0.02592673f, 0.03807161f, 0.00017949f, 0.01696945f, 0.05646532f, 0.06431131f, 0.07558519f, 
    -0.20962730f, 0.07377609f, 0.06026692f, 0.00816754f, 0.05531653f, -0.02172754f, -0.04557000f, -0.01465468f, 
    -0.04576216f, 0.06056295f, -0.00010919f, 0.07775757f, -0.33887723f, 0.09942742f, -0.04306297f, -0.23259903f, 
    -0.04548769f, 0.14387548f, -0.06972859f, -0.00523410f, 0.07564517f, 0.02850787f, 0.01481173f, 0.00249752f, 
    0.09835859f, 0.23784670f, -0.14387512f, -0.06479812f, 0.04259201f, 0.00019184f, -0.01667072f, 0.02695031f, 
    0.09170638f, 0.05147788f, 0.04262044f, 0.01311619f, 0.14743906f, 0.13284475f, 0.02368201f, -0.17706572f, 
    -0.06516849f, 0.02652706f, 0.01498242f, 0.04698463f, 0.02202776f, 0.04787310f, 0.03285391f, -0.01458878f, 
    0.45405832f, -0.19313994f, -0.07105136f, 0.06147822f, 0.10498356f, 0.03030416f, -0.02328249f, 0.04417874f, 
    0.04367249f, 0.10482012f, 0.02152579f, 0.11611147f, -0.03145668f, -0.18466489f, -0.04930053f, 0.14729030f, 
    0.04294341f, -0.00088420f, 0.02440695f, 0.06199063f, -0.00513425f, 0.04403877f, 0.06160825f, 0.02221497f, 
    0.15939146f, 0.03798021f, -0.39041203f, -0.02967096f, 0.07062178f, 0.00795835f, -0.00746623f, 0.08328602f, 
    0.01462916f, 0.01082935f, -0.02806390f, 0.10811286f, -0.02107836f, 0.20733984f, 0.06818298f, -0.06917719f, 
    -0.11444228f, -0.00025122f, -0.08375012f, -0.01582910f, 0.05216977f, -0.09308259f, 0.02693324f, 0.05983819f, 
    0.19416399f, 0.03814203f, -0.07958032f, -0.02607442f, -0.11255962f, -0.02036224f, 0.01580763f, 0.01418016f, 
    0.06481056f, 0.03006224f, 0.05886208f, 0.00963912f, -0.15413164f, 0.19650935f, 0.03916924f, -0.00515572f, 
    0.10071174f, 0.04531207f, 0.03347943f, 0.04530020f, 0.10146113f, 0.09040760f, -0.07159269f, 0.01879919f, 
    -0.38350558f, 0.22506009f, 0.06676572f, 0.01102996f, 0.03775607f, -0.02095888f, -0.05857383f, 0.04468019f, 
    -0.13057208f, 0.07068259f, -0.12906668f, 0.02970025f, 0.04162414f, 0.11710924f, 0.06688483f, 0.10863690f, 
    -0.05981781f, 0.14949307f, 0.01816380f, 0.05304312f, 0.07840411f, 0.05232603f, 0.02669115f, 0.03235810f, 
    0.10093933f, -0.06210721f, 0.00232640f, 0.09598764f, -0.09896756f, 0.06190894f, 0.00607657f, 0.00622168f, 
    0.00097693f, 0.01855702f, -0.04636931f, -0.04632195f, -0.03693806f, -0.09764215f, -0.10135414f, 0.01201156f, 
    -0.01150919f, -0.07256912f, 0.07889514f, 0.00872806f, 0.09611069f, -0.01410155f, 0.04401820f, -0.04556837f, 
    0.19903003f, 0.26587796f, 0.05828733f, 0.00118907f, -0.06917014f, -0.07091356f, 0.00584615f, -0.03727553f, 
    0.01047763f, 0.05205878f, 0.11891859f, 0.01744463f, -0.26282501f, -0.12684567f, 0.10459527f, -0.09316739f, 
    -0.06416871f, 0.02152621f, 0.06834493f, 0.08473099f, 0.22474453f, 0.05373342f, -0.07252189f, 0.04717552f, 
    0.29224184f, -0.00883935f, -0.13878225f, 0.02665912f, 0.01687909f, 0.01164944f, -0.09333914f, 0.10382966f, 
    0.08218775f, 0.10594747f, 0.00861459f, 0.03075884f, 0.06643886f, 0.06117049f, -0.00845440f, -0.22742416f, 
    0.00192054f, 0.00749282f, -0.02480291f, 0.03751307f, 0.05060311f, 0.04913722f, -0.00588340f, 0.08421320f, 
    0.40146330f, 0.02862461f, -0.10351008f, 0.03072614f, -0.11081900f, -0.10078979f, -0.02996554f, 0.04920236f, 
    0.03526293f, -0.11252026f, 0.03224480f, 0.04465956f, -0.10592195f, 0.09119577f, -0.01631278f, 0.09817342f, 
    0.01757908f, 0.06173477f, -0.05212022f, 0.15384172f, 0.04386548f, 0.03321895f, 0.06979032f, -0.10931143f, 
    -0.15594417f, -0.24768858f, 0.03352303f, 0.15218900f, 0.00642749f, 0.06578191f, -0.01405265f, 0.05821960f, 
    0.01512949f, -0.05991041f, 0.05757650f, 0.00631025f, 0.04491538f, 0.03130987f, 0.00990556f, -0.05337624f, 
    -0.00369993f, -0.11924712f, -0.00906904f, 0.05436885f, -0.01426740f, 0.10680303f, 0.02153273f, -0.11195676f, 
    -0.08030554f, 0.15449089f, 0.05328057f, 0.09564625f, -0.10294154f, -0.09285574f, 0.04363253f, -0.05794164f, 
    0.02450627f, 0.00726282f, 0.09194143f, -0.03445487f, 0.12653111f, -0.03394245f, -0.02100241f, -0.08700227f, 
    -0.12879197f, -0.03153241f, 0.01950943f, -0.02847024f, 0.00746625f, 0.00413730f, -0.04201804f, 0.00270664f, 
    0.37362477f, -0.15951301f, -0.10356134f, -0.06166634f, 0.01842330f, 0.02721947f, -0.00921858f, 0.05645452f, 
    0.01464428f, 0.04596352f, -0.01461362f, 0.10800277f, 0.21123788f, -0.34750506f, -0.01683136f, 0.38061830f, 
    0.00646222f, -0.00526267f, 0.01833766f, 0.00247708f, 0.11630534f, 0.03912784f, -0.01392334f, 0.01009461f, 
    -0.17226276f, -0.02115638f, 0.16450597f, 0.11218000f, 0.07283392f, -0.04570246f, -0.05925252f, 0.06260932f, 
    0.09841798f, 0.18715428f, 0.04359270f, -0.00004004f, -0.44557539f, 0.24985689f, -0.14058720f, 0.17665003f, 
    0.07180815f, -0.03695296f, 0.00579130f, -0.05030194f, 0.03898455f, -0.01194542f, -0.01376588f, 0.09357084f, 
    -0.03876987f, 0.01764131f, 0.00980278f, 0.22564654f, -0.00796509f, 0.01125301f, 0.07680079f, 0.04942755f, 
    0.13607268f, 0.09182481f, -0.10251562f, 0.01236974f, 0.17717664f, 0.08747732f, 0.05831724f, -0.02869112f, 
    -0.02151913f, 0.07715709f, 0.03567327f, 0.03852111f, 0.04680005f, 0.18834874f, 0.04601205f, -0.03759567f, 
    0.07390092f, 0.03081519f, -0.20314841f, 0.11687396f, -0.01043565f, -0.13183880f, 0.08839899f, 0.02468014f, 
    0.00594810f, 0.01262726f, -0.01494529f, -0.00409285f, -0.34588501f, -0.04796069f, 0.08197798f, 0.15822940f, 
    0.09175311f, 0.07347206f, -0.02754161f, 0.02350917f, -0.10298826f, -0.05307172f, 0.08413381f, -0.05117157f, 
    0.15783453f, 0.10558563f, 0.17339934f, 0.05091496f, -0.23753859f, -0.04341664f, -0.02278461f, 0.11370061f, 
    0.01009974f, 0.06510411f, 0.02951227f, 0.03366736f, 0.43424574f, -0.08318731f, -0.06008757f, 0.14602596f, 
    -0.07871434f, 0.02564342f, 0.03105325f, -0.02593511f, 0.01882595f, 0.02126941f, -0.03442826f, -0.02206454f, 
    0.16380350f, -0.07947607f, -0.08744801f, 0.11870115f, -0.02254599f, 0.02274479f, -0.04064012f, -0.03352188f, 
    0.06402522f, 0.06688844f, 0.07199328f, 0.04165695f, 0.02686563f, 0.28530231f, -0.02258961f, -0.22092438f, 
    -0.07908469f, 0.01461026f, 0.12873909f, 0.00071867f, 0.03946513f, -0.06432506f, -0.04095137f, -0.06845679f, 
    0.19356875f, -0.07214066f, -0.07728747f, 0.09480505f, -0.09877952f, 0.14631014f, 0.07927110f, 0.04296015f, 
    0.02865154f, -0.09878226f, -0.02546156f, -0.07606556f, 0.03202130f, -0.00238666f, -0.00187321f, -0.02442299f, 
    -0.03384728f, 0.07096177f, -0.04255461f, 0.08767994f, 0.09902690f, 0.04955534f, -0.08149486f, 0.02301976f, 
    0.10527003f, -0.10502850f, -0.09987982f, 0.18456097f, 0.07043366f, -0.10195840f, 0.05671488f, 0.04114430f, 
    0.12130524f, -0.02331822f, 0.00434731f, 0.08691962f, -0.08294377f, -0.01555107f, -0.09759340f, 0.12575890f, 
    0.06659225f, 0.00181099f, -0.01966567f, 0.04654166f, 0.05890702f, -0.11854031f, -0.06535695f, 0.04409660f, 
    0.23984897f, 0.28285819f, -0.04529127f, 0.09485665f, 0.00572408f, 0.13338661f, 0.06049543f, -0.00630511f, 
    0.16278566f, 0.07479730f, -0.04820029f, 0.00656058f, -0.02726854f, 0.14020716f, -0.06218493f, 0.09564380f, 
    -0.07928174f, 0.03583860f, -0.07356753f, 0.08079862f, -0.02351017f, -0.06069762f, -0.01875242f, 0.07124058f, 
    0.04665597f, -0.02510039f, -0.19026092f, 0.29757699f, 0.05276157f, -0.05769421f, -0.01812077f, 0.06612965f, 
    0.11886481f, -0.06579429f, -0.00931165f, 0.07854889f, 0.11300805f, -0.17252693f, 0.08727052f, 0.08119082f, 
    0.06332745f, 0.01352176f, -0.04022501f, 0.02463106f, -0.07217482f, 0.00819456f, -0.00846102f, -0.00554476f, 
    -0.00681916f, 0.15438525f, -0.13082130f, -0.00252497f, -0.16581514f, 0.08889468f, 0.01754923f, 0.13032615f, 
    0.11510750f, 0.00041840f, 0.06166562f, 0.07145978f, -0.06396422f, -0.03889165f, -0.08362629f, 0.22027229f, 
    0.04961358f, 0.00057199f, -0.08452410f, 0.01205118f, 0.00521144f, -0.04876218f, 0.05028944f, 0.01941831f, 
    -0.08146813f, -0.21327978f, 0.12458228f, 0.00400508f, -0.11740491f, -0.05712571f, 0.00643473f, -0.02542304f, 
    -0.02081067f, 0.01360497f, 0.03629825f, -0.12163733f, 0.16933028f, 0.08577992f, 0.19031531f, 0.13209659f, 
    -0.00266290f, -0.11434292f, 0.13866271f, -0.00930071f, 0.03235540f, 0.05243184f, -0.06630206f, 0.09948824f, 
    0.27541310f, -0.16592388f, -0.00275719f, 0.13747495f, -0.03002959f, -0.06444097f, -0.00376891f, 0.00142470f, 
    0.10129588f, 0.01764626f, -0.00517997f, -0.00908513f, 0.24680834f, -0.06390972f, -0.13382590f, -0.15626371f, 
    0.00690198f, 0.11060071f, -0.09062652f, 0.09896339f, 0.07188616f, 0.09511302f, -0.05920774f, 0.01408677f, 
    0.06108639f, 0.12895384f, -0.04736371f, 0.18796390f, -0.04924108f, 0.00654962f, 0.01769873f, 0.10625987f, 
    -0.01264749f, -0.03834808f, 0.01299166f, 0.04533545f, 0.05714798f, 0.23445952f, 0.11510619f, -0.08961982f, 
    -0.12432402f, -0.01959338f, -0.12779160f, 0.06521853f, 0.07166999f, 0.04096486f, 0.01299610f, -0.03835826f, 
    -0.01639684f, 0.00148144f, -0.01989083f, 0.03168902f, 0.00479942f, -0.03087785f, 0.01697038f, -0.01669228f, 
    -0.02648893f, -0.00512454f, 0.00650927f, 0.01518583f, -0.00894942f, 0.02905290f, 0.00370131f, -0.02285540f, 
    0.01564671f, -0.00136070f, 0.02357248f, -0.02325705f, -0.03368073f, -0.01614100f, 0.01305496f, -0.00986596f, 
    -0.02062834f, -0.03861300f, -0.01038400f, -0.01479183f, 0.02181249f, -0.03556500f, -0.00509402f, -0.00627052f, 
    -0.01706761f, -0.00534699f, 0.02714918f, 0.02753563f, 0.02182813f, 0.03409089f, 0.02444368f, 0.01321099f, 
    0.00656981f, 0.01311891f, -0.03096631f, 0.01467022f, 0.02014460f, -0.02766549f, -0.01118857f, 0.01694463f, 
    -0.02644723f, -0.01256838f, 0.02833102f, -0.01064399f, -0.02089571f, 0.02187025f, 0.01588905f, 0.00981820f, 
    -0.02119099f, 0.00403065f, 0.02174536f, -0.04145972f, -0.01780638f, -0.00261034f, 0.02345242f, 0.00381016f, 
    0.02236789f, -0.01018266f, -0.02564313f, -0.02257991f, -0.02362672f, -0.02997300f, -0.01703505f, 0.00819627f, 
    -0.03032175f, -0.01508874f, 0.01529209f, -0.03848933f, 0.00131335f, -0.01504982f, 0.01221627f, 0.01900564f, 
    -0.01582267f, -0.01806138f, -0.02075322f, 0.02287251f, 0.02333108f, -0.03289162f, -0.02450879f, 0.00612631f, 
    -0.02793717f, 0.00236453f, 0.02056948f, 0.03186350f, -0.00638217f, 0.01342167f, 0.02506026f, -0.03587836f, 
    -0.01517234f, 0.02640720f, 0.02770503f, -0.03734681f, 0.01690626f, 0.02761329f, 0.03325973f, -0.00920276f, 
    -0.01053152f, -0.00709257f, 0.02286594f, -0.02733826f, 0.02914887f, 0.02951376f, -0.02695216f, -0.03137702f, 
    -0.00450072f, 0.02359406f, -0.01722660f, -0.00800460f, -0.01324725f, -0.01677283f, 0.00713027f, -0.01386983f, 
    0.00550196f, -0.04155019f, 0.02527123f, -0.00522097f, -0.01436379f, -0.02148443f, 0.00355420f, 0.00920134f, 
    0.02554389f, 0.03198081f, -0.02649887f, -0.02410479f, -0.03126511f, -0.03224544f, 0.02458671f, -0.00729710f, 
    -0.00972487f, -0.01627292f, 0.02206097f, -0.01413057f, 0.00650215f, -0.00866394f, -0.00048305f, 0.02353644f, 
    -0.03463313f, -0.02202739f, 0.01468022f, 0.00494630f, 0.02578511f, -0.02216953f, -0.03300790f, -0.01722018f, 
    -0.00722875f, 0.00993655f, -0.03510262f, 0.02809010f, 0.00525255f, -0.00449131f, -0.01214735f, 0.02402501f, 
    -0.01949621f, 0.00079996f, -0.00522242f, 0.00428992f, 0.00032240f, 0.00690682f, 0.01603361f, 0.01946190f, 
    -0.02942000f, -0.00642622f, -0.01360660f, 0.01317998f, -0.02593831f, -0.00263082f, -0.01498202f, -0.00925191f, 
    0.02832657f, 0.01051701f, -0.02259442f, -0.02275068f, -0.00923801f, -0.02272449f, 0.02118394f, 0.02034104f, 
    -0.04178682f, 0.01481851f, 0.00140674f, -0.03461349f, 0.02012886f, 0.02747335f, 0.02615682f, 0.00781441f, 
    -0.02339742f, 0.01639078f, 0.02035990f, -0.01543297f, 0.00956980f, -0.03271379f, 0.01551683f, -0.01138491f, 
    -0.01308638f, -0.02754422f, -0.03381050f, 0.01411760f, 0.01308505f, -0.00163019f, 0.01708434f, 0.02118529f, 
    -0.01347923f, -0.03187615f, 0.02958240f, 0.01094147f, 0.02780964f, -0.02507823f, 0.02189292f, -0.02843367f, 
    0.01432628f, -0.03085019f, 0.01089177f, -0.00104094f, -0.02929315f, -0.02394981f, -0.00688427f, 0.00346440f, 
    -0.04005860f, -0.03536391f, 0.00331272f, 0.02588219f, -0.03285879f, 0.00684880f, 0.02277784f, 0.00394311f, 
    0.02003441f, 0.02367341f, -0.01326554f, -0.02368040f, -0.02805811f, 0.00966638f, 0.02504859f, -0.00591650f, 
    -0.02518892f, 0.01443149f, 0.01486464f, 0.00183543f, 0.02094492f, 0.01091044f, -0.01704921f, -0.00651330f, 
    -0.03817339f, -0.01357914f, 0.03169322f, 0.02813678f, -0.01175501f, 0.02213250f, 0.00088647f, 0.01034252f, 
    -0.02591245f, 0.01022062f, 0.01398608f, 0.01297264f, 0.02133042f, -0.01018931f, 0.00603056f, -0.01163772f, 
    0.02939058f, -0.00738679f, 0.01281956f, 0.01574209f, -0.03280454f, -0.02010464f, -0.02539273f, -0.02956508f, 
    0.02931594f, -0.03175364f, 0.01913664f, 0.00449259f, -0.02429680f, 0.01216374f, 0.02512316f, 0.00728260f, 
    -0.00840820f, -0.00279231f, -0.00103196f, -0.03684244f, 0.01733483f, -0.03342667f, 0.00172432f, 0.03167708f, 
    -0.00371829f, -0.01500378f, -0.03220881f, -0.02660559f, 0.02546653f, -0.03156988f, 0.03020864f, 0.01032846f, 
    0.01160796f, 0.01621578f, -0.01855526f, -0.00812271f, 0.02063356f, 0.01387279f, 0.00473749f, 0.00019544f, 
    0.01723495f, 0.00857364f, 0.00975582f, -0.03657350f, 0.02202853f, 0.00090703f, -0.00624136f, 0.02739233f, 
    0.00946174f, 0.02061158f, -0.03146045f, -0.03658752f, 0.02408205f, 0.00937538f, 0.00316861f, -0.03248202f, 
    0.02232514f, -0.03441273f, 0.02710842f, 0.01019489f, 0.02468307f, -0.02411857f, 0.01806308f, -0.04559257f, 
    -0.00894921f, -0.03664742f, 0.03217886f, 0.02600608f, -0.00551052f, -0.03325628f, 0.02172579f, 0.00200606f, 
    0.00275652f, -0.02786801f, -0.03789308f, -0.02068034f, 0.02825628f, -0.00917889f, 0.00077626f, -0.01485657f, 
    0.02896561f, 0.00501348f, -0.01234654f, 0.01341434f, -0.02641468f, 0.01108193f, 0.01522304f, -0.00316440f, 
    -0.00910585f, -0.03360768f, -0.01329374f, 0.01917325f, 0.00893387f, 0.02840966f, -0.01169323f, -0.00842688f, 
    0.00129095f, 0.01584748f, -0.00969047f, -0.02905299f, 0.02928331f, 0.01213951f, 0.00582110f, -0.03818915f, 
    0.02426707f, 0.00530102f, -0.03374946f, 0.01515679f, 0.04057743f, 0.02601301f, 0.01638781f, 0.00524683f, 
    -0.00598036f, 0.02535379f, 0.02229321f, -0.01245274f, -0.01503685f, -0.02341060f, -0.01925155f, 0.02472506f, 
    -0.03361281f, -0.01291853f, 0.03378613f, -0.03740065f, 0.02782051f, 0.02012084f, -0.00008348f, 0.01505428f, 
    -0.03369511f, -0.03726259f, 0.00437232f, 0.02236768f, -0.03448674f, -0.00064849f, -0.02717677f, -0.01044159f, 
    -0.02919739f, -0.03526459f, 0.01197434f, -0.00370560f, -0.00780613f, 0.02532815f, 0.01838048f, -0.02653316f, 
    0.00778920f, -0.02604357f, 0.01167936f, 0.02469957f, -0.02656147f, -0.02049508f, 0.00458721f, 0.01600914f, 
    -0.01342537f, -0.00737057f, 0.00892520f, 0.01263911f, 0.00319611f, 0.02402367f, -0.00149921f, -0.01108210f, 
    -0.02876555f, 0.01557524f, -0.01525068f, -0.01473364f, 0.00691903f, -0.00772173f, -0.00713099f, -0.02514876f, 
    0.01918681f, 0.02556469f, -0.02249471f, 0.01427875f, 0.01301411f, 0.01653732f, 0.01353358f, -0.01888909f, 
    -0.01006956f, -0.00330192f, -0.03105288f, -0.01438398f, -0.01855809f, 0.00137654f, 0.01610864f, 0.03005919f, 
    -0.00328584f, -0.01662900f, 0.00073918f, -0.02608929f, 0.00904933f, 0.01213043f, 0.00574675f, 0.03389037f, 
    -0.01888776f, -0.03462847f, -0.00818635f, -0.00104326f, -0.02447469f, 0.00467579f, -0.01771072f, -0.03676612f, 
    -0.03479326f, -0.02607127f, 0.02476527f, -0.03542785f, -0.02343783f, -0.01853525f, -0.04223435f, 0.00725293f, 
    -0.02964189f, -0.00592628f, -0.01861086f, 0.00979020f, -0.03124217f, -0.02910961f, 0.00605386f, -0.00711465f, 
    -0.02149931f, -0.02391685f, 0.02180255f, 0.00063944f, 0.01457263f, 0.00385551f, 0.02739209f, -0.04028501f, 
    0.02592149f, 0.01326908f, -0.01924461f, -0.00602661f, -0.00353960f, 0.00052983f, -0.02449975f, 0.02811922f, 
    0.01213615f, -0.00760610f, -0.00885363f, 0.01948899f, -0.02805463f, 0.00656281f, -0.03002148f, -0.03330864f, 
    -0.01853835f, 0.01224218f, -0.01303368f, -0.03243509f, -0.00389130f, -0.03032428f, -0.02878184f, -0.01943276f, 
    -0.01755064f, -0.02922525f, 0.00870312f, 0.03282389f, 0.00159177f, -0.03355733f, -0.03433267f, -0.01169225f, 
    -0.01221284f, -0.00166383f, 0.01613846f, 0.00638795f, -0.01023543f, 0.02111936f, -0.01542212f, -0.02250273f, 
    -0.00526004f, -0.03600904f, -0.01997913f, 0.02374419f, -0.01444831f, -0.02913482f, 0.01887026f, -0.03550826f, 
    -0.01970998f, -0.03440833f, 0.00807398f, 0.01755979f, 0.03098629f, 0.01364853f, -0.02315498f, -0.00808289f, 
    -0.00443336f, 0.02679356f, -0.03570891f, -0.02909084f, -0.02727961f, -0.01027146f, -0.01593850f, -0.00554185f, 
    0.01866448f, -0.00292511f, -0.02077189f, -0.00638086f, -0.00776272f, -0.02751463f, -0.01478847f, -0.00783307f, 
    -0.02958864f, -0.00523532f, -0.00892981f, -0.02669235f, -0.00230078f, -0.03501411f, 0.01866132f, -0.00375597f, 
    -0.01323131f, 0.00847746f, -0.02865052f, -0.02135178f, 0.01390379f, -0.04070272f, -0.01286099f, -0.00687524f, 
    0.00478710f, -0.02856291f, 0.01341901f, -0.00564498f, 0.01597528f, -0.01108527f, 0.02508329f, -0.01421462f, 
    -0.02312134f, 0.02517989f, -0.03409265f, -0.04229973f, 0.03175990f, -0.02610898f, -0.01582184f, -0.03559465f, 
    -0.02121080f, -0.02941259f, 0.00851952f, 0.02759368f, -0.01506564f, 0.01593146f, -0.02273406f, 0.02633687f, 
    -0.02961501f, -0.01927665f, -0.03834414f, 0.01637044f, -0.01394104f, 0.01849917f, -0.02858314f, -0.00943065f, 
    -0.03188035f, 0.03130981f, -0.04008276f, -0.02351641f, -0.03319813f, 0.00710959f, 0.01931603f, 0.01849395f, 
    -0.02600164f, -0.00979471f, -0.02041948f, 0.00226654f, -0.03178291f, -0.01815443f, 0.02553958f, 0.03071764f, 
    0.02624188f, -0.02807834f, -0.01126666f, -0.03781980f, 0.00309825f, -0.02021169f, -0.00098934f, -0.01071197f, 
    -0.00177084f, 0.00095904f, -0.04080207f, -0.02427198f, -0.01946021f, -0.01001397f, 0.02586746f, 0.00599336f, 
    0.02375985f, -0.02727854f, -0.01740016f, -0.03415130f, -0.02260176f, -0.01668477f, 0.00766792f, -0.02775062f, 
    0.01616448f, -0.02121425f, -0.00925015f, -0.01544607f, 0.02927393f, 0.01437896f, -0.00685683f, 0.00933576f, 
    0.01489333f, 0.00368191f, 0.01159947f, 0.01307796f, -0.00483988f, -0.01219504f, -0.03147873f, -0.00498628f, 
    -0.01029746f, 0.01696329f, -0.00491511f, 0.02126619f, -0.00055417f, -0.00938356f, 0.00893365f, 0.00926097f, 
    -0.02116087f, -0.00571008f, 0.01725237f, 0.03055660f, -0.01874948f, 0.02162079f, -0.00853482f, -0.03459701f, 
    0.01973590f, 0.01678762f, 0.02536115f, -0.04464560f, 0.01648588f, 0.02008643f, 0.02122338f, 0.01076358f, 
    0.00466053f, -0.04138589f, 0.00414883f, -0.02169375f, 0.01952049f, -0.02201768f, 0.01036292f, 0.02297086f, 
    -0.04067011f, -0.02678694f, -0.03098811f, 0.01945004f, -0.04018494f, -0.01556279f, 0.00297333f, -0.02033998f, 
    -0.01575723f, -0.01654627f, -0.00834475f, 0.02613181f, 0.01442345f, -0.01341717f, 0.02424447f, -0.00720201f, 
    0.00885646f, 0.00870336f, -0.01609769f, -0.00169036f, -0.02839492f, -0.00726220f, -0.00572400f, -0.02266266f, 
    -0.00614931f, 0.02507616f, -0.03901507f, 0.00796133f, 0.02191523f, -0.00244545f, 0.01117908f, 0.02137189f, 
    -0.00877937f, 0.01411418f, 0.00769541f, -0.00920865f, -0.00747648f, 0.01670929f, -0.02499757f, -0.01873635f, 
    0.02433988f, 0.01963482f, -0.03991481f, 0.02808052f, -0.03625261f, 0.00613279f, 0.02246541f, -0.01624455f, 
    0.00458903f, 0.01159710f, -0.03459450f, -0.00307633f, 0.01572524f, 0.01761049f, -0.03536789f, 0.00201634f, 
    -0.01762613f, 0.00743406f, -0.00141323f, 0.00939229f, -0.01971480f, -0.01208353f, 0.01765470f, -0.00633715f, 
    -0.00478265f, 0.02488925f, -0.02979982f, -0.00570684f, -0.02641912f, 0.01131856f, 0.01249410f, -0.00141739f, 
    -0.03476073f, 0.02234554f, -0.00770692f, -0.03362607f, -0.02015467f, -0.02752631f, -0.01588116f, -0.03884465f, 
    0.00492898f, -0.00646789f, 0.01144249f, 0.00919816f, -0.02152352f, -0.01435412f, -0.00756657f, 0.01769624f, 
    -0.03722696f, -0.03367594f, -0.01157686f, -0.01746222f, -0.01635708f, 0.02030060f, -0.02819831f, -0.03986053f, 
    0.03304704f, -0.03049626f, -0.02213964f, -0.02683634f, -0.01485961f, -0.00505276f, -0.02302734f, -0.01719278f, 
    -0.03443041f, -0.00287305f, -0.00160432f, -0.01613681f, 0.01102632f, -0.02598377f, -0.02157968f, -0.03737771f, 
    0.00960393f, 0.00198824f, -0.02636445f, 0.00634795f, 0.02798297f, 0.02204489f, -0.01016221f, -0.02244573f, 
    0.02640864f, 0.00638161f, 0.01553450f, -0.02134042f, -0.01309887f, -0.01481675f, 0.01549677f, -0.03488730f, 
    -0.00110407f, -0.00463382f, 0.00216034f, 0.03413806f, -0.01024403f, 0.02445053f, -0.02112495f, 0.02796637f, 
    -0.01718381f, 0.02052372f, 0.02023613f, -0.00044659f, -0.01067634f, 0.02865302f, -0.00850427f, 0.02238484f, 
    0.02417362f, 0.03746818f, -0.02861682f, 0.02021448f, -0.00159712f, -0.01041065f, 0.02845508f, -0.03092453f, 
    -0.03468190f, -0.03887325f, 0.00227167f, 0.01406938f, -0.01455634f, -0.03673018f, -0.01734306f, 0.02092630f, 
    -0.01480487f, 0.01603043f, -0.01276006f, -0.03391937f, 0.01801339f, 0.02937404f, -0.02498508f, -0.01591488f, 
    -0.03975870f, -0.01672084f, -0.00810416f, 0.01621873f, -0.00897838f, 0.02381518f, 0.00216094f, -0.00225132f, 
    -0.03496414f, -0.03819194f, 0.01964944f, -0.02054977f, -0.03560871f, -0.02250367f, -0.04163893f, -0.03789654f, 
    -0.04143956f, 0.01292647f, 0.02504289f, -0.01301319f, 0.01135120f, -0.03436855f, -0.00051791f, 0.01957339f, 
    0.02197231f, -0.01108868f, 0.02968308f, -0.00512544f, 0.00432519f, -0.00312767f, -0.03090444f, -0.04538177f, 
    0.02240864f, -0.02162897f, 0.00536274f, -0.02343318f, 0.00974164f, -0.00372931f, 0.01938444f, 0.01847515f, 
    -0.03116166f, 0.00602261f, -0.03904083f, 0.01911289f, 0.02160841f, 0.01073673f, -0.04173109f, -0.02292098f, 
    0.00948478f, -0.03792323f, -0.00083116f, -0.02159060f, -0.02844749f, -0.01385242f, 0.02073864f, 0.02388456f, 
    -0.03070437f, -0.00256490f, -0.00262598f, 0.03137296f, 0.03498287f, 0.00552317f, 0.02302678f, 0.00509876f, 
    0.03756436f, 0.01853804f, -0.04056992f, -0.00071424f, -0.03675282f, 0.02533988f, 0.02656222f, -0.01125484f, 
    0.01831415f, -0.03201383f, 0.01567003f, 0.01284972f, -0.02233967f, -0.03021069f, 0.00713099f, -0.01448391f, 
    -0.02893539f, 0.03415723f, -0.02711840f, 0.00729142f, -0.03868758f, 0.01210931f, 0.01916523f, -0.01442987f, 
    0.02253784f, 0.01867175f, 0.00030023f, 0.01866221f, -0.02397096f, 0.00693873f, 0.01302580f, 0.01200594f, 
    -0.00229261f, 0.01309243f, 0.01126859f, -0.01528561f, -0.01306763f, 0.00547676f, -0.01614462f, -0.00888647f, 
    0.01192866f, -0.00339305f, 0.01165117f, 0.01872217f, 0.02865085f, -0.04272010f, 0.01365218f, -0.03356554f, 
    -0.01293742f, 0.00154168f, 0.02792023f, 0.02017715f, 0.01676829f, -0.01933724f, 0.01827437f, -0.03396401f, 
    0.00027578f, 0.00579433f, 0.03315870f, 0.02435879f, -0.02033051f, -0.02727091f, 0.02226637f, -0.03575109f, 
    -0.03578121f, 0.02229404f, -0.04024192f, -0.01207345f, 0.01950700f, -0.00648037f, 0.00796423f, 0.02082324f, 
    -0.01096921f, -0.00371317f, -0.03747940f, 0.01699471f, -0.04050601f, 0.02145575f, -0.02821183f, 0.00890831f, 
    -0.00230819f, -0.04040036f, 0.01425272f, -0.02394856f, 0.02490863f, 0.04443757f, 0.01117861f, 0.02793921f, 
    0.01934394f, -0.02086421f, 0.00977627f, -0.02869502f, -0.01874092f, -0.03773724f, -0.04107682f, -0.00539864f, 
    0.02429219f, -0.02453184f, 0.03200107f, 0.00008853f, -0.02864070f, -0.01251697f, 0.02326774f, -0.02635795f, 
    -0.02996670f, 0.02669377f, 0.00754290f, 0.02757958f, -0.02527325f, -0.02801545f, 0.01521512f, -0.03314353f, 
    0.00700806f, 0.00611538f, -0.03385196f, 0.03414460f, -0.01215094f, -0.01692309f, 0.02843872f, 0.00053368f, 
    -0.02728433f, -0.02395641f, 0.01101811f, -0.02826751f, -0.01710819f, -0.02812043f, -0.03229392f, -0.02855167f, 
    -0.00009370f, 0.00370728f, -0.00849888f, 0.01398273f, 0.01227639f, -0.00959296f, 0.02768240f, -0.00604578f, 
    -0.03886942f, 0.01643910f, -0.03334026f, -0.02604005f, 0.02230363f, 0.00421815f, 0.01107859f, 0.01384163f, 
    -0.04201780f, -0.03381904f, 0.01329669f, 0.01573466f, 0.01708906f, 0.02389219f, 0.03727610f, 0.02737309f, 
    -0.01013208f, 0.00413761f, -0.02001397f, -0.01730591f, -0.00592264f, 0.00665128f, -0.01822266f, -0.03928063f, 
    0.02300976f, 0.01642163f, 0.00016324f, -0.00309798f, 0.02048766f, 0.01018535f, -0.00832005f, 0.01106998f, 
    -0.03247220f, -0.03890679f, -0.03836086f, -0.01618210f, 0.01518729f, 0.02430448f, -0.01449514f, 0.01407702f, 
    0.01612919f, -0.03217377f, -0.00120989f, -0.01380864f, -0.02089256f, -0.03473450f, 0.02255253f, -0.00717598f, 
    -0.02664362f, 0.02002221f, 0.04143026f, -0.01827519f, 0.00352941f, 0.00504285f, -0.03332667f, -0.04312854f, 
    0.02558909f, 0.00349666f, 0.01628427f, -0.00443154f, 0.01596855f, 0.00004408f, 0.00864668f, -0.00080283f, 
    0.01755683f, -0.04458125f, -0.03863500f, -0.00080102f, -0.00706983f, 0.01097865f, 0.03338065f, 0.01599906f, 
    0.00081885f, 0.01307204f, -0.00086759f, -0.03282820f, -0.01830542f, -0.01430431f, 0.02274213f, -0.03217981f, 
    0.00202990f, 0.03080665f, 0.02379828f, 0.00639203f, 0.02430217f, -0.00022553f, -0.00108506f, 0.00374523f, 
    0.02402474f, -0.04385707f, -0.00779523f, 0.00734276f, 0.01718684f, 0.00086287f, -0.03049538f, 0.02640195f, 
    -0.00122615f, -0.00903254f, -0.01062045f, 0.01317013f, -0.02597124f, 0.01191702f, 0.01654087f, 0.01661482f, 
    -0.00319525f, -0.00536947f, -0.03477983f, -0.03209715f, 0.00121276f, -0.01151155f, -0.00536605f, -0.02680577f, 
    -0.00768568f, -0.01193644f, 0.00005212f, -0.03397143f, -0.03031366f, 0.02727042f, -0.02940329f, -0.04398710f, 
    -0.01811204f, -0.00522448f, 0.01350417f, 0.02319875f, -0.01616732f, -0.01801903f, 0.00143409f, -0.00611096f, 
    -0.02395918f, -0.03274299f, 0.00272442f, 0.02990790f, -0.03636356f, 0.01860646f, 0.01288160f, -0.01905227f, 
    -0.00750807f, 0.01169129f, -0.00043294f, 0.01300480f, 0.02968464f, 0.02749984f, 0.02570468f, 0.00507141f, 
    -0.02429153f, -0.01236945f, 0.01397859f, -0.03815388f, 0.01331793f, -0.02531601f, -0.01313058f, -0.00185597f, 
    -0.04356712f, -0.03132968f, 0.01914373f, -0.02515787f, -0.00706503f, -0.02294610f, -0.01435822f, -0.03788708f, 
    -0.00128377f, -0.00027398f, -0.02078610f, -0.04152298f, 0.01551537f, 0.00374796f, -0.00421305f, 0.03407467f, 
    -0.01097151f, -0.00561143f, -0.01531103f, -0.03265749f, 0.02075893f, -0.00595095f, 0.00108538f, 0.01153350f, 
    -0.03356234f, 0.00900581f, -0.03144060f, 0.00490376f, 0.02036374f, 0.01773162f, 0.03216144f, -0.03488943f, 
    0.02305569f, -0.02951429f, -0.03070409f, -0.03523025f, 0.02466087f, 0.02577020f, -0.00765975f, -0.00565596f, 
    0.01172751f, -0.00010763f, -0.03568557f, 0.01260080f, 0.02705259f, -0.02575614f, -0.00741178f, -0.01891207f, 
    -0.02952772f, 0.02478012f, 0.00561234f, -0.03998999f, -0.02370879f, 0.00773233f, 0.02099024f, -0.00773704f, 
    0.02433310f, 0.00391779f, 0.02806568f, -0.01673263f, -0.03941688f, -0.03062328f, 0.00467625f, 0.00667554f, 
    -0.03636799f, -0.00660503f, -0.02766188f, 0.02941478f, -0.02741896f, -0.01375522f, -0.02624993f, 0.00132425f, 
    -0.01742133f, 0.00262302f, -0.00789282f, 0.01938768f, 0.01393946f, 0.00597119f, -0.01698125f, -0.02494215f, 
    -0.04321164f, -0.00714450f, 0.01054537f, 0.01876993f, -0.02047660f, -0.01454675f, 0.02793033f, -0.02634952f, 
    0.01880196f, -0.00225122f, -0.03746924f, 0.03364204f, -0.03074727f, -0.00839193f, -0.02873544f, 0.01093610f, 
    0.01346596f, -0.01318271f, -0.00225561f, 0.01948080f, 0.01087880f, 0.02557991f, 0.03370270f, -0.03539495f, 
    0.01132960f, 0.01051151f, 0.02140606f, -0.01552690f, 0.03877211f, -0.01174455f, -0.00053616f, -0.02384326f, 
    -0.04250174f, -0.02287470f, 0.01839268f, -0.03373177f, -0.02115658f, -0.01211942f, -0.01874415f, -0.00119043f, 
    0.03818859f, 0.02497401f, -0.00362744f, -0.02425823f, 0.01966804f, -0.03229716f, -0.02470643f, -0.03742329f, 
    -0.03680247f, -0.00467740f, 0.02374297f, -0.04227287f, 0.00604007f, -0.03816640f, 0.02276345f, -0.02267150f, 
    -0.03597498f, 0.01336681f, -0.00424836f, 0.01115878f, 0.01530756f, -0.02260770f, 0.02165807f, 0.00719174f, 
    -0.03425522f, 0.01935350f, 0.01997764f, -0.01842254f, 0.02896740f, -0.02287938f, -0.02971426f, 0.02189737f, 
    -0.00458651f, -0.02210331f, -0.02866590f, -0.00692837f, 0.02288941f, -0.04178989f, -0.02904723f, 0.02234606f, 
    -0.02197684f, -0.03723557f, -0.02247272f, -0.04220052f, -0.03123948f, 0.02686374f, 0.00623237f, -0.01219662f, 
    -0.00244949f, 0.02142968f, -0.00941176f, 0.03075998f, -0.02506007f, -0.03316093f, 0.02391535f, -0.03793075f, 
    -0.04445034f, 0.01512241f, -0.03722018f, 0.00036708f, -0.03676888f, 0.00183344f, 0.01651179f, -0.03006359f, 
    -0.02644466f, 0.01877726f, 0.01738860f, 0.03671847f, -0.02209446f, -0.02185917f, 0.00551519f, -0.02139211f, 
    0.00883816f, -0.02443282f, 0.00472612f, -0.04162576f, 0.01152015f, -0.00951350f, 0.00313368f, 0.01107291f, 
    -0.01965465f, -0.00949818f, -0.00054331f, 0.01958733f, 0.00782505f, -0.01131213f, 0.01278476f, -0.01167819f, 
    0.02164219f, 0.03520524f, -0.02885651f, -0.01428983f, 0.03856247f, -0.00422062f, -0.01096788f, -0.00297649f, 
    -0.01944269f, 0.00228117f, -0.02540975f, -0.03775467f, 0.00467143f, 0.00654573f, 0.03662766f, -0.00531181f, 
    -0.02143841f, -0.03353872f, -0.03182340f, 0.00511586f, -0.03044137f, 0.02602206f, -0.03693236f, -0.01934247f, 
    -0.00833340f, -0.01374560f, -0.00522497f, -0.01357482f, -0.01713545f, 0.01888303f, -0.03207454f, -0.00551228f, 
    0.03154649f, 0.03473838f, -0.02357353f, 0.02516816f, 0.01192653f, 0.00359077f, 0.00276612f, 0.01024605f, 
    -0.00471040f, 0.01383967f, -0.00166466f, -0.02445604f, -0.01967008f, -0.02117515f, -0.02341770f, 0.01030387f, 
    -0.02013401f, 0.02987744f, 0.01226143f, -0.02067089f, -0.01700613f, 0.02705873f, -0.03276345f, -0.01545543f, 
    0.00332505f, 0.02488174f, -0.01982449f, 0.01715782f, -0.02383367f, 0.00865259f, 0.02484827f, 0.00265723f, 
    0.02866810f, 0.01433400f, 0.02341603f, 0.01109315f, 0.01142631f, -0.00903953f, -0.01615545f, -0.02921606f, 
    0.02891530f, 0.02006220f, -0.00285828f, -0.01113833f, 0.02617777f, -0.03085094f, 0.01917148f, -0.00474386f, 
    -0.02686130f, 0.01915815f, -0.04112205f, -0.00971443f, 0.02340608f, 0.00401685f, 0.02299123f, 0.03137891f, 
    -0.01918221f, -0.00533608f, 0.00682384f, -0.00619873f, 0.01041037f, 0.01382609f, -0.01052243f, -0.00484046f, 
    -0.02616018f, -0.01557237f, 0.01646241f, -0.00117807f, -0.00106765f, 0.00543358f, -0.02691464f, 0.00677733f, 
    0.00603972f, -0.02357260f, 0.00585879f, -0.00847663f, -0.00937048f, -0.01897878f, -0.03325948f, 0.00359633f, 
    -0.18494719f, -0.23649894f, 0.09547026f, -0.02131276f, -0.00262345f, 0.02209658f, 0.08587021f, -0.01400600f, 
    -0.02655357f, -0.04413568f, 0.00181285f, 0.01767965f, 0.29968268f, -0.08690312f, 0.11217047f, 0.01401376f, 
    0.00676419f, 0.01008549f, 0.05237603f, -0.08305658f, 0.03575797f, 0.04437255f, 0.01553923f, 0.02919423f, 
    -0.00663030f, -0.01490286f, 0.15426420f, 0.04034154f, 0.04399970f, -0.05004258f, 0.02191815f, 0.01602325f, 
    0.15587446f, 0.09365735f, -0.16841663f, -0.06358997f, 0.11235736f, 0.06548249f, 0.00800621f, -0.11915627f, 
    -0.05989757f, -0.02348877f, -0.08848269f, 0.03934694f, 0.04927213f, 0.00858586f, 0.06888419f, -0.04950766f, 
    0.04920160f, -0.06354494f, 0.06073776f, -0.14932415f, -0.02543195f, -0.03961287f, -0.00147919f, -0.03369512f, 
    0.01755912f, -0.04216053f, 0.08080520f, 0.04789037f, -0.42098281f, 0.03510164f, 0.05243308f, 0.00731818f, 
    -0.00653148f, -0.00764906f, 0.05808178f, 0.03787880f, 0.03222951f, -0.06142394f, 0.06577594f, -0.04897327f, 
    0.13657443f, 0.12052941f, 0.10831405f, -0.10684067f, -0.01072482f, 0.03895278f, 0.04035629f, 0.04795245f, 
    0.09167717f, -0.01319739f, -0.01100777f, 0.03774996f, 0.15432335f, -0.22555904f, -0.03129127f, 0.09165459f, 
    -0.06982955f, -0.04893821f, -0.05253023f, -0.03771564f, -0.02390358f, -0.03270996f, 0.03115082f, -0.05737767f, 
    0.27844542f, -0.04523302f, 0.20739804f, -0.11693826f, 0.00467479f, -0.07488605f, 0.05857701f, 0.00056328f, 
    0.02683479f, 0.07464721f, 0.07939290f, -0.00865351f, 0.24220563f, 0.07275581f, -0.17794095f, -0.01162732f, 
    0.05457974f, 0.09914362f, -0.00773716f, 0.03406708f, -0.07940820f, 0.03014873f, -0.01023563f, 0.04527678f, 
    0.06144261f, -0.06214410f, -0.13357259f, 0.11810239f, 0.00294057f, 0.01485341f, -0.02349421f, 0.02745662f, 
    -0.01305851f, -0.02421720f, 0.10181263f, -0.06702727f, 0.06143297f, 0.07576057f, -0.06468414f, 0.01957354f, 
    0.14426802f, 0.01236104f, 0.00375110f, 0.04152742f, 0.06907754f, -0.07999032f, 0.04087861f, -0.00315148f, 
    -0.02182218f, -0.23322506f, -0.06539463f, -0.08879969f, -0.05015181f, 0.00895280f, 0.01078993f, 0.00682285f, 
    0.15971193f, 0.04304657f, -0.05913810f, 0.04649122f, 0.05458161f, 0.06610929f, -0.21747147f, 0.07825357f, 
    -0.01047838f, 0.02266846f, 0.13278934f, -0.07737504f, 0.04675587f, -0.06117047f, 0.00286070f, 0.04503120f, 
    -0.01344888f, 0.19631481f, -0.15110731f, 0.01787036f, -0.04393306f, -0.02779181f, -0.01511315f, -0.04420879f, 
    0.03324731f, -0.05651732f, 0.04016647f, 0.09447476f, 0.11820196f, 0.08216126f, -0.18713036f, 0.18686914f, 
    -0.07914698f, -0.03125729f, -0.03487661f, -0.09583919f, -0.09501565f, 0.09565625f, 0.00369869f, 0.01460333f, 
    -0.02767180f, -0.05389157f, 0.05651077f, 0.14230496f, -0.05662212f, 0.10079052f, -0.13548672f, 0.07303591f, 
    -0.01325871f, -0.01415814f, -0.08068860f, -0.04588762f, 0.16613530f, 0.04388759f, -0.08996139f, -0.00810035f, 
    -0.08155645f, 0.01891418f, -0.02050208f, -0.01721940f, 0.00276589f, 0.09261157f, 0.09219538f, -0.00569816f, 
    -0.17202261f, 0.18105777f, -0.14373417f, 0.07357147f, 0.04312972f, 0.09468348f, -0.03584893f, 0.02985750f, 
    0.09428262f, 0.07397373f, -0.02672484f, -0.08352804f, 0.10479948f, 0.21633792f, 0.13972852f, -0.04154897f, 
    -0.02369449f, 0.00509318f, 0.01967059f, -0.11232127f, -0.04208863f, 0.01630937f, 0.04626739f, 0.13831732f, 
    0.23947893f, 0.08693963f, -0.10755228f, 0.18296508f, 0.07952774f, 0.07012652f, -0.01365852f, -0.00610449f, 
    0.06891385f, 0.10454709f, 0.02476319f, -0.09709872f, -0.26457009f, 0.07495794f, -0.09100667f, 0.11165684f, 
    0.02817271f, -0.00831111f, -0.03099008f, 0.07032873f, -0.02254647f, -0.02134455f, -0.16117349f, -0.02226284f, 
    -0.12759659f, 0.13565890f, 0.01753094f, 0.10182152f, -0.03010781f, -0.01423064f, 0.02260655f, 0.01744885f, 
    -0.01973852f, -0.09583983f, -0.01597940f, -0.11526504f, 0.08502466f, 0.09610566f, -0.16262038f, 0.34406388f, 
    0.10384850f, -0.01179826f, -0.02013794f, -0.04072197f, 0.06250155f, -0.03877054f, -0.02047734f, -0.04547476f, 
    -0.12676436f, -0.13751280f, -0.05493625f, 0.07085300f, -0.09662200f, -0.07198978f, -0.00721714f, -0.03493920f, 
    0.01679421f, 0.07447988f, -0.03714141f, 0.01774070f, -0.08166600f, -0.15112811f, 0.06581284f, -0.03057719f, 
    0.00785875f, -0.03938207f, -0.02555425f, 0.03614239f, -0.03480252f, 0.06340095f, -0.04157304f, -0.02002970f, 
    -0.05994821f, 0.15178476f, 0.03959552f, -0.05538476f, -0.02894050f, -0.05306195f, -0.05814473f, 0.03537349f, 
    -0.03775615f, -0.02304344f, -0.09475164f, 0.01025448f, -0.22607616f, 0.05158387f, 0.05147252f, 0.15858504f, 
    -0.13014968f, 0.06418920f, 0.04514996f, -0.00055191f, -0.06793414f, 0.05020326f, -0.06100138f, 0.00855553f, 
    -0.09468213f, -0.01347685f, -0.07789660f, 0.07342850f, -0.03840464f, 0.00640074f, -0.09009959f, 0.04290897f, 
    -0.00241194f, 0.02715758f, -0.07196266f, -0.02988949f, -0.02946652f, 0.26349813f, -0.11263588f, 0.14874183f, 
    0.01266951f, 0.05142434f, -0.04532943f, -0.04888616f, -0.01280965f, 0.01999236f, -0.00799420f, 0.01154505f, 
    0.22166885f, 0.08108998f, -0.01617896f, -0.13497075f, -0.18334040f, 0.03052933f, 0.03072777f, -0.04171643f, 
    -0.11813433f, 0.03388041f, -0.02005458f, 0.17516322f, -0.05496395f, 0.02164124f, 0.02565019f, 0.17176495f, 
    0.09436182f, 0.01953756f, -0.04140382f, -0.01145362f, 0.03841371f, -0.10550112f, -0.13827789f, -0.03886914f, 
    -0.00710250f, -0.02979858f, 0.13156661f, -0.11095297f, 0.10064094f, 0.20113152f, 0.01523187f, 0.00697498f, 
    -0.05793434f, -0.09307764f, 0.03022238f, 0.07232316f, 0.33670393f, 0.01270162f, 0.21218048f, -0.20831701f, 
    -0.03190740f, -0.05275992f, 0.02748999f, 0.02342485f, -0.03322091f, 0.03895887f, 0.06369401f, 0.03913914f, 
    -0.10835743f, -0.25309440f, 0.20058188f, 0.03187268f, -0.03220992f, 0.01783599f, 0.04716672f, 0.02387685f, 
    0.08329077f, -0.10401841f, 0.01985183f, 0.00229535f, 0.18484887f, 0.10035539f, -0.03698042f, -0.02076789f, 
    -0.07537814f, 0.04387348f, 0.08165066f, 0.02077046f, -0.01976694f, -0.02807724f, 0.08307663f, 0.01676893f, 
    0.05450556f, -0.02959705f, -0.07302006f, -0.01612816f, -0.07249825f, -0.07794510f, -0.07792098f, -0.06712685f, 
    -0.08235237f, 0.06052397f, -0.06522617f, -0.01593405f, 0.10543611f, -0.14707689f, -0.27498496f, 0.02928365f, 
    0.01494096f, -0.02381741f, -0.02489014f, -0.02153522f, 0.03588459f, -0.01309081f, -0.00388519f, 0.00527806f, 
    0.26476943f, 0.08606792f, -0.02260239f, 0.02082789f, 0.05752340f, -0.03364772f, 0.05231024f, -0.01735385f, 
    0.00365884f, 0.04939532f, -0.00453639f, -0.03164057f, 0.21742332f, -0.03941597f, 0.08857889f, 0.19628431f, 
    -0.08927425f, 0.05557330f, 0.11760885f, 0.05238713f, 0.01396863f, 0.10262563f, -0.01806429f, -0.06482800f, 
    0.10968366f, -0.07388312f, -0.11521862f, 0.10111066f, 0.03859562f, -0.06038124f, 0.02562167f, 0.14318208f, 
    -0.01397880f, -0.02140614f, -0.03289094f, -0.01323369f, 0.03521541f, 0.01776035f, -0.13492665f, 0.03382640f, 
    0.00307540f, -0.01780693f, -0.06028132f, -0.00971747f, -0.03365742f, -0.11452001f, -0.04228318f, 0.04772923f, 
    -0.00790145f, -0.01001043f, -0.07042462f, -0.14124531f, -0.03249153f, 0.03651265f, -0.05233185f, -0.04834507f, 
    -0.07720300f, 0.00038806f, 0.10532536f, 0.06076884f, 0.39481807f, 0.02072520f, -0.12894984f, 0.12011138f, 
    0.03219202f, 0.00503564f, 0.05190298f, 0.02204982f, -0.05454536f, -0.00422723f, -0.10114389f, 0.05899720f, 
    0.13244359f, 0.17215024f, 0.12000976f, 0.09754936f, -0.07582342f, 0.02170378f, -0.06829114f, -0.08296809f, 
    -0.05523293f, -0.07376976f, -0.00043506f, -0.05275427f, 0.17103454f, -0.08513191f, -0.04831169f, 0.12552856f, 
    -0.08560526f, -0.00171480f, 0.09658094f, -0.00755475f, 0.10622843f, 0.07891580f, -0.02816142f, 0.07377311f, 
    -0.02249750f, -0.17004023f, 0.07989006f, -0.03996687f, -0.02004903f, -0.09115533f, -0.02367689f, 0.02038469f, 
    -0.01012093f, -0.07335707f, 0.00436924f, 0.02575419f, 0.23329532f, 0.27153534f, 0.01739016f, -0.00924078f, 
    -0.06414162f, -0.02222581f, -0.02617310f, -0.12524143f, -0.08503685f, 0.05804158f, 0.08011304f, -0.13168314f, 
    0.10637895f, 0.08984979f, 0.02124971f, 0.18645440f, -0.06169304f, 0.08390558f, 0.00831542f, -0.01454248f, 
    0.07898015f, 0.07539572f, 0.07099907f, 0.06180124f, 0.06788173f, 0.06175630f, 0.14394701f, 0.12653500f, 
    -0.01976937f, -0.17214490f, 0.02859528f, -0.05140001f, -0.00663859f, -0.03817842f, -0.00252692f, 0.04403035f, 
    0.06900758f, 0.07761634f, -0.15995298f, -0.07137670f, 0.02239526f, -0.05772012f, -0.02476523f, -0.02014595f, 
    0.00354230f, 0.05834238f, 0.04790476f, 0.03236519f, 0.11159652f, 0.01167981f, 0.05652257f, -0.01054476f, 
    0.00870053f, -0.02858330f, -0.01259136f, -0.02121003f, -0.02387203f, 0.10345683f, -0.09663119f, 0.14214769f, 
    -0.02094354f, 0.06639025f, 0.07199810f, 0.18242551f, 0.14197460f, 0.03577448f, 0.09533643f, 0.02383224f, 
    0.07506263f, -0.01318695f, -0.06928847f, -0.04004433f, 0.28172642f, 0.10910456f, 0.09245194f, -0.06839229f, 
    -0.00999732f, 0.01185146f, -0.04041014f, -0.04580232f, 0.05181608f, 0.05743017f, 0.06413461f, 0.05849870f, 
    -0.07866526f, 0.25407407f, 0.10284729f, -0.17390774f, 0.06791651f, 0.10083370f, -0.01001869f, -0.00779480f, 
    0.00113609f, -0.12121610f, 0.01365004f, -0.03984761f, 0.01502971f, -0.00284787f, 0.10022946f, -0.09062599f, 
    -0.01620731f, -0.05633938f, -0.01238171f, 0.01231883f, 0.01286794f, 0.00707392f, 0.10285225f, -0.10954490f, 
    -0.05069585f, 0.00784911f, -0.03575831f, -0.01256160f, -0.02220296f, -0.00882001f, 0.02604887f, -0.05014865f, 
    -0.06994171f, 0.12264176f, -0.00971184f, 0.07103269f, -0.04337374f, 0.12061425f, 0.05567453f, -0.17729554f, 
    -0.00206836f, 0.02261075f, -0.04231004f, -0.10351706f, 0.00523762f, -0.11665759f, -0.04791717f, 0.08145095f, 
    -0.12942043f, -0.17657147f, 0.07929942f, 0.09217001f, 0.00198292f, -0.02546400f, 0.09002823f, 0.02491760f, 
    0.04603541f, -0.01121172f, 0.04644903f, -0.20945650f, 0.12913485f, -0.04751576f, 0.02488802f, -0.09646647f, 
    -0.04950978f, -0.00544927f, -0.02232649f, -0.11745340f, 0.04721177f, 0.02140313f, 0.02244245f, -0.04135885f, 
    0.14223042f, 0.03049821f, 0.07303318f, 0.05747699f, 0.08058887f, 0.07547995f, 0.06792048f, -0.01149271f, 
    0.02519888f, 0.00641913f, 0.04286256f, -0.01023235f, -0.10039288f, 0.01382378f, -0.06065403f, -0.00841182f, 
    0.05184866f, -0.04035650f, -0.08965681f, 0.02608775f, 0.06619345f, 0.01101628f, -0.00514203f, -0.12030874f, 
    0.22352135f, 0.01683248f, 0.22066438f, 0.07688800f, 0.08000165f, 0.03972552f, 0.09468270f, 0.12487398f, 
    0.00864232f, -0.02599111f, 0.01542529f, 0.06113140f, 0.13486466f, 0.19671705f, 0.14400937f, -0.07657298f, 
    -0.03152056f, 0.05245347f, 0.03314345f, -0.02366186f, -0.05747953f, 0.05357833f, 0.03160563f, 0.06947422f, 
    0.17852692f, -0.20633282f, 0.05879869f, -0.09836582f, -0.00549726f, -0.01078225f, -0.01293590f, -0.14010419f, 
    0.00169271f, -0.03330185f, -0.00680964f, 0.00692290f, -0.32733017f, 0.06972674f, -0.02393971f, -0.17431614f, 
    -0.10822255f, 0.00735530f, -0.02085257f, 0.08910783f, -0.10343096f, -0.07285801f, 0.01706406f, -0.01701376f, 
    0.07551955f, -0.06578097f, -0.13329120f, 0.05315439f, 0.07957730f, -0.03377756f, -0.02378488f, -0.03993984f, 
    -0.03224298f, -0.10973639f, 0.04460117f, 0.12554516f, 0.09921933f, 0.02704072f, 0.01863601f, 0.14614569f, 
    0.04953287f, 0.03337945f, 0.15787199f, 0.06032579f, -0.02991247f, 0.05156126f, -0.09365109f, -0.00677270f, 
    0.15186851f, 0.03504586f, 0.11174891f, -0.05583492f, -0.05171278f, 0.08820886f, -0.00210184f, -0.02702632f, 
    -0.00953434f, 0.06848557f, 0.04656506f, 0.01064718f, 0.02217897f, -0.12188026f, 0.15138093f, 0.00692024f, 
    -0.06699210f, -0.05912042f, 0.00325277f, -0.01278150f, 0.00828334f, -0.00178812f, -0.10801663f, -0.08454479f, 
    -0.30316746f, 0.07825035f, 0.00464632f, 0.01944556f, -0.01566663f, 0.02627927f, 0.01959549f, 0.02738615f, 
    0.00796991f, -0.03450439f, -0.06622144f, 0.10638867f, -0.14222756f, 0.08891375f, 0.00788475f, -0.05577192f, 
    -0.02734106f, -0.00632000f, 0.04754613f, 0.07549251f, 0.01541527f, 0.02497641f, -0.03095142f, 0.10855976f, 
    -0.18759315f, 0.08439978f, 0.09232000f, -0.08178427f, 0.01057953f, 0.10083359f, -0.07536048f, 0.06688682f, 
    0.03075969f, 0.02747342f, -0.04715758f, 0.02514582f, -0.14939012f, -0.22660065f, 0.14552458f, 0.15285745f, 
    -0.06139420f, -0.01988234f, 0.00645908f, 0.03514526f, 0.00472952f, -0.01069370f, -0.00102334f, 0.04703689f, 
    -0.07376967f, 0.04323317f, 0.09504229f, 0.11223242f, -0.08784948f, -0.13199854f, -0.07920063f, -0.00129618f, 
    -0.00931202f, 0.01313928f, -0.06142212f, 0.02338289f, -0.06614752f, -0.05377325f, 0.04663186f, 0.05661849f, 
    -0.07344743f, -0.11714423f, 0.00634179f, -0.01458095f, -0.04332879f, 0.01587097f, -0.00075226f, -0.02355793f, 
    -0.16071904f, 0.11257215f, -0.04490360f, -0.18862501f, 0.00988031f, 0.03210641f, -0.00098534f, 0.06024761f, 
    0.04950380f, 0.01316740f, 0.03125761f, 0.02082845f, 0.06382439f, -0.04497208f, 0.09972707f, -0.01959757f, 
    0.09665586f, 0.01298761f, -0.06929171f, -0.16351734f, 0.08291262f, 0.04856636f, 0.01711448f, 0.06992932f, 
    0.14499019f, -0.06659448f, 0.05431917f, 0.11606526f, -0.02954864f, -0.07051462f, 0.04514310f, -0.11849660f, 
    -0.05527075f, 0.03085873f, -0.06824222f, -0.14446783f, 0.07385755f, 0.09671437f, 0.10027013f, 0.20450580f, 
    0.12061171f, 0.00788172f, 0.09879772f, 0.01250860f, 0.02669862f, 0.01991165f, 0.03797174f, -0.03127060f, 
    -0.00132635f, 0.03648797f, -0.09283940f, 0.03067324f, -0.09743954f, -0.04940750f, -0.02428735f, -0.07400178f, 
    -0.08261935f, -0.02411034f, 0.03610646f, -0.03359193f, -0.06905538f, -0.00179550f, -0.01137955f, -0.02438306f, 
    -0.00229791f, 0.01828356f, -0.04282594f, 0.06038367f, 0.02047468f, -0.09464297f, -0.06059326f, 0.05508729f, 
    -0.10636046f, -0.11285603f, 0.00718454f, -0.10849354f, -0.10929876f, 0.01458939f, 0.04151241f, -0.05268798f, 
    -0.01223469f, 0.06931177f, -0.03842019f, -0.00590945f, 0.00055234f, -0.04607783f, 0.09863833f, -0.04453043f, 
    0.16717546f, -0.03368984f, -0.00545950f, 0.04045516f, 0.01944045f, 0.02207472f, 0.05543540f, -0.05447341f, 
    0.11024871f, 0.04261205f, 0.06869598f, 0.08346202f, -0.06186660f, 0.01636217f, 0.07664003f, -0.12946065f, 
    -0.08756316f, 0.09846393f, 0.15961955f, 0.02475589f, -0.06703813f, -0.01740696f, 0.16986099f, 0.25690269f, 
    -0.10986881f, -0.11133809f, 0.00528370f, -0.01126260f, 0.04888885f, -0.00721160f, 0.07588027f, 0.02529361f, 
    0.04586937f, -0.15667775f, -0.08756229f, -0.02270921f, -0.04590349f, -0.02684173f, 0.01481500f, 0.09440783f, 
    0.07629206f, 0.06976093f, -0.01522574f, 0.06663869f, 0.17461567f, -0.00502046f, -0.07730343f, 0.32441670f, 
    0.09491658f, -0.02315453f, -0.04459713f, -0.06759381f, 0.10937171f, -0.01097078f, 0.06682239f, 0.11770608f, 
    -0.19717869f, -0.01159948f, 0.20594694f, -0.01247741f, -0.04059882f, 0.01199658f, 0.01213429f, 0.03137537f, 
    0.11114908f, -0.04307981f, -0.02505657f, 0.04085243f, 0.08802345f, 0.10775607f, -0.01154274f, -0.04572333f, 
    -0.00499709f, -0.04852819f, -0.02646729f, 0.00117495f, -0.00482868f, -0.01145179f, -0.01213210f, -0.02150921f, 
    -0.06336951f, 0.05880250f, 0.07930527f, 0.05933264f, 0.19047044f, 0.08337372f, -0.05356115f, 0.00961170f, 
    0.14211534f, 0.04423398f, 0.12973940f, -0.03180824f, 0.12767948f, 0.01500453f, -0.13948441f, 0.11986199f, 
    0.11886265f, 0.12579048f, 0.05133359f, 0.04096143f, -0.02762645f, -0.05032597f, -0.06557396f, -0.09170585f, 
    -0.15920369f, -0.09266499f, 0.01168357f, 0.11791293f, 0.05043263f, 0.00075833f, 0.00743640f, -0.03497143f, 
    0.03150173f, -0.12264001f, -0.03240676f, -0.05587883f, 0.25702700f, -0.04723847f, -0.06055976f, 0.07676946f, 
    0.10299937f, -0.07561132f, 0.08320390f, -0.03252393f, 0.10546037f, 0.05497097f, 0.03661167f, -0.03227736f, 
    -0.13393803f, 0.00383047f, -0.04007337f, 0.04750090f, 0.01554845f, -0.01531007f, 0.10075558f, -0.07863913f, 
    0.08718562f, -0.01247667f, 0.02246842f, -0.07190453f, -0.01648166f, -0.15130521f, 0.18552226f, 0.15840651f, 
    -0.13560596f, -0.00486061f, -0.01706019f, 0.00388228f, -0.05996406f, 0.00845632f, 0.00554324f, 0.10481311f, 
    0.15332659f, -0.06957237f, -0.10306531f, -0.09418759f, -0.03628197f, -0.02010785f, 0.01777207f, -0.02304283f, 
    0.13301782f, 0.01845718f, 0.05952933f, 0.07964610f, -0.20344996f, 0.17991325f, 0.00103019f, -0.09518854f, 
    0.06592426f, 0.14170554f, 0.00353315f, 0.02631278f, 0.01378796f, -0.04136118f, 0.00331700f, -0.03123467f, 
    -0.43867388f, 0.15717435f, -0.14812814f, -0.08865664f, 0.06985414f, 0.07452190f, 0.02038190f, 0.12042632f, 
    0.04777265f, 0.09393768f, 0.06172334f, 0.05961040f, -0.07350446f, 0.11444893f, -0.10914788f, 0.17529233f, 
    0.07249158f, 0.14349018f, 0.03270664f, 0.01969349f, 0.07650553f, 0.01564658f, 0.03488402f, -0.00151657f, 
    0.04567497f, 0.01702022f, 0.14043608f, 0.15183994f, 0.01845606f, -0.02056529f, 0.08504490f, -0.01556089f, 
    0.03957657f, -0.02879180f, 0.04198676f, 0.04258449f, -0.12693711f, -0.02063313f, 0.23522338f, 0.21420230f, 
    -0.09698614f, 0.02826058f, -0.08539802f, 0.04313998f, -0.03341122f, -0.06976895f, -0.00188773f, 0.17283149f, 
    0.16200593f, -0.07437591f, 0.01697793f, 0.08805654f, -0.03485731f, 0.02176332f, 0.01894998f, 0.02993306f, 
    -0.16687155f, -0.03514571f, 0.10722761f, -0.07307057f, -0.21165717f, 0.24148804f, -0.01738231f, -0.06488340f, 
    -0.06707976f, -0.01876816f, -0.09609858f, -0.06385697f, 0.06695946f, -0.00475287f, -0.06137171f, 0.03767682f, 
    -0.08871426f, -0.12583369f, 0.17548190f, 0.09948111f, -0.07626805f, -0.11840100f, -0.05127169f, -0.00988405f, 
    -0.02381317f, -0.00467312f, 0.05257614f, 0.04444937f, 0.03977291f, 0.03944911f, 0.12050020f, 0.22122386f, 
    0.03273206f, -0.07069538f, 0.12087882f, -0.00115651f, 0.03497569f, -0.05004105f, -0.02217460f, 0.10100906f, 
    -0.04495303f, 0.07680682f, 0.07918330f, -0.12670976f, -0.00897585f, -0.07087971f, 0.01232152f, 0.04099718f, 
    0.09985072f, 0.14785463f, -0.01412192f, 0.01909889f, -0.03207104f, -0.10044936f, -0.02178670f, 0.05786134f, 
    -0.10975235f, -0.01153378f, -0.05446502f, -0.01360726f, -0.02572392f, 0.02066448f, 0.03295988f, 0.01066250f, 
    0.21509500f, 0.02748837f, 0.08433777f, 0.29866216f, 0.14994301f, 0.12623291f, -0.01499434f, 0.08909693f, 
    0.06278121f, 0.05652559f, -0.08276887f, -0.01982158f, -0.03025013f, 0.14647569f, 0.07214063f, 0.00576469f, 
    0.02986392f, 0.02234135f, 0.09279184f, -0.00364230f, -0.08463766f, 0.07413127f, -0.02708131f, -0.08225267f, 
    0.06915352f, 0.06560224f, 0.12301725f, -0.05676543f, -0.00820733f, 0.07143241f, 0.03780132f, 0.05900237f, 
    0.00168389f, -0.05570564f, 0.05291753f, 0.00503473f, 0.23746549f, 0.03290179f, -0.10892335f, 0.00300308f, 
    0.19576515f, 0.10726362f, 0.07982598f, -0.00676102f, 0.01512319f, -0.01540623f, -0.06451291f, 0.01122602f, 
    -0.00745775f, 0.16513185f, 0.08415045f, -0.01596001f, 0.06951574f, 0.02571311f, 0.01191835f, -0.00958077f, 
    -0.12478327f, -0.00549391f, -0.04692138f, -0.05342411f, -0.01538595f, 0.18466157f, 0.10829844f, -0.09328332f, 
    0.06511925f, 0.00385030f, -0.06279474f, 0.09208934f, 0.05835455f, 0.03439352f, 0.09347097f, -0.03709497f, 
    0.05995287f, -0.00943071f, -0.01307518f, -0.01890905f, -0.08068540f, 0.01607882f, -0.04791276f, 0.13802038f, 
    -0.14283200f, -0.09738097f, -0.03023750f, 0.06358611f, -0.15982071f, 0.02291257f, 0.02978559f, -0.01684849f, 
    0.04839624f, -0.07822894f, -0.01468405f, -0.02600433f, -0.00261165f, 0.01204531f, 0.00222101f, -0.03130314f, 
    -0.08281074f, -0.00706135f, 0.13623203f, 0.12566942f, -0.02505469f, -0.13442886f, 0.01330271f, -0.03635554f, 
    -0.08069509f, -0.06507175f, -0.03952674f, 0.01971729f, -0.23450615f, 0.01210077f, 0.11208465f, 0.01304486f, 
    0.00929500f, 0.02599829f, -0.02994073f, -0.01159028f, -0.05707817f, 0.01990730f, -0.06728925f, -0.02709282f, 
    0.18412682f, -0.05367652f, 0.07260249f, 0.02894479f, -0.03656337f, 0.00870774f, 0.02347840f, 0.04956534f, 
    0.02915822f, 0.06549233f, -0.00258492f, 0.08434877f, -0.00640576f, -0.06451139f, 0.12438172f, -0.03559574f, 
    -0.04070683f, 0.02655575f, 0.05895114f, 0.00317805f, 0.01267856f, -0.05296677f, 0.00925151f, 0.03990915f, 
    -0.15178809f, 0.03146676f, 0.12245565f, 0.04412149f, -0.08205751f, -0.02635077f, -0.03947040f, 0.00843961f, 
    -0.00873308f, -0.07800364f, -0.09255878f, -0.15229255f, 0.16643251f, -0.04948273f, -0.06266984f, -0.02551326f, 
    -0.01536695f, 0.01256463f, 0.06095539f, -0.02958115f, -0.05223735f, -0.03064939f, 0.01767145f, 0.07144562f, 
    -0.01629079f, 0.14932367f, -0.00791329f, 0.01563536f, -0.02852510f, 0.01906925f, 0.13818397f, -0.03993626f, 
    0.01573708f, 0.13898465f, -0.07798479f, 0.07842961f, 0.00526339f, -0.07805318f, 0.13734397f, -0.10890732f, 
    -0.03217108f, 0.00744768f, 0.02225083f, 0.03331347f, -0.09810091f, -0.03502661f, 0.07626391f, -0.09133537f, 
    0.38691527f, 0.02440579f, 0.06011571f, 0.01623957f, -0.01499354f, 0.02530918f, 0.07902359f, 0.08385137f, 
    -0.03573931f, 0.00730317f, 0.02197388f, 0.08890792f, -0.09082787f, -0.10098502f, 0.15405835f, -0.06578287f, 
    -0.14963977f, 0.07247083f, 0.04620799f, -0.03191108f, -0.00623479f, 0.01711476f, 0.02857146f, -0.09667419f, 
    -0.44790816f, 0.20898668f, -0.01219715f, -0.15768716f, 0.02917310f, -0.02928911f, -0.00066362f, 0.00068576f, 
    -0.01833781f, -0.06604591f, -0.03364976f, -0.03144350f, -0.03203537f, 0.13559648f, 0.16716184f, 0.12798449f, 
    0.19496532f, 0.12395857f, 0.03362285f, 0.04795774f, 0.03981381f, 0.06945212f, -0.01822846f, -0.01334979f, 
    0.00437131f, -0.00346745f, -0.00978419f, -0.03124275f, -0.02930040f, 0.01217086f, -0.03161272f, -0.02305347f, 
    -0.02519162f, -0.02583263f, -0.02297897f, 0.01304468f, 0.02826311f, 0.02699302f, -0.02320904f, -0.01503086f, 
    -0.02116010f, 0.01815785f, 0.01024004f, -0.03473044f, 0.01558576f, -0.03707862f, -0.02813033f, -0.02294868f, 
    -0.03320397f, 0.00172518f, -0.03657432f, -0.02233728f, -0.03589258f, 0.01540029f, -0.03417880f, 0.03239413f, 
    0.03192592f, 0.02559607f, 0.00148607f, -0.03199372f, 0.01205420f, 0.00267876f, 0.01255141f, -0.03806013f, 
    -0.04137785f, -0.03652505f, -0.00474649f, -0.02431680f, -0.02439598f, -0.02428191f, -0.01749880f, -0.00811513f, 
    0.01393272f, -0.01199854f, -0.02533826f, -0.03275941f, -0.03881535f, 0.00381766f, 0.01279521f, -0.03986288f, 
    -0.00436315f, -0.03983818f, 0.02668412f, 0.02735580f, -0.03888824f, 0.00598935f, 0.00669104f, -0.02759344f, 
    -0.02719413f, -0.01485743f, -0.02972949f, -0.00184678f, 0.01516263f, -0.00652259f, 0.00711235f, -0.02223206f, 
    -0.00564079f, 0.03189192f, -0.01571828f, -0.04049101f, 0.00277502f, -0.03756054f, -0.03094624f, 0.01854612f, 
    -0.02543738f, 0.00258047f, -0.01933676f, -0.00775283f, -0.02816630f, 0.01965197f, -0.00016192f, -0.00621358f, 
    0.00065998f, -0.02974389f, 0.01436236f, 0.02970772f, 0.01524366f, 0.02889598f, 0.00898213f, -0.02101576f, 
    0.01535559f, -0.03405711f, 0.02966051f, -0.03079264f, -0.01750410f, 0.02900898f, 0.02521477f, 0.02184698f, 
    0.00849113f, -0.02397413f, 0.01711445f, -0.02982930f, 0.00280912f, -0.02638300f, 0.01632788f, -0.03229569f, 
    -0.00192959f, -0.00191692f, -0.01923098f, -0.01091765f, -0.01703962f, 0.00168803f, -0.02674727f, -0.00000545f, 
    0.02928131f, -0.00100068f, -0.00450499f, -0.01807127f, -0.03575565f, -0.02313571f, -0.02444226f, -0.02941706f, 
    -0.00194148f, 0.00099738f, 0.01763783f, 0.01935499f, -0.00575831f, 0.00253121f, -0.02130822f, 0.00680877f, 
    -0.00439879f, 0.00304956f, -0.03707847f, -0.00425989f, -0.00343561f, 0.03061000f, 0.02430849f, -0.00462434f, 
    -0.03114296f, 0.00252837f, 0.00671440f, -0.02226881f, 0.02358287f, -0.02302922f, 0.00580086f, 0.00210316f, 
    0.00785845f, 0.01132806f, -0.02969481f, 0.02236795f, -0.03024434f, -0.01223942f, -0.03601191f, -0.00210183f, 
    -0.00190860f, 0.01049864f, -0.03435682f, 0.01257709f, -0.01371864f, -0.02494579f, -0.03349839f, -0.00290950f, 
    -0.03506167f, -0.00503371f, -0.01041301f, 0.00119427f, -0.01724631f, -0.02663246f, 0.00528191f, -0.02388036f, 
    0.01941020f, 0.01199124f, -0.03605114f, 0.02789195f, -0.03717070f, -0.00095455f, -0.01394895f, -0.01228975f, 
    0.01083126f, 0.01591359f, 0.03137370f, 0.01372613f, 0.02948098f, 0.02128590f, 0.01586270f, -0.01803373f, 
    -0.01852689f, -0.02536761f, -0.02240715f, -0.03449266f, 0.02468251f, -0.00237621f, -0.01140425f, 0.00817023f, 
    -0.02265586f, -0.03795789f, -0.01746352f, -0.00632697f, 0.02415068f, -0.01453787f, 0.03076502f, 0.01165084f, 
    -0.01309164f, 0.00282142f, -0.02834113f, -0.00235812f, 0.00864865f, -0.01361415f, -0.02729894f, -0.03683781f, 
    -0.00300656f, 0.00058542f, -0.03021286f, 0.02822833f, -0.03164299f, -0.02466884f, -0.00566281f, -0.03613663f, 
    0.02523006f, 0.02127726f, -0.01483470f, -0.02590259f, 0.02840537f, 0.03004158f, -0.00721538f, -0.03281132f, 
    -0.00244214f, 0.00265440f, -0.00933898f, 0.01773028f, 0.01256277f, 0.02723060f, -0.01209484f, 0.00428954f, 
    -0.03802074f, -0.01994550f, 0.02616459f, 0.02886672f, 0.00516770f, -0.02783854f, -0.03000008f, 0.02017055f, 
    0.02665275f, -0.02920235f, -0.00537909f, -0.03739974f, 0.01095921f, 0.00694207f, -0.02601086f, -0.02645514f, 
    0.00919451f, -0.00803588f, 0.03243141f, -0.03635909f, 0.01070937f, -0.02281578f, -0.02485017f, 0.02162731f, 
    -0.00456956f, 0.00981559f, -0.01964522f, 0.02098703f, -0.00199258f, 0.01524348f, -0.03848184f, -0.02917265f, 
    0.02523204f, -0.02865928f, 0.01953007f, 0.00287277f, -0.01401965f, -0.02710372f, 0.00731409f, 0.00553673f, 
    -0.02541490f, -0.02494514f, -0.00948007f, 0.00017170f, 0.03035973f, 0.02635548f, -0.01517080f, -0.03041258f, 
    -0.03148688f, -0.01554166f, 0.00488301f, -0.03046382f, 0.01214072f, 0.01860512f, 0.02972043f, -0.00680604f, 
    0.00809203f, -0.01932670f, 0.01319106f, -0.03280802f, 0.00625672f, -0.02059479f, -0.01888326f, -0.02073588f, 
    -0.01602769f, -0.00976656f, -0.01459807f, 0.00957201f, 0.02756645f, -0.02758329f, 0.00692180f, -0.00186511f, 
    0.01312078f, -0.01823148f, -0.02084344f, -0.02763280f, 0.01383105f, 0.01542876f, -0.01074346f, -0.03415162f, 
    0.00216551f, 0.02736249f, -0.02942033f, -0.00521001f, -0.04065947f, 0.02306122f, -0.02345838f, 0.01017115f, 
    0.02946994f, 0.01189072f, 0.01086541f, 0.02598094f, 0.00928576f, -0.00238820f, 0.02914107f, -0.01013001f, 
    -0.03167902f, -0.03571866f, -0.02592451f, -0.03056085f, -0.01758432f, -0.00337895f, -0.00341609f, 0.01120806f, 
    0.00244716f, -0.01577005f, -0.03943571f, -0.01880097f, 0.02718764f, 0.00078301f, 0.00739088f, 0.00136954f, 
    0.02941607f, 0.03432684f, 0.01727330f, 0.00043656f, 0.01055209f, -0.02833335f, 0.02944734f, 0.00728276f, 
    -0.03241200f, 0.03232254f, -0.00693385f, -0.00406573f, 0.02144524f, -0.02049186f, -0.02078942f, -0.02904397f, 
    -0.00133061f, -0.00434308f, 0.00721516f, -0.02541208f, 0.02149272f, 0.00913441f, 0.00571077f, 0.01330226f, 
    -0.03388402f, -0.02946077f, 0.03020757f, 0.02308163f, -0.03553992f, 0.00923932f, -0.03527189f, 0.00635145f, 
    -0.01508390f, -0.01828053f, 0.01473869f, -0.01437245f, -0.00198775f, 0.00752768f, -0.03234318f, 0.02588161f, 
    -0.01019896f, -0.02969611f, -0.01548180f, -0.03044201f, -0.00749722f, 0.03469805f, -0.02659238f, -0.00227495f, 
    0.01704497f, -0.03267626f, -0.02881799f, 0.02882901f, -0.02133602f, -0.00623215f, 0.01587632f, 0.01166496f, 
    -0.00081421f, -0.00894182f, -0.01178544f, -0.02982502f, -0.03443403f, -0.00722527f, 0.02064943f, -0.03273234f, 
    -0.01146943f, -0.00055618f, 0.00732253f, -0.00445767f, 0.00574984f, -0.01731770f, 0.03032662f, 0.00644208f, 
    0.02776414f, -0.02237189f, -0.02945757f, -0.02043317f, 0.01498868f, 0.01282699f, 0.00639251f, 0.00764899f, 
    0.02560917f, 0.03024767f, 0.02742440f, -0.03989501f, 0.01298175f, -0.01462237f, -0.03239024f, -0.02592746f, 
    -0.03837589f, -0.02497105f, -0.02562124f, -0.01122543f, -0.01803032f, 0.00166408f, -0.02464447f, -0.01251727f, 
    0.02043831f, 0.01394869f, 0.01481192f, -0.00168249f, -0.02318031f, -0.00508926f, -0.00443994f, 0.02402218f, 
    -0.01558130f, -0.01143870f, -0.01308931f, -0.01529255f, 0.00870513f, 0.02238329f, -0.01071825f, 0.02052676f, 
    0.00936548f, 0.03208331f, 0.02905088f, -0.00904888f, -0.00763466f, 0.01641118f, 0.01352323f, -0.01394830f, 
    -0.03432838f, -0.00978177f, -0.02654621f, -0.03003873f, -0.00553612f, 0.02717548f, -0.01411052f, -0.01156237f, 
    0.00674280f, 0.01404022f, 0.03140692f, 0.00508813f, 0.01892742f, -0.01170112f, -0.00067426f, 0.02755072f, 
    -0.01936461f, -0.01534052f, -0.01620036f, 0.02742314f, -0.01769065f, -0.02197334f, -0.02981263f, -0.02112333f, 
    -0.04304571f, 0.02600936f, -0.00120123f, 0.01112310f, -0.01550581f, -0.00761542f, -0.03102338f, 0.02890685f, 
    -0.03730119f, 0.01195597f, 0.00763393f, 0.01208225f, -0.03413818f, 0.03103667f, 0.01613515f, -0.02710696f, 
    -0.03213597f, 0.00664915f, -0.00773840f, -0.01863576f, -0.03087390f, 0.02815268f, 0.02667749f, -0.01023671f, 
    0.02409017f, 0.00520234f, -0.01530338f, 0.01095081f, -0.01248738f, 0.02703422f, -0.02332433f, 0.01914102f, 
    0.03355639f, 0.01878797f, -0.00676636f, -0.00468582f, -0.03475343f, -0.00456188f, -0.03923450f, -0.03365704f, 
    0.00900476f, 0.00589503f, -0.00865880f, -0.03652301f, 0.01282698f, -0.03519307f, 0.01785592f, -0.02319762f, 
    -0.03480035f, 0.01896348f, -0.02469496f, -0.01244440f, -0.02091688f, -0.02257942f, -0.01673901f, 0.03603889f, 
    0.00368133f, 0.00571235f, -0.00851747f, 0.00114517f, 0.01023523f, -0.00547113f, -0.01448093f, 0.01830417f, 
    -0.01437772f, 0.02686207f, -0.02981046f, -0.02740942f, -0.00255168f, 0.01211800f, -0.03550151f, 0.02971873f, 
    0.01149832f, -0.01909444f, 0.02720542f, 0.01295232f, 0.01140546f, 0.02050722f, 0.02903855f, -0.00771611f, 
    -0.02819068f, -0.00020323f, 0.02000880f, 0.00896352f, 0.02875208f, -0.01529035f, 0.00300622f, 0.00639679f, 
    0.01612687f, -0.01869871f, 0.02306391f, 0.03925809f, 0.01621805f, 0.00225262f, -0.02249304f, -0.01045896f, 
    -0.01268674f, 0.01080659f, -0.02403984f, -0.00015934f, 0.01510083f, -0.00006894f, 0.01806442f, -0.00135028f, 
    -0.01283890f, -0.03663074f, 0.00173238f, -0.01410137f, -0.01070887f, -0.02851940f, -0.01731776f, -0.00261771f, 
    0.01939885f, 0.01470341f, -0.00154001f, -0.02750125f, 0.00517749f, -0.02658682f, 0.02341257f, -0.01138371f, 
    0.00438403f, -0.01269988f, 0.01123325f, -0.02651859f, -0.03562627f, 0.00284624f, 0.02459177f, 0.00176025f, 
    -0.01571934f, -0.02631134f, -0.00493083f, -0.03144238f, -0.02296103f, 0.01098318f, -0.03010937f, -0.01179455f, 
    0.01324883f, -0.01210402f, -0.00258786f, 0.00758816f, 0.03278780f, -0.00133180f, -0.02497836f, 0.00869780f, 
    -0.00120664f, -0.01824507f, -0.02024230f, -0.02522098f, -0.01843810f, 0.01238038f, -0.01775865f, -0.01550811f, 
    -0.01391100f, 0.01238577f, -0.03845322f, 0.01936591f, -0.02232095f, 0.02151173f, 0.03172618f, 0.02802613f, 
    -0.01347220f, 0.00362227f, 0.01722310f, -0.01069690f, -0.01971178f, -0.03241509f, 0.00597715f, -0.02905137f, 
    -0.00369975f, -0.02229297f, -0.00728383f, 0.01237045f, 0.02142577f, 0.02958197f, -0.02601889f, -0.00816899f, 
    -0.01487743f, 0.02441180f, 0.02395271f, -0.02633180f, -0.00964051f, 0.00589168f, 0.02273046f, -0.00416076f, 
    -0.03173311f, 0.00714348f, -0.00411611f, -0.00636221f, -0.01928474f, -0.01974025f, -0.02765031f, 0.02986633f, 
    -0.01783463f, 0.01922561f, -0.03650342f, 0.00893795f, -0.01581864f, 0.02457211f, -0.02182900f, 0.01728654f, 
    -0.03454735f, 0.01499284f, 0.01252379f, 0.00086420f, 0.01986651f, 0.01721802f, -0.01690263f, 0.01623917f, 
    -0.01388039f, 0.00090433f, 0.02986401f, -0.02402846f, -0.02128187f, 0.01465642f, 0.02006430f, -0.03539519f, 
    0.00865164f, -0.01762848f, 0.03129297f, -0.00466696f, -0.01932182f, 0.03220595f, 0.01359310f, -0.00095435f, 
    -0.01218348f, 0.02285683f, 0.02907774f, -0.02014075f, 0.02588837f, -0.00427153f, 0.03040697f, -0.00581571f, 
    0.00517896f, -0.00982863f, -0.00833016f, -0.00088013f, 0.02049363f, 0.00607582f, 0.01051474f, 0.01573668f, 
    0.01480106f, -0.00375616f, -0.01793641f, -0.03010645f, -0.03557773f, -0.03698668f, 0.02010280f, -0.02603832f, 
    0.02597854f, 0.00009479f, 0.00704579f, -0.00439829f, 0.00719263f, -0.00712522f, -0.00909764f, -0.01031113f, 
    0.02689089f, -0.00540299f, 0.02910034f, -0.00845276f, -0.02747743f, -0.03327748f, 0.01191630f, 0.00351278f, 
    -0.00805956f, 0.00423663f, 0.02855881f, 0.03036185f, -0.03406801f, 0.00853076f, 0.02454682f, -0.02080320f, 
    0.18822604f, 0.14627406f, 0.00448344f, 0.02673424f, 0.06753117f, -0.01279958f, 0.03108855f, 0.03751881f, 
    0.05343881f, 0.04976910f, 0.02605441f, 0.11247247f, -0.25975388f, 0.07533094f, -0.09603450f, -0.00383409f, 
    -0.03452411f, 0.08002543f, -0.03299797f, 0.04034887f, 0.01153911f, -0.00361180f, 0.05127020f, -0.01032776f, 
    -0.07743232f, -0.07079269f, -0.03934659f, 0.04965958f, -0.05721615f, 0.09625790f, -0.03411936f, 0.05564604f, 
    -0.02792441f, -0.08832262f, 0.25411063f, 0.09798160f, -0.07626616f, -0.17255925f, 0.00724577f, 0.05597151f, 
    0.07155140f, 0.06245796f, 0.06671371f, 0.06329674f, -0.00335680f, 0.09529568f, 0.01687221f, 0.11933854f, 
    0.17541470f, 0.16753714f, 0.03519084f, 0.38080847f, 0.03116897f, -0.02263347f, -0.00498389f, 0.04915965f, 
    -0.02362481f, 0.07751134f, 0.03584300f, 0.06392451f, 0.22364898f, 0.09021505f, 0.08165029f, -0.04750404f, 
    0.04259760f, -0.06054626f, 0.06257296f, 0.07196695f, 0.05141072f, 0.07577773f, 0.01577887f, 0.08277001f, 
    -0.02681003f, 0.00280289f, -0.01574393f, 0.05369503f, -0.03452761f, 0.02795038f, -0.03200820f, 0.01289944f, 
    -0.02117987f, 0.01484778f, 0.02893081f, 0.05402645f, 0.06452149f, 0.25052702f, 0.22682431f, 0.08164048f, 
    0.01034552f, 0.01071810f, -0.00439630f, 0.00993083f, 0.09065896f, 0.00857549f, -0.08845019f, 0.08408200f, 
    -0.23833989f, 0.10719804f, -0.11101997f, 0.07543563f, -0.01174117f, -0.00719657f, -0.03971669f, 0.01640152f, 
    -0.00124265f, -0.03092153f, 0.06369684f, 0.09661875f, -0.12486593f, 0.00099072f, 0.20990241f, 0.11587439f, 
    0.05134330f, -0.03441997f, 0.07432850f, -0.05614105f, 0.12915388f, 0.09513950f, -0.00444851f, -0.00696421f, 
    -0.20539497f, 0.04589932f, 0.10815383f, -0.07319099f, 0.03750903f, 0.06187333f, -0.00543372f, 0.05548574f, 
    0.06976198f, 0.01309072f, -0.05623050f, 0.08160320f, 0.00859820f, 0.01464933f, 0.15927909f, -0.11734688f, 
    -0.05238559f, 0.03757651f, 0.11567584f, 0.00757247f, -0.03303574f, 0.07681999f, 0.04003390f, 0.01774480f, 
    0.01677868f, 0.23175171f, 0.01994659f, 0.14185879f, -0.01491368f, -0.00990328f, 0.00419050f, 0.02514170f, 
    -0.03390851f, 0.05563486f, 0.08970761f, 0.02662106f, 0.09457925f, 0.09217905f, 0.08508518f, -0.09249633f, 
    -0.00982927f, 0.02356430f, -0.03051664f, 0.09090078f, 0.00929191f, 0.06369711f, 0.08654146f, 0.08729737f, 
    -0.04333355f, -0.23682581f, 0.00894019f, -0.03764753f, 0.03412917f, 0.03444920f, 0.14540710f, 0.13705201f, 
    0.06733494f, -0.01538689f, 0.01894803f, 0.02457154f, -0.16240580f, -0.11648760f, -0.00423345f, -0.23826070f, 
    0.01643224f, 0.02393271f, 0.15948761f, 0.09155665f, 0.06966363f, -0.05843804f, 0.06754690f, 0.04228212f, 
    0.08019672f, -0.04316367f, 0.00986794f, -0.13366151f, 0.01638877f, 0.03903529f, 0.12518187f, -0.02657615f, 
    0.06326766f, 0.08407065f, 0.11264330f, 0.06034479f, 0.07803778f, 0.02452738f, 0.15984823f, 0.33616686f, 
    0.05505770f, -0.00765675f, -0.00028395f, 0.04153999f, 0.02305350f, 0.06446753f, -0.02961688f, 0.02821913f, 
    -0.15964098f, 0.01957023f, 0.05307693f, 0.00777848f, 0.03935552f, -0.01613233f, 0.07510288f, -0.04929122f, 
    -0.02544423f, 0.01415239f, 0.07840092f, 0.03365035f, -0.09569196f, 0.00801984f, -0.09948724f, -0.20100072f, 
    0.05205292f, -0.01466854f, -0.00690041f, 0.15721612f, 0.04993248f, -0.03085043f, -0.02938274f, -0.04402588f, 
    -0.17684329f, -0.07178341f, 0.12121040f, -0.26927108f, -0.01856152f, 0.04359797f, 0.14289376f, 0.09273279f, 
    0.05975211f, -0.07408468f, 0.08193076f, 0.12313869f, 0.02721623f, 0.13055305f, 0.01109808f, -0.16205278f, 
    0.07444267f, 0.01913515f, 0.09562433f, -0.08642415f, 0.01999027f, 0.02606595f, 0.11448093f, -0.00434844f, 
    0.10025964f, -0.06684177f, 0.04792255f, 0.09219837f, 0.07904895f, 0.07235554f, -0.05253045f, -0.05895089f, 
    0.01980090f, 0.11974488f, 0.01579557f, 0.04524880f, -0.12946650f, -0.10022753f, 0.17509755f, -0.18897845f, 
    -0.08767892f, 0.01748124f, 0.06068587f, 0.04119135f, -0.03107113f, 0.00119055f, 0.04191626f, 0.09081663f, 
    0.14433014f, 0.32024923f, 0.19296293f, 0.04368008f, 0.00859596f, 0.01851044f, 0.06536548f, -0.00262037f, 
    0.02526588f, -0.03497076f, 0.11564197f, 0.04220362f, 0.22902951f, 0.11780693f, 0.01215501f, 0.24149466f, 
    -0.01310799f, 0.05072447f, 0.04047836f, 0.01317966f, -0.00725207f, 0.05596898f, 0.08932378f, 0.08827664f, 
    -0.10289893f, -0.07332469f, -0.09857924f, 0.10024944f, -0.02181212f, 0.00882672f, 0.02251421f, 0.07256705f, 
    0.11965974f, 0.05107065f, 0.01870890f, 0.05234609f, -0.09353264f, -0.01216744f, -0.05337437f, -0.08422862f, 
    -0.04348253f, -0.03096109f, 0.04429981f, 0.03195916f, 0.11147787f, 0.06688990f, -0.01763283f, 0.07635862f, 
    0.04722289f, 0.00386325f, 0.13097785f, -0.13861139f, 0.04820097f, 0.08832344f, 0.17926590f, -0.07955728f, 
    0.06194932f, -0.07452375f, 0.12449898f, 0.09670234f, 0.04119306f, -0.16484196f, 0.03543966f, -0.06328183f, 
    -0.09196370f, 0.01825979f, 0.13014796f, 0.11242373f, 0.01299863f, 0.00467290f, 0.05591552f, 0.04877492f, 
    -0.11836971f, -0.02028742f, 0.17511767f, -0.13257232f, 0.12635343f, -0.00448679f, 0.00581909f, 0.09725224f, 
    0.03644360f, 0.04810655f, -0.03767537f, -0.03417850f, -0.27831411f, -0.05995139f, 0.09708215f, -0.18760893f, 
    0.05040921f, 0.09011009f, 0.03103447f, -0.03875854f, 0.05898972f, 0.11012095f, 0.18033928f, 0.11934011f, 
    0.09695633f, 0.16575463f, -0.03251972f, 0.25282663f, 0.07579684f, -0.09689437f, -0.00529226f, 0.02771981f, 
    0.12750500f, 0.11173586f, 0.04960303f, 0.00094738f, -0.24504048f, -0.03342954f, -0.12981319f, 0.08121765f, 
    0.00489742f, 0.05739963f, 0.00881410f, 0.10825327f, 0.10887396f, -0.04249174f, -0.11994151f, 0.05689907f, 
    0.03852620f, 0.24096909f, -0.08431393f, 0.02138450f, -0.01285635f, -0.00647854f, -0.02065391f, -0.02548050f, 
    -0.02619303f, 0.09517300f, 0.07468553f, 0.02433663f, 0.09153833f, -0.01609305f, 0.06297418f, 0.00687575f, 
    0.00647942f, 0.00042900f, -0.02639744f, 0.13574867f, -0.01310986f, -0.00386452f, 0.05589480f, 0.11206046f, 
    -0.02264752f, -0.01798121f, 0.02265562f, -0.11987560f, 0.00266652f, 0.07687585f, 0.14107896f, 0.03695132f, 
    0.03138513f, -0.01381074f, 0.08804271f, 0.06332930f, -0.15993622f, 0.13954476f, 0.42749897f, 0.00882168f, 
    0.09817045f, 0.14637539f, 0.03622762f, -0.00623944f, 0.05060966f, -0.02590653f, 0.03153764f, 0.00980352f, 
    -0.16106802f, -0.05897313f, 0.03301833f, -0.08114453f, -0.00260636f, 0.12740102f, -0.00487999f, -0.02625902f, 
    0.10106659f, 0.01182196f, 0.01821054f, 0.05873123f, -0.04714574f, -0.04153670f, -0.03746935f, -0.24859570f, 
    0.01831293f, 0.00062932f, -0.04083028f, -0.03244103f, 0.06220814f, -0.04504530f, -0.03517066f, 0.05787361f, 
    -0.11409288f, 0.02036503f, 0.13526598f, -0.06572049f, 0.04230010f, 0.10292262f, -0.02391469f, -0.06647682f, 
    0.07669587f, 0.01752349f, 0.05870430f, -0.00426301f, -0.15034689f, -0.04943611f, 0.03894745f, -0.20170139f, 
    0.02165811f, 0.03246382f, 0.19044794f, 0.04067118f, 0.04789008f, 0.06400373f, 0.12927768f, -0.00129132f, 
    0.07562300f, 0.03543034f, 0.03848364f, 0.14629988f, 0.05437218f, -0.04450565f, 0.05587687f, 0.01446696f, 
    0.17557368f, 0.02140515f, -0.03309533f, 0.01304684f, -0.29932690f, -0.11542100f, 0.08374426f, 0.03625453f, 
    0.04063081f, 0.10648376f, 0.02222130f, -0.06585348f, 0.09011155f, 0.02479188f, 0.13061474f, -0.00401297f, 
    -0.21757998f, -0.15274610f, -0.02761415f, -0.15050854f, 0.09322870f, -0.02532974f, 0.02623770f, 0.13183764f, 
    0.08636631f, 0.04228362f, -0.01002040f, 0.04652280f, -0.06877121f, 0.01049427f, 0.19407395f, -0.17806615f, 
    0.14304814f, 0.06686211f, -0.03819195f, 0.07845510f, 0.01389700f, 0.02342654f, 0.02637547f, 0.03620173f, 
    0.24699353f, 0.11532700f, 0.03517802f, 0.16511954f, -0.00596008f, 0.03610764f, -0.01836701f, -0.00471653f, 
    0.03930926f, 0.09373753f, -0.03934498f, 0.06383418f, -0.01121982f, -0.07326361f, -0.08758357f, -0.18558265f, 
    0.01263775f, -0.05195104f, 0.02552699f, 0.12963787f, 0.04276200f, -0.09972390f, -0.03519669f, 0.07822323f, 
    -0.05893639f, -0.05642224f, 0.02231695f, -0.20641033f, 0.05328828f, -0.01247674f, -0.05003117f, 0.06066836f, 
    0.03698824f, 0.01182189f, -0.01459489f, 0.02371210f, -0.00349365f, -0.06086909f, -0.09529222f, -0.16366115f, 
    0.01446736f, 0.10386714f, -0.04699830f, 0.09152945f, 0.08748744f, -0.02873550f, -0.02639700f, 0.03432521f, 
    0.01148760f, -0.05961261f, 0.15955479f, 0.27270687f, 0.02924754f, 0.00410382f, 0.00270539f, -0.02265044f, 
    -0.00974024f, 0.06778584f, -0.01965435f, 0.01983319f, 0.08172713f, 0.03235772f, 0.02511005f, 0.00191404f, 
    0.02836926f, 0.03182498f, -0.01774649f, 0.02180617f, 0.01169056f, -0.05627703f, 0.09486296f, -0.06706914f, 
    -0.01455628f, 0.03780302f, -0.00002980f, -0.30042350f, -0.01122083f, -0.07508880f, -0.02068384f, -0.03769656f, 
    -0.01749725f, 0.08178090f, 0.13334201f, 0.04258099f, -0.20419541f, -0.04505745f, -0.06330337f, -0.07116206f, 
    0.02123258f, 0.00552123f, 0.07690489f, 0.15011568f, 0.07189280f, 0.02980370f, 0.02073574f, 0.05156754f, 
    0.26665270f, -0.17299247f, 0.05697268f, 0.29712322f, -0.02349436f, -0.00666893f, -0.02185926f, -0.03906111f, 
    0.07822158f, 0.16604206f, -0.00029220f, 0.05225385f, 0.18991373f, 0.10961832f, 0.00774565f, 0.27797666f, 
    0.09296929f, 0.00082123f, -0.02274455f, 0.00233996f, -0.10651433f, 0.12703413f, 0.06295487f, 0.09361266f, 
    0.06678730f, 0.14506097f, 0.05532198f, 0.10191955f, 0.04512123f, 0.00748621f, 0.01788796f, 0.00206367f, 
    0.02999277f, 0.01443146f, -0.01809747f, 0.03220173f, 0.10418992f, -0.03824563f, 0.01711394f, 0.23440810f, 
    0.04789327f, 0.04850389f, -0.03395559f, 0.06057400f, 0.02737783f, 0.07589497f, -0.00259176f, 0.05382114f, 
    0.10067780f, 0.11845148f, -0.10852051f, 0.05931050f, 0.07399523f, 0.04909882f, -0.08695324f, 0.04390040f, 
    0.04717743f, 0.06575970f, 0.03285489f, 0.10434254f, -0.12037144f, 0.04329962f, -0.01204495f, -0.06012619f, 
    0.04608509f, 0.01806203f, 0.05770192f, 0.13013087f, -0.03458984f, 0.05711451f, 0.01605451f, -0.01656770f, 
    0.00931910f, -0.13539475f, 0.05982177f, 0.08893096f, -0.03993075f, 0.01056257f, 0.02874586f, -0.00403311f, 
    0.06119324f, 0.14747332f, -0.04769142f, -0.03137856f, 0.04608846f, 0.10454018f, 0.12207434f, -0.03138064f, 
    0.05391926f, 0.05250020f, 0.16556521f, -0.01798778f, -0.00907538f, -0.01391305f, 0.10211017f, 0.03222533f, 
    -0.15695331f, -0.01972619f, -0.02722574f, 0.05187210f, -0.01835842f, -0.03887240f, -0.08468164f, -0.00284319f, 
    0.05204241f, 0.04732559f, 0.05090199f, -0.01435791f, -0.24256974f, -0.15718304f, -0.09896683f, 0.01312959f, 
    0.03960563f, -0.01348553f, -0.00292583f, 0.14214140f, 0.09283061f, 0.00270776f, -0.02830397f, 0.06587041f, 
    -0.00641334f, -0.03198375f, -0.03977536f, 0.02115723f, 0.03025689f, -0.03848406f, 0.03127766f, -0.00486992f, 
    -0.03186795f, -0.03874254f, -0.01956507f, 0.03109430f, -0.01529072f, 0.00546572f, 0.02890035f, -0.02970816f, 
    0.01865789f, -0.02900229f, -0.01739792f, -0.01384686f, 0.01599406f, -0.02866597f, 0.00422837f, 0.02938295f, 
    -0.00515879f, -0.01574318f, -0.03683482f, 0.02445066f, -0.00091318f, 0.02487347f, -0.01527285f, 0.02354091f, 
    -0.03001118f, -0.02372301f, -0.02769881f, 0.02811947f, 0.01281898f, -0.00479539f, -0.00067525f, 0.03361410f, 
    -0.02783265f, 0.02674018f, 0.03427008f, -0.01877894f, -0.03596821f, 0.03461756f, 0.00499494f, -0.01300673f, 
    -0.01864283f, 0.01096023f, -0.01916764f, -0.02986316f, -0.03440728f, 0.01008069f, 0.01910538f, -0.00249582f, 
    -0.00753276f, 0.01319013f, -0.04155507f, -0.04066751f, -0.04992951f, -0.00507233f, -0.00139279f, -0.03819710f, 
    -0.01738374f, -0.02620400f, 0.01326294f, -0.02054384f, -0.00984690f, 0.01246994f, -0.00832242f, -0.01442481f, 
    0.00306339f, -0.01348274f, 0.00866234f, -0.03121025f, 0.01666763f, 0.02359254f, -0.01515790f, -0.02803717f, 
    -0.00841227f, 0.02246268f, 0.00154823f, -0.03338827f, 0.02150881f, 0.01056581f, -0.04704058f, -0.04160496f, 
    0.00012218f, 0.02930945f, 0.00882502f, -0.01506277f, -0.00082183f, 0.01567413f, -0.01680632f, -0.00795616f, 
    -0.02123033f, -0.01299808f, 0.00402758f, -0.02368268f, -0.00050347f, -0.02214251f, 0.01458126f, -0.02972191f, 
    -0.02649720f, -0.02765022f, 0.00789969f, -0.00345491f, 0.00226411f, 0.00429887f, -0.00512020f, 0.00143936f, 
    -0.01003751f, -0.00363224f, -0.03511255f, -0.02162782f, 0.01517110f, 0.02122989f, 0.00241008f, -0.03208183f, 
    -0.02749044f, -0.03522950f, 0.00497149f, -0.00128576f, -0.03313797f, -0.00201619f, -0.01833777f, -0.03098188f, 
    -0.02686300f, -0.04005140f, -0.03298067f, 0.02691176f, 0.00768134f, -0.01853267f, 0.02036167f, -0.02595902f, 
    -0.03562564f, -0.03442081f, -0.02944062f, -0.02112721f, 0.00463542f, -0.00318041f, 0.00778230f, -0.00668061f, 
    0.02220695f, -0.00125077f, -0.03995977f, 0.01284944f, 0.00991312f, -0.02894210f, 0.01951714f, -0.04083473f, 
    -0.03388163f, -0.01106007f, 0.01018936f, 0.00905649f, -0.01121856f, -0.00509763f, -0.01977438f, 0.03540635f, 
    0.00919995f, -0.02179285f, 0.00785713f, 0.01058554f, 0.02973545f, -0.00287308f, -0.01131965f, 0.00561371f, 
    0.03561368f, -0.03386306f, -0.00365328f, 0.01072287f, 0.02605171f, -0.01226830f, -0.02678056f, -0.00421878f, 
    0.01948717f, -0.00225011f, -0.01502243f, 0.02291066f, 0.00458799f, -0.02979239f, -0.02199197f, 0.01779937f, 
    -0.03602412f, 0.01718356f, 0.00171128f, -0.03802690f, 0.00414661f, -0.02808123f, -0.01718282f, -0.00316192f, 
    0.01217750f, 0.01309914f, -0.00783690f, 0.00493939f, -0.02165394f, 0.00003202f, 0.00451449f, 0.00263783f, 
    0.02718893f, 0.03093469f, 0.01386517f, -0.03753038f, -0.00840628f, 0.00280169f, 0.00154927f, -0.03640603f, 
    -0.03368718f, -0.01627634f, 0.01640486f, 0.01881434f, 0.02432003f, 0.01623012f, -0.03904375f, -0.03072919f, 
    -0.01664230f, 0.00589433f, -0.03456677f, -0.02912549f, -0.02125733f, -0.03739799f, 0.01427991f, 0.01055418f, 
    -0.03867139f, 0.01519665f, -0.01560989f, -0.03101671f, 0.00532955f, -0.02302260f, 0.03125814f, 0.00868991f, 
    -0.01927208f, -0.01570705f, -0.01867920f, -0.03787597f, 0.01315983f, 0.02365519f, -0.02339946f, 0.03177288f, 
    -0.00744112f, 0.01863970f, 0.00266083f, -0.03710507f, 0.02248756f, -0.03542648f, 0.02002465f, -0.04089748f, 
    0.02923782f, -0.00521689f, 0.02802395f, -0.03604674f, -0.03480453f, -0.03100944f, -0.03418549f, 0.01133514f, 
    -0.02897453f, -0.02027697f, -0.02301727f, -0.00215104f, -0.03690631f, -0.03700960f, 0.02359030f, -0.01063498f, 
    -0.00794368f, -0.00947215f, -0.01010010f, 0.00660193f, -0.01676243f, 0.01650710f, 0.02483929f, 0.01209236f, 
    -0.01987984f, 0.02125288f, 0.02607307f, -0.00404920f, 0.01020584f, -0.02359112f, -0.00151210f, 0.01978575f, 
    0.01620964f, -0.03661701f, 0.02801153f, 0.00327562f, 0.01572297f, -0.02419309f, 0.01553414f, -0.01241477f, 
    -0.04724595f, 0.00291187f, -0.00842428f, -0.00065190f, -0.00883244f, 0.01343594f, 0.01526435f, 0.01927958f, 
    -0.00513155f, -0.02439966f, -0.03586914f, -0.04105493f, -0.03838321f, -0.00794787f, -0.02835438f, -0.03682286f, 
    -0.00745340f, 0.03022915f, 0.01556979f, -0.04241227f, 0.02520635f, -0.00058932f, 0.01978131f, -0.02269914f, 
    0.00226066f, 0.00628967f, -0.00569845f, -0.00652944f, -0.00489383f, 0.01301309f, -0.00087712f, -0.03989748f, 
    -0.01611820f, -0.03804215f, -0.03305293f, -0.00216391f, -0.02151636f, 0.02439933f, 0.01286406f, 0.00459628f, 
    -0.00603218f, -0.00831103f, 0.00367849f, -0.00386286f, -0.01129279f, -0.03341293f, -0.03517458f, -0.02916190f, 
    -0.03160360f, -0.01645939f, -0.01187948f, -0.00866853f, -0.04141512f, 0.02658438f, 0.01653627f, -0.04212188f, 
    -0.01679388f, -0.01319508f, -0.01376498f, 0.01111966f, -0.02370164f, -0.01699893f, 0.02497259f, -0.01444951f, 
    0.00026957f, -0.03180715f, -0.02488055f, 0.00952014f, -0.01958776f, -0.02628882f, -0.03974593f, 0.02288621f, 
    -0.01053569f, -0.00250696f, -0.01714002f, 0.02104990f, -0.01703046f, -0.01449007f, 0.03252581f, -0.01903444f, 
    0.03533046f, -0.00603822f, -0.00084093f, -0.00174320f, 0.00060953f, -0.03358650f, -0.02654931f, 0.02874758f, 
    -0.03205490f, -0.01093604f, -0.03248019f, 0.00695977f, -0.02432800f, 0.03057505f, -0.03807758f, -0.00583359f, 
    0.01093599f, -0.02038170f, -0.00958601f, -0.04616073f, 0.01094716f, 0.00308547f, 0.02124972f, -0.01213528f, 
    -0.02806874f, -0.00871306f, -0.00025893f, -0.00514660f, 0.00059205f, -0.01509901f, 0.01293659f, -0.02654129f, 
    0.02045811f, -0.01842591f, -0.02718684f, -0.00406074f, -0.02723832f, -0.01653763f, -0.00237641f, -0.00822174f, 
    0.02293484f, -0.01056755f, 0.01565181f, -0.02154604f, -0.02254482f, -0.00453907f, 0.02092922f, -0.02766094f, 
    -0.00692827f, -0.04050950f, -0.04067834f, -0.02572628f, -0.01734391f, 0.01798938f, -0.03273068f, -0.03859992f, 
    0.00656639f, -0.02477916f, 0.01587582f, -0.03014123f, -0.01211098f, -0.00431844f, -0.02868012f, -0.03896976f, 
    -0.02946801f, -0.01495479f, -0.02144300f, 0.01642215f, -0.03544836f, -0.00164312f, 0.02281294f, -0.03094796f, 
    -0.00409574f, 0.01626279f, -0.04074690f, 0.01385060f, -0.00385471f, -0.01299501f, -0.00069182f, 0.01455838f, 
    -0.02674999f, -0.03792304f, -0.02273960f, -0.02510894f, -0.03153102f, 0.01410774f, -0.00715105f, -0.02479828f, 
    -0.00709558f, -0.01666519f, -0.02849308f, -0.01824977f, 0.01136470f, -0.03650633f, 0.00893863f, 0.00252025f, 
    -0.00832877f, 0.02580297f, -0.00069898f, 0.00247890f, -0.03725074f, -0.02033794f, 0.02019346f, 0.00582926f, 
    -0.02050341f, -0.00752525f, -0.01524219f, -0.03281445f, -0.02907423f, 0.00243805f, 0.00446495f, -0.00604447f, 
    0.02006598f, -0.02134875f, 0.02322156f, 0.02477072f, 0.02011875f, -0.03336914f, 0.01666705f, 0.01972107f, 
    -0.02439811f, -0.00982299f, -0.00790504f, 0.01922647f, -0.01837576f, -0.03415304f, -0.00179964f, 0.01903827f, 
    0.02763281f, 0.02221012f, -0.00533351f, -0.01795574f, 0.00726412f, 0.01365979f, 0.00139852f, -0.00192073f, 
    -0.00759346f, 0.02564767f, 0.00389366f, -0.01212449f, -0.01012675f, 0.02354507f, 0.01628685f, -0.02899948f, 
    -0.00813165f, 0.03336169f, 0.03210216f, -0.04088239f, -0.02306665f, -0.01273145f, 0.02852076f, -0.02427159f, 
    -0.03518214f, 0.02862820f, 0.02901779f, -0.00791423f, -0.03861775f, 0.00003798f, 0.02415280f, 0.00914804f, 
    0.03083588f, 0.03263551f, -0.00085821f, 0.02259038f, 0.02716573f, -0.01006606f, -0.00035053f, 0.01823542f, 
    -0.00114503f, 0.01143278f, 0.01948009f, 0.01678827f, 0.03574106f, -0.02949005f, 0.01283545f, -0.01720600f, 
    -0.03840062f, -0.03799526f, 0.01979737f, -0.00734252f, -0.02861458f, -0.02263847f, 0.02006504f, -0.03680371f, 
    0.00573880f, -0.00068709f, 0.02049300f, 0.02445517f, -0.02835628f, -0.00157077f, 0.00985482f, -0.01644428f, 
    -0.00455686f, 0.00135370f, -0.03361688f, -0.03654427f, 0.00266338f, -0.02682437f, 0.03061412f, -0.00030751f, 
    0.00017452f, -0.00538534f, -0.01378052f, -0.04297348f, -0.01875628f, -0.01693033f, -0.03688041f, -0.02571782f, 
    0.00653174f, -0.00389787f, 0.03020755f, 0.00532948f, 0.01414987f, -0.03422932f, -0.02892119f, -0.02626105f, 
    0.01937621f, -0.02324975f, 0.01069850f, -0.01905119f, 0.02526310f, -0.01422128f, -0.02998550f, 0.00412456f, 
    0.00227873f, -0.01753539f, 0.01680490f, -0.01130945f, 0.00094974f, 0.01408829f, -0.04003594f, -0.02145660f, 
    -0.03407279f, -0.03432367f, 0.02095319f, -0.02900445f, -0.00992923f, -0.03820493f, -0.02189612f, -0.00591775f, 
    -0.03534304f, -0.02634453f, 0.01806036f, 0.00608380f, -0.02309266f, 0.02862018f, 0.02616483f, -0.04155518f, 
    -0.02997882f, 0.00411522f, -0.01762851f, -0.04056775f, 0.00436405f, 0.02059953f, 0.01282306f, -0.04256582f, 
    -0.00303691f, -0.02833832f, 0.02352173f, -0.02574927f, -0.02582714f, -0.01388391f, -0.03808175f, 0.00633903f, 
    0.03399698f, -0.01376551f, -0.03636087f, 0.02122669f, 0.01575201f, 0.02838834f, -0.01771173f, 0.03188151f, 
    0.00324359f, -0.00287762f, 0.02613964f, -0.03207618f, 0.01662929f, -0.00898794f, 0.01846372f, -0.01686815f, 
    0.01437301f, -0.02513243f, -0.01797324f, -0.02210083f, 0.00570924f, 0.02902724f, 0.00506688f, -0.02346448f, 
    0.00694329f, 0.02136475f, 0.00074230f, -0.03549680f, -0.04818131f, -0.03480949f, -0.00923506f, -0.00507337f, 
    -0.01952174f, -0.01056492f, -0.01947423f, -0.03333019f, 0.01029986f, 0.01830836f, -0.03035749f, -0.00978627f, 
    -0.03463539f, -0.00183382f, 0.00358917f, 0.01982732f, 0.00714525f, -0.01799919f, -0.00653357f, -0.04257187f, 
    -0.01526937f, 0.02201005f, 0.02941539f, 0.01303976f, 0.01089452f, -0.03087659f, 0.00543819f, 0.01724025f, 
    -0.00227087f, 0.01969216f, 0.01987121f, 0.01665500f, 0.00994733f, 0.01778618f, -0.00700842f, 0.02392359f, 
    0.01506597f, 0.00364534f, -0.02949232f, -0.01811203f, -0.02997083f, 0.01581394f, 0.02250548f, -0.01871501f, 
    0.00471341f, -0.02940272f, -0.02569196f, -0.02117402f, -0.00671340f, 0.00959702f, 0.01617049f, 0.02276050f, 
    0.02872297f, -0.01630296f, 0.02285881f, -0.02421419f, -0.02629476f, -0.01105770f, -0.01816800f, 0.00740805f, 
    -0.03682830f, 0.02447655f, -0.00738223f, -0.02827227f, 0.02057813f, -0.02512256f, -0.03050127f, -0.02908751f, 
    -0.01062322f, 0.00097096f, 0.01347583f, 0.01552281f, 0.00298050f, 0.01277554f, 0.00214923f, 0.00563633f, 
    0.03160182f, -0.02475709f, -0.03271230f, -0.02016332f, -0.02429930f, -0.02086191f, -0.03203236f, 0.02573846f, 
    0.00583262f, -0.00955512f, 0.02686011f, -0.02867227f, 0.01299741f, -0.01698801f, -0.02619005f, 0.00354675f, 
    0.02416183f, -0.03454088f, 0.02262330f, 0.01721035f, 0.02370075f, 0.00136854f, 0.01629821f, 0.02276210f, 
    0.02600953f, -0.02567235f, 0.01967792f, -0.03970231f, -0.01244375f, -0.02363526f, 0.00519038f, -0.01768453f, 
    0.06729763f, -0.15255930f, 0.26075429f, -0.00726637f, 0.15983909f, 0.02537518f, -0.12463930f, -0.04969754f, 
    -0.04439587f, 0.00260627f, -0.05789986f, -0.02549692f, 0.05584056f, -0.17954680f, 0.02389119f, 0.16734743f, 
    0.04632271f, 0.01522596f, 0.03677258f, -0.05920129f, 0.06701092f, -0.15653749f, 0.04118904f, 0.00348667f, 
    0.04904941f, -0.03169290f, 0.09033397f, -0.14816348f, 0.06586120f, 0.05767225f, 0.04376192f, 0.00836137f, 
    -0.03654763f, 0.12391505f, -0.06723665f, 0.10353085f, 0.09867191f, 0.07808466f, 0.01349103f, -0.09676440f, 
    0.03232007f, 0.02405896f, -0.06228607f, -0.12060834f, -0.03017534f, 0.00386281f, 0.07645816f, 0.09765851f, 
    -0.05689558f, 0.03729076f, 0.28488958f, -0.04645451f, -0.19928694f, -0.00577411f, 0.00619854f, 0.03583468f, 
    0.02195509f, 0.09968539f, 0.03443924f, 0.15147763f, -0.12853317f, 0.12872623f, 0.02096923f, 0.02954322f, 
    -0.14143419f, 0.01714648f, -0.01029049f, -0.01164454f, 0.02419297f, -0.15713650f, -0.05126249f, -0.04884880f, 
    0.16508922f, -0.17008621f, -0.26809195f, -0.10551104f, 0.05924169f, 0.05017871f, -0.06540988f, 0.04522321f, 
    0.09254902f, 0.01112571f, -0.01114838f, 0.05538825f, 0.00602194f, -0.01859887f, 0.15480925f, 0.00821555f, 
    -0.09487790f, 0.06659562f, 0.06820096f, 0.01239312f, 0.00679841f, 0.09921367f, 0.10953723f, -0.00878965f, 
    0.43768337f, -0.32288072f, 0.23515463f, -0.31168661f, -0.05055960f, 0.16737214f, -0.06308548f, 0.06069352f, 
    0.05811634f, -0.00220283f, -0.11521890f, 0.06327226f, 0.10203963f, 0.03953691f, -0.06849998f, 0.01957862f, 
    0.01871228f, -0.03717300f, 0.01597010f, 0.07228070f, -0.05251278f, -0.07888694f, 0.01229524f, 0.03521860f, 
    -0.23995572f, 0.02502591f, 0.03188046f, 0.16898645f, 0.01451781f, 0.12939207f, 0.13102466f, 0.08799980f, 
    -0.07879409f, 0.07065275f, 0.03105576f, 0.09255370f, 0.10492665f, -0.24700072f, 0.12432650f, 0.00904015f, 
    0.07700478f, -0.05233897f, 0.14925988f, -0.05015757f, 0.01756856f, 0.06578721f, 0.05973659f, 0.06181392f, 
    -0.01272511f, -0.19210215f, 0.06579132f, -0.06404345f, -0.01169126f, 0.05931921f, -0.03596168f, -0.06850271f, 
    0.07540100f, -0.04123125f, 0.00584000f, 0.05118505f, -0.11011238f, -0.03963048f, -0.21629004f, -0.05737712f, 
    0.07413970f, -0.04341344f, -0.04935818f, -0.17293830f, 0.10880504f, 0.06974176f, -0.02458148f, -0.12707914f, 
    -0.09333944f, -0.00604614f, 0.01962988f, -0.01160934f, 0.05642446f, 0.09238115f, -0.02757413f, 0.10748665f, 
    0.03011552f, -0.10784552f, 0.05159248f, 0.03453892f, -0.07066733f, 0.06474528f, -0.00811640f, 0.10959280f, 
    -0.10033444f, 0.06290385f, 0.00598857f, -0.01137336f, 0.04172452f, 0.08643332f, 0.04434030f, -0.12323640f, 
    0.10012092f, -0.04584241f, -0.00268962f, 0.15260674f, 0.09518563f, -0.10404080f, 0.10120410f, -0.02919602f, 
    0.02947993f, 0.05235957f, 0.03429274f, 0.08689315f, 0.09702227f, 0.00291905f, 0.17658392f, -0.07528258f, 
    -0.11428501f, -0.05394186f, -0.01678200f, 0.07592600f, 0.03183792f, -0.08035304f, 0.07024665f, 0.03048405f, 
    -0.49458730f, 0.28123808f, -0.11604515f, 0.08175097f, 0.04104694f, -0.01730132f, 0.00627923f, 0.02436466f, 
    -0.02092743f, 0.02173784f, -0.05099918f, 0.08719128f, 0.06299700f, -0.00747866f, -0.19609599f, 0.14467005f, 
    0.03411870f, -0.00014256f, 0.02981346f, -0.03358592f, 0.06782243f, -0.06378157f, -0.01192935f, -0.06175420f, 
    -0.02191593f, 0.05261271f, -0.01923882f, 0.12978913f, 0.03949155f, -0.09952649f, 0.06585115f, -0.03482677f, 
    -0.12796812f, 0.06315282f, 0.14661971f, -0.13207197f, -0.06861380f, 0.18144101f, 0.10167564f, -0.09430726f, 
    0.02737483f, 0.10005227f, -0.00921057f, -0.01894057f, 0.02248836f, 0.19020671f, -0.04690798f, 0.06731407f, 
    0.17201079f, 0.10178751f, -0.02582863f, -0.25159752f, 0.03829025f, 0.01563080f, -0.08348271f, -0.06100963f, 
    -0.04586733f, 0.05210450f, 0.06039079f, -0.01834347f, -0.39422911f, 0.10004883f, 0.02521440f, 0.34012383f, 
    0.09615526f, -0.00876073f, 0.11673740f, -0.07496886f, -0.02632941f, 0.07918506f, 0.04154645f, -0.01005365f, 
    -0.32276943f, 0.02512778f, 0.15548213f, 0.09772079f, -0.16177671f, -0.05509035f, 0.07529251f, -0.00985917f, 
    -0.01131095f, 0.00457983f, -0.02297677f, 0.12382057f, 0.09702956f, 0.01052707f, 0.20550473f, 0.00529981f, 
    -0.15859230f, 0.03253027f, 0.01001734f, -0.03851747f, 0.04786904f, -0.00043014f, 0.06138352f, 0.04372766f, 
    0.03980661f, 0.08649633f, 0.00214804f, -0.24356596f, 0.12848109f, 0.13167997f, -0.05342406f, -0.05311863f, 
    0.00479948f, 0.07430357f, 0.01050839f, -0.01687003f, -0.36099717f, -0.13269927f, -0.08145234f, 0.09154317f, 
    -0.06141662f, -0.10125220f, 0.12655018f, -0.05406768f, 0.25893274f, 0.05057644f, -0.10867567f, 0.01762562f, 
    -0.11802568f, -0.13940306f, -0.19031000f, 0.18919048f, -0.08396341f, -0.11673857f, 0.01570854f, 0.11041228f, 
    0.01761879f, 0.11487430f, 0.10926749f, -0.06763529f, -0.22885059f, -0.05410003f, -0.08772990f, 0.07135089f, 
    0.06742798f, -0.01656868f, 0.07078780f, -0.09498270f, 0.07187334f, 0.14642815f, 0.04033579f, -0.03405200f, 
    0.19028078f, -0.04229317f, -0.09427442f, -0.11821145f, -0.04896566f, -0.06962288f, -0.08408513f, -0.03208141f, 
    -0.02652705f, -0.06461424f, 0.00994305f, -0.03154278f, 0.15382956f, -0.02710991f, -0.09947027f, 0.03885281f, 
    -0.04993026f, 0.03785343f, 0.01458048f, 0.07099703f, -0.07255533f, -0.00835513f, 0.09381904f, 0.03522196f, 
    -0.20990291f, 0.04744582f, 0.12083659f, 0.05063006f, -0.03496663f, -0.02180435f, -0.00770310f, 0.06245479f, 
    -0.02275199f, 0.07129973f, -0.10099942f, 0.05064602f, 0.27901712f, 0.03557594f, -0.06985644f, -0.12182903f, 
    0.11396192f, 0.03081975f, -0.02824527f, -0.03447031f, -0.01267090f, 0.00852731f, 0.00421523f, 0.07170004f, 
    0.11249840f, -0.07626939f, 0.03134388f, 0.12345023f, 0.03946200f, -0.05689327f, 0.07470296f, -0.13469392f, 
    0.00765814f, 0.13681063f, 0.01718633f, 0.02588167f, 0.13305329f, -0.14729099f, -0.22173995f, -0.24763933f, 
    -0.03692773f, 0.00363962f, 0.03860112f, -0.15447013f, 0.03960136f, 0.12689470f, -0.12347604f, 0.08973605f, 
    0.23544550f, -0.15203875f, 0.00817424f, 0.04338505f, 0.00809286f, 0.03134927f, -0.03516499f, 0.06721090f, 
    -0.01230419f, -0.01992540f, 0.07122409f, 0.02786890f, 0.06307156f, -0.02985492f, 0.05935574f, 0.04997758f, 
    -0.02133927f, -0.00016103f, 0.16113137f, -0.05447841f, -0.01525637f, 0.07905786f, 0.02470835f, 0.03273614f, 
    0.15448804f, -0.15042712f, 0.02506012f, 0.01195499f, 0.17855147f, 0.01654165f, 0.05421458f, 0.06840736f, 
    0.00484428f, -0.01320258f, 0.02383593f, -0.13858178f, -0.24855898f, 0.15272808f, -0.11191977f, 0.11700454f, 
    -0.04270397f, 0.09524486f, 0.04805547f, -0.08787665f, 0.14760752f, 0.01518022f, 0.12010056f, -0.02728776f, 
    0.10584094f, 0.18244375f, 0.06127093f, -0.00834319f, 0.04982648f, -0.01321050f, 0.04253826f, 0.10987663f, 
    -0.04859669f, -0.06625737f, -0.05577391f, 0.05839898f, 0.18886040f, -0.10480773f, 0.04077042f, 0.05886791f, 
    0.04822661f, 0.04815494f, 0.02730739f, 0.06492620f, -0.05701545f, 0.07151198f, 0.04515853f, 0.01364929f, 
    -0.05437385f, -0.10235956f, 0.01389262f, 0.07548077f, 0.06200572f, -0.01867048f, 0.01118248f, 0.05760292f, 
    0.00129850f, 0.09327571f, -0.03266664f, 0.01707450f, 0.06042236f, 0.12733199f, -0.00481456f, 0.03350152f, 
    0.00634193f, 0.11066219f, 0.02335782f, 0.10828191f, -0.04164783f, 0.13375002f, 0.09618074f, 0.12680057f, 
    -0.09497601f, 0.07388028f, -0.16058899f, 0.12738119f, 0.02639983f, 0.03337625f, 0.04074767f, -0.06246830f, 
    -0.04665058f, 0.05329093f, -0.00688757f, -0.02375778f, -0.11014965f, -0.14557071f, 0.09903866f, 0.20417471f, 
    -0.02050515f, 0.09665027f, -0.02247603f, 0.04894250f, -0.13413925f, -0.08362059f, -0.10320630f, -0.18006867f, 
    0.04708461f, 0.11522136f, 0.10520365f, -0.04067858f, -0.13155285f, 0.02990206f, -0.05451637f, 0.06632046f, 
    0.03692783f, 0.02418120f, 0.01259926f, 0.04624353f, -0.14522718f, -0.15585008f, -0.10697759f, -0.16019060f, 
    -0.01666434f, 0.07652804f, 0.09564400f, -0.08736949f, 0.12625541f, 0.03548331f, -0.00306934f, 0.05732560f, 
    0.12048179f, 0.06183403f, 0.02629136f, 0.28870144f, -0.01022527f, -0.00595658f, -0.02595339f, -0.07222206f, 
    -0.01837224f, -0.12021977f, 0.03776169f, -0.20712513f, -0.05097522f, 0.13097276f, 0.09145218f, 0.20906353f, 
    -0.03023053f, 0.02125199f, 0.02458437f, 0.04060773f, 0.12159932f, 0.09732330f, -0.09761540f, 0.01750625f, 
    0.00918467f, 0.14706141f, 0.07453799f, 0.07819224f, -0.03628927f, 0.00820274f, 0.05429037f, -0.02734081f, 
    -0.02585360f, -0.06103718f, -0.02385941f, -0.04942064f, 0.03166116f, 0.02055434f, 0.00249750f, 0.12825818f, 
    -0.04858433f, 0.00960005f, 0.01085356f, 0.03920054f, 0.05207523f, 0.00004519f, 0.02985019f, -0.00383066f, 
    -0.21309589f, 0.02728957f, -0.04664061f, 0.05652142f, 0.03337562f, -0.04795802f, 0.02511999f, 0.00936179f, 
    0.11661771f, 0.03739833f, -0.14571777f, 0.09273880f, 0.05497842f, 0.06337132f, -0.10905539f, 0.14386381f, 
    0.01894739f, 0.05708202f, 0.07392009f, 0.08496823f, -0.01608433f, -0.07288846f, 0.03493797f, 0.01832651f, 
    -0.23282811f, 0.15320072f, 0.13249786f, -0.24215591f, 0.03816118f, -0.06004573f, -0.01522749f, 0.09831648f, 
    -0.03765436f, 0.02244466f, 0.01903062f, 0.07513244f, -0.14111115f, 0.17556047f, 0.15418892f, 0.07600892f, 
    0.00900678f, -0.05869739f, -0.04410624f, -0.05845260f, 0.00118072f, -0.00585170f, -0.01745367f, 0.06060270f, 
    -0.12846190f, 0.09961125f, -0.01441572f, 0.18493727f, -0.00988752f, 0.21728323f, -0.00384239f, 0.09096196f, 
    -0.04155376f, -0.13467892f, 0.00485421f, -0.04571448f, 0.03251871f, 0.07619184f, 0.13076815f, -0.13967474f, 
    -0.06632309f, -0.06407158f, -0.02614786f, 0.04098507f, -0.02126788f, 0.06894033f, 0.09427842f, 0.24666449f, 
    -0.01924587f, -0.09549376f, 0.00869224f, 0.11309856f, -0.20658213f, 0.08472957f, 0.03246816f, -0.06920478f, 
    0.02176073f, 0.05748215f, 0.00269928f, -0.03643275f, 0.22478533f, -0.08907117f, 0.01503929f, -0.06707886f, 
    -0.00306149f, -0.00387895f, -0.00285948f, -0.02345097f, 0.13010205f, 0.03062500f, 0.02322042f, 0.01707333f, 
    -0.03921662f, -0.16516782f, 0.13584375f, -0.09794051f, -0.13126341f, -0.12076768f, 0.00419302f, -0.03233946f, 
    0.02183457f, -0.02244796f, -0.03309000f, 0.01755110f, -0.09078243f, -0.10465356f, 0.00200433f, 0.11936998f, 
    -0.06117256f, -0.11427673f, 0.00741218f, -0.06638668f, -0.02793935f, -0.12023724f, -0.03551489f, 0.03524970f, 
    0.48340812f, -0.08052939f, -0.13161902f, -0.07383067f, -0.00642637f, 0.03112744f, -0.06220974f, 0.11440732f, 
    -0.05042323f, -0.03540972f, -0.06765542f, -0.03553455f, 0.17575243f, 0.03526390f, -0.11202371f, -0.13645858f, 
    0.04392191f, -0.13605247f, -0.04254377f, -0.03768097f, 0.14296213f, -0.13721222f, 0.00801504f, -0.04983205f, 
    0.11818629f, 0.00227546f, -0.01238022f, 0.01710144f, 0.03438627f, -0.01358542f, 0.08679006f, 0.17012337f, 
    0.06558573f, 0.01069917f, 0.06624487f, 0.10631908f, -0.05327014f, -0.03160511f, 0.04628733f, 0.06081996f, 
    0.04330844f, -0.04480362f, 0.05738477f, 0.05494295f, -0.06698436f, 0.05906584f, -0.00002332f, 0.07418416f, 
    0.06111198f, 0.09223058f, 0.09547685f, 0.06373416f, -0.01825172f, -0.05951623f, 0.06663944f, -0.04931752f, 
    0.15010341f, 0.01168915f, -0.07761163f, -0.11572359f, -0.18004842f, -0.19887894f, -0.16064425f, -0.00023895f, 
    0.08914880f, 0.05981240f, -0.03919174f, 0.13200156f, -0.01207236f, 0.05113290f, 0.15721495f, -0.13230889f, 
    0.20290340f, 0.17115119f, 0.19332704f, -0.19204907f, -0.01407479f, -0.03708641f, 0.12180411f, -0.00133524f, 
    -0.01434517f, 0.01247149f, -0.06755541f, 0.04342136f, -0.10460276f, 0.05255352f, 0.16936180f, 0.03705572f, 
    -0.06700249f, 0.09291039f, -0.02263560f, 0.10224196f, -0.02555208f, 0.08637845f, 0.09439374f, 0.11055794f, 
    -0.30327272f, -0.09493043f, -0.09111906f, -0.03873171f, 0.14799346f, 0.03414219f, 0.05118129f, 0.01864284f, 
    -0.01810945f, -0.07980520f, -0.08804503f, -0.07494703f, 0.28006056f, 0.17704205f, 0.03450438f, -0.04190706f, 
    0.07178146f, -0.06712607f, -0.02567359f, 0.05662338f, -0.02226573f, -0.08829609f, -0.03465511f, -0.05041147f, 
    -0.17622377f, 0.12747896f, -0.19291680f, -0.03035401f, 0.14324103f, -0.00822488f, -0.03218503f, -0.03637514f, 
    -0.00146565f, -0.04392042f, 0.13769819f, -0.07393847f, 0.05550492f, 0.15260679f, 0.12806371f, -0.06223907f, 
    -0.00304296f, -0.00928512f, 0.00460497f, -0.00643951f, 0.10155326f, 0.18382400f, 0.07586460f, 0.08641689f, 
    0.30199763f, 0.10870715f, 0.06396911f, -0.00280775f, -0.06725500f, 0.02651696f, 0.00104471f, 0.03105893f, 
    -0.00046261f, 0.10077158f, 0.05149766f, -0.13020076f, 0.28965765f, 0.13409901f, 0.08984081f, 0.04619955f, 
    -0.01929430f, 0.04702625f, 0.06253049f, 0.07230661f, 0.06223251f, -0.01772513f, -0.10141972f, 0.00007720f, 
    -0.00804897f, -0.05560796f, -0.06698331f, 0.02515440f, 0.07731763f, 0.04968545f, 0.12116411f, 0.09357588f, 
    0.18436395f, 0.08160307f, -0.05083847f, 0.08786530f, -0.03960668f, -0.16580743f, 0.10562462f, 0.13771607f, 
    0.06610402f, -0.02232037f, 0.10424846f, 0.07118623f, 0.05068200f, 0.06399115f, 0.03606941f, 0.14761966f, 
    -0.02700695f, -0.03764951f, 0.00496901f, -0.06595442f, -0.04870184f, 0.06252024f, 0.09085750f, 0.03578778f, 
    -0.01003749f, 0.00593982f, 0.06708772f, 0.12297378f, 0.14700340f, -0.14899558f, 0.01939325f, 0.21718581f, 
    0.02040831f, -0.08547322f, -0.01281131f, 0.02613944f, -0.05880982f, -0.00751094f, 0.04180959f, 0.05912689f, 
    0.12083932f, 0.11412079f, 0.08816625f, 0.10931366f, -0.04655594f, 0.08295701f, -0.01802928f, 0.08524244f, 
    0.03642377f, -0.01101803f, 0.02740788f, -0.04858230f, 0.26326752f, 0.14775810f, 0.13937080f, -0.09832737f, 
    -0.05282814f, 0.01805866f, 0.04396069f, 0.04416974f, 0.04322634f, 0.04579848f, -0.02065221f, 0.09094870f, 
    0.42317969f, 0.06748240f, 0.19767542f, 0.22119747f, -0.06843092f, 0.07859203f, 0.08867887f, 0.06949800f, 
    0.12588762f, 0.02561972f, 0.06358581f, -0.15678671f, -0.23887569f, -0.12221541f, 0.10549403f, 0.20408674f, 
    0.13712929f, 0.03710131f, 0.03569492f, -0.00126138f, 0.00021893f, 0.07186416f, 0.08863136f, 0.18159795f, 
    0.10048272f, -0.14687295f, 0.17561181f, 0.12349284f, -0.12380403f, 0.00009041f, 0.03409471f, 0.04015676f, 
    0.04080028f, -0.01049617f, -0.07730830f, -0.04479640f, -0.15046029f, -0.12718329f, 0.00069439f, 0.02504884f, 
    -0.04542649f, -0.04484535f, 0.00398712f, 0.04520077f, -0.09063707f, -0.17492814f, -0.00599302f, -0.15861553f, 
    -0.21516375f, 0.03048106f, 0.06720007f, -0.02764801f, -0.03990023f, 0.01905864f, 0.10191192f, 0.06733289f, 
    0.11544617f, -0.09717861f, 0.08895440f, -0.05258164f, 0.15449752f, -0.06439082f, -0.04260086f, -0.17168920f, 
    -0.00393721f, -0.02766548f, -0.02207468f, 0.05062833f, -0.04043876f, -0.11013103f, -0.04455588f, -0.03947398f, 
    0.07629079f, 0.03152243f, 0.01305512f, 0.09061278f, 0.00652926f, -0.01270237f, -0.00619616f, 0.02483198f, 
    -0.01471233f, 0.03603910f, 0.05232154f, 0.01738172f, -0.06941901f, 0.05776645f, 0.08391220f, -0.01768048f, 
    0.06974129f, 0.04440629f, 0.01050513f, 0.06308746f, -0.01584092f, 0.05373561f, 0.02411637f, 0.09546749f, 
    -0.01096613f, -0.05575212f, -0.14541775f, 0.00758309f, 0.11102948f, 0.10021177f, 0.01916596f, 0.06166890f, 
    0.11095626f, 0.03385574f, -0.06951500f, 0.00695404f, 0.17575373f, -0.15844926f, -0.08444162f, -0.02242076f, 
    0.10550167f, 0.05120173f, 0.01737174f, 0.00398008f, -0.12254944f, -0.06509719f, 0.03243395f, 0.10059752f, 
    0.06764512f, 0.02979224f, 0.09048498f, 0.09616376f, 0.05892793f, 0.00665436f, -0.00360443f, -0.02599486f, 
    -0.07050056f, -0.01454545f, 0.00079924f, 0.01562842f, 0.16682254f, 0.00371254f, 0.04856116f, -0.00026647f, 
    0.01937196f, 0.01711196f, 0.01990697f, 0.06476462f, -0.00693685f, -0.10211043f, -0.00806891f, 0.02596019f, 
    -0.09439418f, -0.24115759f, 0.02164672f, -0.04167307f, 0.20831233f, 0.04432795f, 0.08732058f, -0.01270123f, 
    0.05576954f, 0.12399618f, 0.08459478f, 0.17814413f, -0.08671392f, -0.04083752f, 0.01519469f, 0.18327357f, 
    0.12164233f, 0.11088459f, 0.04847997f, -0.06223510f, -0.04213753f, -0.02244997f, -0.13601519f, 0.11047170f, 
    0.35206133f, 0.17143248f, 0.01694214f, -0.12359648f, 0.05887300f, 0.10110341f, 0.09012441f, -0.10926518f, 
    0.11257111f, -0.07968495f, -0.05562840f, -0.00246164f, -0.17984810f, 0.08078281f, -0.24462347f, 0.09276710f, 
    0.11005183f, 0.14737555f, 0.00597886f, -0.03635564f, 0.01676980f, 0.03971487f, 0.18261899f, 0.10881159f, 
    -0.09783582f, -0.07829393f, -0.01836882f, -0.09636515f, 0.12071368f, 0.22514784f, -0.09465167f, 0.05622189f, 
    -0.02407717f, -0.09467656f, -0.02981761f, 0.04843435f, -0.20387471f, -0.26914322f, -0.16160645f, -0.17663547f, 
    0.18969825f, 0.05565793f, 0.01945789f, -0.01522011f, 0.00982440f, -0.00057579f, 0.10687299f, 0.03739118f, 
    -0.30572522f, -0.01247637f, 0.11581419f, 0.23088694f, 0.05917339f, -0.07857703f, 0.03051994f, 0.00216714f, 
    -0.00627645f, 0.08264481f, -0.06147725f, -0.01408435f, 0.27809298f, 0.12202547f, 0.01383223f, -0.05521406f, 
    -0.01126854f, 0.06708263f, 0.00597457f, 0.14762858f, -0.07969686f, -0.06052093f, -0.04740952f, 0.02606363f, 
    -0.12139630f, 0.03505114f, -0.03193848f, 0.15529513f, -0.02679702f, 0.01757454f, 0.06071778f, -0.07446916f, 
    -0.05542826f, -0.03865559f, 0.01552341f, 0.06606133f, 0.14680673f, -0.03183623f, 0.10980538f, 0.11848644f, 
    0.05062424f, 0.04269420f, -0.02060616f, 0.12163658f, 0.03126165f, 0.07730414f, -0.08830000f, -0.12904686f, 
    -0.10571033f, 0.02717943f, 0.13901399f, -0.02579732f, -0.03076884f, 0.04570416f, -0.02774469f, 0.05008359f, 
    -0.05663165f, 0.03100624f, -0.01012804f, -0.02852268f, -0.17195487f, -0.19108348f, 0.09985830f, 0.17933059f, 
    0.07044362f, -0.02408725f, 0.05805142f, 0.00305552f, -0.06515438f, -0.13874619f, -0.02214318f, 0.07773684f, 
    0.08386348f, 0.27837417f, 0.13327621f, -0.11951604f, -0.00920004f, 0.08266692f, -0.07731162f, -0.02108333f, 
    -0.05327937f, -0.02700092f, 0.03222129f, -0.12655219f, 0.07120457f, -0.10584685f, 0.03911635f, -0.01672161f, 
    -0.03146661f, -0.03842934f, 0.07714158f, -0.02957122f, 0.03247626f, -0.08658475f, -0.11598829f, -0.07653820f, 
    -0.16190548f, -0.06393956f, -0.20098640f, 0.04669440f, 0.00519205f, 0.06046907f, 0.01698579f, 0.03576272f, 
    0.02607842f, -0.01132989f, 0.05479329f, -0.00734818f, 0.16158248f, 0.04467493f, 0.04307086f, -0.00742753f, 
    -0.10008349f, 0.00914818f, 0.09519852f, 0.06656297f, 0.16187127f, 0.09668685f, 0.01484164f, 0.16934673f, 
    -0.02465068f, 0.05285146f, 0.17936507f, -0.05314032f, 0.02432356f, -0.04158320f, 0.01728704f, 0.05886701f, 
    -0.05165146f, -0.10236904f, 0.01202594f, -0.01734771f, -0.06083845f, -0.11099003f, 0.02834418f, -0.01145795f, 
    0.03122705f, -0.06087589f, -0.05894449f, -0.02351070f, -0.11370173f, 0.00086066f, 0.16003540f, 0.06628439f, 
    0.09447344f, 0.08162397f, 0.19116333f, -0.04199958f, -0.05956588f, 0.08720012f, 0.03376665f, 0.08313885f, 
    0.08660170f, 0.23584937f, 0.15942882f, 0.41080025f, 0.06515761f, 0.02257675f, -0.03053903f, 0.18532062f, 
    0.11530188f, 0.02176444f, 0.07177182f, 0.05325546f, -0.03092379f, -0.10020718f, 0.03752949f, 0.03512490f, 
    0.15486844f, 0.10450577f, 0.11142488f, -0.07581621f, -0.09933331f, 0.03054401f, -0.00938853f, 0.12107693f, 
    0.00911098f, 0.15858452f, 0.06100808f, 0.09689181f, -0.13520798f, -0.10263260f, 0.01247374f, -0.11250030f, 
    0.06201627f, 0.01502598f, 0.05145619f, -0.07323058f, 0.00058360f, 0.09898478f, -0.04790338f, -0.05845334f, 
    0.10526200f, -0.12917879f, 0.08439889f, 0.00312444f, -0.05467791f, 0.02431386f, 0.03388873f, 0.10069772f, 
    -0.05513829f, -0.04058358f, 0.06082083f, -0.05625036f, -0.29362339f, -0.04325264f, 0.04702631f, 0.08782356f, 
    0.09291588f, 0.10167427f, -0.02027036f, -0.04953581f, 0.10495274f, 0.01815418f, -0.00953992f, 0.11875232f, 
    0.20781942f, 0.13185516f, 0.22869955f, -0.13131967f, -0.04351167f, 0.17472446f, 0.01688028f, -0.00454915f, 
    -0.06250492f, -0.07354232f, -0.02122138f, -0.13563964f, 0.07071811f, 0.04730599f, 0.05765015f, -0.11143208f, 
    -0.11680961f, 0.01837031f, 0.08538559f, 0.07767826f, 0.17457183f, 0.13440943f, -0.00728015f, -0.01861192f, 
    0.10197895f, -0.02434539f, 0.31150916f, -0.05101018f, 0.00109898f, -0.03903590f, 0.08106491f, -0.04409576f, 
    -0.09132934f, 0.11766162f, -0.02474931f, 0.04383077f, 0.25666085f, 0.20802410f, 0.07103682f, -0.14988641f, 
    -0.09516716f, 0.10551111f, 0.07239372f, 0.00788356f, -0.02992301f, -0.15683067f, -0.02285418f, -0.01111890f, 
    0.09868829f, 0.16441815f, 0.04059959f, 0.14397138f, 0.16461878f, -0.06172477f, 0.09096570f, 0.09314165f, 
    -0.00471482f, -0.01386060f, 0.07789316f, -0.02423780f, -0.11118856f, 0.00925468f, 0.01801708f, 0.07888220f, 
    0.12620904f, -0.00496163f, 0.05083498f, -0.00287819f, -0.05859268f, -0.04652932f, 0.08780073f, -0.05234337f, 
    0.04018369f, 0.30322003f, -0.04522904f, -0.04710572f, -0.01886236f, 0.12455277f, 0.04574095f, 0.11695832f, 
    0.02554023f, -0.01268082f, 0.10500059f, 0.03664847f, 0.24150249f, 0.20827261f, 0.10229351f, 0.25221908f, 
    0.01405884f, -0.02599821f, 0.05343831f, 0.11735737f, 0.01378849f, 0.09718159f, 0.04385504f, 0.01971372f, 
    -0.27028415f, 0.06579873f, -0.00620535f, 0.01889377f, 0.15042087f, 0.10574248f, 0.11789696f, -0.04771118f, 
    0.03791218f, -0.00992566f, 0.09450445f, 0.01099230f, -0.26769564f, -0.04143089f, -0.24416375f, -0.13497873f, 
    0.10336262f, 0.09251878f, 0.03152315f, 0.07485186f, -0.02530478f, 0.08636299f, 0.10417730f, 0.08891051f, 
    0.34688964f, -0.08409921f, 0.04904963f, -0.11174180f, 0.03142069f, 0.07450252f, -0.00991212f, -0.06972949f, 
    0.05642744f, 0.02845524f, 0.03326541f, 0.02107511f, -0.09993782f, 0.07665390f, -0.05795747f, 0.00924478f, 
    -0.11921225f, 0.05472731f, -0.02334117f, 0.01217064f, -0.01714416f, -0.01708111f, -0.02467755f, 0.08323590f, 
    0.18675075f, 0.00574625f, 0.05800172f, -0.07141634f, 0.04670720f, -0.08532483f, 0.05452085f, -0.02848467f, 
    0.08084976f, 0.00435749f, 0.03382609f, 0.03262514f, -0.02186434f, -0.03099372f, -0.05767505f, 0.19868682f, 
    0.02071761f, 0.04663859f, 0.10843673f, -0.01899607f, -0.00577859f, -0.01154031f, -0.02524268f, -0.03862034f, 
    -0.01751102f, -0.05154452f, 0.07027718f, 0.00956830f, -0.09638184f, 0.00814554f, 0.00865162f, -0.05485843f, 
    -0.03148817f, -0.02577436f, 0.03592392f, -0.06165572f, 0.07899540f, -0.12138656f, 0.07632706f, -0.07930092f, 
    -0.07681488f, 0.01226348f, -0.09695757f, 0.02039587f, -0.01301040f, 0.01925717f, -0.10283974f, 0.01746988f, 
    -0.15797088f, -0.01298438f, -0.07117663f, -0.11258688f, 0.03831482f, 0.06109794f, 0.00645583f, -0.06342274f, 
    0.00904403f, 0.06126346f, -0.04777757f, 0.09310170f, -0.22210687f, 0.17778088f, -0.05831242f, -0.07032597f, 
    0.02865143f, -0.04717494f, 0.06460772f, 0.05101141f, 0.01899532f, 0.00678902f, -0.01637370f, 0.02542922f, 
    -0.03942573f, -0.06295768f, 0.00779512f, -0.08764954f, 0.00501820f, 0.16316001f, -0.03040341f, 0.05719958f, 
    -0.03216114f, -0.04631630f, -0.03765829f, -0.08057049f, -0.16660643f, -0.15282013f, 0.13517562f, 0.13406362f, 
    -0.12406000f, -0.07682900f, -0.01752164f, 0.00156896f, 0.00029391f, -0.00874102f, -0.03016343f, -0.00508491f, 
    -0.10677604f, 0.18983880f, 0.05489318f, 0.18635266f, -0.08071046f, -0.05466226f, 0.03103149f, -0.03015380f, 
    -0.07153354f, 0.05169564f, -0.00938033f, -0.00749088f, 0.06694990f, -0.10945573f, 0.17318554f, -0.02230279f, 
    -0.07063127f, 0.00874827f, 0.07770056f, 0.08016013f, 0.02660183f, -0.01745196f, -0.04960176f, 0.02829937f, 
    -0.19330056f, 0.10850285f, -0.02789048f, -0.01168885f, 0.12060603f, 0.00998586f, 0.01906027f, 0.04790395f, 
    0.06202136f, -0.01507408f, 0.04787111f, 0.02080620f, 0.08644731f, -0.15506585f, 0.21127681f, -0.17587225f, 
    0.11727802f, -0.05497663f, -0.13374135f, -0.06405134f, 0.04891993f, 0.07936148f, 0.00939369f, 0.07547924f, 
    0.17983174f, -0.09946164f, 0.09130384f, -0.06072286f, -0.03036669f, 0.05480469f, -0.02174902f, -0.05686698f, 
    -0.12186925f, 0.07936096f, -0.00553244f, -0.04050884f, 0.07175270f, -0.04594767f, 0.21749441f, 0.17356935f, 
    0.10097856f, 0.08327466f, 0.07168951f, 0.02877391f, 0.01327939f, 0.08296628f, 0.00900713f, 0.00539792f, 
    0.03875368f, -0.03230584f, -0.07121775f, 0.02130533f, -0.03276405f, 0.01795444f, 0.08661877f, -0.04824338f, 
    -0.07483246f, -0.04062721f, 0.09273650f, 0.03376907f, 0.00444665f, -0.03346846f, -0.04948113f, 0.03486600f, 
    -0.04106119f, -0.02061799f, -0.06665646f, 0.00447271f, 0.01238349f, -0.02034942f, -0.10246564f, -0.00356425f, 
    -0.08382545f, -0.08016292f, 0.08586843f, 0.03733191f, 0.02336253f, -0.06338323f, -0.04995809f, -0.01213302f, 
    0.02030668f, -0.01320061f, 0.02186922f, 0.01808936f, -0.08252066f, -0.10186829f, 0.06984626f, 0.17406586f, 
    0.05936816f, 0.05078393f, -0.01839656f, 0.05544683f, 0.02597497f, 0.06843704f, 0.00142958f, -0.00899780f, 
    0.11129898f, -0.00698619f, 0.09827624f, 0.00575731f, -0.00255211f, -0.02823369f, -0.02134766f, -0.02525987f, 
    -0.02511313f, 0.05180384f, 0.00967408f, 0.03055009f, 0.05466941f, -0.10204288f, 0.17573521f, 0.03527891f, 
    0.00497412f, 0.00139841f, 0.03799766f, -0.00960374f, 0.04972121f, 0.02761213f, -0.01243920f, 0.02222192f, 
    -0.03651014f, -0.13691464f, 0.02927568f, -0.06588700f, 0.07287490f, -0.08044691f, 0.01938406f, 0.09528751f, 
    0.10866240f, -0.03196825f, 0.02007431f, 0.15883318f, 0.02138510f, 0.06573887f, -0.11067032f, 0.03295193f, 
    0.06969284f, -0.08609701f, 0.02986629f, -0.00083944f, 0.05756158f, -0.05625247f, 0.05389929f, 0.14333728f, 
    -0.22901116f, 0.04389012f, 0.14989215f, -0.02351524f, -0.04292662f, 0.04789836f, -0.06568608f, 0.02200295f, 
    0.00783287f, -0.00864986f, 0.05303228f, 0.02222558f, 0.06034539f, 0.10535853f, -0.09389996f, 0.01320802f, 
    -0.05852614f, 0.01447911f, -0.01602953f, -0.01255470f, 0.04057534f, 0.00471564f, 0.03211831f, -0.02477000f, 
    0.12540363f, 0.04263703f, -0.00956048f, -0.05865170f, 0.16013339f, 0.04386005f, 0.04933354f, 0.03198052f, 
    0.05147932f, 0.05362234f, 0.03614308f, 0.05591182f, 0.34777635f, -0.06089122f, -0.03948275f, 0.21270363f, 
    0.14839867f, 0.00876931f, 0.03657822f, 0.00632239f, -0.02267495f, 0.09531365f, -0.02197455f, -0.03889686f, 
    -0.07714649f, -0.04152749f, -0.02932221f, 0.14580269f, -0.00103040f, 0.00571245f, 0.08964533f, -0.05242214f, 
    -0.03120898f, -0.03216226f, 0.05842846f, -0.08488651f, 0.19777997f, -0.13832504f, -0.03422748f, -0.15384196f, 
    0.03760786f, -0.05505737f, 0.00738852f, -0.00367977f, 0.08341108f, 0.00601661f, 0.02312901f, 0.03834270f, 
    0.00543941f, 0.00988366f, -0.07002924f, 0.05246925f, 0.07912598f, -0.02729624f, 0.12410868f, -0.03873905f, 
    0.05661914f, 0.03818502f, 0.06290895f, -0.07648285f, 0.00307354f, 0.00830466f, 0.09318916f, 0.11630613f, 
    -0.09894917f, -0.00005746f, 0.02379490f, 0.01789807f, -0.05927889f, 0.00938054f, -0.01905681f, 0.03189171f, 
    0.17847048f, -0.08210772f, -0.03269857f, -0.00183446f, -0.12983204f, 0.01201305f, -0.01596092f, -0.13391818f, 
    0.10669500f, 0.03600562f, -0.01866860f, 0.00005287f, 0.05152460f, 0.24753273f, -0.13720968f, 0.10462730f, 
    0.09922986f, 0.16432720f, -0.01100056f, 0.03966485f, -0.05708275f, 0.00523383f, 0.02354896f, -0.04636527f, 
    -0.13902062f, 0.08325294f, -0.07254192f, -0.06336369f, 0.08274296f, 0.08724703f, -0.00247460f, -0.01821401f, 
    0.03628293f, 0.03552348f, -0.02926668f, 0.07087384f, 0.01250764f, 0.07895231f, -0.18702771f, -0.19481778f, 
    0.07513981f, 0.08018746f, 0.06661627f, -0.11607657f, 0.12291707f, 0.06227311f, 0.01089837f, 0.00313762f, 
    -0.06649788f, -0.12509722f, 0.22615880f, 0.13375917f, -0.04808966f, 0.01050591f, 0.06491961f, 0.06314896f, 
    0.02585241f, -0.02677555f, 0.00346900f, 0.03103881f, 0.05850616f, -0.10640855f, 0.05323014f, 0.07751202f, 
    -0.04328986f, -0.06901688f, 0.01115309f, 0.03590706f, -0.02597088f, -0.09297911f, -0.02777137f, 0.11144923f, 
    0.13383725f, -0.15454730f, 0.05360239f, 0.21006417f, -0.09240304f, -0.01346096f, 0.04068125f, -0.02564439f, 
    -0.08025380f, -0.07445226f, -0.02551968f, -0.00617267f, -0.27136278f, 0.16645104f, 0.08935926f, 0.05289128f, 
    0.04923989f, 0.04374907f, -0.09556246f, -0.00821112f, 0.05289140f, 0.04420545f, 0.01891427f, 0.06050873f, 
    -0.12063852f, 0.00364255f, 0.11431593f, 0.00459297f, -0.04792665f, 0.01385210f, -0.05610873f, -0.02783504f, 
    -0.02605291f, -0.00308864f, 0.03955976f, 0.09552464f, 0.04832531f, -0.14093463f, 0.09596799f, 0.26885623f, 
    0.02979831f, 0.01206983f, 0.03979725f, 0.01964343f, -0.04181184f, -0.03166377f, 0.02411204f, -0.00524216f, 
    -0.09254269f, 0.01465434f, 0.10361657f, -0.01261715f, 0.02314541f, -0.05171750f, -0.01837772f, -0.00523793f, 
    0.10142460f, 0.11906305f, -0.07743107f, 0.04550514f, 0.00072528f, -0.03744224f, -0.06485580f, 0.08016107f, 
    -0.15639326f, -0.02781412f, -0.02019637f, -0.05360281f, 0.00108059f, -0.01698918f, 0.08103041f, -0.02146574f, 
    0.15280801f, 0.01174130f, 0.01896236f, 0.09717471f, 0.11259382f, 0.11151210f, 0.04899899f, 0.03878698f, 
    0.00231234f, 0.05637903f, -0.05299038f, 0.01573065f, -0.11056492f, 0.13537464f, 0.15535113f, -0.08488432f, 
    0.03990036f, 0.05418291f, 0.08934808f, 0.01385075f, -0.09782681f, -0.02164680f, 0.09366111f, -0.04652958f, 
    -0.15029000f, 0.13552454f, 0.06268709f, -0.03307486f, -0.12013809f, 0.05398998f, 0.01181160f, -0.02377553f, 
    0.07167523f, -0.01720252f, 0.07245417f, -0.06211622f, 0.08101028f, -0.04011665f, 0.10788313f, -0.03802737f, 
    0.16781820f, 0.11126430f, 0.07463083f, 0.06189568f, 0.07558216f, 0.03934808f, -0.03732133f, -0.01806152f, 
    -0.06296651f, 0.08707431f, 0.03784529f, 0.22544678f, 0.04227578f, -0.01386795f, 0.04785691f, 0.06729194f, 
    -0.06480110f, 0.01685934f, -0.09218816f, 0.02442739f, -0.00488777f, 0.14478120f, 0.04809525f, 0.03066088f, 
    0.13348329f, 0.11757705f, -0.03459937f, 0.15392555f, 0.05392373f, 0.02725135f, 0.05534912f, 0.03740133f, 
    0.04818370f, -0.06773246f, -0.01433097f, 0.14429377f, -0.04728482f, -0.00540639f, 0.02727327f, 0.10267927f, 
    -0.06307121f, -0.07619012f, -0.05766410f, 0.01246212f, -0.19647945f, 0.01379611f, -0.02985481f, -0.13233122f, 
    0.07331306f, -0.04974311f, 0.05597355f, -0.00643652f, -0.01238176f, 0.04361839f, -0.01042049f, -0.08379684f, 
    -0.05968840f, 0.00351041f, 0.22662684f, -0.03333241f, -0.06303654f, -0.05843299f, -0.04006124f, 0.05203467f, 
    -0.05261783f, -0.07693267f, 0.02412727f, 0.00253142f, -0.19431315f, 0.08088433f, 0.04730244f, 0.15218617f, 
    0.04253782f, 0.01710190f, -0.00143099f, -0.00783789f, -0.00357861f, 0.01188352f, -0.05329529f, 0.02879662f, 
    0.11136449f, -0.11935444f, 0.08922587f, -0.02311844f, -0.09165906f, 0.07619786f, 0.00237108f, -0.01593486f, 
    -0.01773658f, 0.00945944f, -0.00054393f, 0.07606661f, -0.07682502f, -0.11191729f, 0.07786100f, -0.00217623f, 
    -0.14614169f, 0.00602711f, -0.01144489f, -0.02693981f, 0.08841583f, -0.01199428f, -0.03291817f, 0.02436696f, 
    -0.22078818f, -0.04025544f, 0.14835855f, 0.04130263f, -0.08659390f, -0.01497554f, -0.02297611f, 0.04120020f, 
    -0.06602631f, 0.01040635f, -0.05677219f, -0.12938218f, 0.18355778f, 0.00363926f, -0.03889582f, -0.02031321f, 
    -0.02818842f, 0.00067139f, 0.09104799f, -0.01674222f, -0.05986850f, -0.04273309f, -0.02720385f, 0.08021828f, 
    0.16804084f, 0.04767409f, -0.03217760f, 0.09043092f, 0.03362831f, 0.05164387f, 0.16597711f, -0.05397620f, 
    0.06237453f, 0.09979440f, 0.00437875f, 0.05089317f, 0.01500191f, -0.07415752f, 0.06360925f, 0.14852904f, 
    0.07629910f, 0.04025120f, -0.01396145f, 0.01305113f, -0.04932623f, 0.00359208f, 0.13190582f, -0.07356314f, 
    0.32067007f, 0.03087103f, 0.04681065f, 0.04464858f, 0.00615602f, 0.01483208f, -0.01553843f, 0.02121132f, 
    -0.02548217f, 0.05056434f, 0.02820436f, 0.03814149f, 0.00737945f, -0.09002277f, 0.06445139f, 0.06567746f, 
    -0.02138210f, 0.01996570f, -0.03423658f, -0.00330762f, -0.00857619f, -0.00926292f, -0.04305706f, -0.00625254f, 
    -0.32567582f, 0.18725501f, -0.03156152f, -0.05567064f, -0.02012446f, 0.01775108f, -0.02303427f, -0.05338051f, 
    -0.07647216f, 0.04501738f, -0.00278104f, -0.05851170f, 0.08042260f, 0.09305234f, 0.04937109f, 0.00653408f, 
    0.06413808f, 0.15964690f, 0.08648849f, 0.10103767f, 0.02911605f, 0.07969412f, -0.00658708f, -0.06511062f, 
    0.29967624f, 0.02800213f, 0.08144952f, -0.03330149f, 0.12161913f, 0.11320463f, 0.02374163f, 0.12524027f, 
    0.07893681f, -0.11170622f, -0.02017837f, 0.00280697f, 0.19962311f, 0.00049192f, -0.08269374f, 0.30549812f, 
    -0.11606225f, 0.07085963f, 0.00998756f, -0.05905012f, 0.03175182f, 0.08341818f, 0.03365916f, -0.02919552f, 
    0.05890462f, 0.04468136f, 0.20000310f, -0.05238337f, -0.07591663f, 0.02954503f, -0.00675508f, 0.09640171f, 
    0.21605907f, 0.13680574f, 0.20588927f, -0.04088961f, -0.12150341f, -0.21452746f, -0.07503713f, -0.16448703f, 
    -0.02303440f, -0.00231929f, -0.02637329f, 0.03147032f, 0.04435798f, -0.08030482f, 0.02446394f, -0.15575339f, 
    0.07550205f, 0.01641495f, -0.12954171f, 0.07085109f, -0.10151815f, -0.04732207f, -0.00306009f, 0.06024291f, 
    -0.02987186f, -0.10256590f, -0.07565706f, 0.04037499f, -0.02708028f, 0.00331991f, 0.05448373f, -0.26756731f, 
    -0.02619860f, -0.06664746f, 0.05289263f, 0.09535180f, -0.01161917f, -0.04111600f, -0.02636056f, 0.11764761f, 
    0.13460279f, -0.01275408f, 0.05377307f, -0.09595368f, -0.01732104f, 0.03657031f, -0.04990333f, -0.01403004f, 
    0.04187754f, 0.07030740f, -0.09472772f, 0.08172870f, 0.15506385f, 0.02790532f, -0.11626071f, 0.04600307f, 
    0.07686995f, -0.04873770f, 0.02318588f, -0.00204023f, 0.05758082f, 0.00408319f, 0.02743763f, 0.04957828f, 
    0.21403205f, -0.10622893f, -0.03645810f, -0.09741223f, -0.07614266f, -0.04288497f, 0.03912297f, 0.05534601f, 
    -0.02275367f, 0.04208007f, 0.12742992f, 0.01762738f, 0.13079493f, 0.10843922f, -0.04232624f, -0.06429702f, 
    -0.08033608f, -0.05306184f, -0.03379063f, 0.00709188f, 0.00967125f, 0.10170337f, -0.04790958f, -0.06624895f, 
    -0.17063624f, 0.18212730f, -0.11806941f, 0.02285831f, -0.02730064f, 0.05316097f, -0.00191222f, 0.01207862f, 
    -0.04891927f, 0.06646734f, 0.03444800f, -0.04514411f, 0.17178974f, 0.04142075f, 0.24214251f, -0.35878125f, 
    -0.01901275f, 0.12540855f, 0.12452989f, 0.02255547f, 0.11654465f, -0.04532038f, -0.01947765f, 0.02163718f, 
    -0.13648674f, -0.05744365f, -0.07444112f, 0.13164839f, -0.01551328f, 0.10812090f, 0.01963910f, -0.06685282f, 
    0.04920133f, 0.02208546f, -0.00739593f, 0.00425550f, 0.25503317f, 0.01668896f, -0.05860600f, -0.24905933f, 
    0.07526153f, -0.06634671f, -0.01592588f, 0.06269717f, -0.03362790f, -0.02527525f, 0.07442790f, 0.08018214f, 
    -0.06995422f, -0.11623026f, 0.06083962f, -0.24489535f, -0.05564520f, 0.05136866f, 0.10875191f, 0.03137846f, 
    -0.03162846f, -0.02975797f, 0.03421662f, 0.09873281f, -0.08945417f, -0.10867843f, 0.04371399f, -0.09722847f, 
    0.00092532f, 0.04120826f, 0.02775567f, 0.00167952f, 0.01357601f, 0.04368379f, -0.05181326f, -0.00435296f, 
    -0.06292374f, -0.09279564f, 0.11183956f, -0.00028309f, -0.10266524f, -0.02871191f, 0.01797298f, 0.11968632f, 
    -0.01472475f, 0.00270600f, 0.03250972f, 0.00803715f, 0.08023713f, -0.03165124f, -0.08286456f, 0.21935138f, 
    -0.05759831f, 0.04936086f, -0.00611175f, 0.00741405f, -0.01703004f, 0.06152468f, -0.01536342f, -0.05964036f, 
    -0.18221444f, 0.22652192f, -0.01445011f, 0.12354188f, 0.01326325f, -0.04359578f, -0.03422660f, -0.04314411f, 
    0.08968461f, -0.10708406f, 0.07100569f, -0.04880277f, 0.01218561f, 0.14286384f, -0.05823272f, 0.08704703f, 
    -0.08445445f, 0.01133543f, -0.04274919f, 0.02105661f, 0.00661100f, 0.01358410f, -0.08750546f, -0.00071676f, 
    -0.16259904f, 0.03054368f, 0.14719260f, -0.13814032f, 0.06898560f, 0.01252340f, 0.03496245f, -0.00226805f, 
    0.01991419f, -0.00204251f, -0.10783395f, -0.05887014f, -0.06843548f, 0.06884515f, -0.04209170f, -0.28314015f, 
    0.05272175f, 0.00647523f, -0.02919272f, 0.06071817f, 0.01406315f, 0.09194916f, -0.04861795f, 0.01719470f, 
    0.04189042f, -0.10879242f, -0.01202864f, 0.08377093f, 0.06891823f, -0.00649468f, -0.08204844f, -0.03962308f, 
    0.10334706f, -0.08689184f, 0.14779420f, 0.08831321f, -0.14468795f, 0.09346257f, 0.01528270f, -0.17405903f, 
    0.01421289f, -0.07511093f, 0.05121018f, -0.00697535f, -0.10620371f, -0.10581771f, 0.03710218f, 0.10376685f, 
    -0.11711963f, 0.10264981f, -0.05347143f, -0.08623997f, -0.00426528f, -0.01221675f, -0.03054585f, 0.03127320f, 
    0.02653982f, -0.00806866f, 0.10620716f, 0.03587074f, 0.03906300f, -0.05841842f, -0.12620303f, 0.15829116f, 
    0.00460287f, 0.07938211f, -0.07461538f, -0.00319503f, 0.02237039f, 0.06312414f, 0.10529091f, 0.05324027f, 
    0.09681891f, 0.11111741f, -0.07676601f, -0.10995528f, -0.01720343f, 0.00696721f, -0.04823929f, 0.07335458f, 
    0.01405519f, -0.02891421f, -0.09674083f, -0.01038543f, 0.00300728f, 0.07299331f, 0.06066168f, 0.26622796f, 
    -0.03228502f, -0.07624884f, 0.02268010f, -0.10066305f, -0.01004957f, 0.08115377f, 0.09020190f, 0.03107764f, 
    -0.05567278f, -0.00193148f, 0.13932586f, -0.14174142f, -0.11512884f, 0.04077472f, 0.15209626f, -0.07056663f, 
    -0.02909970f, 0.05601417f, 0.05781134f, -0.01715823f, -0.03145780f, -0.03002216f, -0.06597871f, -0.13036485f, 
    -0.03590277f, 0.00360566f, 0.00066160f, 0.03373992f, 0.00957626f, 0.05852651f, -0.00243002f, -0.01144431f, 
    0.11958198f, -0.04265602f, 0.15535182f, -0.28189358f, 0.05411392f, -0.02647289f, 0.02409239f, 0.10201728f, 
    -0.02749186f, 0.09499586f, 0.04770937f, 0.02726291f, -0.19137241f, 0.19023509f, -0.01064769f, -0.10083745f, 
    -0.01577369f, 0.05750564f, -0.02089825f, -0.08543301f, 0.05248625f, 0.06612432f, -0.01180502f, -0.04491693f, 
    0.08062773f, 0.01026795f, -0.02754136f, 0.12547299f, -0.00338841f, -0.01631921f, -0.00700599f, -0.04244447f, 
    0.01646563f, -0.03385641f, -0.06889310f, -0.07197393f, 0.40794030f, 0.21827081f, -0.06719621f, 0.04603502f, 
    -0.00881996f, 0.10747119f, -0.03268692f, 0.05405667f, -0.02186154f, -0.01010408f, 0.03679633f, 0.01967828f, 
    0.15542804f, -0.01009229f, 0.09015401f, 0.06932237f, 0.05097958f, 0.03757095f, -0.10020480f, -0.03393967f, 
    0.06355456f, 0.00340251f, 0.02959117f, -0.05340508f, 0.38144243f, 0.03429788f, -0.11225837f, -0.28916168f, 
    -0.00289387f, -0.07361943f, 0.10155793f, -0.03580669f, 0.07738568f, 0.09248449f, 0.01803211f, 0.06866601f, 
    -0.23302890f, -0.04599221f, 0.11819113f, -0.01931108f, -0.13389398f, -0.02215057f, 0.08405642f, 0.03912942f, 
    -0.04382327f, 0.06219359f, -0.08298349f, -0.05688952f, 0.07624707f, 0.08652097f, 0.00177813f, -0.32351637f, 
    0.09168461f, -0.01316516f, 0.08345551f, 0.10681918f, -0.00144040f, -0.02494428f, 0.03650654f, -0.05381937f, 
    0.15987985f, 0.03828924f, -0.07095619f, 0.06641257f, -0.03240673f, 0.06395248f, 0.07736608f, -0.03686612f, 
    0.09273718f, 0.04404227f, -0.12725514f, -0.02621722f, 0.13696194f, -0.15496024f, 0.21225226f, 0.02836437f, 
    0.00756867f, 0.04168510f, 0.07546546f, 0.09939962f, 0.08804147f, 0.03108170f, 0.03780275f, 0.01600809f, 
    -0.08502659f, 0.01662015f, 0.06154894f, -0.22237048f, 0.03957409f, 0.11037094f, -0.02202149f, 0.06569450f, 
    -0.02158829f, 0.03149457f, -0.01435724f, 0.01509092f, -0.26870736f, -0.14237002f, 0.07576578f, -0.09557330f, 
    0.02688259f, 0.04072402f, 0.04905180f, 0.02984058f, -0.13828516f, -0.13708444f, 0.01853890f, 0.01037424f, 
    -0.10157463f, -0.12938438f, -0.05574149f, 0.03353660f, 0.04474542f, 0.00029284f, -0.09139492f, 0.03804214f, 
    0.07416642f, -0.00234405f, -0.04945737f, 0.05622035f, 0.25859874f, 0.07056145f, -0.13415854f, 0.09300055f, 
    -0.11596099f, 0.02699678f, 0.05658407f, -0.04581136f, -0.00681376f, 0.04635289f, 0.06272982f, 0.01257669f, 
    -0.10128689f, 0.02336455f, -0.01347716f, -0.25584245f, -0.02348628f, -0.03858251f, 0.02939530f, -0.00675602f, 
    -0.00728637f, -0.05923519f, -0.04070125f, -0.00818387f, -0.30436984f, 0.04685356f, 0.11838251f, -0.24769098f, 
    -0.03964604f, -0.03405170f, 0.14223760f, 0.00507270f, -0.04836075f, -0.01314144f, -0.00512898f, 0.05743671f, 
    -0.08971078f, -0.05722581f, -0.06182926f, 0.10567148f, -0.08582374f, 0.00562824f, 0.01352882f, 0.05752277f, 
    -0.01405043f, 0.02755334f, 0.00144198f, -0.00672789f, 0.13070396f, 0.08991887f, 0.06283766f, -0.21751596f, 
    -0.04729283f, -0.01068634f, -0.08936527f, 0.03159026f, 0.04675080f, 0.04854079f, 0.04384084f, -0.11188237f, 
    -0.16838378f, 0.06892040f, -0.01935137f, 0.18318553f, 0.04920687f, -0.01730100f, -0.01897428f, -0.04586349f, 
    0.10254547f, -0.01187748f, -0.06313483f, 0.03511704f, 0.02287984f, 0.00292511f, -0.06420796f, 0.13956945f, 
    0.02782664f, -0.03228329f, -0.04712091f, 0.04994087f, 0.00805398f, -0.04565696f, -0.02448174f, 0.01618275f, 
    -0.00406706f, -0.00043452f, -0.12090272f, 0.11949552f, -0.03214821f, 0.00337548f, -0.00544573f, -0.02334129f, 
    -0.05122442f, 0.08917260f, 0.11188792f, -0.11362347f, 0.00355494f, 0.03967760f, -0.01217338f, -0.09159231f, 
    0.01594408f, 0.08897342f, 0.00332552f, 0.00357190f, -0.02181008f, 0.10969426f, -0.05148133f, 0.03947883f, 
    -0.14661899f, -0.07472943f, 0.14047350f, -0.27463788f, -0.06436104f, -0.01711265f, 0.04750240f, -0.02347566f, 
    -0.04220373f, -0.00178983f, 0.02582500f, -0.06884240f, 0.10507051f, 0.10209089f, 0.00341430f, 0.08247177f, 
    -0.04207673f, -0.02076547f, -0.00694707f, 0.04814294f, 0.12610760f, 0.03923898f, -0.01975982f, 0.02753131f, 
    0.11141143f, 0.05446137f, 0.03645272f, -0.15942240f, -0.04248237f, 0.00845418f, 0.02586812f, 0.01887644f, 
    -0.09601698f, 0.03080575f, -0.00254067f, 0.07562289f, 0.08595793f, 0.02559218f, -0.04042744f, 0.01646357f, 
    -0.08665930f, 0.03943522f, -0.00198874f, 0.10634538f, -0.00803634f, 0.03925082f, 0.06367683f, -0.03105703f, 
    -0.04296552f, -0.05650944f, 0.06782643f, -0.10193326f, -0.03000851f, -0.00173388f, 0.03358672f, -0.12162949f, 
    -0.08966966f, 0.01072121f, -0.01986438f, 0.02957561f, 0.02828639f, 0.10582824f, -0.10645641f, -0.04247885f, 
    -0.06684936f, -0.02325157f, 0.01893948f, 0.00870456f, 0.02881601f, -0.09374969f, -0.05438542f, 0.10074115f, 
    0.20223965f, -0.08960036f, -0.05028183f, 0.17884304f, 0.13171929f, 0.06203492f, 0.03250930f, 0.17166705f, 
    0.12378135f, -0.00816751f, 0.08363464f, -0.12928155f, 0.04036817f, -0.08580448f, -0.09777980f, 0.14033793f, 
    0.03409265f, -0.00047084f, -0.11340266f, -0.03233036f, 0.06178015f, 0.04283957f, 0.03197340f, 0.00743686f, 
    -0.02545395f, -0.11539124f, 0.05628267f, 0.01169497f, 0.08830296f, 0.04534759f, -0.04573092f, -0.01283709f, 
    -0.06773306f, 0.10433177f, -0.01086798f, -0.07281756f, 0.11401708f, 0.11387113f, 0.02078672f, 0.10805669f, 
    0.00798962f, -0.05365761f, -0.06618121f, 0.01392391f, 0.00195607f, -0.08159842f, -0.01117750f, -0.01170274f, 
    0.17626329f, -0.00195685f, 0.11614848f, 0.16650639f, -0.04055027f, 0.01771595f, -0.01138656f, 0.00545851f, 
    0.01475022f, 0.08508136f, -0.05058434f, 0.02252952f, -0.02206350f, 0.03045975f, -0.22567420f, -0.17957965f, 
    -0.08911244f, 0.01653874f, 0.03512397f, 0.04675835f, 0.04962481f, -0.01244016f, 0.01163813f, 0.03357219f, 
    0.01900813f, -0.03016440f, 0.04077756f, 0.02509309f, 0.02866762f, -0.00569963f, -0.00909312f, 0.02977931f, 
    0.02060601f, -0.00741070f, -0.02267600f, -0.00039278f, -0.03276621f, 0.00656506f, 0.00353693f, -0.03108184f, 
    -0.00510818f, -0.03859809f, 0.00446903f, 0.02438243f, -0.03820045f, 0.02177880f, -0.02638247f, 0.01245626f, 
    0.01244764f, -0.02412812f, 0.02337554f, 0.00097373f, 0.02235856f, 0.03816975f, -0.03655589f, -0.02162327f, 
    -0.02281133f, 0.02977117f, -0.00844031f, 0.03077306f, -0.02104433f, 0.02954605f, 0.00469686f, 0.02672572f, 
    -0.01601893f, -0.01818898f, -0.01731452f, 0.01646402f, -0.03481638f, 0.01483255f, -0.01683820f, 0.02977725f, 
    0.00659514f, 0.02240857f, -0.01796700f, 0.02849453f, 0.02189355f, -0.02981616f, -0.00537406f, -0.02762559f, 
    0.01256788f, 0.01431915f, -0.02012519f, 0.01237056f, 0.03128302f, 0.01013484f, -0.01120927f, -0.02703460f, 
    0.02041032f, 0.01636287f, 0.01157840f, 0.02348559f, 0.02162829f, 0.01147692f, 0.03628964f, -0.01940053f, 
    -0.03359085f, -0.00279442f, -0.03973984f, 0.00958648f, 0.00825417f, 0.01203070f, -0.04070244f, -0.02077794f, 
    -0.02189950f, 0.01153610f, 0.00308344f, 0.02746722f, 0.03449566f, 0.03379300f, -0.02312380f, -0.02360398f, 
    0.01740306f, 0.00931756f, -0.01889255f, 0.02090047f, 0.02363305f, 0.00313705f, -0.00025991f, 0.02777699f, 
    0.02940605f, -0.03789466f, 0.00715996f, 0.00797749f, -0.01200199f, 0.02620185f, 0.02045186f, 0.03842228f, 
    -0.02694342f, 0.03994695f, -0.00423255f, -0.02722508f, -0.01284966f, 0.03372510f, -0.01637512f, 0.01481590f, 
    -0.00573710f, 0.01654108f, 0.01628661f, -0.03930424f, -0.01956356f, -0.02526567f, -0.01163494f, -0.01609038f, 
    0.01033187f, 0.01707805f, 0.03432669f, 0.01417323f, -0.02395616f, 0.02637452f, 0.02064551f, -0.03476159f, 
    0.01401671f, -0.02736972f, -0.00858992f, 0.01789695f, 0.02898811f, 0.02184670f, -0.00407022f, -0.03376919f, 
    -0.02347103f, 0.01310856f, 0.01997369f, 0.03335763f, -0.01846836f, -0.01674960f, 0.01617964f, -0.03469954f, 
    -0.04032400f, 0.02149910f, -0.00294031f, -0.03289882f, 0.02750253f, -0.03123297f, 0.00206521f, 0.00148049f, 
    0.02856420f, 0.03246444f, 0.02016644f, 0.03536084f, -0.00323789f, -0.02512162f, 0.02335363f, -0.02768733f, 
    -0.03231563f, -0.02360675f, 0.00073174f, 0.00446419f, -0.02421880f, -0.02483523f, -0.01478129f, -0.03497906f, 
    0.03790081f, 0.01902872f, -0.00758026f, -0.03446919f, -0.01011516f, -0.02900712f, 0.00023845f, -0.00611428f, 
    0.02179417f, 0.02049481f, 0.01745245f, -0.01764552f, -0.03775451f, -0.00920352f, 0.00758538f, 0.03451796f, 
    0.02252111f, -0.00084548f, 0.01402812f, -0.00567799f, -0.02972649f, 0.02020089f, 0.00126130f, -0.00501686f, 
    0.01315116f, -0.03692592f, -0.03984066f, 0.01670392f, -0.02650622f, 0.00823985f, 0.02964200f, 0.04062458f, 
    -0.00225087f, 0.02509354f, 0.00554437f, -0.03875155f, -0.02659715f, 0.01302619f, 0.01683356f, 0.01528099f, 
    -0.00776394f, -0.02321982f, 0.01699010f, -0.02924845f, -0.03883717f, 0.02054350f, 0.02289876f, -0.02552634f, 
    -0.03326761f, 0.01538965f, 0.02155111f, 0.00831223f, -0.01207153f, -0.00746328f, -0.00943035f, -0.02526499f, 
    -0.02376446f, 0.01315381f, 0.00063653f, 0.02670928f, 0.02298907f, -0.00352306f, -0.01070471f, -0.04020828f, 
    0.01583591f, -0.01923882f, -0.02563043f, -0.00946119f, 0.03813575f, 0.01544957f, -0.03924565f, -0.02376886f, 
    0.01377222f, -0.02016867f, -0.01793354f, -0.00102176f, -0.01702925f, 0.01386571f, -0.00431439f, 0.00288114f, 
    -0.02830781f, -0.02833563f, -0.01693716f, 0.00663046f, -0.01418454f, -0.03126168f, 0.01684972f, 0.02998182f, 
    0.00653237f, -0.00497968f, 0.01770149f, 0.02040332f, -0.04076543f, -0.02283942f, -0.00135417f, -0.03306985f, 
    -0.02902358f, 0.00509445f, 0.00588713f, -0.01701455f, 0.02789083f, 0.01161535f, 0.02893465f, -0.00231465f, 
    0.02570448f, 0.02478745f, 0.00921742f, -0.03670290f, 0.01403245f, 0.01494650f, 0.02432895f, 0.02553278f, 
    -0.01684764f, 0.00547659f, -0.03644666f, -0.00035511f, -0.01644852f, 0.00039037f, -0.01794088f, -0.02393515f, 
    -0.02370198f, 0.00813475f, 0.00903204f, -0.03716997f, -0.01915822f, -0.01548799f, -0.04000821f, -0.00017478f, 
    -0.01791448f, -0.03909694f, -0.00558191f, -0.04001097f, 0.00017742f, -0.02944126f, 0.01414971f, -0.01276475f, 
    0.01831495f, -0.03312941f, -0.03256669f, -0.01656044f, -0.02132469f, 0.03697361f, -0.04130733f, -0.01450184f, 
    -0.00116404f, -0.00302762f, -0.04114742f, 0.02602672f, -0.00667139f, 0.01437639f, 0.00560022f, 0.03144866f, 
    -0.01679627f, 0.01033759f, 0.00421287f, 0.02549776f, 0.02901546f, -0.00656513f, 0.00178181f, 0.00662969f, 
    0.02859641f, -0.01326043f, 0.00341011f, -0.01277270f, -0.02201466f, -0.02298190f, 0.02069128f, 0.02696478f, 
    0.02079861f, -0.02696081f, -0.01211165f, 0.02621702f, -0.00532851f, 0.00034001f, -0.02412161f, -0.01023356f, 
    0.01544286f, -0.03440703f, 0.01233507f, -0.00705788f, -0.01772429f, -0.02243077f, -0.02993595f, -0.01016938f, 
    -0.02650211f, -0.02066120f, -0.02471403f, 0.03344495f, -0.00549146f, 0.00025689f, 0.02017308f, -0.00296535f, 
    0.01134975f, 0.00707340f, 0.02297100f, -0.02288431f, 0.04003567f, -0.00774167f, -0.03628233f, 0.03334855f, 
    0.00322833f, -0.02137789f, 0.00126569f, 0.01972655f, 0.01627773f, -0.01167808f, 0.02069658f, -0.02179235f, 
    0.01859909f, 0.03632503f, 0.02597842f, -0.01303481f, -0.02023458f, 0.02455208f, -0.02169328f, 0.02640855f, 
    0.02948733f, 0.02965200f, -0.03324243f, -0.01030294f, -0.01578857f, 0.00413102f, 0.02465129f, 0.00123059f, 
    0.00563292f, -0.02223504f, -0.01158513f, 0.03516574f, -0.00268934f, 0.02482783f, 0.02830109f, -0.03605305f, 
    0.02808566f, -0.03689950f, -0.00205370f, 0.02857779f, 0.02472398f, 0.01369340f, -0.00120722f, -0.02199084f, 
    0.02721000f, 0.03153806f, 0.02910823f, 0.02871401f, 0.01515220f, 0.00048311f, -0.01230344f, -0.01866047f, 
    -0.04053493f, 0.00964521f, -0.01244175f, 0.02100118f, -0.02295992f, 0.01218880f, 0.00455023f, -0.02177916f, 
    -0.01198702f, -0.01460116f, 0.01083088f, -0.02010844f, -0.00169301f, -0.02842583f, 0.02835587f, -0.02860311f, 
    -0.00393003f, -0.01815975f, 0.02094321f, 0.04170677f, -0.02822847f, -0.00519860f, 0.01774981f, -0.03703120f, 
    -0.00337778f, 0.01615242f, 0.01965778f, -0.02168562f, -0.04139025f, -0.02297200f, -0.02350948f, -0.00996826f, 
    0.00947138f, -0.03801509f, 0.01343430f, -0.00583693f, 0.01774791f, 0.00621561f, -0.00847076f, -0.01693671f, 
    0.00528100f, 0.01579722f, 0.03584042f, 0.02045920f, 0.00377243f, 0.00784206f, 0.01602107f, -0.03113360f, 
    0.01215487f, -0.01108124f, 0.01304114f, 0.02626590f, -0.00753715f, -0.00347677f, 0.01539313f, -0.00461282f, 
    -0.02045379f, -0.01030490f, -0.03657518f, 0.04090486f, 0.01305099f, 0.02869735f, -0.01620801f, 0.01636206f, 
    0.03406251f, -0.00932209f, -0.01490816f, 0.02402188f, -0.01432384f, 0.02825412f, -0.02878228f, -0.00819792f, 
    -0.03521864f, -0.03921262f, -0.01139303f, -0.01889797f, -0.02668958f, 0.02327622f, -0.01112798f, -0.01645472f, 
    -0.02060715f, -0.00545022f, -0.03386298f, 0.01435377f, -0.01520218f, -0.03091911f, -0.00881655f, -0.02569909f, 
    -0.02289828f, 0.01145635f, 0.00685020f, -0.02570619f, -0.01535900f, -0.01752634f, -0.02302723f, -0.00856804f, 
    0.02354720f, -0.00938581f, 0.02505473f, -0.04162377f, 0.00901687f, -0.03573538f, -0.03241392f, -0.00143053f, 
    0.02537202f, -0.02823981f, 0.03498853f, -0.00251570f, 0.01333446f, -0.03841874f, 0.00209597f, -0.02649677f, 
    -0.00805422f, -0.02194266f, 0.00643432f, -0.01528051f, 0.01425788f, -0.02515966f, -0.00462161f, -0.01125281f, 
    0.00966173f, -0.00701678f, 0.01021516f, -0.02329148f, -0.02834285f, -0.03580820f, -0.00387901f, -0.02774331f, 
    -0.03626292f, -0.01709484f, -0.00332847f, -0.03447694f, -0.01812653f, -0.02896801f, -0.00001732f, -0.02994457f, 
    -0.03471752f, -0.02217393f, 0.02800765f, -0.00686115f, -0.04055939f, 0.02214334f, -0.03961805f, 0.02200829f, 
    -0.00821901f, 0.02813148f, 0.00732168f, -0.00706833f, 0.04049381f, 0.00965425f, 0.02626221f, 0.03698710f, 
    -0.02759348f, -0.02887655f, 0.00493697f, -0.02045861f, 0.00833538f, 0.00115254f, -0.04165746f, -0.01989560f, 
    0.02134857f, -0.01339344f, 0.00206576f, -0.02504682f, 0.02091233f, 0.00009921f, -0.02525606f, -0.01476019f, 
    -0.03890384f, 0.00518574f, -0.01285943f, -0.01493663f, -0.03805005f, -0.02187417f, -0.01406261f, -0.00439648f, 
    0.00030207f, 0.02223687f, -0.01729653f, 0.01751581f, -0.00202977f, 0.00586518f, -0.02566190f, -0.03536942f, 
    -0.03184366f, -0.01742230f, 0.03074213f, 0.00612761f, -0.01198611f, -0.02158937f, -0.03128355f, -0.01922351f, 
    0.00427458f, -0.02170838f, -0.00118016f, -0.02313338f, -0.02073283f, -0.00992179f, -0.03001161f, -0.02282283f, 
    0.01082951f, -0.01022504f, 0.00521693f, 0.01289747f, -0.02870307f, -0.01985392f, 0.01920913f, -0.02547991f, 
    0.01287913f, -0.04128949f, 0.01392664f, -0.03567139f, 0.00773368f, 0.01597170f, 0.02830490f, 0.02433267f, 
    -0.02334817f, -0.02149752f, -0.02952485f, 0.01109891f, 0.00057853f, -0.04158611f, -0.02633889f, -0.01035156f, 
    -0.02387293f, 0.01101268f, -0.02227977f, 0.00019376f, 0.00726692f, 0.04088024f, 0.02432785f, 0.02398428f, 
    0.01127859f, -0.01488268f, -0.02436148f, 0.00964105f, -0.00752277f, -0.00334380f, -0.02203236f, -0.01530467f, 
    -0.03801730f, -0.01054537f, 0.00431844f, -0.02554716f, -0.00143294f, 0.00272136f, -0.02331504f, 0.02485022f, 
    0.01479935f, 0.01984707f, -0.00940097f, -0.03226005f, -0.00677030f, -0.02025678f, 0.01393391f, 0.03002884f, 
    0.03293708f, 0.02942959f, 0.01195365f, 0.02601501f, 0.01049881f, -0.03956166f, -0.03840916f, 0.00133203f, 
    0.00959400f, -0.03882441f, 0.02726346f, 0.02060088f, -0.02053818f, 0.01952439f, -0.03694700f, 0.02703378f, 
    -0.01716653f, -0.00527468f, -0.00626897f, 0.03529252f, -0.03130835f, -0.01243702f, -0.02259559f, 0.01877028f, 
    -0.02735088f, 0.00161518f, 0.01332775f, 0.02122645f, -0.02104637f, 0.01340171f, -0.01907735f, 0.00422225f, 
    -0.01596851f, -0.01896433f, -0.02488177f, 0.02553011f, -0.02622856f, -0.01965452f, 0.01831943f, -0.00114676f, 
    -0.02114947f, -0.02003857f, -0.03936746f, 0.01019513f, 0.01996888f, 0.01886555f, -0.02451422f, 0.01611343f, 
    -0.00489131f, -0.00738417f, 0.00958510f, -0.01565489f, -0.00879989f, -0.00936204f, -0.03673610f, 0.02818419f, 
    -0.00137935f, 0.01651054f, 0.00173823f, -0.02397216f, -0.03541948f, -0.00600971f, 0.03207530f, 0.00531922f, 
    -0.00559192f, -0.03684933f, -0.02910310f, 0.02477705f, -0.00906773f, -0.02350394f, 0.00757595f, -0.03476205f, 
    0.02688758f, 0.01054092f, 0.02523468f, 0.00735872f, 0.01449773f, 0.02588832f, 0.00137903f, 0.02199740f, 
    0.02235022f, -0.04174959f, 0.02860832f, -0.03584626f, -0.04194053f, -0.02705440f, 0.02310219f, -0.03476532f, 
    -0.01635058f, -0.00598398f, -0.01670894f, 0.00576912f, 0.02775012f, -0.00572802f, -0.00659461f, -0.02059152f, 
    0.00434783f, -0.00479996f, 0.01036920f, -0.00581225f, -0.01239506f, 0.02108976f, 0.02171957f, -0.03567116f, 
    -0.00501870f, 0.00631526f, -0.00140498f, -0.03876286f, -0.02228719f, -0.00551625f, -0.00787914f, -0.03281642f, 
    -0.03299161f, -0.01707157f, -0.02932685f, -0.00421996f, -0.02988545f, -0.00343887f, -0.03662361f, -0.01053402f, 
    -0.00460697f, -0.01510227f, 0.01793526f, 0.01082615f, 0.03180668f, 0.00210099f, -0.00227139f, -0.00657777f, 
    -0.02190765f, 0.01484247f, -0.02790853f, -0.02628158f, -0.03872198f, 0.02433630f, 0.00039052f, -0.04137547f, 
    0.02542580f, 0.01478419f, -0.00218834f, -0.02668467f, 0.02845833f, 0.02098357f, 0.01318485f, 0.02702468f, 
    0.01951114f, -0.00735699f, -0.02917745f, -0.01656649f, 0.01074588f, -0.03126200f, 0.00509829f, 0.01504238f, 
    0.02207815f, -0.03390008f, -0.02884797f, -0.02538721f, -0.01342423f, -0.01665207f, -0.03351859f, 0.02693983f, 
    -0.01197373f, 0.01911206f, 0.02168099f, 0.02798769f, -0.02683001f, 0.02161639f, 0.00307035f, -0.00528642f, 
    -0.03958534f, 0.03680798f, 0.00496677f, -0.03652464f, -0.00783563f, 0.00450196f, 0.00478207f, -0.03777592f, 
    -0.00995491f, -0.02258945f, -0.00712366f, -0.00107028f, -0.03729301f, 0.02620986f, 0.01961621f, -0.02676342f, 
    -0.02015972f, -0.02049207f, 0.00039012f, 0.01955472f, -0.01743821f, -0.01625797f, -0.02007751f, 0.01970700f, 
    0.01688641f, 0.02863774f, -0.03588050f, -0.03968742f, 0.01377503f, -0.03799479f, -0.02988495f, 0.01921470f, 
    -0.00101426f, -0.00054520f, 0.03019306f, -0.00361859f, 0.01432015f, 0.00739280f, -0.03026127f, 0.02490987f, 
    -0.03178436f, -0.02906923f, -0.02408369f, -0.03039787f, 0.00604147f, 0.01454849f, -0.00548479f, -0.02926351f, 
    -0.01712674f, -0.01771343f, 0.03584833f, 0.02932142f, -0.01743228f, -0.02111457f, -0.01188856f, -0.04441496f, 
    0.01595824f, -0.02923734f, 0.02491119f, 0.01144449f, -0.04001464f, 0.00834445f, 0.00454458f, -0.01168196f, 
    0.03077535f, 0.01034135f, -0.01124839f, -0.01360701f, -0.02009058f, 0.03243872f, 0.03090406f, -0.02438247f, 
    -0.00205631f, -0.02881009f, -0.03599034f, 0.01679283f, -0.00544268f, 0.03079157f, 0.02526856f, 0.02789977f, 
    0.01562230f, 0.00654434f, -0.01520891f, -0.02492420f, -0.02473421f, -0.01538380f, 0.01377552f, 0.00530878f, 
    0.01052937f, -0.00711039f, -0.04482344f, 0.01640699f, 0.02758807f, -0.02413226f, 0.01436171f, 0.00460295f, 
    -0.02762532f, -0.00421557f, 0.00094535f, 0.01630595f, 0.03039629f, -0.03698466f, 0.02626706f, 0.01240247f, 
    0.02177479f, 0.01025108f, 0.01581976f, 0.00383525f, -0.00198539f, -0.03571925f, 0.02689741f, -0.00242402f, 
    0.00558662f, 0.01604052f, -0.03380641f, -0.00818156f, 0.00695658f, -0.01901349f, 0.02501479f, 0.03075561f, 
    -0.01209497f, 0.00788186f, -0.03965302f, 0.01653583f, -0.03864323f, 0.02534239f, 0.01156624f, -0.01609641f, 
    -0.02177208f, -0.03321724f, -0.02748369f, 0.00970919f, 0.01827081f, 0.02352864f, 0.00795012f, -0.01314673f, 
    -0.01462751f, -0.00628546f, 0.02520970f, 0.00768899f, 0.00191256f, -0.00144075f, -0.03121055f, -0.02387219f, 
    0.02620412f, 0.00641780f, 0.02532491f, -0.01577535f, 0.02190770f, -0.03476308f, 0.03094150f, -0.01869690f, 
    -0.02316275f, -0.00177251f, -0.03740626f, -0.01482297f, 0.00745608f, -0.00097918f, -0.02271579f, -0.02905572f, 
    0.02444889f, -0.01069481f, 0.01765056f, 0.03271859f, 0.02894778f, 0.00607473f, 0.03529570f, -0.02307093f, 
    -0.01281809f, 0.01746608f, 0.00196516f, -0.04011180f, -0.02959886f, 0.02865230f, -0.00531945f, 0.03716214f, 
    -0.00709117f, -0.01025284f, -0.03104692f, 0.00763004f, -0.04050805f, 0.02969427f, 0.02407866f, -0.02590982f, 
    0.02918983f, -0.01064233f, 0.00462701f, -0.02644458f, -0.03559193f, -0.00548208f, -0.00237074f, -0.00142038f, 
    -0.01701917f, -0.00226094f, -0.00024326f, -0.03815515f, 0.02412508f, -0.02347539f, -0.03399441f, 0.02126329f, 
    0.02062449f, -0.01173259f, -0.00280711f, -0.02994280f, 0.03499395f, -0.00647979f, 0.02879071f, 0.00447822f, 
    -0.00717968f, -0.03276411f, -0.02076426f, 0.02245275f, 0.03162146f, -0.00679520f, -0.00092430f, 0.00115676f, 
    -0.02588085f, 0.02627439f, -0.03629770f, -0.02641090f, 0.02578393f, -0.01959247f, 0.02059405f, -0.02704401f, 
    -0.00024345f, 0.02318694f, -0.01265693f, 0.02177540f, -0.03613614f, 0.00708410f, 0.03097960f, 0.03021706f, 
    -0.00068997f, 0.00357817f, -0.03053260f, -0.03228108f, -0.02866553f, 0.02001717f, 0.00725142f, 0.01316841f, 
    0.01668809f, -0.02519598f, 0.02454039f, -0.03449571f, 0.01707109f, -0.01296028f, -0.03030647f, 0.02016245f, 
    0.00982872f, -0.00278483f, 0.00232174f, 0.00914622f, -0.02637520f, -0.03308814f, -0.01800922f, 0.02084927f, 
    -0.01925661f, -0.01244272f, 0.01968751f, -0.03071686f, 0.02049663f, -0.01815205f, -0.00643644f, -0.03182082f, 
    0.01437984f, -0.01152972f, 0.00052169f, -0.01721914f, -0.02955401f, 0.03171933f, -0.01929303f, 0.01440180f, 
    -0.03026024f, 0.02941994f, 0.02070484f, 0.00894046f, 0.00614786f, -0.00515105f, 0.02808732f, -0.02656983f, 
    0.02798654f, 0.01237881f, 0.00452483f, 0.00395811f, 0.00423462f, -0.02482685f, -0.01797974f, 0.01196023f, 
    0.00039863f, 0.02687080f, 0.00223316f, -0.02991240f, 0.01485035f, 0.02849335f, 0.01144089f, -0.01902600f, 
    -0.02244804f, -0.00053370f, 0.00619114f, -0.03323281f, 0.01550534f, -0.00462428f, -0.02774398f, 0.00112143f, 
    -0.03890529f, 0.01200192f, -0.00822431f, 0.01855094f, -0.03647368f, -0.03088852f, 0.01150093f, -0.00657887f, 
    -0.01495806f, -0.00565677f, 0.01585380f, -0.02044811f, -0.02537865f, -0.00046949f, -0.00631904f, -0.03462315f, 
    -0.02092026f, -0.03078789f, -0.02460099f, -0.01385433f, -0.00691964f, -0.02144529f, -0.01166259f, -0.00308142f, 
    0.00470906f, 0.02569888f, -0.03692153f, 0.03382136f, -0.03046139f, -0.02262915f, 0.01179959f, -0.03017454f, 
    0.02813250f, 0.02965545f, 0.02083679f, 0.02665302f, 0.02228345f, 0.02740215f, -0.03281240f, 0.02237558f, 
    -0.04033433f, 0.01935785f, -0.02475529f, 0.01635244f, -0.03197450f, 0.01834251f, 0.00010070f, -0.02496818f, 
    0.03089176f, 0.02643537f, 0.02501911f, -0.01162009f, -0.02346260f, -0.01231863f, 0.02950246f, -0.03579484f, 
    -0.03195572f, 0.01138244f, -0.02927077f, -0.03601930f, 0.02107383f, -0.00084265f, 0.02126011f, -0.03860971f, 
    -0.00746038f, -0.00717573f, -0.02339213f, 0.00909400f, 0.02753427f, -0.02593199f, 0.03379629f, 0.01328380f, 
    0.02469487f, -0.01851503f, -0.02458608f, -0.02637812f, -0.01095713f, -0.01462645f, -0.02323439f, 0.03285626f, 
    0.03382314f, 0.00850490f, -0.03394366f, 0.00712384f, 0.00878619f, 0.02246608f, -0.02773727f, 0.01488763f, 
    0.00918406f, -0.00689166f, -0.00372556f, 0.02586831f, 0.00397756f, -0.01109380f, -0.03921318f, -0.03086706f, 
    -0.03875557f, -0.03244112f, 0.02773457f, 0.00324420f, 0.01473195f, 0.03396888f, 0.02727236f, -0.00405176f, 
    -0.00986871f, -0.01296609f, -0.01237484f, 0.00609695f, 0.00485307f, -0.01838779f, -0.00609943f, -0.01172644f, 
    0.02444465f, -0.03160816f, 0.00167879f, -0.02117707f, 0.02250656f, -0.00192811f, 0.00189340f, 0.01592863f, 
    0.02363747f, 0.01899664f, -0.02134242f, -0.04014741f, 0.02598696f, 0.00187171f, 0.01797040f, -0.02875373f, 
    -0.02652894f, -0.02457550f, 0.03144250f, 0.01126598f, -0.01714177f, -0.02260265f, -0.01924429f, -0.01199857f, 
    -0.00412645f, -0.01794250f, -0.01371927f, 0.00433410f, -0.02501604f, 0.00351392f, -0.03587953f, -0.02720900f, 
    -0.03431390f, 0.00974723f, -0.04160593f, -0.03290457f, 0.00825446f, 0.00051362f, 0.01831682f, 0.02286950f, 
    -0.00035419f, -0.02109661f, -0.00656328f, -0.00440842f, -0.00400970f, -0.01524437f, -0.02121991f, -0.01840806f, 
    -0.04079738f, 0.00513521f, -0.01483390f, -0.02215356f, -0.02655538f, -0.02725881f, -0.01830346f, 0.02824556f, 
    -0.02699594f, 0.02911544f, -0.03085332f, -0.00274179f, 0.01407890f, -0.02848720f, -0.00650968f, -0.01916511f, 
    -0.02090598f, 0.01352565f, -0.03736036f, -0.01646132f, -0.00040391f, -0.02249536f, -0.01908007f, -0.00956753f, 
    -0.02809920f, 0.02253247f, -0.00699898f, -0.01180210f, -0.01148451f, 0.01919858f, -0.03220845f, 0.01046390f, 
    0.01048641f, -0.03636501f, 0.02286978f, -0.02525618f, 0.02493698f, -0.02605117f, -0.04141488f, -0.02350718f, 
    0.01160624f, -0.02589298f, -0.00721865f, -0.01356390f, 0.01690940f, 0.02858276f, 0.01489430f, 0.02477137f, 
    -0.00977873f, -0.03822058f, -0.02747872f, -0.00279091f, -0.04017391f, -0.01840731f, -0.01147711f, -0.03583280f, 
    0.01178278f, -0.03017420f, -0.00856386f, -0.02858872f, 0.02560673f, -0.02924710f, -0.00929773f, 0.01137743f, 
    -0.00340188f, 0.02358565f, -0.01851285f, -0.02603470f, -0.00270691f, -0.00032495f, 0.00877806f, 0.00635377f, 
    -0.00764278f, -0.00505969f, -0.02392604f, 0.01211525f, -0.03348289f, 0.00571577f, 0.03157078f, -0.00332390f, 
    0.01482368f, 0.02676639f, -0.02884529f, 0.02603019f, -0.01218833f, -0.02717841f, -0.03911421f, -0.03529735f, 
    -0.00061828f, -0.00337881f, -0.01132141f, -0.03782783f, -0.00372565f, -0.02636115f, -0.03439531f, -0.02964762f, 
    0.01630503f, 0.02499452f, 0.00501011f, -0.01721071f, -0.00014942f, 0.00675053f, -0.03274500f, -0.00034159f, 
    -0.03607405f, 0.02772251f, -0.01563598f, -0.03395959f, 0.01685153f, 0.03731603f, -0.00464820f, 0.02817388f, 
    -0.02317975f, 0.00988857f, 0.01866992f, 0.00940319f, 0.01091498f, -0.03329497f, 0.02255692f, -0.01519373f, 
    -0.01493391f, -0.03026845f, 0.00078362f, -0.00432204f, -0.01819661f, -0.01906076f, -0.01201085f, 0.00847469f, 
    0.01549623f, 0.00006111f, 0.00052465f, -0.00731170f, 0.01083049f, 0.01580734f, 0.00138978f, -0.01332917f, 
    0.00350205f, -0.01479598f, 0.02942481f, -0.00708039f, -0.01771341f, 0.01071285f, -0.02238961f, -0.01258240f, 
    -0.00720245f, 0.01297888f, 0.00189459f, 0.01583043f, 0.00361301f, -0.02424119f, -0.02119065f, -0.02938034f, 
    0.02359780f, -0.00391474f, 0.02784429f, -0.01148300f, 0.02950395f, -0.02853169f, -0.03662999f, -0.02588808f, 
    0.02769084f, -0.02417319f, 0.03173753f, -0.02664878f, -0.00947564f, -0.01047594f, 0.01115792f, -0.01200390f, 
    -0.03904055f, -0.01500562f, -0.03903009f, -0.01001805f, -0.03070315f, 0.00751252f, 0.00316936f, -0.00270742f, 
    0.00893737f, 0.01910960f, -0.00692991f, -0.01281880f, 0.00327600f, 0.01482892f, -0.00368300f, -0.03426896f, 
    0.00534813f, -0.03494523f, 0.01658448f, 0.02643598f, 0.00741549f, 0.03583747f, 0.01202992f, -0.00921385f, 
    0.02911804f, -0.02227365f, 0.01369556f, 0.03937826f, 0.03104342f, -0.03133878f, -0.02105331f, 0.00544494f, 
    0.01049994f, 0.02456132f, 0.02915100f, -0.01122844f, -0.02073456f, 0.01785698f, -0.01587748f, -0.00081233f, 
    0.02865647f, -0.00341357f, -0.00635648f, -0.00326685f, 0.00589461f, -0.03054282f, 0.01506533f, 0.01244118f, 
    0.01598374f, -0.00270877f, -0.01067163f, 0.00973121f, -0.03865150f, 0.01234359f, 0.02083238f, 0.00697212f, 
    -0.01390707f, 0.01184633f, -0.01100956f, 0.03494185f, -0.03608727f, -0.02029540f, -0.00129129f, 0.03852472f, 
    -0.22013049f, -0.10180098f, -0.09437294f, 0.02921615f, 0.06820138f, -0.01905531f, 0.10053681f, 0.13784455f, 
    0.03072199f, 0.03829368f, 0.06187644f, 0.05299400f, -0.36046141f, 0.13514049f, -0.00484308f, -0.04130171f, 
    0.12419901f, -0.02111420f, 0.02892471f, 0.01972347f, 0.02550017f, 0.04546250f, 0.06772906f, -0.03622160f, 
    0.02097723f, -0.09153038f, 0.02969746f, 0.24288924f, 0.08689550f, 0.01270706f, -0.01928927f, 0.09260347f, 
    -0.05069900f, -0.01791552f, 0.03897256f, -0.07277612f, 0.31256703f, 0.10734802f, 0.11723577f, 0.11596487f, 
    -0.00732178f, -0.00327930f, 0.00323176f, 0.15531354f, -0.00030605f, 0.09759224f, 0.00385775f, 0.10714079f, 
    0.17204361f, 0.09337866f, -0.07609655f, 0.16605483f, 0.14735475f, 0.00867865f, -0.00371027f, 0.07388314f, 
    0.13063888f, 0.02029241f, -0.05068604f, 0.10299993f, 0.16630673f, 0.05642832f, 0.01301675f, 0.08482122f, 
    0.03722643f, 0.05408057f, 0.13941073f, -0.01888105f, 0.08945795f, -0.04120712f, 0.11176748f, 0.05330695f, 
    0.29753202f, 0.06735780f, 0.07480203f, 0.17379801f, 0.03970747f, -0.06858421f, 0.05184027f, 0.17532991f, 
    -0.09422019f, 0.01942998f, 0.14112327f, -0.07229850f, 0.23202428f, -0.13354865f, 0.11043868f, 0.07250667f, 
    -0.03797316f, 0.03240917f, 0.00817760f, -0.01289723f, 0.00069636f, 0.05821354f, 0.03104856f, 0.01919879f, 
    0.05497202f, 0.08821445f, -0.02826078f, 0.19211335f, 0.05591559f, -0.12925465f, 0.10458291f, 0.00395739f, 
    0.03070702f, 0.02536426f, 0.08135087f, 0.09977420f, 0.14163116f, 0.11789207f, -0.03793902f, -0.08714373f, 
    0.02867852f, 0.04634970f, 0.01550710f, -0.00862833f, 0.10502484f, 0.00766396f, 0.05678344f, 0.01634045f, 
    0.22024259f, -0.15701012f, 0.10587011f, -0.23270990f, 0.08405668f, 0.02412380f, -0.04107071f, 0.01341522f, 
    0.03998345f, -0.11625981f, 0.07595654f, 0.09272471f, 0.05066954f, 0.11116309f, -0.15562749f, 0.13139112f, 
    0.00505665f, -0.03645040f, 0.03745933f, -0.06985496f, 0.00266914f, 0.09344459f, 0.03178970f, -0.03248874f, 
    0.11526699f, 0.12756836f, -0.06974453f, -0.03886019f, -0.06763771f, 0.00267933f, -0.01211260f, 0.07148509f, 
    -0.11625545f, 0.03775795f, 0.03973961f, 0.05750230f, -0.16408606f, 0.09388499f, -0.00892817f, 0.16899109f, 
    -0.05570707f, 0.05052224f, 0.17526931f, 0.06931099f, -0.02174801f, -0.04373164f, -0.00051173f, 0.02666878f, 
    -0.02790235f, 0.12707563f, -0.03800871f, 0.13037059f, 0.04390152f, -0.04958649f, 0.07939313f, 0.02654592f, 
    0.10323151f, 0.00661632f, 0.04226570f, 0.10161813f, 0.04536605f, 0.04785779f, -0.12665774f, -0.24550343f, 
    -0.02457667f, -0.07650194f, 0.02524292f, 0.01551369f, 0.01615503f, -0.01118158f, 0.05959975f, 0.07492118f, 
    0.11325309f, -0.02018422f, 0.12483258f, -0.00773661f, 0.01654407f, 0.08083559f, 0.06527465f, 0.05332123f, 
    0.06168677f, 0.10307225f, -0.03132325f, -0.01085669f, -0.03968111f, 0.06895203f, 0.02321512f, -0.04689127f, 
    0.04541061f, 0.01358397f, 0.04018705f, 0.01689905f, 0.03047635f, 0.08724525f, 0.07771172f, 0.04307498f, 
    0.19190904f, -0.11003928f, 0.00352031f, -0.11893934f, -0.09031751f, 0.04292710f, 0.01799391f, -0.04628803f, 
    -0.01748081f, 0.01440043f, 0.06029883f, -0.01461901f, 0.05802651f, 0.16165459f, -0.00720291f, -0.20306750f, 
    -0.06776460f, 0.02200303f, -0.01747024f, 0.04321819f, 0.01771318f, -0.01672823f, 0.01877130f, 0.07126063f, 
    -0.05141858f, -0.01459925f, -0.13925603f, 0.06438038f, -0.06767025f, 0.09415779f, 0.08173256f, 0.09904803f, 
    0.00419588f, -0.00385307f, 0.00740139f, 0.02326524f, 0.06878462f, 0.13725078f, -0.15466635f, 0.02048365f, 
    0.02923916f, -0.00332398f, 0.02500460f, 0.03792696f, 0.04872625f, -0.00838538f, 0.00449742f, -0.01404553f, 
    0.02062145f, 0.21962008f, -0.01828361f, 0.04318336f, -0.03100768f, 0.03220543f, -0.09171954f, 0.09376036f, 
    -0.10618970f, 0.07067806f, -0.03111335f, -0.07887189f, 0.12584934f, -0.02223061f, 0.21391658f, 0.01169854f, 
    -0.10151955f, 0.25150058f, 0.04426483f, 0.09813576f, 0.03848319f, 0.05758530f, 0.06454147f, -0.06155982f, 
    0.26432902f, 0.07598189f, -0.12611744f, 0.00098219f, -0.02350676f, 0.03698618f, -0.01312384f, -0.02323385f, 
    -0.00392078f, 0.09219612f, 0.04338150f, -0.01003935f, -0.02972860f, -0.07553084f, -0.03583766f, -0.01119533f, 
    0.05050041f, -0.02811635f, 0.02918987f, 0.11866075f, 0.06219114f, 0.03817092f, 0.02815661f, 0.10135659f, 
    0.18960589f, 0.12654142f, -0.04362784f, 0.18744999f, -0.01927204f, -0.07518352f, 0.06192911f, 0.18648259f, 
    -0.07698737f, -0.01603453f, 0.04972947f, -0.03351153f, -0.37173322f, 0.12329131f, 0.05087409f, -0.30671066f, 
    -0.06499691f, 0.06327902f, -0.04960329f, 0.04941240f, 0.08315788f, -0.13663149f, 0.09277368f, 0.07753048f, 
    0.15799618f, -0.03703621f, 0.14337695f, -0.18593894f, -0.01009728f, 0.09407726f, -0.02413026f, 0.03559195f, 
    0.14762664f, 0.05924245f, -0.03215082f, 0.04293411f, 0.08209439f, 0.07273749f, 0.13508789f, 0.15515974f, 
    -0.05086167f, 0.12148296f, 0.05311911f, 0.09150404f, 0.03897964f, -0.07254057f, -0.03624129f, 0.02066239f, 
    0.14848869f, -0.11542258f, 0.09129862f, 0.11545570f, 0.00978464f, -0.06299298f, 0.01115299f, 0.13073972f, 
    0.01532133f, -0.02062191f, -0.06422028f, 0.00087859f, -0.05991364f, 0.06869528f, -0.05011194f, -0.10395557f, 
    0.11118811f, 0.11530472f, 0.00129207f, 0.09067959f, 0.05986164f, 0.04743975f, 0.08673155f, -0.04003979f, 
    -0.07872695f, -0.04301601f, 0.02763552f, 0.10723209f, 0.10585632f, 0.06040793f, 0.01597194f, 0.10682106f, 
    0.02553013f, -0.06837589f, 0.00363507f, 0.10031749f, -0.11102969f, -0.07370306f, -0.00039598f, 0.00372201f, 
    -0.03146602f, -0.05449034f, 0.02750729f, 0.04312091f, 0.08970868f, 0.00699193f, 0.00443149f, 0.10862961f, 
    0.08299270f, 0.07696740f, -0.00090841f, 0.07886788f, -0.03263238f, -0.01469277f, -0.02629541f, 0.08232326f, 
    0.05332183f, -0.01744379f, 0.02371954f, 0.05651025f, 0.00926434f, -0.07426853f, 0.28325886f, 0.28977457f, 
    0.00203135f, -0.00425495f, -0.06554799f, 0.20354335f, 0.00233219f, -0.05909649f, 0.14080052f, -0.01334554f, 
    0.26738238f, 0.04859150f, -0.22509152f, -0.13973977f, 0.14175431f, 0.04394866f, -0.01143725f, 0.08120017f, 
    -0.01043455f, 0.03152701f, -0.04056498f, -0.01451174f, 0.03948800f, 0.11678046f, 0.16339137f, 0.12582493f, 
    -0.02344763f, -0.01014658f, -0.04241414f, -0.03422299f, 0.06971797f, 0.06278638f, -0.00475489f, -0.12789004f, 
    -0.24789532f, 0.10103303f, -0.05345724f, -0.13907351f, 0.07185065f, -0.02420304f, -0.06815778f, 0.02776897f, 
    0.12721126f, 0.17839755f, -0.00529144f, 0.02231732f, -0.02357232f, -0.00193795f, -0.13568474f, -0.16096380f, 
    0.06467284f, -0.02782218f, 0.04603970f, -0.00190417f, 0.00880568f, -0.06244900f, 0.03647035f, 0.01277382f, 
    0.13116793f, 0.00097380f, -0.07957604f, 0.07933482f, -0.00943235f, -0.04778665f, 0.09431486f, 0.06231979f, 
    0.13049099f, 0.00512959f, -0.09724478f, -0.04679166f, 0.02186202f, 0.10759404f, 0.00053132f, -0.12910698f, 
    0.07043257f, 0.11476152f, 0.02753948f, 0.03939613f, 0.06962106f, 0.09652832f, -0.00797985f, -0.09717615f, 
    0.19342338f, 0.14546978f, -0.09300301f, 0.07455673f, -0.06770097f, -0.01477021f, 0.06246902f, -0.00389421f, 
    0.02184828f, -0.13798192f, 0.01944421f, -0.05042416f, -0.28472626f, -0.04694130f, 0.12337726f, 0.02360783f, 
    0.22475661f, 0.03402239f, -0.01945399f, 0.02770155f, -0.02431561f, -0.01152880f, 0.01370950f, 0.01410971f, 
    0.08017588f, 0.03747310f, 0.11374772f, 0.04801152f, -0.11966307f, -0.01949912f, 0.01846428f, 0.08321919f, 
    -0.03110317f, 0.00200286f, 0.04814669f, -0.00074280f, 0.22871770f, 0.07234348f, -0.22077718f, 0.06337796f, 
    -0.08745646f, 0.01842135f, 0.01503905f, -0.00525511f, 0.06756570f, 0.06792366f, 0.02098874f, 0.11441372f, 
    0.28465283f, -0.02034626f, -0.09594643f, 0.09987485f, 0.15332925f, 0.00728977f, -0.01023457f, 0.01283568f, 
    -0.02148794f, 0.07186149f, 0.00911071f, 0.11010007f, 0.01933246f, 0.10656244f, -0.03465767f, 0.01275708f, 
    -0.03886382f, -0.11098819f, 0.07118008f, 0.06454186f, 0.03579885f, 0.00022030f, 0.03884236f, 0.02484246f, 
    0.03570701f, 0.08444855f, -0.08522656f, -0.27632728f, -0.14287998f, 0.03875788f, 0.06261861f, -0.03061932f, 
    0.05212366f, -0.00488072f, 0.08434808f, 0.03387771f, 0.01448649f, -0.18588655f, -0.06812417f, -0.13006790f, 
    0.00795335f, 0.03817158f, -0.00023136f, -0.03850827f, -0.02336578f, 0.07724553f, 0.01411237f, -0.01015215f, 
    0.07373478f, 0.09226240f, 0.13967493f, -0.07947370f, -0.00195204f, -0.03004066f, -0.03419736f, -0.04057455f, 
    0.15568016f, -0.00079750f, 0.03582816f, 0.06811518f, 0.10286392f, 0.01381939f, 0.00354142f, 0.12267029f, 
    0.02446453f, 0.06185690f, -0.07685874f, 0.03092313f, 0.08349081f, -0.03476831f, -0.11333743f, -0.00708215f, 
    0.19731480f, 0.04170512f, -0.18480334f, 0.03625624f, -0.00168841f, 0.03760479f, 0.02419636f, -0.06139938f, 
    0.13784464f, 0.13972589f, 0.15848735f, 0.05434379f, 0.10906427f, -0.01562495f, -0.11342832f, -0.12864806f, 
    -0.00685839f, 0.04272270f, 0.01825081f, 0.01926067f, 0.06605988f, -0.04104479f, 0.04279611f, 0.03843524f, 
    0.06872492f, -0.01384817f, -0.11127312f, 0.33820537f, 0.05147124f, -0.09459429f, -0.02709691f, -0.00767360f, 
    0.14894937f, -0.05952579f, -0.00202388f, -0.06379455f, 0.18928917f, -0.01664316f, -0.09774153f, 0.01839618f, 
    0.16088845f, 0.00164670f, -0.00143522f, 0.07302766f, -0.12590258f, 0.06099538f, 0.08491077f, 0.03550870f, 
    0.25421306f, 0.21369727f, -0.08398636f, 0.00150672f, -0.03379899f, -0.03040683f, 0.06529371f, 0.01201634f, 
    0.19455652f, 0.02639945f, 0.14734149f, 0.19283295f, -0.01771473f, 0.00525494f, -0.08988266f, 0.24245308f, 
    0.06238933f, 0.01668860f, -0.04746016f, 0.06401202f, 0.08760860f, -0.03360050f, -0.00625043f, -0.06722874f, 
    -0.21473029f, -0.05837261f, 0.12209547f, -0.16135082f, -0.02344972f, -0.03481964f, -0.12666386f, 0.06233672f, 
    -0.00797807f, -0.07450121f, 0.16053531f, 0.00539889f, 0.11437850f, 0.10717785f, 0.02888815f, -0.01772591f, 
    -0.00894872f, -0.09270992f, 0.04563857f, 0.01392357f, 0.00196204f, -0.01930683f, -0.09663615f, 0.18164451f, 
    -0.00358125f, -0.09627735f, -0.00387283f, 0.02563437f, -0.04269063f, -0.04892236f, 0.05666611f, 0.08260676f, 
    0.06295397f, -0.01340771f, 0.06092500f, 0.03700335f, 0.09183449f, 0.01755399f, 0.10758824f, -0.19325723f, 
    -0.06572467f, 0.06891857f, 0.05743739f, 0.05955419f, 0.09403104f, 0.07742142f, 0.06508734f, 0.04595346f, 
    0.23867750f, -0.03787133f, -0.06781042f, 0.01108877f, -0.00420182f, 0.08014321f, 0.09549326f, 0.08750769f, 
    0.08349074f, 0.00833960f, 0.06740727f, 0.10963701f, -0.12288716f, 0.03182589f, 0.06388928f, 0.13753787f, 
    -0.05626826f, -0.05972977f, -0.07710402f, 0.05069803f, -0.06486825f, 0.04334285f, 0.09693896f, 0.03412150f, 
    -0.00749185f, -0.00496384f, 0.00326421f, -0.02791808f, 0.03576445f, -0.02033205f, -0.02705199f, -0.00199774f, 
    -0.00833767f, 0.00657208f, -0.00159064f, -0.03333912f, -0.00415381f, -0.01803673f, -0.02399546f, -0.03224073f, 
    0.01972329f, 0.02583052f, 0.03182247f, -0.00373917f, -0.03352820f, 0.02760507f, 0.02277260f, -0.01419827f, 
    -0.03280962f, -0.02189889f, -0.00758157f, 0.01314942f, -0.02951675f, -0.00478163f, 0.02560431f, -0.01128618f, 
    0.01753061f, 0.03452967f, 0.02645451f, 0.01884854f, 0.00310970f, -0.01211043f, -0.01859412f, -0.02869683f, 
    -0.01474130f, -0.00947549f, 0.01887801f, 0.02599037f, 0.02802191f, 0.02346006f, -0.02530358f, 0.00868379f, 
    -0.00140446f, -0.01731441f, 0.02488112f, -0.02403559f, 0.01616846f, -0.00972247f, -0.02482251f, -0.00757418f, 
    0.02327589f, -0.02764685f, 0.01494335f, -0.02483018f, -0.00459453f, -0.02937518f, -0.03495901f, 0.00191516f, 
    -0.00687923f, -0.02792463f, 0.00228171f, -0.00316235f, -0.02286262f, 0.00545915f, -0.01301532f, 0.02981249f, 
    -0.02419845f, -0.01505587f, -0.02195247f, -0.02173290f, -0.02989094f, 0.03509264f, 0.03438595f, -0.02687060f, 
    -0.02756247f, -0.02542774f, -0.02183760f, -0.03602240f, -0.00689144f, 0.01485609f, -0.00107993f, 0.03065229f, 
    0.02970597f, -0.00580145f, 0.02539277f, -0.02112164f, 0.02262306f, 0.02986705f, -0.03087148f, -0.01174616f, 
    0.03468077f, 0.03033285f, -0.00775008f, -0.00388058f, 0.01520386f, -0.00562478f, -0.01180894f, 0.03358659f, 
    0.00414001f, -0.01593053f, -0.01836300f, -0.01094401f, -0.03091285f, -0.02979275f, 0.03174357f, -0.02474792f, 
    0.00426304f, 0.01124683f, 0.00366729f, -0.00465409f, -0.00347026f, -0.02639692f, 0.00994154f, -0.01435885f, 
    0.02937100f, -0.03102039f, -0.00813211f, 0.01826705f, -0.00336869f, 0.00172484f, -0.02142756f, -0.03516693f, 
    -0.02293949f, -0.03404672f, 0.00354692f, -0.00921128f, 0.00548161f, 0.00807303f, 0.01186458f, 0.00265053f, 
    -0.01203256f, -0.00012495f, -0.03061620f, 0.00254339f, 0.01638599f, 0.02873207f, -0.03439977f, -0.02941890f, 
    0.01185412f, -0.02954733f, -0.02176071f, 0.01757660f, 0.01735630f, -0.03547546f, 0.02498371f, 0.00453413f, 
    -0.01855370f, -0.01192478f, -0.03220294f, 0.03351130f, -0.00547765f, -0.01357805f, -0.02556317f, 0.03501398f, 
    0.02420639f, 0.00134093f, 0.00672368f, 0.02435373f, 0.00195001f, -0.03282971f, 0.01294840f, 0.02427258f, 
    0.02125205f, -0.02373146f, 0.01822842f, 0.02786560f, -0.00793506f, -0.03463557f, 0.00926742f, -0.00125301f, 
    -0.00067684f, 0.00580852f, -0.01335913f, -0.02719833f, -0.02059346f, 0.02051390f, -0.01442819f, 0.03456237f, 
    -0.02084423f, 0.01494443f, -0.00295002f, 0.00384616f, 0.00024010f, -0.03421200f, 0.00487099f, -0.01553634f, 
    0.00204132f, -0.01690954f, -0.01752473f, -0.03298093f, -0.00186350f, -0.02358380f, -0.02530221f, -0.02911865f, 
    -0.02423449f, -0.02587383f, -0.01012258f, 0.00258200f, 0.00945604f, 0.03107786f, -0.00997556f, -0.01842836f, 
    0.00857812f, 0.01593810f, -0.02402722f, 0.01380569f, -0.00402083f, -0.00391129f, 0.00758512f, 0.02497985f, 
    0.01861785f, 0.01839991f, -0.00955372f, -0.01566016f, 0.02047132f, 0.01352650f, -0.02226525f, 0.00376926f, 
    -0.00487670f, 0.01068112f, 0.01640035f, 0.03589500f, 0.01835324f, 0.00696119f, 0.02019717f, -0.03300912f, 
    -0.03102291f, -0.02418362f, 0.02701794f, -0.01456384f, -0.03538370f, -0.00109112f, -0.02208116f, -0.01806091f, 
    -0.03221746f, 0.02625250f, -0.02389853f, -0.03085732f, -0.02458722f, -0.00550680f, 0.00185412f, 0.00347550f, 
    0.00492601f, 0.00357355f, -0.03130116f, 0.02215988f, -0.00389596f, -0.02403217f, -0.01084349f, -0.03286901f, 
    -0.02164785f, 0.02852729f, 0.02295081f, -0.00024661f, -0.01732989f, 0.00373518f, -0.02409603f, -0.01104763f, 
    0.03143683f, -0.00917981f, -0.01937983f, -0.02982190f, 0.01755032f, -0.01532759f, 0.01920754f, -0.02278999f, 
    -0.00985766f, -0.02809808f, -0.01180922f, 0.03136006f, -0.01206368f, 0.01449183f, -0.00315032f, 0.00566249f, 
    -0.00465830f, -0.01828444f, -0.00704996f, 0.01666969f, 0.00711223f, 0.03200701f, -0.01962701f, -0.02384323f, 
    -0.01214674f, 0.02844175f, -0.02682850f, -0.03169657f, -0.02797583f, -0.01272807f, -0.00439009f, -0.02537261f, 
    0.00958450f, -0.01162863f, -0.01063016f, -0.01940655f, -0.00877659f, 0.01324697f, 0.00087166f, -0.03530146f, 
    -0.01204493f, 0.03198874f, -0.00046040f, -0.00543099f, -0.03091784f, -0.02760772f, 0.00342538f, -0.01583792f, 
    -0.00371459f, 0.01000705f, 0.02715886f, -0.02412737f, -0.01066235f, -0.02041073f, 0.03481746f, 0.00765166f, 
    0.00034017f, -0.01096395f, -0.00567121f, -0.01868397f, -0.02503580f, -0.00622713f, 0.03553671f, -0.00129951f, 
    -0.00439054f, 0.03182652f, -0.01464954f, -0.01957612f, -0.03413064f, -0.02873311f, -0.01040479f, -0.01555169f, 
    -0.00208244f, -0.02098179f, 0.02464357f, 0.01632897f, -0.00614346f, 0.02682902f, -0.00449271f, -0.01285811f, 
    0.02741746f, -0.02737530f, -0.02292007f, 0.00557509f, -0.01841895f, -0.01598743f, 0.00951694f, -0.00475590f, 
    0.00643728f, -0.02702617f, 0.03312056f, -0.00946088f, 0.00777143f, 0.03405219f, 0.00122386f, 0.00730237f, 
    0.02159023f, -0.03522858f, 0.01802323f, -0.01112450f, -0.02688947f, -0.01727175f, 0.00955373f, 0.03218186f, 
    0.03326659f, 0.02992080f, 0.01493090f, 0.00924528f, 0.01189985f, -0.03468014f, 0.03239576f, 0.02500365f, 
    0.01129231f, 0.00904757f, 0.01375855f, 0.01084774f, 0.00180997f, -0.02135866f, -0.02816900f, 0.00458193f, 
    -0.02784175f, -0.03294010f, -0.01606231f, 0.01868457f, 0.00826550f, -0.03072254f, -0.02317463f, -0.01467612f, 
    0.00071051f, -0.03160508f, -0.00305639f, 0.01223227f, -0.01259818f, 0.02039207f, 0.02920393f, -0.01106462f, 
    -0.02820049f, 0.01173873f, 0.00131642f, -0.02514707f, -0.01112736f, -0.00250792f, 0.01706782f, -0.02663902f, 
    0.02056987f, 0.01382071f, -0.02623402f, 0.00877154f, -0.01800356f, 0.01263799f, 0.01321308f, 0.02850247f, 
    -0.00125882f, -0.02622564f, 0.01367682f, 0.01170284f, 0.00062580f, -0.01566594f, 0.02381553f, -0.02947284f, 
    -0.00660067f, 0.02336077f, -0.01811059f, -0.00115346f, -0.02309017f, 0.02757669f, 0.03497834f, -0.01197886f, 
    0.00164795f, 0.00461046f, -0.02802968f, -0.02648485f, 0.01037007f, -0.03559585f, 0.03034486f, -0.02660302f, 
    -0.01901267f, -0.00861022f, -0.01242193f, 0.01793859f, -0.02073080f, -0.03239883f, -0.00403991f, 0.03332959f, 
    0.01586675f, -0.02740151f, 0.02328040f, -0.00361158f, 0.02003502f, 0.00003555f, 0.02786745f, 0.00666436f, 
    -0.01564050f, -0.02712017f, 0.03007265f, 0.00898684f, -0.02163948f, 0.01029796f, -0.01134010f, -0.01566255f, 
    0.02768895f, -0.02396197f, -0.01566822f, 0.00809862f, -0.03511358f, 0.01341714f, -0.00946617f, -0.00771097f, 
    0.03095181f, -0.02520189f, -0.03447198f, -0.02993068f, 0.00079248f, -0.01296080f, -0.02267895f, -0.01531778f, 
    0.03401435f, 0.02713413f, -0.01078730f, -0.01509406f, -0.01232126f, 0.01650875f, -0.00954448f, -0.01129758f, 
    0.00992192f, -0.02609196f, 0.00708238f, -0.00272141f, 0.02480320f, 0.00393562f, -0.01405944f, 0.02003494f, 
    -0.01059087f, 0.03393845f, 0.00422681f, 0.02672683f, 0.03483730f, 0.01611684f, 0.02152314f, 0.00269692f, 
    -0.03494501f, 0.02479079f, -0.02082762f, -0.02777007f, -0.03232124f, 0.01455525f, 0.01527319f, -0.02548219f, 
    -0.00030685f, 0.02701791f, -0.01681680f, 0.01960460f, -0.01934945f, 0.01780491f, 0.02858377f, 0.03576690f, 
    -0.00432606f, 0.00203571f, 0.02089609f, -0.00209723f, -0.03548541f, -0.01245377f, -0.00957934f, 0.02005703f, 
    0.02490951f, -0.01012188f, 0.03528025f, 0.01894943f, -0.00612746f, 0.00363002f, 0.01052010f, -0.02364583f, 
    -0.03135663f, -0.00519026f, -0.01340511f, -0.01806665f, 0.01690414f, 0.03041509f, -0.02907937f, -0.00536418f, 
    -0.02963885f, -0.02165488f, -0.01503510f, 0.01819553f, -0.01752910f, 0.01856914f, -0.02895600f, 0.00279741f, 
    0.00018406f, 0.03355497f, -0.03477902f, 0.01961396f, 0.01407969f, 0.01769251f, 0.02359859f, -0.01587602f, 
    -0.03471994f, 0.01010365f, -0.02210782f, -0.00920168f, 0.00455634f, 0.02331088f, -0.01926344f, 0.02573900f, 
    -0.02753407f, 0.02086948f, -0.00496916f, -0.01957698f, 0.01748650f, -0.02696290f, -0.03518704f, -0.00800643f, 
    0.00692054f, -0.00933926f, 0.00094059f, -0.00000785f, 0.00689757f, 0.01695091f, 0.01847783f, 0.00941394f, 
    0.00964421f, 0.02508339f, 0.02907801f, -0.03044476f, 0.03494991f, 0.01947473f, -0.03044618f, 0.02741218f, 
    -0.01274345f, 0.01469427f, -0.02106161f, -0.01550018f, -0.00503266f, -0.02590779f, -0.00174406f, 0.01042160f, 
    0.00170866f, 0.01269766f, -0.00200764f, 0.03222255f, -0.02485320f, 0.03515897f, 0.01315297f, 0.02959310f, 
    -0.02679448f, -0.02237936f, -0.02249272f, -0.00881851f, -0.02396649f, -0.00817072f, 0.00149137f, 0.01538344f, 
    -0.00177395f, -0.02862874f, 0.02569422f, -0.02063679f, -0.03191072f, 0.00103795f, -0.03313721f, 0.00792788f, 
    0.01923223f, -0.00376599f, 0.03511244f, 0.01937577f, -0.03178088f, 0.03514433f, -0.00472913f, -0.00074572f, 
    0.02844380f, -0.02025350f, -0.02772060f, -0.01122139f, 0.02253565f, -0.03163709f, -0.00802088f, -0.00053175f, 
    0.03140351f, 0.03270500f, -0.01469854f, 0.02683869f, -0.01962238f, -0.00866004f, -0.02776260f, -0.01041832f, 
    0.01126554f, -0.01846374f, -0.03369237f, 0.02313646f, -0.02307322f, -0.02461109f, -0.02411125f, 0.02292099f, 
    -0.01496341f, 0.01582758f, -0.02704540f, 0.02901772f, 0.00497414f, -0.02086068f, -0.01409648f, -0.03326672f, 
    0.01664506f, 0.02151086f, 0.00085906f, 0.00263771f, -0.02514774f, -0.02066640f, 0.01863791f, -0.02303969f, 
    0.01218930f, 0.01050438f, -0.02500193f, -0.02604487f, -0.03088519f, -0.02661649f, -0.01298061f, 0.02412354f, 
    -0.00077667f, -0.01759764f, 0.01306642f, 0.00048480f, -0.01063587f, 0.01204271f, 0.02494784f, -0.00995670f, 
    -0.00038323f, 0.03112051f, 0.00692539f, -0.03169636f, -0.03564746f, 0.00597470f, -0.00243005f, -0.03105479f, 
    0.02079258f, 0.01070488f, -0.02148077f, 0.02388972f, -0.03191444f, 0.00574524f, -0.03083976f, -0.03583814f, 
    -0.00678872f, 0.01257603f, -0.03211470f, -0.00781536f, 0.00152273f, 0.02797550f, 0.02571915f, 0.02088491f, 
    0.02202507f, 0.00792878f, 0.02220461f, -0.03380824f, 0.03396372f, 0.02718022f, 0.01584086f, 0.03008009f, 
    -0.03383191f, -0.00592615f, 0.02056709f, 0.03173888f, -0.03072065f, -0.01147272f, -0.03519104f, -0.01574666f, 
    0.02358335f, -0.01312041f, 0.02888713f, 0.02158030f, 0.00643943f, 0.03250882f, 0.03558827f, 0.01513188f, 
    -0.01315509f, -0.03158570f, 0.01368813f, -0.00999070f, 0.02515939f, 0.00558756f, 0.02903231f, -0.02085060f, 
    -0.00779910f, 0.02233835f, -0.02570506f, 0.00067369f, -0.02868288f, -0.01694554f, -0.01931944f, -0.00720746f, 
    -0.01088324f, 0.00646084f, -0.01840121f, 0.00131253f, -0.00924082f, -0.02167322f, -0.02611510f, 0.00094805f, 
    -0.01004677f, -0.00291837f, 0.02048685f, 0.03068581f, -0.03019611f, -0.01829575f, -0.03437220f, 0.02316707f, 
    0.01465807f, -0.03309784f, -0.00884437f, 0.00477317f, -0.02154950f, -0.00035590f, 0.02056742f, -0.03061625f, 
    -0.03829210f, -0.02011590f, -0.01038715f, -0.02309746f, -0.03636765f, -0.03173587f, -0.01572237f, 0.00554245f, 
    -0.00821450f, -0.02965132f, 0.02619608f, -0.02435744f, 0.00746330f, -0.00793651f, -0.03942939f, -0.00680087f, 
    0.01437494f, -0.01529390f, -0.04136820f, -0.00642235f, -0.00035241f, 0.02290988f, -0.03008867f, -0.01166941f, 
    -0.02342146f, -0.00046823f, 0.00217133f, 0.02485600f, -0.03849820f, -0.03672781f, 0.02193503f, -0.02412281f, 
    -0.02088475f, -0.02897158f, -0.00502148f, -0.00981257f, 0.00153173f, 0.01022000f, 0.02519288f, -0.03592560f, 
    -0.03065858f, 0.01460359f, -0.01866657f, -0.02721635f, -0.01343476f, 0.03385909f, -0.01663820f, 0.02445186f, 
    0.00603908f, -0.03977349f, -0.01546008f, -0.01706952f, -0.02356746f, -0.01106805f, 0.02528670f, 0.02506906f, 
    -0.02184263f, -0.02711559f, 0.00206002f, 0.00880597f, -0.02943745f, -0.00618625f, -0.00620934f, 0.00357519f, 
    0.02531664f, 0.02245386f, 0.02964944f, 0.02346118f, -0.01788323f, -0.02694576f, -0.04110345f, 0.01335736f, 
    -0.01885145f, -0.00692772f, 0.00596705f, 0.01601997f, 0.03097235f, -0.02685295f, 0.01904711f, 0.00287885f, 
    -0.01838790f, 0.00145328f, -0.00788630f, -0.02518618f, -0.02010439f, -0.03309987f, -0.03283836f, -0.02955884f, 
    -0.00115530f, 0.01574612f, 0.02522312f, 0.01725885f, -0.02500205f, 0.01370730f, -0.00825591f, -0.00286153f, 
    -0.03087652f, 0.00985609f, -0.02139344f, 0.02669934f, 0.01725409f, -0.00038691f, 0.02148976f, -0.02034187f, 
    -0.02503479f, -0.03182361f, -0.01750908f, -0.00736896f, -0.03259924f, 0.01676010f, -0.03082783f, -0.03054614f, 
    -0.01676380f, -0.00954471f, -0.01551593f, -0.02833643f, -0.00271904f, -0.03023745f, -0.03275665f, -0.03126479f, 
    0.01989893f, -0.01978195f, -0.02845508f, 0.00241913f, 0.02254731f, -0.02001833f, 0.00302291f, -0.04148029f, 
    0.00992719f, -0.02401037f, 0.01315858f, 0.00488600f, 0.01281173f, -0.01562564f, -0.02028948f, 0.02453909f, 
    0.01915340f, -0.02098759f, 0.02266247f, -0.02447554f, -0.00681873f, -0.03359728f, -0.03988117f, -0.01753524f, 
    -0.01323287f, -0.01208213f, -0.00003714f, -0.01017974f, -0.03350603f, -0.01979022f, 0.02084138f, -0.00036466f, 
    0.01393221f, 0.02495784f, -0.00292067f, -0.03521070f, -0.03193402f, -0.03853444f, -0.01789931f, 0.01430923f, 
    0.02520772f, -0.03206257f, 0.00218325f, -0.03712557f, -0.00962525f, 0.00450317f, -0.01030347f, -0.02487837f, 
    0.02362153f, 0.00615392f, -0.02769892f, 0.02228685f, 0.02202534f, -0.01454509f, -0.00577417f, 0.01579586f, 
    -0.02877164f, -0.02847143f, 0.01033351f, -0.01425233f, 0.01393608f, -0.01289287f, -0.00158034f, 0.00502546f, 
    0.00530118f, -0.00983613f, -0.03201009f, 0.01373281f, -0.02331205f, -0.01568002f, -0.03736952f, -0.01624221f, 
    0.01881845f, -0.00458108f, -0.01054361f, 0.01222883f, 0.00925059f, 0.00480679f, 0.01234899f, 0.00034456f, 
    0.00350644f, -0.01972915f, -0.03511446f, -0.00073534f, 0.00775527f, -0.03762765f, 0.03026018f, -0.02652955f, 
    -0.03233569f, 0.02362287f, -0.00709499f, -0.01062297f, -0.01896341f, -0.02184676f, -0.00634116f, 0.02526510f, 
    -0.02231137f, 0.01484940f, -0.03042928f, 0.00192015f, 0.00078678f, -0.03318200f, -0.02297417f, -0.03538001f, 
    0.03380858f, -0.03714654f, 0.01666883f, 0.00289744f, -0.03027545f, -0.00917433f, 0.00054902f, -0.03646888f, 
    -0.02511925f, 0.00442223f, -0.03400796f, -0.00987465f, -0.02768443f, 0.02024761f, 0.01021562f, 0.02018170f, 
    0.00644757f, -0.02992853f, 0.00090766f, -0.01896910f, 0.02298319f, -0.02401609f, 0.02464597f, -0.01882655f, 
    -0.02185028f, -0.01963460f, 0.00070323f, 0.03189112f, 0.02251373f, 0.00235354f, 0.00587557f, 0.01357715f, 
    -0.04199621f, -0.02961200f, 0.01993231f, -0.01862353f, -0.01866907f, -0.00405034f, 0.00480897f, -0.01682692f, 
    -0.00459982f, 0.00009029f, 0.02567506f, 0.02972629f, 0.00931093f, -0.01812579f, -0.03910368f, -0.04331404f, 
    0.02066715f, -0.03483622f, 0.02424225f, 0.02259968f, -0.03436118f, -0.02847952f, -0.03708064f, 0.02314842f, 
    0.03188458f, -0.00793482f, 0.03020815f, 0.02086892f, -0.02824214f, 0.00700893f, -0.02445420f, -0.00884307f, 
    0.02052829f, 0.01667105f, 0.03388811f, 0.02843512f, 0.01319944f, 0.01903429f, -0.00263988f, 0.01128155f, 
    -0.03687536f, -0.00343805f, 0.02889905f, 0.00887207f, 0.00395578f, -0.02707007f, 0.00644354f, 0.02858997f, 
    -0.03788367f, -0.00877389f, 0.02825191f, -0.01415547f, 0.02871397f, 0.00073650f, -0.00884946f, -0.02231406f, 
    -0.02266261f, 0.03440192f, 0.00953258f, 0.02372323f, 0.02185435f, -0.03236923f, 0.00174744f, 0.01398500f, 
    0.02082952f, 0.01231907f, 0.02066504f, 0.02187143f, -0.01363314f, -0.01277952f, -0.01240850f, 0.00182736f, 
    -0.01681391f, 0.02396210f, -0.00526477f, -0.01715836f, 0.00082944f, -0.03049756f, 0.01132162f, -0.00824727f, 
    -0.02327907f, -0.01182788f, 0.01318142f, 0.00028675f, 0.01945314f, 0.01399218f, 0.01000885f, -0.00965280f, 
    0.01225968f, -0.01908235f, 0.01391620f, -0.00353732f, -0.02440705f, -0.03355573f, 0.01848457f, 0.00408616f, 
    0.02942845f, 0.01999824f, -0.01759692f, -0.02394286f, 0.02560149f, -0.00745270f, -0.01621859f, 0.01825526f, 
    -0.01098965f, 0.01365715f, -0.01624088f, 0.01358444f, -0.03180219f, -0.02891819f, -0.03266064f, 0.01471878f, 
    0.02274754f, -0.00833287f, -0.02448601f, 0.00232390f, 0.02459495f, -0.01889280f, 0.00433300f, 0.01904294f, 
    -0.01691481f, 0.02019861f, 0.00032877f, 0.00886526f, -0.04001787f, 0.03023011f, -0.01067866f, -0.01409229f, 
    -0.03257236f, -0.00604405f, -0.01146979f, -0.03278800f, -0.00847030f, 0.00647470f, 0.00722939f, 0.01481965f, 
    -0.03944249f, 0.01421517f, 0.00369077f, -0.02402288f, 0.03153285f, -0.02026468f, 0.01269235f, -0.00193389f, 
    -0.03831586f, -0.00270292f, 0.00805993f, 0.01697170f, 0.02474660f, -0.01080858f, 0.01627940f, -0.01808101f, 
    -0.01850132f, -0.01832234f, -0.02001986f, 0.00022497f, 0.00014573f, 0.02368130f, 0.01603875f, 0.01492429f, 
    0.02446448f, 0.02277105f, 0.02765842f, -0.01851463f, -0.04111057f, 0.01742187f, 0.01595732f, 0.01126909f, 
    0.01851675f, -0.01633602f, -0.02319759f, -0.04226426f, 0.00972413f, 0.02550841f, 0.02227597f, -0.03061104f, 
    -0.02709831f, -0.00722488f, 0.00448649f, 0.00649380f, 0.01518538f, -0.04276793f, -0.01994948f, 0.01600756f, 
    0.03691769f, 0.00608642f, 0.01191859f, 0.01484057f, 0.00226731f, -0.03052880f, -0.03106709f, -0.03892524f, 
    0.00053797f, 0.02367739f, -0.03231800f, -0.01292406f, -0.02692884f, -0.00842600f, 0.01766392f, -0.03663190f, 
    0.00670192f, -0.00520006f, 0.01297433f, -0.00882591f, -0.03584345f, -0.01633824f, -0.02202785f, 0.00798108f, 
    -0.00394782f, 0.00048559f, 0.02316799f, -0.01328275f, -0.03861374f, 0.02478372f, -0.02622866f, 0.01588044f, 
    -0.02572909f, 0.00856006f, 0.02701532f, 0.02278800f, -0.02107023f, -0.00609547f, 0.00824352f, -0.01361436f, 
    0.01483025f, 0.00347167f, -0.01957075f, -0.00383154f, 0.02702687f, -0.00618315f, -0.02455826f, 0.00205442f, 
    -0.00927995f, -0.02146421f, 0.01847377f, -0.03280099f, 0.00379898f, -0.03041389f, -0.02198301f, -0.03267095f, 
    0.02982537f, -0.02815377f, 0.02796909f, 0.02222623f, -0.00400978f, 0.01423949f, 0.03074895f, -0.00493538f, 
    -0.02147501f, -0.03684308f, -0.03667220f, -0.02740441f, 0.00944275f, -0.00001234f, -0.01830999f, -0.01117918f, 
    0.03088279f, -0.03179086f, -0.01922195f, 0.03498805f, -0.03190394f, 0.02556272f, -0.01549013f, -0.01199954f, 
    0.02535057f, 0.00836267f, 0.01950281f, -0.03002563f, -0.03722927f, 0.01915287f, -0.02083419f, -0.02316654f, 
    0.01978031f, -0.00870762f, -0.01398680f, 0.00880586f, -0.02394506f, 0.01321655f, 0.01731321f, -0.03562838f, 
    -0.00218460f, 0.01277251f, 0.02989587f, 0.02296899f, -0.01037556f, -0.02335396f, -0.00654742f, -0.00140615f, 
    0.03231640f, -0.01436612f, -0.00978071f, -0.02830107f, 0.02660008f, 0.02390930f, 0.00321795f, 0.02177184f, 
    0.01242621f, 0.02996345f, 0.02778332f, -0.02199626f, -0.01037663f, 0.03175916f, -0.00024575f, -0.02590526f, 
    -0.01444938f, -0.03578648f, 0.00364917f, 0.00718942f, 0.00175120f, -0.03526560f, -0.03305993f, -0.03557694f, 
    -0.02899381f, 0.01413545f, -0.01374032f, -0.03171412f, -0.00087931f, 0.02416710f, -0.01940876f, -0.02882247f, 
    -0.01967604f, 0.01647607f, 0.00615742f, -0.01778124f, -0.00133762f, -0.03148641f, -0.03761274f, -0.03551503f, 
    -0.00084664f, -0.02895908f, 0.03080172f, -0.00622904f, 0.02990283f, 0.02899165f, -0.00153103f, 0.00930940f, 
    0.01806585f, 0.02778338f, 0.02288119f, -0.01223966f, -0.01400098f, 0.01350345f, -0.02470576f, 0.00429681f, 
    -0.03142396f, -0.03628779f, -0.01715386f, -0.03667731f, -0.01097112f, -0.03006815f, -0.01578688f, -0.00235014f, 
    0.00139928f, -0.01474803f, -0.00101491f, 0.00385326f, 0.02257143f, -0.00513019f, 0.00988720f, 0.03030445f, 
    -0.03214631f, -0.02287100f, -0.03932250f, 0.02502936f, 0.02829824f, -0.01760446f, -0.02829156f, -0.02156738f, 
    -0.01649811f, -0.03061579f, 0.01248348f, -0.00504371f, 0.00218527f, -0.01736034f, -0.02306575f, 0.01763548f, 
    -0.01606764f, 0.01305493f, -0.00912782f, -0.04093273f, 0.00289466f, -0.02790721f, -0.01476444f, -0.02556753f, 
    -0.01041987f, 0.01307000f, 0.02648163f, 0.01581000f, -0.03424942f, 0.03215316f, 0.00955171f, 0.01694140f, 
    -0.01704632f, -0.00024902f, 0.00880816f, 0.01732629f, -0.01342001f, 0.02300934f, -0.00803483f, -0.00670534f, 
    -0.03674281f, 0.02339967f, -0.01081186f, 0.02901716f, -0.03853137f, 0.00165232f, -0.02367342f, -0.01685856f, 
    0.01114285f, -0.01309752f, 0.02817060f, 0.02382321f, 0.01071384f, -0.03572171f, -0.03076237f, 0.01948630f, 
    0.02301825f, -0.02743401f, 0.01565574f, -0.01957952f, -0.03602783f, 0.02639583f, -0.01313862f, -0.00501295f, 
    -0.02609010f, -0.02926138f, 0.03483990f, 0.01042903f, -0.03323954f, -0.01868784f, 0.00747361f, 0.00409544f, 
    -0.00072561f, 0.00310109f, 0.01813611f, 0.02774924f, -0.02609026f, -0.02094636f, 0.01505726f, 0.00447523f, 
    0.01229308f, 0.03175430f, -0.00117032f, -0.01304360f, 0.02781507f, -0.01855218f, -0.00919738f, -0.00811634f, 
    0.02608988f, -0.02104766f, -0.03976536f, 0.03125571f, -0.03970454f, -0.01132895f, -0.02498398f, 0.00706398f, 
    -0.01616283f, 0.01198713f, 0.03047416f, -0.00148117f, -0.02367592f, 0.02498367f, 0.01440363f, -0.01310233f, 
    -0.02079482f, -0.02821238f, 0.00413727f, 0.02977864f, -0.02947800f, -0.00976903f, -0.02609568f, -0.03158414f, 
    -0.02897943f, 0.00634186f, 0.00976456f, -0.02148215f, 0.00879579f, 0.01348592f, -0.01900544f, -0.03463693f, 
    0.01679008f, -0.00787964f, -0.02023917f, 0.01263842f, 0.00638641f, 0.01705449f, -0.00506056f, -0.01600788f, 
    -0.01715157f, 0.01237841f, -0.03591546f, 0.02838054f, 0.01142646f, 0.00322843f, -0.00364470f, -0.01486935f, 
    -0.01973675f, -0.01708899f, 0.00875644f, -0.03034989f, 0.00001812f, -0.02044240f, -0.03782843f, -0.03035834f, 
    0.03675150f, 0.12201204f, 0.01701495f, 0.11231595f, -0.03582931f, -0.07072915f, -0.03251085f, -0.16533783f, 
    0.00509403f, 0.04307354f, 0.02774333f, 0.00249619f, 0.40429431f, 0.01237813f, 0.13550298f, -0.29260454f, 
    -0.01688057f, -0.00554533f, 0.01916319f, 0.02274264f, 0.01710677f, -0.01027194f, 0.07170740f, 0.08875071f, 
    -0.26765987f, 0.00194873f, -0.22629887f, -0.07521650f, -0.08529564f, -0.00059261f, -0.08827111f, 0.00898987f, 
    0.01859143f, -0.04713463f, 0.06563307f, 0.07483904f, -0.05352093f, 0.08607566f, 0.17067647f, 0.09894961f, 
    0.02964111f, 0.10571390f, 0.05220681f, -0.03787574f, 0.09831198f, 0.07278423f, -0.06368609f, 0.10808895f, 
    0.03031369f, 0.14315991f, 0.02135087f, 0.07388673f, 0.08975710f, -0.02836936f, 0.03125276f, -0.01847549f, 
    0.05110367f, 0.07359146f, 0.09877543f, -0.00799038f, 0.07595892f, 0.03263574f, -0.04238595f, 0.12655547f, 
    0.15275769f, -0.11600236f, 0.04704304f, -0.08059587f, -0.02416505f, -0.06381159f, 0.00978964f, -0.03587507f, 
    -0.01051826f, 0.10386170f, 0.16488439f, -0.01441640f, -0.07484027f, 0.06993189f, -0.02643244f, 0.00166819f, 
    -0.00077485f, -0.01466348f, 0.07673867f, 0.07766713f, -0.07943477f, -0.10293968f, -0.01696155f, 0.02788410f, 
    0.04258835f, 0.06496894f, -0.02066985f, 0.01117429f, 0.06327698f, -0.05034419f, -0.04635376f, -0.04903926f, 
    0.14447403f, 0.05319526f, 0.22538039f, -0.06619293f, -0.02245869f, 0.02560509f, 0.00431590f, 0.03573949f, 
    0.02199678f, 0.11696272f, 0.00217034f, 0.13004388f, -0.07563488f, -0.17584868f, -0.03450349f, -0.02468342f, 
    0.05073106f, 0.03356755f, 0.00304166f, 0.05727441f, -0.04704868f, -0.07335867f, -0.05921741f, 0.01053878f, 
    -0.16158788f, -0.14501087f, -0.06757595f, 0.00247827f, 0.00776069f, -0.02173812f, -0.11686409f, -0.02517519f, 
    0.02269532f, -0.03557480f, -0.01459499f, -0.03151605f, -0.23942973f, 0.12940499f, -0.13883175f, 0.01580140f, 
    0.00184923f, -0.03132804f, -0.12592840f, 0.01209016f, -0.05427494f, 0.02442592f, 0.06218991f, -0.03251707f, 
    0.18071881f, -0.07315856f, 0.10023014f, 0.03055234f, -0.13678372f, -0.00506480f, 0.04215381f, -0.06570891f, 
    -0.05152003f, -0.07903244f, 0.06949736f, 0.00387294f, 0.25294235f, 0.18145813f, -0.15692654f, 0.27943584f, 
    0.01904542f, -0.00502412f, 0.01121867f, -0.04620516f, 0.00440639f, 0.02384983f, 0.01175834f, 0.03383683f, 
    -0.10250045f, -0.00795181f, 0.00797937f, 0.11014163f, 0.07561014f, -0.03829374f, -0.02253322f, 0.07466134f, 
    0.02066788f, 0.03042921f, -0.02592738f, -0.17289726f, -0.18522476f, 0.17748478f, -0.09528634f, 0.01807971f, 
    -0.00721329f, -0.12971281f, -0.06760544f, -0.01609712f, 0.00132791f, -0.02517331f, -0.02396403f, -0.03237063f, 
    -0.10126215f, 0.17494842f, -0.04597075f, -0.07212304f, -0.07146140f, 0.01548823f, 0.01559720f, -0.03304738f, 
    -0.01447441f, 0.05758818f, -0.03803717f, -0.04386453f, -0.01851139f, 0.06915119f, -0.00555691f, -0.01422070f, 
    0.05455146f, 0.02106507f, -0.00586312f, -0.05910479f, -0.05988948f, -0.03561852f, 0.05031245f, -0.08596818f, 
    -0.30629304f, -0.17678116f, 0.00930155f, -0.15185627f, 0.06848939f, 0.09375829f, 0.04901454f, 0.02192351f, 
    -0.03119282f, 0.11528276f, -0.02872504f, 0.02920868f, 0.20590648f, -0.02265822f, -0.00473406f, -0.12301355f, 
    0.17278655f, -0.00146827f, -0.06387834f, -0.00503422f, -0.03109007f, 0.04281742f, 0.03643712f, -0.08054584f, 
    -0.02472400f, 0.25761074f, -0.12082888f, -0.05951387f, 0.17816910f, 0.03134755f, -0.02186492f, 0.04128065f, 
    0.04998608f, 0.05186874f, 0.13819565f, 0.05699957f, 0.10266284f, -0.02166774f, -0.04200033f, 0.14154497f, 
    0.02382526f, -0.06996942f, -0.05627273f, -0.10585525f, 0.07053144f, -0.01309152f, 0.03186374f, 0.02246707f, 
    0.24492742f, -0.21338387f, 0.07022503f, 0.07679937f, -0.01195946f, 0.04684058f, 0.03576357f, -0.05002090f, 
    0.00296768f, 0.06544752f, -0.03122996f, -0.08086989f, -0.18642445f, 0.03548201f, 0.02683262f, 0.22520703f, 
    0.10005004f, -0.05312535f, 0.02539932f, 0.02464972f, 0.10569104f, 0.07425555f, 0.00025535f, -0.01380697f, 
    0.05449193f, 0.04448289f, 0.00794828f, 0.04776933f, 0.04975693f, -0.06003479f, 0.00016461f, 0.01896461f, 
    0.00967217f, -0.00200432f, -0.10477918f, 0.03143054f, 0.20562054f, 0.02746779f, 0.11816394f, 0.03273742f, 
    -0.05646465f, -0.02483072f, 0.00966126f, 0.00039908f, -0.00991762f, -0.02693994f, -0.00535239f, -0.04607571f, 
    -0.27206492f, -0.10524755f, 0.20234267f, 0.02694096f, 0.08211834f, 0.00188675f, -0.02148718f, 0.00583568f, 
    0.02978613f, -0.03611943f, 0.03940118f, -0.02219380f, 0.02985492f, 0.33102286f, 0.03665964f, 0.11629049f, 
    -0.05055162f, 0.05286022f, -0.03671716f, 0.10479710f, 0.06288393f, 0.01738550f, -0.02248698f, 0.06178601f, 
    -0.17268564f, 0.12616952f, -0.08224057f, -0.02416980f, -0.04331222f, 0.03362035f, 0.01579557f, -0.00663113f, 
    0.02700382f, -0.07362451f, -0.04340211f, 0.03465978f, -0.18061674f, 0.16036341f, -0.06340904f, 0.22801961f, 
    0.05146422f, -0.03139050f, 0.02611752f, 0.02687517f, 0.06030433f, -0.02393645f, 0.02754316f, -0.06419543f, 
    -0.20590085f, 0.30808812f, -0.02471901f, 0.02226470f, -0.14309199f, 0.12613516f, -0.03447289f, -0.11437140f, 
    -0.03713270f, 0.06224807f, -0.02740461f, -0.00194288f, 0.05667623f, -0.29724053f, -0.06530929f, -0.18286279f, 
    0.04099603f, -0.13043554f, 0.02434613f, -0.01789769f, 0.05709643f, -0.03812335f, 0.05123537f, 0.05929661f, 
    -0.04084360f, 0.08741947f, -0.06032613f, 0.00512587f, 0.02915181f, -0.01098332f, 0.00087817f, 0.02354567f, 
    -0.03139569f, 0.09887133f, 0.11109966f, 0.03125568f, 0.03555170f, -0.06437194f, 0.25454032f, -0.07856414f, 
    -0.04748621f, -0.02665037f, 0.03164425f, 0.04588461f, 0.04056881f, 0.02444356f, -0.06184546f, 0.02897534f, 
    0.03015033f, -0.09346912f, 0.02001642f, -0.06051632f, -0.09291152f, -0.08653886f, 0.14218782f, 0.04622574f, 
    0.00933296f, 0.01865159f, 0.03045625f, -0.09120945f, -0.06003146f, 0.29339382f, 0.17169037f, 0.34881034f, 
    -0.05107218f, 0.11273098f, 0.00323186f, 0.07103605f, -0.04561827f, 0.04330728f, 0.11842461f, 0.04429438f, 
    0.08237925f, 0.19867310f, -0.12401403f, -0.01415785f, -0.04870669f, -0.01772610f, -0.04470266f, -0.02825678f, 
    0.03774675f, -0.02701441f, 0.13084272f, 0.01914269f, -0.39792836f, 0.10811170f, -0.06545623f, 0.00006831f, 
    -0.00359815f, 0.06322679f, -0.01473906f, -0.10239351f, 0.05801689f, 0.03599235f, 0.00484046f, -0.00957136f, 
    0.34276605f, -0.04460101f, -0.02468033f, -0.13234602f, 0.00602090f, 0.00850362f, -0.02261581f, 0.05364786f, 
    -0.06465553f, -0.08095533f, 0.04504915f, -0.07264627f, 0.29987958f, -0.09463536f, -0.07486603f, -0.20002496f, 
    -0.10050642f, 0.06476424f, 0.00876254f, -0.01380800f, -0.03741828f, -0.01993924f, -0.00693210f, 0.05659787f, 
    0.04828624f, -0.11606867f, -0.07243146f, 0.00110465f, 0.00840067f, -0.11986750f, -0.04994655f, -0.04889639f, 
    0.03538403f, -0.07023844f, 0.03607693f, -0.08113113f, 0.06920002f, 0.20775241f, -0.12917864f, -0.07074493f, 
    -0.00820633f, -0.09057894f, -0.08782773f, -0.03356653f, 0.09027097f, -0.01326499f, 0.05046658f, 0.02903787f, 
    0.08905201f, -0.14092025f, -0.02748272f, 0.00806574f, -0.01992814f, 0.02800873f, 0.06465814f, 0.01230337f, 
    -0.07493445f, 0.12718470f, 0.06610935f, 0.08664131f, 0.26116243f, -0.05929264f, -0.16942793f, -0.06617267f, 
    0.00373238f, 0.03527640f, -0.00838075f, 0.06057430f, 0.08714343f, 0.08457876f, -0.01503721f, 0.04807904f, 
    0.20359865f, 0.11064579f, 0.19956447f, 0.19799183f, 0.13871142f, 0.06898985f, -0.08384538f, 0.01605780f, 
    -0.03063956f, 0.02804839f, -0.00604365f, 0.08071294f, 0.02615566f, 0.08316550f, -0.06855947f, 0.07448872f, 
    0.14200512f, -0.02194172f, -0.03126991f, 0.04281701f, -0.06081662f, 0.09413453f, 0.05014791f, -0.02622451f, 
    0.11840520f, -0.01821851f, 0.03110212f, 0.08256571f, 0.07604911f, -0.00192574f, -0.02390542f, -0.02082884f, 
    0.00474420f, -0.05586269f, -0.09838177f, 0.00750283f, 0.21375421f, 0.06429307f, -0.08230448f, 0.19490896f, 
    0.07815845f, -0.02662514f, -0.02021484f, -0.01931436f, 0.02628167f, -0.04028438f, -0.06379525f, 0.05562361f, 
    0.02921046f, -0.00471400f, -0.04330365f, 0.00452115f, 0.05404573f, -0.09116173f, -0.02888962f, 0.04010619f, 
    -0.05109401f, 0.02814987f, 0.06575122f, -0.13446197f, -0.00480162f, 0.02988372f, 0.02081820f, -0.19748580f, 
    -0.05657646f, -0.13696763f, 0.01174138f, -0.05930018f, 0.02099235f, 0.03097936f, 0.02409187f, -0.04688505f, 
    -0.14650781f, -0.05691363f, -0.05324163f, -0.02670908f, 0.10191414f, 0.04736210f, -0.06389067f, -0.01918305f, 
    -0.09918132f, -0.01050759f, -0.04341889f, 0.04613646f, 0.22009900f, 0.00409560f, 0.08109371f, 0.05047267f, 
    0.02285733f, 0.01066826f, 0.01915715f, -0.08181461f, -0.06748990f, -0.02003344f, 0.09203711f, 0.09944015f, 
    -0.18141302f, 0.09693190f, 0.00988639f, -0.02900309f, 0.14152423f, -0.13082455f, -0.00327500f, -0.02984590f, 
    0.02302594f, -0.00151387f, 0.01632482f, 0.04033303f, 0.25481188f, -0.06135111f, 0.12343511f, -0.21922450f, 
    -0.00509619f, -0.00305470f, -0.00125621f, 0.03422265f, -0.01822632f, 0.03873040f, -0.05082789f, -0.09315321f, 
    -0.08409294f, 0.00754626f, 0.11603349f, -0.03128514f, 0.12622325f, -0.01448880f, -0.05604086f, -0.03039838f, 
    0.08186220f, 0.08350437f, 0.06351798f, -0.08574440f, 0.07728203f, 0.20379947f, 0.04948424f, 0.14137317f, 
    0.10857562f, -0.01099290f, -0.05586863f, -0.04027629f, -0.03077139f, -0.07943796f, 0.09551869f, -0.01627451f, 
    -0.05386241f, -0.08244268f, -0.11670755f, 0.06024149f, 0.14582407f, -0.02791433f, -0.03663862f, -0.03631138f, 
    0.07200326f, -0.03315750f, -0.01807265f, 0.08017534f, -0.10171673f, -0.19484790f, 0.03421185f, -0.06097040f, 
    0.09427348f, -0.02006844f, 0.02436621f, -0.04885649f, 0.03100605f, 0.08355010f, -0.03781202f, 0.02128010f, 
    0.06710158f, 0.15649869f, 0.08391939f, -0.09905311f, -0.06252984f, 0.02796501f, 0.01908446f, -0.07303827f, 
    0.06984485f, 0.03788142f, -0.03488186f, 0.06420176f, -0.13584939f, 0.00805166f, 0.00985613f, -0.30683538f, 
    -0.19575071f, -0.01084475f, -0.03995714f, 0.02473466f, 0.03800302f, -0.01061736f, -0.03579075f, -0.04720342f, 
    0.10948578f, 0.07231870f, 0.12437496f, -0.06016434f, -0.01101930f, 0.03389052f, 0.09750325f, -0.06925058f, 
    -0.05616158f, 0.03626183f, 0.02235428f, -0.02256849f, -0.10526656f, -0.06226333f, -0.05644384f, -0.09032332f, 
    0.04300905f, 0.00021645f, 0.06693221f, -0.03942778f, -0.05742728f, -0.01690585f, -0.00022256f, -0.04912364f, 
    0.00592794f, -0.01764468f, 0.14635503f, -0.16694908f, -0.06574384f, -0.00748795f, -0.01137292f, 0.04672805f, 
    0.08804654f, -0.00543421f, -0.02714890f, -0.01033382f, 0.21917510f, -0.06480977f, 0.33625621f, 0.22299927f, 
    0.11151825f, 0.06799672f, 0.10210933f, 0.00526709f, -0.00839946f, 0.06511775f, -0.04620551f, 0.07033876f, 
    0.05998797f, -0.03175457f, -0.06780864f, 0.07290059f, 0.08032970f, 0.04299604f, 0.15001287f, 0.07642757f, 
    0.07732992f, 0.03627452f, 0.02484845f, 0.04995065f, 0.37846568f, 0.00309021f, 0.06826438f, -0.15637743f, 
    -0.11894245f, 0.08076189f, -0.04135469f, 0.03560502f, -0.07350167f, 0.09338517f, 0.06457911f, 0.05996649f, 
    -0.03394049f, -0.07460399f, -0.00795954f, 0.06248216f, -0.02879660f, -0.03551507f, -0.00592240f, -0.02402606f, 
    0.20558602f, 0.06549891f, 0.07871909f, -0.15680747f, 0.08320364f, -0.07812832f, 0.06786742f, 0.23647662f, 
    -0.04599615f, 0.05260421f, -0.08519779f, 0.16134110f, 0.06477442f, 0.06130211f, 0.11472245f, -0.11300685f, 
    0.06632208f, 0.12447216f, 0.09657916f, 0.10113052f, -0.00420275f, -0.05353562f, 0.11692940f, 0.03859784f, 
    -0.02568049f, -0.07559553f, -0.09818996f, 0.00873728f, -0.13926288f, -0.04214070f, 0.18014120f, 0.01505111f, 
    0.03563598f, -0.10924111f, 0.12555087f, 0.16825733f, -0.09530242f, -0.05280754f, 0.02413810f, 0.06806505f, 
    -0.00678542f, 0.04721466f, 0.03538096f, 0.06018480f, -0.09560136f, -0.05789572f, -0.05963463f, 0.03128684f, 
    -0.01864159f, -0.06857003f, 0.03811934f, 0.00162270f, 0.02360223f, -0.01817625f, -0.00638813f, 0.01452831f, 
    -0.00866004f, -0.01825273f, -0.05463511f, 0.00441535f, -0.11087856f, -0.14127961f, -0.03956892f, -0.17081554f, 
    0.24396083f, -0.12292093f, 0.07255492f, 0.08458378f, -0.00054761f, -0.00228220f, -0.01770244f, -0.09526118f, 
    -0.12103450f, 0.03789905f, 0.20447703f, 0.01562138f, -0.19459110f, -0.03774659f, 0.14394405f, 0.10387915f, 
    -0.03246590f, 0.09672023f, -0.02516101f, 0.00949855f, -0.00149881f, 0.07569245f, -0.03424620f, -0.07549950f, 
    -0.11461330f, 0.06393868f, -0.17396140f, -0.03380556f, -0.04010946f, -0.02324199f, -0.07090731f, -0.07674903f, 
    -0.06705875f, -0.02904108f, 0.13470997f, -0.08941659f, -0.00220146f, 0.06892242f, 0.06561228f, -0.10331378f, 
    -0.06411478f, 0.10080856f, -0.02049916f, 0.09853069f, -0.01972851f, -0.09841130f, -0.02351340f, -0.13344841f, 
    0.02959688f, -0.05232402f, -0.06469785f, 0.11672475f, -0.03823940f, -0.00189617f, 0.08556424f, -0.01366794f, 
    -0.01239033f, 0.00128564f, -0.09587380f, -0.06225992f, -0.10252541f, -0.07547663f, 0.12746337f, 0.18854484f, 
    0.02964828f, -0.04901575f, 0.21266218f, 0.14795890f, -0.00086072f, -0.01039454f, 0.06860668f, 0.19369668f, 
    0.02053149f, -0.15112448f, -0.07701669f, -0.02114513f, -0.07279553f, -0.03715193f, 0.16385454f, 0.00652094f, 
    -0.02599170f, 0.05109643f, 0.07075780f, 0.11324798f, 0.09065202f, -0.03450711f, -0.10589232f, -0.07960055f, 
    -0.01596809f, -0.18350105f, 0.03819658f, 0.00640655f, -0.12141960f, 0.01431006f, -0.08551419f, 0.13837653f, 
    -0.04078588f, 0.00955249f, 0.01051953f, 0.01271117f, -0.24632362f, 0.13187277f, 0.00336359f, 0.17277373f, 
    -0.01347485f, -0.06820403f, -0.03544432f, -0.01928638f, -0.02336612f, 0.21543127f, -0.01625133f, 0.16606893f, 
    -0.08942741f, 0.10184315f, 0.10533430f, -0.01964167f, -0.11340449f, -0.00065474f, -0.06271452f, -0.06051750f, 
    -0.32289115f, -0.25651971f, 0.07058544f, 0.18884660f, -0.03361618f, 0.10744968f, 0.17324002f, -0.01717406f, 
    0.02700351f, -0.00366746f, -0.00067249f, -0.22417030f, 0.15163520f, 0.17021105f, 0.13721152f, -0.00522788f, 
    0.09246365f, 0.00185637f, -0.05699596f, 0.06912913f, -0.05323682f, 0.12094681f, -0.06205539f, 0.13734472f, 
    0.08366010f, 0.05672329f, 0.01840124f, -0.04554289f, 0.01233296f, 0.04114149f, -0.08592345f, 0.13394229f, 
    0.01156541f, 0.05142068f, 0.02427629f, 0.01272325f, 0.02160436f, -0.09777138f, -0.15165150f, -0.14057331f, 
    -0.05514868f, -0.09797124f, -0.04474525f, 0.04062710f, 0.03853004f, -0.07277344f, -0.07457272f, -0.10460827f, 
    -0.02933911f, -0.08982195f, 0.18261719f, 0.12665558f, -0.02720025f, 0.08863983f, 0.02556231f, -0.01596101f, 
    0.02912671f, 0.00430257f, -0.00533017f, -0.21368925f, 0.00275700f, 0.03890399f, 0.02571474f, -0.04720569f, 
    0.10114157f, 0.08572198f, 0.04030909f, 0.15861291f, 0.06684349f, -0.04640527f, 0.05682891f, -0.01565173f, 
    -0.15688920f, 0.08188359f, 0.01270699f, 0.01141594f, -0.06281655f, -0.08667414f, -0.00258686f, 0.03665616f, 
    -0.07517667f, 0.01627612f, 0.03687328f, -0.06747649f, -0.06467178f, 0.01873859f, -0.04186683f, 0.12995286f, 
    0.01258289f, 0.03549444f, 0.02569320f, 0.12741072f, -0.02297468f, 0.07898682f, -0.00231176f, 0.07900263f, 
    0.07766978f, -0.08509926f, 0.01654243f, 0.14341329f, 0.01475765f, -0.08951554f, 0.04948485f, 0.18658592f, 
    -0.02470755f, -0.03084076f, -0.08507708f, 0.00792729f, 0.03590152f, 0.29752597f, -0.00891508f, 0.14844672f, 
    -0.01215488f, 0.01743771f, -0.04708679f, -0.02701852f, -0.10958478f, 0.02838937f, 0.07420817f, 0.12793842f, 
    -0.24555890f, 0.02795507f, 0.16952354f, -0.05570555f, -0.15952301f, 0.07357959f, -0.02976701f, -0.00006727f, 
    -0.05809740f, -0.07694446f, -0.06969532f, 0.04713293f, -0.18303663f, 0.09424203f, 0.01407959f, 0.11496853f, 
    -0.03521553f, 0.10676312f, 0.03748884f, 0.07171718f, 0.00823995f, -0.15073736f, 0.02043298f, 0.05936112f, 
    -0.15742901f, 0.01205609f, 0.21009006f, -0.05836711f, -0.07462061f, 0.03757482f, 0.00089840f, 0.12239370f, 
    -0.12134296f, 0.08325239f, -0.04766399f, 0.19073205f, -0.17255431f, -0.16249515f, 0.10029145f, -0.08923347f, 
    0.21109232f, 0.05624625f, 0.03470764f, -0.04307122f, 0.04183607f, 0.01488378f, -0.09208320f, -0.04012213f, 
    0.15297304f, 0.06271044f, 0.05500385f, 0.04265343f, 0.04986360f, 0.15128510f, 0.10014462f, -0.09435306f, 
    0.00547456f, -0.03544081f, -0.02046801f, -0.05677995f, 0.13057290f, -0.04994440f, -0.01894215f, 0.11356473f, 
    -0.06005346f, -0.02778604f, 0.00692777f, 0.07629102f, -0.00316773f, 0.07110654f, 0.15349270f, 0.10752722f, 
    0.18895698f, -0.05507913f, -0.02778613f, -0.06385440f, -0.04367572f, 0.01105942f, -0.07327519f, 0.01283620f, 
    0.04640146f, -0.14681038f, -0.07351890f, 0.01604662f, -0.03355571f, 0.10158718f, 0.16686696f, 0.16207771f, 
    0.00582009f, 0.00314244f, 0.02969340f, 0.07933197f, 0.01844420f, -0.02688706f, 0.13030867f, 0.14704177f, 
    -0.07345115f, -0.06303132f, 0.03057840f, 0.00139629f, -0.10288110f, 0.04684498f, 0.00503327f, -0.03450471f, 
    0.02001108f, 0.06323671f, -0.16453731f, -0.16992112f, -0.26448444f, 0.03836167f, 0.04912262f, -0.04243561f, 
    -0.00773820f, 0.05888272f, -0.09352449f, 0.10559219f, 0.06265789f, -0.01432703f, -0.04066865f, -0.10280882f, 
    0.23772788f, -0.05110518f, -0.08877864f, -0.00426114f, -0.15375935f, -0.05465238f, 0.07211669f, -0.16169614f, 
    0.02066939f, 0.01686749f, -0.12014851f, 0.12046887f, 0.16608405f, -0.13101380f, 0.02474486f, -0.13742574f, 
    -0.02266932f, 0.03319830f, -0.01149986f, 0.09271457f, 0.05395895f, -0.06070184f, -0.01057956f, -0.10108303f, 
    -0.11921051f, -0.14181772f, 0.03701431f, -0.01573692f, -0.01879169f, 0.06871066f, -0.09525728f, -0.07031980f, 
    0.09309642f, -0.00634332f, -0.10361424f, -0.16055909f, -0.10860196f, -0.03267313f, 0.01953875f, -0.08367355f, 
    -0.03192303f, 0.00917858f, 0.03243750f, 0.00036443f, -0.03150661f, -0.13563921f, -0.09134930f, -0.04158931f, 
    -0.03286465f, 0.04841721f, -0.04443889f, 0.04526192f, -0.07757618f, -0.00666897f, 0.03255634f, -0.08744061f, 
    -0.03905893f, -0.04534462f, 0.03364718f, -0.00001331f, 0.24449953f, -0.09263335f, -0.02773908f, 0.15244934f, 
    0.00419893f, -0.00637758f, 0.07634307f, -0.05299278f, -0.00720980f, 0.02028914f, -0.10414622f, -0.09550867f, 
    0.18549164f, 0.03477129f, 0.10151108f, 0.11395305f, 0.03057134f, -0.00693242f, -0.05145189f, 0.00270514f, 
    -0.07798661f, -0.05887110f, 0.03225552f, 0.06043214f, 0.28393075f, 0.23470818f, -0.07201657f, -0.20175157f, 
    0.02919757f, -0.06636133f, 0.14499663f, 0.15710159f, -0.03083017f, 0.09427352f, 0.03285563f, 0.19713216f, 
    -0.05220599f, -0.02204884f, 0.10022996f, 0.14281940f, 0.01324246f, -0.02089040f, -0.05260232f, -0.06336211f, 
    -0.15412211f, -0.07055933f, -0.05090754f, 0.06448847f, 0.14755267f, 0.09845081f, 0.03353564f, 0.07601684f, 
    -0.00367822f, -0.25026819f, 0.02976317f, 0.03837510f, -0.07037437f, 0.03465927f, 0.15298891f, -0.06137187f, 
    0.11930069f, 0.08123653f, -0.06767391f, 0.04498109f, -0.02977844f, 0.01625385f, 0.07071435f, 0.04214425f, 
    -0.01545860f, 0.16731721f, 0.04878180f, 0.30785343f, 0.05959057f, -0.07586168f, -0.17475705f, -0.00133223f, 
    0.04772501f, -0.07897709f, -0.02118480f, 0.02972952f, -0.06646784f, -0.03506858f, 0.08271553f, 0.00567977f, 
    -0.10664242f, 0.14230371f, -0.00451311f, 0.11068621f, -0.07800107f, 0.06331138f, -0.02296991f, -0.01446352f, 
    -0.00277791f, 0.07984240f, 0.10047414f, 0.04030484f, 0.01370249f, 0.06760323f, 0.12808439f, -0.25479689f, 
    -0.05409873f, -0.00308930f, -0.05722567f, -0.06725652f, 0.00451933f, 0.10141405f, -0.15565866f, 0.06977089f, 
    0.07162885f, 0.03093707f, 0.03961231f, -0.18467660f, -0.05180823f, -0.02401700f, 0.08041640f, -0.02466517f, 
    0.03940254f, -0.04003742f, 0.18283755f, -0.17493097f, 0.18506974f, -0.03640655f, 0.18040092f, -0.11168443f, 
    -0.01983319f, 0.02106183f, -0.13439634f, 0.02230321f, 0.02647858f, 0.00108320f, -0.09318491f, 0.14989929f, 
    0.16152781f, -0.08960236f, 0.08329105f, 0.06176835f, -0.10212646f, 0.17858769f, 0.00375941f, -0.09994563f, 
    0.01107743f, -0.06760430f, -0.07566324f, -0.12498508f, 0.06199759f, 0.02250658f, 0.14911555f, 0.11841642f, 
    -0.05141028f, 0.06607023f, 0.04025041f, 0.14428617f, -0.04373147f, 0.03750478f, 0.06112004f, -0.12294968f, 
    0.03283830f, 0.04725618f, 0.15665054f, -0.09683874f, 0.16194773f, -0.07509094f, 0.16348557f, -0.07071929f, 
    -0.15624949f, 0.07783948f, 0.05996764f, 0.14149398f, 0.00024635f, 0.01812457f, -0.01414524f, -0.00272043f, 
    -0.01167961f, 0.06055487f, 0.05819698f, -0.13314840f, -0.02956030f, -0.17565213f, -0.16212076f, 0.02170892f, 
    0.11073549f, 0.12429462f, 0.01803276f, 0.01024229f, 0.06852139f, -0.05423824f, 0.01668103f, 0.14895163f, 
    0.10081928f, -0.07189874f, 0.14454849f, -0.10125193f, 0.05745372f, -0.00978754f, -0.06613056f, -0.03652170f, 
    -0.00356070f, -0.01994388f, -0.08809644f, -0.08193182f, -0.07808482f, -0.01272939f, -0.01589142f, -0.03735015f, 
    0.27612412f, 0.10825042f, 0.06667373f, -0.01362792f, -0.08081047f, 0.21156596f, -0.04266490f, 0.04822484f, 
    -0.05873870f, 0.00159382f, 0.03134226f, -0.05084771f, 0.01015854f, 0.03076549f, 0.05955144f, 0.00865019f, 
    -0.05874347f, 0.02254910f, -0.00787400f, 0.08752513f, -0.01477642f, -0.03261727f, -0.02104145f, -0.07876290f, 
    0.07132841f, -0.15363415f, 0.09413470f, -0.00892795f, -0.07959162f, 0.10712225f, 0.04000834f, -0.01864462f, 
    -0.00304532f, 0.08444146f, 0.02364578f, 0.01595430f, 0.12078366f, -0.11318331f, 0.24169128f, 0.16133797f, 
    0.01717957f, 0.07272223f, -0.00361572f, 0.04147821f, -0.07987288f, 0.15676971f, 0.14305016f, 0.16173857f, 
    0.21735235f, 0.02679090f, 0.04120166f, -0.06991011f, -0.11028794f, 0.11491569f, -0.05265883f, -0.10166553f, 
    0.01569903f, 0.01087453f, 0.00163086f, -0.03091762f, 0.22376315f, 0.06932287f, 0.04570130f, 0.02577651f, 
    -0.13598765f, 0.11194552f, -0.09797803f, 0.06111433f, 0.05665090f, 0.09319432f, 0.01239582f, 0.04617072f, 
    0.09057148f, 0.01720246f, 0.06977376f, -0.06087657f, 0.08712301f, -0.05047252f, 0.07912945f, -0.03683617f, 
    0.03529349f, 0.04333305f, 0.12928016f, 0.09702870f, 0.08878341f, 0.06176489f, -0.02922978f, 0.12751873f, 
    0.03060329f, 0.03976553f, 0.12755495f, -0.03723868f, 0.01179638f, -0.09241498f, -0.05936534f, -0.05281634f, 
    -0.32403377f, -0.24417469f, -0.11035974f, 0.07252117f, -0.13943218f, 0.03880180f, -0.05793402f, -0.03696045f, 
    -0.08104599f, -0.08742441f, 0.08154749f, -0.10554160f, 0.03784595f, -0.19287045f, -0.00435494f, -0.13094668f, 
    -0.02191539f, -0.07499952f, -0.09714212f, -0.07563825f, -0.02835864f, 0.11632352f, -0.15008408f, -0.06197168f, 
    0.07839914f, 0.09548240f, 0.02003304f, -0.04901653f, -0.04902851f, 0.00191935f, -0.00505038f, -0.04505562f, 
    -0.02918892f, 0.07802941f, -0.09365808f, 0.12980306f, -0.37580168f, 0.00287191f, -0.16593091f, 0.07127212f, 
    0.00742443f, 0.05129989f, -0.04963206f, 0.01560455f, -0.01537185f, 0.02584939f, 0.01009856f, 0.10556937f, 
    0.07773850f, -0.01281360f, 0.08336501f, 0.00712445f, -0.00866412f, 0.12867574f, 0.09496184f, 0.00535129f, 
    -0.06289325f, 0.04821053f, -0.06772156f, -0.02878009f, -0.23089655f, -0.14869437f, 0.05719056f, 0.23637214f, 
    -0.06405755f, 0.03301927f, -0.03569261f, -0.01807854f, -0.00118060f, -0.05003160f, -0.02632767f, -0.06734367f, 
    -0.16833872f, 0.07331921f, -0.06828807f, 0.26221204f, 0.02703863f, -0.07664981f, 0.04330814f, -0.03937497f, 
    -0.05452803f, 0.05153834f, -0.01196414f, 0.00227275f, -0.07428685f, -0.07273180f, 0.10113275f, -0.14945592f, 
    0.02856681f, -0.01467173f, 0.02966130f, 0.09339199f, -0.01419101f, 0.02554679f, 0.00063313f, 0.06296521f, 
    -0.25664619f, 0.15611272f, 0.07983930f, -0.01254871f, 0.14285456f, 0.01870630f, -0.00992440f, -0.01276931f, 
    -0.08524480f, -0.03240477f, 0.07887173f, 0.01853545f, 0.11462097f, 0.07495555f, 0.16626768f, -0.29758388f, 
    0.02052824f, 0.03173219f, -0.05090307f, 0.00078449f, 0.03804506f, 0.05971890f, -0.00792329f, 0.03429560f, 
    0.16438653f, 0.02053052f, 0.03948319f, 0.01293561f, 0.05043264f, 0.06283067f, -0.05725692f, -0.10279372f, 
    -0.13134646f, 0.14036775f, -0.03301835f, -0.04153517f, 0.05818817f, 0.03985292f, 0.21309163f, 0.10206047f, 
    0.17457600f, 0.12607877f, 0.02278461f, 0.02279367f, 0.01839283f, 0.11961196f, -0.01780902f, 0.02017275f, 
    -0.02875094f, -0.12266414f, -0.08147323f, -0.07842002f, -0.01904758f, 0.04222502f, 0.03894650f, 0.04614286f, 
    0.00124925f, -0.04815610f, 0.01618240f, 0.02190843f, -0.23295218f, -0.16468826f, -0.16926475f, 0.17929783f, 
    0.03993731f, 0.04502019f, -0.06446108f, -0.04117663f, -0.03640860f, 0.04570625f, -0.05696215f, 0.02561641f, 
    -0.18302171f, -0.09575139f, -0.06668255f, -0.00235170f, 0.02922190f, -0.00498330f, -0.04804392f, 0.05081884f, 
    0.05539046f, -0.07669548f, 0.00361756f, 0.03631948f, 0.12239096f, 0.08658274f, 0.10510250f, 0.12570806f, 
    0.01944562f, -0.01139173f, -0.05295357f, 0.08190790f, 0.06172533f, 0.07832218f, -0.02405187f, -0.05871976f, 
    0.06946738f, 0.04254271f, 0.04948505f, -0.07666741f, 0.19123541f, -0.00640356f, -0.01845541f, -0.07953652f, 
    0.03777346f, 0.09228431f, -0.02755446f, 0.07496935f, 0.15688103f, -0.08781618f, 0.10874429f, 0.03784536f, 
    0.03376017f, -0.01575523f, -0.01166223f, 0.00516653f, 0.12852833f, 0.08439989f, -0.00050807f, 0.10115332f, 
    0.00306519f, -0.13207413f, 0.04420966f, 0.04109763f, 0.09455775f, -0.06838597f, 0.01007533f, -0.00735943f, 
    0.11717617f, -0.02997695f, 0.01146949f, 0.14422750f, 0.04684700f, 0.07186971f, -0.13411842f, 0.06733309f, 
    0.14528596f, -0.01694418f, -0.02799574f, -0.01668006f, -0.00377329f, -0.05581191f, -0.01683389f, 0.16027911f, 
    -0.27188325f, -0.12669474f, 0.06005405f, -0.12468628f, 0.00661021f, 0.02784132f, -0.06249234f, -0.02293449f, 
    0.04622561f, -0.03665549f, -0.00839817f, -0.05687675f, 0.00666132f, 0.06685027f, -0.20945628f, -0.05337730f, 
    -0.06541125f, -0.00741253f, -0.07886473f, -0.09139301f, 0.02350521f, -0.02622502f, 0.00342871f, -0.06025150f, 
    0.07243744f, 0.11142313f, 0.07628602f, 0.00617574f, 0.09336520f, -0.03126427f, 0.06610881f, -0.02378349f, 
    0.00869764f, 0.02017597f, 0.02621586f, 0.07825742f, 0.44868356f, -0.02147916f, 0.00157774f, 0.30303600f, 
    0.08436413f, 0.01448224f, 0.01052917f, 0.03729202f, 0.01082684f, 0.17903695f, 0.01106621f, -0.01552324f, 
    -0.02583781f, 0.03470960f, 0.05589897f, 0.09880955f, -0.02085416f, 0.01263879f, 0.09660321f, -0.02084401f, 
    -0.02509719f, 0.02158342f, -0.00537873f, -0.05294911f, 0.10126212f, 0.00338854f, -0.06472898f, -0.15770075f, 
    0.04101440f, -0.02002069f, -0.00057309f, -0.02903414f, 0.02206592f, 0.03485411f, -0.00952884f, -0.00055531f, 
    0.02120739f, 0.17794114f, -0.02906319f, 0.09974813f, -0.01766225f, -0.01480395f, 0.07851841f, -0.01830131f, 
    0.04771684f, 0.02526783f, 0.05396043f, -0.04747138f, 0.10513027f, 0.13944614f, 0.11108793f, 0.09355803f, 
    -0.10934918f, -0.04244380f, 0.03150197f, 0.04739223f, -0.01592202f, 0.09317969f, -0.07626119f, -0.02465480f, 
    -0.02444515f, -0.22587572f, 0.00996016f, 0.01007176f, -0.17748898f, 0.00695585f, -0.03099001f, -0.11645432f, 
    0.06132966f, 0.08548775f, 0.09238160f, -0.13290197f, 0.18031792f, 0.15887266f, 0.11192723f, 0.08641504f, 
    0.03001762f, 0.03373022f, 0.06696524f, 0.08500098f, -0.03701777f, 0.08018681f, -0.01172620f, -0.09930624f, 
    0.03035006f, 0.13110216f, 0.01700407f, 0.00838913f, -0.02176876f, -0.05344496f, 0.01804079f, 0.09049521f, 
    -0.00761608f, -0.01841320f, 0.05374811f, -0.03851973f, 0.19260876f, 0.26341909f, -0.09818055f, -0.08839400f, 
    -0.04051082f, 0.04166200f, 0.14977323f, 0.00786213f, 0.11719159f, 0.07962020f, -0.03159849f, -0.04088198f, 
    -0.00283915f, -0.03224066f, 0.10138619f, 0.04776423f, -0.11001353f, 0.01228784f, 0.05154498f, -0.00313228f, 
    0.04457555f, -0.02408399f, 0.03483482f, 0.08610214f, -0.02951416f, -0.20311925f, -0.01881696f, 0.14692627f, 
    0.06809605f, -0.02170780f, 0.00260401f, 0.01804775f, 0.02019167f, -0.01036857f, -0.05885828f, 0.07290691f, 
    0.18777308f, -0.02422360f, 0.11540157f, 0.17323492f, -0.07218707f, 0.02460441f, 0.07391993f, -0.00053541f, 
    -0.02127743f, -0.01307949f, -0.03152192f, 0.09295625f, -0.18068074f, 0.17450884f, 0.18328165f, 0.08492949f, 
    0.02315820f, 0.05386904f, -0.07360521f, 0.03473315f, -0.05240710f, 0.04107445f, 0.07135484f, 0.14295743f, 
    -0.02941918f, -0.07630531f, 0.01367579f, 0.06630994f, 0.01815777f, 0.06682102f, 0.01697212f, -0.03370444f, 
    0.03506715f, 0.02275606f, 0.09036504f, 0.01986124f, 0.15104780f, 0.02310824f, 0.04251882f, 0.13883281f, 
    -0.04076041f, 0.00026480f, -0.00929543f, 0.01762095f, -0.02417909f, 0.01005586f, -0.05602143f, -0.03340163f, 
    -0.16863529f, -0.18267030f, -0.01114328f, 0.05770464f, 0.04444511f, -0.07313079f, -0.03000348f, -0.00769428f, 
    0.02744871f, 0.10286273f, -0.08354955f, 0.11969713f, 0.15495464f, 0.08820287f, -0.06138148f, 0.07966140f, 
    -0.09968304f, -0.00536779f, 0.01289866f, -0.06069822f, -0.04168776f, 0.08187227f, 0.10609438f, -0.04535863f, 
    0.19812834f, 0.01511863f, 0.15558439f, 0.02438518f, 0.11341926f, 0.07828181f, 0.03378417f, 0.05881775f, 
    0.06413516f, 0.01114998f, 0.01520819f, 0.04015328f, -0.05574512f, 0.04730075f, 0.12182272f, -0.08526963f, 
    0.12810621f, -0.01011673f, 0.08510901f, -0.02467957f, -0.07016309f, -0.02905227f, 0.15592174f, -0.01194081f, 
    -0.23915975f, -0.02773329f, -0.05773144f, -0.03084512f, -0.07517081f, 0.04210113f, -0.07835370f, -0.03309560f, 
    0.05240779f, 0.02387811f, 0.03920605f, -0.04314283f, 0.17093658f, 0.05559868f, 0.13747863f, 0.05160904f, 
    0.06534072f, 0.06941317f, 0.06187829f, 0.08421483f, 0.04920417f, 0.05994396f, -0.06509942f, -0.02883915f, 
    0.01750605f, 0.03570984f, -0.04890751f, 0.31735018f, 0.13988662f, 0.00602512f, 0.05636153f, -0.00310546f, 
    -0.00106612f, -0.02663002f, -0.12205192f, -0.09601155f, 0.04109016f, 0.13092665f, 0.02353039f, 0.00165395f, 
    0.12183865f, 0.04638523f, -0.07578076f, 0.13889058f, -0.00574496f, 0.02888480f, 0.07925212f, 0.03328019f, 
    -0.06634463f, -0.19582851f, -0.23343787f, 0.20499571f, 0.11343271f, 0.02838932f, 0.00124108f, 0.01805137f, 
    -0.11153772f, -0.03716544f, -0.03084765f, -0.01212089f, -0.15175956f, 0.04307985f, 0.04183806f, -0.10946748f, 
    0.04119512f, -0.00950069f, -0.00659567f, 0.03580445f, 0.00935483f, 0.00383521f, 0.06633475f, -0.03407812f, 
    0.06249576f, 0.08011211f, 0.20598131f, -0.05323692f, -0.01637486f, 0.02079465f, -0.03496544f, 0.07580223f, 
    -0.04984922f, -0.03743655f, -0.05953136f, -0.03619749f, 0.07410314f, 0.14492968f, 0.16233373f, 0.09352606f, 
    0.05834117f, 0.01653780f, 0.00010173f, 0.02369461f, -0.05937521f, 0.04566851f, -0.03338682f, -0.01077759f, 
    0.07079055f, -0.13120505f, -0.14490011f, -0.04473509f, -0.01496490f, 0.06318560f, -0.01152195f, -0.09436984f, 
    -0.05065347f, -0.02245503f, -0.02732895f, 0.17862396f, -0.17750877f, -0.21288766f, 0.07695904f, -0.00916481f, 
    -0.09946933f, 0.03874435f, -0.04050598f, -0.04584366f, 0.01930067f, -0.08857062f, -0.05030615f, 0.00585777f, 
    -0.19987878f, -0.12535705f, -0.03013116f, 0.00354149f, 0.00131013f, -0.02815253f, -0.08796961f, -0.07429086f, 
    -0.04417364f, -0.04954602f, -0.03365628f, -0.03367635f, 0.01752138f, -0.12463605f, -0.09712297f, -0.04623220f, 
    0.02016939f, -0.00542772f, 0.06954449f, -0.01548711f, -0.00211463f, 0.01853295f, -0.05218839f, -0.03632496f, 
    0.19671924f, -0.03758679f, -0.06665811f, 0.00539915f, 0.01516559f, -0.01438963f, 0.11248175f, 0.00297060f, 
    0.03020657f, 0.09150153f, -0.06412429f, 0.00691945f, 0.08120547f, -0.05706912f, 0.03930385f, 0.24705933f, 
    0.08258959f, 0.07653417f, -0.03502541f, 0.04253111f, 0.02690572f, 0.07347704f, 0.08196231f, 0.06229683f, 
    0.25354683f, 0.02839798f, 0.03322774f, 0.12124161f, 0.07161545f, -0.00730743f, -0.01751244f, -0.05108196f, 
    -0.05233665f, 0.01831215f, -0.04274343f, 0.06639929f, -0.11567938f, -0.15187749f, -0.05395777f, -0.05450645f, 
    -0.02597819f, 0.04791509f, -0.06751173f, -0.02202969f, -0.01400653f, -0.06025897f, -0.08304019f, 0.01842121f, 
    -0.14711078f, 0.09593846f, 0.11138546f, 0.05584814f, -0.01178423f, -0.01800498f, -0.04911911f, -0.03889192f, 
    -0.14196587f, 0.07239351f, -0.04460290f, -0.03896956f, 0.27271575f, 0.06737053f, 0.16361055f, 0.01728504f, 
    0.04533293f, 0.14069213f, 0.13344006f, 0.07866912f, 0.08909015f, 0.09282126f, -0.00430800f, -0.08458678f, 
    0.08931826f, 0.32165286f, 0.18527217f, 0.08804618f, 0.11393945f, -0.03032712f, -0.07593100f, 0.01058614f, 
    0.00137170f, -0.04933636f, -0.01345796f, -0.02239351f, 0.09342553f, -0.00322636f, -0.05240212f, 0.16792305f, 
    0.07586758f, -0.01405316f, 0.07524762f, 0.01006034f, 0.10781255f, 0.01080243f, 0.04631211f, 0.00929772f, 
    -0.10224739f, 0.10648426f, 0.05190987f, -0.21906579f, -0.03554153f, 0.11284510f, -0.01627406f, 0.08839890f, 
    -0.07848270f, 0.04564783f, 0.02206247f, 0.10434098f, -0.17479144f, -0.04122093f, -0.04090881f, -0.17137179f, 
    0.05343131f, 0.01678957f, 0.01014429f, -0.07203922f, 0.06558158f, -0.05800429f, 0.05020675f, 0.11805468f, 
    -0.02187580f, 0.10121708f, 0.09105597f, 0.08590668f, 0.08184983f, 0.03417197f, -0.05875574f, 0.00546478f, 
    -0.00156065f, 0.04055583f, 0.06260076f, 0.05576763f, 0.13827938f, 0.18092485f, -0.06321704f, 0.01552866f, 
    0.06114754f, 0.05084488f, -0.01387756f, -0.02618708f, 0.09242076f, -0.02374048f, 0.03289412f, 0.06383617f, 
    0.09848198f, -0.12403060f, -0.01021901f, -0.02710946f, 0.08544759f, 0.05754159f, 0.00710116f, 0.02183823f, 
    0.10806575f, 0.06811576f, -0.00984980f, 0.00936264f, 0.12474345f, 0.12641989f, 0.07657297f, -0.01250497f, 
    0.10623284f, 0.02557766f, 0.07334347f, -0.02873990f, 0.11003448f, 0.10927510f, 0.02917295f, 0.05372307f, 
    0.10028734f, 0.01503795f, -0.03487357f, -0.09548963f, -0.00063225f, 0.01776050f, 0.02632576f, 0.10403095f, 
    0.10763382f, -0.03868443f, -0.11321189f, 0.08727393f, 0.21195607f, 0.21720167f, 0.01309037f, -0.03801619f, 
    0.09145096f, -0.01824997f, 0.02941876f, 0.00958671f, -0.00580510f, -0.03449360f, -0.00352669f, 0.04313273f, 
    -0.04526144f, 0.04731980f, 0.13730279f, 0.00829643f, 0.04474165f, 0.13521117f, 0.08176971f, 0.10214341f, 
    0.04145577f, 0.09163659f, -0.00360453f, 0.09886511f, -0.02048303f, -0.02592597f, 0.15787736f, -0.03005958f, 
    0.05218193f, -0.02259219f, 0.10404418f, -0.06281749f, 0.09293570f, 0.01298800f, 0.09467678f, 0.15969382f, 
    0.16969600f, -0.05594048f, 0.06323067f, 0.08574007f, -0.02873095f, 0.08349795f, -0.07428855f, -0.08765554f, 
    0.02606627f, 0.00013993f, 0.03020096f, 0.05376290f, 0.21860117f, 0.06067956f, -0.16170974f, -0.06619550f, 
    0.00458913f, -0.00612535f, -0.05539137f, -0.04632234f, -0.03739636f, 0.02745678f, 0.02173451f, -0.12003574f, 
    -0.15942797f, -0.03684159f, 0.10989195f, -0.03148609f, 0.05786907f, 0.04845030f, 0.02819772f, 0.09557910f, 
    0.05925103f, -0.03781830f, 0.06641262f, 0.04754585f, -0.19960062f, -0.04364340f, 0.02208082f, -0.03898776f, 
    -0.01859359f, 0.16772217f, -0.00354061f, -0.00187512f, 0.04831560f, -0.02927720f, 0.08914278f, -0.06732032f, 
    -0.00363730f, 0.08754402f, 0.09336670f, 0.01290672f, 0.15920466f, -0.14252454f, 0.11244048f, -0.05188895f, 
    0.08383863f, 0.01943360f, 0.09458811f, 0.05789061f, 0.06158108f, -0.00929437f, 0.19327247f, 0.05813150f, 
    0.00348623f, -0.00668377f, -0.02331111f, 0.02639018f, 0.13637340f, -0.00594904f, 0.09851661f, 0.02555837f, 
    -0.03154896f, 0.39078516f, 0.04877128f, 0.04552418f, 0.07180985f, -0.01779290f, 0.00300011f, 0.01133773f, 
    0.00307298f, 0.01117759f, 0.02162175f, 0.14621522f, -0.04885453f, -0.11133129f, -0.16269650f, 0.07582406f, 
    -0.02393966f, 0.04368903f, 0.06965953f, 0.04118058f, 0.08121391f, -0.02752347f, 0.01078562f, -0.07171526f, 
    -0.18140844f, -0.02542827f, 0.04830863f, -0.03255447f, 0.04960004f, -0.05897530f, 0.07959337f, -0.02945110f, 
    -0.02392838f, -0.09008449f, 0.05800932f, 0.03916178f, 0.05486053f, 0.14746824f, 0.05591042f, -0.09035055f, 
    0.09247930f, 0.15182841f, 0.03256961f, -0.05038415f, -0.00802910f, 0.11594410f, 0.05145730f, 0.17128141f, 
    0.33901736f, 0.05265873f, -0.04532632f, -0.10090481f, 0.04484719f, 0.02692807f, -0.02403330f, -0.07323515f, 
    0.02140776f, 0.03640513f, 0.09733204f, 0.16245189f, -0.29686907f, -0.02526832f, 0.16977757f, -0.05897747f, 
    -0.03973294f, -0.06350890f, 0.04707511f, -0.09942096f, -0.05771581f, 0.01970407f, 0.03064466f, 0.06588996f, 
    0.08870064f, 0.10720419f, 0.06903404f, 0.08802057f, 0.11079730f, 0.05240202f, 0.12517209f, -0.01551666f, 
    0.04886197f, -0.00523145f, 0.02744436f, 0.07942904f, 0.16982190f, 0.07303633f, 0.17892334f, 0.10345948f, 
    -0.02519830f, 0.10012361f, 0.05572661f, -0.06300282f, 0.01863156f, -0.00647506f, 0.05292271f, -0.06609476f, 
    -0.11619256f, -0.00980100f, -0.00270140f, -0.08601616f, 0.00447901f, 0.13353860f, -0.05698591f, -0.04720853f, 
    -0.00805598f, 0.07603262f, 0.02210274f, 0.02287870f, -0.10752182f, -0.12671930f, -0.03587059f, -0.00307179f, 
    -0.04896044f, -0.02003681f, 0.10373845f, -0.02470852f, 0.10477558f, 0.04997380f, -0.03412853f, -0.04057339f, 
    0.06910627f, 0.07090984f, -0.01879448f, 0.00613317f, 0.05177130f, -0.07575149f, 0.16978894f, 0.08416519f, 
    0.10003617f, 0.08605369f, 0.11291827f, -0.04441310f, -0.13415991f, -0.11794888f, 0.03828694f, 0.00555269f, 
    0.02248149f, -0.01789963f, 0.05450087f, -0.02254397f, -0.00718631f, 0.11707982f, 0.06465465f, 0.01120184f, 
    0.05098513f, -0.03487301f, -0.02333868f, -0.08371647f, 0.10151017f, 0.05430546f, -0.09397966f, 0.02786398f, 
    0.03342720f, -0.05629441f, 0.08579454f, -0.09736167f, 0.05698371f, 0.12806043f, -0.16281499f, -0.09453205f, 
    -0.03775704f, 0.02498565f, 0.07014083f, -0.00165662f, -0.06354922f, 0.04555671f, 0.14001834f, 0.05504651f, 
    -0.14341174f, 0.18091947f, 0.03420969f, 0.13289121f, 0.03665110f, -0.11839750f, -0.05612164f, 0.06183904f, 
    0.01495592f, 0.06743213f, -0.04521740f, 0.04419113f, 0.01166535f, -0.00748708f, -0.04718005f, -0.00911003f, 
    0.04634370f, 0.06335136f, -0.01470711f, 0.00556488f, 0.08110578f, -0.01951596f, -0.14124264f, 0.03458318f, 
    0.22032999f, -0.01522494f, 0.10774194f, 0.11525069f, 0.01485256f, -0.00070760f, 0.07332265f, -0.04880862f, 
    -0.01794457f, 0.21113206f, 0.08272333f, -0.05168175f, 0.16668692f, -0.11846203f, -0.08242767f, -0.13443471f, 
    -0.02891723f, -0.01604176f, 0.04744838f, -0.01104115f, -0.01155230f, 0.05681483f, -0.08980495f, 0.01736716f, 
    -0.00772263f, 0.08124302f, 0.00637027f, -0.05282713f, 0.00012499f, 0.01759337f, 0.01591306f, 0.04120122f, 
    0.01387315f, -0.06018317f, 0.11465965f, 0.09739634f, 0.10330375f, 0.15559715f, 0.03291743f, -0.15085182f, 
    0.03061299f, 0.03553670f, 0.17481820f, -0.09019861f, -0.02531345f, 0.09037967f, 0.10132249f, 0.05299411f, 
    -0.07662312f, 0.07750374f, 0.05706787f, -0.05738375f, 0.14318192f, 0.07416385f, 0.01201933f, 0.11232322f, 
    0.03339306f, -0.00814716f, 0.02355046f, -0.00096061f, 0.13296336f, -0.02731395f, -0.00883458f, -0.01476957f, 
    -0.02862227f, 0.06350339f, 0.10252696f, -0.01727950f, 0.04656309f, 0.04904207f, 0.03322395f, 0.09326039f, 
    0.18750228f, 0.19361174f, -0.00999801f, -0.15555289f, 0.14185001f, 0.07602046f, 0.03275590f, 0.05424927f, 
    -0.09105232f, -0.04519372f, 0.03295019f, 0.16693322f, -0.03396023f, -0.01985004f, -0.05447792f, -0.14529192f, 
    0.06154428f, 0.01132728f, -0.00380970f, 0.03583338f, -0.01061965f, 0.10461709f, 0.13885050f, 0.07489412f, 
    0.06011724f, -0.09487931f, 0.00359106f, 0.07481062f, 0.14958824f, 0.11937355f, 0.01668310f, 0.06440059f, 
    0.02751889f, 0.06613269f, -0.06014969f, 0.06489956f, 0.03391061f, 0.13586521f, 0.03539925f, -0.10944272f, 
    0.03230704f, 0.10424500f, -0.04564848f, 0.08561593f, 0.05778514f, 0.09107632f, 0.09285236f, 0.19248104f, 
    -0.25782478f, -0.07398234f, -0.11525211f, -0.16799167f, 0.08024520f, 0.00237329f, 0.05400273f, -0.06463216f, 
    0.06705997f, 0.04327673f, -0.01033012f, 0.03654030f, -0.32158920f, -0.19091333f, 0.18417305f, 0.05101632f, 
    0.02091817f, 0.04861543f, -0.10169151f, -0.00586711f, -0.03898704f, -0.06558675f, -0.02330193f, -0.08285561f, 
    0.02465666f, 0.13187701f, 0.00748140f, -0.01520847f, 0.03102914f, -0.00357677f, 0.03112322f, 0.04003027f, 
    0.10373853f, 0.06424043f, -0.03222429f, -0.00958823f, -0.15842268f, -0.17227434f, -0.03026966f, -0.00539524f, 
    -0.02219482f, 0.11361111f, -0.05096402f, -0.03183673f, 0.09024932f, 0.02149970f, -0.11438266f, 0.16594079f, 
    -0.09114405f, -0.03019606f, 0.03873485f, 0.03645179f, 0.03596756f, 0.01629133f, -0.03070903f, 0.03006607f, 
    0.05155842f, -0.08034819f, 0.05956381f, -0.08024186f, -0.06719583f, 0.05686814f, 0.09456821f, 0.08797943f, 
    -0.06690697f, -0.01047326f, 0.03849439f, -0.02505022f, 0.07978751f, 0.07866172f, -0.05487214f, 0.04940256f, 
    0.05774004f, 0.05548441f, 0.13241631f, 0.05754920f, 0.05721628f, 0.02428521f, 0.05903886f, -0.06536435f, 
    0.00819244f, 0.03015020f, -0.04330777f, -0.13534643f, 0.18877266f, 0.05899123f, 0.00687325f, 0.13617708f, 
    -0.02161554f, 0.08845943f, 0.11011631f, 0.05212267f, 0.00726574f, -0.02346302f, 0.17055960f, 0.00143960f, 
    -0.12597510f, -0.06911399f, -0.02603736f, -0.00047640f, 0.02600810f, -0.00304485f, 0.00336588f, 0.02086626f, 
    0.03955559f, 0.04653301f, -0.07622844f, 0.12371272f, 0.07200795f, -0.01766980f, -0.11198077f, 0.08034328f, 
    0.05309566f, -0.00211738f, 0.13169938f, 0.14020666f, 0.03091960f, 0.04532230f, 0.10490989f, -0.06933640f, 
    -0.18241997f, 0.16698042f, 0.08577483f, -0.16190317f, 0.10088924f, -0.12605526f, 0.02185667f, 0.07893946f, 
    -0.06503530f, 0.05618670f, 0.09809584f, 0.10105614f, -0.05075613f, 0.23562159f, -0.01853400f, 0.13109690f, 
    0.05385038f, -0.03431670f, -0.00059964f, -0.07376073f, 0.03927762f, 0.00919374f, 0.02506898f, 0.12480935f, 
    0.01901434f, -0.01748666f, -0.07187162f, 0.18312533f, -0.00773944f, 0.14858784f, -0.01130863f, 0.08278866f, 
    0.05729057f, -0.04927782f, 0.07620899f, -0.06367581f, 0.03229697f, 0.08697895f, 0.07544672f, -0.00309987f, 
    0.01964439f, -0.07074898f, -0.07258634f, 0.12373783f, 0.01749636f, 0.16270794f, 0.14011845f, 0.14821599f, 
    0.09504914f, -0.00111116f, -0.05034169f, 0.07548281f, 0.03608496f, 0.13349007f, -0.03457925f, -0.05960339f, 
    0.04162255f, 0.09302621f, -0.14570826f, 0.12112038f, -0.00844885f, 0.02255518f, -0.02073863f, -0.05876997f, 
    0.04693143f, 0.05286585f, -0.05982764f, 0.12460934f, 0.14560731f, 0.04836122f, 0.05356284f, 0.05794296f, 
    -0.35603067f, -0.15140323f, 0.06344240f, -0.09990502f, 0.09410661f, -0.06027152f, 0.00570717f, -0.03399072f, 
    0.06429373f, 0.04230499f, 0.00947710f, -0.01735406f, 0.00336877f, 0.12118604f, -0.04900188f, 0.15060380f, 
    0.12913878f, -0.09968586f, 0.11427792f, -0.07312602f, -0.03540126f, 0.01451580f, 0.10181294f, 0.07852934f, 
    0.34759060f, -0.00828545f, -0.01618256f, 0.00668995f, 0.05265363f, -0.04721570f, -0.07097851f, 0.10806458f, 
    0.07154941f, -0.00057168f, -0.02365624f, -0.00743582f, -0.02511879f, -0.06324889f, -0.20090495f, -0.06836532f, 
    -0.00190085f, -0.06012345f, 0.08005046f, 0.00748148f, 0.17914720f, -0.14834855f, -0.04771776f, -0.01732272f, 
    0.02734039f, -0.02768501f, -0.00899156f, 0.00408845f, -0.02176997f, 0.01883208f, 0.00663431f, -0.01683654f, 
    -0.03934876f, -0.02330941f, 0.01299668f, 0.01083329f, 0.01624530f, 0.01365003f, -0.00516617f, -0.00348838f, 
    0.02577045f, 0.00129788f, -0.00989039f, 0.00774146f, -0.03858232f, -0.03443079f, -0.02289113f, -0.03308097f, 
    -0.00841870f, 0.01697710f, -0.00499649f, 0.02981181f, -0.01702926f, 0.01056702f, 0.02629223f, 0.02521472f, 
    -0.00455579f, -0.01242213f, -0.02513269f, -0.00571749f, 0.00960494f, -0.03818728f, -0.00458747f, 0.00220836f, 
    -0.04121029f, -0.04295753f, 0.01912393f, 0.01534221f, 0.00980909f, -0.00739021f, 0.00482683f, -0.01473808f, 
    0.02388731f, -0.02500860f, -0.02272440f, 0.02075135f, -0.01938523f, 0.00226183f, -0.02215651f, 0.00757434f, 
    -0.01497664f, -0.04138604f, -0.01682377f, 0.00674941f, -0.03484170f, 0.02532884f, 0.01698411f, -0.01789113f, 
    0.01925575f, -0.02971336f, 0.00284270f, -0.01898200f, 0.00705530f, -0.01042801f, 0.02262481f, -0.01574551f, 
    0.00903931f, -0.00660563f, -0.02072755f, -0.00494785f, 0.02108064f, 0.00569348f, 0.00481057f, -0.03833661f, 
    -0.01803692f, -0.02004864f, -0.03381246f, -0.00912213f, 0.01100210f, 0.02862008f, -0.02634561f, 0.00369006f, 
    0.01697864f, -0.02930097f, -0.01269393f, -0.02553036f, -0.02198168f, 0.01550240f, 0.01854864f, 0.00179340f, 
    -0.02602889f, 0.00056312f, 0.02414562f, 0.01638182f, -0.00229958f, 0.00237041f, -0.04281875f, 0.02765352f, 
    -0.01327764f, -0.02591649f, 0.02695048f, -0.03582682f, -0.00335591f, -0.03816378f, 0.01738134f, -0.03290900f, 
    -0.03568190f, 0.01742915f, 0.01769609f, -0.00190067f, -0.01221886f, -0.02833757f, -0.02307565f, 0.01908900f, 
    -0.02337831f, -0.03970019f, -0.02295714f, -0.03837014f, -0.01859543f, -0.01353963f, 0.02068597f, 0.00553404f, 
    0.00215390f, -0.02184713f, -0.02562384f, -0.00676286f, -0.02051396f, -0.01098412f, 0.00949216f, -0.01362881f, 
    0.01293606f, -0.03635789f, -0.04133436f, 0.00647567f, 0.00405611f, -0.02583127f, -0.00070478f, -0.02290866f, 
    0.01660092f, -0.02384065f, -0.03232596f, 0.01107274f, 0.01109453f, -0.00903732f, 0.01739273f, -0.02875589f, 
    0.01617469f, 0.00343673f, 0.02305168f, 0.02382047f, 0.01983313f, -0.01356774f, -0.00891331f, -0.00220495f, 
    0.00725077f, 0.01995885f, 0.02615959f, -0.00520710f, -0.03307232f, 0.02463561f, -0.02876529f, -0.02899525f, 
    0.01199963f, -0.03964349f, -0.03978150f, 0.02101762f, 0.01247446f, -0.02879885f, -0.02166604f, 0.01131505f, 
    0.02573156f, 0.00946283f, -0.04339260f, -0.02912130f, -0.02638794f, -0.03299326f, -0.00044406f, -0.02579347f, 
    -0.00048929f, -0.02036605f, -0.01103363f, 0.00606649f, -0.01625554f, 0.02261202f, -0.01729835f, 0.01586782f, 
    -0.00038482f, -0.01597365f, -0.02091137f, 0.02093344f, 0.00079365f, -0.00412868f, -0.01681772f, -0.00534081f, 
    -0.00508857f, 0.02397519f, 0.01598511f, 0.01942723f, -0.00093968f, 0.00270013f, -0.00024615f, 0.02817568f, 
    0.02289636f, 0.02505164f, -0.03392297f, -0.00079425f, 0.00137556f, -0.03047833f, -0.04074718f, -0.03234074f, 
    0.01598030f, -0.01974232f, -0.00348813f, -0.01637128f, 0.02496812f, -0.02523202f, 0.02613248f, -0.01541231f, 
    -0.03560778f, 0.01252150f, -0.00972837f, -0.03860650f, -0.00139272f, -0.03421047f, -0.01643962f, 0.00943493f, 
    -0.02712432f, 0.01788232f, 0.02019766f, -0.03666973f, 0.00876910f, -0.00794838f, -0.03409357f, 0.02209271f, 
    0.00006934f, 0.02790303f, -0.02690815f, -0.00231026f, -0.01998564f, 0.01319161f, -0.02790902f, 0.02201435f, 
    -0.02017658f, 0.02532438f, 0.00769038f, -0.00548547f, -0.00020940f, -0.03498017f, -0.02927284f, 0.01631777f, 
    -0.01265495f, -0.01949138f, 0.00457777f, -0.01730171f, -0.03064220f, -0.02540822f, 0.01418338f, -0.00456653f, 
    0.01731989f, 0.00732102f, -0.01157306f, -0.02780366f, 0.00539452f, 0.01686441f, 0.01906658f, 0.01155381f, 
    -0.02789744f, -0.01504673f, -0.03855173f, -0.00867567f, 0.00259164f, 0.00158489f, -0.01108252f, -0.03271861f, 
    0.03805953f, -0.02263834f, -0.03047643f, -0.00096783f, 0.01813436f, 0.00327029f, 0.01531744f, 0.02263482f, 
    0.01482105f, -0.02093195f, 0.00997307f, -0.01464394f, 0.01361296f, 0.00305432f, 0.02611767f, 0.01337583f, 
    0.00316280f, -0.03224718f, -0.01158275f, -0.02502876f, 0.00889146f, -0.03721401f, -0.03600682f, -0.02696887f, 
    -0.00919742f, 0.02469281f, -0.02505365f, -0.01869049f, -0.01929612f, -0.02759130f, 0.01428719f, -0.00846017f, 
    -0.02622798f, -0.02077039f, 0.00472236f, -0.03894735f, -0.01894337f, -0.01679060f, -0.01131449f, 0.02784301f, 
    -0.04205706f, -0.02584153f, 0.01394159f, 0.00738072f, 0.01639622f, -0.01351800f, -0.03032688f, -0.02157398f, 
    0.02128330f, -0.04278959f, 0.00632969f, 0.01925048f, -0.03236936f, -0.02984786f, 0.04072078f, 0.01414578f, 
    -0.03580977f, 0.01080715f, -0.00663200f, -0.03158936f, 0.00789312f, 0.01673122f, 0.01866782f, -0.04266384f, 
    0.02186078f, -0.03896272f, 0.02393280f, -0.03228776f, -0.01008729f, -0.01854717f, -0.00281202f, -0.00848432f, 
    0.02396950f, -0.00198932f, -0.02263567f, -0.00593526f, -0.04160101f, -0.03660662f, 0.02728485f, -0.00921824f, 
    -0.03672853f, -0.01717599f, -0.00671708f, 0.01661400f, 0.01107497f, -0.01323436f, 0.02147006f, 0.00123171f, 
    -0.03295182f, -0.00138002f, -0.02722613f, 0.01662751f, 0.02335093f, -0.00843949f, -0.00457088f, 0.01265468f, 
    -0.04258990f, -0.02118807f, -0.00731538f, -0.00447686f, 0.01901206f, 0.00758851f, -0.04206189f, 0.00306842f, 
    0.00451447f, 0.00627223f, -0.01684021f, -0.02122404f, 0.00189219f, 0.01904908f, 0.00221139f, -0.02959086f, 
    -0.02398130f, 0.00263218f, -0.03608491f, -0.02769956f, -0.04159614f, -0.03286586f, 0.01758025f, -0.01817492f, 
    -0.00714861f, -0.03677903f, -0.02000417f, 0.02232346f, 0.02502264f, 0.02352718f, -0.01435606f, 0.01257451f, 
    -0.04324564f, -0.04151082f, -0.01915326f, -0.03815421f, -0.02894319f, -0.03926630f, 0.01713902f, 0.02204649f, 
    0.01627748f, 0.01697837f, -0.02095659f, 0.01637938f, -0.02718699f, 0.01128364f, 0.00273009f, -0.03459438f, 
    0.02046684f, 0.00383336f, 0.03330036f, -0.02532545f, -0.00290224f, 0.02210221f, 0.02356752f, 0.02968702f, 
    0.00148692f, -0.00230220f, -0.02499668f, -0.02303924f, -0.03357198f, -0.01075292f, 0.01457275f, -0.01693413f, 
    -0.02699479f, 0.00194622f, 0.00967742f, -0.01907650f, 0.00403740f, -0.02637185f, 0.00318325f, 0.02326209f, 
    -0.00294151f, -0.01430549f, -0.02599339f, -0.03568600f, -0.02688476f, -0.03703407f, 0.00350341f, 0.02167860f, 
    -0.02045353f, -0.01583694f, -0.03886443f, 0.01005162f, 0.00054948f, 0.00060973f, 0.00144684f, -0.02490336f, 
    -0.03723200f, 0.00897387f, -0.01769152f, -0.01207620f, 0.01139125f, 0.02576521f, -0.02847553f, -0.01433354f, 
    -0.03094182f, 0.00601025f, -0.02850199f, -0.03755273f, 0.00240435f, -0.03771032f, -0.00161542f, 0.01557203f, 
    -0.02260648f, -0.04157110f, 0.01437978f, 0.00277384f, -0.01148529f, 0.02009363f, 0.00216237f, -0.01407001f, 
    -0.01819908f, 0.00774853f, 0.01647932f, 0.00056129f, -0.03983247f, 0.00479934f, -0.02674864f, -0.00458506f, 
    -0.03441636f, -0.03273508f, 0.02158676f, -0.02898526f, -0.02424406f, 0.01777030f, -0.01845940f, 0.02259946f, 
    -0.01795613f, 0.03210197f, 0.00420840f, 0.01399479f, -0.01948536f, -0.02786825f, 0.02829401f, 0.00787476f, 
    0.03111278f, -0.03953178f, -0.02702857f, -0.01217587f, -0.01742988f, -0.01146643f, -0.01525752f, 0.00990080f, 
    -0.02905179f, -0.01708414f, -0.04387558f, -0.00301729f, 0.00980499f, 0.01421164f, 0.00696415f, 0.02198486f, 
    -0.03091851f, -0.00947381f, 0.00690579f, -0.00493656f, 0.00154543f, -0.03047090f, 0.00177712f, 0.01736846f, 
    -0.02248336f, -0.00048016f, 0.01006956f, -0.04130252f, 0.01246736f, -0.03965161f, -0.00823019f, 0.01595836f, 
    -0.01659084f, -0.03450145f, 0.00873670f, -0.00076964f, -0.00182675f, 0.02080035f, 0.01384665f, 0.00822151f, 
    -0.02313039f, -0.02905985f, -0.00845338f, -0.04232454f, 0.00285718f, -0.03699525f, -0.00837318f, 0.01500770f, 
    -0.01377833f, -0.03578703f, 0.00251583f, -0.00339653f, -0.02380572f, 0.02106388f, 0.01749068f, -0.03564734f, 
    -0.03237273f, 0.01998478f, -0.00367484f, -0.02418261f, -0.01576631f, 0.01999068f, 0.01347553f, -0.03101648f, 
    -0.02198204f, 0.01679203f, 0.00366237f, -0.01008862f, 0.02727350f, -0.01841454f, -0.00404809f, -0.00311688f, 
    -0.03300382f, 0.01238902f, -0.02859062f, -0.00845628f, 0.00029746f, -0.02209066f, -0.00398377f, -0.02832677f, 
    -0.01378872f, -0.00177310f, -0.00120634f, 0.01914549f, 0.02459121f, -0.03623481f, -0.00161798f, -0.01917605f, 
    0.02449524f, -0.02279153f, 0.01237101f, 0.00059642f, 0.01495500f, -0.00770747f, 0.00037220f, -0.03044333f, 
    -0.02050974f, 0.01770273f, -0.00953405f, -0.00029387f, -0.04175072f, 0.01983819f, 0.02056099f, 0.01361167f, 
    -0.02513856f, 0.01205164f, -0.00870132f, -0.01242239f, 0.02850201f, 0.02348611f, -0.04358853f, -0.04252380f, 
    0.01221743f, -0.03769997f, -0.01065887f, 0.01503809f, 0.00024048f, -0.00673266f, -0.04049127f, 0.02894705f, 
    0.02340236f, -0.00334515f, -0.02036968f, -0.02241003f, -0.01357549f, -0.02799733f, -0.00004602f, 0.02130990f, 
    -0.00842273f, -0.04220585f, -0.01177452f, -0.02883101f, 0.00068462f, -0.03485069f, 0.02395230f, -0.02525291f, 
    0.01643834f, -0.02501306f, 0.00302897f, 0.01259054f, -0.00126998f, 0.02099207f, -0.01426997f, -0.01759870f, 
    -0.00167117f, -0.01901847f, -0.01016325f, 0.03003558f, 0.01418281f, 0.00835512f, 0.01924061f, 0.02201983f, 
    -0.00227440f, 0.02817810f, -0.03411442f, 0.02468520f, -0.02948129f, -0.00371597f, -0.00381067f, -0.03270939f, 
    -0.01492779f, -0.03486397f, 0.02283325f, -0.03063873f, -0.02040486f, -0.03921903f, 0.00677309f, -0.03511085f, 
    0.02124223f, 0.03728943f, 0.00769226f, -0.04072726f, -0.00475736f, 0.00475860f, 0.00747249f, -0.03208076f, 
    0.01673844f, -0.03587407f, -0.02989071f, -0.00725426f, 0.03495035f, 0.02357090f, 0.01601246f, -0.03341031f, 
    0.01048827f, 0.00180139f, -0.03897076f, 0.02528100f, -0.01845297f, -0.04274761f, -0.01775214f, 0.01072460f, 
    -0.02268313f, -0.03902750f, -0.01926155f, 0.01853829f, 0.01669209f, -0.00960140f, 0.00819727f, 0.00867768f, 
    -0.01498479f, 0.00141201f, -0.02584978f, -0.01204316f, 0.02689254f, 0.02854965f, 0.00478501f, -0.01444013f, 
    -0.01563193f, 0.00426770f, -0.00250355f, -0.02719010f, 0.01115195f, -0.00293739f, 0.01074565f, -0.02181000f, 
    0.02126388f, 0.01005411f, -0.03912325f, -0.03894722f, -0.01862029f, 0.01316121f, 0.01489723f, -0.02812371f, 
    -0.03575659f, -0.01990246f, 0.00772359f, 0.01211370f, 0.02497044f, -0.04235059f, 0.02890547f, -0.01484847f, 
    0.01342585f, -0.03564775f, 0.01480821f, -0.01542265f, 0.00512519f, 0.00812865f, -0.03418563f, 0.00569640f, 
    -0.02682497f, -0.03478592f, -0.02407088f, -0.00128801f, 0.01383591f, 0.02657262f, 0.00804809f, -0.04159997f, 
    0.00821778f, 0.01205877f, 0.02420200f, -0.04194413f, 0.01130814f, -0.03724331f, 0.00786345f, 0.00105981f, 
    -0.02187802f, 0.00349238f, 0.01919247f, -0.03055936f, -0.03348473f, -0.01866233f, -0.00552518f, -0.04458201f, 
    0.01532075f, -0.00160239f, 0.01181576f, 0.02657034f, -0.00177693f, 0.00794616f, 0.00454013f, 0.02016220f, 
    -0.01023517f, -0.03017292f, 0.01572303f, -0.02993447f, -0.03622691f, -0.04581288f, -0.00492794f, -0.01225397f, 
    -0.02830024f, 0.00629602f, -0.04363413f, 0.00175662f, 0.02170091f, 0.01776055f, -0.03444080f, 0.00754637f, 
    -0.02970379f, 0.01429348f, 0.00628858f, -0.00697994f, -0.03093768f, 0.02547259f, 0.02424620f, -0.00734016f, 
    0.02198874f, -0.04225973f, -0.03549547f, 0.01256322f, 0.01280015f, -0.03577187f, -0.04260816f, -0.02475698f, 
    -0.02954905f, -0.03018540f, -0.01564516f, 0.00415172f, -0.01042995f, 0.02402771f, -0.00944053f, 0.00074252f, 
    -0.04306505f, -0.00920563f, -0.02213444f, -0.03747768f, -0.01288643f, -0.01342815f, 0.02186079f, -0.01495558f, 
    -0.01200578f, -0.00379029f, 0.01870108f, 0.00040243f, 0.02558795f, -0.03137919f, 0.00117865f, -0.00888645f, 
    -0.00701997f, -0.01860358f, 0.02500344f, 0.02267586f, -0.01691473f, -0.01226714f, -0.01861097f, -0.00389466f, 
    -0.01355521f, -0.01767427f, -0.00780545f, -0.00403684f, -0.03007841f, 0.00974035f, -0.02400677f, 0.00167086f, 
    -0.04556838f, -0.03808871f, 0.02292193f, -0.02453502f, 0.00706146f, 0.01332824f, 0.02246694f, -0.00993974f, 
    -0.03262702f, 0.01224354f, -0.01465509f, -0.00803060f, 0.01867264f, -0.02909389f, -0.00450447f, -0.00535769f, 
    -0.00082287f, -0.02239008f, -0.02661428f, -0.00632752f, 0.02323625f, -0.01305857f, 0.02199480f, -0.00962509f, 
    -0.02039495f, -0.00274005f, -0.00729172f, 0.01239371f, -0.03677646f, -0.00171473f, 0.00500868f, -0.02053348f, 
    -0.00870834f, -0.03275660f, 0.00124449f, 0.01167879f, 0.00091589f, 0.02092047f, 0.01650365f, -0.00858777f, 
    -0.02557249f, 0.01647217f, 0.01636543f, -0.02192845f, -0.04195109f, 0.02245985f, -0.00232850f, -0.02997739f, 
    -0.03310801f, 0.00610723f, -0.03392163f, -0.00495000f, -0.01712113f, 0.01320982f, -0.00683038f, 0.02441701f, 
    -0.04241746f, 0.02029251f, 0.00747890f, 0.02431522f, 0.02380058f, -0.03079799f, 0.00247598f, -0.00347911f, 
    0.02409139f, -0.00289142f, 0.02479331f, -0.03294681f, -0.03895830f, -0.01010644f, 0.01179869f, -0.01501508f, 
    -0.00969257f, -0.02921412f, 0.00297973f, 0.01480064f, -0.01563962f, 0.02656849f, -0.03932475f, -0.03938722f, 
    -0.03362196f, -0.02831543f, -0.03009003f, -0.00847612f, -0.03090829f, -0.01039060f, -0.01775327f, -0.03720345f, 
    0.00611414f, -0.02988791f, 0.01617187f, 0.00238510f, 0.01333202f, -0.04193831f, 0.02886647f, 0.01691573f, 
    -0.03960817f, 0.01291370f, 0.01488884f, -0.01651365f, -0.00747622f, -0.02108579f, 0.02677306f, -0.00773608f, 
    -0.03303728f, -0.01294653f, -0.04374671f, -0.02142318f, -0.00617191f, -0.02074609f, -0.02766009f, 0.01545191f, 
    0.00643097f, 0.01807098f, -0.02344457f, 0.01465784f, -0.00047431f, -0.01604410f, 0.00070019f, 0.02297987f, 
    -0.01290334f, -0.01763730f, 0.00436858f, 0.02377357f, -0.03908442f, 0.02495569f, -0.01769069f, -0.00186243f, 
    0.01031397f, 0.01856554f, -0.03772067f, -0.03012647f, 0.00634850f, 0.02484838f, 0.01957345f, -0.03840685f, 
    0.00322935f, 0.02515718f, -0.02231788f, -0.01596885f, 0.02032649f, -0.03592882f, -0.01371394f, -0.02834164f, 
    -0.04099551f, 0.01382488f, 0.00419796f, -0.02275229f, 0.00532502f, -0.04102916f, 0.00975101f, -0.00715442f, 
    -0.04038017f, -0.03587704f, -0.03159239f, 0.00446705f, -0.01197824f, -0.04270975f, -0.03100892f, 0.01837462f, 
    -0.00632425f, -0.01823857f, -0.00807980f, -0.02593120f, 0.02279730f, -0.02451513f, -0.01455552f, -0.03051947f, 
    0.01941170f, -0.00148730f, 0.00125286f, 0.01230047f, -0.01114896f, -0.01611638f, 0.00172181f, 0.02152891f, 
    -0.02055619f, 0.00812404f, -0.03023157f, -0.02432900f, -0.01379097f, -0.04018657f, 0.02329599f, 0.01139858f, 
    -0.03707589f, 0.02257835f, 0.01534001f, 0.02842264f, -0.00417817f, 0.00912237f, -0.03629955f, 0.03537044f, 
    -0.04486029f, 0.02420479f, -0.02988723f, -0.03519521f, -0.03109314f, 0.00654969f, 0.01662278f, -0.02989590f, 
    -0.01287990f, 0.01609794f, -0.00598058f, -0.03714309f, -0.03725325f, 0.01946743f, -0.00360943f, -0.02512511f, 
    -0.03887730f, 0.01597046f, -0.01929261f, 0.01061635f, 0.02277890f, -0.01143005f, -0.00068813f, 0.00351683f, 
    -0.03021551f, -0.00378091f, 0.02702007f, 0.02531371f, 0.01219149f, 0.01658598f, -0.04491842f, -0.03959903f, 
    -0.02414883f, -0.01833867f, -0.00977335f, 0.00378409f, -0.04187081f, 0.00661608f, -0.03459806f, -0.03489398f, 
    0.01562229f, 0.02420630f, -0.02653132f, 0.00954941f, -0.01812207f, 0.00458927f, -0.04355267f, -0.00973163f, 
    0.00922980f, 0.02431425f, -0.03665765f, 0.00492363f, 0.01493169f, -0.00733145f, -0.01066461f, -0.04457105f, 
    -0.01651179f, -0.02345866f, -0.01951392f, -0.01551900f, -0.02478400f, -0.00152622f, 0.00934719f, -0.02821423f, 
    0.01303457f, 0.02583232f, -0.03887277f, -0.03820139f, 0.01006148f, -0.01238159f, 0.00048119f, 0.00117276f, 
    -0.03003124f, 0.02484589f, 0.00762174f, 0.01609261f, -0.04187714f, 0.00711378f, -0.02712930f, -0.02314034f, 
    -0.01493052f, -0.02877844f, 0.00337866f, -0.04014701f, 0.02117592f, -0.00569083f, -0.03047882f, -0.01596693f, 
    0.01438099f, -0.03106181f, -0.02388468f, 0.01070622f, 0.02382376f, -0.02467549f, -0.00082660f, -0.02310686f, 
    -0.00567177f, 0.01262006f, 0.01150610f, -0.00089885f, -0.01870086f, 0.02567710f, 0.00013658f, -0.00570932f, 
    0.00811787f, -0.02198555f, -0.01452323f, 0.01334759f, -0.03347073f, -0.00862616f, -0.02486677f, -0.00224692f, 
    -0.01782483f, 0.01424712f, 0.00749224f, -0.01171739f, 0.01240612f, 0.00543766f, -0.01288752f, -0.00856304f, 
    0.02623225f, -0.02280554f, 0.02577123f, 0.00133995f, 0.00508309f, -0.02940066f, -0.02788274f, -0.03115007f, 
    -0.03876915f, -0.04352671f, -0.00044784f, -0.01414138f, -0.01114876f, -0.01663303f, -0.04170482f, 0.00814276f, 
    -0.03730021f, -0.03949901f, -0.01462191f, -0.03228030f, 0.01710280f, -0.03714220f, -0.04283728f, -0.03377088f, 
    0.01158031f, -0.01748487f, 0.00476574f, 0.01889255f, 0.02085468f, -0.02506402f, 0.01609370f, -0.02230637f, 
    0.00972367f, -0.03717101f, -0.01323447f, 0.01981532f, -0.01015993f, -0.02877485f, -0.00486133f, -0.03408851f, 
    0.01302261f, 0.01910604f, -0.04207112f, -0.01886808f, 0.01855289f, 0.02516305f, 0.00495852f, -0.02859031f, 
    0.02095883f, -0.02564161f, -0.02364990f, 0.00092231f, -0.02037954f, -0.03403944f, -0.00245930f, -0.02620703f, 
    0.00541435f, -0.01607090f, -0.03556968f, -0.02915632f, 0.01285509f, -0.04240714f, 0.01414662f, -0.04215050f, 
    -0.01855147f, 0.02046173f, 0.00747126f, -0.02658607f, 0.01701620f, -0.02631034f, -0.03837258f, 0.01343957f, 
    0.01660633f, -0.02927844f, -0.04300500f, 0.00235176f, 0.01564915f, 0.00144442f, -0.00164282f, -0.04416823f, 
    0.01346986f, -0.00533354f, -0.02862436f, -0.03499701f, -0.02567697f, 0.02082237f, 0.02053023f, 0.02839462f, 
    -0.04179024f, -0.02595547f, -0.04431928f, -0.03984543f, 0.01156105f, -0.04322388f, -0.01330503f, 0.00185612f, 
    -0.03339536f, -0.01801682f, -0.04294841f, -0.00541548f, -0.01339033f, -0.03586837f, 0.01141498f, -0.04225420f, 
    0.00703774f, 0.02127611f, -0.01263921f, 0.01420842f, 0.00683504f, -0.04083544f, -0.01450680f, -0.01534825f, 
    0.00003855f, -0.02414555f, 0.00666330f, -0.01135790f, 0.01520125f, 0.01395818f, -0.02753332f, -0.00884777f, 
    0.01182556f, -0.01749936f, -0.02525508f, 0.01772599f, -0.03093832f, -0.01964779f, -0.00060811f, 0.00998267f, 
    0.00130210f, 0.00192952f, -0.03402337f, 0.01597540f, 0.01733846f, -0.02971114f, -0.01876354f, 0.01023390f, 
    -0.03279652f, -0.01265341f, -0.01621375f, -0.03642494f, -0.00080719f, -0.01744909f, 0.02682171f, 0.01108919f, 
    0.01859256f, 0.02313488f, -0.00543168f, -0.04455530f, -0.01371553f, 0.02233573f, -0.00378939f, 0.00393666f, 
    0.01347331f, -0.02741322f, 0.02224450f, 0.00665666f, -0.00307074f, 0.02131126f, 0.01345248f, 0.00364587f, 
    -0.00390898f, 0.01927672f, -0.00939528f, -0.02522784f, 0.02164845f, -0.04260850f, -0.03209468f, -0.03999886f, 
    -0.01444690f, -0.01586256f, -0.00410874f, -0.00275123f, 0.00237301f, 0.00146290f, 0.01516613f, -0.01141789f, 
    -0.00040855f, 0.02309059f, -0.03138687f, -0.03391628f, 0.00852968f, -0.01497488f, -0.02668713f, -0.02490844f, 
    -0.01390697f, -0.00719660f, -0.03942559f, -0.03028605f, 0.01804688f, -0.03275551f, 0.00977101f, 0.00297114f, 
    -0.03060075f, -0.04477711f, 0.01490736f, 0.03010633f, -0.02570634f, -0.03293437f, 0.01220554f, -0.01609048f, 
    -0.02039488f, -0.00082919f, 0.00425847f, 0.01914359f, -0.02725604f, -0.02122996f, -0.01850509f, 0.02472667f, 
    -0.00323598f, -0.00414364f, 0.01450868f, -0.01197453f, -0.02691376f, -0.00270992f, 0.01147047f, -0.01150101f, 
    0.02383272f, 0.02323815f, -0.03894687f, -0.01944680f, 0.02070284f, -0.00026244f, -0.04453032f, 0.02357305f, 
    -0.02900528f, 0.00978777f, -0.02329772f, -0.01803609f, -0.01133701f, -0.01578544f, -0.00903975f, -0.01009331f, 
    0.00857054f, -0.00602842f, 0.02024507f, -0.03884097f, 0.00325889f, 0.01780186f, 0.01779375f, -0.03393638f, 
    -0.02540898f, -0.01983446f, 0.01139094f, 0.00100486f, 0.00742510f, 0.00299794f, -0.03750690f, 0.00169554f, 
    -0.02682735f, -0.03929517f, 0.01851134f, -0.04376419f, 0.00921829f, -0.01782564f, 0.01259852f, -0.03928998f, 
    -0.00025535f, -0.03226579f, -0.00705528f, -0.01198921f, -0.01891014f, -0.00114525f, 0.00637211f, -0.01674015f, 
    0.01580364f, -0.04436366f, 0.01136568f, -0.01749099f, -0.00658898f, -0.01991904f, -0.00010496f, 0.00879683f, 
    0.01125179f, -0.01947786f, -0.01550698f, 0.02010047f, -0.03901942f, 0.02510176f, -0.00568813f, 0.00645772f, 
    -0.01978897f, -0.02933847f, -0.01273999f, 0.00315067f, -0.02493777f, -0.02990516f, 0.01865746f, -0.02416635f, 
    0.02721682f, -0.02113041f, 0.02478706f, -0.03684502f, -0.00814958f, -0.03964491f, -0.03010913f, -0.03508300f, 
    0.02448020f, -0.00478893f, -0.00699469f, -0.00416646f, 0.01059381f, -0.02659848f, -0.02275332f, -0.04277720f, 
    -0.00070286f, 0.02160357f, 0.00198229f, -0.02536350f, -0.02372485f, -0.02183053f, -0.01908808f, -0.03354114f, 
    -0.01039014f, -0.03762746f, 0.01735428f, -0.03331079f, 0.02143358f, 0.00647164f, -0.03239462f, -0.01617931f, 
    0.02519609f, -0.01841171f, -0.02099108f, 0.00729581f, -0.00163348f, 0.01058891f, -0.04201403f, -0.01874545f, 
    -0.03597919f, 0.01902807f, 0.01910552f, -0.00420848f, -0.03582624f, 0.00445935f, -0.02177362f, -0.02517902f, 
    0.00452999f, -0.01218454f, 0.01484073f, 0.02693010f, -0.02464992f, 0.00619540f, -0.00931395f, -0.04192139f, 
    0.02382352f, 0.01063732f, 0.00963797f, 0.01087462f, -0.04205308f, 0.00213508f, 0.01646307f, 0.01311223f, 
    -0.01001905f, 0.00319720f, 0.02152468f, 0.01691997f, 0.02210672f, 0.00548630f, 0.02663614f, 0.00528918f, 
    0.00678027f, -0.01249156f, 0.01122214f, 0.00133602f, -0.01068006f, 0.00844513f, 0.00333421f, -0.03062452f, 
    0.01391250f, -0.02724800f, -0.01481367f, -0.00801268f, 0.01755855f, 0.01294931f, -0.04046173f, 0.00694278f, 
    -0.03522190f, 0.01318015f, 0.01444284f, -0.04016570f, -0.02835608f, 0.01175844f, -0.03465078f, -0.01071655f, 
    -0.01122713f, 0.01630222f, 0.01344976f, 0.00236993f, -0.03001554f, 0.00462567f, -0.03626056f, -0.03695139f, 
    -0.02199176f, 0.00455560f, -0.03556686f, 0.00892966f, -0.03921662f, 0.01360773f, -0.03694789f, -0.01815481f, 
    -0.01227010f, 0.00153478f, -0.02636501f, -0.02584879f, -0.00390081f, -0.01643299f, 0.01813327f, 0.01677906f, 
    0.00618873f, -0.03411853f, 0.02474688f, -0.02376464f, -0.00716043f, 0.01092068f, 0.00848933f, 0.00506797f, 
    -0.02101215f, -0.04433013f, 0.01656212f, 0.00113172f, 0.02639108f, 0.02644507f, 0.00727321f, 0.02211280f, 
    0.00665437f, 0.00454864f, -0.01031853f, 0.01318881f, 0.03226533f, -0.03306081f, -0.02955405f, 0.01216076f, 
    -0.02046327f, 0.00297680f, -0.00264542f, -0.03478702f, 0.01205678f, -0.03814131f, 0.02062760f, 0.00470192f, 
    -0.02007605f, 0.01418347f, 0.02872240f, 0.03019699f, 0.00603781f, -0.02818397f, -0.03146442f, -0.04013412f, 
    -0.01548675f, -0.00419251f, -0.03991842f, -0.00942965f, -0.02952881f, -0.00520011f, -0.03156209f, -0.03713668f, 
    0.02760506f, 0.00113393f, -0.02318148f, -0.00241209f, -0.01853781f, 0.02286330f, -0.03778648f, 0.02827409f, 
    0.01473515f, 0.01077196f, -0.01368126f, 0.03004513f, -0.00004810f, 0.02042324f, -0.02200169f, -0.02007200f, 
    0.02779056f, -0.00381543f, 0.00206194f, 0.01816259f, 0.02348627f, 0.01548027f, -0.01293282f, -0.03643589f, 
    0.00454181f, 0.00036274f, 0.02510045f, -0.04267706f, -0.00732182f, -0.01827035f, 0.01066323f, 0.01816979f, 
    -0.00523269f, 0.01047265f, -0.00647826f, 0.02163483f, 0.01215893f, -0.03584246f, -0.03812506f, 0.01170649f, 
    -0.00386069f, 0.00917293f, 0.02201594f, -0.02966335f, -0.03129993f, -0.00597521f, -0.03420809f, 0.00741407f, 
    0.03250878f, -0.01059692f, -0.02349008f, 0.02288461f, 0.02109090f, 0.01728801f, -0.03383334f, -0.01448471f, 
    0.01480808f, -0.03650782f, -0.01681873f, 0.00233127f, -0.02059289f, -0.03312581f, -0.01387314f, 0.02907299f, 
    0.00278468f, 0.02097293f, 0.01785290f, 0.02045272f, 0.00304231f, 0.01772976f, 0.02158510f, 0.00625451f, 
    0.01525490f, 0.02306995f, 0.01293817f, 0.02297374f, -0.04496228f, 0.02901089f, -0.00397118f, -0.01751937f, 
    -0.03220891f, -0.02815293f, -0.03473375f, -0.02835164f, -0.02108654f, 0.02222042f, -0.00219349f, -0.01205634f, 
    -0.00764629f, -0.03652338f, 0.01185739f, -0.00234011f, 0.01571921f, -0.02242339f, 0.02504822f, 0.02419046f, 
    -0.02605345f, 0.02613324f, -0.02598820f, 0.00073037f, -0.00742228f, 0.01165333f, -0.00032772f, 0.01318378f, 
    -0.02664329f, 0.02291875f, -0.02468804f, 0.01526034f, -0.00742538f, -0.00004540f, 0.01769913f, 0.00408862f, 
    -0.02765788f, 0.02160547f, 0.02456885f, -0.03388099f, 0.01602069f, -0.00434210f, -0.00313481f, 0.03357639f, 
    0.00091005f, -0.00838042f, -0.01509609f, 0.01102345f, 0.02439310f, -0.01843999f, 0.02500433f, 0.03305995f, 
    0.03054410f, 0.01701035f, 0.02183496f, 0.03272107f, 0.01805043f, 0.00421128f, 0.00415492f, 0.01991989f, 
    -0.03798114f, 0.02121868f, 0.02701233f, 0.00220142f, 0.00770508f, -0.02612374f, -0.00965436f, -0.03520313f, 
    0.00596231f, -0.04311294f, 0.00609718f, -0.02572615f, 0.01274511f, 0.02999880f, -0.00432834f, 0.00299054f, 
    -0.04054070f, 0.00388977f, -0.03123981f, -0.04219913f, -0.01124284f, 0.01518441f, -0.00439083f, 0.01519767f, 
    -0.01744946f, -0.01511903f, -0.00255621f, -0.01419074f, 0.01918464f, -0.01620827f, 0.02504622f, -0.00216378f, 
    0.02487534f, 0.02624422f, -0.01534542f, 0.00792632f, -0.00903513f, -0.02283832f, 0.02002385f, -0.00407999f, 
    -0.00779196f, -0.01214311f, -0.01091908f, 0.01079938f, 0.01586333f, 0.00493367f, 0.01236148f, -0.00153085f, 
    -0.02981222f, 0.02645748f, 0.00460088f, -0.01965540f, 0.02134505f, -0.01762861f, 0.02321107f, -0.02545870f, 
    0.01351819f, -0.02208141f, -0.01297549f, 0.02333634f, 0.00399000f, 0.03518253f, -0.02054522f, -0.00667947f, 
    -0.00629792f, -0.01738150f, -0.01114255f, -0.02812638f, 0.01986858f, -0.03424137f, 0.01273718f, 0.02069160f, 
    -0.00928045f, -0.00507743f, 0.01880420f, -0.02794767f, 0.02840631f, -0.04122841f, 0.01175178f, 0.01220451f, 
    -0.01247210f, -0.01385572f, -0.01467998f, 0.01372956f, 0.01825027f, -0.04237850f, -0.00747206f, 0.00229464f, 
    0.02169676f, 0.02045970f, -0.00343580f, 0.00796891f, 0.01652773f, 0.00264720f, 0.00972745f, -0.00765219f, 
    0.02011169f, 0.01461955f, 0.03205362f, -0.03113641f, -0.02262197f, -0.00442081f, -0.04514375f, -0.00048391f, 
    0.01363882f, 0.01257280f, -0.01720174f, -0.00859093f, -0.01380177f, 0.00608149f, 0.00977632f, -0.03270592f, 
    0.01902874f, 0.01182919f, -0.03369323f, 0.01609492f, 0.02040490f, -0.03329591f, 0.03248885f, 0.00335541f, 
    0.00256017f, -0.02212710f, -0.01018211f, -0.02226226f, -0.02178222f, -0.02069825f, -0.01207102f, -0.01732449f, 
    0.00961543f, -0.02114195f, -0.01656622f, 0.01218665f, -0.00621909f, -0.02663426f, -0.04194422f, 0.02743962f, 
    -0.03521447f, -0.01463524f, -0.02702974f, -0.04469028f, -0.01788952f, -0.03298632f, -0.02747213f, -0.02442163f, 
    -0.00325860f, 0.00720672f, -0.02316208f, 0.00716842f, -0.01532078f, -0.01621740f, -0.01119082f, 0.01182779f, 
    0.01858678f, -0.01380179f, 0.02684166f, 0.02839111f, -0.00550850f, -0.00712585f, 0.01707256f, 0.02813037f, 
    -0.03529797f, -0.00419987f, 0.02610723f, -0.00169904f, 0.02229184f, -0.04305344f, 0.03470962f, -0.03474516f, 
    0.02007560f, -0.00166787f, 0.03273291f, 0.03267123f, 0.02935493f, 0.01779825f, 0.00265664f, 0.02943485f, 
    -0.04474547f, 0.00907092f, -0.00052481f, -0.01361062f, -0.01655840f, -0.01924114f, 0.01390198f, -0.02743984f, 
    -0.04331410f, 0.02683433f, -0.02868502f, 0.00982757f, -0.01426195f, -0.01917803f, -0.01527135f, -0.03318537f, 
    -0.04246408f, -0.03005849f, -0.01802486f, -0.00336766f, 0.02553263f, 0.04331698f, 0.00502529f, -0.02984168f, 
    -0.01695587f, 0.00928561f, -0.03572347f, -0.01516184f, -0.03278327f, 0.00764225f, 0.01159557f, -0.02984129f, 
    -0.00321688f, 0.01955152f, -0.03189303f, 0.02394475f, 0.00683041f, 0.01449760f, 0.01979547f, -0.01759863f, 
    -0.04026933f, -0.02500560f, -0.02892276f, -0.04011499f, -0.03934224f, 0.00788855f, -0.03480886f, 0.00438789f, 
    0.00506948f, -0.02659139f, -0.01630913f, -0.00844109f, -0.01052797f, -0.01928089f, -0.01522351f, 0.02843828f, 
    0.02619133f, 0.01970343f, -0.00645239f, -0.01563170f, -0.01221527f, 0.00130060f, -0.00655184f, -0.02964669f, 
    0.00831072f, 0.02965156f, -0.00689607f, -0.00037744f, -0.00282590f, 0.00163901f, -0.02582368f, 0.00490244f, 
    0.00309964f, -0.01937033f, 0.02046615f, -0.00660909f, 0.00002430f, -0.00944997f, 0.00353101f, 0.00897773f, 
    -0.04074853f, 0.00673256f, 0.00942632f, -0.01874840f, 0.01318883f, 0.01177903f, -0.00863297f, 0.02677874f, 
    0.02979555f, -0.01022729f, 0.01247815f, -0.02229292f, 0.02624364f, 0.01192246f, 0.00042782f, -0.01862741f, 
    0.02142005f, 0.01374870f, 0.01693642f, 0.00479507f, 0.01804699f, 0.00740993f, -0.00137084f, -0.02674855f, 
    0.00663569f, -0.03053322f, 0.00378373f, -0.03029320f, 0.00809790f, -0.01554892f, -0.03538009f, 0.00076195f, 
    -0.01892965f, -0.00536849f, -0.02316927f, 0.00857126f, -0.03331070f, 0.01501853f, -0.01104555f, -0.01105835f, 
    -0.00205550f, 0.00801075f, -0.00817259f, -0.02952807f, 0.01687655f, -0.03283249f, -0.00255734f, -0.01876151f, 
    -0.02412713f, -0.00601194f, 0.00814624f, -0.02628108f, -0.02707596f, 0.01722244f, -0.00763222f, 0.02662091f, 
    0.00479536f, 0.00825647f, 0.02590468f, 0.00265687f, -0.04060942f, 0.00861479f, -0.00107814f, 0.02720767f, 
    -0.02078509f, -0.02006268f, -0.02552187f, -0.00411334f, -0.02509573f, -0.03691122f, -0.03359868f, 0.01070232f, 
    0.02954180f, -0.00095228f, -0.01827370f, -0.02117667f, -0.00045339f, 0.02511198f, -0.02673696f, 0.00119475f, 
    0.01746251f, 0.00932839f, -0.01584809f, 0.03111102f, 0.02262221f, 0.02957909f, 0.02356100f, -0.00371660f, 
    -0.00048953f, 0.01562276f, -0.03980346f, -0.02333788f, -0.01592738f, 0.02388791f, -0.01350635f, -0.03683652f, 
    -0.03396280f, -0.00599227f, -0.02914734f, 0.03647084f, 0.03033390f, -0.00007515f, -0.01343448f, -0.01567237f, 
    -0.00778269f, 0.00114750f, -0.02168178f, -0.01352909f, -0.01850279f, 0.01707867f, 0.00799216f, 0.03276124f, 
    -0.00942197f, -0.00916432f, -0.02528475f, -0.00798498f, 0.02500541f, -0.00891233f, -0.02029302f, -0.00984504f, 
    -0.00696608f, 0.00078217f, -0.04353540f, 0.02393849f, -0.02856700f, -0.03797713f, -0.00535684f, -0.04267293f, 
    0.01585058f, -0.02970494f, -0.02042119f, 0.02184817f, -0.02675854f, -0.03822681f, 0.02497767f, 0.02979414f, 
    -0.03828489f, -0.00708321f, 0.01725720f, -0.03133250f, 0.01840574f, 0.02568966f, 0.03429337f, 0.02914380f, 
    0.00612341f, -0.04496280f, 0.01209103f, -0.02505905f, 0.00115364f, -0.02374993f, 0.01243298f, -0.02576529f, 
    0.01941691f, 0.02001134f, -0.01370352f, -0.00056458f, 0.00635870f, -0.02353372f, -0.02118219f, 0.02019792f, 
    -0.00493483f, 0.02242030f, -0.01576894f, -0.03168872f, 0.00910382f, 0.02980137f, -0.02536797f, -0.02220468f, 
    -0.02950365f, -0.02325083f, -0.03027417f, -0.01455086f, -0.00716116f, -0.02857672f, 0.00995403f, -0.03087112f, 
    0.00284870f, 0.00274116f, -0.00095953f, -0.02033484f, 0.03639989f, -0.02393443f, 0.01304784f, -0.03269200f, 
    0.00460779f, 0.01891370f, -0.02749984f, -0.01270440f, 0.01705525f, 0.02620452f, -0.02487233f, 0.00105318f, 
    -0.02011096f, 0.00413357f, 0.00809313f, -0.00540496f, 0.01619943f, -0.03263862f, 0.02553458f, 0.02939308f, 
    -0.03854560f, -0.01810625f, 0.02797411f, -0.01922301f, -0.00109271f, -0.01054983f, -0.04169343f, 0.02871130f, 
    -0.01731458f, 0.02167548f, 0.02474229f, -0.04223113f, -0.00897100f, -0.01976309f, -0.04129517f, 0.01699167f, 
    -0.02915295f, 0.00292331f, -0.00929287f, -0.02632337f, 0.03167120f, -0.03403313f, -0.03144785f, 0.02283213f, 
    0.02607553f, -0.00894691f, 0.01364051f, -0.03597293f, -0.00869339f, 0.02687808f, -0.02994257f, 0.00029364f, 
    0.01901367f, -0.03578684f, -0.00995318f, -0.01840592f, 0.03362391f, 0.01358291f, -0.00562049f, -0.00468400f, 
    0.03742310f, -0.03258073f, 0.01650984f, 0.01862571f, -0.03218626f, 0.01485310f, 0.02375126f, -0.00564805f, 
    0.00899408f, -0.00314539f, -0.00696474f, -0.03340780f, 0.03127155f, -0.00790082f, -0.04672999f, -0.00142888f, 
    0.00330317f, -0.01425700f, -0.00761575f, -0.00876607f, 0.02721492f, -0.01911837f, 0.03167960f, -0.00469659f, 
    -0.00576872f, -0.00063058f, -0.02547841f, 0.02527581f, -0.03717123f, 0.00625997f, -0.01513587f, -0.01089754f, 
    -0.00402319f, -0.03818701f, -0.00496225f, 0.02155655f, -0.00372954f, -0.03050279f, 0.00750216f, -0.02432497f, 
    0.02180341f, 0.01097376f, 0.00640426f, -0.01520184f, 0.01017202f, -0.02371160f, -0.03301984f, -0.00833979f, 
    0.00131743f, 0.00600562f, 0.00049006f, -0.02488488f, 0.01285093f, 0.01031322f, -0.03239963f, -0.02961054f, 
    -0.03061431f, -0.01636632f, 0.01829964f, -0.01628467f, 0.01481359f, 0.02272470f, -0.00592742f, -0.01036305f, 
    0.01810772f, 0.01788443f, 0.00165495f, -0.00223365f, -0.03001956f, -0.00584202f, 0.00808918f, -0.00695389f, 
    -0.02384396f, 0.01221790f, -0.03338132f, 0.01670350f, 0.00134537f, 0.02182826f, 0.02533904f, 0.00212409f, 
    -0.02975527f, 0.00734864f, -0.00244891f, -0.02218767f, -0.01415857f, -0.02223684f, 0.01855211f, -0.01892286f, 
    -0.02220388f, 0.01363181f, -0.02714005f, 0.01819625f, 0.01865047f, -0.00384209f, 0.02409033f, -0.00473916f, 
    0.01831089f, 0.01196282f, 0.01761695f, 0.01693906f, 0.00633094f, -0.02202221f, -0.01887981f, 0.04136886f, 
    0.03669246f, 0.02178964f, 0.03298579f, -0.03681375f, -0.01983213f, 0.02092331f, -0.02846701f, -0.00549249f, 
    -0.01799760f, 0.03317297f, 0.00699524f, -0.01516109f, 0.01004880f, -0.00018191f, -0.00596069f, -0.03522515f, 
    0.00138977f, 0.01032249f, 0.00337861f, 0.00630358f, -0.03700729f, -0.01694353f, 0.00665079f, 0.02562514f, 
    0.03696720f, 0.01893389f, -0.01793842f, 0.01936742f, 0.02678914f, 0.01788374f, -0.01930701f, 0.01324919f, 
    -0.00492691f, 0.02151577f, 0.02690511f, 0.02192841f, -0.00991728f, -0.02995695f, 0.00525393f, 0.02984929f, 
    0.00313875f, 0.00711723f, -0.01314744f, -0.02484372f, 0.02946539f, -0.02392815f, -0.04052977f, 0.01141909f, 
    0.00613036f, 0.03586853f, -0.01343457f, -0.02462492f, 0.01307207f, -0.03869729f, -0.04061330f, -0.00711047f, 
    -0.00813496f, -0.03505274f, 0.02537713f, -0.00287925f, 0.02804603f, 0.00917353f, 0.01371988f, -0.00931181f, 
    -0.01011473f, -0.00938808f, 0.02748052f, 0.00957553f, -0.01478513f, -0.03772717f, -0.00389056f, -0.00124867f, 
    0.01182821f, -0.01122547f, -0.03979912f, 0.00252081f, 0.01008877f, 0.01919748f, 0.02474526f, 0.00356002f, 
    -0.02305776f, -0.03282335f, 0.00081747f, -0.01724012f, 0.03376526f, 0.02563402f, -0.00170915f, -0.03408654f, 
    -0.03161244f, -0.01091485f, -0.02102688f, 0.01474592f, -0.03688800f, -0.04164797f, -0.01235280f, 0.00675465f, 
    -0.02433204f, 0.02920087f, -0.01781315f, 0.02447616f, -0.01597086f, -0.02789151f, 0.01031080f, 0.02082752f, 
    0.01601138f, 0.01915923f, 0.01385719f, -0.01266504f, 0.01158323f, 0.00274852f, -0.01142315f, 0.01645875f, 
    -0.00488404f, -0.03029797f, -0.02672033f, -0.03213771f, -0.02074575f, -0.02563030f, 0.03098434f, 0.00284360f, 
    -0.00699330f, 0.02407279f, -0.03522842f, -0.04116482f, -0.03066082f, -0.00031429f, -0.04108774f, 0.02573599f, 
    0.00018442f, 0.02562905f, -0.02447976f, 0.03537266f, -0.02983174f, 0.00619543f, -0.02016639f, -0.00266779f, 
    -0.02792571f, -0.01361783f, -0.00394957f, 0.00964779f, -0.00315767f, 0.00502217f, -0.02064173f, 0.02412879f, 
    -0.01440443f, 0.01852291f, -0.01890425f, -0.00849192f, -0.01227674f, -0.03610343f, 0.00641431f, 0.00538578f, 
    0.01772668f, 0.01972521f, -0.00905610f, 0.02664960f, 0.00187598f, -0.01481567f, -0.03629631f, -0.00634073f, 
    -0.03111351f, -0.00304277f, 0.00105079f, 0.00922408f, 0.01292726f, 0.01582471f, 0.01259576f, -0.03041871f, 
    0.02956685f, 0.03974361f, -0.01185549f, -0.02653133f, 0.02141375f, 0.03439834f, 0.00305549f, -0.01137184f, 
    -0.02503866f, 0.02270680f, -0.02814816f, -0.00412985f, -0.01451834f, 0.02543115f, -0.03832078f, -0.00628178f, 
    0.02753847f, 0.01003663f, -0.02218622f, 0.02139895f, -0.02883277f, -0.00704807f, -0.01119799f, 0.01124968f, 
    -0.01495230f, -0.03625644f, 0.00841875f, -0.02711371f, -0.00297318f, 0.00945232f, 0.02975079f, 0.02422171f, 
    0.04164759f, 0.02214708f, -0.03315206f, 0.00509401f, -0.02980271f, -0.00641414f, 0.01363187f, 0.00331706f, 
    0.02615137f, -0.00819791f, 0.02559559f, 0.01086492f, -0.04228663f, 0.02597694f, 0.01049852f, 0.02141096f, 
    -0.03135813f, 0.02994422f, -0.02309123f, 0.02333396f, -0.02016917f, 0.01081036f, 0.00956299f, -0.03897471f, 
    0.03324830f, 0.00269059f, 0.04022111f, 0.00695097f, 0.02359276f, 0.00505019f, 0.02671885f, -0.01050016f, 
    -0.00155930f, 0.01361589f, -0.00563013f, -0.02408213f, 0.01756983f, -0.03647623f, 0.00288642f, -0.00018911f, 
    -0.01629324f, -0.03293357f, -0.01820575f, -0.03508306f, -0.00865687f, 0.02611220f, 0.00033501f, -0.04004688f, 
    -0.03704024f, 0.02719515f, 0.01296766f, -0.03435078f, -0.03554874f, -0.02233501f, -0.00009268f, -0.02309221f, 
    -0.00559933f, 0.01873995f, 0.00510221f, -0.01152165f, -0.00339536f, 0.00854436f, 0.00749981f, -0.02073277f, 
    -0.01087003f, 0.00731381f, 0.00209171f, 0.03649680f, 0.01016582f, 0.00454181f, 0.01405123f, -0.00226770f, 
    0.02771620f, 0.02372405f, 0.00797591f, -0.00987427f, 0.02879507f, 0.00648495f, -0.00467845f, -0.01073055f, 
    -0.02742404f, 0.01473990f, 0.02737944f, -0.02476027f, 0.01213240f, 0.00645014f, 0.01762880f, -0.03493742f, 
    -0.00387485f, -0.03794987f, -0.03952511f, 0.02108483f, 0.01643861f, -0.00171293f, -0.02139629f, -0.01410023f, 
    -0.04056211f, 0.00357621f, 0.00164373f, -0.01579811f, -0.03518487f, -0.02474391f, 0.01708497f, 0.02000568f, 
    0.02524136f, 0.02223457f, 0.02118704f, -0.00077661f, -0.04195104f, -0.00216866f, -0.02139729f, 0.00799981f, 
    0.00837550f, 0.01142989f, 0.00063675f, 0.02206348f, -0.01183518f, 0.02298914f, -0.02359262f, -0.01204361f, 
    -0.01507229f, 0.00290628f, 0.01480496f, 0.00820068f, -0.03063073f, -0.04224238f, -0.01183606f, 0.01683130f, 
    0.00653433f, -0.01721057f, 0.02126432f, -0.00134651f, -0.01052887f, -0.00714856f, -0.00583144f, -0.03899952f, 
    -0.00302379f, -0.01602750f, -0.02987203f, 0.04247089f, -0.00556445f, 0.01230692f, -0.00047913f, 0.00019818f, 
    -0.01387595f, 0.01936234f, 0.02224257f, 0.02777038f, -0.03565393f, 0.00555174f, 0.02828123f, -0.02032831f, 
    -0.02095797f, -0.00799022f, 0.03850790f, 0.02152771f, -0.03596101f, -0.03080658f, 0.01184662f, 0.04205810f, 
    -0.01322801f, -0.01418058f, 0.01067403f, 0.01056591f, -0.02236270f, -0.01712031f, -0.03847510f, -0.03392891f, 
    0.03345722f, 0.01325399f, 0.00971825f, -0.00647863f, -0.01403150f, -0.02695981f, -0.02300170f, -0.00534767f, 
    0.03242014f, 0.01888503f, -0.01761574f, -0.00116185f, 0.01558863f, -0.02517398f, -0.02942314f, -0.00588040f, 
    0.02687805f, 0.00142738f, -0.01414777f, 0.00092769f, -0.02185129f, -0.02098601f, 0.02539399f, 0.00007973f, 
    0.02234950f, 0.01324548f, -0.01601884f, -0.00741888f, 0.01430720f, 0.03439610f, -0.00900052f, -0.00027733f, 
    -0.02392867f, -0.04279251f, 0.01893439f, -0.01556410f, 0.00024502f, -0.03422786f, -0.01329003f, -0.02395532f, 
    0.00083390f, 0.02579414f, 0.00490096f, -0.00185946f, 0.00729094f, 0.00498929f, -0.02718179f, -0.00553453f, 
    0.01038275f, -0.02882479f, -0.02232086f, 0.00455081f, -0.00495461f, -0.02255297f, -0.00437543f, 0.00555264f, 
    -0.02999340f, 0.00577208f, -0.02185824f, -0.03954146f, -0.01875255f, -0.03711617f, -0.01169829f, -0.02340536f, 
    0.02154936f, 0.02105515f, -0.02678036f, -0.01533846f, -0.01111205f, 0.01942524f, 0.01780393f, -0.00553399f, 
    0.01022817f, -0.00944211f, 0.02151243f, 0.01033789f, -0.03934431f, -0.00965008f, 0.02785091f, -0.02192210f, 
    -0.01565470f, -0.03025003f, 0.01670498f, -0.03041653f, -0.02055145f, 0.01154835f, -0.03597837f, -0.03087769f, 
    0.00831438f, 0.00180234f, -0.03854395f, -0.02184455f, -0.03571115f, 0.02462436f, -0.01645148f, -0.02063874f, 
    -0.00717060f, 0.01749183f, 0.02050449f, 0.01838678f, -0.02010314f, -0.01924370f, -0.00914098f, 0.02796951f, 
    -0.02820478f, 0.02190373f, 0.00429120f, -0.03013251f, -0.01592848f, 0.01772301f, 0.02353922f, -0.01963721f, 
    0.01504591f, 0.02362480f, -0.04005657f, -0.02181577f, -0.03585573f, -0.02439627f, -0.02662756f, 0.00305155f, 
    0.01859716f, 0.02534987f, -0.03316690f, -0.02673278f, -0.00210072f, -0.00083197f, -0.02917199f, -0.02723398f, 
    -0.01583816f, 0.01009000f, 0.03402073f, -0.02706468f, -0.00816648f, 0.01207899f, 0.02793480f, 0.02715757f, 
    0.02844749f, -0.01776059f, 0.00797130f, -0.00601067f, -0.01418763f, 0.03228167f, 0.02494451f, -0.02132968f, 
    0.00733127f, -0.03358229f, 0.01077789f, 0.01030854f, 0.02744687f, -0.00839129f, 0.02854673f, -0.00526476f, 
    -0.02069881f, -0.03229438f, 0.01047965f, -0.04200230f, 0.01684479f, 0.01693616f, 0.01900872f, -0.00874913f, 
    -0.02949488f, -0.01158700f, -0.02512883f, -0.01885177f, 0.02531516f, 0.03288804f, 0.02845487f, -0.02034744f, 
    0.00125803f, 0.01942555f, 0.02003668f, 0.02850733f, -0.02172831f, -0.00854645f, 0.00337168f, -0.01629064f, 
    0.02797181f, 0.02015328f, 0.00985200f, -0.03251540f, 0.00717372f, -0.03796390f, -0.01350899f, 0.01293097f, 
    -0.03276209f, -0.00736831f, 0.02154827f, 0.00321060f, 0.02346966f, -0.02168134f, 0.00948658f, 0.00214157f, 
    -0.03420461f, 0.03031312f, -0.03519113f, -0.00184310f, 0.04207041f, 0.00892513f, 0.03766830f, -0.02830765f, 
    0.02698205f, -0.01903182f, 0.00518377f, 0.01466761f, -0.03606381f, 0.00409030f, 0.04119315f, -0.02667953f, 
    0.02197696f, -0.00072787f, -0.02703691f, -0.03216106f, -0.00313270f, -0.03440871f, -0.00737532f, 0.00253735f, 
    0.03312111f, 0.02608307f, -0.02853611f, 0.00362410f, -0.03325016f, 0.02756133f, -0.01773355f, 0.00795152f, 
    -0.01734766f, -0.02852797f, -0.00092107f, -0.00750743f, -0.02957336f, -0.01951668f, 0.03602252f, -0.01916192f, 
    -0.03945831f, -0.00326355f, -0.00930489f, 0.00371499f, 0.00489258f, -0.03275713f, 0.00149647f, -0.03460239f, 
    -0.01760158f, 0.02927779f, 0.03020054f, -0.01677603f, 0.01669986f, -0.01655715f, -0.03515019f, 0.00433122f, 
    -0.01608366f, 0.00224808f, -0.01000134f, 0.00210329f, -0.02276857f, -0.02374860f, 0.00568416f, 0.03002789f, 
    -0.00622439f, 0.01708459f, -0.00835195f, -0.01453634f, -0.03934008f, -0.01687573f, -0.03726471f, -0.03227339f, 
    -0.02761507f, -0.03686779f, 0.01288658f, 0.03860602f, -0.02476481f, 0.03463824f, 0.00423415f, -0.02493697f, 
    0.01131011f, -0.00667195f, 0.02221012f, 0.02371034f, 0.02788496f, -0.00555707f, 0.00935479f, -0.03902768f, 
    0.02447268f, 0.01757761f, 0.03398467f, 0.02785098f, 0.01317271f, -0.01020056f, -0.00741981f, -0.02809537f, 
    -0.03928954f, 0.03597607f, -0.00874014f, -0.01509943f, 0.00111544f, 0.00156083f, -0.03009226f, 0.01559237f, 
    -0.01226510f, -0.03180372f, -0.02725207f, 0.04336727f, 0.00595929f, 0.03900468f, -0.00897412f, 0.01343937f, 
    0.01443619f, -0.02373443f, -0.00805524f, -0.01182785f, -0.01975806f, -0.00700613f, 0.03330734f, 0.00096496f, 
    -0.01819667f, -0.02609634f, -0.02111610f, -0.02025383f, 0.00962737f, -0.00125168f, -0.01993323f, -0.01747659f, 
    -0.02194041f, -0.02055477f, -0.01874992f, -0.03002189f, -0.02097379f, 0.00666860f, 0.02407651f, 0.02345805f, 
    -0.03452815f, -0.00936911f, -0.02171144f, 0.00436007f, 0.02326880f, 0.01940303f, 0.00029000f, -0.00815018f, 
    -0.02846264f, -0.00445455f, -0.03559402f, -0.01602959f, 0.00620066f, 0.02184357f, 0.01519702f, 0.01746041f, 
    -0.17969050f, -0.04471525f, -0.14378944f, -0.03016385f, 0.01966975f, 0.08083212f, 0.10980838f, 0.11755866f, 
    0.10522180f, 0.04042608f, 0.01289996f, 0.04281854f, 0.39364800f, 0.02258337f, -0.00043303f, -0.00530159f, 
    0.07997823f, 0.06428884f, 0.06743518f, 0.01258514f, -0.00115232f, 0.18758336f, 0.08080244f, 0.08071356f, 
    0.23751214f, 0.07351004f, -0.01682804f, 0.12265895f, 0.05493298f, -0.06233481f, 0.03638398f, 0.09507351f, 
    0.15417035f, 0.06476086f, 0.03329297f, -0.15133056f, 0.13622232f, -0.05223249f, -0.06280725f, 0.07200684f, 
    -0.09356503f, 0.03954210f, -0.07263684f, 0.14938451f, 0.02854668f, -0.05289583f, 0.08222941f, -0.10347188f, 
    -0.26187178f, -0.05126234f, -0.11228684f, -0.19447263f, 0.04291164f, -0.02623375f, -0.00089557f, -0.00063841f, 
    -0.03802720f, -0.05507196f, -0.08201253f, -0.03693186f, -0.15610233f, -0.08740988f, 0.02812412f, -0.08698113f, 
    0.09670521f, -0.08912590f, 0.02725742f, -0.03664425f, -0.00787524f, -0.03816624f, 0.03351818f, 0.09708181f, 
    0.01073921f, -0.03602833f, 0.15707390f, 0.04312769f, 0.00530897f, 0.01622580f, 0.02681884f, 0.05599712f, 
    0.04319221f, 0.02118098f, 0.02692110f, 0.04646979f, -0.05445611f, 0.08003282f, -0.19748747f, -0.10289776f, 
    0.14424631f, -0.06968269f, 0.02316328f, 0.03697453f, 0.00227356f, -0.05741739f, 0.08668222f, 0.02236722f, 
    0.09383457f, -0.07968925f, -0.02279997f, 0.18106651f, 0.00438704f, -0.10741462f, 0.06801880f, 0.00914994f, 
    0.03164408f, 0.04921352f, 0.16302533f, -0.02071598f, -0.13182794f, -0.01966452f, 0.16059357f, -0.10662071f, 
    0.00212183f, 0.05214075f, -0.06294889f, -0.08623642f, 0.01509207f, 0.07845799f, -0.05283578f, -0.03864625f, 
    -0.10381686f, 0.11117131f, 0.08591078f, -0.06081693f, 0.05109403f, 0.00433819f, -0.06031241f, -0.06769659f, 
    -0.01502344f, -0.02840879f, 0.09040925f, -0.03703426f, -0.10548037f, -0.09449587f, 0.04627983f, -0.02656132f, 
    0.03972708f, 0.13115567f, 0.00282201f, 0.11248476f, 0.00745504f, -0.01060031f, -0.00887256f, -0.08487508f, 
    0.05852638f, 0.08538758f, -0.07076172f, 0.00549086f, 0.07494926f, 0.02213486f, 0.03176570f, 0.09033181f, 
    0.00786110f, 0.00950129f, 0.01352387f, -0.06664912f, 0.01282489f, -0.05524393f, 0.15386470f, 0.11977812f, 
    -0.02173898f, -0.02204103f, 0.18481687f, 0.19257072f, -0.02928117f, -0.05293492f, -0.00726336f, 0.04307953f, 
    0.08603627f, -0.05349425f, 0.00852603f, 0.07818969f, -0.03915318f, 0.02161363f, 0.10210183f, -0.10433043f, 
    -0.00855678f, -0.01136663f, 0.02798427f, 0.11421268f, 0.12098247f, -0.10135102f, -0.01162224f, 0.10370864f, 
    0.01742664f, 0.03899966f, -0.03165675f, -0.08495562f, -0.00961068f, 0.00797602f, -0.05306930f, 0.09984738f, 
    -0.31569958f, -0.06419995f, 0.12391508f, 0.02126636f, -0.04846560f, 0.09678007f, -0.03631327f, 0.02440341f, 
    0.01351596f, -0.06913128f, -0.00121095f, -0.00069058f, -0.15608779f, 0.07091353f, -0.12321567f, -0.13949451f, 
    -0.00999194f, 0.04332580f, 0.04783021f, -0.02779851f, -0.00202631f, 0.02927241f, 0.03814822f, 0.02780277f, 
    -0.12899612f, -0.15522990f, 0.22417809f, 0.09991917f, 0.02247432f, -0.00989743f, -0.00398770f, -0.04834954f, 
    0.04074086f, -0.05330021f, 0.06132555f, -0.07153753f, 0.14386955f, 0.08677577f, 0.16564062f, 0.03701009f, 
    -0.04536204f, 0.03837172f, 0.05659302f, 0.03743678f, -0.03581399f, 0.07969932f, -0.01058462f, 0.06487975f, 
    0.09311447f, 0.00609467f, -0.00185904f, 0.11016096f, 0.08766987f, 0.14148334f, -0.01671783f, 0.05173624f, 
    -0.02326695f, 0.07872451f, -0.10803909f, -0.01078599f, 0.21288651f, -0.13388616f, -0.07135429f, -0.04743306f, 
    -0.01234511f, -0.00607358f, 0.03402433f, 0.08203880f, 0.02320906f, 0.03419654f, -0.02359563f, -0.01252049f, 
    0.13560727f, 0.05333328f, 0.00313926f, 0.12109284f, -0.01863009f, 0.01482292f, 0.03034922f, 0.10758096f, 
    0.09697179f, -0.04172517f, 0.07005026f, -0.04445956f, 0.28873831f, 0.02392323f, -0.09577154f, 0.03439924f, 
    0.07067534f, 0.07194916f, -0.01702954f, 0.04823252f, -0.01616572f, -0.01592893f, 0.00196329f, -0.01637898f, 
    -0.17110002f, -0.10239463f, -0.17600341f, -0.18592767f, 0.04371046f, -0.02686775f, -0.08011996f, 0.04058667f, 
    -0.01761708f, 0.04243571f, 0.11774556f, 0.04728356f, -0.23395258f, -0.06035981f, -0.09283946f, -0.07087758f, 
    0.08212167f, -0.00346707f, -0.01473694f, 0.03784949f, 0.02041345f, 0.06564256f, 0.02375197f, 0.08472082f, 
    0.22733587f, 0.02789497f, -0.03891363f, 0.11453627f, -0.09106947f, -0.10123689f, 0.04599193f, 0.12253116f, 
    -0.05930172f, -0.01040032f, -0.07289676f, 0.00883453f, 0.18978019f, 0.13918483f, 0.02717021f, 0.07471535f, 
    0.08625818f, 0.02145704f, -0.07938360f, -0.04884331f, -0.17844829f, 0.03487993f, 0.13345312f, 0.04043699f, 
    -0.11151618f, -0.02948340f, 0.19682580f, -0.02988432f, -0.09156416f, 0.07949878f, 0.02513271f, -0.04206293f, 
    -0.07493447f, 0.00973865f, -0.01059324f, 0.09129597f, 0.02377238f, 0.07011569f, -0.01619456f, 0.17464589f, 
    -0.02233730f, 0.09501585f, 0.02940710f, -0.00592799f, -0.00279765f, -0.01906567f, -0.01264855f, -0.02240904f, 
    -0.05163450f, 0.05586746f, 0.07404567f, 0.07178856f, -0.01209008f, 0.04189130f, 0.11424760f, 0.12619321f, 
    -0.04061135f, 0.12195510f, -0.01326342f, 0.10812053f, 0.11071101f, 0.12641738f, 0.16067794f, -0.04938616f, 
    0.08398063f, 0.00842541f, 0.04541032f, -0.05217058f, 0.01661279f, -0.00531953f, -0.12101507f, -0.05981039f, 
    -0.00505254f, 0.02595932f, 0.03044051f, -0.15136117f, -0.00264001f, 0.07093590f, 0.00278151f, -0.01723679f, 
    -0.01300801f, 0.02783001f, -0.00143089f, -0.06147655f, 0.26103815f, -0.01279241f, 0.06505512f, 0.11964358f, 
    -0.08892754f, -0.05576922f, 0.03828621f, 0.05515921f, -0.02358953f, -0.00863288f, 0.08086569f, 0.10796160f, 
    0.16513835f, -0.13334648f, 0.03822079f, 0.01557974f, 0.01089886f, 0.01214425f, 0.00628274f, 0.13045584f, 
    0.09381892f, -0.07410847f, -0.00345755f, 0.07082091f, 0.00609149f, 0.02538436f, 0.14295982f, 0.01057530f, 
    -0.00393705f, -0.12081634f, 0.01692677f, 0.09469781f, 0.05790057f, -0.01390267f, 0.06953236f, 0.05529955f, 
    -0.13042304f, 0.01027707f, 0.03090770f, -0.04697882f, 0.00918976f, 0.09421021f, 0.02568674f, -0.05114421f, 
    0.01068570f, 0.07504749f, -0.09314185f, -0.07581655f, -0.07998944f, 0.07938282f, -0.06028852f, -0.28765523f, 
    0.06335162f, -0.08050209f, -0.10115620f, 0.00560755f, -0.03384107f, 0.03623646f, -0.02434791f, -0.07340923f, 
    0.11796746f, 0.08202339f, -0.09630848f, 0.02218810f, -0.00207283f, 0.01083334f, 0.07773849f, -0.05079164f, 
    0.07048050f, 0.04276025f, -0.07459126f, 0.09683022f, 0.23869440f, -0.14867811f, 0.13460204f, 0.00175504f, 
    0.04235614f, 0.04436178f, 0.07578719f, 0.17724669f, -0.05913604f, 0.02619059f, 0.04745248f, -0.12551409f, 
    0.11439641f, -0.08475372f, -0.03490737f, -0.06315410f, 0.02787462f, -0.00340750f, 0.05199057f, 0.06153062f, 
    0.00068497f, 0.02484611f, 0.02981881f, -0.00943793f, 0.11975912f, -0.08405270f, -0.00025504f, 0.02146596f, 
    0.06791869f, 0.06488545f, 0.02357785f, -0.01809713f, -0.03226471f, -0.11891711f, -0.07893439f, -0.02791992f, 
    -0.17972513f, 0.01306047f, -0.01720860f, -0.07375600f, -0.01349338f, 0.07476740f, -0.07850621f, 0.00641516f, 
    -0.08711600f, -0.05992531f, 0.07688989f, 0.03267451f, 0.23647372f, 0.10710920f, 0.01178601f, 0.04108328f, 
    -0.01487347f, -0.05522163f, 0.10324066f, 0.01505850f, 0.01457771f, 0.03454776f, -0.02562788f, -0.00488564f, 
    0.19910838f, 0.06578161f, 0.13660438f, -0.05273715f, -0.04564335f, 0.01028977f, 0.02177607f, -0.04887877f, 
    -0.01514768f, -0.11250261f, 0.01783851f, 0.00194136f, -0.10378404f, 0.14644380f, -0.07272267f, -0.16692023f, 
    0.01664794f, -0.07721483f, 0.00814166f, -0.00673190f, 0.02670386f, 0.03562407f, 0.00723123f, 0.14021252f, 
    -0.22361143f, -0.06473805f, -0.12654400f, -0.03597686f, 0.03532312f, -0.02050488f, 0.04839947f, -0.00097792f, 
    -0.04351967f, 0.05949432f, 0.07102904f, 0.12658535f, 0.15730101f, 0.01462267f, 0.19097798f, 0.18069714f, 
    -0.10087170f, -0.11711796f, -0.04460510f, 0.03143033f, -0.05788326f, 0.13365217f, 0.14667180f, -0.11893014f, 
    -0.04123352f, 0.12170696f, -0.03905506f, 0.08792028f, 0.05673178f, -0.01797665f, 0.04480726f, -0.07336535f, 
    0.08854302f, 0.09725204f, 0.02579296f, 0.17449985f, 0.10562710f, -0.08653199f, 0.05849783f, 0.20905447f, 
    0.08320977f, -0.08705546f, 0.05882710f, -0.00731337f, -0.03899879f, 0.01648630f, 0.00616856f, 0.06802397f, 
    -0.12506837f, 0.07221301f, -0.06259509f, -0.17143933f, -0.03313763f, 0.02693021f, -0.01394107f, -0.06847031f, 
    0.05057496f, 0.10607647f, 0.10181098f, 0.03071127f, -0.02281319f, 0.06142948f, 0.06106547f, -0.07069119f, 
    -0.03243385f, 0.09770045f, -0.03267483f, 0.04178107f, 0.10174483f, 0.20046903f, -0.04482114f, 0.07235128f, 
    0.09542149f, -0.07314429f, 0.07223694f, -0.00001798f, -0.02661633f, 0.07294007f, 0.03415447f, 0.04940717f, 
    0.02088800f, 0.01958731f, 0.11299594f, -0.04742976f, 0.24296892f, 0.05066797f, 0.08208879f, 0.03822714f, 
    0.01060516f, -0.02412524f, 0.00079965f, -0.05407880f, 0.09312239f, 0.05182862f, -0.01869176f, 0.07125463f, 
    -0.03539687f, -0.04242938f, -0.04960151f, -0.06241179f, -0.03973523f, 0.03399501f, 0.01178059f, -0.07609338f, 
    -0.02654961f, -0.02822579f, -0.04306066f, -0.03772875f, -0.14870252f, -0.13323863f, -0.15556948f, -0.16179970f, 
    -0.00739861f, 0.02331774f, 0.02447139f, 0.04685929f, 0.05559927f, 0.08585393f, 0.06938616f, -0.06644503f, 
    0.01496455f, -0.11484204f, 0.06106313f, -0.14848678f, 0.11048494f, -0.10760844f, -0.03073809f, -0.06634567f, 
    -0.01523539f, 0.09063764f, 0.08790084f, 0.15085135f, -0.15333430f, 0.05627840f, 0.01514760f, -0.14558743f, 
    0.03992058f, 0.02209443f, 0.07256419f, -0.03715763f, 0.10296523f, -0.00223896f, -0.07527909f, -0.07088479f, 
    -0.06661911f, -0.02764810f, 0.00638092f, -0.07692399f, 0.17805924f, -0.00140946f, -0.01709656f, 0.12539969f, 
    0.05873043f, -0.07120837f, 0.12302632f, 0.00675463f, 0.17035359f, -0.05154046f, -0.09051703f, 0.22091244f, 
    0.08494742f, 0.05513006f, -0.06689849f, -0.03068949f, 0.04779189f, 0.04626013f, 0.05217129f, 0.02657457f, 
    -0.18910579f, 0.04712711f, -0.04939793f, -0.03268081f, 0.04262112f, 0.04844362f, -0.04312816f, 0.05078790f, 
    -0.00331913f, -0.03157101f, 0.03338340f, 0.06281571f, -0.25337434f, 0.02834039f, 0.12399999f, -0.01035410f, 
    0.05233455f, 0.01824729f, -0.03824480f, 0.01251240f, 0.04048358f, 0.06193427f, -0.03648693f, 0.00765927f, 
    0.18005480f, -0.09159826f, 0.08157214f, 0.15049711f, 0.00453179f, 0.02561682f, 0.07063537f, 0.00876690f, 
    -0.00614100f, 0.09596509f, 0.03158915f, 0.06998030f, 0.15316480f, 0.01046692f, 0.10169999f, 0.00603778f, 
    -0.08507553f, 0.03575636f, 0.06748490f, -0.02359138f, -0.12228565f, 0.04374847f, 0.05922700f, 0.02051383f, 
    -0.02500704f, 0.02054335f, -0.02677572f, -0.03890605f, 0.01065831f, -0.01441194f, -0.00644601f, -0.00120884f, 
    -0.03371487f, -0.01598878f, -0.02188374f, 0.00732393f, -0.03121745f, -0.04111384f, -0.00772823f, 0.02698702f, 
    -0.01908539f, -0.01368361f, -0.01320390f, -0.00280643f, -0.00828811f, -0.02988021f, -0.01205742f, -0.03138049f, 
    -0.01757737f, -0.02218319f, -0.01990737f, 0.01022425f, -0.04251526f, 0.01485306f, -0.00373596f, -0.03770265f, 
    0.01213186f, -0.01228995f, -0.03480372f, 0.00891744f, 0.00169443f, -0.01954559f, -0.02066113f, -0.02601346f, 
    0.00451739f, 0.02226717f, -0.03503856f, 0.01969879f, 0.00319640f, 0.02414193f, 0.01578716f, -0.04089126f, 
    -0.03850612f, -0.03141582f, -0.00748988f, -0.01092902f, -0.03555234f, -0.03525349f, 0.01728631f, -0.03188029f, 
    -0.03799112f, 0.02086074f, -0.03857390f, 0.02413824f, 0.02227439f, 0.02491721f, -0.00048104f, -0.00374495f, 
    0.00636321f, -0.00627125f, -0.01097887f, -0.01239657f, 0.00061220f, 0.01691449f, -0.00090499f, 0.00083379f, 
    0.02118771f, -0.02886141f, 0.02905115f, -0.00817520f, -0.02249607f, 0.01634591f, -0.01919751f, 0.03093695f, 
    0.02837298f, 0.02437762f, 0.00503975f, 0.02951298f, -0.03458126f, 0.02694521f, 0.00998388f, -0.03707182f, 
    0.01231560f, 0.02890438f, 0.02239779f, -0.00220311f, 0.00748164f, 0.01221738f, -0.01565356f, -0.01649507f, 
    -0.01122338f, -0.00655424f, 0.01576655f, 0.01367122f, -0.01461783f, -0.01537367f, -0.02236196f, -0.02793578f, 
    -0.00939247f, 0.01761366f, 0.02916458f, 0.02819331f, 0.01881837f, 0.02159692f, -0.02466135f, 0.02920320f, 
    0.02490035f, 0.01727027f, -0.03387252f, -0.03586709f, 0.01891928f, -0.03629982f, 0.02437188f, 0.02353576f, 
    -0.01475817f, 0.00088023f, -0.00194518f, 0.01172666f, -0.03948479f, -0.02829227f, -0.00925896f, -0.02918606f, 
    -0.00868585f, 0.02765322f, 0.03130161f, 0.02742857f, 0.00729926f, -0.03718699f, 0.00697679f, -0.02138499f, 
    0.00642311f, -0.03601179f, 0.00809492f, -0.03828689f, -0.00902588f, -0.00638375f, -0.02749066f, 0.00980290f, 
    0.00849823f, -0.03162083f, -0.03747329f, -0.00455179f, -0.02919388f, -0.01818506f, -0.00525147f, -0.00069134f, 
    -0.03370971f, 0.02175215f, 0.01569526f, -0.02778479f, 0.01732314f, -0.03292245f, -0.02703215f, 0.03078782f, 
    0.00105103f, 0.02437082f, -0.01252154f, -0.01442368f, -0.04334427f, -0.00066934f, -0.03056633f, 0.02613099f, 
    -0.02415431f, -0.00696501f, 0.00474645f, 0.02440422f, 0.02873445f, 0.00889783f, -0.00754458f, -0.04140531f, 
    -0.00543033f, 0.00751328f, -0.02207054f, -0.04114520f, 0.01902016f, 0.00440624f, -0.01207569f, 0.00381003f, 
    -0.00219717f, 0.03324842f, 0.02468023f, -0.03540924f, 0.01534401f, -0.00985883f, -0.02411584f, 0.02439266f, 
    -0.01012656f, -0.04037272f, -0.00756310f, -0.01395150f, -0.01874792f, 0.01957541f, -0.03481365f, -0.04021268f, 
    -0.01613137f, 0.01597475f, 0.01616872f, 0.02771931f, -0.01315475f, -0.00848700f, -0.01381511f, 0.02289134f, 
    -0.02091267f, -0.01098647f, -0.01902566f, -0.02989480f, 0.00095114f, 0.00632490f, -0.03391739f, 0.01667363f, 
    -0.01355134f, 0.00819676f, -0.02648893f, 0.02498647f, -0.02246179f, -0.02604191f, -0.02687206f, -0.00378490f, 
    -0.03352605f, -0.03722527f, -0.01501852f, 0.03165125f, -0.02771581f, 0.01314852f, -0.00239412f, 0.01599814f, 
    -0.01409386f, 0.00252339f, 0.01787373f, 0.01448385f, -0.03018834f, -0.01847688f, -0.02780809f, -0.01484466f, 
    -0.00835144f, -0.03456423f, -0.01469306f, 0.00465354f, 0.02606794f, 0.01342545f, -0.01204887f, -0.02616318f, 
    -0.04290837f, -0.01730546f, -0.02494847f, 0.01682158f, -0.00540803f, -0.02745570f, -0.03041312f, 0.01925333f, 
    0.01747426f, -0.03699185f, -0.02590864f, 0.02086403f, -0.01299745f, 0.00656376f, -0.04055572f, 0.02924717f, 
    0.00438603f, -0.03982669f, 0.00602522f, 0.01415294f, 0.02411043f, 0.01918332f, 0.01779425f, -0.01840820f, 
    -0.01866625f, -0.00468978f, -0.03031031f, 0.02607443f, 0.01600899f, -0.01209414f, -0.02315939f, 0.01305011f, 
    0.01836403f, -0.00746171f, 0.03402841f, 0.00984939f, -0.00613851f, -0.03068717f, -0.03945043f, -0.03092442f, 
    -0.00220981f, 0.00451067f, -0.02944168f, 0.02425330f, 0.00195263f, 0.01366140f, -0.01099615f, -0.02592300f, 
    -0.02326169f, -0.00668243f, -0.03757048f, 0.02984288f, -0.03714935f, -0.02817146f, 0.02541013f, -0.03296463f, 
    0.02000852f, 0.00102046f, 0.00035516f, -0.02980868f, 0.02135886f, -0.02114396f, -0.02400660f, 0.02506021f, 
    0.01064028f, 0.01467759f, -0.00282988f, 0.00769845f, 0.00537095f, -0.00901525f, -0.02261111f, 0.01348661f, 
    -0.00791634f, 0.02427577f, -0.03598894f, -0.02635595f, -0.02875434f, -0.02771328f, -0.03751861f, -0.00462200f, 
    0.01212257f, -0.01952702f, -0.02036017f, 0.01353686f, 0.01718497f, -0.02554468f, -0.03047851f, -0.03199721f, 
    -0.00788461f, -0.01177558f, -0.03262351f, -0.01774325f, -0.01358357f, 0.01146013f, -0.00098457f, -0.00408533f, 
    0.02536683f, 0.01539335f, -0.01460534f, -0.01627219f, -0.00405666f, -0.02333491f, -0.00688066f, -0.01382949f, 
    -0.01266358f, 0.02645811f, -0.02631334f, -0.02849670f, -0.02728357f, -0.01029341f, 0.02213987f, -0.02039196f, 
    -0.00879953f, 0.02378274f, 0.01375597f, -0.03369565f, -0.02863732f, -0.00899886f, -0.02471471f, -0.00250838f, 
    -0.03136894f, 0.00566213f, -0.02351745f, -0.04035451f, 0.00838281f, 0.03144619f, -0.02220067f, 0.02489601f, 
    0.01495346f, 0.00282453f, -0.02740428f, -0.03017852f, 0.00389890f, -0.02355381f, -0.01173044f, 0.01662284f, 
    0.01525933f, -0.01340273f, 0.01980510f, -0.00356660f, 0.01925978f, -0.01083958f, -0.03972047f, 0.00049215f, 
    0.02993228f, 0.00013324f, 0.01293242f, -0.02518514f, -0.03070986f, -0.02439574f, -0.02650544f, 0.02089831f, 
    0.02249029f, 0.00049595f, 0.03230086f, -0.04053667f, 0.02881251f, -0.03450459f, -0.03019040f, 0.02840362f, 
    0.01308533f, -0.00970054f, 0.00759372f, 0.02087956f, 0.02722880f, -0.00095876f, 0.02189155f, 0.02324045f, 
    0.01666049f, 0.02133868f, -0.03810751f, -0.00804195f, 0.02779971f, -0.01439051f, -0.00836014f, -0.03052038f, 
    -0.02098704f, -0.00046644f, -0.00747653f, 0.02389419f, 0.00948102f, 0.01595913f, 0.00101956f, -0.01629821f, 
    -0.03836817f, 0.00923670f, -0.03313376f, 0.01502027f, -0.03657250f, -0.02212851f, -0.03163091f, -0.02286959f, 
    0.02788477f, 0.00799334f, -0.00166486f, -0.03309282f, -0.02631882f, 0.00298228f, 0.00224405f, -0.01958073f, 
    -0.01712409f, 0.01179192f, -0.02180050f, 0.03003899f, 0.00204617f, -0.01631520f, 0.02995734f, -0.01062415f, 
    -0.03156192f, -0.01851999f, -0.01447178f, 0.00427840f, 0.00584509f, 0.02052278f, -0.02196901f, 0.01432004f, 
    -0.01546797f, -0.03744667f, -0.04328490f, -0.00234984f, 0.00764942f, 0.02365902f, 0.00001493f, -0.01799827f, 
    0.02481896f, -0.01943719f, -0.02279006f, -0.01405002f, -0.02551640f, -0.00207913f, -0.01139813f, -0.03134698f, 
    -0.00774912f, -0.00280299f, 0.01875857f, -0.00414422f, -0.02190900f, 0.00109173f, -0.02259224f, -0.03878209f, 
    -0.01848947f, -0.01273527f, 0.01945668f, -0.04328140f, -0.00167722f, 0.02209459f, 0.00714643f, -0.00112250f, 
    0.01034136f, 0.02315183f, 0.03132753f, 0.01890834f, -0.01651539f, 0.02078199f, 0.00955704f, 0.02612654f, 
    -0.01815761f, -0.00719965f, -0.04442772f, 0.00380179f, -0.03272936f, 0.02172134f, 0.00985567f, -0.01993528f, 
    0.00891163f, 0.00800268f, -0.02951616f, -0.03037331f, -0.00194042f, 0.02677898f, 0.00048354f, -0.03736749f, 
    -0.03626131f, -0.01440951f, -0.00456906f, -0.03647001f, 0.02113678f, -0.01323439f, -0.03390090f, -0.01689373f, 
    -0.01447093f, -0.03059511f, -0.01699683f, -0.02785989f, -0.03148151f, -0.00633757f, 0.01792585f, 0.01179739f, 
    -0.00323172f, -0.02885978f, -0.00060504f, -0.03241463f, -0.01836735f, 0.01978450f, -0.01939852f, 0.01771000f, 
    -0.03353634f, -0.03154043f, -0.03365971f, 0.02812105f, 0.00446582f, 0.01228636f, 0.00125691f, 0.03221252f, 
    0.02091428f, 0.01271085f, 0.00200379f, 0.02322788f, -0.02021641f, -0.03446033f, -0.02945921f, 0.01923615f, 
    -0.02585124f, 0.02558582f, 0.01191070f, 0.02421224f, 0.00656392f, 0.01890206f, -0.00702191f, -0.03057713f, 
    0.02482684f, -0.00653928f, 0.00217295f, -0.01412088f, 0.00182084f, 0.01206129f, -0.02044901f, -0.00411916f, 
    0.00326197f, -0.02084305f, -0.00159191f, 0.01999142f, -0.01438242f, -0.02427319f, -0.03731299f, 0.02666059f, 
    -0.00016171f, -0.02205154f, 0.02681406f, -0.03904735f, -0.00834347f, -0.01918928f, 0.02565644f, 0.00773661f, 
    0.01565805f, -0.03291120f, 0.00575555f, 0.01776299f, 0.03242167f, 0.02845521f, 0.02380240f, -0.01759487f, 
    -0.03958682f, -0.00946766f, 0.02410865f, 0.01859926f, -0.03437534f, -0.01456957f, 0.01512349f, 0.01688043f, 
    -0.01665321f, 0.02330988f, 0.02058227f, -0.00688728f, -0.02147903f, 0.02439581f, -0.01605151f, -0.00849401f, 
    0.02650625f, -0.02893705f, 0.02957446f, 0.01248436f, 0.02229164f, -0.03370346f, -0.00518082f, -0.02621416f, 
    0.00203745f, -0.01444445f, -0.02568320f, -0.04032935f, -0.01270647f, 0.02643101f, -0.01704923f, 0.01918765f, 
    0.01194751f, -0.02145486f, -0.01847756f, 0.03138869f, 0.00351246f, -0.01968609f, -0.02764360f, 0.02017734f, 
    0.00727890f, -0.00568575f, -0.02954734f, -0.00964247f, -0.01478758f, -0.02470496f, -0.03297745f, -0.03230856f, 
    0.02270260f, 0.02186426f, 0.02342447f, -0.02747605f, -0.00390191f, -0.00194215f, -0.02743064f, 0.01033495f, 
    -0.00322041f, -0.01788794f, -0.02310208f, 0.01056365f, 0.00097137f, -0.03377922f, -0.01882820f, -0.02796932f, 
    0.00782054f, -0.03980455f, -0.01905550f, -0.02305393f, -0.04055310f, 0.00446270f, -0.02119771f, -0.02592763f, 
    0.00902963f, -0.00331334f, 0.02349711f, -0.01000091f, -0.01448846f, -0.03312087f, -0.03264219f, -0.00571632f, 
    -0.02330066f, -0.00704231f, -0.02694826f, 0.01425325f, 0.01684945f, -0.00293312f, 0.00604791f, 0.00604697f, 
    0.03412525f, 0.02296370f, -0.03290685f, -0.02882165f, -0.03649741f, 0.00004743f, -0.00237918f, 0.01370788f, 
    -0.00679219f, 0.03136555f, -0.01227545f, -0.04041454f, -0.03272539f, -0.02843248f, 0.01318041f, 0.03179492f, 
    -0.00584571f, -0.03244874f, 0.00751930f, 0.02442421f, 0.01598858f, -0.01750880f, -0.00040518f, 0.02411139f, 
    0.00280977f, -0.03583415f, 0.02575727f, -0.02410876f, -0.02697393f, -0.01310627f, -0.00264182f, -0.02202298f, 
    -0.01120234f, -0.03316956f, 0.01525164f, 0.00299221f, 0.00785904f, -0.00999354f, -0.00965170f, -0.03859586f, 
    -0.03754146f, 0.00970662f, -0.01189533f, -0.02905480f, -0.01892102f, 0.00806858f, 0.03206661f, 0.00070846f, 
    -0.00829006f, -0.04290503f, 0.00335257f, -0.02624295f, -0.01809303f, 0.01655781f, -0.02068673f, -0.02787459f, 
    -0.00984767f, -0.00897652f, 0.01181519f, -0.01568294f, 0.02012041f, -0.01883206f, 0.02231691f, -0.03814747f, 
    0.02585721f, -0.01106282f, 0.03141951f, 0.01647721f, 0.00138972f, -0.00481275f, -0.00298166f, 0.03316970f, 
    0.00950474f, 0.02412522f, -0.03092199f, -0.02326918f, -0.02557592f, 0.01339605f, 0.00743811f, 0.02661908f, 
    -0.01306666f, -0.17666663f, -0.00687609f, -0.02007674f, -0.08743051f, -0.02844526f, 0.03204083f, -0.12524901f, 
    -0.03435379f, 0.02936096f, 0.01621860f, 0.11430065f, -0.26709870f, -0.11707960f, 0.16575691f, -0.16549473f, 
    0.02826391f, -0.03565163f, -0.00841379f, -0.00217718f, -0.06289954f, -0.09164971f, -0.06986029f, -0.01285864f, 
    -0.03961805f, 0.03110421f, 0.06793065f, 0.10085593f, -0.00381366f, 0.00968501f, 0.00883844f, -0.14865646f, 
    -0.00301620f, -0.10896741f, -0.13030151f, 0.10676913f, -0.09179194f, -0.03998834f, -0.10184374f, 0.01330788f, 
    0.00872995f, -0.03591520f, 0.03563463f, 0.04656813f, -0.00574050f, 0.14313132f, 0.00070110f, 0.07506151f, 
    0.25563517f, 0.08970080f, 0.26934057f, -0.02550529f, -0.04066894f, -0.00499495f, -0.00519385f, -0.05789047f, 
    0.04732629f, 0.02557526f, 0.09879780f, 0.01236075f, -0.26110652f, -0.02033164f, 0.07659280f, 0.16544326f, 
    -0.03771261f, 0.09767368f, -0.09359010f, 0.11441622f, -0.01610037f, 0.10992280f, 0.08613699f, -0.11145335f, 
    -0.39683202f, 0.08479854f, -0.05454436f, -0.05464949f, 0.02984510f, 0.02559160f, 0.11529857f, 0.02051807f, 
    0.04248430f, -0.00349132f, -0.02556434f, 0.02387429f, 0.04023605f, 0.03803384f, 0.15881683f, 0.11133353f, 
    -0.06576759f, -0.03467283f, -0.05472173f, 0.09868170f, -0.01166468f, -0.02410984f, -0.05402591f, -0.05163254f, 
    -0.40271550f, 0.20146324f, -0.02328768f, -0.10000745f, 0.10351234f, 0.02349531f, -0.01091141f, -0.03316505f, 
    -0.01284393f, -0.01269926f, -0.00345069f, -0.06263676f, -0.12862462f, -0.01113889f, 0.06139280f, 0.21920088f, 
    0.08351198f, -0.00971876f, 0.06724641f, 0.04127037f, 0.04559127f, 0.08056007f, 0.06936088f, 0.10583763f, 
    0.13524973f, -0.02000433f, 0.07229740f, 0.14542097f, -0.01563797f, -0.07016961f, -0.07309461f, 0.02560506f, 
    0.00377842f, 0.06554276f, -0.02762639f, -0.01694727f, 0.14766149f, 0.10790858f, -0.04945565f, 0.15109956f, 
    -0.03513743f, -0.03239135f, -0.01183180f, 0.09168757f, 0.04176959f, -0.02087012f, 0.00382661f, -0.05113033f, 
    -0.06841048f, -0.06036484f, 0.02124624f, -0.10653118f, 0.06574375f, -0.00778531f, 0.05761592f, 0.08219368f, 
    0.21549125f, 0.06969735f, -0.01757658f, 0.13470012f, -0.08232422f, -0.08584926f, -0.03284099f, 0.04548291f, 
    0.00697167f, 0.12060091f, 0.00918218f, -0.08241509f, 0.10348443f, 0.06333502f, 0.02765849f, 0.13831671f, 
    0.04199833f, 0.01492209f, -0.13117251f, 0.04791833f, -0.07107256f, -0.02583506f, 0.02489539f, 0.00501133f, 
    0.01734366f, 0.06387884f, -0.05576363f, -0.08306473f, 0.14318849f, -0.00959182f, 0.00534968f, 0.13793954f, 
    -0.01982265f, -0.07465421f, 0.04103444f, 0.07427479f, -0.00262038f, -0.03998689f, -0.00489505f, 0.00088689f, 
    0.23876189f, 0.06998470f, -0.11196404f, 0.07679640f, 0.00384283f, 0.06863596f, -0.11754902f, -0.07670479f, 
    0.03461918f, 0.01226244f, 0.04196552f, -0.02769025f, 0.20625910f, -0.02661791f, 0.14085330f, 0.04564626f, 
    -0.05559251f, -0.00159556f, 0.02317168f, 0.02247340f, -0.02611032f, 0.07810530f, 0.00223365f, 0.02062285f, 
    0.18099125f, 0.06034299f, -0.00716340f, 0.09949017f, 0.00253852f, 0.11515062f, 0.07823379f, -0.01925996f, 
    0.08336814f, 0.15812999f, -0.02570482f, -0.04001677f, -0.19302270f, -0.03296233f, 0.16472758f, -0.15638468f, 
    0.15385337f, -0.02469741f, -0.00831438f, 0.02303936f, -0.08742559f, 0.08357476f, 0.13307485f, 0.13129827f, 
    0.36291879f, -0.10939010f, -0.00499085f, 0.12232912f, -0.12984517f, 0.10344394f, -0.03571369f, -0.02137907f, 
    0.08793753f, 0.06348920f, 0.08023256f, 0.01713563f, -0.28610143f, 0.05556535f, 0.16066797f, 0.23863952f, 
    -0.07388364f, -0.07469530f, 0.03146857f, 0.02062461f, -0.03517221f, -0.12376251f, -0.05206258f, -0.07553903f, 
    -0.34981781f, 0.10529733f, 0.12458740f, 0.05613346f, -0.05073390f, -0.03197320f, 0.11821503f, -0.00752588f, 
    0.01220035f, 0.02348908f, -0.09563245f, -0.03966287f, 0.16015162f, -0.05985838f, -0.19415332f, 0.07447779f, 
    0.01418326f, -0.02357265f, -0.09148766f, 0.06430871f, 0.12608685f, -0.02606763f, -0.01811692f, -0.07348417f, 
    0.01606495f, -0.02639988f, 0.10495109f, 0.14780077f, -0.03082642f, 0.00821042f, -0.01102054f, 0.06835089f, 
    0.01441483f, 0.06810523f, -0.04655057f, 0.00580986f, 0.02044097f, 0.01046725f, 0.08667822f, -0.02661657f, 
    0.01356908f, -0.09983212f, 0.06271202f, -0.03521891f, 0.00375544f, 0.05357294f, -0.06068397f, 0.05304463f, 
    -0.20929377f, -0.11066413f, -0.00595290f, -0.07936353f, 0.06511200f, -0.06508985f, -0.03289090f, -0.06322991f, 
    0.19030441f, 0.09833299f, 0.05885278f, 0.02594747f, 0.00122667f, -0.24010684f, -0.12819980f, -0.13792095f, 
    -0.02054072f, 0.11284593f, 0.01686212f, 0.12943497f, -0.01955776f, -0.01568269f, -0.10786033f, 0.01493463f, 
    0.05652447f, 0.01884766f, -0.13765509f, 0.13410029f, 0.12738630f, 0.05177958f, -0.05196619f, -0.04006242f, 
    -0.04971206f, -0.13508579f, 0.00081073f, 0.03353962f, 0.21860048f, 0.02274496f, -0.07872251f, -0.01319088f, 
    0.00672248f, -0.05236189f, 0.04435512f, 0.05299234f, 0.04671916f, -0.01393860f, 0.00938922f, 0.08131073f, 
    -0.08997087f, -0.09978366f, -0.15663426f, -0.04443984f, -0.02871632f, 0.03688768f, 0.10521709f, -0.15479939f, 
    0.02387137f, 0.01557271f, -0.01507746f, 0.08460890f, -0.08842950f, -0.11433465f, 0.15080330f, 0.16159335f, 
    0.04477667f, 0.02831113f, -0.02131077f, 0.01979416f, 0.05071008f, -0.09508261f, -0.08943652f, 0.14805607f, 
    0.22299115f, -0.02007310f, 0.07102128f, -0.03013255f, 0.04619824f, 0.06780525f, 0.11173391f, 0.00383608f, 
    0.05490734f, -0.03685015f, 0.07431770f, 0.06731452f, -0.39008778f, -0.06614592f, -0.04313375f, -0.21705097f, 
    0.03929023f, -0.01719585f, 0.04334383f, 0.01510846f, -0.03585109f, 0.07485773f, 0.03457488f, -0.05797982f, 
    -0.40777236f, -0.03471408f, -0.05662486f, -0.09865118f, 0.09398974f, 0.11193866f, 0.04161210f, 0.07393178f, 
    0.00793265f, -0.05622580f, 0.07095277f, -0.00060346f, -0.23815577f, -0.08775274f, -0.16710745f, -0.07060633f, 
    -0.01908540f, 0.15210365f, 0.04600060f, -0.04560031f, -0.02145905f, -0.01651778f, 0.08155957f, -0.00550380f, 
    -0.03891554f, -0.03649645f, 0.05542215f, 0.14292270f, 0.04191943f, -0.06174000f, -0.00693818f, -0.04848625f, 
    -0.01563429f, -0.02056584f, 0.08305775f, 0.13729812f, 0.05641197f, -0.05522327f, 0.13290808f, 0.28907117f, 
    -0.03449051f, 0.04998612f, -0.04757790f, 0.12425641f, -0.01347337f, -0.08960305f, -0.01405490f, 0.14530770f, 
    -0.00995583f, -0.02071656f, 0.10218182f, 0.12013473f, -0.02202832f, 0.01430174f, -0.01382507f, -0.01344571f, 
    -0.06870229f, -0.09176764f, 0.13063893f, -0.00184851f, -0.14440300f, 0.19386238f, -0.02726305f, 0.11079763f, 
    -0.03573079f, -0.01112983f, -0.07058742f, 0.03892628f, 0.05779133f, 0.09335718f, -0.07977585f, -0.00505374f, 
    -0.12067563f, -0.03240963f, 0.08023959f, 0.23572351f, -0.07024022f, 0.01218493f, -0.04918603f, -0.04951703f, 
    0.00821196f, -0.02171991f, 0.01464359f, 0.00264231f, 0.02436874f, 0.01116481f, -0.02381778f, 0.17247856f, 
    -0.04356471f, -0.04277939f, 0.04826831f, 0.00509403f, 0.10492273f, -0.05478103f, -0.00823019f, 0.11864121f, 
    -0.00246501f, 0.16889015f, 0.07757222f, -0.09574609f, 0.01357591f, 0.03583552f, 0.05791407f, -0.00067647f, 
    -0.01422614f, 0.15424487f, 0.07754593f, -0.05798609f, -0.04794365f, -0.17604478f, 0.06014324f, 0.05153832f, 
    0.00663702f, -0.00680660f, 0.06778857f, -0.03521512f, 0.02889563f, -0.10626046f, -0.08445472f, -0.06498023f, 
    -0.05291300f, -0.04790700f, -0.08733512f, 0.03554941f, -0.02791310f, 0.00786645f, -0.06159030f, 0.11958348f, 
    0.00499131f, 0.01437507f, 0.02607650f, -0.01045305f, 0.41131651f, 0.03471658f, 0.02145489f, 0.11565726f, 
    0.01810093f, 0.01087206f, 0.01416015f, 0.07417876f, 0.11658128f, 0.08147850f, -0.01631896f, 0.00840076f, 
    0.05944430f, -0.02498726f, 0.24303964f, 0.02095952f, -0.04000068f, -0.02286064f, -0.05404351f, 0.01292019f, 
    0.01049153f, -0.12964213f, 0.03724629f, -0.03347805f, 0.15772505f, 0.08382721f, -0.08299337f, -0.13586813f, 
    0.01971619f, 0.05200320f, 0.08206825f, -0.04242718f, -0.08958470f, -0.08889604f, -0.00406940f, 0.00764455f, 
    0.21927588f, 0.01412921f, 0.08614867f, -0.09925070f, -0.01533363f, 0.06148554f, 0.04059149f, 0.08645436f, 
    0.04491776f, 0.08781847f, 0.07798247f, 0.15962882f, 0.06921364f, 0.08542877f, 0.01747373f, -0.02390643f, 
    0.03626239f, 0.02134516f, 0.08687350f, 0.01538469f, 0.04454177f, -0.07832041f, 0.03228065f, 0.05394273f, 
    0.15111798f, -0.07587612f, 0.06721239f, 0.05859460f, -0.01404095f, -0.04970154f, -0.01788101f, 0.16175582f, 
    -0.02729549f, 0.00896797f, 0.00224964f, 0.16553955f, -0.09773371f, -0.10387404f, 0.02085490f, -0.01923260f, 
    0.12577394f, -0.06854134f, -0.00709480f, -0.09631959f, 0.00119274f, -0.03409715f, 0.03216303f, 0.04443656f, 
    0.04393894f, 0.14586149f, 0.09121302f, 0.14482976f, 0.06622665f, -0.03951233f, 0.03997561f, 0.09335465f, 
    0.01764838f, -0.04276223f, -0.00966236f, 0.03078769f, -0.34432703f, -0.00510800f, 0.10207325f, -0.13855562f, 
    0.05384799f, 0.02633715f, -0.02949871f, -0.05734082f, -0.01221365f, 0.03830878f, 0.02502333f, 0.03168282f, 
    0.18488277f, 0.01249542f, 0.22319965f, 0.13448100f, -0.01635121f, 0.12719513f, -0.00895891f, -0.03142355f, 
    0.03161338f, 0.07991241f, 0.09102864f, -0.07929882f, 0.12600660f, 0.05204918f, 0.18513851f, 0.00765533f, 
    -0.00396507f, 0.04023684f, 0.07960859f, 0.01671223f, 0.10501598f, 0.05418219f, 0.09116406f, 0.02078279f, 
    -0.07394104f, 0.09098458f, 0.15460125f, 0.10724606f, -0.02762020f, -0.04685837f, -0.03577643f, 0.02353760f, 
    -0.08078812f, 0.08699533f, -0.14760581f, -0.01020147f, 0.15013412f, -0.00466406f, 0.16438010f, 0.04681145f, 
    0.03060729f, 0.14172664f, 0.00335462f, -0.03245159f, 0.02791045f, -0.01002658f, -0.01197182f, -0.05572331f, 
    -0.04948230f, 0.09942511f, 0.07858980f, 0.11744448f, 0.03135353f, -0.09044723f, 0.04331985f, -0.07315785f, 
    -0.03329775f, 0.11874083f, 0.00880605f, 0.00480773f, -0.12848549f, 0.05073289f, 0.15927984f, -0.14412963f, 
    -0.05383155f, 0.01465124f, 0.14006950f, 0.00609302f, -0.14207393f, 0.00467546f, 0.02360309f, -0.08643595f, 
    0.33734438f, 0.14612994f, -0.00937052f, 0.13991390f, -0.01297294f, 0.09534071f, 0.14768361f, 0.00871461f, 
    0.07177100f, -0.00642412f, 0.05735961f, 0.04267110f, 0.11371411f, 0.02795769f, 0.05044261f, -0.02421294f, 
    0.01533076f, 0.14170443f, 0.02980640f, 0.06054235f, 0.03945179f, 0.03253859f, 0.06277388f, -0.05414999f, 
    -0.53035468f, 0.18593562f, -0.00755691f, -0.07214046f, 0.08760321f, -0.04075197f, 0.00962327f, -0.01551966f, 
    0.05194554f, -0.05670420f, 0.04744303f, 0.04612436f, -0.29033300f, 0.05479689f, 0.03276801f, -0.15600915f, 
    0.07819664f, 0.12930717f, -0.00966500f, 0.11304306f, -0.07372880f, 0.13465710f, -0.04075294f, 0.09252387f, 
    -0.15635203f, 0.20715065f, -0.12605503f, 0.07470553f, 0.01954130f, -0.00436394f, -0.02674683f, 0.07256062f, 
    0.02861709f, 0.06300402f, 0.06156282f, -0.04267587f, -0.11176879f, 0.12875578f, -0.06704814f, 0.01857161f, 
    0.12371927f, -0.04945843f, 0.07207458f, 0.07664986f, 0.05878102f, 0.06360970f, 0.07306557f, -0.04123747f, 
    0.04936697f, 0.03352511f, -0.11092201f, 0.04674630f, 0.06046992f, -0.00276415f, 0.05369552f, 0.09790559f, 
    -0.19123571f, 0.03920637f, 0.01701782f, 0.01844399f, 0.11994337f, 0.12823857f, 0.03974373f, 0.02996016f, 
    0.01054496f, -0.07247858f, 0.03472602f, 0.01446656f, 0.02793112f, -0.05883455f, 0.01517384f, 0.07218061f, 
    -0.09670020f, -0.08569649f, -0.22590135f, -0.09625305f, 0.17265172f, 0.02061000f, 0.05148739f, 0.02432558f, 
    0.01580038f, 0.02990684f, -0.04602070f, -0.02886989f, 0.34762669f, -0.01619457f, -0.10440146f, 0.07347681f, 
    0.05232859f, 0.12360188f, 0.08434374f, -0.12314330f, 0.06973203f, 0.05441508f, 0.05197247f, 0.06272265f, 
    0.26251918f, -0.05579336f, 0.06407151f, 0.12477649f, 0.06260953f, -0.05268430f, 0.00267445f, 0.03582105f, 
    -0.03842820f, 0.01226915f, 0.09662406f, -0.06537338f, 0.05141620f, 0.01667723f, -0.02323943f, -0.13601446f, 
    0.09262920f, 0.09148762f, 0.07391889f, -0.06008310f, -0.00189836f, 0.11972386f, 0.00420601f, 0.12575778f, 
    -0.01522405f, 0.03269017f, -0.08764756f, 0.21977589f, 0.06418749f, -0.05936645f, 0.06935462f, 0.07592111f, 
    0.04317374f, -0.03488541f, -0.10549537f, 0.02518081f, 0.25041965f, 0.08732510f, -0.04214755f, -0.20829035f, 
    0.04888250f, 0.05732280f, 0.00360964f, -0.02530274f, 0.01969584f, -0.05095482f, 0.05526485f, 0.00282563f, 
    0.29570669f, -0.12181788f, 0.12682366f, -0.15635991f, 0.05667928f, 0.11605074f, 0.12320466f, 0.04083125f, 
    0.05766441f, -0.02905115f, -0.02511355f, 0.12701762f, -0.09107508f, 0.02060078f, -0.08091670f, 0.22227928f, 
    0.01595727f, -0.06611764f, 0.06884997f, -0.05768544f, -0.00792755f, 0.09058233f, -0.01008962f, 0.05915061f, 
    0.12878437f, 0.11066554f, 0.07398843f, -0.01845515f, 0.03708573f, 0.06017863f, -0.10552850f, -0.02582016f, 
    -0.14957376f, 0.03386651f, 0.07642119f, -0.00194916f, -0.04040184f, 0.11833046f, 0.04051269f, 0.03614318f, 
    -0.12135758f, 0.01930799f, -0.01132246f, 0.12396085f, -0.08490753f, -0.03136963f, -0.02013653f, -0.15682282f, 
    -0.02538446f, 0.18732524f, 0.12416190f, 0.12585722f, 0.09760188f, -0.00371373f, -0.06126693f, -0.01524950f, 
    0.03404118f, 0.03337628f, 0.03312531f, 0.08467713f, -0.05025811f, 0.05454929f, 0.01425087f, -0.00113015f, 
    -0.02399543f, 0.09676335f, -0.01029991f, 0.00852189f, 0.10403776f, -0.03132678f, 0.09711739f, 0.02282663f, 
    0.02452374f, 0.09802698f, 0.11588980f, -0.04824791f, 0.15655608f, -0.05370577f, 0.15270735f, -0.01552309f, 
    0.02299158f, 0.05174266f, -0.00749752f, 0.05947677f, -0.20711592f, -0.03000485f, -0.08140969f, -0.22354379f, 
    0.17162165f, -0.03192429f, -0.00493089f, 0.00072628f, 0.08565655f, -0.02379929f, 0.04388494f, 0.10942875f, 
    0.48437759f, -0.08407006f, 0.03073701f, -0.19021513f, -0.06697787f, 0.00664311f, -0.05676516f, 0.05354451f, 
    -0.06122373f, -0.08653628f, 0.04557848f, 0.11081797f, 0.06885472f, -0.00845310f, -0.12821974f, 0.09166834f, 
    -0.14178978f, 0.05790456f, 0.01021418f, 0.00521559f, 0.09866975f, -0.03329161f, 0.00716363f, -0.03096516f, 
    -0.17603312f, 0.04034035f, -0.06270645f, 0.03577272f, 0.00900776f, -0.00772400f, 0.05060840f, 0.02901194f, 
    -0.01714164f, -0.08461680f, -0.06027796f, -0.00129540f, 0.25055605f, -0.03518197f, -0.06056574f, 0.04078851f, 
    0.02400519f, 0.09610219f, 0.05311842f, 0.01791818f, 0.01676776f, 0.06013871f, 0.07419173f, 0.11593323f, 
    0.17951573f, 0.09552450f, -0.13032639f, -0.09048390f, 0.07211951f, -0.00903816f, -0.05729526f, 0.02998408f, 
    -0.03675884f, -0.01190959f, -0.00218725f, 0.11797792f, 0.05355438f, 0.00192925f, 0.21079437f, -0.15152483f, 
    -0.14698440f, 0.03478556f, -0.01392171f, 0.02367883f, -0.05151169f, 0.03261479f, -0.02303435f, -0.03590545f, 
    0.25128856f, -0.06175717f, -0.13224162f, -0.06141626f, 0.12024596f, 0.16336773f, 0.01638293f, -0.00156082f, 
    0.01807758f, 0.03326585f, 0.04839811f, -0.01670194f, -0.09893136f, -0.00759613f, -0.01154220f, -0.20422573f, 
    0.09984014f, 0.07220213f, 0.03146471f, -0.01336676f, 0.00836078f, -0.06650370f, 0.00296535f, -0.05875088f, 
    0.19048773f, 0.12294909f, -0.02127388f, 0.14604145f, -0.08022049f, 0.02975331f, 0.00017867f, -0.00450561f, 
    -0.09582478f, 0.00692774f, 0.06815167f, -0.01796467f, 0.02776177f, -0.00490119f, 0.06375623f, -0.18184713f, 
    0.08988961f, -0.01692962f, -0.00047110f, 0.03053702f, 0.02368082f, -0.12398762f, 0.11371545f, -0.03468857f, 
    0.18273540f, 0.05103843f, 0.12632363f, -0.04791287f, 0.08607285f, -0.06566237f, 0.02623543f, 0.08033984f, 
    0.14362508f, 0.13365743f, 0.07878900f, -0.01725863f, 0.05576880f, -0.00410906f, 0.16686495f, 0.07689800f, 
    0.02268360f, 0.03110117f, -0.05885742f, -0.00961524f, -0.02010438f, 0.04589438f, -0.03181279f, -0.00014088f, 
    0.09572788f, -0.03453466f, 0.08545779f, 0.22775660f, 0.10672609f, -0.01007170f, -0.04362259f, 0.07879350f, 
    0.09646995f, -0.01765392f, 0.07135279f, -0.08687513f, 0.20110787f, 0.12830026f, -0.15288273f, 0.03243435f, 
    -0.04239992f, -0.00693143f, 0.03242200f, 0.07326204f, 0.00905220f, 0.05958099f, 0.11644728f, -0.06828800f, 
    -0.15806054f, 0.02942538f, -0.10633005f, -0.08759544f, -0.01504233f, -0.03237223f, 0.00911081f, 0.08060641f, 
    -0.02414488f, 0.06384692f, 0.04126662f, 0.03224972f, -0.02036314f, -0.06889031f, 0.02624546f, 0.21358410f, 
    -0.02698244f, -0.03976246f, -0.03089452f, 0.00736290f, 0.05647670f, -0.05043026f, -0.03054688f, -0.02559776f, 
    0.25958940f, 0.06878090f, 0.07517472f, 0.07377953f, -0.02801756f, -0.05546107f, 0.03333593f, 0.00953453f, 
    -0.01437046f, 0.12283284f, 0.04539828f, 0.07419113f, -0.01204158f, -0.07666872f, 0.13598986f, 0.16805644f, 
    0.05365891f, -0.15163170f, -0.07905628f, 0.06670719f, 0.04686633f, 0.02205178f, -0.04756300f, -0.09601136f, 
    0.06519361f, 0.13680716f, -0.03860640f, -0.03687965f, 0.11690533f, 0.05685676f, 0.03000232f, 0.10802659f, 
    0.04134927f, 0.00300869f, 0.03075155f, 0.06523817f, 0.08191248f, 0.05295767f, -0.10294612f, -0.03197260f, 
    0.08974360f, -0.01053578f, 0.01597458f, -0.01786433f, -0.05162390f, 0.08539487f, 0.08863229f, -0.03982184f, 
    -0.27766433f, 0.11456045f, -0.02583431f, -0.03377848f, 0.04766640f, -0.00697137f, -0.07789721f, 0.11140918f, 
    0.06331506f, 0.08648219f, -0.00726291f, 0.04367270f, 0.05074448f, 0.02570871f, -0.01140224f, -0.04637443f, 
    0.07772443f, -0.01005650f, -0.04472536f, -0.00443650f, -0.09022693f, -0.02030765f, 0.04445796f, 0.06636935f, 
    0.21689832f, 0.06549658f, -0.05374606f, -0.05966875f, 0.05920485f, -0.00366425f, 0.07037878f, 0.04486868f, 
    0.04569815f, 0.06305814f, 0.00248823f, 0.04897178f, 0.07872523f, 0.12773973f, 0.05970730f, 0.01391004f, 
    0.02536213f, 0.05057256f, -0.00682202f, 0.06435089f, 0.00008420f, 0.25943443f, 0.04828262f, -0.06851533f, 
    0.12183628f, 0.03911043f, -0.03603979f, -0.00162487f, 0.06420595f, 0.04378728f, 0.10215268f, 0.06505845f, 
    0.00379735f, -0.14936581f, -0.00435802f, 0.01976306f, -0.20749722f, 0.07152831f, 0.10555803f, -0.11457222f, 
    0.13185799f, 0.01364695f, -0.05288032f, 0.12976846f, 0.01493255f, -0.04159965f, 0.11225558f, 0.04768782f, 
    -0.05743404f, -0.01678075f, 0.01112328f, -0.01845573f, -0.01214043f, -0.07414269f, 0.03944454f, 0.00815443f, 
    0.02002947f, 0.08080110f, 0.04207931f, 0.04613077f, -0.15741539f, -0.13874528f, -0.07577319f, 0.13863792f, 
    0.00524331f, 0.04353612f, -0.02118288f, -0.12296734f, 0.07297158f, -0.05258166f, 0.02199795f, -0.00978543f, 
    0.05509234f, 0.00406693f, -0.23742464f, -0.12347197f, 0.15069272f, 0.10481013f, 0.11949039f, 0.01244447f, 
    0.07739375f, 0.15504828f, 0.03936485f, 0.03539889f, -0.30634171f, -0.05764624f, 0.07720635f, 0.24016403f, 
    0.01239741f, 0.05785463f, -0.01976694f, 0.03072216f, 0.05556491f, 0.08811714f, -0.03204295f, 0.13018344f, 
    -0.11007455f, 0.00312047f, -0.01447732f, -0.13623652f, -0.01371780f, -0.01100072f, 0.02216059f, -0.08811293f, 
    -0.01320463f, -0.03252489f, 0.00060538f, -0.12853590f, -0.04341722f, -0.07267761f, 0.02319094f, 0.00881327f, 
    -0.07659999f, 0.09978747f, -0.01083670f, -0.06661522f, -0.05908683f, 0.05007849f, 0.02604547f, -0.01696209f, 
    0.10490880f, 0.04435004f, 0.08397306f, -0.20280783f, 0.09329052f, 0.05330681f, 0.07385895f, -0.05740882f, 
    0.09577543f, -0.04043441f, -0.00776767f, -0.01541116f, 0.05871030f, 0.07988720f, -0.01662356f, 0.15744099f, 
    0.00569209f, 0.09409811f, 0.04391502f, 0.04157773f, 0.09067743f, -0.03887261f, 0.06758348f, 0.01998908f, 
    0.15974784f, -0.11396630f, -0.13453694f, 0.11640689f, -0.05671090f, 0.08664299f, -0.04686059f, 0.03697805f, 
    0.06561387f, 0.13734680f, 0.01306890f, 0.13778313f, 0.12828836f, 0.05064741f, -0.12834583f, 0.11233529f, 
    -0.02243792f, 0.06644122f, 0.07471901f, 0.07627508f, 0.01309254f, -0.00238909f, 0.06690337f, -0.04448111f, 
    -0.10147142f, -0.00275401f, -0.29717708f, 0.01052243f, 0.10078777f, -0.13116537f, 0.05344234f, 0.05766646f, 
    0.01399754f, -0.05932443f, -0.04075171f, 0.03461382f, -0.07204392f, -0.04592662f, -0.20555907f, -0.10039750f, 
    0.14994326f, 0.01620809f, -0.01361102f, -0.09707976f, -0.04816202f, -0.07770275f, -0.04040551f, 0.12452564f, 
    0.25369367f, -0.03275774f, -0.09656452f, -0.03742020f, -0.03578267f, 0.02064125f, 0.00509300f, 0.02821902f, 
    0.16428091f, -0.04324790f, 0.13059075f, 0.06763650f, -0.04965852f, 0.00973298f, -0.10527723f, 0.04900550f, 
    0.04794393f, -0.02752843f, -0.00406945f, 0.12455493f, 0.01943025f, 0.10833497f, 0.12394325f, -0.05301654f, 
    -0.06916058f, -0.03060262f, -0.03397092f, -0.17326853f, -0.01898058f, 0.02169754f, -0.06209267f, -0.02857448f, 
    -0.06029754f, -0.07025056f, -0.05847309f, 0.13303761f, 0.02861976f, 0.10291795f, 0.00069264f, 0.13802543f, 
    0.08448791f, -0.04943369f, 0.01849928f, 0.10588883f, 0.08236156f, 0.00792951f, -0.00357997f, 0.16476442f, 
    -0.32213423f, 0.02673960f, -0.09737103f, -0.05401532f, 0.12982062f, -0.09214243f, -0.04904753f, 0.00910097f, 
    0.02298787f, -0.08087488f, 0.06559280f, 0.05446172f, 0.13076571f, 0.00493397f, -0.02435988f, -0.06356509f, 
    -0.01287643f, 0.00021045f, 0.08463777f, -0.02440943f, 0.01622918f, 0.07616503f, 0.03551133f, 0.15076101f, 
    0.29698163f, -0.05952103f, -0.05389014f, -0.01625494f, 0.05835204f, 0.03733376f, 0.00239129f, 0.05852399f, 
    -0.00566814f, -0.03111126f, 0.05736821f, 0.00872779f, 0.09022029f, 0.03353298f, -0.08855009f, 0.13817742f, 
    -0.05362641f, -0.08498062f, -0.06993502f, -0.06280924f, 0.05309891f, -0.06736403f, 0.02405439f, -0.11630036f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01200808f, 0.07593934f, -0.00310090f, 0.06243657f, 0.02301550f, 0.01095459f, -0.04832724f, 0.02541776f, 
    0.00936549f, 0.01849437f, -0.02724231f, 0.04724513f, 0.04739980f, 0.01443172f, -0.04502381f, 0.01753474f, 
    -0.00543418f, 0.04734260f, -0.02873220f, -0.02797619f, -0.08419063f, -0.08613594f, -0.00541685f, 0.06687584f, 
    -0.01226371f, -0.00510661f, 0.02584029f, -0.04059087f, 0.02417236f, 0.01863419f, 0.00305649f, 0.03083796f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.07300545f, 0.15204614f, 0.01064863f, -0.08182977f, -0.04764777f, -0.02032001f, -0.02902211f, 0.06558136f, 
    0.12821530f, -0.06732897f, -0.12413031f, -0.15230867f, -0.13348709f, -0.12326773f, 0.16077566f, 0.05704698f, 
    -0.05221560f, -0.05510523f, -0.10558525f, -0.07851794f, -0.02948410f, -0.00020483f, 0.02543181f, -0.01387801f, 
    -0.07789496f, -0.07800362f, 0.10624934f, 0.04400146f, 0.02323537f, 0.04389999f, -0.08810143f, -0.12606338f, 
    0.10229766f, 0.10345688f, -0.13184144f, -0.03088244f, -0.17923021f, -0.14499852f, 0.11857349f, 0.25828588f, 
    -0.16372217f, -0.28866860f, -0.06259973f, 0.06825878f, 0.04427971f, 0.34102315f, -0.15858783f, -0.04523686f, 
    -0.12847106f, -0.01388852f, 0.05978400f, -0.16374643f, 0.30454013f, 0.26027456f, 0.28499708f, -0.19616029f, 
    -0.10634629f, -0.01698540f, -0.06754360f, 0.07149233f, 0.01317449f, -0.18275081f, -0.01583585f, -0.10248649f, 
    -0.14212053f, -0.39604643f, -0.04478544f, 0.23436874f, 0.10040993f, 0.02357950f, -0.31805971f, -0.16631028f, 
    0.15289597f, 0.27357894f, -0.13215268f, -0.13100831f, -0.07494246f, -0.07371852f, 0.25607488f, 0.01377787f, 
    -0.00590683f, 0.20582977f, -0.10923708f, 0.06751529f, -0.02780090f, 0.13196672f, -0.16776636f, 0.10996767f, 
    -0.04856436f, -0.10984255f, 0.07052111f, 0.10422032f, -0.19120370f, 0.14159007f, -0.09337582f, 0.11822929f, 
    0.06492906f, -0.19744261f, 0.15831454f, 0.28208724f, 0.11755573f, 0.09764766f, 0.23256034f, 0.04953848f, 
    -0.16866891f, -0.13538881f, 0.00789264f, 0.47614181f, 0.09979739f, 0.03224398f, 0.00569274f, 0.05806825f, 
    -0.07087384f, 0.00338250f, 0.04665247f, -0.08036716f, -0.10669275f, -0.10612354f, -0.08036250f, 0.06833896f, 
    -0.10334964f, -0.12196726f, 0.03018344f, -0.08079162f, -0.28860798f, 0.12963855f, 0.28245962f, 0.12791678f, 
    0.04346498f, -0.09921480f, 0.15192920f, 0.04840221f, -0.07846953f, 0.14758572f, 0.25886449f, 0.04367863f, 
    0.10621963f, -0.09925403f, -0.09892307f, 0.02298025f, -0.03074104f, 0.08404989f, 0.05285229f, -0.14788702f, 
    0.01951775f, -0.15378270f, -0.03822515f, -0.04862762f, 0.38271102f, -0.04941374f, 0.22041397f, -0.19111338f, 
    0.10858193f, 0.11752195f, 0.11500733f, 0.10030335f, 0.13889453f, -0.04963179f, -0.23339163f, 0.09209080f, 
    0.02124632f, -0.16949263f, -0.13391595f, 0.27298427f, 0.04858313f, -0.08526456f, 0.10952561f, -0.29604691f, 
    -0.16459475f, 0.19741699f, -0.17723164f, 0.03460591f, 0.10352585f, -0.26864502f, 0.03492719f, 0.01550798f, 
    -0.00254110f, 0.31873590f, 0.13147381f, 0.00735910f, -0.24192464f, 0.09361236f, -0.20953277f, 0.22675425f, 
    -0.13647506f, 0.03063563f, 0.13448787f, 0.09470998f, 0.10221873f, -0.05569718f, -0.12316897f, 0.32014197f, 
    0.12201207f, -0.30661330f, -0.07804536f, 0.13096774f, 0.17071818f, -0.12969953f, 0.03708426f, 0.44609672f, 
    0.14318521f, 0.21831883f, -0.06036270f, 0.03649664f, -0.07659603f, 0.26365176f, 0.29425579f, 0.11769632f, 
    -0.14048812f, -0.10790108f, -0.00619746f, 0.12161711f, -0.06394875f, 0.08099341f, 0.37097242f, 0.00179538f, 
    -0.01559031f, 0.14698027f, 0.02784825f, 0.09160758f, -0.02971575f, 0.12524395f, 0.07801645f, -0.10898384f, 
    0.14186184f, 0.06538668f, -0.09308858f, 0.13903652f, 0.13870898f, -0.00008867f, -0.15685184f, 0.07674868f, 
    -0.16847844f, 0.11889302f, 0.10111930f, 0.14774588f, -0.29471120f, -0.01190609f, -0.27522296f, 0.13163528f, 
    0.16076626f, 0.21117385f, 0.11526740f, 0.16129386f, 0.21656093f, -0.44094330f, 0.04882766f, 0.26732785f, 
    -0.14819697f, -0.05062350f, 0.15504734f, 0.06978371f, -0.06756115f, -0.04298433f, -0.23513307f, 0.11580415f, 
    0.07541501f, -0.08857115f, -0.02030737f, -0.35118786f, 0.05238439f, -0.05804056f, -0.04925809f, 0.32895488f, 
    -0.02021409f, 0.09555956f, -0.15435866f, 0.20622443f, 0.23824582f, 0.27107394f, 0.37820745f, 0.08929700f, 
    -0.01168071f, -0.01570503f, -0.05589694f, -0.15009794f, -0.10052779f, 0.08149175f, -0.15262510f, 0.10888968f, 
    0.09484521f, 0.09107642f, 0.04547141f, -0.03259252f, 0.26884201f, 0.06694152f, -0.02620486f, -0.08110736f, 
    0.14416772f, -0.07979599f, 0.13156566f, -0.03704066f, -0.17012112f, -0.11628927f, -0.39350206f, 0.35912010f, 
    -0.11922690f, 0.20003523f, 0.13561247f, -0.06070710f, 0.28245792f, -0.00337253f, -0.29698026f, -0.11673642f, 
    -0.10998789f, 0.23433371f, -0.03805055f, -0.07479061f, -0.20429981f, -0.15156437f, -0.38231054f, 0.05689661f, 
    0.00502717f, 0.07366846f, -0.15059659f, 0.09177741f, -0.13143672f, -0.12858786f, 0.19627719f, 0.18919310f, 
    0.16869691f, 0.00613941f, -0.10243638f, 0.13730811f, 0.04754730f, -0.03303821f, 0.11880063f, 0.22635317f, 
    -0.15544027f, -0.20907103f, -0.10454334f, -0.28185880f, 0.15892954f, -0.00922541f, -0.24781014f, -0.15466909f, 
    -0.11811277f, 0.23045009f, -0.00400420f, -0.11003775f, -0.08694917f, 0.23881936f, -0.02232197f, -0.19353008f, 
    0.05785418f, 0.08689361f, -0.04452903f, -0.14148317f, 0.06931769f, 0.04604840f, 0.02921800f, 0.07179449f, 
    0.06647210f, -0.17407358f, 0.17037007f, -0.02579348f, 0.13648096f, 0.00026283f, -0.12045223f, -0.10859159f, 
    0.13434252f, -0.01636052f, -0.01301029f, 0.15387598f, -0.04125774f, 0.03155879f, -0.14878327f, 0.10914369f, 
    0.04258123f, -0.09472782f, -0.13972694f, 0.00907302f, 0.09712601f, 0.17366718f, -0.14071657f, -0.08490729f, 
    -0.14918260f, -0.13160168f, 0.03361502f, -0.14920904f, -0.09714454f, 0.09620698f, -0.07882864f, 0.04762463f, 
    -0.12366622f, 0.43492556f, 0.00874818f, 0.19092461f, 0.04628572f, -0.02149844f, -0.07047905f, 0.33052632f, 
    -0.07587215f, -0.07804321f, 0.18499179f, 0.19046289f, 0.24440365f, 0.35899267f, -0.23745298f, -0.15499285f, 
    0.08143021f, -0.15693817f, 0.09756331f, -0.05344136f, -0.34990722f, -0.28738597f, 0.12868378f, 0.00771786f, 
    -0.10171904f, -0.16010112f, -0.13686283f, 0.11744932f, 0.13650493f, -0.03270224f, 0.33719018f, -0.05868985f, 
    -0.06193439f, -0.12954254f, -0.06268876f, -0.14695928f, -0.10387181f, 0.01004935f, -0.03138259f, -0.00147575f, 
    -0.12148612f, -0.03385108f, 0.04499288f, 0.04551866f, -0.16452074f, -0.03665821f, -0.06409058f, 0.16619998f, 
    -0.15231903f, 0.09427333f, -0.05583062f, 0.13469915f, -0.01283934f, -0.09974353f, -0.10301476f, -0.12869702f, 
    -0.04274887f, -0.15487982f, -0.13486445f, 0.13567473f, 0.01216508f, 0.09257043f, -0.08859398f, 0.03817792f, 
    -0.09479708f, -0.01398285f, -0.01573934f, -0.04956924f, -0.02346323f, 0.03401177f, -0.27123642f, -0.06905367f, 
    -0.06322682f, 0.06093182f, -0.02906588f, 0.19207862f, 0.21483807f, 0.30566677f, 0.49030334f, -0.09244453f, 
    -0.07415733f, -0.09319668f, 0.00560696f, 0.14262865f, -0.37129110f, 0.04250761f, 0.14514112f, 0.22402099f, 
    -0.06736498f, 0.02555628f, -0.16325247f, 0.05788796f, 0.07944261f, 0.03836930f, -0.06242512f, -0.10663746f, 
    -0.00236284f, -0.03699002f, 0.03941114f, -0.15557414f, 0.03044721f, -0.07611070f, 0.00836807f, -0.14647083f, 
    -0.08854085f, -0.05685082f, 0.10952099f, -0.19332440f, 0.12590221f, 0.03015475f, -0.07511410f, 0.13859814f, 
    -0.10678410f, -0.12519446f, 0.16091938f, -0.15457502f, 0.09686874f, -0.03007307f, 0.03650980f, -0.03818492f, 
    0.04001807f, 0.01762153f, 0.08766833f, 0.10221709f, -0.02587128f, -0.13674547f, 0.15493777f, -0.06283269f, 
    -0.11759146f, 0.01919261f, -0.06942347f, -0.10824736f, 0.09368909f, -0.03373851f, 0.25296631f, -0.22635555f, 
    -0.05287953f, -0.10436283f, 0.09107468f, 0.04674281f, -0.09261683f, -0.25164390f, 0.20866944f, -0.11717851f, 
    0.04256079f, 0.27288690f, 0.13548487f, -0.12381902f, -0.07174277f, -0.26864272f, -0.14815886f, 0.25665709f, 
    -0.17026050f, -0.09691559f, 0.10265522f, -0.13470952f, 0.21191005f, -0.14253229f, -0.26940960f, 0.29013395f, 
    -0.07839628f, -0.02933475f, 0.05691447f, 0.44019461f, -0.00550958f, -0.01678870f, 0.19266863f, -0.25649837f, 
    0.00539836f, 0.11285021f, 0.02782420f, 0.22869372f, -0.02797125f, -0.09055747f, 0.07248284f, 0.14627935f, 
    -0.14919531f, 0.23685086f, -0.04316863f, 0.16115350f, -0.36841476f, 0.07827073f, -0.06261781f, -0.13313456f, 
    0.10388839f, -0.05357460f, 0.01773331f, -0.14861582f, 0.18913718f, 0.01294081f, -0.06776100f, -0.18571381f, 
    -0.05473854f, 0.35254821f, -0.08731361f, 0.16895002f, 0.02685815f, 0.00402270f, -0.09193973f, 0.09329584f, 
    0.12222452f, -0.12434413f, -0.01598799f, -0.17203909f, -0.15380299f, 0.07747580f, -0.06146058f, 0.01127747f, 
    -0.08467804f, 0.02294130f, 0.03302387f, -0.13070396f, 0.07796135f, 0.23777957f, 0.40794402f, -0.24185587f, 
    -0.14701645f, -0.03340324f, 0.07137928f, -0.14449812f, 0.35876814f, 0.05943632f, 0.07875795f, 0.10258611f, 
    0.13869339f, 0.29950717f, -0.16564512f, -0.22202097f, -0.00718200f, -0.11092033f, -0.29287702f, -0.14732519f, 
    0.07279329f, 0.12891293f, -0.14725839f, -0.07744220f, -0.06866510f, -0.07502831f, 0.12745784f, -0.11582022f, 
    0.02086587f, -0.13148673f, -0.11307329f, 0.13762116f, 0.06479466f, -0.12561454f, 0.22418515f, 0.21488874f, 
    0.15016416f, -0.03623896f, 0.06991488f, 0.02600473f, 0.20993499f, -0.08727957f, -0.39653051f, 0.30811584f, 
    -0.08942430f, 0.19693023f, 0.10305625f, 0.02426634f, 0.10379917f, -0.05608681f, -0.04985004f, -0.28005815f, 
    -0.11708782f, 0.09263476f, -0.00975065f, -0.24749380f, 0.31117409f, 0.14091790f, 0.31712806f, -0.09878057f, 
    -0.01104570f, -0.05610212f, -0.11714278f, -0.14982282f, -0.02142114f, -0.15209068f, -0.03479417f, 0.23678757f, 
    -0.09782396f, -0.06369832f, 0.00558639f, -0.05923375f, -0.07873166f, -0.05937748f, 0.19430350f, -0.04342417f, 
    0.09489436f, 0.31106716f, -0.11626721f, 0.17642382f, -0.09482368f, 0.12934214f, 0.25357667f, -0.03297861f, 
    0.08350605f, -0.09113299f, 0.16714329f, 0.35142735f, -0.10058905f, -0.28115618f, -0.14835984f, 0.17743237f, 
    -0.13953079f, -0.03757604f, -0.01366746f, -0.08401704f, 0.49654388f, -0.00106616f, -0.21650016f, 0.18419494f, 
    -0.10509332f, 0.11126675f, -0.17981222f, 0.14572623f, 0.04060554f, -0.10689038f, 0.22678582f, -0.08099861f, 
    -0.08665982f, 0.02510280f, 0.06352010f, 0.10248311f, -0.07351797f, 0.04420789f, -0.09627055f, -0.06298818f, 
    0.10097744f, -0.13214958f, -0.07894497f, -0.08241918f, -0.18053143f, -0.07777603f, 0.15443225f, -0.14735647f, 
    -0.00307227f, -0.15685779f, 0.13182491f, 0.12767610f, 0.06321823f, 0.05909053f, 0.05230705f, -0.15721749f, 
    -0.02344005f, 0.02083626f, -0.15658081f, 0.04065236f, -0.09398134f, -0.00202880f, -0.14409660f, -0.10873193f, 
    0.05832026f, 0.33506614f, 0.09158934f, 0.26947284f, -0.06363784f, -0.08117533f, -0.01826631f, -0.27956718f, 
    0.08523405f, -0.24693756f, 0.12107390f, -0.18443209f, 0.07604425f, 0.07645078f, -0.07910013f, -0.17513146f, 
    -0.16341376f, 0.21245466f, 0.03764019f, -0.14876597f, -0.42227820f, -0.01647752f, -0.01818646f, -0.17430399f, 
    -0.05236811f, 0.10364374f, -0.10809419f, -0.10425124f, 0.31886393f, -0.17369708f, -0.17359018f, 0.36490411f, 
    0.12696028f, -0.02860707f, 0.04300277f, -0.05099965f, 0.10609732f, 0.12488902f, -0.59160346f, -0.14050528f, 
    -0.06093791f, 0.29897159f, -0.00535916f, 0.23119980f, -0.05417669f, 0.12014998f, -0.32099438f, -0.15529454f, 
    0.00887362f, 0.06244486f, -0.05642873f, 0.03857725f, 0.01167522f, -0.09753483f, -0.10360515f, 0.13697910f, 
    0.04698043f, -0.00772190f, -0.13218080f, 0.04128055f, -0.21271910f, -0.08082827f, -0.04245092f, 0.08523697f, 
    -0.16898344f, 0.05262797f, -0.05280368f, 0.09173325f, -0.16317293f, 0.08000329f, -0.22941662f, 0.03536089f, 
    -0.04641679f, 0.28461221f, 0.06918984f, -0.49848124f, 0.02707627f, -0.02472414f, -0.06505732f, -0.15145171f, 
    -0.06783108f, 0.09843746f, -0.17022128f, -0.08400768f, 0.21056460f, 0.23112796f, 0.12630816f, -0.14947745f, 
    0.04492161f, -0.04128442f, 0.00805400f, 0.14185867f, -0.02182956f, -0.01462453f, 0.28845564f, 0.02142511f, 
    0.01284365f, 0.44650170f, -0.14708494f, -0.13336894f, 0.02579762f, -0.07647583f, 0.26176745f, -0.05852835f, 
    -0.03159779f, -0.06328709f, -0.11706765f, 0.10625316f, 0.13711031f, 0.10784616f, 0.08738472f, 0.16842790f, 
    0.07692046f, -0.11297423f, -0.11872297f, 0.13357660f, -0.26115125f, -0.11330073f, 0.07617334f, 0.15681759f, 
    0.16320452f, -0.07911381f, 0.05223976f, -0.02789361f, 0.00656385f, 0.11877134f, 0.11080398f, 0.00270992f, 
    -0.04186136f, 0.11624450f, 0.01412124f, -0.15377872f, -0.02853090f, 0.02730867f, 0.27387205f, 0.07859402f, 
    -0.00092211f, 0.13101484f, 0.13362616f, -0.31246108f, 0.25991443f, -0.09076798f, -0.15286395f, 0.03476912f, 
    0.08327410f, 0.14300261f, -0.08684406f, -0.10461842f, 0.17275633f, 0.38339603f, -0.31057069f, -0.16247474f, 
    0.08859457f, -0.01282746f, -0.10987256f, -0.02478096f, 0.29024523f, 0.03520276f, 0.29941103f, -0.12291536f, 
    -0.14847361f, -0.08704381f, 0.15323476f, -0.12487079f, 0.01989297f, 0.07812035f, -0.20333993f, -0.19176075f, 
    -0.07372693f, 0.12426939f, 0.06126522f, 0.19826753f, -0.06684758f, -0.13651049f, -0.12824377f, -0.00669144f, 
    -0.13181780f, 0.16045916f, -0.13077252f, -0.17371173f, 0.41805688f, 0.40282148f, -0.20328470f, 0.21748795f, 
    -0.09871317f, -0.17320380f, -0.04785395f, 0.06839895f, -0.08369739f, -0.08777179f, -0.15496138f, 0.12512904f, 
    -0.13870826f, -0.00054468f, 0.03918615f, 0.37906528f, 0.02232999f, 0.05771494f, 0.04373919f, 0.41420549f, 
    -0.14438057f, 0.14469339f, -0.07523594f, -0.03508244f, -0.11752525f, 0.19608659f, -0.17479233f, 0.06769025f, 
    0.10276916f, -0.03968701f, 0.17429323f, -0.10952178f, 0.00996995f, -0.45635214f, 0.20972840f, 0.10643152f, 
    0.03231077f, -0.16767395f, 0.02641352f, -0.07945060f, -0.26451010f, 0.13853316f, 0.17304438f, 0.01577561f, 
    -0.15118346f, 0.12708229f, -0.15008321f, -0.10732456f, 0.17043690f, -0.17285851f, 0.07385869f, 0.05834346f, 
    0.16089633f, -0.14015406f, -0.06105642f, -0.01696850f, -0.10155214f, 0.04138266f, -0.17560592f, 0.09688775f, 
    0.06316406f, -0.06777514f, -0.12836415f, -0.15616745f, 0.01543786f, -0.11046114f, -0.14118850f, -0.03915794f, 
    0.04687383f, 0.16434556f, -0.07520872f, 0.10147838f, -0.10661384f, -0.14403984f, 0.13377541f, 0.07257643f, 
    0.10884667f, -0.22959632f, 0.15199378f, 0.07341807f, -0.09537982f, -0.07221857f, 0.31947291f, -0.21361704f, 
    -0.04219712f, 0.02583156f, 0.09314311f, 0.35017350f, 0.05723040f, 0.16363446f, 0.54423654f, 0.05723279f, 
    -0.07663135f, -0.08100955f, 0.13596982f, -0.03582577f, 0.20022865f, 0.37916806f, 0.17669542f, 0.13877514f, 
    -0.13133162f, -0.17026109f, 0.11132178f, 0.09081151f, 0.24838276f, 0.05662699f, -0.34993926f, -0.18284360f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.02336160f, 0.10942823f, -0.12003163f, -0.02979982f, 0.05666287f, 0.07637446f, -0.00590458f, 0.10580303f, 
    0.16460869f, -0.03697230f, -0.13655503f, -0.02870351f, 0.19542228f, -0.16337128f, 0.14771877f, -0.10016067f, 
    0.15316747f, 0.04278601f, 0.18569376f, 0.03821422f, 0.22186413f, 0.13285179f, 0.08236124f, 0.05791917f, 
    0.27253106f, 0.04659831f, -0.04020942f, 0.08315329f, -0.03393488f, 0.05193337f, 0.06976236f, 0.06201126f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.04337619f, -0.42420405f, -0.00240270f, 0.05754947f, -0.21907519f, -0.02999974f, 0.38632351f, -0.48862836f, 
    0.27754587f, -0.15557703f, -0.25270501f, -0.14238288f, -0.18363230f, -0.16405191f, 0.29438776f, 0.15656145f, 
    -0.10243762f, 0.10183802f, -0.24664478f, -0.45599052f, 0.20414096f, -0.38240772f, -0.10552609f, -0.48968136f, 
    -0.61642051f, 0.12756264f, -0.10324487f, 0.03538064f, -0.24568729f, 0.06888973f, -0.16888198f, 0.23746696f, 
    0.02261440f, 0.20155172f, 0.35140425f, 0.30902570f, 0.15209818f, 0.16040817f, 0.11723989f, 0.02159866f, 
    -0.03242381f, 0.17455456f, 0.00749298f, -0.09116546f, -0.12532778f, 0.12353671f, 0.00391365f, 0.00289178f, 
    -0.13800901f, 0.21111451f, -0.18322916f, -0.32478529f, -0.15534237f, -0.17563833f, -0.00075470f, 0.06937029f, 
    0.43478248f, -0.31072333f, -0.34264186f, -0.42270666f, 0.14768283f, 0.01187155f, -0.10900649f, 0.14135243f, 
    0.04578789f, -0.37470758f, -0.04760747f, -0.32371628f, -0.46588850f, 0.22609109f, -0.12083234f, 0.03044316f, 
    0.08641050f, -0.15866444f, -0.09638479f, -0.03973161f, -0.71521521f, 0.04543860f, -0.13780575f, 0.16854295f, 
    0.39696628f, 0.00326242f, -0.15930249f, 0.21166195f, -0.05087242f, -0.00924194f, -0.07890088f, -0.03516268f, 
    -0.20311850f, -0.03724836f, -0.21148546f, 0.08505248f, 0.30523729f, -0.45995644f, -0.08116484f, 0.25407064f, 
    0.14679037f, 0.00363916f, -0.68412399f, 0.07073368f, -0.34234473f, 0.11999104f, 0.00437764f, -0.34803608f, 
    -0.43162751f, -0.64157128f, 0.08666185f, 0.04623674f, 0.16146882f, -0.16471688f, -0.12941091f, -0.12652130f, 
    -0.40277350f, 0.36234370f, 0.17632838f, -0.43092763f, 0.06071471f, -0.02602680f, -0.13142620f, 0.14779979f, 
    -0.05893567f, 0.18427582f, 0.14761934f, -0.09233588f, -0.42129546f, 0.02440553f, -0.00439248f, 0.05276312f, 
    0.02977203f, 0.05400111f, -0.01544314f, -0.20186599f, -0.47610408f, -0.06441290f, 0.09331093f, -0.11151447f, 
    0.17053252f, 0.25074351f, 0.21547596f, 0.03351121f, 0.10257436f, -0.03841415f, -0.21002190f, 0.08555353f, 
    -0.48625797f, 0.06140811f, 0.04827822f, -0.44849312f, -0.05821360f, -0.23027465f, 0.03248617f, -0.05282638f, 
    0.09736649f, 0.36265388f, -0.20749585f, 0.31445771f, 0.07588000f, 0.02375794f, 0.10827290f, -0.31152031f, 
    -0.01795650f, 0.03809802f, -0.55064231f, 0.26732105f, -0.01247036f, -0.08579563f, 0.06320419f, 0.12891904f, 
    0.03811474f, 0.20958531f, -0.25550032f, -0.00963973f, 0.24660999f, -0.07578151f, 0.10791176f, -0.16276523f, 
    -0.21392764f, -0.37156424f, -0.38699913f, 0.14866000f, 0.12026425f, -0.04266664f, -0.10529130f, -0.41768456f, 
    0.21939793f, -0.06906257f, 0.19096622f, -0.24167192f, -0.10169581f, 0.31083220f, 0.03896653f, -0.16912054f, 
    0.17473617f, -0.40245426f, -0.76077044f, 0.15353866f, -0.41555241f, 0.10075914f, -0.45644453f, -0.36520824f, 
    0.13321467f, -0.03858547f, -0.24184108f, 0.00610671f, -0.03627683f, 0.00230056f, 0.00228925f, 0.17572600f, 
    -0.01662645f, 0.10257356f, -0.35139140f, -0.34358785f, 0.19896626f, 0.34422764f, 0.11370296f, -0.16663985f, 
    -0.41698477f, -0.28310123f, 0.27201980f, 0.29778773f, 0.19301184f, -0.28433871f, 0.08651945f, 0.07527909f, 
    -0.01580926f, 0.41241547f, -0.07803643f, -0.09471589f, 0.36048821f, -0.42744756f, 0.11736771f, -0.09222887f, 
    0.04914151f, -0.36579627f, 0.14801852f, 0.17057936f, 0.04629056f, -0.04957784f, -0.27328274f, 0.01242371f, 
    0.00029372f, -0.18464145f, 0.21436691f, -0.16388772f, -0.27829611f, 0.02684566f, -0.16676690f, 0.01794543f, 
    -0.11181341f, -0.13627736f, -0.03643947f, 0.11888920f, 0.23507552f, -0.00305195f, -0.01355701f, 0.13459034f, 
    -0.06365276f, -0.10223521f, 0.08278195f, 0.00001941f, -0.18866757f, 0.18177411f, -0.19761041f, 0.36330155f, 
    -0.56172878f, 0.06977700f, -0.32353497f, 0.02214343f, -0.32163829f, 0.16551983f, -0.40256348f, 0.01572498f, 
    0.04693911f, -0.12817167f, -0.13921405f, -0.08511920f, 0.12926312f, 0.22436070f, -0.01352884f, -0.28355768f, 
    0.19997579f, 0.32580090f, -0.35308757f, -0.17115936f, 0.12022786f, 0.35020795f, -0.08856533f, -0.20245045f, 
    0.11408258f, -0.11919823f, -0.08753968f, -0.57152379f, 0.00451658f, 0.07660818f, -0.35693318f, -0.36160603f, 
    0.14083144f, 0.05648760f, -0.16925552f, 0.06460628f, -0.00887389f, -0.15592445f, 0.22661030f, 0.12877697f, 
    -0.08397408f, -0.31012323f, 0.00945035f, 0.42119494f, 0.23225045f, -0.43620563f, -0.16851729f, 0.26582974f, 
    0.05732084f, 0.17426823f, 0.17421426f, -0.01129802f, 0.00434101f, -0.42615348f, -0.17837718f, 0.04117614f, 
    0.11533090f, -0.20539846f, -0.31020182f, -0.06651219f, -0.26651949f, -0.01928472f, -0.07320925f, 0.33674330f, 
    0.06816269f, -0.41700113f, -0.24862455f, 0.08627148f, 0.11840364f, 0.16280061f, 0.06074591f, -0.06355852f, 
    0.31027395f, 0.09635782f, 0.18957049f, 0.31568447f, -0.16232809f, -0.01622029f, 0.15431558f, 0.25038806f, 
    0.04141457f, -0.62379402f, 0.03695504f, -0.41356486f, -0.02933880f, 0.11811907f, 0.08107585f, 0.00997382f, 
    -0.06266172f, -0.60755551f, -0.06511360f, 0.25178060f, -0.64121592f, 0.25882092f, -0.49841017f, -0.13899708f, 
    -0.27770594f, 0.04487031f, 0.31725326f, 0.03684440f, 0.04191047f, -0.12297749f, -0.21549334f, 0.17231132f, 
    0.27051961f, 0.17586136f, -0.16581427f, -0.36259890f, 0.15235339f, -0.11569217f, -0.04243863f, 0.37589830f, 
    -0.47682738f, -0.04500155f, -0.03383889f, -0.03406242f, -0.45004690f, 0.12950587f, 0.01400745f, -0.24186881f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.10243595f, 0.02986222f, 0.14735040f, 0.00183480f, -0.04987950f, -0.16134903f, -0.00869782f, -0.22620028f, 
    0.14279230f, 0.04208487f, -0.12634863f, -0.06259796f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
