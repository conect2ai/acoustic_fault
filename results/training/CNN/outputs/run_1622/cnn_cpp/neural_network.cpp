#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.13265225f, -0.06946621f, -0.13014425f, 1.17537856f, -0.67279583f, 0.79724824f, -0.08866503f, 0.14577581f, 
    -0.00203972f, 0.67700958f, -0.90510225f, -1.05254185f, -0.50907236f, -0.55475032f, 0.36551312f, -0.80641979f, 
    -0.60527557f, -0.89666015f, -0.82459778f, -0.03197104f, 0.83685642f, -0.05770253f, 1.08929229f, -0.96073115f, 
    -0.59531814f, 0.48259306f, 0.10315589f, -1.12405348f, -1.38270044f, 0.05013614f, -1.29605949f, -1.60975802f, 
    -0.32759818f, 0.19442511f, 0.44997275f, 0.61914366f, 1.10842478f, -1.72021520f, -1.98906541f, 0.87284261f, 
    1.10201061f, 0.28172082f, 0.00101763f, 0.02006018f, -0.07579052f, 0.89790571f, 0.35707748f, 0.00797793f, 
    -0.58072233f, 0.49432099f, 0.71097142f, 0.08088808f, 0.64443761f, -0.24327318f, -1.93283951f, -0.32942376f, 
    0.74305195f, 0.36764008f, 0.28107142f, 0.91090733f, -0.14616384f, 0.20439216f, -0.18528378f, 0.11507684f, 
    0.20186543f, -0.62633353f, -0.64864236f, -0.42767203f, -0.09627681f, 0.67446584f, 0.30183128f, 0.67276645f, 
    1.06884003f, -0.03677621f, -0.34978464f, 0.20229904f, 0.59664935f, -1.24200356f, 0.93766981f, -0.33974397f, 
    -0.44890344f, 1.05390716f, 0.93006057f, 0.64657491f, -0.32314846f, -0.47773454f, -0.07360823f, -0.41138956f, 
    -0.67416263f, -0.19996719f, -0.51323342f, 0.41072524f, 0.08789942f, 0.29725182f, -0.13330179f, -0.54673421f, 
    0.20281920f, 0.52552968f, 0.51754653f, -1.01016164f, 0.66703993f, 0.60706395f, -1.19730842f, -0.97909665f, 
    -1.40587664f, -0.20718682f, -0.96406710f, -0.74650449f, -1.36623025f, 0.42125332f, 0.78746861f, -0.22694023f, 
    0.85814780f, 0.36846948f, 0.10006371f, -0.48868805f, -0.42402473f, 0.11017943f, -1.07311296f, -1.03647768f, 
    -0.28219113f, 0.33885893f, 0.50594974f, 0.39461783f, 0.96065414f, 0.02337319f, -0.56606728f, -1.28568566f, 
    -0.18131554f, -0.94285411f, -0.93828499f, -0.54682118f, -0.02344641f, -0.49196631f, -0.61416471f, -1.53939760f, 
    -0.63266748f, -1.15942526f, 0.57262248f, -0.62234664f, 0.52833128f, -0.31789589f, -0.78255296f, -0.40024203f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.12923078f, -0.43220773f, 0.35002089f, 0.46226487f, 0.50496101f, 0.41048703f, 0.03793095f, 0.25287947f, 
    0.48212901f, 0.24897124f, -0.14366876f, 0.28950736f, 0.51673633f, 0.09062883f, -0.41266435f, 0.03199775f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.10186544f, -0.02065755f, 0.06093502f, -0.00305490f, 0.09266383f, -0.03257004f, 0.04793951f, -0.00743626f, 
    0.03803684f, 0.16106203f, -0.17021765f, -0.09384052f, 0.13700622f, -0.04634839f, -0.03113228f, 0.05563463f, 
    0.07502698f, -0.07755426f, 0.01027832f, -0.07182254f, 0.37441051f, 0.15309456f, 0.34469688f, -0.12238006f, 
    -0.26701221f, 0.21176958f, 0.08578227f, 0.15231398f, -0.00854093f, 0.16186087f, 0.00934680f, -0.04669281f, 
    0.03850102f, -0.13314858f, -0.24602710f, 0.11047355f, -0.21263783f, -0.13261674f, 0.16238812f, 0.27799299f, 
    0.24018551f, -0.21292813f, -0.06142461f, -0.35591775f, -0.12376453f, -0.22224794f, -0.33483899f, 0.09658533f, 
    0.00752755f, -0.07313593f, -0.11240949f, -0.17854348f, -0.14865683f, -0.41109395f, -0.42167249f, -0.27917296f, 
    -0.10624847f, -0.16396323f, -0.09670341f, -0.03497510f, 0.35777390f, 0.57651514f, 0.24137217f, -0.62593150f, 
    -0.19649675f, -0.05703019f, 0.04649934f, 0.01343970f, 0.02555795f, 0.01126265f, 0.07139526f, -0.12508489f, 
    0.03168869f, 0.06243753f, 0.05692441f, 0.02764434f, -0.10737451f, -0.01016821f, -0.05032643f, -0.05231185f, 
    0.54436642f, -0.23020282f, -1.20547688f, 0.11699948f, -0.01776911f, 0.30205971f, 0.06751039f, 0.02238764f, 
    -0.22150938f, 0.05310265f, -0.15182297f, -0.07321011f, -0.24099450f, -0.03135172f, -0.03933322f, 0.02377902f, 
    0.13190331f, -0.07080614f, -0.04086365f, 0.03180516f, -0.19414802f, -0.12494047f, -0.03836301f, 0.02008617f, 
    0.03037856f, 0.00371108f, -0.00017651f, -0.01455236f, 0.05364813f, -0.01032908f, -0.11654460f, 0.14675751f, 
    -0.14301610f, -0.05936451f, -0.03019883f, 0.08924492f, -0.27744097f, 0.00873442f, -0.04791551f, -0.06659900f, 
    0.19475991f, -0.46284255f, 0.39175129f, -0.29773891f, 0.01562076f, -0.00736363f, 0.14936586f, 0.15817671f, 
    0.09458978f, -0.08458461f, -0.06223778f, -0.14867072f, -0.06218330f, -0.04488894f, -0.18328856f, 0.00959928f, 
    0.01807395f, 0.04677204f, 0.01043348f, -0.00710207f, 0.33382633f, 0.27747923f, 0.05079192f, -0.12929825f, 
    -0.09737401f, -0.06116419f, -0.00986627f, 0.05924036f, -0.00314540f, -0.08040024f, 0.07432027f, 0.14769693f, 
    -0.01549763f, -0.02756480f, 0.02389805f, -0.12295645f, -0.07923304f, -0.04881251f, -0.01303720f, -0.14640057f, 
    -0.34986147f, -0.49412584f, -0.50886136f, -0.16861975f, -0.17543693f, -0.28151950f, -0.09200157f, -0.18440138f, 
    -0.11187867f, 0.09934950f, -0.25739211f, 0.05567683f, 0.06636026f, -0.06970578f, -0.02284783f, -0.22761196f, 
    -0.23890118f, -0.19110215f, -0.52702332f, 0.01621471f, -0.97706288f, 0.17552085f, -0.00382357f, 0.06035889f, 
    0.26255620f, 0.09056287f, -0.02566561f, -0.04345571f, 0.06979763f, 0.03283040f, 0.10003554f, -0.01115245f, 
    0.06235658f, 0.10770331f, 0.03313887f, 0.18652894f, 0.29408649f, -0.11776917f, 0.03172939f, -0.09298443f, 
    0.10661042f, 0.05773394f, -0.00376982f, 0.04131104f, -0.01458406f, 0.03020821f, 0.06548598f, 0.10089420f, 
    0.01658701f, 0.13078396f, 0.03923800f, 0.13948496f, -0.11728452f, -0.07860807f, -0.15789808f, -0.07018978f, 
    -0.06114394f, 0.00225956f, -0.11515277f, 0.01202061f, 0.08769386f, 0.45453793f, 0.04622053f, -0.55278409f, 
    -0.08698659f, -0.25889608f, 0.02393720f, -0.26809543f, 0.07299379f, 0.10308995f, 0.00607002f, -0.07510609f, 
    -0.01242469f, 0.07580507f, 0.01342684f, -0.09466075f, -0.05858478f, 0.09123737f, -0.12994412f, 0.01777385f, 
    -0.07634719f, -0.74245691f, 0.20116204f, -0.30478615f, -0.12676063f, -0.14437385f, -0.01493525f, 0.04997538f, 
    0.15103161f, -0.01273120f, -0.12512065f, 0.01081798f, -0.09895378f, -0.03150854f, -0.00543333f, -0.15483671f, 
    -0.09039114f, 0.02274236f, -0.23385099f, 0.13494569f, 0.39747295f, 0.20538437f, -0.19061865f, 0.00988659f, 
    -0.02507708f, 0.19879712f, -0.01520197f, 0.06168653f, 0.02520602f, -0.14039239f, -0.09130157f, -0.03578918f, 
    -0.13485040f, 0.02316819f, 0.01613554f, 0.01437349f, -0.05718105f, -0.04996933f, 0.04153457f, 0.06258874f, 
    0.67185444f, 0.37547830f, 0.20069756f, -0.56830937f, 0.03569981f, 0.29320392f, 0.25431043f, 0.21028545f, 
    -0.01482287f, 0.08002310f, 0.02835222f, -0.02257711f, -0.10283145f, -0.08872768f, -0.10438781f, 0.05771672f, 
    -0.11905254f, -0.09884986f, 0.05129654f, 0.14311185f, 0.64084387f, 0.31148729f, 0.19391736f, -0.51584947f, 
    -0.14358671f, 0.02120869f, 0.26594141f, 0.05464521f, 0.04437109f, -0.01696647f, -0.00589597f, 0.00719213f, 
    -0.00144560f, -0.05097778f, 0.06588111f, 0.03978632f, 0.00846936f, -0.01183668f, -0.16943365f, -0.05031336f, 
    0.16492845f, 0.06814718f, -0.02218489f, -0.05338972f, 0.07943165f, -0.08027682f, -0.07983855f, -0.03339254f, 
    -0.02348173f, -0.08447831f, -0.13100018f, 0.09390808f, -0.08145470f, -0.17934670f, -0.07915238f, -0.15876782f, 
    0.00273087f, 0.05600429f, -0.00764308f, -0.06114597f, 0.30970529f, 0.68722641f, 0.16593775f, 0.21911044f, 
    -0.30829737f, 0.02217894f, -0.01879697f, 0.11039956f, -0.20968577f, -0.08722202f, 0.01192585f, 0.00250872f, 
    -0.01578898f, -0.00604337f, 0.08592268f, -0.32247633f, -0.27172789f, 0.06289592f, -0.19238825f, -0.11662206f, 
    0.13005868f, -0.19991601f, 0.02722829f, 0.04867916f, 0.38145480f, -0.12411815f, 0.23232244f, 0.02548780f, 
    0.07775948f, 0.06643089f, 0.21269083f, 0.08292872f, 0.13861607f, 0.11029402f, -0.12541345f, -0.06478923f, 
    0.07806733f, 0.01923589f, -0.08707135f, -0.27244240f, -0.66784853f, 0.22398297f, -0.31912899f, 0.24643749f, 
    0.21386725f, -0.10954814f, 0.09817793f, 0.03683718f, 0.10766953f, -0.17138457f, -0.06407034f, -0.02262894f, 
    0.10572416f, 0.04148018f, -0.02237236f, -0.01817976f, 0.04407275f, 0.00067369f, -0.12780738f, 0.00934879f, 
    1.19845378f, -0.34433919f, -0.21692237f, 0.13301118f, -0.41223758f, 0.00269743f, 0.05859407f, 0.18291637f, 
    -0.13671872f, -0.04960545f, 0.18307914f, -0.23622665f, 0.01006025f, -0.08489799f, -0.12609400f, 0.01856223f, 
    0.02929779f, -0.18512805f, -0.02451645f, -0.00768785f, 0.21040237f, 0.07819913f, 0.26892185f, 0.11911550f, 
    0.10959055f, -0.02898419f, 0.04679169f, 0.00349030f, 0.00100870f, -0.02929382f, 0.06795624f, -0.01418189f, 
    -0.07959330f, 0.11877480f, -0.03818945f, -0.17440836f, 0.15856545f, -0.09665570f, 0.09711404f, 0.10134532f, 
    -0.53671801f, -0.65123844f, 0.00626060f, 0.17426288f, 0.01823539f, 0.07316487f, -0.05123666f, -0.00019136f, 
    0.09641532f, -0.05040388f, -0.06811321f, -0.03198036f, -0.20608056f, 0.02046871f, 0.13274656f, -0.03180054f, 
    -0.02482990f, -0.12531947f, 0.03198760f, -0.10774198f, -0.36714908f, -0.16097443f, -0.16033950f, -0.02802860f, 
    -0.12631790f, 0.16959102f, 0.02396315f, -0.01121036f, 0.10476753f, 0.11288793f, 0.16521840f, -0.13362108f, 
    -0.02218229f, 0.15850739f, 0.09304489f, -0.09210385f, -0.03451939f, -0.05573517f, 0.11297513f, 0.23520696f, 
    0.50780046f, 0.24087760f, -0.07175494f, -0.33525461f, -0.23498049f, -0.07108555f, -0.13566759f, -0.25887597f, 
    0.03600725f, -0.17173678f, 0.02845916f, 0.01673319f, 0.02692761f, 0.04456898f, 0.05457620f, 0.19634177f, 
    -0.11559854f, 0.11956061f, 0.37251985f, -0.11181033f, 0.54427719f, 0.33542562f, -0.01872187f, -0.03329371f, 
    0.21610206f, -0.01900231f, -0.06336194f, -0.01273378f, -0.04648316f, -0.01937353f, -0.04550299f, 0.03941234f, 
    -0.03739979f, 0.06337381f, -0.04796762f, -0.04009069f, -0.02835119f, -0.16066265f, 0.09693392f, 0.06460372f, 
    0.00769054f, -0.03390694f, 0.02360915f, 0.04793090f, -0.03936666f, 0.06116458f, -0.09087358f, 0.00777570f, 
    0.07385610f, 0.02358220f, -0.21329847f, 0.18502650f, -0.22984548f, 0.05871412f, -0.00697513f, -0.09715760f, 
    0.02439720f, -0.06102997f, 0.10748479f, -0.02433495f, -0.37622494f, -0.16608608f, -0.53320032f, -0.53105915f, 
    -0.21526390f, 0.28815618f, -0.23640825f, -0.12200411f, 0.07670305f, 0.01927257f, -0.00276993f, 0.08589675f, 
    0.02612588f, 0.01424843f, 0.10568824f, -0.10186893f, -0.06983758f, -0.00033289f, -0.30322903f, -0.35287619f, 
    -0.14117317f, -0.64178473f, 0.14612274f, 0.06851039f, 0.35762560f, 0.03799166f, -0.02209612f, 0.03784456f, 
    -0.16399688f, 0.02663112f, 0.17014164f, 0.06104410f, 0.12527719f, 0.06431605f, 0.15610735f, 0.26422629f, 
    -0.00024318f, -0.03587041f, 0.24276635f, -0.19140455f, -0.02957382f, -0.26195401f, -0.32951882f, -0.04220033f, 
    -0.03152142f, -0.07300390f, 0.25473630f, 0.02984773f, -0.19254595f, -0.06922244f, -0.05101470f, 0.20143999f, 
    -0.19353272f, 0.02812056f, -0.05034990f, -0.09134662f, 0.11088537f, -0.03743180f, -0.03955095f, 0.07196998f, 
    -0.08549210f, 0.52009070f, 0.16670515f, 0.29520109f, 0.34781241f, -0.03110408f, -0.19775352f, -0.06178204f, 
    0.05455715f, 0.03276834f, -0.03386235f, -0.01252192f, 0.01302583f, -0.05441971f, 0.15641086f, 0.06348235f, 
    -0.08562724f, 0.18443260f, -0.21044971f, -0.06724925f, -0.04720036f, 0.36036190f, 0.17205882f, -0.04036883f, 
    -0.23794444f, 0.07282637f, -0.01684820f, 0.10761311f, -0.19327529f, -0.10416111f, 0.03077422f, 0.02059893f, 
    0.09405953f, -0.17161626f, 0.13787705f, 0.24062178f, 0.03244730f, -0.12240846f, -0.17238009f, -0.01237667f, 
    -0.31226677f, -0.24101326f, -0.26308101f, -0.06146748f, 0.04248829f, 0.13136061f, -0.03381949f, 0.14122988f, 
    0.10629321f, -0.01487341f, -0.01065874f, 0.01049609f, -0.23237218f, 0.13731979f, 0.10094921f, 0.00535498f, 
    -0.10263348f, 0.12672113f, 0.08097579f, 0.01525738f, -0.24234244f, -0.11160221f, 0.17335185f, 0.54771107f, 
    -0.36844563f, -0.18740202f, -0.07173169f, -0.14389524f, -0.15609185f, 0.27578253f, -0.01030537f, -0.00478880f, 
    0.03002414f, 0.03235134f, -0.08340752f, 0.13690482f, 0.06826877f, -0.12891263f, 0.12084777f, 0.10034021f, 
    0.78386950f, 0.36617199f, -0.23078658f, -0.28466022f, 0.15596908f, 0.16102295f, -0.01036418f, -0.01422298f, 
    0.06440189f, 0.22388417f, -0.25993550f, 0.14589939f, 0.25614917f, 0.02361127f, 0.13808452f, 0.12892520f, 
    -0.06706347f, -0.02802511f, 0.24741958f, -0.12022740f, -0.26240355f, -0.31159648f, -0.99073321f, 0.28269574f, 
    -0.38609788f, 0.08611038f, 0.15275441f, -0.02571665f, -0.08824191f, 0.00001464f, 0.04976694f, 0.08870067f, 
    0.04163777f, 0.05471699f, -0.07407507f, 0.00208445f, -0.04409915f, 0.05345349f, -0.26566169f, 0.10905264f, 
    -0.23351963f, 0.38427463f, 1.22752905f, -0.07595936f, 0.34616029f, -0.04774740f, -0.12318498f, 0.16546135f, 
    0.06000493f, -0.04370828f, 0.09762509f, 0.00275336f, -0.02655327f, -0.15061504f, 0.13562559f, 0.04636564f, 
    0.01097572f, -0.04107663f, 0.10124960f, -0.10516540f, -0.25302485f, -0.11836727f, -0.10918969f, -0.00345285f, 
    0.06362157f, -0.12499154f, -0.12338449f, -0.05969056f, -0.01419532f, 0.15951297f, 0.09492158f, -0.01935033f, 
    -0.25932911f, 0.21097052f, -0.09171809f, 0.10177973f, -0.14213990f, 0.09844346f, -0.00097558f, -0.05886912f, 
    0.56045425f, -0.22731157f, -0.16693999f, 0.34421387f, 0.30711010f, -0.04993441f, 0.05697827f, -0.03874278f, 
    0.04912243f, -0.17096570f, -0.19882978f, -0.06403309f, -0.06370523f, 0.07552957f, -0.29948053f, 0.02130686f, 
    -0.01459886f, 0.10274275f, -0.17334853f, 0.13524048f, -0.13285002f, -0.04467295f, -0.15651678f, 0.04839524f, 
    0.05204615f, 0.10672219f, -0.06528072f, -0.33154306f, -0.39132747f, -0.65085661f, 0.05286634f, -0.08951825f, 
    0.13503216f, 0.08523794f, 0.02288558f, 0.05473580f, -0.05377034f, -0.02850379f, -0.13739020f, -0.08860531f, 
    -0.31813523f, -0.12499898f, -0.01698301f, -0.23547594f, -0.46747786f, 0.03536912f, 0.01691219f, -0.10734741f, 
    -0.07050540f, 0.06205711f, 0.05479890f, 0.03501835f, 0.00892239f, 0.15727040f, -0.11725205f, 0.07441915f, 
    -0.04446973f, -0.24005692f, 0.15824409f, 0.06563375f, -0.81434011f, -0.36954620f, 0.11479796f, -0.71601015f, 
    -0.21246971f, -0.00184356f, -0.04472743f, -0.01878278f, -0.00717967f, 0.02739934f, 0.05075795f, -0.00432112f, 
    -0.03105202f, 0.02754131f, -0.02119556f, -0.02608516f, -0.01614480f, 0.15391305f, -0.00617700f, -0.15039636f, 
    0.04873550f, -0.12744422f, 0.02068708f, 0.00275853f, 0.09715772f, 0.14178351f, -0.15372340f, 0.01175365f, 
    0.14174117f, 0.03939131f, -0.17274699f, -0.09406994f, -0.05778977f, 0.00215262f, -0.15035450f, 0.04740121f, 
    -0.11454930f, -0.16146152f, 0.06615584f, -0.08225214f, -0.11882154f, -0.35624892f, 0.23840559f, -0.35053104f, 
    0.07566150f, 0.02774009f, -0.04236478f, -0.27118504f, 0.00725411f, 0.06071970f, -0.01827748f, -0.00796211f, 
    0.04861018f, 0.01675448f, -0.11570729f, 0.01522722f, -0.02424779f, 0.14648563f, 0.15847324f, 0.17730638f, 
    0.21485665f, -0.13426620f, -0.25732604f, -0.18239841f, 0.43380046f, 0.11207682f, 0.05035255f, -0.14288837f, 
    0.00654588f, -0.05788221f, -0.07410105f, -0.06562721f, 0.08519793f, 0.06495788f, 0.12635756f, 0.14337826f, 
    0.10420889f, 0.16947603f, 0.06459001f, 0.19119573f, -0.01784217f, 0.37745079f, 0.35051823f, 0.02774512f, 
    0.19953687f, -0.08353405f, -0.08595083f, 0.07812996f, 0.12543413f, -0.23585691f, 0.07755811f, 0.20506325f, 
    -0.12407521f, 0.12377822f, 0.06907637f, 0.04545750f, -0.15431862f, -0.06934288f, 0.06199810f, -0.04363417f, 
    -0.73295516f, -0.50743967f, -0.48977613f, 0.13887732f, -0.80285269f, -0.20138702f, 0.18883894f, -0.13210417f, 
    0.20345658f, -0.00829397f, -0.06635628f, -0.04080034f, 0.03136431f, -0.00694093f, -0.07833251f, -0.02046341f, 
    -0.02247399f, 0.03054019f, -0.34289438f, 0.02371456f, -0.51174188f, 0.24214382f, 0.36756262f, 0.79030955f, 
    0.33855230f, 0.13518225f, -0.05343327f, 0.11749428f, -0.03253178f, -0.01948016f, -0.04632108f, 0.03095038f, 
    0.07856238f, -0.01194566f, -0.00219715f, -0.13004051f, 0.02160666f, -0.02893075f, 0.00941540f, -0.00137587f, 
    0.07022538f, -0.10780265f, 0.02412387f, -0.55238640f, -0.42487776f, 0.79532415f, 0.41242608f, 0.39794895f, 
    0.17536102f, -0.05549446f, -0.15221870f, -0.09160739f, -0.24190949f, -0.24193560f, -0.14803237f, 0.12057505f, 
    0.18436886f, 0.64477116f, 0.06347081f, -0.64505297f, -0.18763901f, 0.04091474f, -0.25198096f, -0.00956760f, 
    0.47221035f, -0.01342474f, 0.11332496f, -0.15280771f, 0.15534055f, 0.01226457f, 0.04360781f, 0.01921875f, 
    -0.15715244f, -0.05396297f, -0.11214891f, -0.07726513f, 0.29642650f, 0.03382733f, -0.05735803f, -0.02112324f, 
    -0.39162144f, 1.24825811f, -0.36877397f, -0.56238437f, -0.59104699f, -0.08456177f, -0.29461282f, -0.03801237f, 
    -0.21600316f, 0.15539750f, -0.31151673f, -0.23854415f, -0.11471844f, -0.06238531f, 0.21324208f, -0.21070473f, 
    -0.04551227f, 0.05301347f, -0.17121178f, -0.03600731f, 0.10177593f, -0.07479102f, -0.44059977f, -0.04280507f, 
    0.27556014f, 0.16956131f, -0.06275043f, -0.01176017f, 0.19114901f, 0.07192618f, 0.09748911f, 0.03213144f, 
    -0.09866827f, 0.04138187f, 0.02517842f, -0.06124581f, -0.26678944f, 0.04244585f, -0.21030608f, 0.07322676f, 
    -0.54495597f, 0.77229106f, -0.15670024f, 0.17430708f, 0.54665846f, 0.24815278f, -0.02205247f, -0.09668545f, 
    -0.27404127f, 0.06555007f, -0.20953676f, 0.01891599f, 0.08683911f, 0.07711326f, 0.07141181f, -0.02088169f, 
    -0.08048962f, 0.01345852f, 0.03198277f, -0.06113654f, -0.65161318f, -0.08373827f, 0.18542892f, 0.11185023f, 
    -0.14974196f, 0.03762497f, -0.63419348f, -0.16083094f, -0.13446492f, -0.29030314f, -0.14678362f, 0.10162101f, 
    -0.02912280f, -0.17043927f, -0.23808090f, -0.07491852f, 0.06172349f, -0.00788497f, -0.12043736f, -0.21519169f, 
    0.21195421f, 1.06855500f, -0.10497782f, -0.18256927f, 0.14794460f, 0.55025643f, 0.19085379f, -0.27193743f, 
    0.09526416f, -0.36628035f, -0.36245176f, -0.05296005f, -0.15852679f, 0.01197440f, 0.17658468f, 0.03472232f, 
    0.00069733f, -0.12177379f, 0.09645045f, 0.03382999f, -0.23426035f, -0.09873767f, -0.19620742f, 0.03679200f, 
    0.32238165f, 0.05541457f, 0.08597281f, 0.12263932f, 0.01303997f, 0.13210443f, 0.00165182f, -0.07804762f, 
    0.03840836f, -0.16249542f, 0.06516999f, 0.16553293f, -0.21132913f, 0.17320150f, -0.17291328f, -0.07882040f, 
    -0.68425989f, 0.21094480f, -0.66716444f, 0.40343338f, 0.04120585f, -0.14366762f, -0.24177152f, 0.02387071f, 
    0.01502057f, -0.04156442f, -0.11129008f, 0.14694987f, 0.19540362f, -0.01150194f, -0.34001175f, -0.12866613f, 
    -0.02648750f, -0.01703471f, 0.21791056f, -0.02011209f, -0.69312871f, -1.04345083f, 0.74444878f, -0.02898603f, 
    0.03426386f, -0.12360328f, -0.14116856f, -0.14329302f, 0.16766816f, 0.04211444f, 0.10721717f, 0.08890121f, 
    0.18568133f, -0.08569698f, 0.13714631f, -0.08514724f, 0.10810194f, 0.05545068f, -0.04213429f, -0.27799878f, 
    -0.28496221f, -0.06923924f, -0.08997454f, -0.42049468f, 0.07960645f, 0.18942210f, 0.20123985f, -0.11180110f, 
    0.02415270f, 0.11132756f, 0.12430823f, -0.06574432f, -0.29244742f, 0.02923734f, -0.09537738f, 0.04167781f, 
    -0.09126014f, -0.04970857f, -0.01019680f, -0.20831163f, 0.36412439f, 0.10942207f, 0.33180693f, -0.05632380f, 
    0.45424250f, -0.25226232f, 0.19852895f, 0.11548120f, -0.23402362f, -0.05386497f, 0.03258102f, 0.03476604f, 
    -0.16779126f, -0.10457999f, 0.05667804f, -0.06742504f, -0.18906160f, -0.00076001f, 0.06213162f, -0.11839919f, 
    1.05780208f, 0.68887085f, 0.15880756f, -0.47231394f, -0.50218213f, 0.22964987f, 0.13286257f, -0.09811034f, 
    -0.05426147f, 0.03432367f, -0.07818964f, -0.21750088f, 0.22594157f, -0.12141879f, -0.14846107f, -0.07198960f, 
    0.00320575f, -0.20967893f, -0.00019413f, 0.04996355f, -0.39927197f, 0.11250270f, -0.35545668f, 0.16038729f, 
    0.54882503f, 0.17388552f, -0.01449917f, 0.05298355f, -0.12949342f, 0.09676100f, -0.15518171f, 0.04499621f, 
    0.14792462f, -0.02590030f, 0.05951539f, -0.01753336f, 0.02565279f, 0.26968929f, 0.12449475f, 0.25741306f, 
    -0.31229067f, -0.04980908f, -0.22762422f, -0.10287634f, 0.21406202f, -0.05578972f, 0.18050247f, 0.00021645f, 
    -0.09310146f, -0.01375900f, -0.03973911f, 0.01807212f, -0.07102293f, -0.16077228f, -0.03887828f, -0.00906962f, 
    0.02569492f, 0.21185268f, -0.24014385f, 0.02252024f, 0.05369272f, -0.17981532f, -0.21396282f, -0.17238566f, 
    0.44442055f, 0.19861902f, 0.08408348f, -0.07780994f, 0.02050563f, -0.15505326f, 0.08903874f, 0.12270545f, 
    0.11145622f, 0.17873110f, 0.15475288f, -0.28546742f, 0.14037751f, 0.19231069f, 0.02215179f, 0.05552834f, 
    0.26617542f, 0.26821131f, 0.06372625f, 0.16922443f, -0.09115148f, -0.09049436f, -0.00551932f, 0.02670162f, 
    0.10543506f, 0.14136533f, 0.00914785f, 0.10307348f, -0.25274909f, 0.06306252f, 0.10180262f, 0.16257989f, 
    -0.06627588f, -0.15499821f, -0.11518860f, 0.01249223f, -0.23959114f, -0.13386533f, 0.02390650f, -0.15347214f, 
    0.06707842f, -0.03991153f, 0.26626727f, 0.01335741f, -0.11678971f, -0.01882106f, -0.09592383f, -0.01234013f, 
    -0.14571986f, 0.25373709f, 0.13351019f, 0.08173576f, 0.03432830f, -0.22717851f, -0.02303142f, 0.14525279f, 
    0.08997364f, -0.59069413f, -0.08830801f, 0.14345179f, -0.35402134f, 0.15609223f, -0.08095648f, 0.04235956f, 
    -0.11930382f, 0.08693397f, -0.10312192f, -0.09248526f, -0.08313943f, -0.16427821f, -0.07146554f, -0.20144264f, 
    -0.18617241f, 0.03248330f, -0.47206458f, -0.09244155f, 0.20488429f, 0.28656790f, 0.45790157f, 0.31446657f, 
    0.28565979f, -0.23350349f, -0.14540064f, 0.11679220f, -0.02043938f, 0.19067219f, 0.10722857f, -0.04536168f, 
    -0.02448355f, 0.06791306f, 0.06637199f, -0.05131426f, -0.04903142f, -0.11343633f, -0.09254259f, -0.14543131f, 
    -0.13774805f, -0.35017914f, 0.46443334f, -0.03763542f, 0.10139783f, -0.24188529f, -0.03404830f, -0.28537890f, 
    -0.12444346f, -0.08075227f, -0.04788505f, -0.16218069f, -0.12941991f, 0.11011661f, 0.03037058f, -0.00923294f, 
    0.07463892f, -0.00109425f, -0.01541654f, -0.19188738f, 0.03025302f, 0.04950067f, -0.11567976f, -0.13860910f, 
    -0.04287639f, 0.10418148f, 0.04745603f, 0.11873456f, -0.02311916f, 0.02399654f, 0.18797043f, 0.01799237f, 
    -0.00863235f, -0.18419817f, 0.14206333f, 0.05885176f, -0.06683602f, -0.10701637f, -0.03851194f, 0.07034482f, 
    0.29362959f, -0.93185294f, -0.16717623f, -0.14698769f, -0.07998794f, -0.35772273f, -0.35997975f, 0.12914869f, 
    -0.06408726f, 0.25869927f, 0.11164185f, -0.02894116f, -0.08437100f, -0.14360140f, -0.05993550f, 0.01977407f, 
    -0.11763140f, 0.01724499f, 0.07247479f, -0.01916831f, 0.15780061f, 0.18123612f, 0.26745820f, 0.06133202f, 
    0.07516193f, 0.05481963f, 0.20024723f, -0.01524265f, -0.06350388f, 0.24936117f, 0.11739708f, -0.04692897f, 
    0.03703913f, -0.04612980f, -0.06076701f, -0.03046674f, -0.09721278f, -0.23528066f, -0.06098772f, -0.25340819f, 
    0.27418989f, -0.15724610f, -0.30406526f, -0.25591195f, -0.11426479f, 0.24390571f, -0.20084083f, 0.20444183f, 
    0.02691373f, 0.01617709f, -0.01601252f, -0.02279132f, -0.13341908f, -0.00467080f, 0.01478075f, -0.26742840f, 
    0.14067283f, -0.32263142f, -0.40513852f, 0.00899559f, 0.19263749f, 0.22179498f, -0.35702404f, 0.44410393f, 
    0.32313448f, -0.02141499f, 0.09901229f, 0.00797288f, 0.08261997f, 0.07992627f, 0.16105777f, 0.04503639f, 
    0.02841679f, -0.06314275f, 0.07922069f, 0.09631187f, 0.05023077f, 0.21606825f, -0.19674623f, 0.05749071f, 
    0.03847530f, 0.21193528f, -0.05060842f, -0.00806976f, 0.02128544f, 0.14824513f, 0.08468085f, -0.00114321f, 
    -0.02808626f, 0.14071603f, 0.05505411f, -0.01678762f, 0.08002894f, 0.03270178f, 0.04063433f, 0.20592079f, 
    -0.03248384f, -0.01918326f, -0.14713085f, -0.05689399f, 0.22819324f, 0.00317129f, 0.03676838f, 0.40960640f, 
    -0.01659321f, 0.08333876f, 0.11520994f, 0.11956889f, 0.05707721f, 0.02999634f, -0.00768063f, -0.06139148f, 
    -0.04263130f, 0.01022282f, -0.07376314f, 0.01813518f, 0.20122039f, -0.08170788f, 0.07039618f, 0.31557682f, 
    -0.21872026f, -0.63305914f, -0.16800325f, -0.34286261f, -0.44489929f, 0.07544523f, 0.02837848f, 0.11751376f, 
    -0.09971530f, 0.10083627f, -0.04157709f, -0.21687517f, -0.04998278f, -0.04056098f, -0.32285088f, -0.18965150f, 
    -0.07577538f, 0.00764585f, -0.21998733f, 0.06287779f, 0.34840271f, -0.06868014f, 0.17560531f, -0.02857981f, 
    0.08997396f, -0.18601912f, -0.13204658f, -0.04769706f, -0.20866127f, -0.07867388f, 0.21326585f, -0.23018984f, 
    0.01635904f, -0.06545193f, 0.01195414f, 0.08175104f, 0.04127370f, -0.03374662f, -0.05506699f, -0.08502489f, 
    -0.03157568f, -0.10280878f, 0.20442227f, 0.09116878f, 0.11551309f, -0.19130473f, 0.03657476f, -0.07623048f, 
    0.01782287f, 0.03712519f, -0.07412328f, 0.07544030f, 0.00195328f, 0.16552675f, 0.01973532f, 0.10707497f, 
    0.03386204f, -0.13770027f, 0.03194582f, 0.07142730f, 0.07487822f, -0.26983714f, 0.13508148f, 0.37790123f, 
    0.04341764f, -0.28306669f, -0.06321139f, -0.03566094f, -0.09627835f, -0.18758909f, 0.08056519f, 0.03235554f, 
    -0.07578724f, 0.07005050f, -0.09611724f, -0.02208828f, 0.00054231f, 0.00148375f, 0.08139385f, -0.00532399f, 
    -0.11447626f, -0.07182796f, -0.09084905f, 0.06645604f, 0.13350764f, 0.01063208f, 0.06745384f, -0.07361254f, 
    -0.23426415f, -0.08710322f, 0.25133473f, -0.20893908f, 0.33293086f, 0.19595167f, 0.12732913f, -0.04271980f, 
    -0.05595681f, 0.10157393f, 0.04924059f, 0.09896060f, 0.10565636f, -0.05463182f, 0.11596276f, -0.06326552f, 
    -0.00425728f, 0.01415941f, -0.14508505f, -0.21140197f, 0.30158272f, -0.14306884f, 0.11682977f, 0.01251049f, 
    0.07408724f, -0.01253568f, -0.01280214f, 0.02461395f, 0.10536060f, -0.26165080f, -0.04235253f, -0.46418348f, 
    -0.41675332f, -0.46842563f, -0.14500356f, 0.29741001f, -0.17256778f, 0.08053533f, -0.50394583f, -0.15966597f, 
    0.25387305f, -0.33669180f, 0.16719201f, 0.02556239f, 0.03966580f, 0.19481449f, 0.07133076f, 0.25861782f, 
    -0.01559222f, -0.02131239f, 0.41762242f, 0.46791178f, 0.36078241f, -0.20664135f, 0.46644416f, 0.00588355f, 
    -0.51666337f, 0.32951009f, 0.21863039f, -0.17609079f, -0.09619420f, -0.04143177f, 0.08704560f, -0.00158951f, 
    -0.03803432f, 0.03298856f, 0.03187770f, -0.01164173f, 0.08574462f, -0.03357975f, 0.19288804f, 0.36695305f, 
    -0.47149098f, 0.03896580f, -0.48723006f, -0.74178106f, -0.14429376f, 0.06003584f, 0.08352158f, -0.01511546f, 
    -0.07043429f, 0.14297287f, 0.11289514f, 0.19405209f, -0.12855707f, -0.28239065f, -0.01946584f, -0.08441848f, 
    -0.09492683f, 0.20926197f, -0.03693858f, 0.04670335f, 0.01444976f, -0.24061854f, -0.51543015f, 0.07972709f, 
    0.15075007f, 0.08453937f, -0.16942072f, -0.05898450f, -0.02802894f, 0.07247781f, 0.04460922f, -0.02842363f, 
    0.12879087f, 0.15250921f, 0.02937633f, 0.07088412f, -0.02257542f, 0.16773176f, 0.00987329f, -0.21279378f, 
    -0.69981658f, 0.07186430f, -0.68641943f, -0.01557752f, -0.15513016f, 0.03833964f, -0.04373622f, -0.17915376f, 
    0.13274066f, -0.01282287f, 0.22292531f, -0.00605215f, -0.01921831f, 0.01168498f, -0.01982758f, -0.07072668f, 
    0.06857153f, 0.07886536f, -0.10252540f, 0.09700137f, 0.22648001f, 0.14916801f, 0.06290423f, 0.00551106f, 
    -0.07195098f, -0.12626328f, -0.12875338f, 0.13283740f, -0.02452039f, -0.00383254f, -0.27873257f, 0.09916180f, 
    -0.11628421f, -0.15602508f, -0.00308943f, 0.11281766f, 0.19885623f, 0.10187273f, -0.09916039f, 0.04933644f, 
    -0.06923127f, 0.16069910f, 0.12094787f, -0.52817923f, 0.56137210f, 0.20719470f, 0.16511853f, -0.04511876f, 
    -0.10679346f, -0.34593886f, 0.16571380f, -0.13535152f, -0.23544084f, 0.01382399f, 0.16309503f, -0.05774566f, 
    0.10602665f, -0.05386627f, 0.02200829f, -0.10973842f, 0.10331389f, -0.37173259f, -0.23262665f, 0.15992895f, 
    -0.05910766f, 0.13754007f, 0.05462185f, 0.00471412f, -0.03248719f, 0.05369425f, 0.01554051f, -0.01359453f, 
    -0.08379263f, 0.03589937f, 0.02638573f, -0.18745258f, -0.24633360f, 0.20602465f, 0.09229422f, 0.02591337f, 
    -0.01046541f, 0.07425757f, 0.03564403f, 0.01197527f, 0.02777532f, -0.10350957f, -0.08855586f, -0.10854109f, 
    0.00468502f, -0.12922634f, 0.31856403f, -0.16445147f, 0.27318755f, -0.14760230f, 0.07383277f, 0.03367877f, 
    0.10261475f, 0.02888193f, -0.03177871f, 0.13417126f, -0.20282102f, 0.03902088f, 0.53868711f, 0.29687905f, 
    -0.39544865f, 0.01722127f, -0.03726111f, 0.08420126f, 0.27872857f, 0.13896956f, 0.00219852f, 0.05326886f, 
    -0.03238321f, 0.02660877f, -0.01336732f, 0.03543997f, 0.00641810f, -0.05960670f, -0.16968074f, -0.19211455f, 
    -0.46854109f, 0.75287217f, -0.06791715f, 0.28438109f, -0.12003428f, 0.01237202f, -0.17026368f, 0.10381143f, 
    0.20206104f, -0.03833512f, 0.01350057f, 0.08373383f, -0.38354391f, -0.05817178f, 0.25320485f, -0.07969929f, 
    -0.01426736f, 0.09783828f, -0.14076532f, -0.16901121f, 0.04818630f, -0.32162309f, -0.07496458f, -0.09276169f, 
    -0.26951450f, 0.07374407f, -0.03206342f, 0.05080703f, 0.19412377f, 0.07588170f, -0.08710900f, -0.15066671f, 
    0.10027026f, -0.01371700f, -0.21913840f, -0.12418573f, 0.10808656f, 0.06993729f, -0.00624477f, 0.06686609f, 
    0.13327679f, -0.04636667f, 0.33157310f, 0.18348427f, -0.30466095f, 0.11440847f, 0.09007762f, 0.02455736f, 
    -0.10086720f, 0.00767751f, 0.11848442f, 0.07471621f, -0.03825227f, 0.07283291f, 0.02037870f, -0.10446981f, 
    0.02148019f, -0.14927401f, -0.05770399f, -0.25628093f, -0.48642045f, 0.22013977f, -0.17514762f, 0.00090191f, 
    -0.14398713f, 0.01764599f, -0.00466611f, -0.06429809f, -0.09875356f, 0.26138368f, 0.06927109f, -0.12910660f, 
    -0.11894670f, 0.04382484f, -0.06252617f, -0.13683879f, -0.23575200f, 0.07465972f, -0.00727370f, 0.06744795f, 
    -0.22949736f, 0.15173551f, 0.29092142f, -0.05550447f, -0.06220299f, -0.08232430f, -0.07624199f, -0.13307104f, 
    -0.05384210f, 0.10661159f, 0.07728778f, 0.09659331f, 0.10586527f, 0.04518935f, -0.01460725f, 0.07210918f, 
    -0.02153985f, -0.01945693f, -0.17096032f, 0.06382838f, -0.04727579f, -0.65611112f, -0.33367673f, -0.15562600f, 
    0.17082776f, -0.24609919f, 0.00267997f, -0.02673110f, -0.04665979f, -0.32164100f, 0.09496818f, -0.06847995f, 
    -0.00307527f, 0.00168202f, 0.15155149f, -0.04054096f, 0.18309759f, 0.31880808f, 0.14212613f, 0.06931958f, 
    -0.06805138f, -0.48644954f, 0.42816344f, 0.14139977f, 0.21922854f, -0.09183318f, 0.09689386f, 0.01790046f, 
    -0.01921131f, 0.01285645f, 0.27865699f, 0.09396862f, -0.17889766f, 0.17527315f, -0.31509265f, 0.04375227f, 
    0.05679729f, 0.00794587f, 0.15883380f, 0.19888145f, -1.27679098f, -0.64655799f, -0.54903466f, -0.23673153f, 
    0.03110947f, -0.29313865f, 0.00907199f, -0.12593625f, -0.25233451f, -0.48113999f, -0.04220658f, -0.01188308f, 
    -0.12313591f, 0.02108638f, 0.07091753f, 0.02047357f, -0.06545500f, 0.05466747f, 0.21012750f, -0.20676138f, 
    -0.81927389f, 0.95558065f, 0.30418161f, -0.05773482f, 0.40912166f, -0.13591066f, 0.02247530f, -0.07980100f, 
    0.13157000f, 0.02318168f, 0.05814676f, 0.13500336f, 0.20373963f, 0.07577682f, 0.17474753f, 0.09406435f, 
    0.05351595f, 0.09955352f, 0.05809925f, 0.03368556f, 0.34664935f, 0.10426142f, -0.20292431f, -0.22782016f, 
    -0.03911396f, 0.02837988f, -0.08566772f, 0.15840684f, -0.00616426f, 0.10543394f, -0.15430000f, 0.00264408f, 
    -0.00667105f, -0.33103710f, -0.11599559f, -0.18369363f, 0.01099391f, -0.40119064f, 0.01783971f, 0.12920357f, 
    -0.47996032f, -0.22348292f, 0.14628775f, 0.19442345f, 0.07660387f, -0.21858533f, -0.05928266f, -0.10051478f, 
    -0.13561989f, 0.52452612f, -0.08197843f, 0.24733697f, 0.18127584f, 0.07993636f, -0.01533516f, 0.04325631f, 
    0.13084324f, -0.15744387f, 0.05285925f, -0.02246454f, 0.05462921f, 0.25199848f, 0.01797695f, -0.22334187f, 
    0.02756853f, -0.30558276f, -0.10647858f, -0.26641706f, 0.12164850f, -0.08738539f, 0.10494146f, -0.15906112f, 
    -0.16060281f, -0.02606216f, 0.03849022f, -0.03715787f, 0.00774939f, -0.00952447f, 0.07539211f, -0.21342704f, 
    0.39933327f, -0.15584466f, -0.18594521f, -0.07485916f, -0.45622852f, 0.30284694f, 0.14373256f, 0.20895588f, 
    0.09405697f, -0.19082262f, -0.04517131f, 0.01063189f, -0.04708583f, -0.10266578f, 0.14170884f, 0.03531909f, 
    0.11730206f, 0.25979966f, -0.28630722f, 0.04292204f, -0.17038570f, -0.05201144f, -0.19415951f, -0.50356686f, 
    0.11906960f, -0.07127926f, 0.06650410f, 0.09023087f, -0.04313427f, -0.00115351f, -0.10074290f, -0.05202357f, 
    -0.01647437f, 0.00524212f, -0.02347614f, -0.01141261f, -0.03927438f, -0.13235143f, 0.04687274f, 0.25640669f, 
    -0.23603573f, -0.12617500f, 0.17273976f, -0.03733185f, 0.03007764f, -0.07611831f, -0.05439249f, -0.06443018f, 
    -0.10800984f, -0.11074387f, 0.24650666f, -0.17066646f, -0.10120834f, 0.05819400f, 0.05486681f, -0.07924724f, 
    -0.03230626f, -0.07237307f, -0.03193456f, -0.06834438f, -1.22698987f, -1.06849909f, -1.55912757f, -0.21763244f, 
    0.56728023f, -0.11631978f, 0.34939191f, 0.02459974f, -0.10154552f, -0.33626390f, 0.03959517f, -0.04724601f, 
    0.02123920f, 0.06745917f, 0.13823523f, 0.03469614f, 0.02312114f, 0.26025659f, 0.32050410f, 0.05666379f, 
    0.05907438f, 0.23200062f, 0.14863749f, 0.11522271f, 0.08440340f, 0.02428010f, 0.02271127f, -0.03918960f, 
    -0.02101957f, 0.28270939f, -0.07122588f, 0.06406389f, 0.25130010f, 0.14762415f, 0.03957089f, -0.05057452f, 
    0.15847127f, -0.15347333f, 0.01017081f, 0.04664946f, -0.41566619f, 0.70268005f, 0.32036322f, -0.00729979f, 
    -0.19497205f, -0.21926987f, -0.01791179f, -0.26061118f, -0.16365550f, -0.08430296f, -0.05027656f, -0.08394650f, 
    0.05643157f, 0.08587686f, 0.03404405f, 0.04325144f, -0.14889778f, -0.01837882f, 0.05333578f, -0.17399167f, 
    -1.00905240f, -0.61479926f, -1.10377502f, -0.22831385f, -0.25367904f, -0.22393091f, -0.12807199f, -0.12627955f, 
    -0.21497858f, -0.35732558f, 0.00020689f, -0.04830277f, -0.01569621f, -0.11841845f, -0.03579414f, -0.01334105f, 
    -0.05490021f, -0.03380492f, 0.27677003f, -0.00228379f, -0.08629241f, -0.74818879f, -0.37627083f, 0.07049759f, 
    0.71815163f, 0.03897282f, -0.34596756f, -0.05864460f, -0.04237152f, 0.13311735f, -0.01540059f, -0.02843617f, 
    -0.00954879f, -0.01340708f, -0.08579081f, 0.00820555f, 0.11301524f, -0.07697138f, 0.17683914f, -0.07960373f, 
    0.18895991f, 0.15440583f, 0.06981150f, -0.18779926f, -0.00750662f, 0.02667710f, 0.05965918f, 0.02849775f, 
    0.05722399f, -0.08169659f, -0.09562084f, -0.16778880f, -0.31855744f, -0.36299661f, -0.09787035f, -0.04157850f, 
    -0.01376034f, -0.09999114f, 0.08683065f, -0.04211969f, -1.01885712f, -0.41897663f, -0.45957038f, -0.43734962f, 
    0.38309368f, 0.24759290f, -0.19646850f, 0.32598767f, -0.10775433f, 0.14720248f, 0.00316876f, 0.09599108f, 
    -0.00861759f, -0.10633732f, -0.01627873f, 0.14227137f, 0.17432106f, 0.06772318f, 0.13330995f, 0.06061442f, 
    0.23400196f, 0.29421508f, -0.25418636f, -0.13349858f, -0.12108114f, 0.02019047f, 0.10211122f, 0.06474076f, 
    -0.11887053f, -0.08567387f, -0.20539618f, 0.12737340f, 0.14950638f, -0.34692016f, -0.15040725f, -0.24715976f, 
    0.00072343f, -0.07488618f, -0.29390004f, 0.12978601f, 0.51069885f, -1.05515993f, -0.00073713f, 0.88680571f, 
    0.22131121f, -0.01857721f, 0.14401411f, 0.03872294f, -0.14420986f, 0.09362046f, -0.00443688f, 0.01022792f, 
    -0.01891159f, -0.03461925f, -0.01724412f, 0.00664115f, 0.03752408f, -0.01918891f, -0.09496551f, -0.15603246f, 
    -0.23832238f, -1.01640439f, 0.00741036f, -0.23037952f, -0.12726310f, -0.04853890f, -0.31545022f, 0.33867985f, 
    0.09664270f, 0.08341923f, -0.05543070f, 0.03222256f, 0.10931619f, 0.18916558f, 0.05681991f, -0.05211308f, 
    0.03993275f, -0.01615486f, 0.08148885f, 0.09378483f, -0.00514922f, 0.08239364f, 0.03941984f, 0.07175914f, 
    -0.17080072f, 0.04106972f, -0.06774786f, -0.00720123f, -0.08089174f, -0.02950807f, 0.00253920f, 0.06088015f, 
    0.03014959f, -0.02368917f, -0.01505797f, -0.04164797f, -0.15382867f, 0.06810899f, 0.03754923f, 0.06262606f, 
    0.65208703f, 0.76736069f, -0.13068074f, -0.19528838f, -0.55926520f, 0.17150554f, 0.01102682f, -0.11121757f, 
    -0.07704329f, -0.10102651f, 0.01480694f, 0.03304560f, 0.22772820f, -0.06988733f, -0.06977218f, 0.00476368f, 
    -0.04894399f, 0.02664203f, 0.03991235f, -0.09398949f, -0.00060561f, -0.32541376f, -0.24459237f, 0.17609616f, 
    0.06122594f, 0.11713552f, 0.03629664f, 0.01587967f, -0.03048777f, 0.12127483f, -0.03854284f, 0.18916014f, 
    0.09919250f, 0.01267969f, 0.01160773f, -0.01085102f, -0.01480362f, 0.02910962f, -0.15671444f, -0.12817000f, 
    -0.23573169f, -0.04431006f, 0.36209548f, -0.38821393f, 0.22491077f, -0.19206718f, 0.03642698f, 0.01519314f, 
    0.00924668f, 0.06722717f, 0.13381112f, -0.08046827f, 0.09676417f, -0.06408548f, -0.10429119f, -0.19824940f, 
    -0.05499754f, -0.22353110f, 0.18672007f, -0.22537071f, -0.14119068f, 0.20709580f, 0.02526742f, -0.00985598f, 
    -0.24961697f, 0.14810325f, 0.11270496f, -0.00792861f, -0.03946608f, -0.04875675f, 0.06148093f, 0.02346059f, 
    0.13570349f, -0.00921212f, 0.00261431f, 0.15948375f, 0.09770543f, -0.18223961f, 0.15025140f, 0.15057811f, 
    0.22335277f, 0.05024652f, 0.05622301f, -0.05781011f, 0.00569099f, 0.03598452f, 0.05126832f, 0.18270645f, 
    0.02694164f, -0.09097934f, -0.13560192f, -0.42073426f, 0.23810187f, 0.04988988f, -0.01596919f, 0.04064889f, 
    -0.01836075f, 0.03805564f, 0.03358234f, -0.04455126f, -0.61223924f, -0.32790440f, -0.01438490f, 0.80613929f, 
    -0.24547616f, -0.08681386f, 0.17264067f, -0.04966548f, -0.00624300f, 0.26792634f, 0.01713620f, -0.05427247f, 
    0.00408386f, -0.02411840f, -0.05615893f, 0.00712144f, 0.15728314f, -0.29260096f, -0.05832744f, -0.03392377f, 
    0.13963814f, 0.41100010f, -0.13864522f, 0.09188239f, -0.71086746f, -0.10817789f, 0.05344227f, 0.02466337f, 
    0.05303093f, -0.09579824f, -0.27236274f, 0.04332918f, -0.18945767f, -0.20771454f, -0.36205253f, 0.05728757f, 
    -0.07737792f, -0.08675370f, -0.08129551f, -0.00037609f, -0.08385956f, -0.34306508f, -0.34772962f, -0.12643510f, 
    -0.21852514f, 0.13182364f, -0.16454591f, 0.18000318f, -0.18494214f, 0.29343683f, -0.14877716f, 0.03936700f, 
    0.24807353f, -0.00944589f, 0.11420766f, 0.05082039f, -0.09698076f, 0.12569147f, 0.00422367f, 0.02239066f, 
    0.01218915f, -0.83623475f, -0.32738656f, 0.23384172f, 0.07713514f, 0.04832898f, -0.08200318f, 0.01474786f, 
    0.19100738f, 0.23168729f, -0.03586263f, -0.02267930f, -0.06857254f, -0.19004552f, -0.06504326f, -0.05582518f, 
    0.09143618f, 0.01893440f, 0.32234117f, -0.12707174f, 0.97264767f, -1.19689226f, -0.77718920f, -1.08197320f, 
    -0.22870101f, 0.09060974f, 0.06046568f, -0.28229702f, 0.27405304f, 0.05203756f, 0.06523885f, -0.01654413f, 
    -0.05588048f, -0.08804666f, 0.01571672f, -0.14408258f, -0.09285807f, 0.02645692f, -0.03292146f, -0.03064166f, 
    -0.33183125f, -0.39576834f, -0.23472445f, -0.05210906f, -0.07888342f, -0.04945796f, -0.03948862f, 0.06230638f, 
    -0.02017608f, 0.10105418f, 0.12690161f, 0.17081158f, 0.06725517f, 0.09315123f, 0.09073319f, -0.01102240f, 
    0.16221954f, -0.07302763f, -0.02148447f, 0.09256456f, 0.32613721f, -0.50027442f, -0.71819985f, -0.45061859f, 
    0.11517464f, 0.03611585f, 0.22024439f, 0.12888022f, 0.05966666f, 0.14217207f, 0.06951229f, -0.01881983f, 
    0.00809018f, 0.08104639f, 0.14576952f, -0.08675238f, -0.13185963f, 0.05816627f, -0.30328706f, -0.48233300f, 
    0.10135435f, 0.30829304f, -0.00577950f, 0.16585986f, -0.57969552f, -0.09499905f, 0.38947639f, 0.15429437f, 
    0.20962654f, 0.01595311f, 0.16169082f, 0.18200721f, -0.16668047f, 0.15878068f, 0.30836448f, 0.17142558f, 
    0.32162982f, 0.03657467f, 0.15202548f, 0.01250678f, 0.41566217f, -0.84010017f, -0.94560605f, -0.22005762f, 
    -0.08684566f, 0.04546474f, 0.06277482f, 0.10733856f, 0.07256021f, 0.07191375f, -0.09332979f, 0.02751165f, 
    0.09676809f, 0.02439415f, 0.08939827f, 0.02420900f, 0.10379839f, 0.09611610f, 0.14045173f, 0.21430288f, 
    -0.28458220f, -1.30994380f, -0.10757280f, 0.16214330f, 0.58029646f, -0.08627588f, 0.21311389f, 0.22551721f, 
    0.12993385f, 0.00060459f, 0.07691770f, -0.06043017f, -0.05163347f, 0.06471134f, -0.09544134f, -0.09428574f, 
    0.00406337f, -0.05073243f, 0.01677498f, -0.15610002f, -0.45190117f, 0.22312218f, 0.20436117f, -0.09269741f, 
    -0.09899998f, -0.08480598f, 0.05921436f, -0.01228858f, -0.00376600f, -0.01457678f, 0.01119623f, -0.08263532f, 
    0.08741932f, 0.15048060f, 0.07384438f, -0.01353925f, 0.13309656f, 0.06035377f, 0.04011242f, -0.01981097f, 
    0.16127492f, -0.29138649f, -0.56058228f, -0.33567649f, -0.21358867f, -0.07970212f, -0.04682935f, 0.09007335f, 
    0.03197005f, 0.02686110f, 0.15422101f, -0.13699463f, 0.23661934f, -0.09947129f, -0.18167320f, 0.03157873f, 
    0.05002424f, -0.02688838f, 0.07943405f, -0.08349679f, 0.16215892f, -0.30190167f, -0.25524521f, -0.08013495f, 
    0.11300220f, -0.06819860f, -0.06990471f, -0.06799555f, -0.05821605f, -0.07926393f, -0.15539004f, -0.00140814f, 
    -0.03518780f, 0.02604447f, -0.07652608f, -0.00402035f, 0.06901372f, 0.22607052f, 0.19456603f, 0.14765397f, 
    -0.27360013f, 0.20155138f, 0.22694467f, 0.16202562f, 0.23468460f, 0.21036230f, -0.13270801f, 0.17730522f, 
    0.14348271f, -0.04819107f, -0.05976180f, 0.03000411f, 0.15756923f, -0.03819685f, 0.06920791f, -0.25681677f, 
    -0.18856433f, 0.26418325f, 0.00737252f, 0.26992878f, -0.90829277f, 0.40436533f, 0.51408505f, 0.18783109f, 
    -0.26777178f, 0.00107088f, -0.11905873f, -0.09295870f, -0.08925376f, -0.12120055f, -0.07760140f, -0.12401884f, 
    -0.01043591f, -0.15035626f, -0.13402577f, -0.12954572f, -0.32376894f, -0.22266468f, -0.30295229f, -0.09198214f, 
    0.00063814f, -0.14249496f, -0.14290190f, -0.12580854f, -0.23131925f, -0.19009186f, -0.13659704f, -0.04958918f, 
    -0.09470920f, 0.00569119f, 0.02637454f, 0.15032752f, -0.07382118f, -0.00107811f, 0.17699808f, -0.05321104f, 
    0.27412036f, 0.14721371f, 0.16675036f, 0.22953922f, 0.58061296f, 0.19357865f, 0.20142852f, -0.34882683f, 
    0.02413782f, 0.10464841f, -0.38441613f, -0.23513263f, -0.22751994f, -0.37728187f, 0.05410375f, 0.05040902f, 
    0.06693136f, 0.01560257f, 0.03731994f, 0.19969967f, 0.21102528f, -0.10943489f, -0.08429608f, -0.48754176f, 
    0.25068530f, 0.19385342f, -0.07669292f, -0.21407534f, -0.14963719f, -0.19451067f, -0.01248362f, -0.17553866f, 
    0.13377459f, -0.07379087f, 0.00603790f, 0.23917736f, 0.23657420f, 0.08438757f, 0.23129302f, -0.09412497f, 
    -0.15371414f, -0.17468956f, -0.01651499f, -0.05232998f, -0.23334505f, -0.57547772f, -0.35847822f, -0.02280638f, 
    0.03773138f, -0.15914591f, 0.25263739f, 0.24354908f, 0.09545540f, 0.22349253f, 0.18138957f, -0.07535335f, 
    -0.14475639f, -0.14281549f, -0.10092196f, -0.12357320f, 0.12625235f, 0.00755491f, 0.16605860f, -0.01868653f, 
    0.31266207f, -0.18519309f, -1.02527308f, -0.62093395f, -0.25151816f, -0.25071830f, -0.28273571f, 0.08605420f, 
    0.14376435f, -0.16615410f, -0.03376122f, -0.07904995f, -0.06976007f, 0.13520443f, 0.12562929f, 0.04287674f, 
    -0.05856228f, 0.07084525f, -0.16256049f, -0.14644834f, 0.02781138f, -0.51574409f, -1.53342688f, -0.16541988f, 
    0.16913031f, 0.17420062f, -0.05021125f, 0.33724630f, 0.13365667f, -0.04279790f, -0.03815503f, -0.05429880f, 
    -0.04126160f, -0.06047078f, 0.03728820f, 0.12574773f, -0.05789509f, -0.08896302f, -0.18757120f, -0.08351070f, 
    0.27094468f, 0.41067389f, -0.04610628f, -0.27654353f, 0.24266534f, 0.10263069f, -0.30375254f, -0.14849897f, 
    -0.00949007f, -0.27732700f, -0.04297063f, 0.10901141f, 0.22501172f, -0.02778728f, -0.34765771f, 0.24224207f, 
    -0.10894369f, -0.20736332f, -0.13477254f, 0.00632588f, 0.32060084f, -0.68982297f, -0.21449298f, 0.19514327f, 
    -0.33737361f, 0.05982912f, -0.27084303f, 0.09735823f, 0.17887798f, 0.03977942f, -0.00316629f, 0.05588627f, 
    -0.02224682f, -0.13521130f, 0.10057235f, 0.15547732f, 0.16044907f, 0.05820689f, 0.06689449f, 0.34025308f, 
    -0.94374043f, -0.30014190f, 0.00134019f, -0.29829794f, 0.20604491f, -0.19366580f, 0.42709824f, -0.62923914f, 
    0.12708256f, 0.00138537f, -0.06820379f, -0.07707193f, -0.21945813f, 0.02585758f, 0.02337434f, 0.30533075f, 
    -0.11944581f, -0.10812806f, -0.19278975f, -0.06286969f, -0.42636752f, -0.22072554f, 0.24562235f, 0.20398144f, 
    -0.42593476f, -0.19231579f, -0.29424140f, 0.26568791f, -0.02074238f, 0.19733056f, -0.00610185f, -0.00604436f, 
    0.03324869f, -0.04509857f, -0.11163159f, 0.01576350f, -0.07020807f, 0.06657205f, -0.11854977f, -0.27939233f, 
    0.24478777f, -0.25255683f, 0.58925503f, 0.13056485f, -0.82290083f, 0.10159186f, -0.25666755f, -0.34589151f, 
    0.12548219f, -0.10826018f, -0.02700484f, 0.05178903f, 0.04732168f, 0.21012361f, -0.05088218f, 0.08457964f, 
    0.01739985f, -0.00160757f, 0.00624717f, 0.12215236f, -0.45290741f, 0.03567998f, -0.09384169f, -0.12173767f, 
    0.25787479f, 0.06271151f, 0.31864280f, 0.23801053f, 0.02651655f, -0.15328810f, 0.22149220f, -0.06475093f, 
    0.04891272f, -0.14703640f, 0.06929143f, 0.28638566f, 0.07665113f, -0.07303931f, 0.10069438f, -0.06741185f, 
    -0.51575810f, 0.60919893f, -0.04650210f, 0.84733289f, 0.17861883f, -0.11651025f, -0.15102422f, -0.49232060f, 
    -0.20742932f, -0.34877935f, 0.22916022f, -0.21960771f, -0.08508068f, -0.07723127f, 0.08206441f, 0.15919493f, 
    -0.10222557f, -0.17495178f, 0.08514482f, 0.02121330f, -0.10678946f, 0.49546850f, 0.45411700f, -0.13835865f, 
    -0.20903149f, 0.20981692f, -0.07690731f, 0.08050316f, -0.05905007f, 0.07744303f, -0.02565292f, 0.06906310f, 
    0.06302270f, -0.10013617f, -0.10747162f, -0.00706899f, -0.12667999f, -0.09481803f, -0.06277511f, -0.27891707f, 
    0.30562532f, -0.62161613f, -0.16024747f, -0.33903995f, 0.36568967f, -0.46135676f, 0.17259073f, 0.13422027f, 
    0.08219337f, 0.37833193f, -0.01842763f, 0.04478686f, 0.03502804f, -0.33402684f, -0.20149446f, 0.07609273f, 
    0.14804091f, 0.07678067f, -0.27835575f, 0.00674724f, -0.23360969f, -0.11310556f, -0.89483207f, 0.13648221f, 
    0.03042183f, 0.10188325f, 0.15237492f, 0.36651069f, 0.08060663f, 0.07796571f, -0.07232706f, -0.03439393f, 
    -0.00752076f, -0.01145928f, -0.03599575f, -0.01520364f, 0.22436440f, -0.00801845f, -0.00500660f, 0.11740994f, 
    -0.06369802f, -0.00266719f, -0.05374445f, 0.20852396f, 0.18613556f, -0.05357384f, 0.20710671f, -0.04867113f, 
    -0.10785580f, -0.09607189f, -0.11066748f, -0.03939380f, 0.04970296f, -0.02433485f, 0.08277426f, 0.27901164f, 
    -0.18529706f, 0.05328207f, -0.12817557f, 0.00289040f, -0.07174023f, 0.10253996f, -1.16656530f, 0.33103234f, 
    -0.31778136f, -0.00190255f, 0.02863025f, 0.26011232f, -0.26220697f, 0.13128684f, 0.02213076f, 0.01504563f, 
    -0.00578286f, -0.03935054f, -0.06916229f, -0.06267449f, 0.10645423f, -0.01096698f, 0.19354606f, 0.05152699f, 
    -0.60109770f, 0.04287051f, -0.24272464f, 0.61558855f, 0.03887132f, 0.00260142f, -0.02623355f, -0.13561855f, 
    0.06279687f, -0.20717242f, 0.19110090f, -0.15973158f, 0.08918428f, -0.33166701f, -0.06702913f, 0.17156279f, 
    0.06041382f, -0.07842527f, 0.14221601f, 0.17619489f, -0.13338326f, -0.00771698f, 0.69521266f, -0.01859929f, 
    -0.51390958f, 0.26269042f, -0.40190598f, -0.35678753f, -0.05270574f, 0.00541429f, -0.14007732f, 0.07538743f, 
    -0.06960063f, 0.04192762f, 0.05535800f, 0.00261488f, -0.12193701f, -0.13370237f, 0.03164621f, 0.01403896f, 
    -0.22449578f, -0.44794753f, 0.51645952f, 0.50922287f, -0.54219216f, -0.04415997f, -0.33833241f, 0.12106875f, 
    0.08023509f, 0.23887140f, 0.09037269f, 0.12967542f, 0.08443376f, 0.05872289f, -0.02608388f, -0.04818776f, 
    0.10206766f, 0.01362041f, 0.27691144f, 0.28196159f, 0.04219065f, -0.15345736f, -0.06826560f, 0.33443037f, 
    -1.25842381f, -0.10616054f, 0.01716126f, -0.28854370f, 0.09992758f, 0.02392545f, 0.19470239f, -0.05491986f, 
    0.00381922f, 0.04050030f, 0.12296895f, -0.00534193f, 0.15467559f, 0.02477311f, 0.03457907f, 0.12110770f, 
    0.05012127f, -0.33579251f, 0.31660959f, 0.76195008f, 0.15255293f, 0.00094533f, -0.03055493f, -0.22797900f, 
    -0.28351218f, 0.09025759f, -0.40359434f, 0.12671813f, 0.10620183f, -0.01480524f, -0.04661375f, 0.01903692f, 
    -0.18352623f, 0.11388247f, 0.31851864f, 0.09132347f, -0.58179957f, 0.11181468f, -0.43921328f, 0.29865098f, 
    -0.13989852f, -0.26489148f, 0.05863105f, -0.04362528f, -0.09111870f, 0.01126108f, 0.10456123f, 0.16404971f, 
    -0.23248984f, 0.18034707f, -0.03142337f, -0.01378259f, -0.23054545f, 0.02974386f, -0.37233800f, -0.12261850f, 
    0.23428194f, -0.40714118f, 0.86147112f, -0.03278407f, -0.10821878f, -0.04117213f, -0.38195390f, -0.03703671f, 
    0.05659158f, -0.03768300f, -0.09758982f, 0.18825750f, 0.05444661f, 0.22490610f, 0.05890084f, -0.17926717f, 
    0.18321978f, 0.10386890f, 0.01326406f, -0.06101178f, -0.78410351f, 0.07736434f, 0.21781868f, -0.09037171f, 
    0.31706053f, -0.09900669f, 0.01904685f, -0.07943850f, 0.04185612f, -0.06043135f, -0.15542640f, 0.07067709f, 
    -0.02050169f, 0.25438127f, 0.03828222f, 0.23037326f, 0.09238862f, -0.19851492f, 0.22258979f, 0.13798884f, 
    -0.11398701f, 0.45658299f, -0.21727546f, 0.26794681f, 0.08942600f, 0.09232349f, -0.15462503f, 0.01262071f, 
    0.01399895f, 0.01322049f, -0.10842238f, -0.05108555f, 0.01477091f, 0.01226592f, -0.05809283f, -0.18874076f, 
    -0.11876427f, -0.07625403f, -0.03742349f, -0.05106634f, -0.30335706f, -0.78062797f, 0.11154895f, -0.61471033f, 
    -0.22866040f, -0.07740459f, -0.17935267f, -0.23323022f, 0.13755819f, -0.07377151f, -0.17752340f, -0.01407200f, 
    0.18078321f, -0.13273214f, 0.22418551f, 0.03323354f, 0.09857960f, 0.17988573f, 0.12878335f, -0.07759662f, 
    0.78317326f, 0.32713383f, 0.61021650f, -0.15229101f, -0.33069608f, 0.05483410f, -0.14276828f, 0.10586833f, 
    -0.04376110f, -0.10927384f, -0.18984596f, 0.18572082f, 0.04071788f, -0.00484278f, 0.06461101f, 0.02398214f, 
    -0.31753328f, 0.14711232f, 0.17423572f, -0.10027268f, -0.48119354f, -0.40821356f, 0.07365613f, 0.30663925f, 
    0.06873790f, -0.17106746f, 0.18021062f, 0.18011153f, -0.06691790f, 0.02332081f, -0.04215738f, -0.11320542f, 
    0.11862380f, 0.18407074f, 0.14966877f, 0.24677609f, 0.16615076f, 0.09901227f, 0.25332779f, 0.48108450f, 
    0.10338007f, 0.19868536f, 0.40706465f, 0.63478291f, -0.12119956f, -0.01444942f, -0.17151655f, -0.02710711f, 
    -0.06656901f, 0.09945903f, -0.24684884f, 0.03540593f, -0.15929097f, 0.13977814f, 0.13727470f, 0.18923303f, 
    0.12279230f, 0.16864048f, -0.09198700f, 0.16512322f, -0.03508497f, -0.51252168f, -0.43987468f, -0.03497644f, 
    0.01657422f, -0.43030909f, -0.15988830f, -0.26406091f, -0.24476475f, -0.29031292f, -0.14779381f, 0.08481497f, 
    -0.24424645f, 0.03544525f, 0.07508106f, 0.23397134f, -0.23355170f, -0.21791834f, -0.08655743f, -0.11929466f, 
    -0.05791342f, -0.55030680f, 0.03295904f, -0.24867582f, -0.35301355f, -0.12164166f, 0.17459249f, 0.12641078f, 
    -0.16453817f, 0.05938728f, -0.02570042f, 0.03434736f, 0.13422678f, -0.06563877f, -0.03674295f, -0.13028502f, 
    0.28336063f, 0.18969776f, 0.23387018f, 0.22050898f, -0.01009026f, -0.11297276f, -0.19811764f, -0.12743342f, 
    0.07813842f, -0.08868907f, -0.04691706f, 0.26138809f, -0.22817323f, -0.15963505f, -0.04788133f, 0.09405176f, 
    0.01142290f, 0.05959281f, -0.07134089f, 0.38387668f, -0.24777327f, -0.14880233f, -0.34595618f, -0.31513402f, 
    0.48420566f, -0.38237500f, 0.41202781f, -0.26048946f, -0.05724585f, 0.02638515f, -0.23875682f, 0.08894459f, 
    0.14583947f, -0.06490862f, -0.13517871f, -0.04284021f, -0.29275438f, 0.03918349f, -0.05820421f, -0.15988493f, 
    -0.18767920f, 0.10868607f, -0.24939725f, -0.22442323f, -0.43357545f, 0.11360109f, 0.15117095f, 0.12871091f, 
    -0.21663280f, -0.02877778f, 0.11079384f, -0.46422583f, 0.11652942f, 0.04595556f, 0.18475433f, -0.13094057f, 
    0.08678532f, -0.15437336f, 0.00130748f, 0.02657404f, 0.00077732f, 0.05280826f, 0.06843837f, 0.14207983f, 
    -0.60878032f, 0.26481795f, -0.90111977f, 0.02291416f, 0.05642873f, 0.00029339f, -0.18576445f, -0.17615095f, 
    -0.02537596f, -0.00987567f, -0.09307546f, 0.16939877f, -0.04015515f, -0.02220999f, -0.01214323f, 0.02403561f, 
    -0.11433524f, -0.07791828f, -0.08751731f, -0.24065994f, -0.13946298f, 0.06859823f, -0.00812981f, 0.21763329f, 
    0.21780676f, -0.07014838f, 0.00986666f, 0.24675030f, 0.04865706f, 0.16448860f, -0.16037838f, 0.24393642f, 
    -0.08637825f, -0.17986678f, -0.36252895f, 0.06444287f, -0.04182830f, 0.08376025f, -0.01294980f, -0.05750988f, 
    -0.63126689f, -0.37082359f, 0.07713919f, 0.42698565f, -0.34647211f, 0.06585528f, 0.15619531f, 0.18852948f, 
    0.03934832f, -0.06875026f, -0.01164337f, -0.15880466f, -0.17499681f, -0.07044168f, 0.05570491f, 0.09209462f, 
    -0.04774075f, 0.03758344f, 0.07257158f, -0.21467265f, -0.37739375f, -0.88876081f, 0.06628459f, -0.16102882f, 
    -0.16665536f, 0.02520362f, -0.02405437f, -0.12205233f, -0.04879807f, -0.23695968f, -0.08935852f, -0.02807911f, 
    0.21665736f, 0.01767048f, -0.02915285f, 0.21999156f, -0.05906233f, 0.25409251f, 0.26765421f, -0.08943196f, 
    -0.69994092f, 0.35992572f, -0.62625831f, 0.27797401f, 0.25705445f, 0.18655680f, 0.30934709f, 0.35139561f, 
    -0.46196404f, 0.14436263f, -0.08999442f, 0.15439394f, -0.20405437f, 0.10291681f, 0.19130909f, 0.01921450f, 
    -0.14991833f, 0.20332341f, 0.22982937f, -0.19407141f, 0.18253602f, -0.66124612f, -0.08622960f, -0.31245673f, 
    -0.00207063f, -0.02556432f, -0.40056795f, -0.07046295f, -0.13181159f, -0.09367189f, 0.01633977f, 0.00890612f, 
    -0.09641057f, -0.02543254f, -0.12251370f, 0.01723645f, -0.01625787f, 0.07556656f, -0.14167482f, -0.14087382f, 
    -1.23861134f, 0.16244565f, -0.83327579f, 0.70599085f, -0.61437017f, -0.07965638f, 0.16332865f, -0.18969420f, 
    0.42244300f, 0.06546449f, -0.21880278f, -0.12423797f, 0.09161246f, 0.06539115f, 0.05774163f, -0.00695077f, 
    0.08660398f, 0.06637894f, -0.07995783f, 0.19014624f, 0.44972491f, 0.11820033f, 0.20103438f, 0.44153592f, 
    0.03029238f, -0.05557074f, 0.40761900f, -0.08579360f, 0.39188746f, -0.07735763f, -0.38368216f, -0.13377655f, 
    0.06652928f, 0.02443642f, -0.11310025f, 0.06163838f, -0.02127811f, 0.06532422f, -0.32201573f, 0.01199148f, 
    -0.47253233f, -0.59224981f, 0.34838867f, -0.26080421f, -0.01699036f, 0.29707530f, 0.47065541f, 0.17331846f, 
    -0.29408374f, 0.23423479f, -0.12830353f, 0.07939494f, 0.20880285f, 0.28636679f, 0.19144581f, 0.10733715f, 
    0.07298719f, -0.08908088f, -0.07814414f, 0.17804563f, 0.12004464f, -0.28956673f, 0.18944393f, 0.06708489f, 
    0.18752874f, -0.25403017f, -0.03217307f, -0.00102755f, -0.00965968f, -0.37551531f, 0.10317715f, 0.03550548f, 
    -0.12622987f, -0.19325921f, 0.02727259f, -0.07129524f, -0.10123139f, 0.18004614f, -0.04405160f, -0.49697629f, 
    -0.33033779f, 0.37000009f, 0.12353767f, 0.73872179f, -0.29675132f, -0.18262200f, 0.15774198f, -0.00999398f, 
    -0.06157305f, 0.30904537f, -0.05834082f, -0.10417741f, 0.06214780f, 0.20015152f, -0.08002003f, 0.16084941f, 
    -0.08210583f, 0.00212510f, -0.01953991f, -0.09351375f, 0.91940415f, -0.21032538f, 0.62574375f, -0.29267281f, 
    -0.32172292f, -0.09057254f, -0.09756160f, -0.23313813f, -0.06854173f, -0.11027438f, -0.27151090f, 0.01505070f, 
    -0.08442006f, -0.10022945f, -0.08483287f, -0.00329531f, 0.28681484f, -0.03246326f, 0.06537265f, -0.02339782f, 
    -0.28113925f, 0.11249363f, -0.15835840f, -0.08323684f, -0.11346091f, -0.17064735f, -0.01840364f, 0.04360418f, 
    -0.01132745f, 0.09260090f, -0.12285390f, 0.28187376f, -0.18228814f, -0.01806470f, -0.03974162f, 0.08732549f, 
    -0.25707349f, -0.23504506f, -0.35404754f, -0.23594514f, 0.29917681f, -0.39360070f, 0.22661281f, -0.19261436f, 
    0.27972326f, -0.09961942f, -0.51054794f, -0.04208574f, -0.02383914f, -0.18036535f, 0.04697758f, 0.11480156f, 
    -0.02216334f, -0.06931978f, 0.00816285f, -0.01035599f, -0.02817067f, -0.00798878f, 0.02115626f, 0.22096843f, 
    -0.30333635f, -0.22104238f, -0.23200107f, -0.11972396f, 0.43098444f, 0.08505505f, 0.26912823f, 0.24431783f, 
    -0.03870016f, 0.01749348f, 0.11964828f, 0.10131606f, 0.06234402f, 0.16880910f, -0.13581324f, -0.05803081f, 
    0.22217417f, 0.17305937f, 0.21533018f, 0.02775225f, -0.10236419f, -0.41634020f, -0.48511988f, 0.46633336f, 
    -0.01339900f, -0.04363831f, -0.06622627f, -0.02436154f, 0.32212439f, -0.26169765f, 0.12751521f, -0.00943608f, 
    0.00667162f, -0.18403035f, 0.04918487f, -0.00910630f, -0.12325782f, 0.05496467f, -0.03008271f, 0.03613140f, 
    0.31719473f, -0.42901051f, -0.36548579f, -0.33674404f, 0.17649157f, -0.09107124f, -0.15280135f, 0.13114081f, 
    0.07215003f, -0.11367428f, -0.01434222f, 0.04961814f, 0.18490513f, -0.12242679f, -0.10897309f, 0.11165117f, 
    -0.19107679f, 0.02457319f, 0.02851896f, 0.01382148f, 0.23234119f, -0.30704141f, 0.68699169f, -0.48272887f, 
    -0.49124417f, 0.05375846f, -0.10759654f, -0.01285522f, -0.04349066f, 0.04229789f, -0.11019178f, 0.05130991f, 
    0.26075339f, 0.19362891f, 0.11694679f, 0.01017558f, 0.06175466f, 0.03126426f, 0.21745552f, 0.09253580f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.33050519f, 0.24694657f, 0.05154631f, -0.23903699f, -0.07406507f, 0.05353581f, 0.04742162f, -0.19896244f, 
    0.10309353f, 0.08762335f, 0.03501198f, -0.05633366f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
