#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.64718831f, 1.03571475f, -0.37355399f, -0.22465089f, -0.53334737f, -0.02591015f, -0.13607651f, -0.35137334f, 
    -0.51701576f, 0.32621998f, 0.39397150f, 0.06942932f, -0.24786399f, 0.66541111f, -0.28314668f, 0.24378401f, 
    0.64365405f, -0.37090752f, -0.74155062f, -0.53507948f, -0.38892531f, -0.56985724f, -0.81177747f, -0.55639112f, 
    -0.10926308f, -0.24821477f, -0.30522436f, -0.20995997f, -0.47027612f, 0.26806465f, -1.14541090f, -0.72783256f, 
    0.20365784f, -0.61073422f, -0.63533163f, -0.29165003f, 0.41086516f, 0.05428141f, 0.31667084f, -0.76551157f, 
    0.56881851f, 0.69544232f, 0.14658812f, -0.47627115f, 0.34006646f, -0.30909413f, -0.31484264f, 0.52194560f, 
    1.00437677f, -0.13417225f, -0.10015730f, 0.12964778f, 0.26626039f, -0.22115232f, -1.43468285f, 0.50010592f, 
    0.64526790f, -0.22397883f, 0.24511810f, -0.17396867f, -0.17684239f, -0.55224997f, -0.62818462f, 0.02513521f, 
    0.52938735f, 0.41816005f, -0.14536807f, 0.56365097f, 0.34997785f, 0.36783198f, 0.09861852f, -0.09566431f, 
    -0.88255429f, -0.15521662f, -0.46738443f, -0.76994485f, -0.41774684f, -0.98249668f, 0.32264596f, 0.57131934f, 
    0.16005641f, -0.33619383f, -0.50973678f, -0.36939377f, 0.00566204f, -0.34781885f, -0.31099394f, 0.43277872f, 
    0.22416171f, 0.59693921f, 1.35943842f, -1.47403622f, -1.13869166f, 0.45955199f, -0.29191905f, 0.71027464f, 
    -0.07423317f, 0.29447421f, -0.17128174f, 0.39036536f, 0.74325496f, 0.83879119f, -1.32906103f, -0.83187294f, 
    -0.19171435f, 0.26838493f, 0.09722851f, 0.30209187f, 0.59220564f, -0.71213585f, -0.22366144f, 0.75509536f, 
    0.15957397f, 0.55241507f, -0.18305552f, -0.64999586f, -0.21489130f, 1.02710545f, -0.44458911f, -0.70289707f, 
    -0.32380202f, 0.18825829f, -0.34711686f, 0.06090562f, 0.21565607f, 0.44472679f, 0.64226240f, 0.38052237f, 
    0.20060542f, -0.50785077f, -0.61895400f, 0.13245763f, -0.49435261f, -0.19270153f, 0.77617449f, -0.32058114f, 
    -0.53270638f, -1.25894570f, -0.11005909f, 0.84792936f, -0.36897016f, -0.24760063f, -0.55422914f, -0.62243640f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.40286329f, 0.08575527f, -0.24026655f, 0.30991799f, 0.00807891f, 0.38387182f, 0.08790456f, -0.17837977f, 
    -0.07635956f, 0.41908368f, 0.49804604f, 0.25284305f, 0.20585136f, 0.43201381f, -0.11641853f, -0.31582689f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00384282f, -0.03774953f, -0.01117862f, -0.05165999f, -0.00932231f, 0.01357043f, -0.05951304f, -0.02853890f, 
    -0.04053037f, -0.05338185f, -0.02232699f, 0.03679379f, -0.03395469f, -0.06018546f, 0.03513538f, -0.00328612f, 
    0.02510554f, -0.04189517f, 0.02009175f, -0.04382668f, -0.03762691f, -0.03218765f, 0.04455446f, -0.03167089f, 
    0.01661912f, 0.01552905f, -0.04254216f, 0.00011886f, -0.00540843f, 0.02305845f, -0.04906513f, -0.04030123f, 
    -0.03435897f, -0.04565300f, -0.06132401f, -0.03644039f, 0.02333226f, 0.01799101f, 0.04316217f, 0.02243326f, 
    -0.00080753f, -0.02694168f, 0.00005090f, -0.00427780f, 0.03665726f, -0.04637446f, 0.02302037f, 0.03108276f, 
    -0.02648017f, 0.04834441f, 0.01250351f, 0.02518373f, -0.05536365f, -0.02138244f, 0.01622797f, -0.01391385f, 
    0.03756033f, -0.02227889f, -0.02837527f, -0.02880419f, 0.00735536f, -0.00437084f, 0.03211261f, 0.01981127f, 
    0.04982372f, -0.03768438f, -0.03198152f, -0.04350515f, 0.00452643f, -0.02570079f, -0.04885345f, -0.04984384f, 
    0.00308064f, -0.00126079f, 0.02581680f, -0.04093039f, -0.03704865f, -0.04388103f, 0.01581448f, -0.02978972f, 
    -0.05561702f, 0.00998241f, -0.01959251f, -0.03800185f, -0.05052510f, -0.03811947f, 0.00813732f, -0.04060384f, 
    0.02792015f, -0.05814312f, 0.01154024f, 0.01455101f, 0.03764780f, 0.03561674f, -0.01975882f, 0.01424721f, 
    -0.03807206f, 0.01585164f, -0.04233423f, -0.03992849f, 0.00419444f, -0.00465037f, -0.04877141f, -0.00523990f, 
    -0.05104076f, 0.02140219f, -0.02952570f, 0.03052605f, 0.04026735f, 0.00852509f, -0.04216293f, 0.02642236f, 
    -0.04581429f, 0.01465964f, -0.06297298f, -0.04970343f, -0.00527262f, 0.00857823f, -0.02984025f, 0.04803823f, 
    0.00496130f, 0.01100721f, 0.02853779f, -0.00898057f, -0.03788179f, -0.05575335f, 0.01899831f, -0.02187761f, 
    0.02098001f, -0.01165312f, -0.01165573f, 0.03376617f, 0.00335295f, -0.05573928f, 0.03609638f, -0.01723671f, 
    0.03667074f, -0.00689853f, 0.02580042f, -0.01318103f, -0.02247554f, 0.00513990f, -0.00098249f, -0.04345538f, 
    -0.00657988f, 0.04575581f, -0.05290628f, -0.02600172f, -0.02436574f, 0.03252858f, 0.02286228f, 0.03856137f, 
    -0.00354115f, 0.03027372f, -0.01946889f, -0.03000727f, 0.02120026f, -0.00712947f, -0.03947347f, 0.01650016f, 
    -0.03773683f, 0.00106412f, -0.03864738f, -0.04296107f, 0.00110050f, -0.05331735f, 0.02647848f, 0.02648183f, 
    -0.01000729f, -0.04090853f, 0.01839537f, -0.03738252f, 0.03359424f, 0.00036485f, 0.00759762f, -0.04671957f, 
    0.01245002f, 0.01670163f, 0.01613716f, -0.05644947f, -0.00141336f, -0.02173683f, 0.04636649f, 0.03769687f, 
    -0.04152501f, -0.05466757f, 0.02053685f, -0.03092494f, -0.04368396f, -0.01707474f, 0.02679773f, -0.02326977f, 
    -0.03249878f, -0.00122832f, 0.03032375f, 0.03917926f, 0.04016276f, -0.04217835f, -0.03023245f, 0.00631354f, 
    -0.04027468f, -0.01494446f, -0.05402607f, 0.04635504f, -0.02951043f, -0.01042774f, 0.02292768f, -0.03715913f, 
    -0.01271875f, -0.06092428f, 0.03857095f, 0.02729142f, -0.05167708f, 0.01896640f, -0.05061115f, -0.01268384f, 
    -0.00887360f, -0.04448099f, -0.02293249f, 0.04243916f, -0.00453051f, -0.05955867f, -0.02121101f, -0.00774853f, 
    0.02254518f, 0.01235118f, 0.04356724f, 0.00452101f, 0.02617205f, -0.05593440f, 0.02838012f, 0.03609795f, 
    0.04703560f, 0.03424205f, -0.01875688f, -0.03534672f, 0.04491360f, -0.02555575f, -0.02084631f, 0.00500219f, 
    -0.03890231f, -0.02723057f, -0.00490276f, -0.02398136f, 0.01801637f, -0.02545256f, -0.00028027f, 0.01228106f, 
    -0.00856627f, 0.00012731f, -0.03664122f, 0.00153840f, 0.03647019f, 0.01156172f, 0.00420183f, -0.01589034f, 
    -0.00259430f, 0.05343053f, 0.00438047f, 0.02045362f, -0.05694114f, -0.02207295f, -0.04491925f, -0.02547575f, 
    -0.05050378f, 0.00358609f, 0.00349829f, -0.03416311f, -0.03345175f, 0.04043702f, -0.02139235f, -0.01897508f, 
    0.01731322f, -0.04376710f, -0.00340904f, -0.01545433f, -0.02926549f, -0.00715903f, 0.00181933f, 0.00811642f, 
    -0.04914931f, 0.01261272f, 0.01263535f, -0.05990875f, -0.03897259f, 0.00617779f, 0.02111349f, 0.02470826f, 
    0.00498639f, 0.01313667f, -0.01626668f, -0.02283126f, -0.04480041f, 0.02104386f, 0.02190807f, 0.00485578f, 
    -0.04833840f, 0.04185945f, 0.00325969f, -0.05164504f, 0.00263635f, 0.04385075f, 0.04575203f, -0.05974325f, 
    -0.03345209f, -0.04867707f, -0.02635016f, -0.05220544f, -0.03657633f, -0.03513227f, -0.05012726f, 0.04187259f, 
    -0.05107626f, -0.02456666f, -0.02040646f, -0.05761955f, -0.01075601f, 0.00817312f, -0.03349133f, 0.03984318f, 
    0.09775870f, 0.00357683f, 0.09383925f, 0.14539374f, -0.15285145f, -0.06816468f, -0.09954768f, -0.07590060f, 
    -0.01075139f, 0.07580210f, -0.05521716f, -0.04230573f, -0.03001761f, 0.04973525f, -0.05648199f, 0.11141081f, 
    0.08291125f, 0.03209824f, 0.07097469f, 0.09447803f, 0.16998437f, 0.08457298f, 0.17814904f, -0.00844742f, 
    0.04096374f, -0.16662569f, 0.04243258f, -0.04222805f, 0.11119659f, -0.07983658f, -0.00537428f, 0.04643333f, 
    0.04526634f, -0.05935158f, 0.00744376f, 0.02340906f, -0.00843062f, -0.12476074f, -0.00053943f, 0.05367501f, 
    0.21976449f, 0.32647920f, -0.00753573f, 0.18269959f, 0.26214758f, -0.00450659f, 0.03673592f, 0.00763225f, 
    0.06820563f, 0.32916135f, -0.04910104f, 0.07367322f, 0.00844247f, -0.06041034f, 0.02483227f, 0.08301619f, 
    -0.05615152f, -0.03975094f, -0.05123428f, 0.18207720f, -0.19880714f, 0.19515093f, -0.00963948f, -0.14089736f, 
    0.16757557f, 0.04508223f, 0.03955635f, -0.05457697f, -0.03726457f, -0.01732861f, -0.07231698f, 0.04627876f, 
    -0.00913512f, -0.07027463f, -0.00964589f, 0.07599462f, -0.02490624f, 0.13373163f, -0.09037187f, 0.16186935f, 
    0.13561174f, -0.07618126f, 0.29463083f, 0.10425178f, 0.03052634f, 0.03074266f, 0.06334504f, 0.01966904f, 
    0.08100681f, -0.23328288f, -0.06345791f, -0.09566126f, -0.00259853f, -0.06702060f, 0.03461873f, 0.04086134f, 
    -0.00797772f, 0.13120189f, -0.09484503f, -0.18546592f, 0.19684707f, 0.15922521f, -0.04849860f, 0.20942420f, 
    0.09091751f, 0.00840404f, -0.15943556f, 0.12252939f, -0.01006979f, -0.17530088f, -0.15990399f, -0.03853006f, 
    -0.03963070f, -0.00569679f, 0.02121814f, 0.02496801f, -0.01683587f, -0.04428590f, 0.03347205f, -0.17476264f, 
    0.16394278f, -0.46786681f, -0.13002691f, -0.20851351f, 0.19531636f, 0.09366652f, 0.09208661f, 0.19131158f, 
    -0.12179128f, 0.10827890f, 0.14208521f, 0.04921526f, 0.02659893f, -0.01365378f, 0.06561600f, 0.08625498f, 
    -0.05906057f, -0.00000985f, 0.04974995f, 0.23596056f, 0.19948760f, -0.03538289f, 0.14374261f, 0.14285600f, 
    0.16453905f, -0.09149216f, 0.03510949f, 0.08289702f, 0.02836628f, -0.03108922f, 0.03567552f, 0.07904261f, 
    0.09310221f, -0.11147562f, -0.04753740f, -0.03997452f, -0.02047710f, -0.10859621f, -0.01011370f, -0.04785048f, 
    0.14140001f, 0.45887107f, -0.06380238f, 0.31024876f, 0.15810196f, -0.01367447f, -0.10960416f, -0.13415332f, 
    -0.01784650f, 0.32377726f, 0.01415564f, 0.06392156f, 0.02174298f, 0.05742029f, -0.08788053f, -0.03374712f, 
    -0.05487308f, -0.14533536f, -0.13950428f, -0.03908218f, -0.17133535f, -0.07414418f, -0.05161697f, 0.14311789f, 
    0.09073236f, 0.08376370f, 0.11945120f, 0.32201463f, 0.03513897f, 0.00842714f, -0.04861308f, 0.06251161f, 
    0.05075137f, 0.02971419f, -0.01409363f, 0.00907236f, -0.16727643f, -0.04482655f, -0.11825812f, -0.16567732f, 
    0.34775561f, 0.09629522f, 0.06387273f, 0.17169873f, -0.35068056f, -0.06471959f, -0.21381740f, -0.09379815f, 
    -0.03296331f, -0.02889225f, -0.09569822f, 0.09881938f, -0.14329126f, 0.08609478f, 0.09221132f, -0.02179241f, 
    0.01966201f, -0.06522419f, -0.08490305f, 0.06034530f, 0.14098620f, 0.14738531f, 0.63070291f, -0.09654496f, 
    -0.01952926f, 0.00286690f, -0.00059291f, -0.05920785f, 0.04963908f, 0.01515022f, -0.04450339f, -0.03199299f, 
    0.04112454f, -0.00041066f, -0.05104549f, 0.04750201f, -0.00182764f, -0.24065217f, 0.09407859f, 0.03882030f, 
    0.18081586f, -0.06296305f, 0.12700729f, 0.33475381f, -0.27237022f, -0.06364788f, 0.02927681f, 0.04808138f, 
    -0.03185102f, -0.11221994f, 0.03187937f, -0.04493472f, -0.11658169f, -0.08440389f, -0.07578633f, -0.00249773f, 
    -0.02944973f, -0.02157716f, 0.01245262f, 0.02528821f, -0.17883880f, -0.03820909f, 0.13534530f, 0.04375139f, 
    -0.16912703f, -0.06563815f, -0.01989734f, 0.08457099f, 0.08618549f, 0.08613125f, 0.05509489f, 0.00181434f, 
    0.24445227f, 0.04787113f, 0.09863265f, -0.09897145f, -0.06357987f, -0.10883450f, 0.11946987f, -0.10901302f, 
    0.29549628f, 0.09802938f, 0.52569795f, -0.18985787f, -0.13824387f, 0.07289086f, -0.14548658f, -0.21984266f, 
    -0.15392457f, 0.07001851f, -0.02718993f, 0.10011335f, -0.01424713f, 0.05473674f, -0.13767479f, -0.12203522f, 
    0.17227504f, -0.22220714f, 0.04279994f, -0.19246766f, 0.34328887f, 0.20050026f, 0.33768290f, 0.21157688f, 
    -0.24635704f, 0.13057359f, -0.01044207f, 0.07866436f, -0.07727270f, 0.17490801f, -0.03052341f, 0.03195593f, 
    -0.00978648f, 0.02654844f, 0.10089777f, 0.15281606f, 0.07357274f, -0.05503682f, 0.04393170f, 0.23785052f, 
    -0.09953427f, -0.32854319f, 0.74136788f, -0.14781284f, -0.07695261f, 0.01123580f, -0.05574799f, -0.09701452f, 
    0.03684244f, 0.05204928f, 0.02643959f, -0.07166848f, 0.04631090f, 0.01429647f, 0.09828597f, -0.00217497f, 
    -0.02902231f, 0.14238347f, 0.22976439f, -0.03996949f, -0.04364591f, -0.09572759f, -0.11613666f, -0.06214898f, 
    -0.04366286f, -0.20296709f, -0.15162595f, -0.20545977f, 0.02493476f, 0.01978752f, 0.11687467f, -0.12638451f, 
    -0.00894331f, 0.11804028f, -0.03931393f, -0.04940012f, -0.01166383f, -0.21211922f, 0.18414441f, -0.13346678f, 
    -0.10994204f, -0.08217701f, -0.10085566f, 0.16111475f, -0.03243309f, 0.15293533f, -0.05760219f, -0.06496176f, 
    0.09667478f, -0.13663477f, -0.01456413f, -0.08024853f, -0.03631098f, -0.09648643f, -0.00294656f, -0.06872975f, 
    -0.01535579f, 0.14694215f, -0.35714820f, 0.15403916f, -0.02222628f, 0.05975816f, -0.13647388f, 0.08989463f, 
    0.05019471f, 0.17269357f, -0.05978923f, -0.00285577f, 0.00669635f, 0.03377453f, -0.02112921f, 0.01290283f, 
    0.01220794f, -0.12866230f, -0.11403155f, -0.26262617f, -0.10052586f, 0.20184998f, -0.04327378f, 0.04357580f, 
    -0.05417854f, -0.04727035f, -0.08823566f, 0.14703353f, -0.02349632f, 0.02126493f, 0.01454132f, 0.03866442f, 
    -0.18802913f, 0.01744638f, 0.04567428f, 0.07601271f, 0.11432844f, -0.09746777f, -0.01339388f, -0.14200656f, 
    0.04756936f, 0.08530106f, 0.08178061f, 0.00647826f, 0.07882598f, 0.11222714f, -0.07104579f, -0.14932109f, 
    0.14455591f, 0.04670077f, -0.08036141f, 0.05573445f, 0.23473309f, 0.05257391f, 0.12099866f, -0.02076605f, 
    0.22213764f, 0.08976740f, 0.04667245f, -0.03160542f, -0.02947823f, -0.04134793f, 0.04684627f, -0.14626788f, 
    0.19176386f, 0.21089065f, 0.26029179f, -0.09966808f, 0.39770168f, 0.08576738f, 0.03953117f, -0.10217483f, 
    -0.10661496f, 0.10078330f, 0.09155124f, 0.06150020f, 0.03100283f, -0.07931363f, 0.07909480f, 0.07425576f, 
    0.08607008f, 0.07233841f, 0.31997812f, 0.09343018f, -0.02149776f, 0.00249036f, 0.09238586f, -0.05103946f, 
    0.07594447f, -0.01635485f, -0.17453827f, -0.05990875f, 0.02582737f, 0.06225780f, 0.08395583f, -0.00115615f, 
    0.06892630f, 0.01439566f, 0.06126193f, -0.14334874f, -0.08256609f, -0.11752065f, 0.10314836f, 0.00503958f, 
    0.04915578f, -0.41128629f, -0.54830915f, 0.13934590f, 0.04233208f, 0.08120686f, 0.07636385f, -0.20172779f, 
    0.05238202f, -0.19013895f, 0.05265558f, 0.10366032f, -0.06363665f, 0.01415124f, 0.00401138f, -0.07488084f, 
    -0.07996760f, 0.03127145f, -0.07668041f, -0.06518275f, -0.13934052f, -0.22445716f, -0.17302150f, 0.29807654f, 
    0.28433129f, 0.05372166f, 0.00059824f, 0.14370041f, 0.19042976f, -0.11436101f, 0.07409602f, 0.11507628f, 
    0.02571327f, 0.07568996f, -0.05491747f, -0.04237523f, 0.00143741f, 0.16464068f, -0.09092221f, -0.01071619f, 
    0.41698590f, 0.57252890f, 0.04081978f, 0.08756942f, 0.30300549f, -0.03743044f, 0.21616566f, 0.23229744f, 
    -0.30146763f, 0.11519603f, 0.11401063f, 0.14336291f, 0.10521857f, 0.02196041f, 0.12859534f, 0.01181564f, 
    0.02174241f, 0.08703420f, -0.03233488f, 0.01790570f, 0.16302004f, -0.14465165f, 0.32203597f, -0.24244189f, 
    0.05793029f, 0.02468353f, 0.04119113f, -0.14881054f, 0.03641684f, 0.11373964f, 0.04822852f, -0.11877512f, 
    0.09370324f, 0.09024066f, 0.03351593f, -0.00338060f, -0.08293853f, 0.00801886f, 0.04992697f, -0.00539078f, 
    0.30199817f, 0.50290161f, 0.16498604f, 0.04442527f, 0.11138764f, -0.03892786f, 0.04194757f, 0.03379131f, 
    -0.08797346f, 0.00506965f, 0.18230115f, -0.18215641f, 0.20153426f, -0.02761191f, 0.12097270f, 0.15693390f, 
    0.25442067f, 0.18121308f, 0.04383396f, -0.11743958f, -0.17025027f, 0.11138710f, -0.24652708f, 0.20481969f, 
    0.07538737f, -0.05835606f, -0.05366538f, 0.03662484f, -0.09894433f, -0.04350168f, 0.36907533f, 0.31412634f, 
    0.05053109f, 0.06872675f, 0.08001564f, 0.03901243f, -0.01629462f, 0.07680932f, 0.16193983f, -0.08435828f, 
    -0.23139529f, 0.34116134f, -0.18107912f, -0.18860067f, 0.01967681f, 0.13091859f, 0.11760598f, 0.11016705f, 
    -0.24702489f, 0.10462607f, 0.04332438f, 0.01967310f, 0.06219948f, 0.03241445f, -0.01106719f, 0.10442627f, 
    0.23159455f, -0.11097283f, -0.12899479f, 0.01108659f, 0.19233583f, -0.01353728f, 0.22418188f, -0.01876883f, 
    -0.03140685f, 0.21840666f, -0.03441325f, 0.11333877f, 0.15487081f, 0.01184705f, -0.02790156f, -0.09291990f, 
    0.09913532f, -0.26872280f, 0.10309491f, 0.13474603f, 0.00685130f, -0.41485620f, 0.17802683f, 0.02373479f, 
    0.63873535f, -0.04355369f, 0.12163355f, 0.03724798f, 0.37633577f, 0.04825137f, 0.11539108f, -0.09614319f, 
    0.09870937f, 0.16424268f, -0.00185438f, 0.21399759f, -0.02729264f, -0.16526631f, -0.07266918f, 0.08225656f, 
    -0.00842777f, -0.01592806f, 0.08466161f, 0.23126893f, -0.10977049f, -0.06608159f, 0.05171248f, -0.27736425f, 
    -0.11649931f, 0.24197321f, 0.12969661f, 0.06544909f, -0.19326401f, 0.15897724f, 0.02190675f, -0.08763074f, 
    0.10074131f, 0.05681667f, 0.07064647f, 0.20912096f, -0.08968210f, 0.00818473f, -0.21409342f, -0.32870647f, 
    -0.27377421f, -0.33615136f, -0.07460275f, 0.41668612f, -0.00173782f, -0.18780188f, -0.06362620f, -0.06813832f, 
    0.06015588f, 0.13659082f, 0.02796942f, 0.13877976f, -0.08116224f, 0.08978726f, -0.01626747f, 0.06060511f, 
    0.12215410f, -0.11111449f, -0.04149864f, 0.01197946f, 0.00375996f, -0.36428240f, -0.08784765f, 0.52901083f, 
    -0.01335307f, 0.04034420f, 0.08131327f, 0.02837068f, 0.11638842f, 0.23638201f, 0.07331827f, 0.08878145f, 
    0.09838233f, 0.07313816f, 0.09571542f, 0.01324329f, 0.15886439f, -0.08316897f, 0.00155698f, 0.24953242f, 
    0.07971684f, -0.30122921f, -0.24293132f, -0.16490546f, -0.46899003f, 0.12253352f, -0.34280494f, -0.06400715f, 
    -0.13017295f, -0.09299086f, 0.11175711f, -0.04531815f, 0.07811507f, -0.02405457f, 0.17144358f, -0.07161426f, 
    -0.14208193f, -0.09119254f, 0.03396929f, 0.17654659f, -0.05594426f, 0.10800827f, 0.10726469f, 0.02813149f, 
    -0.13363269f, 0.07372443f, 0.04592934f, -0.04902538f, -0.07825198f, -0.10152645f, 0.01849576f, 0.14028656f, 
    -0.05868502f, 0.03785774f, -0.13286071f, 0.00089057f, -0.22573061f, -0.00656127f, 0.14647463f, -0.18370634f, 
    0.02695530f, -0.03314164f, -0.02694893f, 0.48477751f, -0.17466998f, 0.07271302f, 0.02849922f, 0.06032387f, 
    0.08849072f, 0.03370163f, -0.20525947f, 0.02758635f, 0.09265255f, -0.03247765f, -0.08301930f, -0.02097526f, 
    0.11156264f, 0.11517496f, 0.08874889f, 0.22641462f, -0.01974496f, -0.22084087f, -0.14304174f, -0.27089086f, 
    -0.34500924f, 0.35239729f, 0.05022851f, -0.22161718f, -0.05041686f, 0.21128218f, 0.10245477f, 0.10776530f, 
    -0.00740473f, 0.15965612f, 0.12333360f, 0.15495375f, -0.05821757f, -0.17320788f, -0.11325596f, -0.09112702f, 
    0.07477557f, -0.29484552f, 0.21720995f, 0.32833505f, 0.10944657f, 0.14406416f, -0.03250806f, 0.14764628f, 
    -0.21275580f, 0.07438158f, 0.02532877f, -0.11799407f, -0.04965341f, -0.07162734f, -0.09247720f, -0.00938824f, 
    -0.06970436f, -0.02765008f, -0.13047038f, -0.00356159f, 0.24117744f, -0.29083574f, 0.32205126f, 0.33279607f, 
    0.11096816f, -0.00769356f, -0.03571665f, 0.07384185f, -0.07805202f, 0.02919356f, 0.20648716f, 0.08004772f, 
    -0.14231604f, -0.08511768f, -0.05969033f, 0.05555076f, -0.04531489f, -0.13101251f, -0.13539045f, -0.18592520f, 
    -0.65284127f, 0.06598153f, 0.79833949f, 0.08864685f, 0.10685270f, -0.16719264f, -0.01425219f, 0.21420841f, 
    0.06146808f, -0.09670050f, -0.05384582f, -0.05874776f, -0.00614284f, 0.04677331f, 0.08979323f, 0.01895233f, 
    -0.06823847f, 0.08855028f, 0.08222927f, -0.06689170f, -0.61022359f, -0.26498517f, 0.25686020f, 0.59946942f, 
    -0.12100416f, 0.18857385f, -0.09166045f, -0.11827400f, -0.01843554f, 0.13669841f, 0.08138656f, -0.00430222f, 
    -0.15901120f, 0.04765202f, -0.14182346f, 0.01931528f, -0.12680520f, 0.02106542f, -0.16693161f, -0.04852577f, 
    -0.57794726f, 0.04905319f, -0.16121916f, -0.24687076f, -0.24454172f, 0.13888900f, 0.03158626f, 0.01476577f, 
    -0.02522022f, -0.02002734f, -0.23995410f, 0.18657318f, 0.20795329f, 0.08509197f, 0.10681653f, -0.01926195f, 
    -0.08608247f, 0.09767701f, 0.26741675f, 0.06560527f, -0.44192258f, -0.19999257f, 0.64583749f, 0.05521488f, 
    0.50178027f, 0.12547629f, 0.05930432f, 0.15335234f, 0.12165122f, 0.06784560f, -0.08293819f, -0.05894218f, 
    0.10591848f, -0.12765564f, -0.13968283f, 0.11036006f, -0.01510360f, -0.11476612f, -0.11649080f, -0.11253224f, 
    -0.25997046f, 0.11634269f, 0.35968143f, 0.12032590f, 0.06259197f, -0.02509032f, -0.09106530f, -0.22481234f, 
    0.22425012f, 0.10343013f, -0.05291784f, -0.05290955f, 0.03806390f, -0.19503711f, -0.09549066f, 0.02767511f, 
    0.04232562f, 0.18691403f, -0.11202591f, -0.07688273f, -0.50476515f, -0.10349491f, 0.17767604f, 0.26277444f, 
    0.31986877f, -0.19728696f, -0.17051908f, -0.14944534f, 0.09276615f, 0.00444911f, -0.06421063f, 0.05465971f, 
    0.26077780f, 0.13185744f, -0.05330083f, -0.05690983f, 0.26201755f, 0.02998118f, 0.16087590f, -0.03214219f, 
    0.60702384f, 0.44400474f, -0.24030006f, -0.00151803f, -0.07456891f, 0.14281540f, 0.06130030f, 0.00083658f, 
    -0.04098417f, 0.10729793f, -0.06104926f, 0.04538175f, 0.04301037f, 0.01518960f, -0.00340769f, 0.09372643f, 
    0.04759993f, 0.04001749f, 0.06418699f, -0.00726094f, 0.09467852f, 0.02345734f, -0.02346581f, 0.07834270f, 
    0.17884268f, 0.09250265f, 0.03208741f, -0.05157360f, 0.00528185f, 0.09043316f, 0.15634057f, -0.01171455f, 
    -0.02465435f, 0.09276188f, 0.13389930f, 0.01759489f, -0.07259263f, -0.04121840f, 0.03641789f, -0.11563749f, 
    -0.12549329f, 0.02444766f, 0.27823466f, 0.17428924f, -0.23017663f, 0.07770713f, 0.00174645f, 0.13633722f, 
    -0.05570609f, -0.11738682f, 0.03532947f, 0.03749334f, 0.05731925f, 0.04916410f, 0.03126647f, 0.05989342f, 
    0.09472980f, 0.00065347f, 0.04853094f, -0.01598072f, -0.01146282f, 0.11673943f, 0.02744850f, 0.23254611f, 
    -0.14481027f, 0.24088003f, 0.00781195f, 0.03278065f, -0.04444176f, 0.10673238f, -0.03855140f, 0.08293322f, 
    0.07780077f, 0.05429310f, 0.02506710f, 0.02070446f, 0.05129517f, -0.14194079f, 0.06382025f, 0.21512154f, 
    0.11465260f, -0.10727968f, 0.01191173f, 0.11217882f, 0.34279746f, -0.00117983f, -0.03147673f, 0.04920167f, 
    -0.06953895f, 0.08972523f, -0.07736201f, 0.05213581f, -0.00400852f, 0.13251938f, 0.03610346f, -0.07281949f, 
    0.05252729f, 0.02191747f, -0.01848118f, 0.09258646f, 0.22508989f, -0.31312910f, -0.06271861f, 0.14647983f, 
    0.25861347f, -0.01063588f, -0.04275371f, -0.09515301f, 0.08043969f, 0.05966970f, 0.21015657f, 0.14453524f, 
    0.15555249f, 0.21322644f, 0.00509157f, 0.05861112f, -0.06665257f, -0.02634118f, 0.08574509f, 0.05618608f, 
    -0.57864296f, -0.16421396f, -0.07274105f, 0.50528216f, -0.16346331f, 0.26709116f, -0.12321926f, 0.00766369f, 
    0.14476137f, -0.11230746f, 0.01491986f, -0.00102869f, 0.03951394f, -0.03065832f, -0.11607464f, 0.16761956f, 
    0.09016649f, 0.05345565f, -0.10386398f, 0.00012188f, 0.07926641f, -0.04876149f, -0.04290316f, 0.08267751f, 
    0.21504289f, 0.09200842f, 0.03869854f, -0.11102258f, 0.04598708f, 0.11030080f, -0.01200915f, -0.19669522f, 
    -0.09020617f, 0.19630067f, -0.04254986f, 0.05747951f, 0.05232732f, 0.02521649f, 0.04795326f, -0.02976203f, 
    -0.22968343f, -0.15201250f, 0.38144183f, 0.21970583f, -0.33801728f, -0.06701919f, 0.09742854f, -0.14110716f, 
    -0.04010039f, -0.19456574f, 0.02574783f, -0.03836580f, 0.04184463f, -0.00479685f, -0.11018229f, -0.04634383f, 
    -0.04208511f, -0.02032293f, 0.07482582f, -0.06993122f, 0.10889930f, 0.03417083f, 0.23354217f, 0.02822124f, 
    -0.11650907f, -0.04347349f, 0.05709860f, -0.09780828f, 0.05877192f, -0.09329305f, 0.01327261f, 0.07154164f, 
    0.05508593f, 0.00890504f, 0.06172666f, -0.01081951f, 0.00718433f, -0.06829163f, 0.02723273f, 0.01201339f, 
    0.20826814f, -0.10540675f, 0.10837130f, 0.03552339f, -0.41474116f, 0.03672327f, -0.01903775f, -0.00039738f, 
    0.16942722f, 0.05914399f, 0.17640115f, 0.07141566f, -0.08063973f, -0.07771049f, 0.03308536f, -0.04512933f, 
    -0.05142596f, -0.04784531f, 0.10703085f, 0.03419052f, -0.28836572f, 0.23898119f, -0.16276324f, 0.23692395f, 
    -0.18216538f, 0.18167216f, -0.01154380f, -0.04907151f, -0.06076326f, 0.18554291f, -0.05368890f, -0.01933926f, 
    0.02052270f, 0.04715662f, -0.06468693f, 0.04324581f, -0.02939332f, -0.03971164f, -0.15429953f, -0.11521989f, 
    0.51738060f, -0.50394952f, 0.02168362f, -0.09212365f, 0.29290488f, -0.14742218f, -0.11527367f, -0.06992928f, 
    -0.02933706f, -0.12412894f, 0.08131190f, 0.15760715f, 0.07800162f, 0.02645958f, 0.00847041f, -0.00291862f, 
    -0.10928670f, 0.03784930f, 0.03998722f, -0.13130300f, 0.26698962f, -0.08790120f, 0.24661048f, -0.36558074f, 
    -0.01096257f, 0.02949660f, 0.16934933f, -0.04363713f, -0.12371995f, 0.01209749f, 0.17424032f, -0.08093053f, 
    0.03602818f, 0.00623169f, 0.11164957f, -0.00881473f, 0.05988249f, -0.01928251f, 0.08736346f, 0.19042706f, 
    0.02596079f, 0.15078570f, -0.17492248f, 0.14976045f, -0.00670723f, -0.05733642f, 0.11308221f, 0.06757755f, 
    -0.13735120f, 0.05356792f, -0.12740247f, -0.11634552f, 0.00648634f, 0.01540705f, -0.10687495f, 0.00130144f, 
    -0.09016866f, -0.09107329f, -0.26804385f, -0.00703394f, -0.32651934f, -0.11762451f, 0.39491656f, 0.04491511f, 
    -0.13429609f, -0.05360360f, -0.00118293f, 0.00534068f, 0.05094805f, -0.07253930f, 0.04430307f, -0.06546895f, 
    -0.01630203f, -0.11538391f, -0.09042859f, -0.07198154f, -0.13062453f, -0.13858625f, 0.04135609f, -0.03785752f, 
    0.41747758f, -0.18015043f, -0.14566481f, 0.33992046f, 0.51518947f, 0.06477668f, 0.00498680f, -0.01596690f, 
    -0.00839929f, -0.06282324f, -0.02870261f, -0.00545086f, -0.07225853f, -0.15755132f, -0.12064721f, -0.02350187f, 
    0.07440041f, -0.21617724f, -0.07008160f, -0.12554695f, -0.15287209f, 0.16384073f, -0.29157943f, 0.10592679f, 
    0.04590705f, 0.03803786f, 0.11829642f, -0.02364031f, -0.09587973f, -0.05460529f, -0.06770059f, 0.15445170f, 
    -0.07240520f, 0.16633204f, 0.07173654f, 0.14418569f, 0.24116345f, 0.22157924f, -0.04636174f, -0.01180456f, 
    -0.12183183f, -0.25728968f, 0.15157974f, -0.00299596f, -0.01030892f, 0.14904144f, -0.21561605f, 0.20989513f, 
    0.02254835f, -0.07937771f, 0.05203013f, 0.03676631f, 0.06156451f, -0.02618641f, -0.00334951f, 0.09738205f, 
    0.05414369f, -0.00640077f, 0.03563068f, -0.07222339f, 0.38669598f, -0.02736100f, 0.29088339f, 0.07582229f, 
    0.08162323f, 0.20151483f, -0.19049294f, 0.22707249f, 0.17477480f, 0.05383743f, 0.08295394f, 0.07675234f, 
    0.11202189f, 0.06832192f, 0.07040964f, 0.09903802f, 0.07455940f, -0.09019519f, -0.08000392f, -0.28874665f, 
    -0.09008833f, -0.05883361f, 0.22114155f, -0.11904993f, 0.24210359f, 0.03009487f, -0.05712906f, -0.07551631f, 
    0.00950271f, -0.05304922f, 0.00725091f, -0.06111755f, -0.03331585f, 0.00789021f, 0.04219243f, 0.07202376f, 
    0.07128726f, -0.02731123f, -0.00398465f, 0.01020235f, -0.48912689f, -0.16913345f, -0.20854442f, 0.06731407f, 
    -0.11901402f, -0.11435191f, 0.11032521f, 0.01645564f, -0.20383883f, -0.05902697f, 0.31064382f, 0.13864262f, 
    0.13719727f, 0.15990771f, 0.06170824f, 0.10758775f, -0.01415925f, 0.00549325f, 0.04883862f, 0.07944781f, 
    -0.33753574f, 0.35015666f, 0.19243149f, 0.07425576f, -0.10589898f, -0.08341133f, 0.05351043f, 0.11725342f, 
    0.11229736f, -0.05207004f, -0.07819151f, -0.04530827f, -0.07673106f, -0.03619953f, 0.12914252f, -0.01802861f, 
    -0.05644129f, 0.05410615f, -0.00467564f, -0.31440839f, -0.23615888f, 0.10243991f, -0.13179132f, 0.07271122f, 
    -0.03700437f, -0.04428931f, 0.03512095f, -0.13398001f, -0.03416666f, -0.03327367f, -0.07996866f, 0.02593784f, 
    -0.01386035f, -0.03238676f, 0.06581501f, 0.08977921f, 0.20520191f, 0.07826781f, -0.04468736f, 0.03098241f, 
    -0.22856350f, -0.20113291f, 0.19049804f, -0.17865692f, -0.06500064f, 0.15622278f, -0.06527039f, 0.21513146f, 
    0.08628196f, -0.03506844f, -0.06221463f, -0.13843875f, -0.10146819f, -0.07356772f, 0.04675198f, -0.09382456f, 
    0.08674147f, 0.11650157f, 0.11265274f, 0.16588011f, -0.01662475f, -0.14474025f, 0.03001203f, -0.18992612f, 
    -0.13716380f, -0.09789196f, -0.17017967f, -0.01509613f, 0.07259704f, 0.27013183f, 0.09992043f, 0.02886331f, 
    -0.12825996f, -0.11834356f, -0.07641417f, -0.03799741f, 0.10813539f, 0.05243496f, -0.02044017f, 0.13870001f, 
    -0.22414619f, -0.70930636f, 0.08311022f, -0.10567663f, -0.07954551f, 0.31906798f, 0.05205905f, -0.08363550f, 
    0.22954206f, 0.13409731f, 0.03129471f, 0.12706408f, 0.08529707f, -0.10966938f, 0.06777755f, -0.08207083f, 
    -0.07544066f, 0.11448248f, 0.05099471f, -0.02624265f, 0.46103415f, 0.65645182f, 0.03124115f, 0.21791227f, 
    0.00103186f, 0.25514442f, -0.06643455f, 0.06660400f, 0.04034435f, -0.12573439f, -0.03371752f, 0.06083310f, 
    -0.02245975f, -0.04702994f, -0.00328205f, -0.09320280f, 0.07416803f, 0.13780823f, -0.08264029f, 0.03362460f, 
    -0.12542935f, 0.09214348f, -0.20252484f, -0.04961992f, 0.08242401f, -0.05754405f, -0.13617714f, -0.08093469f, 
    -0.03013495f, -0.22762609f, 0.04480894f, -0.00051778f, -0.01277967f, 0.10884482f, 0.13692014f, 0.06274743f, 
    -0.13290180f, 0.08731466f, -0.22052401f, -0.03084643f, 0.26296702f, -0.17216417f, 0.11978672f, 0.05645933f, 
    0.14831777f, 0.04295762f, 0.00724229f, 0.01892191f, 0.06641828f, 0.15257046f, 0.00348177f, -0.00048567f, 
    -0.14500099f, -0.10763189f, -0.13014266f, -0.05638748f, 0.20511724f, 0.13997622f, 0.06752870f, 0.12304285f, 
    0.33967113f, 0.29466036f, -0.01854772f, 0.17605874f, -0.05750832f, 0.24751219f, 0.04538055f, 0.22442512f, 
    0.09305556f, 0.18591321f, -0.01311119f, -0.01056502f, 0.02949700f, -0.09133705f, 0.05894820f, 0.11019866f, 
    0.08141919f, 0.21491410f, 0.12947933f, 0.04876579f, -0.20032831f, 0.14636616f, -0.46704453f, -0.04063433f, 
    0.23210075f, -0.11165484f, -0.02172102f, -0.04562743f, 0.24389312f, -0.02911010f, -0.08407686f, -0.18469870f, 
    -0.05060242f, 0.04926910f, 0.08117718f, -0.04554347f, -0.14207299f, 0.16078772f, 0.04314335f, -0.07065476f, 
    -0.28347224f, 0.17186269f, 0.28489500f, 0.06451088f, 0.27011743f, 0.07389058f, 0.06173520f, -0.01104360f, 
    0.05579296f, 0.03153699f, 0.05657448f, 0.00504552f, 0.02498796f, -0.08752165f, -0.00995250f, -0.00596463f, 
    -0.05774921f, 0.03634049f, -0.01060197f, 0.11137328f, -0.14929090f, 0.11648731f, 0.06730849f, 0.01575834f, 
    0.01736899f, 0.19230305f, -0.00254345f, 0.10245654f, -0.01934367f, 0.01015009f, -0.00032519f, -0.02988477f, 
    0.07750557f, 0.03495678f, 0.09459285f, 0.09095479f, -0.00042442f, 0.05961058f, -0.05771919f, -0.04936983f, 
    0.08019290f, -0.16285412f, -0.03400046f, -0.15018523f, 0.09358096f, 0.01182903f, 0.21316029f, -0.00458435f, 
    0.08680581f, -0.08154143f, 0.06340747f, -0.01892734f, -0.04229508f, 0.16333444f, 0.02893333f, 0.00480846f, 
    -0.03680344f, -0.04968836f, -0.14606556f, -0.17539734f, 0.37606448f, -0.18619579f, 0.29121023f, 0.12161879f, 
    0.02531573f, -0.07429054f, 0.22514427f, 0.01673533f, 0.04543041f, 0.17043296f, -0.01770368f, -0.00436976f, 
    -0.00690208f, -0.01363005f, -0.01491875f, 0.17014530f, 0.07307848f, -0.17147487f, -0.10052828f, -0.11862357f, 
    -0.02646795f, 0.03645086f, -0.07949372f, -0.05359247f, -0.17684168f, 0.02228692f, 0.04309533f, -0.09891248f, 
    0.06107953f, 0.10488343f, -0.00293353f, 0.03876994f, 0.07671761f, 0.07443791f, 0.06746451f, 0.15361729f, 
    -0.09113299f, -0.01184392f, -0.01951061f, -0.00981279f, -0.04335130f, 0.09101963f, -0.05100311f, -0.23191324f, 
    -0.16840497f, 0.08636389f, 0.01844918f, 0.00622274f, 0.01910031f, 0.08772735f, 0.03459393f, -0.00412192f, 
    -0.12916373f, -0.05326489f, 0.08311763f, -0.14438118f, 0.06636591f, 0.08517451f, 0.13481709f, 0.02972627f, 
    0.76544696f, 0.57209569f, 0.21260744f, -0.04121226f, -0.17089155f, -0.00620460f, -0.05346614f, -0.18393794f, 
    0.15203500f, -0.10266680f, -0.19450600f, -0.02270341f, -0.11899910f, 0.02501465f, 0.00081654f, -0.03948328f, 
    -0.03106547f, -0.02770141f, -0.08687016f, -0.03596729f, -0.09813063f, 0.09567714f, -0.07649866f, 0.00179158f, 
    -0.15533213f, 0.15689027f, 0.00673283f, -0.02297375f, 0.01904237f, -0.00133262f, -0.05143533f, -0.00662191f, 
    -0.11722928f, 0.18583360f, 0.17402250f, 0.15754522f, 0.01959918f, 0.03179384f, -0.02365565f, -0.04295249f, 
    0.48949036f, 0.04810484f, 0.11369093f, -0.13884255f, 0.11497160f, 0.19469653f, 0.10616273f, 0.24548033f, 
    0.06722615f, -0.01827189f, 0.06798485f, 0.03742208f, 0.09062371f, -0.03897900f, 0.04050722f, -0.00280685f, 
    0.01073874f, 0.03929019f, 0.27009627f, 0.32700568f, 0.20010179f, -0.05239918f, -0.08639547f, -0.14490849f, 
    0.03425475f, 0.02519024f, -0.08129623f, -0.10382409f, -0.06394400f, 0.07076294f, 0.13949779f, 0.06190554f, 
    -0.03241237f, -0.05390100f, -0.00545651f, 0.07700990f, 0.06177072f, -0.01435627f, 0.10809319f, 0.16177051f, 
    -0.53809714f, -0.07274826f, -0.05487964f, -0.02674286f, 0.70319963f, 0.03008573f, 0.20343557f, 0.04880860f, 
    0.02136708f, 0.06391753f, 0.11932570f, -0.08048917f, 0.04780113f, 0.13511185f, -0.11465310f, -0.10145998f, 
    0.05650178f, -0.07449329f, 0.09290349f, -0.14468870f, -0.34225604f, -0.08527845f, 0.30125168f, 0.32598153f, 
    0.01466483f, -0.08867987f, -0.04011389f, 0.03805754f, -0.08332535f, 0.08434027f, 0.03948482f, 0.08548125f, 
    -0.04266053f, 0.00588081f, 0.03046647f, -0.02120511f, -0.01329113f, 0.07055242f, -0.15366268f, 0.09646105f, 
    -0.51502687f, 0.15453215f, -0.04466074f, -0.41980499f, -0.04342325f, 0.13042541f, 0.07553868f, -0.02864037f, 
    0.01392072f, 0.10951830f, -0.04783108f, 0.10082001f, -0.12814260f, 0.03148053f, 0.04888377f, -0.29500681f, 
    -0.07936876f, 0.00019130f, 0.00857590f, -0.06984890f, -0.07785700f, -0.16253750f, -0.03714963f, 0.18557262f, 
    0.21238212f, 0.05656028f, 0.08200215f, -0.06106079f, -0.04271425f, 0.07571217f, -0.04416183f, -0.11650670f, 
    -0.03874866f, -0.03045888f, -0.19416094f, 0.02947188f, 0.15482771f, -0.02096783f, 0.05905073f, 0.12384626f, 
    -0.16212200f, -0.22771953f, 0.15606235f, 0.30524746f, 0.21636194f, -0.26909715f, 0.19633070f, 0.03800574f, 
    0.19946125f, 0.01450921f, 0.07725084f, 0.05832016f, 0.06312688f, 0.00440583f, 0.10893475f, 0.10105512f, 
    -0.29829851f, 0.19385831f, -0.04120375f, 0.06027917f, -0.12715398f, 0.17076628f, -0.22539255f, -0.01430603f, 
    0.71039599f, -0.05669489f, 0.12240027f, 0.12899472f, -0.11298209f, 0.08869500f, -0.02823044f, -0.00655191f, 
    -0.07387896f, 0.22588363f, 0.14644463f, -0.23264067f, -0.07333816f, 0.25226325f, -0.05524046f, -0.17733987f, 
    -0.04432586f, 0.01420276f, -0.00129234f, -0.03878693f, -0.06190014f, 0.03433136f, -0.04400035f, 0.01017374f, 
    0.02840209f, -0.03823196f, -0.02439290f, 0.03961696f, 0.01060140f, -0.05548713f, -0.03672018f, -0.00283313f, 
    -0.00205547f, 0.04043458f, -0.01079321f, -0.03414662f, -0.00167088f, 0.03218273f, -0.03786173f, -0.04675543f, 
    0.00673420f, 0.02253081f, -0.04595359f, -0.02535754f, 0.04582975f, 0.04842694f, -0.02443324f, 0.05256494f, 
    -0.03727562f, -0.05912833f, 0.01337561f, 0.01964240f, 0.03881038f, 0.03270186f, -0.05388067f, 0.02927977f, 
    0.03497427f, -0.00652806f, 0.03259149f, -0.00126347f, 0.02433181f, -0.05247541f, 0.00476461f, -0.03267471f, 
    -0.02252344f, -0.06258067f, 0.03063692f, 0.01315408f, 0.01109426f, -0.03301010f, -0.03188797f, 0.01234467f, 
    0.01256513f, -0.00097851f, 0.04332980f, 0.00382448f, 0.01674097f, -0.05762701f, 0.01788891f, -0.04935239f, 
    -0.00764701f, 0.03889271f, -0.01667005f, 0.01320548f, -0.06222754f, 0.00998349f, -0.04077745f, 0.02440647f, 
    -0.00595356f, -0.04913285f, 0.03001420f, 0.03913253f, 0.04157415f, -0.01315600f, -0.06188048f, -0.01481634f, 
    -0.04011821f, -0.01336241f, 0.01921033f, 0.01457772f, -0.01118047f, 0.04618473f, 0.00212854f, -0.03902470f, 
    -0.04370468f, 0.04225563f, 0.00981236f, -0.04414466f, -0.00861256f, -0.01347462f, -0.00304309f, -0.04334731f, 
    0.01776402f, -0.05715236f, -0.00862096f, 0.00030395f, -0.02380026f, 0.00243138f, 0.04086726f, -0.05425586f, 
    0.03187330f, -0.06105387f, 0.00684341f, -0.03232752f, -0.06058725f, -0.01643982f, 0.01417333f, -0.01310665f, 
    0.02357540f, 0.01524094f, 0.01637492f, -0.04490148f, -0.02030507f, 0.02915168f, -0.02487330f, -0.01902821f, 
    -0.03785295f, -0.02300939f, 0.01717331f, 0.01152142f, 0.04593917f, -0.05066302f, 0.00222532f, -0.00167071f, 
    -0.02510693f, 0.01115407f, 0.02758536f, -0.01073296f, 0.03259864f, -0.02454315f, -0.02542404f, -0.05366762f, 
    -0.05656767f, -0.02712350f, -0.00637485f, 0.03114424f, 0.00122483f, 0.01061106f, -0.03303370f, 0.00515548f, 
    -0.00060379f, -0.04744257f, -0.00968275f, 0.01279832f, -0.03767254f, -0.01665278f, 0.06214239f, -0.04868089f, 
    -0.04659382f, 0.01056174f, -0.04373140f, -0.02727018f, 0.04979680f, -0.03147277f, -0.01534548f, 0.01639548f, 
    0.03607710f, -0.02866957f, -0.02800888f, 0.02722903f, 0.00067895f, -0.04226803f, -0.02720360f, -0.02425526f, 
    -0.02672777f, -0.00478861f, -0.00702659f, 0.03955022f, 0.01867946f, -0.05710843f, -0.03864973f, -0.05655146f, 
    0.00301684f, -0.00657284f, 0.01156639f, -0.05922043f, 0.03484077f, 0.00665835f, -0.03054035f, 0.03623256f, 
    0.03256956f, -0.02849466f, 0.03069624f, -0.05414264f, 0.02314869f, -0.02962468f, 0.04400360f, 0.00782970f, 
    0.00944287f, -0.01062096f, -0.01408291f, 0.00223856f, 0.03976253f, -0.00786189f, 0.03636374f, -0.05851164f, 
    -0.00828411f, -0.01904063f, 0.02659482f, -0.02618194f, -0.01508408f, -0.02755051f, -0.00211858f, -0.00047072f, 
    -0.02539416f, -0.00230789f, -0.01549389f, -0.01871697f, 0.03959883f, -0.00143062f, 0.04839528f, 0.00225664f, 
    -0.05417690f, -0.00032209f, -0.04139674f, 0.00260889f, -0.05823103f, 0.01101407f, -0.02260436f, 0.04676282f, 
    0.04328278f, -0.03584758f, -0.04759605f, -0.03243940f, 0.04028793f, -0.02103118f, -0.00206045f, -0.04247965f, 
    -0.00597215f, -0.05606875f, 0.00506827f, -0.02427201f, -0.00878606f, 0.03020961f, 0.02430743f, -0.00823646f, 
    -0.04431539f, -0.02085107f, -0.02670162f, 0.01718044f, 0.04131345f, -0.04216939f, 0.04784216f, -0.01242912f, 
    -0.05182501f, -0.05456799f, -0.05590874f, -0.00003024f, 0.02426469f, -0.03851838f, -0.04384273f, -0.05881884f, 
    -0.01941212f, -0.01702788f, -0.05257846f, -0.02664944f, 0.02841506f, 0.03985994f, -0.04604490f, -0.04577680f, 
    -0.00813348f, -0.05382604f, -0.02627427f, -0.04635337f, 0.02332889f, -0.02070936f, 0.03110713f, 0.01021375f, 
    -0.01827506f, 0.04566597f, -0.06011224f, -0.02541469f, -0.06187726f, -0.00054787f, 0.04786653f, -0.00253246f, 
    -0.01638433f, 0.01727536f, -0.03382749f, 0.00144010f, 0.03266236f, 0.01809771f, 0.01724682f, 0.02034122f, 
    -0.03567217f, 0.01872606f, -0.04594944f, -0.01191629f, 0.04775461f, -0.01545429f, -0.04720385f, -0.00664659f, 
    -0.01717800f, 0.01865831f, 0.03961674f, -0.00591530f, 0.04592422f, 0.01080772f, 0.04386223f, -0.02986741f, 
    0.04194484f, -0.00138866f, 0.03015515f, -0.01312857f, -0.04159411f, 0.03848458f, -0.02846235f, 0.04546868f, 
    0.03032313f, -0.04943817f, 0.04118698f, 0.01668974f, 0.00866827f, 0.00828756f, -0.02983561f, -0.03253193f, 
    0.52578115f, -0.06122955f, -0.38816631f, 0.01614783f, 0.32402223f, 0.00078417f, 0.11543459f, -0.03604501f, 
    0.07239534f, 0.08606177f, 0.08711134f, 0.17018163f, -0.04381847f, -0.07135175f, -0.07041422f, 0.02882767f, 
    0.11356758f, -0.00419778f, 0.01453856f, 0.11108828f, -0.31468895f, -0.17846002f, -0.45142707f, -0.11603918f, 
    0.14005795f, 0.22941971f, 0.09757710f, 0.09525418f, -0.10939280f, 0.06834961f, -0.00365404f, 0.05061541f, 
    0.04981256f, 0.09846078f, -0.00306561f, 0.15606539f, 0.04028352f, 0.05246685f, -0.06110468f, -0.18839595f, 
    -0.25760293f, -0.33540723f, 0.19092473f, 0.16006118f, -0.21127245f, 0.05065842f, 0.00772724f, 0.13003188f, 
    0.00615974f, -0.00030148f, 0.08696856f, 0.01346795f, -0.01850090f, 0.02573115f, -0.00533998f, 0.07294815f, 
    0.10919140f, -0.10700044f, 0.04284755f, -0.00639747f, 0.10740094f, -0.10858169f, 0.05853488f, 0.26284671f, 
    -0.12122559f, 0.09186049f, 0.06559065f, 0.11892867f, 0.08816405f, 0.17894222f, 0.09957721f, 0.02758590f, 
    0.13359928f, 0.03382266f, 0.08285592f, 0.03267763f, 0.07900938f, 0.01690366f, 0.00839831f, 0.24881563f, 
    -0.14871500f, -0.33374834f, -0.38840410f, -0.38514775f, 0.09451427f, -0.06536121f, -0.25947589f, -0.11335751f, 
    -0.03237080f, 0.15784481f, 0.06897571f, 0.01289420f, -0.00568411f, 0.06569683f, 0.03692836f, -0.03873461f, 
    0.04771141f, -0.08460559f, 0.11820834f, 0.13737588f, -0.11486989f, -0.24724926f, -0.09447981f, 0.18162401f, 
    0.05041812f, -0.07999077f, -0.00614628f, -0.10813630f, -0.21350133f, 0.03239333f, 0.14134932f, -0.00728937f, 
    0.08293562f, 0.04931428f, 0.00258665f, 0.11687662f, -0.08180673f, 0.10310496f, -0.05557657f, 0.08224170f, 
    -0.30884147f, 0.07961473f, 0.02524781f, 0.39628088f, -0.20010866f, 0.04952236f, -0.04646949f, -0.00664581f, 
    0.08742688f, -0.09139814f, -0.07079045f, -0.05453062f, -0.07858899f, -0.11035641f, 0.03546133f, 0.10676189f, 
    0.07297045f, 0.29684290f, -0.04286015f, 0.00443752f, -0.41639781f, -0.39171061f, -0.39425027f, -0.07988085f, 
    -0.03591582f, 0.14408079f, -0.01130100f, -0.22879310f, -0.05998206f, 0.05400059f, 0.01151044f, -0.03558920f, 
    -0.09951104f, 0.25601685f, 0.05989497f, 0.11116417f, 0.15792690f, 0.10660119f, -0.05062977f, 0.01978985f, 
    -0.07533912f, -0.17795464f, 0.37012571f, 0.00774567f, -0.12462121f, 0.13646671f, -0.04007123f, 0.20691936f, 
    -0.08658705f, -0.16457306f, -0.02042688f, -0.17408144f, -0.05602715f, -0.08907280f, 0.09332757f, 0.02526150f, 
    0.06107553f, 0.00421346f, -0.17679556f, -0.03228697f, 0.24154736f, 0.18726631f, 0.25358263f, 0.02645876f, 
    -0.11827890f, 0.02915323f, -0.04182277f, -0.03835489f, -0.07706247f, 0.06309187f, 0.06905232f, -0.01566899f, 
    -0.00498124f, 0.03002424f, 0.09455232f, 0.05651094f, 0.06891091f, -0.10349736f, -0.12486109f, 0.04005233f, 
    -0.26523501f, 0.04553794f, 0.58544755f, 0.02587883f, -0.08935665f, 0.04193776f, -0.06000191f, -0.07744627f, 
    0.12196474f, 0.05726879f, 0.03769769f, 0.00570105f, 0.07108632f, -0.03703799f, 0.08504514f, 0.03962608f, 
    -0.06351533f, -0.06496306f, 0.05014263f, 0.02974951f, -0.55118114f, 0.13307695f, -0.44486439f, 0.34411299f, 
    -0.04509756f, 0.10447745f, 0.05864776f, 0.00446110f, 0.03309109f, 0.20731929f, -0.00821907f, 0.03121835f, 
    -0.02531872f, -0.08204714f, -0.12042558f, -0.02104266f, -0.03872818f, 0.18072939f, -0.10811497f, -0.00232764f, 
    -0.27347261f, -0.00488295f, -0.26242805f, -0.30471727f, 0.12231671f, -0.01095506f, -0.13606663f, -0.20139809f, 
    -0.03382418f, -0.00750243f, -0.11782577f, 0.19702896f, 0.08577924f, 0.02968419f, 0.18598442f, -0.00033474f, 
    -0.11299569f, 0.20697929f, 0.18359885f, 0.11295689f, 0.16634801f, 0.11991812f, 0.28886989f, -0.30982640f, 
    0.08716660f, 0.15401995f, 0.11705802f, 0.04157005f, -0.12803055f, 0.12951173f, 0.03842752f, -0.15252231f, 
    -0.01430173f, -0.09398802f, -0.08864094f, 0.12094120f, 0.01135683f, -0.06958029f, -0.05262394f, 0.06467284f, 
    -0.26646930f, -0.00769660f, -0.35056069f, 0.00299435f, 0.14308766f, -0.15701006f, 0.05888133f, 0.10561861f, 
    0.02195736f, 0.10918085f, -0.04796052f, -0.13511997f, 0.06555337f, -0.23616797f, 0.03723801f, -0.06765535f, 
    -0.12987216f, 0.15908478f, -0.06420516f, 0.12799464f, -0.47009802f, -0.06387945f, 0.04383410f, 0.07663743f, 
    0.12920102f, -0.10856867f, -0.02672158f, -0.22499032f, -0.03475857f, 0.00082298f, -0.03527830f, -0.10811070f, 
    0.00267814f, -0.08960052f, 0.01115722f, -0.13934258f, 0.05302351f, -0.01914479f, 0.01269832f, -0.06949680f, 
    0.34977198f, 0.25498855f, -0.62631547f, -0.02599434f, -0.06632526f, -0.03532043f, -0.09245107f, 0.08666282f, 
    -0.18100426f, 0.00798435f, -0.03352805f, 0.13250716f, -0.00144965f, -0.01273964f, -0.02918113f, -0.10109103f, 
    -0.12357716f, -0.13506933f, -0.07138526f, 0.02249191f, -0.05766691f, -0.23679508f, 0.01691026f, -0.05447804f, 
    -0.11352163f, 0.05611746f, -0.10764419f, 0.07997011f, -0.01313770f, -0.04462466f, 0.04360763f, 0.08274157f, 
    0.14995426f, -0.05469390f, 0.13944244f, 0.00294846f, 0.12001415f, 0.17913905f, -0.05140611f, 0.01928657f, 
    -0.02347940f, 0.37088835f, 0.35495397f, 0.27707469f, 0.20390503f, -0.02330337f, 0.13895388f, -0.00559949f, 
    0.00182438f, 0.08530252f, 0.03845241f, 0.10453928f, -0.06895702f, 0.00947030f, 0.03024470f, 0.00381432f, 
    0.02506243f, -0.19798838f, -0.02618595f, -0.05844241f, -0.28981030f, 0.04064203f, 0.18396005f, 0.13510524f, 
    0.00841114f, 0.00573937f, 0.22230953f, -0.08259467f, 0.05826471f, 0.09604885f, -0.01452012f, 0.14423369f, 
    -0.06382407f, 0.00470293f, 0.01357954f, 0.06103837f, 0.01249886f, -0.01584847f, -0.18152519f, -0.14435761f, 
    0.03378640f, -0.34522194f, -0.02021615f, 0.05866864f, -0.03678604f, -0.02478450f, -0.16748609f, -0.08747523f, 
    0.06155438f, -0.07038827f, -0.04134065f, 0.02501806f, -0.06000232f, 0.11371538f, 0.07605515f, 0.03569229f, 
    0.07588179f, 0.23767005f, -0.05669584f, 0.00168055f, -0.01558158f, -0.19189592f, -0.18216977f, 0.07036632f, 
    -0.10573527f, -0.00648329f, -0.06799182f, 0.05734544f, -0.12744527f, -0.10606448f, -0.06226913f, 0.10907093f, 
    -0.09551537f, 0.08938397f, 0.02583292f, -0.00580471f, -0.08506570f, 0.04767454f, 0.04413011f, -0.01078684f, 
    -0.47257984f, -0.43170908f, 0.12530716f, 0.05446389f, -0.07582652f, 0.05129641f, -0.07223413f, 0.03413169f, 
    -0.02729661f, -0.10362253f, 0.01614824f, 0.03746341f, -0.07314916f, -0.11471637f, -0.06736152f, -0.07478032f, 
    -0.20994696f, 0.05095369f, -0.19393168f, -0.18421839f, -0.00438099f, -0.22642657f, -0.13831882f, -0.00160489f, 
    -0.09440289f, -0.04503901f, -0.03030402f, 0.00127320f, -0.03913748f, -0.08379202f, 0.10338041f, -0.06308495f, 
    -0.03576844f, 0.08412385f, 0.12894320f, 0.01672132f, 0.09606256f, 0.12918918f, -0.01147577f, -0.02136592f, 
    -0.13832101f, 0.46999499f, 0.61606449f, 0.26405427f, 0.19455265f, -0.11122796f, 0.10332686f, 0.10713641f, 
    0.10135712f, 0.19838293f, 0.01689133f, -0.04898114f, -0.04825625f, 0.00329869f, -0.00796617f, -0.03386696f, 
    0.02625968f, -0.07309063f, 0.08100627f, 0.14352116f, -0.04727189f, 0.24307291f, 0.23986611f, 0.02867844f, 
    0.04105955f, 0.09879384f, 0.27386901f, 0.16450867f, 0.05706622f, 0.12303305f, -0.10085646f, -0.04736070f, 
    0.01052438f, 0.06290981f, -0.05961900f, 0.04872354f, 0.10038020f, -0.09205683f, 0.02660452f, 0.19568162f, 
    0.44375730f, 0.12755111f, -0.21922827f, 0.05691293f, -0.13811176f, -0.07760040f, -0.06635115f, -0.08244748f, 
    0.23689498f, 0.00940014f, -0.03885616f, -0.13796210f, -0.07157290f, -0.12105607f, -0.01834567f, -0.04160744f, 
    -0.03331716f, -0.08566608f, -0.04596989f, 0.06143975f, -0.31524551f, -0.13309309f, 0.04750643f, -0.01304233f, 
    -0.22108307f, -0.02519611f, -0.00882314f, 0.06377742f, 0.20118853f, 0.09792508f, -0.03207431f, 0.08679362f, 
    0.01973879f, -0.01288535f, 0.03717203f, 0.10572668f, 0.03168232f, 0.09074274f, 0.14250250f, -0.01259163f, 
    0.44336215f, -0.36181900f, -0.08909979f, 0.23969416f, -0.06771692f, -0.03777224f, -0.05913831f, -0.03300724f, 
    -0.01024973f, -0.08137465f, 0.03071061f, 0.17273141f, -0.16502866f, -0.05654514f, -0.02962073f, -0.04351345f, 
    -0.19357437f, -0.09948033f, 0.22316700f, 0.07441144f, 0.19805981f, -0.17478311f, 0.06597887f, -0.07030737f, 
    -0.13047510f, 0.11444248f, 0.05298674f, 0.15231301f, 0.18860726f, 0.24792284f, -0.05120882f, -0.08463133f, 
    0.02551795f, -0.04189501f, 0.06692471f, 0.00924469f, -0.02458840f, -0.00184641f, 0.06369565f, 0.17651483f, 
    0.25266156f, -0.17645122f, 0.02446250f, 0.14228396f, -0.22975023f, -0.25053349f, 0.01429524f, -0.24373913f, 
    0.10878894f, 0.16315083f, -0.09726963f, -0.02551610f, 0.15481637f, -0.00596246f, -0.02742608f, 0.20331332f, 
    0.15768860f, -0.04747838f, 0.17771842f, 0.19380783f, -0.15083672f, 0.37028962f, 0.24265809f, 0.20444949f, 
    -0.05773578f, 0.23062170f, -0.00887485f, 0.08881671f, -0.10598932f, 0.17352103f, -0.00092992f, 0.04083199f, 
    -0.07806525f, 0.09455106f, -0.01790482f, -0.15031943f, -0.07807795f, 0.09289935f, -0.24527521f, -0.00680260f, 
    0.53931040f, 0.13502713f, 0.26877549f, 0.01768645f, 0.13878092f, 0.08066507f, 0.02337693f, 0.00276808f, 
    -0.09727545f, -0.17789432f, -0.09294519f, -0.04979190f, 0.02375073f, -0.00220175f, -0.02808213f, -0.03192190f, 
    -0.17248991f, -0.05191180f, -0.04558785f, -0.05984792f, 0.19105124f, 0.08385738f, 0.07739364f, 0.09709135f, 
    -0.04654914f, -0.01915863f, -0.10091206f, -0.12410038f, -0.05047182f, -0.11203042f, 0.01296457f, -0.09741110f, 
    0.02815041f, 0.04612521f, 0.11837179f, -0.19995159f, 0.05774582f, 0.18078923f, 0.06202731f, -0.04628044f, 
    -0.33990946f, -0.07820576f, -0.05804268f, 0.22490393f, 0.13204157f, 0.14828880f, -0.05009817f, 0.00082523f, 
    0.06366050f, -0.18697880f, 0.00745060f, 0.02808985f, 0.01557391f, -0.02382206f, -0.02937538f, 0.13361011f, 
    0.01688994f, 0.00569414f, -0.00360870f, -0.09627992f, 0.06154662f, -0.07510263f, -0.03549666f, 0.11105818f, 
    0.20754531f, 0.20683584f, 0.05737723f, 0.11323712f, 0.14130947f, 0.04150517f, 0.10760185f, 0.01026759f, 
    0.07387710f, 0.07075832f, 0.07807522f, 0.16058071f, 0.04330217f, -0.01760935f, -0.06523728f, -0.26636955f, 
    0.46707103f, 0.18950275f, 0.20187144f, 0.10546926f, 0.16391581f, -0.08881257f, -0.07801006f, -0.03470074f, 
    -0.07301408f, 0.02316140f, -0.12440816f, 0.00218022f, 0.11476865f, 0.16691552f, -0.05645930f, -0.24433140f, 
    0.25761083f, -0.00771201f, 0.00694571f, 0.08688815f, -0.06050551f, -0.10401521f, 0.01583883f, 0.01562456f, 
    -0.07721338f, -0.00956371f, 0.04264235f, 0.14324179f, 0.05226181f, -0.01958523f, 0.30475339f, 0.11688932f, 
    0.24657513f, 0.16036066f, 0.04934066f, -0.05925049f, -0.03701961f, 0.06731809f, -0.00174198f, 0.01130993f, 
    -0.38230869f, 0.12508495f, 0.25816733f, -0.04074117f, 0.24573524f, 0.21121122f, 0.03067142f, 0.05667081f, 
    0.03046526f, -0.00525646f, 0.03035074f, 0.04501806f, 0.09676533f, 0.01594683f, 0.08064590f, -0.06060369f, 
    0.06177027f, -0.15644670f, -0.08228569f, -0.34666294f, 0.25998622f, 0.12056167f, 0.03789409f, 0.07336202f, 
    -0.04402167f, -0.02681555f, -0.12757766f, -0.11799676f, -0.02119745f, -0.07015856f, -0.16248579f, -0.21237430f, 
    -0.13552564f, -0.01626433f, -0.07979468f, -0.21595693f, -0.02675341f, -0.07169779f, 0.05509825f, 0.01360296f, 
    -0.54080796f, -0.49163797f, 0.01640637f, 0.14041461f, 0.00817249f, -0.10561488f, 0.24007373f, -0.09587631f, 
    -0.03582769f, -0.29956174f, -0.01586762f, 0.05387802f, -0.10340883f, -0.01568342f, 0.04117779f, -0.04259650f, 
    0.07158086f, 0.02618338f, 0.21090542f, -0.09761456f, -0.31568995f, -0.16837013f, -0.01138550f, -0.06956239f, 
    -0.07241143f, -0.08308895f, -0.00333456f, 0.13780878f, 0.12473197f, -0.00972911f, -0.05856991f, 0.05588337f, 
    -0.05027729f, -0.05933399f, 0.04049230f, -0.07267770f, 0.07293237f, 0.08153212f, 0.02029264f, 0.09007759f, 
    0.18501180f, 0.06717456f, -0.48435757f, -0.14674325f, -0.04148308f, 0.04443552f, 0.23556426f, 0.21165594f, 
    0.31189892f, 0.09115995f, 0.17366253f, 0.07879569f, 0.02910000f, -0.27325088f, 0.10239143f, -0.03732645f, 
    0.01704476f, 0.16709681f, 0.05302398f, 0.09053151f, 0.36952254f, -0.16569203f, -0.00781124f, -0.07455517f, 
    0.00168499f, 0.17638727f, -0.15044114f, -0.06121967f, 0.12906928f, -0.02780828f, -0.14181823f, 0.01785013f, 
    -0.00696472f, 0.03872953f, 0.02498285f, -0.02172152f, -0.03048098f, 0.09075475f, -0.00621870f, 0.24433529f, 
    0.44650912f, 0.13056469f, 0.12094464f, 0.38927212f, 0.25062299f, -0.06040382f, -0.01715657f, 0.00911802f, 
    -0.02417465f, -0.10732017f, 0.10545038f, -0.07655279f, 0.08323973f, 0.00991818f, 0.07787523f, 0.09206536f, 
    -0.15768273f, -0.21641216f, 0.04343960f, -0.02810159f, 0.07192922f, -0.05661920f, -0.11649807f, 0.13625441f, 
    0.08196000f, -0.09147150f, 0.10503750f, 0.09765052f, 0.24977984f, 0.13059273f, 0.09972668f, 0.14541276f, 
    -0.12358781f, 0.02538747f, 0.11903718f, 0.01232980f, 0.01563482f, 0.14926231f, 0.02524905f, 0.17857146f, 
    0.68793678f, 0.10340312f, -0.00889596f, 0.19931839f, 0.05856382f, 0.03714868f, 0.29962930f, 0.04333667f, 
    0.09238017f, 0.11092159f, -0.10952941f, -0.04397652f, -0.00488831f, 0.00733797f, 0.00943360f, 0.18162756f, 
    0.22491463f, -0.09757475f, 0.02098293f, 0.28830096f, -0.30503505f, -0.01302116f, -0.16685002f, -0.05998192f, 
    -0.00165517f, 0.02746836f, -0.07366134f, 0.04843394f, 0.15840949f, -0.14193068f, 0.05425921f, -0.05422682f, 
    0.01932942f, -0.06098784f, -0.00774848f, 0.09983894f, -0.16426700f, 0.09862600f, 0.09007876f, -0.07249825f, 
    -0.15684043f, -0.10878928f, 0.57197553f, -0.02097394f, 0.10824938f, -0.11089799f, -0.08557049f, -0.04118811f, 
    -0.08114347f, -0.12301218f, -0.02524467f, -0.02885660f, 0.00383448f, -0.03989404f, 0.05443587f, -0.00501758f, 
    -0.12266620f, -0.01935459f, -0.09487443f, -0.11407778f, -0.09564760f, 0.02220558f, 0.15265480f, -0.13168830f, 
    -0.26029974f, -0.29849404f, -0.17166054f, -0.11091667f, -0.09638993f, -0.13294838f, -0.08153611f, -0.08985446f, 
    0.00488610f, -0.06002282f, -0.14103281f, -0.12139674f, 0.02634171f, 0.04867635f, 0.18889926f, -0.00486209f, 
    -0.07802443f, -0.07974244f, -0.44408229f, 0.04092570f, 0.07442287f, 0.06769012f, -0.10158242f, -0.15776415f, 
    0.17196746f, -0.12745044f, -0.06599288f, 0.04896902f, 0.04528734f, -0.04250575f, 0.02633533f, -0.01876027f, 
    0.02448802f, 0.22601978f, -0.08340913f, 0.07675180f, 0.01790362f, -0.01304311f, -0.21934861f, 0.00030535f, 
    0.18149570f, 0.15999298f, -0.00847157f, 0.05181500f, 0.11913426f, 0.01186922f, 0.02534623f, 0.04695325f, 
    -0.04631607f, 0.03399578f, 0.05062545f, 0.18958971f, -0.06397033f, 0.09752262f, -0.03516885f, -0.15999837f, 
    0.02891059f, 0.18888307f, 0.02707292f, 0.02622184f, -0.33089015f, -0.18050079f, -0.06915841f, -0.10560409f, 
    -0.08771201f, -0.11261491f, -0.08586618f, 0.11654457f, 0.18788156f, -0.03132548f, -0.12692173f, 0.04317838f, 
    0.03532336f, 0.02554777f, 0.05820297f, 0.01670823f, -0.11940893f, 0.14604910f, 0.04704766f, -0.09791648f, 
    -0.24682993f, -0.06390892f, 0.10406586f, 0.07277837f, 0.10603848f, -0.05521230f, -0.00883782f, -0.02596675f, 
    0.12047169f, 0.04728408f, 0.16651669f, -0.12422500f, 0.00016759f, 0.00975609f, 0.03087442f, -0.05243927f, 
    0.40242317f, 0.31254014f, 0.33424193f, -0.16186245f, 0.41472575f, 0.01041130f, 0.14313336f, 0.05176093f, 
    0.03813241f, 0.07384268f, -0.03673572f, -0.00257137f, 0.06882583f, 0.05626571f, 0.17073250f, 0.01489226f, 
    0.02164098f, -0.00860001f, 0.18745269f, -0.18386814f, 0.07505471f, 0.09276726f, 0.08959894f, -0.18121234f, 
    -0.37238744f, -0.27300689f, -0.20114709f, -0.11157530f, -0.08984255f, -0.15230256f, -0.02417479f, 0.11314439f, 
    -0.02966051f, -0.24272649f, -0.15814583f, -0.17186806f, -0.03475701f, -0.06951039f, 0.05132451f, -0.05595041f, 
    -0.26846662f, -0.41730502f, -0.39060968f, -0.06810910f, 0.12029637f, 0.04886748f, 0.14178473f, -0.01198620f, 
    0.14159878f, -0.10731602f, -0.03833100f, -0.03692681f, -0.06078278f, 0.06361049f, -0.03689496f, 0.02218306f, 
    0.04928637f, 0.03303073f, 0.18507098f, 0.17854850f, -0.40706098f, -0.40352821f, -0.30990463f, 0.09076332f, 
    0.12806888f, 0.03197507f, 0.16338344f, 0.02940197f, 0.15143146f, 0.08248334f, -0.02392240f, 0.00337858f, 
    -0.10222485f, 0.07469099f, -0.08673583f, 0.03937918f, 0.09297615f, 0.16380410f, 0.05620009f, 0.20955530f, 
    -0.08712260f, 0.48419109f, -0.10048729f, 0.14795721f, 0.47060421f, 0.16830978f, 0.24487023f, 0.12632142f, 
    0.21846302f, 0.24878433f, 0.06106766f, 0.12533832f, 0.14371419f, -0.00102871f, 0.04562853f, 0.05026659f, 
    0.10208867f, 0.19062154f, 0.18973111f, 0.01203870f, 0.27674270f, -0.35474727f, 0.12444543f, -0.19942477f, 
    0.01687179f, 0.03776910f, -0.08338795f, 0.04430069f, 0.00716218f, -0.18156174f, -0.11901807f, -0.01016957f, 
    -0.00973200f, 0.03134840f, 0.03912344f, 0.02897784f, 0.03343766f, 0.15513435f, 0.12205786f, 0.16595240f, 
    0.02366511f, 0.66778821f, 0.28703520f, 0.32349667f, 0.12926258f, 0.02949507f, -0.03182757f, 0.01763762f, 
    -0.04228733f, -0.05561065f, 0.09147765f, -0.05141262f, 0.13989791f, 0.06255964f, 0.07112835f, 0.15706132f, 
    0.02145313f, 0.00848743f, -0.04342128f, -0.08581898f, -0.35531422f, 0.04233140f, -0.22043495f, 0.47666022f, 
    0.00374249f, 0.01787014f, 0.07771506f, -0.01927137f, 0.28284186f, 0.00317712f, 0.00553116f, 0.16996710f, 
    -0.03067751f, 0.16801359f, 0.02595964f, 0.06628358f, 0.16162542f, 0.03942406f, 0.14666773f, 0.11111279f, 
    0.13393699f, 0.08737999f, 0.07803585f, 0.06683766f, -0.02025437f, -0.02175449f, -0.03938804f, -0.04133233f, 
    -0.01902459f, -0.05394415f, -0.02813302f, 0.09113987f, -0.09774913f, -0.04997661f, -0.00585781f, 0.07073501f, 
    0.11373471f, -0.04805793f, 0.20596386f, 0.03557334f, 0.06437414f, 0.06831151f, -0.03899956f, -0.07225279f, 
    0.14365469f, 0.09175940f, -0.02484456f, 0.16013537f, 0.15442027f, -0.01172207f, 0.03282865f, -0.01927330f, 
    0.01722560f, -0.07304192f, 0.09259779f, 0.17537522f, -0.13293953f, 0.07493930f, 0.17711844f, -0.04758495f, 
    -0.10715098f, 0.67127329f, -0.21576935f, 0.04736177f, -0.11323671f, 0.08634424f, -0.06809435f, 0.06338980f, 
    -0.16353324f, 0.02301924f, -0.06994147f, 0.00416668f, -0.01885713f, 0.03986442f, -0.01985541f, 0.03832911f, 
    -0.01888451f, 0.01134474f, -0.06429467f, -0.00280783f, 0.03757774f, -0.00248008f, 0.18493250f, 0.07409593f, 
    -0.00020072f, 0.05813950f, -0.08136939f, -0.04093314f, -0.04802136f, -0.08238750f, 0.00820034f, -0.06657281f, 
    0.03459316f, -0.08571468f, 0.03047705f, -0.32458588f, -0.00103503f, 0.01218847f, -0.03962662f, -0.04473331f, 
    0.16109590f, 0.33007377f, 0.23999999f, -0.09339875f, -0.05016883f, 0.04327701f, 0.20944285f, 0.03357450f, 
    -0.13776974f, -0.02502683f, 0.03112025f, -0.01532861f, 0.03478352f, 0.10608254f, 0.15002330f, 0.02002556f, 
    0.01444504f, -0.06416781f, 0.17914738f, -0.00887698f, -0.10182997f, 0.17057167f, 0.09854008f, -0.06759442f, 
    -0.10774958f, 0.00496210f, 0.31267384f, 0.00589838f, -0.01306041f, 0.15503885f, 0.04230553f, 0.08286016f, 
    -0.00469785f, 0.07085976f, 0.08440705f, 0.09506551f, -0.13412356f, -0.07694510f, -0.07997844f, 0.00907265f, 
    0.13238953f, 0.12086201f, 0.21707332f, 0.05072634f, 0.17058900f, -0.04515390f, -0.04985024f, -0.02658439f, 
    0.00146623f, 0.02688923f, -0.00158967f, -0.03075715f, -0.05293750f, 0.12698747f, 0.06629028f, 0.02439363f, 
    0.10466435f, 0.04993919f, -0.15707254f, -0.08392268f, 0.26755533f, -0.22058022f, -0.04987113f, 0.15913366f, 
    0.07176690f, -0.10465847f, -0.06984377f, -0.09002385f, -0.10766300f, 0.02454316f, 0.08245122f, 0.15504381f, 
    0.08800669f, -0.01777274f, 0.03937778f, -0.05590888f, 0.00319852f, -0.05654569f, 0.03634034f, 0.11337185f, 
    -0.20622022f, -0.15137284f, -0.05400341f, -0.12201779f, -0.17695442f, 0.06182078f, -0.17203310f, -0.03811586f, 
    0.12400637f, -0.17277183f, 0.12930948f, 0.06577037f, -0.01467594f, 0.07933394f, -0.00010105f, 0.03476951f, 
    -0.12376662f, -0.10600630f, -0.22187866f, -0.13165405f, 0.08207417f, 0.05828791f, 0.08559362f, 0.07543723f, 
    0.03256187f, 0.05342907f, -0.09771440f, -0.04696942f, -0.11353923f, -0.03858257f, 0.00071896f, -0.08662958f, 
    -0.19972908f, 0.07670958f, 0.04170337f, -0.15963270f, -0.00028811f, 0.02538522f, -0.09138009f, -0.04695125f, 
    -0.03771476f, 0.28500253f, 0.44634950f, -0.03083876f, -0.16384314f, -0.15541212f, 0.14078464f, -0.07157607f, 
    0.02972982f, 0.00734530f, -0.00139645f, -0.01976509f, -0.02814724f, 0.06217582f, 0.11366373f, -0.09416664f, 
    0.06121975f, 0.05871141f, 0.10538432f, 0.18056612f, -0.03020183f, 0.25037184f, 0.14377333f, -0.19216405f, 
    -0.08241451f, 0.03380729f, 0.20725140f, -0.00482308f, -0.04592984f, 0.00470028f, 0.04248975f, 0.01742168f, 
    0.05969076f, 0.03561190f, 0.01584769f, -0.04174411f, 0.06105147f, -0.09362601f, 0.13610837f, 0.17788133f, 
    0.52770054f, -0.03661527f, -0.70391816f, -0.09267683f, -0.02095350f, 0.08770416f, 0.00355183f, 0.07047284f, 
    0.15765727f, 0.26611778f, 0.07644461f, -0.03116791f, -0.06283587f, -0.08649238f, -0.13684559f, -0.05131954f, 
    0.04206021f, -0.11565364f, 0.06446683f, 0.08194924f, -0.15680543f, -0.07034193f, -0.18393530f, -0.14385457f, 
    -0.06308024f, -0.06646087f, -0.04525614f, 0.11482456f, -0.00019340f, -0.00163062f, -0.09896417f, -0.04411267f, 
    -0.08626824f, 0.03395300f, -0.00533493f, 0.11078674f, 0.02018050f, 0.14271045f, 0.07230733f, 0.03201984f, 
    0.57844198f, -0.30277085f, 0.17141445f, 0.21262804f, 0.17204645f, -0.02356918f, -0.03619769f, -0.11954490f, 
    -0.00857778f, -0.04813743f, 0.08167066f, 0.21267945f, -0.19236028f, -0.00494406f, -0.11244912f, -0.06619330f, 
    -0.14229587f, -0.23484448f, 0.19490746f, 0.06212731f, 0.23278907f, -0.09610448f, -0.16504794f, -0.19903193f, 
    -0.14320359f, 0.11545023f, 0.13311712f, -0.02181667f, 0.07699461f, 0.03985269f, 0.08637311f, -0.03784776f, 
    -0.11491743f, 0.06764761f, -0.00520047f, -0.04494082f, -0.02741774f, -0.02588136f, 0.05244913f, 0.18277808f, 
    0.08148224f, -0.17393611f, -0.00316041f, 0.07179729f, -0.01818690f, 0.00956047f, 0.01912303f, 0.04710349f, 
    0.13817374f, -0.09217692f, -0.08435124f, -0.14366829f, 0.00937404f, 0.02806444f, -0.05038220f, 0.14833397f, 
    -0.06145290f, -0.07287583f, -0.04817585f, 0.17697550f, 0.09349485f, 0.00280016f, 0.13606960f, -0.15886217f, 
    -0.24464887f, 0.07190559f, 0.07363390f, 0.10176204f, -0.04202369f, 0.13832180f, 0.05391599f, -0.03895666f, 
    -0.12186199f, 0.10913258f, -0.06251061f, -0.01895746f, -0.08488142f, 0.15076719f, -0.07223652f, -0.04289375f, 
    0.39973873f, 0.07466365f, -0.15853211f, 0.01605297f, 0.21384102f, 0.07908011f, 0.08007709f, -0.06240986f, 
    0.16844776f, 0.14711766f, 0.06578998f, 0.18194465f, -0.18147245f, -0.13754053f, -0.02645326f, 0.03376425f, 
    -0.07726239f, -0.02474668f, 0.06479799f, -0.02239979f, 0.03087872f, 0.27440828f, -0.19934373f, 0.32014033f, 
    0.18130620f, 0.24725796f, -0.06459969f, 0.05259418f, -0.15355942f, -0.00030136f, -0.28312641f, 0.01758501f, 
    0.02667138f, 0.01083625f, -0.30640298f, 0.15829302f, -0.08993108f, 0.21765845f, -0.29707545f, -0.11373715f, 
    0.26115629f, 0.15295359f, 0.30884266f, -0.13541158f, -0.02833095f, 0.27160728f, 0.25539696f, 0.19265898f, 
    0.01285895f, 0.05214500f, 0.07536700f, 0.00347198f, 0.02071187f, -0.04753961f, -0.03633016f, -0.13529919f, 
    0.04709924f, -0.17765665f, 0.01109749f, -0.10538257f, 0.31519985f, -0.07491963f, 0.52470815f, 0.00430313f, 
    -0.15299326f, 0.12887602f, 0.09276211f, -0.05582458f, -0.04430918f, 0.15410307f, -0.00512189f, 0.04753495f, 
    -0.05055422f, -0.01915594f, -0.05627829f, -0.04046291f, -0.03760633f, -0.10628399f, 0.03579729f, -0.09719775f, 
    0.42982218f, -0.40038338f, 0.22939098f, 0.22423412f, 0.07496604f, 0.33800486f, -0.44056866f, -0.09156609f, 
    -0.13984986f, -0.15770282f, 0.09327412f, 0.10946231f, -0.02878515f, 0.10991628f, -0.08425941f, -0.03291126f, 
    0.05650322f, 0.07363914f, 0.05501012f, 0.08140926f, -0.20174226f, 0.04715146f, 0.03211744f, -0.29084235f, 
    -0.23832604f, -0.20231867f, 0.08103441f, -0.03435474f, -0.21943675f, -0.16594535f, 0.07005949f, -0.01576858f, 
    -0.09905063f, 0.03774743f, -0.03017043f, -0.10241026f, -0.15624502f, 0.18040809f, 0.04353505f, 0.01494022f, 
    -0.05784523f, 0.43002728f, 0.33719400f, -0.09889349f, -0.14180328f, -0.12495529f, 0.24668404f, 0.03806929f, 
    0.22447224f, 0.03429261f, -0.08933783f, -0.03753715f, 0.02078947f, -0.09801188f, 0.13038237f, -0.03741423f, 
    0.01867250f, 0.12183337f, -0.05569204f, -0.08661356f, -0.00537176f, -0.06461225f, 0.03619482f, 0.48449203f, 
    -0.07850482f, 0.16431057f, -0.16938213f, -0.08416279f, -0.22727513f, -0.00744518f, -0.24363254f, -0.02353515f, 
    -0.13412470f, 0.16052492f, -0.17500703f, -0.05691133f, 0.06944263f, 0.36063370f, -0.12973166f, -0.13690948f, 
    0.34945717f, 0.27090782f, 0.34723231f, -0.18466485f, -0.14535092f, 0.25990900f, -0.00577273f, 0.28592110f, 
    0.10085988f, -0.05403968f, 0.01941133f, -0.06456091f, 0.04017677f, 0.04498417f, 0.08937417f, -0.11580639f, 
    -0.22623461f, 0.00252536f, -0.06920307f, 0.16748421f, 0.26378393f, 0.15955371f, 0.17409040f, -0.14545622f, 
    -0.16213571f, -0.04242560f, -0.09298272f, -0.04097765f, -0.04847585f, 0.12367814f, 0.19653732f, -0.01736898f, 
    -0.10495704f, 0.05752916f, 0.03427016f, 0.02988548f, 0.04702952f, -0.13628246f, -0.05161287f, 0.04631500f, 
    -0.24308069f, -0.26112059f, -0.21065702f, -0.29599074f, -0.08927286f, 0.13828774f, -0.02026218f, 0.06003389f, 
    -0.01934068f, 0.01996990f, -0.06497995f, 0.14234629f, 0.08140288f, -0.19533888f, -0.11565826f, 0.14741130f, 
    0.01139825f, 0.14757730f, 0.17788963f, 0.11479643f, -0.41775003f, 0.02603511f, 0.25513631f, 0.15272586f, 
    -0.12991062f, -0.03159229f, -0.06544965f, -0.08902961f, 0.06950402f, -0.02975624f, -0.00914968f, -0.04837910f, 
    -0.24706373f, -0.01419432f, -0.02803802f, 0.03927692f, -0.01470650f, 0.11118639f, -0.03270276f, 0.06038237f, 
    0.03497682f, -0.04262099f, -0.66269505f, -0.19534391f, -0.10513353f, -0.03652430f, -0.00283743f, 0.02714371f, 
    -0.06338172f, -0.06818333f, -0.10183132f, 0.15708917f, -0.03347969f, 0.12845290f, 0.16013452f, -0.05660934f, 
    -0.03168451f, 0.31844860f, 0.29159966f, 0.16198228f, -0.09454262f, -0.07713445f, 0.08215469f, -0.01663714f, 
    0.11038876f, -0.10000267f, -0.09031880f, 0.06338020f, 0.05101547f, 0.06527539f, -0.11783449f, -0.11384122f, 
    -0.18782327f, -0.23855682f, -0.13163468f, 0.02518839f, 0.04408338f, -0.12496154f, -0.03638760f, 0.13958083f, 
    0.04658657f, 0.09745724f, 0.19210233f, -0.09877571f, -0.07253660f, 0.14555323f, 0.08498986f, 0.03248464f, 
    0.24835835f, 0.11394330f, 0.09808482f, -0.13508873f, 0.12710282f, -0.03304261f, 0.09807862f, -0.04081543f, 
    0.04800618f, 0.10867316f, 0.07485133f, 0.11542497f, 0.19232099f, 0.31797346f, -0.20131183f, -0.15538622f, 
    0.00050958f, 0.08970991f, -0.04670985f, 0.19221057f, 0.01308809f, 0.20070361f, -0.06218148f, -0.00734078f, 
    -0.01212311f, 0.09368263f, 0.00313165f, -0.08693630f, 0.09808800f, 0.19389729f, 0.11972572f, 0.10681585f, 
    0.18282495f, -0.33794993f, 0.51306891f, -0.20701008f, -0.19042681f, 0.01731011f, 0.00390404f, 0.03295355f, 
    -0.02555717f, -0.04623030f, -0.03790531f, 0.00852959f, -0.04927641f, 0.01362411f, 0.03770117f, 0.20220001f, 
    0.01092251f, 0.08380219f, 0.07769340f, 0.17312597f, 0.00098312f, -0.21505247f, 0.28566131f, -0.11811413f, 
    -0.15674551f, -0.01511497f, -0.02381046f, -0.04547952f, -0.00593031f, 0.03983169f, -0.14207426f, 0.00147090f, 
    0.14594561f, 0.07504313f, -0.08005554f, -0.04749579f, -0.24234629f, -0.00683090f, -0.06046556f, -0.03255282f, 
    -0.34492719f, -0.23497328f, -0.78544384f, -0.36404574f, -0.11408564f, -0.04257958f, -0.10213631f, -0.17612615f, 
    0.01686144f, -0.22690740f, -0.10546504f, -0.00510218f, -0.00145612f, -0.06641517f, -0.08864620f, 0.01104404f, 
    -0.13881607f, -0.12189436f, -0.02008546f, 0.02570947f, 0.06716785f, -0.23198736f, -0.09957039f, 0.15517661f, 
    0.18021336f, -0.11302225f, 0.23368734f, -0.03648160f, 0.01078271f, -0.02508239f, -0.04865097f, -0.10946169f, 
    0.02631108f, 0.01165562f, -0.02197197f, 0.20911184f, -0.03600649f, -0.03558851f, 0.14879820f, 0.00344079f, 
    0.10717488f, -0.31741214f, -0.01833401f, -0.00797397f, -0.05950283f, -0.09799902f, -0.02416158f, -0.07829077f, 
    0.11781199f, 0.12835157f, -0.04086436f, -0.05588967f, 0.01453297f, 0.11750006f, -0.02584943f, 0.06188212f, 
    0.16669354f, -0.02939834f, 0.06812622f, -0.08412325f, 0.04723578f, 0.00489388f, -0.10225483f, 0.27040657f, 
    -0.09839431f, 0.17491128f, -0.13872595f, 0.14941221f, 0.06430912f, 0.17238158f, -0.09075332f, 0.13552032f, 
    0.01362428f, 0.24163426f, 0.24753064f, 0.01492959f, -0.13745114f, 0.10991652f, 0.12387538f, -0.02859152f, 
    0.41851482f, -0.01178028f, 0.04043323f, 0.03780984f, 0.55388826f, 0.02337309f, 0.14301518f, 0.04033144f, 
    0.05669704f, -0.10747708f, -0.01827892f, 0.05852868f, -0.01372113f, -0.01138876f, -0.00015619f, 0.12892868f, 
    0.00696527f, 0.19801812f, -0.03572351f, 0.06243769f, 0.03425650f, -0.25895274f, -0.02595609f, -0.21274175f, 
    -0.05707140f, -0.00244738f, -0.14263836f, -0.00655189f, -0.04953653f, 0.04900679f, -0.06320182f, -0.08293313f, 
    -0.12312985f, 0.12956305f, -0.01531978f, -0.06446183f, -0.06857877f, -0.00112110f, -0.02153882f, -0.10959817f, 
    -0.20810695f, -0.45830026f, -0.13967791f, -0.17710923f, 0.03455241f, -0.06091494f, 0.00494597f, -0.16940857f, 
    0.02764741f, -0.22350402f, -0.07265458f, 0.07909463f, -0.03949926f, -0.01713252f, -0.01381409f, -0.00748602f, 
    -0.03225799f, 0.00366187f, 0.10752890f, 0.16801246f, -0.06590197f, -0.02301716f, 0.11161180f, 0.30992940f, 
    0.18666425f, -0.05128700f, -0.12994711f, -0.24180144f, -0.00923020f, -0.00878238f, -0.02160181f, 0.07592019f, 
    0.03096072f, -0.02296735f, -0.01570273f, -0.08709236f, -0.00725323f, -0.07567060f, -0.01313521f, 0.01243538f, 
    -0.42923403f, 1.08847761f, 0.15342513f, 0.61802685f, 0.40875274f, -0.04402172f, 0.20373830f, -0.05122232f, 
    0.44027579f, 0.07538809f, 0.01907664f, 0.07108470f, 0.03879532f, -0.05031169f, 0.09410901f, -0.06275216f, 
    -0.02241245f, -0.02803729f, 0.10605972f, -0.04213380f, -0.24527138f, -0.54999626f, 0.35809827f, -0.39685294f, 
    0.08467593f, 0.02013787f, 0.09531673f, 0.03394161f, 0.00758518f, 0.03916959f, -0.12047762f, 0.01309335f, 
    -0.00127869f, 0.03382542f, 0.01768007f, -0.04434044f, -0.16614942f, -0.00997278f, -0.09153401f, 0.18376307f, 
    -0.40209469f, 0.20593268f, 0.20451830f, 0.38048282f, 0.01024284f, 0.03342223f, -0.02589281f, -0.10185511f, 
    -0.00802019f, 0.09698747f, 0.03132934f, 0.03602228f, 0.03236468f, 0.04789284f, 0.02599113f, 0.03987847f, 
    -0.05454524f, 0.17028451f, 0.13242711f, -0.07861250f, -0.00725079f, 0.19388385f, -0.21071951f, 0.25299111f, 
    0.01970210f, 0.00543699f, 0.27248162f, -0.18106329f, 0.31223783f, -0.09687582f, -0.05507093f, -0.01737171f, 
    0.02986296f, 0.10156383f, 0.06550599f, -0.02714672f, -0.05707218f, 0.02220164f, 0.16375606f, 0.17051609f, 
    0.02847086f, -0.46390647f, 0.46659470f, -0.09401307f, 0.17932680f, -0.11034131f, 0.19834703f, -0.04466679f, 
    0.23616783f, -0.07148539f, -0.18844122f, -0.00741205f, 0.06918900f, -0.02873371f, -0.02781884f, 0.02904655f, 
    -0.05150567f, -0.00885502f, 0.08405942f, -0.02003015f, -0.27589583f, -0.20507616f, 0.42710236f, 0.27202368f, 
    0.21551815f, 0.09660191f, 0.13330005f, 0.13643594f, -0.15842083f, -0.23696730f, 0.05068333f, 0.00939615f, 
    0.02023293f, -0.00187605f, -0.12403995f, -0.00857194f, -0.11744063f, -0.10196093f, 0.01195873f, -0.04379114f, 
    -0.29174617f, -0.00180305f, -0.05421994f, -0.01061435f, -0.09626780f, 0.07792371f, 0.16170333f, 0.21518868f, 
    0.06056726f, -0.07611547f, -0.03921181f, -0.06230097f, -0.04436499f, -0.07171384f, 0.03236654f, -0.08625689f, 
    0.11180695f, -0.09650176f, -0.07792157f, 0.03884904f, -0.05069951f, 0.03816739f, 0.03462995f, -0.05272291f, 
    -0.07239483f, -0.06530347f, 0.00866235f, 0.08570036f, -0.02364889f, -0.06914401f, -0.10747468f, -0.09526770f, 
    -0.14942458f, -0.01562589f, -0.07685075f, 0.00536844f, 0.04276828f, 0.05832344f, -0.03997930f, -0.02032186f, 
    -0.15020496f, -0.24403118f, -0.25748420f, -0.20841002f, -0.08334801f, -0.05936909f, -0.22003615f, -0.00958887f, 
    0.04376024f, 0.19291696f, 0.04134226f, 0.00890633f, -0.05655435f, -0.13129684f, -0.13309896f, 0.02737456f, 
    -0.08324273f, 0.01310265f, 0.31137729f, 0.10871914f, 0.01889605f, -0.12832618f, -0.24021295f, -0.02423176f, 
    0.01418017f, 0.20696127f, -0.04559887f, 0.21092731f, 0.11893630f, 0.04550369f, 0.01883935f, -0.01735314f, 
    -0.08156887f, 0.04949465f, -0.04097874f, 0.24381280f, 0.06045852f, 0.13448305f, 0.30759284f, 0.20585686f, 
    -0.09153400f, 0.17698188f, -0.16032788f, 0.02308066f, -0.06757593f, -0.01008529f, 0.03268249f, 0.04411444f, 
    -0.02798272f, -0.04088652f, -0.06241748f, 0.03837838f, 0.01920099f, 0.04311370f, -0.08924224f, 0.04019533f, 
    0.09652152f, -0.07781930f, 0.07975110f, 0.01511777f, -0.06687618f, 0.13146493f, 0.15354514f, -0.04927360f, 
    -0.02679135f, -0.02794356f, 0.15295643f, -0.06714926f, -0.03639385f, -0.09342651f, 0.03254263f, 0.02845856f, 
    0.11908650f, -0.04356033f, 0.15024506f, -0.07642220f, 0.08647392f, -0.09268628f, -0.07243034f, 0.00494567f, 
    -0.04656736f, 0.17535070f, -0.06297373f, 0.05496085f, -0.10200131f, -0.01796421f, 0.15205504f, -0.07314183f, 
    0.06128792f, 0.18770374f, 0.01837268f, 0.04360431f, 0.01687107f, -0.02502648f, 0.02899522f, 0.12862112f, 
    0.12539081f, -0.07233536f, 0.20829019f, 0.19276111f, -0.07441931f, 0.12924619f, 0.02992628f, -0.11247855f, 
    -0.17926376f, -0.11711092f, 0.06171554f, 0.04382563f, -0.02528539f, -0.15252559f, -0.13508199f, -0.04433079f, 
    0.02330704f, -0.18642771f, -0.05950700f, -0.05216359f, -0.07340774f, 0.01836187f, -0.03991224f, -0.05230284f, 
    -0.54255217f, -0.43476814f, -0.29172066f, -0.19829655f, 0.01606633f, -0.13534984f, -0.07294925f, 0.03779704f, 
    0.11962967f, 0.02178843f, 0.02849540f, -0.00899445f, -0.04223479f, -0.09448081f, -0.03144990f, -0.02732840f, 
    -0.01827139f, 0.02921308f, 0.08874334f, -0.15349397f, -0.09858064f, -0.12921102f, 0.04002790f, 0.10971907f, 
    0.00023186f, -0.16807787f, -0.13912895f, -0.03854492f, 0.16446288f, -0.03306606f, 0.06661022f, 0.19773182f, 
    -0.01828757f, -0.07369474f, 0.04389548f, -0.00341912f, -0.05404854f, 0.03874583f, 0.03752565f, -0.07977100f, 
    -0.36996019f, -0.29631731f, 0.13456333f, -0.14594105f, -0.04242539f, 0.17547785f, -0.16153757f, 0.23068881f, 
    0.28134406f, 0.14050896f, 0.01801893f, 0.17584476f, 0.16371834f, 0.22537443f, 0.09771299f, 0.06155304f, 
    0.00189593f, 0.06420749f, -0.02343686f, 0.10201234f, 0.22867182f, 0.06957234f, -0.62681866f, 0.02443534f, 
    -0.23413450f, 0.22319895f, 0.08149396f, 0.24369657f, 0.16691630f, -0.14062461f, -0.01465837f, 0.05338229f, 
    0.04234465f, 0.01180346f, 0.03887935f, -0.01176285f, 0.05925600f, -0.05780207f, 0.27059582f, 0.21442589f, 
    -0.09295250f, -0.08042444f, 0.00359809f, 0.33940285f, 0.27917525f, 0.07559503f, -0.04629115f, 0.07660019f, 
    -0.04373653f, -0.10286690f, 0.00945777f, -0.01287919f, 0.15804425f, 0.21770124f, 0.10708979f, 0.10971100f, 
    0.17360798f, -0.01257179f, 0.10326412f, 0.21917680f, -0.10401788f, 0.04636396f, 0.13572259f, 0.08815322f, 
    0.06952653f, -0.02133424f, -0.14005885f, -0.00606926f, 0.37639317f, -0.02993444f, 0.13666576f, 0.29620010f, 
    -0.09665430f, 0.03746556f, 0.01564710f, -0.05275546f, 0.03317131f, 0.03470442f, -0.11541367f, 0.02734325f, 
    0.03443573f, 0.17507568f, -0.25663662f, -0.00000904f, -0.34368277f, 0.36495468f, 0.10347805f, 0.17324756f, 
    0.14174061f, -0.14793120f, 0.01644229f, 0.02617623f, -0.08265138f, -0.00400756f, 0.01880791f, 0.14547326f, 
    0.05219518f, -0.00362923f, 0.16165188f, 0.18642709f, -0.01801940f, -0.35263404f, -0.65564269f, -0.18782280f, 
    -0.22035730f, -0.07967317f, -0.13221011f, -0.03052965f, 0.19611888f, -0.01434710f, 0.02484515f, 0.04551226f, 
    0.04425224f, 0.08600564f, 0.12396786f, 0.06947911f, 0.08867119f, 0.07981502f, 0.06976996f, 0.16916132f, 
    -0.41731760f, 0.42986375f, -0.22569638f, -0.01187728f, -0.19352815f, 0.01285192f, 0.00772441f, 0.15786262f, 
    -0.21800300f, -0.02008111f, 0.01932327f, -0.09885132f, -0.00181791f, -0.03393270f, 0.04744308f, 0.07652506f, 
    0.02834884f, 0.04788932f, -0.19253421f, -0.23937593f, 0.06865760f, -0.00397369f, 0.25492471f, -0.14391662f, 
    -0.06496689f, -0.08380169f, -0.07869817f, -0.00149072f, -0.04091602f, -0.08293395f, 0.11291721f, 0.00095930f, 
    0.05495964f, -0.11378109f, 0.02888361f, -0.25305831f, 0.02117932f, 0.07061613f, 0.17112957f, 0.09168153f, 
    -0.14619985f, 0.13057815f, -0.16631560f, 0.29369321f, 0.12968345f, -0.06995302f, -0.09226956f, -0.20582919f, 
    0.03899597f, 0.10627296f, -0.00401118f, -0.00342417f, -0.03442405f, -0.09943434f, 0.00578369f, 0.00256317f, 
    -0.01987140f, 0.05227654f, 0.03332924f, -0.00957120f, -0.33387846f, 0.22125188f, -0.34925938f, 0.11689523f, 
    0.07351616f, 0.21397801f, 0.09036992f, 0.08907381f, 0.05674187f, 0.10174717f, 0.07675017f, 0.05073623f, 
    0.01576607f, 0.01402641f, 0.09874475f, -0.02718525f, -0.10620675f, 0.04187884f, -0.06005089f, -0.01350445f, 
    -0.07817478f, 0.37143588f, 0.02003505f, 0.00343184f, -0.15864816f, -0.10630763f, -0.00840968f, 0.07720350f, 
    -0.09444278f, -0.08778444f, -0.00049240f, 0.03104875f, 0.05894704f, 0.09010378f, 0.00360151f, 0.01950468f, 
    0.05622166f, 0.21171241f, 0.03115089f, 0.01406004f, 0.27079174f, -0.11283529f, 0.18277022f, 0.01794714f, 
    0.12274653f, -0.04379258f, -0.03236362f, -0.05244730f, 0.08037642f, -0.07154771f, 0.14838764f, 0.05023213f, 
    0.19523101f, -0.08664723f, 0.15318151f, 0.04762422f, 0.01954555f, -0.01441420f, -0.05906965f, 0.04495447f, 
    0.10166103f, -0.39145365f, -0.19528106f, 0.17277896f, -0.07899796f, 0.02306408f, -0.04205766f, -0.02567358f, 
    -0.01899649f, -0.04264092f, 0.07947169f, 0.01308201f, 0.04532717f, 0.04455682f, -0.06412487f, 0.00632015f, 
    -0.18420084f, -0.06120936f, -0.08561438f, -0.13266136f, 0.13384160f, 0.16482861f, 0.09882088f, -0.05188216f, 
    -0.10878833f, -0.12254665f, -0.00831262f, 0.10430846f, -0.00705208f, -0.13696815f, 0.22845373f, 0.05072024f, 
    0.04695605f, -0.09376583f, 0.10716644f, -0.03389564f, -0.11960585f, -0.00343718f, 0.16496414f, 0.02418816f, 
    -0.26470917f, -0.00504810f, 0.00683996f, 0.23280485f, 0.09609867f, -0.27411956f, 0.14147189f, -0.10840368f, 
    0.02161926f, 0.12382335f, -0.03653616f, 0.01212211f, 0.03894135f, 0.04779877f, -0.05636579f, 0.00838446f, 
    0.02599730f, -0.00055426f, -0.16527863f, -0.11332784f, -0.11103512f, -0.14107504f, -0.04858530f, 0.12400304f, 
    0.02709365f, -0.02448304f, 0.18335342f, -0.03506230f, 0.12001017f, -0.01853169f, -0.10735187f, -0.06285618f, 
    0.12891121f, 0.07476416f, 0.07381094f, 0.00448755f, 0.06537470f, 0.05124167f, 0.03542793f, 0.05994984f, 
    0.50415772f, -0.09839989f, -0.05763797f, -0.06149197f, -0.02507598f, 0.00199963f, 0.00857578f, 0.16055243f, 
    -0.07453930f, 0.14820242f, 0.09650074f, -0.01021330f, 0.05021696f, 0.04764166f, 0.04123614f, -0.05739951f, 
    0.12210441f, -0.10809437f, -0.11251146f, 0.02103673f, 0.04539446f, 0.08221716f, -0.45188263f, 0.06326957f, 
    -0.14928766f, 0.06247209f, -0.00364394f, 0.14059292f, 0.17593667f, -0.00069112f, -0.01855784f, -0.06638549f, 
    -0.01405563f, 0.03304144f, -0.00561847f, 0.08770635f, 0.03793593f, 0.06163537f, 0.28714582f, -0.04306922f, 
    0.30460918f, -0.16820897f, 0.35235667f, 0.47875535f, 0.02297873f, -0.10773914f, -0.11499737f, -0.07165973f, 
    -0.03757618f, -0.01048795f, 0.22166027f, 0.17918946f, 0.07253709f, -0.04681313f, -0.14411476f, 0.27979693f, 
    0.04075092f, -0.16162370f, 0.07838742f, 0.17477728f, -0.05896161f, -0.10517833f, 0.16741347f, -0.03885115f, 
    -0.10853662f, 0.04914792f, 0.11332998f, 0.04504288f, -0.00967606f, 0.09745820f, 0.07636675f, 0.09833021f, 
    0.13868417f, 0.18552913f, 0.09998048f, -0.00021941f, -0.03066252f, -0.04867930f, 0.08794367f, 0.04112941f, 
    -0.25377905f, 0.32081431f, -0.22779700f, 0.12921993f, -0.22123367f, 0.24889138f, -0.12572435f, 0.12018112f, 
    0.11017861f, -0.17321125f, -0.11090192f, -0.14026237f, -0.07074796f, -0.03871961f, -0.09544750f, 0.11234447f, 
    0.12290321f, -0.13567387f, 0.19111544f, 0.02070652f, 0.00926392f, -0.21809611f, 0.33573148f, -0.10089537f, 
    -0.13432024f, 0.02546386f, -0.08990634f, 0.03569182f, 0.07152264f, 0.08674091f, 0.04657215f, -0.05183335f, 
    -0.05584675f, -0.09345928f, -0.05814391f, 0.13138038f, 0.12239727f, -0.03819108f, -0.10800335f, 0.04668860f, 
    0.15541789f, -0.17935961f, 0.01847132f, 0.24243869f, 0.08269656f, -0.05714773f, -0.02360544f, 0.02531703f, 
    0.04397759f, -0.15178470f, -0.05858722f, 0.00725601f, -0.04853990f, -0.14244999f, -0.10194104f, 0.15587875f, 
    0.07875359f, 0.07151524f, 0.00552425f, 0.13096502f, -0.09502493f, -0.14712714f, 0.06817495f, -0.03612304f, 
    -0.07612287f, -0.08949692f, 0.14071912f, 0.06778673f, -0.21381396f, -0.10003420f, -0.06418376f, -0.00782545f, 
    0.15500565f, -0.01935246f, 0.25716674f, 0.06292040f, 0.05116777f, -0.00953931f, -0.07025892f, 0.09865450f, 
    -0.26326180f, -0.11032674f, -0.32161435f, -0.02572857f, 0.20633213f, -0.19870980f, -0.12945928f, -0.02391186f, 
    -0.06741729f, 0.00646817f, -0.01833640f, 0.05841640f, 0.01466274f, 0.07264187f, 0.02728145f, 0.13935238f, 
    -0.00083431f, -0.06516565f, 0.19115752f, -0.00199763f, -0.16691925f, -0.14782706f, -0.20512128f, -0.02849038f, 
    0.23750433f, -0.18875785f, 0.03183654f, 0.07043625f, 0.12805200f, -0.07051571f, -0.00842588f, -0.04168031f, 
    0.11480007f, 0.04422079f, 0.07637857f, 0.18966468f, 0.18168005f, 0.01889414f, 0.04585915f, 0.04764170f, 
    0.04014062f, -0.13612731f, 0.00314869f, -0.35089469f, 0.07644157f, -0.06316913f, 0.00777190f, -0.07506179f, 
    0.20634404f, 0.03718978f, -0.01538061f, -0.23626493f, -0.16063415f, -0.08900397f, 0.03612813f, 0.19375640f, 
    0.02230746f, -0.16370995f, -0.08941767f, -0.21746489f, -0.19502422f, -0.09441119f, -0.27527764f, 0.58894312f, 
    -0.16661672f, 0.17849307f, -0.16595396f, 0.16435833f, -0.15828303f, 0.16873214f, -0.05128305f, 0.16669847f, 
    0.00898092f, 0.26956952f, 0.12768324f, 0.09574261f, -0.09164108f, 0.01914557f, 0.07239316f, 0.07895697f, 
    0.09910657f, -0.41178522f, -0.25786865f, -0.09111356f, 0.10891858f, 0.11807404f, 0.03769825f, 0.16895758f, 
    -0.14655507f, -0.06492836f, 0.05058510f, 0.07872223f, 0.08818062f, 0.00752382f, 0.06912857f, 0.00741491f, 
    -0.00583249f, 0.04734969f, 0.00147711f, 0.08153452f, -0.08292939f, -0.30204451f, -0.08204914f, -0.38839164f, 
    -0.06792227f, -0.06967168f, 0.09973244f, -0.07669742f, -0.04775707f, -0.00734968f, 0.05007237f, -0.07388721f, 
    0.13474020f, -0.01107835f, 0.21878193f, 0.10360744f, 0.00670822f, -0.16271426f, -0.01819621f, 0.00879458f, 
    -0.23144947f, 0.04823741f, 0.07385748f, 0.14807799f, 0.27014872f, -0.08295994f, -0.11169802f, -0.03909520f, 
    -0.17694280f, -0.00623405f, 0.08435359f, 0.08729009f, -0.01232668f, -0.10554334f, 0.03726031f, 0.01600149f, 
    0.00884382f, -0.01733415f, 0.13174956f, -0.04855788f, -0.16888638f, 0.15486225f, 0.14117025f, 0.17610155f, 
    0.09997041f, 0.00191838f, -0.11605813f, 0.00047450f, -0.01708571f, 0.05237549f, 0.06832089f, 0.01762635f, 
    -0.10490610f, -0.05594520f, -0.02624245f, -0.03156395f, -0.06635238f, -0.09976159f, -0.01798424f, -0.12444673f, 
    -0.29268935f, 0.20571065f, 0.30187005f, 0.52033448f, 0.03616317f, 0.03148123f, 0.07915477f, -0.10567712f, 
    0.29764664f, -0.01908182f, 0.02796093f, -0.26638669f, 0.03101757f, 0.18552899f, 0.15015770f, -0.02283793f, 
    0.13263309f, -0.16418956f, -0.03554761f, -0.01692922f, 0.39867935f, -0.06578712f, 0.15948969f, -0.10665894f, 
    0.32337999f, 0.01849428f, 0.20638302f, 0.24945557f, 0.15324460f, -0.04297740f, -0.09360780f, -0.08999217f, 
    0.13349067f, -0.10914700f, 0.04289137f, -0.20689493f, -0.08576856f, 0.07059103f, 0.10029181f, 0.07019739f, 
    -0.46351495f, 0.04782518f, 0.30055439f, 0.28178620f, -0.05392151f, 0.05278514f, -0.17353633f, -0.09870616f, 
    0.06999552f, 0.13387103f, -0.04497423f, -0.10260257f, 0.06171352f, 0.16999958f, -0.00315986f, 0.03254928f, 
    0.04252860f, -0.14290628f, -0.12837155f, 0.12219441f, 0.36880898f, 0.06540058f, -0.08561600f, 0.28565168f, 
    0.10602892f, 0.07716665f, 0.11983726f, -0.04209918f, 0.21345277f, 0.04917338f, -0.02087775f, -0.02563375f, 
    0.08273175f, -0.01916278f, 0.11841114f, -0.15386100f, -0.09941677f, 0.02160895f, 0.16180561f, -0.05260232f, 
    0.41515693f, -0.29275015f, 0.41970825f, -0.03514664f, 0.18992925f, -0.11252314f, 0.07441424f, 0.08433949f, 
    0.27736512f, -0.02851268f, -0.16369607f, -0.03538515f, -0.10707213f, -0.05112514f, -0.10155772f, -0.02023218f, 
    -0.10803353f, 0.21578875f, 0.22649801f, -0.09438521f, -0.42555138f, -0.20914353f, -0.16198431f, 0.23833929f, 
    0.17667481f, -0.16057085f, 0.19145617f, -0.12505712f, -0.15245561f, -0.13127616f, -0.03668527f, 0.06940639f, 
    0.02253813f, 0.14570069f, 0.02533833f, 0.12228908f, 0.03875884f, 0.21043256f, -0.09913479f, 0.04276017f, 
    -0.16810121f, -0.18067211f, -0.43033332f, -0.06283015f, 0.14099041f, -0.09127920f, 0.14397202f, 0.33616528f, 
    -0.03301857f, -0.04636594f, 0.13684003f, 0.00730362f, -0.04995504f, 0.07224301f, 0.02524777f, 0.11059377f, 
    0.02004840f, 0.06348412f, -0.18935223f, 0.04391335f, -0.01012801f, -0.14203736f, 0.22978464f, -0.19812641f, 
    -0.04475826f, 0.14370474f, 0.06753228f, 0.07187075f, -0.04778346f, -0.08380143f, 0.12987241f, -0.01978953f, 
    0.00444307f, -0.13605735f, 0.05164978f, 0.10800687f, 0.01460611f, 0.02383881f, 0.00920718f, 0.07249168f, 
    -0.18660888f, -0.13604109f, -0.21979485f, 0.40586933f, 0.29967025f, -0.21435189f, 0.05210466f, -0.21840344f, 
    -0.02240673f, 0.26172075f, -0.05832099f, 0.05228749f, -0.02518171f, -0.00636087f, 0.10235072f, -0.08444788f, 
    0.01810039f, -0.06247826f, 0.20643088f, 0.06034157f, -0.24731620f, -0.03199757f, -0.39541456f, 0.16584094f, 
    0.10497936f, -0.10122614f, 0.16057022f, 0.02363859f, 0.02335215f, 0.05101275f, -0.08889129f, -0.00147954f, 
    -0.07106989f, 0.06147354f, 0.07167091f, 0.04136381f, 0.02025676f, 0.06208021f, 0.02188773f, 0.24479298f, 
    -0.01283135f, 0.27926207f, -0.27858704f, -0.12786876f, -0.24732330f, -0.03893052f, -0.12542193f, 0.02868659f, 
    -0.01095831f, -0.04225197f, 0.02497199f, 0.07835174f, -0.02755470f, -0.12843160f, -0.01274365f, 0.07159358f, 
    -0.08724465f, -0.00181180f, 0.08985367f, -0.06435892f, 0.19412811f, 0.12640521f, 0.25842783f, 0.02655016f, 
    -0.01490300f, 0.17896613f, 0.05211572f, -0.07005733f, -0.10570103f, -0.09177668f, -0.17608209f, -0.00162127f, 
    -0.13002409f, -0.14840026f, -0.05255954f, 0.14394042f, 0.02059935f, -0.04977572f, 0.03543136f, -0.02262142f, 
    0.33378243f, -0.15592007f, -0.15283617f, 0.09034075f, -0.18534410f, -0.00050682f, 0.19858430f, 0.04123716f, 
    -0.19212347f, 0.09344584f, -0.03903827f, -0.12463931f, 0.01845184f, 0.04281046f, -0.09562398f, -0.08098353f, 
    0.03139982f, -0.08508430f, 0.17154355f, 0.19775139f, -0.01551416f, -0.08313639f, -0.04474670f, -0.12890615f, 
    -0.06935898f, 0.08376222f, 0.00543153f, 0.09825096f, -0.01230417f, -0.10714903f, 0.26395246f, 0.13886720f, 
    -0.05190754f, -0.01870601f, -0.03081415f, 0.15131143f, 0.01428041f, 0.04848496f, 0.02853528f, 0.01011160f, 
    -0.22111203f, -0.00186065f, 0.09419865f, 0.18624824f, 0.38811269f, 0.02042965f, 0.02604011f, 0.21008378f, 
    -0.08526437f, 0.22214609f, -0.01445274f, 0.01691490f, 0.07398642f, -0.06081850f, 0.00218467f, 0.02310611f, 
    -0.04016694f, -0.04123629f, -0.11734457f, -0.12362482f, -0.20022066f, 0.04984481f, 0.08539844f, 0.00727205f, 
    -0.00136488f, 0.17240511f, 0.10470464f, -0.00220688f, 0.09699313f, 0.02517647f, 0.07443910f, 0.11222526f, 
    0.13176633f, 0.13509440f, 0.01680467f, 0.04467539f, 0.00255654f, -0.03024759f, 0.02177271f, -0.00909746f, 
    -0.23802704f, 0.37273636f, 0.57051659f, -0.11995502f, 0.12140030f, -0.12881607f, -0.21261264f, -0.19680391f, 
    -0.07757536f, -0.08047120f, 0.01741550f, 0.02391623f, 0.13084017f, 0.16688132f, 0.01560210f, 0.01674283f, 
    0.07837708f, 0.05006140f, -0.07820859f, -0.05036532f, -0.19235721f, -0.16975468f, -0.52084053f, 0.25312003f, 
    0.15740836f, 0.02195883f, 0.23017581f, 0.29774007f, 0.04381035f, 0.15134430f, 0.13145824f, 0.04172673f, 
    -0.04489643f, -0.00852906f, 0.10609825f, 0.08267260f, -0.06159185f, -0.13498886f, 0.14921103f, -0.08916543f, 
    -0.15960339f, 0.31662336f, 0.14673704f, -0.11065312f, 0.09455922f, 0.13354455f, 0.07557903f, 0.06858369f, 
    0.17482957f, 0.09219033f, 0.04965137f, 0.04108203f, -0.04189786f, -0.09914762f, -0.06822191f, 0.03505619f, 
    0.00269964f, -0.11199885f, 0.04333991f, 0.19566832f, -0.16702625f, 0.02240073f, 0.27233580f, -0.12580396f, 
    -0.03344091f, 0.17168175f, -0.07238518f, 0.13369985f, 0.02527196f, 0.13680875f, 0.18212005f, 0.03727010f, 
    0.08560980f, -0.04827601f, -0.06506523f, 0.07012109f, 0.00287535f, -0.01816785f, -0.01585139f, -0.20443814f, 
    -0.33751020f, 0.19656929f, -0.38637897f, 0.01633942f, 0.27754235f, -0.15059626f, -0.16721585f, 0.19424058f, 
    0.13036098f, -0.16719308f, 0.06455318f, 0.02825228f, -0.00597333f, -0.08279911f, 0.07949076f, 0.07418110f, 
    0.11353666f, 0.02816052f, 0.12594181f, -0.03053215f, -0.10795188f, 0.10049961f, -0.01461396f, 0.15861203f, 
    0.25051963f, -0.01620496f, -0.10254680f, -0.24001861f, -0.01346309f, 0.03380429f, -0.05311203f, 0.08031608f, 
    -0.00321122f, 0.12009550f, -0.07062652f, -0.02872493f, 0.12165898f, 0.18374877f, -0.07938690f, 0.08830454f, 
    -0.14730985f, -0.24115886f, -0.00964163f, 0.03921581f, 0.24158500f, -0.01804738f, 0.00027297f, -0.08230021f, 
    0.15431491f, 0.06019698f, 0.03715761f, 0.00918499f, 0.03543792f, -0.03401680f, -0.03436872f, 0.05336297f, 
    0.17794989f, 0.11829818f, 0.15869339f, 0.36828658f, -0.03774841f, -0.03895402f, -0.15620805f, -0.01349802f, 
    0.07480391f, 0.03863304f, 0.09575022f, -0.00309854f, -0.06327496f, 0.08247269f, -0.13591157f, 0.08599663f, 
    -0.00005434f, -0.04011276f, -0.01075122f, 0.18512811f, -0.06310230f, -0.08394087f, -0.13861033f, 0.06638706f, 
    0.38684207f, 0.06901448f, 0.13004830f, -0.30929902f, 0.13107286f, 0.01133310f, 0.26358306f, 0.21846227f, 
    -0.03195639f, 0.02203731f, -0.04440232f, -0.01851908f, 0.00081020f, 0.08630057f, 0.03520228f, -0.05491488f, 
    0.01223652f, -0.01993228f, 0.23241980f, 0.05907778f, 0.28113747f, -0.00514248f, 0.37648743f, -0.35760000f, 
    0.11798702f, -0.25123474f, 0.02190210f, 0.01305933f, 0.03453595f, -0.08905646f, -0.03424820f, -0.08121380f, 
    -0.04588776f, 0.00464515f, -0.05583194f, -0.00481916f, 0.06965940f, 0.01269556f, 0.17732194f, 0.01202515f, 
    -0.07100930f, -0.21095192f, -0.03560177f, -0.12361669f, -0.01171545f, 0.08662309f, 0.05455504f, -0.05124135f, 
    0.07080295f, 0.04390896f, 0.17461930f, 0.00080998f, -0.04570141f, -0.14583963f, -0.07621482f, 0.22397438f, 
    -0.14051500f, -0.18005534f, -0.00113111f, -0.03673745f, -0.20275407f, 0.01489170f, -0.07829047f, -0.02065463f, 
    -0.16155744f, 0.01523750f, 0.01695519f, 0.03685492f, -0.05494044f, 0.01022463f, -0.14259262f, 0.02481402f, 
    -0.19611406f, -0.07111747f, -0.23499696f, 0.04867173f, 0.08139319f, 0.04829367f, -0.05660711f, 0.02869416f, 
    0.29844093f, 0.19698377f, 0.06563807f, -0.33042455f, -0.01683704f, -0.29378122f, 0.03455485f, -0.02875751f, 
    0.04205834f, 0.01583815f, 0.00345696f, 0.02960398f, -0.00489295f, 0.05736006f, 0.01870122f, -0.06272284f, 
    0.13973780f, 0.00408831f, 0.31307369f, 0.28105190f, -0.10393380f, -0.15562662f, -0.11182750f, -0.01098914f, 
    -0.01340682f, 0.05196714f, 0.08333732f, 0.05642079f, 0.00853931f, 0.07818232f, -0.00653271f, 0.04199542f, 
    -0.01495506f, -0.09548554f, -0.08486669f, 0.03444055f, 0.08243126f, 0.02821372f, -0.06052999f, -0.00309684f, 
    0.49604216f, 0.48943999f, 0.12891567f, -0.20794789f, 0.14569543f, 0.26688349f, -0.01595265f, 0.22677658f, 
    0.03077905f, 0.18771699f, 0.10278956f, -0.09574188f, 0.04832263f, -0.01618074f, 0.02172406f, 0.01702384f, 
    -0.03662130f, 0.04389637f, 0.00529540f, 0.10386709f, 0.15711574f, 0.34859964f, 0.03511652f, -0.17833105f, 
    -0.05377446f, 0.07714382f, 0.04185510f, -0.04481901f, -0.07518214f, 0.12401961f, -0.02209300f, -0.04831360f, 
    -0.14095047f, 0.03257382f, 0.02786241f, 0.07125486f, -0.11668365f, 0.03608230f, 0.01425501f, -0.08074086f, 
    -0.27677897f, 0.00133504f, 0.04974192f, -0.04887921f, 0.15067129f, 0.02148537f, -0.04276956f, -0.10834847f, 
    -0.10163537f, -0.18830451f, -0.09264222f, -0.11925570f, 0.00732189f, 0.12110674f, -0.20259684f, 0.04935202f, 
    -0.01306950f, 0.03544630f, -0.04958043f, 0.00982172f, 0.06490417f, -0.05182684f, 0.08577443f, -0.06745200f, 
    0.34443137f, -0.10919518f, 0.39532539f, 0.23716611f, 0.13591382f, 0.04093662f, -0.00025500f, -0.01079921f, 
    -0.01142803f, -0.04275458f, 0.08309353f, -0.07473081f, 0.08997677f, 0.03591127f, 0.09195859f, -0.01048826f, 
    -0.27053365f, 0.12162566f, -0.15179127f, -0.41295531f, -0.17414045f, 0.08936819f, 0.08136573f, 0.04519458f, 
    0.10428373f, 0.13315389f, -0.11289947f, 0.10434356f, 0.00887058f, 0.09207989f, 0.15433401f, -0.07113907f, 
    0.15635695f, 0.15550749f, -0.13293062f, 0.11136492f, 0.14416651f, 0.14633119f, -0.14892693f, -0.01489061f, 
    0.07554138f, 0.05782386f, -0.11257329f, 0.07426813f, -0.05937860f, -0.06639265f, -0.29776263f, 0.06485382f, 
    -0.10868902f, -0.08463816f, -0.06122757f, 0.03365467f, -0.08525721f, -0.00743886f, -0.14434610f, -0.16571572f, 
    0.18126529f, -0.34889027f, 0.23222901f, -0.17095001f, 0.35951036f, -0.27140176f, 0.00662178f, 0.08116240f, 
    0.12479628f, 0.01562460f, 0.11407791f, 0.04846889f, -0.07463966f, 0.06872670f, 0.13402294f, -0.13442653f, 
    0.06296304f, 0.25947183f, 0.03648553f, 0.05308444f, 0.29568592f, 0.23518968f, -0.44926322f, 0.14291702f, 
    0.19745564f, 0.00392758f, 0.22938113f, -0.01978335f, -0.08320108f, 0.14636074f, 0.01109926f, 0.09266847f, 
    0.02051108f, 0.30118573f, 0.01019794f, -0.05498083f, 0.01984675f, 0.20379223f, 0.04751680f, 0.06431276f, 
    0.12982590f, 0.37212110f, -0.00177692f, 0.18630873f, -0.21820949f, 0.11256374f, -0.05619438f, -0.08311081f, 
    0.02285654f, 0.10217112f, -0.08797379f, -0.03857517f, -0.00018520f, 0.07916147f, 0.01426427f, -0.04401179f, 
    0.03539382f, 0.08446191f, 0.16319452f, 0.06007661f, -0.02212513f, -0.01696148f, -0.17883161f, 0.00405904f, 
    0.13443749f, -0.03987985f, -0.02412212f, -0.14502929f, 0.03700100f, 0.05522639f, 0.06211947f, -0.00395476f, 
    -0.09830338f, 0.07218324f, -0.03683217f, -0.11636497f, -0.01930816f, -0.17315325f, -0.04346085f, -0.04337326f, 
    0.17727926f, 0.23063813f, 0.40036449f, 0.00486206f, -0.31115723f, 0.12554520f, 0.05624999f, 0.13798636f, 
    0.08822788f, 0.07830808f, -0.03174317f, 0.00237933f, 0.00389777f, 0.04390077f, 0.02469638f, -0.01410232f, 
    0.04279947f, 0.12937868f, -0.12357086f, 0.07315561f, 0.02584941f, 0.25694731f, 0.19305597f, 0.08369655f, 
    -0.26040748f, 0.12280481f, -0.02510202f, 0.03861092f, 0.00051383f, 0.08074186f, 0.02716554f, 0.09220027f, 
    0.09453248f, -0.06254195f, -0.03152148f, -0.16860728f, 0.00688299f, 0.01650959f, -0.00408460f, 0.18180002f, 
    -0.08814292f, -0.14402622f, 0.15930849f, 0.12264818f, 0.30265367f, 0.07354982f, -0.01414633f, 0.06993114f, 
    -0.07808434f, 0.05630428f, -0.02954718f, 0.08055992f, -0.03125599f, 0.12256610f, 0.00828886f, -0.06779651f, 
    0.00929292f, 0.11912050f, -0.02265376f, -0.03347279f, 0.15977034f, -0.17285569f, -0.08453355f, 0.07627185f, 
    0.26373231f, -0.07147246f, -0.02459114f, 0.00120702f, 0.03958623f, 0.00241503f, 0.17058934f, 0.02180806f, 
    0.12310060f, -0.00756138f, 0.08869743f, -0.03099072f, -0.04259400f, -0.03130367f, -0.01855436f, 0.08909964f, 
    -0.49196425f, -0.10195126f, -0.07817475f, 0.32140306f, -0.04705670f, 0.18561195f, -0.19422999f, -0.02883469f, 
    0.04226009f, -0.10020531f, 0.17944577f, 0.09500326f, -0.03219885f, -0.04150268f, 0.02773784f, 0.16464582f, 
    -0.02424925f, 0.03733258f, -0.11023623f, 0.08028333f, -0.08269004f, -0.00025745f, -0.01073934f, 0.11968700f, 
    0.21135743f, 0.03197042f, -0.00852271f, 0.00063744f, 0.02287778f, 0.00931089f, 0.01749688f, -0.05898140f, 
    0.05666799f, 0.10954678f, -0.05095391f, -0.07094800f, -0.00212667f, 0.00856665f, -0.02077311f, 0.01227776f, 
    0.29390624f, 0.28897843f, 0.24966401f, 0.03227185f, -0.41614050f, -0.07215551f, 0.03139428f, -0.11939838f, 
    0.07886302f, -0.09720998f, 0.04682362f, -0.03341311f, -0.02114809f, 0.06406291f, -0.05633395f, -0.03567446f, 
    0.03025052f, 0.00018319f, -0.06602180f, 0.04675144f, 0.25819242f, 0.21382810f, 0.11522210f, 0.01801695f, 
    -0.04345780f, 0.04850118f, 0.12020155f, 0.04516723f, 0.06543609f, -0.04056111f, -0.03393476f, -0.04837376f, 
    0.06536794f, -0.05639789f, 0.01582699f, -0.09528494f, 0.00888426f, 0.00327378f, 0.05163668f, 0.07149243f, 
    0.65940362f, -0.07990487f, -0.03986036f, -0.00458472f, -0.30531496f, 0.02616813f, 0.01787617f, 0.03849601f, 
    -0.05732058f, 0.03276484f, -0.03043343f, -0.01653854f, -0.14635238f, -0.07639443f, -0.02360784f, -0.00728537f, 
    0.00415544f, -0.08698907f, -0.03804645f, 0.08340958f, -0.13242635f, 0.40210465f, 0.15967120f, -0.00816453f, 
    -0.14363213f, 0.00967112f, 0.04483993f, -0.18749425f, -0.06414530f, 0.06056624f, 0.00951418f, -0.13886794f, 
    -0.00048887f, 0.04482363f, -0.04552066f, 0.00393268f, 0.02754782f, -0.03987619f, -0.05274209f, -0.10548038f, 
    0.58669072f, -0.35135463f, 0.01513613f, -0.00619952f, 0.08082538f, -0.16740270f, -0.04720233f, -0.03922726f, 
    -0.02042766f, -0.09150843f, 0.13896975f, 0.06061682f, 0.05120091f, 0.03678286f, -0.00891721f, -0.00589862f, 
    0.06960028f, 0.14331888f, 0.01367622f, -0.14971694f, 0.16671233f, 0.04000303f, 0.07911018f, -0.23933157f, 
    -0.08080532f, 0.04442936f, 0.05678444f, 0.03766314f, -0.15131107f, -0.10127523f, 0.19434743f, 0.07339379f, 
    0.10343687f, 0.06063007f, 0.03611095f, -0.06032900f, 0.00613073f, -0.00956737f, 0.01654878f, 0.10577811f, 
    -0.11361589f, -0.01436497f, 0.02974956f, -0.06297517f, -0.08979746f, 0.13919471f, 0.01910091f, -0.17044024f, 
    -0.26721114f, 0.13435093f, -0.06436066f, -0.05635751f, -0.03294478f, 0.07245845f, -0.02483115f, -0.03811273f, 
    0.00443426f, -0.22807501f, -0.21999466f, -0.04149090f, 0.16026333f, 0.01102734f, 0.60822266f, -0.05268547f, 
    -0.41233489f, 0.11024375f, 0.08011695f, 0.16236094f, 0.02855002f, 0.10547574f, 0.02771608f, -0.08101723f, 
    -0.02096637f, -0.14652517f, 0.03911952f, 0.02788942f, 0.00110714f, -0.13505331f, 0.03357430f, 0.01568279f, 
    0.03065060f, 0.29155701f, 0.49065468f, 0.13252325f, -0.09681713f, -0.03564425f, -0.26191637f, -0.16125101f, 
    0.02799918f, 0.02913889f, -0.04839386f, -0.00068686f, 0.07987490f, -0.01954129f, 0.01566582f, -0.00684968f, 
    0.00271996f, 0.21250494f, 0.29229128f, 0.06479985f, 0.04993771f, 0.06185548f, -0.00998386f, 0.12742770f, 
    -0.05177398f, -0.06873360f, -0.02741111f, -0.13375974f, 0.00310101f, -0.00772478f, -0.05018480f, 0.03194727f, 
    0.01291535f, 0.04901302f, 0.08412153f, -0.09040562f, 0.17204158f, -0.12855104f, 0.07270237f, -0.03409860f, 
    0.24326240f, 0.17104405f, 0.15948507f, 0.09997471f, 0.16598286f, 0.05369642f, 0.08943212f, 0.01243404f, 
    0.04096569f, -0.04122333f, -0.03002747f, -0.04637672f, 0.00369276f, 0.04556066f, 0.07485927f, 0.04084108f, 
    0.07317863f, 0.07073303f, -0.15181684f, 0.13278204f, -0.03367642f, 0.24674809f, 0.15266119f, 0.01705498f, 
    0.15206209f, 0.09150483f, -0.01030377f, -0.07293039f, -0.01339302f, 0.04518700f, 0.02140898f, -0.01617198f, 
    0.08628809f, -0.04859293f, -0.03259385f, -0.19742920f, 0.06425256f, 0.16278577f, -0.15196419f, -0.01200146f, 
    0.06691525f, -0.08526746f, 0.16081864f, 0.11498903f, 0.11979479f, 0.06079455f, 0.09473778f, -0.04430410f, 
    0.07272467f, 0.01605017f, 0.04645745f, -0.10278627f, 0.05049803f, -0.04495259f, 0.04801571f, 0.03790689f, 
    -0.17182250f, 0.08333555f, -0.07449752f, -0.04322571f, 0.12089229f, -0.01542682f, -0.17386846f, -0.02267969f, 
    -0.05726290f, 0.05299169f, -0.13900767f, 0.14535891f, 0.12515409f, 0.04496167f, 0.02445527f, 0.06726019f, 
    -0.02427774f, 0.08974680f, 0.07462499f, -0.05286939f, -0.03143777f, -0.01449102f, -0.00523788f, -0.09578119f, 
    0.10217854f, -0.42737404f, -0.03342880f, -0.03626052f, 0.10888816f, 0.02989808f, -0.18105200f, 0.08345355f, 
    -0.06874243f, -0.06403948f, 0.21809192f, 0.07202160f, -0.04967765f, 0.04527029f, -0.00599881f, 0.06462346f, 
    -0.03899684f, 0.09189606f, -0.13596791f, 0.20121436f, 0.06349615f, 0.07150789f, 0.02643818f, 0.10508019f, 
    0.07861201f, 0.05444041f, -0.07677855f, -0.04700820f, -0.02829156f, 0.02060469f, 0.14599638f, -0.02865252f, 
    0.13823219f, 0.11829749f, 0.15780941f, -0.09752694f, 0.01445096f, -0.04873106f, -0.02682824f, 0.00873430f, 
    0.50956315f, 0.30062291f, -0.07683069f, 0.41896549f, 0.04208687f, -0.10829332f, 0.03066244f, -0.29605404f, 
    -0.05411299f, 0.14398888f, 0.05682891f, 0.02256966f, 0.01042809f, 0.06453259f, -0.01301805f, -0.06118619f, 
    -0.00203586f, -0.02564399f, -0.04491396f, 0.09889890f, 0.04892705f, -0.08620347f, -0.14148355f, 0.06117008f, 
    0.10150775f, 0.10175920f, 0.07175911f, 0.15238068f, -0.05966539f, 0.07161929f, 0.02075819f, -0.07048944f, 
    0.07739216f, -0.00809550f, 0.00693158f, -0.03303769f, -0.08652943f, 0.05046219f, -0.05882644f, -0.00744465f, 
    0.71081859f, -0.18082502f, -0.36077020f, 0.15298788f, -0.10645024f, -0.16847116f, 0.25180396f, 0.08163947f, 
    -0.20579220f, -0.01448255f, 0.03185052f, -0.07117110f, -0.06269917f, -0.05995329f, -0.03137742f, -0.07374100f, 
    0.11881867f, -0.01886211f, -0.04697883f, -0.03342362f, 0.19116974f, 0.12270540f, 0.83815283f, -0.12961616f, 
    0.13371307f, -0.07127914f, -0.10819028f, -0.28505954f, -0.06370452f, 0.03292777f, 0.01306432f, -0.08442190f, 
    0.08371455f, 0.00820793f, -0.05042566f, -0.01082277f, 0.06722751f, 0.00046681f, -0.03424385f, -0.00331716f, 
    0.18994938f, -0.21130954f, 0.05079732f, -0.11256707f, -0.30307660f, -0.05761126f, -0.03179989f, 0.00809189f, 
    0.00842067f, 0.03940988f, 0.00481618f, -0.17143117f, -0.01684956f, 0.04629880f, 0.02562820f, -0.04778660f, 
    -0.02699254f, -0.09064142f, -0.13392940f, -0.22880223f, 0.14026046f, -0.27359673f, -0.03701865f, 0.00493458f, 
    0.04753904f, -0.01206235f, 0.14144899f, 0.03815683f, -0.13854529f, 0.00304268f, 0.11727819f, 0.07049167f, 
    0.18524513f, 0.12064123f, 0.01653743f, -0.01702768f, 0.00605770f, -0.00795518f, 0.06351272f, -0.10566823f, 
    0.24364641f, -0.05340102f, 0.45913666f, -0.11778609f, 0.08895646f, -0.00796614f, -0.12041005f, -0.14351732f, 
    -0.20264001f, 0.05944883f, -0.00331825f, -0.01669374f, 0.03410255f, -0.00734756f, -0.06823923f, -0.03226000f, 
    0.13996078f, -0.08707867f, -0.05991339f, -0.04459200f, 0.15785445f, -0.00388526f, 0.46391881f, 0.09837636f, 
    0.03582813f, 0.14294156f, 0.13393442f, 0.19294377f, -0.04231636f, 0.08806776f, -0.11239434f, -0.07860355f, 
    0.06966574f, 0.05095837f, 0.09649757f, 0.06503414f, 0.05009317f, -0.09113064f, 0.08075468f, 0.12058268f, 
    -0.43938205f, 0.22624598f, 0.33599213f, -0.01391599f, -0.06057825f, -0.08287459f, -0.05535432f, 0.02138907f, 
    -0.15261355f, -0.00163568f, -0.00715458f, -0.03367612f, 0.02928944f, 0.00090895f, 0.09231114f, -0.02474234f, 
    -0.06097608f, 0.03835165f, -0.02353374f, -0.09559978f, -0.02266137f, 0.12325785f, 0.17651354f, -0.07123936f, 
    -0.08335365f, -0.07776259f, -0.05196993f, 0.02155649f, -0.02094447f, -0.05117809f, 0.10211246f, 0.03942462f, 
    0.14351563f, -0.00062047f, 0.02030918f, -0.01699069f, 0.07163342f, 0.05237219f, 0.12880370f, -0.00831387f, 
    0.16057296f, 0.20761916f, -0.17769620f, 0.03781727f, 0.11725110f, 0.09294134f, 0.13234788f, -0.13642849f, 
    0.17629220f, 0.10722882f, -0.01725551f, -0.02113770f, -0.02535369f, -0.12886056f, -0.03872882f, -0.04711235f, 
    0.02105054f, 0.01422678f, -0.09699812f, 0.05904468f, -0.08628967f, 0.18257579f, -0.06127382f, 0.08718735f, 
    0.01346852f, 0.11655752f, 0.02800307f, -0.03916337f, -0.04731215f, 0.13019092f, 0.01570299f, 0.02881803f, 
    -0.07510095f, -0.14460067f, -0.09736023f, -0.01085283f, -0.05949143f, 0.16615210f, -0.10178109f, -0.12077668f, 
    -0.04128677f, 0.14067367f, 0.09341310f, 0.19447064f, -0.25025436f, -0.01543216f, 0.08197821f, 0.00967077f, 
    -0.11058053f, -0.14398851f, 0.03117399f, 0.11969016f, 0.18737742f, 0.11643885f, 0.09705126f, -0.07119866f, 
    -0.06877220f, 0.18942024f, 0.01063064f, -0.09945685f, 0.15288350f, 0.18982884f, 0.09745891f, -0.18888164f, 
    0.04154281f, -0.01197043f, 0.09103837f, 0.03112658f, 0.11265109f, -0.11337287f, -0.02807360f, -0.05282166f, 
    -0.12679611f, -0.23666111f, 0.19047387f, -0.07647321f, 0.04653395f, -0.01707006f, 0.04914080f, -0.08615958f, 
    0.45647550f, 0.16307394f, 0.14351042f, -0.14542265f, 0.09269854f, -0.02342985f, -0.06790233f, -0.14067331f, 
    -0.07160193f, -0.06063263f, 0.08002078f, -0.00189553f, -0.03177180f, -0.03743795f, -0.01312859f, 0.05800940f, 
    -0.04704538f, -0.06422232f, -0.07075526f, 0.06971408f, 0.02382928f, 0.15844181f, 0.11029350f, -0.01498996f, 
    -0.12934783f, -0.02588855f, -0.02669525f, 0.09781029f, -0.00171138f, -0.09632818f, 0.08439714f, 0.09101444f, 
    0.13217723f, 0.13887107f, 0.13837522f, -0.08797110f, -0.08677727f, 0.07187621f, 0.04049207f, -0.06016881f, 
    0.25910988f, 0.04604682f, -0.24731237f, 0.08555105f, 0.12052990f, -0.00145016f, 0.17654309f, 0.01509957f, 
    0.10113444f, 0.14415313f, -0.10347577f, -0.00381303f, 0.04690762f, 0.03808240f, -0.00040994f, -0.04769713f, 
    0.03218661f, -0.04471004f, 0.00613135f, 0.10868856f, 0.02090146f, -0.31569678f, -0.27239630f, 0.10829518f, 
    0.06957980f, 0.16511665f, 0.26309246f, 0.26674736f, 0.15040766f, -0.00652070f, -0.05104708f, -0.09491485f, 
    0.03286149f, 0.06190009f, -0.03501195f, -0.02159280f, 0.07208697f, -0.01521671f, 0.05187659f, 0.15927453f, 
    0.37921759f, -0.06400421f, -0.20953071f, -0.14476319f, 0.31134838f, 0.00892058f, 0.00263537f, 0.22960022f, 
    -0.13454786f, 0.18489383f, -0.11472410f, 0.04120397f, -0.02776278f, -0.01792502f, 0.01343519f, -0.00286174f, 
    0.10437530f, -0.04350932f, -0.04107922f, -0.00133080f, -0.09418556f, 0.09764370f, 0.15316018f, -0.01972139f, 
    -0.27734607f, -0.00693110f, -0.16623683f, -0.00145148f, 0.01155940f, -0.06010654f, -0.00194409f, 0.02342692f, 
    0.08634748f, 0.03456687f, -0.00412083f, 0.04534512f, -0.02462562f, 0.07803980f, 0.00433242f, -0.02809625f, 
    0.13889748f, 0.11502864f, 0.08442964f, 0.25783715f, -0.07650378f, -0.03937689f, 0.00082079f, 0.06155341f, 
    -0.03987592f, -0.00485497f, 0.04388146f, 0.08800308f, -0.13177468f, -0.02266294f, -0.01659893f, 0.05512851f, 
    0.00795273f, -0.14703967f, 0.13402286f, -0.00550330f, -0.33086869f, -0.10541562f, -0.03355490f, 0.08099934f, 
    -0.01696835f, 0.05160087f, 0.13597177f, 0.10164689f, 0.17727146f, 0.11312401f, 0.04759834f, 0.09285893f, 
    0.05430976f, 0.05524948f, -0.05455567f, 0.03196143f, 0.00621964f, -0.03503264f, 0.15131451f, 0.08268926f, 
    -0.28117833f, 0.20233834f, -0.00220220f, 0.04906176f, -0.25975135f, 0.22811513f, -0.07716228f, -0.33868602f, 
    -0.15094277f, 0.01287764f, 0.09858789f, -0.02501005f, 0.12582155f, 0.01920578f, -0.02921761f, 0.15584506f, 
    0.00424653f, -0.05822101f, 0.05830618f, -0.06020504f, 0.43667397f, 0.16263473f, 0.23827931f, -0.06874309f, 
    -0.04179363f, 0.12051704f, -0.07917873f, 0.27273351f, 0.02211798f, 0.22457534f, -0.07168280f, -0.04930671f, 
    -0.08604099f, -0.07315131f, 0.11291447f, 0.04027722f, 0.09199933f, -0.08964811f, -0.03626274f, -0.02871859f, 
    0.00807745f, -0.29883507f, -0.04248343f, 0.06464642f, 0.04749630f, 0.05356888f, 0.04432316f, -0.00901838f, 
    0.02147454f, 0.09054051f, -0.02772419f, 0.05283537f, -0.03768954f, 0.01256688f, 0.00153589f, -0.06069788f, 
    -0.00601796f, -0.19633204f, -0.09360160f, -0.03642148f, -0.24436301f, -0.02504107f, -0.08504993f, -0.00535370f, 
    0.08172195f, -0.06566110f, 0.04650136f, -0.00771351f, 0.04526849f, 0.01034415f, -0.08106334f, 0.07252245f, 
    -0.01481783f, 0.04154573f, -0.07090180f, 0.10741770f, -0.08605781f, 0.12418826f, -0.03630693f, 0.05784465f, 
    -0.03642808f, -0.07812574f, -0.10550249f, -0.32339036f, -0.37665349f, 0.13516468f, -0.13064477f, 0.15934597f, 
    0.11488530f, -0.07871976f, -0.02893393f, 0.01436751f, 0.06276368f, 0.07964656f, -0.10649153f, 0.05277682f, 
    -0.00927631f, -0.05020464f, 0.01341656f, -0.01091226f, 0.27921623f, 0.07979649f, 0.25746402f, 0.03377968f, 
    -0.15650617f, 0.02576887f, -0.14092283f, 0.02116897f, 0.12372560f, 0.01521821f, -0.00755242f, 0.00168403f, 
    0.06851666f, -0.02468292f, -0.06485428f, 0.18943484f, -0.04575250f, -0.07466777f, 0.09453376f, -0.02545505f, 
    -0.42482033f, -0.38164634f, 0.08026449f, -0.02432880f, 0.15598956f, 0.09904028f, 0.02520968f, -0.02910130f, 
    0.09717906f, -0.05615851f, -0.10013229f, 0.07442677f, -0.02723273f, 0.11756866f, 0.01858310f, 0.05646560f, 
    0.12523046f, 0.03259372f, 0.15305126f, -0.04422973f, -0.17921256f, -0.11305179f, -0.09082062f, 0.14857449f, 
    0.13295314f, -0.01471198f, 0.11471494f, 0.02933617f, -0.01549887f, 0.02504012f, 0.04071825f, -0.00628794f, 
    0.05227578f, 0.15434046f, 0.13120820f, 0.07637196f, 0.07361111f, 0.04848440f, 0.04936521f, 0.21058637f, 
    -0.10050183f, 0.49885616f, 0.09668314f, 0.10521410f, 0.18036668f, -0.00851803f, 0.15524136f, 0.00727009f, 
    0.23931755f, -0.10278706f, 0.02293693f, 0.02320214f, -0.03162193f, -0.04228221f, 0.05430097f, 0.17162004f, 
    -0.05343075f, 0.10921921f, 0.00389614f, -0.04455868f, -0.26788953f, -0.22673731f, -0.06360262f, -0.07972075f, 
    0.04482318f, -0.10312915f, -0.02053330f, 0.07690690f, 0.01489754f, 0.04892818f, -0.20162623f, 0.10910248f, 
    -0.03076380f, 0.09658326f, -0.06925434f, 0.12550792f, 0.07448319f, 0.10901955f, -0.02066846f, -0.02445824f, 
    0.03023612f, -0.00592348f, 0.05301568f, -0.36600178f, -0.40740880f, 0.11733047f, -0.13836189f, 0.17060921f, 
    0.20966601f, -0.28349125f, -0.03828147f, -0.05025508f, -0.02463430f, -0.07239297f, -0.11465070f, 0.01411384f, 
    0.03578068f, 0.00832693f, 0.19288817f, 0.16368961f, 0.25214350f, 0.19257188f, 0.23144057f, 0.07775005f, 
    0.07129705f, -0.13305451f, -0.08900229f, -0.03930481f, 0.05041950f, 0.06128284f, 0.00627914f, 0.03709378f, 
    0.01585880f, -0.04161718f, -0.07424136f, -0.04550737f, 0.11591570f, 0.02883761f, 0.09718382f, 0.11186061f, 
    -0.22690986f, 0.01104205f, 0.27649847f, 0.25669518f, -0.08100788f, 0.30409223f, -0.06198063f, -0.05061797f, 
    0.27604684f, 0.18569607f, -0.06954060f, 0.21350774f, -0.01585758f, -0.01848206f, 0.10263338f, 0.03684740f, 
    -0.00665814f, -0.12128281f, 0.10169821f, 0.17112698f, -0.11957114f, 0.38199827f, 0.03818633f, -0.06373587f, 
    -0.27084231f, 0.06180289f, -0.01970515f, -0.00687161f, -0.16616246f, -0.08204567f, 0.00884066f, 0.04171507f, 
    0.00065728f, 0.07406811f, -0.09677991f, -0.00777656f, -0.07216434f, 0.11071467f, -0.13302192f, -0.03308266f, 
    -0.17008440f, -0.04478251f, -0.14613596f, 0.17785397f, 0.19390993f, -0.02446130f, -0.14176251f, -0.10080750f, 
    -0.06849577f, -0.09749986f, -0.04991372f, 0.15160145f, 0.03304885f, -0.00881197f, 0.15385997f, 0.06539311f, 
    0.10399023f, 0.33037820f, 0.05848115f, -0.10613765f, -0.03014179f, 0.25420481f, 0.15399648f, 0.06058518f, 
    0.01633747f, -0.12630764f, -0.10110370f, -0.18150425f, 0.16841452f, -0.01818671f, -0.06851793f, -0.05830051f, 
    -0.01086519f, -0.01257752f, 0.04233781f, 0.05173229f, 0.19133747f, 0.02874857f, 0.13729763f, 0.32065082f, 
    -0.29809329f, -0.14230826f, 0.13592474f, 0.03692256f, -0.45723236f, 0.31753415f, 0.05245342f, 0.00686564f, 
    -0.00373776f, 0.11931454f, 0.01183090f, -0.00208962f, 0.04013192f, 0.06921685f, 0.01685543f, -0.03649954f, 
    -0.13848235f, 0.04972195f, 0.03330252f, -0.15179151f, 0.17416227f, 0.06981693f, -0.00461804f, -0.03692096f, 
    -0.26133907f, -0.01485045f, -0.06465316f, 0.06455705f, 0.02325392f, -0.09265751f, 0.05786081f, -0.01050859f, 
    0.00995011f, -0.11174431f, 0.05300273f, 0.08519129f, -0.00334021f, -0.10090855f, -0.04689680f, -0.11971685f, 
    0.04133645f, -0.04655157f, 0.02525430f, 0.00762788f, 0.03732286f, -0.05747862f, -0.00753854f, -0.05165277f, 
    0.04117654f, -0.04998827f, 0.04021190f, 0.04324390f, 0.04169618f, -0.02913547f, -0.05871340f, 0.02762498f, 
    0.01764817f, -0.04893184f, 0.00999925f, -0.04079780f, -0.04344888f, -0.03915434f, -0.03346145f, -0.03997822f, 
    -0.01391220f, 0.03877496f, 0.03097255f, -0.01723912f, -0.01797570f, -0.05573356f, -0.00064117f, 0.02693396f, 
    -0.05875607f, -0.05176017f, 0.00207074f, 0.03914326f, 0.01788147f, -0.01402066f, 0.00054219f, 0.01293874f, 
    -0.01766550f, 0.00391678f, 0.02685369f, 0.04490016f, 0.02670950f, 0.00521022f, -0.04247856f, 0.04916080f, 
    0.03035011f, 0.01331682f, 0.02724830f, 0.04666421f, -0.06090566f, 0.02930080f, 0.01985541f, -0.02487086f, 
    -0.05685936f, 0.02271940f, 0.00749113f, 0.01773110f, -0.05496372f, 0.03111567f, 0.04735073f, -0.00078396f, 
    0.00451545f, -0.05851331f, -0.04782100f, -0.05142228f, -0.05067553f, 0.03716952f, 0.03876477f, -0.03124912f, 
    0.04011307f, -0.05268984f, -0.01900253f, -0.01657112f, 0.04372187f, -0.01340511f, -0.00025139f, 0.04712700f, 
    -0.02091755f, 0.01818278f, -0.03753848f, -0.04440736f, -0.03428122f, 0.04426786f, -0.01244231f, -0.00351823f, 
    0.04393553f, 0.00818951f, -0.06116804f, 0.00044223f, -0.02287490f, -0.04899725f, 0.03669212f, -0.03523996f, 
    -0.05797724f, -0.01811297f, 0.03148030f, 0.04379930f, 0.01606286f, -0.05020057f, 0.02935846f, -0.04857494f, 
    -0.05183161f, -0.01269336f, 0.03831785f, 0.01103362f, 0.03993176f, -0.00893539f, -0.03839031f, 0.04316967f, 
    -0.00333682f, -0.03485412f, 0.00600140f, 0.01378427f, -0.04838054f, -0.00449028f, 0.01627255f, 0.02140943f, 
    0.01531525f, -0.01475951f, -0.03768227f, -0.02569310f, 0.03944282f, 0.02088362f, -0.05011786f, 0.03231414f, 
    -0.00226673f, -0.00104995f, 0.00483480f, -0.03056420f, -0.05766442f, 0.01050927f, -0.00168988f, 0.00716001f, 
    -0.00823888f, 0.00057087f, -0.04410500f, -0.03613799f, 0.00909335f, 0.02385201f, -0.03129767f, 0.03138961f, 
    0.00579344f, 0.03324840f, -0.01088235f, -0.03059745f, -0.03269603f, 0.04667205f, -0.06186465f, -0.05339051f, 
    -0.05731995f, 0.00812935f, 0.02457317f, -0.00981643f, -0.03151248f, 0.00779264f, -0.00553812f, -0.00761061f, 
    -0.05617712f, -0.00860866f, -0.01098211f, -0.04617506f, -0.02863665f, 0.04963893f, 0.02219999f, -0.05482377f, 
    0.00912781f, 0.01531440f, 0.01610880f, -0.02417352f, 0.00603933f, 0.00743143f, -0.02866841f, -0.02186430f, 
    0.02318546f, 0.01517465f, 0.03858178f, 0.01954759f, 0.00352852f, 0.03724215f, 0.04357693f, -0.04585091f, 
    0.00635758f, 0.00822731f, -0.00886263f, 0.00158311f, -0.02933012f, 0.03174848f, -0.00093923f, -0.01620790f, 
    -0.04280344f, 0.01437830f, 0.00566124f, -0.04351711f, -0.04514039f, 0.03420169f, -0.03135164f, -0.04732020f, 
    0.01680282f, -0.01951884f, 0.01472291f, -0.00625361f, 0.02806545f, -0.03631946f, -0.01259013f, -0.04860933f, 
    -0.05037371f, -0.03907887f, 0.00347191f, 0.00780495f, 0.02362115f, -0.02115835f, 0.00829357f, -0.03861490f, 
    0.04048168f, -0.02844556f, -0.02700310f, 0.01494566f, -0.00194856f, 0.00770184f, -0.03803253f, 0.03727218f, 
    0.02594738f, -0.04779248f, 0.02460017f, 0.00827089f, 0.03818531f, 0.02136443f, -0.01961453f, 0.00667956f, 
    -0.01079591f, -0.01609569f, -0.05682655f, -0.05884168f, -0.04045422f, 0.01139496f, -0.00621181f, -0.03158748f, 
    -0.01821256f, 0.03664254f, -0.02950018f, -0.04958663f, -0.04518973f, -0.03223740f, -0.01095421f, 0.01960016f, 
    -0.02254477f, -0.01604715f, -0.03375276f, -0.00882113f, 0.00528244f, 0.02700631f, -0.06235224f, -0.05216252f, 
    -0.03661672f, 0.03387834f, -0.02986091f, 0.00284174f, -0.06076380f, 0.02595817f, 0.03678313f, 0.00763624f, 
    -0.02247133f, -0.02279108f, -0.00865751f, 0.01677255f, -0.02363907f, 0.03208977f, -0.01772701f, -0.03640645f, 
    -0.00717613f, 0.03592001f, -0.00261478f, 0.03735865f, 0.03512840f, -0.02084262f, -0.03323748f, -0.00854062f, 
    -0.00518510f, -0.00907328f, -0.02457495f, 0.01206280f, 0.04500142f, -0.01893124f, 0.01807397f, -0.00452624f, 
    0.00628321f, 0.01003555f, -0.02248628f, 0.03061392f, -0.02934496f, -0.03875143f, 0.02362172f, 0.02741650f, 
    0.00674383f, 0.03053648f, -0.03728595f, 0.03202453f, 0.00444719f, 0.05074096f, -0.05468952f, -0.00238949f, 
    -0.05090125f, -0.02308225f, 0.00687532f, 0.02342898f, -0.00454053f, -0.00876967f, -0.00625311f, -0.04557027f, 
    0.03766699f, 0.01758097f, -0.05363689f, -0.03693097f, -0.06202885f, 0.02951016f, -0.02460838f, -0.00428817f, 
    0.03281437f, 0.45849687f, -0.14315237f, 0.26481739f, -0.16968362f, 0.00985351f, -0.11235537f, -0.03940308f, 
    -0.00725390f, -0.03009238f, -0.07334256f, 0.02783890f, 0.03026458f, -0.01929608f, -0.03013042f, -0.02599381f, 
    0.17386544f, -0.15740857f, 0.07653564f, -0.03854648f, -0.15482137f, 0.23830788f, 0.03232440f, 0.14649794f, 
    -0.15203366f, -0.11951610f, 0.09174667f, 0.10172357f, 0.00738042f, -0.08669214f, -0.00065058f, 0.08187555f, 
    -0.04949474f, 0.07299878f, -0.00115546f, -0.02264048f, 0.08758039f, 0.13563597f, -0.02156157f, 0.09482934f, 
    0.24278350f, 0.08889196f, 0.18693058f, -0.18285678f, -0.14010315f, 0.09811404f, -0.15692064f, 0.07740379f, 
    0.01517504f, 0.07110991f, 0.08960251f, 0.04043638f, -0.03920865f, -0.08129185f, -0.04027169f, 0.02577468f, 
    -0.01026761f, 0.02532024f, 0.20125879f, -0.11202864f, 0.21819796f, 0.08375856f, 0.22370282f, 0.10634480f, 
    0.12513871f, 0.19978668f, -0.11597897f, 0.05396974f, 0.02712697f, -0.01940850f, 0.01823895f, -0.02062551f, 
    0.05480703f, 0.05835907f, -0.00206948f, 0.25105995f, 0.22082084f, 0.14129710f, 0.15390657f, -0.05464754f, 
    -0.08083159f, 0.14392175f, 0.15819772f, -0.00072856f, -0.05666023f, 0.00998989f, 0.13387673f, 0.01007110f, 
    0.00121918f, -0.12965931f, -0.00084361f, -0.10043410f, 0.13402088f, -0.00550496f, 0.10672919f, 0.22030710f, 
    -0.04886891f, 0.19333701f, -0.11718961f, -0.01926366f, -0.16598795f, -0.06489605f, -0.00210596f, 0.03297193f, 
    -0.07224531f, -0.04660720f, 0.02572490f, 0.05417763f, -0.10997790f, -0.06021829f, 0.10513435f, 0.08261828f, 
    -0.03945678f, 0.02447699f, 0.15383416f, -0.00117899f, 0.02713323f, 0.00105879f, 0.00034711f, 0.03062451f, 
    -0.16801570f, -0.14643800f, -0.22183308f, 0.35315061f, -0.27782148f, -0.01998211f, -0.11557845f, 0.08868413f, 
    0.15673263f, 0.01649786f, 0.07671120f, 0.05180225f, -0.02069825f, 0.11686302f, 0.03329881f, 0.07964229f, 
    0.00963928f, 0.10220605f, -0.14417982f, 0.02054939f, -0.04309689f, 0.21171215f, 0.06367058f, -0.04264442f, 
    -0.17951545f, -0.05882397f, 0.16808018f, 0.04902358f, 0.02291375f, -0.10993098f, -0.05772235f, 0.00610431f, 
    0.11865237f, -0.04292534f, -0.00438609f, 0.07943357f, -0.02411555f, 0.09239298f, -0.05330743f, 0.06930133f, 
    0.14666761f, 0.15993768f, 0.13211267f, 0.06091370f, -0.12713882f, -0.11108198f, -0.14094703f, 0.02906600f, 
    -0.05618474f, 0.17516091f, -0.08214455f, -0.01256200f, 0.02345468f, -0.05098945f, -0.02665953f, -0.01200190f, 
    0.02091732f, -0.08661598f, -0.03714655f, -0.04965462f, 0.27129933f, -0.19676654f, -0.02981162f, 0.04190340f, 
    -0.01452691f, 0.01450382f, 0.00083859f, 0.09611626f, 0.04661358f, 0.12540591f, 0.02692811f, -0.06163151f, 
    0.04509685f, -0.07582962f, 0.05313045f, -0.01393797f, 0.02148156f, -0.06579440f, 0.03567797f, -0.02340883f, 
    -0.08310224f, -1.27785873f, -0.16557644f, 0.12742159f, -0.37640113f, 0.21488237f, -0.08608030f, 0.17774297f, 
    0.27649546f, 0.23073883f, -0.12688604f, 0.03300154f, -0.00444951f, 0.15646555f, 0.05932773f, 0.00006241f, 
    0.05813627f, -0.01759916f, -0.01618419f, 0.06295125f, 0.23367719f, 0.57367361f, 0.08426401f, 0.20509611f, 
    -0.36257875f, 0.13615718f, -0.20148933f, -0.05222258f, 0.00152203f, -0.22996993f, 0.02464871f, 0.05368141f, 
    0.05516651f, -0.02751395f, -0.05105798f, -0.02257151f, 0.16051140f, 0.04279512f, 0.02261744f, 0.18732597f, 
    -0.18857700f, -0.64511889f, -0.23786825f, 0.36760587f, -0.11006608f, -0.03600813f, -0.02413248f, 0.01837906f, 
    -0.08999356f, -0.08102003f, -0.09549724f, 0.16668190f, -0.03822305f, 0.24886121f, -0.05108471f, 0.10331009f, 
    0.00653144f, -0.00718870f, -0.12115575f, 0.12561725f, -0.01952415f, -0.28813308f, 0.37222308f, -0.05133626f, 
    0.05939282f, 0.05235551f, 0.17041239f, -0.07524327f, 0.13611053f, -0.00293380f, -0.13603915f, -0.00245145f, 
    0.03868989f, -0.00234306f, 0.04026863f, -0.07799414f, -0.01362951f, -0.00544122f, 0.00652060f, 0.15572760f, 
    0.27136549f, -0.00027796f, 0.37862724f, 0.09068768f, -0.56566918f, 0.29647973f, -0.14936733f, -0.21450152f, 
    0.10923300f, -0.04471420f, 0.06013451f, 0.01930100f, 0.06182051f, 0.00697011f, -0.13003092f, 0.01096452f, 
    -0.19894816f, 0.13663261f, 0.20978363f, 0.06540109f, -0.06989506f, -0.31490666f, -0.16541317f, -0.14719181f, 
    -0.23568161f, -0.11392110f, 0.03960479f, 0.14272738f, 0.06002006f, 0.03913065f, -0.02489112f, 0.01073551f, 
    -0.04602480f, 0.10547744f, 0.06408077f, 0.11449880f, 0.05944302f, 0.17393424f, 0.00148063f, 0.18278532f, 
    0.13000949f, 0.07220004f, -0.40959576f, -0.04993719f, 0.01218787f, 0.08902691f, 0.12025171f, 0.09750430f, 
    -0.00068370f, 0.10030148f, -0.02356983f, 0.00515214f, -0.07100946f, 0.05274149f, 0.02677395f, -0.00317823f, 
    0.03553054f, 0.04408828f, 0.03303363f, 0.11576187f, -0.11051164f, -0.17637590f, -0.31561229f, -0.23184583f, 
    0.22171800f, 0.09374877f, -0.00202954f, -0.03425410f, 0.05216511f, 0.05018671f, 0.16453570f, -0.01836821f, 
    -0.01477877f, 0.12002195f, -0.00173169f, 0.00683794f, -0.06944286f, -0.04794617f, -0.05765022f, -0.19889435f, 
    -0.16609716f, -0.12984876f, 0.31971222f, 0.12298888f, -0.35009721f, -0.03920338f, -0.00703827f, 0.12141266f, 
    -0.08386134f, -0.01868375f, 0.06934908f, -0.05577319f, -0.06161525f, 0.11247411f, 0.06549290f, -0.02960194f, 
    0.06280154f, 0.02457326f, -0.02327394f, 0.11850453f, -0.10239811f, 0.13136761f, -0.00254807f, 0.15286958f, 
    -0.33734736f, 0.11386020f, 0.21600698f, 0.09818869f, 0.04142893f, 0.10093402f, 0.04610546f, 0.10887682f, 
    0.14791937f, 0.02906863f, 0.09871661f, -0.09500981f, -0.01526640f, 0.06475698f, 0.02671535f, 0.24927133f, 
    -0.16887897f, -0.11286996f, -0.37554473f, -0.19415694f, 0.28949535f, -0.12123092f, -0.16307727f, 0.00975379f, 
    -0.21040423f, 0.16501002f, 0.03636914f, 0.05820523f, -0.08564837f, 0.00879560f, 0.07639286f, 0.02951788f, 
    0.12138754f, 0.03494237f, -0.00897247f, 0.01081670f, 0.18814750f, -0.19965756f, 0.03725000f, -0.00559643f, 
    0.27173078f, -0.02674355f, -0.00280302f, -0.30241776f, -0.12202656f, 0.06631520f, 0.24593776f, 0.00976710f, 
    0.12649971f, 0.05213260f, -0.00612745f, 0.07368755f, 0.02831923f, 0.10460070f, -0.05838109f, 0.06174279f, 
    -0.58145070f, -0.00145231f, -0.03254005f, 0.34364104f, -0.14576510f, 0.17496978f, -0.08414041f, 0.01294794f, 
    0.12621218f, -0.12566042f, 0.05563109f, -0.10071939f, -0.03642208f, -0.10970885f, -0.09120402f, 0.12029959f, 
    0.11520270f, 0.17581972f, 0.07736222f, 0.01240093f, -0.27186331f, -0.20664081f, -0.27665514f, 0.00670533f, 
    0.28017986f, 0.05812347f, -0.05359747f, -0.15976083f, -0.11786898f, 0.11091866f, 0.08834256f, -0.04411392f, 
    -0.09036157f, 0.10718016f, -0.03892918f, 0.03611178f, 0.11827562f, 0.02116344f, -0.09463720f, -0.11418854f, 
    -0.04655974f, -0.00265403f, 0.40481922f, 0.04780922f, -0.33119681f, 0.04521859f, 0.02214086f, -0.08771361f, 
    0.01691659f, -0.13390866f, 0.05884975f, 0.01768567f, 0.03955359f, -0.05334479f, 0.02190287f, -0.05630537f, 
    0.00905574f, -0.00246544f, -0.07776844f, 0.06215535f, 0.14399660f, 0.27841529f, 0.32112119f, -0.05872462f, 
    -0.21370207f, -0.01539020f, 0.01315145f, -0.04996801f, 0.04396668f, -0.09550389f, 0.06020075f, 0.09840075f, 
    0.17217492f, 0.07115906f, 0.06102555f, -0.01113557f, 0.05720780f, -0.16492528f, -0.04060541f, 0.11643645f, 
    0.24985075f, 0.26114160f, 0.44066387f, -0.18024075f, -0.24257120f, 0.05134599f, -0.08611923f, -0.05528309f, 
    0.03322515f, 0.14335920f, 0.14206366f, 0.05948419f, 0.00913635f, 0.01163371f, -0.03817305f, 0.06495593f, 
    -0.00415505f, -0.11532585f, -0.00112512f, 0.09064320f, -0.33908117f, 0.23309913f, -0.53363883f, 0.12300456f, 
    -0.05683609f, 0.12373745f, 0.09257641f, 0.08212848f, 0.07862010f, 0.24209677f, -0.00028186f, 0.03124291f, 
    -0.08988413f, -0.08333977f, -0.02179040f, 0.03544160f, -0.01260760f, 0.12035586f, 0.02397258f, -0.02978616f, 
    0.30440450f, -0.04621389f, 0.01142470f, -0.15754457f, 0.24609508f, -0.14664212f, -0.16911273f, -0.21471636f, 
    -0.07260025f, -0.12898402f, 0.19611359f, 0.12670563f, 0.06019249f, -0.01586017f, 0.07225173f, 0.07247933f, 
    -0.03917460f, 0.23321791f, 0.34729770f, 0.14107682f, 0.20691039f, 0.24385932f, 0.16169693f, -0.49199918f, 
    -0.11377522f, 0.04861991f, 0.13049847f, -0.01705686f, -0.17819177f, 0.02146954f, 0.27156478f, -0.09746005f, 
    0.07816324f, 0.08010343f, -0.09262522f, 0.10286758f, -0.00086275f, -0.12490174f, -0.12247900f, 0.08413417f, 
    -0.28819776f, 0.15485568f, -0.47660011f, -0.07654277f, 0.06006151f, -0.05959126f, 0.01924860f, 0.07972848f, 
    -0.07196478f, 0.08828614f, -0.01153159f, -0.10029449f, -0.02201753f, -0.15751131f, 0.00008782f, 0.01674388f, 
    -0.15032345f, -0.05481320f, -0.11580189f, 0.17965859f, -0.21860681f, -0.12994085f, 0.41921586f, -0.07026695f, 
    -0.10082206f, 0.03680215f, -0.01654655f, -0.16794710f, 0.07274324f, -0.02828474f, 0.04393609f, -0.13390924f, 
    -0.00129646f, -0.07848504f, -0.00216309f, 0.00705420f, 0.03792595f, 0.01031237f, 0.08377214f, -0.01275518f, 
    -0.42149651f, -0.00327277f, 0.01352243f, 0.03095813f, 0.11019100f, 0.10667367f, 0.17451748f, 0.31624588f, 
    0.02371759f, 0.07438761f, -0.12452671f, -0.15986839f, -0.10863806f, -0.15995382f, 0.02659128f, 0.20327729f, 
    0.30976829f, 0.21423119f, 0.05228640f, 0.29938722f, -0.14679645f, 0.02616360f, 0.08943313f, -0.27355465f, 
    -0.25755537f, -0.06256264f, 0.00533471f, 0.10554736f, -0.10561093f, 0.02462429f, 0.06478235f, -0.27950403f, 
    -0.01308131f, -0.03607798f, -0.01072509f, -0.01374919f, -0.09050214f, -0.34102687f, -0.30844808f, 0.03902849f, 
    0.26576537f, -0.06633549f, -0.10920275f, -0.05358796f, 0.05867242f, -0.08647375f, 0.08121426f, -0.00895009f, 
    0.13566254f, 0.28983828f, -0.06484732f, -0.01600669f, -0.10364652f, 0.07782485f, -0.01606502f, 0.12814465f, 
    0.00659913f, 0.10798787f, 0.16284668f, 0.13712221f, -0.02091835f, -0.05634785f, -0.19130078f, 0.05657020f, 
    -0.02042315f, 0.01798529f, 0.06769764f, 0.01341403f, 0.03297141f, 0.01506994f, -0.00305932f, -0.00171161f, 
    -0.04593834f, 0.10344561f, -0.06646096f, 0.04607286f, 0.09930561f, 0.20116720f, 0.17762132f, 0.30608162f, 
    -0.37484458f, 0.21569708f, -0.28119481f, -0.09205142f, -0.45878750f, 0.20346956f, -0.04936881f, 0.43847722f, 
    0.12416196f, -0.47759694f, -0.00833728f, 0.08210034f, -0.14563987f, -0.00229184f, 0.09219452f, 0.05855254f, 
    -0.00373024f, -0.13425624f, 0.07721592f, -0.40424633f, 0.09052022f, 0.32235059f, 0.42195621f, -0.33304918f, 
    0.09995082f, -0.10040531f, -0.03352011f, -0.31590506f, -0.03004540f, -0.40914261f, 0.01101408f, 0.07957958f, 
    -0.00220632f, -0.20490640f, -0.19802386f, -0.22836693f, 0.01419533f, -0.26880240f, -0.11742067f, 0.06168317f, 
    0.65909207f, 0.07910376f, -0.25434092f, 0.18215841f, -0.31466612f, -0.10708894f, 0.22377139f, -0.06509567f, 
    -0.15134868f, 0.22988804f, -0.08564000f, -0.03911410f, 0.15895507f, 0.02317261f, -0.00885827f, 0.11595669f, 
    0.09052328f, -0.00434166f, 0.18749936f, 0.51267290f, -0.12872732f, 0.09283892f, -0.13957186f, -0.15842138f, 
    -0.22216453f, 0.01338298f, 0.15132251f, 0.18754485f, 0.01371248f, -0.04010233f, -0.07690232f, -0.05494354f, 
    0.18110254f, 0.08267356f, 0.20762627f, -0.12175412f, -0.25580135f, -0.26860499f, 0.06364784f, 0.01019733f, 
    0.61105645f, 0.30694902f, -0.05356663f, -0.06913029f, 0.00859654f, 0.03950819f, -0.14765319f, 0.27628830f, 
    0.01456658f, 0.38134003f, -0.00075579f, 0.18086746f, 0.04435674f, -0.12415512f, 0.02265327f, -0.00952485f, 
    -0.29434657f, -0.12033348f, -0.11798902f, -0.26036885f, 0.72458905f, 0.19221662f, 0.15673086f, 0.04038462f, 
    -0.08009468f, -0.15704377f, -0.13083059f, 0.16103789f, 0.09737701f, 0.03583719f, 0.09251452f, 0.20649621f, 
    -0.14458330f, -0.12756029f, 0.04126490f, -0.15885699f, -0.40376356f, -0.20852128f, -0.00951363f, -0.24902026f, 
    -0.18279053f, -0.35249326f, 0.58726543f, 0.08482144f, 0.36288294f, 0.06933837f, -0.11875383f, 0.38768864f, 
    -0.18234895f, -0.14185692f, 0.08586425f, -0.07120207f, -0.15093583f, 0.07221483f, 0.07025971f, 0.05832373f, 
    -0.09622797f, -0.11127416f, -0.05298433f, 0.04955125f, -0.32522377f, 0.17295779f, -0.19911434f, 0.40643689f, 
    0.13784267f, 0.06189806f, 0.29895791f, 0.22760968f, 0.17569821f, 0.17065790f, 0.12873289f, -0.06626951f, 
    0.02078776f, -0.20708878f, -0.21659172f, 0.02455473f, 0.09531017f, -0.15619946f, 0.02811085f, -0.19889520f, 
    -0.21073835f, 0.02948960f, 0.10004235f, -0.17454948f, 0.06725336f, -0.00544637f, -0.06044915f, 0.07099563f, 
    0.16796890f, 0.19058296f, 0.00362496f, 0.15584457f, 0.02717546f, 0.12611765f, 0.13401547f, -0.00904065f, 
    0.28164551f, 0.23878950f, 0.01903676f, 0.15522332f, -0.44753927f, 0.05158913f, 0.64668030f, -0.20669159f, 
    0.11160503f, 0.02796401f, -0.31331280f, 0.17804708f, -0.06866450f, -0.00804442f, 0.04411302f, 0.15275373f, 
    -0.00205856f, -0.20578738f, 0.01310544f, -0.12297039f, -0.24085157f, -0.30280837f, -0.12567683f, -0.20700932f, 
    -0.70094502f, 0.16562590f, 0.04712088f, -0.00173971f, -0.00039795f, 0.22536643f, 0.04392685f, 0.04779318f, 
    0.20155777f, -0.15329300f, -0.13771121f, -0.18055804f, -0.11902153f, -0.10400516f, -0.09900347f, 0.21243304f, 
    0.15701671f, 0.15900432f, 0.00242160f, -0.26432043f, 0.23199159f, -0.10689741f, -0.08942953f, 0.03128771f, 
    0.28792527f, 0.01227692f, 0.09397521f, 0.01743327f, 0.06972278f, 0.24103121f, 0.05245743f, 0.01761561f, 
    0.14659277f, 0.18962207f, 0.26530841f, 0.04124008f, 0.42390266f, 0.13033639f, 0.16323690f, 0.33392692f, 
    0.49884450f, -0.08124248f, -0.23885043f, -0.11400772f, -0.19237672f, -0.04819307f, -0.11257150f, 0.05427368f, 
    0.06941900f, 0.08036143f, 0.02747897f, 0.02576562f, 0.05905243f, 0.04175222f, -0.01589247f, 0.08803154f, 
    0.09288050f, 0.27600148f, 0.20091526f, 0.20093717f, 0.30108562f, -0.08281259f, -0.07693031f, 0.01403044f, 
    0.16607513f, -0.03744674f, 0.09405410f, -0.04207449f, -0.00549554f, 0.14997743f, 0.01121394f, 0.03279321f, 
    -0.03200714f, 0.01867041f, -0.05010269f, -0.00049165f, -0.08630108f, -0.12996240f, -0.02033390f, -0.00817204f, 
    0.13491358f, 0.18478751f, 0.28179318f, 0.11640029f, 0.06299376f, -0.04719907f, 0.04539605f, 0.07414337f, 
    -0.15059744f, 0.07729639f, -0.01869389f, -0.04572738f, 0.06832902f, -0.00042071f, -0.03930636f, -0.01914168f, 
    -0.04823534f, -0.05845546f, 0.25671741f, 0.19531330f, -0.37025580f, 0.09559599f, -0.02729711f, -0.16970119f, 
    0.07737529f, -0.03446902f, -0.05397344f, 0.04852645f, -0.15032624f, -0.09202923f, 0.01558951f, -0.02097765f, 
    0.00937378f, -0.08770543f, 0.01462455f, -0.18479903f, -0.00410812f, 0.17428474f, 0.15432206f, 0.30804363f, 
    0.31902227f, -0.02316098f, 0.06750008f, -0.02057797f, 0.25334510f, -0.01595164f, -0.05038506f, 0.04485625f, 
    0.07379957f, 0.08118567f, 0.12386699f, 0.03598218f, -0.05678882f, -0.10601573f, -0.08242099f, -0.02610595f, 
    0.01066368f, 0.01501066f, -0.09310152f, 0.06175618f, 0.11363645f, -0.06204480f, -0.01096125f, 0.22063498f, 
    0.10354814f, 0.04097534f, -0.06935683f, 0.04791475f, -0.01370374f, 0.12311558f, -0.14448042f, 0.01377525f, 
    0.01360166f, 0.07850807f, -0.12065515f, 0.12123348f, 0.01406930f, 0.04365307f, -0.13510136f, -0.12741175f, 
    -0.54702789f, -0.72391069f, -0.25328648f, 0.00899656f, 0.16621071f, -0.05497393f, -0.01660494f, 0.12566841f, 
    -0.15343989f, 0.13225411f, 0.17991202f, 0.00515367f, 0.12061469f, 0.05719322f, 0.00408653f, 0.02292841f, 
    0.18214059f, 0.05976694f, 0.22030959f, 0.16735950f, 0.17157044f, -0.11964457f, 0.03940308f, 0.09549302f, 
    0.22754321f, 0.09399262f, 0.05339843f, 0.03691287f, 0.00722227f, 0.09412058f, 0.09302009f, -0.05031043f, 
    0.09468973f, -0.04202722f, -0.01132060f, -0.11657747f, -0.00185423f, -0.00649808f, 0.00072307f, 0.06109304f, 
    -0.20662221f, 0.32297584f, 0.12793940f, 0.26615360f, 0.04395943f, -0.05586041f, 0.01525517f, -0.23723140f, 
    -0.07587765f, 0.08954370f, 0.05530648f, -0.00594222f, 0.02359517f, 0.01665423f, 0.03401821f, -0.03803270f, 
    -0.12363645f, 0.01212259f, -0.24376124f, -0.20729981f, -0.24992095f, 0.27701497f, 0.15605311f, 0.06087447f, 
    -0.05736661f, 0.06063861f, 0.21586493f, 0.10370410f, 0.07247139f, -0.01888946f, -0.08247358f, -0.16273867f, 
    0.08926350f, 0.04783052f, -0.00492787f, 0.09343416f, -0.09291289f, -0.10352316f, -0.18762262f, -0.17521469f, 
    0.33680561f, 0.37782848f, 0.09785144f, 0.05531885f, -0.55740595f, -0.18329051f, -0.07427431f, -0.13247526f, 
    -0.01715355f, -0.26051965f, -0.08573753f, -0.07380989f, 0.01781555f, -0.01744485f, 0.00872131f, 0.13511987f, 
    -0.01187302f, 0.07929296f, -0.04238930f, 0.05659600f, 0.21869749f, -0.20202844f, -0.06276190f, -0.25974196f, 
    0.37588838f, -0.03374652f, 0.31524605f, 0.03107942f, 0.14725612f, 0.08499140f, -0.03912961f, -0.10150860f, 
    0.03824988f, 0.01668260f, 0.04911438f, 0.10994847f, 0.08272879f, -0.10486528f, 0.16605888f, -0.01060979f, 
    0.46429598f, -0.07064598f, -0.00023871f, 0.12538411f, -0.07562876f, -0.02475007f, 0.02353277f, 0.07266512f, 
    0.09948803f, 0.10003936f, -0.01776638f, 0.02126264f, 0.21809947f, 0.06192306f, 0.04271222f, 0.16044085f, 
    0.10251017f, -0.03377509f, 0.06991024f, 0.13637662f, 0.20618807f, 0.16470072f, -0.08693697f, -0.22393763f, 
    -0.10681217f, 0.03133341f, 0.05017208f, 0.17699723f, -0.01897932f, -0.04989266f, 0.00347538f, 0.16655971f, 
    0.05409489f, -0.01905345f, 0.09099539f, -0.05675070f, -0.20746592f, 0.07766765f, -0.11444376f, -0.20649457f, 
    0.34563124f, -0.06447207f, 0.11238763f, -0.31890538f, 0.36013034f, -0.15508293f, -0.19165905f, -0.05057615f, 
    0.00170182f, -0.09619268f, -0.04859040f, 0.05618924f, -0.10002127f, 0.08007734f, -0.02584250f, -0.13606955f, 
    0.24266180f, 0.00512390f, 0.03262281f, 0.12591660f, 0.05907568f, -0.01468464f, 0.25234115f, 0.15026648f, 
    -0.30188587f, 0.14002424f, 0.00309365f, -0.15912153f, -0.00978347f, -0.03702652f, 0.01969669f, 0.03221061f, 
    0.12356041f, -0.05472147f, -0.15271196f, 0.02316318f, -0.03372585f, -0.17617665f, 0.03606522f, 0.24451317f, 
    0.37879035f, -0.10257215f, -0.43779364f, 0.00169012f, 0.08561166f, 0.05876697f, 0.09868412f, 0.06638671f, 
    0.15845348f, -0.00527461f, -0.01070922f, 0.07379031f, -0.04414011f, -0.02614876f, -0.06205658f, 0.13077332f, 
    0.25825912f, 0.09335744f, 0.13415292f, 0.20688525f, 0.00130655f, -0.04744738f, -0.28348744f, -0.00671392f, 
    0.12485887f, 0.11674938f, 0.20690328f, 0.08547680f, -0.00091714f, 0.07208088f, -0.03720883f, 0.06971705f, 
    -0.07413584f, -0.02288483f, 0.06359418f, 0.17882653f, 0.03480585f, -0.09229400f, -0.15700832f, -0.04910289f, 
    0.02352867f, -0.14896224f, 0.43211702f, 0.04992347f, 0.08833169f, 0.08962328f, 0.04889048f, 0.23383300f, 
    -0.09858458f, 0.04862833f, 0.08112164f, -0.04688043f, 0.01611204f, 0.05665372f, -0.01702395f, -0.05448762f, 
    0.03569875f, 0.00354448f, 0.23636134f, 0.05781557f, 0.12751079f, -0.09264280f, 0.14399824f, -0.05449285f, 
    0.16313371f, 0.05323032f, -0.06675909f, 0.20176041f, 0.08418486f, -0.11599757f, 0.03895044f, -0.05393044f, 
    -0.01230977f, 0.06257211f, 0.02193997f, 0.06205261f, 0.19659606f, 0.02228565f, 0.23665936f, 0.18973294f, 
    0.02611888f, -0.01674934f, -0.19839139f, -0.16833104f, 0.10298560f, 0.01764101f, 0.00380567f, -0.00353023f, 
    0.06287145f, 0.03968693f, 0.07412440f, -0.02750384f, -0.10345181f, -0.16901459f, -0.02430552f, 0.05414581f, 
    -0.04909420f, -0.13152082f, -0.11366620f, 0.09212049f, -0.20329449f, -0.10760359f, 0.04671748f, 0.01556519f, 
    -0.08821774f, 0.00599661f, 0.01684088f, -0.10114413f, -0.07798083f, 0.03804350f, 0.09724235f, 0.03552761f, 
    0.04640460f, 0.19021262f, -0.09661429f, 0.08379702f, 0.01098272f, -0.03001400f, -0.14513801f, -0.00170618f, 
    -0.35097191f, -0.15494712f, -0.21917057f, 0.34711829f, -0.06182570f, -0.04922567f, 0.07645357f, 0.13308527f, 
    -0.02640579f, 0.12941208f, -0.04308591f, -0.00263425f, 0.00231114f, 0.10058079f, 0.01693284f, -0.02487902f, 
    0.22537005f, 0.16116385f, 0.21283138f, 0.11657112f, -0.03932315f, -0.01664934f, -0.24240689f, -0.10084540f, 
    -0.01763698f, 0.04509361f, 0.14049530f, -0.03952830f, 0.03831117f, 0.06472319f, -0.02274063f, -0.01726297f, 
    0.00055154f, -0.06515135f, -0.00824869f, 0.08485338f, 0.09011529f, -0.07298183f, -0.07278690f, -0.03298656f, 
    -0.08903730f, 0.06046286f, 0.21742398f, 0.03008737f, 0.01152268f, 0.15750971f, -0.15472789f, 0.13991718f, 
    -0.16006550f, 0.10488153f, 0.12768827f, -0.03732186f, -0.07276982f, -0.06347988f, -0.00296829f, -0.02534528f, 
    -0.06453135f, 0.01089749f, -0.03697098f, -0.16067895f, 0.08431552f, 0.24835233f, 0.24538544f, -0.18690054f, 
    -0.16240494f, -0.02971631f, -0.15622310f, -0.14196950f, -0.00054607f, 0.08540918f, 0.04415905f, 0.09758789f, 
    -0.14299323f, -0.04015612f, -0.03388923f, 0.03665065f, -0.13940434f, -0.04523096f, -0.05850901f, -0.18223183f, 
    -0.41227379f, -0.23921314f, 0.48145291f, -0.01195150f, -0.37349653f, -0.03893338f, -0.08990707f, -0.07256665f, 
    0.09372785f, -0.09028579f, -0.02911595f, -0.08668576f, 0.06490353f, 0.16472964f, -0.01660967f, 0.11303674f, 
    -0.06029358f, 0.16055322f, 0.02628415f, -0.01348335f, 0.22089514f, 0.07790697f, -0.41541699f, 0.12781985f, 
    0.32808021f, 0.14763726f, 0.27913496f, 0.11744291f, 0.05229086f, 0.01387803f, 0.03937711f, -0.03413533f, 
    -0.01758891f, -0.07228019f, 0.06269713f, -0.09781729f, 0.06431713f, -0.05947147f, 0.03774946f, -0.00256664f, 
    -0.20400947f, -0.13064215f, -0.18291266f, -0.37442762f, 0.02247916f, -0.00557562f, 0.00542740f, 0.01050325f, 
    0.10157037f, 0.10282460f, -0.16320118f, 0.02194912f, 0.27870640f, 0.20757963f, 0.16180508f, -0.06592418f, 
    0.09911180f, 0.12853065f, -0.02727186f, 0.14092030f, 0.26232904f, 0.04611806f, 0.21446167f, -0.19950686f, 
    0.05643098f, 0.07907114f, -0.01673055f, 0.08637468f, -0.05497751f, -0.08292632f, -0.04928061f, 0.07609358f, 
    -0.01952438f, -0.07753379f, -0.00075764f, 0.02331617f, -0.06432045f, 0.03565220f, -0.19301902f, -0.11794437f, 
    0.32984412f, -0.06155954f, -0.09138210f, -0.20563789f, 0.22996646f, -0.11215929f, 0.02441256f, 0.27535796f, 
    0.18242301f, -0.05615958f, 0.00273006f, 0.00959250f, -0.13842562f, -0.02665343f, 0.03718125f, -0.05760541f, 
    -0.07812641f, 0.17662887f, -0.07426140f, 0.05960845f, -0.24614364f, -0.14862224f, -0.31074247f, 0.13855948f, 
    0.12648220f, -0.02233045f, 0.15446895f, -0.19106723f, 0.09624786f, -0.00884331f, -0.06065491f, -0.01053240f, 
    0.06232616f, 0.20140411f, 0.03742351f, -0.03047184f, 0.13576321f, 0.13876401f, 0.09908249f, 0.24783105f, 
    0.23368968f, -0.16337247f, -0.25381672f, 0.20411204f, 0.11940593f, -0.08318579f, -0.07741149f, -0.00119115f, 
    -0.17361274f, -0.11210606f, 0.04763030f, -0.02707285f, -0.04243713f, -0.03146563f, -0.02172962f, -0.08941276f, 
    -0.11936900f, -0.02284816f, -0.03284187f, -0.09782256f, -0.13457237f, -0.18905103f, -0.00580421f, -0.19438748f, 
    -0.16510065f, -0.04105351f, -0.14912637f, 0.00676657f, 0.00588275f, -0.09708472f, -0.00084550f, -0.02250939f, 
    0.13393924f, -0.04298069f, 0.24240026f, 0.00147764f, 0.29686484f, 0.06645929f, 0.09629312f, -0.05218605f, 
    -0.28524730f, 0.04893348f, -0.02602739f, 0.54183829f, 0.29885456f, -0.08951396f, -0.10008550f, -0.10884137f, 
    0.08973802f, 0.13725677f, 0.02680914f, 0.04829399f, 0.07451167f, 0.13489506f, 0.18855608f, 0.10206593f, 
    0.03394491f, -0.05783956f, -0.09184801f, 0.01147501f, -0.09713983f, 0.10596707f, 0.05858550f, 0.28289506f, 
    0.18577136f, 0.10569812f, 0.03087981f, -0.00366125f, 0.17496908f, 0.18511826f, 0.06929190f, 0.09989949f, 
    0.06114947f, -0.06977732f, 0.10777158f, 0.07564992f, -0.01564546f, 0.08440378f, -0.27520466f, -0.10186180f, 
    -0.31960103f, -0.42825270f, 0.05388611f, -0.11685550f, -0.17111059f, -0.01989724f, -0.02394497f, -0.06792425f, 
    -0.04814737f, -0.17837241f, -0.08401407f, -0.07320003f, 0.10113160f, 0.05846952f, 0.13096194f, 0.08185688f, 
    0.00350227f, 0.02667769f, -0.06317635f, -0.14172755f, -0.21108621f, -0.22987798f, -0.30661535f, 0.01447281f, 
    -0.21387351f, 0.00727159f, -0.04179079f, 0.07287937f, -0.12496801f, -0.12188764f, 0.00064509f, 0.09733652f, 
    0.07855816f, 0.06957104f, 0.16486576f, -0.00931789f, -0.11544220f, 0.06272363f, -0.00544231f, -0.07245670f, 
    -0.00003894f, -0.03324982f, 0.06829975f, 0.03273821f, 0.00024152f, 0.23274329f, -0.04756744f, 0.08599353f, 
    -0.14776441f, -0.11879398f, 0.06238417f, -0.01888038f, -0.01767694f, 0.03435674f, 0.04987400f, 0.02828648f, 
    -0.06275266f, 0.07414149f, -0.02920888f, -0.12143207f, -0.24497499f, -0.26121220f, -0.11519220f, -0.14749953f, 
    -0.14944403f, 0.01256847f, -0.07856925f, -0.06076107f, -0.06593907f, -0.15792176f, 0.11148021f, -0.02500583f, 
    0.04005824f, 0.01639828f, 0.10429989f, 0.09450631f, 0.14757508f, -0.06314131f, -0.08828204f, 0.00971317f, 
    -0.04569182f, 0.22012487f, 0.45196083f, 0.48088264f, 0.25556430f, -0.05036264f, 0.04885389f, 0.08272601f, 
    0.12182108f, 0.13379785f, -0.05510591f, -0.01264177f, 0.00599891f, 0.04460898f, -0.02813266f, -0.01816823f, 
    0.00877667f, 0.03932023f, 0.05817930f, 0.09288193f, 0.00241598f, 0.09599496f, 0.03900131f, 0.04081466f, 
    0.07944748f, 0.07232013f, 0.17143351f, 0.18434542f, 0.16926636f, 0.14085740f, 0.10723975f, 0.06877682f, 
    0.06146159f, 0.01822468f, -0.01475313f, 0.07750775f, 0.02831922f, 0.01338638f, 0.08893392f, 0.10484074f, 
    0.42039254f, 0.14828707f, 0.15164915f, 0.14630279f, 0.08207881f, -0.07506275f, 0.09415007f, -0.26871285f, 
    0.02234543f, -0.05691590f, -0.01564134f, -0.00749722f, -0.06694510f, 0.08033563f, -0.07180949f, -0.12953311f, 
    0.02314278f, -0.08662703f, -0.04134577f, -0.01174884f, 0.25476804f, 0.26807639f, 0.18594177f, 0.04957693f, 
    -0.14274919f, -0.00638714f, -0.19497825f, 0.03764601f, 0.06944592f, 0.15456210f, 0.03471698f, -0.06303551f, 
    0.00724162f, 0.06475352f, 0.07286311f, 0.01337476f, 0.01661583f, 0.01273816f, 0.01503597f, -0.07867184f, 
    0.06485807f, 0.03531610f, -0.14802398f, 0.04496366f, -0.21982846f, 0.01904324f, -0.03745450f, -0.02333269f, 
    -0.08465993f, -0.12986596f, 0.03479106f, -0.16193701f, -0.09252279f, -0.12661789f, 0.02017275f, 0.18311223f, 
    -0.14978626f, -0.22592972f, -0.03279696f, -0.06514233f, 0.19745253f, -0.07994271f, 0.04754429f, -0.01364133f, 
    -0.07375164f, 0.02894837f, -0.00687974f, 0.04582672f, 0.15400711f, 0.16004728f, 0.08847493f, -0.00813533f, 
    0.15951926f, 0.08417778f, 0.01474175f, 0.06232370f, 0.02130677f, -0.01287538f, 0.11885985f, 0.00730142f, 
    0.36598888f, 0.03708578f, -0.07467914f, -0.03328160f, -0.02532253f, -0.03825733f, 0.01391985f, -0.05887907f, 
    -0.07335711f, 0.17553180f, 0.03408061f, -0.02628158f, 0.14750075f, -0.05964593f, -0.01993178f, 0.19253777f, 
    0.15819734f, -0.09823722f, 0.15163246f, -0.06555258f, -0.08137854f, 0.31928292f, 0.32269180f, 0.35121769f, 
    0.26551861f, 0.05072368f, -0.09241022f, -0.08454124f, 0.02899412f, 0.04401180f, 0.00200901f, -0.01843220f, 
    -0.03988885f, 0.06637032f, 0.05480773f, 0.08758634f, -0.02491027f, 0.13115539f, -0.10255307f, -0.06374363f, 
    -0.01402892f, 0.09621799f, 0.21852669f, 0.20725887f, 0.26918861f, -0.04996584f, -0.12764779f, -0.11519149f, 
    -0.08711440f, 0.00237297f, -0.01133009f, 0.04337705f, 0.03655332f, -0.01863219f, 0.03270945f, -0.03670840f, 
    -0.05870846f, -0.03970336f, 0.06782331f, 0.01145820f, -0.14172411f, 0.03212827f, 0.00171867f, -0.07536733f, 
    -0.07916529f, -0.00725412f, -0.14663699f, -0.10271528f, 0.05561315f, -0.14481789f, 0.00129432f, 0.03300828f, 
    0.14781250f, -0.01770093f, 0.05407087f, 0.03923875f, 0.22980447f, 0.04360176f, 0.00695359f, -0.05562808f, 
    0.22674681f, 0.20971479f, 0.03758004f, 0.10074963f, 0.12608476f, 0.15086986f, 0.18208557f, 0.09681679f, 
    0.19521610f, 0.08395469f, 0.00707194f, -0.02726400f, 0.04383391f, 0.02165216f, -0.03068219f, 0.05201013f, 
    -0.00363774f, -0.04000023f, -0.21077545f, -0.02876796f, 0.09471288f, 0.21514459f, 0.35577708f, 0.00308766f, 
    -0.03724466f, 0.05835175f, 0.06225125f, -0.09220579f, 0.07008196f, 0.22328715f, 0.02167988f, 0.03422985f, 
    -0.00883986f, -0.10596640f, -0.12773268f, -0.05119826f, -0.07389405f, 0.04181531f, -0.19599940f, -0.05758785f, 
    -0.19640258f, -0.22512083f, 0.16715838f, 0.06035809f, -0.05926723f, 0.02093488f, -0.07635090f, -0.08590280f, 
    -0.05935222f, -0.14226042f, 0.01452585f, 0.08175234f, 0.07841153f, 0.14990161f, 0.07815749f, -0.06752787f, 
    -0.04123045f, 0.15502706f, -0.00820446f, -0.04865208f, 0.01389034f, -0.02634663f, -0.19808783f, -0.14116701f, 
    -0.02169658f, -0.08432329f, -0.03134059f, 0.03079149f, 0.01192057f, -0.14033389f, 0.05864098f, -0.00093412f, 
    -0.07849000f, -0.22247611f, 0.14833330f, -0.03880072f, -0.02878094f, 0.02029715f, 0.05323153f, 0.05879698f, 
    0.27654257f, 0.40956339f, 0.22993502f, -0.17491579f, -0.02601869f, 0.02626305f, -0.11807806f, -0.06828477f, 
    0.05305156f, -0.04375247f, 0.09946534f, 0.02836250f, 0.01588206f, -0.04794361f, -0.01699596f, 0.16016871f, 
    0.00594310f, -0.06429499f, 0.02965247f, 0.06450111f, -0.12428331f, -0.05123559f, -0.00629937f, 0.05001833f, 
    -0.09730022f, 0.01915926f, -0.11258483f, -0.01199266f, -0.03272747f, -0.11223154f, 0.01890803f, 0.13855295f, 
    0.04270607f, 0.16614027f, 0.12561265f, 0.04100770f, 0.04121551f, 0.07355798f, 0.03129187f, -0.02700871f, 
    0.54183888f, 0.40343690f, 0.11303720f, 0.04164823f, 0.00805888f, 0.20397386f, 0.09024893f, 0.10913185f, 
    0.21233380f, 0.15729381f, -0.02578636f, -0.00006529f, 0.02321018f, 0.00898086f, 0.04615352f, 0.05165805f, 
    -0.02946826f, 0.01143447f, 0.04576523f, 0.33393762f, 0.19953437f, 0.04123595f, -0.16238315f, -0.01644137f, 
    0.04620476f, 0.12172560f, 0.24938565f, 0.30292061f, 0.07007457f, 0.21088029f, 0.02914887f, -0.04113348f, 
    0.09775860f, -0.01653868f, -0.01889675f, -0.01825078f, 0.10631324f, -0.00808603f, 0.05919055f, 0.18818153f, 
    0.47067803f, -0.16613735f, -0.25906238f, -0.14629121f, 0.22295246f, 0.08951389f, 0.15075937f, -0.06090147f, 
    -0.09382396f, 0.15630229f, -0.05965801f, 0.05882409f, -0.15970023f, -0.08498690f, -0.08580821f, -0.02312789f, 
    0.09294861f, -0.02949628f, -0.01201609f, 0.03986150f, -0.04122972f, 0.31736881f, 0.63835919f, 0.14589764f, 
    -0.15542972f, 0.01275857f, -0.08116835f, -0.11216599f, -0.04905060f, 0.05443816f, -0.01391764f, 0.01346841f, 
    -0.01002050f, 0.08208101f, -0.08390320f, 0.04396090f, 0.02328996f, 0.07179676f, -0.10078873f, -0.06632563f, 
    0.33330730f, 0.04006029f, -0.12548974f, -0.13330336f, -0.20142899f, -0.01178627f, 0.04260924f, 0.04707958f, 
    -0.04632458f, -0.12323804f, 0.08471297f, 0.03660420f, -0.20781311f, -0.12300542f, 0.10820363f, -0.04118014f, 
    -0.08111067f, -0.07421267f, -0.02806151f, -0.09724474f, -0.08110049f, -0.07641555f, -0.01163321f, 0.04931001f, 
    -0.03128469f, -0.01056784f, 0.04983434f, 0.10342127f, 0.08574048f, 0.20058061f, -0.02280497f, -0.06570461f, 
    0.09137426f, 0.00194308f, -0.06120060f, 0.01930243f, 0.08112443f, -0.02559503f, 0.12425039f, 0.28007925f, 
    -0.01032741f, 0.04426051f, 0.19220269f, 0.09087554f, -0.06121045f, 0.09189514f, 0.00896727f, -0.28123370f, 
    -0.18587165f, 0.16383553f, -0.01315331f, 0.04928135f, 0.05300553f, 0.05807021f, -0.02579096f, 0.15880238f, 
    0.03029558f, 0.01302373f, 0.03963890f, -0.03696582f, 0.44787940f, 0.45150051f, 0.23563392f, 0.03124630f, 
    -0.00966046f, 0.14893055f, 0.00492172f, 0.32675564f, 0.10011266f, 0.22314230f, -0.03259258f, 0.01354969f, 
    -0.10481592f, -0.08293558f, 0.09809060f, 0.08519223f, -0.00169056f, 0.10641517f, -0.02935998f, -0.08606733f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04626009f, 0.00356557f, 0.16093805f, 0.06033483f, 0.17294666f, 0.07979383f, -0.06463496f, 0.03739682f, 
    0.16832455f, -0.00835668f, 0.13273691f, 0.09779502f, -0.00508728f, -0.10896348f, 0.16136098f, 0.04027199f, 
    0.12650131f, 0.13100073f, 0.04751421f, -0.14685600f, 0.08939154f, -0.00483035f, -0.03732251f, 0.09201470f, 
    -0.04519567f, 0.04743396f, 0.15732101f, -0.13256374f, 0.07613165f, 0.05827071f, 0.08680597f, -0.02822655f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.03283411f, 0.26656628f, -0.13538982f, -0.87377584f, -0.08846457f, -0.43456942f, 0.08286130f, -0.00920904f, 
    -0.49516702f, 0.02696839f, -0.47684333f, -0.39440554f, 0.34394646f, 0.42370439f, -0.11335589f, -0.28484541f, 
    -0.21571530f, -0.52934998f, -0.35430288f, 0.32445833f, 0.35545170f, 0.17532992f, 0.14786565f, 0.18746847f, 
    -0.10460518f, 0.13781527f, -0.03840506f, 0.20141572f, 0.15829150f, -0.07468352f, -0.29231864f, 0.20916031f, 
    -0.03951647f, 0.38649991f, 0.21380185f, -0.80566096f, 0.19598429f, -0.15525721f, -0.22078739f, 0.16273724f, 
    -0.42175123f, 0.20647827f, 0.19410543f, 0.08368798f, 0.23399673f, -0.32316706f, -0.22597295f, -0.23946436f, 
    0.15831010f, -0.18934537f, -0.09316946f, -0.20389780f, 0.28680515f, 0.24942277f, 0.13319534f, -0.16728906f, 
    -0.05371247f, -0.14827377f, 0.17806178f, -0.86892915f, 0.21152805f, -0.23431388f, 0.15801083f, 0.10609368f, 
    -0.05086922f, 0.01772662f, 0.28354123f, 0.64059973f, 0.20250021f, -0.59127545f, 0.07683573f, 0.08929711f, 
    0.24706179f, -0.65442050f, -0.17988887f, 0.11280279f, -0.29949802f, -0.54809761f, 0.53105205f, -0.20259793f, 
    -0.06136770f, -0.13933094f, -0.02905017f, -0.14765465f, 0.22302389f, 0.01839530f, -0.01325871f, 0.23404349f, 
    -0.15705694f, -0.34946740f, 0.33662096f, 0.02125023f, -0.00845555f, -0.15852629f, -0.10053567f, -0.04714146f, 
    0.06857561f, 0.18132985f, 0.27055502f, 0.10463866f, -0.94445509f, -0.02312061f, 0.28012553f, -0.14138436f, 
    -0.24874926f, -0.23381777f, -0.21489978f, 0.34593028f, -0.54618073f, 0.16353212f, -0.16765377f, -0.00923959f, 
    -0.62788528f, -0.10185848f, 0.28598261f, 0.30197427f, -0.27112630f, 0.00694441f, 0.21430297f, -0.06971361f, 
    0.03342951f, -0.75209337f, -0.35976017f, 0.17929411f, -0.15177277f, -0.12741460f, 0.13481136f, 0.26324213f, 
    0.01874305f, 0.09884167f, -0.29373872f, 0.33708870f, 0.06379680f, -0.23414116f, 0.19722962f, 0.08234011f, 
    0.20701094f, 0.11006667f, -0.20923786f, -0.71220785f, 0.09901622f, -0.12625535f, -0.31448436f, -0.39358917f, 
    -0.04645552f, 0.37959075f, 0.24399883f, 0.15705585f, 0.03997852f, 0.19024520f, -0.15205140f, -0.40178388f, 
    0.02471953f, -0.04205656f, 0.14487003f, 0.22084691f, 0.18928194f, 0.21122210f, 0.10425305f, -0.01009792f, 
    0.00687608f, -0.39452082f, -0.18855567f, 0.19649327f, 0.29544336f, 0.38305041f, 0.22116159f, -0.12106486f, 
    0.47772941f, 0.16079108f, 0.21858005f, -0.22591813f, 0.17335509f, 0.50509179f, -0.18805453f, -0.14722218f, 
    -0.25345767f, -0.41663268f, -0.20114639f, -0.04953477f, 0.16832195f, -0.12672202f, -0.14596729f, 0.10305848f, 
    0.10906664f, -0.03240689f, 0.34492913f, -0.56824958f, -0.11071800f, 0.07433172f, 0.04366174f, 0.09485677f, 
    -0.07964949f, -0.66983104f, 0.05483488f, -0.12512815f, 0.03301876f, -0.14495818f, -0.16983396f, -0.11726769f, 
    -0.01103068f, -0.59425372f, 0.31200030f, 0.18727455f, 0.02909159f, -0.72541267f, 0.32000932f, 0.17168254f, 
    0.11401027f, 0.38839996f, 0.23554893f, 0.07257818f, -0.23947637f, -0.62318349f, -0.36519808f, -0.12314725f, 
    -0.04928502f, -0.43359706f, 0.14511211f, -0.16788851f, 0.29574850f, 0.32103428f, -0.50523704f, -0.64994550f, 
    -0.06829072f, -0.09509074f, -0.01369931f, 0.60996443f, -0.01357005f, -0.34833449f, 0.08066313f, -0.08687820f, 
    -0.59940815f, -0.10769439f, 0.09972412f, 0.21083833f, 0.00312935f, 0.13556550f, -0.43352079f, 0.13646354f, 
    0.27331278f, -0.83847994f, 0.24216431f, -0.28532478f, -0.13917643f, -0.15584232f, 0.36720508f, -0.29881772f, 
    0.06277534f, 0.28464231f, -0.42724586f, 0.50586110f, -0.08997364f, -0.10820455f, -0.65594894f, -0.05000422f, 
    0.08701924f, -0.47197017f, 0.01705931f, -0.73604971f, -0.07666017f, 0.43772146f, 0.23727480f, -0.03343318f, 
    -0.53944165f, -0.75967562f, 0.17159988f, 0.38105509f, 0.08327071f, -0.72432858f, -0.15564877f, 0.06423836f, 
    0.27519861f, 0.11336146f, -0.34402204f, -0.19997619f, -0.00212763f, 0.08077369f, 0.20021126f, 0.14754318f, 
    -0.14925383f, 0.42575487f, -0.33944741f, -0.20073383f, -0.64628339f, -0.40345502f, -0.00361776f, 0.13171495f, 
    0.12278254f, 0.22359140f, -0.24588516f, 0.09129853f, 0.28030542f, 0.19323373f, -0.61158329f, -0.13408993f, 
    0.34693027f, -0.23665872f, -0.29581288f, -0.36453936f, -0.24099508f, -0.48028424f, -0.78905904f, 0.13565397f, 
    0.21568936f, -0.10053393f, 0.39194447f, -0.12343798f, 0.22824124f, -0.60541236f, -0.32383412f, 0.35545266f, 
    -0.14665303f, 0.19294503f, 0.48041421f, 0.46263644f, 0.16874219f, 0.32857573f, 0.07628837f, -0.24138276f, 
    0.04654532f, 0.24144691f, -0.45926324f, 0.01040790f, -0.13621137f, -0.27981091f, 0.09636993f, -0.16252640f, 
    -0.14697957f, 0.40786740f, 0.09763079f, 0.23287338f, 0.37150005f, -0.15125079f, 0.65121943f, -0.22660579f, 
    0.19675155f, 0.37207603f, 0.31684488f, -0.29183140f, -0.34072116f, -0.43365753f, 0.13935395f, 0.25806007f, 
    0.14743134f, -0.25348714f, -0.26856428f, -0.43134564f, -0.26240143f, -0.69139671f, 0.21973725f, 0.08799671f, 
    0.11251658f, 0.39054590f, -0.11993104f, 0.15699591f, -0.03885615f, 0.28859702f, -0.34304342f, 0.07816705f, 
    -0.41109553f, -0.24909924f, 0.26706597f, 0.06337656f, -0.60713601f, 0.18332048f, 0.33368060f, -0.00753919f, 
    -0.47570503f, 0.51162368f, -0.55533451f, 0.00572720f, -0.13303946f, 0.17352328f, -0.47824439f, 0.20636329f, 
    0.09389231f, 0.48925981f, -0.79998916f, -0.39866346f, 0.24338427f, 0.26014882f, -0.10560753f, -0.20618717f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.16704364f, -0.00745935f, 0.09267540f, 0.11015469f, -0.19060408f, 0.00002971f, -0.04403562f, -0.03294522f, 
    -0.05129195f, 0.18998660f, -0.15629688f, -0.02239890f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
