#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.70861381f, -0.80936718f, -0.23023778f, -0.80970722f, -0.55381960f, 0.37815958f, 0.11129367f, 0.15548712f, 
    -0.03607988f, 0.59848291f, -0.43716291f, -0.62341326f, -0.33504599f, -0.25250369f, -0.73976219f, 0.47272766f, 
    0.16765916f, -0.03284568f, 0.71172839f, 0.60948378f, 0.23957157f, -0.04075294f, -0.71189666f, 0.59984720f, 
    -0.26380423f, 0.18013979f, -0.06150941f, 0.63304275f, -0.18515013f, 0.34416458f, -0.56309628f, -0.92333448f, 
    -0.70684987f, -0.09794009f, 0.64384806f, 0.25327969f, -0.38588250f, 0.59100389f, -0.20880285f, 0.97146338f, 
    -0.11874314f, -0.49017429f, -0.01920904f, 0.00295379f, -0.26739883f, -0.33177343f, 0.29825106f, -0.12781332f, 
    -0.70887798f, 0.49962246f, -0.78799278f, -0.18224567f, 0.23674113f, -0.10760346f, -0.88402665f, -0.22992478f, 
    -0.54794598f, 0.20630948f, -0.15004084f, 0.68439478f, 0.17268258f, 0.19447556f, -0.35149744f, -0.49448898f, 
    -0.50864023f, -0.44745383f, 0.51517016f, -0.26207995f, 0.07049876f, -0.35051703f, -0.55308521f, -0.50762606f, 
    -0.05605071f, -0.48534185f, -0.69613153f, 0.53961307f, 0.23605835f, 0.22742444f, 0.78078765f, 0.20286348f, 
    0.21687424f, 0.61003679f, 0.69068730f, -0.40024406f, 0.60555977f, 0.06830332f, -0.00896690f, 0.30077270f, 
    0.39517984f, -0.09877001f, 0.38809159f, -0.42334473f, 0.13208929f, -0.88756841f, 0.50050765f, -0.16432416f, 
    0.28512716f, 0.25496304f, 0.74648660f, -0.43360588f, -0.50107980f, -0.73843080f, 0.44128910f, -0.30383807f, 
    0.17873606f, -0.35995007f, 0.27719164f, 0.63891447f, -0.81451339f, 0.52709180f, -0.40086883f, -0.34462726f, 
    -0.57071209f, -0.21601655f, 0.05034610f, 0.19565496f, -0.03868649f, 0.63792765f, -0.61122262f, 0.77845430f, 
    0.99489027f, 0.42652100f, 0.32237309f, -0.05829973f, -0.24991454f, 0.20332383f, -0.78824830f, -0.36088115f, 
    -0.53831011f, 0.34260663f, 0.96746773f, 0.12765342f, 0.11334072f, -0.24640584f, -0.09827704f, 1.02541292f, 
    0.77217174f, 0.68120205f, -0.58622009f, 0.33375892f, -0.36449715f, 0.20493563f, 0.05461191f, 0.01427103f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.10159367f, 0.35060984f, 0.15825103f, -0.02958207f, -0.18513250f, 0.19489993f, 0.05630718f, -0.45007658f, 
    -0.11396810f, 0.07940897f, -0.42630166f, -0.03088121f, 0.74422890f, 0.20409934f, -0.21428864f, 0.08938249f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.15324453f, 0.13322595f, -0.01568474f, -0.03299731f, -0.11399468f, 0.05203314f, -0.20094959f, -0.02720290f, 
    -0.01996648f, 0.12403917f, -0.14834055f, 0.00663527f, -0.01666203f, 0.00473131f, 0.23297487f, 0.02707390f, 
    -0.17044188f, -0.32778957f, -0.09483378f, -0.45868668f, -0.00155597f, 0.13025732f, -0.18107335f, -0.11781038f, 
    0.04446878f, -0.08218616f, 0.09276659f, 0.19051450f, -0.06424397f, 0.02549980f, -0.14124851f, -0.07396197f, 
    0.04538500f, -0.11570586f, -0.11720554f, -0.04792984f, 0.02555611f, -0.11271171f, -0.11911446f, 0.19894619f, 
    0.23623191f, 0.06760297f, -0.00404592f, 0.04668208f, -0.01755445f, -0.11711098f, -0.08256007f, 0.24125290f, 
    0.12908354f, -0.04224288f, 0.10281307f, -0.39289615f, -0.04952987f, -0.27729326f, 0.06606866f, 0.13909209f, 
    0.12059831f, -0.02391354f, 0.12035841f, -0.01508399f, 0.16659746f, 0.07358143f, 0.05266813f, 0.12646778f, 
    0.13985820f, -0.18036979f, 0.06659327f, -0.01383468f, 0.10233358f, -0.17131521f, 0.12265496f, -0.05863687f, 
    0.17912187f, 0.28645715f, 0.17604426f, -0.14497389f, -0.24628949f, 0.26344234f, 0.13438816f, 0.04515997f, 
    0.24309497f, -0.33250535f, -0.06129251f, -0.18806343f, -0.09125429f, -0.21094197f, -0.22107579f, 0.10430338f, 
    -0.02627620f, 0.01888901f, -0.25918236f, -0.11021193f, 0.03349627f, 0.00270005f, -0.13991256f, -0.12913680f, 
    0.00148634f, -0.02144596f, 0.03935860f, 0.15633649f, 0.27125710f, 0.14375964f, 0.00981760f, -0.03215345f, 
    0.13943052f, 0.12575279f, 0.20523413f, 0.14976373f, 0.32810158f, 0.05362494f, -0.03066530f, 0.04088038f, 
    0.06424284f, 0.06377742f, 0.03099210f, 0.15329175f, -0.11065548f, -0.12152782f, -0.17391774f, -0.00049147f, 
    0.07148567f, 0.09214172f, -0.14225988f, 0.05600225f, 0.03507844f, 0.23708059f, 0.45416930f, 0.24571031f, 
    -0.08333129f, 0.04292997f, 0.02544859f, 0.05784582f, 0.14807598f, -0.00116923f, -0.05254875f, -0.46168098f, 
    -0.19138706f, 0.23518734f, 0.08474658f, 0.06683581f, 0.08305330f, -0.12040734f, 0.02934244f, 0.12232614f, 
    -0.28562504f, -0.15254070f, 0.26808259f, 0.09165687f, -0.06887277f, -0.13103481f, 0.06880593f, 0.28317773f, 
    -0.08855609f, -0.13314506f, 0.24351591f, -0.03685423f, 0.04889967f, -0.06065793f, 0.01011239f, -0.04970090f, 
    -0.11379120f, -0.08603498f, -0.08284919f, 0.03637775f, 0.07595405f, 0.09687582f, 0.05410200f, 0.10941821f, 
    -0.04770647f, 0.05463765f, 0.09582292f, 0.02604781f, 0.04140853f, -0.13499194f, 0.09358785f, -0.04795156f, 
    0.06799857f, -0.10645997f, 0.10605705f, -0.05719880f, -0.22265968f, -0.14848559f, -0.04654302f, 0.09399109f, 
    -0.02055580f, 0.15928958f, 0.02817541f, -0.10869808f, -0.09882469f, -0.09544684f, 0.10061036f, -0.12431596f, 
    0.32053590f, 0.22542614f, 0.11179166f, 0.02940561f, -0.13733733f, 0.02479692f, -0.11053826f, 0.02370762f, 
    0.24795075f, 0.00538699f, 0.09494354f, -0.04913632f, -0.10553972f, -0.09526465f, -0.11036567f, -0.05741437f, 
    0.10183015f, -0.02874557f, -0.07507405f, -0.13845520f, -0.07406920f, 0.03197677f, 0.12355966f, -0.16039935f, 
    -0.35960203f, 0.19323173f, 0.28652075f, -0.00363180f, 0.08245698f, 0.06883486f, 0.07166711f, 0.14797787f, 
    0.10224717f, 0.06324060f, 0.29797101f, 0.18715094f, 0.22852968f, 0.15276761f, -0.23463877f, -0.22918499f, 
    0.06080811f, 0.14674060f, 0.06088373f, 0.19537240f, -0.09235214f, -0.21060547f, -0.06911957f, 0.03162576f, 
    0.13711636f, 0.04430746f, 0.18533422f, -0.30621848f, -0.04432764f, 0.35798630f, 0.18705638f, 0.08921505f, 
    0.02214011f, -0.09049945f, 0.05486730f, 0.10512467f, -0.43528181f, -0.41032225f, -0.04131715f, 0.02041254f, 
    0.16900934f, 0.15624763f, -0.02247081f, -0.09192742f, 0.02136899f, 0.28269380f, 0.05726574f, 0.14264734f, 
    -0.04540350f, -0.41570628f, -0.25812715f, 0.12998991f, 0.24588002f, 0.36314750f, -0.39234847f, -0.37023547f, 
    -0.01024319f, 0.20684496f, 0.01876820f, -0.11848274f, 0.04407654f, -0.12092903f, -0.11507866f, -0.14932886f, 
    -0.02757098f, 0.03381966f, 0.32048482f, 0.09323093f, 0.12783717f, -0.09628038f, 0.18126363f, 0.16861123f, 
    0.02660448f, 0.08364905f, -0.05409841f, -0.12673962f, -0.00031823f, -0.09994332f, 0.00275816f, -0.03418315f, 
    0.11251736f, 0.28577608f, 0.28951648f, -0.26403230f, 0.12275048f, 0.01077529f, -0.10601426f, -0.09862504f, 
    -0.08529726f, 0.10027726f, 0.06366895f, -0.13596208f, 0.22881183f, -0.04608202f, 0.19438465f, 0.24104069f, 
    0.08854022f, 0.02462398f, 0.04526861f, 0.19308664f, -0.06883352f, -0.30480507f, 0.06780611f, 0.12528396f, 
    -0.33465406f, 0.05031981f, -0.06225194f, -0.06701493f, 0.26537374f, 0.04440888f, 0.02287048f, -0.19789924f, 
    -0.20037688f, 0.09507020f, 0.09925480f, 0.30498496f, 0.11833120f, 0.22434033f, 0.05610108f, 0.03405001f, 
    -0.07479477f, -0.03249351f, -0.30026272f, -0.11898612f, 0.04260372f, 0.09717564f, -0.13213129f, 0.21138686f, 
    -0.16864112f, -0.45240626f, 0.15475471f, -0.04190858f, -0.03204235f, 0.11970846f, 0.16212161f, -0.39504784f, 
    -0.07550047f, -0.33181906f, -0.18013410f, -0.07331261f, 0.10704148f, -0.11908887f, -0.15650363f, 0.16248193f, 
    0.11972082f, 0.02492524f, 0.04070972f, 0.07203222f, -0.00862916f, 0.02248422f, -0.03772524f, -0.13679765f, 
    -0.22104149f, -0.11434315f, -0.04689076f, 0.01481440f, -0.10362339f, 0.07489064f, 0.13466346f, -0.18765220f, 
    -0.02945818f, -0.04447644f, 0.13105084f, -0.05181093f, 0.08097306f, -0.00323824f, 0.15053512f, 0.12688714f, 
    -0.17046684f, 0.10886890f, -0.23071796f, 0.11473542f, -0.01291187f, -0.04346517f, 0.20443062f, -0.03848958f, 
    0.10484135f, 0.06365759f, -0.01944681f, 0.00076453f, 0.05329426f, 0.20596696f, 0.06582943f, -0.01360488f, 
    0.01288193f, -0.04928461f, 0.16127743f, 0.07071535f, -0.11080173f, -0.25600418f, -0.11752398f, -0.20804583f, 
    -0.04016517f, -0.07687715f, 0.13474484f, -0.03246324f, 0.01609182f, -0.25480369f, 0.06239069f, -0.14706795f, 
    -0.00950638f, -0.18780714f, -0.09830232f, 0.04185786f, -0.03173847f, 0.26192859f, 0.25912121f, 0.21533637f, 
    0.19734104f, -0.02469613f, 0.02374622f, -0.10820632f, -0.17016104f, 0.03010594f, -0.05300265f, 0.03572655f, 
    -0.26463935f, -0.28566664f, 0.05115679f, -0.09389964f, -0.16814817f, -0.00080392f, 0.05093669f, 0.08057339f, 
    0.09515575f, -0.05929236f, -0.30859476f, 0.22119549f, 0.12894171f, 0.13110079f, 0.05361224f, -0.08776317f, 
    -0.11108898f, 0.04637835f, 0.04746703f, -0.07066577f, -0.07097247f, 0.06488425f, -0.04674302f, 0.14367242f, 
    -0.13373278f, 0.07686064f, 0.22287622f, -0.40980124f, -0.01933554f, 0.11043541f, 0.01346010f, 0.10943077f, 
    -0.03905338f, -0.01099320f, 0.10156819f, 0.09922214f, 0.09923479f, -0.91133845f, -0.00366068f, -0.05116373f, 
    -0.00584225f, -0.10060624f, -0.00188625f, 0.10946887f, -0.12659630f, 0.02145289f, -0.20671064f, -0.74972236f, 
    0.03488043f, 0.12644078f, 0.04670989f, -0.02870080f, -0.18811870f, -0.16612197f, 0.25708970f, 0.27624369f, 
    -0.27722740f, 0.05462234f, -0.15372823f, 0.10670469f, -0.00849922f, 0.05805903f, 0.12009046f, 0.01922082f, 
    0.30244839f, -0.00603208f, 0.14001699f, -0.10020864f, -0.09058466f, 0.05439721f, 0.24947873f, -0.05999136f, 
    -0.05510582f, -0.06103963f, 0.03847037f, 0.19618462f, -0.05842416f, -0.02626451f, -0.15734011f, 0.01920762f, 
    -0.04500281f, 0.18576787f, -0.23197027f, 0.28519434f, -0.21626328f, 0.08193963f, -0.05675081f, -0.13030554f, 
    -0.02524857f, 0.00997734f, 0.44357049f, -0.11270639f, -0.20793821f, -0.05048515f, 0.16478556f, -0.14246115f, 
    0.00376680f, -0.05302435f, 0.01321606f, -0.17385723f, 0.08002504f, -0.17049125f, 0.08037072f, 0.07297218f, 
    0.01300696f, 0.10687834f, 0.00581924f, -0.10527304f, -0.14766610f, -0.02320278f, -0.46088800f, -0.10867065f, 
    0.02897325f, -0.01071150f, 0.09335442f, 0.10407899f, 0.12503764f, -0.17623518f, 0.09030252f, 0.22483929f, 
    -0.06386530f, 0.28676054f, -0.18138281f, 0.07820924f, -0.01801684f, 0.03776968f, 0.66833216f, 0.28008017f, 
    -0.27505791f, -0.02035932f, -0.01656753f, -0.02783645f, 0.12397029f, -0.03326432f, -0.12524512f, 0.39153481f, 
    0.30317467f, -0.15682884f, -0.09213227f, -0.11526070f, 0.19379643f, -0.02238635f, -0.02072417f, 0.03832411f, 
    0.03549689f, -0.00947052f, -0.04951456f, -0.05259259f, 0.03348117f, -0.09291520f, -0.03823787f, -0.01469796f, 
    -0.03467295f, 0.02252125f, 0.04564298f, 0.00017474f, -0.04497138f, 0.03126329f, 0.06284952f, -0.08876978f, 
    0.03958326f, 0.04471845f, -0.07581663f, -0.03372957f, -0.02671644f, -0.07742999f, 0.05548597f, 0.02124862f, 
    -0.09365160f, 0.00460803f, -0.07220693f, -0.02515434f, 0.01453977f, -0.03483733f, 0.02633697f, -0.09687459f, 
    0.06795637f, -0.06184468f, 0.01148769f, -0.03051921f, -0.05032344f, -0.08042161f, 0.01015167f, 0.07579878f, 
    -0.04193753f, -0.03567937f, -0.04170656f, 0.03799475f, -0.06361245f, 0.05451620f, 0.02767924f, 0.03422265f, 
    0.00985445f, 0.05421763f, 0.05586421f, -0.06296277f, -0.02625157f, -0.09234224f, -0.01554509f, -0.04329135f, 
    -0.01196052f, -0.03253479f, 0.04825372f, -0.04980909f, -0.03130336f, -0.11630999f, 0.03265557f, 0.06628453f, 
    -0.07219965f, -0.01752431f, 0.01674005f, -0.08883469f, -0.07928718f, -0.00460661f, -0.10105313f, -0.01473045f, 
    0.04438457f, -0.06994379f, 0.00203048f, -0.05241624f, -0.09757350f, 0.01951631f, 0.01406282f, 0.03891034f, 
    -0.04936139f, -0.09344922f, -0.03083373f, 0.02544132f, -0.02844061f, -0.01407013f, 0.01408186f, -0.01203289f, 
    -0.03883060f, 0.00443773f, -0.10236773f, 0.01183524f, 0.07070257f, -0.05019729f, -0.04942372f, -0.06110695f, 
    -0.06131924f, -0.01405631f, 0.00060862f, -0.01079687f, 0.00404678f, -0.03278834f, 0.03687882f, 0.03167545f, 
    0.05001185f, -0.04221958f, -0.06509310f, 0.03759091f, -0.09658969f, -0.01067680f, -0.02980484f, -0.00637774f, 
    0.01995216f, -0.09832390f, -0.01625361f, -0.01825268f, -0.07161220f, -0.07606163f, 0.00580254f, -0.10531776f, 
    -0.01796127f, 0.02182356f, -0.00175148f, 0.00057220f, 0.05756219f, -0.02442461f, -0.00156347f, 0.02615919f, 
    -0.07459582f, 0.06336723f, 0.05827109f, 0.00650770f, -0.07563900f, 0.03120767f, -0.00263502f, -0.02282760f, 
    -0.06007107f, 0.07002888f, -0.02080386f, 0.02060757f, 0.05874294f, 0.04391409f, 0.05909848f, -0.06568116f, 
    -0.33946067f, -0.23221335f, -0.30637476f, 0.11141258f, 0.00105081f, 0.20361534f, 0.02233352f, -0.04267742f, 
    0.01505627f, 0.02644422f, -0.06416576f, -0.19142167f, 0.15911354f, 0.01912304f, -0.17537026f, 0.04798523f, 
    0.00115911f, 0.04345604f, -0.13109004f, 0.33125439f, 0.35064682f, 0.06798330f, 0.02840142f, 0.01243770f, 
    -0.05260619f, 0.09089372f, 0.18150124f, 0.21978500f, 0.28988808f, -0.15946096f, -0.28219235f, -0.06935322f, 
    0.16057029f, -0.05876805f, -0.04209483f, 0.06589440f, -0.45555386f, -0.17846191f, -0.02154001f, 0.05736351f, 
    0.23149584f, -0.13991258f, 0.15677017f, -0.07402112f, 0.01342988f, 0.06471240f, -0.27656141f, -0.27682927f, 
    0.09516849f, -0.09113913f, 0.08112710f, -0.07693122f, 0.04715388f, -0.04990184f, -0.35034183f, -0.07696731f, 
    -0.28938600f, 0.09929561f, 0.16870633f, -0.17382582f, -0.00707092f, -0.15231967f, -0.07275654f, 0.26533419f, 
    0.10756944f, -0.12609583f, -0.07930126f, -0.11255284f, 0.08766211f, 0.24207985f, 0.07607580f, 0.14466667f, 
    -0.05459386f, -0.00099274f, -0.04078848f, -0.06661244f, 0.09860623f, -0.22282986f, 0.08671142f, 0.24441676f, 
    -0.23555274f, -0.00033823f, 0.05650119f, 0.24897367f, -0.13938195f, -0.01794022f, 0.10609978f, -0.07535593f, 
    -0.07725705f, -0.02663784f, 0.07679119f, 0.03228061f, -0.05195458f, -0.05568139f, 0.08721355f, 0.01614520f, 
    0.07615075f, -0.31814995f, -0.05397341f, -0.33811915f, -0.00913313f, -0.10483300f, 0.13480714f, -0.01396795f, 
    -0.05627681f, -0.04991531f, 0.12701800f, 0.00009168f, 0.05700604f, -0.15821515f, 0.16970186f, -0.17132679f, 
    0.04456944f, -0.00449081f, -0.06301454f, 0.17430139f, 0.10549823f, 0.15712661f, -0.33615854f, -0.09774155f, 
    -0.03012329f, 0.09109956f, 0.07717774f, 0.11639611f, -0.09560592f, 0.05170166f, -0.38243514f, -0.55167335f, 
    -0.40126902f, 0.15820293f, 0.13998884f, 0.13906205f, -0.03295711f, -0.09729585f, -0.09551587f, 0.22684179f, 
    0.39577278f, 0.51258963f, -0.00824114f, -0.13964811f, -0.03052023f, -0.07686994f, 0.02197794f, 0.06430347f, 
    -0.05818118f, 0.01534935f, -0.08751399f, -0.04334441f, -0.05611463f, 0.03870221f, 0.02113463f, 0.01238806f, 
    -0.07881324f, 0.05370611f, 0.02131169f, -0.01926701f, -0.07499835f, 0.03927767f, 0.04449131f, 0.02803806f, 
    0.05534201f, -0.04666126f, -0.04608573f, -0.06808037f, 0.07861571f, -0.05743737f, -0.09030736f, -0.08957248f, 
    -0.03640450f, -0.01907367f, 0.00793592f, -0.00186172f, -0.05505890f, -0.03348039f, -0.08740832f, -0.07125945f, 
    -0.01747244f, -0.01030694f, 0.01012988f, 0.01601769f, 0.00131295f, -0.07168224f, -0.00175948f, 0.07140215f, 
    -0.05196844f, -0.04954869f, 0.03260471f, 0.01584942f, 0.02582772f, 0.05351774f, -0.02093177f, -0.06171234f, 
    0.01433032f, 0.00899153f, -0.00259204f, 0.04900916f, 0.01470084f, 0.05208132f, 0.01758632f, -0.06378615f, 
    0.00997734f, 0.05954083f, -0.04075988f, -0.01865567f, -0.02128688f, -0.05088752f, 0.06094557f, 0.02341587f, 
    -0.03073347f, -0.05724614f, -0.01543395f, 0.03972581f, -0.06301146f, -0.04228587f, -0.03534291f, -0.00267889f, 
    -0.07633652f, -0.05842753f, -0.04919633f, 0.03152903f, 0.03213218f, -0.08564412f, -0.08749881f, -0.00046030f, 
    -0.02063438f, 0.02223768f, 0.07406549f, -0.07231764f, 0.00346819f, -0.04756458f, -0.08163925f, -0.03211960f, 
    0.01761309f, -0.03098538f, 0.03878349f, 0.05018024f, 0.06708164f, 0.01761857f, -0.07139429f, -0.03756556f, 
    0.07950098f, -0.01986920f, 0.03019581f, 0.02156642f, 0.05423723f, -0.01105863f, -0.00679961f, 0.04334158f, 
    -0.07627642f, -0.08463513f, -0.05951450f, -0.08124282f, -0.05664822f, 0.00178183f, -0.03975507f, 0.01113660f, 
    -0.01085143f, 0.01167122f, -0.03980239f, 0.04008683f, 0.03265897f, -0.05814406f, 0.03777108f, 0.03981542f, 
    -0.00983199f, 0.02839143f, -0.07865936f, -0.07031570f, -0.02607970f, -0.08517563f, -0.07661227f, -0.06464022f, 
    0.04517235f, -0.02142168f, 0.07325729f, -0.02357814f, 0.06886441f, 0.04093472f, -0.01624060f, 0.03568234f, 
    0.01259753f, -0.08690997f, 0.02049593f, 0.02109386f, 0.03474860f, 0.02299717f, -0.02568023f, 0.04178927f, 
    -0.19499007f, 0.25601983f, -0.06088451f, 0.14648606f, -0.06294829f, -0.14036630f, 0.04838772f, 0.15636790f, 
    0.02766294f, 0.02687874f, -0.09192952f, -0.16396981f, -0.17310357f, -0.25244370f, -0.24798903f, -0.18218505f, 
    0.24774094f, -0.12147920f, 0.04256061f, 0.14788158f, -0.30444118f, -0.02766240f, -0.12219466f, 0.05172322f, 
    -0.08693816f, 0.33273056f, 0.11501011f, 0.04098595f, -0.55262357f, 0.18585487f, -0.33888277f, -0.08825397f, 
    0.02717937f, 0.07153708f, -0.17856734f, 0.16362283f, 0.23380926f, 0.09624912f, 0.27439949f, -0.02217479f, 
    -0.07943315f, -0.11083087f, -0.01142352f, 0.01734750f, -0.09673327f, -0.10723324f, 0.10327350f, -0.06936376f, 
    -0.13305357f, -0.18830940f, 0.02539288f, 0.17444251f, -0.01779404f, -0.18048267f, 0.17320307f, 0.03879631f, 
    0.12032774f, 0.10587799f, 0.09309915f, -0.18214659f, 0.17715324f, -0.03785330f, -0.01772188f, 0.49744505f, 
    0.27189076f, 0.05077575f, 0.16446297f, -0.00657199f, -0.02691510f, 0.17969351f, 0.04445793f, 0.27616894f, 
    -0.09691444f, -0.14744796f, -0.04769807f, 0.38359323f, -0.04491000f, -0.11479874f, -0.09557195f, 0.10274348f, 
    0.08052967f, 0.19503061f, 0.15088865f, 0.22390766f, 0.15803067f, 0.00705388f, -0.00449017f, 0.04302523f, 
    -0.04209460f, 0.06255192f, 0.07940072f, -0.05716501f, 0.19121492f, 0.08588412f, -0.00375164f, 0.35786462f, 
    0.01097411f, -0.07112946f, 0.01189647f, 0.15252681f, -0.13824545f, 0.07453515f, -0.02806323f, 0.28210771f, 
    -0.15284470f, 0.16083656f, -0.22145864f, 0.11026391f, -0.05143540f, -0.21560524f, 0.25087398f, -0.17995104f, 
    -0.17940135f, -0.10074437f, -0.05502087f, -0.07999568f, -0.15539928f, -0.46424595f, -0.20490226f, -0.36703253f, 
    0.21934041f, 0.06313691f, 0.12644792f, -0.14914656f, 0.01157649f, -0.11739538f, 0.01826972f, 0.51384115f, 
    0.17630462f, 0.12370234f, -0.08776283f, -0.08752371f, -0.09844635f, 0.07943556f, -0.00390955f, 0.03545475f, 
    -0.02266042f, 0.30597672f, -0.18614398f, 0.12655485f, 0.22708170f, 0.02863995f, -0.01229745f, 0.03801224f, 
    -0.03189645f, 0.03682411f, 0.36416134f, 0.14124863f, -0.23817539f, -0.06701197f, 0.09088340f, 0.11060002f, 
    0.17235520f, -0.29633820f, -0.16744518f, -0.06023939f, -0.26693380f, 0.09873475f, 0.01883350f, -0.15409449f, 
    -0.01505845f, -0.05853251f, -0.22821409f, 0.15837818f, -0.31015438f, 0.08061966f, 0.02960161f, -0.10157097f, 
    -0.00368700f, -0.04900942f, 0.07382805f, -0.55510736f, -0.14042497f, -0.29612523f, -0.07668184f, -0.11078691f, 
    0.07770953f, -0.24017115f, 0.07151756f, 0.15981098f, 0.04553879f, 0.01452037f, -0.09038068f, -0.04299101f, 
    0.10592480f, 0.12814073f, 0.12601568f, 0.02102686f, -0.01991429f, 0.08872849f, -0.01706420f, -0.04417831f, 
    0.05886299f, -0.01013739f, -0.11751531f, 0.01896149f, -0.10840642f, 0.01726283f, 0.40496323f, -0.00049638f, 
    0.22712563f, -0.00399370f, 0.09351214f, 0.04803281f, 0.01505231f, 0.01554694f, -0.06389295f, 0.30633262f, 
    -0.06870323f, 0.07092491f, 0.00485474f, -0.00395657f, 0.03634081f, 0.31762046f, -0.04467774f, -0.04742115f, 
    0.16793731f, 0.03601313f, -0.06467373f, 0.17390372f, 0.20034976f, -0.11624599f, 0.27730364f, 0.05657665f, 
    -0.11791865f, -0.47460482f, 0.22554237f, -0.01013100f, 0.00429964f, -0.21018821f, 0.00151757f, 0.16347317f, 
    -0.02663236f, 0.13536187f, -0.19609678f, -0.08121549f, -0.13208711f, -0.25786382f, 0.04720629f, 0.11736689f, 
    -0.17968199f, -0.08169722f, 0.04431965f, 0.32876691f, 0.23720996f, 0.08038461f, -0.09651439f, 0.09309757f, 
    0.10525063f, 0.05942112f, -0.02564740f, -0.22334027f, 0.35492530f, -0.19029269f, -0.06306792f, -0.09277791f, 
    0.18856195f, -0.04623678f, -0.03616872f, 0.09023789f, -0.02898979f, -0.14971149f, 0.12624499f, 0.19645651f, 
    0.17868806f, -0.01948059f, -0.15681775f, 0.03727510f, 0.06859884f, 0.01943441f, 0.42879730f, 0.24864243f, 
    0.10197326f, 0.07769367f, -0.13207863f, 0.14642103f, 0.06472262f, 0.21395059f, -0.03159027f, -0.40962279f, 
    -0.04215777f, -0.10711802f, 0.00888901f, -0.05951455f, -0.00639921f, 0.07655936f, 0.12663241f, -0.10542192f, 
    -0.00608490f, -0.32543793f, -0.16800691f, 0.01084530f, 0.19903025f, -0.11493830f, 0.14032198f, -0.06858660f, 
    0.03976249f, 0.01917034f, 0.04171760f, 0.37720454f, -0.02275766f, 0.23785123f, -0.01476542f, 0.13546757f, 
    -0.03701636f, 0.15709201f, 0.02807689f, -0.06851342f, -0.08944133f, -0.31380537f, -0.04300914f, 0.02247000f, 
    0.03465451f, 0.16626428f, -0.02359784f, 0.08093978f, 0.21634726f, -0.03287730f, -0.01517866f, 0.06667995f, 
    -0.25320074f, -0.13214460f, -0.00387459f, -0.01132128f, 0.16023080f, 0.06555294f, 0.15438862f, -0.23303537f, 
    -0.01214604f, 0.03701954f, -0.14602186f, 0.20596251f, -0.14449155f, -0.00979558f, 0.16581753f, 0.11161331f, 
    -0.05873048f, -0.19917080f, -0.29986146f, 0.00942526f, -0.06508471f, 0.27110541f, 0.17281580f, 0.09106991f, 
    0.08283822f, -0.03005308f, 0.01532277f, 0.22895592f, -0.29311037f, -0.00209220f, 0.15262604f, -0.12480659f, 
    -0.09226368f, -0.00052546f, 0.25363290f, -0.24145824f, 0.22755584f, -0.10242273f, -0.03963941f, 0.00408628f, 
    -0.16773768f, 0.06246185f, 0.03552892f, 0.17365748f, 0.12619141f, -0.11947809f, -0.04046987f, -0.04034024f, 
    -0.00217877f, -0.39134270f, 0.32534400f, 0.05253837f, -0.14475369f, -0.12638395f, -0.08932181f, 0.21632102f, 
    -0.01894220f, -0.08470990f, -0.27071875f, -0.33401415f, -0.10458194f, -0.00775992f, -0.08140016f, -0.20206261f, 
    -0.02240280f, -0.21458007f, -0.17369826f, 0.16817726f, -0.29695830f, 0.15794027f, -0.00024964f, 0.04565936f, 
    0.07709701f, 0.03450007f, 0.01125803f, 0.05959208f, 0.05036486f, -0.15976071f, -0.12808131f, -0.13162118f, 
    0.28933626f, 0.02250188f, 0.06272802f, 0.12138899f, 0.07392535f, 0.33963424f, 0.15634397f, -0.23316301f, 
    0.04905194f, 0.07044388f, 0.20163520f, 0.07030284f, 0.05943188f, -0.12767892f, 0.28959867f, 0.14837095f, 
    0.25576320f, -0.01963137f, -0.16456844f, 0.03831761f, -0.06237767f, 0.11153895f, -0.00266528f, -0.25701395f, 
    0.12607819f, -0.14992519f, -0.16290502f, 0.03610722f, 0.04120483f, -0.03670704f, 0.07573448f, 0.13092847f, 
    -0.24510263f, 0.16469319f, 0.22956355f, -0.22947930f, -0.12368591f, -0.27783272f, 0.06167093f, -0.00362172f, 
    -0.09710678f, -0.05973219f, 0.07850791f, -0.17901909f, -0.13483588f, -0.02125518f, -0.01832273f, 0.02546411f, 
    0.03778785f, 0.11850872f, -0.20830521f, -0.63820297f, -0.11351211f, 0.17065044f, 0.02864332f, 0.07800784f, 
    0.11801349f, 0.04432685f, -0.08018652f, 0.09234628f, -0.22665030f, 0.16692467f, 0.06612195f, 0.02761077f, 
    -0.17219423f, 0.15043686f, -0.06919464f, 0.02030618f, 0.65970027f, -0.22383299f, 0.09208341f, -0.12887593f, 
    -0.05721673f, -0.10951491f, -0.15278126f, 0.07977238f, 0.08444044f, 0.19975519f, 0.09468772f, 0.11977093f, 
    0.18395008f, 0.10785686f, -0.04335435f, 0.13575272f, -0.08327615f, -0.04212444f, 0.11956568f, 0.09088539f, 
    -0.05319970f, 0.14859845f, -0.05175176f, -0.00799636f, -0.12438633f, 0.19065973f, 0.04045503f, 0.27009213f, 
    0.03909492f, -0.09002247f, 0.06918636f, 0.11153880f, 0.01763842f, -0.12262282f, 0.06395545f, -0.02162838f, 
    0.20844749f, 0.01532791f, -0.09015393f, -0.01352853f, 0.05301486f, 0.09452802f, -0.07122611f, -0.00687520f, 
    0.18861842f, 0.04012760f, -0.08555853f, -0.03764030f, -0.23116249f, 0.03837253f, -0.05189861f, -0.04043395f, 
    0.06891333f, -0.15612251f, -0.31708753f, 0.15482256f, 0.00840680f, -0.11901427f, -0.10268427f, -0.16072868f, 
    0.17386566f, -0.05199118f, 0.07289169f, 0.16784017f, 0.11643058f, 0.02935074f, 0.12895519f, 0.03856976f, 
    -0.01484555f, 0.03849698f, 0.19005902f, -0.12643544f, 0.17330486f, -0.17142665f, -0.04154599f, -0.01668153f, 
    -0.02233191f, 0.03539902f, 0.00151321f, -0.00710797f, 0.05198764f, -0.44574249f, -0.30662441f, -0.23878102f, 
    0.00749295f, 0.00461757f, -0.06089687f, 0.07078216f, 0.20475829f, 0.00143640f, 0.33603761f, 0.34295487f, 
    0.02591162f, -0.02079203f, -0.05714002f, -0.11335268f, 0.03907333f, 0.28783134f, -0.00345452f, -0.24032970f, 
    -0.24902520f, 0.00076816f, 0.00892582f, 0.26444986f, -0.06741437f, 0.01265456f, -0.15768747f, -0.00718320f, 
    -0.12714240f, 0.45058516f, -0.07792765f, 0.18222937f, 0.03018050f, -0.11535759f, -0.07225123f, -0.07558167f, 
    0.15058775f, 0.56708688f, 0.00330039f, -0.16704346f, 0.07985181f, -0.02414145f, -0.03751090f, -0.12965399f, 
    -0.01868380f, -0.03616399f, 0.03201490f, 0.12670711f, 0.06180923f, 0.14849603f, -0.06289979f, -0.02914320f, 
    0.01847070f, -0.02703253f, -0.02899971f, 0.09016161f, -0.11420063f, -0.12665407f, 0.06179677f, 0.07687024f, 
    0.05123882f, 0.16547439f, 0.01197439f, 0.10003597f, -0.68845135f, -0.09540262f, -0.27398059f, -0.00838661f, 
    -0.17572173f, -0.13755833f, -0.30666745f, -0.26105678f, 0.17714040f, -0.22493342f, -0.27698407f, -0.37393636f, 
    -0.05502300f, 0.03595809f, 0.17753877f, -0.00221580f, 0.04226042f, 0.14728141f, -0.18214554f, 0.32504845f, 
    0.11042229f, 0.06532328f, 0.13629112f, 0.00542654f, -0.05152348f, -0.09734470f, -0.07137310f, 0.04896194f, 
    0.33021954f, -0.14008296f, -0.14534456f, 0.05598865f, -0.16030639f, 0.03612940f, -0.00844118f, -0.07100119f, 
    0.16002670f, 0.23103102f, 0.27273765f, -0.17509030f, -0.11518183f, 0.05172768f, 0.28750187f, 0.02166364f, 
    -0.13862653f, 0.33345908f, -0.15963446f, 0.01221923f, 0.02245490f, -0.06571323f, 0.04797402f, -0.04902981f, 
    0.03508216f, 0.25365430f, -0.05048262f, -0.03348476f, -0.52615160f, 0.04217876f, -0.06560113f, 0.01167564f, 
    -0.01927990f, 0.11388005f, 0.00806786f, -0.00639421f, 0.14275384f, -0.14702719f, 0.04939934f, 0.02093229f, 
    0.00291519f, -0.07513402f, 0.03123768f, 0.07763392f, -0.22997506f, -0.09957128f, -0.33550245f, 0.16143489f, 
    0.02012210f, 0.17673884f, 0.16488181f, 0.09904024f, -0.00800263f, 0.27157924f, 0.01356307f, 0.00263319f, 
    0.00330046f, 0.03407125f, -0.03344824f, 0.07301475f, 0.05009486f, -0.11478557f, -0.15849631f, -0.11609782f, 
    -0.09817047f, -0.05816206f, 0.07797092f, -0.20866193f, -0.08180390f, 0.05670442f, 0.00429042f, 0.25511909f, 
    -0.15985438f, 0.00331021f, 0.21891090f, -0.03080809f, 0.12592988f, 0.07071050f, -0.06562804f, -0.02156113f, 
    0.07608128f, 0.05251939f, -0.01348213f, 0.21051669f, 0.16206306f, -0.07096219f, 0.01351990f, 0.00221035f, 
    -0.01148479f, 0.24881841f, 0.10569046f, -0.12401706f, -0.26568159f, -0.06460012f, -0.25543353f, -0.00959344f, 
    -0.00830541f, -0.06624633f, 0.25789517f, 0.34526023f, -0.31953195f, 0.03701925f, 0.15816340f, 0.02888662f, 
    -0.04774127f, -0.11714087f, -0.08699837f, 0.09768584f, 0.10765008f, -0.48534653f, -0.06895652f, 0.02888448f, 
    -0.03278448f, 0.04175870f, 0.00223352f, -0.21411870f, 0.06857523f, 0.09942861f, -0.18674581f, -0.25540504f, 
    -0.17800671f, 0.14298122f, -0.10152384f, -0.06493325f, 0.01502636f, -0.20574127f, 0.15486471f, -0.09687629f, 
    -0.03228960f, -0.11084725f, -0.04824762f, -0.02045270f, 0.07177321f, 0.17920658f, -0.15056744f, -0.12735526f, 
    0.21711384f, 0.05943575f, 0.02753901f, 0.13199230f, 0.05381057f, 0.02682412f, 0.05526429f, -0.29067656f, 
    -0.41541305f, 0.27475709f, 0.26764521f, 0.01965822f, 0.11680200f, -0.18039574f, 0.13309473f, 0.15522423f, 
    0.13090141f, -0.08971331f, 0.27145332f, 0.10105640f, 0.15992600f, 0.01243532f, -0.26096773f, -0.18943572f, 
    -0.03235282f, 0.02763693f, 0.16971000f, 0.19931319f, 0.05041926f, 0.03876290f, -0.11031873f, 0.11246052f, 
    -0.02476201f, -0.16883317f, 0.28133801f, -0.13252793f, 0.03948832f, -0.15480216f, 0.11494880f, 0.13579048f, 
    0.08884952f, -0.04265702f, -0.05700740f, -0.01925521f, 0.10239076f, 0.32648858f, 0.12610686f, 0.03276636f, 
    0.05551013f, -0.05826513f, -0.11639608f, 0.00992471f, -0.19543181f, 0.02734776f, 0.09070379f, -0.05814661f, 
    0.11956101f, -0.05913692f, 0.17633700f, 0.14324057f, 0.18261407f, 0.21572138f, -0.25107488f, -0.18969525f, 
    0.13562706f, -0.01584729f, 0.28933632f, -0.01546363f, 0.14801519f, -0.29114664f, -0.45697427f, -0.26514003f, 
    0.50681555f, 0.20905529f, -0.00604477f, 0.08201712f, -0.30587894f, 0.17098829f, 0.27740207f, 0.15501733f, 
    0.04077673f, -0.38278008f, 0.03621840f, -0.10960037f, -0.11272077f, 0.11021353f, -0.00064223f, 0.05503244f, 
    -0.02761710f, 0.15612251f, -0.17930171f, -0.01472296f, 0.09207055f, 0.10190587f, -0.05934247f, 0.19784728f, 
    -0.01601319f, 0.07715639f, -0.10961828f, 0.12142742f, 0.11112817f, 0.17569789f, 0.05463684f, 0.12767784f, 
    -0.16217145f, 0.05161896f, 0.27141136f, 0.40009114f, -0.11712991f, 0.09758680f, 0.01259305f, 0.16469830f, 
    -0.10544823f, 0.09945372f, -0.07960139f, 0.43508232f, -0.28278545f, 0.01995943f, -0.00059657f, -0.02931286f, 
    0.20929633f, 0.11296353f, -0.09933060f, 0.11846416f, -0.15655912f, -0.51075828f, 0.01111753f, 0.04009846f, 
    0.02492540f, 0.07121250f, -0.14085768f, -0.24193722f, -0.01646871f, 0.05553043f, -0.14462280f, -0.35275316f, 
    0.10070536f, 0.32605532f, 0.18425974f, -0.16102207f, 0.02367164f, -0.03227300f, 0.14425734f, 0.22874932f, 
    -0.49872029f, -0.05175952f, -0.11499981f, 0.13200065f, 0.19845150f, 0.10829003f, -0.18146224f, -0.26307416f, 
    -0.26186165f, 0.00587274f, -0.14609380f, 0.05391533f, -0.01432710f, -0.03379176f, -0.19297571f, 0.12047114f, 
    0.16481015f, 0.30269378f, -0.31556180f, -0.10103569f, 0.06619850f, 0.06319433f, 0.02512106f, 0.12474760f, 
    -0.33648938f, -0.01196971f, 0.01431231f, -0.19557516f, -0.23510553f, 0.10592247f, -0.11329686f, 0.22390261f, 
    0.00216670f, 0.09313393f, -0.27747065f, -0.10255624f, -0.11933607f, 0.13797265f, 0.06850176f, -0.19886775f, 
    0.12420852f, -0.02102687f, 0.11248062f, -0.08822200f, -0.13732620f, -0.14204085f, 0.01171075f, 0.27339774f, 
    0.03555115f, 0.27461094f, -0.07396735f, 0.09864557f, 0.24395552f, 0.25700298f, 0.19397883f, -0.06527878f, 
    0.21790278f, 0.08637504f, 0.13366726f, -0.26089385f, -0.06783930f, -0.26250425f, -0.23887134f, 0.39428836f, 
    0.04672414f, 0.27830610f, 0.11354596f, 0.07791633f, 0.12865749f, 0.11887883f, 0.17866912f, -0.17075166f, 
    -0.09818535f, 0.03836887f, 0.07447481f, 0.08171779f, -0.03708428f, -0.34545472f, -0.21621405f, 0.61318982f, 
    0.28680131f, -0.10036697f, -0.05045409f, 0.23334965f, 0.15470044f, 0.07235541f, -0.00471545f, 0.09654138f, 
    0.44201717f, -0.47822630f, -0.43625516f, -0.07420625f, 0.18088771f, 0.23358434f, 0.00751942f, -0.03572171f, 
    -0.00312415f, -0.03922698f, -0.06450760f, 0.18100388f, -0.10840593f, 0.17333151f, 0.00073555f, 0.05898005f, 
    0.09422441f, -0.03069110f, -0.27640215f, -0.02888612f, -0.17135999f, 0.02218534f, 0.08479452f, 0.20452142f, 
    -0.06295817f, -0.04873111f, -0.01858635f, -0.01614792f, 0.31737357f, 0.32141191f, 0.02693620f, 0.06110611f, 
    -0.19767189f, 0.07278967f, 0.07674614f, -0.06064151f, 0.16819227f, -0.26724347f, 0.15429267f, -0.12944342f, 
    -0.15064688f, 0.04460863f, -0.00143431f, 0.00972348f, -0.10349420f, 0.32481256f, -0.06791842f, -0.21338373f, 
    -0.02866576f, -0.04800395f, 0.26978010f, -0.21325688f, -0.08522288f, -0.08872727f, 0.12919195f, -0.21867535f, 
    0.05486834f, -0.25079703f, 0.00301384f, -0.13078471f, 0.10831566f, 0.00430806f, -0.04093217f, -0.13347664f, 
    -0.38161600f, 0.20172440f, 0.00967957f, 0.14500360f, 0.09028655f, 0.12924410f, 0.03280944f, 0.02013328f, 
    0.15900168f, 0.02468527f, 0.48593813f, -0.12407785f, -0.03942794f, -0.01364347f, -0.05733368f, 0.09111250f, 
    -0.07008547f, 0.32447612f, -0.20017168f, -0.08481947f, -0.05117827f, -0.14155036f, 0.01757686f, 0.01173239f, 
    0.00900105f, 0.07184172f, 0.52967894f, 0.36401483f, -0.00988446f, -0.13614686f, 0.01244595f, 0.17286320f, 
    -0.03461540f, -0.06915089f, 0.03698783f, -0.15044972f, -0.01460257f, 0.38230726f, -0.21690233f, -0.20931238f, 
    -0.16197903f, -0.01251925f, -0.02293276f, 0.07716462f, -0.22642441f, -0.39711899f, -0.30575880f, 0.10959215f, 
    -0.08425037f, -0.00763782f, -0.14913571f, -0.04018562f, -0.12979658f, -0.24164672f, 0.02486621f, 0.15074632f, 
    0.11053029f, -0.14377315f, 0.05248925f, -0.04336245f, -0.15343580f, 0.24163948f, 0.48388335f, 0.11133851f, 
    0.03622317f, -0.23815385f, -0.15228415f, 0.04101482f, 0.05202048f, -0.09718087f, -0.01354519f, -0.19201413f, 
    0.22116843f, -0.04621477f, 0.12876289f, 0.19130449f, 0.18341850f, 0.13923343f, -0.10071695f, 0.00018882f, 
    -0.21534117f, -0.16476396f, -0.18421580f, 0.06876466f, 0.01860980f, 0.03302151f, 0.17456783f, -0.11275624f, 
    -0.03268372f, 0.03381639f, -0.03158989f, -0.00002240f, -0.00834603f, 0.14210735f, -0.10551199f, 0.05349508f, 
    0.13887346f, -0.05014413f, -0.20566364f, -0.05268716f, 0.24763036f, -0.11971564f, 0.11061405f, -0.00710449f, 
    0.13634625f, 0.13824761f, -0.08171546f, -0.13364068f, -0.20265345f, 0.42136264f, -0.07559203f, -0.10332915f, 
    -0.12573476f, -0.03765072f, -0.00816002f, -0.00691845f, 0.40029508f, -0.05477452f, -0.16383901f, -0.00911868f, 
    -0.12158352f, -0.00573400f, 0.15829411f, 0.14902133f, 0.06204994f, -0.16069713f, 0.15410180f, -0.06231798f, 
    0.07374120f, -0.03022703f, -0.02840430f, 0.06331088f, 0.05411924f, 0.11064165f, 0.14419428f, -0.31311044f, 
    -0.25002819f, 0.26688349f, 0.01831623f, 0.02543561f, -0.13655274f, -0.00977498f, 0.05207355f, -0.23851341f, 
    -0.06793073f, -0.18119371f, 0.20515156f, 0.14023581f, -0.11541394f, 0.22176746f, -0.16133723f, 0.18100832f, 
    0.34129080f, 0.28320375f, 0.10298747f, 0.15701474f, -0.14884156f, 0.02329260f, -0.02312687f, 0.00613753f, 
    -0.17545524f, -0.36684540f, -0.34756824f, -0.15329884f, -0.15510716f, -0.12934314f, -0.06205596f, -0.06416579f, 
    -0.26758841f, -0.13275303f, -0.19938181f, -0.12056722f, -0.17345883f, 0.03946224f, -0.03769405f, 0.27369818f, 
    -0.09695729f, -0.06232604f, -0.08032471f, 0.00487029f, 0.03081729f, -0.07372475f, -0.01062038f, 0.12212922f, 
    0.16276638f, -0.01620620f, -0.20294203f, 0.03987604f, 0.02337117f, 0.04316817f, 0.06581437f, -0.02803892f, 
    0.01092156f, -0.19388823f, 0.02851009f, -0.12464590f, 0.10225664f, -0.18574393f, -0.04504117f, -0.19237302f, 
    0.07553884f, 0.07361399f, 0.06522172f, 0.01179781f, 0.20763281f, 0.02688813f, -0.11563388f, -0.32243845f, 
    0.00972218f, -0.01596964f, 0.06132042f, -0.04068656f, -0.07120878f, -0.11175340f, 0.15706713f, -0.03895802f, 
    0.45831487f, 0.58381605f, -0.02587242f, -0.08906260f, 0.05326912f, 0.13475603f, 0.19550024f, -0.16516432f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.09001847f, 0.10810864f, 0.06693808f, -0.00592324f, -0.08272426f, 0.11148170f, 0.05242899f, -0.20356312f, 
    0.05335583f, 0.15670875f, -0.07352267f, 0.02300819f, 0.08255331f, 0.26236376f, -0.11730043f, 0.27290997f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05925408f, -0.14843908f, 0.03465267f, 0.03406718f, 0.04444605f, 0.23427998f, -0.11561607f, 0.04814335f, 
    -0.26987100f, -0.04029172f, -0.17301384f, 0.21422419f, -0.12022255f, -0.21969481f, -0.22295384f, 0.16235699f, 
    0.07341287f, -0.12497304f, -0.07459179f, 0.03471605f, 0.21045743f, -0.29890180f, 0.17075911f, 0.27302891f, 
    0.48790154f, 0.48200297f, 0.06977845f, 0.14090000f, 0.21519335f, -0.03885539f, -0.67694640f, 0.13489924f, 
    -0.17452225f, -0.05515983f, 0.13243566f, 0.26447892f, -0.23293097f, 0.20013179f, 0.21941267f, 0.04205010f, 
    -0.57544935f, 0.00710399f, 0.12139379f, 0.42599839f, 0.19131123f, 0.19809669f, -0.47436199f, 0.36922657f, 
    0.21692005f, -0.22622916f, 0.04861041f, -0.12255399f, -0.07884724f, 0.06320906f, -0.17890167f, 0.01961798f, 
    0.34887674f, -0.11404467f, -0.29122120f, 0.17073897f, 0.05565477f, -0.15511233f, 0.17624764f, -0.05435741f, 
    0.32097015f, -0.10469263f, 0.09444014f, -0.15305398f, 0.13532630f, -0.56133246f, -0.07888708f, -0.08169369f, 
    0.26479238f, -0.39290705f, 0.05784567f, 0.54679066f, 0.07990711f, 0.08390642f, 0.54506499f, -0.29066041f, 
    -0.04876989f, -0.19794229f, 0.01269051f, -0.10025790f, 0.24160421f, 0.14058751f, -0.24295250f, -0.06620470f, 
    0.01322809f, -0.11674044f, -0.12241128f, -0.12655506f, 0.07283667f, -0.23614091f, -0.24462196f, -0.13678586f, 
    -0.31696776f, 0.00105537f, 0.23353638f, -0.60486364f, 0.07763408f, 0.27772498f, -0.18446346f, 0.51954401f, 
    -0.67361736f, -0.19104251f, 0.05110243f, 0.38156539f, 0.20091623f, 0.27867422f, -0.49306071f, 0.56752270f, 
    -0.02631357f, 0.17727154f, -0.14802134f, -0.16715860f, 0.22781193f, -0.10448977f, 0.04126695f, -0.11391723f, 
    -0.14280987f, 0.05884966f, -0.03913432f, -0.20532224f, -0.18709922f, -0.19973269f, 0.17190212f, -0.02276963f, 
    -0.24553379f, -0.37019017f, 0.50666654f, 0.16896185f, -0.03489278f, 0.06398094f, -0.01952490f, 0.54731965f, 
    -0.28693581f, 0.30796596f, 0.35062897f, -0.50020784f, -0.09194753f, 0.21497978f, 0.34601191f, 0.39940494f, 
    0.42147112f, 0.10605097f, -0.02285882f, 0.52107704f, -0.17250763f, 0.17696746f, -0.21410902f, 0.19891176f, 
    0.51271451f, 0.27268696f, 0.39355293f, -0.35878649f, -0.11677480f, -0.26721039f, -0.26155597f, -0.47628328f, 
    0.01107529f, -0.18773554f, 0.31032652f, 0.06546538f, -0.02596407f, -0.53282917f, -0.02670451f, 0.26545066f, 
    0.29795223f, -0.23236790f, 0.35736972f, 0.20234586f, 0.33500656f, -0.08164760f, 0.70158839f, 0.03244182f, 
    -0.03836441f, 0.00801668f, -0.24726349f, -0.22321439f, 0.02522504f, 0.19516635f, 0.07165927f, 0.08924726f, 
    -0.04841730f, -0.21377546f, -0.16767007f, -0.05760401f, 0.03668484f, -0.02097467f, -0.16352457f, -0.24826404f, 
    -0.05752695f, 0.48238713f, -0.27037975f, -0.30531368f, 0.11114687f, 0.33153185f, -0.19167189f, -0.42872307f, 
    -0.29838407f, 0.26161841f, -0.33127758f, 0.66955096f, 0.38546062f, -0.13594569f, -0.03230570f, 0.06346565f, 
    -0.33038044f, -0.25142762f, -0.27733016f, 0.02517386f, 0.05484315f, -0.04216170f, 0.02841334f, -0.06866286f, 
    -0.26400107f, 0.23560543f, -0.09022459f, 0.29438761f, 0.21813186f, 0.13456757f, -0.35947374f, 0.01606729f, 
    -0.21452020f, 0.14089823f, -0.10780475f, 0.10133892f, 0.20740007f, 0.64304763f, 0.22985241f, -0.15637639f, 
    -0.21458645f, 0.33126447f, -0.26942170f, 0.30734220f, 0.09306969f, 0.37580445f, -0.37354392f, -0.13551421f, 
    -0.10528150f, -0.29405636f, 0.30882147f, -0.41692773f, 0.09667137f, -0.52970755f, -0.20325966f, -0.04750910f, 
    -0.25317204f, 0.22608635f, 0.30441415f, -0.10665505f, 0.37415183f, 0.29618186f, 0.09557456f, 0.48366058f, 
    0.23810592f, 0.02455283f, 0.22706529f, 0.63518524f, 0.16421448f, -0.57951945f, 0.22815742f, -0.64288020f, 
    0.24463312f, 0.23700635f, 0.42946628f, 0.00981302f, 0.08492010f, -0.11510285f, 0.73392898f, 0.16545156f, 
    -0.44388959f, -0.11873564f, 0.48659673f, 0.21879868f, -0.11324493f, -0.43818220f, 0.05806659f, 0.21116033f, 
    -0.06027995f, 0.38734072f, 0.24986984f, 0.05877141f, 0.41033956f, -0.07331906f, 0.66136539f, -0.13191368f, 
    0.39150706f, -0.31910223f, -0.15528369f, -0.15781856f, 0.04488779f, -0.53246975f, -0.11902342f, 0.43745247f, 
    0.18064682f, 0.66882151f, 0.26880363f, -0.12295868f, 0.01164676f, 0.20229630f, -0.45755327f, -0.57554317f, 
    0.49543330f, -0.07482531f, -0.20433444f, -0.20616511f, -0.11600155f, -0.31343237f, -0.22471498f, 0.56985956f, 
    0.37358940f, 0.31777948f, 0.41128477f, -0.31905961f, 0.00855194f, 0.04226695f, -0.37808186f, 0.44166210f, 
    0.52963102f, -0.17093746f, 0.06905572f, -0.23818798f, -0.19054869f, -0.07715045f, 0.12458957f, 0.46692252f, 
    0.35418862f, 0.34283015f, 0.55795610f, -0.25617680f, -0.12722257f, -0.42128080f, 0.10945261f, 0.08754133f, 
    0.23501453f, 0.20264468f, -0.47537544f, 0.38212410f, -0.11997629f, -0.02369752f, 0.14650463f, -0.34999990f, 
    0.48013744f, 0.46760580f, 0.09283727f, 0.21885903f, -0.17531636f, -0.14325947f, -0.42768571f, 0.42237428f, 
    0.13136049f, 0.43590388f, -0.40492150f, -0.31490687f, -0.02646135f, 0.36734116f, 0.06112259f, -0.35672021f, 
    -0.09944601f, -0.25160223f, -0.01436253f, 0.19312631f, -0.12797382f, 0.40238953f, -0.18851116f, -0.20295896f, 
    0.00490795f, 0.06194492f, -0.55421823f, 0.26387727f, 0.15503369f, 0.28831178f, 0.05040336f, -0.05536664f, 
    -0.02016209f, -0.11566237f, -0.02170354f, -0.22685258f, -0.43034327f, -0.15728386f, 0.67117512f, 0.43243408f, 
    0.18599361f, 0.27727008f, -0.39825070f, 0.28930110f, -0.09213525f, 0.48254976f, 0.22821169f, 0.06900490f, 
    0.65777493f, 0.10751567f, -0.23869760f, -0.13639268f, -0.16000299f, 0.08228569f, -0.48523819f, 0.26841226f, 
    0.21636149f, 0.03089179f, -0.37618423f, 0.14327776f, -0.07735720f, -0.10357969f, 0.11842833f, -0.23731710f, 
    0.17104883f, -0.53548849f, -0.15137665f, 0.61057764f, -0.06069231f, 0.35271707f, 0.11482874f, -0.30059662f, 
    -0.15615481f, -0.02297926f, -0.23508179f, -0.06771940f, -0.10597569f, 0.16951793f, 0.06839484f, -0.09463948f, 
    -0.04940200f, 0.09444642f, -0.17744613f, -0.24638316f, 0.00214738f, -0.22369707f, 0.12479758f, -0.12836182f, 
    -0.47855282f, -0.00030323f, -0.18158452f, 0.76663852f, -0.26274315f, -0.09528955f, -0.02162593f, -0.54635531f, 
    -0.06239244f, 0.56886709f, -0.52177972f, -0.49766460f, 0.21416706f, 0.20850492f, 0.06228315f, 0.41550657f, 
    0.23323607f, 0.12291943f, 0.02158989f, 0.35098898f, 0.09701066f, -0.34548977f, -0.11321238f, 0.11533726f, 
    0.15681022f, 0.16857269f, 0.13848954f, -0.54710221f, -0.30485541f, 0.18639249f, 0.26050058f, 0.22090115f, 
    0.00423380f, -0.25421706f, 0.47127768f, -0.35855967f, -0.17245093f, -0.13774039f, 0.13866399f, -0.46275610f, 
    -0.30340973f, 0.12578592f, 0.16484794f, -0.07626667f, 0.23361029f, 0.24891423f, 0.57540464f, -0.51655734f, 
    0.33925933f, 0.33266446f, 0.18793960f, 0.17294601f, -0.01248338f, 0.04689107f, 0.11116842f, 0.05685683f, 
    0.32562581f, -0.24859823f, 0.24671954f, 0.68047231f, 0.00786947f, -0.11688786f, -0.37702212f, -0.83326495f, 
    -0.15164584f, -0.18309045f, 0.17983215f, 0.56156063f, -0.04463120f, 0.12621257f, -0.23214446f, 0.16030473f, 
    -0.08287182f, -0.18213786f, -0.20123880f, 0.36935544f, -0.19784553f, 0.46113035f, -0.48088142f, 0.33389488f, 
    0.31331226f, 0.16631687f, -0.24922365f, -0.28096026f, 0.19387004f, 0.46355629f, -0.13068028f, 0.43962252f, 
    -0.23921396f, -0.24610183f, -0.23355910f, 0.54822642f, 0.15477015f, 0.23835540f, -0.31119928f, -0.28009877f, 
    0.28524736f, -0.57859784f, 0.47851217f, -0.41835630f, -0.21061331f, -0.68907994f, 0.03334826f, 0.14373285f, 
    -0.00988617f, -0.13270949f, 0.07416809f, 0.60423976f, -0.09055049f, 0.13291375f, 0.41710490f, 0.13912551f, 
    0.43714389f, 0.35997066f, 0.41091752f, -0.08221452f, 0.09816416f, 0.20176357f, 0.21460983f, -0.18743531f, 
    -0.23141879f, -0.37177989f, 0.23511243f, 0.42201060f, 0.42308351f, -0.12880543f, 0.44003049f, -0.58023721f, 
    0.31760329f, -0.00730110f, 0.15915476f, -0.83060098f, 0.17722686f, -0.63782513f, -0.20111975f, -0.40521556f, 
    0.04577120f, 0.12976637f, -0.04888724f, 0.00288496f, -0.17848811f, 0.37453464f, -0.07375110f, 0.21173307f, 
    -0.23028044f, 0.07002702f, 0.36746708f, -0.45541999f, 0.14783482f, 0.16015238f, -0.21270707f, 0.68090725f, 
    -0.06695698f, 0.09728856f, 0.13008802f, -0.23609625f, 0.49203178f, -0.05748364f, 0.30015111f, 0.18118462f, 
    -0.01051460f, 0.01009555f, -0.21727982f, -0.20184006f, -0.07787856f, 0.14835030f, -0.01046595f, 0.09414699f, 
    -0.07032094f, 0.03264965f, -0.08380505f, -0.22871402f, 0.05078468f, -0.13391736f, -0.01422608f, 0.01637006f, 
    -0.43901882f, -0.11011675f, 0.36940348f, -0.16736756f, 0.04213623f, 0.02411190f, -0.05975625f, -0.08518255f, 
    0.23917072f, 0.62768805f, 0.19902258f, -0.75383186f, -0.02393644f, 0.14752476f, 0.39013955f, 0.43543667f, 
    -0.17660545f, 0.02146669f, 0.45522940f, 0.02112706f, 0.22061823f, -0.32990107f, -0.12347633f, -0.23359065f, 
    -0.18270472f, 0.25745663f, -0.14402811f, 0.40150848f, -0.13745518f, 0.36041504f, -0.00640340f, 0.41937816f, 
    -0.11607388f, 0.21216762f, 0.09415402f, 0.01754502f, -0.25710574f, -0.18990742f, -0.12972516f, -0.01730555f, 
    -0.34196320f, 0.06854994f, -0.98044395f, 0.35428387f, 0.37834373f, 0.17831822f, -0.14522180f, -0.02805943f, 
    0.39738348f, 0.30919653f, -0.11406557f, -0.41851139f, 0.22880241f, 0.40531456f, -0.20934428f, 0.18237711f, 
    0.11080591f, -0.38937986f, -0.18968347f, 0.26141506f, -0.14007001f, 0.06171371f, 0.17191753f, 0.13763519f, 
    -0.11157978f, -0.13025278f, -0.01156309f, 0.04257819f, 0.07460967f, 0.19723657f, 0.01207936f, -0.22639161f, 
    -0.05973577f, -0.14282316f, -0.22783491f, -0.03510541f, -0.12220150f, -0.11284316f, -0.21012399f, -0.04912359f, 
    -0.36747727f, 0.06264755f, 0.15087941f, -0.05891301f, 0.10077993f, 0.16509584f, -0.15522692f, -0.26369122f, 
    -0.27911639f, 0.26142064f, -0.27256727f, 0.21020991f, 0.28621006f, -0.18103661f, -0.33225492f, 0.22167523f, 
    -0.33954039f, 0.02953818f, 0.52751660f, -0.25034919f, 0.17460713f, -0.21865694f, -0.08196849f, -0.02502324f, 
    0.10761759f, 0.36089173f, -0.09609059f, -0.06436468f, 0.54800957f, -0.12051009f, 0.46043229f, -0.04792531f, 
    0.31108665f, -0.13936479f, 0.47027135f, -0.37549475f, 0.15605341f, 0.00102951f, -0.04382724f, -0.19926649f, 
    0.05906501f, 0.01905778f, -0.08999078f, -0.62577009f, -0.02446255f, 0.40422115f, -0.00217682f, 0.52267551f, 
    -0.26614770f, 0.32245421f, -0.21789782f, 0.10190069f, 0.02846145f, 0.53529048f, 0.23735237f, -0.51294672f, 
    0.18169975f, 0.05352042f, -0.30274704f, -0.13559158f, 0.29999810f, 0.21377105f, -0.36454284f, 0.45666796f, 
    0.64105314f, 0.52011162f, -0.17610565f, -0.06449394f, -0.14767171f, 0.22092006f, 0.22876878f, -0.33940390f, 
    0.12353849f, 0.24795347f, 0.17985246f, -0.38346910f, -0.04292038f, -0.14574587f, 0.02012393f, 0.11408532f, 
    -0.03543554f, 0.06404866f, -0.10500651f, -0.04040187f, 0.03486562f, 0.06335848f, 0.21852463f, 0.19469303f, 
    -0.10656019f, -0.22775468f, -0.22152290f, 0.17440562f, 0.04676942f, -0.25464511f, -0.10827844f, -0.10306523f, 
    -0.17381740f, 0.04942796f, 0.31068814f, -0.85146147f, 0.23479459f, 0.43705139f, 0.24317020f, -0.20874360f, 
    -0.40994629f, 0.17778549f, 0.04498814f, 0.25217050f, 0.57636052f, 0.05416063f, -0.34887961f, 0.09636544f, 
    -0.06933042f, -0.15823634f, 0.30038416f, 0.30777004f, 0.07285625f, 0.25377339f, 0.04053478f, 0.36509103f, 
    0.08573655f, 0.54959720f, -0.21485987f, -0.63462901f, 0.08340182f, 0.06660544f, 0.03094717f, 0.06508747f, 
    0.16884837f, 0.39354905f, -0.10977172f, 0.26144245f, 0.15241358f, -0.31012598f, 0.15816022f, -0.56954354f, 
    0.10041623f, -0.00550093f, -0.44236770f, 0.45972916f, -0.01870894f, 0.08907326f, 0.43927521f, -0.25009605f, 
    -0.15347105f, -0.01433356f, -0.18386361f, 0.15938646f, 0.18284550f, 0.28751278f, -0.03822762f, 0.15086205f, 
    -0.06963827f, -0.05007739f, -0.37681320f, -0.28070682f, 0.39705724f, -0.36904353f, 0.27781218f, 0.52256119f, 
    0.15526165f, 0.10821441f, -0.31989232f, 0.24593504f, 0.14558485f, -0.21317840f, 0.00336975f, 0.22484234f, 
    0.22303721f, -0.43463561f, -0.40304285f, 0.64662760f, -0.46439001f, 0.40849385f, -0.06768724f, -0.01742439f, 
    0.21167083f, 0.21010801f, 0.07716270f, 0.25346136f, 0.02611944f, 0.65933210f, 0.06270262f, -0.16871230f, 
    0.00327099f, 0.13262025f, -0.26755425f, 0.16853078f, -0.45098442f, 0.30925402f, -0.06586065f, 0.10755868f, 
    -0.31645221f, -0.08165386f, -0.16993673f, 0.08244175f, -0.24307269f, 0.04713728f, -0.11184689f, 0.54759669f, 
    0.70106488f, 0.02754237f, -0.12779576f, -0.03875664f, 0.29124343f, -0.21357863f, -0.23938298f, 0.53848588f, 
    -0.56722337f, 0.43450332f, -0.18589531f, -0.26295751f, -0.17168938f, -0.18459833f, 0.11896317f, -0.34064522f, 
    -0.63754225f, 0.03606830f, -0.84193355f, 0.57114369f, 0.11851375f, 0.09558034f, 0.38813975f, 0.23616010f, 
    0.39879042f, 0.00519336f, 0.26739481f, 0.02822451f, 0.08268547f, 0.02432938f, 0.09804784f, -0.65524065f, 
    -0.30608812f, -0.09617298f, -0.10480244f, 0.17116944f, -0.21480905f, 0.41811034f, 0.66760802f, -0.03823268f, 
    0.27886516f, 0.21640961f, -0.32204625f, -0.13422973f, -0.09639469f, -0.31495860f, 0.08886261f, 0.56483549f, 
    0.17860186f, -0.04564507f, 0.15897420f, -0.03438761f, -0.06133685f, 0.13768743f, 0.12657927f, -0.31961736f, 
    0.15213625f, 0.32604697f, 0.12401138f, -0.05668227f, 0.12840797f, 0.35189822f, -0.13716355f, -0.11811231f, 
    0.19299255f, -0.36511016f, -0.17571709f, -0.24618253f, -0.31950459f, 0.17360727f, 0.09632237f, 0.11865823f, 
    0.28861290f, -0.02076154f, -0.00510207f, -0.39880052f, 0.06573585f, -0.27893633f, -0.11280173f, 0.03593983f, 
    0.41357571f, 0.01226857f, -0.19006111f, 0.18638417f, 0.10585120f, -0.19491737f, 0.24115145f, 0.20818114f, 
    0.16455068f, 0.27101448f, 0.12853822f, -0.46242249f, 0.21121608f, -0.20888406f, 0.02993058f, 0.18044284f, 
    -0.30900931f, 0.14146872f, 0.35737973f, 0.36644456f, 0.36271167f, -0.12722509f, 0.24126939f, -0.47472501f, 
    -0.42286101f, -0.32627863f, 0.20841342f, 0.51648736f, 0.18176012f, 0.76782387f, -0.18060745f, 0.31179351f, 
    0.18051752f, 0.07217568f, -0.40733409f, 0.17205641f, 0.19206321f, 0.28327864f, 0.10761116f, -0.08568813f, 
    -0.06318616f, -0.27048698f, 0.42524576f, -0.37919366f, -0.19542366f, 0.36242396f, 0.19908263f, 0.21586566f, 
    -0.00335412f, 0.24734913f, 0.32062647f, -0.35573488f, 0.49938878f, -0.06575139f, -0.19877374f, 0.41435099f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12227003f, 0.36349735f, -0.02735621f, 0.02096963f, 0.11908907f, 0.02900928f, 0.00207807f, -0.09632298f, 
    0.00361658f, -0.30026582f, 0.22211732f, -0.06855416f, 0.20465773f, 0.27616182f, 0.31731543f, 0.09415031f, 
    -0.10044184f, -0.21935350f, 0.39086697f, 0.37772074f, -0.18625130f, 0.05245178f, 0.27567557f, -0.12901667f, 
    -0.04435083f, -0.11956901f, -0.21312818f, 0.35799485f, -0.16726731f, 0.25133994f, -0.13844493f, -0.02324086f, 
    -0.01584865f, -0.20117855f, -0.15254007f, 0.63627201f, -0.00767712f, -0.14256108f, 0.33685273f, -0.12766890f, 
    0.33554271f, 0.21805409f, 0.05223215f, 0.12403103f, 0.19007482f, 0.31369042f, 0.09280850f, 0.03572118f, 
    -0.23099715f, 0.09643322f, 0.38202900f, -0.01263617f, -0.03339444f, 0.22181220f, -0.08341856f, -0.10886008f, 
    0.68656349f, 0.28111976f, 0.24261729f, 0.08649731f, -0.12160674f, -0.14223742f, -0.06242350f, -0.15965036f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.18265440f, 0.33629796f, 0.00877176f, -0.42311236f, -0.15556602f, -0.10433051f, -0.38330275f, -0.10029422f, 
    0.12650566f, 0.19275181f, -0.15896454f, 0.03540871f, -1.08463395f, -0.10178081f, 0.06402380f, -0.04849807f, 
    0.22644699f, 0.08849790f, 0.25852194f, 0.11369468f, -0.57317865f, 0.30912459f, -0.19626307f, 0.02404460f, 
    0.15324305f, -0.03100956f, 0.08372124f, 0.57130134f, 0.23814277f, -0.25924826f, 0.01548267f, 0.23895210f, 
    -0.37417132f, -0.44961339f, -0.80325842f, 0.06780153f, -0.28243172f, 0.01505225f, 0.20585552f, 0.19582723f, 
    0.07479081f, -0.47556713f, 0.05539103f, -0.02540803f, 0.01366323f, 0.11641735f, -0.18654630f, -0.18007679f, 
    -0.10372816f, -0.45105276f, 0.23934944f, 0.05368571f, 0.50093728f, 0.15901612f, -0.03354326f, 0.15501851f, 
    -0.84371012f, -0.11873062f, 0.06524123f, -0.15725140f, -0.14597458f, -0.50792152f, -0.06623143f, -0.10095072f, 
    -0.36463714f, -0.06820049f, 0.10748678f, 0.17534144f, 0.18175431f, 0.06045932f, -0.24637350f, -0.05886886f, 
    -0.15142301f, 0.07318981f, -0.23453537f, -0.02925351f, -0.11858699f, 0.25419694f, 0.09460614f, -0.43293634f, 
    0.12842031f, -0.44351023f, -0.39422655f, -0.03366132f, 0.14311697f, 0.40486073f, 0.17905043f, -0.03352505f, 
    0.25344202f, 0.19772409f, -0.10873041f, 0.41761178f, 0.05256795f, -2.17452455f, 0.14523572f, 0.22429597f, 
    -0.04054121f, 0.82022178f, -0.18126342f, -0.40410459f, -0.62874329f, -0.05075620f, -0.26963362f, 0.05394324f, 
    0.17946699f, -0.06258132f, -0.01726402f, -0.04626029f, -0.48966604f, -0.13399053f, 0.35643664f, 0.14741406f, 
    0.00008658f, -0.73654258f, -0.03115462f, 0.08465880f, -0.15555923f, 0.10654581f, 0.22156082f, -0.24112403f, 
    -0.28052482f, 0.16804256f, -0.31663120f, 0.04190547f, 0.63512421f, -0.19732952f, 0.11807884f, -0.38113928f, 
    0.11394753f, -0.70383376f, -0.12533267f, 0.05985933f, 0.24240176f, 0.12263782f, -0.75618106f, -0.09198356f, 
    0.10640167f, -0.13923097f, 0.25891489f, 0.03251356f, -0.22235504f, 0.03517481f, -0.03207418f, -0.22466435f, 
    0.52466857f, 0.54694891f, -0.96494097f, -0.85166162f, -0.74850112f, -0.33210510f, -0.32912534f, -0.52275831f, 
    -0.47046641f, -0.10287514f, 0.02337988f, 0.34204045f, 0.08686988f, 0.47073063f, -0.11457045f, -0.17543787f, 
    -0.71264851f, -0.07223798f, 0.26611868f, -1.04408121f, -0.04723815f, -0.02439077f, 0.25936621f, 0.12103980f, 
    -0.44294211f, -0.35190043f, 0.04802099f, 0.08700000f, 0.37964281f, -0.24961373f, -0.03702851f, -0.28145799f, 
    0.05630684f, -0.19298953f, 0.12563606f, 0.31213444f, 0.03031706f, -0.17480208f, -0.01069469f, -0.26295111f, 
    0.06116257f, 0.34458154f, -0.41935050f, -0.08152630f, -0.61507952f, -0.13522317f, 0.31745154f, -0.23041873f, 
    0.04640298f, -0.14357117f, 0.21154797f, -0.19270667f, -0.17816834f, -0.04233091f, 0.21397582f, -0.00717169f, 
    0.35463175f, -0.18311150f, 0.07021279f, 0.08221154f, -0.43886694f, 0.13095786f, -0.34959087f, 0.41200688f, 
    0.17684175f, 0.16839388f, 0.22535685f, 0.19753470f, 0.36657122f, -0.21770221f, -0.25986472f, 0.73164010f, 
    -0.81462163f, -0.44327322f, -0.10559878f, -0.64068174f, 0.18999054f, 0.33121175f, -0.32338235f, -0.29337677f, 
    -0.26144677f, 0.09757539f, 0.07456410f, 0.26723140f, 0.12520793f, -0.14784232f, 0.19191314f, 0.04065120f, 
    -1.24468696f, -0.09194177f, -0.06470793f, -0.12354835f, -0.03189578f, 0.18852675f, -1.24192357f, 0.09361628f, 
    0.03872558f, 0.34605122f, -0.04386780f, -0.46778283f, 0.76129895f, -0.37355196f, -0.19548060f, -0.92149270f, 
    -1.71889079f, 0.26432654f, 0.03345877f, -0.11995684f, -0.31225288f, 0.35601351f, -0.84822673f, -0.01042880f, 
    -0.06087892f, 0.19867314f, -0.12093707f, 0.18021478f, -0.38468862f, 0.11064842f, 0.09151465f, -0.08645266f, 
    0.03094368f, -0.46244565f, 0.00220800f, -0.12030637f, 0.18819699f, -0.33602473f, -0.22593050f, 0.24859656f, 
    0.00395389f, 0.09449917f, -0.07478287f, 0.17875738f, 0.06638448f, 0.15997158f, -0.25986347f, -0.23470192f, 
    -0.02185200f, -0.26647645f, -0.08063874f, 0.16971326f, 0.06765046f, -0.56633377f, -0.89283192f, -0.19980378f, 
    -0.35545212f, -0.32652760f, -0.41870141f, 0.19001275f, 0.31233206f, -0.06387519f, 0.37206724f, 0.03129932f, 
    0.16415606f, 0.01320854f, 0.08444710f, -0.17776726f, 0.27563062f, 0.18844126f, 0.15959927f, -0.03925237f, 
    0.04837349f, 0.08899562f, 0.04684357f, 0.14169191f, -0.00308585f, -0.23860165f, -0.19263172f, 0.43551496f, 
    0.06088036f, -0.08105530f, -0.11149020f, -0.16676641f, 0.20192182f, -0.03091058f, -0.16466050f, 0.14813133f, 
    -0.40625453f, 0.01782355f, -0.13965644f, 0.07873511f, -0.12701271f, 0.01422992f, 0.00460934f, 0.00706272f, 
    -0.03866225f, 0.21609315f, -0.38738132f, -0.01356262f, -0.04090463f, -0.42519361f, 0.10170976f, -0.88657111f, 
    -0.56137586f, -0.42578706f, 0.11038962f, 0.10454716f, 0.53072226f, 0.15725321f, 0.15152067f, -0.56145287f, 
    0.27568662f, 0.17423929f, 0.01967953f, -0.13817513f, 0.12384883f, 0.11735114f, -0.11427994f, -0.01273882f, 
    0.24127576f, -0.47027212f, -0.41122419f, -0.38083056f, -0.14942448f, 0.01282739f, 0.03098842f, -0.15910058f, 
    0.30703643f, 0.24308957f, 0.00604597f, -0.39044687f, -0.52286410f, -0.07416710f, 0.05096642f, 0.16630948f, 
    0.05308115f, -0.18521465f, 0.17826630f, -0.01687879f, -0.39254764f, 0.29262730f, 0.14757414f, -0.03590015f, 
    0.74667823f, -0.06697360f, 0.17585030f, 0.26410261f, -0.09073196f, -0.33551291f, 0.13770401f, -0.24759012f, 
    0.03473924f, -0.21751493f, 0.16944976f, -0.30889341f, -0.26602656f, -0.07456751f, 0.44615290f, -0.01517004f, 
    0.22602735f, -0.03539990f, -0.28836545f, -0.01817012f, -0.31260064f, -0.28831661f, 0.12635891f, 0.04728165f, 
    -0.44401500f, -0.19257522f, -0.48828399f, -0.15101880f, -1.06932962f, -0.28103179f, 0.03628378f, -0.27223220f, 
    0.08841892f, -0.10947121f, 0.09904744f, 0.03704300f, -0.01830032f, -0.13956144f, -0.53437853f, 0.22398470f, 
    0.10191898f, -0.18818241f, -0.06641775f, -0.32661498f, 0.17201085f, -0.00518841f, 0.20297500f, 0.03262303f, 
    -0.14093675f, 0.11763880f, 0.09773338f, -0.09643745f, -0.02607822f, 0.37735492f, 0.14076614f, -0.17250207f, 
    -0.00217593f, 0.49765652f, 0.10050940f, -0.28893322f, -0.91969556f, -0.07252029f, 0.05625949f, 0.01984239f, 
    -0.94295114f, 0.05475626f, -0.25121763f, 0.23320840f, -0.48605147f, -0.48844469f, 0.24313855f, 0.31623822f, 
    -0.07776956f, 0.20060454f, -0.48635912f, -0.03775386f, 0.00316909f, 0.11908282f, -0.69227248f, 0.10930687f, 
    -0.05206311f, 0.44649830f, 0.35186854f, 0.02690193f, -0.26003543f, 0.18592300f, -0.63642699f, -0.15482222f, 
    0.13752903f, 0.25887740f, 0.24635179f, 0.24368665f, 0.29279482f, -0.00975120f, -0.79587251f, 0.47084737f, 
    -0.00715476f, -0.29722625f, -0.10105497f, -0.75852007f, 0.08357655f, -0.01194491f, 0.32702032f, -0.50396013f, 
    -0.27589196f, -0.55210078f, 0.07954922f, -0.37274948f, 0.21437170f, 0.04380396f, -0.08231089f, -0.86658931f, 
    -0.53661048f, -0.28661135f, -0.04653904f, -0.02917768f, 0.07445747f, -0.47102788f, -0.40044439f, 0.01582674f, 
    -0.00036145f, -0.17301123f, 0.05199407f, -0.52490169f, 0.51215172f, -0.50992566f, -0.46945783f, 0.30254164f, 
    -0.73450136f, -1.04625750f, 0.25693265f, -0.21623446f, -0.00283053f, 0.17240036f, 0.03254925f, 0.07584729f, 
    0.07030801f, -0.12521593f, 0.24288879f, -0.12667099f, 0.16304047f, -0.09718806f, 0.29009530f, 0.00746417f, 
    -0.88520128f, -0.20065321f, -0.05384227f, -0.05637138f, 0.39344308f, -0.33290157f, -0.03862775f, -0.31918934f, 
    -0.20829225f, -0.16555838f, -0.33889115f, -0.27410388f, -0.16559081f, 0.18585053f, 0.26078886f, 0.22681886f, 
    -0.08640018f, 0.39064586f, -0.05843087f, -0.63210195f, -0.20617370f, 0.07279666f, 0.64101624f, 0.10589506f, 
    0.40350458f, -1.02026498f, 0.48160854f, -0.17994723f, -0.37125733f, 0.09313520f, -1.12607884f, 0.09229480f, 
    0.23309638f, 0.24852146f, -0.12122704f, -0.25476763f, -0.18725002f, -0.98454833f, 0.00238312f, -0.16075495f, 
    0.00967409f, 0.30470303f, -1.00731039f, 0.19466195f, 0.48430443f, 0.34626907f, -0.06352769f, 0.19372974f, 
    -0.09938958f, -0.01355364f, 0.03683908f, 0.05652255f, -0.16159333f, 0.25107786f, -0.25861523f, -0.56824040f, 
    0.06917954f, 0.21019399f, -0.02110656f, 0.14395049f, -0.94246864f, 0.02193707f, 0.20769264f, 0.00172929f, 
    -0.24115513f, 0.44204521f, -0.38797584f, 0.07697184f, 0.44397590f, 0.62436616f, 0.17967021f, -0.15233219f, 
    -0.38011554f, -0.02771978f, 0.23385863f, -0.10311276f, 0.21092249f, 0.03927211f, 0.10867698f, -0.41231769f, 
    -0.16580349f, -0.47051805f, 0.00963421f, 0.14595845f, -0.39069238f, -0.19614372f, 0.24015859f, -0.28511509f, 
    0.12622321f, -1.73903358f, 0.10128856f, -0.18565787f, 0.18700907f, -0.01806558f, 0.03695545f, -0.07074064f, 
    0.34758544f, -0.17479125f, 0.02578904f, 0.49606559f, 0.27317137f, -0.15132587f, 0.18494287f, 0.12408995f, 
    -0.11373868f, 0.55440855f, 0.09357749f, -0.09834504f, 0.39492083f, -0.52846366f, -0.01591855f, -0.00831324f, 
    0.59873128f, -0.21671544f, -0.22287740f, -0.27400303f, -0.03785830f, 0.31752619f, -0.06092500f, 0.17817785f, 
    0.03363833f, -0.16274056f, -0.47407511f, -0.12381603f, 0.33584967f, 0.11849923f, -0.57936865f, 0.07780103f, 
    -0.47667798f, -0.06300475f, 0.05321863f, -0.11016943f, -0.11628465f, -0.09902161f, -0.09908606f, 0.00291130f, 
    0.13316597f, -0.28406385f, 0.13962640f, -0.07890473f, -0.12541632f, -0.16010623f, 0.39683041f, 0.18954833f, 
    -0.10477888f, 0.37861520f, 0.05213791f, -0.81718946f, 0.00856128f, 0.04728441f, 0.19108191f, -0.21935119f, 
    0.09139819f, -0.19750443f, 0.20735797f, 0.39085224f, -0.37575677f, 0.07529710f, -0.03971223f, -0.11715873f, 
    -1.71995473f, 0.27888227f, 0.04853918f, 0.06540571f, -0.05665875f, 0.19919199f, -0.39865208f, 0.32174435f, 
    -0.11799424f, -0.36962846f, -0.28257856f, 0.30504620f, -0.69470233f, 0.15949212f, 0.02491154f, -1.05651569f, 
    -0.34968740f, 0.38653588f, 0.12306633f, 0.29489529f, -0.03651865f, 0.02353458f, -0.44826630f, -0.36988324f, 
    -0.07820415f, -0.01183219f, 0.12585939f, -0.19087566f, 0.32160360f, 0.04706345f, 0.44089869f, 0.01881932f, 
    0.26706594f, -0.58309340f, 0.23798135f, -0.05435811f, -0.38033935f, 0.24022397f, -0.00551394f, 0.22705354f, 
    -0.31159082f, 0.21055132f, 0.12650663f, -0.11523788f, -0.76220703f, -0.79988164f, -0.09008143f, 0.14925322f, 
    -0.62173772f, 0.23330021f, -0.06205820f, -0.72276396f, -0.18648021f, 0.27730322f, 0.11358809f, 0.28787163f, 
    0.31910884f, 0.47834897f, -0.12433135f, 0.13492435f, 0.19565639f, 0.08248091f, -0.07920090f, 0.11795156f, 
    0.13709065f, -0.03033202f, -0.11094044f, -0.14057021f, 0.07012010f, -0.03939347f, -0.56211454f, -1.12642837f, 
    0.10257399f, 0.09462540f, -0.01913275f, -0.29834613f, 0.10497463f, 0.23031428f, -0.04185531f, 0.05257047f, 
    -0.54806626f, -0.00445586f, 0.00821780f, -0.30576029f, -0.20317073f, 0.00785256f, 0.31821007f, 0.00632008f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.02056457f, -0.22428815f, -0.07346847f, -0.05952363f, 0.08269392f, 0.27383983f, -0.12341066f, -0.34953538f, 
    -0.39342919f, -0.02073906f, 0.23089679f, 0.03622548f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
