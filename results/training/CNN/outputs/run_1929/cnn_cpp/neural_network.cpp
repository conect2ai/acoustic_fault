#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.02927171f, -0.25359318f, -0.05845742f, 0.04952721f, 0.03171676f, -0.10661722f, 0.12548324f, 0.12670775f, 
    -0.17229865f, 0.27585319f, -0.26046491f, -0.22581397f, 0.04909289f, 0.23349066f, -0.02955349f, 0.24403028f, 
    0.07477315f, -0.21499394f, -0.16972569f, 0.25605038f, -0.03433109f, 0.49319890f, -0.07167894f, -0.24569827f, 
    -0.28023487f, 0.40876436f, 0.69159997f, 0.56203777f, -0.23541559f, -0.56874174f, -0.30211121f, -0.25420746f, 
    -0.19163363f, 0.10285300f, -0.12718515f, 0.40402392f, -0.46359423f, 0.00797457f, 0.21314245f, -0.21145713f, 
    0.15341906f, 0.12000252f, -0.23399310f, -0.09578385f, 0.20424254f, -0.12701233f, 0.08930434f, -0.01852168f, 
    -0.24585034f, 0.24273135f, -0.57078224f, -0.49752894f, 0.26194710f, 0.49489310f, -0.21093965f, -0.26805207f, 
    -0.75053304f, -0.38403422f, 0.20947948f, 0.26592529f, 0.26415104f, 0.03905205f, 0.27462041f, 0.22601508f, 
    0.24906242f, 0.15471773f, -0.04210860f, -0.12354080f, -0.19638667f, -0.21254180f, -0.13666664f, 0.04581097f, 
    0.08102104f, -0.20758660f, 0.07726093f, -0.53292221f, 0.17032205f, 0.26845244f, 0.43373001f, 0.29691818f, 
    -0.40806082f, -0.30404437f, 0.00185496f, 0.16560692f, -0.07702720f, -0.38996872f, -0.39531076f, 0.06096842f, 
    0.30641949f, 0.24665385f, 0.17434022f, -0.03824600f, 0.01435266f, 0.05056236f, -0.27261293f, 0.01018314f, 
    0.02028541f, 0.02528991f, 0.12421082f, 0.01113138f, -0.47148070f, 0.06666364f, 0.31061527f, 0.10155559f, 
    -0.13632220f, -0.17698033f, 0.25977704f, 0.27573586f, -0.39482674f, -0.10064843f, 0.01012491f, 0.02260777f, 
    -0.33228439f, 0.14111359f, -0.00023401f, 0.22515555f, 0.21782647f, -0.29524717f, -0.27004266f, 0.06024361f, 
    -0.30548361f, -0.12329197f, 0.10896455f, 0.00966184f, 0.22243847f, -0.86099857f, -0.23312671f, -0.60023654f, 
    -0.33337587f, -0.49819639f, 0.09730282f, 0.28133968f, 0.41234574f, 0.32604846f, 0.28967735f, 0.40305954f, 
    0.12801085f, 0.21709213f, -0.10624509f, 0.21211766f, 0.00238523f, -0.03157872f, -0.07682393f, 0.08172318f, 
    -0.03291107f, -0.12226349f, -0.11571904f, 0.21408567f, 0.00733796f, -0.08035477f, 0.19923922f, 0.39884278f, 
    0.37644309f, -0.12822329f, -0.01469495f, -0.00753977f, -0.00825844f, 0.09662522f, 0.01812766f, 0.06588583f, 
    0.13421665f, 0.03620546f, 0.37739068f, -0.28742421f, -0.05779196f, 0.17714137f, 0.04751350f, -0.21102729f, 
    -0.08363261f, -0.05749336f, 0.04462126f, -0.01895282f, -0.18782961f, 0.05707468f, 0.24927315f, 0.59295648f, 
    -1.07254100f, -0.77468324f, 0.26293209f, -0.02553988f, 0.41640437f, 0.58387327f, 0.43600896f, 0.01897081f, 
    -0.00014445f, -0.22757839f, -0.14636171f, -0.21600150f, -0.17570451f, 0.30471411f, -0.04498016f, 0.03270617f, 
    0.11666275f, -0.19987857f, -0.06146954f, -0.03799552f, -0.26836979f, -0.25755382f, -0.00229621f, -0.16401307f, 
    -0.13766974f, -0.57813174f, -0.60828704f, -0.08869567f, -0.40833333f, 0.41525877f, 0.41433275f, -0.37308779f, 
    -0.26064935f, 0.31981617f, 0.20802994f, -0.08026410f, -0.10101035f, 0.31664404f, -0.16334206f, -0.41198656f, 
    0.02112533f, -0.35657531f, -0.53808832f, -0.34638646f, 0.12243781f, 0.01863703f, 0.04538499f, 0.45986417f, 
    0.20139994f, -1.13367641f, -0.16083480f, -0.46164659f, -0.77177614f, -0.47344911f, 0.30768731f, 0.09690968f, 
    -0.19664130f, -0.30932730f, 0.00829424f, -0.22373392f, -0.37659436f, -0.43045014f, -0.29137650f, -0.01321763f, 
    0.11844182f, 0.00234775f, -0.24975005f, -0.14019792f, -0.18522432f, 0.02745008f, -0.08134575f, 0.02431500f, 
    -0.03389523f, -0.05567532f, -0.12141332f, 0.11100032f, 0.41746977f, 0.19147618f, 0.29125997f, -0.34039527f, 
    -0.53112006f, -0.29754293f, -0.16629887f, -0.11212591f, 0.30875739f, 0.25823745f, 0.12070503f, 0.13709754f, 
    0.17789404f, 0.08101777f, -0.21347427f, 0.09890649f, -0.24328840f, -0.06944797f, -0.02360778f, 0.21459503f, 
    -0.15263964f, -0.17773299f, -0.24412297f, -0.89019042f, -0.61258644f, -0.20545794f, 0.20451137f, 0.30773094f, 
    0.78190255f, -0.43122274f, -0.43045673f, 0.19810738f, 0.68255085f, 0.09475005f, 0.11554746f, -0.09115830f, 
    -0.02626113f, -0.16586395f, -0.14834031f, 0.07763053f, -0.08026326f, 0.11470959f, -0.10488499f, 0.26330474f, 
    0.02713121f, 0.06395531f, -0.04588601f, 0.13956350f, 0.33530071f, -0.06309301f, -0.02980257f, 0.39675835f, 
    0.14676802f, -0.14847443f, -0.04833946f, -0.18260092f, -0.45938954f, -0.07753765f, 0.17139082f, 0.25596070f, 
    -0.17156431f, 0.26509795f, -0.01023872f, -0.13058132f, 0.02154447f, -0.05075712f, -0.14058945f, 0.21610264f, 
    -0.21411546f, -0.01548023f, 0.18624331f, 0.09343567f, -0.04892901f, -0.22177368f, 0.10212918f, 0.31400824f, 
    -0.10060425f, -0.38733020f, 0.44678050f, -0.10823629f, -0.33262619f, -0.03597537f, 0.34492299f, -0.25087652f, 
    -0.10854992f, 0.09400142f, 0.10351423f, -0.31044531f, -0.15771335f, -0.09008266f, 0.25893053f, -0.09253028f, 
    -0.22498198f, 0.11983332f, 0.06669158f, -0.09609624f, 0.08947048f, 0.34904894f, 0.08841649f, -0.14330032f, 
    -0.20659088f, -0.52492988f, -0.38710362f, -0.17493922f, 0.05886979f, -0.29610893f, -0.14305665f, -0.06524917f, 
    0.27540609f, 0.48097897f, 0.15846422f, 0.12684174f, -0.15250354f, -0.32835531f, 0.05218293f, -0.01146267f, 
    -0.18645914f, -0.00547320f, -0.25572860f, -0.18665054f, 0.06551398f, -0.40841097f, -0.36483839f, -1.01160991f, 
    -0.23992382f, -0.14627391f, -0.43675551f, -0.36878633f, 0.30026168f, 0.03454098f, 0.17820244f, 0.44498453f, 
    0.64285213f, -0.08539007f, 0.20800139f, -0.02322762f, -0.05453808f, 0.03714873f, -0.12243058f, -0.02512680f, 
    -0.09731605f, 0.22618854f, 0.10927135f, 0.11641476f, 0.07348806f, 0.11071420f, -0.10747597f, -0.23559983f, 
    0.13578540f, -0.77615899f, 0.14829955f, 0.52622706f, 0.30496347f, -0.77390975f, -0.62688947f, -0.44491521f, 
    0.24747889f, 0.03313278f, -0.13528235f, 0.44907099f, 0.01432950f, -0.04102913f, -0.29994583f, 0.12156415f, 
    0.00801606f, 0.10451593f, -0.11597162f, -0.03970576f, 0.05623120f, -0.11393040f, 0.03016524f, 0.13962066f, 
    0.07323760f, 0.36712810f, 0.21091352f, 0.22879718f, -0.25095400f, -0.33542302f, -0.04871732f, 0.19187988f, 
    0.00170598f, -0.22220595f, 0.01787444f, 0.24462077f, -0.17562826f, 0.33942398f, -0.23030958f, -0.20599410f, 
    -0.06328235f, -0.05482274f, -0.06912945f, 0.00823606f, 0.12273479f, -0.15521657f, 0.12526543f, -0.14303608f, 
    -0.21231815f, 0.28951496f, -0.35587648f, -0.25323603f, 0.38176134f, -0.71780175f, -0.70731658f, 0.40989444f, 
    0.33855271f, -0.29797366f, -0.36355266f, 0.32550228f, -0.05802673f, -0.09217958f, -0.12019480f, 0.19209063f, 
    0.49683812f, -0.09565984f, -0.20424992f, -0.02449254f, -0.24657989f, -0.02679836f, 0.19591530f, 0.23524815f, 
    0.10726596f, -0.17114986f, -0.24913730f, -0.72461361f, 0.42187628f, 0.70473999f, -0.47429454f, 0.11214442f, 
    -0.17881973f, -0.17932592f, -0.15669444f, -0.01221698f, 0.33014140f, 0.10973857f, 0.06484674f, 0.02232932f, 
    -0.20285867f, -0.07178050f, -0.02734998f, -0.07398137f, -0.15683390f, 0.13884020f, -0.05517821f, 0.10050514f, 
    0.16013677f, -0.15977196f, 0.10877732f, -0.23816481f, -0.04287969f, -0.67597920f, -0.03549804f, 0.29633623f, 
    0.35720855f, 0.16453858f, -0.11386716f, -0.40797409f, 0.08382731f, 0.28653800f, -0.21902376f, 0.34694481f, 
    -0.55493397f, -0.08068854f, 0.07695806f, 0.15195204f, 0.08579973f, -0.19684388f, 0.04750069f, 0.06222659f, 
    -0.04583186f, -0.21609719f, -0.24772269f, -0.05893267f, 0.22881551f, 0.10662105f, 0.54763615f, 0.83000124f, 
    -0.44808447f, -0.84359169f, -0.64176989f, -0.56397110f, -0.46816793f, -0.17034547f, -0.28560787f, 0.35780928f, 
    -0.36192560f, -0.17667407f, 0.51931298f, 0.29304817f, -0.06335477f, -0.13269292f, -0.20258054f, 0.03843979f, 
    -0.35688967f, 0.01327309f, 0.08330458f, -0.17311601f, 0.01232440f, -0.26987761f, -0.74033749f, -0.90484881f, 
    0.55353701f, 0.78836292f, 0.64450198f, 0.65874308f, -0.73703575f, -0.85272121f, -0.14176472f, -0.25519651f, 
    -0.60282844f, -0.00564333f, -0.38296580f, -0.09233636f, -0.31206170f, -0.19296232f, -0.29108185f, 0.13279329f, 
    0.09086671f, -0.17938733f, -0.08077279f, 0.17252691f, -0.15354383f, 0.02633175f, -0.12770054f, 0.87069225f, 
    0.12324017f, -0.17159569f, -0.13903134f, -0.03483157f, 0.36335281f, 0.14644104f, 0.05867512f, -0.24473462f, 
    0.00018986f, -0.14756577f, -0.29169142f, 0.33824208f, -0.15318824f, -0.35723421f, -0.28020510f, 0.02567834f, 
    0.28982463f, -0.13063158f, -0.22076777f, 0.16618212f, -0.27384704f, 0.06675825f, 0.28318751f, -0.19176885f, 
    0.74073488f, -0.51865816f, -0.29774040f, 0.21971297f, 0.21934123f, -0.29482636f, -0.21986067f, -0.08931485f, 
    -0.03153589f, -0.02886906f, 0.20708108f, 0.14834444f, -0.00461355f, 0.08995125f, 0.00991387f, -0.11574603f, 
    -0.12358791f, 0.12928148f, 0.10975847f, -0.03860343f, 0.03354729f, 0.08955649f, 0.03947527f, -0.08850509f, 
    -0.31096098f, 0.12929790f, -0.44194585f, 0.05381434f, 0.03262442f, 0.23426014f, -0.00354332f, 0.08530465f, 
    0.24866444f, 0.13663724f, -0.16367516f, -0.09596612f, -0.24152106f, 0.61751598f, -0.47061667f, -0.08912477f, 
    0.00147920f, 0.02961543f, 0.22223635f, -0.03623592f, -0.12414909f, -0.21141961f, -0.17443120f, -0.13470045f, 
    0.21871999f, 0.26483196f, 0.30356610f, 0.34633762f, 0.17992358f, 0.11808071f, -0.24497722f, 0.09552786f, 
    0.24991411f, -0.02418090f, -0.14412901f, -0.30023965f, 0.15715611f, -0.08509600f, -0.14604829f, 0.25154230f, 
    -0.14609167f, -0.20045879f, -0.19609250f, -0.20544192f, 0.32010284f, -0.13264814f, 0.36146164f, 0.05677367f, 
    -0.19321859f, -0.24295601f, -0.11582057f, 0.29729280f, 0.12420628f, -0.18760641f, 0.12037968f, 0.02072141f, 
    0.30649900f, -0.04106901f, 0.03445550f, 0.24168508f, -0.22760926f, 0.22261406f, 0.30431384f, -0.07206581f, 
    -0.40435106f, 0.00004214f, -0.00996621f, 0.09220982f, 0.11541481f, -0.25196764f, -0.05790649f, 0.35938135f, 
    0.27038810f, 0.01064044f, -0.23211938f, -0.31104380f, 0.95778370f, -0.84195036f, -0.72660637f, -0.14473850f, 
    -0.52043229f, 0.62603045f, 0.56914830f, 0.59939748f, -0.39752942f, -0.32027352f, -0.04592669f, 0.01295106f, 
    -0.12349724f, -0.02655278f, -0.07809134f, -0.18115544f, 0.10610720f, -0.03719697f, 0.23740703f, -0.02033935f, 
    -0.04964979f, -0.18016790f, 0.01831994f, 0.21568403f, 0.02777223f, 0.49213347f, 0.37234074f, -0.00098761f, 
    -0.31767446f, -0.47296390f, -0.05898814f, -0.21565820f, 0.12032998f, 0.24336854f, -0.25344500f, 0.26725355f, 
    -0.31320009f, -0.20912573f, 0.33166668f, -0.12177286f, 0.08456094f, 0.12795828f, -0.31292868f, 0.02816212f, 
    -0.31736138f, 0.05831780f, 0.04777745f, 0.01704937f, 0.35984853f, 0.24163423f, -0.60056841f, -0.72286618f, 
    0.26925096f, 0.40853709f, 0.57065499f, -0.26714271f, -0.16490735f, -0.05667024f, 0.50923699f, 0.06778414f, 
    -0.33803338f, -0.39326501f, -0.17376505f, 0.03969667f, 0.33646417f, -0.16372062f, 0.02742464f, 0.00598510f, 
    0.17540084f, -0.12341092f, 0.34499136f, 0.11222050f, -0.30825391f, -0.07028528f, 0.29324347f, -0.58522844f, 
    0.25564942f, 0.13130689f, -0.25819269f, -0.20760559f, -0.16726820f, 0.09374316f, -0.30966729f, 0.09025700f, 
    -0.34341198f, -0.00538316f, 0.29533198f, -0.14786498f, -0.16055414f, -0.27790225f, 0.16296482f, -0.00058136f, 
    0.07564428f, 0.24995939f, 0.27006412f, 0.09175306f, 0.00151202f, -0.17943755f, -0.12279863f, -0.08234634f, 
    -0.70445591f, -0.47339347f, 0.30092508f, 0.59685832f, 0.24212933f, 0.64810365f, 0.60307515f, -0.07326344f, 
    -0.11105788f, -0.32006970f, -0.35017103f, -0.26275700f, 0.21842821f, 0.17686746f, -0.20912078f, -0.05664054f, 
    -0.10508769f, -0.07685064f, -0.19046490f, 0.10185598f, -0.04617542f, -0.00508514f, 0.10021723f, 0.25283155f, 
    -0.15747383f, -0.17457144f, -0.46065992f, -0.04663031f, 0.25797653f, 0.14650671f, -0.21813805f, 0.01986035f, 
    0.03666873f, 0.48084140f, -0.43926871f, -0.28420448f, 0.02137682f, 0.13980255f, 0.13380150f, -0.08255340f, 
    -0.08047593f, -0.08955247f, -0.01567148f, 0.00131634f, 0.13264185f, -0.02621914f, 0.09422354f, 0.15291011f, 
    -0.25242522f, 0.18921779f, 0.28950283f, -0.07252516f, -0.13554811f, 0.44419634f, -0.41252020f, 0.49910343f, 
    0.05480253f, -0.75839168f, -0.76795346f, -0.20778982f, 0.38161138f, -0.16335133f, -0.20953643f, -0.12385394f, 
    -0.13255830f, -0.54266161f, 0.41831782f, -0.14900583f, 0.00870700f, -0.13424836f, 0.36452684f, -0.03365634f, 
    -0.07018016f, -0.16815537f, -0.39541477f, 0.03069390f, -0.12443554f, -0.32670146f, -0.05037187f, 0.62718320f, 
    -0.05299935f, 0.62668860f, 0.39257899f, -0.12022189f, -0.61525857f, 0.05718662f, 0.11603431f, -0.02771906f, 
    -0.14001052f, 0.14701626f, -0.23342893f, -0.00926737f, -0.09088533f, -0.28494051f, 0.26321194f, 0.19565290f, 
    0.01569151f, -0.24408068f, 0.03822348f, -0.01030206f, -0.14834262f, -0.28025892f, -0.72579199f, -0.49711704f, 
    -0.84484231f, 0.73336679f, 0.00961865f, 0.16968462f, 0.16677658f, 0.19393124f, -0.04512854f, 0.25865725f, 
    -0.54277408f, -0.17145079f, -0.21476385f, -0.15065420f, -0.56908858f, 0.41226140f, -0.01447958f, -0.15374188f, 
    -0.14541237f, -0.27322292f, 0.08750450f, -0.23560442f, -0.05291445f, 0.44980145f, -0.47731823f, -0.11440420f, 
    0.44953060f, 0.04541871f, 0.15591779f, 0.70027971f, -0.33181486f, -0.64023036f, -0.23020940f, -0.04583355f, 
    0.08839029f, -0.05614277f, -0.12539150f, 0.16724049f, 0.21738158f, -0.43107677f, -0.13760306f, 0.20502998f, 
    0.07352518f, -0.01136815f, -0.11239976f, -0.03650336f, 0.17833909f, -0.07310743f, -0.67384315f, -0.48455858f, 
    -0.02634181f, 0.81790185f, -0.17352265f, 0.06897230f, -0.18617928f, -0.36715916f, 0.28971535f, 0.20168595f, 
    -0.40797332f, 0.26390347f, -0.17015126f, -0.00917864f, -0.12504810f, -0.24555570f, 0.00986961f, -0.15645266f, 
    -0.28250033f, 0.09378026f, -0.28030717f, -0.19781503f, -0.30303711f, -0.39087871f, -0.41580743f, 0.01179944f, 
    0.09795672f, 0.34480608f, -0.04038505f, 0.56081182f, -0.33774403f, -0.30968258f, -0.35168916f, -0.34402442f, 
    -0.04288916f, 0.02723823f, -0.02996575f, 0.07095110f, -0.13095494f, 0.45101586f, -0.15547228f, 0.30318332f, 
    -0.13084765f, -0.11639771f, 0.14006464f, -0.34546039f, 0.03197714f, -0.01641492f, 0.14555216f, -0.00241990f, 
    0.01670567f, -0.10149365f, -0.31344989f, -0.16459845f, 0.20197284f, 0.16227415f, -0.22873385f, -0.06605418f, 
    0.26371077f, -0.13543969f, 0.23737256f, 0.59128284f, -0.46657380f, -0.05721649f, -0.31629562f, -0.16178451f, 
    0.02656162f, -0.21158676f, -0.33682173f, 0.10805094f, 0.11876650f, -0.12634377f, 0.07451233f, 0.29255232f, 
    0.11379302f, -0.32010654f, 0.18636714f, -0.13157514f, -0.12607652f, -0.11784527f, -0.29875112f, 0.13982721f, 
    -0.22024025f, -0.23484977f, -0.25478774f, 0.37207913f, 0.02366940f, -0.09368162f, 0.12764971f, -0.16735686f, 
    0.20847030f, -0.01746698f, 0.10384077f, 0.14662988f, 0.15088715f, -0.03121397f, 0.12779526f, 0.05117868f, 
    -0.12750562f, 0.09841483f, 0.10653894f, -0.19225582f, 0.26062205f, 0.17567028f, -0.16642989f, 0.03371313f, 
    -0.08429718f, -0.39368603f, -0.03053496f, 0.40483543f, 0.06093884f, -0.17191769f, -0.32369778f, -0.02730504f, 
    0.51338601f, -0.17468488f, -0.08597806f, -0.02362331f, -0.04757471f, -0.02627295f, 0.17298451f, -0.23830430f, 
    0.21601632f, 0.00094833f, -0.09772502f, -0.17743365f, 0.28402010f, 0.17236985f, 0.14076437f, 0.21087307f, 
    -0.32917795f, -0.27799904f, 0.05783686f, -0.12268437f, 0.38956213f, 0.08746479f, 0.32493636f, -0.16392276f, 
    -0.27418044f, -0.26512384f, -0.22265297f, 0.17698605f, 0.19224203f, 0.09632389f, -0.19145580f, -0.20850274f, 
    0.01409850f, 0.18708967f, -0.17744339f, -0.43624952f, -0.68060774f, 0.07612167f, 0.23691782f, 0.43056497f, 
    -0.29266626f, -0.49571568f, -0.33169717f, 0.30263257f, 0.29584342f, -0.03817181f, 0.21919248f, -0.28133333f, 
    -0.24973343f, 0.67083341f, -0.63406008f, -0.28266218f, -0.28006741f, 0.14270110f, 0.15902033f, -0.03766965f, 
    0.19703594f, -0.33056659f, 0.08953565f, -0.35000914f, 0.54952556f, -0.78054589f, -0.40651703f, -0.21254461f, 
    0.24562152f, 0.28185973f, -0.04685141f, 0.28673750f, 0.23966815f, 0.48282716f, 0.45565245f, -0.18041420f, 
    -0.16039807f, 0.32121265f, -0.11578298f, -0.01041654f, -0.27675682f, -0.09314997f, -0.18335988f, 0.14528231f, 
    -0.39553747f, -0.02787059f, 0.22459722f, 0.29988906f, -0.07976051f, 0.39606637f, -1.00739861f, -0.74417984f, 
    0.19030693f, 0.33049077f, 0.79087174f, -0.55044246f, -0.77435184f, -0.22973563f, 0.40419394f, 0.45884782f, 
    0.12429737f, -0.25153449f, -0.16788061f, 0.08763613f, -0.25490355f, -0.10842551f, -0.31579629f, -0.22456914f, 
    -0.11724888f, -0.37546343f, -0.32468280f, -0.07151656f, -0.03478793f, 0.12749831f, -0.27610159f, -0.78627521f, 
    -0.18747213f, -0.55360144f, -0.70617956f, -0.14276704f, -0.14133728f, -0.31965417f, -0.32839167f, 0.48999307f, 
    0.43780693f, -0.00626565f, -0.36020890f, -0.24291550f, -0.31941649f, -0.22057034f, 0.41335559f, 0.20846273f, 
    0.12818187f, 0.18249464f, -0.12637283f, -0.09078096f, -0.15059629f, -0.28832665f, -0.07059598f, -0.33899039f, 
    -0.07988052f, -0.39935178f, -0.59118807f, -0.18387994f, -0.65440351f, -0.71586794f, -0.52288663f, -0.66047907f, 
    -0.58171475f, -0.86618870f, 0.38649836f, 0.21676958f, 0.25002921f, 0.13349730f, 0.01933452f, 0.16786736f, 
    -0.29552662f, 0.04094012f, 0.29792705f, -0.29298210f, -0.07602898f, 0.18176006f, -0.16735820f, 0.30678010f, 
    0.05950701f, 0.25074974f, 0.29934898f, 0.29403234f, 0.36030430f, 0.25017270f, 0.22360580f, 0.12050344f, 
    -0.05392454f, 0.02103409f, -0.38528797f, -0.35112935f, -0.23340605f, -0.00388019f, -0.02121222f, -0.21364114f, 
    -0.10155163f, 0.09270374f, -0.08765332f, 0.00764742f, -0.12180804f, 0.26168820f, -0.02338248f, -0.19188182f, 
    -0.26786327f, -0.37807566f, -0.47105786f, -0.54130733f, -0.69791538f, -0.45684573f, 0.09638507f, -0.14793597f, 
    -0.08974152f, 0.25047022f, 0.14213082f, -0.47075874f, -0.30696532f, -0.33162472f, -0.24910247f, -0.02057210f, 
    0.39021823f, -0.27770317f, 0.18292962f, -0.12605207f, -0.23492625f, 0.07867069f, 0.02051218f, 0.00036747f, 
    0.23687309f, -0.04927588f, -0.31110159f, -0.27275011f, 0.19014783f, -0.21034347f, 0.49444312f, 0.14499335f, 
    0.02563339f, 0.11551215f, -0.50257915f, -0.09621694f, -0.01273419f, 0.05986503f, 0.07997831f, -0.39717752f, 
    0.23130265f, 0.00688145f, 0.13622661f, 0.02851672f, -0.11774164f, 0.15523508f, 0.06651274f, -0.31410429f, 
    0.03973885f, 0.02167385f, -0.01852512f, -0.35463676f, -0.51060516f, -0.47728804f, -0.16811770f, -0.10799353f, 
    -0.08267283f, -0.63697618f, -0.32256874f, -0.49134961f, -0.33491236f, -0.27458611f, 0.29785070f, -0.08415771f, 
    0.04329358f, -0.00385902f, 0.09583274f, -0.25027969f, 0.03009259f, -0.10786786f, -0.15509923f, -0.12971726f, 
    -0.07112989f, -0.30612868f, -0.26880291f, -0.19187182f, -0.17692074f, 0.24875300f, 0.05910293f, -0.15199985f, 
    0.06116300f, -0.04370736f, -0.27471742f, 0.08791455f, 0.32085967f, 0.16849898f, -0.16443090f, -0.03065747f, 
    -0.21267805f, 0.04382123f, 0.45082706f, -0.18321881f, -0.08919789f, 0.34230664f, -0.24841478f, 0.13278033f, 
    -0.36444673f, -0.24281751f, 0.22969078f, 0.22595768f, -0.17056003f, -0.01326900f, -0.23191173f, 0.35077056f, 
    -0.10246496f, 0.06117447f, 0.03557361f, -0.33874926f, -0.32877949f, 0.09594533f, 0.28196186f, -0.27396712f, 
    -0.13174497f, -0.20557104f, 0.26784274f, -0.30672038f, 0.01017835f, 0.17629576f, -0.05650276f, -0.06413278f, 
    0.03505095f, 0.08004123f, 0.06938050f, 0.08647016f, 0.06619560f, 0.20230885f, 0.00625209f, 0.44536158f, 
    -0.01196264f, -0.23274827f, -0.51108164f, -0.09819234f, 0.12506729f, 0.00638108f, -0.27309301f, -0.11919408f, 
    0.25195891f, 0.21638276f, -0.33025721f, 0.25713092f, 0.17821275f, 0.22701059f, 0.11497202f, -0.16697226f, 
    0.00682326f, -0.16271859f, -0.39729902f, 0.18536125f, 0.18662746f, 0.07752754f, -0.15305297f, 0.31900394f, 
    -0.25127926f, -0.53867763f, -0.64181006f, -0.54767591f, -0.03603872f, -0.14638939f, -0.20207444f, 0.60856295f, 
    0.20488000f, -0.35264859f, -0.36297649f, 0.02566485f, -0.03996366f, -0.05293944f, -0.16622502f, 0.27340552f, 
    -0.50263250f, -0.17224690f, 0.18332304f, -0.23260915f, -0.04671083f, 0.52086657f, -0.08191542f, -0.20380203f, 
    0.26212889f, 0.63218540f, 0.10661826f, 0.04633691f, -0.61091918f, -0.53964955f, 0.28667992f, 0.08186217f, 
    0.00332400f, 0.10392947f, -0.28375691f, 0.05770503f, -0.25281134f, -0.10071856f, -0.06559166f, -0.04729111f, 
    0.03781601f, 0.03636036f, -0.08522457f, -0.21045592f, -0.42970642f, -0.42223534f, -0.32346323f, -0.42066512f, 
    -0.38044760f, -0.49680468f, 0.09953369f, -0.67320639f, -0.71508175f, -0.67127442f, -0.59756601f, 0.55713075f, 
    0.08379374f, 0.41497245f, 0.36622432f, -0.00190573f, 0.28520066f, 0.39818642f, -0.09870839f, -0.07354531f, 
    -0.16836545f, -0.48252240f, 0.16109063f, 0.04799328f, -0.30200222f, -0.15228961f, -0.12372506f, 0.01305011f, 
    0.07530168f, -0.06615432f, 0.49550414f, -0.65691727f, -0.48853284f, -0.12590988f, -0.26925823f, 0.38466001f, 
    0.66200459f, 0.28681487f, 0.34545389f, -0.48443249f, 0.41421530f, 0.01312593f, -0.32058421f, -0.37611327f, 
    0.07231234f, -0.40331742f, 0.16841125f, -0.03686892f, 0.05095969f, 0.16099809f, 0.12019722f, -0.07797747f, 
    -0.01477535f, -0.09017486f, 0.00762662f, 0.10274765f, 0.08113664f, -0.12878898f, 0.28455466f, -0.11157367f, 
    0.24324434f, 0.17933477f, -0.09489992f, -0.09094128f, 0.16361371f, 0.26189440f, -0.22397065f, -0.05885225f, 
    -0.11757992f, 0.29896033f, 0.29215807f, -0.09026052f, -0.04300023f, -0.11631034f, -0.10892396f, 0.10488829f, 
    0.01804317f, -0.24939418f, 0.11106513f, 0.17354929f, 0.03261621f, 0.03542545f, 0.01686144f, -0.17045029f, 
    -0.14216404f, 0.03006163f, -0.19355421f, -0.21295550f, 0.18307202f, -0.16071828f, -0.08197077f, 0.03005273f, 
    0.30419862f, -0.09119125f, 0.34259537f, -0.04279384f, 0.10393219f, 0.15433814f, -0.11346003f, -0.24294613f, 
    -0.12874496f, 0.10292063f, 0.33420748f, -0.05278940f, -0.32354179f, -0.09280147f, -0.30627516f, -0.00706956f, 
    -0.14148627f, -0.32678133f, -0.19931117f, -0.14012694f, -0.53936708f, -0.65041161f, -0.72330958f, -0.74137026f, 
    -0.02032961f, 0.01959705f, 0.02927133f, 0.01125059f, -0.28794578f, -0.20224735f, -0.70960635f, -0.28734696f, 
    -0.10164573f, -0.17723420f, -0.11374969f, -0.31736904f, -0.21258676f, 0.25437006f, 0.18075222f, 0.81442761f, 
    -0.08420064f, 0.07398598f, 0.30357218f, -0.19662383f, -0.27149266f, 0.39594382f, -0.42508513f, -0.39568850f, 
    -0.16921812f, -0.21069728f, 0.08345512f, -0.23574328f, -0.25611514f, 0.36035830f, 0.05952423f, 0.23472999f, 
    -0.05983267f, 0.30170989f, -0.12745114f, -0.11994001f, -0.19501333f, -0.01270445f, -0.19237818f, -0.29642689f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11973512f, 0.28681460f, 0.19562383f, 0.00079499f, 0.24442020f, 0.23601229f, 0.04129359f, -0.08714202f, 
    0.19584134f, -0.35370249f, -0.19517784f, 0.26349410f, 0.00183760f, -0.06414343f, -0.04299006f, 0.06930932f, 
    0.31664738f, 0.25100324f, 0.17405690f, 0.12540933f, 0.23587455f, 0.21877301f, -0.01553732f, 0.17950328f, 
    0.05475033f, 0.21338674f, 0.15926082f, -0.03654440f, 0.37147802f, 0.07442971f, 0.22172655f, 0.26638445f, 
    0.20833880f, 0.29875833f, -0.03294371f, 0.40821001f, -0.14941415f, 0.25512192f, -0.00352960f, 0.05210341f, 
    0.03146666f, -0.03590938f, 0.30224329f, 0.04813395f, 0.09178152f, 0.12695280f, -0.06191311f, -0.24421149f, 
    -0.12753896f, 0.02283403f, -0.03915733f, 0.00209366f, -0.25557056f, 0.31608403f, 0.22866815f, 0.00854203f, 
    -0.04672683f, 0.09759448f, 0.43023825f, 0.02669747f, 0.02040876f, 0.05683260f, -0.22123361f, -0.06258623f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.06436490f, -0.02850675f, 0.03681383f, -0.03921135f, 0.02397265f, -0.02427088f, 0.00066557f, -0.05990336f, 
    -0.06115083f, 0.08163244f, -0.01357696f, -0.19666690f, -0.14118741f, -0.18535766f, -0.10172252f, -0.07536139f, 
    -0.04921337f, 0.09440571f, -0.16621144f, -0.18316229f, -0.11888497f, 0.02148042f, 0.00728353f, -0.04022994f, 
    0.18016349f, 0.24916878f, 0.22208276f, -0.45262986f, -0.09329235f, -0.01957524f, 0.05598181f, -0.03815906f, 
    0.09366569f, -0.07896864f, -0.05441924f, 0.00577074f, -0.07440889f, 0.08854806f, 0.15017933f, -0.07972629f, 
    -0.01129720f, -0.18075301f, -0.03306179f, 0.03019321f, 0.01971562f, -0.02506912f, -0.03700132f, 0.00285215f, 
    -0.10759234f, -0.35744262f, 0.04016904f, -0.10278916f, -0.05528834f, -0.14173728f, 0.06408346f, 0.18689029f, 
    -0.17406522f, 0.09074803f, -0.12799789f, 0.04495132f, 0.17577997f, 0.02116803f, 0.07344134f, 0.02566873f, 
    0.09895932f, 0.06559897f, -0.03018573f, 0.00521210f, -0.02556931f, -0.04003741f, -0.05562860f, 0.08848169f, 
    -0.14863503f, -0.09133164f, -0.13838887f, -0.04871233f, 0.03772718f, 0.02514016f, 0.04508385f, -0.00363548f, 
    -0.05167397f, -0.06323448f, -0.06395717f, 0.00632622f, 0.23478821f, -0.38597053f, -0.12199623f, 0.11913456f, 
    0.02419460f, 0.03132812f, 0.03123533f, -0.06146194f, 0.14288564f, 0.07634367f, -0.02656711f, 0.17189300f, 
    0.11544876f, 0.09398787f, -0.20232362f, 0.02137857f, 0.13054432f, 0.01720498f, -0.00716147f, -0.35867175f, 
    -0.08712466f, -0.14235719f, -0.12976365f, -0.05637799f, 0.20482154f, 0.26240146f, 0.01514931f, -0.10790092f, 
    0.04803718f, 0.26375654f, 0.06511233f, 0.12873895f, -0.05042679f, 0.00756968f, 0.02746662f, -0.06069138f, 
    0.01862432f, 0.13154978f, 0.07516568f, -0.13863319f, -0.25920257f, 0.10685281f, -0.00717581f, 0.02334742f, 
    0.06944098f, 0.03268433f, 0.00680534f, -0.05181593f, 0.26618859f, 0.16056351f, 0.15796748f, -0.13026166f, 
    -0.17262934f, 0.05485366f, 0.07717854f, -0.13864155f, -0.03647466f, -0.00307064f, -0.01838101f, -0.16185103f, 
    -0.07562682f, 0.03145092f, -0.07416542f, -0.03084441f, -0.18251316f, -0.06118774f, -0.10615471f, -0.01584036f, 
    0.01429997f, 0.09375302f, 0.00613467f, -0.02990585f, 0.07888441f, -0.08670246f, -0.08837347f, -0.04103726f, 
    -0.10062337f, 0.01829154f, -0.01713517f, 0.06445821f, 0.02438667f, -0.15169331f, 0.01358601f, 0.06063220f, 
    0.20257771f, 0.05828899f, -0.06716543f, -0.05930081f, 0.06561294f, 0.01343111f, -0.05814648f, 0.01271096f, 
    0.00873339f, 0.14861642f, -0.07657411f, -0.00744739f, 0.01596637f, 0.07768952f, 0.14179495f, -0.00154551f, 
    0.07362176f, 0.12122575f, 0.09437187f, -0.00750963f, 0.00022119f, 0.08213803f, -0.00093721f, 0.06671658f, 
    0.05734842f, 0.28953457f, 0.02401827f, -0.37673935f, 0.01711738f, 0.00030837f, -0.05796605f, -0.09625158f, 
    0.02364690f, -0.06273215f, -0.00828292f, 0.07121828f, -0.06973672f, -0.17707561f, -0.19265887f, -0.02885813f, 
    0.02734836f, 0.00255356f, -0.01489272f, 0.02168868f, -0.03584965f, -0.02226672f, -0.05075737f, 0.02486774f, 
    0.16022742f, -0.01890058f, -0.15762140f, -0.22729853f, 0.04901863f, 0.08417307f, -0.12097161f, -0.04160046f, 
    -0.14105365f, -0.06963152f, 0.04295453f, 0.13486524f, -0.26827392f, 0.06543729f, 0.13278620f, 0.03983431f, 
    -0.17844181f, 0.00132671f, 0.04152108f, 0.01578609f, 0.09393799f, -0.05393003f, -0.19236653f, -0.09647246f, 
    -0.02893148f, 0.09420215f, 0.00269090f, -0.02393906f, -0.07393400f, -0.02665333f, 0.10596562f, -0.09330187f, 
    -0.07919478f, 0.09367627f, -0.02658734f, -0.20393725f, 0.09630149f, 0.07774927f, -0.07083496f, -0.10717379f, 
    -0.00328790f, 0.08253827f, -0.15464345f, -0.09696817f, 0.10020731f, -0.03287603f, 0.03953189f, -0.08942389f, 
    0.52625453f, 0.19337656f, 0.01832356f, -0.27639794f, -0.16703950f, -0.23068672f, 0.04528080f, -0.07044300f, 
    0.02754869f, -0.02893653f, 0.00111717f, -0.03006216f, -0.36027694f, -0.46212518f, -0.51787382f, 0.26976436f, 
    0.05846624f, 0.00097264f, 0.02918600f, 0.00301857f, 0.06054981f, -0.07852333f, -0.05509029f, 0.09465055f, 
    0.01820954f, 0.04830668f, -0.01211741f, -0.15057002f, -0.33135986f, -0.08832401f, 0.00333289f, 0.01156109f, 
    -0.08345149f, 0.06647852f, -0.02005059f, -0.04658600f, -0.06414445f, -0.15102755f, -0.11033947f, -0.04773824f, 
    -0.10187265f, 0.00278019f, 0.04658422f, 0.04597672f, 0.00782867f, -0.04365517f, -0.02335194f, -0.04624283f, 
    -0.22045925f, -0.44222745f, -0.23898940f, 0.10986401f, 0.05983767f, 0.04253326f, -0.01520685f, 0.02310854f, 
    -0.02324347f, -0.00009854f, -0.01701181f, 0.03139450f, -0.12730265f, -0.14577845f, -0.15618107f, 0.03954995f, 
    -0.01871552f, -0.10527316f, -0.02654134f, 0.04665987f, -0.14097604f, 0.02168120f, -0.04498469f, -0.09977063f, 
    0.16533227f, -0.41951120f, -0.56656003f, 0.04899532f, 0.07873814f, -0.05694743f, -0.04777856f, -0.01565082f, 
    -0.03229340f, -0.07172702f, -0.19968490f, 0.01010096f, -0.04060018f, -0.15232337f, 0.00342124f, 0.05346332f, 
    -0.07407425f, 0.04878615f, -0.05386371f, -0.06089060f, 0.03404416f, -0.08529279f, -0.06682599f, 0.01751170f, 
    0.23928931f, 0.15560216f, 0.21198979f, -0.35386896f, -0.19225430f, -0.11220845f, 0.05267355f, 0.07569796f, 
    -0.01127210f, 0.02285876f, -0.03665216f, -0.10218928f, 0.12564157f, 0.22405723f, -0.13687150f, -0.09427579f, 
    -0.08869894f, 0.13151500f, -0.06242192f, 0.00965562f, 0.02358179f, 0.03797841f, 0.06484704f, -0.01993977f, 
    0.35771310f, -0.41331044f, -0.07965429f, -0.25572726f, 0.00734093f, -0.05183770f, 0.07128717f, 0.02436377f, 
    -0.03959808f, -0.03855772f, -0.01566166f, 0.02674399f, -0.01652826f, 0.17540015f, 0.17231014f, -0.02389159f, 
    -0.08658960f, -0.15163937f, -0.02928658f, -0.04637196f, -0.14898938f, -0.11246044f, -0.04484976f, -0.16440007f, 
    0.14943029f, -0.08263717f, -0.28253961f, -0.13351837f, -0.12010971f, -0.10698579f, 0.14893174f, -0.05548555f, 
    -0.06429815f, -0.01363270f, 0.08365422f, -0.01106451f, -0.08058856f, -0.52912939f, -0.43640497f, -0.15988210f, 
    -0.06607208f, -0.05354432f, -0.00472840f, -0.08009797f, -0.13751236f, -0.13390467f, -0.01887244f, -0.11014284f, 
    0.13843744f, 0.07270841f, -0.04428662f, -0.11532357f, 0.09298006f, 0.09845357f, -0.14348799f, -0.08729006f, 
    0.02454072f, 0.08459188f, -0.05676504f, 0.16414662f, 0.05680642f, -0.17813376f, -0.20252763f, -0.02324517f, 
    -0.13403316f, -0.06211748f, 0.00946553f, -0.16105026f, -0.13137694f, 0.01897818f, 0.04195204f, -0.02033449f, 
    0.16219190f, 0.03608407f, 0.06458156f, -0.14490201f, 0.06446452f, -0.01299170f, 0.05843828f, -0.01673803f, 
    -0.06261558f, 0.10522640f, 0.04991653f, 0.10556442f, -0.06035517f, 0.09258157f, -0.02615168f, -0.08526238f, 
    0.02204504f, -0.01996950f, -0.12252159f, -0.05837471f, 0.01287448f, -0.00792462f, 0.02067409f, -0.01159794f, 
    0.01265526f, 0.09226641f, -0.15064694f, -0.05882433f, -0.07960992f, 0.03909412f, -0.06554704f, -0.01191332f, 
    -0.16991197f, 0.01182709f, -0.07498994f, -0.14625919f, 0.11232904f, 0.09614462f, -0.03322617f, 0.07662678f, 
    -0.15310678f, -0.07610025f, -0.05968149f, -0.01240995f, 0.03415465f, 0.07151794f, -0.01389410f, -0.00017177f, 
    -0.09321743f, -0.00058607f, -0.01560686f, -0.14125325f, -0.10159960f, -0.02448332f, -0.07193678f, 0.00532684f, 
    -0.04405433f, -0.12852046f, 0.02721578f, 0.09954258f, -0.49651286f, 0.11002224f, 0.09260421f, -0.05411255f, 
    0.08479955f, -0.01053714f, 0.00882636f, -0.02809659f, -0.13285591f, -0.10244629f, -0.01582949f, 0.00562316f, 
    -0.02441328f, 0.22822593f, 0.42075327f, -0.17432828f, -0.16984612f, -0.09844629f, -0.08151595f, 0.12705065f, 
    -0.05327886f, -0.02435211f, -0.01929963f, -0.14160515f, -0.24413903f, 0.17791560f, 0.11630572f, -0.11530906f, 
    0.01947679f, 0.00799016f, 0.02975116f, -0.06633234f, -0.01488778f, -0.10282682f, -0.12985335f, -0.18445598f, 
    0.39559811f, 0.30560142f, 0.30493495f, -0.20998278f, -0.13145474f, 0.06666119f, 0.03477277f, -0.08997428f, 
    -0.13305211f, -0.23301388f, -0.12929562f, -0.04575209f, 0.14813547f, 0.24632493f, 0.10351840f, 0.01236577f, 
    0.14263505f, 0.31638730f, 0.16061269f, 0.06710004f, 0.07495149f, 0.04806963f, 0.04774192f, 0.02190592f, 
    0.27373424f, 0.13834703f, -0.19677961f, -0.18850900f, 0.10615773f, -0.10189770f, -0.03108363f, -0.01646968f, 
    -0.01222475f, -0.03488994f, 0.02667632f, 0.03450948f, -0.35652328f, -0.35558075f, 0.02738393f, 0.31706861f, 
    0.02313021f, 0.00800274f, 0.01227868f, 0.06267904f, 0.00004867f, 0.06065849f, 0.01846053f, 0.02786432f, 
    0.27821085f, -0.00623490f, 0.05741676f, -0.07852610f, 0.03538242f, 0.21094120f, 0.16386177f, 0.04242638f, 
    -0.03168170f, 0.03205232f, -0.00498287f, 0.00713871f, 0.01122302f, 0.01452246f, -0.00932536f, -0.01418839f, 
    -0.01443252f, -0.01803426f, -0.04828410f, -0.08103461f, -0.13352248f, -0.03277050f, -0.01661654f, -0.00751843f, 
    0.22771531f, 0.20433982f, 0.03021375f, -0.24876855f, 0.06767359f, 0.02969874f, -0.06528915f, 0.20874174f, 
    -0.08731364f, -0.01462513f, -0.02139183f, -0.04631172f, -0.38704225f, -0.33941984f, 0.02278990f, -0.02103963f, 
    -0.04798714f, -0.11093571f, -0.02551227f, -0.05003658f, -0.07691562f, -0.05000406f, -0.31853455f, -0.18904091f, 
    -0.08695777f, 0.06557000f, 0.05170681f, 0.00337126f, -0.09407167f, -0.05556412f, -0.02694540f, 0.01869920f, 
    0.01159816f, 0.02474303f, -0.04489096f, 0.00950245f, 0.12367055f, 0.17410226f, -0.19840516f, 0.00826897f, 
    0.04188550f, -0.02366072f, 0.11696929f, -0.45126399f, -0.16904479f, -0.09661056f, -0.00856517f, -0.03272111f, 
    0.18104739f, 0.08906821f, -0.00695057f, -0.01764930f, 0.09485129f, 0.10881510f, 0.11911181f, 0.01362598f, 
    -0.04985772f, -0.03679880f, -0.03309979f, 0.06423631f, -0.19781844f, -0.33553508f, -0.25789925f, 0.01508634f, 
    0.02670887f, 0.02926164f, -0.11483835f, 0.02285431f, -0.04451583f, -0.06412120f, 0.09813312f, 0.16201258f, 
    0.12219616f, -0.07287829f, -0.08965892f, -0.05314621f, 0.07354952f, 0.06260068f, -0.10648098f, -0.01974409f, 
    -0.08759658f, -0.03257340f, 0.04347840f, -0.02848141f, 0.32605073f, 0.01114362f, -0.21451001f, -0.10660647f, 
    -0.19962326f, 0.13718672f, 0.04310309f, 0.09873091f, 0.06889126f, 0.02837268f, -0.04159395f, -0.11744237f, 
    -0.27088767f, -0.02399582f, -0.08709179f, -0.05000953f, 0.02417506f, 0.02032126f, 0.01869250f, 0.01781852f, 
    -0.04800767f, -0.01104602f, -0.05241574f, -0.09467188f, 0.10273740f, 0.10055535f, -0.06409631f, -0.05105717f, 
    -0.10514701f, -0.10508162f, 0.07773583f, -0.01714641f, -0.11217190f, 0.08191885f, -0.06725802f, -0.00529075f, 
    0.31542408f, 0.20944247f, -0.32896391f, -0.15705775f, 0.09925425f, -0.15941031f, -0.00919573f, 0.06501996f, 
    -0.07750250f, 0.00073634f, 0.00214331f, -0.12161599f, -0.08752488f, 0.02185104f, 0.02486165f, -0.24391884f, 
    0.08411642f, -0.07660468f, -0.01499189f, -0.05529792f, -0.14398088f, 0.05334250f, 0.06577632f, 0.10283652f, 
    -0.07538907f, 0.04143865f, 0.00621016f, 0.09124219f, 0.01313178f, 0.09161483f, -0.19191650f, 0.15772028f, 
    -0.01680054f, -0.03167488f, 0.16618253f, -0.05110735f, 0.17470761f, -0.00601041f, 0.09219181f, -0.16748804f, 
    0.02339612f, -0.05033180f, -0.02431932f, -0.01694500f, -0.00213370f, 0.00739345f, -0.02900033f, 0.02183278f, 
    -0.59868073f, 0.01021987f, -0.11827262f, -0.12723741f, 0.07390502f, 0.03278365f, 0.11146741f, 0.13878907f, 
    -0.01776864f, 0.08875269f, 0.06621480f, -0.03023531f, -0.14704937f, -0.01849120f, -0.04170085f, -0.00649002f, 
    -0.07805084f, -0.16151281f, 0.12456004f, -0.02419752f, 0.01601146f, 0.05931357f, 0.05025535f, -0.04792380f, 
    0.10532625f, -0.02122966f, 0.07132193f, 0.07301162f, 0.07300603f, -0.00291436f, 0.09569933f, -0.15417679f, 
    0.17995489f, 0.12942006f, -0.11071561f, 0.03712340f, -0.19527949f, -0.13576730f, -0.16473474f, -0.08370879f, 
    -0.00049179f, 0.09882323f, 0.01160372f, -0.04481287f, 0.02915939f, 0.17727871f, 0.05106825f, 0.01431946f, 
    0.19564933f, 0.14196073f, 0.10781749f, 0.01864685f, -0.01878516f, 0.00215067f, 0.04283076f, -0.01769751f, 
    0.06642572f, 0.01915468f, 0.00076335f, 0.05891003f, 0.62019610f, -0.27531412f, 0.04094876f, -0.01288949f, 
    -0.01686977f, 0.00069879f, -0.04677267f, -0.12779148f, 0.11823738f, -0.23042214f, -0.12177381f, -0.13406990f, 
    0.07733397f, -0.26350334f, -0.01562525f, -0.20155762f, -0.07317965f, 0.03576739f, 0.20564638f, 0.16181532f, 
    0.04955373f, -0.06894722f, 0.22177397f, -0.13163027f, 0.37264615f, 0.33370313f, 0.36450928f, 0.10922048f, 
    0.22478761f, 0.05776135f, -0.10105988f, -0.00497007f, 0.01345669f, 0.04077106f, -0.02403373f, -0.06391931f, 
    -0.07734036f, 0.01450471f, -0.03767132f, -0.01376829f, 0.01181894f, -0.15228653f, -0.03174535f, 0.17284825f, 
    -0.16617879f, 0.00539595f, 0.03196596f, 0.06882049f, 0.03340400f, 0.24253100f, -0.25082776f, -0.11773578f, 
    -0.01434468f, -0.02358402f, -0.02410351f, 0.14229590f, -0.02043972f, -0.07158384f, -0.05023082f, -0.01748194f, 
    0.06182555f, 0.10586645f, -0.07382823f, -0.03613553f, -0.07068156f, 0.02086832f, -0.02465545f, -0.02489644f, 
    -0.10787261f, 0.06077160f, -0.04922521f, 0.07659682f, 0.00364395f, 0.07106433f, 0.06238756f, 0.01545817f, 
    -0.01004522f, 0.06092942f, 0.02547720f, -0.04930931f, 0.03991161f, -0.02150390f, 0.10505990f, -0.11027902f, 
    0.04963709f, -0.11338055f, -0.02096016f, -0.05796347f, 0.00961855f, 0.09165129f, -0.06128917f, 0.08433133f, 
    -0.07042128f, -0.02628358f, -0.11536277f, 0.00644540f, -0.18169214f, 0.10525599f, -0.16117497f, -0.11080974f, 
    -0.03158173f, -0.00352495f, -0.05853677f, 0.04619803f, -0.20798494f, -0.07669894f, -0.04072753f, -0.07136565f, 
    -0.35077029f, 0.23056988f, -0.25364587f, -0.02018293f, 0.11142294f, 0.04694177f, -0.05772341f, 0.00565880f, 
    -0.05304143f, 0.01492990f, -0.03225950f, 0.06067590f, 0.18664394f, 0.04278866f, 0.06797379f, -0.03304321f, 
    -0.03604981f, 0.04396676f, 0.01197462f, -0.00521554f, -0.02360585f, -0.00368183f, 0.02091510f, -0.04809870f, 
    -0.12734319f, -0.02191387f, 0.15247256f, -0.11987934f, 0.05629509f, 0.07937305f, -0.18557470f, 0.16598471f, 
    -0.18976475f, 0.00206424f, 0.14149837f, -0.03396050f, -0.02966190f, -0.02620105f, 0.02947578f, -0.01763849f, 
    0.14108765f, -0.04983971f, -0.14190851f, 0.10073114f, -0.00203717f, -0.12099436f, 0.20160951f, 0.15834752f, 
    0.02401898f, 0.08443411f, -0.09957707f, -0.01647260f, -0.03847187f, 0.04781086f, -0.00462195f, -0.09010389f, 
    0.16939220f, -0.01943359f, -0.13102725f, 0.18955806f, 0.02453509f, -0.15901688f, -0.06810377f, -0.23472172f, 
    -0.04583312f, -0.23614252f, -0.02019834f, 0.20851067f, 0.03715194f, 0.02014860f, 0.00463892f, 0.08973645f, 
    -0.40908855f, -0.26012605f, -0.45996466f, -0.07693385f, -0.04405200f, -0.13478978f, 0.01674146f, 0.08588546f, 
    0.08122911f, -0.01191454f, 0.02302253f, -0.08685153f, 0.60150623f, 0.19527353f, 0.16001852f, 0.10708979f, 
    -0.01084058f, -0.11488868f, -0.00175974f, -0.01794334f, -0.03813328f, 0.05945777f, 0.11502607f, 0.08465067f, 
    0.00991404f, 0.11949931f, -0.04209174f, -0.02210998f, -0.05834626f, -0.08510150f, 0.00839670f, 0.00457744f, 
    -0.04333177f, -0.01770261f, 0.05281957f, 0.04964674f, 0.01881585f, 0.04094229f, 0.08144145f, 0.07683667f, 
    -0.02806379f, 0.03059617f, 0.04909152f, -0.03852746f, 0.24115722f, 0.09249511f, 0.02319631f, 0.09312180f, 
    0.32460135f, 0.18302158f, 0.06905556f, 0.12278105f, 0.01225311f, -0.03079052f, -0.07029300f, -0.01582703f, 
    0.04083857f, -0.04663388f, 0.08248002f, 0.01853292f, 0.12910327f, 0.05193726f, 0.01899515f, 0.01675477f, 
    0.05162577f, -0.09007015f, -0.04291063f, 0.11727928f, -0.04915942f, -0.03152331f, -0.21004315f, -0.00660299f, 
    0.80847269f, -0.19575907f, -0.24013728f, 0.04206842f, 0.02721442f, -0.07772762f, 0.09361526f, -0.09431691f, 
    0.15537038f, -0.05720778f, 0.09442542f, -0.05292770f, 0.11937638f, -0.00848216f, 0.08628128f, -0.02069436f, 
    0.05024844f, -0.05127988f, 0.03558942f, 0.01522613f, -0.05381517f, -0.09564798f, -0.01427879f, -0.02823049f, 
    -0.52848178f, 0.27293080f, 0.00987289f, 0.04422426f, -0.12655838f, 0.07381757f, 0.03245762f, 0.10664870f, 
    0.11420401f, -0.01009890f, -0.06954189f, -0.07327368f, -0.11670624f, -0.09839196f, -0.04471144f, -0.13284659f, 
    -0.09843124f, -0.03974197f, -0.03296819f, -0.04416818f, -0.04973325f, -0.07290018f, 0.00470573f, 0.05730681f, 
    0.12870936f, -0.24209887f, 0.38999793f, 0.13311882f, -0.07130991f, -0.05888727f, 0.07766069f, 0.06285606f, 
    -0.00088472f, 0.07194829f, 0.10013472f, 0.03548601f, -0.14803812f, -0.00365774f, 0.00309594f, -0.00196119f, 
    0.00916553f, -0.02714119f, 0.08737851f, 0.00737017f, -0.01361073f, 0.01279163f, 0.07739658f, -0.01108842f, 
    0.02739863f, -0.00974107f, -0.09754336f, -0.57369298f, -0.02636819f, -0.29378751f, -0.10183790f, 0.01239286f, 
    0.01379452f, -0.02466021f, -0.00184122f, 0.03029596f, 0.20261301f, -0.10300665f, 0.34292376f, 0.21686986f, 
    0.02884153f, 0.00735625f, -0.01462898f, -0.08781997f, 0.17463113f, 0.11896735f, -0.09689812f, -0.02381769f, 
    0.07012771f, 0.33722264f, -0.14708073f, -0.34132499f, -0.00333191f, 0.02276316f, -0.12526754f, -0.07783698f, 
    0.08106552f, -0.02846731f, -0.14624383f, -0.10252625f, 0.40416026f, -0.05488406f, -0.00912243f, 0.07073051f, 
    -0.11270553f, -0.01685745f, 0.02579392f, -0.09634540f, -0.04947868f, -0.00008281f, 0.19651979f, -0.03666187f, 
    -0.03107469f, 0.21063398f, -0.14048678f, -0.12654975f, 0.00985091f, -0.00723233f, 0.04942956f, -0.02880840f, 
    -0.24421234f, -0.41835865f, -0.23490801f, -0.32311106f, 0.09015121f, 0.01162455f, -0.17645502f, -0.02420423f, 
    -0.12449345f, -0.10414514f, -0.05867839f, 0.04262583f, -0.05106076f, 0.04388385f, -0.07564146f, 0.05773518f, 
    -0.06549956f, -0.05833967f, -0.04796906f, 0.15165408f, 0.07702279f, 0.04956656f, 0.03636129f, 0.06123545f, 
    0.04403814f, -0.05792608f, -0.01318907f, 0.00007376f, -0.03371667f, -0.07134200f, 0.02894104f, -0.03122739f, 
    0.01086410f, 0.19072253f, 0.01425834f, -0.15898280f, -0.05350124f, -0.05441771f, -0.01962601f, 0.03921310f, 
    -0.04136354f, 0.08932543f, 0.03339880f, -0.00073760f, -0.00022363f, 0.04570580f, -0.02759516f, 0.00429623f, 
    -0.02033136f, -0.03885968f, 0.13791925f, -0.14570659f, -0.03677778f, 0.07043717f, 0.12272593f, -0.01140792f, 
    0.01707082f, -0.02311307f, -0.06442200f, 0.02414049f, 0.08286668f, -0.07388534f, -0.05974479f, 0.05527206f, 
    -0.57523406f, -0.24102817f, -0.13989156f, -0.42705628f, 0.00152412f, 0.00116828f, 0.13835388f, -0.10614822f, 
    0.13038559f, -0.01383388f, -0.04693043f, -0.10042740f, -0.19697775f, 0.07526243f, 0.08369930f, 0.00654333f, 
    -0.08525087f, 0.05235557f, 0.05226632f, 0.01218817f, -0.04943420f, 0.07514180f, -0.07439917f, 0.07629043f, 
    -0.27056319f, 0.02807203f, -0.47590300f, -0.09531666f, 0.04204544f, -0.01012516f, 0.02054281f, 0.04374772f, 
    0.04889316f, 0.02325813f, -0.17189914f, -0.16831417f, 0.21727240f, 0.25121340f, 0.11459474f, 0.15214890f, 
    0.02326678f, -0.02759735f, -0.40711308f, -0.30825350f, -0.01345620f, -0.05336270f, -0.12991334f, -0.11872688f, 
    0.05668685f, 0.10340198f, 0.15894583f, 0.11661557f, -0.18990704f, 0.09315431f, -0.18939683f, 0.03412220f, 
    -0.04095517f, -0.03614491f, 0.00398879f, 0.02988823f, 0.20205677f, 0.26417437f, 0.20491977f, 0.15219223f, 
    0.01666501f, -0.02782440f, -0.05080171f, 0.00032252f, -0.01804304f, 0.02999399f, 0.03122241f, 0.04542348f, 
    -0.05534910f, 0.22728552f, 0.31245834f, 0.04700545f, 0.13656680f, 0.02024848f, 0.07322078f, -0.19187802f, 
    -0.02264086f, -0.03051625f, -0.00746515f, -0.11042928f, -0.01849972f, 0.08374581f, -0.02148284f, 0.02530899f, 
    -0.05894439f, 0.00151613f, -0.05967599f, 0.05511169f, 0.04241448f, 0.20601782f, 0.01798580f, -0.01587436f, 
    -0.02623204f, 0.00908400f, 0.04630581f, -0.06312796f, 0.00537817f, -0.02518236f, 0.10416514f, -0.01919864f, 
    0.00706373f, 0.01420622f, -0.00513051f, -0.00974574f, -0.09476283f, 0.09682687f, 0.03439352f, 0.03687629f, 
    -0.05747352f, 0.01887837f, 0.11277857f, -0.03344656f, -0.10067217f, -0.06106512f, 0.00741320f, 0.14444079f, 
    -0.07119681f, 0.01866421f, -0.02893764f, 0.05414220f, 0.01744399f, 0.03849083f, -0.03280110f, -0.05876312f, 
    -0.08651187f, 0.02703339f, 0.00234189f, -0.02496016f, 0.03707357f, -0.26539335f, 0.07103231f, -0.10764766f, 
    0.03570717f, 0.08979794f, 0.01964522f, 0.08468521f, -0.04102657f, 0.03293344f, 0.08510009f, -0.12370001f, 
    -0.01691588f, 0.34830919f, -0.01386667f, 0.15880729f, -0.14645979f, 0.02910254f, 0.08812719f, -0.15069708f, 
    -0.08657295f, 0.08043439f, -0.07032882f, -0.05495468f, 0.21414235f, -0.07529019f, 0.13827743f, -0.07705314f, 
    0.04362585f, -0.00636765f, -0.06553494f, 0.00809608f, -0.35738730f, -0.17509413f, -0.35545847f, -0.07636454f, 
    0.11956824f, -0.05421669f, -0.42043242f, -0.43185869f, -0.02458048f, 0.06480235f, 0.12381053f, 0.02554701f, 
    0.04500084f, 0.21151929f, -0.09059224f, -0.04984024f, 0.12942517f, -0.10107569f, -0.24150789f, -0.00306170f, 
    -0.03994502f, -0.05122395f, 0.07802078f, -0.10044791f, 0.04491014f, -0.11060597f, -0.04507954f, 0.01701410f, 
    0.06683589f, 0.12116914f, -0.00720934f, 0.12442742f, -0.00904758f, -0.02282278f, 0.00554901f, -0.05985500f, 
    0.04880274f, -0.01146659f, 0.10252273f, -0.11171323f, -0.17317252f, -0.00324463f, -0.15979040f, 0.00510492f, 
    -0.06861038f, 0.03835364f, -0.01401459f, 0.10021325f, -0.11875150f, -0.00982797f, -0.01429237f, 0.08717296f, 
    0.03065955f, -0.18859743f, 0.04097090f, 0.22273763f, -0.12337441f, 0.15578440f, 0.15167885f, 0.16075936f, 
    -0.03200020f, -0.04520102f, 0.00373060f, 0.06450757f, 0.16937806f, 0.01678775f, -0.06381097f, -0.13920270f, 
    -0.04232167f, 0.01651247f, -0.31694716f, -0.11864740f, -0.03528344f, 0.02316380f, -0.03031414f, -0.02635803f, 
    0.06764524f, -0.07216652f, 0.00877231f, 0.05967423f, 0.04400132f, 0.02864277f, 0.04893420f, 0.00363211f, 
    0.08449082f, -0.08851240f, 0.02064359f, 0.16986620f, -0.22542679f, -0.05241753f, 0.14367728f, -0.28002024f, 
    0.03418082f, -0.06301348f, -0.07563897f, 0.13338107f, -0.01252533f, 0.02869208f, -0.07154350f, 0.11806840f, 
    0.12899597f, -0.05349966f, -0.12849341f, 0.26659209f, -0.00439848f, -0.06017769f, -0.15283762f, -0.11109349f, 
    -0.01308715f, -0.05429759f, 0.01287572f, 0.05558790f, -0.06284159f, 0.11600006f, -0.14083314f, 0.16301359f, 
    -0.13075379f, 0.03851709f, 0.03974378f, -0.02300187f, -0.05542452f, -0.02454579f, 0.02167210f, -0.06860823f, 
    0.18755163f, 0.02528956f, -0.09876844f, -0.03232939f, 0.07774463f, -0.02368563f, 0.00705640f, -0.05962824f, 
    -0.00664047f, 0.00229461f, 0.01433041f, 0.11853266f, 0.12264896f, 0.23383024f, 0.24895851f, 0.17163686f, 
    -0.05830107f, -0.01006525f, 0.12481890f, -0.11925367f, -0.07840151f, 0.08351013f, 0.03225219f, 0.09595296f, 
    -0.13873695f, -0.14708041f, 0.01865746f, -0.06928775f, -0.00882306f, 0.01152683f, 0.01593329f, 0.00909176f, 
    0.00230684f, -0.02700821f, 0.01548856f, -0.02773011f, -0.01449574f, 0.02304463f, 0.40898165f, 0.00435330f, 
    -0.07932574f, 0.02125079f, 0.02337977f, -0.02338468f, 0.08014812f, 0.10945803f, -0.01082383f, 0.05113545f, 
    0.07683524f, -0.11270650f, 0.35666430f, -0.02055710f, 0.04912009f, 0.02801193f, -0.03284728f, -0.03710887f, 
    0.00946940f, -0.31748292f, -0.07878058f, 0.01545939f, -0.45011175f, -0.04219129f, 0.28445607f, 0.31168199f, 
    -0.00615300f, -0.03055188f, 0.02596543f, -0.04224363f, -0.00033948f, -0.07597244f, -0.03183993f, 0.01018180f, 
    -0.09712084f, 0.01499431f, 0.00050578f, -0.07116870f, -0.00063306f, -0.31694886f, -0.16756061f, 0.06662674f, 
    0.05700379f, -0.03566389f, 0.01619172f, 0.00088098f, -0.20062800f, -0.18874885f, 0.13514459f, 0.28574356f, 
    0.07777185f, -0.08935345f, -0.02522463f, 0.08237685f, 0.00810488f, -0.04629301f, -0.02658554f, 0.00627284f, 
    -0.13412645f, 0.03230798f, -0.06929945f, -0.07569160f, -0.15202403f, -0.20173636f, -0.09917226f, 0.06159703f, 
    -0.03186570f, 0.00438914f, 0.01493531f, -0.01251139f, -0.02193381f, 0.03620430f, 0.05722916f, -0.03070498f, 
    -0.09514503f, 0.11197072f, -0.11521390f, 0.09834640f, -0.02961834f, -0.09049928f, 0.10418084f, -0.17982265f, 
    0.02997257f, 0.00058161f, 0.04265850f, 0.05876293f, -0.09803612f, -0.06813790f, 0.04646942f, -0.17483386f, 
    0.13409783f, 0.10017939f, -0.03421996f, 0.05761892f, 0.29919773f, 0.21961477f, 0.14173777f, 0.33618817f, 
    -0.01132688f, 0.00409217f, 0.03862316f, 0.03507315f, 0.07171775f, 0.00286759f, 0.05172976f, 0.02235942f, 
    -0.15279062f, -0.01512844f, -0.10441181f, 0.02699024f, -0.09508881f, 0.09856956f, -0.02470240f, 0.06534917f, 
    0.00959385f, -0.03883326f, 0.03317286f, 0.00620677f, -0.12306971f, 0.03759853f, 0.10237980f, -0.07794151f, 
    0.05618504f, -0.02154202f, 0.00168300f, 0.07861309f, 0.02588638f, -0.04711717f, 0.00976581f, -0.00912545f, 
    0.25665995f, -0.16354258f, 0.30650973f, 0.29266098f, 0.06234465f, -0.06444395f, -0.02235817f, 0.06285106f, 
    0.09591585f, 0.00220804f, -0.06566001f, -0.05166325f, 0.42123193f, -0.06448062f, 0.05213400f, 0.12056314f, 
    0.13443045f, -0.08887922f, -0.05891448f, -0.02011131f, -0.06598356f, -0.05738558f, 0.09956510f, 0.04908033f, 
    0.04182591f, -0.02766198f, -0.04168681f, 0.03161079f, -0.04453296f, 0.03277398f, -0.07317077f, 0.16120742f, 
    0.05426676f, 0.03838940f, -0.10088892f, 0.07202523f, -0.28456989f, -0.26154834f, 0.09334628f, -0.26624039f, 
    0.13037777f, 0.00835901f, -0.12125923f, -0.15202147f, 0.05313310f, -0.01689318f, -0.05077538f, 0.07618680f, 
    -0.23945907f, 0.64062977f, -0.49953252f, -0.18632686f, 0.00661432f, 0.00928844f, -0.08373873f, 0.07935480f, 
    -0.01677817f, -0.06282113f, 0.07469817f, -0.08996405f, -0.34871861f, -0.02540471f, 0.09898680f, -0.34862825f, 
    0.00866127f, -0.00874561f, 0.06328564f, -0.03339092f, 0.01614039f, 0.01867898f, 0.07003738f, -0.09772798f, 
    -0.12007865f, 0.05119402f, -0.01682099f, 0.16394155f, -0.01602383f, -0.02238483f, -0.09717645f, -0.01921926f, 
    0.11033407f, -0.10287270f, 0.02909636f, 0.08162136f, 0.05235504f, 0.06547145f, -0.08723976f, -0.05478768f, 
    0.02264341f, -0.00187422f, 0.03385047f, -0.03535601f, -0.05214910f, -0.02601010f, 0.13099054f, -0.09784611f, 
    -0.06168119f, 0.15571170f, -0.08681580f, -0.23767842f, 0.00719432f, -0.03618588f, -0.08693215f, 0.06958656f, 
    -0.01748262f, -0.05595904f, 0.01257255f, 0.03143428f, -0.03729745f, -0.06674890f, -0.00936844f, 0.01305194f, 
    0.06164018f, -0.05636815f, -0.01560900f, 0.04602428f, 0.02573107f, -0.08864149f, -0.08931296f, 0.11516469f, 
    -0.25043368f, 0.25515804f, 0.41446522f, -0.18910789f, -0.03303927f, -0.03302516f, -0.01222598f, -0.11054872f, 
    0.01876507f, -0.00878618f, 0.08026039f, -0.14156550f, -0.22995736f, -0.05603218f, 0.02135715f, -0.05235175f, 
    -0.09558876f, 0.03376699f, 0.00713006f, -0.01763051f, -0.00047683f, -0.02881429f, -0.04995560f, -0.01348813f, 
    -0.13192910f, 0.16483663f, -0.26057410f, 0.27377492f, -0.02964386f, 0.12785263f, -0.05042100f, 0.07329126f, 
    -0.00415671f, 0.05398521f, -0.07969058f, -0.05576717f, 0.14342062f, 0.02214408f, -0.22905077f, -0.01883748f, 
    0.05528078f, -0.03474265f, -0.04478116f, 0.13374817f, 0.01102142f, 0.04393564f, 0.01814699f, -0.00611718f, 
    0.00716590f, 0.20065852f, -0.25562933f, 0.07326718f, 0.06883198f, -0.06264608f, 0.03889789f, 0.00443713f, 
    -0.03625699f, 0.09877212f, 0.09875707f, -0.12452891f, 0.03271390f, 0.03603281f, -0.06264009f, 0.14325111f, 
    -0.03943191f, 0.01063798f, 0.08255815f, 0.01581898f, 0.00652760f, 0.04248923f, 0.01585724f, -0.07049377f, 
    -0.23185880f, 0.26770705f, -0.09726456f, -0.25158924f, 0.09728731f, -0.12271709f, -0.08629057f, 0.13411224f, 
    0.02663385f, -0.00589159f, -0.08348825f, 0.08094109f, 0.25034401f, -0.01007616f, 0.05771822f, 0.04673037f, 
    -0.03996710f, -0.01968022f, 0.10974213f, 0.13883026f, -0.00265969f, 0.14402784f, -0.20435864f, 0.03058318f, 
    -0.04996961f, 0.51044858f, 0.41453919f, 0.02393321f, -0.04710976f, -0.04273650f, 0.11658908f, -0.10117610f, 
    -0.16902332f, 0.04241235f, -0.02206086f, 0.04751228f, -0.05599945f, 0.08482733f, -0.01544421f, -0.20518030f, 
    0.06577327f, -0.01685631f, -0.04744315f, 0.15146194f, 0.01713989f, 0.05883410f, 0.03903181f, 0.02739465f, 
    0.07541636f, -0.08985168f, 0.02439864f, 0.15218416f, -0.09274750f, -0.02211115f, 0.03559088f, 0.03223743f, 
    0.02284481f, 0.12052391f, 0.10590506f, 0.14907597f, -0.15734792f, -0.02068058f, -0.02142732f, 0.03918061f, 
    -0.22205885f, -0.00179201f, -0.09089839f, 0.02418544f, -0.03715363f, 0.03025247f, -0.03729169f, 0.00698207f, 
    0.00694921f, 0.06802547f, -0.29913908f, -0.09452882f, -0.01091302f, -0.13510045f, 0.03088277f, 0.03078752f, 
    -0.00028543f, -0.00575159f, -0.20219724f, 0.01248138f, -0.05439281f, -0.06764829f, -0.03800654f, -0.06879746f, 
    -0.06832546f, -0.02514915f, -0.07467530f, 0.05872241f, 0.00824016f, -0.02743220f, 0.00456842f, -0.01256578f, 
    0.00007527f, -0.00890686f, 0.07555505f, 0.10374112f, 0.07934598f, -0.00667568f, 0.04650686f, 0.00707308f, 
    -0.05377443f, 0.04063527f, -0.00064228f, -0.01470396f, -0.01646826f, -0.12371979f, 0.04936007f, -0.00810414f, 
    0.03680733f, -0.00988785f, 0.03226206f, 0.01223111f, 0.06400255f, -0.05888573f, 0.05893771f, 0.06346145f, 
    -0.01939934f, 0.12608136f, -0.17212659f, -0.19258690f, 0.16115215f, 0.07799520f, -0.02196527f, 0.11939660f, 
    0.00793470f, -0.10331952f, 0.05574431f, -0.10551666f, -0.15383144f, -0.10205036f, -0.03288775f, 0.10397033f, 
    0.02319187f, 0.06488372f, 0.02130732f, -0.00980423f, -0.13893622f, -0.16134429f, 0.00977854f, -0.01884880f, 
    -0.10830510f, -0.15407746f, -0.33410710f, 0.10756636f, -0.05445675f, -0.04349669f, -0.07947023f, 0.06438025f, 
    -0.08827493f, -0.13331498f, 0.03612067f, 0.05017631f, -0.18905538f, 0.28126651f, -0.08485433f, 0.32460690f, 
    0.14914280f, -0.13411063f, 0.09363367f, -0.04798892f, -0.01920166f, -0.04468403f, 0.06591485f, 0.09905492f, 
    -0.85436028f, -0.35861495f, -0.25476667f, -0.50522453f, -0.05505764f, 0.01031776f, 0.11200369f, -0.01460796f, 
    0.03036946f, -0.03948782f, 0.01711436f, -0.00207355f, -0.00493319f, 0.13124315f, -0.31353742f, -0.16570921f, 
    0.01763643f, -0.00343676f, 0.00963004f, 0.04325033f, 0.03999015f, 0.02586952f, 0.04791908f, -0.04196417f, 
    -0.34660754f, 0.02524289f, 0.20807241f, 0.14181477f, -0.18015601f, -0.06051238f, 0.12922199f, -0.00329753f, 
    0.01004704f, 0.01595451f, -0.06032410f, -0.04844265f, -0.00842759f, -0.01072098f, -0.03036284f, 0.03252248f, 
    0.04100039f, -0.08840038f, -0.00984716f, -0.00921496f, 0.00485602f, -0.01275572f, -0.05408559f, 0.15232916f, 
    -0.31593969f, -0.37876341f, -0.21516244f, -0.19383742f, -0.05341680f, -0.02844317f, -0.09960831f, 0.06492227f, 
    -0.03963045f, 0.08769767f, 0.00529984f, 0.02311296f, -0.00977158f, -0.00142945f, -0.02413917f, 0.12275445f, 
    -0.00276002f, 0.09808761f, 0.07295223f, -0.03147011f, -0.00574332f, -0.18791412f, 0.10291085f, 0.14490764f, 
    0.00874203f, -0.02047411f, 0.03195221f, 0.04596068f, -0.02035091f, -0.05013216f, 0.09849822f, 0.03773035f, 
    -0.06322751f, -0.03473145f, -0.00906033f, -0.01659820f, -0.47304773f, -0.14158441f, 0.02557240f, 0.07752224f, 
    -0.02351410f, 0.07293282f, -0.21986502f, -0.05550560f, -0.01947335f, -0.07480884f, -0.02008542f, -0.00390387f, 
    -0.25845894f, 0.32413065f, 0.14004777f, 0.12277555f, -0.01923503f, -0.00654057f, 0.07319503f, 0.04470927f, 
    0.02882385f, -0.07497609f, -0.00870720f, -0.03961010f, -0.10150956f, 0.15046728f, 0.04057702f, -0.13690253f, 
    0.02444161f, -0.00417847f, 0.00690031f, -0.13565147f, 0.21365741f, 0.19785501f, 0.06962840f, 0.21163967f, 
    -0.08736105f, 0.47016120f, 0.14606203f, -0.04334515f, -0.07368562f, 0.04282219f, 0.12695901f, -0.13201302f, 
    -0.09905672f, -0.04153541f, -0.21544011f, 0.07412417f, -0.13866068f, -0.18260974f, 0.37263501f, 0.02846933f, 
    0.09075070f, -0.07640616f, -0.15227155f, -0.03106618f, 0.07851828f, 0.00022076f, 0.12716772f, -0.00586052f, 
    -0.07426654f, -0.03214507f, -0.03683323f, 0.01016523f, -0.05826600f, 0.01695559f, 0.03364073f, 0.01688371f, 
    -0.08141152f, -0.00722853f, 0.04014646f, 0.00750790f, 0.01458908f, -0.05421812f, -0.09334752f, 0.02081299f, 
    0.03275164f, -0.05097432f, 0.02017812f, -0.04706799f, 0.11184581f, -0.00458341f, -0.04395299f, 0.06414064f, 
    -0.57951707f, -0.33355603f, -0.25353840f, -0.40099585f, 0.26391083f, 0.00456202f, 0.03019287f, -0.13491595f, 
    -0.06399914f, -0.01234471f, 0.00359462f, -0.06135280f, -0.25534460f, -0.12880203f, -0.17866114f, -0.33992839f, 
    0.00663056f, -0.00085347f, -0.20058531f, -0.26375291f, 0.14515255f, -0.10869688f, -0.04027040f, 0.03111414f, 
    -0.08447742f, 0.05548590f, -0.04649916f, -0.08132286f, -0.11508846f, -0.04242248f, -0.08000959f, -0.06470799f, 
    -0.16267154f, -0.04289927f, -0.09488403f, -0.00284219f, -0.01945849f, -0.09863107f, 0.44572940f, -0.01194499f, 
    -0.08506733f, 0.03588573f, -0.06891198f, -0.00620601f, 0.00683280f, 0.02375680f, -0.00879538f, -0.15190563f, 
    0.15001890f, 0.01310790f, -0.11430640f, 0.00963213f, 0.10471071f, -0.04170660f, -0.11416006f, 0.04652336f, 
    -0.03043044f, 0.04220877f, -0.07619541f, -0.07410590f, 0.32537517f, 0.36090580f, -0.00549842f, -0.08468578f, 
    -0.25072461f, -0.13002273f, -0.03763827f, 0.05022249f, 0.04943269f, 0.01208116f, 0.15346739f, 0.05708025f, 
    0.10698242f, 0.31178251f, -0.18175043f, -0.14354616f, 0.00770608f, -0.17945360f, -0.14464635f, -0.14150336f, 
    -0.20272294f, -0.12826924f, -0.05968671f, -0.05271213f, 0.20818457f, -0.21381725f, 0.01648174f, 0.06927722f, 
    0.13522698f, -0.04070518f, 0.04650581f, -0.14117135f, -0.09256101f, -0.02978044f, 0.02055154f, 0.00599811f, 
    -0.29778647f, -0.30825201f, -0.05294155f, 0.01016639f, -0.17897566f, -0.24324135f, -0.34363908f, -0.13599642f, 
    -0.09315351f, 0.13288893f, 0.12045597f, -0.06440444f, -0.32015350f, 0.59953964f, -0.01645885f, 0.05846375f, 
    0.14982133f, 0.12896915f, 0.06879760f, -0.02614148f, -0.16394149f, 0.09243675f, 0.05224877f, -0.01505194f, 
    -0.01877513f, 0.00581998f, -0.01022713f, 0.20799924f, 0.03012162f, -0.00584227f, 0.01430875f, -0.01995446f, 
    -0.04609066f, 0.09618353f, -0.11135580f, 0.09322823f, 0.18252316f, -0.21634266f, 0.04973826f, 0.20123585f, 
    0.04948138f, -0.11041336f, -0.06598638f, -0.07091113f, -0.00861030f, -0.01811124f, 0.09642216f, 0.13849002f, 
    0.23660424f, 0.11165328f, 0.20769419f, 0.00914363f, 0.11127867f, 0.05369908f, 0.12171435f, 0.10732341f, 
    0.12125625f, 0.00623883f, 0.05290067f, 0.12348585f, 0.03059385f, 0.08481960f, -0.00806079f, -0.26983592f, 
    0.15228011f, -0.00654248f, 0.03255146f, -0.05422695f, -0.06419456f, 0.07286450f, -0.08503204f, 0.03217746f, 
    -0.02685521f, -0.13265353f, -0.16960391f, 0.27207625f, 0.06283446f, -0.15236688f, -0.01925905f, 0.08744553f, 
    0.04517931f, -0.04328710f, -0.01481201f, 0.06970293f, 0.23230451f, -0.06320926f, 0.00365468f, -0.00330700f, 
    0.16331516f, -0.03551750f, -0.06601488f, -0.13224964f, -0.26531523f, 0.24596895f, -0.06351294f, -0.01173457f, 
    -0.18981458f, -0.16275646f, -0.03095034f, 0.21722020f, 0.03255040f, -0.00060446f, 0.03313070f, 0.01703179f, 
    0.01482965f, -0.04789547f, -0.03596804f, 0.02112544f, 0.54787976f, -0.14677894f, -0.04949197f, 0.07038677f, 
    0.12554382f, 0.07935318f, -0.00219635f, -0.02332550f, -0.06875730f, -0.06049151f, -0.01246945f, 0.12876166f, 
    -0.04655178f, 0.02838996f, -0.05478040f, -0.01865536f, -0.05612806f, -0.10399190f, 0.02819932f, -0.05776785f, 
    -0.03392115f, -0.00220815f, -0.12429252f, -0.08344252f, -0.47750172f, -0.04419800f, -0.15451039f, 0.04171586f, 
    -0.09250959f, -0.02462072f, -0.18088864f, -0.04513199f, -0.01300038f, 0.04042981f, 0.15825292f, -0.08246131f, 
    0.00474243f, -0.15898435f, 0.09035527f, 0.26599395f, 0.00468125f, -0.03710273f, -0.01992833f, 0.02325840f, 
    -0.07890183f, -0.00137352f, -0.02597735f, -0.00659280f, 0.55084783f, 0.18498027f, -0.01768560f, -0.27638009f, 
    -0.09216692f, 0.03313695f, -0.08636794f, -0.19175202f, 0.02778866f, -0.04213207f, 0.00402728f, 0.01542914f, 
    -0.22325984f, 0.33039549f, -0.28137979f, -0.16888055f, -0.13091263f, -0.17757896f, 0.07716408f, -0.14925946f, 
    -0.02054412f, 0.12782210f, 0.04365840f, 0.05166347f, 0.02738672f, -0.03365460f, 0.20593405f, 0.07158952f, 
    -0.08535550f, 0.14244628f, 0.05875438f, 0.04930605f, -0.05199454f, -0.03680580f, 0.05798755f, -0.03573198f, 
    -0.38929000f, 0.44803897f, -0.17333795f, 0.17622046f, 0.02435913f, 0.02237311f, 0.06623287f, 0.00595624f, 
    -0.18721037f, 0.02483136f, -0.02969874f, 0.09533221f, -0.51146519f, 0.18416578f, -0.34277201f, 0.13995101f, 
    0.10073270f, 0.17851579f, 0.21585205f, -0.09142184f, 0.04561115f, 0.07390435f, 0.06921738f, -0.01560193f, 
    -0.27374163f, 0.17625833f, -0.17285669f, 0.19775070f, 0.03983692f, 0.02495262f, -0.05235959f, -0.02869209f, 
    -0.05667045f, -0.06519712f, 0.05716912f, 0.12074476f, -0.29963037f, 0.45902473f, -0.28296849f, 0.00470927f, 
    0.05565315f, 0.05740260f, -0.03612572f, -0.07939553f, -0.04739108f, -0.02266162f, -0.14951086f, -0.25619012f, 
    -0.32602832f, -0.04223005f, 0.09798014f, 0.14533497f, -0.00455433f, -0.06779622f, -0.08947088f, -0.05972505f, 
    0.02540110f, -0.05764649f, 0.13299829f, -0.08739268f, -0.12973116f, -0.21795486f, -0.11730241f, -0.00077711f, 
    -0.01897826f, 0.38577291f, -0.15381472f, -0.04588720f, -0.00944300f, 0.07217941f, -0.14875659f, -0.05437580f, 
    -0.47483593f, 0.29296201f, 0.04678071f, 0.21417557f, 0.06629325f, -0.10913182f, 0.11307877f, -0.18867247f, 
    -0.11183827f, -0.10008061f, -0.03222178f, 0.12336234f, -0.04307668f, -0.17409471f, 0.10778182f, 0.11785834f, 
    -0.17151190f, -0.08032621f, -0.04615716f, -0.04682223f, -0.06198853f, 0.04399141f, -0.05588945f, 0.01030413f, 
    -0.07224163f, 0.29891142f, -0.12755430f, -0.71411836f, 0.06325103f, -0.08581807f, -0.01699153f, -0.01372000f, 
    -0.00498863f, -0.08575859f, 0.01236743f, 0.07594907f, 0.17385148f, -0.08077262f, 0.03556200f, -0.06675762f, 
    0.04333971f, -0.05938923f, 0.00986239f, -0.00995706f, 0.01203745f, -0.04115110f, -0.02549783f, 0.05072697f, 
    -0.60105121f, 0.83386356f, -0.44273856f, -0.46576399f, 0.10274111f, 0.25027409f, -0.03938496f, 0.10099024f, 
    -0.18088488f, -0.05459160f, 0.08629368f, -0.03255506f, -0.09157383f, -0.08373834f, -0.20453496f, -0.27987266f, 
    0.03900056f, -0.10864591f, -0.03060019f, 0.02211000f, 0.00714359f, -0.01441169f, -0.02942698f, -0.13895486f, 
    -0.16932781f, 0.01396297f, 0.00011757f, 0.38233986f, -0.07295933f, 0.11983952f, 0.14629376f, -0.19352677f, 
    -0.07196677f, 0.01389607f, -0.00699578f, 0.21157251f, 0.32640344f, 0.46442807f, -0.28580680f, 0.03934789f, 
    -0.01140662f, -0.10488269f, -0.00811445f, -0.00314190f, -0.16074108f, -0.05545464f, -0.11365216f, -0.08230980f, 
    -0.06107373f, -0.28162718f, -0.06808536f, 0.25513449f, 0.13797516f, 0.06680024f, 0.02073600f, 0.04294933f, 
    0.06138550f, -0.02064358f, 0.25113732f, -0.05169474f, -0.54240102f, 0.44988316f, -0.39426398f, 0.42014602f, 
    0.04490194f, -0.16222970f, -0.00330475f, -0.06596071f, -0.03318629f, -0.08240274f, 0.15781078f, -0.07136331f, 
    -0.12895329f, 0.25827280f, -0.15314384f, -0.13585626f, 0.02452585f, 0.06159801f, -0.01921750f, 0.07263202f, 
    -0.03592043f, 0.08785420f, -0.07756393f, -0.04858736f, 0.02200174f, -0.18563256f, 0.17615408f, 0.08355173f, 
    -0.13830438f, 0.01371823f, -0.03613997f, -0.02872211f, 0.14180757f, 0.02996325f, -0.00718763f, 0.00214628f, 
    -0.19161311f, 0.10868913f, -0.00473327f, -0.16065654f, -0.01879054f, -0.11508609f, 0.06039377f, -0.10254502f, 
    -0.02534153f, 0.24947259f, 0.03475296f, -0.01136710f, 0.10544250f, -0.04251558f, -0.07267459f, -0.02945502f, 
    0.13022293f, 0.13935986f, 0.02738816f, -0.02802317f, 0.07720453f, -0.03531830f, 0.01916935f, -0.04009556f, 
    -0.03923593f, -0.18155423f, 0.00189239f, -0.12768941f, -0.08159567f, -0.09426400f, -0.04055462f, -0.18594806f, 
    0.04807159f, 0.02559344f, -0.08509128f, 0.04876786f, 0.00620620f, 0.13836260f, -0.13036102f, -0.25045791f, 
    -0.09420202f, 0.07892587f, 0.04447786f, 0.09144832f, 0.16520326f, 0.08756334f, -0.11021466f, 0.04196113f, 
    0.05440421f, -0.02291559f, -0.16454586f, -0.13603519f, -0.03713960f, 0.04577865f, -0.11966150f, -0.27517477f, 
    -0.08900371f, 0.11723831f, 0.07574793f, -0.14958565f, 0.24411255f, 0.07427549f, -0.06166827f, -0.19094439f, 
    0.20257695f, 0.14109232f, 0.03962839f, -0.05204393f, -0.05005969f, 0.08125015f, 0.09061085f, 0.03542019f, 
    -0.11778566f, 0.09588076f, -0.18454573f, -0.18073347f, 0.01684540f, -0.00397453f, -0.03832335f, -0.14733045f, 
    -0.10460117f, 0.00237519f, -0.03926322f, -0.05596958f, 0.22650021f, -0.16786563f, -0.06547341f, 0.09353084f, 
    0.00312881f, -0.03974724f, -0.02621183f, -0.07369005f, -0.00271290f, 0.06693789f, 0.05348136f, 0.15218495f, 
    -0.08859672f, -0.10384241f, 0.01477421f, 0.12597513f, 0.08419101f, 0.06690262f, 0.09047084f, 0.07922368f, 
    0.04507703f, -0.03318747f, 0.03697219f, -0.12520589f, 0.14271553f, 0.12351731f, 0.11839424f, -0.07296409f, 
    -0.20786726f, 0.13814364f, -0.13516846f, 0.00718724f, 0.02698904f, 0.05083363f, 0.04172904f, -0.02398295f, 
    0.10447794f, -0.11507194f, -0.16825512f, 0.06124769f, 0.05511980f, -0.06968793f, 0.00871931f, 0.03840950f, 
    0.04067829f, 0.03003556f, 0.02629462f, 0.02968892f, 0.07884901f, 0.51792169f, -0.53418469f, 0.14328077f, 
    -0.15412085f, 0.12464933f, -0.10612802f, 0.18799683f, 0.02251388f, -0.18232815f, 0.23232390f, 0.14899388f, 
    -0.06634730f, -0.08545548f, -0.07024333f, 0.06766401f, 0.10342007f, 0.03588767f, 0.04158713f, 0.13965261f, 
    -0.05771380f, 0.00510337f, -0.01076657f, -0.02153840f, 0.00548638f, -0.47417170f, 0.04119716f, -0.04909360f, 
    -0.07747456f, -0.07387506f, -0.23161326f, -0.00121184f, -0.07727624f, -0.12834994f, -0.01520734f, 0.02688303f, 
    0.26202390f, -0.14294362f, 0.00139675f, -0.05473468f, -0.04376870f, -0.06443100f, -0.12317806f, -0.01206258f, 
    -0.04070497f, -0.00350551f, -0.00277748f, -0.08135401f, -0.19929345f, -0.00888814f, -0.12413554f, 0.33040342f, 
    0.02833990f, 0.06913104f, 0.04365852f, 0.00966885f, -0.02478594f, -0.02464074f, 0.02190849f, -0.08802120f, 
    0.10341009f, -0.03778285f, -0.07851190f, 0.16263205f, 0.04736082f, -0.04498810f, -0.09072017f, 0.00617744f, 
    0.04249659f, 0.07417677f, 0.06958477f, 0.04689797f, -0.15817069f, -0.09594591f, 0.12027026f, 0.09136529f, 
    -0.09193511f, 0.04457527f, -0.05087878f, -0.04616737f, 0.05273785f, 0.15100895f, -0.00048390f, -0.00443015f, 
    -0.13808449f, -0.06557092f, 0.03402233f, 0.16965899f, 0.02824083f, 0.04236411f, -0.04284144f, -0.00282537f, 
    -0.01805217f, 0.09419551f, -0.06342946f, 0.04875049f, 0.09895910f, 0.14878672f, -0.27382022f, -0.19997378f, 
    0.23135890f, 0.06231371f, 0.01828788f, 0.02061856f, -0.15138268f, -0.09559000f, -0.08015242f, -0.07296899f, 
    -0.24129260f, -0.05336730f, 0.00936558f, -0.39685476f, 0.06195438f, -0.27010626f, 0.06426792f, -0.15667751f, 
    -0.11622508f, -0.05068736f, -0.19654207f, -0.01747919f, -0.03870066f, -0.13617271f, -0.18515794f, 0.12498674f, 
    0.07615950f, 0.04154132f, 0.02098235f, 0.00279380f, 0.03058713f, -0.07245733f, -0.00673001f, -0.09799553f, 
    -0.01081811f, -0.03397068f, 0.09279741f, 0.22021002f, 0.02951017f, 0.08662091f, 0.08074728f, 0.09037329f, 
    -0.08837692f, -0.04346256f, -0.03265144f, -0.09394010f, -0.28957883f, 0.06748711f, 0.00685076f, 0.43506569f, 
    -0.23435308f, -0.14591491f, 0.20620275f, 0.00878872f, 0.18347642f, 0.15487061f, -0.13986391f, 0.05032444f, 
    0.03232037f, 0.01408719f, 0.06183635f, -0.09628333f, -0.02921667f, 0.00164136f, 0.08334734f, 0.00077780f, 
    0.01361839f, -0.12102605f, -0.07826367f, 0.05687920f, 0.01290224f, 0.07437474f, -0.18271984f, 0.24551995f, 
    -0.00205215f, 0.07444131f, -0.27123931f, -0.00254848f, 0.09076224f, -0.06746420f, -0.04573380f, -0.01891147f, 
    0.02368860f, 0.09811790f, -0.00473298f, 0.05470715f, -0.11573080f, 0.03800971f, 0.02656673f, -0.11176129f, 
    -0.14891830f, 0.08136580f, -0.05215936f, -0.02843971f, -0.02961767f, -0.21261461f, 0.07548212f, 0.04799424f, 
    0.14721231f, 0.10766454f, -0.07413837f, 0.02989898f, 0.06336858f, -0.05912323f, -0.04592695f, 0.01284985f, 
    -0.00161135f, -0.06332935f, -0.13071378f, -0.07694380f, -0.15186626f, 0.03428980f, -0.00134033f, -0.01388685f, 
    -0.14388977f, -0.12371104f, -0.01463834f, -0.27085182f, 0.12250418f, 0.12895119f, 0.05775315f, 0.06269739f, 
    -0.06654920f, -0.02653923f, 0.00278796f, 0.08812898f, 0.07194648f, -0.08893000f, -0.04974321f, 0.02329240f, 
    0.04112165f, 0.07656668f, -0.00187642f, 0.09726498f, 0.04303177f, 0.08582616f, 0.03256617f, 0.02321080f, 
    0.05744133f, 0.04449094f, -0.05982403f, -0.03420979f, -0.17145589f, -0.32579032f, -0.11068363f, -0.11550625f, 
    -0.08030954f, 0.02145697f, 0.00535460f, 0.11164126f, 0.14952084f, 0.05162135f, 0.05106717f, 0.18352014f, 
    0.19834639f, 0.19143257f, 0.01876494f, 0.19105689f, -0.08596759f, -0.02790122f, -0.05167147f, -0.27156785f, 
    -0.22158307f, -0.10559689f, 0.02470866f, -0.04074791f, -0.12847334f, -0.11016516f, -0.08473245f, 0.08610573f, 
    -0.00248854f, -0.06559063f, 0.11191280f, -0.04166761f, 0.01426214f, 0.00667147f, 0.04007851f, 0.10103291f, 
    -0.01076975f, -0.00661086f, 0.16566409f, 0.26930389f, 0.10004886f, 0.11905559f, -0.05957340f, -0.05327548f, 
    0.08579206f, 0.05631180f, 0.11151641f, 0.09041011f, 0.12047303f, -0.02426904f, -0.15088597f, 0.02964552f, 
    -0.12320423f, 0.01197599f, -0.02953081f, -0.14951023f, -0.00642295f, -0.06647202f, -0.02617087f, -0.09391995f, 
    -0.02289155f, -0.01865112f, 0.13586177f, 0.11833859f, -0.03714750f, 0.09745532f, 0.07467620f, 0.10016360f, 
    -0.07274672f, 0.01209932f, 0.01841681f, -0.03270706f, 0.04966216f, 0.06574991f, -0.32963473f, 0.03114125f, 
    -0.00308491f, -0.01853155f, 0.13493487f, 0.00096131f, -0.04892284f, -0.07339176f, -0.03438772f, -0.10012398f, 
    -0.04989897f, 0.10010422f, 0.07520131f, 0.13804899f, 0.08867799f, -0.07944557f, 0.00379204f, -0.18790317f, 
    0.22094014f, 0.10286600f, 0.14538006f, 0.05745154f, -0.05585404f, 0.17381823f, 0.04851909f, 0.02032839f, 
    -0.02194732f, -0.08184822f, 0.02512978f, 0.07914223f, 0.05220257f, -0.02829639f, -0.06680603f, 0.04020719f, 
    0.05643610f, -0.09460274f, 0.25706318f, 0.07198323f, -0.14377779f, 0.00549294f, -0.10053957f, 0.08146922f, 
    -0.00029367f, 0.01940563f, -0.01834377f, -0.06910251f, -0.01068666f, -0.00784801f, -0.07817858f, 0.03198148f, 
    0.05048411f, 0.02473650f, -0.00479360f, 0.04516291f, 0.05080842f, 0.00590281f, -0.07117546f, -0.02938884f, 
    -0.03922672f, 0.24554719f, 0.05660484f, 0.07178191f, -0.11750683f, -0.08804046f, -0.02609242f, -0.11377355f, 
    0.05530607f, -0.00463851f, 0.02585966f, 0.01937914f, -0.01597399f, 0.06857464f, -0.20547663f, 0.11261235f, 
    0.13216890f, -0.10964660f, -0.03412067f, -0.29697427f, 0.00046626f, 0.06037780f, -0.01981964f, 0.02705314f, 
    0.08885028f, -0.26588696f, 0.04886583f, 0.00349515f, -0.16986048f, 0.04853581f, -0.06563509f, 0.00943045f, 
    -0.20108193f, -0.17807712f, -0.12957886f, -0.06384033f, 0.00560760f, 0.19439046f, -0.02902892f, 0.26313034f, 
    0.00761912f, 0.06748262f, -0.04502134f, -0.07840385f, 0.01290483f, 0.02877177f, -0.10697647f, -0.05061839f, 
    0.16002735f, -0.37951148f, 0.39475492f, 0.13514104f, 0.03587893f, 0.08233827f, 0.02093173f, -0.08371858f, 
    -0.07759068f, -0.02742875f, -0.01747623f, 0.09600343f, -0.07594798f, -0.13757759f, -0.19495130f, -0.31120756f, 
    0.06788369f, 0.04423887f, -0.03260927f, 0.02209753f, 0.04019459f, 0.04312943f, -0.04836629f, -0.04535499f, 
    0.09521186f, -0.11613877f, 0.21828593f, -0.01179009f, 0.05387958f, 0.00576124f, 0.13085279f, -0.16667314f, 
    0.05253419f, -0.05641216f, 0.10518315f, 0.05166811f, -0.04420817f, -0.23831578f, 0.07758572f, -0.15017568f, 
    0.06465419f, 0.03494423f, 0.03102627f, 0.11771905f, -0.07342210f, -0.04513290f, -0.03229103f, -0.18406732f, 
    -0.15132786f, -0.36029831f, -0.53884143f, 0.11784756f, 0.07554378f, 0.00181811f, 0.04114836f, -0.02722204f, 
    0.03050282f, 0.09529934f, -0.06029445f, 0.01509423f, 0.06642386f, 0.11410619f, 0.02598846f, -0.15452093f, 
    0.08052883f, 0.00486896f, 0.13674735f, -0.01066169f, 0.11805517f, -0.04954841f, 0.00557488f, -0.08303373f, 
    -0.31065932f, 0.00404414f, -0.00398774f, -0.16303995f, -0.07599055f, -0.04020558f, -0.26760325f, -0.11143740f, 
    -0.07101559f, -0.05956453f, -0.09905048f, 0.02427685f, -0.09071374f, 0.00437400f, 0.00656490f, 0.18268278f, 
    0.15514731f, 0.02152620f, -0.02295209f, 0.06112001f, -0.03236614f, 0.03639380f, -0.08346208f, -0.04393210f, 
    -0.09573618f, -0.27240744f, 0.00978400f, -0.01163582f, 0.03963165f, 0.01108018f, -0.04705921f, -0.07431041f, 
    -0.09200083f, 0.02924431f, -0.00555469f, 0.01958243f, 0.10944889f, -0.14554405f, 0.02193564f, 0.28715348f, 
    -0.05235052f, -0.19690809f, -0.04059492f, -0.12318441f, 0.04786322f, 0.04431607f, -0.03710222f, -0.05985905f, 
    0.33653706f, -0.67937195f, 0.18772928f, -0.19099161f, 0.02822646f, 0.10658780f, 0.03220792f, -0.06095224f, 
    -0.01241624f, 0.05342212f, -0.10142768f, -0.08198983f, 0.07501049f, -0.23291770f, 0.14191437f, -0.07268625f, 
    -0.24902956f, 0.02156197f, -0.13547179f, -0.02425519f, -0.02030331f, -0.01890043f, -0.10906974f, 0.03045602f, 
    0.14856444f, -0.10866456f, 0.06417333f, 0.02706369f, 0.26743919f, -0.09927835f, -0.19625781f, -0.05374385f, 
    -0.01437232f, -0.02852568f, 0.01853256f, -0.10630200f, -0.30475202f, -0.61881769f, -0.02173207f, -0.16023566f, 
    0.02228934f, -0.00032851f, 0.00739492f, -0.05301319f, 0.07039399f, -0.08982565f, 0.00759680f, -0.28704795f, 
    -0.01954680f, 0.17881633f, 0.13103925f, 0.22649576f, -0.07391915f, -0.16528440f, 0.10915820f, 0.08771420f, 
    -0.08076132f, -0.01982658f, -0.13618653f, 0.03458883f, 0.03668100f, -0.24075955f, -0.00265512f, -0.06194889f, 
    0.00577257f, 0.15887694f, -0.14316279f, -0.00707206f, -0.13731988f, -0.05121105f, -0.13258915f, 0.09883019f, 
    0.09536019f, -0.27316830f, 0.03612421f, -0.01879955f, -0.03357492f, -0.00360180f, 0.01961834f, 0.00396884f, 
    0.20410612f, 0.21978167f, -0.00265594f, 0.26496318f, -0.02595811f, 0.22827862f, 0.11440082f, 0.21405804f, 
    0.03493454f, 0.08104647f, 0.08242525f, 0.07081867f, -0.00938088f, -0.10770377f, 0.02926674f, -0.07434316f, 
    0.15222418f, 0.10032100f, 0.03267565f, 0.08962262f, -0.04722914f, -0.02599072f, -0.02561564f, -0.04836721f, 
    -0.11945592f, -0.10570113f, -0.13529131f, -0.12102239f, 0.06393442f, 0.05747690f, 0.02868538f, 0.06663990f, 
    -0.18349706f, -0.17197303f, -0.29173994f, 0.04687441f, 0.08352809f, 0.01201252f, 0.01337830f, -0.03784719f, 
    -0.13681161f, -0.03467235f, -0.12727889f, 0.00958644f, -0.04226578f, -0.03767103f, -0.02421813f, 0.05240303f, 
    -0.08694966f, -0.04076304f, -0.17454955f, 0.01296221f, 0.16329974f, -0.24084710f, -0.13169390f, 0.15455504f, 
    0.00182610f, -0.14408672f, 0.00514432f, -0.13662212f, 0.03030465f, 0.00536115f, 0.06102597f, 0.01268527f, 
    -0.02995660f, -0.24541844f, -0.01795413f, -0.01243291f, -0.29316592f, 0.01878185f, -0.06133903f, 0.04771721f, 
    0.03173302f, -0.11225192f, -0.13169256f, 0.14218989f, 0.24642217f, -0.01868025f, -0.13004595f, -0.01138296f, 
    -0.11480785f, 0.03502777f, 0.01379154f, 0.08304015f, -0.04516589f, -0.25658548f, -0.14934695f, -0.17020500f, 
    -0.15313815f, -0.03276298f, 0.00437153f, 0.16993098f, -0.11151285f, -0.01568010f, -0.05686392f, -0.06841044f, 
    -0.17398976f, 0.09987403f, 0.17356579f, 0.15417145f, -0.16681126f, -0.15186837f, 0.04216084f, 0.10398404f, 
    -0.02455112f, 0.04188805f, -0.09786660f, 0.01387034f, 0.03738251f, 0.03201109f, 0.01502689f, 0.06622232f, 
    0.10192510f, 0.18871579f, 0.18602020f, 0.18636310f, -0.12178487f, -0.07508133f, 0.01516408f, 0.14245513f, 
    0.02961148f, 0.04400919f, -0.00341554f, 0.00628612f, 0.04785995f, -0.39449647f, -0.04681184f, 0.06229128f, 
    0.08033790f, 0.02356723f, 0.04868528f, -0.00159953f, 0.13269664f, 0.03423736f, 0.05836094f, 0.07441281f, 
    -0.21498202f, -0.06212711f, 0.03640747f, -0.00314620f, -0.13138510f, 0.09515764f, -0.11523603f, -0.05617574f, 
    0.00818188f, -0.00075118f, 0.01748172f, 0.05626960f, 0.07925621f, -0.05222670f, 0.08572956f, 0.07542071f, 
    -0.00134449f, 0.05538234f, 0.04700310f, -0.03737272f, -0.15460332f, 0.10100655f, -0.27898204f, 0.22342463f, 
    0.10144099f, 0.18281452f, 0.19895884f, 0.18055086f, -0.06600065f, -0.01240909f, -0.05804472f, -0.04993811f, 
    0.07008803f, 0.05015816f, -0.00022570f, 0.14681524f, -0.01173287f, -0.05408008f, -0.01463241f, -0.08456289f, 
    -0.03734571f, 0.02758637f, -0.07301142f, -0.00819363f, -0.12641853f, -0.13636839f, -0.03017084f, -0.09780344f, 
    0.01016353f, 0.00150148f, 0.03515313f, -0.04614525f, -0.04980776f, -0.01417202f, -0.09820786f, 0.06869354f, 
    0.07131022f, -0.04097181f, -0.02766902f, -0.10284385f, 0.16579209f, -0.04023086f, 0.16619112f, 0.07017117f, 
    -0.02240651f, 0.07270743f, -0.04648872f, 0.14277069f, 0.03365652f, 0.06627579f, -0.02496681f, -0.01488204f, 
    -0.04433222f, -0.07025309f, 0.10719392f, 0.01425545f, -0.17023277f, -0.07182951f, -0.17442554f, -0.09019022f, 
    0.03609936f, -0.01045717f, -0.01989550f, -0.00513178f, -0.02674434f, 0.09630288f, -0.10896458f, -0.04220586f, 
    0.04484182f, -0.10339627f, -0.01357092f, -0.02944952f, -0.05966310f, 0.04814884f, 0.06997776f, 0.25269365f, 
    0.21794581f, 0.08267445f, 0.13123918f, 0.12885483f, 0.00039363f, -0.07148106f, -0.02340901f, -0.08444221f, 
    -0.03754396f, -0.16839465f, -0.02051078f, -0.01546540f, -0.27725604f, -0.13182764f, 0.29800373f, -0.06763241f, 
    -0.01359846f, 0.04042151f, 0.01203817f, 0.05859867f, -0.04306375f, 0.03301739f, -0.02879132f, 0.05149973f, 
    0.04850082f, -0.13477945f, 0.00837355f, 0.06019916f, 0.02115814f, 0.08232233f, 0.03009628f, 0.01945320f, 
    0.03104127f, -0.01687228f, -0.12819310f, -0.02508143f, 0.03887225f, -0.00782468f, 0.17833787f, 0.00404741f, 
    -0.17678583f, 0.05567464f, 0.04804648f, -0.03723527f, 0.15854564f, -0.02991867f, 0.04762736f, -0.07543316f, 
    0.07624101f, 0.15739675f, 0.11957480f, 0.19281915f, 0.04321617f, 0.00173344f, -0.03883114f, 0.07655409f, 
    -0.06818307f, -0.03773348f, -0.09310427f, 0.03744559f, 0.25551647f, 0.31740749f, 0.04489420f, 0.08029964f, 
    0.02198733f, 0.13586700f, 0.14555915f, -0.05770313f, 0.07206246f, -0.00349227f, -0.05332910f, 0.01195859f, 
    0.07320995f, -0.09410480f, -0.01531266f, 0.00576502f, 0.09178722f, -0.18570384f, 0.11842646f, -0.07807887f, 
    -0.09269629f, 0.14809057f, -0.04040674f, 0.09929848f, -0.08159668f, 0.07932707f, -0.29831263f, 0.21291494f, 
    0.15625693f, 0.06755017f, 0.14709753f, -0.09802565f, 0.04659799f, 0.05751713f, 0.07369772f, 0.11107687f, 
    0.10667768f, -0.20611569f, 0.12053619f, 0.07193222f, -0.03847467f, -0.05254514f, -0.05637823f, 0.02130909f, 
    0.13345358f, -0.18922381f, -0.06483173f, 0.00849036f, -0.16836528f, -0.27621982f, 0.18357651f, 0.08231383f, 
    0.16229430f, 0.14995056f, -0.11779470f, 0.05091003f, -0.02184298f, 0.00342168f, -0.03618331f, 0.07442978f, 
    -0.16374387f, -0.14396244f, 0.06773115f, 0.11966472f, 0.04603924f, -0.06827325f, -0.12964723f, 0.08589340f, 
    0.08101308f, -0.14115283f, 0.02982013f, 0.16011851f, -0.31929755f, -0.05947181f, -0.26567855f, -0.08502803f, 
    0.01573158f, -0.01559673f, -0.03137668f, 0.13458815f, 0.04234014f, -0.09442564f, -0.07296366f, -0.13324435f, 
    -0.19103266f, -0.11824637f, -0.08661104f, 0.13004419f, 0.06572352f, -0.05675232f, -0.11170199f, 0.00381707f, 
    0.00898836f, -0.08691410f, 0.06840305f, 0.13895620f, -0.11733680f, -0.14897341f, -0.22873552f, -0.11427336f, 
    0.05556432f, -0.03432170f, 0.02955718f, 0.04323766f, -0.19244336f, -0.11411445f, -0.15055478f, -0.31673366f, 
    -0.15243454f, 0.05319596f, 0.06222251f, -0.22791244f, 0.05727817f, 0.00894949f, -0.18406539f, 0.05592386f, 
    0.14023575f, 0.16644484f, -0.08920284f, -0.07036419f, -0.30493373f, 0.23750006f, -0.00950166f, -0.19034526f, 
    -0.06197051f, -0.03684349f, -0.03450397f, 0.03770184f, 0.03443348f, 0.03206468f, -0.01251707f, 0.05918458f, 
    0.07298476f, -0.01632772f, 0.08732273f, 0.01214297f, -0.02309585f, -0.08315349f, 0.04607377f, -0.12489947f, 
    -0.03129820f, -0.04924165f, -0.07544082f, -0.10514084f, -0.42942274f, -0.17744547f, 0.22562243f, -0.02160189f, 
    0.04393651f, 0.05926926f, 0.03235502f, -0.00686807f, 0.11814934f, 0.06936550f, 0.09150998f, 0.08660183f, 
    -0.05506079f, -0.11105128f, 0.07584444f, -0.09818394f, 0.23058128f, 0.04235878f, -0.01691366f, -0.04214762f, 
    0.12308207f, -0.07060889f, 0.01057809f, -0.03852535f, -0.26908627f, -0.03421434f, 0.07531393f, -0.14988506f, 
    0.07358201f, -0.14913538f, -0.08150326f, 0.08726633f, 0.04088198f, -0.15134503f, -0.03933068f, 0.13291119f, 
    0.09954024f, 0.09748823f, -0.12118188f, -0.12245560f, -0.00319566f, 0.03978360f, 0.01512365f, -0.05325926f, 
    -0.16431597f, -0.15512559f, 0.14548092f, -0.20940293f, -0.57535636f, -0.47320199f, -0.09968736f, -0.05099184f, 
    0.01877568f, -0.08245987f, 0.02059075f, 0.06826075f, 0.07342907f, 0.03064632f, 0.14352374f, -0.14987288f, 
    0.38597295f, -0.03505184f, 0.21263835f, -0.05405669f, 0.07145646f, 0.12565191f, 0.03750793f, 0.00958328f, 
    0.10452713f, -0.02006234f, 0.04842393f, 0.02829134f, -0.05910609f, -0.04469763f, -0.30282933f, 0.16281584f, 
    0.09267110f, -0.04673259f, 0.05718417f, -0.08828935f, 0.07791631f, 0.03134179f, -0.03063028f, 0.17808767f, 
    0.03421186f, 0.09139156f, -0.09350259f, -0.16742742f, 0.08516526f, -0.06258387f, 0.18516600f, 0.07179131f, 
    0.11739407f, 0.01538176f, -0.11484569f, -0.09240042f, -0.47370881f, 0.06767405f, 0.13018505f, 0.00839963f, 
    -0.09195839f, 0.00714131f, -0.03782654f, 0.24630642f, -0.00760289f, 0.10651414f, -0.07922285f, -0.13625805f, 
    -0.03848094f, -0.12560262f, 0.25159407f, 0.02685966f, 0.08969710f, -0.07083979f, -0.02383073f, 0.15443689f, 
    -0.03441364f, -0.14336316f, 0.02947628f, -0.03404598f, -0.07176618f, 0.14756189f, 0.13771473f, 0.03030541f, 
    0.04612450f, 0.00866143f, 0.03536627f, 0.06752998f, -0.09892908f, -0.06654891f, -0.02808571f, -0.10924170f, 
    0.05564065f, -0.04791437f, 0.37686515f, -0.31364274f, -0.11146768f, -0.02389969f, 0.03123539f, -0.08107851f, 
    -0.00512322f, 0.03370966f, 0.01420999f, -0.02650620f, -0.17697597f, -0.12230546f, -0.32852960f, -0.15693942f, 
    0.02666524f, 0.10170463f, -0.04668372f, 0.04793905f, 0.07655350f, -0.06971030f, -0.06616955f, -0.06745052f, 
    0.07243105f, -0.12778340f, 0.06489351f, -0.10724208f, 0.12973157f, -0.00915672f, 0.00585032f, 0.02823031f, 
    -0.12416577f, 0.02528322f, -0.13069823f, -0.09501282f, 0.25694329f, -0.24452655f, 0.07037543f, 0.08029768f, 
    -0.00797463f, 0.02005886f, -0.13198064f, -0.07441232f, -0.14632267f, -0.13769023f, 0.02826343f, 0.20660141f, 
    -0.07171983f, -0.14379852f, -0.24385819f, 0.01862885f, -0.00729501f, 0.02510189f, 0.06302726f, -0.00374356f, 
    -0.03440152f, 0.08348134f, -0.10724444f, 0.01012555f, 0.13805257f, -0.00077837f, -0.22801529f, 0.01884156f, 
    -0.02489921f, -0.02793449f, 0.01621555f, -0.11882067f, 0.13381745f, 0.02823703f, 0.26240182f, 0.00247212f, 
    -0.09749219f, 0.00302688f, -0.23663932f, -0.24598405f, -0.03220114f, 0.22372811f, -0.07521118f, 0.04838055f, 
    0.09088945f, 0.19433877f, -0.00893683f, -0.01502541f, 0.12856010f, 0.05086898f, -0.11118863f, -0.26381242f, 
    -0.07092003f, 0.10447859f, -0.16196731f, -0.04191508f, 0.06990546f, 0.08865125f, 0.17156236f, 0.09136089f, 
    0.08677840f, -0.45261467f, 0.28078315f, 0.16483080f, 0.05472127f, -0.08439243f, -0.00074390f, -0.00978082f, 
    -0.02610457f, 0.05223146f, 0.01429606f, 0.02805386f, -0.12960449f, 0.13707159f, 0.00193104f, 0.02267196f, 
    0.11442044f, 0.13563275f, 0.08108483f, 0.17189603f, -0.03742419f, 0.10622243f, 0.05593159f, 0.04569860f, 
    -0.10434484f, 0.01578129f, -0.01030514f, 0.24726874f, -0.04825534f, -0.08951029f, -0.06780472f, -0.00060094f, 
    0.11186099f, -0.10170146f, -0.10170893f, -0.11471550f, 0.12020166f, -0.01951196f, -0.05613839f, 0.11595877f, 
    0.03438140f, 0.07951766f, 0.09636854f, -0.07523484f, 0.03577839f, 0.07877568f, -0.04150375f, 0.07505783f, 
    0.10190009f, 0.13952175f, 0.02076440f, -0.05903900f, -0.12299759f, 0.00121903f, 0.04454853f, 0.34568995f, 
    0.05142505f, 0.00735670f, -0.03861817f, -0.14886907f, -0.05341837f, 0.19457722f, -0.30729753f, -0.10225966f, 
    0.04462598f, -0.02174543f, -0.10871388f, 0.11611024f, -0.18278621f, -0.02502734f, 0.14400133f, 0.28289327f, 
    0.00095077f, -0.10614866f, -0.21109495f, -0.51559716f, -0.08980757f, 0.05585255f, -0.10036284f, -0.02721614f, 
    -0.07021458f, -0.13165371f, 0.09965562f, -0.06442588f, 0.03199495f, 0.03080628f, -0.03763143f, -0.23581912f, 
    0.11195239f, -0.11143351f, 0.06207191f, 0.06112028f, 0.15747140f, 0.08579248f, -0.24808183f, -0.09417473f, 
    -0.08167719f, -0.29938704f, 0.04847202f, 0.08967719f, 0.03372622f, 0.03942280f, -0.04330466f, 0.06987316f, 
    -0.07724266f, -0.25877884f, -0.00913924f, -0.32419011f, -0.22083876f, -0.13695012f, 0.14774393f, -0.04357095f, 
    0.08422495f, -0.00488901f, -0.02186666f, -0.05530062f, -0.00991468f, -0.03744650f, 0.09393580f, 0.04149934f, 
    -0.02643262f, 0.04204496f, 0.04847982f, -0.28007957f, -0.14606896f, 0.07461753f, -0.12229176f, -0.22010033f, 
    0.08896541f, 0.00808693f, 0.09032096f, 0.14337686f, -0.05885138f, 0.05268127f, -0.06630632f, -0.10030013f, 
    0.17709818f, -0.03080986f, 0.20112631f, 0.17368798f, 0.03128731f, 0.08130648f, 0.08049995f, 0.13122818f, 
    0.07350064f, -0.08561463f, 0.03607760f, 0.10232197f, 0.03278171f, 0.03092444f, -0.07184444f, 0.22163704f, 
    0.04315097f, 0.07683519f, -0.04861767f, 0.02631106f, -0.08075054f, -0.00008466f, -0.03583925f, 0.06523438f, 
    0.11764840f, -0.05786021f, 0.04364290f, 0.07926816f, -0.02932168f, 0.11005257f, 0.17538771f, -0.03352391f, 
    0.16746064f, -0.04582158f, 0.04915181f, 0.47962838f, 0.08211038f, -0.01864467f, 0.01825769f, 0.00917959f, 
    -0.11461036f, 0.04518395f, -0.01358061f, 0.08375288f, -0.26527470f, -0.35936275f, 0.10011625f, 0.10126348f, 
    -0.11903871f, -0.07819825f, -0.03782020f, 0.00412695f, 0.16492315f, 0.02381537f, 0.05234474f, 0.07610704f, 
    -0.02053483f, -0.07727783f, 0.53733075f, -0.06469880f, -0.02203524f, -0.09460571f, 0.07970322f, 0.06604242f, 
    0.16463073f, -0.11951103f, -0.20009106f, 0.02795677f, -0.30233470f, 0.02381614f, 0.08483317f, -0.18210049f, 
    0.00861014f, -0.16960976f, 0.14497772f, 0.18589616f, -0.08367497f, -0.04091114f, -0.02164594f, 0.08114319f, 
    0.06362194f, 0.16162321f, -0.01840037f, -0.01237163f, 0.30138320f, 0.12450783f, 0.13949275f, -0.21520738f, 
    -0.00690918f, 0.05201156f, 0.01497824f, 0.06423672f, -0.16557632f, -0.28522354f, -0.08100675f, -0.01991918f, 
    0.01724679f, 0.01163648f, 0.01185163f, 0.01583102f, -0.06990143f, -0.04336830f, -0.01628978f, -0.12385599f, 
    0.11543030f, 0.16205180f, -0.07981860f, 0.06329595f, 0.03503405f, -0.09455254f, -0.03128482f, 0.13936763f, 
    0.03136745f, 0.04714441f, -0.00043421f, 0.03856056f, -0.07437449f, -0.07662841f, 0.05709073f, -0.06783296f, 
    0.10736240f, -0.10799970f, 0.03188317f, 0.02506655f, -0.06131046f, -0.14530142f, 0.00806394f, -0.22253267f, 
    0.12185098f, 0.11799761f, 0.15071070f, 0.11078877f, 0.02833540f, -0.02078811f, -0.17699705f, -0.17503087f, 
    0.03300222f, -0.03321341f, -0.00296645f, -0.03186513f, 0.25445515f, -0.09697140f, -0.04001301f, -0.05917509f, 
    0.00343729f, -0.02640551f, -0.09992968f, 0.01102381f, 0.27058950f, 0.31429935f, 0.07885627f, -0.15425114f, 
    0.01193837f, 0.04988910f, -0.08529159f, 0.06010601f, 0.03877507f, 0.14541431f, 0.16140065f, -0.00220570f, 
    0.04962517f, 0.08227268f, 0.06527060f, 0.06973387f, 0.01398247f, 0.07515536f, -0.11282769f, -0.22451955f, 
    -0.07944871f, -0.05226456f, -0.07793400f, 0.10957238f, 0.11442664f, -0.12226051f, -0.08138340f, 0.15019064f, 
    0.02163949f, -0.04903502f, 0.03526852f, -0.12639813f, 0.26772058f, 0.09812929f, 0.10455955f, 0.03623883f, 
    0.11757649f, -0.05354350f, 0.01094389f, 0.05020395f, 0.01131913f, -0.02908191f, -0.22616556f, -0.08192898f, 
    -0.07083344f, 0.07230037f, 0.06495354f, 0.03102092f, 0.16883671f, -0.31042677f, -0.14101768f, -0.47892016f, 
    -0.06426439f, -0.27529377f, -0.09301145f, -0.04299883f, -0.03661457f, 0.08650061f, -0.00293399f, -0.04725118f, 
    0.15922259f, -0.09389941f, 0.15440652f, 0.06036017f, -0.28814360f, 0.16713302f, -0.18090867f, -0.03312866f, 
    -0.00685636f, -0.06670778f, 0.01976358f, -0.05031178f, -0.03478416f, 0.01103606f, -0.11183885f, 0.05252974f, 
    -0.20920053f, -0.03245434f, 0.09131184f, 0.11538041f, -0.02581959f, -0.03777210f, -0.05452888f, 0.07573153f, 
    -0.01563404f, 0.07059197f, -0.02361751f, 0.16821879f, 0.18884856f, -0.05787201f, 0.01807998f, -0.06600817f, 
    0.15759544f, -0.08224597f, 0.05317098f, -0.01705509f, -0.10872470f, 0.03719787f, 0.08860751f, 0.01151393f, 
    0.06919627f, 0.21483976f, 0.04486051f, -0.16579616f, 0.00044074f, 0.07310041f, -0.09487750f, -0.18677993f, 
    0.13064544f, 0.02068586f, 0.04143577f, 0.10714257f, 0.05157072f, -0.22528994f, 0.00935751f, -0.10004205f, 
    0.05517598f, -0.03220117f, 0.09503238f, 0.19826932f, -0.01920583f, -0.01884819f, 0.04765685f, -0.14567928f, 
    0.02475242f, 0.01712972f, 0.00130488f, -0.05805767f, -0.02334141f, 0.01349978f, 0.04422482f, 0.10612214f, 
    0.17191735f, -0.16838183f, 0.03855852f, 0.01086708f, 0.35077432f, -0.08730452f, -0.22041170f, -0.10162368f, 
    -0.07336991f, 0.09685150f, 0.20293994f, -0.18322875f, 0.01204962f, 0.01395292f, 0.01512275f, -0.05135979f, 
    -0.13528790f, -0.17580879f, -0.14506854f, 0.06070602f, -0.12285981f, -0.05036645f, -0.00792155f, 0.07307741f, 
    0.02995980f, -0.00493160f, -0.01800815f, -0.02792439f, -0.25940624f, -0.14239152f, -0.13146080f, 0.05047613f, 
    -0.07796393f, 0.16400065f, -0.04124338f, -0.07866303f, -0.08152497f, -0.03323746f, -0.04481075f, 0.02714224f, 
    0.03773743f, 0.02764660f, 0.06657268f, -0.04209528f, -0.01228632f, 0.01411654f, -0.00470742f, 0.05328883f, 
    -0.09244700f, -0.04619857f, 0.19897021f, -0.02999391f, -0.31353346f, 0.34774724f, 0.24423523f, 0.12512772f, 
    -0.09160385f, 0.06666820f, -0.14046142f, 0.00009568f, -0.02853368f, 0.02411532f, 0.08833762f, -0.01099706f, 
    0.09412299f, -0.04380634f, -0.12084738f, -0.09746016f, -0.01339833f, -0.02741014f, 0.02390177f, 0.02146913f, 
    -0.06949331f, 0.04502568f, -0.20280595f, -0.16094901f, -0.40551412f, 0.46390095f, -0.04053847f, 0.04243704f, 
    -0.06930590f, 0.01760381f, 0.03570004f, 0.04369121f, 0.10351875f, 0.01833311f, 0.16601129f, 0.10454503f, 
    -0.28505501f, 0.16994567f, 0.31130582f, 0.02466597f, 0.07495945f, -0.17111076f, -0.02501054f, 0.07197066f, 
    -0.01051767f, 0.08164734f, 0.04939336f, 0.03257662f, -0.67711234f, -0.60887396f, -0.42600942f, -0.22148331f, 
    -0.09029257f, -0.16302274f, -0.14864123f, -0.14759138f, -0.05304784f, -0.00477697f, 0.00222994f, -0.01552085f, 
    -0.06216076f, -0.27139178f, -0.17461950f, 0.03708705f, -0.03223659f, 0.04563541f, 0.04578915f, -0.00758720f, 
    0.00919857f, -0.07619632f, -0.00470486f, -0.00591164f, -0.18827401f, -0.32006502f, 0.15504549f, 0.22314665f, 
    -0.04814534f, -0.24189284f, 0.01344801f, 0.04713309f, -0.04863448f, 0.13129644f, 0.02070052f, -0.07215194f, 
    -0.07754853f, -0.20855193f, -0.03287328f, 0.07935647f, 0.05309305f, 0.12390603f, 0.09361496f, -0.12989882f, 
    0.02430458f, -0.11594569f, -0.07594434f, -0.02804655f, -0.08944148f, -0.15361664f, -0.06654321f, -0.11677384f, 
    -0.16217388f, -0.10081147f, 0.14055726f, -0.03867775f, 0.04259379f, 0.06447952f, -0.19695026f, 0.04713915f, 
    0.01600876f, 0.03671554f, 0.22039758f, -0.11643310f, -0.09133600f, 0.05094243f, -0.02800037f, -0.14429751f, 
    -0.00532455f, 0.02105647f, -0.07847321f, 0.14295264f, -0.31446812f, 0.05288237f, 0.21412838f, 0.19718890f, 
    0.00653533f, 0.09511342f, -0.03489567f, -0.19332507f, 0.02977075f, 0.07951704f, -0.00642761f, 0.12842052f, 
    -0.34756741f, -0.54518598f, -0.60261685f, -0.11261293f, -0.12219287f, 0.02584772f, 0.06418506f, -0.01594829f, 
    -0.01408431f, 0.02509554f, -0.01750269f, 0.01764488f, 0.05752258f, -0.00209655f, 0.03404852f, -0.05511682f, 
    0.02185264f, 0.01608574f, 0.02562392f, -0.04386141f, -0.02657254f, -0.00642984f, -0.08930515f, -0.02548480f, 
    0.25150651f, -0.34584162f, 0.03189516f, -0.05340726f, 0.04786406f, -0.07021876f, 0.07107276f, -0.05569453f, 
    -0.05008477f, -0.06193721f, 0.04118662f, 0.07113837f, 0.04733337f, -0.17130619f, 0.13175225f, 0.04509324f, 
    -0.01962589f, 0.13431028f, -0.06737937f, 0.04892817f, 0.08239576f, 0.20994546f, 0.03898222f, -0.10240995f, 
    0.05552074f, -0.00775753f, -0.09032568f, 0.14120454f, 0.06674986f, 0.03025628f, 0.14642093f, 0.13440585f, 
    0.07460924f, 0.11910262f, 0.23756443f, -0.04142039f, 0.40093356f, -0.88752180f, -0.55446589f, -0.45793909f, 
    0.12559766f, 0.05270663f, 0.00477680f, -0.25360477f, -0.00771786f, -0.02238035f, 0.02407861f, -0.03823490f, 
    0.08964168f, -0.67108178f, -0.41230243f, 0.35533103f, 0.06573044f, 0.14224860f, -0.18096966f, -0.03657338f, 
    -0.00181552f, 0.01091444f, 0.01003294f, 0.06605026f, -0.11648970f, -0.08550753f, -0.05552548f, -0.35815322f, 
    0.04412816f, -0.02747301f, -0.00914908f, -0.04004280f, -0.01408853f, 0.12530002f, -0.19249736f, 0.07250688f, 
    0.01770213f, 0.06321052f, -0.04086963f, -0.01418041f, -0.01273822f, 0.06634603f, -0.02337344f, -0.02963783f, 
    0.03498470f, 0.00771194f, -0.01170457f, 0.03162591f, -0.13962600f, 0.18327680f, 0.00683662f, -0.03285658f, 
    -0.02983068f, -0.06834123f, -0.00769753f, 0.12430745f, -0.07170042f, 0.04067265f, -0.11384383f, 0.03900336f, 
    0.05009630f, -0.04821553f, -0.03316351f, -0.12696142f, 0.07263022f, -0.01666117f, 0.07590295f, -0.00604157f, 
    -0.01360085f, -0.02673114f, 0.01850077f, 0.01178181f, 0.11542274f, -0.00830691f, -0.00282490f, -0.11360786f, 
    0.04957470f, 0.07706752f, -0.03109770f, -0.09319741f, 0.03884762f, -0.09704937f, -0.02160511f, -0.18922174f, 
    -0.17906994f, 0.36148626f, 0.10817782f, 0.06391276f, -0.07595205f, 0.01169711f, 0.02795403f, 0.13765746f, 
    0.02675362f, 0.06125136f, 0.06499362f, -0.02931487f, 0.26180816f, 0.11968248f, -0.10204871f, -0.32086545f, 
    -0.01655249f, -0.08326130f, 0.06886643f, -0.00807616f, 0.04757869f, 0.08784127f, 0.00543498f, -0.15531860f, 
    -0.12419800f, -0.03383971f, -0.19763213f, 0.10696944f, -0.09865891f, -0.02307804f, -0.00658259f, -0.02811568f, 
    -0.05318536f, -0.04610418f, 0.02858813f, 0.14689572f, -0.34578171f, -0.35766867f, 0.05978842f, 0.21826009f, 
    0.05698316f, 0.00434522f, 0.02869913f, -0.15664865f, 0.07286429f, 0.06189724f, -0.06096903f, -0.02275240f, 
    -0.01789664f, -0.08653138f, 0.08857513f, -0.09730957f, 0.00077944f, 0.06968085f, -0.03142834f, -0.05638942f, 
    0.04352795f, -0.01273834f, -0.02692121f, 0.15026240f, -0.16529441f, 0.04131325f, 0.02730301f, 0.01812306f, 
    -0.02541777f, 0.05765046f, -0.10451983f, 0.02862667f, -0.04247385f, -0.07866946f, -0.08808438f, 0.05017764f, 
    -0.01173091f, -0.53660518f, 0.11655301f, 0.13868362f, 0.19347522f, 0.23976175f, -0.04829814f, -0.29801425f, 
    0.00406138f, 0.07445331f, 0.05629934f, -0.00651521f, -0.35931852f, 0.06843895f, 0.11962703f, -0.03107821f, 
    0.10187680f, 0.06938810f, 0.02913949f, -0.03094144f, 0.02659947f, -0.09361393f, 0.18816057f, 0.05347113f, 
    -0.41909084f, 0.02366538f, 0.02933642f, 0.54834712f, -0.05601251f, -0.02395393f, 0.04554088f, 0.06388068f, 
    0.05552388f, 0.09604470f, 0.01728727f, 0.10720094f, -0.32869947f, -0.11120568f, -0.02701605f, 0.37179843f, 
    0.26134893f, 0.11054882f, 0.10500492f, -0.18810758f, 0.04645501f, -0.01760061f, 0.07513268f, -0.01233420f, 
    -0.23715538f, 0.16603449f, 0.02677800f, 0.17658678f, -0.02985469f, 0.00897384f, 0.07838117f, 0.03458755f, 
    0.12063961f, 0.18525600f, 0.18120535f, 0.14470105f, -0.20715100f, -0.33887419f, -0.16733114f, 0.14846991f, 
    0.15054083f, 0.10124873f, 0.14185165f, 0.15556361f, -0.01547502f, -0.07471331f, -0.01797482f, 0.04034663f, 
    -0.08620121f, -0.07854757f, 0.09367844f, 0.10530218f, 0.09363511f, -0.03429588f, -0.02420254f, 0.05906032f, 
    0.06940192f, 0.03173736f, 0.05338615f, -0.24727705f, -0.10934694f, -0.12572736f, 0.01800972f, -0.11822142f, 
    -0.16080774f, -0.14764096f, -0.03271990f, -0.12993266f, 0.00405487f, -0.08040705f, -0.06173334f, -0.07835389f, 
    0.11139385f, -0.12298200f, -0.15352421f, 0.15460783f, 0.03910897f, 0.09707753f, 0.15799661f, 0.04069914f, 
    -0.01930971f, -0.00359525f, -0.01969577f, -0.01422725f, 0.09857954f, -0.02926889f, -0.10405486f, 0.04403545f, 
    0.01408340f, 0.03341768f, -0.03615656f, 0.16676398f, -0.10765479f, 0.11942280f, 0.02750229f, -0.00531297f, 
    -0.10651682f, 0.21763401f, -0.00806570f, 0.00646354f, 0.06396690f, -0.02221318f, 0.10113283f, 0.00659681f, 
    -0.07652247f, -0.02675769f, 0.03531357f, 0.12598427f, -0.14821304f, -0.01950606f, 0.18985946f, 0.02450435f, 
    -0.07221570f, -0.12209284f, -0.06341344f, 0.10956322f, 0.02334654f, 0.07967218f, 0.09453703f, 0.08131383f, 
    0.20153578f, -0.47417837f, -0.12754388f, -0.24081916f, -0.10185557f, -0.02615562f, -0.03134789f, 0.17026109f, 
    -0.07812672f, 0.04327629f, 0.21957724f, 0.06253779f, -0.40390182f, -0.53593737f, -0.28932858f, -0.01342998f, 
    -0.25375962f, 0.06224605f, 0.05483940f, 0.16935082f, -0.00576388f, 0.09505384f, -0.00407523f, -0.09544941f, 
    -0.66802830f, -0.46380448f, -0.36544365f, -0.25536016f, -0.13436903f, -0.13874577f, -0.09564209f, -0.43545923f, 
    0.00965828f, 0.00451274f, -0.05863075f, 0.01112933f, -0.17242517f, -0.06443747f, 0.00497149f, -0.04001692f, 
    0.00474323f, 0.09648319f, -0.01786100f, -0.10511553f, -0.03136417f, -0.06392985f, -0.02509650f, -0.01339324f, 
    -0.53797477f, -0.50296777f, -0.50744957f, -0.37842026f, -0.15186878f, 0.12470317f, -0.23387994f, -0.17818628f, 
    0.04789390f, -0.05479350f, 0.02470546f, -0.00359506f, -0.13882715f, -0.07520665f, -0.06811791f, 0.10650492f, 
    0.00021601f, 0.02223003f, 0.00559638f, 0.07940969f, 0.19784766f, -0.07765153f, 0.11821433f, -0.12180154f, 
    -0.51676679f, -0.45083830f, -0.39211434f, -0.12094350f, -0.26677185f, 0.06436113f, 0.00566749f, -0.23980266f, 
    -0.03763210f, -0.04622203f, 0.02909895f, 0.04256355f, 0.11577161f, 0.21708992f, -0.03174046f, -0.12279721f, 
    0.05240805f, 0.04065958f, -0.07104276f, 0.01482255f, 0.03371365f, 0.17118983f, 0.04534139f, -0.03581583f, 
    -0.04456936f, -0.09019943f, -0.17171481f, -0.02824315f, -0.10731833f, -0.02940384f, 0.08057208f, 0.03925990f, 
    0.01833013f, -0.03586246f, 0.02382287f, -0.03396013f, 0.39639926f, 0.28145376f, -0.00357480f, -0.02864605f, 
    0.01474120f, -0.34974295f, 0.14444320f, 0.12674338f, -0.02526886f, 0.00315023f, -0.06859048f, -0.02706764f, 
    -0.49659622f, -0.19927427f, -0.17453535f, -0.37173119f, -0.09623004f, -0.12443037f, -0.01414517f, -0.10062511f, 
    0.02874322f, 0.03191548f, -0.04545821f, -0.03865661f, 0.21426415f, 0.14441730f, 0.02514084f, 0.02421286f, 
    0.03674030f, 0.00061420f, 0.03738869f, 0.06921010f, 0.13821752f, 0.14262038f, 0.27705300f, 0.17629966f, 
    -0.31309557f, 0.43629095f, 0.30280119f, 0.30344990f, -0.01827166f, -0.09251840f, -0.05551458f, -0.01862779f, 
    0.03436970f, 0.09067668f, -0.00015705f, -0.01363336f, 0.00768732f, 0.11681695f, 0.33723080f, -0.04135222f, 
    0.11660139f, -0.07226313f, 0.03285139f, 0.18260190f, -0.11165819f, 0.08582589f, 0.12680618f, 0.05340695f, 
    -0.02223567f, -0.05355496f, -0.04211546f, 0.01136521f, -0.04147177f, 0.02440549f, 0.00103148f, 0.12574719f, 
    -0.11200714f, -0.11371668f, -0.03977947f, 0.03228005f, 0.11191630f, 0.07632156f, 0.10430344f, -0.10144419f, 
    -0.05623846f, 0.00314035f, 0.05182768f, 0.10670543f, 0.04820293f, -0.07056856f, 0.03970614f, -0.03768223f, 
    -0.42022246f, -0.62818134f, -0.35673997f, -0.20563291f, 0.05469058f, -0.22427221f, -0.19193609f, -0.31010333f, 
    -0.02886691f, 0.04091648f, -0.00679569f, -0.03268237f, 0.04819611f, -0.33985320f, -0.18371622f, 0.14410464f, 
    0.02671791f, 0.20377207f, 0.26599348f, -0.17684165f, 0.07981294f, -0.06089041f, 0.05133128f, 0.08730808f, 
    0.10787520f, 0.03436608f, -0.01687295f, 0.01195699f, -0.03471196f, -0.01873085f, 0.06969485f, -0.05005766f, 
    -0.14879926f, 0.03000867f, -0.06357345f, -0.01095351f, -0.13753842f, 0.12979335f, 0.04023078f, 0.03278719f, 
    -0.12350434f, 0.03746800f, -0.07134064f, 0.06779844f, 0.01855135f, -0.02178692f, 0.04106952f, 0.02489915f, 
    0.16463594f, -0.46656275f, 0.10230643f, 0.24523976f, 0.04218626f, 0.08965392f, -0.02918770f, -0.09579264f, 
    0.04369812f, 0.05807817f, 0.03774218f, 0.03179480f, 0.05840296f, 0.04111683f, 0.00727340f, -0.05652058f, 
    -0.08557630f, -0.09422887f, -0.09734548f, -0.14498265f, 0.02785622f, 0.02116882f, -0.04794244f, 0.00060594f, 
    0.04554464f, 0.10973205f, -0.04718965f, 0.15152138f, -0.11822491f, 0.00526104f, 0.03007554f, -0.00366601f, 
    -0.13573296f, 0.02305833f, -0.08692962f, -0.16863437f, 0.56008601f, -0.35680974f, -0.21768561f, -0.21111229f, 
    0.02771220f, -0.06490077f, -0.03180913f, -0.03108254f, 0.04025529f, -0.01488594f, 0.05892936f, 0.01862773f, 
    -0.00912410f, 0.02736962f, 0.00806780f, 0.00442703f, 0.00424961f, 0.00034230f, -0.05407453f, -0.02719248f, 
    0.03382193f, -0.01493416f, 0.01452347f, -0.04008568f, 0.08569002f, -0.46220341f, -0.23017062f, -0.00763375f, 
    0.00699531f, -0.02421984f, 0.02402723f, 0.00555931f, 0.04610198f, 0.13540955f, 0.14015257f, 0.00970676f, 
    0.08934359f, -0.50752151f, 0.15616223f, -0.27906379f, -0.08840681f, -0.07097615f, 0.02592262f, -0.00213965f, 
    0.04201517f, 0.17163728f, 0.00344828f, 0.10536412f, -0.14958607f, -0.24270433f, -0.32494757f, -0.23538092f, 
    0.00346691f, -0.04850682f, 0.00227788f, 0.11771402f, 0.00780232f, 0.02106433f, -0.06743622f, 0.00931378f, 
    -0.00029268f, -0.09343793f, -0.02126095f, 0.05004005f, -0.00487502f, 0.01801507f, 0.14691538f, 0.08539528f, 
    0.08593371f, 0.02090039f, 0.05003153f, 0.00079413f, 0.64218181f, -0.37096632f, 0.41433960f, -0.47966188f, 
    -0.23322940f, 0.23339282f, -0.25010478f, 0.17049916f, -0.00056737f, -0.00423237f, 0.02195330f, -0.06311328f, 
    -0.05592789f, -0.03727322f, 0.03011181f, -0.00516199f, -0.06185414f, -0.00453618f, 0.04977670f, 0.06349977f, 
    0.04509041f, 0.01727525f, 0.02511446f, -0.05967349f, 0.20579183f, -0.05134347f, 0.11810362f, -0.12285721f, 
    0.05664113f, 0.11508853f, -0.06218136f, 0.03927629f, -0.01926629f, 0.04905321f, -0.03359981f, 0.09559998f, 
    -0.30763301f, -0.26900917f, -0.24295364f, -0.04287826f, -0.02530250f, 0.00487073f, 0.07631938f, 0.11474261f, 
    0.06667986f, -0.00586228f, 0.12134868f, -0.03778505f, 0.66075134f, -0.38918629f, -0.17137773f, -0.28739527f, 
    -0.04284342f, -0.06103033f, -0.20508614f, -0.02659516f, 0.05753708f, -0.07575647f, 0.03945696f, -0.03855980f, 
    -0.53082132f, -0.57126272f, 0.18222399f, -0.02613518f, -0.01268266f, -0.07597180f, -0.01751258f, -0.17534658f, 
    0.05327507f, -0.00310650f, 0.00917463f, 0.03780044f, 0.00248868f, 0.08395405f, 0.01971372f, 0.01286434f, 
    -0.01217598f, 0.01172169f, 0.01648113f, -0.01666696f, -0.00400505f, -0.01393001f, 0.04199131f, -0.02027690f, 
    -0.34282741f, -0.16288726f, -0.09530172f, -0.27749261f, -0.02215480f, 0.05009203f, 0.11691381f, -0.06333104f, 
    0.04796423f, -0.00057663f, -0.03978292f, 0.05062664f, 0.14681000f, -0.09973461f, -0.10911459f, 0.06446404f, 
    0.06027065f, 0.05451149f, -0.03857778f, -0.01243584f, -0.19062613f, 0.05792886f, -0.06288186f, 0.02872268f, 
    0.11509472f, -0.14637525f, 0.10899590f, -0.16992563f, 0.02101275f, -0.04245061f, -0.06695245f, -0.06008548f, 
    -0.19804926f, 0.00440428f, -0.02143278f, -0.02596294f, -0.63699180f, 0.09471373f, -0.27033150f, 0.44858307f, 
    -0.07595222f, 0.08403981f, -0.05287560f, 0.03666395f, -0.02149253f, 0.02426061f, -0.04020721f, 0.00771958f, 
    0.34839302f, -0.73939037f, 0.39265981f, -0.20487846f, -0.00125656f, -0.04644531f, -0.21341118f, 0.12716325f, 
    -0.01175949f, 0.08976985f, 0.01533693f, -0.03422318f, 0.00871195f, 0.01783415f, -0.03348153f, 0.04071124f, 
    0.01067987f, 0.03433763f, 0.03003861f, -0.01689425f, 0.01892265f, -0.00940943f, 0.02391579f, -0.03880842f, 
    0.01056272f, -0.08627689f, 0.06442732f, -0.11955996f, 0.02500238f, 0.06392784f, 0.04048856f, -0.00715521f, 
    0.07443105f, -0.02299825f, 0.00603515f, 0.03069625f, 0.02931195f, 0.05566261f, -0.09633660f, -0.03436509f, 
    0.10189746f, -0.00214769f, 0.00679533f, 0.00253101f, 0.00267020f, -0.04166654f, -0.02629094f, -0.09902310f, 
    -0.00334834f, 0.09307997f, -0.03191070f, -0.06458601f, -0.01475728f, -0.04935395f, -0.03127166f, 0.04181363f, 
    0.04363484f, 0.06619614f, -0.03964639f, -0.09021752f, 0.00225563f, -0.02951196f, 0.06742676f, -0.10211723f, 
    0.01064776f, 0.00221617f, 0.02871592f, 0.02577614f, 0.00197403f, -0.12615584f, 0.05163778f, 0.05952054f, 
    -0.23698872f, 0.11704531f, -0.04536023f, 0.15180904f, 0.04116473f, -0.02700939f, 0.23798373f, -0.03477211f, 
    -0.08502072f, 0.05312361f, -0.08385405f, -0.07272271f, -0.06108084f, 0.17747805f, 0.03687990f, 0.12209022f, 
    -0.06367237f, 0.15263166f, 0.03224539f, -0.05924238f, 0.00741639f, 0.04762260f, 0.00734417f, -0.02300787f, 
    0.45619607f, -0.36556235f, -0.04129537f, -0.12510787f, 0.01932512f, 0.05746901f, -0.07070290f, 0.03790204f, 
    0.01880748f, 0.08295918f, -0.01942420f, -0.01699836f, -0.11968312f, 0.00470881f, -0.19470617f, 0.00761768f, 
    0.01947972f, -0.00247616f, -0.01742083f, 0.07735903f, 0.02369534f, -0.04228885f, 0.01408498f, 0.02559604f, 
    0.19369988f, 0.04358974f, -0.25530231f, -0.14728874f, 0.08691832f, 0.01114810f, 0.01124973f, 0.06085808f, 
    -0.04401492f, 0.14117523f, -0.02354400f, -0.14593589f, 0.14363597f, -0.06887732f, -0.08065628f, -0.05989172f, 
    -0.12500030f, 0.02599415f, -0.02098444f, -0.08652974f, -0.00896123f, -0.00231793f, -0.03152955f, -0.07319341f, 
    0.23592810f, -0.04801118f, 0.19823790f, -0.27003232f, -0.16239879f, 0.13739058f, 0.02094731f, 0.16237843f, 
    0.02422018f, 0.03686495f, 0.08513869f, 0.03565339f, 0.04222649f, 0.07281530f, -0.19703235f, -0.00226496f, 
    0.05051909f, -0.05379667f, 0.06730212f, -0.04723244f, 0.00904552f, 0.05310988f, -0.18275978f, -0.22399752f, 
    -0.09054720f, -0.60077947f, -0.05116932f, -0.24438959f, 0.00094103f, -0.18299614f, -0.01459603f, 0.03977662f, 
    0.08705218f, -0.04977777f, 0.01086855f, 0.01926230f, -0.07379749f, 0.00471037f, 0.13629131f, -0.09636066f, 
    -0.00898497f, -0.05462242f, 0.02536522f, 0.10139184f, 0.01878609f, 0.05828733f, -0.02330806f, 0.00253984f, 
    0.34503111f, -0.22279526f, 0.06476840f, -0.29428598f, -0.00657548f, -0.08785114f, -0.13376151f, 0.02012827f, 
    0.02826962f, 0.16334718f, 0.03050866f, 0.12170417f, -0.11779892f, -0.16275212f, -0.01855173f, -0.03408993f, 
    0.00706979f, -0.09545186f, -0.05680646f, -0.06048476f, 0.06295506f, -0.03946687f, 0.06347449f, -0.02437472f, 
    0.05686470f, -0.10547917f, 0.01625445f, 0.04725141f, 0.00001204f, 0.07976487f, 0.01976474f, 0.01088026f, 
    -0.02726231f, -0.01402017f, 0.01199519f, -0.00174800f, 0.03086706f, -0.01724967f, 0.02844497f, -0.02860629f, 
    0.06117650f, -0.20257987f, -0.06397964f, 0.03160115f, 0.07062806f, 0.00811910f, -0.00913495f, 0.05833597f, 
    0.08811349f, -0.05512972f, 0.13171645f, -0.11342069f, -0.04397333f, 0.00962329f, -0.02947357f, -0.04571100f, 
    0.07843927f, 0.02760852f, -0.05796776f, -0.00862916f, 0.01966181f, 0.04986771f, 0.07657300f, -0.02903092f, 
    -0.01418166f, 0.06033777f, -0.03785091f, -0.11670720f, 0.02948201f, -0.04902595f, 0.07577710f, -0.03237855f, 
    0.09661939f, 0.26469386f, 0.08259939f, 0.02215678f, -0.09417653f, 0.13094017f, -0.16871201f, 0.05971525f, 
    -0.08118043f, 0.04964705f, -0.03958600f, -0.02465425f, 0.34575060f, 0.00248876f, -0.23847982f, -0.26329562f, 
    0.03221365f, 0.06341648f, 0.00563230f, 0.02721181f, -0.12411247f, -0.11289001f, 0.10257199f, -0.19652021f, 
    0.56449360f, -0.44062522f, 0.17679526f, 0.38256195f, -0.02547325f, 0.03097917f, -0.16599400f, -0.06832260f, 
    -0.05047835f, -0.00875310f, -0.07573246f, -0.05884912f, -0.01480853f, -0.34165299f, -0.18939815f, -0.18880039f, 
    -0.08629171f, 0.16931307f, 0.17021655f, 0.09774201f, 0.05213407f, -0.06866354f, -0.07161932f, -0.04167361f, 
    -0.37170157f, -0.24412690f, -0.15393010f, 0.16618411f, 0.06086534f, -0.03016556f, 0.07173448f, 0.06773473f, 
    0.05544276f, -0.01003018f, -0.04437021f, -0.01621283f, 0.07875035f, -0.01338921f, -0.06531697f, -0.02306828f, 
    0.01617489f, -0.01439818f, 0.01999764f, -0.05660114f, 0.06176880f, 0.05533848f, 0.00709820f, 0.04197871f, 
    0.11195928f, -0.17028517f, -0.28687081f, -0.28404027f, 0.03056175f, 0.00772520f, 0.12534265f, 0.05595744f, 
    0.03998589f, 0.01253104f, -0.00997966f, -0.00935644f, 0.16267388f, -0.00485198f, -0.00968219f, -0.12363939f, 
    -0.06272177f, 0.03763115f, -0.01645192f, -0.02396374f, 0.05018385f, 0.02755638f, 0.03940962f, -0.07054466f, 
    -0.07249235f, -0.33199641f, -0.07413706f, 0.27964905f, 0.05195368f, 0.11488096f, 0.15152378f, 0.14802738f, 
    -0.04448506f, -0.08371279f, -0.10805958f, -0.02540149f, -0.00880069f, -0.03094682f, 0.02699151f, 0.01632931f, 
    0.01425579f, -0.00399426f, 0.01984916f, -0.07163100f, -0.11107327f, -0.13510865f, -0.06246144f, -0.20840660f, 
    -0.01744644f, 0.05862309f, -0.03775801f, 0.04767204f, 0.04466034f, -0.09252782f, -0.02409701f, -0.01779561f, 
    -0.01268719f, 0.03002533f, -0.01327158f, -0.00159145f, -0.11767299f, 0.09206836f, 0.18437167f, -0.01356600f, 
    0.00967268f, -0.02057069f, 0.01403485f, -0.05267099f, -0.00185550f, 0.13072576f, 0.03900300f, 0.05443501f, 
    -0.33680457f, -0.20442031f, -0.29773551f, -0.19002114f, -0.03960358f, -0.07181779f, 0.10306996f, 0.04475598f, 
    0.02071407f, -0.00856763f, -0.05896115f, -0.00572785f, 0.07021957f, -0.00419530f, 0.06646075f, 0.08312105f, 
    -0.05273948f, -0.02647221f, 0.00738260f, -0.02710238f, 0.02424405f, 0.02952252f, 0.02897280f, -0.02037091f, 
    -0.23283863f, -0.61034912f, -0.59442359f, -0.34575331f, -0.12783694f, -0.07477512f, 0.02971214f, 0.04317690f, 
    -0.00810650f, 0.02329278f, 0.08846585f, -0.01774321f, 0.25087178f, -0.07920247f, -0.39477572f, -0.12603170f, 
    0.04496578f, -0.11578234f, 0.04760180f, 0.10131776f, 0.01053382f, 0.03982216f, -0.06373917f, -0.04481620f, 
    0.08694694f, -0.03844537f, 0.02637565f, -0.09123796f, -0.04149742f, 0.00447908f, -0.00545154f, -0.05300567f, 
    -0.02107424f, -0.00728289f, 0.01076195f, -0.08274862f, -0.11524574f, 0.04798033f, -0.03881231f, 0.08201883f, 
    -0.00437070f, -0.01519634f, 0.02513292f, -0.13366057f, 0.02039784f, 0.01663508f, 0.05283852f, -0.01420184f, 
    -0.43237171f, 0.26167527f, 0.51880932f, 0.27712750f, 0.10014214f, -0.12974051f, -0.06728182f, 0.17696950f, 
    -0.12475783f, -0.04342920f, -0.14277457f, -0.02038654f, 0.02060606f, 0.05791165f, 0.08337580f, -0.06918956f, 
    -0.09415913f, -0.23812912f, -0.03439749f, 0.00329267f, -0.01960651f, -0.03406001f, 0.12009077f, 0.07010147f, 
    -0.06976876f, -0.05523806f, 0.05496093f, -0.08485612f, 0.05077941f, 0.03133184f, 0.00954136f, -0.03323506f, 
    0.06115789f, -0.04840518f, 0.05882686f, 0.04363887f, -0.30660179f, 0.13876583f, 0.04977035f, 0.11102258f, 
    0.13724332f, -0.08584584f, 0.01307154f, 0.10822796f, -0.08233640f, 0.03990844f, 0.13753249f, -0.06110765f, 
    0.36638591f, -0.12183516f, -0.05688365f, -0.21640892f, 0.07698343f, -0.07881896f, 0.04755166f, -0.01799222f, 
    -0.13628705f, 0.12379897f, 0.03719400f, -0.10187806f, 0.28206044f, 0.04701062f, -0.08026505f, -0.11735833f, 
    0.14357965f, -0.00987295f, -0.03805079f, -0.04132649f, 0.06470086f, 0.04618093f, 0.05761388f, 0.09378412f, 
    -0.02333907f, 0.21919069f, -0.03743678f, -0.01387388f, 0.04766728f, -0.07743298f, -0.04507384f, 0.12254798f, 
    0.15008862f, -0.07213660f, 0.05978881f, 0.06039990f, -0.18610969f, -0.35634643f, -0.28075001f, -0.15386686f, 
    -0.02816385f, 0.09803257f, 0.06458040f, 0.14152010f, 0.12878400f, -0.10830799f, -0.06880875f, -0.13155869f, 
    -0.16895813f, 0.03515893f, -0.00336453f, 0.07155603f, 0.00376164f, -0.03376376f, -0.00162878f, 0.01822395f, 
    0.01335587f, 0.03134838f, 0.03045367f, 0.04692474f, -0.11974043f, -0.40469503f, -0.09037634f, -0.04500751f, 
    -0.06099183f, 0.05656224f, 0.03115467f, -0.04466159f, 0.00565315f, -0.18516660f, -0.13615689f, -0.15338328f, 
    -0.16564396f, -0.34041461f, -0.06932370f, -0.05295034f, 0.00814562f, 0.16587453f, 0.18905018f, 0.07802672f, 
    0.19387311f, 0.08236203f, 0.22094546f, 0.17452617f, -0.06223642f, -0.44858539f, -0.47038749f, -0.10784294f, 
    -0.12520032f, -0.03245752f, 0.10399166f, -0.08186724f, -0.07088285f, 0.02693100f, 0.00157297f, 0.04476460f, 
    0.08884075f, -0.02326500f, -0.03708518f, -0.04677884f, -0.06592349f, -0.10884421f, -0.20863022f, -0.18799694f, 
    -0.10565179f, 0.08508965f, -0.12632716f, -0.17036666f, 0.07049958f, -0.14099950f, -0.33383071f, -0.09002148f, 
    0.04659393f, -0.21581712f, 0.08917937f, 0.05920661f, 0.03235428f, 0.06648700f, 0.04638000f, 0.12095181f, 
    -0.00218955f, 0.07342573f, 0.01447287f, -0.04020047f, -0.02606232f, -0.02543920f, -0.02690867f, -0.11400794f, 
    0.07698589f, 0.05848226f, 0.07507202f, 0.01627077f, -0.15420315f, -0.05847266f, -0.04002738f, 0.18137020f, 
    0.03585916f, -0.10743570f, -0.09917852f, 0.06696353f, 0.08412141f, 0.02976341f, 0.04306659f, 0.08466889f, 
    -0.09364596f, -0.10048744f, -0.07724331f, 0.10653803f, 0.03372740f, 0.04333690f, 0.03782238f, 0.13011454f, 
    -0.34916458f, -0.21927874f, -0.31299731f, -0.20984328f, -0.21374084f, -0.28513363f, -0.16638683f, 0.02348506f, 
    -0.00725761f, 0.05583565f, 0.13800591f, 0.10129040f, 0.03197442f, 0.04424035f, -0.10743849f, -0.10432347f, 
    0.63572073f, 0.01873910f, -0.00994078f, -0.01394202f, 0.01077334f, -0.06206361f, -0.02769127f, -0.16842690f, 
    0.11634990f, 0.06655478f, 0.02740546f, -0.01242977f, -0.12366138f, 0.04687990f, 0.03053884f, 0.11329918f, 
    -0.04189264f, 0.01674988f, -0.03365927f, -0.01119472f, -0.06686856f, 0.01876551f, 0.03820682f, 0.01451125f, 
    -0.28495169f, -0.49387866f, -0.09515404f, 0.05991052f, 0.03293431f, 0.21141970f, 0.12397636f, 0.11420305f, 
    0.01047099f, 0.03614056f, 0.01040274f, 0.05105163f, 0.17437203f, -0.02825474f, -0.09999239f, 0.00124429f, 
    0.06208619f, 0.04040107f, -0.11377644f, 0.06556825f, -0.05664511f, -0.12823391f, 0.09883398f, -0.06578992f, 
    0.27306864f, 0.11820395f, -0.04124852f, -0.14320791f, 0.02922962f, -0.01875060f, 0.08228140f, -0.05368672f, 
    -0.02274196f, -0.06476079f, 0.06223322f, -0.13761328f, -0.18136841f, -0.20718418f, -0.00529528f, -0.02538728f, 
    0.20046093f, -0.02206766f, 0.01118778f, 0.15930156f, -0.00148550f, 0.09505232f, 0.12685071f, -0.04199328f, 
    0.49873772f, 0.57646596f, -0.03210028f, -0.69448304f, 0.00276977f, -0.12344830f, -0.09029495f, -0.00261103f, 
    0.00806707f, 0.05767353f, -0.03666885f, 0.06117587f, -0.50850052f, -0.06171130f, 0.23274623f, 0.17003155f, 
    -0.08025793f, -0.06717205f, -0.03588892f, -0.02404890f, 0.04843136f, -0.03089129f, -0.00020069f, 0.15862751f, 
    0.09484221f, 0.02172983f, -0.08756126f, 0.00448062f, 0.01824901f, -0.01684727f, -0.06219193f, -0.17914771f, 
    -0.10546220f, -0.02183179f, 0.01897405f, -0.06037916f, 0.12380907f, -0.03164556f, -0.06547233f, 0.10463960f, 
    0.02955152f, -0.04918115f, 0.00831814f, -0.08412828f, 0.14405906f, 0.04525514f, 0.04704029f, 0.14451040f, 
    -0.23698671f, 0.03659923f, 0.06758380f, -0.01406967f, -0.08938600f, -0.00156557f, -0.07347395f, 0.00547711f, 
    -0.14452074f, 0.00288001f, 0.00142629f, -0.03347841f, -0.27757111f, -0.03562005f, 0.15067391f, -0.00988151f, 
    -0.07732561f, -0.03962825f, -0.06043704f, -0.08379027f, 0.00479122f, 0.06764998f, -0.06967117f, 0.09651030f, 
    -0.11666652f, -0.17432031f, 0.22163543f, 0.14605179f, -0.06398550f, 0.08856439f, 0.06737356f, -0.03559797f, 
    0.11664002f, -0.01925996f, 0.05226718f, 0.16234733f, -0.36698619f, 0.13452932f, 0.03382244f, 0.07631209f, 
    0.17053047f, -0.11553075f, -0.11615268f, 0.03081811f, 0.08493517f, 0.06245502f, 0.18518148f, 0.08515180f, 
    0.28856248f, 0.15780255f, -0.06148335f, -0.28534254f, 0.03423101f, -0.15987474f, 0.00832384f, -0.09083146f, 
    0.01933380f, 0.01867144f, 0.13748817f, 0.03308983f, -0.01860619f, 0.10730664f, 0.00567692f, 0.13753641f, 
    0.03523595f, 0.07282843f, 0.06740170f, -0.01695437f, -0.02930583f, -0.00799772f, -0.07236236f, -0.09424874f, 
    0.12969331f, 0.15288955f, -0.09031551f, -0.10314540f, -0.12893194f, -0.09130578f, 0.02967411f, -0.03931940f, 
    0.09239884f, 0.05300391f, -0.01355649f, 0.12531829f, 0.12951647f, -0.07845964f, -0.04702798f, -0.09923899f, 
    0.01336193f, 0.03073895f, 0.01757194f, -0.04324980f, -0.05214624f, 0.09303717f, 0.05539380f, 0.16328174f, 
    -0.01184371f, 0.18321951f, 0.02396339f, -0.06858598f, 0.08393621f, -0.05288544f, 0.02246539f, -0.10606535f, 
    0.00736448f, 0.02347313f, -0.02935222f, 0.08736708f, -0.07416463f, -0.11424179f, 0.05604376f, -0.15425146f, 
    -0.17340060f, -0.01737249f, 0.14669944f, 0.00648926f, -0.10802238f, 0.12868744f, 0.06443814f, 0.05485064f, 
    0.04065076f, -0.47104436f, 0.01705336f, 0.33571395f, 0.17636195f, 0.07237074f, 0.15033679f, -0.02013133f, 
    -0.10909984f, -0.10748623f, -0.11827381f, -0.31100333f, 0.01499049f, -0.10021376f, 0.17482506f, -0.03720535f, 
    -0.00371200f, 0.13766520f, 0.00145997f, -0.17871486f, -0.03987280f, 0.00108728f, 0.06772744f, -0.03741271f, 
    0.05543229f, 0.14242095f, -0.10515723f, 0.04061361f, 0.12101337f, 0.01307170f, 0.06812820f, -0.00979027f, 
    -0.08444394f, -0.08551522f, -0.22502775f, -0.21851651f, 0.09108034f, 0.11851843f, 0.05756794f, -0.07780284f, 
    0.04851916f, -0.15768754f, -0.10840590f, -0.22536163f, 0.08243406f, -0.00470899f, 0.01059804f, 0.01778715f, 
    0.03434800f, -0.07590773f, -0.08236293f, -0.04488417f, -0.03954565f, -0.08607727f, 0.18584304f, -0.06400234f, 
    0.11957333f, -0.03595129f, 0.10225675f, 0.10088006f, 0.01070339f, -0.06858578f, 0.00793463f, -0.04454667f, 
    -0.02184476f, 0.08367144f, -0.01292123f, 0.04397365f, -0.01494447f, 0.04818856f, -0.01375555f, -0.01345059f, 
    -0.00346155f, -0.04413342f, 0.02189881f, -0.09185679f, 0.00451351f, 0.02627294f, -0.04482478f, -0.02997625f, 
    -0.00090161f, -0.04085171f, 0.14510357f, 0.05520013f, 0.11526097f, 0.12085169f, -0.06708096f, -0.07375050f, 
    -0.03976352f, -0.04333407f, 0.04025988f, -0.05564744f, -0.15991062f, 0.03808659f, -0.17285915f, 0.00556655f, 
    0.46310136f, 0.13929792f, -0.11035195f, -0.06484310f, 0.13860494f, 0.03716202f, -0.00259246f, 0.03089732f, 
    0.04264069f, -0.07278345f, 0.14636067f, 0.03346958f, 0.05817787f, -0.07879443f, -0.21853034f, -0.06620745f, 
    0.00335575f, 0.00866548f, -0.03245264f, -0.00924218f, 0.19524501f, 0.07814645f, 0.14615582f, 0.11073036f, 
    0.29209507f, -0.14664565f, -0.47994176f, -0.19497478f, 0.09149052f, -0.02296185f, 0.04370382f, 0.04031405f, 
    0.13634555f, 0.10984166f, 0.22080119f, 0.07463272f, -0.13656621f, -0.30677414f, -0.39898229f, -0.12031046f, 
    0.08584075f, 0.10051017f, 0.16548079f, -0.04084677f, -0.07466287f, -0.00249863f, -0.16238844f, -0.12115429f, 
    -0.23115642f, -0.47654504f, -0.33788037f, -0.09033761f, -0.04436902f, 0.07486099f, -0.05332930f, -0.07657514f, 
    -0.03672395f, 0.02963586f, 0.01979123f, 0.01825471f, -0.31676441f, 0.06444024f, 0.15151516f, -0.12235992f, 
    -0.11863232f, -0.14210510f, -0.06709924f, -0.11558712f, -0.16190688f, -0.03694214f, -0.14265962f, -0.13518046f, 
    -0.00394544f, -0.32744697f, -0.42190531f, -0.19765069f, -0.03757080f, 0.02265336f, 0.10078032f, -0.00001000f, 
    0.00928015f, -0.05000462f, -0.01079916f, 0.01550507f, -0.04971100f, -0.00549107f, -0.01125786f, -0.11018538f, 
    -0.06402875f, -0.04238313f, 0.08567669f, -0.08785610f, -0.05643716f, 0.00580360f, -0.06211513f, -0.04427941f, 
    0.08783304f, -0.05482119f, -0.22520307f, -0.32890171f, -0.09561893f, -0.03800418f, 0.08134189f, -0.00029166f, 
    -0.01763397f, -0.01345754f, -0.08231349f, -0.04195634f, -0.16676494f, 0.17098622f, -0.03246256f, -0.11334015f, 
    0.07531359f, 0.11214610f, -0.04127246f, 0.03978917f, 0.00190535f, 0.00796648f, -0.08585355f, 0.13604856f, 
    0.06225016f, 0.03979788f, 0.02302855f, -0.01404297f, 0.08329771f, -0.00729057f, -0.04415473f, -0.00055108f, 
    0.07838042f, 0.09654541f, 0.11151069f, 0.08093402f, -0.18069714f, -0.24322687f, -0.13575181f, -0.08966197f, 
    0.15441039f, 0.03943388f, 0.01843533f, 0.04767875f, -0.03435007f, 0.16915183f, -0.04373478f, 0.05380737f, 
    0.09187301f, -0.61048776f, -0.40042657f, -0.04301075f, -0.00953775f, 0.13105901f, 0.07653610f, 0.12545361f, 
    -0.00166532f, 0.07845980f, 0.01261907f, 0.05883016f, -0.20436080f, -0.00895866f, 0.06693970f, 0.13613120f, 
    0.06619498f, 0.04373588f, -0.01827131f, 0.01252352f, -0.20439130f, 0.00597830f, -0.12091653f, -0.38160786f, 
    -0.32043782f, -0.35922164f, -0.12146834f, 0.22875932f, 0.01656878f, 0.01828733f, 0.10461670f, 0.12502606f, 
    -0.00706018f, 0.03850742f, 0.05838229f, 0.16374409f, 0.16838329f, -0.09128872f, -0.02304892f, -0.03225365f, 
    -0.07237897f, -0.07275520f, -0.04713231f, 0.05389881f, 0.05353506f, 0.03009742f, 0.00071378f, -0.05403236f, 
    0.08250146f, -0.06277385f, 0.04266230f, -0.18544303f, 0.03618033f, -0.05779775f, -0.00869605f, 0.03923158f, 
    0.06515562f, -0.00187377f, 0.07568343f, 0.06308175f, -0.02060559f, -0.10083162f, -0.05876604f, 0.03954530f, 
    0.06989609f, 0.04628214f, 0.03847434f, 0.04297262f, -0.09759516f, 0.04040645f, -0.02891434f, -0.00238361f, 
    -0.26301968f, -0.34563178f, -0.33457384f, -0.52180040f, -0.31864682f, -0.15903510f, -0.06419357f, -0.16231403f, 
    0.04268941f, 0.07233058f, 0.10598879f, 0.05540996f, -0.35734919f, -0.12518072f, 0.21812786f, 0.05605618f, 
    0.11409331f, 0.23994783f, -0.09317743f, -0.34908685f, -0.15330520f, -0.02535741f, -0.10157058f, -0.10263729f, 
    -0.03402032f, 0.11147490f, -0.11981150f, 0.02105694f, 0.20224835f, 0.04555021f, -0.12456903f, -0.13491325f, 
    0.08916775f, 0.15423523f, 0.09311921f, 0.04534394f, -0.16780704f, 0.27223518f, -0.75436741f, -0.06855860f, 
    0.04450965f, -0.02959958f, 0.19214211f, 0.16862728f, -0.00349985f, -0.01331494f, -0.10394204f, -0.04650099f, 
    0.31770223f, 0.12281951f, 0.03996452f, -0.03700098f, -0.10995034f, -0.11427458f, -0.00147625f, 0.01156727f, 
    0.04113613f, 0.08297747f, -0.02792925f, -0.00702069f, -0.19942518f, 0.01855544f, -0.28956065f, 0.03870110f, 
    0.16614819f, 0.06057298f, 0.16005042f, 0.05751402f, 0.06150445f, -0.16241366f, -0.07587312f, -0.01902018f, 
    -0.43410608f, -0.03712012f, -0.22581269f, 0.02698070f, -0.01367604f, 0.09633805f, -0.02527819f, 0.03876166f, 
    0.01821902f, -0.00532584f, -0.04871792f, -0.19230412f, 0.09340546f, 0.12475187f, 0.35255334f, -0.02926322f, 
    0.10195130f, -0.17552315f, -0.20466083f, -0.24868321f, 0.01194584f, -0.00730587f, 0.12155908f, 0.09955927f, 
    -0.27261817f, 0.06343564f, -0.26141751f, 0.06090823f, 0.08002853f, 0.06553931f, 0.10322823f, -0.00436799f, 
    0.13418014f, 0.03695952f, 0.02021006f, -0.02395608f, 0.22609015f, -0.08763414f, 0.27090380f, 0.30701083f, 
    0.06502736f, -0.16262966f, -0.06309900f, -0.09658102f, -0.03697052f, -0.04084991f, 0.17450821f, 0.13042942f, 
    0.15742731f, 0.03669480f, 0.03856625f, -0.12706713f, -0.13531011f, -0.00394054f, -0.25399151f, -0.01801667f, 
    -0.18595771f, -0.00759644f, -0.00305710f, -0.03573515f, -0.23364617f, -0.05610038f, -0.02069745f, -0.16255309f, 
    -0.13939832f, 0.06706648f, 0.05254627f, 0.05928697f, 0.08126815f, 0.04653863f, 0.10502630f, -0.03092266f, 
    0.18909542f, 0.16192637f, -0.29773653f, 0.06966883f, 0.18686038f, 0.17520855f, 0.10211723f, -0.05047066f, 
    0.16269335f, 0.07597356f, -0.18011796f, -0.11197346f, 0.06540295f, -0.34573835f, 0.17420070f, 0.10998351f, 
    -0.04943130f, 0.02533604f, -0.24036716f, -0.06966213f, 0.02690639f, -0.08801164f, -0.14335442f, 0.03932611f, 
    0.35225138f, -0.38959447f, -0.06970409f, -0.11131652f, 0.12559123f, 0.13942297f, 0.02796637f, 0.11618572f, 
    0.08687706f, -0.06527311f, -0.09437164f, -0.17411442f, 0.03737457f, -0.07056416f, 0.03281002f, -0.06948950f, 
    -0.11065302f, 0.03553749f, 0.00989065f, -0.09566576f, 0.02340237f, 0.08673231f, -0.25534236f, -0.02949705f, 
    -0.06603027f, 0.23356947f, 0.17063293f, -0.21351911f, -0.00497313f, -0.11755345f, -0.04192033f, 0.08949043f, 
    0.08001194f, 0.07552370f, 0.01148216f, -0.00945770f, -0.01599151f, 0.16849165f, 0.23471101f, -0.00092285f, 
    -0.12456060f, -0.08545230f, -0.20728441f, -0.23546077f, 0.11932228f, -0.11784528f, 0.02038543f, 0.12703305f, 
    -0.12081639f, -0.43639138f, -0.26990324f, 0.04396854f, 0.09881572f, -0.06540522f, 0.08045211f, 0.01929166f, 
    0.00843387f, -0.07387179f, 0.05916306f, -0.05753459f, -0.09574122f, 0.00432798f, -0.16615291f, -0.08131282f, 
    0.02967156f, 0.05899109f, 0.18214832f, 0.15867639f, 0.00403085f, 0.09178872f, -0.07355998f, -0.05545307f, 
    -0.05609868f, 0.26279977f, -0.26787269f, -0.36810720f, -0.29499498f, 0.02342167f, -0.17497179f, -0.19346713f, 
    0.04870158f, -0.01450216f, 0.03652576f, 0.10697539f, -0.47098923f, 0.04903320f, -0.41872147f, 0.03085175f, 
    -0.25926363f, 0.02392496f, -0.15191332f, -0.14594813f, 0.02239774f, -0.11602905f, -0.14296527f, 0.04646783f, 
    0.02599405f, -0.15148751f, 0.12076215f, -0.01112242f, -0.02186530f, -0.00410279f, -0.04940473f, -0.11459822f, 
    -0.05157059f, 0.14751235f, 0.07753745f, -0.08411296f, 0.12049854f, 0.52573627f, -0.48872837f, 0.02168279f, 
    -0.21383213f, 0.00295280f, 0.05493798f, 0.06366169f, 0.07119640f, 0.06434104f, 0.07336894f, -0.02583658f, 
    -0.31889364f, -0.86197829f, 0.16579920f, 0.01774170f, -0.00016656f, 0.13685472f, -0.04668377f, 0.10212972f, 
    -0.08391041f, 0.04124641f, 0.04428669f, -0.08829278f, 0.08449196f, -0.24375193f, 0.15075479f, 0.07745378f, 
    0.06395143f, 0.00986841f, 0.07582752f, -0.04188221f, -0.05702525f, -0.01562643f, -0.00910494f, -0.06309745f, 
    0.05186054f, -0.21962772f, 0.07861712f, -0.10053241f, 0.13048123f, -0.02272634f, 0.06236467f, 0.03374944f, 
    0.19661000f, -0.03367600f, -0.01515839f, -0.09976502f, -0.11965767f, 0.00738976f, 0.06467987f, 0.02167796f, 
    0.17919067f, -0.01136315f, 0.05355788f, 0.06916866f, -0.05507456f, -0.02771612f, -0.17596573f, -0.17216425f, 
    -0.09986954f, -0.10617460f, 0.10616330f, -0.02778155f, -0.05430197f, 0.17945024f, 0.12113919f, 0.04159333f, 
    0.07227077f, 0.03653371f, -0.05929632f, 0.03455740f, -0.04187238f, -0.06594708f, 0.04674034f, 0.12654866f, 
    0.06075105f, 0.17937954f, -0.04745442f, -0.01546106f, 0.20337322f, 0.12341733f, -0.00994752f, 0.06288105f, 
    0.06270162f, -0.26665965f, 0.03265474f, -0.24469590f, 0.15666072f, -0.04934825f, -0.11646739f, 0.11494961f, 
    -0.03847167f, 0.03325946f, 0.01151870f, 0.14623886f, -0.31928530f, 0.03293427f, -0.34744129f, -0.00132302f, 
    -0.15421650f, -0.01541998f, 0.13327499f, -0.04550020f, 0.08574930f, -0.08537097f, -0.09198941f, -0.09704918f, 
    0.07008034f, -0.13652173f, 0.01756364f, 0.18836123f, 0.09778783f, -0.06228555f, -0.04270065f, 0.03433011f, 
    -0.04012648f, -0.08679384f, 0.06243406f, 0.01871343f, -0.35560393f, 0.16887972f, -0.11273605f, -0.36878586f, 
    -0.10384657f, -0.02511558f, 0.01278935f, -0.05133304f, 0.03389714f, 0.02829638f, -0.04895480f, -0.01130406f, 
    -0.28977484f, 0.09148219f, 0.15627317f, 0.34882662f, 0.05692255f, 0.12679824f, -0.18090136f, 0.13253470f, 
    -0.04618607f, -0.11241013f, 0.00552113f, 0.00073910f, -0.22035345f, -0.06933379f, -0.07410505f, 0.05209836f, 
    0.21657726f, -0.15367100f, -0.08719026f, 0.10100964f, 0.09543417f, -0.03397587f, -0.06828962f, 0.09447513f, 
    0.09311849f, -0.56253511f, 0.16450137f, -0.03891474f, -0.07783856f, 0.12932038f, -0.05557804f, 0.16919091f, 
    0.09346911f, 0.05790896f, -0.05008299f, -0.05265453f, -0.15058883f, 0.02342529f, 0.14917584f, 0.08668951f, 
    0.07981931f, -0.11795948f, 0.00108531f, -0.08922341f, 0.07340856f, -0.07914942f, -0.09359454f, -0.00967741f, 
    0.24358310f, -0.35994098f, 0.31955534f, -0.67117929f, 0.02113652f, -0.06957022f, -0.11515782f, -0.12254081f, 
    -0.00602695f, 0.08016094f, 0.01672741f, 0.07758582f, 0.22419336f, -0.40537566f, 0.20305681f, -0.57443452f, 
    -0.03002289f, 0.05098191f, -0.23083448f, 0.10065114f, -0.03770633f, -0.06500675f, -0.06065828f, 0.01032008f, 
    0.01561298f, -0.13433887f, 0.18846692f, 0.12881872f, -0.00133008f, -0.02801390f, -0.09434848f, -0.09761053f, 
    0.04143881f, 0.01780456f, 0.08752359f, 0.19122955f, 0.20967549f, -0.40702313f, -0.24142699f, -0.15209854f, 
    0.13598822f, -0.06991055f, 0.07904172f, -0.05181266f, -0.08464752f, -0.04353181f, -0.06058719f, -0.05980805f, 
    0.12455439f, -0.04861302f, 0.15295072f, -0.02696246f, 0.23773228f, -0.07919222f, -0.01827020f, 0.02339784f, 
    -0.16254334f, 0.11554242f, -0.08651317f, 0.06857358f, -0.10486022f, 0.20038757f, -0.05138833f, -0.08122505f, 
    0.05437450f, 0.02141948f, 0.08108042f, -0.03389068f, 0.02869769f, -0.10101114f, -0.06288947f, -0.08960529f, 
    0.24388748f, -0.20225285f, -0.05478157f, -0.09046543f, -0.01760239f, -0.02391159f, -0.15897574f, -0.22227015f, 
    -0.04213255f, -0.05049663f, -0.07649647f, 0.02861034f, -0.05835532f, -0.32886615f, -0.07604004f, 0.00280356f, 
    -0.01806309f, 0.21562506f, 0.09372342f, -0.11792915f, 0.19221164f, -0.07086040f, -0.01801470f, -0.05381873f, 
    -0.27818704f, -0.08955012f, -0.56297040f, 0.21293178f, -0.05891462f, -0.05404498f, -0.02553294f, -0.18303569f, 
    -0.00162466f, 0.00346147f, 0.01476814f, 0.05197632f, 0.17024495f, 0.16923039f, 0.26996657f, 0.52075416f, 
    0.22337449f, -0.11884226f, -0.15528545f, -0.12076470f, -0.09095049f, -0.03149937f, -0.22206636f, 0.00348193f, 
    -0.42502350f, -0.18412223f, 0.26726884f, 0.51866210f, 0.10424396f, -0.01455457f, -0.00346469f, -0.18208002f, 
    0.03817777f, -0.02703201f, 0.02183857f, -0.04643118f, -0.08263188f, -0.03692183f, 0.26339504f, -0.05680467f, 
    -0.05920800f, -0.04442899f, -0.09050256f, -0.16936165f, 0.11187170f, 0.06902190f, 0.04013681f, 0.10891858f, 
    -0.06288680f, 0.18205088f, 0.04510583f, -0.30822811f, -0.09921670f, -0.08287144f, 0.13722283f, 0.29243952f, 
    -0.00982578f, 0.04392749f, 0.00390657f, -0.06712582f, -0.15612100f, -0.21910912f, 0.04361471f, 0.03758668f, 
    0.08704937f, 0.09454865f, 0.09207796f, 0.08944031f, 0.01537258f, 0.00973885f, 0.03401151f, 0.13690111f, 
    -0.02657028f, -0.12542711f, 0.07387646f, 0.18537439f, 0.07330360f, -0.15644926f, 0.06500255f, 0.09429277f, 
    0.02925346f, -0.00659994f, 0.05528745f, 0.08011963f, 0.25911736f, -0.22041935f, -0.02527719f, -0.06929784f, 
    0.06544811f, 0.19063912f, -0.11525471f, -0.06200531f, -0.00357921f, -0.02012445f, 0.05481552f, -0.11413694f, 
    -0.19673686f, -0.07044282f, 0.02332810f, 0.04724019f, 0.15323034f, -0.08766936f, 0.12577580f, 0.18266830f, 
    -0.00415823f, 0.09400913f, 0.09602301f, -0.00931919f, -0.09462328f, -0.03134071f, -0.17972669f, 0.06734681f, 
    0.17970479f, -0.06185319f, -0.00650049f, 0.06407629f, 0.14310177f, -0.03278893f, -0.03737414f, -0.05796108f, 
    -0.17624754f, -0.02773060f, -0.24861950f, 0.08998445f, 0.03067536f, 0.01262694f, 0.04804598f, 0.00516919f, 
    -0.01404888f, -0.12921223f, -0.12288801f, -0.07375859f, 0.17686459f, 0.18123683f, 0.03411126f, -0.25779244f, 
    -0.07950278f, -0.17936260f, 0.04622848f, -0.17430867f, 0.08121188f, 0.14207610f, -0.08680936f, -0.05809867f, 
    -0.03461213f, -0.15688467f, 0.14764962f, 0.01562981f, -0.06711630f, -0.11017941f, -0.10993829f, 0.02574007f, 
    -0.06811324f, -0.02020062f, 0.02719127f, -0.03325754f, -0.01012031f, 0.08279333f, 0.02715057f, -0.07542620f, 
    -0.00279225f, 0.01727199f, 0.04562453f, -0.06090155f, 0.02064238f, 0.14459050f, 0.17277265f, 0.18290468f, 
    0.25357902f, 0.08733772f, 0.34651974f, -0.36697173f, 0.09359199f, -0.26703659f, -0.17311753f, 0.10423896f, 
    -0.13201191f, -0.05824475f, 0.10532739f, -0.04060412f, -0.05363240f, -0.17484237f, -0.04355885f, 0.39821565f, 
    -0.11296105f, 0.07071355f, -0.13365559f, -0.01975079f, 0.17120549f, -0.04056848f, 0.06289033f, -0.06172011f, 
    0.06091003f, 0.15128751f, 0.04784605f, 0.01198599f, 0.12080802f, 0.02061965f, -0.02388684f, -0.19692378f, 
    -0.03906944f, -0.15898587f, 0.07780766f, -0.00561834f, -0.17777406f, 0.27847236f, -0.15545844f, 0.15801604f, 
    0.06853976f, -0.05849906f, -0.11671284f, -0.01293358f, 0.10126854f, -0.06820802f, -0.06186951f, -0.10701419f, 
    -0.25716624f, -0.13003458f, -0.06016453f, -0.17084053f, -0.28829634f, 0.05417611f, 0.14026845f, 0.19282819f, 
    0.10187969f, 0.06488834f, 0.09090544f, -0.13695207f, 0.14143723f, -0.36749303f, -0.03574801f, -0.35036331f, 
    0.10632519f, 0.02477993f, 0.01359354f, 0.10483587f, -0.06531410f, -0.00794049f, 0.00697052f, 0.03638079f, 
    -0.05121870f, 0.09367255f, 0.07040295f, -0.04047837f, -0.07168724f, -0.07263708f, 0.03680593f, 0.01160605f, 
    -0.09885248f, 0.11767409f, -0.24681559f, -0.16047587f, 0.05365211f, -0.02674234f, -0.16451526f, 0.03334600f, 
    -0.23370710f, 0.00612807f, 0.06596087f, -0.04987770f, -0.01770984f, 0.08780025f, -0.12457177f, 0.03332063f, 
    -0.54833156f, 0.01846819f, 0.07202008f, -0.24055961f, 0.08892207f, 0.11684394f, 0.07679082f, -0.03320417f, 
    -0.18903437f, 0.08333264f, -0.03447743f, 0.10706456f, -0.12136225f, 0.08306701f, -0.06414391f, -0.03135054f, 
    -0.07800395f, 0.07442325f, -0.01075670f, 0.00274698f, -0.05306549f, 0.02707890f, -0.10221858f, 0.01209580f, 
    0.21511288f, -0.00377181f, 0.21692437f, -0.13644856f, 0.01588141f, 0.05841345f, 0.08006639f, 0.20604655f, 
    -0.02355792f, 0.15305483f, 0.07739726f, 0.06042086f, 0.11709879f, 0.00052267f, 0.05337459f, 0.00497270f, 
    -0.02975731f, -0.05981931f, -0.02692687f, 0.11839615f, -0.00814897f, 0.07971755f, -0.06168674f, -0.01654702f, 
    -0.14045979f, -0.39617252f, 0.02237388f, -0.17701085f, -0.14722726f, -0.04661384f, 0.06364228f, -0.00825287f, 
    -0.08455942f, -0.07999536f, 0.00451275f, -0.00356022f, -0.59219879f, 0.44697666f, -0.06846940f, -0.09949074f, 
    -0.00244587f, -0.05127825f, -0.23926058f, 0.08150388f, -0.03321758f, -0.01485419f, -0.04320189f, -0.14501865f, 
    0.13986166f, 0.22773929f, -0.09675123f, 0.00941504f, 0.00277388f, 0.08704674f, -0.00508300f, 0.03571061f, 
    -0.01779979f, 0.06934247f, -0.07814716f, 0.06472630f, 0.07872457f, -0.42210940f, -0.31047562f, -0.08533018f, 
    0.04107637f, -0.06215591f, 0.01362902f, 0.19441728f, -0.01774006f, 0.03849853f, -0.00982466f, -0.02608376f, 
    -0.26312324f, -0.32874167f, -0.22377332f, -0.20612223f, -0.09472924f, -0.07337444f, 0.14252165f, -0.11209830f, 
    -0.12032472f, -0.04293058f, -0.07678322f, 0.02715847f, -0.30181956f, 0.12594850f, -0.41129628f, 0.08913348f, 
    0.11319597f, 0.00094721f, 0.07484417f, 0.01232912f, -0.02269172f, 0.15596955f, 0.04396446f, 0.02137327f, 
    -0.24184737f, -0.06191438f, 0.16476800f, 0.00403911f, 0.02120226f, 0.08574987f, -0.03606604f, 0.02566720f, 
    -0.05408271f, 0.11003251f, 0.15171795f, -0.00051740f, 0.04165673f, 0.04334534f, 0.01045779f, 0.23496708f, 
    0.03966083f, -0.01114283f, 0.05608579f, -0.21447946f, 0.10172340f, 0.05954551f, 0.09830814f, 0.13610034f, 
    0.00175449f, 0.06610141f, 0.12918334f, 0.03565342f, -0.01622274f, -0.14047353f, 0.11191158f, 0.07090692f, 
    -0.13766240f, -0.15455002f, -0.22603138f, -0.22235876f, 0.20535177f, 0.05086010f, 0.02454782f, -0.17247662f, 
    0.08058511f, -0.21437061f, -0.03048359f, 0.07361264f, -0.17083821f, 0.09821167f, -0.10599712f, -0.25374654f, 
    -0.42319679f, 0.02930168f, 0.03255468f, 0.09220261f, 0.07498059f, -0.00509476f, -0.08317020f, 0.04880021f, 
    -0.12749390f, 0.06581210f, 0.03444795f, 0.05807758f, -0.04507427f, -0.18815951f, 0.15806511f, 0.08091016f, 
    -0.11602515f, -0.06603796f, 0.03271695f, -0.01236315f, 0.00534646f, -0.09569407f, 0.05753905f, 0.07820731f, 
    0.15809970f, 0.13912219f, 0.07917546f, 0.12582800f, 0.03170132f, -0.18892258f, 0.08043707f, 0.09311336f, 
    -0.18187840f, 0.06424072f, 0.00672742f, -0.08852000f, 0.16345130f, -0.11547241f, 0.04006129f, -0.17580390f, 
    -0.13374208f, -0.01560488f, 0.29580444f, -0.01895235f, 0.03549138f, 0.08634157f, -0.07654147f, 0.05575180f, 
    -0.41819316f, 0.12194866f, 0.08626325f, 0.05760705f, 0.07841132f, 0.00245198f, -0.04552240f, -0.08019836f, 
    -0.14553723f, -0.05044959f, 0.07797842f, -0.24751896f, 0.04305289f, -0.07635041f, 0.07558355f, -0.00546228f, 
    -0.02815775f, -0.15104657f, 0.08041283f, -0.12221611f, -0.08850389f, 0.01424496f, -0.13630404f, 0.10689043f, 
    -0.47434208f, 0.05088093f, -0.62063140f, 0.31478277f, -0.04831815f, 0.09911913f, 0.15807901f, 0.09339660f, 
    0.03743762f, -0.07716752f, -0.12236149f, -0.04409940f, -0.09478582f, -0.04428987f, -0.30348796f, 0.30069092f, 
    -0.07480767f, 0.00096969f, -0.13319224f, 0.02711716f, -0.00995588f, 0.02934545f, -0.01723715f, 0.13479544f, 
    -0.29781124f, -0.05323768f, -0.11050933f, 0.07052787f, -0.03732315f, 0.07358295f, -0.09462976f, 0.13860945f, 
    -0.16942574f, -0.06124215f, -0.05141465f, -0.12851825f, -0.14750062f, 0.05864871f, 0.13186951f, 0.12835446f, 
    -0.07927904f, 0.04196859f, -0.10437024f, 0.08675114f, 0.03703824f, -0.06516524f, 0.17661184f, 0.18575189f, 
    0.13789631f, -0.06999565f, 0.16109852f, -0.14129215f, -0.11693475f, -0.04559708f, 0.05403676f, -0.01779142f, 
    0.01507953f, 0.03376625f, -0.18402061f, -0.06904732f, -0.20343511f, 0.21544786f, -0.09017584f, 0.00450169f, 
    -0.10432199f, -0.24420753f, -0.06873900f, -0.07971241f, -0.23661646f, -0.09263121f, 0.17439908f, 0.16053875f, 
    -0.01192997f, -0.05277118f, 0.13089508f, 0.26751587f, 0.03314725f, 0.01416275f, -0.19159001f, 0.07957493f, 
    0.04354469f, 0.15184011f, 0.07592821f, -0.04574818f, 0.09119921f, 0.01303923f, -0.22738989f, -0.08354148f, 
    -0.15162490f, 0.02739706f, 0.07013934f, -0.02474157f, -0.00322137f, 0.14286512f, 0.03069954f, 0.14824733f, 
    -0.26223460f, 0.14362316f, -0.10087904f, 0.09128859f, 0.00364825f, 0.05848824f, 0.10847469f, -0.04438455f, 
    0.17793582f, -0.08763738f, 0.14186227f, -0.07444835f, 0.15965030f, 0.07465050f, 0.19673230f, 0.05789806f, 
    0.09685835f, -0.02123383f, 0.01193492f, -0.00404627f, -0.12672912f, 0.00255441f, -0.01540268f, -0.01415402f, 
    0.02219785f, 0.10257987f, 0.06225194f, -0.11298741f, -0.07124233f, -0.03520874f, -0.06471499f, -0.04731125f, 
    0.01610138f, 0.06745516f, -0.09409733f, 0.14555168f, -0.19765942f, 0.32974300f, 0.08101013f, -0.01200024f, 
    -0.06947306f, 0.04367141f, -0.04713586f, 0.10375230f, 0.03835500f, 0.00627101f, 0.06509317f, 0.04291072f, 
    -0.04536181f, -0.12616943f, -0.10251239f, 0.14338253f, 0.05863802f, 0.23464632f, 0.15242906f, 0.04236734f, 
    0.03579364f, -0.04872675f, 0.02450930f, -0.00168191f, 0.08335125f, 0.08103779f, 0.17209406f, 0.09421578f, 
    -0.12448762f, 0.15235025f, 0.02943724f, 0.06032918f, 0.06022380f, -0.11896040f, 0.06590646f, 0.04526972f, 
    0.03183658f, -0.23850192f, -0.13599026f, 0.37138626f, 0.08081042f, 0.02011551f, 0.01171757f, 0.05236441f, 
    -0.04062158f, -0.12830986f, -0.39846793f, -0.37266916f, -0.14364186f, 0.29244399f, 0.21437341f, -0.01370162f, 
    0.12039078f, 0.13120963f, -0.27876160f, -0.01444447f, 0.03573371f, -0.09555002f, -0.08589407f, 0.04329548f, 
    -0.20312022f, 0.23491554f, -0.11979222f, 0.01973397f, -0.03785905f, 0.28338924f, -0.09295760f, 0.00819419f, 
    -0.16496316f, -0.08409131f, -0.19587012f, -0.41406333f, -0.25367680f, 0.03760441f, 0.05580864f, -0.02871017f, 
    -0.08948002f, 0.08308644f, 0.21861272f, 0.06655797f, -0.04145471f, 0.11158836f, 0.10298431f, 0.01606739f, 
    -0.07761546f, 0.12647566f, 0.42951959f, -0.09856393f, -0.04787840f, -0.09470881f, -0.06962467f, 0.05025190f, 
    -0.11308534f, -0.11516081f, 0.40744668f, 0.04615992f, -0.09478865f, 0.10569115f, 0.06767565f, 0.08563124f, 
    -0.08461394f, -0.02745269f, 0.18132912f, 0.12097678f, -0.13232049f, 0.11649603f, 0.06207462f, 0.09086827f, 
    -0.24309614f, 0.28054562f, 0.00820459f, -0.08467342f, 0.00649642f, 0.03968584f, 0.04119497f, -0.00016666f, 
    -0.14885460f, 0.09616574f, 0.07322791f, 0.00023777f, -0.18283588f, 0.13740021f, 0.01847558f, -0.10045256f, 
    -0.11138217f, -0.00234926f, -0.00976328f, -0.08630192f, -0.02231004f, -0.00265414f, -0.11434694f, -0.07766820f, 
    0.06371383f, 0.40776375f, 0.04476299f, -0.23975538f, -0.17036209f, 0.00449720f, 0.11042285f, 0.23393293f, 
    0.10083801f, 0.11172532f, -0.00006880f, 0.10131902f, -0.04747761f, 0.07322707f, 0.08901756f, -0.24133042f, 
    -0.11410776f, -0.08649539f, 0.03097604f, -0.01502608f, 0.05557703f, 0.07214472f, 0.03788687f, 0.12067568f, 
    -0.60100448f, 0.31329036f, -0.16847031f, -0.25500616f, 0.01816361f, 0.14081150f, 0.14938432f, 0.00268924f, 
    -0.08477112f, -0.04716295f, -0.18682532f, -0.13219830f, -0.06570800f, -0.05527913f, -0.27598268f, -0.08241156f, 
    0.06944522f, -0.07537088f, -0.02862938f, 0.03983817f, -0.01768514f, 0.06423192f, -0.10037236f, -0.17913510f, 
    -0.10344545f, -0.37672570f, 0.01048250f, 0.19825512f, -0.07588706f, -0.07836435f, -0.00008131f, -0.06025615f, 
    0.10546381f, 0.15957916f, -0.02193821f, 0.09175066f, -0.13205737f, -0.11039677f, -0.19441478f, -0.16706951f, 
    -0.22517808f, -0.10573657f, -0.05075568f, -0.14401935f, -0.02228878f, -0.06447956f, -0.13088907f, -0.04536533f, 
    -0.21738555f, 0.05440904f, -0.28204730f, 0.10664006f, -0.08950596f, -0.07188989f, -0.15743238f, 0.10806397f, 
    -0.01887436f, 0.10886012f, -0.05296708f, -0.03747375f, -0.32944375f, 0.11731310f, 0.18215257f, -0.13226089f, 
    -0.14341775f, 0.24134234f, 0.16364132f, -0.03054561f, 0.12093612f, -0.02391053f, 0.03948249f, -0.03610220f, 
    -0.15324856f, 0.07044935f, -0.19447872f, 0.00007685f, -0.08415927f, -0.03673273f, -0.02105874f, 0.04715556f, 
    0.03174657f, 0.14366053f, 0.00781477f, -0.11278491f, -0.04956296f, 0.14594555f, -0.15731852f, -0.01981951f, 
    -0.06310039f, -0.06253183f, 0.07419741f, 0.07064337f, -0.03809742f, 0.16585059f, 0.05774935f, 0.05360336f, 
    0.04453887f, -0.04679972f, 0.06827369f, 0.02389683f, -0.12225150f, 0.11495933f, 0.03835963f, 0.06549989f, 
    -0.09122331f, 0.00590869f, 0.06448457f, 0.07943230f, -0.07827701f, 0.00481704f, -0.04530662f, 0.34782293f, 
    0.04711840f, 0.05398702f, 0.05961757f, -0.11439805f, -0.04650796f, -0.04968843f, 0.09994349f, 0.14199467f, 
    -0.00574164f, -0.14093791f, -0.04004137f, 0.09871358f, -0.08512848f, -0.03799004f, 0.12128829f, 0.08616243f, 
    0.04856841f, 0.07940979f, -0.04202432f, 0.00864997f, -0.01069170f, 0.13908444f, -0.07725298f, 0.09935729f, 
    -0.02815923f, -0.11839917f, -0.05620938f, 0.11582264f, -0.26909083f, -0.36679402f, -0.29645139f, -0.42852363f, 
    0.10619012f, 0.05691493f, -0.00431564f, 0.16473392f, -0.13296822f, -0.10233276f, -0.05874408f, 0.08701675f, 
    0.06149289f, -0.07208128f, 0.01212136f, -0.06703711f, 0.01874635f, 0.06245401f, 0.37095383f, 0.25733876f, 
    0.02055594f, -0.02428722f, -0.02375723f, -0.19470520f, -0.10114295f, 0.16413124f, -0.12249149f, -0.12402496f, 
    -0.24631101f, 0.12942891f, -0.17195906f, -0.20460901f, -0.08637314f, 0.02221118f, 0.06211489f, -0.00844685f, 
    -0.03425032f, 0.07522067f, -0.00068461f, -0.04987999f, -0.18285511f, 0.11219554f, 0.19330338f, 0.13418208f, 
    0.12046997f, -0.03147526f, -0.10938287f, 0.02011547f, -0.14830591f, 0.11161389f, -0.03164481f, -0.00490284f, 
    -0.09924048f, -0.49586469f, 0.01044331f, -0.04967625f, -0.10175293f, -0.00721382f, -0.04355513f, -0.08324871f, 
    0.18068019f, 0.14458445f, 0.09965054f, -0.05439558f, -0.21672782f, 0.28965360f, 0.40096000f, 0.09057183f, 
    0.03008966f, -0.00698738f, -0.14181332f, 0.10389398f, -0.25077814f, -0.04225986f, -0.03127908f, -0.16103749f, 
    -0.01355037f, 0.05904222f, -0.07781161f, 0.01270173f, -0.02071525f, 0.11033700f, -0.03296117f, 0.01371528f, 
    0.04602420f, -0.04611082f, -0.06625491f, -0.09161548f, 0.27991974f, -0.15298399f, 0.56166756f, 0.10620268f, 
    0.04510169f, -0.08473306f, 0.00155206f, 0.01348089f, 0.06566411f, -0.05871216f, 0.07128018f, -0.07475770f, 
    -0.20568639f, 0.03994758f, -0.09827010f, 0.24685322f, 0.10780577f, -0.01182024f, -0.04782489f, -0.03865846f, 
    0.06651744f, 0.06020463f, 0.12160981f, 0.06956372f, 0.38887390f, 0.04842070f, 0.03500690f, -0.11288057f, 
    -0.01659859f, -0.04328162f, 0.06686506f, 0.10178951f, -0.05978237f, 0.07305346f, -0.00784784f, -0.11481726f, 
    -0.09101266f, 0.01649337f, 0.14314412f, -0.03845124f, -0.00992589f, 0.04816141f, 0.01472464f, -0.09099542f, 
    0.12034955f, 0.04660769f, 0.10543837f, -0.04677958f, -0.22923794f, -0.11864534f, -0.07367493f, -0.13088344f, 
    0.03152469f, -0.13750714f, 0.04911369f, -0.02932087f, -0.02151217f, 0.10475100f, -0.12200811f, -0.11328747f, 
    0.23192285f, -0.00797233f, 0.31824073f, -0.23344791f, -0.02328964f, -0.00710200f, -0.03746976f, 0.04221288f, 
    -0.24611640f, 0.15279312f, 0.15997046f, -0.10083277f, -0.54519492f, 0.06644486f, -0.23942111f, 0.17150775f, 
    -0.00897539f, -0.03663830f, -0.00013962f, 0.12803014f, -0.27003551f, 0.07886255f, 0.06508724f, 0.08332416f, 
    -0.57075655f, 0.15116853f, -0.45287994f, 0.10927536f, 0.11569929f, -0.28392684f, 0.07266132f, 0.02484668f, 
    -0.06727172f, -0.04215291f, -0.11000071f, 0.09886479f, -0.09692010f, -0.16361290f, -0.11098111f, -0.24136709f, 
    -0.25525811f, 0.02826389f, 0.08892190f, -0.14475606f, -0.01088946f, -0.01787827f, -0.01688182f, 0.01488645f, 
    0.20949499f, 0.22180538f, -0.00039561f, -0.15609963f, -0.06268425f, 0.05091169f, -0.03339749f, -0.06161842f, 
    -0.03981897f, -0.02966261f, 0.11485083f, 0.03060246f, -0.39354867f, 0.21843331f, -0.40317690f, 0.29427141f, 
    0.13920657f, -0.02396127f, 0.11927444f, -0.20955980f, -0.01345664f, -0.12795600f, -0.02103561f, -0.11166098f, 
    0.28036183f, 0.24357636f, 0.14725782f, 0.00201935f, -0.04274986f, 0.04333122f, 0.11628626f, 0.09830662f, 
    0.01577429f, 0.00881847f, 0.01742768f, 0.00993803f, -0.15681908f, 0.03144218f, 0.10589369f, 0.07499103f, 
    0.02888441f, 0.04110680f, 0.08538310f, -0.05617693f, -0.11583423f, 0.09994576f, -0.12356704f, -0.14872554f, 
    -0.17060985f, -0.13381176f, -0.24919957f, -0.10427359f, -0.07331685f, -0.02740082f, 0.04140761f, -0.03604901f, 
    -0.05934484f, 0.12509702f, 0.01376802f, 0.06991217f, -0.11714958f, -0.02431596f, -0.17226291f, -0.28114688f, 
    0.03099433f, 0.03145826f, 0.11643839f, -0.13436007f, 0.03332321f, 0.05021013f, -0.01854319f, -0.11098587f, 
    0.31778076f, 0.12251584f, 0.09312242f, 0.37613076f, -0.02424894f, -0.23761921f, -0.01594829f, 0.12085004f, 
    -0.14675447f, 0.03641768f, -0.04119217f, -0.00909951f, 0.08010037f, 0.08521172f, 0.24959484f, -0.05070660f, 
    -0.04370796f, 0.01845741f, -0.12014601f, -0.00644932f, -0.04835271f, 0.00662956f, 0.02934133f, -0.06327244f, 
    -0.42469037f, 0.25914884f, -0.19848219f, 0.00041728f, -0.06584468f, -0.06068154f, 0.07080073f, -0.17215234f, 
    0.09709097f, -0.02227675f, -0.12956937f, 0.01578925f, -0.10169856f, 0.04118951f, 0.11858076f, -0.25286442f, 
    0.02852784f, 0.01891918f, 0.25600487f, -0.09198873f, -0.06381771f, 0.01620581f, -0.03156656f, -0.01128962f, 
    -0.13925856f, 0.06968880f, -0.17803723f, 0.13572870f, 0.10481405f, 0.02807329f, 0.00315726f, -0.01313075f, 
    0.15095620f, 0.00756141f, -0.04264995f, 0.18440185f, 0.09236644f, -0.08732810f, 0.38415900f, 0.01475077f, 
    0.01539494f, -0.06525336f, 0.00297716f, -0.08909533f, 0.04863462f, 0.01801916f, 0.08117266f, 0.12888405f, 
    -0.45815155f, -0.15802890f, -0.03863113f, 0.27797350f, 0.14352636f, -0.08461755f, 0.21471381f, -0.09195624f, 
    -0.02018503f, 0.03397965f, 0.04817269f, 0.06117243f, 0.19403687f, 0.09744674f, 0.18253249f, 0.01551695f, 
    -0.11457559f, -0.03976941f, -0.05298541f, 0.06091297f, -0.13008308f, 0.00359601f, 0.02935694f, -0.11635190f, 
    0.04927508f, 0.01622217f, -0.12290668f, 0.20527814f, -0.08243617f, 0.15275231f, -0.08483016f, 0.20144179f, 
    0.06969858f, 0.05620645f, 0.01523362f, -0.01929114f, -0.04075772f, -0.04049826f, 0.10292419f, -0.10279339f, 
    0.04028888f, -0.11072373f, -0.14834821f, 0.02931116f, -0.14607741f, 0.14555350f, -0.05283573f, -0.07091404f, 
    0.08489023f, 0.10660104f, 0.16425312f, -0.01350100f, -0.08125806f, -0.03855060f, -0.06271159f, -0.05366658f, 
    0.00693591f, -0.06641281f, 0.06641309f, 0.09255852f, -0.17205316f, 0.06203855f, 0.01211662f, 0.16442117f, 
    -0.18911929f, 0.15216905f, 0.07493424f, 0.03835291f, -0.06981980f, 0.04932273f, 0.12191129f, -0.09740059f, 
    -0.49303171f, 0.17897882f, -0.02804522f, 0.17266695f, -0.03436169f, 0.12139118f, 0.02530163f, 0.15896495f, 
    -0.21438958f, -0.04412153f, -0.02331831f, -0.00700176f, 0.22769915f, -0.20717567f, 0.19881785f, 0.14012423f, 
    0.04747555f, -0.01553579f, -0.02385870f, -0.01852925f, -0.18282691f, -0.11341202f, -0.00508927f, -0.00409663f, 
    -0.03128879f, -0.13783160f, -0.10640117f, 0.13540547f, 0.15234710f, 0.09852975f, 0.11845947f, -0.14061120f, 
    -0.02207551f, 0.02019263f, 0.10456168f, 0.03927593f, 0.09262800f, -0.05717228f, 0.15471302f, -0.17479788f, 
    -0.00661955f, -0.05078965f, 0.03522817f, -0.07542776f, -0.01989440f, -0.04914756f, -0.00773411f, 0.00038483f, 
    -0.30705047f, -0.05724625f, -0.25713867f, 0.05746637f, 0.15952313f, -0.05283530f, 0.04620843f, -0.01523568f, 
    -0.05667452f, 0.00407614f, 0.00014010f, 0.04625735f, 0.09752228f, -0.12675197f, 0.12397308f, 0.02610377f, 
    0.09137886f, 0.06960530f, 0.00692082f, 0.09468409f, 0.06122947f, 0.00759855f, 0.01841644f, -0.13189214f, 
    -0.62555879f, 0.45225343f, -0.26339245f, 0.17391025f, -0.19500184f, -0.10556918f, 0.19747348f, -0.27008885f, 
    0.02272904f, 0.02995015f, 0.11355921f, 0.09960391f, -0.08501662f, 0.10530046f, -0.16633272f, -0.02001128f, 
    -0.02305277f, 0.21285778f, -0.05776793f, 0.03493126f, 0.07214140f, -0.03167885f, 0.06633639f, 0.04328546f, 
    -0.18767780f, -0.04047570f, -0.21523304f, -0.11279204f, -0.04225590f, 0.08945677f, 0.01629278f, 0.03191975f, 
    -0.02154876f, 0.01705460f, 0.16917896f, 0.04727073f, -0.21667340f, 0.24455728f, -0.42474726f, 0.18988638f, 
    -0.11263997f, -0.03979005f, 0.16631378f, 0.20525613f, 0.04781897f, 0.04211828f, -0.06780563f, 0.04393543f, 
    -0.05281598f, -0.22408578f, -0.19636548f, -0.06120668f, 0.07324368f, -0.06498265f, -0.00444611f, 0.01559531f, 
    0.13994338f, 0.04307777f, 0.09125251f, 0.14740416f, 0.41431591f, 0.34495199f, 0.13600270f, -0.21354280f, 
    0.01686155f, 0.05855765f, 0.00044074f, 0.00848483f, 0.00320107f, 0.09461182f, 0.02012356f, -0.03167530f, 
    0.03844890f, -0.09250773f, -0.04735811f, 0.12588905f, 0.09556066f, 0.25365135f, 0.01553620f, 0.14229301f, 
    -0.01630813f, 0.11503885f, -0.04929643f, -0.09101851f, -0.05153688f, -0.03904477f, 0.07191777f, 0.18999204f, 
    -0.02683758f, -0.03594196f, -0.14250351f, -0.19693710f, -0.08954940f, -0.15137130f, -0.12996860f, -0.20339878f, 
    -0.12978768f, 0.28284678f, -0.12821418f, 0.13681969f, 0.13583431f, -0.08946056f, 0.14349407f, -0.22239508f, 
    0.12880176f, -0.05556975f, -0.01798514f, 0.03916797f, 0.14529201f, 0.03674828f, -0.04319933f, -0.03103468f, 
    -0.02751689f, 0.15340453f, 0.00582711f, -0.04901729f, -0.03103483f, 0.01247449f, -0.00731563f, -0.08358847f, 
    0.18689509f, -0.58612698f, 0.42502707f, 0.24508360f, 0.11542664f, -0.13141541f, -0.00978292f, 0.08154827f, 
    0.03043592f, 0.08016083f, 0.03374214f, 0.05786263f, -0.25463292f, -0.23521033f, -0.29646766f, 0.02330065f, 
    0.07341549f, -0.01872378f, -0.07609316f, -0.09151500f, -0.12920044f, 0.02745476f, -0.01431410f, -0.15392475f, 
    -0.06719180f, -0.63714451f, -0.32493669f, 0.00984483f, 0.19138812f, 0.03685858f, -0.04145854f, -0.01007911f, 
    0.01574755f, 0.09512350f, 0.19570175f, 0.01374240f, 0.15462674f, 0.02259813f, -0.00483174f, -0.53108835f, 
    -0.01851848f, -0.15212527f, 0.12287495f, 0.01266355f, 0.05534622f, 0.10159571f, 0.15212765f, 0.01652525f, 
    0.01479350f, -0.27878734f, -0.06943712f, 0.03448392f, -0.11513183f, -0.20147854f, -0.12590931f, 0.00236051f, 
    -0.05361519f, -0.01035433f, -0.07832728f, -0.03592127f, 0.16561839f, 0.15323323f, -0.00290399f, -0.12486226f, 
    -0.08697182f, -0.01569527f, 0.01452384f, 0.00886303f, 0.01513996f, 0.04867400f, -0.02656338f, 0.01493371f, 
    0.03962907f, -0.11366910f, 0.30193946f, -0.37001643f, -0.13351846f, -0.08501066f, 0.10051327f, -0.02182543f, 
    -0.02354924f, -0.02476041f, 0.00597393f, -0.02536275f, -0.06466608f, 0.07616912f, -0.12070714f, 0.06916997f, 
    -0.01136370f, -0.04695676f, -0.09788544f, -0.03427026f, 0.10325702f, 0.06642710f, 0.11688881f, 0.06687326f, 
    -0.15420324f, -0.34441212f, -0.25173354f, -0.03475155f, -0.19429019f, -0.07108841f, 0.01618309f, -0.19310398f, 
    0.04665155f, 0.03644668f, -0.02411479f, -0.02994630f, 0.11029003f, -0.13794476f, 0.07172272f, 0.06381797f, 
    -0.00051993f, 0.07398637f, -0.02228586f, 0.10446630f, 0.01151850f, -0.07134006f, 0.19999492f, 0.03257764f, 
    0.19844556f, -0.07205451f, 0.15866144f, -0.11602375f, 0.08538392f, -0.04218063f, -0.16415286f, 0.06900292f, 
    -0.04445506f, -0.04677508f, -0.17208603f, -0.05470705f, -0.33645499f, 0.01147091f, 0.01293225f, 0.06326364f, 
    -0.08192544f, 0.06409289f, -0.01701392f, -0.14041312f, 0.00487677f, -0.15756133f, 0.06721623f, -0.05990412f, 
    0.10960510f, -0.25243002f, 0.28595960f, -0.38763487f, 0.01143658f, -0.15947697f, -0.18723692f, -0.02903471f, 
    0.01332319f, 0.00735037f, 0.08602799f, 0.00903670f, -0.13291135f, 0.03285903f, 0.08257240f, 0.00683129f, 
    0.01562767f, -0.05103090f, -0.00164855f, 0.00463430f, 0.03186899f, 0.10585883f, 0.09784026f, 0.11437764f, 
    -0.25229925f, -0.13862236f, 0.01339070f, 0.03762697f, -0.00942074f, -0.08399351f, -0.02239252f, 0.06343585f, 
    -0.13018502f, -0.00818152f, -0.06387337f, -0.08436100f, -0.33579770f, 0.22961345f, -0.11442500f, 0.03821424f, 
    0.08148915f, -0.04253843f, 0.00603265f, -0.09952685f, -0.08257588f, -0.01934942f, 0.18389605f, 0.17638963f, 
    0.11319561f, 0.02823978f, -0.02955926f, -0.02135360f, 0.11427363f, -0.02065508f, 0.10282926f, -0.11679222f, 
    0.01696187f, 0.07609750f, -0.11221153f, 0.04145291f, -0.04317987f, -0.17486659f, 0.16455285f, -0.08650462f, 
    -0.05434960f, 0.08746269f, -0.11813858f, -0.08229645f, 0.10971579f, 0.00628625f, 0.06515230f, -0.11213355f, 
    -0.10462631f, -0.41645205f, 0.03033834f, 0.15476178f, -0.15342003f, -0.07527539f, -0.07788769f, -0.14410950f, 
    0.00721895f, 0.04801149f, -0.05371555f, 0.04297907f, 0.07670459f, 0.34596732f, -0.29867098f, 0.17077258f, 
    -0.06924205f, -0.15975975f, 0.11848886f, 0.23681162f, 0.07755789f, 0.00300377f, 0.04218461f, -0.05086894f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15321389f, 0.10776091f, 0.04589486f, -0.04213617f, -0.08248237f, 0.06842021f, 0.02393745f, -0.10324228f, 
    0.03052992f, -0.00698589f, 0.04117376f, 0.02318079f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
