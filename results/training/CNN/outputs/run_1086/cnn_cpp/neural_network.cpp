#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.15004981f, -0.30097270f, 0.84206676f, -0.32020494f, -0.30783999f, -0.62940520f, -0.35998246f, 0.81016493f, 
    -0.35645553f, 0.15576632f, -0.28839925f, 0.35086018f, 0.07467322f, 0.21125272f, 0.61471272f, 1.10244417f, 
    -0.36697367f, -0.69623041f, 0.56266809f, 0.01234087f, 0.71545488f, 0.60420811f, 0.88611871f, 0.93094957f, 
    0.05752164f, 0.22035819f, -0.31436452f, -0.45398372f, 0.42060596f, 0.26098564f, -0.73937780f, -1.18361747f, 
    -0.75967366f, -0.23617981f, -0.14417803f, -0.64690536f, -0.10138366f, -0.00603139f, -0.20781188f, -0.58073622f, 
    -0.69299304f, -0.26557392f, 0.18445402f, 0.66726619f, 0.80289632f, -0.89353436f, -0.64855266f, -0.40534902f, 
    0.43308282f, 0.14532857f, -0.07890331f, -0.59487194f, -0.57268751f, -0.07499282f, -0.07418366f, 0.44830543f, 
    0.06479581f, 0.95197791f, 0.62299025f, 0.10248505f, 0.38529715f, 0.68886197f, 0.38222301f, 0.69155473f, 
    -0.13623998f, -0.40572673f, -0.05216146f, 0.99888337f, -0.51804018f, 0.34794146f, 0.18911059f, 0.41850260f, 
    -0.50656265f, 0.14735256f, -0.03600139f, 0.34468257f, 0.18434384f, -0.77604467f, 0.54855508f, -0.07410879f, 
    0.85807335f, -0.30434394f, 1.73158169f, -1.30916536f, -0.17708635f, -0.14976932f, -0.40952855f, -0.11645523f, 
    0.31369266f, -0.05036749f, -0.38187236f, -0.65834183f, -1.33516586f, 0.04988778f, 0.62877715f, 0.74389160f, 
    0.38287157f, 0.54950142f, 0.15825035f, -0.73096687f, -1.07386827f, -0.42977700f, -0.32746696f, -0.20793021f, 
    -0.10605442f, 0.48291439f, -0.00365969f, -0.18135148f, -0.27199125f, 0.54608142f, -0.62691033f, -0.12952046f, 
    -0.24540551f, 0.30847493f, -0.12230926f, -0.64369744f, -0.74094146f, 0.71289277f, 0.58889431f, -0.29735124f, 
    0.24566640f, 0.58008194f, 0.55420321f, 0.35717654f, -0.33168066f, 0.31147060f, 0.08952836f, 0.28401321f, 
    0.98090500f, -0.75737053f, 0.65939838f, -0.80812579f, 0.21223788f, 0.23799735f, 0.41188473f, 0.14306167f, 
    -0.31959426f, 1.26426387f, -0.38937190f, 0.61571318f, 0.22241014f, -0.18314821f, -0.47873989f, -0.27213910f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06576294f, 0.16274792f, -0.03667303f, -0.05904086f, -0.11673507f, -0.42304045f, -0.27303103f, 0.19281405f, 
    0.34600806f, -0.02305715f, 0.65513396f, -0.41411391f, 0.64672083f, 0.50884509f, 0.31268713f, 0.36325377f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.20580216f, -0.01389633f, 0.10404509f, 0.29544556f, 0.14759588f, 0.00175474f, 0.08001236f, 0.15589280f, 
    0.12826575f, 0.07969010f, 0.07924842f, -0.10341132f, 0.09584963f, 0.22180775f, -0.13559359f, 0.28806922f, 
    -0.31235009f, 0.15989253f, 0.03093266f, 0.04944030f, -0.03242882f, -0.07508598f, -0.06470314f, 0.06477693f, 
    -0.03992743f, -0.11235836f, 0.08962332f, 0.33793527f, 0.47206420f, 0.46116191f, 0.14204583f, 0.05603647f, 
    0.04410493f, 0.09854666f, -0.02229063f, 0.10134718f, -0.04719101f, 0.08131289f, -0.10042666f, 0.12521181f, 
    0.14503929f, 0.05238842f, 0.01447633f, -0.42123854f, -0.40974703f, -0.16965933f, -0.08640157f, -0.13280797f, 
    0.04001449f, -0.07484015f, 0.41427451f, 0.07970867f, 0.23803632f, 0.03068723f, -0.13768937f, -0.03479844f, 
    -0.17887382f, 0.00130870f, 0.15479080f, 0.13486110f, -0.15362568f, -0.23497768f, -0.45242900f, -0.11668084f, 
    0.03057316f, -0.17167531f, 0.08676862f, 0.00648857f, 0.13357051f, -0.00586843f, -0.14654164f, -0.08472691f, 
    0.07647369f, -0.22134121f, -0.07493366f, 0.10260013f, 0.00341604f, 0.27834037f, 0.10005319f, -0.05802476f, 
    -0.44463810f, 0.28474921f, 0.60951138f, 0.05943997f, 0.09981276f, 0.00984625f, 0.09282176f, 0.06472753f, 
    -0.13819718f, -0.02379938f, -0.23640093f, -0.28544483f, 0.13122749f, 0.18031576f, 0.14455716f, 0.08243007f, 
    -0.08192185f, -0.11431487f, 0.18636613f, 0.05180317f, -0.36001161f, 0.09148828f, 0.22805332f, 0.07263275f, 
    0.15067698f, 0.09448978f, 0.10774273f, -0.08831152f, 0.27482408f, 0.24133417f, 0.04756456f, -0.11216892f, 
    0.24185081f, 0.27078632f, 0.35989141f, 0.12306798f, 0.29147017f, 0.05490211f, 0.27337861f, -0.32818112f, 
    0.11745346f, 0.06495259f, -0.02338971f, -0.01434257f, 0.25389716f, -0.11141133f, 0.13572189f, -0.01146457f, 
    0.08053234f, 0.02200203f, -0.00272095f, 0.39546254f, -0.06441937f, -0.20328215f, -0.00996428f, 0.22349453f, 
    0.06262115f, -0.11992694f, 0.16179807f, 0.15713212f, 0.05686608f, 0.20683599f, -0.03479531f, 0.17098297f, 
    0.24605855f, -0.37449124f, -0.05937732f, -0.03277842f, -0.07922664f, -0.10484212f, 0.05488357f, 0.03269693f, 
    -0.00584842f, 0.06709271f, 0.16674984f, -0.12970795f, -0.02989198f, -0.00005000f, -0.16094412f, 0.21201678f, 
    0.09688052f, 0.26715356f, 0.14348644f, 0.00029654f, -0.05126458f, -0.01269130f, 0.08980310f, -0.01910246f, 
    0.13336074f, -0.08165056f, 0.01209338f, -0.66013908f, -0.31269401f, -0.46522740f, 0.01671544f, 0.01352031f, 
    -0.11982673f, 0.10545276f, 0.05748097f, 0.05942385f, -0.40094337f, -0.56902587f, -0.69920766f, -0.28010595f, 
    -0.08528192f, -0.22300889f, 0.07382847f, -0.01070227f, -0.01547041f, -0.37780860f, -0.08539452f, 0.54680616f, 
    -0.13776188f, 0.00515013f, 0.00501787f, -0.33615679f, 0.25258976f, -0.06738470f, -0.07619984f, -0.12513314f, 
    0.02538880f, -0.08317291f, -0.20245948f, -0.16115558f, 0.04410664f, -0.09943461f, 0.14753298f, -0.06101331f, 
    0.05624009f, -0.14624250f, -0.23210171f, 0.11187428f, 0.07930730f, -0.05027724f, -0.07362693f, 0.02923873f, 
    -0.18209805f, -0.14305985f, 0.39394188f, 0.09111069f, -0.11773037f, -0.07144713f, 0.06122322f, 0.09826945f, 
    -0.10294930f, 0.17326637f, -0.69783062f, -0.35908845f, 0.07270700f, -0.20030531f, -0.14415053f, 0.05023280f, 
    -0.07368041f, 0.21857733f, -0.17265870f, 0.66065919f, 0.68581754f, -0.09308220f, 0.08929539f, 0.04259202f, 
    0.22568877f, 0.17039584f, 0.06260761f, -0.35480589f, -0.43986315f, -0.30316806f, 0.10341931f, 0.21280998f, 
    -0.15555181f, -0.16617107f, -0.21224256f, -0.14709875f, -0.03061777f, 0.04731368f, 0.10932608f, 0.09436246f, 
    0.01045234f, -0.00301220f, 0.21518080f, 0.05306036f, 0.18882158f, 0.12353360f, 0.02513621f, 0.07699087f, 
    -0.09727227f, -0.04289074f, 0.05940359f, 0.02913466f, 0.06696511f, 0.17645186f, 0.02943172f, -0.60237855f, 
    0.00755898f, 0.08971520f, -0.09367743f, -0.05406111f, 0.08886520f, 0.06304976f, -0.11912184f, 0.09711220f, 
    -0.08179244f, -0.02606807f, -0.07086369f, -0.11553097f, 0.07823075f, 0.18114366f, 0.01553400f, 0.20968083f, 
    0.15837806f, 0.24403849f, 0.59280050f, 0.08966321f, 0.19490170f, 0.05686149f, 0.07366148f, 0.14877613f, 
    -0.06154710f, -0.30498266f, 0.00765459f, 0.16827948f, -0.36599159f, -0.28428778f, 0.05192826f, -0.02209263f, 
    -0.11537012f, -0.24690086f, -0.01016503f, -0.00345360f, 0.13580197f, 0.27096322f, -0.11747016f, 0.06881455f, 
    -0.00897373f, -0.15327309f, -0.07363564f, 0.12630655f, -0.27958068f, 0.13858999f, 0.16663268f, 0.07637325f, 
    -0.01812940f, 0.05325741f, 0.12243816f, -0.03627946f, -0.01586291f, 0.30918428f, -0.01677983f, 0.18893902f, 
    0.19710684f, 0.24928652f, 0.12497954f, 0.00731912f, 0.19327654f, -0.45210445f, 0.09991694f, -0.02519119f, 
    -0.00431788f, -0.12233029f, -0.20475572f, -0.09973132f, -0.27466264f, -0.06711533f, 0.14086573f, -0.00225140f, 
    -0.06679065f, 0.08818799f, -0.08073780f, -0.00806173f, 0.11614296f, -0.02573768f, 0.10526080f, -0.12812945f, 
    0.02375062f, 0.29446045f, -0.12225185f, -0.20002149f, 0.25734895f, 0.06470739f, 0.07041507f, 0.36123639f, 
    0.16661401f, 0.32671082f, 0.06638050f, 0.04385268f, 0.18116122f, -0.02404995f, 0.15036829f, 0.33315524f, 
    0.22003607f, 0.08638845f, -0.37047693f, 0.15169199f, 0.02314704f, 0.45747530f, 0.18829301f, -0.22495222f, 
    0.21053834f, -0.12521568f, 0.09186012f, 0.18934321f, 0.11134459f, 0.10726681f, -0.30047444f, -0.23982611f, 
    0.04579283f, -0.01026729f, -0.15884459f, 0.45423463f, -0.05339220f, -0.09085791f, -0.18894140f, -0.16270944f, 
    -0.06268910f, 0.17557028f, 0.14489853f, 0.16058828f, 0.22090675f, 0.08116214f, -0.20373079f, 0.04994763f, 
    -0.15002994f, -0.23334159f, 0.05525375f, -0.13237828f, -0.02182182f, -0.11364630f, -0.02764115f, 0.04203668f, 
    0.16317526f, -0.07580286f, -0.06515362f, -0.20527694f, -0.36960307f, 0.05344518f, -0.68002224f, 0.16603635f, 
    -0.26531094f, 0.04043155f, 0.05577748f, -0.18648502f, 0.00559411f, 0.17476083f, 0.17966920f, -0.38910064f, 
    -0.18123592f, -0.01196453f, -0.12905812f, 0.04741940f, 0.11436603f, 0.11613677f, -0.16064784f, -0.07732868f, 
    -0.75214660f, -0.19739556f, -0.49399531f, 0.02280813f, 0.00297931f, -0.09777329f, 0.06226869f, -0.20399955f, 
    0.03046376f, 0.04324729f, 0.39039350f, 0.34577653f, 0.06553484f, 0.19265856f, -0.11309139f, 0.10296748f, 
    -0.01831915f, 0.29916623f, -0.17400894f, 0.10784873f, -0.16172466f, 0.05538427f, 0.19703099f, -0.13468067f, 
    0.22168474f, -0.10662533f, -0.07243081f, -0.13407105f, -0.13706969f, -0.88640583f, 0.01957513f, -0.10836913f, 
    0.14242323f, 0.08800910f, 0.03037775f, 0.16428475f, 0.22097905f, 0.13918754f, -0.15875416f, -0.05880834f, 
    -0.17046079f, -0.13323763f, 0.02664675f, -0.00771094f, -0.07398261f, -0.05207602f, -0.14128686f, -0.00454779f, 
    0.01919897f, -0.13174707f, 0.01126051f, -0.08721391f, 0.02054698f, 0.18541275f, -0.19415000f, -0.02945148f, 
    -0.09714409f, 0.02794069f, -0.01047227f, 0.04148546f, -0.19455037f, 0.02224447f, 0.06743275f, 0.41271505f, 
    0.00173804f, 0.10132616f, 0.00368168f, 0.10368092f, 0.11934779f, -0.05557484f, 0.22713292f, 0.09968507f, 
    -0.11902387f, 0.04506977f, 0.20649607f, 0.05500667f, 0.23404530f, -0.29183012f, 0.36803705f, 0.17074859f, 
    -0.13174151f, -0.28346199f, -0.29130068f, 0.01292045f, 0.25681716f, -0.18274137f, 0.18407364f, 0.21671186f, 
    -0.01339770f, -0.12421142f, -0.17537647f, 0.19648345f, 0.24945575f, -0.04483969f, -0.05431831f, -0.03092864f, 
    -0.02545571f, 0.21865234f, 0.21509111f, -0.52203351f, -0.15658182f, 0.18638344f, 0.25470328f, 0.28355673f, 
    0.02987226f, -0.01977620f, -0.08571620f, -0.16913016f, 0.10128802f, -0.12108976f, 0.10066086f, 0.13219593f, 
    0.03454433f, 0.18882163f, 0.18187417f, 0.07715044f, 0.03885299f, 0.05954166f, 0.18460612f, 0.23416710f, 
    0.06757758f, 0.06148577f, 0.19543990f, 0.12153664f, -0.07254375f, -0.06936724f, 0.26392058f, -0.27957633f, 
    -0.18577957f, -0.07791828f, 0.09033611f, -0.07706331f, 0.01970573f, 0.11244384f, 0.32924697f, -0.31367865f, 
    0.10546552f, -0.10162865f, 0.15140428f, 0.28486907f, -0.00236599f, 0.09553278f, -0.09890858f, 0.01859859f, 
    0.41484207f, 0.01184031f, -0.33530346f, -0.04572775f, -0.10919006f, -0.12454978f, 0.01966637f, -0.06877066f, 
    0.12324577f, -0.13338940f, -0.05093963f, 0.11779561f, -0.19070676f, 0.17799750f, -0.25998816f, 0.11914887f, 
    -0.05115353f, 0.13570426f, -0.08589005f, 0.19233008f, 0.34637520f, -0.23638164f, -0.11326921f, -0.38824037f, 
    0.00019424f, -0.12329610f, 0.12270112f, 0.36904806f, -0.00010692f, -0.05727100f, -0.15975228f, 0.03240577f, 
    -0.09323790f, 0.11703967f, 0.10956731f, 0.15103127f, 0.38322455f, 0.37497804f, 0.02348272f, -0.17497614f, 
    0.01043429f, -0.04434749f, 0.02451973f, 0.06300441f, 0.10725830f, 0.46583456f, -0.27936813f, -0.05965572f, 
    0.09273709f, 0.15079226f, -0.56497461f, 0.16882825f, -0.05248902f, 0.09593708f, 0.20063704f, 0.20711532f, 
    0.28421941f, -0.37512264f, -0.04069984f, -0.41702551f, 0.32048720f, 0.00116378f, 0.10269398f, 0.04140661f, 
    0.18280801f, 0.34733415f, -0.08806700f, -0.09502757f, 0.09381882f, 0.27042708f, 0.13872901f, -0.01204538f, 
    0.35326907f, -0.16297369f, -0.04775545f, -0.06252133f, 0.25659400f, -0.22887254f, 0.01081971f, -0.00712706f, 
    0.09468408f, 0.02956623f, 0.00496007f, -0.42060602f, -0.19237734f, 0.08145435f, 0.14864542f, -0.04284543f, 
    -0.07283277f, -0.18013187f, 0.20047373f, -0.31699866f, 0.14425920f, 0.14903732f, -0.11511181f, -0.09157997f, 
    0.05056933f, 0.04422233f, 0.04687123f, 0.07011906f, -0.32805461f, 0.24399835f, 0.17453344f, -0.06250100f, 
    0.06610751f, 0.10098099f, -0.06422552f, -0.10355353f, -0.27082622f, -0.15015654f, -0.10720927f, -0.03814026f, 
    -0.20018208f, 0.20003882f, -0.14719498f, 0.12518345f, -0.03852461f, -0.04280438f, 0.00052309f, 0.14196166f, 
    0.03905370f, -0.00346134f, -0.10724407f, 0.02105804f, 0.21819335f, 0.24305129f, -0.54897749f, 0.36960545f, 
    0.00244224f, -0.05755867f, 0.09320861f, 0.13480060f, 0.26955512f, 0.08176109f, -0.11181608f, -0.43629980f, 
    0.09291875f, -0.17215313f, -0.14594859f, -0.13787071f, -0.01383573f, 0.07535613f, 0.25969443f, 0.07667036f, 
    0.29710639f, 0.04589055f, -0.33663028f, -0.35367197f, -0.30978078f, 0.05644724f, 0.09899688f, 0.04309433f, 
    0.00077447f, -0.27183136f, -0.07865106f, 0.01144412f, 0.04610876f, 0.33790573f, -0.01256685f, 0.06949191f, 
    -0.11131193f, 0.00493374f, -0.51218462f, 0.16036420f, 0.29376528f, -0.25324756f, 0.14009544f, -0.38783225f, 
    -0.12884589f, 0.10908749f, 0.13880484f, -0.16555889f, 0.18492734f, 0.03359070f, -0.00588673f, -0.41298139f, 
    -0.16047898f, 0.05598908f, 0.18047607f, 0.13826817f, 0.09968905f, -0.50527692f, 0.02872227f, -0.18016779f, 
    -0.22986192f, -0.05936433f, 0.10912479f, -0.13674510f, -0.05977296f, 0.14832853f, 0.23748100f, 0.21590622f, 
    -0.18608823f, 0.04721201f, 0.02067363f, 0.10342395f, 0.04704452f, -0.10107520f, -0.09185922f, 0.17433988f, 
    0.02374429f, -0.24682209f, -0.13305600f, 0.04229091f, 0.19004925f, 0.08794875f, -0.19689855f, -0.09535263f, 
    -0.42073533f, -0.33033535f, 0.07804689f, 0.08430198f, -0.13420188f, 0.22026099f, 0.03474817f, -0.15340717f, 
    -0.15588853f, 0.06920827f, 0.09656128f, -0.01067366f, -0.04790192f, 0.04889582f, -0.04584878f, -0.07736164f, 
    0.13027596f, -0.21058415f, -0.66533983f, -0.45735404f, 0.09804562f, -0.64434415f, -0.19605689f, -0.00177517f, 
    0.07200851f, -0.16122034f, -0.04577738f, -0.35213968f, -0.16145529f, 0.18518448f, 0.22676997f, 0.29299939f, 
    0.17288086f, -0.03127624f, 0.14122713f, 0.02970087f, -0.00895763f, 0.09428061f, -0.13596706f, 0.00321687f, 
    0.02984462f, -0.16546732f, 0.00863690f, -0.32471973f, 0.02012425f, 0.23729010f, 0.17562300f, 0.24438055f, 
    0.05323995f, 0.02976473f, 0.01085092f, 0.21069154f, 0.12035232f, -0.38524368f, 0.32711586f, 0.13367385f, 
    0.10944676f, -0.07149338f, -0.17042686f, 0.05292043f, 0.05925668f, 0.09333111f, 0.27802432f, 0.24585956f, 
    -0.08497806f, 0.01426420f, 0.09173568f, -0.22533290f, -0.07031423f, -0.00072541f, 0.08389921f, 0.33389759f, 
    -0.12591985f, 0.00608859f, -0.10240599f, 0.23291644f, -0.10999267f, 0.04426106f, 0.20800337f, 0.24767016f, 
    0.05618590f, 0.43723017f, 0.39667925f, -0.25182813f, -0.04215856f, 0.21600963f, -0.13749489f, 0.02881264f, 
    0.19390027f, -0.30015692f, -0.08976761f, 0.07614280f, -0.05955165f, -0.00884759f, 0.18128537f, 0.02388249f, 
    0.30381089f, 0.22774178f, 0.14485367f, -0.36909422f, -0.22385994f, 0.15358534f, -0.06677679f, -0.05072974f, 
    0.03039937f, 0.02507697f, -0.21543229f, -0.16337268f, 0.01072244f, 0.17121729f, 0.07630017f, 0.10650112f, 
    -0.17453294f, 0.13142559f, 0.04909147f, -0.03560631f, -0.37772900f, -0.03330515f, 0.12917623f, 0.32044315f, 
    -0.01337670f, -0.04968397f, -0.10391584f, 0.09509102f, -0.20613311f, -0.09476013f, 0.05039311f, 0.20377651f, 
    -0.07556548f, 0.08351886f, -0.11044646f, 0.08923613f, 0.05486402f, -0.03095432f, 0.10470360f, -0.13283888f, 
    -0.35749665f, 0.01675540f, -0.15834337f, -0.32521313f, 0.09071711f, 0.22641134f, -0.04461449f, -0.10767297f, 
    -0.38475382f, 0.06602210f, -0.14384204f, 0.18350746f, -0.29663998f, -0.04915099f, -0.10272255f, 0.12167718f, 
    0.05416982f, -0.01843925f, 0.47870460f, -0.05099560f, 0.25555670f, 0.02371797f, -0.00201491f, 0.20598824f, 
    0.18151103f, -0.03888074f, -0.40457299f, 1.30788553f, -0.10924947f, 0.00838103f, 0.50381666f, 0.12375954f, 
    -0.35094076f, 0.31372073f, -0.00385114f, 0.24629457f, 0.37113434f, 0.19856548f, 0.25920674f, 0.05999478f, 
    0.05533716f, 0.17841996f, -0.12868513f, -0.10851531f, 0.15679713f, 0.25142467f, -0.25959834f, 0.13191929f, 
    -0.35230193f, 0.02672811f, 0.14549720f, 0.10045707f, 0.20240544f, -0.09379573f, 0.04646282f, 0.19245386f, 
    0.27791259f, 0.24822186f, 0.10151344f, -0.15344793f, 0.19255275f, -0.05304632f, -0.51384807f, -0.18323779f, 
    0.13698903f, 0.22796285f, 0.06382488f, 0.23554829f, 0.08840588f, 0.04498864f, -0.30337176f, -0.37677851f, 
    0.11837225f, 0.01288432f, -0.00705806f, 0.01950050f, 0.09816861f, -0.23414500f, 0.16985546f, -0.11308471f, 
    -0.06191885f, -0.29142568f, -0.00982147f, 0.32192022f, 0.11446377f, 0.11468416f, -0.01202172f, -0.08253644f, 
    0.26606220f, 0.09874281f, -0.26485372f, 0.12166999f, -0.13897543f, 0.06943829f, -0.04074793f, 0.00010328f, 
    -0.14369422f, 0.10427696f, 0.03170202f, -0.01487754f, 0.24212299f, 0.25932634f, -0.13398862f, 0.08324948f, 
    0.07702266f, -0.23290826f, -0.29626882f, -0.09011459f, -0.07569699f, -0.09380721f, 0.06691631f, -0.05201969f, 
    -0.29125395f, -0.15227591f, -0.07258615f, -0.01888759f, -0.09371559f, -0.03369490f, 0.01006250f, 0.03842568f, 
    0.12462851f, -0.13207306f, 0.18506923f, -0.00918011f, 0.25861353f, -0.00577614f, -0.13721250f, 0.03538397f, 
    -0.19400010f, 0.19217457f, 0.25919583f, 0.03550303f, 0.03175527f, 0.41232845f, 0.15725721f, -0.59926009f, 
    -0.07040524f, -0.19600974f, -0.16628166f, -0.27133757f, 0.01181942f, -0.14865287f, -0.08224035f, 0.17864190f, 
    -0.11665564f, 0.02365250f, -0.19087134f, -0.23018014f, 0.01734597f, 0.09801264f, 0.19370137f, -0.18493339f, 
    0.15865520f, -0.19362235f, 0.24348868f, -0.05684762f, -0.02881469f, 0.13569432f, 0.19088772f, 0.20147672f, 
    0.03014043f, -0.05456143f, 0.10990021f, 0.04340119f, -0.05689459f, -0.20307614f, 0.02379853f, 0.17511798f, 
    0.33109847f, -0.26869166f, -0.37776616f, -0.18563285f, 0.14658776f, -0.02300910f, 0.35996822f, 0.08691636f, 
    0.09817819f, -0.09607974f, 0.10428780f, -0.01844849f, -0.29504445f, -0.07509427f, 0.07936358f, -0.03141052f, 
    0.05829496f, -0.11055346f, 0.14898339f, 0.07532831f, -0.12868756f, 0.04662834f, -0.23672898f, -0.03993816f, 
    0.03525144f, 0.04216071f, 0.00044808f, 0.03376890f, 0.07985494f, 0.05531803f, -0.15905313f, 0.01570761f, 
    -0.09955657f, 0.02248622f, 0.03832642f, 0.02141605f, 0.11233992f, -0.38980168f, 0.02895520f, 0.12895888f, 
    0.00285159f, 0.21465920f, -0.14376578f, -0.23003106f, -0.21973673f, -0.15621045f, 0.10269835f, 0.27615684f, 
    -0.00439846f, 0.17484437f, 0.10001847f, -0.06695849f, 0.09489711f, 0.27754229f, 0.29640111f, -0.03400816f, 
    0.06251053f, 0.17414625f, 0.05784545f, 0.05186689f, -0.01937881f, 0.16486883f, 0.04077153f, -0.32306758f, 
    0.86510700f, 0.28060400f, -0.47928500f, 0.16222115f, -0.12646863f, 0.16434632f, 0.08476359f, -0.05544744f, 
    -0.10953728f, 0.05510069f, 0.00870227f, -0.10087138f, -0.03908988f, -0.09326562f, -0.06694607f, -0.05451363f, 
    0.37632915f, 0.06926969f, -0.01461407f, -0.26006112f, 0.03359702f, 0.25887927f, 0.16235545f, -0.17189695f, 
    0.00686498f, -0.01122965f, -0.14689180f, 0.23099340f, -0.15449204f, -0.37088487f, -0.03339893f, 0.11746392f, 
    0.16243450f, -0.03428292f, -0.00183987f, -0.02479356f, -0.18076034f, -0.39876583f, -0.37749827f, -0.09786203f, 
    -0.08324175f, -0.01833985f, 0.13211896f, -0.30226400f, 0.35988533f, 0.36042303f, 0.27865547f, 0.06067110f, 
    0.04097466f, 0.02993445f, -0.09293065f, 0.07073230f, -0.00905514f, -0.05508731f, 0.22593889f, -0.03537564f, 
    0.31758669f, -0.05161642f, 0.04789145f, -0.03546223f, -0.00042110f, -0.16180111f, 0.05806140f, 0.16278826f, 
    -0.11988358f, 0.24379259f, -0.19313736f, -0.14846575f, -0.04996359f, 0.08325780f, 0.00985387f, 0.11284463f, 
    0.08732911f, 0.16655159f, 0.38699588f, 0.06912819f, -0.06428597f, 0.16295706f, -0.02469939f, 0.09943677f, 
    0.20811126f, -0.14880751f, -0.10622126f, -0.00980776f, -0.38246199f, 0.03064339f, 0.04377119f, -0.11860445f, 
    -0.26435646f, -0.09820479f, -0.24304824f, 0.13175377f, 0.19953299f, 0.05601420f, -0.04441977f, 0.17950509f, 
    0.10662942f, 0.02198005f, -0.07201634f, 0.05372455f, -0.02673044f, -0.33650979f, 0.00603830f, 0.05863340f, 
    0.06455356f, -0.19770433f, 0.01267029f, -0.12631012f, 0.13907300f, -0.17465930f, 0.09960517f, 0.07019181f, 
    -0.04127881f, -0.21996385f, 0.11030342f, 0.01283529f, -0.34173471f, 0.02769436f, 0.06962045f, 0.09835389f, 
    -0.11729836f, -0.01324596f, -0.41360539f, -0.09724850f, -0.08805559f, -0.06785288f, -0.32128677f, -0.04768577f, 
    0.16970924f, 0.05275597f, 0.03439451f, 0.16368535f, -0.02843426f, -0.22294909f, 0.39581996f, -0.07666217f, 
    0.05167027f, 0.03350681f, 0.05718841f, -0.02047331f, -0.03184086f, 0.03811542f, 0.21039002f, -0.05068900f, 
    -0.23905772f, 0.13404089f, 0.30869910f, -0.22647132f, -0.02735645f, 0.13266110f, 0.06782607f, 0.14307456f, 
    -0.00062377f, -0.31494653f, -0.24916977f, -0.50450689f, 0.06664865f, 0.16884227f, -0.24218251f, 0.09289855f, 
    -0.20640139f, 0.00613891f, 0.26293319f, -0.87503403f, -0.20754878f, -0.25069931f, 0.02072609f, -0.29971144f, 
    -0.00317953f, -0.00607437f, 0.22821271f, -0.24384056f, 0.12799320f, 0.03919612f, 0.04400982f, -0.11858755f, 
    0.04331382f, -0.05355424f, -0.03808657f, 0.10475530f, 0.52598351f, 0.44677526f, 0.29169711f, -0.08782943f, 
    -0.10254253f, -0.33394825f, -0.07262281f, -0.03354062f, 0.08091710f, 0.33976063f, 0.02101648f, 0.30156493f, 
    0.01643232f, 0.11481809f, -0.12816860f, 0.48906943f, -0.08265850f, 0.00299747f, -0.14618737f, -0.20324890f, 
    -0.28897220f, -0.07280847f, -0.17932995f, 0.44522870f, 0.10300814f, 0.02560282f, -0.07538931f, 0.00921057f, 
    -0.11214644f, -0.22682005f, -0.18502989f, -0.10018977f, 0.08642094f, 0.07096186f, 0.11201082f, 0.27720743f, 
    -0.30477601f, 0.18527952f, 0.51371831f, 0.03186474f, -0.06669714f, 0.17309719f, -0.08982127f, -0.10409422f, 
    0.21391939f, -0.07352387f, -0.23174858f, -1.28004134f, 0.00230444f, -0.21074070f, -0.07143811f, 0.12212420f, 
    0.03181277f, -0.11799096f, -0.08622363f, -0.16260536f, -0.26321998f, 0.11605445f, 0.21567601f, 0.12524034f, 
    0.15995497f, 0.07770371f, 0.00930749f, 0.41909426f, 0.21929340f, 0.32663286f, 0.04168593f, -0.01357247f, 
    0.08442737f, -0.11433506f, -0.09380253f, -0.19130154f, -0.09818146f, 0.48594010f, 0.15834540f, 0.11927456f, 
    0.07553978f, 0.03091369f, 0.20030555f, 0.14884734f, -0.12047690f, 0.02326626f, -0.21275344f, -0.15650792f, 
    -0.05208359f, -0.20696416f, 0.27745461f, 0.12157761f, -0.07093674f, 0.02433230f, -0.16895516f, -0.52757287f, 
    -0.08675694f, -0.31574279f, -0.04467258f, 0.02905796f, -0.00724656f, 0.13290752f, 0.09641070f, -0.18563461f, 
    -0.47497335f, -0.04360979f, 0.10361398f, -0.06811402f, 0.17930809f, 0.22300254f, -0.04235033f, -0.01262056f, 
    0.12369871f, 0.22039835f, 0.00093834f, 0.04658315f, -0.09514324f, 0.00154301f, 0.02201966f, 0.00878055f, 
    0.16676629f, -0.06544694f, 0.12614325f, 0.40822741f, 0.02966198f, -0.32597363f, 0.13136786f, -0.18827783f, 
    0.04287270f, 0.28670275f, 0.07039456f, 0.20879255f, 0.28522751f, -0.10567442f, -0.32333240f, -0.03290581f, 
    0.00663903f, 0.05746103f, 0.07800185f, -0.21522591f, 0.01908912f, -0.12053510f, -0.09380084f, -0.07931428f, 
    -0.13514645f, 0.16111551f, 0.34651184f, 0.23172687f, -0.16828281f, -0.36120602f, -0.59878218f, 0.11710653f, 
    -0.20563523f, -0.01906883f, 0.21477312f, -0.06168634f, 0.26912400f, -0.20032218f, -0.09929300f, -0.42251953f, 
    -0.33603123f, -0.08602582f, 0.04476572f, 0.03751630f, -0.11817523f, -0.10920830f, -0.05016301f, 0.00315777f, 
    0.11400482f, -0.09930664f, 0.13123500f, -0.10378058f, -0.12989715f, -0.03379231f, 0.12426905f, -0.12998924f, 
    -0.12636815f, 0.26017299f, 0.01227648f, 0.22312291f, 0.07464501f, -0.03095316f, -0.02672145f, 0.26427257f, 
    -0.01392428f, -0.25784543f, 0.25110257f, -0.06928017f, 0.12175971f, -0.02817393f, 0.20158003f, 0.05560809f, 
    0.06017723f, -0.33087155f, -0.38659129f, 0.28914768f, 0.26209342f, -0.04885143f, 0.42946443f, 0.06564368f, 
    0.03310143f, 0.04094166f, -0.40253735f, -0.17587428f, -0.23682459f, -0.17581181f, 0.19276048f, -0.15524855f, 
    0.06658385f, -0.08122337f, 0.00863449f, -0.26579723f, 0.24353772f, -1.01833236f, -0.40462369f, 0.07887416f, 
    -0.09040693f, 0.06584440f, -0.11857899f, -0.02609101f, 0.09259304f, 0.22604412f, -0.05187412f, 0.09357416f, 
    -0.10489899f, 0.14784765f, -0.12892789f, -0.05370971f, -0.12167152f, 0.02325436f, 0.24748617f, 0.15735798f, 
    0.05781418f, -0.12158798f, -0.06781686f, 0.00157586f, -0.06336142f, 0.02956211f, 0.06265260f, -0.34541464f, 
    0.42948636f, -0.06352565f, -0.09598289f, -0.19851901f, 0.23866178f, 0.10568261f, 0.12099432f, 0.03060674f, 
    0.14681314f, 0.23800008f, 0.15141280f, -0.25980705f, -0.07782342f, -0.24829800f, -0.09003790f, -0.07278168f, 
    -0.10071871f, 0.01300139f, 0.17257887f, 0.00834264f, 0.11860818f, -0.34673640f, 0.08052115f, 0.12420376f, 
    0.06455192f, -0.25418651f, 0.09279131f, -0.39826497f, 0.01546654f, 0.09368864f, 0.00722785f, 0.11331098f, 
    0.19052240f, 0.06426727f, 0.16147424f, 0.17748837f, 0.06593352f, -0.05071526f, -0.07826876f, 0.15834323f, 
    0.07468298f, 0.02033398f, 0.12992704f, 0.15018396f, 0.18617246f, 0.50031257f, 0.03931756f, 0.29487681f, 
    0.03774055f, 0.06204583f, 0.00606433f, 0.07110270f, 0.15004314f, 0.48146075f, 0.27989116f, 0.29410359f, 
    0.00777163f, -0.25591218f, 0.06853962f, -0.40017557f, -0.37343878f, -0.24814010f, -0.35459229f, 0.07275061f, 
    0.13012931f, -0.13643683f, -0.35616189f, -0.06132603f, -0.13028973f, 0.16460538f, 0.07246975f, 0.01597062f, 
    -0.02284463f, 0.02388150f, -0.07725775f, 0.12192353f, -0.07721356f, -0.05287162f, -0.18709692f, -0.23018278f, 
    -0.08045655f, 0.10009415f, -0.08922476f, -0.22359601f, -0.03084256f, -0.11392262f, -0.09561262f, 0.11205261f, 
    -0.01504677f, -0.38631001f, 0.10402864f, 0.02593836f, 0.10871155f, -0.34161749f, 0.00153598f, 0.01588428f, 
    -0.29380983f, 0.07873122f, 0.44950321f, -0.23222566f, -0.15622532f, -0.08432169f, 0.08512630f, -0.16781314f, 
    0.03654686f, 0.17901210f, -0.00336255f, 0.27222344f, 0.15547824f, 0.00396923f, -0.19547702f, -0.21305384f, 
    0.13981451f, 0.17328651f, 0.21251208f, 0.13267548f, -0.09382010f, 0.40482914f, 0.22260374f, -0.34288943f, 
    -0.03448770f, 0.01223152f, -0.08418632f, -0.07121346f, 0.09031499f, -0.09709104f, 0.00250056f, -0.12900692f, 
    0.10132522f, 0.08810286f, 0.12466971f, 0.19871315f, 0.26863483f, 0.10936699f, 0.04712288f, -0.11860025f, 
    0.14962861f, -0.06494173f, -0.01855880f, 0.06913242f, 0.03283071f, 0.10175841f, -0.27410948f, -0.31139332f, 
    0.00836639f, 0.22218938f, -0.04414513f, -0.09093216f, -0.25857159f, -0.17147116f, -0.26517597f, -0.13428806f, 
    -0.19923300f, -0.64713329f, -0.08015737f, 0.01164157f, 0.11205313f, 0.07903754f, 0.27069405f, 0.05205607f, 
    -0.70098418f, -0.37442937f, -0.00068320f, 0.00464744f, -0.01263203f, -0.19055171f, -0.01486639f, 0.02416117f, 
    -0.00288543f, 0.15645532f, 0.24855568f, 0.24262194f, 0.01268409f, -0.04769481f, 0.11677281f, -0.13327968f, 
    0.12681901f, 0.15338354f, 0.18803859f, 0.34012192f, -0.03762485f, -0.26402354f, -0.07418731f, -0.04551031f, 
    -0.02650885f, 0.08296598f, -0.14230853f, -0.28415456f, 0.04598983f, -0.38270363f, -0.02531369f, 0.10033669f, 
    -0.01919958f, 0.11876509f, -0.20700628f, -0.14648806f, -0.39425045f, -0.14954394f, -0.29802659f, 0.10265499f, 
    -0.01308504f, -0.07272071f, -0.00683978f, -0.10453979f, -0.05339785f, 0.12528847f, -0.56718504f, -0.69924039f, 
    0.04544091f, 0.03988273f, -0.19444901f, -0.13347493f, -0.06855629f, 0.15146583f, 0.06585593f, -0.01172928f, 
    0.01502489f, 0.08613473f, 0.04742854f, 0.16829774f, 0.17403802f, -0.00670983f, 0.06145516f, 0.17936975f, 
    0.11263668f, 0.09755953f, 0.13546745f, 0.22960886f, -0.09839331f, 0.08866078f, 0.11457219f, -0.31365681f, 
    -0.31816396f, -0.01601450f, 0.14552811f, 0.10993212f, 0.07308786f, -0.23049240f, 0.10215903f, 0.15978320f, 
    -0.23636168f, -0.36013296f, -0.24140310f, -0.41691107f, 0.17253794f, -0.08926231f, 0.39445904f, 0.13045454f, 
    -0.21891405f, -0.17662975f, -0.58006608f, -0.32567739f, -0.55951136f, 0.05266453f, 0.19711150f, -0.01483232f, 
    -0.01715590f, 0.00281920f, -0.01187525f, -0.15730253f, 0.18821009f, -0.15361218f, -0.00434294f, 0.08938602f, 
    -0.12270315f, 0.21782871f, 0.00852835f, 0.01497873f, 0.11820583f, 0.13576296f, -0.17849365f, 0.04131302f, 
    -0.04351530f, 0.11913602f, 0.07955329f, 0.28220290f, 0.30086353f, 0.17438105f, 0.33136290f, 0.28640547f, 
    0.00286933f, 0.04931060f, 0.07978554f, -0.06878634f, 0.13171801f, -0.03981322f, 0.45034483f, -0.15302578f, 
    0.09624862f, 0.04328399f, 0.04374959f, -0.34595579f, -0.08028819f, -0.01253647f, -0.05931295f, 0.09495671f, 
    0.15957351f, 0.03432215f, 0.00251142f, 0.15111983f, -0.08246344f, 0.16200721f, 0.02954245f, 0.36827055f, 
    -0.27797171f, -0.39420190f, 0.08830034f, 0.19967428f, 0.09925159f, 0.12735067f, 0.01126919f, 0.10216693f, 
    0.14624394f, 0.02166769f, -0.18797016f, -0.03032718f, 0.53643662f, -0.12191005f, -0.10486382f, -0.18802236f, 
    -0.21536312f, 0.17074780f, -0.30297396f, -0.42383075f, -0.22988550f, -0.02612917f, 0.04131034f, 0.06767091f, 
    -0.07933911f, -0.02318933f, -0.14146796f, -0.30852374f, -0.14500307f, -0.00530160f, 0.06424923f, -0.00026146f, 
    0.01494240f, 0.07641570f, -0.00858526f, -0.15765257f, 0.06597576f, -0.13297914f, 0.19309311f, -0.07546935f, 
    0.07554689f, -0.14452556f, 0.33944356f, 0.01490230f, 0.14338294f, -0.49493301f, 0.04568618f, -0.14050423f, 
    -0.05125840f, -0.00048149f, -0.08198751f, 0.08920080f, -0.25220099f, -0.41621923f, 0.03493349f, 0.14134151f, 
    0.00199084f, 0.18968552f, 0.03561564f, 0.21345393f, 0.22230643f, 0.41786882f, -0.02799414f, -0.04114972f, 
    -0.11489189f, -0.13370058f, 0.02552658f, 0.09494952f, 0.16352130f, 0.25319663f, 0.26025677f, 0.19825166f, 
    0.23011492f, -0.16880874f, 0.07278799f, 0.07511686f, 0.13425073f, -0.25280270f, 0.34671196f, 0.08343952f, 
    0.14484636f, -0.06508448f, 0.12040079f, 0.55946207f, -0.02179439f, -0.03556409f, -0.07700340f, 0.00149984f, 
    0.02838787f, 0.19962342f, 0.27461720f, 0.07733517f, -0.02808242f, 0.17088017f, 0.03549992f, 0.14582494f, 
    -0.12682597f, 0.01498488f, 0.04878519f, 0.04220324f, 0.01227614f, -0.12281719f, 0.11769751f, -0.40434203f, 
    0.15977074f, 0.01218132f, 0.11585505f, 0.18497324f, 0.41127568f, 0.02439101f, 0.17915644f, -0.00556166f, 
    -0.09268913f, 0.08992650f, 0.10970382f, -0.27440283f, -0.42757484f, 0.23840035f, -0.32428417f, -0.26565391f, 
    0.22000225f, 0.00592480f, -0.12878659f, -0.07413763f, -0.03874469f, -0.07228968f, -0.01033831f, -0.38921642f, 
    0.00212986f, -0.16082172f, 0.06444558f, 0.23855448f, 0.11895894f, 0.24389705f, 0.15452334f, -0.01966026f, 
    -0.67368126f, 0.20086512f, 0.11491650f, -0.18537931f, 0.04104653f, -0.26988056f, -0.11255436f, -0.20253539f, 
    0.29346481f, 0.08387774f, 0.08616532f, -0.04152558f, 0.06132924f, -0.09489667f, -0.00939670f, -0.01299837f, 
    -0.00632000f, -0.01548450f, -0.15721515f, 0.15847762f, -0.09830653f, -0.04633088f, -0.02885642f, -0.00968952f, 
    -0.09256421f, -0.17735265f, 0.23594046f, 0.19204471f, 0.27638632f, -0.08538873f, -0.08418630f, -0.23599462f, 
    0.00156508f, -0.14888790f, -0.16198161f, -0.18447098f, 0.33093315f, 0.21539658f, 0.06961409f, -0.07782393f, 
    -0.14538801f, 0.06862651f, -0.10397637f, 0.16197787f, -0.04077526f, 0.31141719f, 0.14507431f, -0.10674415f, 
    0.07511451f, -0.11309621f, -0.07498068f, 0.09511828f, 0.06564693f, 0.53919399f, -0.02629444f, 0.04875982f, 
    -0.05203907f, 0.01678209f, -0.12992208f, -0.05221817f, -0.01310430f, -0.00398046f, 0.36802074f, 0.17978390f, 
    0.18640338f, 0.13903548f, 0.01961557f, 0.28676760f, -0.00946959f, 0.13351540f, -0.11412183f, 0.19196509f, 
    -0.02461978f, 0.10508119f, 0.03893113f, 0.13170497f, 0.22242953f, 0.09752037f, 0.10339504f, -0.00633718f, 
    0.29958394f, -0.00725797f, -0.18772249f, 0.13507511f, -0.08049240f, 0.07779440f, 0.05361591f, 0.00401456f, 
    -0.04159831f, -0.14054483f, -0.13107422f, -0.58030599f, -0.00375586f, -0.27107474f, 0.15752448f, 0.02069865f, 
    -0.06136840f, 0.09400835f, 0.33951399f, -0.58983272f, -0.52859491f, -0.01061584f, -0.08849465f, 0.05854245f, 
    0.05059407f, 0.01220130f, 0.00163968f, 0.51409769f, 0.35715121f, 0.41734883f, -0.07661058f, 0.10618317f, 
    -0.02673782f, 0.07627933f, 0.17059803f, 0.01818662f, -0.31386510f, -0.10700048f, 0.28570777f, -0.08412837f, 
    -0.04904760f, -0.08298092f, -0.03616387f, -0.12545133f, -0.01513133f, 0.11389557f, 0.01280473f, 0.00277385f, 
    0.15717873f, -0.24107580f, 0.01675735f, -0.04246632f, -0.00331582f, 0.08652180f, -0.03773170f, -0.38781762f, 
    -0.02471073f, 0.05792264f, 0.18093373f, -0.03423669f, 0.03797472f, 0.01124784f, -0.04355092f, -0.00153518f, 
    -0.21343781f, 0.15321144f, -0.06469356f, -0.22173229f, 0.06666856f, 0.01211002f, 0.04898617f, -0.12337562f, 
    -0.06800900f, 0.04124847f, -0.01179423f, -0.06960203f, 0.04844771f, -0.06951042f, -0.05404970f, -0.03366298f, 
    -0.05486993f, -0.00532307f, 0.04156721f, -0.04586895f, -0.02767333f, -0.08444235f, 0.04351469f, -0.08808208f, 
    -0.00668123f, -0.02179524f, -0.03250678f, -0.00564316f, -0.03198693f, 0.04923163f, -0.05622362f, 0.04807987f, 
    -0.02389451f, 0.00215070f, -0.03965040f, 0.00581620f, 0.08240135f, -0.06324764f, -0.00040368f, 0.01456983f, 
    -0.01337201f, -0.02757162f, -0.07204165f, -0.02989963f, -0.04979132f, 0.02527584f, 0.05549278f, 0.06497023f, 
    -0.06256359f, -0.01209550f, 0.01011395f, -0.03062439f, 0.06397250f, 0.04003452f, 0.00840489f, -0.02809992f, 
    -0.06528661f, 0.01809053f, -0.01434703f, 0.02698485f, -0.03973376f, 0.03808993f, -0.08130355f, 0.07373846f, 
    -0.05381013f, 0.07034132f, 0.02932467f, 0.02913113f, -0.08201740f, 0.03958635f, 0.06793158f, -0.03228455f, 
    -0.07793220f, -0.01588145f, 0.03206993f, 0.01397819f, -0.08042737f, -0.03261334f, -0.07690503f, -0.07341347f, 
    -0.07272089f, -0.00658566f, 0.07276947f, -0.07197649f, -0.07099880f, -0.08613698f, -0.04871177f, 0.06071531f, 
    -0.05622074f, 0.03625203f, -0.00108481f, 0.04326951f, -0.05931055f, 0.06545265f, 0.00146438f, 0.06840714f, 
    -0.00775702f, 0.01359933f, -0.06036779f, 0.06156278f, -0.03685042f, 0.04228914f, -0.02374082f, -0.02724521f, 
    0.01386850f, -0.00410532f, 0.03858706f, -0.03364152f, 0.04758230f, 0.04389517f, 0.00488024f, 0.03084773f, 
    -0.07217596f, 0.03933693f, 0.07990441f, 0.06548160f, 0.02383577f, -0.05709680f, -0.00770579f, -0.04396967f, 
    -0.02994486f, -0.04621910f, 0.02284905f, -0.00135442f, -0.07138242f, -0.04324005f, 0.02025613f, 0.02888544f, 
    -0.06892513f, -0.04223569f, 0.03722884f, -0.00117801f, -0.03196038f, 0.00056808f, 0.02649670f, -0.00751740f, 
    -0.07767853f, 0.01411892f, -0.05043076f, -0.02162228f, -0.00795456f, -0.04641548f, 0.07625290f, 0.04390325f, 
    -0.03028029f, -0.01178222f, -0.04752492f, -0.03400971f, -0.06002602f, -0.06989848f, 0.06057158f, -0.03388009f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.01452937f, 0.16536868f, 0.08390068f, 0.40554354f, -0.20805040f, 0.41419229f, 0.22846194f, 0.20361008f, 
    0.11651544f, 0.11008089f, 0.08822482f, -0.10240158f, 0.22256562f, 0.16310096f, -0.04261097f, -0.06130349f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02065936f, -0.26168773f, -0.08669525f, -0.03052917f, -0.24427946f, -0.13311917f, -0.05952075f, -0.24843159f, 
    -0.02100596f, -0.13582781f, 0.05455566f, -0.17914751f, -0.08943298f, -0.14132187f, 0.18939483f, 0.22617012f, 
    0.02924721f, 0.26221770f, 0.41175935f, -0.25273326f, 0.11758047f, -0.74631679f, 0.19976534f, -0.51457536f, 
    0.23001333f, 0.74610120f, -0.06972018f, 0.24431132f, -0.41836214f, 0.26882434f, -0.14362100f, 0.22290637f, 
    0.19470413f, 0.72991180f, -0.47172749f, -0.24260074f, -0.54919922f, 0.21439297f, 0.26046035f, -0.07565659f, 
    0.03417793f, -0.06586969f, -0.25364894f, 0.40094358f, -0.35467529f, 0.48555532f, -0.67332011f, 0.21380579f, 
    0.14252631f, 0.03826587f, 0.19537738f, -0.05609858f, -0.52841514f, 0.82243598f, 0.02374198f, 0.18619525f, 
    0.16833939f, -0.35684371f, 0.46160930f, -0.24051766f, -0.12973687f, 0.14166424f, -0.10283563f, 0.19749904f, 
    -0.09566928f, -0.10016143f, 0.10078859f, 0.30400634f, 0.00817587f, -0.58598852f, 0.34575197f, -0.47158420f, 
    -0.09224018f, 0.06441243f, 0.35806525f, 0.18610801f, 0.18206236f, -0.38157609f, -0.17275432f, -0.13922578f, 
    -0.27171516f, 0.40264547f, 0.68137252f, -0.07614905f, -0.28644228f, 0.22840077f, 0.57233787f, -0.07442527f, 
    -0.21372211f, -0.46865809f, 0.14184339f, 0.27649865f, 0.02167639f, -0.02341183f, -0.19658037f, -0.04604384f, 
    -0.20833482f, 0.33319277f, 0.10202236f, 0.35464209f, -0.21605137f, 0.20376989f, -0.06208519f, -0.11021068f, 
    0.27650234f, -0.62638217f, 0.14717259f, 0.08340990f, 0.37053505f, 0.00036272f, -0.20304365f, -0.06256822f, 
    0.44817975f, -0.10186487f, -0.06837504f, -0.01174625f, -0.14365074f, -0.39678991f, 0.02379394f, -0.17293052f, 
    -0.43698323f, -0.07439946f, -0.15333739f, 0.29558140f, 0.28542143f, -0.03891653f, 0.33563331f, 0.18174434f, 
    0.37993655f, -0.09254454f, 0.05277924f, -0.15263620f, 0.57842016f, -0.57546961f, 0.06976148f, -0.33857688f, 
    -0.01389205f, 0.93797028f, -0.30003390f, 0.50210428f, -0.17352310f, 0.14452477f, 0.29742041f, -0.04626440f, 
    0.33533671f, 0.25497186f, -0.36207691f, 0.36625847f, -0.09092727f, -0.08807060f, 0.47334760f, -0.40979990f, 
    -0.14567237f, -0.48662007f, -0.48373005f, 0.37513822f, -0.57000440f, -0.10444696f, -0.96536011f, 0.06428361f, 
    0.20239694f, 0.32737756f, -0.03681433f, 0.39676204f, -0.08548540f, 0.53346950f, 0.03646691f, 0.34431329f, 
    -0.01521861f, -0.32246858f, 0.00865714f, -0.25582674f, -0.07889538f, 0.03557888f, -0.50785547f, 0.19512679f, 
    0.42641842f, -0.83790994f, -0.18836333f, -0.21048918f, 0.65129352f, -0.07010943f, 0.28197867f, 0.54905236f, 
    -0.57199520f, 0.08890702f, -0.53490555f, 0.18255882f, -0.37474972f, -0.36078906f, 0.38359624f, -0.14124072f, 
    -0.33195776f, -0.38832030f, 0.13337170f, 0.27496207f, -0.67904431f, 0.24460416f, 0.44001138f, 0.03159944f, 
    -0.00132057f, 0.63264298f, 0.27841911f, -0.23038769f, 0.35232759f, -0.13283646f, 0.21833861f, 0.14847320f, 
    0.20390816f, -0.01665745f, -0.25917363f, 0.20786946f, 0.11891782f, 0.16345118f, 0.33365950f, 0.45322004f, 
    0.32197347f, -0.66858464f, -0.12737229f, 0.04270699f, -0.02172292f, -0.09361292f, -0.51803130f, 0.04855205f, 
    -0.00132165f, 0.16993514f, -0.06382782f, 0.35004437f, -0.49284872f, 0.50272948f, -0.11358703f, 0.06688711f, 
    0.03475920f, 0.70251691f, 0.26983911f, -0.18835677f, 0.33131692f, -0.07597160f, -0.07144264f, 0.02575220f, 
    -0.27865556f, -0.47474128f, 0.35614783f, 0.30547538f, -0.18748064f, 0.10625734f, 0.08970852f, 0.29800341f, 
    -0.25858593f, 0.30616975f, 0.24632426f, 0.12796398f, -0.14284451f, 0.57308644f, -0.02378070f, -0.22913958f, 
    0.15444447f, -0.29824135f, -0.38982338f, 0.28277710f, 0.42997798f, 0.29115695f, 0.02873495f, 0.12049592f, 
    -0.37022594f, 0.19451846f, -0.79430920f, 0.43996093f, 0.20648298f, -0.18687586f, 0.09737204f, 0.05441564f, 
    -0.05689385f, -0.21993159f, -0.21159309f, 0.25766173f, 0.07459179f, -0.64000410f, -0.51411134f, -0.28983349f, 
    -0.49144751f, -0.44718987f, -0.15990338f, -0.12971133f, 0.38808927f, -0.16608396f, 0.01289905f, 0.18542233f, 
    0.14440340f, -0.01681576f, -0.03455739f, 0.53586388f, -0.35713482f, -0.59623462f, 0.24617015f, -0.35657221f, 
    -0.46887758f, 0.30468187f, -0.25066984f, 0.14135456f, 0.10783926f, -0.16105953f, 0.03307355f, 0.08972669f, 
    -0.02032408f, -0.14884587f, 0.06620307f, 0.22498560f, -0.14898653f, 0.46070236f, 0.01707023f, 0.20414886f, 
    -0.24402133f, 0.32588354f, 0.18366970f, -0.18793821f, 0.38679695f, -0.23366068f, 0.01695954f, 0.00555196f, 
    -0.01613284f, 0.11080720f, 0.61330158f, -0.01182095f, -0.61348546f, -0.47535032f, 0.21032529f, -0.03940330f, 
    -0.38372681f, 0.19811067f, 0.63566756f, -0.12624602f, -0.61961883f, 0.83576429f, -0.81644434f, 0.16557679f, 
    -0.22569737f, -0.24540633f, -0.07323924f, -0.00338623f, -0.07187429f, -0.06106445f, -0.24843362f, -0.03025588f, 
    -0.22302836f, -0.22287804f, -0.00591195f, 0.04505271f, -0.23737836f, -0.09000170f, -0.20219502f, 0.05860621f, 
    0.13050576f, -0.08967072f, 0.25067341f, -0.19969219f, 0.21612138f, -0.38351697f, 0.23707397f, 0.10606003f, 
    0.19795382f, 0.05795682f, -0.72185814f, 0.55174786f, -0.96867317f, 0.26593846f, 0.14331982f, -0.18826079f, 
    -0.06211197f, -0.32764828f, 0.39480218f, -0.36775488f, 0.47046942f, -0.14714068f, 0.53618836f, 0.02880718f, 
    0.37069154f, 0.14053723f, 0.15761238f, 0.00408237f, -0.15540779f, -0.08426434f, 0.19212221f, -0.03638741f, 
    0.25947607f, 1.00190783f, -0.14661857f, 0.18209940f, -0.71032047f, 0.62708956f, 0.02440773f, -0.02305156f, 
    0.38109863f, 0.53625757f, -0.80866963f, -0.16667695f, -0.06682894f, -0.22953422f, -0.55597001f, 0.24119812f, 
    -0.00937133f, -0.09819385f, -0.32892796f, 0.01306206f, 0.17306894f, -0.20102973f, -0.14348161f, 0.19616869f, 
    -0.19122660f, 0.18173003f, -0.04433551f, -0.30261037f, 0.04556251f, -0.02228292f, -0.30468494f, 0.14076084f, 
    0.23593673f, 0.15704477f, -0.15861487f, -0.38536054f, 0.30519533f, -0.19531117f, -0.19593850f, 0.11813555f, 
    0.30109227f, -0.09203006f, -0.16670242f, 0.11108229f, -0.22547865f, 0.22237799f, -0.06706220f, 0.06977839f, 
    -0.07774178f, -0.19078676f, 0.10517703f, -0.20806955f, -0.39567757f, 1.08663058f, 0.36310551f, 0.55302352f, 
    0.31363145f, 0.31173086f, -0.07548530f, -0.35249373f, -0.52253270f, 0.95302439f, -0.67920101f, -0.24280594f, 
    0.22716622f, 0.71541959f, -0.29900998f, 0.19962451f, -0.33294663f, -0.10167857f, 0.12906408f, -0.30503798f, 
    -0.85969013f, 0.05341646f, -0.28544849f, 0.82913029f, -0.17786068f, 0.05963492f, -0.36131960f, -0.04689074f, 
    0.39821109f, 0.55154395f, -0.10648288f, -0.31729159f, 0.13134991f, 0.48644242f, -0.35528272f, 0.56276524f, 
    -0.28205079f, 0.28251684f, 0.03511729f, 0.31339306f, -0.08177745f, 0.45018631f, 0.40066516f, -0.18556173f, 
    -0.25520229f, -0.59143692f, 0.56775957f, -0.26077753f, -0.05040684f, 0.72525644f, 0.35897729f, 0.32543832f, 
    -0.04948969f, 0.24991821f, 0.06415765f, 0.01281381f, 0.20960374f, -0.33012629f, 0.43729448f, 0.08422479f, 
    -0.19376113f, -0.39015162f, -0.45407313f, -0.19223537f, 0.02284200f, 0.43954545f, 0.42128903f, 0.44439602f, 
    0.25085843f, 0.22030979f, 0.33553332f, -0.38646194f, 0.04724050f, 0.12050728f, 0.12963414f, -0.11880008f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.21206586f, -0.04467643f, 0.26452735f, 0.05585843f, -0.21647057f, -0.20976882f, -0.16594368f, 0.12101706f, 
    0.27156827f, 0.54298919f, 0.34839079f, 0.18198252f, 0.24219468f, 0.32313898f, 0.31056613f, -0.21408063f, 
    -0.04551489f, 0.34318757f, 0.38443986f, 0.28531930f, 0.18540725f, 0.03407815f, 0.42611808f, 0.15878794f, 
    0.34938157f, -0.27760524f, -0.32502910f, 0.50503457f, 0.04279757f, -0.20278165f, 0.28363279f, 0.26817724f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.07803567f, 0.41116560f, -1.20143843f, -0.26319933f, -0.17669818f, -1.08052492f, -0.15926555f, -0.08677047f, 
    0.26479852f, -1.27769625f, -0.35828447f, 0.54763657f, 0.01837706f, -0.86008137f, -0.01355123f, -0.04706181f, 
    0.01095337f, -0.33394530f, -0.11503802f, -0.32659239f, -1.06560671f, -0.05506747f, 0.13132422f, 0.00343977f, 
    -0.10785155f, -0.05304947f, -0.07500798f, -0.11801516f, -1.04125941f, 0.24162906f, 0.17944908f, 0.03968246f, 
    -0.16838376f, 0.12054671f, -0.49348143f, 0.11124472f, -0.04116621f, -0.24254127f, 0.00289519f, -0.11846840f, 
    -0.03350480f, -0.50332797f, -0.06480433f, -0.56018472f, 0.63126981f, -0.08418132f, 0.18953952f, -0.04652093f, 
    -0.25259730f, 0.34280425f, 0.06179767f, 0.19217671f, 0.14351924f, -0.03667939f, -0.14424324f, 0.09146760f, 
    0.40952137f, -0.16075945f, 0.21673146f, 0.34345552f, -1.29494464f, -0.16646837f, 0.16290894f, 0.31545967f, 
    -0.16332942f, -0.00380944f, 0.75022447f, 0.22324215f, 0.01367815f, 0.11540624f, 0.08616908f, -0.28168470f, 
    0.01246348f, 0.43754268f, 0.11206049f, -0.71850795f, -0.90212262f, -0.03689985f, -0.05173697f, -0.95305210f, 
    -0.65600652f, -0.05823371f, -0.39787692f, -0.23864090f, 0.02637082f, -0.16075128f, 0.13897119f, -0.25923657f, 
    0.73898506f, -0.04423995f, -0.38432619f, 0.24974145f, 0.28224725f, 0.19482400f, -0.89358652f, -0.12479411f, 
    -0.01760458f, -0.16723417f, 0.25368372f, -0.05858857f, -0.42270988f, -0.26583099f, -0.44457304f, -0.08341306f, 
    0.04096757f, 0.03879005f, -0.19065297f, 0.34810078f, -0.32146588f, 0.35451099f, -0.83651167f, -0.12225223f, 
    0.27445120f, -0.07843878f, -0.46794963f, -0.53445864f, -0.84847116f, -0.14297612f, 0.28712147f, 0.21316797f, 
    -0.34701419f, -0.10357205f, 0.68667632f, 0.12112086f, -0.23431347f, 0.05749422f, 0.10253985f, 0.15313642f, 
    -0.05948436f, 0.14678997f, -0.25255656f, -0.68705845f, 0.18226545f, 0.41003376f, 0.10120682f, 0.30437905f, 
    0.15441050f, -0.23359101f, -0.53102970f, -0.05036807f, -0.10726664f, -0.58123261f, -0.21610318f, 0.11425808f, 
    -0.05164446f, -0.38020298f, 0.12200698f, -0.17625681f, 0.12862015f, 0.08216222f, 0.19791339f, 0.07171121f, 
    -0.25186643f, -0.01294140f, -0.58230239f, -0.33656225f, 0.07971854f, -0.06861580f, 0.20732684f, -0.73440862f, 
    -0.17852437f, 0.15338334f, 0.26881465f, 0.30222628f, -0.08968130f, -0.38223997f, -0.27876586f, 0.22354217f, 
    0.02656786f, -0.35604793f, -0.02040770f, -0.18368316f, 0.02744123f, -0.27219605f, 0.15353726f, 0.23741473f, 
    -0.38891676f, -0.68195182f, -0.09720676f, -0.05697072f, 0.50826514f, 0.04080940f, 0.01303348f, -0.17814094f, 
    -0.35237801f, 0.00821168f, 0.02887111f, 0.24802849f, -0.13216367f, 0.37361321f, -0.25393665f, 0.17674151f, 
    0.06707178f, -0.14780240f, 0.57149643f, 0.01639517f, 0.12814082f, 0.40954289f, 0.26327184f, 0.11659675f, 
    -0.42297652f, 0.24734670f, 0.27049968f, -1.41907275f, -0.22865261f, 0.36034623f, 0.02550082f, -0.83750987f, 
    0.00969770f, 0.41165647f, 0.34700269f, -0.05691331f, -0.20842889f, -0.03515167f, -1.69867682f, -0.54360688f, 
    0.52924365f, 0.08605330f, 0.18538173f, -1.58626139f, 0.65131390f, 0.09112749f, -0.43650648f, -0.65335453f, 
    0.11332345f, -0.30808246f, -0.56705123f, -0.41698900f, 0.14320771f, 0.33702293f, -0.13855708f, 0.17955710f, 
    0.17019793f, -0.59732318f, -0.39896858f, 1.01111722f, -0.42385238f, -0.21818426f, -0.25813824f, 0.00451501f, 
    0.34404817f, -0.43841448f, -0.11715059f, 0.17627323f, -0.82864046f, 0.01443418f, -1.28610444f, 0.09260129f, 
    -0.61181790f, -0.08527898f, -0.50448489f, -1.13914168f, 0.32856545f, -0.01100226f, 0.34274822f, 0.08583755f, 
    -0.10334358f, -0.59014642f, -0.30107781f, 0.49734476f, -0.36673206f, 0.35796690f, 0.20299651f, -0.49624425f, 
    -0.73557752f, -0.70943409f, 0.22400631f, -0.10645804f, -0.00287535f, 0.11615740f, 0.11479118f, 0.35644135f, 
    -0.08542512f, 0.40396792f, -1.00745738f, 0.18746765f, 0.01863587f, 0.03901207f, -1.02016759f, -0.31699061f, 
    -0.09487770f, -0.08254515f, 0.11392629f, 0.66956645f, -0.76916379f, 0.27384579f, 0.45632246f, 0.08176515f, 
    0.16034232f, -0.19138910f, -0.33172706f, -0.55043405f, 0.10169809f, -0.78721648f, -0.19488473f, 0.09974252f, 
    0.25663632f, 0.42169362f, 0.28048912f, 0.24546044f, -1.10714412f, 0.35071263f, -0.11089558f, 0.15856415f, 
    0.60815644f, -0.93187469f, 0.36939430f, 0.05813722f, -0.23699707f, 0.07836918f, -0.30600670f, -0.51653659f, 
    0.01058998f, -0.08840745f, -1.03193462f, -0.40763789f, 0.15234983f, -0.03314029f, -0.86745584f, -0.49836516f, 
    0.06825718f, 0.49841985f, -0.07832015f, 0.05222263f, 0.38818967f, 0.57095164f, -0.38706496f, -0.68103224f, 
    -0.10651452f, 0.30106828f, 0.08866647f, -0.18061574f, -0.10104477f, 0.27923751f, -0.64008605f, 0.29402509f, 
    -0.91940784f, -0.10054337f, -0.32764915f, -0.51051950f, 0.72351599f, 0.14254266f, -0.10218588f, 0.37650263f, 
    -0.87479848f, -0.14491968f, -0.56941682f, 0.11351356f, -0.72837681f, -0.88586950f, -0.14365292f, -0.15466070f, 
    -0.14161953f, -1.29288149f, 0.25789386f, 0.17470102f, 0.35760352f, -0.03036019f, 0.33709103f, 0.11810930f, 
    -0.73552650f, 0.47138551f, 0.12530324f, 0.20478341f, 0.50012827f, 0.20079808f, 0.19087839f, 0.30017841f, 
    -0.08625102f, -1.09088814f, 0.43728802f, 0.14909858f, -0.14582491f, 0.06345071f, 0.17139947f, -0.55876219f, 
    -0.14949040f, -0.03736148f, -0.47968403f, -0.15369602f, 0.03132323f, -0.83680034f, -0.04514636f, 0.37706423f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.37115222f, 0.57997179f, -0.07464175f, 0.08301977f, 0.00210896f, -0.05541375f, -0.38246641f, -0.09948727f, 
    -0.13018131f, 0.17552307f, -0.10683385f, -0.25026718f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
