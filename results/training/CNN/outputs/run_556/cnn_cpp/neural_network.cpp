#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.17453663f, -0.16640463f, -0.09986363f, 0.51991582f, -0.20396833f, -0.36074215f, -0.16886449f, -0.15234244f, 
    0.35628566f, 0.68486321f, -0.62044507f, -0.00272986f, -0.10541507f, -0.49149874f, 0.32929236f, -0.04181365f, 
    -0.19287474f, 0.05250430f, 0.64301836f, 0.57184500f, 0.70797312f, -0.20086978f, -0.01329929f, -0.15523328f, 
    0.03128156f, 0.11324138f, -0.12636417f, 0.42686856f, 0.56863821f, -0.22754258f, 0.53021634f, 0.37012714f, 
    -0.06179484f, 0.19197103f, 0.26568246f, 0.04143461f, 0.00329034f, 0.53394854f, -0.18248579f, -0.13659957f, 
    0.26395538f, 0.26080826f, 0.23888077f, 0.12798147f, 0.38192323f, 0.19282778f, -0.50675488f, -0.39928955f, 
    -0.61222833f, -0.05092646f, -0.11961201f, -0.00319660f, 0.01539568f, 0.09284856f, -0.47961521f, 0.53411454f, 
    -0.00371453f, 0.23246792f, 0.41281521f, 0.41649124f, 0.19106442f, -0.18148832f, -0.06615424f, -0.11518519f, 
    -0.35980347f, -0.25981179f, 0.44594833f, -0.04120331f, 0.30012122f, -0.39571807f, -0.04812714f, -0.15084359f, 
    0.01662200f, -0.37800038f, -0.15732288f, -0.09784567f, 0.65640926f, -0.48174945f, 0.18868043f, -0.06302476f, 
    -0.04533738f, 0.61451167f, 0.59298462f, -0.22432029f, -0.33301771f, -0.40708268f, 0.11832517f, 0.10855573f, 
    0.09958523f, -0.04057465f, -0.62670332f, 0.53871024f, -0.35774034f, -0.01347299f, 0.14767018f, -0.48401678f, 
    -0.09311155f, 0.12904415f, -0.23872514f, 0.16830939f, 0.09539883f, -0.28785461f, 0.10339711f, -0.41294882f, 
    -0.47155407f, -0.31835550f, -0.26046780f, 0.06226347f, 0.39039382f, -0.32535371f, 0.29029649f, 0.63172263f, 
    0.23944527f, 0.16527309f, -0.17310363f, -0.38053960f, 0.15006898f, 0.38238615f, -0.23647211f, 0.40081438f, 
    0.54300547f, -0.06028078f, 0.23500533f, 0.25379369f, 0.23419219f, -0.00790551f, -0.34960285f, -0.29430521f, 
    0.05453169f, 0.73862547f, 0.58930463f, -0.10872433f, 0.23151127f, 0.16817012f, -0.03751253f, -0.51791674f, 
    -0.65729642f, -0.63494080f, -0.02376836f, 0.00283111f, 0.20075130f, 0.03512739f, -0.06847189f, 0.01434174f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.35271046f, -0.15192251f, -0.03434847f, 0.24484056f, -0.03524879f, -0.00230398f, -0.39059100f, -0.08174866f, 
    -0.13562447f, -0.22849865f, 0.02451128f, 0.31997210f, -0.03316205f, -0.50084335f, -0.20534557f, 0.21730962f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.06599721f, 0.08743088f, -0.12709823f, 0.07548582f, -0.02212970f, 0.01535952f, 0.03583340f, 0.05256151f, 
    -0.04326608f, 0.15767451f, 0.03292099f, -0.00509829f, -0.09914432f, -0.04435421f, 0.03847344f, -0.06477053f, 
    -0.03979256f, -0.03745601f, -0.06707996f, 0.02309075f, 0.02316390f, 0.01953262f, 0.01471194f, -0.06629550f, 
    -0.14154856f, 0.01508227f, -0.02276278f, -0.17649379f, 0.11676688f, 0.09050310f, -0.06995699f, -0.12791210f, 
    -0.15105204f, 0.14222658f, -0.08819436f, -0.06875226f, -0.35243854f, 0.15797628f, 0.21513082f, -0.01294189f, 
    -0.21403167f, -0.00997929f, -0.12821898f, -0.03460175f, -0.05526195f, 0.20425659f, -0.04226239f, 0.01439970f, 
    -0.12613761f, 0.20530428f, -0.13419007f, -0.12456722f, 0.07449372f, 0.02441127f, 0.08711696f, -0.15900725f, 
    0.19925335f, 0.16968042f, 0.05601276f, -0.21359813f, -0.01092244f, 0.08021737f, 0.13878384f, 0.36927861f, 
    0.19439010f, 0.36269379f, -0.15911703f, 0.19934770f, -0.01057866f, 0.07552177f, 0.00723386f, 0.03880978f, 
    -0.08280649f, 0.24208851f, 0.25901636f, -0.04030156f, -0.00281702f, 0.08691208f, -0.00130742f, -0.00669995f, 
    -0.04429518f, -0.33870909f, 0.05572398f, -0.11235724f, -0.09873578f, -0.04219602f, -0.22689018f, -0.03864990f, 
    0.01685414f, 0.00006080f, -0.02726187f, -0.04731203f, 0.03742457f, 0.08913742f, -0.21419653f, 0.07461078f, 
    0.00568060f, -0.09752736f, -0.04975273f, 0.20102052f, 0.13255720f, 0.12790853f, -0.04014590f, -0.14301525f, 
    -0.00187852f, -0.00844638f, -0.06232269f, 0.01444308f, 0.17854989f, -0.01677012f, -0.31771842f, -0.13423705f, 
    -0.01721978f, -0.05307721f, 0.15304294f, -0.09166533f, -0.02512892f, -0.38390464f, -0.02221833f, -0.36598048f, 
    0.14105882f, 0.09647591f, 0.12242714f, 0.04575131f, -0.09590439f, 0.02159142f, 0.05409902f, 0.28325182f, 
    -0.06343148f, -0.09215364f, 0.08270385f, -0.03558163f, -0.01020215f, 0.14674670f, 0.09191461f, -0.10087796f, 
    0.05482461f, 0.08294373f, 0.20234007f, 0.02782072f, 0.11451881f, 0.05292349f, 0.08227464f, 0.10196419f, 
    -0.02007960f, -0.15391712f, 0.05646849f, -0.14261271f, 0.01590815f, -0.09663405f, -0.04327827f, 0.00227130f, 
    0.10106400f, -0.15715496f, 0.20485222f, -0.06231330f, -0.02023509f, -0.00646041f, -0.05733112f, -0.02844527f, 
    -0.06596232f, 0.07398135f, -0.02558642f, 0.24729052f, 0.13274336f, 0.13730937f, 0.25643322f, -0.00441192f, 
    -0.04820650f, -0.07684796f, -0.07075470f, 0.12307984f, -0.13344009f, -0.03883032f, -0.06181829f, -0.08639415f, 
    0.17874807f, 0.03408785f, -0.00380082f, -0.01299121f, -0.21373865f, 0.07058518f, -0.35755122f, 0.02668024f, 
    0.06647091f, -0.04790006f, -0.07596133f, -0.06524889f, -0.08962442f, 0.47318533f, -0.04739308f, 0.01272872f, 
    0.05915056f, 0.11484248f, -0.00843759f, -0.05888538f, -0.03900324f, -0.15446605f, 0.26535442f, 0.14946598f, 
    -0.10060914f, -0.05362162f, 0.05489338f, 0.05683529f, -0.12569962f, 0.08452906f, 0.06643078f, 0.00774144f, 
    -0.03759234f, -0.15014222f, -0.01811000f, -0.21283378f, 0.07368666f, 0.06658684f, 0.04738441f, 0.11781970f, 
    0.09404007f, -0.11272430f, 0.04173498f, 0.16225798f, -0.06103057f, -0.06519820f, -0.06551324f, -0.06815450f, 
    0.05080840f, -0.01079823f, 0.33281603f, 0.05333131f, 0.02245918f, 0.00402791f, 0.04239801f, -0.17277449f, 
    0.07235766f, -0.00388897f, 0.20581891f, -0.25769076f, -0.16750635f, -0.10739874f, -0.01692235f, -0.01235192f, 
    -0.11938024f, -0.00137948f, 0.05086927f, -0.30398250f, -0.12985076f, 0.03938419f, -0.08656165f, 0.03226518f, 
    -0.06620733f, -0.05285659f, 0.14381158f, 0.05797907f, -0.19928280f, -0.03692930f, 0.08774293f, 0.06338216f, 
    -0.01759628f, -0.04872936f, 0.05691631f, -0.08233605f, -0.03959573f, -0.43797138f, -0.04446436f, -0.05131606f, 
    0.05604516f, 0.15205438f, -0.01583140f, 0.02211306f, 0.02848990f, 0.06171760f, 0.45797190f, -0.17437135f, 
    0.08767702f, -0.08763402f, -0.18859409f, -0.17797367f, 0.02396629f, 0.06083921f, 0.05642687f, 0.05976498f, 
    -0.09337111f, 0.15971619f, -0.23312601f, -0.01226578f, 0.02737177f, 0.04314658f, -0.04683177f, -0.08263730f, 
    0.24012138f, -0.34844604f, 0.03424054f, -0.11477338f, -0.02460920f, -0.12726723f, 0.19108953f, -0.08021920f, 
    0.00837942f, -0.05869958f, 0.12945209f, -0.05270809f, 0.04078460f, -0.09052695f, -0.11537254f, 0.10045363f, 
    0.16116275f, -0.19686493f, 0.35546353f, -0.05108834f, -0.26225847f, -0.01709002f, -0.00252392f, -0.00846537f, 
    0.05494035f, -0.06351788f, -0.02898350f, 0.09427342f, -0.02517918f, -0.08713100f, 0.38791877f, -0.01268077f, 
    -0.07546732f, 0.11243694f, -0.06190622f, 0.03709301f, 0.05787552f, -0.10797765f, 0.03524964f, -0.06790159f, 
    0.06759669f, 0.19317156f, 0.01482198f, -0.15472430f, -0.17743218f, -0.08506587f, -0.15239795f, 0.04899937f, 
    0.06384555f, -0.13008109f, 0.05592420f, -0.00637261f, 0.06862653f, -0.04080370f, -0.31117490f, -0.14589883f, 
    -0.03519797f, -0.10036869f, 0.17231873f, 0.15628485f, -0.08275525f, 0.06803973f, -0.16408697f, 0.38686556f, 
    0.09887867f, 0.03180596f, -0.00521706f, 0.07993806f, 0.00133999f, -0.14875874f, 0.02660044f, 0.03298871f, 
    0.07075375f, 0.09701453f, -0.16324437f, 0.03623313f, -0.06543857f, 0.13982110f, -0.15442130f, 0.08238362f, 
    -0.07873100f, 0.26510450f, 0.29017651f, -0.05121443f, -0.03215506f, -0.08024058f, 0.02015666f, -0.03467067f, 
    0.17233536f, -0.10608570f, 0.05124464f, -0.06021122f, 0.04490957f, -0.04317717f, -0.04516869f, -0.30856410f, 
    -0.07700267f, -0.05286385f, 0.13090181f, -0.02762567f, -0.00887635f, 0.09721413f, 0.03435308f, -0.01637189f, 
    0.02814644f, -0.02052466f, 0.10164846f, -0.05230515f, -0.28716934f, -0.13983567f, -0.11734344f, 0.17456402f, 
    -0.03523017f, 0.01188891f, -0.08111796f, -0.09510919f, -0.02316810f, -0.20677382f, -0.27563292f, -0.14209682f, 
    0.11598418f, 0.09706514f, 0.05587767f, -0.08748066f, -0.03186481f, 0.01919113f, -0.15591462f, 0.06846465f, 
    0.07559832f, -0.03448726f, 0.12958880f, 0.07726058f, -0.00644944f, -0.19531073f, 0.11384334f, 0.09523459f, 
    0.20863223f, 0.07406929f, -0.00092669f, 0.00943533f, -0.08155797f, 0.11034543f, 0.10383298f, 0.08473059f, 
    0.03180796f, 0.05559437f, -0.04580446f, -0.05215119f, 0.00550046f, -0.04635781f, -0.10502629f, 0.01241850f, 
    -0.06845103f, -0.02553472f, -0.07283910f, 0.04115109f, -0.05148743f, 0.00656603f, 0.04139011f, -0.08391383f, 
    0.05147828f, -0.06944379f, 0.02606370f, -0.03882314f, -0.01954605f, 0.03246232f, -0.02325095f, 0.03590015f, 
    0.04011881f, -0.08096886f, 0.00007474f, 0.01971320f, -0.09704152f, -0.06948742f, -0.09957960f, 0.05425272f, 
    -0.08007680f, -0.03618729f, -0.03096309f, 0.02227130f, -0.06550889f, -0.01907429f, -0.05944505f, -0.01418783f, 
    0.06575942f, 0.05682006f, 0.03282147f, 0.03737853f, 0.00380794f, -0.02899251f, 0.02359321f, 0.05346804f, 
    -0.09997724f, 0.04200673f, 0.06035173f, -0.00538477f, 0.02105600f, 0.05564831f, 0.05186575f, -0.01762955f, 
    0.00809476f, 0.00367633f, -0.09273764f, -0.03352568f, -0.00495202f, 0.06074990f, 0.01634016f, -0.07625566f, 
    0.01375406f, 0.04431580f, 0.02502972f, -0.04700038f, -0.05375250f, -0.05719926f, -0.06451859f, -0.07210960f, 
    0.04386612f, -0.06821068f, 0.05466673f, -0.06101674f, 0.00542402f, 0.00659595f, -0.09572481f, -0.00014347f, 
    0.05115211f, -0.07323872f, -0.00990414f, -0.00749751f, 0.03217074f, -0.08016618f, 0.05275562f, -0.01244322f, 
    0.06700037f, -0.00413575f, -0.00580374f, -0.06663397f, -0.09886538f, 0.02610593f, -0.09251162f, -0.01030048f, 
    0.04998032f, -0.02311698f, -0.08006327f, 0.05663850f, -0.05661979f, -0.00645404f, 0.00200849f, -0.01339647f, 
    -0.04899767f, -0.08800333f, -0.07040455f, -0.03908928f, 0.01820697f, -0.01057981f, 0.02962965f, -0.02365142f, 
    -0.00223417f, -0.00735175f, -0.00450975f, -0.05036137f, 0.03135475f, 0.00410884f, -0.07566283f, -0.01403974f, 
    -0.04720621f, -0.02826123f, 0.04859701f, 0.01641187f, 0.02867826f, -0.04425503f, 0.04484699f, -0.07378831f, 
    -0.08485616f, -0.09524237f, -0.02327065f, -0.03942377f, 0.01647806f, -0.01089924f, -0.00588161f, -0.02153164f, 
    0.06300885f, -0.06455506f, -0.07709479f, -0.06464717f, -0.08228653f, 0.04839385f, -0.07741930f, -0.09018634f, 
    -0.07964625f, 0.16498800f, 0.08483817f, 0.00022978f, -0.07464763f, -0.09957160f, -0.14606616f, -0.10824291f, 
    0.10999863f, 0.13339372f, -0.08213941f, -0.06478817f, -0.05942927f, -0.09933916f, -0.21983081f, 0.06941485f, 
    0.08960297f, 0.07702225f, -0.43806890f, -0.17438106f, 0.08968209f, 0.18998463f, 0.14730033f, 0.20121229f, 
    0.03236716f, -0.08136905f, -0.27179515f, -0.03896746f, 0.24096875f, -0.00590990f, 0.18009047f, -0.28168657f, 
    0.11778112f, 0.03947086f, 0.01501281f, 0.05562083f, -0.42073902f, 0.05501630f, 0.10138367f, -0.05423253f, 
    0.10798054f, 0.03843312f, -0.03758424f, 0.00797263f, -0.06738552f, -0.13321406f, -0.01380265f, 0.06572057f, 
    -0.02504739f, -0.13437699f, -0.16883497f, 0.00134142f, 0.01253444f, 0.08859559f, -0.22159867f, 0.32349795f, 
    0.14378256f, 0.24346232f, 0.03464878f, 0.21131100f, 0.11329267f, -0.04069128f, -0.00898645f, 0.19293965f, 
    -0.01324930f, 0.22429223f, -0.10987870f, 0.11991241f, 0.19010749f, 0.03246326f, -0.23598042f, 0.03104224f, 
    0.01994068f, 0.11905276f, 0.11791901f, -0.20309266f, -0.11637662f, -0.21303803f, -0.10646001f, -0.10378891f, 
    -0.07388349f, 0.01860235f, -0.19397797f, -0.11160932f, -0.01515975f, 0.01441776f, -0.01156070f, -0.12295800f, 
    0.20101416f, -0.11261866f, 0.40778482f, 0.13305640f, 0.05090458f, -0.03106130f, -0.04907532f, -0.05437114f, 
    -0.08194873f, 0.02078634f, 0.06308497f, 0.10289753f, 0.06962006f, -0.04904352f, -0.06701579f, -0.01838104f, 
    -0.07862333f, -0.01603645f, -0.11650061f, 0.03191783f, -0.17236398f, 0.00293722f, -0.12004150f, 0.17971033f, 
    -0.17557533f, -0.11791777f, -0.15813813f, 0.13098823f, -0.16142616f, -0.12430861f, 0.14651479f, -0.05977367f, 
    0.07638171f, -0.05324980f, 0.19693044f, 0.08098702f, 0.06889799f, -0.02670590f, 0.13642888f, 0.00201729f, 
    0.01077511f, 0.10578799f, 0.02780198f, 0.06794481f, -0.02346052f, 0.07985272f, 0.10452803f, 0.01103658f, 
    -0.03373943f, 0.05116903f, -0.00774781f, -0.07957020f, 0.06197204f, 0.04741986f, 0.09853829f, 0.01741841f, 
    -0.15755434f, 0.03044672f, -0.07884627f, -0.19962515f, -0.10026685f, 0.00017337f, 0.00805471f, -0.11162245f, 
    0.27034202f, -0.21481471f, 0.20168595f, -0.01145492f, 0.01556919f, -0.09062628f, 0.04905861f, 0.17263785f, 
    -0.07005437f, 0.03030414f, -0.12199944f, -0.09774211f, 0.17408548f, 0.04413934f, 0.07927163f, -0.11088435f, 
    0.03572932f, -0.00332310f, -0.06876974f, 0.06585000f, 0.10693567f, 0.01218437f, -0.00076703f, -0.12437046f, 
    -0.02019908f, 0.06263882f, -0.03853978f, -0.03213121f, 0.12957731f, 0.17357856f, -0.00159122f, -0.03978792f, 
    -0.04843207f, 0.05603493f, 0.04647128f, -0.08839968f, 0.14739159f, -0.21371858f, 0.42026412f, 0.01341415f, 
    0.06520812f, 0.08167952f, 0.01559972f, -0.08396706f, 0.06112307f, 0.06331567f, 0.13946976f, 0.00694289f, 
    0.12874471f, -0.08534386f, 0.03676161f, -0.14383966f, -0.02073883f, 0.04706511f, -0.06339267f, 0.00151286f, 
    0.13374524f, -0.07533810f, -0.04226746f, 0.00533475f, -0.00511307f, 0.12223133f, 0.05931599f, 0.07936049f, 
    -0.24446440f, -0.14295270f, -0.06255415f, 0.01826584f, 0.10322160f, 0.00999004f, 0.00336711f, -0.04054746f, 
    -0.04596982f, -0.28522408f, -0.04675304f, -0.37871113f, 0.12281834f, 0.03466870f, -0.07970351f, -0.04812874f, 
    -0.07215435f, -0.11487983f, -0.10734177f, -0.10626995f, -0.62961006f, -0.08408217f, 0.07668079f, -0.00025025f, 
    0.00509045f, 0.03959529f, 0.03181208f, -0.37423354f, -0.14222094f, -0.21860418f, -0.04044236f, 0.02491672f, 
    -0.04494450f, 0.01865764f, -0.05488839f, 0.09832349f, 0.09147140f, 0.16218255f, 0.08740419f, -0.10007136f, 
    0.03803511f, -0.03519638f, -0.10671732f, -0.00670308f, 0.01887490f, -0.07943837f, 0.24665675f, 0.03349183f, 
    -0.07449646f, -0.02601863f, 0.01215506f, -0.03904711f, -0.17133884f, -0.00640767f, -0.09066243f, -0.06077447f, 
    0.08605644f, -0.00610279f, -0.15763356f, 0.08424868f, 0.03980270f, -0.01292486f, 0.00612814f, 0.05014162f, 
    0.27051854f, 0.48159489f, -0.08772598f, -0.03813680f, -0.02208516f, 0.01865456f, 0.03419083f, -0.03582515f, 
    -0.03017785f, -0.01521771f, -0.11507047f, -0.07148792f, 0.04576835f, 0.14906208f, 0.16720799f, 0.08449822f, 
    -0.03747341f, 0.08742981f, 0.17713551f, -0.00758198f, 0.00685060f, 0.06873929f, 0.09057309f, 0.01073078f, 
    0.01145259f, 0.02586150f, 0.13093571f, -0.35449579f, 0.06355789f, 0.06241279f, 0.07452574f, 0.18681701f, 
    -0.14443670f, -0.01729809f, 0.10399847f, 0.18472014f, -0.09375591f, -0.03671402f, -0.01473562f, 0.02648454f, 
    -0.04994304f, 0.05539761f, -0.01096048f, 0.32856187f, -0.05242246f, 0.02329350f, 0.04565955f, -0.01553704f, 
    -0.09476823f, 0.03283644f, 0.04805155f, -0.10776345f, -0.09098998f, -0.06629805f, 0.20187850f, -0.33174330f, 
    0.05221906f, -0.22460949f, 0.00100365f, -0.01327386f, -0.10147815f, -0.12006693f, -0.06172422f, -0.04985846f, 
    -0.06007911f, 0.13586517f, 0.00657170f, -0.21402480f, -0.15343721f, 0.16703524f, 0.05267776f, 0.10457821f, 
    -0.02038842f, -0.04143529f, -0.02977283f, 0.16872057f, 0.01090479f, -0.08457080f, -0.02499721f, 0.02155205f, 
    0.00272371f, 0.03443286f, -0.10068356f, 0.01555382f, -0.02657253f, -0.11754823f, -0.09024131f, -0.03533847f, 
    -0.20356517f, 0.18451871f, -0.18327177f, -0.04636933f, 0.02214675f, -0.13985458f, 0.03789226f, -0.01843865f, 
    -0.05300152f, -0.02576205f, 0.14030807f, 0.03789528f, 0.13785549f, -0.07788175f, 0.02107735f, 0.13374731f, 
    -0.08152966f, -0.04231449f, -0.11137308f, 0.20473737f, -0.12776463f, 0.03562857f, 0.12959585f, 0.11600178f, 
    -0.04028986f, -0.25402656f, -0.05433218f, 0.00081849f, -0.25144663f, -0.22708996f, -0.04396849f, 0.13322794f, 
    0.04620869f, -0.00699551f, 0.00924912f, 0.07146481f, 0.03212171f, -0.24040569f, -0.22429475f, -0.10719475f, 
    0.19495654f, -0.07366067f, -0.12824929f, 0.14711687f, 0.35064632f, -0.06033225f, -0.14128149f, 0.09311629f, 
    0.00987898f, -0.08791830f, 0.06555592f, -0.11617143f, 0.06914389f, 0.03381098f, -0.02295138f, 0.14693363f, 
    0.38756070f, -0.04390759f, -0.05877981f, -0.12993632f, 0.02845768f, 0.02717250f, 0.16236043f, 0.11377827f, 
    -0.09949672f, -0.11790727f, -0.13745455f, 0.04934444f, 0.11708590f, -0.07409569f, 0.02028505f, -0.01497154f, 
    0.09054641f, -0.07565657f, -0.02687146f, -0.14968683f, -0.08563006f, -0.02493022f, 0.15952797f, 0.05098166f, 
    -0.07847816f, 0.03651886f, 0.51528728f, 0.16915561f, 0.10099870f, 0.07068039f, -0.00485465f, 0.14376128f, 
    0.08238644f, 0.00095792f, 0.08582365f, 0.29976410f, -0.02116867f, 0.27138186f, -0.01864754f, 0.03624095f, 
    -0.19911695f, 0.00513036f, 0.05251056f, 0.02111465f, 0.17763530f, 0.06837805f, 0.16817573f, -0.08374745f, 
    -0.03639413f, -0.05081208f, 0.05608032f, -0.09448022f, -0.01343361f, -0.16904525f, -0.01809288f, -0.31898856f, 
    0.11844033f, -0.00697335f, -0.00599478f, 0.05706420f, -0.01563824f, -0.02567049f, -0.42007139f, 0.16195388f, 
    -0.08783238f, -0.01478186f, 0.10190800f, -0.00608054f, 0.00831854f, 0.02894771f, 0.04592581f, -0.24539612f, 
    0.00761440f, 0.00590665f, 0.06942920f, -0.02596375f, -0.14764754f, -0.05367211f, -0.00406610f, 0.06199693f, 
    -0.04203993f, -0.12275311f, -0.01666687f, 0.02893630f, 0.07012517f, 0.20779292f, 0.00082128f, 0.00019969f, 
    -0.06257104f, 0.36610529f, 0.20491518f, 0.08512316f, 0.03742791f, -0.14829829f, -0.07862742f, -0.02666168f, 
    -0.07065435f, 0.06444527f, -0.37007779f, 0.02745084f, 0.14739697f, -0.00195923f, 0.12950237f, -0.18071821f, 
    0.00950072f, -0.05727098f, -0.00027402f, 0.16936827f, -0.04294595f, 0.09975597f, 0.08711111f, 0.08421507f, 
    -0.07446597f, -0.06572275f, -0.00800984f, 0.10188761f, -0.28283450f, -0.17758687f, -0.09177999f, 0.07187018f, 
    0.13669892f, 0.03736543f, 0.00703477f, -0.04593066f, 0.06840931f, -0.18496779f, -0.13750689f, 0.21570984f, 
    -0.00276416f, 0.05309819f, 0.08602055f, 0.07636523f, -0.01836884f, -0.11677688f, -0.49841335f, -0.50943136f, 
    -0.18296637f, 0.03755285f, -0.04988620f, 0.00562483f, -0.09678753f, -0.10342105f, -0.12242629f, -0.08209580f, 
    -0.08249879f, -0.11359739f, -0.02892281f, 0.09880666f, -0.01669960f, 0.06120327f, 0.06956407f, 0.03325107f, 
    -0.18629047f, -0.17790920f, -0.09686000f, -0.07954364f, 0.03162837f, 0.02386816f, -0.08568092f, -0.21109380f, 
    0.07472795f, -0.09526153f, -0.21214680f, 0.15314457f, 0.00812324f, 0.10212930f, -0.04457505f, -0.04358890f, 
    0.03255662f, 0.04075087f, -0.08690900f, 0.05170231f, -0.33996692f, 0.30152068f, 0.07633860f, 0.01594708f, 
    0.04142415f, 0.00122256f, -0.06562509f, 0.30278528f, 0.16204943f, -0.03161140f, 0.13238123f, -0.00280078f, 
    -0.07698762f, -0.00452258f, 0.09935252f, -0.00548367f, -0.20501085f, 0.20212494f, 0.06145759f, 0.11273485f, 
    -0.01523878f, 0.19171794f, 0.02735213f, -0.09478384f, 0.23499191f, 0.23437673f, -0.08142535f, -0.06198120f, 
    0.05007272f, -0.01644446f, -0.07491689f, -0.08143474f, -0.09280411f, 0.05148559f, -0.19132668f, -0.07227293f, 
    -0.08636081f, -0.04384227f, 0.12038115f, -0.05591876f, 0.04094455f, 0.01997377f, 0.03747498f, -0.00649758f, 
    -0.11734265f, 0.05200408f, 0.03376601f, 0.04186347f, -0.07374823f, -0.01752785f, 0.01847807f, 0.03278334f, 
    0.03457471f, -0.24888787f, -0.16625255f, 0.02240307f, -0.00296355f, 0.03511249f, -0.04689971f, 0.03060408f, 
    -0.11462488f, -0.16009369f, 0.13619903f, 0.05972116f, -0.02014795f, -0.00962344f, -0.14000829f, -0.00826433f, 
    0.11336488f, -0.08466349f, -0.42116880f, -0.02606552f, -0.01682374f, 0.03387379f, -0.08775181f, 0.11041283f, 
    -0.02238212f, 0.02576976f, -0.04715475f, 0.29006499f, 0.10010149f, -0.26713353f, 0.04766244f, 0.06980047f, 
    -0.01327922f, 0.16637734f, 0.02879896f, 0.08508658f, 0.31351608f, -0.06576241f, 0.14047264f, -0.09462752f, 
    0.03446820f, -0.01182387f, -0.12070484f, 0.02977294f, 0.15554231f, 0.17511433f, 0.02427823f, -0.22047684f, 
    0.22680609f, 0.17340288f, -0.08685912f, -0.11936701f, 0.07786807f, -0.02919719f, 0.03944132f, -0.19121687f, 
    0.26453322f, -0.10434768f, -0.22734703f, -0.10585850f, 0.04614421f, -0.07614217f, 0.00867014f, -0.13068397f, 
    -0.13549593f, 0.48820314f, -0.02018173f, 0.00857679f, 0.03618528f, -0.10433667f, 0.01756713f, 0.00335997f, 
    -0.06195961f, -0.14824192f, -0.18143961f, -0.07580157f, -0.12589671f, -0.11041427f, 0.13435312f, -0.00734462f, 
    -0.11294672f, -0.19408305f, -0.03739298f, -0.01720116f, -0.01284165f, -0.00068441f, 0.02139010f, -0.03035375f, 
    0.19246677f, -0.05227038f, -0.66496134f, -0.18239300f, 0.03733382f, 0.41368902f, 0.06877495f, 0.06161796f, 
    0.03750586f, 0.00772318f, -0.00121546f, -0.33577049f, -0.21279356f, -0.18674716f, -0.03489622f, 0.11880319f, 
    0.03821578f, 0.08873012f, 0.03804003f, 0.11612274f, -0.11166723f, -0.00006017f, -0.14429541f, -0.19647904f, 
    0.04243011f, 0.05359133f, -0.04719542f, 0.01871724f, 0.10080361f, 0.00870363f, -0.09398352f, 0.14047889f, 
    0.13429742f, -0.05418163f, 0.06889151f, 0.09094048f, 0.01002188f, 0.13006569f, -0.15559919f, -0.06847566f, 
    0.03191474f, 0.05263523f, 0.14873961f, -0.10846921f, 0.00755051f, -0.05546170f, -0.21358535f, 0.16222137f, 
    0.10252099f, 0.05711737f, 0.04683971f, -0.09633488f, 0.08174700f, -0.16662294f, 0.06842939f, 0.00633620f, 
    -0.00544329f, -0.10321320f, -0.06949315f, 0.07369304f, -0.25159821f, 0.03620201f, 0.09424876f, 0.08186109f, 
    0.00877396f, -0.15772554f, -0.12555924f, -0.08410307f, 0.04113667f, -0.01280196f, 0.07263198f, -0.09467898f, 
    -0.11803333f, -0.01986136f, 0.13278565f, 0.11593803f, -0.11298111f, -0.05863091f, 0.12583007f, -0.02681314f, 
    -0.01063627f, 0.13276477f, -0.03039824f, 0.02169337f, 0.08330546f, 0.14403498f, 0.04278632f, 0.12705663f, 
    0.05290708f, -0.05719110f, 0.04978734f, -0.01267653f, -0.13686843f, 0.03800923f, -0.15001704f, 0.06006446f, 
    0.08166061f, 0.02617300f, -0.04160556f, 0.02914710f, 0.10080165f, -0.25767154f, 0.01749900f, -0.21403462f, 
    0.12963799f, 0.03881162f, -0.14659764f, 0.09809612f, -0.08290569f, -0.01037027f, 0.29392654f, 0.14616558f, 
    -0.14557232f, -0.12427766f, -0.03410882f, 0.03577824f, 0.02306510f, 0.17394759f, 0.12534378f, 0.10817078f, 
    0.16245893f, 0.11274280f, -0.20228168f, -0.03303134f, -0.04054430f, -0.01181229f, -0.04688145f, 0.03418278f, 
    0.02090235f, 0.05021738f, 0.04772668f, -0.17255780f, 0.05038290f, 0.18061669f, 0.04626026f, 0.03600109f, 
    -0.05826668f, 0.00718758f, -0.14647064f, -0.07407261f, -0.28295231f, -0.07214823f, -0.01353204f, 0.15518525f, 
    0.10324232f, -0.02106559f, -0.14295895f, 0.34843218f, 0.18131851f, 0.14252597f, 0.15168153f, -0.04463500f, 
    -0.04967306f, -0.06823062f, 0.07811675f, -0.05606800f, -0.04622182f, 0.01807431f, 0.09086269f, 0.00133193f, 
    0.02713435f, -0.00706408f, -0.01624140f, -0.00987408f, -0.09104220f, 0.01609526f, -0.11606370f, 0.04116476f, 
    0.07766959f, 0.03851344f, -0.04091494f, 0.04157448f, -0.03570647f, 0.05246412f, 0.10740174f, 0.14747179f, 
    0.02448660f, -0.02812983f, -0.14397958f, 0.21667357f, 0.15990616f, -0.05614855f, 0.02455747f, -0.09926733f, 
    0.15841107f, 0.10081499f, 0.05611170f, 0.17921913f, 0.02825421f, -0.19115765f, 0.00124127f, 0.02429465f, 
    -0.06704279f, 0.12589315f, -0.01112789f, 0.11371119f, -0.04503034f, 0.00824786f, -0.02183303f, 0.02971691f, 
    -0.30414698f, 0.00154349f, 0.00800137f, 0.16983429f, -0.10161537f, -0.10375847f, -0.09947836f, 0.13446139f, 
    0.05722783f, -0.06057662f, -0.17512140f, 0.14323507f, -0.24361338f, -0.06684452f, -0.02362186f, 0.00671707f, 
    -0.05647647f, -0.02392646f, 0.24662784f, 0.31797224f, 0.16476707f, -0.10978591f, -0.02232671f, -0.20738326f, 
    -0.01823389f, 0.05146205f, 0.19154017f, 0.10675802f, -0.03897745f, 0.13136484f, -0.02283049f, -0.11927834f, 
    -0.13288707f, -0.10099567f, 0.22538553f, 0.00606436f, -0.02179679f, -0.11889529f, -0.39261746f, 0.09920826f, 
    -0.10173662f, 0.13754541f, 0.01196092f, 0.11739126f, 0.01423514f, 0.07021135f, -0.22829852f, -0.28011164f, 
    0.04903246f, 0.17434290f, -0.02760932f, -0.03509354f, -0.09827552f, -0.16296425f, -0.03833209f, -0.23726261f, 
    -0.37380475f, -0.07725920f, 0.02338120f, 0.01314017f, 0.04910458f, -0.14013743f, -0.13404588f, -0.08679195f, 
    -0.09529161f, -0.01244567f, 0.10207189f, 0.11151363f, 0.09195392f, -0.00950032f, -0.17568959f, 0.16379021f, 
    -0.06278203f, 0.02151832f, -0.07391039f, 0.02296001f, -0.07133853f, 0.00099497f, -0.06273715f, -0.00775081f, 
    0.05995517f, -0.07933699f, 0.00364594f, -0.03350966f, -0.07796308f, -0.01912414f, -0.01718745f, -0.09314413f, 
    -0.03707818f, -0.00057121f, -0.04080566f, -0.08895999f, -0.10720318f, -0.04070188f, 0.00277816f, -0.00637321f, 
    0.07093012f, -0.07816499f, 0.03225287f, 0.04992484f, 0.02727802f, -0.03320953f, 0.02582812f, -0.01807311f, 
    0.04190502f, 0.06678887f, 0.02675225f, -0.07326735f, -0.02287390f, 0.00022279f, -0.09351353f, 0.00171076f, 
    0.02523809f, -0.03820911f, 0.04495962f, -0.08793579f, 0.05266248f, -0.01997295f, 0.01338982f, -0.05160725f, 
    -0.04284383f, -0.00899340f, -0.08972939f, 0.01864336f, 0.06533185f, 0.02537533f, -0.05427265f, -0.04513485f, 
    -0.00299395f, 0.04408033f, -0.01706698f, -0.10200129f, -0.01569565f, 0.07780860f, 0.00992946f, 0.00798274f, 
    -0.08430146f, -0.05820084f, -0.10337057f, 0.03083649f, 0.01252409f, 0.02547854f, 0.05983759f, -0.05474169f, 
    -0.01511900f, -0.06333297f, -0.05770335f, -0.10925882f, 0.03376039f, -0.08642401f, -0.06331278f, -0.00696489f, 
    -0.02191705f, -0.05349001f, -0.01797961f, -0.02063147f, 0.06971814f, 0.05460325f, -0.07857312f, -0.05287742f, 
    0.00726430f, -0.04893850f, -0.04371463f, -0.07373278f, 0.04138866f, 0.01401509f, -0.06645797f, -0.01627695f, 
    -0.10548035f, 0.05056476f, -0.08069649f, -0.08840684f, -0.04492592f, 0.02247354f, -0.01992354f, -0.00705132f, 
    -0.10114385f, 0.02504109f, 0.04120335f, -0.05145646f, -0.02966229f, 0.02811232f, -0.05495454f, -0.03048634f, 
    0.05603571f, -0.10154029f, 0.07544015f, -0.05595504f, -0.03112803f, 0.09927952f, -0.06785157f, 0.06102377f, 
    0.00341777f, -0.02761055f, -0.05600054f, -0.06722878f, 0.02990923f, 0.00904610f, 0.10799727f, -0.00371991f, 
    0.06328507f, 0.05958663f, -0.10019148f, -0.00332522f, 0.04431765f, -0.04932259f, -0.00512912f, -0.04186818f, 
    0.04794012f, 0.00434955f, -0.03140471f, -0.06086846f, -0.00353495f, 0.02006793f, 0.04918676f, 0.00989721f, 
    0.01131453f, -0.08519936f, 0.00074690f, 0.00652718f, -0.08070037f, -0.02837111f, -0.04174424f, 0.04407220f, 
    0.05207838f, 0.02469230f, -0.00130419f, -0.00399062f, 0.03464708f, -0.04665410f, -0.04341388f, 0.00633897f, 
    -0.06858308f, -0.06503289f, -0.03251376f, 0.04799915f, -0.08522941f, 0.00685031f, -0.07841071f, 0.05781844f, 
    0.05612654f, -0.07048423f, 0.04586658f, -0.06995475f, -0.01845847f, -0.02629943f, 0.00833728f, -0.09276585f, 
    0.06932669f, 0.02838527f, 0.01814630f, -0.07106265f, -0.05313585f, -0.04033386f, 0.00087248f, 0.02907350f, 
    -0.04211221f, 0.03409053f, 0.00026651f, -0.00146155f, 0.04311283f, -0.09212197f, 0.03987690f, 0.01837081f, 
    -0.10450435f, 0.06521607f, 0.03648616f, 0.02784632f, -0.00429814f, 0.05655050f, -0.09344377f, -0.00861581f, 
    -0.01770515f, -0.00704659f, -0.08472961f, 0.04573215f, 0.01477476f, 0.03334912f, -0.09467010f, -0.01172459f, 
    -0.00168501f, -0.06135236f, 0.00896570f, -0.07767293f, -0.01134545f, 0.05928255f, -0.02148898f, -0.06235893f, 
    0.06044655f, -0.06186678f, 0.00004069f, 0.04059192f, -0.00245036f, 0.02211093f, 0.00079481f, 0.05637607f, 
    -0.07639460f, 0.06449891f, -0.02050193f, 0.05565527f, 0.01430095f, -0.06537379f, -0.01302976f, -0.08197166f, 
    -0.07600199f, -0.03161010f, -0.01194644f, -0.03364491f, -0.04677133f, -0.03480564f, -0.02908024f, -0.04140197f, 
    -0.07676512f, -0.03696309f, 0.04830474f, -0.05508166f, -0.02828543f, 0.01967105f, 0.01675257f, 0.01916156f, 
    -0.02906769f, -0.01709225f, -0.09494790f, -0.01243757f, 0.05056723f, -0.03546696f, -0.02579743f, -0.08377948f, 
    -0.02100238f, -0.06714340f, 0.05204670f, 0.00633236f, 0.05733867f, 0.01185182f, -0.01442626f, -0.05826100f, 
    -0.03062156f, 0.04805858f, -0.08017783f, -0.09274853f, -0.00404143f, 0.05554133f, 0.02817075f, 0.01953004f, 
    -0.02149165f, -0.04430592f, -0.06895807f, 0.04508312f, -0.02864130f, -0.08211405f, -0.07221629f, -0.00110617f, 
    -0.03228039f, -0.03646503f, -0.04227247f, -0.02872703f, -0.07685211f, -0.01245026f, -0.02246582f, -0.07576638f, 
    -0.07024280f, -0.08391633f, 0.12251941f, -0.04497465f, 0.00725185f, 0.06773964f, -0.39776760f, -0.08906662f, 
    -0.17586575f, 0.32045686f, 0.10870047f, -0.13599776f, 0.14359494f, 0.03821675f, 0.07217975f, 0.07555464f, 
    0.02761107f, -0.27022377f, 0.19545637f, 0.00537396f, -0.06856105f, 0.06518061f, -0.04341045f, -0.08134445f, 
    0.04288297f, -0.04604363f, -0.16169782f, -0.04074060f, -0.15743023f, 0.26663780f, -0.05823234f, 0.04595594f, 
    -0.02571228f, -0.18686467f, 0.01087621f, -0.04708336f, 0.14307334f, 0.08909825f, -0.07461166f, 0.01510741f, 
    0.11822111f, -0.07365528f, -0.00475205f, 0.08216474f, -0.19140066f, -0.17768727f, 0.10625939f, -0.01102469f, 
    -0.12727694f, 0.06839132f, -0.27734208f, 0.07856942f, -0.06137312f, -0.02272095f, 0.03872560f, 0.04504852f, 
    0.13004650f, -0.12547466f, -0.02073527f, -0.02935955f, -0.07442911f, -0.15836288f, 0.15143530f, -0.02570374f, 
    -0.01177591f, 0.05967287f, -0.03758826f, -0.00126568f, 0.17837293f, 0.14715953f, -0.07305413f, 0.19833738f, 
    -0.14138679f, 0.12615326f, 0.12789418f, -0.03853844f, -0.12372737f, 0.06157417f, -0.08876076f, -0.02949634f, 
    0.12655582f, 0.08427351f, -0.21191286f, -0.02645337f, 0.09201846f, 0.18501474f, -0.05317153f, 0.14481011f, 
    -0.04500784f, -0.08541312f, 0.31003931f, 0.06551786f, -0.14044130f, 0.03767436f, -0.05594183f, 0.02753983f, 
    -0.02017282f, 0.06067977f, 0.17563561f, 0.25749233f, 0.14991841f, -0.01723593f, -0.01384047f, -0.09428175f, 
    0.09913889f, 0.16720220f, 0.11268889f, 0.03218512f, -0.16801891f, -0.17965484f, -0.04057655f, -0.16755280f, 
    0.06679281f, 0.10051000f, 0.06294844f, 0.25539550f, -0.29047450f, 0.00425083f, 0.01196306f, -0.29727226f, 
    -0.14283289f, -0.03480998f, 0.02451044f, -0.19121458f, -0.07787929f, -0.33212548f, 0.01304187f, 0.11735287f, 
    0.07185569f, 0.12419686f, -0.06346983f, -0.00327089f, -0.07528909f, 0.12851085f, -0.13845800f, 0.15160471f, 
    -0.07492599f, 0.03162868f, -0.13041382f, -0.01774762f, -0.09495864f, 0.05963381f, 0.00321158f, 0.16873270f, 
    -0.35428762f, -0.12898313f, -0.00464709f, -0.06827420f, 0.05313948f, 0.13966078f, 0.03720562f, -0.08142264f, 
    -0.05007100f, -0.68780690f, 0.15248998f, -0.04680924f, 0.12728117f, 0.18675616f, -0.07457882f, -0.07965253f, 
    -0.09760991f, -0.09399966f, -0.02504888f, 0.09212461f, -0.09944378f, 0.02416252f, 0.05868239f, 0.05695556f, 
    0.00903038f, 0.10090283f, 0.04479834f, -0.01050745f, -0.09318376f, 0.19391382f, -0.05272037f, -0.00959136f, 
    -0.15276647f, -0.07261230f, 0.00008258f, 0.10368613f, 0.27907133f, 0.18293191f, -0.05146097f, 0.09031771f, 
    -0.04631964f, -0.00482723f, -0.03557293f, -0.05691873f, 0.00879759f, 0.09651573f, -0.33113340f, 0.07203305f, 
    0.04736018f, 0.03114147f, 0.13647832f, 0.07576384f, 0.06227818f, -0.09618360f, 0.20620690f, 0.11820750f, 
    -0.12632741f, -0.01177720f, 0.03555540f, 0.03773798f, 0.02081011f, 0.05827797f, 0.03987783f, 0.24391752f, 
    -0.14575249f, 0.02284875f, 0.03973800f, 0.05059666f, 0.00859006f, 0.09356799f, 0.02542049f, -0.14532074f, 
    -0.01210596f, -0.41272065f, -0.00975310f, -0.08096155f, 0.12481396f, 0.11854247f, 0.05015505f, 0.06943294f, 
    -0.04789132f, 0.00049892f, -0.09799179f, -0.18393709f, -0.00719572f, -0.23000030f, 0.07255092f, -0.06969207f, 
    -0.08427680f, 0.05612020f, 0.00775541f, -0.24859944f, -0.38811895f, 0.06310737f, 0.13905430f, 0.01653224f, 
    0.00668555f, 0.01954835f, -0.14871950f, 0.01804492f, -0.31730914f, 0.10730467f, -0.01242590f, 0.09375805f, 
    -0.00810859f, -0.14051250f, 0.00181558f, -0.04036070f, 0.10007055f, 0.08578892f, 0.14985175f, -0.08717503f, 
    -0.01643927f, -0.17292729f, 0.06623764f, 0.05083714f, 0.20003235f, -0.00200804f, -0.12591179f, 0.21910100f, 
    -0.10977593f, 0.04289785f, -0.10154334f, -0.01116513f, -0.00363325f, 0.08495148f, 0.05040385f, -0.07653939f, 
    0.12042261f, -0.04446946f, -0.04140921f, -0.22126597f, 0.08049823f, -0.04259090f, -0.07113274f, 0.28294843f, 
    0.25257632f, -0.00718094f, 0.13315223f, -0.04191119f, -0.06426399f, 0.00664155f, 0.14406608f, 0.15441528f, 
    -0.52000582f, -0.25975722f, -0.32462734f, 0.01688777f, -0.00620572f, -0.03360173f, 0.03358468f, 0.04646645f, 
    -0.00193408f, 0.14355941f, -0.34242749f, -0.14068989f, 0.00041183f, -0.02091063f, 0.04921056f, -0.06839052f, 
    0.04218638f, -0.02133337f, 0.13721496f, 0.19916767f, 0.16797529f, -0.13750796f, -0.07325207f, 0.04260714f, 
    0.02183673f, 0.06546225f, 0.10587890f, 0.00680200f, -0.00171664f, 0.25612462f, -0.02066281f, 0.13547786f, 
    -0.00984068f, 0.09720319f, 0.07113787f, -0.00801257f, 0.06112831f, -0.02189683f, -0.22791712f, -0.05365084f, 
    0.11936929f, -0.12892452f, 0.02418106f, -0.01787148f, -0.03628764f, -0.23203589f, -0.04016180f, 0.10637835f, 
    0.07386255f, 0.13283828f, -0.08150681f, 0.09782233f, -0.01302729f, -0.21152744f, 0.23806977f, 0.17771444f, 
    -0.22769123f, -0.08957732f, -0.16280055f, 0.13103974f, 0.02627977f, -0.02769269f, -0.05994574f, 0.14334446f, 
    0.21586986f, -0.08101740f, 0.09691904f, -0.02047796f, 0.04744089f, 0.02393913f, 0.08155340f, -0.07097968f, 
    -0.27373031f, -0.20822699f, -0.28930366f, 0.03323274f, 0.12855573f, 0.13623722f, -0.08044022f, -0.02591051f, 
    -0.07902534f, 0.02662279f, 0.15252009f, 0.15337412f, -0.20310631f, -0.17483601f, -0.02126650f, -0.24162149f, 
    -0.11942390f, 0.17685941f, 0.07659399f, -0.23397084f, 0.09228577f, 0.03839348f, 0.05629740f, -0.03756868f, 
    -0.02659659f, 0.03365471f, -0.09504919f, -0.07897712f, -0.04629066f, 0.24613152f, 0.05015614f, -0.07813678f, 
    0.11052443f, -0.01227949f, 0.13095957f, 0.18090433f, 0.33327040f, -0.06895459f, -0.05611517f, -0.03643222f, 
    0.05800203f, -0.14147304f, 0.15540497f, 0.10732880f, 0.07342689f, -0.02660108f, -0.09649643f, 0.14987841f, 
    -0.02558308f, 0.08380335f, 0.00668023f, 0.03383110f, -0.11318475f, -0.07779647f, 0.04130806f, -0.19302747f, 
    -0.08891386f, 0.08010105f, 0.09981179f, -0.08221222f, 0.03049756f, -0.10981268f, -0.05056700f, 0.00817381f, 
    0.13319793f, -0.32177329f, 0.13875431f, 0.16814682f, 0.07464203f, 0.10627040f, 0.01553675f, -0.05953471f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.18815690f, -0.05071716f, -0.05287360f, 0.02492652f, -0.15710115f, 0.02985387f, 0.12696110f, 0.08586457f, 
    0.17078158f, 0.19384173f, 0.08134539f, -0.03501172f, -0.00373646f, 0.02953208f, -0.03627134f, 0.17652120f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.52463496f, -0.19224915f, 0.35726616f, -0.00944935f, -0.30287290f, -0.21404003f, -0.37598386f, -0.04105351f, 
    0.11136836f, 0.26194391f, -0.08148366f, 0.03144769f, -0.06017466f, 0.20543346f, 0.06096625f, -0.30547866f, 
    -0.07753411f, 0.33779803f, -0.05500825f, -0.24541727f, -0.36427477f, 0.06814034f, -0.12925467f, -0.34567654f, 
    0.29230830f, 0.01838793f, -0.11265130f, 0.08202431f, 0.23136322f, 0.12073846f, 0.27028215f, 0.07724533f, 
    0.40355775f, -0.20373695f, 0.06414525f, -0.13944611f, -0.05108665f, 0.45583433f, -0.11567788f, -0.27963501f, 
    -0.14871329f, 0.20349257f, -0.02921290f, -0.08589047f, -0.07344491f, -0.12509744f, 0.21198280f, 0.18450567f, 
    0.29690319f, 0.05158902f, 0.10863995f, 0.05134938f, 0.05874675f, -0.22055942f, -0.01731028f, 0.08544961f, 
    0.15765619f, 0.04382950f, -0.03319685f, 0.10128688f, -0.15888584f, 0.23565885f, -0.36955005f, -0.03750334f, 
    -0.12075699f, -0.31993300f, -0.24656379f, -0.09407648f, -0.10569006f, -0.35664928f, 0.13669184f, -0.11617450f, 
    -0.15138772f, 0.01271648f, 0.16918308f, -0.09898748f, 0.05706246f, 0.04150835f, 0.36568111f, 0.17756669f, 
    -0.05768647f, -0.04713824f, -0.08400790f, 0.18810824f, -0.15145886f, 0.17064165f, -0.23162203f, 0.20699447f, 
    0.08569013f, -0.12506764f, 0.25374612f, 0.26281643f, -0.17850932f, -0.10199591f, 0.09502897f, 0.34727609f, 
    0.50864124f, -0.33072713f, 0.20776179f, 0.21952297f, -0.13371949f, -0.17493337f, -0.25297827f, -0.33558801f, 
    0.04047973f, 0.01865516f, 0.35779774f, -0.19242889f, 0.12862729f, -0.15868382f, -0.09441518f, 0.30552140f, 
    0.12342475f, 0.30733460f, 0.15754859f, -0.14292496f, 0.08272480f, 0.00923226f, 0.08110521f, -0.42039716f, 
    0.08794724f, 0.35255942f, 0.22399996f, 0.22187683f, -0.11281198f, 0.07606404f, -0.05716908f, -0.02042440f, 
    0.06461121f, 0.39403892f, 0.11155824f, 0.07552823f, -0.05156711f, -0.36212969f, -0.30821830f, 0.23521391f, 
    0.18179341f, 0.35475546f, 0.25466296f, -0.03675458f, -0.21391124f, -0.06481913f, -0.01473764f, -0.34311855f, 
    0.21969597f, 0.17834964f, 0.20061266f, 0.14694545f, -0.32313007f, 0.27532262f, -0.25799775f, 0.09134514f, 
    0.28580847f, -0.05747996f, 0.16296080f, -0.20986098f, 0.09165704f, -0.23286125f, 0.17940398f, 0.12236018f, 
    -0.02767463f, -0.02149192f, -0.20404083f, 0.11748444f, -0.20094271f, 0.15663764f, -0.23539466f, -0.20809373f, 
    -0.15649487f, -0.15983029f, 0.11717460f, 0.03654817f, -0.02158728f, -0.12514322f, 0.11254418f, -0.05995210f, 
    -0.14653806f, -0.02967792f, 0.31627670f, -0.14387056f, 0.15626474f, 0.20893775f, 0.19710383f, -0.17764838f, 
    0.28257662f, 0.33475617f, -0.33347765f, 0.18165167f, 0.22385730f, -0.12342735f, 0.25624588f, -0.17403880f, 
    -0.24024019f, 0.17749850f, -0.02624525f, 0.01816745f, 0.44015834f, -0.17992312f, -0.07356249f, 0.09602661f, 
    -0.28649703f, 0.01476856f, 0.48138201f, -0.12111764f, -0.16134320f, 0.16571403f, -0.05161946f, 0.11807142f, 
    -0.32266262f, 0.42443162f, 0.30213937f, 0.17388354f, -0.46037167f, -0.46533582f, 0.16844212f, 0.30690461f, 
    0.08089190f, 0.03027650f, 0.14299984f, 0.09054403f, -0.07344182f, 0.22286598f, 0.18585576f, -0.13166848f, 
    -0.27055138f, -0.14323604f, -0.02663261f, -0.07033928f, -0.18555601f, 0.26194695f, -0.15801841f, 0.12656513f, 
    -0.19679913f, -0.09433556f, -0.09400675f, 0.09888563f, 0.08837061f, 0.38662326f, 0.30947271f, 0.37737811f, 
    -0.00792613f, -0.18753387f, -0.06779245f, -0.16000323f, 0.35835993f, 0.08804616f, 0.23559925f, 0.27496681f, 
    -0.22232915f, 0.03449032f, 0.01298025f, -0.16884126f, -0.18490925f, 0.24228433f, 0.34658372f, -0.23726262f, 
    -0.09188028f, 0.25992119f, 0.20902513f, 0.00517462f, -0.38002247f, -0.23612636f, -0.11673342f, 0.52274704f, 
    -0.08484694f, -0.30428386f, -0.03727251f, 0.07310937f, 0.23715074f, 0.25012386f, 0.37851706f, -0.14238712f, 
    0.20849705f, -0.69095415f, 0.21454599f, -0.24507153f, -0.00988533f, -0.37254328f, -0.11157481f, -0.81008714f, 
    0.16940124f, 0.27040458f, -0.11053888f, 0.13109222f, 0.21038994f, 0.14011529f, -0.95774359f, -0.32542181f, 
    0.12319140f, -0.29796302f, -0.08441850f, -0.01764259f, -0.10134793f, -0.03035975f, 0.11180943f, 0.00995049f, 
    0.29110330f, 0.12981503f, -0.10625736f, -0.11545174f, 0.07988772f, -0.48078415f, 0.15609536f, 0.08815216f, 
    -0.33043665f, 0.06858157f, 0.42087495f, -0.18635966f, -0.24452786f, -0.12068986f, -0.13403913f, 0.17428735f, 
    0.23977411f, 0.32684714f, -0.02185615f, -0.21762596f, -0.11411331f, 0.12351576f, 0.15825161f, -0.07546523f, 
    -0.13529594f, -0.32675156f, 0.32164258f, -0.09469357f, -0.30622718f, 0.55714077f, 0.23976047f, -0.16743678f, 
    -0.08525350f, 0.25344005f, -0.06763639f, -0.02668689f, -0.16991901f, 0.17713545f, 0.32949495f, -0.11171371f, 
    0.21560231f, 0.18236420f, 0.16324447f, -0.17307925f, -0.19245490f, -0.05957802f, -0.18620056f, 0.29072246f, 
    -0.32896236f, 0.11289702f, -0.08674537f, -0.16972631f, 0.16995808f, -0.25202113f, -0.54294491f, 0.48561704f, 
    0.04752691f, -0.30712107f, 0.22855988f, -0.10906354f, 0.06052818f, 0.00672576f, 0.14412227f, -0.06366175f, 
    0.28424448f, 0.29024971f, -0.36130342f, 0.07840675f, -0.03014572f, 0.06496257f, 0.16918646f, -0.23772617f, 
    -0.34989059f, -0.66871321f, 0.21687752f, 0.03186407f, 0.09546294f, -0.33018929f, 0.07816947f, 0.34918720f, 
    0.28819814f, 0.07860004f, 0.20017596f, 0.25449353f, 0.02279380f, -0.29286233f, -0.01235818f, -0.05594370f, 
    0.06345756f, -0.21682450f, 0.05369329f, 0.16633448f, -0.16615289f, -0.21195471f, -0.14008945f, -0.18558331f, 
    -0.25325227f, 0.10829050f, -0.14929700f, -0.12904331f, -0.23649514f, -0.24054834f, 0.18762392f, -0.14608330f, 
    0.01012264f, 0.48817748f, -0.30778748f, -0.04577478f, -0.09307336f, -0.37478411f, 0.24251400f, 0.30329883f, 
    -0.24277255f, 0.26412004f, 0.18309717f, -0.18700020f, -0.19077206f, 0.02051241f, 0.00954231f, -0.07311253f, 
    0.35957089f, -0.21687941f, -0.16181028f, 0.19549759f, -0.08412820f, -0.02195627f, -0.07049906f, 0.30607909f, 
    0.11079978f, 0.22540233f, 0.46546808f, -0.02632532f, -0.23130211f, 0.02435712f, -0.40272829f, -0.39971989f, 
    -0.03324185f, -0.00495856f, 0.25345743f, 0.08864236f, -0.04253670f, -0.20718804f, -0.32942080f, -0.36476144f, 
    0.18946820f, -0.48189723f, -0.14240628f, -0.00002582f, -0.17095709f, 0.31345701f, -0.23134191f, 0.35548759f, 
    -0.03933259f, 0.12400818f, 0.57779473f, 0.11944234f, 0.39446300f, 0.03128830f, 0.18103990f, -0.00528676f, 
    0.02438944f, -0.21334551f, -0.29198712f, -0.17949092f, 0.22517678f, -0.00020379f, -0.27442712f, 0.05468022f, 
    -0.19482879f, -0.68564051f, -0.34900552f, 0.17561480f, -0.33423218f, 0.11627404f, -0.21015307f, 0.18720989f, 
    0.37303630f, -0.06666238f, 0.17075109f, 0.02038080f, 0.13462435f, 0.30187398f, -0.02342108f, 0.08847863f, 
    0.18751307f, -0.39373383f, -0.13266410f, -0.13770130f, -0.25000897f, -0.13508935f, -0.31508830f, 0.29286298f, 
    0.09438571f, -0.21291426f, 0.16040079f, 0.13902558f, 0.05428655f, 0.10271743f, -0.24483997f, 0.46695569f, 
    -0.05611290f, -0.24316522f, -0.14615561f, 0.06147339f, -0.54986727f, 0.46715873f, 0.34635738f, 0.16247049f, 
    0.35157645f, 0.00126631f, -0.22503926f, 0.09915723f, 0.16682123f, -0.06947876f, 0.35400444f, -0.08792771f, 
    -0.15949795f, 0.20474079f, 0.57438833f, -0.12823585f, 0.14906915f, 0.25684223f, -0.15453155f, 0.33328232f, 
    0.26174015f, -0.10083948f, -0.30013591f, 0.12507972f, -0.13991188f, 0.12562805f, -0.30133951f, -0.08018455f, 
    -0.24493870f, -0.13618380f, 0.01008547f, -0.16598985f, -0.24314511f, 0.16999559f, -0.20097570f, -0.35925302f, 
    0.25607625f, -0.12036399f, -0.16155154f, -0.05703317f, 0.20133980f, 0.36143711f, 0.18731847f, 0.28611395f, 
    -0.11170961f, 0.23174927f, 0.09925151f, -0.12605441f, -0.24771912f, -0.24502978f, 0.35321048f, 0.25036427f, 
    -0.00146905f, 0.43931073f, -0.15296334f, -0.12462918f, -0.18051726f, 0.14564437f, -0.09982719f, -0.40840307f, 
    -0.24593857f, 0.39140069f, 0.31149420f, -0.25269353f, 0.02856623f, -0.31234837f, 0.34819654f, -0.09820145f, 
    0.10884524f, 0.34098634f, -0.31566837f, 0.14964059f, 0.03408817f, -0.00091167f, 0.26008540f, -0.26396707f, 
    -0.01577478f, 0.21491268f, 0.07371830f, 0.16711192f, 0.08510399f, -0.25408462f, -0.23643051f, 0.29776534f, 
    0.31754571f, -0.10136029f, 0.04332341f, -0.10061968f, -0.13445064f, -0.11525644f, -0.57692212f, 0.20336527f, 
    0.05149987f, 0.01837030f, 0.29563117f, -0.05268825f, -0.20420122f, 0.26616704f, -0.05590008f, 0.16769359f, 
    -0.02888284f, 0.26510036f, 0.30915439f, -0.03342721f, 0.04461646f, 0.30411902f, 0.00999449f, -0.23588595f, 
    0.40170866f, 0.21073389f, -0.12289995f, 0.16636519f, -0.03636843f, -0.34338859f, -0.12801379f, 0.16155358f, 
    -0.03930348f, 0.26037878f, -0.02795562f, -0.09893299f, -0.01822306f, 0.03701486f, -0.42187983f, 0.21613108f, 
    0.02208047f, -0.42413813f, 0.10200395f, -0.10528724f, -0.16987343f, 0.22008336f, -0.05122977f, -0.04672289f, 
    0.18483756f, -0.44474757f, -0.11751676f, -0.14896445f, 0.10276973f, 0.25511679f, 0.03873135f, 0.39688995f, 
    0.17605908f, 0.40663970f, -0.20980017f, 0.10663300f, -0.27100989f, -0.44298232f, -0.13931745f, -0.38000247f, 
    -0.15377782f, 0.25068173f, 0.30947912f, -0.17310068f, 0.15251406f, 0.25667015f, 0.26755887f, 0.07973739f, 
    0.01082203f, 0.16454101f, -0.46355370f, 0.12758450f, 0.47980532f, 0.10382247f, -0.19888072f, 0.19699886f, 
    -0.08116861f, -0.15612635f, 0.02599084f, 0.05410551f, -0.13683344f, 0.28748217f, -0.41424483f, 0.15900017f, 
    0.04534438f, -0.05404327f, -0.18770152f, 0.10077815f, -0.45078212f, 0.04083135f, -0.21795115f, 0.17569049f, 
    0.54910606f, -0.16602615f, 0.27274078f, -0.18092066f, 0.16533065f, -0.03442393f, -0.02312717f, -0.00192072f, 
    -0.14179033f, 0.33679503f, 0.11521401f, 0.05849036f, -0.01147255f, -0.49981132f, -0.21412982f, 0.26631182f, 
    0.02172560f, -0.34739366f, 0.16925439f, 0.14907160f, 0.10626341f, 0.36228901f, -0.36026165f, 0.02766529f, 
    0.01999498f, 0.40059856f, 0.10515542f, 0.01631266f, 0.18371940f, 0.30260184f, 0.43213633f, -0.18687384f, 
    -0.03526620f, -0.03915751f, 0.15980159f, -0.07791340f, 0.01566830f, -0.57317591f, 0.41382727f, -0.41525042f, 
    0.39311326f, 0.43858001f, -0.02789735f, 0.21170032f, -0.23698665f, -0.09171118f, -0.11641227f, -0.18070236f, 
    -0.39439762f, -0.13034298f, -0.25282255f, -0.12373773f, -0.16847886f, 0.18726744f, 0.50160760f, 0.13485645f, 
    -0.29337490f, 0.42406437f, -0.01309764f, -0.04890418f, 0.08254740f, -0.68022239f, -0.05126116f, 0.18113515f, 
    -0.07019687f, -0.05643684f, -0.03036273f, 0.20072924f, 0.11200398f, 0.36784452f, 0.02360751f, -0.00149054f, 
    -0.18908237f, -0.32474211f, 0.35289839f, -0.00836067f, -0.09015315f, 0.32940447f, 0.03610288f, 0.25250119f, 
    -0.29095596f, 0.38948491f, 0.01785981f, 0.15936419f, 0.04191669f, -0.00701987f, 0.26534170f, -0.17204194f, 
    -0.26102278f, 0.52655643f, 0.01465587f, -0.05566245f, -0.35380697f, -0.25994349f, -0.01357618f, 0.14631817f, 
    0.32689148f, 0.29417232f, 0.29841578f, 0.17493752f, -0.07317030f, 0.41802949f, 0.01274271f, -0.08774491f, 
    -0.07794246f, -0.00916279f, -0.11694491f, 0.15849066f, -0.20547245f, 0.24947886f, 0.13080259f, 0.05648885f, 
    -0.40550244f, 0.43002200f, -0.04305860f, -0.09546509f, -0.23062618f, 0.04977167f, -0.16674310f, 0.16685051f, 
    0.03712430f, -0.13531372f, -0.24233669f, -0.04981548f, 0.01559342f, -0.08978426f, 0.02621779f, -0.11872699f, 
    -0.28055647f, -0.22140861f, -0.24960911f, -0.07041293f, 0.14418298f, -0.12473339f, 0.07514222f, -0.14583014f, 
    0.43950111f, 0.17747787f, -0.08318049f, -0.07962649f, 0.04664447f, -0.20868282f, 0.27205610f, -0.12028503f, 
    -0.27056986f, 0.21273699f, 0.04992502f, 0.17848769f, -0.21838500f, 0.30625701f, -0.38966146f, 0.03489197f, 
    0.23522668f, -0.30070892f, -0.13680643f, 0.23057301f, -0.38584268f, 0.34673116f, 0.31346646f, 0.10605428f, 
    0.38234261f, 0.25833628f, -0.32914212f, 0.15839726f, 0.14878081f, -0.31741837f, -0.09514159f, 0.11619885f, 
    -0.15415360f, 0.38429907f, 0.35303783f, 0.01392760f, -0.22863565f, -0.24023688f, 0.06299987f, 0.42325935f, 
    0.09962334f, 0.21931398f, 0.12467162f, 0.03356506f, -0.20256716f, 0.02315560f, -0.01765225f, -0.19438301f, 
    -0.32304490f, -0.22693379f, 0.14682995f, -0.19845805f, -0.06658939f, -0.38251978f, 0.21160889f, 0.47529826f, 
    -0.39688411f, 0.01714233f, 0.01557708f, -0.11603992f, 0.17272906f, -0.26954493f, 0.35563424f, 0.16896524f, 
    -0.52957785f, -0.46000537f, 0.44879183f, 0.21093281f, 0.15695377f, 0.03518209f, 0.47507170f, -0.02117561f, 
    -0.12987970f, -0.23402494f, -0.03553103f, 0.11214330f, -0.11915927f, 0.18686423f, 0.33026680f, -0.10438683f, 
    0.45538697f, -0.29889533f, 0.08758271f, 0.15328376f, 0.11542949f, -0.18553180f, 0.06302623f, 0.39885610f, 
    -0.39639127f, -0.23198898f, 0.18805307f, -0.12711439f, 0.22553624f, 0.20145991f, -0.02326599f, -0.30035064f, 
    -0.27951142f, -0.01702963f, -0.37393311f, -0.07394715f, -0.09612124f, -0.00350666f, 0.12054566f, 0.37211215f, 
    -0.34250519f, 0.06960136f, -0.03687199f, 0.10083315f, 0.04747172f, 0.00767610f, 0.16024803f, 0.27181998f, 
    -0.18658645f, 0.32714912f, -0.07441302f, 0.01833032f, -0.07524012f, 0.28339913f, -0.23612551f, -0.22391096f, 
    -0.19160210f, 0.15943466f, -0.45473763f, -0.16083169f, 0.06226166f, 0.07528765f, 0.28545249f, 0.33159965f, 
    -0.11548459f, -0.21805891f, -0.18186983f, 0.08136381f, 0.20489612f, 0.05108805f, 0.08641970f, -0.03503373f, 
    -0.01199482f, 0.25872922f, -0.04591671f, 0.15233351f, 0.09832547f, 0.37682131f, -0.28348988f, 0.03963869f, 
    0.23992032f, 0.12142869f, 0.24153854f, -0.12698400f, 0.07293459f, -0.06317161f, 0.17599835f, -0.32890940f, 
    -0.08199801f, -0.05077680f, -0.00910758f, 0.00386081f, -0.14526144f, 0.09005845f, 0.44358441f, -0.01799076f, 
    -0.10520279f, -0.26695839f, -0.01908057f, -0.19675429f, 0.14496870f, -0.49950892f, 0.03640474f, 0.20352775f, 
    0.11480470f, 0.09344499f, 0.23439731f, 0.03325736f, 0.19214423f, 0.22439386f, -0.29887488f, 0.10352862f, 
    -0.24439640f, -0.14052691f, -0.25617728f, 0.06079437f, -0.16708091f, -0.04521012f, 0.16459225f, 0.19777118f, 
    0.11586484f, 0.39925736f, -0.30298793f, 0.11528320f, 0.20250468f, -0.32545632f, 0.17918353f, 0.18316518f, 
    0.39806989f, 0.06992092f, 0.10561167f, 0.16605128f, -0.17624430f, -0.34895483f, -0.10078005f, -0.17845079f, 
    0.09344763f, -0.26191029f, -0.15164143f, 0.09811956f, 0.21852900f, -0.22393680f, 0.25696605f, 0.28140101f, 
    0.34701514f, -0.37055573f, 0.20367391f, 0.11510277f, -0.25974214f, -0.56514412f, 0.10016603f, -0.22063567f, 
    0.22094156f, 0.13560763f, 0.15966478f, -0.00848369f, -0.11722878f, -0.40789315f, -0.02531173f, 0.24306197f, 
    0.07353409f, 0.19423781f, 0.42605147f, -0.23799680f, -0.00528048f, 0.51807332f, -0.04007778f, 0.23871841f, 
    0.00545452f, 0.11981918f, -0.31418639f, 0.10992492f, -0.07284070f, -0.04763757f, 0.13028346f, -0.11758134f, 
    -0.28936580f, 0.16476789f, 0.30410770f, -0.26000243f, -0.11884007f, 0.27991599f, 0.06425092f, 0.35419977f, 
    0.00299244f, -0.00336390f, -0.06339256f, -0.07270049f, 0.11248656f, 0.19932057f, 0.10831542f, -0.14352338f, 
    -0.21896023f, -0.26814616f, 0.03388882f, -0.07105823f, 0.15379497f, -0.07201069f, 0.14188080f, 0.17904548f, 
    -0.21198443f, 0.18576545f, 0.30157664f, -0.10386842f, 0.24592155f, 0.22575332f, -0.10180049f, -0.02787670f, 
    0.22338924f, 0.26797515f, 0.01450189f, 0.11261807f, -0.09791361f, 0.26653218f, -0.18434401f, 0.33745638f, 
    0.45775849f, 0.42267582f, -0.37229177f, 0.12163340f, -0.06617609f, -0.05773573f, -0.42138165f, -0.40205181f, 
    0.32887831f, 0.17374738f, -0.37079224f, -0.04800943f, 0.39454377f, 0.30024740f, -0.31709921f, 0.27480748f, 
    -0.19294056f, 0.34296918f, -0.00262768f, 0.23999390f, 0.10679784f, -0.09618507f, 0.20747358f, 0.02451631f, 
    0.01960627f, 0.02049119f, -0.12493751f, 0.24687162f, -0.16563103f, -0.08598593f, -0.04804470f, 0.10291237f, 
    -0.14454970f, 0.21774344f, -0.14449869f, -0.17066276f, -0.03530052f, -0.23109701f, -0.04714502f, -0.14993216f, 
    0.40106630f, -0.56338561f, -0.07782222f, 0.13502449f, -0.07923477f, 0.14315209f, 0.24991366f, -0.00105414f, 
    -0.01599976f, -0.06864563f, 0.41973197f, -0.03775525f, 0.05292388f, 0.12146562f, -0.13544543f, -0.35239521f, 
    0.13477366f, -0.19737899f, -0.15332112f, 0.01274903f, 0.10067828f, -0.21578826f, 0.05026532f, -0.07085836f, 
    0.11671728f, -0.01423969f, 0.21673004f, -0.05297094f, 0.15963359f, -0.22651403f, -0.16798952f, 0.19136669f, 
    -0.32532564f, -0.23566221f, 0.05843212f, -0.05768899f, 0.13631777f, 0.05408286f, 0.27445981f, 0.36424461f, 
    0.12811531f, -0.19183452f, 0.27861747f, -0.10921570f, 0.25396380f, 0.25427273f, 0.07957937f, -0.14588313f, 
    0.09696945f, 0.07803682f, -0.04733594f, -0.09740692f, 0.08471496f, -0.33191255f, 0.26008618f, -0.29669756f, 
    0.33654284f, 0.05812202f, 0.20639159f, -0.21878293f, -0.07516292f, 0.32805464f, -0.39324930f, -0.21594785f, 
    -0.15212809f, 0.05168254f, -0.26113746f, 0.05650252f, -0.33605444f, 0.37312546f, 0.09246986f, 0.33733478f, 
    -0.38521835f, 0.10397628f, 0.06504466f, 0.07075991f, 0.22575559f, -0.19565769f, 0.24750698f, 0.36718211f, 
    0.29621628f, 0.15219650f, -0.28202704f, 0.22438842f, -0.26510349f, -0.31963089f, -0.35650456f, 0.20682327f, 
    0.13587606f, 0.31633100f, 0.22131513f, -0.08328462f, -0.10744563f, 0.05479397f, -0.19246969f, 0.29887992f, 
    0.11887863f, 0.15458676f, 0.12171871f, 0.21531519f, -0.38546532f, -0.29321370f, 0.01629120f, 0.32317340f, 
    0.33169287f, 0.12469830f, 0.33435580f, -0.14113843f, -0.05042682f, -0.01569909f, -0.28990051f, -0.16895558f, 
    -0.24073920f, -0.10750558f, -0.11842717f, 0.17494759f, -0.30671710f, 0.48038781f, 0.56107754f, -0.07533128f, 
    0.27415517f, -0.18656440f, -0.28215483f, 0.25560951f, 0.15166280f, -0.20668624f, 0.34005055f, 0.05795103f, 
    -0.15443125f, 0.00753429f, 0.14197667f, 0.23531187f, -0.52276456f, 0.68535942f, -0.01303599f, -0.13357745f, 
    0.24413280f, -0.20562752f, -0.12407862f, 0.06089750f, -0.07309412f, 0.19973810f, -0.27339682f, 0.13321020f, 
    -0.35146832f, -0.15369095f, 0.17753050f, -0.05900010f, -0.22371784f, 0.01628440f, 0.44154960f, -0.50935441f, 
    0.10592765f, 0.02640063f, 0.41193774f, -0.13697749f, 0.12068243f, 0.10849798f, -0.02729548f, -0.02621322f, 
    -0.00711565f, -0.14172053f, -0.36566752f, 0.19161871f, -0.19352169f, -0.57892472f, 0.24084543f, 0.34258622f, 
    -0.18223903f, -0.12647343f, 0.19723700f, -0.15607096f, 0.14921992f, -0.33669978f, -0.08162415f, 0.39314005f, 
    -0.25001231f, 0.38368985f, 0.25577852f, 0.19275388f, -0.64369863f, 0.20623563f, -0.03855452f, 0.14402483f, 
    0.24544865f, 0.17853090f, -0.11716860f, -0.14160340f, -0.01356249f, 0.13204551f, 0.29470238f, -0.07988521f, 
    0.17487551f, -0.05743746f, -0.32179266f, -0.00443647f, 0.32752562f, 0.04177655f, -0.18670103f, 0.25821710f, 
    0.22937153f, 0.22998898f, -0.31985605f, -0.20199212f, -0.16255957f, 0.28816783f, 0.27879968f, -0.18718196f, 
    -0.18908475f, -0.48760396f, 0.19206053f, 0.08524752f, -0.05640800f, -0.16701597f, 0.03087779f, 0.11342974f, 
    -0.24150449f, 0.30976567f, 0.31679353f, 0.20630769f, -0.00440188f, -0.09275684f, 0.01055572f, 0.14948140f, 
    -0.30637196f, 0.67749935f, 0.31491458f, 0.20679478f, -0.01523469f, -0.37291008f, 0.19670436f, 0.21989200f, 
    0.04405248f, -0.38073081f, 0.12277651f, 0.19468693f, 0.20138389f, -0.21206743f, 0.10144415f, -0.04315811f, 
    0.35787916f, 0.65860444f, -0.23957621f, 0.17449576f, 0.23197475f, 0.06263731f, -0.35237324f, -0.11189647f, 
    -0.03803019f, -0.09651660f, 0.19751120f, 0.22418799f, -0.09885436f, 0.41445163f, 0.37229925f, -0.12340125f, 
    -0.31567928f, 0.12107828f, 0.17337443f, -0.05258552f, -0.11754365f, 0.08145928f, 0.32808280f, 0.24471501f, 
    -0.51364094f, 0.07447245f, 0.29984882f, -0.20128770f, 0.16315134f, 0.34573057f, -0.01407085f, 0.25313878f, 
    0.34629869f, 0.03384691f, -0.03740606f, -0.12954445f, 0.08815117f, -0.13253482f, 0.21441159f, -0.14693618f, 
    0.28164193f, 0.31076035f, -0.35891828f, 0.03962244f, 0.03277206f, -0.39876908f, 0.22775820f, -0.01647918f, 
    0.13047674f, -0.03587206f, 0.29360190f, -0.20634827f, 0.12647271f, -0.05323844f, 0.33357731f, 0.17648378f, 
    -0.35081464f, -0.08655995f, 0.28253543f, 0.21275233f, -0.07229903f, 0.08191227f, -0.19419700f, 0.09536103f, 
    0.09481759f, -0.09646586f, -0.17903939f, 0.01975730f, 0.20842633f, 0.36360547f, -0.22652629f, -0.47863260f, 
    -0.39847678f, -0.16539036f, 0.14891684f, 0.20737815f, 0.12450644f, 0.27257246f, 0.22903492f, 0.40395430f, 
    0.42590481f, 0.23044725f, 0.12451848f, 0.22957051f, 0.48242617f, 0.06938936f, -0.13589665f, -0.22773361f, 
    -0.12295043f, 0.34138003f, 0.14896365f, -0.12767833f, 0.10188449f, -0.33206886f, 0.00365108f, -0.04596792f, 
    0.07345526f, -0.24061406f, 0.20485201f, 0.09501907f, 0.21874778f, 0.70839512f, -0.12661850f, -0.26606876f, 
    0.42326617f, 0.01391628f, 0.04578860f, -0.21935648f, 0.02088244f, 0.11092485f, 0.02753200f, 0.02552354f, 
    0.05942916f, -0.05349346f, 0.28383318f, 0.06160156f, 0.35949439f, -0.50064158f, 0.09653836f, 0.16252185f, 
    -0.16318259f, 0.10571786f, -0.05612382f, 0.11222969f, 0.02026027f, -0.10986745f, -0.16165093f, 0.13938397f, 
    0.01593183f, -0.12210464f, 0.02832203f, -0.19260705f, -0.22338659f, 0.11130596f, -0.09299649f, -0.05671078f, 
    -0.14837520f, 0.15321581f, -0.03433728f, 0.24190517f, -0.19780985f, -0.28899652f, 0.09277483f, -0.25284418f, 
    0.29919696f, -0.31939819f, -0.35016724f, -0.02859082f, 0.00947890f, 0.39215791f, 0.25322583f, -0.14498720f, 
    0.12358081f, -0.10103647f, -0.11042034f, -0.01148567f, -0.20362155f, -0.24734573f, 0.18769559f, 0.36853346f, 
    0.01070327f, -0.40803292f, 0.11551087f, 0.02176929f, -0.30389640f, -0.02225701f, 0.33329844f, 0.48680553f, 
    0.23808727f, -0.10496906f, -0.19657023f, -0.02427419f, 0.06274540f, -0.35644636f, 0.07113288f, 0.21367390f, 
    -0.15450269f, -0.47759098f, -0.25033069f, -0.23099214f, 0.33031148f, 0.15920097f, 0.05516676f, -0.60450345f, 
    0.07705372f, 0.17234568f, -0.37408793f, -0.07984194f, 0.05470339f, 0.35882273f, -0.08688776f, 0.20505366f, 
    0.08294941f, 0.34291980f, 0.03363400f, -0.16866082f, -0.10446364f, 0.23611835f, -0.31374624f, -0.09564456f, 
    -0.11461251f, -0.15041019f, 0.28272557f, -0.21140023f, 0.10485755f, 0.23882522f, 0.19848061f, 0.21082367f, 
    0.12066767f, -0.32802618f, 0.13533524f, 0.01454527f, -0.14586857f, 0.08963641f, 0.20366824f, 0.34341630f, 
    -0.48406124f, -0.40658358f, 0.03479162f, -0.00793391f, -0.24376908f, -0.14441520f, 0.20317942f, 0.27886137f, 
    0.17720050f, 0.44773632f, 0.01553009f, -0.03875541f, -0.14500442f, -0.24187145f, -0.40319130f, 0.10411529f, 
    0.36707476f, 0.10084525f, 0.32524657f, 0.17437829f, -0.06582383f, 0.20208992f, 0.15001038f, -0.19139875f, 
    0.01812673f, 0.11452933f, 0.14896074f, -0.21825896f, -0.14086658f, -0.35992202f, -0.15999803f, -0.21656677f, 
    0.02720330f, 0.48367462f, -0.42352962f, 0.12847726f, 0.10092745f, -0.28206694f, 0.38097820f, -0.01583945f, 
    0.51404113f, -0.13474014f, 0.15178014f, 0.20198883f, 0.12320779f, -0.12257060f, 0.41541111f, -0.18885812f, 
    -0.23540923f, -0.09734546f, -0.37917230f, 0.08767094f, 0.23675483f, 0.05343033f, -0.34464043f, 0.22817765f, 
    0.35605744f, -0.30086288f, -0.03968854f, 0.19288875f, -0.03606586f, -0.41460156f, -0.22434655f, 0.20962718f, 
    -0.15640141f, -0.25283298f, 0.26456699f, 0.11713048f, 0.07425590f, 0.06581703f, -0.19860604f, 0.29227689f, 
    0.38595012f, -0.24576572f, 0.02592410f, -0.12182338f, -0.03195120f, -0.34364906f, -0.18869174f, 0.27065966f, 
    -0.24452466f, 0.22019112f, 0.21148936f, -0.04486309f, -0.07381265f, 0.26402739f, -0.32685202f, 0.06792673f, 
    -0.03954079f, 0.20911233f, -0.03528151f, 0.12076584f, -0.24970756f, -0.26217043f, -0.19350615f, -0.44731331f, 
    0.22429568f, 0.05752450f, -0.20337574f, -0.00660795f, -0.12962002f, 0.25457111f, -0.17950201f, 0.40668306f, 
    -0.17464703f, -0.01582977f, -0.01513091f, -0.16744950f, -0.01859078f, 0.03527296f, -0.03900346f, -0.17748353f, 
    -0.21935174f, 0.09399804f, -0.22874412f, -0.14220917f, -0.18237421f, -0.22383651f, -0.12980542f, 0.12646458f, 
    -0.41823089f, -0.37652722f, 0.48864371f, 0.02108277f, -0.17516606f, -0.02955391f, 0.08144860f, -0.05545387f, 
    0.24201293f, 0.06301278f, 0.06907630f, 0.28392640f, 0.09792459f, -0.16723052f, 0.21927011f, 0.08802918f, 
    0.16223168f, -0.32541323f, 0.15895808f, 0.00796982f, -0.17412515f, 0.10942888f, -0.44898340f, -0.32016206f, 
    0.22245459f, -0.10906798f, 0.18648069f, -0.01628963f, -0.16431473f, 0.15312931f, 0.26371998f, 0.06471373f, 
    -0.26664099f, 0.07861313f, 0.19760807f, 0.22261202f, -0.22332312f, -0.34125367f, 0.15456398f, 0.12048934f, 
    0.22819588f, -0.19924594f, 0.32368582f, 0.09130895f, 0.18359682f, 0.01093654f, -0.23537248f, 0.10122035f, 
    0.02135508f, -0.28528088f, 0.16877761f, -0.21897571f, -0.11229109f, -0.12992324f, 0.20406179f, -0.10323963f, 
    -0.22012949f, -0.25795835f, -0.38313118f, -0.10478183f, -0.01680057f, -0.08617473f, 0.32230034f, 0.38093352f, 
    -0.14714195f, -0.49145868f, -0.41365820f, 0.08228420f, -0.14871591f, 0.23260695f, 0.10141213f, 0.23339328f, 
    0.20285879f, 0.05255810f, -0.23169602f, -0.05203454f, -0.01433774f, 0.07693210f, 0.35233009f, 0.09764302f, 
    -0.05009213f, -0.38550141f, -0.19730948f, -0.22092131f, 0.08849677f, -0.49479592f, 0.15626892f, 0.22027919f, 
    0.42389613f, -0.50561613f, 0.12636270f, 0.05645045f, 0.01801042f, -0.35783839f, 0.21834359f, -0.22338860f, 
    -0.03561952f, -0.10207589f, -0.00909447f, 0.06101245f, 0.10210932f, -0.14752993f, -0.02760426f, -0.16803478f, 
    0.02192285f, -0.21805124f, 0.17043243f, -0.18481150f, -0.10545996f, -0.06222873f, -0.16381215f, -0.15305862f, 
    0.14853980f, 0.35910490f, -0.05193391f, -0.16288579f, -0.07342809f, -0.51667237f, -0.09436033f, 0.28472286f, 
    -0.33648691f, -0.43183088f, 0.08807711f, -0.16263555f, -0.04369430f, 0.23857974f, 0.50443137f, 0.02191747f, 
    -0.33145162f, -0.17825402f, -0.35109183f, 0.22626084f, -0.24177949f, 0.34184819f, -0.13355368f, 0.13347697f, 
    0.13633519f, 0.34175131f, -0.04811981f, -0.18574263f, -0.25164118f, 0.15253505f, 0.35990569f, 0.05841320f, 
    0.15152664f, 0.08745350f, -0.00496444f, 0.00994497f, 0.30173552f, -0.06574502f, 0.01880602f, 0.12343932f, 
    -0.29629228f, 0.24647340f, 0.31332830f, 0.07381640f, 0.12197115f, 0.15295725f, -0.22457293f, 0.11281801f, 
    0.55472100f, -0.33255431f, -0.04542103f, 0.01466777f, 0.04641436f, 0.15506691f, 0.11017868f, -0.21562928f, 
    0.22584645f, 0.04745080f, -0.05301684f, 0.17124915f, -0.07618982f, 0.18191762f, -0.19593804f, -0.42215306f, 
    -0.15581813f, 0.42800117f, -0.13088587f, 0.14333896f, 0.30937031f, -0.08238203f, 0.03478628f, -0.09378953f, 
    0.08984763f, 0.52154529f, 0.29814821f, 0.07965323f, 0.20098673f, -0.21006750f, 0.28982651f, -0.25262070f, 
    0.33453679f, -0.24612607f, 0.14999992f, 0.20632990f, -0.02975004f, -0.38982350f, -0.11107341f, 0.30853570f, 
    0.25187421f, -0.01226437f, 0.15857990f, -0.05663572f, -0.07503873f, -0.25993317f, -0.43623671f, 0.08884041f, 
    0.00846897f, 0.21482997f, -0.20104626f, 0.19728267f, 0.01645356f, 0.40569341f, 0.15519622f, -0.16540626f, 
    0.04095118f, 0.26500511f, -0.37304890f, -0.17120589f, -0.04722245f, -0.24715036f, 0.28853148f, 0.08384138f, 
    0.21555193f, 0.05787693f, 0.16155449f, 0.17366844f, -0.32569546f, 0.05245190f, -0.26088744f, -0.22009619f, 
    0.29761752f, -0.18312740f, 0.32131767f, -0.15573880f, -0.24216366f, -0.12350755f, 0.22623362f, 0.09160763f, 
    -0.14698784f, -0.08581239f, 0.41439104f, 0.03636825f, -0.06786247f, 0.00170185f, 0.27510110f, -0.45789438f, 
    -0.15803596f, 0.06855977f, -0.07582638f, 0.06565148f, 0.18718654f, 0.03914298f, 0.17895725f, 0.07895626f, 
    -0.11314433f, 0.54274756f, 0.24701804f, 0.02155491f, -0.07605499f, 0.18902737f, 0.13559099f, 0.15533063f, 
    0.06851865f, 0.17271835f, -0.32378310f, 0.10081017f, 0.12465755f, 0.21716213f, 0.04778996f, -0.20257045f, 
    -0.23002799f, 0.33799103f, -0.18521696f, 0.00525974f, -0.06416056f, -0.25887743f, -0.12792589f, 0.19069092f, 
    0.30364603f, 0.17452966f, -0.08933353f, 0.02432354f, 0.18560864f, 0.46680880f, -0.32596943f, -0.00292105f, 
    -0.22761261f, 0.12447242f, -0.04336849f, -0.11585570f, -0.49013445f, -0.98302501f, 0.12793906f, 0.17352690f, 
    0.29274699f, 0.21132715f, -0.02575765f, -0.11449052f, -0.05579327f, 0.07087926f, -0.22441600f, 0.29431066f, 
    0.28734875f, -0.05124744f, 0.32535085f, -0.02916721f, -0.02915921f, -0.27577060f, 0.16454600f, 0.04707409f, 
    -0.18590777f, 0.17514659f, 0.24139448f, -0.24076906f, -0.04217743f, 0.05524471f, -0.13035388f, 0.05910763f, 
    -0.01587841f, -0.47078741f, 0.00512026f, 0.01036868f, -0.20047297f, -0.19962233f, -0.29027173f, -0.23319261f, 
    0.24505000f, -0.08260265f, 0.28403854f, -0.10327808f, 0.03469295f, 0.35233811f, -0.40723827f, 0.33854598f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.20847164f, 0.53834867f, -0.21714963f, 0.21221717f, 0.62023872f, 0.28232044f, 0.14767785f, 0.03534912f, 
    0.33445427f, -0.06775233f, -0.04839888f, 0.08331040f, -0.10200579f, -0.00439306f, 0.02631044f, 0.10410091f, 
    0.19672155f, 0.27050465f, 0.16647314f, 0.35730022f, 0.08850675f, 0.12698859f, 0.34599879f, 0.58634436f, 
    -0.14396502f, 0.34111395f, -0.00900829f, 0.40817806f, -0.46500021f, 0.27328396f, 0.14716408f, 0.03254059f, 
    0.02766730f, 0.40253860f, 0.17657852f, 0.07674076f, 0.41352370f, 0.21851088f, 0.01036622f, 0.12053356f, 
    0.54499835f, -0.01445446f, 0.24576402f, 0.25055957f, -0.12287756f, 0.15949038f, 0.26929295f, 0.01925552f, 
    -0.01882410f, -0.25408131f, -0.11596943f, -0.34171516f, 0.01149777f, -0.00465851f, 0.20037787f, -0.11377136f, 
    0.03484125f, 0.07532718f, 0.39612126f, 0.10577843f, -0.16926527f, -0.10513961f, 0.15802205f, 0.17286427f, 
    0.05754806f, -0.21242830f, 0.01301223f, 0.09290933f, 0.11942706f, -0.23203301f, -0.20797513f, -0.15075295f, 
    0.39588994f, -0.22919729f, 0.27229252f, -0.05297995f, 0.10491212f, 0.11644565f, 0.10563513f, 0.16913679f, 
    -0.13450979f, 0.15957159f, -0.06107898f, -0.38932168f, 0.84855723f, -0.06257525f, -0.31993547f, -0.29523963f, 
    -0.20734040f, -0.06006227f, 0.01444983f, -0.13428004f, -0.13438773f, -0.21146031f, -0.23738110f, -0.16911379f, 
    -0.20121302f, 0.32762292f, -0.08126722f, 0.15654150f, 0.09719661f, 0.58833313f, -0.21467222f, 0.35409084f, 
    0.07485822f, 0.43367672f, -0.23322502f, 0.28638196f, 0.41080469f, 0.18679294f, 0.20850460f, 0.17442693f, 
    0.53902602f, -0.16718888f, 0.34196034f, 0.22975515f, -0.29973423f, -0.55235457f, -0.05670075f, 0.19708927f, 
    0.25960571f, 0.42329979f, 0.64701486f, -0.18615882f, 0.22815168f, 0.11690030f, -0.29014185f, 0.17347284f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.22751150f, 0.06189118f, 0.29374167f, -0.27412477f, 0.02266388f, 0.01781029f, 0.12184446f, 0.07056976f, 
    0.09449176f, 0.05147893f, -0.06746957f, 0.10975637f, -0.09084277f, 0.02537289f, 0.06849080f, 0.03593379f, 
    -0.06431149f, 0.59789044f, 0.09939010f, 0.00381864f, -0.01758496f, 0.09511361f, 0.02791173f, 0.16511427f, 
    -0.05782827f, 0.05327410f, 0.13268849f, -0.21207000f, -0.17393596f, 0.05833869f, -0.16138345f, 0.19776617f, 
    -0.14725439f, -0.03750310f, -0.04836167f, 0.15623300f, 0.03799478f, 0.04062124f, -0.07982795f, -0.08873656f, 
    0.18030383f, -0.02671665f, -0.05172151f, -0.18558584f, -0.08382086f, -0.02824525f, 0.01346484f, 0.11513630f, 
    -0.08201519f, 0.20791349f, 0.02365458f, -0.17988233f, 0.22337301f, 0.03957568f, 0.24469493f, 0.08883952f, 
    -0.45440495f, 0.05956320f, 0.30221653f, -0.03310159f, 0.05150337f, -0.08849177f, 0.26202190f, -0.00500125f, 
    0.16109374f, 0.04321824f, 0.00810615f, -0.06124333f, 0.39836729f, -0.11274946f, 0.08546897f, -0.25081727f, 
    -0.06304814f, -0.10487323f, -0.37425593f, 0.08459677f, 0.06543867f, -0.07520669f, 0.39615363f, -0.18203232f, 
    -0.39220214f, -0.02219276f, 0.15877102f, -0.25218228f, 0.16846474f, 0.09503766f, -0.18977237f, 0.03391521f, 
    0.06774025f, -0.06493229f, 0.10263763f, 0.15820903f, -0.00847869f, 0.03663219f, -0.05626717f, 0.01500986f, 
    -0.03751454f, -0.22836487f, 0.07781614f, 0.06180218f, -0.02491801f, 0.62043726f, -0.11877310f, -0.17588145f, 
    -0.16194871f, 0.13448927f, -0.04889486f, 0.04555524f, 0.03174623f, -0.11358771f, 0.28336641f, 0.15546091f, 
    0.46791565f, -0.04179083f, -0.09487846f, 0.22759695f, -0.02671410f, -0.12417737f, 0.05551516f, -0.13455632f, 
    0.26242059f, 0.09022599f, 0.20025472f, -0.08089829f, -0.13301505f, -0.08771147f, -0.14274055f, -0.19507976f, 
    0.52374864f, -0.44762325f, 0.23529419f, 0.10735670f, 0.03376829f, -0.30554250f, 0.11341900f, 0.10172323f, 
    -0.00452748f, -0.04100852f, -0.05508255f, 0.17002173f, -0.14574276f, -0.05013488f, -0.56074142f, 0.19966504f, 
    -0.42527592f, -0.03285316f, 0.00071790f, -0.07274106f, 0.38818458f, -0.18722636f, 0.24859826f, -0.34012139f, 
    0.00728786f, 0.00726348f, 0.16889462f, -0.36884168f, 0.00058602f, -0.72429687f, -0.33753607f, 0.05088986f, 
    0.00363214f, -0.37621340f, 0.23836161f, 0.19721216f, -0.60665447f, 0.12549190f, 0.10997359f, -0.17412111f, 
    0.16111323f, -0.76992887f, -0.21704340f, -0.66776592f, 0.33933654f, 0.20363168f, -0.22739357f, 0.11796521f, 
    -0.19179575f, 0.29879609f, -0.01736736f, 0.34618708f, 0.05291978f, -0.08153158f, -0.26205850f, -0.04796788f, 
    0.38091466f, -0.43048555f, -0.51777011f, -0.05260133f, 0.30989939f, -0.00745722f, -0.24293084f, 0.02950791f, 
    0.12300003f, 0.10997292f, 0.04824584f, -0.10705160f, 0.13061678f, 0.06961192f, -0.05333017f, 0.59999549f, 
    -0.19897738f, -0.10758358f, 0.04201196f, -0.31208888f, -0.16429894f, -0.14227206f, 0.08051030f, -0.07220194f, 
    0.13485141f, 0.02779001f, -0.28805497f, 0.20138873f, -0.19500342f, 0.00063166f, 0.19772194f, -0.03270762f, 
    0.28550133f, 0.04376470f, 0.00975727f, 0.18264516f, 0.20994358f, -0.00010985f, 0.06925598f, 0.04304343f, 
    0.02511595f, 0.17235708f, -0.07003900f, -0.11374583f, 0.15840298f, 0.05450248f, 0.11810874f, -0.08471373f, 
    0.17804986f, -0.13151526f, 0.07074280f, -0.10253289f, 0.04248689f, -0.41904125f, -0.02099101f, -0.47531399f, 
    0.09680329f, -0.07360258f, -0.14735326f, -0.55425936f, -0.03471578f, 0.96207005f, -0.13180967f, -0.13724819f, 
    0.04916952f, -0.03552848f, 0.21625631f, 0.24752036f, -0.53080356f, -0.11576250f, 0.19236401f, -0.24061121f, 
    -0.05298570f, -0.02263208f, 0.06682193f, 0.01196857f, -0.04825618f, -0.06227349f, -0.03380747f, -0.08398151f, 
    -0.09000338f, 0.05206026f, -0.04443021f, -0.07554735f, -0.01326397f, 0.05728935f, -0.09190270f, 0.06225259f, 
    -0.00665037f, -0.01492570f, -0.07272473f, 0.02722165f, -0.06265222f, 0.06639695f, -0.01091946f, -0.07644714f, 
    -0.08339667f, 0.02947792f, 0.01548899f, -0.06461688f, -0.07735401f, 0.06608848f, 0.04019969f, -0.03526066f, 
    -0.03725031f, 0.03303351f, -0.10370069f, -0.10249518f, 0.06544957f, -0.05584681f, -0.06889350f, -0.08286677f, 
    -0.05113537f, 0.03701577f, -0.03408453f, -0.06900628f, 0.00781508f, 0.00900723f, 0.03926801f, -0.04228519f, 
    -0.04941683f, -0.02078828f, -0.01811570f, -0.07015710f, -0.00067643f, 0.01095818f, -0.09247957f, -0.10370595f, 
    -0.06402466f, -0.09275697f, -0.03106786f, 0.06652271f, 0.04919125f, 0.03804315f, -0.10062365f, 0.04190028f, 
    -0.04090339f, -0.03796137f, -0.04160387f, 0.02607135f, -0.08500957f, -0.03921283f, -0.06232739f, 0.03582055f, 
    -0.08091046f, -0.04141689f, 0.02699462f, 0.00920509f, -0.04196170f, -0.00857726f, -0.06057935f, -0.00566006f, 
    0.01825386f, 0.01165207f, 0.04513649f, -0.08625397f, -0.04541263f, -0.00324463f, -0.08654369f, 0.03993401f, 
    -0.00324700f, -0.04616057f, -0.00619345f, 0.02613933f, -0.06658045f, -0.04735186f, -0.01914663f, 0.02845297f, 
    0.05433982f, 0.00690501f, -0.05868385f, 0.03543659f, -0.01816203f, -0.04694972f, -0.07818712f, 0.01707491f, 
    0.03193790f, -0.10790275f, 0.06700265f, -0.02494850f, -0.01793781f, -0.09345005f, -0.07875755f, 0.06171817f, 
    -0.01684652f, -0.01505384f, -0.03200945f, 0.04134623f, 0.01491343f, 0.04885253f, -0.04944590f, -0.08777317f, 
    0.03270278f, -0.04166712f, -0.00059743f, 0.01343599f, 0.01115566f, -0.01989380f, -0.06972325f, -0.06228737f, 
    0.13110404f, 0.10632125f, 0.16879421f, 0.24956509f, 0.01809488f, -0.17492574f, 0.39178431f, 0.11335243f, 
    -0.06765579f, -0.07025526f, 0.06616585f, 0.07969827f, -0.10017545f, -0.07367028f, -0.23494074f, -0.08362875f, 
    -0.12188689f, -0.84424180f, 0.02690285f, -0.05249251f, 0.00788133f, 0.10462843f, 0.09230185f, -0.21905956f, 
    0.08037028f, 0.11542399f, 0.63923740f, 0.24177423f, 0.03477040f, -0.33829153f, 0.12460753f, -0.41719285f, 
    -0.00881136f, 0.05286297f, 0.00782037f, 0.04839600f, 0.10137361f, 0.13950673f, 0.22330593f, 0.17173320f, 
    0.14691772f, -0.21052235f, -0.04812927f, -0.11037803f, -0.19694760f, 0.24265008f, -0.15893312f, -0.25729319f, 
    -0.06798238f, 0.29134017f, -0.01413150f, 0.49529871f, 0.00149977f, -0.11102279f, -0.24467729f, -0.51293093f, 
    0.15580069f, -0.31943280f, -0.05655918f, 0.02040400f, 0.14805201f, 0.14318722f, -0.16491705f, 0.35329759f, 
    0.36203369f, -0.16506797f, -0.13684312f, -0.05080794f, -0.43926805f, -0.04198419f, -0.05156048f, 0.10775092f, 
    0.16429627f, -0.37292838f, 0.25879219f, -0.37566692f, 0.00816997f, 0.10746396f, -0.13156070f, -0.01242396f, 
    -0.13726614f, -0.05307851f, -0.52197295f, -0.13249652f, 0.03903796f, -0.11681691f, 0.12883975f, 0.06103315f, 
    0.24182221f, 0.15261398f, 0.15207836f, 0.35734439f, 0.08340573f, 0.12023614f, 0.00166186f, 0.13190155f, 
    0.03618304f, 0.04554960f, 0.04805298f, -0.05302784f, -0.09634061f, -0.16524740f, 0.57824683f, 0.24261150f, 
    0.21295764f, 0.05076639f, 0.08051555f, -0.07007268f, 0.16228834f, -0.03169737f, 0.22911189f, -0.14248930f, 
    -0.50800979f, -0.00246909f, -0.08278031f, -0.40026766f, 0.08874579f, 0.32628345f, 0.00121310f, 0.14628141f, 
    0.13547480f, 0.13505469f, 0.22804992f, -0.18777634f, -0.02020384f, -0.00045462f, 0.24514331f, 0.18637252f, 
    0.03455634f, -0.09662943f, -0.06090317f, -0.11171990f, -0.05401116f, -0.01971707f, -0.02888176f, 0.05714537f, 
    -0.06030312f, -0.02482025f, -0.07412057f, -0.05422686f, 0.00004620f, 0.05932034f, 0.08268367f, 0.04490083f, 
    -0.09140887f, -0.07463970f, 0.05049530f, -0.01709742f, -0.00393368f, -0.08503573f, -0.02493898f, -0.00360246f, 
    -0.00285649f, 0.03071004f, -0.01584301f, 0.03754966f, -0.03579867f, -0.02608151f, 0.04039602f, -0.04426610f, 
    -0.04437463f, 0.03305582f, 0.02427620f, -0.05326052f, -0.06152084f, -0.00436816f, -0.03124150f, -0.06658565f, 
    -0.04451367f, 0.08716384f, -0.07646369f, 0.08174271f, 0.04325299f, 0.04540586f, -0.07587586f, 0.03515736f, 
    -0.03791954f, -0.00344564f, -0.01005675f, -0.00204948f, 0.00398764f, -0.10008298f, -0.07074295f, -0.00030234f, 
    -0.08702239f, -0.07923920f, -0.01081325f, 0.03912178f, -0.00598235f, -0.05936285f, -0.05189411f, 0.01630110f, 
    -0.00749204f, -0.04261681f, 0.06469242f, 0.04066221f, -0.03099455f, 0.05357423f, 0.04146876f, 0.04124879f, 
    -0.11881757f, 0.05825563f, 0.05449628f, 0.03153786f, 0.00930568f, 0.05991937f, -0.02761520f, 0.03384417f, 
    0.01322549f, -0.00036139f, -0.02211154f, -0.03082329f, -0.06192167f, 0.03064166f, -0.01376411f, -0.04275985f, 
    -0.07497441f, -0.12241262f, -0.04853190f, 0.02951683f, -0.10420932f, 0.03030778f, 0.05223268f, -0.04131122f, 
    -0.08746438f, 0.01686135f, 0.03296371f, -0.08492407f, -0.06021944f, -0.03793234f, -0.02076025f, -0.02110134f, 
    -0.05383662f, 0.06862930f, 0.06423214f, 0.00028396f, -0.05786483f, 0.02341083f, -0.04248322f, 0.00904245f, 
    0.00416912f, 0.06422850f, -0.07207517f, 0.01135550f, -0.11537547f, -0.09839752f, -0.05339937f, -0.01107987f, 
    0.01768918f, -0.05025305f, -0.07953689f, -0.04411372f, -0.00789262f, -0.06621628f, 0.04096135f, 0.05372237f, 
    0.31196350f, 0.10649420f, 0.07326904f, -0.04651943f, 0.02837284f, 0.08751858f, 0.00824577f, 0.01454993f, 
    0.17606133f, 0.09499501f, 0.05421516f, 0.08920313f, 0.13770181f, -0.12628187f, 0.33612627f, 0.08656152f, 
    -0.08718027f, 0.35271555f, -0.06773590f, 0.07264267f, -0.05197400f, 0.00177868f, 0.07510898f, 0.21376793f, 
    -0.02673643f, -0.22750291f, 0.03827149f, 0.17005384f, -0.03967312f, -0.34281290f, 0.18224980f, -0.13470389f, 
    0.23438326f, 0.17153364f, -0.03306708f, 0.02609309f, -0.03721377f, 0.11296477f, -0.11155984f, 0.07473763f, 
    -0.21958907f, 0.29601794f, -0.09895466f, 0.18203293f, -0.18852898f, -0.09531736f, 0.03243754f, 0.22499824f, 
    -0.16615506f, -0.14214288f, -0.04271049f, -0.40740904f, -0.06886774f, 0.16530634f, 0.24133451f, 0.25040078f, 
    0.25602227f, 0.02747395f, 0.40295500f, -0.06511966f, 0.02141062f, 0.03506975f, -0.05687675f, -0.05505532f, 
    -0.15832549f, 0.27075228f, 0.09828041f, 0.06184508f, 0.57506269f, -0.06914055f, -0.00336455f, -0.26525223f, 
    -0.08369081f, -0.02903140f, -0.11623107f, -0.07343470f, -0.04149117f, -0.07929211f, -0.29655105f, 0.09852371f, 
    -0.34271434f, -0.02025413f, 0.39367127f, 0.04415157f, 0.12909985f, 0.04955534f, 0.02663722f, 0.13400283f, 
    -0.16550545f, -0.00630877f, 0.27458292f, -0.16817831f, 0.27521640f, -0.02708097f, -0.04661177f, -0.13206096f, 
    -0.02142467f, 0.18733928f, 0.08111690f, 0.18171121f, 0.18711746f, -0.10187551f, -0.21634394f, 0.22247010f, 
    0.03965470f, 0.02026550f, 0.06593415f, 0.16544081f, 0.12726045f, -0.11895505f, 0.22197244f, 0.05490240f, 
    -0.30330533f, -0.01836479f, -0.08624317f, 0.10920301f, -0.00132739f, -0.52606416f, -0.26097801f, 0.00585368f, 
    -0.19130516f, 0.10443853f, 0.09274182f, -0.00386045f, 0.05916655f, -0.15885119f, 0.10731494f, 0.06880246f, 
    -0.15148421f, 0.31933674f, 0.10425604f, -0.07043307f, -0.02645339f, 0.14193155f, -0.07630154f, -0.02882041f, 
    0.07432552f, 0.17679885f, 0.02250577f, -0.05881790f, 0.19804583f, -0.13813284f, 0.28841442f, -0.06697992f, 
    0.10706656f, 0.31640214f, -0.02788442f, 0.06017761f, -0.12643273f, 0.44769734f, -0.08280985f, 0.12763472f, 
    0.08768776f, 0.06587257f, -0.27896875f, 0.42101273f, 0.15364754f, 0.23754367f, 0.42762297f, 0.17841378f, 
    0.21274588f, 0.18569076f, -0.02218436f, -0.13131614f, 0.10707071f, 0.06044770f, 0.00408009f, 0.10196534f, 
    -0.06161018f, 0.16415115f, 0.22175290f, 0.28981456f, 0.32069468f, 0.12126201f, 0.15603130f, 0.12977259f, 
    0.03075293f, 0.21107763f, 0.04509665f, -0.15531303f, 0.21171898f, 0.02967182f, 0.32075140f, 0.25829720f, 
    -0.17268495f, 0.26252076f, 0.14395526f, -0.01493135f, -0.11595671f, 0.07597335f, 0.15460204f, 0.02835113f, 
    -0.13059968f, 0.18202926f, 0.16284275f, 0.02381909f, 0.30528671f, -0.08034053f, -0.04129490f, -0.30588752f, 
    -0.01643647f, 0.00598595f, -0.27624792f, 0.67675310f, 0.11970726f, -0.04602855f, 0.10926409f, 0.02446106f, 
    -0.52822393f, 0.61523300f, 0.25425184f, -0.11722860f, 0.10459517f, 0.27332872f, 0.07660548f, 0.19660631f, 
    -0.20878237f, 0.03107780f, 0.13537209f, -0.18547931f, 0.08494033f, -0.08890207f, -0.01054848f, 0.09982588f, 
    0.18233347f, 0.18905634f, 0.22030635f, 0.28027597f, 0.06816167f, 0.26154441f, -0.07112723f, 0.17114356f, 
    0.04471032f, 0.23938337f, -0.08017603f, 0.15975487f, -0.02114271f, 0.17156459f, 0.29165152f, 0.22052622f, 
    0.07302754f, -0.03289213f, 0.20859419f, 0.35718071f, 0.07116853f, -0.32563940f, -0.17213947f, 0.03438666f, 
    0.16402483f, 0.18304165f, -0.04821796f, 0.04142519f, 0.09726395f, -0.08607252f, -0.05073316f, 0.03914078f, 
    -0.02984704f, 0.08063991f, -0.05952963f, -0.06997851f, -0.09661803f, -0.08977795f, 0.00583639f, 0.01199646f, 
    0.04839686f, -0.04236797f, -0.04583159f, -0.02813189f, 0.02348313f, -0.00167625f, -0.04674037f, -0.00305064f, 
    0.01054072f, 0.05059506f, 0.06034544f, 0.04430871f, -0.04151679f, 0.04703674f, -0.11330096f, -0.07230680f, 
    0.02713558f, -0.07668398f, -0.02837762f, 0.07040370f, 0.04690139f, -0.02785269f, 0.00419817f, -0.09571162f, 
    -0.00159731f, -0.05085174f, -0.09928738f, 0.05523558f, 0.02364717f, -0.10097963f, -0.01406483f, 0.03155243f, 
    0.03007747f, 0.06958965f, -0.07177079f, 0.02446120f, -0.06814820f, -0.05377410f, -0.03087841f, -0.03061412f, 
    -0.02112799f, 0.05804549f, 0.06151869f, 0.03820549f, 0.04016294f, -0.05790026f, 0.03259313f, 0.03917019f, 
    0.02566848f, 0.02991072f, 0.01571629f, -0.10467563f, 0.02910073f, 0.02681558f, -0.09624140f, -0.02990787f, 
    -0.05741816f, -0.10066787f, -0.09619094f, -0.02161230f, 0.05672527f, 0.02381818f, -0.02720371f, -0.10937811f, 
    -0.01429501f, -0.05379048f, -0.12280345f, -0.04840458f, -0.06159264f, -0.05038942f, -0.02533250f, 0.05160601f, 
    0.04034256f, 0.03622559f, -0.07227769f, 0.04129540f, -0.04159893f, -0.03032647f, -0.05792764f, -0.05678271f, 
    -0.03556525f, -0.05816340f, 0.07158750f, -0.06126043f, -0.08731070f, -0.04267851f, 0.00349103f, 0.02579010f, 
    -0.01659112f, 0.02643842f, 0.02721249f, 0.03324656f, 0.03308818f, 0.03590454f, -0.07495877f, -0.03185873f, 
    -0.02493614f, -0.00800620f, 0.08836599f, -0.09415601f, 0.05951866f, -0.04026051f, 0.02415666f, -0.00145722f, 
    -0.06085359f, -0.08197231f, 0.04319856f, 0.07429127f, 0.00194564f, -0.08331607f, -0.07454517f, -0.00610418f, 
    0.00597839f, 0.00173812f, 0.07711639f, 0.05564238f, -0.03129996f, -0.06768318f, -0.05482856f, -0.08269790f, 
    -0.00142351f, -0.07111458f, -0.00572012f, -0.09011582f, -0.02204130f, -0.10793374f, 0.05814210f, -0.04945302f, 
    -0.00694756f, -0.04242776f, -0.02472253f, -0.04789787f, -0.00050746f, -0.04281569f, 0.00546428f, -0.06854731f, 
    -0.07903873f, -0.05897881f, -0.01250776f, -0.09263764f, -0.06861605f, -0.08243527f, -0.10699601f, 0.01843581f, 
    0.07472548f, -0.11045592f, -0.09232195f, -0.01048546f, -0.03261559f, 0.04126123f, -0.10370357f, 0.00091388f, 
    -0.04540787f, 0.00959277f, -0.08265250f, -0.11117233f, -0.06845279f, 0.02864954f, 0.00015143f, -0.05709491f, 
    0.02404885f, -0.08776867f, -0.05431631f, -0.06650487f, 0.05212742f, 0.05240817f, -0.03660681f, -0.10604211f, 
    0.04900895f, 0.05598355f, 0.08757248f, 0.03096604f, 0.04287207f, -0.03826153f, 0.03265171f, -0.06744898f, 
    -0.07370080f, -0.05572463f, -0.06239332f, -0.11009811f, -0.11811245f, -0.05490079f, 0.05291711f, -0.05503353f, 
    0.01984098f, -0.02066895f, -0.05255754f, 0.05487035f, -0.08160120f, 0.02029838f, 0.00099831f, -0.02957036f, 
    0.04670551f, -0.00025332f, 0.00730269f, -0.00289654f, -0.09171983f, 0.00689994f, -0.08189830f, 0.00491503f, 
    0.04020197f, -0.11324448f, -0.05137850f, -0.01872181f, -0.09992226f, -0.05356066f, 0.05563973f, -0.05957691f, 
    -0.01210327f, -0.09772924f, -0.07681352f, 0.05813620f, -0.04701719f, -0.08021736f, -0.04748563f, 0.03322735f, 
    -0.02858655f, 0.03367019f, -0.09981827f, 0.00056818f, -0.08191144f, -0.08617639f, -0.08297951f, -0.00676595f, 
    0.02892488f, -0.04897729f, -0.07661987f, 0.03824386f, -0.09934876f, 0.03614419f, 0.05390880f, 0.04491715f, 
    -0.02516447f, 0.06305331f, -0.00000120f, 0.00050562f, -0.04722523f, -0.08169150f, 0.04407614f, -0.05889284f, 
    -0.08975188f, -0.10711256f, 0.04633470f, 0.04605618f, 0.01954087f, 0.00481264f, 0.01874648f, -0.05150511f, 
    -0.02169995f, -0.05502835f, -0.05987446f, -0.04670732f, -0.06805281f, -0.07160988f, 0.03128527f, 0.05695569f, 
    -0.08824629f, -0.04980626f, 0.07635626f, 0.01028771f, -0.10518113f, -0.07863417f, -0.02581828f, -0.06089341f, 
    0.02353869f, 0.00914104f, 0.02491239f, -0.06737857f, -0.08529227f, 0.05448110f, -0.01535699f, -0.09141482f, 
    0.02728249f, -0.04366990f, 0.01657148f, 0.05030339f, -0.09258520f, 0.02291374f, -0.04493322f, 0.04330339f, 
    -0.06810947f, -0.00306317f, 0.04893890f, -0.02222614f, -0.01773662f, -0.08833309f, -0.10433694f, -0.05188276f, 
    -0.11281206f, 0.06160009f, 0.00282816f, -0.05090695f, 0.08184423f, -0.05599472f, 0.00616995f, 0.04490971f, 
    -0.06854363f, 0.00224638f, -0.08226737f, -0.05991244f, 0.03051585f, 0.00944211f, -0.06293719f, -0.00683835f, 
    0.01657858f, -0.06876158f, 0.04533662f, 0.02088894f, 0.04827853f, 0.00623388f, -0.08315814f, -0.08858918f, 
    0.04367450f, -0.07368769f, -0.07743182f, -0.09170915f, -0.03274953f, -0.04523623f, -0.00804890f, 0.02383205f, 
    -0.05080310f, -0.06734496f, 0.06145213f, 0.00651500f, -0.00864037f, -0.04056316f, -0.04338310f, 0.05171486f, 
    0.08558491f, 0.00159293f, -0.06234016f, 0.04207331f, -0.09095439f, 0.02641397f, -0.07129370f, -0.02841768f, 
    -0.07754503f, -0.10242449f, 0.04453740f, -0.07549090f, -0.07117685f, -0.03667364f, -0.07244729f, -0.00653303f, 
    0.04626781f, -0.03118075f, 0.06872841f, -0.00727139f, -0.02351016f, 0.02359666f, -0.00341879f, -0.06077924f, 
    -0.10486037f, 0.02053013f, 0.01485927f, -0.06243036f, -0.05067831f, -0.04129924f, 0.03169582f, -0.09518319f, 
    0.06149863f, -0.01388516f, -0.02400864f, 0.08057588f, -0.01136588f, -0.01811381f, 0.01760657f, -0.03177417f, 
    -0.10476957f, -0.07061028f, -0.04020377f, 0.03941812f, -0.10089054f, -0.10929294f, -0.06016046f, -0.02579922f, 
    0.06526478f, -0.08025476f, -0.08294475f, 0.01302195f, 0.00363239f, -0.10011563f, 0.02601729f, -0.10384915f, 
    -0.08047407f, 0.06229509f, -0.01703218f, -0.00262325f, -0.06208639f, -0.07238828f, 0.05080016f, 0.00188274f, 
    -0.07341457f, 0.02943379f, -0.01441215f, 0.06788547f, -0.03299205f, 0.03374936f, 0.03570528f, -0.09787764f, 
    0.08652182f, -0.06783723f, -0.04453076f, 0.04510542f, -0.05548035f, -0.07106972f, -0.07884009f, 0.07337610f, 
    -0.05199150f, 0.02788946f, 0.06274045f, 0.06614791f, -0.02046007f, -0.11265522f, 0.04073741f, -0.04346779f, 
    0.02482526f, -0.02161885f, 0.04593090f, 0.00829880f, -0.07938043f, -0.06489949f, 0.03433573f, -0.03905750f, 
    -0.10041209f, 0.07714341f, -0.01519134f, -0.07941758f, -0.05385933f, -0.10431320f, -0.08953295f, 0.07047127f, 
    0.07438480f, -0.01435092f, 0.02472322f, -0.07473317f, 0.00175595f, -0.11000723f, -0.03212608f, -0.00790321f, 
    -0.03040782f, -0.05712897f, -0.09892605f, -0.01666698f, -0.03571312f, -0.05081790f, -0.03752285f, 0.00510267f, 
    0.01606786f, -0.11964861f, -0.00419634f, 0.03596313f, 0.03194218f, -0.01181029f, -0.05520467f, 0.04998049f, 
    -0.07650845f, -0.04223933f, -0.03117692f, 0.02723243f, -0.02483303f, -0.02943414f, -0.03318718f, 0.02572343f, 
    -0.00141406f, -0.01429390f, 0.02564913f, -0.00447389f, -0.08740517f, -0.11423829f, 0.04759558f, -0.02370471f, 
    -0.07028591f, 0.00003248f, 0.02233989f, -0.01711086f, -0.01979177f, 0.01091215f, -0.10119730f, -0.03936082f, 
    -0.00767992f, -0.08693716f, 0.02086994f, -0.01079901f, 0.00163877f, 0.05355335f, 0.06374434f, 0.00235124f, 
    -0.04622047f, 0.03703817f, 0.01169113f, -0.07827929f, -0.03460276f, -0.07929837f, 0.05597962f, 0.04081565f, 
    -0.06350026f, -0.07597840f, -0.11597801f, -0.08728554f, 0.00054799f, 0.04544939f, 0.02328958f, -0.03802376f, 
    0.03396958f, -0.06323611f, -0.01405401f, 0.01726681f, 0.00753349f, -0.04987257f, -0.05924113f, -0.03236450f, 
    -0.08891542f, 0.00012865f, 0.00755623f, 0.04278986f, -0.05506938f, 0.01613242f, -0.03256706f, -0.03436016f, 
    -0.09032392f, 0.07901003f, -0.01033994f, -0.01533399f, -0.04842260f, 0.03916059f, 0.07494397f, 0.07270280f, 
    0.07927410f, -0.07137606f, -0.09162333f, -0.00302260f, 0.02185526f, -0.02207482f, -0.04958614f, -0.01609000f, 
    -0.08735608f, 0.03075464f, 0.01981150f, -0.00665335f, -0.01915784f, 0.01663979f, -0.04857067f, -0.09444977f, 
    -0.07265698f, -0.02398821f, 0.06810924f, 0.00085837f, -0.08703724f, -0.05012237f, -0.01827853f, -0.06220625f, 
    0.02136996f, -0.06659956f, -0.07205472f, -0.01725208f, -0.05665006f, -0.04691244f, -0.04594348f, 0.02467632f, 
    -0.05291761f, 0.02558059f, -0.07061349f, -0.07829876f, 0.04644408f, 0.02260214f, 0.03824504f, -0.11836658f, 
    0.01415963f, 0.06679144f, -0.07782254f, -0.01134550f, 0.02208178f, -0.04405267f, -0.07027233f, 0.01159437f, 
    -0.05252191f, 0.00146285f, 0.08938899f, -0.08234354f, 0.02295440f, 0.05341479f, -0.09494242f, 0.00856894f, 
    0.05149057f, -0.02106818f, -0.01251135f, -0.08676290f, -0.05483855f, 0.02122288f, -0.00028014f, -0.12539552f, 
    0.03010456f, -0.02794799f, 0.08583654f, -0.07629596f, 0.01287242f, -0.09738775f, -0.04804200f, -0.10791651f, 
    -0.07440064f, -0.06432669f, -0.10727418f, -0.03164322f, -0.09345739f, -0.05756430f, -0.04063384f, -0.08487474f, 
    0.03643098f, -0.00241481f, -0.02243854f, -0.02714321f, -0.03427790f, -0.08418959f, -0.10423532f, 0.02521692f, 
    -0.00098638f, 0.02994143f, -0.07444447f, 0.02734954f, -0.09114683f, -0.09629394f, 0.07966726f, -0.00902199f, 
    -0.06328221f, -0.06256082f, -0.07381060f, 0.01592360f, -0.06349555f, -0.09298626f, -0.09830764f, -0.05626619f, 
    0.04316732f, -0.08794459f, -0.09562169f, 0.05184998f, -0.09851651f, -0.05245057f, -0.07126668f, -0.06644981f, 
    -0.03538618f, -0.04945617f, 0.08341023f, -0.09329745f, -0.09789322f, 0.03281341f, 0.02795364f, -0.11153882f, 
    0.04609114f, -0.00799798f, -0.07102785f, -0.10333984f, 0.02145959f, -0.00025458f, -0.02971170f, -0.01851281f, 
    -0.03681351f, -0.05875220f, -0.03767537f, -0.10380120f, 0.04448536f, -0.02940953f, 0.00005668f, -0.07824665f, 
    0.03578751f, 0.03371456f, -0.03102927f, -0.01174658f, -0.12168092f, -0.08203826f, -0.05009233f, -0.00501865f, 
    0.03137292f, 0.03685400f, 0.01508823f, -0.05880367f, -0.05169266f, -0.08467475f, -0.11771959f, -0.01871813f, 
    -0.09229149f, 0.00225967f, -0.08008153f, -0.04570173f, 0.01621003f, 0.00531652f, -0.05391098f, -0.03167510f, 
    -0.02152102f, 0.04377024f, 0.00918683f, 0.00470218f, -0.00076675f, -0.05319996f, 0.03975469f, -0.03083947f, 
    0.06634878f, -0.08075202f, -0.01636815f, -0.07454467f, -0.05289730f, 0.05686874f, -0.04595266f, -0.06108303f, 
    -0.05409027f, -0.01689104f, 0.03801187f, 0.05320982f, -0.00154461f, 0.04151954f, -0.07790441f, -0.06176846f, 
    -0.07431327f, -0.08002052f, -0.01012877f, -0.01391748f, 0.03688494f, -0.01066230f, -0.00732364f, -0.02226202f, 
    0.02625524f, -0.01302729f, 0.00213315f, 0.02516888f, -0.04974404f, 0.04424923f, -0.00300696f, -0.09107726f, 
    -0.06331342f, 0.04930927f, -0.06298113f, -0.08021418f, -0.05529941f, 0.00549680f, -0.00377984f, -0.07590654f, 
    0.03662882f, -0.07736748f, -0.07345551f, 0.03385496f, -0.11107612f, 0.01193081f, -0.00044439f, -0.07411794f, 
    0.02996654f, 0.06946654f, -0.09495647f, -0.11010120f, 0.00633412f, 0.02336229f, -0.07084260f, -0.09793724f, 
    -0.07810019f, 0.01436983f, -0.01595831f, -0.11314157f, 0.03260532f, -0.10678299f, -0.04644049f, -0.03704553f, 
    -0.01852774f, -0.14778219f, -0.07534813f, -0.05745610f, 0.09176694f, -0.08500253f, 0.10673554f, 0.02363098f, 
    -0.03827304f, -0.05997436f, 0.01463341f, -0.06297918f, 0.16884038f, -0.03588395f, 0.06177116f, 0.17117877f, 
    0.01841139f, -0.06460620f, -0.09895622f, 0.09515890f, 0.07130041f, -0.24052244f, 0.09986741f, 0.13859738f, 
    -0.08078688f, 0.11061855f, 0.23992935f, -0.08791626f, -0.36023110f, 0.08468274f, 0.00382332f, 0.04021086f, 
    -0.31712607f, -0.07057274f, 0.00914244f, 0.02186065f, -0.06153252f, 0.05275064f, -0.02610100f, -0.01601198f, 
    0.21458794f, -0.15424877f, -0.17480777f, 0.10113417f, 0.14394611f, 0.21098451f, 0.12124033f, 0.02310940f, 
    -0.06594076f, 0.01765515f, 0.07737537f, 0.12679380f, -0.29321319f, 0.07046495f, -0.03575248f, 0.03660812f, 
    0.24529636f, 0.11968072f, 0.08967214f, 0.09079688f, 0.05876738f, 0.15401812f, 0.04449137f, 0.07935740f, 
    -0.08028289f, 0.05873992f, 0.11991999f, 0.10167000f, -0.19656657f, 0.21250726f, -0.02401478f, 0.35302836f, 
    0.00933129f, 0.12249584f, -0.09856337f, 0.01776572f, 0.09080745f, -0.08736362f, -0.10000464f, -0.60472721f, 
    0.41697049f, 0.14924273f, -0.20368627f, 0.28882319f, 0.13579187f, 0.06369997f, 0.12469241f, 0.07667265f, 
    0.03262297f, 0.02458306f, 0.02482264f, 0.12139524f, -0.25203514f, -0.00042303f, -0.06709912f, -0.14444213f, 
    -0.10038607f, -0.17304623f, -0.05532031f, -0.05428134f, -0.03202843f, 0.17408724f, -0.22933637f, 0.18641730f, 
    0.14055388f, 0.03792734f, 0.00551994f, -0.04866687f, 0.14078233f, 0.01246172f, 0.03543792f, 0.17853191f, 
    0.08902032f, -0.01157898f, 0.40815702f, 0.16146791f, 0.10879911f, -0.18461972f, 0.40823200f, -0.07767463f, 
    -0.05790790f, 0.00821313f, -0.15515050f, 0.08558577f, -0.06155023f, 0.00155602f, -0.02637232f, 0.12382772f, 
    -0.09387591f, 0.04493525f, -0.31590730f, -0.05936940f, 0.11206340f, 0.00101130f, -0.25677818f, -0.03794222f, 
    0.20571108f, -0.16999835f, -0.00337559f, 0.02736620f, 0.10954175f, 0.47887483f, 0.07156447f, 0.03178380f, 
    0.41851524f, 0.64775366f, -0.27742130f, 0.18910535f, 0.20561799f, 0.27818808f, 0.09575534f, -0.06783213f, 
    0.05819406f, 0.33453572f, -0.22031753f, -0.22762582f, -0.33790207f, -0.40838268f, -0.42164567f, -0.13639444f, 
    -0.08939961f, -0.00541870f, 0.25315470f, 0.35620049f, -0.09174149f, 0.13763393f, -0.00480621f, -0.17082460f, 
    0.35873139f, -0.23749647f, -0.17876653f, 0.24348983f, -0.10240506f, 0.17989823f, 0.21904074f, 0.14144300f, 
    0.41517898f, 0.20938700f, 0.04736292f, -0.05823260f, -0.34212264f, 0.42160526f, 0.10100457f, 0.01159988f, 
    0.05385860f, 0.24931921f, 0.00060535f, -0.04110648f, 0.00425154f, -0.05138750f, 0.06565844f, -0.24145442f, 
    -0.11604839f, -0.07051176f, 0.07681926f, 0.13449790f, -0.00246860f, -0.16516505f, -0.03850393f, -0.04829938f, 
    -0.17061511f, -0.05163333f, 0.07932691f, 0.07015311f, 0.01490298f, -0.01122016f, -0.13701408f, -0.24857542f, 
    0.47772583f, 0.00757604f, 0.18394893f, -0.10677423f, 0.07304311f, 0.31304887f, 0.06310621f, 0.12474281f, 
    -0.07180768f, 0.04564627f, 0.01054552f, -0.32007149f, -0.45768768f, 0.00210957f, 0.00851083f, -0.60516113f, 
    -0.15320067f, -0.12172395f, -0.01385400f, -0.03006671f, 0.12628415f, 0.66848958f, -0.18667893f, -0.16879520f, 
    0.02814265f, 0.12925464f, -0.01733714f, 0.12365931f, -0.07872774f, 0.13229054f, -0.18014835f, -0.18311803f, 
    -0.01041229f, -0.01412996f, 0.38615966f, -0.09739996f, 0.00474683f, -0.31001693f, 0.22268124f, -0.11925481f, 
    -0.01360076f, -0.19657834f, 0.34217581f, 0.24344780f, 0.28239506f, 0.35761172f, 0.00697647f, -0.33421403f, 
    -0.04465421f, -0.08101850f, -0.09657626f, -0.08793170f, -0.02789106f, 0.02927256f, 0.01721950f, 0.05905652f, 
    0.03176901f, -0.07775732f, 0.02236180f, 0.02265883f, 0.04843453f, -0.00726232f, -0.09395663f, 0.00361230f, 
    0.01067563f, 0.04482477f, 0.03533107f, 0.05720232f, 0.03016925f, -0.09408996f, -0.01994421f, -0.00077801f, 
    0.03540521f, -0.04313963f, 0.01733608f, 0.04828994f, -0.04942977f, -0.01825378f, -0.03402405f, 0.01172885f, 
    0.05980470f, -0.06973147f, -0.02700047f, -0.02461115f, 0.03349032f, -0.09051158f, -0.00405515f, -0.00411670f, 
    0.07356157f, -0.06518926f, 0.06501269f, -0.09775776f, -0.00187322f, -0.03569637f, 0.03540338f, -0.06427290f, 
    0.04446359f, 0.05142320f, 0.08247095f, 0.05432281f, 0.05700968f, -0.03362129f, 0.06516828f, -0.08904227f, 
    0.03950407f, 0.01465439f, -0.03295079f, -0.08834072f, -0.09138685f, -0.11982866f, -0.00711875f, -0.00184060f, 
    -0.04553881f, -0.00328342f, -0.03306504f, 0.02838696f, 0.00194335f, 0.05534685f, -0.02538778f, 0.01955955f, 
    0.02099900f, -0.08630146f, 0.05659027f, 0.03513798f, -0.08570404f, -0.09621779f, 0.04809141f, -0.08392605f, 
    0.02163159f, -0.01376871f, -0.02325629f, -0.11192381f, -0.10269877f, -0.01173670f, -0.05601226f, -0.07592821f, 
    0.04867883f, 0.03324461f, 0.02061806f, -0.04127233f, -0.11295723f, -0.09333315f, -0.05015395f, 0.03339210f, 
    -0.02048399f, 0.00934443f, 0.00102853f, -0.03633286f, -0.09086516f, -0.01976515f, -0.08799128f, -0.05370102f, 
    -0.13070101f, -0.07110406f, -0.00648007f, -0.06716476f, -0.07940729f, 0.02051412f, 0.06396034f, -0.01645240f, 
    -0.09287722f, -0.01233468f, -0.01308560f, -0.00204941f, -0.07779993f, 0.00152064f, 0.01855660f, -0.11225095f, 
    -0.07268853f, -0.09435136f, 0.03299917f, -0.05284124f, -0.06530017f, -0.00272480f, 0.02843274f, -0.10561711f, 
    -0.46742904f, 0.48453686f, 0.08365498f, -0.00495135f, 0.12009181f, 0.02140736f, 0.18080357f, 0.23480308f, 
    -0.27213570f, -0.24055226f, -0.06619997f, 0.26733512f, -0.06663988f, -0.16223590f, -0.09746574f, -0.04488491f, 
    -0.34274259f, 0.61019641f, 0.12671907f, 0.08728267f, 0.13650557f, -0.08791071f, 0.25057286f, 0.01236179f, 
    -0.01594527f, 0.04754792f, -0.21493036f, 0.14263162f, -0.33737361f, -0.22072990f, -0.49949905f, -0.18654579f, 
    -0.29756781f, 0.20746426f, 0.23842166f, 0.16079730f, -0.04767817f, 0.03522718f, -0.09679516f, -0.03199046f, 
    0.24099053f, -0.14199355f, -0.02802317f, -0.55062127f, -0.14844182f, 0.14367229f, -0.12422381f, -0.08043475f, 
    0.01910014f, 0.23474859f, -0.07332131f, -0.10313300f, 0.11897399f, -0.31575584f, -0.18311472f, -0.11751243f, 
    -0.35320762f, -0.13038424f, 0.36025721f, 0.11321246f, 0.06343409f, -0.04856031f, 0.08240458f, 0.15393531f, 
    0.21986119f, -0.31143385f, -0.24800849f, -0.00348646f, 0.37920779f, -0.08587721f, 0.00356381f, -0.25429720f, 
    0.23849814f, -0.43331110f, 0.15410714f, -0.20089185f, -0.13792659f, -0.19701692f, 0.00702745f, 0.13314945f, 
    0.39333731f, -0.22835404f, -0.13213430f, -0.18986921f, 0.31207237f, -0.18935101f, -0.28780577f, -0.14526655f, 
    0.20730600f, -0.13360351f, 0.10084447f, 0.02955483f, 0.26270688f, -0.00724082f, 0.01766246f, 0.13189977f, 
    -0.31832498f, 0.62562245f, -0.07935558f, -0.08826783f, -0.12846117f, 0.84472597f, 0.13335991f, -0.22006820f, 
    -0.04583444f, 0.36265305f, 0.07397266f, 0.24541935f, 0.27342814f, 0.05071845f, 0.18228592f, -0.04511775f, 
    -0.08643679f, -0.00334661f, -0.11477379f, 0.32988355f, -0.12139944f, -0.48822299f, 0.18762660f, -0.17678294f, 
    0.43830347f, 0.17748491f, 0.62257302f, -0.13533370f, -0.12384294f, 0.00397703f, -0.09381159f, 0.23532856f, 
    0.25531361f, 0.17677189f, 0.05267372f, -0.06114384f, -0.01100164f, -0.08303078f, -0.08695158f, 0.13972537f, 
    0.27001506f, 0.02082364f, -0.02861338f, 0.25027978f, -0.08181965f, 0.22571854f, 0.02253654f, -0.17157573f, 
    0.18657020f, 0.38320002f, 0.01679811f, 0.26754093f, -0.04321194f, 0.19229105f, 0.08609938f, -0.12983268f, 
    -0.04778078f, 0.06246503f, -0.09644967f, -0.05906735f, -0.30737877f, -0.28178331f, -0.48984984f, -0.08195067f, 
    0.21494149f, 0.07049068f, 0.13679516f, 0.31638917f, 0.10958610f, 0.10543379f, 0.09598596f, -0.48705775f, 
    0.23648542f, -0.05274326f, -0.16107257f, 0.08299806f, -0.31558892f, -0.00433009f, 0.07015418f, 0.12985824f, 
    0.27562228f, 0.37424180f, 0.07752569f, -0.41325703f, 0.13425575f, 0.27762458f, 0.04016649f, -0.49695107f, 
    -0.32632136f, -0.00407475f, 0.22767641f, -0.04692351f, -0.00454867f, -0.11358164f, 0.17561118f, -0.16199924f, 
    0.09532861f, 0.18239194f, 0.07726274f, -0.23992141f, 0.54158556f, 0.16400769f, 0.03488474f, -0.37894034f, 
    -0.35937122f, -0.22014840f, -0.32734764f, -0.09028188f, 0.17588544f, 0.06698067f, -0.05261669f, -0.02776271f, 
    -0.47285423f, -0.46301955f, 0.36496547f, 0.12511516f, -0.04581389f, 0.01128292f, 0.16549024f, -0.07294073f, 
    0.23311284f, -0.31543052f, -0.19300289f, 0.10207711f, 0.02125444f, -0.03113403f, 0.09943694f, -0.47320971f, 
    -0.13499865f, -0.35407954f, 0.05145016f, -0.42071095f, 0.22573259f, 0.54400605f, -0.46763337f, -0.45890200f, 
    -0.11321021f, 0.26312792f, 0.02690310f, 0.01107914f, -0.01778767f, -0.20301972f, -0.16912758f, 0.03586993f, 
    -0.50738037f, 0.00308642f, -0.05934455f, 0.13446057f, -0.02856422f, -0.33172628f, 0.24772517f, -0.10039780f, 
    0.27685544f, 0.00663319f, 0.02714326f, 0.35487655f, 0.33250144f, 0.08865610f, -0.27180010f, -0.34699401f, 
    -0.09222484f, -0.33602089f, -0.21838397f, 0.13649905f, -0.08928432f, -0.03918890f, -0.05992570f, -0.05926716f, 
    0.11048383f, -0.07361387f, 0.04254802f, -0.12610811f, 0.04448008f, 0.25219414f, -0.21440870f, 0.20031883f, 
    0.08628061f, -0.57963169f, -0.18395385f, 0.05898231f, 0.25978133f, -0.06726035f, -0.04061405f, 0.14022505f, 
    -0.00370954f, 0.22708701f, 0.31553957f, -0.54088670f, -0.02745530f, -0.16669039f, 0.05913438f, -0.02696396f, 
    0.19894746f, -0.25356558f, 0.18488842f, -0.19375341f, -0.09716742f, 0.23205775f, -0.09529238f, 0.04410290f, 
    -0.11975276f, -0.08601609f, -0.09808740f, 0.03527318f, -0.19133043f, -0.19121979f, 0.03735167f, 0.21545263f, 
    0.12500830f, -0.06687617f, 0.03823354f, -0.31798932f, -0.13454340f, 0.36855426f, -0.01317475f, 0.26645508f, 
    0.37309694f, -0.19636959f, -0.68514949f, -0.00629481f, -0.10103741f, 0.06551535f, -0.33012280f, -0.35549164f, 
    -0.08554255f, 0.10725175f, 0.08357876f, 0.24765235f, 0.11819584f, -0.27163082f, 0.01811273f, 0.10287850f, 
    -0.04878652f, 0.38758314f, 0.23832414f, -0.10202160f, 0.00131640f, 0.34686852f, 0.00214220f, 0.08755682f, 
    0.29629457f, 0.08935024f, 0.06728460f, 0.06330726f, 0.12967630f, 0.25547770f, -0.10897011f, 0.28379530f, 
    -0.17562917f, 0.18644571f, -0.26677963f, -0.37649718f, -0.04662073f, 0.02433284f, 0.07265794f, -0.31358305f, 
    0.06076143f, -0.28934714f, -0.10567643f, 0.14142501f, 0.05291483f, -0.82794476f, -0.32022378f, 0.10485744f, 
    0.16095783f, -0.61288804f, -0.01803323f, 0.03861206f, -0.07733942f, 0.12404146f, -0.20563991f, -0.22154225f, 
    0.00789697f, 0.00461260f, 0.09409915f, -0.27743644f, 0.03587978f, -0.56314528f, 0.04926748f, 0.11091324f, 
    -0.65622663f, 0.02004328f, -0.02004734f, 0.27182451f, 0.11326573f, 0.05708600f, 0.10614960f, -0.22329591f, 
    -0.37534437f, 0.12190101f, -0.10642430f, -0.05068366f, 0.15332423f, 0.10743147f, 0.03229843f, 0.02678743f, 
    -0.04962080f, 0.12470790f, 0.07645361f, -0.04755723f, 0.08987195f, -0.03272458f, 0.07934719f, 0.12360965f, 
    0.03190812f, 0.62959224f, 0.03911183f, 0.11837887f, -0.00497813f, 0.18876550f, 0.11488306f, 0.46719760f, 
    0.06447273f, 0.17583601f, -0.25475538f, -0.09585530f, 0.03799868f, 0.26280800f, 0.15873820f, 0.11544117f, 
    -0.07113284f, 0.14939545f, -0.04591241f, -0.10234597f, 0.05425977f, 0.12153443f, 0.02982164f, -0.03972083f, 
    -0.06012348f, -0.34351224f, 0.20797576f, 0.17457807f, 0.24451359f, -0.20817322f, -0.01214312f, 0.09202456f, 
    -0.08589035f, -0.32763690f, -0.00864106f, -0.12768961f, -0.02136595f, -0.00093126f, 0.26629007f, 0.21317576f, 
    0.05611821f, 0.14344837f, -0.04127336f, -0.00544908f, -0.11506482f, 0.11186262f, 0.09465229f, -0.03028188f, 
    -0.11875213f, -0.02355902f, 0.02592795f, 0.19630589f, -0.29287091f, -0.05996533f, -0.03830097f, -0.02803326f, 
    0.25518471f, 0.11188184f, 0.03209732f, 0.32066140f, 0.08330522f, 0.01047043f, 0.00523901f, -0.03245947f, 
    -0.37665233f, 0.56062669f, 0.26947469f, -0.08630087f, 0.35077912f, -0.05853413f, -0.27949426f, 0.16487204f, 
    -0.10553219f, 0.15112841f, 0.05688031f, 0.00657958f, 0.05617794f, 0.12058454f, 0.02258891f, -0.02146352f, 
    0.01599298f, 0.17759748f, -0.04416954f, 0.10022384f, -0.17744902f, 0.04389862f, -0.06890047f, 0.19440855f, 
    -0.01320138f, 0.10236139f, 0.00128464f, 0.35526878f, 0.07749466f, 0.18956639f, 0.01312395f, 0.00108971f, 
    0.15155609f, 0.02096300f, -0.13820824f, 0.21022141f, -0.02751328f, -0.27851209f, -0.22398958f, 0.11156181f, 
    0.01408504f, 0.16943553f, 0.10865818f, -0.04054809f, -0.01019067f, 0.06677671f, 0.12447003f, 0.12233999f, 
    0.08398265f, 0.15708455f, 0.12575601f, -0.11735144f, 0.08503232f, 0.02023879f, 0.14076927f, 0.04245421f, 
    0.25693533f, 0.20113985f, -0.05064344f, 0.09336276f, -0.16893530f, 0.05389871f, 0.17073141f, -0.25249392f, 
    0.08233859f, 0.36256498f, 0.33122876f, 0.18822218f, -0.11824822f, 0.10015318f, 0.04432115f, 0.17010584f, 
    -0.07555405f, -0.10422453f, -0.04631194f, 0.17709221f, 0.20560405f, 0.45324284f, 0.03939544f, 0.35069138f, 
    0.23962530f, 0.09293125f, -0.12378836f, 0.03541489f, 0.07172732f, 0.13565035f, -0.08169772f, -0.03252276f, 
    0.04285537f, -0.10477336f, 0.38769975f, 0.15010653f, 0.29130438f, -0.11408051f, -0.08014764f, 0.06382862f, 
    0.10919529f, 0.10522201f, -0.02466043f, -0.07606455f, 0.29802105f, 0.03435314f, 0.07454204f, 0.00128213f, 
    -0.26576909f, 0.08688059f, -0.18236803f, -0.21729803f, -0.00022484f, -0.06779003f, 0.16271473f, 0.01863256f, 
    0.16374300f, 0.06871119f, 0.06910582f, -0.08680157f, 0.16710757f, -0.35565460f, -0.03874129f, -0.16726314f, 
    -0.09482574f, -0.15194580f, -0.17039290f, 0.10930167f, 0.14872760f, 0.07501939f, 0.38763487f, 0.31883466f, 
    -0.43450385f, 0.15548298f, 0.58187151f, -0.19778462f, 0.07708619f, 0.10838388f, -0.00024677f, -0.12708583f, 
    0.10132444f, -0.06058260f, -0.16710165f, 0.12309299f, 0.07422857f, -0.10191607f, -0.03909245f, 0.05635878f, 
    0.10174613f, -0.16714959f, 0.04903085f, 0.00137385f, 0.16079724f, 0.24813356f, -0.05735078f, -0.06696125f, 
    -0.00521244f, 0.20571285f, 0.05301524f, 0.11785863f, 0.17674790f, 0.09510182f, 0.12097809f, 0.06629199f, 
    0.55864435f, 0.07480910f, -0.20396534f, 0.16002524f, -0.02366054f, 0.00084014f, -0.13211003f, 0.15088071f, 
    -0.02592892f, 0.16055420f, 0.02076791f, 0.06510193f, 0.07199495f, 0.00714623f, -0.01322355f, 0.03797838f, 
    -0.02370000f, -0.13435698f, -0.06812288f, -0.05694628f, -0.02177457f, -0.26317626f, -0.12684590f, 0.09656233f, 
    0.03456855f, -0.27438536f, 0.08459236f, 0.15348874f, -0.00271398f, 0.10911134f, -0.65402836f, 0.14003554f, 
    0.06571673f, -0.09273884f, -0.07337199f, -0.12374699f, 0.10412862f, -0.09066743f, 0.05193386f, -0.07940081f, 
    0.06025719f, 0.19776520f, 0.20310752f, -0.08503997f, 0.00632123f, 0.03700923f, -0.54736304f, -0.44270381f, 
    -0.15106769f, -0.21226197f, 0.26598403f, 0.25192937f, 0.06959336f, -0.06870036f, 0.16664957f, -0.37298983f, 
    0.19835901f, -0.24392001f, -0.42248461f, 0.15376036f, 0.18598877f, 0.11967658f, 0.13937165f, -0.08534738f, 
    0.15684064f, 0.09900633f, 0.01393027f, 0.28732544f, 0.08623526f, 0.12285812f, -0.08272173f, -0.02965204f, 
    -0.03998665f, -0.27834460f, -0.09416196f, -0.04265596f, 0.13437380f, 0.03662765f, -0.00913959f, 0.05768416f, 
    -0.10728454f, -0.19596303f, -0.12099241f, -0.11468818f, -0.28327993f, 0.03782485f, 0.05611693f, 0.28306934f, 
    0.07886524f, -0.00014181f, 0.21352123f, -0.58177894f, -0.10757315f, -0.07594737f, 0.16641124f, -0.41540429f, 
    0.34162444f, -0.10351200f, -0.89000225f, -0.18010041f, -0.08120456f, 0.31564346f, 0.14955015f, -0.07975237f, 
    0.21645042f, 0.03763897f, -0.02074150f, 0.13635325f, -0.19916716f, 0.07847638f, 0.05161323f, -0.08422945f, 
    -0.17662464f, -0.08569505f, -0.01193771f, -0.15858321f, 0.11750655f, 0.16445775f, 0.02301208f, -0.37860504f, 
    -0.11532909f, -0.04314528f, -0.05890001f, -0.09707002f, 0.00566274f, 0.10179015f, -0.18266857f, -0.34154874f, 
    0.24336413f, 0.03299352f, 0.22898792f, -0.67154175f, -0.02846395f, 0.28420404f, 0.23374236f, -0.09725475f, 
    0.35966289f, -0.16356409f, 0.15481754f, 0.23649801f, -0.04350655f, -0.10525166f, 0.01110742f, -0.09333653f, 
    -0.28630000f, 0.03072495f, -0.07748302f, 0.04989325f, -0.02490163f, -0.01988452f, 0.02795354f, 0.04289715f, 
    0.04991188f, -0.04930554f, -0.03147825f, 0.00182712f, 0.02003727f, -0.00446835f, 0.03264927f, -0.02933522f, 
    -0.07761651f, 0.04092741f, 0.16631880f, 0.15125522f, 0.15005822f, -0.37608671f, 0.08061253f, 0.13616693f, 
    -0.06361990f, 0.08974494f, 0.16808575f, 0.14701816f, -0.17687291f, 0.25448227f, 0.09610603f, -0.25231069f, 
    -0.00987088f, 0.03535345f, 0.05345264f, -0.08066828f, 0.07300326f, -0.04332888f, 0.16077791f, -0.10643301f, 
    0.12064485f, 0.42703566f, 0.12498361f, -0.03793918f, -0.10180560f, -0.34689993f, 0.08247756f, -0.06890392f, 
    0.03858165f, -0.09099910f, -0.05244637f, 0.08109716f, 0.17465717f, 0.11094044f, -0.14649226f, -0.34477049f, 
    -0.04477717f, 0.07422725f, 0.08272317f, 0.28509045f, -0.12245508f, 0.19408762f, 0.23921981f, 0.17127357f, 
    0.24069861f, 0.00588999f, -0.05900147f, 0.02935647f, -0.05861062f, 0.17019977f, 0.01812997f, 0.18590017f, 
    0.22017810f, -0.06810772f, 0.24754550f, -0.10820241f, 0.18459718f, 0.19480950f, -0.39799497f, -0.07342967f, 
    0.45776847f, -0.02042829f, -0.17365286f, 0.22088543f, -0.01586236f, -0.42666849f, -0.22595528f, -0.09338032f, 
    0.24945675f, 0.03601700f, -0.29123902f, 0.21095821f, 0.00261125f, 0.08914893f, 0.12601727f, -0.09367659f, 
    -0.00361981f, 0.11715985f, -0.13961978f, -0.14893240f, 0.04321783f, 0.18298551f, -0.01457258f, 0.03459902f, 
    0.13150133f, 0.09090550f, -0.08508503f, -0.01004040f, 0.03551406f, -0.04582345f, -0.32884705f, -0.00728898f, 
    -0.44673491f, -0.02756683f, -0.12861350f, 0.16831437f, 0.15514688f, -0.56844163f, 0.25573850f, 0.16535048f, 
    0.07138964f, 0.08564910f, -0.01455481f, -0.03796462f, 0.09938596f, 0.03715481f, 0.02890602f, 0.23897286f, 
    -0.05499873f, -0.01797448f, -0.07868535f, -0.07953653f, -0.05849620f, -0.05966261f, 0.02896431f, 0.02079015f, 
    -0.03193557f, -0.01529145f, 0.06083417f, 0.03154273f, -0.07149609f, 0.06626501f, -0.02914426f, -0.03887486f, 
    -0.04045252f, 0.06837057f, -0.10987829f, 0.02022985f, -0.07953187f, 0.02561875f, -0.10234353f, -0.04896820f, 
    0.04815377f, 0.03072573f, -0.09123267f, -0.06720442f, -0.04719439f, 0.06006414f, 0.04178788f, 0.05660743f, 
    -0.11093241f, 0.00527296f, 0.01303836f, 0.05647969f, -0.08322567f, -0.06274617f, -0.01677963f, -0.05092189f, 
    -0.10857989f, -0.04845863f, 0.04789240f, -0.04457473f, 0.03874447f, -0.08359849f, -0.09356309f, -0.09796157f, 
    -0.07660529f, 0.04803395f, 0.05071568f, -0.05625849f, 0.00110319f, -0.07310746f, 0.04319405f, -0.07214867f, 
    0.00627844f, -0.07226732f, -0.02665568f, -0.08639394f, 0.04555547f, -0.00645522f, -0.03122939f, -0.01388840f, 
    -0.07309912f, 0.00134300f, -0.10287853f, 0.03486726f, 0.04015646f, -0.05115337f, -0.06145190f, 0.00912932f, 
    -0.06920143f, -0.01274108f, -0.10963096f, -0.07175363f, 0.05621829f, 0.03708725f, -0.05577500f, 0.01640018f, 
    0.07722806f, -0.00281273f, 0.00227836f, 0.05326967f, -0.04293906f, 0.08056844f, 0.00075732f, -0.01251091f, 
    -0.11248837f, -0.01004061f, -0.07522140f, 0.01882066f, -0.02561477f, 0.00518122f, -0.03908690f, -0.07088406f, 
    0.00829900f, 0.06266561f, -0.08612785f, -0.06239265f, 0.00653521f, -0.02303296f, 0.04409335f, -0.02294906f, 
    0.02501433f, 0.03737291f, -0.05766819f, -0.00126091f, -0.02677312f, -0.07222401f, -0.06992669f, -0.08656235f, 
    0.00317039f, 0.00270308f, -0.01283024f, 0.01489326f, -0.08504363f, -0.02142288f, 0.01108667f, 0.03298654f, 
    0.04699415f, 0.04165932f, -0.04020875f, -0.11269457f, -0.02955648f, -0.03986061f, 0.03920147f, 0.02170979f, 
    0.54028744f, 0.00504329f, 0.24590307f, -0.10690375f, 0.08739711f, -0.04781960f, -0.13678232f, -0.14445764f, 
    0.00632445f, 0.08221626f, -0.04652573f, 0.18438603f, -0.22507536f, 0.04729689f, 0.18093328f, 0.02817755f, 
    -0.05695376f, 0.85919201f, 0.21620683f, 0.26202691f, 0.36980790f, -0.33986807f, 0.11769406f, 0.14525373f, 
    0.02238144f, -0.03963051f, 0.39378595f, -0.19892742f, -0.30151537f, 0.15793771f, -0.00402740f, 0.45695469f, 
    0.01194438f, 0.13761102f, 0.29697686f, 0.09390461f, -0.09739514f, 0.16595571f, -0.08464046f, -0.03161749f, 
    -0.01362703f, -0.20886126f, 0.11614996f, -0.36807692f, -0.70169580f, -0.02504679f, -0.13626431f, 0.24674056f, 
    0.18538281f, -0.14244206f, -0.01690309f, -0.65762186f, 0.31367055f, 0.08845679f, 0.16559960f, 0.09095905f, 
    -0.14348227f, 0.23600204f, 0.18441670f, 0.05455507f, -0.03898653f, 0.03335074f, 0.24959269f, -0.07402717f, 
    -0.11447000f, 0.19772579f, 0.08234322f, 0.10556836f, 0.60174650f, 0.03542642f, 0.05698017f, 0.15098320f, 
    -0.04216839f, -0.05605097f, -0.16134924f, 0.34313598f, 0.16797027f, 0.22541229f, 0.20933306f, -0.19191070f, 
    -0.09224465f, 0.02621220f, 0.28913745f, 0.16109723f, 0.17314124f, -0.58199012f, -0.21735600f, 0.04012779f, 
    0.10916750f, -0.07898742f, -0.19165722f, -0.44623855f, 0.03563760f, -0.16424024f, -0.01439513f, 0.02277967f, 
    0.08323186f, -0.15497714f, -0.08051442f, -0.01105260f, 0.09851972f, 0.35103378f, -0.55131060f, -0.05972377f, 
    -0.03324911f, -0.01501658f, 0.05364196f, 0.12958065f, 0.02629207f, 0.03976968f, 0.08134332f, 0.13529745f, 
    0.04608138f, 0.03025420f, -0.21842457f, 0.22710720f, -0.10127995f, -0.03143032f, -0.20413521f, 0.02297997f, 
    0.10480209f, 0.11184052f, -0.16425040f, 0.12628041f, -0.03668740f, 0.10869887f, -0.09987487f, -0.24374814f, 
    0.05238556f, 0.00873487f, 0.01283998f, -0.06143186f, -0.09236851f, -0.00132641f, -0.04809863f, 0.02256821f, 
    0.06804039f, -0.02823019f, -0.08427790f, -0.04419604f, 0.00881883f, -0.03236574f, -0.02990881f, 0.04197272f, 
    -0.05639174f, -0.06189952f, -0.01608883f, -0.09073376f, 0.03475343f, -0.01209731f, -0.04267235f, -0.03221175f, 
    0.07168721f, -0.05083620f, -0.06161135f, -0.09770565f, -0.05117679f, -0.05725811f, -0.00756458f, -0.07256187f, 
    -0.01305139f, -0.00653502f, -0.07758760f, -0.02969719f, -0.05188752f, 0.01205730f, -0.02331899f, -0.08537684f, 
    -0.08878435f, -0.03105148f, -0.03801154f, -0.01821860f, -0.02669611f, -0.03984619f, 0.01638110f, -0.04968517f, 
    0.06648695f, -0.05589911f, 0.04815804f, -0.06712722f, 0.00545942f, -0.05275395f, 0.06336377f, 0.04461385f, 
    -0.01521174f, -0.04555029f, -0.07521436f, 0.00867652f, 0.02010128f, 0.07130977f, 0.04743366f, 0.05338571f, 
    0.00317171f, 0.06471090f, 0.05759724f, -0.08406524f, 0.02273713f, -0.02871177f, -0.00162532f, -0.07125112f, 
    0.05004796f, 0.00921073f, -0.02301699f, -0.04844644f, -0.09211364f, -0.09594490f, -0.00983561f, -0.06515159f, 
    -0.07366832f, -0.10638922f, 0.05502547f, 0.05260879f, 0.05811897f, -0.04236009f, 0.04374722f, 0.04967963f, 
    -0.02611955f, -0.02811567f, -0.07594342f, 0.00352137f, -0.08145320f, -0.02819975f, 0.06069137f, 0.00623195f, 
    0.05281460f, 0.01722864f, -0.07748196f, -0.02894286f, -0.03423437f, -0.00068771f, -0.07110322f, 0.06238912f, 
    0.01331419f, -0.08482870f, -0.08575751f, 0.00258519f, 0.01520936f, -0.01730368f, -0.10541915f, 0.04927648f, 
    0.02433018f, 0.04873702f, 0.01653748f, 0.01530506f, -0.01026725f, -0.00221918f, 0.02535543f, -0.02064534f, 
    -0.06817077f, -0.01428888f, 0.04284477f, -0.03091915f, -0.03860725f, -0.09577623f, 0.05179874f, 0.01578856f, 
    -0.02107339f, 0.14145359f, -0.15648204f, 0.13319038f, 0.04574840f, -0.11635996f, -0.25779977f, 0.03743662f, 
    -0.05281870f, -0.24911869f, -0.00950726f, 0.28316560f, -0.18971759f, 0.04216235f, -0.16705418f, 0.08340001f, 
    -0.20726426f, 0.63171351f, 0.00521539f, 0.17331247f, 0.42502788f, -0.24034455f, 0.31874940f, 0.27683479f, 
    0.00438611f, 0.20536301f, 0.33910021f, -0.14725384f, -0.65418041f, 0.15346156f, -0.37066025f, 0.20977803f, 
    0.02279447f, 0.15446994f, 0.58102930f, 0.39922646f, -0.01648547f, 0.08171850f, 0.04291129f, -0.35477456f, 
    0.02338088f, 0.21144223f, -0.06065457f, -0.25668317f, -0.72607857f, -0.20763773f, 0.00820147f, 0.07473172f, 
    0.28359255f, 0.13602784f, 0.06632935f, -0.13004346f, 0.44669384f, 0.08322237f, -0.09202000f, -0.01421375f, 
    -0.11566503f, 0.05422275f, 0.22718535f, 0.33378857f, -0.13541567f, 0.11306242f, 0.16544999f, -0.30293941f, 
    -0.01820619f, -0.11286134f, 0.04524409f, 0.13467734f, 0.64864868f, 0.09193966f, 0.08548657f, 0.16480064f, 
    0.15003926f, 0.04754404f, 0.35776067f, 0.16689943f, -0.16031891f, 0.11474849f, 0.22150521f, 0.40168464f, 
    0.71335095f, -0.12581359f, -0.02293064f, 0.21153639f, 0.27680227f, -0.88107026f, -0.24746779f, 0.00034343f, 
    0.05264459f, -0.03954603f, -0.19812678f, -0.07949159f, 0.15111478f, -0.11517416f, 0.00527159f, -0.06956596f, 
    -0.01627223f, 0.40585044f, -0.36542180f, -0.18507802f, -0.12557833f, 0.39412868f, -0.27081260f, -0.38039941f, 
    -0.10410757f, 0.04964957f, -0.06058489f, 0.10789728f, -0.08842331f, 0.00643172f, -0.19148426f, 0.13365036f, 
    0.12130935f, -0.05543885f, -0.39663851f, 0.24071944f, 0.02064229f, -0.29320535f, 0.16466404f, -0.05154400f, 
    0.26513758f, -0.18598384f, 0.28809741f, 0.13188615f, 0.33321524f, 0.19505033f, -0.20031014f, -0.26286557f, 
    0.00718879f, -0.06633627f, 0.05143562f, -0.11030388f, -0.12062612f, 0.05722906f, 0.02369257f, -0.14217760f, 
    -0.13134758f, 0.00590079f, 0.06542090f, -0.03746681f, 0.05686584f, -0.08392217f, 0.01389952f, -0.10159853f, 
    -0.14489636f, -0.06556297f, -0.05513883f, -0.16090253f, -0.03350611f, 0.04119809f, -0.12235676f, -0.00262697f, 
    -0.08200010f, -0.12422353f, 0.02674347f, 0.02425083f, 0.07449611f, 0.15555316f, 0.03680542f, 0.03027019f, 
    0.04750605f, -0.02690632f, -0.03293462f, -0.11844599f, -0.01077938f, -0.02184451f, 0.03302746f, -0.01850715f, 
    0.00361850f, 0.03297132f, -0.05303641f, 0.02672815f, -0.00148597f, -0.00987093f, 0.01042489f, -0.07717527f, 
    -0.11920027f, 0.03708589f, -0.06934441f, -0.04917679f, 0.13852558f, -0.11195005f, -0.00861188f, -0.06008393f, 
    -0.06792147f, 0.03384813f, 0.03950435f, -0.05495358f, -0.05214569f, -0.02015068f, 0.01856615f, 0.01340034f, 
    -0.07067871f, 0.05615935f, -0.05664834f, -0.07245895f, 0.06849740f, 0.03504798f, 0.06887024f, -0.03866984f, 
    -0.07674617f, 0.05885072f, -0.05430308f, -0.02536774f, -0.01293532f, -0.13148184f, 0.03304847f, 0.13624398f, 
    -0.01054987f, 0.04760267f, -0.15553741f, -0.00121860f, -0.06238229f, 0.00061238f, -0.04880642f, -0.03148618f, 
    -0.04610074f, -0.04785455f, -0.10748443f, -0.05059088f, 0.01081717f, -0.04012466f, -0.01713993f, -0.08579733f, 
    -0.02732346f, -0.09978025f, -0.06816839f, 0.04467281f, -0.10940569f, -0.20644045f, 0.02323181f, -0.08119133f, 
    -0.12388060f, -0.04221841f, 0.06005578f, -0.15754457f, -0.05795213f, -0.04497084f, 0.05917100f, -0.05874811f, 
    0.07102030f, -0.00110811f, -0.03227648f, -0.01273562f, -0.08849169f, 0.04062035f, 0.02915166f, -0.09837832f, 
    -0.06045215f, -0.08329397f, -0.09178692f, -0.02793524f, -0.12836754f, -0.12588111f, -0.05024630f, -0.05910960f, 
    -0.10837586f, -0.06848498f, 0.00948674f, -0.05921537f, -0.07994680f, -0.07807240f, -0.12546229f, -0.11091515f, 
    -0.02964969f, -0.07445800f, 0.00572902f, 0.00917190f, 0.04936681f, 0.03343499f, 0.05428131f, -0.02776932f, 
    -0.03874294f, 0.04456643f, -0.04389020f, -0.03939248f, 0.09228469f, -0.12158341f, -0.01615014f, -0.11129192f, 
    -0.06372453f, -0.07211428f, 0.01450713f, -0.05501084f, 0.08308247f, -0.00239918f, -0.00124683f, 0.05156431f, 
    0.06042405f, -0.10305820f, 0.02789247f, 0.02267602f, 0.01652362f, -0.04351966f, -0.04248479f, -0.03058888f, 
    -0.04039767f, -0.05096301f, -0.01142738f, -0.00254038f, 0.10539829f, -0.10862818f, -0.01889419f, -0.07048629f, 
    -0.01305974f, 0.03919532f, -0.00326766f, 0.03200722f, -0.07446332f, 0.01402367f, 0.04114850f, -0.02479726f, 
    0.02490218f, -0.02733299f, -0.06376202f, -0.01878466f, -0.05355816f, -0.11782907f, 0.00665534f, 0.03492928f, 
    0.01130779f, 0.04018271f, -0.03754807f, 0.01711563f, -0.01751086f, -0.05871218f, -0.05191319f, -0.07716095f, 
    -0.04364726f, 0.05003197f, -0.11754216f, 0.07982366f, -0.07359307f, -0.09552033f, -0.01568272f, 0.04874163f, 
    0.04005795f, -0.03594366f, -0.05562956f, -0.10369412f, -0.05237761f, -0.01833157f, -0.00914619f, 0.02334618f, 
    -0.02058443f, -0.01866951f, 0.07094661f, -0.08258304f, 0.08802158f, -0.02536684f, 0.01495278f, -0.04843087f, 
    0.00256310f, 0.07060458f, -0.06059824f, -0.04466442f, 0.00341108f, 0.04447855f, 0.04636738f, -0.12634394f, 
    -0.01894641f, -0.01576112f, -0.01856613f, -0.03191303f, -0.08410786f, 0.02808951f, 0.04077291f, 0.03719388f, 
    -0.09501708f, 0.04562022f, -0.02162822f, -0.00276979f, -0.06437039f, 0.07388528f, -0.05183733f, 0.00726852f, 
    -0.03539300f, -0.10477720f, 0.06367213f, -0.02798994f, -0.02622516f, -0.05531671f, -0.09813196f, -0.04818574f, 
    -0.15600954f, -0.37535492f, -0.04537714f, 0.07198523f, 0.06332886f, -0.08218921f, 0.11317946f, 0.01370827f, 
    0.02505692f, -0.02204285f, -0.01036150f, 0.03247342f, 0.01799675f, 0.17577925f, -0.10227177f, 0.18895079f, 
    -0.12591325f, -0.06364329f, 0.28845155f, 0.07812070f, 0.18751641f, 0.04839629f, 0.06512894f, 0.21687704f, 
    -0.02782371f, 0.13642421f, -0.13753125f, -0.35706878f, -0.13011576f, 0.18137448f, 0.04359847f, 0.11233725f, 
    -0.07289597f, -0.20027083f, 0.07403806f, 0.08995705f, -0.00394220f, 0.09154981f, 0.12213456f, -0.04194870f, 
    -0.00341659f, -0.04045855f, -0.07536710f, 0.05684619f, -0.03447065f, -0.26145113f, 0.11688181f, 0.25314519f, 
    -0.01805819f, -0.15433808f, 0.04206065f, -0.04258964f, 0.06699819f, 0.21086711f, 0.06455120f, -0.05507757f, 
    0.20933495f, -0.03613555f, -0.27066123f, 0.08422459f, 0.01490570f, 0.10919832f, -0.03660502f, -0.00440379f, 
    0.10001526f, 0.09769623f, 0.07820043f, 0.13479567f, -0.34576565f, 0.12457036f, -0.10215260f, 0.13515437f, 
    0.18112504f, 0.22397701f, 0.00789294f, 0.03448294f, 0.17259003f, 0.15463142f, -0.04525601f, -0.35943130f, 
    0.42465311f, 0.10359187f, -0.12695286f, 0.14169271f, 0.14790946f, -0.16757710f, -0.05772178f, 0.04883568f, 
    0.30191815f, 0.02424251f, -0.24811058f, 0.22861384f, -0.06893887f, 0.00158751f, 0.06820744f, -0.04009392f, 
    0.00366762f, -0.48574033f, -0.04871067f, 0.03169147f, 0.09379666f, 0.07484545f, -0.28011003f, 0.07251624f, 
    0.08383535f, -0.29062405f, 0.03622965f, 0.16572903f, -0.04299713f, 0.05983713f, -0.43213400f, 0.06389010f, 
    0.40765864f, -0.03916957f, -0.07301354f, -0.16604644f, 0.10941727f, -0.35578701f, 0.27879548f, 0.21889621f, 
    -0.00851274f, 0.13020624f, -0.28621840f, 0.14833228f, 0.01794807f, -0.05707023f, 0.23111299f, -0.17136806f, 
    -0.09202080f, 0.02970115f, 0.00434137f, 0.02068753f, -0.02087968f, -0.07379619f, -0.08548591f, -0.10139161f, 
    0.03665971f, 0.06538169f, 0.06060365f, 0.05892497f, 0.04847312f, 0.06686937f, 0.01074419f, -0.03295736f, 
    0.07352377f, -0.07576022f, 0.04903966f, 0.01193097f, 0.06410416f, 0.00036330f, 0.01936517f, 0.04884091f, 
    -0.06326022f, 0.04719635f, -0.06807728f, -0.08353247f, -0.03898817f, -0.00594940f, 0.01995497f, -0.06402986f, 
    -0.04029077f, 0.02728822f, -0.04616591f, -0.05505811f, -0.01914641f, 0.01824779f, -0.01771546f, 0.02008711f, 
    -0.03825616f, 0.07737352f, -0.05063275f, -0.04391871f, -0.04834663f, 0.05989781f, 0.04712627f, 0.03068119f, 
    -0.08853213f, 0.05627607f, 0.00483249f, -0.10520123f, 0.07243196f, 0.11018730f, 0.02722052f, -0.08685801f, 
    -0.08456122f, 0.04929993f, 0.01752847f, -0.03516558f, -0.03946943f, 0.01758027f, -0.06468177f, -0.09507438f, 
    0.08096563f, 0.01541603f, -0.04007347f, -0.03807081f, 0.00545823f, -0.02550213f, 0.03854493f, -0.00615249f, 
    -0.02849062f, -0.04799825f, -0.05765757f, 0.00381975f, 0.05879347f, -0.00440986f, -0.09876769f, 0.06782181f, 
    -0.07022242f, -0.04070485f, -0.05869435f, -0.10211948f, -0.05721453f, -0.08233830f, -0.05296081f, -0.05418144f, 
    0.04711911f, 0.05657403f, -0.02216372f, -0.06260501f, -0.03301158f, 0.00230739f, -0.02664666f, 0.02242460f, 
    -0.01115346f, -0.05010473f, 0.01456474f, -0.08027865f, -0.00071652f, 0.05290125f, -0.01342403f, -0.00509007f, 
    -0.03252539f, 0.05146763f, 0.06755958f, -0.06121643f, -0.08353388f, 0.04229210f, 0.02679226f, -0.05829339f, 
    0.08775353f, 0.02727178f, -0.07534327f, 0.06815388f, 0.01770298f, 0.01261349f, -0.07619300f, 0.03948519f, 
    -0.05013501f, 0.05339308f, -0.03623826f, -0.05122008f, -0.08356433f, -0.08538043f, 0.00664932f, 0.05956474f, 
    -0.18519865f, 0.01550477f, 0.02726487f, 0.03296006f, -0.10253198f, 0.10022470f, -0.03271108f, -0.01931034f, 
    -0.05085788f, 0.16431950f, 0.00074427f, -0.18952344f, -0.11417241f, 0.01568031f, 0.19985844f, -0.15891999f, 
    0.33739603f, 0.16936849f, 0.03945129f, -0.02621604f, -0.48800150f, 0.71742195f, -0.02802112f, -0.09445613f, 
    -0.07616007f, 0.06696989f, -0.42905375f, 0.22562757f, 0.14099088f, -0.13476488f, 0.20121019f, -0.18908276f, 
    0.18600881f, 0.07788301f, -0.09042341f, -0.28587624f, 0.16943260f, -0.13133512f, 0.18162765f, -0.05101817f, 
    -0.18274117f, 0.23428875f, 0.13974249f, 0.12755480f, 0.27351460f, 0.02446543f, -0.04948945f, -0.10820556f, 
    -0.09259012f, 0.67652774f, -0.08030093f, 0.15862148f, 0.50918579f, 0.11972089f, 0.13663150f, -0.61608344f, 
    -0.11553025f, 0.23326622f, 0.05522664f, 0.00729329f, -0.27074343f, -0.01858642f, 0.17690313f, 0.12570490f, 
    0.23646018f, 0.21849187f, -0.02789420f, -0.11491855f, 0.20273258f, 0.04464562f, -0.00159083f, -0.19826487f, 
    0.00903584f, -0.09286226f, -0.08356915f, 0.49742126f, 0.24390067f, 0.09470890f, -0.45131099f, 0.21816407f, 
    -0.28004348f, 0.38754320f, 0.08875949f, -0.00707117f, -0.15268949f, 0.14306000f, -0.30843183f, 0.03839044f, 
    0.18435542f, -0.00415401f, -0.20496735f, -0.04527661f, -0.08237474f, 0.03240859f, -0.00952129f, 0.04928558f, 
    0.30902827f, 0.23832045f, -0.10302765f, 0.10532284f, -0.10825152f, 0.42840528f, 0.25101310f, 0.07636749f, 
    0.08532698f, 0.28951004f, 0.08714261f, -0.06316121f, -0.15249842f, 0.01131947f, -0.06939438f, -0.13895215f, 
    -0.00642577f, -0.09850051f, 0.12282018f, -0.06911165f, 0.00044109f, 0.19441225f, -0.36912873f, 0.19282848f, 
    0.18165076f, -0.06499589f, -0.19467744f, 0.00306427f, 0.12474493f, 0.29021844f, 0.08939750f, -0.05488927f, 
    -0.06775770f, -0.09826083f, -0.10324438f, 0.05105213f, -0.07625102f, 0.02058377f, -0.08578271f, -0.08151470f, 
    -0.06961469f, 0.03675918f, 0.08860441f, -0.08665170f, 0.06493952f, 0.00493797f, -0.10194615f, -0.04462976f, 
    -0.02923081f, -0.03123445f, 0.04334733f, -0.08774851f, -0.03135636f, -0.02194698f, 0.02675356f, -0.12375647f, 
    -0.03759060f, -0.07985825f, 0.05429975f, 0.08484451f, -0.04944332f, 0.01601939f, 0.04339036f, -0.07977633f, 
    -0.05628029f, -0.04334805f, -0.05784689f, -0.00505514f, -0.06087220f, -0.03810888f, -0.07514776f, -0.03503048f, 
    0.01074536f, 0.02505442f, -0.02502131f, -0.09318687f, -0.07465539f, -0.07477134f, 0.01637547f, -0.01118302f, 
    0.05767789f, -0.07371711f, -0.01414940f, -0.05651556f, -0.03863036f, -0.05282959f, -0.05965698f, -0.08290765f, 
    -0.01323762f, 0.01051116f, -0.01395962f, -0.01078966f, -0.00568353f, 0.00912649f, -0.05705282f, 0.03076416f, 
    -0.00866026f, -0.13652645f, 0.01733598f, -0.00285525f, 0.08048815f, 0.04288308f, -0.00329468f, -0.03121775f, 
    0.05752866f, -0.01612783f, 0.04350922f, 0.01871963f, -0.10694377f, -0.02248521f, -0.12310472f, -0.04100421f, 
    0.06153669f, 0.03752316f, -0.01694514f, -0.04591955f, -0.12769173f, -0.07242955f, -0.12075155f, 0.03394073f, 
    -0.00221794f, -0.10902900f, 0.05274059f, 0.02939345f, 0.01978762f, -0.02010374f, -0.08292736f, 0.05028450f, 
    -0.07128391f, -0.04920757f, -0.01068204f, -0.12657470f, -0.03444777f, -0.05087008f, -0.02403973f, -0.03320736f, 
    -0.04787675f, 0.01424556f, -0.04784711f, 0.00313239f, -0.00430638f, 0.01779106f, 0.02922210f, 0.01917038f, 
    -0.09221464f, -0.07263541f, -0.12291727f, -0.06755235f, -0.10976581f, -0.07287381f, -0.03482663f, -0.05741132f, 
    -0.00423928f, -0.07060292f, 0.05476101f, -0.09247078f, 0.00727351f, 0.01335862f, 0.01765792f, 0.04972401f, 
    -0.07015447f, -0.07956395f, -0.06365544f, 0.04223346f, 0.00783625f, -0.02486502f, -0.05809741f, -0.04555400f, 
    -0.08796377f, -0.01779118f, -0.04222896f, -0.05110020f, 0.03980634f, -0.07143182f, 0.01485054f, 0.04362211f, 
    -0.04392353f, -0.04962865f, 0.05474244f, -0.04326192f, -0.00893255f, -0.05396897f, -0.09925114f, -0.03116700f, 
    -0.00013567f, -0.06527124f, -0.03910482f, 0.04313213f, 0.05258638f, -0.08097079f, -0.00737003f, 0.02896363f, 
    -0.10394859f, -0.05071510f, -0.06712771f, -0.09579388f, -0.09787500f, -0.00952414f, -0.02628275f, -0.07566893f, 
    -0.02004712f, -0.00875213f, 0.05014693f, -0.01376599f, -0.01967158f, 0.01856219f, -0.00849108f, -0.07708044f, 
    0.05828355f, 0.03961848f, 0.03628180f, -0.00472041f, -0.07331409f, 0.05877955f, -0.05832689f, 0.06118739f, 
    -0.03024114f, 0.04373674f, -0.07144270f, 0.03837016f, 0.03803143f, -0.07650166f, -0.02712134f, -0.09207645f, 
    -0.01717975f, 0.02928619f, 0.02442329f, -0.10678933f, -0.05200762f, -0.07209028f, 0.06632791f, -0.07549287f, 
    -0.10619044f, -0.05403922f, -0.06276478f, -0.06459405f, 0.05601510f, 0.05264876f, 0.00577889f, 0.05570287f, 
    -0.03061768f, 0.02004020f, -0.06219254f, -0.10149436f, -0.03715580f, -0.04549204f, -0.00760949f, -0.00158037f, 
    -0.06028074f, 0.06194336f, -0.10479038f, -0.09635387f, 0.06338179f, -0.04451638f, -0.01627887f, -0.07323577f, 
    0.02353537f, -0.01173360f, -0.05389320f, -0.04176017f, 0.03123122f, 0.02232992f, 0.01146832f, 0.06182668f, 
    0.04417743f, 0.04215217f, -0.02553288f, -0.08385812f, -0.06756026f, -0.08554235f, 0.05436200f, -0.02848482f, 
    0.05706224f, 0.06246170f, -0.08061998f, -0.02666731f, 0.02736146f, -0.01173863f, -0.06774267f, -0.08285375f, 
    0.03378751f, 0.05427048f, -0.03420057f, -0.10132584f, -0.02328463f, -0.06565519f, -0.01431432f, -0.09367516f, 
    -0.06771249f, 0.00227418f, -0.10898183f, -0.04268339f, -0.04810705f, 0.00919330f, -0.06258045f, 0.01303104f, 
    -0.07290867f, 0.06453749f, -0.02730324f, -0.11115476f, -0.02966225f, -0.02530956f, -0.01547353f, -0.03190162f, 
    -0.05083722f, -0.03715544f, 0.06354552f, -0.07908398f, -0.05870469f, -0.00205246f, -0.00671496f, -0.00955443f, 
    -0.08531413f, 0.03869091f, -0.06792136f, 0.05412532f, 0.02704677f, -0.05664023f, 0.02337108f, -0.00921268f, 
    0.07562356f, -0.09884165f, 0.03860803f, 0.00929107f, -0.07988443f, -0.09840622f, -0.00055166f, -0.05634654f, 
    -0.09672332f, -0.01354482f, 0.01073187f, -0.03326435f, -0.00052168f, -0.06924031f, -0.03586487f, -0.08340970f, 
    0.04579636f, 0.07878362f, 0.06274633f, 0.02609003f, 0.00570947f, -0.06710043f, 0.03428092f, 0.05121291f, 
    -0.02923643f, -0.03072943f, -0.04654388f, -0.05490213f, 0.00069649f, -0.10080434f, 0.06551816f, -0.09325235f, 
    -0.05234673f, -0.09559827f, 0.01846976f, -0.07902746f, 0.02210645f, 0.02213021f, -0.08463547f, -0.07810299f, 
    -0.00940474f, 0.05125408f, -0.05504866f, -0.02815459f, 0.01666336f, 0.05696904f, -0.10243915f, -0.06014502f, 
    -0.04913817f, 0.05028913f, 0.01066564f, -0.09385546f, 0.06344761f, 0.05303102f, -0.01866161f, 0.04364416f, 
    0.02804871f, 0.04083146f, -0.08873271f, -0.03552204f, -0.02050810f, -0.08305713f, 0.05692187f, -0.01711499f, 
    -0.08189003f, -0.07731821f, -0.06736290f, 0.05382060f, -0.09719517f, -0.10418364f, -0.12472080f, -0.07703227f, 
    -0.07600270f, -0.01088113f, -0.08326152f, 0.01330021f, -0.08650870f, -0.01639459f, 0.00690861f, 0.04790752f, 
    0.09520119f, -0.03526979f, -0.06500199f, -0.03648380f, -0.00406458f, -0.08504284f, -0.07721867f, -0.04085592f, 
    0.00468820f, -0.10108090f, -0.10778908f, 0.01843607f, -0.02957057f, 0.04309194f, -0.04287254f, 0.00331683f, 
    -0.09387298f, -0.02508126f, 0.00972300f, -0.03612273f, -0.09557110f, -0.10241224f, -0.03957891f, 0.01398716f, 
    0.04924514f, 0.01203707f, -0.08749131f, -0.02041477f, -0.05264228f, -0.03560425f, -0.04983280f, -0.02883392f, 
    -0.06153668f, 0.03463892f, 0.00443826f, -0.06489284f, -0.02922441f, -0.04921897f, -0.06946361f, 0.05373859f, 
    -0.00335378f, 0.01055876f, 0.05424364f, 0.08028730f, 0.03947632f, 0.06782921f, -0.00555255f, -0.02080839f, 
    0.01819939f, -0.06806610f, -0.03909572f, -0.09704895f, -0.00826127f, -0.00429225f, 0.03248812f, -0.01134794f, 
    0.00072414f, -0.02779728f, -0.07699621f, -0.03350442f, 0.06771246f, -0.00443530f, -0.11388618f, -0.07903701f, 
    0.05427650f, 0.01724672f, -0.08736384f, -0.09428290f, 0.05294653f, -0.02466581f, -0.05666562f, -0.08386138f, 
    0.03540605f, 0.00060411f, -0.04243623f, -0.11563316f, -0.08635338f, 0.00465834f, -0.01782581f, -0.10594067f, 
    -0.00373913f, -0.00888309f, -0.04852300f, -0.09884578f, -0.05145962f, -0.10948754f, 0.08103364f, -0.08077849f, 
    0.01397671f, -0.07694183f, -0.11312172f, -0.01607984f, -0.03483447f, -0.10825964f, -0.04611468f, -0.05757365f, 
    -0.00904412f, -0.01492589f, -0.04525208f, 0.01339764f, -0.04417509f, -0.01786594f, -0.05109264f, 0.04033136f, 
    -0.01830088f, -0.07088072f, -0.03603872f, 0.00017312f, -0.03999600f, -0.10692888f, 0.00359224f, -0.02240168f, 
    -0.06771645f, -0.07677491f, -0.09627737f, -0.04846074f, 0.00819678f, 0.05464782f, -0.06681350f, -0.07092654f, 
    -0.10093111f, -0.07171234f, 0.02671267f, -0.03345379f, -0.07248361f, -0.07801127f, 0.06075740f, -0.06434256f, 
    -0.05851302f, -0.03932082f, -0.10371116f, 0.08571900f, 0.00937870f, -0.07177683f, -0.06954298f, 0.02750130f, 
    -0.06535002f, -0.10502767f, -0.07192949f, 0.02523283f, -0.06485990f, -0.02565841f, 0.00910352f, 0.00410711f, 
    -0.16479813f, -0.05828393f, -0.11090039f, 0.16034526f, 0.07378510f, 0.02494376f, 0.16007553f, 0.02636111f, 
    0.00035747f, -0.01436190f, 0.02662742f, 0.36314231f, -0.15403222f, 0.02920364f, 0.16356754f, 0.15503661f, 
    -0.15285608f, 0.34784213f, 0.21392825f, 0.26746538f, 0.41868496f, -0.03102743f, 0.29243115f, 0.32592461f, 
    -0.05516111f, -0.15482748f, -0.39768565f, -0.06782836f, 0.23010665f, 0.17362924f, -0.01048404f, 0.23654185f, 
    0.22411855f, 0.04779922f, -0.04059279f, 0.24722417f, -0.03450776f, -0.04246065f, -0.07888617f, 0.04382057f, 
    -0.11072606f, -0.30073085f, 0.04966571f, -0.21186316f, 0.00514626f, -0.37981725f, -0.06171485f, 0.17905055f, 
    -0.06079245f, -0.33304730f, 0.06082085f, -0.00269905f, 0.19061334f, 0.13047655f, 0.04402975f, 0.21293154f, 
    0.00507555f, -0.00872057f, -0.04304411f, 0.02044492f, 0.05940877f, -0.00821931f, 0.05524164f, -0.03382943f, 
    0.16900036f, 0.02749938f, 0.02758908f, 0.06214536f, -0.10406977f, -0.12106372f, 0.09048858f, -0.28438193f, 
    -0.01412965f, 0.05374378f, 0.20387265f, -0.01972453f, -0.16394964f, 0.15517248f, 0.12596342f, 0.58894843f, 
    0.11949579f, -0.12229060f, 0.14436698f, 0.07266822f, 0.26287746f, -0.25603509f, -0.35444590f, -0.07653245f, 
    0.04415449f, -0.00853053f, 0.02326935f, 0.20626980f, 0.26095778f, 0.09497178f, -0.02154152f, -0.00971691f, 
    0.18457542f, -0.35630265f, -0.11033771f, 0.05347458f, -0.15321273f, 0.15479831f, -0.09860393f, 0.03490391f, 
    0.05893101f, -0.08752362f, 0.03626809f, 0.27590588f, 0.07726581f, -0.05945634f, -0.04316968f, -0.05668068f, 
    0.03849985f, 0.07452814f, -0.37965074f, -0.02016374f, -0.06134340f, -0.30818078f, 0.06553575f, 0.10368130f, 
    -0.03077625f, 0.09929419f, 0.23786871f, 0.08620510f, -0.06617705f, 0.15368040f, 0.13483971f, -0.10829982f, 
    -0.15955420f, 0.24578220f, -0.14247292f, 0.07771119f, 0.02925987f, -0.01648537f, 0.19948271f, -0.00946224f, 
    0.26948300f, 0.07339724f, 0.00263552f, 0.01853087f, -0.19995902f, 0.21562949f, -0.01587983f, -0.27724877f, 
    0.25839910f, 0.47833493f, 0.28233260f, 0.12164076f, -0.23379172f, 0.02988069f, 0.03556547f, 0.26830721f, 
    -0.05567295f, 0.02396087f, -0.01954179f, 0.26660523f, 0.09930585f, -0.15710786f, -0.05684744f, 0.00328880f, 
    0.14991803f, 0.02780160f, -0.11023803f, 0.03948407f, 0.14802171f, 0.07095043f, 0.08204645f, -0.10830379f, 
    0.15851146f, -0.41604054f, 0.29568276f, 0.06520343f, 0.60492653f, 0.01462051f, -0.08319626f, -0.18354964f, 
    -0.05562032f, -0.34336689f, 0.07228432f, -0.10137957f, 0.01468234f, 0.08468046f, -0.06973150f, -0.07332475f, 
    -0.29964966f, -0.21906650f, -0.25663686f, -0.22905017f, 0.02022020f, -0.04895917f, -0.02885239f, 0.20178640f, 
    0.33987299f, -0.08317879f, -0.03264270f, -0.23970442f, 0.19364712f, -0.35595757f, 0.00358789f, -0.16874087f, 
    0.15756042f, -0.33873129f, -0.00217249f, -0.28886169f, 0.09080494f, 0.16120432f, -0.07447543f, -0.13405091f, 
    -0.32632136f, 0.04932737f, 0.36226252f, -0.24637753f, 0.15850574f, 0.27946070f, -0.06697128f, -0.44840124f, 
    0.11996426f, -0.16347325f, -0.19443706f, 0.23725459f, -0.28257886f, 0.02235642f, -0.06996519f, -0.24721469f, 
    -0.07202094f, -0.34211519f, -0.03161869f, -0.20231242f, 0.25789365f, 0.53143549f, 0.04707006f, 0.06841964f, 
    -0.08240509f, 0.21927615f, 0.05770717f, 0.19621155f, 0.14377034f, 0.16661286f, 0.09397551f, -0.14613995f, 
    0.43659618f, -0.02098566f, 0.02891741f, -0.13231346f, -0.16307390f, -0.10760873f, 0.08686109f, 0.26558989f, 
    -0.06126398f, 0.28767470f, 0.01873040f, -0.05809678f, -0.13270162f, 0.13962781f, -0.08085830f, 0.08197446f, 
    -0.08932918f, 0.06992994f, -0.11852229f, 0.01774216f, -0.00033377f, 0.03103400f, -0.03619939f, -0.08232379f, 
    -0.04824818f, 0.03216622f, 0.02861026f, -0.01479159f, 0.08708806f, -0.02955168f, 0.01434720f, -0.02285991f, 
    -0.05574096f, -0.10038766f, -0.04781771f, -0.03089370f, -0.04180578f, -0.03392632f, -0.05056809f, 0.00054447f, 
    0.06912684f, 0.00521726f, 0.00148753f, 0.01495261f, 0.04653466f, -0.03680190f, -0.06031656f, -0.00106773f, 
    0.01286318f, 0.07555833f, -0.05889795f, 0.02722166f, 0.00105385f, -0.01991788f, 0.00116327f, 0.04490665f, 
    0.04129926f, 0.00388929f, 0.07700161f, 0.05774142f, -0.11680215f, -0.05915590f, 0.08705708f, -0.01862806f, 
    -0.05400734f, -0.12867503f, 0.04000057f, -0.01098903f, 0.03488044f, 0.05362852f, 0.05428897f, 0.04333625f, 
    0.03234698f, -0.03833165f, -0.05493938f, -0.07947780f, -0.12567180f, 0.02266788f, -0.04598425f, 0.05461847f, 
    0.01091878f, -0.01925095f, 0.08932350f, 0.05648234f, -0.02977164f, -0.01040084f, 0.06560412f, -0.00826559f, 
    -0.09346204f, -0.05070869f, -0.13230398f, -0.05467407f, 0.03195615f, -0.04026669f, -0.04762742f, 0.10159830f, 
    -0.09582826f, 0.05649839f, 0.00617431f, -0.10208397f, 0.01187818f, -0.05302037f, -0.10765401f, -0.07137044f, 
    -0.10142439f, -0.05506526f, -0.05093297f, 0.04024498f, -0.11975596f, 0.02957901f, -0.08822836f, -0.10185719f, 
    -0.06186499f, -0.04774650f, -0.03773197f, 0.01965033f, -0.09560979f, 0.05612736f, 0.02051690f, 0.02982458f, 
    -0.04617306f, -0.03090090f, 0.05935748f, -0.03873535f, -0.10423470f, -0.07146355f, -0.08804682f, 0.07138660f, 
    0.04951796f, -0.01840163f, 0.00942448f, -0.03775199f, -0.06976063f, -0.09132543f, -0.00405851f, -0.04082209f, 
    -0.15188339f, 0.06679627f, 0.01113193f, -0.06319107f, 0.06544769f, -0.05461125f, -0.02123268f, -0.05711694f, 
    0.25623652f, 0.17481123f, -0.08272779f, -0.07483450f, -0.01693591f, -0.06179042f, -0.38272437f, 0.00828375f, 
    0.06668521f, 0.08160746f, -0.08997700f, 0.24293277f, -0.00558483f, 0.37385750f, 0.06631319f, 0.10753914f, 
    0.03557637f, -0.15895616f, -0.09092566f, 0.20540509f, 0.31308812f, -0.06325989f, 0.17832993f, 0.06658515f, 
    0.00554902f, -0.10953039f, -0.01753231f, 0.01431294f, 0.25019637f, 0.09480195f, -0.08128103f, 0.24523622f, 
    0.27368879f, 0.09837439f, 0.31589198f, 0.41954836f, -0.09149135f, -0.00742539f, -0.04942591f, 0.18720078f, 
    -0.14564770f, -0.28308129f, 0.28308809f, 0.08901797f, -0.48466331f, -0.16522689f, 0.25973645f, 0.15665139f, 
    0.46808359f, 0.14998439f, 0.05064140f, 0.06730241f, 0.15304607f, 0.23511164f, -0.04092692f, 0.31750578f, 
    -0.45713693f, 0.06643671f, -0.03189475f, 0.15408249f, 0.07203906f, 0.07201035f, 0.08386753f, -0.28706694f, 
    -0.25821477f, 0.13123949f, 0.27013966f, 0.02348203f, -0.27100608f, -0.35281217f, 0.05614071f, 0.25366473f, 
    -0.17323254f, 0.13309361f, 0.10059385f, -0.05991998f, -0.09378577f, 0.20293687f, 0.35537213f, 0.47248054f, 
    0.20800866f, -0.28373748f, 0.38706535f, 0.08378926f, -0.03320492f, -0.05365272f, 0.00001361f, 0.28081766f, 
    0.00310538f, -0.02449982f, -0.09517100f, -0.35629889f, 0.28849888f, 0.03585847f, 0.02305338f, -0.01829314f, 
    0.00288007f, -0.01093101f, 0.12726718f, -0.13508783f, 0.18510264f, -0.01613809f, -0.05110082f, -0.30287343f, 
    -0.16472079f, 0.03091956f, 0.07946041f, 0.12059397f, -0.00159569f, 0.27610305f, 0.11270797f, 0.13071299f, 
    0.07776321f, 0.02405204f, -0.21561690f, -0.09143152f, -0.04260070f, 0.20713285f, -0.12581410f, -0.22927952f, 
    0.09159045f, -0.01786816f, 0.12243739f, 0.43272585f, 0.12823889f, 0.34895042f, 0.02281827f, -0.18162769f, 
    0.40521535f, -0.04610778f, -0.06090340f, 0.08225040f, -0.13405500f, -0.07677186f, 0.06209334f, -0.04209284f, 
    0.17198645f, 0.03493554f, -0.04452630f, 0.11859642f, -0.09284383f, -0.09665611f, -0.00340899f, 0.08431862f, 
    0.19688912f, 0.54449272f, 0.12131782f, 0.12051402f, 0.05485060f, 0.14275908f, 0.21888626f, 0.15760803f, 
    -0.07448352f, -0.05759398f, 0.00999365f, 0.18930508f, 0.16719070f, -0.22959383f, 0.04944576f, -0.13384417f, 
    0.20273937f, 0.00140598f, 0.07789379f, 0.03818173f, -0.07857139f, -0.03652708f, 0.10462966f, -0.01552823f, 
    -0.14650592f, -0.29437837f, -0.18834235f, 0.00971764f, 0.15364331f, -0.06361115f, 0.06107680f, 0.20069070f, 
    -0.34154484f, -0.02421600f, -0.00192533f, 0.00376575f, -0.12217531f, 0.12204325f, 0.18810406f, 0.21458258f, 
    0.47623667f, 0.01484556f, -0.02540447f, -0.09218671f, -0.05220328f, -0.05622407f, 0.00413890f, 0.04706050f, 
    0.22442885f, 0.18176354f, 0.00136762f, -0.00378131f, 0.29794014f, -0.02513645f, 0.04262041f, -0.15773292f, 
    0.00786370f, 0.00689338f, -0.06867759f, 0.17762250f, -0.20165527f, -0.04784068f, -0.19628677f, 0.08491088f, 
    -0.12776828f, 0.01772863f, 0.03823559f, -0.07742566f, 0.10948816f, 0.07714725f, -0.29365805f, -0.17487553f, 
    0.08439156f, 0.02489119f, -0.06193718f, -0.01695653f, -0.22689848f, 0.12473588f, 0.08659197f, -0.23924249f, 
    0.11687486f, -0.51814944f, -0.32742411f, 0.07351246f, -0.04658611f, 0.20753184f, 0.04401826f, 0.14084323f, 
    0.17018944f, -0.04153096f, -0.08565491f, 0.13088046f, 0.12845427f, -0.01997190f, 0.19853964f, 0.01730527f, 
    0.16091192f, 0.01453756f, 0.19638199f, 0.02271941f, -0.02984878f, 0.38086987f, 0.02557781f, 0.30355605f, 
    -0.09881219f, 0.09828155f, 0.07642036f, 0.05523244f, -0.12403272f, -0.02524725f, 0.05644440f, -0.09233174f, 
    -0.17912179f, -0.20163831f, -0.36565790f, 0.07727830f, 0.12079341f, -0.06442887f, -0.35423434f, 0.07487494f, 
    0.18776450f, -0.01854821f, -0.07750916f, -0.10140165f, 0.15896925f, 0.24252480f, -0.14157854f, 0.14156798f, 
    0.21342707f, 0.02307185f, -0.00761943f, 0.03686675f, 0.22052218f, 0.04468172f, 0.10292493f, 0.08970027f, 
    0.02316496f, 0.31353089f, 0.11393773f, -0.27073798f, -0.67959243f, -0.29617786f, -0.20364793f, 0.05447605f, 
    -0.14168982f, -0.24703041f, 0.55250734f, 0.23949955f, 0.04456474f, 0.04348504f, 0.12188108f, -0.36993274f, 
    0.12457316f, 0.15774679f, -0.20936231f, 0.21975580f, -0.37759900f, 0.00814495f, 0.25351870f, 0.23732774f, 
    0.24202754f, -0.17238547f, -0.00660659f, -0.23205020f, 0.10633172f, 0.42712966f, 0.14796533f, 0.01371599f, 
    0.18997169f, 0.16364916f, 0.12982880f, 0.17140472f, -0.22259201f, 0.15848699f, 0.14514300f, -0.28148767f, 
    -0.27418008f, 0.06529697f, 0.09835814f, 0.05817516f, 0.39197847f, 0.07495134f, 0.08662465f, 0.06403720f, 
    -0.06514946f, 0.21032414f, 0.34086373f, 0.09741263f, 0.18363625f, 0.16343096f, -0.11881338f, -0.39655659f, 
    0.95514536f, 0.18503395f, 0.04830682f, 0.01828056f, 0.05868791f, 0.26092613f, -0.10883449f, 0.18873486f, 
    -0.09945954f, 0.08515760f, -0.39259464f, -0.44474247f, -0.31651238f, 0.00884387f, -0.02897627f, -0.42119512f, 
    0.00881413f, -0.11299230f, -0.14249885f, 0.01471730f, 0.13768220f, 0.25008878f, -0.35181528f, 0.01152273f, 
    0.04940218f, -0.28940079f, 0.08515855f, -0.07513113f, -0.29941770f, 0.06907637f, -0.20934984f, -0.07477789f, 
    -0.23428753f, -0.05940576f, 0.17992309f, 0.05801324f, 0.02173205f, -0.57973474f, 0.29241791f, -0.05519210f, 
    -0.03378620f, -0.05434938f, 0.11841056f, 0.34010956f, 0.37528935f, 0.15430216f, 0.05214568f, -0.37098324f, 
    0.77526426f, 0.19639918f, 0.33285958f, -0.09775434f, 0.04369471f, -0.01821262f, -0.03777656f, 0.00422340f, 
    -0.09414886f, -0.03432296f, 0.04447053f, 0.14801532f, -0.18962984f, 0.08567842f, 0.33699805f, 0.06885171f, 
    0.14911518f, 0.12983686f, -0.03602200f, 0.05190497f, 0.20588255f, 0.12080944f, 0.20187263f, -0.20658618f, 
    0.01428179f, -0.13076383f, 0.10394406f, 0.08834143f, 0.35754061f, -0.32520753f, -0.13061017f, -0.03073248f, 
    0.15725540f, 0.28787020f, 0.21398373f, 0.32090682f, -0.10205191f, -0.10054745f, -0.03495827f, 0.19257084f, 
    0.08709954f, -0.02290195f, -0.10935680f, -0.16121556f, -0.71892905f, 0.36213440f, 0.01105065f, 0.05995687f, 
    -0.12343121f, -0.24233502f, 0.03075847f, 0.01432441f, -0.05177382f, -0.09019437f, 0.13154303f, 0.28125429f, 
    -0.03688198f, 0.11994387f, 0.51095659f, 0.01295648f, 0.12056262f, -0.12429791f, -0.08175565f, 0.25473666f, 
    0.08587457f, 0.11670460f, 0.01985310f, -0.14635648f, 0.23180160f, -0.13593976f, -0.10747871f, -0.02307135f, 
    -0.14358409f, -0.08934426f, -0.13844788f, 0.00177082f, -0.15344818f, -0.13245916f, 0.14950077f, 0.29244077f, 
    -0.22375187f, -0.23467778f, 0.26287854f, -0.01373712f, -0.00566505f, 0.15437545f, 0.11989037f, 0.03779192f, 
    -0.03422526f, -0.01444580f, 0.14269930f, -0.15504350f, 0.04247703f, -0.02824542f, -0.01730173f, -0.01571614f, 
    -0.06411985f, 0.27064312f, 0.14976385f, 0.05835722f, 0.03690491f, 0.25494620f, 0.12341579f, -0.16243790f, 
    -0.07171911f, 0.11444599f, -0.03089378f, 0.10668517f, 0.17365856f, -0.17770867f, 0.61963934f, 0.06018499f, 
    -0.08520338f, -0.00062800f, 0.11806218f, 0.13661495f, -0.09160221f, 0.88261425f, -0.42241156f, -0.23832314f, 
    0.09191759f, 0.09414225f, 0.37058964f, 0.30796352f, -0.24161422f, -0.07149831f, -0.00294841f, -0.32130274f, 
    0.24304201f, 0.26265639f, -0.10323331f, 0.23390044f, -0.06629035f, 0.02119779f, 0.19617715f, 0.04330447f, 
    0.21064682f, 0.12848370f, -0.05133036f, 0.25577006f, -0.36554804f, -0.08509028f, 0.00925236f, -0.42028937f, 
    -0.20278423f, 0.24158321f, 0.22661807f, 0.05483919f, 0.03084404f, 0.19121633f, 0.12310552f, 0.05608078f, 
    -0.01504997f, -0.11242156f, 0.51369834f, 0.15973893f, -0.17820229f, 0.03144504f, 0.08084103f, 0.20440266f, 
    0.27400675f, 0.23570147f, 0.08136706f, 0.08113949f, 0.03254766f, 0.10259451f, 0.22211269f, 0.07239164f, 
    -0.10556094f, 0.22247393f, 0.20924902f, -0.03585820f, 0.21041521f, -0.42734331f, -0.23740786f, -0.27144259f, 
    0.09066617f, -0.05439599f, 0.01251996f, 0.04081927f, 0.57816148f, 0.12573770f, -0.21594727f, -0.46970019f, 
    0.15011004f, -0.01822544f, 0.16620912f, -0.07954356f, -0.04936546f, -0.16415863f, 0.02169270f, 0.14521784f, 
    0.41430372f, 0.00547502f, -0.02345335f, -0.30567062f, 0.58584958f, -0.28470981f, -0.06438202f, -0.05479874f, 
    0.08656354f, -0.20853162f, 0.35383546f, 0.00609600f, 0.01617941f, 0.37017897f, 0.27125213f, 0.75180173f, 
    0.15492651f, -0.28536600f, 0.22546682f, -0.19319221f, -0.04820454f, -0.45763704f, -0.36487451f, -0.14846197f, 
    0.25711548f, -0.10581797f, -0.32691935f, 0.03948711f, 0.30953401f, -0.04700809f, -0.04319970f, 0.14327195f, 
    0.19315432f, 0.05754254f, 0.01024787f, -0.12463730f, 0.12786715f, 0.08086804f, 0.06615915f, -0.09294026f, 
    0.11568423f, 0.16056664f, -0.03831286f, 0.10698733f, -0.01184375f, 0.10378650f, -0.00487271f, -0.00747509f, 
    -0.50165242f, -0.06665172f, -0.41075665f, 0.05993268f, -0.04933977f, 0.13741732f, -0.10218644f, 0.18506049f, 
    0.19852756f, 0.10037378f, -0.00171809f, 0.12604679f, 0.24097236f, 0.14905810f, 0.03601461f, 0.11957009f, 
    -0.06808913f, -0.04199925f, -0.04201340f, -0.02759418f, -0.07195905f, 0.01298033f, 0.03468446f, -0.08608758f, 
    -0.05713498f, 0.01513422f, 0.02218921f, -0.03434716f, 0.02221320f, 0.01627721f, 0.00996824f, 0.01353983f, 
    -0.06342028f, -0.08250100f, -0.00545848f, -0.04328861f, 0.01110522f, -0.07699245f, 0.00110565f, 0.03430843f, 
    0.04616563f, 0.02656996f, -0.02922545f, -0.04556214f, -0.10756656f, -0.01535408f, 0.02169093f, -0.05930237f, 
    -0.01119632f, -0.04226116f, 0.01993669f, -0.05533210f, -0.09210498f, -0.10916020f, -0.04964103f, -0.06351936f, 
    -0.01185980f, -0.02885037f, -0.08529837f, -0.00418928f, -0.02577994f, -0.07266665f, -0.12078271f, 0.00507359f, 
    0.02243606f, -0.07356018f, -0.07427808f, 0.05076386f, 0.01263420f, -0.01544193f, -0.10608523f, -0.09715990f, 
    -0.04333619f, -0.09257783f, -0.05802812f, 0.00761095f, -0.10068630f, -0.09472643f, -0.13677311f, 0.03170349f, 
    -0.02509844f, -0.00804727f, -0.00989215f, -0.01277667f, 0.05994565f, -0.04017100f, -0.04951631f, 0.02349596f, 
    -0.05530781f, -0.01977900f, -0.06446955f, -0.10652307f, -0.06230531f, 0.04013458f, 0.04347702f, 0.14130470f, 
    -0.00149358f, 0.04066847f, -0.06294722f, -0.01968179f, 0.05984237f, -0.04931939f, -0.08478238f, -0.08474454f, 
    -0.09468827f, -0.11447427f, -0.01731053f, -0.08365650f, -0.01489758f, -0.09836483f, -0.06928638f, 0.01859795f, 
    -0.12839183f, 0.07585980f, -0.00738176f, 0.00714771f, -0.01297111f, -0.09046610f, 0.03787418f, 0.04892204f, 
    -0.03497057f, -0.04598187f, -0.06988075f, -0.01489909f, -0.11246946f, -0.08840161f, -0.03533280f, -0.06830672f, 
    -0.06120227f, -0.06088281f, 0.00516108f, -0.03531455f, -0.12698339f, 0.03917073f, -0.09275886f, -0.11633663f, 
    0.01780737f, -0.00663496f, 0.03735935f, -0.04547872f, -0.03995844f, -0.09123801f, 0.01054255f, 0.04551475f, 
    0.01012642f, -0.03869903f, -0.10746945f, 0.02860738f, -0.03417685f, 0.06156749f, -0.00477684f, -0.04407178f, 
    -0.04347929f, 0.00997544f, -0.08391478f, -0.03909512f, 0.03527807f, -0.01841622f, -0.00003453f, 0.05316513f, 
    -0.10920820f, 0.05176843f, -0.02994775f, -0.04665432f, 0.05500795f, -0.02896021f, -0.04466926f, -0.07017283f, 
    -0.06170774f, -0.08642429f, -0.05117055f, -0.03315986f, -0.02864518f, 0.00464901f, 0.02127646f, 0.02420290f, 
    -0.06698150f, -0.00113338f, -0.00768171f, -0.07615713f, -0.08707158f, -0.05500247f, -0.02200759f, -0.01955372f, 
    -0.07475382f, -0.04238663f, 0.01976231f, -0.07368001f, -0.04089774f, -0.08833383f, -0.06874651f, -0.00705753f, 
    0.04605813f, 0.00621216f, -0.06277370f, 0.03879880f, -0.07302415f, -0.00034838f, -0.04037225f, 0.09015810f, 
    -0.03922849f, -0.08521143f, -0.07733423f, 0.01555654f, -0.04240818f, 0.00757933f, 0.02455630f, 0.04904714f, 
    -0.03223070f, -0.15833557f, -0.04564693f, -0.02008441f, -0.05858454f, -0.03382612f, 0.01448316f, 0.06310244f, 
    -0.09251618f, -0.02904036f, 0.00674581f, -0.00264001f, 0.01390233f, 0.03355615f, -0.01185930f, 0.04955399f, 
    0.13741459f, -0.03582026f, 0.01220314f, -0.04242953f, 0.04342429f, 0.05220997f, -0.09337242f, -0.09488139f, 
    -0.06531572f, -0.09214459f, 0.05484153f, 0.01422988f, -0.04808842f, -0.06646361f, -0.05268075f, -0.06947636f, 
    -0.12119373f, -0.09563818f, 0.03675333f, -0.07745659f, 0.03519429f, -0.10162131f, -0.06695301f, -0.02345270f, 
    -0.01636879f, 0.02066339f, 0.08209338f, -0.00759998f, 0.03157695f, -0.09551275f, -0.04262010f, -0.00570352f, 
    -0.09336375f, -0.01749922f, 0.03573445f, 0.06571695f, -0.03413865f, -0.00549055f, 0.04767865f, 0.01709745f, 
    -0.05720762f, -0.07476012f, -0.04453123f, -0.05927506f, -0.05595577f, -0.06598712f, 0.01023449f, 0.07462141f, 
    0.12760176f, -0.37080434f, 0.23438582f, 0.03026766f, 0.09363168f, -0.10126671f, 0.27048418f, 0.15363355f, 
    0.05161826f, -0.08844229f, -0.03658338f, 0.15437302f, 0.13153164f, 0.01115575f, -0.24500686f, 0.17483214f, 
    -0.40011352f, -0.25902569f, 0.09105007f, -0.08816618f, 0.17623773f, 0.08466350f, 0.07464433f, -0.16824722f, 
    0.08815099f, 0.11568592f, 0.13155943f, -0.37678298f, 0.10945687f, -0.26297277f, -0.26263323f, -0.26913083f, 
    -0.32191753f, -0.39012432f, -0.04811687f, 0.41716689f, -0.16450776f, 0.07071390f, 0.19580323f, -0.34763786f, 
    0.24070275f, -0.03042377f, -0.24006508f, -0.32768664f, 0.11830837f, -0.08013808f, 0.00146323f, 0.01578724f, 
    -0.00670009f, 0.04451692f, 0.04962581f, 0.44175324f, -0.00979370f, 0.12808120f, 0.04263993f, -0.04165914f, 
    -0.01404743f, -0.06750942f, -0.26857999f, -0.08250856f, 0.19008175f, 0.05275466f, -0.04460217f, 0.05110642f, 
    0.27686051f, 0.05182122f, -0.13056193f, -0.01912559f, -0.50826770f, 0.43041071f, -0.10987192f, 0.12188543f, 
    -0.01760538f, -0.20305493f, 0.11177296f, 0.03586136f, 0.18180230f, 0.07309842f, -0.13277395f, -0.40784985f, 
    0.22199897f, 0.07081781f, -0.09240972f, 0.05488555f, 0.06285871f, 0.06620250f, 0.14786981f, 0.04462160f, 
    0.38865870f, 0.02661808f, 0.02251500f, 0.56951016f, -0.08270549f, 0.16691169f, -0.03917193f, 0.10190358f, 
    -0.01422220f, -0.58195645f, 0.07130013f, -0.01570598f, -0.02391377f, 0.35573703f, 0.13356902f, -0.00843469f, 
    0.18614902f, -0.10617971f, 0.00571731f, -0.06250032f, 0.12727703f, -0.23534445f, -0.31727934f, -0.30813533f, 
    -0.53371125f, -0.08198512f, -0.09983405f, -0.29520559f, 0.19370615f, 0.50660640f, 0.33528197f, -0.05974161f, 
    0.21757542f, 0.06342737f, 0.05822937f, 0.08993071f, -0.20278677f, -0.05060111f, 0.22250871f, -0.08218695f, 
    -0.21931958f, 0.12566160f, -0.11313563f, 0.09522809f, 0.10710370f, 0.10976107f, 0.01062878f, 0.00223892f, 
    -0.13718830f, 0.00762746f, -0.01489038f, -0.16436918f, 0.08906826f, -0.04458636f, 0.10610833f, 0.07471927f, 
    0.37107840f, 0.33539262f, -0.06152438f, 0.00867312f, -0.00799558f, 0.31465200f, 0.06469181f, 0.20929329f, 
    0.05707945f, 0.12167453f, 0.03450829f, 0.14662153f, -0.11550738f, -0.18648237f, 0.25079760f, -0.26346344f, 
    -0.18774609f, 0.14174290f, 0.13648430f, -0.12287994f, 0.18738216f, 0.16530630f, -0.04524947f, -0.00046904f, 
    0.12769142f, -0.22521164f, 0.03255319f, 0.24733281f, 0.18091002f, 0.14479336f, -0.12826137f, -0.02660871f, 
    -0.11059973f, 0.06696730f, -0.07214352f, -0.09713820f, -0.50836319f, -0.08541809f, 0.01686154f, 0.04057595f, 
    0.05477396f, -0.03910126f, 0.12951542f, 0.11541518f, -0.13806722f, -0.04674440f, -0.03634464f, -0.05141077f, 
    -0.12087577f, -0.04197832f, -0.14313067f, 0.20761840f, -0.22060232f, -0.09276034f, -0.02867203f, 0.09014738f, 
    0.11801652f, 0.01486481f, -0.00933422f, -0.01538561f, 0.07796974f, -0.11211903f, -0.10036930f, -0.35650665f, 
    -0.37065181f, 0.52714127f, -0.15844671f, -0.23474048f, 0.29805773f, 0.16826279f, -0.08164982f, 0.07975257f, 
    -0.12567890f, 0.07193588f, 0.00838050f, -0.08796179f, -0.21544443f, -0.07079110f, 0.05738887f, -0.15881491f, 
    -0.20919180f, 0.49663639f, 0.09810372f, 0.04587156f, -0.08142871f, 0.05623495f, -0.08702797f, 0.26031691f, 
    0.11481963f, 0.18827906f, 0.06497891f, -0.03525487f, 0.06554330f, 0.19232947f, 0.04630578f, 0.01968361f, 
    0.03254950f, -0.01180914f, 0.20525403f, 0.10104010f, 0.08911695f, -0.15246175f, -0.26521668f, -0.01280649f, 
    -0.08938877f, 0.03049383f, 0.34208244f, -0.13509209f, -0.03187411f, -0.08441083f, -0.02321362f, 0.25047290f, 
    0.04798582f, -0.01305307f, -0.05046824f, -0.02604405f, 0.04544312f, -0.05251940f, -0.09838237f, 0.01228129f, 
    0.05883541f, 0.01499248f, -0.04142487f, -0.02925590f, 0.07967775f, -0.04279450f, -0.05620195f, -0.05022868f, 
    -0.02864058f, 0.03203487f, -0.04395890f, -0.08887610f, -0.04004855f, 0.05979036f, -0.01877319f, -0.05369979f, 
    -0.07029475f, 0.05886213f, 0.06575964f, 0.05406414f, -0.06491763f, 0.07555788f, -0.00124997f, 0.04774513f, 
    -0.00233548f, 0.01275848f, -0.03990316f, 0.06885822f, -0.01367413f, -0.09979061f, 0.02151196f, -0.09564094f, 
    0.02695480f, 0.01193864f, 0.01793131f, 0.01135683f, 0.09900031f, 0.06872331f, 0.03937452f, -0.08826743f, 
    -0.06391210f, -0.01404006f, -0.08426543f, 0.07551489f, -0.01983129f, 0.07448563f, -0.01868852f, -0.11569183f, 
    0.06548020f, -0.03359820f, 0.02505107f, -0.05040210f, 0.00397433f, -0.06710528f, 0.02546200f, -0.07523765f, 
    -0.03607085f, -0.07106713f, -0.07232017f, -0.08810250f, 0.07557653f, -0.04471854f, 0.04439184f, -0.07570590f, 
    -0.06125172f, 0.06809839f, -0.09296616f, -0.03121955f, -0.07753637f, 0.00600024f, 0.00856061f, 0.09092011f, 
    0.03888951f, -0.10243571f, 0.04418893f, -0.03196688f, -0.01189114f, 0.03165615f, 0.04669163f, -0.07006345f, 
    0.04250292f, -0.07484641f, 0.05625532f, -0.05885190f, 0.04078806f, -0.03791477f, 0.09160244f, -0.07909109f, 
    -0.08246643f, 0.11388833f, -0.07955130f, -0.09988829f, -0.02634929f, 0.02335490f, -0.05096402f, 0.03439147f, 
    0.01060002f, -0.02762050f, -0.03082461f, -0.02692680f, 0.04236660f, -0.07372060f, 0.02961628f, -0.06076143f, 
    0.09784608f, 0.05729149f, -0.07951583f, 0.04992475f, -0.03042714f, 0.02456512f, 0.00291805f, -0.09854174f, 
    0.00666654f, -0.01283661f, -0.06623957f, -0.07471132f, -0.05536178f, -0.02083497f, 0.02284198f, 0.06956910f, 
    0.45143467f, -0.17792635f, -0.06599131f, 0.17450221f, -0.02952120f, -0.07704408f, -0.07967327f, 0.08158919f, 
    0.36616611f, -0.01163391f, 0.04479907f, 0.05025854f, -0.05399596f, 0.37227231f, -0.01162860f, 0.10416839f, 
    0.38848120f, 0.37939036f, -0.17556536f, 0.18531811f, 0.29349837f, 0.05519272f, 0.03713965f, 0.19320861f, 
    0.05591891f, 0.17446235f, 0.44322643f, -0.48653460f, -0.00844193f, -0.39116329f, -0.18806669f, 0.04511726f, 
    0.26490679f, -0.35538000f, 0.30317587f, 0.18366142f, -0.10029349f, 0.23792289f, 0.03567860f, -0.18247002f, 
    -0.10664146f, 0.07902056f, -0.13012479f, 0.03792761f, -0.38659856f, -0.25139394f, 0.00599618f, 0.25937548f, 
    0.33338231f, 0.05415543f, 0.03998768f, 0.03556136f, 0.10894188f, 0.50966972f, -0.05328862f, -0.00684643f, 
    0.42025319f, -0.07988169f, -0.23537438f, 0.00108094f, 0.00647783f, -0.00278441f, -0.11228149f, -0.39169917f, 
    0.08707102f, 0.23737279f, 0.19549952f, 0.16760351f, 0.88166088f, 0.07151774f, -0.01654011f, 0.21633016f, 
    -0.14860295f, 0.11559182f, 0.12572932f, -0.00963761f, -0.07191469f, 0.30879703f, -0.34574077f, 0.02654636f, 
    0.44489878f, -0.27956557f, 0.31033722f, 0.23702164f, 0.12385749f, 0.08085408f, -0.04005837f, 0.05213853f, 
    -0.00286278f, 0.10124788f, -0.36833790f, 0.00904004f, -0.24529852f, 0.10464517f, -0.04853233f, -0.51631212f, 
    0.02038292f, -0.44197148f, -0.05332915f, -0.12086757f, 0.15278207f, -0.06831992f, -0.24222103f, -0.12331498f, 
    0.09135305f, -0.47614732f, 0.01860509f, 0.04877186f, -0.08145677f, 0.03298156f, -0.40927055f, -0.16380754f, 
    -0.35859853f, -0.10744779f, 0.08437137f, 0.06815133f, 0.13540964f, 0.15676500f, 0.21115181f, 0.07200348f, 
    -0.35405672f, 0.01206498f, -0.03467465f, 0.39634928f, 0.07777572f, 0.03778264f, 0.17479849f, -0.33110777f, 
    -0.34307167f, -0.10797366f, -0.29577228f, 0.13446501f, 0.13902920f, 0.01247615f, 0.01870580f, 0.02535278f, 
    0.12123828f, -0.01920658f, 0.01687987f, 0.15016732f, 0.02238865f, 0.16829397f, -0.06039673f, 0.17770699f, 
    -0.01399786f, -0.05584566f, 0.18794070f, 0.23109990f, 0.23820001f, 0.15000269f, 0.04239712f, 0.27931988f, 
    -0.00872603f, -0.07990768f, -0.29864401f, 0.07862396f, 0.15644005f, 0.15088227f, 0.05533054f, 0.00240400f, 
    0.16546628f, -0.07966568f, -0.03570596f, 0.15382704f, 0.20492812f, -0.01158297f, -0.07529462f, 0.12029306f, 
    -0.00476277f, -0.09401701f, 0.16580085f, 0.19156271f, 0.51256353f, -0.44600281f, 0.12646346f, 0.06633389f, 
    0.08629736f, -0.32668898f, -0.02163417f, -0.03904990f, -0.14146487f, 0.17262442f, 0.00149222f, 0.29885605f, 
    -0.05516010f, -0.10989336f, -0.41625720f, 0.10254097f, -0.01785223f, 0.14159781f, 0.03762842f, -0.04920321f, 
    0.18010841f, -0.09184781f, 0.03314247f, 0.11960284f, -0.80594450f, -0.27488849f, 0.02282924f, -0.19171771f, 
    0.17393272f, 0.28545296f, 0.14164892f, -0.25055972f, -0.00250227f, 0.13163304f, 0.06310952f, -0.18575180f, 
    -0.04872706f, 0.05545467f, -0.04013198f, -0.06176180f, 0.06052198f, 0.06926564f, -0.10833792f, -0.04396432f, 
    -0.01712878f, 0.06169209f, -0.15980867f, -0.03793422f, 0.07094264f, 0.05316916f, 0.08734277f, -0.04073356f, 
    0.12194028f, -0.18004403f, -0.11277715f, -0.00759938f, 0.03674977f, -0.13206394f, 0.04139546f, 0.03008635f, 
    -0.00428554f, -0.01206492f, 0.04344368f, 0.31269678f, -0.02627980f, 0.23319052f, -0.16699649f, 0.14723003f, 
    0.39710647f, 0.00704480f, -0.19128034f, -0.22230443f, -0.04576485f, -0.54193401f, 0.18106869f, 0.10832236f, 
    -0.03702174f, 0.10513952f, 0.10524391f, -0.03735442f, 0.17131147f, 0.25223863f, 0.01968677f, 0.28978458f, 
    0.17023404f, -0.12565055f, 0.08459622f, 0.18098086f, 0.05003685f, -0.20618142f, -0.05891844f, 0.14310990f, 
    -0.06193567f, -0.33934343f, 0.09005211f, 0.18999380f, 0.07801562f, -0.00054776f, -0.09295554f, 0.13816556f, 
    -0.28304732f, 0.13499245f, 0.07794205f, 0.03361360f, 0.22439896f, -0.24344322f, 0.13613246f, -0.20086479f, 
    -0.04598904f, 0.04475635f, 0.03964036f, -0.42616421f, -0.00639179f, -0.36937231f, -0.36745745f, -0.00177979f, 
    -0.00409870f, -0.05951981f, 0.05228108f, 0.17726904f, -0.00536680f, 0.03861765f, 0.11669459f, -0.20310737f, 
    0.09584585f, 0.16420087f, -0.18128856f, -0.60540992f, -0.52767950f, -0.15588580f, 0.06494351f, -0.05696828f, 
    0.11757617f, 0.07286052f, -0.01282143f, 0.21232030f, 0.16688879f, -0.07109688f, 0.00029746f, -0.18714292f, 
    -0.18991923f, 0.06236727f, 0.04593813f, 0.20157148f, 0.09698743f, 0.23284805f, 0.11835783f, -0.13131647f, 
    0.29754087f, -0.02305441f, -0.09178353f, 0.11196078f, 0.02870843f, 0.26643151f, -0.06335618f, 0.18684970f, 
    0.06354579f, -0.13312545f, 0.07476798f, -0.09346745f, -0.00030316f, -0.04519545f, -0.06466269f, 0.12263223f, 
    0.28835905f, -0.17298229f, -0.29877523f, 0.44868132f, 0.02637307f, -0.50574768f, 0.08282242f, 0.10507501f, 
    0.33433366f, -0.05686616f, -0.07032222f, 0.22581638f, 0.02191328f, 0.20858397f, 0.04171844f, -0.06929954f, 
    0.04000597f, 0.27266005f, -0.19552751f, -0.24316566f, -0.08373501f, 0.47018984f, 0.23831156f, -0.25333604f, 
    -0.08843703f, 0.03437096f, -0.02665639f, -0.02363597f, -0.10324734f, -0.21715313f, -0.21871367f, 0.08156917f, 
    -0.19465853f, -0.00205292f, -0.15969050f, 0.17384887f, 0.13706766f, 0.62556821f, 0.23804322f, 0.02118136f, 
    0.11779039f, -0.35847089f, 0.02808835f, 0.31913248f, 0.09800357f, 0.42366976f, 0.00501535f, -0.31604373f, 
    0.03240321f, -0.00094458f, 0.04583537f, 0.02385367f, -0.02134948f, -0.08767069f, -0.05672809f, -0.07235814f, 
    0.01927192f, -0.08002543f, -0.07689341f, 0.03679958f, -0.00482119f, -0.00853402f, -0.06451393f, 0.06703018f, 
    -0.01087527f, -0.02378456f, -0.02970704f, 0.07250377f, 0.00271251f, -0.06007580f, -0.08400524f, -0.07592026f, 
    -0.05478609f, 0.04449108f, 0.06342803f, -0.09495166f, 0.08455474f, -0.06055393f, 0.04513208f, 0.07011653f, 
    -0.02002381f, -0.06642412f, -0.00866842f, -0.09369779f, -0.05280248f, -0.09011327f, -0.00555235f, 0.00707289f, 
    -0.04491150f, 0.02750498f, -0.03208891f, -0.04174817f, 0.08430931f, -0.08029363f, 0.01802250f, 0.01728462f, 
    -0.06978364f, -0.06084165f, -0.07989693f, 0.04589957f, -0.03653270f, -0.07962546f, 0.05401539f, 0.03208781f, 
    -0.04544908f, 0.01393407f, -0.00049110f, -0.01890911f, -0.04535092f, 0.00522346f, 0.04880266f, -0.03197559f, 
    -0.06020640f, -0.03508738f, -0.09452631f, -0.07055710f, -0.01453104f, 0.05930691f, -0.05964408f, 0.06477068f, 
    -0.07815860f, 0.01297253f, -0.00001892f, -0.06594447f, -0.07239577f, -0.01679746f, 0.02990932f, 0.00716627f, 
    -0.04663179f, -0.09162474f, 0.06856333f, -0.09485890f, 0.04193293f, -0.00092493f, -0.05374292f, -0.04136361f, 
    -0.03741239f, 0.05525962f, -0.00155091f, 0.00936280f, -0.07348759f, -0.03373680f, -0.01723209f, -0.01025904f, 
    0.03748655f, -0.06592219f, 0.05786819f, -0.01601733f, 0.07595895f, -0.01884221f, 0.02216373f, 0.06177069f, 
    -0.08852401f, -0.01661606f, -0.07147142f, 0.07865933f, 0.04459382f, -0.08462187f, -0.00782939f, 0.02702789f, 
    -0.08283368f, -0.05593947f, -0.03463037f, -0.00411292f, -0.01370163f, -0.04451659f, -0.07529774f, -0.09310983f, 
    -0.01924660f, -0.06489106f, -0.02577672f, 0.03041028f, 0.01297822f, -0.08622426f, -0.06824136f, -0.01736397f, 
    -0.00986122f, 0.22784282f, -0.02419342f, 0.11168579f, -0.00896995f, 0.06790913f, -0.00354521f, -0.07497138f, 
    -0.11867613f, 0.19113798f, 0.02307170f, 0.06545956f, -0.14515659f, -0.16911814f, 0.09618651f, -0.11865031f, 
    0.08246214f, 0.09907349f, 0.29895279f, 0.11625627f, -0.01494719f, 0.15538907f, 0.07288531f, 0.27523595f, 
    0.02878477f, -0.14747575f, -0.26683843f, 0.09647115f, 0.27904648f, 0.63712311f, 0.40360913f, 0.39200938f, 
    0.26853234f, 0.25117201f, -0.03850980f, -0.09897166f, 0.19552539f, 0.06065734f, 0.11756223f, 0.31001437f, 
    -0.14016460f, -0.07455330f, 0.37069586f, 0.20117769f, -0.06287900f, -0.18425432f, 0.03038712f, 0.19465300f, 
    -0.00188579f, -0.24668027f, 0.09387032f, 0.04957636f, 0.52505362f, -0.12973742f, 0.28220859f, -0.01174092f, 
    -0.02848827f, 0.07778114f, -0.21563846f, 0.08465020f, -0.20733772f, 0.15456192f, 0.09485094f, 0.06736939f, 
    0.12339421f, 0.19747262f, 0.12477960f, 0.11525761f, 0.09357660f, -0.19002952f, 0.03735812f, -0.42607287f, 
    0.10482290f, 0.01872564f, 0.02578995f, 0.32432574f, 0.05629306f, 0.06605253f, 0.32111984f, 0.79577428f, 
    -0.51501960f, 0.38971743f, 0.17371824f, -0.01559350f, 0.21632279f, -0.39011696f, -0.33743811f, 0.03670224f, 
    0.03107359f, -0.00823791f, -0.34841219f, -0.26368624f, 0.18848874f, 0.06481420f, 0.01583038f, 0.10742132f, 
    0.49546596f, 0.04377630f, 0.00244608f, 0.22484827f, 0.02424577f, 0.02891203f, 0.02537864f, 0.14131992f, 
    0.06221709f, 0.04145071f, -0.03659695f, 0.28532383f, 0.09784705f, 0.08034314f, 0.13891391f, 0.17864102f, 
    0.06228410f, 0.04944469f, -0.26319042f, 0.20865311f, -0.04451724f, -0.07687631f, -0.42116001f, 0.07017789f, 
    0.12057538f, 0.17243825f, -0.02357936f, 0.03908681f, 0.28305805f, 0.07679725f, -0.00073403f, 0.14153476f, 
    -0.18904519f, 0.09087436f, 0.06307384f, 0.07913687f, 0.12331246f, 0.09858950f, 0.06021467f, -0.39602935f, 
    -0.22881810f, 0.02639110f, 0.10011717f, -0.21309339f, -0.30580032f, -0.64350468f, 0.13772573f, -0.02811266f, 
    -0.26058912f, 0.08477482f, 0.16927135f, -0.21487232f, -0.30458224f, -0.19005287f, 0.11970928f, -0.26427379f, 
    0.00975304f, -0.21972732f, -0.19703338f, 0.16476265f, -0.57170784f, 0.39709100f, 0.31193626f, 0.00301686f, 
    -0.30122170f, 0.19010875f, 0.13583034f, -0.34073013f, 0.04545762f, -0.23226127f, 0.22969086f, 0.19732155f, 
    0.06650394f, 0.18159877f, 0.08900571f, -0.03345823f, -0.12337477f, 0.00709752f, 0.02970564f, -0.38243324f, 
    -0.04936815f, -0.48339772f, -0.03924114f, -0.25878027f, 0.24630617f, -0.48540476f, -0.23776917f, -0.38642466f, 
    0.27038455f, -0.01724762f, 0.10479268f, 0.00975483f, -0.18587737f, 0.06372582f, -0.00877259f, 0.21238311f, 
    -0.07290465f, -0.18607327f, -0.33452544f, -0.29543680f, 0.14664164f, 0.28394186f, 0.02335695f, -0.21368062f, 
    0.07228994f, -0.39219743f, 0.14634477f, 0.22925335f, 0.32837826f, -0.13532354f, -0.20435233f, -0.13790050f, 
    -0.43515208f, 0.05813818f, -0.25367144f, 0.47726655f, -0.15419781f, -0.40908396f, 0.03893811f, -0.43902481f, 
    0.06426672f, -0.44375759f, 0.06608476f, -0.55019480f, -0.11323560f, -0.21718593f, 0.03403167f, 0.21358259f, 
    0.08329354f, 0.48807454f, -0.02617413f, 0.00345354f, 0.07970002f, -0.03020457f, -0.45587656f, 0.31357926f, 
    0.15839420f, 0.19780293f, 0.02160277f, -0.43554240f, 0.16169420f, -0.25046921f, -0.11041628f, 0.38100493f, 
    0.01825211f, 0.02323022f, 0.23658943f, 0.15613723f, -0.16640173f, -0.48754457f, -0.72450596f, 0.13159862f, 
    0.01652432f, 0.05207124f, -0.42479843f, -0.19714385f, 0.22563578f, -0.08119477f, -0.46556944f, 0.21454884f, 
    0.35316816f, 0.29878309f, 0.13098793f, -0.14128403f, 0.12153032f, 0.09275530f, 0.08407807f, -0.08463027f, 
    -0.21297866f, -0.00079922f, -0.06252265f, -0.04879191f, 0.00637178f, 0.08842229f, 0.33697554f, 0.09081161f, 
    0.13998702f, 0.37838721f, -0.28399166f, -0.02530505f, 0.21178259f, -0.14092061f, 0.00839568f, -0.28152943f, 
    -0.06129530f, 0.11370149f, -0.15780875f, 0.22070959f, -0.44551373f, -0.45581397f, -0.02427619f, -0.16195475f, 
    -0.14547507f, 0.32832342f, 0.21971633f, 0.15945089f, -0.05643674f, 0.02098753f, -0.04954121f, 0.07172766f, 
    0.38672847f, 0.03164183f, -0.34334138f, 0.03450181f, -0.46453354f, 0.68728161f, 0.11265668f, -0.15079848f, 
    -0.00625063f, 0.31740490f, 0.00221482f, -0.08129176f, -0.48415837f, -0.19859645f, 0.19690967f, 0.08310402f, 
    -0.19868127f, 0.09561870f, 0.61432314f, 0.03341674f, 0.02708766f, -0.18593733f, -0.01380179f, 0.28966030f, 
    0.02414831f, -0.12713663f, -0.03310897f, -0.16134492f, -0.23378851f, 0.21304962f, -0.01098995f, 0.18508922f, 
    -0.14695434f, -0.17498051f, -0.05525391f, 0.08057453f, -0.06842160f, -0.32214737f, 0.13943371f, -0.29195544f, 
    0.51773059f, 0.00292848f, -0.18895184f, -0.06882283f, 0.00035175f, 0.44366843f, 0.26050133f, 0.07015941f, 
    -0.18989711f, -0.07250733f, 0.31604898f, -0.21545361f, -0.28483447f, -0.17630780f, 0.06444980f, -0.02154949f, 
    -0.16219240f, 0.31087187f, 0.22811678f, 0.19666305f, -0.04162699f, 0.50894690f, -0.08264771f, 0.09595753f, 
    -0.16884032f, 0.14695597f, -0.08024085f, 0.06479599f, 0.23718676f, -0.01590520f, 0.36198026f, 0.07263611f, 
    -0.07727716f, -0.01649543f, 0.47761694f, 0.20860951f, -0.12802570f, 0.48977968f, 0.07170499f, -0.32436985f, 
    0.21840982f, 0.04333283f, 0.38530174f, -0.00075218f, -0.15158716f, -0.11170916f, -0.18670291f, 0.10379128f, 
    0.03301612f, 0.02755238f, 0.05074086f, -0.01640118f, -0.06933263f, -0.03711891f, 0.00837780f, 0.02083783f, 
    -0.04006786f, 0.05371945f, 0.06549428f, -0.04936505f, 0.02701111f, 0.04394170f, -0.06812721f, -0.01785973f, 
    -0.03711743f, -0.01236914f, 0.05054886f, 0.02095798f, -0.05742786f, -0.01172780f, -0.05956651f, 0.03427403f, 
    0.06606554f, 0.05773364f, 0.02017409f, 0.00804894f, -0.07639749f, -0.01623645f, -0.01774249f, -0.07182898f, 
    -0.07994483f, -0.06949583f, 0.05699965f, -0.01342918f, -0.02923525f, 0.05453720f, -0.02386702f, 0.04748764f, 
    -0.01250448f, -0.05264299f, -0.00027130f, -0.03205715f, -0.04807800f, -0.03235808f, -0.05790067f, -0.08154253f, 
    -0.07724980f, -0.04975320f, -0.02286249f, -0.06881302f, 0.02554708f, -0.07436120f, 0.00060824f, -0.01918791f, 
    -0.07879979f, 0.04871013f, -0.09569537f, -0.00830582f, -0.06295098f, 0.03573081f, 0.06497698f, -0.05648235f, 
    0.03469332f, 0.06167770f, 0.05978193f, -0.05497114f, -0.04135974f, 0.02692464f, 0.05094822f, -0.09004818f, 
    0.03503119f, -0.06567423f, 0.07379182f, -0.02756712f, -0.04043927f, -0.02067873f, -0.01699680f, 0.02982164f, 
    -0.04716307f, 0.02516886f, 0.04660793f, 0.06671606f, 0.01090347f, 0.04040549f, -0.00189537f, -0.08356424f, 
    0.00110040f, -0.09320989f, -0.04784701f, 0.04892892f, 0.07490803f, 0.06870584f, 0.08125600f, -0.03349552f, 
    0.02343329f, -0.05444217f, -0.08105920f, -0.05189839f, 0.00561578f, -0.06789962f, -0.06996270f, -0.04455112f, 
    -0.07200043f, -0.08387580f, -0.02359859f, -0.01536296f, -0.00240218f, 0.03714843f, 0.04581211f, -0.04265909f, 
    0.04063734f, 0.06966556f, 0.06048561f, 0.05889077f, -0.05748972f, -0.02570615f, -0.00657321f, -0.02877450f, 
    -0.00204720f, -0.01229016f, 0.05564693f, 0.03095699f, -0.05648304f, -0.04667739f, 0.00776390f, -0.08925168f, 
    0.06621495f, -0.07534628f, 0.02294619f, -0.08149071f, -0.01873971f, -0.03617162f, 0.06266993f, -0.08280354f, 
    -0.04022108f, 0.00274780f, 0.07353803f, -0.00330240f, -0.05062314f, -0.05482492f, 0.01020045f, -0.03665262f, 
    -0.08311202f, 0.02319306f, 0.06146017f, 0.08104075f, 0.03908646f, 0.03934769f, -0.01515885f, 0.00790957f, 
    -0.01360351f, 0.04479121f, -0.02886125f, -0.05298642f, -0.00775801f, -0.01375477f, -0.03924175f, 0.06170855f, 
    -0.02452552f, -0.02597341f, -0.02475574f, 0.05411129f, -0.07459135f, -0.02496646f, -0.01923461f, -0.04566408f, 
    -0.05036292f, -0.05969229f, 0.04837964f, 0.07663714f, -0.02264277f, 0.05966341f, -0.00127631f, 0.01080106f, 
    0.01545602f, 0.06054686f, -0.00538885f, 0.06257389f, -0.04334341f, -0.07588931f, -0.06341094f, -0.07630483f, 
    -0.05971606f, -0.04563954f, 0.04706287f, -0.06373788f, -0.08687805f, 0.02076877f, 0.03037171f, -0.09673899f, 
    0.04793952f, -0.00256268f, 0.02204889f, 0.05774972f, -0.01683869f, -0.01584460f, -0.00922139f, -0.01630436f, 
    0.05668486f, -0.08368162f, -0.04623271f, -0.02133775f, -0.05808979f, -0.07513459f, 0.04414341f, -0.07856642f, 
    0.03243361f, 0.06776167f, -0.00108400f, 0.05576865f, 0.06836484f, 0.07882099f, -0.00934577f, 0.05853095f, 
    -0.08433466f, -0.00751468f, -0.03305310f, -0.08512397f, -0.01944278f, 0.07193228f, 0.07831184f, 0.05828213f, 
    -0.05459847f, -0.06523693f, -0.04069982f, -0.01161651f, -0.03681402f, -0.08431933f, -0.00275796f, -0.00280262f, 
    -0.03191654f, -0.01768166f, -0.01452415f, 0.06837564f, 0.06856985f, -0.04110118f, -0.10366385f, -0.09357967f, 
    -0.06536075f, 0.03163822f, 0.04722185f, -0.00516542f, -0.08507034f, 0.05865841f, 0.02725585f, 0.00046087f, 
    -0.09026834f, -0.06874320f, -0.07973004f, 0.03382641f, -0.03416170f, -0.05145536f, 0.06495161f, -0.08695295f, 
    -0.09686187f, 0.04990816f, -0.37364489f, 0.14331110f, -0.06921656f, 0.06998451f, -0.06682940f, 0.07232340f, 
    0.33919284f, 0.05764838f, -0.05995013f, -0.08251572f, 0.08477676f, 0.18500645f, 0.03945439f, 0.03436308f, 
    0.27976710f, -0.16270539f, 0.06371491f, 0.12883477f, 0.02174559f, 0.15188108f, -0.01305055f, 0.13111292f, 
    -0.06935917f, 0.06664270f, -0.11308219f, -0.05247569f, 0.14573374f, -0.14487913f, 0.16455479f, 0.03075253f, 
    0.13245218f, 0.05483606f, -0.03343660f, 0.01355043f, 0.15674567f, 0.14097829f, 0.26526845f, -0.05534117f, 
    0.18946731f, 0.21228039f, 0.08558331f, 0.44402361f, -0.11284438f, -0.05627368f, 0.29387784f, 0.09319340f, 
    0.36123452f, -0.24108286f, -0.08356151f, -0.23510009f, -0.23916180f, 0.39486542f, -0.10578385f, 0.19617736f, 
    0.03554415f, -0.01463371f, -0.28995761f, 0.12489714f, -0.15909019f, 0.09482145f, 0.10939804f, -0.10823778f, 
    0.02922105f, 0.14231187f, 0.20855924f, -0.05182641f, 0.00707152f, -0.15956081f, 0.00605233f, -0.08280340f, 
    -0.15035580f, 0.21129726f, 0.15251140f, -0.38612068f, 0.18308160f, 0.15713964f, -0.22394049f, -0.30825824f, 
    -0.14229356f, -0.07280406f, 0.32282311f, 0.26276737f, -0.16637944f, 0.36663702f, 0.23133890f, -0.15426789f, 
    -0.02420126f, -0.12046799f, -0.29798147f, -0.39218393f, -0.02894546f, -0.07058434f, 0.02412660f, -0.35006851f, 
    -0.12293915f, 0.08411650f, 0.01879987f, -0.37631822f, 0.24624208f, 0.02473979f, -0.32218310f, -0.03864963f, 
    0.18993610f, 0.05202350f, -0.02036865f, 0.02341851f, -0.04788662f, 0.21024656f, -0.27066359f, 0.01713640f, 
    0.25994059f, 0.07356298f, 0.03093755f, -0.20585676f, 0.07945905f, -0.59165657f, -0.18356274f, 0.12857212f, 
    -0.23163070f, 0.04372408f, -0.17054670f, 0.20354326f, 0.32393560f, 0.32796708f, -0.02515325f, 0.08471709f, 
    -0.47970101f, 0.32805702f, -0.04033690f, 0.12297057f, 0.11319853f, -0.01723503f, 0.24864921f, 0.17544673f, 
    0.05222044f, 0.07468307f, -0.01238152f, 0.04076611f, -0.04803628f, -0.03260872f, 0.01002580f, -0.18402945f, 
    -0.07835831f, 0.00268215f, -0.02114349f, 0.10959356f, 0.11007138f, -0.17863753f, 0.01030957f, -0.01490470f, 
    0.06293129f, -0.12055041f, 0.06927619f, 0.45894220f, -0.31269357f, -0.12269887f, -0.07818475f, -0.18907864f, 
    -0.04783041f, 0.39464843f, 0.02451176f, 0.07506192f, 0.10849317f, 0.00886957f, -0.01652103f, 0.12262181f, 
    0.33078250f, 0.12649165f, 0.29940975f, 0.03181178f, 0.28066468f, -0.06028230f, -0.02967344f, -0.25306663f, 
    0.21502747f, -0.03619775f, 0.08638787f, -0.08428882f, -0.02437700f, 0.00118448f, -0.48185506f, -0.28460330f, 
    -0.16600417f, -0.12508923f, 0.19651924f, 0.13861069f, 0.11935289f, 0.02037288f, -0.08553971f, 0.10742504f, 
    0.28627351f, -0.21082407f, -0.18822819f, -0.11485994f, -0.11974222f, -0.43399113f, 0.04297156f, -0.09176021f, 
    0.08853070f, -0.19484243f, 0.32306576f, -0.54923797f, 0.09147435f, 0.19767389f, -0.18461181f, -0.02315112f, 
    0.12705907f, -0.33316824f, 0.02421963f, -0.24451806f, -0.00822621f, -0.21043031f, 0.11298311f, -0.03753067f, 
    -0.05595877f, 0.02226298f, 0.08265267f, -0.08640420f, 0.26356640f, -0.06007416f, 0.03441093f, -0.14533830f, 
    -0.39606231f, 0.61810702f, 0.13962476f, -0.23791766f, 0.18122977f, 0.10515111f, 0.03859540f, -0.06520606f, 
    -0.08600616f, 0.44490463f, 0.05170113f, 0.07067677f, 0.29003182f, 0.08531660f, -0.01425097f, 0.01738446f, 
    -0.42319018f, -0.09316402f, -0.11355940f, -0.00402312f, 0.02447274f, -0.76257986f, 0.02964636f, -0.02890725f, 
    0.08115783f, 0.21444860f, 0.42529443f, -0.05136507f, 0.26053566f, 0.13995671f, 0.03064356f, 0.40819237f, 
    -0.31821728f, 0.26550668f, -0.05054422f, 0.08687255f, 0.12511167f, 0.22698212f, 0.23899986f, 0.04340493f, 
    0.00600787f, 0.29962841f, -0.06654126f, -0.12035285f, 0.02983011f, -0.07545988f, 0.10054933f, -0.06485514f, 
    0.21482854f, -0.34421939f, -0.02844015f, 0.00192056f, -0.38374066f, 0.09311022f, -0.12013441f, -0.12386382f, 
    0.04973155f, -0.00288465f, 0.03085893f, 0.46495429f, 0.01998133f, 0.24875173f, 0.40838045f, -0.04382818f, 
    -0.05032571f, 0.34089923f, -0.33570790f, -0.27910349f, 0.35540381f, -0.04764101f, 0.06604302f, 0.29139474f, 
    0.26002792f, 0.28955311f, 0.31863421f, 0.46159387f, 0.56356293f, 0.04195566f, 0.17625812f, -0.45700282f, 
    0.15894888f, -0.41798773f, -0.07676996f, -0.11440869f, -0.26700968f, -0.15924838f, -0.19116411f, -0.22300594f, 
    -0.14487572f, -0.03763441f, 0.29284373f, -0.08893512f, -0.08825202f, -0.06021003f, 0.00383027f, 0.21759023f, 
    -0.03650706f, -0.10701162f, 0.04552827f, -0.13305718f, 0.03290814f, -0.02323145f, -0.04668328f, -0.16619246f, 
    0.18499234f, 0.04418681f, -0.02859074f, 0.05941365f, 0.20596206f, 0.06026189f, -0.00571969f, -0.32961860f, 
    -0.33177277f, 0.24932809f, -0.05248237f, -0.17930888f, -0.00400999f, 0.45924327f, 0.18880986f, -0.05423358f, 
    -0.10850115f, -0.05602020f, 0.07982934f, -0.06683251f, 0.12215340f, -0.24360649f, -0.03701265f, 0.27070990f, 
    -0.08492385f, 0.51976907f, 0.32853812f, 0.11320551f, 0.30990475f, -0.10109536f, 0.01786008f, 0.23641905f, 
    -0.02516019f, 0.41492635f, -0.07438160f, -0.13689128f, 0.22209378f, 0.19693820f, 0.19042158f, 0.26129860f, 
    -0.03083519f, -0.00470037f, 0.30962938f, 0.26397741f, 0.07167709f, -0.42087737f, -0.14069842f, 0.13872793f, 
    0.14284982f, 0.26875377f, -0.17683420f, -0.18705486f, 0.15620957f, -0.06409299f, -0.15392430f, 0.63431358f, 
    0.42019361f, 0.15024467f, 0.12719290f, -0.05310541f, 0.01537749f, -0.02169901f, -0.08466677f, 0.18093948f, 
    0.18029313f, -0.01859180f, 0.02387931f, 0.11831400f, 0.09071924f, -0.07331380f, 0.15291673f, 0.19785455f, 
    -0.13885726f, 0.55596173f, -0.08953825f, 0.12261968f, 0.14023635f, -0.41474998f, 0.05065765f, 0.02986514f, 
    -0.02936967f, 0.05633074f, 0.59714329f, -0.04107649f, -0.22149904f, 0.04365448f, -0.23491961f, 0.21745606f, 
    -0.19439562f, -0.04334043f, 0.22810033f, 0.36263329f, -0.15728097f, 0.07631037f, -0.03120155f, -0.15998796f, 
    0.26756641f, 0.17030333f, -0.12594341f, -0.20033188f, -0.72754270f, 0.29030234f, 0.04953970f, 0.16391362f, 
    0.12478054f, -0.19528060f, -0.00964766f, -0.12803708f, 0.12332912f, 0.04436161f, 0.02808058f, 0.07774835f, 
    0.05949360f, 0.03218536f, 0.43402973f, 0.04311245f, 0.15928425f, -0.00731900f, 0.06099982f, -0.06714614f, 
    -0.13762079f, -0.08413303f, 0.06934755f, 0.16326377f, 0.71190381f, 0.20247574f, 0.08499265f, 0.30944222f, 
    -0.06152346f, -0.00497487f, -0.00436041f, 0.03852896f, -0.05520153f, 0.03595428f, 0.11968693f, -0.21622410f, 
    0.01664838f, -0.35827908f, 0.02070913f, 0.20656566f, 0.06415576f, -0.38503522f, 0.25073236f, 0.10256345f, 
    0.01239503f, 0.04898984f, 0.30563530f, 0.05111216f, 0.11584805f, -0.07317002f, -0.00019636f, 0.01783870f, 
    -0.24943443f, 0.07175192f, 0.10625882f, -0.15386066f, 0.10133722f, 0.41462466f, -0.35291842f, -0.11426714f, 
    -0.10172132f, -0.07440256f, 0.07284506f, -0.03282378f, 0.10655668f, -0.21880798f, 0.06597857f, 0.20973413f, 
    -0.06402698f, 0.04665031f, 0.09597813f, 0.21949326f, 0.12336327f, 0.32664689f, 0.19497342f, -0.02070609f, 
    0.17530230f, 0.07124481f, -0.03769119f, 0.02746516f, -0.06070464f, -0.16701439f, 0.01960650f, -0.16101493f, 
    -0.49274385f, 0.21274982f, -0.13757275f, 0.03880413f, 0.12400045f, 0.14604084f, 0.21909820f, -0.03927923f, 
    0.05769416f, 0.04475968f, 0.08307868f, -0.43221438f, 0.10104898f, 0.13856758f, 0.04142796f, -0.25175804f, 
    0.32799834f, -0.58305568f, 0.05195046f, 0.08397688f, -0.70592409f, 0.64304501f, -0.25447002f, 0.06602663f, 
    0.01671890f, 0.16865177f, -0.49092957f, 0.21115464f, -0.19014260f, 0.19345550f, 0.29969740f, 0.01507614f, 
    -0.10354588f, 0.15529504f, -0.39774019f, -0.55424124f, 0.17659619f, 0.05488874f, 0.20120583f, 0.01307122f, 
    0.28427267f, -0.15600313f, 0.43225423f, 0.25848216f, -0.01368258f, 0.14340666f, 0.08400634f, -0.21974820f, 
    0.10892466f, 0.39732707f, 0.03340466f, 0.28942561f, -0.07295144f, -0.10241441f, 0.22381231f, -0.42163125f, 
    -0.12479079f, 0.04659761f, -0.35020807f, 0.10533159f, -0.17286143f, 0.07602798f, 0.04167717f, 0.28212461f, 
    0.11725303f, -0.22363234f, 0.00990295f, 0.07697634f, -0.12748305f, -0.10138663f, 0.01670348f, -0.48897064f, 
    0.18636088f, -0.14339252f, -0.18633929f, 0.28277916f, 0.37124643f, 0.00091612f, -0.18744966f, 0.01736045f, 
    -0.16301312f, 0.62501550f, 0.02859546f, -0.39085516f, 0.24253963f, 0.06202151f, -0.12431609f, 0.11911026f, 
    -0.18909505f, 0.00306326f, -0.07812218f, 0.07987651f, -0.44719940f, 0.02460642f, -0.06371570f, -0.01792656f, 
    0.05106760f, -0.14728062f, 0.11485603f, 0.14021215f, 0.11849452f, 0.41695726f, 0.27460423f, 0.35771441f, 
    0.15618025f, 0.19779763f, -0.06394245f, 0.07119970f, 0.00011318f, 0.23284175f, 0.01401282f, -0.06236132f, 
    0.66112697f, 0.00575468f, 0.26253080f, 0.05373873f, -0.00780456f, -0.29457423f, -0.23437092f, 0.19123688f, 
    -0.15859856f, 0.19809891f, -0.13532022f, -0.26910156f, 0.00201082f, 0.26101103f, -0.00835357f, 0.13733795f, 
    -0.26321349f, 0.08028371f, -0.13112141f, 0.22350292f, 0.15172197f, 0.15650333f, 0.37658051f, -0.08488015f, 
    0.01352563f, -0.01072033f, -0.02714870f, -0.30406457f, 0.04954487f, 0.03543592f, -0.04013849f, -0.13922791f, 
    0.16317317f, -0.88808584f, 0.14375603f, 0.23863785f, -0.18144590f, 0.64701331f, -0.01905238f, 0.25968683f, 
    0.08118743f, 0.00474117f, -0.09959583f, 0.43995801f, 0.27047026f, 0.38142732f, 0.52275258f, -0.27810684f, 
    0.34752584f, 0.27945665f, -0.27023953f, -0.53208774f, 0.36778826f, 0.08030072f, 0.18265697f, 0.36400735f, 
    0.11042075f, -0.17128326f, 0.13337325f, 0.48162127f, -0.12811004f, -0.06107474f, 0.17818120f, 0.08632906f, 
    -0.00982719f, -0.00364942f, 0.06267394f, -0.12196711f, 0.00119173f, 0.01630942f, 0.07105258f, -0.20252214f, 
    -0.05074010f, -0.08814859f, -0.16656528f, 0.10451133f, -0.21275407f, 0.22512308f, -0.08863095f, 0.24813356f, 
    0.15161881f, -0.12519524f, 0.05596748f, 0.15083021f, -0.51905197f, -0.34245750f, 0.04610547f, -0.62268162f, 
    0.27404886f, 0.02840274f, -0.06521022f, -0.32589084f, 0.21887825f, 0.11283261f, -0.37108198f, 0.09027482f, 
    -0.66273189f, 0.47193089f, -0.18943703f, -0.38204047f, 0.41711125f, -0.36855730f, -0.22333767f, 0.11231785f, 
    -0.26374155f, 0.12279867f, -0.17637931f, -0.13319907f, -0.02246681f, 0.04950967f, 0.04711483f, -0.09498072f, 
    0.19521223f, -0.04652516f, -0.00111089f, 0.04676838f, -0.07044996f, -0.25905937f, 0.21919009f, 0.45905888f, 
    0.34792575f, 0.26347148f, 0.07732544f, 0.14417961f, 0.24542971f, 0.21872495f, 0.01765218f, 0.12721440f, 
    0.15298326f, -0.07796235f, 0.00166852f, 0.01701163f, 0.14377129f, -0.93107188f, -0.39052895f, 0.34299043f, 
    -0.30666578f, 0.21882303f, -0.08544583f, -0.28730506f, 0.30193597f, 0.23825896f, 0.16509239f, 0.66913432f, 
    -0.08395796f, 0.06081496f, 0.17687455f, -0.02319396f, -0.01672481f, 0.17324694f, 0.28127250f, 0.12004344f, 
    -0.02288214f, 0.22533390f, 0.05483082f, -0.05502049f, -0.03832766f, -0.21996234f, 0.03756362f, -0.12237796f, 
    -0.21691832f, -0.10976064f, 0.18168312f, -0.15159759f, -0.28966334f, 0.12326949f, -0.11441261f, 0.01620432f, 
    -0.01306194f, 0.00226860f, 0.11314379f, 0.26843846f, 0.29758537f, 0.90021706f, 0.42500281f, 0.32538429f, 
    -0.07358537f, 0.02559367f, -0.28992939f, -0.17563915f, 0.03793828f, -0.07373281f, 0.05376824f, 0.27407312f, 
    0.07703947f, 0.13247876f, 0.36054382f, 0.19314826f, 0.46590272f, -0.17128964f, 0.03944414f, -0.02382558f, 
    -0.12630914f, -0.14584984f, -0.09646425f, 0.21970755f, 0.42177317f, -0.13937652f, 0.02287461f, 0.04816831f, 
    -0.02611275f, 0.07195123f, -0.03289776f, -0.05598560f, 0.11670569f, 0.11322413f, 0.07077542f, 0.27011159f, 
    0.25142333f, 0.06006359f, -0.00289327f, -0.01303799f, -0.17601381f, -0.04158219f, 0.04602418f, -0.02434944f, 
    0.15559904f, 0.03592039f, -0.05956581f, 0.12599465f, 0.18731107f, 0.12185852f, 0.49271220f, 0.05030726f, 
    -0.41251963f, 0.19318376f, -0.11030495f, -0.08025169f, 0.07266230f, 0.07868353f, -0.00124359f, 0.01474710f, 
    0.14467953f, 0.00539551f, -0.11585474f, 0.26660532f, 0.21524552f, -0.03107437f, 0.06384692f, 0.37637633f, 
    0.26278955f, -0.23512475f, 0.09162683f, 0.11244371f, 0.08854642f, -0.19453014f, 0.06075625f, 0.22366099f, 
    0.06230724f, 0.18463483f, -0.02633178f, -0.02767989f, 0.14013374f, 0.08409247f, 0.12893441f, 0.35489509f, 
    0.11410046f, -0.02614888f, -0.06965751f, 0.12400391f, 0.08875237f, 0.20460205f, -0.15686198f, 0.19159177f, 
    0.20336407f, 0.20549011f, -0.12674855f, -0.10234795f, 0.03664558f, -0.03481828f, 0.11351733f, 0.26621005f, 
    -0.26507533f, 0.15910524f, 0.03668733f, -0.13809401f, 0.08627126f, 0.18688072f, 0.06612282f, 0.12089349f, 
    0.20287926f, 0.17916110f, -0.03127398f, -0.08574845f, 0.13738355f, -0.08147704f, 0.05204922f, -0.09895136f, 
    -0.01988766f, 0.11303633f, 0.09688634f, -0.03767133f, -0.00849164f, 0.16900575f, -0.12726288f, 0.19409786f, 
    0.07763904f, -0.00968438f, -0.04399064f, 0.19286342f, -0.10012171f, 0.00874645f, 0.00638723f, -0.09368362f, 
    -0.01014657f, 0.13476045f, -0.02867752f, -0.03900888f, 0.21522462f, 0.02657396f, 0.02099282f, 0.02112032f, 
    0.01333178f, 0.35463104f, 0.22055493f, 0.27225542f, 0.24585679f, -0.27150366f, -0.05962812f, -0.00367912f, 
    0.21162802f, -0.21883366f, -0.00730402f, -0.22822630f, 0.02848619f, -0.03038655f, -0.08903790f, -0.08959603f, 
    -0.06981756f, -0.03314703f, 0.16181910f, -0.02004707f, -0.07585551f, 0.04705919f, -0.01856388f, -0.06082283f, 
    -0.03517866f, 0.07892533f, -0.08097040f, 0.04775080f, 0.01520537f, -0.05416640f, 0.06911878f, -0.05787818f, 
    0.13199230f, -0.09391615f, 0.12340163f, 0.00103258f, 0.09600981f, 0.00572384f, -0.07593542f, -0.25394079f, 
    -0.27769265f, -0.00438818f, 0.13944049f, -0.03215524f, -0.03602049f, -0.06083237f, -0.03019298f, 0.01902437f, 
    -0.00268679f, -0.01030410f, 0.06025752f, -0.10192866f, 0.24111468f, 0.01322526f, 0.06836614f, -0.00908055f, 
    -0.24312592f, 0.32872552f, 0.09398261f, -0.12382026f, 0.22267164f, 0.01295193f, -0.01094394f, 0.04032380f, 
    -0.00339581f, 0.35858804f, -0.00828249f, -0.07955641f, 0.08345784f, 0.04811335f, -0.11593514f, 0.08679126f, 
    -0.07814091f, 0.04746652f, -0.15350653f, -0.03909972f, 0.00207614f, -0.56370890f, -0.14514707f, 0.04292764f, 
    0.04871337f, 0.16233952f, 0.15879732f, -0.04112519f, 0.32544428f, 0.07200640f, -0.08768832f, 0.25923994f, 
    0.50887328f, 0.40074053f, -0.00284822f, 0.05976683f, 0.01580817f, 0.06495671f, -0.14407340f, -0.07865195f, 
    0.03154781f, 0.11259326f, -0.06954958f, 0.31136721f, -0.18861754f, 0.14047362f, 0.10695385f, -0.05099131f, 
    0.09348312f, 0.33358803f, 0.02062510f, 0.09562092f, 0.13758364f, -0.10522964f, 0.19510131f, 0.04350730f, 
    -0.04003188f, -0.14522742f, 0.01073082f, 0.09834851f, 0.19396554f, -0.17500688f, -0.21049701f, 0.12191636f, 
    0.28771827f, 0.14786251f, 0.26058954f, 0.43696120f, 0.06966363f, -0.00717074f, -0.21718858f, 0.11932611f, 
    -0.08299519f, -0.22429143f, 0.15088871f, -0.16187553f, -0.37472022f, 0.25820288f, 0.11500803f, 0.09963239f, 
    -0.04381845f, -0.56260836f, -0.08491018f, -0.56571245f, -0.06162149f, 0.13089898f, 0.18573573f, 0.32531545f, 
    -0.04978703f, 0.08652680f, 0.39401430f, -0.19306311f, 0.21672136f, -0.18819705f, -0.05197196f, 0.16281864f, 
    0.05712374f, 0.20967321f, 0.16614221f, -0.05339579f, 0.42108530f, -0.32532853f, -0.02666230f, -0.26604220f, 
    -0.02790678f, -0.11745903f, -0.16711397f, -0.23465578f, -0.28046259f, -0.07930584f, 0.27366158f, 0.32092530f, 
    -0.48898041f, -0.15551767f, 0.28021452f, -0.12026975f, 0.04489347f, 0.15552148f, 0.00404730f, -0.00492463f, 
    0.06028852f, -0.05819082f, 0.23348060f, -0.32889682f, 0.11067640f, -0.04068999f, -0.02421099f, -0.03630143f, 
    0.08521622f, 0.16026150f, 0.12350357f, 0.16823772f, -0.04671342f, 0.17625479f, -0.01296268f, -0.05030679f, 
    -0.15180512f, 0.06535432f, -0.00552484f, 0.03071532f, 0.16400608f, 0.04396818f, 0.55917192f, 0.05251594f, 
    0.14084347f, 0.01214512f, 0.08097329f, 0.12672114f, -0.06476196f, -0.24175239f, -0.14107817f, -0.07740180f, 
    0.02023163f, 0.13861834f, 0.45478296f, 0.22283329f, -0.09020371f, -0.05086452f, -0.16346431f, -0.27737713f, 
    -0.07811989f, -0.02291204f, 0.03840005f, 0.01385867f, 0.07765500f, 0.16210905f, 0.02864962f, 0.01424073f, 
    0.16201657f, 0.23056319f, -0.05172990f, -0.00422760f, 0.12877542f, 0.17329894f, -0.01574148f, 0.07146654f, 
    0.28645158f, -0.27665886f, -0.09234299f, 0.20533785f, 0.24207820f, 0.14771391f, 0.02838611f, -0.01583533f, 
    -0.07206377f, 0.08414032f, -0.08262919f, -0.10640582f, -0.03567536f, 0.04356031f, 0.10263990f, -0.02909184f, 
    0.07470042f, 0.01406316f, 0.03574971f, -0.06082875f, 0.06023910f, 0.25873235f, 0.06026444f, 0.23466678f, 
    0.17490847f, -0.70221430f, 0.18918784f, 0.32021564f, -0.01541298f, 0.13741902f, 0.03810403f, 0.09380394f, 
    0.21293566f, 0.06230036f, 0.03218658f, 0.05294205f, -0.38459608f, 0.17819452f, -0.06423908f, 0.14215370f, 
    -0.22573964f, -0.14393115f, -0.16497126f, 0.00069684f, 0.11875978f, 0.07023375f, -0.12244561f, -0.02522629f, 
    -0.16257501f, -0.06762972f, 0.17221420f, 0.00995346f, -0.49516478f, -0.12663189f, 0.02731924f, 0.01420563f, 
    -0.08766394f, 0.14803861f, 0.12591021f, -0.22480796f, 0.14352895f, 0.07223140f, 0.12732399f, -0.10074330f, 
    -0.03149138f, 0.03095726f, 0.13957414f, -0.03672717f, 0.12056434f, 0.23430693f, 0.19575062f, 0.17877756f, 
    -0.23802724f, 0.00416368f, 0.13098945f, -0.13193256f, -0.13942498f, -0.02949652f, -0.09446061f, -0.08758700f, 
    -0.12953070f, -0.09363228f, 0.27175784f, -0.06088493f, 0.21420138f, -0.12680076f, -0.02558463f, 0.04217761f, 
    -0.01081172f, 0.09746819f, -0.00884767f, -0.00550456f, 0.16893536f, 0.27548853f, -0.11957557f, -0.04168961f, 
    0.06332073f, 0.04208455f, 0.08795632f, -0.12923852f, 0.01628055f, -0.33742037f, -0.00793149f, 0.09065367f, 
    -0.09948897f, 0.08104160f, -0.09008224f, 0.07829142f, 0.12417717f, 0.13890283f, 0.03847656f, 0.06478972f, 
    -0.13454668f, 0.07212073f, -0.29095951f, 0.24892426f, -0.07997924f, -0.09385474f, -0.16850629f, 0.06883923f, 
    0.45100078f, 0.06950627f, 0.04755247f, -0.02793146f, -0.07593317f, 0.40989670f, -0.10829018f, -0.06589047f, 
    0.26852128f, -0.53051072f, -0.13993810f, 0.12042185f, 0.15961257f, 0.14400777f, 0.02370872f, -0.06065975f, 
    -0.02757448f, 0.03341272f, 0.12895086f, -0.03173190f, 0.09523161f, -0.11995661f, 0.01545169f, -0.28146785f, 
    0.32186472f, 0.00638933f, 0.08341287f, 0.15096216f, 0.16809458f, 0.18136525f, 0.23976408f, -0.03588178f, 
    0.13976127f, 0.18176472f, 0.10633689f, 0.35007599f, 0.14224966f, -0.15798199f, 0.25518733f, 0.10790825f, 
    0.40742841f, -0.20026584f, -0.00307568f, -0.07386199f, -0.18166322f, 0.47988537f, -0.11163423f, 0.02114352f, 
    0.22925422f, -0.11646154f, -0.13003674f, 0.01666079f, -0.04298968f, 0.16210933f, -0.12655152f, -0.22983901f, 
    0.20237835f, 0.09576814f, 0.25573620f, 0.02088675f, -0.05793924f, -0.23263812f, -0.02238129f, 0.02744386f, 
    -0.23033926f, 0.12552096f, 0.29183418f, -0.25142956f, 0.05865268f, 0.43183845f, -0.29262948f, 0.23098783f, 
    0.52050304f, -0.18478528f, 0.27192351f, 0.02579797f, -0.09158295f, 0.31595170f, 0.11443287f, -0.04533819f, 
    -0.15884425f, 0.01628376f, -0.34987688f, -0.20338911f, -0.02992627f, 0.02051479f, -0.00420725f, -0.44367930f, 
    -0.11464766f, -0.25982314f, 0.05781857f, -0.06369642f, 0.37981510f, -0.10209961f, -0.13987195f, -0.00768462f, 
    0.06277691f, 0.03948051f, -0.07549931f, -0.01382353f, 0.08435503f, 0.21204343f, -0.30790931f, -0.20782354f, 
    -0.41893831f, 0.02754869f, 0.04202808f, -0.08080207f, -0.05640199f, -0.44801438f, 0.13877742f, 0.10007168f, 
    -0.36490378f, 0.08202222f, -0.11154084f, 0.47679457f, 0.45609105f, 0.20610607f, 0.10052471f, 0.16706777f, 
    -0.14299138f, 0.05622450f, 0.03087225f, 0.04247686f, 0.14972450f, 0.07636395f, 0.21334834f, 0.13647974f, 
    -0.03165491f, -0.01550225f, 0.04057672f, 0.00917927f, 0.11476632f, -0.02941454f, -0.10878255f, 0.01619386f, 
    -0.08763210f, -0.58760923f, 0.08144627f, -0.03058533f, 0.01574412f, -0.32654822f, 0.04915342f, 0.00202097f, 
    -0.06040640f, 0.08816899f, 0.42628542f, 0.04221265f, -0.33084607f, -0.06281561f, 0.11473989f, -0.34105417f, 
    -0.36464620f, 0.11992162f, 0.10190479f, -0.08302727f, 0.04481325f, -0.09917696f, 0.05267119f, 0.04957255f, 
    0.24858496f, 0.05407662f, -0.24041057f, -0.00996624f, -0.09265383f, 0.16113774f, 0.03528763f, -0.12849894f, 
    0.07889980f, -0.06531650f, -0.04994180f, 0.22927684f, -0.05624303f, -0.15347372f, -0.03029656f, -0.17998463f, 
    0.10268115f, 0.06738359f, 0.28215513f, 0.06056574f, 0.08251344f, 0.08545801f, 0.08478326f, 0.10513105f, 
    0.13318661f, -0.01178469f, -0.02846818f, 0.12103632f, -0.32196754f, 0.22367270f, 0.04185829f, 0.11877586f, 
    0.17094144f, -0.11719497f, 0.19614710f, -0.01634005f, 0.02363784f, -0.05973510f, -0.12999339f, -0.33009198f, 
    0.23716724f, 0.03732853f, -0.42534587f, 0.16696101f, 0.09565561f, -0.17615066f, 0.07956802f, 0.02926049f, 
    0.08384217f, -0.06589404f, -0.05022730f, 0.20859118f, -0.05883624f, -0.05034315f, 0.06291755f, 0.09874895f, 
    -0.21134833f, 0.11855857f, -0.04299492f, -0.05439252f, -0.04976301f, 0.26261607f, 0.01498324f, 0.00062191f, 
    0.05453050f, 0.18125299f, 0.04948221f, -0.04062657f, 0.17932545f, -0.02613903f, -0.00466804f, 0.09987274f, 
    -0.58188301f, -0.00675266f, 0.27206746f, 0.15473299f, 0.12830201f, -0.27568278f, 0.25894096f, 0.04890931f, 
    0.21860103f, 0.13817447f, 0.00128438f, -0.18560202f, -0.02146806f, -0.08600061f, 0.04899139f, 0.32569215f, 
    -0.03301871f, 0.03513778f, -0.06059995f, -0.08819317f, 0.00450890f, -0.08193741f, 0.01418920f, 0.04561104f, 
    -0.04320083f, -0.04308502f, -0.05897254f, 0.01531516f, -0.08487593f, 0.00155645f, -0.00002360f, -0.03480626f, 
    0.02505606f, -0.02597700f, -0.08515976f, -0.07344120f, -0.00463357f, -0.01126969f, 0.03055737f, 0.00551687f, 
    0.01190691f, -0.05531834f, 0.04130184f, -0.07304212f, 0.05414918f, -0.03354390f, -0.00342482f, 0.03957036f, 
    0.04744790f, -0.05500676f, 0.04250100f, -0.09458893f, -0.05657938f, -0.02057321f, 0.04852361f, 0.03221031f, 
    -0.01653012f, 0.07196555f, -0.07116991f, 0.00279016f, 0.01893349f, -0.06109800f, -0.10548961f, -0.11429023f, 
    0.03091701f, -0.00891836f, 0.00643953f, -0.04583049f, -0.04603880f, -0.06537037f, 0.06524350f, 0.04599844f, 
    0.02300528f, 0.00101493f, -0.05717440f, 0.03174895f, 0.00027135f, 0.00331832f, -0.07367785f, 0.03245219f, 
    -0.05006929f, -0.02405764f, -0.06241263f, 0.01994422f, -0.00266869f, -0.07214835f, -0.03076029f, -0.06530158f, 
    -0.08041101f, -0.07938909f, -0.07048495f, -0.01864192f, 0.07283777f, 0.01688534f, -0.05102875f, -0.00481130f, 
    0.03775883f, -0.06134019f, -0.01349435f, -0.09726277f, -0.03169477f, 0.02472052f, -0.09979872f, -0.08090713f, 
    0.01881131f, -0.08128542f, 0.00709029f, 0.04176350f, 0.01192120f, -0.04292324f, -0.03783286f, -0.11375018f, 
    0.00410789f, 0.02673105f, 0.03718897f, 0.01262543f, 0.03339923f, 0.07876986f, 0.00510894f, 0.07191231f, 
    -0.06095879f, -0.03937469f, 0.07226242f, 0.04269594f, -0.09974221f, -0.07141569f, -0.03688972f, 0.02414763f, 
    -0.07078185f, -0.02746672f, 0.03719690f, 0.05333075f, 0.01072115f, -0.07268642f, 0.03330801f, -0.06265560f, 
    -0.10435077f, -0.09979949f, 0.06364742f, 0.02255969f, -0.08765095f, -0.03761258f, -0.04579996f, -0.04455452f, 
    -0.31268817f, -0.02465890f, -0.31774098f, 0.03452085f, -0.03577255f, -0.03488328f, -0.09732676f, 0.09763694f, 
    0.26963514f, 0.11993840f, -0.02819861f, 0.06190115f, 0.04697589f, 0.29273832f, -0.00563888f, -0.14300403f, 
    0.12324478f, -0.14680979f, 0.12347081f, 0.23944086f, -0.10892622f, 0.47760752f, -0.06704362f, 0.08687620f, 
    0.03090268f, -0.01577019f, -0.66390282f, 0.27915457f, 0.40497074f, 0.12858514f, 0.05780584f, -0.04216626f, 
    0.36376572f, 0.03085088f, 0.06654133f, 0.16777261f, 0.29860303f, -0.01047935f, 0.22334519f, -0.01459126f, 
    -0.05462909f, -0.08335225f, 0.16623297f, 0.51066911f, 0.15138724f, -0.21413283f, 0.22216584f, -0.02555476f, 
    0.26909414f, 0.15540616f, -0.01898662f, 0.13902219f, -0.17357837f, 0.33413544f, 0.04127711f, 0.12451221f, 
    -0.36331254f, -0.10579689f, -0.26527777f, 0.05305889f, -0.03086744f, 0.21422450f, -0.07941946f, -0.03219485f, 
    0.01044935f, 0.05345498f, 0.16554722f, 0.00629762f, -0.18490839f, -0.34729138f, -0.03882986f, -0.48150054f, 
    -0.07195690f, 0.19161053f, 0.02975733f, -0.14472231f, 0.16841893f, 0.24841917f, 0.03146371f, -0.07837273f, 
    -0.30405462f, 0.06946705f, 0.22724727f, -0.14006127f, 0.06628706f, 0.35743874f, -0.01988965f, 0.04896716f, 
    -0.07172386f, -0.02305044f, -0.10376253f, -0.16346882f, -0.21819799f, 0.05383326f, 0.04062000f, -0.23053928f, 
    0.02207547f, -0.47110090f, 0.04615208f, -0.12377711f, 0.25609118f, -0.13349487f, -0.04915779f, 0.00488035f, 
    0.07932967f, 0.12819453f, -0.01361318f, 0.16789810f, -0.07441127f, 0.24553585f, -0.17090932f, -0.08274825f, 
    0.45825550f, -0.01129223f, -0.12027792f, -0.24896000f, 0.03183159f, -0.38118017f, -0.00875089f, 0.11282059f, 
    -0.30310032f, 0.00489177f, -0.15589370f, 0.16898583f, 0.30737403f, 0.33724818f, 0.08656815f, 0.07323067f, 
    -0.00922461f, -0.03424307f, 0.02129705f, 0.07023687f, 0.05125292f, -0.09965089f, 0.03655828f, -0.04724028f, 
    -0.09023499f, 0.02320618f, -0.06192291f, -0.09362894f, 0.05672340f, -0.07533145f, -0.07985274f, 0.03792118f, 
    0.07370591f, -0.00736505f, -0.05130270f, 0.01415981f, 0.02894593f, 0.00445453f, -0.04624895f, 0.00807539f, 
    -0.03673717f, -0.02699559f, -0.01625368f, 0.00657196f, 0.07399605f, 0.04290984f, 0.01980617f, 0.01379335f, 
    -0.08919878f, -0.07411149f, 0.07306706f, 0.00781198f, -0.04308805f, -0.04034720f, 0.01390649f, -0.00704916f, 
    -0.05611317f, -0.02401527f, -0.08625594f, -0.07310905f, 0.03772165f, -0.09366800f, -0.01576187f, -0.07798246f, 
    -0.02793751f, 0.01858056f, -0.05959033f, -0.04236119f, 0.02748487f, -0.04759035f, 0.01203569f, -0.00412407f, 
    0.03771350f, -0.06543633f, 0.01128389f, -0.01071354f, -0.07749414f, -0.01619355f, -0.00322066f, 0.07349180f, 
    -0.09238678f, -0.06981953f, 0.03066473f, -0.06037945f, -0.00970902f, 0.01355900f, 0.03398979f, 0.02050210f, 
    -0.06373083f, -0.04919443f, 0.00270570f, 0.06927464f, 0.04082265f, 0.07189633f, 0.05836520f, -0.04263465f, 
    0.04985769f, 0.03895641f, -0.01145265f, -0.10044433f, -0.06499524f, 0.00528768f, -0.00893000f, -0.00199512f, 
    -0.03820343f, -0.06788759f, -0.08794662f, 0.06366909f, 0.05981142f, -0.01090278f, -0.02977896f, -0.00679982f, 
    -0.04427935f, -0.00352435f, 0.02704042f, 0.05525225f, -0.00619282f, -0.04966771f, 0.06066507f, -0.08949436f, 
    -0.05762730f, 0.06489754f, -0.04226266f, 0.01537682f, -0.04668910f, -0.03637492f, -0.00320163f, 0.06680138f, 
    -0.03740170f, -0.00510666f, -0.00093294f, 0.06124162f, 0.04595823f, -0.01481484f, -0.04546752f, 0.08032280f, 
    0.02677927f, -0.00379459f, 0.05591911f, 0.05256485f, -0.00898944f, -0.03351014f, -0.04882213f, -0.03118614f, 
    -0.02430109f, 0.01878780f, 0.05300334f, -0.02020193f, -0.03831978f, 0.01433993f, -0.08490662f, -0.07027528f, 
    0.04178666f, -0.03233473f, 0.03453820f, -0.04772158f, -0.05541570f, -0.06921511f, 0.03663769f, -0.08459780f, 
    0.06827477f, 0.06534715f, 0.00009330f, 0.01764366f, 0.04231911f, -0.06529118f, 0.05670692f, -0.06249346f, 
    0.02649090f, -0.04666972f, -0.08116104f, -0.04276809f, -0.02117265f, 0.06668513f, -0.05420132f, -0.08217783f, 
    -0.01744830f, -0.04891570f, -0.03040029f, -0.02133438f, -0.04697648f, -0.06733234f, -0.05673984f, -0.07743098f, 
    -0.03725167f, -0.01571994f, -0.06118295f, 0.04478256f, 0.02348223f, -0.05812277f, -0.06989022f, -0.03338376f, 
    0.02268048f, 0.02641204f, -0.01963055f, 0.04027144f, 0.02921532f, 0.05730940f, 0.07510509f, 0.07312263f, 
    0.01144230f, -0.04910770f, 0.03639140f, 0.00153943f, 0.02386657f, 0.05699826f, -0.08539896f, 0.04056837f, 
    -0.00527320f, -0.06145560f, 0.04067067f, -0.04204778f, 0.07262460f, -0.04323375f, -0.06268795f, 0.03735357f, 
    0.04032054f, 0.06958129f, -0.07814141f, -0.08568992f, -0.05663221f, -0.08142379f, -0.01357768f, -0.02362725f, 
    0.00604975f, -0.07096768f, -0.06906474f, 0.06618939f, -0.02419268f, -0.01709601f, -0.00304020f, 0.01067478f, 
    -0.00886745f, -0.00405733f, -0.02649670f, -0.07661851f, -0.00370340f, -0.06230460f, -0.02844395f, -0.01310011f, 
    0.07639169f, 0.05459195f, 0.05363007f, -0.04959302f, -0.07896418f, -0.08737366f, 0.07155930f, 0.07654931f, 
    0.06366418f, -0.07436514f, 0.07755486f, 0.00183164f, 0.05559310f, -0.05725196f, 0.00859823f, -0.07058071f, 
    0.03228725f, 0.08773860f, 0.00576049f, 0.07056239f, -0.07289101f, 0.05705493f, 0.05141838f, -0.00521936f, 
    -0.03997398f, -0.02835670f, -0.02392774f, -0.08664668f, -0.03899937f, -0.07809095f, 0.05483039f, 0.07632794f, 
    -0.10372055f, 0.22352962f, -0.00168243f, -0.07886710f, 0.13556306f, 0.13893756f, -0.07363411f, 0.15800478f, 
    0.00772935f, -0.05492115f, 0.09330894f, 0.13458900f, 0.16186374f, -0.00357021f, 0.25897288f, 0.08163399f, 
    0.34400499f, 0.71984732f, -0.29298502f, 0.17226335f, 0.33820197f, -0.19603501f, 0.16306016f, 0.10569330f, 
    -0.07688331f, 0.13697198f, -0.05665113f, -0.04129994f, -0.27071008f, -0.38209385f, -0.23204623f, -0.20125571f, 
    -0.11807193f, 0.14762130f, 0.23907059f, 0.19514261f, -0.02774774f, 0.12978500f, -0.09485682f, 0.01405886f, 
    0.22624168f, -0.13730222f, -0.30044630f, -0.09087268f, -0.27153838f, 0.28774881f, 0.12013217f, 0.06491135f, 
    0.13940206f, -0.13379738f, -0.02421209f, -0.28948393f, -0.54303658f, -0.01068911f, 0.17629758f, 0.31218779f, 
    0.23468304f, 0.14932102f, 0.39424559f, 0.02617509f, -0.00139597f, 0.07058568f, 0.00422629f, -0.17341943f, 
    -0.25173005f, 0.02448510f, 0.13073723f, 0.07900663f, 0.03350159f, -0.06124068f, -0.04919482f, 0.08260678f, 
    -0.07144372f, -0.06696707f, -0.05483090f, 0.13209943f, -0.02755913f, -0.13755625f, -0.12791096f, -0.35466233f, 
    0.33307141f, -0.08953637f, 0.23997390f, -0.12539224f, 0.27413467f, 0.17625660f, 0.08625534f, 0.15202537f, 
    -0.19932425f, -0.00459679f, 0.21660611f, -0.33561593f, -0.09779174f, -0.01065403f, 0.03554178f, -0.31085062f, 
    -0.17619537f, 0.48502025f, 0.09375224f, 0.12572387f, 0.01227517f, 0.52396917f, -0.22862148f, -0.08347735f, 
    -0.12065782f, 0.06658783f, 0.02836790f, 0.10464502f, 0.11155239f, -0.04780805f, 0.27659917f, 0.00418583f, 
    -0.28617609f, -0.05468215f, 0.30641088f, 0.30238852f, 0.08401702f, -0.11803757f, -0.17230387f, -0.20807520f, 
    0.02796663f, 0.05319821f, 0.45076293f, 0.12370094f, -0.06129410f, 0.02801479f, -0.07130963f, -0.19136125f, 
    -0.18958053f, -0.02566468f, -0.25189474f, 0.19254854f, 0.08815276f, 0.00627351f, -0.06001560f, 0.03249009f, 
    0.04797420f, -0.04746819f, 0.03561816f, -0.05969199f, -0.06524932f, 0.18628353f, -0.10283790f, -0.02701167f, 
    0.50178123f, -0.18661635f, -0.20966874f, 0.10516886f, 0.13927031f, 0.17874667f, 0.17235880f, 0.05581073f, 
    0.04821748f, -0.03109552f, 0.08232124f, 0.28870606f, -0.10171661f, 0.07657177f, 0.04147262f, -0.37505367f, 
    0.09276055f, 0.16634652f, 0.23195928f, -0.11352554f, 0.13111562f, 0.09562452f, 0.03098783f, 0.22387868f, 
    0.06277272f, -0.43137228f, 0.21327882f, 0.07710218f, -0.39844903f, 0.08866998f, -0.08046706f, 0.09995355f, 
    0.03979240f, 0.07376901f, -0.03329860f, 0.13783310f, -0.33504620f, 0.15066385f, -0.11760284f, 0.11610670f, 
    0.20883214f, -0.18663627f, -0.07053167f, 0.19527973f, -0.05647494f, 0.00769544f, -0.22475120f, -0.02568785f, 
    0.03487407f, -0.06420898f, 0.11818451f, 0.06984131f, 0.02103002f, -0.29881316f, 0.03558635f, -0.02049177f, 
    0.08178157f, 0.06318580f, 0.27246112f, -0.29210696f, -0.08566294f, 0.20846008f, -0.37153998f, 0.52249789f, 
    0.20839334f, -0.05048472f, -0.21847224f, -0.09655348f, 0.21040824f, 0.03652653f, -0.28272501f, 0.09560597f, 
    -0.38747850f, 0.14537770f, -0.04850158f, -0.28088617f, -0.20942445f, -0.05846905f, -0.02621339f, -0.30185938f, 
    0.08883439f, 0.29508626f, -0.13115546f, 0.20518683f, -0.03415644f, -0.32374117f, 0.17685233f, 0.21423224f, 
    0.10172579f, 0.11896753f, -0.05959706f, 0.07373734f, 0.18685913f, 0.18018396f, 0.04296815f, -0.11994954f, 
    -0.31063995f, -0.06693413f, 0.19987337f, -0.16438785f, 0.03985954f, -0.33275175f, -0.15552808f, 0.15254699f, 
    -0.27037519f, -0.03532858f, 0.33416989f, -0.05997275f, 0.24101096f, 0.02217437f, -0.01341852f, 0.26078281f, 
    -0.38871303f, 0.25063705f, 0.10555743f, -0.02968180f, 0.17618233f, 0.08362065f, 0.24666512f, -0.04080452f, 
    -0.40295213f, 0.02503374f, 0.06224233f, -0.13918309f, -0.16374025f, 0.09584597f, -0.12076332f, -0.16877742f, 
    0.35145673f, -0.44931102f, 0.14021046f, 0.02588423f, -0.33477110f, 0.25335920f, 0.08067653f, 0.10609875f, 
    0.01033352f, 0.06865133f, -0.80200523f, 0.07278082f, 0.03439679f, 0.20339850f, 0.26127613f, -0.07539367f, 
    -0.07227885f, 0.22738543f, -0.41957015f, -0.04020570f, 0.03364388f, -0.04439715f, 0.09199145f, 0.26459178f, 
    0.13343574f, -0.56063366f, 0.23244211f, 0.06824692f, 0.46115747f, 0.29448926f, 0.03581882f, -0.17241523f, 
    -0.14280985f, 0.42551884f, 0.02608349f, 0.32632506f, 0.16006812f, -0.16732466f, 0.20425931f, -0.25241309f, 
    -0.49069369f, 0.10494413f, -0.40044945f, -0.07862722f, 0.08034276f, -0.02674940f, 0.14307053f, 0.46625647f, 
    0.35814467f, -0.25550595f, -0.07380430f, -0.12179101f, -0.58081818f, -0.43603820f, -0.00132607f, -0.84454530f, 
    0.22900000f, -0.22263311f, -0.08513073f, -0.02559236f, 0.05718042f, -0.15419798f, 0.05156350f, 0.29192245f, 
    -0.53798217f, 0.44292033f, -0.02465077f, -0.50257301f, 0.09539331f, 0.13373722f, -0.36857662f, -0.03327971f, 
    0.19154614f, 0.06741776f, -0.13454463f, -0.02336729f, -0.23609076f, -0.02918023f, 0.08444028f, 0.23730385f, 
    0.23329589f, -0.28777632f, -0.06680892f, 0.14824411f, -0.19161606f, 0.30722636f, 0.42413336f, 0.13506489f, 
    -0.03208493f, 0.24125372f, -0.05971735f, 0.20750627f, 0.00924775f, 0.21145168f, 0.38220015f, -0.08152951f, 
    0.53158790f, 0.06207979f, 0.13907133f, -0.05827996f, -0.13337727f, -0.36045128f, -0.35162181f, 0.16817962f, 
    0.14606535f, 0.21076949f, 0.23548444f, -0.35320863f, -0.01061069f, 0.32933643f, 0.08013137f, 0.20688145f, 
    0.21342428f, -0.12647301f, -0.04338204f, -0.08873811f, 0.19358370f, -0.03415633f, -0.21138039f, 0.02122418f, 
    -0.19165394f, -0.16329542f, -0.08025105f, 0.12540874f, -0.01094745f, 0.06375436f, -0.10937371f, 0.18579416f, 
    0.07963490f, 0.49893051f, 0.04755814f, 0.09032731f, 0.14950740f, 0.09420060f, 0.11154604f, 0.13160422f, 
    -0.07997142f, 0.10997062f, -0.31633312f, -0.22470649f, 0.23019160f, 0.12499058f, -0.04420492f, 0.41403988f, 
    0.07686973f, -0.17672601f, 0.21434161f, 0.25666875f, -0.08044742f, 0.10122325f, -0.01690109f, -0.09308383f, 
    -0.00792272f, -0.29777545f, -0.15647607f, -0.07642578f, -0.14191824f, 0.00479067f, 0.02651951f, 0.31592798f, 
    -0.06985410f, 0.31025806f, 0.03850364f, 0.06410561f, 0.16594492f, 0.11977197f, 0.29748636f, 0.53307211f, 
    0.24204108f, 0.07668100f, -0.18347920f, 0.07447487f, 0.04405051f, 0.05461207f, 0.07997267f, -0.06109620f, 
    -0.21593641f, 0.00569092f, 0.14274745f, 0.25416791f, 0.03027486f, -0.04579056f, -0.04387749f, 0.19300148f, 
    -0.06840436f, 0.12944329f, -0.00720981f, 0.35856593f, -0.02639346f, -0.14255205f, 0.35911921f, 0.33785683f, 
    0.01976510f, 0.25484118f, -0.02477409f, -0.14402489f, 0.24008916f, -0.02591049f, -0.18748604f, 0.14454713f, 
    -0.00818618f, 0.13449134f, -0.04924208f, -0.15860774f, -0.10613625f, 0.11982678f, -0.02741248f, -0.00176949f, 
    0.22334401f, -0.25603428f, -0.15703243f, 0.29486674f, -0.26916897f, 0.02008801f, -0.08209737f, 0.05688588f, 
    0.08391518f, -0.42976716f, 0.05727627f, 0.05396702f, -0.02057688f, 0.14699309f, 0.06890246f, -0.02486115f, 
    0.62374890f, -0.02306221f, 0.13730574f, 0.09029491f, -0.06788653f, 0.91055977f, -0.17526534f, 0.00329837f, 
    0.06798486f, -0.13369559f, 0.10189600f, 0.25555003f, -0.26013887f, 0.02576694f, 0.12615980f, -0.34037223f, 
    -0.07842027f, 0.03064046f, 0.04737315f, 0.01479710f, -0.07976891f, 0.04523895f, 0.00366258f, -0.11753900f, 
    -0.06387430f, -0.05245470f, 0.03838916f, -0.06709560f, 0.02969057f, -0.04209602f, -0.11660721f, -0.09639255f, 
    0.03169033f, -0.06413308f, -0.02513631f, -0.10658418f, -0.02470359f, -0.00128882f, -0.04469120f, -0.01079559f, 
    0.08290477f, -0.03803498f, -0.04787745f, 0.02961822f, -0.01376236f, 0.02330966f, -0.11543124f, -0.11848867f, 
    -0.10841530f, 0.00890608f, -0.04279168f, 0.02427322f, -0.11794693f, -0.11229977f, -0.07004890f, -0.06788013f, 
    -0.05645138f, 0.00257907f, -0.03365977f, -0.10143644f, 0.06171859f, -0.03942917f, 0.01127745f, 0.03215022f, 
    0.05753280f, 0.01504325f, -0.01965623f, -0.06966377f, -0.10291081f, -0.04539160f, -0.07702776f, 0.01184620f, 
    0.01457304f, -0.08334716f, -0.06058482f, -0.01029585f, -0.05011063f, -0.10428028f, -0.09980211f, -0.00819227f, 
    0.01889556f, -0.02376963f, -0.01914800f, -0.04507292f, 0.02808646f, 0.02751749f, -0.06535172f, 0.04066670f, 
    0.01120191f, -0.03091378f, -0.07558641f, 0.04163509f, -0.01300940f, 0.05096243f, -0.01445839f, -0.03219382f, 
    0.03723588f, 0.03076096f, -0.05201466f, -0.04831075f, 0.07875237f, 0.02330766f, -0.08358344f, -0.08426826f, 
    -0.07358512f, -0.05949732f, -0.03600606f, 0.08751132f, 0.05527313f, 0.04896074f, 0.08022849f, -0.04499115f, 
    -0.08611214f, 0.04733155f, -0.03828011f, -0.07984015f, 0.01350573f, 0.08814155f, 0.01142255f, -0.05137332f, 
    -0.06417350f, -0.09434305f, -0.07309885f, 0.02985682f, 0.02491220f, 0.00090513f, 0.00084563f, 0.04280386f, 
    -0.05267227f, -0.08489059f, -0.02984113f, 0.01147364f, -0.04877782f, 0.05124161f, -0.06245282f, -0.02888625f, 
    -0.11446851f, -0.04362763f, -0.09987102f, 0.04887770f, 0.02408019f, -0.07895154f, -0.07870886f, 0.01484688f, 
    -0.15591620f, 0.27205679f, -0.32842326f, 0.11136866f, 0.14707233f, 0.08119465f, 0.01062946f, 0.07409117f, 
    0.29843006f, 0.09307985f, -0.07258067f, -0.17209001f, -0.03695529f, 0.05234427f, -0.15905584f, 0.02369896f, 
    0.20990816f, -0.51791936f, -0.05297963f, 0.07785302f, 0.02395898f, 0.28461814f, -0.02485312f, 0.11478288f, 
    0.01230183f, 0.06619341f, 0.17580260f, 0.36396050f, -0.15032636f, 0.17992271f, 0.10706674f, -0.28316793f, 
    0.15264384f, 0.33032063f, 0.02918123f, -0.21511507f, 0.45102462f, 0.14066957f, 0.08161350f, 0.25349003f, 
    0.07947230f, 0.17800388f, 0.20474228f, 0.51006949f, 0.07076953f, -0.02900788f, -0.00211399f, -0.05875791f, 
    0.21761827f, 0.03373355f, 0.01272098f, -0.02040818f, -0.18894823f, 0.06060671f, -0.24068348f, -0.37498757f, 
    -0.09506172f, -0.14123499f, -0.00589238f, 0.25855863f, -0.18670577f, 0.13374376f, 0.02684330f, -0.03777650f, 
    0.01572897f, -0.08777588f, 0.15285474f, 0.17045510f, -0.06626936f, -0.16519311f, -0.00734829f, -0.15546855f, 
    0.18789800f, 0.05271092f, 0.26673397f, -0.55865163f, 0.21007881f, 0.14637071f, -0.22620712f, -0.02583144f, 
    -0.21310370f, -0.01432838f, -0.16005635f, -0.12086448f, 0.09244931f, -0.12536940f, -0.01939483f, -0.01006822f, 
    -0.23960376f, -0.03618111f, -0.00877585f, -0.12825409f, 0.13526106f, -0.02050162f, -0.05976906f, -0.17447788f, 
    -0.29186895f, 0.41039243f, 0.03339388f, -0.23660885f, 0.23542683f, -0.21518631f, 0.14177988f, 0.12351415f, 
    0.09112833f, 0.43684745f, 0.07124531f, 0.01727145f, 0.08530356f, 0.11477501f, -0.09221868f, 0.04443398f, 
    -0.18223630f, -0.02256306f, -0.05951611f, -0.02004501f, -0.05008268f, -0.67497677f, -0.11265403f, 0.09717963f, 
    -0.05416008f, 0.12096846f, 0.03872924f, -0.14938949f, 0.49931639f, 0.17860235f, 0.00720472f, 0.40884188f, 
    0.05849397f, 0.05669975f, -0.05901245f, -0.08117682f, -0.12444487f, -0.03579072f, 0.01734534f, -0.04211511f, 
    -0.06790024f, -0.08252357f, -0.09348135f, 0.01715469f, -0.09373591f, 0.08688110f, -0.08555783f, 0.01545716f, 
    -0.10513221f, 0.05299361f, 0.02732496f, 0.03014014f, 0.02042684f, -0.02489495f, 0.04432888f, 0.02711154f, 
    -0.00858615f, -0.10333461f, 0.02144010f, 0.03081829f, -0.04659452f, 0.03349152f, -0.10588193f, -0.05234164f, 
    -0.06622262f, 0.02424949f, -0.04937238f, 0.07637358f, 0.02080009f, -0.06820881f, 0.00805735f, 0.03477426f, 
    0.03736380f, -0.13007557f, -0.06392987f, 0.03339829f, 0.00406578f, 0.01473233f, -0.03207423f, -0.00872727f, 
    0.00961304f, 0.08241124f, -0.00231947f, 0.02414028f, -0.07808832f, 0.05108232f, -0.09529628f, 0.06687414f, 
    -0.01185893f, -0.03323993f, -0.05754652f, 0.02492546f, -0.05129960f, 0.03981004f, -0.00993863f, -0.04695718f, 
    -0.05906700f, 0.04594796f, 0.08686668f, -0.00947912f, -0.03469814f, 0.04521005f, -0.02990828f, -0.01502333f, 
    0.05599356f, 0.08493262f, 0.05123656f, 0.02816179f, -0.09691556f, -0.06595352f, -0.04027541f, 0.00224066f, 
    0.10377514f, 0.02329267f, 0.00180175f, 0.04035048f, -0.04674410f, 0.01265684f, -0.11704581f, -0.05913007f, 
    0.02093366f, -0.07459953f, -0.13059832f, 0.02086625f, -0.01328524f, -0.05238750f, 0.07106516f, -0.10546909f, 
    -0.09174611f, -0.03745928f, 0.05520053f, -0.15041518f, 0.03265945f, -0.02380677f, -0.07207347f, -0.03472837f, 
    -0.12340122f, -0.09255000f, -0.07864699f, 0.07285722f, -0.01587080f, -0.02133694f, -0.02565588f, 0.02882257f, 
    -0.00697947f, 0.08779592f, -0.15106216f, -0.08694654f, -0.01493398f, 0.01726459f, -0.04370955f, -0.10238256f, 
    0.03029665f, 0.03875554f, -0.05344246f, -0.08549015f, -0.05911501f, -0.04273354f, -0.03041941f, -0.01698751f, 
    -0.34552088f, 0.08626450f, 0.03849356f, -0.02930253f, 0.16720980f, 0.04718023f, -0.07551929f, 0.05999513f, 
    0.03912798f, 0.15703565f, -0.05095912f, -0.10473817f, 0.15575700f, -0.00499703f, 0.03149066f, 0.10493027f, 
    -0.06718198f, -0.34709826f, -0.04205267f, -0.09120017f, 0.05745223f, -0.35327902f, -0.01607532f, -0.03075700f, 
    -0.03045524f, 0.10900766f, 0.46994960f, -0.06651286f, -0.27827385f, -0.15070194f, 0.03692955f, 0.03017479f, 
    -0.19153364f, 0.00985107f, 0.35777578f, 0.03689166f, 0.12352755f, 0.10972653f, -0.02832381f, 0.13207690f, 
    0.14269918f, 0.04517951f, -0.06741306f, 0.14279474f, -0.27420095f, 0.19545299f, 0.02401910f, -0.01966521f, 
    0.27896065f, -0.33748931f, -0.01586392f, -0.38044268f, -0.25766882f, 0.02211680f, -0.11624618f, 0.27028564f, 
    0.08442323f, -0.03646313f, 0.24812429f, 0.19014230f, 0.04864363f, -0.02812784f, -0.11703587f, -0.06289740f, 
    -0.41839090f, 0.04537525f, 0.02131448f, 0.20250690f, 0.40723491f, 0.02230187f, 0.01688264f, 0.15336585f, 
    0.01117612f, 0.25271395f, 0.15999842f, -0.15727812f, 0.16638544f, 0.09028404f, 0.00189944f, -0.53407353f, 
    0.10877601f, -0.22098038f, 0.08383375f, 0.11175079f, 0.02383072f, 0.11203985f, 0.25157651f, 0.14652520f, 
    -0.15554185f, -0.00591715f, 0.15622333f, -0.23803398f, 0.18411562f, 0.01284123f, 0.06246004f, -0.04344148f, 
    -0.24037974f, 0.41778371f, 0.26304838f, 0.07956245f, 0.27160570f, -0.18322375f, -0.37299910f, -0.05692730f, 
    -0.02912442f, 0.05130467f, -0.06771127f, -0.13705029f, 0.09082227f, 0.07348578f, 0.03966505f, 0.12371604f, 
    -0.11972259f, 0.00637268f, 0.21952425f, 0.06701732f, 0.02472529f, -0.77768087f, -0.09995152f, -0.09356871f, 
    0.07589059f, 0.08844215f, 0.05072152f, 0.12235744f, 0.14320900f, -0.18219517f, -0.10139210f, -0.01017054f, 
    0.13957164f, 0.06365211f, 0.20514995f, -0.13890016f, 0.13547190f, 0.09122929f, -0.05221897f, -0.10813595f, 
    0.15122889f, -0.09501451f, 0.07674604f, 0.16366588f, -0.29549107f, 0.02167916f, 0.04408423f, 0.07248286f, 
    -0.12090088f, 0.62304890f, 0.33327591f, 0.08731776f, 0.18452403f, 0.17236358f, 0.17815970f, 0.25154945f, 
    -0.01464275f, 0.18473406f, -0.05057117f, -0.26224089f, -0.54090506f, 0.02953354f, -0.27843919f, 0.48440647f, 
    -0.03002185f, 0.04256026f, 0.12201454f, 0.19274162f, 0.06654898f, -0.07946272f, 0.12147570f, -0.37845650f, 
    -0.00254543f, -0.27595606f, -0.14605136f, -0.26549494f, -0.13149416f, -0.04706740f, 0.00442463f, 0.30296588f, 
    -0.08311502f, -0.15380524f, -0.04802499f, -0.32721865f, 0.54391789f, 0.22478916f, 0.30144367f, -0.03741469f, 
    -0.36455292f, 0.24903296f, 0.25011098f, 0.03242472f, -0.12096510f, -0.10127866f, 0.41235197f, 0.01919725f, 
    0.11398596f, 0.11170744f, 0.03658255f, -0.02379713f, 0.52498353f, -0.01844861f, -0.02028086f, -0.11595273f, 
    0.10244896f, -0.21096565f, -0.32273898f, 0.31213519f, 0.10108684f, -0.06598622f, 0.28295159f, 0.23582640f, 
    -0.05940677f, 0.22002096f, 0.27004856f, -0.12412676f, 0.30524683f, -0.39295399f, -0.44439927f, -0.05739162f, 
    0.20772898f, -0.06309347f, -0.22625138f, -0.04456187f, -0.18204294f, -0.17094275f, -0.01319415f, 0.03986653f, 
    0.22610357f, -0.24041241f, -0.37574643f, 0.07960968f, -0.18075748f, 0.64980537f, -0.32815874f, -0.05152456f, 
    -0.07607826f, 0.12818441f, 0.01763737f, 0.11317910f, -0.22251327f, -0.15162610f, 0.01935220f, 0.14487089f, 
    0.27821398f, -0.00618311f, -0.27876779f, 0.21902703f, -0.19544813f, -0.48148301f, 0.17010087f, 0.03803497f, 
    0.38219813f, -0.02864247f, 0.07789014f, 0.17466038f, -0.08454218f, 0.13615462f, -0.18149675f, -0.44057989f, 
    0.05848939f, 0.05609144f, -0.09112998f, -0.05931428f, 0.06674711f, -0.08248195f, -0.10065825f, -0.06610053f, 
    -0.05824858f, 0.04763929f, -0.08700135f, 0.05973295f, 0.01796172f, 0.06353487f, -0.06707148f, 0.02045033f, 
    0.04929550f, -0.00578291f, -0.05601194f, -0.08974711f, 0.06583094f, -0.07375997f, -0.02062007f, -0.05580498f, 
    0.00961909f, 0.06190295f, 0.04677610f, -0.01233324f, 0.03862675f, 0.05850298f, 0.03059700f, 0.00174856f, 
    -0.02342095f, 0.07035965f, -0.08517013f, -0.04260654f, -0.04746816f, 0.00690691f, 0.00346665f, 0.01164449f, 
    -0.02240424f, -0.03987958f, -0.05735432f, 0.03050764f, -0.02711587f, -0.03002251f, -0.08338236f, -0.03126202f, 
    0.02578928f, -0.03889757f, -0.05322440f, 0.01908215f, -0.02463357f, -0.05000299f, 0.01064565f, 0.00776133f, 
    -0.02882149f, 0.00461740f, 0.05932335f, -0.06275801f, -0.08946782f, -0.00550357f, -0.08131680f, -0.08692803f, 
    0.02947267f, 0.05075824f, 0.04971020f, -0.03826465f, -0.00326606f, -0.05199810f, 0.03481274f, -0.03074266f, 
    0.01369544f, 0.05044599f, -0.06033358f, -0.06920850f, -0.03507897f, -0.09996167f, -0.05745599f, 0.00593004f, 
    -0.09235100f, -0.03240915f, 0.06058786f, -0.02624268f, -0.08644063f, 0.02258693f, -0.04958728f, -0.04817190f, 
    -0.02032170f, -0.02208443f, -0.08951686f, 0.00792868f, -0.03938315f, -0.07731274f, 0.06937934f, -0.04859426f, 
    -0.07293407f, -0.04399037f, -0.07868448f, -0.01980978f, 0.01380751f, 0.04869351f, 0.08486073f, 0.01774054f, 
    0.01046200f, -0.10075925f, -0.06836298f, 0.05377911f, -0.03921813f, -0.10318187f, 0.02535295f, 0.00237691f, 
    -0.08598710f, -0.03211512f, -0.06341003f, -0.09511943f, -0.04831310f, -0.05287419f, 0.03186486f, 0.01347311f, 
    -0.09659787f, 0.07135881f, 0.05326969f, 0.04845131f, -0.05172358f, -0.00642384f, -0.06820745f, -0.03145496f, 
    -0.00777797f, -0.39108866f, 0.17558405f, 0.08777713f, -0.04242256f, -0.07624511f, 0.31556627f, 0.14913321f, 
    0.05818811f, -0.01437922f, -0.00520771f, 0.09641162f, 0.16767493f, 0.00173225f, -0.30237374f, 0.05372402f, 
    -0.58913118f, -0.47075287f, -0.02229783f, 0.01083865f, 0.05045251f, 0.14378721f, 0.04161127f, -0.03636418f, 
    -0.07752349f, 0.28449845f, 0.28721604f, -0.13793816f, -0.19973378f, -0.10643089f, 0.04436029f, -0.11050533f, 
    -0.30368924f, -0.26529220f, 0.05399573f, 0.23787923f, -0.00367777f, 0.20874114f, 0.28649545f, -0.11880606f, 
    0.21320096f, 0.04583848f, -0.26453775f, 0.16392614f, -0.42565686f, -0.07191285f, 0.06589559f, 0.08048750f, 
    0.08789814f, -0.12402837f, 0.05813734f, 0.27457443f, 0.05339660f, -0.02544157f, -0.02654635f, -0.32986173f, 
    0.00184712f, -0.11337369f, -0.24882528f, 0.02119194f, 0.06628948f, 0.08023721f, 0.04120071f, -0.20937534f, 
    0.10382163f, -0.30000815f, -0.07179759f, 0.04411459f, -0.82117069f, 0.19052303f, 0.03971969f, 0.28865185f, 
    0.11134224f, -0.09055708f, 0.15612648f, 0.00890876f, 0.27745011f, 0.02671275f, -0.08477387f, -0.45099294f, 
    -0.04251453f, -0.10354369f, -0.27398935f, -0.06591958f, 0.10238931f, -0.04602348f, 0.25308484f, 0.19782358f, 
    0.23140129f, 0.24366297f, 0.02834889f, 0.44773075f, 0.01153769f, 0.09213878f, 0.02500325f, -0.09783336f, 
    -0.18059640f, -0.62775862f, 0.14157018f, -0.01793337f, 0.03992729f, 0.05759807f, -0.00665808f, 0.15588707f, 
    0.27382049f, -0.20129916f, 0.00737690f, -0.13806126f, 0.06798124f, -0.12277653f, -0.51453024f, -0.24931799f, 
    -0.85998094f, 0.04661734f, -0.09278341f, -0.48235396f, 0.15490730f, -0.06629896f, 0.27773416f, 0.15130699f, 
    -0.00096994f, 0.05978399f, -0.08890491f, -0.21246561f, -0.00355198f, -0.07773793f, 0.25137901f, 0.11496821f, 
    0.41335011f, 0.29290044f, 0.20301135f, 0.06687457f, -0.14891057f, -0.13236661f, -0.24287331f, 0.03306058f, 
    -0.29313225f, 0.11530624f, -0.03521637f, 0.06580212f, -0.17411615f, 0.07144997f, 0.11113284f, 0.11441999f, 
    -0.01701618f, -0.31736684f, 0.01790527f, -0.01015252f, 0.18957722f, -0.17916985f, 0.14850031f, -0.03330577f, 
    0.02016739f, -0.35195568f, -0.25211695f, -0.07686729f, 0.51513708f, 0.02559725f, 0.12426551f, 0.26419473f, 
    0.37237969f, 0.27471918f, 0.02444670f, 0.07528658f, -0.15743855f, -0.00924477f, -0.14257549f, 0.32210967f, 
    -0.58857667f, -0.30711383f, -0.03066299f, -0.12536153f, -0.25465876f, 0.05024158f, -0.03244300f, 0.06177169f, 
    -0.01624333f, 0.05910665f, -0.00725661f, -0.06840464f, 0.38014889f, -0.02742377f, -0.04925145f, 0.41615334f, 
    0.15086021f, -0.26984930f, -0.10942633f, 0.06855728f, 0.01587367f, -0.03517258f, -0.06458022f, -0.06059328f, 
    -0.26547277f, 0.34096354f, 0.25811514f, -0.00588955f, 0.13439108f, -0.08031160f, -0.06554710f, 0.07166982f, 
    -0.33571529f, 0.21859103f, 0.05496439f, 0.13221687f, -0.43042693f, 0.04950154f, 0.25420445f, 0.94437689f, 
    -0.03079128f, -0.22242203f, 0.21179059f, 0.20207377f, -0.13814592f, 0.20774592f, 0.04904136f, 0.13618334f, 
    0.13931926f, 0.08858676f, -0.05373435f, -0.23868534f, 0.36558536f, 0.07051750f, 0.00146127f, 0.09121331f, 
    0.22438386f, -0.00480045f, 0.02634254f, 0.16526081f, -0.00452858f, -0.55799806f, 0.17153534f, -0.14740421f, 
    -0.13388364f, -0.11160814f, -0.02191246f, 0.15372950f, 0.08402704f, 0.06271490f, 0.20847721f, 0.05345129f, 
    -0.30237606f, -0.08997384f, -0.01465516f, -0.06460322f, -0.03091319f, 0.52006721f, -0.31892011f, -0.09117617f, 
    -0.12846301f, 0.05373086f, 0.04686093f, 0.42518947f, -0.08929318f, -0.08717396f, -0.08410560f, -0.26990205f, 
    -0.40652123f, 0.01555134f, -0.24359460f, 0.03238005f, 0.17711923f, 0.22208676f, -0.01756844f, 0.01996680f, 
    0.18840706f, 0.10852806f, -0.01118908f, -0.21003520f, 0.29036352f, 0.11702736f, -0.10091399f, 0.01560942f, 
    0.16898413f, -0.39626956f, 0.12818387f, 0.12343168f, -0.37430897f, 0.32988739f, -0.17373092f, 0.12270025f, 
    0.07098833f, 0.29253346f, -0.10447512f, 0.15113418f, -0.20988314f, -0.00121733f, 0.35569686f, -0.12339367f, 
    -0.14303669f, 0.10532299f, -0.08588039f, -0.37322691f, 0.27835914f, 0.12096614f, 0.12372146f, -0.01579213f, 
    0.23861884f, 0.20920867f, 0.17221847f, 0.49082527f, 0.14834791f, 0.00662315f, 0.13388197f, -0.16976173f, 
    0.24082440f, -0.01303463f, -0.02891661f, -0.06645678f, -0.09614942f, 0.20939671f, -0.05617930f, -0.40710217f, 
    -0.04421436f, -0.03567171f, -0.09274209f, 0.10073020f, -0.23142697f, 0.14257705f, 0.12415391f, 0.08834362f, 
    -0.08233047f, -0.08022969f, 0.06483816f, 0.15128054f, -0.03834768f, -0.01967558f, -0.05129677f, -0.08235028f, 
    0.32612717f, -0.03635804f, 0.01160868f, -0.06211018f, 0.41109440f, 0.15626428f, -0.12392886f, -0.37050310f, 
    -0.09841068f, 0.51214790f, -0.06564892f, -0.15378940f, 0.18816534f, 0.13555773f, -0.00338501f, 0.10558357f, 
    -0.13343456f, 0.00229094f, -0.04096686f, -0.13769388f, -0.27934241f, 0.02440513f, 0.07481931f, -0.11201392f, 
    -0.01091324f, 0.16266187f, 0.10768631f, 0.05675231f, 0.23640572f, 0.14524586f, -0.07413889f, 0.14524700f, 
    0.02806231f, 0.15256637f, -0.02564235f, -0.07798781f, 0.04195920f, 0.25399444f, -0.26491678f, 0.01803771f, 
    0.22209814f, 0.10125332f, 0.26312768f, 0.03813650f, 0.13042635f, -0.62105364f, -0.10626680f, 0.22087657f, 
    -0.01164332f, 0.19507448f, -0.18252647f, -0.09045275f, 0.26283714f, 0.22985815f, -0.02147436f, 0.20629351f, 
    -0.00380028f, -0.05449933f, -0.11545316f, -0.03455419f, -0.04763369f, -0.06586677f, -0.02886883f, 0.04025890f, 
    -0.04973052f, 0.05477295f, -0.00057862f, 0.03450735f, -0.14345838f, -0.04717205f, 0.00535479f, -0.12413218f, 
    0.02643557f, 0.02502083f, 0.06224611f, -0.01100859f, 0.02714675f, 0.03508276f, -0.03396121f, -0.07092728f, 
    -0.02982012f, -0.03393774f, -0.00255512f, -0.03675091f, -0.13650317f, -0.00166276f, 0.05763051f, -0.08392208f, 
    -0.11771043f, -0.05179510f, 0.01416709f, -0.06587765f, 0.04307311f, 0.04794837f, 0.03824719f, -0.06340446f, 
    -0.03424375f, -0.09987218f, 0.04121291f, 0.06756496f, -0.07015718f, -0.03752412f, 0.01398126f, 0.02330340f, 
    -0.05443494f, -0.09358298f, 0.08400578f, 0.00809369f, -0.04305923f, -0.09257915f, -0.06880207f, 0.02885249f, 
    -0.10361826f, 0.00392384f, 0.04466178f, 0.04589037f, 0.01176834f, -0.04072996f, -0.07273027f, -0.01392226f, 
    -0.09259424f, -0.06693016f, 0.01725447f, -0.10999317f, 0.06936260f, -0.02454134f, 0.05628994f, 0.05076555f, 
    -0.09132589f, -0.04892684f, -0.04839069f, -0.01371404f, -0.07201093f, 0.01457142f, -0.04291896f, 0.06462890f, 
    0.04369411f, -0.02055189f, -0.07437471f, 0.00172360f, -0.00482159f, -0.01965553f, 0.01176291f, -0.03080311f, 
    0.05720208f, -0.07966482f, -0.02152805f, 0.04658500f, -0.08078957f, -0.11333206f, 0.05142502f, -0.03312559f, 
    -0.11107410f, 0.04126102f, -0.07338549f, 0.02072469f, -0.07009258f, 0.05561258f, -0.10541236f, 0.05807645f, 
    -0.10023104f, -0.00421639f, 0.01410691f, 0.05658615f, -0.07441188f, 0.04147745f, 0.04132313f, 0.07580096f, 
    -0.03015470f, -0.07235050f, 0.07663941f, 0.00573288f, -0.08794567f, -0.10990661f, 0.04455660f, -0.01924800f, 
    -0.05129063f, 0.01123788f, 0.05317926f, -0.12078451f, -0.07417259f, -0.06567406f, -0.00429368f, 0.04865719f, 
    0.65443063f, 0.14272414f, 0.07414388f, 0.04182878f, 0.02403321f, -0.07990608f, 0.29905847f, 0.01584959f, 
    -0.08066525f, 0.00205011f, -0.02056661f, 0.03509211f, 0.01720850f, -0.02918074f, 0.11915066f, 0.03297956f, 
    0.10362530f, -0.25404862f, -0.10155430f, 0.14406568f, 0.27367494f, 0.02552266f, 0.20091549f, 0.00972153f, 
    -0.05865891f, -0.06249676f, 0.01277545f, -0.04569471f, 0.16686387f, -0.32036602f, -0.05564900f, -0.16188636f, 
    0.14069776f, 0.11265845f, 0.15420783f, 0.25861564f, -0.07135757f, 0.13307540f, 0.10056781f, 0.23163700f, 
    -0.08200572f, -0.57365614f, -0.23185726f, -0.15398017f, -0.27232289f, 0.39380163f, -0.06139956f, 0.12184978f, 
    -0.25266707f, 0.20670955f, -0.00574639f, 0.24888687f, -0.27069074f, 0.04143048f, 0.16685215f, 0.34885466f, 
    0.11867478f, -0.15922943f, -0.01756584f, 0.01824701f, 0.07728143f, 0.03719710f, -0.09441311f, 0.20451528f, 
    0.23649043f, -0.04692129f, 0.05599476f, 0.04857348f, -0.30566266f, -0.17886825f, 0.02517346f, 0.07232309f, 
    -0.07343365f, -0.02797842f, -0.10695477f, -0.06588455f, -0.13976617f, -0.15681891f, 0.09498861f, 0.31721199f, 
    -0.22816271f, -0.02080450f, -0.00821412f, -0.11946107f, 0.21228980f, 0.17984247f, -0.13307841f, 0.01321015f, 
    0.04415774f, 0.15160096f, 0.17842144f, -0.03370387f, -0.06056528f, 0.15659466f, -0.06216319f, -0.08110942f, 
    0.00499806f, -0.28116348f, 0.06803112f, 0.19970846f, -0.17006408f, -0.08365352f, 0.27538529f, 0.20319058f, 
    0.10448401f, -0.02021429f, 0.06786153f, 0.22459999f, 0.21209180f, 0.03343859f, 0.43107310f, -0.17349057f, 
    0.03974603f, 0.02765544f, 0.09473310f, -0.15858772f, -0.05279301f, 0.74715549f, -0.11753752f, 0.11584134f, 
    -0.24764255f, 0.11905838f, 0.35941628f, 0.09757636f, -0.25829053f, -0.09304536f, 0.17031518f, -0.00399190f, 
    0.13156578f, 0.12202652f, -0.02891486f, 0.19943547f, 0.02799751f, -0.01641846f, -0.07480687f, 0.01961049f, 
    0.26744023f, 0.11358083f, -0.04221940f, 0.25085720f, -0.19779512f, -0.27718717f, -0.31486389f, 0.24776329f, 
    -0.01919695f, 0.48028788f, 0.25760657f, 0.00553779f, 0.01646120f, 0.18649061f, 0.25210306f, 0.32884249f, 
    0.02671747f, 0.08270776f, -0.27852863f, -0.00203724f, 0.28312749f, 0.02709624f, -0.10895061f, 0.14420374f, 
    0.24565890f, -0.20518307f, -0.14412270f, 0.02828489f, 0.28401810f, -0.14624006f, 0.01077110f, -0.07902128f, 
    -0.11910898f, 0.02070598f, 0.10720831f, 0.05563344f, 0.18139544f, -0.31091627f, -0.05030678f, -0.05167491f, 
    -0.36043936f, -0.19741112f, -0.07552517f, -0.28186864f, 0.26999161f, 0.07236084f, -0.04250591f, -0.14509900f, 
    -0.11875069f, -0.10755882f, -0.05360097f, -0.05086286f, 0.06882835f, -0.12437934f, 0.02184215f, 0.14596838f, 
    0.12030289f, 0.22097254f, 0.04046360f, -0.23422323f, 0.36984900f, 0.12074538f, 0.04198242f, -0.55465829f, 
    0.13394845f, -0.07763284f, -0.01372607f, -0.27574977f, -0.09131879f, 0.09467385f, 0.17674074f, -0.18384157f, 
    -0.33965248f, -0.11334795f, -0.29552680f, 0.01600092f, -0.00090743f, -0.10427716f, -0.29217508f, -0.77359337f, 
    0.29838452f, -0.24413611f, -0.36247617f, 0.44692394f, -0.02346721f, -0.02018566f, 0.11828595f, 0.08312213f, 
    0.08904699f, -0.19448721f, -0.57788688f, -0.09912759f, -0.08135150f, 0.32273069f, -0.11247350f, -0.01928385f, 
    0.01027775f, -0.00938608f, -0.07188077f, -0.00077563f, -0.09346518f, -0.06491975f, -0.00963069f, 0.10130079f, 
    0.59082681f, 0.07398464f, -0.10694315f, 0.09771549f, -0.19262317f, -0.34792736f, 0.27983895f, 0.20883615f, 
    0.26784694f, -0.01401699f, 0.12172507f, -0.20036994f, 0.08710323f, -0.00182431f, -0.21106265f, -0.32465300f, 
    0.00503312f, 0.01141683f, -0.02388468f, 0.22282979f, -0.07874908f, 0.07015113f, 0.26661798f, 0.10109150f, 
    0.16996188f, 0.09114446f, 0.04703897f, 0.07036691f, 0.02362840f, 0.00567234f, 0.13603166f, -0.13626367f, 
    0.02570361f, -0.09822118f, 0.14521803f, 0.09862313f, 0.17853063f, -0.05494145f, 0.14478029f, 0.23843201f, 
    0.00114936f, -0.14201289f, -0.01607184f, 0.12930760f, 0.03114175f, 0.27245313f, 0.16047214f, -0.08549369f, 
    0.13372856f, 0.21030790f, -0.13572386f, -0.11915661f, 0.10641414f, 0.19659328f, 0.22517347f, 0.11708811f, 
    -0.01224701f, -0.01678826f, 0.07025085f, 0.07501873f, 0.23292728f, -0.27749640f, 0.01789386f, 0.07822379f, 
    -0.17032228f, -0.06540634f, -0.01926438f, 0.20889163f, -0.05850857f, 0.14528720f, -0.08576693f, -0.10116363f, 
    0.35493296f, -0.10207596f, -0.15286434f, 0.07653239f, 0.04692370f, 0.10834143f, -0.07081134f, 0.19933742f, 
    0.30994397f, 0.00708604f, 0.00174880f, 0.02939052f, -0.25992283f, -0.15089616f, 0.00731795f, -0.12978879f, 
    0.19772331f, -0.04645121f, -0.00152035f, -0.26170442f, 0.00388923f, 0.20428394f, -0.24234965f, 0.11167066f, 
    -0.38132349f, -0.02917353f, -0.07973758f, 0.00885526f, 0.19484998f, -0.22855416f, -0.25024527f, -0.17517811f, 
    -0.04530875f, 0.10407480f, -0.19771524f, 0.21356219f, -0.01986765f, 0.11400645f, 0.00918035f, -0.11336937f, 
    0.03898677f, -0.42911169f, -0.07319617f, -0.07615818f, 0.06600975f, 0.08856591f, 0.13082021f, 0.21476531f, 
    0.18069530f, 0.12436323f, -0.03328367f, 0.18206048f, 0.10600433f, 0.05092112f, -0.05356255f, -0.02745003f, 
    -0.10750603f, 0.04579264f, -0.08552419f, 0.02577547f, 0.07917342f, -0.23243791f, -0.02437701f, 0.33194971f, 
    -0.12170159f, 0.09787618f, -0.00214683f, -0.12159950f, 0.03303291f, 0.15956248f, 0.18491399f, 0.28483859f, 
    -0.09949408f, -0.08031446f, -0.06215563f, 0.01872287f, 0.00772674f, -0.04881198f, 0.01020992f, -0.04379738f, 
    0.01663879f, 0.02688715f, -0.02638228f, -0.07427211f, -0.06252927f, -0.04740720f, -0.08459374f, -0.11995451f, 
    -0.06166003f, -0.07043358f, -0.02153519f, -0.00009177f, 0.03831978f, -0.02164378f, -0.02587751f, -0.03472540f, 
    -0.05688100f, 0.05289489f, 0.01936907f, -0.00821736f, -0.07932040f, -0.03783790f, 0.03163315f, 0.00970083f, 
    -0.07761908f, 0.02197335f, -0.05574251f, 0.06418727f, 0.00681930f, -0.12434148f, -0.09019828f, 0.05398611f, 
    -0.08019362f, 0.03829899f, -0.01425259f, -0.06149634f, -0.03525686f, 0.03897510f, -0.09564652f, -0.09108061f, 
    -0.07249235f, -0.04680878f, -0.01930081f, 0.01840701f, -0.14557977f, -0.12090453f, 0.03019130f, 0.03952235f, 
    0.04441489f, -0.01145205f, -0.04183038f, -0.02980403f, -0.04011554f, -0.05477679f, -0.01318788f, -0.10641864f, 
    -0.07429019f, -0.07594971f, 0.01115244f, -0.02051949f, 0.03249528f, -0.03869171f, -0.01297633f, 0.05311310f, 
    0.00155773f, -0.01028114f, -0.07789113f, -0.07222362f, -0.04844440f, -0.03955239f, -0.01670129f, 0.01246692f, 
    -0.10094122f, 0.00815082f, 0.02868196f, -0.06591755f, -0.08658139f, -0.03636759f, -0.00570086f, 0.01545999f, 
    0.00416221f, -0.05051265f, -0.12063274f, -0.08440613f, -0.09301222f, -0.08274808f, 0.07243768f, 0.04110558f, 
    0.00577091f, 0.04699200f, -0.11116426f, -0.07515590f, 0.02790078f, -0.00797986f, -0.10366800f, 0.05430568f, 
    -0.06076429f, 0.00596595f, 0.02890905f, -0.08653141f, -0.06304333f, -0.02772055f, -0.04506262f, -0.00285367f, 
    -0.04695890f, 0.03921979f, -0.12077253f, -0.10334522f, -0.08339424f, 0.04853458f, -0.06771490f, -0.10826267f, 
    -0.09247141f, 0.04837939f, -0.04860430f, -0.05025944f, -0.05596939f, -0.08853229f, -0.05659881f, -0.08575874f, 
    0.10424290f, 0.08752777f, 0.18899755f, -0.15124778f, 0.17198533f, 0.00220015f, 0.01315837f, -0.03545400f, 
    -0.20410013f, 0.12396538f, 0.01005441f, -0.01235101f, -0.02877798f, -0.06725003f, -0.01434349f, -0.00786387f, 
    -0.11398468f, -0.06755364f, 0.13769732f, -0.00375982f, 0.15427652f, 0.17054804f, 0.01600221f, 0.12721075f, 
    -0.01495015f, 0.15485492f, -0.08686373f, 0.03492890f, -0.07198410f, 0.66001445f, 0.18837859f, 0.31451946f, 
    -0.05414123f, 0.08154286f, -0.20512128f, -0.04846779f, -0.02319497f, -0.05732456f, 0.02926751f, 0.06624092f, 
    -0.06445595f, -0.47002327f, 0.15474595f, -0.11326066f, 0.24053405f, 0.03556989f, -0.05222939f, 0.17195906f, 
    -0.25620708f, 0.42393801f, -0.01866353f, 0.26298985f, 0.33304006f, -0.15595672f, 0.29089284f, 0.02449569f, 
    -0.05770971f, 0.05157892f, 0.03668351f, -0.15926975f, 0.08099578f, -0.10698891f, 0.10528676f, 0.16576289f, 
    0.07860772f, 0.06170417f, 0.15036497f, -0.07314529f, -0.11174320f, -0.02575854f, -0.00976855f, 0.06730708f, 
    0.08364671f, 0.06143448f, -0.12406521f, 0.38515115f, -0.00468171f, -0.18712205f, 0.42857707f, 0.47674018f, 
    -0.40101227f, 0.26720798f, 0.00679276f, -0.24056289f, 0.18899751f, -0.01159940f, -0.18920450f, 0.02150324f, 
    0.12497059f, 0.02908975f, -0.10072752f, 0.14960279f, -0.01722050f, -0.06366522f, 0.00575145f, 0.31627280f, 
    0.29833037f, -0.39089727f, -0.10970126f, 0.18218809f, -0.23718095f, 0.08108539f, -0.05135517f, 0.09282181f, 
    -0.03732923f, -0.08550325f, 0.07291571f, 0.10552613f, 0.02821855f, 0.03978216f, 0.20499951f, 0.17862235f, 
    0.31717142f, 0.09796645f, -0.02817179f, 0.11303082f, 0.01553778f, 0.83717549f, -0.13738836f, 0.00833908f, 
    0.22829854f, -0.01031748f, -0.02316676f, -0.12818879f, -0.12508020f, -0.00678887f, -0.00437118f, 0.04032414f, 
    -0.11867552f, -0.06249061f, 0.07242078f, 0.03751129f, 0.03516722f, -0.08684704f, 0.08450942f, 0.02012881f, 
    -0.20007728f, -0.09085830f, -0.04090821f, -0.16461466f, 0.01393365f, -0.06039095f, 0.04090557f, -0.04444382f, 
    0.10948963f, -0.02111153f, -0.02450963f, -0.12376028f, -0.02810695f, 0.04244288f, -0.05269742f, -0.09869310f, 
    -0.08449889f, -0.08226398f, -0.05940283f, 0.10060064f, -0.04173165f, 0.08328261f, 0.03543306f, 0.09212808f, 
    0.02519823f, -0.04457838f, -0.13350646f, -0.00277420f, 0.09296288f, -0.00459104f, 0.00156702f, 0.04397869f, 
    -0.05137657f, 0.05212468f, -0.06517661f, 0.13647416f, -0.01171335f, 0.01589184f, -0.12391397f, -0.01488794f, 
    -0.09253009f, 0.12568644f, -0.05212244f, 0.06909655f, 0.07142435f, -0.02591377f, 0.01587468f, -0.04199257f, 
    0.12580979f, -0.10437240f, -0.10485072f, -0.04441921f, 0.00376943f, 0.02738445f, -0.04046035f, 0.02377200f, 
    0.08595407f, -0.02409702f, -0.09834917f, 0.04124830f, 0.04085560f, -0.08274785f, -0.06869534f, 0.03220040f, 
    0.05691183f, -0.10412175f, 0.07410845f, -0.03272995f, 0.04228368f, 0.05836743f, 0.12242958f, 0.00287116f, 
    -0.00629310f, 0.10136590f, 0.01525909f, -0.09092835f, -0.05931260f, 0.05771966f, 0.03739900f, -0.01911987f, 
    -0.00096354f, 0.05853026f, -0.04844909f, -0.10981927f, -0.02801846f, -0.11725187f, 0.06938340f, 0.05326187f, 
    0.05958666f, -0.08656198f, 0.06326067f, -0.01965082f, -0.08940746f, -0.01801232f, 0.12392296f, 0.09024694f, 
    -0.06817088f, 0.02953154f, -0.00215518f, -0.07553971f, 0.06046495f, 0.08695358f, 0.11056271f, -0.11756372f, 
    -0.01174095f, 0.00481516f, 0.00619843f, -0.12425717f, 0.00547832f, 0.05248183f, -0.15962012f, -0.02764006f, 
    -0.04730524f, -0.03873790f, 0.00761507f, -0.18825229f, -0.05684827f, 0.05167215f, 0.01376949f, 0.05492720f, 
    -0.01774999f, 0.06907697f, 0.06291730f, -0.00450317f, -0.00614575f, -0.07034723f, -0.02474170f, -0.08069496f, 
    -0.04558898f, -0.04137006f, -0.07483218f, 0.03168792f, -0.01348429f, 0.00025770f, -0.06052227f, -0.08664941f, 
    0.01225691f, -0.04872766f, -0.09268180f, 0.00639247f, -0.04384645f, 0.04498459f, -0.07573092f, -0.07177649f, 
    -0.06152178f, -0.03012959f, 0.06302386f, -0.04970542f, -0.08288870f, 0.07922770f, 0.01127283f, -0.07157073f, 
    -0.03796797f, -0.03289650f, -0.00044002f, -0.08997519f, 0.00268747f, -0.09256593f, 0.03335501f, 0.01980393f, 
    -0.00419299f, -0.05292675f, -0.06579044f, -0.03701396f, -0.06996723f, -0.08856653f, 0.03748721f, -0.09007956f, 
    0.04524353f, -0.08560180f, 0.07049163f, 0.05451867f, -0.07878974f, -0.00627820f, 0.03299906f, -0.01609531f, 
    0.07543539f, 0.00221914f, 0.05340060f, -0.01436404f, -0.07606224f, -0.05919592f, 0.06326737f, 0.04349345f, 
    0.07012328f, 0.02114006f, 0.04562240f, -0.04361685f, 0.04106713f, 0.00423592f, 0.05451581f, -0.03328829f, 
    0.03102324f, 0.00343376f, -0.06059594f, -0.01797008f, -0.07370456f, 0.07038718f, 0.02430138f, -0.03308160f, 
    -0.07317219f, 0.00792081f, 0.07023358f, 0.03451950f, -0.03036289f, 0.02614567f, 0.05879540f, 0.06382087f, 
    0.04728021f, 0.01687026f, 0.03122291f, -0.03043844f, -0.01709329f, 0.07613803f, 0.07214125f, 0.01826329f, 
    -0.05098612f, 0.05828113f, 0.05434142f, 0.02488007f, -0.03183066f, -0.06981776f, -0.05388707f, 0.00727745f, 
    -0.06679004f, -0.07457394f, -0.08043326f, 0.04195634f, -0.06989625f, 0.03889196f, -0.05953961f, 0.04317376f, 
    -0.02858192f, -0.00403516f, -0.00039455f, 0.00553165f, 0.05859615f, 0.01379477f, -0.01621104f, 0.01263033f, 
    -0.09135587f, -0.07201805f, 0.03368007f, -0.04875943f, 0.02819286f, -0.00293174f, 0.04535329f, -0.03765822f, 
    0.14597200f, -0.03979658f, 0.01681045f, 0.13638155f, 0.05338586f, 0.01888496f, 0.31080225f, -0.01439030f, 
    0.22868475f, 0.08690739f, 0.03812101f, 0.08010279f, 0.12226135f, -0.21181186f, -0.04374622f, 0.19324608f, 
    -0.29240429f, 0.48358098f, 0.16996124f, -0.00390547f, -0.01237003f, -0.21208313f, 0.15720204f, 0.20783265f, 
    -0.07979394f, 0.10536377f, 0.51857507f, -0.00264264f, -0.26974139f, -0.02022550f, 0.02865867f, -0.00715160f, 
    -0.11956950f, -0.17140378f, -0.03045508f, -0.12479682f, -0.04417971f, -0.00540649f, 0.16435064f, -0.17260288f, 
    0.02273022f, 0.10616320f, -0.22403368f, -0.09061266f, 0.41349107f, -0.02099609f, 0.09005302f, 0.16906384f, 
    -0.18847875f, -0.29402480f, -0.08733242f, 0.00698027f, -0.05321816f, 0.00875068f, -0.06279143f, -0.08943319f, 
    0.49469841f, 0.01973937f, 0.11500884f, -0.00148050f, -0.03353813f, 0.10162138f, 0.07400854f, 0.11180825f, 
    0.10390287f, 0.01605284f, 0.05146310f, 0.11407595f, 0.19717604f, 0.26656213f, 0.06377886f, 0.12563822f, 
    0.16490437f, -0.06318922f, 0.03032480f, -0.02995467f, 0.09514476f, -0.05190801f, -0.20142087f, -0.52908796f, 
    -0.13992694f, -0.02439514f, -0.20714602f, 0.20436384f, 0.13888763f, -0.18251483f, 0.07934523f, -0.13005698f, 
    0.07217910f, 0.03382535f, -0.02015851f, 0.44522089f, -0.01047516f, -0.01141430f, -0.04466901f, -0.06006765f, 
    -0.15112747f, -0.32845291f, 0.03425091f, 0.00687067f, 0.06025531f, 0.11764966f, -0.14764751f, 0.25683856f, 
    0.28588375f, 0.06197006f, -0.01603027f, 0.07483824f, 0.05859300f, -0.23415859f, -0.10661498f, 0.14144452f, 
    -0.00614843f, 0.03238941f, 0.28868920f, 0.11104129f, 0.13692324f, -0.37868086f, 0.46109810f, 0.24270949f, 
    0.04358459f, 0.02266602f, -0.13557923f, -0.07773145f, -0.10821083f, -0.25053000f, 0.02501260f, 0.16431166f, 
    -0.00300303f, 0.00294667f, 0.01605639f, -0.06688251f, -0.08218668f, -0.10073049f, -0.09188472f, -0.00124208f, 
    -0.05612825f, -0.09346585f, 0.05960404f, -0.06072721f, -0.04454834f, -0.05125202f, 0.02623573f, -0.06529372f, 
    -0.03452102f, 0.01261706f, -0.02065383f, 0.02720321f, -0.03607682f, -0.03716694f, 0.06354224f, 0.01814964f, 
    0.06547435f, -0.09419450f, -0.04343476f, 0.05936303f, 0.08702923f, -0.08766810f, -0.02314699f, -0.07411537f, 
    0.07472788f, 0.04627449f, -0.00971364f, -0.08884832f, -0.04015118f, -0.05862368f, -0.01344603f, 0.01237746f, 
    -0.07126985f, -0.06983646f, 0.02796510f, 0.01185858f, -0.03007730f, 0.04653553f, -0.02039892f, -0.05466904f, 
    -0.06829679f, -0.03050479f, -0.04294311f, -0.00176621f, 0.00957673f, 0.03504040f, 0.06705364f, -0.08878678f, 
    -0.02520083f, -0.00087326f, 0.02852181f, -0.05405767f, 0.06398510f, -0.00103179f, 0.04334824f, -0.03651694f, 
    0.01355058f, -0.06080539f, -0.10490298f, -0.00552460f, -0.02515563f, 0.06504528f, -0.02240607f, 0.05073265f, 
    0.07206083f, 0.07347900f, -0.05125974f, 0.05905573f, -0.08584642f, 0.07886261f, -0.01179677f, 0.02765361f, 
    0.06539805f, -0.05634056f, 0.02299404f, -0.03656377f, 0.04549751f, 0.00405711f, -0.05678814f, 0.04922968f, 
    -0.03183233f, -0.07035925f, -0.00114077f, 0.05575233f, -0.03159487f, -0.05294256f, -0.01233274f, 0.04943648f, 
    0.00373358f, -0.04167928f, -0.02550959f, -0.03400765f, 0.00720193f, -0.10182133f, -0.07555214f, -0.04902149f, 
    0.03839640f, -0.03651569f, 0.06411186f, -0.00742032f, -0.02163151f, -0.05327367f, 0.02041238f, 0.06327799f, 
    0.05153510f, -0.00852887f, 0.02620086f, 0.03892868f, -0.06752793f, -0.01962527f, -0.05298850f, -0.08251733f, 
    0.03376855f, 0.00382501f, 0.07574580f, 0.04801478f, 0.01532728f, 0.04442266f, 0.03602896f, -0.09744881f, 
    0.69792587f, 0.16747302f, 0.16950244f, 0.06440082f, 0.11521095f, -0.04995852f, -0.01706253f, 0.01878261f, 
    0.18836384f, -0.00535724f, -0.08286801f, -0.01189326f, 0.09628455f, 0.05604037f, 0.30475235f, 0.10812435f, 
    0.33403519f, 0.54546529f, -0.13887985f, 0.11634006f, -0.03028758f, -0.12136087f, 0.03309381f, -0.18820153f, 
    0.07871971f, 0.19554588f, 0.52994663f, 0.02770722f, -0.31654122f, -0.45865878f, -0.19287789f, -0.19316983f, 
    -0.07105612f, 0.08961912f, 0.24692452f, 0.29967263f, -0.00288387f, 0.00788659f, 0.11661165f, -0.07894199f, 
    0.27724966f, 0.11438912f, -0.27823231f, 0.01942596f, -0.51604688f, 0.60392654f, 0.24966644f, 0.04351378f, 
    0.23595460f, 0.11951131f, 0.09766351f, -0.11298726f, -0.51164615f, 0.17208061f, 0.14560531f, -0.04138003f, 
    0.35669461f, 0.18923761f, 0.59326285f, 0.00594264f, 0.18364188f, -0.07202556f, 0.04725979f, 0.20253024f, 
    -0.11570393f, 0.07539119f, 0.03032484f, -0.01967314f, 0.41866264f, 0.28701127f, 0.10042836f, 0.30272987f, 
    -0.11306345f, -0.08776116f, -0.07951606f, 0.07705034f, 0.10557171f, -0.03311491f, -0.22138338f, -0.49572402f, 
    0.19035168f, -0.22938919f, 0.15693118f, 0.16216345f, 0.04175997f, 0.17607184f, 0.41909823f, 0.18548101f, 
    -0.10615795f, -0.07106802f, 0.31914616f, -0.02773163f, -0.19333223f, 0.07402737f, 0.03093729f, -0.19253257f, 
    -0.41167074f, 0.15279691f, 0.33610937f, 0.02428855f, 0.21667190f, 0.56290203f, -0.17348108f, 0.03606525f, 
    0.00032760f, 0.13802947f, -0.01588282f, -0.14098001f, 0.08211740f, -0.10043892f, 0.34540695f, -0.08687766f, 
    -0.14472367f, -0.01078928f, 0.44896156f, 0.19010244f, 0.04021150f, 0.29973516f, 0.21317263f, -0.08243043f, 
    0.15995288f, 0.02158854f, 0.17957151f, 0.12759820f, 0.03022058f, 0.00420294f, -0.01297692f, -0.18386054f, 
    0.29007664f, -0.05704948f, 0.07449481f, -0.10109655f, 0.08272197f, -0.02978425f, 0.13319325f, -0.03478463f, 
    -0.02883014f, -0.07508025f, -0.07980094f, 0.12122310f, 0.05175194f, -0.13302219f, 0.10408460f, 0.23659182f, 
    0.00971367f, 0.03036675f, -0.04977944f, 0.01335796f, 0.33147517f, -0.11110237f, 0.14952134f, 0.08486203f, 
    0.02441528f, 0.04342476f, 0.23545237f, 0.03391679f, -0.45747733f, -0.07959477f, -0.11037192f, -0.02380185f, 
    -0.27426365f, -0.03679200f, 0.22897731f, 0.19117069f, -0.04837418f, 0.08750670f, -0.12396534f, -0.04092164f, 
    0.19395356f, -0.30425817f, -0.29532906f, -0.13742594f, -0.25387931f, 0.34782657f, -0.08824772f, 0.21682987f, 
    -0.20510761f, 0.28536853f, -0.07163416f, 0.11694279f, -0.35873517f, -0.17497192f, 0.26029730f, 0.15366328f, 
    0.11409339f, 0.08325541f, 0.30805174f, -0.00815524f, 0.14979334f, 0.01729372f, -0.03157244f, -0.09057611f, 
    -0.05832945f, -0.02556893f, -0.03836477f, 0.14304674f, -0.28664008f, 0.02201998f, 0.05486006f, 0.22447118f, 
    0.16882436f, 0.11170797f, -0.06454459f, 0.04448053f, -0.04733286f, -0.15790883f, 0.06373565f, -0.36711574f, 
    0.24621077f, 0.06442375f, -0.30890250f, 0.00054953f, 0.33757484f, 0.06941639f, -0.04137024f, 0.00903759f, 
    -0.05490409f, 0.06639890f, 0.21436657f, 0.14521568f, -0.04270507f, 0.02947490f, 0.04243164f, -0.05882608f, 
    -0.17399560f, 0.04683917f, 0.04538823f, 0.11000351f, -0.05839549f, 0.24818672f, -0.16665383f, 0.12633444f, 
    -0.03850145f, -0.02800288f, -0.01598726f, 0.05495002f, 0.17646466f, -0.04250306f, 0.23931520f, -0.09367190f, 
    0.01572866f, -0.03291016f, 0.30370301f, 0.09169486f, 0.09125751f, -0.17600243f, 0.39296404f, -0.01802817f, 
    -0.02462626f, 0.03620713f, 0.25295511f, -0.27168790f, -0.29972792f, -0.20315456f, -0.09761415f, 0.07275312f, 
    -0.06243984f, -0.10187117f, 0.00046876f, -0.07739450f, -0.07975274f, 0.05549587f, -0.01362009f, -0.03595576f, 
    0.02826523f, -0.03351144f, 0.08094379f, 0.00390738f, 0.05676563f, -0.09414138f, -0.01943147f, -0.03063127f, 
    0.01289036f, 0.06180713f, 0.01742224f, -0.05393120f, 0.01371450f, -0.07111397f, -0.05129936f, 0.07298226f, 
    0.07506564f, -0.04880985f, 0.03271981f, -0.04714884f, 0.02146849f, -0.08268546f, -0.05819981f, -0.06531134f, 
    -0.03437098f, 0.06450844f, -0.01025407f, -0.02305602f, -0.10187970f, -0.08140412f, 0.03467579f, -0.07749320f, 
    0.05295825f, 0.00882575f, 0.03611088f, -0.08908350f, -0.03468877f, 0.00181204f, 0.04143092f, -0.00916819f, 
    -0.07986780f, 0.04081636f, 0.06848389f, -0.06714459f, -0.03216775f, 0.07714475f, -0.02569931f, -0.03839177f, 
    -0.07376161f, -0.02154850f, 0.05396070f, 0.02685821f, -0.08017346f, 0.04691042f, 0.06844890f, 0.00509191f, 
    -0.04827007f, 0.02766955f, -0.00658206f, -0.03894936f, -0.02277567f, 0.07260221f, -0.01411515f, 0.04904415f, 
    -0.07051529f, -0.07013599f, 0.01206465f, 0.02413283f, 0.06328329f, 0.05593121f, 0.04651668f, -0.03439920f, 
    -0.05407641f, -0.04090716f, -0.08579121f, 0.04215701f, -0.05962736f, -0.00567860f, 0.02856148f, 0.06896652f, 
    -0.05587215f, -0.01289952f, 0.00261396f, -0.04365261f, -0.04908390f, -0.06668099f, -0.04055731f, -0.07893190f, 
    -0.04667115f, 0.03809520f, -0.01503917f, -0.03627537f, -0.06866583f, -0.10151011f, 0.06649166f, -0.07290373f, 
    -0.02569806f, -0.06380500f, -0.05652792f, -0.07865195f, 0.03940881f, -0.07797320f, -0.01914237f, -0.01252158f, 
    0.05051690f, 0.05383384f, -0.08970941f, 0.06692666f, -0.00884764f, -0.05259942f, -0.05618761f, -0.08778231f, 
    -0.01327581f, -0.07909884f, -0.05694466f, -0.10176074f, -0.07894366f, 0.05148286f, 0.02278274f, -0.08609715f, 
    0.39675039f, 0.33162218f, 0.14875586f, 0.02015335f, 0.04491115f, 0.16305311f, 0.17104717f, 0.06528798f, 
    0.11014746f, 0.17413558f, 0.02515354f, 0.15969090f, 0.02238641f, -0.27976927f, 0.08253467f, 0.01026000f, 
    -0.22486788f, 0.30103630f, 0.01420033f, -0.14164457f, -0.05946123f, -0.05671125f, 0.12786517f, 0.00302528f, 
    -0.04009938f, -0.03778978f, 0.35977677f, 0.21178429f, 0.15359487f, 0.06925512f, -0.05141628f, 0.17405684f, 
    0.15635626f, 0.04214824f, -0.06537994f, 0.04611955f, 0.05084270f, -0.01886425f, -0.02953621f, 0.10964353f, 
    -0.06117907f, 0.02847688f, 0.09003785f, -0.17272402f, 0.27448797f, 0.05658536f, 0.02778346f, 0.04504013f, 
    -0.31866893f, -0.17377056f, -0.04239170f, 0.01134450f, 0.16123267f, -0.27083498f, 0.08177655f, 0.15396672f, 
    0.26920784f, 0.01417777f, 0.21478213f, -0.03327442f, 0.16167285f, -0.13213205f, -0.08929957f, 0.22636135f, 
    0.18801966f, 0.03955471f, 0.05576153f, -0.06456523f, 0.46991459f, 0.01865002f, 0.06581904f, 0.13332959f, 
    0.06625723f, -0.11066710f, 0.01420147f, -0.00628184f, -0.19196263f, -0.03819081f, 0.43077433f, 0.22945063f, 
    -0.58250779f, 0.01688837f, 0.14916803f, -0.14698356f, 0.11918892f, 0.07011553f, 0.00659813f, -0.10530203f, 
    0.09774669f, 0.01968408f, 0.18108854f, 0.23402841f, 0.25312516f, 0.04502185f, -0.07838953f, 0.18989499f, 
    0.09749762f, -0.11675656f, 0.06311205f, 0.20168550f, 0.02879001f, 0.09444584f, 0.22206426f, 0.09246668f, 
    0.08246993f, 0.07330994f, 0.02837937f, 0.11202112f, 0.07729836f, -0.04147816f, 0.40250382f, -0.06002926f, 
    -0.00951980f, 0.01415430f, -0.04659773f, 0.21342440f, -0.01980250f, 0.39552960f, -0.00155160f, 0.02225265f, 
    0.19099309f, 0.18095464f, 0.20086321f, -0.14425300f, -0.31076446f, -0.20194131f, 0.03652443f, 0.04841881f, 
    -0.05125622f, 0.20151688f, 0.03636734f, 0.10884088f, -0.26654348f, -0.16391686f, -0.11673347f, 0.03808059f, 
    -0.11821749f, -0.08236954f, -0.03979046f, 0.15791315f, 0.03248598f, 0.08622930f, -0.17464779f, -0.00996723f, 
    -0.29661998f, 0.22876525f, 0.01776588f, -0.01139992f, -0.00173406f, 0.11175822f, 0.05965326f, -0.02975435f, 
    0.07012974f, -0.42426905f, -0.12692042f, 0.21364337f, 0.07630656f, 0.11402720f, -0.16298442f, 0.11450054f, 
    0.18530019f, 0.18380205f, -0.02478999f, 0.12796600f, 0.15567560f, -0.09513567f, -0.12386634f, -0.00889794f, 
    -0.38469610f, 0.20172748f, -0.04389660f, -0.09074125f, 0.36040026f, -0.24271572f, -0.19176926f, -0.22811820f, 
    0.05990845f, 0.26083586f, 0.07527691f, -0.11040138f, 0.16461125f, -0.08064838f, -0.15368503f, -0.06395029f, 
    -0.43657476f, -0.31982186f, -0.08396352f, 0.13723995f, -0.12328714f, 0.05805096f, -0.00398867f, -0.14603063f, 
    -0.05316910f, -0.17578833f, -0.15344848f, -0.10442685f, 0.21068311f, 0.17921504f, 0.02775983f, -0.17232731f, 
    0.12222383f, -0.03291729f, 0.27212253f, -0.22135779f, -0.15023887f, -0.00471458f, 0.16465567f, 0.23077741f, 
    0.25302669f, -0.40803796f, -0.08347506f, 0.28462535f, -0.20280391f, -0.06076500f, -0.05015139f, -0.23788387f, 
    0.07042775f, -0.24123573f, 0.10376323f, 0.17261319f, 0.29691070f, 0.04488175f, 0.05706524f, 0.10148435f, 
    -0.09774841f, 0.74601817f, -0.02040245f, -0.16683777f, -0.12616916f, 0.09419387f, 0.05872371f, -0.24256058f, 
    -0.15335386f, 0.10389480f, 0.00993347f, 0.07156634f, -0.03903193f, 0.01063385f, -0.22295810f, -0.02805929f, 
    0.19815335f, 0.04875924f, -0.87868243f, -0.05550351f, -0.02693372f, 0.27008349f, 0.13415049f, -0.01234910f, 
    0.11163288f, -0.10460223f, 0.00180906f, -0.07179659f, 0.13365355f, 0.11230636f, -0.17857975f, 0.20375708f, 
    0.04973374f, -0.07772776f, -0.08060274f, 0.02422857f, -0.02165005f, -0.02769615f, 0.02446422f, -0.09974520f, 
    -0.07189359f, -0.04281610f, 0.08296558f, -0.03573609f, -0.11711057f, -0.06965991f, -0.08391619f, -0.05864950f, 
    0.05409665f, 0.09168677f, -0.02284059f, -0.03430982f, -0.02050770f, 0.04424692f, -0.03173129f, -0.03000533f, 
    0.07909393f, -0.11424233f, -0.01988081f, 0.03064250f, -0.10021080f, -0.02397088f, 0.10002050f, -0.06085981f, 
    -0.04514854f, -0.10272764f, -0.09289309f, -0.04297630f, 0.01780334f, 0.03071227f, 0.06204551f, -0.01889117f, 
    -0.04034021f, -0.12095444f, 0.02632186f, 0.05500966f, -0.05677133f, -0.00380490f, -0.03401934f, -0.09134374f, 
    -0.09128948f, -0.00244991f, 0.05650630f, 0.02596859f, -0.00877948f, -0.05243062f, -0.07718281f, 0.02611295f, 
    0.03874837f, -0.00843298f, -0.08689445f, -0.04897464f, 0.04005631f, -0.06218189f, -0.03642091f, -0.04470676f, 
    0.07360830f, -0.00921941f, 0.03975467f, -0.00315053f, -0.03016523f, -0.00014417f, -0.07746286f, 0.03483240f, 
    -0.01824099f, -0.09251007f, -0.08657312f, -0.05205374f, 0.08393481f, 0.04616805f, 0.02198736f, -0.06783570f, 
    -0.05557536f, -0.07034720f, -0.06180138f, -0.06068168f, -0.05484086f, -0.02013607f, 0.00834507f, -0.04335628f, 
    -0.11466326f, -0.05861676f, -0.10426366f, -0.05858980f, 0.02693144f, 0.01271416f, -0.00344402f, 0.04560369f, 
    -0.06803077f, -0.12538603f, 0.13092168f, 0.04847621f, 0.02508800f, -0.14879556f, 0.04651892f, 0.04214580f, 
    0.06624199f, 0.06228642f, 0.07029428f, -0.00762723f, 0.07826322f, 0.03436751f, -0.00801402f, -0.09641585f, 
    0.05310892f, 0.04834601f, 0.09801212f, -0.05938956f, 0.00271861f, 0.08952408f, -0.08451439f, -0.03352710f, 
    -0.03890150f, 0.03298207f, -0.08733988f, 0.00356080f, 0.05348236f, 0.02795043f, 0.02204919f, -0.00364196f, 
    -0.35724780f, 0.03783932f, -0.19416031f, 0.24681671f, 0.05628874f, -0.04630863f, 0.19847605f, 0.10622518f, 
    0.02252023f, 0.05813240f, 0.05016430f, -0.00162664f, -0.08715077f, 0.02873305f, -0.23262069f, -0.19516465f, 
    -0.07442867f, -0.18941914f, -0.01414964f, 0.07138577f, 0.10009012f, -0.04371901f, 0.08304952f, 0.15251100f, 
    -0.08060355f, 0.15898812f, 0.31615138f, 0.00723108f, -0.43614620f, 0.06987679f, 0.11131103f, 0.05796984f, 
    -0.24665177f, 0.11964280f, 0.24161661f, -0.07655121f, 0.05070298f, 0.20823184f, 0.08583201f, 0.04361174f, 
    0.21419682f, -0.07256412f, 0.34151086f, 0.04500336f, 0.05948684f, -0.63497585f, -0.06643747f, -0.03589481f, 
    0.32756716f, -0.23830800f, -0.00948431f, -0.00619157f, 0.10577898f, 0.11609440f, -0.32706127f, -0.47079834f, 
    0.08537713f, -0.19425587f, -0.26376432f, 0.09602597f, -0.10247904f, 0.09239163f, 0.02612890f, -0.21985954f, 
    0.17400840f, -0.06507160f, -0.04368778f, -0.02730975f, -0.29844189f, -0.19151568f, 0.02847201f, 0.17920512f, 
    0.10904866f, -0.12481834f, 0.50101328f, -0.47790158f, 0.17703167f, 0.39346635f, -0.17304724f, 0.04005133f, 
    0.35647970f, -0.05359526f, 0.05643168f, -0.04535901f, 0.09677715f, -0.42315689f, -0.36333814f, -0.04140258f, 
    -0.02616828f, 0.00839578f, -0.37800467f, -0.22882979f, 0.19323911f, -0.12403793f, 0.05221190f, -0.13041185f, 
    -0.16191728f, 0.14770982f, -0.10738985f, -0.08516596f, 0.19568598f, 0.01550350f, -0.02355031f, 0.02137751f, 
    0.14997341f, 0.22761355f, 0.04436001f, 0.08792852f, 0.14177898f, 0.20727949f, -0.50771612f, -0.12395545f, 
    -0.55682755f, -0.07657947f, -0.34200329f, -0.04412329f, -0.02745622f, -0.65494543f, -0.06864899f, 0.12151074f, 
    -0.02814028f, 0.11188570f, 0.12092989f, 0.12666395f, 0.22702481f, 0.16709349f, 0.02686064f, 0.42439628f, 
    -0.08367230f, 0.05045407f, -0.04408318f, -0.02862233f, -0.09625418f, 0.06814768f, -0.04364201f, -0.03058234f, 
    -0.10793963f, 0.00234760f, -0.07856391f, 0.02310744f, -0.03190398f, 0.05312956f, -0.02378607f, -0.08696057f, 
    0.06831657f, 0.04552571f, 0.05831917f, -0.08339790f, -0.08823401f, 0.02214460f, 0.01004138f, -0.10210547f, 
    -0.00336527f, -0.02705092f, 0.04770628f, -0.00482118f, -0.06688072f, -0.08036473f, -0.07542936f, -0.07161295f, 
    -0.03406970f, -0.10481136f, 0.01106888f, -0.07099039f, 0.03822378f, -0.02163771f, -0.06503876f, 0.05873484f, 
    0.00701660f, -0.03768977f, 0.05891811f, -0.05388095f, -0.08672189f, -0.01451213f, -0.05110902f, 0.02920479f, 
    -0.01988100f, -0.03198210f, -0.03963786f, 0.01584589f, -0.02531286f, -0.00116770f, -0.06767426f, 0.02287059f, 
    -0.06547333f, 0.00966026f, 0.06188808f, -0.05823364f, 0.03772314f, 0.03403529f, -0.09201128f, -0.10080978f, 
    0.05637113f, 0.05660655f, -0.02405069f, -0.00922276f, -0.07925643f, 0.05814661f, 0.06592223f, -0.02398688f, 
    0.06443869f, 0.04806500f, -0.00438771f, -0.05265607f, -0.00814074f, -0.00630507f, -0.08260535f, 0.02872754f, 
    0.07302488f, -0.05175757f, -0.10269846f, -0.00165952f, 0.06264446f, -0.03325848f, 0.03743938f, -0.02575986f, 
    -0.01975867f, -0.00807697f, -0.04470152f, -0.02130154f, 0.03727904f, 0.01712928f, -0.03579579f, -0.00319207f, 
    0.02619656f, 0.03859452f, 0.02448986f, -0.03796700f, -0.09714242f, -0.05398914f, 0.04471225f, 0.02143373f, 
    -0.06202343f, -0.02799297f, -0.02719613f, -0.03770043f, -0.06861039f, -0.06020241f, -0.09728537f, -0.07343749f, 
    0.06436428f, 0.06824920f, 0.00374295f, -0.01786197f, -0.08576511f, 0.07415792f, 0.05401163f, -0.08832625f, 
    0.05143665f, -0.04986179f, 0.04582887f, -0.00162962f, -0.01773748f, 0.05858985f, 0.00700858f, 0.05861206f, 
    -0.00721722f, -0.35698676f, 0.37365976f, 0.03158513f, -0.00505415f, -0.03792489f, 0.14244470f, 0.15692784f, 
    -0.34793928f, -0.07227929f, 0.04210997f, 0.05144783f, 0.11879010f, -0.23726100f, -0.05258733f, 0.07720497f, 
    -0.50137335f, -0.43540078f, 0.05690221f, -0.26483881f, 0.20561197f, 0.31526443f, -0.00584259f, -0.27468756f, 
    -0.02873218f, 0.01065506f, -0.34960282f, -0.16171552f, 0.27606985f, -0.20284511f, -0.01037003f, 0.13737395f, 
    -0.13371624f, -0.18963504f, -0.16994028f, 0.17685500f, -0.20555481f, 0.05959974f, 0.09352506f, 0.22038703f, 
    -0.00475799f, -0.03637575f, -0.39514020f, -0.10838667f, 0.43975550f, 0.20559114f, -0.00464872f, 0.04916208f, 
    -0.09029783f, 0.32434422f, 0.00429608f, 0.50299609f, -0.02970979f, -0.17207274f, -0.04066251f, 0.20971586f, 
    -0.02841358f, -0.07526821f, -0.22535242f, 0.11163177f, 0.27894753f, 0.00918266f, -0.01870448f, 0.04193825f, 
    0.01215769f, 0.10529633f, -0.00254520f, 0.06426922f, -0.84616792f, 0.26433909f, -0.10408559f, 0.21566756f, 
    -0.08833405f, -0.06072972f, -0.19479536f, 0.23010458f, 0.06383503f, -0.23637560f, 0.33247295f, 0.10189828f, 
    -0.07830595f, 0.23541927f, -0.25478783f, 0.04556600f, -0.10431479f, 0.34039524f, 0.11659306f, 0.24848081f, 
    0.19301441f, 0.15348689f, 0.43481317f, 0.21656708f, 0.19437195f, 0.19512396f, 0.01681346f, 0.38927764f, 
    0.11560670f, -0.07673861f, 0.24048445f, 0.13816962f, -0.30583411f, -0.12820365f, 0.36085573f, 0.05652675f, 
    0.19356129f, -0.12898970f, -0.07536196f, -0.10075670f, -0.13938300f, -0.19472390f, 0.12601745f, -0.06038407f, 
    -0.44532678f, -0.01240000f, -0.27626085f, -0.34116071f, 0.15834033f, 0.57021689f, 0.14876033f, -0.10390206f, 
    0.11165990f, -0.07960469f, -0.01988302f, 0.15723664f, -0.24276546f, -0.04400701f, 0.11907291f, 0.16975588f, 
    0.29092142f, -0.26826757f, 0.33733171f, 0.05646724f, -0.17194527f, -0.50937271f, 0.13257457f, 0.20502585f, 
    -0.06519260f, -0.09416214f, -0.05155630f, 0.15869588f, -0.21586934f, 0.04068817f, -0.53185105f, -0.04073737f, 
    -0.36742264f, -0.08165532f, 0.00193614f, -0.00951533f, 0.42450744f, -0.20489444f, 0.21059684f, -0.24158052f, 
    0.08597955f, -0.00829915f, 0.07253791f, -0.41087076f, 0.13494591f, -0.36997271f, -0.59193093f, 0.10753114f, 
    0.04492853f, -0.25299412f, 0.18533289f, 0.19240068f, -0.47185752f, 0.12425919f, 0.01105502f, -0.17100379f, 
    -0.05829720f, -0.58061987f, -0.22416677f, -0.53194940f, -0.15419485f, -0.11640918f, -0.23652786f, 0.10763102f, 
    0.11455823f, 0.36061952f, -0.04444731f, 0.38018945f, 0.03741474f, -0.01800411f, -0.48992696f, -0.17018534f, 
    -0.09937999f, -0.43166262f, -0.31148329f, 0.10471155f, 0.11058584f, -0.06355220f, -0.30704272f, 0.03950014f, 
    0.19507705f, 0.18607582f, 0.04603498f, 0.01577521f, -0.00539339f, 0.02862025f, -0.00459505f, 0.32332343f, 
    -0.11566080f, -0.05674220f, 0.13512492f, -0.54040450f, -0.16528393f, 0.08930219f, 0.09365256f, -0.19066170f, 
    0.61594319f, -0.48739198f, -0.00331206f, 0.07815169f, -0.17154133f, -0.39219734f, 0.07318904f, 0.05661115f, 
    0.30387306f, 0.02105949f, 0.03381504f, 0.30046290f, 0.26201683f, -0.07147637f, -0.05819686f, 0.06276906f, 
    -0.01047113f, -0.09585013f, 0.05537153f, -0.18946920f, 0.04139380f, 0.11591539f, 0.20937590f, -0.26450413f, 
    -0.04735385f, -0.21714671f, 0.03633556f, 0.02468523f, 0.11158175f, -0.24288945f, -0.18859561f, -0.36548221f, 
    -0.31945831f, 0.04647909f, -0.49014860f, -0.29962641f, 0.12246560f, 0.64254028f, 0.03519087f, -0.11459845f, 
    0.01629356f, -0.04082841f, 0.13750713f, 0.18939786f, -0.17563705f, 0.11957294f, 0.18562938f, -0.05414023f, 
    0.06674796f, 0.01723624f, -0.00047082f, -0.08635546f, -0.07008789f, -0.03898903f, -0.06981384f, 0.02010482f, 
    -0.10875284f, -0.03535394f, -0.03567956f, -0.03085376f, 0.05646528f, 0.03626269f, -0.10353316f, 0.00970505f, 
    0.00632591f, -0.04293245f, 0.04311116f, -0.07173228f, -0.07713704f, 0.00828656f, -0.05021218f, 0.05128182f, 
    -0.04100317f, -0.09051791f, -0.01596536f, -0.00964621f, -0.05517626f, 0.00020596f, -0.01557518f, -0.08445793f, 
    0.03698035f, -0.07461655f, 0.03428397f, 0.02970455f, -0.02161769f, -0.06678329f, 0.01128021f, -0.00710936f, 
    -0.01547103f, 0.04793050f, -0.01114087f, -0.07818829f, -0.04320706f, -0.08500998f, -0.09652442f, 0.05157884f, 
    0.05940209f, 0.00254687f, 0.06153473f, -0.03728868f, -0.02530574f, 0.06802186f, 0.03535242f, -0.10447148f, 
    -0.06590962f, -0.02331001f, -0.06457341f, 0.05121493f, -0.00364272f, -0.03048498f, -0.04154084f, 0.03473787f, 
    -0.08231305f, 0.00356956f, -0.09684188f, 0.03019661f, -0.01142510f, -0.00152976f, -0.04361013f, -0.02438528f, 
    0.05075820f, -0.05834974f, -0.00421139f, 0.03711872f, 0.04209158f, -0.01466377f, -0.09645358f, 0.06736466f, 
    -0.00373335f, -0.00387940f, 0.03073096f, -0.05939577f, -0.01997115f, 0.04762973f, 0.02628833f, -0.02667636f, 
    -0.04833242f, -0.04318360f, 0.04657878f, -0.07538929f, -0.05209948f, -0.10343404f, 0.02355430f, -0.07784469f, 
    0.03897963f, 0.05982634f, -0.00655450f, 0.03164609f, 0.00771548f, 0.00359683f, 0.01994472f, -0.02023365f, 
    0.01139108f, -0.01240612f, -0.04708577f, -0.03216410f, 0.01492660f, -0.05847060f, -0.01788727f, -0.06588107f, 
    0.06268464f, -0.04582746f, 0.03028776f, -0.02623261f, -0.10303103f, -0.06518375f, -0.06517361f, 0.01787196f, 
    0.05608595f, -0.05802704f, 0.08550970f, -0.02505975f, -0.08722945f, -0.05603484f, -0.00630979f, 0.07325149f, 
    -0.06520547f, 0.24650262f, 0.13723710f, -0.12749466f, 0.18879646f, -0.02805913f, 0.24672914f, -0.01250752f, 
    0.04343123f, -0.01388880f, -0.05949898f, 0.10897990f, -0.28184432f, 0.01909955f, 0.12032042f, -0.17851850f, 
    0.22866501f, 0.53506815f, 0.10322156f, 0.16085789f, 0.01529033f, 0.03369923f, 0.06153502f, 0.23187213f, 
    -0.07637031f, 0.08233108f, -0.23859613f, 0.02346394f, -0.17458951f, -0.33511963f, -0.03852792f, 0.00829468f, 
    -0.10319690f, 0.19671118f, -0.09117897f, 0.13320331f, -0.03594531f, 0.08954516f, -0.03535247f, -0.02263885f, 
    0.27966598f, -0.69727343f, -0.06307561f, -0.40963587f, 0.19616333f, 0.37500665f, -0.01340990f, 0.00012804f, 
    0.01141706f, -0.03717599f, 0.06718381f, -0.07294936f, 0.19873917f, -0.07989652f, 0.27015454f, 0.02289400f, 
    -0.48557118f, 0.09418021f, 0.15903734f, -0.13445990f, -0.04598807f, -0.14036521f, 0.07489598f, 0.30451843f, 
    0.27504981f, 0.01022802f, -0.07579059f, -0.18748158f, 0.29193991f, -0.10167870f, -0.02479174f, -0.34237996f, 
    0.12067891f, -0.46081501f, -0.13576910f, 0.25066647f, 0.06460241f, -0.07852547f, 0.10220454f, -0.11001870f, 
    -0.11771720f, 0.24034868f, 0.23424770f, -0.13528879f, 0.21716784f, 0.09108343f, -0.16441925f, -0.27250093f, 
    0.09751451f, -0.19238116f, 0.03017436f, -0.01278574f, -0.24516913f, 0.02513420f, 0.06835538f, 0.08246408f, 
    0.14551774f, 0.11413984f, -0.01420556f, -0.00478907f, 0.02665725f, 0.83839709f, -0.07482876f, -0.04819613f, 
    -0.06942034f, 0.24826969f, 0.08070585f, 0.23789674f, 0.27873337f, 0.01374746f, 0.38398701f, -0.05519154f, 
    0.37889245f, -0.01383931f, 0.19231161f, 0.17518294f, -0.18629217f, -0.16597828f, -0.06804344f, -0.02331120f, 
    0.27343565f, 0.20630769f, 0.30315331f, -0.10825188f, -0.27785280f, 0.19038917f, -0.07479849f, -0.10214857f, 
    0.00866126f, -0.02078495f, -0.01613794f, -0.07747272f, -0.02710026f, 0.05466062f, 0.08385944f, -0.03710537f, 
    0.07291529f, -0.03367320f, -0.01783301f, -0.02805599f, -0.00646620f, -0.02383422f, -0.02582886f, -0.01672183f, 
    0.00985516f, 0.00136756f, -0.02972019f, -0.09046227f, 0.00749271f, 0.01536095f, 0.06283354f, -0.07443907f, 
    -0.06927680f, -0.06447208f, -0.00539061f, -0.02236119f, -0.04837627f, 0.01481868f, -0.04740889f, 0.05180671f, 
    -0.07209446f, -0.08503506f, -0.04632821f, 0.00797096f, -0.00711233f, -0.02071862f, -0.03515068f, 0.02223952f, 
    -0.07888752f, -0.02205754f, -0.03884666f, -0.00031992f, -0.00395915f, 0.03897415f, -0.04884231f, -0.08316810f, 
    -0.02516120f, 0.01462011f, 0.00063970f, 0.00311548f, 0.04936586f, -0.07397597f, -0.00947223f, 0.08741261f, 
    0.05560527f, -0.02723975f, -0.02194763f, 0.02487028f, -0.00709931f, 0.05274815f, 0.00878905f, -0.05367789f, 
    0.05797707f, -0.01597973f, -0.00241036f, -0.00537829f, 0.03075031f, -0.09244871f, -0.05973236f, -0.05888416f, 
    0.04892586f, -0.07291368f, 0.03090637f, 0.06963672f, -0.02143797f, 0.01256694f, 0.07970086f, 0.00586677f, 
    0.00884533f, 0.02433708f, -0.00224183f, 0.02258567f, -0.07134049f, 0.03691399f, 0.03640004f, -0.07628082f, 
    0.00911726f, -0.00832295f, -0.08455653f, 0.00012713f, -0.05779832f, -0.06771815f, 0.01531149f, -0.06201290f, 
    -0.02382382f, -0.06896362f, 0.00201841f, -0.08389207f, 0.02501739f, -0.01362209f, 0.01498287f, -0.02035190f, 
    -0.00903831f, -0.08417611f, 0.01471798f, 0.06028002f, 0.06079229f, 0.06624560f, -0.01203006f, 0.07319080f, 
    -0.08069910f, -0.05617135f, -0.05777648f, 0.07036050f, -0.01901934f, -0.03279001f, 0.00963121f, 0.05233719f, 
    0.00001892f, -0.04540664f, -0.07967986f, -0.01866038f, -0.00232128f, -0.03238582f, 0.07919142f, 0.06396472f, 
    0.05832766f, -0.07454169f, 0.08040545f, -0.09768493f, -0.04095486f, -0.03172204f, 0.06727923f, -0.09627008f, 
    -0.02431333f, -0.05698239f, 0.04378992f, -0.05935722f, -0.05564836f, 0.06486865f, -0.02249905f, 0.06002392f, 
    0.02123517f, 0.05093669f, -0.05336158f, -0.08108522f, -0.08618812f, 0.02035861f, -0.06406911f, 0.00180353f, 
    0.06113257f, -0.06870743f, -0.01397414f, -0.01228458f, -0.08633550f, 0.01868010f, -0.05204184f, 0.01606226f, 
    -0.04229953f, -0.07345872f, -0.03659604f, -0.07483425f, 0.03995132f, 0.06564334f, -0.06757721f, 0.01364608f, 
    -0.06665909f, 0.02606694f, -0.09422927f, -0.07137468f, -0.00672464f, -0.07986388f, 0.00736573f, -0.09249693f, 
    -0.08734029f, 0.04663157f, -0.06663604f, 0.07850045f, -0.00308484f, 0.00095228f, 0.05790312f, -0.08355166f, 
    0.01826059f, -0.05007334f, -0.03134029f, 0.06806934f, 0.05193397f, -0.04512865f, -0.02942540f, -0.00843285f, 
    -0.08066742f, -0.08388020f, -0.00862609f, -0.01861552f, 0.03845359f, -0.03347456f, -0.05878549f, -0.03317143f, 
    -0.08468640f, -0.04122499f, -0.01255778f, 0.02167127f, 0.07899649f, -0.03755202f, -0.04946995f, -0.04996910f, 
    0.00700475f, -0.04878012f, -0.04449762f, -0.08325618f, -0.05679321f, -0.05596809f, 0.07994053f, 0.00059021f, 
    0.00419215f, -0.06843551f, 0.03578599f, 0.04357010f, -0.02261171f, 0.02689149f, -0.07939829f, -0.02000347f, 
    0.03750952f, 0.07696716f, 0.00341926f, 0.02233549f, -0.02721839f, 0.00311264f, -0.08861059f, 0.02243735f, 
    0.04521425f, 0.04156878f, 0.00633623f, -0.01915649f, -0.04452911f, -0.08053906f, 0.08524850f, 0.05083410f, 
    0.06955586f, -0.02460186f, -0.05037615f, 0.00928057f, 0.06037866f, -0.01755216f, -0.01046402f, -0.06308162f, 
    -0.08786479f, -0.03582485f, -0.06946734f, 0.02968973f, 0.04886552f, 0.04743424f, -0.09001923f, 0.05957733f, 
    0.07002915f, 0.03055461f, 0.04671159f, -0.06436141f, -0.07548727f, -0.08687732f, -0.07540264f, -0.03835623f, 
    -0.07317949f, -0.01228721f, 0.04027257f, 0.02628848f, 0.04416183f, -0.10046328f, 0.04488656f, -0.02802770f, 
    0.06396180f, -0.03823613f, -0.05794923f, -0.09511266f, 0.04745474f, -0.02325858f, 0.04421557f, 0.02345111f, 
    0.06015340f, 0.06967501f, -0.05822938f, 0.04996179f, -0.08625127f, -0.01785308f, -0.04914882f, 0.03757155f, 
    0.03600713f, -0.03012090f, 0.00260401f, -0.06353199f, 0.06167184f, -0.05400371f, -0.04300726f, 0.03733911f, 
    -0.03554926f, 0.08282369f, 0.06508880f, -0.08518528f, 0.04993733f, -0.09348168f, -0.04564849f, 0.04959691f, 
    -0.07447735f, -0.04179771f, -0.07874836f, -0.00436380f, -0.03866817f, -0.00531168f, 0.03716399f, 0.02445858f, 
    0.08463605f, 0.02443701f, 0.05847364f, -0.04621521f, 0.03086032f, -0.05754171f, 0.03820185f, 0.00675178f, 
    0.01139868f, 0.01195566f, -0.03779989f, -0.06743550f, 0.03363765f, -0.03986491f, 0.08607717f, 0.08399177f, 
    -0.08420098f, -0.02636811f, 0.06451965f, -0.06325753f, 0.02349853f, -0.04351571f, -0.02213530f, -0.02073615f, 
    -0.01763883f, -0.04135058f, -0.07712834f, -0.09109812f, -0.07973260f, -0.05943627f, 0.00952005f, -0.03796850f, 
    -0.03268402f, -0.02917906f, 0.00779515f, 0.03935356f, 0.00897908f, 0.07445952f, -0.03568527f, 0.00084875f, 
    0.02993349f, -0.08099800f, 0.02333739f, -0.04603177f, -0.10640989f, -0.05402295f, -0.04233395f, 0.00608984f, 
    -0.02105026f, 0.04038498f, 0.04371823f, -0.01299520f, 0.00328358f, 0.06574570f, -0.00012523f, -0.02146541f, 
    -0.07456927f, 0.00504933f, -0.07284836f, -0.08644767f, -0.05730834f, 0.01167246f, -0.04448687f, 0.00566168f, 
    0.05683730f, -0.06975565f, -0.02337499f, 0.00171891f, -0.05772767f, 0.02745338f, 0.02991305f, 0.02111073f, 
    -0.45408505f, 0.12172621f, -0.29026392f, 0.17380983f, 0.02437339f, 0.00153262f, 0.11804928f, 0.10611406f, 
    0.04606814f, -0.07415456f, -0.01736490f, 0.17319605f, 0.01981840f, -0.02588025f, -0.04904276f, 0.04276228f, 
    -0.22622564f, -0.21575187f, -0.05315437f, 0.08559719f, 0.28715280f, -0.37463018f, 0.17179736f, 0.15149316f, 
    0.04259212f, -0.04141882f, 0.38373202f, 0.15285358f, -0.18838950f, 0.05929526f, 0.04944064f, -0.22780195f, 
    -0.07362471f, 0.09074938f, 0.07072823f, -0.01698828f, 0.16176583f, 0.19522545f, 0.01487100f, 0.04503790f, 
    0.02853681f, 0.28183478f, 0.08899227f, -0.04802305f, 0.24572565f, -0.64935929f, 0.08269681f, -0.02528076f, 
    0.09959293f, -0.37727681f, 0.02179235f, -0.13755006f, 0.07399242f, -0.06364571f, -0.43400094f, -0.14733072f, 
    -0.03980630f, -0.22515886f, 0.00678938f, 0.34326428f, -0.05368037f, 0.25535867f, 0.04812637f, -0.15858564f, 
    0.18880573f, -0.11172942f, 0.01821989f, 0.14759541f, -0.18188143f, -0.04948648f, 0.00715736f, 0.01888352f, 
    0.12872742f, 0.03885886f, 0.36915210f, -0.51450235f, 0.08558505f, 0.21604988f, -0.13609907f, 0.08453336f, 
    0.31819978f, -0.28507191f, -0.20529982f, 0.31809115f, 0.13859600f, -0.49419603f, -0.31696692f, -0.03675601f, 
    0.03250900f, 0.01741792f, -0.23429629f, 0.01947327f, 0.18972771f, 0.10786113f, -0.06432180f, -0.07846490f, 
    -0.18832031f, 0.45218319f, -0.07471066f, -0.24484341f, 0.09048470f, -0.10696328f, -0.07351826f, -0.06121641f, 
    0.06682301f, 0.27006969f, 0.07063123f, 0.04397763f, 0.18602358f, 0.13139465f, -0.43834528f, 0.08973482f, 
    -0.31727567f, -0.02756460f, -0.25015688f, -0.03208822f, 0.16970500f, -0.82727414f, 0.31494632f, 0.12689516f, 
    0.04155348f, 0.16553554f, 0.14877422f, -0.12747659f, 0.22633636f, -0.01777955f, 0.02427037f, 0.49062610f, 
    -0.33047330f, -0.08762676f, 0.07437781f, -0.01920838f, -0.17287973f, 0.10081981f, -0.21359172f, -0.20294665f, 
    0.01265430f, 0.09089696f, -0.07974985f, -0.19415617f, 0.08401487f, -0.07203867f, 0.17662643f, 0.06963718f, 
    0.24940409f, 0.42481345f, 0.01047878f, -0.11313922f, -0.12867095f, 0.66777915f, -0.47532138f, -0.28365645f, 
    0.07690778f, 0.26625273f, -0.14097895f, -0.07996155f, 0.10282391f, -0.40170920f, 0.20470874f, -0.01340476f, 
    0.13047692f, -0.18766589f, 0.09747984f, -0.49383160f, 0.05516840f, -0.04774975f, 0.31992269f, -0.16980886f, 
    -0.03896083f, 0.21585308f, -0.29936552f, 0.07902795f, -0.21788268f, 0.18698969f, 0.06554036f, 0.14302173f, 
    -0.03861821f, 0.83682382f, -0.07552021f, 0.23043059f, 0.44895607f, 0.28671139f, 0.15858826f, -0.71313709f, 
    0.26356611f, 0.37233734f, 0.39527136f, -0.02788753f, -0.22972856f, 0.02064024f, 0.13360214f, 0.12753622f, 
    -0.10173736f, 0.39778906f, 0.14985365f, -0.03560834f, 0.37497285f, 0.33501801f, 0.07699998f, 0.13444395f, 
    -0.08145432f, -0.11574904f, -0.46793780f, 0.54463094f, 0.32389885f, -0.03031937f, -0.29999676f, -0.26824328f, 
    -0.59516293f, 0.28368697f, -0.02817989f, 0.02055309f, -0.10974874f, 0.21120101f, 0.11721038f, 0.26762933f, 
    0.17090616f, 0.14821097f, 0.06759954f, -0.29371950f, -0.36742851f, 0.07207374f, 0.00959392f, 0.15041478f, 
    0.36187422f, 0.16752991f, 0.16457024f, 0.21957396f, -0.20649849f, 0.25154895f, 0.23876421f, 0.13255285f, 
    0.11993399f, 0.21635216f, -0.04514245f, -0.27864680f, -0.53450972f, -0.18738663f, 0.14253728f, -0.01040066f, 
    -0.19132575f, 0.08312640f, 0.29370630f, 0.09513988f, 0.10745873f, 0.05111267f, -0.21629952f, 0.14980400f, 
    0.45609042f, -0.30666324f, -0.36798686f, 0.37259722f, 0.00493814f, 0.08548292f, 0.03886383f, -0.43812957f, 
    0.02104302f, 0.00682447f, 0.00149644f, -0.03890901f, -0.08509666f, 0.05131189f, 0.06394947f, -0.07942009f, 
    -0.04800269f, 0.10387167f, 0.05119703f, -0.01705194f, -0.10214431f, -0.04062283f, -0.01500642f, -0.12056689f, 
    -0.03656060f, -0.08089463f, -0.05043369f, 0.01872883f, -0.01783863f, -0.04984907f, -0.07096341f, -0.10802478f, 
    -0.07295211f, 0.07427403f, 0.02234354f, -0.03579643f, -0.06454170f, 0.01229376f, -0.00047716f, -0.03922719f, 
    -0.11643821f, -0.06606108f, -0.05983211f, -0.03411190f, 0.00921901f, 0.00408428f, 0.05186471f, 0.06451853f, 
    0.02372087f, -0.02745962f, -0.00716405f, 0.03466602f, -0.00244051f, 0.14227597f, -0.03264622f, -0.08570475f, 
    0.09366248f, -0.05433604f, -0.02576463f, -0.09582522f, -0.05799108f, 0.06593871f, -0.09279913f, 0.01655434f, 
    -0.09055731f, -0.06562528f, 0.01260026f, -0.04986655f, -0.04905812f, -0.03736228f, 0.00723473f, 0.02151231f, 
    -0.01726513f, 0.05165077f, 0.00134771f, -0.03501218f, -0.05736867f, -0.06627586f, -0.07119827f, -0.09195068f, 
    -0.03772996f, -0.12647581f, -0.06350765f, -0.02608402f, 0.01539506f, -0.06020687f, 0.02782625f, 0.03430917f, 
    0.07627260f, -0.01169641f, 0.01784368f, -0.07141052f, 0.03958334f, -0.04303563f, -0.01591696f, 0.03117848f, 
    -0.01359518f, -0.08855098f, 0.04588367f, 0.00384837f, -0.06081472f, -0.11916415f, 0.05907480f, -0.09334221f, 
    0.01591183f, -0.11522195f, -0.00893276f, -0.08457923f, -0.01380686f, -0.05367172f, -0.08506913f, -0.10227174f, 
    -0.01171060f, -0.06394526f, 0.07222655f, -0.09076627f, -0.01282872f, 0.07019804f, -0.05333300f, -0.00040426f, 
    -0.01365182f, 0.03007404f, 0.02188678f, 0.03666389f, 0.02603762f, 0.06575144f, -0.10159341f, -0.08949661f, 
    0.08994377f, -0.01632789f, -0.03125222f, 0.06358699f, 0.00118542f, 0.06610584f, -0.08387224f, 0.06150552f, 
    0.14367960f, -0.10947306f, 0.06859379f, 0.14521055f, 0.17649454f, -0.04167759f, 0.26080936f, 0.05236042f, 
    -0.04750033f, 0.03798315f, 0.02985538f, 0.07417192f, 0.06379197f, -0.12246121f, 0.02318107f, 0.06687956f, 
    -0.12875506f, 0.36639333f, 0.02919698f, 0.05907292f, 0.07332775f, -0.45307270f, 0.10831571f, 0.05655148f, 
    -0.03530355f, 0.21335223f, 0.29909980f, 0.02285692f, -0.33632183f, 0.13106264f, 0.08444548f, -0.01130248f, 
    -0.27899113f, -0.05898099f, -0.02852155f, 0.03841980f, -0.14005242f, 0.09600827f, 0.13985777f, -0.14318426f, 
    0.13688813f, 0.05781431f, -0.13652173f, -0.10943072f, 0.04022832f, -0.01305743f, 0.05891407f, 0.18602112f, 
    -0.06057197f, -0.00365437f, -0.00885689f, 0.11170720f, -0.02138909f, -0.04397828f, 0.07374704f, -0.03051802f, 
    0.22500710f, 0.13088220f, 0.21420161f, 0.07913334f, -0.04408378f, 0.06467515f, 0.16130997f, 0.17858702f, 
    -0.03214532f, 0.10329472f, 0.04519128f, 0.16489409f, 0.11922199f, 0.22743297f, 0.03561129f, 0.30381206f, 
    0.14585702f, 0.02730424f, -0.07935084f, 0.21320716f, 0.10142267f, -0.04683850f, -0.02037178f, -0.55633271f, 
    0.37374806f, 0.12977175f, -0.17347957f, 0.29116857f, 0.21505733f, -0.30288124f, -0.11791603f, -0.00748118f, 
    0.19362625f, 0.07931358f, -0.03035620f, 0.14534093f, -0.11174636f, -0.02777389f, -0.05798937f, -0.02102798f, 
    -0.00286059f, -0.29483780f, -0.15962595f, 0.07193056f, -0.10268466f, 0.42757687f, -0.31086653f, 0.19178836f, 
    0.08365821f, 0.05138784f, 0.00470609f, 0.11667166f, 0.00735573f, -0.03967237f, 0.00971355f, 0.07274746f, 
    0.07215780f, -0.01713126f, 0.37518027f, 0.30838588f, 0.13707356f, 0.07007441f, 0.23974074f, 0.15420502f, 
    0.02366639f, 0.06967343f, -0.17215873f, 0.04227558f, -0.12031940f, -0.15825385f, -0.00568637f, 0.13556828f, 
    0.00156551f, -0.00620520f, -0.00023106f, -0.04309854f, -0.08648349f, -0.09492932f, -0.06433133f, -0.08451027f, 
    -0.05942771f, -0.04091110f, 0.01859360f, 0.00618286f, -0.03060111f, 0.03286961f, 0.04766976f, -0.04720548f, 
    -0.00698026f, -0.00441388f, -0.03924913f, -0.00585947f, -0.04490171f, 0.06490848f, -0.08603121f, -0.07349169f, 
    -0.04168722f, -0.03997643f, 0.00831461f, 0.07768922f, -0.08989429f, -0.01252801f, 0.04708559f, -0.07465078f, 
    -0.04975742f, -0.00221242f, -0.03840129f, -0.04520904f, 0.06950553f, 0.05466620f, 0.00299742f, -0.06855901f, 
    -0.05954248f, 0.03425627f, -0.03137307f, -0.07361475f, -0.00464350f, -0.02059353f, 0.06948948f, 0.06814364f, 
    -0.10929926f, -0.06509056f, -0.02681919f, 0.00887770f, 0.03226177f, -0.08765962f, -0.03992940f, -0.06824213f, 
    0.06412451f, -0.09828386f, -0.00890101f, -0.10408463f, 0.00397726f, -0.09065456f, -0.10291760f, -0.08905157f, 
    -0.04126815f, 0.07104647f, -0.08003920f, -0.09598786f, -0.00817288f, -0.09946851f, 0.00841247f, -0.10716110f, 
    -0.05955240f, -0.11270812f, -0.02394816f, 0.04902936f, 0.05095898f, 0.02322161f, 0.08430461f, -0.04620383f, 
    0.05722452f, -0.05105135f, -0.04889000f, -0.00085005f, -0.01212795f, 0.06492761f, -0.08038553f, 0.00307422f, 
    -0.06225205f, -0.01219300f, -0.07354545f, 0.03528751f, -0.04042042f, 0.07242717f, -0.03110440f, -0.02514143f, 
    -0.00958583f, 0.05652303f, -0.06248808f, -0.01538395f, 0.03717963f, 0.00811041f, -0.00968427f, 0.03968753f, 
    0.02733099f, -0.09259218f, 0.07547145f, -0.02274778f, -0.00515311f, 0.05121801f, 0.06020992f, -0.03480786f, 
    0.00993016f, 0.08271974f, -0.00522909f, 0.03700056f, 0.06137295f, -0.02458554f, -0.03254976f, -0.04723597f, 
    -0.01099158f, -0.08285756f, 0.05416424f, -0.07827585f, -0.06883690f, 0.06326833f, 0.06814918f, 0.01114881f, 
    0.03717373f, 0.06972218f, -0.02745137f, -0.00266793f, 0.03361874f, -0.07358088f, 0.02582879f, -0.10034119f, 
    -0.07671616f, 0.02925077f, -0.06575487f, 0.01989919f, -0.09486705f, -0.08806515f, -0.02673943f, -0.05108540f, 
    -0.06570263f, -0.05340545f, -0.03767917f, -0.01112052f, 0.04373519f, 0.01658349f, -0.03057248f, 0.04645333f, 
    0.05339331f, 0.03530980f, -0.00932946f, -0.03097825f, -0.02187810f, 0.07967699f, -0.02400215f, -0.03081664f, 
    -0.07237833f, -0.08129194f, -0.00801652f, -0.11885874f, 0.03942884f, -0.04599772f, -0.08453547f, -0.00480971f, 
    -0.02244803f, 0.04849913f, -0.01723055f, -0.10076650f, -0.09609682f, 0.02866448f, -0.06742085f, -0.03927180f, 
    -0.05755430f, 0.07946362f, 0.07718927f, 0.02690074f, 0.04367985f, 0.00772069f, -0.03014308f, -0.11188368f, 
    0.04975885f, 0.06020853f, -0.09358408f, -0.03912779f, 0.02010259f, -0.04181954f, -0.07214282f, -0.03154172f, 
    -0.08919439f, 0.00893332f, 0.03155630f, 0.04680675f, -0.02661199f, -0.00064256f, 0.05091743f, -0.02948594f, 
    0.03717335f, -0.09524959f, -0.11258607f, -0.05409544f, -0.07315956f, 0.01539121f, -0.07750420f, 0.00086634f, 
    -0.11494327f, 0.00211441f, -0.07022274f, -0.06061200f, 0.04588960f, 0.02516799f, 0.08691138f, -0.09164967f, 
    0.04105154f, -0.11486103f, -0.04316015f, -0.02343339f, -0.09237485f, 0.04561926f, 0.02439012f, 0.02332487f, 
    -0.07107344f, 0.01913418f, 0.00293498f, -0.03973439f, 0.04796116f, 0.06394963f, -0.07655707f, -0.03908809f, 
    -0.06709864f, 0.00718217f, -0.07790721f, -0.00768308f, 0.01751390f, 0.01740694f, -0.08326997f, 0.00090540f, 
    0.10720684f, 0.06284796f, -0.08571327f, -0.02616285f, -0.08700002f, 0.06449120f, 0.01527195f, 0.04766690f, 
    -0.10285240f, -0.07068145f, -0.01288833f, -0.04826557f, -0.00878557f, -0.10436417f, -0.03816991f, 0.00257681f, 
    0.42517424f, -0.11978798f, -0.18920402f, 0.15152253f, -0.32573289f, -0.33875114f, -0.39757076f, 0.07123184f, 
    0.14343807f, -0.25333509f, 0.05890350f, 0.23322728f, -0.08419902f, 0.24314433f, -0.47060734f, 0.11626144f, 
    0.26052752f, -0.31705019f, -0.34056094f, 0.09715638f, 0.09005661f, -0.15663497f, 0.20010921f, -0.08217456f, 
    0.09378912f, -0.04370148f, 0.25770536f, 0.03528442f, 0.36895007f, -0.35356468f, -0.29285768f, -0.28367889f, 
    0.50924909f, -0.13484246f, 0.29419318f, 0.16303423f, 0.09688509f, 0.17203054f, -0.00201314f, -0.17439766f, 
    -0.28837681f, -0.07661498f, 0.02313679f, 0.30938572f, -0.05135536f, 0.20122652f, 0.13518973f, 0.13585511f, 
    0.13762330f, 0.22970964f, -0.02531013f, 0.24219522f, -0.17461354f, 0.25342810f, -0.23705028f, 0.28008348f, 
    0.37648958f, -0.42163384f, -0.28568584f, 0.05272185f, 0.06035721f, 0.04791726f, -0.19903009f, -0.54848927f, 
    -0.18248208f, 0.12993793f, 0.23471788f, 0.02980122f, 0.55255127f, -0.01435512f, -0.00796482f, 0.26536933f, 
    -0.29965863f, 0.26758969f, 0.05502892f, -0.34413466f, -0.22012752f, 0.07836445f, -0.02948614f, 0.24385597f, 
    0.24711721f, -0.24586542f, -0.05921368f, 0.17142029f, -0.11977161f, 0.20866631f, 0.03779860f, -0.04313719f, 
    0.00344337f, 0.04315853f, -0.19911657f, 0.01157004f, 0.19796160f, 0.16646887f, -0.07823539f, -0.25546139f, 
    0.06434847f, -0.03950640f, -0.15505438f, -0.08247875f, 0.11634103f, -0.40326232f, 0.09726724f, -0.12701476f, 
    0.03086242f, -0.48337278f, 0.02597507f, 0.04470617f, -0.20273845f, -0.05917249f, -0.28559178f, -0.87271631f, 
    0.15085100f, 0.02201976f, 0.02821521f, -0.38031161f, 0.00975034f, 0.81820738f, 0.00851224f, 0.00438636f, 
    -0.26734206f, -0.19809236f, -0.02103969f, 0.50133300f, 0.21441610f, 0.02418625f, 0.04253582f, -0.42478597f, 
    0.00178951f, -0.02036822f, -0.07493638f, -0.08359797f, -0.01556099f, -0.10518008f, -0.07585016f, -0.08716754f, 
    0.01129801f, 0.02095901f, 0.05665350f, -0.04877478f, 0.03463282f, 0.06393822f, 0.06618308f, -0.08587931f, 
    -0.02219927f, -0.03828318f, 0.01352679f, 0.01335678f, 0.03779321f, 0.02423454f, -0.01037831f, -0.03806006f, 
    -0.03480370f, -0.05497755f, 0.07701889f, 0.02416417f, 0.04350468f, 0.02860879f, -0.05822904f, 0.03007054f, 
    -0.02113333f, -0.05205015f, -0.02096842f, -0.02330155f, 0.06731553f, -0.07916564f, -0.05659898f, 0.03962870f, 
    -0.01863402f, 0.00708227f, 0.07170013f, -0.06545649f, -0.03579971f, -0.04368985f, 0.04029111f, 0.03105197f, 
    -0.09615479f, -0.00115844f, -0.00176198f, -0.00229961f, 0.07727101f, 0.04256023f, 0.05610646f, -0.00272683f, 
    0.02289603f, 0.02518022f, 0.01141182f, -0.00833275f, -0.10151220f, 0.00499077f, -0.01547210f, -0.03735946f, 
    -0.02950727f, -0.06407811f, -0.04225640f, -0.07819114f, -0.00158602f, -0.07006384f, -0.01967946f, 0.05193963f, 
    0.05173265f, -0.05773056f, -0.04281661f, 0.05619098f, -0.09565718f, -0.02005321f, -0.04286437f, -0.06916969f, 
    -0.07403222f, 0.07417469f, -0.04859667f, -0.00818873f, -0.04964787f, 0.05563625f, -0.05246152f, 0.03383756f, 
    -0.09589432f, -0.00602010f, 0.02837268f, 0.00194661f, -0.01023196f, -0.04537065f, 0.03037903f, -0.04234409f, 
    -0.01276404f, -0.01265375f, -0.01950754f, -0.06712224f, 0.05364224f, 0.04770395f, 0.03392094f, -0.08201021f, 
    -0.06919298f, 0.07890454f, -0.05944282f, 0.06165729f, -0.09167189f, -0.05157446f, 0.05800970f, -0.05847669f, 
    0.01685033f, 0.08417006f, -0.00562824f, -0.00154543f, -0.05502067f, -0.06257332f, -0.06653012f, -0.05064362f, 
    0.03069424f, 0.06273982f, 0.00436030f, -0.01520623f, 0.07259842f, 0.01148118f, -0.03529532f, 0.00207826f, 
    -0.36610481f, -0.07224324f, 0.10054223f, -0.17097540f, 0.08486161f, -0.05289739f, -0.15632942f, -0.14219260f, 
    -0.24902253f, -0.13359213f, -0.06304473f, 0.00994110f, 0.25114724f, -0.32559723f, 0.23881669f, 0.14332059f, 
    -0.46928877f, -0.32503441f, -0.20021325f, -0.48736751f, -0.33413690f, -0.17657577f, 0.01413402f, -0.06030146f, 
    0.02951593f, -0.35901928f, -0.53598642f, 0.27624276f, 0.39312115f, -0.07817160f, -0.12867777f, -0.55222958f, 
    0.10299199f, 0.10255899f, -0.37584305f, -0.13738048f, 0.12473559f, -0.34143075f, -0.17916927f, 0.33551061f, 
    -0.22501729f, 0.41562507f, -0.01959077f, 0.20398425f, -0.09929132f, -0.02889810f, 0.22594589f, 0.00473032f, 
    -0.29607257f, 0.06682589f, -0.04272519f, -0.20042267f, -0.49397096f, -0.55765128f, 0.06820490f, 0.18253644f, 
    -0.12454616f, -0.01005589f, 0.07587917f, 0.11153030f, 0.09395068f, 0.19883546f, -0.26488268f, 0.19170944f, 
    -0.25976706f, 0.00748423f, -0.24673517f, 0.12037963f, -0.40447703f, 0.11919140f, 0.04622846f, -0.48835328f, 
    0.08441599f, 0.04771276f, -0.05032187f, -0.06788649f, -0.10025592f, -0.42554218f, -0.32219210f, -0.49135277f, 
    -0.06757584f, -0.24458031f, -0.59802771f, 0.20704670f, -0.08986647f, -0.21820301f, 0.14481887f, 0.15109065f, 
    0.08232657f, 0.14096718f, 0.35689211f, 0.23278730f, 0.07233089f, 0.27444583f, -0.01476672f, 0.15345244f, 
    -0.25174677f, 0.45332965f, 0.09225669f, 0.04950263f, -0.11522863f, -0.74372375f, 0.29292855f, 0.05007450f, 
    -0.19072184f, 0.36473584f, -0.03704332f, -0.21402974f, -0.20497100f, -0.24155372f, 0.25399986f, -0.03575470f, 
    0.36273411f, -0.01904412f, -0.03578041f, -0.47702295f, 0.19325282f, -0.15950207f, -0.09987883f, -0.05523995f, 
    0.03888934f, -0.28619072f, 0.08357729f, -0.32215640f, 0.00215402f, -0.07346413f, 0.07786645f, 0.01507492f, 
    -0.76262230f, 0.01088857f, -0.02183428f, -0.06780855f, 0.22367048f, 0.14634618f, 0.04743697f, -0.03827643f, 
    -0.00690931f, -0.00847412f, -0.04305412f, -0.11870002f, 0.12006213f, 0.09663755f, 0.14249317f, -0.06018436f, 
    0.25353661f, -0.02847124f, 0.29707000f, 0.13604426f, -0.02761145f, 0.29500440f, -0.10853580f, 0.45253435f, 
    -0.08886608f, 0.14795323f, -0.63024008f, -0.20542377f, -0.00974823f, 0.27864179f, 0.29959071f, 0.18313402f, 
    -0.19370025f, 0.06382027f, -0.13040926f, -0.20729928f, 0.06264524f, -0.00957451f, 0.00967206f, -0.08864044f, 
    0.02268299f, -0.41315255f, 0.16642654f, 0.17066102f, 0.40107343f, -0.07481026f, 0.03240246f, 0.15952112f, 
    -0.08242911f, 0.26004195f, 0.10369986f, -0.15851274f, 0.15636536f, 0.20231383f, 0.42338312f, 0.07684486f, 
    -0.24234039f, 0.25438190f, -0.26275757f, -0.04141683f, -0.08234473f, 0.05983463f, 0.21128991f, 0.04874178f, 
    0.19167957f, -0.10581136f, 0.00912668f, 0.15626323f, -0.30259115f, -0.10218893f, 0.07496715f, -0.29054451f, 
    0.28773969f, 0.13915688f, -0.26532578f, 0.35436934f, 0.27800664f, 0.09207664f, 0.00418618f, -0.09989814f, 
    -0.21699075f, 0.65930742f, 0.05817655f, -0.18488927f, 0.40760556f, -0.07820221f, -0.47892764f, 0.13113728f, 
    0.03607314f, 0.04822958f, -0.24609983f, -0.18081363f, -0.35920316f, 0.06805531f, -0.02736672f, 0.03519246f, 
    0.44142857f, -0.33595300f, -0.16922714f, 0.06415264f, -0.17479880f, 0.21409072f, -0.25447500f, 0.24390623f, 
    0.11716402f, 0.09930968f, 0.01069531f, 0.36607614f, 0.02428176f, 0.27866498f, 0.08018730f, 0.09463177f, 
    0.61226392f, 0.01287642f, 0.17360722f, 0.23197222f, 0.05758037f, -0.44053701f, -0.09007905f, 0.14782795f, 
    -0.09218527f, 0.08409207f, -0.10784763f, -0.13856569f, -0.12356904f, 0.31653991f, 0.13342540f, -0.16187584f, 
    0.14134867f, 0.23528345f, 0.32591674f, -0.25830862f, -0.02606207f, 0.10178207f, -0.05761530f, 0.11820624f, 
    -0.02653644f, 0.09463231f, 0.10746450f, 0.00096663f, -0.22675188f, 0.02030487f, 0.16227381f, -0.13725865f, 
    0.02136724f, 0.20793417f, -0.01557269f, 0.04094985f, 0.24242394f, -0.68231887f, -0.03532150f, -0.09388316f, 
    -0.00980642f, 0.07658055f, 0.26928964f, -0.17400686f, -0.25774622f, 0.07367347f, -0.04207551f, 0.33578166f, 
    -0.26974294f, 0.08954231f, 0.14320478f, 0.00778561f, -0.20157400f, 0.08366208f, -0.23180722f, 0.12928335f, 
    0.18246721f, -0.22713846f, 0.14488816f, -0.35181192f, -0.33561617f, 0.24655077f, -0.20133741f, 0.10785005f, 
    0.17328697f, 0.27453628f, 0.06649480f, -0.19858438f, 0.13215651f, 0.01993112f, -0.09513588f, -0.22332154f, 
    0.01846500f, -0.06710121f, 0.03635240f, -0.15716718f, 0.20087478f, -0.24408990f, -0.08209556f, 0.01987545f, 
    -0.07932313f, 0.06336354f, 0.03303914f, -0.03571922f, 0.36944264f, 0.00436654f, -0.03583214f, 0.21385221f, 
    -0.19373482f, -0.03524750f, -0.25086626f, 0.09632339f, 0.09213594f, 0.08615061f, 0.16359344f, -0.09772336f, 
    -0.43718424f, -0.24842466f, 0.38094789f, 0.03590725f, -0.03020384f, -0.34910923f, 0.17673478f, 0.16562994f, 
    -0.10139021f, -0.18010202f, 0.20053171f, -0.17075929f, 0.18969719f, -0.47148645f, 0.02561006f, 0.17390078f, 
    -0.28298005f, -0.10503214f, 0.32198691f, 0.06827874f, 0.21673207f, 0.15152529f, -0.47416160f, -0.25081533f, 
    -0.08639718f, -0.11894618f, 0.08104839f, -0.04416624f, 0.12284262f, -0.13460433f, 0.01624535f, 0.09470486f, 
    -0.08658309f, -0.10267642f, -0.05918651f, 0.31987903f, 0.04815086f, -0.04845589f, -0.02226700f, -0.34721944f, 
    0.18924993f, 0.17067772f, -0.30854806f, -0.06409883f, 0.00000079f, -0.05637898f, 0.00275638f, -0.16178079f, 
    0.28003940f, 0.02241934f, 0.01853920f, -0.09621386f, 0.17446132f, -0.02189532f, 0.00832152f, -0.06430603f, 
    -0.15047553f, -0.14676061f, 0.05336103f, -0.20077355f, 0.08164321f, 0.12220412f, -0.13542560f, 0.08154941f, 
    0.27299553f, -0.44630536f, -0.26561469f, 0.00306097f, 0.35829434f, -0.09085532f, -0.10085212f, 0.09656802f, 
    0.00933157f, 0.15074435f, 0.05678601f, -0.26699531f, -0.31205350f, 0.11618056f, 0.11296851f, -0.01993125f, 
    -0.19156165f, -0.03379245f, 0.17696463f, -0.08728788f, -0.17164001f, 0.03655212f, -0.02278284f, 0.11545213f, 
    0.12359559f, -0.63033277f, -0.07439129f, 0.02824185f, -0.31596884f, 0.26740775f, -0.07376414f, 0.24112643f, 
    0.00758090f, 0.28917232f, 0.01757533f, 0.24308951f, -0.42815050f, 0.02970684f, 0.23942018f, 0.14224201f, 
    0.14428581f, 0.01258322f, 0.01610137f, 0.01513705f, 0.02017028f, 0.11368044f, -0.08893766f, -0.02969270f, 
    -0.21859506f, -0.06157902f, 0.14432634f, 0.16918252f, -0.33624488f, -0.03268860f, 0.04336404f, 0.45487887f, 
    -0.02721487f, 0.31343660f, 0.06455383f, 0.14834622f, -0.10932547f, -0.06013061f, 0.12773813f, -0.37277472f, 
    0.17238653f, 0.32098013f, -0.07014304f, -0.01883467f, 0.18523401f, 0.22305611f, -0.01128587f, 0.12720422f, 
    -0.16393226f, 0.09863488f, -0.00029571f, -0.30962825f, -0.24559818f, -0.02675199f, -0.03360962f, -0.04834618f, 
    -0.12378650f, -0.08544546f, 0.04060815f, 0.25590155f, -0.12680617f, -0.04826065f, -0.14451702f, 0.20075749f, 
    0.07294162f, -0.28422868f, 0.00965338f, 0.05621522f, 0.04404813f, 0.08611149f, -0.03826289f, 0.10273588f, 
    0.22942667f, 0.02474476f, 0.33765572f, -0.03536721f, 0.03923161f, 0.08953635f, -0.09121986f, -0.01203091f, 
    -0.18737377f, 0.06237577f, -0.11407311f, -0.13864024f, -0.18170738f, -0.08267893f, 0.00583897f, -0.00879088f, 
    -0.01506407f, -0.06814962f, 0.00105287f, 0.01293534f, -0.09217007f, -0.02638401f, -0.06123909f, -0.10579729f, 
    -0.10081615f, 0.07049803f, 0.02806386f, -0.09248213f, 0.00246007f, 0.04969171f, -0.09555802f, -0.07183229f, 
    -0.07402056f, -0.03907213f, -0.09626621f, -0.02206377f, 0.03070534f, -0.03438773f, -0.08107756f, -0.03756233f, 
    0.00196689f, 0.02714758f, 0.05018201f, 0.02943442f, -0.05467395f, 0.03834838f, 0.06574056f, 0.03488727f, 
    0.04136848f, -0.07162350f, 0.01885801f, -0.05882729f, -0.01393630f, -0.07345010f, -0.05589634f, -0.03207320f, 
    -0.11989901f, -0.06504549f, 0.02382929f, -0.00107590f, -0.04887269f, -0.10547090f, -0.10599003f, -0.10752840f, 
    -0.00205682f, -0.03355265f, 0.00168469f, 0.05145288f, 0.01650431f, -0.07780819f, 0.00665659f, 0.03035444f, 
    0.00566713f, 0.03997533f, -0.03973848f, 0.00929032f, -0.01978069f, -0.02960541f, -0.00833389f, -0.00003682f, 
    -0.07326249f, 0.00637428f, -0.01485363f, -0.01061166f, 0.07587300f, -0.03261507f, -0.04822729f, 0.00126711f, 
    -0.10448527f, 0.14158341f, 0.02001736f, 0.04012194f, -0.09534454f, 0.04884785f, -0.05604566f, 0.05443058f, 
    0.05098476f, -0.05082407f, -0.00788943f, -0.06912802f, -0.03281512f, -0.07496300f, -0.06702863f, -0.09626587f, 
    -0.02133556f, -0.08547860f, 0.00432422f, 0.05523499f, 0.01799865f, 0.03760385f, -0.02900985f, -0.02875061f, 
    -0.00944768f, 0.01052817f, -0.04893050f, -0.00355907f, -0.03128232f, -0.01188215f, 0.04123151f, 0.03272203f, 
    -0.12060655f, -0.09014644f, 0.03676951f, 0.04051254f, -0.09833145f, -0.05429412f, -0.02237036f, 0.02785732f, 
    -0.03046635f, 0.04831200f, -0.04525292f, -0.02886405f, 0.04551614f, -0.00247795f, -0.04234937f, 0.05189876f, 
    -0.07662831f, 0.02831450f, 0.06927001f, 0.09826710f, -0.10502414f, -0.04890501f, 0.03039090f, 0.02597481f, 
    0.05982818f, -0.05362381f, -0.04501098f, 0.02554751f, -0.03864472f, -0.08077441f, -0.00051498f, 0.01816806f, 
    0.00779475f, -0.08047804f, 0.04320830f, 0.00091968f, 0.01730526f, 0.06348015f, 0.05096724f, -0.05799837f, 
    -0.03295643f, 0.09290994f, 0.01933870f, -0.08117876f, 0.02507779f, -0.06020061f, -0.04603818f, -0.05722868f, 
    -0.06267653f, -0.05243083f, -0.08323526f, 0.02461335f, -0.05139969f, -0.05284358f, -0.08183556f, 0.00497415f, 
    -0.02505454f, 0.05303665f, -0.00088929f, 0.03394371f, -0.06391194f, -0.01195471f, 0.04174793f, 0.03794929f, 
    -0.06009573f, -0.04730149f, -0.05585468f, -0.08301011f, -0.00829620f, -0.05228722f, -0.10032845f, -0.07889319f, 
    0.01332601f, -0.00534247f, 0.05960405f, 0.03057700f, -0.12210457f, -0.04749874f, -0.01672870f, 0.06344619f, 
    0.04122696f, -0.01467622f, 0.04527353f, -0.07589492f, -0.02273994f, 0.05955130f, -0.08842590f, -0.07273269f, 
    -0.00649099f, -0.00614507f, -0.05846591f, -0.00090464f, -0.10123963f, 0.01796868f, 0.03166989f, 0.01682106f, 
    0.01731841f, 0.05623107f, -0.02163294f, -0.08436078f, 0.04376056f, -0.02035176f, -0.03856657f, 0.01615462f, 
    0.05318211f, -0.04920695f, 0.00872291f, 0.03946184f, -0.00192816f, -0.06724049f, -0.11146263f, -0.04070976f, 
    0.01659132f, -0.03806532f, 0.00167668f, 0.00354899f, -0.10669084f, 0.06237552f, -0.04976670f, 0.06510759f, 
    -0.05701106f, 0.02119345f, 0.03489802f, 0.05159556f, -0.02174610f, 0.03792194f, -0.04352638f, -0.10207945f, 
    -0.00512337f, -0.08978331f, -0.07812464f, 0.03793196f, -0.04799939f, 0.02425967f, 0.04915900f, -0.02823279f, 
    -0.04807814f, 0.03393238f, 0.02858050f, -0.03274063f, -0.04088560f, -0.06846291f, -0.03183820f, -0.09131006f, 
    0.06422497f, -0.06592339f, -0.05601410f, 0.03036224f, -0.03762934f, 0.04813489f, -0.01793904f, -0.09373124f, 
    0.55329186f, 0.28180072f, -0.09252888f, -0.06392178f, 0.00070851f, 0.11489858f, 0.02657424f, -0.22591573f, 
    0.19402336f, 0.24198604f, -0.07357217f, -0.05929821f, -0.41581431f, 0.25660527f, 0.02046204f, -0.26415277f, 
    0.45196790f, 0.07908740f, 0.26871771f, 0.14491911f, -0.27586547f, -0.81571001f, 0.11727547f, 0.13397677f, 
    -0.05462255f, -0.07380837f, 0.10435788f, -0.14535169f, -0.55266935f, 0.48851219f, 0.15409710f, 0.51834494f, 
    -0.05612142f, 0.16928367f, -0.36563966f, -0.16030121f, -0.06892636f, -0.01062133f, -0.17945783f, 0.09710605f, 
    0.22303016f, -0.77484268f, 0.58283693f, -0.06255284f, -0.52907246f, 0.13338625f, 0.02135973f, -0.09476031f, 
    0.26946056f, -0.72446519f, 0.04235912f, 0.19569190f, 0.24095121f, 0.11606258f, -0.02614232f, -0.12454285f, 
    -0.18764009f, 0.06981383f, -0.24480715f, -0.37432417f, -0.09848976f, -0.06003832f, 0.18886003f, 0.11557724f, 
    0.19919755f, -0.13056137f, 0.10616951f, -0.30170685f, 0.36058939f, -0.50846058f, 0.05929593f, 0.41754946f, 
    -0.17592534f, 0.14676057f, -0.00331542f, -0.00574893f, 0.02010721f, 0.31824389f, 0.36207294f, -0.04186258f, 
    -0.67042816f, -0.08477719f, 0.47608376f, 0.16877143f, -0.12352505f, -0.05532940f, 0.05689795f, -0.25407505f, 
    0.10984156f, -0.35079807f, -0.51876521f, -0.39236787f, 0.01864211f, -0.53696322f, -0.02702387f, 0.03350755f, 
    0.27272201f, -0.67708945f, -0.06925419f, -0.06287447f, 0.34867820f, 0.14572401f, -0.74007899f, -0.17098996f, 
    -0.18173124f, 0.11313015f, 0.01112205f, 0.12045638f, 0.22281006f, 0.19445421f, -0.08448897f, 0.40155324f, 
    0.82381368f, 0.08580497f, 0.12608647f, 0.23706561f, -0.37285554f, 0.83149570f, -0.52686822f, 0.03678952f, 
    -0.04095459f, 0.27880743f, -0.46389595f, -0.06825855f, 0.08789305f, 0.16011563f, -0.07390391f, 0.01361171f, 
    0.06509385f, 0.00507194f, -0.00820596f, 0.19384876f, 0.11040224f, -0.02074057f, 0.22914700f, 0.07333821f, 
    -0.02739470f, -0.05546103f, 0.07381500f, 0.02235361f, 0.04186440f, -0.27807796f, -0.11306012f, 0.01725295f, 
    -0.27292898f, -0.51324207f, 0.18338853f, -0.19447751f, -0.03610027f, -0.15638453f, 0.11879779f, -0.01105074f, 
    0.02041375f, -0.02719300f, 0.51019061f, 0.05856117f, -0.09645675f, 0.18826781f, 0.07993621f, -0.15025733f, 
    -0.07957893f, -0.01833273f, -0.08153006f, -0.00873888f, 0.07844911f, -0.00120226f, 0.00654545f, 0.07054538f, 
    0.00278703f, 0.15114167f, -0.02373531f, 0.00484323f, 0.21903867f, -0.00363625f, -0.02242204f, -0.08033991f, 
    -0.23653233f, -0.26391894f, -0.07785577f, 0.13240145f, 0.25388241f, -0.22096467f, -0.00584865f, -0.13776717f, 
    0.23512478f, -0.07983673f, 0.02265307f, 0.01228247f, 0.14160493f, 0.07034154f, 0.04198082f, 0.20948553f, 
    0.15370969f, -0.01683404f, -0.09208521f, 0.00430922f, 0.15928060f, 0.23124157f, 0.00830164f, 0.19671226f, 
    0.16545624f, 0.01571509f, 0.21802460f, -0.05334223f, 0.06260622f, -0.02420968f, -0.03315856f, -0.22670591f, 
    -0.10146002f, -0.07305694f, -0.37998644f, 0.22782348f, 0.00133656f, -0.03187039f, 0.08209750f, -0.05347875f, 
    0.19474939f, 0.09095485f, -0.04394713f, 0.43012601f, 0.18500155f, 0.07462800f, 0.02471490f, 0.23662521f, 
    0.03502870f, -0.06903028f, -0.06918804f, 0.07137329f, 0.05670822f, -0.06826334f, 0.18525909f, 0.08445962f, 
    0.06756474f, -0.02557057f, -0.02011296f, -0.16240127f, 0.08422682f, -0.17138492f, 0.00603124f, 0.08299814f, 
    -0.10663938f, -0.07734765f, 0.10848493f, -0.04153038f, -0.02421021f, -0.07668304f, 0.34417304f, 0.11452272f, 
    0.23086922f, 0.09767132f, 0.02061130f, -0.22302578f, 0.02041871f, -0.16369188f, -0.04292094f, 0.32480901f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.07311191f, -0.10335649f, -0.09242395f, 0.14021732f, -0.02591146f, 0.16779010f, 0.12236362f, -0.08589792f, 
    -0.09067617f, -0.11041131f, -0.09716038f, 0.01875154f, -0.09476061f, 0.07947834f, 0.23150638f, -0.06148103f, 
    0.41363633f, 0.03651532f, -0.01698186f, 0.27594197f, 0.03403311f, 0.13398916f, 0.00788204f, 0.02913397f, 
    0.11329804f, -0.05514331f, 0.33299533f, -0.10251173f, -0.06175959f, 0.06004073f, -0.02963982f, -0.08471218f, 
    0.05262554f, -0.08007509f, -0.03670022f, -0.08496618f, 0.10885482f, 0.15803142f, 0.01771067f, -0.03444516f, 
    0.19549091f, 0.08009867f, 0.12854098f, 0.01876252f, -0.08080404f, 0.01647871f, -0.15125377f, 0.30757979f, 
    -0.08782694f, -0.07915621f, 0.21595922f, -0.04618344f, 0.04724852f, 0.13473384f, -0.02467794f, 0.21004869f, 
    -0.01540050f, -0.07962085f, 0.02448775f, 0.09430764f, 0.10689324f, 0.11774430f, 0.03444343f, 0.20276137f, 
    -0.04040346f, 0.07483156f, 0.16849557f, 0.10183945f, 0.02060146f, 0.03074354f, -0.10891548f, -0.05995518f, 
    -0.03090284f, 0.03216043f, 0.20200436f, 0.13735877f, 0.13518022f, 0.06005791f, -0.05646782f, 0.23203075f, 
    -0.04000068f, 0.09690664f, 0.28267708f, -0.08362121f, -0.04976770f, -0.19277945f, 0.21113685f, 0.04043580f, 
    0.14982226f, 0.32685459f, 0.16504608f, -0.09047815f, -0.01577855f, -0.10449936f, -0.04235382f, 0.16409233f, 
    -0.04862813f, 0.15227088f, 0.26795289f, -0.04332287f, 0.14659940f, -0.08853301f, 0.04459910f, 0.05278223f, 
    -0.06028907f, -0.14825830f, -0.23419675f, -0.02442042f, 0.24510695f, 0.05466830f, 0.06122624f, -0.04103873f, 
    0.16641256f, -0.10439678f, -0.08621779f, 0.22770165f, -0.06521040f, 0.04381840f, -0.09493428f, -0.05933978f, 
    -0.04739979f, 0.20071687f, -0.08867361f, 0.03480313f, 0.04937956f, -0.00284285f, -0.00379735f, 0.06816659f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.02672904f, -0.36214948f, -0.05214857f, 0.25039408f, 0.01642364f, 0.00242265f, 0.01971288f, -0.01943584f, 
    -0.00447464f, 0.00430419f, 0.03907184f, -0.05367244f, 0.01046589f, 0.03101780f, -0.23791476f, 0.06453397f, 
    0.50398433f, -0.10424810f, -0.05392240f, 0.00423881f, -0.05421111f, -0.87459356f, 0.04406539f, 0.04272510f, 
    -0.47914937f, 0.03620625f, 0.11458708f, 0.05696564f, -0.01986725f, -0.34911555f, 0.04295889f, 0.29101980f, 
    0.02050022f, -0.00896938f, -0.02655808f, 0.08166210f, -0.18704920f, 0.09484193f, -0.02061852f, -0.54911125f, 
    0.13060562f, 0.01316214f, 0.03633411f, 0.07862642f, 0.02068799f, -0.03988432f, -0.12307423f, 0.13031888f, 
    -0.02902987f, -0.20101984f, -0.28564745f, -0.09772824f, 0.00008667f, -0.09281744f, -0.64953899f, 0.31372139f, 
    0.00672823f, 0.05001199f, -0.36681777f, 0.24120235f, 0.20835149f, -0.06641525f, 0.05780593f, 0.06019680f, 
    0.03920364f, 0.03759468f, 0.09501607f, -0.06567100f, -0.20652562f, 0.13228399f, -0.09880461f, -0.51077425f, 
    -0.02921619f, -0.01549205f, 0.10703044f, 0.17618762f, 0.30753520f, -0.15588507f, -0.01604415f, 0.18516907f, 
    0.02592745f, 0.02308377f, -0.66142273f, -0.02103511f, -0.12855472f, -0.15234461f, 0.07067452f, 0.01960946f, 
    0.11297596f, 0.14171505f, -0.01080413f, -0.11182618f, -0.06085586f, 0.03825062f, -0.05645388f, 0.04578896f, 
    -0.07646526f, 0.02617309f, 0.08880297f, 0.00821054f, 0.18850809f, 0.15975481f, 0.04427968f, 0.01526782f, 
    0.01524935f, -0.20715268f, -0.83647937f, -0.00940775f, 0.17836168f, 0.00014593f, -0.06395654f, -0.04068251f, 
    0.11444649f, 0.09432089f, -0.11976714f, -0.00599202f, -0.05083364f, 0.02975267f, 0.21757831f, -0.06107034f, 
    -0.30316460f, -0.17294239f, -0.02552857f, 0.07575476f, -0.02301570f, 0.03284180f, -0.86978960f, 0.13160282f, 
    0.08843394f, 0.32054093f, 0.01631932f, -0.33701131f, 0.05982348f, -0.00510629f, 0.05485637f, 0.02588940f, 
    -0.03177191f, -0.00367149f, -0.01904783f, 0.00292295f, -0.02100923f, 0.10346613f, 0.05910067f, -0.10020192f, 
    0.04724751f, -0.68376333f, 0.05552756f, 0.14612868f, 0.05637047f, -0.26297876f, -0.15336677f, -0.06665231f, 
    0.31771711f, 0.02978398f, 0.28553262f, -0.04607249f, 0.02740283f, -0.02062416f, 0.04556968f, -0.20710853f, 
    0.06129178f, -0.01282752f, -0.08763165f, 0.03491293f, -0.10264372f, 0.03707541f, -0.01065607f, 0.14739943f, 
    -0.10918997f, 0.01616802f, 0.09212029f, -0.41127303f, -0.10923122f, -0.07009807f, -0.18189047f, 0.13173828f, 
    -0.06689528f, -0.50055933f, -0.12713681f, 0.34663707f, 0.01985916f, 0.05439509f, 0.26217398f, 0.25056556f, 
    -0.00929246f, -0.03025557f, -0.14761817f, -0.33139157f, 0.04881679f, 0.14461996f, 0.16613409f, -0.04040658f, 
    0.02070932f, -0.04109737f, 0.00268591f, 0.07366926f, -0.79288465f, 0.04345014f, -0.06082565f, -0.22499472f, 
    -0.03027482f, -0.00843308f, 0.26613852f, -0.52910501f, 0.03907207f, 0.14463322f, 0.02774698f, -0.37725854f, 
    -0.02932568f, 0.11837437f, 0.08781678f, -0.05586342f, -0.01551869f, 0.00862553f, 0.09451732f, 0.06289702f, 
    0.06331322f, -0.37455940f, -0.14707366f, 0.00244949f, -0.01742240f, -0.09083811f, -0.04413024f, -0.09123220f, 
    -0.04751983f, 0.09465316f, 0.09615754f, -0.00744550f, 0.06041368f, -0.32351029f, -0.02104253f, -0.36987025f, 
    -0.07465307f, -0.15440035f, 0.45403776f, -0.00427445f, 0.15733518f, -0.04973965f, 0.02802817f, 0.06500291f, 
    -0.15671864f, -0.15638977f, 0.00246079f, 0.09411116f, 0.07444510f, 0.05183725f, -0.38775066f, -0.06071053f, 
    -0.27070943f, 0.17417455f, 0.30323824f, 0.25383350f, -0.07242600f, 0.07251006f, 0.29694358f, -0.13481329f, 
    0.07960196f, -0.18372364f, -0.01799533f, -0.15997933f, -0.02903957f, 0.06756383f, 0.08544438f, -0.01132479f, 
    -0.03330621f, 0.02288063f, -0.00912903f, 0.06974903f, 0.06284816f, -0.09576795f, 0.33176202f, -0.04735549f, 
    0.01745623f, 0.52897978f, -0.06153011f, -0.16240847f, 0.07687089f, -0.34866631f, -0.46932107f, -0.05489022f, 
    -0.10805900f, 0.01594241f, -0.28527334f, 0.01826481f, -0.01779088f, -0.30085084f, -0.01518992f, 0.08154656f, 
    -0.05221416f, -0.01793880f, 0.04579990f, -0.07159664f, -0.63003552f, 0.12681343f, 0.05807677f, 0.04952059f, 
    -0.22145842f, 0.04258775f, 0.23330322f, -0.00619109f, 0.03639888f, -0.08375707f, -0.66631436f, 0.01989102f, 
    0.02014288f, 0.11214764f, -0.15423457f, -0.33984607f, 0.05401887f, -0.36300907f, -0.08162843f, 0.17890640f, 
    -0.02656481f, 0.01919914f, 0.37407362f, 0.25570604f, 0.17700435f, 0.12181253f, -0.08894631f, -0.46284160f, 
    -0.11915562f, 0.14012004f, 0.12903579f, 0.13134572f, 0.19567779f, -0.25420970f, -0.01909451f, 0.22283842f, 
    -0.04925442f, 0.03975861f, 0.18123414f, -0.24896169f, -0.21686883f, -0.19570316f, -0.07266419f, 0.06700177f, 
    0.05354517f, 0.22578683f, -0.02541137f, 0.02209144f, -0.64953125f, -0.30720076f, 0.15933706f, 0.03307086f, 
    -0.16694863f, -0.26498723f, -0.42733309f, 0.04139455f, -0.60114163f, 0.03589395f, -0.08678296f, -0.26094446f, 
    -0.00244886f, 0.35982969f, -0.25144482f, 0.03289531f, -0.06097598f, -0.26317891f, -0.01838009f, -0.30887917f, 
    -0.05218628f, -0.00897284f, -0.68370336f, 0.01198514f, -0.00930056f, 0.04962434f, 0.01452016f, 0.01439008f, 
    -0.52946848f, 0.15938406f, 0.01038621f, -0.49884611f, -0.06950530f, 0.03445275f, 0.11881351f, 0.02011644f, 
    0.24464585f, -0.34233773f, 0.14069535f, -0.25085771f, -0.01041249f, 0.04912159f, 0.00431392f, -0.39629376f, 
    -0.28008446f, 0.02210279f, -0.06005045f, 0.04956796f, 0.08733793f, -0.55012637f, -0.78633219f, -0.11105554f, 
    0.01461183f, -0.04564642f, 0.01140004f, -0.01475853f, -0.04487957f, 0.09343836f, 0.30208588f, 0.02352698f, 
    0.05095193f, 0.18231443f, 0.13825831f, -0.24431990f, -0.75699729f, 0.14586571f, 0.13662247f, 0.05681610f, 
    -0.39049202f, -0.01717626f, 0.25796607f, -0.08209454f, -0.01456040f, 0.12505914f, -0.01302671f, -0.31193635f, 
    -0.06067900f, 0.07247648f, 0.00680933f, 0.02869274f, 0.06739412f, -0.71756661f, 0.01863657f, 0.13772824f, 
    -0.10612866f, 0.28184858f, -0.04171649f, -0.06955142f, 0.04500117f, 0.00839332f, 0.12591456f, -0.17309129f, 
    -0.04843352f, 0.07323683f, 0.10909518f, 0.11313890f, -0.04282763f, -0.75826293f, -0.06300844f, 0.21670724f, 
    -0.08375186f, -0.05424918f, 0.00971237f, 0.01626389f, -0.36752945f, 0.05029125f, -0.73666984f, -0.29176921f, 
    -0.47628623f, -0.11245824f, -0.40470541f, 0.15503898f, 0.12849092f, 0.10456046f, -0.05649612f, 0.06529992f, 
    0.02654597f, 0.02034725f, 0.02973437f, 0.12035924f, -0.66283268f, -0.03723252f, -0.05542959f, 0.06976410f, 
    0.10318521f, 0.05397485f, -0.38553569f, -0.06314012f, 0.14506154f, -0.38901782f, -0.09374204f, 0.03982679f, 
    -0.03625217f, 0.29162771f, -0.03918178f, 0.04590142f, -0.17230336f, -0.06285381f, -0.07644691f, -0.00765123f, 
    0.05475583f, 0.02375833f, 0.09665370f, -0.05432688f, -0.36083367f, 0.22717538f, 0.07826213f, 0.16286772f, 
    0.00496836f, 0.04164712f, 0.06386560f, -0.01501928f, -0.46857336f, -0.07886779f, 0.02972512f, 0.01441237f, 
    0.20008048f, -0.09755281f, 0.00717463f, 0.01208040f, 0.00532641f, 0.03480877f, 0.00905332f, 0.04916218f, 
    0.19287010f, -0.48847461f, -0.30134293f, 0.22482625f, 0.03259588f, -0.06705899f, -0.38492867f, 0.05316987f, 
    -0.00092167f, -0.70853287f, 0.06713086f, 0.08472537f, -0.03346137f, 0.13302663f, -0.03149686f, -0.00348494f, 
    -0.00933872f, -0.05352227f, 0.01885089f, 0.04641600f, 0.00967347f, 0.10555054f, -0.19258459f, 0.02973930f, 
    -0.16627848f, 0.03454948f, 0.00278978f, 0.04481845f, -0.04930446f, 0.40972459f, 0.07324447f, -0.05301867f, 
    0.10589384f, 0.04297513f, -0.12084740f, -0.09033448f, -0.04892235f, 0.10817511f, -0.01374192f, -0.39946312f, 
    -0.06943812f, -0.06220413f, -0.08856202f, 0.02160047f, 0.00450448f, -0.11204951f, -0.02367064f, -0.05215307f, 
    -0.08799158f, 0.07375940f, 0.05546743f, 0.00517110f, -0.02694333f, 0.04531147f, -0.03334023f, 0.08471054f, 
    0.04628746f, 0.10623521f, 0.12736094f, -0.45471019f, -0.08120584f, -0.08697875f, 0.89452082f, -0.11536404f, 
    -0.02673102f, 0.03781383f, 0.08844844f, 0.17848749f, 0.14585735f, 0.07114574f, -0.29522803f, 0.16085705f, 
    0.15713567f, 0.11512906f, 0.06789346f, 0.00935896f, 0.06598090f, 0.12188038f, 0.02617791f, -0.13970309f, 
    -0.00254686f, 0.07924996f, -0.05255288f, -0.01070184f, -0.46516886f, -0.27168864f, 0.05666118f, 0.16011775f, 
    -0.04518798f, 0.24079131f, 0.14401169f, 0.05819565f, 0.22074220f, -0.16073202f, 0.04550784f, -0.02191846f, 
    -0.03081212f, 0.22877407f, 0.08155368f, -0.06599931f, -0.15056328f, -0.06883069f, 0.02988121f, 0.19809912f, 
    -0.06111780f, -0.03448715f, 0.07568704f, 0.00622263f, 0.08521686f, -0.42850623f, 0.04721262f, 0.19500306f, 
    -0.01616703f, -0.08584779f, -0.33375031f, 0.01727825f, -0.45339221f, 0.02368663f, 0.02637422f, -0.07108244f, 
    0.22781685f, -0.53965056f, -0.07680037f, 0.05795617f, -0.10096073f, -0.00716600f, -0.95987117f, -0.09302515f, 
    0.20372716f, -0.13813186f, 0.20765582f, -0.06224139f, 0.02551541f, -0.03655078f, -0.05758294f, 0.19203065f, 
    0.09051485f, 0.44350004f, -0.00421228f, 0.08226693f, -0.03052753f, -0.12165092f, 0.07829681f, 0.01344930f, 
    -0.01730689f, 0.04141362f, 0.04998968f, 0.03196323f, -0.07505295f, 0.05803451f, -0.05460267f, -0.03402686f, 
    -0.60481983f, 0.09776151f, -0.58451420f, 0.08438684f, 0.11327317f, 0.17795821f, -0.13320972f, 0.02510196f, 
    -0.06353220f, -0.05642599f, -0.28163925f, -0.06294020f, -0.02977464f, 0.01685096f, 0.08050945f, 0.11682738f, 
    -0.06258228f, -0.03237662f, -0.01475317f, 0.00471684f, -0.00301131f, 0.16045706f, 0.03716669f, -0.14668569f, 
    0.06398809f, -0.42127505f, -0.29940850f, -0.55091757f, -0.00399037f, -0.07682113f, 0.25233784f, 0.09750103f, 
    0.05577268f, -0.46288162f, 0.12115095f, -0.24035838f, 0.06497190f, 0.01901889f, -0.52322847f, -0.18917720f, 
    -0.01819468f, 0.03243846f, -0.01977722f, -0.51285809f, 0.02321168f, -0.21584792f, 0.28191614f, 0.27228415f, 
    0.15639536f, -0.04623487f, -0.27320698f, 0.03412304f, -0.28717363f, -0.09353993f, -0.07299656f, 0.23611479f, 
    0.09091231f, 0.07970749f, -0.15368615f, -0.04831173f, 0.30340782f, 0.18731330f, 0.01389539f, 0.02303360f, 
    -0.09607614f, -0.26233873f, 0.19681996f, -0.04413470f, 0.17992386f, -0.22475712f, 0.08520082f, -0.00397495f, 
    0.08697918f, 0.46105644f, 0.07244963f, -0.07469461f, 0.19674332f, 0.03648330f, -0.01230537f, 0.01561336f, 
    0.04300489f, -0.20782873f, 0.01469748f, 0.02335180f, 0.03798268f, -0.31027552f, -0.04382002f, -0.57620752f, 
    -0.03478190f, 0.42737341f, -0.01156817f, -0.09155804f, 0.13858375f, -0.04286835f, -0.07831241f, -0.04001863f, 
    -0.39127398f, -0.12209050f, -0.09708929f, 0.00626441f, -0.02817274f, -0.01677049f, 0.50738376f, 0.00515563f, 
    -0.59854883f, 0.24682583f, -0.44234812f, 0.10193515f, -0.05819879f, -0.05149377f, 0.29690409f, -0.04894372f, 
    -0.18545987f, -0.28733832f, -0.03491644f, -0.55805564f, 0.04093959f, 0.05657354f, 0.17624161f, 0.02357573f, 
    -0.04170621f, -0.00361473f, -0.03831068f, -0.04097387f, -0.03819285f, 0.07515378f, 0.02509565f, -0.05944754f, 
    0.21440110f, -0.63174778f, 0.36935738f, 0.13999026f, -0.05370075f, -0.07057457f, 0.09713422f, 0.03400298f, 
    -0.13964920f, -0.09756509f, -0.08294779f, -0.04163106f, -0.04093146f, 0.11533995f, 0.01808653f, 0.31506428f, 
    -0.07030092f, -0.02815258f, -0.06857389f, -0.04858939f, -0.15340832f, -0.15984589f, -0.12385690f, -0.21500520f, 
    -0.06821913f, 0.29094011f, -0.54866630f, -0.21524753f, -0.08754891f, 0.00382385f, -0.65203065f, 0.15199411f, 
    0.04660919f, 0.16931725f, 0.01625555f, -0.40396625f, -0.01727252f, 0.05334003f, 0.68147355f, -0.07298893f, 
    0.02165554f, -0.01305947f, 0.11538307f, 0.02782315f, 0.12943208f, -0.20683764f, 0.16222872f, 0.15690632f, 
    0.03549028f, 0.12927827f, -0.54985183f, -0.00397484f, 0.08803237f, 0.01841146f, 0.03590290f, 0.00983594f, 
    0.07681088f, -0.00662608f, 0.00081170f, 0.00647833f, -0.05565282f, 0.07633952f, -0.04659686f, 0.10742304f, 
    -0.04717716f, 0.13178085f, -0.18786986f, -0.01870330f, -0.65166777f, 0.30870163f, 0.20947108f, 0.01737791f, 
    -0.51821351f, -0.81069386f, -0.03819809f, -0.04706414f, -0.04612984f, -0.08865499f, -0.03080530f, -0.00000294f, 
    0.05768024f, -0.13048896f, -0.13497743f, -0.06162700f, -0.25669330f, 0.16340931f, 0.06995738f, 0.12155201f, 
    -0.01910505f, -0.67123628f, -0.38683537f, 0.05543991f, -0.07258376f, -0.04219826f, 0.03015837f, -0.07013155f, 
    0.09901664f, 0.57581812f, -0.01709129f, 0.01982904f, -0.01016004f, 0.05389341f, 0.23712495f, -0.04604360f, 
    -0.70233202f, 0.22498313f, -0.30096373f, 0.13845757f, -0.00257119f, -0.06648862f, -0.59233207f, -0.09931840f, 
    -0.20352979f, 0.22937779f, 0.03608394f, 0.17032775f, -0.03327321f, -0.17964040f, -0.11613696f, -0.13092373f, 
    -0.00161907f, 0.02322486f, -0.00625128f, -0.02604816f, 0.01123824f, 0.03278663f, -0.64026880f, 0.03159497f, 
    -0.68394893f, -0.05623072f, -0.05681015f, -0.49281204f, -0.02816921f, 0.02267677f, 0.02484045f, 0.05525524f, 
    -0.05997703f, -0.06251930f, -0.17778142f, -0.01481696f, -0.03183321f, -0.00688190f, -0.06098879f, -0.39558521f, 
    0.05338082f, -0.02849823f, 0.01038353f, -0.00699151f, -0.06593407f, -0.17470177f, 0.03733791f, -0.05506058f, 
    -0.00119695f, -0.17984772f, 0.04842559f, 0.17780057f, -0.00024763f, 0.00655722f, 0.18263176f, -0.54319549f, 
    0.07998517f, 0.13398716f, -0.57767636f, 0.15916300f, -0.02568789f, 0.29022047f, 0.23115611f, 0.06122437f, 
    -0.08293870f, -0.07280398f, -0.41606948f, -0.46994299f, 0.00589329f, 0.10436282f, -0.44117486f, -0.14168470f, 
    0.22471625f, -0.40931171f, -0.06037290f, -0.37488845f, -0.00144247f, 0.07153324f, 0.04437906f, -0.12691812f, 
    0.02266385f, 0.00302512f, -0.72433209f, -0.45265239f, 0.10867710f, 0.00426217f, -0.09280790f, -0.54057264f, 
    0.03856820f, -0.32936922f, -0.17173643f, -0.02640432f, 0.11917756f, 0.35535708f, -0.71118969f, 0.02556869f, 
    0.10597304f, -0.43627661f, 0.07599651f, -0.03150905f, 0.19154914f, 0.06853005f, -0.04860444f, 0.04199232f, 
    -0.00192304f, 0.03496296f, -0.09455571f, -0.05542547f, 0.09891596f, 0.17070563f, 0.06738205f, -0.37109989f, 
    -0.06676501f, 0.15876463f, 0.30543461f, 0.03642802f, -0.28690189f, 0.02238397f, -0.01421334f, 0.06011203f, 
    -0.25861987f, 0.16293947f, -0.01736511f, 0.06916441f, -0.01248814f, -0.07238935f, 0.29645535f, -0.06450219f, 
    -0.14156543f, -0.34013155f, -0.12126166f, -0.04653820f, -0.05024512f, -0.03949657f, -0.15756333f, 0.15917149f, 
    0.14670764f, -0.42117065f, -0.03385952f, -0.19427826f, -0.00392715f, 0.11747091f, 0.09129967f, -0.11551479f, 
    0.01648322f, -0.00427869f, 0.05848804f, -0.04155073f, 0.05630368f, -0.44009736f, -0.33385527f, 0.01009764f, 
    0.22783755f, -0.06221230f, 0.08888543f, 0.10887028f, 0.14380202f, -0.31144610f, -0.42458355f, -0.02387978f, 
    0.19605538f, 0.02655714f, 0.39118424f, 0.05788236f, -0.08900126f, -0.26468581f, -0.05922616f, -0.04993999f, 
    -0.07522688f, -0.04936512f, -0.06066302f, 0.06579740f, 0.11460400f, -0.33412269f, -0.00162548f, 0.23230627f, 
    -0.16612810f, -0.12425181f, 0.17642936f, 0.30435514f, -0.04677056f, -0.14633276f, 0.12008378f, -0.15437748f, 
    -0.04681833f, -0.07303925f, -0.04441807f, -0.02082063f, -0.00002415f, 0.25888804f, -0.17547978f, -0.43484309f, 
    -0.07975015f, -0.07679304f, -0.39537770f, -0.12648867f, -0.19878866f, 0.01062213f, -0.33663341f, -0.64309716f, 
    0.12228669f, 0.05158503f, 0.22890203f, -0.39793053f, -0.08674794f, -0.50869960f, 0.05043205f, -0.25942343f, 
    0.05814636f, -0.01807732f, -0.08474456f, -0.10010023f, -0.10026412f, 0.25418338f, -0.03446623f, -0.49282905f, 
    0.04274522f, -0.09364142f, 0.22500488f, -0.05513109f, 0.04519795f, 0.27654880f, -0.66096747f, -0.00044010f, 
    -0.01984097f, -0.08088016f, -0.53033257f, -0.06316277f, 0.19904700f, -0.01464781f, 0.02100703f, -0.50233012f, 
    -0.08664373f, -0.43115187f, -0.24635690f, -0.04406116f, 0.22145350f, 0.38815072f, 0.09364160f, -0.02074573f, 
    -0.02504025f, -0.09638850f, -0.73130345f, 0.08347683f, 0.02403976f, -0.05212358f, 0.02705314f, -0.02606979f, 
    -0.26008502f, 0.03099479f, 0.04203604f, -0.40593898f, 0.07374366f, 0.04294756f, -0.18568346f, -0.00554341f, 
    0.30595902f, 0.06411832f, 0.15993726f, -0.18684724f, 0.00180175f, 0.03935285f, -0.08059372f, -0.03163640f, 
    -0.16671859f, 0.02054092f, 0.02672660f, 0.16596135f, 0.06449337f, -0.12614149f, -0.00960952f, -0.03098323f, 
    0.01330963f, -0.04260083f, 0.03894425f, -0.07471006f, 0.04608804f, -0.09548105f, -0.32223105f, 0.01790960f, 
    -0.13284306f, -0.17117962f, -0.29791626f, 0.10715985f, 0.14130668f, -0.69847572f, 0.10462023f, -0.06099600f, 
    -0.38384622f, 0.01194835f, -0.64544165f, -0.11623487f, 0.00388019f, -0.05736256f, -0.08749750f, 0.17031983f, 
    0.07944540f, -0.02243197f, -0.00835497f, -0.02405515f, 0.04154979f, 0.24142037f, 0.02754847f, -0.00341618f, 
    -0.20495573f, -0.55787218f, -0.52625340f, 0.18976255f, -0.09724197f, -0.07625587f, 0.14856316f, 0.00821934f, 
    -0.01616246f, -0.49955487f, 0.21353900f, -0.06159485f, -0.01074933f, 0.13826299f, -0.55645835f, -0.78700489f, 
    0.02942666f, -0.03125974f, 0.06189162f, 0.22831856f, 0.15737940f, -0.53846753f, 0.12054002f, 0.22972435f, 
    0.18037640f, 0.11898103f, -0.18006946f, 0.08816254f, 0.12473729f, -0.01397172f, 0.03181311f, 0.08026467f, 
    -0.00422912f, 0.05921805f, -0.39393526f, -0.00132239f, 0.19870259f, -0.38721901f, 0.03309767f, 0.16541457f, 
    0.05130047f, -0.31027141f, -0.50679380f, -0.07698417f, 0.01068479f, -0.04480900f, 0.09752156f, 0.06592461f, 
    -0.15354793f, -0.72412223f, 0.16326760f, -0.02223568f, -0.09557053f, -0.05144661f, 0.02423884f, -0.09199139f, 
    0.02609919f, -0.62453938f, -0.35621086f, -0.06524335f, -0.03931301f, 0.01836905f, 0.02837794f, 0.23905106f, 
    -0.09024587f, 0.24026635f, 0.06109630f, 0.06879471f, -0.04634902f, 0.04863586f, -0.03310080f, -0.01329402f, 
    0.18374145f, -0.64303237f, -0.00196801f, -0.19643949f, 0.04074170f, -0.02668687f, 0.06523764f, -0.07360296f, 
    0.23335207f, 0.10009510f, 0.10315255f, -0.28422460f, 0.02898224f, 0.01279504f, 0.47248963f, 0.00384753f, 
    0.13373475f, -0.05294053f, 0.04736473f, -0.11039815f, -0.03775032f, 0.14505310f, -0.13536632f, -0.01662934f, 
    -0.04033099f, -0.05950447f, 0.04119848f, -0.05081239f, 0.03174094f, 0.07655818f, 0.22427486f, -0.04661316f, 
    0.20456368f, 0.38168997f, -0.33357525f, 0.00083357f, 0.00069658f, -0.18143554f, 0.18683355f, 0.02413275f, 
    0.36675555f, -0.07373877f, 0.25755784f, -0.04490287f, 0.02151719f, 0.02417184f, -0.06908172f, 0.04709679f, 
    -0.01425627f, -0.05656678f, 0.01703233f, -0.07158672f, 0.12454212f, 0.19082025f, -0.01948835f, -0.16345392f, 
    0.20105909f, 0.22162329f, -0.11267725f, 0.20865589f, 0.03154579f, -0.00979249f, 0.09603073f, -0.11419793f, 
    -0.07055540f, 0.17105868f, -0.03817466f, 0.14503027f, 0.04488305f, -0.31454408f, -0.16465338f, -0.11948173f, 
    0.06033194f, 0.04575613f, -0.05534160f, 0.10140584f, -0.70007873f, 0.20773937f, -0.30362788f, -0.91258317f, 
    -0.36226770f, -0.03580950f, -0.02600648f, -0.25534481f, -0.02960905f, 0.01465980f, 0.04277318f, -0.28201354f, 
    0.02959041f, -0.08270048f, 0.18919677f, -0.12134532f, -0.75194228f, -0.02772778f, -0.04078015f, -0.34524322f, 
    0.08444797f, -0.06724486f, 0.42673334f, 0.00937221f, -0.06055274f, -0.40707108f, -0.19840527f, 0.05296437f, 
    -0.12471780f, 0.21060173f, 0.08082023f, -0.01954306f, -0.30971292f, -0.06093852f, 0.07150925f, 0.19534533f, 
    -0.07350922f, 0.17100540f, 0.03430701f, 0.01903667f, 0.00087977f, -0.47205973f, -0.02344129f, 0.07229491f, 
    0.01904199f, -0.17812434f, -0.06951410f, 0.04596733f, 0.22291461f, -0.08243215f, -0.03061701f, -0.02685241f, 
    0.10062521f, 0.41023681f, -0.05644137f, 0.18394366f, 0.07221768f, -0.04621588f, -0.31017017f, -0.01965791f, 
    -0.14831275f, -0.10384017f, -0.07717191f, -0.19443022f, 0.00337478f, -0.01021283f, -0.62854868f, -0.01670546f, 
    -0.54419631f, -0.02933778f, -0.05779347f, -0.18087807f, -0.06106461f, 0.21105970f, -0.10740207f, -0.12095552f, 
    0.02884887f, -0.06696054f, -0.02754570f, 0.06117727f, 0.03766057f, -0.02259130f, 0.12029461f, -0.00597168f, 
    -0.33869377f, -0.22650354f, 0.32753992f, 0.05827227f, -0.03694570f, -0.31753868f, -0.17678900f, -0.04922257f, 
    -0.00432983f, -0.07536452f, -0.02297674f, -0.07112282f, 0.04669682f, 0.03538359f, 0.07647503f, -0.10789455f, 
    -0.05328764f, -0.04914807f, -0.02606444f, -0.03586482f, 0.13195515f, 0.03381155f, 0.05490493f, 0.13055509f, 
    0.22073856f, 0.11489939f, 0.17102014f, 0.08870058f, -0.09223825f, -0.01884634f, -0.23449183f, 0.06671049f, 
    -0.03844051f, 0.20995893f, 0.14918944f, -0.21409312f, -0.05093120f, -0.06448194f, -0.07258637f, -0.10726544f, 
    -0.01564043f, -0.06167542f, 0.24290635f, -0.16480100f, -0.50704420f, -0.16038677f, -0.27958184f, 0.12995663f, 
    -0.28077748f, -0.03639835f, 0.25445184f, 0.13343143f, 0.13973990f, -0.38285086f, -0.02385912f, 0.24650182f, 
    -0.00923096f, 0.00016680f, 0.10657787f, 0.15814681f, -0.06535181f, 0.15710525f, -0.06490225f, -0.02637585f, 
    -0.06779263f, -0.03487280f, -0.20581438f, 0.04873568f, -0.26570669f, 0.33341128f, -0.13326626f, -0.02938535f, 
    0.25454646f, -0.07631917f, 0.08359260f, -0.04312225f, -0.26772463f, -0.08179282f, 0.07069096f, -0.01629948f, 
    0.01273225f, -0.06469341f, -0.01965623f, -0.04996560f, -0.01926798f, 0.02465267f, -0.07072361f, -0.05476153f, 
    0.07575957f, 0.08274786f, -0.19928487f, -0.04994985f, -0.43508878f, -0.07456782f, 0.06409082f, 0.03368554f, 
    -0.03187453f, -0.22438519f, -0.04292151f, -0.18490396f, -0.02585397f, -0.05028447f, 0.26819038f, -0.04097977f, 
    0.06856818f, 0.10399016f, -0.30839452f, 0.10290927f, -0.08877328f, -0.05168054f, -0.77919924f, -0.17024371f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.20902707f, 0.02179124f, -0.17165644f, 0.02405074f, 0.08089975f, 0.05712847f, -0.03316222f, -0.44420177f, 
    -0.01071885f, -0.11425764f, 0.14364673f, 0.00137892f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
