#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.72986478f, -0.00631522f, 0.96011901f, -0.50950325f, -0.50785249f, -0.22961007f, 0.40107408f, 0.10583977f, 
    -0.13381396f, -0.14475347f, 0.20276617f, -0.34993568f, 0.37885317f, 0.34963423f, 0.05637744f, -0.48933181f, 
    -0.15345894f, 0.30901518f, -0.06025203f, 0.29973948f, 0.13274398f, -0.09384093f, 0.09878834f, -0.13952112f, 
    -0.37723410f, 0.38286427f, -0.07707564f, 0.61597419f, -0.97160333f, -0.00817487f, -0.45868585f, 0.08312366f, 
    0.39549917f, -0.40858197f, -0.08195132f, 0.61469984f, -0.31477877f, 0.85016227f, 0.31477749f, -0.85001975f, 
    0.20870028f, -0.22981350f, 0.10349291f, -0.05953930f, 0.19104871f, 0.16779085f, -0.10917253f, 0.22796446f, 
    -0.35068819f, 0.37319434f, 0.15356088f, 0.01742728f, 0.32623959f, -0.28684658f, -0.36538002f, -0.29470721f, 
    0.26942226f, -0.38620770f, -0.80891627f, -0.54411542f, -0.04860276f, -0.00933856f, 0.52670419f, -0.50957620f, 
    -0.90327787f, 0.08827925f, 0.55144072f, 0.24837144f, 0.12214223f, -0.13629721f, -0.48172292f, 0.49167827f, 
    -0.90000457f, -0.90883219f, 0.30723539f, 1.07412386f, 0.08611016f, -0.37951574f, 0.18891725f, -0.16114146f, 
    -0.09381430f, -0.59610337f, -0.35132438f, -0.20894247f, 0.00195944f, -0.05627873f, -0.43664622f, -0.13860874f, 
    -0.29694381f, -0.54838687f, -0.14959884f, -0.60033065f, 0.21461397f, -0.14139915f, 0.23141921f, -0.69207954f, 
    -0.23890954f, -0.02177170f, 0.36405024f, 0.16829675f, 0.11802374f, 0.32538056f, -0.34162492f, -0.44617337f, 
    -0.35306975f, 0.42510802f, 0.20566489f, 0.16843773f, 0.33199888f, 0.74132866f, -0.69165397f, -0.23706298f, 
    0.51575327f, -0.57891756f, 0.32765532f, 0.01063621f, -0.10743365f, -0.86380672f, 0.71941108f, 0.03020658f, 
    0.47925359f, -0.25174382f, 0.07434452f, -0.11614075f, 0.32874933f, -0.47248372f, -0.74565428f, 0.75958771f, 
    0.17181861f, -0.68250519f, 0.48103270f, 0.22188936f, -0.04751501f, 0.05476688f, -0.09562998f, -1.35066915f, 
    0.73507416f, 0.51818001f, 0.39265653f, 0.08809132f, -0.15949798f, -0.19795395f, 0.05296310f, -0.43559873f, 
    0.09289739f, 0.66835082f, 0.02921567f, -0.77604842f, -0.74847156f, -0.63252419f, -0.22019288f, 0.44165584f, 
    0.01320838f, -0.66871631f, -0.41425666f, -0.66301000f, -0.27388287f, -0.05568825f, 0.63536394f, 0.07856306f, 
    -0.13030641f, -0.11423866f, 0.08255727f, -0.71846026f, -0.06298895f, 0.00958365f, 0.30839601f, 0.26515779f, 
    -0.12695540f, -0.10625378f, 0.14724517f, -0.11983959f, 0.27359048f, 0.21850227f, -0.71148890f, -0.68123901f, 
    0.66654986f, -0.25543317f, -0.18436317f, -0.36966190f, -0.27755734f, -0.36228254f, -0.65548933f, -0.69846255f, 
    -0.67936176f, -0.00310580f, 0.51978999f, -0.48205578f, 0.30277994f, -0.05490294f, 0.40304503f, -0.19923647f, 
    0.02877320f, 0.17713447f, -0.03893056f, 0.23047987f, 0.02324663f, 0.06009596f, 0.45408350f, -0.07876327f, 
    -0.82140195f, 0.29430291f, 0.23651677f, 0.54740942f, -0.27626806f, -0.15284513f, -0.43702897f, 0.16332085f, 
    -0.76799995f, -0.25562131f, -0.50701338f, -0.49983037f, -0.08713213f, -0.44225034f, -0.29549497f, -0.32524237f, 
    -0.47731259f, -0.61449969f, -0.48962045f, 0.31234455f, -0.12102333f, 0.47422844f, -0.43630192f, -0.08307683f, 
    -0.52595598f, -1.03346801f, -0.08062955f, 0.70554531f, 0.46917695f, 0.18119779f, -0.38204306f, -0.39913607f, 
    0.33818087f, -0.04825249f, -0.76721388f, -0.53050578f, -0.81755883f, 0.42245325f, 0.37481087f, -0.37914541f, 
    -0.18068187f, -0.35479137f, -0.51679897f, 0.46660972f, -1.27379048f, 0.60471898f, -0.39260799f, -0.51652223f, 
    0.32516846f, 0.19669598f, -0.07800862f, -0.44155538f, 0.66007411f, 0.32184762f, 0.36083603f, 0.13170497f, 
    -0.02479833f, -0.30107862f, -0.07051431f, 0.30308861f, -0.37448040f, 0.89658773f, -0.89238822f, 0.22563334f, 
    -0.27162719f, 0.02952510f, -0.02589202f, 0.14634575f, 0.18512736f, -0.19215026f, 0.13381796f, 0.08668023f, 
    -0.09434106f, -0.00495601f, 0.11750060f, -0.20459926f, -0.16510344f, 0.40707144f, -0.13383164f, 0.75354707f, 
    0.24133429f, 0.36544880f, -0.40633857f, -0.25123349f, -0.09083316f, 0.10797180f, -0.25160208f, -0.29513294f, 
    -0.40055677f, 0.11203719f, -0.39939561f, 0.11874689f, -0.24062109f, -0.35641545f, 0.37131861f, 0.29526290f, 
    0.33742744f, 0.07379442f, -0.04296982f, 0.09090532f, -0.43937406f, 0.18134798f, 0.56295955f, -0.35557520f, 
    0.54365104f, -0.38524449f, -0.66470128f, 0.49660507f, -0.18845572f, 0.15721890f, 0.15868832f, -0.12662525f, 
    0.06268989f, -0.07065419f, 0.02971247f, -0.82006311f, -0.32788378f, 0.51007307f, -0.00772017f, -0.83407992f, 
    0.77862090f, 0.05965345f, 0.29503992f, -0.03139321f, -0.77753776f, -0.75609678f, -0.64860541f, 0.65502852f, 
    0.46030590f, 0.05181076f, 0.40544942f, -0.00430743f, 0.04488955f, -0.20959754f, 0.37740567f, 0.02068408f, 
    0.20362161f, 0.19303785f, 0.22876392f, 0.07817374f, 0.24929795f, -0.30223849f, -0.37566924f, 0.57257855f, 
    -0.29587945f, -0.12196775f, 0.65107507f, -0.23181537f, -0.30485597f, -0.21074687f, 0.35494909f, 0.14024337f, 
    -0.28673899f, 0.27638575f, 0.12817888f, -0.01203207f, 0.15952860f, -0.10534719f, 0.37840453f, -0.42149401f, 
    0.43285498f, 0.23469032f, -0.62488866f, 0.28373966f, -0.44840157f, -0.41862583f, -0.50197297f, -0.27117082f, 
    -0.77534705f, 0.09639181f, 0.30342463f, 0.27402726f, -0.59182906f, 0.26057339f, -0.27801549f, 0.17793158f, 
    0.10648360f, 0.14773211f, 0.51355368f, -0.51264203f, -0.07094895f, -0.08208589f, -0.13488966f, -0.27184412f, 
    0.04729450f, 0.10888156f, 0.44294938f, -0.64024383f, 0.03441813f, 0.45344645f, -0.54609829f, 0.34582725f, 
    0.76874739f, -0.47346902f, -0.46491903f, 0.28182319f, -0.67896324f, -0.30603927f, 0.92971873f, -0.60146433f, 
    -0.59031534f, 0.86425418f, 0.24540481f, -0.16313271f, -0.35827991f, 0.82967508f, -0.69290233f, -0.85690260f, 
    -0.08095016f, 0.21647629f, -0.05295576f, 0.16056089f, 0.34869742f, 0.14422269f, -0.58505869f, -0.57611263f, 
    -0.43675280f, -0.12910636f, -0.38215184f, -0.64753562f, 0.20925172f, 0.51724613f, 0.09895348f, -0.35112327f, 
    -0.28666276f, -0.33201700f, 0.63908559f, -0.56702185f, -0.03002399f, -0.10465045f, -0.40754604f, 0.28980294f, 
    -0.33458692f, 0.42296615f, -0.05305855f, 0.04647730f, -0.26977584f, 0.42814508f, 0.47254452f, -0.11987076f, 
    -0.45971191f, 0.30087528f, -0.31669050f, 0.06609138f, -0.23882592f, -0.46079525f, 0.00352557f, 0.35739097f, 
    0.26827034f, 0.13409096f, 0.82156569f, -0.19355536f, -0.78203136f, 0.21014771f, 0.13625796f, 0.02101114f, 
    -0.02989971f, 0.28807402f, -0.23872654f, -0.81597036f, -0.47805572f, 0.51126838f, -0.42436817f, 0.46963143f, 
    0.47654319f, 0.00527102f, 0.07184910f, -0.16923498f, 0.46589452f, -0.17887002f, 0.03113294f, -0.31441057f, 
    0.71382874f, -0.41983521f, -0.14838529f, -0.06554248f, 0.11503240f, -0.48859778f, -0.11387288f, 0.12165236f, 
    -0.78707463f, -0.60143888f, -0.60970193f, -0.06070993f, -0.51998609f, -0.52816778f, -1.03777146f, 0.59859568f, 
    -0.78114492f, 0.06593917f, 0.67220742f, 0.58891636f, 0.21652457f, -0.25584128f, -0.32824937f, -0.74643457f, 
    0.78896773f, 0.04979914f, -0.12222789f, 0.08441334f, -0.34705052f, -0.32618821f, 0.36783329f, 0.26031217f, 
    0.48122030f, -0.18404731f, -0.37916023f, -0.51185417f, 0.05755772f, 0.35656372f, 0.16908647f, -0.00503544f, 
    -0.04629221f, -0.70396721f, -0.38531870f, 1.03498733f, -0.45766100f, -0.57501465f, -0.38257682f, 0.45307511f, 
    -0.58714998f, -0.21419312f, 0.60126942f, 0.17435305f, -0.39883763f, -0.17636788f, -0.20078960f, -0.26735497f, 
    -0.51797581f, -0.10137949f, 0.68236262f, 0.38522890f, 0.13384585f, 0.15870817f, -0.20125304f, 0.13038480f, 
    -0.26472452f, 0.14633358f, -0.00586731f, -0.09805624f, 0.97830939f, -0.37474027f, -0.69985026f, -0.40838638f, 
    -0.00736703f, -0.70715183f, -0.41800988f, -0.35744348f, -0.43305132f, -0.05018580f, -0.40774590f, -0.04356444f, 
    -0.57129163f, -0.27462444f, -0.53609443f, 0.32849619f, -0.10805605f, 0.27878278f, 0.96169317f, -0.38409114f, 
    -0.37119097f, 0.52610362f, -0.35781285f, -0.02654532f, 0.22614937f, 0.13881283f, -0.36558837f, -0.11116011f, 
    -0.47522256f, 0.27979296f, -0.56105500f, 0.47586808f, -0.18909079f, 0.16430618f, -0.17584236f, 0.43679836f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04768370f, -0.03261992f, 0.16773282f, 0.11025368f, 0.06673295f, -0.04636731f, 0.07196397f, -0.26586142f, 
    -0.01019645f, -0.04648407f, -0.02895982f, -0.05816863f, 0.03801491f, -0.05527379f, 0.22838639f, -0.13985179f, 
    -0.00036448f, 0.12962627f, 0.06270391f, -0.09373932f, -0.25143582f, -0.34024122f, -0.25494626f, -0.30611831f, 
    -0.10303232f, -0.03109516f, -0.36045605f, 0.04356034f, -0.30891261f, -0.04981479f, -0.06470903f, 0.07950708f, 
    -0.21478496f, 0.04576441f, -0.13011223f, 0.02835917f, 0.24469903f, -0.17211165f, -0.07417390f, -0.30499038f, 
    -0.11677139f, -0.26616505f, -0.06664629f, -0.00479667f, -0.08116859f, 0.04730676f, -0.34402466f, 0.05576646f, 
    -0.13554154f, -0.13609932f, 0.12224126f, -0.01301062f, 0.16966504f, -0.31097114f, -0.14427763f, 0.01624280f, 
    0.16907158f, -0.05655450f, -0.09027536f, 0.26821613f, -0.20135656f, 0.17408994f, -0.01430186f, -0.06748340f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01813619f, 0.23251021f, 0.13929999f, -0.39100963f, -0.04411333f, -0.00687522f, 0.05029438f, -0.11372813f, 
    0.04944028f, 0.02081574f, 0.07675903f, -0.01003409f, -0.08152521f, -0.03531235f, -0.04907789f, -0.00668533f, 
    0.06953870f, 0.01049443f, 0.01575809f, -0.02717412f, -0.16181122f, -0.11383969f, -0.08751915f, 0.07566660f, 
    0.04378550f, 0.02670707f, 0.00250103f, 0.00568477f, -0.00229705f, 0.02723363f, 0.00488786f, -0.02647555f, 
    -0.05975618f, 0.04243356f, 0.01316645f, -0.00432802f, 0.06141806f, -0.03051780f, 0.02521685f, -0.03520193f, 
    -0.42686784f, -0.23150884f, -0.19126211f, -0.00097321f, -0.24039820f, 0.07022341f, -0.03643011f, -0.03148420f, 
    0.06637422f, 0.03668437f, -0.02328336f, 0.05941906f, 0.00081879f, -0.02860105f, -0.00810497f, -0.04496115f, 
    0.05057446f, -0.06409718f, -0.02492052f, -0.01753994f, -0.01054098f, 0.14976324f, 0.14156482f, 0.01771729f, 
    0.03284251f, -0.03093648f, -0.07357977f, 0.01399658f, -0.20855145f, -0.19679004f, -0.13984309f, -0.12233158f, 
    -0.01573397f, 0.02795884f, -0.05053344f, -0.01980212f, 0.00008357f, 0.01007235f, -0.11609679f, -0.10581020f, 
    -0.12227954f, -0.04786057f, 0.11908343f, 0.00472596f, -0.06904413f, -0.14008620f, -0.28167185f, -0.13993271f, 
    0.04334451f, 0.01415576f, -0.01399182f, 0.06574676f, -0.02103784f, -0.00457281f, -0.01793496f, -0.09110856f, 
    0.01204550f, -0.04912177f, -0.28915602f, -0.17263240f, -0.09649080f, -0.02540037f, 0.01906884f, 0.00065005f, 
    -0.01219469f, -0.01767042f, 0.05179208f, 0.01495260f, 0.03562372f, 0.00609562f, -0.03385198f, 0.04638853f, 
    0.05058181f, 0.02751244f, -0.07739302f, 0.07944606f, -0.11995757f, -0.06940906f, -0.07192905f, 0.03198032f, 
    0.18017298f, 0.20653650f, -0.04367970f, -0.32306549f, -0.11578491f, 0.02486194f, 0.06325071f, -0.03896601f, 
    0.00474402f, 0.05291922f, 0.04086732f, -0.07541241f, 0.01432608f, -0.03743647f, -0.03027738f, -0.00124906f, 
    -0.00803594f, 0.04141809f, 0.04483431f, -0.12111185f, 0.46730047f, 0.09269655f, -0.07983825f, -0.21191476f, 
    0.02023285f, 0.14285693f, 0.14724608f, 0.10262928f, -0.08004738f, -0.05228354f, -0.04352884f, 0.02897617f, 
    -0.01393967f, 0.00753976f, 0.03230635f, -0.02705966f, 0.09108452f, 0.11127292f, 0.01749751f, -0.01109324f, 
    0.45278847f, 0.08196890f, -0.00213774f, -0.36368924f, 0.00435599f, -0.03907963f, 0.11212681f, 0.04233156f, 
    -0.03694029f, 0.06066659f, 0.04717410f, -0.01848829f, -0.09915651f, 0.02361190f, 0.09223373f, -0.08778860f, 
    0.06137231f, 0.13039818f, -0.03315368f, 0.01079105f, 0.24530470f, 0.16652788f, 0.02761816f, -0.15396121f, 
    -0.04742619f, 0.09732345f, 0.11105765f, 0.06729322f, 0.00724575f, 0.04665290f, 0.00781985f, 0.01013161f, 
    -0.04920489f, -0.07720292f, -0.02401606f, -0.01422728f, -0.11314061f, -0.11512384f, -0.07099479f, 0.02011911f, 
    0.19024874f, 0.24095775f, -0.07571933f, -0.23668240f, -0.07467517f, 0.04459988f, -0.09220747f, 0.12812878f, 
    -0.13398077f, 0.06010997f, -0.01141507f, -0.01714023f, -0.00912159f, -0.03531386f, 0.05625403f, 0.01068741f, 
    -0.01006598f, -0.11011561f, 0.06742859f, -0.13084768f, 0.10652595f, 0.10554513f, 0.02324256f, -0.09183028f, 
    -0.01164980f, -0.09350975f, 0.02985342f, -0.17378953f, -0.00523773f, -0.07602596f, 0.01656650f, 0.03293754f, 
    0.04322900f, -0.01658928f, -0.09958099f, 0.00007346f, -0.00270538f, 0.00712725f, -0.13072379f, -0.16192746f, 
    -0.07068128f, -0.07657518f, -0.31989351f, 0.16369854f, -0.13766897f, -0.13895541f, 0.02007636f, -0.25165758f, 
    -0.01922641f, 0.11504441f, -0.07676257f, 0.05983373f, 0.01084213f, 0.01287550f, -0.04384899f, -0.12434989f, 
    -0.04172802f, -0.31484586f, -0.14800698f, -0.09267627f, -0.54474342f, 0.04510149f, -0.04968730f, -0.30783650f, 
    0.06223385f, -0.09767830f, -0.02780922f, 0.14422017f, 0.08949107f, 0.06281321f, -0.19330016f, 0.07677168f, 
    -0.05413246f, -0.21428533f, -0.12193290f, -0.09139119f, 0.03847066f, 0.01998314f, -0.18242775f, 0.04802319f, 
    -0.67855006f, -0.34904560f, 0.36423960f, 0.09049954f, -0.26834533f, -0.02158873f, -0.05810379f, -0.01790938f, 
    0.04748560f, 0.01822166f, -0.00462107f, 0.01651051f, -0.01068103f, -0.04509128f, -0.04853277f, -0.10651460f, 
    -0.00928051f, -0.01136718f, -0.17540912f, -0.03598041f, -0.16713490f, 0.23205286f, -0.25621447f, -0.35931486f, 
    0.10779697f, -0.13436620f, -0.01804030f, 0.11822426f, 0.13060009f, 0.06893207f, 0.03754794f, 0.07254232f, 
    -0.05621020f, -0.08850460f, -0.03642736f, 0.03500237f, 0.02521499f, 0.12510255f, -0.15428133f, 0.18663262f, 
    -0.05284137f, 0.15837938f, -0.15188120f, -0.23425275f, -0.22281353f, 0.05229253f, 0.03859672f, -0.15660672f, 
    0.09981114f, 0.05002454f, 0.02545935f, -0.00004338f, 0.01274180f, 0.05412419f, 0.02661575f, -0.02923361f, 
    0.00197711f, 0.02476089f, -0.10473850f, 0.03200388f, 0.20790564f, 0.05269685f, -0.02178867f, -0.19129662f, 
    -0.06558101f, 0.03251052f, 0.02840770f, 0.13613793f, 0.04029869f, -0.04302700f, -0.03054471f, -0.06574495f, 
    -0.04200521f, 0.03752488f, 0.05477744f, 0.07521577f, 0.01811397f, -0.03007416f, -0.03449255f, -0.03013997f, 
    -0.06103922f, -0.08547585f, -0.09556320f, 0.02437603f, 0.02757115f, 0.06150268f, 0.00756746f, 0.05639386f, 
    -0.03580037f, 0.04864711f, -0.07820790f, -0.01745015f, -0.10108241f, -0.04971255f, -0.04269847f, -0.01274952f, 
    0.03760805f, 0.04789915f, -0.04020433f, 0.00091390f, -0.28465343f, 0.32806912f, 0.36914796f, -0.13948061f, 
    0.01612104f, -0.37010986f, -0.27825159f, -0.26184526f, -0.04803091f, -0.12418742f, 0.02545598f, -0.04303097f, 
    -0.03287560f, 0.01159296f, 0.04424455f, 0.09837961f, 0.01452555f, 0.01460620f, -0.06622563f, -0.01488066f, 
    0.34124723f, 0.29861167f, 0.04440919f, -0.40903360f, -0.03506154f, 0.19054945f, 0.24524976f, 0.15524733f, 
    0.05630735f, -0.02247333f, -0.00986721f, -0.02722558f, 0.03998071f, -0.01913403f, -0.00611414f, -0.04870456f, 
    -0.00024321f, 0.05177929f, -0.03290451f, 0.14195554f, 0.01919207f, 0.03351496f, 0.02360268f, 0.04616848f, 
    0.04505143f, 0.03596989f, 0.02886555f, 0.04734892f, 0.03061424f, 0.03564790f, -0.27232245f, -0.17113252f, 
    -0.35885620f, 0.01199610f, -0.21820128f, -0.04813384f, 0.04110483f, -0.00750233f, -0.01201939f, 0.00146113f, 
    0.21808402f, -0.13057008f, -0.19514705f, 0.02630101f, -0.17794572f, -0.04374397f, 0.09696899f, 0.00322122f, 
    0.03353115f, 0.03689203f, 0.04093781f, 0.03897930f, -0.10307700f, 0.10870278f, -0.11892214f, 0.06856252f, 
    0.07976207f, 0.05101613f, 0.00962934f, -0.04609269f, 0.22774202f, 0.14332210f, 0.20906840f, -0.18524474f, 
    -0.02574166f, 0.16881898f, 0.18452673f, 0.20797609f, -0.03860687f, 0.00696079f, -0.01070326f, -0.03670299f, 
    -0.00922574f, -0.10831231f, -0.21617612f, -0.03141524f, -0.10064199f, -0.05262191f, 0.13470346f, 0.07041726f, 
    0.22911523f, 0.02423568f, 0.04697423f, -0.17837016f, -0.03919927f, -0.01084075f, 0.04207674f, 0.13646455f, 
    -0.06731685f, -0.00019344f, -0.03638790f, 0.00164248f, -0.01275245f, -0.01169347f, -0.11139091f, 0.06375359f, 
    -0.00401949f, 0.00298932f, -0.05369953f, -0.04189111f, 0.31358477f, 0.19637060f, -0.09904481f, -0.26485267f, 
    0.05843562f, -0.28336132f, 0.06039910f, 0.08507919f, 0.00229172f, -0.05306298f, -0.10267221f, -0.09355560f, 
    -0.03496972f, -0.12980880f, -0.02827851f, -0.09245262f, 0.09922098f, 0.06176781f, -0.07419794f, 0.01783034f, 
    0.30148402f, 0.07617363f, -0.15777196f, -0.14004092f, -0.08891256f, 0.09886950f, 0.10180596f, 0.18606302f, 
    -0.05129112f, 0.05837080f, -0.01799073f, 0.01614125f, -0.05829385f, 0.01491186f, 0.05621160f, -0.01711648f, 
    0.06004548f, -0.02042593f, -0.10004151f, 0.00347564f, 0.05238305f, 0.02583591f, 0.08181982f, -0.42344278f, 
    0.02457038f, 0.02394510f, -0.05307030f, 0.07959229f, -0.12348918f, 0.00476345f, -0.05195529f, 0.01904835f, 
    -0.07878850f, -0.01948442f, -0.05107028f, 0.05592850f, -0.06218351f, -0.02830235f, -0.09273364f, -0.00212468f, 
    -0.20625740f, -0.10973453f, -0.35709617f, -0.13863944f, -0.01111734f, 0.02321930f, -0.00664791f, 0.03447932f, 
    0.01026629f, 0.06749522f, 0.03356580f, 0.07652504f, 0.04210470f, 0.05542223f, 0.07257651f, 0.06272901f, 
    0.06262976f, -0.04104801f, -0.07430120f, 0.00100102f, -0.04985150f, 0.02997549f, -0.11221738f, -0.13645974f, 
    0.10662745f, -0.16625175f, -0.10891187f, -0.09350102f, -0.05596335f, 0.03346276f, -0.13060501f, 0.01676893f, 
    0.03508330f, 0.07131063f, -0.04903699f, 0.01482827f, -0.03997546f, -0.03392767f, -0.29090169f, 0.08528715f, 
    -0.06288725f, -0.01062949f, -0.11231422f, 0.03651557f, 0.03981339f, 0.01506524f, 0.00966095f, -0.03235075f, 
    0.07103173f, 0.03716443f, -0.03846188f, 0.03676994f, 0.02776879f, -0.00258425f, -0.01815643f, -0.15932772f, 
    -0.04631132f, -0.06343082f, -0.02958845f, 0.01916967f, -0.40084347f, 0.18653344f, -0.06390101f, -0.20808157f, 
    -0.05462238f, 0.00626024f, 0.00187965f, -0.08385839f, 0.02434503f, 0.08213741f, 0.00251655f, -0.01370910f, 
    0.02265519f, 0.06208775f, 0.02375146f, 0.14326826f, 0.00391597f, 0.02907597f, -0.02154769f, -0.08159547f, 
    0.29619893f, 0.20665245f, -0.02183019f, 0.06537655f, 0.06444582f, 0.07293008f, 0.12372158f, 0.08474994f, 
    -0.01524219f, 0.07040896f, 0.04899652f, -0.12417104f, 0.04590409f, 0.01789727f, 0.04313815f, -0.03209735f, 
    0.00240668f, 0.00498774f, -0.00034364f, -0.02070036f, -0.17934102f, -0.14785859f, 0.06421227f, 0.06853707f, 
    -0.05395021f, -0.00179016f, 0.02370405f, 0.05252351f, 0.04337469f, 0.01516936f, 0.06412726f, 0.11087697f, 
    -0.04848265f, -0.12014797f, -0.09130425f, 0.00739179f, -0.13039713f, 0.02090033f, -0.05483850f, 0.00321873f, 
    -0.07110073f, -0.01344759f, -0.04177637f, 0.02174943f, 0.06475224f, -0.01092562f, 0.03879360f, -0.01356619f, 
    0.04243352f, 0.00746972f, -0.07313687f, -0.06651933f, -0.13280815f, -0.01387348f, -0.00274299f, -0.02932280f, 
    0.02416847f, 0.05641958f, -0.07139263f, -0.06562550f, 0.10785320f, 0.12688638f, 0.33636805f, -0.30026442f, 
    0.06419959f, -0.02617864f, 0.08883642f, 0.06968550f, -0.08463447f, -0.11899856f, 0.01877711f, -0.13634667f, 
    -0.03722794f, -0.03701827f, -0.01124877f, -0.04842953f, -0.11518639f, -0.00216674f, -0.04788508f, -0.07302789f, 
    0.24647278f, 0.04090548f, -0.29286334f, 0.01989252f, 0.04116138f, 0.11267177f, 0.14032066f, 0.12089541f, 
    -0.13524422f, -0.05636946f, -0.07215610f, -0.09962908f, -0.13323393f, 0.02213934f, 0.04652344f, 0.00146862f, 
    0.06176151f, 0.02007199f, -0.00056198f, 0.01842049f, -0.05609730f, -0.03464842f, 0.01342631f, 0.03786965f, 
    0.01701581f, 0.02010998f, 0.01974436f, 0.02635787f, 0.01941321f, 0.06661425f, -0.17107539f, -0.12826312f, 
    -0.07471532f, -0.03770838f, -0.21864358f, 0.02939308f, -0.01324836f, 0.03903595f, -0.04213708f, 0.02429537f, 
    -0.35814315f, -0.07871622f, 0.06076415f, 0.04637124f, 0.06783060f, 0.05345511f, -0.03233296f, -0.01415933f, 
    0.03560278f, 0.01979314f, 0.02328275f, 0.00214204f, 0.08752577f, 0.00806084f, -0.06850347f, -0.13591971f, 
    -0.05765215f, 0.07227448f, -0.08190504f, -0.05505240f, -0.09024782f, -0.08985803f, -0.13476413f, 0.00809286f, 
    0.05798881f, 0.00916491f, 0.02711847f, 0.05255828f, 0.05339349f, 0.04456448f, 0.04252206f, 0.10295239f, 
    0.04326382f, -0.11471802f, 0.06269117f, -0.01000764f, -0.13368624f, 0.00234590f, -0.00216081f, 0.02425010f, 
    0.02470053f, 0.10306600f, 0.08215727f, -0.08397245f, -0.16862555f, -0.18694216f, -0.04719226f, -0.16448037f, 
    -0.09619225f, -0.01428973f, -0.03139958f, -0.01972865f, -0.03139732f, -0.00227073f, 0.03468528f, 0.06662286f, 
    -0.00146607f, 0.12178434f, 0.02651210f, 0.06604493f, -0.01574038f, 0.02094072f, 0.01679263f, 0.03020891f, 
    -0.02548745f, -0.10735906f, -0.06334244f, 0.08438148f, 0.08536787f, 0.05841254f, -0.01371155f, 0.10424837f, 
    0.05941945f, -0.03499054f, -0.06857155f, -0.04526869f, -0.02630040f, -0.07836410f, -0.07691914f, -0.07250167f, 
    0.11603696f, 0.09056419f, -0.01899426f, -0.00054443f, 0.01055944f, -0.07940375f, 0.05066100f, -0.06024460f, 
    0.02700356f, -0.00203652f, -0.03201494f, 0.09445510f, 0.01333916f, -0.00018302f, 0.01616677f, -0.02870192f, 
    -0.02884434f, -0.04334989f, -0.08597939f, 0.03951444f, -0.36473313f, -0.59532106f, 0.32968038f, -0.04486141f, 
    0.03371717f, -0.00860973f, -0.04013067f, -0.00132340f, 0.06773734f, 0.04956292f, -0.07729857f, 0.08381494f, 
    0.14227153f, -0.04018713f, -0.06905064f, -0.09785941f, -0.10141955f, 0.05228887f, -0.07682700f, -0.11319371f, 
    0.10644252f, 0.21703954f, 0.42457604f, -0.31305873f, 0.17084076f, -0.20729151f, 0.02888316f, -0.09471276f, 
    0.01472827f, -0.12520602f, -0.03460336f, -0.02131854f, -0.14874177f, 0.02320672f, -0.00066297f, 0.11460091f, 
    0.03483280f, -0.02997647f, -0.12089021f, 0.01993253f, 0.14846313f, 0.18374157f, -0.17558964f, 0.09298757f, 
    0.04127659f, 0.08142100f, 0.04869483f, 0.04009372f, 0.04097416f, -0.09013234f, -0.11905866f, 0.01785901f, 
    -0.03729341f, 0.04199730f, 0.00705219f, -0.01641617f, -0.04489089f, 0.00961473f, -0.02740994f, 0.03940564f, 
    0.35973355f, 0.35773826f, -0.10428941f, -0.27316090f, -0.11836512f, 0.16642126f, 0.06636312f, 0.15662766f, 
    -0.01771535f, -0.00557839f, 0.07950365f, -0.05470929f, 0.01995251f, 0.02154896f, 0.02442017f, 0.03250147f, 
    -0.02955841f, -0.03418235f, 0.00386813f, 0.03226312f, 0.18931916f, 0.12287717f, -0.03345995f, -0.20073308f, 
    -0.04100109f, -0.02127129f, 0.10759397f, 0.03186628f, -0.03175824f, -0.03110323f, -0.01437125f, -0.00691870f, 
    0.02867731f, -0.03997934f, -0.02660618f, -0.02857092f, -0.01278310f, 0.03248947f, -0.04547072f, -0.00943971f, 
    -0.25033858f, -0.18631004f, -0.00425128f, -0.04948625f, -0.07814489f, 0.01168295f, -0.01289058f, -0.00968207f, 
    0.05811266f, -0.03221000f, -0.00494402f, -0.02263309f, -0.06121476f, 0.04744869f, 0.05491275f, 0.10959888f, 
    0.04807436f, 0.03114488f, -0.19886097f, 0.11749820f, 0.13206509f, 0.12577213f, 0.03618469f, -0.09731721f, 
    0.02443078f, -0.08224757f, 0.07308927f, -0.01744656f, 0.06422800f, -0.02155659f, 0.07594697f, 0.20246525f, 
    0.01235646f, 0.03077708f, -0.00691655f, -0.01366565f, -0.00693746f, -0.00769153f, -0.06578596f, 0.02742258f, 
    -0.20276524f, -0.08515174f, -0.24315496f, 0.11452715f, 0.03986103f, 0.03165852f, -0.01552484f, -0.07463676f, 
    0.04127780f, 0.06064411f, -0.11156470f, -0.02806949f, -0.34862480f, -0.20014995f, -0.15821752f, -0.00940909f, 
    0.01175138f, 0.06180457f, 0.00268461f, -0.00358053f, 0.15091316f, -0.11696817f, 0.08529840f, -0.13950861f, 
    -0.01516600f, -0.00535570f, -0.03389960f, 0.16412751f, 0.03634807f, -0.06239034f, -0.13992634f, -0.00908097f, 
    -0.07941397f, 0.13642938f, -0.07918356f, 0.01051626f, 0.01641690f, 0.04905405f, -0.02483300f, -0.00958902f, 
    -0.43070635f, -0.42523101f, 0.03319216f, 0.00221893f, -0.15610926f, -0.05213933f, -0.06877912f, -0.00085908f, 
    -0.04225625f, 0.11234044f, -0.08302226f, 0.03299091f, 0.02029424f, 0.01661772f, -0.02280838f, -0.21048124f, 
    -0.02099084f, -0.13139683f, -0.21233702f, 0.07487425f, 0.17897351f, 0.23018524f, 0.17674726f, -0.27705765f, 
    0.02579767f, 0.08736538f, 0.15571997f, 0.02800649f, 0.01520104f, 0.05240153f, -0.00864044f, -0.01148323f, 
    0.00682930f, -0.02051704f, -0.06882480f, -0.11401270f, -0.09712761f, 0.02712224f, 0.02411841f, 0.08129222f, 
    -0.03232335f, -0.33071372f, -0.07743792f, 0.08417475f, 0.05583005f, 0.09259070f, 0.06427012f, -0.00794316f, 
    0.09420715f, -0.10938798f, 0.00109118f, -0.03895704f, 0.02486828f, 0.08869040f, 0.08479416f, 0.02166166f, 
    0.09033535f, 0.00586793f, -0.02349469f, -0.02857696f, 0.01517107f, -0.01575181f, -0.14452155f, 0.06577498f, 
    -0.16641167f, -0.05298036f, -0.15510820f, 0.00568767f, 0.01133976f, -0.09510163f, -0.02636612f, 0.02523706f, 
    0.01802768f, -0.07904953f, -0.05539443f, -0.09929394f, 0.02399000f, -0.00161140f, -0.14889148f, -0.14515106f, 
    0.03132299f, 0.15442124f, -0.12208975f, -0.07227004f, -0.16667773f, -0.01718878f, -0.22849426f, -0.16580668f, 
    0.01995722f, -0.06810413f, -0.10883991f, -0.09110433f, -0.18935895f, 0.06195453f, -0.08051196f, -0.03341044f, 
    -0.11802248f, 0.00273061f, -0.03688838f, -0.04103711f, 0.23033568f, 0.20961764f, 0.19177336f, -0.53417408f, 
    0.09849063f, 0.01264130f, 0.08756167f, -0.05896292f, 0.03251007f, 0.01141630f, 0.06311645f, -0.04042530f, 
    -0.06524535f, -0.01942568f, -0.01375047f, -0.06941121f, 0.04766611f, -0.02644574f, 0.08440788f, -0.03801530f, 
    -0.08509578f, -0.07286873f, 0.05452015f, 0.02201504f, -0.41455266f, 0.13032141f, -0.22252382f, -0.06901163f, 
    -0.09907256f, -0.11869905f, 0.06618638f, -0.04023643f, -0.01264285f, 0.08347958f, 0.07493012f, -0.05029867f, 
    -0.02722003f, -0.13639462f, -0.12188240f, -0.15844904f, -0.24581240f, -0.19746487f, -0.16126697f, -0.03539251f, 
    -0.01961305f, -0.00039157f, -0.01157045f, -0.02052940f, -0.01613065f, 0.00362151f, -0.01812805f, 0.02173173f, 
    -0.00101603f, 0.01872986f, 0.01728067f, 0.00482943f, -0.01945777f, -0.14360942f, -0.08135903f, 0.00677293f, 
    0.09170263f, 0.09032387f, 0.23956667f, -0.26940006f, -0.13023484f, 0.04738028f, -0.01090869f, -0.03473709f, 
    -0.08978958f, 0.06212841f, -0.08679803f, -0.02133514f, -0.02580016f, 0.00646117f, -0.01497697f, 0.04074388f, 
    0.01225635f, 0.16196632f, 0.15654278f, 0.25983572f, 0.16776398f, 0.25997922f, 0.07205098f, -0.35556301f, 
    -0.10044283f, -0.00368566f, 0.01629187f, 0.02395723f, -0.01674801f, -0.01174553f, 0.02566352f, 0.00668083f, 
    -0.02853275f, 0.01962957f, 0.00860020f, 0.01877290f, -0.05466612f, -0.02328149f, 0.03531458f, -0.07413215f, 
    -0.17887846f, -0.06507006f, -0.08270071f, 0.10334763f, 0.03765185f, -0.04181796f, 0.00137777f, -0.02529637f, 
    0.01541042f, 0.05844462f, -0.15561615f, 0.02924425f, 0.02069105f, -0.13778187f, 0.00445412f, -0.08314262f, 
    -0.08217113f, 0.02608189f, -0.03074239f, -0.02429636f, 0.06477153f, 0.21687289f, 0.07560401f, -0.13216126f, 
    0.03521245f, -0.05044221f, -0.09229221f, 0.15703076f, -0.10415033f, -0.05079321f, -0.10965337f, 0.01664030f, 
    -0.08501720f, 0.02841755f, 0.00837262f, -0.00165955f, -0.08801088f, -0.05808661f, -0.05259845f, -0.02860750f, 
    -0.32047695f, 0.01641697f, -0.06306915f, -0.18435138f, 0.16700774f, 0.09831391f, -0.11658860f, -0.17799729f, 
    0.24362598f, 0.02540631f, -0.03319820f, -0.02944571f, 0.11590602f, 0.00326155f, -0.03080976f, -0.02746483f, 
    -0.03596089f, 0.04228997f, -0.04032975f, -0.06926030f, 0.04962765f, -0.04722565f, 0.18718621f, 0.11099307f, 
    0.04858199f, 0.01694477f, -0.01784717f, 0.04157903f, 0.04576080f, -0.05644285f, 0.08494326f, -0.01138239f, 
    -0.04208994f, -0.12380223f, -0.03738468f, 0.09430154f, -0.00155256f, -0.15532534f, 0.04389155f, -0.06672538f, 
    0.21100235f, 0.04627359f, 0.10651561f, -0.02244577f, 0.10917331f, 0.00709219f, -0.00337534f, -0.03110146f, 
    -0.00676872f, -0.02872629f, 0.02301748f, 0.03823814f, 0.00889751f, 0.00185270f, 0.05501446f, -0.14667325f, 
    0.25930077f, -0.06724314f, 0.07925921f, -0.00498410f, 0.20466632f, 0.11559758f, -0.02146838f, 0.03941354f, 
    -0.26121309f, -0.15312336f, 0.32067919f, 0.14344341f, -0.26048246f, 0.15958603f, -0.05239994f, -0.27149245f, 
    0.13164464f, 0.00914362f, -0.04000499f, 0.00072674f, 0.13446292f, 0.07048074f, -0.00577897f, -0.02656939f, 
    0.26764190f, -0.08004319f, 0.11369455f, -0.20083642f, 0.11179385f, -0.06712014f, 0.11261924f, -0.21634705f, 
    -0.02315446f, 0.05324019f, -0.03965925f, -0.06312210f, 0.05219779f, 0.00940283f, 0.03950714f, -0.04189044f, 
    0.05208266f, -0.09653061f, 0.02849143f, 0.04594263f, 0.14375013f, 0.02751221f, 0.12365911f, 0.08777771f, 
    0.08151942f, -0.03714987f, 0.01462834f, -0.04592768f, -0.00756934f, -0.01391861f, -0.00386325f, -0.00871678f, 
    0.04436826f, 0.00198290f, -0.02472235f, -0.22938000f, 0.04255411f, 0.01632959f, -0.01443492f, 0.02919417f, 
    -0.22597273f, 0.12739202f, -0.16201662f, 0.21385890f, -0.05137111f, -0.01740247f, 0.01569934f, -0.05094857f, 
    0.00483350f, -0.03526545f, -0.05373462f, 0.01553985f, 0.03236669f, 0.03439325f, 0.06061243f, -0.05599356f, 
    0.02903729f, 0.05620944f, -0.17496398f, 0.11131819f, -0.04906673f, -0.15577929f, 0.29661670f, 0.03275659f, 
    0.04244713f, 0.06070644f, -0.01884408f, 0.20694865f, -0.02312495f, -0.25699604f, 0.13282366f, -0.23280419f, 
    0.03632622f, -0.15864749f, -0.12489638f, 0.08073743f, 0.01911617f, -0.01615225f, -0.06563480f, -0.04544332f, 
    0.55897528f, 0.08225478f, -0.07602719f, -0.24482213f, 0.04779344f, 0.08673319f, -0.18739465f, 0.11044787f, 
    0.19126150f, -0.10323878f, 0.11288872f, -0.07657108f, 0.02958222f, -0.17169213f, -0.20650274f, 0.07510348f, 
    -0.10036814f, -0.05384095f, -0.02162063f, -0.04630050f, 0.19467303f, 0.16294096f, 0.12253749f, 0.07301063f, 
    0.09075398f, 0.13460876f, 0.00966084f, -0.00477529f, 0.14328690f, 0.11116794f, 0.02060582f, -0.00632727f, 
    0.03004468f, 0.00737967f, 0.00756744f, -0.05180775f, -0.03955175f, 0.02447924f, -0.09098557f, 0.04163105f, 
    -0.02795588f, -0.01890489f, -0.04308110f, 0.10334229f, 0.03204308f, 0.05528741f, 0.08634853f, 0.08074310f, 
    0.10470732f, 0.06606330f, 0.04013657f, -0.07936782f, 0.08855333f, 0.01631257f, 0.00332186f, -0.07594938f, 
    0.02404717f, -0.01604631f, -0.20736596f, -0.07735398f, -0.06484016f, 0.01559104f, 0.02543615f, -0.07001578f, 
    0.01880877f, 0.10399948f, -0.00829968f, -0.14673658f, 0.10945768f, 0.00988417f, -0.02845172f, -0.08278839f, 
    0.04298179f, 0.16697979f, 0.06963442f, -0.02147960f, -0.04634156f, -0.04844658f, 0.13791069f, -0.08843423f, 
    -0.08128943f, -0.15487683f, 0.03478276f, -0.07102109f, -0.26874292f, -0.06158045f, -0.11638553f, -0.20995197f, 
    0.12012275f, -0.04946921f, 0.02002818f, 0.00998942f, -0.02857024f, 0.06784291f, -0.01112814f, 0.11635699f, 
    -0.03268229f, -0.00482706f, 0.13718419f, 0.04769609f, -0.20855653f, 0.10620276f, -0.01131280f, 0.12593016f, 
    0.00733338f, -0.00693079f, 0.07160871f, 0.03889318f, 0.05144616f, -0.04246018f, -0.05040674f, 0.04035696f, 
    0.03990678f, 0.10319278f, 0.08200222f, 0.06381460f, -0.07441225f, -0.01860956f, 0.07923736f, -0.18303552f, 
    0.00271019f, -0.49612322f, 0.14589930f, -0.05391096f, 0.17819446f, -0.03053631f, 0.01108650f, -0.01223764f, 
    -0.05706753f, 0.05936390f, 0.14722753f, 0.03769078f, 0.00302257f, -0.00080092f, 0.04344707f, 0.10709049f, 
    0.03678243f, -0.04455316f, 0.13957652f, 0.16084157f, -0.46967632f, -0.25083259f, -0.05667822f, 0.09620999f, 
    0.13308471f, 0.03229938f, -0.07504323f, -0.10168033f, 0.03461619f, -0.07755277f, 0.07010242f, 0.05098016f, 
    0.14091392f, 0.07548868f, 0.18379897f, -0.03773395f, -0.09252926f, -0.00447083f, 0.00936656f, -0.29558086f, 
    -0.06502426f, -0.06002815f, -0.28257155f, -0.15343066f, -0.34317067f, -0.05138788f, -0.11545311f, -0.29868823f, 
    0.05459299f, 0.01562723f, -0.09069096f, -0.05705614f, 0.07064144f, 0.03573685f, 0.01631712f, -0.01413884f, 
    0.06205515f, -0.11631712f, -0.02995141f, 0.01721691f, -0.16351600f, 0.09776414f, 0.01141256f, 0.04433597f, 
    -0.09917525f, -0.01468274f, -0.08626259f, 0.04998870f, -0.26369840f, 0.02126328f, -0.04342732f, 0.01796173f, 
    -0.01062453f, -0.07550920f, -0.03779348f, 0.05418762f, 0.04701008f, 0.01785641f, -0.02121827f, 0.05085727f, 
    0.18641955f, -0.14612962f, 0.01389968f, 0.01045905f, -0.08489355f, -0.04489644f, 0.04908304f, 0.05545880f, 
    -0.06665510f, 0.02667776f, 0.00189122f, -0.23044609f, 0.02703517f, -0.04069863f, -0.08253650f, -0.04742528f, 
    0.00000688f, -0.03200282f, -0.04862539f, -0.00439824f, -0.65884966f, -0.00386566f, 0.02908650f, -0.19010438f, 
    -0.18108316f, 0.09331420f, -0.05536914f, 0.06426141f, -0.05690573f, -0.09073362f, 0.00147657f, 0.00123124f, 
    0.00124421f, 0.01972913f, 0.00537826f, -0.06119575f, -0.05151588f, 0.00774570f, -0.03406921f, -0.19474679f, 
    -0.51103497f, 0.20071363f, -0.06766158f, 0.23932771f, 0.05563053f, 0.04275554f, -0.16416274f, 0.18378776f, 
    -0.49303275f, 0.02139768f, -0.01706145f, 0.01366272f, 0.04771171f, -0.01989404f, -0.01362823f, 0.01994095f, 
    0.03957346f, -0.02689047f, -0.35735303f, -0.07250774f, 0.03427636f, 0.02849098f, 0.02489062f, 0.05751247f, 
    0.06505839f, -0.05685256f, -0.00708404f, -0.02986562f, -0.02582902f, -0.03734602f, 0.14356007f, 0.07295305f, 
    0.04505549f, -0.00323644f, -0.07878168f, -0.10452849f, -0.09822883f, -0.11421388f, -0.02413053f, -0.01232100f, 
    0.58112580f, 0.28822961f, 0.07521031f, 0.11649496f, -0.60580927f, -0.03254040f, -0.08010604f, 0.03228735f, 
    -0.03206751f, -0.04981264f, 0.04200824f, -0.05435090f, -0.04866966f, -0.17255645f, -0.10113349f, 0.24180487f, 
    -0.10505593f, -0.10089345f, -0.00295791f, -0.08835664f, -0.06990649f, 0.36140031f, 0.06066700f, 0.11541121f, 
    0.11940055f, 0.10830639f, 0.07738230f, -0.06372573f, -0.10326836f, -0.02242603f, -0.01052471f, 0.01763166f, 
    0.02909982f, -0.09340154f, 0.07542940f, -0.03800699f, -0.02608297f, 0.07673247f, -0.27737394f, 0.04787440f, 
    -0.02981097f, 0.18147478f, 0.04087967f, -0.06352358f, -0.17976110f, -0.11182208f, -0.05128163f, 0.08444049f, 
    0.15071426f, -0.00695364f, -0.01827556f, -0.03385998f, -0.01799670f, -0.01903394f, 0.03484832f, 0.07919867f, 
    0.05493670f, -0.16628885f, -0.05537108f, 0.03227247f, -0.14540093f, -0.02633946f, 0.27038911f, 0.08947853f, 
    0.21357454f, -0.00670146f, 0.14306632f, 0.08785716f, 0.16723013f, -0.24916543f, 0.05298148f, -0.08338051f, 
    -0.09540501f, 0.22146384f, -0.01319990f, 0.02210215f, -0.03922615f, 0.00629249f, -0.06886682f, -0.18570024f, 
    0.48077527f, 0.20458572f, 0.31249207f, 0.04427044f, -0.15263787f, 0.13100137f, -0.17770331f, -0.01697846f, 
    0.26074517f, -0.01933556f, 0.08003981f, -0.03771603f, -0.01022818f, -0.21693379f, 0.02936449f, 0.05762136f, 
    -0.05687395f, -0.28023383f, 0.02906104f, 0.05826050f, -0.66913527f, 0.21812178f, -0.32237244f, -0.03360845f, 
    0.28277880f, -0.02755346f, 0.07354807f, -0.20095797f, 0.10946973f, 0.09904002f, -0.05616967f, 0.04294612f, 
    -0.02838088f, 0.02860040f, 0.03938479f, 0.01119080f, 0.05486575f, 0.00221947f, -0.22183776f, -0.04597029f, 
    0.35648614f, 0.16954099f, 0.08600760f, 0.14656596f, 0.20442791f, -0.01482932f, -0.02658951f, -0.04507606f, 
    -0.02907540f, -0.07806186f, -0.02008818f, 0.02102626f, -0.01984641f, -0.01729668f, 0.02517784f, 0.00460489f, 
    0.01193659f, -0.05601867f, 0.04651557f, -0.07655836f, 0.09507049f, 0.07133737f, -0.09084709f, -0.04060777f, 
    0.03054577f, -0.06980163f, 0.13909882f, -0.07587407f, -0.02702041f, 0.03720501f, -0.09955873f, -0.00072168f, 
    0.02271364f, 0.14263746f, -0.06573304f, -0.00450627f, -0.00873329f, 0.09840973f, 0.03297058f, -0.02225075f, 
    0.11995878f, 0.07101400f, 0.06434834f, 0.05469935f, 0.03118720f, 0.01340776f, -0.05553143f, -0.05663895f, 
    -0.00168682f, -0.07592098f, 0.02764078f, 0.03041620f, -0.02662074f, 0.01720847f, -0.00236690f, -0.11053297f, 
    0.10023585f, -0.04550189f, 0.04495125f, -0.01254900f, 0.53298903f, 0.22601481f, 0.08587284f, 0.15699099f, 
    0.20249736f, 0.00112261f, -0.08764192f, -0.04404201f, -0.08858600f, 0.02268094f, -0.01566305f, -0.00910232f, 
    0.01890284f, 0.05138711f, 0.00706999f, 0.00982221f, -0.03548589f, -0.05301383f, 0.04818341f, 0.00459502f, 
    -0.23743436f, -0.13709757f, -0.05120556f, 0.11198851f, -0.05035449f, 0.09074418f, 0.11977525f, 0.02958498f, 
    0.19186807f, -0.10384863f, -0.26017377f, 0.09086767f, -0.00781727f, 0.01486853f, -0.02496612f, -0.02045968f, 
    0.00218845f, -0.02262423f, -0.03030445f, 0.06669188f, 0.21219143f, -0.00450731f, 0.10594171f, 0.06357785f, 
    0.07390842f, -0.05262161f, 0.03743023f, 0.03336677f, -0.02918370f, -0.05373954f, 0.05461185f, 0.09059130f, 
    0.00842615f, 0.00397267f, -0.04315762f, -0.19336151f, -0.01301219f, -0.04348008f, 0.11676627f, 0.08920189f, 
    -0.06086239f, 0.02091411f, -0.03759025f, 0.06344225f, -0.01159697f, 0.02915445f, 0.01533293f, -0.05133748f, 
    0.02237694f, -0.06271593f, -0.15172906f, 0.04866924f, -0.10220768f, 0.09095594f, -0.05450467f, 0.03766295f, 
    -0.00887318f, -0.06806195f, 0.01201394f, -0.04788830f, -0.76499963f, -0.21970093f, -0.11528819f, -0.23695666f, 
    0.02340689f, -0.04075563f, 0.04487297f, 0.18891361f, 0.20995951f, 0.05581107f, -0.11394642f, 0.12418346f, 
    -0.09419204f, 0.05707645f, -0.05322929f, -0.06914892f, 0.15625095f, 0.09054783f, -0.08651740f, 0.08186004f, 
    0.23239322f, -0.15539597f, -0.26151219f, -0.12703072f, -0.15210512f, -0.02067072f, -0.01124815f, 0.07874388f, 
    0.05575077f, -0.13436444f, 0.03606873f, -0.09600969f, 0.03039637f, -0.02398169f, 0.02600619f, -0.02349269f, 
    -0.05875045f, 0.00067188f, 0.01515611f, 0.02276837f, 0.08069231f, 0.04657566f, 0.11933270f, 0.11168066f, 
    0.09560279f, -0.01375365f, 0.00490973f, 0.00147410f, -0.05985265f, -0.06553593f, 0.11525731f, 0.06056430f, 
    -0.08601600f, -0.03314464f, 0.01641946f, -0.11967225f, -0.13583550f, -0.09566994f, -0.02696880f, 0.00212785f, 
    -0.09259003f, -0.15950662f, 0.16394329f, 0.01775031f, 0.10593160f, -0.01997911f, 0.02674981f, 0.03650757f, 
    -0.01506383f, -0.07966640f, 0.05664060f, 0.04994636f, -0.13170670f, -0.02694390f, 0.00772097f, 0.10575800f, 
    0.05327080f, -0.20844439f, -0.03688198f, 0.01425001f, 0.23880953f, 0.03006999f, 0.11805534f, 0.09750808f, 
    0.13524018f, -0.04336905f, -0.03034208f, -0.01354849f, 0.03948192f, -0.03942126f, 0.01718059f, -0.03844324f, 
    -0.04390649f, 0.05580084f, -0.01790154f, -0.11827499f, -0.04878321f, -0.11888648f, -0.07751065f, -0.05064170f, 
    0.19818747f, 0.16409396f, -0.20834506f, 0.03010606f, -0.30225477f, 0.11206527f, 0.02164085f, -0.09281103f, 
    -0.01814618f, -0.08307239f, 0.01698152f, 0.03250077f, -0.03705721f, 0.04170066f, 0.11551247f, -0.17751935f, 
    -0.29578221f, -0.20773178f, -0.09460705f, -0.04081099f, 0.10703110f, 0.00566624f, 0.04196664f, 0.03126994f, 
    0.02888273f, -0.04914383f, -0.02032591f, -0.12852497f, -0.01590262f, 0.02397645f, 0.03682589f, -0.02129949f, 
    0.04561998f, 0.00786631f, 0.00932111f, -0.06779972f, -0.05316140f, -0.08852354f, 0.03072980f, -0.03706861f, 
    -0.03429433f, 0.00726206f, -0.11355165f, -0.11979376f, -0.05971554f, 0.04015291f, 0.02787830f, 0.03110701f, 
    -0.07169227f, 0.04291724f, 0.12628330f, 0.07836694f, 0.12122607f, 0.03111932f, 0.03527641f, -0.03005243f, 
    -0.02738867f, 0.01745229f, 0.09595902f, -0.03202820f, -0.53029698f, -0.25951111f, 0.23195243f, 0.05025626f, 
    0.21168725f, -0.01053554f, -0.08204626f, 0.07965454f, -0.07559022f, -0.01631614f, 0.12567116f, 0.12672058f, 
    -0.02699060f, 0.00309910f, 0.11361709f, 0.29748264f, 0.10244177f, 0.01394612f, 0.13302554f, -0.00287460f, 
    -0.98027849f, -0.05819773f, -0.18197419f, -0.29073629f, 0.13118376f, 0.06251942f, -0.01227579f, -0.08045213f, 
    0.12382858f, -0.10859413f, -0.00748918f, 0.04869838f, -0.04830982f, -0.11209413f, -0.00185890f, -0.04236085f, 
    -0.01219777f, 0.04140489f, 0.03327050f, 0.02489411f, 0.25516534f, -0.11411886f, -0.25707605f, -0.08751488f, 
    -0.16060616f, 0.01460046f, 0.12076885f, 0.04644252f, -0.15882538f, 0.05138866f, 0.30408183f, 0.04304371f, 
    -0.03168653f, -0.00247296f, 0.02653007f, -0.02228696f, 0.00920541f, -0.01471101f, -0.01135775f, 0.08013110f, 
    -0.06897383f, 0.08553719f, 0.05730467f, 0.48032916f, 0.21392851f, -0.14090298f, 0.11179158f, -0.10337531f, 
    0.11000005f, -0.05735527f, -0.05518130f, -0.01709232f, -0.03642465f, 0.00627756f, 0.01594888f, -0.03277852f, 
    0.03119085f, -0.00182595f, -0.04847461f, 0.07456695f, -0.10784513f, 0.14264199f, -0.04502035f, -0.00691176f, 
    -0.05590232f, 0.07195371f, 0.05211079f, 0.05690439f, 0.01370189f, -0.13109499f, -0.00641968f, -0.01960641f, 
    0.07599618f, -0.15198730f, 0.01311826f, 0.13019535f, 0.13412012f, -0.03364510f, -0.11020619f, 0.04102392f, 
    -0.11913709f, -0.18103495f, 0.13205178f, 0.06942861f, -0.04191242f, 0.07656856f, 0.01306583f, 0.15130973f, 
    -0.08298428f, 0.04585844f, -0.01555873f, 0.00100862f, -0.06413493f, 0.00557312f, -0.02858424f, 0.08617205f, 
    -0.17954531f, 0.09249075f, 0.19308779f, -0.17821577f, -0.18484321f, -0.06438945f, -0.03977767f, -0.07260985f, 
    -0.02491964f, 0.05496718f, 0.08498613f, 0.01924423f, 0.08932524f, 0.04587072f, 0.05132447f, -0.06195612f, 
    -0.02551900f, 0.08952884f, -0.01870835f, -0.01269086f, -0.02424916f, -0.02152350f, 0.02440269f, -0.03665813f, 
    0.50284064f, 0.01135783f, -0.01945933f, 0.03355554f, -0.08928023f, 0.01242112f, -0.00390560f, -0.04507758f, 
    0.04666288f, -0.05825340f, 0.15903467f, 0.05180233f, -0.02065301f, -0.05347183f, 0.11018033f, -0.05223006f, 
    -0.06111056f, 0.01949442f, 0.09103338f, 0.06057990f, -0.11149308f, -0.28518847f, -0.01831327f, -0.06431562f, 
    0.01386997f, 0.00747010f, 0.01779131f, 0.00594898f, -0.09409595f, 0.06989852f, -0.00769876f, 0.01584846f, 
    -0.05854184f, -0.03093139f, -0.22259429f, 0.00611609f, 0.00389972f, -0.05125991f, 0.05784626f, -0.01641089f, 
    0.45563731f, 0.05896260f, -0.01957534f, 0.06292870f, 0.10771807f, -0.10039611f, 0.01075037f, -0.01164303f, 
    0.00400197f, -0.04618298f, -0.03722859f, 0.05371924f, 0.05070784f, 0.00655272f, -0.01573189f, -0.01381790f, 
    -0.03967116f, -0.09899951f, 0.06111360f, -0.03903034f, -0.03082680f, 0.05160248f, -0.18898159f, -0.13230565f, 
    0.01781221f, 0.21555907f, -0.17558235f, -0.13281909f, 0.03096744f, 0.00054844f, 0.02760361f, 0.02857388f, 
    0.09057404f, 0.01706439f, 0.06580352f, -0.08408298f, -0.05579365f, 0.15245423f, -0.22091840f, -0.26920345f, 
    -0.57558095f, -0.46705842f, 0.14324926f, -0.07008050f, -0.14410791f, 0.07243539f, 0.00002668f, -0.07791962f, 
    -0.12935585f, -0.03197820f, -0.08048879f, -0.03164950f, -0.07038220f, 0.05907869f, 0.07496216f, 0.06753589f, 
    -0.05491732f, -0.09685234f, 0.02258917f, 0.00520116f, -0.23252687f, -0.09939407f, 0.09764984f, 0.05773552f, 
    -0.00324141f, 0.09413416f, -0.01673876f, -0.04162148f, 0.02001996f, 0.10521022f, -0.05418786f, -0.07709900f, 
    0.01043773f, 0.17648216f, -0.05107852f, -0.18522704f, 0.08452547f, -0.06292995f, 0.06931173f, -0.08386543f, 
    0.07987010f, -0.01429570f, 0.10888430f, 0.07398162f, -0.12722966f, 0.00173412f, 0.18791309f, 0.09857041f, 
    -0.07028739f, 0.08525719f, 0.02637194f, 0.05438346f, 0.04590556f, 0.09381733f, -0.02183452f, 0.03201438f, 
    -0.00016028f, 0.00146222f, 0.07035501f, 0.10409606f, -0.32685363f, 0.04158626f, -0.40732244f, -0.33514020f, 
    0.29680327f, -0.06818967f, -0.15109579f, -0.09456410f, 0.18014286f, -0.06427099f, 0.04147429f, 0.03228382f, 
    0.06228180f, -0.09265492f, 0.05356907f, -0.01121833f, 0.04240061f, 0.18144409f, -0.18554038f, -0.12067512f, 
    0.24740514f, 0.05024083f, -0.21231765f, 0.11033168f, -0.16293184f, -0.03343257f, -0.11407990f, -0.05652153f, 
    -0.25600582f, 0.03509149f, -0.03605978f, 0.01618377f, 0.09363831f, 0.10347892f, -0.09382343f, 0.04560411f, 
    0.25331393f, -0.08842225f, 0.01415313f, 0.03131783f, 0.22467270f, 0.10576160f, 0.08385111f, 0.06599586f, 
    0.03460719f, -0.03205684f, -0.00924156f, -0.02839871f, -0.02693107f, 0.01207322f, -0.02850908f, 0.03602136f, 
    0.02070319f, 0.04674870f, 0.02074851f, 0.03637158f, 0.03146079f, 0.02279592f, 0.06791975f, -0.02238981f, 
    0.22658049f, 0.05762761f, -0.23418468f, -0.21122536f, -0.58047342f, 0.00643839f, -0.12535234f, -0.08245859f, 
    -0.06523082f, 0.03002248f, 0.02898921f, -0.00498282f, -0.01415934f, 0.01657326f, 0.03279920f, -0.20143613f, 
    -0.18128285f, -0.26846513f, -0.27934569f, -0.08897927f, -0.24440989f, 0.08061555f, -0.11416345f, 0.00271978f, 
    0.08693795f, -0.07138713f, 0.06437904f, 0.05288782f, 0.05592275f, 0.00859517f, 0.03584709f, -0.05088139f, 
    0.06185037f, 0.04138621f, 0.05786150f, -0.02165402f, 0.01965757f, 0.07591318f, -0.18026985f, -0.03217278f, 
    0.50165564f, 0.10634997f, -0.07291887f, 0.09436042f, -0.04442622f, 0.02100041f, -0.06644168f, -0.09553012f, 
    0.07254936f, -0.12695624f, -0.02765319f, 0.09179578f, -0.09444775f, 0.06284525f, -0.00353942f, -0.00905844f, 
    -0.06797034f, 0.18600020f, 0.04444923f, -0.02936815f, -0.14958429f, -0.00396202f, -0.14613767f, -0.09041827f, 
    0.03963504f, -0.14234692f, 0.20957217f, 0.19598913f, 0.01816519f, 0.04895816f, 0.02139569f, -0.09891371f, 
    0.19302101f, -0.02290721f, 0.01904672f, -0.00676028f, -0.00429618f, 0.05600387f, -0.05037982f, -0.07443346f, 
    0.20753548f, -0.07530363f, -0.23706922f, -0.11542102f, -0.12547641f, 0.09476779f, 0.08176133f, -0.06231286f, 
    0.07737501f, 0.06527945f, -0.01175398f, -0.01723566f, 0.05064474f, -0.00730542f, -0.10112596f, 0.02928695f, 
    -0.01372763f, 0.03734261f, -0.04943260f, -0.05147061f, -0.00519241f, -0.11889121f, 0.01601009f, 0.02043303f, 
    0.01300545f, 0.00011194f, -0.07199277f, 0.01904008f, 0.00993257f, -0.01248849f, 0.06891716f, 0.02662468f, 
    0.06413475f, -0.02919391f, 0.08598609f, -0.00857817f, 0.05384446f, 0.06880014f, 0.07896912f, -0.11916377f, 
    0.07149004f, 0.02698187f, -0.01461106f, -0.25505123f, 0.01369267f, 0.02294113f, 0.02628961f, -0.01104536f, 
    0.10187784f, 0.00432391f, 0.00279017f, 0.00088707f, 0.02962084f, 0.03869738f, 0.02243327f, 0.03984444f, 
    0.00678078f, -0.01917243f, 0.01575212f, -0.05038282f, 0.10768515f, 0.13211630f, -0.15113147f, 0.12236822f, 
    0.08224019f, -0.21700600f, 0.07691490f, 0.04184204f, -0.20223230f, 0.09497867f, 0.17947762f, -0.03011827f, 
    0.03294241f, -0.02480982f, 0.00563009f, -0.03744098f, 0.04572256f, -0.01511704f, 0.09281144f, -0.13504054f, 
    -0.05733956f, -0.16057187f, 0.17807423f, -0.14992678f, 0.07250091f, 0.08056711f, -0.04149277f, -0.14445135f, 
    -0.17323790f, 0.11873701f, -0.03420754f, 0.00201958f, 0.03346422f, -0.00172547f, -0.02519247f, 0.12926778f, 
    -0.01408356f, -0.11292926f, -0.00922499f, 0.01563283f, 0.02162335f, -0.06510773f, -0.07627727f, -0.02440853f, 
    0.08389525f, -0.01493699f, -0.05058812f, -0.00940995f, 0.06122119f, 0.06577189f, 0.06798837f, 0.04863649f, 
    -0.04708330f, 0.03784052f, -0.07719787f, 0.01604498f, -0.05319918f, 0.00359400f, 0.06727841f, 0.01805422f, 
    -0.23880251f, -0.58628643f, -0.37959641f, 0.01452913f, -0.23329039f, 0.04279449f, 0.02802831f, 0.02540898f, 
    -0.07630818f, 0.10956974f, -0.00718617f, 0.01067638f, -0.00172582f, 0.00592990f, -0.08287805f, 0.00250595f, 
    -0.00594856f, 0.05587351f, -0.12191422f, 0.02059598f, -0.01186526f, -0.08788577f, 0.60920554f, 0.39431265f, 
    0.26435858f, -0.23540343f, -0.09592120f, -0.00497727f, 0.01965783f, 0.02677687f, 0.07968226f, 0.04873398f, 
    0.04986874f, -0.07589875f, 0.02815174f, -0.07244313f, 0.00121457f, 0.07598917f, -0.06491636f, -0.06242875f, 
    0.01504685f, -0.05356812f, 0.69664568f, 0.39965117f, 0.23968142f, 0.05862875f, -0.09525260f, -0.17288287f, 
    0.28322721f, -0.09622728f, 0.01855771f, 0.11367033f, 0.01395671f, 0.03045401f, -0.06139443f, -0.01496601f, 
    -0.00639837f, 0.00573990f, 0.00632757f, -0.02839183f, -0.11796555f, -0.18776330f, 0.17728832f, 0.21734807f, 
    -0.01170354f, 0.01627753f, 0.01472447f, -0.01328990f, 0.04834402f, -0.03003659f, 0.00619479f, -0.00055192f, 
    -0.02092584f, 0.02633086f, -0.05549077f, -0.02473264f, -0.00276445f, -0.05334677f, -0.02197858f, 0.12662180f, 
    0.25381112f, -0.34018126f, -0.02969452f, 0.11781212f, -0.18246883f, 0.03132249f, 0.07495107f, 0.03659461f, 
    0.01708596f, 0.02243036f, 0.05984363f, 0.00075718f, 0.04221344f, -0.02579018f, -0.02394943f, 0.00274676f, 
    0.01185377f, -0.02845038f, 0.07163154f, -0.04326392f, -0.25838041f, -0.00144819f, 0.10268281f, -0.09506846f, 
    -0.03581228f, 0.04254633f, -0.04461795f, -0.21478844f, -0.14525388f, 0.09288952f, 0.07249058f, -0.00584354f, 
    0.08366451f, 0.01975955f, -0.08339777f, 0.00447785f, 0.00452730f, -0.03531119f, -0.20552303f, -0.02399475f, 
    0.10741273f, -0.35267678f, 0.21484762f, -0.28191471f, 0.01884291f, 0.16331896f, -0.17137620f, -0.15263435f, 
    -0.10759571f, 0.00909220f, -0.00875859f, 0.00611529f, 0.02488730f, 0.00993782f, 0.01787204f, 0.09303167f, 
    -0.02889152f, -0.32577127f, 0.10965333f, 0.03169002f, 0.17858024f, -0.26018018f, -0.23887064f, 0.10861689f, 
    0.03489082f, 0.09367077f, -0.02490148f, -0.02462962f, -0.00716513f, -0.02125354f, -0.05304775f, 0.14645897f, 
    -0.05939138f, 0.03385706f, 0.06156227f, 0.07615262f, 0.02885676f, -0.00563009f, 0.17990626f, 0.07988285f, 
    0.19953638f, -0.13828814f, -0.05435207f, -0.19364607f, 0.07692640f, 0.09550007f, 0.00917511f, -0.01913716f, 
    -0.01531390f, 0.01037930f, 0.01357333f, 0.02655019f, 0.00489068f, 0.07863192f, -0.03483153f, 0.06251247f, 
    0.03214851f, -0.06008187f, 0.13598092f, -0.00818216f, 0.33993465f, 0.06936513f, 0.02122973f, 0.28569266f, 
    0.22177392f, 0.09662464f, 0.08763890f, -0.10817284f, 0.01801872f, -0.11754744f, -0.07650170f, 0.04453646f, 
    0.00428231f, -0.00318415f, -0.03307156f, 0.05609709f, 0.16394833f, 0.02122259f, 0.12638681f, 0.08773513f, 
    -0.56845713f, -0.59528917f, 0.09772570f, -0.29098669f, -0.03045719f, 0.05014497f, 0.01348256f, -0.25781500f, 
    0.02509600f, -0.04525268f, 0.00409390f, -0.02120070f, -0.00188218f, -0.00569974f, 0.00626798f, 0.01557192f, 
    -0.06991458f, 0.01217539f, 0.02934803f, 0.11825180f, -0.08009034f, 0.43559879f, 0.33921075f, 0.21787454f, 
    0.36621001f, -0.02682780f, -0.09636495f, 0.10267870f, 0.05986670f, 0.10207044f, -0.02759208f, 0.05880901f, 
    0.02299687f, -0.02635951f, 0.03463345f, 0.02260026f, 0.04773692f, 0.02262090f, -0.03919938f, -0.00508492f, 
    0.12121195f, 0.08019896f, 0.21465260f, 0.06908104f, 0.11361004f, -0.01805532f, -0.00379183f, 0.09522160f, 
    0.03693317f, -0.05302087f, 0.06709188f, 0.03299628f, 0.05512507f, -0.07108241f, 0.08080557f, -0.00048416f, 
    -0.02694340f, 0.03652235f, 0.01660431f, -0.07021796f, 0.04123066f, -0.25164068f, -0.19544336f, 0.20364423f, 
    -0.24861076f, -0.09654687f, 0.14803931f, 0.05162798f, -0.14681211f, 0.12896900f, 0.00865325f, 0.00849268f, 
    -0.02208305f, 0.03063881f, -0.01975491f, -0.09002434f, 0.03684068f, 0.03757546f, 0.01719533f, 0.12867001f, 
    -0.77178341f, -0.29017287f, -0.69570959f, -0.04316042f, -0.30536261f, 0.04889439f, -0.02648931f, 0.04493701f, 
    -0.15228608f, -0.02603575f, -0.02191944f, -0.01150106f, 0.08488166f, -0.03909085f, -0.03409833f, 0.02869450f, 
    -0.03740358f, -0.03770911f, -0.04010472f, -0.05493514f, 0.03230120f, -0.07452731f, 0.00877416f, -0.00678483f, 
    0.06302492f, 0.01207171f, 0.00952124f, 0.02194692f, 0.02991843f, 0.06276800f, -0.06195293f, -0.22556338f, 
    0.05615073f, 0.00228106f, -0.05488373f, 0.00207509f, -0.02277489f, -0.06746546f, -0.02505727f, 0.01050288f, 
    -0.18371373f, -0.10529809f, 0.46553898f, -0.02618141f, -0.07937869f, -0.00687546f, -0.16739637f, -0.00898237f, 
    -0.03897511f, 0.08775347f, 0.07929105f, 0.01055402f, 0.09175277f, -0.02669277f, 0.06717001f, -0.00986524f, 
    0.09982575f, -0.05267792f, -0.02946958f, -0.11193889f, -0.26407701f, -0.34079891f, -0.38160190f, 0.09532335f, 
    -0.38691688f, -0.08233350f, 0.04246176f, 0.00747074f, -0.02252454f, 0.03489451f, -0.00506930f, -0.02526835f, 
    0.01604985f, 0.00584123f, 0.00213275f, -0.06546067f, 0.02772354f, -0.09829123f, -0.00308570f, 0.06605849f, 
    -0.17338547f, 0.09002059f, 0.39177161f, 0.20589511f, 0.12151520f, -0.04091315f, -0.13108109f, -0.06706948f, 
    -0.03292991f, -0.01896339f, 0.02273216f, 0.02224804f, 0.02240117f, 0.04605937f, 0.01716644f, -0.05497917f, 
    0.02621290f, 0.06886867f, -0.02348455f, -0.07290641f, 0.54305828f, 0.14329183f, 0.02969158f, 0.34056896f, 
    0.14185470f, 0.13057736f, -0.03641744f, -0.04364984f, 0.06225224f, -0.09612950f, -0.10782369f, 0.14364985f, 
    0.03780765f, 0.05803435f, -0.08650151f, 0.07062087f, -0.09652111f, -0.02686984f, 0.10136276f, -0.04121149f, 
    -0.24888220f, -0.23608333f, 0.59042370f, 0.29245263f, 0.18092525f, -0.00661130f, -0.13846374f, -0.10979114f, 
    0.05757388f, -0.11775966f, -0.00171582f, 0.02867902f, -0.00319587f, 0.00675089f, -0.03561746f, 0.01509841f, 
    -0.01988816f, -0.03309542f, 0.04846316f, -0.01171876f, -0.18456693f, 0.22939667f, -0.31085575f, 0.16111198f, 
    -0.06678379f, -0.04757088f, 0.00717469f, -0.08068433f, 0.01247254f, 0.04336980f, 0.00079108f, 0.05369291f, 
    -0.00146167f, 0.07270611f, -0.13794418f, -0.12163042f, 0.03356261f, -0.01946039f, -0.07473879f, 0.04225425f, 
    -0.51804763f, -0.22806866f, -0.04384314f, -0.64157200f, -0.25456837f, -0.00974876f, -0.04349416f, -0.01765751f, 
    0.07553098f, 0.00649905f, 0.01827563f, 0.00216483f, 0.01463538f, 0.02819368f, 0.03634836f, 0.03136251f, 
    -0.13128304f, 0.04939536f, 0.01277240f, -0.00917236f, -0.23980094f, 0.17089064f, -0.10105643f, 0.14268805f, 
    -0.03164265f, -0.12553532f, 0.01741468f, -0.26099342f, -0.05982915f, -0.06200965f, 0.13918582f, 0.03508633f, 
    -0.08692846f, 0.05165261f, -0.02002731f, 0.04489482f, 0.03376639f, -0.05523661f, -0.03255384f, 0.00183619f, 
    -0.08624067f, -0.01756069f, 0.05835319f, -0.15453906f, 0.04125511f, -0.01283938f, -0.05953293f, -0.07188036f, 
    0.03824691f, 0.12298249f, 0.03945849f, -0.03371758f, -0.00760155f, 0.03402261f, 0.01201488f, 0.00420585f, 
    -0.15963602f, -0.05956680f, 0.04670307f, 0.01027446f, -0.63959622f, -0.11725963f, 0.16835558f, -0.11283830f, 
    -0.20404109f, 0.02414273f, 0.05074108f, 0.03055394f, 0.06395914f, 0.03126432f, 0.04589801f, -0.00210993f, 
    -0.00854379f, 0.06724323f, -0.04444041f, -0.02103943f, 0.02722955f, 0.16999219f, -0.07297862f, -0.13126208f, 
    0.12020458f, -0.04013966f, -0.00987442f, 0.05579836f, -0.01100364f, 0.01759129f, -0.19991374f, -0.32679003f, 
    -0.00737314f, -0.29785278f, 0.04372226f, 0.14241418f, 0.02717739f, -0.01764256f, -0.05156848f, -0.02394838f, 
    -0.03296893f, -0.04949035f, 0.07879219f, -0.03851772f, 0.14616883f, -0.16255687f, -0.13581793f, -0.08872619f, 
    0.12004072f, -0.09068281f, -0.00421811f, 0.04167661f, 0.04655641f, 0.12335702f, 0.04811473f, -0.02975874f, 
    -0.17331396f, 0.19685625f, -0.10883976f, 0.11751036f, -0.08864732f, 0.03086632f, 0.06115695f, -0.04988815f, 
    0.20143002f, -0.11277256f, 0.06269009f, 0.07631856f, 0.10983267f, 0.05516533f, -0.04415732f, -0.02911654f, 
    0.04769172f, -0.03424975f, -0.11070612f, -0.00619067f, 0.02150795f, 0.02787538f, -0.01470592f, -0.00843612f, 
    -0.00524881f, -0.03818249f, 0.03220837f, -0.04263050f, 0.32369193f, 0.23626246f, -0.23827055f, 0.12109006f, 
    0.07445380f, -0.04797839f, 0.03612455f, -0.05263768f, -0.04256921f, 0.04512452f, -0.11574886f, 0.05973332f, 
    -0.09292913f, 0.06065376f, -0.07586204f, 0.01435499f, 0.01559345f, 0.08460028f, -0.16896202f, 0.09214839f, 
    -0.09175324f, -0.09134075f, 0.43438888f, 0.14967650f, 0.21667604f, -0.02117148f, -0.04438367f, 0.01717377f, 
    0.16085547f, -0.13202436f, 0.04019624f, 0.04545686f, 0.03135274f, 0.01711546f, 0.07076446f, 0.04462057f, 
    0.00368285f, 0.02951232f, 0.00574121f, -0.02323312f, 0.00662303f, -0.13517934f, -0.01450570f, -0.01723034f, 
    0.05980945f, 0.03716472f, -0.00944273f, 0.03764707f, 0.01732451f, 0.01813051f, -0.11567755f, -0.11355948f, 
    0.01317061f, 0.15586905f, -0.03110102f, 0.04661820f, 0.00397481f, 0.01764645f, 0.00201567f, -0.06516038f, 
    0.31962001f, -0.26709658f, -0.20767811f, -0.20729002f, -0.02894644f, 0.04542815f, -0.06139822f, -0.04601273f, 
    0.00411259f, -0.01271722f, -0.10769273f, -0.09164868f, 0.07131851f, -0.09929246f, 0.08425993f, -0.01018130f, 
    0.10408003f, -0.08946847f, 0.15250881f, -0.13547778f, -0.09890168f, -0.14298511f, -0.27667019f, -0.11312211f, 
    0.03061035f, -0.07395919f, -0.02834533f, 0.02772878f, -0.00256905f, 0.03374770f, 0.01034773f, -0.03028126f, 
    -0.12644486f, 0.12368544f, 0.00978447f, 0.09101836f, 0.09677678f, 0.06740774f, -0.00851448f, 0.03470684f, 
    -0.14156622f, -0.06761670f, 0.14131092f, -0.03689352f, -0.33586958f, 0.05440367f, -0.03917738f, 0.01597515f, 
    0.00376973f, 0.03897084f, -0.01309273f, -0.02151578f, -0.01051147f, -0.04844303f, -0.03255062f, 0.16936530f, 
    0.11889848f, 0.17987821f, 0.12673947f, 0.23137873f, -0.12348788f, -0.05626168f, 0.05792049f, -0.02405774f, 
    0.09737433f, -0.01531594f, -0.08969920f, -0.09365397f, 0.03909387f, 0.08238966f, 0.00073799f, -0.03557972f, 
    -0.01002776f, 0.00274135f, -0.10313737f, 0.05052473f, -0.11577860f, -0.14642105f, -0.01556747f, -0.04480071f, 
    -0.11502859f, 0.09579996f, -0.03461451f, 0.03385553f, 0.05814364f, -0.01347867f, -0.03277540f, -0.14776169f, 
    -0.08558426f, -0.04505208f, 0.05556948f, -0.05955891f, 0.07813960f, 0.04946850f, -0.05562833f, 0.00396425f, 
    -0.04906054f, -0.02800502f, 0.06220263f, -0.02702827f, 0.09884766f, 0.01998817f, -0.43405181f, -0.08865470f, 
    0.13602835f, -0.06239340f, 0.03717744f, -0.00118809f, -0.02030413f, -0.07450812f, -0.03009948f, -0.17221381f, 
    0.03893737f, -0.03496655f, -0.08947472f, -0.03659004f, 0.16828302f, 0.09155741f, 0.01110583f, -0.03512856f, 
    0.25944972f, 0.10051314f, -0.72670013f, 0.12024653f, 0.10838503f, -0.04462289f, 0.01811867f, 0.04205963f, 
    -0.04677887f, 0.19875051f, 0.01086637f, -0.01808353f, -0.04365212f, 0.01906332f, -0.14275135f, -0.00127103f, 
    0.02971534f, 0.09518837f, -0.21779655f, 0.01237089f, -0.03996196f, 0.15264462f, 0.10447163f, 0.04524781f, 
    0.06450232f, 0.01087828f, -0.03639330f, -0.02396057f, -0.05793848f, -0.24622478f, -0.01445075f, -0.05552870f, 
    0.05124640f, -0.00490601f, -0.02047813f, -0.00977871f, -0.01364007f, -0.02484598f, 0.02113394f, -0.05699556f, 
    -0.10098845f, -0.45527664f, -0.18663171f, -0.08434177f, -0.43831530f, -0.07790036f, -0.10611910f, -0.02651414f, 
    0.11163335f, -0.25722983f, 0.00364525f, 0.06933919f, -0.03150973f, 0.02308162f, -0.08511797f, -0.00670110f, 
    0.00551209f, 0.00066309f, 0.07231211f, -0.02210671f, -0.09142485f, -0.02615835f, 0.16134535f, 0.39522576f, 
    0.05149885f, 0.06479847f, -0.00354671f, 0.06035583f, 0.05180483f, -0.00707277f, 0.00951491f, 0.05942774f, 
    -0.01229525f, -0.02144855f, -0.01515150f, -0.06674124f, -0.05897178f, 0.03634260f, 0.05711808f, -0.00478325f, 
    0.02397351f, -0.16640769f, -0.14191519f, -0.13616624f, 0.27639505f, -0.03386127f, -0.02098904f, 0.02401487f, 
    -0.14277777f, -0.02950481f, 0.07874510f, -0.06770594f, -0.12220045f, 0.06421889f, -0.06620067f, 0.13271382f, 
    0.08085351f, -0.02487998f, 0.14483538f, 0.03272798f, -0.17073987f, 0.03355950f, -0.02397548f, 0.04919373f, 
    0.05140532f, -0.05169256f, -0.04866077f, -0.20582914f, -0.09228498f, -0.09421396f, 0.01193508f, -0.02531936f, 
    -0.10521550f, 0.02032159f, -0.07514206f, 0.00268947f, -0.01938760f, -0.03041173f, -0.05946032f, 0.00717589f, 
    -0.21964444f, 0.19263695f, 0.14162090f, -0.03215027f, 0.07363594f, 0.02118564f, -0.01836050f, -0.00474895f, 
    -0.02158137f, 0.05217963f, -0.03186975f, -0.10138422f, -0.08544073f, 0.07106201f, 0.08455607f, 0.04647489f, 
    -0.01880351f, -0.03784653f, 0.00680632f, -0.09134165f, 0.23431422f, 0.04634378f, 0.05731766f, -0.03909360f, 
    0.25652525f, -0.14848419f, 0.13154346f, 0.00328254f, -0.02214809f, 0.08322043f, 0.01746655f, 0.02594701f, 
    0.01434507f, -0.09276547f, 0.03576582f, 0.07840579f, 0.03647022f, 0.00189050f, -0.01365525f, 0.07413298f, 
    -0.24234509f, -0.02279657f, -0.05187029f, -0.13059667f, -0.09588517f, 0.10311028f, -0.03115584f, 0.00605110f, 
    0.01379314f, 0.04790328f, 0.00351643f, 0.02010152f, 0.02314163f, -0.03774142f, 0.09957262f, 0.00262896f, 
    -0.09303048f, -0.26475191f, 0.14568543f, 0.01790322f, -0.48575830f, -0.54577821f, -0.32703030f, -0.11635476f, 
    -0.25011641f, -0.00991114f, -0.00620763f, 0.00587236f, 0.07918733f, -0.05870412f, -0.03416153f, -0.03875698f, 
    -0.06190360f, -0.02482750f, -0.04559175f, -0.06595669f, -0.01883677f, 0.01269162f, 0.00624392f, 0.17997661f, 
    0.01079486f, 0.03544596f, 0.38304016f, 0.01567913f, 0.27545723f, -0.03272214f, 0.00752029f, -0.00626133f, 
    -0.07062457f, -0.10495365f, 0.02625545f, -0.11273411f, -0.07792952f, 0.01471101f, 0.12489051f, 0.06133055f, 
    0.00288607f, -0.04431004f, 0.04019385f, 0.00753318f, 0.27703515f, -0.00794862f, 0.05036884f, 0.02345634f, 
    0.10982745f, 0.10781877f, -0.07160030f, -0.20006849f, -0.14159863f, 0.05775208f, 0.05759614f, 0.04923794f, 
    -0.00671359f, 0.00559943f, 0.00352545f, 0.07722390f, 0.01737107f, -0.11473387f, 0.11328370f, 0.08858108f, 
    -0.22733149f, 0.17624557f, 0.06020654f, 0.10747665f, 0.07127602f, -0.08070038f, 0.14186747f, -0.11581141f, 
    -0.12091462f, 0.01833177f, 0.12985250f, 0.06977019f, 0.04178288f, 0.07042463f, 0.00869804f, 0.03364211f, 
    0.06212565f, 0.03747681f, 0.01968981f, -0.01511552f, 0.29285362f, 0.10817315f, -0.39598182f, -0.00992015f, 
    0.02788898f, -0.01467313f, 0.00671990f, -0.04829201f, 0.13841063f, 0.03626314f, -0.04677253f, 0.00767286f, 
    -0.01267776f, -0.01620120f, -0.05523107f, -0.01649859f, 0.00380670f, 0.07162741f, -0.17275497f, -0.06663205f, 
    -0.64126807f, -0.00087295f, -0.08078232f, -0.12656358f, 0.07153820f, -0.05096811f, 0.03553842f, -0.08756942f, 
    -0.11016317f, -0.04112109f, 0.00131402f, 0.04334362f, -0.00090110f, -0.06662880f, -0.03060877f, -0.00052565f, 
    -0.08311753f, -0.05187584f, -0.13592809f, 0.01645597f, -0.24771649f, -0.05819929f, 0.15537605f, -0.13871565f, 
    0.01262364f, 0.05321052f, 0.01585962f, -0.00754539f, 0.03283436f, 0.07249077f, 0.01261799f, 0.00684205f, 
    0.03247963f, 0.00304069f, -0.02133734f, 0.01418933f, -0.08281595f, -0.05850625f, 0.05144725f, -0.00590400f, 
    -0.65279138f, 0.12554087f, 0.10583787f, 0.15117519f, -0.68285400f, -0.11997405f, -0.17349294f, -0.20850034f, 
    -0.14756379f, 0.14414813f, 0.01923394f, -0.09089717f, -0.02299795f, -0.03670869f, -0.07152934f, 0.03792057f, 
    -0.01798563f, 0.05860211f, 0.20233434f, 0.18042243f, -0.23666012f, -0.27090907f, -0.23649956f, 0.01052061f, 
    -0.23360258f, 0.06946487f, 0.11956983f, 0.03397874f, 0.00139332f, -0.06886506f, 0.03215432f, 0.00139735f, 
    0.04346141f, 0.02833044f, -0.05501882f, -0.01352141f, 0.01199679f, 0.01412370f, -0.07231975f, 0.02571566f, 
    -0.29334778f, 0.18420342f, -0.03036045f, -0.07113079f, -0.07066537f, -0.00213323f, -0.02522830f, -0.02543151f, 
    0.05439458f, 0.02896026f, -0.05471562f, 0.10754325f, -0.14223178f, 0.02911892f, -0.04725354f, 0.07709968f, 
    -0.01079847f, -0.07925799f, 0.04960712f, -0.04443833f, 0.09946524f, -0.05425078f, -0.04821723f, 0.05407195f, 
    0.06696723f, -0.07039852f, -0.01862950f, -0.07831024f, -0.08997191f, -0.03326082f, -0.02577821f, -0.06846187f, 
    0.07175136f, 0.03260298f, -0.02573309f, 0.06198184f, 0.02039547f, -0.04123249f, 0.08831781f, -0.05124841f, 
    0.17796122f, 0.08414280f, 0.06525027f, -0.08793477f, 0.20820379f, -0.02241796f, 0.02978951f, -0.02715816f, 
    0.00606636f, 0.05060407f, 0.01190514f, -0.05912670f, -0.04831359f, -0.03393470f, -0.01902335f, -0.07310822f, 
    -0.05415507f, 0.01307714f, -0.04362393f, 0.03163099f, 0.26475894f, -0.13654694f, -0.12584428f, 0.03033994f, 
    -0.28069240f, 0.30511665f, 0.16660017f, 0.04757462f, 0.01509546f, 0.10046660f, -0.02180688f, -0.12547015f, 
    -0.01800593f, -0.02937196f, -0.12395928f, -0.09770309f, -0.07650420f, -0.04165512f, -0.00790838f, -0.14476672f, 
    0.01653560f, 0.25894782f, 0.29445612f, -0.31320217f, -0.09854320f, -0.23419993f, -0.10025243f, -0.02708671f, 
    -0.09407036f, 0.02368177f, -0.03358121f, -0.11441282f, 0.02356010f, 0.09633695f, 0.04488781f, -0.06206836f, 
    -0.04346891f, -0.06751351f, -0.06247685f, 0.02853975f, -0.47383657f, 0.25542527f, -0.18275370f, 0.07289355f, 
    0.05553789f, 0.05496090f, -0.25830323f, -0.07125626f, -0.02817188f, -0.01982467f, 0.08183510f, 0.01812894f, 
    -0.08802174f, -0.24855152f, 0.03821895f, 0.05448804f, -0.14148524f, 0.03421809f, -0.20445265f, -0.09310979f, 
    0.16716383f, 0.09529366f, 0.27283338f, -0.33220682f, 0.07914104f, -0.13985603f, -0.05432665f, -0.05657734f, 
    0.01700276f, 0.01663183f, 0.07792023f, -0.02631172f, 0.08694619f, -0.05350998f, -0.04622514f, -0.05442966f, 
    -0.01955149f, -0.12285189f, 0.13743444f, 0.00089470f, -0.32788754f, -0.21322940f, -0.10382495f, -0.14628077f, 
    -0.24029179f, 0.09487674f, -0.24583969f, -0.00108599f, -0.20655487f, -0.08855799f, 0.02900145f, 0.05857247f, 
    0.03273630f, -0.07208074f, -0.10129921f, -0.03587629f, -0.05520241f, -0.00713116f, 0.13385330f, -0.14285149f, 
    0.01584130f, -0.06260771f, -0.15293916f, -0.01378437f, 0.17337739f, 0.08521739f, -0.06310835f, 0.02728261f, 
    0.07261703f, 0.07261983f, -0.05356798f, -0.06867258f, -0.07948370f, -0.00502396f, -0.03877674f, 0.03668829f, 
    -0.10738307f, 0.00395020f, -0.15168908f, -0.03519662f, -0.71464401f, 0.43589559f, -0.09085719f, -0.18356222f, 
    0.30999699f, 0.21499881f, 0.14892097f, -0.06063887f, 0.00085828f, -0.07798012f, -0.16441488f, 0.06519390f, 
    0.04328347f, -0.02375039f, 0.14118946f, -0.04765129f, 0.20944288f, 0.01137076f, 0.11212701f, -0.13271677f, 
    -0.56639403f, 0.37190649f, -0.03639205f, -0.06924264f, 0.26148406f, 0.12606470f, 0.02427307f, -0.01622503f, 
    0.04496279f, -0.17471738f, -0.36931819f, 0.04989428f, -0.03605828f, 0.04161218f, 0.09040150f, -0.05633350f, 
    0.06166769f, -0.03024198f, 0.18312861f, -0.03937456f, -0.06373899f, -0.02672516f, -0.09348924f, -0.06657055f, 
    0.09005811f, -0.05841013f, 0.03485489f, -0.02080749f, -0.03416770f, 0.06357183f, -0.04743978f, 0.00765479f, 
    0.00420822f, 0.00567458f, -0.01116073f, -0.02395953f, 0.00581399f, 0.09324995f, -0.00748523f, 0.01254908f, 
    -0.17212926f, 0.04303534f, -0.16567032f, 0.00002375f, 0.06639408f, 0.06566064f, -0.07946961f, 0.07457493f, 
    0.07240389f, 0.03414650f, -0.07185948f, 0.08664320f, -0.15590745f, 0.04808877f, -0.07540521f, 0.02527254f, 
    -0.15599464f, 0.11238705f, -0.10971837f, -0.05286250f, 0.02570073f, -0.08173005f, 0.15111153f, -0.00890875f, 
    0.17724581f, -0.01265213f, 0.10766694f, 0.05831185f, 0.06806695f, 0.07637633f, 0.09908699f, 0.02858512f, 
    -0.01601378f, -0.00627820f, 0.00050364f, -0.06743985f, -0.03407369f, 0.02683294f, -0.12864184f, -0.01979983f, 
    -0.44402823f, 0.41005731f, -0.18117031f, 0.24013363f, 0.41756657f, -0.16577463f, 0.00329569f, -0.12776370f, 
    0.06329829f, -0.04116545f, -0.14171228f, -0.09700265f, 0.04634752f, -0.24439831f, -0.02872938f, -0.02237214f, 
    0.08931303f, 0.02587664f, 0.15653284f, -0.02084601f, 0.54266936f, 0.53471577f, -0.15020910f, 0.06823991f, 
    -0.56145883f, 0.22955446f, -0.00527352f, 0.10451201f, -0.05233289f, -0.04673075f, 0.02238639f, -0.24508993f, 
    0.04084331f, -0.05485545f, -0.12167311f, 0.00315006f, -0.01121807f, -0.02039025f, 0.09272446f, 0.09150168f, 
    0.68757331f, 0.15648399f, 0.03058628f, -0.43277887f, -0.32867321f, -0.01378703f, -0.07617131f, 0.03879505f, 
    -0.18869299f, -0.04487485f, -0.17453264f, -0.16013569f, 0.10089567f, -0.02750084f, 0.01601947f, -0.03764648f, 
    0.01271838f, -0.14434402f, 0.04998711f, 0.08724555f, 0.64214885f, 0.67582053f, 0.13947798f, -0.13440080f, 
    0.17976463f, 0.16019878f, 0.09024389f, 0.00300795f, -0.18947154f, 0.05631487f, -0.17512228f, -0.04063017f, 
    0.13156009f, -0.01628244f, 0.04941472f, -0.02587462f, -0.01609885f, -0.11910830f, 0.17231993f, 0.14351012f, 
    0.05572759f, -0.01340045f, 0.19159429f, -0.09698655f, 0.24656184f, -0.20712252f, 0.06038950f, 0.04748038f, 
    0.05074020f, 0.06164622f, 0.10672954f, 0.02274919f, -0.05986458f, 0.01251615f, 0.03002601f, -0.08613154f, 
    -0.09792283f, 0.05086732f, -0.03780104f, 0.01526076f, 0.00193528f, -0.01120482f, -0.10235904f, 0.00471072f, 
    0.20211747f, 0.04031534f, -0.02585861f, -0.02381435f, -0.07481936f, -0.19507375f, -0.02434182f, 0.05490116f, 
    0.01771255f, 0.07655741f, 0.08358873f, -0.00206926f, -0.03161694f, 0.03072412f, -0.08342933f, -0.01292480f, 
    -0.57226288f, 0.57849014f, 0.01052353f, -0.15217151f, 0.10855421f, 0.16864344f, -0.02663074f, 0.03882544f, 
    -0.07792749f, -0.13270959f, -0.09578236f, -0.01990937f, -0.04840597f, -0.14117014f, -0.02194911f, -0.05044712f, 
    -0.01781591f, -0.02136990f, -0.02726833f, -0.09137688f, 0.29627448f, -0.14385216f, 0.13405818f, -0.37023780f, 
    0.14589083f, -0.06685371f, -0.02018564f, 0.05558580f, 0.13764182f, -0.02786621f, 0.01628636f, 0.01799069f, 
    -0.14522727f, -0.01534294f, 0.10212437f, -0.07867243f, -0.02583727f, 0.09868183f, -0.12721969f, -0.01957482f, 
    0.07954918f, -0.15413921f, -0.12512854f, -0.06703251f, 0.17027903f, -0.04073081f, 0.06792712f, -0.11791533f, 
    -0.04073170f, -0.06104752f, -0.00441241f, 0.00089534f, 0.01731325f, -0.05967183f, 0.06422818f, 0.02399247f, 
    -0.14380741f, 0.03818458f, -0.03286162f, -0.05603918f, -0.25273940f, -0.28238553f, -0.28355080f, -0.07349993f, 
    -0.20636606f, -0.02049556f, 0.07264467f, 0.01828173f, -0.17971368f, -0.08850253f, -0.09827083f, 0.04433851f, 
    0.04391943f, -0.20497309f, -0.01133663f, 0.01872466f, 0.03283329f, 0.05090487f, -0.16798428f, -0.05090923f, 
    0.26547691f, 0.16822037f, 0.05450270f, 0.19686742f, 0.17343681f, 0.13467634f, 0.06594504f, 0.04879209f, 
    0.09300452f, -0.04259988f, -0.00333321f, -0.05336837f, 0.08531136f, 0.01652438f, 0.01909266f, -0.03668104f, 
    0.11042685f, 0.02933306f, 0.03455556f, -0.00719952f, -0.16543628f, -0.00736673f, -0.20671740f, 0.04059780f, 
    0.16020128f, -0.15121716f, -0.04497300f, -0.02500889f, -0.03881471f, -0.00595908f, -0.00017291f, 0.04168827f, 
    0.01193436f, -0.14642060f, 0.03398550f, 0.02436370f, 0.01944353f, 0.13274771f, -0.11016099f, 0.05313966f, 
    0.00215771f, 0.03613875f, -0.11107432f, -0.04701591f, 0.15868244f, 0.11365928f, 0.02585226f, 0.03070472f, 
    0.05281135f, -0.05886202f, -0.03705177f, 0.04524000f, 0.07058711f, 0.04670932f, 0.01820087f, 0.01318732f, 
    0.08236285f, 0.11465789f, -0.01337926f, 0.06064668f, -0.10052706f, 0.83634514f, -0.22871569f, -0.10471433f, 
    0.04278687f, 0.15441518f, -0.05206534f, -0.08503149f, 0.03800065f, -0.10110453f, -0.24615268f, -0.00820384f, 
    -0.15462908f, -0.02832305f, 0.09262875f, -0.16113777f, -0.07242411f, -0.05370226f, 0.01500745f, -0.03536460f, 
    -0.05916303f, 0.07372443f, -0.17921168f, 0.09416674f, 0.25713545f, 0.04014892f, 0.03240403f, -0.01403936f, 
    -0.05774054f, 0.06464625f, -0.04550905f, 0.10256156f, 0.05786548f, 0.11202026f, 0.13429008f, 0.00867892f, 
    0.00321328f, 0.08214904f, 0.09425129f, 0.08784249f, -0.39591464f, 0.09124721f, 0.07846681f, 0.00716262f, 
    -0.05018662f, -0.03948544f, 0.06268793f, -0.12430876f, -0.12736115f, -0.03469892f, -0.07377785f, 0.05423355f, 
    -0.10764986f, 0.01577397f, 0.01673912f, 0.08238404f, 0.08897240f, 0.19208165f, -0.19481225f, -0.04660254f, 
    -0.51720792f, -0.13473029f, 0.02586710f, -0.12314402f, -0.22290018f, 0.07399346f, -0.08586179f, -0.18264794f, 
    -0.03605584f, -0.00787780f, 0.14869751f, 0.04875751f, 0.02110366f, 0.03824791f, 0.01881511f, 0.01586471f, 
    -0.05416925f, 0.05802306f, -0.06446712f, 0.03091349f, -0.71391231f, 0.08433780f, 0.03526501f, 0.30745390f, 
    -0.28820169f, 0.10179198f, -0.05424088f, 0.08219846f, -0.05273157f, -0.00510827f, 0.01273963f, 0.18605720f, 
    -0.08888944f, -0.03334003f, -0.12001502f, 0.06193023f, 0.06905718f, 0.18248783f, -0.05182924f, -0.10104329f, 
    -0.17036743f, -0.07190460f, -0.03348238f, -0.05139353f, -0.26533318f, -0.08241171f, -0.08825573f, -0.10514753f, 
    -0.10435542f, -0.09064599f, 0.06145735f, -0.02293921f, -0.04700833f, 0.01605841f, 0.00479059f, 0.04989497f, 
    -0.03725084f, 0.02996279f, -0.09465513f, -0.09991135f, -0.35982767f, -0.37775937f, 0.30466419f, 0.21069498f, 
    0.18081182f, 0.00818978f, -0.09020657f, -0.02605523f, 0.06517295f, 0.01109883f, 0.15271546f, 0.15475403f, 
    0.02029462f, -0.02298386f, -0.02383406f, -0.08031276f, 0.05377696f, 0.04785454f, 0.05194539f, -0.09752487f, 
    -0.15435044f, -0.10369902f, -0.24158423f, -0.04022407f, 0.26934949f, 0.13111983f, 0.20875701f, 0.10769255f, 
    0.05053381f, 0.07345732f, 0.02434213f, 0.00766506f, -0.05722898f, 0.04971810f, -0.13769664f, 0.12056975f, 
    -0.05330911f, 0.07124014f, 0.00626291f, 0.01478952f, 0.24093488f, -0.11635511f, -0.02923400f, -0.35723579f, 
    -0.30875155f, 0.14267953f, -0.08099687f, 0.10086737f, -0.03734603f, -0.13076249f, -0.10141749f, 0.00874441f, 
    -0.08944558f, -0.07151029f, -0.10978180f, 0.01075722f, -0.02351530f, 0.02369525f, 0.02648592f, 0.07490980f, 
    0.31918421f, 0.05398579f, -0.04677178f, 0.04575276f, -0.10402121f, 0.16885066f, 0.06155877f, -0.03200234f, 
    -0.16313002f, -0.07974398f, -0.10606962f, -0.05949308f, 0.09385081f, -0.09265658f, -0.11842696f, -0.06250047f, 
    -0.03964442f, -0.07629802f, -0.00093673f, -0.07236260f, 0.10311732f, 0.29278111f, -0.18954590f, -0.31855327f, 
    0.05657498f, 0.13242726f, -0.08830006f, -0.01869510f, 0.08458517f, -0.25455880f, 0.03792364f, 0.02590759f, 
    -0.21871023f, -0.05226756f, -0.04301865f, 0.12640053f, 0.03327230f, 0.06092079f, -0.12764919f, -0.05889065f, 
    -0.30363971f, 0.06865937f, -0.03979585f, -0.01226796f, 0.22917645f, 0.20632102f, 0.06339385f, 0.01868372f, 
    -0.09496217f, -0.09872378f, -0.12694100f, 0.02065618f, 0.06682808f, -0.00975100f, 0.01782002f, -0.02107289f, 
    -0.05860095f, -0.08591648f, 0.05629110f, 0.03531438f, -0.22587982f, -0.27336901f, -0.24112788f, -0.08353069f, 
    -0.37902904f, 0.28596395f, 0.02583396f, 0.03169994f, -0.01859020f, -0.09911473f, -0.14088710f, -0.14057212f, 
    -0.00713270f, -0.12151821f, -0.09719393f, 0.04625544f, -0.03802645f, -0.18749319f, -0.03684153f, 0.05776582f, 
    0.10612161f, -0.24932534f, -0.03742823f, 0.05557948f, -0.58806622f, 0.26580063f, 0.06394154f, -0.06818236f, 
    -0.20283405f, 0.23645282f, -0.08403652f, -0.16976352f, -0.00645682f, -0.11497901f, -0.05972534f, -0.00008829f, 
    -0.11419418f, -0.04347596f, 0.01153241f, -0.17061748f, -0.34571394f, -0.23812936f, 0.12755440f, -0.19485560f, 
    -0.32852960f, 0.19412148f, 0.01594483f, 0.22469512f, -0.06069476f, 0.05578787f, -0.09818156f, 0.00153229f, 
    0.01783886f, -0.01701777f, -0.18746483f, 0.00819788f, -0.00476734f, 0.00021623f, 0.07025215f, -0.17465740f, 
    -0.00727771f, -0.18028684f, -0.07739503f, 0.09350977f, 0.16421863f, -0.05329993f, 0.05187420f, -0.08283835f, 
    0.06580808f, -0.00280677f, 0.01703876f, 0.04459399f, -0.02418680f, -0.04918469f, 0.05568817f, 0.04805098f, 
    -0.02507176f, -0.00718304f, 0.03305842f, 0.10156445f, -0.04899536f, -0.38625574f, -0.09789322f, -0.17446601f, 
    -0.11316714f, 0.03366810f, -0.00451790f, 0.04564359f, 0.01773727f, -0.01173412f, 0.08739851f, -0.00085520f, 
    0.05107435f, -0.07715307f, 0.03209441f, 0.00061730f, 0.11018401f, -0.10023930f, 0.09657913f, -0.07975451f, 
    -0.30257624f, -0.00150981f, -0.12732877f, 0.18630916f, -0.05905791f, 0.10595434f, -0.02115111f, 0.14125223f, 
    0.05535873f, 0.04811070f, 0.00561918f, 0.02467531f, 0.00146949f, -0.08711369f, -0.04540335f, 0.00833645f, 
    -0.06851190f, 0.11083776f, -0.05085737f, -0.25315753f, 0.70857596f, 0.57943708f, -0.00747423f, -0.16440293f, 
    -0.42930716f, 0.03611658f, -0.00073802f, -0.12644687f, -0.02608864f, -0.05969033f, -0.00813410f, -0.03385236f, 
    0.04904347f, 0.01486142f, -0.04179505f, 0.00926468f, 0.02616795f, -0.33363891f, -0.04079722f, -0.01063789f, 
    0.20969801f, 0.10277568f, -0.07737603f, -0.39043707f, -0.03282941f, 0.10913552f, 0.03547616f, -0.11669223f, 
    0.01867475f, -0.01003199f, -0.06280921f, -0.05608378f, -0.04735742f, 0.06124467f, 0.04263051f, 0.03344127f, 
    -0.03729722f, -0.02045517f, -0.07400794f, -0.03456178f, -0.20928022f, 0.19317587f, -0.01042596f, 0.33478171f, 
    0.35556611f, -0.02885975f, -0.06855845f, 0.11384843f, -0.04232924f, 0.06977015f, 0.00417579f, 0.04885884f, 
    0.02589903f, -0.07400700f, 0.04806438f, 0.13740452f, -0.00549049f, 0.06008519f, -0.01614255f, -0.09155471f, 
    -0.07074622f, -0.16043228f, -0.30922890f, 0.03798937f, 0.19669934f, 0.12876378f, 0.02931116f, 0.11217500f, 
    0.13987310f, 0.07655185f, -0.02463433f, 0.05197901f, 0.03807994f, 0.11312340f, -0.00417611f, 0.02922208f, 
    0.03137805f, 0.14657590f, -0.02545343f, 0.14280629f, -0.11409081f, -0.03973674f, -0.18516369f, -0.04272032f, 
    0.19358079f, 0.06059763f, 0.02708416f, -0.14490616f, -0.00450537f, -0.06142754f, -0.02310167f, 0.06260847f, 
    -0.03357792f, 0.02743996f, 0.13804936f, -0.10340229f, 0.03989623f, 0.13290884f, 0.04208241f, -0.09594439f, 
    0.36439061f, -0.12808438f, -0.03681569f, -0.34548974f, -0.47852552f, 0.07579397f, -0.09250911f, 0.11255617f, 
    0.10796221f, -0.14467609f, 0.00186914f, -0.10090692f, -0.03580973f, -0.14048783f, -0.06858893f, -0.17317490f, 
    -0.16804677f, 0.16555855f, -0.06425701f, -0.09703348f, -0.07485749f, -0.01279507f, -0.05365041f, 0.03980879f, 
    0.03845731f, 0.14539753f, 0.08248280f, 0.13332163f, 0.06500195f, 0.09261219f, 0.09971937f, 0.04093023f, 
    -0.11988400f, 0.02017842f, 0.03258701f, 0.10713620f, 0.01873716f, 0.05730786f, -0.12122070f, -0.06605881f, 
    -0.09753842f, 0.28099272f, 0.07344275f, 0.38533300f, 0.21084650f, -0.00538048f, -0.10310514f, -0.03320646f, 
    -0.10232832f, -0.19819827f, -0.03988408f, -0.01670514f, 0.10765769f, -0.02039146f, -0.08256659f, 0.04633212f, 
    -0.00338689f, 0.05574342f, -0.02927829f, -0.11191217f, 0.02180733f, 0.30500078f, 0.05317312f, -0.18291664f, 
    0.07177042f, 0.17862740f, 0.05959461f, -0.14495032f, -0.16547465f, -0.12806220f, -0.11162931f, -0.00072372f, 
    0.00040292f, -0.06124190f, 0.02911191f, 0.02652463f, 0.05046504f, -0.02411651f, 0.05013400f, 0.11165037f, 
    -0.45613286f, 0.26935425f, -0.28119206f, 0.09120474f, -0.39734417f, 0.06803202f, -0.27110785f, 0.17465605f, 
    0.09394597f, -0.18397377f, 0.08782612f, -0.10104547f, -0.04402336f, -0.13249832f, -0.06168969f, -0.02745166f, 
    0.02445695f, -0.00683512f, 0.06718601f, -0.15629393f, 0.03614869f, -0.08575032f, -0.02742309f, 0.03599405f, 
    0.18247181f, -0.11504906f, 0.13856082f, 0.02769963f, 0.01279543f, 0.10736781f, -0.04134825f, -0.06321356f, 
    -0.04425190f, -0.10434273f, 0.00279967f, 0.01611902f, 0.00208171f, 0.04644706f, -0.03801662f, -0.01539059f, 
    0.78601152f, -0.13315772f, -0.15583073f, 0.11269449f, 0.13598035f, 0.26846555f, 0.07141339f, 0.15853232f, 
    -0.08426437f, -0.06615674f, -0.15316996f, -0.09715921f, 0.12734389f, -0.01038566f, -0.02292699f, -0.12176945f, 
    -0.04853104f, -0.16088551f, -0.05323671f, 0.09890391f, 0.02631342f, 0.26513889f, 0.11577050f, -0.44769454f, 
    0.27592343f, 0.00000346f, -0.01517436f, -0.01557562f, -0.10545887f, 0.03585472f, -0.05058444f, -0.01981275f, 
    -0.16238105f, 0.03659460f, -0.01263777f, -0.03718903f, 0.07894798f, -0.03828280f, -0.03720647f, 0.04667970f, 
    -0.09874669f, -0.01348336f, 0.01117715f, 0.15346429f, -0.03007443f, -0.04154836f, -0.13232276f, 0.04679633f, 
    -0.02508450f, -0.07102679f, -0.03843361f, 0.07614964f, -0.09753435f, -0.09421011f, 0.00586929f, -0.06888450f, 
    -0.05213806f, -0.09320185f, -0.09662217f, 0.00303210f, 0.01237975f, 0.05767379f, 0.22589903f, -0.06328244f, 
    0.20586616f, 0.00090679f, 0.09133592f, -0.10985202f, 0.02260222f, -0.02981803f, 0.01948161f, -0.05862227f, 
    -0.06133861f, -0.07316219f, 0.01060259f, -0.00885140f, -0.03308742f, 0.02831589f, -0.12517603f, -0.00469859f, 
    -0.15840970f, 0.03451160f, -0.06525483f, 0.16648415f, 0.26399219f, 0.00923380f, -0.05502517f, -0.02801811f, 
    -0.09830654f, 0.15501796f, 0.09376631f, 0.24070741f, -0.01291745f, -0.01713129f, 0.02037884f, -0.23996803f, 
    -0.04830144f, 0.14049667f, -0.00900035f, -0.15323457f, -0.49869683f, -0.14647372f, 0.06211815f, 0.18808019f, 
    -0.10904394f, -0.07732839f, -0.14357466f, -0.03588474f, 0.01952137f, -0.03067244f, 0.04593636f, 0.06483778f, 
    -0.00231316f, -0.05803724f, -0.01406266f, -0.04357753f, 0.02678972f, -0.00472653f, 0.04826080f, -0.09603634f, 
    -0.20036031f, -0.01626728f, -0.26266444f, 0.30285013f, 0.24339032f, -0.14474244f, -0.04853151f, 0.10004830f, 
    0.05660068f, 0.02392488f, -0.02109009f, 0.05053416f, -0.00746988f, -0.08979138f, -0.05974261f, -0.05915696f, 
    0.11784184f, -0.12193377f, 0.09097965f, -0.01732176f, 0.02112131f, -0.03691773f, -0.18990153f, 0.00094247f, 
    0.09051104f, 0.04598220f, 0.00874751f, 0.06429660f, 0.07391177f, 0.07050683f, 0.00784925f, -0.05352112f, 
    -0.03521391f, -0.14115538f, -0.00947955f, 0.04511211f, -0.08170087f, 0.01933040f, 0.01385603f, 0.04224278f, 
    -0.65912402f, -0.09659772f, 0.12303486f, 0.03783001f, 0.16363671f, -0.08906601f, 0.02198946f, -0.02801519f, 
    -0.26178950f, -0.20356770f, -0.11554300f, 0.08906576f, 0.01337310f, 0.17254251f, -0.10345520f, 0.08013792f, 
    0.09568469f, 0.14195330f, -0.03214859f, 0.02167272f, -0.03100790f, -0.01906755f, -0.00081449f, -0.09738492f, 
    -0.03502643f, 0.16108744f, -0.05480628f, 0.07814125f, 0.09724999f, -0.02346472f, 0.05453463f, 0.01607799f, 
    0.00374851f, -0.17055519f, -0.13869999f, 0.16109085f, -0.05130427f, 0.00795938f, 0.13193582f, 0.04367068f, 
    -0.05804883f, 0.02848958f, -0.01367946f, 0.32111895f, 0.01823158f, -0.02594217f, 0.00834380f, 0.00365898f, 
    -0.07056411f, -0.05666567f, -0.02748245f, -0.02640981f, 0.02733150f, 0.03875750f, 0.01934618f, 0.02718787f, 
    -0.01125114f, -0.12038653f, -0.13950458f, -0.00684021f, 0.13534464f, 0.05854424f, 0.04311911f, -0.13505816f, 
    -0.12834463f, 0.03545446f, 0.00007720f, -0.00714911f, 0.05512625f, 0.07438894f, -0.09612653f, -0.05830671f, 
    0.13630043f, -0.10025144f, 0.02298502f, -0.01792581f, 0.02756799f, 0.03939755f, -0.09838481f, 0.01458750f, 
    0.17661732f, -0.16115597f, -0.31750584f, 0.09788053f, 0.08127513f, 0.06267510f, -0.04100224f, 0.05161143f, 
    -0.00299206f, 0.01937475f, 0.05125271f, 0.03890469f, -0.01405433f, -0.06143474f, 0.02957595f, -0.01909224f, 
    -0.16052993f, 0.08404330f, -0.05553378f, -0.00301544f, 0.02450383f, -0.28038710f, -0.01202596f, -0.19472060f, 
    0.04772004f, 0.06286316f, -0.03532388f, 0.00581662f, 0.02617119f, -0.18166676f, -0.10956085f, -0.08428238f, 
    -0.04532646f, 0.10475691f, -0.03902899f, -0.12929960f, -0.10140749f, -0.01173272f, -0.02969084f, -0.15132481f, 
    -0.00002813f, 0.12788863f, -0.11635222f, 0.22023165f, -0.02747306f, 0.00366425f, 0.17955442f, -0.01998823f, 
    -0.07522947f, -0.03354972f, 0.17662877f, -0.08956943f, -0.04189781f, -0.00470684f, -0.01583071f, -0.00865457f, 
    0.02607839f, -0.02690935f, -0.14463267f, -0.14250004f, -0.01121794f, -0.02118078f, -0.10819836f, -0.05580291f, 
    -0.03258269f, 0.06519742f, -0.01046893f, 0.01309839f, 0.02013249f, -0.01757617f, 0.04407940f, -0.01142122f, 
    -0.03256837f, -0.00296040f, 0.07280412f, 0.08778446f, -0.01275432f, -0.07966033f, -0.06833737f, 0.06790216f, 
    0.07779448f, 0.17046180f, 0.17917837f, 0.18614936f, 0.20210570f, -0.10608132f, 0.04529524f, 0.07594894f, 
    0.11778172f, 0.13388032f, -0.01976114f, -0.00183079f, -0.04651892f, 0.00286224f, 0.01479477f, -0.02520455f, 
    -0.03717446f, -0.06655930f, 0.03010569f, -0.19847052f, 0.21619752f, -0.17779601f, 0.03408810f, 0.07202115f, 
    -0.02605126f, -0.36723053f, -0.16413619f, 0.09442095f, -0.04346090f, -0.00072519f, -0.03679264f, 0.00153468f, 
    0.05336910f, 0.02078996f, 0.02115314f, -0.04145395f, 0.00523031f, 0.01280382f, -0.00877409f, -0.04138122f, 
    0.13479280f, -0.20992550f, -0.02011141f, 0.25392061f, 0.00912633f, -0.14032701f, -0.14748806f, 0.02625023f, 
    -0.31503239f, 0.07256503f, -0.10691743f, 0.05674280f, 0.00967878f, -0.05042578f, -0.09359897f, 0.02900705f, 
    -0.00873867f, 0.03992880f, -0.03922604f, 0.03481083f, -0.09847703f, -0.06975478f, 0.05129864f, 0.06761499f, 
    0.05905963f, -0.07135697f, -0.00358967f, -0.04163186f, -0.16218303f, -0.06741811f, -0.02613176f, 0.01036273f, 
    -0.01652649f, 0.03589018f, -0.05251699f, 0.09764642f, 0.12554745f, 0.04552145f, -0.03911129f, 0.04877198f, 
    0.16926871f, 0.08230855f, 0.08620713f, 0.09461795f, 0.15679751f, -0.12914540f, 0.02423391f, 0.00457486f, 
    -0.09349753f, 0.00381554f, -0.07299389f, 0.02305816f, -0.01626594f, 0.02324439f, 0.03808886f, -0.00258331f, 
    -0.06102959f, 0.02270687f, -0.22139858f, -0.14950147f, -0.07991347f, 0.00147864f, 0.05266156f, 0.09837859f, 
    0.10293236f, -0.01884533f, 0.02587748f, -0.01662548f, 0.03495733f, 0.04864805f, 0.01349148f, 0.03334866f, 
    -0.01355562f, -0.02275949f, -0.01108252f, 0.00745447f, -0.03841625f, -0.11267971f, -0.03796601f, -0.06699817f, 
    0.00289502f, -0.04011343f, -0.14585082f, -0.10801485f, -0.15165432f, 0.12480803f, -0.05496744f, 0.16913800f, 
    -0.07210002f, 0.09173428f, 0.03726357f, -0.05742231f, 0.08901908f, 0.00651609f, -0.00410332f, -0.18798682f, 
    0.08093227f, -0.05870838f, -0.22385344f, -0.01437193f, 0.50697863f, -0.86697721f, -0.19606692f, 0.12092724f, 
    -0.24266902f, 0.06344330f, -0.08170784f, 0.02080682f, 0.03337715f, -0.00315985f, 0.00040650f, -0.03437974f, 
    -0.09880351f, -0.00827336f, 0.06123866f, -0.04928308f, 0.00709444f, 0.04928334f, -0.15492068f, -0.04810425f, 
    0.23380409f, -0.04493509f, -0.30583188f, -0.04244751f, -0.12816016f, 0.15786280f, -0.02696570f, 0.02137582f, 
    -0.00496034f, -0.01555610f, 0.16673480f, -0.15632784f, -0.02474175f, 0.04796467f, 0.05797787f, -0.04451487f, 
    -0.14663446f, 0.03436276f, -0.24593428f, -0.01442808f, 0.37503308f, -0.96397811f, -0.32969680f, 0.23241968f, 
    -0.39731643f, 0.14181435f, -0.12105313f, 0.09377792f, -0.11526292f, 0.01819357f, 0.05938925f, -0.07105150f, 
    -0.13939272f, 0.11476477f, -0.07662090f, -0.08780306f, 0.01454489f, 0.02579286f, -0.18599631f, 0.08839133f, 
    0.03444177f, 0.09651908f, 0.10831384f, 0.33726788f, 0.22809809f, 0.11500346f, 0.15287812f, 0.15154395f, 
    0.05751180f, 0.24134958f, 0.02055948f, -0.00312422f, 0.00953236f, -0.05302669f, -0.03146626f, -0.02223033f, 
    0.00377136f, -0.08059347f, 0.16589727f, -0.00870798f, 0.00800859f, -0.02923543f, 0.15905178f, 0.14768399f, 
    0.19035855f, -0.09001292f, 0.01449130f, -0.03324981f, -0.01937569f, -0.02306774f, 0.01367046f, 0.05273760f, 
    -0.05429031f, -0.02186657f, -0.01091209f, -0.02084668f, -0.03034372f, -0.03037271f, 0.02711936f, -0.04064025f, 
    0.02390262f, -0.14353105f, 0.05759066f, -0.02550172f, -0.02054463f, -0.09599507f, -0.04065954f, -0.04784206f, 
    0.10945838f, -0.03470507f, 0.03917270f, -0.04971552f, -0.06124518f, -0.01389942f, -0.00138786f, 0.01825874f, 
    0.01578637f, 0.00011635f, -0.02994767f, -0.03090664f, 0.18230304f, 0.04267620f, -0.18867765f, 0.10903657f, 
    0.04244082f, -0.12057079f, 0.01096063f, -0.03143075f, 0.10975491f, -0.01425476f, 0.04465896f, -0.09711134f, 
    0.02087391f, 0.01883129f, 0.02055692f, 0.07912737f, 0.12628452f, -0.01165489f, -0.02920393f, 0.10602826f, 
    0.12120818f, 0.10355513f, 0.32309866f, 0.23164473f, 0.10714972f, -0.16842519f, -0.11526687f, -0.15767789f, 
    0.15450563f, 0.11939962f, 0.08789566f, 0.03747379f, 0.00438875f, 0.02200321f, 0.03227242f, 0.01545389f, 
    0.01280885f, -0.07495890f, 0.04198020f, -0.10696115f, 0.04167487f, 0.03941793f, 0.01418990f, -0.00036631f, 
    -0.01448800f, 0.08075480f, 0.09021775f, 0.04257451f, 0.04507006f, 0.01428037f, 0.02501657f, -0.07683048f, 
    0.09555215f, -0.03550493f, 0.06010217f, 0.09772514f, 0.10931876f, 0.00995197f, -0.01066389f, 0.01987496f, 
    -0.62056082f, 0.00656011f, -0.03308350f, -0.14146490f, -0.00245127f, 0.01940015f, 0.08950815f, -0.06339838f, 
    0.00861752f, 0.11728741f, -0.06700997f, 0.10320121f, 0.00075021f, 0.14871415f, 0.02959947f, -0.07593861f, 
    -0.00425329f, 0.04919016f, -0.06469183f, 0.16635312f, -0.00627932f, -0.02598730f, 0.14271168f, 0.03086809f, 
    0.09981991f, -0.05315972f, 0.08420482f, -0.10628778f, -0.00185510f, 0.05853779f, -0.03743703f, -0.01100687f, 
    0.01534826f, 0.08630928f, 0.09438022f, -0.00056174f, 0.10128085f, -0.07254701f, -0.06409873f, 0.05409826f, 
    -0.12112951f, -0.09749281f, 0.09317143f, 0.12441033f, 0.06799398f, -0.09501737f, 0.00472794f, -0.12198704f, 
    -0.10128650f, 0.01408762f, -0.00917280f, 0.01640731f, -0.08927277f, -0.12477364f, 0.00058669f, -0.07288786f, 
    -0.00975252f, 0.02506643f, 0.01600814f, 0.02981904f, 0.15807703f, -0.81393760f, -0.11271758f, 0.02159901f, 
    -0.21053313f, 0.03521764f, -0.29059714f, 0.00535467f, -0.29251686f, -0.01789611f, -0.00261761f, -0.10875066f, 
    0.06543607f, -0.12735519f, -0.22491428f, -0.06587067f, -0.12597519f, 0.04524223f, -0.06625170f, -0.02240509f, 
    -0.05043786f, -0.11784770f, 0.11104442f, 0.13883108f, 0.15725480f, -0.13061102f, -0.02084893f, -0.16646297f, 
    -0.18842331f, -0.09995996f, -0.03384740f, 0.02621032f, -0.01257219f, -0.01828845f, -0.11579264f, -0.05765818f, 
    0.01717766f, 0.08568668f, -0.02272242f, 0.02793322f, 0.03176163f, -0.13164601f, 0.04361134f, -0.09540579f, 
    -0.02597069f, -0.10541052f, -0.08888381f, -0.05583549f, 0.04963708f, -0.17607428f, 0.00552939f, -0.06799049f, 
    0.03758432f, -0.09457828f, -0.01150495f, 0.03693524f, 0.02615979f, -0.10079587f, 0.14180896f, 0.11935321f, 
    0.09977303f, 0.05197300f, -0.02280541f, 0.16964227f, 0.26326621f, 0.07546993f, 0.03744060f, 0.05760480f, 
    0.02638167f, 0.07878207f, 0.04867062f, 0.07489823f, -0.01568272f, -0.00567771f, 0.06299424f, -0.01709764f, 
    -0.02267094f, -0.04811365f, 0.04206507f, 0.00027921f, 0.12930675f, -0.12599926f, 0.13884333f, -0.15405920f, 
    0.12249625f, 0.03003862f, -0.01670223f, 0.09483396f, -0.02794807f, -0.18153663f, 0.09699685f, 0.09281892f, 
    -0.04157241f, -0.11910310f, 0.00704445f, 0.01258734f, -0.03225821f, -0.17522860f, -0.09750649f, -0.13825519f, 
    -0.00392810f, -0.03617681f, -0.03673987f, -0.04053893f, -0.00788250f, 0.05425986f, 0.03209174f, 0.08862431f, 
    -0.04479022f, 0.04000993f, 0.02212374f, 0.05238530f, 0.02669230f, -0.02661706f, 0.05312811f, 0.08932128f, 
    -0.03253773f, -0.00645211f, -0.06553993f, 0.03767879f, 0.03992026f, 0.10188518f, -0.13467170f, -0.06673441f, 
    0.22896186f, -0.02776019f, 0.01940808f, 0.05987176f, 0.08683868f, 0.08188336f, 0.03934865f, 0.00775214f, 
    -0.01721199f, -0.01291010f, 0.01595174f, 0.02604770f, 0.09370561f, -0.03558428f, 0.03237005f, 0.14828475f, 
    0.11599163f, 0.17761196f, 0.15897384f, -0.00421406f, -0.05641536f, 0.03905711f, -0.05606539f, -0.05698973f, 
    -0.08596767f, 0.19473495f, 0.18356124f, 0.05940445f, 0.04951632f, 0.06954189f, 0.06275479f, 0.04091588f, 
    -0.01600142f, -0.05299578f, -0.05040567f, -0.10577825f, -0.12441617f, 0.12911412f, -0.06963518f, -0.17162852f, 
    -0.07911945f, 0.10999922f, -0.01929043f, 0.00637606f, 0.06592371f, 0.03933465f, -0.00047914f, -0.08821652f, 
    -0.04452787f, -0.07883940f, 0.09109895f, -0.03874952f, -0.10602701f, -0.05045447f, -0.15241027f, 0.07701356f, 
    0.07359585f, -0.07181378f, 0.00958814f, -0.02176833f, -0.03020315f, -0.02649775f, -0.07165710f, -0.02694108f, 
    0.00252112f, 0.00129096f, 0.09145346f, -0.07793158f, -0.04066335f, 0.02557552f, 0.00022831f, 0.08727169f, 
    0.01921421f, 0.01932052f, -0.08462485f, 0.02399699f, -0.03623113f, -0.15160607f, -0.01789400f, 0.12145832f, 
    -0.01430935f, -0.12034601f, -0.10253120f, 0.05205942f, -0.08536269f, -0.01180505f, -0.02533930f, 0.02175560f, 
    0.04074401f, -0.02415302f, 0.07731720f, -0.01781178f, -0.16040990f, -0.04547610f, 0.01234832f, -0.09839773f, 
    0.13525444f, -0.05818157f, 0.18884236f, 0.07984961f, 0.03886496f, -0.11061315f, -0.05848268f, -0.09562863f, 
    -0.05125064f, 0.07605135f, 0.04924575f, 0.00783065f, -0.02898345f, -0.03847418f, -0.00713304f, 0.06709402f, 
    0.03891812f, 0.04086081f, -0.02784373f, -0.05875049f, 0.10638043f, 0.06126757f, -0.03082867f, -0.05371001f, 
    -0.01614012f, 0.04082773f, -0.02335845f, 0.05553224f, 0.05636792f, 0.02523281f, -0.01948052f, -0.07462456f, 
    0.06744925f, -0.04972425f, 0.02071913f, 0.04772221f, 0.05363612f, 0.04512640f, -0.03399029f, 0.05823464f, 
    0.30835488f, -0.07622750f, -0.03923437f, -0.00209700f, -0.23038143f, 0.11605550f, -0.01833365f, 0.04064320f, 
    0.05661847f, 0.02081065f, -0.03758204f, -0.11921016f, 0.03849124f, -0.18525879f, 0.16601183f, -0.05846472f, 
    -0.00955634f, 0.10708047f, -0.20602202f, -0.08826234f, 0.07093088f, 0.04996011f, 0.05775911f, -0.02662372f, 
    -0.03204915f, 0.05072696f, 0.05269038f, 0.02545735f, 0.03669119f, 0.06887361f, 0.06151673f, 0.11839801f, 
    -0.07335939f, 0.00296529f, -0.02936324f, 0.03548091f, 0.03358380f, 0.01604595f, -0.00781391f, 0.08818618f, 
    -0.15941431f, 0.06619466f, 0.06854101f, -0.07480302f, 0.01279390f, -0.10874007f, -0.07757869f, 0.00431544f, 
    0.02218692f, 0.04339248f, 0.06244958f, -0.00607952f, -0.00299891f, 0.03052815f, -0.03915012f, -0.04143561f, 
    0.12792645f, 0.07313763f, 0.05945080f, 0.25638071f, 0.04236558f, 0.01471253f, -0.01164351f, 0.00414132f, 
    0.06774134f, 0.14946130f, 0.15818414f, -0.03459717f, -0.00877579f, 0.03725483f, 0.12787804f, 0.00566651f, 
    -0.02325150f, 0.03477490f, 0.07232412f, -0.00597228f, -0.00177850f, -0.04784447f, -0.02608343f, 0.01424725f, 
    0.09504806f, -0.03749593f, 0.11673597f, -0.10822169f, 0.08165967f, 0.13431098f, -0.01018469f, 0.05076385f, 
    -0.05597568f, 0.04182040f, -0.00107272f, 0.05707827f, 0.00103531f, 0.04568210f, 0.02501210f, 0.02496254f, 
    -0.08181450f, -0.09606728f, -0.15882529f, -0.26027086f, -0.28053555f, -0.27778071f, -0.09877646f, -0.42645332f, 
    -0.30279449f, 0.07902796f, -0.00757026f, 0.02132674f, 0.06502287f, 0.07483122f, -0.00126307f, -0.15707661f, 
    -0.02754468f, -0.13465697f, -0.00481968f, -0.17342880f, -0.17707342f, -0.05210480f, -0.18080428f, 0.03494887f, 
    -0.10427266f, -0.14102086f, -0.05919551f, 0.16722770f, -0.16281749f, -0.14191516f, -0.11330371f, 0.01794180f, 
    -0.10676063f, 0.01505862f, 0.03267958f, -0.06792699f, 0.05864394f, 0.04907195f, -0.05286894f, 0.07671288f, 
    -0.06219573f, -0.01528016f, 0.14966597f, 0.02512547f, 0.18135689f, -0.12066879f, 0.24183086f, -0.03868229f, 
    0.01746233f, -0.01845385f, -0.03533838f, 0.00859580f, -0.18980494f, -0.00127467f, -0.02293173f, -0.15756840f, 
    0.09032664f, 0.00870610f, 0.01777279f, 0.02580985f, 0.00173472f, -0.00201495f, -0.02408678f, -0.13335894f, 
    0.20331644f, 0.19900872f, 0.32645604f, 0.23801635f, 0.15308422f, -0.12862545f, -0.11372480f, -0.08569450f, 
    -0.05628449f, 0.20470932f, 0.01046916f, 0.04538338f, 0.04930118f, 0.03782513f, 0.04334658f, 0.01359595f, 
    -0.02802354f, -0.00446282f, -0.03639967f, -0.13509698f, 0.08009315f, -0.04829117f, 0.19245321f, 0.11726306f, 
    -0.04876338f, -0.13569865f, -0.07568951f, -0.02559248f, -0.00186572f, -0.16505378f, 0.01527290f, -0.07661340f, 
    -0.01477971f, 0.02786779f, -0.02572091f, -0.06386062f, -0.02304779f, -0.07162210f, -0.06299876f, -0.09938190f, 
    0.20512979f, 0.01675526f, 0.00836021f, -0.19811718f, -0.09340934f, -0.02458858f, -0.06024810f, 0.03282276f, 
    0.14302562f, -0.04451787f, -0.01317220f, -0.02946587f, 0.05703567f, -0.09226798f, -0.28388113f, -0.00119954f, 
    0.06047011f, -0.04364940f, -0.16809145f, 0.04429903f, 0.03670811f, 0.01776141f, 0.13110428f, 0.03584389f, 
    0.05990243f, 0.11589044f, 0.02864730f, -0.01248181f, -0.01563659f, 0.06759172f, 0.05160823f, 0.08211894f, 
    0.04204519f, -0.01584124f, 0.04980275f, 0.07883880f, -0.04747021f, -0.06324620f, -0.13807833f, -0.23242730f, 
    -0.08498778f, -0.12178489f, -0.03362579f, -0.11795206f, -0.03766542f, 0.00372631f, 0.00926216f, 0.06790869f, 
    -0.06659597f, -0.03151153f, -0.05408399f, -0.13857582f, 0.01039273f, 0.13746712f, -0.07125502f, 0.05054051f, 
    0.06747209f, -0.14590745f, -0.12732853f, -0.03272455f, -0.14275432f, -0.07926025f, 0.04132488f, -0.07768741f, 
    0.04365721f, -0.15248354f, -0.16683823f, 0.00725766f, -0.04527574f, 0.10530822f, 0.05092116f, -0.00600741f, 
    0.02031287f, -0.08976957f, -0.03685139f, -0.04128651f, -0.06297246f, -0.02281593f, -0.06109453f, 0.00517701f, 
    -0.00039238f, -0.01927051f, -0.00095338f, -0.11493009f, -0.00777764f, 0.04060284f, 0.00435297f, -0.03360867f, 
    0.03477008f, -0.06831396f, 0.06279216f, 0.00515333f, -0.07463316f, 0.02809638f, 0.04417427f, -0.11054074f, 
    0.01314688f, 0.01081857f, -0.03858584f, -0.15108514f, -0.00939015f, 0.00084084f, 0.04924151f, 0.20044981f, 
    0.08316778f, -0.01727638f, 0.05524588f, 0.04250225f, 0.03960259f, 0.09935170f, -0.01420004f, -0.03161811f, 
    0.00525824f, 0.02637424f, -0.03257267f, 0.07709833f, 0.06444780f, -0.14459123f, 0.11172540f, 0.22262479f, 
    0.08942075f, -0.27969944f, 0.08362325f, -0.10974646f, -0.08924409f, -0.12942185f, -0.09895338f, -0.00036405f, 
    0.12898295f, 0.25161201f, 0.06586395f, 0.04187122f, -0.01071046f, -0.13244975f, -0.08066902f, 0.03234345f, 
    0.03753889f, 0.07293947f, -0.02346005f, 0.06216845f, 0.09662893f, 0.05475288f, -0.07885797f, 0.03138191f, 
    -0.08022724f, 0.13620213f, -0.09102962f, -0.05157666f, -0.07084987f, -0.05516886f, 0.09605044f, -0.06760105f, 
    0.01219194f, -0.09755441f, 0.04834650f, 0.05936336f, -0.14898291f, 0.01650879f, -0.19651741f, -0.25657925f, 
    -0.02194723f, -0.21087149f, 0.03845632f, -0.24510959f, -0.00518154f, -0.09103755f, 0.01353444f, 0.05515356f, 
    -0.07943738f, -0.19871409f, 0.02772504f, -0.06361872f, -0.01101309f, -0.07158212f, -0.00524770f, 0.07225399f, 
    -0.04688069f, -0.04818493f, -0.09209526f, -0.11597255f, -0.10558884f, -0.06755511f, -0.09362577f, 0.30199414f, 
    -0.13622443f, -0.13803868f, -0.05528233f, -0.01882635f, -0.09283957f, -0.04338889f, -0.06521961f, -0.05691177f, 
    -0.04200879f, 0.03580591f, -0.06963391f, 0.08898489f, 0.00190504f, -0.15314259f, 0.04766795f, 0.16374613f, 
    0.02117113f, -0.10611705f, 0.17362610f, -0.24278755f, 0.25587285f, -0.01936650f, 0.23370925f, 0.17082360f, 
    0.15314528f, 0.06569317f, 0.06184035f, -0.00939698f, -0.02718266f, -0.12291120f, -0.02113313f, 0.03397189f, 
    -0.18656942f, -0.05202761f, -0.03538289f, -0.11810831f, 0.01459111f, -0.05722639f, -0.14386322f, -0.00864068f, 
    0.07973096f, 0.02478568f, 0.05451687f, 0.00125890f, -0.00219672f, 0.00504393f, 0.05920917f, 0.02949863f, 
    -0.00784136f, -0.01202365f, 0.02336111f, -0.06347211f, 0.02365294f, -0.03789363f, -0.01415812f, 0.04691337f, 
    0.01342103f, 0.07684714f, 0.14879274f, -0.12784526f, 0.06348114f, 0.05396471f, 0.15817954f, -0.05259885f, 
    0.02368674f, 0.00324128f, 0.00399343f, -0.02086500f, 0.00354173f, 0.03930551f, -0.02485942f, -0.00457823f, 
    0.11508348f, -0.05550248f, 0.04926450f, 0.11677147f, 0.06599411f, 0.11013503f, 0.17793904f, 0.23611589f, 
    0.18850994f, -0.10491898f, -0.04522131f, -0.06464268f, 0.00864168f, 0.06116985f, -0.01174736f, 0.00973027f, 
    -0.01274762f, 0.04608866f, 0.02570063f, -0.01099091f, -0.01399935f, -0.09370032f, -0.13638589f, -0.17684770f, 
    0.12058803f, -0.05882478f, 0.03914336f, -0.10988660f, -0.05167809f, 0.08716127f, 0.01417453f, 0.11811961f, 
    -0.01184146f, -0.02311155f, 0.13839945f, 0.02547764f, -0.06476846f, -0.06415652f, -0.08337170f, 0.01923510f, 
    0.05568060f, -0.22953920f, -0.18693592f, 0.02001824f, 0.05626590f, 0.00347657f, 0.01401895f, 0.12912582f, 
    0.02156203f, 0.08222185f, 0.00578071f, -0.12369811f, -0.08429316f, -0.03028050f, -0.09030045f, 0.00069809f, 
    -0.11827018f, 0.06316461f, 0.07152588f, -0.02011151f, -0.03602130f, 0.03492447f, -0.15831269f, -0.18187462f, 
    0.01617882f, -0.11119934f, 0.29698333f, 0.11661192f, -0.41142571f, 0.00016915f, 0.03745403f, 0.11171276f, 
    -0.06644993f, 0.08254018f, 0.06096688f, 0.02111603f, -0.04504035f, -0.02807151f, 0.10145830f, -0.00777981f, 
    -0.03047325f, 0.04921524f, -0.03040830f, 0.09457860f, -0.04503341f, 0.03704074f, -0.31262788f, -0.07410997f, 
    0.00789798f, -0.01133846f, -0.03608990f, -0.05414784f, -0.08403971f, 0.04308745f, 0.04585652f, 0.09071327f, 
    0.00474475f, 0.05976789f, 0.04132305f, -0.08052816f, -0.09855408f, 0.13919583f, 0.03992338f, 0.11072785f, 
    -0.18136773f, -0.03618871f, -0.17640951f, 0.22285907f, 0.08838953f, -0.01232940f, -0.01117770f, -0.00259951f, 
    0.01031549f, -0.03717016f, 0.03701580f, 0.02139902f, 0.05399151f, 0.06981730f, -0.04621625f, 0.16088784f, 
    -0.13642956f, -0.03616115f, 0.06926663f, -0.10739084f, 0.29129350f, -0.34623337f, 0.04858034f, -0.03609883f, 
    -0.11027928f, 0.13844265f, -0.18950197f, -0.11279352f, 0.10303876f, 0.20459835f, 0.14380939f, 0.31867987f, 
    -0.06334030f, -0.01270177f, -0.02679699f, 0.10356970f, -0.02420387f, -0.08562571f, -0.05320857f, 0.35920084f, 
    -0.54625082f, 0.03056343f, -0.16720699f, 0.29889414f, -0.01702393f, 0.18182507f, -0.28822717f, 0.13842028f, 
    0.01701579f, -0.01427012f, -0.08821512f, 0.08364353f, 0.03924676f, 0.05596438f, 0.04886929f, 0.09328882f, 
    -0.01684472f, 0.25316224f, -0.08596142f, 0.00137354f, -0.08730726f, -0.14673090f, -0.17499483f, 0.03988123f, 
    0.10446774f, 0.08779884f, -0.05142142f, -0.03394663f, 0.01235312f, 0.01562866f, -0.05809321f, 0.02022424f, 
    0.00367472f, 0.10315999f, 0.08943938f, 0.06500721f, 0.04192722f, 0.13498846f, 0.05643215f, -0.10575701f, 
    0.09561861f, -0.00826891f, 0.29928184f, -0.03633140f, -0.21642259f, 0.09063014f, 0.10604034f, -0.04332140f, 
    -0.04983310f, -0.07480917f, 0.09274995f, 0.04113486f, 0.03626926f, -0.01167545f, 0.00716608f, -0.00398351f, 
    0.05810243f, -0.07229552f, -0.01645594f, 0.18079925f, -0.28760356f, -0.16811250f, -0.13815261f, -0.09442189f, 
    -0.28887632f, 0.06905390f, -0.06120242f, -0.15374258f, -0.12032918f, 0.21512397f, -0.02125441f, 0.16848595f, 
    -0.12380175f, 0.01777025f, -0.08651702f, -0.05303120f, -0.09322003f, -0.02069588f, 0.01960398f, 0.15829939f, 
    -0.54460239f, -0.07289509f, -0.01710133f, -0.14372282f, -0.29146001f, -0.05176886f, 0.23262699f, -0.02278480f, 
    -0.12002899f, 0.04089642f, 0.07800440f, -0.00964634f, -0.06246399f, 0.04755251f, 0.11647648f, -0.04461755f, 
    -0.02271947f, 0.01279030f, 0.00968538f, 0.03305189f, -0.17175241f, 0.00326404f, 0.16075265f, 0.02540214f, 
    -0.07764571f, -0.00704110f, -0.00339155f, 0.06994723f, 0.06502143f, -0.12490121f, 0.00273267f, 0.00444431f, 
    0.04235427f, 0.00746650f, 0.04502065f, -0.00243136f, -0.03110776f, -0.18008345f, -0.08136787f, -0.18954292f, 
    -0.05509972f, -0.01943105f, 0.24072495f, -0.06217888f, -0.07636916f, 0.03781852f, -0.01007469f, -0.18369880f, 
    0.04983356f, 0.01561712f, 0.08735102f, 0.05520397f, -0.03457599f, -0.02556460f, 0.02005409f, 0.02864703f, 
    0.04625196f, -0.00452832f, 0.19815049f, 0.30761296f, -0.03698089f, 0.03914570f, -0.00302567f, -0.00869940f, 
    -0.03482135f, -0.10509098f, -0.04772514f, 0.08560511f, -0.10858901f, 0.01981768f, -0.01782361f, -0.00435006f, 
    -0.05683123f, -0.11051285f, 0.02116085f, 0.01871826f, 0.08621414f, 0.05768762f, -0.11284207f, 0.03508690f, 
    0.33532128f, 0.24050669f, 0.01362586f, -0.33833954f, 0.36500922f, 0.15444860f, -0.06002547f, 0.01949708f, 
    -0.36184075f, -0.09866623f, 0.00887648f, -0.05473572f, -0.17845678f, 0.03148656f, 0.03858189f, 0.06254820f, 
    -0.03595397f, 0.18427287f, -0.05919784f, -0.12259592f, -0.49410218f, 0.32041407f, 0.12279891f, -0.23226716f, 
    0.07590425f, 0.01932677f, -0.05603607f, -0.23246215f, 0.04870954f, -0.02639500f, 0.15941113f, -0.10564242f, 
    -0.01384766f, 0.02739117f, -0.06286503f, -0.11536577f, -0.08680795f, 0.01727560f, 0.04003529f, 0.00517099f, 
    -0.69527078f, 0.53893560f, -0.18771145f, 0.38199306f, -0.01560570f, 0.00303148f, -0.16605839f, -0.08990405f, 
    0.09336579f, -0.00707298f, -0.14570305f, 0.08738694f, -0.07626447f, 0.03062348f, -0.05704302f, 0.04643589f, 
    0.02136067f, 0.12204181f, -0.03538163f, -0.16871016f, -0.92806351f, 0.39157778f, 0.31890148f, -0.23109719f, 
    -0.16286294f, -0.02490050f, -0.06988030f, -0.07656232f, 0.14746776f, -0.07571309f, 0.00639112f, -0.16674368f, 
    -0.14339429f, -0.10436076f, -0.20598890f, -0.01410020f, -0.01241451f, -0.08751691f, 0.05748148f, -0.17099889f, 
    0.13869908f, 0.13737488f, 0.14977725f, 0.11552605f, -0.12078921f, -0.07007176f, -0.03210651f, 0.09855988f, 
    -0.06592768f, -0.03012669f, 0.03902247f, 0.03926750f, -0.06032063f, -0.04238000f, -0.00967589f, 0.03171863f, 
    0.01829518f, 0.09262098f, -0.17472403f, -0.05454029f, -0.15846615f, 0.00536154f, -0.17652312f, 0.05731646f, 
    -0.19923890f, 0.01797207f, 0.06039293f, 0.03776948f, 0.06794252f, 0.03166997f, 0.07996757f, -0.04430489f, 
    -0.01365031f, 0.05888087f, -0.04230000f, -0.10191671f, -0.01616787f, 0.04357368f, 0.00165205f, 0.01024318f, 
    0.09822884f, -0.25087234f, -0.23041055f, -0.06838815f, 0.01672437f, 0.07081955f, -0.02720792f, -0.07748858f, 
    0.05297747f, -0.01165072f, -0.08438732f, 0.22072922f, -0.01056280f, 0.02480752f, -0.00098472f, -0.00679308f, 
    -0.03097041f, 0.03359926f, 0.00429963f, 0.10569114f, 0.00929538f, -0.24474686f, 0.00136158f, 0.09110598f, 
    -0.18182155f, 0.10968784f, -0.06347095f, -0.15490431f, -0.14124674f, 0.26589528f, 0.02918468f, 0.10894384f, 
    0.04093814f, -0.00770030f, -0.04616968f, -0.12796435f, -0.29457086f, -0.07302334f, 0.01262330f, 0.01047223f, 
    0.11642296f, -0.06171527f, 0.05829672f, 0.01801364f, -0.17238072f, 0.05638101f, 0.24705730f, -0.00759734f, 
    0.10350373f, 0.03147813f, 0.04073852f, -0.01755495f, -0.02190747f, 0.08341496f, -0.00181494f, -0.01423423f, 
    0.03805882f, 0.00585599f, 0.21671940f, 0.15258972f, 0.01077156f, 0.07384771f, 0.00360678f, 0.02671904f, 
    0.01115926f, 0.06220677f, -0.01202164f, -0.02739051f, -0.03417585f, 0.01414252f, -0.00687648f, 0.06635895f, 
    -0.01566186f, 0.06431768f, 0.16249229f, 0.03495032f, 0.06311618f, 0.07398053f, 0.05195572f, -0.04029758f, 
    -0.15223771f, -0.01575036f, -0.15209179f, -0.27610987f, 0.19444071f, -0.00688296f, 0.01555447f, -0.02793670f, 
    -0.03473074f, -0.03410779f, 0.06269645f, -0.09334710f, -0.10027321f, -0.15609734f, 0.12612487f, -0.31377205f, 
    -0.13652124f, 0.03083732f, 0.01562470f, -0.21396737f, 0.25079772f, -0.02817624f, 0.22895445f, 0.11792897f, 
    -0.20174013f, 0.06937720f, -0.04667639f, 0.02214895f, 0.13080642f, 0.05003679f, 0.08498173f, 0.03115398f, 
    0.00728669f, 0.14024667f, -0.06773885f, 0.04821231f, 0.01539976f, -0.20181896f, -0.07480972f, -0.16947082f, 
    -0.14839637f, 0.01517207f, -0.08833411f, -0.01349160f, -0.11335029f, 0.05403107f, -0.03747239f, -0.04565816f, 
    -0.11103002f, -0.08130774f, -0.01749994f, -0.04702736f, 0.05399593f, 0.01683208f, 0.07800487f, -0.13349830f, 
    -0.14563563f, -0.04040160f, 0.01990920f, -0.07130040f, -0.63137776f, -0.26741830f, 0.10233972f, -0.02318252f, 
    -0.37612405f, -0.04637300f, -0.24783696f, -0.26685151f, 0.12259486f, -0.00472412f, 0.08407693f, 0.08657327f, 
    0.03330139f, -0.05517176f, 0.00669311f, 0.10158024f, 0.05750883f, -0.09196252f, 0.09098557f, 0.15671599f, 
    -0.47337914f, 0.07308676f, -0.11974873f, -0.28030995f, -0.17078470f, -0.05291870f, -0.01249575f, 0.05082589f, 
    -0.18609767f, 0.08032080f, 0.00673277f, 0.00460724f, -0.02308396f, 0.05044594f, -0.01895451f, -0.09330340f, 
    -0.09415710f, 0.04291071f, -0.01405078f, -0.12472197f, 0.61835039f, -0.10045616f, 0.24286471f, -0.00291706f, 
    -0.21265621f, -0.01463307f, 0.07673360f, 0.15302318f, -0.06241727f, 0.03594114f, 0.05423081f, -0.03093967f, 
    0.01224930f, -0.01397713f, 0.02019488f, -0.09998555f, -0.12952915f, 0.02833188f, 0.15203571f, -0.07677948f, 
    -0.27360997f, -0.10395834f, -0.15369903f, 0.04733161f, 0.13068515f, 0.06858178f, 0.08368620f, -0.00101274f, 
    -0.01252177f, 0.04009456f, 0.08342814f, 0.01271357f, 0.03159977f, -0.00071813f, -0.04320002f, -0.02986757f, 
    0.00913913f, 0.11067252f, -0.03578085f, -0.05468061f, 0.11525184f, -0.10209743f, 0.03398911f, -0.06060732f, 
    -0.16114558f, 0.15471220f, 0.01105238f, 0.16000333f, -0.12124445f, 0.04995400f, 0.09342010f, -0.10637472f, 
    0.00494477f, -0.09058364f, 0.07989930f, -0.08879742f, -0.00304502f, 0.04284423f, 0.07449379f, 0.00016303f, 
    0.01956982f, -0.01780062f, -0.18971871f, 0.05273524f, 0.11616914f, 0.00161252f, 0.04337746f, -0.02638037f, 
    -0.02155077f, -0.00139478f, 0.09727200f, -0.04747147f, 0.09018762f, 0.00255832f, -0.04240613f, 0.18311669f, 
    -0.09791271f, 0.05344050f, 0.01571330f, -0.06425337f, -0.03872237f, -0.10734718f, -0.25882441f, -0.11028946f, 
    -0.01005382f, 0.15443398f, 0.05230152f, -0.04375323f, 0.02113884f, 0.02697154f, 0.00370870f, 0.02241302f, 
    0.02619012f, 0.00303252f, -0.00831314f, -0.06184826f, -0.11591068f, 0.09621946f, 0.02258614f, -0.07680672f, 
    0.06001056f, 0.01140342f, 0.09813961f, -0.30417797f, -0.06337803f, -0.10706706f, -0.04876662f, 0.13807701f, 
    -0.01589894f, -0.11771249f, 0.12157532f, -0.09623711f, -0.02204953f, -0.06879913f, -0.01769061f, 0.03282514f, 
    0.07681165f, 0.01052535f, 0.03079550f, 0.11333506f, -0.15827863f, -0.38752580f, -0.12628490f, 0.15241285f, 
    0.13243094f, 0.05339441f, -0.13693285f, -0.05413010f, 0.01019712f, 0.06502708f, -0.00777136f, -0.03556002f, 
    0.11108994f, 0.01099599f, 0.07962679f, 0.01764413f, 0.06760640f, -0.00899301f, 0.07131645f, -0.19347815f, 
    -0.28301162f, 0.18120024f, -0.09655313f, -0.11623228f, -0.01860299f, -0.00818380f, 0.01945815f, 0.00033234f, 
    0.02548770f, 0.02360780f, 0.20313446f, 0.02614094f, 0.07016458f, -0.10162936f, -0.02637271f, -0.05899144f, 
    -0.00416383f, 0.08156582f, 0.13114461f, 0.04430228f, 0.00168528f, -0.17392050f, 0.08489683f, 0.20412393f, 
    -0.10750861f, 0.02547119f, 0.06207477f, -0.11347481f, -0.05078290f, 0.11338598f, 0.06679041f, -0.11238796f, 
    0.07793270f, -0.05365183f, 0.03509033f, 0.05100927f, 0.01806884f, -0.00632471f, 0.11005919f, 0.06604721f, 
    -0.49266684f, 0.08973680f, -0.20640931f, -0.28862017f, -0.09059592f, 0.01747920f, 0.05955537f, -0.02773521f, 
    -0.00670323f, 0.09092975f, 0.02104362f, 0.03223697f, -0.07590868f, -0.03450903f, -0.09401765f, -0.05995341f, 
    -0.01595101f, 0.04355159f, -0.01006246f, 0.05638671f, -0.11451507f, -0.02767568f, -0.23565736f, -0.00158425f, 
    0.04137028f, 0.04498392f, 0.01815703f, -0.13620616f, 0.01819472f, 0.04300368f, 0.08361413f, 0.06277850f, 
    -0.02991890f, 0.21190621f, 0.03137325f, -0.03408051f, 0.08366031f, 0.13386214f, 0.10885331f, -0.03567585f, 
    -0.10984370f, 0.40551832f, -0.37393323f, 0.13420157f, 0.07981699f, -0.06752649f, -0.05140935f, -0.12657009f, 
    -0.03649662f, 0.08040064f, 0.10810616f, 0.00756539f, 0.11439851f, 0.07644778f, -0.23753086f, -0.01144874f, 
    -0.08630300f, 0.04935525f, 0.18860328f, 0.10137334f, -0.08453178f, -0.04976419f, -0.03956029f, 0.00615586f, 
    0.05892545f, 0.02557804f, 0.03524267f, -0.08900811f, -0.00766902f, 0.03210852f, 0.00438566f, -0.03231459f, 
    0.04110372f, -0.03118759f, 0.16604581f, -0.11095080f, 0.10136437f, 0.11262106f, 0.17502880f, -0.06922322f, 
    0.17732561f, 0.10084522f, 0.15894453f, -0.13259073f, 0.27076009f, 0.04014039f, 0.09810816f, 0.00653342f, 
    -0.00178105f, -0.03205239f, 0.03980028f, 0.05715970f, 0.08917828f, 0.00067049f, -0.06611433f, -0.03255202f, 
    -0.11358991f, -0.39486620f, -0.14300707f, -0.47066036f, -0.05296307f, 0.03290785f, -0.04284736f, 0.04919845f, 
    0.06258631f, 0.13933067f, -0.14688544f, 0.00564769f, 0.02879411f, 0.00921618f, -0.11194345f, 0.01568798f, 
    -0.00289820f, -0.01828640f, -0.01451508f, 0.11542886f, 0.06627638f, 0.15086253f, -0.10903418f, -0.01076989f, 
    0.09541609f, -0.06994795f, 0.01888257f, -0.01648740f, -0.03244084f, -0.15096292f, 0.03515413f, -0.03719775f, 
    0.02776819f, -0.01950843f, -0.10111173f, -0.17479798f, -0.02655541f, -0.08343604f, -0.08176405f, 0.03059858f, 
    0.08073468f, -0.05012647f, -0.01094416f, 0.21008140f, 0.17103149f, -0.19396514f, -0.05936694f, 0.16823357f, 
    0.03927927f, -0.01242078f, -0.01893746f, -0.00278735f, -0.01211730f, -0.01422420f, -0.01626601f, 0.03233402f, 
    -0.14947976f, 0.01899711f, 0.04133423f, -0.10287532f, 0.00636421f, 0.05311742f, 0.00429074f, 0.12162291f, 
    0.16495916f, -0.14875926f, 0.10417862f, 0.18659826f, -0.29952180f, 0.05718816f, -0.07264006f, -0.06398313f, 
    -0.14190073f, 0.08050726f, 0.05806669f, 0.04284681f, 0.04487674f, -0.03504074f, 0.09298924f, -0.10097740f, 
    -0.07646710f, 0.01550214f, -0.15226068f, -0.09685706f, -0.05609471f, -0.04679970f, -0.01677070f, -0.16760312f, 
    -0.07210128f, 0.07121857f, -0.00678640f, -0.00850097f, 0.01864069f, 0.07963797f, -0.16480553f, 0.00681727f, 
    -0.03494263f, -0.02505176f, -0.11105030f, 0.01967635f, 0.06234640f, 0.06558512f, 0.00801313f, 0.04490114f, 
    -0.07462226f, -0.11572711f, 0.16163912f, -0.27123848f, -0.21543191f, 0.17147213f, 0.09851480f, 0.09801093f, 
    -0.15941024f, -0.20668820f, 0.10393690f, -0.00501135f, -0.01267219f, -0.03916316f, -0.01936049f, -0.00343866f, 
    0.03683791f, -0.03114732f, 0.11359470f, 0.13268910f, -0.15022880f, 0.06507149f, 0.12422114f, -0.06321564f, 
    -0.07686719f, 0.11398298f, 0.00517517f, -0.07839938f, -0.00609437f, 0.20956914f, 0.04247269f, 0.03188735f, 
    -0.05753522f, 0.10222194f, 0.05560046f, 0.04870211f, -0.16467720f, 0.00387564f, 0.12288226f, 0.13364340f, 
    -0.37093860f, 0.44060299f, -0.40386829f, -0.01255017f, 0.23801155f, -0.01475143f, -0.03353759f, -0.31661156f, 
    -0.05140287f, 0.17219587f, 0.10225336f, -0.02591400f, 0.06351458f, 0.14917295f, 0.16141579f, -0.08312663f, 
    0.03423542f, 0.02347665f, -0.02906664f, 0.00453488f, 0.10786058f, 0.07664030f, 0.06706251f, -0.04378746f, 
    -0.09894542f, -0.08244213f, -0.07453632f, 0.01754778f, -0.17303841f, -0.02515124f, -0.21615274f, -0.09966469f, 
    0.07259431f, -0.03560070f, -0.04520810f, -0.02056488f, 0.09025197f, 0.00038859f, 0.05266768f, 0.11493224f, 
    -0.10249900f, -0.03198170f, -0.25178567f, -0.23595509f, 0.07782391f, 0.09095195f, 0.08407374f, 0.09347441f, 
    -0.14700542f, 0.04307843f, 0.04881793f, -0.03726659f, 0.06124835f, -0.12409576f, -0.06122161f, 0.01264239f, 
    0.03608020f, 0.04046022f, 0.01529565f, -0.04145759f, -0.25362951f, -0.05159254f, -0.16536692f, 0.11636682f, 
    -0.16772078f, 0.11860468f, -0.05753941f, -0.01908229f, 0.14061365f, -0.14177507f, 0.04066149f, 0.01534027f, 
    -0.09469943f, 0.08761770f, 0.28101242f, -0.01409600f, 0.03650974f, 0.02315026f, -0.08254316f, -0.00599272f, 
    -0.02821057f, -0.12460191f, -0.16367978f, -0.09643263f, 0.24058089f, 0.00816640f, 0.03131436f, 0.02290878f, 
    -0.07017790f, 0.07097475f, 0.11568990f, -0.07610515f, 0.05787447f, 0.02616279f, 0.07030262f, 0.03815250f, 
    0.02302509f, 0.19791175f, -0.06172351f, -0.01772190f, -0.02842130f, 0.02740947f, 0.31217808f, 0.16556814f, 
    -0.28696710f, -0.08762638f, -0.00880603f, 0.06844586f, 0.07402845f, -0.09819050f, 0.02861740f, 0.04783389f, 
    0.00246100f, 0.01123143f, -0.01748326f, 0.01815485f, 0.08996743f, -0.21531239f, -0.33688807f, -0.26708755f, 
    -0.25884780f, 0.72758925f, -0.87504029f, -0.09278817f, 0.00701233f, -0.07265694f, -0.06396188f, -0.01238668f, 
    -0.03228385f, -0.01298619f, 0.09138865f, 0.02762564f, -0.09853089f, 0.06213588f, -0.00660321f, -0.09580460f, 
    -0.01973335f, 0.19679405f, -0.04714848f, -0.07303062f, -0.17008829f, -0.02940428f, 0.02717167f, 0.12474090f, 
    0.01893943f, -0.13274813f, -0.00863563f, 0.10429346f, 0.16609915f, -0.11656006f, -0.00778209f, 0.03862973f, 
    -0.01001845f, -0.06594809f, 0.04367241f, 0.18444826f, -0.09141663f, 0.03105961f, 0.06313328f, 0.21539211f, 
    0.14873734f, -0.12774070f, -0.18465255f, 0.01542319f, 0.00739279f, 0.07484560f, -0.20600705f, -0.10871764f, 
    0.02335414f, 0.14749543f, 0.06111429f, -0.06159091f, -0.02864865f, -0.00928606f, -0.03107663f, -0.05148655f, 
    0.13010219f, -0.00602317f, 0.00866538f, 0.09784290f, 0.12087855f, -0.06290380f, 0.41048026f, 0.15429798f, 
    -0.43780646f, 0.14272124f, 0.10020114f, 0.16714425f, -0.02587739f, 0.08517925f, 0.02440144f, 0.03319654f, 
    0.00169880f, -0.03225429f, 0.08254386f, -0.02707137f, -0.05055811f, -0.01410771f, -0.00979498f, -0.08108957f, 
    0.32552391f, 0.13350724f, -0.19792753f, 0.08905618f, 0.06523776f, -0.01076689f, 0.02416413f, 0.05468697f, 
    0.07810508f, 0.16428992f, -0.02122246f, -0.04321357f, 0.02696146f, -0.01408455f, 0.07668248f, 0.03603455f, 
    -0.13374415f, -0.05434206f, 0.02622507f, 0.30797985f, -0.05232134f, -0.05372532f, -0.25724897f, -0.01491047f, 
    0.15226308f, 0.06164892f, 0.00641762f, 0.01233544f, 0.01456516f, -0.00164171f, 0.02641053f, -0.06538413f, 
    -0.02994885f, -0.00311898f, -0.01300032f, 0.02153481f, 0.00625697f, 0.07202913f, -0.05967223f, -0.06070931f, 
    0.11308641f, 0.13603328f, 0.20031784f, 0.04159196f, 0.03671310f, 0.02649325f, 0.00454612f, -0.05189441f, 
    0.05837189f, -0.02282910f, 0.08088072f, 0.04576613f, 0.08593835f, -0.02298621f, 0.03544466f, -0.00527994f, 
    -0.00340937f, -0.16433543f, -0.04292171f, -0.28077745f, 0.19399978f, -0.01274039f, 0.20912804f, 0.06438385f, 
    -0.12692855f, 0.19666444f, 0.08286596f, -0.02761236f, -0.09777646f, -0.12591819f, -0.00897361f, 0.01928593f, 
    0.00525529f, 0.00600727f, -0.01574928f, 0.00529713f, 0.04119473f, -0.06930588f, 0.15450555f, 0.13770680f, 
    -0.30259857f, 0.02500914f, -0.12199944f, -0.30541754f, 0.17066738f, 0.05040943f, 0.13551126f, -0.06553628f, 
    -0.19696665f, 0.05177880f, 0.25466543f, -0.21695128f, 0.06883805f, -0.08054734f, 0.04522950f, 0.05041235f, 
    -0.00836847f, -0.24516347f, 0.07327151f, -0.05703619f, 0.05454057f, -0.09454461f, 0.05495138f, -0.02828944f, 
    -0.11867028f, 0.00334840f, -0.07539941f, -0.15413560f, 0.19738770f, 0.01789814f, -0.00531054f, 0.05835669f, 
    -0.10025076f, 0.02158506f, -0.02767562f, 0.02507187f, 0.09734664f, -0.04553272f, 0.10770600f, 0.23522411f, 
    -0.63151515f, -0.73614901f, -0.66445857f, -0.08756519f, 0.27442256f, 0.01631121f, 0.07367752f, 0.01806952f, 
    -0.14460102f, -0.11363576f, -0.02685794f, 0.04684289f, 0.00592441f, -0.03400328f, 0.03280070f, -0.00289790f, 
    0.04578593f, -0.01516275f, 0.17369795f, -0.02832486f, -0.02130687f, 0.06913301f, 0.10595536f, -0.06581861f, 
    0.11642390f, -0.05106279f, -0.02306078f, -0.01561239f, -0.02128982f, 0.05576672f, 0.01662169f, 0.07452987f, 
    0.03968804f, 0.10803784f, 0.03560916f, 0.01950235f, -0.01776229f, -0.00907020f, -0.04377882f, 0.06531556f, 
    -0.08615459f, -0.02433691f, -0.00215113f, -0.03081459f, -0.02205082f, -0.03808903f, 0.07250536f, 0.06534973f, 
    -0.05841430f, 0.01139246f, -0.04536972f, -0.02276045f, 0.00429688f, 0.00241812f, 0.00538326f, -0.03107741f, 
    0.03857399f, -0.02206050f, 0.06315233f, 0.07696608f, -0.24351053f, 0.61240429f, -0.37305677f, -0.05380689f, 
    0.22088328f, -0.03375148f, -0.03786435f, -0.12681288f, 0.24727730f, 0.09929704f, 0.04388650f, 0.09253328f, 
    -0.03975824f, 0.01400725f, -0.01724145f, 0.03519467f, 0.00436734f, 0.06585710f, -0.00300774f, -0.01761585f, 
    0.04216317f, -0.41587287f, -0.31238681f, -0.11408941f, 0.21191654f, -0.04842273f, 0.10244878f, 0.28845215f, 
    0.06482626f, 0.00001092f, 0.02248141f, 0.00078134f, -0.03037715f, -0.02213333f, 0.08760064f, 0.01012361f, 
    -0.02768542f, 0.07010906f, 0.12955570f, -0.02106655f, 0.09162471f, 0.05681140f, -0.04178163f, -0.07639950f, 
    -0.01700807f, 0.04747615f, -0.01123441f, 0.04890681f, -0.03224529f, 0.09479121f, -0.02073529f, -0.09513856f, 
    -0.02037669f, -0.03632017f, -0.03030552f, -0.07949645f, -0.00972567f, -0.14897431f, -0.03980813f, 0.01426514f, 
    -0.65954041f, -0.75668454f, -0.47244966f, -0.15518507f, 0.15645227f, -0.03473402f, -0.03815592f, -0.09795956f, 
    -0.15209757f, -0.40256047f, 0.02034235f, -0.07694782f, -0.06427528f, 0.01755307f, -0.00763173f, 0.00146424f, 
    0.01646867f, 0.04120693f, 0.10254467f, 0.06900976f, -0.34635085f, 0.40412721f, 0.40799001f, -0.16943046f, 
    0.11869311f, -0.04333114f, -0.08194355f, -0.07976628f, -0.07788716f, 0.10888263f, -0.07480694f, 0.09974645f, 
    -0.05430604f, 0.20202537f, -0.06781526f, 0.01122644f, -0.04243280f, -0.06221757f, 0.06446945f, 0.09749795f, 
    -0.34116039f, -0.12236410f, 0.42980447f, -0.11545765f, 0.01777625f, -0.06646456f, -0.09029003f, -0.07525212f, 
    -0.12159948f, 0.12098587f, -0.04729735f, 0.07834855f, 0.09362462f, -0.01529585f, -0.06380007f, 0.04950246f, 
    0.07648036f, -0.01409050f, 0.00528786f, 0.06537554f, -0.27480048f, -0.40437248f, -0.64442146f, -0.03420245f, 
    -0.01818923f, -0.03855100f, -0.07155016f, -0.05014940f, -0.09126993f, -0.09343185f, -0.00475971f, -0.02448208f, 
    0.00680420f, -0.07027226f, -0.04231199f, 0.02750568f, -0.02960082f, 0.11279286f, 0.07356067f, -0.00602136f, 
    -0.39481416f, -0.39825475f, -0.17527400f, 0.06478176f, -0.10379072f, 0.04922238f, -0.07703359f, -0.03756372f, 
    -0.03419895f, -0.20952615f, -0.02008992f, 0.00484735f, -0.04738398f, 0.05599374f, -0.02024028f, -0.00051271f, 
    -0.01043923f, 0.10163619f, -0.04193297f, -0.01969180f, 0.21494031f, -0.25166157f, -0.27734783f, -0.07623079f, 
    0.11661731f, 0.00883341f, 0.11336457f, 0.09918483f, 0.07253373f, -0.10523480f, 0.05676617f, 0.03963694f, 
    -0.07481123f, -0.08678962f, 0.06725627f, -0.05394158f, 0.02322816f, 0.03776194f, 0.13393511f, 0.00959868f, 
    0.20334977f, -0.07130859f, 0.03504368f, 0.08935415f, -0.02889664f, 0.09761767f, -0.02313744f, 0.25105968f, 
    0.21249761f, -0.16588230f, 0.08292202f, 0.04739505f, 0.00419992f, -0.12256425f, 0.04343109f, -0.02008787f, 
    -0.03054436f, 0.15448263f, -0.11298497f, -0.01851933f, -0.15089744f, -0.02474077f, 0.10717561f, 0.24466005f, 
    -0.01609272f, 0.03134102f, -0.03175025f, -0.10585511f, -0.07747179f, 0.17014961f, 0.07737253f, -0.02868741f, 
    0.04593222f, -0.12097621f, -0.03425226f, 0.11854297f, 0.10373641f, 0.01885949f, -0.01725133f, 0.03057619f, 
    -0.08004525f, 0.04749653f, 0.03914820f, -0.08006863f, 0.20422196f, -0.05311925f, 0.03481903f, 0.07469859f, 
    -0.02322913f, 0.09701556f, 0.01911740f, 0.03209140f, 0.09068180f, -0.05949378f, 0.07218178f, -0.05559782f, 
    0.00916400f, -0.04614596f, 0.01325842f, -0.02217111f, -0.12826233f, -0.07131530f, 0.11046981f, 0.27809593f, 
    -0.30349597f, -0.03974796f, 0.00936078f, -0.10452237f, -0.05741176f, 0.17181948f, 0.06600258f, 0.00261516f, 
    0.03341437f, -0.06890786f, -0.12809683f, 0.02495729f, 0.12109221f, -0.00753573f, 0.15507017f, 0.08125226f, 
    -0.14844733f, -0.75662166f, -0.88504255f, -0.24774602f, 0.17618689f, -0.10056624f, 0.09158563f, 0.18896608f, 
    0.02278663f, -0.33658347f, -0.00172055f, -0.03388033f, -0.00629593f, -0.02966987f, 0.08940215f, -0.04138671f, 
    0.04270028f, 0.05906457f, 0.15241727f, -0.06639274f, -0.33264515f, 0.10596502f, 0.01164274f, -0.09988073f, 
    0.23331036f, -0.19765505f, -0.11431506f, 0.02520527f, 0.00428441f, 0.01748309f, 0.01496315f, 0.01948768f, 
    0.05910609f, -0.00131124f, -0.00212809f, 0.01089147f, 0.00972448f, -0.02360965f, 0.06183339f, -0.05595743f, 
    -0.20689550f, 0.34634125f, 0.10544199f, 0.03912654f, 0.15647978f, -0.03427255f, 0.01878606f, -0.05803690f, 
    -0.02754627f, 0.08742835f, 0.04414309f, 0.05741948f, 0.09057944f, 0.09974334f, 0.04512079f, -0.00632504f, 
    -0.01661653f, -0.07470153f, 0.00855099f, 0.01842258f, -0.32341072f, 0.35129958f, -0.81805873f, -0.36983693f, 
    0.05988953f, -0.15249474f, 0.11860588f, 0.16153936f, 0.08848499f, 0.01436380f, -0.07065687f, 0.02769922f, 
    0.04785486f, -0.02130090f, 0.03326530f, 0.05314050f, 0.00361035f, -0.25500944f, 0.14324415f, -0.03658220f, 
    -0.73271799f, -0.91460693f, -0.41762137f, 0.06115610f, -0.48359150f, -0.25070906f, -0.04073967f, -0.15086278f, 
    -0.09643314f, -0.21376778f, 0.02497857f, -0.03887903f, -0.04542685f, -0.06529152f, -0.01404814f, 0.00503449f, 
    -0.05046067f, -0.06100426f, 0.13105729f, -0.05387368f, 0.02296976f, -0.04144180f, -0.00843311f, -0.11909107f, 
    -0.07560836f, 0.01036509f, -0.10545389f, -0.00014392f, -0.03619436f, 0.01132829f, -0.05694990f, -0.03330095f, 
    -0.02491554f, -0.22607790f, 0.01980405f, -0.03307712f, -0.07858742f, -0.04309582f, -0.05722675f, -0.05946823f, 
    -0.26702848f, 0.07992098f, 0.10926813f, -0.03362593f, 0.35062471f, -0.01468703f, 0.01985909f, -0.03091857f, 
    0.08626191f, -0.08533699f, 0.08746621f, 0.04407103f, 0.05817148f, 0.02652897f, -0.09015584f, -0.02542000f, 
    0.04534212f, 0.03083464f, 0.09111099f, 0.00946797f, -0.55703861f, -0.58734214f, -0.61301017f, -0.32235128f, 
    -0.05302762f, -0.13546354f, -0.03108241f, -0.05991888f, -0.05853955f, -0.20447132f, 0.00843217f, -0.01550024f, 
    -0.05839633f, 0.00449772f, 0.06054755f, -0.06609614f, -0.07384603f, 0.08879471f, 0.13471289f, 0.06829950f, 
    -0.00412527f, -0.22430301f, -0.08817189f, 0.02671741f, 0.39056808f, 0.00280648f, 0.00014829f, -0.00721877f, 
    -0.01625440f, 0.02572258f, 0.01983032f, 0.05414039f, 0.04446279f, -0.05323612f, -0.13741842f, 0.02769257f, 
    0.03654803f, 0.04668420f, 0.05638381f, -0.01475823f, -0.31166178f, -0.40037262f, 0.25801587f, 0.16582821f, 
    -0.11714843f, 0.05871700f, 0.00425228f, -0.01019562f, -0.04357757f, 0.14789049f, 0.07695122f, 0.10567416f, 
    0.00400969f, 0.06317500f, -0.19660646f, 0.01744564f, 0.08337282f, -0.00533220f, 0.01387717f, 0.16953395f, 
    -0.35269836f, -0.43759713f, -0.39081579f, -0.08571975f, 0.22494864f, -0.00778769f, -0.08764006f, -0.13408826f, 
    0.02521888f, -0.01624621f, -0.00772786f, 0.03953532f, 0.03172411f, -0.01153129f, -0.11646639f, 0.04618859f, 
    0.03803271f, -0.01352107f, 0.01205564f, -0.01248710f, -0.02541342f, 0.05347804f, -0.41891065f, -0.00785695f, 
    0.00852163f, -0.02776652f, 0.03357638f, 0.05275222f, -0.03552969f, 0.03811974f, 0.03770128f, -0.02652079f, 
    0.04854865f, -0.00357705f, 0.04620363f, 0.02392485f, 0.06494582f, -0.02683357f, 0.16875480f, 0.04271847f, 
    0.04426536f, -0.22205999f, -0.12275697f, -0.22255380f, -0.16312380f, -0.02904302f, 0.09961698f, 0.09333630f, 
    -0.12327278f, -0.04273251f, -0.01695790f, -0.07477279f, -0.08291613f, -0.04633807f, -0.02485635f, 0.04610914f, 
    -0.03872908f, -0.10034546f, 0.00236161f, 0.02365637f, 0.11376692f, 0.18736351f, -0.08939094f, -0.08757304f, 
    -0.01900807f, 0.06815273f, 0.06089777f, 0.09370116f, 0.04841030f, 0.09444975f, -0.02128097f, 0.01396086f, 
    -0.00743986f, -0.03151719f, 0.09238864f, -0.01750110f, -0.05755850f, 0.06397840f, -0.00574905f, 0.03922525f, 
    0.09311615f, -0.03534695f, -0.01187341f, -0.04481361f, -0.02952799f, 0.05063016f, 0.03635004f, 0.08684418f, 
    -0.01264110f, 0.03342051f, -0.03396465f, -0.06462670f, -0.07967733f, -0.04354919f, -0.01696131f, -0.12106816f, 
    -0.05203614f, -0.03691675f, -0.03700111f, -0.02988847f, 0.12432414f, -0.07785057f, -0.26360378f, -0.25354716f, 
    -0.10419361f, 0.02544553f, 0.06949089f, 0.14265770f, -0.04216531f, -0.06818572f, 0.00134839f, -0.03277614f, 
    -0.01462125f, -0.00540695f, 0.05766988f, -0.01229284f, 0.00111526f, 0.02582780f, 0.01773945f, 0.19833532f, 
    -0.26743948f, -0.01085410f, 0.09883288f, -0.04237574f, -0.01649095f, -0.19241430f, -0.14617513f, -0.23165977f, 
    -0.10525519f, -0.09932005f, -0.01512645f, -0.14393447f, -0.04204517f, -0.01365674f, 0.03887050f, -0.05912418f, 
    -0.01802260f, 0.06353579f, -0.08543624f, -0.08659696f, -0.05173868f, 0.15693466f, -0.06816605f, 0.01572630f, 
    0.15453376f, 0.02016460f, -0.06906754f, -0.00907848f, -0.05408511f, 0.06714609f, 0.04196281f, 0.01215113f, 
    0.12444607f, 0.02565316f, -0.14246839f, -0.04793935f, 0.22964668f, -0.13877302f, -0.02495650f, 0.07093653f, 
    -0.22011749f, -0.02054408f, 0.21809626f, -0.01597809f, 0.00357390f, -0.01500141f, -0.07327498f, 0.01513819f, 
    0.01257699f, 0.03522317f, 0.09105121f, 0.00326712f, -0.01425130f, 0.10438830f, 0.07595884f, -0.01388371f, 
    0.00311154f, -0.07236337f, -0.07030753f, 0.01251407f, -0.29148713f, -0.08408095f, 0.09128611f, 0.18637042f, 
    0.00066549f, -0.15383445f, 0.04195971f, -0.11337554f, 0.00144310f, 0.15908839f, -0.04630823f, 0.07053056f, 
    0.13750407f, 0.00602835f, 0.03529674f, 0.04421641f, 0.05271412f, -0.09799173f, 0.12741628f, -0.08830868f, 
    -0.52178633f, 0.37684879f, 0.40276167f, -0.00614171f, 0.19889605f, -0.04144407f, -0.07775659f, -0.02582274f, 
    -0.14968731f, 0.17845392f, -0.03773797f, 0.07815202f, 0.08316563f, 0.10165764f, 0.06015587f, 0.00917529f, 
    -0.02404789f, -0.04119962f, -0.00599795f, 0.00414627f, -0.01291419f, -0.00231406f, 0.01563723f, 0.02582602f, 
    -0.02088097f, -0.00984253f, -0.02703995f, -0.00547893f, -0.04602856f, 0.01170422f, 0.03802734f, 0.03339525f, 
    0.01942751f, 0.03467700f, 0.06121962f, 0.01004412f, -0.05097259f, -0.06722534f, -0.04714860f, -0.01187427f, 
    -0.08740207f, -0.07095534f, 0.10792146f, -0.09707461f, 0.08101524f, -0.05378170f, 0.03668000f, 0.10968799f, 
    -0.02644058f, 0.01492288f, 0.12155628f, 0.05440410f, 0.00721487f, 0.08667816f, -0.07789928f, -0.04975951f, 
    -0.10492732f, 0.05316095f, -0.01013671f, 0.06691284f, -0.01547784f, 0.11852627f, -0.09826218f, -0.02876540f, 
    -0.11597837f, 0.02130463f, 0.03568574f, -0.02420215f, -0.07543526f, -0.00175652f, -0.01668984f, -0.13814069f, 
    0.00837289f, -0.00463115f, -0.20034529f, 0.11075904f, -0.05790082f, -0.05372314f, 0.01232334f, 0.06363926f, 
    -0.27448550f, -0.22593533f, -0.04607329f, -0.05136187f, -0.29810154f, 0.01002089f, 0.08841364f, 0.02797428f, 
    0.03367825f, -0.05610755f, 0.01914426f, -0.03551539f, 0.00636693f, 0.01941743f, 0.08111306f, 0.03852280f, 
    0.12881233f, 0.17688183f, 0.06339991f, 0.02276706f, 0.10156790f, -0.15986870f, -0.11910971f, -0.05723223f, 
    0.09454177f, -0.06070283f, 0.02561289f, 0.02618122f, -0.01516660f, 0.02557450f, -0.01231585f, -0.05680821f, 
    -0.15501766f, -0.08730480f, 0.04457239f, -0.08247212f, -0.06169496f, -0.04823183f, 0.00901719f, -0.03426947f, 
    0.03032146f, 0.14543997f, -0.08789709f, -0.02444062f, 0.05240374f, 0.02647397f, -0.05042162f, -0.04971786f, 
    0.07917990f, -0.06909470f, -0.06192354f, -0.01636701f, -0.20547767f, -0.00152992f, 0.04204984f, -0.02080186f, 
    -0.06460798f, 0.07306245f, -0.25953907f, -0.21060693f, -0.00132734f, 0.12117039f, -0.10044394f, -0.11315584f, 
    0.15578279f, -0.09154238f, 0.05068341f, 0.01558573f, -0.02588970f, 0.15002474f, -0.04340067f, 0.12020651f, 
    0.11838491f, 0.06753585f, 0.04910909f, 0.03005437f, 0.11622753f, 0.02075790f, 0.13469490f, 0.02024429f, 
    0.07296014f, 0.26256305f, -0.55286503f, -0.03946960f, 0.08227922f, -0.08065823f, 0.05834334f, -0.04477056f, 
    -0.05769616f, 0.15372238f, -0.03685330f, -0.00861692f, 0.09901103f, 0.02694175f, 0.04940929f, -0.00726810f, 
    -0.05335075f, -0.27423593f, 0.26507434f, -0.13224985f, -0.13225520f, 0.41391140f, 0.08483961f, -0.13715848f, 
    -0.04267086f, -0.08239897f, -0.00611861f, -0.13669620f, -0.01463218f, -0.05452820f, -0.01598805f, -0.05526128f, 
    -0.06397754f, 0.00684022f, 0.00486197f, 0.03758702f, -0.10849328f, 0.01038848f, -0.06328205f, -0.06220857f, 
    -0.73535442f, -0.50729489f, -0.09184238f, -0.27637964f, -0.38551551f, -0.21270919f, -0.08198037f, -0.09422739f, 
    -0.18248814f, -0.28840685f, -0.04776060f, -0.01374700f, -0.00027147f, -0.02695998f, 0.01870504f, -0.02378966f, 
    -0.01366866f, 0.04341160f, -0.04914083f, -0.22713660f, -0.24264619f, 0.05121450f, 0.26946965f, 0.01479351f, 
    0.11855100f, -0.03030563f, -0.17062274f, -0.03076202f, -0.04819021f, -0.04147052f, 0.00271598f, 0.02117374f, 
    0.00645607f, 0.12635167f, -0.04050763f, -0.02460678f, 0.06425155f, 0.01428932f, -0.07448148f, 0.04320447f, 
    -0.05533910f, 0.17087199f, 0.03873559f, 0.19130601f, -0.15237127f, 0.09493803f, -0.01088519f, -0.03698492f, 
    0.01355056f, 0.03933919f, 0.09582872f, 0.05728344f, 0.08012011f, -0.23248476f, -0.06264324f, 0.06967913f, 
    0.12758878f, -0.22973406f, 0.05959271f, -0.07671444f, 0.07093792f, 0.03413913f, -0.08433023f, -0.09919605f, 
    0.04477147f, -0.08091275f, 0.03467046f, -0.15210740f, -0.02834729f, 0.00027244f, 0.06423655f, -0.01203528f, 
    -0.06811891f, -0.07225122f, 0.05807596f, -0.04333547f, -0.02159388f, -0.00259548f, -0.01201045f, -0.13327233f, 
    0.12404005f, 0.25998548f, -0.02643387f, -0.02402001f, 0.02781912f, 0.07996850f, 0.01823061f, -0.01787004f, 
    0.00546867f, -0.05419429f, -0.01069182f, -0.00202813f, 0.12670235f, -0.04776766f, 0.00976977f, 0.05293560f, 
    -0.10797513f, -0.09773152f, -0.06282429f, -0.02643800f, -0.20987014f, -0.05690334f, 0.19709320f, 0.04422059f, 
    0.19353898f, -0.23510323f, 0.04486451f, -0.05395808f, -0.16208886f, 0.21882540f, -0.04697521f, 0.08338831f, 
    0.18791033f, 0.05140156f, 0.05740108f, -0.04429252f, 0.07276937f, -0.01612928f, 0.11820354f, -0.00917336f, 
    -0.03321485f, -0.06558985f, 0.06138599f, 0.20397711f, -0.02247314f, 0.01380276f, 0.01555272f, 0.04112502f, 
    -0.02889016f, -0.05171517f, 0.03234689f, 0.00478240f, -0.00244751f, 0.00367617f, -0.03338467f, 0.15109691f, 
    0.05073560f, 0.06702325f, -0.10553832f, 0.05055596f, -0.46691614f, -0.34335101f, -0.57411653f, -0.27751082f, 
    0.23255061f, -0.08992186f, 0.06754083f, -0.03083908f, -0.11742109f, -0.30765766f, -0.01039246f, -0.03356426f, 
    -0.01332271f, 0.03237804f, 0.06126346f, 0.02550618f, 0.02474372f, -0.00137703f, 0.13615181f, 0.09323227f, 
    -0.41609570f, -0.10938342f, 0.17217654f, 0.15469413f, 0.24278155f, -0.10703302f, -0.03383046f, -0.02352895f, 
    0.11613443f, 0.13520850f, 0.07340385f, 0.16603851f, 0.12985593f, 0.00630382f, 0.12139780f, 0.03934472f, 
    0.00772657f, -0.01780732f, -0.00955078f, -0.01673127f, -0.27025500f, -0.17228915f, 0.05109467f, 0.00238144f, 
    0.14176483f, 0.04365300f, 0.17505893f, 0.12892334f, 0.03564611f, -0.03654987f, 0.16320375f, -0.05232282f, 
    -0.09085669f, 0.07001209f, 0.01723621f, -0.04149661f, 0.05260637f, 0.07275683f, 0.10810099f, -0.00899211f, 
    0.24497806f, 0.36020538f, -0.17359753f, -0.03116436f, -0.02040146f, -0.08773323f, -0.01784326f, -0.02364679f, 
    0.11307544f, 0.10443836f, 0.14591742f, 0.01000434f, 0.01789873f, -0.12857090f, 0.01352202f, -0.01472444f, 
    0.06835166f, -0.01562867f, 0.12048867f, -0.07449054f, -0.48589265f, -0.63830441f, -0.34772277f, 0.05440528f, 
    0.30245125f, 0.01247625f, 0.09791457f, -0.07799315f, -0.25241226f, -0.12308625f, -0.08762775f, -0.02209484f, 
    0.02407200f, 0.05080241f, 0.05881720f, 0.07005528f, 0.01915023f, -0.05966356f, 0.16962890f, 0.04091718f, 
    0.22665754f, -0.04996837f, -0.43815297f, -0.02217036f, 0.07484127f, -0.02906443f, -0.03452848f, 0.11901928f, 
    0.16454302f, -0.53405333f, 0.02432054f, 0.02527154f, -0.14039871f, 0.04255067f, 0.03221716f, -0.10231968f, 
    0.07607638f, 0.22359921f, -0.17985870f, -0.10363533f, 0.12370592f, -0.06495556f, -0.07755940f, -0.02068482f, 
    -0.00930585f, 0.00774639f, 0.02512064f, 0.09592879f, -0.05398972f, 0.04242068f, -0.06306684f, -0.04363530f, 
    -0.05948513f, -0.02271213f, 0.00596425f, -0.02592008f, -0.00694988f, -0.00207050f, -0.00526360f, 0.02295441f, 
    -0.49770534f, -0.52741337f, -0.63922483f, 0.15723944f, -0.44341716f, -0.13141474f, 0.15696478f, 0.02486967f, 
    -0.14596234f, -0.40810862f, 0.03671663f, -0.05125939f, -0.01031226f, 0.06707642f, 0.05617938f, -0.01276893f, 
    0.01791290f, 0.20683280f, 0.04902213f, 0.10770097f, -0.59699297f, -0.42928430f, -0.17946504f, -0.16045536f, 
    0.02016622f, -0.15003164f, -0.09495442f, -0.17942138f, -0.15038648f, -0.22933319f, 0.04870403f, 0.00977169f, 
    -0.05982881f, -0.01987377f, 0.00980215f, -0.00932153f, 0.00023808f, 0.05578468f, 0.00482105f, -0.01546829f, 
    0.09425641f, 0.18371791f, 0.04519028f, -0.12241445f, -0.07182445f, 0.06017193f, 0.01492992f, 0.09368692f, 
    -0.08775325f, 0.00495113f, 0.11100276f, -0.00017619f, 0.01692168f, -0.10772840f, 0.17709035f, 0.02118479f, 
    -0.00576217f, -0.07669939f, -0.14325282f, 0.00155860f, -0.11967474f, 0.15857387f, 0.12362028f, 0.00287006f, 
    0.12758255f, -0.11603367f, -0.03586235f, -0.15423751f, -0.07941572f, 0.12121302f, 0.09107621f, 0.03274599f, 
    -0.09083278f, -0.02125859f, 0.02506089f, -0.01063058f, -0.02869099f, -0.00643251f, 0.02823393f, -0.12109050f, 
    -0.13363197f, -0.45196757f, -0.07121541f, 0.37438515f, -0.03397303f, -0.09504326f, 0.11748420f, 0.06025663f, 
    -0.01919860f, 0.04025556f, -0.06783498f, 0.01365540f, -0.00966940f, -0.01456185f, -0.05069967f, -0.08926950f, 
    0.03505509f, -0.03956220f, -0.08790581f, 0.02088688f, 0.07188763f, 0.06517106f, -0.17865032f, 0.03107047f, 
    -0.09377049f, 0.00632289f, 0.05323267f, 0.05374032f, 0.02149244f, -0.07161351f, -0.02045351f, -0.08050416f, 
    -0.03401389f, -0.01470092f, 0.03273469f, -0.02143059f, 0.02098525f, 0.02119478f, -0.00487222f, 0.06821577f, 
    -0.04546854f, 0.09895305f, -0.04147517f, 0.00322738f, -0.11825104f, 0.02856443f, -0.03002457f, 0.00045561f, 
    -0.02775067f, -0.04983972f, 0.02807127f, 0.00357204f, 0.03905302f, -0.06763902f, -0.04633006f, -0.10379823f, 
    -0.19968461f, 0.14522341f, -0.04652831f, -0.01605936f, -0.37000585f, -0.44690955f, -0.00304924f, 0.00653869f, 
    0.09693795f, -0.03832018f, 0.09379534f, 0.09843490f, 0.07089142f, -0.30220410f, -0.07160938f, 0.04858343f, 
    -0.04180690f, -0.00716656f, -0.09654476f, 0.05622822f, -0.07178458f, 0.06750184f, -0.11244391f, -0.05076033f, 
    0.00748185f, 0.05307193f, -0.18858922f, 0.11096335f, -0.38208455f, -0.12385127f, 0.09676253f, -0.00382734f, 
    0.04621186f, -0.01790900f, -0.00613087f, -0.00802500f, 0.00790724f, 0.00308191f, -0.03078558f, 0.01515541f, 
    -0.08051503f, 0.11270317f, -0.01394142f, 0.02103030f, 0.03173677f, 0.10206103f, 0.03138917f, 0.00419093f, 
    -0.13389812f, -0.03001416f, 0.00666468f, -0.00143439f, -0.03611182f, -0.01790406f, -0.01386533f, 0.04384848f, 
    -0.04138472f, -0.01838264f, -0.02912837f, 0.07666635f, -0.07321802f, 0.01591954f, 0.04560276f, 0.03095230f, 
    -0.18264119f, -0.38270140f, 0.19009919f, 0.37817606f, 0.04426632f, -0.05081482f, 0.06817023f, -0.00409381f, 
    0.02472302f, -0.01798926f, 0.02220730f, -0.05545865f, -0.02643826f, -0.05985866f, -0.04926518f, 0.04668658f, 
    -0.02499354f, -0.06433631f, 0.09740796f, -0.04390293f, 0.65153849f, -0.69817650f, -0.63370311f, -0.41413802f, 
    -0.03913760f, 0.09196919f, 0.06776213f, -0.34390295f, 0.26960063f, -0.18558490f, 0.06643781f, 0.03534184f, 
    0.03154049f, 0.05258860f, 0.01152572f, -0.00107326f, 0.04659794f, -0.02879669f, 0.01584519f, 0.03449079f, 
    0.48406717f, -0.71857607f, 0.00017139f, -0.31180885f, 0.07311545f, -0.28079641f, 0.20090105f, -0.32487804f, 
    0.26084322f, -0.06115858f, 0.03662726f, 0.03619810f, 0.00106864f, -0.01814382f, 0.14723553f, -0.08442766f, 
    0.07389911f, -0.03348358f, 0.08485732f, -0.00258974f, 0.02865147f, -0.24516234f, -0.15661986f, -0.19211663f, 
    -0.11635403f, -0.07823440f, -0.05840779f, -0.08297013f, 0.11906654f, 0.09223682f, -0.02135123f, -0.02496281f, 
    -0.10016688f, -0.10826246f, 0.03376696f, 0.03017123f, 0.04936268f, -0.10064889f, 0.07521154f, -0.07917131f, 
    -0.01724762f, -0.21408485f, 0.11691827f, -0.11491397f, 0.14801018f, -0.02464495f, 0.02173321f, 0.02897533f, 
    -0.01262322f, -0.13666548f, 0.01439609f, -0.02303926f, -0.01822076f, -0.04911748f, -0.03069672f, 0.02436818f, 
    -0.02995146f, -0.03930048f, 0.00144142f, 0.03653277f, -0.23660317f, -0.23463163f, 0.00673979f, 0.16438913f, 
    -0.06935713f, 0.04739424f, 0.04008674f, -0.00378213f, 0.06388623f, 0.06626349f, 0.03323836f, 0.01575901f, 
    0.05369683f, 0.00510837f, -0.03389378f, 0.04136305f, 0.02009731f, -0.06377710f, 0.04234815f, 0.10450581f, 
    -0.12518045f, 0.09210894f, 0.12618288f, 0.01141541f, 0.03587181f, -0.10228992f, 0.09338734f, -0.01650288f, 
    0.00399286f, -0.00645268f, 0.11145406f, -0.01381268f, 0.07407640f, -0.05540865f, -0.00344316f, -0.03595561f, 
    -0.08836712f, -0.06273030f, -0.13083526f, 0.01779449f, 0.26172262f, 0.03289425f, 0.07960387f, -0.21405742f, 
    -0.14221594f, 0.01104633f, 0.02746111f, 0.00461634f, 0.03741174f, -0.10105370f, -0.00227615f, -0.20981823f, 
    0.01194844f, -0.26760587f, -0.03656250f, -0.07637101f, -0.06369904f, 0.07501727f, 0.07549666f, -0.04271398f, 
    0.18135162f, 0.27381632f, -0.13765416f, 0.08587295f, -0.38738492f, -0.09509274f, 0.10380730f, 0.01039054f, 
    -0.09757634f, -0.04183991f, -0.09484272f, 0.03081017f, -0.02641679f, -0.06194952f, -0.00840934f, -0.15240799f, 
    -0.18719652f, 0.08588547f, -0.11161437f, -0.08462322f, 0.37528041f, -0.02259753f, -0.02766432f, -0.21475522f, 
    -0.31949440f, 0.06381959f, 0.04835907f, -0.03351684f, 0.07013424f, -0.03093764f, -0.12547059f, -0.01806289f, 
    -0.01944759f, -0.26657709f, -0.15592195f, 0.05478381f, -0.03210556f, 0.03182235f, -0.02113450f, -0.03961083f, 
    -0.67869049f, -0.46349123f, 0.02984293f, 0.13733719f, -0.06177106f, -0.01902853f, -0.09224997f, -0.00474164f, 
    -0.07888050f, 0.05788207f, 0.03602879f, 0.03569703f, 0.01424856f, -0.01081120f, -0.04561204f, 0.02794223f, 
    -0.06468561f, -0.10845130f, -0.04994831f, -0.05801033f, 0.40117323f, -0.35052389f, -0.34816194f, -0.33304888f, 
    -0.11737400f, 0.06585214f, -0.04258642f, 0.01243620f, 0.08343660f, -0.04044334f, -0.03500513f, 0.00654068f, 
    -0.06784253f, -0.05328206f, -0.06876122f, -0.05303137f, -0.04257577f, 0.05710230f, -0.03907738f, -0.07242410f, 
    0.04645893f, 0.06321584f, -0.12583703f, -0.04601109f, -0.11236942f, 0.02767641f, -0.01014865f, -0.00490931f, 
    0.00707808f, -0.04870314f, -0.02683799f, 0.02322675f, -0.02033902f, -0.03905580f, -0.00376203f, 0.03244273f, 
    -0.00356709f, 0.02361316f, 0.01073398f, -0.01088033f, -0.15269178f, 0.29287854f, -0.05068271f, 0.16567820f, 
    -0.10679879f, 0.09706978f, 0.07997297f, -0.15203315f, -0.24845743f, -0.17180572f, 0.02811371f, 0.04711930f, 
    0.04121983f, 0.01394434f, 0.02758442f, -0.00716516f, 0.11867693f, 0.14593269f, -0.01270870f, -0.05463750f, 
    0.19241039f, -0.57264555f, -0.59220630f, 0.03846144f, -0.15867788f, 0.02151136f, -0.00788408f, -0.04653068f, 
    0.16017473f, 0.01153244f, -0.05044541f, 0.02756515f, 0.01933914f, 0.00444188f, -0.07869229f, -0.02658976f, 
    0.04881569f, 0.00749560f, -0.06015605f, -0.14930837f, 0.05905509f, 0.10488437f, 0.02949995f, -0.07560779f, 
    -0.08355702f, -0.00271413f, 0.02135381f, 0.01713496f, 0.01111106f, -0.00174613f, -0.03501278f, -0.36142161f, 
    0.00446131f, -0.01649510f, 0.03321455f, 0.09386251f, 0.02277664f, 0.08689097f, 0.04878886f, 0.05251948f, 
    -0.33255455f, -0.06982945f, -0.15013248f, 0.06624819f, 0.15271382f, -0.01086079f, 0.05344251f, 0.17661577f, 
    -0.00535270f, 0.04456526f, -0.07722558f, 0.04898849f, 0.00796206f, 0.08387286f, 0.09046318f, -0.12145235f, 
    -0.07195887f, -0.12277849f, 0.10318644f, 0.13760144f, -0.51126224f, -0.28688315f, -0.15619273f, -0.03850949f, 
    0.17313674f, 0.10330456f, -0.02209694f, 0.16396788f, 0.02347462f, 0.06375894f, 0.00242385f, -0.01956431f, 
    -0.09485586f, -0.02239218f, -0.04638002f, 0.11443312f, -0.00425649f, -0.00730253f, 0.12232631f, -0.06254155f, 
    0.09625922f, -0.42909932f, -0.39240387f, -0.44873747f, -0.13782236f, 0.07316715f, 0.05330600f, -0.01755075f, 
    0.14777729f, -0.04642785f, 0.00809419f, 0.01167121f, -0.00166298f, -0.01308047f, 0.08522566f, -0.15300806f, 
    -0.07418153f, -0.00978830f, 0.07340810f, -0.00571981f, 0.48862609f, -0.03920880f, -0.13276672f, -0.41305545f, 
    -0.02357882f, 0.07819315f, 0.13052863f, 0.01025389f, 0.10802000f, 0.05819118f, 0.02694536f, 0.10534589f, 
    0.17315462f, -0.13961716f, 0.04881588f, -0.10493844f, 0.04236504f, 0.06706838f, 0.02129942f, 0.01466622f, 
    0.19625250f, -0.44520083f, -0.34453180f, -0.37817466f, -0.32840437f, -0.14261432f, -0.08703141f, 0.02212412f, 
    0.23562454f, 0.02294412f, 0.01529522f, 0.00101346f, -0.01986841f, 0.03086857f, 0.06547033f, -0.14148018f, 
    -0.01566282f, -0.01121338f, 0.01381771f, 0.03889506f, -0.10516915f, -0.40733230f, 0.09557165f, 0.15192361f, 
    0.15538065f, -0.09161091f, 0.03651283f, 0.11282760f, -0.14472309f, 0.00210252f, -0.00084016f, -0.04012173f, 
    -0.02876521f, -0.03804341f, -0.00183901f, -0.00953301f, 0.02832530f, -0.04265336f, 0.07850534f, -0.02979066f, 
    -0.04684359f, 0.08473065f, 0.12326574f, -0.04801625f, -0.01864208f, 0.05158474f, -0.02494561f, -0.02117704f, 
    -0.00783393f, 0.00117897f, 0.07225039f, 0.04730451f, 0.08176050f, -0.00062826f, -0.01988559f, -0.00712017f, 
    -0.08497342f, -0.05149582f, 0.12576778f, 0.06761597f, -0.06995267f, -0.19194029f, 0.04025554f, -0.02535133f, 
    0.12926504f, 0.02071220f, -0.10662103f, 0.14235866f, -0.01081573f, 0.03937963f, 0.06209025f, -0.04694894f, 
    -0.00750615f, 0.03366616f, -0.01765571f, -0.00077964f, 0.03511539f, -0.07972616f, 0.12969595f, 0.05837045f, 
    -0.05861261f, 0.04974407f, 0.04476693f, -0.01036170f, -0.02455958f, 0.02854192f, -0.00086514f, 0.03123591f, 
    -0.02184062f, -0.00471656f, 0.06306656f, -0.00433313f, 0.08298191f, -0.06487464f, -0.02568500f, -0.04066047f, 
    -0.06127042f, 0.13070725f, 0.00195148f, 0.03961414f, -0.18928279f, -0.04203566f, 0.07605317f, -0.10352474f, 
    -0.13864964f, -0.00765301f, 0.01339811f, -0.06335086f, -0.05712808f, -0.04906425f, 0.05066637f, -0.02286677f, 
    0.07031719f, 0.02196983f, -0.04592174f, 0.03246595f, 0.04916555f, -0.09372924f, 0.05451788f, 0.05436980f, 
    0.22231656f, -0.22489850f, -0.01417609f, 0.06963930f, 0.02191862f, 0.05587785f, 0.06361446f, 0.07320619f, 
    -0.01184630f, 0.04938133f, -0.03676272f, 0.02666558f, 0.08575970f, 0.05730018f, 0.01023661f, 0.00157540f, 
    -0.00486238f, -0.01197386f, -0.06490741f, -0.05071273f, 0.00861716f, 0.18616483f, -0.03840226f, 0.04273487f, 
    -0.21693081f, -0.00662131f, 0.01152240f, 0.02200635f, -0.05857190f, -0.01825322f, -0.00779812f, 0.09563317f, 
    -0.08200749f, -0.03412957f, -0.00769479f, 0.06922788f, -0.18380733f, 0.07478852f, 0.01918609f, 0.05829150f, 
    0.27097628f, 0.07835759f, -0.07693087f, -0.07981471f, -0.05892534f, -0.01986837f, -0.03459949f, 0.02093419f, 
    -0.03234357f, -0.04793463f, -0.01545966f, -0.23806700f, 0.08988395f, 0.07936613f, 0.06798354f, 0.01812976f, 
    -0.01591320f, -0.00326988f, -0.01503148f, -0.02682559f, 0.46979627f, 0.09360500f, -0.14943388f, 0.00917190f, 
    -0.16479371f, 0.08453217f, -0.03061777f, -0.10808304f, 0.00496570f, -0.11758868f, 0.06119327f, -0.00374630f, 
    0.05283008f, -0.07783300f, -0.01694267f, 0.01262204f, -0.05292578f, 0.00671031f, 0.01618635f, -0.19047391f, 
    0.41652700f, -0.22056964f, -0.37759364f, -0.17051233f, -0.19366473f, -0.14630637f, -0.11283217f, -0.00822281f, 
    0.06830198f, -0.12700449f, -0.01539083f, -0.01232102f, 0.03142231f, 0.02823817f, 0.06818042f, 0.01353062f, 
    0.05546494f, 0.01955653f, 0.06172894f, 0.02722759f, 0.10574843f, 0.09902433f, 0.06841051f, -0.02103203f, 
    -0.12269927f, -0.00425983f, -0.00848481f, 0.00920975f, -0.00363982f, -0.02671933f, -0.04230583f, -0.23946176f, 
    -0.09351599f, -0.26080635f, -0.12616125f, 0.02689377f, 0.01396417f, 0.05359711f, 0.01495095f, 0.02889356f, 
    0.12708101f, 0.22178073f, -0.15304801f, 0.01388977f, -0.14453839f, 0.06241076f, 0.06241041f, 0.03876378f, 
    -0.08625402f, 0.00204443f, -0.07796886f, -0.10806217f, 0.12339550f, -0.00170291f, 0.12338126f, -0.19690062f, 
    0.08399195f, 0.09599544f, -0.12742950f, 0.06525511f, 0.02984604f, 0.03390896f, 0.13215815f, -0.02359249f, 
    -0.10184522f, 0.05977590f, 0.00216825f, 0.03649237f, -0.02673062f, -0.00349960f, 0.03075464f, 0.01115785f, 
    -0.00059906f, -0.12735830f, -0.01837457f, 0.05575899f, -0.05313104f, 0.05283761f, 0.06546924f, 0.00839892f, 
    -0.15914492f, -0.16090636f, 0.31069767f, -0.17820752f, 0.11002927f, 0.00929096f, -0.08918589f, 0.01891452f, 
    -0.01984630f, -0.01021774f, -0.00542801f, -0.01360365f, -0.03386709f, -0.03357273f, -0.04867187f, 0.06217318f, 
    0.02407870f, 0.04398298f, -0.02838355f, -0.12580821f, -0.03349238f, 0.01209939f, -0.03965504f, 0.06129463f, 
    -0.10621019f, -0.01219897f, 0.03005787f, 0.08362172f, 0.02594126f, -0.01113801f, -0.00224006f, 0.01949993f, 
    0.01461187f, 0.05534024f, -0.01418022f, 0.02470224f, -0.04150396f, 0.10326017f, 0.03119548f, 0.05975760f, 
    -0.16587004f, -0.18959022f, 0.04601916f, 0.06295985f, 0.06189185f, 0.02885079f, 0.06221541f, 0.02294010f, 
    0.04975129f, 0.02871886f, -0.01944801f, -0.05066618f, -0.01912149f, 0.02159777f, 0.02138650f, 0.03224384f, 
    -0.00879575f, -0.03493119f, -0.00285443f, 0.00780957f, 0.17798924f, 0.26190862f, -0.39208311f, 0.18366207f, 
    -0.39714593f, 0.04094008f, 0.08296572f, 0.05303272f, -0.02982457f, -0.00496212f, -0.07539177f, -0.05299750f, 
    0.01029305f, 0.09053133f, -0.13111496f, -0.11063784f, -0.17144284f, 0.01890441f, -0.15073955f, -0.01999233f, 
    0.26273972f, -0.04563351f, 0.13556369f, 0.37992501f, -0.06828151f, -0.02142801f, 0.10428321f, -0.06842430f, 
    0.00934967f, 0.01250944f, 0.03742433f, 0.06403291f, -0.06998163f, 0.01034208f, 0.03186156f, -0.12088209f, 
    0.00740464f, 0.03845366f, -0.01819577f, 0.01905735f, -0.30125010f, -0.27968884f, -0.02541356f, -0.08054569f, 
    0.02131920f, 0.03760758f, -0.09110569f, 0.10467985f, 0.01572561f, 0.04178548f, -0.23334141f, 0.12075927f, 
    0.06155070f, 0.07954326f, 0.02376855f, -0.00872111f, 0.01187831f, 0.01512433f, -0.05590355f, -0.01206596f, 
    0.41305760f, -0.40209985f, -0.16794106f, -0.09098910f, 0.12344231f, 0.00295478f, 0.11494201f, 0.04758605f, 
    0.15931895f, 0.04124174f, -0.00428491f, 0.02118458f, 0.05147627f, -0.00952744f, -0.00718849f, -0.02955368f, 
    0.02462761f, -0.04338214f, -0.03170646f, -0.07211624f, 0.27064499f, -0.38656512f, 0.17106029f, -0.42499092f, 
    -0.20442264f, -0.13453403f, 0.10149518f, -0.08529603f, 0.18979631f, -0.11350702f, 0.00559942f, -0.01970006f, 
    0.04019840f, -0.03047374f, -0.10247280f, -0.08751160f, -0.02274712f, -0.07415558f, -0.01635522f, -0.02540606f, 
    0.30168554f, 0.15208422f, 0.15004577f, -0.17113933f, -0.11808823f, -0.00949337f, 0.19001991f, -0.03467695f, 
    0.00681033f, -0.03716934f, -0.02055025f, -0.11047197f, -0.11754154f, -0.08691008f, 0.10461207f, 0.06226911f, 
    -0.09861138f, 0.03452611f, 0.02314123f, -0.01742800f, -0.13402192f, -0.19913335f, -0.06027501f, 0.16040015f, 
    0.02418762f, 0.07962973f, -0.05510503f, 0.11724266f, 0.04815629f, 0.04825176f, 0.02524601f, -0.08938089f, 
    0.09779929f, 0.07809281f, 0.00777546f, 0.04965882f, 0.05015519f, -0.03496494f, 0.04747928f, 0.05737065f, 
    -0.12645917f, 0.00612578f, 0.05084148f, 0.00688651f, 0.00611071f, 0.05145597f, -0.07142914f, 0.05325697f, 
    -0.04383959f, 0.01384446f, -0.11668751f, 0.06022327f, 0.06127772f, 0.10517349f, -0.03009517f, 0.02784690f, 
    -0.01652126f, 0.02129905f, 0.01754144f, 0.00358134f, 0.41628224f, 0.26211500f, -0.29612786f, 0.03608537f, 
    -0.34992236f, 0.07885501f, -0.13857394f, -0.03158206f, -0.02677063f, -0.00083891f, 0.02736577f, 0.08111933f, 
    -0.11868315f, -0.07849439f, -0.04279310f, 0.05514099f, -0.07907996f, 0.00781863f, 0.05485183f, -0.08419588f, 
    -0.01068355f, 0.07372779f, 0.09052747f, -0.04912582f, -0.05896971f, -0.02707804f, 0.00343803f, -0.01108452f, 
    -0.08613177f, -0.02733599f, 0.07851319f, 0.00937911f, 0.03866196f, 0.02147199f, -0.00355836f, -0.09578306f, 
    -0.08950280f, 0.04799977f, 0.00949492f, -0.00732863f, -0.18004212f, -0.22552708f, -0.09493989f, 0.45629695f, 
    -0.05775996f, -0.00252740f, 0.05460963f, -0.00036552f, 0.10084300f, 0.19253728f, -0.02291835f, -0.07294910f, 
    -0.10578453f, -0.04117294f, -0.06399450f, 0.03816140f, 0.02372649f, -0.18852687f, 0.07768276f, 0.00910570f, 
    0.57266372f, 0.32467437f, -0.12101737f, -0.14949347f, -0.24365765f, 0.08510408f, -0.00201709f, 0.04431757f, 
    -0.09452631f, 0.01629115f, -0.00498294f, 0.00218231f, -0.06795464f, -0.10179909f, -0.07507335f, 0.09349120f, 
    -0.01784541f, -0.01139766f, 0.05930804f, 0.04490227f, 0.31685424f, 0.07653013f, -0.18545577f, 0.05466329f, 
    -0.34019351f, -0.09923244f, 0.07097907f, 0.09354530f, -0.06216266f, -0.02530866f, -0.20406026f, 0.07862081f, 
    0.07033244f, -0.01904942f, -0.01875328f, 0.08515711f, -0.06661879f, 0.11662310f, -0.09487813f, -0.00644725f, 
    -0.10233324f, -0.03604417f, -0.09883437f, 0.02865150f, 0.11165595f, 0.12245687f, -0.06482379f, 0.08566914f, 
    -0.16995777f, 0.00752135f, -0.09502747f, 0.12609239f, 0.03667380f, 0.08386391f, -0.03169430f, 0.01866326f, 
    0.01635577f, 0.01386256f, -0.02037601f, -0.03948169f, -0.12046254f, -0.34855869f, 0.12549655f, 0.59494835f, 
    0.04292738f, -0.08753311f, 0.15051919f, -0.09838356f, 0.07090735f, 0.10407431f, -0.01924621f, 0.05021033f, 
    -0.07425560f, 0.01278698f, -0.07694867f, -0.06696516f, -0.00932359f, -0.19087774f, 0.01073442f, 0.04737412f, 
    -0.56197083f, -0.11931744f, 0.42487189f, -0.04039314f, -0.01556845f, -0.01063143f, 0.00934160f, -0.04899335f, 
    0.15070897f, 0.04187872f, 0.07911941f, -0.00662166f, 0.05220928f, -0.04281374f, -0.15713915f, 0.04883459f, 
    -0.11328281f, -0.05968752f, -0.18886010f, 0.19047061f, -0.01935593f, 0.06708986f, 0.04469782f, -0.00489070f, 
    -0.04780385f, -0.04233614f, -0.02529042f, -0.01621684f, -0.00171711f, 0.00411169f, 0.06810948f, 0.03232046f, 
    0.02186282f, 0.00253844f, -0.02879792f, -0.05686799f, -0.12754121f, -0.03275027f, 0.05058122f, 0.00526052f, 
    -0.41265398f, -0.48993760f, 0.56665039f, -0.09917565f, 0.38990179f, 0.08207352f, -0.01200410f, 0.23234539f, 
    -0.06741867f, -0.00110329f, 0.01009157f, -0.00107977f, -0.06104372f, -0.02065098f, -0.05302737f, 0.14404583f, 
    0.10078564f, 0.07677694f, -0.09427188f, -0.17169011f, -0.23186284f, -0.43800327f, -0.19056326f, 0.21145293f, 
    -0.00523025f, -0.03685086f, -0.00051354f, -0.01066682f, -0.03587978f, -0.00252179f, -0.03712396f, -0.02408254f, 
    -0.03938883f, -0.02829785f, 0.00830300f, 0.02336733f, 0.00855005f, -0.05254650f, 0.03028827f, -0.04949658f, 
    -0.05526045f, -0.01616079f, 0.18114355f, -0.11853269f, 0.07867244f, -0.02180751f, 0.03528272f, 0.09036202f, 
    -0.01447522f, 0.05702806f, 0.08650878f, -0.09649555f, 0.08206499f, 0.03591030f, -0.05863569f, -0.02361729f, 
    0.02667194f, -0.08651211f, 0.10013493f, -0.01371432f, 0.08546981f, -0.26964611f, -0.09279364f, 0.05254384f, 
    -0.07239566f, 0.12299999f, -0.04472482f, 0.01146357f, -0.02176721f, -0.19720258f, 0.04391780f, 0.02598732f, 
    0.05011788f, 0.05182448f, -0.01971927f, 0.03629158f, 0.01570635f, 0.05203485f, -0.08879121f, -0.10331433f, 
    0.48228154f, 0.07867803f, 0.02319456f, -0.23569949f, -0.06119048f, 0.03764191f, -0.08458968f, -0.00867790f, 
    0.00216477f, -0.16329554f, 0.05476501f, 0.06576757f, 0.05011657f, 0.03634583f, 0.03806168f, 0.01306199f, 
    0.02196422f, 0.09310962f, 0.12923841f, -0.10744244f, -0.16251205f, -0.07550061f, 0.05555911f, 0.03359871f, 
    -0.06460454f, -0.07904345f, -0.01594308f, -0.00101860f, -0.03646989f, -0.02466053f, 0.02361185f, 0.07496429f, 
    0.04998706f, 0.08159062f, 0.06059479f, 0.03814850f, -0.00472922f, 0.01291658f, 0.02886880f, 0.04529774f, 
    -0.11999542f, 0.08861642f, 0.13957281f, 0.06495559f, -0.17051397f, -0.01077649f, -0.01442546f, -0.02851869f, 
    0.02023910f, -0.05858525f, -0.03722952f, 0.01236042f, -0.05987394f, -0.00244919f, -0.00935017f, 0.03190208f, 
    0.10189106f, -0.07740554f, -0.02543979f, -0.05091316f, 0.49406144f, -0.46611369f, -0.28425601f, 0.10040442f, 
    0.15740366f, 0.07874373f, 0.16285537f, 0.10649379f, -0.09339297f, 0.01227841f, -0.01387652f, -0.00251311f, 
    -0.06476292f, 0.07912178f, -0.03487279f, -0.00420742f, -0.00401842f, -0.02151315f, 0.13130277f, 0.00903460f, 
    0.28489915f, 0.22941054f, -0.01778808f, -0.02214455f, -0.17394079f, -0.01714210f, -0.08559195f, 0.01151470f, 
    0.03698851f, -0.30947810f, -0.00927800f, 0.06553487f, 0.04771540f, 0.00541930f, 0.01856359f, -0.02702293f, 
    0.02161577f, -0.04761826f, 0.13136534f, 0.08370461f, -0.11190063f, 0.13166948f, 0.07990021f, -0.00986057f, 
    -0.15327236f, -0.09263439f, 0.02658469f, -0.04784797f, -0.02648999f, 0.03084136f, 0.01782751f, -0.04874836f, 
    0.00003183f, 0.06556228f, 0.08862902f, -0.02862032f, 0.08673204f, 0.02333685f, 0.00467960f, 0.02586241f, 
    0.20804344f, -0.31134430f, -0.24467024f, -0.21232088f, -0.17941470f, 0.04265964f, -0.08443019f, 0.04568387f, 
    0.06475677f, -0.11377436f, -0.04413049f, 0.05127904f, 0.02148952f, 0.00326126f, 0.08459107f, 0.02989606f, 
    0.05143019f, 0.09709249f, 0.06481081f, 0.17525172f, 0.05163579f, -0.50175512f, -0.82403749f, -0.19893740f, 
    0.11333738f, -0.07569361f, 0.06587704f, 0.25313523f, 0.12748930f, 0.11533821f, 0.05043163f, -0.06803014f, 
    -0.11171359f, -0.00330544f, -0.00424995f, 0.04077925f, -0.04684407f, 0.01603602f, 0.01484481f, -0.00339387f, 
    -0.12270753f, -0.18365194f, -0.90540463f, -0.25921330f, 0.13501285f, 0.04390462f, -0.11973252f, 0.22409251f, 
    0.24952401f, -0.00671904f, 0.11531103f, -0.08160545f, -0.02275040f, 0.01166836f, 0.02174694f, -0.00192036f, 
    0.02232216f, 0.00641741f, -0.04703330f, 0.00306279f, 0.06664909f, 0.01674663f, -0.21876603f, -0.25006384f, 
    -0.04123808f, -0.08068955f, -0.08721413f, 0.00506380f, -0.15818100f, -0.16399330f, -0.00202423f, 0.01316327f, 
    -0.01632205f, 0.06038332f, 0.09920015f, 0.04599237f, 0.03907028f, 0.08646688f, -0.10312472f, -0.28401989f, 
    0.29497328f, -0.37407869f, -0.37599209f, 0.00309738f, -0.01299405f, -0.03702974f, 0.07334530f, 0.05931018f, 
    -0.03849295f, 0.05849279f, 0.02905906f, 0.00803686f, -0.05623550f, -0.00074425f, 0.02004664f, 0.04822448f, 
    0.08141293f, 0.02046168f, 0.12697005f, 0.07694729f, 0.14381039f, 0.01510938f, 0.04333873f, 0.01610908f, 
    -0.10780777f, 0.01979090f, -0.12998840f, -0.10959481f, -0.07255924f, -0.16804048f, -0.03698402f, 0.01822531f, 
    0.08539858f, -0.02438946f, 0.06814390f, -0.07074029f, 0.07224987f, 0.13217048f, 0.17570682f, 0.16037989f, 
    -0.36618844f, -0.05542031f, 0.00914487f, 0.11083200f, 0.15786412f, 0.04233696f, -0.03877042f, 0.05723777f, 
    0.11602308f, -0.15915120f, -0.01231723f, 0.03714029f, 0.12275623f, -0.02133881f, 0.02009247f, -0.08773749f, 
    -0.12538478f, 0.06768484f, 0.17222711f, 0.11215701f, 0.21340537f, -0.02768913f, -0.01027992f, -0.01204536f, 
    0.04485491f, -0.05173740f, -0.06260640f, -0.03540820f, -0.08737198f, -0.09259599f, 0.05775120f, 0.11540017f, 
    -0.02096508f, -0.00878926f, 0.05829891f, -0.05621979f, -0.07191780f, -0.08213207f, -0.11311463f, 0.09297130f, 
    0.41000107f, 0.19925015f, 0.05908855f, -0.10571349f, -0.08365095f, -0.04333127f, 0.15050498f, -0.06284458f, 
    0.07082746f, -0.09360414f, -0.00428723f, 0.02736716f, 0.02226859f, -0.03266946f, 0.06813470f, -0.00566764f, 
    -0.08591946f, -0.16806954f, 0.05809344f, -0.04419900f, 0.43677935f, 0.20566483f, -0.10946090f, -0.12875296f, 
    -0.29850894f, -0.07895739f, -0.08497062f, -0.08761796f, -0.04986169f, -0.14920963f, 0.01503046f, 0.09837621f, 
    -0.07060624f, 0.07043368f, 0.11782791f, -0.21524039f, -0.22745374f, -0.06147419f, -0.23267530f, -0.09357422f, 
    0.17810000f, 0.06012870f, 0.20570683f, -0.08679107f, -0.23424841f, 0.10972538f, -0.00649956f, -0.13417658f, 
    -0.00677103f, -0.30482367f, -0.01108638f, -0.03204548f, -0.00251928f, -0.02134092f, 0.02664424f, 0.03600991f, 
    0.10861804f, 0.02485435f, -0.02937288f, -0.19522862f, -0.04519948f, -0.46650019f, -0.60541213f, -0.39307374f, 
    0.05745838f, -0.04328743f, 0.18690985f, 0.14841251f, 0.15828975f, 0.04518645f, -0.02763273f, -0.08662831f, 
    -0.08959802f, -0.03042545f, -0.02345960f, 0.03011656f, -0.05194452f, -0.03116957f, -0.02502962f, -0.02781782f, 
    -0.00786247f, -0.19903815f, -0.12005496f, -0.08052650f, 0.00290801f, -0.04613304f, 0.06667022f, 0.08097748f, 
    0.03727772f, 0.06270831f, 0.08318124f, 0.04088763f, -0.04264854f, 0.00706691f, 0.02006975f, 0.00007060f, 
    0.03565155f, 0.01958205f, 0.07958631f, 0.00962751f, 0.42391878f, 0.47590455f, 0.01037258f, 0.23448157f, 
    -0.00657231f, 0.12666310f, -0.07028049f, 0.13904205f, 0.09093380f, -0.11712083f, -0.01708010f, -0.04124788f, 
    0.02166013f, -0.03627174f, -0.07980417f, 0.01743958f, -0.01300693f, -0.13438241f, -0.08090558f, -0.17917517f, 
    -0.25524482f, -0.73163295f, -0.74126321f, -0.46040931f, 0.11589649f, -0.04373321f, -0.00455000f, 0.01691367f, 
    0.10462675f, 0.00872292f, -0.03366059f, -0.03255532f, -0.04760561f, -0.03884311f, -0.02746915f, 0.02980429f, 
    0.01539000f, 0.07773957f, 0.09327845f, 0.18240134f, -0.10299160f, -0.04541308f, -0.04594909f, -0.04498443f, 
    -0.08802526f, -0.04972999f, -0.03117915f, -0.03303558f, -0.00364915f, -0.03393456f, 0.02952015f, 0.04754545f, 
    0.05478233f, 0.03405114f, 0.06798904f, -0.04545544f, -0.01596580f, 0.01441480f, 0.09357794f, 0.09305035f, 
    -0.16177700f, -0.34843746f, 0.16323709f, 0.17964554f, 0.32532418f, -0.12443358f, -0.02493206f, -0.11393632f, 
    -0.03579665f, -0.05271471f, -0.00362460f, -0.05204263f, 0.02234061f, -0.00629776f, 0.02267319f, -0.09246390f, 
    -0.03490856f, -0.31561124f, -0.16898182f, -0.16254403f, 0.22982231f, -0.36799094f, -0.39247504f, -0.40927345f, 
    -0.06913121f, -0.01699177f, -0.15939972f, 0.00623401f, -0.15134992f, -0.25483507f, 0.03672608f, 0.00901844f, 
    0.02013913f, 0.01517000f, 0.09669787f, 0.06711942f, 0.04400284f, 0.11088110f, -0.21674474f, -0.27541500f, 
    0.06327499f, -0.14188665f, -0.41337839f, -0.03468324f, 0.20149253f, 0.00861115f, 0.00665083f, 0.10182956f, 
    0.06474369f, 0.06223226f, 0.00970899f, -0.00074722f, -0.05528339f, 0.02432008f, -0.00341995f, 0.08003466f, 
    0.02489263f, -0.02585575f, -0.09111378f, -0.11652056f, 0.17824540f, 0.14450996f, -0.33594203f, -0.18803702f, 
    -0.14922616f, 0.08805966f, -0.07329749f, 0.15579386f, 0.14380263f, 0.05672726f, 0.20729567f, 0.05754464f, 
    -0.07816417f, -0.05237022f, 0.06860622f, -0.03029308f, 0.04486712f, -0.01704893f, -0.02097064f, -0.00279942f, 
    -0.07462347f, -0.16320907f, -0.57515037f, -0.25798717f, 0.03934249f, -0.07687315f, 0.07296199f, 0.16629411f, 
    -0.00005551f, -0.08873382f, -0.04370375f, -0.08232296f, -0.05436137f, 0.09289469f, 0.10359348f, 0.06703620f, 
    -0.01168491f, 0.07463107f, -0.02168483f, -0.06939071f, 0.63310802f, 0.11945427f, -0.11190963f, 0.00394296f, 
    -0.04447046f, 0.09352994f, -0.04252601f, 0.04649884f, 0.06125484f, 0.06350833f, 0.05042906f, 0.03721810f, 
    0.07841394f, 0.04784860f, 0.02807605f, -0.03944033f, -0.00437941f, 0.07011295f, -0.12041517f, 0.04003736f, 
    -0.42255005f, 0.03118742f, 0.15153839f, 0.03580159f, -0.21485911f, -0.02283281f, -0.08107188f, -0.06670881f, 
    -0.01481226f, -0.06166503f, -0.04682254f, -0.05860724f, -0.08004262f, -0.03845813f, -0.03694609f, -0.04110910f, 
    0.03196552f, 0.02087138f, -0.10024671f, -0.00981040f, 0.31125501f, -0.00271984f, -0.06772279f, 0.09462202f, 
    -0.01733881f, -0.04506349f, -0.02323150f, -0.06338369f, -0.00575590f, 0.09451937f, 0.14087206f, -0.01352039f, 
    0.02525526f, 0.04616415f, 0.03617352f, -0.09288593f, 0.03179520f, 0.04565343f, -0.00013586f, 0.08734143f, 
    -0.20404948f, 0.06858887f, 0.11984037f, 0.03328945f, -0.11375081f, -0.07831126f, -0.01049310f, 0.01799620f, 
    0.00692970f, -0.01432818f, -0.02480293f, -0.01377849f, -0.04500491f, 0.02804046f, 0.02458883f, 0.03243139f, 
    0.12393714f, 0.02758247f, 0.04166925f, 0.04459122f, -0.30982006f, 0.16358075f, 0.24290475f, 0.18063995f, 
    -0.06962100f, 0.02085490f, -0.14658335f, -0.04747861f, -0.06182167f, -0.04317869f, -0.03484335f, -0.03678288f, 
    -0.00649638f, -0.07583590f, -0.07674105f, -0.17160413f, -0.10019407f, -0.08520344f, -0.17000102f, -0.05024888f, 
    -0.10594266f, -0.16968717f, -0.08846648f, -0.08164937f, -0.02516591f, -0.18688084f, -0.18056868f, -0.06707916f, 
    0.04534488f, 0.03568124f, -0.07568210f, 0.09728761f, -0.15569517f, -0.07290923f, 0.00121828f, -0.06507340f, 
    0.07748012f, 0.11971179f, 0.05633273f, 0.06704071f, -0.08960228f, 0.15458986f, 0.10366461f, -0.00928925f, 
    -0.19930062f, -0.04141629f, 0.03922226f, -0.01376224f, -0.00084587f, 0.01643986f, 0.02468575f, -0.04829958f, 
    0.02234755f, 0.10145068f, 0.05606178f, -0.01881267f, 0.11066858f, -0.03292881f, 0.02125086f, -0.08900222f, 
    0.02575727f, -0.13258153f, -0.09450880f, -0.11638553f, -0.11670117f, -0.09730064f, -0.00632751f, 0.05897580f, 
    0.02766072f, 0.00736148f, 0.10499509f, 0.12113447f, 0.02236839f, -0.04967535f, 0.03423931f, 0.02694562f, 
    0.05742483f, -0.00352719f, 0.03659640f, 0.12607850f, 0.25742888f, -0.16664647f, -0.34570694f, -0.12298507f, 
    -0.02996319f, 0.05277207f, 0.00325463f, 0.07970092f, 0.05105688f, 0.10485946f, 0.02055004f, -0.03979353f, 
    0.03491255f, 0.02884446f, -0.02728951f, -0.05118574f, 0.01127497f, -0.07171862f, 0.02792896f, 0.00628084f, 
    -0.07718863f, -0.40857941f, -0.51292694f, -0.16118261f, -0.00869873f, -0.05598112f, 0.00414327f, 0.14960888f, 
    0.15861730f, 0.15389694f, 0.08081638f, -0.08008156f, -0.06520188f, -0.05841112f, -0.09640816f, -0.05360092f, 
    0.01762492f, 0.05712916f, 0.02623720f, 0.00386500f, -0.10579214f, -0.02216908f, 0.02555292f, -0.07622312f, 
    -0.12576589f, -0.05752601f, -0.03645978f, 0.01297974f, -0.01600353f, -0.04061012f, 0.00399429f, 0.05214728f, 
    0.06151137f, 0.10135657f, 0.09253336f, 0.02633299f, 0.01178108f, -0.00428021f, 0.07079595f, 0.06486776f, 
    -0.08859608f, -0.04237760f, -0.10456721f, -0.01828310f, -0.19023974f, -0.10173203f, 0.04570583f, -0.00994429f, 
    0.07862197f, -0.03648666f, 0.05862854f, 0.07939354f, -0.01222459f, 0.07403344f, 0.16076200f, 0.07780468f, 
    0.03874499f, -0.04350141f, 0.06512807f, 0.05567972f, -0.17878631f, 0.00829802f, 0.01042149f, -0.03466001f, 
    -0.19501519f, -0.06417406f, -0.03291500f, -0.06838880f, -0.02478276f, -0.00328363f, -0.06247496f, -0.08961066f, 
    0.00922216f, 0.00025285f, -0.01948390f, -0.04202146f, 0.03228932f, -0.05045487f, -0.01901012f, -0.04322844f, 
    -0.18278962f, -0.16258195f, 0.02259068f, 0.03597361f, 0.07513853f, 0.09795766f, -0.07714121f, 0.07546417f, 
    -0.03428673f, -0.00333290f, 0.02898713f, -0.00633062f, 0.01805746f, -0.03212454f, 0.03162504f, -0.18088251f, 
    -0.07363436f, -0.04990858f, -0.14579794f, -0.41354102f, -0.09517377f, 0.05516173f, -0.04065948f, 0.00174650f, 
    -0.12570702f, -0.07591648f, -0.04759252f, -0.05495075f, -0.02513974f, -0.08494644f, -0.01009536f, 0.04204302f, 
    0.02393043f, 0.00515366f, 0.04393521f, -0.01174622f, 0.07897607f, 0.05283259f, 0.13192959f, 0.06170879f, 
    0.17777435f, -0.17718998f, -0.07304573f, 0.08415467f, -0.04106726f, 0.00185793f, -0.06144460f, -0.10436038f, 
    -0.13310960f, 0.00311411f, 0.06592645f, 0.09857715f, -0.01844500f, 0.02431021f, 0.01217811f, 0.02284801f, 
    0.13461336f, 0.11044199f, 0.06980202f, 0.17942889f, 0.23592405f, 0.17106006f, 0.01095994f, -0.08136132f, 
    -0.25417587f, 0.00218328f, 0.01691097f, -0.06464385f, 0.03770266f, -0.04540323f, -0.02789849f, 0.01853321f, 
    0.02072672f, 0.03102582f, 0.01625945f, -0.02024275f, -0.03681537f, -0.08141997f, 0.08740114f, -0.24793093f, 
    0.37644780f, 0.29111797f, -0.31854820f, -0.08222242f, -0.09684005f, 0.08489017f, 0.00445766f, 0.13099612f, 
    0.14053974f, -0.05862789f, 0.05556257f, 0.04305898f, 0.07531554f, 0.01492744f, 0.00578339f, -0.04471345f, 
    -0.01749903f, 0.00676322f, 0.02931104f, -0.17937362f, -0.13322967f, -0.28175426f, -0.18385537f, 0.02606650f, 
    0.08405207f, -0.12078390f, 0.01825937f, 0.02777492f, 0.02177587f, 0.14067814f, 0.03856533f, 0.04773589f, 
    -0.10037385f, -0.04475978f, 0.02537621f, -0.03973800f, 0.07974232f, 0.02267513f, 0.11246188f, 0.05756659f, 
    -0.24545203f, -0.48687181f, -0.52319199f, -0.24221222f, -0.12380613f, -0.20037448f, -0.01993386f, 0.05982241f, 
    -0.03031764f, 0.07137852f, -0.11572699f, -0.04494209f, -0.05321062f, -0.05587965f, -0.00859799f, -0.02302202f, 
    0.04324527f, 0.05511397f, 0.03112771f, 0.02683209f, -0.00719070f, -0.21734901f, -0.58228070f, -0.13246539f, 
    0.09375755f, 0.15531059f, -0.01889954f, 0.19223131f, 0.03625031f, 0.05367485f, 0.00873059f, 0.01937160f, 
    -0.07895664f, 0.04079289f, -0.02927646f, 0.01151260f, 0.03067954f, 0.08376195f, -0.03404722f, 0.00183133f, 
    0.13416435f, 0.02008950f, -0.09973793f, -0.12544990f, -0.01612593f, -0.01863624f, 0.06470589f, -0.06256566f, 
    0.00648377f, -0.16112293f, -0.10135516f, 0.03462725f, 0.01222807f, -0.09298615f, 0.07877792f, -0.01881134f, 
    -0.02380197f, -0.17778321f, 0.02802774f, 0.17185870f, 0.22139950f, -0.10936926f, -0.07842368f, 0.01991908f, 
    -0.07220345f, -0.08817858f, -0.06452449f, -0.09973263f, -0.06349906f, -0.08258093f, 0.03750120f, 0.09161635f, 
    0.12913899f, -0.04299515f, 0.06922321f, -0.05825566f, 0.10777673f, 0.09662212f, 0.11040650f, 0.14191212f, 
    -0.42666784f, -0.16118847f, 0.16196351f, 0.04000319f, 0.05755648f, -0.05033054f, 0.02496883f, -0.03525215f, 
    -0.02064278f, 0.08935115f, 0.08537777f, 0.08775081f, 0.00469522f, 0.10253809f, 0.07079723f, 0.00727130f, 
    0.02117131f, 0.03018114f, 0.11911225f, 0.07527897f, 0.12150829f, -0.04994269f, -0.36341947f, -0.26388758f, 
    -0.08198012f, -0.09117723f, 0.12449194f, 0.01126843f, 0.15406652f, 0.05375453f, 0.07900196f, -0.05049622f, 
    0.02701162f, -0.06293510f, 0.04557786f, 0.01409956f, -0.00910689f, -0.03952792f, 0.01364181f, -0.11116971f, 
    -0.11371101f, 0.01588202f, 0.11645881f, 0.10461660f, -0.07600668f, -0.04756519f, 0.01742535f, -0.10427685f, 
    -0.04680447f, 0.04445989f, -0.01385182f, 0.03385777f, 0.02479918f, 0.04240800f, -0.00725959f, 0.09499045f, 
    0.00436947f, -0.05871733f, -0.03039980f, 0.00934539f, 0.00752250f, -0.05685138f, -0.12875986f, -0.29390761f, 
    -0.19805495f, -0.07050391f, -0.30645084f, -0.21813825f, -0.20316711f, -0.32010856f, 0.04058626f, 0.04243933f, 
    0.00100009f, 0.04205029f, 0.02363354f, 0.08061794f, 0.04757318f, 0.17489226f, -0.11337684f, -0.30170119f, 
    0.04339819f, -0.60445899f, 0.04559543f, -0.26394662f, 0.05814467f, -0.14762025f, 0.13162212f, 0.01703800f, 
    0.12065370f, -0.01892591f, 0.03034942f, 0.09673555f, 0.04112238f, -0.16126943f, -0.01207110f, -0.01897964f, 
    -0.01576565f, -0.05864182f, 0.02675514f, -0.06657819f, 0.37609589f, 0.03276456f, 0.02572066f, -0.05680522f, 
    -0.24118362f, -0.06771382f, -0.05145643f, 0.07869416f, 0.02341010f, -0.08957040f, 0.05522314f, 0.09237778f, 
    -0.05167507f, 0.02026795f, 0.09246121f, -0.03531187f, 0.19102487f, -0.02240927f, 0.15330142f, 0.09180274f, 
    0.04807904f, -0.01219637f, -0.02205909f, 0.01500421f, 0.18698049f, 0.04336544f, 0.07658695f, 0.02019722f, 
    0.05320529f, 0.05788695f, 0.09068356f, -0.04997665f, 0.09257239f, 0.08742034f, -0.01929004f, -0.03163500f, 
    -0.06369666f, 0.05537082f, 0.04601398f, 0.02204769f, 0.26000333f, 0.10979187f, 0.00121255f, -0.17287047f, 
    -0.22284417f, -0.04090965f, -0.21543582f, -0.04359168f, 0.01401630f, -0.16734555f, 0.02244298f, 0.11661538f, 
    0.06128015f, 0.05102581f, 0.01603490f, 0.07416932f, 0.05702517f, 0.03483847f, 0.01020737f, -0.16132168f, 
    -0.56457406f, -0.51707762f, -0.02715862f, 0.24705558f, -0.06465942f, 0.00766726f, 0.03853659f, 0.00707593f, 
    -0.10295293f, -0.14802265f, -0.10019336f, -0.02204880f, 0.00195952f, 0.02586393f, 0.00372703f, 0.02636878f, 
    0.04833330f, 0.03687606f, 0.05841913f, -0.02279379f, -0.21093151f, 0.10907935f, 0.14410591f, 0.09152636f, 
    -0.08891899f, -0.02560828f, -0.03237195f, -0.00874565f, 0.00593482f, -0.01207998f, -0.07344551f, -0.00486622f, 
    0.03272475f, -0.01543300f, -0.01740376f, -0.03493775f, 0.01976122f, 0.02751486f, -0.00222439f, 0.02908872f, 
    0.06101054f, -0.61589301f, -0.16548535f, -0.07518825f, 0.14971475f, 0.02679116f, 0.11814604f, -0.05131026f, 
    -0.08826414f, 0.05295815f, 0.00162748f, 0.01279846f, 0.05545069f, -0.03409988f, 0.03465289f, -0.02068733f, 
    -0.17587981f, -0.11286453f, -0.31953838f, -0.34877062f, 0.20648234f, -0.32112172f, -0.29127663f, -0.15955463f, 
    -0.00700935f, -0.03006742f, -0.05308833f, 0.00772092f, 0.04528411f, 0.02556537f, -0.06776539f, 0.01402276f, 
    -0.01345663f, 0.01736874f, 0.03581847f, -0.01643065f, 0.04758338f, 0.10545537f, 0.01727714f, 0.13048141f, 
    -0.26433825f, -0.17256296f, 0.05239733f, 0.05626133f, 0.02161942f, -0.00337504f, -0.03485082f, 0.01593613f, 
    0.00698742f, 0.05224985f, 0.02925263f, -0.02972521f, -0.01847146f, 0.08084556f, 0.06718078f, -0.07144526f, 
    0.07142244f, 0.08997294f, -0.03355773f, 0.09104230f, 0.26912838f, -0.12491559f, -0.16348773f, -0.00589191f, 
    -0.01991333f, -0.06008066f, 0.07805704f, 0.04753247f, -0.01345579f, 0.05769848f, 0.09476897f, 0.03800692f, 
    -0.09500490f, -0.05198531f, -0.00552455f, 0.01979713f, 0.07934473f, 0.04281488f, 0.12361208f, 0.08748198f, 
    0.15099762f, 0.01787115f, -0.51052970f, 0.13543406f, -0.19954257f, -0.08211628f, -0.03346531f, 0.02508175f, 
    -0.07435781f, 0.08332394f, -0.03310927f, -0.02228767f, -0.00451383f, -0.02049158f, -0.02457348f, 0.06283287f, 
    0.00574663f, -0.06357757f, 0.06134002f, -0.03827814f, 0.02109118f, 0.14793153f, 0.07306835f, 0.17882618f, 
    0.04467229f, -0.03841787f, -0.13629007f, -0.03845612f, -0.00932557f, -0.05060711f, 0.02673518f, 0.02694762f, 
    0.00828659f, 0.07610599f, -0.17268819f, 0.08454475f, 0.05375366f, 0.00529566f, -0.06049467f, 0.08037934f, 
    -0.08331286f, -0.06211773f, -0.12782264f, -0.12027009f, 0.05356179f, 0.04502980f, 0.08150589f, 0.10520968f, 
    -0.00803238f, 0.06898339f, 0.06608262f, -0.08027520f, -0.05384757f, 0.04165901f, -0.05663579f, 0.11813454f, 
    0.00601741f, 0.02795074f, -0.00678461f, 0.04466951f, -0.46226767f, 0.02462078f, 0.21186639f, -0.06261477f, 
    -0.29616761f, -0.04649870f, -0.24764077f, 0.10543750f, -0.29357013f, -0.22261454f, -0.03685198f, 0.02406643f, 
    -0.04866395f, 0.03998275f, -0.02013704f, -0.18798178f, -0.05804801f, -0.05505713f, -0.03321070f, 0.00952907f, 
    -0.34669992f, 0.38901529f, -0.59784442f, -0.14288132f, -0.07355903f, 0.05329745f, 0.03063334f, 0.12658115f, 
    -0.04832541f, 0.01162744f, 0.02363375f, -0.11033200f, -0.10135382f, 0.02739450f, -0.06138101f, 0.05113163f, 
    -0.06361053f, -0.08007804f, 0.00377805f, -0.09338213f, -0.21474624f, -0.03441891f, -0.10508101f, -0.08973714f, 
    0.08813662f, 0.02383087f, 0.17831157f, 0.01866735f, 0.02669661f, -0.14728354f, 0.05920690f, 0.08271840f, 
    -0.00374652f, -0.10294670f, 0.04088507f, 0.17713837f, 0.01038519f, -0.04778547f, -0.03165592f, -0.06207456f, 
    0.18758138f, 0.08118910f, -0.19109455f, 0.05743660f, -0.19680722f, -0.17689915f, -0.04813990f, 0.19975889f, 
    0.00042217f, 0.17691723f, -0.04020219f, -0.00013114f, 0.01965637f, -0.07845881f, 0.00388702f, 0.03550514f, 
    0.00895310f, 0.05782118f, 0.07939161f, -0.18663947f, 0.01258002f, 0.16289508f, -0.32061216f, 0.45959339f, 
    -0.44791681f, -0.22062367f, 0.05661537f, -0.25823992f, 0.08427360f, -0.08518948f, 0.10550006f, -0.11866062f, 
    0.03931669f, 0.04904665f, 0.12055869f, 0.03922849f, 0.10092498f, 0.02509520f, -0.01593263f, -0.02298141f, 
    -0.22442490f, -0.01499058f, -0.07543990f, 0.35102656f, -0.40167677f, -0.23118821f, 0.14742574f, -0.33562636f, 
    0.04433813f, -0.06970334f, 0.08266973f, -0.03587501f, 0.06587295f, 0.09201624f, 0.11249453f, 0.06816763f, 
    0.03521287f, -0.01458581f, 0.03614936f, -0.02577177f, -0.07855183f, 0.00351993f, 0.09457698f, 0.13236858f, 
    -0.24985164f, -0.01457142f, -0.03271741f, -0.04483457f, 0.05084553f, 0.11491340f, 0.04059343f, 0.01784803f, 
    0.05888223f, 0.04511004f, 0.02358310f, -0.11502301f, 0.08284738f, 0.04440251f, 0.15395203f, 0.05315781f, 
    -0.24992591f, -0.11446891f, -0.06643540f, -0.09712994f, -0.09471987f, -0.17947346f, 0.07174690f, -0.02301495f, 
    0.05150558f, 0.05989163f, -0.03282407f, -0.03115971f, 0.04347585f, -0.01915446f, 0.02333612f, 0.00015561f, 
    0.01413376f, -0.00308994f, -0.04972352f, -0.08924922f, 0.07000867f, 0.13772728f, -0.31458056f, 0.08571906f, 
    -0.08301622f, -0.00490373f, -0.00078239f, 0.18674566f, 0.00196148f, 0.06780789f, 0.01528193f, -0.03561718f, 
    -0.09896448f, -0.05465994f, -0.10146446f, 0.09315074f, -0.03346626f, -0.05549188f, -0.02733194f, -0.12008829f, 
    -0.09342482f, 0.33302191f, -0.23310821f, -0.41300294f, 0.02867497f, -0.11329947f, 0.16138349f, 0.08820625f, 
    -0.05249446f, 0.17367966f, -0.07118901f, 0.03247667f, -0.08391435f, 0.01961584f, -0.02987517f, 0.03787470f, 
    0.13411210f, -0.12968625f, -0.00976360f, -0.10565744f, -0.23298638f, 0.05224305f, -0.18005775f, -0.09235027f, 
    0.23525929f, -0.09811481f, 0.02540674f, 0.05510106f, -0.27207804f, 0.01149826f, 0.15300953f, 0.02895067f, 
    0.01923875f, -0.01522969f, -0.02906489f, 0.08422939f, 0.10750212f, -0.02599125f, -0.12335005f, -0.03007957f, 
    -0.58790278f, -0.00843838f, -0.41348234f, 0.05231072f, 0.02361663f, 0.04173326f, -0.03287395f, 0.10180790f, 
    -0.11582567f, 0.00183271f, -0.00091104f, -0.04989813f, 0.02853824f, 0.03721818f, 0.01247161f, 0.01384764f, 
    0.01560161f, -0.02882816f, 0.08691230f, 0.03690054f, -0.68346834f, -0.25070891f, -0.24479839f, 0.13216609f, 
    0.31099412f, -0.08771709f, 0.13869520f, 0.02325318f, -0.26044580f, 0.13067475f, 0.07230915f, -0.13477343f, 
    0.06801033f, 0.02327238f, -0.04055938f, 0.11709320f, 0.07051591f, -0.05759458f, -0.00309047f, -0.02199179f, 
    0.11859796f, 0.36636537f, -0.52909267f, 0.05383805f, -0.08360626f, 0.06372264f, 0.08979896f, 0.17419107f, 
    -0.08393849f, 0.14488201f, 0.05494943f, 0.00540575f, -0.03539560f, 0.01169632f, -0.11318719f, 0.09409635f, 
    0.05598915f, 0.00785402f, 0.03011750f, 0.00104330f, -0.05015118f, -0.08329340f, 0.21847714f, 0.38925987f, 
    -0.70920324f, 0.19932885f, -0.16857190f, -0.22309935f, 0.00463858f, -0.01802366f, 0.05919715f, -0.01736194f, 
    0.06264328f, 0.07815933f, 0.07018911f, -0.01396672f, -0.02380723f, 0.01289172f, 0.02746032f, 0.03554748f, 
    0.08995822f, 0.05143225f, 0.16052905f, 0.21550761f, -0.03646103f, -0.02264143f, -0.07383633f, -0.14867546f, 
    -0.13062765f, -0.17458659f, 0.03876100f, 0.02451927f, 0.01113297f, 0.15300611f, 0.03057941f, 0.06999430f, 
    -0.00875207f, -0.09407663f, -0.04101676f, 0.02461103f, -0.41377848f, -0.22252654f, -1.23627830f, 0.26645705f, 
    -0.00311284f, 0.05788670f, 0.02046201f, 0.27898517f, -0.04966211f, -0.08600046f, 0.04186727f, -0.00260465f, 
    -0.01237990f, 0.00615134f, -0.02606929f, -0.08447560f, 0.12746252f, 0.10383254f, 0.09884515f, 0.25071871f, 
    -0.29001591f, -0.13447361f, 0.44040802f, -0.17155941f, -0.46141833f, 0.09849416f, -0.38420767f, 0.07790783f, 
    0.10830041f, 0.23564214f, 0.00751138f, 0.01298838f, -0.03184505f, 0.00878132f, 0.02317077f, -0.04394848f, 
    -0.00029575f, 0.07894129f, -0.16769922f, -0.11985558f, -0.11995547f, 0.04064009f, 0.03555967f, 0.04917303f, 
    0.06507099f, -0.03490524f, -0.01400718f, -0.03243566f, -0.02139670f, -0.08244804f, 0.10744059f, 0.17501155f, 
    0.09317926f, -0.01170244f, 0.00903993f, 0.12808751f, 0.03093725f, -0.01585663f, 0.05809299f, 0.05101724f, 
    0.12425342f, -0.20169601f, -0.08907606f, -0.02176600f, -0.21645705f, 0.00808158f, -0.11081921f, 0.04678170f, 
    0.15733446f, -0.04588687f, -0.10841317f, 0.01896487f, -0.01794102f, -0.08419176f, 0.02883880f, 0.14752910f, 
    0.14903826f, 0.09065934f, -0.01887771f, 0.29575297f, -0.05809198f, -0.51190740f, -0.08464731f, 0.10402444f, 
    -0.11026803f, -0.05285003f, -0.37098640f, -0.00392798f, 0.04632517f, 0.15043256f, -0.03522965f, 0.03076958f, 
    0.04516489f, 0.04063885f, 0.09123573f, -0.01132563f, 0.05483747f, 0.08726530f, 0.11740749f, 0.13652797f, 
    0.13570711f, 0.12859091f, -0.03098166f, 0.23249039f, -0.32399291f, 0.06860089f, -0.14303397f, -0.12337390f, 
    0.10778858f, -0.03956052f, 0.05587868f, -0.05159286f, 0.06500916f, 0.02770755f, 0.08572862f, 0.08023577f, 
    0.02607181f, 0.02746332f, 0.04843688f, 0.11415718f, -0.70789343f, -0.08795420f, -0.09229416f, -0.05304446f, 
    0.38376376f, -0.37901247f, 0.30197945f, -0.35011968f, -0.06880768f, 0.16045581f, 0.09701834f, -0.06129748f, 
    -0.06110546f, -0.09640079f, 0.01245464f, 0.12635703f, 0.06276726f, -0.01560935f, -0.07031673f, -0.06319635f, 
    0.10897709f, -0.08538571f, 0.09185893f, 0.21678971f, -0.58584219f, -0.11436908f, 0.01588180f, -0.16917750f, 
    0.11778821f, 0.07772733f, 0.05816455f, -0.00486912f, 0.04208318f, 0.06893701f, 0.04423055f, 0.05465820f, 
    0.07848291f, 0.03360258f, 0.06834427f, 0.07326180f, -0.10936448f, -0.30607250f, -0.04548823f, -0.00114841f, 
    -0.07529329f, 0.00580734f, -0.15084384f, -0.01055100f, -0.03659172f, -0.01345897f, -0.02887033f, 0.02924619f, 
    0.04911491f, -0.05965742f, 0.03070254f, 0.01819549f, 0.06699684f, -0.10123660f, 0.02427980f, 0.02170995f, 
    -0.04146289f, -0.17456760f, -0.32769907f, -0.03990120f, 0.05744657f, 0.00173542f, 0.06499809f, 0.15523472f, 
    0.06489693f, 0.06885226f, -0.01498959f, -0.07474862f, -0.04377637f, 0.01128610f, -0.05693446f, -0.01593982f, 
    0.02533024f, 0.02360549f, 0.01515012f, 0.01432095f, -0.07346079f, -0.05544754f, 0.28149667f, -0.12556280f, 
    -0.02313844f, 0.06883567f, -0.07718308f, -0.08218219f, -0.02035400f, 0.05309609f, 0.08478259f, -0.10983101f, 
    0.12710494f, -0.05878521f, -0.13392067f, 0.12446980f, 0.05180482f, -0.21093653f, -0.08303034f, -0.08466651f, 
    0.00318530f, -0.12771238f, -0.09339307f, -0.11049467f, -0.01167802f, 0.04423858f, 0.11973982f, 0.08773721f, 
    0.13042898f, -0.02460162f, 0.08501493f, -0.01080081f, -0.06659731f, 0.01479600f, 0.03899367f, 0.12624840f, 
    0.04250323f, 0.03679683f, 0.01259726f, 0.03933816f, -0.03119646f, -0.22345254f, -0.51301664f, 0.05484558f, 
    0.13276449f, 0.01320798f, 0.12501420f, 0.11546436f, 0.06763195f, 0.02314507f, -0.01364636f, -0.01453373f, 
    -0.07951123f, -0.00505646f, -0.05555970f, 0.00813126f, 0.06765816f, 0.00529343f, 0.00955208f, -0.04467765f, 
    -0.00046774f, 0.03505093f, 0.14824314f, -0.02609570f, -0.05284667f, 0.01552863f, 0.03893698f, -0.05194609f, 
    -0.01012060f, 0.04587926f, -0.05459762f, 0.02772438f, 0.14777999f, -0.00638465f, -0.00428613f, 0.04076082f, 
    -0.05218711f, -0.04112712f, -0.07771603f, -0.09235892f, -0.13594566f, 0.12899897f, -0.11514382f, -0.08030689f, 
    0.02942642f, 0.03376754f, 0.05104641f, 0.00322633f, 0.00035282f, -0.19564106f, -0.06434531f, -0.00295174f, 
    -0.06903326f, -0.13538603f, 0.10563237f, 0.17728719f, -0.10493489f, 0.00872634f, 0.02794159f, 0.00078867f, 
    -0.06153160f, 0.12015103f, 0.01979047f, 0.23834878f, 0.05814559f, -0.00467863f, 0.06183628f, -0.15074639f, 
    -0.14118983f, -0.07987025f, 0.06296515f, -0.02856742f, 0.08303841f, 0.03464722f, 0.04307164f, 0.05137739f, 
    0.04722931f, -0.04828383f, -0.03049959f, -0.01648546f, -0.08639029f, 0.16500551f, 0.05738161f, 0.14553200f, 
    -0.12679772f, -0.06350621f, -0.14289483f, -0.04850697f, -0.21090066f, -0.11032853f, 0.12816183f, -0.10368339f, 
    -0.01674166f, 0.01714883f, 0.07206977f, -0.02947188f, -0.07406473f, -0.10913339f, 0.06832036f, 0.08629060f, 
    0.32418966f, 0.12702905f, 0.29657662f, 0.36518690f, -0.23408991f, 0.00540095f, -0.04159595f, -0.36538211f, 
    -0.07475975f, -0.17313656f, 0.13174456f, 0.01468171f, 0.06508194f, 0.09807983f, 0.07140879f, 0.07364778f, 
    -0.00133760f, -0.04853702f, 0.03652526f, 0.02844605f, -0.06397396f, 0.06861866f, 0.02752636f, 0.05060451f, 
    0.15844606f, -0.04383216f, 0.01424806f, 0.02771312f, -0.06799530f, -0.07043317f, 0.13983005f, 0.13957176f, 
    0.10517628f, -0.05361147f, -0.00676986f, 0.08242529f, 0.06973853f, 0.01367251f, -0.00337492f, 0.05568082f, 
    -0.35414717f, 0.05609867f, 0.00553370f, 0.01040592f, 0.01014983f, 0.00323874f, -0.11326241f, -0.02381497f, 
    -0.08586151f, 0.00754994f, -0.09857155f, 0.05690804f, -0.05240066f, 0.10270312f, -0.03446249f, 0.09838515f, 
    0.02124959f, 0.02807898f, -0.13063303f, -0.00361606f, -0.09598708f, 0.01914039f, -0.10680904f, -0.21790187f, 
    0.18996727f, -0.00029393f, 0.04711038f, -0.11761271f, -0.01539680f, -0.12487940f, -0.11057743f, 0.04575000f, 
    0.04024111f, -0.05512579f, -0.03719196f, 0.14444304f, -0.09983609f, -0.03697336f, -0.02939340f, -0.01044067f, 
    0.10496476f, -0.49155122f, -0.30153394f, 0.02397257f, 0.10951188f, -0.08074436f, 0.01971000f, 0.10737514f, 
    0.08035144f, 0.12934411f, -0.04266028f, 0.02619549f, 0.02129751f, -0.03042966f, -0.02678799f, -0.07346498f, 
    0.13601872f, 0.22828004f, -0.05878812f, 0.17419361f, -0.12329073f, 0.09236041f, -0.16105363f, -0.11655254f, 
    -0.04400793f, 0.10972367f, 0.09221813f, 0.16526094f, 0.03910092f, -0.09055112f, 0.11694406f, -0.03892871f, 
    -0.09854635f, -0.03184809f, -0.07113741f, 0.14359359f, -0.00699983f, -0.10006181f, 0.02442680f, 0.00148197f, 
    0.00972956f, 0.05950031f, 0.25410959f, -0.09067203f, -0.13576770f, 0.03419242f, 0.01661588f, 0.08549998f, 
    -0.02906106f, 0.02746790f, 0.03532153f, -0.09860375f, 0.08093380f, -0.01902560f, 0.00326937f, -0.00486041f, 
    -0.01254716f, -0.08246558f, -0.08821592f, -0.10303887f, -0.29312256f, 0.21103378f, -0.17480820f, 0.36019742f, 
    -0.02288371f, 0.05334595f, -0.21343625f, 0.03248132f, 0.05118512f, -0.09486461f, 0.07510308f, 0.04478685f, 
    0.07092076f, -0.07244281f, -0.05912949f, -0.04617334f, -0.05570997f, -0.07027843f, -0.00488640f, 0.12913448f, 
    -0.70699209f, -0.17935561f, -0.54413497f, 0.16378760f, -0.24170543f, -0.04172239f, -0.06256282f, 0.04672695f, 
    0.02047082f, -0.12059123f, -0.01479281f, 0.04072112f, 0.06586962f, 0.00267057f, 0.01936909f, -0.16521807f, 
    0.11659225f, -0.10528533f, 0.08214002f, 0.20119667f, 0.02139634f, 0.09430248f, 0.51890981f, -0.18801679f, 
    -0.30031577f, 0.01702891f, -0.19642051f, -0.08799034f, 0.03426260f, 0.03272986f, -0.01822074f, 0.08010062f, 
    0.10749509f, 0.05499773f, -0.03468109f, -0.04153045f, -0.01630553f, -0.05732969f, -0.09907479f, 0.00268140f, 
    -0.38545194f, -0.23940176f, 0.19089916f, -0.00404298f, -0.32949510f, -0.06509970f, -0.13561501f, 0.04069461f, 
    0.11371756f, 0.18808615f, 0.01926078f, 0.00344909f, 0.03802019f, -0.00170166f, -0.05828300f, -0.01393336f, 
    0.00141574f, -0.03345125f, -0.08434844f, -0.04758686f, 0.15472746f, -0.10096001f, -0.16786927f, -0.07048398f, 
    -0.24770446f, -0.14993708f, 0.06976417f, -0.13360938f, 0.00142010f, 0.12208290f, 0.05127728f, -0.02467659f, 
    0.04948629f, 0.01414659f, 0.08278614f, 0.02441300f, 0.00085041f, 0.10511754f, -0.03843230f, -0.06594746f, 
    -0.39226666f, -0.17168085f, -0.05821608f, 0.10518394f, 0.09921040f, -0.10204637f, 0.02149569f, -0.03704306f, 
    -0.15443195f, -0.16420007f, 0.02338501f, 0.13449180f, 0.04602122f, -0.09789367f, -0.06620122f, -0.15325446f, 
    0.08302502f, -0.14512642f, -0.10918020f, 0.23240642f, 0.08076891f, 0.06771272f, 0.20816216f, 0.02464837f, 
    -0.10141617f, 0.06526157f, -0.03314214f, 0.09518951f, 0.03937893f, 0.00800297f, -0.04854425f, -0.05776384f, 
    0.00416710f, -0.06153130f, -0.04022986f, 0.04964280f, -0.04346872f, -0.08146997f, -0.06032363f, -0.12453128f, 
    0.00622225f, -0.02119310f, 0.30372134f, -0.35482404f, -0.07992545f, -0.03658380f, -0.09972762f, -0.04028215f, 
    0.14933476f, -0.00691891f, -0.02859171f, 0.10047080f, 0.06608211f, -0.04188386f, -0.00719531f, 0.06574841f, 
    0.12829262f, -0.02111563f, -0.06996430f, 0.03965624f, -0.18371421f, 0.24256937f, 0.06271110f, 0.42747030f, 
    -0.18139955f, 0.17041978f, -0.11309516f, -0.15657806f, -0.01244772f, -0.19945467f, 0.08046756f, -0.06792391f, 
    0.02965461f, -0.02580475f, 0.06043185f, 0.09639706f, -0.05936695f, -0.02663764f, -0.01518769f, 0.00297923f, 
    -0.06203090f, -0.15946296f, -0.02447511f, -0.46097064f, 0.14976592f, 0.12790804f, 0.09714855f, 0.03280798f, 
    0.05015415f, 0.02020556f, 0.01135036f, 0.07280303f, -0.00869268f, 0.04545271f, 0.01363243f, -0.02491182f, 
    0.06572817f, -0.04308240f, -0.09801444f, 0.06781921f, -0.10522470f, -0.24914658f, -0.24178822f, 0.18714808f, 
    -0.13752681f, 0.06603788f, -0.11783638f, 0.00097095f, -0.07360122f, 0.17433965f, 0.04532496f, 0.03712887f, 
    0.01368413f, 0.06766335f, 0.01953122f, -0.03544352f, 0.04434814f, 0.13953117f, 0.19446395f, 0.14848158f, 
    0.03201742f, 0.32577738f, 0.39102620f, 0.40393323f, -0.27590853f, 0.12905744f, -0.15406202f, -0.09865699f, 
    -0.30547518f, -0.20467001f, 0.06800552f, -0.11267747f, 0.07321751f, -0.01645391f, -0.05495298f, 0.00180052f, 
    0.05378908f, -0.13413574f, -0.03553425f, 0.13526438f, -0.27293009f, 0.09656765f, -0.18754965f, -0.07124888f, 
    -0.02137005f, -0.07611065f, 0.00566997f, -0.00772042f, -0.06274097f, 0.04279690f, -0.10463978f, -0.08186724f, 
    -0.00986717f, -0.08134694f, 0.00023248f, 0.14415242f, -0.12843490f, -0.05352435f, -0.01038949f, -0.14175333f, 
    -0.25895974f, 0.00972883f, 0.21566346f, -0.08762025f, -0.02430441f, 0.09289943f, -0.12147851f, 0.13188183f, 
    -0.03000004f, -0.02167057f, -0.11704180f, -0.00398483f, 0.01183877f, -0.08010674f, 0.04143944f, 0.04605404f, 
    -0.04240225f, -0.02133764f, -0.08493935f, -0.04335517f, -0.03517339f, -0.26721939f, -0.35883650f, 0.03948538f, 
    -0.33951518f, 0.06967214f, -0.02990781f, -0.02193825f, -0.00626494f, 0.04512547f, 0.01422710f, -0.03540734f, 
    0.01469792f, 0.04892523f, -0.02198345f, -0.05864564f, -0.00730004f, -0.13031106f, 0.09664991f, 0.02976992f, 
    -0.44548267f, 0.35211951f, -0.32931641f, -0.22066429f, -0.28410229f, 0.03117977f, 0.02947523f, -0.00137022f, 
    -0.22021553f, 0.06175748f, 0.01114015f, -0.02573028f, -0.08844095f, -0.08624231f, 0.02619883f, -0.13037948f, 
    -0.13574320f, 0.02191306f, -0.17392209f, -0.15769218f, 0.01498889f, -0.08747610f, -0.19349974f, -0.03611036f, 
    0.06766204f, -0.00413567f, 0.10535149f, 0.15822740f, 0.06059067f, 0.02442396f, 0.06514073f, 0.00762872f, 
    -0.00037914f, -0.00694050f, -0.02079717f, 0.01850674f, 0.05784164f, 0.00888087f, -0.01596109f, 0.04038512f, 
    0.42199051f, -0.79954845f, -0.22821610f, -0.40279317f, 0.20487539f, -0.05255488f, -0.12667559f, 0.11094127f, 
    0.18177649f, 0.13904339f, -0.06726089f, 0.05938012f, 0.04750704f, -0.07668602f, 0.01646850f, -0.06605667f, 
    0.10215542f, 0.10052574f, -0.08363103f, 0.06085804f, 0.14874649f, 0.15339360f, 0.11090451f, 0.01102873f, 
    -0.26009822f, -0.00741397f, -0.12877522f, 0.09738509f, 0.09754527f, 0.16347626f, -0.00208435f, 0.01408488f, 
    0.00860762f, -0.00964360f, -0.00499718f, 0.04664088f, -0.01615140f, 0.02460331f, -0.02711190f, -0.14705011f, 
    0.07542346f, -0.24516982f, 0.07460815f, -0.22090667f, -0.01633640f, -0.05942012f, -0.05696087f, -0.10973223f, 
    0.14423177f, 0.09166741f, -0.07316990f, 0.02414869f, 0.12808993f, -0.08252766f, -0.05002818f, 0.14825803f, 
    -0.01915854f, 0.06976393f, 0.00264172f, -0.06372271f, -0.07412691f, 0.09524016f, 0.06181948f, -0.05529550f, 
    -0.14904906f, 0.16276436f, -0.05164912f, -0.10666758f, -0.00840077f, -0.14716358f, 0.00877995f, -0.08777704f, 
    -0.00505458f, 0.02626824f, 0.02776769f, -0.02264751f, -0.01955255f, -0.04499339f, -0.07896484f, 0.08529828f, 
    -0.16757075f, 0.03171763f, -0.15309621f, -0.24641311f, 0.11777788f, -0.02639889f, 0.01448656f, 0.13908589f, 
    -0.13733454f, 0.00932945f, -0.03868912f, 0.03612315f, -0.03295944f, 0.11122830f, 0.09089256f, 0.07860177f, 
    -0.07548768f, 0.04298646f, -0.07953188f, 0.00119567f, 0.12589341f, -0.13536663f, 0.09889138f, -0.05825325f, 
    -0.17453340f, 0.01752227f, -0.02114039f, 0.06769703f, -0.01802359f, 0.05798025f, -0.15077055f, 0.09564878f, 
    -0.09073783f, -0.05100063f, -0.15896931f, 0.04864370f, -0.02624354f, 0.10108612f, -0.03004948f, -0.12472673f, 
    0.01474062f, -0.11878322f, 0.25957537f, 0.01619909f, 0.06497095f, -0.08396706f, -0.03879000f, -0.03332432f, 
    -0.05289113f, -0.16042112f, -0.01936296f, -0.04796380f, 0.09215538f, 0.02876032f, 0.03224152f, -0.07679569f, 
    0.05611243f, -0.01407586f, 0.01542234f, -0.00538391f, -0.61990803f, 0.21595562f, 0.09578495f, 0.09878094f, 
    0.01995517f, 0.08742473f, 0.02156038f, -0.16638395f, 0.39743477f, 0.00603041f, 0.08703314f, -0.20899241f, 
    0.03729902f, 0.03170330f, 0.14135088f, 0.08327567f, 0.10748111f, -0.13241431f, 0.23453565f, -0.04730413f, 
    -0.11439855f, -0.45054081f, 0.17339343f, 0.12494931f, -0.06516255f, -0.18523455f, 0.18536645f, 0.16277434f, 
    -0.03530250f, -0.09479608f, -0.05476426f, 0.02383530f, -0.09715317f, 0.05837455f, -0.06125932f, -0.07640775f, 
    0.05720916f, 0.12972109f, 0.10000289f, 0.05705632f, -0.08065499f, -0.16918738f, 0.14599143f, -0.15431203f, 
    -0.17124723f, -0.01223254f, -0.04630685f, 0.09905716f, 0.04110746f, -0.07906169f, -0.05534711f, 0.00085697f, 
    0.08733840f, -0.08713530f, 0.01627763f, 0.01272908f, 0.03057814f, 0.07643414f, 0.03011865f, -0.09792119f, 
    -0.22303352f, -0.06541729f, 0.10061832f, -0.05542278f, 0.12736088f, 0.01120604f, -0.08530050f, -0.08850425f, 
    -0.08698377f, 0.03712638f, -0.02015047f, 0.11471809f, 0.00977531f, 0.08673894f, -0.02118824f, 0.09094885f, 
    0.01526773f, -0.06997503f, 0.17675830f, -0.01602189f, -0.12044380f, 0.14140457f, 0.02525673f, 0.10442460f, 
    0.07192485f, 0.07252772f, -0.15763085f, -0.05668019f, 0.06856104f, 0.03311744f, -0.28129980f, 0.05669404f, 
    -0.03565343f, -0.17887047f, -0.16694462f, 0.13337390f, 0.01454174f, -0.13555793f, 0.03615449f, -0.06037298f, 
    0.07117786f, 0.27089095f, -0.53081787f, 0.11705316f, 0.24351944f, 0.20107096f, 0.04887225f, 0.02627066f, 
    -0.13739397f, 0.05202806f, -0.22804755f, 0.07785490f, -0.09511319f, -0.08539397f, -0.02453443f, -0.07328711f, 
    -0.01115352f, -0.18754502f, 0.02762743f, 0.07726242f, -0.15463392f, 0.08860577f, -0.16286966f, 0.02744511f, 
    0.00547127f, -0.04999047f, -0.03000753f, 0.02067854f, -0.01996094f, 0.01062976f, -0.03292488f, 0.03421016f, 
    -0.01360885f, 0.00044860f, 0.00516259f, 0.02591604f, -0.03460338f, -0.09127548f, -0.01166835f, -0.02922185f, 
    -0.30200019f, 0.06309634f, 0.10498652f, 0.10716023f, 0.08689344f, -0.01158523f, -0.07718989f, -0.14772616f, 
    0.12046338f, 0.01014712f, -0.10678342f, 0.07816389f, 0.03798335f, 0.04213599f, 0.05789250f, -0.02967754f, 
    0.08110681f, -0.04497567f, 0.04734978f, 0.02715800f, -0.30841863f, -0.22496055f, -0.22835153f, -0.07653643f, 
    -0.06283145f, 0.04624921f, -0.02552211f, 0.11654229f, -0.02668224f, 0.02229318f, -0.04117348f, 0.02970604f, 
    0.05395797f, 0.07963461f, -0.03832399f, 0.02562537f, -0.00364075f, 0.04257407f, 0.12957391f, 0.19972809f, 
    0.11526807f, -0.32316491f, 0.32772717f, 0.36631808f, -0.15351452f, -0.03728738f, 0.07931472f, 0.29331893f, 
    -0.08639563f, -0.26545122f, 0.00204144f, -0.04000240f, -0.07001745f, 0.08481439f, -0.04975835f, -0.01444597f, 
    -0.00285790f, 0.26813474f, -0.08506111f, 0.19924323f, 0.34336790f, -0.10135449f, 0.36570239f, 0.17965007f, 
    -0.11002437f, -0.13497309f, 0.12256620f, 0.05261200f, -0.02002993f, -0.01984899f, -0.06527324f, 0.07544576f, 
    0.09132425f, 0.00375583f, 0.10526982f, -0.07152267f, -0.02829839f, -0.09987181f, 0.09657044f, -0.11441865f, 
    0.16601996f, -0.34637672f, 0.21422155f, 0.04758061f, 0.01689789f, -0.12358064f, 0.08488177f, 0.10312681f, 
    0.05476721f, -0.06985649f, -0.02696129f, -0.02301735f, -0.13452201f, 0.04342021f, 0.02637976f, -0.08814122f, 
    0.13535805f, 0.06649631f, 0.02011108f, -0.10658702f, 0.50763452f, -0.09510977f, 0.31961557f, 0.05200721f, 
    -0.03681192f, -0.00589365f, 0.07995441f, 0.03353182f, 0.03203185f, -0.11217165f, 0.08706619f, -0.05588246f, 
    0.05820211f, -0.00956088f, 0.15890586f, -0.02967491f, -0.18316878f, -0.13954255f, 0.00022773f, -0.15411669f, 
    -0.31054109f, -0.21842420f, 0.08634546f, -0.03604314f, 0.15923639f, 0.01937173f, -0.08134580f, 0.13058868f, 
    -0.21335258f, -0.13970299f, -0.02842974f, 0.09743389f, 0.09914505f, 0.02213038f, -0.02909511f, 0.03286079f, 
    -0.03212011f, -0.01673357f, -0.08261506f, -0.06481362f, -0.03591853f, 0.02828555f, 0.12586938f, -0.08122586f, 
    0.04763564f, -0.07688713f, -0.01216026f, -0.15314299f, 0.12050612f, 0.02853164f, -0.01215704f, -0.02996000f, 
    -0.06943686f, -0.11984791f, -0.11635742f, -0.00088102f, 0.00088671f, 0.05484544f, -0.01722516f, -0.00040695f, 
    -0.18253401f, 0.06995562f, 0.05993449f, -0.07396201f, -0.08971719f, 0.05383407f, -0.04229505f, -0.07078360f, 
    0.09970573f, 0.00488732f, 0.02514954f, 0.00954301f, 0.01140833f, 0.00850553f, -0.02088999f, -0.02866836f, 
    -0.01660000f, -0.03281865f, 0.06341059f, -0.05679717f, -0.25930378f, -0.33162585f, 0.16525418f, -0.01447699f, 
    0.07540312f, -0.00251063f, -0.03197967f, -0.04812207f, -0.05767671f, -0.22331946f, -0.13030396f, 0.07011418f, 
    -0.01280512f, 0.10166457f, 0.00320933f, 0.24991901f, -0.14786352f, -0.06550750f, -0.14505570f, -0.26642224f, 
    -0.28382713f, -0.06781641f, -0.23892264f, 0.22444010f, 0.17501211f, -0.15459739f, -0.09851526f, 0.09049886f, 
    -0.09634789f, -0.07821865f, -0.03369310f, 0.03517668f, -0.01601070f, 0.11358114f, 0.10189926f, 0.01037902f, 
    -0.04297909f, -0.00344378f, 0.00917931f, 0.09535514f, -0.07418396f, -0.29676327f, -0.15960149f, -0.12572144f, 
    -0.16482908f, -0.12237338f, -0.01602685f, 0.09142575f, -0.03614809f, -0.05476464f, -0.01272057f, -0.03476646f, 
    -0.11417892f, 0.03864447f, 0.04526628f, -0.12124769f, -0.00452688f, 0.19960000f, -0.01062899f, 0.03534421f, 
    0.02705330f, 0.04343186f, -0.07747482f, 0.12196390f, -0.02299802f, 0.02226453f, 0.06828950f, 0.11472662f, 
    -0.13139687f, -0.01146101f, 0.04817708f, 0.08039934f, -0.13985740f, -0.02761724f, -0.17944975f, 0.01104689f, 
    -0.22022830f, -0.01022787f, -0.15719408f, -0.09361718f, -0.37076709f, 0.09476783f, -0.62378603f, 0.13021302f, 
    -0.05940969f, -0.12910689f, -0.01615228f, -0.13333952f, 0.07482067f, -0.00874982f, 0.01395919f, 0.11011335f, 
    -0.06293110f, 0.05223133f, -0.00005892f, 0.03153180f, 0.00933682f, -0.08734079f, 0.00251417f, -0.10146698f, 
    -0.07081418f, 0.08083867f, -0.00845597f, 0.11857584f, 0.04603636f, 0.00794156f, 0.01914826f, -0.03865390f, 
    0.03188824f, 0.06689687f, -0.10186196f, 0.06102693f, -0.02549584f, -0.16343240f, -0.18737383f, 0.02025309f, 
    -0.07324200f, -0.00934428f, -0.03579499f, -0.06090003f, 0.54112256f, 0.10967530f, 0.12876600f, 0.10137969f, 
    0.07466628f, 0.10541753f, -0.01253117f, 0.01567880f, -0.05082195f, -0.03507743f, -0.05254703f, 0.01138710f, 
    0.12164145f, 0.06823808f, 0.07425187f, -0.17218730f, 0.06484289f, -0.09663818f, -0.05339742f, -0.02663247f, 
    -0.11412322f, -0.00168341f, -0.15974498f, 0.03966996f, 0.03211017f, 0.11653744f, -0.04619758f, 0.02765856f, 
    0.04895445f, 0.00875396f, -0.01482731f, 0.06941384f, -0.01538880f, -0.13019107f, -0.18787916f, 0.01468734f, 
    0.01911883f, 0.06843177f, -0.00384745f, -0.09963167f, -0.37091082f, 0.09172621f, -0.00626927f, 0.01841186f, 
    0.03733778f, 0.18779312f, -0.01436919f, 0.06449192f, 0.21791373f, 0.09700578f, -0.15869620f, -0.01096368f, 
    -0.05964024f, 0.00084644f, 0.00575943f, 0.02204675f, -0.10916991f, -0.07416393f, 0.02891294f, -0.01333133f, 
    0.09713653f, -0.40069208f, -0.00244174f, -0.13306521f, -0.26803017f, -0.06713390f, -0.14357585f, -0.10072194f, 
    -0.09711495f, -0.13410303f, -0.13318484f, 0.04436717f, 0.04443583f, -0.06503967f, 0.06360795f, -0.12012103f, 
    0.00308720f, -0.09341945f, -0.09610990f, 0.06289689f, -0.42636484f, 0.01586085f, -0.07303540f, -0.00420488f, 
    -0.06629721f, 0.06068104f, 0.09568166f, 0.01840602f, 0.21344350f, 0.08174610f, -0.33060694f, -0.08527619f, 
    0.01155848f, -0.06681529f, 0.08284609f, 0.01517827f, -0.06150611f, -0.05691142f, 0.16822918f, 0.08066372f, 
    -0.10940133f, -0.22234668f, 0.19553463f, -0.07141002f, -0.14604758f, -0.04319172f, -0.15294880f, -0.01170897f, 
    -0.03446280f, -0.03023049f, -0.14342771f, -0.00227445f, 0.07211139f, -0.09683213f, 0.02593827f, -0.12155729f, 
    0.06928038f, 0.10918980f, 0.09121133f, 0.01804525f, -0.06232304f, -0.23558453f, -0.28108045f, -0.14861803f, 
    0.07767587f, 0.01185780f, -0.00577079f, -0.06632660f, -0.05740495f, -0.08894222f, -0.15623625f, 0.04731636f, 
    -0.08848884f, 0.00979585f, 0.04130118f, 0.10783251f, -0.20047578f, -0.20824017f, -0.12592378f, 0.02077077f, 
    -0.16712412f, -0.13507797f, -0.20334914f, -0.07771658f, 0.05757482f, -0.04015729f, 0.10038564f, 0.17261972f, 
    0.08176509f, 0.02257628f, 0.04515269f, -0.08392614f, 0.05397415f, 0.02770191f, 0.04629612f, 0.01767467f, 
    0.04532516f, 0.12951118f, 0.10976882f, 0.16949931f, -0.19606385f, -0.09214913f, 0.23775959f, 0.00305159f, 
    -0.23052974f, 0.04253384f, 0.00026082f, -0.08683104f, -0.03873771f, -0.08669187f, -0.12621048f, 0.00240391f, 
    0.19148906f, 0.03383491f, 0.01408144f, 0.07049573f, 0.10544655f, 0.03401462f, -0.03405048f, -0.22823530f, 
    0.26763618f, -0.17050865f, 0.14387925f, -0.00524374f, -0.03474282f, 0.00938232f, 0.03234707f, 0.13208887f, 
    0.01848191f, -0.01511746f, -0.07270613f, 0.07005194f, -0.08961819f, -0.08173005f, -0.08796290f, -0.04940270f, 
    0.05867736f, 0.09140821f, 0.10440867f, 0.07133438f, 0.16801804f, 0.19636396f, 0.23635153f, 0.15078224f, 
    0.02039537f, -0.10353187f, 0.03668305f, 0.01719197f, 0.05054710f, -0.00549110f, -0.11337049f, -0.00293575f, 
    -0.02280198f, 0.02265794f, -0.01322324f, 0.03872741f, 0.04044285f, 0.09993367f, 0.13833156f, 0.11365756f, 
    0.04285941f, 0.19419080f, -0.02174937f, 0.09836875f, 0.10061979f, 0.03960440f, -0.04483140f, -0.11038724f, 
    -0.04581540f, 0.04060796f, -0.14413796f, 0.09621993f, -0.07573005f, -0.08690183f, -0.09690833f, 0.01625165f, 
    0.00187747f, -0.04387136f, 0.02368842f, 0.00823347f, 0.13005537f, -0.34476763f, 0.08693829f, -0.04914177f, 
    -0.25986147f, -0.05778751f, -0.00708398f, -0.03102260f, -0.08458298f, -0.07549375f, 0.07755339f, 0.04212363f, 
    -0.04671283f, -0.07953133f, 0.03381897f, -0.04905896f, 0.05896659f, 0.01318708f, 0.01853153f, -0.10115232f, 
    0.24597739f, -0.46309263f, 0.37149203f, -0.08006110f, -0.14308910f, -0.20287640f, 0.01769532f, 0.17268921f, 
    0.13670310f, -0.12712353f, -0.20772623f, 0.06140822f, -0.15400887f, 0.04981208f, -0.06769622f, -0.07191402f, 
    0.06579273f, 0.17795989f, -0.16495720f, 0.04550435f, -0.12594381f, -0.19998001f, 0.14858583f, 0.10677879f, 
    -0.25592530f, 0.05369842f, -0.10912833f, 0.09397302f, -0.02067061f, -0.13311473f, 0.01231264f, -0.01373066f, 
    0.21878274f, -0.03451643f, 0.00254010f, -0.01728523f, 0.00292231f, 0.03174632f, 0.03178094f, -0.03260057f, 
    -0.03267081f, -0.02722339f, -0.22810946f, 0.13402835f, 0.03196458f, -0.02066955f, 0.00899594f, 0.07257037f, 
    -0.27278143f, -0.02247712f, -0.04302667f, 0.03450731f, -0.12786235f, 0.01932820f, -0.00632770f, -0.07111910f, 
    -0.10977118f, -0.29680181f, -0.28156656f, -0.05075781f, -0.15397672f, -0.27506706f, -0.01053925f, -0.09973475f, 
    -0.18347597f, -0.09535778f, 0.01227502f, 0.04747265f, -0.07692780f, -0.10869827f, -0.04253779f, -0.02399135f, 
    -0.04164188f, -0.02104251f, -0.11399563f, -0.05437555f, 0.06427927f, 0.11694854f, 0.08942264f, 0.07435287f, 
    -0.31112650f, 0.00322949f, -0.08138431f, 0.10171858f, -0.11171089f, 0.04472098f, 0.00880640f, 0.01716345f, 
    0.25525916f, 0.09548534f, -0.13882154f, -0.06593084f, -0.00177373f, 0.05685361f, 0.01743050f, 0.07892027f, 
    0.07650699f, -0.06033845f, 0.21919644f, 0.27502212f, 0.05462700f, -0.24241027f, 0.22636546f, -0.17355219f, 
    -0.06772085f, -0.07579537f, -0.00724888f, 0.01072127f, 0.06167942f, 0.01200560f, -0.06312948f, -0.00927554f, 
    -0.15451981f, 0.00284079f, 0.02864430f, 0.00127466f, -0.03843199f, 0.06350950f, -0.01493841f, -0.21617477f, 
    -0.20676611f, -0.00245456f, 0.27910137f, -0.21523756f, 0.07223529f, 0.02092946f, -0.02054686f, 0.11514132f, 
    0.04013637f, -0.08676367f, -0.11314981f, -0.07358810f, 0.01178944f, 0.05344494f, 0.04728622f, 0.14919914f, 
    -0.17827781f, 0.01661195f, -0.08530071f, -0.13885434f, -0.32949445f, 0.12984714f, -0.05225566f, 0.17433213f, 
    -0.02004714f, -0.04334712f, 0.08758673f, -0.11846480f, 0.13086957f, 0.09111618f, -0.01298754f, -0.17831396f, 
    -0.08820268f, -0.07945966f, 0.05922281f, 0.03916660f, -0.04157900f, -0.02078871f, 0.15955125f, 0.08722596f, 
    -0.36425000f, 0.03726068f, -0.22642076f, -0.17373350f, 0.08974700f, -0.06901587f, -0.08449727f, 0.01995962f, 
    0.02624915f, -0.03859267f, -0.16376536f, 0.03256972f, 0.02034605f, -0.01541790f, 0.00384759f, 0.00228282f, 
    0.03734714f, -0.08590320f, 0.11216880f, 0.07707638f, -0.06815990f, 0.00401032f, -0.02132136f, 0.16491699f, 
    0.20982592f, 0.01772844f, 0.02522261f, 0.05930340f, -0.10460285f, 0.09774010f, -0.18816203f, 0.03640328f, 
    -0.05327956f, -0.03142971f, -0.08726911f, 0.06741311f, 0.00919340f, -0.17597783f, 0.10275803f, 0.04985883f, 
    0.13376886f, -0.27651551f, 0.17197114f, 0.09215724f, 0.03752043f, -0.19458023f, -0.03007189f, 0.11723967f, 
    0.01360603f, 0.00895197f, 0.04551345f, -0.14904614f, -0.19473247f, 0.09960216f, 0.13209513f, -0.13817684f, 
    -0.04641685f, 0.08633029f, -0.21828158f, 0.04338224f, -0.35708466f, -0.11890649f, -0.23834316f, -0.07430092f, 
    -0.09814361f, -0.08120158f, 0.01822393f, 0.00972837f, 0.11674231f, 0.04053228f, -0.05239885f, 0.00675865f, 
    -0.05828313f, 0.02748528f, -0.03667813f, 0.06960637f, 0.02947619f, 0.01238823f, 0.18575497f, 0.24951218f, 
    -0.05521406f, -0.08637044f, 0.07579617f, 0.07077423f, -0.05767348f, -0.02271547f, 0.03990196f, -0.11739229f, 
    -0.00189607f, 0.10674033f, -0.00552809f, -0.02089318f, -0.01703164f, -0.00210092f, 0.09542561f, -0.04819519f, 
    -0.08745278f, 0.08188820f, 0.06854775f, 0.05179790f, 0.12763704f, 0.16619518f, 0.14201038f, -0.00541050f, 
    -0.04865546f, 0.02299365f, -0.01780485f, 0.00157988f, 0.03372925f, -0.04528804f, -0.08058342f, -0.03159732f, 
    -0.04678087f, 0.01854863f, -0.15331185f, -0.11868159f, -0.05025825f, 0.03117410f, -0.07766857f, -0.09095748f, 
    -0.12120110f, 0.05917327f, 0.32553899f, 0.07652153f, -0.05319189f, -0.03215460f, -0.01310119f, -0.11724823f, 
    0.03698216f, -0.14077111f, -0.20141608f, 0.06798340f, -0.06275281f, -0.01572637f, 0.05093735f, -0.04090128f, 
    0.05058132f, 0.15632793f, 0.05608249f, -0.00595401f, -0.22369345f, -0.03638142f, -0.47396821f, -0.17372461f, 
    0.05325674f, 0.06659370f, -0.02346929f, -0.02631434f, -0.11776895f, -0.11393876f, -0.01244700f, 0.10615204f, 
    0.03853387f, 0.04753582f, -0.00405232f, 0.11896052f, -0.08917538f, -0.14533119f, -0.12828372f, -0.20433359f, 
    0.50460356f, -0.43931401f, 0.24592599f, 0.06097390f, -0.11500581f, -0.00612264f, -0.06451096f, 0.10693464f, 
    0.16383451f, -0.03108078f, -0.02730881f, 0.01218043f, -0.18622936f, -0.13038272f, -0.23678330f, -0.12527668f, 
    -0.05267810f, 0.09171715f, -0.10774531f, -0.07829513f, 0.12060579f, -0.11963972f, 0.11507685f, -0.12758979f, 
    0.02859128f, -0.01756559f, 0.11032573f, 0.14228411f, 0.10044579f, 0.10495330f, 0.05037807f, -0.04769082f, 
    0.04255792f, 0.00400887f, 0.05112322f, -0.03518232f, 0.10986878f, 0.12490115f, 0.13579150f, 0.05410408f, 
    -0.10620723f, -0.05461089f, -0.02991977f, 0.07012276f, 0.00814447f, -0.00454453f, 0.06377011f, -0.12633999f, 
    0.10620520f, 0.01951553f, -0.12259275f, -0.02295815f, 0.05911641f, -0.04503196f, 0.18496799f, 0.04708469f, 
    -0.01994011f, 0.06059376f, -0.07293655f, -0.04068849f, -0.25330397f, 0.07958262f, -0.09618780f, -0.14099063f, 
    0.08451212f, 0.05441146f, 0.01345636f, 0.11224493f, -0.15442957f, 0.09084525f, -0.13383529f, 0.00635053f, 
    -0.12818815f, 0.09284338f, 0.10106228f, 0.06742956f, -0.14230755f, -0.01153520f, -0.10705531f, -0.06757174f, 
    -0.11151433f, -0.05595933f, -0.07609370f, 0.08681490f, -0.16505620f, 0.04535058f, 0.01853787f, -0.06837057f, 
    0.09780391f, -0.08175392f, -0.17933419f, -0.12781793f, 0.00473596f, 0.03418199f, -0.03099910f, 0.11657528f, 
    0.15042362f, -0.12830311f, 0.18786626f, 0.01214315f, -0.03887750f, -0.17448623f, 0.11194544f, -0.03666444f, 
    -0.15549092f, -0.03562611f, -0.08749467f, 0.00770657f, -0.00849109f, -0.04160407f, -0.08525360f, 0.01389206f, 
    0.00003785f, -0.05761642f, 0.02087590f, 0.04278774f, -0.10569026f, 0.02141899f, -0.01459008f, 0.04516281f, 
    -0.27487889f, 0.06818998f, -0.28922787f, 0.21379866f, -0.03938500f, 0.07256396f, 0.02333494f, 0.05581867f, 
    -0.02587815f, -0.04264689f, -0.01481014f, 0.12452529f, -0.05548406f, 0.02890803f, -0.05527466f, -0.00579046f, 
    -0.04195470f, -0.19136004f, -0.45528343f, -0.31209132f, -0.28609246f, 0.07231341f, 0.04146184f, 0.09536196f, 
    0.11665328f, -0.02687541f, 0.00832658f, -0.08537270f, 0.01729988f, 0.00521316f, -0.09573352f, 0.11302759f, 
    0.00630513f, 0.06160479f, -0.00473691f, 0.04244648f, 0.00828574f, -0.08643222f, 0.01809286f, 0.09799901f, 
    -0.16960654f, -0.09933627f, -0.32479459f, 0.21628925f, 0.12189982f, -0.14099972f, 0.06395627f, -0.23186690f, 
    0.05272071f, 0.13119276f, -0.25524616f, 0.11948732f, -0.12396386f, -0.02549078f, 0.13781603f, -0.08610432f, 
    0.02294352f, -0.22420678f, 0.10541484f, 0.19531247f, -0.28432378f, -0.01742301f, 0.23177209f, 0.07466412f, 
    0.06086336f, -0.05935797f, 0.10182422f, -0.01796741f, 0.08006767f, 0.09294462f, -0.01175710f, 0.02154839f, 
    0.06426234f, 0.12895261f, 0.04077245f, -0.05359876f, 0.09052016f, 0.01035397f, -0.00507612f, 0.11035269f, 
    0.10656226f, -0.09359545f, 0.16203973f, 0.00438233f, 0.08990036f, -0.13302641f, -0.21743478f, 0.07216480f, 
    -0.01047899f, -0.11344589f, 0.04912278f, -0.03001076f, -0.03348307f, -0.02561022f, -0.03576263f, 0.02361556f, 
    0.00797730f, -0.03206363f, -0.05426083f, 0.03363845f, -0.19714482f, 0.00081022f, -0.09093955f, -0.14603192f, 
    0.04643695f, 0.04638599f, 0.09323490f, -0.06971718f, 0.07058542f, -0.00033175f, -0.08388014f, -0.02315817f, 
    -0.04896213f, 0.02400862f, 0.07852154f, 0.00447329f, -0.02863480f, -0.03541514f, -0.04041361f, -0.00565750f, 
    0.12647292f, 0.01290346f, 0.00227137f, -0.01380596f, 0.08901174f, -0.03158978f, 0.06095478f, -0.00705593f, 
    0.02625244f, 0.02494605f, 0.00530037f, 0.04348097f, -0.07583711f, 0.01703729f, -0.02040957f, -0.04243423f, 
    -0.01201883f, 0.07527161f, -0.04757831f, 0.10398364f, -0.02709792f, -0.04707140f, 0.14949904f, 0.07179487f, 
    -0.11867079f, -0.03839321f, 0.03558251f, -0.10031300f, 0.11850420f, -0.07469975f, -0.12680188f, 0.10273855f, 
    0.04637842f, -0.05759919f, 0.11128358f, 0.09751616f, -0.03621732f, 0.00608207f, -0.02108468f, -0.01531844f, 
    0.31682563f, 0.03923272f, 0.25138724f, -0.01964214f, 0.06478170f, 0.13630252f, -0.01554926f, -0.16545966f, 
    0.10634725f, 0.09123262f, -0.04725244f, 0.01108901f, -0.03968899f, -0.03334955f, -0.09499984f, -0.12622970f, 
    0.07341470f, -0.14014609f, 0.00249495f, 0.08085828f, 0.02838223f, 0.13018377f, -0.00962035f, 0.11471167f, 
    0.02905461f, 0.00568774f, 0.06669039f, 0.05193965f, 0.07441151f, 0.01442763f, -0.05130966f, 0.00637495f, 
    -0.01300691f, 0.03771162f, -0.10878820f, 0.10349024f, -0.00151117f, 0.06462555f, -0.11363883f, 0.02933718f, 
    -0.06826934f, -0.32015309f, 0.00118751f, -0.14753185f, 0.01440342f, 0.03288222f, -0.27469239f, 0.00875123f, 
    -0.09603196f, -0.07889768f, -0.00069855f, 0.03493854f, 0.00929698f, 0.03915260f, -0.01934793f, 0.01408916f, 
    -0.03590573f, -0.01721092f, -0.01743824f, -0.09812098f, -0.26435584f, 0.02450828f, -0.32496619f, 0.00233311f, 
    -0.36484516f, 0.07639234f, 0.07360520f, 0.03230863f, -0.06816112f, 0.05435671f, -0.04154817f, -0.19917156f, 
    0.01354955f, 0.03936685f, -0.06404702f, 0.02640775f, -0.05222118f, 0.05289918f, -0.03540033f, 0.00234773f, 
    -0.60225880f, -0.13679007f, -0.33334398f, 0.45085660f, -0.38003638f, 0.07278461f, -0.00470500f, 0.13620029f, 
    -0.17042309f, 0.05528763f, -0.08194716f, -0.13455462f, 0.10800663f, 0.06643070f, -0.11594033f, 0.01240123f, 
    -0.02442550f, 0.08875538f, 0.05506961f, 0.02249786f, 0.00751089f, -0.13258949f, -0.14819367f, -0.08246152f, 
    -0.03093541f, -0.04828830f, -0.00428848f, 0.05527034f, -0.07603779f, -0.01971390f, 0.00575182f, 0.02463109f, 
    0.10660487f, 0.06691164f, 0.02428559f, 0.04569004f, 0.01200167f, 0.05191173f, 0.04797569f, 0.12068486f, 
    -0.19135708f, 0.00882078f, -0.20559439f, 0.15832675f, -0.17975639f, 0.04550250f, -0.13951769f, 0.03080797f, 
    -0.16611290f, -0.07019509f, -0.03032782f, 0.03113472f, -0.08189570f, 0.01812905f, -0.01029857f, 0.03068555f, 
    -0.06192473f, 0.03964702f, -0.03085903f, 0.01657610f, 0.18921092f, 0.12419646f, 0.20262414f, 0.02634116f, 
    -0.14055999f, -0.06352773f, -0.03478821f, -0.00275753f, -0.07965538f, -0.13379171f, -0.11620569f, 0.01682029f, 
    0.05151912f, -0.02745037f, -0.01862924f, -0.05385794f, -0.03010324f, -0.05759994f, -0.11869848f, 0.04262473f, 
    0.17881590f, -0.02511776f, -0.07319187f, 0.27503672f, 0.13179995f, -0.05195481f, 0.12931779f, -0.19589484f, 
    0.09180061f, 0.20566662f, -0.00317850f, 0.02442009f, 0.03319024f, -0.02244700f, 0.10844602f, 0.11907924f, 
    0.04267245f, -0.08496781f, -0.02835333f, 0.02411957f, -0.35404924f, -0.12130477f, -0.14912291f, -0.14036602f, 
    0.14207651f, 0.03699359f, 0.05923937f, -0.02567428f, -0.03043354f, 0.18268849f, -0.11403213f, 0.11768105f, 
    -0.10444038f, 0.21727678f, 0.04839398f, 0.11679097f, 0.01302471f, 0.06844725f, 0.04526444f, 0.08102918f, 
    0.06463797f, -0.10241173f, -0.03286072f, -0.05112686f, 0.31066939f, -0.00033159f, 0.09084297f, -0.02225575f, 
    0.05919238f, 0.10245819f, -0.06369022f, 0.00432068f, -0.04144470f, -0.00899917f, -0.09531215f, -0.03980152f, 
    0.07373845f, -0.01940962f, 0.06548626f, 0.00897727f, -0.65196383f, -0.38905412f, -0.23217709f, -0.31933522f, 
    0.50722933f, -0.00824601f, 0.15163456f, 0.19532235f, -0.14182751f, 0.16030502f, -0.10623655f, 0.14185381f, 
    -0.01016914f, 0.18995684f, 0.15571316f, 0.04937179f, 0.13491113f, 0.09540089f, 0.08536053f, 0.10947602f, 
    0.43031183f, -0.26096588f, 0.26460022f, 0.11911722f, -0.04135815f, 0.04256065f, -0.15188554f, -0.21594509f, 
    -0.00415494f, -0.11912034f, -0.04678190f, 0.08646742f, -0.01225841f, 0.09094726f, 0.01464894f, -0.06666970f, 
    -0.08310912f, -0.00168315f, -0.00349632f, 0.11557578f, 0.08752839f, -0.23189704f, 0.21867600f, -0.21378100f, 
    -0.31569922f, -0.01655616f, -0.00381225f, -0.20960560f, -0.07508167f, -0.00757213f, -0.02069413f, 0.00106311f, 
    0.04371899f, 0.00458742f, -0.01306522f, -0.00140111f, 0.01504210f, 0.00560225f, 0.04402503f, 0.03348428f, 
    -0.22656980f, 0.01490764f, -0.06189229f, 0.05199692f, -0.17169099f, -0.01477716f, 0.02578460f, -0.00897792f, 
    0.02795503f, -0.02061362f, -0.03144493f, 0.00119946f, -0.01063938f, -0.02000812f, -0.03948969f, -0.02714467f, 
    -0.02258275f, -0.04396786f, -0.11678406f, 0.02970959f, 0.65625632f, -0.61333787f, 0.55280423f, -0.20939012f, 
    0.17691232f, 0.07090864f, 0.05179799f, -0.21223155f, 0.10478407f, -0.15180625f, -0.11070313f, -0.06107282f, 
    0.01931299f, 0.00795132f, -0.05168219f, 0.03779181f, 0.07171778f, 0.05848932f, -0.01398630f, -0.03688145f, 
    0.44537693f, -0.40090716f, -0.08017105f, -0.28055474f, -0.02597238f, -0.16224314f, -0.41094279f, -0.20367005f, 
    0.10122942f, -0.18150984f, 0.01660216f, 0.07586192f, -0.01154936f, -0.07829000f, -0.07431529f, 0.02710623f, 
    0.00967822f, 0.04241493f, 0.13105677f, -0.10802553f, -0.04779627f, 0.00297861f, 0.08048632f, -0.00651630f, 
    -0.01310623f, -0.04978951f, 0.04507126f, 0.01879442f, 0.10229494f, 0.06258932f, -0.04998004f, 0.14151461f, 
    0.03688807f, 0.11756412f, 0.02595225f, -0.00489072f, -0.01764647f, -0.12494823f, -0.15386994f, -0.13306758f, 
    -0.30164263f, 0.01321542f, -0.06240175f, 0.11359216f, -0.06335000f, 0.10387945f, 0.05512045f, -0.12104396f, 
    -0.02885541f, -0.01367036f, -0.18015450f, -0.01575808f, 0.13821377f, 0.11076951f, 0.07560436f, 0.08058137f, 
    -0.03782611f, 0.11615130f, 0.16485837f, 0.16160706f, 0.03195122f, -0.28490943f, -0.00838168f, -0.23365760f, 
    -0.09447620f, 0.00167741f, -0.21452238f, -0.10310284f, 0.03579637f, -0.19488962f, -0.02964058f, 0.01114096f, 
    0.08846059f, 0.00205393f, -0.02970524f, 0.11719917f, -0.03006561f, 0.03946041f, 0.17410429f, 0.02962996f, 
    -0.04054121f, -0.16081974f, 0.18004137f, -0.15557539f, -0.34369597f, 0.11595790f, 0.05526594f, -0.03911993f, 
    -0.18297835f, 0.01545820f, -0.05558123f, -0.10269172f, 0.10886030f, 0.13281222f, 0.04674852f, 0.01226427f, 
    -0.00286085f, 0.05952965f, 0.06899390f, 0.07873703f, -0.75600314f, -0.18179201f, -0.29094082f, 0.01260364f, 
    0.31626335f, 0.16490209f, 0.16498025f, 0.18449216f, -0.28569159f, 0.14997621f, -0.13166122f, 0.00435764f, 
    -0.04916489f, 0.09768862f, 0.14119589f, 0.05946386f, -0.06670690f, 0.00178335f, 0.16120540f, 0.00807916f, 
    -0.21223448f, -0.03127114f, -0.27029634f, 0.05981645f, -0.22807622f, -0.06678458f, 0.12341974f, 0.07697814f, 
    -0.12478817f, -0.01791839f, -0.01965835f, 0.02370385f, 0.17307240f, 0.09714942f, 0.07028199f, 0.04997042f, 
    0.16090938f, 0.08064833f, 0.02872614f, 0.08758130f, 0.00889409f, -0.25716677f, 0.27624863f, 0.31368163f, 
    -0.01737934f, 0.04960138f, -0.04394432f, 0.08724386f, 0.00997347f, -0.16219963f, 0.02920755f, -0.02652078f, 
    0.07397689f, -0.01200102f, -0.03615266f, 0.07144772f, -0.01705872f, 0.06290364f, 0.06896037f, -0.10671642f, 
    0.28184348f, 0.20431887f, 0.20132381f, 0.14163077f, -0.25661382f, -0.04237189f, 0.06843307f, -0.03531188f, 
    0.05524502f, 0.09384482f, -0.09418632f, -0.03355562f, -0.01442598f, 0.01820062f, -0.02312047f, 0.00543580f, 
    0.07915278f, 0.17698647f, -0.03105176f, -0.01642528f, -0.18420829f, 0.06794951f, -0.05258054f, 0.26050720f, 
    -0.07300963f, -0.00823696f, -0.03012460f, 0.06414135f, 0.10529379f, -0.22153476f, -0.07769429f, 0.02326512f, 
    -0.07878146f, -0.07209070f, -0.02606140f, 0.09841181f, -0.06817609f, 0.03218197f, -0.01050486f, -0.04460483f, 
    0.11543963f, 0.11360949f, 0.00287073f, 0.13195536f, 0.02456562f, -0.06406036f, 0.10165178f, 0.01220399f, 
    -0.00551249f, 0.07885458f, -0.10589425f, 0.05724027f, -0.04262020f, 0.07870736f, 0.00650602f, 0.03444971f, 
    0.03195210f, 0.08111606f, -0.15653233f, -0.02036588f, 0.32451454f, 0.09304254f, 0.31512454f, 0.11375546f, 
    -0.25026569f, -0.11297268f, -0.05100098f, -0.09641181f, 0.01987435f, -0.03157534f, -0.04672202f, -0.03175693f, 
    0.00939853f, -0.05661078f, -0.00508955f, 0.05768429f, 0.07423586f, -0.01515264f, -0.02082398f, 0.01927987f, 
    -0.14224055f, -0.19451824f, -0.11500578f, 0.20199998f, 0.00410548f, -0.15129033f, -0.12098159f, -0.00973724f, 
    -0.12793764f, -0.04220069f, 0.04286694f, -0.09607576f, -0.21259205f, -0.09419473f, -0.08448438f, 0.00375020f, 
    -0.12821361f, -0.03703415f, -0.14633527f, -0.34783608f, 0.16378319f, -0.13466074f, -0.07691220f, 0.12911451f, 
    0.06781732f, 0.03592529f, 0.21173294f, -0.06118829f, 0.05043634f, -0.05114288f, -0.12842877f, -0.05966916f, 
    -0.02586684f, 0.01225942f, -0.05192312f, 0.07514122f, 0.02733336f, 0.17432038f, -0.18985066f, 0.01088696f, 
    -0.32509062f, -0.11344887f, -0.05049435f, -0.04752247f, 0.06329279f, -0.03724382f, 0.00956698f, -0.05683396f, 
    0.04221315f, 0.12298438f, -0.05932685f, 0.04910335f, -0.00365801f, -0.06151701f, -0.06467140f, 0.01019868f, 
    -0.06195486f, -0.02339501f, 0.01050430f, -0.02842918f, 0.08213374f, -0.31402937f, 0.25459117f, -0.05022009f, 
    0.06772941f, 0.19981131f, 0.02273373f, -0.03230808f, -0.00764893f, -0.00712126f, 0.04981253f, -0.08251491f, 
    -0.04141784f, 0.00174226f, -0.02054759f, -0.02459620f, 0.03474636f, 0.06890746f, -0.06852713f, -0.10281597f, 
    -0.48068735f, -0.04401350f, -0.28555572f, 0.14684325f, -0.28458422f, -0.08233244f, 0.02338136f, -0.03090387f, 
    -0.01034634f, 0.07237564f, -0.08123250f, -0.04488977f, 0.00455515f, -0.06141797f, -0.12484036f, -0.04992947f, 
    -0.06167918f, -0.04268644f, -0.04120266f, -0.00075689f, -0.10918687f, -0.04088901f, -0.08867731f, -0.06324175f, 
    0.00863356f, 0.02273645f, 0.09265388f, 0.06695656f, 0.06578074f, 0.06137238f, -0.10786943f, 0.11757031f, 
    0.07157307f, 0.08231830f, -0.01772961f, 0.01739795f, -0.02543557f, -0.03127763f, -0.15510496f, -0.04118343f, 
    0.04695920f, -0.00728897f, -0.00619451f, 0.16248195f, 0.23645301f, 0.10515595f, 0.02770642f, -0.13733585f, 
    0.10643540f, -0.02047735f, -0.00529575f, 0.09210835f, -0.14286420f, 0.01669135f, 0.02461723f, -0.08550384f, 
    0.03316063f, -0.06131344f, 0.10431801f, -0.08133239f, -0.20262627f, -0.04731888f, -0.24539913f, 0.03346259f, 
    -0.11828216f, 0.07649422f, 0.00843167f, 0.14600743f, -0.02091457f, 0.04064074f, -0.10085090f, -0.06598996f, 
    -0.12038338f, 0.12309348f, 0.00876813f, 0.09235854f, 0.00375235f, 0.17491382f, -0.20154804f, -0.03085424f, 
    -0.31201300f, -0.21892025f, -0.05210061f, 0.10827236f, 0.08524814f, 0.07226512f, 0.00629454f, -0.01862725f, 
    -0.03004608f, 0.07031856f, 0.01401377f, 0.02511369f, -0.00123697f, -0.02375313f, 0.04518488f, 0.21626949f, 
    0.02641940f, 0.10394008f, 0.14822547f, 0.01337421f, 0.15676808f, 0.18331075f, 0.14029543f, -0.02801655f, 
    -0.04829747f, 0.03390530f, 0.05518911f, -0.04332977f, -0.07079851f, -0.00820111f, -0.17741762f, 0.03396130f, 
    0.03680183f, -0.01401056f, -0.03032531f, 0.01329346f, -0.04599551f, -0.11538211f, -0.14907490f, 0.02557780f, 
    -0.08008943f, -0.04841944f, 0.05945705f, 0.16480473f, -0.09965240f, -0.15612304f, -0.04664637f, 0.02212146f, 
    0.05861650f, -0.09499919f, -0.09227090f, 0.01137174f, -0.06386935f, -0.03272142f, 0.00360172f, 0.01024479f, 
    -0.09785303f, 0.06140479f, -0.10864373f, -0.23683438f, 0.18460219f, -0.11136538f, 0.05861644f, -0.11192697f, 
    0.27239206f, 0.12328851f, 0.11930810f, 0.01156210f, -0.04289015f, -0.14007072f, -0.01139736f, -0.05291684f, 
    0.02029922f, 0.04479839f, -0.00830180f, -0.07931808f, 0.04846191f, 0.00683177f, -0.03344008f, 0.02673882f, 
    0.39047039f, -0.48688808f, 0.42143086f, 0.05931230f, 0.30666947f, 0.08213492f, 0.07239098f, 0.15702273f, 
    0.08967129f, -0.03792490f, 0.03381136f, 0.00706500f, 0.05068866f, 0.00623751f, 0.01503071f, 0.02291554f, 
    0.13270947f, 0.12792434f, -0.12589128f, -0.09049799f, -0.37890142f, -0.26652822f, -0.29969290f, 0.34096411f, 
    0.06394574f, -0.08446196f, 0.02799790f, 0.02317577f, 0.26015335f, -0.09288792f, -0.07307811f, -0.01359410f, 
    -0.13635159f, -0.17950855f, 0.05354987f, -0.06816111f, -0.09956778f, 0.06158885f, -0.07075284f, -0.03247223f, 
    -0.08453586f, -0.10375071f, -0.30343777f, 0.23125708f, -0.17793892f, 0.00808039f, -0.18350756f, -0.13403706f, 
    -0.22780469f, -0.05872091f, 0.08204915f, 0.09328361f, -0.10076489f, -0.05395308f, -0.00917771f, 0.00025321f, 
    -0.00778898f, -0.02146841f, -0.10419913f, -0.10472140f, 0.03527458f, -0.02811119f, 0.01192221f, 0.12159758f, 
    -0.17194237f, -0.05407738f, -0.08845261f, 0.04324497f, -0.00539914f, 0.05731906f, 0.03895229f, -0.05592300f, 
    0.02211446f, -0.03288870f, -0.04135994f, 0.06741450f, -0.00927605f, -0.00488677f, 0.07583623f, -0.05751524f, 
    0.03875682f, 0.02830912f, 0.07711305f, 0.11079185f, -0.02658013f, -0.10453244f, -0.07315451f, -0.01503314f, 
    0.19825438f, 0.15032482f, -0.08511728f, 0.12055903f, 0.13029511f, 0.10435474f, 0.02018099f, -0.05764845f, 
    -0.01496541f, 0.11836663f, 0.07212834f, -0.21141008f, -0.04283740f, -0.04119363f, -0.04240078f, 0.19268277f, 
    0.00824225f, -0.19100150f, -0.07340015f, 0.00010905f, 0.01087132f, -0.21464422f, 0.00321491f, 0.00298925f, 
    -0.06741226f, -0.07637209f, -0.00129119f, -0.00088186f, -0.12091924f, 0.01028248f, -0.20441934f, -0.18855302f, 
    -0.14652503f, -0.10836072f, -0.20725566f, 0.37331453f, 0.07974366f, 0.00712441f, 0.15186571f, 0.03482710f, 
    0.19099380f, 0.02610037f, -0.15877524f, -0.00655146f, 0.00549716f, 0.06879596f, 0.02639562f, -0.05869829f, 
    -0.06257307f, 0.10779569f, -0.05952197f, -0.04860206f, -0.05238796f, -0.15139675f, 0.00732930f, -0.06886570f, 
    0.12870662f, 0.09772915f, 0.20584233f, 0.03817169f, -0.10224389f, 0.05306625f, -0.06981742f, 0.02139338f, 
    0.00537217f, 0.06441392f, -0.08969499f, -0.09511434f, 0.01634500f, 0.05835576f, 0.00007972f, 0.07777042f, 
    0.09457349f, 0.19900787f, -0.21533316f, 0.17057627f, 0.01702413f, 0.08714589f, 0.04789381f, 0.06051222f, 
    0.09255648f, -0.06554575f, -0.07364567f, 0.01937534f, -0.12564965f, -0.09574240f, -0.03366065f, 0.16591480f, 
    -0.05335685f, -0.00016760f, 0.07297142f, 0.00721639f, 0.17760210f, -0.21732953f, -0.34173843f, -0.21210842f, 
    0.06992843f, -0.15949418f, -0.25139058f, 0.00924080f, -0.07477199f, -0.11235479f, 0.01239982f, 0.02442278f, 
    0.03702684f, -0.03711285f, 0.00091429f, 0.05611984f, -0.03483673f, -0.00665450f, 0.02793755f, -0.01727943f, 
    -0.44734547f, -0.01089153f, -0.25201833f, -0.19198374f, -0.07836322f, 0.02645854f, 0.10258938f, -0.10569767f, 
    0.14550653f, 0.06215239f, -0.11834275f, 0.02035822f, 0.08451861f, -0.00441635f, -0.06718508f, -0.04908216f, 
    -0.06885371f, 0.01023285f, 0.08632477f, 0.05040934f, -0.04688975f, -0.05316893f, 0.06905651f, -0.05806341f, 
    0.15207176f, 0.00646479f, 0.06372725f, -0.08293983f, -0.01875735f, 0.11620099f, 0.01047434f, 0.17649288f, 
    -0.04687635f, 0.10675387f, -0.08493915f, -0.05870372f, -0.07199228f, -0.00152330f, -0.14968757f, 0.10624513f, 
    0.03118173f, -0.22178276f, 0.09011615f, 0.10350505f, 0.10163665f, -0.05750332f, 0.15387312f, 0.03772846f, 
    0.13481678f, -0.28003821f, -0.06069529f, -0.05187304f, 0.00342809f, -0.06532761f, 0.05570349f, -0.06509031f, 
    -0.02009284f, 0.00721735f, 0.05209988f, 0.01744618f, -0.00513381f, -0.27513140f, -0.02633369f, 0.05086000f, 
    0.13185415f, -0.15773250f, -0.24534032f, 0.14534841f, -0.09912564f, -0.01674043f, 0.12732112f, -0.05229278f, 
    0.05699073f, -0.04574555f, 0.02089751f, -0.02282538f, -0.00087228f, 0.01628953f, 0.00155219f, -0.07783093f, 
    0.45048699f, -0.07942555f, 0.50655872f, -0.02619274f, -0.09732059f, -0.05826846f, 0.04926782f, -0.10046668f, 
    0.11341803f, 0.07342553f, -0.05902170f, 0.08535999f, -0.10450248f, -0.04792060f, 0.09291737f, -0.06360654f, 
    -0.04029634f, 0.10778778f, 0.28856191f, -0.16279128f, 0.11893227f, 0.17748001f, 0.16467854f, 0.08818790f, 
    -0.11383481f, -0.06432500f, -0.00174825f, -0.03695009f, 0.06460685f, -0.00243694f, -0.08174026f, -0.00851531f, 
    0.02336071f, -0.08484935f, -0.01906253f, 0.08194749f, 0.06073286f, 0.02676817f, -0.10221536f, 0.03867695f, 
    -0.44209945f, -0.40647829f, -0.42251813f, 0.17643838f, 0.15827519f, -0.04640618f, -0.07695944f, -0.06240682f, 
    0.09795461f, -0.22200611f, -0.09339187f, 0.03418420f, 0.02687273f, -0.02047695f, 0.03882919f, 0.22152023f, 
    -0.12051073f, 0.23237239f, 0.18029550f, 0.01849939f, -0.09828849f, -0.27962729f, -0.15878995f, 0.02122766f, 
    -0.02387369f, -0.09900694f, -0.20612495f, 0.03026227f, -0.15064287f, -0.06984641f, 0.00081469f, -0.00692325f, 
    -0.02982647f, -0.05837063f, -0.01115819f, 0.01375030f, -0.01169080f, -0.00787013f, 0.05468014f, -0.04993916f, 
    -0.24703096f, -0.05202069f, -0.03843576f, 0.31937474f, -0.15231240f, -0.08758929f, 0.10286559f, 0.07884464f, 
    0.10977925f, -0.01070738f, -0.25333869f, -0.05446079f, 0.09477519f, 0.18855016f, -0.11556046f, -0.01517382f, 
    0.08555783f, 0.18074676f, -0.10065594f, -0.19233285f, -0.10452380f, -0.09879965f, -0.09634466f, 0.16488312f, 
    0.03529752f, 0.05271438f, -0.04488688f, 0.01634426f, -0.17435968f, -0.06916902f, -0.05937576f, 0.08545955f, 
    -0.09189160f, -0.07808497f, -0.09104315f, -0.03068161f, -0.04373746f, -0.00838239f, 0.03079814f, -0.04236262f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15061654f, 0.11810014f, 0.01939596f, -0.09047634f, -0.01735121f, 0.04765840f, 0.02141659f, -0.09545077f, 
    0.04399783f, 0.04248098f, -0.00942370f, -0.01352260f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
