#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.19488367f, -0.61441255f, -0.50175667f, -0.49957252f, 0.72600073f, -0.44804561f, 0.29652032f, -0.14166038f, 
    -0.28969538f, 0.00677661f, 0.84552324f, -0.52419358f, -0.19940758f, -0.38003612f, -0.45079553f, -0.03290727f, 
    0.28656542f, 0.15118712f, 0.52668118f, 0.24692477f, -0.10266486f, -0.66906613f, 0.29735577f, 0.48525214f, 
    -0.12382974f, 0.08491874f, 0.37222561f, 0.53010923f, -0.16296972f, 0.17468432f, -0.11575173f, -0.36695272f, 
    0.11569019f, -0.39541954f, 0.04143326f, -0.02427790f, 0.18581437f, 0.02786531f, 0.05793404f, -0.50993621f, 
    -0.84166300f, -0.42854959f, -0.11690183f, 0.02606745f, 0.30563438f, -0.76684546f, 0.22042575f, -0.65670508f, 
    0.37023541f, 0.46989235f, -0.49301064f, -0.27706912f, 0.34589902f, -0.01112035f, -0.58873206f, -0.04514620f, 
    -0.01548646f, 0.57830888f, 0.64277560f, 0.29457468f, 0.23236798f, -0.25595713f, 0.13061528f, -0.92006910f, 
    -0.81645423f, -0.44926605f, -0.20986307f, -0.43663177f, 0.03574634f, 0.19301620f, 0.10556749f, -0.21880576f, 
    -0.10357419f, -0.91689807f, -0.49963555f, -0.46994805f, -0.38285431f, -0.17698738f, 0.09846564f, 0.28000027f, 
    0.29366177f, -0.69020414f, -0.44067633f, 0.37773547f, 0.16846831f, 0.71295208f, -0.44462901f, -0.06675858f, 
    -0.13885018f, -0.33962238f, 0.46788999f, -0.12640718f, 0.26104984f, 0.27859926f, -0.82267177f, 0.46381900f, 
    0.14197728f, 0.16029784f, -0.02300974f, 0.23162991f, 0.29828125f, -0.51698166f, -0.33782485f, 0.28477323f, 
    -0.55320930f, 0.61659062f, 0.38844880f, 0.29234701f, 0.58286262f, 0.47773111f, 0.47085899f, 0.24557319f, 
    -0.29678798f, 0.13476339f, 0.24003214f, 0.22930697f, -0.38729206f, -0.56681293f, -0.46076578f, -0.71256286f, 
    -0.05874762f, 0.55155706f, 0.72870666f, 0.12671846f, -0.01052784f, 0.22743306f, 0.65606976f, 0.28157136f, 
    0.66280365f, 0.06983738f, -0.01488069f, 0.41276434f, -0.29596421f, -0.24650812f, 0.09938981f, -0.67145509f, 
    0.20048440f, -0.19515848f, 0.33173382f, 0.67993009f, 0.08715834f, -0.22905383f, -0.53269738f, -0.42996585f, 
    0.23847729f, 0.73952442f, -0.00043338f, -0.59585053f, -0.68786407f, -0.29331028f, 0.10014528f, -0.17231092f, 
    -0.10912760f, 0.42218745f, -0.07843855f, -0.58763617f, -0.52421761f, -0.20779042f, -0.24385926f, 0.08243134f, 
    -0.14163201f, 0.40305185f, 0.65109807f, -0.04649118f, 0.21377866f, 0.82112539f, 0.57440251f, -0.62095064f, 
    0.06657561f, 0.41819417f, -0.13295566f, 0.59496814f, 0.68847841f, 0.08744065f, 0.68905473f, -0.58785063f, 
    -0.25838780f, -0.14322990f, -0.03230897f, -0.20073594f, -0.19099739f, 0.72166586f, 0.62701303f, 0.43113044f, 
    0.16247186f, -0.20248106f, -0.28142834f, -0.03796576f, -0.08794557f, 0.66777694f, 0.49375400f, 0.51738971f, 
    -0.01785015f, -0.35057786f, -0.18165353f, -0.25750694f, 0.32521600f, 0.00505353f, -0.17648330f, 0.54234934f, 
    0.47373575f, -0.42827430f, 0.24830803f, 0.40247187f, -0.39263740f, -0.17712052f, -0.55184329f, -0.08628591f, 
    0.49422380f, -0.86103064f, -0.10106317f, 0.12864242f, 0.25201243f, 0.00135649f, -0.24009719f, -0.09036183f, 
    0.31629983f, -0.21571575f, 0.50831085f, 0.65533185f, 0.22290954f, -0.00613232f, -0.57144874f, 0.25969657f, 
    -0.03122457f, 0.60234886f, 0.60101634f, 0.47701237f, -0.30472896f, 0.45881337f, -0.53219551f, 0.24327612f, 
    0.22924896f, 0.17927369f, 0.58766115f, -0.79172951f, 0.41389063f, 0.31766582f, 0.28971455f, 0.55547899f, 
    0.12289887f, -0.56740707f, 0.09130626f, -0.32598579f, -0.61547887f, 0.59059727f, 0.48290583f, 0.30641261f, 
    -0.29334632f, 0.42177102f, -0.01779665f, 0.43463162f, 0.25903967f, -0.70989388f, 0.61189795f, -0.42863902f, 
    -0.43069828f, -0.60629708f, -0.05008681f, -0.01956808f, -0.31044397f, -0.44356233f, -0.60904777f, -0.26921481f, 
    0.53062928f, 0.18063565f, 0.40509108f, 0.30109656f, -0.25893986f, 0.11837366f, 0.31559622f, -0.38369474f, 
    0.50254923f, -0.11834017f, -0.09414607f, 0.52198726f, 0.22501327f, 0.01713628f, -0.32970503f, 0.70195550f, 
    -0.39241490f, -0.60368854f, 0.09758684f, -0.32499242f, -0.05682117f, -0.27361935f, -0.31511313f, 0.40173137f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05857681f, -0.19717808f, 0.13010511f, -0.04262690f, -0.13840407f, 0.12542637f, -0.06375846f, 0.14409843f, 
    0.08776733f, -0.32737920f, -0.18913832f, -0.00574366f, -0.10616346f, -0.25500482f, 0.18466571f, -0.21466514f, 
    0.09653325f, 0.19140539f, -0.26550737f, -0.26868522f, 0.27460086f, -0.04664855f, 0.05198867f, 0.00483268f, 
    0.15705711f, -0.13600416f, -0.03816089f, -0.09270836f, -0.03477775f, -0.15825586f, 0.17638503f, 0.09309513f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.09466604f, -0.07222550f, -0.02296447f, 0.15465550f, -0.01207839f, 0.17004018f, -0.04524640f, -0.28625503f, 
    -0.05474598f, -0.21959151f, -0.22462805f, -0.06547070f, 0.03149461f, 0.07448693f, 0.14872301f, -0.18375315f, 
    -0.05560630f, -0.15766922f, 0.04335567f, -0.01251989f, -0.00912716f, -0.10793531f, -0.06777338f, -0.00400560f, 
    0.03362238f, -0.02406925f, -0.00984467f, -0.18587081f, 0.03813156f, 0.09099784f, -0.00340638f, 0.11440101f, 
    0.05875862f, -0.01297948f, 0.04321253f, -0.01077225f, -0.02844949f, -0.06040594f, 0.26184741f, -0.17332967f, 
    0.01050153f, -0.04667581f, 0.10647743f, 0.01130255f, 0.08854779f, -0.22212137f, 0.02271873f, -0.06638204f, 
    0.06768835f, -0.00676552f, 0.00156586f, -0.06528171f, 0.03137220f, -0.05798977f, 0.02777598f, 0.17882271f, 
    -0.15006262f, -0.03100055f, 0.11396357f, 0.01557589f, 0.12407473f, 0.02541897f, -0.02387523f, 0.00445283f, 
    -0.04328631f, -0.13535076f, 0.14419235f, 0.05795541f, 0.08217427f, 0.12905838f, -0.00156342f, -0.01535452f, 
    -0.08412819f, 0.01183135f, 0.14930308f, 0.07320339f, 0.06583936f, 0.12116557f, 0.15127729f, 0.18525158f, 
    -0.00913350f, -0.11511528f, -0.06937174f, -0.37102595f, -0.09839512f, -0.02327720f, -0.01316064f, -0.12656601f, 
    0.03351920f, -0.09073683f, -0.17830200f, -0.13047674f, -0.18046667f, -0.05246837f, 0.04292322f, 0.06843156f, 
    0.06391910f, -0.07012969f, -0.13689651f, -0.09000961f, -0.07144649f, -0.16446759f, 0.13939245f, -0.04073896f, 
    -0.01250018f, 0.08499071f, -0.03072717f, -0.11016978f, -0.06992657f, -0.05453411f, 0.22563058f, 0.00785997f, 
    -0.00519874f, -0.08901337f, 0.09086085f, 0.00184992f, -0.02669886f, 0.13106565f, -0.01403090f, -0.09752941f, 
    0.05163120f, 0.09885146f, 0.01734559f, 0.07587308f, -0.09327102f, 0.10066377f, 0.18029955f, -0.02044714f, 
    0.13601486f, 0.10383803f, 0.05662152f, -0.11490666f, 0.08848631f, -0.05078892f, -0.02233504f, 0.00535765f, 
    -0.04777887f, -0.22859080f, 0.00628288f, 0.13280009f, 0.00712224f, -0.02903424f, 0.03817746f, -0.02342912f, 
    -0.20650484f, 0.03216639f, 0.19016437f, -0.17148653f, -0.01248367f, -0.11017525f, -0.01851833f, 0.00819596f, 
    0.05164425f, 0.06114895f, -0.18554021f, -0.05601833f, -0.04063191f, 0.03796322f, 0.08452609f, -0.00426736f, 
    0.07799020f, -0.00973005f, 0.00973496f, -0.20282993f, 0.17553668f, 0.01136696f, 0.00151529f, -0.15644829f, 
    -0.03258185f, 0.04948832f, -0.02740859f, -0.09104138f, 0.10575528f, 0.08622237f, -0.14513429f, -0.01208280f, 
    0.08111819f, -0.01396590f, -0.21200633f, 0.12980984f, 0.29211485f, 0.14377967f, 0.19063111f, 0.02526021f, 
    0.10044395f, 0.05955321f, 0.05384239f, 0.05991108f, 0.09938973f, -0.11027300f, -0.02934308f, 0.26015633f, 
    0.05446227f, -0.10818131f, 0.08948599f, 0.09567612f, 0.01601951f, -0.01221768f, 0.04253529f, 0.15157391f, 
    0.10495254f, 0.04589510f, 0.10469703f, -0.05342549f, 0.06761139f, -0.10534903f, 0.02447609f, -0.09450548f, 
    -0.23606254f, -0.24565513f, 0.14955719f, 0.15808508f, -0.00622980f, -0.08479284f, 0.03708577f, 0.13639383f, 
    -0.11602310f, 0.04089678f, 0.16938406f, -0.07359031f, 0.10907659f, -0.15024439f, 0.07635390f, -0.00619902f, 
    0.04859363f, -0.24267344f, 0.07691947f, 0.23878910f, -0.05873686f, 0.02052853f, 0.07534734f, -0.03401539f, 
    -0.05575313f, -0.00169470f, -0.44764140f, -0.11591344f, -0.14289376f, 0.11564416f, 0.06696343f, -0.08426931f, 
    0.13219394f, 0.02385171f, 0.01409117f, -0.30729225f, 0.15450822f, -0.02558494f, 0.06566711f, -0.04360323f, 
    0.01175298f, -0.00219183f, 0.03043549f, -0.10745376f, 0.07992965f, 0.14500356f, 0.14901984f, 0.10051957f, 
    0.11343785f, -0.25123110f, -0.10770335f, 0.06692269f, 0.04737931f, 0.04300167f, 0.22098476f, -0.13675532f, 
    0.04439511f, 0.01758516f, -0.05700484f, 0.13494833f, 0.01851287f, -0.07604180f, -0.31629631f, -0.00935006f, 
    0.00405140f, 0.14999470f, -0.07164230f, -0.03155920f, -0.04443287f, 0.03731624f, 0.05179743f, 0.11790100f, 
    -0.30673078f, -0.31747681f, -0.10701323f, 0.00502587f, 0.05083526f, 0.00694485f, -0.02149666f, 0.03204378f, 
    -0.02149407f, -0.05676630f, 0.17951809f, 0.10438063f, 0.03409462f, 0.07105301f, -0.03127854f, -0.21334331f, 
    -0.21840635f, -0.17406067f, -0.05981969f, 0.14103554f, -0.18207143f, -0.08211210f, -0.02423464f, -0.14512967f, 
    0.01898808f, -0.03226018f, -0.03530993f, -0.08438833f, -0.09388232f, -0.03945528f, 0.04783569f, 0.08472013f, 
    -0.05099479f, 0.02109484f, 0.14175124f, -0.11632615f, -0.09370755f, 0.02486426f, -0.01454771f, 0.08028423f, 
    -0.03288642f, -0.06716810f, 0.02332204f, -0.01872952f, -0.22842756f, -0.15167528f, -0.07716919f, -0.01615879f, 
    0.01273223f, -0.03277272f, -0.09329715f, 0.21556734f, 0.13952197f, -0.05455890f, 0.03268709f, 0.10742598f, 
    0.11151779f, 0.03742621f, -0.02499104f, -0.06916173f, 0.00425952f, -0.06551625f, 0.06366225f, 0.09912921f, 
    0.00319289f, 0.04545577f, -0.02500220f, -0.01195092f, -0.01129423f, 0.06681637f, 0.15327844f, -0.17957848f, 
    -0.04136160f, 0.25998437f, 0.05974202f, 0.03700213f, -0.08282229f, 0.13818294f, -0.00886620f, -0.05430839f, 
    -0.05723886f, -0.00706633f, 0.17283247f, -0.02153303f, 0.13656701f, -0.01794592f, 0.00506572f, -0.09393533f, 
    -0.04709027f, 0.01254261f, 0.13646942f, 0.09714863f, 0.10932814f, -0.07835126f, -0.04263544f, 0.08596341f, 
    -0.00151940f, -0.01044352f, -0.00952085f, -0.02054315f, -0.03280827f, 0.14470722f, -0.03306377f, -0.01164163f, 
    -0.12893248f, 0.06136717f, 0.09750295f, -0.28594643f, 0.06552655f, 0.10679295f, -0.09819776f, 0.04191119f, 
    -0.00072542f, 0.06331857f, -0.18737759f, -0.00562491f, 0.12013523f, 0.15491010f, 0.06923609f, 0.02391579f, 
    -0.05335246f, 0.05884354f, -0.09162864f, 0.03082305f, -0.00589129f, 0.08850628f, -0.01777459f, -0.12382629f, 
    0.03192058f, 0.03559452f, 0.04777276f, -0.07632865f, 0.14848542f, 0.11296932f, 0.05725781f, -0.02270374f, 
    0.03756930f, 0.02800793f, 0.02352663f, -0.02657110f, 0.03551865f, 0.12077381f, 0.10686721f, 0.03945720f, 
    0.08695611f, 0.14406507f, 0.05776760f, -0.02227542f, -0.25072750f, 0.09116914f, 0.04798574f, 0.12714399f, 
    -0.14037475f, -0.12338883f, 0.17553152f, 0.03016116f, 0.02604789f, 0.15003274f, -0.06588358f, 0.02478780f, 
    0.09264114f, -0.17736156f, 0.09928592f, 0.09100772f, -0.03803073f, 0.09865160f, -0.00235325f, -0.13202508f, 
    0.02738153f, -0.09947591f, 0.04602491f, 0.14301246f, -0.03250275f, 0.02124409f, -0.21655066f, 0.05651920f, 
    0.09604841f, 0.18046451f, 0.11260171f, -0.05015326f, 0.04767717f, 0.18427925f, -0.03796959f, -0.04234308f, 
    0.02589189f, -0.11480382f, 0.04567022f, 0.01554050f, -0.06962993f, 0.08095186f, 0.00851514f, -0.04461385f, 
    -0.03147578f, -0.02175656f, 0.16253677f, 0.14652336f, -0.01239954f, -0.11577616f, -0.05175784f, 0.12999728f, 
    0.06218264f, -0.06397726f, 0.08051880f, -0.18394725f, 0.16889888f, 0.05186479f, 0.07809206f, -0.13328032f, 
    0.01787128f, 0.00458529f, -0.22578537f, -0.04230313f, 0.30923456f, 0.15249415f, 0.12789454f, -0.08177060f, 
    0.02905141f, -0.00336096f, -0.00456567f, -0.05088293f, -0.06038848f, 0.17847554f, -0.05969797f, 0.05099257f, 
    0.03941171f, 0.05251887f, -0.05628502f, -0.08206140f, -0.02351910f, -0.07250714f, 0.12166160f, 0.18179283f, 
    0.03629833f, -0.19814144f, 0.11090790f, -0.08813375f, 0.09142132f, 0.00175037f, 0.16865538f, -0.00322328f, 
    0.05490293f, 0.14336900f, 0.15212286f, -0.08842774f, -0.09208708f, -0.05837351f, 0.05135503f, -0.20205450f, 
    0.03331061f, 0.04858867f, 0.04281027f, 0.11781481f, -0.07860173f, -0.00562195f, 0.09575963f, -0.04413477f, 
    0.00154404f, 0.06905385f, 0.03681520f, -0.02826574f, -0.10011306f, -0.13391156f, 0.02434623f, 0.04708891f, 
    0.15349017f, 0.00998561f, -0.11232132f, 0.01637348f, -0.15857732f, 0.06431224f, -0.04401774f, 0.07123107f, 
    0.05735787f, -0.08762751f, 0.08671951f, 0.06352743f, 0.01140762f, 0.10205280f, -0.04068399f, -0.06716015f, 
    0.05507144f, 0.00630623f, 0.08878211f, -0.01414739f, 0.00726787f, 0.07030179f, -0.04119733f, -0.06778705f, 
    0.08526386f, 0.06924111f, -0.00970818f, 0.09725257f, -0.09356925f, -0.11546285f, 0.07870405f, -0.16063499f, 
    -0.08776265f, 0.09001835f, 0.25853470f, 0.00620068f, -0.08719411f, -0.05860201f, -0.04434889f, 0.02116631f, 
    0.02837041f, 0.06111114f, -0.14234935f, 0.03593897f, -0.14114933f, -0.22593661f, 0.01490338f, 0.06784162f, 
    0.08598268f, 0.02353787f, -0.15555997f, 0.00739190f, -0.02412600f, 0.08710736f, -0.05997048f, -0.05721334f, 
    0.12169640f, 0.02474653f, -0.09205566f, 0.13742514f, 0.02095189f, -0.00527200f, 0.00383515f, 0.04644184f, 
    -0.11368512f, 0.04494255f, 0.10927568f, -0.11454992f, 0.06708263f, -0.05758620f, 0.08293870f, 0.00727097f, 
    0.03328040f, -0.21471128f, 0.06399071f, 0.03973416f, 0.00684941f, 0.24490240f, -0.07446485f, 0.08529586f, 
    -0.13354151f, -0.07993395f, 0.07741053f, 0.25166422f, -0.04149931f, 0.09596708f, 0.09591791f, -0.17829907f, 
    -0.11012569f, 0.06522032f, -0.02481176f, 0.05950649f, 0.01080102f, -0.09294337f, 0.00394069f, 0.06542702f, 
    -0.02255667f, 0.04414164f, -0.06538578f, 0.04105532f, -0.05188122f, 0.02032667f, 0.01071204f, 0.06202850f, 
    0.03675806f, -0.12411815f, 0.09599534f, 0.03914013f, 0.02651901f, 0.06998177f, 0.03294368f, 0.00379976f, 
    0.05760841f, 0.06650543f, -0.22503899f, 0.00370055f, -0.20722133f, -0.18818751f, 0.03593798f, 0.17643131f, 
    0.09744532f, -0.02286816f, -0.03303907f, -0.22376367f, 0.10000624f, -0.03000251f, 0.08854461f, -0.13526538f, 
    -0.17267957f, 0.07937706f, -0.05728946f, -0.02572640f, 0.11504796f, -0.00023919f, -0.00211128f, 0.01242712f, 
    -0.06322610f, -0.17402977f, -0.16177391f, -0.01938282f, -0.14626130f, -0.02985562f, 0.08524638f, 0.21153124f, 
    0.08776966f, -0.00403824f, -0.03874869f, -0.09575094f, 0.06041587f, -0.20824200f, 0.01625782f, -0.02418413f, 
    0.05944519f, 0.03446434f, 0.07159497f, 0.05132608f, 0.07714904f, 0.03564982f, 0.04503810f, 0.14229828f, 
    -0.09714837f, 0.04763648f, 0.13026285f, 0.13287576f, 0.08706696f, 0.12561543f, -0.04365276f, 0.06248938f, 
    -0.11979592f, -0.08100739f, -0.00418373f, -0.12270812f, 0.18016529f, -0.10360129f, -0.03343998f, 0.22414252f, 
    -0.05230107f, -0.00759668f, 0.08349883f, -0.12421273f, -0.02179451f, -0.18336162f, 0.18423891f, 0.02549067f, 
    -0.00706646f, 0.09687117f, 0.06716206f, -0.10237101f, -0.01832849f, 0.03485573f, -0.11716860f, -0.01444091f, 
    0.09359584f, -0.07747412f, -0.20141724f, -0.10225850f, 0.09083391f, 0.16884358f, -0.12622346f, 0.00027711f, 
    -0.03594125f, 0.13787960f, -0.06173798f, 0.04750488f, -0.10779490f, 0.13121670f, -0.01573489f, -0.16698742f, 
    0.16014162f, -0.03283921f, 0.06977580f, -0.05732790f, 0.20262219f, 0.15195723f, -0.01148761f, 0.09900978f, 
    -0.06113480f, 0.13768020f, 0.04524912f, -0.02574245f, 0.06145951f, -0.18255645f, -0.02775423f, 0.23733005f, 
    0.00592381f, 0.08890606f, 0.00110120f, 0.15510036f, -0.01789831f, 0.00976473f, -0.18806200f, 0.04596904f, 
    -0.14879848f, -0.13109156f, 0.04242897f, 0.19484726f, 0.15548457f, -0.07200166f, -0.04150984f, 0.00830966f, 
    -0.04289824f, 0.02302384f, -0.05069993f, 0.01094825f, 0.00658585f, -0.01512069f, 0.05389694f, 0.06416192f, 
    -0.18045406f, -0.01553448f, -0.05396092f, 0.16194506f, -0.03130085f, 0.08721963f, 0.02003890f, 0.14914283f, 
    -0.09554593f, -0.11577453f, 0.00955488f, 0.28726909f, -0.01897779f, -0.02942111f, -0.05106898f, -0.13513505f, 
    0.02196795f, 0.05834816f, -0.20071054f, -0.15904714f, -0.26160669f, 0.00791164f, -0.06095451f, 0.05600690f, 
    -0.07889840f, 0.03437168f, -0.06222825f, 0.10605276f, -0.10996863f, -0.00895420f, -0.01940768f, -0.05379453f, 
    0.01722717f, -0.01562230f, -0.05595323f, -0.03947847f, 0.22604530f, -0.06264205f, 0.20317665f, -0.02496151f, 
    0.02652675f, -0.13187736f, 0.06452885f, 0.13914865f, 0.02835704f, -0.15556219f, -0.12246057f, -0.09409264f, 
    -0.07202118f, 0.16114965f, -0.01987974f, -0.06029810f, -0.06992097f, 0.04324386f, -0.00383236f, -0.00493972f, 
    -0.19953410f, -0.04476919f, 0.07620658f, 0.08172062f, 0.06354965f, 0.02622294f, -0.04541511f, 0.10193837f, 
    -0.02932266f, -0.03507918f, 0.08217953f, 0.16234885f, 0.00583730f, -0.06633500f, 0.16590866f, 0.03290423f, 
    -0.22900410f, -0.21297775f, -0.06051476f, 0.09789228f, 0.04413680f, 0.00308155f, -0.05140963f, -0.05421948f, 
    -0.16668881f, -0.15310876f, 0.03663594f, 0.05411495f, -0.13102910f, -0.04918281f, -0.06523290f, -0.06857154f, 
    -0.10074527f, 0.15063371f, -0.14482398f, -0.01705777f, -0.21606049f, -0.07329804f, 0.00868192f, 0.01041773f, 
    -0.15212545f, -0.00612893f, 0.05822178f, 0.14195395f, -0.14625426f, 0.01111617f, -0.11036615f, 0.07979748f, 
    -0.03292245f, -0.04823613f, 0.07300337f, -0.08847425f, 0.00682262f, 0.03233338f, 0.03142383f, -0.23310120f, 
    -0.10602331f, -0.06493467f, -0.10406515f, 0.10566039f, 0.26307911f, 0.35591418f, 0.05541774f, -0.09308489f, 
    0.08521491f, 0.14005822f, 0.03816709f, 0.03155922f, -0.03855172f, 0.06794747f, 0.34430632f, 0.28833768f, 
    0.11606716f, 0.07172689f, 0.09892443f, 0.06095193f, 0.03889799f, -0.05699242f, -0.12566957f, -0.44698459f, 
    -0.06556229f, -0.13208604f, 0.06993339f, 0.04909471f, -0.07291378f, 0.18805721f, 0.08014344f, 0.00843612f, 
    -0.29678077f, -0.17243181f, 0.03186820f, -0.00885581f, -0.01224511f, -0.03728301f, 0.13157246f, -0.05197660f, 
    0.13531698f, -0.27464190f, 0.05562802f, 0.15597185f, -0.05038041f, -0.05070115f, 0.02385643f, -0.10383893f, 
    -0.23213972f, -0.06451079f, 0.01430208f, -0.10681305f, -0.10963535f, 0.10797126f, 0.02441983f, 0.05729770f, 
    0.02367056f, 0.01693554f, -0.07005916f, -0.24062164f, 0.10086681f, 0.20934623f, -0.01433318f, -0.05699573f, 
    0.06658252f, 0.06067252f, 0.01938742f, 0.01238725f, -0.05067884f, 0.08236717f, 0.11434913f, 0.05033730f, 
    -0.02426992f, -0.02924520f, 0.01796430f, -0.02707505f, -0.10976869f, -0.01109930f, 0.25770870f, -0.53849334f, 
    0.08029432f, 0.05397160f, -0.00989142f, 0.04869053f, -0.11277433f, -0.14639701f, 0.11622176f, -0.07584485f, 
    0.10099714f, 0.06470526f, 0.06037448f, 0.01676823f, 0.07727026f, 0.00721067f, -0.12839495f, 0.48213270f, 
    0.35673699f, 0.11089675f, -0.16714473f, -0.00733749f, 0.06678388f, 0.16883412f, -0.03871321f, -0.03103516f, 
    0.08115722f, 0.07239947f, 0.12152366f, -0.14157499f, -0.07643449f, 0.02623395f, -0.03248545f, 0.08416206f, 
    0.13857034f, 0.04323734f, -0.04901896f, 0.09618090f, -0.10115988f, 0.02597493f, 0.10439350f, -0.14612165f, 
    -0.00075790f, 0.10392726f, -0.21695012f, -0.16705529f, 0.02514730f, -0.17904986f, -0.01962330f, 0.08709228f, 
    0.04918334f, -0.00733278f, -0.05147953f, -0.09046399f, -0.13630097f, 0.09455033f, -0.00606506f, 0.06160842f, 
    -0.02289101f, 0.06773450f, -0.00529731f, -0.02787851f, -0.04359170f, 0.07280783f, 0.30364731f, -0.06272729f, 
    -0.00086256f, -0.04935278f, 0.04198663f, 0.07889304f, 0.03127248f, 0.10285006f, 0.14589675f, 0.05662545f, 
    -0.08212757f, -0.02565062f, -0.05852126f, -0.06762034f, 0.01313192f, 0.00683920f, -0.09011476f, -0.04158545f, 
    -0.06446654f, 0.00001823f, -0.08280430f, 0.04445057f, 0.21110563f, 0.10084725f, -0.05472248f, -0.01258457f, 
    0.19681299f, -0.19256504f, -0.05877401f, -0.04845174f, -0.07599577f, -0.02174724f, 0.06934835f, 0.00333155f, 
    0.20340760f, -0.00048173f, 0.20799571f, -0.01564309f, 0.01271965f, 0.04209290f, 0.06724159f, 0.05289215f, 
    -0.00212293f, -0.04728757f, 0.15087920f, -0.08673382f, -0.03797216f, 0.00937987f, 0.03548418f, 0.00195175f, 
    0.01240818f, 0.02320822f, 0.13296740f, 0.03627583f, -0.05635478f, -0.00983222f, 0.13004193f, -0.02416540f, 
    -0.01950647f, -0.02953591f, 0.08711347f, -0.27906954f, -0.10036383f, 0.03575514f, -0.06457739f, 0.08052227f, 
    -0.19102070f, -0.01774155f, 0.16756141f, -0.02383136f, 0.09453612f, -0.13283400f, 0.00373527f, -0.01181720f, 
    0.15126221f, -0.10325974f, 0.03968581f, 0.03680579f, 0.05933606f, 0.02854108f, 0.07795741f, -0.35296485f, 
    0.01532139f, 0.14828858f, -0.06629715f, 0.04256848f, -0.08109375f, -0.12998068f, -0.03633121f, -0.02781712f, 
    -0.04862576f, 0.02356482f, -0.06277176f, 0.10166919f, 0.04072952f, 0.05280126f, 0.01151877f, 0.12682609f, 
    -0.41064256f, -0.01100505f, -0.19039156f, 0.10460160f, 0.06971850f, 0.00622104f, 0.06560590f, 0.05870152f, 
    -0.00562871f, 0.02328372f, -0.05788167f, -0.03652297f, -0.00322691f, -0.02155370f, 0.00484850f, -0.03791837f, 
    0.01356156f, -0.03003096f, -0.03642898f, 0.01925933f, 0.03234256f, -0.05077933f, -0.06218767f, -0.04847578f, 
    -0.00818218f, -0.02858363f, -0.03360087f, -0.00291004f, -0.01886896f, -0.01479381f, 0.02988857f, -0.02596874f, 
    -0.03163197f, -0.02536979f, -0.04708292f, -0.03577356f, -0.04562584f, 0.03644165f, -0.05827842f, 0.01288958f, 
    0.00458739f, -0.01199623f, 0.03713759f, -0.04531240f, -0.03754135f, -0.04558966f, -0.00303656f, -0.00442447f, 
    0.02836167f, 0.03928633f, -0.00570794f, 0.04014750f, 0.03473319f, 0.04156990f, 0.03019817f, -0.01158107f, 
    -0.02516901f, -0.02863697f, 0.02928379f, 0.02604667f, -0.05790519f, -0.01003327f, 0.03716950f, -0.02143922f, 
    0.00636790f, -0.03389748f, -0.06316074f, -0.06472043f, -0.00005384f, -0.05696307f, -0.04593429f, -0.04289780f, 
    -0.05037748f, 0.02993431f, 0.02313289f, -0.05765841f, 0.04163929f, -0.03635674f, 0.03528000f, 0.00240147f, 
    -0.01876361f, 0.00594588f, 0.04234128f, -0.01306399f, 0.02211718f, -0.05100743f, -0.03787196f, -0.05483361f, 
    -0.00909173f, -0.02696857f, 0.03519120f, 0.01470942f, -0.04789962f, -0.03260127f, -0.00764462f, -0.00674712f, 
    0.03929990f, -0.01477529f, -0.00260871f, -0.03457299f, -0.03473414f, -0.03868695f, -0.04355711f, -0.06426152f, 
    0.00990675f, -0.04287371f, 0.00850233f, 0.00808580f, -0.02555826f, 0.01452724f, -0.01992650f, -0.04166470f, 
    0.04891116f, -0.05326360f, 0.00833237f, 0.04693852f, 0.00948633f, -0.00045204f, -0.01950293f, -0.02677358f, 
    -0.04260780f, -0.00215659f, 0.01449400f, 0.00755450f, -0.00412073f, 0.02934796f, -0.06374166f, 0.04010538f, 
    -0.04500446f, 0.03343355f, 0.00863076f, -0.06160187f, 0.00410186f, -0.01547895f, -0.00003071f, 0.03629879f, 
    -0.06266063f, 0.03872598f, -0.06042878f, 0.00153003f, -0.03415891f, -0.06193222f, 0.03583702f, 0.00248688f, 
    -0.04945978f, 0.00848094f, 0.02076294f, -0.05041837f, -0.02965013f, -0.02632756f, -0.04432582f, -0.06413060f, 
    -0.00396074f, 0.04662101f, -0.01322991f, -0.04514682f, -0.05710088f, -0.03952151f, 0.00589359f, -0.01412357f, 
    -0.00974671f, -0.02771788f, -0.04977196f, -0.02952399f, -0.05678773f, 0.02614595f, 0.04010115f, -0.03641535f, 
    0.05027892f, -0.05122627f, 0.04654877f, -0.00938566f, -0.01529107f, 0.00858288f, 0.00811904f, -0.03626797f, 
    0.04842899f, -0.01293948f, 0.02659264f, -0.02716829f, -0.04213127f, 0.04017929f, -0.04661140f, 0.04155048f, 
    0.00272499f, 0.03131389f, 0.01908252f, -0.00979746f, -0.00673439f, -0.04232838f, -0.03661498f, 0.04055465f, 
    -0.01935832f, -0.01651425f, 0.04354422f, -0.03810626f, -0.00370779f, -0.02493185f, -0.05789730f, -0.04368799f, 
    -0.00491011f, -0.03870048f, 0.00654080f, -0.05139504f, -0.01069019f, 0.04416253f, -0.04744131f, -0.06493617f, 
    0.00624752f, 0.02786541f, -0.06307320f, 0.01471468f, 0.01419377f, -0.04115123f, -0.01041042f, -0.03235834f, 
    -0.02696660f, -0.03711339f, 0.02600555f, 0.01678970f, 0.00777649f, -0.00044295f, 0.00231359f, 0.03661650f, 
    -0.00503551f, -0.03581196f, -0.00948997f, 0.01075794f, -0.00944983f, 0.01306407f, 0.01717163f, -0.04201714f, 
    -0.04613191f, 0.00739805f, -0.03573686f, 0.03345749f, 0.04334471f, 0.00366293f, 0.02219035f, 0.03241609f, 
    0.02898353f, -0.00753392f, 0.02987057f, 0.01276363f, 0.01849634f, -0.06233565f, 0.02261703f, -0.04426198f, 
    -0.06472023f, -0.00452451f, 0.03834910f, -0.04600717f, 0.04146978f, -0.02770068f, 0.02407035f, 0.03759664f, 
    0.02130593f, 0.01436460f, 0.04708789f, 0.04280179f, 0.03841083f, -0.01336449f, 0.03017567f, -0.06372944f, 
    -0.06276631f, -0.03192578f, -0.01156040f, -0.04963076f, -0.05232450f, 0.03567248f, 0.01430184f, -0.05979080f, 
    -0.03774257f, -0.00146494f, -0.04956772f, 0.01785416f, -0.06299113f, -0.03753334f, 0.03058841f, 0.00792275f, 
    0.01140494f, -0.00465511f, -0.01754674f, -0.03706031f, 0.03151054f, -0.06180748f, -0.02169332f, 0.02193352f, 
    0.02180414f, 0.02182098f, -0.00351131f, -0.03032305f, -0.01738285f, 0.03898279f, -0.01011903f, -0.01112686f, 
    0.02549201f, 0.03371138f, 0.00309874f, 0.12056314f, 0.03142058f, 0.14398503f, 0.03066987f, 0.02658427f, 
    -0.04876332f, 0.14890502f, -0.07605341f, 0.00417975f, 0.09231228f, 0.02984398f, -0.01230472f, -0.01157318f, 
    -0.04486930f, 0.01842063f, -0.15333903f, -0.09959934f, -0.12360827f, 0.07086574f, 0.05641170f, -0.12055489f, 
    -0.00054694f, -0.07025810f, 0.14165597f, -0.31817058f, -0.13736114f, 0.26050118f, 0.02958786f, -0.07993422f, 
    0.04667130f, -0.07648219f, -0.02850986f, 0.14571092f, 0.11015604f, 0.09067920f, -0.03086248f, 0.01815435f, 
    -0.01772216f, -0.06766725f, -0.13709904f, -0.03075517f, 0.04168419f, -0.02358672f, 0.14854361f, -0.01347134f, 
    0.07455203f, -0.00226404f, 0.16670680f, 0.03554928f, 0.10828827f, 0.10113564f, 0.14379874f, 0.12730114f, 
    -0.02212726f, -0.05036829f, -0.00692581f, 0.02930690f, 0.14714874f, 0.02348206f, 0.07120551f, 0.06382874f, 
    0.10027206f, 0.21825463f, -0.04062355f, -0.01019023f, 0.04431953f, -0.05054160f, 0.03349323f, 0.01217977f, 
    0.19805820f, 0.19436966f, -0.01154042f, -0.04023479f, -0.02704326f, -0.00918263f, -0.15749465f, 0.07196672f, 
    0.03620318f, 0.21876214f, 0.16439085f, -0.09376516f, -0.03372227f, -0.00229361f, -0.10677722f, -0.00429303f, 
    0.11119073f, 0.02603658f, -0.07599040f, -0.15079063f, 0.09361628f, 0.05690582f, 0.03432457f, -0.07121594f, 
    -0.15802702f, -0.01458267f, -0.00348007f, -0.06958208f, -0.03245356f, -0.03898702f, 0.04554278f, -0.00234628f, 
    -0.04750581f, -0.08138041f, 0.03748209f, 0.09619429f, -0.40046588f, -0.19027013f, -0.12793678f, 0.06011324f, 
    -0.03390379f, 0.07899661f, 0.02087878f, -0.06016093f, -0.10067273f, 0.11704187f, 0.07368112f, 0.05028842f, 
    -0.09056515f, 0.04172532f, -0.01878523f, -0.06293903f, 0.02302445f, 0.05124213f, -0.39102674f, -0.31955871f, 
    -0.06141061f, -0.04989193f, -0.01681335f, -0.05400760f, -0.01594642f, -0.03664441f, 0.01204055f, 0.12062591f, 
    0.07491407f, -0.06569996f, -0.01404379f, 0.09636669f, -0.09565635f, 0.00322471f, 0.16970870f, -0.20121288f, 
    0.09950230f, 0.26483694f, 0.03746105f, 0.15797742f, 0.01511665f, 0.10010704f, -0.16236694f, -0.11091064f, 
    -0.14267346f, 0.02565400f, -0.06482242f, 0.03139535f, 0.05201982f, 0.08842754f, 0.15787089f, -0.01318267f, 
    -0.05996455f, -0.00929357f, -0.26363200f, -0.35753965f, -0.22232646f, -0.06110299f, 0.03165535f, -0.00711238f, 
    0.11318609f, 0.01926707f, 0.09942681f, -0.23875797f, -0.02612854f, -0.00500913f, 0.08239125f, 0.17506579f, 
    0.08507123f, -0.00774850f, -0.02057477f, -0.05942630f, -0.40275913f, 0.09269340f, -0.36742064f, 0.08061424f, 
    0.05756434f, 0.02728026f, -0.07901245f, -0.02373917f, 0.05112785f, -0.53002173f, -0.17877643f, -0.00041405f, 
    0.08033934f, 0.06974476f, 0.07648348f, -0.02405042f, 0.06945460f, 0.01936565f, -0.22448297f, 0.15815239f, 
    -0.17755871f, 0.00458313f, 0.07991836f, -0.06769734f, -0.07171689f, -0.08935384f, -0.05943859f, -0.12019192f, 
    -0.24296294f, 0.11484725f, 0.08038758f, 0.07487067f, 0.06711115f, -0.11650956f, -0.07480375f, 0.02732651f, 
    -0.11343291f, -0.16596942f, -0.10863061f, 0.01671218f, 0.01185644f, -0.05716868f, 0.07644287f, -0.04859871f, 
    0.12868667f, -0.42790383f, -0.15552054f, -0.07361571f, 0.05964640f, 0.02156439f, -0.08636579f, 0.00767556f, 
    0.00231674f, 0.08393096f, 0.02588125f, -0.12704824f, -0.14856713f, -0.02249625f, 0.08480516f, -0.15630275f, 
    -0.02422221f, 0.03215282f, 0.00383083f, -0.00547981f, 0.10720572f, -0.06831133f, -0.02932301f, -0.13774273f, 
    -0.01427495f, 0.06568864f, -0.01497222f, 0.07488186f, -0.04534309f, 0.22194777f, 0.15712622f, -0.02299503f, 
    -0.01817794f, -0.02842885f, -0.09274128f, 0.04788219f, -0.11014394f, 0.16222943f, 0.22171861f, 0.03114744f, 
    -0.05760183f, -0.08436659f, 0.15765981f, -0.18193874f, 0.09270742f, 0.07546646f, -0.06020284f, 0.05133342f, 
    0.11692931f, 0.02554605f, 0.00093006f, -0.15417916f, 0.00671034f, 0.05426938f, 0.15092468f, -0.04697538f, 
    0.00772327f, 0.04582433f, 0.09924959f, -0.07629522f, 0.07094581f, 0.01827239f, 0.06043548f, -0.04086116f, 
    -0.05414778f, -0.01200575f, -0.02443657f, -0.06431708f, -0.01020788f, 0.00508253f, 0.02355286f, -0.06638088f, 
    -0.04949487f, -0.02182215f, 0.01237435f, 0.05819900f, -0.06145849f, 0.01241119f, -0.06261589f, -0.02236398f, 
    -0.02934300f, 0.02062444f, 0.00385181f, -0.02688619f, 0.00438297f, -0.03494611f, -0.01124560f, -0.05193191f, 
    0.01392556f, -0.02368819f, -0.04778944f, 0.00836362f, 0.02025026f, -0.02252733f, 0.02084789f, -0.02198262f, 
    -0.00287720f, -0.06368969f, 0.05551824f, -0.03882213f, -0.00424768f, -0.04585532f, -0.01489505f, 0.03688310f, 
    -0.04404546f, -0.05107623f, -0.04059321f, 0.04880577f, -0.01280231f, -0.04199039f, 0.01320000f, 0.00514531f, 
    0.02122920f, -0.04732416f, 0.00286946f, 0.02650877f, 0.03281000f, -0.05809855f, 0.02492045f, 0.00511959f, 
    -0.01086839f, 0.02105865f, -0.05610451f, -0.02085553f, 0.04771564f, -0.01620853f, 0.00012567f, -0.05332337f, 
    -0.02583125f, -0.01724147f, -0.02897898f, -0.00250303f, -0.06101066f, 0.02909220f, 0.02895330f, -0.01728556f, 
    -0.00800660f, 0.02200802f, 0.02200029f, 0.00529001f, 0.04197268f, 0.02422718f, -0.06626276f, 0.00976054f, 
    -0.02407133f, -0.04890839f, -0.02543201f, -0.01056238f, -0.04626787f, -0.00160479f, 0.01787258f, -0.02516565f, 
    -0.02710574f, -0.03462902f, 0.00680345f, -0.04690636f, -0.04239494f, 0.00294235f, 0.03148170f, -0.00418269f, 
    0.01950912f, -0.03752856f, 0.04530772f, 0.01684543f, -0.05096441f, 0.03782289f, 0.00153215f, -0.03623420f, 
    -0.06682612f, -0.05284210f, -0.00980231f, -0.06318241f, -0.04026419f, 0.03086887f, -0.01654650f, -0.03145543f, 
    0.00976464f, 0.01026157f, -0.04538479f, -0.05770681f, -0.03481840f, 0.06000662f, 0.03267022f, -0.02921837f, 
    0.03419081f, -0.05622626f, 0.01041969f, 0.04596501f, -0.06856094f, -0.05311023f, -0.03087161f, -0.05593727f, 
    0.03229387f, -0.03289010f, 0.02569890f, -0.02675186f, 0.03538438f, 0.04974779f, -0.02545599f, -0.07072742f, 
    -0.06519696f, 0.03070052f, 0.03180887f, -0.03814160f, 0.03989487f, -0.00807492f, -0.01097376f, 0.01512202f, 
    0.03943833f, -0.01508748f, -0.02450662f, -0.03693660f, 0.00592482f, -0.00575997f, -0.05611258f, -0.00768377f, 
    0.04541111f, -0.00212044f, 0.00611477f, -0.06825686f, -0.02790839f, 0.05066199f, 0.03690719f, -0.03375704f, 
    0.03284386f, 0.00716491f, -0.00906379f, -0.03959730f, -0.04133531f, 0.00849831f, -0.01970835f, -0.01503674f, 
    0.02957786f, 0.01310931f, -0.02585106f, 0.03593672f, -0.06031035f, -0.04986304f, -0.05705039f, 0.04070228f, 
    0.02931626f, 0.01185489f, -0.01191221f, 0.01238521f, 0.01475746f, -0.04910875f, 0.00262385f, -0.01997259f, 
    -0.01861852f, 0.04715351f, -0.03803742f, 0.04551428f, -0.00584097f, 0.04616713f, 0.03293608f, 0.03508881f, 
    -0.00972269f, 0.01338527f, -0.04733497f, -0.00641392f, 0.01185769f, 0.04667239f, 0.01088379f, -0.04240976f, 
    -0.05787628f, 0.00795876f, 0.02350042f, 0.04416200f, 0.00376657f, -0.05534016f, 0.03316125f, 0.03425745f, 
    -0.06861093f, -0.02259924f, -0.02079436f, -0.05595196f, -0.03841281f, 0.00699486f, -0.00133330f, 0.01500520f, 
    -0.02376012f, -0.06338390f, 0.03215071f, 0.05107834f, 0.02307626f, -0.03832991f, 0.04790470f, -0.02169320f, 
    -0.00458872f, -0.01480935f, 0.03511677f, -0.01741414f, 0.00021290f, 0.01022958f, 0.03697698f, 0.05524665f, 
    -0.04409328f, 0.03679663f, 0.01471620f, 0.01288087f, 0.01824217f, 0.04169911f, 0.03561476f, 0.04482899f, 
    0.02608790f, 0.01521333f, 0.04981266f, 0.00024166f, -0.02649750f, 0.01915182f, 0.01164176f, 0.03817102f, 
    -0.04823517f, 0.04513257f, 0.03510126f, -0.01976577f, -0.06668276f, 0.04115076f, 0.01588640f, -0.03324577f, 
    0.00140357f, -0.02091989f, 0.02969759f, -0.00714826f, 0.04853453f, -0.01458377f, 0.02664333f, 0.00628398f, 
    -0.02197316f, -0.06277799f, 0.02582129f, -0.06429500f, -0.02838333f, -0.01634012f, 0.03044883f, -0.06926701f, 
    0.01859250f, -0.02639194f, 0.01780277f, -0.03967169f, -0.04415856f, -0.03086630f, -0.00878596f, -0.02814192f, 
    -0.03085325f, -0.02176802f, 0.02822837f, -0.06291744f, -0.01657938f, -0.01693955f, 0.01097502f, 0.03680379f, 
    -0.28553674f, 0.11477481f, -0.17748944f, 0.08486693f, 0.15624297f, 0.09039560f, -0.07316302f, 0.09713389f, 
    -0.02193976f, -0.07785299f, -0.03503022f, 0.14737798f, -0.12755650f, -0.08211750f, -0.11299817f, -0.19964059f, 
    0.15789358f, 0.00403276f, -0.04170724f, 0.13042472f, 0.08479591f, -0.04916291f, -0.09648705f, 0.08382120f, 
    0.06237917f, 0.05794542f, -0.12074104f, 0.07270550f, 0.03423112f, 0.00203451f, 0.02094248f, -0.01732867f, 
    -0.01291007f, 0.06399500f, 0.10884817f, 0.07968803f, 0.16240852f, 0.13593219f, 0.06402389f, 0.03964170f, 
    0.02926392f, -0.03812250f, 0.19875225f, 0.06482660f, 0.23186147f, -0.38905931f, -0.18453571f, 0.21080422f, 
    0.15205939f, 0.19646090f, 0.00958949f, 0.15926972f, 0.04607831f, -0.09423009f, -0.20838560f, -0.12966298f, 
    -0.10203809f, 0.07446916f, 0.11443064f, 0.08426141f, 0.06792311f, -0.15134765f, 0.00805371f, -0.38331026f, 
    0.00217101f, -0.13841152f, 0.21191950f, 0.17476961f, 0.02518894f, 0.11988223f, 0.07652873f, -0.09856395f, 
    -0.04006456f, -0.00011477f, -0.11247747f, 0.14945106f, 0.15629895f, -0.02935452f, -0.01428391f, -0.06536642f, 
    0.03996297f, -0.19063157f, -0.05240885f, -0.35409474f, -0.01966160f, 0.00040745f, -0.03712261f, 0.12816459f, 
    -0.08137862f, -0.02110844f, -0.05513531f, -0.18056239f, -0.11148307f, -0.07864098f, -0.06042197f, 0.07758854f, 
    -0.00542939f, -0.03637087f, -0.15682827f, 0.02690549f, 0.03303491f, 0.08018370f, 0.02385689f, -0.03064138f, 
    -0.08704953f, 0.15416208f, 0.11494839f, -0.08816931f, 0.02211678f, 0.00310058f, 0.06863839f, -0.03189331f, 
    0.11863258f, 0.11355924f, 0.09896436f, 0.05020361f, -0.11426586f, -0.13714850f, -0.00010004f, -0.08316149f, 
    0.16916582f, 0.08596840f, 0.07189903f, -0.06056122f, -0.16241913f, -0.08240229f, -0.02947740f, 0.16959377f, 
    0.16105765f, 0.09102770f, 0.02947332f, -0.06529930f, -0.01600116f, 0.03370472f, -0.01837035f, 0.13016976f, 
    -0.01602599f, -0.03101472f, 0.05056190f, 0.04100097f, 0.07260437f, 0.09770535f, 0.02271457f, -0.04647855f, 
    0.02678584f, 0.06112736f, 0.14695697f, -0.04580013f, 0.02045184f, -0.04886491f, -0.06176092f, 0.01917099f, 
    0.12474525f, -0.03015036f, 0.11450985f, 0.01182610f, -0.03039398f, -0.06967887f, 0.03736152f, 0.11959124f, 
    0.04730178f, 0.05566858f, -0.31917375f, -0.12990144f, -0.00766271f, 0.12330131f, 0.01721085f, 0.00480847f, 
    -0.01223519f, 0.02138530f, 0.07403352f, -0.05814413f, 0.18267687f, 0.08505464f, 0.06112752f, 0.00781757f, 
    -0.07858267f, -0.01121687f, 0.02553136f, -0.01701717f, -0.00021612f, -0.07744812f, 0.20517485f, 0.02868693f, 
    0.06315899f, -0.14428137f, -0.05869592f, 0.03154524f, -0.02404559f, 0.06824910f, 0.15385619f, 0.06922898f, 
    -0.00586873f, 0.11346161f, -0.05432464f, -0.00532278f, 0.05553218f, 0.04979723f, 0.04409616f, 0.04378949f, 
    0.13433088f, -0.05263566f, -0.09914609f, -0.07574482f, -0.15812434f, 0.09138823f, 0.11816224f, -0.13807452f, 
    -0.14681822f, 0.28365242f, -0.03977382f, -0.03077884f, -0.00451926f, 0.01438357f, -0.07032467f, 0.13830042f, 
    -0.08293190f, 0.02817934f, -0.06506197f, -0.04131433f, -0.04708239f, -0.02939666f, 0.02848731f, -0.05473147f, 
    -0.05585721f, 0.12187582f, 0.11439019f, 0.02490453f, 0.01090822f, -0.13832287f, -0.01905621f, -0.03855599f, 
    -0.01253149f, -0.13337989f, 0.33422178f, -0.08849741f, -0.05694740f, -0.08772910f, 0.07715413f, 0.01408220f, 
    0.00394841f, -0.09277523f, 0.00502228f, -0.10212091f, -0.22348344f, -0.07063991f, -0.06965936f, 0.02805835f, 
    -0.01839782f, 0.09729448f, -0.04104408f, -0.01180642f, 0.15771699f, -0.08972648f, -0.02741220f, -0.21214277f, 
    0.06201483f, 0.01130489f, -0.17757270f, -0.08236649f, 0.20201339f, -0.19999692f, -0.14506535f, -0.23690335f, 
    0.15046835f, 0.09482551f, 0.02063384f, -0.06351706f, -0.04851610f, -0.04288793f, 0.10173835f, -0.04025118f, 
    0.15633827f, -0.04727703f, -0.15396695f, 0.05645810f, 0.10941702f, 0.01085890f, 0.02167679f, -0.00040426f, 
    -0.06915112f, -0.20959653f, -0.05340350f, -0.00571651f, -0.04386248f, -0.03019452f, -0.03935429f, 0.13164470f, 
    0.15069215f, -0.15653631f, 0.10533359f, -0.03414741f, 0.12130217f, -0.00925852f, -0.09434695f, -0.01199214f, 
    0.04834882f, -0.14292122f, -0.03346997f, -0.06788204f, 0.00260822f, 0.08002500f, 0.05075352f, -0.10211663f, 
    -0.00323546f, -0.09495316f, 0.24558862f, 0.08414645f, -0.07268375f, -0.05138041f, -0.12285876f, 0.03764490f, 
    -0.11311140f, 0.03572536f, -0.06788522f, -0.23460788f, 0.02435284f, -0.07752106f, -0.01736045f, -0.01873226f, 
    0.03026456f, -0.07905226f, 0.03873935f, 0.03685414f, -0.21591921f, 0.12028084f, 0.02615118f, 0.13243306f, 
    -0.00553316f, 0.03369293f, -0.04094565f, 0.07988054f, 0.09928459f, 0.21278302f, -0.07488727f, -0.06105737f, 
    -0.06849252f, -0.13474849f, -0.04327212f, 0.09534840f, 0.03565451f, 0.00392348f, 0.38286397f, 0.18476142f, 
    0.01518557f, 0.04985883f, -0.11926838f, -0.01417619f, -0.00242921f, -0.01072080f, 0.03974070f, -0.08511924f, 
    -0.26228362f, 0.08019564f, -0.15554284f, -0.03105685f, -0.05792635f, -0.00331696f, 0.01479787f, 0.04657727f, 
    0.29216346f, -0.27848309f, 0.10811607f, -0.09417665f, 0.04959897f, -0.05241244f, 0.00938177f, 0.05097785f, 
    -0.06601137f, 0.20792343f, -0.12998940f, -0.15026882f, -0.01023561f, -0.03182340f, 0.08018712f, -0.12716718f, 
    0.12262160f, -0.01663839f, -0.33731747f, 0.20624261f, 0.12625071f, -0.06439193f, -0.00855620f, 0.10780337f, 
    0.08647337f, -0.04322179f, 0.01213988f, 0.10784805f, 0.02722508f, 0.00821106f, 0.16444547f, -0.02634623f, 
    0.03927990f, -0.15383404f, -0.15516466f, -0.04817245f, -0.04556727f, 0.00352272f, 0.11426068f, -0.10886683f, 
    -0.01870904f, 0.16989091f, 0.12677775f, 0.05307339f, 0.07596820f, 0.37645134f, 0.06248832f, 0.07064066f, 
    -0.01608910f, 0.03369017f, 0.00855245f, -0.03469200f, 0.01702945f, 0.08811368f, -0.30088952f, 0.05957610f, 
    -0.14012313f, -0.16070744f, 0.01452459f, 0.00667246f, 0.01449742f, -0.06448539f, 0.17322341f, 0.32465553f, 
    0.03490322f, -0.07259692f, 0.06832696f, 0.10632090f, 0.03812809f, 0.03207376f, 0.15066062f, 0.03435042f, 
    -0.15906052f, -0.01503530f, -0.05176662f, 0.07256139f, 0.06511872f, 0.02372686f, -0.11978662f, 0.03173212f, 
    0.02047477f, 0.17392646f, -0.22572227f, 0.00641746f, -0.05141077f, 0.10846415f, -0.01327843f, -0.02440306f, 
    -0.02331543f, -0.06431135f, -0.26527858f, -0.31781694f, 0.03440142f, -0.02034716f, 0.01910848f, 0.03299161f, 
    -0.06567535f, -0.03029105f, -0.01094794f, 0.04614066f, -0.22865190f, 0.08846650f, -0.19239248f, 0.09372602f, 
    0.07699730f, -0.04341552f, -0.04458746f, 0.08102319f, 0.07600226f, -0.12188759f, 0.04014038f, -0.23884010f, 
    0.14864212f, 0.05994302f, -0.03410529f, 0.01632016f, -0.02210794f, -0.15932709f, 0.21942645f, 0.06165243f, 
    -0.01630445f, -0.00729152f, -0.01351918f, 0.05156434f, 0.11976063f, -0.07650654f, 0.03477792f, 0.07954192f, 
    -0.29242364f, 0.09854320f, -0.01613143f, 0.15757835f, -0.10271193f, -0.12233721f, -0.04338207f, 0.05434431f, 
    -0.31871450f, -0.19537266f, 0.01880186f, 0.10035235f, -0.10806317f, 0.07243568f, -0.01397368f, 0.16268370f, 
    0.01386523f, -0.00507415f, 0.07394443f, 0.05707981f, 0.11424015f, -0.03825970f, 0.00588739f, 0.08296911f, 
    -0.02406477f, 0.06618502f, 0.27904367f, -0.11599591f, -0.01360153f, 0.05216900f, 0.06615130f, -0.03980439f, 
    -0.15119831f, -0.09856204f, -0.27069011f, 0.14997397f, -0.02158307f, 0.06426846f, 0.03465755f, 0.06352171f, 
    0.05169570f, 0.02105515f, 0.08093945f, 0.10013713f, -0.19983619f, 0.19247109f, -0.11515945f, -0.04901720f, 
    -0.04707122f, 0.06808944f, 0.00750183f, -0.08622261f, -0.35086158f, -0.07641964f, -0.23296881f, 0.02751807f, 
    0.09706789f, -0.00192159f, 0.06587800f, 0.01524786f, 0.11106025f, 0.22143652f, 0.10557387f, 0.09148676f, 
    0.02558061f, 0.01096347f, -0.16031009f, 0.04414018f, 0.07177815f, 0.01026404f, -0.20180829f, 0.13660426f, 
    -0.09224535f, -0.05369984f, 0.01737685f, -0.06035869f, -0.07574476f, -0.01982586f, 0.05803866f, -0.11675096f, 
    -0.24472329f, -0.10056502f, -0.10265901f, -0.03911064f, -0.00078537f, -0.08826596f, 0.01647587f, -0.05187274f, 
    0.02841986f, 0.03838113f, -0.03166778f, -0.02861862f, -0.05707615f, 0.03083629f, -0.02858232f, 0.01197796f, 
    -0.05312782f, -0.05703327f, -0.01677682f, -0.01802671f, 0.01096065f, 0.01109329f, 0.00574286f, -0.00477991f, 
    -0.01254099f, -0.04952664f, -0.01165137f, -0.00459497f, -0.00263587f, -0.00704358f, -0.00065895f, -0.04306862f, 
    -0.05663952f, -0.01096513f, -0.04849243f, -0.02811668f, -0.03724784f, -0.02022629f, -0.04023653f, -0.04457612f, 
    0.03651868f, 0.01118047f, 0.04248865f, 0.01342903f, 0.04579915f, -0.00551403f, 0.00901313f, 0.00722705f, 
    0.05243403f, -0.04853578f, -0.03541080f, 0.03138591f, 0.04761908f, -0.06941558f, 0.01175442f, -0.02642045f, 
    -0.02917111f, -0.05587023f, -0.02641641f, -0.00909115f, -0.00585247f, -0.05709380f, -0.01273384f, -0.01868344f, 
    -0.02136500f, 0.04517497f, 0.01884111f, 0.01480107f, -0.02933074f, 0.02516288f, 0.02074235f, 0.04614817f, 
    -0.02433131f, -0.02869219f, 0.02861719f, 0.03717125f, -0.03393501f, -0.03014742f, -0.06145510f, -0.00107716f, 
    -0.02084742f, 0.01212784f, -0.05983415f, 0.03814732f, 0.04820997f, -0.01636347f, 0.00317871f, -0.04215899f, 
    0.00782427f, -0.05806684f, -0.05928622f, 0.04479274f, -0.00183482f, 0.03930168f, -0.05216257f, -0.05488630f, 
    0.00671254f, -0.01110563f, -0.01216553f, 0.04355480f, -0.01599949f, -0.04909816f, -0.01319440f, -0.05808666f, 
    -0.04466660f, 0.04090103f, -0.00001355f, -0.00715649f, 0.00110319f, 0.01493527f, 0.03131298f, -0.00611670f, 
    -0.02183061f, -0.04347898f, 0.04132964f, -0.01579448f, -0.02619585f, -0.02154347f, 0.03378111f, -0.06943487f, 
    0.00388981f, -0.01510767f, -0.05377590f, 0.05151355f, 0.00358266f, 0.04669536f, 0.05271479f, -0.01136241f, 
    0.06132567f, 0.03636223f, 0.01113116f, -0.04285684f, -0.01018984f, -0.00782556f, -0.00772765f, 0.01173841f, 
    -0.00244779f, 0.04234604f, 0.02515939f, -0.01503720f, -0.03656025f, -0.02226292f, -0.03344518f, 0.01532642f, 
    -0.01898261f, 0.01174990f, -0.02606757f, 0.02766879f, -0.00390401f, 0.04408618f, 0.01791409f, 0.04628583f, 
    -0.05215587f, 0.02782448f, 0.02154824f, -0.05451639f, 0.03860426f, -0.02323049f, 0.01113404f, 0.01991763f, 
    0.04527878f, -0.04512541f, 0.00415602f, -0.04592292f, 0.04344488f, 0.01919010f, -0.04571332f, 0.00150691f, 
    0.02874330f, -0.02407249f, -0.01867832f, 0.04133500f, 0.01834898f, 0.00462286f, -0.05490845f, 0.02507523f, 
    0.03683212f, 0.05582203f, -0.03664278f, 0.02063949f, -0.04354081f, -0.03133702f, -0.03178566f, -0.06842113f, 
    0.00827170f, -0.01081467f, -0.03483543f, -0.03709526f, 0.03686232f, 0.00675505f, -0.01835244f, -0.04474273f, 
    0.02316014f, 0.01909366f, -0.05419357f, -0.05929507f, -0.02695593f, -0.04267944f, 0.04481243f, -0.05396165f, 
    0.01859882f, -0.01143348f, -0.01111034f, -0.05815203f, -0.04308537f, 0.03898629f, 0.01000682f, 0.03740567f, 
    -0.00873239f, 0.02202664f, 0.02913802f, 0.03834499f, -0.01333213f, 0.02932267f, -0.02086109f, 0.00003283f, 
    -0.04578761f, -0.04601001f, 0.02570098f, 0.00192593f, -0.01159121f, 0.00347541f, -0.02252290f, -0.04915333f, 
    0.04864790f, 0.00888254f, 0.03850323f, -0.03937501f, -0.02944358f, 0.00551757f, -0.05198941f, -0.03561581f, 
    -0.05543521f, -0.00674929f, 0.01254614f, 0.04051050f, -0.00723145f, -0.03218538f, -0.03440599f, 0.00239108f, 
    -0.06180995f, 0.00211548f, 0.04096171f, 0.02428257f, -0.03249216f, -0.05965082f, -0.04639178f, -0.01603892f, 
    0.01911974f, 0.03906932f, 0.02076561f, -0.04785512f, 0.01931880f, -0.02330631f, -0.04530839f, -0.00588231f, 
    -0.03047516f, -0.05375147f, 0.00635765f, -0.00126430f, 0.05005321f, 0.01915303f, -0.04544948f, 0.04948871f, 
    -0.05424033f, -0.02579887f, -0.00618884f, 0.00743994f, 0.02795638f, -0.03880823f, 0.01548101f, 0.01162026f, 
    -0.03092734f, 0.02596627f, -0.02459610f, 0.00745458f, -0.04239982f, -0.06159895f, -0.00410299f, 0.02629689f, 
    -0.01639507f, -0.02914486f, -0.01820949f, 0.01924835f, -0.05034305f, 0.03258368f, -0.04670949f, 0.00684537f, 
    -0.03060569f, -0.05857745f, -0.05578642f, 0.01320848f, -0.00593297f, -0.04518508f, 0.02755542f, -0.01212737f, 
    0.04572909f, -0.02066847f, 0.00200406f, -0.02556072f, -0.01963922f, -0.01639174f, 0.00664747f, 0.04450030f, 
    -0.06136103f, -0.04226062f, 0.00184673f, -0.01363459f, -0.01989687f, 0.03432704f, 0.02269132f, -0.01446225f, 
    0.00796256f, -0.00633974f, 0.05304391f, 0.02647823f, -0.05351958f, -0.01781535f, -0.03637549f, 0.00408704f, 
    -0.03584452f, 0.00750055f, -0.03154832f, -0.01640617f, -0.01814117f, -0.06097175f, 0.00711908f, -0.03079282f, 
    0.03772578f, -0.02833228f, 0.03527494f, 0.02401223f, 0.05023967f, 0.04856608f, -0.02479079f, 0.00026241f, 
    -0.03631586f, -0.05619391f, -0.03386749f, -0.05085151f, -0.04253376f, 0.02301403f, 0.03695746f, 0.00404700f, 
    0.00114499f, 0.00117946f, -0.04607890f, -0.04392688f, 0.03634151f, -0.02111639f, -0.00873668f, 0.03512588f, 
    -0.04583331f, 0.00739423f, 0.00165833f, -0.03899642f, -0.02637299f, 0.03198522f, -0.02022575f, 0.04599969f, 
    0.00540888f, -0.00125864f, 0.03253596f, 0.02497894f, -0.05884652f, 0.03291647f, 0.04124038f, 0.04544602f, 
    -0.05694856f, -0.02911939f, -0.03894114f, 0.02322441f, -0.00419369f, 0.03863803f, -0.02942618f, 0.04206224f, 
    -0.01828387f, 0.01102104f, -0.04507729f, 0.04038676f, -0.01176936f, -0.00476362f, 0.04762636f, 0.00083907f, 
    0.00599995f, -0.05781166f, 0.00617096f, -0.01465160f, 0.05453724f, 0.03641352f, 0.00020348f, 0.00330052f, 
    0.02765163f, 0.02060539f, -0.04145039f, -0.01434971f, 0.00992903f, 0.04347929f, -0.04201852f, -0.01918492f, 
    -0.05936591f, -0.01181871f, -0.03314085f, -0.03454074f, 0.04663914f, -0.02958282f, -0.01751512f, -0.02814252f, 
    -0.04160888f, 0.01711844f, 0.02055694f, -0.06301679f, 0.04530598f, -0.02645510f, -0.00022918f, -0.03022930f, 
    -0.00480512f, -0.00706650f, 0.01839731f, 0.03885733f, 0.03197451f, 0.03251879f, -0.06740197f, 0.02944013f, 
    -0.02493718f, 0.00040609f, -0.03074563f, -0.02075087f, 0.02216769f, 0.01149198f, -0.05358408f, 0.03947535f, 
    -0.05566767f, -0.04843083f, 0.03124368f, 0.01975318f, -0.02603859f, 0.00960057f, -0.04621473f, -0.03541379f, 
    -0.03225708f, 0.02530758f, 0.00835409f, -0.02680178f, 0.02716859f, 0.03512649f, -0.05293946f, 0.03887774f, 
    0.00930163f, -0.05071729f, 0.01875385f, 0.01308023f, 0.03159276f, -0.03086619f, 0.01907928f, -0.00516423f, 
    -0.03402885f, 0.02940125f, -0.05953771f, -0.01024405f, -0.06315742f, 0.02486292f, 0.04889775f, 0.05613269f, 
    0.01906160f, -0.03270200f, 0.02097499f, 0.00633401f, -0.00294143f, -0.05129255f, -0.05821611f, -0.05227342f, 
    -0.01154373f, -0.05547294f, -0.06280503f, 0.01315289f, 0.01486521f, -0.06399415f, -0.00404813f, -0.02852656f, 
    0.03658585f, -0.01429565f, 0.03226224f, 0.03179606f, 0.01881964f, 0.00196396f, -0.05362128f, 0.01131873f, 
    0.05028564f, -0.05726776f, -0.02591482f, -0.04593707f, -0.05492352f, -0.00692162f, -0.05632591f, 0.01123322f, 
    -0.00750692f, 0.05599863f, 0.00927123f, 0.05393265f, 0.02026239f, -0.00072432f, -0.02343128f, -0.04817784f, 
    0.02512674f, 0.04577809f, 0.04780599f, -0.06270905f, 0.04941490f, 0.00919233f, 0.04748102f, -0.01809369f, 
    -0.04368092f, -0.05411271f, -0.00242190f, -0.05946151f, -0.06054294f, -0.04967994f, -0.00557693f, -0.03493841f, 
    -0.06344926f, -0.04197527f, 0.02434258f, -0.01150495f, 0.01995280f, -0.00337602f, 0.02584204f, -0.06220297f, 
    0.01091335f, -0.02766060f, -0.02854456f, 0.01144428f, -0.04774911f, 0.03691896f, -0.01274376f, -0.04342031f, 
    0.02248506f, 0.03653447f, -0.04345656f, 0.03715094f, -0.05443876f, -0.05196040f, -0.05171074f, -0.00413439f, 
    0.03281579f, -0.00504841f, 0.01457364f, -0.04915497f, 0.02109771f, 0.00279459f, -0.05530885f, 0.01026378f, 
    -0.05605464f, 0.01155261f, -0.03992889f, 0.01237438f, 0.00914821f, -0.06199414f, 0.03407547f, 0.06060807f, 
    0.01288790f, -0.00134950f, -0.05215150f, 0.02719831f, -0.04427589f, 0.03751166f, -0.04398492f, 0.01518680f, 
    -0.04215723f, -0.02307077f, -0.00440879f, 0.02803150f, 0.00002630f, -0.00711120f, 0.00345518f, -0.04686234f, 
    0.04818904f, 0.03966988f, 0.00231225f, 0.03563051f, 0.02116028f, -0.05307453f, 0.01212508f, -0.03620800f, 
    0.16926433f, 0.14854567f, -0.14842357f, 0.05714760f, 0.04543383f, -0.01671795f, -0.13652928f, -0.04662532f, 
    -0.05892725f, 0.26175144f, 0.01034866f, -0.14521557f, 0.04395704f, -0.04686707f, 0.07979859f, 0.09186832f, 
    -0.14505567f, -0.04860010f, -0.17091355f, -0.05624316f, -0.07219370f, 0.03593923f, -0.03173459f, -0.02610338f, 
    0.10233040f, -0.00356559f, 0.10181653f, -0.05854744f, -0.00106344f, -0.00155382f, 0.04671228f, -0.13248490f, 
    0.04003377f, -0.00407692f, 0.03964556f, -0.05168055f, 0.07108689f, -0.27242503f, -0.17909506f, -0.00826746f, 
    0.01804202f, 0.00123056f, 0.09864453f, 0.08276425f, 0.00095817f, 0.02918294f, 0.03369706f, -0.04592618f, 
    -0.14642368f, -0.01979084f, -0.08862395f, 0.00557925f, -0.17056842f, 0.05305183f, -0.11898527f, 0.03993070f, 
    0.15574962f, -0.11400841f, 0.09082631f, -0.06706085f, -0.02232295f, 0.17250898f, 0.02187641f, -0.05787658f, 
    0.42402515f, 0.03879547f, -0.09496988f, 0.02271014f, -0.08525679f, 0.03707683f, 0.03654594f, 0.09203822f, 
    0.09495754f, 0.32013941f, -0.10414195f, 0.10015813f, -0.04837156f, 0.04927274f, 0.07684476f, -0.03652151f, 
    0.02330270f, -0.13298932f, 0.12346020f, -0.05508116f, 0.03239456f, 0.13138986f, -0.06916118f, -0.04485647f, 
    0.07973762f, 0.09120250f, 0.08737864f, -0.31454739f, -0.13387614f, 0.05425583f, -0.16723132f, 0.04976470f, 
    0.11215970f, 0.00523356f, -0.13471715f, 0.21045028f, -0.12901694f, -0.09916063f, -0.05491715f, 0.02300091f, 
    0.04031256f, -0.00755870f, 0.05595696f, -0.02617359f, 0.32707313f, -0.14881170f, 0.02876339f, 0.07648869f, 
    0.00974305f, 0.02828694f, 0.11013276f, -0.07112954f, 0.05518032f, -0.22480774f, 0.18393326f, 0.08362438f, 
    0.11003125f, 0.16627516f, -0.04039988f, -0.08197962f, 0.05981604f, 0.05314738f, 0.09247364f, 0.15836817f, 
    -0.01254122f, 0.09121083f, -0.01478095f, -0.10539487f, -0.05119523f, 0.02047401f, 0.00780094f, -0.07403059f, 
    0.06315526f, 0.03735257f, -0.07405923f, 0.08068762f, -0.09951853f, -0.12142063f, 0.14253470f, 0.05018222f, 
    0.08393146f, -0.09305259f, -0.14690699f, 0.01792062f, 0.03249598f, 0.11466226f, 0.10704876f, -0.09294594f, 
    -0.05765539f, 0.00218644f, -0.09792406f, -0.30629858f, -0.01576097f, 0.03235323f, -0.01624801f, 0.01677650f, 
    -0.03150548f, -0.07887685f, 0.07500832f, -0.02473573f, -0.11962998f, -0.10176697f, -0.06404290f, 0.07664733f, 
    -0.04211424f, 0.10877260f, 0.10099039f, 0.24328807f, -0.19207989f, 0.15427090f, 0.15277183f, -0.06594783f, 
    0.05856317f, 0.07114495f, -0.04794719f, 0.24566579f, 0.15198168f, -0.20763442f, 0.16943155f, -0.04902324f, 
    -0.01713014f, -0.14153308f, 0.06330518f, -0.11610185f, 0.08894119f, 0.10671057f, -0.02529370f, 0.23326313f, 
    0.06890721f, -0.04971552f, 0.00373729f, 0.01379826f, -0.02188951f, 0.02689632f, -0.26204643f, -0.08028702f, 
    -0.01940750f, -0.11031660f, -0.14264153f, 0.04669531f, 0.04378984f, -0.04012013f, 0.07477605f, 0.05523295f, 
    -0.03183578f, -0.27876058f, -0.13378742f, -0.10105614f, -0.16125256f, -0.01383001f, 0.00592148f, 0.06308821f, 
    -0.11392330f, -0.02984772f, -0.06736627f, -0.07332120f, -0.00824004f, 0.14959235f, 0.11368333f, -0.04522954f, 
    -0.03386820f, 0.17927767f, -0.27792078f, 0.11937162f, 0.13844241f, -0.01289721f, 0.13180923f, -0.05129344f, 
    -0.09211452f, 0.07177267f, -0.13189338f, -0.06151745f, 0.07374105f, 0.17229284f, 0.05117930f, -0.01539540f, 
    -0.07825015f, 0.11791702f, -0.05724476f, -0.12746502f, 0.14156598f, -0.09855796f, -0.00875982f, 0.01219208f, 
    -0.03564939f, 0.12432913f, 0.02232709f, -0.02969454f, -0.12175240f, -0.12009398f, -0.10927129f, 0.02925270f, 
    0.08663999f, -0.00005620f, -0.15468697f, 0.05834915f, 0.02850496f, -0.07863909f, 0.14942002f, 0.12420453f, 
    -0.02254707f, 0.25738347f, 0.00105598f, 0.06821067f, 0.08822949f, -0.03930048f, -0.06191745f, -0.01152146f, 
    -0.14544384f, 0.01577025f, -0.09223120f, -0.05785335f, 0.02119528f, -0.07088984f, -0.06129352f, -0.00339070f, 
    0.08570364f, -0.18092975f, 0.03223585f, -0.10241728f, 0.16518326f, -0.04867588f, -0.04066191f, 0.00134216f, 
    -0.04494087f, -0.12143501f, -0.13196406f, 0.09531306f, -0.10327952f, 0.09381458f, 0.13302787f, -0.07383915f, 
    -0.16852194f, 0.01446749f, -0.15289408f, -0.06197703f, -0.07842661f, 0.07441610f, 0.09314447f, -0.09871385f, 
    0.00352345f, -0.18197383f, 0.10921273f, 0.07048649f, 0.18759254f, 0.24075621f, -0.04820026f, 0.00520970f, 
    -0.02206292f, -0.01351364f, 0.18352248f, -0.23431085f, -0.12611379f, 0.00510975f, 0.22135006f, -0.05677697f, 
    -0.05760504f, -0.04676792f, 0.06861346f, -0.05440237f, -0.28175315f, -0.18082334f, -0.12126033f, 0.12964141f, 
    0.05518799f, 0.10399424f, 0.03982130f, -0.00803821f, 0.14175622f, 0.04966940f, -0.19556026f, 0.05999951f, 
    -0.06055354f, -0.00067831f, 0.15024932f, 0.01944846f, -0.00685009f, 0.08954133f, 0.12847438f, 0.18139689f, 
    0.07023773f, -0.03028913f, 0.03692341f, 0.03493069f, 0.03130204f, -0.03939313f, -0.02051250f, 0.05005570f, 
    0.07857578f, 0.00440600f, 0.25586745f, -0.06042906f, 0.08194255f, 0.03021052f, 0.09447926f, -0.14843722f, 
    0.18128918f, -0.07834072f, -0.14151652f, 0.06612135f, 0.00429941f, 0.09577349f, 0.05051072f, 0.01913621f, 
    0.07425954f, -0.12245594f, -0.11442765f, -0.13886319f, -0.00554439f, 0.01324007f, -0.01899994f, 0.04232147f, 
    -0.02674912f, 0.00926459f, -0.25347129f, -0.02043846f, -0.06841965f, 0.14455158f, -0.00481177f, -0.16001421f, 
    0.16974989f, 0.06404237f, 0.15583983f, 0.16561487f, -0.13671024f, -0.01219587f, -0.03998019f, -0.05773243f, 
    0.13620733f, 0.11026581f, 0.08253960f, 0.04810309f, -0.16612044f, -0.04856747f, -0.02625710f, 0.08583315f, 
    0.05743362f, 0.00580090f, 0.02286937f, 0.07237451f, 0.07679591f, 0.25805685f, 0.12296861f, 0.06660575f, 
    0.00456619f, -0.00107616f, 0.03399459f, 0.02952725f, -0.14109243f, 0.04838254f, -0.10303318f, 0.00954306f, 
    -0.05293518f, 0.09668036f, -0.15757230f, -0.07745231f, -0.12956087f, -0.00423163f, 0.14055476f, 0.01182518f, 
    0.11863456f, -0.00508366f, -0.04300225f, 0.03777319f, -0.02421479f, -0.02240255f, -0.18291137f, -0.13614732f, 
    -0.17066815f, -0.01344419f, -0.00436533f, 0.06205426f, 0.02784578f, -0.00269731f, -0.06927212f, 0.01878153f, 
    -0.18325107f, 0.00528802f, -0.25387517f, 0.06733781f, -0.05341597f, 0.02999742f, 0.09899224f, 0.02856096f, 
    0.04370860f, -0.06720237f, -0.07180959f, 0.08988403f, -0.00972490f, 0.04133574f, -0.00767018f, -0.10831409f, 
    0.01503148f, 0.14280346f, -0.00844549f, -0.24467690f, -0.10166690f, -0.11185454f, 0.18819815f, 0.09660224f, 
    0.08166587f, -0.09905273f, -0.03897988f, -0.04745936f, -0.07048044f, -0.10929980f, -0.09889174f, 0.09371785f, 
    0.07007061f, 0.04191032f, 0.00341728f, -0.04189282f, 0.02271542f, -0.07144844f, -0.06199402f, -0.03614864f, 
    -0.03171266f, 0.16388199f, -0.17763658f, 0.08807934f, 0.03709738f, 0.09592593f, 0.06602313f, 0.16537884f, 
    -0.07513873f, -0.00341702f, -0.03910239f, -0.02511062f, 0.01503120f, 0.02542108f, -0.07283278f, -0.06788304f, 
    -0.01493861f, -0.17388840f, 0.09034915f, -0.03247930f, -0.00219544f, -0.01340047f, 0.00242713f, 0.07436280f, 
    0.02288549f, 0.16438809f, 0.03154793f, -0.11758689f, 0.01186196f, -0.04487414f, 0.01102457f, 0.12852708f, 
    0.02957121f, 0.05507265f, 0.08028661f, 0.00805950f, 0.11898284f, -0.04876941f, 0.02440629f, 0.07320689f, 
    0.09740093f, 0.03149293f, -0.09578387f, 0.21576667f, 0.13132291f, -0.00474699f, -0.02468285f, -0.07969343f, 
    0.03488237f, 0.08357985f, 0.01841187f, 0.09675895f, 0.05782802f, 0.15769228f, -0.21423663f, -0.08700758f, 
    -0.03177975f, 0.18947113f, 0.01783486f, 0.04796820f, -0.22948129f, -0.10899567f, -0.26543278f, 0.10245579f, 
    -0.00371474f, 0.02768780f, -0.06222562f, -0.01784860f, 0.03654478f, 0.06824221f, 0.34752890f, 0.06356257f, 
    -0.01597058f, -0.05332705f, -0.16285391f, 0.02149606f, -0.04294977f, 0.00628032f, -0.22166386f, -0.02306980f, 
    -0.06917129f, -0.03395579f, 0.02104771f, 0.01623244f, 0.05251174f, 0.09729939f, -0.07074261f, -0.18836766f, 
    -0.10488503f, -0.05307611f, 0.05874658f, -0.05239409f, -0.00449098f, 0.03886339f, -0.09883586f, -0.16020410f, 
    -0.03821562f, 0.04924960f, -0.00940447f, 0.03046555f, 0.03434431f, -0.06337827f, -0.04960040f, 0.04432837f, 
    0.00142559f, -0.02589724f, -0.05009197f, -0.02109184f, 0.01137183f, 0.04177139f, 0.01007206f, -0.02642616f, 
    -0.00063613f, -0.00433525f, 0.03239727f, -0.02124145f, -0.02924129f, -0.01135047f, -0.02637375f, 0.02740519f, 
    -0.03640174f, -0.01393221f, -0.05457661f, -0.05056821f, -0.05105498f, 0.04383699f, 0.04282401f, -0.04841778f, 
    -0.05852231f, 0.02579646f, 0.01473948f, -0.04964926f, -0.04515218f, 0.00793670f, 0.04728548f, 0.01800630f, 
    0.00757626f, -0.02175370f, 0.01643878f, 0.05365082f, 0.02393902f, -0.05932479f, 0.00883252f, -0.00300357f, 
    -0.03637350f, 0.05361931f, -0.02181842f, -0.00900679f, -0.06160754f, 0.00282822f, -0.01742577f, -0.00352219f, 
    -0.05855953f, -0.01363339f, 0.04712857f, -0.03626966f, -0.02685016f, -0.05746886f, 0.01583388f, -0.00849438f, 
    -0.06527121f, -0.05058467f, -0.05264427f, 0.05030941f, -0.02019858f, 0.01022732f, -0.00247011f, 0.04576013f, 
    0.01252526f, -0.06364302f, 0.00938909f, -0.04650109f, 0.01606466f, -0.05473733f, -0.00255289f, -0.05238838f, 
    0.04067017f, -0.02734355f, -0.04366507f, -0.06164023f, 0.04362230f, -0.02818530f, -0.00055691f, -0.01578166f, 
    0.03790045f, -0.03908291f, -0.05538702f, -0.00672093f, -0.06605390f, 0.03004431f, -0.04896532f, 0.00123532f, 
    0.00295290f, -0.04556928f, 0.05328621f, 0.01339640f, 0.02442661f, 0.02767755f, -0.05358558f, 0.00911442f, 
    -0.03069308f, -0.05565326f, 0.03430185f, -0.05596141f, -0.02864454f, 0.01222007f, 0.01917152f, 0.02351014f, 
    0.00009205f, -0.01605012f, 0.03392756f, -0.05564292f, -0.01596398f, -0.00761038f, -0.05544098f, -0.04113971f, 
    0.01771382f, 0.03454553f, 0.02550102f, -0.03415309f, -0.04941202f, -0.02081279f, -0.00699180f, -0.00600046f, 
    0.01759281f, -0.00863849f, -0.06670070f, -0.03953883f, 0.01197072f, 0.04662064f, -0.01995789f, -0.04892538f, 
    -0.06360912f, -0.00740828f, 0.04194569f, 0.02895606f, -0.01818427f, 0.04565830f, -0.03951462f, -0.01707227f, 
    -0.01793243f, -0.05639836f, 0.05036963f, -0.01632647f, -0.03091785f, 0.01648822f, 0.02629773f, 0.01116848f, 
    0.01593663f, 0.03820860f, 0.03675648f, -0.02176916f, -0.03036989f, 0.03278839f, -0.06303570f, -0.01220083f, 
    -0.00160644f, 0.03776848f, 0.00896353f, -0.01658918f, -0.05767186f, -0.04105367f, 0.04175137f, -0.00074733f, 
    -0.02628628f, -0.05185897f, -0.06579594f, -0.01898163f, -0.01445349f, -0.03786796f, -0.00148132f, -0.01024140f, 
    -0.06240547f, -0.05320314f, 0.00681763f, -0.02174685f, 0.01572318f, -0.01603450f, -0.03749596f, -0.01119749f, 
    0.01778323f, -0.03319464f, -0.05954270f, 0.01156599f, 0.03830622f, -0.04549323f, -0.00297519f, -0.00990302f, 
    -0.01397863f, -0.04126659f, 0.01526574f, -0.06240922f, 0.01199082f, -0.00256038f, 0.00227029f, 0.00253383f, 
    0.03436171f, -0.02355228f, -0.05655109f, -0.03030710f, -0.06057855f, 0.02675364f, -0.05473003f, 0.02895195f, 
    0.01228019f, -0.05114784f, -0.06010401f, 0.02170542f, -0.02657210f, -0.01928785f, -0.01307873f, 0.01916141f, 
    -0.02991554f, 0.03607876f, 0.03031440f, 0.01465052f, 0.02957136f, -0.01760657f, 0.04614606f, -0.01961136f, 
    -0.03050925f, 0.00639333f, -0.00220095f, 0.03312395f, -0.00499162f, 0.02808760f, -0.03724096f, -0.05970906f, 
    -0.03964306f, 0.01760901f, 0.02364446f, -0.05743647f, -0.02774415f, -0.03337722f, 0.01952305f, -0.04692490f, 
    -0.01175728f, 0.03057253f, 0.02967220f, -0.01838598f, 0.02200318f, -0.04299732f, 0.01753058f, 0.02286289f, 
    -0.01548615f, -0.01620928f, 0.01114332f, -0.01961116f, -0.05375593f, 0.00949096f, 0.01199432f, -0.04437118f, 
    0.02396957f, 0.04228007f, 0.04331508f, 0.00192706f, 0.04659269f, 0.01857987f, -0.05613863f, -0.02241220f, 
    -0.01146242f, -0.05795119f, -0.03287674f, -0.04379082f, -0.00530120f, 0.04091581f, -0.04095616f, -0.03227071f, 
    0.00056205f, -0.02150120f, 0.00451162f, -0.02607435f, -0.03245233f, -0.03937826f, -0.06052457f, -0.01332411f, 
    -0.02863814f, 0.04033945f, 0.01057234f, -0.01052206f, -0.02857031f, -0.03805653f, 0.00341618f, -0.05313162f, 
    0.02968647f, 0.01147662f, 0.13022779f, -0.02048300f, -0.10712290f, 0.07098377f, -0.08316223f, 0.01171635f, 
    -0.00481753f, 0.06679351f, 0.10850938f, 0.12734719f, -0.02472675f, -0.07978970f, -0.13235231f, 0.05152727f, 
    -0.02812740f, 0.08079863f, -0.15255274f, 0.19812736f, -0.04764762f, -0.05996237f, -0.05064834f, -0.01124111f, 
    0.10375751f, -0.03827651f, 0.03602476f, -0.00225157f, 0.04475537f, -0.04455641f, -0.25086120f, -0.08055414f, 
    -0.04302713f, 0.08198076f, 0.01817097f, -0.01994653f, 0.02370832f, -0.08418336f, -0.17372453f, -0.02930055f, 
    -0.07613073f, 0.14867635f, 0.09984253f, 0.04593327f, -0.20003121f, 0.08412281f, 0.12469343f, 0.07186719f, 
    0.09393758f, 0.16081934f, -0.07378304f, 0.01343712f, 0.02492149f, 0.02366963f, -0.25686100f, -0.08090911f, 
    0.09689812f, 0.18440726f, 0.27431077f, 0.07583145f, -0.16647893f, 0.12743680f, -0.00317159f, 0.05588701f, 
    0.08770771f, -0.09712167f, 0.06079050f, -0.01311974f, -0.07791308f, 0.09481772f, 0.05951966f, -0.01788782f, 
    -0.01090946f, -0.06197507f, 0.05725230f, 0.11944901f, 0.06018610f, -0.00926731f, 0.17834607f, 0.01943085f, 
    -0.05623321f, -0.20141637f, -0.13924922f, 0.04143848f, 0.09498262f, -0.07080691f, 0.00684737f, -0.03820397f, 
    0.09401132f, 0.01287319f, -0.21664551f, -0.23224778f, -0.23578848f, -0.08161137f, -0.09006022f, 0.02205956f, 
    -0.02583110f, 0.02750549f, -0.18791252f, -0.11072009f, 0.18540210f, 0.09379957f, -0.01229044f, 0.04388918f, 
    -0.08162863f, -0.03016517f, -0.16178103f, -0.21049066f, -0.06243721f, 0.10703817f, -0.18417230f, 0.14067385f, 
    0.05588646f, 0.01265546f, -0.00556211f, 0.05858578f, 0.08842375f, -0.28118557f, 0.08162183f, 0.00585722f, 
    0.17829578f, -0.00910430f, -0.01105754f, 0.01092287f, 0.06579079f, 0.09159145f, 0.06487274f, 0.17041238f, 
    -0.22037137f, 0.09025355f, 0.12359045f, 0.07719541f, 0.03549112f, 0.02637937f, -0.05366796f, -0.13689864f, 
    -0.05337030f, 0.08272491f, 0.00852728f, 0.11615374f, 0.02229663f, -0.09449481f, 0.02446521f, 0.14004332f, 
    0.16554838f, -0.01766620f, 0.04288833f, 0.02242872f, -0.10122959f, -0.19037214f, 0.14975622f, 0.14971882f, 
    0.11133176f, 0.11871781f, 0.06851694f, -0.11424761f, 0.04679763f, -0.07182778f, 0.14756103f, 0.10057675f, 
    -0.06150768f, -0.04943437f, -0.24181300f, -0.09841458f, -0.01786932f, 0.03321514f, -0.04659211f, 0.10176345f, 
    -0.09761745f, 0.01137704f, -0.00966054f, 0.00564037f, 0.17820007f, 0.07402485f, 0.07592545f, 0.00256785f, 
    0.11805514f, 0.04841251f, -0.08322770f, 0.08285797f, 0.07169409f, 0.05724014f, -0.03316930f, -0.00435576f, 
    0.03479651f, 0.08519497f, 0.02107573f, -0.06021791f, 0.05382383f, 0.08169958f, 0.06549048f, 0.01124805f, 
    -0.17522526f, -0.03017707f, 0.02997824f, 0.03715280f, 0.15584773f, 0.08527829f, 0.08006328f, 0.00603992f, 
    -0.16663295f, -0.00541281f, 0.06263188f, 0.05536238f, -0.17949864f, -0.01326918f, -0.00613024f, -0.01677042f, 
    0.03902249f, 0.11583034f, -0.01587821f, 0.02517403f, -0.06294813f, 0.01994897f, -0.04188418f, 0.11790993f, 
    -0.25667262f, -0.10734744f, -0.04072480f, 0.05023043f, 0.06960496f, 0.10685204f, -0.01342745f, -0.11277094f, 
    0.04134227f, 0.03946171f, 0.14702465f, 0.10501679f, -0.21869957f, -0.05138607f, -0.10387642f, -0.03468024f, 
    0.15406664f, 0.00964732f, -0.19621038f, -0.01879270f, -0.22678122f, 0.11932955f, 0.02656704f, 0.12114634f, 
    -0.10673609f, -0.07706104f, -0.04097417f, -0.01051444f, -0.16967122f, 0.01313735f, 0.19194534f, 0.00145782f, 
    0.00061945f, -0.01243768f, -0.06345154f, -0.08206584f, -0.00396690f, -0.12925375f, -0.06908082f, -0.26211834f, 
    -0.13839847f, -0.02980129f, 0.14268374f, 0.04067534f, 0.11393142f, -0.20441541f, 0.02638948f, -0.02566874f, 
    0.06777465f, 0.13809468f, -0.11938331f, 0.00659183f, -0.03911775f, -0.01085114f, 0.08294155f, -0.09132714f, 
    -0.14193048f, 0.00948211f, 0.03843807f, 0.02440992f, 0.06539049f, 0.04362529f, -0.08694176f, 0.19379809f, 
    -0.03974696f, 0.00889016f, 0.00173251f, -0.05650813f, 0.11660789f, -0.01641640f, 0.13562344f, -0.03499909f, 
    0.01017025f, -0.03218336f, -0.16287862f, -0.06060069f, 0.03668822f, -0.08945420f, -0.12098490f, -0.00028754f, 
    -0.01446424f, 0.24601504f, 0.01843643f, 0.21041933f, 0.08725936f, 0.06110505f, 0.01759467f, 0.10302706f, 
    -0.00075495f, -0.10882791f, -0.19515680f, 0.18266562f, 0.14197570f, 0.04083819f, 0.00781964f, 0.11616748f, 
    0.08168343f, 0.06137585f, -0.03027241f, -0.31337091f, 0.04892358f, -0.20101176f, 0.07120813f, -0.02906214f, 
    0.08120199f, 0.05784844f, 0.05465464f, -0.03621820f, 0.24105364f, 0.28138390f, 0.04714536f, 0.10161214f, 
    0.03742840f, 0.00119672f, 0.06955650f, -0.01959952f, -0.06614818f, 0.13764937f, 0.02810429f, 0.11036021f, 
    -0.07652896f, -0.08498795f, -0.03792731f, -0.11522967f, -0.01056989f, 0.05522766f, 0.11451747f, 0.02936645f, 
    -0.02018628f, -0.08039115f, -0.12164032f, 0.08038609f, -0.04620565f, -0.07914203f, 0.03773048f, -0.07200809f, 
    -0.02204835f, -0.14896092f, -0.23829490f, 0.06694113f, 0.07351498f, -0.03999558f, -0.02699121f, 0.10613118f, 
    0.26659384f, -0.14087631f, -0.07833550f, -0.10342581f, 0.03266917f, -0.00636439f, 0.08710862f, -0.01248436f, 
    -0.03546156f, -0.05087998f, -0.03119076f, -0.15753281f, -0.20791727f, -0.05952374f, -0.04495145f, -0.09413416f, 
    -0.01335709f, -0.00503397f, -0.24166290f, -0.08824206f, -0.05382504f, 0.02813048f, -0.00637187f, 0.16662276f, 
    0.11981124f, 0.05004071f, 0.15172753f, 0.09722476f, 0.02783793f, 0.04092287f, 0.09727984f, -0.10416067f, 
    -0.13050205f, 0.03231847f, 0.04886253f, 0.05921179f, 0.09323433f, -0.12935400f, -0.13300006f, 0.08338913f, 
    0.12692839f, -0.00123707f, 0.03453227f, 0.05869740f, 0.01445522f, 0.02822694f, -0.00516981f, 0.11421259f, 
    -0.19054289f, -0.02492237f, 0.02147128f, -0.06563665f, 0.02211600f, -0.05917270f, -0.10851675f, 0.05576337f, 
    0.07389728f, 0.04790845f, -0.01649212f, 0.14512119f, -0.01050578f, -0.06372506f, -0.10544463f, 0.01168234f, 
    0.07992709f, -0.19673790f, -0.14763188f, -0.14782318f, 0.02983926f, -0.04242204f, -0.13459669f, -0.03681979f, 
    0.46079612f, 0.28621873f, -0.00168538f, 0.13255645f, 0.09687795f, -0.00235864f, 0.08815549f, 0.00516143f, 
    0.06496286f, 0.03989496f, 0.06521046f, -0.02050412f, 0.03291642f, 0.07362659f, 0.02655490f, 0.14718583f, 
    0.03703595f, -0.01247257f, -0.26124546f, -0.05062098f, -0.13833417f, 0.05530125f, 0.15553111f, 0.03720992f, 
    0.01661761f, 0.10209348f, -0.01915492f, 0.34754151f, -0.09402014f, 0.03640206f, 0.14163250f, 0.10846561f, 
    -0.02706679f, -0.11056412f, -0.01180271f, -0.07534172f, 0.02669522f, -0.08688366f, -0.06105416f, 0.08928780f, 
    -0.01789675f, 0.07789064f, 0.07752643f, -0.01077147f, -0.03027002f, 0.18224350f, 0.06378496f, -0.10371635f, 
    0.12343888f, 0.05947123f, 0.05331546f, -0.02926509f, 0.06421119f, -0.02183574f, -0.13999894f, -0.06601041f, 
    -0.17487225f, 0.03369344f, 0.04583838f, 0.10082433f, -0.04080161f, -0.07779129f, -0.13784353f, -0.20989424f, 
    0.04338494f, 0.20064779f, -0.14274198f, 0.05327002f, -0.19468477f, 0.01008843f, 0.01246124f, -0.09831370f, 
    -0.24400766f, -0.08142594f, -0.05246080f, -0.01216289f, 0.08799780f, 0.06831107f, 0.01219863f, 0.08498151f, 
    0.01742505f, 0.16508199f, 0.15781263f, -0.00569630f, 0.15156917f, 0.03933607f, 0.07547611f, 0.01920374f, 
    -0.03318690f, 0.06913143f, 0.10088352f, -0.04118387f, 0.07063745f, -0.09037668f, -0.04830346f, 0.09322044f, 
    0.00931374f, -0.11535151f, -0.07219756f, 0.10750175f, 0.00048678f, 0.10725050f, -0.02023895f, -0.01415333f, 
    0.05745894f, -0.04891731f, 0.07389270f, 0.06261091f, -0.01467900f, -0.08924051f, 0.04041434f, -0.02754694f, 
    -0.00177711f, 0.07799637f, -0.06339172f, 0.00752920f, -0.01269614f, 0.01237670f, 0.01954404f, 0.04705051f, 
    -0.23152423f, -0.10070230f, -0.06237955f, -0.05417765f, -0.10098165f, 0.08338753f, -0.02945238f, 0.13201937f, 
    -0.01680161f, 0.05327460f, 0.06323562f, 0.10059133f, 0.03584108f, -0.06916479f, -0.01113006f, 0.01152459f, 
    -0.01132420f, -0.00078342f, -0.03452040f, 0.12309300f, 0.17410111f, 0.13810484f, 0.11672466f, 0.00603867f, 
    -0.05244706f, 0.01927717f, -0.05964360f, -0.00452228f, -0.02620218f, -0.06451733f, -0.00285096f, -0.00587985f, 
    -0.06713415f, -0.05554139f, 0.01184860f, 0.03011919f, -0.05340537f, 0.01876420f, -0.02456394f, -0.06377244f, 
    -0.02560281f, -0.02979524f, -0.00154172f, 0.04346967f, 0.00050859f, 0.04178993f, -0.03057265f, 0.03334198f, 
    0.04436392f, 0.03129033f, -0.03779775f, -0.00915154f, 0.00668307f, 0.01691788f, -0.06447710f, -0.00020985f, 
    0.00543318f, 0.04444124f, -0.01612583f, 0.04234749f, 0.02645631f, -0.00866897f, 0.03937366f, -0.02245318f, 
    0.01823612f, -0.02798241f, 0.04882379f, -0.01213465f, 0.03628762f, 0.02312271f, -0.00770193f, -0.02974643f, 
    0.05461502f, -0.05337287f, 0.03274014f, -0.05801705f, 0.03204148f, -0.00327554f, 0.02169781f, -0.00800867f, 
    -0.01712838f, 0.05061446f, -0.02185173f, -0.05097136f, 0.04655082f, 0.02687225f, -0.04930216f, 0.02263249f, 
    0.02391151f, 0.00001930f, -0.03285745f, 0.01523740f, -0.04439300f, 0.02112095f, -0.06954917f, -0.02202743f, 
    -0.00240955f, -0.04420806f, 0.00655766f, 0.02141762f, 0.00168853f, 0.04665529f, -0.05986521f, 0.03566657f, 
    0.02673398f, 0.02824151f, 0.01922104f, -0.03947183f, 0.01980177f, 0.00378066f, -0.01641880f, 0.03661175f, 
    0.03394593f, 0.02954715f, -0.02352059f, -0.05133116f, -0.03485284f, -0.04201458f, 0.04159256f, 0.01939136f, 
    0.02882983f, -0.06007859f, 0.00118801f, -0.04965070f, -0.02204885f, 0.03814612f, -0.06524849f, 0.03939259f, 
    -0.02315678f, -0.05752720f, -0.03012630f, -0.01055618f, -0.04629464f, 0.00099989f, -0.05183984f, -0.05274078f, 
    -0.02914878f, 0.04274732f, 0.00757163f, -0.04733718f, 0.04316927f, -0.01317480f, 0.00068599f, -0.04281912f, 
    0.01106184f, 0.05603853f, 0.04684344f, -0.05816536f, 0.04818422f, 0.05439137f, -0.03900903f, 0.04502379f, 
    0.00049068f, -0.06017327f, -0.03091182f, -0.02075637f, 0.01475178f, -0.04396266f, -0.01284362f, -0.00427064f, 
    0.03646595f, -0.02921506f, 0.03752089f, -0.03552280f, -0.01552720f, -0.05676430f, -0.04915853f, 0.00599206f, 
    -0.04872667f, -0.05664166f, -0.00212231f, 0.03696496f, -0.03635940f, -0.00670719f, -0.00975309f, -0.00260084f, 
    0.04722163f, 0.00401322f, 0.00162115f, 0.04905037f, -0.01303373f, 0.02811714f, 0.00465986f, 0.02990597f, 
    -0.05626911f, -0.00461808f, 0.00924734f, -0.03156613f, 0.04154420f, 0.02549951f, 0.03044084f, -0.01100405f, 
    -0.06421135f, -0.00236568f, -0.01598234f, 0.03902114f, -0.04368474f, 0.04767166f, 0.03276647f, -0.05589117f, 
    -0.00987416f, -0.05729546f, -0.05737994f, -0.04321371f, -0.03160866f, -0.00989684f, 0.02924750f, 0.02814880f, 
    -0.06004073f, -0.05675500f, -0.06080085f, -0.01591147f, 0.01085264f, -0.00673201f, -0.04746624f, 0.00492924f, 
    -0.06385499f, 0.03374163f, -0.03772840f, -0.00658452f, 0.01721777f, 0.01542507f, -0.06513038f, 0.02762347f, 
    0.03159279f, 0.03749845f, -0.04368503f, 0.01537705f, 0.03053103f, 0.04792921f, -0.01825007f, 0.00030143f, 
    0.04597061f, -0.07090583f, 0.01958344f, -0.04386636f, 0.02974505f, 0.01033612f, 0.03919831f, -0.03546671f, 
    0.00426292f, -0.01987513f, 0.01376145f, 0.04409630f, -0.04509571f, 0.01327710f, 0.04338340f, 0.02837422f, 
    -0.00836904f, -0.05849348f, -0.03415580f, 0.00027506f, 0.01080402f, 0.03783150f, -0.02528558f, -0.01497095f, 
    -0.05689929f, -0.05692550f, -0.04668956f, -0.06284058f, -0.06019292f, -0.06209765f, 0.00370889f, 0.04089497f, 
    -0.04390454f, 0.03133174f, 0.02397211f, -0.03816097f, 0.03222600f, -0.03764943f, -0.03392972f, -0.02613230f, 
    0.00386428f, 0.03398225f, 0.00731764f, 0.04500739f, 0.01917107f, -0.05578998f, 0.04807931f, 0.01961595f, 
    0.04319579f, 0.02296203f, -0.06522279f, 0.00749969f, -0.03849160f, 0.04506355f, -0.02256037f, 0.02903711f, 
    0.02125532f, -0.04131783f, 0.04232718f, -0.04377440f, 0.01410019f, -0.05287313f, -0.04214417f, -0.03853663f, 
    -0.01620129f, -0.02191604f, 0.00323877f, -0.03652322f, -0.05542567f, -0.01175837f, 0.01110690f, 0.02514958f, 
    0.00983165f, 0.00427602f, 0.03787942f, -0.02615185f, 0.00958780f, -0.02440222f, 0.01744622f, 0.04769450f, 
    -0.00416039f, -0.16985950f, -0.20765276f, 0.03905546f, 0.10733387f, 0.07436408f, -0.00184479f, 0.03823251f, 
    -0.00466476f, 0.16950662f, -0.29746756f, 0.03123669f, 0.09468347f, 0.02066226f, 0.11070738f, -0.03704458f, 
    0.02046301f, -0.04781151f, 0.14299560f, 0.11244228f, 0.19216375f, -0.01786092f, 0.01085687f, -0.05720854f, 
    -0.03419169f, 0.06579193f, 0.02533129f, 0.13397226f, 0.08671409f, -0.00844388f, -0.05358998f, 0.10366957f, 
    0.04685370f, -0.13578647f, 0.01910916f, 0.02786769f, 0.02191387f, 0.06290328f, -0.18381837f, -0.05221903f, 
    0.00334661f, 0.27738574f, -0.01573895f, 0.04912706f, 0.05728925f, -0.28100890f, -0.15890291f, 0.10891294f, 
    0.06290561f, -0.02013561f, -0.06140667f, 0.00966814f, -0.03845127f, 0.02331980f, -0.32168067f, -0.27337250f, 
    -0.13170032f, -0.22175929f, 0.04985765f, -0.22886792f, -0.11254190f, -0.04381725f, -0.00137309f, -0.26508844f, 
    0.03771410f, -0.14233215f, -0.11365487f, 0.10606548f, 0.01485295f, 0.08832888f, 0.05269186f, -0.01488345f, 
    -0.15636227f, 0.09640910f, -0.20695002f, 0.03762626f, 0.07014947f, 0.04183734f, 0.02513411f, 0.02487409f, 
    -0.10257995f, -0.21602149f, -0.46860602f, -0.18970199f, 0.07257011f, 0.08699456f, -0.12952878f, 0.13305970f, 
    -0.03032266f, -0.06670009f, 0.26719257f, 0.18982053f, 0.16028102f, -0.00695294f, 0.12567917f, 0.09512465f, 
    0.06039986f, -0.04861820f, 0.13550739f, -0.00757095f, -0.00935555f, 0.18956372f, 0.06669068f, 0.04143703f, 
    -0.01583201f, 0.03471657f, -0.12378480f, -0.00862378f, 0.21375485f, 0.03429676f, 0.14311753f, -0.05374901f, 
    0.05591576f, -0.04375460f, 0.01765164f, -0.05551263f, 0.01769548f, -0.13546990f, -0.24041490f, -0.21795096f, 
    -0.02051769f, 0.02592293f, 0.06556046f, -0.02370264f, 0.02074556f, -0.08477104f, 0.01823066f, 0.06414503f, 
    0.15954842f, -0.11596201f, 0.08804104f, -0.01047933f, -0.02577863f, 0.03444857f, 0.02091528f, -0.18118767f, 
    -0.21188718f, -0.09197574f, -0.04293270f, -0.01244258f, -0.21989077f, 0.05941305f, -0.15178964f, -0.05445686f, 
    0.15081473f, -0.07602007f, -0.09659319f, 0.02800114f, 0.00931957f, -0.06673175f, 0.07288691f, -0.01817080f, 
    -0.11953752f, -0.16727839f, -0.01314078f, 0.05374500f, -0.01328904f, -0.01137700f, 0.05424542f, 0.08972154f, 
    -0.06640157f, 0.00287723f, -0.27538419f, 0.17701679f, -0.02668798f, 0.14371780f, -0.03437223f, -0.07437548f, 
    0.13254312f, 0.00372507f, -0.02047839f, 0.12183430f, 0.12785451f, 0.13967524f, 0.08965358f, 0.17795244f, 
    0.03175423f, -0.10367414f, 0.01664553f, 0.05846821f, -0.00419282f, -0.06403870f, 0.05457995f, 0.01520687f, 
    -0.03539797f, 0.13155271f, 0.03638694f, 0.02006625f, 0.01327787f, 0.19255422f, 0.17256644f, 0.03727304f, 
    0.11832146f, -0.01331598f, 0.03700886f, 0.00987692f, 0.12009772f, 0.10675434f, 0.06359036f, -0.11634518f, 
    0.03742833f, 0.12536383f, 0.08696452f, -0.01406467f, 0.07286292f, 0.07084219f, -0.01683470f, -0.07753759f, 
    -0.07620820f, 0.30722895f, 0.01266514f, -0.03722691f, 0.03455569f, 0.04908121f, -0.10640933f, 0.08818010f, 
    -0.11067796f, -0.05916652f, 0.00786791f, 0.05706833f, -0.08932348f, -0.00903222f, 0.02452521f, -0.01600743f, 
    -0.01533254f, 0.37387964f, 0.25311795f, 0.02124404f, 0.01093286f, -0.00456613f, 0.01416536f, -0.03122495f, 
    -0.04604421f, -0.05334716f, 0.23492378f, 0.00667704f, -0.08228769f, -0.12881376f, -0.09356148f, 0.05757514f, 
    0.06611993f, 0.01621957f, 0.06641740f, 0.03460258f, -0.05038562f, -0.11012629f, -0.05291493f, 0.00191533f, 
    -0.09996114f, 0.06746682f, -0.03927488f, -0.03384864f, 0.01841999f, -0.04459979f, -0.14924178f, -0.04131889f, 
    0.07417743f, 0.16817553f, -0.13265544f, 0.03417505f, -0.07519596f, -0.11095759f, -0.26763675f, -0.17342299f, 
    -0.08814217f, 0.03931820f, -0.07397000f, 0.06221886f, -0.01190650f, -0.02736191f, 0.14260401f, -0.04261855f, 
    0.13616383f, -0.02576654f, -0.01076693f, 0.07351310f, 0.09604806f, -0.04612582f, 0.13013244f, -0.32588956f, 
    -0.16800095f, -0.26133442f, -0.00330578f, -0.13456848f, -0.01177542f, 0.05169271f, -0.10264310f, -0.00834202f, 
    0.01800624f, -0.04744351f, -0.05428398f, 0.05798660f, -0.03068195f, 0.02507705f, 0.03437040f, -0.02748403f, 
    0.02152076f, 0.02032186f, -0.05272323f, -0.05683076f, 0.03085377f, -0.02334900f, 0.04304230f, -0.01335784f, 
    -0.03972817f, 0.04450623f, -0.00414376f, -0.00212853f, -0.02807423f, -0.05021132f, -0.00567320f, 0.03723177f, 
    0.00874276f, -0.05632141f, -0.03974994f, -0.02310931f, 0.03072059f, -0.04109085f, 0.01798694f, -0.03850189f, 
    -0.03550497f, -0.05671796f, 0.02729517f, -0.01563425f, 0.03089134f, -0.00712068f, 0.01984271f, 0.06499685f, 
    0.04606145f, -0.02549818f, 0.04873829f, -0.04928222f, -0.03019249f, 0.02706143f, 0.02706897f, -0.00981495f, 
    -0.06203958f, -0.00068652f, -0.00773430f, -0.03053511f, -0.01702432f, -0.02083864f, -0.01966707f, 0.04579524f, 
    -0.06669632f, 0.02422469f, -0.01845047f, -0.02782096f, 0.01751446f, 0.02643038f, 0.02838975f, 0.02930852f, 
    0.02888665f, -0.06016449f, -0.00988563f, -0.05516763f, -0.02111716f, 0.02265862f, 0.00323782f, 0.03496537f, 
    -0.01663302f, 0.03542287f, -0.00410358f, 0.03071542f, 0.02567948f, 0.04802320f, -0.02917638f, 0.03143709f, 
    -0.03483899f, -0.02372083f, 0.03884171f, -0.03836052f, 0.05161595f, 0.03579657f, -0.03006463f, -0.00102694f, 
    0.00636002f, -0.04528979f, -0.01986408f, -0.02639642f, 0.00190054f, -0.05373740f, -0.06536485f, -0.00525114f, 
    -0.03531357f, -0.01997787f, -0.00208036f, 0.05989911f, -0.01681721f, 0.00418608f, -0.00570162f, -0.03954840f, 
    -0.06706318f, 0.05490061f, -0.03902515f, -0.07037927f, 0.00182445f, 0.01703314f, -0.01390491f, 0.03321254f, 
    -0.00632829f, -0.03931762f, -0.02494038f, -0.04627421f, -0.02057179f, 0.05180219f, -0.04059748f, -0.06469937f, 
    -0.08155797f, 0.00147698f, -0.03338801f, -0.01481241f, -0.04792275f, -0.05541741f, -0.04161589f, -0.00992159f, 
    -0.05114726f, -0.02767343f, -0.03508811f, -0.04636748f, -0.03225103f, 0.02453313f, -0.00747452f, -0.06013452f, 
    -0.05208313f, -0.01063053f, -0.05403999f, -0.00142493f, 0.02189264f, 0.02952714f, 0.02202258f, 0.00943273f, 
    -0.02546007f, -0.00592268f, 0.03447056f, 0.02245574f, 0.05245528f, -0.02662125f, -0.04185811f, -0.01489399f, 
    0.01984349f, 0.02591679f, 0.00575025f, -0.01635473f, -0.04084461f, 0.01729442f, 0.00687041f, 0.02975519f, 
    -0.05498842f, -0.04550369f, -0.05433113f, 0.00432655f, -0.04112409f, -0.05017095f, 0.01434771f, -0.00702025f, 
    -0.06588638f, -0.01567609f, -0.04863823f, -0.06475705f, -0.00079007f, -0.03751087f, 0.07084656f, 0.04944988f, 
    0.01740051f, 0.04630362f, -0.06210952f, 0.02575780f, -0.01715669f, 0.02825874f, -0.03549440f, 0.01430978f, 
    0.05232655f, -0.00710068f, 0.01520424f, -0.01382557f, -0.04809953f, 0.04346696f, -0.03046411f, 0.01767498f, 
    -0.00702844f, 0.04800583f, -0.06439357f, -0.03646378f, -0.03547603f, -0.01393094f, 0.00891259f, -0.00115308f, 
    -0.04096689f, 0.05673574f, -0.03621467f, -0.03767805f, -0.05008605f, 0.01904187f, -0.06255572f, -0.04170752f, 
    -0.00487392f, 0.04308316f, -0.01081282f, -0.01230557f, -0.04524036f, -0.02490983f, -0.00024803f, -0.05899087f, 
    -0.01355176f, -0.01345510f, -0.03462625f, -0.02961368f, -0.01095425f, -0.01716404f, -0.00428582f, 0.03474775f, 
    0.00104630f, -0.05415583f, -0.04751368f, -0.05943205f, 0.03608161f, -0.05884404f, -0.07578214f, 0.00507840f, 
    -0.05047857f, 0.00388472f, -0.00866256f, -0.01960965f, -0.00544649f, -0.04818039f, 0.02747685f, -0.01696227f, 
    0.01811043f, -0.05489593f, -0.00252518f, -0.02536494f, -0.06162833f, -0.06043737f, 0.04058325f, -0.05010156f, 
    0.00036223f, -0.06856468f, 0.00180284f, -0.06429572f, -0.04668795f, -0.00430633f, 0.00173764f, 0.04514884f, 
    -0.01708174f, -0.01787377f, 0.00351573f, -0.00762938f, 0.03918215f, -0.04302047f, -0.04576290f, 0.02524284f, 
    0.03277181f, -0.06991360f, -0.01775980f, 0.00568649f, 0.04379144f, 0.02997831f, -0.02906036f, 0.01571104f, 
    0.02631865f, 0.01934367f, -0.03211303f, -0.05446335f, 0.01024596f, -0.02758498f, -0.03519373f, 0.04468979f, 
    0.01436810f, 0.00661275f, 0.01845932f, 0.02144730f, -0.01343107f, 0.00225472f, 0.04025264f, 0.00828920f, 
    -0.02730860f, 0.00117095f, -0.03356718f, 0.02391554f, 0.02237647f, -0.03203515f, 0.02954567f, 0.01058664f, 
    0.02332750f, 0.03917524f, -0.02544354f, 0.01750211f, -0.04142687f, 0.05083323f, -0.04627763f, -0.05675057f, 
    -0.04360406f, 0.02417683f, -0.01033485f, -0.01739812f, 0.04740075f, -0.02769584f, 0.02745760f, -0.02677021f, 
    -0.02054989f, 0.01903246f, -0.01608652f, -0.03385898f, -0.06148993f, -0.02570017f, -0.02735059f, -0.07195057f, 
    -0.03872010f, 0.04172642f, 0.01465768f, 0.00521574f, -0.02479270f, 0.05380554f, -0.02682977f, -0.06896569f, 
    0.04408132f, -0.06417778f, -0.03074772f, -0.01443333f, -0.02679562f, 0.04682694f, -0.00177965f, 0.01203768f, 
    0.01773188f, -0.04670636f, -0.02466358f, -0.02688947f, 0.01702539f, -0.01373180f, -0.03465995f, 0.02451849f, 
    0.03347944f, 0.02402415f, -0.05386526f, -0.05140653f, -0.00799032f, -0.06328809f, -0.03918921f, 0.01145475f, 
    -0.00341831f, -0.08864360f, 0.02851396f, 0.00509992f, -0.01849176f, -0.02052102f, 0.00835116f, -0.01269922f, 
    -0.07831225f, -0.01574061f, 0.01806721f, 0.00723585f, 0.02009600f, -0.05285311f, 0.02879415f, -0.08609715f, 
    -0.06311843f, -0.07468902f, 0.00676171f, 0.02645351f, 0.04835135f, -0.07677919f, -0.07366482f, -0.06779517f, 
    -0.05046796f, -0.04997836f, -0.01454356f, -0.00668100f, 0.04764068f, -0.03425209f, 0.01372717f, 0.03970102f, 
    -0.02103773f, -0.01352879f, 0.01571598f, -0.05482619f, 0.02879028f, -0.07604693f, -0.01185030f, 0.05263286f, 
    0.01619436f, -0.04171735f, -0.01607868f, -0.05607074f, -0.01506746f, -0.02293938f, -0.01166084f, -0.06062434f, 
    0.02182293f, 0.02143844f, -0.01748680f, 0.05045252f, -0.00565548f, -0.01542230f, -0.00894431f, -0.04214296f, 
    0.05138794f, -0.00570530f, -0.05614026f, -0.04783893f, 0.03306609f, -0.03757479f, -0.05219100f, -0.01910281f, 
    0.01318731f, -0.01502546f, -0.07026199f, 0.01684858f, 0.00336550f, 0.00052614f, -0.01288739f, 0.02928554f, 
    0.02240433f, -0.00273458f, -0.01336790f, -0.02354972f, -0.01854013f, 0.01870595f, -0.02751373f, 0.04822956f, 
    0.00730249f, -0.01668016f, -0.03953446f, -0.03103750f, 0.01792184f, 0.02001930f, -0.02200546f, -0.04155987f, 
    -0.06730413f, -0.06877036f, -0.01352752f, -0.00206950f, -0.05256483f, 0.01633615f, 0.00941287f, 0.00957137f, 
    -0.03948774f, 0.01394476f, 0.02812042f, 0.00098967f, 0.05960762f, -0.00573633f, -0.05288278f, 0.04680971f, 
    0.03554680f, -0.03643452f, 0.04662077f, -0.02460025f, 0.04432757f, 0.06548788f, -0.07083691f, -0.04477586f, 
    -0.01100937f, -0.03276655f, 0.01328795f, 0.04506317f, -0.03836636f, 0.00254169f, 0.01118412f, 0.01977785f, 
    -0.02117621f, 0.02587306f, -0.06805085f, 0.03403250f, 0.01790949f, -0.00235624f, 0.02446705f, 0.02662981f, 
    0.04117815f, -0.03651788f, -0.05499611f, 0.02940355f, -0.05228234f, -0.01510132f, 0.02900783f, 0.01943658f, 
    -0.04912317f, -0.02717552f, -0.04382360f, 0.01650659f, -0.04257608f, 0.02213077f, 0.03054659f, 0.03668880f, 
    0.02167301f, 0.03104230f, 0.00421616f, -0.05051917f, -0.01491774f, -0.04330521f, 0.00525843f, -0.00634272f, 
    0.03204716f, 0.04278257f, 0.03458286f, -0.07498635f, -0.02406910f, 0.02181801f, -0.05309422f, -0.00910949f, 
    -0.02065768f, -0.00306849f, 0.01446827f, 0.04473055f, -0.00951744f, 0.03894642f, 0.05085019f, -0.00711305f, 
    -0.03392193f, 0.00150132f, -0.03595395f, -0.00900693f, -0.00073818f, 0.00322554f, -0.06073366f, -0.02014713f, 
    -0.06804895f, -0.01949130f, -0.07286812f, -0.03416859f, 0.03021316f, -0.03929307f, -0.03631842f, 0.01300236f, 
    -0.00060149f, -0.01401304f, -0.03691272f, 0.00149690f, -0.04304797f, 0.03954851f, -0.05172927f, 0.03986780f, 
    0.01937425f, 0.02582729f, 0.04543208f, 0.02091816f, -0.04359462f, -0.01500045f, 0.04080872f, -0.04999951f, 
    -0.03970333f, -0.04591595f, -0.00421485f, -0.05417353f, -0.07358430f, 0.01644426f, -0.01076282f, 0.03388730f, 
    -0.04213162f, 0.02707856f, -0.06572676f, -0.03855176f, 0.02655940f, -0.01274810f, -0.02883223f, -0.05641877f, 
    0.00185154f, 0.03420563f, 0.03239823f, -0.01370805f, -0.06785541f, 0.03381561f, -0.02712360f, -0.05907613f, 
    0.04943226f, -0.04689625f, 0.02488704f, -0.03591805f, -0.03832769f, 0.00863979f, -0.06334773f, 0.01928248f, 
    0.02688413f, 0.00677116f, 0.02214041f, 0.03228363f, 0.04535212f, 0.03721374f, -0.03876504f, -0.03765114f, 
    0.04496653f, -0.03264145f, -0.04557228f, -0.04146234f, -0.00355066f, 0.00378693f, -0.03651759f, 0.00322352f, 
    0.00460222f, -0.02122639f, -0.04472698f, 0.03903436f, -0.02936440f, -0.03217553f, -0.02446716f, -0.04614743f, 
    -0.03746549f, -0.04432216f, 0.02471874f, -0.03199448f, -0.05555430f, 0.04357842f, -0.01609720f, -0.04376619f, 
    0.04348643f, 0.00041507f, -0.04579968f, 0.02906869f, -0.01226980f, -0.03643984f, -0.01258129f, -0.06286035f, 
    -0.05776148f, -0.02571093f, -0.02078072f, -0.02563174f, 0.03731441f, -0.00200071f, -0.00515334f, -0.01724237f, 
    -0.00392140f, 0.00737456f, 0.04170468f, 0.04219690f, 0.03283847f, 0.03452810f, 0.01973402f, -0.05764322f, 
    -0.05273531f, -0.03010994f, 0.02571094f, 0.00883986f, -0.04487274f, 0.01859070f, 0.02489892f, -0.00946715f, 
    0.01759498f, -0.01811500f, 0.04952278f, -0.06088718f, 0.01434291f, -0.03537429f, 0.00900196f, 0.03268773f, 
    0.02832533f, 0.00021411f, -0.05104138f, 0.02000650f, 0.00432523f, -0.04733481f, 0.02183078f, -0.01990815f, 
    0.01336139f, -0.02092726f, 0.04511229f, 0.01913870f, -0.04967570f, 0.03073175f, 0.02304409f, 0.01171703f, 
    -0.04637226f, -0.00779521f, -0.00858279f, -0.00514951f, 0.01584243f, -0.00782259f, -0.04374850f, 0.03341526f, 
    0.02832950f, 0.01792675f, 0.00271132f, -0.00802250f, 0.03155658f, 0.04350331f, 0.02707583f, 0.04711546f, 
    -0.01045037f, 0.02723399f, 0.02132355f, -0.00051137f, -0.00436101f, -0.05228842f, -0.02704763f, 0.02091409f, 
    -0.05324370f, 0.03444123f, -0.03118820f, -0.06380391f, -0.00905594f, 0.03188336f, -0.04092941f, 0.04622573f, 
    -0.04389809f, 0.02114142f, -0.01127036f, 0.01746950f, 0.01474890f, -0.05116162f, 0.04171548f, 0.02182089f, 
    0.03055298f, 0.02321643f, 0.01854545f, -0.00195393f, -0.00790741f, 0.02463535f, -0.01689842f, -0.00600129f, 
    -0.05245936f, -0.04491088f, 0.03519198f, -0.02641760f, -0.01642682f, -0.01502091f, 0.00494808f, 0.00199313f, 
    -0.00717170f, -0.00051937f, -0.01790427f, -0.06206229f, 0.02688405f, -0.05695422f, 0.04239014f, -0.03873629f, 
    -0.01080777f, 0.02214055f, -0.00213932f, -0.03659588f, -0.03679466f, -0.06466294f, -0.03072776f, 0.01327035f, 
    0.02879584f, 0.01879577f, 0.03093365f, -0.02843656f, -0.04548281f, -0.03960545f, -0.04047998f, 0.00886349f, 
    0.02168066f, 0.02045171f, -0.01878181f, -0.03348508f, -0.00799387f, -0.02000177f, 0.01545547f, -0.05908885f, 
    -0.03785503f, -0.03519295f, -0.03648295f, -0.02013961f, -0.03435918f, -0.06441284f, 0.02587472f, 0.01494666f, 
    0.05218653f, -0.05941910f, -0.04462008f, 0.01692962f, 0.03123458f, -0.05963739f, -0.00192979f, 0.02404322f, 
    -0.04896825f, -0.03820956f, 0.03647495f, -0.04726188f, 0.00229129f, -0.03596312f, 0.04461919f, 0.00861384f, 
    0.02889747f, -0.01540810f, 0.02149330f, 0.04646574f, 0.04264576f, -0.06239331f, 0.00626927f, 0.04774862f, 
    -0.04410532f, 0.04944628f, -0.00422266f, -0.05341101f, -0.06208256f, 0.03743054f, -0.02063227f, -0.00409568f, 
    -0.00455029f, 0.01984324f, 0.04751072f, -0.04849273f, 0.00654647f, -0.06510273f, 0.04184750f, -0.03754351f, 
    -0.03347473f, -0.05457599f, -0.04050123f, -0.00250679f, 0.04053697f, -0.03499974f, 0.01900486f, -0.02624808f, 
    -0.02076335f, -0.04251966f, -0.01860719f, -0.00855411f, -0.06599076f, -0.01719677f, 0.01847831f, -0.03219173f, 
    0.03738124f, 0.00261246f, -0.05869826f, 0.00397369f, 0.04353784f, -0.05382527f, -0.02998842f, 0.02776384f, 
    0.04807578f, -0.06236782f, -0.02984679f, 0.00140435f, 0.01814638f, -0.01727521f, 0.03995837f, -0.04055798f, 
    0.00458707f, -0.05719525f, 0.04822081f, -0.03805878f, 0.03002943f, 0.01196195f, 0.01741346f, 0.03748246f, 
    -0.05283968f, 0.05189518f, 0.03966175f, -0.05953279f, -0.02844820f, -0.00366540f, 0.04837774f, -0.05765932f, 
    -0.00334983f, -0.06328136f, -0.04292574f, 0.03107445f, -0.06130857f, -0.02870439f, 0.01786290f, -0.00390301f, 
    0.03907232f, 0.06306516f, 0.10051353f, -0.02215092f, 0.02776782f, 0.09026268f, -0.18850411f, 0.09294007f, 
    0.10019845f, -0.02872268f, 0.27165222f, -0.15901223f, 0.01108906f, -0.03881036f, -0.02770516f, 0.03823083f, 
    0.03929681f, 0.09648403f, -0.14103681f, -0.01391144f, -0.17107935f, 0.02654847f, 0.11831158f, -0.04197705f, 
    0.02530750f, -0.07147847f, -0.07426279f, 0.10678264f, -0.04944026f, -0.06482472f, 0.13765214f, -0.04397631f, 
    0.02406638f, -0.14447036f, -0.07165870f, -0.05243404f, 0.16390590f, -0.03748794f, -0.06004780f, -0.00491046f, 
    -0.03954954f, -0.02891300f, 0.10939363f, -0.00088703f, -0.17156371f, 0.02417495f, 0.11739226f, 0.16599317f, 
    0.01216439f, -0.09731083f, 0.05958531f, 0.10602424f, -0.09013767f, 0.15255636f, -0.05045395f, -0.00942440f, 
    0.08215678f, 0.12983568f, 0.01866445f, 0.07158078f, 0.00950551f, 0.05857001f, -0.03480947f, 0.07600375f, 
    -0.17976855f, 0.15160444f, -0.01202824f, -0.01073062f, -0.03678614f, -0.16580351f, 0.08508329f, 0.05732005f, 
    0.19608711f, -0.18045056f, 0.05983035f, 0.02551096f, -0.13696127f, -0.12370027f, 0.00173904f, -0.05346007f, 
    -0.00071418f, 0.01217361f, 0.03399228f, 0.09807201f, 0.16269739f, -0.16704263f, 0.16062599f, -0.03346459f, 
    -0.07114878f, -0.07319292f, 0.01621881f, -0.04781472f, -0.19660433f, -0.10459003f, 0.03619841f, 0.01108607f, 
    -0.12027153f, -0.00957995f, -0.15974921f, -0.08906804f, 0.12941422f, -0.01241491f, 0.00363119f, 0.03142761f, 
    -0.26676992f, -0.06939112f, 0.10820400f, -0.04534615f, -0.05240483f, -0.11110550f, -0.05351979f, -0.03825938f, 
    0.05283843f, -0.07770456f, -0.01884122f, 0.01965498f, -0.36630046f, -0.10160562f, -0.05406027f, 0.14989607f, 
    0.07979833f, 0.03249342f, -0.01252864f, -0.05404050f, 0.07826425f, -0.01766832f, 0.08938274f, 0.01329243f, 
    -0.19675034f, -0.03711019f, 0.09553212f, 0.07675651f, 0.02369598f, -0.03858064f, -0.11805908f, -0.05015102f, 
    0.22478957f, 0.06615674f, -0.07483058f, -0.01041683f, 0.11634287f, -0.00108464f, -0.07252221f, 0.05988601f, 
    -0.19496213f, 0.14113790f, -0.11679406f, 0.05952722f, 0.00129147f, -0.04043566f, 0.11348277f, 0.03466519f, 
    0.05517144f, 0.23515095f, 0.12243459f, -0.04877967f, -0.02300328f, 0.01007406f, -0.01172374f, -0.04555395f, 
    0.07756435f, 0.07285000f, -0.03458761f, 0.04634464f, -0.13489506f, 0.05308615f, 0.07756230f, 0.03549364f, 
    0.00081481f, 0.15025271f, -0.18198466f, 0.17971358f, 0.22440320f, -0.12199922f, -0.17907569f, 0.04319544f, 
    0.15329541f, 0.02533557f, -0.01707056f, -0.19321217f, 0.06205494f, 0.04006907f, 0.01125776f, -0.09439091f, 
    -0.03966943f, 0.11970533f, 0.06753919f, -0.03254168f, -0.14938566f, -0.02856682f, -0.03144023f, -0.15673697f, 
    0.04554931f, -0.03914873f, -0.11744286f, -0.10201715f, 0.06038045f, -0.10616535f, -0.12287372f, 0.24912576f, 
    -0.02236446f, 0.06720713f, 0.13105316f, -0.10558027f, 0.08425490f, -0.02325054f, -0.05011571f, -0.03383248f, 
    0.23504840f, -0.01928284f, -0.01939822f, 0.10900479f, 0.01414375f, -0.13262863f, -0.04790038f, 0.05086695f, 
    0.04868542f, -0.04537386f, -0.16697396f, -0.09329503f, 0.08026621f, 0.07976145f, 0.10158742f, 0.12588534f, 
    0.09468760f, -0.19838224f, 0.15107287f, -0.12760164f, -0.03702275f, -0.06658936f, -0.14407007f, 0.02787615f, 
    0.12030794f, 0.02287606f, -0.02738483f, -0.00675458f, -0.12756060f, -0.18114002f, 0.00960803f, -0.04111068f, 
    0.02563325f, 0.03315571f, -0.11095199f, 0.00201115f, -0.03634467f, -0.06992527f, 0.08982411f, -0.00898730f, 
    0.02591787f, -0.00263181f, 0.00087966f, -0.10309932f, 0.13199809f, -0.01510781f, 0.12223427f, 0.02477602f, 
    -0.02306764f, -0.14506705f, -0.03387254f, 0.10139430f, 0.02775826f, 0.04571715f, -0.12935242f, 0.15912195f, 
    0.00983918f, 0.01754434f, -0.08347251f, -0.00548985f, -0.01882156f, 0.03919674f, 0.09501719f, -0.03316740f, 
    -0.08443420f, 0.02907136f, 0.07793953f, 0.12324997f, 0.01437291f, -0.01552741f, 0.06181056f, 0.19814916f, 
    0.17512809f, 0.15815891f, -0.06718740f, 0.01817594f, 0.00291173f, 0.04933193f, 0.19661456f, 0.06167982f, 
    0.03674696f, 0.17831747f, 0.11744844f, 0.00850387f, 0.06700335f, -0.00308904f, -0.11516021f, 0.01426544f, 
    -0.15359646f, -0.20773195f, 0.26116261f, 0.12607974f, -0.16273052f, -0.25421619f, -0.13881117f, -0.13403931f, 
    0.06774735f, -0.15177202f, 0.02995628f, 0.10064042f, -0.34204537f, 0.04016241f, -0.10689615f, -0.03602778f, 
    -0.00098083f, -0.00751428f, 0.02250875f, 0.10655808f, -0.08083903f, 0.16372752f, -0.09558743f, -0.02014393f, 
    -0.03455492f, -0.05427542f, -0.11332002f, 0.13007686f, 0.08290065f, -0.15660135f, -0.19715174f, -0.15685040f, 
    -0.13156521f, -0.02106193f, 0.01143138f, 0.16043922f, -0.08865796f, 0.06461500f, 0.10709575f, -0.04516809f, 
    0.00571226f, -0.06956399f, 0.05439952f, 0.08918168f, 0.00620517f, -0.05496021f, 0.05910582f, 0.17560317f, 
    0.08357996f, 0.04457853f, 0.05984861f, -0.00989211f, -0.02461432f, -0.01486871f, 0.10526166f, 0.11367985f, 
    0.08769848f, 0.18188044f, 0.20948307f, 0.01042253f, 0.00087557f, 0.09940905f, -0.03616448f, 0.02304178f, 
    0.21006499f, 0.14538510f, 0.08225910f, -0.04164703f, 0.04253905f, 0.03785997f, 0.00746351f, 0.04374692f, 
    -0.05129332f, 0.26571435f, 0.45313323f, 0.20985609f, 0.09911849f, 0.04951020f, 0.02402364f, -0.05849158f, 
    0.08667365f, 0.10943226f, 0.09949193f, -0.11468127f, -0.26824048f, -0.10956144f, 0.00249757f, 0.04191683f, 
    -0.09483841f, -0.07831593f, 0.07212040f, -0.11714828f, 0.16153732f, 0.03679509f, -0.03671035f, 0.00953243f, 
    -0.20979273f, -0.13091817f, 0.00117946f, -0.15256938f, 0.08401223f, 0.07819537f, -0.10464327f, 0.04704303f, 
    0.00222017f, -0.01340168f, 0.01443437f, -0.13801366f, -0.03412733f, 0.17257689f, 0.01795859f, 0.06216845f, 
    0.11768256f, 0.11461065f, 0.00478941f, 0.03401133f, 0.00357285f, 0.09137166f, 0.07528808f, -0.00813819f, 
    -0.08624965f, -0.15897930f, 0.04911416f, 0.05101417f, -0.05607008f, -0.02242263f, 0.01984850f, 0.18732229f, 
    0.30594561f, 0.18905203f, 0.11122226f, 0.08296297f, -0.04572781f, 0.00730073f, 0.03321660f, -0.03219937f, 
    -0.14437044f, -0.15880857f, 0.00276046f, -0.20102784f, -0.10886512f, -0.01072602f, -0.08183039f, 0.02790451f, 
    -0.15420976f, 0.12166560f, 0.15055037f, -0.08255006f, -0.10601603f, -0.00867828f, -0.10586721f, -0.17115763f, 
    -0.02608705f, -0.07824795f, -0.20774017f, 0.08072550f, 0.03699344f, 0.06837907f, -0.01447069f, -0.04032519f, 
    0.05004510f, 0.06603726f, -0.09482036f, 0.36988309f, 0.11276700f, -0.06363892f, -0.08225457f, 0.00651720f, 
    -0.01097314f, 0.06852267f, -0.05277115f, -0.00913594f, 0.06872855f, -0.00842595f, 0.03452181f, -0.09958234f, 
    0.06590253f, -0.03797244f, -0.02697385f, 0.03902725f, -0.05336923f, -0.05889016f, -0.17615488f, 0.09655538f, 
    -0.13792652f, -0.02363985f, 0.05514900f, -0.03055972f, -0.01327600f, 0.08169348f, -0.06691922f, -0.17230779f, 
    -0.09003432f, -0.09540197f, 0.14888465f, -0.01017041f, -0.05460433f, -0.11692430f, 0.07231383f, 0.03818551f, 
    -0.01708020f, -0.00327789f, -0.05617837f, -0.04071454f, -0.06128380f, -0.02708958f, 0.00104257f, -0.00699583f, 
    0.12139616f, -0.20325877f, -0.11358517f, 0.02655669f, -0.07328951f, 0.06890653f, 0.10359387f, -0.08218680f, 
    -0.12662946f, -0.02487430f, -0.11558704f, 0.04021519f, 0.01866809f, -0.05674724f, -0.00762545f, -0.06788939f, 
    0.03657908f, -0.03663583f, -0.09034765f, -0.03504524f, -0.18002833f, -0.04268051f, -0.04247127f, -0.05663035f, 
    -0.01884368f, 0.02065342f, 0.08737656f, 0.00921235f, 0.16943321f, -0.08666976f, -0.02836474f, -0.05542943f, 
    0.02205677f, 0.10572760f, -0.02294531f, 0.04032888f, 0.15627734f, 0.11302889f, 0.06967937f, 0.03583380f, 
    -0.04637792f, 0.01753300f, 0.01081736f, -0.02445260f, 0.08640037f, 0.05811215f, 0.04614378f, 0.04632782f, 
    0.06670954f, 0.06344277f, 0.13326599f, 0.11525526f, -0.04340461f, 0.04268127f, 0.04383441f, -0.07144654f, 
    -0.08028834f, -0.10575694f, 0.01492573f, 0.01062407f, -0.14056250f, -0.13105634f, 0.02167204f, 0.18656757f, 
    0.04552170f, -0.18627198f, -0.01858661f, -0.07068792f, -0.07213488f, -0.10468097f, -0.02575315f, -0.01291793f, 
    0.15444569f, -0.10261767f, -0.24824648f, 0.02282488f, 0.13093913f, 0.18874513f, 0.01866036f, 0.01443844f, 
    -0.17742981f, -0.02659965f, 0.00922780f, -0.00071310f, 0.10306355f, -0.01979752f, -0.04005257f, 0.08828666f, 
    0.01761440f, 0.09158652f, 0.21892464f, 0.09936121f, 0.11805696f, -0.00326724f, -0.08489824f, -0.11670130f, 
    0.02068095f, 0.05355165f, 0.07165780f, -0.05233942f, 0.13285485f, 0.06740268f, 0.06962226f, -0.08758417f, 
    0.09224515f, 0.01508421f, -0.02834996f, 0.20048597f, 0.05216440f, 0.00251634f, -0.01908001f, 0.04139625f, 
    -0.08379634f, 0.03875472f, -0.07600021f, 0.06279384f, 0.21575969f, -0.21648602f, 0.11983659f, 0.00138417f, 
    -0.13048658f, 0.12656738f, -0.08777479f, 0.06207218f, 0.03460192f, 0.05331249f, -0.22831404f, -0.02299010f, 
    0.01365098f, 0.00082170f, 0.06790377f, -0.08812716f, -0.01224487f, 0.04028231f, 0.00315870f, -0.08589584f, 
    0.25406897f, -0.09538687f, -0.09045985f, -0.07410271f, -0.00445419f, 0.05942933f, 0.11993808f, -0.03022183f, 
    -0.19324188f, 0.17179954f, -0.09020870f, -0.05725240f, 0.05264035f, -0.02088263f, -0.04506197f, -0.04029752f, 
    0.01341410f, -0.33062819f, -0.14805344f, -0.00155298f, 0.09048020f, 0.03582635f, -0.08237603f, -0.04171684f, 
    -0.06621403f, -0.00496900f, -0.24964270f, 0.35844573f, 0.07895941f, 0.12324680f, 0.06068255f, 0.09574201f, 
    0.06642392f, -0.01227609f, 0.13804337f, 0.14843255f, -0.18042390f, 0.23573826f, 0.07512496f, -0.02934055f, 
    -0.08600947f, 0.07952679f, 0.03458229f, -0.00127980f, 0.15237510f, -0.02740815f, 0.10886750f, 0.05071762f, 
    0.00137726f, 0.09979330f, 0.14029610f, 0.02290055f, 0.04580809f, -0.04153750f, 0.01794425f, -0.28339112f, 
    0.02460705f, 0.12141711f, 0.10412950f, 0.01929731f, -0.01422889f, -0.02652756f, 0.16776833f, -0.00899436f, 
    0.11377164f, 0.08955128f, 0.10691416f, -0.04327019f, 0.06962625f, 0.08201873f, 0.00606490f, -0.22478655f, 
    -0.16382469f, -0.09963864f, -0.03509476f, 0.04417563f, -0.20877467f, -0.14497863f, 0.04620877f, -0.09705424f, 
    0.24881767f, -0.06224787f, -0.11848734f, 0.03661394f, -0.02596220f, -0.03696466f, 0.10854857f, -0.05466641f, 
    0.06760492f, -0.07788804f, -0.12324517f, 0.00565369f, 0.09510187f, -0.04644643f, -0.07794174f, 0.09232170f, 
    0.11384322f, -0.01032303f, -0.27847314f, -0.27684009f, -0.14293164f, -0.00924909f, -0.03666877f, 0.03668944f, 
    -0.05982318f, 0.18200271f, 0.14943157f, 0.06637424f, -0.05040535f, 0.05986936f, -0.01419947f, -0.01824034f, 
    0.03678080f, -0.03014010f, -0.12706478f, 0.09855987f, 0.14205524f, 0.04590701f, 0.07052056f, -0.10869927f, 
    0.09263644f, 0.07597899f, -0.01190596f, 0.07402120f, 0.05163558f, 0.19926873f, 0.03322754f, -0.02440486f, 
    -0.09749986f, -0.04917312f, 0.16913903f, 0.23528288f, -0.04246803f, 0.09492398f, -0.01471414f, 0.04616831f, 
    0.00544032f, 0.05600083f, 0.12605242f, 0.03462679f, 0.04309389f, -0.07686640f, 0.13853054f, 0.05012049f, 
    0.06816846f, 0.33739984f, 0.15725145f, -0.09244735f, 0.05026584f, -0.01635034f, 0.02693390f, 0.23855391f, 
    -0.26454768f, -0.01756615f, 0.03037986f, 0.02794555f, 0.09402844f, 0.00187087f, 0.05798832f, 0.02435700f, 
    0.04130860f, 0.35330626f, 0.19176808f, -0.01886409f, 0.00449684f, 0.02754804f, 0.06496441f, -0.03109635f, 
    -0.06942468f, -0.00930130f, -0.14272302f, -0.06742667f, -0.03829806f, -0.00958011f, 0.11967241f, -0.00115043f, 
    -0.04502501f, 0.16803040f, 0.12327549f, -0.29202455f, -0.16784002f, 0.10210833f, 0.05753843f, 0.05048124f, 
    -0.04161017f, -0.09108578f, -0.00219993f, 0.01580560f, -0.12582932f, -0.02027856f, 0.20651786f, 0.03977364f, 
    0.01153887f, -0.04307372f, 0.09272857f, 0.05366956f, 0.04389658f, -0.20142904f, 0.14400515f, -0.14436372f, 
    -0.05917810f, -0.02872190f, 0.02150919f, 0.10036022f, 0.02442551f, -0.11561749f, -0.03542111f, 0.03389300f, 
    0.06073985f, 0.04485798f, 0.01817906f, 0.05680234f, 0.03117061f, 0.16538113f, 0.02271158f, -0.22255675f, 
    -0.15776114f, -0.02919020f, 0.15376261f, 0.04579523f, -0.19899543f, -0.10036528f, 0.02924869f, 0.15589033f, 
    -0.00088488f, 0.00583025f, -0.04642553f, -0.02911307f, -0.04036009f, 0.03417914f, 0.01444220f, -0.01516846f, 
    -0.03102828f, 0.00419483f, -0.02844346f, 0.03742015f, 0.02288488f, -0.05970155f, -0.06795033f, 0.05582060f, 
    0.03624657f, 0.02751874f, 0.00464384f, -0.01749634f, 0.01525804f, -0.05369006f, -0.01337886f, -0.04834208f, 
    0.04645555f, -0.06905647f, -0.03454842f, -0.00976864f, -0.06183155f, -0.04245723f, 0.02185678f, -0.04589765f, 
    -0.04881988f, -0.01000084f, 0.01196121f, -0.05105997f, -0.04735352f, -0.00041703f, 0.01717653f, -0.06181626f, 
    0.00853645f, -0.03499541f, -0.01949451f, -0.05836937f, 0.05755941f, 0.03222346f, -0.03164385f, 0.02085505f, 
    -0.05909407f, -0.00246855f, -0.05955597f, -0.03689814f, -0.05360051f, -0.03737566f, -0.06186629f, 0.00270552f, 
    0.02024140f, 0.00518505f, 0.04305356f, 0.01074443f, 0.01171728f, 0.03705150f, 0.01372769f, 0.03759022f, 
    -0.01132918f, -0.01599634f, -0.00399422f, -0.04662786f, 0.03968391f, -0.04608018f, 0.04743286f, 0.02352846f, 
    0.01927807f, -0.01663041f, -0.01919443f, 0.03109377f, -0.04824222f, -0.06483529f, -0.02812038f, -0.07064202f, 
    0.03126531f, 0.01166884f, -0.04406354f, 0.04810471f, 0.05446874f, -0.02449354f, 0.00456852f, -0.06895407f, 
    -0.02510558f, 0.04109677f, -0.06045479f, -0.03881320f, 0.01745132f, 0.00498948f, 0.01062373f, -0.00890523f, 
    -0.02291277f, -0.05202811f, -0.00213458f, -0.01529130f, -0.00118051f, -0.05326514f, 0.01134244f, -0.05782951f, 
    0.00758757f, 0.02617400f, -0.04979990f, 0.02848662f, 0.01855559f, 0.03344654f, 0.02967911f, 0.04017467f, 
    0.01717627f, -0.01550323f, 0.05165574f, 0.01476955f, 0.04438174f, -0.03877364f, -0.05660436f, 0.01961660f, 
    -0.01787761f, -0.00137561f, -0.01211042f, 0.04012212f, -0.02648528f, -0.06037856f, 0.01804069f, -0.03056137f, 
    -0.04656913f, 0.02379104f, -0.04041923f, -0.03627185f, -0.03803825f, -0.02716288f, 0.02254784f, -0.04670747f, 
    0.04037378f, -0.03428471f, -0.01831560f, 0.02265142f, 0.01744744f, -0.01626750f, 0.02982814f, 0.02616866f, 
    -0.07372420f, -0.01931433f, 0.00632808f, -0.00474786f, -0.05098755f, -0.07559581f, 0.03521714f, -0.04580419f, 
    0.00990320f, 0.04828726f, -0.01601392f, -0.05918230f, 0.00899349f, -0.04761387f, -0.03609115f, -0.04913360f, 
    -0.05307266f, 0.03535295f, 0.04456802f, -0.03312104f, -0.02448429f, 0.02114923f, -0.05390807f, -0.00723946f, 
    -0.01524625f, 0.01502638f, -0.02826655f, 0.02520292f, 0.01048384f, -0.05406312f, -0.03019814f, -0.05984282f, 
    0.02565823f, 0.05789151f, -0.01062325f, -0.03553731f, -0.02316894f, -0.02884529f, -0.05381281f, -0.01834169f, 
    0.01178756f, -0.00293410f, 0.01467464f, -0.00936906f, -0.02683752f, -0.01721074f, -0.07309031f, -0.03952491f, 
    -0.01835192f, -0.01337403f, 0.02988111f, -0.02695986f, 0.02480218f, 0.05593799f, 0.01671270f, -0.01689879f, 
    -0.02627546f, -0.02388194f, 0.03653881f, 0.00453982f, -0.04841203f, 0.00725983f, 0.04894236f, -0.04539455f, 
    -0.01421293f, -0.02527383f, -0.06100194f, 0.04005535f, 0.03334070f, -0.05601360f, -0.02473805f, -0.03495100f, 
    -0.05404484f, -0.04668768f, -0.07746420f, 0.00015168f, -0.03415723f, 0.01865781f, -0.03845719f, 0.03279190f, 
    -0.01844263f, 0.03196458f, 0.01500105f, 0.00747541f, 0.03284132f, -0.01967456f, 0.00929550f, 0.01981983f, 
    -0.01854005f, -0.05692019f, -0.05358664f, -0.07005794f, -0.06477076f, 0.00688087f, 0.01730132f, 0.01475685f, 
    0.04104084f, -0.05820481f, -0.02936860f, -0.01689443f, -0.02073572f, 0.00517781f, -0.03344068f, -0.06150772f, 
    -0.03349221f, -0.05873972f, -0.01542099f, 0.01984015f, 0.04355792f, 0.06255931f, 0.00701279f, -0.03362753f, 
    0.04701589f, 0.00184358f, -0.03621261f, 0.03931577f, -0.00883343f, -0.02656552f, 0.02009491f, 0.03234667f, 
    -0.04071096f, 0.01285148f, 0.03053804f, -0.01004237f, 0.00193306f, -0.02369188f, -0.05044440f, 0.02709608f, 
    -0.00226112f, 0.01749956f, -0.01670500f, -0.04975794f, -0.04482596f, 0.04794573f, -0.04142946f, 0.01922795f, 
    -0.06165837f, -0.06240345f, -0.03539586f, -0.05374624f, 0.02358723f, 0.04089619f, -0.00876356f, 0.00648817f, 
    -0.03595324f, -0.17360000f, -0.20708370f, -0.00923341f, 0.11392833f, 0.11677847f, 0.04401195f, -0.09548637f, 
    0.13773833f, 0.05048086f, 0.02762110f, -0.22546430f, -0.14398895f, -0.08061695f, -0.12582015f, -0.03345473f, 
    0.11650083f, 0.08277971f, -0.00322661f, -0.08865289f, 0.17127006f, 0.04706912f, -0.03804548f, -0.15622547f, 
    0.00412846f, 0.08158844f, -0.12339418f, 0.16038284f, -0.02988916f, 0.08909602f, -0.00020535f, -0.07772520f, 
    0.07526845f, -0.01009675f, 0.03462743f, -0.02709206f, -0.03435074f, 0.00098731f, 0.06322655f, 0.08158866f, 
    -0.04347951f, 0.01214817f, 0.05940393f, 0.00482540f, 0.12861352f, 0.05846816f, -0.18665710f, -0.08525181f, 
    0.05261523f, -0.02999862f, -0.04157821f, 0.04822215f, -0.17097771f, 0.08826612f, 0.11895880f, -0.13920747f, 
    0.02908580f, 0.11517837f, -0.08957038f, 0.00487076f, -0.02752145f, -0.01280227f, -0.01229766f, 0.15896520f, 
    0.16846485f, -0.01768631f, -0.05086745f, -0.06482549f, -0.06684996f, 0.09619306f, -0.12076979f, 0.04264928f, 
    -0.03178287f, 0.18096596f, -0.07630614f, 0.16304620f, 0.02175809f, 0.00602803f, -0.02015197f, -0.06769641f, 
    -0.06339797f, -0.32695436f, -0.24823807f, 0.21469575f, 0.07187457f, 0.03312516f, 0.08348821f, 0.00076010f, 
    -0.10605820f, 0.06833844f, 0.02918016f, -0.06602023f, 0.01685183f, 0.03026370f, 0.16165555f, 0.03652937f, 
    -0.03637214f, 0.05846825f, 0.03531467f, -0.03078858f, -0.15932660f, -0.17229469f, 0.06969836f, -0.00400593f, 
    0.01211376f, -0.20004031f, 0.04098272f, -0.05673844f, 0.16298829f, 0.14272092f, 0.04004015f, -0.06088214f, 
    -0.00533238f, 0.03050890f, 0.13740902f, 0.11227135f, -0.03180050f, 0.15359351f, -0.03358839f, 0.04937946f, 
    -0.12309732f, 0.12430740f, 0.06534614f, -0.03103197f, 0.16356228f, -0.11265443f, 0.12486366f, 0.04666621f, 
    0.13539326f, -0.12636630f, 0.00231163f, 0.06760842f, 0.04923356f, 0.00183276f, -0.10017829f, -0.04028049f, 
    -0.36974218f, -0.08170548f, -0.03395237f, 0.09966803f, -0.01106993f, -0.04030850f, -0.08693107f, 0.14240061f, 
    0.19584689f, 0.19511044f, -0.11604169f, 0.09805895f, 0.04662824f, -0.04478953f, 0.09631240f, 0.03974140f, 
    0.06666925f, -0.08773751f, 0.05276384f, -0.03119969f, -0.05424388f, -0.00981164f, 0.05378680f, 0.05203435f, 
    -0.03299250f, -0.04495805f, 0.07668331f, 0.19067654f, -0.41740885f, -0.20572160f, -0.06673552f, 0.18803766f, 
    -0.02176270f, -0.14393704f, 0.05158855f, 0.10381645f, 0.27403805f, 0.01232632f, 0.04392292f, -0.05720134f, 
    -0.12305648f, 0.10619917f, 0.10478940f, -0.01499588f, 0.00637690f, 0.17425984f, 0.01175387f, -0.02477003f, 
    -0.05605010f, 0.02699161f, 0.07742038f, 0.00384021f, 0.01991945f, 0.23283868f, 0.14700416f, -0.04442103f, 
    -0.11853053f, -0.00474929f, -0.09940337f, 0.07957639f, -0.12329488f, -0.05748032f, 0.06356984f, -0.14041732f, 
    0.14535229f, 0.05380904f, -0.02515424f, -0.04814440f, -0.07631811f, -0.06005170f, -0.03364476f, -0.13500966f, 
    -0.03220680f, -0.05366568f, -0.02045383f, 0.03476882f, 0.14967711f, -0.02166227f, 0.03562009f, -0.12722996f, 
    0.04339333f, 0.07151293f, 0.05126167f, 0.02067857f, 0.02610678f, 0.03017093f, -0.06323881f, -0.03165311f, 
    -0.09885492f, 0.25965559f, 0.13300185f, -0.07602123f, -0.23541136f, -0.01419138f, -0.07175381f, 0.10758454f, 
    -0.07556518f, -0.08962428f, 0.25898939f, -0.18464145f, 0.13621087f, -0.09260555f, 0.00037551f, 0.06479497f, 
    0.00938006f, -0.04232716f, -0.16021256f, -0.17129983f, -0.01872748f, 0.04719778f, 0.04348660f, 0.09544174f, 
    -0.00759143f, -0.09638459f, -0.05222178f, 0.04457358f, -0.09126292f, 0.03093067f, -0.13083553f, 0.24828421f, 
    -0.26181495f, -0.01440653f, -0.10780329f, -0.03579548f, 0.12749362f, 0.27674398f, 0.08451402f, -0.00838649f, 
    0.13809948f, 0.00321268f, 0.05185668f, 0.01918491f, -0.04994726f, -0.08599646f, 0.25854000f, -0.11002057f, 
    -0.00939040f, -0.06599832f, -0.07028783f, 0.01535075f, -0.02058833f, 0.07606655f, 0.00398901f, -0.17913076f, 
    0.16088188f, -0.15323980f, -0.05838175f, -0.00798606f, -0.11302064f, 0.00054662f, -0.05312704f, -0.00529731f, 
    0.10694498f, 0.02666322f, 0.03518990f, -0.11415220f, -0.01218711f, 0.01239087f, -0.10560933f, 0.05699474f, 
    0.17381658f, 0.11094715f, 0.03628961f, -0.20325479f, 0.15046988f, 0.02559817f, -0.06706157f, 0.04982240f, 
    -0.02410358f, -0.04997843f, -0.24138919f, 0.09562626f, 0.03254287f, 0.06712000f, 0.03771516f, -0.00003851f, 
    0.07136600f, -0.11139522f, -0.23680143f, -0.04889524f, 0.16136728f, 0.00346006f, 0.16271873f, 0.02590828f, 
    -0.03156729f, -0.04317645f, -0.00672450f, -0.00109317f, -0.02712595f, 0.23033355f, 0.21370795f, 0.07434743f, 
    -0.03187705f, -0.12909697f, 0.06133744f, -0.02569384f, 0.04829809f, 0.06005517f, -0.01307230f, 0.03449680f, 
    -0.03507593f, -0.06813349f, -0.12088549f, -0.04435107f, -0.02378723f, 0.06934988f, 0.11560734f, 0.03053132f, 
    0.11970203f, -0.12717813f, 0.00264212f, 0.01056880f, -0.08675256f, -0.00863208f, 0.01356455f, 0.12388042f, 
    -0.06341406f, 0.12563559f, -0.18476334f, -0.00481509f, 0.13005988f, 0.03982619f, -0.07511187f, 0.01752624f, 
    0.11494479f, 0.09713471f, 0.09754426f, -0.01709076f, 0.02775454f, -0.06056263f, -0.03012196f, -0.08492797f, 
    -0.01667527f, -0.00499833f, -0.26413578f, -0.17251728f, 0.02084962f, -0.17478138f, -0.10823426f, 0.02088868f, 
    -0.10057200f, 0.03046881f, -0.02777196f, -0.10014581f, 0.18457407f, 0.08168005f, -0.06854114f, -0.10469089f, 
    -0.16711043f, 0.02922392f, -0.10330824f, 0.14868318f, 0.03411825f, -0.24849284f, -0.04958071f, 0.02248253f, 
    0.01122187f, -0.11393512f, 0.00385625f, 0.07126297f, 0.17749916f, -0.04318183f, 0.09533416f, 0.15139489f, 
    -0.05481475f, -0.04154420f, -0.08997861f, 0.03814233f, -0.01563585f, -0.04369812f, 0.14860767f, 0.18288046f, 
    -0.19918440f, 0.13938256f, 0.06279999f, 0.00023386f, -0.14241895f, -0.03060770f, 0.00249981f, 0.09236971f, 
    0.05688262f, 0.14709023f, 0.07489857f, 0.12802604f, 0.07639902f, -0.03994408f, -0.02250016f, -0.00567450f, 
    -0.06371227f, -0.08266418f, 0.00419298f, -0.01189675f, 0.22787616f, -0.17280963f, 0.04456161f, 0.16746601f, 
    0.00896543f, 0.06903844f, -0.02615936f, 0.07574715f, 0.01392660f, -0.09310066f, 0.01189705f, 0.07119988f, 
    0.02153984f, -0.04439554f, 0.05419846f, -0.04338675f, 0.04185837f, 0.07021768f, -0.04029214f, 0.13030726f, 
    -0.01152120f, 0.05559603f, 0.13047561f, -0.06155675f, -0.06429583f, -0.06708889f, -0.06621280f, 0.08125632f, 
    -0.07027278f, -0.09136285f, -0.07328660f, 0.30595320f, -0.06712748f, 0.07064596f, 0.04612024f, 0.03108574f, 
    -0.05930677f, 0.01545786f, 0.11083046f, -0.04087959f, 0.27790919f, -0.01826297f, -0.01351871f, 0.14069991f, 
    0.07737881f, 0.01327248f, -0.00839174f, -0.01608825f, -0.02849823f, 0.06240485f, 0.10776169f, 0.10153853f, 
    0.12476337f, 0.13298836f, 0.02738780f, 0.09131598f, -0.06660530f, -0.03872244f, 0.02095033f, -0.01843015f, 
    0.14940067f, -0.12744032f, 0.09086096f, -0.09287486f, -0.13594544f, 0.00280234f, 0.04187101f, 0.02524869f, 
    -0.03620359f, 0.11217401f, -0.18393815f, 0.14406173f, -0.00875647f, -0.06582578f, -0.07538857f, -0.00625063f, 
    0.10895964f, -0.01326570f, -0.09113628f, 0.02673826f, 0.02209976f, 0.06832100f, -0.06137711f, -0.08990301f, 
    -0.03238675f, 0.25115937f, 0.07445223f, 0.01210369f, 0.12533262f, 0.02988601f, -0.00211357f, -0.03050541f, 
    -0.11132912f, -0.10207744f, 0.03007972f, 0.12192107f, 0.02185559f, 0.03535441f, 0.03835615f, 0.12606747f, 
    -0.12494574f, -0.03984267f, -0.20435022f, 0.19881286f, -0.11600792f, 0.14443532f, -0.12460510f, -0.03871707f, 
    -0.00966416f, -0.24472333f, -0.13116798f, -0.00722133f, 0.08754727f, 0.16518261f, 0.02861347f, -0.11619248f, 
    -0.12776974f, 0.09542818f, -0.02976882f, -0.01287228f, 0.23364003f, -0.02030422f, -0.14626916f, 0.21980339f, 
    -0.01019449f, -0.10381407f, 0.11551215f, -0.25176439f, -0.07955199f, -0.06405360f, -0.01305401f, -0.06110989f, 
    0.07696418f, 0.02695815f, -0.05733455f, 0.02979428f, 0.01805893f, -0.00358104f, -0.09297093f, 0.14548910f, 
    0.09539890f, -0.10064293f, -0.02085098f, 0.13285683f, -0.00020026f, 0.09176572f, 0.03674732f, 0.09181260f, 
    0.02490485f, 0.02929731f, -0.02659887f, -0.05011182f, 0.04104684f, -0.01695046f, 0.01204720f, 0.05558878f, 
    -0.12113702f, 0.32001844f, -0.04572599f, 0.01940219f, -0.02015821f, 0.12730847f, -0.00690062f, -0.05612986f, 
    0.06369543f, 0.03566496f, -0.16730033f, -0.09499051f, 0.01871843f, 0.04680777f, -0.08271141f, 0.04240976f, 
    0.11121749f, 0.09130955f, -0.04264347f, -0.08926774f, -0.14469200f, -0.04063509f, -0.00617205f, 0.14012495f, 
    -0.03524212f, 0.01854980f, -0.05285234f, -0.10695887f, 0.25666910f, 0.18125065f, 0.06509770f, 0.11671704f, 
    0.12824604f, -0.03792775f, 0.00345970f, 0.09743926f, 0.08052792f, 0.21895044f, 0.01926188f, 0.04946741f, 
    -0.10135154f, -0.03087180f, -0.08141553f, -0.00437519f, -0.04881958f, 0.03727916f, 0.09250779f, 0.15914866f, 
    0.03217604f, -0.01634702f, -0.01806418f, -0.15672198f, -0.01421151f, 0.08313332f, 0.04464778f, -0.07443778f, 
    0.12346850f, -0.19430158f, -0.17473491f, -0.03477481f, 0.02276001f, 0.03896321f, 0.07111789f, 0.09959612f, 
    0.11403068f, 0.16350658f, -0.19933060f, 0.09806409f, -0.10638197f, -0.11887248f, 0.03578758f, 0.07128242f, 
    0.04689900f, -0.27836519f, -0.04354386f, 0.30041346f, -0.11887243f, -0.08170792f, 0.13197678f, 0.03834960f, 
    0.05469845f, -0.03208519f, 0.04772834f, -0.20668173f, -0.02879424f, 0.04790495f, -0.05028576f, 0.05743807f, 
    -0.12314459f, 0.02521277f, -0.00612694f, 0.06237765f, 0.04355836f, -0.03441388f, 0.01352771f, 0.08852693f, 
    -0.08676007f, -0.03790130f, 0.02258489f, 0.04555533f, -0.26355973f, -0.44220331f, -0.04877675f, -0.03470460f, 
    0.03800986f, 0.07142191f, 0.06369580f, 0.01222736f, -0.14162566f, 0.01919949f, 0.02465849f, -0.07070938f, 
    -0.06206899f, -0.07339212f, -0.01727456f, 0.17952797f, 0.09283175f, -0.00102417f, -0.33652934f, -0.23619066f, 
    0.06289959f, -0.01804524f, 0.09948878f, -0.01686433f, 0.05803508f, 0.06018991f, 0.01634908f, -0.20210648f, 
    0.01597016f, 0.02077687f, -0.05993991f, 0.01704937f, -0.01112812f, -0.08659840f, -0.09315918f, 0.06997539f, 
    0.29652846f, -0.07327285f, 0.07359033f, 0.12602395f, 0.05773712f, 0.06860545f, 0.08794740f, -0.01609267f, 
    0.00219685f, 0.12777236f, 0.14611247f, -0.11675637f, 0.11331081f, -0.04984136f, 0.03213384f, -0.08759680f, 
    0.02826507f, -0.02754495f, -0.17124109f, -0.14084597f, -0.13713883f, -0.09923733f, -0.11189435f, -0.00263268f, 
    -0.03704074f, 0.11150893f, 0.04759563f, 0.19420707f, -0.37541994f, -0.27944124f, 0.06377029f, 0.01703356f, 
    -0.00218467f, 0.04613858f, 0.00393526f, 0.02071290f, 0.10959901f, -0.12207029f, -0.08439112f, 0.04742162f, 
    0.03636689f, 0.06720374f, -0.03982336f, -0.12147162f, -0.08882473f, -0.14389662f, -0.46540609f, 0.01919963f, 
    0.01461645f, 0.06740412f, 0.03957383f, 0.02641841f, -0.10070121f, -0.02252737f, 0.08682960f, -0.14977717f, 
    0.10964222f, 0.04874836f, 0.03226091f, 0.09031383f, 0.00829566f, -0.09273946f, 0.03007747f, 0.06429242f, 
    0.05550731f, -0.00012906f, -0.02076845f, 0.10071690f, 0.01109966f, -0.01437201f, -0.02821835f, -0.08253387f, 
    -0.24214618f, -0.02581863f, 0.07250828f, 0.01271532f, 0.02990855f, 0.02873026f, 0.06332632f, -0.04354204f, 
    0.06965802f, 0.10044671f, -0.30332407f, 0.10343200f, -0.07315183f, 0.02919934f, 0.02760116f, -0.00125669f, 
    -0.02779169f, -0.03583506f, 0.05647521f, -0.05024575f, -0.05124756f, -0.03400879f, 0.07702305f, -0.02878815f, 
    0.04502035f, 0.08089796f, 0.01364974f, -0.11112493f, 0.10037505f, 0.05172752f, -0.07098397f, -0.05552708f, 
    0.03651944f, -0.14073779f, 0.01015521f, 0.04716288f, 0.04904197f, 0.25871041f, 0.13640243f, 0.05034982f, 
    0.00851827f, 0.03145521f, -0.03428060f, -0.00107764f, 0.04628051f, 0.21657176f, 0.14922848f, -0.16249099f, 
    -0.07016773f, 0.02468498f, 0.02962140f, 0.03688205f, 0.12202416f, 0.13194998f, 0.09360479f, 0.01574027f, 
    -0.01375182f, 0.02362049f, 0.04710354f, -0.02002142f, 0.02772895f, 0.07148751f, 0.04946554f, 0.18630418f, 
    0.06982268f, -0.16181371f, 0.06491661f, 0.04786083f, -0.05506764f, 0.01598320f, 0.04372586f, -0.01312828f, 
    -0.17077902f, 0.03630795f, -0.02165223f, 0.14329441f, 0.06533172f, 0.11866297f, -0.07000488f, -0.07769122f, 
    0.01178223f, -0.24097180f, 0.12378308f, -0.32320803f, 0.10188473f, 0.04870832f, -0.08156326f, -0.15074916f, 
    -0.02833759f, -0.01940902f, 0.02986526f, 0.06057375f, 0.12447178f, 0.04174294f, -0.09094092f, 0.04114323f, 
    0.05659330f, -0.13304238f, 0.07799245f, -0.00236648f, -0.13730396f, -0.03874363f, 0.08239451f, 0.07331409f, 
    -0.03516132f, 0.14668137f, 0.03230637f, -0.07934885f, -0.14670074f, -0.10037330f, -0.30889833f, 0.08854289f, 
    0.01134153f, -0.07807067f, 0.20806864f, -0.00527079f, 0.03535866f, -0.15782866f, -0.12003757f, -0.06731954f, 
    0.04733512f, 0.00309793f, 0.06851299f, 0.06444972f, -0.12248897f, 0.01850253f, -0.02003645f, -0.01917479f, 
    0.17189299f, -0.07848341f, -0.12307987f, 0.03967288f, -0.05410170f, -0.10491624f, 0.14708751f, -0.29315230f, 
    -0.08218700f, 0.41659230f, 0.06383990f, 0.08822255f, -0.06737934f, -0.06748996f, 0.13484415f, 0.06080717f, 
    -0.18062636f, 0.13022539f, 0.24643084f, 0.17922238f, -0.02953869f, -0.06265872f, 0.03081675f, -0.00675504f, 
    0.05539259f, -0.27275950f, -0.31605104f, -0.02749768f, -0.04413985f, -0.04423359f, 0.12685716f, -0.09991697f, 
    -0.00626095f, -0.02250842f, 0.02120643f, 0.03249417f, -0.14834119f, -0.09657699f, 0.10414084f, 0.16618603f, 
    -0.04669688f, 0.09999663f, -0.04262647f, 0.04610886f, 0.06355666f, -0.23177341f, -0.02307399f, 0.06438647f, 
    -0.03892196f, -0.01215485f, 0.00692460f, 0.00460888f, 0.06761005f, 0.19957624f, 0.03969698f, 0.07190778f, 
    0.07447697f, 0.05935713f, -0.01341414f, 0.00423699f, -0.12255735f, 0.01954648f, -0.17748289f, 0.38980973f, 
    -0.12905861f, 0.00270743f, 0.12857123f, -0.04046794f, -0.05978508f, 0.07571252f, -0.05913422f, 0.09053186f, 
    0.01109889f, 0.14407788f, 0.10025121f, -0.02581350f, 0.05069789f, 0.10669399f, -0.00074127f, -0.13398911f, 
    0.03854208f, -0.13163881f, 0.00467403f, -0.14807184f, -0.06066513f, 0.03195776f, 0.11730325f, 0.11723393f, 
    -0.26358128f, 0.08483028f, -0.30478862f, 0.13160910f, 0.04244814f, -0.04807549f, 0.04064601f, 0.07026102f, 
    -0.06323589f, 0.04008931f, -0.00410986f, -0.04393959f, -0.06626212f, -0.04394637f, 0.04304558f, -0.04910835f, 
    -0.02549994f, -0.04897542f, 0.51594281f, -0.05719644f, -0.17092879f, -0.03846263f, -0.13340248f, 0.07316479f, 
    -0.06431057f, -0.06120903f, 0.20826100f, -0.07236646f, 0.16007645f, -0.14624767f, -0.13895796f, 0.21592788f, 
    -0.10479995f, 0.02106394f, -0.06414428f, -0.04187672f, -0.06608010f, 0.07255702f, -0.36504018f, 0.05386686f, 
    -0.05670661f, 0.03935424f, 0.06267019f, 0.07668097f, 0.06183380f, 0.19565889f, 0.12212905f, -0.06619139f, 
    0.06692158f, -0.03180774f, 0.04903932f, -0.01875252f, -0.13967215f, 0.03004214f, -0.28756443f, 0.12725802f, 
    0.02558009f, 0.13330363f, 0.13883381f, -0.07074315f, 0.02106421f, 0.20859662f, 0.03165873f, -0.23263794f, 
    -0.00875942f, -0.08876581f, -0.01802447f, -0.06700514f, 0.03976673f, -0.02138870f, 0.03771698f, 0.07418825f, 
    0.14510529f, -0.02769736f, -0.05666230f, -0.02652113f, -0.07525446f, 0.07063477f, 0.08582877f, -0.00126708f, 
    0.07790902f, 0.19365852f, -0.01071357f, -0.33070883f, 0.06346085f, 0.03834447f, -0.02399201f, -0.07248046f, 
    -0.09848582f, 0.08624265f, 0.22249918f, -0.04385201f, 0.07187103f, -0.00720773f, -0.07211724f, -0.09971637f, 
    0.16622815f, 0.08693092f, -0.07572743f, 0.09073822f, -0.06523609f, -0.10277972f, -0.09325475f, -0.10142760f, 
    -0.01941398f, 0.01238446f, -0.13215695f, 0.10461032f, -0.22193919f, -0.23443973f, -0.29212156f, 0.07466178f, 
    -0.00785897f, 0.03621547f, -0.01704285f, 0.05618516f, 0.17431043f, -0.00512713f, -0.02917258f, 0.28441659f, 
    0.05146787f, -0.05861749f, 0.00193079f, -0.04960267f, 0.03302128f, 0.03161927f, -0.14623350f, 0.03262429f, 
    -0.00360591f, -0.01480775f, 0.14212435f, 0.00385790f, 0.00072980f, 0.05658008f, 0.01612848f, 0.21976176f, 
    -0.00217724f, 0.13175143f, -0.10013521f, -0.07174205f, 0.04361172f, -0.05284948f, 0.03286121f, 0.08355340f, 
    -0.02178696f, -0.05478905f, -0.03399740f, -0.05278960f, -0.05289526f, -0.02153285f, 0.05804249f, -0.04945642f, 
    -0.02065755f, 0.04291216f, 0.00396936f, -0.00377520f, -0.04479564f, 0.05338785f, -0.05620392f, 0.03327511f, 
    0.00271065f, 0.00955239f, -0.02946594f, 0.00250086f, -0.03721691f, -0.03256249f, -0.04121118f, -0.05179192f, 
    -0.03199359f, -0.04790129f, -0.01393192f, -0.00104627f, -0.00004678f, 0.04232436f, 0.02194261f, 0.05672142f, 
    0.03784415f, -0.02049837f, -0.05350455f, -0.02707525f, 0.02665823f, -0.01866199f, -0.05844949f, 0.03947013f, 
    -0.02911410f, -0.04734598f, -0.05372373f, -0.02819895f, -0.03924182f, -0.05302759f, -0.01948218f, 0.01912742f, 
    0.01991435f, -0.05160148f, -0.00878529f, -0.00544355f, -0.01064044f, -0.02218763f, -0.04708134f, -0.04622907f, 
    -0.00602585f, -0.05727107f, -0.03833658f, -0.00513688f, 0.04587550f, -0.00976313f, 0.03298720f, 0.03195861f, 
    -0.00934355f, 0.04636525f, -0.02304797f, 0.02361040f, 0.04042690f, -0.04298806f, 0.01765911f, -0.00675647f, 
    0.00389511f, 0.01427297f, 0.00191031f, 0.01299281f, 0.04996072f, -0.00538555f, 0.03970065f, -0.01889104f, 
    -0.04647018f, 0.02988172f, -0.01204833f, -0.00821513f, -0.04378055f, -0.00464647f, 0.01306586f, -0.03179185f, 
    0.00814521f, -0.00102961f, -0.00941515f, 0.00625892f, -0.03738596f, 0.04464687f, -0.03293576f, 0.04862572f, 
    0.03350921f, -0.03477055f, 0.04759525f, -0.04253906f, 0.03228069f, -0.02430579f, -0.05608026f, 0.00135577f, 
    -0.00135121f, 0.02834732f, -0.00450490f, 0.04577377f, -0.03074058f, 0.01232818f, -0.01633416f, 0.03833255f, 
    0.04618112f, -0.00106976f, -0.04066821f, -0.03997928f, 0.04409925f, 0.04020837f, -0.00507696f, 0.04342641f, 
    0.05447894f, 0.04738662f, -0.02216596f, 0.01537376f, -0.00794416f, -0.05723640f, -0.04811405f, -0.04473287f, 
    -0.03840324f, 0.02849887f, -0.05487697f, 0.05631726f, -0.04898339f, -0.05562059f, 0.02417446f, -0.02770876f, 
    -0.04611354f, -0.03485929f, -0.03134741f, -0.02090459f, 0.01551126f, 0.03911388f, -0.04964049f, -0.00098206f, 
    -0.04381546f, -0.01349869f, -0.05451892f, -0.05033529f, -0.00362111f, -0.05044437f, -0.04681813f, -0.03155547f, 
    0.00695769f, 0.05859796f, -0.04151711f, -0.04986285f, -0.05124765f, -0.01423148f, -0.02601421f, -0.03374306f, 
    -0.05222537f, 0.00151340f, 0.03114821f, 0.05256161f, -0.01121495f, -0.05370048f, -0.04649776f, 0.05207369f, 
    -0.05789077f, -0.00138743f, -0.03983919f, -0.05636155f, 0.00170821f, 0.03777987f, -0.03003044f, -0.00507464f, 
    -0.02688466f, -0.03699948f, 0.04385364f, 0.02997150f, -0.03420745f, 0.03440308f, -0.05421439f, -0.02578001f, 
    0.05008486f, -0.01543464f, -0.05261474f, -0.04738075f, 0.02279627f, 0.02729809f, 0.03244060f, -0.00664213f, 
    0.05600578f, -0.02378877f, -0.03028105f, -0.01230050f, -0.05186804f, 0.05298236f, 0.01573114f, 0.01108433f, 
    -0.04705016f, -0.03335215f, 0.02302942f, 0.05542700f, 0.01749551f, -0.02921914f, -0.04661107f, 0.01451899f, 
    -0.02456332f, -0.04511761f, 0.04390960f, -0.04788478f, -0.03904765f, -0.05595438f, -0.05445422f, -0.01197594f, 
    0.04831299f, -0.02358169f, -0.04394742f, -0.01852087f, 0.00007517f, 0.00903173f, -0.03199362f, 0.04001066f, 
    0.03938087f, 0.05709232f, 0.04477777f, -0.01559683f, -0.02495859f, 0.02264518f, -0.05159866f, 0.00719153f, 
    0.05495993f, -0.05447086f, 0.00494017f, -0.05262183f, -0.03000929f, 0.02739698f, 0.05149145f, -0.02979760f, 
    0.05088251f, -0.02861430f, -0.04293104f, 0.02580373f, -0.01879247f, 0.04190584f, 0.05788374f, -0.02754693f, 
    0.05216182f, 0.04556999f, -0.02245435f, 0.01938558f, -0.00213097f, -0.02659017f, -0.00535606f, -0.05533150f, 
    -0.05776614f, 0.03737124f, 0.02088744f, -0.00217292f, -0.02458987f, 0.03414305f, 0.05341917f, 0.05365068f, 
    -0.04724093f, -0.00123713f, -0.01761119f, 0.04643741f, -0.04989609f, -0.00501912f, -0.03547679f, -0.04919139f, 
    -0.05676914f, -0.01041458f, -0.01549922f, -0.04940241f, 0.01195393f, -0.02763324f, -0.01477222f, 0.01810316f, 
    0.04222433f, -0.02778842f, 0.02466580f, -0.03390810f, 0.02031892f, -0.02079075f, 0.04842560f, 0.02761117f, 
    0.25635535f, -0.30452818f, -0.02353720f, 0.03490290f, 0.15958957f, 0.12856346f, 0.09600092f, -0.09454878f, 
    -0.08174451f, -0.04977146f, -0.23499052f, -0.31610906f, -0.08331551f, 0.08244722f, -0.04944477f, -0.13558117f, 
    -0.05546616f, -0.00159172f, 0.11786383f, 0.06459652f, -0.09980547f, -0.05335345f, -0.09500457f, -0.06426269f, 
    0.09896310f, -0.07527648f, 0.12703042f, -0.03372401f, -0.02608314f, -0.03777356f, 0.01821337f, -0.08553369f, 
    0.01768911f, -0.08446599f, -0.00180026f, -0.02685611f, -0.28819793f, -0.16338298f, -0.04480554f, 0.17198220f, 
    -0.01102015f, 0.22330840f, -0.06023257f, 0.06805888f, 0.17915212f, 0.08278451f, -0.21770988f, -0.21703997f, 
    -0.05336672f, 0.02505328f, -0.02994614f, 0.02563747f, -0.03700762f, 0.04123383f, 0.07375541f, 0.21035340f, 
    0.04182644f, -0.08049849f, -0.04534876f, -0.12532249f, 0.00195762f, -0.03229465f, -0.06732872f, -0.00543915f, 
    0.13488725f, -0.01253914f, 0.10074019f, 0.02100031f, 0.15865512f, 0.06451409f, 0.09257159f, 0.03022693f, 
    0.04255226f, -0.12833261f, 0.14623846f, 0.10026728f, 0.10835317f, 0.09159330f, -0.08345891f, 0.07020167f, 
    0.04631414f, -0.26907066f, -0.14089097f, -0.08545179f, 0.09598354f, 0.00865486f, 0.08432458f, 0.02512438f, 
    -0.00941719f, 0.06239253f, -0.09785803f, 0.08847736f, 0.03572820f, -0.02239786f, -0.07421017f, 0.04084041f, 
    0.01754074f, 0.11352163f, 0.02734735f, 0.10554159f, -0.28554249f, 0.02570803f, -0.05632727f, -0.00565440f, 
    0.09553069f, -0.07379302f, 0.06283784f, 0.01485429f, 0.15289722f, 0.09710427f, 0.07116058f, -0.06508881f, 
    -0.01655690f, 0.02986065f, -0.05192600f, -0.05788211f, 0.03647207f, 0.35987917f, 0.11244005f, 0.03308786f, 
    0.01769642f, -0.00659111f, 0.03864709f, -0.01871627f, 0.03982163f, 0.00516816f, 0.05878883f, 0.05401782f, 
    -0.09287047f, -0.02478823f, -0.07955039f, -0.04375441f, -0.04676841f, -0.02353330f, -0.05336748f, 0.02197583f, 
    0.07528515f, 0.00013995f, -0.17476456f, 0.02629546f, -0.30750304f, 0.20076175f, 0.13285348f, -0.06418164f, 
    -0.13076422f, -0.07188086f, -0.13785768f, 0.05846848f, 0.00042307f, 0.08128989f, 0.00478130f, -0.04145772f, 
    -0.07470836f, 0.10089453f, -0.29409975f, 0.07777650f, 0.11553170f, -0.00533924f, 0.02481801f, 0.02768249f, 
    0.03756439f, -0.00929418f, 0.10823658f, -0.16696748f, 0.10188304f, 0.04780617f, -0.03988547f, -0.08426610f, 
    -0.03200292f, -0.03983818f, 0.17416535f, -0.02372585f, -0.18331657f, -0.01463610f, 0.02030360f, -0.00496424f, 
    -0.04960785f, -0.06185494f, 0.05103693f, 0.06622253f, 0.09622232f, -0.07817233f, 0.11488814f, -0.04989455f, 
    -0.03653110f, -0.14761192f, -0.06824698f, 0.13344446f, 0.08264434f, 0.13365963f, 0.03919853f, -0.07972489f, 
    -0.00147250f, -0.01806004f, 0.00543808f, -0.14138061f, -0.09041592f, 0.08172219f, 0.05550287f, 0.13458858f, 
    -0.23854919f, -0.04163576f, 0.00908545f, 0.07806617f, 0.15010539f, 0.09761486f, -0.10616191f, 0.31260872f, 
    -0.20930433f, -0.30565307f, 0.04214577f, 0.04899461f, 0.01519789f, -0.04994765f, 0.06297726f, 0.01782542f, 
    0.18085261f, 0.04589126f, 0.15002419f, -0.06846981f, -0.02537050f, 0.06230367f, 0.02211765f, 0.01546883f, 
    0.14298694f, 0.24936433f, -0.00218840f, -0.07989381f, -0.20893475f, -0.04014765f, -0.04404561f, -0.12297958f, 
    -0.01704846f, -0.03223027f, -0.15726283f, -0.04689699f, 0.08022650f, 0.08883097f, -0.08170249f, -0.10568094f, 
    0.09582438f, 0.02426079f, 0.07457754f, -0.23603983f, -0.17966606f, 0.20432819f, 0.02389234f, 0.09070450f, 
    0.00180087f, 0.06828528f, -0.01836872f, 0.08323295f, -0.27115586f, -0.06731753f, -0.11585545f, 0.03765860f, 
    0.06277917f, 0.10626349f, -0.07500356f, 0.09048274f, 0.02914837f, 0.11297235f, 0.21311902f, 0.02781020f, 
    0.01587399f, 0.01497243f, -0.02626827f, 0.08805274f, 0.17288642f, -0.11737930f, -0.18199486f, 0.03534815f, 
    -0.06164133f, 0.06878164f, -0.17421167f, 0.05272152f, -0.04248816f, 0.00211724f, 0.00556232f, -0.15852629f, 
    -0.37284350f, -0.03298530f, 0.05848287f, 0.11069620f, -0.02680960f, -0.04660220f, -0.04611581f, 0.00388952f, 
    0.04690014f, -0.04765515f, -0.03915685f, -0.04302071f, 0.04350260f, -0.03853308f, 0.01068934f, -0.00144455f, 
    0.02827954f, -0.06333249f, 0.00417527f, -0.03688606f, -0.01552784f, -0.06472956f, -0.00485471f, -0.00070385f, 
    -0.02110045f, 0.02534912f, 0.02845350f, -0.02172974f, -0.03030867f, -0.01100000f, 0.01539895f, -0.05461400f, 
    0.04422079f, -0.03922318f, 0.01026797f, -0.04960054f, -0.04843269f, -0.00269186f, -0.03842210f, 0.04023588f, 
    -0.00080118f, -0.03789455f, -0.02538053f, 0.00914788f, 0.01620354f, -0.02382778f, 0.00196181f, 0.03295868f, 
    -0.05070001f, 0.02392017f, -0.06471860f, -0.00056783f, 0.02094441f, 0.03103894f, 0.03587058f, -0.06022001f, 
    0.03570501f, -0.00552362f, 0.04700787f, -0.03055744f, 0.00791875f, -0.02311128f, 0.02530403f, 0.00039666f, 
    -0.04571813f, 0.04531293f, -0.02854086f, 0.01901483f, -0.06176132f, -0.02806229f, -0.01458329f, 0.02398157f, 
    -0.01803485f, -0.01880111f, -0.03122921f, 0.04368708f, -0.06380781f, -0.03019001f, 0.03661335f, 0.00342542f, 
    0.05115291f, -0.05406970f, 0.03425703f, -0.05421560f, 0.05123334f, 0.02039744f, -0.01021244f, 0.00577984f, 
    0.02260543f, -0.03958256f, 0.01511400f, -0.02760532f, -0.02174949f, -0.04711925f, -0.02375671f, -0.04812801f, 
    0.04010936f, -0.03177293f, 0.00463202f, -0.04439250f, 0.00216034f, -0.04120042f, 0.03932148f, -0.04321786f, 
    0.05023905f, 0.00483895f, -0.05066136f, -0.01286546f, -0.04218559f, 0.01661794f, -0.04864031f, 0.05086500f, 
    -0.04457036f, 0.01620194f, -0.05088255f, -0.04992606f, 0.03865171f, -0.01404884f, -0.03874242f, 0.02659034f, 
    -0.01645072f, 0.00539908f, -0.01083613f, 0.04451167f, 0.01761649f, 0.04264271f, 0.03269772f, 0.04872163f, 
    -0.03498186f, -0.00352334f, 0.03624038f, 0.00114106f, -0.05056975f, 0.01695776f, 0.00576090f, -0.02772408f, 
    0.04677874f, -0.05753197f, 0.00524321f, -0.01422681f, -0.06308954f, -0.06013492f, -0.01140188f, 0.04915538f, 
    0.02529121f, -0.04007478f, 0.00687823f, 0.04294303f, 0.01480408f, 0.00132798f, -0.02304504f, -0.05553301f, 
    -0.00473239f, 0.05276644f, -0.03464649f, -0.04739175f, -0.05902965f, 0.01746113f, -0.02508881f, -0.05542332f, 
    -0.05956438f, 0.03736687f, -0.04022972f, 0.01895605f, -0.06022533f, -0.05252920f, -0.00193015f, 0.01242453f, 
    -0.02944572f, -0.03319353f, -0.04225802f, 0.02391304f, -0.05807370f, -0.02166604f, 0.01326180f, -0.04745945f, 
    -0.02876294f, 0.03685079f, 0.04703600f, 0.03625318f, 0.01145081f, -0.05285657f, -0.00894769f, 0.04314242f, 
    -0.03572164f, -0.03690353f, -0.03669676f, -0.01752175f, -0.00446337f, -0.01252170f, -0.01215446f, 0.01284790f, 
    -0.00641638f, -0.01396056f, -0.04820592f, 0.05169836f, -0.05234521f, -0.05032238f, 0.02180226f, -0.02203815f, 
    0.00265846f, -0.02413632f, -0.00526443f, -0.06436687f, 0.03575135f, 0.03160901f, -0.05341978f, -0.03171890f, 
    -0.04851490f, 0.02366273f, -0.03307365f, 0.02109085f, -0.02549412f, -0.01567811f, -0.00887455f, -0.01419769f, 
    -0.03526842f, 0.03250303f, -0.05219410f, 0.01537477f, 0.03176804f, 0.04100273f, -0.04153807f, -0.00585479f, 
    0.01543664f, -0.02442528f, 0.01557812f, -0.02874629f, 0.01160028f, -0.04292924f, 0.00702940f, -0.04376048f, 
    0.02368454f, 0.04059238f, -0.04798171f, 0.05137440f, -0.00819197f, -0.00658689f, 0.01951053f, 0.00214641f, 
    0.00363415f, -0.03011514f, -0.03194776f, 0.05172916f, -0.04783456f, 0.02676927f, -0.00735256f, -0.01348106f, 
    -0.00920747f, -0.05782398f, 0.01329421f, -0.04555010f, 0.02212336f, 0.02024639f, 0.02284707f, -0.06449006f, 
    -0.01714147f, 0.00357396f, 0.03516717f, 0.02704650f, -0.04355913f, -0.02084834f, -0.02337918f, -0.01174605f, 
    0.04824372f, -0.03999943f, -0.06010687f, -0.05496155f, -0.05203998f, 0.03037996f, -0.05108016f, -0.05311567f, 
    -0.03193878f, -0.04387593f, 0.04960701f, -0.02804708f, -0.05331535f, 0.04507013f, 0.00753806f, 0.02354232f, 
    -0.02052840f, 0.00702429f, -0.02682778f, -0.01578237f, -0.03571866f, 0.02442319f, -0.04482195f, 0.00516342f, 
    0.05026938f, 0.04952690f, -0.02270830f, -0.06007677f, 0.02751474f, 0.04368590f, -0.03493755f, -0.00196586f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.16817720f, 0.00734652f, 0.05528382f, 0.18118410f, -0.04114462f, 0.09693613f, -0.05719141f, 0.08858348f, 
    0.00249736f, -0.06123435f, 0.00185670f, -0.13284548f, 0.14957383f, -0.05027926f, 0.05809704f, 0.07077301f, 
    -0.06127115f, 0.01557349f, 0.03197656f, 0.03966329f, -0.05589268f, -0.00227846f, -0.11616394f, 0.15641478f, 
    -0.00625740f, -0.05927220f, 0.01656063f, 0.03380342f, 0.09386628f, 0.01710539f, 0.04527787f, -0.03466832f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.26957396f, 0.17307122f, 0.15108728f, 0.39041930f, 0.08411819f, -0.04024174f, 0.12370499f, 0.15755640f, 
    0.11017911f, 0.12601271f, 0.03580408f, -0.38399643f, -0.29962939f, 0.04423021f, -0.04387041f, -0.01318624f, 
    0.00473477f, 0.28126985f, -0.12698121f, 0.05804592f, -0.04740051f, 0.02511553f, 0.24771252f, 0.13087057f, 
    0.11970968f, 0.26934701f, -0.11055666f, -0.22365792f, -0.13873073f, -0.05065676f, 0.24229957f, 0.02409664f, 
    -0.09245107f, -0.08241259f, -0.16426222f, -0.12232424f, -0.11942316f, -0.17184499f, -0.15058796f, -0.01542784f, 
    0.06038889f, 0.06822792f, 0.03370690f, 0.15958756f, 0.03681089f, -0.04425408f, -0.14960590f, 0.02512612f, 
    -0.11978982f, -0.06516473f, -0.07105853f, -0.02772588f, 0.17386004f, -0.09542949f, 0.00365202f, -0.14080277f, 
    0.12993950f, -0.17110762f, 0.03137579f, -0.13620746f, -0.08543549f, -0.07703637f, -0.02717125f, -0.15128081f, 
    -0.03029028f, 0.24876267f, -0.04645777f, 0.44052631f, -0.14106956f, 0.01580946f, -0.10053906f, 0.09449908f, 
    -0.29782546f, -0.00573893f, 0.03913910f, -0.08504232f, 0.27003625f, -0.14027463f, -0.14786728f, -0.20368251f, 
    -0.09962672f, 0.26989770f, 0.00643830f, -0.07713919f, -0.10102344f, -0.22918588f, 0.06708558f, 0.24594755f, 
    0.01978035f, 0.19812128f, -0.12112378f, -0.15511060f, 0.11103228f, 0.08695409f, 0.41005957f, 0.12455565f, 
    0.06396747f, -0.09608278f, 0.13297507f, 0.11155313f, -0.03675592f, -0.14574280f, 0.13684170f, -0.27702913f, 
    0.04925644f, 0.01301353f, -0.16064382f, 0.37682006f, -0.26227522f, -0.15672250f, -0.09359448f, 0.13978606f, 
    0.09269848f, 0.13473484f, -0.11011685f, 0.09294759f, -0.10821903f, -0.10951650f, -0.18385422f, 0.27520752f, 
    -0.09127220f, 0.38075972f, -0.01862439f, 0.40069696f, -0.25294444f, -0.02006757f, 0.26178914f, -0.11122535f, 
    0.36153919f, 0.05778253f, 0.10901131f, 0.16196491f, -0.11329309f, 0.00054254f, 0.16562527f, 0.00573818f, 
    -0.23706686f, -0.06377253f, 0.15393110f, 0.05302818f, 0.17993094f, 0.14321952f, -0.06750113f, -0.27929047f, 
    0.03808857f, -0.44496343f, -0.02801886f, 0.10844541f, -0.04504731f, -0.20996678f, -0.12766303f, 0.26063159f, 
    -0.09896686f, 0.15835784f, 0.20845982f, -0.10462713f, 0.18331984f, 0.06814165f, 0.41088766f, -0.10951912f, 
    0.00366150f, 0.35546619f, 0.19286901f, 0.39733812f, -0.00594273f, 0.02014420f, -0.06429852f, 0.33371207f, 
    -0.29600576f, -0.05856964f, 0.13163039f, -0.27892017f, 0.04403721f, -0.09876059f, -0.02485162f, -0.08615168f, 
    0.14256014f, 0.00439883f, -0.08937464f, 0.15115412f, -0.02704133f, 0.10706019f, 0.40030122f, -0.09311892f, 
    0.01369459f, -0.01630732f, -0.15116134f, -0.11531363f, 0.03118327f, 0.04515344f, -0.14704485f, 0.04009706f, 
    0.35069409f, 0.13134082f, 0.18940595f, 0.41161251f, 0.15851235f, -0.17497414f, 0.11636336f, -0.05669682f, 
    -0.04044939f, -0.18018973f, -0.09027034f, -0.07663697f, -0.37837982f, 0.05036377f, 0.07523691f, 0.08329178f, 
    0.09086595f, -0.20983747f, -0.14354551f, 0.06906090f, -0.06883539f, 0.05927951f, 0.13438587f, -0.06544852f, 
    0.00588147f, 0.39632270f, 0.11571592f, -0.03180978f, -0.36197907f, -0.00721933f, 0.25379756f, -0.08369358f, 
    -0.09985286f, 0.04842408f, 0.03243762f, -0.06479787f, -0.00622412f, -0.25929692f, -0.17636989f, 0.46036902f, 
    -0.59870487f, 0.16773586f, -0.05451639f, -0.21276212f, -0.16353562f, 0.10495387f, 0.01106249f, -0.01434641f, 
    -0.03250725f, 0.59553325f, 0.06225175f, 0.17492211f, -0.10838091f, -0.18241109f, -0.00518963f, 0.29256970f, 
    0.07334027f, 0.37570009f, -0.13829808f, -0.17857260f, 0.19436118f, -0.01157915f, 0.17003545f, 0.05338937f, 
    -0.08638287f, -0.03819923f, -0.12796636f, 0.22454630f, -0.03953937f, 0.32504520f, -0.12328667f, -0.19070607f, 
    -0.12578185f, -0.08286450f, -0.05525642f, 0.36241794f, 0.36890000f, -0.13100237f, 0.17757575f, 0.01440832f, 
    -0.11833812f, -0.07073394f, 0.06340172f, 0.15993813f, -0.14356922f, 0.13701271f, 0.49301511f, -0.10665800f, 
    0.05318463f, -0.12661837f, 0.07214648f, 0.08226205f, -0.44540128f, 0.04591210f, -0.04106512f, -0.06226413f, 
    -0.07093294f, -0.30915660f, 0.28196067f, -0.20136702f, -0.13396400f, -0.16879216f, 0.10137425f, -0.19926496f, 
    0.17014252f, -0.13751103f, 0.14623900f, 0.13123612f, 0.10576992f, -0.02082835f, 0.31877735f, 0.20818229f, 
    0.07567407f, 0.21794915f, -0.15272912f, -0.11546192f, 0.07421387f, -0.05615127f, 0.16304512f, 0.34360906f, 
    0.02289499f, -0.09277497f, 0.19394408f, 0.09564824f, -0.34734499f, -0.13599125f, -0.09918597f, 0.13977450f, 
    -0.23776099f, -0.27101994f, -0.02442150f, 0.16856535f, 0.10479025f, -0.54762602f, 0.02412684f, 0.35890469f, 
    0.03710132f, -0.12719591f, 0.03678218f, 0.18263197f, 0.02516898f, -0.11940847f, 0.33660698f, 0.27928856f, 
    -0.01692010f, 0.06907641f, -0.08936954f, -0.06581361f, -0.01174319f, -0.00561796f, 0.03060791f, -0.03421517f, 
    0.09186150f, 0.35290122f, 0.22571456f, -0.27207625f, -0.07301254f, -0.04400120f, -0.07833903f, 0.17269386f, 
    -0.09188846f, 0.12779543f, 0.04176657f, 0.09582461f, -0.12269244f, -0.13938065f, 0.06363080f, 0.24754891f, 
    0.13876092f, -0.12244354f, 0.06700546f, -0.32131636f, -0.17129199f, 0.09853400f, 0.09143461f, 0.20276219f, 
    0.16953170f, -0.43824843f, -0.10049540f, -0.13614565f, -0.12696734f, 0.32078150f, 0.11216888f, -0.26916766f, 
    0.08812752f, 0.31974953f, 0.24389885f, -0.19115931f, 0.25785458f, 0.07548258f, -0.22517686f, 0.15026787f, 
    -0.07406364f, -0.00796037f, 0.06220493f, 0.12369417f, -0.07926187f, -0.40776157f, 0.14507338f, 0.13544603f, 
    0.43114305f, -0.00488188f, 0.06424067f, -0.29446152f, 0.06560417f, -0.01425443f, 0.28004310f, 0.13110088f, 
    0.12906805f, -0.21250680f, -0.03491427f, -0.11652472f, -0.04302609f, 0.21740574f, -0.16927364f, 0.02265826f, 
    -0.05075848f, 0.21993229f, 0.23949453f, -0.35356647f, 0.05434177f, -0.10735913f, -0.04363679f, -0.13092457f, 
    0.10495570f, 0.31427360f, -0.28448346f, 0.03003036f, 0.03080438f, 0.25167850f, 0.11702433f, 0.17938387f, 
    -0.07855573f, 0.00677175f, 0.14787962f, -0.20770435f, 0.38280010f, -0.04916210f, -0.24001436f, -0.09747981f, 
    0.11892870f, -0.05910856f, -0.08315296f, -0.08921567f, -0.13884456f, 0.03071365f, -0.14357440f, 0.14378875f, 
    0.07890505f, 0.22691092f, -0.14479437f, -0.04751272f, 0.30771884f, -0.12482436f, 0.28585488f, -0.14492340f, 
    0.05788546f, -0.12667485f, 0.22885194f, -0.12917061f, 0.11208067f, 0.03223728f, -0.09451851f, 0.24626809f, 
    -0.33149102f, 0.01371668f, 0.14866936f, -0.00601014f, -0.30804390f, -0.01324667f, 0.08748927f, 0.10544065f, 
    -0.14890744f, 0.08740140f, 0.12556903f, 0.02595740f, 0.05948553f, 0.09585533f, -0.26251811f, 0.17782059f, 
    0.18683814f, -0.09791000f, 0.28308716f, 0.41858861f, 0.02919069f, -0.04923727f, -0.32688490f, 0.15645230f, 
    -0.12498578f, 0.21382977f, -0.19277920f, 0.29199263f, 0.08291689f, 0.25231901f, -0.16825385f, 0.20724501f, 
    -0.30419901f, -0.04042614f, -0.16580209f, -0.07465193f, 0.17020762f, 0.09084344f, -0.16445808f, 0.08646815f, 
    -0.09565286f, 0.46215865f, 0.00386061f, 0.00043803f, 0.08137368f, -0.10005739f, -0.04415018f, 0.27689040f, 
    -0.14662816f, -0.12650506f, -0.23922627f, 0.25707123f, -0.43939880f, -0.13456132f, 0.14284202f, 0.17358871f, 
    -0.47298381f, -0.11897195f, 0.10401095f, -0.09846193f, 0.01842462f, -0.03262124f, 0.13740234f, 0.21094529f, 
    0.15153034f, 0.12600277f, -0.15385562f, -0.00065966f, 0.26067072f, -0.07067688f, 0.12298167f, 0.38167852f, 
    0.13524632f, -0.09719883f, 0.04622118f, 0.05512997f, -0.03617392f, 0.30768505f, -0.07914610f, -0.13855113f, 
    0.06585256f, 0.11033066f, -0.04544365f, 0.09785706f, -0.08584747f, 0.02168006f, -0.32580441f, -0.01693440f, 
    -0.04337279f, 0.25306085f, 0.03569955f, 0.51404774f, 0.02813314f, -0.20485997f, 0.09938976f, 0.24770372f, 
    -0.06971259f, 0.12990057f, -0.09122409f, -0.35277957f, -0.39741305f, -0.04354583f, 0.01852664f, -0.19773377f, 
    0.09723797f, -0.11096113f, -0.17627911f, 0.04244907f, -0.07348309f, 0.08686240f, -0.04058477f, 0.18341345f, 
    -0.03586385f, 0.49246010f, 0.14489971f, -0.11219496f, 0.09506303f, -0.05209041f, 0.15879889f, -0.12848321f, 
    -0.16108280f, -0.06417105f, 0.39493954f, -0.12668133f, -0.03341010f, 0.23122802f, 0.13975000f, -0.24269116f, 
    0.21294890f, -0.01658892f, 0.01566536f, 0.08081917f, 0.23385002f, -0.12944777f, 0.22728388f, 0.38413718f, 
    0.14982720f, -0.19354321f, 0.10245945f, -0.13126412f, 0.12014959f, 0.41033587f, -0.00812572f, -0.05479075f, 
    0.19728322f, -0.12286493f, 0.01943794f, 0.12215298f, 0.03046435f, 0.06606729f, -0.28213584f, -0.01869887f, 
    -0.31373343f, 0.19974861f, -0.26545000f, -0.08882823f, -0.07842169f, -0.12470006f, 0.14283851f, 0.35410306f, 
    -0.36722541f, -0.08613315f, -0.14518750f, 0.06021113f, -0.10416198f, 0.14273050f, -0.03420102f, -0.04557135f, 
    -0.04955049f, 0.43065274f, -0.07102134f, 0.11121226f, -0.11011886f, 0.26187095f, 0.12676120f, -0.07321940f, 
    0.11489640f, 0.25063974f, -0.23719884f, -0.01389370f, 0.47964877f, 0.13112047f, -0.23844704f, -0.08665609f, 
    0.35729152f, 0.14858338f, 0.23929000f, 0.23446259f, -0.00590948f, -0.13388489f, -0.01474027f, 0.30899805f, 
    -0.16197167f, -0.11307963f, -0.15922017f, -0.18486153f, -0.43305203f, -0.05249117f, 0.19826733f, -0.12575524f, 
    -0.13817137f, -0.03234391f, -0.05147311f, -0.11743824f, -0.10318887f, 0.32680205f, 0.12623344f, -0.20500517f, 
    0.03865943f, -0.08157628f, 0.20279863f, 0.00869168f, 0.33673602f, 0.15985164f, -0.36440668f, 0.05378347f, 
    -0.29128352f, 0.09043965f, -0.17405930f, -0.14203729f, -0.16359922f, -0.20036048f, -0.14859200f, 0.29941034f, 
    -0.28671926f, -0.09302789f, 0.03137636f, 0.31892669f, -0.12946577f, -0.13181357f, 0.15599863f, 0.13203484f, 
    -0.11931645f, -0.02877698f, 0.12756065f, 0.06871515f, -0.18067744f, 0.08011562f, 0.14230745f, -0.19851431f, 
    -0.01601668f, 0.23342037f, 0.20163202f, -0.19217488f, 0.59205633f, 0.14156966f, 0.02593825f, -0.07198511f, 
    0.18445709f, 0.19487152f, -0.19503011f, 0.37932456f, 0.03634678f, 0.06368507f, -0.11604952f, -0.26634502f, 
    -0.17021784f, 0.15563071f, 0.17817134f, 0.41235611f, 0.42721257f, -0.04064225f, -0.19830449f, -0.29855007f, 
    0.07105940f, -0.13874342f, -0.12037981f, 0.12079726f, 0.11381634f, -0.21212308f, 0.26704243f, 0.14652871f, 
    -0.07408238f, 0.17266510f, -0.13624197f, -0.13899359f, 0.21981199f, -0.11982781f, 0.46245044f, 0.06845526f, 
    -0.39359805f, -0.25347090f, -0.09924220f, -0.33911008f, 0.12369965f, -0.01462658f, -0.08375482f, 0.18265891f, 
    0.17786947f, -0.16182923f, 0.10110112f, -0.37939113f, 0.20582856f, 0.05085180f, 0.31400812f, 0.40905267f, 
    -0.02446098f, 0.50391841f, 0.05718757f, 0.00753124f, -0.08151658f, 0.06028560f, -0.30504221f, 0.17845906f, 
    -0.10351024f, 0.26072717f, 0.17638513f, -0.09267545f, -0.06468719f, -0.07395566f, 0.02609789f, -0.12808870f, 
    0.43867105f, 0.21362038f, 0.16401470f, 0.34840590f, 0.04346047f, -0.13541929f, 0.16270147f, 0.06986647f, 
    -0.19458279f, -0.09085862f, 0.10181884f, 0.04568596f, 0.05778352f, -0.01167356f, 0.05021110f, -0.15003002f, 
    0.12161584f, 0.15761295f, 0.05495475f, -0.05755342f, 0.09723994f, -0.22306038f, 0.16968742f, 0.14846025f, 
    0.10802404f, -0.35229868f, 0.12029254f, -0.08959953f, -0.23163629f, -0.02427553f, 0.00212437f, 0.14487833f, 
    0.15235028f, -0.19645360f, 0.04482401f, -0.23211436f, 0.01916514f, -0.27326691f, -0.03830054f, 0.31810150f, 
    0.29688063f, -0.15145308f, -0.00143908f, -0.04884266f, -0.00112366f, 0.16902930f, 0.09732761f, -0.10207281f, 
    0.05764948f, 0.14848429f, 0.16921587f, 0.05237415f, 0.03053959f, 0.00242318f, 0.24363826f, 0.11765746f, 
    -0.04286208f, 0.38837340f, 0.10096069f, -0.11402564f, 0.13027295f, 0.16702487f, 0.09739891f, 0.05956730f, 
    0.18630619f, -0.02412282f, 0.18016005f, 0.34469780f, -0.00114530f, 0.24278486f, 0.00717067f, 0.21860921f, 
    0.30396697f, 0.12933731f, 0.09186932f, -0.40428466f, -0.26156241f, 0.10516302f, -0.23173857f, -0.03996638f, 
    -0.17112048f, 0.31076688f, -0.02533012f, -0.02134662f, 0.13719447f, 0.12203255f, 0.02741452f, 0.09445597f, 
    -0.16806398f, -0.00879371f, 0.00552017f, 0.12007542f, -0.04179616f, 0.09536068f, 0.19106302f, 0.12783703f, 
    0.05318368f, 0.01431703f, -0.00911097f, -0.13886319f, 0.13597356f, -0.04630816f, 0.03187159f, -0.13344371f, 
    0.05281685f, -0.06714795f, -0.06069857f, 0.10329158f, -0.16711855f, 0.15989494f, -0.15074371f, 0.13392283f, 
    0.02120098f, -0.15616950f, 0.05623196f, -0.06011879f, -0.04520518f, -0.08336174f, -0.12348528f, 0.12594174f, 
    0.12224549f, -0.12563691f, -0.07632078f, -0.16683257f, -0.09936791f, -0.08257815f, -0.16888723f, 0.03151149f, 
    0.14109358f, -0.04337707f, -0.13731778f, -0.00043913f, -0.15007420f, 0.00152129f, -0.07380774f, -0.16767685f, 
    0.03162481f, 0.00462437f, -0.16274925f, -0.15365322f, -0.08614257f, -0.04821507f, -0.02237113f, -0.13737583f, 
    0.07539198f, 0.07016489f, -0.16360685f, 0.15912394f, -0.14057116f, 0.00144416f, -0.05974632f, -0.06589266f, 
    0.02691548f, -0.11756990f, 0.01110467f, 0.00573523f, 0.05628564f, 0.07820478f, -0.11112770f, -0.11237159f, 
    -0.30133662f, 0.23585056f, -0.04392318f, 0.00746514f, -0.05912499f, 0.26063582f, 0.02549263f, -0.34404346f, 
    0.23367293f, -0.06905058f, -0.01144236f, 0.29883674f, 0.44300976f, 0.12123571f, -0.19342627f, 0.00181499f, 
    -0.08214381f, 0.20259082f, -0.01717490f, 0.03969010f, 0.02774887f, -0.14694726f, 0.29948843f, 0.12101199f, 
    0.00396921f, -0.11785176f, 0.12549505f, -0.14006504f, -0.09540788f, 0.00655683f, 0.16708140f, 0.02829361f, 
    0.11018367f, -0.28982651f, 0.23552345f, 0.07584599f, -0.05324394f, -0.16854994f, -0.08206218f, -0.06045928f, 
    -0.24055290f, 0.07573622f, -0.02720348f, 0.07780057f, -0.22737369f, -0.04799904f, 0.10270444f, 0.16052881f, 
    -0.16285028f, -0.27084228f, -0.12565571f, -0.14249592f, 0.05156393f, 0.02920541f, -0.14059171f, 0.23164319f, 
    0.12693210f, 0.46973330f, 0.16127610f, -0.11168516f, -0.17018208f, 0.11670024f, 0.04994430f, -0.14611880f, 
    0.33035684f, -0.00826490f, 0.15059789f, 0.39068472f, 0.01921467f, -0.32978624f, -0.03441175f, 0.45840457f, 
    0.20538555f, -0.15108427f, 0.07605868f, -0.10155580f, -0.24867858f, -0.12074149f, 0.20939024f, -0.07408009f, 
    0.17970149f, -0.33737645f, -0.06086438f, 0.11424809f, 0.17252520f, 0.12355997f, -0.00229998f, 0.16850318f, 
    0.03109875f, 0.18865652f, 0.09616641f, -0.17423703f, -0.01219922f, -0.06685480f, -0.12957488f, 0.13583258f, 
    -0.14921071f, -0.04940088f, -0.23065613f, -0.03046978f, 0.11151467f, 0.15814391f, 0.12822708f, -0.03484700f, 
    0.08754116f, -0.06573610f, -0.03359322f, -0.26255089f, 0.37182432f, 0.02583560f, -0.07783497f, 0.18345632f, 
    -0.09589695f, 0.02551891f, 0.03043427f, -0.08623628f, 0.13576069f, -0.19943531f, -0.02204357f, 0.27275294f, 
    -0.05286495f, 0.15013328f, 0.10928448f, -0.11996862f, 0.10233617f, -0.07807392f, 0.32685208f, -0.01999294f, 
    -0.04611659f, 0.19470572f, -0.05494496f, 0.33501860f, 0.08983250f, 0.35848922f, 0.05850367f, 0.14922293f, 
    -0.39824697f, -0.02787401f, 0.10378871f, -0.17253734f, -0.01836995f, 0.00000510f, 0.02162573f, -0.08200130f, 
    0.07550683f, 0.14372191f, 0.10324246f, -0.12859704f, 0.10946900f, -0.08342572f, -0.21786395f, 0.18247975f, 
    -0.00854937f, 0.03188629f, -0.22144580f, -0.01836798f, 0.23425464f, 0.08100788f, 0.05986087f, -0.04443295f, 
    0.41819093f, 0.17229943f, 0.13879338f, -0.13610928f, 0.12664536f, 0.12532815f, -0.00189532f, 0.27540696f, 
    0.24468720f, -0.02378571f, 0.03158771f, -0.28687838f, 0.19778509f, -0.00402253f, -0.20017257f, -0.18506593f, 
    0.13678478f, -0.32472426f, -0.03822546f, -0.01608387f, -0.06812429f, 0.31091493f, 0.10644185f, -0.17482266f, 
    0.09696945f, 0.11525396f, 0.18246379f, -0.19915700f, 0.47176039f, 0.05804824f, 0.10553572f, 0.06677017f, 
    -0.24165669f, 0.36187193f, 0.03632523f, 0.35667831f, 0.15102592f, 0.24213032f, -0.00314210f, 0.33645308f, 
    -0.11960226f, -0.05240640f, 0.02362268f, -0.23421495f, -0.06841452f, -0.13194931f, 0.03922453f, -0.14087394f, 
    -0.16654676f, 0.18612190f, -0.18794620f, -0.07407903f, 0.04237975f, 0.22442302f, 0.39197561f, 0.00974301f, 
    -0.07829580f, -0.24237421f, -0.25458628f, 0.11070435f, 0.00017636f, 0.11172286f, -0.16967534f, 0.12540786f, 
    0.10623979f, -0.14797451f, 0.02697996f, 0.10633399f, 0.01209181f, -0.08556180f, 0.07433822f, -0.13138318f, 
    0.00391779f, -0.12091298f, -0.17165641f, -0.02617792f, -0.10995811f, -0.05739542f, 0.08484729f, -0.02120662f, 
    -0.16387084f, 0.09661913f, 0.12780060f, -0.10056197f, -0.12028909f, -0.17804565f, -0.13925691f, -0.16218805f, 
    -0.05645629f, 0.04981244f, -0.02659204f, 0.06969029f, -0.10202555f, -0.16970862f, -0.17326826f, 0.05943633f, 
    0.17840233f, 0.10717098f, -0.06711653f, -0.13911538f, -0.13743655f, 0.15580402f, 0.16254623f, 0.39081794f, 
    -0.26769474f, -0.01682112f, 0.05170899f, -0.12183068f, 0.16855948f, -0.16572033f, 0.29270220f, 0.21380444f, 
    -0.01864697f, -0.32509744f, -0.02895864f, 0.03391269f, -0.04082507f, -0.03867743f, 0.11230657f, -0.18784209f, 
    -0.04471710f, 0.11736681f, 0.16689463f, -0.11540740f, -0.09074427f, 0.15157202f, -0.30684546f, 0.08781040f, 
    -0.06555066f, 0.00256126f, 0.39117220f, 0.42048210f, -0.17695370f, 0.01590721f, 0.15486924f, 0.11538860f, 
    -0.29608622f, 0.03460454f, 0.03403007f, -0.11597639f, -0.01804295f, -0.13557766f, 0.29744816f, 0.01634150f, 
    0.03805289f, -0.35718861f, 0.09769520f, 0.14847060f, -0.14446642f, 0.17863907f, 0.31990993f, 0.09640040f, 
    0.12073724f, -0.16796172f, -0.08362320f, 0.29619449f, -0.13974549f, -0.11564703f, -0.13710493f, -0.10571677f, 
    0.22877537f, -0.17360887f, -0.09985921f, -0.34596470f, -0.07928476f, 0.16596469f, 0.14370458f, 0.18947190f, 
    0.24279089f, 0.07803282f, -0.07345233f, 0.15221353f, -0.01536356f, -0.13738459f, -0.20011847f, -0.18304200f, 
    -0.09143066f, -0.01708131f, -0.06726348f, 0.02170177f, 0.15319106f, 0.07939572f, -0.31957871f, 0.24380751f, 
    -0.04883964f, 0.26959926f, 0.22447821f, 0.21621257f, 0.26769248f, 0.12867612f, 0.15210325f, -0.15714744f, 
    0.11606040f, 0.23949781f, -0.25218415f, 0.29137331f, 0.11704057f, -0.08881519f, -0.05754524f, 0.26292890f, 
    0.11034569f, -0.07821789f, 0.06786646f, 0.15856369f, 0.06570636f, -0.05188481f, 0.10334466f, -0.27068865f, 
    0.11389848f, -0.12656279f, 0.16074635f, 0.15483983f, -0.14319436f, -0.08826966f, 0.20046470f, 0.19320171f, 
    -0.08360891f, 0.32000738f, -0.21849805f, -0.14791922f, 0.16285534f, -0.08896091f, 0.30621293f, 0.11934067f, 
    0.33165002f, 0.07174727f, 0.03796276f, -0.29076126f, -0.11810523f, -0.33211660f, 0.10691267f, 0.08972704f, 
    -0.31020045f, -0.09781834f, -0.03984077f, 0.42849448f, 0.17966837f, -0.08461370f, 0.16366500f, -0.00752308f, 
    0.16271567f, 0.10931045f, 0.03345368f, 0.16015053f, -0.04145916f, 0.02297411f, 0.17841220f, -0.06707916f, 
    0.09383809f, -0.20694771f, 0.11477868f, 0.08903421f, 0.33279967f, 0.15307038f, -0.02900142f, -0.16606341f, 
    0.24690332f, -0.03694652f, 0.24497029f, -0.04831326f, -0.14089581f, -0.32574964f, -0.15957114f, 0.09152872f, 
    -0.08497062f, 0.03975470f, 0.02096943f, 0.04701683f, 0.02589642f, 0.02953719f, 0.15357259f, -0.11829760f, 
    -0.05302981f, -0.66981965f, -0.01362793f, 0.00750376f, -0.02644405f, 0.00801458f, -0.02740358f, 0.08723203f, 
    0.07903215f, 0.47040543f, 0.22517326f, -0.01564196f, 0.25614545f, -0.03361081f, 0.08826162f, 0.17647189f, 
    0.26558766f, 0.04577496f, -0.13450213f, -0.17502192f, 0.01127072f, -0.14828157f, -0.02536615f, 0.42849755f, 
    -0.54912823f, -0.11382466f, -0.06419580f, -0.03644067f, 0.06307945f, 0.06272393f, 0.12745555f, 0.15475754f, 
    -0.07748188f, 0.28957823f, -0.17641987f, 0.08226413f, -0.04840057f, 0.03535639f, -0.23044789f, 0.07457855f, 
    0.05388733f, 0.11037660f, 0.16884579f, 0.03229026f, 0.09249499f, 0.02272008f, -0.14397228f, 0.10237518f, 
    0.31338924f, 0.37028128f, -0.05791857f, 0.40882477f, -0.11585625f, 0.29070219f, 0.02928825f, 0.12633260f, 
    -0.29676551f, 0.17499430f, -0.11639103f, -0.22863238f, 0.29957774f, 0.03399647f, -0.09164717f, 0.05008175f, 
    -0.08990704f, -0.19457920f, -0.09773953f, -0.14878601f, 0.03046353f, -0.09415414f, 0.30891559f, 0.00349613f, 
    -0.13777967f, -0.40704641f, -0.07146692f, -0.05252380f, -0.01798950f, -0.04833931f, 0.11688129f, 0.00639814f, 
    0.32566708f, -0.12688838f, 0.15151803f, -0.45553526f, 0.01180931f, 0.34187725f, 0.10157702f, -0.26243809f, 
    0.20154800f, -0.15841016f, -0.11224907f, 0.18134001f, 0.22068045f, 0.00625527f, -0.01023918f, -0.04645831f, 
    0.04967400f, -0.09847627f, -0.10329521f, -0.10964596f, -0.03524897f, 0.18962148f, 0.03807293f, -0.02552387f, 
    -0.08688557f, -0.09807300f, 0.25543660f, 0.30522457f, 0.46115890f, -0.11548108f, 0.04280407f, 0.15936339f, 
    -0.11342124f, 0.30077976f, 0.24579634f, 0.31039634f, -0.14798622f, -0.02418967f, -0.09016420f, 0.04426049f, 
    -0.37081370f, 0.17503177f, -0.08546788f, -0.05577802f, -0.15786092f, -0.01555674f, 0.27508575f, -0.13487872f, 
    0.00590226f, -0.08990319f, -0.19423467f, -0.09342968f, -0.06352130f, 0.18508109f, 0.20993283f, 0.15039708f, 
    -0.00859793f, -0.30794993f, -0.03911590f, -0.02871540f, -0.21135809f, 0.00446786f, 0.05863563f, -0.07695283f, 
    0.31959730f, -0.16425097f, 0.06292327f, 0.08297420f, 0.16618080f, -0.14378937f, 0.07796840f, 0.10427648f, 
    0.12826507f, 0.10828716f, 0.14300069f, -0.04367970f, -0.01095567f, 0.16027519f, -0.14309511f, -0.11167933f, 
    0.10192014f, 0.42299795f, 0.02483376f, 0.09571050f, -0.12089646f, 0.03308083f, 0.08058289f, 0.19307189f, 
    0.08916920f, 0.08683562f, -0.02154230f, -0.16821659f, -0.31086460f, 0.10369518f, 0.10142359f, 0.04253738f, 
    0.32769969f, -0.07749456f, 0.50691777f, 0.28582445f, -0.15287547f, -0.08215109f, 0.07044680f, -0.00580245f, 
    0.00894109f, -0.03346037f, -0.11830846f, -0.14699838f, -0.28350466f, -0.06556857f, -0.05109863f, 0.15430821f, 
    0.09239180f, -0.10730737f, 0.12376178f, 0.05712361f, -0.05949299f, 0.26929465f, 0.20145270f, -0.01207463f, 
    0.13288824f, -0.07770235f, -0.03458640f, 0.32617420f, -0.02901179f, 0.15789016f, -0.06111433f, 0.13275503f, 
    0.09539400f, 0.29434863f, -0.10764273f, -0.30870169f, -0.12126195f, 0.36565578f, 0.05832649f, -0.28646725f, 
    0.15097356f, -0.13823177f, 0.17772919f, 0.42207924f, 0.27473733f, -0.05714777f, -0.17333692f, 0.02770705f, 
    0.14827210f, 0.13493839f, 0.10703960f, 0.07001614f, 0.05395885f, -0.22088327f, 0.30692735f, 0.12291440f, 
    0.15890507f, -0.39555389f, 0.10904151f, -0.03552919f, 0.24660704f, 0.16710645f, 0.18310215f, 0.14429218f, 
    0.19994614f, -0.04371600f, -0.01915500f, -0.14754778f, 0.06738465f, 0.05184928f, 0.14455286f, 0.36831421f, 
    0.02565607f, 0.01438229f, 0.01095050f, -0.02136453f, 0.40815702f, -0.07460986f, 0.08767628f, 0.16267136f, 
    0.01229828f, 0.18876354f, 0.00670025f, -0.04333078f, 0.00890703f, -0.03096323f, -0.04214975f, -0.01190829f, 
    0.13456191f, -0.05304933f, 0.09930038f, -0.30634901f, 0.06174850f, 0.13335423f, 0.08632248f, 0.01886813f, 
    -0.07379263f, -0.05945703f, 0.01671215f, 0.00482797f, 0.05160061f, 0.03477056f, 0.15150553f, -0.09250644f, 
    0.04287442f, 0.03632646f, -0.05213863f, -0.09435313f, -0.04785654f, -0.08623934f, 0.11952566f, -0.16270758f, 
    0.14670657f, -0.17127123f, 0.07088681f, 0.13263477f, -0.05036112f, -0.02172593f, -0.02572537f, -0.09471267f, 
    0.12083420f, -0.13582742f, 0.14223152f, -0.13989066f, -0.03118274f, -0.09330595f, -0.02983050f, -0.01505239f, 
    0.29882851f, 0.23560080f, 0.13397585f, 0.34513175f, 0.08326984f, 0.21838160f, 0.13338034f, 0.24972522f, 
    -0.18244848f, 0.04568759f, -0.17968647f, -0.18109663f, -0.18103595f, -0.11873236f, 0.15219329f, 0.02067389f, 
    -0.01629005f, 0.10698801f, 0.08850963f, 0.15838638f, 0.10878072f, -0.02098052f, -0.05131313f, 0.21738294f, 
    -0.00061046f, -0.13869902f, -0.10593457f, -0.29510677f, -0.30494276f, -0.06520016f, 0.08468121f, 0.01716927f, 
    -0.16683841f, 0.14427459f, 0.23806964f, -0.27997366f, -0.10960618f, 0.31353143f, 0.05102470f, 0.14399216f, 
    -0.38619936f, -0.07531901f, -0.06746592f, -0.23021591f, -0.05595156f, -0.09888232f, 0.28776675f, 0.03223991f, 
    0.00197568f, 0.12181646f, -0.00788376f, -0.14534123f, 0.12024181f, -0.14544612f, -0.03821908f, 0.37850967f, 
    -0.08308785f, -0.24853100f, 0.05349568f, -0.16315705f, -0.32018343f, -0.04968224f, -0.21033038f, -0.15406775f, 
    0.13644303f, 0.10716194f, 0.08070076f, -0.00345056f, 0.08332237f, 0.08423283f, 0.00288475f, -0.19349556f, 
    -0.10709359f, -0.12729058f, -0.01759797f, 0.38243440f, 0.16586982f, -0.08592455f, 0.13338755f, -0.16365267f, 
    0.10199101f, -0.23685597f, -0.11746011f, 0.13015790f, 0.10589175f, -0.01575900f, 0.33430457f, -0.13323565f, 
    -0.00148485f, 0.07652358f, 0.16068099f, 0.17310503f, 0.19039673f, -0.08344016f, -0.05373679f, 0.05825257f, 
    0.19003120f, 0.22668225f, 0.31158388f, 0.36685252f, 0.13070540f, -0.06958701f, 0.14127026f, 0.08935428f, 
    -0.05496190f, -0.00357203f, -0.11737404f, 0.17604871f, -0.22664835f, 0.07961252f, 0.07182682f, -0.22947323f, 
    0.14553887f, -0.27041525f, -0.17328475f, -0.02091299f, -0.11781974f, 0.22931066f, 0.44493893f, -0.31001040f, 
    0.16472651f, -0.30510774f, 0.16306040f, 0.15098402f, -0.12882203f, -0.14964724f, -0.07334068f, 0.05815278f, 
    0.16308112f, -0.00684888f, -0.15195313f, -0.17848483f, 0.09419262f, 0.29538798f, -0.15357435f, 0.13834073f, 
    -0.18952698f, 0.13763821f, 0.16387826f, -0.16729595f, 0.35439301f, -0.05523612f, 0.00811319f, 0.11760997f, 
    -0.00069055f, -0.04918282f, -0.03854318f, 0.02525519f, -0.10547520f, -0.26288980f, -0.28425801f, 0.29422012f, 
    0.08690878f, 0.16431974f, 0.22388144f, 0.21357813f, -0.13832015f, 0.04990393f, 0.34337130f, 0.00390606f, 
    -0.06815089f, -0.03229120f, -0.19903231f, -0.00083554f, 0.15218858f, -0.37586647f, 0.04635858f, 0.03685459f, 
    -0.09626169f, -0.01407457f, 0.11119173f, 0.30345187f, -0.35199103f, 0.08738239f, 0.25323927f, 0.16922681f, 
    -0.02685480f, 0.10166053f, 0.04124721f, 0.01582898f, 0.07588599f, 0.18634218f, 0.23797274f, 0.10661530f, 
    0.09687423f, 0.29007310f, 0.12288081f, -0.01838383f, 0.30925474f, 0.05512588f, -0.36982566f, -0.05301838f, 
    -0.15497161f, -0.16959719f, -0.06600095f, -0.08921986f, 0.10692394f, -0.16386439f, -0.09436184f, 0.06410255f, 
    -0.07592575f, -0.16244926f, -0.11172830f, 0.04036947f, 0.06165766f, -0.12070830f, 0.09960464f, 0.07862876f, 
    -0.00322130f, 0.04336704f, -0.16340558f, -0.06494793f, 0.11217955f, -0.08396655f, -0.13753034f, -0.14687391f, 
    0.16363217f, -0.08261593f, -0.13742912f, -0.17188001f, -0.11674283f, -0.11928696f, 0.08656029f, -0.06073190f, 
    0.09542257f, 0.08965880f, 0.42280641f, 0.01135412f, -0.03250040f, -0.28239945f, 0.05174582f, -0.15194918f, 
    0.00772386f, 0.11043777f, 0.08287273f, 0.07037276f, -0.37327033f, -0.17897871f, 0.18144269f, -0.04814414f, 
    0.07847711f, -0.21537302f, 0.08475109f, -0.00510912f, 0.15144137f, 0.17865250f, 0.11456504f, 0.01584702f, 
    -0.05799154f, 0.33018968f, 0.24725708f, 0.15991031f, -0.20602769f, 0.15771349f, -0.07524154f, -0.03166434f, 
    -0.19076505f, 0.28702223f, 0.00408890f, 0.45453560f, 0.07265168f, -0.10250048f, 0.08042746f, 0.22040062f, 
    -0.07638375f, -0.10293057f, -0.02159501f, 0.10124256f, 0.16987133f, -0.15445641f, -0.11037092f, -0.06983172f, 
    -0.01939307f, 0.08939829f, -0.11420876f, 0.17433460f, -0.00912550f, 0.03265746f, 0.50272739f, -0.12957278f, 
    -0.00787867f, 0.10401603f, -0.11156484f, -0.25298086f, -0.25016001f, 0.08693556f, 0.30863774f, -0.01519187f, 
    -0.16908501f, -0.01193994f, 0.22580078f, 0.08472789f, -0.00920575f, 0.13650315f, 0.07544310f, -0.23565501f, 
    0.12315190f, 0.06979898f, 0.08450784f, 0.40431264f, -0.22356549f, -0.15232512f, 0.03321847f, -0.15686105f, 
    0.10119297f, 0.15452538f, 0.16912161f, -0.17592873f, -0.09638426f, 0.17651087f, 0.43470415f, -0.15922394f, 
    -0.02461304f, -0.24278636f, 0.08857814f, 0.14234425f, -0.05879587f, 0.16757391f, -0.36047062f, 0.06140669f, 
    0.18834029f, 0.34607142f, -0.38727790f, 0.03131656f, 0.11236028f, 0.11120621f, -0.08979254f, -0.11862262f, 
    -0.28243136f, 0.06147045f, -0.09730675f, 0.33798271f, 0.36185798f, 0.15668710f, -0.17855187f, 0.02246130f, 
    0.17148542f, 0.17520519f, -0.01647943f, 0.15273693f, 0.00084402f, -0.21326318f, 0.36548686f, -0.02309828f, 
    -0.06244306f, -0.20792703f, 0.10459311f, -0.24505413f, 0.25067896f, -0.03590541f, 0.36136401f, -0.17941168f, 
    -0.05523022f, -0.26675725f, 0.31481218f, -0.05892029f, -0.12195846f, -0.37917957f, 0.07678694f, 0.20442776f, 
    0.12386945f, -0.11793531f, 0.08902959f, -0.05848164f, -0.16281584f, -0.02791693f, 0.13425098f, 0.24678101f, 
    -0.10054235f, -0.21218580f, 0.02072767f, 0.15081868f, 0.02695944f, 0.27595285f, -0.08675223f, 0.06115687f, 
    0.08989690f, -0.09569567f, 0.36428863f, 0.03241133f, 0.08170557f, -0.11161891f, -0.07907007f, 0.11307006f, 
    -0.00973464f, 0.18810204f, -0.05531617f, 0.05684349f, 0.05410683f, -0.01462632f, 0.13067017f, 0.04575646f, 
    -0.43378997f, 0.01737672f, -0.03942573f, 0.22031882f, -0.29843229f, 0.01540431f, 0.24745488f, 0.24099703f, 
    -0.03756531f, 0.08442529f, 0.10765314f, -0.09214649f, -0.04950875f, 0.27208483f, -0.02826273f, 0.07207938f, 
    -0.10453299f, -0.24164397f, 0.02966205f, 0.15763232f, 0.34079707f, 0.11730170f, -0.40957567f, 0.06494065f, 
    -0.21716388f, 0.00857865f, -0.05374041f, 0.07408540f, -0.04558554f, 0.10469101f, 0.05450964f, -0.36932316f, 
    0.32357988f, -0.05029652f, -0.07635359f, 0.21159005f, 0.16213503f, -0.02086701f, -0.04763670f, 0.25257495f, 
    0.06838293f, -0.19836076f, 0.01724324f, -0.08098502f, -0.09584095f, -0.17153537f, -0.22319604f, 0.23105517f, 
    0.09195045f, 0.17213307f, -0.06394893f, 0.39861602f, 0.05198661f, 0.14453547f, 0.37303802f, -0.05528038f, 
    0.25530520f, 0.12699316f, 0.24168523f, 0.25341681f, 0.12547015f, 0.00087303f, 0.01601711f, 0.17649694f, 
    -0.51963675f, 0.05266741f, -0.08296731f, 0.01091686f, 0.14409688f, 0.02831471f, 0.31459573f, 0.04941816f, 
    0.04613632f, 0.01298448f, 0.12091452f, 0.03959295f, 0.02150817f, -0.25520709f, 0.19530463f, 0.30174530f, 
    0.13416496f, -0.35587430f, 0.06356331f, -0.05590352f, -0.55393660f, 0.06314451f, 0.00104898f, -0.05645695f, 
    0.32369027f, -0.08124911f, -0.04986842f, -0.27267551f, -0.16651461f, 0.09349229f, 0.14388379f, 0.11674974f, 
    0.30358881f, 0.11092950f, -0.14486434f, -0.01001113f, 0.34445879f, 0.08318226f, 0.14703409f, 0.22561996f, 
    -0.06467806f, -0.30027732f, -0.15127510f, 0.11859501f, 0.08306860f, -0.19171020f, -0.03819302f, 0.15287541f, 
    0.15336399f, -0.26212144f, 0.30090022f, -0.29099974f, -0.02640258f, 0.01185578f, 0.06848738f, -0.07819460f, 
    -0.00780010f, -0.06454795f, 0.16469578f, -0.19018357f, -0.05408994f, -0.32008839f, -0.14138037f, 0.30733484f, 
    -0.46726677f, -0.01171670f, 0.00860018f, 0.27641070f, -0.28334081f, -0.16140401f, 0.19142215f, 0.16298929f, 
    -0.05582413f, 0.26253724f, -0.06544136f, -0.13387798f, -0.08189663f, -0.15411879f, 0.04373749f, 0.13002914f, 
    0.12489747f, 0.05288116f, 0.15241744f, 0.34592724f, 0.08470266f, 0.00765393f, -0.21396138f, -0.12458235f, 
    -0.01735653f, -0.07073473f, -0.40029144f, -0.01608838f, 0.17105916f, -0.03994597f, -0.05729385f, 0.23344275f, 
    -0.17095238f, -0.08973523f, 0.14439054f, 0.15521421f, 0.27095434f, -0.07463408f, 0.24254721f, 0.01773601f, 
    0.15240289f, -0.18688048f, 0.04339721f, -0.11354224f, 0.09282157f, -0.07733577f, -0.09800460f, 0.28156087f, 
    -0.14745535f, 0.05662320f, 0.03665408f, -0.07094602f, 0.22269176f, -0.16840823f, 0.25969645f, 0.03284430f, 
    0.30692551f, 0.15124331f, 0.16567984f, -0.06613969f, 0.06338873f, 0.21309759f, 0.08481956f, -0.05692852f, 
    -0.27379879f, -0.08339994f, -0.15634680f, 0.24490607f, 0.07947370f, 0.14094940f, -0.07223523f, -0.12389096f, 
    0.00015837f, -0.25108165f, 0.06152243f, -0.09005419f, -0.12236089f, 0.17295824f, 0.10809130f, -0.08863266f, 
    0.00406780f, -0.18261385f, 0.27982891f, 0.22074357f, 0.31605893f, 0.14662893f, -0.07994273f, 0.11859485f, 
    -0.26091254f, -0.19360864f, -0.17197275f, -0.05558337f, -0.14367276f, -0.37990808f, 0.13695258f, 0.39013189f, 
    0.19801401f, -0.01266549f, -0.15021689f, 0.14377955f, -0.10761186f, -0.01099844f, 0.07839268f, 0.16666232f, 
    0.16373436f, 0.14707491f, 0.02705606f, 0.17572761f, -0.10801058f, 0.08564167f, -0.09396354f, 0.11994950f, 
    0.16990061f, 0.29189703f, 0.14060830f, -0.14650312f, 0.27415618f, 0.16140948f, -0.06252451f, 0.09081244f, 
    0.21693534f, -0.02950586f, -0.35309142f, 0.14812183f, -0.02143778f, -0.16440746f, 0.02995616f, 0.06554043f, 
    0.31944883f, -0.15319397f, 0.12249369f, -0.19473700f, 0.14933372f, 0.07526384f, -0.26771712f, -0.04299292f, 
    0.12597933f, 0.28762344f, 0.09833231f, -0.04873775f, -0.13990048f, -0.23353133f, 0.07255355f, -0.00755919f, 
    0.10037825f, 0.25193527f, 0.01221192f, -0.11269999f, -0.16686068f, 0.15331513f, 0.24976107f, -0.17426686f, 
    -0.12385029f, 0.27095190f, -0.06426432f, -0.11043258f, -0.02815280f, 0.02255713f, 0.01740204f, -0.02191012f, 
    0.35093546f, -0.10706388f, 0.05970754f, -0.01445120f, -0.09729867f, 0.14964855f, -0.20539688f, -0.20178962f, 
    0.18681812f, 0.15958606f, -0.11709023f, -0.11333138f, -0.01663206f, 0.25890806f, 0.07725002f, 0.01454002f, 
    0.15148266f, 0.58970731f, -0.10961020f, -0.22503439f, 0.59918272f, 0.14752099f, 0.29228118f, 0.05886393f, 
    0.12012847f, 0.07413305f, 0.22992082f, -0.11190628f, 0.01162903f, -0.11999005f, 0.08852587f, 0.02884260f, 
    -0.18046671f, -0.05587780f, 0.01734156f, -0.39889511f, -0.23719577f, 0.02757611f, -0.00476925f, 0.06829517f, 
    -0.09249852f, -0.03712484f, -0.04621472f, -0.17055026f, 0.08334450f, 0.40088218f, -0.30078334f, 0.15982355f, 
    -0.12968735f, 0.08254372f, 0.06841507f, 0.25858125f, 0.10506948f, -0.13297518f, -0.35309780f, 0.16304460f, 
    -0.29468226f, 0.05145140f, -0.10274356f, -0.02566985f, -0.17033663f, 0.49579149f, 0.02552219f, 0.01037565f, 
    0.37564179f, -0.01626657f, 0.17480345f, -0.41417095f, -0.02371170f, -0.11945988f, -0.05790731f, 0.37547037f, 
    -0.11676123f, -0.13460936f, -0.06862701f, -0.18120040f, -0.09781338f, 0.28336787f, -0.32067394f, -0.25148383f, 
    0.01809189f, 0.08229158f, 0.26177636f, 0.11965935f, 0.35893631f, 0.06704921f, -0.02451457f, -0.02239528f, 
    -0.30775657f, 0.03776221f, -0.13073616f, 0.23209476f, -0.04253329f, -0.44033152f, -0.11554471f, 0.12163177f, 
    -0.09481276f, -0.04899729f, -0.12967128f, 0.44752994f, -0.27025029f, 0.10233685f, 0.19227378f, 0.10184552f, 
    -0.06931439f, -0.10323819f, 0.08624167f, 0.00936506f, 0.05822180f, 0.17003115f, 0.15949202f, 0.07191255f, 
    -0.00047682f, 0.36778408f, -0.00919687f, 0.14872819f, 0.33017907f, -0.07371166f, 0.06140609f, 0.14596124f, 
    -0.18913104f, 0.10445320f, -0.01051773f, 0.28923419f, -0.00045198f, 0.19106944f, -0.01437261f, -0.25934985f, 
    0.05146480f, 0.16830897f, -0.03609314f, 0.29468262f, -0.00909546f, 0.12479962f, 0.15715326f, 0.00237854f, 
    -0.17335650f, -0.27926511f, 0.05694832f, 0.00770558f, -0.00867513f, 0.22691433f, 0.38540986f, -0.15764737f, 
    0.08053063f, 0.27588865f, -0.14433101f, 0.06053852f, 0.28753045f, 0.11363126f, 0.31558588f, -0.06250559f, 
    0.08047374f, -0.13071094f, 0.08931440f, 0.10502873f, 0.06678782f, -0.07866590f, 0.10331060f, -0.13691625f, 
    -0.04248026f, -0.00567731f, -0.10030401f, -0.09224808f, -0.17005195f, -0.10857599f, -0.12322668f, 0.07025862f, 
    -0.15999329f, -0.15430108f, -0.05790109f, -0.16429444f, 0.02205247f, -0.04495743f, -0.10404262f, -0.08195170f, 
    -0.01106689f, -0.13747782f, -0.01665767f, -0.00443320f, -0.16056879f, -0.05463418f, -0.17130108f, -0.06636082f, 
    0.10211252f, -0.23159124f, -0.04971211f, -0.02440293f, 0.11886144f, -0.00971976f, 0.16018166f, 0.16105215f, 
    0.46265933f, -0.11665474f, 0.10286575f, -0.37742558f, 0.05536122f, -0.01702296f, 0.06952033f, -0.00365236f, 
    -0.15859994f, 0.46274003f, 0.12080135f, -0.13435267f, -0.15814081f, -0.13021101f, -0.34120870f, 0.33066353f, 
    0.10259710f, -0.15540573f, 0.22484817f, 0.13426553f, -0.45828715f, -0.17368951f, 0.31051141f, 0.15489723f, 
    -0.39220497f, -0.20882878f, 0.00383243f, 0.12926209f, 0.02191905f, -0.03425369f, 0.08429424f, -0.26434317f, 
    0.58384967f, -0.06806426f, 0.10124540f, -0.04537120f, 0.12712532f, -0.01665394f, 0.13424920f, 0.12808080f, 
    0.07539063f, 0.05345061f, 0.04450471f, 0.10929117f, -0.08771606f, 0.16875111f, -0.00959366f, 0.01110114f, 
    -0.06515204f, 0.47064015f, 0.01944464f, 0.32023564f, -0.22419575f, 0.00139791f, 0.24729151f, -0.03144830f, 
    0.23082741f, -0.13019422f, 0.01220728f, -0.06670909f, 0.15304083f, 0.07180730f, -0.05830200f, 0.18045720f, 
    -0.37661266f, 0.09189189f, 0.04931043f, -0.10740845f, -0.32238269f, -0.10437307f, 0.29911521f, 0.19117261f, 
    -0.11348051f, -0.20894210f, -0.11757308f, 0.04582363f, -0.11012837f, 0.01503377f, -0.23174818f, 0.15692496f, 
    0.17257451f, -0.01137116f, 0.30540633f, -0.03157946f, 0.23991074f, 0.05624440f, -0.26657167f, 0.12885082f, 
    0.33956116f, 0.09103021f, 0.15297017f, 0.29288480f, 0.03382977f, 0.14793274f, 0.02669798f, 0.10763054f, 
    -0.46247041f, 0.07316759f, -0.05746672f, -0.00730048f, 0.16929947f, -0.07195576f, -0.04891739f, -0.28225654f, 
    -0.17370287f, 0.08859029f, 0.11499815f, 0.00510552f, -0.06669566f, -0.03261328f, 0.01904969f, 0.22933652f, 
    0.05184869f, -0.03427628f, 0.04159329f, -0.15714313f, -0.24941225f, -0.01976890f, 0.25883180f, 0.01382932f, 
    -0.15970474f, -0.23660655f, 0.07689230f, 0.23366453f, -0.06090731f, -0.14648539f, -0.02607851f, -0.03268250f, 
    0.40440091f, -0.06677800f, 0.07616381f, -0.12551245f, -0.09454404f, -0.05670505f, 0.33628809f, 0.29341465f, 
    0.02064986f, -0.18419345f, -0.10752225f, 0.01857888f, 0.14319363f, 0.34697536f, -0.27809104f, -0.09726752f, 
    -0.13314331f, 0.32609010f, 0.24697600f, 0.12029634f, -0.06217860f, -0.13598545f, -0.25138876f, -0.06355001f, 
    0.22877963f, -0.00274961f, -0.10227735f, 0.29363039f, 0.10295967f, 0.26689568f, -0.15025347f, 0.17550106f, 
    0.08273809f, 0.01695614f, 0.08596274f, 0.33509752f, 0.08805207f, -0.05759584f, 0.07034012f, -0.20273830f, 
    -0.14451267f, -0.14765783f, 0.03294179f, 0.14208305f, 0.01337882f, 0.13974054f, 0.60729992f, -0.23547654f, 
    0.16890077f, -0.23215207f, 0.10917521f, 0.12971218f, -0.49167129f, 0.07376019f, -0.27660567f, 0.12137078f, 
    -0.44916505f, -0.19380625f, -0.18911707f, 0.21502489f, 0.14421099f, 0.03515191f, -0.03412009f, 0.13579606f, 
    -0.39495471f, 0.07433765f, 0.05014098f, 0.22500442f, -0.08730265f, -0.05507942f, 0.24626949f, 0.13343874f, 
    0.10420571f, 0.44217369f, 0.15543988f, -0.01205345f, 0.00661749f, -0.00120609f, -0.02918892f, 0.16772121f, 
    0.05420222f, 0.18517925f, 0.04785233f, 0.03084539f, -0.07879008f, 0.16419010f, 0.25599337f, -0.03770240f, 
    -0.05812413f, 0.08986146f, 0.14283518f, 0.32051790f, -0.17629820f, 0.32530561f, -0.03885419f, -0.23765440f, 
    0.08476745f, -0.06096974f, 0.08779587f, -0.17376405f, -0.13677940f, -0.16132984f, 0.03898848f, 0.12873338f, 
    0.02056848f, -0.29086614f, -0.15239377f, 0.08250742f, -0.00862202f, 0.35150766f, 0.24377890f, -0.11960994f, 
    0.00186492f, 0.00130941f, -0.07759693f, 0.02587852f, 0.26893049f, -0.00953115f, -0.02131345f, -0.11510799f, 
    -0.07486542f, 0.00040701f, 0.02381898f, 0.07062554f, 0.00832282f, 0.03786260f, -0.12958471f, -0.15051998f, 
    -0.16528212f, -0.11155737f, -0.09465982f, -0.09732048f, -0.09912713f, 0.14938819f, -0.08843983f, -0.16676760f, 
    0.02068148f, -0.02542747f, 0.08480044f, -0.14998990f, 0.15880182f, -0.16189595f, -0.16373219f, -0.07938068f, 
    0.14887093f, -0.15596917f, -0.04503262f, -0.09715337f, -0.11001712f, -0.13519238f, -0.07981844f, 0.06542373f, 
    -0.18618324f, -0.22425888f, 0.22506662f, -0.39581060f, 0.10857987f, 0.28874874f, -0.00576129f, -0.09453888f, 
    0.10593370f, -0.07607687f, -0.14285102f, 0.20579313f, 0.27356786f, 0.00809199f, 0.17991552f, 0.19454230f, 
    0.04605698f, 0.11669027f, 0.17360863f, -0.03458858f, 0.08332454f, 0.20165604f, 0.02201313f, 0.10840223f, 
    0.19738300f, -0.24203269f, 0.27308208f, 0.12098108f, 0.10145425f, 0.13753597f, -0.36734822f, 0.05197310f, 
    -0.03704944f, 0.24588527f, -0.21726541f, 0.31340048f, 0.04655610f, -0.01086453f, 0.01425016f, 0.15129644f, 
    -0.09042552f, -0.09607599f, 0.06326513f, -0.25750479f, 0.30299008f, 0.09835480f, 0.04269867f, 0.05812699f, 
    0.13109234f, -0.07205726f, -0.11295368f, -0.01963088f, 0.13573922f, 0.00878047f, 0.30042663f, -0.12132732f, 
    0.04406967f, 0.03450702f, -0.21770860f, -0.10441725f, 0.15994690f, 0.17153762f, 0.21698910f, 0.08563808f, 
    0.19275624f, -0.01982307f, -0.03369825f, 0.18860579f, 0.02439204f, 0.19538505f, 0.03582537f, -0.24363150f, 
    -0.12256150f, 0.10821249f, -0.01414117f, 0.31177634f, -0.05395596f, 0.04178930f, -0.17960265f, -0.21406005f, 
    0.00568194f, 0.33918557f, 0.12363987f, -0.03903778f, -0.06466207f, -0.12533067f, 0.08074700f, 0.29453102f, 
    0.16005555f, 0.13277200f, 0.10819105f, 0.35590446f, -0.17170647f, 0.07022476f, 0.11405995f, 0.15364935f, 
    -0.16457474f, 0.18584815f, 0.44620547f, 0.12879659f, 0.15797628f, -0.12241887f, 0.04655216f, 0.00341314f, 
    0.25079903f, 0.14819683f, 0.06908987f, -0.19728318f, -0.27305326f, -0.07500178f, 0.02376101f, -0.16813429f, 
    0.15271798f, -0.53078711f, 0.13311513f, 0.02571814f, -0.05779812f, 0.36504921f, 0.23160017f, -0.06442746f, 
    -0.12895019f, 0.09018903f, 0.00549481f, 0.02368431f, -0.10457188f, 0.15952790f, 0.13725589f, -0.02869764f, 
    -0.22591798f, 0.05567423f, 0.05599650f, 0.19841847f, -0.17597784f, 0.20981386f, 0.15774274f, -0.32565227f, 
    0.30609345f, 0.13819906f, -0.12435969f, -0.42337668f, 0.50414819f, 0.06992739f, -0.01549596f, 0.19523209f, 
    0.13177559f, 0.13769493f, 0.03299424f, 0.00445769f, 0.12692648f, 0.03349772f, -0.31721315f, 0.00130532f, 
    -0.09697409f, -0.04123452f, -0.19044060f, -0.05863866f, 0.10496230f, 0.09144330f, 0.49200821f, -0.17793113f, 
    0.38971740f, -0.12479186f, -0.01394980f, 0.32802585f, 0.10094038f, -0.34587318f, -0.10772939f, -0.31861436f, 
    0.02005047f, -0.14815682f, 0.07880493f, 0.35183102f, 0.27046809f, -0.05769197f, 0.05011998f, -0.00604832f, 
    0.16588739f, -0.28618774f, -0.02777391f, 0.16109696f, -0.13264771f, -0.22420748f, 0.13594000f, 0.25376394f, 
    0.08700842f, 0.03775579f, 0.19612658f, 0.21525510f, -0.20174207f, 0.10044216f, 0.45669487f, 0.16275413f, 
    -0.18442301f, -0.08450159f, 0.02482582f, -0.33363330f, -0.11804346f, 0.31516245f, 0.07014209f, 0.12536331f, 
    -0.00495790f, -0.08941203f, 0.12862469f, 0.16246733f, 0.05512026f, -0.00039447f, 0.11555707f, -0.24410501f, 
    0.05782609f, 0.04955935f, 0.07861270f, 0.03143276f, -0.15443055f, 0.15007780f, 0.31446576f, -0.06379835f, 
    -0.08239702f, -0.34238091f, 0.02982708f, -0.06474582f, 0.13409328f, -0.07532462f, -0.21391402f, 0.04578467f, 
    -0.33682927f, 0.16819127f, -0.08799950f, -0.21490428f, -0.10784132f, -0.29875636f, 0.08040668f, -0.11168630f, 
    -0.01519599f, 0.05094064f, -0.03551137f, -0.21255852f, 0.04426486f, -0.06145046f, 0.05882489f, 0.34064105f, 
    -0.13856788f, 0.25633869f, 0.13457049f, -0.05624664f, -0.11919250f, -0.01098650f, -0.53807425f, -0.06603012f, 
    -0.07319286f, -0.02568863f, 0.00494088f, -0.05663790f, 0.52704793f, 0.11036011f, 0.20124750f, 0.17721620f, 
    -0.12649934f, -0.05463266f, 0.06922931f, 0.15035497f, -0.07007964f, -0.15208410f, -0.12052608f, -0.38375196f, 
    0.22163995f, -0.14814213f, 0.00347514f, 0.42828718f, 0.11986770f, -0.03130152f, -0.05206237f, -0.10557429f, 
    0.08995023f, -0.13998324f, 0.09595059f, 0.02600297f, -0.00782943f, -0.10433804f, 0.02024828f, 0.15926634f, 
    0.06136039f, 0.47290170f, 0.02486911f, 0.25493360f, 0.12360252f, 0.03809239f, 0.38488498f, 0.05093991f, 
    0.29202652f, 0.02461777f, 0.05294952f, 0.03254253f, -0.09263455f, 0.35857362f, 0.07577150f, -0.30530164f, 
    0.04681024f, 0.03562805f, 0.08937272f, 0.00674489f, 0.25599527f, -0.16419438f, -0.14962918f, 0.18379195f, 
    0.14662988f, 0.09190280f, 0.13100110f, -0.01851276f, -0.11152068f, -0.05135468f, -0.06401931f, 0.08163028f, 
    0.12605639f, 0.08000673f, 0.14057447f, 0.13606240f, -0.35776046f, -0.08806048f, 0.26750925f, 0.08145756f, 
    0.05192729f, -0.17266360f, 0.00073664f, -0.10862777f, -0.14708474f, 0.05996430f, -0.11611671f, -0.16225374f, 
    -0.14019285f, 0.04547328f, 0.01540068f, 0.07926174f, -0.13919006f, -0.01528320f, -0.01350769f, 0.04998113f, 
    0.16832858f, 0.13866527f, -0.04089990f, 0.08512816f, 0.12749232f, 0.03826370f, 0.07070196f, -0.14863020f, 
    -0.01202349f, 0.01098248f, -0.18376537f, -0.05400704f, 0.07581055f, 0.04032027f, -0.17110860f, 0.13970451f, 
    0.29988888f, -0.06115568f, -0.08222634f, 0.31565699f, 0.17255747f, -0.19851285f, 0.01717375f, 0.35213017f, 
    -0.31952778f, 0.05788025f, -0.14468162f, -0.04886485f, -0.11265996f, 0.09784761f, 0.08614721f, -0.08908472f, 
    0.09233340f, -0.00260115f, -0.14394420f, -0.10174750f, 0.16038859f, -0.15476096f, 0.04273142f, 0.35293716f, 
    0.03788020f, 0.21434103f, 0.21784216f, -0.20198567f, -0.15795583f, 0.08850572f, 0.03207006f, -0.17320018f, 
    -0.15872082f, 0.10850397f, -0.13915572f, -0.07510452f, 0.08884224f, -0.44097680f, 0.15424801f, 0.16723064f, 
    -0.01805178f, 0.16207959f, -0.09604091f, 0.41551909f, -0.29500714f, 0.14315191f, 0.29976520f, 0.14149003f, 
    -0.06668038f, 0.16596906f, -0.10735583f, -0.16442835f, 0.10330053f, 0.06157434f, 0.06232910f, 0.16430055f, 
    -0.00222475f, -0.14014040f, 0.20382880f, -0.01065846f, 0.32852194f, 0.05343761f, -0.36653697f, -0.07913718f, 
    0.43049937f, -0.27953252f, 0.23937517f, -0.22725727f, -0.08181570f, 0.00313784f, 0.09446746f, -0.31410244f, 
    0.33378690f, 0.17741603f, 0.07570305f, 0.12936690f, 0.20027156f, -0.03170610f, 0.20361802f, -0.03274474f, 
    -0.01768913f, -0.18944919f, -0.12024117f, -0.13489392f, -0.06773742f, -0.04978943f, -0.19767463f, 0.30205381f, 
    -0.09994221f, -0.02806635f, 0.18652581f, 0.35602137f, -0.13141683f, -0.02727455f, 0.26157242f, 0.09313170f, 
    -0.27334967f, 0.02061852f, 0.09105996f, -0.08655758f, 0.16583082f, 0.07314532f, 0.17539516f, -0.09918419f, 
    0.28156513f, -0.09840427f, -0.01499920f, 0.02602243f, 0.20208094f, 0.16121793f, -0.11234238f, 0.20400314f, 
    -0.02161178f, 0.24719131f, 0.04158371f, 0.13884401f, -0.09026192f, -0.03517041f, -0.24274185f, 0.05678905f, 
    0.10199107f, 0.36665204f, -0.02198781f, 0.20391704f, -0.13426872f, 0.10631460f, 0.33985397f, 0.05166358f, 
    -0.33050120f, -0.12643500f, -0.12013122f, 0.43313837f, 0.14337870f, -0.36457446f, 0.02640369f, 0.12157656f, 
    -0.05616620f, -0.04330914f, 0.07199609f, 0.35480526f, 0.12284652f, 0.15371531f, 0.11975502f, 0.25697932f, 
    -0.14843950f, -0.40714434f, -0.08589919f, -0.16579722f, -0.00474498f, -0.03157553f, 0.01157917f, -0.10734750f, 
    -0.13532890f, 0.24854860f, 0.12963907f, 0.04683385f, -0.18134449f, -0.02678059f, 0.14962006f, 0.01467407f, 
    0.30979174f, 0.01723594f, -0.06723411f, -0.16032043f, 0.08754525f, 0.14766805f, 0.08592085f, 0.06040670f, 
    0.26097772f, -0.12318289f, 0.17238307f, -0.23904261f, 0.37799484f, 0.14406955f, -0.08618771f, -0.05233506f, 
    0.07729956f, -0.32794687f, -0.09048510f, 0.11169616f, -0.07696715f, -0.08077327f, -0.14428815f, 0.25440052f, 
    -0.05367903f, -0.15754363f, 0.23763061f, 0.05687488f, 0.03907686f, 0.07911240f, 0.42850152f, -0.08942018f, 
    -0.01845914f, -0.09043293f, -0.03785289f, 0.11286659f, -0.00387053f, 0.00770128f, -0.11507408f, -0.20992205f, 
    -0.03166060f, -0.09873556f, 0.14499445f, 0.03252792f, 0.01905046f, -0.11327673f, -0.11166523f, -0.00580951f, 
    0.10547867f, -0.05088193f, -0.12783253f, -0.13179709f, -0.00932484f, -0.15965863f, -0.01443827f, -0.21504894f, 
    0.07763404f, 0.05993771f, 0.04841113f, -0.16289152f, -0.19273582f, 0.05876948f, 0.07459203f, 0.09227899f, 
    0.00294515f, 0.22923890f, 0.45727026f, -0.01988149f, -0.05624142f, 0.40415919f, 0.02483706f, -0.11493239f, 
    -0.36633095f, -0.14493808f, -0.15104747f, -0.35648677f, 0.16541560f, -0.15466243f, 0.14995547f, -0.01045872f, 
    0.17367966f, -0.13925117f, 0.14072184f, 0.05194519f, -0.02485881f, 0.33818263f, 0.12256890f, 0.14463343f, 
    -0.07134761f, -0.33746040f, 0.22247186f, 0.04470780f, -0.16260508f, 0.06715272f, -0.25437605f, 0.17629318f, 
    -0.33825010f, -0.18351068f, -0.09355558f, -0.14943027f, -0.01016979f, -0.17808391f, -0.02536272f, -0.00475972f, 
    -0.09197109f, 0.01525186f, -0.01459101f, 0.33341053f, 0.34456784f, -0.12349368f, 0.13774884f, 0.33022872f, 
    -0.02592217f, 0.11157274f, 0.07724550f, 0.07081090f, -0.15062813f, 0.12262167f, 0.23730800f, -0.07689966f, 
    0.11127482f, -0.12491032f, 0.20558502f, -0.22420928f, 0.35403404f, -0.03045038f, 0.00348607f, -0.13567343f, 
    0.08881418f, 0.03679189f, -0.14009899f, 0.00296030f, -0.13864331f, 0.30758864f, -0.10017093f, 0.09506724f, 
    0.14664800f, 0.01583979f, 0.02351150f, -0.36907065f, 0.31503960f, -0.00857838f, -0.03495152f, 0.11245352f, 
    0.10584545f, 0.03625353f, 0.13851120f, 0.11650509f, -0.04703581f, -0.10038587f, -0.06441042f, 0.17174874f, 
    -0.06179631f, -0.19151497f, 0.14451109f, -0.24241881f, 0.03209022f, 0.12184970f, 0.05569728f, -0.08777837f, 
    -0.09207740f, 0.17432585f, -0.03112643f, 0.11276685f, -0.09047276f, 0.25998449f, 0.16051242f, -0.33217224f, 
    0.44910219f, 0.06707424f, -0.01079854f, -0.25374711f, -0.01477319f, -0.01067708f, -0.04191578f, -0.05836962f, 
    0.00740688f, -0.12316220f, -0.06149088f, 0.15905365f, -0.14867008f, 0.13830751f, -0.05878353f, 0.04226916f, 
    0.13935614f, 0.26697782f, -0.04558019f, 0.08613302f, 0.22252391f, -0.09891231f, 0.07750076f, -0.15941030f, 
    0.10531952f, -0.15276290f, -0.21684676f, -0.03788910f, -0.03031569f, -0.33937907f, 0.10116848f, 0.20123251f, 
    -0.03593807f, 0.17404436f, 0.07636763f, 0.40650007f, 0.03315164f, -0.00197294f, -0.08212937f, 0.01223903f, 
    -0.12937732f, 0.12172849f, 0.01398002f, -0.05768643f, 0.05925733f, -0.04668688f, 0.03322598f, 0.10712997f, 
    0.14301760f, 0.19540840f, 0.15573654f, -0.15317076f, 0.39446715f, -0.02089778f, 0.30345774f, -0.18005581f, 
    0.19388162f, -0.09755515f, 0.08662143f, 0.08229791f, 0.07107980f, 0.29140857f, -0.06898421f, 0.10140988f, 
    0.29910663f, -0.00274978f, -0.04883502f, 0.27592584f, -0.05361327f, -0.01296264f, -0.20267217f, -0.27856258f, 
    0.09416229f, 0.00623083f, 0.07952884f, -0.12882808f, 0.11027750f, 0.26343751f, 0.62085736f, -0.16267607f, 
    -0.19011194f, -0.17860882f, -0.18239082f, 0.35086647f, -0.07270417f, 0.04711234f, -0.25885698f, -0.14274383f, 
    -0.00067326f, 0.04181447f, -0.12842909f, -0.46688366f, -0.09863783f, 0.14114882f, -0.02030469f, 0.01652988f, 
    -0.14269985f, -0.00927302f, -0.07190821f, 0.43465009f, -0.10230814f, 0.02440108f, 0.17499430f, -0.10484596f, 
    0.02077472f, 0.24938911f, -0.13791597f, 0.00457660f, -0.04650160f, 0.20838557f, 0.24611339f, 0.19557014f, 
    -0.04382134f, -0.18760175f, 0.26360008f, 0.14114164f, 0.13850331f, -0.04108943f, -0.07867797f, -0.04247332f, 
    0.01204731f, -0.20354487f, -0.05724453f, -0.13052432f, -0.03750998f, -0.01087387f, 0.16660029f, -0.27340418f, 
    0.37896168f, -0.09106332f, 0.11015061f, 0.38371488f, 0.22495204f, 0.03774560f, 0.02229431f, -0.09688077f, 
    0.05564632f, -0.26781771f, -0.00500112f, 0.02773394f, 0.13257539f, 0.04535684f, 0.00011307f, 0.17773566f, 
    0.12464164f, 0.43629074f, 0.11694828f, 0.22811417f, 0.25178558f, 0.07018019f, 0.36085868f, 0.05608996f, 
    0.22398937f, 0.02612920f, 0.26788104f, -0.25738090f, 0.00924852f, 0.43477738f, 0.15644290f, -0.31090006f, 
    0.01374247f, 0.13153386f, -0.10247523f, -0.25042844f, -0.03984676f, -0.00792061f, 0.12141297f, 0.22604984f, 
    0.00235802f, -0.38843662f, 0.00788567f, 0.05946519f, 0.17083886f, 0.46595526f, -0.17472914f, -0.12674335f, 
    -0.05005227f, 0.16003518f, 0.26098776f, 0.31204084f, 0.39225677f, -0.12607422f, -0.20091535f, 0.07639395f, 
    -0.25448373f, 0.17479751f, -0.20325303f, -0.18299039f, -0.10842512f, 0.32071915f, -0.04165815f, -0.00699861f, 
    -0.23553997f, -0.12317581f, 0.09731013f, 0.15469499f, -0.02303906f, 0.03091587f, 0.06544798f, 0.27743438f, 
    -0.00817747f, 0.66415524f, 0.15874143f, -0.11021806f, 0.12497277f, -0.13184015f, -0.20579630f, 0.12312176f, 
    0.05482189f, -0.12366150f, -0.04734852f, 0.39218003f, 0.24936363f, 0.14589338f, -0.15472385f, -0.06727969f, 
    0.16352442f, 0.16142806f, -0.17431661f, 0.13058594f, -0.11268841f, 0.41897252f, -0.01050588f, 0.01006429f, 
    0.20729731f, 0.00960570f, 0.14826636f, -0.12735100f, 0.31915161f, 0.03115958f, -0.23055956f, -0.09703145f, 
    0.02344356f, -0.11147131f, -0.01953049f, 0.10720421f, -0.08443106f, 0.12482260f, 0.04065566f, 0.06118107f, 
    -0.16189544f, -0.04074031f, -0.19073848f, -0.22135445f, 0.44176015f, 0.12811582f, 0.43191713f, 0.08794605f, 
    0.31368470f, -0.03916771f, 0.17457317f, 0.19390288f, 0.13375413f, -0.25966960f, -0.11182342f, 0.11524217f, 
    -0.54773587f, 0.13692470f, -0.07366572f, 0.15462320f, 0.02408311f, 0.09810168f, 0.36736760f, 0.04681871f, 
    0.07840758f, 0.05405843f, 0.14499284f, -0.14916492f, 0.00510786f, -0.14641273f, -0.08720084f, 0.22953486f, 
    -0.00152241f, -0.24139962f, 0.18809451f, -0.11921249f, -0.10259537f, 0.12708229f, -0.20734380f, 0.07410420f, 
    0.09669392f, -0.12129378f, 0.12343366f, -0.02448189f, 0.16363336f, 0.58731329f, -0.11192203f, -0.23804288f, 
    0.56271577f, -0.03129914f, -0.01082211f, -0.28864628f, 0.27101684f, -0.03253861f, 0.02152855f, 0.00258492f, 
    0.11450710f, 0.03020996f, 0.07591604f, -0.00428238f, -0.02767896f, 0.16105103f, 0.00467514f, 0.09216055f, 
    -0.02945703f, 0.07306243f, 0.07621713f, -0.16591562f, -0.06719720f, -0.01229915f, 0.08252812f, 0.09608404f, 
    -0.25354552f, -0.17956178f, 0.04791000f, 0.04282271f, 0.13313924f, 0.13339312f, -0.07364722f, -0.49112886f, 
    0.03903889f, 0.10316043f, -0.06085351f, 0.40692103f, -0.25979078f, -0.05897543f, -0.06806088f, 0.01465120f, 
    0.13532850f, -0.06291793f, -0.09630657f, 0.01990655f, 0.06285287f, 0.32948807f, 0.24748251f, 0.11837371f, 
    0.03503918f, -0.04070511f, -0.09204322f, 0.40467942f, 0.21698028f, 0.06387839f, -0.20585181f, 0.01310818f, 
    -0.28057420f, -0.19046204f, 0.12367369f, 0.30342728f, 0.03494451f, -0.24772432f, 0.11370207f, -0.02941262f, 
    0.01686585f, -0.10758314f, 0.10947432f, 0.13235369f, -0.31197301f, 0.16350554f, 0.39097828f, 0.36179626f, 
    0.16028336f, 0.23168156f, 0.15194753f, 0.02167680f, 0.14826062f, 0.08857679f, -0.07783255f, 0.10242392f, 
    -0.03679160f, 0.00114982f, 0.00165220f, 0.41554505f, -0.38958287f, 0.10011783f, -0.06979293f, -0.11193187f, 
    -0.15825954f, 0.22122055f, -0.34236664f, -0.13912314f, 0.14939433f, 0.24678329f, -0.06192252f, 0.43069229f, 
    -0.43867031f, -0.02148164f, 0.06128420f, 0.14724949f, 0.07638546f, -0.12812549f, -0.03205942f, 0.07604824f, 
    -0.00196837f, 0.60386896f, 0.16720356f, 0.01039293f, -0.13902926f, -0.16209580f, 0.27632028f, 0.10498279f, 
    0.12788329f, -0.13444291f, 0.13599244f, -0.18410607f, 0.20654778f, -0.11018701f, -0.12100634f, -0.11778954f, 
    0.02507201f, 0.13964538f, -0.09434389f, 0.10372732f, 0.01666590f, 0.20323406f, -0.14423427f, 0.04516489f, 
    0.47663546f, -0.08173114f, 0.08701230f, -0.18380839f, -0.06242559f, 0.15777986f, -0.36101788f, 0.07706074f, 
    -0.03136554f, 0.32266206f, 0.12394431f, -0.01487649f, -0.14451869f, -0.18651061f, -0.03405678f, 0.08015438f, 
    -0.14682691f, 0.32650679f, 0.03728720f, -0.12690328f, 0.21004646f, 0.13569804f, 0.21065196f, 0.02783892f, 
    0.02581937f, -0.05704945f, -0.12893443f, -0.06226341f, 0.11426094f, -0.08504929f, 0.06361480f, -0.18554360f, 
    0.00451016f, 0.12161955f, 0.14891925f, 0.03681246f, 0.13877751f, 0.05079781f, -0.00279167f, -0.14186819f, 
    0.07400684f, -0.10259144f, 0.00050854f, -0.03035817f, -0.17450991f, -0.07021368f, 0.04778024f, -0.17933403f, 
    0.15765883f, 0.12134713f, -0.17337435f, 0.06330721f, -0.06124659f, -0.13564043f, -0.00291939f, 0.08543835f, 
    -0.26504114f, 0.24428652f, -0.04253262f, 0.38512197f, -0.12101024f, 0.30276501f, 0.17045368f, -0.27394632f, 
    0.34467500f, 0.02468589f, 0.12914161f, -0.23540542f, 0.08948087f, -0.08149166f, -0.08456085f, 0.16746725f, 
    0.12662438f, -0.38455623f, -0.13732192f, 0.06658734f, 0.08098578f, 0.07042903f, 0.01216792f, -0.03611821f, 
    -0.04897281f, 0.41174108f, -0.00823941f, -0.03953968f, -0.17308360f, 0.08341535f, 0.21524297f, -0.08510226f, 
    0.03025934f, -0.07778693f, -0.06073344f, -0.22967276f, 0.05167661f, 0.19547272f, 0.09891724f, 0.15053995f, 
    0.00305276f, 0.11827994f, -0.16447133f, -0.10285968f, -0.21462341f, 0.13771689f, 0.04027764f, -0.22411503f, 
    -0.16890097f, 0.49989927f, 0.07750279f, -0.04211222f, 0.13502580f, 0.06329650f, 0.30223739f, 0.27927789f, 
    -0.03935054f, 0.48774555f, -0.09215160f, -0.09808078f, -0.22255701f, 0.11930396f, 0.05839259f, 0.12287831f, 
    -0.06115377f, -0.09675566f, 0.15047270f, -0.22777307f, -0.01906917f, -0.04426742f, 0.08226406f, 0.10246036f, 
    -0.41729531f, -0.11396603f, -0.18663116f, 0.06220644f, 0.22334701f, 0.05689970f, 0.30817083f, 0.32999101f, 
    0.09979723f, 0.04726241f, -0.03760304f, 0.09594686f, 0.15982684f, -0.15772666f, -0.36107230f, 0.28467771f, 
    -0.14797814f, -0.08989369f, 0.35862976f, 0.12362256f, -0.15560536f, -0.12368273f, -0.33412203f, 0.07178163f, 
    -0.08674043f, -0.16011381f, -0.12484071f, -0.07270744f, -0.02100628f, 0.15953724f, -0.11215511f, -0.08900958f, 
    -0.10737164f, 0.12081849f, 0.10061917f, -0.15140408f, 0.04851573f, -0.08843241f, -0.00629679f, -0.06407395f, 
    0.15600193f, -0.18879050f, 0.17322415f, 0.07720949f, -0.10280651f, -0.04570193f, 0.03116380f, 0.07492773f, 
    -0.14685123f, 0.08019996f, -0.18761368f, -0.08061041f, -0.16742741f, 0.10943256f, 0.08699200f, 0.14015795f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.09774135f, 0.01599528f, 0.06403894f, -0.15866528f, 0.14435720f, -0.07702910f, 0.03797355f, -0.07416633f, 
    0.09335844f, 0.17559789f, 0.13187253f, 0.07654728f, 0.00548479f, 0.28788003f, 0.10485701f, 0.14153048f, 
    0.25517437f, 0.26838920f, -0.00899911f, 0.11926018f, 0.12175299f, 0.09695323f, 0.11459030f, -0.08363372f, 
    -0.10768551f, -0.17530924f, 0.13485730f, -0.05932519f, -0.08064113f, 0.15867361f, 0.16626495f, 0.25232059f, 
    0.24328929f, 0.13076451f, 0.16568251f, 0.10371044f, 0.13759153f, 0.10297785f, -0.02217869f, 0.07285643f, 
    0.06750125f, 0.07998905f, 0.03034071f, 0.22458449f, 0.08325710f, -0.07768977f, 0.19831805f, -0.18370444f, 
    0.10864735f, 0.04455215f, 0.10735442f, -0.04740020f, -0.04115346f, -0.02568566f, 0.03500334f, -0.02583398f, 
    0.23543186f, -0.08849201f, -0.07332391f, -0.09833401f, -0.16118185f, 0.05535236f, 0.16198830f, -0.01426289f, 
    0.04675497f, 0.17825831f, 0.17812955f, -0.05407091f, 0.13388699f, 0.10831635f, -0.07388741f, -0.01816662f, 
    0.00257739f, 0.05091521f, 0.02632771f, 0.26189247f, -0.21469328f, 0.02408661f, 0.14852121f, -0.16543545f, 
    0.13866667f, 0.27262071f, 0.20439593f, 0.10127917f, -0.10121159f, 0.04085986f, -0.00261324f, 0.12151733f, 
    0.09724426f, 0.20717247f, -0.11529017f, 0.07833752f, 0.11763164f, 0.16189948f, -0.09027733f, 0.26337099f, 
    -0.11145379f, 0.06554832f, -0.04544978f, 0.14866190f, -0.20724759f, 0.09736860f, 0.04579416f, 0.08639060f, 
    0.15084690f, -0.20275241f, 0.10460936f, -0.08107372f, 0.17903426f, 0.14401978f, -0.03120999f, -0.07543298f, 
    -0.15372829f, 0.00957643f, 0.21944031f, 0.18792115f, 0.10688280f, 0.11557165f, 0.21750623f, -0.04790441f, 
    0.22904013f, -0.00094254f, 0.06389768f, 0.11739548f, -0.07382931f, -0.21072026f, 0.23494594f, 0.15948762f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.23710787f, -0.00585206f, 0.15604483f, 0.08713530f, 0.12103251f, 0.16087948f, 0.28616089f, -0.34563813f, 
    0.00582731f, -0.33020502f, -0.08871879f, 0.09729883f, 0.06252926f, 0.04860533f, -0.18411006f, 0.02522892f, 
    -0.11273238f, 0.22652830f, -0.05544605f, -0.38482305f, 0.00775218f, -0.05872757f, 0.23552798f, -0.66133279f, 
    0.02465587f, -0.28767073f, 0.07727242f, 0.02963733f, -0.04768919f, -0.03673112f, 0.14657125f, 0.10478391f, 
    -0.09565932f, 0.08989065f, -0.01793274f, 0.17501917f, 0.02558619f, -0.19411826f, 0.23105906f, -0.14860921f, 
    0.12410785f, -0.37246019f, 0.12127974f, -0.19316293f, 0.13316797f, -0.35374424f, 0.17534781f, -0.22056411f, 
    0.12805428f, -0.29283273f, -0.29882115f, 0.00937050f, 0.07955392f, 0.02804036f, 0.04390572f, 0.14207393f, 
    -0.12477563f, -0.10910860f, -0.08512678f, 0.18266129f, 0.22933675f, -0.31597397f, -0.20661432f, -0.13322194f, 
    -0.12952922f, 0.13403307f, -0.00723452f, -0.29660904f, -0.27375296f, -0.12479164f, -0.06603318f, -0.17386155f, 
    -0.25935510f, 0.05246542f, -0.06041778f, -0.05804297f, 0.15072809f, 0.30485335f, -0.03926580f, -0.43340084f, 
    0.14468989f, -0.18298815f, 0.06438600f, 0.14795735f, -0.31913164f, 0.03198937f, 0.23329784f, -0.06256588f, 
    -0.38157052f, 0.11589792f, 0.02480732f, 0.35428211f, 0.09470323f, 0.14191860f, -0.45753604f, -0.40641159f, 
    0.17243099f, -0.00211665f, -0.04709733f, -0.03360882f, -0.28410557f, -0.13975814f, 0.04460998f, 0.27319914f, 
    -0.04846512f, 0.00647898f, -0.02496895f, -0.30953518f, -0.19808400f, 0.18597054f, -0.14281639f, -0.13439067f, 
    -0.47004005f, 0.04562521f, -0.01058970f, -0.37767044f, 0.03551252f, -0.17745975f, -0.00284019f, -0.12545252f, 
    0.10126954f, -0.59983242f, 0.00480464f, -0.02794122f, 0.49943975f, -0.24149586f, -0.31347132f, -0.11623109f, 
    0.11717953f, 0.02295095f, 0.21382859f, 0.14570642f, 0.19796874f, -0.13882039f, 0.11425306f, 0.13924254f, 
    -0.09813844f, -0.06747495f, -0.14312205f, -0.33169588f, -0.02942440f, 0.16002384f, -0.51783842f, 0.00612138f, 
    -0.67978913f, 0.06556836f, -0.30425650f, -0.31237191f, -0.29303396f, -0.34461623f, 0.24318540f, -0.07324125f, 
    0.06801607f, 0.17891936f, 0.11280204f, -0.03324465f, -0.03368664f, 0.13524000f, 0.14123577f, -0.01714969f, 
    0.17916112f, 0.07682578f, 0.11952058f, -0.19167377f, 0.07205568f, -0.41747063f, -0.27535862f, 0.11872650f, 
    0.18102123f, -0.09315857f, 0.05386779f, -0.01060477f, -0.01839425f, 0.11124089f, -0.22001618f, 0.17657328f, 
    -0.06608994f, 0.02619585f, 0.03053852f, -0.00880235f, 0.03618192f, -0.93617219f, 0.01598848f, -0.26181418f, 
    0.13558640f, -0.12518200f, 0.08266994f, -0.18176730f, 0.07365535f, 0.08134295f, 0.17513186f, -0.37980705f, 
    -0.44197929f, 0.08800303f, -0.10836278f, 0.00643236f, -0.28073195f, 0.03962300f, -0.12627949f, -0.11688062f, 
    0.48717749f, 0.27639401f, -0.30447370f, -0.26299694f, -0.14141211f, 0.00882133f, 0.06399689f, 0.06835510f, 
    0.08279692f, -0.27052274f, 0.07363950f, -0.25785825f, -0.04237787f, -0.01120430f, -0.09352601f, 0.01507826f, 
    -0.17015290f, 0.05242608f, 0.19103476f, -0.27537489f, 0.18240698f, 0.18672998f, 0.31998816f, -0.13920689f, 
    0.19643179f, 0.16335110f, 0.00194175f, 0.05328789f, -0.42463434f, 0.19648965f, 0.12114595f, -0.15972815f, 
    0.20226324f, -0.01918872f, -0.26190749f, -0.24124046f, 0.07581916f, 0.13036475f, 0.11109883f, 0.09945156f, 
    -0.04135759f, 0.19886537f, -0.04279158f, -0.15447055f, 0.22074369f, -0.17604141f, 0.15658684f, 0.32675949f, 
    -0.31292862f, -0.13037132f, 0.19394304f, 0.05045253f, 0.04148002f, 0.37152204f, -0.20064196f, -0.04223994f, 
    0.13326392f, 0.06755074f, -0.09221898f, -0.09112453f, -0.10736208f, -0.30031812f, -0.06992166f, -0.30312964f, 
    -0.38448983f, 0.11904146f, 0.19548523f, 0.23562862f, 0.35123619f, -0.02778349f, -0.29616129f, -0.22940174f, 
    0.26918313f, 0.00284578f, 0.11543319f, -0.58764553f, -0.24808666f, -0.03592810f, -0.25063089f, 0.30755061f, 
    -0.34418827f, 0.21208631f, 0.08404931f, 0.01089005f, 0.04740927f, 0.15848300f, -0.11461335f, 0.13377316f, 
    0.15178157f, -0.32922953f, 0.10754329f, -0.21386379f, 0.00380714f, -0.03630230f, -0.42429745f, 0.13022260f, 
    -0.00506686f, -0.33208257f, 0.00301122f, -0.13908207f, -0.36646056f, -0.06277914f, -0.58997959f, -0.34673849f, 
    -0.19781831f, -0.06995960f, 0.09265569f, -0.02846674f, -0.20934412f, -0.42556009f, -0.34506080f, -0.31775549f, 
    -0.05973906f, 0.00041279f, 0.06680598f, -0.15750182f, 0.04303817f, -0.26017860f, -0.22787112f, 0.28540140f, 
    -0.36933222f, 0.16181278f, -0.45247671f, 0.22517662f, -0.33091700f, -0.05197784f, -0.57231557f, 0.25618121f, 
    0.09211204f, 0.18590014f, -0.18083300f, 0.32278511f, 0.05385321f, -0.03807724f, -0.03614201f, 0.19142632f, 
    0.35114488f, -0.25323096f, -0.50695419f, 0.29852319f, -0.46849281f, -0.05766455f, -0.09310660f, -0.03290891f, 
    0.11279245f, 0.01957832f, -0.44688448f, 0.18070702f, 0.24488236f, -0.10060465f, -0.04155925f, 0.21722093f, 
    0.04670759f, -0.05040457f, -0.07912280f, -0.12806439f, 0.06170750f, -0.00219276f, 0.20263425f, 0.15994070f, 
    0.13478875f, -0.09929267f, -0.48404339f, 0.14026238f, 0.13530616f, 0.19764429f, 0.02193665f, -0.54971963f, 
    -0.27842429f, 0.15255469f, -0.07379998f, -0.16696021f, 0.03319646f, -0.47772372f, 0.30928349f, -0.34865701f, 
    -0.00194323f, -0.14697821f, 0.25279835f, -0.00416334f, 0.26713848f, -0.25352269f, -0.09267697f, 0.00132559f, 
    -0.21218602f, -0.06462823f, -0.34087577f, 0.32100695f, -0.26260874f, -0.24267386f, 0.06082682f, -0.46329370f, 
    -0.05077887f, 0.12844698f, -0.66034693f, -0.21329191f, -0.57655305f, -0.33183983f, 0.25938764f, -0.03877162f, 
    0.03459443f, -0.05876929f, 0.07448371f, -0.13870151f, 0.09624906f, -0.21590114f, -0.18583995f, -0.28183436f, 
    -0.01585954f, -0.42574850f, 0.14425635f, 0.05317164f, 0.03248997f, -0.10133760f, -0.42008495f, -0.07178288f, 
    -0.24159351f, -0.25851360f, -0.16219425f, 0.00390411f, -0.05913341f, -0.33858040f, 0.11871285f, 0.08499473f, 
    -0.42444927f, 0.01580104f, -0.08032084f, -0.07564770f, -0.17941166f, 0.17951228f, -0.01482511f, 0.13711424f, 
    0.28905258f, 0.01715744f, -0.42375815f, -0.00728925f, -0.22132486f, -0.44298530f, 0.05108645f, 0.14125304f, 
    -0.15415075f, 0.05550210f, 0.07820669f, 0.18064386f, -0.53636503f, 0.24693851f, -0.44246355f, 0.11063220f, 
    0.11708834f, 0.18866956f, -0.10717106f, -0.27676481f, 0.21476009f, -0.31916624f, 0.12902959f, -0.40519619f, 
    -0.12029578f, -0.09323940f, 0.27553090f, 0.08212539f, -0.03620245f, 0.01620774f, -0.07056677f, 0.12687646f, 
    0.15254053f, -0.04024814f, -0.26640683f, 0.11256176f, -0.18616433f, -0.15542160f, 0.11538693f, 0.00890260f, 
    0.02438292f, -0.41240475f, 0.22806829f, 0.07615596f, -0.22697338f, 0.05243568f, -0.26069751f, -0.53064519f, 
    0.16810055f, 0.07575336f, 0.02737650f, -0.30655903f, -0.03574893f, 0.25555199f, 0.10723325f, -0.19237472f, 
    -0.03946318f, -0.01910521f, 0.10844504f, -0.25505632f, -0.18984896f, 0.07484424f, -0.41986898f, 0.21068104f, 
    0.01635953f, 0.08738286f, 0.24872233f, 0.17847922f, -0.37409797f, -0.12324905f, -0.03168913f, 0.38017273f, 
    0.26986822f, -0.39013502f, 0.17270687f, 0.05281140f, -0.11329849f, -0.47517994f, -0.04283061f, 0.01515728f, 
    -0.27863199f, -0.03761061f, -0.20850930f, -0.36460423f, 0.18354157f, 0.08018031f, 0.06190046f, -0.27396405f, 
    -0.28162766f, -0.14578205f, -0.11572613f, 0.21109419f, 0.15751791f, -0.00952604f, 0.05794277f, -0.42098063f, 
    -0.07431990f, -0.00671582f, 0.05771203f, -0.62453341f, 0.28902483f, 0.00476982f, -0.18821774f, -0.24260744f, 
    0.17299885f, 0.05406078f, -0.01903944f, 0.07677414f, 0.01849347f, -0.30191630f, -0.00563115f, 0.17244944f, 
    -0.09448434f, -0.13975036f, 0.48559484f, -0.09025810f, -0.03837814f, 0.32759547f, 0.09469146f, 0.10239442f, 
    -0.05213956f, 0.18063162f, 0.24539030f, 0.12162390f, 0.15275960f, 0.19086494f, 0.04238167f, -0.15792760f, 
    0.14466676f, -0.07367112f, 0.12611170f, 0.03730787f, 0.07751394f, 0.15110420f, 0.05807103f, 0.19043873f, 
    -0.01596297f, -0.07012565f, -0.06998909f, 0.08633789f, -0.22129911f, -0.27276301f, -0.01087231f, 0.29264781f, 
    0.03631976f, -0.41133380f, 0.04617178f, 0.26743832f, -0.01553516f, -0.04182607f, 0.25425145f, -0.14691885f, 
    0.04273160f, -0.16484731f, 0.22957331f, -0.00233452f, -0.22960836f, -0.17614096f, -0.03629923f, -0.16579248f, 
    -0.46191138f, 0.27764505f, 0.06394303f, 0.02549035f, -0.04069617f, -0.51444924f, -0.01983894f, 0.04016264f, 
    0.04435498f, -0.06445984f, -0.21919219f, 0.15893191f, -0.40420479f, -0.02051113f, -0.17477624f, -0.15328068f, 
    -0.33606499f, -0.00849493f, -0.01867549f, 0.04436431f, -0.07315431f, 0.13703893f, -0.31113076f, -0.22686920f, 
    0.18767063f, 0.05887064f, 0.24168526f, -0.12281784f, 0.07977380f, -0.09052990f, -0.05077766f, -0.11339937f, 
    0.01670521f, -0.09638748f, 0.29468796f, -0.38943073f, 0.02250925f, 0.18553512f, 0.05954552f, -0.78489429f, 
    -0.31738505f, -0.22306606f, -0.16393405f, 0.00837763f, -0.30701596f, -0.34534049f, 0.06580722f, -0.06016179f, 
    0.14337353f, -0.07751659f, 0.22516033f, -0.14790098f, 0.03147133f, 0.20331466f, 0.00174477f, 0.13427977f, 
    0.35894376f, -0.07229586f, -0.02781648f, -0.26579094f, -0.08177749f, 0.03942936f, -0.21978180f, 0.28611538f, 
    -0.24314898f, 0.05193921f, -0.31196576f, -0.17983976f, -0.02968411f, -0.16824052f, 0.12643151f, -0.08923320f, 
    0.36757678f, -0.14770402f, 0.08563790f, 0.04338285f, -0.03342668f, 0.15166090f, -0.48765925f, 0.11492048f, 
    0.06446686f, 0.19451462f, -0.18608586f, 0.21266413f, -0.06670926f, -0.01991325f, 0.11588442f, -0.18658237f, 
    0.09456386f, 0.01146261f, -0.20125127f, 0.11367998f, 0.35560629f, -0.45682845f, 0.20962380f, -0.06378093f, 
    -0.03307312f, 0.03016538f, 0.08253205f, 0.02133215f, 0.19498256f, -0.07309244f, -0.09583096f, 0.16973524f, 
    0.01314507f, -0.10951988f, 0.03587070f, -0.36945754f, 0.23780189f, 0.27190322f, 0.31086719f, -0.12691723f, 
    -0.02221358f, -0.09579602f, 0.31085354f, 0.03353059f, 0.02842120f, 0.03367533f, -0.14365835f, -0.11623193f, 
    -0.28768176f, -0.34572014f, -0.29762858f, -0.29648933f, -0.11004651f, -0.16286942f, 0.06880257f, 0.03237723f, 
    -0.32410726f, -0.15634876f, 0.12423568f, -0.29093349f, 0.58439893f, 0.05380534f, -0.20985664f, -0.05529516f, 
    -0.26732266f, 0.20397946f, 0.02546950f, -0.22924444f, 0.13137680f, 0.07756381f, -0.49871850f, 0.30028969f, 
    -0.21773358f, 0.00060750f, -0.02354476f, 0.13222884f, -0.02978580f, -0.20206034f, -0.08120640f, 0.07670051f, 
    0.04164002f, 0.03878080f, -0.02489046f, 0.03146147f, 0.12708513f, -0.24665783f, -0.05459094f, 0.30363864f, 
    -0.17751859f, -0.36996812f, -0.62312013f, 0.02826420f, -0.00641656f, 0.24898702f, -0.20010969f, 0.06686939f, 
    0.04862308f, 0.25965154f, -0.03193953f, -0.06429414f, -0.17934720f, -0.26401690f, -0.03205369f, 0.01033268f, 
    0.13244918f, -0.01804451f, 0.00817964f, 0.21678296f, 0.01023965f, -0.09799576f, 0.11172435f, 0.30688688f, 
    -0.65272784f, 0.24316703f, 0.14586489f, -0.23238629f, 0.02557332f, -0.17348418f, 0.26677489f, 0.17077968f, 
    -0.13497682f, 0.06999192f, -0.21415712f, -0.16436714f, 0.01235513f, -0.20203477f, -0.46918142f, 0.18206696f, 
    0.03748519f, 0.11490414f, 0.14878237f, -0.08238454f, -0.10846470f, -0.29828453f, 0.21725656f, 0.12750000f, 
    -0.05787197f, -0.01471449f, -0.30727184f, 0.03311564f, -0.04894589f, -0.09899399f, -0.02032730f, 0.13825560f, 
    0.00441998f, -0.11002281f, -0.01653461f, 0.18541941f, -0.30680072f, -0.28556705f, -0.03460327f, 0.21383904f, 
    0.03828193f, -0.31815723f, -0.02516524f, 0.07213067f, 0.16428642f, 0.37212017f, -0.31658950f, -0.21481445f, 
    0.10351118f, 0.10541846f, 0.03177464f, 0.06906319f, -0.09744219f, -0.22910254f, -0.55478847f, 0.13398574f, 
    0.09288312f, -0.17454493f, 0.14407051f, -0.03835655f, 0.32256544f, -0.02466142f, -0.26812661f, 0.10880467f, 
    -0.24832213f, -0.22435203f, 0.18827808f, -0.41120496f, 0.03052575f, -0.53790992f, 0.03935242f, 0.31517997f, 
    -0.10236016f, 0.18804778f, 0.06045721f, 0.01893506f, -0.96686900f, 0.20660052f, -0.56144369f, 0.04623053f, 
    -0.01166026f, -0.35013044f, 0.18144543f, -0.06401835f, -0.56931394f, -0.11530504f, -0.21266276f, -0.48409322f, 
    -0.16429834f, -0.00191095f, -0.03298810f, 0.18245201f, 0.19501050f, 0.01322083f, -0.00166593f, -0.10102566f, 
    -0.07738661f, -0.03166533f, -0.02252703f, -0.28645128f, -0.07420658f, -0.28872326f, 0.00743896f, -0.27632841f, 
    0.13828409f, -0.19737388f, -0.21507441f, 0.06361981f, -0.47372633f, 0.14858511f, -0.13066280f, -0.14289108f, 
    0.24705631f, 0.13078105f, -0.01772560f, -0.01744810f, -0.27098095f, 0.49388313f, 0.20207684f, -0.08917903f, 
    0.14349128f, -0.07731900f, -0.15582038f, -0.26583773f, -0.45108613f, 0.22798681f, -0.06806929f, -0.03070923f, 
    0.20980096f, 0.07127952f, -0.06697953f, -0.09051043f, -0.05555752f, -0.20345096f, -0.26404306f, -0.06649370f, 
    -0.02996670f, -0.35666236f, 0.13831919f, 0.27549279f, 0.04700023f, 0.22739640f, 0.01862394f, -0.16910183f, 
    0.07287299f, 0.11440947f, -0.05300629f, 0.04205838f, -0.00628389f, 0.23214594f, -0.81160182f, -0.21580233f, 
    -0.31705585f, -0.37801474f, -0.04109626f, 0.25239336f, -0.00121256f, -0.12177667f, 0.06618415f, -0.22728175f, 
    0.04412864f, 0.08742160f, -0.30551434f, -0.28476706f, 0.02500146f, 0.10501248f, 0.13126449f, 0.32462284f, 
    0.09414051f, 0.18638517f, -0.05690848f, -0.07693661f, -0.08935302f, 0.08089662f, 0.13983697f, 0.21435197f, 
    -0.53458446f, 0.09232764f, 0.04312812f, 0.01087501f, 0.26028118f, 0.35462081f, 0.12669839f, -0.22944154f, 
    0.11305362f, -0.28784135f, -0.05953937f, -0.11019287f, -0.08682782f, -0.29587969f, 0.04561062f, 0.00382876f, 
    -0.14036252f, 0.12512341f, -0.44625875f, -0.38056201f, 0.06333252f, 0.23919480f, -0.08658384f, -0.04401771f, 
    -0.04684705f, -0.55340910f, -0.15607482f, -0.25208569f, 0.30999598f, -0.01392775f, 0.17838974f, 0.07596034f, 
    0.09710862f, -0.02047890f, -0.02718844f, 0.18205443f, 0.04626459f, -0.18532069f, 0.45459595f, -0.11851452f, 
    -0.12185062f, -0.05738385f, -0.03003991f, -0.32631287f, 0.10201833f, -0.24708070f, -0.19494188f, -0.33599266f, 
    -0.33368117f, 0.04544538f, 0.02275327f, 0.17880733f, -0.19459271f, 0.02539711f, 0.05655886f, 0.29769757f, 
    0.18759593f, -0.10305381f, -0.03858006f, -0.08025696f, 0.05569647f, -0.35455391f, 0.06459908f, 0.21313225f, 
    -0.07187139f, 0.21489215f, 0.03962007f, -0.03041443f, -0.03260902f, 0.18509728f, -0.56084174f, -0.00117813f, 
    -0.50937891f, -0.08515456f, 0.12294137f, 0.04776667f, 0.21391569f, -0.26016298f, -0.38230902f, 0.16797577f, 
    -0.25652793f, -0.38331330f, -0.13564335f, -0.32496724f, -0.22991815f, 0.19876064f, -0.08880523f, -0.07849138f, 
    -0.24740015f, -0.12201771f, -0.30519870f, 0.27473980f, -0.23487167f, 0.43269455f, 0.31789321f, -0.18502897f, 
    -0.02838108f, -0.02762784f, -0.33687767f, 0.03100407f, 0.05088325f, 0.13395114f, -0.22282365f, -0.17673382f, 
    0.03682784f, 0.12630825f, 0.03939511f, -0.14991650f, 0.02260424f, -0.12278748f, -0.41582137f, 0.23980834f, 
    0.15990816f, 0.30639353f, 0.05164081f, 0.12313950f, -0.13027379f, 0.15476336f, -0.35712773f, -0.68845057f, 
    -0.45850688f, 0.29012579f, 0.02494912f, 0.06459004f, -0.28431028f, -0.48873720f, 0.15035577f, -0.18739288f, 
    0.06705476f, 0.08051786f, -0.01356552f, -0.33272210f, -0.05212608f, -0.22210313f, 0.36012778f, -0.25186342f, 
    0.09336224f, 0.11563569f, -0.25507978f, 0.02063248f, 0.16569483f, 0.18275231f, 0.17532229f, 0.09807662f, 
    -0.01174172f, 0.24189866f, -0.43392852f, -0.29289088f, 0.25577757f, 0.06489494f, -0.04390714f, -0.49522719f, 
    -0.39848208f, -0.02377040f, -0.07505808f, -0.48089302f, -0.21816497f, 0.12814635f, -0.41831356f, 0.00269770f, 
    -0.02741548f, -0.08018035f, 0.10133361f, -0.38162330f, -0.31357130f, 0.00391893f, -0.64416701f, 0.17602298f, 
    0.24361065f, -0.08954702f, 0.01116665f, -0.06270733f, 0.28450933f, -0.10663029f, 0.01868342f, -0.00613635f, 
    0.05810155f, -0.04947304f, -0.47039866f, 0.18441823f, -0.12025855f, -0.12509234f, 0.24962249f, -0.00177611f, 
    0.23241673f, 0.24476431f, -0.19629441f, 0.20440720f, 0.10081135f, -0.05411084f, -0.44934189f, -0.23339362f, 
    -0.61654824f, 0.30568290f, 0.07467864f, -0.03141301f, -0.34915000f, -0.24917017f, 0.02576560f, -0.04169840f, 
    0.15869300f, -0.02762122f, 0.01468370f, -0.37889025f, -0.17729393f, 0.17146881f, -0.09669879f, 0.25323471f, 
    -0.05486922f, -0.41104311f, 0.09044329f, 0.28521475f, 0.10816183f, 0.14569221f, -0.01106878f, -0.05505927f, 
    0.27647036f, 0.15756769f, -0.11288335f, 0.70819414f, 0.23117018f, 0.45412400f, -0.26658523f, 0.17142485f, 
    -0.30461493f, 0.04357203f, 0.04865311f, -0.08720084f, -0.09390581f, -0.35083324f, -0.25294846f, 0.05237946f, 
    -0.01687973f, 0.16907603f, 0.15769723f, 0.24510027f, 0.00615653f, 0.19669318f, -0.06263144f, -0.05546386f, 
    0.03333004f, -0.03397410f, 0.01396904f, 0.20112003f, -0.06814114f, -0.23208652f, 0.00701784f, -0.59307128f, 
    -0.05751677f, -0.39315179f, -0.00525176f, 0.07710087f, 0.01058807f, -0.42299441f, -0.12764378f, -0.05108771f, 
    -0.15709765f, 0.18649416f, 0.03055935f, -0.25643480f, 0.00701579f, -0.28800330f, -0.16568443f, 0.00042505f, 
    0.24173918f, -0.32347715f, -0.24480917f, -0.39376161f, 0.10676516f, 0.01675535f, -0.07591579f, 0.17390199f, 
    -0.43323871f, 0.30698887f, 0.20965299f, 0.32441339f, 0.17705511f, 0.00647170f, 0.06428251f, -0.62985814f, 
    -0.13435690f, 0.13483496f, -0.19942638f, 0.10450537f, 0.15618308f, 0.09026509f, 0.01857856f, 0.01546803f, 
    -0.14063920f, 0.22267812f, -0.31717175f, -0.15490472f, -0.05720282f, -0.66710895f, -0.03113158f, 0.37097743f, 
    -0.28935543f, -0.28947940f, 0.04107635f, -0.01920740f, 0.18816033f, -0.70947629f, -0.04704821f, -0.02307332f, 
    -0.21758428f, 0.03391314f, -0.01522856f, 0.08578359f, -0.03103682f, 0.07595914f, 0.03869852f, 0.13527492f, 
    -0.04001991f, -0.26692587f, 0.12352347f, 0.14140406f, 0.00059501f, -0.10087059f, -0.25102159f, -0.24204738f, 
    -0.00685445f, 0.27408382f, 0.03077089f, 0.07111520f, -0.13088742f, -0.04565187f, -0.02224191f, 0.07111259f, 
    -0.42112461f, -0.05655957f, -0.07260633f, -0.14566712f, -0.12189471f, -0.23916268f, -0.47717196f, -0.17182052f, 
    0.19617245f, 0.06215605f, -0.43615893f, -0.33616060f, -0.23095615f, 0.21487011f, 0.00652172f, 0.22244568f, 
    0.19190650f, -0.58639395f, 0.16383883f, -0.62162137f, -0.43045193f, -0.41438791f, -0.05412011f, 0.28861809f, 
    -0.23014694f, -0.28985250f, -0.04421595f, -0.00455736f, -0.03092194f, 0.27313185f, -0.37484232f, -0.52764428f, 
    0.19108917f, 0.08562909f, -0.10055132f, -0.00714263f, 0.06666409f, 0.11789706f, -0.08282387f, 0.04552023f, 
    -0.36373338f, -0.12607130f, -0.37388957f, 0.03521966f, 0.12250068f, 0.16258754f, -0.04700023f, -0.09313952f, 
    -0.14301313f, 0.17230162f, 0.10866839f, 0.03148813f, -0.00131759f, 0.37723231f, -0.05048877f, -0.30539775f, 
    0.21951015f, -0.38611829f, 0.02775058f, -0.45363823f, -0.32159907f, -0.09280340f, 0.03474192f, -0.35915777f, 
    0.02596193f, 0.18944387f, 0.04320334f, 0.16737621f, -0.15620066f, -0.02320518f, 0.01602050f, -0.19160636f, 
    -0.32415387f, -0.21641503f, 0.00089588f, 0.37128726f, -0.73604518f, -0.09045787f, 0.07255360f, 0.20563602f, 
    0.03549443f, -0.06002615f, -0.06321499f, -0.07781847f, -0.39918768f, -0.00032699f, -0.02766396f, -0.05034531f, 
    0.21639125f, -0.11629992f, -0.00120836f, -0.27444449f, 0.42221010f, -0.25657928f, 0.22952534f, -0.02327448f, 
    -0.22265893f, 0.22887903f, -0.05699440f, -0.32278499f, -0.53577524f, 0.11173782f, 0.19242969f, -0.27806994f, 
    0.16576123f, 0.06674249f, 0.26226830f, -0.02123149f, 0.24941337f, 0.09715643f, -0.12851824f, -0.28863865f, 
    0.03833524f, -0.07712091f, 0.22184592f, 0.32204470f, 0.15505068f, -0.20885268f, 0.36129698f, -0.08139414f, 
    -0.08843361f, 0.09954403f, 0.01496635f, 0.05040219f, 0.18075116f, -0.05532993f, 0.21197852f, 0.00742062f, 
    -0.43518123f, -0.06470979f, -0.28886008f, 0.16316476f, -0.10648709f, -0.42421448f, -0.01027844f, -0.31229293f, 
    0.11031295f, 0.36199442f, 0.32759559f, -0.09466040f, 0.03134004f, -0.38042930f, 0.06519108f, -0.18993355f, 
    0.30982068f, -0.23985220f, 0.15650107f, -0.78015900f, -0.20901802f, 0.09538086f, -0.12752147f, 0.18589959f, 
    -0.17567930f, 0.01643504f, -0.48187593f, 0.01291490f, -0.00524197f, -0.09357224f, 0.39006573f, -0.05280123f, 
    -0.03383410f, -0.38894558f, -0.54630834f, -0.47626659f, -0.04800110f, 0.09719753f, 0.07060914f, -0.08556089f, 
    -0.13815086f, 0.14545661f, 0.16094156f, 0.05219758f, -0.38242343f, 0.04373995f, -0.07666529f, -0.26256779f, 
    -0.07585124f, -0.19354337f, -0.05684928f, -0.04813918f, -0.20936963f, -0.04499437f, 0.08758104f, -0.15955770f, 
    -0.02809974f, 0.12551151f, -0.04950670f, 0.03890483f, -0.17736179f, -0.11405227f, -0.20904943f, 0.24778740f, 
    0.03978613f, 0.03203428f, 0.10516471f, 0.06639902f, 0.20246223f, 0.14326444f, -0.06432572f, 0.08565645f, 
    -0.33454612f, -0.51915973f, -0.12320596f, -0.29255337f, 0.20971252f, 0.01725838f, -0.07355290f, -0.20419443f, 
    0.23440576f, 0.10439516f, -0.20999996f, 0.19915093f, -0.36971268f, 0.26718020f, -0.17365465f, 0.00864122f, 
    0.17629823f, -0.12773378f, -0.04824174f, -0.26398942f, -0.09813580f, 0.20356999f, -0.51841128f, -0.03721271f, 
    0.11663955f, 0.02814335f, -0.01458526f, 0.00418168f, 0.14199673f, 0.23271339f, 0.05399747f, 0.31075943f, 
    -0.11836231f, 0.01733423f, -0.04121576f, 0.31089231f, -0.17508994f, -0.19531845f, 0.05287356f, -0.59996426f, 
    0.09816831f, 0.15395372f, 0.02252941f, -0.04829565f, -0.53346515f, 0.19934322f, -0.19762403f, 0.00904791f, 
    0.35805696f, -0.21574369f, -0.63701105f, 0.02996701f, -0.27777150f, -0.11410106f, 0.25840017f, 0.01041164f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.00440282f, -0.00703193f, -0.01319362f, 0.07054513f, -0.00459660f, -0.00566496f, -0.02668785f, -0.10254260f, 
    -0.15263203f, 0.07317030f, 0.02550775f, -0.01001269f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
