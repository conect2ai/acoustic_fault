#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.43112570f, -1.47234094f, 0.08112949f, 0.71789664f, 0.52467132f, 1.02946961f, -0.00854605f, -0.05293471f, 
    -0.13504371f, 0.05308628f, 0.03514480f, 0.22607151f, 0.04293386f, -0.56116128f, -0.07981801f, -0.23393528f, 
    0.15568197f, -0.05418672f, -0.15574698f, -0.23370004f, 0.09178426f, -0.15004425f, -0.36070850f, 0.08166395f, 
    0.21371643f, 0.11480983f, 1.08784938f, 0.95808482f, 0.12704620f, 0.35032806f, -0.90184885f, -0.42205667f, 
    0.15831994f, -0.06750325f, -0.18561560f, -0.79569763f, 0.13839032f, -0.20099500f, -0.44186404f, -0.12412170f, 
    0.12528588f, 0.32656983f, 0.03197750f, -0.03125303f, 0.09999792f, -0.27644834f, -0.24387054f, -0.28696418f, 
    0.02332566f, -0.15019001f, -0.95418990f, -0.43348256f, -0.09773362f, -0.93082851f, -0.84728521f, 0.33733743f, 
    -0.14342667f, -0.04009510f, 0.53451824f, 0.85454571f, -0.69517648f, -0.35928163f, -0.25337031f, -0.17120145f, 
    0.49986345f, -0.39638546f, -0.28058493f, -0.35628736f, 0.22836232f, -0.20968042f, -0.25967851f, -0.65124094f, 
    -0.26375490f, -0.64253742f, -0.67773277f, 0.07696626f, -0.99686629f, 0.20806807f, 1.73381364f, 1.02616811f, 
    0.24703005f, -0.82346630f, -0.92693996f, -0.57144850f, -0.08097465f, 0.21118484f, 0.07084430f, 0.13862988f, 
    0.07207789f, 0.30809620f, -0.29667026f, -0.13644148f, -0.11799458f, 0.13107844f, 0.15157902f, -0.15537249f, 
    0.07763007f, -0.02328915f, 0.29194531f, -0.01158250f, -1.61925280f, -0.22862458f, -0.80216670f, -1.56940305f, 
    -0.55794954f, 0.11157706f, -0.69324976f, -0.50617248f, 0.01428968f, -0.03541363f, -0.56249535f, -0.77404821f, 
    -0.35358396f, -0.58495915f, -0.55126750f, 0.10602865f, -0.39695641f, -0.19079769f, -0.06347401f, -0.22905588f, 
    -0.14982820f, -0.00897281f, -0.08262892f, 0.01710850f, -0.11791268f, -1.34425497f, -0.35740334f, 0.02651587f, 
    -0.15113348f, 1.15949941f, -0.10604462f, -0.48662037f, 0.25739762f, 0.00686576f, 0.17124288f, -0.29300779f, 
    -0.33273354f, -0.54126936f, 0.86692178f, -1.14223278f, 0.40584815f, -0.14586399f, -0.31976810f, 0.50337654f, 
    -0.58934903f, 0.00362755f, 0.25214714f, 0.06696469f, -0.30858997f, -0.35215589f, -1.49610090f, -0.37961704f, 
    -0.43659550f, -1.50086617f, -1.08018470f, 0.27290213f, -1.08697331f, -0.18089795f, -0.11874071f, -0.13560392f, 
    -0.29205003f, 0.20517349f, 0.19521669f, -0.18080164f, -0.08353171f, 0.42843768f, 0.10413475f, 0.16784158f, 
    -0.02727639f, 0.14262636f, 0.15927364f, 0.91995311f, -0.05067196f, -0.08177879f, -0.09306441f, -0.55378753f, 
    -0.95115244f, -0.24070443f, -0.13916752f, -0.49779823f, -0.63217890f, -1.03241622f, -1.06231141f, -0.51406127f, 
    -0.01149881f, -0.27753595f, 0.02135375f, -0.62733233f, -0.40678722f, 0.46063706f, -0.40698984f, -0.51589030f, 
    -0.61380494f, -0.56650889f, -0.91775566f, -0.40090787f, -0.59927821f, -0.27349430f, 0.08858954f, -0.34707525f, 
    1.06601322f, -0.78092957f, -0.35249102f, 0.31448027f, -0.14050949f, -0.80004191f, -0.09917359f, 0.63394821f, 
    0.23895346f, -0.34753177f, 0.22408506f, -0.29508600f, 0.11066645f, -0.00610785f, 0.26044887f, 0.05070324f, 
    0.24547210f, -0.25737557f, -0.22816719f, 0.31983483f, -0.03987786f, -0.31315899f, 0.30728337f, 0.40859196f, 
    0.02835567f, -1.05337691f, -0.33641082f, 0.69606918f, 0.47442746f, 0.05127249f, -1.25394452f, -1.53470850f, 
    -1.29094696f, -0.16454892f, -0.33846155f, 0.13372430f, -0.07281969f, -0.12573825f, 0.15030342f, -0.40052596f, 
    -0.01678693f, 0.43956661f, 0.44281146f, -0.19442396f, -0.35839334f, 0.34775779f, 0.04570886f, 0.31674564f, 
    0.17093891f, 0.17184877f, -1.05493104f, -0.91404909f, -0.60014832f, -0.17183593f, -0.15034163f, 0.76455325f, 
    0.35996982f, 0.23427151f, 0.52773738f, 1.19216335f, -0.04607836f, -0.09970599f, -0.09083030f, -0.03080175f, 
    -0.19552867f, -0.05229526f, 0.02876556f, -0.16336963f, -0.15102814f, 0.08021910f, -0.14929293f, -0.08855162f, 
    0.22491492f, 0.30989248f, -0.08463524f, -0.78936809f, 0.32257280f, 0.29298761f, -0.07146944f, -0.01563653f, 
    0.17663547f, 0.60812914f, 0.40307030f, 0.33611727f, -0.22816020f, -0.75198275f, -0.60270184f, 0.06058832f, 
    0.15468687f, 0.05154327f, -0.21882036f, -0.27378872f, -0.46609589f, -0.73393142f, -0.44989198f, -0.34295034f, 
    -0.48173133f, -0.21727449f, -0.22318380f, -0.39868668f, -0.25896758f, -0.66605133f, -1.00860393f, -0.77950221f, 
    -0.12297653f, 0.19111209f, 0.21469913f, 0.35496309f, 0.77311504f, 0.22740439f, 0.03610720f, 0.46617576f, 
    0.15009241f, -0.02302647f, -0.02185270f, -0.48289138f, -0.56006223f, 0.27043277f, -0.52745968f, -0.62810415f, 
    0.23180333f, 0.32604724f, 0.48976871f, -0.03140708f, 0.25322551f, 0.04055024f, 0.28245431f, 0.48573002f, 
    0.40395907f, 0.47689441f, 0.37760407f, -0.31978983f, -0.38931468f, 0.41767386f, 0.66719317f, -0.00529751f, 
    -0.16826700f, 0.12466246f, 0.16588438f, -0.40654084f, 0.02518103f, -0.25509784f, -0.07625403f, -0.12312426f, 
    -0.33954242f, -0.41531131f, -0.10786477f, -0.16430089f, -0.02938820f, -0.31826159f, 1.33182430f, -0.96659428f, 
    -1.19878531f, -0.46344423f, -0.93915385f, 1.28707743f, 0.30004045f, 0.57407302f, 0.03711536f, -0.06647718f, 
    0.20220166f, -0.07855304f, 0.05185493f, 0.02431291f, -0.04101034f, 0.14124084f, -0.09713462f, -0.05356409f, 
    -0.23993896f, -0.53593475f, -0.46799019f, -0.29412651f, -0.15964572f, -0.32892734f, -0.42890096f, -0.88847548f, 
    -1.21543932f, -0.36986229f, 0.53231430f, 0.95155859f, -1.23555899f, -0.90765673f, 0.77027506f, 0.40648845f, 
    -0.22350012f, 0.02426293f, 0.29512411f, -0.34190783f, 0.67164820f, -0.39586958f, -0.15240155f, -0.23478809f, 
    -0.16820849f, -0.34032205f, 0.32191521f, -0.24114233f, -0.06266149f, -0.15509386f, -0.31514350f, 0.66802579f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.85032815f, 0.45634931f, 0.31570241f, 0.68927020f, -0.65315497f, 0.36132205f, 0.46199849f, -0.29210231f, 
    0.49491635f, 0.09418691f, 0.09111618f, 0.28269306f, 0.57292020f, 0.47975177f, 0.22368316f, 0.69975287f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.09393357f, -0.27061689f, 0.15870382f, -0.23263745f, -0.17754741f, -0.03655295f, 0.00403938f, -0.11986942f, 
    0.00592567f, -0.13230175f, -0.08488516f, -0.24677651f, -1.44801509f, 0.57553446f, -0.06441140f, 0.26353186f, 
    0.00109160f, 0.05127626f, 0.00912851f, 0.11181870f, -0.07740281f, 0.03410529f, 0.02698760f, 0.03310734f, 
    0.08731321f, 0.17872052f, 0.06245666f, -0.21772103f, 0.15275213f, 0.19668226f, -0.16567621f, -0.09380440f, 
    0.14231071f, 0.01008700f, -0.01329011f, 0.20018099f, -0.15479848f, -0.02444696f, 0.07221738f, -0.08993074f, 
    -0.27954146f, -0.23171607f, 0.00666745f, -0.27055424f, -0.02275387f, -0.08234279f, 0.01141840f, -0.06058683f, 
    0.26765713f, 0.40333652f, 0.03430766f, -0.21559033f, 0.20941623f, 0.53450066f, 0.19908108f, 0.24893992f, 
    0.00705745f, -0.02022159f, -0.06909579f, -0.09775156f, 0.44034860f, 0.17519684f, -0.01341999f, -0.22159095f, 
    -0.17179064f, 0.21497267f, -0.06482054f, -0.08392686f, 0.00647193f, -0.02433367f, -0.36629039f, -0.11047837f, 
    0.40813193f, 0.23595239f, -0.14179163f, -0.38667536f, -0.24309291f, 0.34817505f, -0.37465996f, -0.12164283f, 
    -0.02622333f, 0.04265345f, 0.09641496f, 0.08139704f, 0.46348307f, 0.37841001f, 0.06224761f, -0.37726116f, 
    0.00440080f, -0.10819612f, 0.01470518f, -0.14148897f, -0.10035574f, -0.19800085f, -0.16045745f, -0.01979262f, 
    -0.06020133f, -0.11416006f, 0.00019958f, -0.18600464f, -0.33919260f, -0.36338320f, -0.29030326f, -0.24781083f, 
    -0.31020409f, -0.06026776f, -0.15443195f, 0.02417646f, 0.37403190f, 0.49992079f, 0.11306338f, -0.57230252f, 
    -0.01668771f, -0.06640023f, -0.19368920f, 0.07337368f, 0.12548991f, -0.17651178f, -0.05996046f, -0.02748936f, 
    0.24404487f, -0.08183298f, 0.13799159f, 0.05417624f, 0.14323345f, 0.13963275f, 0.13099486f, -0.10979327f, 
    0.03441931f, 0.24988690f, -0.03162423f, -0.20429018f, -0.07548913f, -0.59332228f, 0.01946966f, -0.10086069f, 
    -0.03613840f, 0.05383538f, -0.04646251f, 0.11215378f, 0.00786886f, -0.08580523f, 0.16355358f, 0.12496437f, 
    0.07265373f, -0.24513723f, -0.24791931f, 0.01001874f, 0.18097204f, 0.13721882f, -0.02433005f, -0.36512581f, 
    -0.16922802f, -0.26350921f, -0.21755292f, -0.10176511f, -0.77237475f, -0.33947664f, -0.05486548f, -0.04402099f, 
    0.11475553f, 0.03518797f, -0.02243150f, 0.00037910f, -0.14145637f, -0.13163842f, -0.16708001f, 0.10773097f, 
    0.17520517f, -0.42532140f, -0.54959708f, 0.06592137f, 0.08786248f, 0.09477407f, 0.01650620f, 0.14155793f, 
    -0.00383391f, -0.05891722f, -0.02887843f, 0.17758998f, 0.28279164f, 0.37641069f, 0.16852662f, -0.52100140f, 
    0.04034016f, -0.13460672f, -0.08452499f, -0.19912212f, -0.07676942f, -0.22381741f, -0.14122379f, -0.11561845f, 
    0.48881072f, -0.12158678f, -0.09055166f, 0.41744933f, -0.10062221f, -0.00072572f, 0.02128684f, -0.04648454f, 
    0.27174574f, 0.10685848f, -0.11625604f, 0.29393342f, 0.28783682f, 0.14027849f, 0.17518727f, -0.27461258f, 
    0.01815434f, -0.02937448f, -0.13803679f, -0.12881061f, 0.10670473f, 0.08689322f, -0.02688961f, 0.03133934f, 
    -0.07199752f, 0.27020809f, -0.03627481f, -0.15868008f, 0.18967083f, 0.18014526f, -0.21819498f, -0.25587749f, 
    -0.31089312f, -0.00546379f, -0.18495391f, -0.71402645f, -0.04299616f, 0.09784042f, -0.27204320f, 0.08867776f, 
    -0.00449075f, -0.15102847f, 0.05708586f, 0.04861762f, -0.12466681f, -0.01966686f, 0.05032767f, 0.08135471f, 
    0.38943422f, 0.63312125f, 0.15290615f, 0.27936107f, 0.06744035f, 0.03360710f, -0.15647933f, -0.07933095f, 
    0.02417142f, 0.05986924f, -0.15479465f, -0.05112712f, -0.64326525f, -0.29959175f, -0.18906426f, 0.06787269f, 
    0.13830107f, -0.15929247f, 0.22211140f, -0.02259719f, 0.03360512f, -0.15509446f, -0.09146441f, -0.01853742f, 
    -0.12179191f, 0.49301764f, 0.15152861f, 0.15062445f, -0.07424533f, 0.09636439f, -0.25205284f, 0.15053110f, 
    -0.30746257f, -0.05403356f, 0.02169473f, -0.00270877f, 0.06495414f, -0.05954198f, 0.04288774f, -0.35819250f, 
    -0.06388453f, -0.12181143f, -0.12450263f, 0.48475277f, 0.01146941f, -0.04753426f, 0.21057275f, 0.02364022f, 
    0.19134070f, 0.20219707f, 0.21094242f, 0.07566112f, -0.14377892f, 0.29854167f, 0.50229239f, -0.44398236f, 
    0.04945692f, -0.01910540f, 0.10361724f, 0.02403582f, -0.58438897f, 0.18747269f, -0.31808743f, -0.32616198f, 
    -0.00634925f, -0.22378497f, 0.03973062f, 0.25252756f, -0.03650077f, 0.05047183f, 0.03905831f, 0.00788403f, 
    0.29806754f, 0.27320057f, -0.35490161f, -0.16200794f, -0.16040303f, -0.09558130f, -0.01981761f, -0.16529359f, 
    0.03111001f, -0.06341483f, 0.02436382f, 0.16728760f, -0.12390038f, -0.22310722f, 0.42959487f, 0.17792383f, 
    -0.01075669f, 0.00097597f, 0.06801024f, -0.06370768f, -0.10165066f, -0.19870076f, -0.31916681f, -0.48351815f, 
    -0.48618457f, -0.07444958f, -0.22886363f, -0.34979826f, -0.02728015f, 0.26298243f, 0.01901735f, 0.38038930f, 
    0.02036993f, 0.30020651f, -0.01676281f, -0.19377777f, 0.06190864f, 0.25132182f, -0.02504529f, 0.22951068f, 
    0.02886540f, 0.04346546f, -0.06582906f, -0.03649286f, 0.08993938f, 0.23178121f, -0.04308443f, -0.05324847f, 
    0.73521394f, -0.25651640f, -0.29342499f, -0.11813297f, 0.05924495f, -0.07137658f, -0.05061409f, -0.11030553f, 
    -0.03196868f, -0.02282526f, -0.04169428f, 0.00606337f, -0.96105093f, -0.02015772f, -0.51732051f, -0.06465270f, 
    0.12039889f, 0.06232233f, 0.43414152f, -0.16545713f, -0.03053821f, 0.05615892f, -0.07950462f, 0.16400735f, 
    0.33644062f, 0.13355374f, -0.33068448f, 0.05253742f, -0.03267221f, -0.02778894f, -0.03549995f, 0.19648401f, 
    -0.00988244f, -0.10458454f, -0.13500361f, -0.13875633f, -0.33361614f, 0.06365380f, 0.21177235f, -0.10210808f, 
    -0.03486383f, 0.01640587f, 0.02301118f, 0.05458860f, -0.02750842f, -0.00514223f, -0.03937533f, 0.03718012f, 
    0.35415402f, 0.32303765f, 0.45704237f, 0.51849174f, -0.06114679f, -0.01477484f, 0.07982717f, 0.06675995f, 
    0.09704667f, -0.05436617f, 0.05027372f, 0.09167858f, -0.19464821f, 0.76517278f, -0.38342121f, 0.15748309f, 
    -0.16651292f, -0.09868334f, -0.10828754f, 0.17828991f, -0.10467286f, -0.02963422f, -0.00647223f, -0.08425824f, 
    -0.79094446f, 0.49678293f, -0.27038592f, 0.37423718f, 0.17045891f, 0.03288979f, -0.03017245f, -0.06429578f, 
    -0.11414859f, -0.06335651f, -0.01033787f, -0.07369453f, -0.14388618f, -0.38926524f, -0.09049527f, 0.32470903f, 
    0.06133270f, 0.00399685f, -0.01757327f, 0.02427182f, 0.04405590f, -0.19644837f, 0.21381515f, 0.03708830f, 
    0.03355261f, 0.43809891f, -0.33191505f, 0.68858457f, -0.05984807f, -0.07235298f, 0.04008242f, 0.02689482f, 
    0.02020186f, -0.02222784f, -0.01880895f, 0.09588747f, -0.42511338f, -0.56038809f, 0.13338053f, -0.24464610f, 
    0.02301328f, -0.02241602f, -0.00972732f, -0.30439579f, 0.00399943f, -0.02040725f, -0.18862548f, 0.01122717f, 
    -0.32799345f, 0.19244534f, -0.05552420f, 0.22988743f, -0.26819292f, 0.08054432f, 0.10143206f, -0.65037209f, 
    0.02723798f, 0.07935561f, -0.07968580f, -0.01791158f, -0.84418577f, -1.04375637f, -0.56499070f, -0.38663328f, 
    0.02665021f, 0.07252616f, 0.07791429f, 0.12198001f, -0.04113887f, -0.11687703f, 0.09795608f, -0.12757055f, 
    -0.13460419f, -0.00353962f, 0.54957032f, 0.43823120f, -0.02628129f, -0.05244859f, 0.10741995f, -0.07048786f, 
    -0.05700928f, -0.12293956f, -0.08559606f, -0.19866757f, 0.04371091f, 0.09608202f, -0.28552070f, -0.29873845f, 
    -0.00137158f, 0.00266300f, 0.01874054f, 0.00123865f, 0.03353560f, 0.16364734f, 0.27868906f, -0.11098451f, 
    -0.02907273f, 0.50385368f, 0.17356530f, -0.04324760f, -0.04428321f, 0.10953549f, 0.18840428f, -0.34689751f, 
    -0.23937164f, -0.17960007f, -0.16057295f, -0.03446297f, -0.35898674f, -0.00514639f, -0.11037475f, 0.04287598f, 
    0.03338913f, -0.02632093f, -0.01132252f, 0.05401394f, -0.02637821f, -0.17290437f, 0.35904625f, 0.01567680f, 
    -0.12499610f, 0.36588812f, 0.34504005f, -0.02626793f, -0.11084395f, -0.08162158f, 0.12741989f, -0.21045592f, 
    0.19155191f, 0.06073954f, 0.10234837f, 0.20611520f, 0.10523356f, -0.03309791f, -0.85870302f, 0.16367313f, 
    -0.00985332f, 0.14187168f, -0.13157263f, 0.08898353f, -0.09765987f, 0.16955189f, -0.00640159f, 0.05796149f, 
    -1.13009572f, 1.51118374f, 0.09916467f, -0.77525342f, 0.22331078f, -0.26460463f, 0.04983689f, -0.52193052f, 
    -0.25818542f, 0.11044762f, -0.11198155f, -0.01650084f, 0.14991297f, -0.15156171f, 0.63434923f, -0.32769778f, 
    -0.65430379f, -0.18554249f, 0.21465652f, -0.00370453f, 0.11746018f, 0.14834748f, 0.01682384f, 0.18043344f, 
    0.47001782f, -0.16049030f, 0.07121247f, 0.21863174f, 0.08646256f, 0.03811731f, 0.05997403f, -0.08735288f, 
    0.13371237f, -0.02270891f, -0.00514745f, 0.03918085f, -0.09717759f, 0.71846539f, -0.23868182f, 0.40743086f, 
    -0.05657120f, -0.33769864f, -0.10035352f, -0.06424018f, -0.06343039f, -0.09072518f, -0.12834625f, 0.23086424f, 
    0.58568335f, -0.39463928f, -0.09944169f, 0.29472035f, -0.09364257f, -0.11653176f, -0.03460404f, -0.02204094f, 
    -0.02447638f, 0.02182219f, 0.09815819f, 0.08035868f, 0.36132604f, 0.11945441f, -0.38382342f, -0.45547888f, 
    -0.21758690f, -0.13182123f, -0.18257254f, 0.12448272f, -0.07330508f, -0.11368011f, 0.13483524f, 0.14805254f, 
    0.34398076f, -0.39456320f, -0.05827296f, 0.33162424f, 0.04014902f, -0.09487260f, -0.28518274f, 0.07345619f, 
    -0.04855414f, 0.00917539f, 0.03380030f, 0.14987741f, -0.18217897f, -0.10635164f, -0.24593572f, 0.32273620f, 
    0.03495203f, 0.07429659f, 0.05184931f, 0.03285873f, 0.00436508f, 0.17239885f, -0.12730938f, 0.08398969f, 
    -0.56381541f, 0.00803385f, 0.08218997f, -0.08586410f, -0.10808161f, -0.60252023f, -0.19443758f, -0.40579271f, 
    -0.39961243f, -0.04988862f, -0.20352404f, -0.45375913f, 0.21861736f, 0.04237219f, -0.01039031f, 0.23924524f, 
    -0.21808562f, 0.13723442f, 0.09199075f, 0.06444196f, -0.08858407f, 0.01708754f, -0.09714764f, -0.05969886f, 
    0.06760230f, -0.45283076f, 0.02368549f, -0.31833798f, 0.36797634f, 0.32307294f, 0.22434466f, 0.05959079f, 
    -0.13834035f, -0.17545600f, -0.05695578f, 0.04960852f, 0.52520275f, 0.58128476f, 0.03473821f, -0.33448815f, 
    -0.13502811f, -0.08925778f, -0.10873473f, -0.01703890f, -0.19278763f, -0.04347318f, 0.07762561f, -0.17988284f, 
    0.21112175f, 0.02066338f, -0.04204389f, 0.46854910f, 0.25122336f, -0.07544586f, 0.08089725f, -0.09386896f, 
    0.10055858f, 0.06311878f, -0.02812831f, -0.02675765f, -0.42304114f, 0.34207958f, 0.16368484f, -0.71581084f, 
    -0.30142555f, -0.06761194f, -0.17736882f, -0.20145820f, 0.08491070f, 0.10951912f, 0.12404078f, -0.13320379f, 
    -0.58651203f, -0.00776285f, 0.11373389f, 0.28914765f, 0.12523279f, 0.19710141f, 0.10197381f, 0.01655689f, 
    -0.06769599f, -0.01345424f, 0.09195361f, 0.18188323f, 0.09670943f, -0.21407829f, -0.44975519f, -0.32976460f, 
    -0.04755456f, -0.03277806f, -0.11768959f, 0.02402725f, 0.04474229f, -0.00136665f, -0.02792804f, -0.08209067f, 
    0.45345807f, -1.01750648f, -0.46527267f, -0.46188194f, 0.12828425f, 0.08417868f, -0.02933713f, 0.02720546f, 
    -0.10397343f, -0.00559347f, -0.10814787f, -0.17484823f, 0.63357627f, 0.16955429f, -0.31894624f, 0.34546924f, 
    0.17815423f, 0.02300990f, 0.14169383f, 0.08079145f, 0.15773618f, -0.07050021f, 0.16112036f, 0.01431496f, 
    -0.20254336f, 0.15910688f, -0.16364130f, 0.11267299f, -0.14121009f, -0.06964090f, 0.06975744f, -0.01913830f, 
    0.12980528f, 0.10594713f, -0.00779453f, 0.23819819f, -0.06371358f, -0.33955699f, 0.45849639f, 0.05592332f, 
    0.00939955f, 0.00584895f, -0.09079986f, 0.18209060f, -0.09096820f, -0.06038888f, -0.10440860f, 0.01367549f, 
    -0.15238865f, -0.27181149f, -0.01469814f, 0.26123348f, 0.09374928f, -0.09997504f, 0.12636930f, -0.00463147f, 
    -0.00513352f, -0.10434349f, 0.05229191f, 0.07781097f, -0.23682891f, -0.31259856f, 0.32490900f, -0.23396178f, 
    -0.20431846f, -0.14935169f, -0.38278791f, -0.18774192f, -0.15114573f, -0.00412826f, -0.08999705f, 0.22537112f, 
    -0.05583443f, -0.00671020f, 0.26754135f, 0.03252232f, -0.10566358f, -0.37501299f, 0.05647057f, -0.17684819f, 
    0.22535340f, -0.01028940f, 0.06944146f, 0.04324321f, 0.21747048f, 0.28351370f, 0.22699469f, 0.39261648f, 
    -0.00509332f, 0.20491278f, 0.01770657f, -0.08314879f, -0.19978985f, 0.17418258f, -0.03102109f, 0.10006493f, 
    0.02955885f, -0.31814775f, 0.10292976f, -0.14068936f, -0.28937045f, -0.15169893f, -0.23222589f, 0.08042052f, 
    0.00420833f, -0.14322676f, -0.14652464f, 0.01467651f, -0.06989358f, 0.02215566f, 0.39982551f, 0.33435485f, 
    -0.05954841f, 0.10121293f, 0.07914441f, -0.15610373f, -0.10198003f, -0.06886265f, -0.01965947f, -0.19556114f, 
    0.22938830f, 0.45218951f, -0.18037044f, 0.07005595f, -0.15218244f, -0.07924926f, 0.12501602f, 0.24810655f, 
    0.02115295f, -0.14605264f, -0.08022921f, -0.05402495f, -0.18012059f, -0.22803268f, 0.00149336f, -0.22759244f, 
    0.00684680f, -0.04461445f, 0.07400035f, 0.06053059f, -0.01438214f, -0.02231334f, 0.11196546f, 0.15710424f, 
    0.12891516f, 0.09289459f, 0.22397348f, 0.23102561f, -0.04538984f, 0.06823440f, -0.24279115f, -0.20174113f, 
    0.00731646f, -0.41430008f, -0.23785913f, -0.06849308f, 0.05594615f, -0.43626234f, -0.10814759f, -0.10528691f, 
    0.04104888f, 0.03659511f, 0.06301419f, 0.06560713f, 0.06203906f, 0.01623217f, -0.15382636f, 0.28395239f, 
    -0.13717782f, -0.10255512f, 0.25215665f, 0.07373962f, -0.05274723f, -0.15493143f, -0.00499173f, -0.07512903f, 
    0.28448701f, -0.10219884f, -0.06118268f, 0.30243558f, 0.07302995f, -0.21899527f, 0.46149135f, -0.07109381f, 
    -0.46857762f, -0.20462072f, -0.39742720f, -0.17115358f, -0.00315997f, -0.03661977f, 0.04158545f, 0.01949730f, 
    -0.09487608f, -0.28612593f, 0.33477175f, 0.02274537f, 0.10565331f, -0.12063132f, -0.08979771f, 0.07386229f, 
    0.08783071f, 0.05501740f, 0.22599453f, -0.05083410f, -0.59552336f, -0.68899357f, -0.19367354f, 0.40820220f, 
    0.11941563f, 0.00949090f, -0.00799677f, 0.08528572f, -0.09255163f, -0.07918148f, 0.02007792f, -0.14139210f, 
    -0.26778895f, -0.14790834f, 0.26611134f, -0.12178724f, -0.01018019f, -0.16101718f, 0.05585144f, 0.15768033f, 
    -0.08400660f, -0.04978633f, -0.04677296f, -0.30799708f, 0.11411648f, -0.29835266f, 0.33231544f, -0.23085146f, 
    -0.06377684f, 0.12586947f, 0.22722000f, 0.02817567f, 0.11402125f, 0.05619110f, 0.00692486f, 0.02891682f, 
    -0.33170843f, 0.20471182f, 0.24556282f, -0.30537999f, 0.00724259f, -0.07674498f, -0.18939957f, -0.14159039f, 
    -0.00254990f, -0.00820666f, -0.04038673f, 0.03095723f, -0.56918150f, 0.27148041f, 0.43778649f, -0.04719776f, 
    -0.02672901f, -0.19765119f, 0.22594509f, 0.02473339f, -0.10411043f, 0.10076378f, -0.01921072f, -0.24836436f, 
    -0.09635304f, 0.06042674f, 0.05556823f, -0.32826096f, 0.41688752f, 0.09492683f, 0.26724991f, 0.10112396f, 
    0.01072891f, 0.06466820f, 0.08108284f, -0.03230004f, 0.10258663f, -0.00247696f, 0.31548190f, -0.10299572f, 
    -0.01098937f, -0.02488300f, 0.08808975f, -0.00853942f, 0.25335205f, 0.07040322f, -0.14914733f, 0.03808738f, 
    0.06716653f, -0.29624471f, -0.19805034f, -0.08692595f, 0.31702754f, 0.27634069f, -0.39489648f, 0.12386512f, 
    0.09890904f, 0.03495288f, -0.06119074f, 0.02796054f, 0.29281068f, -0.03902811f, 0.55968171f, -0.11724780f, 
    0.09317948f, 0.04651021f, 0.08988626f, 0.06559841f, 0.03425927f, 0.08532356f, 0.10958474f, 0.03449892f, 
    -1.03714013f, -0.92996365f, -0.23339026f, -0.13965371f, 0.01735421f, -0.12087668f, -0.15330015f, -0.04675384f, 
    0.08534367f, -0.06518152f, -0.03052427f, 0.13852185f, 0.06869714f, 0.08696664f, -0.19631977f, 0.31000516f, 
    -0.00355857f, 0.03964880f, 0.11303948f, -0.04019954f, 0.07574032f, -0.14191787f, -0.27204928f, -0.23467447f, 
    0.31899464f, -0.23246916f, -0.16889161f, -0.31861413f, -0.03179146f, -0.24788831f, 0.11085854f, -0.18415342f, 
    0.28832889f, 0.13365085f, 0.25149512f, -0.06352744f, -0.16462663f, -0.44619563f, 0.19249988f, 0.13446829f, 
    -0.06808684f, -0.05588681f, 0.09179623f, 0.04165374f, 0.08969822f, -0.20892574f, -0.00044258f, -0.07692572f, 
    0.02461657f, -0.19477758f, -0.37841144f, -0.59545922f, -0.05991697f, 0.11940869f, -0.00781283f, 0.12224057f, 
    -0.01848073f, -0.28420493f, -0.18016997f, -0.45373553f, 0.42663419f, -0.15901914f, 0.39777792f, 0.30627370f, 
    -0.11345726f, 0.25661287f, 0.13176121f, -0.03381945f, -0.01356421f, 0.02084256f, -0.11470738f, 0.15640393f, 
    -0.05297098f, 0.09389108f, 0.38537273f, 0.10023391f, 0.11172625f, 0.08493669f, 0.06303961f, 0.14788978f, 
    -0.05224435f, 0.04526899f, 0.11545504f, -0.25013649f, -0.30538380f, -0.15786055f, -0.42099082f, -0.46209806f, 
    -0.00026123f, 0.10704319f, 0.11063904f, -0.15321793f, -0.17687830f, 0.02272742f, 0.04799556f, 0.02460754f, 
    -0.19173820f, -0.20958437f, -0.02921816f, 0.47390923f, -0.23531044f, 0.11537737f, 0.07160261f, 0.02238132f, 
    0.08962885f, -0.14299168f, 0.00649556f, 0.19542319f, -0.78052807f, -0.55439323f, 0.03414375f, 0.68098754f, 
    0.35134032f, 0.26339942f, -0.21222381f, 0.07753804f, -0.04382341f, -0.09459110f, -0.04200571f, -0.07950749f, 
    -0.61731052f, -1.24442649f, -0.40570530f, 0.22423227f, -0.17155874f, -0.19637181f, -0.24297775f, -0.14312068f, 
    -0.09941801f, 0.09215035f, -0.00601069f, 0.00297075f, 0.69881821f, -0.31733647f, 0.32466108f, -0.53334516f, 
    0.03011040f, -0.01861399f, 0.12449477f, 0.46069703f, 0.03090826f, 0.32079515f, 0.16998525f, 0.00414382f, 
    -1.18606234f, -0.26259485f, 0.11019886f, -0.30063021f, 0.13416010f, -0.12240753f, -0.13865671f, -0.35738793f, 
    0.04659160f, 0.00916045f, -0.04083711f, -0.05079126f, -0.79372972f, -0.90547568f, -0.71323359f, -0.27252749f, 
    -0.04253994f, 0.05918705f, -0.24282923f, -0.02370178f, -0.02689320f, -0.10141060f, 0.22391406f, -0.04711882f, 
    0.06948659f, 0.50346178f, -0.32920566f, -0.15799470f, -0.24736543f, 0.15325475f, 0.03646534f, 0.27402645f, 
    0.20287877f, -0.22958662f, 0.01039390f, -0.14899200f, -1.32406199f, -1.27910185f, -1.58375347f, -0.31606621f, 
    -0.32329956f, 0.07350209f, -0.40508497f, -0.41755426f, 0.04247982f, -0.04807438f, -0.04968222f, 0.06892220f, 
    -0.66403896f, 0.26187786f, 0.30936238f, 0.30849499f, -0.10038587f, -0.09533542f, -0.21031956f, 0.39388233f, 
    -0.30634266f, 0.13130070f, 0.11349950f, -0.12037981f, 0.08597887f, 0.05474009f, 0.17611031f, -0.56068850f, 
    -0.07990585f, -0.03572378f, -0.05375104f, 0.04743331f, 0.03433403f, 0.28130227f, 0.39596283f, 0.54476720f, 
    -0.30076131f, 0.94042122f, 0.19325373f, 0.27127373f, -0.08632712f, -0.07591438f, -0.36431769f, 0.21553847f, 
    -0.22804438f, 0.13067965f, -0.10603995f, 0.19556899f, 0.19171156f, -0.04909170f, -0.10170987f, -0.03769199f, 
    0.10119078f, 0.13378583f, -0.13044287f, 0.13098025f, -0.12134581f, 0.07570370f, -0.22947234f, -0.08073530f, 
    -0.07616199f, 0.90939665f, 0.18912853f, -0.04279765f, -0.08135176f, 0.04324859f, 0.05927986f, -0.07762511f, 
    0.11686153f, 0.00237607f, 0.21485996f, 0.07980616f, -0.15959121f, 0.36830857f, 0.02281017f, -0.05219723f, 
    -0.23576409f, -0.24646457f, 0.05543682f, 0.29535136f, 0.00527725f, -0.02669343f, 0.19706619f, -0.09942705f, 
    0.14724296f, 0.10458838f, 0.27178615f, -0.54693556f, 0.03854373f, -0.02054423f, 0.00036432f, 0.02339346f, 
    -0.03654082f, -0.13106942f, -0.11471819f, -0.46126261f, 0.04267129f, 0.36497727f, -0.34287396f, -0.14956425f, 
    0.10061084f, -0.08636590f, -0.11628632f, -0.14222515f, 0.10871682f, 0.17521995f, 0.15397713f, 0.00745297f, 
    0.27641818f, -1.18536532f, -0.65163767f, -0.42770764f, -0.04738403f, -0.13000709f, -0.29310325f, 0.11536434f, 
    0.18951432f, -0.09500973f, -0.03133664f, 0.30963874f, 0.05889351f, -0.46265298f, 0.23147050f, -0.51528656f, 
    0.12434682f, 0.10136323f, 0.08251642f, -0.02152624f, 0.08403946f, 0.13572109f, 0.06387641f, -0.12971282f, 
    -0.61778909f, -0.23059788f, -0.25312251f, 0.28793117f, -0.02486281f, 0.13223752f, -0.12220356f, 0.27643281f, 
    -0.01416349f, -0.00040993f, -0.02755919f, 0.04248635f, 0.47058135f, -0.01651923f, -0.45624679f, 0.00751467f, 
    0.09151690f, 0.28994155f, -0.38416472f, 0.01665289f, -0.04710576f, 0.10219030f, -0.34755576f, -0.19675267f, 
    -0.34376618f, -0.84560603f, -0.58643514f, -0.87565255f, 0.10649475f, -0.08773596f, -0.13101463f, -0.07798082f, 
    0.14048848f, -0.03251775f, 0.05641430f, 0.05367354f, -0.36348909f, -0.93412197f, 0.76919585f, 0.43300068f, 
    -0.01441745f, -0.05350588f, 0.20224980f, 0.14396864f, -0.19291894f, -0.04161429f, 0.05826877f, 0.08703389f, 
    -0.09358308f, -0.03239343f, -0.15404031f, -0.01864682f, 0.32208303f, 0.06058101f, 0.22678961f, -0.39592707f, 
    -0.19192055f, 0.28634930f, -0.11307423f, 0.02046114f, -0.50309026f, -1.42163873f, 0.80421102f, 0.89404011f, 
    -0.08051217f, 0.13196778f, -0.13965109f, 0.11730233f, -0.04886927f, -0.05018947f, -0.13188376f, -0.11280040f, 
    0.89697093f, -0.34647289f, -0.12788528f, -0.26182657f, 0.02429832f, 0.14317730f, -0.09416133f, 0.08817980f, 
    0.04144975f, 0.18454637f, 0.02480427f, -0.23561756f, 0.12742971f, -0.03552904f, -0.26191005f, 0.28375849f, 
    0.02743745f, 0.05288963f, -0.08503978f, 0.01746081f, 0.08046895f, -0.03867292f, 0.08008902f, 0.06748633f, 
    0.50844389f, -1.02315497f, -0.49435800f, -0.67334086f, -0.12602063f, -0.04387110f, 0.04183025f, -0.04340362f, 
    -0.08258638f, -0.17019312f, 0.25132170f, 0.12783477f, 0.19716656f, 0.08085542f, 0.09116616f, -0.23301093f, 
    0.04731201f, -0.03195115f, -0.16941381f, -0.07817623f, 0.05845006f, -0.14864092f, -0.12965405f, 0.02552605f, 
    -0.00542524f, -0.42858130f, 0.14605512f, -0.02020412f, -0.06541376f, 0.02695420f, 0.08247335f, 0.06709678f, 
    0.17619696f, 0.21309948f, -0.01064090f, -0.11825608f, 0.50971055f, -0.13288248f, -0.46253374f, 0.11229319f, 
    -0.18966448f, 0.28725109f, 0.03903401f, -0.05945341f, -0.29628152f, 0.11686348f, -0.03947956f, -0.03533383f, 
    0.37744340f, -0.19070941f, -0.51899487f, -0.16867870f, -0.19722278f, -0.21314812f, 0.20575154f, -0.30413631f, 
    0.07157200f, -0.17002642f, -0.01229510f, 0.25651434f, 0.00724283f, 0.31926915f, 0.26845536f, 0.02153134f, 
    -0.20819569f, -0.04431165f, -0.13688171f, -0.14184581f, -0.13649929f, -0.27218103f, 0.04140707f, -0.19189925f, 
    -0.16265582f, -0.24026702f, -0.20993592f, 0.21291552f, 0.29646790f, 0.16427955f, 0.05489242f, 0.35805002f, 
    -0.40665239f, 0.06897776f, -0.02675271f, -0.68085706f, 0.68960577f, 0.11722939f, -0.01246358f, -0.27087331f, 
    -0.36223370f, -0.17681573f, -0.11708666f, -0.52422190f, 0.25076243f, 0.30189702f, 0.09277610f, 0.23671405f, 
    -0.30208150f, -0.75293869f, -0.98001891f, -0.68932849f, -0.27883643f, -0.04534998f, 0.19153927f, -0.03837090f, 
    -0.07359719f, -0.00539940f, 0.02795505f, -0.00404814f, 0.62177396f, 0.08919975f, -0.29702455f, -0.26119387f, 
    0.11709809f, -0.00319776f, 0.27365184f, 0.31506094f, 0.02169791f, 0.02730634f, 0.05830222f, 0.08144403f, 
    -0.17133287f, -1.22018683f, -0.64225942f, 0.17647566f, 0.28341216f, 0.20775877f, 0.00184564f, 0.29871535f, 
    -0.51892501f, -0.12707655f, -0.10640760f, 0.06166774f, 0.33345330f, -0.91139024f, -0.27918151f, -0.80851948f, 
    0.14119516f, -0.01114169f, 0.14021686f, 0.05263057f, 0.13438541f, -0.16899863f, -0.16206707f, -0.34395510f, 
    0.03245792f, -0.00129044f, -0.25305527f, -0.10441659f, 0.23831101f, 0.04556586f, -0.08610103f, -0.12109102f, 
    0.26940298f, 0.09637763f, 0.29917696f, 0.36686823f, 0.86044878f, 0.17987879f, -0.25046331f, -0.43513569f, 
    0.31974253f, -0.22868237f, -0.23642212f, 0.04304216f, 0.15547067f, 0.04039324f, 0.02766013f, 0.17057055f, 
    -0.29305848f, -0.40587169f, -0.43553922f, 0.09595904f, -0.23196518f, 0.11022964f, 0.05865672f, -0.02186709f, 
    0.34060615f, 0.09700231f, 0.15226963f, 0.07570004f, -0.14832142f, 0.01353222f, -0.04995512f, -0.05536076f, 
    -0.16483854f, -0.01032394f, -0.14558889f, 0.20822778f, 0.11794253f, 0.19830449f, 0.00437593f, -0.24189247f, 
    -0.69675547f, -0.27810180f, -0.12323183f, -0.02513886f, 0.12355194f, 0.30628723f, 0.15274112f, -0.05311147f, 
    -0.06272203f, 0.05707703f, 0.13386804f, 0.17352621f, 0.12934406f, 0.24151066f, -0.17929021f, -0.30828869f, 
    -0.05521521f, -0.11439667f, -0.09438759f, -0.07862008f, -0.25806946f, 0.10798201f, 0.07523980f, -0.04810057f, 
    -0.51400977f, -0.34604496f, 0.00048027f, 0.16011526f, 0.00180026f, 0.09428520f, 0.06269763f, 0.04167435f, 
    -0.16254164f, -0.26365033f, -0.32912642f, -0.29009485f, 0.79998904f, -0.09417750f, -0.87708288f, 0.06384034f, 
    -0.05262133f, 0.15736811f, 0.26395664f, 0.03196653f, 0.29192445f, -0.09942686f, 0.40051588f, 0.08752786f, 
    -0.02603896f, -0.53345990f, 0.28167972f, -0.05687349f, 0.22617835f, 0.07038623f, -0.07750010f, -0.01481779f, 
    -0.10814588f, 0.36206439f, 0.12217231f, 0.12657478f, -0.52715212f, -0.34436396f, -0.80701631f, 0.19470939f, 
    0.22285031f, 0.21214551f, 0.19840345f, 0.10730702f, 0.04813314f, -0.18356781f, 0.13169110f, 0.08042350f, 
    -0.09853662f, -0.14295281f, 0.06942170f, -0.27686238f, -0.09221825f, -0.10803608f, -0.14283569f, -0.14421637f, 
    0.06047862f, -0.01336318f, 0.19503531f, 0.24152398f, 0.72040266f, -1.56129611f, 0.15716359f, -0.36904454f, 
    0.10152216f, 0.31272942f, -0.09338429f, 0.02355893f, -0.39235196f, -0.07315131f, -0.04645830f, -0.28514370f, 
    -0.44770098f, -0.00312426f, 0.44539830f, -0.49248889f, -0.03298475f, -0.10346728f, 0.02951867f, -0.05353911f, 
    0.09407269f, 0.13918558f, 0.10233992f, -0.10332324f, -0.32696837f, -0.06340431f, -0.54705101f, 0.78953278f, 
    0.11360251f, -0.04374303f, -0.37025109f, -0.19159858f, 0.14308113f, -0.16092363f, -0.09948948f, -0.25289896f, 
    -0.17419811f, 0.24518548f, 0.09124748f, -0.78468329f, -0.27988797f, 0.04807806f, 0.01920264f, -0.13932924f, 
    0.17700735f, -0.02135428f, 0.01453499f, -0.02271188f, 0.02196341f, -0.28024614f, 0.10707175f, 0.05011375f, 
    -0.05788459f, 0.07023598f, 0.11720224f, 0.16539003f, 0.02618271f, 0.15511335f, 0.00362433f, 0.04150560f, 
    -0.11174743f, -0.23838066f, 0.09820199f, -0.14749232f, 0.49833617f, -0.24520984f, -0.29583055f, -0.06032250f, 
    -0.21966466f, 0.02092188f, -0.18163781f, -0.17064105f, -0.09033611f, -0.21545899f, -0.97488427f, 0.29682913f, 
    -0.02596228f, -0.13148324f, -0.03643743f, -0.06533021f, -0.10662089f, 0.13865218f, 0.04055052f, -0.06792856f, 
    0.47885543f, 0.43065923f, 0.56714410f, 0.39741415f, 0.03755516f, 0.15269057f, -0.22403231f, -0.37641245f, 
    -0.09166530f, -0.16354229f, 0.00247623f, 0.03979362f, -0.20937194f, 0.15005650f, -0.28640339f, 0.57753474f, 
    0.05819826f, -0.06412873f, 0.04742735f, 0.05198724f, -0.11134157f, 0.09080036f, 0.07998778f, 0.20642866f, 
    0.38023221f, 0.20104043f, 0.74992687f, -0.16009882f, 0.34568739f, -0.55097574f, -0.16779572f, -0.39019772f, 
    -0.05581309f, 0.03069391f, -0.18016884f, 0.01675480f, -0.02646499f, -0.43945035f, 0.06850895f, 0.26517463f, 
    0.10305355f, 0.12135686f, 0.14763078f, -0.10640611f, -0.04169965f, 0.18689787f, 0.14866276f, 0.09859902f, 
    0.30801380f, -0.02261807f, 0.56994939f, -0.04695345f, -0.17159648f, -0.24427384f, -0.20492497f, -0.04216909f, 
    -0.03725763f, 0.19231196f, 0.07749630f, 0.07100136f, -0.94671202f, -0.21457841f, -0.22659834f, 0.46776378f, 
    0.38724625f, -0.70932603f, 0.18832563f, 0.02764879f, -0.06333493f, 0.05059259f, -0.00906361f, 0.02498336f, 
    -0.52644902f, 0.35083395f, -0.26584598f, 0.27720883f, -0.18391949f, 0.14644639f, -0.07026450f, 0.12425104f, 
    0.06435669f, -0.33576590f, 0.01097107f, 0.12102427f, 0.11424224f, -0.39744839f, -0.08058494f, -0.09244186f, 
    -0.45325235f, -0.00335119f, -0.01066647f, -0.29325619f, -0.16735938f, 0.00328873f, -0.00716748f, 0.02064847f, 
    0.12225103f, -0.01623505f, -0.06462010f, -0.06299690f, 0.02025510f, -0.08041012f, -0.00756599f, 0.03527315f, 
    -0.14773265f, 0.13474430f, -0.19495201f, -0.67802423f, -0.62466168f, 0.29018465f, -0.62938482f, 0.07641926f, 
    -0.09619218f, 0.23546444f, -0.05456408f, -0.04455063f, 0.30527201f, 0.05690172f, 0.21526296f, 0.09927797f, 
    0.06600910f, -0.84197551f, -0.31523335f, 0.03181845f, -0.08920206f, -0.09857108f, 0.14060162f, 0.27459392f, 
    -0.04078151f, 0.09442218f, 0.03782189f, -0.12465842f, -0.14347997f, 0.87208587f, -0.02942353f, 0.25241613f, 
    -0.19439797f, 0.34694484f, -0.00329400f, -0.34534773f, 0.00457541f, 0.23582122f, -0.20857073f, -0.09271853f, 
    0.14313227f, -0.36226740f, 0.12726296f, 0.38260454f, -0.16111635f, 0.14652723f, 0.24416107f, 0.21496971f, 
    -0.22019652f, 0.10278764f, 0.09682541f, 0.02117510f, -0.52064949f, 0.24825577f, -0.46678013f, 0.09353492f, 
    -0.01221265f, 0.15305731f, 0.05804602f, 0.00920806f, 0.04942877f, 0.24256416f, -0.11626079f, -0.28591204f, 
    -0.22455776f, 0.28817934f, -0.25435093f, 0.08717737f, -0.04375632f, 0.11482476f, -0.27127856f, 0.65850174f, 
    -0.10057614f, -0.06119115f, 0.24357140f, 0.11436839f, -0.36692220f, 0.08505405f, -0.45379448f, 0.00648815f, 
    0.14585967f, 0.00606703f, 0.11960565f, -0.14932558f, -0.13268852f, 0.12166093f, -0.09853074f, 0.29143432f, 
    -0.43202952f, 0.12816203f, 0.24104227f, -0.45140973f, 0.19378790f, -0.11316491f, 0.02679654f, -0.23363282f, 
    -0.14553605f, 0.17875502f, 0.03080903f, -0.31527090f, 0.23654391f, -0.02361258f, 0.07021493f, -0.32642919f, 
    -0.15804057f, -0.11622892f, 0.04123332f, 0.04588565f, 0.29161724f, -0.05613962f, -0.43376249f, -0.33486500f, 
    0.06086512f, 0.10763071f, 0.00422649f, -0.04044296f, -0.04428956f, -0.17834173f, 0.20169733f, 0.07482942f, 
    0.06217976f, -0.11235687f, 0.19827749f, 0.04130717f, -0.44812918f, 0.38214746f, -0.62105358f, -0.04490651f, 
    -0.24642678f, -0.23109201f, 0.39117292f, -0.16394712f, 0.10085572f, 0.19550365f, -0.10365868f, 0.09400499f, 
    -0.41721430f, 0.27016643f, -0.25239053f, 0.54107702f, 0.13254882f, -0.32752308f, -0.08508275f, 0.11164135f, 
    -0.18825415f, -0.09232280f, -0.33573556f, -0.57113034f, -0.51843327f, 0.76118135f, 0.52728212f, 0.17282546f, 
    0.07687933f, 0.10956075f, -0.16969745f, 0.20372413f, 0.13246104f, -0.02638120f, -0.06875864f, -0.10733471f, 
    -0.90626758f, 0.33071166f, -0.65916210f, 0.53028595f, 0.03399899f, -0.24045077f, 0.30240989f, 0.01633803f, 
    -0.09265424f, -0.00251242f, 0.14198041f, 0.01253931f, 0.98124665f, -0.05010045f, 0.24673986f, -0.25077498f, 
    0.02702879f, -0.01565319f, -0.26445478f, 0.04637263f, -0.25463405f, 0.23980278f, -0.06337810f, 0.04434706f, 
    0.15574706f, 0.16755649f, -0.00732370f, -0.30252922f, -0.32406300f, -0.26360038f, 0.34593683f, 0.00796431f, 
    0.16307473f, 0.06793080f, 0.07392824f, 0.14682658f, -0.00623901f, 0.80747062f, -0.57176399f, -0.01484279f, 
    0.19233039f, -0.09330016f, -0.01067210f, 0.20309770f, -0.01155674f, -0.24871680f, 0.04884078f, 0.01810940f, 
    0.24137378f, -0.37543255f, 0.22614300f, -0.95833999f, 0.02058448f, -0.08773541f, 0.26193723f, -0.10075554f, 
    0.01747818f, 0.12109091f, 0.14632413f, -0.09140215f, 0.30767512f, -0.26226062f, 0.11501578f, 0.24961546f, 
    0.16057637f, 0.24917640f, 0.22756603f, -0.02532593f, 0.13187942f, -0.00668755f, 0.36578235f, 0.34528029f, 
    0.01709425f, -0.02116863f, 0.39506873f, -0.42798558f, -0.20017575f, -0.23081085f, 0.10711725f, -0.12837863f, 
    0.06168477f, -0.04633659f, -0.18050557f, -0.19544084f, -0.37715393f, -0.49233848f, -0.34938997f, -0.09881885f, 
    -0.08966546f, -0.09352807f, -0.13623993f, -0.40710333f, -0.02703292f, 0.11131655f, 0.05104006f, 0.18211967f, 
    0.56527942f, -0.38177177f, 0.37351471f, 0.20948632f, -0.02564824f, -0.11329548f, 0.26952082f, 0.84751207f, 
    -0.08270014f, -0.25898817f, 0.03334702f, -0.24464557f, -0.14903143f, -0.61016518f, -0.03578343f, 0.35829702f, 
    -0.03143963f, -0.40054578f, 0.21432404f, -0.32929742f, -0.07843211f, -0.03411818f, 0.13934746f, -0.19091484f, 
    -0.74394977f, 0.36364952f, -0.77223384f, -0.09333349f, 0.14736941f, -0.09465683f, 0.05246856f, 0.02350764f, 
    -0.19402677f, -0.10262498f, -0.03774768f, -0.12333367f, -0.31043363f, -0.20507431f, -0.07757486f, -0.31726471f, 
    0.11835430f, -0.06073851f, -0.11124659f, -0.07107888f, 0.17968634f, 0.10740045f, -0.01461067f, 0.19926734f, 
    -0.58009315f, -0.49018511f, -0.00343698f, 0.12687872f, -0.15781389f, 0.10811348f, -0.10703700f, 0.12437107f, 
    -0.08800831f, 0.04621844f, 0.06299797f, -0.34487104f, 0.32132378f, 0.22199064f, 0.10062499f, -0.05572025f, 
    -0.08809143f, -0.05019294f, 0.00822192f, 0.05145369f, 0.03743852f, 0.06403105f, 0.13698955f, -0.17123292f, 
    -0.88798308f, 0.10225907f, 0.05196491f, 0.48589367f, -0.20709595f, -0.14824520f, -0.08140549f, 0.34259078f, 
    -0.44181150f, 0.14403506f, 0.13208529f, 0.13597657f, 0.24617895f, -0.86813611f, 0.57830840f, 0.09975217f, 
    0.42179483f, 0.05454440f, -0.51659447f, 0.19569203f, 0.26558667f, 0.05590127f, 0.11672804f, -0.08150526f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.32874292f, 0.28557393f, 0.16774464f, -0.22667384f, -0.27640575f, 0.02950045f, 0.19998151f, -0.22472283f, 
    0.12782408f, 0.02566892f, 0.07122619f, -0.03434628f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
