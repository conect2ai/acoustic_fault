#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.83136863f, 0.61209822f, 0.74162024f, 0.13002165f, -0.80087066f, 0.07756052f, 0.05146165f, 0.57621121f, 
    0.00626861f, -0.82757550f, 0.69436508f, -0.47216544f, 0.12472636f, -0.28536484f, -1.24688792f, -0.23350702f, 
    0.04888962f, 0.08703884f, 0.50069791f, -0.84589279f, -0.10909072f, 0.40003228f, -0.20636025f, -0.93564141f, 
    0.15194702f, -0.25509006f, -0.53601950f, 0.44280222f, -1.00573599f, -0.68643975f, -0.71768528f, -0.65367752f, 
    -0.25969422f, -0.38526481f, 0.52651942f, 0.05602861f, -0.68380177f, -0.25783765f, -0.28490275f, 0.02210174f, 
    0.09831548f, 0.99333429f, -0.03528492f, -0.02550034f, -0.33020660f, -0.15829618f, 0.18707062f, 1.06870651f, 
    0.64431554f, 0.36280635f, 0.83220237f, -0.19644016f, -0.53628802f, 0.15548678f, 1.01860964f, 0.84416074f, 
    -0.95253158f, 0.67144412f, 0.43958315f, -0.26559883f, 0.07056020f, -0.04323133f, -0.22897665f, -0.67583567f, 
    -0.90702397f, -0.47759429f, -0.89391685f, -0.12153690f, 0.40821609f, 0.30150586f, -0.02849571f, 0.36674845f, 
    -0.66267395f, 0.95995784f, -0.13495877f, -0.52860326f, 0.84960872f, -0.28575572f, -0.22406727f, -0.49193862f, 
    0.05755621f, 0.51059598f, 0.46995664f, 0.62380648f, -1.00703597f, -0.47463572f, -0.82314545f, -0.13140066f, 
    -0.29715490f, -0.06755817f, 0.07478420f, -0.56381559f, -0.08022384f, 1.00549018f, 0.72923452f, -0.08216108f, 
    0.25733572f, 0.12544708f, 0.16392086f, -0.93678802f, 0.86314112f, 0.51608485f, 0.73164034f, -0.20610228f, 
    -0.25662717f, 0.07866870f, 0.34559250f, 0.23755555f, 1.08694756f, 0.52267855f, 0.71191353f, 0.18857335f, 
    0.88172090f, 0.17577581f, -0.11539859f, 0.46342990f, 0.19995031f, 0.61283547f, 0.83347213f, 0.27400827f, 
    -0.66821826f, -0.66381037f, 0.48528743f, -0.22791138f, -0.58749843f, -0.51644844f, -0.43028781f, -0.89918596f, 
    -0.89634609f, -0.20413972f, 0.80435264f, 0.40127584f, -0.40199134f, -0.13775438f, -0.31827354f, -0.79507291f, 
    -0.52735293f, -0.98190236f, 0.58826429f, -0.35768783f, 0.23465496f, -0.13785321f, -0.00349704f, 0.30093518f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10732017f, 0.08075197f, 0.34619117f, -0.13587418f, 0.29570168f, 0.06514233f, -0.18496926f, 0.00236462f, 
    0.04268359f, 0.38892847f, -0.22601086f, -0.46169797f, 0.29583934f, 0.20756611f, 0.14852339f, -0.30432621f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.02736817f, -0.27207333f, -0.10523901f, 0.09353434f, -0.13123472f, 0.04185656f, 0.19650598f, 0.06792495f, 
    0.13523227f, 0.09533808f, -0.20852941f, 0.25143790f, -0.14214985f, -0.06758329f, 0.05254132f, 0.10209007f, 
    -0.11074119f, 0.09511469f, -0.27289528f, -0.02542043f, 0.18788917f, 0.20412384f, 0.22433311f, 0.02636729f, 
    -0.00536072f, 0.17317227f, -0.16741244f, 0.18478066f, -0.46062103f, -0.04396715f, -0.08135153f, 0.00618230f, 
    0.02017756f, 0.08192309f, -0.11363517f, -0.23106393f, 0.16755889f, 0.35687658f, 0.04838118f, 0.09228089f, 
    0.11228340f, 0.03204449f, 0.00266703f, 0.08327049f, -0.06413954f, -0.15253079f, -0.03750357f, -0.24555872f, 
    0.12539554f, 0.14751905f, -0.02598368f, -0.35233781f, -0.01653581f, 0.05882096f, -0.24384394f, -0.15559886f, 
    0.07926729f, -0.00439878f, 0.06821150f, -0.27963588f, 0.23294660f, 0.09866390f, -0.01859501f, -0.08443248f, 
    0.17294860f, -0.05175790f, 0.20270061f, -0.01720282f, -0.16164497f, 0.37716353f, -0.00137665f, 0.00659568f, 
    -0.35947597f, -0.11899737f, -0.19546339f, 0.13510974f, -0.07603440f, -0.02229827f, -0.02267974f, 0.03911732f, 
    -0.05122028f, 0.29788905f, 0.21334854f, 0.13094333f, -0.05090574f, 0.15241228f, 0.07814884f, -0.01541237f, 
    0.10078502f, 0.18544634f, 0.17883953f, 0.13518795f, -0.07445265f, 0.22797808f, -0.08456816f, 0.25206289f, 
    0.07987916f, 0.07708286f, 0.15443937f, -0.42277220f, 0.03558063f, 0.01652100f, -0.09641483f, -0.29450542f, 
    -0.25886118f, -0.05039753f, 0.03870826f, 0.23565818f, -0.20212503f, -0.30340621f, -0.31380317f, 0.21349289f, 
    0.34088606f, 0.04630114f, 0.28463015f, -0.16038403f, -0.05749348f, 0.24895376f, 0.04538231f, -0.28605348f, 
    0.12734695f, 0.00627309f, 0.23848009f, -0.14129914f, -0.04091231f, -0.09619815f, 0.29877004f, 0.10491917f, 
    0.20818500f, -0.27787665f, -0.10973778f, -0.67023706f, -0.10106301f, 0.14945540f, -0.03668035f, 0.22451119f, 
    -0.08122577f, -0.12226726f, -0.01427255f, 0.05066079f, 0.06346738f, -0.18726858f, -0.00989179f, 0.07173673f, 
    -0.78971529f, -0.62744486f, -0.08781625f, 0.24960624f, -0.09432847f, 0.16225228f, 0.04326265f, 0.05169415f, 
    -0.05151984f, 0.39281642f, -0.23237875f, -0.17933284f, -0.12083600f, -0.14235173f, 0.05410150f, -0.10393815f, 
    -0.07596167f, -0.07570115f, 0.01403456f, -0.06521983f, 0.00687721f, -0.16432047f, -0.01343457f, -0.01287136f, 
    -0.01550197f, -0.06096655f, 0.03260258f, 0.26616368f, 0.38832757f, -0.00484587f, -0.00851977f, -0.16496132f, 
    -0.08852199f, 0.04325607f, 0.01031974f, -0.06414112f, 0.28170651f, 0.03759131f, -0.01538047f, 0.03338652f, 
    0.19439636f, -0.09407948f, -0.01022411f, -0.00643694f, 0.15094081f, 0.13251269f, 0.05706677f, 0.22044927f, 
    0.05709331f, 0.12746286f, -0.10089564f, 0.08918632f, 0.31587726f, -0.06028051f, 0.00469469f, 0.30225107f, 
    0.03050862f, -0.06115762f, 0.04039042f, -0.12412383f, -0.22828375f, -0.09048850f, -0.10738449f, -0.17451476f, 
    0.05474302f, -0.09005871f, -0.19334458f, -0.11863662f, -0.17162529f, -0.13589637f, 0.13053346f, 0.17917427f, 
    -0.18406074f, -0.17572461f, -0.12928899f, 0.01501092f, -0.03047025f, 0.07870607f, -0.03902457f, 0.03884694f, 
    0.05410688f, 0.15060528f, 0.18355727f, 0.23876318f, 0.26575598f, 0.04328863f, 0.15501998f, -0.07544071f, 
    -0.04982299f, 0.07026660f, 0.30796167f, 0.29313332f, -0.23589200f, 0.01751323f, -0.04947443f, -0.22272071f, 
    0.14429274f, 0.39552748f, 0.29414469f, 0.15499629f, -0.26723632f, -0.24936420f, -0.15183379f, -0.17377725f, 
    -0.21559668f, 0.11883903f, -0.00508190f, -0.00839918f, -0.35055524f, -0.41205832f, 0.00897063f, 0.13962355f, 
    -0.04572130f, 0.01963994f, 0.22002512f, 0.07543127f, 0.27049685f, -0.35542986f, -0.51114357f, 0.12865496f, 
    0.01873418f, 0.09290820f, -0.03825771f, -0.30369282f, -0.20898454f, 0.04533790f, 0.37622809f, 0.00395720f, 
    0.22131027f, 0.21692897f, 0.28278279f, -0.04674397f, 0.12018231f, 0.10892450f, -0.14180197f, 0.05982305f, 
    0.52823281f, 0.04307923f, -0.12973882f, -0.07230522f, 0.00583092f, -0.01394681f, 0.21487406f, 0.06241971f, 
    0.23124167f, 0.44285408f, 0.07019436f, 0.02060404f, 0.16573085f, -0.06920216f, -0.16298397f, 0.03522141f, 
    0.32356396f, -0.50003111f, -0.28050035f, -0.34192795f, 0.30012959f, -0.03568158f, 0.03364957f, 0.09449606f, 
    0.23057880f, 0.09559333f, 0.17633854f, 0.01813282f, 0.12809879f, 0.22675975f, -0.13715443f, -0.12046009f, 
    -0.06096178f, -0.03902874f, 0.02277724f, -0.37622917f, 0.38993907f, -0.38090748f, 0.02628505f, 0.02698949f, 
    0.18632688f, -0.01226895f, -0.13199764f, -0.01071014f, -0.05048475f, -0.32724968f, 0.15287715f, 0.08638965f, 
    -0.04568378f, -0.19745550f, -0.00272293f, -0.04528784f, -0.06755668f, 0.51010454f, 0.29068565f, 0.29458398f, 
    -0.20128135f, -0.12154091f, 0.02410596f, 0.28231844f, -0.07237794f, 0.11232889f, -0.14863841f, 0.12153420f, 
    -0.50982171f, -0.02735381f, -0.12699157f, -0.27061576f, -0.09180118f, -0.01215827f, -0.02390501f, -0.22561653f, 
    0.43390191f, 0.37598574f, 0.02707287f, -0.04679389f, 0.33511057f, -0.18692082f, 0.13193205f, 0.19325730f, 
    0.05533830f, -0.02909323f, -0.27995944f, 0.22186992f, -0.10214321f, 0.09148460f, 0.07401652f, 0.09102657f, 
    0.16456257f, -0.26256073f, -0.38634479f, -0.03490821f, 0.08147484f, 0.00458362f, 0.13006005f, 0.21708529f, 
    0.03558066f, 0.14526609f, 0.00279906f, 0.12326570f, 0.01949035f, -0.16175862f, -0.23175773f, 0.09319561f, 
    -0.12459514f, -0.17161205f, 0.15739655f, -0.43352243f, -0.30259272f, -0.16333404f, 0.14258097f, -0.15274052f, 
    -0.15093535f, 0.21771143f, -0.12311979f, 0.12172800f, 0.19899461f, 0.16909778f, 0.09148569f, 0.12189063f, 
    0.04583345f, -0.06946641f, 0.16320100f, 0.06251074f, 0.03672615f, -0.07489101f, 0.12838878f, -0.04442856f, 
    0.14737178f, -0.02586473f, 0.20485204f, 0.10365716f, 0.09129614f, -0.20317364f, -0.14079705f, -0.00354552f, 
    -0.25726214f, -0.03732199f, -0.06124648f, -0.16862217f, -0.02000356f, -0.07409598f, -0.17120172f, -0.35423031f, 
    0.24965276f, -0.08745439f, -0.16388260f, 0.03952405f, -0.11677402f, 0.12034311f, -0.01048854f, -0.09959732f, 
    -0.10698725f, -0.27587366f, 0.06398580f, -0.32836422f, -0.09866916f, 0.09176824f, -0.17808741f, -0.01298707f, 
    -0.25389025f, 0.16432849f, -0.09890479f, -0.06568689f, -0.09316854f, -0.07117756f, -0.11986508f, 0.10173188f, 
    -0.04947123f, -0.00910218f, -0.03909508f, 0.10542534f, -0.03096515f, -0.02694265f, -0.01491526f, -0.23886123f, 
    0.03360853f, -0.05997578f, -0.03722078f, 0.53374392f, 0.23633002f, 0.25728384f, -0.01912892f, 0.10186701f, 
    -0.10491491f, -0.16858010f, 0.16389847f, 0.12834810f, 0.11293835f, 0.07732719f, -0.01433585f, 0.18745533f, 
    0.14861490f, -0.04881998f, -0.19985798f, 0.08899811f, 0.01724480f, 0.13858639f, -0.10890175f, -0.09244689f, 
    0.20508444f, 0.01644402f, -0.00654335f, 0.04545295f, -0.00923639f, 0.14591858f, 0.11469253f, 0.57704729f, 
    -0.25530776f, -0.07395720f, -0.31826758f, -0.01615269f, -0.06814597f, -0.01430609f, -0.17079568f, 0.25351474f, 
    -0.10182396f, 0.10849790f, 0.08105233f, 0.09321703f, -0.16531956f, 0.22918229f, -0.03518022f, -0.15260471f, 
    0.05011514f, -0.02889738f, 0.11164434f, 0.06736991f, -0.04621132f, 0.19648549f, 0.12375480f, 0.05259692f, 
    -0.02787694f, -0.03249625f, -0.56104791f, 0.24385385f, -0.34908080f, -0.13755234f, -0.04246399f, -0.03911717f, 
    -0.11896122f, -0.05991206f, 0.06948177f, 0.21464215f, -0.36079693f, 0.00837559f, 0.04097180f, -0.11166763f, 
    0.15649144f, 0.20019412f, 0.07818145f, 0.24423444f, -0.18107186f, 0.15162066f, -0.22320454f, -0.05355577f, 
    0.01943250f, -0.10207245f, -0.15105209f, -0.03899807f, -0.25010797f, -0.16281103f, 0.39006311f, 0.09746124f, 
    0.22943783f, 0.09906438f, -0.02566152f, 0.04087332f, -0.15305065f, 0.16464914f, -0.44885087f, 0.01797648f, 
    -0.34390041f, -0.20029396f, -0.16178106f, -0.04018288f, 0.06920931f, -0.04490135f, 0.32314327f, 0.27717102f, 
    0.09233788f, 0.22238964f, 0.28700054f, -0.08991114f, 0.02107305f, 0.13938560f, 0.25281739f, 0.28924203f, 
    0.31653953f, 0.31720328f, 0.13796528f, 0.30107498f, 0.43606308f, 0.08117905f, 0.29899740f, -0.04797914f, 
    -0.06189904f, -0.03528146f, 0.01156292f, -0.07313372f, -0.00420586f, -0.01050295f, 0.04481812f, -0.08404593f, 
    -0.02866777f, -0.09730470f, -0.03894517f, -0.01651392f, 0.03092655f, 0.02197902f, -0.01891364f, -0.04515480f, 
    -0.05546985f, 0.02459690f, -0.08326536f, -0.02101909f, -0.08800299f, 0.03512000f, -0.04749108f, -0.09677631f, 
    -0.09256364f, -0.07894064f, 0.00056200f, -0.05888639f, 0.02931954f, 0.05798231f, 0.00827541f, 0.03550261f, 
    -0.04788850f, -0.04615283f, -0.06322981f, 0.04488723f, -0.08853138f, -0.05063143f, 0.03388914f, 0.00888378f, 
    0.03432367f, 0.01833356f, -0.05220743f, -0.00473607f, -0.00465219f, -0.08109166f, -0.08306628f, 0.01725505f, 
    -0.06620777f, -0.00352580f, -0.01969541f, 0.03739105f, 0.01897682f, -0.00693885f, 0.02107666f, -0.07890454f, 
    -0.02621048f, -0.03620316f, -0.03907815f, -0.05539466f, -0.08173142f, -0.07282268f, -0.08681717f, 0.06255508f, 
    0.04597303f, -0.01180574f, -0.02205818f, 0.02656104f, 0.05733525f, 0.01481159f, -0.04906549f, -0.04327730f, 
    -0.07960813f, -0.03004746f, -0.00319108f, -0.03798224f, -0.00247060f, -0.09823072f, -0.02745796f, -0.06437434f, 
    -0.06455351f, 0.02605274f, 0.00288272f, -0.03541705f, -0.08146416f, -0.00637578f, 0.00415276f, -0.05910040f, 
    0.03741282f, -0.04512884f, -0.06565217f, 0.05279972f, 0.05684059f, 0.04999606f, 0.06438723f, -0.07911097f, 
    0.01579264f, 0.02347480f, -0.01570520f, 0.03137749f, 0.04931460f, -0.07379892f, -0.02150610f, -0.01770507f, 
    0.00259951f, -0.09026148f, 0.02736751f, 0.00938142f, 0.02751506f, -0.05127901f, 0.05561671f, -0.02619737f, 
    0.01781992f, 0.04736562f, -0.02248016f, -0.00550184f, -0.07404689f, -0.03967829f, -0.09012351f, -0.00303082f, 
    0.01300444f, 0.04452234f, 0.01943550f, -0.04727953f, 0.07362664f, 0.01923049f, 0.04818856f, -0.00530232f, 
    0.00285466f, -0.03455542f, 0.01732936f, 0.04130467f, -0.03662458f, -0.05144090f, 0.04613309f, 0.05561977f, 
    -0.03850617f, -0.06364024f, -0.00709245f, -0.04276840f, 0.04963676f, 0.04838448f, 0.02112848f, 0.03368956f, 
    -0.49926907f, 0.14276312f, 0.14606540f, 0.15192631f, 0.08251335f, -0.10136463f, 0.09526816f, -0.07270435f, 
    0.05147983f, -0.26592261f, -0.37798148f, -0.43799460f, 0.07468178f, 0.03610701f, 0.11869747f, -0.04835651f, 
    0.00415444f, 0.03842939f, -0.26585928f, -0.16897707f, 0.14105774f, 0.02739601f, 0.05194373f, -0.15598509f, 
    0.04699362f, 0.15225166f, -0.10454529f, -0.27124074f, -0.12688224f, -0.02035401f, 0.31203264f, 0.25367182f, 
    0.13790169f, -0.09799356f, -0.07855394f, -0.15845595f, 0.19012864f, 0.14361587f, -0.02773220f, 0.18594925f, 
    0.09094119f, 0.01809745f, -0.03427342f, -0.03896283f, -0.04298946f, 0.24458060f, 0.32580605f, -0.02087827f, 
    0.05056892f, -0.05618038f, -0.15023424f, -0.13533646f, 0.08130588f, 0.03630107f, 0.33546767f, -0.88442087f, 
    -0.18694031f, -0.15364246f, 0.13306244f, -0.17028916f, 0.03157645f, 0.09176407f, 0.00052010f, 0.68195772f, 
    -0.07116915f, 0.21362370f, -0.16137485f, -0.08277870f, -0.10932964f, 0.12486985f, 0.12323846f, 0.10780019f, 
    -0.06827173f, -0.06743959f, -0.39614928f, 0.23997797f, 0.09197424f, 0.10396511f, -0.15341710f, -0.09569214f, 
    -0.18144263f, -0.10294855f, 0.17474002f, -0.26287949f, -0.01590212f, -0.05282073f, 0.13064827f, -0.16283359f, 
    -0.03905259f, -0.02914448f, 0.13684760f, -0.18262146f, 0.38010001f, -0.15412562f, -0.05916455f, 0.01307823f, 
    0.19623025f, 0.16049978f, -0.06607944f, 0.03288848f, 0.02518462f, 0.03007867f, -0.12573551f, -0.00113683f, 
    -0.11597356f, -0.03126716f, -0.04574074f, 0.16652106f, -0.13350843f, 0.13765037f, 0.05625785f, 0.14732517f, 
    0.06027490f, 0.01836880f, -0.03170688f, 0.00016742f, 0.32521892f, -0.02814314f, 0.10429349f, -0.23542996f, 
    -0.03015823f, -0.23501508f, 0.17536531f, -0.11123005f, 0.06938374f, 0.02621401f, 0.29046309f, -0.01856352f, 
    -0.04714875f, -0.15501434f, 0.04882422f, -0.04317441f, 0.13997753f, -0.07296497f, 0.04065499f, 0.02350427f, 
    0.43916342f, 0.11982801f, -0.02951489f, 0.14140390f, 0.13425398f, -0.13641091f, 0.03534419f, 0.08025254f, 
    -0.18227443f, 0.18710198f, 0.07724415f, 0.21502009f, 0.19937384f, 0.10723224f, -0.21587680f, 0.04345223f, 
    -0.30330944f, 0.22711368f, 0.05978624f, -0.05159375f, -0.04736837f, -0.02993717f, 0.00433235f, 0.19077021f, 
    0.02370779f, 0.18645231f, -0.04273335f, -0.16227978f, 0.25966635f, 0.23176788f, -0.05896695f, -0.01015391f, 
    -0.13376279f, 0.02991789f, 0.02245994f, 0.40231583f, -0.30765447f, 0.14185798f, 0.00777552f, 0.25727421f, 
    0.12653986f, 0.18385388f, 0.11451096f, 0.11569279f, 0.28883871f, 0.02669884f, -0.03798575f, -0.26168463f, 
    0.09877606f, -0.07230194f, 0.15134872f, -0.15352258f, 0.09583576f, 0.26534984f, -0.03919896f, 0.10148186f, 
    0.09016328f, -0.07536851f, 0.29680750f, 0.21340537f, 0.13220215f, -0.13092405f, 0.30209026f, -0.26497880f, 
    0.04464456f, -0.01190548f, -0.19645350f, 0.10589811f, 0.06403380f, -0.09149061f, -0.05313642f, 0.52142006f, 
    -0.18609279f, -0.08295912f, -0.09273546f, -0.00289193f, -0.07883445f, -0.10059112f, -0.02924593f, -0.09823724f, 
    0.10368889f, 0.31416664f, -0.22922748f, 0.01877664f, 0.13301818f, 0.06090507f, 0.20964102f, -0.01399863f, 
    0.16422057f, 0.14943987f, 0.45296356f, 0.24848948f, 0.21681975f, 0.20900217f, -0.15171906f, 0.01199483f, 
    0.12326191f, -0.07059270f, 0.23234670f, -0.17305601f, 0.18303086f, -0.27719229f, -0.36775100f, -0.35604537f, 
    -0.01350317f, -0.07591467f, -0.07851807f, 0.50687671f, -0.03396252f, -0.23754081f, -0.34255180f, -0.12753241f, 
    -0.02888651f, -0.21801931f, -0.07609569f, -0.23661557f, -0.49721843f, 0.05470428f, -0.17733368f, 0.11256946f, 
    0.06442943f, 0.48204979f, 0.32992446f, -0.09814255f, -0.14959423f, -0.58694404f, 0.15129596f, 0.06176676f, 
    0.13786699f, 0.16347983f, -0.00057609f, 0.25828016f, 0.09728356f, -0.29306552f, 0.05834318f, -0.16949511f, 
    0.21500543f, -0.22643372f, -0.20766908f, -0.01161935f, 0.10961524f, 0.10792615f, 0.36594373f, -0.17911850f, 
    -0.39150828f, 0.41562089f, -0.35716125f, -0.17502601f, 0.02836824f, -0.20860797f, -0.13899177f, -0.00062117f, 
    -0.06353492f, -0.06479096f, 0.06319053f, 0.05877375f, 0.01007349f, 0.00214947f, 0.01076412f, -0.03724551f, 
    -0.03912033f, 0.02906889f, 0.03444189f, -0.05779730f, -0.05038591f, -0.07443975f, -0.05206088f, 0.07172478f, 
    0.03164691f, 0.04120866f, 0.01212414f, 0.06189321f, -0.04136242f, -0.06916621f, 0.00434409f, -0.08202878f, 
    -0.07700951f, 0.02724314f, -0.01231940f, 0.04390239f, -0.08860851f, -0.08034068f, 0.06709594f, -0.01871731f, 
    -0.06855319f, 0.02583173f, -0.02665203f, -0.01260927f, 0.07041053f, -0.03257237f, -0.08132840f, 0.06616844f, 
    -0.03745258f, 0.01224956f, 0.07032645f, -0.00803055f, 0.06512875f, 0.08237198f, -0.02798742f, -0.01124107f, 
    -0.00549094f, 0.02024824f, -0.03227155f, -0.08315236f, -0.07233747f, -0.08165220f, 0.01640975f, 0.00494065f, 
    -0.06479174f, 0.07286306f, -0.06786478f, 0.00248046f, 0.01329724f, -0.06439739f, -0.00878374f, 0.00701631f, 
    -0.03027881f, -0.05505987f, -0.00869327f, -0.05445301f, -0.01154839f, -0.00738113f, -0.08229197f, -0.04751110f, 
    -0.08259438f, -0.07251909f, -0.00696871f, -0.03207792f, -0.07637351f, 0.04238107f, -0.07568235f, 0.03840152f, 
    -0.00481492f, -0.02369710f, -0.06337482f, 0.00743777f, -0.08026165f, 0.02973674f, -0.01723635f, 0.05894051f, 
    0.01879430f, 0.05189642f, -0.04629299f, 0.02035576f, 0.05192152f, -0.07682049f, 0.06776444f, -0.00477262f, 
    -0.01343720f, 0.00991532f, -0.04897082f, 0.01125505f, 0.07013512f, -0.03362044f, 0.01912170f, -0.07558651f, 
    -0.03574179f, 0.00255083f, -0.05921916f, -0.07969491f, 0.00593237f, -0.08098665f, -0.04928006f, 0.07502115f, 
    0.04312795f, -0.03337473f, -0.02163180f, -0.00547859f, -0.07832950f, 0.04322581f, -0.04291790f, 0.05171239f, 
    0.03917949f, -0.03108604f, -0.01773732f, 0.01946497f, -0.04143147f, -0.06575347f, -0.05088370f, 0.07972880f, 
    -0.06958023f, 0.06955835f, -0.06585659f, -0.02070431f, 0.07654583f, 0.03760986f, -0.06345089f, -0.02824870f, 
    0.04740236f, -0.05052194f, 0.01829593f, 0.00739236f, -0.08881810f, -0.02780469f, -0.00931910f, 0.00964744f, 
    0.20048092f, 0.30643728f, 0.29728258f, -0.15813306f, 0.03976208f, 0.02308584f, 0.18750003f, -0.03204894f, 
    0.11926138f, 0.23855045f, 0.11784330f, -0.02210988f, 0.24404836f, 0.13671534f, -0.03536586f, 0.10599740f, 
    0.19823167f, 0.26299557f, -0.23181002f, -0.30497509f, -0.31780207f, -0.02767473f, -0.10011193f, 0.24253492f, 
    0.23923600f, 0.22574696f, -0.04619453f, -0.21104331f, -0.17103338f, 0.04083845f, -0.17190044f, -0.10065495f, 
    -0.14550968f, 0.11895323f, 0.16095528f, -0.02582686f, -0.01560565f, 0.27651393f, -0.43734106f, 0.26598281f, 
    -0.05104660f, 0.14201404f, -0.03953991f, 0.05880823f, 0.02130520f, 0.33068711f, -0.01926016f, 0.13142316f, 
    0.22719702f, 0.01593932f, 0.06240382f, 0.07352459f, 0.05164060f, 0.02969038f, -0.32362592f, -0.17620225f, 
    0.08594785f, 0.12915412f, 0.04047200f, -0.13487047f, -0.00901885f, -0.16179954f, -0.06554977f, -0.58633608f, 
    -0.30030590f, -0.32107523f, 0.13851757f, 0.07961453f, 0.09317881f, 0.21376322f, -0.17202052f, 0.09337138f, 
    -0.14986889f, -0.12297516f, -0.04781299f, -0.28022921f, -0.07032293f, -0.21139222f, 0.21536228f, 0.17928042f, 
    -0.15855296f, 0.11816154f, 0.26248446f, 0.01786668f, -0.09401616f, 0.14296360f, 0.19510490f, -0.09056228f, 
    -0.05073883f, 0.12179284f, -0.24552208f, -0.45030561f, 0.02607291f, -0.03878542f, 0.16081524f, -0.15091284f, 
    0.01558747f, -0.17660056f, -0.19721179f, 0.16340677f, -0.36394444f, 0.23418334f, 0.02406338f, -0.07394260f, 
    0.00709457f, -0.08707660f, 0.00308196f, 0.00028810f, -0.14326981f, 0.24001768f, 0.12628850f, 0.04474118f, 
    0.34270954f, 0.22021174f, 0.15335380f, -0.10930125f, 0.05036593f, -0.39008760f, 0.23960000f, 0.00540491f, 
    -0.18731588f, 0.16890559f, 0.01529637f, 0.28947848f, 0.06809853f, 0.13194892f, 0.19887537f, -0.39094257f, 
    -0.42580023f, 0.15379943f, 0.02706825f, 0.33795375f, -0.06367701f, -0.24787349f, -0.12251422f, -0.26177320f, 
    -0.12370647f, -0.31614786f, 0.10896336f, 0.06117463f, 0.02648483f, 0.01701294f, 0.07453577f, 0.05006842f, 
    0.20497793f, 0.33431748f, 0.03597075f, -0.33670583f, -0.26893595f, -0.13126016f, 0.00215587f, -0.07961047f, 
    -0.03449963f, -0.51011640f, -0.18406419f, -0.01151544f, 0.18668465f, -0.07474026f, 0.10609395f, -0.06447081f, 
    0.14006025f, 0.13917799f, -0.42656064f, 0.26330674f, 0.05250317f, 0.22673802f, 0.06570323f, 0.05224748f, 
    -0.06585908f, -0.05819605f, 0.11801828f, -0.67324835f, -0.04276535f, 0.04043323f, -0.18488690f, -0.13700940f, 
    -0.04674996f, 0.09943171f, 0.16465090f, -0.12417971f, 0.22122921f, -0.09268121f, -0.08426669f, 0.20494530f, 
    0.13762783f, 0.11464243f, -0.25828767f, 0.30590153f, -0.08702066f, 0.03226724f, 0.16145529f, 0.45252341f, 
    -0.10525395f, 0.03713045f, -0.03678296f, 0.10233305f, 0.15205537f, 0.05071050f, -0.51105684f, 0.18046823f, 
    -0.29482651f, -0.11193848f, -0.02606300f, 0.18264148f, 0.04224820f, 0.11404219f, 0.20593046f, -0.22943057f, 
    -0.08388641f, -0.02519101f, 0.14363509f, -0.21385488f, 0.03028953f, -0.09748088f, -0.16641948f, -0.14249682f, 
    0.05586377f, 0.02695982f, -0.43141577f, 0.06461520f, -0.22622196f, 0.02835769f, -0.05389303f, -0.15209384f, 
    -0.38175091f, -0.07109122f, -0.04815167f, 0.13881791f, 0.03214414f, -0.04816455f, 0.05382904f, -0.02579664f, 
    0.14889362f, 0.01687233f, 0.45542842f, -0.10347334f, -0.26612741f, -0.04268778f, 0.16415893f, 0.02433749f, 
    0.17396653f, 0.01095443f, -0.27477518f, -0.21719855f, 0.33997244f, 0.01040130f, -0.15281445f, 0.00072558f, 
    -0.19451909f, 0.01850842f, -0.26359048f, 0.01773548f, 0.13117577f, -0.18682358f, -0.30492300f, -0.01471550f, 
    -0.13916937f, 0.03902075f, 0.12056076f, 0.03139727f, -0.06281934f, 0.00556711f, 0.00517910f, 0.10448511f, 
    -0.21561843f, 0.05682484f, -0.11128747f, 0.20557667f, 0.17682509f, 0.05786018f, 0.40254596f, -0.01885131f, 
    0.03045079f, 0.08241899f, 0.08550970f, -0.08724703f, -0.02861314f, 0.12371268f, 0.18817484f, 0.24487327f, 
    -0.14152859f, -0.20259078f, -0.01695455f, 0.00927126f, 0.09424181f, 0.31077954f, -0.34493306f, -0.00795506f, 
    -0.04979086f, -0.07517152f, -0.08095884f, -0.04084352f, -0.04710723f, 0.01851203f, 0.03455769f, -0.04700111f, 
    -0.02348739f, 0.04130337f, -0.07380480f, -0.01898344f, -0.01531950f, -0.01872055f, -0.08139975f, -0.04355135f, 
    -0.02936360f, -0.02825842f, -0.03705148f, 0.02511863f, -0.08420086f, 0.01721013f, 0.04965603f, -0.02625206f, 
    -0.01936487f, 0.04801747f, 0.05003898f, -0.02002133f, 0.03415091f, 0.02024228f, -0.03744998f, -0.04740599f, 
    -0.00458571f, 0.01028615f, 0.04683155f, 0.06000890f, -0.04584361f, -0.04404819f, 0.04240800f, -0.02009091f, 
    -0.05275690f, -0.06164955f, -0.05556102f, -0.06986747f, 0.00364019f, 0.03086712f, 0.06544729f, 0.03248484f, 
    -0.01555808f, -0.00562716f, -0.04995245f, -0.03875444f, -0.08917425f, 0.05459225f, 0.04412782f, -0.06588132f, 
    0.00603982f, -0.02865664f, 0.00621940f, -0.01273147f, 0.01364046f, -0.04768096f, -0.04182586f, 0.04095017f, 
    -0.04335872f, -0.05001529f, -0.06955930f, -0.03922765f, -0.05890542f, -0.07901102f, 0.05805646f, -0.00981066f, 
    -0.02189694f, -0.06265014f, 0.02348815f, 0.06061061f, -0.05305545f, 0.04256494f, -0.09842473f, 0.06168120f, 
    0.05864815f, -0.04946763f, -0.00704012f, -0.08965337f, -0.00228793f, 0.03817401f, -0.01361254f, 0.03479651f, 
    0.00168315f, -0.06367416f, -0.00204095f, 0.04967178f, -0.03037079f, -0.04341716f, -0.00729877f, -0.08673358f, 
    -0.00332863f, -0.04632870f, -0.01048751f, 0.01952583f, -0.07380212f, -0.01894929f, -0.06518743f, -0.00932844f, 
    0.00082738f, 0.04027128f, -0.03120881f, -0.06734353f, -0.08888870f, 0.03402944f, 0.05774949f, -0.09261192f, 
    -0.06497841f, 0.00722306f, -0.06103908f, -0.01241979f, -0.02740422f, -0.00643188f, -0.06210400f, 0.06042235f, 
    -0.01209375f, 0.05212725f, -0.08140282f, -0.00882330f, -0.00608496f, -0.06574690f, 0.01634287f, -0.00446460f, 
    -0.01629354f, -0.08024667f, -0.08221123f, -0.01694028f, -0.07244330f, 0.00496328f, -0.03536480f, -0.08911266f, 
    -0.00439197f, 0.05308967f, 0.01576608f, 0.06363079f, 0.02391363f, -0.02720627f, -0.08961832f, -0.06195757f, 
    -0.09144870f, 0.13252318f, 0.25307059f, -0.14828250f, -0.05269989f, -0.16031766f, -0.00802645f, 0.03455199f, 
    0.13083979f, -0.14817727f, -0.01687266f, -0.00050195f, 0.00344300f, 0.03399869f, 0.17482223f, 0.06926379f, 
    0.04025117f, 0.02710073f, 0.22206490f, -0.18951806f, -0.28341424f, -0.09498812f, 0.21522832f, 0.17620119f, 
    -0.00725524f, 0.03792788f, 0.31896177f, -0.05799836f, 0.08777024f, -0.07597268f, -0.31506789f, 0.03800566f, 
    -0.00933138f, -0.04482730f, -0.06273849f, -0.23497874f, 0.03723575f, -0.08071124f, -0.17559431f, 0.02738093f, 
    0.09215695f, -0.00221132f, 0.08004794f, -0.23866458f, 0.01322791f, 0.53764898f, -0.19987272f, -0.25737891f, 
    0.06725430f, -0.04330118f, -0.03932248f, 0.21870053f, 0.03933084f, 0.14642538f, -0.27563009f, 0.12847516f, 
    0.32800725f, -0.18666495f, -0.34697902f, -0.10264336f, 0.01685929f, 0.13604319f, -0.01938150f, -0.12802564f, 
    -0.21146147f, 0.06704083f, 0.24748743f, 0.20838749f, 0.02585305f, 0.06568946f, 0.24142127f, -0.05489519f, 
    0.58614308f, -0.54343641f, 0.07200801f, -0.02374303f, 0.04777626f, 0.11653455f, -0.26595154f, -0.19275904f, 
    -0.26207691f, -0.12010694f, 0.12074630f, 0.32558712f, -0.11264709f, 0.02904760f, -0.06935307f, -0.02959037f, 
    0.18172807f, 0.12596387f, 0.05611537f, -0.43067807f, -0.10264904f, 0.12290823f, -0.14600576f, -0.06489200f, 
    0.08803415f, 0.06589260f, -0.15895012f, -0.00862965f, -0.39231652f, -0.42948765f, -0.21539348f, -0.11088677f, 
    0.07186027f, -0.06991872f, -0.11896310f, 0.07465592f, -0.41465381f, -0.04166324f, -0.05152610f, 0.20981947f, 
    0.11648605f, 0.14021432f, 0.02468105f, 0.09223411f, 0.08681064f, 0.20528799f, -0.18118754f, 0.26986337f, 
    -0.06066469f, 0.15580648f, 0.04209499f, -0.15991063f, 0.13837893f, -0.05425500f, -0.29232940f, 0.11076060f, 
    -0.22914658f, 0.15813917f, -0.00673287f, -0.02951043f, -0.09158178f, -0.13430026f, -0.11581536f, -0.57208210f, 
    0.05782491f, -0.02604857f, 0.15718527f, 0.08288052f, 0.08755545f, 0.06198122f, -0.04749250f, 0.03253118f, 
    0.02273391f, -0.23605770f, -0.12103717f, 0.24547213f, 0.09966355f, 0.08343538f, 0.09695973f, 0.00742745f, 
    -0.05277203f, 0.18868984f, -0.16606916f, 0.03197953f, 0.00690833f, 0.05870681f, -0.22652891f, 0.10877514f, 
    0.03315204f, -0.10431877f, -0.16947103f, -0.13734563f, -0.15571581f, -0.13821954f, 0.04583766f, 0.02288799f, 
    -0.18931560f, -0.07860209f, 0.03398820f, 0.02827676f, 0.39761457f, -0.32363114f, -0.01887068f, -0.31816375f, 
    -0.22707728f, 0.01792734f, 0.12890011f, 0.17265102f, -0.11554131f, 0.34592077f, 0.01228078f, -0.00238160f, 
    0.08429080f, 0.25404039f, -0.09972510f, -0.10534034f, 0.15474284f, -0.40880641f, -0.41351825f, -0.13992521f, 
    0.09267125f, 0.28328401f, 0.17609982f, -0.29118106f, 0.08891321f, -0.13160761f, 0.37991795f, -0.02864130f, 
    -0.00029409f, 0.08729877f, 0.14504912f, -0.05581107f, -0.05733459f, -0.02209684f, -0.11884945f, -0.37216133f, 
    -0.02542946f, -0.18136184f, 0.09394246f, 0.01805551f, -0.13156225f, -0.00849237f, 0.02767741f, -0.00262899f, 
    -0.02526979f, 0.08090427f, 0.07901762f, -0.22037160f, -0.05241777f, -0.06791874f, -0.31812966f, 0.01267973f, 
    -0.14017537f, 0.43228954f, 0.32193321f, 0.03217196f, 0.00396126f, 0.12312458f, -0.34109828f, 0.05327237f, 
    0.06122534f, 0.26234066f, -0.42124030f, -0.19410771f, -0.21322064f, 0.41299909f, -0.18047103f, 0.12842631f, 
    -0.33900991f, 0.16665962f, -0.09046837f, 0.34258214f, 0.08891816f, 0.00394597f, -0.16512598f, -0.12139571f, 
    0.12847646f, 0.25485459f, -0.04388558f, -0.11918433f, -0.07980571f, 0.02245742f, 0.04211690f, 0.07505550f, 
    0.23134395f, 0.15458688f, 0.24010901f, 0.23599446f, -0.01918025f, 0.30884680f, -0.17235328f, -0.14973533f, 
    0.05828908f, 0.01095284f, -0.02661055f, 0.14193399f, 0.11045276f, 0.00809971f, -0.46886703f, 0.24025555f, 
    0.06926160f, -0.12208742f, -0.10882539f, 0.11363152f, -0.10985620f, -0.08061541f, 0.26145077f, 0.26410311f, 
    -0.08464288f, -0.18137328f, -0.13788770f, 0.27433655f, 0.14657600f, 0.20905086f, 0.10611157f, -0.05215462f, 
    0.13265277f, 0.45837092f, 0.02630117f, 0.06534716f, 0.11198531f, 0.04292351f, -0.12084248f, -0.02798530f, 
    -0.11376684f, -0.45089898f, -0.30799592f, -0.44897360f, 0.39678568f, -0.11379876f, -0.07338782f, -0.04029188f, 
    -0.00502731f, 0.01558491f, -0.05960630f, -0.16534095f, 0.23805824f, 0.06401113f, 0.06673130f, 0.01629837f, 
    -0.15151708f, 0.12078712f, 0.05564956f, 0.08318011f, 0.29843804f, 0.00610846f, 0.08528639f, -0.14594254f, 
    -0.11214127f, 0.06886056f, -0.12201420f, -0.09417868f, -0.16171476f, -0.38769618f, 0.12375484f, 0.18066904f, 
    0.16560625f, -0.22675121f, -0.05536763f, -0.02788014f, 0.12368161f, 0.19777738f, 0.15306582f, -0.09964497f, 
    0.00134622f, -0.09584555f, 0.03432974f, 0.00564771f, 0.19265257f, 0.06671884f, 0.33638406f, 0.45759451f, 
    0.02119656f, -0.05533200f, 0.11030158f, -0.23852184f, -0.01731770f, 0.09922911f, 0.01410373f, -0.11984566f, 
    -0.01904804f, 0.39548621f, -0.09587880f, -0.10288817f, -0.07056718f, 0.03909905f, 0.11701289f, 0.19157009f, 
    -0.50856435f, 0.00974824f, -0.17805034f, -0.01990631f, -0.09133036f, 0.10696650f, 0.09123319f, 0.12039983f, 
    -0.12086566f, -0.39114875f, 0.15308279f, -0.72984451f, 0.05145230f, -0.02661339f, 0.03853491f, -0.04919193f, 
    0.04731721f, 0.06547097f, 0.29787591f, -0.14840972f, 0.15852867f, -0.15198210f, -0.28504369f, 0.15481433f, 
    -0.01386589f, -0.01975561f, 0.20202285f, -0.04564037f, 0.02905180f, -0.15261661f, 0.08974635f, -0.13849537f, 
    0.02733727f, -0.06019745f, -0.14017001f, 0.13702558f, 0.19609599f, -0.05884570f, -0.23253734f, 0.14881995f, 
    0.12093318f, 0.00350470f, 0.08839761f, 0.03279259f, -0.01238490f, -0.44813219f, -0.09776373f, -0.12059432f, 
    0.19293888f, 0.06498572f, -0.12754136f, 0.02411888f, 0.24413110f, -0.02498724f, 0.06288219f, 0.12893069f, 
    0.62445486f, -0.12766482f, -0.06736001f, 0.09041928f, -0.08027820f, 0.11478574f, -0.01266573f, -0.26033360f, 
    -0.01679302f, 0.37103242f, 0.26112351f, 0.07418640f, -0.02429790f, -0.12663606f, 0.00666389f, 0.03392526f, 
    -0.06678434f, 0.07086430f, 0.06218277f, -0.01264249f, 0.00568125f, 0.02258791f, -0.01130909f, -0.05936561f, 
    -0.00276630f, 0.05128094f, -0.02290233f, 0.05535166f, 0.02862647f, -0.08771539f, 0.03251176f, 0.00356023f, 
    -0.02335116f, -0.03638867f, 0.05404474f, -0.02926888f, 0.02420131f, 0.02270533f, -0.01244183f, -0.01299045f, 
    0.02211848f, -0.03420598f, -0.00187664f, 0.05583565f, -0.04576768f, 0.03222099f, 0.04346566f, -0.01020159f, 
    -0.00684107f, -0.06692233f, -0.04258377f, 0.00600993f, -0.07270720f, -0.00391750f, 0.00212853f, -0.03381116f, 
    -0.03375841f, 0.01106707f, -0.02853755f, -0.08843277f, -0.04560766f, -0.05357100f, -0.01928676f, -0.09203627f, 
    0.05815752f, 0.01905663f, -0.02806252f, -0.00945134f, -0.05005260f, -0.05974469f, -0.05578646f, 0.01297709f, 
    0.02179912f, -0.00477578f, -0.07179831f, 0.01886890f, 0.02974774f, -0.03938422f, 0.01246022f, 0.02369337f, 
    0.06844486f, -0.07948632f, 0.05783499f, 0.04663210f, 0.05946906f, 0.05426466f, -0.03666039f, -0.00909597f, 
    0.03400449f, 0.00630397f, -0.04662231f, -0.01066999f, -0.02952127f, -0.04370788f, 0.06630725f, -0.07214712f, 
    -0.08050549f, -0.07510838f, -0.02528780f, -0.02657621f, 0.01989818f, -0.01085375f, -0.07996300f, -0.04570215f, 
    0.04395045f, -0.04251270f, -0.07599767f, 0.03304862f, -0.01005325f, -0.08684333f, 0.05897561f, -0.06804014f, 
    -0.03864884f, 0.01578717f, -0.01186900f, 0.04917237f, -0.00416490f, 0.06611814f, 0.04355769f, -0.01476912f, 
    -0.09438566f, -0.07654539f, 0.01042378f, -0.05528395f, 0.05723896f, -0.07333889f, 0.02936958f, -0.01656186f, 
    -0.08050211f, -0.07878516f, -0.09095822f, 0.02300966f, -0.06941325f, 0.00121777f, 0.05865405f, 0.05666293f, 
    0.01199961f, 0.05278359f, 0.01983077f, -0.06047713f, -0.05516993f, -0.01223055f, 0.05970462f, -0.01098820f, 
    -0.00072914f, -0.01261337f, -0.05826403f, 0.02710432f, 0.00558510f, 0.02152677f, -0.06945781f, 0.00959369f, 
    0.02090354f, -0.00714945f, 0.06243397f, -0.07329126f, 0.03298812f, -0.05067894f, 0.03465926f, -0.07464856f, 
    0.70125717f, 0.00417797f, -0.03474616f, 0.09092390f, -0.12536053f, 0.14242488f, 0.29998672f, 0.15216960f, 
    -0.06393351f, -0.46749210f, -0.16429019f, 0.05186391f, 0.07054960f, -0.14483254f, -0.00863379f, -0.13106406f, 
    -0.04190433f, 0.10077532f, 0.46589857f, -0.09616646f, -0.38827255f, 0.07273135f, -0.06089190f, 0.17537026f, 
    -0.19393253f, 0.05279306f, -0.00201910f, 0.26425961f, -0.00851952f, -0.43346405f, -0.00909695f, 0.03217093f, 
    0.02511575f, -0.00683731f, 0.00883304f, -0.20089026f, -0.17482948f, 0.05272910f, -0.13575630f, 0.03773026f, 
    0.05128921f, -0.06437338f, -0.07974663f, 0.10673998f, 0.04824397f, -0.20502806f, -0.23315224f, 0.09987899f, 
    0.23738734f, 0.28794667f, 0.06203951f, 0.05371826f, 0.13993989f, -0.16078031f, 0.46705526f, 0.17938417f, 
    0.36355758f, 0.20544897f, 0.01285585f, -0.08802177f, -0.09574074f, 0.08653900f, 0.13411976f, -0.11931872f, 
    0.43043834f, -0.03914347f, -0.11151136f, 0.02046065f, -0.09942485f, -0.16933256f, -0.19792406f, -0.03213577f, 
    -0.46034625f, -0.07640804f, -0.10704849f, -0.13297305f, -0.03903722f, -0.12661606f, 0.06159813f, -0.06783726f, 
    -0.04858968f, 0.27825972f, -0.06845635f, -0.13695133f, 0.16601945f, -0.00023443f, 0.10004359f, -0.07341596f, 
    -0.07516281f, 0.11141954f, -0.42239913f, -0.19673972f, -0.52451855f, 0.04571226f, 0.19153434f, -0.01823833f, 
    -0.21760738f, -0.26893666f, -0.08152531f, -0.40279892f, -0.20554006f, -0.13267219f, -0.04234436f, -0.09455679f, 
    -0.00083014f, 0.04398931f, -0.19292682f, -0.01602522f, 0.38413340f, 0.04941739f, 0.08471267f, -0.07879506f, 
    -0.26929942f, -0.17937474f, 0.08179343f, 0.10926256f, 0.06246536f, 0.42587873f, 0.05996013f, 0.10576601f, 
    -0.00024113f, 0.10615891f, -0.06647947f, -0.00314463f, 0.04346274f, 0.00107032f, 0.03779076f, -0.16060594f, 
    -0.05273658f, -0.10755505f, 0.22830722f, 0.07999080f, 0.04100638f, 0.00487977f, -0.17002918f, 0.00712398f, 
    0.16236904f, 0.43748927f, -0.22501770f, 0.05431055f, -0.00734395f, 0.13902633f, -0.06205563f, -0.02902262f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.20609686f, 0.05800409f, 0.38803503f, -0.25598523f, -0.04586301f, 0.17960116f, 0.20407267f, -0.07355887f, 
    0.23571412f, 0.23340344f, 0.02662953f, 0.28317726f, 0.09117605f, -0.03261155f, -0.03896319f, 0.04214521f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04533207f, -0.03080908f, 0.13024965f, -0.06413211f, 0.15765604f, -0.09099130f, -0.05974537f, -0.14306183f, 
    -0.15723589f, 0.64275539f, -0.21246746f, -0.05591436f, 0.28904992f, -0.39239618f, -0.10055900f, 0.11926086f, 
    -0.14364558f, -0.52157015f, -0.19790080f, 0.25077781f, -0.21835357f, -0.16657878f, 0.19981886f, -0.11271694f, 
    0.47599655f, 0.66902614f, -0.02409652f, 0.42826143f, -0.07273302f, -0.53451705f, -0.12706649f, 0.73896581f, 
    0.00747531f, -0.84036922f, 0.52053905f, -0.22181326f, 0.15465599f, 0.34370652f, 0.04057363f, -0.09234348f, 
    0.26102400f, 0.65885019f, 0.14268707f, -0.28684363f, 0.29447788f, -0.20697768f, 0.03022807f, -0.03492931f, 
    -0.13212182f, 0.43390098f, 0.23281111f, -0.36804447f, 0.10514169f, 0.37366870f, 0.33157688f, -0.23863521f, 
    0.43031460f, 0.26206049f, -0.01814382f, -0.03597479f, -0.12632322f, -0.65673977f, -0.21082552f, 0.58822811f, 
    -0.33430198f, -0.16889210f, -0.22282781f, 0.19189617f, -0.18789692f, 0.41128927f, -0.04628963f, -0.08975215f, 
    0.46328223f, 0.24656293f, -0.01690896f, -0.05514694f, 0.04607489f, 0.01750039f, 0.16546400f, 0.71117008f, 
    -0.09922682f, 0.15117761f, 0.58662099f, 0.64387763f, 0.04987123f, 0.08901396f, -0.38246077f, 0.23674007f, 
    0.21949859f, 0.29815900f, 0.22417575f, 0.22198267f, -0.12069001f, -0.23363592f, -0.15916163f, 0.12988952f, 
    0.48496637f, 0.01937323f, -0.41785869f, 0.55626190f, 0.02683382f, 0.38897985f, -0.37305406f, -0.22917303f, 
    0.10092905f, 0.11191089f, -0.11239904f, -0.17333721f, 0.05702387f, -0.49917880f, -0.12372815f, -0.02889256f, 
    0.59417075f, -0.06717108f, 0.48813662f, -0.51044607f, 0.13865827f, 0.30011669f, 0.10486813f, 0.09363107f, 
    -0.27755570f, -0.65616661f, 0.22233094f, -0.44556144f, 0.31609491f, -0.05676502f, -0.08049279f, 0.37089875f, 
    -0.17016989f, -0.10984874f, -0.23506433f, -0.05203357f, -0.04427940f, -0.22706270f, -0.21879613f, 0.01242208f, 
    -0.22557178f, 0.24578816f, 0.10796154f, -0.16329831f, 0.17373878f, 0.08836651f, -0.22654223f, 0.00193226f, 
    0.44082543f, 0.41335905f, 0.14150344f, 0.10443688f, 0.21368045f, 0.66504836f, 0.39026916f, -0.19730026f, 
    -0.38629523f, 0.45364308f, 0.13867287f, -0.49396154f, 0.15147065f, -0.10209031f, 0.20708930f, -0.58927459f, 
    -0.15986505f, 0.04122017f, -0.30927882f, 0.28453985f, 0.14254697f, 0.37115452f, 0.50970650f, 0.01188991f, 
    -0.02688612f, -0.07618444f, -0.15528081f, -0.63124788f, 0.64611161f, -0.51552355f, -0.23228617f, 0.14171693f, 
    0.50873113f, -0.26673618f, 0.15112780f, -0.24391119f, -0.05427171f, -0.10953315f, 0.34694225f, -0.13788950f, 
    -0.26915672f, -0.06877839f, 0.08861831f, -0.03183552f, 0.42526880f, 0.31465143f, 0.09480043f, 0.69551122f, 
    -0.18010208f, -0.03487328f, -0.02078828f, -0.12368518f, -0.14867097f, -0.15491137f, -0.16798452f, -0.15901944f, 
    -0.22269478f, -0.09645000f, -0.11118087f, -0.23405606f, -0.10640106f, -0.24206167f, 0.00359479f, -0.20159584f, 
    -0.34669611f, -0.69726443f, 0.06056376f, -0.08131946f, 0.21252435f, -0.01301183f, 0.29492766f, 0.25789082f, 
    0.10096306f, -0.10345744f, 0.06261572f, 0.95094329f, -0.10433871f, 0.28446695f, 0.00041129f, 0.46347150f, 
    -0.00363290f, -0.29038283f, -0.00427268f, 0.10367937f, 0.24733046f, -0.14152464f, -0.01220100f, 0.16755307f, 
    -0.24993205f, -0.03606658f, 0.08708367f, -0.16737321f, -0.01765209f, 0.01686983f, 0.20818901f, -0.21826896f, 
    0.61923701f, 0.50382274f, -0.32841539f, 0.37241593f, -0.08661098f, 0.29963434f, -0.03396210f, -0.13281302f, 
    -0.02786336f, -0.27423358f, -0.13979563f, -0.60746872f, 0.04917576f, -0.37050733f, -0.03381883f, -0.21645050f, 
    -0.34072861f, 0.10029843f, 0.36620024f, -0.36324346f, 0.07014494f, 0.74528342f, 0.36292827f, 0.04739441f, 
    0.35953817f, 0.38189754f, 0.24940495f, 0.68847245f, -0.10288087f, -0.12218653f, 0.08090765f, -0.06688507f, 
    -0.32129005f, -0.11164020f, 0.30179602f, 0.24272379f, 0.09330756f, -0.18056491f, -0.33313218f, -0.10541652f, 
    0.32310635f, 0.62974852f, 0.18218784f, 0.32935461f, -0.27709952f, 0.85889757f, 0.01944611f, 0.34532517f, 
    0.58707774f, 0.23730421f, 0.28877103f, -0.03780574f, -0.09075809f, -0.75749111f, -0.10436217f, 0.02533734f, 
    0.50343066f, -0.23499043f, -0.13798793f, -0.24533266f, 0.26370734f, -0.27769303f, -0.20640808f, 0.42409897f, 
    0.09248258f, -0.04854132f, -0.18085377f, -0.29018795f, -0.00149953f, 0.02578708f, 0.05096904f, 0.02163300f, 
    -0.03654096f, -0.27253044f, -0.24248165f, 0.16322434f, -0.24608307f, 0.03150314f, -0.23718226f, -0.14653534f, 
    0.36349776f, -0.35312080f, -0.49353093f, -0.01365301f, 0.19891682f, 0.10100999f, 0.31587905f, 0.02541766f, 
    0.01644626f, 0.66791272f, 0.15187579f, 0.36381415f, 0.02814646f, 0.41857988f, -0.05633180f, -0.56373131f, 
    0.18457545f, 0.05948354f, -0.44980794f, 0.05360318f, -0.22600727f, -0.30430585f, 0.23123491f, -0.16807723f, 
    0.31650630f, -0.88298571f, -0.21752255f, 0.08530039f, 0.47572097f, 0.01415563f, -0.19128773f, 0.02472910f, 
    0.00970759f, 0.04515652f, -0.23875485f, -0.10327193f, -0.24394576f, 0.11634050f, -0.23811507f, -0.01715888f, 
    -0.10332251f, 0.05365191f, 0.15244956f, -0.22541046f, 0.17637227f, 0.05668721f, 0.20426521f, 0.03763643f, 
    0.33017394f, 0.86566812f, 0.42379528f, 0.43536866f, -0.10303810f, -0.05948824f, 0.04090232f, -0.14728399f, 
    -0.27455136f, -0.07632338f, 0.03423701f, 0.05033343f, -0.21223262f, 0.44132224f, -0.11409731f, -0.52517480f, 
    0.00074153f, 0.11351826f, -0.08716979f, 0.65580255f, 0.06322832f, -0.38618484f, 0.08626752f, 0.00784063f, 
    -0.02392429f, 0.33713451f, -0.21170227f, 0.49465445f, -0.18690754f, -0.10774486f, -0.04394193f, 0.13348135f, 
    -0.13161677f, -0.11822637f, -0.14464952f, 0.18420213f, -0.17502917f, -0.11617494f, -0.24563494f, 0.13384010f, 
    -0.20136754f, 0.18158808f, 0.16270548f, -0.18098776f, -0.21122405f, 0.11404564f, -0.12259213f, -0.16615598f, 
    -0.24627893f, 0.10119121f, -0.27066967f, -0.14960998f, -0.19101296f, 0.03090289f, -0.29151013f, 0.03071688f, 
    0.04512671f, 0.02669238f, 0.01030638f, 0.10265525f, 0.13373248f, -0.19785714f, 0.17582682f, -0.17326219f, 
    0.11099368f, -0.10236424f, 0.32847336f, -0.17119357f, 0.01422986f, 0.05477369f, -0.04562199f, -0.08253997f, 
    0.21228130f, -0.33496988f, 0.23708379f, 1.03169513f, -0.29107985f, 0.27787331f, -0.18170498f, 0.05039852f, 
    0.28823772f, -0.20464194f, 0.06525262f, 0.18291788f, -0.15073200f, -0.29847100f, 0.28247079f, 0.02424060f, 
    -0.46073714f, -0.04440983f, 0.10160509f, 0.22263905f, 0.14450403f, 0.87965566f, 0.08163082f, 0.07061145f, 
    -0.18524775f, 0.05546210f, -0.39185297f, 0.52768672f, 0.02271068f, -0.40716940f, 0.06835756f, -0.25335428f, 
    0.15550342f, 0.21965773f, 0.20916510f, 0.36688209f, 0.10175249f, 0.37574434f, 0.08981340f, -0.85401344f, 
    0.21179007f, -0.59567934f, 0.00200457f, 0.41067594f, 0.01484643f, -0.37628156f, -0.16114271f, 0.18058266f, 
    0.56436032f, 0.00352564f, -0.04445214f, -0.20312063f, 0.40282917f, -0.29621756f, 0.15159903f, 0.26424241f, 
    -0.47543582f, 0.20633572f, -0.18838054f, 0.14939447f, 0.12705454f, -0.85826916f, 0.36152896f, 0.08270957f, 
    0.18946612f, 0.66528285f, -0.03947699f, 0.04358853f, 0.60896212f, -0.10927519f, 0.08204651f, -0.62363684f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06220073f, -0.04299460f, 0.50698847f, 0.34990868f, -0.52915859f, -0.28100276f, 0.19414133f, 0.26684162f, 
    -0.18068781f, 0.36293021f, 0.04771874f, 0.34883046f, -0.20070595f, 0.23515242f, -0.22661912f, 0.06180405f, 
    0.57921839f, -0.28724641f, 0.59503448f, -0.28432983f, 0.49279663f, -0.19720851f, -0.16096199f, 0.06976324f, 
    0.20796049f, 0.15050273f, -0.23768012f, 0.68442190f, -0.16054231f, 0.20819804f, 0.29820719f, 0.09797903f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.31064570f, 0.11687864f, 0.24889414f, -0.11755278f, -0.07324263f, 0.30516267f, -0.14128008f, -0.83313400f, 
    -0.09508447f, 0.34482220f, 0.01964912f, -0.28167230f, -0.10203503f, -0.41907477f, -0.10226327f, -0.49827975f, 
    -0.03284208f, 0.06817741f, -0.08229322f, -0.09007922f, 0.64489526f, -0.69672149f, -0.17154701f, -0.11089988f, 
    0.23153859f, 0.08851417f, 0.16726477f, -0.37293690f, -0.12866743f, 0.31312361f, 0.08448981f, 0.30195168f, 
    -0.26670319f, 0.23532675f, 0.52844220f, 0.33238757f, 0.15828778f, 0.52412879f, 0.09481554f, -0.15333126f, 
    -0.07942276f, -0.04224631f, -0.18225487f, -0.33946359f, 0.01124307f, 0.01317192f, -0.05596730f, -0.06151292f, 
    0.23628102f, 0.11991989f, -0.18414095f, -0.16797191f, -0.69978458f, -0.97392583f, -0.18363330f, 0.01085516f, 
    0.17539527f, -0.00967352f, 0.14626646f, 0.08862658f, -0.39557084f, -0.69894785f, -0.25484914f, -0.46121639f, 
    -0.61400545f, 0.11237510f, 0.31473887f, 0.33476645f, 0.31698841f, -1.02587152f, -0.84250236f, 0.19508806f, 
    -0.09284280f, 0.37828332f, 0.40662476f, 0.06417394f, 0.13431428f, 0.25879902f, 0.05430397f, -0.27934799f, 
    0.36834174f, -0.33352607f, -1.29483950f, 0.05941503f, 0.42523229f, -0.06249907f, -0.05709768f, -0.51834536f, 
    -0.89665246f, 0.10406737f, 0.09899944f, -0.21921429f, -0.10922005f, -0.65048414f, -0.94433069f, -0.58683676f, 
    -0.21168736f, -0.65598053f, -1.25683963f, 0.07033874f, -0.45651248f, -0.36014757f, -0.57171869f, -0.13334079f, 
    -0.06075696f, 0.23950014f, 0.42925307f, -0.21342078f, 0.06478971f, -0.77027369f, -0.02481535f, 0.14876227f, 
    -0.15158820f, -0.57243842f, 0.33694419f, -0.09779313f, -0.41669169f, 0.31376567f, -0.11868502f, 0.27407801f, 
    -0.07181542f, -0.01900242f, 0.02769896f, -0.99941307f, -0.07891084f, 0.11862747f, -0.43208200f, 0.86123830f, 
    0.48824692f, -0.14489025f, 0.06765515f, -0.28012368f, -0.32422787f, -0.16770501f, -0.01243137f, -0.38060924f, 
    0.07893523f, 0.02415282f, 0.09343945f, -0.10835429f, 0.08558227f, 0.25372466f, -0.08892581f, -0.37392333f, 
    0.21078046f, -0.28844482f, -0.40298164f, -0.06864972f, 0.36629662f, 0.39277095f, 0.02743328f, -0.06796566f, 
    0.12788104f, -0.12997931f, 0.04374556f, 0.23042019f, 0.16146144f, 0.30019757f, -0.21380734f, 0.41413683f, 
    -0.68660301f, 0.12555102f, 0.29875267f, 0.02626365f, 0.12054419f, 0.29414824f, 0.71256840f, 0.54716241f, 
    -0.13029179f, -0.42067236f, -0.46312818f, -0.57031608f, -0.04260581f, 0.01028779f, -0.12735285f, 0.32016280f, 
    0.18155393f, 0.09064726f, 0.20650354f, -0.08144210f, 0.05536126f, 0.02302489f, 0.07437953f, -0.25694564f, 
    -0.12255318f, 0.13980326f, -0.12540284f, 0.22595173f, -0.68662369f, 0.37069315f, 0.39477569f, -0.08961487f, 
    -0.01416588f, 0.30049917f, -0.39302802f, 0.24467681f, 0.35521734f, 0.02482279f, -0.69572651f, -0.35176384f, 
    0.09610116f, -0.56304497f, 0.24271905f, -0.08124622f, -0.00397059f, 0.11634540f, -0.06332363f, -0.88383460f, 
    -0.07167538f, -0.08477838f, 0.46505794f, -0.11962786f, -0.31392887f, 0.50392872f, 0.16067329f, -0.43315732f, 
    0.14487220f, 0.08621297f, 0.05902714f, 0.06628188f, -0.52930313f, -0.14141235f, 0.30124640f, 0.09265412f, 
    0.37356892f, -0.69233471f, 0.63664389f, -1.15190196f, -0.11939637f, 0.28384325f, 0.33164853f, -1.09682107f, 
    0.00333997f, 0.06019316f, -0.06086889f, -0.54335171f, -0.05712738f, -0.21147254f, -0.11665146f, 0.45867938f, 
    -0.65855420f, 0.42838100f, -0.36388627f, 0.08186971f, -0.02254022f, 0.05264250f, -0.03094213f, 0.39240819f, 
    0.24751911f, 0.13566534f, -0.03971935f, 0.02204947f, 0.41569209f, 0.47446659f, 0.11941823f, -0.25773162f, 
    0.24996421f, -0.52919841f, -0.58151424f, 0.05688614f, -0.19957562f, 0.40820941f, -0.15117417f, 0.29027602f, 
    -0.05240963f, -0.20518216f, -1.14591026f, 0.16858669f, -0.10574280f, 0.03711624f, 0.02683448f, -0.42610019f, 
    0.25851521f, 0.71082705f, -0.17877957f, -0.19323894f, -0.72762370f, -0.83606660f, -0.01566873f, 0.32291153f, 
    -0.35415146f, -0.00812549f, -0.13980040f, 0.22571534f, 0.31167012f, -0.33269504f, -0.99198973f, -0.72858858f, 
    -0.82943642f, 0.20935035f, -0.12877974f, -0.20954718f, -0.18291388f, -0.29870582f, 0.15204370f, -0.84065902f, 
    0.09918005f, -0.58183748f, -0.54334539f, 0.16233610f, 0.09324019f, 0.42383590f, -0.04950653f, -0.15985486f, 
    -0.06078980f, 0.22239077f, 0.11292230f, 0.14399481f, 0.34142655f, -0.06279492f, 0.16524686f, -0.17247348f, 
    0.27654096f, -0.01779281f, -0.14758317f, 0.31386730f, 0.39785442f, 0.21464530f, -0.04771297f, 0.06853111f, 
    -0.21888444f, -0.89569777f, -1.03366637f, 0.09797049f, -0.79987425f, -0.56306440f, 0.21820176f, 0.63611871f, 
    0.05093558f, 0.41708389f, -0.28996322f, 0.02356956f, 0.09360735f, -0.71392757f, -0.21148235f, 0.53328651f, 
    0.07101485f, -0.91814148f, 0.35368541f, -0.11561885f, 0.32865754f, -0.12950546f, -0.04992589f, 0.23726569f, 
    -0.22875263f, 0.08356221f, 0.14463539f, 0.35019115f, -0.07698186f, -0.31230739f, -0.43992448f, -0.75023073f, 
    0.12539296f, 0.01011498f, -0.02799430f, -0.23736964f, -0.16372158f, -0.07401112f, -0.00786766f, 0.43955323f, 
    -0.06357919f, -0.01020453f, 0.38965553f, 0.41929001f, 0.13143787f, -0.27987039f, 0.14907895f, 0.11599670f, 
    -0.37445745f, -0.66245538f, 0.44142056f, 0.05206211f, -0.44212610f, 0.19022018f, -0.01711922f, -0.33007917f, 
    -0.33690667f, 0.13722764f, -0.06136209f, -0.47790176f, 0.18926094f, -0.80299169f, 0.60507959f, -0.21743289f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.02627006f, -0.05253534f, -0.30171847f, -0.27765059f, 0.29134545f, 0.06616409f, -0.07787123f, -0.53583020f, 
    -0.14647271f, 0.12865296f, 0.42438516f, -0.15549204f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
