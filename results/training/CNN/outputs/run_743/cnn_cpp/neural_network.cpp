#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.89747983f, 0.43415371f, -0.96293938f, -0.06134554f, -0.48916709f, -0.27182522f, 0.30284676f, 0.53402573f, 
    0.13928784f, -0.31649965f, 0.08853074f, -0.20726940f, 0.39866176f, -0.43677843f, -0.19172196f, -0.28225228f, 
    0.20265783f, 0.05792912f, 0.09243384f, -0.13816845f, -0.14012973f, -0.20750757f, -0.33090565f, 0.10896226f, 
    -0.03577980f, 0.35701993f, -0.25145251f, -0.46179479f, 0.82602018f, 0.55620795f, 0.04799949f, -0.58703291f, 
    -0.38759714f, -0.05927333f, 0.26583168f, -0.08636720f, 0.00334456f, 0.07116584f, 0.11266929f, 0.33893958f, 
    0.22501078f, 0.22015172f, 0.23621096f, 0.26529497f, 0.24638285f, -0.13816355f, -0.38093647f, 0.07515774f, 
    -0.12914594f, -0.51421618f, -0.07394778f, -0.67614663f, 0.22916695f, 0.51904255f, 0.14313582f, 0.48297605f, 
    0.77122945f, 0.20911554f, 0.54230571f, 0.19169544f, -0.04603462f, 0.36521494f, 0.16401246f, 0.18194786f, 
    -0.38686544f, -0.34877032f, -0.14011016f, -0.05419008f, -0.03213322f, 0.06409957f, 0.01516952f, -0.19073674f, 
    0.25093275f, -0.20318051f, 0.16608532f, -0.72764146f, -0.24719390f, 0.75223482f, 0.33474776f, 0.00618902f, 
    -0.83461076f, 0.09273781f, -0.40701222f, -0.30688184f, 0.16022319f, -0.39677846f, 0.39235225f, 0.18470246f, 
    0.07468274f, -0.18264498f, 0.36981723f, -0.15259375f, 0.20616478f, 0.14028692f, -0.13276638f, -0.15748878f, 
    0.22713824f, -0.10299544f, -0.07998660f, 0.32548815f, -0.32292777f, -0.46514866f, 0.33259836f, -0.53517681f, 
    -0.71667349f, -0.25597322f, -0.35811028f, -0.28070325f, -0.40010381f, -0.53987610f, -0.04700766f, 0.30655441f, 
    -0.27790406f, 0.26448613f, -0.14102048f, -0.07662521f, 0.10946493f, 0.31917942f, 0.17232697f, 0.09222718f, 
    0.25172263f, 0.16852409f, 0.18853545f, 0.03440661f, 0.20679370f, 0.38978383f, -0.53313118f, -0.45937678f, 
    0.47359034f, -0.51200724f, -0.64932197f, 0.45094159f, 0.62306231f, -0.43380353f, 0.22874910f, -0.15179993f, 
    0.36973703f, 0.35162422f, -0.41744721f, 0.26640999f, 0.15230572f, 0.02919026f, -0.40823242f, -0.17455360f, 
    -0.04475391f, 0.25098997f, -0.26133877f, 0.30183220f, -0.12172220f, 0.38279602f, 0.33963525f, 0.24205288f, 
    0.58528769f, -0.10136235f, 0.40371892f, 0.48863941f, 0.40123022f, 0.31217775f, 0.19969791f, 0.26337835f, 
    0.24222437f, 0.70975804f, 0.27267668f, 0.15011154f, 0.05110235f, 0.35425538f, -0.20299551f, -0.36672607f, 
    -0.01172155f, -0.27389133f, 0.31772071f, -0.28232649f, 0.19389923f, 0.11101414f, -0.37022480f, 1.14072597f, 
    0.82470906f, 0.15093514f, 0.69977772f, -0.00192611f, -0.31238201f, -0.28185764f, -0.02620603f, -0.37481752f, 
    -0.07552752f, 0.07192542f, -0.04122728f, 0.05054163f, -0.24190699f, -0.21892539f, -0.02101499f, -0.06748340f, 
    -0.04284995f, -0.36322442f, 0.01593793f, -0.17867474f, 0.05469901f, -0.35194579f, -0.16827446f, -0.08451921f, 
    0.49737990f, 0.60553706f, -0.69329542f, -0.60851288f, 0.27865228f, -0.10818431f, 0.67143381f, -0.09936305f, 
    -0.02319801f, -0.34375256f, -0.04067468f, 0.25170374f, -0.01503254f, -0.07915320f, -0.36366588f, -0.15238203f, 
    0.55420595f, -0.10809272f, -0.01870768f, 0.02894696f, 0.37269706f, 0.02207530f, 0.21509224f, -0.15716727f, 
    -0.30812362f, 0.12339241f, -1.16087055f, 0.33051735f, 0.94456381f, -0.19013101f, -0.70974636f, 0.38492212f, 
    0.40424290f, -0.00317794f, 0.04289688f, 0.19185510f, 0.18917000f, 0.18876986f, -0.06203545f, 0.20297435f, 
    -0.53254813f, -0.09458044f, 0.16772924f, -0.09301727f, -0.34742081f, -0.33172449f, 0.11165343f, -0.20376201f, 
    0.00268467f, -0.04156282f, 0.03542133f, 0.77241170f, -0.77756107f, -0.15055583f, 0.50097710f, 0.06775044f, 
    -0.84114301f, -0.03231602f, -0.77443588f, -0.46668094f, 0.50094211f, 0.15383303f, 0.00873559f, 0.08437894f, 
    -0.01958576f, 0.09238003f, -0.08150467f, -0.27743316f, -0.36735800f, 0.24810044f, -0.18454294f, 0.06721859f, 
    0.22245418f, -0.10498960f, 0.02300008f, 0.28781119f, -0.12120120f, -0.13281584f, -0.41200939f, 0.07611951f, 
    0.50257230f, -0.24200441f, -0.64494854f, 0.40524718f, 0.33082157f, 0.58469003f, 0.46687549f, -0.09062108f, 
    -0.16117486f, 0.15735182f, -0.31651357f, -0.40372479f, 0.09905131f, -0.42226890f, -0.37452394f, 0.13491650f, 
    0.22425482f, -0.20812094f, 0.19206522f, 0.19074096f, -0.62532276f, -0.06241627f, 0.80074888f, 0.76671779f, 
    -0.56330532f, 0.45848206f, 0.89558971f, -0.52919406f, -0.16394390f, 0.18768281f, 0.09492037f, -0.03326491f, 
    0.29621151f, 0.00923875f, -0.10767826f, 0.21234375f, -0.05473555f, -0.10262986f, -0.02042787f, -0.13114047f, 
    0.01465337f, 0.29852208f, 0.12765191f, 0.10479697f, 0.02865493f, -0.57905304f, -0.30571035f, -0.53742450f, 
    0.81851488f, 0.53397936f, 0.34395215f, 0.19797213f, -0.57502002f, 0.70122981f, -0.25726745f, 0.32255661f, 
    0.02388985f, -0.15353777f, 0.12651509f, -0.23148854f, -0.41213259f, 0.20473638f, -0.16418542f, -0.20165826f, 
    -0.30600294f, 0.14386748f, 0.19890693f, -0.11021008f, 0.15187603f, -0.18063450f, 0.69825947f, 0.59405398f, 
    1.01679718f, -0.37754580f, -0.90438461f, -0.66391402f, -0.39368489f, 0.11250820f, 0.23836206f, -0.18932056f, 
    0.09367710f, 0.09155405f, -0.30224550f, -0.00275432f, -0.11339444f, -0.18058674f, 0.04878416f, -0.17846891f, 
    -0.04379423f, 0.04141042f, -0.04278767f, 0.21476445f, -0.01221889f, 0.29592887f, -0.13517369f, -0.76306301f, 
    -0.42149627f, -0.58022112f, 0.23406936f, 0.59684443f, -0.21907185f, 0.62774765f, 0.07952461f, -0.36095801f, 
    0.12748025f, 0.30544916f, 0.06988504f, 0.24722402f, -0.35212108f, 0.08976367f, -0.06580368f, 0.10644056f, 
    -0.15074332f, 0.19610219f, 0.19781259f, -0.02770201f, 0.19818328f, 0.15513586f, 0.20040883f, 0.12462302f, 
    0.40460542f, 0.37894982f, 0.68693298f, 0.37813810f, 0.49096391f, 0.30830476f, 0.07767549f, 0.09996698f, 
    0.32322627f, 0.33223200f, -0.19771501f, 0.07144727f, 0.17097013f, 0.13446377f, 0.00180428f, 0.19720858f, 
    0.06734595f, -0.24560466f, -0.14687665f, -0.28296381f, 0.08722813f, -0.44900441f, 0.26063564f, 0.24952199f, 
    -0.03354672f, -0.18615893f, 0.16517529f, -0.55932522f, -0.28137651f, -0.68665344f, -0.07603187f, 0.07332260f, 
    -0.08843248f, 0.07167368f, 0.01960773f, 0.25619859f, 0.24789101f, -0.16938226f, 0.06752641f, 0.39695680f, 
    0.18208940f, 0.51181406f, -0.41428605f, 0.00017279f, 0.39380017f, -0.16329564f, -0.34978244f, -0.06300648f, 
    0.38052425f, -0.40690666f, 0.11320107f, -0.85016799f, 0.27069050f, 0.41463801f, 0.36805177f, 0.19348113f, 
    0.72894996f, -0.23221911f, -0.23754734f, 0.49123555f, -0.02710392f, 0.19801280f, -0.19943641f, 0.50704932f, 
    0.38746291f, 0.16899110f, 0.16534679f, 0.00104825f, -0.09846047f, -0.06061035f, 0.33667302f, 0.26612842f, 
    -0.12973075f, 0.17647719f, 0.08148832f, -0.41216701f, 1.13634431f, 0.62352127f, -0.86942130f, 0.14126092f, 
    0.01181169f, 0.56536382f, 0.40586770f, -0.30249369f, 0.38054380f, 0.11412703f, 0.26647788f, -0.04130312f, 
    -0.22382317f, -0.11854227f, -0.23490317f, -0.10922159f, -0.08082466f, -0.08847816f, -0.15516087f, -0.05793065f, 
    0.00153639f, 0.25336611f, -0.10373909f, 0.19775417f, -0.71850973f, 0.94165379f, 0.07392990f, -0.59766704f, 
    -0.69999272f, 0.73362106f, 0.45398989f, -0.55778658f, 0.05595356f, 0.43971816f, 0.16582239f, -0.34570479f, 
    0.09628791f, 0.07440883f, 0.25817218f, 0.14029428f, -0.35968274f, 0.02732391f, 0.06742595f, 0.06059813f, 
    -0.27663502f, -0.22515978f, 0.04608869f, 0.08207944f, 0.13824481f, -0.16688333f, -0.03085083f, -0.12828915f, 
    -0.42074764f, -0.11832268f, -0.06530917f, -0.52064079f, 0.58216357f, 0.46646807f, -0.44231662f, -0.42729267f, 
    -0.34601375f, 0.11426745f, -0.07287792f, -0.52332550f, -0.40661353f, 0.18833329f, 0.10774797f, 0.16452082f, 
    0.06694778f, -0.26935983f, 0.57033348f, -0.31766498f, 0.22630484f, -0.29725569f, 0.02093192f, -0.33549973f, 
    0.67452943f, 0.45685324f, 0.64216083f, 0.53091532f, 0.73816836f, 0.19057636f, -0.34747714f, 0.45489508f, 
    -0.13652782f, -0.20803164f, 0.32902166f, -0.26992035f, -0.47100437f, -0.27844733f, -0.00927358f, -0.00874503f, 
    -0.07093544f, -0.20368320f, -0.04404415f, -0.22558160f, 0.11646014f, 0.15948799f, -0.19646432f, -0.51552135f, 
    -0.71463454f, -0.75392574f, -0.55357659f, -0.36396837f, 0.19498695f, -0.32393619f, 0.38846195f, 0.47752020f, 
    -0.06003556f, -0.46727151f, -0.12215161f, -0.04663438f, 0.23364125f, -0.16872871f, -0.35686687f, 0.12234272f, 
    -0.25697443f, 0.07689904f, 0.33225155f, -0.04922163f, -0.05262586f, 0.02011774f, -0.24938841f, -0.02347263f, 
    0.28720567f, -0.24974598f, -0.36322451f, -0.35337284f, 0.50993383f, 0.76678795f, 0.22660843f, -0.65196925f, 
    -0.22726278f, -0.32988587f, 0.25702667f, 0.03911874f, -0.04222839f, 0.30243835f, -0.17523423f, -0.28269941f, 
    -0.05517954f, 0.20719226f, 0.37493578f, 0.33132452f, 0.03421951f, -0.07082511f, -0.22102956f, -0.33962989f, 
    0.04486525f, 0.31346616f, 0.57915145f, 0.83076912f, 0.32417592f, 0.57609326f, -0.68550462f, 0.42277962f, 
    -0.07233962f, -0.69998455f, -0.32593468f, 0.17850520f, 0.22537896f, 0.19384031f, 0.43641269f, 0.20802753f, 
    0.20090252f, 0.02974212f, 0.22231640f, -0.21344224f, 0.25295666f, -0.40623200f, -0.42042404f, 0.05474785f, 
    -0.04357462f, -0.01777980f, 1.03988767f, 0.70246673f, 0.70133573f, 0.23220986f, 0.52047151f, 0.09402543f, 
    -0.50876176f, -0.33652720f, 0.46234471f, 0.25432706f, 0.29488063f, 0.25470230f, 0.08983512f, 0.00099775f, 
    -0.14183539f, -0.20384322f, 0.12241551f, 0.07680872f, -0.37042585f, -0.14284356f, -0.21278822f, 0.44021693f, 
    0.30842441f, -0.11427140f, -0.12240096f, 0.82158250f, 0.38620695f, -0.23110642f, -0.84236729f, -0.66249967f, 
    0.05065957f, 0.60614061f, 0.07577285f, -0.17554945f, -0.13973890f, -0.03278725f, -0.18774864f, -0.53401303f, 
    -0.02578562f, -0.04475488f, 0.00847039f, -0.04696520f, -0.08244328f, -0.17005555f, -0.14254509f, 0.04515194f, 
    -0.22314487f, 0.12426003f, -0.19296774f, -0.13339680f, -0.65570903f, 0.23605961f, -0.64964402f, 0.18820646f, 
    -0.07516718f, -0.58454150f, 0.68087071f, 0.36834171f, -0.04830594f, -0.56790918f, 0.59612781f, -0.31555334f, 
    -0.07165854f, -0.43855003f, 0.29308188f, 0.04356974f, 0.46795431f, 0.37806356f, 0.31941026f, -0.16510464f, 
    0.13250454f, -0.25421900f, -0.24533692f, -0.06340734f, 0.07211629f, 0.40568230f, 0.97410059f, 0.57352138f, 
    0.05293113f, -0.31116435f, -0.74773014f, 0.32163668f, 0.08501282f, -0.74821186f, 0.13409582f, -0.08279778f, 
    0.16958436f, 0.21319576f, 0.32152069f, 0.30395341f, -0.25295001f, 0.00019587f, 0.05106485f, -0.05522259f, 
    0.00625762f, 0.26225427f, 0.13538682f, 0.29579419f, 0.37125343f, 0.19573352f, 0.40139166f, -0.66291696f, 
    -0.84210509f, -0.32481027f, 0.26314515f, 0.56275630f, -0.03414637f, 0.28669903f, 0.49453244f, 0.65210009f, 
    -0.30129743f, 0.32514322f, 0.06954435f, 0.00506746f, 0.11347586f, -0.09218524f, 0.17150114f, 0.16571325f, 
    0.08003963f, 0.41184571f, 0.05407513f, -0.00077921f, -0.33389273f, 0.05008658f, -0.28166485f, -0.40333614f, 
    0.25578439f, 0.04013943f, -0.03284632f, -0.36440274f, 0.75688887f, 0.57097685f, 0.29674959f, 0.38503972f, 
    0.58572954f, -0.26681760f, -0.46552783f, -0.34034982f, -0.52409393f, 0.35289234f, -0.44431505f, 0.14690837f, 
    -0.49457794f, 0.12230946f, 0.03268784f, -0.41562966f, -0.12941241f, -0.32671729f, -0.33909386f, -0.36619365f, 
    0.49821731f, -0.75541043f, -0.19714051f, 0.03361991f, -0.03725749f, 0.13448286f, 0.37131098f, 0.00190286f, 
    0.51767135f, -0.40120864f, 0.03261285f, -0.07899723f, -0.02816750f, 0.15538321f, -0.01179090f, 0.14608349f, 
    -0.51326418f, 0.27779165f, -0.08015932f, -0.10758802f, 0.26424834f, 0.74944741f, -0.04432588f, 0.10923766f, 
    -0.35949084f, -0.71767992f, -0.64888567f, -0.64924455f, 0.00526121f, -0.40813592f, 0.18634643f, -0.15122986f, 
    -0.60794926f, 0.20594925f, 0.56595892f, 0.23792623f, 0.09945395f, 0.04644632f, -0.22103098f, -0.19763416f, 
    0.05558385f, 0.07612582f, 0.06046977f, 0.37913257f, -0.00248760f, -0.41849405f, 0.12470575f, -0.10980043f, 
    -0.13112561f, -0.05527325f, -0.22563969f, -0.29344794f, -0.32922950f, -0.04341826f, 0.21351369f, -0.49582815f, 
    -0.43536958f, -0.61944926f, -0.62800437f, -0.51817799f, -0.59553516f, 0.39080152f, 0.37054619f, 0.32670552f, 
    -0.22936426f, 0.29614234f, -0.17957562f, 0.02737217f, 0.01138190f, -0.48053887f, -0.01276692f, -0.02448656f, 
    0.00884679f, 0.18440898f, 0.16888498f, -0.19529593f, 0.18693221f, 0.21458708f, -0.34065452f, 0.00064241f, 
    -0.03836111f, -0.60539472f, -0.63706565f, -0.45410737f, -0.33314011f, 0.45486498f, 0.46735901f, 0.10693892f, 
    0.04798930f, -0.02045649f, -0.26272658f, 0.10394850f, 0.31241897f, 0.11007804f, 0.51595390f, 0.49480841f, 
    -0.08505492f, -0.48245883f, -0.27292404f, -0.06983608f, -0.65558702f, -0.54914302f, 0.03174992f, 0.34803087f, 
    -0.18344225f, -0.44141880f, 0.27822939f, 0.27401531f, 0.10349265f, 0.23874457f, 0.17039247f, -0.41229877f, 
    0.39663315f, -0.23295967f, 0.05599445f, -0.01812749f, 0.30316216f, 0.14609551f, 0.01666782f, 0.32322109f, 
    0.22003469f, -0.12055223f, -0.19182551f, -0.06729105f, -0.20917566f, 0.75004321f, -0.29952139f, -0.77974290f, 
    0.36238495f, -0.20447658f, -0.58417088f, -0.08413421f, -0.56773365f, 0.23869248f, 0.02608309f, -0.21810077f, 
    -0.35675350f, 0.01082802f, 0.05588872f, -0.39576638f, -0.39007583f, 0.30277801f, -0.35585818f, -0.27252942f, 
    -0.26987100f, -0.05777608f, 0.17283954f, 0.06928635f, 0.11071379f, -0.10706549f, -0.58415753f, 0.79458618f, 
    0.92011052f, -0.45249966f, 0.41963959f, 0.71022946f, -0.13674538f, -0.26617071f, 0.13793960f, -0.44167647f, 
    -0.25332946f, -0.18244915f, -0.35658306f, -0.12801339f, -0.16894129f, -0.35817519f, 0.00194886f, -0.09972627f, 
    -0.15694496f, -0.47262070f, 0.22135900f, -0.06430907f, 0.19677910f, 0.02047201f, 0.22973564f, -0.60796368f, 
    -0.84343421f, 0.14057128f, 0.79554123f, -0.60755086f, -0.53864729f, 0.21046729f, 0.66457999f, -0.52023077f, 
    0.02396509f, 0.30123937f, -0.02717554f, -0.30299348f, 0.05256021f, 0.14626837f, -0.01076075f, -0.04867760f, 
    -0.02831304f, -0.20386845f, -0.24591906f, -0.07306055f, 0.01744112f, 0.07869066f, 0.35672572f, -0.17842962f, 
    -0.40598118f, -0.54498082f, -0.71188003f, -0.40784994f, -0.38466349f, 0.51625896f, 0.82763946f, 0.30905634f, 
    0.02199193f, 0.42329887f, -0.46919459f, -0.28670195f, 0.05415892f, -0.30125308f, -0.28392586f, -0.21065836f, 
    -0.11334027f, 0.09790234f, 0.10395736f, -0.17096524f, 0.08872878f, -0.11421096f, -0.27669913f, 0.05513197f, 
    0.31873485f, -0.94274986f, 0.55872965f, -0.24008626f, -0.67042005f, -0.60338056f, 0.72890794f, -0.03374062f, 
    -0.41626200f, 0.40220308f, 0.23697513f, 0.13599327f, -0.10482459f, -0.13343325f, 0.12149848f, -0.09611338f, 
    -0.04137606f, 0.14558794f, -0.16420050f, -0.14480440f, -0.21645424f, -0.02893932f, 0.12686792f, 0.16348140f, 
    0.19706459f, 0.08339728f, -0.27962026f, -0.97569036f, -0.97943074f, -0.42592216f, -0.01303180f, -0.47743100f, 
    0.17156178f, 0.42446321f, -0.33898786f, 0.14193679f, 0.20199604f, -0.02494659f, 0.21274981f, 0.00931384f, 
    0.45865354f, 0.06228413f, -0.07400018f, 0.10313974f, -0.07646285f, -0.03032026f, -0.06851475f, -0.03677678f, 
    -0.35970038f, -0.01823402f, -0.03293194f, -0.60001934f, -0.54803395f, -0.36569938f, -0.47596681f, -0.50112319f, 
    -0.12486486f, -0.22130695f, -0.19585176f, 0.79751897f, 0.30505437f, 0.20977055f, 0.07907056f, -0.12833688f, 
    0.03878162f, -0.35480303f, 0.21750209f, 0.09446554f, -0.15276131f, 0.32492787f, 0.33743685f, 0.28916469f, 
    -0.38287231f, -0.06803019f, -0.08904428f, 0.45681074f, 1.01376832f, 0.69589323f, 0.62789440f, -0.09976544f, 
    -0.47752652f, 0.09303217f, -0.32330737f, 0.07892039f, 0.19483732f, 0.47952139f, -0.22276203f, 0.00546928f, 
    -0.10036851f, -0.12353507f, 0.13309164f, 0.10113218f, -0.22406702f, -0.17371726f, -0.01348764f, -0.11970904f, 
    -0.32123938f, 0.10464019f, -0.12358503f, -0.42407200f, 0.12091269f, -0.07157075f, 0.19924246f, -0.85355085f, 
    -0.81201655f, -0.53267711f, 0.64749497f, -0.43333444f, -0.22965826f, 0.14300960f, 0.11453835f, -0.53294218f, 
    -0.38688222f, 0.19840194f, 0.01028667f, -0.00208024f, -0.21267967f, 0.03265674f, 0.23811521f, -0.16571896f, 
    -0.03500027f, 0.13106945f, -0.00411662f, 0.12996331f, 0.26827604f, 0.23501264f, 0.70679796f, 0.57986176f, 
    -0.33613685f, 0.54039353f, -0.77982867f, -0.02956576f, -0.14286022f, -0.57904035f, 0.14150287f, 0.09242558f, 
    0.46226206f, -0.16912386f, -0.01466086f, 0.00117039f, -0.12838852f, 0.05588142f, -0.27695853f, 0.44789550f, 
    0.13740805f, 0.36118069f, 0.21063852f, -0.23792434f, 0.22014858f, 0.19434854f, -0.00615365f, -0.05481104f, 
    -0.50774503f, -0.59905046f, -0.51512134f, -0.05554994f, -0.35733524f, -0.61644757f, -0.35362414f, -0.10214049f, 
    -0.18322270f, -0.29099971f, -0.24630177f, 0.30089962f, -0.31731173f, -0.35693803f, 0.21272103f, 0.07784021f, 
    0.22506753f, -0.20165546f, -0.11881635f, 0.02370592f, 0.37009826f, 0.26516137f, -0.05771241f, 0.01699447f, 
    0.35516006f, 0.07896873f, 0.39444101f, 0.75178689f, 0.47838131f, -0.03620436f, -0.26991895f, -0.47199804f, 
    -0.49928749f, 0.26512066f, 0.37095729f, 0.28831229f, 0.13244566f, -0.12736505f, -0.34552783f, -0.28050995f, 
    -0.01875835f, -0.35117927f, 0.17804420f, -0.07036604f, 0.48686895f, -0.02546184f, 0.00820891f, -0.27426875f, 
    0.09138309f, 0.02364009f, -0.30452746f, 0.50705767f, 0.69808823f, -0.76455021f, -0.01694790f, -0.68749541f, 
    0.62018549f, -0.29439747f, 0.24121895f, 0.17422615f, -0.15912920f, 0.20981324f, 0.32839388f, 0.17163235f, 
    -0.08083633f, 0.09287497f, -0.01568580f, -0.27705249f, 0.32554883f, 0.05712516f, 0.19317687f, -0.11800784f, 
    0.07553371f, 0.17235886f, -0.41687691f, -0.78436869f, 0.21275254f, -0.16336466f, -0.58082682f, 0.41833362f, 
    0.67979735f, 0.52346557f, -0.35781312f, 0.12976119f, -0.38498199f, -0.04848222f, -0.30238923f, -0.09452084f, 
    -0.10951647f, 0.00002087f, 0.13075502f, -0.05556545f, -0.13224584f, 0.10739898f, -0.16526066f, -0.00911896f, 
    0.21817364f, -0.23218593f, 0.03280330f, -0.32115591f, -0.89455253f, -0.49972379f, -0.29142255f, 0.20691225f, 
    -0.22786531f, 0.87333220f, 0.20320064f, -0.46766809f, 0.60001761f, -0.13851014f, -0.02786870f, -0.06683094f, 
    -0.26412714f, -0.17382750f, -0.21890976f, 0.12066942f, 0.21924147f, -0.09476825f, -0.30703077f, 0.23230672f, 
    -0.36416581f, -0.02980068f, -0.04250537f, 0.04663539f, -0.58279401f, 0.77696985f, -0.12586921f, -0.75535417f, 
    0.53972971f, 0.49848685f, -0.14089036f, -0.70703691f, 0.29952353f, 0.05133031f, -0.07078321f, 0.19784325f, 
    0.03684120f, 0.44392568f, -0.03231815f, -0.49466673f, 0.20667845f, -0.36384523f, -0.32563093f, 0.13651474f, 
    -0.05374968f, -0.30462521f, 0.17676461f, -0.08187233f, -0.38998976f, -0.92888379f, -0.28277665f, -0.48710543f, 
    0.39994520f, 0.04358958f, 0.08273633f, 0.76569015f, 0.27775675f, 0.49151888f, 0.54707497f, -0.06342781f, 
    -0.50504529f, -0.13825242f, -0.10488617f, 0.15314171f, -0.12857594f, -0.24906676f, 0.06620214f, -0.07678557f, 
    -0.25637022f, 0.09123393f, 0.19177432f, -0.09724053f, 0.21799609f, -0.26515231f, -0.69987100f, -0.78209245f, 
    0.69736201f, -0.23989353f, -0.60756153f, 0.29886967f, 0.14610296f, 0.54132009f, 0.28303462f, -0.31619132f, 
    0.12135939f, -0.21459676f, -0.35179856f, 0.11885870f, 0.23602097f, 0.12454046f, -0.02105390f, -0.30447438f, 
    -0.34805357f, -0.20103145f, 0.15816486f, 0.43542454f, 0.04705985f, 0.38721043f, -0.00276524f, -0.20543015f, 
    0.22080840f, 0.71521461f, 0.04523588f, -0.45553181f, -0.74550664f, -0.18820046f, -0.26991493f, -0.04302056f, 
    -0.10759331f, 0.09203698f, 0.00692221f, 0.11597531f, -0.02834259f, 0.45374370f, 0.04100872f, -0.38397345f, 
    0.36397362f, 0.25149229f, -0.24704242f, -0.54475224f, 0.31937817f, -0.14502887f, -0.06654619f, -0.11999390f, 
    -0.78599006f, 1.07985616f, -0.50548869f, -0.41825485f, 0.07441662f, -0.31188393f, -0.24213392f, 0.17422257f, 
    0.24577948f, -0.63053840f, -0.31972179f, -0.02470273f, -0.04150287f, 0.33031338f, 0.06500768f, -0.03130846f, 
    -0.17652097f, -0.15296727f, -0.12065890f, -0.20791070f, -0.19597016f, -0.03221512f, 0.08199722f, 0.20386659f, 
    0.17705083f, -0.34719041f, 0.06667822f, -0.36413547f, -0.36347699f, 0.12566136f, -0.81821334f, -0.11378337f, 
    0.41746664f, 0.32445908f, -0.00518258f, -0.31975585f, 0.08769067f, 0.42110914f, -0.32177272f, -0.18548632f, 
    0.38302204f, -0.07986762f, -0.33426431f, -0.49703270f, -0.52371788f, -0.25090316f, -0.13630675f, 0.11402474f, 
    0.28084221f, -0.16386907f, -0.36658308f, -0.76530761f, -0.27667344f, -0.07997340f, 0.47186741f, 0.58275127f, 
    0.19740316f, -0.81148088f, -0.13374260f, -0.34764841f, 0.13079423f, 0.33744562f, -0.15838782f, 0.19539230f, 
    0.08427540f, 0.07952447f, 0.30352962f, -0.45958567f, -0.26672956f, 0.20958605f, 0.02713553f, 0.12520324f, 
    0.33477569f, 0.31312099f, -0.09422902f, 0.79251212f, 0.50654888f, -0.57657152f, -0.14427489f, -0.26036942f, 
    0.15437005f, 0.51634574f, 0.67291731f, 0.34662920f, 0.34779373f, 0.10244050f, -0.11944762f, 0.23217152f, 
    -0.08424734f, 0.24016213f, -0.20092854f, -0.20384941f, 0.01469281f, -0.22676958f, 0.17373461f, 0.09373047f, 
    -0.15547498f, 0.03761355f, 0.07366361f, 0.02384478f, 0.65514636f, 0.29039192f, 0.63604116f, 0.94093901f, 
    0.51578856f, 0.53012687f, 0.33031404f, 0.23748818f, 0.25022131f, -0.13898192f, -0.45505422f, -0.31419662f, 
    -0.48577860f, 0.24321274f, 0.32030591f, -0.09030125f, 0.11693967f, -0.15898626f, 0.38708866f, 0.17825051f, 
    -0.22050647f, 0.23710124f, -0.21446551f, -0.12484977f, -0.15144631f, 0.81131214f, -0.08520614f, 0.20574692f, 
    0.67281699f, 0.84096754f, -0.29808113f, -0.37898797f, -0.04573908f, 0.53224224f, -0.62031227f, -0.07808843f, 
    0.17629272f, 0.09362344f, -0.25490928f, -0.07946365f, 0.17574099f, 0.23628877f, 0.28421086f, -0.04457934f, 
    0.02714814f, 0.16606739f, 0.35939455f, 0.00301901f, 0.04658896f, 0.31664959f, 0.81446713f, 0.36409184f, 
    0.51828009f, 0.75336820f, 0.49255234f, -0.32390654f, 0.40680069f, 0.04641399f, -0.53405613f, 0.02017294f, 
    0.18023401f, 0.11377598f, -0.31870762f, -0.26201838f, -0.14920495f, 0.01128447f, 0.09603138f, 0.12305060f, 
    0.11111813f, 0.13655074f, 0.43435878f, 0.46864173f, 0.35099521f, 0.21397950f, 0.30674374f, 0.44692835f, 
    0.28264356f, 0.55790466f, 0.68270785f, 0.65567398f, 0.63114685f, 0.15739061f, -0.23643129f, -0.72541791f, 
    -0.38272166f, 0.20198029f, 0.15448615f, 0.19453229f, 0.15208964f, -0.17456998f, -0.07755586f, -0.07315739f, 
    0.34357271f, 0.13106643f, 0.02691391f, 0.01188527f, 0.19754836f, -0.20378168f, -0.05638326f, 0.02771106f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13231596f, 0.26479059f, -0.16798076f, 0.14320259f, 0.30909786f, 0.07387298f, -0.12392990f, 0.01048864f, 
    0.16887876f, 0.13790736f, 0.10715886f, 0.01433371f, -0.01111681f, 0.26729122f, 0.08643806f, 0.08731753f, 
    0.37205231f, 0.29200491f, 0.14899260f, 0.09233322f, -0.01050461f, 0.03892718f, 0.11300988f, -0.05152387f, 
    0.25468859f, 0.18019287f, 0.05654527f, 0.01173498f, 0.09339142f, 0.11693816f, 0.12205967f, -0.02580964f, 
    0.06395908f, 0.14972158f, 0.31428817f, 0.25230798f, 0.18483768f, 0.16320452f, 0.06299216f, 0.16734128f, 
    0.07618144f, 0.06423694f, 0.33771765f, 0.10017066f, 0.29178578f, 0.37249669f, -0.00266506f, 0.23319583f, 
    -0.02103694f, 0.06273369f, 0.08809091f, 0.19691035f, -0.00973424f, -0.01992775f, 0.11708476f, 0.19082054f, 
    0.23402396f, 0.07258072f, 0.21372996f, 0.31369945f, 0.41334286f, 0.09925597f, -0.01202181f, 0.10849489f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.25972739f, 0.09354592f, 0.04828847f, -0.11475747f, 0.04771602f, -0.06444664f, -0.10245883f, 0.03578533f, 
    0.05468144f, 0.05403895f, 0.07260282f, 0.08349048f, 0.13369718f, -0.14265224f, 0.08733709f, 0.31237710f, 
    -0.11472713f, 0.11012436f, -0.08545926f, 0.00222037f, -0.00866103f, -0.02963720f, -0.08708472f, -0.13544518f, 
    -0.05450159f, 0.19423716f, -0.06920885f, 0.12750679f, -0.02744540f, 0.13474283f, 0.09079592f, 0.03635069f, 
    -0.04554082f, 0.08838945f, -0.09447610f, -0.03548945f, -0.33053955f, -0.05631722f, -0.08542103f, 0.23786509f, 
    -0.09705820f, 0.06608338f, 0.08480498f, 0.08256445f, -0.06336068f, 0.11387889f, -0.21393320f, 0.03607129f, 
    -0.28000864f, 0.00509080f, 0.06578504f, 0.00409235f, -0.01271401f, 0.05534929f, 0.02010382f, 0.07389268f, 
    -0.01032826f, 0.12163548f, 0.02670807f, 0.00923761f, -0.39444429f, -0.14399759f, 0.02095344f, 0.11222723f, 
    -0.09767325f, 0.03697215f, -0.07789642f, -0.05757781f, 0.04887160f, 0.05200453f, 0.10286498f, -0.04012259f, 
    -0.18061578f, -0.13591126f, -0.01523735f, 0.00697014f, 0.06917568f, 0.05962019f, 0.03663735f, -0.00770067f, 
    0.02152436f, -0.06335131f, 0.10476174f, -0.08585608f, 0.24954754f, 0.11899439f, -0.02824719f, 0.03856272f, 
    -0.26907966f, 0.00578898f, -0.00511226f, 0.14621060f, 0.01156055f, -0.02894070f, -0.01227943f, -0.06598081f, 
    -0.14689876f, 0.13085775f, 0.05797342f, -0.36200342f, -0.07494484f, 0.09914858f, -0.08174944f, 0.07581895f, 
    -0.15623640f, 0.06504551f, -0.00005199f, -0.08470830f, -0.01386540f, -0.14715704f, -0.25806627f, 0.31985405f, 
    -0.05309047f, -0.05215206f, 0.05612335f, -0.13807636f, 0.03741984f, -0.00749231f, -0.05046656f, 0.02419052f, 
    0.19902901f, -0.04869913f, 0.21307744f, 0.02506653f, -0.11256939f, -0.02480077f, -0.02483991f, 0.11521966f, 
    0.04949038f, 0.03744416f, -0.04313110f, -0.08790007f, -0.05683508f, -0.05959376f, -0.01074653f, -0.03495900f, 
    -0.10428941f, 0.03220477f, 0.07091457f, -0.05594335f, 0.00419674f, 0.11061226f, 0.05525183f, -0.04329569f, 
    0.10162471f, 0.26280874f, 0.19556129f, 0.16430800f, -0.14573765f, 0.09742942f, 0.00041237f, -0.05001181f, 
    0.06979343f, 0.06064540f, 0.00047191f, -0.00192378f, -0.10729788f, 0.07130885f, -0.13465923f, 0.13101865f, 
    0.04305599f, -0.03576664f, -0.00931441f, -0.01802538f, -0.06837799f, -0.01852858f, -0.05026057f, 0.01894459f, 
    0.02029317f, 0.11464268f, -0.05358041f, 0.24695687f, -0.05307669f, -0.10532134f, -0.12467046f, -0.03953654f, 
    0.02463867f, -0.13636090f, -0.01496476f, 0.07785682f, -0.22302192f, 0.21999080f, -0.00029696f, -0.01303980f, 
    -0.02015452f, 0.02364986f, -0.00348977f, 0.06483983f, 0.02249700f, 0.08208683f, -0.09054841f, 0.01749212f, 
    -0.01543331f, -0.06622586f, -0.11287049f, 0.04817455f, -0.00649951f, -0.10785929f, 0.01798678f, 0.03458852f, 
    0.03494212f, -0.04649756f, 0.00452517f, -0.09754677f, 0.04272758f, 0.01513395f, 0.01544411f, -0.09224555f, 
    -0.03018301f, 0.08539587f, -0.01897559f, -0.03087378f, -0.16731261f, -0.02765359f, -0.02176611f, -0.05072570f, 
    -0.05756278f, -0.03016961f, 0.08097543f, 0.09894408f, -0.08276689f, -0.00715832f, 0.03517612f, 0.02665833f, 
    0.03076448f, 0.07291935f, 0.01786301f, 0.03843839f, -0.08329017f, 0.01532878f, 0.14107762f, -0.19682825f, 
    0.12677327f, -0.13823539f, 0.10911837f, -0.11257970f, 0.02151362f, -0.15767138f, 0.01129884f, 0.02444760f, 
    0.52469009f, 0.04752538f, 0.02628167f, -0.19050030f, -0.08002109f, 0.08661437f, 0.08002713f, 0.05827336f, 
    0.07265133f, -0.02266353f, -0.00919220f, 0.01807534f, -0.08617652f, 0.06045312f, 0.04798318f, -0.02776100f, 
    0.09651636f, 0.08407605f, 0.06336103f, -0.26771733f, 0.03125915f, 0.06636241f, -0.02397530f, 0.01108637f, 
    -0.12637499f, 0.08434710f, 0.04224049f, 0.15976049f, -0.07742207f, -0.03344693f, -0.03055144f, 0.02243011f, 
    -0.05337805f, 0.10903873f, -0.11365499f, -0.04150242f, 0.08493600f, -0.01711288f, -0.17614807f, -0.34115058f, 
    0.07153386f, -0.00810012f, 0.05464417f, 0.04805646f, 0.06244475f, -0.05515107f, 0.04412630f, -0.01505253f, 
    -0.28153241f, -0.14925998f, 0.08359668f, -0.18241307f, -0.01254529f, 0.04925151f, 0.06022135f, -0.01271121f, 
    0.08417071f, 0.03027656f, -0.00932870f, 0.07143369f, 0.01495725f, 0.04642980f, -0.13366804f, -0.00922814f, 
    -0.06525751f, -0.04631038f, 0.01483034f, 0.07781667f, 0.04025203f, -0.02896932f, 0.07864310f, -0.12560919f, 
    0.13829586f, 0.00668603f, -0.00862214f, -0.04796511f, -0.19379374f, -0.02087325f, 0.00581098f, 0.08444630f, 
    0.04911492f, 0.03846028f, -0.04541684f, -0.01194969f, -0.15700693f, 0.15956293f, 0.04059720f, -0.35092303f, 
    -0.20554112f, 0.01760857f, -0.15463360f, -0.06220374f, -0.11128693f, 0.05354535f, 0.00388222f, -0.02965835f, 
    -0.14402522f, 0.25339228f, 0.06781593f, 0.00213607f, -0.04661361f, -0.06717966f, -0.01242586f, 0.02745623f, 
    -0.01213153f, 0.00302619f, -0.02279507f, 0.02312585f, 0.00357962f, 0.11266667f, -0.09929434f, -0.09843222f, 
    -0.04443960f, 0.00756869f, -0.04345942f, -0.07882932f, -0.10936011f, -0.12839124f, -0.03666915f, 0.04258694f, 
    0.26685861f, -0.11702510f, -0.08589980f, -0.20572424f, 0.03646695f, 0.04499755f, 0.01251169f, -0.04681893f, 
    -0.08006705f, 0.02361658f, 0.04906667f, 0.05645247f, 0.29365218f, 0.01833083f, 0.12907790f, 0.10939077f, 
    0.00138006f, 0.07565729f, 0.03709712f, -0.06425896f, -0.02672634f, -0.01009468f, 0.00418825f, 0.11021268f, 
    -0.11273475f, 0.13248257f, -0.09322913f, -0.03258207f, 0.04785129f, -0.03033926f, 0.00129504f, -0.11642974f, 
    0.04973218f, -0.12607262f, -0.04781078f, -0.15353432f, 0.21357892f, -0.05328776f, -0.15820657f, -0.06582078f, 
    -0.04530461f, -0.05252784f, 0.09467043f, -0.02546090f, 0.07130635f, 0.05365926f, -0.08121058f, -0.06349231f, 
    -0.25663236f, -0.16891846f, 0.12664497f, 0.10863452f, 0.06062651f, 0.02684345f, 0.06680140f, 0.03104002f, 
    -0.05933503f, 0.05205285f, -0.06627812f, -0.00948303f, -0.28042427f, -0.13799390f, 0.12947591f, -0.05522906f, 
    -0.06423219f, 0.00592734f, 0.06437986f, -0.11119272f, 0.01974504f, -0.05880490f, 0.08597556f, -0.04435436f, 
    0.00917881f, 0.10198668f, -0.08265745f, 0.06599036f, 0.00399292f, 0.08848740f, -0.10774569f, 0.01967452f, 
    0.06240639f, -0.16984707f, -0.06624637f, 0.07513360f, -0.12792306f, -0.20872703f, 0.11173272f, 0.22263153f, 
    -0.01537420f, 0.07639125f, -0.07952949f, -0.03492264f, -0.09301145f, -0.03015184f, 0.06282710f, 0.00569859f, 
    -0.24006009f, 0.03753103f, 0.19538265f, -0.02906123f, -0.03054443f, -0.06458420f, 0.03484435f, -0.11604246f, 
    0.02987415f, -0.11966890f, 0.03856424f, 0.05503738f, -0.24237725f, -0.04283314f, -0.13829987f, 0.16401008f, 
    -0.02179514f, 0.05088162f, -0.05717712f, 0.03102550f, 0.08460856f, -0.01772935f, 0.00993059f, 0.03389227f, 
    0.13762900f, 0.18768123f, 0.05951868f, -0.28427994f, 0.12297121f, 0.00851304f, 0.02837629f, 0.11233226f, 
    0.03667148f, 0.01544186f, -0.07478459f, 0.08012273f, 0.48500934f, -0.09727291f, -0.12213326f, -0.18954520f, 
    -0.03375636f, 0.00120378f, 0.05627259f, 0.00040475f, -0.04698652f, -0.01367281f, -0.00604284f, -0.00826406f, 
    -0.35461918f, 0.03981654f, -0.12003632f, -0.07119376f, 0.00910399f, -0.08092610f, -0.05287172f, -0.04096339f, 
    -0.00907992f, -0.03506370f, -0.07640926f, 0.05187155f, 0.02934076f, 0.06016028f, -0.35345981f, -0.17460243f, 
    0.04057100f, 0.05925991f, 0.05852857f, 0.05635943f, 0.05776859f, -0.02407597f, -0.01506235f, -0.07161114f, 
    0.08860934f, -0.02781821f, -0.07100248f, -0.04314382f, -0.06638887f, -0.14514178f, 0.00087414f, 0.08490240f, 
    -0.00498771f, 0.02225881f, -0.10101262f, -0.01670719f, 0.20433375f, -0.16733350f, -0.04112616f, -0.17183502f, 
    0.00969042f, 0.02841389f, 0.08001710f, 0.05093096f, -0.07943638f, 0.00051562f, -0.05074048f, 0.04430976f, 
    0.11669204f, 0.03990109f, -0.13339172f, 0.20733011f, -0.07645395f, 0.03572986f, -0.09095536f, 0.02583205f, 
    -0.00273877f, 0.05654757f, 0.02402796f, -0.09104244f, -0.20699470f, -0.24857628f, 0.13323626f, -0.00368930f, 
    0.03056408f, 0.01049782f, 0.04814310f, 0.04178065f, -0.06037388f, 0.04999899f, -0.02768211f, -0.04655283f, 
    0.09854822f, 0.02948679f, 0.00700029f, 0.06387305f, -0.07841456f, 0.00665939f, 0.02118961f, -0.01468229f, 
    -0.00286893f, -0.01348581f, -0.06114246f, -0.00085552f, -0.07283968f, -0.03149157f, -0.08044080f, 0.21602783f, 
    -0.03306919f, -0.02870695f, 0.05154262f, -0.03771006f, -0.07653059f, 0.00245347f, -0.00039114f, 0.11858695f, 
    -0.06645791f, 0.21274710f, 0.21964070f, -0.08523871f, 0.09642683f, 0.06240437f, -0.04987017f, 0.04106945f, 
    0.07791686f, 0.04069621f, 0.04876295f, -0.00414989f, -0.21578620f, 0.09396237f, 0.05422167f, -0.22186112f, 
    -0.01519543f, -0.00184982f, -0.10529061f, 0.03156472f, -0.04138630f, 0.10428058f, -0.04794220f, 0.01691359f, 
    -0.08105699f, -0.08827069f, 0.06293622f, -0.32820600f, -0.02825858f, 0.01334070f, 0.06648770f, -0.04590685f, 
    -0.04889012f, -0.09480958f, 0.02932195f, -0.00060701f, 0.18070328f, 0.26408020f, 0.05960582f, 0.02429236f, 
    0.08676577f, 0.15616809f, 0.03959911f, -0.08093201f, -0.07013923f, -0.12823480f, -0.03334884f, -0.00798730f, 
    -0.12431064f, 0.01346735f, 0.16288659f, 0.13702987f, 0.00864397f, 0.14281248f, 0.03705022f, -0.00153160f, 
    0.08515466f, 0.08333396f, -0.12628245f, -0.04095244f, -0.18596782f, 0.15673786f, -0.12406095f, 0.13255973f, 
    0.01127159f, -0.00038400f, -0.01948278f, 0.00827650f, -0.09529104f, 0.12308758f, -0.04233173f, -0.12013136f, 
    -0.02141937f, 0.14002779f, -0.00593724f, -0.14789511f, 0.01147048f, -0.15244117f, 0.02043238f, -0.03774226f, 
    -0.03700457f, -0.00003952f, -0.05189430f, -0.02341289f, -0.13383009f, 0.04155286f, -0.01921955f, -0.00949343f, 
    -0.04728152f, -0.07624792f, -0.04614648f, 0.01868545f, 0.03306621f, 0.01713524f, 0.15700293f, -0.13891913f, 
    -0.51324767f, -0.17280082f, 0.07238939f, 0.01656984f, 0.04909220f, 0.05216889f, 0.01580474f, 0.01022762f, 
    -0.09777807f, -0.02443109f, 0.15650262f, -0.10944822f, -0.12615788f, -0.02973019f, -0.08379214f, -0.21544696f, 
    0.02493917f, 0.01071929f, -0.02627243f, 0.01573153f, -0.04857512f, 0.00600643f, -0.02006063f, 0.08029916f, 
    0.10418133f, -0.06495123f, -0.02166085f, 0.19291180f, -0.20965619f, -0.06623483f, 0.03981841f, -0.01084915f, 
    -0.03955340f, -0.02986182f, -0.02672007f, -0.11451769f, 0.16678175f, -0.00042252f, -0.07204214f, 0.08059928f, 
    -0.04739725f, 0.03304935f, 0.00523206f, -0.03078391f, 0.00605545f, -0.02322424f, -0.01326456f, -0.05423270f, 
    0.20671664f, 0.10708361f, -0.01045701f, 0.17192630f, -0.12118862f, -0.00902071f, -0.04352625f, 0.05233816f, 
    0.02417609f, -0.09266774f, -0.06683944f, -0.00056898f, 0.02267703f, -0.00116372f, -0.11334004f, 0.00257116f, 
    -0.16176799f, -0.03322999f, 0.08390456f, 0.05940742f, 0.00329719f, 0.01136361f, -0.02751883f, 0.02336236f, 
    0.35973486f, -0.31266797f, -0.07209497f, -0.11959244f, 0.08374240f, 0.03354435f, -0.04179705f, -0.02490847f, 
    -0.01790221f, -0.07314216f, -0.04352159f, 0.06278415f, -0.01492344f, -0.10349661f, -0.10955270f, -0.00028898f, 
    0.00153665f, -0.08063434f, -0.09405778f, -0.09764420f, -0.06441001f, 0.03531996f, 0.07354269f, 0.18046014f, 
    0.28765982f, -0.03009413f, 0.01401576f, 0.12804507f, -0.07442862f, 0.03228159f, -0.02234904f, 0.05568293f, 
    -0.08185368f, -0.01865268f, 0.11388265f, 0.05684155f, -0.31063399f, 0.02457475f, -0.09438699f, -0.10833858f, 
    0.00203889f, -0.02757152f, -0.08680050f, 0.02282565f, 0.05384208f, 0.00868304f, 0.05202594f, -0.09544044f, 
    -0.09995555f, 0.00378465f, -0.08763610f, 0.07905772f, 0.03635325f, 0.07696084f, 0.05923218f, 0.03515266f, 
    0.12965804f, 0.09328654f, 0.05290475f, 0.05576601f, 0.15756077f, -0.03544365f, -0.10599156f, 0.04194283f, 
    -0.04482476f, -0.01877990f, -0.11952335f, 0.02897867f, -0.17387521f, -0.04617744f, 0.04123021f, -0.08968107f, 
    0.11229970f, 0.18560757f, 0.13845038f, 0.00884433f, -0.17022483f, 0.11190984f, -0.08958348f, -0.09722257f, 
    -0.00561965f, -0.14777841f, -0.14460036f, 0.02227361f, 0.23474057f, -0.12016725f, -0.00516891f, 0.17197233f, 
    -0.06783348f, -0.00491124f, 0.02915974f, -0.01405883f, -0.02681094f, 0.01740537f, -0.05312742f, 0.11154052f, 
    0.10915527f, -0.03924752f, 0.03081417f, -0.32431036f, -0.00001182f, -0.16627541f, -0.01449098f, -0.01172669f, 
    0.04815303f, -0.08670017f, -0.02111379f, -0.03388736f, -0.14347033f, -0.04227258f, -0.00566429f, 0.15994406f, 
    -0.11407181f, -0.00036556f, -0.05722667f, 0.01204543f, -0.05292870f, -0.13239738f, 0.05310890f, 0.02113936f, 
    -0.10202415f, -0.12745178f, -0.01586023f, -0.14379600f, 0.04675211f, -0.04596161f, 0.03226126f, -0.05994695f, 
    0.10550759f, 0.11199433f, -0.01254014f, 0.03739983f, 0.00591890f, -0.04085760f, 0.07473812f, -0.06156784f, 
    -0.05993392f, 0.07546004f, -0.11901101f, 0.12648353f, 0.00894254f, -0.17687404f, -0.12619947f, -0.04938697f, 
    -0.28994483f, -0.05121997f, -0.00886224f, 0.04756781f, -0.09655067f, -0.02650893f, 0.01614004f, -0.10020400f, 
    -0.02072893f, -0.07786104f, 0.05440309f, 0.00249052f, 0.13222760f, 0.00081901f, -0.26372820f, 0.10238812f, 
    0.15379049f, 0.08996439f, -0.04353247f, 0.07634700f, -0.00308393f, -0.05133554f, 0.03584551f, -0.13595740f, 
    -0.13534191f, 0.06573237f, -0.31961051f, -0.16063938f, -0.01737699f, -0.14387342f, 0.04698787f, -0.02302107f, 
    -0.04910662f, 0.02942279f, -0.00244729f, -0.04449087f, 0.26491377f, 0.04321221f, -0.13246679f, -0.14484987f, 
    0.06013443f, -0.00527978f, -0.00541139f, -0.03262040f, -0.01140616f, -0.04973279f, 0.05721138f, 0.05433228f, 
    0.21137790f, 0.09777990f, 0.14799535f, 0.12608437f, -0.05987430f, 0.02344621f, 0.01818255f, -0.00913270f, 
    0.04335500f, -0.06784251f, -0.06028413f, 0.05176333f, -0.07417456f, -0.08887883f, -0.06398913f, -0.07881752f, 
    0.01541503f, 0.01517366f, -0.03455168f, -0.04974977f, -0.10926458f, 0.17570679f, 0.04240030f, 0.06210707f, 
    0.23169725f, 0.00480610f, -0.05576794f, -0.04501542f, -0.02645117f, 0.04032169f, 0.01980335f, 0.02657549f, 
    0.07017124f, -0.00620541f, -0.11910042f, 0.04170883f, -0.13747057f, 0.24040087f, -0.07128453f, -0.11648751f, 
    -0.17772464f, 0.04705521f, -0.02150063f, -0.04918838f, 0.02335808f, 0.05952579f, 0.09788560f, -0.07279251f, 
    -0.54897135f, -0.15410815f, 0.07746292f, -0.12741299f, -0.12293724f, -0.02343686f, 0.03855295f, -0.11892353f, 
    -0.04313708f, -0.00100023f, -0.04418663f, -0.01998734f, -0.20482342f, -0.00557647f, -0.05435770f, -0.23771486f, 
    -0.00301970f, -0.15258743f, -0.05223347f, 0.01241919f, 0.05051088f, -0.02052379f, 0.00973182f, 0.00987068f, 
    0.16511439f, 0.07366884f, 0.04167904f, 0.12425096f, -0.06546757f, 0.10396137f, -0.04361467f, -0.00812079f, 
    0.02212052f, -0.05476135f, 0.15322149f, -0.03246358f, -0.05386585f, 0.00010996f, 0.10628626f, -0.04927297f, 
    -0.08610366f, -0.07048252f, 0.04385592f, 0.07984716f, 0.01376402f, 0.02650675f, 0.00242117f, -0.02940127f, 
    0.17560521f, -0.29507408f, -0.02912484f, -0.02891471f, 0.02741322f, -0.07405712f, -0.16421376f, 0.04723833f, 
    -0.22681169f, -0.01150870f, -0.02167198f, -0.12285264f, -0.09242724f, 0.11599829f, 0.05465824f, -0.00960544f, 
    0.04699562f, 0.07377886f, 0.03082708f, -0.03856307f, 0.06631918f, -0.00125368f, 0.00091500f, 0.10502161f, 
    0.13670097f, -0.01372253f, 0.10761862f, 0.20552941f, -0.07120398f, -0.12814739f, 0.04955814f, -0.00136477f, 
    0.00002483f, -0.12354799f, 0.12445531f, -0.00970279f, 0.32625499f, -0.04166624f, 0.02383175f, -0.10588039f, 
    0.00741646f, -0.03438597f, 0.01710703f, -0.00868311f, -0.14170277f, -0.06620756f, -0.09221987f, 0.05151258f, 
    0.21107297f, 0.06384679f, -0.14813031f, -0.00856719f, 0.08353836f, 0.15557301f, -0.09358056f, 0.07206801f, 
    0.03715366f, -0.09873205f, -0.00904086f, -0.05148252f, 0.03511521f, 0.14942756f, -0.11476321f, 0.03538365f, 
    -0.00621869f, 0.04874203f, -0.00935072f, 0.08556619f, 0.15749216f, 0.06217585f, 0.08861663f, 0.09806480f, 
    0.21795970f, -0.19817294f, 0.05632247f, -0.18183525f, 0.12056964f, 0.02010556f, -0.01471179f, 0.02943676f, 
    0.04817834f, -0.01842131f, 0.01541750f, 0.08205613f, -0.12720445f, -0.00885778f, 0.00411647f, -0.01483657f, 
    0.05206773f, -0.05715280f, -0.01962860f, -0.09320682f, 0.00977330f, 0.02505519f, -0.09058473f, -0.01345624f, 
    0.19489364f, -0.37323239f, -0.05318275f, 0.10545382f, 0.03385410f, 0.13677469f, -0.01025296f, -0.01719790f, 
    0.00153269f, 0.11718656f, -0.13334751f, 0.10190344f, -0.01846340f, 0.07299411f, -0.01693446f, 0.03516360f, 
    0.12930711f, -0.07054901f, 0.11565170f, -0.01241686f, 0.00068763f, -0.09429426f, 0.02331971f, 0.09490427f, 
    -0.07993825f, -0.09332734f, -0.03538877f, -0.24278566f, -0.03171375f, 0.01911785f, 0.02170113f, 0.05748009f, 
    0.08045156f, -0.04842395f, -0.09411392f, 0.04111863f, -0.23124099f, -0.10687487f, -0.07635106f, 0.00852571f, 
    -0.01611836f, 0.08528278f, -0.16218665f, 0.05854171f, 0.06564669f, 0.02605906f, 0.11011855f, -0.04588961f, 
    0.09665512f, 0.10292869f, -0.04405164f, 0.08163324f, 0.19584720f, -0.08549030f, -0.05143385f, -0.01029637f, 
    0.02533498f, 0.05742376f, 0.03760609f, -0.00221090f, 0.25463742f, -0.22330776f, -0.28187186f, -0.22209965f, 
    0.10007744f, -0.03496509f, 0.11213636f, 0.08211652f, -0.00480222f, -0.04045585f, -0.00853436f, -0.09722833f, 
    -0.04687969f, 0.02828499f, -0.11173189f, -0.01618959f, -0.01840915f, 0.04814645f, 0.07637359f, 0.02787984f, 
    -0.02122316f, 0.00893927f, -0.05777911f, -0.10786335f, -0.20415363f, -0.05155335f, -0.13997407f, 0.31304920f, 
    -0.09751996f, -0.00696425f, -0.04213189f, 0.04664135f, -0.00079144f, -0.05535926f, -0.04428314f, 0.14044438f, 
    0.04354280f, -0.06616712f, -0.03927388f, -0.10760199f, 0.08818283f, -0.07514580f, -0.05667681f, -0.07340465f, 
    0.00284344f, 0.00909584f, -0.02155763f, -0.01650196f, -0.51738238f, -0.06858062f, 0.01950477f, -0.21047723f, 
    0.08577506f, -0.06097272f, -0.03207132f, 0.06202889f, 0.09402765f, 0.00984271f, -0.03382864f, -0.11649434f, 
    0.28477800f, -0.04897469f, 0.03666931f, 0.04105797f, -0.04003961f, 0.04942950f, 0.11761311f, 0.08081380f, 
    -0.06576776f, 0.00044889f, 0.06384854f, 0.02457927f, -0.11932921f, -0.03252304f, 0.06171205f, 0.01996500f, 
    -0.06037414f, 0.04248273f, -0.00756293f, 0.20368960f, 0.00736205f, 0.03788625f, 0.03253751f, 0.13973071f, 
    0.26254311f, 0.06626393f, 0.03753981f, -0.01808583f, 0.01431591f, -0.11694957f, -0.02897858f, 0.02220608f, 
    0.03431331f, -0.12895945f, -0.01593923f, -0.00609541f, -0.14812218f, -0.11402246f, 0.05631889f, -0.28433323f, 
    -0.01661121f, -0.04165529f, 0.12961707f, 0.04241198f, 0.07527993f, -0.03304360f, 0.01122436f, -0.02619578f, 
    0.19898428f, -0.18683639f, -0.22740616f, -0.07643270f, -0.08973272f, -0.01882131f, 0.10730477f, 0.10755837f, 
    -0.00773819f, 0.05440076f, -0.00390318f, 0.15567192f, -0.05438109f, 0.02555459f, 0.04108425f, -0.26483169f, 
    -0.00691942f, -0.05771117f, 0.02891966f, 0.03509016f, -0.02909077f, -0.11989991f, 0.05911782f, 0.04710393f, 
    0.06495333f, -0.01185659f, 0.13167563f, 0.12083712f, 0.03101531f, 0.03989005f, -0.04176731f, -0.00825554f, 
    -0.10079919f, 0.05984937f, -0.01371189f, -0.02845512f, -0.48759916f, 0.19756833f, 0.01775542f, 0.18428078f, 
    -0.04980920f, 0.01350116f, -0.08130459f, -0.00938309f, 0.09898061f, 0.00590603f, 0.12856196f, -0.05814099f, 
    -0.12984782f, -0.07505984f, -0.22106172f, 0.02120387f, 0.01029872f, 0.00485029f, 0.00584328f, -0.06789934f, 
    0.00668985f, 0.07035305f, -0.08577731f, -0.01737710f, 0.27135316f, -0.06236552f, -0.01657554f, -0.14336959f, 
    0.05011539f, -0.07178836f, -0.03021605f, 0.08529260f, 0.10835330f, -0.03863104f, 0.07919931f, -0.02109643f, 
    -0.29057026f, -0.00445203f, 0.09851243f, -0.16922201f, -0.09373118f, -0.07040291f, -0.01894987f, -0.09829662f, 
    -0.03579772f, 0.06006864f, 0.04107507f, -0.10587775f, 0.11129040f, 0.02379651f, -0.17181498f, 0.00619943f, 
    0.11854816f, -0.01187783f, -0.11681458f, 0.06048703f, 0.08527564f, 0.10578182f, -0.06129638f, 0.00537311f, 
    -0.32665962f, 0.09368688f, -0.11852121f, 0.04311939f, 0.01658625f, -0.09194507f, 0.00327624f, -0.01381156f, 
    0.01910590f, 0.03950780f, -0.13054027f, 0.03347286f, -0.15368608f, -0.05016633f, -0.13915822f, -0.05643508f, 
    -0.05983331f, -0.04020009f, -0.00046203f, -0.03337694f, 0.03231829f, -0.03025896f, -0.01778482f, 0.21661003f, 
    -0.38548747f, 0.00188162f, -0.07482311f, -0.29882669f, 0.05120063f, 0.01757446f, 0.06199922f, 0.07637792f, 
    0.06697717f, 0.06468676f, -0.03365781f, -0.04477682f, 0.02657359f, 0.09498149f, -0.04137494f, -0.22825272f, 
    0.03888448f, -0.00919728f, -0.07810855f, 0.11452778f, -0.11806893f, -0.20450041f, -0.18382825f, 0.03104425f, 
    0.14107081f, -0.05553834f, -0.12579316f, -0.07570492f, 0.03968652f, 0.01748303f, 0.00007281f, -0.09933571f, 
    0.05589379f, -0.07548982f, -0.07929487f, 0.10209980f, 0.35775456f, -0.11165359f, 0.10773140f, -0.00814583f, 
    -0.05239149f, 0.00558279f, -0.05189373f, 0.03390233f, -0.00970564f, -0.05856092f, 0.00158850f, 0.06612439f, 
    0.19517906f, 0.06959900f, 0.05427503f, 0.15718731f, -0.09889686f, -0.04913271f, -0.01757187f, -0.01253362f, 
    -0.01068366f, 0.11774015f, -0.03513457f, 0.03024417f, 0.02471800f, -0.14994523f, 0.02974771f, 0.37350211f, 
    -0.06064044f, 0.07602949f, -0.02932021f, -0.06470367f, 0.01093641f, 0.04270373f, 0.01151311f, 0.04107013f, 
    0.03450223f, 0.05643286f, 0.03382900f, 0.29827124f, -0.13904952f, 0.07601093f, 0.05855129f, 0.05826284f, 
    0.04512822f, 0.11039475f, 0.04123762f, 0.03977617f, 0.14310431f, 0.04455567f, 0.14205624f, 0.10573659f, 
    -0.10827120f, 0.00204225f, 0.03099190f, -0.00744635f, 0.02166671f, 0.08996217f, 0.04510109f, -0.05323559f, 
    -0.09202640f, -0.10230517f, -0.17460498f, 0.01272898f, -0.02016360f, -0.11567666f, 0.01837890f, 0.13260187f, 
    -0.04500652f, -0.02066330f, 0.03601420f, -0.07940194f, -0.01301495f, -0.20442499f, 0.09856077f, -0.05559262f, 
    -0.03063077f, 0.06541501f, -0.09137234f, -0.03724695f, -0.04293493f, -0.16951258f, -0.01704093f, -0.05562343f, 
    0.17009056f, -0.08378001f, 0.06938446f, 0.03499865f, -0.11582716f, 0.01033361f, -0.01921894f, 0.02386397f, 
    -0.02338124f, 0.00851456f, -0.02679490f, 0.01599474f, 0.35259637f, -0.14951625f, -0.14268346f, 0.10948931f, 
    -0.17297979f, -0.06126948f, 0.07943522f, 0.03490279f, -0.03334091f, 0.05011103f, -0.13090743f, 0.02331282f, 
    -0.30328119f, -0.10758169f, -0.14747924f, -0.26963076f, 0.01804331f, -0.04876003f, -0.04047694f, -0.05717467f, 
    0.02224648f, -0.08873033f, -0.01982971f, 0.00793990f, 0.43403077f, -0.01627984f, -0.06626437f, 0.04465446f, 
    -0.04820335f, -0.01326006f, 0.03662213f, -0.01756220f, 0.02023232f, -0.05624039f, 0.00996418f, -0.05334950f, 
    0.15387961f, 0.03078707f, 0.02813975f, -0.01126669f, -0.06346508f, 0.00567228f, -0.03214246f, -0.09185523f, 
    -0.04074603f, -0.10189435f, 0.08513373f, -0.07299267f, -0.03073130f, 0.08905666f, -0.07241508f, -0.07059415f, 
    0.06261597f, -0.03124248f, 0.07243549f, 0.05398235f, 0.02132119f, 0.03850309f, 0.02769638f, -0.06341806f, 
    0.01357222f, -0.00645268f, -0.06230370f, -0.22932388f, -0.04267735f, -0.04340577f, 0.04738413f, -0.02620394f, 
    -0.09328521f, -0.04865700f, 0.05822664f, -0.04760828f, 0.39737347f, -0.06016003f, -0.00270814f, 0.02311656f, 
    -0.07548629f, 0.08987262f, -0.06630760f, 0.02777846f, 0.01781798f, 0.08650875f, 0.04419195f, -0.12051948f, 
    -0.17133711f, 0.07788419f, -0.10395674f, -0.13956769f, -0.00111517f, 0.00729493f, 0.12446900f, -0.09238669f, 
    -0.02042215f, -0.01743362f, 0.05819785f, -0.16425459f, 0.00321509f, -0.01664341f, 0.05563100f, -0.11769171f, 
    -0.05827411f, 0.00572655f, -0.03253035f, -0.01126189f, 0.01656128f, 0.04151678f, 0.07863371f, -0.02922024f, 
    0.31842023f, -0.08844452f, 0.03337713f, -0.15123630f, -0.07524734f, 0.01793681f, 0.01998539f, 0.11500989f, 
    -0.01574034f, 0.06958442f, -0.02213446f, -0.07029063f, 0.08160055f, -0.25981584f, -0.01602998f, -0.03784511f, 
    0.02387316f, 0.02563035f, -0.17793827f, -0.03535679f, 0.01290157f, 0.04805630f, -0.09396507f, 0.00536234f, 
    -0.35750723f, 0.05106594f, -0.09959723f, -0.16647674f, -0.06871796f, 0.07136258f, 0.02937994f, 0.04350411f, 
    -0.01497099f, 0.01564412f, -0.04733109f, 0.04873607f, 0.24005012f, -0.26342669f, 0.06874444f, 0.00808913f, 
    0.00415677f, 0.01379339f, -0.11160263f, -0.09028154f, -0.02644680f, -0.04953514f, 0.05164906f, 0.02390017f, 
    -0.02726752f, -0.04086298f, -0.03550296f, 0.04320385f, 0.02464238f, 0.07006342f, -0.02205813f, -0.02141843f, 
    -0.02805423f, 0.03281769f, 0.02442862f, -0.03404117f, 0.01330087f, -0.04295736f, 0.08976135f, -0.15274327f, 
    -0.08316506f, 0.02633813f, 0.01962509f, -0.03503135f, -0.07888586f, -0.08121709f, 0.02036516f, -0.16160779f, 
    0.21781145f, -0.14759493f, 0.06698794f, -0.04465389f, 0.04228240f, 0.04078313f, 0.09832811f, -0.02859358f, 
    0.01466370f, -0.09522814f, 0.03905781f, -0.04441865f, 0.25479588f, 0.02462728f, -0.08105949f, -0.07044376f, 
    -0.03190387f, 0.04748939f, -0.01282210f, 0.07456505f, -0.02365955f, -0.02725450f, 0.07171723f, 0.06803995f, 
    0.22143088f, 0.15731139f, 0.01952394f, -0.16927040f, 0.08894512f, -0.00283874f, 0.02032585f, 0.11414958f, 
    -0.02676634f, -0.02312795f, 0.03974017f, -0.02916347f, -0.35845417f, 0.02342232f, -0.07573114f, 0.05111401f, 
    -0.02886784f, -0.01623269f, 0.03401162f, 0.09255788f, -0.01571427f, 0.07409887f, -0.02205698f, -0.00150666f, 
    0.00836108f, -0.14202444f, 0.09342615f, -0.04140043f, 0.02162531f, -0.06290910f, 0.05087906f, 0.06028832f, 
    -0.00181008f, 0.03448291f, -0.00844987f, 0.00110886f, -0.08236205f, 0.10720579f, -0.11173195f, 0.25055027f, 
    -0.06495011f, -0.05473787f, 0.01456533f, 0.03066743f, -0.00993541f, 0.01054199f, -0.02049402f, -0.02712355f, 
    -0.01254624f, -0.11376908f, 0.10278410f, 0.03141245f, -0.08810879f, -0.07965548f, -0.02171885f, 0.03102131f, 
    -0.03409652f, -0.12012448f, -0.04508239f, -0.03085791f, 0.12447604f, 0.05169892f, -0.19714648f, 0.06908227f, 
    0.13811886f, 0.06486086f, -0.02008351f, -0.07033110f, -0.04521941f, -0.02877581f, -0.11852463f, -0.05359329f, 
    -0.00635362f, 0.16957991f, 0.00857989f, 0.04118553f, 0.08557922f, 0.05830740f, 0.00343982f, -0.06421161f, 
    0.02375485f, 0.11435511f, -0.04425783f, 0.01429595f, -0.11867674f, -0.00450120f, -0.04804872f, -0.13368911f, 
    -0.02406348f, -0.02692017f, 0.12736373f, -0.01562929f, 0.06130118f, 0.03367119f, 0.06910807f, -0.00460273f, 
    0.19246945f, 0.02772689f, -0.16103980f, -0.02028805f, 0.07137634f, -0.01562052f, -0.07238079f, 0.01455766f, 
    -0.12273476f, 0.00908820f, 0.08143831f, 0.02347617f, -0.02059136f, 0.14133891f, -0.28057611f, -0.20281614f, 
    -0.04387482f, 0.13920166f, 0.04532608f, -0.01589404f, -0.04545429f, 0.00049081f, -0.05637045f, 0.00588323f, 
    -0.00236343f, 0.08982387f, 0.07912791f, 0.15374219f, -0.09135539f, -0.00298452f, 0.06213079f, 0.06230792f, 
    -0.06812580f, -0.11683844f, -0.13713649f, 0.01887688f, 0.17686297f, 0.10874498f, 0.03998139f, -0.04911161f, 
    -0.00520064f, -0.00003877f, 0.09692841f, 0.11108981f, -0.09403285f, 0.03298895f, -0.02336395f, 0.06674733f, 
    -0.13145238f, 0.00724902f, -0.06533997f, 0.02395817f, -0.11432554f, -0.01680051f, 0.06712805f, 0.03117664f, 
    -0.00545203f, -0.05754536f, 0.01638243f, 0.00784516f, 0.10142018f, -0.19221099f, 0.08558038f, -0.05858931f, 
    0.01972384f, -0.11304843f, 0.06460380f, 0.06633402f, -0.04443466f, 0.05852010f, -0.06829983f, -0.00883066f, 
    -0.08338115f, -0.02022072f, -0.08701006f, -0.24367318f, 0.00504833f, -0.03363099f, -0.12623461f, 0.01690719f, 
    -0.06258910f, 0.09215979f, -0.07911447f, -0.07405852f, -0.15757962f, -0.07809824f, 0.05384223f, 0.00476298f, 
    -0.01854525f, -0.13580711f, 0.03534988f, 0.05619882f, 0.01506322f, -0.07269984f, -0.13911952f, -0.07447817f, 
    0.14673269f, -0.11469430f, 0.01677435f, 0.01945875f, -0.10517425f, 0.03660519f, 0.06712285f, 0.03226170f, 
    -0.00127347f, -0.03401052f, 0.02232550f, -0.06503730f, -0.16643323f, -0.22372371f, -0.09794948f, -0.12113488f, 
    -0.00327130f, -0.12072045f, 0.00762146f, -0.04708154f, -0.06795866f, 0.10124657f, -0.05876867f, -0.04264594f, 
    0.15176262f, -0.15025359f, -0.07226666f, -0.01803431f, -0.03960980f, 0.03768371f, 0.05467916f, -0.05404044f, 
    0.03174052f, 0.09478186f, -0.09767029f, 0.07600677f, 0.41762799f, -0.10026164f, -0.07324173f, -0.06253216f, 
    -0.10792986f, 0.03557457f, -0.05114609f, 0.00671894f, 0.04401144f, 0.00094177f, 0.08004062f, -0.13150740f, 
    0.22810003f, 0.09737808f, 0.17547506f, 0.30728695f, -0.05004007f, -0.20715061f, 0.06314620f, 0.03115861f, 
    0.02168016f, 0.05304856f, 0.02875401f, 0.04253594f, 0.20350261f, 0.08032203f, 0.02945487f, -0.04437789f, 
    0.04736058f, 0.00877291f, -0.01495417f, -0.06444660f, -0.08984315f, 0.02350615f, -0.01234879f, -0.03117266f, 
    0.36085671f, 0.01953417f, -0.05631429f, 0.19579820f, -0.09530389f, -0.10052412f, 0.01246480f, 0.05012356f, 
    0.01314289f, 0.02780822f, -0.03585876f, -0.03253613f, 0.03856747f, -0.01093885f, 0.06564227f, 0.12590574f, 
    -0.10893745f, -0.04216058f, -0.08424664f, 0.02487685f, -0.04575766f, -0.00048625f, 0.03107163f, -0.05626848f, 
    -0.16336675f, -0.02136006f, 0.03240471f, -0.16850998f, -0.04283821f, 0.05307194f, 0.03948408f, -0.02238004f, 
    -0.01001788f, 0.03777633f, 0.04203930f, -0.03036682f, -0.14584117f, 0.02099568f, -0.00565790f, 0.12119222f, 
    -0.02631690f, -0.07845467f, -0.07710245f, -0.01421441f, -0.06412966f, -0.03214221f, -0.04892702f, 0.04917951f, 
    0.09789321f, -0.18815856f, 0.07363887f, -0.05992303f, -0.05518876f, 0.00459065f, -0.02769376f, -0.00501676f, 
    -0.14971662f, -0.02855358f, 0.02143722f, -0.00186996f, -0.25060150f, -0.34123832f, -0.15546879f, -0.03763294f, 
    -0.04842792f, -0.06977529f, -0.00889446f, -0.07834233f, 0.03270021f, 0.05075289f, -0.06531704f, 0.03288736f, 
    -0.01622479f, 0.06858700f, -0.02388622f, 0.10349020f, 0.06687168f, 0.02356750f, -0.00675451f, -0.12284213f, 
    -0.01108814f, 0.11402680f, 0.01511526f, 0.01674877f, -0.18205528f, 0.14189346f, -0.17946179f, -0.10556253f, 
    -0.12153322f, 0.02162705f, 0.00881028f, -0.05478629f, -0.12590270f, -0.02019713f, -0.12371540f, -0.00418165f, 
    0.18659908f, 0.04775095f, 0.09140568f, 0.02947034f, -0.07294951f, -0.19139533f, 0.01311304f, 0.06199632f, 
    0.05300228f, -0.06460215f, -0.00012435f, -0.11421514f, 0.27086607f, -0.05024574f, 0.07137316f, 0.09119336f, 
    -0.05385976f, -0.09226125f, 0.03202311f, -0.02059182f, -0.04454654f, -0.01869092f, -0.01818986f, 0.09218801f, 
    0.13419488f, 0.07985969f, -0.00179397f, -0.12813601f, 0.07863116f, 0.15731321f, 0.06727055f, 0.04529837f, 
    -0.05130373f, 0.10504943f, -0.06762483f, -0.00523166f, 0.20950714f, -0.08542705f, -0.00828312f, 0.16320229f, 
    -0.04281093f, 0.01578875f, -0.03620088f, -0.06531393f, 0.07449517f, -0.00090139f, 0.13317586f, -0.02162002f, 
    0.02776391f, 0.02383345f, -0.00461245f, -0.02400772f, -0.03840176f, 0.00207229f, 0.03679694f, -0.02543648f, 
    0.08680000f, -0.01138490f, 0.00321468f, -0.02375140f, 0.16090858f, 0.01256821f, -0.11252299f, -0.15192811f, 
    0.01318484f, 0.07375005f, 0.01988469f, 0.02450272f, 0.00075565f, 0.04970819f, -0.10582156f, -0.10601239f, 
    -0.22890992f, -0.03737493f, -0.29232034f, -0.20961988f, -0.03731633f, 0.11117363f, -0.02362993f, -0.07491180f, 
    -0.07718994f, 0.05046424f, -0.04221262f, -0.00861370f, 0.23755766f, 0.03625755f, -0.16819450f, 0.00892976f, 
    0.01007254f, 0.11945626f, -0.01890417f, -0.02002641f, 0.12030266f, 0.00471528f, 0.02718202f, -0.14268044f, 
    0.21446355f, -0.36260879f, 0.12056612f, -0.11298456f, -0.09343991f, 0.06147378f, -0.13583660f, -0.01194354f, 
    0.00927911f, -0.10409399f, 0.00703644f, -0.09056497f, 0.02596217f, 0.04912678f, 0.04740729f, 0.07262984f, 
    -0.08297899f, -0.11641270f, 0.08232446f, 0.05131733f, -0.03796425f, -0.08302139f, 0.01177099f, -0.02484410f, 
    -0.17278886f, -0.02196089f, -0.00482401f, -0.05252123f, 0.11886232f, 0.05691396f, -0.05452044f, -0.03248655f, 
    0.03337857f, -0.08309548f, 0.03187494f, -0.03270460f, -0.16669673f, 0.11371505f, -0.14438942f, -0.00558817f, 
    0.06451060f, -0.00250199f, 0.01000353f, 0.00506829f, 0.02928329f, 0.02014054f, -0.05362815f, -0.04367239f, 
    -0.03559283f, 0.14132434f, -0.05630028f, 0.02103413f, 0.12491082f, 0.04018299f, -0.03728986f, 0.00614273f, 
    -0.06558412f, 0.01399975f, 0.00407906f, 0.01640232f, -0.01615587f, -0.05773869f, 0.04662017f, 0.05442408f, 
    0.07085724f, 0.01519531f, -0.02893228f, -0.04939192f, 0.06830268f, 0.02103504f, -0.12864114f, 0.05804663f, 
    0.17439526f, -0.18469077f, 0.09696081f, 0.05522816f, -0.09341821f, 0.04897688f, 0.07860651f, 0.03859510f, 
    -0.03900092f, 0.06783649f, 0.01638035f, 0.04670704f, 0.20298575f, 0.01109258f, 0.10521545f, 0.10351156f, 
    0.08872290f, 0.19746989f, 0.14710604f, -0.09277508f, 0.06694086f, -0.10509802f, 0.03192661f, -0.04155787f, 
    -0.11588721f, 0.02968590f, -0.27181995f, -0.18679519f, 0.01246215f, -0.05340225f, -0.06131178f, -0.08857326f, 
    -0.06677875f, 0.06228013f, 0.11928488f, 0.00926735f, -0.28806555f, 0.23542152f, 0.13903819f, 0.18121393f, 
    0.12403322f, -0.04075018f, 0.07569999f, 0.04975056f, -0.03582658f, -0.06450586f, -0.04869531f, 0.12935871f, 
    0.06325559f, 0.12166747f, 0.08353498f, -0.01074865f, -0.02390098f, -0.05144475f, -0.02314318f, -0.01658261f, 
    0.00199867f, 0.01474269f, -0.03540863f, 0.02770398f, 0.14355010f, -0.30025530f, -0.00651160f, 0.01975963f, 
    0.03202363f, 0.05927520f, -0.02388108f, -0.07897253f, -0.01488219f, -0.05210184f, 0.01201876f, 0.04968263f, 
    -0.27079564f, -0.22188941f, -0.12930085f, -0.17125204f, -0.06495176f, 0.00558776f, 0.03854753f, -0.05184060f, 
    -0.07538667f, 0.03769717f, 0.00485277f, 0.03592445f, 0.34133089f, -0.39844209f, -0.22335391f, 0.11651357f, 
    -0.06655057f, 0.04333124f, 0.02918287f, 0.08227626f, 0.05648579f, -0.02884297f, 0.02794750f, -0.10290605f, 
    0.09876379f, 0.06824642f, -0.02075640f, -0.03696457f, -0.04102895f, 0.00549118f, 0.01972929f, -0.01823244f, 
    -0.10621979f, 0.01871538f, -0.08398356f, 0.02462124f, 0.00186615f, 0.01757934f, -0.00626447f, -0.04383310f, 
    -0.04077408f, 0.04701468f, 0.05438988f, 0.02078323f, 0.00108196f, 0.03416973f, -0.02614748f, -0.00698506f, 
    0.32544449f, 0.22135690f, -0.02827836f, 0.05750526f, -0.05524970f, 0.05833157f, -0.08414707f, 0.12991025f, 
    0.04131225f, -0.02981622f, -0.01994199f, -0.11229869f, 0.17283952f, 0.07127211f, 0.11817311f, -0.00759447f, 
    -0.02694521f, 0.03211769f, 0.01598432f, -0.14259130f, -0.09473668f, 0.08793996f, 0.03121302f, 0.07198125f, 
    -0.31382659f, 0.02442810f, 0.00145840f, 0.06449839f, 0.07533073f, -0.00435021f, 0.05139089f, 0.08693022f, 
    -0.02724352f, -0.04187795f, -0.06910051f, 0.01689685f, 0.22152571f, 0.11028457f, -0.03556611f, 0.03745611f, 
    0.04902711f, 0.00889013f, 0.07490214f, 0.02295128f, 0.00517757f, 0.01382973f, 0.05474565f, 0.01513692f, 
    -0.23586884f, 0.09609395f, -0.18795152f, -0.05074067f, -0.02990606f, 0.03281101f, 0.10691447f, 0.06131225f, 
    -0.00491036f, -0.00263734f, 0.00681047f, -0.05147034f, -0.20501485f, 0.04695928f, 0.09458847f, -0.01394600f, 
    -0.07730848f, -0.10813018f, 0.01337096f, 0.12248262f, -0.06164275f, -0.00617369f, -0.07483443f, 0.01476372f, 
    -0.34179747f, -0.24987870f, -0.28172439f, -0.09843135f, -0.13729884f, 0.00345865f, 0.04038332f, -0.08467485f, 
    -0.01002182f, 0.03316563f, -0.03150238f, 0.00018480f, -0.06799443f, -0.10630316f, -0.13792160f, -0.13199812f, 
    -0.13517791f, -0.01797299f, 0.10707077f, 0.05014482f, 0.03830111f, -0.03693644f, 0.05130790f, 0.00410173f, 
    -0.20634578f, -0.06903704f, 0.07514612f, 0.12233714f, 0.02684888f, 0.06892516f, -0.05681689f, -0.05967781f, 
    -0.05043802f, -0.11168304f, -0.03620216f, 0.02056832f, -0.26497528f, -0.06081780f, 0.17738022f, -0.29018438f, 
    0.09294025f, 0.01932226f, -0.02200010f, 0.08917466f, 0.05730079f, 0.03325223f, -0.10094735f, 0.02953476f, 
    0.01471452f, 0.27037239f, 0.08877054f, -0.21048471f, -0.04173481f, -0.01582596f, -0.09859887f, 0.07334357f, 
    0.00317758f, -0.06715941f, -0.02947291f, 0.06001807f, -0.07665693f, 0.01331554f, 0.01296214f, 0.09766692f, 
    -0.11094813f, -0.00398574f, 0.02255990f, 0.09719934f, -0.12097315f, 0.02997670f, -0.09412356f, 0.13445583f, 
    -0.40983891f, -0.28893778f, 0.02667388f, -0.06667209f, 0.03944721f, -0.01310078f, -0.01560314f, 0.00676605f, 
    0.09437571f, 0.06355965f, -0.05526635f, -0.03885743f, -0.03385829f, -0.09963987f, -0.05555557f, -0.02602505f, 
    -0.10792383f, -0.04075984f, 0.07567842f, 0.04043995f, -0.11422165f, -0.05231127f, 0.03813425f, 0.01754844f, 
    0.11438624f, 0.02504534f, 0.14633782f, 0.04115978f, -0.03140413f, 0.02124934f, -0.06550328f, 0.01515903f, 
    0.01064117f, -0.08607305f, 0.01717308f, 0.02464101f, -0.43616086f, -0.13233973f, 0.22499870f, 0.11261222f, 
    -0.00106608f, 0.05898529f, 0.09138785f, 0.07233964f, 0.07526437f, -0.08867797f, -0.03169010f, -0.09030719f, 
    -0.06690250f, -0.25312915f, -0.30779454f, 0.08954795f, -0.01840844f, 0.05386170f, -0.07506578f, -0.04794950f, 
    -0.03237798f, 0.02367250f, -0.06464708f, -0.09989372f, -0.10895633f, 0.00123933f, 0.04123433f, 0.01097933f, 
    -0.07167108f, 0.00854356f, -0.03321162f, 0.04904613f, -0.06523097f, -0.01503406f, 0.06512289f, 0.04625028f, 
    -0.25750577f, 0.03602422f, 0.04213606f, -0.03623939f, -0.03031613f, -0.08184458f, 0.11868747f, -0.04131275f, 
    0.00571563f, -0.11045948f, -0.09689248f, -0.06274637f, -0.32582673f, -0.29950732f, 0.10317032f, 0.00889160f, 
    -0.05652949f, 0.02395187f, -0.00455506f, -0.07236737f, -0.08316218f, -0.04579666f, -0.01666648f, -0.01069047f, 
    -0.03190071f, 0.17757618f, -0.12739207f, -0.05001176f, -0.18327644f, -0.03863781f, -0.04569438f, -0.10517246f, 
    -0.09937839f, -0.01407648f, 0.01424870f, 0.01418056f, -0.44989872f, -0.02805248f, -0.12561074f, -0.18110463f, 
    -0.07905858f, -0.00567681f, -0.12727275f, 0.02134477f, 0.06645849f, -0.09483109f, 0.07527000f, -0.02115891f, 
    0.07782328f, -0.12012463f, -0.04001414f, 0.01287431f, 0.01710249f, 0.08755000f, 0.00507305f, -0.01726071f, 
    0.04576193f, -0.00928703f, -0.00579741f, -0.03810247f, -0.03514758f, 0.09917621f, -0.09919813f, -0.10073362f, 
    -0.04181146f, -0.02695752f, -0.02191874f, 0.02653208f, 0.08352115f, -0.15449764f, 0.06942483f, 0.01136228f, 
    0.15677489f, 0.12444188f, 0.12667288f, 0.08837900f, 0.05528373f, -0.00645614f, -0.02577152f, -0.08141442f, 
    0.04286417f, 0.02644446f, -0.01958702f, 0.01500963f, 0.10486861f, 0.16024318f, 0.00072589f, 0.11573200f, 
    0.03971389f, 0.02092068f, 0.03190618f, -0.00777014f, -0.05443320f, -0.03245547f, -0.07384332f, -0.04045296f, 
    -0.04476580f, 0.00626413f, -0.07290078f, -0.13713552f, -0.02783464f, -0.00358599f, 0.09131120f, -0.04697378f, 
    -0.05914703f, 0.01814232f, -0.01172870f, 0.01298203f, 0.11875458f, 0.07500323f, 0.10708426f, 0.05302295f, 
    0.01759127f, 0.05999697f, -0.00681587f, -0.00518423f, 0.10245024f, 0.00043284f, 0.05798747f, -0.01871784f, 
    0.31718633f, -0.11362899f, -0.06880900f, 0.03863557f, -0.02711316f, -0.07444902f, -0.06420556f, -0.00323012f, 
    0.04599282f, 0.05432881f, -0.00076044f, -0.05720698f, 0.13278531f, 0.08718286f, 0.17438808f, -0.15290195f, 
    0.06211160f, -0.01652231f, -0.00491937f, 0.02480172f, 0.00453057f, -0.06852826f, 0.02064351f, -0.01887552f, 
    -0.07730542f, -0.02630485f, -0.04862347f, -0.08319407f, -0.09338314f, -0.03141100f, 0.10839810f, 0.04981149f, 
    -0.10966742f, -0.01102823f, -0.06169673f, 0.05027634f, 0.10780449f, 0.18598863f, 0.03588185f, -0.08810157f, 
    -0.02902006f, 0.03057535f, 0.00669984f, 0.06750407f, -0.04138535f, -0.00597440f, -0.01275069f, 0.01516210f, 
    0.06838720f, -0.09519634f, -0.07291574f, 0.01421486f, -0.09502571f, -0.10351799f, 0.04717877f, -0.03116795f, 
    -0.06081188f, 0.07992695f, -0.00588230f, 0.06334364f, -0.07036901f, 0.04691511f, 0.01741918f, -0.13140830f, 
    -0.00312358f, -0.05300670f, 0.01641101f, 0.01999879f, -0.07435817f, -0.05985726f, 0.06695483f, 0.02694133f, 
    -0.09676248f, -0.24837442f, -0.26974887f, -0.00318968f, -0.05558606f, -0.00947431f, -0.02068455f, 0.03564247f, 
    0.04334405f, 0.05039575f, -0.00794628f, 0.02740026f, 0.02016790f, 0.05449622f, 0.10551853f, -0.01636839f, 
    -0.01221312f, -0.07728341f, 0.01469743f, -0.01223105f, -0.07973312f, 0.02009533f, -0.07430824f, -0.01108613f, 
    0.25749329f, -0.06043247f, -0.47472996f, -0.05157054f, 0.06176120f, 0.02958587f, -0.14060275f, 0.06366779f, 
    -0.02575187f, 0.02120077f, -0.02243136f, 0.01763691f, 0.19545725f, 0.02581287f, 0.00046563f, -0.01103049f, 
    -0.12480272f, -0.05519373f, -0.04086755f, -0.04796330f, -0.00088839f, 0.02996245f, -0.02004560f, -0.00303952f, 
    -0.25494242f, -0.11894462f, -0.03907693f, 0.28037998f, 0.07857119f, 0.01162890f, 0.01647549f, -0.03997771f, 
    -0.07801832f, 0.11335241f, -0.03044800f, 0.03474657f, 0.32246879f, -0.03172469f, 0.12479741f, 0.07874151f, 
    -0.04126943f, 0.09922927f, 0.15228052f, 0.05619391f, -0.09350137f, 0.01814603f, 0.06606919f, 0.15677449f, 
    0.10743248f, -0.04421910f, 0.08889284f, -0.13598426f, 0.00340771f, 0.03279822f, 0.04611851f, 0.05637315f, 
    -0.08954769f, -0.05672059f, 0.05610164f, -0.08700220f, -0.09129714f, 0.02456737f, 0.07327287f, 0.02667682f, 
    0.02133826f, 0.01123918f, -0.01838807f, -0.00245175f, 0.01432260f, 0.15467888f, -0.06413762f, 0.05022831f, 
    0.47823519f, 0.20243028f, 0.10274240f, 0.06572271f, -0.03433765f, -0.04709889f, -0.08848492f, -0.01121510f, 
    0.03011395f, -0.07055195f, 0.02694763f, 0.00978571f, -0.02947686f, 0.22459394f, -0.03476131f, -0.07338172f, 
    -0.04960763f, -0.07205250f, 0.06667396f, 0.01684404f, 0.00905228f, -0.08149260f, -0.00709091f, -0.02314027f, 
    0.20378394f, -0.04835423f, 0.14455551f, -0.10299545f, -0.05666544f, -0.04060649f, -0.11063613f, 0.01786930f, 
    0.01933634f, -0.01981318f, 0.01485178f, 0.08763965f, -0.16866553f, 0.15252773f, -0.06351728f, -0.04017091f, 
    0.02952769f, 0.01796536f, -0.01640712f, 0.06075543f, -0.02781258f, -0.12353873f, 0.10983001f, 0.01859900f, 
    0.17709419f, 0.24352643f, 0.03477979f, -0.03931385f, -0.02106624f, -0.02059920f, 0.06285561f, 0.10505337f, 
    -0.03716508f, 0.06727336f, 0.08966680f, -0.02455971f, -0.00995147f, 0.18282112f, 0.06839533f, 0.13530874f, 
    0.00300522f, 0.01276821f, -0.02896658f, 0.02062442f, -0.02178073f, 0.12434230f, 0.08097676f, 0.07308544f, 
    0.18866158f, 0.09042112f, 0.02862837f, 0.14390568f, -0.08239915f, -0.05277067f, -0.06840077f, 0.05074456f, 
    -0.00247626f, 0.04720576f, 0.06785956f, -0.18125953f, -0.01655515f, -0.22569171f, -0.07553209f, -0.03427114f, 
    -0.05490799f, 0.01934515f, -0.07438315f, -0.04833360f, -0.10673176f, -0.05103639f, 0.03310983f, -0.02445676f, 
    -0.37587929f, -0.42980054f, -0.10844874f, 0.06307959f, -0.16606142f, -0.02191646f, 0.07042841f, -0.03664412f, 
    -0.02038390f, -0.15957925f, 0.17142816f, -0.01630860f, 0.00251833f, -0.06957695f, 0.10521892f, 0.08901129f, 
    -0.00448797f, 0.03351728f, -0.10480104f, -0.10460859f, 0.03544404f, -0.03202695f, -0.12958507f, -0.11141392f, 
    -0.62413293f, -0.43223169f, -0.05399259f, 0.09379770f, -0.00674603f, 0.00305440f, -0.12619378f, -0.05979095f, 
    -0.14157112f, -0.09110662f, 0.02456627f, -0.01058139f, -0.18102506f, -0.50770032f, 0.22861929f, 0.29881498f, 
    -0.00365334f, 0.07573807f, 0.01333280f, -0.04531640f, -0.00891882f, -0.01130845f, -0.10670115f, 0.01884174f, 
    0.07669713f, -0.07202905f, -0.02082518f, -0.10023094f, -0.06287471f, -0.04755525f, 0.10990527f, -0.01266168f, 
    -0.05416287f, 0.02036024f, 0.05867901f, 0.01740585f, 0.01089441f, 0.00324958f, -0.07475339f, 0.25338703f, 
    -0.08737827f, 0.04609519f, 0.14183256f, 0.03464271f, 0.15329601f, -0.11078908f, -0.10745733f, -0.08541073f, 
    -0.23429129f, 0.19822022f, -0.03213501f, 0.02548314f, 0.02526365f, -0.09282424f, -0.04549011f, -0.06460837f, 
    -0.07749121f, 0.05148228f, -0.09070924f, -0.02949492f, -0.09698702f, -0.11155187f, 0.07906459f, 0.09910952f, 
    0.01846841f, 0.00293032f, -0.11448724f, -0.03360770f, 0.06783147f, -0.09518383f, 0.01322320f, 0.13265045f, 
    0.17009333f, -0.01865645f, 0.12035576f, -0.12330303f, 0.02847354f, 0.05550149f, 0.02096050f, 0.04508500f, 
    0.00732005f, -0.05169028f, -0.03713617f, 0.01791064f, -0.15753368f, 0.20014668f, -0.00158455f, -0.10132760f, 
    0.02158840f, -0.05837158f, 0.07313456f, -0.02579096f, -0.06811328f, 0.00981357f, -0.08038167f, -0.04007692f, 
    -0.08097595f, -0.03477072f, -0.12890959f, 0.09750974f, 0.04735377f, 0.02655273f, 0.04558240f, 0.12049715f, 
    -0.06129441f, 0.12324083f, 0.01534712f, 0.05325947f, -0.02940788f, -0.08866471f, 0.16867673f, 0.13887642f, 
    -0.03225905f, 0.04507659f, 0.02002592f, 0.00871229f, 0.06171959f, 0.04439105f, -0.01120902f, 0.01001745f, 
    0.26912799f, -0.05266105f, 0.10295494f, -0.03813665f, -0.08209400f, -0.01866230f, 0.04264110f, -0.05752588f, 
    0.08920775f, -0.05317368f, 0.01250117f, -0.01456997f, -0.37385276f, 0.06349227f, -0.00916499f, -0.09091496f, 
    -0.03676097f, 0.03537191f, 0.04657885f, 0.03037616f, -0.06157410f, -0.00857034f, -0.01916780f, 0.03277766f, 
    -0.19891411f, 0.02691037f, -0.11819516f, 0.02297235f, -0.09666326f, -0.02867888f, -0.03557857f, -0.14264378f, 
    -0.15015259f, -0.03843721f, 0.13019140f, -0.05631169f, -0.14110246f, 0.02186450f, -0.03693124f, -0.14051601f, 
    0.10247941f, 0.06383493f, 0.01961759f, -0.09946651f, -0.19848502f, -0.16951215f, -0.00130353f, 0.07408894f, 
    -0.42397469f, 0.11407053f, -0.19228843f, -0.31704402f, -0.02801089f, -0.05618637f, -0.14155826f, 0.10851056f, 
    0.03118926f, 0.00432860f, -0.09610368f, -0.02092096f, 0.12175477f, 0.05043985f, -0.03042512f, -0.11420733f, 
    -0.05801483f, 0.09005275f, 0.01418044f, -0.10248533f, 0.02013220f, -0.08873228f, -0.03676307f, 0.03024855f, 
    -0.10273193f, -0.25187087f, 0.06734868f, -0.08425227f, 0.00648002f, -0.00123915f, 0.04332415f, -0.04980817f, 
    0.03852082f, 0.09976331f, 0.13648267f, -0.00471570f, -0.27858377f, -0.05480566f, -0.03011186f, -0.07636911f, 
    0.04428018f, -0.02109779f, -0.01626837f, -0.00988409f, -0.03975040f, -0.00853437f, 0.05568554f, -0.05104411f, 
    0.09082101f, 0.01505701f, -0.11652828f, 0.03170794f, -0.04537078f, -0.05901695f, -0.01557849f, 0.12892185f, 
    -0.06651535f, 0.01784621f, 0.00714061f, 0.11195386f, 0.04846833f, 0.08713938f, 0.04336889f, 0.17419001f, 
    0.03049862f, 0.03726561f, 0.06840781f, 0.09629050f, 0.01872433f, -0.04061944f, -0.03702793f, 0.05969541f, 
    -0.43608746f, 0.18784100f, 0.06617447f, -0.10694949f, 0.04910758f, -0.02808891f, -0.06377031f, 0.00654470f, 
    0.11712229f, -0.01862946f, -0.00358789f, -0.09873860f, 0.06664631f, 0.15419850f, -0.05178231f, 0.08178911f, 
    -0.07318167f, 0.00333903f, 0.08476704f, 0.02852715f, -0.02091462f, -0.03012003f, -0.02452329f, 0.04676503f, 
    -0.04304299f, 0.02398356f, 0.00519578f, 0.01835862f, 0.14639829f, -0.06042528f, -0.06761283f, -0.02729867f, 
    -0.01377987f, 0.07022966f, -0.04516767f, -0.06466274f, 0.20011427f, -0.04033419f, -0.14007451f, -0.02122746f, 
    -0.07431640f, 0.03632521f, 0.09460308f, -0.05608687f, -0.15482990f, -0.01481819f, 0.01877843f, -0.00296858f, 
    -0.15723392f, 0.20297550f, -0.17054605f, -0.09445541f, 0.01560144f, -0.07543004f, -0.05720029f, 0.10996158f, 
    -0.00759111f, -0.12671883f, -0.02636366f, 0.03582316f, -0.14253883f, -0.08637337f, -0.07811632f, 0.14705911f, 
    0.00204216f, 0.00998598f, 0.01994142f, 0.09296410f, 0.05161155f, -0.04583263f, 0.01457609f, 0.02144447f, 
    -0.16772185f, 0.04483582f, 0.06296764f, -0.11563276f, -0.02971295f, -0.07660592f, 0.16174014f, 0.06421706f, 
    0.04397095f, -0.00516674f, 0.05983585f, -0.00923023f, -0.21868014f, -0.05614022f, 0.15797511f, -0.00544599f, 
    0.00544520f, -0.01366200f, -0.01224492f, 0.03832600f, -0.11705341f, 0.02587791f, -0.04393560f, -0.02626753f, 
    -0.14421186f, -0.18960853f, 0.10194706f, 0.08799642f, -0.10900041f, -0.05550628f, -0.11593541f, 0.02503684f, 
    0.00154829f, 0.02528808f, -0.11513971f, 0.08840318f, -0.23749498f, -0.21934880f, 0.28886694f, 0.00515307f, 
    -0.00563285f, 0.01946278f, 0.01142133f, 0.09450048f, 0.03004385f, -0.02103328f, 0.02842322f, 0.08406311f, 
    -0.12804365f, 0.01689978f, -0.02472294f, -0.19908105f, -0.01620779f, -0.05621820f, 0.07884631f, -0.03686026f, 
    0.15634589f, 0.11592887f, -0.05582231f, -0.00046742f, -0.36723709f, -0.17491418f, 0.20684262f, 0.06779245f, 
    -0.12626484f, -0.10383093f, -0.01324417f, -0.07414948f, 0.07141394f, -0.09311754f, -0.07611532f, -0.03351679f, 
    -0.17774217f, 0.03233136f, 0.10076564f, 0.25132573f, 0.06527391f, -0.03386366f, 0.09667119f, -0.08525704f, 
    0.07998556f, -0.05163283f, 0.04798244f, -0.09419467f, -0.15699978f, -0.06475531f, 0.05217771f, 0.21240744f, 
    -0.06218070f, 0.06958207f, 0.15318087f, 0.14995305f, -0.03251558f, 0.08901265f, 0.11900821f, 0.04454688f, 
    -0.11427062f, 0.18392928f, -0.01236162f, -0.26373824f, -0.09785994f, 0.07120181f, -0.01568108f, 0.03852673f, 
    -0.06394637f, -0.02070632f, 0.11641043f, 0.05741223f, 0.04570155f, -0.04482758f, 0.10606258f, 0.20246539f, 
    -0.01399137f, 0.13471727f, -0.02837829f, 0.07836536f, -0.04991077f, 0.10402435f, 0.05078441f, 0.00552978f, 
    -0.03756704f, -0.01026377f, 0.13690870f, 0.06736110f, 0.02803370f, -0.10903121f, -0.00045668f, 0.03597341f, 
    0.02928638f, -0.01285355f, -0.04680258f, -0.00116617f, -0.17370145f, 0.06199576f, 0.12893039f, 0.02817834f, 
    0.07307316f, 0.03846633f, -0.02388914f, 0.07750344f, 0.04226603f, -0.03832799f, -0.02587087f, -0.04309854f, 
    -0.09915543f, 0.01030146f, -0.08534334f, 0.09617919f, 0.00192255f, 0.06974737f, -0.03303661f, 0.05649311f, 
    -0.00952145f, -0.00151994f, 0.07094204f, -0.01283796f, 0.07915267f, 0.04587457f, -0.12009371f, 0.14869021f, 
    -0.06654785f, -0.02836852f, -0.01400585f, 0.05425423f, -0.07279070f, 0.00391068f, -0.02753184f, 0.06662057f, 
    0.41968828f, 0.30327502f, -0.12203401f, -0.11090127f, 0.01698563f, 0.02646357f, 0.00660898f, 0.01143438f, 
    0.01046235f, -0.00640702f, 0.02355851f, 0.09831181f, -0.41025952f, -0.19924727f, -0.04019314f, -0.11055030f, 
    -0.01043728f, 0.10941199f, -0.01694389f, 0.05453155f, -0.12951866f, -0.03077606f, -0.16760877f, 0.00409077f, 
    -0.63349563f, -0.19935901f, 0.13949563f, 0.20397162f, 0.05011297f, -0.09658896f, 0.04594492f, -0.02864266f, 
    -0.05562646f, 0.03429137f, 0.08739956f, 0.02265450f, 0.27546862f, -0.00809176f, 0.03071060f, 0.03262278f, 
    0.10012168f, 0.03161945f, 0.04276728f, 0.07102972f, 0.01788264f, -0.05131058f, -0.00952355f, 0.03246773f, 
    -0.01072884f, 0.12612602f, -0.05510754f, 0.11128050f, -0.00068358f, -0.02024355f, -0.01671494f, 0.12778163f, 
    0.04216432f, -0.06371161f, -0.02752244f, -0.03976414f, 0.14225487f, 0.11962277f, 0.04168574f, 0.24367292f, 
    0.02016087f, -0.04892318f, -0.06977810f, 0.11557095f, -0.03987493f, 0.10722495f, 0.02759874f, -0.07651912f, 
    -0.17882605f, -0.09196585f, 0.14673378f, -0.09296115f, -0.07070544f, 0.01533041f, 0.03145335f, -0.02306807f, 
    0.00896498f, 0.00964701f, 0.06331287f, 0.05739118f, -0.02884591f, -0.27679294f, -0.02740644f, 0.13968565f, 
    -0.02837442f, -0.08578014f, 0.07530026f, 0.05784218f, -0.08225153f, 0.00103594f, -0.06222661f, 0.03471429f, 
    -0.27870780f, -0.00791950f, 0.12827359f, -0.13149668f, -0.04084955f, 0.06720024f, -0.03678146f, -0.22880147f, 
    0.06085129f, -0.17469269f, 0.06725752f, -0.14537914f, 0.06003438f, -0.10265841f, -0.06150445f, 0.14362092f, 
    -0.03826061f, 0.03774225f, 0.11763698f, 0.04208188f, 0.06521264f, 0.08098827f, 0.01131525f, 0.07162590f, 
    -0.27354187f, 0.01983120f, 0.09760416f, 0.08573445f, -0.08072996f, 0.03039999f, -0.07146385f, 0.03032433f, 
    -0.02616410f, -0.10780390f, 0.01221451f, -0.00150751f, 0.09202938f, -0.38037455f, 0.03117624f, -0.13837390f, 
    -0.02503459f, 0.00029339f, -0.16903310f, -0.03107744f, -0.00136458f, -0.03560783f, -0.00950587f, -0.10970871f, 
    -0.29025170f, -0.08325248f, 0.09694131f, 0.03115837f, 0.04967551f, 0.01293816f, -0.08413299f, -0.00853269f, 
    0.03443695f, 0.03622029f, -0.02321260f, 0.09260322f, -0.54414159f, 0.15019460f, 0.11935055f, 0.14313522f, 
    -0.01706174f, -0.01646659f, 0.03566977f, -0.02134942f, 0.00628704f, 0.00457373f, 0.06309415f, 0.02111896f, 
    0.20446694f, 0.11806054f, -0.09762429f, 0.04919596f, 0.02151718f, 0.06746923f, -0.02508673f, 0.07021907f, 
    -0.03276563f, 0.05470921f, -0.02158048f, 0.01363557f, -0.28369731f, -0.09267547f, -0.12621991f, 0.09474593f, 
    -0.01976662f, 0.17873773f, 0.04407129f, -0.04663995f, 0.10995097f, -0.05074159f, 0.08084010f, 0.02298636f, 
    -0.04523227f, -0.04453288f, -0.08480811f, -0.22756445f, 0.07280816f, 0.08529774f, 0.00082199f, 0.01577961f, 
    -0.15541483f, -0.14494608f, -0.01807478f, 0.02658760f, -0.04241466f, -0.23166379f, 0.16860209f, -0.05292528f, 
    0.09922802f, 0.01752293f, 0.15020071f, -0.07764945f, 0.04843301f, -0.01933017f, -0.07501972f, -0.06647618f, 
    0.36201146f, 0.00120736f, -0.15227608f, -0.16695517f, 0.00060809f, 0.01918324f, 0.08349632f, -0.08542942f, 
    0.08376645f, -0.07648288f, 0.05346197f, -0.00490299f, 0.11399801f, -0.10009780f, 0.02177170f, 0.19654924f, 
    -0.07674295f, -0.02122991f, 0.07591332f, -0.00573168f, -0.10194809f, 0.14856365f, -0.00222782f, 0.03795158f, 
    -0.25872636f, 0.05263543f, 0.02513070f, -0.19160901f, 0.08680108f, -0.10205365f, -0.02068353f, 0.00212145f, 
    0.01405365f, -0.03913981f, -0.11480987f, -0.01527032f, 0.13590838f, -0.16264619f, -0.04905628f, 0.07711734f, 
    0.00839590f, 0.06840332f, -0.01978051f, -0.10041878f, -0.02349434f, 0.04126394f, -0.02468458f, 0.00131070f, 
    0.17873448f, 0.15556113f, -0.07895032f, -0.07000601f, 0.03391618f, -0.00452183f, 0.04888207f, 0.12159274f, 
    -0.00235338f, 0.03095816f, -0.03897292f, 0.02384688f, 0.17184637f, 0.01390115f, 0.03524525f, 0.18029149f, 
    0.01566867f, -0.07968564f, 0.04483348f, 0.00150949f, 0.10357456f, -0.05973896f, -0.05818695f, -0.01448094f, 
    -0.00001208f, 0.09286796f, 0.23883151f, 0.00175124f, -0.11301708f, -0.02030313f, 0.00653392f, 0.00286791f, 
    0.09975226f, -0.07832612f, -0.01342464f, -0.24040589f, -0.11013658f, 0.18891783f, 0.00454850f, -0.10323285f, 
    0.08441680f, -0.06721478f, -0.00645362f, 0.05457639f, -0.03890987f, -0.11432206f, 0.06348074f, -0.01065163f, 
    0.05632911f, 0.22512880f, 0.05459249f, 0.08395261f, -0.05840664f, -0.00200319f, -0.10988681f, -0.03944374f, 
    -0.15563713f, -0.04564372f, -0.07473410f, -0.06148187f, -0.12189323f, -0.03013204f, 0.07005242f, -0.38048923f, 
    0.02773320f, -0.06156648f, -0.04070129f, 0.00830478f, 0.12505637f, 0.19032408f, 0.10682161f, 0.13495079f, 
    -0.28751764f, 0.00412190f, 0.03249462f, -0.14835964f, 0.08758516f, -0.06094953f, 0.05526621f, -0.08583903f, 
    0.02407207f, -0.06377159f, 0.04519841f, -0.04026343f, 0.25553435f, 0.06466731f, -0.22179890f, 0.06581642f, 
    0.07060730f, -0.06115598f, -0.02477542f, 0.01556304f, 0.07310134f, -0.01573455f, 0.25079328f, 0.04470028f, 
    -0.09612127f, -0.03880110f, -0.07212413f, 0.20321749f, 0.03630475f, -0.10722362f, -0.06064172f, 0.04855644f, 
    0.01753964f, 0.00435428f, 0.01726057f, 0.04236488f, -0.05405533f, -0.01585587f, 0.08617206f, -0.03475866f, 
    -0.15144454f, 0.02525492f, 0.03535553f, 0.09692602f, 0.11382194f, -0.06373257f, -0.12464157f, 0.05043919f, 
    0.06146321f, 0.11601758f, 0.16413336f, -0.07848279f, 0.10317754f, -0.13483958f, -0.12772429f, 0.10522225f, 
    0.07815329f, -0.00183649f, -0.10786156f, 0.08457299f, -0.05740844f, 0.03417277f, 0.09150932f, 0.13321932f, 
    -0.04346631f, -0.07059508f, -0.03108983f, -0.04330092f, -0.16814384f, -0.05328580f, 0.01522293f, 0.10837279f, 
    0.00329965f, -0.08114776f, 0.05712097f, 0.13387553f, 0.02397288f, 0.13102633f, 0.08370766f, -0.00438567f, 
    0.09305195f, 0.12074636f, -0.10341208f, 0.03805828f, -0.18881612f, 0.06588976f, -0.11164530f, -0.12839018f, 
    0.02563304f, 0.02926012f, -0.07682589f, 0.09260047f, -0.07039172f, -0.10638140f, 0.10289771f, -0.15358694f, 
    -0.17617971f, -0.10096838f, 0.25995561f, 0.24294865f, -0.05483530f, -0.11418448f, 0.08857646f, -0.06875928f, 
    -0.08872116f, -0.08938003f, -0.24732937f, 0.26292083f, -0.12269589f, -0.14882232f, -0.29275307f, 0.11942524f, 
    -0.04771799f, -0.05797320f, 0.07075765f, 0.02179560f, 0.12251099f, -0.08502066f, -0.00354076f, 0.00946062f, 
    -0.26729345f, 0.02847400f, 0.04776290f, 0.13924479f, 0.03752382f, -0.09950550f, 0.00385301f, 0.00300767f, 
    -0.01136843f, -0.00139084f, 0.03550054f, 0.04263560f, -0.30731493f, -0.10110363f, 0.23987649f, -0.41214561f, 
    -0.12763165f, -0.09792154f, 0.05581561f, -0.04406439f, 0.00434940f, 0.05470898f, 0.06125947f, -0.01658933f, 
    0.00215135f, 0.10132760f, 0.04900526f, 0.08854371f, -0.08503927f, 0.01123761f, 0.01650186f, 0.16269496f, 
    0.06072975f, -0.02543312f, 0.01928436f, -0.05911093f, -0.32223886f, -0.05421637f, 0.05651779f, -0.30183527f, 
    0.10274912f, 0.07732993f, 0.09079891f, -0.00761694f, -0.04062098f, 0.03952474f, 0.03120659f, 0.08605689f, 
    0.01378172f, 0.10484824f, 0.12133066f, 0.02337706f, -0.01368518f, -0.06284438f, 0.05592635f, -0.05126178f, 
    0.10499375f, -0.01506258f, -0.09534704f, 0.01290799f, -0.17247358f, -0.12004395f, 0.08394931f, -0.06178444f, 
    0.09878352f, -0.12728858f, -0.08643336f, -0.00851229f, 0.12162144f, 0.12050844f, -0.01007853f, 0.06441873f, 
    -0.23476599f, 0.11213948f, -0.00280782f, -0.12583362f, 0.07214187f, 0.06185838f, -0.06638197f, 0.08235340f, 
    -0.06030702f, 0.10621653f, 0.01429751f, -0.06102689f, -0.12633030f, -0.25873321f, 0.02290500f, 0.05196244f, 
    0.01301256f, -0.05542289f, -0.04358793f, -0.05521571f, -0.00332086f, 0.04960097f, -0.06376327f, 0.01616100f, 
    -0.19360316f, -0.05583781f, -0.00902690f, 0.03140016f, 0.14646032f, -0.11442712f, -0.02725810f, -0.10234863f, 
    -0.03197199f, -0.02630707f, 0.08912215f, -0.04648736f, 0.04731255f, -0.25431687f, 0.15984046f, 0.15030348f, 
    -0.00575726f, 0.05502116f, -0.17074992f, 0.07244432f, -0.05310597f, -0.18096681f, -0.06160439f, -0.16240864f, 
    -0.02222351f, 0.10044940f, 0.22209643f, -0.08157223f, 0.04915898f, -0.06417858f, 0.05572779f, -0.02848137f, 
    0.10261031f, 0.03569280f, 0.04814983f, -0.13353378f, -0.02513666f, -0.27170205f, -0.15399285f, 0.09051026f, 
    0.17378648f, 0.16626857f, -0.06378213f, -0.14501256f, -0.16442662f, 0.14026728f, -0.03669075f, -0.01240570f, 
    0.01616486f, 0.04065311f, -0.04986000f, 0.05713274f, 0.10236493f, 0.18178733f, 0.00250012f, 0.02810139f, 
    0.06489640f, 0.00447227f, 0.08169793f, 0.08876804f, 0.18539162f, -0.01923862f, 0.07668268f, 0.12140260f, 
    -0.06315197f, 0.06603280f, 0.08883501f, -0.03271141f, -0.13370427f, -0.04119559f, 0.19320802f, 0.18911646f, 
    0.07031911f, 0.06016563f, 0.01351544f, 0.09735538f, 0.06580394f, -0.09999710f, 0.07217295f, -0.03917052f, 
    0.04271362f, -0.17036298f, 0.01083418f, 0.05443927f, 0.18846071f, -0.00195550f, -0.24539939f, 0.07381427f, 
    0.07416762f, 0.02716898f, -0.08366331f, 0.01704681f, 0.09019299f, 0.08664510f, -0.13140541f, -0.19896039f, 
    -0.27861753f, 0.18962760f, 0.10025967f, -0.08779278f, 0.01154191f, -0.03717336f, -0.13522369f, 0.03163676f, 
    0.16030420f, 0.01015954f, -0.02349208f, 0.07861089f, 0.11335050f, 0.03845504f, 0.05688988f, 0.02483074f, 
    -0.12017161f, -0.01668083f, 0.05341281f, 0.08135450f, -0.01087998f, 0.04054447f, 0.09733430f, -0.05494624f, 
    -0.08001438f, 0.03987084f, -0.07137576f, -0.07667964f, 0.00093517f, 0.01053220f, -0.26874438f, -0.06877338f, 
    -0.04207259f, -0.03607500f, -0.01021809f, -0.00778927f, 0.07842360f, 0.24039167f, 0.07126299f, -0.05199169f, 
    0.10605710f, -0.09671465f, -0.04806538f, -0.28500432f, -0.06922662f, -0.01875969f, -0.06382395f, -0.27082407f, 
    -0.19828643f, 0.01951580f, -0.10531711f, -0.11129481f, -0.04463904f, -0.21423195f, -0.00669463f, 0.13951285f, 
    0.12293497f, 0.02022510f, -0.05588952f, -0.15877149f, -0.19258229f, -0.09172984f, -0.23858199f, 0.02196934f, 
    0.01852122f, 0.02633552f, -0.06847460f, -0.02054980f, 0.06579065f, 0.00552058f, 0.11991498f, -0.04697387f, 
    0.10183376f, -0.01390613f, -0.03519718f, 0.23804376f, 0.01132116f, 0.02864668f, -0.03868905f, -0.04963480f, 
    -0.13573000f, -0.03768621f, 0.31374454f, 0.12269134f, -0.04532978f, -0.03509605f, -0.21407434f, 0.10572977f, 
    0.00259089f, -0.01620683f, 0.01249152f, -0.00132510f, -0.07322403f, 0.21312831f, -0.02309345f, 0.25358897f, 
    -0.18588847f, -0.06333890f, -0.19442238f, -0.10333116f, 0.02459221f, 0.05193261f, -0.04628728f, 0.02695070f, 
    -0.06558301f, -0.05898686f, 0.05428851f, 0.01669529f, -0.03501425f, -0.00555484f, 0.08806638f, 0.00174235f, 
    -0.06955483f, 0.02634338f, 0.01145461f, 0.00173214f, 0.01253706f, -0.08171701f, -0.12243627f, 0.03979432f, 
    -0.13765199f, -0.28653902f, 0.25475585f, 0.30128574f, -0.06819245f, -0.00809626f, 0.05398856f, 0.05340642f, 
    0.01231272f, 0.01582740f, -0.03614159f, -0.25267237f, -0.06847819f, 0.08708218f, -0.10366796f, -0.20218828f, 
    0.19409397f, -0.09252430f, 0.08431061f, 0.09251349f, 0.04250089f, -0.06160193f, -0.09019488f, -0.08327594f, 
    -0.03405441f, 0.11365927f, -0.25073257f, -0.14555871f, 0.06653145f, 0.21684282f, -0.13579798f, 0.07708174f, 
    0.08426686f, -0.10909665f, 0.11098583f, -0.13104206f, -0.22940868f, -0.19974501f, -0.03272838f, 0.13987127f, 
    0.03353466f, 0.05722148f, 0.05607565f, -0.07730141f, 0.00335767f, -0.00826699f, -0.00796237f, -0.01991642f, 
    -0.69070160f, -0.27750266f, -0.15276596f, 0.01322579f, 0.15874842f, 0.06566261f, -0.14362158f, -0.07272691f, 
    -0.08156769f, 0.05429434f, -0.04495932f, 0.06438206f, 0.04714607f, -0.25414258f, -0.13579351f, 0.00096280f, 
    0.12658782f, 0.05356584f, 0.03614689f, -0.28006771f, 0.00289749f, 0.01306079f, -0.04206314f, 0.15647204f, 
    0.20789818f, 0.03008115f, 0.03444485f, 0.04441090f, 0.03030233f, -0.00155937f, 0.06292012f, -0.10317541f, 
    -0.07482477f, 0.04521603f, 0.00509667f, 0.03957632f, -0.01756904f, -0.09756592f, -0.15752290f, -0.03703180f, 
    0.01768779f, 0.04648015f, -0.06128408f, 0.06824135f, 0.06031619f, -0.07497212f, 0.13645007f, -0.16513768f, 
    -0.04777365f, 0.15994419f, -0.02966424f, -0.04037948f, 0.13732697f, -0.08356134f, 0.05125421f, 0.12739067f, 
    0.12831885f, -0.10576174f, 0.05091621f, 0.01093780f, 0.04331230f, -0.10072009f, 0.00754470f, 0.04073793f, 
    0.12399307f, 0.15320061f, -0.00550295f, 0.12082899f, 0.07197037f, -0.02894800f, 0.02291919f, -0.07514240f, 
    0.13022768f, -0.19257553f, 0.13438278f, -0.04839514f, -0.07465795f, -0.06801425f, 0.06484283f, 0.08038399f, 
    -0.00777712f, -0.00380500f, 0.00982428f, -0.03993961f, 0.25695050f, -0.08608682f, -0.14284042f, -0.08494953f, 
    0.07474269f, -0.04483300f, 0.01882602f, 0.00296677f, -0.02576387f, 0.03257372f, 0.02407487f, 0.08712892f, 
    -0.21996205f, 0.15973113f, -0.17424752f, 0.04416287f, 0.06545156f, -0.01642421f, -0.01185726f, -0.07949194f, 
    0.03301294f, -0.09129211f, -0.01709656f, 0.01821432f, -0.12235449f, 0.04048804f, -0.16921988f, -0.16153823f, 
    -0.03207701f, 0.11438362f, -0.02568042f, 0.01927655f, 0.07696740f, -0.16471809f, -0.01351853f, -0.17582236f, 
    -0.13402762f, -0.26646334f, 0.16191027f, -0.07069496f, -0.08048976f, -0.05530107f, 0.05480208f, -0.08262007f, 
    -0.02859963f, -0.09307514f, 0.03087145f, -0.12428483f, -0.34657371f, 0.07600368f, -0.03095136f, -0.19340619f, 
    -0.00899692f, -0.03229055f, 0.19467190f, -0.02341358f, 0.03462300f, -0.06162119f, -0.01747736f, -0.12991711f, 
    -0.33839387f, -0.12241542f, -0.22651638f, 0.08950759f, -0.04794920f, -0.00823177f, 0.16678569f, 0.08852527f, 
    0.11255928f, 0.08325122f, -0.10458507f, 0.01474631f, 0.20782988f, 0.13146555f, 0.09062421f, 0.08174076f, 
    -0.20906414f, -0.01635161f, 0.00231347f, 0.04557743f, -0.04002485f, -0.02531658f, 0.05761706f, -0.13927694f, 
    -0.10146860f, -0.01166068f, 0.19826873f, 0.39885131f, -0.03409505f, 0.08658013f, 0.02178621f, -0.00909530f, 
    0.00833243f, -0.03181135f, 0.01639854f, 0.10197093f, -0.12509619f, -0.02045903f, -0.04295572f, -0.12182883f, 
    0.05881788f, 0.10192865f, 0.01179842f, -0.18717554f, 0.05071478f, -0.14965276f, -0.16621454f, 0.07014319f, 
    -0.17310195f, 0.03457829f, 0.08244965f, 0.05563877f, -0.01565743f, 0.07258934f, 0.09567074f, 0.04270884f, 
    0.05562716f, 0.20808981f, -0.04149226f, 0.13283893f, 0.14050360f, 0.16259420f, -0.10078940f, -0.21675754f, 
    -0.05264241f, -0.01233069f, -0.01177488f, -0.11258645f, -0.03421691f, 0.04026115f, -0.05230863f, 0.02569075f, 
    -0.00187406f, 0.04958700f, 0.17383704f, -0.00333197f, -0.02202749f, 0.02676073f, 0.01181279f, -0.11246192f, 
    -0.00745736f, 0.05358482f, 0.07647572f, -0.04122996f, -0.03243236f, 0.03300196f, 0.01823018f, -0.30962080f, 
    0.04889123f, -0.13323025f, 0.01287602f, 0.01951231f, 0.01470822f, -0.12500034f, 0.11303718f, 0.20894435f, 
    -0.06213516f, -0.13307711f, 0.17246594f, -0.06162161f, -0.07735591f, -0.00807815f, 0.03772004f, -0.00271239f, 
    0.13221379f, 0.06799577f, 0.03599626f, 0.08481687f, -0.00350782f, -0.03002867f, 0.27377400f, 0.10945611f, 
    0.02384112f, 0.10259071f, -0.03837759f, -0.00267838f, -0.04252227f, 0.02479265f, 0.10911654f, 0.11629319f, 
    -0.09904664f, -0.03185387f, -0.00136202f, 0.19780929f, 0.10662995f, 0.01210403f, 0.07327692f, 0.03975520f, 
    0.13837089f, 0.07024137f, -0.01501976f, 0.02452071f, 0.13688932f, 0.10823669f, 0.01163763f, -0.26264036f, 
    -0.00322611f, -0.01129820f, 0.03362992f, 0.08194008f, 0.03240914f, -0.12457936f, -0.09158015f, -0.10463887f, 
    0.12226861f, -0.47047916f, -0.01471995f, -0.01693484f, -0.16627832f, -0.00343998f, -0.00913320f, -0.02201615f, 
    0.10935865f, -0.09569068f, -0.00882146f, 0.14862199f, 0.05107789f, -0.07594407f, -0.07394058f, -0.04034389f, 
    0.10004328f, 0.06680004f, 0.09633455f, -0.19765833f, -0.06192973f, -0.00409266f, 0.00502427f, -0.21211421f, 
    -0.07542823f, -0.06844000f, -0.10913011f, -0.17476660f, 0.04816148f, -0.04892779f, 0.02285387f, -0.09236328f, 
    -0.14025469f, -0.02773476f, -0.09128743f, -0.00261409f, 0.09301512f, -0.13724028f, 0.22723502f, -0.04577767f, 
    -0.00779005f, -0.09644398f, 0.02157670f, -0.15559226f, -0.01971029f, 0.03099502f, 0.15384217f, -0.05814381f, 
    -0.16676608f, -0.13522229f, -0.03048903f, 0.13469534f, -0.10384098f, -0.05728668f, 0.04461619f, 0.02997060f, 
    0.01128827f, 0.01092147f, 0.01750479f, 0.06796693f, -0.09934737f, 0.20917615f, 0.01522818f, -0.26520666f, 
    -0.03393918f, 0.07497237f, -0.06224413f, 0.06839678f, 0.00276307f, 0.04333598f, 0.06547127f, -0.01066663f, 
    -0.19666150f, -0.10009284f, -0.10210521f, 0.26221031f, 0.09558730f, -0.06338398f, 0.02280294f, 0.08027078f, 
    -0.07877163f, -0.05463650f, 0.13710226f, 0.04472004f, 0.41041127f, -0.18574035f, 0.20220256f, -0.12607297f, 
    0.05111551f, 0.06759509f, 0.07382578f, -0.00629683f, 0.04038692f, 0.08844718f, 0.03152192f, 0.07965024f, 
    0.06549788f, 0.04664854f, -0.25068673f, 0.10329602f, -0.06273688f, 0.01341468f, 0.02606699f, -0.04926401f, 
    -0.08566169f, -0.05043527f, 0.04083177f, -0.09926243f, -0.11683184f, 0.06911938f, -0.19229612f, 0.03474632f, 
    0.03624046f, -0.07360581f, -0.03816137f, -0.02751483f, -0.15368928f, 0.15984367f, 0.12247281f, -0.01273751f, 
    0.36498660f, -0.27126035f, 0.11776260f, -0.04440902f, 0.01898902f, 0.03191281f, 0.08754718f, 0.00416785f, 
    -0.01493762f, 0.06013151f, 0.00174736f, -0.16078247f, 0.23293257f, 0.05913693f, -0.03923633f, 0.20730463f, 
    0.01107981f, -0.02630743f, -0.03965718f, -0.05829900f, -0.00102111f, 0.04076895f, 0.08841154f, -0.02620837f, 
    -0.48756230f, 0.01072321f, 0.04024583f, 0.13762094f, 0.10605434f, 0.04438930f, 0.07975406f, -0.03777110f, 
    -0.07217668f, -0.03610400f, -0.08453949f, -0.01526297f, -0.03461304f, -0.04619195f, -0.23857091f, 0.15136431f, 
    0.01626094f, -0.00274241f, -0.01208449f, 0.00399142f, 0.09426499f, -0.03857043f, -0.10899955f, -0.02751414f, 
    -0.08195677f, 0.10340605f, 0.09988957f, 0.07054570f, -0.08340885f, -0.00698830f, 0.10415534f, 0.02731087f, 
    -0.05952234f, 0.04897029f, 0.04244884f, 0.06748058f, 0.07505192f, -0.03531368f, -0.05962020f, 0.21627490f, 
    0.03993879f, 0.10862558f, -0.05416493f, 0.03903102f, 0.05179403f, -0.10901470f, 0.11576926f, -0.15043204f, 
    0.26075289f, -0.13906516f, 0.11756665f, -0.01653988f, 0.06124158f, -0.02730502f, 0.13873079f, -0.12781078f, 
    -0.07859663f, -0.03334724f, 0.10990359f, -0.13516518f, -0.20555855f, -0.01418028f, -0.09563944f, 0.28110912f, 
    0.02346757f, 0.00051313f, 0.01043542f, 0.00365294f, 0.07066058f, -0.05339246f, -0.08259708f, 0.05326052f, 
    0.08776956f, -0.12571046f, -0.13022101f, 0.32059202f, -0.17320859f, 0.06988686f, 0.05426992f, 0.14792715f, 
    -0.05829755f, -0.05664859f, -0.09888313f, -0.03790627f, -0.12507457f, 0.00205769f, 0.00976555f, -0.04640473f, 
    0.01653382f, 0.00821810f, 0.12017886f, 0.07612289f, 0.14816134f, -0.03337737f, 0.00351155f, 0.18545304f, 
    0.12961979f, -0.22727972f, -0.01583353f, 0.11349031f, -0.06569164f, -0.02076447f, 0.06512469f, 0.05735654f, 
    0.02257644f, 0.02671910f, -0.02077381f, 0.25939521f, -0.22002032f, 0.02883364f, -0.07757119f, -0.34294295f, 
    -0.06655420f, -0.05799549f, 0.10020815f, -0.09630153f, 0.03411572f, 0.03504729f, 0.00327061f, 0.11944683f, 
    -0.00520745f, -0.08737255f, -0.19114119f, -0.00254802f, -0.14165811f, 0.00958878f, 0.02700991f, 0.04959230f, 
    0.06817335f, -0.04090821f, -0.05961651f, -0.02199682f, 0.16847919f, 0.15419191f, 0.12794332f, -0.15264848f, 
    -0.09845261f, -0.02476014f, -0.04696348f, 0.06976324f, 0.07604925f, -0.01723931f, -0.06597675f, -0.08366805f, 
    -0.26194590f, 0.30272999f, 0.01233528f, -0.06634445f, -0.13193297f, 0.03209815f, -0.00526754f, 0.00845733f, 
    -0.08704529f, 0.21299793f, 0.02900286f, 0.03756620f, -0.04555162f, -0.05514667f, -0.09637181f, 0.26322743f, 
    0.06645713f, 0.05373843f, -0.01144882f, 0.00088611f, -0.02973130f, -0.02362538f, 0.08216424f, 0.11104840f, 
    0.00521328f, -0.15571542f, 0.12727581f, 0.30122894f, -0.01399364f, 0.00623991f, 0.13571583f, 0.10230651f, 
    -0.00048734f, -0.01789221f, -0.11276512f, -0.00948325f, -0.18634836f, 0.08290222f, 0.03140968f, -0.02109883f, 
    0.14734848f, -0.10497080f, -0.13051417f, -0.02926724f, -0.09788542f, 0.05795840f, -0.13053495f, -0.02292353f, 
    -0.35897034f, -0.23713945f, 0.04643093f, -0.14412630f, -0.00022934f, -0.01685266f, 0.13031845f, 0.12239906f, 
    -0.01177089f, 0.03733682f, 0.05487615f, -0.05827606f, 0.06675280f, -0.16501419f, -0.17257613f, 0.03971255f, 
    -0.05291036f, 0.02355582f, -0.06314665f, 0.20037477f, -0.07814149f, -0.08696189f, 0.12118824f, 0.03519453f, 
    0.07035464f, -0.07320255f, 0.13165109f, 0.01643931f, 0.17005721f, -0.05236205f, -0.04054518f, -0.09868201f, 
    0.01896600f, -0.02593490f, 0.11828792f, 0.05026178f, -0.19284461f, 0.07907998f, -0.01418190f, -0.16584149f, 
    -0.02142309f, 0.04924852f, 0.01031826f, -0.06040728f, -0.06128334f, 0.08824247f, -0.05888525f, 0.12428544f, 
    -0.04188765f, 0.06031132f, -0.16797493f, -0.06970728f, 0.10511164f, 0.04782687f, 0.00653257f, -0.08141075f, 
    -0.00000973f, -0.01006357f, 0.03660182f, -0.13963188f, 0.13524255f, -0.12258253f, -0.12835184f, 0.02148109f, 
    0.13044570f, -0.02762611f, -0.01045405f, 0.00497216f, -0.02121138f, -0.21481149f, -0.09332024f, 0.00983766f, 
    -0.01227210f, -0.20472828f, 0.03667302f, -0.13991107f, -0.02107749f, -0.00761143f, 0.16203156f, 0.00208488f, 
    -0.00251077f, -0.02222860f, 0.00912933f, -0.04979775f, -0.03017128f, 0.05074621f, -0.11040836f, -0.13117340f, 
    -0.00908454f, 0.11838902f, 0.02509198f, -0.11499973f, -0.05383733f, 0.03866448f, 0.13676357f, 0.12643597f, 
    0.03603331f, 0.13133489f, -0.07796238f, 0.12322841f, -0.01851176f, -0.10162028f, -0.06700240f, 0.08916163f, 
    0.01265577f, 0.07465980f, -0.05595836f, 0.09755560f, 0.25139141f, -0.20938289f, 0.00103960f, -0.29916513f, 
    -0.03996480f, -0.07529630f, 0.07709353f, -0.02869510f, 0.02323021f, 0.03781627f, 0.04589225f, -0.05404701f, 
    -0.06462055f, -0.18777086f, -0.13960452f, -0.09548417f, -0.12358335f, 0.02298824f, 0.06154937f, -0.13996267f, 
    0.08104070f, 0.04594938f, -0.07670888f, 0.19192551f, 0.09745002f, 0.00195148f, -0.13620065f, 0.17510320f, 
    -0.19408411f, 0.07766975f, -0.10941958f, 0.02356893f, -0.17998961f, 0.13921817f, 0.04403233f, -0.00013378f, 
    -0.33735374f, 0.04099967f, -0.07380368f, -0.19416185f, -0.00652931f, 0.04347501f, 0.02278226f, 0.03328940f, 
    0.13976422f, -0.04091033f, 0.08086675f, 0.01423876f, -0.31134132f, -0.04251685f, -0.23953950f, -0.12385941f, 
    -0.02892774f, -0.11321046f, -0.06809697f, -0.09448040f, -0.02539066f, -0.02982241f, 0.06794921f, -0.14605564f, 
    -0.28448176f, 0.26728901f, 0.01258916f, 0.25932589f, -0.05605394f, 0.09761015f, 0.03130309f, 0.18423705f, 
    -0.02015797f, 0.01803674f, 0.04231051f, -0.03560229f, 0.12921533f, 0.11003138f, -0.08682082f, 0.18620734f, 
    -0.06524787f, 0.04324660f, 0.06447589f, -0.11717413f, 0.03201893f, 0.10060310f, 0.00228479f, -0.00919067f, 
    -0.03674447f, 0.12587154f, 0.13533790f, 0.14439712f, 0.05008016f, 0.14734171f, -0.00543930f, 0.01673527f, 
    0.02980163f, 0.00657096f, -0.08492944f, -0.02818780f, -0.00676465f, -0.03308491f, -0.22478905f, -0.14239421f, 
    -0.14094082f, -0.04637466f, -0.16432856f, -0.17607155f, -0.05638359f, -0.01352871f, -0.02456792f, 0.04856905f, 
    0.21104033f, 0.11740139f, -0.01008669f, -0.28954718f, -0.01966280f, 0.07797885f, -0.00662957f, -0.04384260f, 
    0.13952132f, -0.08708517f, 0.03969104f, 0.00398671f, -0.07789619f, 0.01226037f, 0.23604572f, -0.04195100f, 
    0.07566721f, 0.05770440f, 0.04855320f, 0.05341902f, 0.00718770f, -0.17627586f, -0.10644754f, -0.04116200f, 
    0.13353236f, -0.41468674f, -0.21136454f, 0.05031681f, 0.00563980f, 0.07924255f, -0.02517228f, -0.04188307f, 
    -0.07332636f, -0.01583649f, 0.03361316f, 0.11941061f, 0.02463313f, -0.15223064f, 0.00669032f, -0.17828798f, 
    0.05285644f, 0.01352733f, -0.00009919f, -0.04150375f, 0.02624765f, 0.04055217f, -0.02009494f, 0.24995735f, 
    -0.06918978f, -0.03985725f, 0.05688925f, 0.18548726f, -0.08244079f, 0.08077923f, 0.00753730f, 0.07876086f, 
    -0.09794419f, 0.07376339f, -0.03949347f, 0.20454490f, 0.09640036f, -0.33889106f, 0.14130212f, -0.20416977f, 
    -0.05456464f, -0.03666413f, 0.01221363f, -0.09051643f, -0.16825667f, -0.03970606f, 0.01283655f, 0.10131036f, 
    0.09389714f, -0.20619296f, -0.11911501f, -0.03464849f, 0.01728225f, 0.02124573f, -0.06773289f, -0.20426264f, 
    -0.13681589f, -0.07724213f, 0.13156477f, -0.08209483f, -0.03285387f, 0.01324390f, 0.16502783f, -0.01843320f, 
    0.01626825f, -0.06329194f, -0.01736010f, 0.01485935f, -0.00485775f, 0.07177086f, -0.11915656f, -0.01983208f, 
    -0.04830419f, 0.01167602f, 0.03956262f, 0.17288509f, -0.03487399f, -0.05045116f, -0.07430883f, -0.13553241f, 
    -0.09872793f, 0.04246452f, -0.05369780f, 0.09822531f, -0.19075319f, -0.09030929f, 0.05404809f, -0.06670083f, 
    0.02295170f, -0.10576843f, -0.00464788f, 0.01637227f, 0.05083767f, 0.19437870f, 0.08862066f, -0.00500219f, 
    0.16651097f, -0.01418650f, -0.23598813f, -0.24922948f, -0.10681889f, 0.01826816f, -0.05296820f, -0.01942879f, 
    0.01602044f, -0.04144051f, 0.01612907f, -0.05887895f, -0.29403529f, 0.08275402f, 0.00828377f, 0.16246282f, 
    -0.02792375f, 0.07800063f, -0.04917107f, -0.02240442f, 0.06730748f, -0.02255339f, 0.00563785f, -0.07195038f, 
    -0.00371113f, 0.10436302f, 0.01240232f, -0.17113009f, -0.06734612f, -0.03645839f, -0.05803429f, 0.09776810f, 
    -0.01061122f, -0.00634922f, -0.11439014f, -0.02739264f, 0.04594457f, 0.25460118f, 0.07484978f, -0.24638486f, 
    -0.02856798f, 0.15388682f, 0.07405470f, 0.00650593f, -0.14704044f, -0.01960756f, 0.00365867f, -0.10594477f, 
    0.14250247f, 0.03547497f, 0.07846490f, -0.24727987f, 0.11721939f, -0.04172623f, -0.11924377f, 0.06824426f, 
    -0.18926279f, 0.04681236f, -0.00423077f, -0.02704932f, 0.16089493f, -0.16847283f, -0.03468426f, -0.19544636f, 
    -0.03226061f, -0.02250557f, 0.03803863f, 0.09221802f, -0.00180102f, -0.08228827f, -0.01021985f, -0.01954348f, 
    0.00295022f, 0.13665560f, -0.02457870f, -0.03025508f, -0.01399959f, 0.00595494f, 0.01910944f, -0.01671027f, 
    -0.03422913f, 0.10574534f, -0.06966860f, -0.08747584f, -0.18921855f, 0.09619620f, -0.07654168f, -0.16048081f, 
    -0.07032321f, 0.00651273f, 0.02102223f, -0.03496980f, -0.05088454f, -0.09679656f, -0.09664071f, -0.11585983f, 
    -0.05666696f, 0.00751986f, -0.02085377f, -0.04814281f, -0.03372907f, 0.00299685f, -0.00004870f, -0.09693860f, 
    -0.00946758f, 0.03002911f, -0.02017050f, 0.01274861f, 0.18483248f, -0.19644393f, 0.07048379f, 0.01966547f, 
    0.05663407f, -0.01512446f, -0.01371049f, -0.07151069f, -0.04357224f, 0.03029928f, -0.04364099f, -0.05309225f, 
    0.06989879f, -0.00614732f, 0.08653069f, 0.16901624f, 0.05523293f, -0.02960395f, 0.00874262f, -0.02390071f, 
    -0.01496278f, -0.10655583f, -0.02553499f, -0.07403713f, 0.23423503f, 0.09474705f, 0.12524897f, -0.18539338f, 
    -0.07937930f, 0.12318315f, -0.04521380f, -0.00743588f, -0.04556048f, 0.00568414f, -0.02770716f, -0.02530893f, 
    0.06067998f, 0.09787803f, -0.00854472f, -0.04489262f, 0.04922655f, -0.01378515f, 0.07509656f, 0.00721441f, 
    -0.00473316f, 0.00128729f, 0.00025309f, -0.01614844f, -0.28938156f, 0.02168339f, 0.04278417f, 0.06664534f, 
    -0.03287151f, -0.03865305f, -0.01357370f, 0.00046622f, -0.07247593f, -0.04703169f, -0.00504896f, -0.05306304f, 
    -0.00360521f, 0.10268010f, 0.01169934f, 0.06412715f, 0.07085168f, -0.01569407f, -0.04664519f, -0.00521153f, 
    0.00512476f, 0.02751542f, -0.07967728f, 0.00488037f, 0.37209913f, 0.06282207f, -0.06029237f, -0.16441120f, 
    -0.09352560f, -0.02907326f, 0.06024563f, -0.02918479f, -0.09512132f, -0.02606515f, -0.01971635f, 0.01935835f, 
    -0.22182870f, -0.01368742f, 0.00249970f, 0.06817713f, -0.00925714f, -0.10193601f, -0.11320895f, -0.00885052f, 
    -0.02060150f, -0.05535154f, -0.03811661f, -0.01851526f, -0.20924869f, 0.04344100f, -0.09044110f, -0.00594523f, 
    -0.03464358f, -0.06563735f, -0.01553971f, -0.04009581f, -0.00654387f, 0.03786436f, 0.02297992f, -0.06889178f, 
    0.14386067f, 0.03128967f, -0.00343434f, -0.00792293f, 0.00755659f, -0.07617560f, -0.01841049f, -0.03627924f, 
    -0.03457447f, 0.01090660f, 0.02863591f, 0.00402324f, -0.36073205f, 0.05639531f, 0.05722168f, -0.08319408f, 
    -0.03788979f, 0.01524014f, -0.04604958f, -0.00507737f, -0.11315359f, -0.06046794f, -0.00719164f, -0.02535648f, 
    -0.02049169f, -0.35708094f, -0.02030102f, -0.03953281f, -0.04255896f, -0.01592168f, -0.09147257f, -0.02682292f, 
    -0.07746675f, 0.00047761f, 0.00478903f, -0.05666397f, 0.03356936f, -0.16131073f, 0.12405924f, -0.12051793f, 
    0.08139237f, 0.01771527f, 0.00004611f, -0.02319657f, -0.03223579f, 0.02821591f, -0.00456278f, -0.06059401f, 
    -0.15010314f, 0.01822463f, -0.13362779f, -0.17269020f, 0.03354826f, 0.00886183f, -0.05384959f, -0.06371920f, 
    -0.08076981f, -0.00922239f, -0.01946019f, -0.06281373f, 0.02493857f, 0.07152121f, -0.03176333f, 0.07305703f, 
    0.05056420f, 0.00400490f, -0.00789658f, 0.00793749f, 0.08603617f, -0.09726640f, -0.00028473f, -0.12584339f, 
    0.07217603f, -0.04342868f, 0.03101269f, -0.11258851f, -0.02429631f, -0.02176726f, -0.02343497f, 0.01102794f, 
    0.05472354f, 0.03467316f, -0.05023728f, -0.03818508f, 0.17626980f, -0.11077945f, 0.09729034f, 0.03392513f, 
    0.03339269f, -0.08219645f, -0.00193152f, -0.06275162f, -0.00594126f, -0.12014899f, -0.11215525f, -0.04287178f, 
    0.11144414f, 0.16569939f, -0.12655030f, 0.10993771f, 0.02512518f, -0.02207246f, -0.03802360f, 0.05921840f, 
    -0.02452227f, -0.00683228f, 0.06230154f, -0.03917836f, 0.32508633f, 0.15551513f, 0.01392195f, 0.08565808f, 
    0.06574193f, -0.05289118f, -0.00637905f, -0.08958480f, -0.06036632f, 0.07935593f, 0.00637968f, -0.06711672f, 
    -0.05055449f, -0.13418300f, -0.09236180f, -0.11113077f, 0.02988423f, -0.00068672f, -0.07117029f, -0.07442607f, 
    -0.01402023f, 0.04388935f, -0.11512762f, -0.04291295f, 0.14842802f, 0.17815097f, 0.09847684f, 0.25428924f, 
    0.11468450f, 0.03188362f, 0.09478909f, -0.00626846f, -0.04401703f, 0.00665611f, -0.10936981f, -0.01525648f, 
    -0.24756086f, 0.05374399f, -0.01271889f, -0.00313483f, -0.10822096f, -0.01009660f, 0.06521097f, -0.01978921f, 
    0.03902115f, 0.02981599f, 0.00033798f, -0.04537400f, 0.06370373f, -0.27393341f, 0.10007426f, 0.01998280f, 
    -0.10016055f, -0.06031974f, -0.00324263f, -0.04199774f, -0.06084180f, -0.04463330f, 0.00403967f, -0.04555064f, 
    -0.28222504f, 0.02024559f, -0.19187516f, -0.25353357f, 0.07526027f, 0.07500238f, -0.03748903f, -0.06981271f, 
    -0.16962031f, 0.01410282f, 0.05075563f, -0.04046205f, -0.05375967f, 0.00672012f, -0.05693763f, 0.05183152f, 
    -0.05188864f, -0.02978188f, -0.02117171f, -0.02379141f, 0.03378438f, -0.09156350f, 0.06013121f, 0.03288015f, 
    0.14647484f, -0.14298272f, 0.15015639f, -0.10652780f, 0.01411268f, -0.00679836f, -0.05323175f, -0.13689072f, 
    -0.02269178f, 0.07111694f, -0.00413842f, -0.00953981f, 0.14462490f, -0.23870136f, -0.05184759f, -0.16045132f, 
    0.04354658f, -0.10494576f, -0.02212072f, -0.03865958f, -0.01233651f, -0.05397011f, 0.03186702f, -0.01701229f, 
    0.04977051f, 0.06724703f, -0.00206850f, -0.00503439f, -0.05525097f, -0.00370941f, -0.03637395f, -0.09326316f, 
    -0.07420855f, 0.00702210f, -0.06077917f, -0.03175160f, 0.00266708f, 0.04252317f, -0.07100810f, -0.04678956f, 
    -0.05084730f, -0.05673634f, -0.01929168f, 0.02626518f, 0.02824007f, -0.02510264f, 0.04731765f, 0.01562302f, 
    0.05549778f, 0.08644421f, 0.09774005f, -0.02319761f, -0.15652211f, 0.09969378f, 0.04601125f, -0.00401184f, 
    -0.05390532f, -0.07517497f, -0.08574011f, -0.11477892f, -0.10922523f, 0.09667300f, 0.04012187f, 0.09272575f, 
    0.10883291f, 0.05228527f, -0.01750595f, -0.10012292f, -0.05120486f, -0.00681745f, 0.00224920f, -0.06228117f, 
    0.01904683f, 0.02250016f, 0.08610985f, 0.05496091f, 0.00390312f, -0.01217707f, -0.01102569f, -0.08759625f, 
    -0.01722927f, 0.05178736f, -0.04341944f, -0.02978719f, 0.09563404f, 0.02331825f, -0.05135290f, 0.09549294f, 
    0.07725122f, -0.12075246f, -0.03890245f, -0.01933043f, 0.01965205f, -0.03972653f, -0.07036266f, -0.04354663f, 
    0.03968024f, -0.03674078f, 0.06660817f, -0.05687870f, 0.05418799f, 0.00438505f, -0.00601724f, -0.02351110f, 
    -0.02169351f, 0.01957018f, 0.01120788f, -0.01464421f, 0.03045844f, 0.12983133f, -0.03233784f, 0.04621868f, 
    -0.06902915f, -0.00078366f, -0.07112867f, -0.03476782f, -0.12876673f, 0.04106404f, -0.02582284f, -0.07905593f, 
    -0.10210519f, 0.00074875f, -0.00767637f, -0.00001443f, 0.00668743f, -0.04259015f, 0.01855920f, -0.00974495f, 
    -0.05150184f, -0.00909610f, 0.07248298f, 0.07639432f, 0.29359144f, -0.01667776f, 0.10572537f, 0.03723772f, 
    0.03013859f, -0.06568401f, 0.00206596f, 0.01775993f, -0.00950689f, 0.07110524f, 0.02348330f, -0.08275830f, 
    0.00995881f, 0.09959881f, 0.11914609f, 0.08279332f, -0.00540653f, -0.01005303f, 0.10781349f, 0.01467779f, 
    -0.05870273f, 0.02971756f, -0.05171898f, -0.03564835f, -0.02068140f, 0.18394160f, -0.00369645f, 0.22626466f, 
    0.08317302f, -0.05368759f, 0.03290826f, 0.04290097f, 0.02950358f, 0.02392997f, 0.03091829f, -0.04622908f, 
    0.13440177f, 0.09118935f, 0.14757667f, 0.01356851f, -0.05665945f, 0.00942775f, 0.00105042f, -0.11511648f, 
    -0.02250136f, 0.02183102f, -0.08745572f, 0.00328300f, 0.03895018f, 0.17919435f, 0.12463434f, 0.14270370f, 
    0.09705663f, 0.08950950f, 0.14266492f, -0.07607495f, 0.01081785f, 0.02434632f, -0.01172369f, -0.06361992f, 
    -0.13900052f, -0.06513378f, -0.14980306f, -0.13398024f, -0.04195580f, 0.00789683f, -0.03258656f, -0.01585713f, 
    -0.11969963f, -0.01622223f, -0.02198467f, -0.04586487f, 0.16193970f, 0.16547538f, -0.01342253f, 0.19730799f, 
    0.03835685f, 0.02695121f, 0.01019823f, 0.02664485f, -0.07752316f, -0.01152431f, -0.01885618f, -0.03265702f, 
    -0.26338068f, 0.15976535f, -0.10843514f, -0.01548003f, -0.23941064f, -0.08733180f, -0.00613964f, -0.10377748f, 
    -0.00109391f, -0.05967334f, 0.08187407f, -0.10239271f, 0.11812089f, 0.14002872f, 0.10460450f, 0.17364781f, 
    0.12157638f, 0.00909599f, -0.04256422f, 0.01795653f, -0.05456136f, 0.01392295f, -0.00639213f, -0.02310546f, 
    -0.22441325f, -0.05046071f, -0.21182862f, -0.11416593f, 0.00737615f, 0.01130349f, -0.01880751f, -0.04911885f, 
    -0.08052684f, -0.06153560f, 0.00557471f, -0.04197088f, 0.23366183f, 0.04035737f, -0.05305298f, 0.04870811f, 
    -0.06247750f, -0.07029527f, -0.00261004f, -0.07508553f, 0.02865816f, -0.00703921f, -0.02495156f, -0.05076617f, 
    0.15760165f, 0.11843687f, 0.13407244f, 0.14948913f, 0.05444567f, 0.04251399f, 0.00240142f, 0.03865738f, 
    0.02273717f, 0.00229689f, 0.02770888f, -0.01717444f, 0.12584774f, 0.02500673f, 0.12154904f, 0.02865815f, 
    -0.03074919f, 0.02418552f, 0.03309884f, -0.02674088f, -0.06823549f, 0.04876438f, -0.07497293f, -0.07513237f, 
    -0.15354861f, 0.04627334f, -0.01948399f, 0.13136756f, 0.07419315f, -0.00788095f, -0.02254987f, -0.03318537f, 
    0.00927639f, 0.00164249f, -0.02571544f, 0.00042982f, -0.24885049f, 0.08173825f, 0.12713288f, -0.03898326f, 
    0.06199798f, 0.00188669f, -0.09065505f, -0.02495459f, -0.03661644f, 0.04346419f, 0.11658890f, 0.00724467f, 
    0.10492875f, 0.10723526f, 0.08651781f, 0.18322194f, 0.08736747f, 0.04944532f, 0.00106612f, 0.03804730f, 
    -0.00478404f, -0.07563519f, 0.01480311f, -0.07113239f, 0.16007382f, -0.06834000f, -0.06847986f, -0.05788207f, 
    0.04732001f, -0.04149036f, -0.09227942f, -0.03733009f, -0.07558486f, 0.00102495f, -0.02549877f, -0.05348766f, 
    0.02954130f, 0.08392993f, 0.06184479f, 0.11563877f, 0.11899232f, -0.06959520f, -0.05097066f, -0.08078343f, 
    -0.04937892f, -0.03909656f, -0.01314232f, -0.01801844f, 0.09352346f, -0.09766626f, 0.08087519f, 0.11693766f, 
    0.10343725f, 0.00744829f, 0.05082931f, 0.03789170f, 0.00855929f, 0.07674825f, 0.00202658f, -0.02266502f, 
    -0.23296767f, 0.01323744f, 0.08342511f, -0.03691627f, -0.03636207f, 0.07517788f, -0.01236843f, -0.00177061f, 
    -0.03435664f, 0.00205555f, 0.02952065f, -0.00224659f, -0.22985835f, -0.05038851f, -0.01646459f, -0.07255284f, 
    -0.08900940f, 0.01289054f, 0.00078957f, -0.00828122f, -0.00768027f, 0.01462515f, -0.01535851f, -0.06309492f, 
    0.02373573f, 0.02187736f, -0.03532036f, -0.09314337f, -0.09546386f, 0.04432127f, 0.01155164f, -0.06295057f, 
    0.00959979f, -0.05691927f, -0.08853663f, -0.04956523f, 0.02598687f, -0.02245682f, -0.04576481f, -0.07230543f, 
    0.01854601f, 0.01538984f, -0.01814524f, -0.04881895f, -0.10572380f, 0.00485879f, -0.00272556f, -0.07773949f, 
    -0.01122891f, -0.13699129f, -0.13369200f, -0.09331026f, -0.02864724f, -0.05686060f, -0.05152714f, -0.04257812f, 
    0.03006256f, -0.05853515f, -0.01309346f, -0.06514453f, -0.24076429f, 0.01847370f, -0.06957845f, 0.00104010f, 
    -0.12093418f, -0.07672861f, -0.00106771f, -0.06118705f, 0.02230504f, -0.04872318f, -0.07963277f, -0.04671033f, 
    -0.02830167f, 0.14765115f, -0.15074901f, -0.13266395f, 0.01741411f, 0.07307914f, -0.08644469f, 0.00576071f, 
    0.05887738f, -0.07757059f, 0.12041394f, -0.01568343f, -0.21034062f, -0.05085540f, -0.04702334f, 0.01512080f, 
    -0.09565191f, -0.09977373f, 0.04806141f, -0.01822994f, -0.03742732f, 0.10536029f, 0.03332024f, 0.01760337f, 
    0.14495647f, -0.17924912f, 0.12405171f, 0.09131215f, -0.03552965f, -0.00371450f, 0.01399540f, -0.04995086f, 
    0.02393281f, -0.05160607f, 0.03211910f, -0.05325830f, 0.03493236f, -0.21643382f, -0.03922822f, -0.09495427f, 
    -0.02754302f, -0.02619527f, -0.00491204f, -0.02947894f, 0.07134654f, -0.00656098f, 0.07499506f, 0.04016190f, 
    -0.06237751f, -0.09302559f, -0.08032889f, -0.28431427f, -0.07192257f, -0.05634867f, 0.02249683f, -0.00347656f, 
    -0.02194361f, 0.01914669f, 0.06947980f, -0.01384386f, 0.15536839f, 0.07601860f, -0.02268385f, -0.08249031f, 
    0.05263336f, -0.04072806f, 0.01351928f, 0.05952561f, 0.03982431f, 0.07248476f, -0.02352161f, 0.17412502f, 
    0.20211121f, 0.01846929f, -0.04458318f, 0.10082345f, 0.07573452f, 0.00534188f, 0.07003346f, -0.05160869f, 
    -0.04179875f, 0.07980661f, -0.03963939f, -0.02329567f, -0.06588174f, -0.20252119f, 0.05038987f, 0.11672767f, 
    0.12982166f, -0.04145543f, -0.04017321f, -0.05348789f, 0.01499721f, 0.01757904f, 0.03582697f, -0.03240945f, 
    0.01980006f, 0.09737918f, -0.15145724f, -0.02588479f, -0.01413822f, -0.03724657f, 0.02963932f, -0.03379697f, 
    0.08151764f, 0.06752302f, -0.01513268f, -0.02536505f, 0.07715173f, -0.09862523f, 0.10795900f, -0.04566626f, 
    0.05573045f, -0.03593485f, -0.04192367f, 0.02395944f, -0.00586921f, -0.00565504f, 0.03821586f, -0.06271135f, 
    -0.06628758f, 0.21952465f, -0.21429083f, -0.11158373f, 0.05945132f, 0.03784966f, -0.14880119f, -0.00531067f, 
    0.04108470f, 0.02033643f, -0.02478318f, 0.12947683f, 0.05822359f, 0.10418700f, 0.09541366f, 0.05184224f, 
    0.11168790f, 0.11207400f, 0.00218829f, 0.13575873f, -0.01731530f, 0.01828987f, 0.02878501f, 0.14148027f, 
    0.10397432f, -0.16739690f, -0.06904297f, -0.02471013f, -0.04329828f, -0.02882956f, 0.02165211f, -0.00432189f, 
    0.03112949f, -0.15374914f, 0.06106882f, 0.11497857f, -0.01801913f, -0.10832050f, 0.13442422f, 0.13439283f, 
    -0.00077053f, -0.14060077f, -0.12712862f, 0.06217960f, 0.00468015f, -0.00310040f, -0.09259292f, 0.06920858f, 
    0.24314411f, -0.16771702f, -0.09778045f, -0.14616370f, 0.09709906f, 0.05172902f, 0.01755579f, -0.06997076f, 
    0.09286107f, -0.01533258f, -0.09715369f, 0.05582406f, -0.18333466f, 0.09240001f, -0.02807448f, 0.07464249f, 
    -0.12185880f, -0.01955157f, 0.02265342f, -0.06673344f, 0.06249288f, -0.01835010f, -0.06053143f, 0.11874098f, 
    0.09093361f, -0.11068733f, 0.03531510f, 0.10453482f, 0.03815373f, 0.07211746f, -0.05526293f, -0.06824055f, 
    0.01568344f, 0.01774145f, 0.00307692f, -0.07941379f, 0.11151895f, 0.09730909f, -0.18289757f, -0.04796908f, 
    -0.02089812f, -0.11878385f, 0.05207324f, -0.02916194f, -0.08338535f, -0.00670310f, -0.06319959f, 0.08918099f, 
    0.01773337f, -0.04462538f, -0.09824079f, 0.08467168f, -0.03991512f, -0.06793110f, -0.01989329f, 0.04090099f, 
    0.00423288f, 0.03704930f, 0.12021803f, 0.07070886f, 0.19380793f, 0.20778377f, -0.10429347f, 0.12864912f, 
    0.08002882f, -0.00989988f, -0.03759670f, -0.03479121f, -0.04804176f, -0.02356468f, -0.03418373f, 0.07056079f, 
    0.01235640f, 0.17860557f, -0.10853144f, 0.04554618f, 0.08986142f, 0.00431314f, -0.00893115f, -0.04087804f, 
    -0.04442926f, 0.02956308f, 0.02148687f, 0.01485117f, -0.10916998f, 0.00509207f, 0.06103540f, -0.16052689f, 
    0.01286386f, -0.00464251f, -0.02812121f, 0.20077972f, -0.01130962f, -0.00676068f, 0.08982234f, -0.13158584f, 
    0.18209034f, 0.00059169f, -0.02011254f, 0.10763564f, -0.02012336f, -0.06525022f, -0.04683549f, -0.13488044f, 
    0.01197910f, -0.09800109f, -0.09899779f, -0.05926607f, -0.23594967f, -0.07969331f, 0.15321398f, -0.13478774f, 
    0.05574840f, 0.07164482f, -0.04480608f, -0.05280147f, -0.02928620f, -0.04062153f, 0.04059266f, -0.15140116f, 
    -0.01614784f, 0.05713380f, -0.05122459f, 0.00248327f, -0.06696350f, -0.01005600f, -0.04145526f, -0.08775990f, 
    0.05657923f, 0.02312420f, 0.03199467f, 0.12920484f, 0.08417437f, -0.17231075f, -0.13611500f, 0.13685645f, 
    0.00435843f, 0.03180207f, -0.02752969f, -0.01305592f, 0.02192284f, 0.05074246f, 0.04425304f, 0.00891761f, 
    0.01201512f, -0.10097814f, 0.06340260f, 0.13664375f, 0.16079161f, 0.10650410f, -0.05081752f, 0.00846941f, 
    -0.04059860f, 0.00520364f, 0.00285198f, -0.06165024f, 0.15850522f, 0.20642582f, -0.17155738f, -0.11663389f, 
    -0.04713129f, -0.05931511f, -0.01728910f, -0.02969805f, 0.05164566f, 0.05687054f, -0.16851966f, -0.05395439f, 
    -0.09139387f, -0.14989710f, -0.03413134f, -0.26895416f, -0.04592929f, -0.06674553f, -0.12690797f, -0.14617682f, 
    -0.04046122f, 0.03009512f, 0.12085030f, 0.12595242f, 0.09957127f, -0.13360956f, -0.11564207f, 0.01795342f, 
    -0.00374874f, 0.02596095f, -0.02329035f, -0.07284105f, 0.10120780f, 0.01398025f, 0.11471933f, -0.03828634f, 
    -0.13204570f, 0.12642162f, 0.08995448f, 0.15733293f, -0.23886010f, 0.00417672f, -0.12063357f, 0.05009162f, 
    0.08240911f, 0.06511865f, -0.02174047f, 0.04198925f, 0.14520967f, 0.01840171f, -0.01187196f, 0.03230466f, 
    -0.07099856f, -0.12124516f, -0.06713790f, 0.07035843f, -0.00582616f, 0.04057597f, -0.00237240f, -0.10254425f, 
    -0.01581670f, 0.01027595f, 0.09958136f, 0.06882387f, -0.10588516f, 0.04073786f, -0.03327577f, 0.13406742f, 
    0.03726966f, -0.02638255f, -0.06083852f, -0.18155427f, -0.09663256f, -0.11202588f, 0.21743546f, 0.01172019f, 
    -0.07807886f, -0.08733036f, -0.18277119f, 0.06450598f, 0.02912202f, -0.05665193f, -0.05840632f, 0.02207049f, 
    -0.22544453f, -0.12506479f, -0.27049875f, -0.29196566f, -0.03626778f, -0.03643496f, -0.03395292f, 0.01464716f, 
    0.02775876f, -0.09597133f, 0.02818649f, -0.03625487f, 0.14735985f, 0.02826128f, -0.06548562f, -0.22709119f, 
    -0.02095025f, -0.02806242f, -0.08586314f, 0.00861507f, 0.00844890f, 0.06258538f, -0.01159183f, 0.13459952f, 
    -0.00945657f, -0.07863888f, 0.09340686f, -0.05173957f, -0.03016699f, -0.17215697f, -0.01856078f, -0.03176569f, 
    -0.03063650f, 0.06964652f, -0.04837116f, -0.00557756f, -0.11687378f, 0.02868758f, 0.03109763f, -0.07786563f, 
    -0.05686959f, -0.10792509f, 0.02923056f, 0.05056961f, 0.07375965f, -0.15267769f, -0.02192996f, -0.06506442f, 
    0.04550101f, 0.01834085f, 0.00041219f, 0.11495291f, 0.05905158f, 0.00215161f, -0.03221476f, -0.06484388f, 
    0.13299616f, -0.10253010f, -0.05254957f, -0.08646560f, -0.04453731f, -0.19638179f, 0.10477296f, -0.16004296f, 
    0.02284202f, -0.21143751f, 0.05825585f, -0.08126535f, 0.01430739f, 0.13092169f, -0.13700482f, 0.09020267f, 
    0.02505944f, 0.03010472f, 0.10032297f, 0.03975897f, -0.10797038f, 0.10257242f, -0.06297700f, 0.11084329f, 
    -0.01672795f, -0.04236380f, -0.07121258f, -0.17176802f, 0.06471422f, 0.13954504f, 0.03325364f, -0.00848922f, 
    0.06340506f, -0.04370203f, 0.11308482f, 0.02847619f, 0.03445633f, -0.07153108f, -0.05159672f, 0.08487925f, 
    -0.24201120f, 0.11299710f, 0.07123839f, -0.12974618f, -0.05130470f, 0.04177944f, 0.00175033f, 0.00545532f, 
    0.04957350f, 0.07941556f, 0.01359798f, -0.05539252f, -0.08508055f, -0.07712032f, 0.18855983f, 0.10263286f, 
    -0.11055798f, 0.08936167f, -0.08738924f, -0.01522249f, 0.03884668f, -0.11902633f, 0.02804415f, 0.11955918f, 
    0.06720020f, 0.02449449f, -0.04948045f, -0.03601359f, 0.11519459f, 0.05704028f, -0.09330330f, -0.08309940f, 
    -0.00728907f, 0.05084100f, -0.07189362f, -0.04231775f, -0.19217516f, 0.14695932f, -0.02372753f, -0.30636430f, 
    -0.02498106f, 0.03256537f, -0.02553696f, 0.01048692f, 0.04905423f, -0.01587215f, 0.00305820f, -0.11889052f, 
    0.03606635f, -0.09665487f, -0.16647705f, 0.03425991f, 0.05828150f, -0.04313440f, -0.05116441f, -0.05703487f, 
    0.04236168f, 0.05000873f, 0.01127191f, -0.00961868f, -0.24198109f, 0.13671592f, 0.01882443f, -0.20244084f, 
    -0.00095016f, -0.02983618f, 0.01135439f, 0.00558602f, 0.09791385f, -0.15850961f, -0.04428053f, -0.00313972f, 
    -0.01796013f, -0.02247309f, -0.02200703f, 0.12767734f, -0.03022359f, -0.00936209f, -0.05098937f, 0.00701087f, 
    0.04989539f, 0.07921318f, 0.07406313f, -0.01026429f, 0.09089102f, -0.14896113f, 0.03987864f, -0.16075629f, 
    -0.04233469f, -0.14324453f, -0.05953473f, 0.02094750f, 0.02718685f, 0.02825224f, 0.03349369f, -0.04713669f, 
    0.01926599f, -0.07283665f, 0.05234988f, -0.12423752f, -0.07651798f, -0.09418215f, 0.10101499f, -0.02046742f, 
    -0.04791828f, -0.07373699f, -0.07922421f, -0.00129304f, -0.05701622f, 0.03106827f, 0.00505953f, 0.07818004f, 
    -0.10325831f, -0.03792346f, -0.07388024f, -0.07101358f, -0.01060900f, -0.01144381f, -0.06547125f, 0.02096960f, 
    -0.05886351f, -0.03134650f, -0.05709831f, -0.02155896f, 0.10835791f, -0.09561741f, -0.10581395f, -0.04963534f, 
    0.11737831f, 0.09176385f, -0.00593723f, -0.07024917f, 0.04826936f, -0.14158270f, 0.13766032f, 0.11473318f, 
    -0.10137514f, -0.09644625f, -0.06613845f, -0.01445974f, -0.02635689f, -0.07473859f, -0.18355785f, -0.20234278f, 
    0.01850025f, -0.05115604f, 0.11498542f, -0.04681567f, -0.02226100f, -0.03353979f, 0.09555212f, 0.00091879f, 
    -0.02500032f, 0.04928895f, -0.06541912f, 0.01721881f, 0.02491528f, -0.17415868f, -0.10745650f, -0.18206397f, 
    -0.04968864f, -0.01471904f, -0.02394204f, -0.01338071f, 0.02940254f, 0.05194333f, 0.08477644f, -0.02250626f, 
    -0.11399564f, -0.06798892f, -0.12663865f, -0.18985489f, -0.00760812f, 0.00879437f, -0.18497337f, -0.07195793f, 
    0.01262363f, -0.01287746f, 0.04786235f, -0.03545455f, -0.29488593f, 0.01144340f, 0.04918719f, -0.09335129f, 
    0.08266179f, -0.01367391f, -0.07915601f, -0.09984288f, 0.00154201f, -0.08817139f, -0.01656114f, 0.17997986f, 
    -0.12275705f, -0.03877773f, -0.02994557f, -0.14979847f, -0.14766566f, -0.07036769f, 0.01800492f, -0.10240403f, 
    0.05976898f, -0.04915456f, -0.07688998f, 0.04500081f, 0.07484227f, 0.09758056f, -0.09563320f, 0.07454151f, 
    0.03981141f, 0.03388084f, -0.01726928f, -0.01359814f, 0.01109426f, 0.05616689f, 0.00356369f, -0.03293525f, 
    0.13070054f, 0.03628074f, 0.10158771f, 0.19402254f, 0.04968166f, -0.04901893f, -0.06190305f, -0.00716078f, 
    -0.01160173f, 0.04958507f, 0.05897324f, -0.11988514f, -0.19092239f, -0.26764581f, 0.13873337f, 0.06910139f, 
    0.01746609f, 0.01277518f, -0.02775185f, 0.05180577f, 0.05911851f, 0.01639987f, 0.06633012f, 0.05649676f, 
    0.10811394f, -0.04205462f, -0.10802787f, 0.15064636f, 0.15837458f, 0.01382317f, 0.04159890f, 0.00552756f, 
    0.09276868f, 0.03816231f, -0.01815963f, 0.11297370f, 0.04613266f, 0.03957746f, -0.02274471f, 0.20653327f, 
    0.02096008f, -0.04831552f, -0.08130097f, -0.01891858f, 0.08392919f, 0.00459878f, 0.05701841f, 0.03795489f, 
    -0.16803078f, -0.02800637f, 0.14708401f, -0.00604860f, 0.03350824f, -0.06984074f, -0.01133534f, 0.08231691f, 
    0.07560284f, -0.04137261f, -0.03969914f, 0.02835093f, -0.20782554f, 0.22565019f, -0.01931326f, -0.12405173f, 
    0.05817519f, 0.09544525f, 0.09647436f, 0.00716650f, -0.05179917f, 0.08160651f, -0.01619251f, 0.05133044f, 
    -0.05582256f, 0.08286268f, 0.02168031f, 0.02825864f, 0.12571399f, 0.01647929f, 0.09387997f, -0.01802526f, 
    0.02135414f, 0.05005078f, -0.06340777f, -0.01294853f, 0.05287868f, -0.15800016f, 0.25225496f, -0.23675331f, 
    -0.03913818f, 0.02554635f, -0.04447136f, 0.06858179f, -0.08069202f, -0.02887586f, -0.15600376f, -0.01935492f, 
    0.19764733f, -0.07515361f, -0.09561092f, -0.00269410f, 0.08212894f, 0.00454801f, -0.05409867f, -0.04425085f, 
    -0.00176081f, -0.02546035f, -0.01122281f, 0.00051845f, -0.35343015f, 0.00146020f, -0.23029113f, 0.12623450f, 
    0.12926273f, 0.08032687f, 0.10566466f, -0.01229927f, -0.10851873f, 0.01539842f, 0.04771757f, -0.00314834f, 
    0.07428064f, 0.07913382f, -0.01807638f, -0.27874777f, 0.08779099f, 0.03010201f, 0.00650691f, -0.26696786f, 
    -0.00493137f, 0.10284607f, 0.13778056f, -0.17436814f, -0.36023402f, 0.04712930f, -0.04983817f, -0.21896656f, 
    0.05541512f, -0.12533897f, 0.07689013f, 0.02487231f, -0.00308049f, -0.05073859f, -0.06630463f, -0.01714273f, 
    -0.17799661f, -0.05421567f, -0.04687674f, 0.07018441f, 0.02919563f, 0.05621605f, -0.13884364f, 0.04590085f, 
    -0.13492398f, 0.05380551f, -0.00136057f, -0.04379858f, -0.04708710f, 0.08738686f, 0.01300162f, -0.00941966f, 
    -0.06779056f, 0.00026235f, 0.04364107f, 0.00892244f, 0.03300019f, 0.05475568f, -0.03332815f, 0.12798971f, 
    -0.02395003f, -0.18939760f, 0.10345944f, -0.28270954f, -0.06682280f, 0.06005957f, -0.03100452f, 0.18136887f, 
    0.06205783f, 0.00964981f, 0.06307320f, -0.00927558f, 0.08701749f, 0.27030388f, 0.07974444f, -0.08972785f, 
    -0.07818276f, -0.05737480f, 0.00158774f, -0.10742410f, 0.13186593f, 0.03935595f, 0.00871994f, -0.02557418f, 
    0.14437176f, 0.06550857f, -0.11206418f, -0.15491159f, 0.02965957f, -0.00006807f, -0.00897570f, 0.01608068f, 
    0.05953525f, 0.09448109f, -0.11241654f, 0.05495478f, -0.45600700f, -0.01690148f, -0.06884938f, 0.20963643f, 
    -0.02594848f, 0.00693318f, 0.01015055f, 0.03070578f, 0.01794702f, 0.02009315f, 0.02449493f, 0.05815092f, 
    0.47909424f, -0.07972252f, 0.25175416f, 0.06157859f, -0.01195852f, 0.03721992f, -0.02257871f, -0.04824260f, 
    -0.05477377f, -0.01901878f, 0.01873292f, 0.09808008f, 0.29456678f, -0.17666087f, -0.06739775f, 0.11642699f, 
    -0.08774152f, 0.01109709f, -0.06374998f, -0.04252286f, 0.02557873f, -0.00969997f, 0.02558931f, -0.12292699f, 
    0.00696854f, 0.08485854f, 0.09180848f, -0.17357437f, 0.10548466f, 0.04434959f, -0.06938832f, -0.07951093f, 
    0.02949319f, -0.03096510f, 0.14077629f, -0.06295650f, -0.21172900f, -0.03898260f, 0.05096592f, -0.00709696f, 
    0.02459374f, 0.07472140f, 0.02966810f, 0.03544017f, -0.00352408f, -0.10384348f, 0.04242191f, 0.01699722f, 
    -0.00189522f, 0.11755770f, -0.14896819f, -0.13308080f, 0.05840494f, -0.02333426f, 0.02879112f, -0.10059217f, 
    -0.02671888f, -0.02346437f, -0.08410395f, -0.06795748f, 0.30624014f, -0.34060776f, 0.18825628f, -0.06239716f, 
    0.04010494f, -0.01899527f, -0.04765820f, -0.04891230f, -0.09598432f, 0.14788443f, 0.06303832f, -0.03391839f, 
    -0.08736826f, -0.15595552f, 0.25422037f, -0.25424507f, -0.06270940f, -0.03621326f, 0.05092023f, -0.04711086f, 
    0.12248178f, -0.01710872f, 0.00912924f, 0.00079931f, 0.12575911f, -0.01032549f, -0.00443161f, 0.12411083f, 
    -0.04149753f, -0.08065471f, -0.02025694f, 0.07887457f, 0.01812350f, 0.07950902f, 0.00700263f, 0.07207402f, 
    0.04546305f, 0.04482129f, -0.08042262f, -0.05576055f, 0.10984942f, 0.21273497f, 0.03085026f, -0.02925911f, 
    -0.10307829f, 0.00359439f, -0.09265590f, -0.05069641f, 0.06281374f, -0.04851875f, 0.06901924f, 0.00150969f, 
    0.04623534f, -0.05706087f, -0.13845840f, 0.01719126f, 0.01810384f, -0.06448679f, 0.06454353f, 0.03385180f, 
    -0.06948195f, 0.33719307f, -0.05822022f, 0.07122796f, 0.10765646f, -0.04813953f, -0.10929117f, -0.01725643f, 
    -0.04314613f, 0.02679840f, -0.09560037f, -0.02344379f, -0.01385442f, -0.07876548f, -0.06699408f, -0.25493535f, 
    -0.01100749f, -0.01895959f, -0.07558464f, 0.01213080f, 0.15833344f, 0.01047765f, -0.01533848f, -0.09874488f, 
    -0.01696271f, 0.14993559f, 0.11704105f, -0.40919954f, -0.07190025f, 0.05857681f, -0.01834703f, -0.04052335f, 
    0.00438059f, -0.12310454f, -0.06057278f, -0.06049344f, -0.11917220f, 0.10992231f, 0.12824444f, 0.19756129f, 
    0.01429597f, 0.06752226f, -0.03836971f, 0.09729428f, -0.00662873f, 0.02113594f, 0.14168355f, 0.09373654f, 
    0.25680518f, -0.21338108f, -0.23242188f, 0.22625880f, -0.01177584f, -0.01161702f, 0.00970864f, 0.00932237f, 
    -0.01355060f, -0.12079164f, 0.10962337f, -0.12584469f, 0.20027110f, -0.24783446f, 0.09677032f, 0.03304189f, 
    0.00525179f, 0.15102135f, 0.04945436f, -0.04833207f, -0.11191417f, -0.11446831f, -0.11502109f, 0.00836593f, 
    -0.01808590f, 0.12083901f, 0.00710885f, 0.03085962f, 0.01243823f, 0.06039288f, 0.03422992f, 0.07329623f, 
    0.06409656f, 0.04212161f, -0.00304518f, -0.01023425f, -0.13671367f, -0.14197728f, 0.08960246f, -0.12678266f, 
    0.04700750f, 0.04427097f, 0.09451450f, -0.04612655f, 0.14275639f, 0.04200035f, 0.02251398f, 0.18470746f, 
    0.09656198f, 0.16673842f, -0.07935948f, 0.24520285f, 0.01259386f, -0.08339278f, -0.03952237f, -0.17175439f, 
    -0.10086413f, 0.03523855f, -0.00765502f, 0.20630810f, -0.28822061f, -0.35662159f, -0.03956252f, -0.10750535f, 
    0.07178482f, 0.09540731f, 0.02483631f, 0.01404785f, -0.01071606f, 0.06792491f, -0.05143532f, -0.15421183f, 
    -0.11250035f, -0.00930410f, -0.21217057f, 0.10195678f, -0.07250655f, 0.01740968f, 0.02900053f, 0.00402529f, 
    0.04177077f, 0.06535726f, -0.12793794f, -0.03633810f, -0.02175958f, -0.04493413f, 0.02272482f, -0.21861704f, 
    -0.11110560f, -0.09943616f, 0.02706814f, -0.01327412f, 0.00687223f, -0.00220026f, 0.01583046f, -0.11503094f, 
    0.13044515f, 0.03443430f, 0.16099688f, 0.09630822f, -0.00803110f, 0.02664193f, 0.04549065f, 0.02583744f, 
    -0.01767668f, -0.01515680f, -0.10125237f, 0.07002921f, -0.48781198f, 0.15172870f, 0.09824859f, 0.02363945f, 
    0.02416815f, 0.00509333f, -0.08159322f, -0.12389516f, -0.02051647f, 0.07120149f, 0.04230546f, 0.05522758f, 
    -0.28350368f, -0.06703541f, 0.12028931f, -0.27970827f, 0.08764111f, -0.00154900f, -0.10158903f, -0.05027292f, 
    -0.19159289f, -0.03828632f, 0.15317813f, 0.07627210f, 0.09203597f, 0.16227594f, -0.04285593f, 0.08164911f, 
    -0.09632345f, 0.09839090f, -0.03812863f, -0.04229989f, 0.01604800f, 0.02416777f, 0.09384692f, -0.06825405f, 
    -0.20294210f, -0.09452467f, 0.09842815f, -0.02240790f, 0.13417876f, -0.01564455f, 0.02712352f, 0.01304890f, 
    -0.02234933f, 0.08348164f, -0.03903807f, 0.08530559f, -0.58341032f, -0.29299518f, 0.14805599f, 0.00889868f, 
    0.00480566f, -0.03739075f, -0.03665599f, -0.00630730f, 0.07157512f, -0.06166086f, 0.14546868f, 0.05379794f, 
    -0.04280768f, -0.22606117f, 0.02176152f, 0.08030869f, -0.05766049f, 0.00051758f, 0.07339825f, 0.02045283f, 
    0.04505477f, 0.00184695f, -0.05519439f, -0.07718723f, -0.09742519f, -0.22478662f, -0.05626164f, -0.15729998f, 
    0.05728200f, 0.00772850f, 0.08748596f, 0.05743806f, -0.06714988f, 0.05900903f, -0.04352487f, -0.02651676f, 
    0.09197662f, 0.02966551f, 0.11434837f, -0.03818696f, 0.06960075f, -0.00767361f, 0.04851048f, -0.02495874f, 
    -0.00896124f, 0.02527148f, -0.02340907f, -0.02745615f, -0.36308953f, 0.01709295f, 0.31354362f, -0.10424357f, 
    0.01118877f, -0.01365534f, -0.06520829f, -0.03093170f, 0.02782853f, -0.06618508f, -0.05700252f, 0.18050869f, 
    -0.19997056f, 0.24711539f, 0.26670229f, -0.08967426f, -0.06833791f, -0.04456177f, 0.06544832f, -0.03639829f, 
    -0.19829397f, -0.03464629f, -0.02853129f, -0.07053167f, -0.05818316f, 0.02513956f, -0.02213238f, 0.05903921f, 
    -0.07296985f, 0.09369846f, -0.01755937f, 0.00812808f, -0.00329223f, -0.00947982f, -0.11526481f, -0.00240497f, 
    -0.36727965f, 0.22134763f, -0.19882752f, -0.26256216f, 0.01682385f, -0.08863796f, 0.07511743f, 0.06361189f, 
    0.00549151f, 0.01016370f, -0.07369693f, 0.00984992f, 0.11839829f, 0.27471176f, -0.02099275f, -0.18466437f, 
    0.03833900f, 0.04450747f, 0.12743239f, -0.10823152f, -0.03723250f, 0.06089949f, -0.12757725f, -0.02324713f, 
    0.25186786f, 0.10494526f, 0.04629307f, 0.00104266f, 0.11867830f, -0.05429539f, -0.02396880f, -0.01801552f, 
    -0.11448734f, 0.03505516f, 0.06724168f, 0.03398473f, -0.08385339f, -0.24292015f, -0.09310170f, 0.05891137f, 
    0.03679642f, 0.01355115f, 0.03255287f, -0.09705830f, -0.07224059f, 0.11517417f, -0.00646959f, -0.06924302f, 
    -0.22465195f, -0.06368358f, -0.06771213f, -0.11267135f, 0.04181391f, 0.06955151f, -0.09904908f, 0.06187341f, 
    0.05711966f, -0.12485928f, 0.03253014f, 0.00395600f, 0.08829780f, -0.17699122f, 0.05052944f, 0.04767505f, 
    -0.05625758f, -0.00237960f, -0.10611431f, 0.00802856f, -0.02390054f, 0.05567878f, -0.01141598f, 0.16160977f, 
    0.52901483f, 0.09369314f, -0.02257063f, 0.05929338f, 0.08220363f, -0.14699487f, 0.00228268f, 0.01725163f, 
    -0.01390483f, -0.00010259f, 0.03850935f, 0.07860699f, -0.07552242f, -0.10311820f, 0.07992312f, -0.02295747f, 
    -0.01687112f, 0.04529984f, -0.06492149f, -0.02806883f, -0.03414833f, 0.00890153f, 0.17229241f, 0.03549495f, 
    0.16053833f, -0.57011008f, 0.10915451f, 0.15803583f, -0.16941381f, -0.05766138f, 0.03621857f, 0.18187533f, 
    -0.09092198f, -0.02468270f, 0.09062148f, 0.00954689f, 0.21281123f, -0.26606068f, -0.06324876f, 0.09593355f, 
    -0.03205844f, -0.00614852f, 0.00413917f, 0.23840889f, 0.02361531f, -0.05517443f, 0.14228493f, 0.03862412f, 
    -0.07252378f, 0.11749537f, -0.21746844f, 0.25470063f, 0.11859051f, 0.12091184f, -0.10737503f, 0.12267965f, 
    0.06388994f, 0.09810146f, 0.05639099f, -0.11563339f, -0.25023770f, 0.13517077f, 0.24924248f, 0.12820752f, 
    0.08318704f, -0.06388407f, 0.09142455f, 0.07979911f, 0.12265524f, 0.08557085f, 0.04885980f, -0.02616116f, 
    -0.13981099f, 0.06299639f, -0.11290301f, -0.07540499f, 0.17197837f, 0.06044784f, 0.07437396f, -0.01933358f, 
    -0.03529551f, -0.09258941f, -0.02110301f, -0.01120402f, -0.01822671f, 0.06812334f, -0.22264953f, -0.15434672f, 
    0.00510301f, -0.14760205f, 0.02545789f, -0.06748484f, 0.00237069f, 0.02322218f, -0.04185596f, -0.05784154f, 
    -0.31980041f, 0.09723902f, -0.24257636f, -0.16503793f, 0.09483317f, -0.04824285f, -0.03423719f, -0.06082140f, 
    -0.12639119f, -0.10200908f, -0.09534607f, -0.05882800f, -0.09344308f, 0.30866989f, -0.40432894f, -0.34839553f, 
    0.05432975f, -0.03370832f, 0.04375538f, 0.05611853f, -0.04297381f, 0.01531692f, -0.11279638f, -0.10081185f, 
    -0.28207615f, -0.14347070f, 0.00677814f, -0.04319838f, 0.02779524f, 0.05413227f, -0.04489276f, -0.12099414f, 
    -0.00848090f, -0.07819919f, 0.03110583f, -0.01024393f, 0.11706481f, -0.13475178f, -0.08884411f, 0.06601594f, 
    0.01924798f, -0.17890309f, -0.00116185f, 0.04023616f, -0.01484113f, 0.08998858f, 0.01859458f, 0.10177081f, 
    0.16342667f, 0.11475028f, -0.09140348f, -0.13279565f, -0.11030172f, -0.02238085f, -0.01651630f, 0.11534285f, 
    0.11787637f, -0.03714894f, -0.04127685f, -0.01685200f, 0.15242654f, 0.16450636f, -0.00463787f, -0.01901221f, 
    -0.00794572f, -0.00296323f, -0.00502079f, 0.03793239f, -0.01389918f, 0.09315146f, 0.10763226f, -0.04941488f, 
    0.11096893f, 0.04472222f, 0.01640223f, 0.04448573f, 0.06950270f, 0.00789584f, 0.06713098f, 0.02788381f, 
    0.02443083f, 0.11034091f, 0.04878851f, 0.02527527f, -0.12092542f, -0.06907980f, -0.00767415f, 0.02908051f, 
    0.00609260f, 0.00451732f, 0.04204926f, 0.11374015f, 0.09283295f, -0.00847741f, 0.01834562f, 0.11685511f, 
    -0.13959758f, -0.02440184f, -0.02199666f, -0.06076343f, 0.03099945f, 0.03557641f, -0.04892870f, -0.04901685f, 
    -0.02227559f, -0.05218314f, -0.05119883f, 0.00533896f, -0.58016169f, -0.22438441f, -0.07740494f, -0.12151209f, 
    0.11268362f, 0.05757116f, -0.10374609f, -0.11953375f, 0.01895087f, 0.02960516f, -0.10607990f, -0.00204845f, 
    -0.16371684f, -0.11498798f, 0.02319582f, 0.02550718f, -0.00460863f, -0.06025357f, 0.02832251f, 0.01221960f, 
    0.07411885f, -0.05636347f, 0.07160586f, -0.00714789f, -0.03114792f, 0.00389613f, -0.05023434f, 0.07192621f, 
    0.09000920f, -0.00222008f, -0.06910378f, -0.06023972f, -0.04296123f, 0.01272346f, -0.05732925f, -0.08691248f, 
    0.24423996f, -0.07048239f, 0.00938044f, -0.02359745f, 0.18203071f, 0.01049877f, 0.10101555f, 0.00371663f, 
    0.03183926f, 0.04386657f, -0.08098320f, 0.04496008f, 0.02052153f, -0.07132787f, -0.06644890f, -0.02389202f, 
    -0.00599900f, 0.02235588f, -0.00907684f, 0.10909724f, 0.06205815f, -0.01697334f, -0.00585199f, -0.05438209f, 
    -0.12949264f, -0.02632157f, -0.22062597f, 0.07315887f, -0.00320786f, -0.01730862f, -0.03199680f, -0.04406207f, 
    0.01078996f, -0.06491540f, 0.10951453f, -0.04045401f, 0.24645035f, 0.00630605f, -0.04922918f, 0.09149034f, 
    -0.05308457f, -0.15130204f, 0.00105921f, 0.17669649f, 0.03803131f, -0.11896866f, 0.02403972f, 0.02738095f, 
    -0.32645300f, 0.01458888f, 0.19158317f, 0.08234297f, 0.13691849f, -0.05177502f, -0.03545738f, -0.04013496f, 
    -0.00889461f, 0.06261599f, -0.14881851f, 0.07270576f, 0.23914640f, 0.05903770f, -0.05036323f, 0.20771430f, 
    -0.08402494f, -0.02385587f, 0.06752634f, 0.03761293f, 0.01731855f, 0.07057980f, 0.01882628f, 0.13692148f, 
    -0.31951436f, -0.15006639f, -0.03772932f, -0.11046326f, 0.06596948f, 0.01555222f, -0.06710554f, -0.00766943f, 
    0.04393519f, -0.05569709f, 0.10105746f, 0.02235085f, 0.06241883f, 0.03298622f, 0.07620861f, -0.07104337f, 
    0.06541409f, 0.00927601f, -0.06454977f, -0.06895141f, -0.01115794f, 0.02586799f, 0.02955542f, 0.16729358f, 
    -0.00878432f, -0.05275160f, -0.10181566f, 0.11715034f, -0.03109001f, -0.08821056f, -0.03975171f, 0.03750661f, 
    0.04899980f, 0.09303606f, 0.02405953f, 0.10843965f, -0.45615861f, 0.08027602f, -0.20870833f, 0.02083764f, 
    0.03622193f, 0.02584425f, -0.12687516f, 0.01920541f, 0.00117308f, 0.01241629f, -0.03231040f, -0.05664703f, 
    -0.14987771f, -0.12513858f, -0.21029675f, 0.06352095f, 0.03656257f, -0.00242994f, -0.07489092f, -0.04935624f, 
    0.02854980f, -0.04362213f, 0.02007297f, -0.01417619f, 0.04315750f, 0.05510040f, 0.11249874f, -0.05722411f, 
    0.08019674f, 0.03876635f, -0.01422730f, -0.04160548f, 0.08581721f, 0.04263458f, 0.14090995f, -0.17664140f, 
    0.00292403f, 0.05870987f, -0.16230853f, -0.03133416f, 0.01170015f, -0.08076376f, -0.10762039f, -0.06514941f, 
    -0.03709565f, -0.17458126f, 0.09853600f, -0.02608304f, 0.17040066f, -0.01568042f, 0.01775686f, -0.21230967f, 
    -0.08425298f, 0.06580880f, 0.05331676f, -0.06642763f, -0.00536607f, 0.06551692f, -0.07816558f, -0.10745928f, 
    0.07756995f, 0.02490601f, -0.06429498f, 0.00476614f, -0.01413242f, 0.01390849f, 0.04577312f, 0.06724942f, 
    0.03067734f, 0.05875441f, -0.00489303f, 0.04644908f, -0.28007260f, -0.08445870f, -0.11326587f, -0.10038381f, 
    0.01967504f, -0.02171455f, -0.09126331f, -0.02784197f, 0.02915603f, 0.08221530f, 0.05177231f, 0.02680560f, 
    -0.39994296f, -0.33702034f, -0.02320510f, -0.23050714f, 0.10373757f, -0.00727317f, 0.00476927f, -0.04835977f, 
    0.03125777f, -0.00273401f, 0.03437266f, 0.06577487f, -0.21532987f, -0.12516201f, 0.01279702f, -0.07428163f, 
    -0.13950287f, -0.01597050f, -0.01340797f, -0.08568340f, 0.05559282f, -0.11329641f, -0.13354981f, -0.15780583f, 
    -0.00904081f, -0.18837650f, 0.11409792f, 0.06062480f, -0.07120404f, 0.10558493f, -0.10131811f, -0.01756889f, 
    -0.02485309f, 0.07485613f, 0.00781154f, 0.06673761f, -0.50229299f, 0.06586522f, -0.00615537f, -0.00457622f, 
    0.12500744f, 0.01907587f, 0.06295078f, 0.08368073f, 0.09556191f, 0.13649057f, 0.01208127f, 0.05544038f, 
    0.02041439f, -0.04573020f, -0.05390872f, -0.00890295f, -0.01238212f, -0.04055560f, -0.03341128f, 0.02211034f, 
    0.04705410f, -0.07338410f, 0.04759585f, 0.01088250f, 0.12062477f, 0.00838052f, -0.04063343f, -0.06345113f, 
    -0.04791273f, -0.02754760f, 0.03360727f, -0.08958554f, 0.08183611f, -0.02280779f, -0.18900558f, -0.09045453f, 
    0.01036799f, -0.12355772f, 0.04767309f, 0.00911077f, -0.05038394f, -0.03552791f, 0.09347393f, 0.01897279f, 
    0.01377316f, 0.09089524f, 0.12800258f, 0.10371070f, 0.19985749f, 0.14764301f, 0.01738639f, 0.07976978f, 
    -0.04251135f, -0.11610068f, 0.03856577f, -0.05968427f, -0.07340081f, -0.01684668f, -0.06744432f, 0.12806362f, 
    0.31465963f, 0.07189506f, -0.01221631f, -0.01152274f, -0.00092040f, 0.12397736f, 0.05452329f, -0.00924147f, 
    -0.02538574f, -0.06552762f, 0.04997133f, -0.03272050f, 0.18639143f, 0.14091089f, 0.00821240f, -0.09888461f, 
    -0.01249133f, 0.03989053f, -0.01762776f, 0.01078526f, 0.07496596f, 0.08406007f, 0.16184853f, 0.07250401f, 
    -0.02877655f, 0.06130673f, 0.01540159f, 0.00989583f, 0.05743745f, -0.02713978f, -0.11346287f, -0.06054864f, 
    0.00974831f, 0.04280697f, 0.10930976f, 0.10664666f, -0.11859450f, -0.13637288f, 0.20193797f, 0.07073428f, 
    0.04965796f, 0.03217949f, 0.11510748f, -0.04753634f, 0.09782190f, -0.08220705f, -0.09228101f, 0.01305046f, 
    -0.47622949f, 0.19245239f, -0.17534715f, -0.27162147f, 0.17618546f, 0.00600646f, -0.02865297f, 0.02981750f, 
    0.06697662f, -0.08739292f, -0.05606436f, -0.05262588f, -0.08369514f, 0.04638530f, -0.04138197f, 0.09604616f, 
    0.08533382f, -0.01150337f, -0.01708291f, -0.03618305f, 0.00379324f, -0.02336543f, -0.01292938f, 0.13399348f, 
    0.30700207f, 0.16048248f, -0.03515464f, -0.02607946f, -0.17225768f, 0.00956253f, -0.00133934f, 0.04959774f, 
    -0.01244821f, -0.06232288f, 0.04532376f, -0.18517755f, -0.10797655f, 0.04154616f, -0.10680760f, -0.03695767f, 
    -0.11928339f, -0.06938193f, -0.00477940f, -0.02439274f, 0.01934477f, 0.01666280f, 0.04435684f, -0.01594502f, 
    0.15774447f, 0.01615619f, -0.00351325f, -0.05132021f, -0.01691566f, 0.04620661f, -0.04176143f, 0.03055978f, 
    -0.13114300f, -0.04510961f, -0.00620227f, -0.00251318f, 0.08255029f, 0.09734917f, 0.04775067f, -0.09377618f, 
    -0.06736184f, -0.04213978f, 0.02518448f, 0.03692661f, 0.01073879f, -0.00187867f, -0.02635134f, 0.07446752f, 
    -0.60463941f, -0.30747014f, 0.00514672f, 0.07258392f, 0.09299005f, 0.02423465f, -0.06955279f, -0.17017823f, 
    0.00844515f, -0.11782477f, -0.05615970f, 0.05715560f, -0.02164408f, -0.02594524f, -0.08851291f, 0.02955454f, 
    -0.01193099f, 0.09896830f, 0.01665668f, -0.04321703f, 0.02795604f, 0.10452329f, 0.05788153f, -0.08385800f, 
    -0.37937903f, -0.09362709f, 0.26399228f, 0.11902007f, 0.01458858f, -0.01779448f, 0.02722029f, 0.00382817f, 
    0.15822448f, 0.18605644f, -0.05288263f, 0.16442685f, 0.06398132f, 0.05666472f, 0.03125999f, 0.05369350f, 
    0.07430596f, 0.04597924f, 0.07429643f, -0.07270698f, -0.09791455f, 0.00698339f, 0.03952418f, -0.04063491f, 
    0.20785286f, 0.01121322f, -0.06717908f, -0.08695421f, 0.02153611f, 0.04915794f, -0.05192976f, 0.04951866f, 
    0.08095283f, 0.00421196f, 0.03261578f, 0.01273689f, -0.25769231f, 0.00722539f, -0.02753846f, 0.15987134f, 
    0.04803137f, 0.01673720f, 0.05962374f, -0.00849992f, 0.02330843f, 0.10374641f, -0.03691310f, 0.02816525f, 
    0.17713757f, 0.04251920f, -0.01186982f, -0.01544195f, -0.13559636f, -0.04903038f, -0.00867242f, 0.07288537f, 
    0.08983915f, -0.03852408f, -0.05431433f, -0.06579269f, 0.28511336f, -0.01151701f, -0.06300227f, 0.00157873f, 
    -0.11991924f, -0.02087250f, 0.02106452f, 0.06081184f, -0.05372136f, -0.08964457f, 0.02301349f, -0.11001787f, 
    -0.11846398f, -0.03737745f, -0.23805852f, -0.03315591f, 0.10253255f, -0.10362202f, -0.01603828f, -0.04151749f, 
    -0.03295786f, 0.04511059f, -0.02298485f, -0.13944636f, 0.27166453f, -0.07062111f, -0.11242767f, -0.01238770f, 
    -0.07868326f, -0.18225648f, -0.04352652f, 0.09176069f, -0.01923548f, 0.11290073f, -0.13856725f, -0.04408285f, 
    0.10055540f, -0.01114441f, -0.02670139f, -0.07330900f, -0.01292594f, 0.04669942f, 0.05063198f, -0.00886529f, 
    -0.00820028f, 0.12519997f, 0.06804148f, -0.01291896f, -0.11737313f, 0.13526335f, 0.02726933f, 0.15610665f, 
    0.03117176f, 0.06357840f, 0.12072130f, -0.08660021f, -0.06250199f, 0.09462893f, -0.01320073f, 0.06349345f, 
    0.05757280f, -0.14994130f, 0.04465928f, 0.01217123f, 0.02558783f, 0.10567879f, 0.02832102f, -0.12216099f, 
    0.01544314f, -0.01492941f, -0.16052642f, 0.02923862f, 0.07096738f, 0.01145031f, 0.01057418f, -0.03269420f, 
    -0.04327925f, 0.00359505f, 0.00236683f, -0.08185106f, -0.01926083f, -0.27152526f, -0.14780211f, 0.00000991f, 
    0.22946040f, 0.11656767f, -0.02097346f, 0.10814648f, 0.01078044f, 0.03226328f, 0.06265072f, -0.00966077f, 
    0.10258383f, -0.03265728f, -0.01394610f, 0.10624637f, -0.04558901f, -0.08514848f, -0.14561583f, -0.07531534f, 
    -0.07430156f, 0.01812753f, 0.07775871f, 0.00778409f, 0.11211820f, -0.01080376f, -0.02773630f, -0.02707201f, 
    -0.37602425f, -0.28572443f, -0.07802778f, -0.25451899f, 0.05002267f, -0.00021894f, -0.02994866f, -0.04279931f, 
    0.01071354f, 0.09155624f, -0.05280831f, 0.01482096f, -0.27845797f, -0.16208331f, -0.04964896f, -0.14090358f, 
    0.03092653f, 0.02091884f, 0.08845711f, 0.16995773f, -0.08692867f, 0.11355596f, 0.14245819f, 0.16442662f, 
    -0.28258619f, -0.14163080f, -0.19617809f, -0.23403829f, -0.06179351f, 0.01183544f, 0.09319162f, 0.04399691f, 
    0.10202238f, 0.12898138f, 0.09254380f, 0.14019999f, -0.19174652f, -0.05531007f, -0.18794531f, -0.23477541f, 
    0.06343181f, -0.01885580f, -0.03317548f, 0.04209872f, 0.02398102f, -0.01260880f, 0.12641037f, 0.00461693f, 
    -0.23122156f, 0.15645206f, -0.06312323f, 0.08204440f, 0.00413632f, 0.09515339f, 0.03322092f, -0.07211700f, 
    -0.00071110f, -0.01397088f, -0.02540335f, -0.02041011f, 0.00962307f, 0.08277406f, 0.04036773f, 0.08804350f, 
    0.08909780f, -0.05497523f, -0.06476302f, 0.01997349f, -0.12053037f, -0.03809275f, 0.07993022f, -0.01382852f, 
    -0.36671636f, -0.20123462f, -0.02908035f, -0.24825259f, 0.11091737f, 0.08111874f, -0.06900821f, 0.10928938f, 
    -0.00985206f, -0.12057224f, -0.10544712f, -0.02068487f, -0.10495389f, 0.13265714f, -0.05523422f, -0.01445634f, 
    -0.12881015f, -0.05115890f, -0.04116447f, 0.06151291f, 0.02670552f, 0.00135362f, -0.04685235f, -0.01321619f, 
    -0.08860887f, -0.07626427f, -0.04722623f, 0.10068450f, -0.20809503f, 0.00795994f, -0.05949428f, -0.09840041f, 
    -0.00176788f, -0.09909742f, -0.05028149f, -0.14651519f, -0.30987489f, 0.25632411f, 0.00430377f, 0.15567352f, 
    0.17606154f, -0.07548022f, 0.03057734f, 0.02502635f, 0.04988690f, -0.01409612f, 0.05334332f, -0.02197423f, 
    -0.12116752f, -0.27911830f, -0.19917034f, -0.03140580f, -0.02044713f, 0.03910171f, 0.00127962f, 0.06724910f, 
    0.09046812f, 0.01250376f, -0.06995907f, -0.07614482f, 0.22291917f, 0.20366773f, -0.13219224f, -0.20792602f, 
    0.11832203f, 0.00206515f, -0.02265986f, -0.00245436f, 0.05630179f, 0.00751306f, 0.05915464f, 0.04615198f, 
    -0.00394001f, 0.07335868f, -0.07081439f, 0.20863245f, -0.04039602f, 0.06903400f, 0.04955892f, -0.11310624f, 
    -0.04268207f, -0.11022683f, 0.07030123f, 0.08717051f, -0.33532470f, 0.23068832f, -0.03060090f, -0.10883582f, 
    0.19460295f, -0.11330085f, -0.03373650f, -0.04674827f, 0.08841530f, 0.02734544f, 0.09291223f, 0.04478426f, 
    0.00480644f, -0.03668986f, -0.05583286f, 0.14830318f, 0.21757187f, 0.03571228f, -0.07680771f, 0.03221940f, 
    -0.03909141f, 0.09722522f, 0.08604248f, -0.02728298f, 0.24105380f, -0.18409145f, 0.08134688f, 0.21609086f, 
    0.10971372f, -0.04583500f, -0.05025663f, -0.00207473f, 0.08778428f, 0.04144637f, -0.07742397f, -0.05454091f, 
    0.15153705f, -0.07080188f, 0.06285053f, 0.08619785f, 0.07395279f, 0.10198917f, 0.02028566f, -0.06586997f, 
    -0.02566641f, 0.05637421f, 0.00073463f, 0.01486630f, 0.18176758f, -0.06574257f, 0.07215495f, -0.12187879f, 
    -0.01483775f, -0.06675292f, 0.11369112f, -0.00349994f, -0.00680046f, 0.03813740f, 0.00597598f, 0.04647090f, 
    0.48772636f, 0.08942809f, 0.02541845f, -0.10571087f, 0.01824924f, 0.05323335f, -0.11554435f, -0.02532291f, 
    0.06309051f, 0.02163919f, 0.06977610f, 0.07030991f, -0.10547467f, 0.03171693f, 0.08528174f, 0.06069857f, 
    -0.02310728f, -0.05453243f, 0.08710963f, -0.00951943f, -0.09929880f, -0.11795202f, 0.03114703f, -0.09192373f, 
    0.07154177f, -0.08144829f, -0.07517352f, -0.16050529f, -0.01475836f, 0.06330232f, -0.00317371f, 0.05808382f, 
    0.01652190f, -0.00436223f, -0.03540539f, 0.02797596f, 0.11071644f, 0.02197384f, 0.09310724f, -0.02471878f, 
    -0.05508357f, -0.01912767f, -0.01389071f, -0.12125502f, -0.02216334f, -0.04541722f, -0.08043763f, -0.19623581f, 
    0.04373029f, 0.02808612f, -0.00853192f, 0.06424368f, -0.02239103f, 0.01837752f, 0.08493687f, 0.04241292f, 
    -0.04308299f, -0.07986977f, 0.02433131f, -0.01111909f, -0.10817719f, -0.07373805f, 0.00629679f, 0.01554503f, 
    0.01150429f, 0.10554731f, 0.01813695f, 0.11521094f, 0.02250192f, 0.04057642f, 0.18284631f, -0.05805669f, 
    0.01384209f, -0.18273929f, -0.21271196f, 0.23948504f, -0.08920799f, 0.10227084f, -0.10995112f, 0.09517867f, 
    0.11237761f, 0.08667338f, 0.02965915f, 0.01018656f, -0.08210938f, 0.14420380f, -0.08267703f, 0.00401531f, 
    0.05568833f, 0.09080840f, -0.02437475f, -0.16588457f, 0.06941783f, -0.07083832f, -0.09670280f, -0.15903419f, 
    -0.16198362f, -0.27577391f, -0.25018397f, -0.19774061f, 0.03465959f, 0.01270412f, 0.09008405f, -0.08251329f, 
    -0.05549387f, 0.00295883f, -0.05708588f, 0.10215046f, 0.20573172f, 0.00888371f, -0.06200346f, -0.05597756f, 
    -0.13049845f, -0.06913900f, -0.13277048f, -0.11535977f, 0.03299015f, -0.04111105f, 0.09343817f, 0.02766111f, 
    0.13279818f, -0.16124976f, 0.00210036f, 0.21094015f, 0.07014756f, -0.02911172f, -0.02403215f, -0.07050037f, 
    -0.03400783f, 0.05229185f, -0.04198390f, -0.02782448f, 0.09934232f, -0.03595312f, -0.22693039f, 0.08680008f, 
    0.01605685f, -0.09638792f, -0.01565377f, -0.02012072f, -0.01988106f, 0.03433367f, -0.02276482f, -0.03366543f, 
    0.40423441f, 0.00540237f, -0.22788770f, 0.02533718f, 0.07370719f, -0.03695898f, -0.01984513f, 0.07441546f, 
    0.11815280f, -0.02097842f, 0.05962940f, -0.00813101f, -0.00566329f, -0.02922513f, -0.01273986f, 0.05851994f, 
    0.02652810f, -0.09265695f, 0.04977720f, -0.10365292f, 0.05613441f, 0.07233881f, 0.04649869f, 0.10004571f, 
    -0.11261496f, 0.06418451f, 0.07206126f, -0.10873165f, -0.02863077f, -0.03596183f, 0.09698995f, -0.14329223f, 
    -0.23525728f, 0.04191119f, -0.09279819f, -0.19585766f, 0.41786012f, 0.00664769f, -0.08007719f, 0.04841026f, 
    -0.04937826f, -0.01042221f, -0.05976003f, 0.08862118f, -0.02909525f, 0.01988099f, 0.03078716f, 0.02268222f, 
    0.14691442f, -0.04480351f, -0.08030383f, 0.05402084f, -0.01775000f, -0.09383281f, 0.08904825f, -0.00526451f, 
    -0.00654609f, 0.11594348f, -0.07233621f, 0.03658254f, -0.28336868f, -0.31250846f, -0.06271366f, -0.10098676f, 
    -0.05193561f, 0.07012106f, 0.07468952f, 0.10984952f, 0.03090896f, 0.02263421f, 0.01314743f, -0.02032413f, 
    -0.01248443f, -0.01006046f, 0.05640278f, -0.04876249f, 0.13629360f, 0.02993607f, -0.08083032f, 0.00978487f, 
    -0.04727656f, -0.00940061f, 0.06401531f, 0.02708648f, 0.24508993f, 0.01562530f, -0.08825600f, -0.11489683f, 
    -0.13684283f, -0.00671133f, 0.01978029f, 0.02302502f, 0.00455772f, -0.06686676f, -0.11612247f, -0.01539971f, 
    -0.07792029f, 0.00860680f, -0.11686081f, -0.07983015f, -0.06050783f, 0.00837553f, 0.05254190f, 0.09219150f, 
    0.04221319f, 0.00269204f, 0.00970699f, -0.03490308f, 0.10567281f, -0.02054782f, -0.04543572f, 0.26486102f, 
    -0.02026062f, 0.07091188f, 0.04544405f, -0.05131670f, 0.01610094f, -0.08647677f, -0.07506052f, -0.15781164f, 
    -0.13290103f, 0.12647739f, 0.11698613f, -0.02874179f, -0.15691577f, -0.03588032f, -0.00944667f, -0.05202970f, 
    0.05691129f, -0.00270911f, -0.15461361f, -0.11719529f, 0.07928095f, 0.20953922f, -0.05509963f, -0.12449320f, 
    0.11678587f, -0.11287296f, 0.08649902f, 0.05709213f, 0.04577616f, -0.00822774f, 0.03000340f, -0.04584383f, 
    0.06765089f, -0.17179963f, -0.01383472f, 0.04454606f, -0.08993790f, 0.08882613f, -0.07361702f, -0.10605498f, 
    0.02461233f, 0.08256785f, -0.01751876f, 0.01245958f, -0.33038843f, 0.20866515f, 0.00467555f, -0.05992266f, 
    0.02055762f, -0.00667217f, -0.09723378f, -0.05268286f, -0.08031033f, 0.06307966f, 0.09588888f, -0.09388742f, 
    -0.02932167f, -0.15924136f, -0.08841351f, 0.11763226f, -0.04945550f, -0.03105514f, -0.01395132f, -0.10215808f, 
    0.04974391f, -0.05469698f, -0.02745350f, -0.05043392f, 0.02907043f, -0.20400038f, -0.04030882f, 0.05587038f, 
    -0.06126363f, 0.10722827f, -0.08712899f, -0.05942957f, 0.01231290f, 0.02873384f, -0.07819267f, 0.10338386f, 
    0.02978467f, 0.09253789f, 0.03238209f, 0.03031871f, 0.05065079f, 0.03714260f, 0.05010110f, -0.13593897f, 
    0.01238997f, 0.02770667f, 0.07393375f, -0.01566928f, 0.03162283f, 0.07380608f, -0.01224559f, -0.12438212f, 
    -0.16922951f, 0.13047291f, 0.01764650f, -0.06292143f, 0.01347873f, -0.03065406f, -0.18334684f, -0.12883705f, 
    0.39261925f, 0.10372491f, -0.00949409f, -0.08670211f, -0.07447170f, -0.04486592f, -0.04347789f, -0.01926432f, 
    0.09596694f, 0.01107244f, 0.02256308f, 0.03585052f, 0.20186777f, -0.04840775f, -0.12983751f, 0.01170421f, 
    -0.02733260f, 0.04059406f, -0.13541478f, -0.01304219f, -0.03294992f, -0.02929809f, 0.01872944f, 0.04246711f, 
    0.27412447f, -0.22929047f, -0.00953436f, 0.02854960f, 0.10607519f, -0.11358584f, -0.19206180f, -0.03971992f, 
    -0.08682729f, 0.01254595f, -0.10293861f, -0.01999032f, 0.10086701f, 0.14468105f, -0.14071915f, -0.00135314f, 
    -0.01627656f, -0.18001944f, -0.03337592f, -0.06626755f, -0.00616814f, -0.01304503f, 0.03575126f, -0.03144093f, 
    0.14363682f, -0.08314844f, -0.13497128f, -0.05121704f, 0.08534794f, -0.05120793f, 0.09112019f, 0.07469798f, 
    -0.01531111f, -0.01327229f, 0.12483591f, 0.05922069f, -0.10331697f, 0.00595596f, 0.05147639f, -0.09242114f, 
    -0.02056373f, -0.05015481f, -0.00330560f, 0.09108492f, 0.13458019f, -0.09766869f, 0.06469663f, -0.00829991f, 
    -0.32795808f, -0.06213255f, -0.01865692f, 0.02940418f, -0.15840991f, 0.05561623f, -0.07440396f, 0.00466643f, 
    0.01066129f, 0.05250012f, 0.04271442f, -0.09620758f, -0.01731312f, 0.08854150f, -0.13773227f, 0.05913283f, 
    0.03303715f, 0.02497853f, 0.07412002f, -0.04789541f, -0.04992284f, -0.09951558f, 0.06464803f, 0.04411343f, 
    0.02060438f, 0.04296875f, -0.07202109f, 0.35152081f, -0.02359524f, 0.06386920f, 0.05494828f, 0.06601820f, 
    0.09480586f, -0.00205910f, -0.06468956f, 0.18317287f, -0.26048440f, -0.06764653f, 0.00908533f, -0.07931337f, 
    -0.10401507f, -0.03869547f, -0.03996667f, 0.02128707f, -0.04459062f, 0.04808164f, 0.05416677f, 0.01739083f, 
    -0.28313702f, 0.01335884f, 0.05862050f, -0.09357709f, -0.00335445f, -0.03187188f, -0.06822021f, 0.01482016f, 
    -0.03886445f, -0.03130990f, 0.16529541f, -0.02532902f, 0.12281589f, 0.00939850f, 0.02543145f, 0.07998609f, 
    0.03997295f, 0.03083163f, 0.02319246f, 0.03135227f, 0.16834275f, -0.07785235f, -0.02634271f, 0.09880672f, 
    -0.23618647f, 0.08148473f, 0.06996118f, -0.00521350f, 0.01830616f, 0.02755319f, -0.00301890f, 0.00214621f, 
    0.05387984f, 0.00251892f, -0.05856976f, -0.02369804f, -0.28797618f, 0.23679951f, 0.00836514f, -0.25938693f, 
    -0.12326168f, -0.00059682f, 0.04429441f, 0.01500405f, -0.04455342f, 0.12048975f, 0.08050270f, -0.01152774f, 
    0.17953184f, -0.02261972f, 0.02817058f, 0.23723115f, -0.06155774f, -0.10691191f, -0.00591531f, 0.00270509f, 
    -0.10113924f, -0.03297228f, 0.00467304f, -0.02142475f, -0.28810793f, -0.12713060f, -0.04367656f, 0.03729253f, 
    0.09341234f, -0.01598797f, 0.04206945f, 0.14052676f, 0.01707307f, -0.00547761f, -0.01211963f, -0.01361555f, 
    -0.06305625f, -0.36369041f, -0.00959808f, -0.22958043f, 0.02993810f, 0.03310731f, 0.00584785f, 0.05372167f, 
    0.04050637f, -0.06387410f, -0.00951425f, 0.03952970f, -0.12326949f, -0.01113454f, 0.04323275f, -0.09800268f, 
    0.01442578f, 0.05052103f, -0.12856856f, 0.07956027f, 0.00318410f, 0.00425707f, -0.04349275f, -0.06862167f, 
    0.32668591f, -0.00069258f, -0.32337216f, -0.01281139f, 0.01886652f, -0.05805309f, 0.10579344f, -0.05683670f, 
    -0.03188219f, -0.08405168f, -0.13269520f, -0.11770520f, 0.10922173f, -0.26086280f, -0.02327775f, -0.00442882f, 
    0.05412270f, -0.04143323f, 0.04001433f, -0.15348876f, 0.00282956f, 0.03669473f, 0.01164547f, 0.01154488f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08946621f, 0.04922066f, -0.00836716f, 0.01409743f, 0.04383897f, 0.00233577f, 0.03490011f, -0.07068408f, 
    -0.05950719f, -0.01666182f, 0.07190667f, 0.04509402f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
