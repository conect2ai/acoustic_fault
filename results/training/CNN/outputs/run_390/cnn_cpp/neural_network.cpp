#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.10217693f, -0.07898489f, 0.42301786f, -0.09753652f, 0.45410541f, -0.49990901f, -0.06484763f, 0.34080210f, 
    -0.00636555f, -0.49030766f, 0.15215424f, -0.35888016f, -0.05819679f, 0.30823970f, 0.46356449f, 0.44534531f, 
    0.02486589f, 0.39570183f, 0.14412831f, -0.14935377f, 0.28135699f, -0.53429043f, -0.13402912f, -0.39077377f, 
    0.12444320f, 0.36922073f, 0.45257467f, -0.16088936f, -0.47458369f, -0.46169764f, 0.24531351f, 0.14045809f, 
    -0.64152479f, -0.35317433f, 0.35512075f, -0.16124225f, 0.36837620f, 0.22447540f, 0.21381189f, 0.16123319f, 
    0.02981124f, 0.18432048f, 0.35261288f, -0.01558392f, 0.04710935f, -0.07079170f, -0.09468222f, 0.01155764f, 
    -0.28020865f, 0.36364901f, 0.42055213f, -0.69893372f, -0.21410479f, -0.42117760f, 0.69211364f, -0.68736351f, 
    0.38171238f, -0.11838833f, -0.26390725f, 0.14374591f, -0.01638914f, 0.61963725f, -0.38889870f, -0.03214293f, 
    -0.04953343f, 0.13667320f, -0.14404565f, -0.35403922f, 0.09729169f, 0.05876001f, -0.05368306f, -0.07620183f, 
    -0.19809142f, 0.34762764f, -0.32109246f, 0.94557405f, 0.34131569f, 0.28368473f, 0.06633747f, 0.45158514f, 
    0.24644330f, -0.13829544f, 0.05350011f, 0.10990270f, 0.24179631f, -0.46314853f, -0.17253548f, 0.05342836f, 
    -0.09692987f, 0.01994231f, -0.20570445f, -0.00836832f, 0.10470883f, -0.23894927f, 0.01213157f, 0.23434451f, 
    0.22331281f, 0.17728902f, 0.04082179f, 0.33793256f, -0.42710322f, -0.23590705f, -0.33493379f, -0.32544985f, 
    0.27830741f, -0.36132899f, -0.31242704f, -0.40510312f, -0.14201005f, -0.49532887f, -0.14620605f, 0.29660735f, 
    0.33959031f, 0.23065801f, -0.05419953f, 0.31843033f, -0.28932545f, -0.44786724f, 0.00148512f, 0.05583316f, 
    -0.14407125f, 0.29244944f, -0.10974687f, -0.02130819f, 0.02525732f, 0.28947529f, 0.17295596f, 0.50680155f, 
    0.74722588f, 0.31945676f, 0.12324964f, -0.45274800f, 0.61258990f, 0.36670020f, 0.13229732f, -0.23207055f, 
    -0.09112138f, -0.17038658f, -0.09968211f, -0.35508198f, 0.30893013f, 0.10606210f, -0.28707346f, -0.17347114f, 
    -0.14995772f, -0.02724891f, -0.21975677f, 0.19177641f, -0.20975259f, -0.15668298f, -0.60172588f, -0.54430962f, 
    -0.67201632f, -0.04606055f, 0.01610647f, -0.65359104f, 0.19654286f, 0.52939129f, -0.13685091f, 0.44726869f, 
    0.14767963f, 0.08016124f, 0.16637333f, -0.17883350f, 0.09669297f, 0.03008386f, 0.03810151f, -0.12144832f, 
    0.06644115f, -0.14658017f, 0.10256384f, -0.01764534f, -0.14424869f, 0.19509141f, -0.15743287f, 0.25649473f, 
    -0.72447407f, -0.30089119f, 0.46976572f, -0.16014536f, -0.38398448f, -0.73936820f, -0.43820497f, 0.30545935f, 
    -0.03266854f, -0.03847077f, 0.28522292f, 0.05602323f, 0.17739324f, -0.08766121f, 0.11831024f, -0.05227730f, 
    0.22048698f, 0.12335546f, 0.33391070f, -0.16705999f, 0.27827585f, 0.09038357f, 0.13859467f, -0.10013144f, 
    0.78552848f, 0.10864545f, 0.57336938f, 0.77174610f, 0.31067273f, -0.17319798f, -0.37137017f, -0.05946726f, 
    0.25641209f, -0.35702166f, -0.38967502f, -0.00990031f, 0.00840672f, 0.01138788f, 0.11328068f, 0.03000153f, 
    -0.17598279f, 0.23805843f, 0.21603569f, 0.12181018f, -0.10824207f, 0.09224997f, -0.37263182f, 0.12036174f, 
    -0.02460636f, -0.14462303f, -0.10524499f, -0.25868207f, 0.24615809f, -0.05944262f, 0.31518042f, -0.16974118f, 
    -0.02998177f, 0.41457343f, -0.57551146f, -0.29795861f, 0.40623128f, 0.24723397f, -0.28470245f, -0.48971382f, 
    0.00197377f, 0.19366036f, -0.04465377f, 0.31498402f, -0.29043272f, -0.01291921f, 0.24642964f, -0.31836438f, 
    0.04890276f, -0.33192754f, 0.43196496f, 0.59349418f, 0.07245528f, 0.66145825f, -0.25813866f, -0.28155449f, 
    0.31938475f, -0.15011367f, -0.13192262f, 0.39623448f, 0.26000035f, -0.25133857f, 0.19402759f, 0.05785155f, 
    -0.23991957f, 0.02988099f, -0.23549174f, 0.18170790f, -0.13284662f, 0.02207859f, 0.48773226f, -0.19483107f, 
    0.11146758f, 0.41089496f, 0.04634778f, 0.54896605f, 0.24447645f, 0.62030292f, 0.75390846f, 0.33094764f, 
    0.45599753f, 0.25114167f, -0.25122458f, -0.49897113f, -0.26753730f, 0.30758423f, 0.25125727f, -0.15961860f, 
    -0.24586682f, -0.02321486f, 0.02383567f, -0.13217285f, 0.04258319f, -0.00190476f, -0.16066016f, 0.13115235f, 
    0.22650312f, 0.13104673f, -0.01598787f, 0.15472727f, 0.51805133f, -0.02318423f, 0.23886473f, 0.68580729f, 
    0.89614588f, -0.01197848f, -0.11980464f, -0.24684304f, 0.11941604f, 0.13565823f, 0.37024620f, 0.25658125f, 
    -0.14770554f, -0.11810989f, -0.06395617f, -0.21361496f, 0.03675791f, 0.27095333f, -0.08587901f, -0.07634948f, 
    -0.07193118f, -0.05584252f, 0.25036639f, -0.06101457f, 0.11376686f, -1.06698656f, 0.60838127f, 0.39505056f, 
    -0.50390792f, -0.32952440f, -0.12423912f, 0.62077469f, -0.20008659f, 0.30027401f, 0.25054091f, 0.07506372f, 
    0.17891911f, -0.02200367f, -0.16110136f, 0.26502675f, 0.23898785f, 0.24567808f, 0.21829458f, 0.23546132f, 
    0.06711760f, 0.29857045f, 0.26073775f, 0.01255495f, -0.10744983f, -0.03888627f, -0.14187549f, -0.35178226f, 
    -0.20723277f, -0.50507253f, -0.28216466f, 0.24833305f, -0.25914288f, 0.41111121f, 0.42780399f, -0.14702828f, 
    -0.25481233f, -0.02684405f, -0.23591882f, -0.12211388f, -0.15679824f, 0.21080555f, 0.30962861f, -0.29952210f, 
    -0.13853619f, -0.15791072f, 0.03200412f, -0.01152348f, 0.35234421f, -0.25972208f, -0.11996765f, 0.50565660f, 
    -0.16473205f, -0.81131887f, -0.65969467f, 0.26177418f, 0.31489798f, -0.51197660f, 0.24474177f, 0.02993092f, 
    -0.27406752f, -0.31420907f, -0.22653590f, 0.27256262f, -0.06672736f, -0.40014538f, -0.30131921f, -0.00917862f, 
    0.09634588f, 0.34015608f, -0.22448736f, -0.18511929f, -0.00785751f, 0.04347857f, 0.00500578f, 0.20133905f, 
    0.09030333f, -0.66272998f, -0.43840837f, 1.01447296f, 0.10543416f, 0.41865417f, 0.29241100f, 0.29060590f, 
    0.17143202f, 0.26716897f, 0.15019950f, 0.18057831f, -0.31010547f, 0.14394233f, 0.22153057f, -0.07011920f, 
    -0.23465404f, 0.08468337f, -0.06716881f, -0.25103045f, -0.05094295f, 0.06402338f, -0.06174126f, -0.14727499f, 
    -0.25638494f, 0.85831791f, 0.44887874f, -0.17628834f, 0.31864861f, 0.46114618f, -0.01037959f, 0.02512460f, 
    -0.69231451f, -0.12667216f, -0.33436653f, -0.02420156f, -0.00348065f, -0.07525742f, 0.02210358f, -0.22679901f, 
    -0.07133166f, -0.21776707f, -0.29282823f, -0.02147844f, -0.05088573f, -0.17525539f, 0.38628212f, -0.21067443f, 
    -0.13456358f, -0.07441384f, -0.09356312f, -0.49825972f, -0.27480957f, -0.39433211f, -0.36502069f, -0.31331715f, 
    -0.62734753f, -0.22020380f, -0.05751624f, 0.09034587f, -0.24632651f, 0.18062820f, 0.00617289f, -0.15109320f, 
    -0.30232978f, 0.19119085f, 0.26932737f, 0.24987000f, 0.10990914f, -0.27844137f, -0.00843216f, -0.02270673f, 
    0.01503186f, -0.24499655f, -0.23183857f, -0.31973675f, -0.85778725f, -0.20894457f, 0.12941290f, -0.33986887f, 
    0.06118324f, 0.63499826f, 0.56758118f, 0.17152341f, 0.13197383f, 0.00122034f, -0.07411867f, -0.10476730f, 
    0.26552817f, -0.18139389f, -0.26494867f, 0.11337671f, 0.10116505f, -0.12733871f, 0.13157864f, 0.09155335f, 
    -0.30048963f, 0.35971448f, -0.17511031f, 0.11351400f, -0.18069461f, -0.51547515f, -0.55797839f, -0.47611925f, 
    0.15651423f, 0.35104042f, 0.86795855f, -0.19214180f, 0.46782374f, 0.47212839f, 0.29888496f, 0.06097836f, 
    0.01687378f, 0.10210462f, 0.04974805f, 0.08976632f, -0.11840586f, 0.14274588f, -0.05289424f, 0.01070615f, 
    0.10182484f, -0.00506666f, 0.23480511f, 0.04103196f, 0.17225705f, 0.24969329f, -0.07169075f, 0.04457427f, 
    0.64510417f, 0.45296311f, 0.31962964f, 0.04890958f, -0.41462088f, 0.23825443f, 0.20345025f, -0.66981947f, 
    -0.29153886f, -0.38821891f, 0.23433693f, -0.17690398f, -0.03867036f, 0.04074121f, -0.30554774f, 0.04256373f, 
    -0.12949888f, -0.14707911f, 0.12344459f, 0.00971825f, 0.07696982f, -0.00000708f, -0.63635260f, -0.91577744f, 
    -0.50560778f, 0.11822176f, 0.02551108f, 0.42222258f, 0.39209032f, -0.29288211f, -0.05265089f, 0.29221925f, 
    -0.25029936f, 0.17703331f, 0.25537881f, 0.11637051f, 0.37735811f, -0.24841754f, 0.17508577f, 0.26072520f, 
    0.04693126f, -0.24076170f, -0.03653580f, -0.16125353f, -0.52088284f, -0.12769638f, -0.24664086f, -0.35417095f, 
    -0.31848428f, 0.17257236f, -0.12891841f, -0.51110423f, 0.35877496f, 0.49975756f, 0.21007259f, -0.35356933f, 
    0.18954845f, -0.20331761f, -0.33049384f, -0.42911470f, 0.16156627f, -0.04098223f, 0.06473035f, -0.03357385f, 
    -0.29478738f, -0.09533202f, -0.01659391f, 0.12476292f, -0.08048721f, -0.11868159f, -0.10242321f, -0.15503055f, 
    -0.50313115f, 0.23227386f, -0.60523546f, -0.63109237f, 0.10871591f, 0.32288221f, -0.54470873f, 0.29591736f, 
    -0.20198499f, 0.16253889f, 0.18281338f, 0.01459705f, 0.06115273f, 0.11782737f, 0.19738446f, -0.16729359f, 
    -0.12629917f, -0.24615362f, -0.09067427f, -0.05755360f, 0.20741501f, 0.06401105f, -0.02534618f, -0.10819375f, 
    0.13600253f, -0.40147358f, -0.62247014f, 0.48938617f, 0.17788994f, -0.41144449f, 0.19165701f, 0.36282212f, 
    0.50667727f, -0.49848768f, 0.10467875f, 0.00091195f, -0.12137944f, 0.15912855f, -0.12424552f, -0.09145460f, 
    -0.41994980f, -0.13336447f, -0.20383240f, -0.01159515f, -0.03894250f, -0.17801899f, 0.32240549f, 0.18623091f, 
    0.19995795f, 0.10300691f, -0.41111258f, 0.45105842f, 0.47976270f, -0.16078579f, 0.27729666f, -0.94870758f, 
    -0.19661756f, -0.62438244f, -0.76808780f, 0.00879545f, 0.18547936f, 0.26995373f, -0.08185635f, -0.01599566f, 
    0.06252181f, 0.12175889f, -0.40705293f, 0.02144308f, -0.25165644f, -0.06291959f, 0.22362590f, 0.03139346f, 
    0.17913899f, 0.05685972f, 0.00007996f, 0.69755119f, 0.07412013f, -0.34569997f, -0.79860693f, -0.61590219f, 
    0.03566242f, 0.01265590f, -0.13800964f, 0.05452057f, 0.30042234f, 0.31146762f, -0.37903652f, -0.15641949f, 
    -0.31770661f, -0.00275741f, -0.10197838f, 0.07136036f, -0.05325250f, 0.12937208f, 0.48675644f, -0.00990493f, 
    -0.06631163f, -0.38781163f, -0.13108955f, -0.19285515f, 0.07199615f, -0.37346289f, -0.25541067f, 0.08229844f, 
    0.04666989f, -0.24959250f, -0.31655324f, 0.45846736f, 0.40773743f, -0.44655794f, 0.03994182f, -0.49818796f, 
    0.24737613f, -0.12226607f, -0.46583176f, -0.03836631f, -0.10861947f, -0.13067754f, -0.16803892f, 0.13215548f, 
    -0.14770521f, 0.13060749f, -0.20118703f, -0.18171111f, -0.11139101f, -0.58829796f, 0.58107722f, 0.11430565f, 
    0.31908494f, 0.39978421f, -0.09716562f, 0.56413943f, 0.46438706f, 0.14632918f, 0.67503339f, -0.44639280f, 
    -0.27921480f, -0.12968612f, -0.00690314f, 0.03265675f, 0.05937116f, 0.00927049f, -0.14838506f, -0.01948554f, 
    0.08492739f, -0.01207376f, 0.09862898f, -0.15336505f, 0.11389262f, -0.20363228f, 0.87913924f, 0.66206080f, 
    0.40226242f, 0.01060410f, 0.22754073f, -0.58295387f, 0.05665443f, -0.02786991f, -0.35428935f, 0.03976847f, 
    0.08540965f, 0.02544760f, -0.01606881f, 0.28803048f, 0.06315098f, -0.00829516f, -0.04003742f, 0.17289339f, 
    0.15589081f, 0.21369946f, -0.28913626f, -0.12664531f, 0.00217531f, -0.19042797f, 0.30249846f, 0.89537537f, 
    0.30063447f, 0.21660312f, -0.54876530f, 0.15901902f, 0.16694897f, -0.61637157f, 0.44652778f, 0.22403210f, 
    0.37100402f, 0.25180367f, 0.36554325f, -0.38289887f, -0.00077514f, -0.04959561f, 0.06648009f, 0.00265379f, 
    -0.21189357f, 0.01624509f, -0.01498456f, 0.06470946f, 0.13200267f, 0.18287584f, -0.02775970f, 0.07560971f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.07246013f, 0.07446157f, 0.16301954f, 0.11891767f, 0.03669780f, -0.07000383f, 0.12563616f, 0.08079057f, 
    0.06563943f, 0.05707816f, 0.18709020f, 0.03133541f, 0.05927549f, 0.12472336f, 0.04051367f, 0.12442564f, 
    0.30043793f, 0.19300278f, 0.11867483f, 0.12516107f, 0.08636110f, -0.20817079f, 0.07582155f, -0.00313017f, 
    0.12456547f, -0.01818438f, 0.12599109f, 0.08216102f, 0.15444708f, 0.09039219f, 0.15719113f, 0.07266559f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.25788048f, -0.24106783f, -0.12108361f, 0.05321059f, 0.12811412f, -0.01193305f, 0.01444707f, -0.06511786f, 
    -0.01000044f, 0.05111818f, 0.14366008f, -0.02581647f, 0.01377453f, 0.01088807f, 0.03982197f, 0.03793463f, 
    0.06051981f, -0.03352751f, -0.11772658f, 0.04976438f, -0.03533207f, -0.01891989f, 0.00815536f, 0.00256021f, 
    -0.28822738f, 0.34714875f, -0.16976447f, -0.06429321f, 0.07875914f, -0.02803203f, -0.06705168f, -0.08164493f, 
    -0.03105446f, 0.00628588f, 0.11888255f, 0.09062448f, -0.10197016f, 0.28155902f, 0.08059616f, 0.11435730f, 
    0.16461168f, 0.21932124f, -0.14062321f, -0.05066562f, 0.05122710f, -0.03064475f, -0.04945654f, -0.01704836f, 
    -0.26814654f, -0.01614315f, -0.23536314f, -0.07928629f, -0.03800317f, -0.03067217f, 0.02145111f, 0.07969224f, 
    0.03069643f, -0.01908263f, 0.06120330f, 0.13847908f, 0.01330607f, 0.09100261f, 0.05260248f, 0.19334149f, 
    0.13312134f, 0.06757030f, -0.05472510f, -0.06990193f, 0.09505031f, 0.13421963f, -0.03554285f, 0.09159120f, 
    -0.00870957f, -0.20090897f, 0.28113836f, 0.23894471f, -0.06506715f, -0.03484253f, 0.03053449f, -0.00105297f, 
    -0.01053758f, 0.07555177f, 0.12132493f, -0.04612586f, -0.30414858f, 0.00792871f, 0.11274314f, -0.06799210f, 
    -0.21935800f, 0.10623767f, -0.07252039f, 0.02571194f, 0.02244212f, 0.06333658f, -0.04262795f, 0.02046488f, 
    -0.20441297f, 0.03103756f, 0.20035556f, 0.10126238f, 0.14618199f, 0.01715116f, 0.11758384f, 0.04168543f, 
    0.00476669f, 0.16432445f, 0.10494898f, -0.13977414f, -0.15634459f, -0.21832860f, 0.08687675f, 0.01164197f, 
    -0.02158523f, -0.20580374f, 0.00844294f, 0.12868802f, -0.07007141f, -0.00142199f, 0.04209283f, 0.02326945f, 
    -0.13892673f, -0.01394467f, 0.05020981f, 0.00420771f, 0.19897270f, -0.02904997f, 0.04130283f, 0.02076804f, 
    0.05952069f, 0.07622261f, 0.10364074f, -0.10265478f, -0.14598660f, 0.32411796f, -0.04180920f, 0.01490410f, 
    0.12032038f, -0.03819424f, 0.00619379f, 0.05308936f, -0.00275576f, -0.01395201f, -0.08570170f, -0.03089466f, 
    -0.11559100f, 0.08609851f, 0.16615376f, 0.00623454f, 0.20160577f, -0.06292554f, 0.06033592f, -0.03471147f, 
    0.10629977f, -0.00537772f, -0.00276211f, -0.02032218f, 0.20537201f, -0.22212322f, 0.03932057f, -0.02080362f, 
    -0.10981955f, -0.12068868f, 0.26045302f, 0.00746083f, 0.06885728f, -0.03646369f, -0.04293791f, 0.02535737f, 
    -0.10150097f, 0.04027488f, 0.10205419f, 0.16310857f, -0.07211773f, -0.09379914f, -0.06612886f, 0.11655010f, 
    -0.00804390f, -0.10622042f, -0.02091685f, 0.17564118f, -0.29722199f, 0.15722975f, -0.24778512f, -0.12387144f, 
    -0.10962752f, 0.04496878f, -0.00492916f, 0.01084254f, 0.06543280f, -0.03006355f, -0.02035925f, 0.02238536f, 
    0.08335183f, -0.06639095f, 0.11161584f, 0.00933534f, -0.15022558f, -0.08474179f, 0.07808644f, 0.07134568f, 
    0.05521109f, 0.08034660f, 0.11811750f, -0.06107653f, -0.31699499f, 0.14586155f, 0.05737373f, 0.00497314f, 
    0.11010437f, 0.04341842f, 0.02890621f, -0.00346270f, -0.07762676f, 0.10387062f, 0.04110694f, 0.06644953f, 
    -0.19852370f, -0.24827725f, -0.06489979f, -0.02005196f, -0.02951298f, 0.16934553f, 0.00158875f, 0.09148605f, 
    0.00616203f, 0.07694511f, -0.02586557f, 0.10275798f, 0.02959070f, -0.12260951f, 0.29412124f, 0.20937438f, 
    0.03127813f, -0.01060130f, 0.07245671f, -0.01737409f, -0.02253828f, -0.03132855f, -0.01473676f, 0.16314240f, 
    -0.20171684f, 0.15371269f, 0.19283892f, 0.33607987f, -0.10577851f, -0.11170750f, -0.14178026f, 0.05025572f, 
    -0.01661813f, -0.06246657f, 0.09257041f, 0.07842498f, -0.01751619f, 0.14759402f, 0.05749156f, 0.05084110f, 
    0.17172252f, -0.07628822f, -0.05730886f, 0.06158788f, 0.01713958f, -0.01285492f, 0.02912091f, 0.16051477f, 
    -0.33093327f, -0.16385981f, 0.15361936f, -0.02237341f, -0.18805496f, -0.03103503f, -0.01901429f, -0.07870752f, 
    0.08790591f, 0.14528398f, 0.00562288f, 0.04427418f, 0.14873517f, -0.09252643f, 0.02667792f, -0.35098049f, 
    -0.04815822f, -0.07740764f, 0.00451461f, 0.07662580f, 0.02005558f, -0.04939914f, -0.02106487f, 0.07719933f, 
    0.03815366f, 0.05841488f, 0.00360914f, 0.07765831f, 0.06505299f, 0.04225692f, -0.02709035f, 0.04853724f, 
    -0.06237880f, -0.01500049f, 0.03161788f, 0.09409714f, 0.41063058f, -0.11857624f, 0.06529861f, -0.25126976f, 
    0.08387298f, -0.03861430f, 0.03654681f, 0.01016227f, -0.00324939f, -0.03803941f, 0.02838054f, 0.10160555f, 
    -0.30924079f, 0.03657148f, -0.00535926f, -0.25475678f, -0.04074686f, 0.01496929f, 0.12356029f, -0.02898336f, 
    0.12474008f, 0.04109722f, 0.02836311f, 0.01585975f, -0.12464887f, 0.24197839f, 0.01021276f, 0.13774729f, 
    0.14778909f, -0.01126903f, 0.08189636f, 0.09832442f, 0.03354711f, 0.00844921f, 0.07918014f, -0.08530163f, 
    -0.12875819f, 0.10790648f, -0.00033967f, 0.08613938f, -0.02371321f, 0.06579178f, -0.00790374f, 0.16448899f, 
    -0.00483183f, 0.06223101f, 0.00443367f, 0.12211125f, 0.52787352f, -0.08345560f, -0.01769776f, 0.28520823f, 
    0.02246927f, -0.11056885f, 0.03458225f, 0.02521857f, 0.09784066f, -0.03228946f, -0.00602878f, 0.05140620f, 
    -0.23557441f, -0.10886960f, -0.02409280f, 0.13772424f, 0.26921791f, 0.11362078f, -0.07832915f, -0.09717469f, 
    0.03201945f, -0.01953719f, 0.10037409f, -0.06414863f, 0.06409752f, 0.28382453f, -0.10859260f, 0.09272233f, 
    0.01874156f, 0.07943861f, -0.00164208f, -0.05488567f, 0.10641721f, 0.10080571f, -0.09877023f, 0.07719847f, 
    -0.03630613f, 0.02031603f, 0.03258369f, -0.00674315f, 0.02675583f, 0.04313129f, -0.05407439f, 0.01126664f, 
    -0.03127565f, 0.00013395f, -0.04191248f, -0.00253759f, 0.02551945f, -0.00910017f, 0.01894155f, 0.01035862f, 
    -0.00478130f, -0.00413238f, -0.02616800f, 0.02224803f, -0.02206798f, 0.02108010f, 0.00120604f, -0.00057690f, 
    -0.02062990f, -0.02993100f, -0.03606441f, -0.01627796f, 0.01979526f, -0.00473396f, -0.03052426f, -0.01192877f, 
    -0.03826810f, 0.01950184f, 0.02846436f, -0.05876634f, 0.00929221f, 0.02449490f, -0.01585977f, -0.03932610f, 
    0.01322379f, 0.01095246f, -0.02316606f, 0.00185579f, -0.02577935f, 0.04027262f, 0.00270621f, -0.02262617f, 
    -0.00406409f, 0.00624764f, -0.01358324f, 0.02486055f, 0.02320109f, -0.04626621f, -0.00357309f, 0.02307075f, 
    0.01600216f, 0.01999660f, -0.03698837f, 0.03561861f, 0.01540969f, -0.00797984f, 0.00932433f, -0.04031331f, 
    -0.00774535f, 0.00351441f, -0.04275033f, 0.01659947f, -0.01103547f, -0.04686340f, 0.01566171f, -0.00242582f, 
    0.01326565f, 0.03285858f, 0.02825796f, -0.03837483f, -0.02136527f, 0.00364683f, -0.00677956f, -0.00533564f, 
    -0.02247011f, -0.01284130f, -0.03335257f, -0.04406682f, 0.04034340f, 0.01531110f, 0.03229498f, -0.03051093f, 
    -0.06091252f, 0.01506242f, 0.00131833f, -0.03749359f, -0.05012167f, -0.01107823f, -0.00483751f, 0.04415716f, 
    0.02346074f, -0.02178345f, -0.02212547f, -0.03368000f, -0.01170504f, -0.02505015f, -0.04003693f, 0.03354358f, 
    -0.04053104f, 0.01085983f, -0.00700000f, -0.03253249f, -0.03150840f, 0.00334622f, -0.03545740f, -0.01829382f, 
    0.03262912f, 0.03746189f, -0.03027735f, -0.02862898f, 0.02409773f, -0.05605492f, 0.03466401f, -0.05421675f, 
    -0.05394529f, -0.03044468f, 0.01859847f, 0.00956597f, 0.00839381f, 0.03978284f, -0.01218380f, 0.01252260f, 
    0.02862108f, -0.02232273f, 0.02636559f, 0.02995166f, -0.00011761f, -0.00778436f, -0.02445489f, 0.03833335f, 
    -0.01325808f, 0.00942188f, 0.02888435f, -0.03298314f, 0.04542501f, 0.01367384f, -0.04307941f, -0.03597892f, 
    -0.05563316f, -0.04474742f, -0.03076205f, -0.04457465f, 0.00394442f, 0.00759314f, 0.01174331f, -0.04219198f, 
    -0.01130015f, -0.03230796f, -0.03999019f, -0.03811119f, -0.05190964f, -0.04135584f, -0.02628000f, -0.04350028f, 
    -0.02257612f, -0.00875450f, -0.01993484f, 0.01400921f, -0.05574375f, 0.00956649f, 0.00572561f, -0.00298042f, 
    -0.01006567f, 0.03082687f, -0.02602529f, -0.03981519f, 0.01581785f, 0.02784166f, -0.03396539f, 0.00546328f, 
    -0.01192379f, -0.02693682f, 0.02335770f, -0.03905220f, 0.02715765f, 0.02424087f, 0.03763423f, 0.01423233f, 
    0.00287587f, 0.02952705f, 0.04501466f, 0.01581021f, 0.03511558f, -0.04644453f, 0.03149869f, -0.01275119f, 
    0.04688765f, 0.00425454f, 0.01191398f, 0.03481941f, -0.04472748f, 0.02294802f, -0.04708386f, 0.01884168f, 
    -0.05440453f, 0.01799712f, -0.04646187f, 0.03721997f, -0.05218954f, 0.02297674f, -0.01668131f, 0.02225931f, 
    -0.03614859f, 0.02562219f, -0.00406392f, -0.03726733f, -0.05159124f, 0.02676723f, -0.00567723f, -0.02528706f, 
    -0.02519628f, -0.03166184f, -0.02235354f, -0.04543003f, 0.04558724f, 0.01646945f, 0.00467486f, 0.03042674f, 
    -0.05143116f, 0.04081787f, -0.01579445f, 0.04496698f, -0.04828006f, -0.04381371f, -0.01092728f, -0.00308307f, 
    -0.05690901f, -0.02313909f, 0.02661569f, -0.03328397f, -0.05599624f, -0.05241242f, -0.01905585f, 0.04365469f, 
    -0.04575152f, 0.04862376f, -0.05183818f, 0.00866457f, -0.02334350f, -0.02403608f, 0.00614349f, 0.04706813f, 
    0.03871625f, 0.01043331f, -0.00328915f, -0.01750358f, -0.01651645f, -0.01035675f, 0.01498010f, -0.00442544f, 
    -0.00851707f, -0.03297469f, -0.00577013f, -0.00716840f, -0.04390746f, -0.01865159f, 0.03541457f, 0.00929058f, 
    0.04109238f, -0.02972248f, 0.04171977f, 0.04066195f, 0.00388100f, 0.00857113f, -0.03562406f, -0.01851599f, 
    0.03051746f, -0.00088727f, -0.03293363f, 0.00207954f, 0.02003513f, 0.01685985f, 0.03506587f, -0.02995006f, 
    -0.03781623f, 0.01078662f, 0.01000442f, -0.00521602f, 0.02350012f, -0.05352660f, 0.00092822f, 0.00935660f, 
    0.01347808f, 0.02553403f, 0.00894380f, 0.00800561f, 0.02227246f, -0.02971315f, -0.00383213f, -0.00018889f, 
    0.00277987f, -0.03595041f, -0.03994345f, -0.03935530f, 0.02901664f, -0.02334072f, -0.04498482f, -0.03519693f, 
    -0.05306089f, 0.02257512f, -0.05336050f, 0.04252570f, 0.00645564f, 0.02149935f, -0.01378709f, 0.04847275f, 
    -0.04791803f, -0.04619992f, -0.00187539f, 0.00627560f, 0.02508880f, 0.00522126f, 0.02958834f, 0.02490070f, 
    0.01503114f, 0.05321718f, -0.00746219f, 0.01734545f, 0.01306302f, 0.01780749f, -0.02393207f, 0.02301200f, 
    -0.03928445f, -0.00583030f, 0.00808683f, -0.00292599f, -0.04686644f, 0.00077412f, 0.04442543f, 0.02195605f, 
    0.00507497f, -0.01505223f, 0.02517213f, 0.02717483f, 0.03032907f, 0.02516505f, -0.04372713f, -0.00687037f, 
    -0.05643640f, -0.05360406f, -0.05322897f, 0.04555181f, 0.00182521f, -0.04537995f, -0.01725042f, -0.02479223f, 
    -0.01931826f, 0.03353844f, -0.03126956f, -0.04326383f, 0.02763492f, -0.05329916f, 0.01834371f, -0.00646854f, 
    -0.05863883f, 0.01079758f, 0.03639537f, -0.03498022f, 0.00307330f, -0.00293986f, 0.02277659f, -0.00848787f, 
    -0.02389841f, -0.00539283f, 0.00583043f, -0.01538783f, 0.03617708f, -0.01007241f, -0.00344310f, 0.02006477f, 
    0.01564863f, 0.02099208f, 0.01471821f, 0.03994314f, -0.05076044f, -0.00663496f, 0.01618830f, 0.03445159f, 
    0.00142872f, 0.02346677f, 0.03985260f, 0.02678991f, -0.01116325f, 0.00933608f, -0.04305712f, -0.00116122f, 
    -0.03719572f, -0.00860640f, -0.05340412f, 0.00022881f, -0.04685057f, 0.04238241f, -0.02678281f, 0.03172778f, 
    0.03447765f, -0.03599718f, -0.01258637f, -0.03733892f, -0.04428474f, -0.03681466f, -0.03520932f, -0.02345994f, 
    0.00931272f, 0.03845675f, -0.02434712f, -0.00014192f, -0.00676321f, -0.02735212f, -0.00129764f, -0.04434244f, 
    0.01668968f, -0.00534198f, 0.03879730f, -0.03516500f, 0.03527583f, -0.03838186f, 0.00283724f, 0.00812078f, 
    0.00388185f, -0.02106523f, -0.02195423f, -0.05550110f, -0.02780151f, -0.00911800f, -0.03472611f, -0.02876129f, 
    0.01729364f, -0.05159520f, -0.01272906f, -0.02134729f, 0.01676778f, 0.03096720f, -0.04167117f, 0.01162504f, 
    -0.01285769f, -0.04935148f, -0.00604620f, 0.04391987f, 0.03524985f, 0.01071106f, 0.03027803f, 0.01357899f, 
    -0.05162748f, 0.00960951f, -0.00057071f, -0.02996563f, 0.02116812f, 0.03824560f, -0.04639217f, -0.02731774f, 
    0.01197385f, -0.04389041f, 0.01128238f, -0.03730501f, -0.02886189f, 0.02418537f, -0.04126834f, 0.01470811f, 
    -0.04429223f, 0.01071802f, 0.03295157f, 0.01250006f, 0.02925006f, 0.00150431f, -0.03180583f, 0.04107080f, 
    -0.00246976f, -0.01186596f, 0.04162876f, -0.04513265f, 0.02865492f, 0.03988995f, 0.01711410f, -0.05758495f, 
    0.03281249f, -0.05506341f, 0.01743068f, -0.00029977f, -0.03929291f, -0.01364494f, -0.02812206f, 0.04088499f, 
    0.00256149f, -0.00258334f, 0.03514162f, -0.01901931f, 0.00273398f, 0.04009094f, 0.01482089f, -0.01947306f, 
    -0.03174355f, 0.04139757f, 0.03816948f, 0.04002935f, 0.02394324f, 0.01595293f, -0.02720215f, -0.04357567f, 
    -0.04699732f, -0.03062109f, -0.00779013f, -0.02677971f, -0.01246098f, 0.01810743f, -0.03091007f, 0.01320015f, 
    -0.03302382f, -0.04927222f, 0.00992873f, -0.03287793f, -0.01870682f, -0.04787596f, -0.01213124f, 0.03418725f, 
    -0.03450369f, -0.02354242f, 0.02969078f, -0.04311089f, 0.01851430f, 0.01813353f, -0.05691414f, -0.05538700f, 
    -0.03444058f, 0.01559845f, 0.03694009f, 0.03483308f, -0.02188822f, 0.03223022f, -0.01738415f, -0.00106571f, 
    -0.05315725f, -0.01375992f, 0.04285314f, -0.00138466f, -0.02312920f, 0.01680207f, 0.01829966f, 0.02279488f, 
    0.02817868f, -0.02836238f, 0.03971982f, -0.04576408f, 0.04268545f, 0.01507160f, 0.02952998f, -0.05618328f, 
    -0.01930205f, -0.00732341f, -0.01976802f, -0.02668163f, 0.00012896f, 0.04171602f, -0.01589131f, -0.01776457f, 
    -0.01054421f, -0.00282792f, 0.02120411f, 0.03488462f, 0.00179415f, 0.04971158f, 0.03607859f, 0.01491139f, 
    -0.01304858f, 0.00281565f, -0.03056202f, -0.03607049f, 0.03337648f, 0.00076540f, 0.01070796f, -0.02251050f, 
    0.01057028f, 0.02023665f, -0.05584975f, 0.02836202f, 0.03444916f, 0.03113405f, -0.04741814f, -0.00246218f, 
    0.00688896f, -0.05738564f, -0.00907934f, 0.03917442f, -0.01206580f, 0.01185518f, -0.05723909f, -0.05289116f, 
    0.00073703f, 0.02384203f, 0.00720995f, 0.00292755f, 0.00787968f, -0.04996030f, -0.01610884f, -0.04875711f, 
    -0.02437276f, -0.04963079f, -0.00902593f, -0.02526502f, -0.00352400f, 0.03715927f, 0.00367744f, -0.05145430f, 
    -0.03036177f, 0.00065786f, -0.05434318f, 0.03123550f, -0.02698249f, 0.02344109f, -0.04040378f, -0.03247132f, 
    -0.02697182f, 0.01974587f, -0.00191771f, 0.02282328f, -0.02250861f, 0.02909162f, -0.00216570f, 0.02031849f, 
    -0.01362529f, 0.01292626f, -0.04664722f, 0.04271143f, -0.02401185f, -0.02102967f, 0.00033346f, -0.04237408f, 
    -0.01384751f, -0.00334859f, -0.05760600f, -0.02202831f, 0.00070768f, 0.00662782f, -0.03544822f, 0.03408860f, 
    -0.02717088f, 0.04329749f, -0.02768105f, -0.02768237f, 0.00118689f, -0.05273457f, -0.04413545f, 0.04256487f, 
    0.01932095f, -0.02740109f, -0.05931150f, -0.01284117f, -0.02095347f, -0.04097397f, -0.00840939f, 0.02995213f, 
    -0.03571529f, -0.05882047f, 0.01899385f, -0.04298662f, -0.02183139f, -0.00828275f, -0.03897662f, -0.04867609f, 
    0.00060231f, 0.01699691f, -0.05798774f, 0.00064858f, -0.00577357f, -0.03957620f, 0.01161728f, -0.01885185f, 
    0.03025991f, -0.05559187f, -0.05062658f, 0.00816218f, -0.04666995f, -0.02675466f, -0.02238597f, -0.03057212f, 
    -0.03695464f, -0.01888749f, -0.03932257f, -0.04031080f, -0.01090785f, -0.05555992f, -0.01100648f, -0.04666149f, 
    -0.00024695f, -0.03280122f, -0.02351195f, -0.00124636f, -0.04910861f, -0.04117206f, -0.00635818f, -0.03918891f, 
    -0.02765018f, 0.00242219f, 0.02578475f, -0.02034371f, -0.01433242f, -0.02308762f, -0.04181211f, -0.02250643f, 
    -0.00855087f, -0.00206228f, -0.03402149f, 0.00476334f, -0.02382171f, -0.00042992f, -0.03817658f, -0.05368640f, 
    0.02134681f, 0.04043295f, -0.04125590f, 0.01964597f, 0.00939196f, -0.00210612f, -0.04132744f, -0.03161506f, 
    -0.01316832f, -0.00073327f, -0.04900108f, -0.05090169f, -0.03485081f, 0.02641864f, -0.01967796f, -0.05755740f, 
    -0.04805690f, 0.02353090f, -0.03427685f, -0.00620906f, 0.03038374f, 0.01125914f, -0.04437387f, 0.02663257f, 
    -0.05739060f, -0.00401252f, -0.02140893f, -0.00065631f, -0.04722809f, 0.01280691f, -0.01918296f, -0.03884200f, 
    0.00517359f, -0.01880391f, -0.04786012f, 0.03091849f, 0.03780479f, 0.00994522f, 0.00927450f, 0.01841922f, 
    0.01226397f, -0.02401762f, 0.01088805f, 0.00422491f, -0.02114385f, -0.04001519f, -0.03577093f, 0.02025179f, 
    -0.02405181f, -0.00180209f, -0.00011828f, -0.01053076f, -0.01881991f, 0.00110143f, 0.02612809f, 0.00938064f, 
    0.17083175f, 0.01571224f, -0.21305197f, -0.05133122f, 0.04211554f, -0.08545453f, -0.19711229f, -0.02991770f, 
    0.04573384f, 0.05588682f, 0.06749941f, 0.12130395f, 0.10571840f, -0.08481658f, 0.10641438f, -0.14220379f, 
    -0.04862642f, -0.01176378f, 0.17568596f, 0.06481207f, -0.02869554f, 0.02298851f, 0.10670818f, -0.00002641f, 
    0.01242488f, -0.17610981f, -0.04777176f, 0.07543410f, 0.05248852f, -0.17204627f, 0.07675678f, -0.01528132f, 
    -0.06647263f, 0.17194155f, -0.13680705f, -0.08293214f, 0.46738353f, -0.04669423f, -0.07638999f, -0.22937325f, 
    0.11097547f, -0.08651659f, 0.11001983f, -0.02738285f, -0.02239132f, 0.04207536f, 0.02802351f, 0.08124843f, 
    -0.00609858f, -0.05035664f, 0.04280126f, 0.22852263f, -0.10555338f, -0.01496152f, 0.03114200f, 0.24665587f, 
    -0.08724701f, 0.07607933f, -0.07052302f, 0.16480458f, 0.16454546f, 0.01055730f, -0.13042435f, -0.17491724f, 
    0.21614781f, -0.03837089f, -0.01354179f, 0.02245751f, 0.04834507f, -0.15967004f, 0.00379819f, 0.23229302f, 
    -0.02441821f, 0.11515030f, -0.32447970f, 0.07321830f, 0.10507328f, -0.01231236f, -0.04321548f, 0.16403304f, 
    -0.05548321f, 0.01395171f, -0.02027996f, -0.06414445f, 0.00060791f, -0.19462913f, -0.08103961f, 0.17090976f, 
    0.02326735f, -0.16102399f, -0.00521732f, -0.01371365f, 0.01867821f, 0.05798739f, 0.18211915f, 0.16965167f, 
    0.14004564f, 0.01834794f, -0.22645164f, 0.05286682f, 0.00265500f, 0.03726744f, -0.15292463f, -0.03299638f, 
    0.02119859f, 0.02155034f, 0.01365316f, 0.23810178f, -0.15758158f, 0.18218765f, -0.13260013f, -0.03935485f, 
    0.02175591f, 0.26763231f, -0.07978909f, -0.01034881f, 0.11259903f, -0.10696444f, -0.11812051f, -0.15456679f, 
    0.23626953f, 0.00537478f, -0.03455086f, 0.08341042f, -0.07743073f, 0.08266897f, 0.09444982f, 0.01774436f, 
    -0.02759185f, -0.16097924f, -0.10609318f, 0.10212354f, 0.23817430f, 0.01485302f, 0.13152651f, 0.02309063f, 
    0.14823934f, 0.15511718f, -0.05382868f, -0.03879811f, -0.01066630f, 0.18949214f, 0.06789487f, 0.18032466f, 
    0.07349123f, 0.03015191f, -0.23076355f, 0.12862369f, 0.07904176f, -0.04299564f, -0.02667399f, 0.00960650f, 
    0.05678970f, 0.04392389f, 0.02694485f, 0.12131675f, 0.05329503f, -0.06813736f, 0.02852938f, -0.01167134f, 
    0.02281427f, 0.09250640f, -0.16685817f, -0.04444948f, 0.10695214f, 0.08945743f, 0.12772517f, -0.00874137f, 
    0.07556358f, -0.08142675f, -0.10954059f, -0.00973666f, 0.26385605f, 0.03858821f, 0.08283568f, -0.00022101f, 
    0.12757970f, 0.07342990f, -0.03091180f, -0.09410358f, 0.01795870f, 0.06392057f, 0.29460666f, 0.07760288f, 
    0.13777465f, 0.01410687f, -0.03923327f, 0.04320252f, -0.01771880f, -0.03777782f, 0.11029561f, -0.06901951f, 
    -0.30519056f, 0.28017488f, -0.20838960f, -0.11654847f, 0.23498815f, 0.06282518f, -0.07851219f, 0.04651079f, 
    0.04415061f, -0.03774480f, -0.05195275f, 0.16509548f, 0.25359142f, -0.08897818f, 0.05446105f, 0.10246117f, 
    0.08577735f, -0.00245711f, 0.05104848f, -0.13766618f, 0.11127559f, -0.07896493f, -0.05193162f, 0.04422685f, 
    -0.00062737f, -0.00308203f, 0.07497329f, 0.18157339f, 0.07783969f, -0.04280866f, 0.06588164f, -0.08507617f, 
    -0.03382288f, -0.06086776f, 0.21027647f, -0.09559298f, -0.26176748f, 0.31592020f, -0.27688450f, 0.05569876f, 
    0.18199399f, 0.03129609f, -0.06973781f, -0.02417539f, 0.10508496f, -0.00742188f, 0.03044040f, -0.07261278f, 
    0.06739471f, -0.23876855f, -0.07649451f, -0.13379879f, 0.12704264f, 0.02518926f, 0.06361289f, 0.19547427f, 
    0.10608215f, 0.06432096f, -0.14700799f, -0.05376136f, -0.14944138f, 0.07548602f, -0.13180199f, -0.07788266f, 
    0.10690930f, -0.03756490f, 0.12462255f, 0.05160500f, 0.05979449f, 0.14752902f, -0.09215284f, 0.10204642f, 
    -0.02016607f, 0.09422190f, -0.13175121f, 0.17477977f, 0.27153918f, 0.05923948f, 0.04793174f, -0.07923489f, 
    -0.07116000f, -0.05307160f, 0.18686999f, -0.08982548f, -0.31262177f, 0.19305095f, -0.05313419f, 0.01857655f, 
    0.01703934f, 0.01231014f, 0.03602898f, 0.02875664f, 0.15793997f, 0.05011048f, -0.09724710f, -0.09860121f, 
    0.06623445f, -0.31127521f, -0.00878081f, 0.04264021f, 0.03119553f, 0.03114453f, 0.03366060f, 0.10595340f, 
    0.10130526f, 0.03198257f, -0.02192810f, -0.00715698f, -0.64737678f, 0.20276077f, -0.11252553f, 0.13568076f, 
    -0.06014004f, -0.02240969f, -0.02245697f, 0.07641625f, 0.03739517f, 0.08623692f, -0.01279338f, -0.11740543f, 
    0.28606173f, -0.05429304f, 0.10231093f, 0.24973771f, -0.09094686f, -0.11423410f, -0.01420241f, 0.05805146f, 
    -0.02170346f, 0.05959317f, 0.02411353f, 0.17272687f, 0.31854501f, -0.07838458f, 0.24003406f, 0.02942974f, 
    -0.04219431f, 0.03086329f, 0.07755926f, -0.09879144f, -0.10123201f, 0.12584539f, -0.03949253f, 0.15091576f, 
    0.01950231f, -0.09169818f, -0.07755245f, 0.10436918f, 0.03591887f, 0.01894340f, -0.04877516f, -0.03472334f, 
    0.02400056f, 0.00969750f, -0.13402520f, -0.05987595f, -0.02789276f, 0.05328823f, 0.01603894f, -0.14069489f, 
    0.01033552f, 0.03830909f, 0.06606761f, -0.01874349f, -0.05288141f, -0.00315686f, -0.00211403f, 0.01016790f, 
    0.29044059f, 0.05801868f, 0.03502004f, 0.02316269f, -0.10344515f, 0.07898150f, 0.06358285f, -0.06998819f, 
    0.07828730f, -0.00045019f, 0.10799633f, 0.22170565f, 0.46589488f, -0.08764197f, 0.22918588f, -0.17870343f, 
    0.02549925f, -0.14596106f, 0.09824976f, -0.00263314f, -0.06965374f, -0.07728555f, 0.03103773f, 0.02031324f, 
    -0.30133942f, 0.13118692f, 0.16344307f, -0.04490242f, 0.00563460f, 0.07862994f, 0.06842100f, 0.09981212f, 
    -0.09041231f, 0.02431668f, -0.12358680f, 0.04008520f, -0.06737830f, -0.04886704f, -0.08114561f, 0.08450817f, 
    0.04929639f, 0.07062411f, -0.07104213f, 0.04791088f, 0.05512546f, 0.09163761f, 0.00893358f, -0.08593753f, 
    0.23447828f, -0.16130659f, 0.20556559f, 0.10914586f, -0.06718711f, 0.11178984f, 0.02295534f, 0.08111086f, 
    0.14202283f, -0.02780909f, 0.00026899f, 0.03680400f, -0.31384915f, -0.26406953f, -0.05337964f, -0.04495794f, 
    -0.00153504f, -0.03817154f, 0.06078221f, -0.03994144f, -0.00652813f, 0.01195309f, 0.05272675f, 0.05260718f, 
    0.34488416f, 0.07184224f, 0.12706950f, -0.01889762f, 0.10695159f, 0.04301773f, 0.02356971f, -0.18368371f, 
    0.06619618f, 0.07754827f, -0.00217400f, -0.13739882f, -0.14372528f, -0.23184018f, -0.17248400f, -0.09904577f, 
    -0.13160612f, 0.07137994f, 0.01688923f, -0.03129039f, -0.10032313f, -0.04017203f, -0.05381661f, -0.13511302f, 
    0.23936751f, 0.11236804f, 0.11680825f, -0.08687172f, -0.03866507f, 0.00267780f, 0.02037307f, -0.08861195f, 
    0.01680396f, 0.03611865f, 0.01336437f, 0.14020696f, 0.23638064f, 0.11376344f, 0.06828859f, 0.08360661f, 
    0.09164553f, -0.01245865f, 0.14873385f, 0.00733556f, 0.01290936f, 0.08347051f, -0.04756286f, 0.00017551f, 
    -0.13438767f, -0.15196662f, -0.01285172f, -0.12412485f, -0.01230193f, 0.04427730f, -0.00989642f, -0.06524307f, 
    0.00586654f, -0.04943865f, -0.03899688f, 0.06238481f, 0.29518032f, 0.20013751f, 0.14557682f, 0.11086515f, 
    -0.02644203f, -0.00370484f, 0.06837037f, -0.04366676f, 0.09667160f, -0.02214033f, 0.05090577f, 0.09186902f, 
    -0.21087548f, -0.05980245f, -0.04345988f, -0.10100459f, -0.04551805f, 0.09291246f, -0.11113929f, 0.02052797f, 
    0.04716028f, 0.07735126f, 0.08507171f, 0.12349644f, -0.21603884f, -0.20601608f, -0.16305552f, -0.17302802f, 
    0.02355026f, -0.01090832f, 0.03937315f, -0.04100086f, 0.02161375f, -0.12981780f, 0.05145578f, -0.02673368f, 
    0.06775846f, -0.10472258f, -0.10077221f, -0.11581532f, -0.06457914f, 0.07104224f, -0.04507425f, 0.01300229f, 
    -0.10853502f, -0.04133008f, -0.03575623f, -0.03387806f, -0.05220836f, 0.22453742f, -0.03906105f, 0.06377181f, 
    0.10345504f, -0.02187012f, -0.06324077f, 0.03075889f, -0.07235396f, 0.07949730f, 0.00983592f, 0.07227091f, 
    0.10816769f, 0.10523652f, 0.06964850f, 0.02437278f, -0.13536219f, 0.11569078f, 0.03412267f, 0.00894586f, 
    -0.08724742f, 0.05870964f, 0.02819886f, -0.09633137f, 0.24146126f, -0.14111373f, 0.11198496f, 0.06990217f, 
    -0.02889517f, 0.00958478f, 0.02171526f, 0.10481019f, 0.00791758f, 0.04112032f, 0.02229421f, 0.03327297f, 
    0.17028351f, -0.21130472f, -0.03224144f, 0.11407816f, -0.04520737f, -0.01197860f, 0.07396508f, -0.01970312f, 
    0.03166048f, 0.05602817f, 0.03035450f, 0.09606959f, -0.07437994f, -0.04317002f, 0.08596992f, -0.09747085f, 
    0.03570096f, 0.07561164f, -0.00266522f, 0.02433584f, -0.03045083f, -0.09987549f, 0.05190991f, -0.13496673f, 
    0.14492631f, 0.23304170f, 0.09814400f, -0.03565113f, -0.07213230f, -0.03822789f, 0.01326545f, -0.03114865f, 
    0.00670388f, 0.00930551f, -0.00100318f, -0.00349927f, 0.33217686f, -0.02881582f, 0.07481377f, -0.02822371f, 
    -0.17954625f, 0.02059028f, -0.04337811f, 0.04537236f, 0.06586014f, 0.10777172f, 0.00712763f, 0.06628390f, 
    0.27174729f, 0.24251421f, -0.03793202f, -0.03915688f, -0.04316683f, -0.02027095f, 0.13759871f, -0.06405017f, 
    0.07811537f, 0.03435041f, 0.02222231f, 0.07348574f, 0.04064571f, -0.27102351f, -0.06232033f, 0.05871470f, 
    0.02583598f, -0.05941040f, -0.07548685f, -0.10060131f, 0.06212214f, -0.10861210f, 0.06617580f, -0.15209185f, 
    0.37423140f, 0.17818110f, -0.04039533f, 0.06337015f, -0.00957399f, -0.17036878f, 0.02103567f, 0.14383948f, 
    -0.06420331f, -0.17687659f, -0.07016931f, 0.09622998f, 0.23597158f, 0.01298269f, 0.12230391f, 0.25472027f, 
    0.06681542f, 0.03874279f, 0.06871422f, 0.05255486f, -0.03652636f, -0.01607183f, -0.06017158f, 0.08988766f, 
    0.08273486f, 0.20582411f, 0.04303978f, -0.03009682f, -0.12210374f, 0.02720729f, 0.11315243f, -0.02769155f, 
    -0.02949800f, 0.07756543f, -0.01497699f, -0.01572962f, 0.23460141f, 0.02278612f, 0.08711480f, 0.21321502f, 
    0.01824999f, 0.04512363f, 0.00705167f, -0.06324407f, 0.14934495f, -0.01062169f, -0.05945364f, 0.07552727f, 
    0.13116169f, 0.07793522f, 0.04571536f, 0.04969334f, 0.22394815f, 0.11399909f, -0.01622128f, 0.05605861f, 
    -0.05360234f, 0.01016567f, 0.05781313f, -0.04943710f, -0.15569197f, -0.06509671f, -0.04535240f, -0.12243827f, 
    -0.07793889f, 0.00780103f, -0.01187811f, -0.02137093f, 0.07752062f, -0.04341301f, -0.04171520f, -0.05513976f, 
    0.16933015f, -0.01378814f, 0.17644341f, -0.07174140f, 0.02299439f, 0.01112338f, 0.10483944f, -0.07672098f, 
    0.07461488f, -0.01941352f, 0.05733709f, 0.06431259f, -0.38157347f, -0.08960190f, -0.14268750f, -0.11055104f, 
    0.09199265f, 0.06552398f, -0.07884586f, 0.07782167f, -0.04481926f, 0.04244891f, 0.02768179f, 0.07707619f, 
    -0.22851248f, -0.04707427f, 0.01029094f, -0.14779492f, -0.04124095f, 0.00581432f, 0.01809564f, 0.08797694f, 
    -0.02015016f, -0.03104917f, -0.07265037f, -0.04470173f, -0.40377432f, -0.30378303f, -0.05085410f, -0.01280781f, 
    0.05715101f, 0.09748730f, 0.10024893f, -0.03839846f, 0.09416497f, 0.05237073f, 0.05144437f, 0.04365247f, 
    -0.00693002f, -0.03772604f, 0.01360250f, 0.04534732f, -0.04184723f, -0.00827606f, -0.03175062f, 0.01689333f, 
    -0.05423931f, -0.01982483f, -0.00240277f, 0.04534346f, 0.03527200f, 0.02738399f, -0.02651794f, -0.02770922f, 
    -0.05197315f, 0.00227261f, -0.04174818f, 0.04107883f, -0.02808050f, -0.01793007f, 0.02615601f, 0.02202351f, 
    -0.01100743f, -0.04675024f, -0.03411911f, -0.03604316f, 0.02224293f, 0.03401582f, -0.00798757f, 0.03458646f, 
    -0.00396157f, -0.04228340f, -0.02848594f, 0.01091946f, -0.02835154f, 0.00246302f, 0.03789240f, 0.01147258f, 
    -0.04993899f, -0.04357647f, 0.04404179f, -0.02949912f, -0.02544651f, 0.01732396f, -0.05470315f, -0.05424079f, 
    -0.02112104f, 0.01703296f, 0.02709902f, 0.02202256f, 0.03613550f, -0.05518164f, -0.03369382f, -0.01467967f, 
    0.00051338f, 0.01467932f, 0.02551639f, -0.00868165f, -0.05384517f, 0.03300085f, -0.03238096f, -0.03107930f, 
    -0.00286971f, -0.00250662f, 0.01124957f, 0.01566895f, -0.01088092f, -0.00738064f, -0.04380449f, 0.00608128f, 
    -0.01869688f, 0.02502226f, 0.04552311f, 0.03419652f, 0.01744779f, -0.03848133f, 0.01141967f, -0.05329462f, 
    -0.01815072f, -0.04446718f, -0.01030813f, -0.03547502f, -0.02643105f, 0.02858835f, -0.01652968f, 0.02110458f, 
    -0.00670133f, 0.02684261f, 0.04030868f, -0.02734195f, -0.04804645f, -0.01438876f, -0.02188558f, -0.05542961f, 
    0.01038645f, 0.01844381f, -0.03004195f, -0.04048682f, -0.04409777f, 0.01625233f, -0.04698506f, 0.04339908f, 
    0.03289982f, -0.04996661f, -0.01978188f, 0.04499892f, -0.01474419f, -0.01337329f, -0.04845736f, -0.01384420f, 
    0.00559101f, -0.04408730f, 0.02134121f, 0.00887102f, 0.00550958f, -0.03777523f, -0.03355316f, 0.00801611f, 
    -0.05631582f, -0.03150951f, 0.03308954f, 0.02036600f, -0.00429723f, 0.01430772f, -0.05165547f, -0.00017096f, 
    0.00285545f, -0.02674371f, 0.01558163f, -0.05440327f, -0.05502133f, -0.04633074f, -0.05206226f, 0.04351583f, 
    0.01440921f, 0.03349603f, -0.03016759f, -0.01680537f, 0.04458659f, 0.01962581f, -0.00649541f, -0.04831554f, 
    0.00527316f, 0.04582122f, 0.02337111f, -0.03155192f, 0.02418029f, -0.03190760f, -0.01464259f, -0.04084790f, 
    0.01893916f, 0.02002950f, 0.03449000f, -0.05154365f, -0.00709306f, -0.03953117f, -0.03967929f, -0.03264904f, 
    0.01126930f, -0.00495750f, 0.02604171f, 0.02575055f, -0.00557366f, -0.02608477f, -0.04189156f, 0.02201007f, 
    -0.04740351f, 0.03565916f, 0.01451752f, -0.04249861f, -0.01246837f, -0.02267891f, 0.01519863f, -0.02125752f, 
    -0.04042120f, -0.03290984f, -0.00750194f, -0.02898351f, -0.03423607f, 0.01499281f, 0.03638647f, 0.00614769f, 
    0.01960949f, -0.01803676f, 0.03960382f, 0.00950758f, -0.00390521f, -0.02495387f, -0.01021941f, 0.02692760f, 
    -0.02723043f, -0.04040170f, -0.05493609f, 0.01977988f, 0.02936058f, -0.01490447f, 0.02901852f, -0.02673730f, 
    0.02698958f, -0.04637845f, 0.03539249f, -0.05052431f, -0.02972756f, -0.00451605f, -0.03684621f, 0.04626714f, 
    0.00185541f, -0.02724747f, 0.04111701f, 0.02095396f, -0.05150274f, -0.02633982f, 0.00534993f, 0.04487647f, 
    -0.05156639f, 0.00653321f, 0.01463798f, -0.05096781f, 0.02902500f, -0.02982595f, -0.05594018f, 0.03287066f, 
    -0.05537703f, 0.00931293f, 0.04374762f, -0.04844939f, -0.03442632f, -0.01332837f, 0.03854241f, -0.02211120f, 
    -0.01799805f, 0.01441256f, -0.01725777f, -0.03689759f, 0.03344290f, -0.02105698f, 0.00250438f, 0.03828157f, 
    -0.03689332f, 0.01902473f, 0.01205285f, 0.02450357f, -0.03376552f, -0.02487071f, -0.03264353f, 0.01899824f, 
    -0.04503584f, 0.04305035f, 0.01941309f, -0.02783799f, -0.03073063f, 0.01164400f, 0.03986764f, 0.04057373f, 
    0.01564878f, -0.05525847f, 0.00986725f, -0.04860882f, -0.00737598f, -0.01127431f, 0.03710973f, 0.00259233f, 
    0.00416475f, 0.03061396f, -0.03984345f, -0.03155297f, 0.00628213f, -0.01427215f, -0.02871007f, 0.00135921f, 
    0.04279686f, -0.04491866f, 0.02208134f, -0.05310065f, -0.05091537f, -0.00784673f, -0.04763412f, -0.00235863f, 
    -0.03366538f, -0.02406159f, 0.00494118f, -0.03973113f, 0.02970598f, -0.00688348f, -0.02194907f, -0.04571325f, 
    -0.01963882f, -0.03372825f, -0.04693157f, 0.03168628f, -0.04903493f, 0.00018683f, -0.02620441f, -0.02971411f, 
    0.01928685f, -0.00242137f, 0.01387013f, -0.04349285f, 0.00749875f, -0.00897700f, 0.00749023f, -0.05442185f, 
    -0.04934833f, -0.02755729f, 0.04088430f, 0.02624244f, -0.02862913f, -0.01426773f, 0.03426721f, 0.01689023f, 
    0.03041194f, -0.01201770f, 0.04010053f, 0.02812253f, 0.03077487f, -0.01963819f, -0.04519285f, 0.04527523f, 
    0.03061816f, -0.00344106f, -0.04682358f, -0.01623856f, 0.01350043f, 0.03068702f, -0.00872062f, -0.03874397f, 
    0.01756361f, -0.03116188f, -0.03954138f, -0.03008331f, -0.02773134f, -0.02727020f, -0.00908888f, -0.04848352f, 
    0.04203853f, 0.01832244f, 0.03859062f, 0.02099253f, 0.00469779f, -0.01604693f, 0.00877323f, 0.03586202f, 
    -0.04741019f, -0.00402073f, -0.03316121f, 0.01206771f, 0.04128982f, -0.01678511f, -0.04737364f, 0.02194332f, 
    0.01572885f, 0.04117464f, 0.03455015f, -0.01485734f, -0.05576915f, -0.02538571f, 0.02065412f, 0.01106510f, 
    0.03630420f, -0.03674199f, 0.03649101f, 0.01005871f, 0.03423276f, 0.00477625f, 0.03190695f, 0.04169608f, 
    -0.01407652f, -0.04550922f, -0.03637532f, 0.03775639f, -0.05218402f, -0.03368803f, 0.04110163f, 0.00164219f, 
    0.02612919f, 0.03726344f, 0.02864622f, 0.00176874f, -0.00197540f, -0.03275735f, -0.01842996f, -0.04905839f, 
    0.44903314f, -0.09807962f, -0.26511809f, -0.00727680f, 0.20876658f, 0.03437018f, -0.06710956f, -0.00480083f, 
    0.02698227f, 0.03531615f, -0.01439472f, 0.00611022f, -0.03109689f, 0.05052177f, 0.20055684f, -0.03461957f, 
    -0.00845157f, -0.11140052f, 0.03408559f, 0.05113533f, 0.04893741f, 0.00452380f, 0.01503695f, -0.14900260f, 
    0.23223676f, -0.14015216f, 0.15850651f, -0.01139363f, 0.06708805f, 0.08270425f, -0.01783694f, -0.02508830f, 
    -0.10062706f, 0.02410509f, -0.12662661f, 0.03547768f, 0.08207474f, 0.20034757f, 0.16213697f, 0.02741273f, 
    -0.09238911f, 0.09597827f, 0.09804969f, 0.04484893f, 0.00729141f, -0.15781812f, 0.04692186f, -0.01872251f, 
    -0.02474960f, 0.05013873f, -0.04359803f, 0.03231681f, -0.12260740f, -0.06277981f, 0.19214495f, 0.03519054f, 
    -0.13113680f, 0.19605023f, -0.10841635f, 0.01719898f, 0.14105488f, 0.25514773f, 0.11818501f, 0.08913911f, 
    0.06580304f, 0.06359423f, 0.07265984f, -0.03027514f, 0.06711620f, -0.08505340f, 0.03737720f, 0.06881900f, 
    0.45704094f, -0.31838697f, -0.04704907f, 0.27574402f, -0.14633092f, -0.03165795f, -0.07600298f, 0.07489609f, 
    -0.08266576f, -0.06502334f, 0.12077240f, -0.01011454f, -0.13598824f, 0.00649740f, -0.19513939f, -0.04888736f, 
    -0.08345450f, 0.02516026f, 0.07655522f, 0.06049848f, -0.15794118f, -0.00273854f, 0.15258124f, 0.08016983f, 
    -0.10013113f, 0.21494992f, -0.04150648f, 0.08375210f, -0.02633127f, 0.10641946f, -0.01157091f, -0.02661571f, 
    -0.07960300f, 0.06698363f, 0.03171043f, -0.03308354f, -0.14061703f, -0.16178949f, -0.16826388f, 0.13707957f, 
    -0.05643697f, 0.02064911f, -0.12666118f, -0.13383751f, -0.10149415f, 0.05003620f, 0.01029465f, 0.02850999f, 
    -0.11512913f, 0.18814945f, 0.19590762f, -0.02161228f, -0.03005432f, -0.03944285f, 0.07354607f, 0.06828465f, 
    0.00588862f, -0.03456911f, -0.07891331f, 0.04693129f, -0.20514698f, 0.27103114f, 0.22930187f, -0.05592739f, 
    0.03334276f, 0.18675363f, 0.05356343f, 0.08203928f, -0.07122543f, 0.04768399f, 0.04092759f, -0.03547008f, 
    -0.10143005f, 0.26087612f, 0.09002933f, -0.05720322f, -0.02049671f, -0.01449501f, -0.08704855f, -0.06361254f, 
    -0.01522988f, -0.03903593f, 0.02272141f, 0.08443659f, -0.24395114f, -0.32918319f, -0.29306367f, -0.03933907f, 
    -0.01592146f, -0.10635284f, -0.03980938f, 0.04737810f, 0.06455765f, -0.00640104f, -0.06788859f, -0.02913055f, 
    0.02070627f, -0.01912466f, 0.18104060f, 0.20544158f, 0.04962836f, -0.07045619f, 0.09027342f, 0.09055073f, 
    0.17470303f, 0.05028402f, -0.04802060f, 0.16862969f, -0.02239329f, -0.20230272f, 0.19739679f, -0.19666621f, 
    0.00089438f, -0.13682169f, -0.05600455f, 0.10608909f, -0.17994498f, -0.06925505f, 0.05357416f, 0.10542040f, 
    0.04886875f, 0.06175116f, -0.02785343f, -0.05947120f, 0.06077876f, 0.01497788f, -0.09806799f, 0.06695256f, 
    0.05185743f, 0.12349603f, 0.04675884f, 0.19164439f, -0.16707845f, 0.06915844f, 0.06599951f, -0.09422547f, 
    -0.01488109f, -0.10219957f, 0.07241140f, -0.02084131f, -0.00496841f, 0.12589590f, -0.05032736f, -0.00165764f, 
    -0.14343715f, -0.16387455f, 0.13624583f, 0.20079251f, 0.10515467f, 0.04357230f, 0.15600790f, 0.11825847f, 
    0.04404184f, -0.02086002f, 0.14951524f, 0.06114605f, 0.26064134f, 0.00966529f, -0.14190553f, 0.25423771f, 
    -0.01665285f, 0.01322203f, -0.01972677f, -0.09897546f, 0.07601348f, -0.17673029f, 0.07612203f, 0.05314921f, 
    -0.06675711f, -0.15593469f, 0.01276708f, 0.01313318f, 0.16273093f, -0.05999869f, -0.22549194f, 0.05988848f, 
    0.03834623f, 0.01661846f, -0.08325771f, -0.04710859f, 0.01905160f, 0.20122774f, -0.07497431f, -0.14234456f, 
    0.02763443f, 0.18162267f, 0.00019354f, 0.12955734f, 0.00873507f, 0.12447044f, 0.01895043f, 0.00315030f, 
    -0.04148857f, -0.01645699f, 0.04248505f, 0.18581401f, 0.07555322f, 0.02045416f, -0.15345719f, 0.03567027f, 
    -0.09755015f, 0.12830421f, 0.11118459f, -0.02107788f, 0.08247922f, 0.19436513f, -0.23473319f, 0.02845583f, 
    0.05968795f, -0.18796091f, -0.02329085f, -0.15643093f, -0.02752228f, 0.04893174f, -0.19819219f, -0.07805184f, 
    -0.06616630f, -0.10855313f, -0.12048345f, -0.10895032f, 0.02043493f, -0.01887762f, -0.05141404f, 0.05807584f, 
    0.02547148f, -0.09934689f, -0.00040705f, -0.06234323f, 0.18253426f, -0.08090680f, -0.22128598f, 0.15084584f, 
    -0.00622291f, -0.02673179f, -0.06698100f, -0.05393399f, -0.03748143f, 0.06602325f, -0.02048304f, -0.01250039f, 
    -0.27845636f, -0.13687186f, 0.00382524f, -0.40092790f, -0.01588677f, 0.09954963f, -0.00023129f, -0.04471628f, 
    -0.04982448f, 0.07994284f, -0.02756369f, 0.05954834f, 0.22560671f, -0.09274658f, 0.14681546f, 0.19417495f, 
    0.02332356f, -0.06312058f, 0.07444279f, 0.15902573f, -0.03687986f, -0.02899014f, 0.04426228f, -0.04399033f, 
    -0.08022337f, -0.12771520f, -0.11614805f, 0.01890683f, -0.10228612f, -0.01717577f, 0.00755992f, 0.11205032f, 
    -0.04995630f, -0.05108675f, -0.11206407f, -0.03989240f, 0.46481150f, -0.09667902f, 0.08938216f, 0.12526870f, 
    0.15983967f, 0.04157504f, 0.14685857f, -0.07714152f, 0.01540831f, -0.03496955f, 0.11000156f, 0.04292545f, 
    -0.02684955f, 0.02780208f, 0.18200390f, 0.09991650f, 0.05654188f, 0.09081055f, 0.04081222f, -0.09460458f, 
    0.04750592f, -0.09467543f, -0.00091307f, 0.16344170f, 0.16304706f, 0.16623670f, 0.28129664f, 0.07232204f, 
    0.02226918f, -0.02652482f, 0.04916267f, -0.02088763f, -0.17674543f, 0.07385730f, 0.08224009f, 0.01940951f, 
    0.02613114f, -0.00469416f, -0.02698321f, 0.00464522f, -0.04993962f, -0.03338668f, 0.00163138f, 0.01196958f, 
    0.03881955f, -0.02862588f, -0.04367733f, 0.01997164f, -0.01255734f, 0.00294939f, -0.00556111f, -0.02602280f, 
    -0.01757113f, -0.03411959f, -0.00282505f, 0.03214992f, 0.00024038f, -0.00998469f, -0.00491109f, -0.02619462f, 
    0.02626261f, 0.02580629f, -0.05367180f, -0.01686555f, 0.02882948f, -0.00258451f, 0.01410268f, -0.02596050f, 
    0.03254783f, 0.03905575f, 0.01553993f, 0.01469599f, -0.00828244f, -0.03925417f, -0.01169923f, -0.00144006f, 
    -0.03688718f, 0.01112327f, 0.00386602f, -0.02002909f, -0.03295283f, -0.05595767f, -0.01527875f, 0.03405763f, 
    -0.03576169f, 0.03820562f, -0.04487450f, 0.01584987f, 0.01486050f, -0.01330468f, 0.00651958f, 0.02821579f, 
    0.02053096f, -0.04365249f, -0.02874599f, -0.00539649f, 0.00603632f, 0.04304493f, 0.02882379f, -0.04761424f, 
    0.00490046f, 0.03283278f, -0.02610955f, 0.00988746f, -0.03272281f, -0.02714216f, 0.02964868f, 0.01193259f, 
    -0.05224431f, -0.01126853f, -0.04316031f, -0.02690715f, -0.00039877f, 0.03656946f, -0.00809073f, -0.00275503f, 
    0.01229084f, -0.05838610f, 0.03846420f, 0.03826678f, 0.00872758f, -0.04264241f, 0.00822949f, -0.00342538f, 
    -0.04569796f, -0.04935753f, -0.01576386f, -0.03152001f, 0.00873644f, -0.02259818f, 0.00973347f, -0.04732515f, 
    -0.04687859f, 0.00403398f, -0.04296799f, 0.01519646f, -0.04622328f, -0.01109292f, 0.00072961f, 0.01110107f, 
    -0.00380217f, -0.00550758f, -0.05213878f, 0.03898954f, 0.01484657f, 0.01136245f, 0.03585611f, -0.02621294f, 
    0.00185530f, -0.05374486f, -0.00238597f, -0.02363492f, -0.04065940f, 0.03087215f, 0.03943519f, -0.04461433f, 
    0.03523611f, 0.01111982f, 0.00027179f, -0.04899434f, 0.04073070f, -0.02362048f, -0.01720852f, 0.00412750f, 
    0.00930014f, 0.01499531f, 0.02201222f, -0.01546631f, 0.01398883f, 0.00801124f, -0.02403670f, -0.05170908f, 
    -0.02180204f, -0.05130650f, -0.00632574f, -0.05781926f, 0.00422938f, -0.04996258f, 0.04261774f, -0.01556961f, 
    0.04730350f, -0.04906559f, 0.04186773f, 0.00864175f, -0.01124725f, 0.02899041f, -0.00299916f, -0.03442226f, 
    -0.04950918f, -0.01564517f, -0.01494503f, 0.00670515f, 0.02596870f, -0.02589918f, -0.02311350f, 0.00620627f, 
    -0.04140361f, -0.02523118f, 0.00524024f, -0.04190519f, -0.03012084f, -0.03167531f, -0.03246319f, -0.00616492f, 
    -0.04232685f, 0.04287197f, 0.01323885f, 0.01122472f, 0.03313644f, 0.04139899f, 0.03697227f, 0.04350191f, 
    0.03693455f, 0.04574879f, -0.00934279f, 0.03309393f, -0.01229643f, 0.01753922f, -0.02014260f, 0.00748089f, 
    -0.00781446f, -0.00309832f, -0.02828629f, -0.05138284f, -0.02640424f, 0.02245753f, -0.05401400f, -0.03575712f, 
    -0.04707432f, 0.00674302f, 0.02952489f, 0.02104930f, -0.03305525f, 0.02535406f, 0.02575528f, 0.03717567f, 
    -0.05241378f, 0.04235614f, -0.01153634f, -0.03065336f, -0.01137838f, -0.02451709f, -0.01786002f, 0.04102790f, 
    0.01147580f, 0.04263284f, -0.01934145f, -0.04917758f, -0.04089107f, 0.01261315f, 0.01789086f, -0.05017217f, 
    -0.03264930f, 0.04228436f, 0.00775144f, 0.00107994f, 0.01245695f, -0.05487146f, 0.03516280f, 0.02272459f, 
    -0.02611023f, 0.04534183f, -0.01512665f, -0.01826224f, -0.04318834f, -0.01916849f, 0.01638833f, -0.05938450f, 
    -0.04466614f, -0.04142889f, 0.03911069f, 0.02693865f, 0.03057957f, 0.03405175f, -0.03588088f, -0.03895421f, 
    0.02459912f, 0.01126410f, 0.04228687f, -0.04192658f, -0.01733367f, -0.02955111f, -0.01297851f, 0.00862405f, 
    -0.04087429f, -0.02615204f, -0.00533802f, 0.02290761f, 0.02915855f, -0.00761165f, -0.02736464f, 0.03239066f, 
    -0.01751348f, -0.04074659f, 0.01370601f, -0.03241688f, 0.03990102f, -0.01424316f, -0.04872802f, 0.02579293f, 
    -0.05159648f, -0.04405764f, 0.01686569f, 0.00297601f, 0.02281879f, -0.04305190f, 0.02972490f, -0.02924182f, 
    0.01124337f, 0.02213817f, -0.02183484f, -0.04101910f, -0.00397186f, 0.00723459f, -0.04294023f, -0.05776297f, 
    0.00906776f, -0.02507004f, 0.04373698f, -0.01664810f, -0.02711531f, -0.04279686f, -0.02214948f, -0.03204511f, 
    -0.01714131f, 0.02569344f, -0.02682445f, 0.03219793f, 0.03480086f, 0.01376082f, -0.00698045f, 0.02138256f, 
    0.00925931f, -0.00996564f, -0.03965149f, -0.04105029f, 0.02006134f, 0.00649120f, 0.00909417f, 0.00899527f, 
    0.03459733f, -0.02271204f, -0.03105487f, 0.02206467f, 0.04651439f, 0.00432922f, -0.03528498f, 0.01987498f, 
    0.01651589f, -0.01989776f, -0.01434785f, 0.02326844f, 0.01886833f, -0.00499568f, 0.01169767f, -0.03216456f, 
    -0.01242312f, 0.00850327f, 0.04038411f, -0.04193051f, 0.04024508f, -0.02130194f, 0.03875412f, -0.03641031f, 
    0.01199440f, -0.01021610f, -0.00891472f, -0.02616608f, -0.05235777f, -0.05123492f, -0.05875643f, -0.01007759f, 
    0.00660765f, -0.00861629f, 0.04213905f, -0.00249429f, 0.04442313f, -0.04264120f, 0.03300641f, -0.02927536f, 
    -0.03436375f, 0.02741000f, -0.01810607f, 0.04487574f, -0.02544136f, 0.04089589f, -0.02102166f, 0.02655671f, 
    0.02510638f, 0.03189353f, -0.05508737f, -0.03323685f, 0.00084863f, -0.00567171f, -0.04935639f, -0.02092307f, 
    0.03141234f, 0.03147834f, 0.04087471f, 0.02608760f, -0.00722238f, -0.05588730f, 0.00041664f, 0.00557078f, 
    -0.01721440f, -0.03670851f, -0.02054583f, -0.05407192f, 0.01900235f, -0.00906666f, -0.00872828f, -0.02885366f, 
    0.01997307f, -0.00584963f, 0.02445205f, 0.03327192f, 0.04372057f, -0.00455539f, 0.01529017f, 0.03711438f, 
    -0.03439703f, -0.05244823f, -0.00990433f, 0.03531767f, -0.00209444f, 0.02434250f, -0.04553920f, -0.03629557f, 
    -0.05787288f, 0.03966818f, -0.05887136f, 0.02538052f, 0.02240939f, -0.00278097f, -0.03927916f, 0.04298310f, 
    -0.04807886f, -0.00258119f, -0.05890722f, 0.01424965f, 0.01397731f, -0.04177101f, -0.04548122f, -0.03987483f, 
    -0.02956553f, 0.02678465f, -0.03673281f, -0.00879316f, -0.01368683f, -0.02904735f, 0.01478296f, -0.05607319f, 
    0.01090325f, -0.01874096f, -0.01234942f, -0.00614519f, -0.03092521f, -0.05059333f, 0.02556942f, 0.04223618f, 
    0.03884248f, -0.05485448f, -0.01880140f, -0.04103835f, 0.01086439f, -0.05406589f, -0.04666834f, -0.02568860f, 
    -0.02142981f, -0.01240204f, -0.01842122f, 0.02597038f, -0.04612016f, -0.00832977f, 0.00891328f, -0.01170239f, 
    -0.01617919f, 0.03204838f, 0.03134876f, 0.02010266f, -0.05625375f, 0.01674239f, -0.05232463f, 0.00845933f, 
    -0.02793719f, -0.02662139f, -0.02435171f, -0.04163527f, 0.00201134f, -0.04655478f, -0.01869287f, -0.00268252f, 
    -0.05057595f, 0.02518345f, 0.03079435f, -0.00876080f, -0.04174890f, 0.03113698f, 0.03809496f, -0.02373026f, 
    -0.03233933f, -0.00890811f, 0.03608422f, 0.01694418f, -0.03027021f, -0.02230136f, -0.04671828f, -0.04513318f, 
    -0.03418273f, -0.02285803f, 0.02698744f, -0.01921679f, 0.03040330f, 0.00197541f, -0.04524955f, 0.00504946f, 
    -0.05428680f, -0.00390223f, 0.01334364f, -0.01708264f, 0.02775913f, -0.00658419f, -0.01230903f, 0.04017194f, 
    -0.00109402f, -0.00202418f, 0.03917069f, -0.02605290f, 0.01793734f, 0.02285469f, -0.01750613f, 0.03988929f, 
    -0.01435214f, 0.03459056f, 0.03502789f, 0.00247750f, -0.03350195f, -0.01185364f, -0.03150205f, 0.01545734f, 
    0.01725242f, 0.02489054f, 0.02167521f, -0.04711192f, -0.00349516f, -0.00535526f, 0.02565020f, 0.01179777f, 
    -0.02365464f, -0.05188209f, 0.04264423f, 0.02511130f, -0.05418397f, 0.02359843f, -0.04099324f, -0.01351838f, 
    0.00216518f, -0.01273796f, -0.04879562f, -0.03553459f, 0.01688213f, 0.01619008f, -0.02374052f, 0.02651570f, 
    -0.01706171f, -0.00813492f, -0.01045223f, 0.02474997f, 0.00953595f, -0.05817480f, 0.03222919f, 0.01107385f, 
    0.00468896f, -0.04572918f, 0.01842146f, 0.01340769f, 0.01536004f, -0.05400125f, -0.01707955f, -0.01269477f, 
    0.03803792f, -0.02335655f, 0.01794836f, 0.02646685f, -0.02837954f, 0.01731792f, -0.01582236f, -0.04538517f, 
    -0.04464146f, 0.02612929f, 0.01269643f, -0.02726590f, 0.01851778f, 0.02588366f, -0.00100782f, -0.05336645f, 
    0.00683103f, 0.02175794f, -0.00074001f, 0.01970138f, -0.05377920f, 0.03463938f, -0.03575685f, -0.00798017f, 
    -0.02053106f, 0.02694124f, -0.02187131f, 0.02546141f, 0.00658201f, 0.02525509f, -0.02550197f, 0.00875772f, 
    -0.02287743f, -0.01888177f, -0.05294483f, 0.00689853f, 0.00554392f, 0.03999712f, -0.02698558f, -0.00349835f, 
    -0.03721612f, -0.05227730f, -0.04884411f, 0.00821963f, -0.05734933f, 0.00444915f, 0.01341762f, -0.00476022f, 
    0.04110978f, -0.04200328f, 0.03686275f, -0.00654022f, -0.02753924f, -0.00895078f, -0.01980699f, -0.04350901f, 
    0.01527347f, 0.01943357f, -0.02103452f, -0.00842166f, -0.00624191f, -0.05155620f, -0.02381630f, 0.04263891f, 
    -0.05380073f, 0.02209566f, 0.01333243f, 0.04235663f, 0.01951568f, 0.03117343f, 0.02046300f, -0.00453489f, 
    -0.03984646f, 0.01539191f, -0.04583335f, -0.05775439f, 0.01775373f, -0.00460732f, 0.01920632f, -0.05328360f, 
    0.00438142f, -0.02782553f, 0.01577332f, -0.00792153f, -0.05908007f, 0.04296208f, -0.05461604f, 0.02789905f, 
    -0.02242225f, 0.00995402f, -0.04263752f, -0.00387145f, 0.02181322f, 0.01341642f, 0.03905981f, 0.01555644f, 
    0.01721366f, 0.03074243f, -0.03407900f, 0.02494277f, -0.03174639f, -0.04357155f, 0.04039139f, -0.04019249f, 
    0.03104313f, -0.00645627f, -0.00174885f, -0.04385551f, -0.00923659f, 0.01417997f, 0.00661773f, 0.02544650f, 
    -0.04754283f, 0.01172845f, 0.02250194f, 0.02895470f, -0.02458717f, -0.05153709f, -0.01200030f, -0.01574234f, 
    -0.00161053f, 0.02437333f, 0.01901205f, -0.01397076f, 0.01597485f, 0.01678537f, -0.05139778f, -0.04586220f, 
    -0.04883428f, -0.00800448f, 0.02581541f, -0.04003057f, 0.03786597f, -0.05450947f, 0.00765743f, 0.02501971f, 
    -0.00835942f, -0.04965210f, 0.01774836f, -0.00446095f, -0.02669707f, -0.05538682f, 0.03297231f, -0.04734825f, 
    -0.03506589f, 0.04000770f, -0.00997121f, -0.00894602f, 0.01969177f, -0.01139666f, 0.00796939f, -0.00848620f, 
    -0.04128361f, 0.00612229f, -0.00232082f, -0.04116243f, -0.00030957f, -0.01741491f, 0.01405463f, -0.01029548f, 
    -0.03688361f, -0.05842835f, 0.02423616f, -0.04437177f, 0.02745477f, -0.01959990f, 0.00237657f, 0.01361452f, 
    0.00595290f, -0.02363757f, -0.03621015f, -0.03343257f, -0.04611865f, -0.02166107f, -0.04883671f, -0.03510100f, 
    -0.01109456f, -0.02900676f, -0.04626501f, 0.00700376f, -0.03348698f, -0.02659487f, 0.00294430f, 0.02201247f, 
    -0.01978847f, -0.01862441f, 0.00745180f, 0.02966356f, -0.04919701f, 0.01830787f, -0.04636831f, 0.02006737f, 
    -0.03818552f, -0.02668082f, -0.05182882f, 0.01696989f, -0.04694824f, 0.00711835f, -0.04972516f, -0.05474489f, 
    -0.01552946f, 0.01843655f, -0.05931379f, -0.00957005f, -0.05570868f, 0.04084088f, -0.02938618f, 0.02996889f, 
    0.01075187f, -0.00141759f, 0.03686012f, -0.01169681f, 0.02942003f, -0.05471618f, 0.03850129f, 0.03457739f, 
    0.03105677f, -0.00740159f, 0.01068909f, 0.02914906f, 0.00874537f, -0.01826720f, -0.03975099f, 0.03712993f, 
    -0.12532263f, 0.21471331f, 0.20549138f, 0.11163476f, 0.08091091f, 0.09983861f, 0.02881573f, 0.18587831f, 
    0.01820664f, 0.01008773f, -0.07811895f, -0.06322220f, 0.17896397f, -0.04729417f, -0.00435278f, 0.22841072f, 
    0.04161961f, 0.06751721f, 0.13582541f, 0.09268411f, 0.16601250f, 0.09844947f, -0.04853677f, -0.00911759f, 
    0.32747507f, 0.30460843f, 0.00759985f, 0.08872259f, -0.01572520f, 0.18335393f, 0.09718255f, 0.11455318f, 
    0.17454918f, 0.02185809f, 0.18572082f, 0.23945569f, -0.47132352f, 0.02022334f, 0.16193929f, 0.15178248f, 
    0.04070955f, 0.04000532f, 0.02060975f, -0.07094568f, 0.14768893f, 0.05860738f, 0.01092347f, 0.04538592f, 
    0.17724632f, 0.16851841f, -0.02911879f, -0.19780003f, 0.06883135f, 0.07676578f, 0.09410735f, -0.04769029f, 
    0.01407598f, -0.00467588f, 0.01550567f, -0.07658395f, -0.34571287f, 0.13240357f, 0.03618087f, 0.00714963f, 
    -0.00157532f, 0.01176448f, 0.06546923f, 0.02943044f, 0.04942943f, 0.14818092f, 0.24294640f, -0.07641775f, 
    -0.03251869f, -0.07224676f, -0.23026654f, -0.07716455f, -0.00747634f, 0.05687005f, 0.13347046f, -0.02049230f, 
    -0.06996122f, 0.06862046f, 0.02958838f, 0.16040817f, 0.02636441f, 0.06402994f, 0.09303463f, -0.14094846f, 
    0.22673239f, 0.03355314f, 0.07690822f, 0.11043992f, -0.00900880f, 0.09419379f, -0.04333378f, 0.09110127f, 
    -0.01169495f, 0.20337544f, 0.24960044f, -0.12460396f, 0.03506047f, 0.05780951f, -0.00348305f, 0.08778463f, 
    0.14456253f, 0.10426290f, -0.00227406f, 0.07393887f, 0.02876772f, -0.05157645f, 0.06180584f, 0.17806865f, 
    0.04546017f, 0.16013893f, 0.10697450f, 0.11480853f, 0.11320411f, 0.15158290f, 0.03428451f, 0.22531451f, 
    0.02610076f, 0.11391321f, 0.02012390f, 0.08979309f, 0.12419461f, -0.00134336f, -0.05418553f, 0.01451353f, 
    0.12022284f, 0.23322117f, 0.08792597f, 0.15771322f, 0.13862173f, -0.15308855f, -0.00092946f, -0.20369618f, 
    0.05851506f, -0.08399409f, -0.08397355f, 0.05176521f, 0.15771608f, 0.01577711f, 0.17793541f, 0.02744575f, 
    0.29122409f, 0.12097971f, 0.18104565f, -0.14528483f, -0.11403985f, -0.06142053f, -0.04124679f, 0.03737252f, 
    0.11999672f, 0.11958807f, 0.12439105f, 0.07337748f, -0.09871644f, -0.11127251f, -0.03429387f, 0.04851925f, 
    -0.11974069f, 0.10207797f, 0.06582225f, 0.16158770f, -0.10089935f, 0.03640250f, -0.06248022f, -0.20407844f, 
    -0.20899498f, -0.16654728f, -0.06866592f, -0.11521638f, -0.06101105f, -0.04885782f, 0.05539289f, 0.12022477f, 
    0.02800635f, 0.19736303f, 0.16333152f, 0.24628048f, -0.16253321f, -0.20510778f, -0.03327511f, 0.14707683f, 
    0.07362361f, -0.03622655f, 0.11323100f, 0.07364799f, 0.09606151f, 0.08531193f, -0.01632632f, 0.26634213f, 
    0.32041523f, -0.22003971f, 0.04365259f, 0.12589423f, 0.12668310f, 0.02048053f, 0.24587151f, 0.15373768f, 
    0.16521901f, -0.01553757f, 0.10791375f, 0.17554611f, 0.30579200f, 0.16009589f, 0.04924116f, -0.04572171f, 
    0.10918802f, 0.10232649f, 0.05021736f, 0.04982336f, 0.20050077f, 0.14916050f, 0.25853190f, 0.02839800f, 
    -0.07647667f, 0.06093799f, 0.02514884f, -0.00431228f, 0.03592445f, -0.00410859f, 0.06677768f, 0.05384007f, 
    0.03698955f, 0.14695114f, 0.01821302f, 0.15092032f, 0.29539806f, -0.09559481f, -0.13007580f, -0.13919646f, 
    0.09346563f, -0.05861330f, 0.13117154f, 0.14444758f, 0.04935142f, -0.07386355f, 0.04483571f, 0.20920324f, 
    0.46318331f, -0.28165329f, -0.31665444f, -0.23512043f, 0.12226119f, -0.05198567f, 0.08152886f, 0.02621507f, 
    0.05091810f, -0.06053399f, -0.03348152f, 0.05381381f, 0.13119513f, -0.23928149f, 0.04239465f, -0.08460832f, 
    -0.09329587f, -0.05773516f, -0.09048945f, -0.05984981f, 0.12321951f, 0.07899103f, 0.17138006f, 0.00081813f, 
    0.44377869f, -0.08810828f, -0.17080659f, 0.05688395f, 0.05135987f, 0.12261932f, 0.05045825f, 0.29537031f, 
    0.12008958f, -0.01614815f, -0.08126279f, 0.24291024f, 0.22935988f, -0.13499360f, -0.15358664f, -0.21657485f, 
    -0.08413935f, 0.09567209f, 0.08052109f, 0.03312197f, -0.13957570f, 0.11979198f, 0.22463652f, 0.14366274f, 
    0.04097854f, 0.03542068f, 0.04856917f, -0.25941002f, -0.03278590f, 0.11574413f, 0.11339442f, -0.05365023f, 
    0.02807935f, 0.11686682f, 0.12187589f, 0.06834906f, 0.27916530f, -0.24383692f, 0.01102911f, 0.04040538f, 
    -0.03913079f, 0.11542256f, 0.01570411f, 0.05618492f, 0.01176060f, 0.05127297f, 0.13110735f, 0.13321039f, 
    0.19669898f, 0.41465968f, -0.06283717f, -0.22052884f, 0.23498574f, 0.13565429f, 0.07468791f, 0.15247698f, 
    0.11255315f, -0.05038405f, -0.00884611f, 0.05464487f, 0.01359019f, -0.21110007f, 0.11358600f, 0.06497198f, 
    0.02121139f, 0.08063523f, 0.07275892f, 0.19025876f, 0.07809767f, -0.08168557f, 0.19518703f, 0.03124746f, 
    -0.19025713f, 0.06711450f, 0.04939417f, 0.13240948f, 0.14220929f, -0.02249423f, 0.26429442f, 0.20660888f, 
    0.10518849f, 0.11943455f, 0.16680378f, 0.26449829f, -0.06545961f, -0.23693773f, -0.04156205f, -0.16670825f, 
    0.14435573f, 0.08860615f, 0.05031397f, 0.07432805f, -0.01952869f, 0.19988464f, 0.18051170f, 0.18098614f, 
    -0.08452418f, 0.34892261f, 0.15180464f, 0.02686795f, 0.10800229f, 0.03315729f, -0.09409032f, -0.05707224f, 
    0.13910128f, 0.07185476f, -0.08649532f, 0.04496501f, -0.25863859f, 0.10994004f, 0.10060921f, 0.29062825f, 
    0.16679807f, 0.12228498f, 0.19199678f, 0.13828680f, 0.16198833f, 0.07999053f, 0.22654122f, 0.01369352f, 
    0.17706989f, 0.08483073f, -0.01293645f, 0.15486050f, -0.02953321f, -0.00595791f, 0.16536790f, -0.14934818f, 
    0.04165999f, 0.11865187f, 0.05067335f, -0.08154936f, -0.20030668f, -0.01564855f, 0.07656738f, 0.01258817f, 
    0.02789473f, -0.00661619f, -0.03763657f, 0.08075807f, -0.05767261f, 0.00428418f, -0.10960323f, 0.13478486f, 
    -0.04129533f, 0.02167470f, 0.18457292f, -0.04348164f, 0.05109075f, 0.08987907f, -0.07865222f, 0.06661192f, 
    -0.05362182f, 0.00090753f, 0.07721484f, -0.08900499f, 0.00444223f, -0.02289525f, 0.00840295f, 0.04069776f, 
    -0.00283334f, -0.05561210f, -0.03523171f, 0.07902952f, -0.03685413f, 0.17626147f, -0.00464446f, 0.07052796f, 
    -0.02322068f, -0.05731466f, 0.04001863f, 0.14532678f, 0.09991768f, -0.01988507f, -0.03514460f, -0.00786450f, 
    0.06569117f, 0.01175272f, 0.08841132f, -0.02709962f, -0.06182482f, -0.03567044f, -0.05268894f, 0.15253945f, 
    -0.17592439f, 0.10739292f, 0.13738264f, -0.02743288f, 0.05489237f, -0.02397749f, -0.10098930f, -0.01624017f, 
    -0.12101690f, -0.05156305f, -0.00277684f, -0.09249734f, 0.20140761f, 0.05234564f, 0.02713176f, 0.00940761f, 
    0.02984539f, 0.09367278f, -0.07907756f, 0.00155922f, 0.12510481f, 0.19556776f, -0.03030468f, 0.32168865f, 
    -0.15937994f, 0.04225911f, 0.08978402f, 0.01190965f, 0.09016772f, -0.23547529f, -0.09013156f, -0.11095679f, 
    0.22890632f, 0.05857488f, 0.03323458f, 0.10495520f, 0.00356085f, -0.03464483f, 0.10413101f, 0.03648948f, 
    -0.12250586f, 0.02747663f, -0.00224597f, -0.07114935f, 0.19344062f, 0.16001602f, 0.01413777f, -0.10848491f, 
    0.06838170f, -0.03661752f, 0.03569831f, 0.07257099f, 0.09989095f, 0.17441645f, 0.01207382f, 0.00480722f, 
    -0.33963892f, -0.02608372f, 0.21894072f, -0.11158603f, -0.06742945f, 0.00686126f, 0.01463759f, -0.04574791f, 
    -0.00117822f, 0.09205694f, -0.03921839f, -0.09572666f, -0.28816909f, 0.14704338f, 0.11964415f, 0.11403175f, 
    -0.03364766f, -0.07044663f, -0.04414651f, 0.02122257f, -0.03221452f, -0.03879253f, -0.13106360f, -0.05855053f, 
    0.01223304f, 0.05715617f, 0.12388633f, -0.11812122f, 0.00656390f, 0.00566249f, 0.01412380f, 0.01255968f, 
    0.09595812f, 0.05304953f, -0.11613726f, -0.02636177f, 0.16389291f, 0.12583344f, 0.17918514f, -0.02434864f, 
    0.11321212f, 0.04599542f, 0.06513494f, -0.04712327f, 0.04103580f, -0.00011795f, -0.01513227f, 0.12784505f, 
    0.07737989f, 0.07097965f, -0.06629483f, 0.17053552f, -0.03332283f, 0.13048719f, -0.04293358f, -0.01522756f, 
    -0.18136118f, 0.09243750f, 0.01753949f, 0.01613588f, 0.25696686f, 0.12074766f, -0.07202084f, -0.04222599f, 
    0.01570154f, 0.01570066f, 0.16510905f, -0.02808042f, -0.06363793f, 0.15346916f, -0.14526728f, 0.00927777f, 
    -0.19278911f, 0.11848626f, -0.00512859f, -0.14215018f, -0.05176489f, 0.09478818f, 0.04553786f, -0.07009587f, 
    -0.01047773f, -0.14442328f, 0.00341978f, -0.11614421f, -0.13392554f, 0.09946766f, 0.02787716f, -0.05612471f, 
    -0.18222474f, -0.01613653f, -0.06121973f, 0.14570303f, -0.13580024f, -0.10143438f, -0.05134010f, 0.05266138f, 
    0.15507179f, -0.02505024f, 0.04310287f, 0.10828938f, 0.03676166f, 0.09114999f, -0.08849192f, 0.11779808f, 
    0.08283078f, 0.14411853f, -0.09528641f, -0.04882069f, -0.19661723f, 0.01667009f, 0.01524094f, -0.08813448f, 
    0.09392180f, 0.12913142f, 0.03224593f, 0.00774154f, -0.08192448f, 0.15526396f, -0.02728502f, -0.04171245f, 
    -0.35061654f, 0.26261088f, 0.03554874f, -0.00096823f, 0.00042301f, 0.07360452f, 0.06506975f, -0.08632778f, 
    0.01142949f, 0.02127101f, 0.08289650f, 0.12918079f, -0.00721091f, 0.22679728f, -0.02768781f, 0.05048338f, 
    0.12195331f, 0.01721801f, 0.00472976f, -0.03171879f, -0.05963372f, -0.00088172f, -0.15631348f, 0.15588820f, 
    -0.36386576f, 0.00731095f, 0.02247222f, -0.20281065f, -0.10374382f, 0.03097574f, 0.04929454f, -0.05673515f, 
    0.09612099f, 0.06802622f, -0.05277798f, -0.04486527f, 0.08679830f, 0.03552993f, 0.11084278f, 0.08374006f, 
    0.06974741f, 0.13683958f, 0.06583222f, -0.00836206f, 0.01417618f, -0.03942825f, 0.11604456f, 0.00400692f, 
    0.06967383f, 0.00574467f, -0.06904322f, 0.06442679f, 0.12675478f, -0.18267658f, -0.01438602f, 0.00743032f, 
    -0.05570859f, -0.07820559f, 0.04296461f, -0.02487647f, 0.24829413f, 0.13583395f, 0.03545144f, -0.09328164f, 
    0.12664372f, 0.04447423f, -0.02440365f, -0.04992058f, -0.09517458f, -0.06771404f, -0.01349169f, 0.06820040f, 
    -0.18144293f, -0.05943637f, 0.23598400f, 0.17224756f, -0.07821043f, -0.14018166f, -0.09697743f, -0.12878890f, 
    -0.03561045f, -0.05321670f, 0.00775875f, -0.07370067f, -0.14409646f, -0.00843194f, -0.01227579f, 0.11461883f, 
    0.02473272f, 0.05056200f, 0.09370622f, 0.17129451f, -0.09074204f, -0.04876349f, 0.05127803f, -0.05130832f, 
    0.25030112f, 0.15013663f, -0.09288298f, -0.06122623f, 0.03432699f, 0.12207753f, -0.02149969f, -0.20072106f, 
    -0.03216735f, -0.00548859f, -0.05400261f, -0.00316732f, -0.02687343f, 0.17768617f, 0.14493382f, 0.12625553f, 
    -0.16994448f, 0.00307307f, 0.04616876f, -0.06168021f, 0.03859311f, -0.03960821f, 0.00247517f, -0.00276032f, 
    -0.13175210f, -0.12222674f, 0.21362293f, 0.04221537f, -0.24560888f, 0.08554097f, 0.08422918f, 0.05926635f, 
    -0.07347666f, -0.04207977f, 0.06948843f, -0.17293297f, -0.26482570f, -0.14688429f, -0.11413154f, -0.02773895f, 
    -0.21910687f, 0.09671961f, 0.02268403f, 0.06091907f, 0.03222192f, 0.05349527f, -0.03418224f, -0.05277417f, 
    -0.02194588f, 0.02212280f, -0.02732802f, -0.00980907f, 0.02610676f, -0.00137081f, 0.00704813f, 0.02894554f, 
    0.04318074f, -0.00330565f, -0.05332324f, 0.00419627f, 0.03862305f, 0.01048392f, -0.03986932f, 0.02198112f, 
    -0.00062071f, 0.04566847f, 0.01717689f, 0.03538702f, -0.00021906f, -0.05239162f, 0.02435234f, 0.04347975f, 
    0.02087947f, 0.02443429f, 0.00343516f, -0.01248210f, -0.02705122f, -0.04793433f, -0.02993465f, -0.00845929f, 
    0.02618133f, 0.01969717f, -0.04655260f, -0.02061951f, 0.03348446f, 0.04701558f, 0.04763504f, -0.05602445f, 
    0.00457498f, -0.03891232f, -0.04737037f, -0.00086750f, -0.00673173f, 0.02572270f, -0.02498122f, -0.04608569f, 
    -0.01901851f, 0.00796007f, -0.05133217f, -0.00098060f, 0.00506321f, 0.02037186f, -0.04544742f, 0.02177912f, 
    0.01304882f, 0.01736835f, -0.03548092f, -0.01631866f, -0.04363339f, 0.00886716f, 0.00312156f, -0.04251617f, 
    0.04212196f, -0.02590312f, -0.02991514f, 0.02833729f, -0.05636772f, 0.04743201f, -0.00129485f, 0.03263974f, 
    -0.02775653f, 0.03580585f, 0.00509437f, 0.00510916f, 0.03776887f, 0.04427044f, -0.02023624f, -0.03830300f, 
    0.02829458f, -0.05006034f, 0.03861632f, -0.01454671f, 0.00806838f, -0.01548203f, -0.01141672f, -0.05390945f, 
    -0.04963465f, -0.02959882f, -0.03097510f, 0.01854325f, -0.04966920f, -0.00685137f, 0.04768604f, -0.03344881f, 
    -0.04097261f, -0.00337127f, 0.01895836f, -0.05084602f, 0.04409456f, 0.01431648f, -0.02157622f, 0.01255394f, 
    0.01756861f, 0.00132711f, -0.02358238f, 0.02295454f, -0.01289367f, -0.05552181f, -0.00310609f, -0.05440003f, 
    -0.00801332f, -0.01537110f, -0.00289814f, 0.03279022f, 0.02493615f, 0.00754433f, -0.02434099f, -0.03130937f, 
    0.00344606f, -0.02102383f, -0.01816491f, -0.02697963f, 0.03797883f, 0.01930723f, 0.01379534f, -0.04575891f, 
    -0.05023731f, -0.04260164f, 0.02571617f, 0.01219014f, 0.03170001f, -0.02136767f, -0.02912857f, 0.00128351f, 
    0.02906300f, -0.01046067f, 0.02090512f, -0.01127576f, 0.00270385f, -0.02396787f, -0.03362111f, -0.03668255f, 
    -0.01756745f, -0.04358382f, 0.02361334f, -0.02513026f, -0.01222063f, 0.01050024f, -0.02842140f, -0.00511140f, 
    0.03170246f, -0.05204391f, 0.00247214f, -0.04226508f, -0.04555788f, 0.01426127f, 0.01119275f, 0.01865872f, 
    -0.01619753f, -0.04218147f, -0.04982669f, -0.03758348f, -0.05298106f, -0.02464367f, 0.03769880f, 0.03377130f, 
    0.02178760f, -0.01242645f, 0.01887807f, 0.03300987f, 0.02358192f, -0.00467343f, 0.00857405f, 0.00224701f, 
    0.01300537f, -0.02976600f, -0.02372440f, 0.01018180f, 0.03818443f, -0.01681262f, -0.02445200f, -0.02715355f, 
    -0.00184454f, -0.00093391f, -0.00351752f, -0.03637025f, 0.03861898f, -0.02267036f, 0.03029079f, 0.01883009f, 
    -0.02422618f, 0.01226312f, -0.04302583f, -0.01185246f, -0.01626957f, -0.01003601f, 0.01194812f, -0.03081878f, 
    -0.03144189f, -0.04934217f, 0.01289331f, 0.02091476f, 0.01925763f, -0.03188395f, 0.04277634f, -0.04442551f, 
    -0.02252782f, 0.01365359f, -0.04142634f, -0.01463854f, 0.03263749f, 0.00210975f, 0.02069480f, 0.01387223f, 
    0.03667412f, 0.02236026f, -0.00373608f, 0.03330858f, 0.01358949f, -0.02824796f, -0.05477314f, 0.03467302f, 
    -0.00088262f, -0.02994210f, -0.03966861f, -0.03748181f, 0.03426542f, 0.04204053f, 0.03643235f, -0.05595350f, 
    0.00287939f, -0.05177474f, -0.01285387f, 0.03460252f, -0.03971865f, -0.02778895f, -0.05528923f, 0.02928410f, 
    0.03217167f, -0.04994101f, 0.02432005f, 0.00981163f, 0.03393736f, 0.03411663f, -0.04246196f, 0.03824996f, 
    0.00210693f, -0.05199534f, -0.04915362f, -0.05353852f, -0.02580465f, 0.00264874f, -0.01009390f, 0.01307938f, 
    0.00394875f, -0.05134562f, 0.01974108f, -0.03201988f, -0.04144972f, 0.04019381f, -0.04424029f, 0.01772710f, 
    0.01960470f, -0.00659698f, -0.02599104f, -0.04293280f, -0.03770333f, -0.04572199f, -0.01167745f, -0.03747666f, 
    0.03953914f, -0.04303935f, 0.01374307f, 0.04549013f, -0.00947269f, 0.02066122f, 0.01354105f, -0.04866887f, 
    -0.03538159f, -0.05342430f, -0.03126391f, -0.02954431f, -0.00922850f, -0.03597465f, 0.04510031f, -0.02406981f, 
    -0.01431775f, -0.05176798f, 0.00466194f, -0.04091989f, -0.05529879f, -0.05331587f, 0.01138731f, -0.05367366f, 
    -0.04534969f, 0.04541564f, 0.01315775f, 0.01071558f, -0.02572467f, 0.02718608f, 0.04342688f, 0.00396570f, 
    -0.01392915f, -0.02088028f, 0.02221734f, -0.04926490f, 0.03412505f, 0.02309069f, -0.02320231f, -0.03897289f, 
    0.04417107f, 0.03891050f, -0.01877813f, 0.00280190f, -0.04896458f, -0.04415785f, 0.02785682f, -0.00019592f, 
    0.04428691f, -0.05467958f, -0.04005777f, 0.02586923f, -0.03949591f, 0.00928364f, 0.02349731f, -0.03538147f, 
    -0.04694244f, -0.01597246f, -0.03656049f, -0.01044998f, -0.01948431f, -0.02759244f, 0.00122632f, 0.01940108f, 
    -0.01244456f, -0.00780875f, -0.04853868f, 0.00352373f, -0.03159180f, -0.04354764f, -0.01827733f, -0.03678925f, 
    -0.03901808f, -0.00116742f, -0.02479612f, -0.03401254f, 0.01013207f, -0.03273386f, -0.01755692f, 0.02585799f, 
    0.04482758f, -0.05081588f, -0.03096570f, 0.01751044f, -0.02589347f, -0.01009247f, 0.00012928f, 0.01953851f, 
    0.01610616f, -0.02116649f, -0.01865118f, -0.02001642f, -0.05236147f, -0.03472310f, -0.05599172f, 0.02511314f, 
    -0.01111121f, 0.03408855f, 0.02325344f, 0.03419001f, 0.00717823f, 0.03382490f, 0.03971901f, -0.01911443f, 
    -0.02370739f, 0.01218209f, -0.01473128f, -0.05042886f, 0.04034806f, 0.02986967f, -0.00833885f, -0.04570779f, 
    -0.02530450f, 0.03217861f, 0.02080311f, 0.01249026f, -0.00264904f, -0.02842356f, 0.00743933f, 0.04615764f, 
    -0.03092616f, -0.05626875f, -0.00340880f, -0.01284328f, -0.02733636f, -0.03891318f, 0.04264566f, 0.04883527f, 
    -0.03706831f, -0.02202874f, 0.03767006f, 0.03252587f, -0.03645416f, 0.01902801f, -0.01728411f, 0.01995884f, 
    0.03863478f, -0.04628944f, 0.03101820f, -0.03272430f, -0.03449237f, -0.01111470f, -0.03823339f, 0.04257149f, 
    -0.04727183f, -0.01064437f, -0.01671320f, 0.01728993f, 0.00759508f, 0.01479685f, -0.02490800f, -0.03330043f, 
    0.01317047f, 0.02666701f, 0.00203933f, -0.02109789f, 0.03459544f, -0.00839934f, 0.00236377f, -0.03876764f, 
    -0.01120393f, -0.03354309f, 0.00994393f, 0.01196981f, 0.00832831f, -0.00033661f, -0.04806897f, -0.05708471f, 
    -0.04395922f, 0.02908904f, 0.02918073f, -0.03498058f, 0.02713690f, 0.02912717f, -0.02761535f, -0.02018129f, 
    0.03569985f, -0.00916525f, 0.04787365f, 0.01404697f, 0.04934682f, -0.03941032f, -0.01091627f, 0.03407694f, 
    -0.05328413f, -0.03997496f, 0.03301551f, -0.00204488f, 0.01641463f, 0.03204870f, -0.01582935f, -0.04328120f, 
    -0.02810410f, 0.02778933f, -0.00470552f, -0.05403084f, 0.01321440f, -0.01061952f, 0.00090190f, -0.04268376f, 
    -0.03714000f, -0.04101290f, -0.02122870f, -0.01580669f, -0.04315847f, 0.01702575f, 0.03550797f, -0.05259378f, 
    0.03633331f, 0.01773724f, -0.02980828f, -0.01267347f, 0.02756492f, -0.05105297f, 0.02654972f, -0.04263595f, 
    -0.03146129f, -0.00885677f, -0.05121573f, 0.04127707f, -0.04863614f, -0.05209232f, 0.01763557f, 0.04251171f, 
    -0.01671757f, 0.04066202f, 0.03215649f, 0.00767440f, 0.01327274f, -0.03825511f, -0.03198904f, -0.04061095f, 
    -0.05165543f, -0.05280460f, -0.02696664f, -0.02951747f, -0.02073359f, 0.03830522f, 0.00387193f, 0.01141996f, 
    0.02016210f, -0.04425810f, -0.02834716f, 0.04115353f, 0.01472383f, -0.00301098f, -0.05248567f, 0.04133609f, 
    0.04326587f, 0.03036241f, -0.02181148f, -0.02788916f, 0.00421943f, -0.01845450f, -0.04702883f, 0.02825464f, 
    0.02374664f, 0.00040060f, -0.05234341f, -0.03178913f, -0.02759230f, 0.02565089f, 0.03644416f, -0.02694501f, 
    -0.01605606f, -0.00876662f, -0.00799943f, -0.01180146f, -0.00692526f, -0.04430034f, 0.04581605f, -0.04572550f, 
    -0.02984585f, -0.04084187f, 0.04051388f, -0.02364198f, 0.03670616f, -0.04882856f, -0.03267144f, 0.00110675f, 
    -0.02566277f, -0.04265567f, 0.03107233f, -0.00557444f, -0.05610561f, -0.03868401f, 0.03406708f, -0.05085241f, 
    -0.00189051f, 0.00838071f, -0.03176797f, -0.04576106f, -0.01826929f, 0.01659509f, -0.02028749f, 0.02434549f, 
    -0.01786711f, -0.04314538f, -0.02465024f, -0.05366097f, -0.01736859f, 0.00066218f, 0.01185098f, 0.01708942f, 
    0.03875175f, 0.03165856f, 0.04361928f, -0.03026569f, -0.03209407f, 0.03333301f, -0.01276954f, -0.05217629f, 
    -0.05148509f, -0.05477003f, -0.03281942f, 0.03989684f, 0.02647858f, 0.03499499f, -0.02721271f, -0.00112113f, 
    0.03673684f, 0.03650307f, -0.00013439f, -0.00742577f, -0.05259893f, -0.00109422f, 0.01927145f, 0.02268686f, 
    -0.03401187f, -0.02744837f, 0.04311734f, -0.01239133f, -0.01904026f, 0.03435469f, -0.03283220f, 0.00437818f, 
    -0.01399981f, 0.00565949f, 0.03193129f, -0.02200394f, -0.02743589f, -0.03447989f, 0.02767266f, -0.05119579f, 
    -0.05333328f, 0.01548401f, -0.00016275f, -0.02190759f, 0.00351982f, -0.02845171f, -0.00775285f, 0.02024133f, 
    -0.02164361f, -0.00767747f, -0.04369978f, 0.02145033f, 0.00003351f, -0.05157951f, -0.02604122f, 0.03068073f, 
    -0.05193476f, -0.00059019f, -0.05520504f, -0.00488592f, 0.01492923f, -0.01263293f, -0.04140058f, -0.01689417f, 
    -0.02163428f, 0.02166875f, 0.03516943f, 0.03510658f, 0.02973547f, 0.03531961f, 0.02457154f, 0.04497498f, 
    0.04526639f, -0.04928320f, -0.05145391f, -0.02718555f, 0.02201421f, 0.00741034f, -0.01781535f, 0.04082388f, 
    0.03787867f, -0.03355548f, -0.05090227f, -0.03768430f, 0.02830302f, -0.03208451f, -0.02643230f, -0.05462405f, 
    -0.01809908f, 0.01010534f, -0.03176608f, 0.00200447f, 0.02898965f, -0.05529013f, -0.03129682f, 0.01093667f, 
    0.02579891f, -0.01219125f, 0.00127797f, -0.04546377f, 0.01561682f, 0.03358230f, -0.03888799f, -0.03043420f, 
    0.00122467f, 0.00520246f, -0.02923460f, 0.00153176f, 0.00494695f, -0.05381522f, -0.00918654f, -0.04931432f, 
    -0.03057453f, -0.00825619f, -0.02835160f, 0.02268536f, -0.01569670f, -0.02095620f, -0.03902196f, 0.01184681f, 
    -0.01189120f, -0.01629962f, 0.00880450f, -0.03685686f, -0.05040489f, 0.00999361f, 0.02125529f, 0.04545501f, 
    -0.02184175f, -0.03936010f, 0.00623067f, -0.00590053f, -0.00325986f, 0.03848372f, -0.03899675f, -0.00835661f, 
    0.02246238f, -0.04923049f, 0.01098927f, -0.01187797f, 0.04068282f, -0.02125203f, 0.00993170f, 0.01265144f, 
    -0.00005706f, -0.04674940f, -0.03067324f, -0.05534168f, 0.04301545f, 0.03473673f, -0.04635544f, -0.05346471f, 
    0.04323744f, -0.04191672f, -0.02823371f, -0.04657631f, 0.04465814f, 0.02067814f, -0.02137569f, -0.00638090f, 
    -0.02950149f, 0.00652394f, -0.03690362f, 0.00653940f, -0.04648668f, 0.02158212f, -0.04826705f, 0.02716554f, 
    0.00781399f, -0.00076571f, -0.04426696f, -0.01478876f, -0.03991667f, 0.01316024f, -0.00287970f, 0.03129929f, 
    0.04301821f, -0.02919681f, -0.04060080f, 0.01263105f, -0.05320777f, -0.03613253f, -0.04321770f, 0.00377895f, 
    -0.01830721f, 0.00036873f, 0.02686211f, -0.02108832f, -0.00982144f, -0.00215287f, 0.00913633f, 0.02713386f, 
    0.11349131f, -0.04895211f, 0.25518960f, -0.00100926f, 0.08044699f, 0.00794830f, -0.03554812f, 0.04667806f, 
    0.18275936f, -0.18802658f, 0.02974606f, 0.12172790f, 0.06556545f, 0.18687478f, -0.23929349f, 0.10178821f, 
    0.01896735f, 0.00233934f, -0.05104361f, -0.02644402f, -0.03101652f, 0.06365897f, 0.05395533f, -0.09246739f, 
    0.20299828f, 0.08250697f, 0.11891302f, 0.03904620f, 0.03493875f, -0.03232910f, 0.03409509f, -0.14767297f, 
    -0.10644185f, 0.07920306f, -0.13016027f, 0.11887709f, -0.06772308f, 0.09376276f, 0.19197032f, 0.07832081f, 
    -0.07164159f, 0.05689556f, 0.04491273f, -0.03895279f, 0.16739307f, -0.05461846f, 0.11448690f, -0.22000366f, 
    0.14714600f, 0.07794597f, 0.03214329f, 0.15523411f, 0.05063793f, 0.09815886f, -0.10952413f, -0.03535136f, 
    -0.09453724f, 0.03158356f, 0.14404854f, 0.18659458f, -0.00415585f, 0.16417339f, 0.21910885f, -0.15596618f, 
    0.16166916f, 0.03047779f, 0.12152863f, -0.07847857f, -0.04948630f, 0.00416608f, 0.03305197f, 0.15919721f, 
    -0.56739640f, -0.09888722f, 0.00635245f, -0.20452772f, 0.04337816f, 0.04204990f, 0.11412308f, -0.03424034f, 
    0.05815711f, 0.02853377f, 0.05565897f, 0.07260664f, -0.06351557f, 0.07256119f, -0.29982552f, -0.01200779f, 
    -0.03576204f, -0.05542704f, 0.03799024f, -0.05398387f, -0.04404317f, 0.01618326f, 0.15869865f, 0.11809333f, 
    0.05682977f, 0.04183005f, 0.11122286f, -0.14499146f, -0.00270781f, 0.08192133f, 0.05386425f, 0.00540266f, 
    -0.03503178f, 0.10116368f, 0.13350986f, 0.12342630f, 0.14736390f, 0.02140160f, 0.10171485f, 0.01903645f, 
    0.01154407f, 0.04004066f, 0.04484760f, 0.02004847f, 0.05752365f, 0.00786827f, 0.12005738f, 0.11242951f, 
    -0.03518125f, 0.06503230f, 0.21378633f, -0.12418110f, 0.08908191f, -0.04795698f, 0.02584406f, 0.17029046f, 
    0.10690098f, -0.05018773f, 0.01584570f, 0.02105943f, 0.07726116f, -0.10634178f, 0.22636995f, -0.02379075f, 
    -0.07927148f, 0.15621608f, 0.07966442f, 0.17518482f, -0.05941925f, -0.06417025f, 0.07094358f, 0.00630928f, 
    -0.03168193f, 0.17654175f, 0.17172717f, -0.39767599f, 0.12861264f, -0.02444156f, 0.06572147f, -0.02571098f, 
    0.03754746f, -0.12841217f, 0.16051841f, 0.07451694f, -0.37699029f, -0.20632730f, -0.06436069f, 0.14278603f, 
    0.12253519f, -0.11058319f, -0.02636167f, -0.08269497f, 0.02244070f, 0.12082380f, 0.06717522f, 0.00437244f, 
    -0.01677308f, -0.20103119f, 0.03923235f, -0.04855800f, 0.02244774f, -0.10132701f, 0.10311120f, -0.12415969f, 
    -0.01656294f, 0.06821123f, -0.15255722f, 0.09834362f, 0.29016823f, 0.12487592f, 0.05733719f, 0.09102654f, 
    0.02785369f, 0.15445957f, -0.01426357f, 0.01982232f, 0.08327779f, -0.02986167f, 0.01735826f, -0.09432133f, 
    -0.09687174f, 0.17954990f, 0.26993430f, -0.27517593f, -0.05278496f, -0.11551224f, -0.02108362f, 0.01457906f, 
    0.02426010f, 0.03945013f, 0.01432680f, -0.03444856f, -0.16032284f, 0.08395400f, -0.01043952f, 0.14439592f, 
    0.00685520f, -0.03260914f, 0.06942085f, -0.08711927f, -0.11322393f, 0.01875312f, -0.05210602f, 0.08245376f, 
    0.14049767f, 0.07464672f, -0.27819103f, 0.02383115f, 0.16891278f, -0.04079396f, -0.04003716f, -0.06043136f, 
    0.04387816f, -0.13971046f, 0.17974170f, 0.08530574f, -0.04773670f, 0.00574111f, -0.05826704f, 0.00747051f, 
    0.20283784f, 0.00828467f, 0.11736842f, -0.17629719f, 0.06356771f, -0.00766772f, 0.00307215f, -0.04639179f, 
    -0.16310133f, -0.14115511f, -0.20028450f, -0.09172127f, -0.01131570f, 0.00423100f, 0.09121944f, -0.09352555f, 
    0.05108086f, 0.05864889f, -0.04245676f, 0.02235797f, -0.12525873f, 0.19820517f, 0.13413124f, -0.20995517f, 
    -0.03801188f, -0.01142857f, 0.15264471f, -0.03701350f, 0.01045705f, 0.09835068f, -0.17432235f, -0.21511607f, 
    -0.36067620f, 0.11360139f, -0.17573409f, -0.07068187f, 0.12874264f, 0.19159436f, -0.13092490f, -0.07178442f, 
    0.06926081f, 0.02561551f, 0.15137458f, 0.01126360f, -0.01311101f, 0.11618494f, -0.50627244f, 0.05664278f, 
    0.02769975f, 0.12966135f, -0.08225572f, -0.14576727f, -0.04611081f, 0.05553173f, -0.08141240f, -0.05248179f, 
    -0.32470027f, -0.06367616f, 0.09309563f, 0.07139821f, 0.01609377f, 0.08931601f, 0.06079401f, 0.13673395f, 
    -0.01982163f, 0.01835765f, 0.04665200f, 0.04743653f, -0.14133121f, -0.24766478f, -0.12367056f, 0.23291975f, 
    0.06650008f, 0.02145150f, 0.17285542f, 0.05602573f, 0.00257015f, 0.01036565f, 0.01587415f, -0.07581533f, 
    0.02804390f, -0.01424591f, -0.04170694f, 0.08185665f, -0.10594039f, 0.06520607f, 0.09715343f, -0.00897240f, 
    -0.13475627f, 0.04136575f, -0.04539206f, 0.05967446f, 0.25695670f, -0.02712047f, -0.33470681f, 0.28363934f, 
    0.06702203f, 0.03568509f, -0.13148087f, -0.02813060f, -0.01069327f, 0.13973431f, -0.01637997f, 0.01522245f, 
    -0.16965359f, -0.09270759f, 0.01111765f, 0.04757987f, 0.08944073f, -0.00795154f, -0.03518809f, 0.11458214f, 
    0.01667459f, -0.00801455f, -0.03260753f, -0.03069130f, -0.15010175f, 0.02519407f, 0.19097714f, -0.12223627f, 
    0.11208532f, -0.01613293f, 0.05177344f, 0.04803375f, -0.06126502f, -0.03381912f, 0.11602096f, -0.05722224f, 
    0.11198768f, 0.15022345f, 0.16444348f, 0.06180454f, -0.03004009f, 0.06225174f, -0.06440060f, -0.05618220f, 
    0.03746695f, -0.09996384f, 0.10047764f, 0.11529339f, -0.16075990f, 0.31712574f, 0.03838213f, 0.32034749f, 
    0.03122687f, -0.05355849f, -0.12951641f, 0.03731692f, -0.06617931f, 0.05941397f, -0.10441563f, 0.04719039f, 
    0.02474673f, 0.02811210f, 0.01046995f, 0.00970083f, -0.00514468f, -0.03364728f, 0.02906595f, -0.03349892f, 
    -0.02846722f, -0.05262749f, -0.03187440f, 0.02368461f, 0.02944983f, 0.03133655f, -0.03608523f, -0.05652856f, 
    0.00013660f, -0.01942136f, -0.00878067f, 0.00926936f, -0.04568278f, -0.01078117f, 0.02272958f, 0.02416173f, 
    -0.02124481f, 0.02188201f, -0.04412988f, 0.01071706f, 0.00293091f, -0.00728097f, 0.03836731f, -0.03554616f, 
    -0.03612793f, -0.04163265f, 0.00172644f, -0.04922691f, -0.05375317f, -0.03623790f, 0.01597534f, -0.01074935f, 
    -0.00572133f, 0.00565730f, 0.02618464f, -0.04685346f, -0.03252283f, 0.01641084f, -0.00679386f, -0.00029129f, 
    0.01543406f, 0.00695867f, -0.00142753f, -0.01599276f, -0.00016493f, -0.00907437f, 0.03494840f, -0.03496223f, 
    -0.01426101f, -0.04684992f, 0.03048168f, -0.01464566f, -0.03166172f, -0.00139615f, 0.02674435f, 0.01334334f, 
    -0.01590280f, -0.00472147f, 0.01390940f, -0.05098005f, 0.01493040f, 0.04186142f, -0.01392770f, 0.01621621f, 
    -0.02053404f, -0.04014341f, 0.01601124f, -0.03922798f, -0.05329139f, -0.00591853f, 0.01545176f, 0.02078893f, 
    -0.00621224f, -0.04413530f, 0.03425437f, -0.00671067f, -0.02316773f, 0.03126173f, -0.01638984f, 0.03719531f, 
    -0.00719697f, 0.04122351f, -0.00467362f, 0.04461198f, 0.03239987f, 0.01846568f, -0.04455614f, -0.02113432f, 
    0.01504987f, -0.02126548f, 0.02889924f, -0.04587571f, 0.03124718f, -0.04417089f, -0.04432311f, -0.04875812f, 
    -0.02303556f, -0.05419710f, 0.01114326f, 0.02229919f, -0.05682026f, -0.00428819f, -0.01363249f, -0.01000347f, 
    0.03824590f, 0.04054094f, -0.01374312f, 0.03343568f, 0.04143126f, -0.03588832f, 0.04059643f, -0.03243726f, 
    0.02665217f, 0.00930203f, -0.01322997f, 0.02504749f, 0.02961623f, -0.04532979f, 0.03811644f, 0.00753165f, 
    -0.04543944f, 0.00389720f, 0.00563645f, -0.00722722f, -0.02984972f, -0.02440064f, -0.02215180f, -0.03439693f, 
    0.00709821f, 0.00483734f, 0.02681216f, -0.03676070f, 0.00224638f, 0.01502613f, -0.05561096f, 0.00218861f, 
    0.01327679f, 0.00200882f, -0.00273808f, -0.00775650f, -0.00916318f, 0.00671830f, -0.02783968f, 0.02484183f, 
    0.02964007f, -0.05289704f, -0.05656387f, 0.01828198f, -0.01691430f, 0.01511577f, -0.04124045f, 0.01989079f, 
    -0.02198637f, 0.02643955f, -0.01874877f, -0.04991919f, 0.02419684f, 0.00348484f, -0.00502849f, 0.03459196f, 
    -0.00825067f, -0.03429663f, -0.05234332f, -0.04637676f, -0.01509380f, -0.05084500f, 0.02939517f, -0.03791728f, 
    -0.00007887f, -0.02007379f, -0.03951742f, -0.02206717f, -0.02908106f, 0.02079130f, -0.03528301f, -0.03218669f, 
    -0.02474811f, 0.00255210f, 0.03473324f, -0.03842929f, -0.00909641f, -0.05299475f, -0.03578868f, 0.02737365f, 
    0.03364462f, -0.04617921f, -0.01752321f, -0.03112703f, -0.04897525f, -0.05056357f, -0.02402616f, -0.04673734f, 
    -0.02444231f, -0.03826771f, -0.02832482f, 0.00233479f, 0.02918278f, 0.03274179f, 0.00100512f, -0.03473390f, 
    -0.02418336f, 0.01751873f, 0.03304521f, 0.01321985f, -0.00220751f, 0.03383165f, 0.02719538f, -0.01507504f, 
    -0.01225027f, 0.03397279f, -0.01810909f, 0.02198256f, 0.02466081f, -0.00357831f, -0.02730143f, -0.00240032f, 
    -0.00042898f, 0.00357641f, -0.04208837f, 0.00491579f, -0.01457849f, -0.04588713f, -0.00677414f, 0.02554455f, 
    -0.03741992f, 0.00412929f, 0.01088011f, 0.03053286f, -0.03654926f, 0.02090107f, -0.04249099f, 0.03369163f, 
    -0.03339528f, 0.02006530f, 0.04498341f, -0.01372965f, -0.02975829f, 0.02972577f, -0.03853387f, -0.05208153f, 
    -0.00958001f, -0.05218589f, -0.03720027f, 0.04879148f, -0.05152705f, 0.02071420f, 0.01063020f, 0.02722139f, 
    -0.01512392f, 0.02969611f, 0.03922469f, -0.01470453f, -0.01620163f, -0.01686304f, 0.00741541f, -0.02426045f, 
    0.02133425f, 0.00573024f, 0.01611906f, 0.02864851f, -0.03065107f, -0.04647488f, -0.02246081f, 0.01397687f, 
    -0.02872803f, -0.02358069f, -0.01927276f, -0.02290916f, 0.02189323f, -0.01170786f, 0.03285087f, 0.02018795f, 
    -0.03829827f, 0.01274678f, 0.00372222f, -0.03452263f, -0.03424156f, 0.00635132f, -0.02879022f, -0.01123176f, 
    -0.02298582f, -0.02538892f, 0.04313655f, -0.04540265f, -0.04587745f, -0.01677566f, 0.00421946f, 0.03435379f, 
    -0.02367827f, -0.04797106f, 0.02118432f, -0.03737642f, -0.01218512f, -0.00049363f, 0.01732841f, -0.04483626f, 
    0.01136805f, -0.01274068f, -0.04009226f, 0.01299021f, -0.00209473f, -0.00585257f, -0.04821957f, 0.02326939f, 
    0.04356409f, -0.02758250f, 0.01920265f, -0.05374558f, -0.02053199f, 0.00251125f, -0.01740986f, -0.01696454f, 
    0.01860099f, -0.01305796f, -0.01982843f, -0.04236196f, 0.04225249f, 0.02994465f, 0.02851937f, -0.03539171f, 
    -0.01909452f, -0.04030146f, 0.01255251f, -0.04165668f, -0.00792343f, -0.01472717f, -0.00342739f, -0.05283825f, 
    -0.02518508f, 0.00820247f, -0.04987640f, -0.00844726f, 0.00187636f, -0.04540617f, -0.02292303f, -0.01038967f, 
    -0.04875713f, -0.04900580f, 0.02148877f, 0.03414154f, 0.01875046f, -0.03930543f, 0.02807327f, -0.05632716f, 
    -0.03328087f, -0.04432212f, 0.01882499f, -0.04343496f, -0.02082495f, -0.04228369f, -0.04095820f, -0.03155590f, 
    -0.00760099f, 0.03573989f, 0.01564935f, 0.00144439f, 0.04024468f, -0.03445032f, -0.04091023f, 0.02851302f, 
    0.03748386f, 0.01551372f, 0.02023871f, -0.04717788f, -0.05227387f, 0.03732115f, -0.00961092f, 0.03867793f, 
    0.00813008f, 0.02984961f, -0.05037612f, -0.02133965f, 0.01323350f, -0.02137372f, 0.00247262f, 0.03191645f, 
    -0.01716751f, 0.02913880f, 0.01208664f, -0.03126118f, -0.03385293f, 0.01395769f, 0.01186412f, -0.00197680f, 
    -0.00713851f, 0.00179878f, 0.02820607f, 0.01363857f, 0.00348782f, -0.04598590f, -0.01112102f, -0.01848169f, 
    -0.02984805f, 0.01946150f, -0.00166386f, -0.04879270f, -0.03607580f, 0.02465404f, -0.04622487f, 0.01572170f, 
    -0.04433334f, -0.01346584f, -0.03573493f, -0.01885711f, -0.04449243f, -0.05188458f, -0.03209836f, 0.04499009f, 
    -0.04443616f, 0.02412849f, -0.05587704f, 0.00935890f, -0.03979261f, -0.03990120f, -0.05580261f, 0.01177785f, 
    -0.04701344f, 0.01072571f, -0.02489239f, -0.04910630f, 0.00860700f, 0.03933736f, -0.03126289f, -0.01847778f, 
    -0.04296042f, 0.03596134f, -0.04985634f, -0.03090103f, -0.01032523f, -0.04381922f, 0.01413626f, 0.00820331f, 
    0.00110960f, -0.02231881f, -0.00229324f, 0.00493775f, -0.02697559f, -0.01040875f, -0.03018925f, 0.02036424f, 
    -0.03926067f, -0.04633602f, 0.04061681f, 0.04105353f, 0.00312209f, 0.00342577f, -0.05042642f, 0.03152629f, 
    -0.02475999f, 0.03061340f, 0.02478026f, 0.02945551f, -0.00392065f, -0.00539983f, 0.02600202f, -0.02042386f, 
    -0.02083709f, -0.03809054f, -0.01863787f, 0.04194245f, 0.00655359f, 0.02993946f, -0.05346210f, -0.03619485f, 
    0.02427240f, -0.04366919f, -0.00756175f, -0.04909277f, -0.04068260f, -0.04626304f, 0.04316358f, -0.01572147f, 
    -0.00778472f, -0.04365652f, -0.00543763f, 0.04542970f, 0.02040557f, -0.00241204f, 0.03691421f, 0.01106334f, 
    0.02527872f, 0.01036538f, -0.02777393f, -0.02015099f, 0.00986690f, 0.02816656f, -0.03845858f, 0.00094308f, 
    0.04304603f, -0.02489106f, -0.05192108f, -0.01615300f, 0.04428939f, 0.00662055f, 0.01112336f, -0.00374400f, 
    -0.00805405f, -0.02110070f, -0.03917110f, 0.02505109f, -0.04003774f, -0.02662195f, -0.01300501f, 0.04007440f, 
    -0.00835379f, -0.04296278f, -0.05017671f, -0.02459220f, -0.05341259f, 0.04102538f, -0.03723992f, -0.04567597f, 
    -0.02481072f, -0.02056592f, -0.00563122f, 0.04400270f, -0.04364957f, 0.04041591f, 0.01102132f, -0.00936312f, 
    0.00242781f, 0.01173419f, 0.01937032f, -0.04081102f, 0.04412421f, -0.03289590f, -0.04691192f, 0.03107545f, 
    -0.01566882f, -0.02809258f, 0.00400106f, -0.01572081f, 0.02969479f, 0.02256106f, 0.00350282f, -0.02282694f, 
    -0.03137263f, -0.04135655f, -0.02225870f, -0.01213878f, 0.03620336f, -0.02714065f, -0.02355850f, 0.01755654f, 
    -0.01720371f, -0.00980420f, -0.01384255f, -0.05057473f, -0.01168989f, -0.03486799f, -0.01117799f, 0.03907903f, 
    0.02246061f, 0.00681317f, 0.02878907f, -0.04348990f, 0.00852498f, 0.02878796f, 0.04902560f, 0.05371521f, 
    -0.05479574f, -0.00171039f, -0.04507195f, 0.02159115f, -0.05127494f, -0.02273577f, -0.01071085f, -0.02763186f, 
    0.01445519f, 0.00876821f, 0.00437212f, 0.01717499f, -0.04961460f, 0.02303605f, -0.03633143f, -0.04224849f, 
    -0.03547035f, -0.03315923f, -0.02493899f, -0.05093541f, 0.04523756f, -0.05030996f, 0.04101863f, -0.03873991f, 
    -0.01938481f, 0.04158945f, 0.01286840f, -0.03190321f, 0.01269648f, -0.01631895f, -0.04862733f, 0.03742382f, 
    0.02243632f, -0.02864404f, 0.03132452f, -0.00423415f, 0.01122740f, 0.01749184f, -0.01615716f, 0.02761976f, 
    -0.02349330f, 0.04363552f, -0.01709213f, 0.00656089f, -0.00812998f, -0.01427526f, 0.00879721f, -0.04828616f, 
    0.03901576f, -0.03553189f, -0.04869590f, 0.00364018f, -0.00380049f, -0.03088431f, -0.01738814f, -0.00285375f, 
    -0.01716193f, 0.04381046f, 0.01823208f, 0.03131555f, -0.02684319f, -0.03874446f, 0.02446270f, -0.03595496f, 
    -0.02163206f, 0.04529122f, 0.00805092f, -0.00309813f, -0.03991549f, -0.00475962f, 0.00222912f, 0.01785104f, 
    -0.04696540f, -0.01210069f, 0.02619768f, 0.04305531f, 0.01744979f, 0.02516586f, 0.03797501f, 0.01743915f, 
    0.03291487f, 0.00201618f, -0.00321440f, 0.01354745f, 0.01382652f, -0.03211780f, 0.01618679f, -0.00873094f, 
    -0.01468423f, 0.00554427f, 0.01357523f, -0.01424487f, -0.00792785f, 0.00188396f, -0.00150450f, -0.01694131f, 
    -0.05026092f, 0.03880024f, -0.01735978f, -0.05186088f, -0.04682275f, 0.03514062f, -0.04273020f, 0.01291012f, 
    0.01714419f, 0.02451991f, -0.03959227f, -0.01349577f, -0.02151707f, 0.02426184f, -0.01930828f, -0.04071431f, 
    -0.05237357f, -0.04863723f, -0.01369254f, -0.04712252f, -0.02795138f, 0.01366624f, 0.00302414f, -0.01059100f, 
    0.00397943f, 0.00674738f, -0.03419648f, -0.05297812f, -0.01418737f, 0.01807059f, 0.04068029f, 0.04031999f, 
    0.00909784f, 0.00708768f, -0.03302853f, 0.02422728f, -0.02733611f, 0.05113704f, -0.05579832f, -0.00212152f, 
    -0.00553218f, 0.01744235f, -0.03110828f, 0.01576496f, -0.02902701f, -0.05314036f, -0.04519135f, 0.00526574f, 
    -0.04886914f, 0.00323326f, -0.04196115f, 0.03910579f, -0.02791217f, 0.03772378f, -0.00223636f, -0.00930915f, 
    0.01551011f, -0.04813746f, -0.02591218f, 0.01377925f, 0.01201867f, -0.03691124f, 0.04128859f, -0.04260852f, 
    -0.00434070f, 0.02965997f, 0.03020815f, 0.01381156f, 0.01472052f, -0.03491975f, -0.03646789f, -0.04126756f, 
    0.01600789f, 0.00891758f, -0.01551584f, -0.03657012f, -0.01921161f, 0.04088456f, 0.01084716f, 0.04013607f, 
    -0.03317855f, 0.02897552f, 0.01044325f, -0.03163378f, 0.01162706f, -0.05340822f, 0.01810360f, 0.01552892f, 
    0.04114151f, -0.01748037f, -0.00352671f, 0.01668312f, -0.04772391f, -0.01285394f, 0.04361213f, 0.02004195f, 
    0.00282726f, 0.03445659f, -0.03654153f, 0.02278002f, -0.00907627f, -0.00510462f, 0.03393988f, 0.01324012f, 
    -0.17404628f, 0.10069202f, -0.08764017f, -0.06441248f, -0.00808039f, 0.11649911f, 0.03716796f, 0.12041426f, 
    -0.09372951f, 0.00942102f, -0.20302336f, -0.03090931f, 0.03740029f, 0.00097822f, -0.08601142f, -0.00101168f, 
    -0.03565829f, 0.01135855f, 0.08255322f, -0.05833929f, 0.12966350f, 0.05246436f, -0.02050459f, -0.07396705f, 
    0.23449540f, -0.14500250f, -0.04412388f, -0.04216983f, -0.02277016f, 0.09324782f, 0.02329467f, 0.10741202f, 
    0.23361672f, -0.08334439f, -0.01295366f, -0.00638746f, 0.08265682f, -0.14469446f, -0.00372802f, 0.02248418f, 
    -0.07777707f, -0.05163245f, 0.03053814f, 0.03330026f, -0.14220759f, 0.08787240f, -0.00953061f, 0.09560611f, 
    0.04624287f, 0.10581363f, 0.11005354f, -0.29187137f, 0.11496740f, -0.06404218f, 0.15803550f, -0.05463126f, 
    0.15478948f, -0.05451754f, -0.11352193f, -0.15896335f, -0.03400957f, -0.01844400f, -0.02918078f, 0.02044283f, 
    -0.17103732f, 0.07152143f, -0.04817991f, 0.14244813f, 0.02413378f, 0.03480423f, 0.11660299f, -0.17369801f, 
    0.55578464f, 0.22538641f, 0.02195345f, 0.19825977f, -0.04728537f, 0.10510349f, -0.02145166f, -0.09331336f, 
    -0.09447797f, -0.00036691f, -0.01173767f, 0.05048897f, 0.11342563f, -0.01363046f, 0.02992347f, -0.08907866f, 
    0.17434254f, -0.04584835f, 0.03749606f, 0.07507648f, -0.03044108f, 0.05473305f, -0.08639281f, -0.00256085f, 
    -0.04666259f, 0.09295450f, 0.03790886f, 0.11198340f, -0.04847764f, 0.09045106f, -0.05512360f, 0.02700749f, 
    0.13216966f, -0.06836053f, -0.07076404f, 0.04610769f, 0.13228536f, -0.01372464f, -0.06239318f, 0.00305045f, 
    -0.09614605f, 0.06463099f, -0.01179498f, -0.13559443f, 0.06671512f, -0.04585714f, -0.05807139f, -0.04878789f, 
    0.20342052f, -0.03011669f, -0.18498370f, 0.11116119f, -0.05875747f, 0.10610960f, -0.10757616f, 0.00905523f, 
    -0.05508227f, 0.05186058f, 0.06000734f, 0.03975058f, 0.21556865f, -0.10210714f, -0.07851519f, -0.05614628f, 
    0.01679432f, 0.00863061f, 0.06918899f, -0.06875690f, 0.07415469f, 0.01024198f, -0.00138965f, -0.02100678f, 
    0.07410748f, -0.12847731f, -0.02813600f, 0.29752389f, -0.18010962f, 0.04546328f, -0.09073956f, 0.03111386f, 
    -0.17169042f, 0.01399874f, -0.03356869f, -0.00869841f, 0.16137524f, 0.24983402f, -0.07549626f, 0.05331066f, 
    -0.09785577f, 0.13417605f, 0.00496373f, 0.06946221f, -0.09198247f, 0.00489966f, -0.10401466f, -0.02673310f, 
    -0.04526947f, 0.11162451f, 0.01558715f, 0.11267914f, -0.07847302f, -0.02102729f, 0.08002590f, 0.02134501f, 
    0.06390575f, 0.02714781f, 0.10945605f, -0.09232776f, -0.01523402f, -0.24970482f, -0.16978954f, -0.01965850f, 
    0.04772373f, -0.03271057f, -0.02598353f, -0.01495471f, -0.04029201f, 0.03043998f, -0.00540328f, 0.02309236f, 
    0.21626857f, -0.24573047f, -0.03007949f, 0.25095120f, 0.01572702f, 0.06359035f, 0.08667105f, 0.06155032f, 
    -0.07682253f, -0.00210995f, 0.03757322f, 0.03659229f, 0.23101650f, 0.03700551f, -0.03551483f, 0.06154752f, 
    0.02496912f, 0.05560550f, -0.06930745f, -0.02622276f, 0.06658156f, 0.04577896f, 0.10144019f, -0.12352441f, 
    -0.07505710f, 0.10979113f, 0.16933733f, -0.06099804f, -0.11251987f, -0.02034255f, 0.01064752f, -0.05279762f, 
    -0.09933335f, 0.00547643f, -0.03761937f, -0.04520195f, 0.13649423f, 0.02304860f, 0.05134130f, 0.03466880f, 
    -0.14571261f, -0.00342963f, -0.14767934f, 0.17864126f, -0.02708344f, -0.06967086f, 0.04127830f, 0.11786847f, 
    0.36584106f, 0.02906600f, 0.06829490f, 0.07121752f, 0.11776795f, 0.03202933f, -0.03336651f, 0.06724389f, 
    -0.13255556f, 0.05752423f, -0.03254515f, -0.04519908f, 0.25327989f, -0.17508756f, -0.04816948f, 0.15979074f, 
    -0.04676295f, 0.06283023f, -0.09863447f, 0.03253902f, -0.05603819f, -0.02984204f, 0.04874791f, -0.02047616f, 
    0.51830292f, 0.07988270f, 0.19619083f, 0.12062525f, -0.01758632f, -0.09371024f, 0.08285746f, 0.19941023f, 
    -0.12747510f, -0.10001747f, -0.02301328f, 0.03308924f, 0.10696457f, -0.08611453f, 0.21681213f, 0.26665017f, 
    0.01666043f, -0.10083817f, 0.09952437f, 0.06203302f, -0.04689797f, 0.11151911f, -0.00596864f, 0.06288584f, 
    0.29073945f, 0.14929537f, -0.09518328f, -0.09903057f, -0.02149003f, 0.01313718f, 0.05479327f, -0.07278775f, 
    0.05342489f, -0.06887833f, -0.12277735f, -0.04164345f, -0.00677838f, -0.03342233f, 0.07817688f, 0.13547401f, 
    -0.01298168f, 0.02936174f, -0.08678991f, 0.02344439f, 0.07921040f, -0.02441440f, -0.01548693f, -0.07679851f, 
    0.15377901f, 0.00117759f, -0.14345911f, -0.08219980f, 0.12037481f, 0.13027139f, -0.06897628f, 0.04537687f, 
    0.02635721f, 0.03876421f, 0.03601249f, -0.08250435f, -0.06252200f, -0.09603239f, 0.10635375f, -0.12616161f, 
    -0.17761084f, -0.02673774f, 0.07187726f, -0.05683373f, 0.05023270f, -0.05304148f, 0.02326586f, -0.05893806f, 
    0.02931813f, 0.07798147f, 0.01962893f, -0.07429349f, 0.00120656f, -0.06474611f, 0.12625661f, -0.05341212f, 
    0.19223006f, -0.04091311f, 0.01523905f, -0.00884198f, -0.13403106f, 0.02887342f, -0.10531881f, 0.00115950f, 
    0.05695502f, 0.03495548f, 0.00848774f, -0.00217837f, -0.02788993f, 0.11145249f, -0.00264690f, -0.01629779f, 
    0.07079295f, 0.10190058f, -0.15275465f, -0.04028549f, 0.04028202f, -0.11130768f, -0.02691977f, 0.09959576f, 
    -0.03711414f, 0.01878839f, -0.16347459f, -0.02292493f, -0.06961178f, -0.28983915f, 0.07516182f, -0.04230110f, 
    0.06949241f, 0.09946502f, 0.04660662f, -0.00511755f, -0.00149307f, 0.03605984f, 0.15238547f, -0.08806090f, 
    -0.16958362f, -0.06008030f, -0.08244291f, -0.13613497f, -0.12554738f, -0.04185468f, -0.12733349f, 0.01809832f, 
    -0.00294200f, -0.05769664f, 0.11414248f, 0.10514413f, 0.17789733f, 0.16768038f, -0.13426469f, -0.07448591f, 
    -0.11221883f, 0.04054150f, 0.02789679f, 0.01079117f, -0.07163460f, 0.13356861f, 0.08182314f, 0.04468993f, 
    -0.27478448f, -0.00697505f, -0.42203313f, 0.01444086f, -0.08730768f, -0.07240800f, -0.03911745f, 0.08684602f, 
    -0.06578375f, -0.01552926f, 0.11863978f, -0.04692886f, 0.42369193f, 0.23966882f, -0.14122111f, -0.07020900f, 
    0.18192416f, 0.05867664f, -0.02758371f, 0.02856383f, -0.06034803f, 0.09152000f, -0.11069632f, -0.01550093f, 
    -0.21341264f, -0.09724703f, -0.04546437f, -0.15120818f, -0.05237195f, -0.01897843f, 0.01433869f, 0.16783965f, 
    0.18308897f, -0.19330427f, 0.00637764f, 0.06477474f, 0.24396539f, -0.05903007f, -0.04676614f, -0.13218403f, 
    0.20664483f, 0.00445495f, -0.19004178f, 0.06410416f, -0.02435991f, 0.00249069f, 0.17760855f, -0.10053509f, 
    -0.18494512f, 0.28224167f, 0.18917920f, 0.12216469f, 0.07347777f, -0.00805457f, -0.04444867f, -0.03356810f, 
    0.01123596f, 0.05318611f, 0.08458328f, -0.02056300f, 0.02851444f, -0.10872538f, 0.20662081f, -0.32873648f, 
    0.09895458f, -0.18364687f, -0.12631118f, -0.05670871f, -0.05954483f, 0.21872905f, -0.10198896f, 0.06275427f, 
    0.01037764f, -0.07744344f, -0.00918264f, 0.05615595f, 0.07343586f, -0.10829061f, -0.12755482f, 0.01775147f, 
    0.07234553f, 0.03097101f, 0.09201941f, 0.07737314f, -0.05422591f, 0.04244822f, 0.20575863f, 0.02553469f, 
    0.09828314f, -0.02429902f, 0.05071654f, 0.04835849f, 0.06276879f, -0.13295065f, 0.03052500f, -0.18604268f, 
    0.48394144f, -0.05621484f, -0.24406156f, 0.14372657f, -0.02639149f, 0.04319170f, -0.04905508f, 0.00404315f, 
    -0.04859810f, 0.02950970f, -0.07560873f, 0.05848436f, 0.43153965f, 0.07156768f, -0.40429643f, -0.04320094f, 
    0.06812607f, -0.18076883f, 0.05111441f, -0.05709739f, 0.00915683f, 0.03345316f, 0.00794722f, 0.12412291f, 
    -0.08287851f, -0.00143824f, -0.26518333f, 0.28851327f, 0.00197072f, -0.11432140f, 0.05251205f, -0.04234381f, 
    -0.05832145f, 0.02284752f, 0.04784054f, -0.08123520f, 0.40812725f, 0.01102524f, 0.18203425f, 0.18553457f, 
    0.00546369f, 0.22328867f, 0.08980530f, 0.03546687f, -0.00254821f, -0.00200114f, 0.07218821f, -0.01193740f, 
    0.09478527f, 0.26765227f, 0.07052484f, -0.15798800f, 0.11893263f, -0.03686580f, -0.05856984f, 0.05285211f, 
    -0.02042398f, -0.14899792f, 0.14538015f, -0.12204232f, -0.07154529f, 0.31376112f, -0.00705956f, 0.16321105f, 
    0.07905004f, 0.21183847f, -0.08505405f, -0.11367868f, 0.04281878f, 0.02446957f, 0.11112005f, -0.11230946f, 
    -0.14739627f, -0.02823684f, 0.05113276f, 0.27906233f, 0.01932815f, -0.07214323f, 0.00047181f, 0.00964762f, 
    -0.05520082f, 0.05064667f, 0.00867614f, -0.07771591f, 0.04892743f, 0.19546875f, -0.24838953f, 0.05382163f, 
    0.00035218f, 0.02118794f, 0.00439186f, -0.07146701f, 0.10981620f, 0.02387438f, -0.02209937f, -0.12372245f, 
    -0.01360480f, 0.01357851f, -0.11634341f, -0.17212513f, -0.04170159f, -0.07700376f, -0.00922575f, -0.14738342f, 
    -0.07965564f, -0.03713821f, -0.01505592f, -0.04802313f, -0.01857874f, 0.07535277f, 0.26858592f, 0.03870547f, 
    0.02531203f, 0.00838953f, -0.08114859f, 0.02153181f, -0.07739990f, 0.01231437f, 0.01175596f, -0.05008762f, 
    0.14035629f, 0.07174633f, 0.23065823f, 0.17968369f, 0.05971685f, 0.01966796f, -0.00771284f, 0.17179146f, 
    0.00761084f, 0.12319343f, 0.09026004f, -0.05448397f, -0.01064532f, 0.02969951f, 0.14418837f, 0.08863238f, 
    0.10092813f, -0.16363728f, -0.03273214f, -0.05910937f, -0.11509610f, -0.05986694f, 0.08548214f, -0.06092749f, 
    0.22095127f, -0.08327489f, 0.14216378f, 0.09552141f, 0.13305667f, -0.08744624f, 0.23364368f, -0.05592351f, 
    -0.09171417f, -0.10807379f, -0.04278098f, -0.01869955f, -0.06637767f, 0.07805710f, 0.24087107f, -0.09110451f, 
    0.00674270f, 0.03477155f, 0.05863407f, 0.01408103f, 0.15000965f, 0.07421149f, 0.00952354f, 0.05255895f, 
    0.02759322f, -0.17235428f, 0.20847332f, 0.05370964f, 0.01122332f, 0.13508725f, 0.06077691f, 0.01267992f, 
    0.07386056f, 0.00643886f, 0.10147013f, 0.20474246f, -0.40645245f, 0.17687334f, 0.17739311f, 0.01255145f, 
    0.01237727f, 0.03070501f, 0.00357212f, 0.00825977f, 0.17247827f, 0.07260683f, 0.05593428f, 0.02762452f, 
    0.29034111f, -0.21549596f, -0.16835919f, -0.03555359f, -0.01065155f, 0.01460851f, 0.08577156f, 0.09823203f, 
    0.16242574f, 0.04362822f, 0.05885958f, -0.04897325f, 0.11137421f, 0.38338575f, 0.07855587f, -0.08581049f, 
    -0.04481944f, 0.02087354f, -0.20855275f, -0.22503203f, 0.03474914f, 0.12804256f, -0.05979029f, 0.07392222f, 
    -0.02893465f, 0.06016763f, 0.13855770f, -0.02905990f, 0.08788657f, -0.03408442f, -0.03135607f, 0.11974956f, 
    -0.00628491f, 0.10899343f, -0.00821430f, -0.05800087f, 0.10706162f, -0.00112281f, 0.02874613f, -0.02166459f, 
    0.09462922f, -0.01298143f, -0.10280713f, 0.06125022f, 0.06639200f, 0.03024616f, -0.09652916f, 0.02338251f, 
    0.39606103f, -0.03520839f, -0.31423575f, 0.01067339f, 0.15780428f, -0.13098691f, -0.08619303f, 0.07108615f, 
    -0.03638713f, 0.13651951f, -0.03943098f, 0.01598688f, 0.51669985f, 0.19383447f, -0.02795106f, -0.05863221f, 
    0.07844835f, 0.02318249f, 0.01177469f, 0.11296876f, 0.01141191f, -0.11064056f, 0.06234302f, -0.01540001f, 
    0.21955477f, -0.12425025f, -0.04987165f, 0.00244465f, 0.00502555f, -0.01629185f, -0.03366354f, -0.02384469f, 
    0.10136097f, -0.04796647f, -0.03068620f, 0.03142205f, 0.04002555f, 0.13307182f, 0.01745966f, 0.10065950f, 
    -0.00491667f, -0.05371368f, 0.00753887f, 0.12232439f, -0.03489161f, 0.03227228f, -0.15188675f, -0.13223474f, 
    0.32722998f, -0.02687142f, -0.02878042f, -0.01512328f, -0.03491936f, 0.13233142f, -0.04317152f, -0.01972119f, 
    -0.01942474f, -0.05200122f, 0.15146169f, 0.07627890f, -0.39641586f, 0.29240993f, 0.15682213f, -0.02041353f, 
    0.03590831f, 0.15042879f, -0.06877553f, -0.01670514f, -0.01386050f, -0.01896432f, -0.00977218f, -0.02358665f, 
    0.11857472f, -0.10020468f, -0.10831051f, -0.06298090f, -0.01869352f, 0.06655487f, 0.02694285f, -0.06075443f, 
    -0.08079653f, -0.02999409f, -0.02229667f, -0.07261536f, -0.07446072f, 0.32214001f, 0.13976775f, -0.22965787f, 
    0.15086299f, 0.11432575f, -0.05078381f, -0.09839731f, -0.00278708f, -0.00608621f, 0.13974069f, -0.05593047f, 
    0.01806723f, -0.39299843f, 0.01696663f, -0.01698002f, -0.05384961f, 0.04306548f, 0.10211151f, -0.02412961f, 
    -0.01644702f, -0.01160856f, 0.05366645f, -0.03056143f, -0.17456755f, 0.19892536f, -0.08658615f, -0.31446332f, 
    -0.08926079f, 0.04649311f, 0.01534742f, 0.02379629f, -0.20954393f, 0.03015981f, -0.06522105f, 0.00202369f, 
    -0.14385252f, 0.20679730f, 0.06008450f, -0.25552925f, 0.06733169f, 0.04192496f, 0.00266533f, 0.06594308f, 
    -0.05782663f, 0.15157241f, 0.04397052f, -0.05074599f, -0.05844681f, 0.07385854f, 0.22674625f, 0.13499397f, 
    0.01569785f, -0.00682701f, 0.08595096f, 0.05099113f, -0.04711121f, 0.04532037f, 0.07544560f, 0.09435969f, 
    -0.06681396f, 0.19501491f, 0.16991907f, -0.19182913f, 0.18264894f, 0.01294484f, 0.01557314f, 0.08760793f, 
    0.07666083f, 0.11892955f, -0.02910874f, 0.01617651f, 0.03226544f, 0.08715021f, -0.15867911f, -0.34351251f, 
    0.22987182f, 0.02660697f, -0.03023346f, -0.07077023f, -0.04181255f, 0.02648525f, -0.00437592f, 0.06342311f, 
    -0.09704686f, 0.27656400f, 0.06683856f, -0.36781013f, 0.03004875f, -0.06281448f, -0.01892812f, -0.05721942f, 
    0.07342979f, -0.00418560f, 0.09716086f, 0.05258001f, 0.05395604f, -0.53205132f, -0.04437660f, 0.22393861f, 
    0.09026495f, 0.01318587f, 0.12810579f, -0.05326366f, -0.21201178f, -0.13326272f, -0.03971104f, -0.13486393f, 
    -0.05060723f, 0.00380014f, 0.07620008f, 0.09540821f, 0.00730489f, -0.06896650f, 0.01452924f, 0.09735903f, 
    0.00146677f, 0.00480584f, 0.06724138f, 0.15299796f, 0.03142444f, 0.01410307f, -0.00631838f, 0.15079959f, 
    -0.05395763f, 0.09963965f, 0.00725832f, 0.03056538f, 0.02083098f, 0.02304666f, 0.01674887f, 0.09301070f, 
    0.08950387f, -0.08346825f, 0.18757281f, -0.14762831f, -0.07952847f, 0.07941426f, -0.00287943f, 0.06311321f, 
    0.03063875f, 0.01574528f, 0.08064511f, 0.03319596f, -0.33596307f, 0.28438386f, -0.05519029f, -0.18153171f, 
    0.03019006f, -0.04819045f, 0.06278315f, -0.04691660f, 0.05145798f, 0.15764891f, 0.01366392f, 0.03182516f, 
    -0.05585123f, 0.03485476f, -0.22745983f, -0.00641408f, 0.07298545f, 0.00511785f, 0.04372687f, -0.07535627f, 
    -0.00712491f, 0.06925951f, 0.00546820f, 0.05062073f, 0.32085976f, -0.10243052f, 0.00133845f, -0.00978744f, 
    0.11080758f, -0.03431576f, 0.06118761f, -0.02541434f, 0.07737102f, -0.01500088f, 0.05891314f, 0.00043456f, 
    0.01559580f, -0.18035175f, -0.00528889f, 0.02121806f, 0.04849271f, -0.05086343f, -0.04880309f, -0.01217980f, 
    -0.02729634f, 0.09712543f, -0.02741740f, -0.05991649f, -0.15237424f, 0.05154864f, 0.17874342f, -0.31261930f, 
    0.03682799f, 0.08222118f, -0.09108760f, -0.08926854f, 0.00659280f, 0.04211146f, -0.04390864f, -0.05397420f, 
    0.12639025f, -0.27250671f, -0.04837942f, -0.05412197f, 0.01669072f, 0.10419773f, -0.00797057f, 0.06492240f, 
    -0.01805693f, 0.10053020f, -0.08547065f, 0.11720011f, 0.38594675f, 0.05568435f, -0.38805667f, -0.12808296f, 
    -0.02475820f, 0.03129493f, 0.03986835f, -0.10153883f, 0.03233544f, 0.06097683f, 0.04534232f, 0.10157787f, 
    -0.25063765f, -0.16066128f, 0.08476385f, -0.01089879f, -0.07065387f, 0.10805216f, 0.00442798f, 0.09270216f, 
    -0.04273520f, 0.00371208f, 0.15867034f, 0.12791617f, 0.39002246f, -0.19800812f, -0.17936467f, 0.15960856f, 
    0.05594224f, 0.03058673f, -0.01781548f, -0.05666606f, -0.08584148f, 0.10503679f, 0.04569964f, 0.10155318f, 
    0.20761117f, -0.05937297f, -0.06707972f, -0.35432515f, 0.00099723f, 0.11223188f, 0.02700832f, -0.00189627f, 
    -0.07894947f, -0.03816527f, 0.00649118f, -0.04790965f, -0.11382108f, 0.03817769f, -0.02956318f, 0.19746785f, 
    0.05451576f, -0.07573870f, -0.06269236f, 0.07276664f, -0.08425993f, 0.01365518f, 0.06407107f, -0.08008356f, 
    -0.08271071f, -0.01506433f, 0.03626928f, 0.07101411f, 0.06637686f, 0.01212109f, 0.07331681f, 0.18459693f, 
    -0.02090820f, 0.05022616f, 0.05018887f, 0.06199061f, 0.19502363f, -0.23793000f, 0.03472397f, -0.14106680f, 
    0.14824127f, 0.03996573f, 0.04105477f, -0.06158561f, -0.02396453f, -0.00088911f, 0.11772614f, 0.10251689f, 
    -0.07272755f, 0.17498706f, 0.15146270f, 0.03058320f, 0.23206571f, 0.03731562f, -0.11679354f, -0.01565575f, 
    0.01917137f, 0.01966491f, -0.05789896f, -0.00090627f, -0.00253268f, 0.45693812f, 0.13911761f, 0.28143334f, 
    0.02748191f, 0.02266314f, 0.13269326f, 0.18041135f, -0.13191631f, 0.06094345f, 0.07284944f, 0.02047357f, 
    -0.02918276f, 0.03426128f, -0.05322146f, -0.05466876f, 0.01245754f, -0.00747756f, -0.03760434f, 0.04048786f, 
    -0.03860504f, 0.03029944f, 0.01785310f, 0.01830592f, -0.03053281f, -0.01864746f, 0.01898849f, -0.03146173f, 
    -0.03298356f, 0.01247520f, -0.02830578f, 0.04094034f, 0.00966274f, 0.02855390f, -0.02427605f, -0.05495200f, 
    -0.02280153f, -0.01393243f, -0.01446196f, -0.02436195f, 0.00812384f, -0.05139738f, -0.05277930f, -0.05208970f, 
    -0.02546910f, -0.04663673f, -0.02257687f, -0.05567372f, 0.03667800f, 0.02269221f, 0.01429865f, 0.02963229f, 
    0.01674404f, -0.02249554f, -0.02099534f, -0.00402091f, 0.00731579f, -0.02990507f, 0.01007465f, -0.03635966f, 
    0.01514770f, 0.00270977f, -0.00984500f, 0.02804730f, -0.04027422f, 0.00859870f, -0.04097790f, -0.00875101f, 
    0.03924088f, -0.04763502f, -0.02454511f, -0.03408903f, -0.00780633f, -0.03482558f, -0.01147752f, -0.03377966f, 
    -0.02952416f, -0.00037714f, -0.04054326f, -0.03901546f, -0.01357410f, -0.03178084f, -0.01309372f, -0.03425193f, 
    -0.01272115f, -0.00204574f, 0.01361555f, -0.02638354f, 0.00834663f, 0.00271818f, 0.02372383f, 0.02567454f, 
    -0.00471169f, 0.01236495f, 0.01750248f, 0.04115401f, -0.03153705f, -0.05497272f, -0.04943475f, 0.04107610f, 
    -0.02176310f, 0.03060419f, -0.04193986f, -0.04260845f, 0.01944340f, -0.02795654f, -0.00843957f, -0.01573069f, 
    0.02381881f, 0.01803125f, 0.02650634f, 0.00776878f, 0.01447540f, -0.00732346f, -0.03905886f, -0.04931946f, 
    -0.02990804f, -0.03893105f, -0.02547097f, 0.00622036f, -0.05319075f, -0.02548116f, 0.00643253f, 0.01042385f, 
    -0.04095255f, -0.01547518f, 0.02447657f, -0.05638833f, -0.00201046f, -0.03506383f, -0.03419925f, -0.00765838f, 
    0.01315675f, -0.01717698f, -0.01315919f, -0.00978471f, -0.04926796f, -0.04818124f, 0.01775146f, -0.01389332f, 
    -0.02108632f, -0.05444166f, -0.05675407f, -0.04845810f, -0.00756962f, -0.04001681f, -0.03205599f, -0.03980722f, 
    0.03530123f, 0.02377074f, -0.01222561f, 0.01035987f, -0.00948645f, -0.04617231f, -0.00794433f, 0.03921060f, 
    -0.03181032f, 0.02370736f, 0.01661462f, -0.02808790f, -0.03396127f, -0.00610692f, 0.04121458f, -0.01358447f, 
    0.03664831f, -0.02503321f, 0.03209966f, 0.02182135f, 0.03792623f, -0.01452767f, -0.02185258f, -0.02586042f, 
    -0.04461269f, 0.04421189f, 0.01946902f, -0.03340376f, -0.02683821f, -0.02529619f, -0.02886561f, -0.05480193f, 
    -0.00992212f, 0.00196454f, -0.04933069f, 0.01534610f, -0.01612693f, 0.03618373f, -0.03358646f, 0.01964845f, 
    -0.02474675f, 0.04442903f, 0.02744224f, 0.01149591f, -0.02428226f, -0.01856217f, -0.03531552f, 0.04246863f, 
    -0.00943738f, -0.03740148f, 0.00283061f, -0.00566073f, 0.01611508f, -0.01142676f, -0.03008814f, -0.03176500f, 
    0.01718209f, 0.01836823f, 0.01514069f, -0.02697085f, -0.04168770f, 0.00318993f, -0.04582249f, -0.00271953f, 
    0.03335918f, 0.03333283f, -0.02689404f, -0.04757637f, 0.03326511f, -0.04194970f, 0.01448473f, -0.00666298f, 
    -0.00511646f, 0.03470096f, -0.01926078f, -0.05581963f, -0.05359337f, -0.01221978f, 0.00930849f, -0.05688819f, 
    0.00603466f, -0.00225319f, 0.04330923f, -0.04809289f, -0.04246648f, 0.02539159f, -0.01466571f, -0.02694140f, 
    -0.04450428f, -0.04460915f, -0.01475979f, -0.01955607f, -0.02280012f, -0.03639354f, 0.01467127f, 0.03177784f, 
    0.04055861f, -0.00594455f, -0.05501929f, 0.00468574f, 0.02513725f, -0.01818438f, -0.05314517f, -0.04968979f, 
    0.01201299f, -0.03052540f, -0.03455629f, -0.04730012f, -0.01966093f, 0.01766606f, -0.00980985f, -0.02134418f, 
    -0.00701228f, -0.02899064f, -0.05115431f, 0.03468951f, -0.04588499f, -0.05312030f, -0.02655400f, 0.01146295f, 
    0.04192789f, -0.05387004f, -0.01293859f, -0.00736295f, -0.00841695f, 0.02188822f, 0.03871999f, -0.02980153f, 
    0.03646544f, 0.00869507f, 0.03810293f, -0.03396736f, -0.04378894f, -0.04298739f, 0.01511471f, -0.05576872f, 
    -0.01646890f, 0.04433441f, 0.02225263f, 0.02654868f, 0.02093508f, 0.01737736f, 0.00959984f, -0.05041633f, 
    -0.04743118f, -0.04583966f, 0.04129712f, -0.01835816f, 0.02955201f, -0.03493422f, 0.00489939f, 0.01931671f, 
    0.00214590f, -0.03388227f, -0.00030031f, 0.00741395f, 0.04236437f, 0.03371661f, -0.00251563f, -0.04743547f, 
    0.01711101f, -0.03033322f, -0.01253660f, 0.03176778f, -0.04665041f, -0.02546305f, -0.03368325f, 0.02764236f, 
    -0.01315751f, 0.02258881f, -0.02643737f, -0.03968506f, 0.01872264f, -0.02081604f, -0.02838114f, -0.05475052f, 
    0.03595878f, 0.04211507f, 0.03612180f, 0.02001480f, -0.02275082f, 0.03277464f, -0.01509761f, 0.02245192f, 
    0.01661410f, -0.00822433f, -0.01156043f, 0.00693373f, 0.03072972f, 0.03392510f, 0.04034946f, 0.01920043f, 
    0.01768071f, 0.00449942f, 0.01783166f, 0.00151080f, -0.02434568f, 0.02857203f, -0.00071305f, -0.04436767f, 
    0.00460125f, -0.05120412f, 0.01348148f, 0.04280020f, 0.01434253f, 0.02953701f, -0.01321499f, 0.03019559f, 
    0.04053288f, 0.04243078f, 0.04169599f, -0.01983652f, -0.03087231f, -0.00337851f, -0.05245574f, -0.04095618f, 
    0.00998985f, -0.02284047f, 0.03697783f, -0.01663902f, -0.01841744f, 0.02219873f, 0.03128494f, 0.00507594f, 
    -0.05092074f, -0.01537899f, -0.00746298f, -0.02035902f, 0.00129303f, -0.01817491f, 0.01106396f, 0.03553963f, 
    0.03737531f, -0.05510869f, -0.05650596f, -0.00549873f, 0.01092386f, 0.04144102f, -0.04258986f, -0.00408291f, 
    0.03648091f, -0.01463795f, -0.01897639f, 0.01931334f, -0.00162449f, -0.03490803f, -0.04664794f, 0.02839241f, 
    -0.02660836f, -0.00779060f, -0.03203269f, -0.00171242f, 0.01147175f, -0.02285521f, 0.00426535f, -0.00984018f, 
    0.03521923f, -0.05224556f, 0.02890260f, -0.06145185f, -0.02270504f, 0.02096342f, 0.04678636f, -0.01845044f, 
    0.01411558f, 0.02171262f, -0.04429824f, -0.01056955f, 0.01560599f, -0.02464905f, -0.05137376f, 0.00799565f, 
    -0.01506578f, 0.04113740f, -0.04465428f, -0.03191778f, -0.03018316f, 0.02376156f, -0.04799159f, 0.03694211f, 
    0.00989747f, 0.04091791f, -0.02388450f, -0.04388008f, 0.01642100f, 0.00740766f, 0.00749900f, -0.01896640f, 
    -0.01616016f, -0.01082474f, -0.00913335f, 0.03889783f, 0.02777923f, 0.03017594f, -0.03264306f, 0.03744953f, 
    0.04635675f, 0.02412228f, 0.01444456f, -0.04724130f, 0.00665220f, -0.00709942f, -0.03258708f, -0.00342210f, 
    -0.03051128f, -0.02143207f, 0.03528668f, 0.01573657f, 0.01795865f, -0.01692272f, -0.00306974f, 0.01296976f, 
    -0.05833189f, 0.03798985f, -0.03763672f, -0.05250682f, 0.03604294f, -0.05210463f, -0.02105014f, 0.03306674f, 
    0.03725216f, -0.02479211f, 0.01936482f, 0.00179957f, 0.00744589f, -0.04268385f, 0.03584594f, -0.02031677f, 
    -0.00867327f, -0.01629961f, -0.05297765f, -0.04589407f, -0.02111034f, -0.00003692f, -0.02645321f, 0.02360708f, 
    0.00856923f, -0.01023456f, -0.02136508f, -0.03218679f, -0.00114927f, -0.03683034f, 0.00287178f, 0.00589146f, 
    0.04966191f, -0.02462185f, 0.00181416f, -0.02941274f, -0.02163450f, -0.02186672f, -0.00366648f, -0.04899927f, 
    0.02499259f, -0.00322592f, 0.00026510f, -0.04147449f, -0.04792492f, 0.02844409f, -0.05961315f, 0.03314074f, 
    0.01327419f, -0.04931825f, 0.00030642f, -0.04670944f, -0.01566407f, -0.02924507f, -0.04431520f, -0.05034608f, 
    0.03249357f, -0.03367533f, 0.01892460f, 0.04027613f, -0.01003113f, -0.03118069f, -0.04078287f, 0.02935394f, 
    -0.00118145f, 0.02510771f, 0.03328747f, 0.04190465f, 0.02390828f, -0.00215827f, -0.02969587f, -0.00076803f, 
    -0.02942139f, 0.02544818f, 0.02984152f, 0.00390871f, -0.03933376f, 0.00564778f, 0.00649822f, 0.01508985f, 
    -0.00570216f, 0.03918890f, -0.02767432f, -0.02878040f, -0.00083708f, 0.03142349f, -0.05086970f, -0.02943294f, 
    0.00225821f, -0.04627762f, 0.03415032f, 0.02950856f, 0.01989145f, 0.00114725f, 0.03110087f, -0.03030159f, 
    -0.02672770f, 0.00649953f, -0.00955684f, 0.02851718f, -0.05233173f, 0.03852345f, 0.01461664f, -0.04204669f, 
    -0.02176018f, -0.05488443f, -0.01747395f, -0.00594081f, -0.03266817f, 0.03236185f, -0.04997520f, -0.05105697f, 
    0.00718761f, -0.02007060f, 0.00072265f, -0.00742776f, 0.00041934f, -0.02310940f, -0.02928795f, -0.02731754f, 
    0.01872099f, -0.02647967f, 0.00631504f, -0.01735264f, 0.03748732f, 0.03779275f, 0.02836939f, -0.05169930f, 
    0.00076698f, -0.04247098f, -0.00834908f, -0.03054180f, -0.04451143f, -0.05577782f, 0.02768419f, 0.02723288f, 
    0.04259342f, 0.02038484f, -0.04587441f, -0.01190857f, 0.03639323f, -0.00086814f, -0.05098888f, 0.01513963f, 
    -0.01688288f, 0.00544049f, 0.01195443f, -0.01230730f, -0.02097608f, -0.03454516f, 0.02812846f, -0.01472434f, 
    0.03130031f, 0.01223040f, -0.03085761f, 0.02103150f, 0.03201167f, -0.04601324f, 0.01212539f, 0.01772385f, 
    -0.00816145f, 0.04658053f, -0.03285186f, -0.04305128f, 0.01351846f, -0.00068048f, 0.00507375f, -0.02778904f, 
    -0.03972097f, -0.01272247f, -0.05361681f, 0.02646435f, 0.04311541f, 0.02660394f, -0.04931029f, -0.05247253f, 
    0.03433233f, -0.04052808f, -0.02136806f, 0.00099404f, -0.00370772f, -0.01035136f, 0.02420973f, -0.03664263f, 
    -0.04875749f, -0.04294545f, -0.04873511f, 0.02136533f, -0.03495691f, -0.04991703f, 0.01840417f, -0.05830816f, 
    -0.00268629f, -0.02452570f, -0.00141807f, 0.01810972f, 0.01571643f, -0.00209021f, 0.02740922f, 0.04502264f, 
    0.04318044f, 0.00572877f, 0.01771389f, -0.04910369f, 0.03631482f, 0.00368186f, 0.04454727f, 0.04096527f, 
    -0.03541750f, 0.03390070f, 0.04268770f, 0.01848663f, 0.04598909f, -0.04930597f, 0.02517207f, 0.01759384f, 
    -0.01873267f, 0.00159016f, -0.02914749f, -0.05667792f, -0.01093770f, -0.04742439f, -0.02644743f, -0.01455142f, 
    -0.02982502f, -0.04327943f, -0.05576180f, 0.00625016f, 0.04090589f, -0.01814640f, 0.03212193f, -0.01536027f, 
    0.03432522f, 0.02805486f, 0.01336440f, -0.04761879f, 0.04215361f, 0.00348857f, -0.05436767f, -0.02122908f, 
    0.02816489f, 0.00090009f, 0.00789095f, -0.01697064f, -0.03200333f, -0.01242150f, -0.00437828f, 0.02493050f, 
    -0.04922228f, 0.04403416f, -0.02432509f, -0.00584996f, -0.01909585f, 0.01057264f, -0.00347017f, -0.03752328f, 
    0.03067696f, 0.02895270f, -0.04946288f, -0.05021416f, -0.01818031f, 0.03943148f, -0.01144650f, -0.01449592f, 
    -0.02298491f, 0.03392880f, 0.03659445f, -0.03047165f, 0.02110500f, 0.03199071f, -0.04372042f, 0.00857671f, 
    -0.03788311f, 0.04007493f, -0.01107253f, 0.02102587f, -0.05164412f, 0.01420551f, -0.01428653f, 0.03658977f, 
    -0.02409061f, 0.02318709f, -0.00471836f, 0.00494513f, -0.05514248f, -0.01415748f, 0.01908188f, -0.02742998f, 
    -0.05169870f, -0.03415255f, 0.03369181f, -0.00311408f, -0.03067187f, -0.02763697f, 0.02438076f, -0.03715695f, 
    -0.03329556f, -0.03213866f, -0.03558172f, 0.04236515f, 0.03228535f, 0.01611676f, 0.04016301f, 0.03150404f, 
    -0.02236657f, 0.03300131f, 0.00892688f, -0.04619214f, -0.01412640f, -0.03802452f, 0.03837541f, 0.03496513f, 
    -0.01065828f, -0.02752033f, -0.03870874f, -0.01559037f, 0.03379870f, -0.01720568f, -0.00868871f, 0.00171303f, 
    0.26404303f, -0.09055532f, 0.09391821f, 0.17195688f, -0.06722715f, -0.06383124f, 0.02338147f, -0.04861933f, 
    0.11514705f, 0.06033781f, 0.15654968f, -0.21024470f, -0.05895919f, -0.16916777f, 0.29917324f, 0.03213786f, 
    -0.01458307f, -0.05877741f, 0.06685271f, 0.15515253f, -0.01036788f, 0.01442641f, -0.19457641f, 0.11638833f, 
    -0.27813467f, 0.09901727f, -0.04319819f, 0.13230257f, 0.14654906f, -0.03958588f, 0.05512547f, -0.05914318f, 
    -0.06580056f, 0.01902865f, 0.09418985f, -0.05742541f, 0.12144931f, 0.02381156f, -0.20017214f, -0.05532479f, 
    0.05775951f, -0.03768012f, -0.09472018f, -0.03629179f, -0.03504978f, -0.00880579f, -0.09140682f, 0.11173878f, 
    -0.02854815f, -0.08407333f, -0.10346786f, 0.35563841f, -0.06636681f, -0.08818961f, -0.04668052f, 0.14569137f, 
    0.09456482f, 0.11712511f, 0.04441365f, 0.14273208f, 0.10259519f, -0.08219586f, -0.18800478f, 0.09459041f, 
    -0.00561208f, -0.01277165f, -0.07327920f, -0.00788237f, 0.12702967f, 0.03325738f, -0.00764113f, 0.12387980f, 
    -0.23873897f, -0.02940223f, -0.13853894f, -0.06671748f, 0.14351387f, -0.07752425f, 0.07334518f, 0.06721243f, 
    0.00293924f, 0.01704064f, 0.04409604f, -0.06325872f, 0.16137907f, 0.12044305f, 0.18805322f, 0.21302699f, 
    -0.04274800f, 0.03476036f, -0.08911092f, -0.01210343f, 0.05297905f, -0.14409968f, -0.14501695f, -0.22516383f, 
    0.28331313f, 0.04870719f, -0.05222817f, 0.08618759f, 0.13188921f, -0.11742072f, 0.07454651f, -0.05529442f, 
    -0.06804280f, -0.09324182f, -0.02068215f, -0.06532238f, 0.07523045f, 0.14139470f, 0.02718737f, 0.02728590f, 
    0.17348734f, 0.06477945f, 0.08585147f, 0.20113790f, 0.13864142f, 0.15782453f, -0.22583768f, 0.03980053f, 
    -0.15983249f, -0.08151247f, 0.00769210f, -0.03600738f, 0.01672546f, -0.03361799f, -0.08399600f, -0.13532518f, 
    -0.02110832f, 0.04725841f, -0.06062685f, -0.13520415f, -0.16346653f, 0.24360517f, -0.09036303f, -0.07607801f, 
    0.07566191f, -0.19113392f, -0.11293353f, -0.09679422f, -0.11373137f, 0.03746198f, -0.03497183f, 0.00389640f, 
    -0.06688104f, 0.05924077f, -0.04390708f, -0.05176274f, 0.13331260f, -0.00726025f, 0.07983056f, -0.10318259f, 
    0.09954152f, 0.01179417f, -0.08477420f, -0.11967505f, 0.41800630f, -0.08701269f, 0.25387684f, -0.06800180f, 
    0.11609608f, 0.12640598f, -0.01114520f, 0.00787192f, -0.02611316f, -0.17267677f, -0.02734095f, -0.03009677f, 
    0.16508995f, -0.01264953f, -0.24304320f, 0.13818328f, 0.11969376f, 0.20580296f, -0.05304722f, 0.15042409f, 
    -0.04713913f, 0.12371674f, 0.24486934f, 0.12606281f, 0.11836360f, 0.26496086f, -0.04641198f, 0.12618133f, 
    -0.10012244f, -0.06679780f, 0.08799057f, 0.08548637f, 0.00758259f, 0.13055031f, -0.03937081f, 0.15361290f, 
    -0.21705800f, 0.18129319f, -0.11002656f, -0.23679703f, 0.06436421f, 0.12746345f, 0.12411802f, -0.06054565f, 
    0.10528827f, -0.06883424f, 0.04233678f, -0.06277510f, -0.02435900f, 0.19301523f, 0.01191580f, -0.02345871f, 
    -0.00247985f, 0.12488734f, -0.00469233f, 0.10529713f, -0.01602830f, -0.05566031f, 0.06239704f, 0.07328986f, 
    0.21714854f, -0.06140960f, 0.01317426f, 0.14411592f, 0.03611556f, 0.22857063f, -0.03154345f, 0.14369355f, 
    0.01412783f, 0.19809622f, -0.18094321f, 0.03680655f, -0.21439777f, 0.01858753f, -0.05033555f, -0.02977180f, 
    0.13829319f, 0.00872515f, -0.03537834f, 0.00127858f, 0.02815026f, 0.07889693f, -0.05773411f, 0.01304383f, 
    -0.29653898f, 0.17800020f, 0.03038883f, -0.15837200f, 0.06524833f, 0.00423380f, 0.03175376f, -0.04577804f, 
    0.06548201f, -0.12317186f, -0.00463027f, 0.00335326f, -0.11515693f, 0.28302142f, 0.02890642f, 0.03114944f, 
    0.22936217f, -0.04587705f, -0.04623917f, -0.03458852f, 0.00587563f, -0.12488095f, 0.09695961f, 0.29160461f, 
    -0.13852252f, -0.13881236f, 0.01375160f, -0.06132438f, -0.05825870f, 0.02280950f, 0.18618886f, -0.01129302f, 
    0.13061282f, 0.08394963f, -0.16939501f, 0.15578988f, 0.06994431f, 0.04401955f, 0.16645189f, -0.15103863f, 
    0.17451257f, 0.16550650f, 0.15238325f, 0.23775421f, 0.16611877f, -0.03321393f, 0.27583766f, 0.11470645f, 
    0.12801142f, -0.22247277f, -0.02762729f, 0.01812610f, 0.11440310f, -0.12686002f, -0.02649564f, -0.07148270f, 
    -0.02298808f, 0.06443968f, 0.17367513f, 0.03632398f, 0.04632520f, 0.14619054f, 0.02091040f, -0.22455147f, 
    0.08357181f, 0.02440947f, -0.06728811f, 0.01371648f, -0.03110984f, 0.01520625f, 0.04329944f, 0.24960583f, 
    -0.13618608f, -0.07660301f, 0.23099732f, 0.21687348f, -0.08252775f, -0.19129293f, -0.08062268f, -0.13696289f, 
    -0.07717481f, -0.12197411f, 0.02556981f, 0.00020359f, -0.13795285f, 0.16036864f, 0.20020361f, 0.13088262f, 
    0.06554214f, 0.18284309f, 0.13154823f, 0.08003788f, -0.02188541f, -0.05438158f, 0.07836164f, 0.09817629f, 
    0.31283215f, 0.02000263f, -0.17768621f, 0.14822623f, -0.02952597f, 0.17581958f, -0.03252640f, -0.09907565f, 
    -0.11100228f, 0.11412072f, 0.00359728f, 0.09099008f, 0.09839831f, -0.00458352f, 0.09215598f, 0.08914364f, 
    -0.06329947f, 0.08452788f, 0.00697450f, 0.01168604f, -0.03115982f, -0.09335550f, 0.04161341f, 0.10607326f, 
    -0.02311027f, -0.15021904f, 0.15163645f, -0.07537019f, -0.10849363f, 0.03407032f, 0.02560247f, -0.05119678f, 
    -0.08032134f, -0.08850775f, 0.09610190f, -0.11031201f, 0.18463221f, -0.16760722f, -0.21297961f, -0.08549484f, 
    -0.08927238f, 0.02376334f, 0.06677214f, -0.12914285f, 0.02288670f, -0.05760491f, -0.04517034f, -0.04985240f, 
    -0.06609970f, 0.12585035f, -0.20669454f, 0.06813760f, 0.03065221f, 0.13756144f, 0.08015544f, 0.05994932f, 
    -0.08491623f, 0.07591417f, -0.09242343f, -0.03381810f, 0.08049440f, 0.00818587f, 0.06842985f, -0.18588562f, 
    0.01157240f, 0.06713132f, 0.10751112f, -0.07013583f, 0.13499512f, 0.02949502f, -0.01461791f, -0.03143041f, 
    0.17699726f, 0.13320363f, 0.00544715f, -0.20675653f, 0.00780458f, 0.05454271f, -0.03466951f, 0.11649956f, 
    0.17520040f, -0.01309509f, 0.04789174f, 0.06743251f, 0.15867199f, -0.12289784f, 0.07214157f, 0.13858764f, 
    0.03221647f, -0.01984436f, 0.03342959f, 0.03963951f, -0.12890014f, 0.09233194f, -0.04597297f, 0.11548496f, 
    -0.12765338f, 0.04373359f, 0.08374259f, -0.36463314f, 0.00813028f, -0.03474132f, 0.05803048f, -0.04163754f, 
    0.13727228f, -0.06663335f, -0.13540913f, -0.19314550f, 0.05034469f, -0.07129255f, -0.06920235f, 0.30576959f, 
    -0.11845595f, 0.07282493f, -0.00989119f, 0.03800745f, 0.01135411f, -0.00055866f, 0.10460970f, -0.16459422f, 
    0.58659947f, 0.19136982f, 0.02103075f, 0.18833002f, -0.07105725f, -0.06167884f, -0.07846379f, 0.05391508f, 
    -0.05313069f, -0.04276981f, 0.07710844f, 0.02648779f, 0.00473392f, -0.15970792f, 0.15379260f, -0.09372634f, 
    0.08309902f, 0.03745581f, 0.01543663f, 0.08594482f, -0.02536291f, 0.07149770f, 0.02914348f, 0.04039574f, 
    -0.07093953f, 0.07322703f, 0.08110467f, 0.32947499f, -0.00948359f, 0.06018920f, -0.11407147f, -0.01567952f, 
    0.14325286f, -0.07514159f, -0.12228274f, -0.00695990f, -0.07877501f, -0.17016435f, -0.15183383f, -0.06083378f, 
    -0.05894199f, -0.03040336f, -0.05663777f, -0.13109744f, 0.00396932f, 0.01137144f, -0.01629093f, -0.04794438f, 
    0.22197013f, 0.05306159f, -0.10200336f, 0.34906605f, -0.02060301f, 0.02184625f, -0.05835010f, -0.01206059f, 
    -0.16717447f, 0.02076834f, 0.02148293f, 0.04060857f, 0.19093989f, 0.02178689f, 0.09923977f, 0.26108909f, 
    0.04004859f, -0.04465463f, 0.01190751f, 0.00022374f, 0.05864975f, 0.00591216f, -0.00559244f, 0.00382613f, 
    0.11357818f, -0.13973570f, 0.02633077f, 0.51889122f, -0.09233700f, 0.04344747f, -0.03380547f, -0.01703150f, 
    -0.10860386f, 0.07869966f, -0.03838000f, 0.00348900f, 0.23335901f, 0.15065463f, -0.15059693f, -0.08544449f, 
    -0.10022376f, 0.07573999f, 0.06986238f, 0.10298765f, -0.01470698f, -0.08504640f, -0.12929785f, -0.09446394f, 
    -0.09734221f, 0.13172755f, 0.05547245f, 0.00934401f, -0.03136279f, 0.01094035f, 0.09938873f, 0.02566098f, 
    0.14225213f, -0.01570533f, 0.07321636f, -0.02431352f, -0.24970180f, -0.42445114f, -0.10340790f, -0.25823337f, 
    0.09191550f, -0.06469689f, 0.06002984f, -0.02132261f, -0.08403381f, -0.02400819f, 0.03964637f, 0.07798561f, 
    0.28243211f, -0.19432469f, -0.12543303f, 0.32396504f, -0.01863729f, 0.06915964f, 0.06801705f, 0.04454358f, 
    0.03195558f, -0.01410839f, 0.03396483f, 0.07377626f, 0.37244907f, -0.05491201f, 0.11059890f, 0.05916949f, 
    0.10266958f, -0.01787531f, -0.08192562f, 0.06493220f, 0.08629236f, 0.11577449f, 0.05514301f, -0.07499976f, 
    -0.23134789f, -0.11735532f, 0.34757861f, -0.08821273f, -0.08268617f, -0.04031668f, 0.05762656f, -0.01181589f, 
    -0.00215226f, -0.02375574f, 0.00245644f, 0.04152611f, 0.18553756f, 0.05505519f, 0.02123649f, 0.01549545f, 
    -0.21332224f, -0.03745857f, -0.02793271f, 0.10195334f, -0.08684041f, -0.13691966f, 0.03095976f, 0.11767809f, 
    0.32001385f, 0.05309622f, 0.12783045f, 0.03304671f, -0.00778430f, 0.06268436f, -0.05719228f, 0.09601526f, 
    -0.11443280f, -0.02591550f, 0.03145807f, 0.04958943f, 0.32915232f, -0.24848799f, -0.06473130f, 0.25064886f, 
    -0.07278842f, 0.12473062f, -0.13668722f, 0.04614440f, -0.05521357f, 0.04399356f, 0.10352695f, 0.13182001f, 
    0.37843612f, 0.07636009f, 0.24149027f, 0.10308491f, -0.04032522f, -0.07147914f, 0.05635027f, 0.15209760f, 
    -0.08462794f, -0.06340855f, -0.04551060f, 0.09336989f, 0.01949773f, -0.02672704f, 0.28889951f, 0.04670348f, 
    -0.04478349f, -0.08774839f, 0.01966659f, 0.11625821f, 0.02718611f, 0.08754610f, -0.04193190f, 0.06922571f, 
    0.32311016f, 0.15457186f, -0.10224469f, -0.06590130f, -0.00147899f, 0.02347805f, 0.00310968f, -0.02976181f, 
    0.11605410f, -0.05134015f, -0.05671163f, -0.09675908f, 0.14611965f, 0.05395069f, 0.16982409f, -0.05131396f, 
    -0.10304617f, 0.03087446f, -0.05083095f, 0.07661197f, 0.08158296f, 0.03229386f, 0.01533874f, -0.05177785f, 
    -0.07129534f, 0.14053635f, -0.08595030f, -0.25032154f, 0.17744720f, 0.06984201f, -0.02247306f, -0.01599122f, 
    0.07543433f, -0.01873741f, 0.05057542f, 0.01306244f, -0.04051840f, 0.00112644f, 0.19722453f, -0.18934447f, 
    -0.11324684f, 0.01421569f, 0.13972071f, 0.06639212f, 0.12115431f, -0.07251803f, 0.03212096f, 0.00035249f, 
    -0.11851289f, 0.08629186f, -0.00090799f, -0.01093988f, -0.05518910f, -0.03543547f, 0.13529348f, -0.00619541f, 
    0.06569385f, -0.05547170f, 0.09580572f, 0.05322208f, 0.11535584f, 0.13122551f, -0.11829489f, 0.21677648f, 
    -0.01201849f, 0.02174311f, -0.06723188f, 0.00739961f, 0.03559991f, 0.09631762f, -0.04794989f, -0.05138681f, 
    0.11857270f, 0.10822716f, -0.09915472f, 0.07237071f, 0.11127395f, 0.04466746f, 0.05952920f, 0.06633224f, 
    -0.03871312f, 0.05917148f, -0.12063472f, -0.02783357f, 0.07048771f, -0.17490989f, -0.01343852f, -0.12113754f, 
    0.09690557f, 0.06751609f, 0.01799963f, 0.01161848f, 0.03685850f, -0.01390689f, 0.23251712f, -0.00179262f, 
    0.36837628f, -0.09533938f, -0.30593672f, 0.02635924f, -0.03552898f, -0.07467336f, 0.05473332f, -0.09664895f, 
    0.01472611f, 0.10921470f, 0.00591009f, 0.01539865f, -0.12089037f, -0.10115789f, 0.18498485f, 0.09156992f, 
    0.03595411f, -0.03251737f, 0.07131315f, 0.19533105f, -0.01939586f, 0.00058816f, -0.16667533f, -0.03701499f, 
    -0.07365116f, -0.25444761f, 0.07465576f, 0.03075635f, 0.06860124f, -0.02921163f, -0.11483097f, 0.09004831f, 
    0.05145315f, -0.02060954f, 0.13381210f, -0.06763775f, 0.27648383f, 0.13217871f, 0.04881481f, -0.00394373f, 
    -0.09813985f, -0.02628418f, -0.06412581f, 0.15479197f, -0.11000890f, 0.09621224f, 0.07299820f, 0.04073225f, 
    -0.10812781f, -0.17703728f, 0.06576751f, 0.06498867f, -0.11069407f, -0.09112443f, 0.16499425f, 0.21545374f, 
    0.07917143f, 0.01145800f, -0.14474179f, -0.03027030f, 0.16036618f, 0.13807046f, -0.06114002f, -0.05931223f, 
    -0.09289123f, 0.14215124f, 0.00948830f, 0.03455547f, 0.21881388f, 0.04928041f, -0.01894568f, -0.02539328f, 
    0.10296735f, -0.04295550f, -0.16170071f, 0.21390459f, 0.03517292f, 0.06795255f, -0.06482593f, 0.12069036f, 
    -0.08545390f, 0.00334499f, 0.10301120f, -0.08988995f, -0.03527180f, 0.03877604f, -0.01482185f, 0.23728061f, 
    -0.06846922f, 0.01283972f, 0.05189080f, 0.07192641f, -0.02173793f, -0.15455586f, -0.06484877f, -0.08539075f, 
    0.25537440f, 0.27371702f, -0.18090965f, 0.02729234f, 0.06652537f, -0.05101079f, 0.09088332f, 0.07481804f, 
    0.05927896f, -0.02886218f, -0.12342364f, -0.09068540f, 0.07901186f, 0.19517635f, -0.03674988f, -0.08778787f, 
    0.08010439f, 0.12390333f, -0.00587576f, 0.07053725f, 0.12270142f, 0.06104903f, -0.07486243f, -0.08359273f, 
    -0.04140921f, 0.09513521f, 0.23821607f, -0.07748760f, -0.10310846f, 0.07330626f, -0.01805791f, -0.05953356f, 
    -0.02511494f, 0.00075848f, -0.15173827f, -0.07009886f, -0.01791111f, 0.44673780f, -0.11171239f, -0.18542661f, 
    0.09336577f, -0.10217549f, -0.02882584f, 0.05251339f, -0.02140944f, 0.11246164f, -0.00334919f, -0.04660038f, 
    -0.02524780f, 0.16999382f, -0.09661433f, 0.06330254f, -0.09062690f, -0.09038759f, -0.00247172f, 0.03222472f, 
    0.04477017f, 0.02455753f, -0.13360310f, 0.03327239f, 0.39687669f, -0.03287459f, 0.01686618f, 0.02550458f, 
    0.08243898f, 0.08606513f, 0.02812406f, -0.11921560f, 0.00895829f, -0.08607731f, -0.02942478f, -0.03029322f, 
    0.18327568f, 0.16546723f, 0.02019476f, 0.28206399f, 0.03821730f, 0.05029232f, -0.05480173f, 0.09048129f, 
    -0.10134950f, 0.06027667f, 0.22439638f, 0.03569954f, 0.18869856f, 0.01860016f, -0.13408791f, 0.00219380f, 
    -0.08789447f, -0.10221069f, 0.10742658f, 0.05041432f, -0.15091975f, 0.11450509f, -0.01770358f, -0.03064088f, 
    -0.29293400f, 0.00826911f, -0.19229022f, -0.03672430f, -0.02296292f, 0.13485375f, 0.06310925f, -0.02283956f, 
    0.04104305f, -0.03858216f, 0.05412586f, 0.11294820f, -0.15774511f, 0.27119443f, -0.00602131f, -0.18053651f, 
    -0.06068445f, -0.08108740f, -0.02293569f, 0.05840292f, 0.00379792f, -0.08786738f, -0.00116936f, 0.04210432f, 
    0.14699268f, -0.13180554f, 0.11172581f, 0.19126281f, -0.05913560f, 0.08448802f, 0.10538592f, 0.02451551f, 
    -0.11918107f, 0.13684377f, -0.00496398f, -0.15810180f, -0.25056362f, 0.05311766f, -0.01486835f, 0.07496861f, 
    0.05189788f, 0.06682742f, -0.02408586f, 0.07992169f, -0.01975309f, 0.06079597f, 0.00549212f, -0.00524155f, 
    -0.31959081f, 0.09822729f, 0.12151627f, 0.06020122f, 0.06214844f, 0.05159023f, -0.00640672f, 0.11116536f, 
    -0.00504857f, 0.02645490f, -0.06052945f, -0.07615767f, -0.10263741f, 0.30513525f, -0.11571216f, -0.00537060f, 
    0.08656049f, 0.10418077f, -0.08227755f, 0.11632884f, -0.11582872f, 0.06553292f, -0.08180379f, 0.28920603f, 
    -0.13002674f, -0.01275528f, 0.13362308f, 0.09094787f, -0.06429810f, -0.04459831f, 0.15412866f, 0.07868013f, 
    0.10760417f, 0.13332377f, -0.02593797f, 0.08773614f, -0.04870779f, 0.13867290f, 0.13722745f, 0.13998267f, 
    0.10196391f, 0.05442345f, 0.08070677f, 0.04809838f, 0.01988336f, 0.08030522f, 0.02080998f, 0.11799835f, 
    0.16123572f, -0.23979320f, -0.14677501f, 0.08178615f, 0.06002858f, -0.14992844f, 0.02481851f, 0.00619714f, 
    -0.11663444f, -0.21381426f, -0.02752513f, -0.09577399f, -0.03051816f, 0.21995655f, -0.14765745f, -0.05911534f, 
    0.00164534f, 0.02361471f, -0.08505356f, -0.00976510f, -0.01578066f, 0.08830068f, -0.02262281f, 0.14052147f, 
    -0.21262310f, -0.35731998f, 0.25573435f, 0.03292136f, -0.13020653f, -0.05345951f, -0.06359566f, -0.07367624f, 
    -0.05256390f, 0.01165543f, 0.05930245f, -0.01406760f, -0.13373150f, -0.04994715f, 0.30084479f, 0.17327559f, 
    -0.00444300f, -0.05464755f, 0.11127979f, 0.06941001f, -0.04861613f, -0.01114962f, 0.13100870f, 0.00961993f, 
    0.28165978f, 0.10998715f, -0.12880206f, -0.05931463f, -0.03279020f, 0.12855375f, -0.05872668f, -0.12312102f, 
    -0.00176699f, 0.06110457f, -0.05278008f, -0.04585014f, 0.21229248f, 0.02358492f, 0.06586432f, 0.14859883f, 
    -0.06602577f, 0.07016056f, 0.11009147f, 0.03458790f, -0.00267029f, 0.01265268f, -0.06267279f, 0.10333142f, 
    0.08675801f, -0.06717400f, 0.16816783f, -0.02563462f, -0.09840486f, -0.02271733f, -0.00634006f, 0.04632834f, 
    -0.00610899f, -0.04764883f, 0.06261417f, -0.11798259f, 0.06204100f, -0.29098552f, 0.16755724f, -0.13721019f, 
    -0.13742006f, 0.01721827f, 0.01767510f, 0.02538366f, -0.08586236f, -0.00131557f, 0.16304269f, -0.07125854f, 
    0.01428976f, 0.00438634f, -0.22874732f, -0.06160045f, 0.03464494f, -0.01794448f, -0.21830228f, 0.08928980f, 
    -0.09192366f, 0.18811779f, 0.11573548f, 0.10684752f, -0.34358552f, -0.02836137f, 0.11147581f, -0.20629846f, 
    0.08502309f, 0.01148113f, -0.07638090f, -0.03585672f, 0.08387184f, -0.02448080f, 0.17690340f, 0.06820778f, 
    0.24860092f, 0.05265227f, 0.00802844f, -0.19490787f, 0.01307248f, 0.06258430f, -0.02259682f, -0.10892268f, 
    -0.03521337f, -0.04666650f, -0.05978646f, 0.02193202f, -0.33136156f, -0.29964808f, 0.14877529f, -0.13776189f, 
    0.12536128f, 0.03500943f, 0.09207086f, -0.03711933f, 0.21169458f, -0.08031313f, -0.02544187f, 0.10560516f, 
    0.35996130f, 0.05280584f, -0.18862565f, 0.02253880f, 0.15556100f, 0.10946328f, -0.12490419f, 0.06206055f, 
    -0.17329119f, 0.02758616f, 0.16966258f, -0.02096126f, -0.34009236f, 0.00464150f, -0.19869472f, 0.15901715f, 
    0.19765075f, -0.13952632f, -0.00779666f, -0.13136858f, -0.03009537f, -0.13491949f, -0.19723643f, 0.04172199f, 
    0.23494464f, -0.13020872f, -0.07398009f, 0.12843186f, 0.00360132f, 0.08386205f, 0.00185715f, 0.10533974f, 
    0.07225323f, 0.00589794f, -0.16403961f, 0.09222723f, -0.11350502f, -0.11347242f, 0.10903765f, 0.15169279f, 
    -0.03864898f, -0.08056349f, -0.10102277f, -0.05334293f, 0.14618418f, 0.11073907f, 0.24274521f, 0.21321711f, 
    -0.36955371f, 0.02347378f, 0.10884728f, 0.16089462f, 0.04457228f, -0.04342334f, -0.11266360f, -0.03712524f, 
    -0.14052138f, 0.17126721f, 0.09922045f, -0.03159281f, -0.29473922f, 0.07865775f, 0.04191536f, 0.06583096f, 
    -0.06018713f, -0.03311991f, -0.00067800f, -0.09801995f, -0.18732964f, -0.28942180f, 0.12057253f, -0.01181197f, 
    -0.25398812f, -0.00911282f, 0.02434242f, -0.16088159f, 0.00871515f, -0.00070557f, 0.15272959f, 0.01474504f, 
    0.07690884f, 0.01121531f, 0.06217765f, 0.05220428f, -0.29550970f, -0.07453555f, 0.02058578f, 0.00256002f, 
    -0.01342526f, 0.12410597f, -0.04232056f, 0.01747380f, 0.26865342f, 0.04915877f, 0.02898785f, 0.07261187f, 
    -0.00810505f, -0.05704997f, -0.05633623f, -0.08967473f, 0.10636196f, -0.02553587f, 0.02689888f, 0.05265744f, 
    0.02859512f, 0.05475294f, 0.06524333f, 0.03559181f, -0.07659382f, -0.13956487f, -0.08290210f, -0.13200556f, 
    0.04251557f, -0.13293728f, 0.05825581f, 0.02666346f, 0.08085299f, 0.13497975f, 0.11769572f, 0.13128828f, 
    -0.06964164f, 0.03130296f, 0.16365670f, 0.09120988f, 0.01484039f, 0.14377321f, 0.20360212f, 0.00003055f, 
    0.00901364f, -0.10271928f, -0.27040908f, 0.00599236f, -0.37555459f, 0.03419418f, 0.44424662f, -0.15509316f, 
    -0.02840160f, 0.05684479f, -0.04679153f, 0.12083001f, 0.11998738f, -0.14209409f, 0.10728024f, -0.10537331f, 
    -0.07559659f, 0.13116571f, -0.08455759f, 0.10253203f, 0.07643231f, -0.15735553f, -0.06420671f, 0.17187229f, 
    0.12135436f, 0.01348383f, -0.04070913f, 0.09132610f, -0.01385713f, -0.19827925f, 0.32457897f, 0.12151832f, 
    0.02326773f, -0.13283108f, 0.10832196f, -0.09110624f, 0.10677315f, 0.01456947f, -0.02864506f, -0.03014867f, 
    -0.18870367f, -0.05977352f, 0.06353664f, 0.04863471f, 0.13103479f, 0.07548898f, 0.04212444f, 0.01542478f, 
    0.12523188f, -0.05453781f, 0.18664959f, -0.00471345f, 0.25685048f, 0.13920003f, -0.06968723f, 0.11829520f, 
    -0.04989097f, 0.03119568f, 0.05178021f, -0.09846625f, 0.10302567f, -0.01710237f, 0.02919351f, -0.06515049f, 
    0.20535602f, -0.06770805f, 0.05903415f, 0.06933330f, -0.09049781f, -0.05556355f, 0.07224029f, 0.11605112f, 
    0.14222904f, -0.00253784f, 0.05737156f, 0.08438044f, -0.20513226f, -0.21746558f, 0.07402177f, 0.07321288f, 
    0.08632210f, -0.20725138f, -0.07066771f, 0.07374138f, 0.19732372f, 0.06129412f, -0.01794283f, -0.05562273f, 
    -0.13808374f, -0.03142455f, -0.11381867f, 0.02877003f, -0.05134697f, -0.04295114f, 0.02104241f, 0.11462032f, 
    -0.05247710f, -0.03126352f, 0.00156550f, -0.19358018f, 0.34306318f, 0.11027821f, 0.07642496f, -0.16886842f, 
    0.00452250f, -0.05263628f, 0.05265461f, 0.08950622f, -0.00630562f, -0.06549337f, -0.16487437f, -0.19237131f, 
    -0.21117450f, 0.17040776f, 0.18170972f, 0.05356749f, 0.06793441f, 0.07893350f, 0.05462934f, 0.06106795f, 
    0.18971618f, 0.18546042f, -0.08383050f, 0.03862425f, 0.17354646f, 0.05961578f, -0.04922593f, -0.05414916f, 
    -0.03612468f, -0.00453139f, 0.18417329f, -0.00229946f, 0.13583334f, -0.00536301f, -0.04075740f, -0.17834602f, 
    0.37316188f, 0.56768388f, 0.06716885f, -0.07640707f, 0.06188350f, 0.00947876f, 0.00553445f, 0.02448439f, 
    0.04550816f, 0.03044398f, 0.06586211f, 0.06177197f, -0.10753920f, -0.18859506f, 0.20261385f, -0.17938714f, 
    0.03027489f, -0.12751101f, 0.14663433f, -0.15412918f, 0.01691839f, -0.03589217f, -0.08724641f, 0.07166146f, 
    -0.13248967f, -0.13749649f, -0.01306560f, 0.00339692f, 0.01586927f, 0.08677827f, 0.06626607f, 0.20507640f, 
    -0.00109038f, -0.07378121f, 0.01630215f, -0.06469466f, 0.15393259f, 0.00055009f, -0.11229627f, -0.03733720f, 
    0.06253310f, -0.09281429f, -0.02397596f, -0.05685958f, 0.01468440f, -0.02228122f, 0.08453014f, -0.05262510f, 
    -0.41305053f, 0.07799530f, 0.14076430f, -0.00586878f, 0.05512397f, 0.08363958f, -0.06296168f, -0.07410714f, 
    -0.10181682f, 0.05123151f, 0.20389098f, 0.25862846f, -0.40362567f, 0.06247738f, 0.28570947f, -0.02093519f, 
    0.04346035f, -0.16123012f, 0.15283628f, -0.02932568f, 0.07289675f, 0.06172220f, -0.06532291f, 0.19327682f, 
    -0.12876797f, 0.11712348f, 0.14746584f, 0.03341335f, 0.13633569f, 0.03811599f, -0.04754943f, 0.10223063f, 
    0.06270549f, -0.00748935f, 0.22848310f, 0.06595296f, 0.03275557f, 0.01112048f, -0.00500806f, -0.11546605f, 
    -0.06009043f, -0.01880448f, 0.00098118f, -0.12566319f, 0.05063569f, -0.07796893f, 0.20857787f, 0.15411566f, 
    -0.18312386f, 0.28455171f, -0.08946858f, -0.06938565f, 0.04908647f, -0.00929455f, 0.10616735f, -0.05936969f, 
    -0.08450289f, 0.11054283f, -0.17160603f, 0.01733593f, 0.35323834f, -0.20374049f, 0.01977340f, 0.06987876f, 
    0.02772589f, 0.00246300f, 0.02841050f, -0.01050951f, 0.18679018f, -0.00881716f, 0.02625979f, -0.10215231f, 
    -0.22707751f, 0.08975597f, -0.04559180f, 0.01604252f, -0.00833008f, 0.05291986f, -0.12798956f, 0.06520740f, 
    -0.07810575f, 0.11906612f, 0.09533001f, 0.17776680f, 0.20111023f, -0.04641575f, 0.14145966f, 0.24921590f, 
    0.08244234f, -0.16161850f, 0.01558423f, -0.07083069f, -0.01221498f, -0.05446022f, -0.14426097f, 0.12694415f, 
    -0.16917300f, 0.06114066f, -0.02495198f, -0.02993445f, 0.04583215f, -0.06556179f, 0.00075637f, 0.03859894f, 
    0.08612465f, 0.00637419f, 0.02875977f, 0.07490081f, -0.06345899f, -0.18676591f, 0.02595979f, 0.11107656f, 
    -0.00684610f, -0.06994620f, -0.03080995f, -0.03948826f, 0.14614281f, 0.17523083f, 0.20590529f, 0.09663133f, 
    0.10537817f, -0.29090577f, 0.11616435f, 0.31219065f, -0.02781911f, 0.07454093f, -0.00512802f, -0.02885382f, 
    -0.00296454f, 0.04511517f, 0.07897206f, 0.12247273f, -0.13604546f, -0.21785076f, -0.15245232f, -0.04282809f, 
    -0.06437740f, 0.00227519f, 0.01704701f, 0.07112129f, -0.07976028f, 0.00011713f, -0.01162736f, 0.00232593f, 
    0.25717148f, -0.08498833f, -0.13809174f, 0.29320613f, 0.01716795f, -0.01658597f, 0.08921205f, 0.03303505f, 
    0.03435624f, -0.06832442f, 0.12228917f, 0.03093466f, -0.04940405f, -0.17357542f, 0.41400388f, 0.42196438f, 
    -0.02814869f, 0.18713865f, 0.02633131f, 0.06169416f, 0.10459973f, -0.04457260f, -0.03057829f, 0.06836832f, 
    0.05517560f, -0.13395929f, 0.18775299f, 0.20858562f, 0.12386253f, 0.08357913f, 0.07364275f, -0.02861084f, 
    0.05295765f, -0.02699426f, 0.12386185f, 0.04331029f, -0.39162403f, 0.09438810f, -0.01745690f, -0.17707279f, 
    -0.05067877f, -0.16169961f, -0.06334449f, 0.08410341f, 0.28138357f, 0.09832028f, 0.10643548f, 0.14215928f, 
    -0.06463947f, -0.18444435f, -0.07417402f, -0.20676512f, 0.12716222f, -0.03465611f, 0.10310528f, -0.06821233f, 
    0.09766667f, -0.02808304f, -0.25156826f, -0.04233028f, -0.10446072f, -0.10405350f, 0.22962184f, -0.14353418f, 
    -0.01109327f, 0.02917317f, -0.04008828f, 0.02099399f, 0.14480199f, -0.17842329f, 0.10391586f, -0.00365261f, 
    0.13836412f, 0.28502727f, -0.02299678f, 0.02313415f, 0.11513522f, -0.14661963f, -0.01852688f, 0.04292905f, 
    -0.01207908f, 0.09761731f, 0.03834253f, -0.05124762f, 0.35659233f, -0.28426564f, 0.16108426f, 0.22385256f, 
    0.05748625f, 0.00380483f, 0.08113492f, -0.04666548f, -0.01151943f, 0.01799208f, -0.10028384f, 0.00624507f, 
    -0.17497142f, -0.04556888f, 0.07985767f, -0.03427422f, 0.07595434f, -0.00820875f, 0.06282219f, 0.17136617f, 
    0.13044719f, -0.06270397f, 0.14761566f, 0.09818685f, -0.08291982f, 0.09264710f, -0.07426396f, -0.07305762f, 
    0.05804593f, 0.00131361f, 0.08984565f, -0.01519825f, -0.01442246f, -0.10446654f, 0.02724694f, 0.02796170f, 
    0.05209312f, -0.02726704f, -0.19164082f, -0.04814566f, 0.02755442f, 0.08741463f, -0.05616926f, 0.00019923f, 
    0.01671301f, -0.01636953f, 0.01368763f, 0.14076377f, 0.16583434f, -0.04536529f, -0.00434718f, 0.19171605f, 
    -0.09430818f, -0.00600582f, 0.13653961f, 0.03787566f, 0.17823023f, 0.00345427f, 0.10879778f, -0.08872602f, 
    -0.32679552f, 0.14947441f, -0.17568251f, -0.10603552f, 0.09270713f, 0.08071804f, -0.13655615f, -0.14552972f, 
    0.08193389f, 0.03842738f, 0.18149301f, -0.09419583f, -0.26569611f, -0.05878915f, -0.05429970f, -0.14661703f, 
    0.06021280f, -0.14224118f, -0.05260929f, 0.08177821f, 0.01981064f, 0.02850622f, -0.10860230f, -0.12873499f, 
    -0.01219807f, 0.15385102f, 0.08817416f, 0.00857707f, 0.02593981f, 0.04733202f, -0.00056820f, 0.03960904f, 
    0.13768123f, 0.12626779f, -0.01157766f, 0.01910260f, -0.17000429f, -0.05575727f, 0.08755217f, -0.01345018f, 
    0.01089137f, -0.00678087f, 0.16051067f, 0.14002044f, -0.02150811f, -0.06703436f, -0.01373837f, -0.14736460f, 
    -0.27113867f, 0.21214059f, 0.05456402f, 0.07737733f, -0.02284344f, 0.04780860f, 0.06875841f, -0.01012081f, 
    -0.00596364f, 0.02548248f, -0.03600164f, 0.12233753f, 0.28493124f, -0.00949149f, -0.16073160f, -0.13229039f, 
    -0.00631643f, 0.08537775f, 0.02401565f, 0.00068251f, 0.09820687f, 0.08320359f, -0.03628617f, 0.10923868f, 
    -0.13257404f, -0.05848781f, 0.05291181f, 0.13169388f, -0.05652649f, 0.02844423f, -0.03970597f, -0.00500254f, 
    -0.01408716f, -0.00165707f, -0.03696193f, 0.00853329f, -0.00113727f, 0.21859437f, 0.12545006f, 0.15127017f, 
    -0.05110696f, -0.12212078f, -0.03678044f, 0.06050688f, 0.12442704f, 0.08104125f, 0.01999899f, -0.20598032f, 
    0.18631619f, -0.01658195f, -0.01033513f, 0.21356082f, 0.02164825f, 0.08839995f, -0.00062746f, -0.04475929f, 
    -0.01083761f, 0.01609518f, 0.11539950f, 0.06714384f, 0.30888867f, 0.08791288f, -0.09855079f, -0.06180020f, 
    0.05376242f, -0.06751475f, -0.06340825f, -0.07815336f, 0.02905216f, 0.00090532f, -0.17180802f, 0.15268864f, 
    -0.00592996f, 0.01305042f, 0.00523901f, -0.01223398f, 0.00371720f, -0.00283673f, -0.00229021f, -0.03002468f, 
    -0.02667549f, 0.04279536f, -0.04488262f, 0.01042552f, -0.00182259f, 0.01544500f, 0.03008386f, -0.03673328f, 
    -0.00921443f, -0.01829782f, 0.00294784f, 0.03182526f, 0.00377303f, 0.01054574f, 0.03951326f, -0.03918123f, 
    -0.02692686f, -0.00600755f, 0.03546227f, 0.03423360f, -0.02934254f, -0.03182691f, -0.05585341f, -0.04745194f, 
    -0.01829139f, 0.03282389f, 0.03871544f, -0.00308712f, -0.01048776f, -0.04564821f, -0.00313884f, 0.00643207f, 
    0.02193141f, 0.02329197f, -0.04792469f, -0.01420954f, -0.04217768f, 0.03063122f, -0.01965721f, -0.01088187f, 
    0.03021098f, 0.01027150f, -0.03928104f, -0.04424349f, -0.02290764f, -0.03361025f, 0.00914877f, -0.02827922f, 
    0.01846674f, -0.00206018f, -0.03533614f, 0.00628611f, -0.03142965f, -0.01901229f, 0.03173532f, -0.05054032f, 
    0.02397981f, 0.00557791f, 0.01274271f, -0.00111116f, -0.05108021f, -0.00695199f, 0.02009800f, 0.03799241f, 
    -0.01639813f, 0.03502435f, -0.03961933f, -0.03112060f, -0.02630131f, -0.02883217f, 0.02982936f, -0.04546667f, 
    0.00925861f, 0.01151100f, -0.05106459f, 0.00173986f, -0.05845381f, -0.03596400f, -0.03985452f, -0.01150840f, 
    -0.03356717f, -0.03022352f, 0.04043497f, 0.00959302f, 0.01535488f, -0.03827811f, -0.01979328f, -0.04778079f, 
    0.03820389f, 0.02231355f, -0.01663603f, -0.06272151f, -0.05652231f, 0.04029277f, -0.01707893f, -0.05095256f, 
    -0.04723428f, -0.05069463f, -0.02437496f, 0.02074823f, 0.02355528f, 0.01264800f, -0.02790740f, -0.05191484f, 
    -0.00234829f, 0.00913625f, -0.03308612f, -0.02660625f, 0.00168812f, -0.03514399f, -0.04581207f, 0.05179800f, 
    -0.02752641f, 0.03630783f, -0.01954352f, -0.05397474f, 0.00388756f, 0.02884814f, 0.01749576f, -0.00108224f, 
    -0.01324263f, -0.04346105f, -0.01580868f, 0.02504102f, 0.03995994f, 0.02599072f, 0.01902360f, -0.00317863f, 
    0.04114789f, 0.02089318f, -0.02254982f, 0.00062385f, -0.01939647f, -0.04052920f, 0.00133868f, -0.05000420f, 
    -0.02228489f, -0.02420262f, 0.04479670f, -0.02163679f, 0.00027930f, 0.01485779f, 0.02675389f, 0.04303842f, 
    0.01134434f, -0.02082210f, 0.01405353f, -0.04375343f, 0.04555696f, 0.03469863f, 0.01208609f, -0.03491259f, 
    0.04197504f, -0.02834959f, -0.03846562f, -0.02530441f, 0.05110863f, -0.00380872f, -0.02413986f, -0.00622264f, 
    0.03905803f, 0.01930300f, 0.01323206f, -0.02249215f, -0.04091266f, 0.00471370f, -0.03900668f, 0.02363738f, 
    -0.04146047f, 0.02982652f, -0.05576500f, -0.02987595f, 0.04380114f, -0.02896630f, -0.03855524f, -0.04121976f, 
    -0.01569752f, 0.03268277f, -0.02734443f, 0.00283651f, 0.00843377f, 0.02784477f, 0.03310275f, -0.02384196f, 
    0.03235998f, 0.02251731f, -0.01727677f, 0.01873213f, 0.00183359f, -0.04443301f, -0.04991913f, -0.04134002f, 
    0.04016307f, 0.03128764f, -0.04393008f, -0.05823227f, -0.00657739f, -0.01767811f, -0.05899812f, -0.02269214f, 
    0.00312677f, -0.02934417f, -0.05184514f, 0.01444951f, 0.04241309f, 0.02446522f, 0.03348569f, -0.03984199f, 
    0.01442502f, -0.03889094f, -0.05453175f, -0.04244009f, 0.01938873f, -0.06099281f, -0.01129665f, -0.01028254f, 
    -0.00221133f, -0.02261885f, -0.01804686f, -0.03959386f, 0.01149981f, -0.05343571f, 0.02330310f, -0.01764239f, 
    -0.00083893f, 0.03140112f, -0.03520042f, 0.03818068f, -0.00835671f, -0.02384617f, 0.04076590f, -0.05199938f, 
    0.03485597f, -0.01600527f, -0.02754511f, -0.00855833f, -0.00558046f, 0.04803718f, -0.01658431f, -0.00562331f, 
    0.00196914f, 0.04172462f, -0.03944682f, -0.04958569f, 0.04402561f, -0.03376681f, -0.02989754f, -0.02951492f, 
    0.03781606f, 0.03808777f, -0.02860842f, -0.03183756f, 0.04003106f, -0.03211571f, 0.02380276f, 0.03264549f, 
    0.01655901f, -0.01922833f, -0.01601522f, 0.03890171f, -0.02696677f, -0.00028001f, 0.00050531f, -0.04438606f, 
    -0.00257219f, -0.03191258f, 0.03543622f, -0.02138830f, -0.01925504f, -0.02997804f, 0.01316897f, 0.01759367f, 
    -0.04030677f, -0.02647608f, -0.02520151f, -0.01238714f, -0.05212323f, -0.04105945f, -0.05426777f, 0.04349092f, 
    -0.01594654f, -0.01614349f, -0.04352067f, -0.03527888f, -0.03155865f, -0.03658234f, 0.00158283f, 0.04331237f, 
    -0.01512649f, 0.02404770f, -0.06249236f, -0.04251665f, -0.02275732f, -0.03887105f, -0.02084993f, 0.03210847f, 
    0.01632900f, -0.02418756f, -0.02624533f, -0.01232284f, -0.04354264f, 0.00828690f, 0.03780845f, -0.03484178f, 
    -0.00763078f, 0.00678361f, 0.00130595f, -0.05053725f, 0.03074188f, 0.03358224f, 0.02527837f, -0.02342685f, 
    -0.05242606f, 0.03850236f, -0.00475737f, 0.04369375f, -0.04772422f, -0.01202217f, -0.00165295f, -0.04466357f, 
    0.02962136f, -0.01842339f, 0.02384719f, -0.03251717f, -0.03168670f, 0.04419478f, -0.00502261f, 0.02447719f, 
    0.01280160f, -0.02237471f, 0.02125793f, 0.02259247f, -0.01896714f, 0.03217803f, 0.00535265f, -0.00162481f, 
    -0.02397347f, -0.00594442f, -0.03494670f, 0.04708969f, -0.00016013f, -0.02990461f, -0.00946522f, -0.05743597f, 
    -0.02927343f, 0.01792775f, 0.01710723f, -0.03818830f, 0.01336839f, -0.05366607f, 0.01145454f, -0.00710605f, 
    0.01138530f, 0.02595625f, -0.01149170f, -0.01928454f, -0.05880170f, 0.03441822f, -0.01214385f, 0.00194483f, 
    0.03993428f, 0.01960220f, -0.03110875f, -0.04163396f, 0.03596498f, 0.01074379f, 0.01446840f, -0.00423167f, 
    -0.01579866f, -0.01001159f, -0.00656418f, 0.02851777f, 0.03215592f, -0.02461640f, 0.00746127f, -0.02379773f, 
    -0.02267476f, -0.09138316f, 0.15822421f, 0.00968399f, -0.01738448f, -0.00193921f, 0.03932335f, 0.02729142f, 
    -0.04620774f, -0.07458945f, -0.02676045f, 0.02108691f, 0.10351079f, -0.13600373f, -0.23417158f, 0.42203820f, 
    0.09195887f, 0.07080400f, -0.08298960f, 0.01488837f, -0.02113270f, 0.02892957f, -0.01542773f, -0.00084757f, 
    -0.12473010f, -0.00064329f, -0.10923993f, 0.13752581f, 0.11104784f, -0.14351144f, 0.09810846f, -0.04828270f, 
    0.07269704f, 0.09969809f, 0.11745463f, 0.03159779f, -0.26473826f, 0.15723100f, 0.05445232f, 0.02941192f, 
    0.07657202f, 0.06250023f, 0.01241751f, -0.05210542f, 0.05596265f, 0.10311259f, 0.03863449f, 0.04122653f, 
    0.17588656f, 0.04038498f, -0.05823288f, 0.03098099f, 0.09980646f, -0.07996592f, -0.01118160f, 0.01651947f, 
    0.07034171f, -0.09116255f, 0.09700783f, 0.20403662f, -0.12150642f, 0.00530216f, 0.01658265f, -0.33140862f, 
    -0.02353651f, 0.05360862f, -0.05657890f, 0.03975729f, -0.02614858f, 0.17405014f, 0.10196173f, 0.11935833f, 
    -0.26896423f, 0.15487233f, 0.13766147f, 0.03113936f, 0.05003432f, 0.13110882f, 0.16319019f, -0.04515263f, 
    0.00457638f, 0.07902347f, 0.05110038f, -0.12607184f, -0.07112943f, 0.23945816f, -0.14025018f, -0.01540690f, 
    0.00289485f, 0.03093740f, 0.02296083f, -0.03326500f, -0.01283173f, -0.04878093f, -0.11698087f, -0.04080223f, 
    -0.09229530f, 0.14861822f, 0.11411043f, -0.14629136f, 0.09153358f, 0.03899812f, 0.02491088f, -0.00388640f, 
    0.06902301f, 0.05283266f, 0.06660642f, -0.09121460f, 0.28809807f, 0.12428398f, 0.29273060f, -0.09594770f, 
    0.08134817f, -0.00695835f, 0.02610581f, 0.08390104f, 0.10213725f, -0.02508913f, 0.08906618f, 0.02414152f, 
    -0.11945295f, -0.10846061f, 0.06277358f, -0.18944502f, 0.08200893f, 0.08491614f, -0.08413877f, 0.07322610f, 
    0.09871840f, 0.09064990f, -0.04105527f, -0.08121557f, 0.15659694f, -0.00177863f, 0.03504172f, -0.30390128f, 
    0.06252401f, -0.07143285f, -0.10941506f, -0.00091802f, 0.10044193f, -0.02953051f, -0.01617952f, -0.01433278f, 
    0.01871732f, -0.00716277f, 0.09638710f, -0.30659533f, 0.20332229f, -0.01476726f, 0.04477894f, -0.00555908f, 
    0.03190272f, -0.04470211f, -0.08800142f, 0.05930344f, 0.15198043f, 0.18894430f, 0.08034745f, 0.13819715f, 
    -0.02968336f, 0.04772211f, 0.11178783f, -0.18133357f, -0.17777050f, 0.03978951f, -0.04265281f, -0.06110216f, 
    -0.02376723f, -0.00637573f, 0.00175125f, 0.24380165f, -0.11551907f, 0.02892573f, -0.11874866f, -0.04429983f, 
    -0.08703119f, -0.02213307f, 0.03934205f, 0.03723931f, 0.05200954f, 0.20463201f, -0.37053043f, 0.27768639f, 
    0.00495911f, -0.03900593f, -0.00809207f, -0.00514035f, 0.04978804f, 0.01010044f, -0.00568544f, -0.05525817f, 
    -0.09007701f, -0.13929482f, 0.18234052f, -0.12407100f, -0.11467684f, -0.06275545f, 0.12636800f, 0.11423168f, 
    -0.00813015f, -0.10371727f, -0.10982812f, 0.06131607f, -0.21423012f, 0.15369655f, -0.01594421f, 0.19284101f, 
    0.16350690f, 0.08678387f, 0.05316808f, -0.06553274f, 0.04668487f, -0.08200051f, 0.15426555f, 0.15881886f, 
    0.17703338f, 0.05596294f, -0.16509777f, 0.04475183f, -0.00474000f, 0.03340742f, -0.08517759f, -0.13135812f, 
    0.00275533f, 0.12535232f, 0.04066410f, -0.02039370f, -0.37013718f, -0.08887580f, 0.22621758f, 0.06534520f, 
    0.04615853f, -0.06274606f, 0.00382202f, 0.05880872f, -0.01218949f, 0.06667878f, 0.02229972f, 0.10354219f, 
    -0.14086337f, 0.10463940f, 0.06437398f, 0.33932266f, 0.03574424f, -0.09396476f, 0.21899484f, 0.03052112f, 
    -0.01133714f, -0.10952602f, 0.03267974f, -0.12305205f, -0.07251959f, 0.12360513f, -0.05251238f, -0.20545298f, 
    0.07409811f, 0.01187600f, 0.03931955f, 0.13145746f, -0.08408870f, -0.02166435f, -0.06982581f, 0.11649930f, 
    -0.06286349f, 0.00629640f, 0.07126141f, 0.02271383f, -0.05921411f, 0.02446020f, 0.17587200f, 0.04419953f, 
    0.04176184f, 0.12969714f, -0.02688791f, 0.06493700f, -0.07343248f, -0.24824455f, -0.05289995f, 0.13449627f, 
    -0.08750971f, 0.17657006f, 0.01559176f, 0.00552074f, 0.00751316f, -0.03012525f, 0.05536329f, 0.14740883f, 
    0.06438979f, 0.03646609f, -0.18311939f, 0.16113611f, 0.04820823f, 0.02601012f, -0.04645228f, 0.05218058f, 
    -0.14480400f, -0.03353866f, 0.01813190f, -0.02921885f, -0.14322878f, -0.11658329f, -0.09624707f, -0.05804273f, 
    0.05121811f, 0.07602265f, -0.03138354f, 0.11958238f, -0.00581739f, -0.02224722f, 0.09674075f, 0.02009486f, 
    0.16291411f, -0.10178670f, -0.04097918f, 0.45008609f, -0.05564732f, -0.03319154f, 0.10396953f, 0.01364051f, 
    0.01054021f, 0.00364277f, 0.02469246f, 0.00597837f, -0.22513750f, 0.08768055f, -0.03147848f, 0.34472290f, 
    0.05646284f, -0.03477222f, 0.00243736f, -0.05297367f, 0.03803123f, 0.08395533f, 0.01339375f, -0.00833573f, 
    0.06857694f, 0.17318891f, -0.08597685f, -0.06965813f, 0.09162623f, 0.01057318f, -0.11221834f, 0.04686299f, 
    0.11713259f, 0.06009979f, 0.06786696f, 0.08872243f, -0.24244684f, -0.04668302f, -0.14928885f, -0.10871548f, 
    0.04724183f, 0.03263382f, -0.08048116f, 0.20008060f, -0.03660518f, -0.06935547f, -0.09423508f, 0.07652395f, 
    -0.15568173f, 0.03815517f, 0.02060042f, 0.07223303f, 0.08233480f, -0.00279642f, -0.00893459f, -0.11269267f, 
    0.04398354f, 0.04793478f, 0.07822865f, -0.13357413f, -0.42492205f, -0.10429719f, -0.23960929f, 0.23025025f, 
    0.05408380f, 0.11950776f, -0.05185217f, -0.02751398f, 0.11963125f, 0.02055552f, -0.08246332f, -0.00231718f, 
    -0.17388086f, -0.06709264f, 0.13065857f, 0.04451736f, 0.03523008f, 0.00201718f, 0.09095272f, 0.05156824f, 
    -0.12100627f, -0.05367086f, -0.05229824f, 0.06990896f, -0.08815970f, -0.12808685f, -0.19049840f, 0.20007299f, 
    0.09719513f, 0.08291645f, -0.01704272f, 0.08017393f, -0.01794230f, 0.04702799f, 0.00159139f, -0.06069509f, 
    -0.05203675f, -0.15743341f, 0.02913160f, 0.13133499f, 0.02507481f, -0.08198941f, 0.10524174f, 0.04074759f, 
    0.08083206f, 0.14498362f, 0.05029127f, 0.03584313f, -0.20572592f, -0.08612370f, -0.01096950f, 0.01495583f, 
    0.06320319f, 0.10322253f, 0.04455866f, -0.09810217f, -0.01089287f, 0.07459903f, 0.06051844f, 0.15243766f, 
    0.33286992f, 0.13347498f, -0.02814771f, 0.04215772f, 0.16993541f, -0.05949942f, 0.06431356f, 0.00601427f, 
    0.02926701f, -0.03193201f, 0.04343930f, 0.13953368f, -0.03249850f, -0.16132718f, -0.20325723f, -0.27838284f, 
    -0.03297223f, 0.06585919f, -0.03837457f, -0.02872643f, -0.10470875f, 0.13789479f, 0.07821796f, 0.05326506f, 
    0.03679888f, 0.10197967f, 0.15800123f, 0.06302007f, 0.00626124f, 0.10432743f, 0.16025417f, 0.04175287f, 
    -0.05346264f, 0.02242314f, 0.08340146f, -0.07812651f, 0.10582756f, 0.23841240f, -0.04547153f, 0.09152368f, 
    0.17698127f, -0.00754100f, 0.05840839f, -0.00395404f, 0.06230297f, 0.04669205f, -0.08794817f, -0.02191032f, 
    -0.16071258f, -0.01223975f, 0.10432620f, -0.06312475f, 0.05908216f, -0.00636982f, -0.02918225f, -0.06684622f, 
    0.13041937f, -0.03176422f, 0.02642444f, -0.06593599f, 0.26246709f, 0.10710574f, 0.24534799f, 0.04928079f, 
    0.08599480f, 0.05827421f, 0.02226579f, 0.09023467f, 0.08379194f, -0.11071735f, 0.04537626f, -0.03399335f, 
    -0.16895114f, -0.22144249f, -0.01253134f, -0.24565309f, 0.06580246f, 0.14090510f, -0.11715093f, 0.03433787f, 
    0.14474384f, -0.00220820f, -0.05343728f, 0.00988602f, -0.07561434f, -0.03517183f, -0.11398485f, -0.22082838f, 
    0.08061923f, -0.10413472f, -0.05660096f, -0.11873494f, 0.04493068f, -0.02582091f, 0.01711153f, -0.01911413f, 
    -0.01941082f, -0.14254814f, 0.02543249f, -0.08137578f, 0.22963533f, 0.02600073f, -0.01469619f, -0.06353098f, 
    -0.04115677f, 0.02435894f, -0.06863558f, -0.00167873f, 0.07376947f, 0.34814987f, 0.01667162f, 0.01961653f, 
    -0.03194546f, 0.10080558f, -0.02635748f, -0.08426064f, -0.14523727f, 0.08623612f, -0.08773547f, -0.02123090f, 
    0.06359676f, 0.09855183f, 0.02508207f, 0.25363931f, -0.09945905f, 0.06098123f, -0.03051418f, 0.02877429f, 
    -0.05800633f, 0.00491557f, 0.04461807f, -0.05715283f, 0.13532777f, 0.14620653f, -0.21254402f, 0.25159496f, 
    0.01048025f, 0.01195705f, -0.01022696f, 0.05488734f, 0.01527078f, 0.04685530f, -0.00321837f, 0.00910665f, 
    0.03181873f, -0.14775370f, 0.07681791f, 0.01812625f, -0.02964172f, -0.06256864f, 0.12792164f, 0.11283037f, 
    -0.01520948f, -0.00203105f, -0.10536584f, 0.00944849f, -0.16749562f, -0.04610155f, 0.08028010f, 0.20213220f, 
    0.12064330f, 0.07745282f, 0.04914318f, -0.12198176f, 0.12929483f, -0.05329411f, 0.05209086f, 0.02557460f, 
    0.16249853f, 0.18375325f, -0.06909088f, 0.01372947f, -0.04390550f, 0.05783381f, 0.07888684f, -0.08227558f, 
    0.04574202f, 0.09978394f, -0.02593489f, -0.09033434f, -0.06320097f, -0.03069527f, 0.21217771f, 0.05257804f, 
    -0.08406334f, -0.05354692f, -0.09027269f, 0.09223763f, 0.04965994f, 0.09511120f, -0.05161124f, -0.00013810f, 
    0.07817230f, 0.09221326f, 0.09383407f, 0.28958967f, -0.00408722f, -0.08597048f, 0.21697259f, 0.08331338f, 
    -0.02553889f, -0.14954342f, 0.05534571f, -0.09698488f, -0.01987326f, 0.04519921f, -0.05825859f, -0.09631718f, 
    0.07253355f, -0.06145581f, -0.02568743f, 0.05479177f, -0.01576186f, -0.05330795f, -0.08882134f, 0.09721849f, 
    0.10116331f, 0.06720555f, 0.07229232f, 0.09133875f, 0.01368269f, -0.04500798f, 0.17435877f, 0.06240420f, 
    0.01114558f, -0.02450648f, -0.07496493f, 0.04698991f, 0.02042210f, -0.08476405f, 0.03233190f, 0.17801815f, 
    -0.00502046f, 0.06511222f, 0.03989498f, 0.10016671f, -0.01391573f, -0.02020292f, -0.03958580f, 0.10216347f, 
    0.11316531f, 0.15249313f, -0.12531741f, 0.18208870f, 0.01171411f, 0.07363363f, 0.00194689f, 0.02107004f, 
    -0.16300033f, -0.00413612f, -0.04385738f, 0.04958833f, 0.04309712f, 0.01458878f, -0.11345713f, -0.01662587f, 
    0.08971946f, 0.01987625f, 0.00048723f, 0.21893322f, 0.15615068f, -0.05975133f, -0.05253374f, -0.02473563f, 
    0.21890506f, -0.01124487f, 0.03813276f, 0.34840426f, 0.00281788f, -0.02404762f, -0.00104771f, 0.09631917f, 
    -0.00554773f, -0.02289090f, 0.05325467f, 0.00588085f, -0.18413806f, -0.07889654f, 0.07950999f, 0.17354903f, 
    0.00172134f, 0.00286868f, 0.06964993f, -0.06924107f, 0.15998380f, 0.09212169f, -0.06491815f, -0.02058316f, 
    0.26076153f, 0.11289879f, -0.05862464f, -0.02573160f, 0.10398428f, -0.00183053f, -0.07299963f, 0.03328221f, 
    0.12726246f, 0.10486213f, 0.03679964f, 0.07058160f, -0.34573981f, -0.03445100f, -0.28820682f, -0.11997476f, 
    0.06762969f, 0.03834889f, -0.13328050f, 0.14870644f, -0.03509961f, -0.03590878f, 0.01132132f, 0.10696661f, 
    -0.34305340f, -0.15020537f, -0.05204638f, -0.01688597f, 0.13500404f, 0.00076347f, -0.00368101f, -0.09681098f, 
    0.00335427f, 0.04159509f, -0.00422446f, -0.05737908f, -0.50919122f, -0.33243361f, -0.13681386f, 0.01744464f, 
    0.00813226f, 0.05188469f, 0.03954281f, -0.11249559f, 0.13516665f, 0.05621165f, -0.09948459f, 0.06786767f, 
    -0.00024627f, -0.09429853f, 0.03874820f, 0.04119172f, -0.01815260f, -0.04260186f, 0.18370579f, -0.14246304f, 
    0.08762078f, 0.05362825f, 0.08698930f, -0.11149193f, -0.06531969f, 0.04452636f, 0.31297937f, -0.03200328f, 
    0.02191354f, -0.08099830f, 0.02870564f, 0.07363482f, -0.08004251f, -0.02295250f, -0.11768296f, 0.08869436f, 
    -0.24269551f, 0.07449322f, -0.05473096f, 0.14370677f, -0.08569282f, 0.03450784f, 0.15450853f, 0.03413914f, 
    -0.07509430f, -0.01094673f, 0.15214568f, 0.00736233f, 0.04745815f, -0.03132627f, -0.38142720f, -0.00926487f, 
    -0.01294606f, 0.02189519f, -0.11486644f, 0.00391303f, 0.02898706f, -0.04203220f, -0.04436260f, 0.13076063f, 
    0.05163996f, 0.07145025f, -0.02055835f, 0.27867129f, -0.16233088f, -0.05677859f, 0.03022655f, 0.06368573f, 
    0.05024940f, 0.15540878f, 0.05482922f, -0.03094030f, 0.21815175f, -0.16624464f, -0.15888493f, 0.09191003f, 
    -0.03394562f, 0.03429555f, 0.00182538f, -0.15039849f, 0.13685177f, 0.10110527f, -0.02661801f, 0.06774089f, 
    0.24825338f, -0.06990201f, 0.08680067f, -0.00413048f, 0.02023528f, -0.08751811f, -0.06175102f, 0.07431088f, 
    0.01362666f, 0.02486789f, -0.02485356f, 0.07911145f, 0.21797565f, 0.11885621f, 0.10770612f, -0.06210061f, 
    -0.09452222f, 0.08516189f, 0.05197332f, 0.00590863f, 0.01256121f, 0.01013403f, -0.08666284f, -0.11763327f, 
    0.03816660f, -0.25661311f, -0.13504283f, 0.06921238f, 0.08810906f, -0.08309864f, 0.13171412f, -0.08658853f, 
    0.00053693f, -0.04800382f, -0.09324840f, -0.09210207f, 0.01633638f, 0.04071693f, 0.01445800f, 0.19326825f, 
    0.02738018f, -0.04159863f, 0.02688750f, 0.05269095f, -0.00663578f, 0.12673292f, -0.05798350f, 0.08704998f, 
    -0.24160318f, -0.20567504f, -0.07294867f, -0.03501963f, -0.05387506f, 0.04617224f, 0.08060373f, -0.10793144f, 
    0.06656104f, 0.06986671f, -0.01978871f, 0.03564509f, -0.40894866f, 0.02053646f, -0.27627361f, 0.04061184f, 
    0.03628410f, -0.07130424f, -0.03663018f, -0.12013245f, -0.14153318f, 0.05100993f, -0.10788690f, -0.00120175f, 
    -0.32820362f, 0.05467843f, -0.13275826f, 0.08359618f, 0.10531461f, 0.04973292f, 0.01341160f, -0.06577034f, 
    0.10433704f, 0.10089730f, -0.03391820f, -0.12589242f, 0.05894006f, -0.00266017f, 0.17639862f, -0.10551231f, 
    0.01310925f, 0.10240832f, -0.05232606f, 0.11124948f, 0.00207509f, -0.20722266f, -0.00597279f, 0.08309808f, 
    0.18038923f, 0.07221081f, 0.10142700f, 0.06675281f, -0.00148332f, 0.05086391f, -0.04513721f, 0.10374025f, 
    0.03554339f, 0.06949133f, 0.14465658f, -0.05170194f, 0.17545739f, 0.18535191f, 0.20744802f, 0.11863913f, 
    -0.07766765f, -0.01244640f, 0.05954044f, 0.11620994f, -0.01775562f, 0.13377729f, 0.00660066f, 0.17035402f, 
    -0.05655334f, 0.14763127f, -0.21286781f, -0.01144809f, 0.14564879f, 0.08984818f, 0.03615105f, -0.14927547f, 
    0.10263057f, 0.03573511f, -0.02253755f, 0.03008284f, -0.09399980f, -0.01674823f, -0.01136910f, -0.18537480f, 
    -0.10113958f, 0.01100472f, 0.01914485f, 0.11839843f, 0.00711405f, 0.04744885f, -0.05219276f, -0.03865546f, 
    0.13133566f, 0.09735970f, 0.05525848f, 0.02420445f, 0.01144964f, 0.27843496f, 0.04828897f, 0.19347061f, 
    -0.03230336f, 0.14762665f, -0.09443402f, -0.02988415f, 0.31845847f, -0.02732944f, 0.07152785f, 0.01717376f, 
    0.01389986f, 0.11980619f, -0.02057662f, 0.09504206f, -0.03756388f, 0.10841902f, -0.02717336f, -0.11604104f, 
    -0.07968986f, 0.23272529f, 0.09247126f, 0.10781266f, -0.01884218f, -0.05229497f, -0.11029307f, -0.06187158f, 
    -0.04028654f, -0.01997130f, 0.04984553f, 0.00364840f, -0.06421146f, 0.11561070f, -0.04578907f, 0.17292875f, 
    0.03487355f, 0.02894537f, -0.04687371f, -0.04460726f, 0.10021021f, -0.14757477f, 0.20004630f, 0.17258723f, 
    0.00273848f, -0.08897578f, 0.06459315f, 0.14193426f, 0.03078975f, -0.07152688f, 0.07722091f, -0.05780455f, 
    0.00361612f, 0.02168516f, -0.03159575f, 0.01251125f, 0.07840300f, 0.05194808f, 0.24802996f, -0.01173475f, 
    0.06208109f, -0.09458128f, 0.04160059f, 0.00811904f, 0.06049288f, -0.06544080f, 0.11660729f, 0.00453672f, 
    0.06225602f, 0.05217883f, 0.08035874f, -0.03184206f, -0.04057375f, -0.03910956f, -0.00178472f, -0.00547957f, 
    -0.04338776f, -0.03484785f, -0.01350448f, 0.07684476f, 0.37065786f, 0.29522559f, 0.14192668f, -0.08245204f, 
    0.08860786f, -0.05547128f, -0.04853243f, -0.10760087f, -0.05085189f, 0.03935879f, -0.09525925f, 0.14102075f, 
    -0.15936370f, -0.13812497f, 0.16070631f, -0.08044154f, 0.02721999f, -0.03230497f, -0.04768324f, -0.06538036f, 
    -0.03886027f, -0.07249683f, 0.11270170f, -0.10878750f, 0.03815187f, 0.13035204f, 0.14297786f, -0.05191179f, 
    -0.00407811f, 0.10509575f, 0.07775176f, 0.19664060f, -0.01831956f, 0.04164605f, 0.04124543f, 0.06677010f, 
    0.28726745f, -0.02523765f, 0.12972127f, 0.15743566f, -0.14257835f, 0.05834613f, 0.08951700f, -0.04658358f, 
    -0.09189311f, 0.05483360f, -0.00181738f, 0.04869670f, 0.15437058f, -0.05082151f, -0.03414820f, 0.01586812f, 
    -0.05562176f, 0.04082885f, -0.05300068f, -0.03025296f, 0.16134074f, 0.05064136f, 0.00530732f, 0.11898044f, 
    -0.13608114f, -0.49008158f, -0.00102490f, -0.07187888f, -0.05502001f, 0.06290130f, 0.08225693f, 0.08796902f, 
    0.00380178f, 0.05383651f, -0.01273796f, -0.06354054f, 0.26454633f, -0.23239878f, -0.13165778f, -0.09946911f, 
    -0.05462193f, 0.02484055f, 0.07384640f, -0.00380638f, -0.05791906f, 0.03178691f, -0.00969069f, -0.05580462f, 
    -0.03270525f, 0.21684299f, 0.13593189f, 0.03418326f, 0.02140325f, 0.03787931f, 0.02951893f, 0.10594030f, 
    0.09827557f, -0.01279488f, 0.03901352f, -0.00845616f, -0.02217516f, 0.00853748f, 0.02912529f, 0.02566714f, 
    -0.03644145f, 0.06559374f, 0.08057652f, -0.02467219f, 0.02470697f, -0.03653601f, 0.05371028f, 0.18076922f, 
    -0.09620214f, 0.10963689f, 0.18371262f, 0.05621520f, 0.16103847f, 0.06744620f, 0.00062609f, 0.11303458f, 
    0.04199081f, 0.09316345f, -0.10507628f, 0.02852643f, 0.28860369f, -0.15197170f, 0.05354577f, 0.08243961f, 
    -0.18259901f, -0.20091988f, -0.01171732f, 0.08935067f, 0.02868510f, 0.10708682f, 0.06084478f, -0.07071474f, 
    -0.26137716f, 0.03708764f, 0.26615727f, 0.13557290f, -0.03575866f, -0.03986979f, -0.05016259f, 0.13183077f, 
    0.07523263f, -0.01099489f, 0.04854192f, 0.03336312f, 0.12031674f, -0.01342881f, 0.11262109f, 0.25185725f, 
    -0.22721606f, -0.10843806f, 0.05716423f, 0.17055404f, 0.07155105f, 0.05763160f, -0.06784122f, 0.01410770f, 
    -0.28035018f, 0.24710777f, -0.19701543f, -0.13923548f, 0.13935626f, -0.05063299f, -0.01463909f, 0.13377954f, 
    0.10321552f, -0.04986306f, 0.03917072f, 0.09198221f, 0.03761213f, -0.16427565f, -0.06562085f, 0.40819010f, 
    0.05973109f, 0.07022535f, 0.06039902f, 0.00536593f, 0.07205845f, -0.07777222f, 0.10622437f, -0.03031551f, 
    0.41545978f, 0.03896368f, 0.10248157f, 0.20734110f, -0.14447683f, 0.07254304f, 0.04148970f, 0.03678546f, 
    0.03264052f, -0.09376985f, -0.05282122f, 0.08739795f, 0.08752380f, -0.13237347f, -0.31369597f, -0.17082439f, 
    0.09549231f, 0.18188274f, -0.01027561f, 0.03976855f, 0.07241783f, 0.12191807f, -0.09387717f, 0.10629980f, 
    0.20217377f, 0.02059659f, -0.01765637f, 0.32844225f, -0.10881403f, -0.10245153f, -0.04065150f, -0.04349139f, 
    -0.06586949f, -0.05549287f, 0.09586302f, -0.07797201f, 0.24291195f, 0.02267294f, 0.48044726f, 0.34480083f, 
    -0.15556252f, 0.10251592f, 0.07937222f, 0.11287782f, -0.03465490f, 0.02891008f, 0.04725220f, -0.06852731f, 
    0.29329503f, -0.14496952f, 0.27062434f, 0.18720165f, -0.16221102f, 0.10238393f, 0.03793345f, 0.04371409f, 
    0.09545537f, 0.03930048f, -0.05674867f, 0.09679769f, -0.16097058f, 0.27034017f, 0.01469703f, -0.04944940f, 
    -0.01273877f, -0.07720391f, 0.00715597f, -0.01407674f, 0.15470824f, 0.15370594f, 0.02417215f, -0.05179339f, 
    -0.09922058f, -0.18235923f, -0.16022423f, -0.19535047f, 0.06142712f, 0.06849244f, 0.08602430f, -0.06696827f, 
    0.01166909f, 0.13566904f, -0.06521614f, -0.00415208f, 0.18086420f, -0.18724643f, -0.07705534f, -0.11690146f, 
    0.09202734f, -0.05775910f, 0.16112481f, -0.02300858f, -0.03509950f, -0.00254937f, 0.04419569f, 0.03355408f, 
    0.03834851f, 0.13001227f, -0.04525590f, -0.08954488f, 0.08308122f, 0.07369532f, 0.04580754f, -0.05254288f, 
    0.02298833f, -0.06417416f, 0.06145089f, 0.00004467f, 0.40199694f, -0.02825118f, 0.10190820f, 0.13334256f, 
    -0.09195562f, -0.01305489f, -0.07899984f, 0.14523987f, 0.02640865f, -0.05279974f, 0.00452252f, 0.01552965f, 
    0.11955472f, -0.11150172f, 0.09732887f, 0.08573259f, 0.02578928f, -0.00262079f, 0.08372089f, 0.13183750f, 
    0.04860641f, 0.03307087f, 0.13449262f, 0.09453820f, -0.39777136f, 0.03279573f, -0.16368833f, -0.13457641f, 
    0.03730427f, 0.03269839f, 0.02911398f, 0.01520034f, 0.02449118f, -0.07534135f, 0.00431579f, 0.07612729f, 
    -0.19505294f, -0.04600483f, -0.26396486f, -0.30116782f, -0.02853577f, 0.13786878f, -0.00000302f, -0.10770344f, 
    -0.01336529f, -0.02360997f, -0.02732197f, 0.06126801f, 0.29451281f, 0.02313399f, -0.07893434f, 0.20028917f, 
    -0.12450999f, 0.08530808f, 0.11435506f, 0.08554064f, 0.02953039f, 0.15832029f, 0.00220565f, 0.07173922f, 
    -0.30824482f, 0.14958671f, -0.11806565f, -0.16803838f, 0.08103666f, 0.10323915f, -0.02701730f, -0.04671360f, 
    0.13694128f, 0.09819410f, 0.17705277f, 0.01769879f, -0.31762186f, -0.10299118f, 0.03551571f, 0.18177840f, 
    0.03561193f, 0.09214875f, -0.02956511f, 0.03743180f, 0.05481191f, 0.05222683f, 0.03591877f, 0.01705453f, 
    0.23266917f, 0.00479698f, -0.20322782f, -0.02546182f, 0.05661549f, -0.07665795f, 0.02308757f, 0.00782860f, 
    0.03099697f, 0.00879581f, 0.05275560f, -0.18322898f, -0.36297196f, -0.02839070f, 0.02216284f, 0.03163522f, 
    -0.03353110f, 0.05024603f, -0.02907385f, 0.04974464f, -0.07598256f, -0.02682946f, 0.03918072f, -0.01966827f, 
    -0.45896444f, 0.06631793f, 0.12930937f, 0.38545895f, -0.07642204f, -0.04178005f, -0.05297289f, -0.02415824f, 
    -0.00738584f, -0.03628359f, -0.04612314f, 0.10439069f, 0.13143863f, -0.07512126f, -0.06967501f, 0.04275249f, 
    0.02505729f, 0.10907875f, 0.01907548f, -0.00351082f, 0.03328336f, 0.03544340f, 0.11368787f, 0.10942904f, 
    -0.07578782f, -0.00781533f, -0.04329461f, 0.00915673f, -0.06770006f, 0.03548122f, -0.02145316f, -0.15318875f, 
    0.00637737f, -0.02855760f, 0.04934245f, 0.03139511f, -0.15860434f, 0.26509070f, 0.08888666f, 0.16404039f, 
    -0.15756065f, -0.01791914f, 0.00243153f, 0.01034346f, 0.07232832f, 0.06774151f, -0.04210593f, -0.11709390f, 
    0.25961441f, 0.15184145f, 0.13817169f, 0.21391045f, -0.27368134f, -0.04859865f, 0.07922673f, 0.05389452f, 
    0.05142194f, -0.00956729f, 0.00875356f, -0.01139752f, -0.03639299f, -0.22063473f, -0.05042873f, -0.02762303f, 
    -0.12426016f, -0.02072949f, -0.19825910f, -0.07063168f, 0.04679096f, 0.02157322f, 0.01195210f, -0.04458005f, 
    -0.14421369f, -0.17109886f, 0.20847784f, 0.00062792f, 0.07244278f, 0.02518635f, 0.06827792f, 0.00739896f, 
    -0.02762451f, -0.03643782f, 0.09545978f, 0.07235352f, 0.01785735f, -0.10809933f, -0.13648343f, 0.23043063f, 
    0.07201853f, 0.04400877f, -0.03829350f, -0.00974219f, -0.07105878f, -0.07600013f, 0.11446982f, 0.00314554f, 
    -0.37032014f, -0.04798521f, -0.09433343f, 0.33594242f, -0.00658247f, -0.09194330f, 0.20393020f, -0.02008404f, 
    -0.05290267f, 0.13941896f, -0.14006151f, -0.00034586f, 0.08840480f, -0.14152560f, -0.11939992f, -0.08807318f, 
    -0.05250539f, 0.00361394f, -0.03970663f, -0.03649346f, 0.16581005f, -0.03653939f, 0.03539776f, 0.05236225f, 
    0.26161191f, 0.17964087f, -0.09280153f, 0.36633781f, -0.02384505f, -0.06636197f, -0.05742616f, 0.00187681f, 
    -0.00973929f, 0.20341741f, 0.15567657f, 0.28320155f, 0.20676947f, -0.18084076f, -0.09344113f, -0.12301651f, 
    0.04138707f, -0.12303361f, -0.04847652f, -0.10170278f, -0.09304702f, 0.04826786f, -0.09022903f, 0.31899923f, 
    0.03689269f, 0.06696200f, 0.20347321f, -0.01191038f, 0.10404091f, 0.00237011f, 0.03594193f, -0.03940181f, 
    -0.01452177f, 0.02186064f, -0.01017694f, -0.05443982f, 0.13133432f, 0.23597319f, -0.11352439f, 0.07301093f, 
    -0.08472563f, 0.02694549f, -0.01469892f, -0.08232753f, 0.12368107f, 0.09099668f, -0.00075920f, 0.03261715f, 
    -0.02205724f, -0.17030534f, 0.07596514f, 0.11036033f, -0.00821021f, -0.03611997f, 0.03512200f, -0.09977945f, 
    0.08187858f, 0.04149977f, 0.18488774f, 0.04742784f, 0.16078585f, -0.10198699f, 0.06655486f, 0.15237364f, 
    -0.01795223f, -0.02304874f, 0.02085659f, 0.10614054f, -0.05345534f, -0.04197275f, 0.04263939f, -0.01579517f, 
    -0.14124759f, -0.29737166f, -0.00374364f, -0.08484085f, 0.05959184f, 0.09520165f, -0.04989223f, -0.04225300f, 
    0.23273833f, -0.04801579f, 0.00401062f, 0.12089066f, -0.30322996f, -0.05710924f, 0.10264596f, 0.08256158f, 
    -0.09437416f, -0.03308090f, -0.09924028f, -0.00759704f, 0.05932275f, -0.01843283f, 0.02230697f, 0.02083171f, 
    -0.22824509f, -0.16095680f, 0.01213449f, -0.21153459f, 0.26872581f, 0.02691801f, 0.07758404f, -0.06260574f, 
    -0.00267291f, -0.01581404f, -0.00716281f, 0.01640683f, -0.26179531f, 0.28284967f, 0.13839056f, -0.19376692f, 
    0.00192894f, -0.04338923f, -0.12633340f, -0.00314597f, 0.08278182f, 0.04056615f, 0.04882872f, 0.13010095f, 
    0.14489704f, -0.08137995f, 0.04759490f, 0.10029009f, 0.00681039f, 0.01808826f, -0.04801552f, 0.07252159f, 
    -0.01989410f, 0.00835586f, -0.11750350f, -0.00923101f, 0.20067167f, 0.28517190f, -0.02807230f, 0.29834685f, 
    -0.14897197f, 0.02381322f, -0.08395670f, 0.13150354f, 0.11468197f, -0.02108753f, 0.05852128f, -0.00855699f, 
    -0.03609046f, 0.13035974f, -0.03147554f, -0.09027822f, 0.10524981f, -0.19759342f, -0.08338862f, 0.05570250f, 
    0.00518285f, 0.05803007f, -0.07067771f, 0.03581590f, -0.04675595f, -0.24476266f, 0.11126915f, 0.28621790f, 
    -0.03321617f, -0.03327160f, 0.06031190f, -0.11606725f, 0.02042868f, 0.00789521f, -0.02156120f, 0.07762281f, 
    0.25390425f, 0.15959822f, -0.07552831f, 0.06923109f, -0.06572554f, 0.15350284f, 0.06658085f, 0.02928271f, 
    0.10659572f, 0.04121912f, 0.08814076f, 0.04525668f, -0.04833218f, 0.00115942f, 0.12465987f, 0.16119966f, 
    0.02055177f, 0.05109925f, -0.11497361f, -0.07228314f, 0.04263182f, 0.07508891f, 0.01612694f, -0.02722552f, 
    -0.12701862f, 0.19018991f, -0.01047130f, 0.31764132f, 0.01478522f, 0.01070727f, 0.06283950f, -0.03406299f, 
    0.00594477f, -0.08525071f, 0.09326226f, 0.00220427f, -0.05474675f, 0.28829652f, -0.19470181f, -0.11702202f, 
    0.02879943f, -0.02526108f, 0.04500574f, 0.03616819f, 0.13409179f, -0.05437175f, 0.12375634f, 0.06441518f, 
    -0.28997198f, 0.17163694f, -0.07784522f, 0.14426787f, 0.00931610f, -0.00708201f, 0.07117180f, -0.09084125f, 
    -0.07916714f, 0.08401185f, 0.15912622f, -0.12207273f, -0.26385120f, -0.13347159f, 0.05877892f, 0.17788278f, 
    0.08745542f, -0.04219189f, -0.01012985f, 0.00770879f, -0.00828474f, -0.03031741f, -0.10459888f, 0.00243064f, 
    0.00043094f, 0.08930494f, -0.05321373f, 0.23511681f, 0.12921360f, -0.00663318f, -0.02601549f, -0.02302361f, 
    -0.00710634f, 0.12423525f, -0.12739342f, 0.01160731f, 0.02520757f, 0.09286913f, 0.05488989f, -0.00648601f, 
    0.06714051f, -0.06446739f, 0.08120910f, 0.13300049f, 0.05209364f, -0.08148719f, -0.01406305f, -0.06151190f, 
    -0.02514003f, -0.08148018f, 0.11494263f, 0.27369875f, -0.10267797f, -0.07271226f, 0.06366187f, 0.00486529f, 
    -0.04991259f, -0.01394986f, 0.00565320f, 0.08063854f, 0.06775358f, 0.10030279f, 0.00586998f, 0.14256093f, 
    -0.02911997f, 0.14760335f, -0.03702925f, -0.05117894f, 0.19034423f, 0.08251371f, -0.03193895f, 0.07501217f, 
    0.28840867f, 0.05070426f, 0.02011229f, 0.07354008f, -0.04634167f, -0.00370846f, -0.03242376f, 0.04970812f, 
    -0.04213281f, 0.06780790f, 0.02772869f, 0.03076945f, -0.19116966f, 0.09900799f, -0.13585471f, -0.12393291f, 
    -0.02280704f, -0.04561470f, -0.06100237f, 0.10069735f, 0.14209478f, 0.04343802f, 0.03584809f, 0.05140366f, 
    -0.23931523f, -0.30860022f, 0.05549616f, 0.08922010f, 0.00413533f, 0.08070475f, 0.05872335f, -0.17464191f, 
    0.09589486f, 0.02500130f, 0.15060861f, 0.09541789f, -0.19937535f, -0.23134589f, -0.22818509f, -0.02199866f, 
    0.04049001f, 0.01796000f, -0.10234289f, -0.13189688f, 0.08596504f, 0.14158694f, -0.29429153f, 0.10500436f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04761178f, -0.04340303f, -0.03916383f, 0.01182816f, 0.04254829f, -0.05410658f, -0.00731227f, 0.02849719f, 
    -0.04696296f, 0.21791223f, -0.04602305f, -0.02190792f, -0.04434202f, 0.08624160f, 0.03579393f, -0.04155042f, 
    -0.01328538f, -0.06747600f, 0.09038012f, 0.04257464f, 0.02957480f, -0.01826628f, -0.04505726f, -0.07279476f, 
    0.08952928f, 0.00059607f, 0.01060018f, 0.08589514f, 0.04137519f, -0.02455264f, 0.02870958f, 0.07701718f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.26871285f, -0.04340104f, 0.14704835f, -0.19051893f, 0.38785949f, -0.14039575f, -0.09064666f, -0.14033237f, 
    0.16313314f, 0.27853397f, -0.18818064f, 0.07255373f, -0.03509570f, 0.01432106f, -0.07509085f, -0.13368438f, 
    0.34861147f, -0.16249228f, 0.06081130f, -0.09811647f, 0.00582474f, -0.12040524f, 0.11946770f, -0.15536600f, 
    -0.30801141f, -0.11284751f, 0.08026622f, 0.26887310f, 0.16654941f, -0.08041056f, 0.14870007f, 0.00350859f, 
    -0.04779150f, -0.02647675f, -0.15721343f, 0.25280935f, 0.07434133f, -0.05311124f, -0.08793622f, 0.04690160f, 
    0.10989051f, -0.10142768f, 0.40659195f, -0.08586643f, 0.15246515f, -0.08652022f, -0.00151172f, 0.15864283f, 
    0.15822107f, -0.05513586f, -0.39848915f, -0.02557593f, -0.12332416f, 0.19084096f, 0.32989734f, 0.23418726f, 
    0.07543033f, 0.18461800f, 0.01000956f, -0.23413329f, -0.22867543f, -0.12000342f, 0.49275658f, -0.20889096f, 
    -0.06449328f, 0.04847401f, 0.14195792f, 0.06747083f, -0.01153868f, 0.01143657f, 0.22396937f, -0.16990228f, 
    -0.01266011f, -0.01296451f, -0.02884886f, -0.07800680f, -0.05404419f, -0.05121980f, 0.14302723f, -0.05785700f, 
    -0.07231048f, -0.19720121f, -0.17049922f, -0.01743916f, 0.00286659f, 0.16927400f, -0.04293336f, -0.13125668f, 
    0.53944576f, 0.29455265f, 0.04362884f, -0.28026575f, -0.15932544f, 0.21297647f, 0.18625963f, 0.30996317f, 
    0.02254471f, 0.09116690f, 0.07008938f, 0.25826880f, -0.08711917f, -0.10157073f, -0.00527998f, -0.05241894f, 
    -0.05340491f, 0.14363179f, -0.22587422f, 0.17470136f, 0.00513799f, 0.55082113f, -0.09634629f, 0.03607655f, 
    -0.32605985f, 0.19423947f, 0.45180771f, -0.04958772f, 0.16001144f, -0.05620191f, -0.25232422f, -0.17668839f, 
    0.15864268f, 0.12710039f, -0.13912353f, 0.39762503f, 0.19484989f, -0.30833292f, -0.18921144f, 0.23073395f, 
    -0.13126685f, 0.07226912f, -0.13446395f, -0.12994075f, 0.04715634f, -0.13222431f, 0.08647814f, -0.17291109f, 
    -0.02221843f, -0.10081737f, -0.10391415f, 0.03825374f, -0.04798157f, -0.04236547f, -0.13984618f, 0.04952708f, 
    0.09388025f, -0.13565560f, -0.03298806f, 0.11115359f, 0.03835782f, -0.13549142f, -0.05525222f, -0.05847833f, 
    -0.17577244f, -0.10005166f, -0.11082526f, 0.15724768f, 0.03497925f, -0.02423437f, -0.00868274f, -0.11536911f, 
    0.38865680f, 0.11595064f, 0.02526215f, -0.23965780f, 0.23833801f, 0.01104864f, -0.13734639f, -0.16083838f, 
    -0.04932373f, 0.20315039f, 0.20812908f, 0.04083828f, 0.07697166f, 0.05491148f, 0.10323694f, 0.06102917f, 
    -0.24323472f, -0.33654904f, 0.36938182f, -0.01764127f, 0.12042353f, 0.24308009f, -0.00150175f, -0.26566887f, 
    0.50475156f, -0.02887486f, -0.15271285f, 0.22881928f, 0.22034693f, 0.17185371f, -0.27816123f, 0.19506696f, 
    -0.00500772f, 0.06455120f, -0.05944246f, -0.16907182f, -0.05163253f, 0.15144472f, -0.03640956f, -0.00871962f, 
    0.15257546f, 0.06880050f, -0.03503356f, 0.10462673f, -0.10071988f, -0.18439122f, 0.13488714f, -0.03982142f, 
    -0.05809877f, -0.01090374f, -0.15913430f, -0.00923236f, 0.10069129f, -0.04280866f, -0.13475314f, -0.13447964f, 
    -0.02160292f, 0.07185659f, 0.07732670f, -0.15209298f, -0.04218660f, 0.00704271f, -0.01771375f, 0.12252679f, 
    -0.05075477f, 0.08563635f, -0.10049855f, -0.00665568f, -0.09407846f, -0.12289127f, 0.04352193f, 0.17072952f, 
    0.10867592f, -0.07845814f, 0.06156234f, -0.02648556f, -0.06380942f, 0.14349419f, 0.16429837f, -0.14491905f, 
    0.02522076f, -0.11548010f, -0.13213065f, 0.08266669f, 0.01212885f, -0.15087946f, -0.06703832f, -0.04733784f, 
    0.12742865f, -0.07909570f, 0.10543710f, -0.08801454f, -0.00135836f, -0.13188334f, -0.17559874f, 0.11252901f, 
    0.08513639f, -0.12072998f, 0.07575293f, -0.06214095f, -0.08042949f, -0.12193047f, -0.04868374f, 0.13897398f, 
    -0.15418968f, -0.19391647f, -0.03913802f, 0.00189604f, 0.04668712f, -0.15854302f, 0.14366452f, 0.14436400f, 
    0.09652938f, -0.06423135f, -0.10644207f, -0.12264309f, -0.08242486f, -0.14673707f, -0.09169762f, 0.00644629f, 
    0.04033611f, 0.01870531f, -0.11352241f, -0.14110291f, -0.08077349f, 0.03813774f, 0.03059384f, -0.02817765f, 
    -0.11519915f, 0.05137609f, -0.14634472f, -0.11603128f, 0.46571276f, -0.13483109f, -0.16870280f, -0.02339205f, 
    0.10382210f, 0.04826476f, -0.14515765f, -0.14565025f, 0.06763446f, -0.03730601f, -0.07451703f, -0.11234728f, 
    0.40011102f, 0.09716675f, -0.18996626f, 0.08236463f, -0.15100586f, -0.09543854f, 0.03971687f, -0.12055899f, 
    -0.00325112f, -0.08134988f, -0.12116355f, 0.13911428f, 0.51066154f, 0.44459862f, -0.36616457f, 0.36581138f, 
    0.11546496f, -0.15088589f, -0.06917436f, -0.12493271f, -0.08085560f, 0.11014283f, 0.05428777f, 0.05584852f, 
    0.08780156f, -0.01128211f, 0.10072063f, -0.01704747f, -0.13902776f, -0.15732104f, 0.14661893f, -0.10062490f, 
    -0.09827195f, -0.19892533f, 0.10196441f, -0.08261199f, -0.03793749f, -0.14976215f, -0.16723081f, 0.10261022f, 
    0.06585063f, -0.21527915f, -0.10424650f, -0.01390526f, -0.08934233f, -0.15634446f, -0.20970906f, 0.05515001f, 
    0.35924754f, 0.12333849f, -0.13815406f, 0.24848519f, -0.34563786f, 0.15625095f, 0.43890411f, 0.00636565f, 
    -0.14717668f, 0.02302035f, -0.32243451f, -0.12352957f, 0.00745263f, -0.11661701f, 0.08231337f, -0.01289542f, 
    0.34173921f, 0.21657482f, 0.35965008f, 0.03185107f, -0.09116378f, 0.00112278f, 0.33640331f, 0.19276106f, 
    -0.33525401f, -0.09900127f, 0.11759366f, 0.07096167f, -0.06165974f, -0.02610788f, -0.00062517f, -0.33476532f, 
    -0.14375049f, 0.01256479f, 0.04022684f, -0.04515149f, 0.23640159f, -0.13273972f, -0.07530884f, 0.06460993f, 
    0.02753492f, -0.13644350f, 0.06195822f, 0.05796182f, 0.05298303f, -0.09145088f, -0.03925698f, 0.06749526f, 
    0.17869513f, 0.08286635f, 0.06763913f, -0.12541303f, 0.16183504f, 0.03242552f, -0.07558588f, 0.05336325f, 
    0.07986791f, 0.04716474f, 0.01788667f, -0.08785821f, -0.08871121f, 0.17995064f, -0.08521181f, -0.06336876f, 
    -0.26835996f, -0.06756085f, -0.13472000f, 0.35826933f, -0.01637883f, -0.11719620f, -0.35069624f, -0.14012475f, 
    -0.11740021f, 0.01742621f, -0.16408448f, -0.12930042f, 0.15920883f, 0.28925785f, 0.12000503f, 0.03605890f, 
    -0.11534925f, 0.33283651f, 0.00380878f, 0.08638939f, 0.03725378f, 0.00964367f, -0.19895063f, -0.11041892f, 
    0.13700669f, 0.03888373f, 0.16643922f, -0.03429501f, 0.08037687f, 0.02391453f, 0.24260455f, -0.20672177f, 
    0.18562201f, -0.14778787f, -0.12543753f, 0.09188252f, -0.12566401f, 0.09486236f, -0.32172284f, -0.13804728f, 
    -0.11498333f, 0.12850836f, -0.04182566f, -0.03091844f, 0.02970626f, -0.35185507f, -0.01994935f, 0.12462354f, 
    0.05974985f, 0.29019147f, -0.21326570f, 0.01280461f, -0.05909051f, 0.35575056f, 0.11975464f, -0.22294186f, 
    0.12212403f, 0.31818667f, 0.16573340f, -0.17768511f, -0.21600489f, 0.04146694f, 0.03785299f, -0.14062288f, 
    0.08892516f, -0.16026312f, 0.06649447f, 0.01881903f, 0.06369697f, 0.06147360f, -0.16464876f, 0.11789309f, 
    0.16215612f, -0.15695104f, 0.06001456f, -0.02206478f, 0.14159077f, -0.17638859f, -0.02757946f, 0.09434669f, 
    0.09723705f, -0.15600172f, -0.14093544f, 0.10053859f, -0.04470214f, -0.04205431f, -0.13511905f, 0.10522545f, 
    -0.00281326f, -0.03802524f, 0.09874050f, -0.15806949f, 0.02841390f, 0.08116151f, -0.06133631f, -0.15866017f, 
    -0.26709664f, -0.08239539f, 0.17016131f, -0.02737121f, 0.23817234f, -0.14878345f, -0.00693997f, 0.08940071f, 
    0.01736984f, 0.14261563f, 0.00117464f, -0.05224074f, 0.16938467f, 0.16995218f, 0.10406171f, 0.16144039f, 
    0.35994107f, 0.19691831f, 0.29063720f, 0.01865784f, 0.04881078f, -0.13612977f, 0.19075620f, -0.15997823f, 
    -0.14138305f, 0.10046379f, 0.03697967f, -0.22224791f, -0.08968706f, -0.23900080f, 0.16546898f, -0.36854494f, 
    -0.10490269f, -0.17035057f, 0.15636520f, 0.31723237f, -0.26109809f, 0.10199435f, 0.26370731f, 0.06919119f, 
    -0.16913417f, 0.04288632f, 0.51022238f, 0.02834956f, -0.04090734f, 0.12486022f, 0.10346590f, -0.11800987f, 
    -0.26020685f, -0.24557650f, -0.08271233f, 0.11099248f, 0.09844577f, 0.41698256f, -0.01433639f, 0.34083650f, 
    -0.09596231f, 0.24958454f, -0.14441009f, -0.21019574f, -0.09836520f, 0.10165446f, 0.35301229f, 0.13422580f, 
    0.02625894f, 0.02471412f, -0.01704481f, 0.10712185f, -0.26538584f, -0.12944889f, -0.29242015f, -0.07950738f, 
    0.13982911f, 0.09943847f, -0.32837662f, 0.07837994f, -0.13342848f, -0.20030613f, -0.08131714f, -0.03700772f, 
    -0.04306381f, 0.26700905f, -0.46114171f, 0.16201226f, -0.14570014f, 0.01322667f, 0.21658714f, -0.11417194f, 
    -0.28973153f, 0.42100888f, 0.11068060f, 0.01309073f, -0.00287966f, 0.05953809f, 0.42119116f, 0.06499662f, 
    -0.17933106f, -0.07799760f, -0.01818315f, 0.24468251f, 0.17440541f, 0.14886518f, 0.06440041f, 0.05356980f, 
    0.12445567f, 0.18774532f, -0.39583391f, 0.10957175f, 0.01573195f, -0.32566696f, -0.05079835f, -0.08954947f, 
    0.31020230f, -0.07354171f, -0.21581969f, -0.07704059f, -0.12266672f, -0.25301719f, 0.36317363f, -0.24890260f, 
    0.53234935f, 0.34484956f, 0.17133769f, -0.34907541f, 0.12609316f, 0.00357677f, -0.01040433f, 0.02769608f, 
    0.25695679f, -0.14726281f, 0.07696703f, 0.00825480f, -0.21961045f, -0.17065465f, 0.22330232f, 0.03048329f, 
    -0.14124976f, 0.25838190f, -0.11037507f, 0.17039032f, 0.16393687f, 0.29418722f, 0.18210474f, -0.17214024f, 
    -0.16380769f, -0.20368698f, 0.26231667f, -0.13342346f, 0.00972175f, -0.09909251f, -0.07417306f, 0.10691017f, 
    0.34315622f, 0.14982814f, -0.16302097f, 0.31854451f, -0.01128179f, -0.39768279f, 0.25173944f, -0.16570188f, 
    0.26070371f, -0.00313765f, 0.06668170f, 0.06518811f, 0.03259224f, 0.17096449f, 0.16850898f, -0.08296892f, 
    0.16985354f, -0.10215303f, 0.03471536f, -0.08590981f, -0.05707191f, 0.40388077f, -0.00361429f, 0.04253471f, 
    -0.13495025f, -0.04174107f, -0.18566339f, -0.01462997f, 0.06718991f, -0.11762346f, -0.10977482f, 0.04625881f, 
    -0.33710593f, 0.31024379f, 0.03995152f, 0.13006809f, 0.20420556f, 0.03371004f, 0.36779127f, 0.61727744f, 
    -0.26808757f, 0.17109115f, 0.04691716f, 0.33584282f, 0.14286961f, -0.12951264f, -0.19160284f, 0.04598908f, 
    0.01558439f, 0.00084871f, -0.10237223f, -0.12882774f, -0.02256879f, -0.39227459f, 0.14243007f, -0.15456896f, 
    0.24105942f, 0.21840835f, -0.08654027f, 0.11625694f, 0.07413370f, 0.19818561f, 0.12345345f, 0.35066986f, 
    0.01444674f, -0.32587352f, -0.11337680f, 0.32083416f, 0.40990150f, 0.08792982f, -0.12689601f, 0.36645433f, 
    0.22175883f, 0.10227067f, -0.13727717f, -0.15564945f, -0.06946646f, -0.03197577f, 0.02134331f, 0.08866498f, 
    0.12171652f, 0.32866627f, -0.24817178f, -0.16703485f, 0.02097640f, 0.05664335f, -0.16221534f, -0.05199043f, 
    -0.08266336f, 0.04901629f, 0.23520888f, 0.04882684f, 0.12495351f, 0.10166265f, 0.13454808f, 0.08870436f, 
    -0.15733778f, -0.06101251f, -0.12467035f, -0.21248282f, -0.29403120f, 0.13090560f, 0.12096410f, -0.31461924f, 
    0.39591530f, 0.15924874f, 0.08058106f, -0.19930799f, -0.04694851f, -0.06672998f, 0.02080011f, -0.06766105f, 
    -0.15968947f, 0.04539062f, -0.37976480f, -0.00337097f, -0.13793811f, -0.24359567f, -0.17456371f, 0.17468719f, 
    0.21309030f, 0.14179443f, -0.23426902f, -0.05438928f, 0.14430720f, -0.35826400f, 0.36903334f, -0.26470628f, 
    0.55994445f, 0.32412800f, 0.08555827f, 0.04843230f, 0.11567073f, -0.17336319f, -0.09831407f, 0.17106752f, 
    -0.06760059f, -0.15018298f, 0.02789165f, -0.14498328f, 0.37417942f, 0.02031893f, 0.04508087f, -0.16600929f, 
    -0.15857737f, 0.19379815f, 0.43064550f, -0.12019896f, 0.07454728f, -0.27987462f, 0.03101654f, -0.05054104f, 
    0.11515368f, -0.33676189f, -0.04092568f, -0.15518287f, 0.06350803f, 0.19075856f, 0.10905556f, 0.23634784f, 
    0.12502828f, -0.16504002f, 0.01957468f, 0.01935406f, 0.27258107f, 0.26622534f, 0.10525540f, -0.13312458f, 
    0.27380136f, -0.10503795f, -0.12079882f, 0.04843976f, -0.06437496f, 0.02992212f, -0.00861866f, -0.13337208f, 
    0.07200410f, -0.16165270f, 0.26492724f, 0.16854459f, 0.14682385f, -0.06042518f, 0.11841138f, 0.10408319f, 
    -0.20610185f, 0.38827625f, -0.03019076f, -0.06845067f, -0.07964202f, 0.51625001f, -0.00717657f, 0.31063977f, 
    0.04272678f, -0.01245586f, -0.12538593f, 0.12067059f, 0.15624101f, 0.37432995f, -0.07062641f, 0.02889801f, 
    -0.16631415f, -0.14697039f, -0.07815254f, 0.43197665f, 0.02395554f, 0.17120948f, -0.10929994f, 0.03115174f, 
    -0.01140473f, 0.13053936f, -0.20585433f, 0.12908033f, 0.07113386f, 0.01998305f, 0.02604146f, -0.05878395f, 
    0.18516538f, -0.04301187f, -0.41356984f, -0.01065947f, -0.07435384f, 0.01061752f, -0.00449309f, 0.13118285f, 
    0.16651149f, -0.06973010f, -0.01298938f, 0.25231975f, 0.10272063f, -0.45761555f, 0.26813149f, -0.15310870f, 
    0.31782112f, 0.04176529f, 0.04653944f, -0.23091325f, 0.05415783f, 0.01823404f, -0.10180904f, -0.15808818f, 
    0.14371461f, 0.14393857f, 0.11762435f, -0.07909574f, -0.00480504f, -0.28471750f, 0.10920843f, 0.00056799f, 
    0.22546947f, 0.20269713f, 0.09740100f, 0.03967992f, -0.06398091f, 0.24006584f, 0.13929708f, 0.22352907f, 
    0.03003651f, -0.32290560f, -0.17325968f, 0.29132330f, 0.28283677f, -0.07386404f, -0.23033279f, -0.16458718f, 
    -0.14186543f, -0.12677772f, -0.13872653f, -0.12105612f, -0.11106712f, 0.09392798f, 0.06140703f, -0.05231636f, 
    -0.12486994f, -0.05754636f, -0.16251710f, -0.16378614f, -0.13993558f, -0.02414389f, -0.08216317f, -0.12598468f, 
    -0.15554503f, -0.12951539f, 0.14570905f, -0.01391602f, -0.15255733f, -0.12706564f, 0.01452307f, 0.01078801f, 
    -0.06753710f, -0.02104419f, 0.02392540f, 0.01858606f, -0.01443751f, -0.14130656f, -0.05276410f, 0.04612532f, 
    0.06522870f, -0.09092087f, -0.03209535f, 0.35328075f, 0.06248170f, -0.05770695f, 0.39364761f, 0.06551069f, 
    0.13550325f, 0.14344239f, -0.37886626f, -0.12482779f, -0.03057848f, -0.15579617f, 0.12555994f, -0.04914335f, 
    0.02241035f, 0.15717416f, 0.30801669f, 0.09087116f, -0.08089421f, -0.16085769f, 0.06497747f, 0.12140609f, 
    0.45992145f, -0.02590813f, -0.01640441f, -0.52441484f, -0.24080488f, 0.29735640f, -0.35439670f, -0.18968025f, 
    0.03821709f, 0.09400529f, 0.06459371f, 0.05097650f, 0.01217591f, -0.03677738f, -0.17649092f, 0.14155398f, 
    0.00209234f, 0.03642317f, 0.14866504f, -0.06457793f, 0.05730589f, -0.24577855f, -0.15441187f, -0.03523822f, 
    -0.00102566f, 0.06112009f, -0.16904682f, -0.15883368f, -0.05456394f, 0.52715522f, -0.10778324f, 0.00984950f, 
    -0.39113081f, 0.05080681f, -0.02536095f, 0.16780743f, 0.04043832f, 0.44592986f, 0.08364719f, 0.38308296f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09786491f, -0.11191095f, 0.20741917f, 0.14127406f, 0.08728096f, 0.16099522f, 0.10267036f, -0.13011250f, 
    -0.14329506f, 0.20215562f, -0.07696628f, 0.14062151f, 0.08179891f, 0.05167105f, 0.04855257f, -0.09091391f, 
    -0.12396028f, -0.11358720f, 0.00432304f, 0.23825055f, 0.20664395f, 0.05708082f, -0.10751759f, 0.08759872f, 
    0.04973244f, 0.06062907f, 0.12852536f, 0.12129571f, 0.03899861f, -0.14781491f, 0.19849358f, 0.10183726f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.11979576f, 0.36548033f, -0.01579338f, -0.64219922f, 0.15475529f, -0.39516819f, -0.12631378f, -0.02900168f, 
    -0.10105440f, -0.87268502f, -0.11722153f, -0.16337818f, -0.12317982f, 0.22397585f, 0.30628464f, 0.07888859f, 
    0.30619961f, 0.15991999f, 0.21858492f, 0.17715687f, -0.22249426f, -0.26716757f, 0.03397830f, 0.07211783f, 
    -0.21890126f, 0.10646857f, 0.08169061f, 0.24390978f, -0.06765891f, 0.08171459f, 0.02025949f, 0.07597781f, 
    0.07273088f, -0.02754461f, 0.18257996f, -0.21682779f, 0.06846252f, -0.40040255f, 0.14503203f, 0.09344324f, 
    0.04361098f, 0.12346079f, -0.17515877f, 0.10833665f, 0.07628056f, -0.16157497f, -0.09299441f, 0.11283575f, 
    0.24453716f, 0.09930748f, 0.20148291f, 0.40102854f, 0.00958368f, 0.11869325f, -0.21133304f, 0.10397960f, 
    0.16184403f, -0.12170748f, -0.51675773f, 0.03540886f, -0.55815572f, -0.14134993f, 0.30016604f, -0.31868243f, 
    -0.14880680f, -0.15858404f, -0.26887432f, -0.24070311f, -0.01048753f, 0.13266417f, -0.17249151f, -0.02610523f, 
    0.12601191f, -0.09708479f, -0.13421412f, 0.32551125f, -0.01841417f, -0.59596533f, 0.11096429f, -0.14081000f, 
    0.02877086f, -0.16719830f, -0.27236843f, 0.32730299f, 0.02472227f, -0.53979808f, 0.01529514f, -0.06841501f, 
    0.13968551f, 0.11508629f, -0.15460698f, -0.03355850f, 0.31877878f, -0.03806160f, 0.31120408f, -0.54646277f, 
    0.22141436f, -0.28184447f, 0.26810107f, -0.31395569f, -0.04208681f, 0.31722692f, -0.16062205f, -0.08030286f, 
    0.03069516f, 0.25383967f, -0.08044636f, -0.82816547f, -0.19012952f, -0.20879522f, 0.21041590f, -0.05683295f, 
    -0.14816262f, -0.01421326f, 0.13326970f, 0.19410466f, -0.24272563f, 0.03429594f, -0.08664010f, -0.00173244f, 
    -0.19289391f, 0.27669847f, -0.04411321f, -0.20151401f, -0.09426294f, 0.05055967f, -0.77642262f, 0.35898280f, 
    -0.22741839f, 0.04240160f, -0.03148122f, -0.21895157f, 0.13319300f, -0.04614200f, 0.02167643f, -0.08990464f, 
    -0.14769423f, -0.32437778f, -0.05209505f, -0.01391706f, 0.09116649f, -0.30039662f, -0.09221820f, -0.09167031f, 
    -0.56830215f, 0.21651056f, 0.10721080f, -0.14228086f, 0.15046270f, 0.18359205f, 0.17966627f, -0.19994609f, 
    0.06015920f, 0.19331017f, 0.09831245f, 0.25298470f, 0.08509978f, 0.01906369f, -0.54541653f, 0.22580132f, 
    -0.34295228f, -0.02220350f, 0.17713061f, 0.41932771f, -0.10543945f, 0.08923154f, -0.17214824f, 0.11335046f, 
    0.10415301f, -0.14518093f, -0.07039177f, -0.21543054f, 0.09757705f, 0.24713522f, 0.01898551f, 0.03085538f, 
    -0.10577562f, 0.30681348f, -0.04874796f, -0.01344702f, 0.23430914f, 0.11571113f, -0.38590795f, -0.13796696f, 
    -0.23843856f, -0.23974837f, -0.09090914f, 0.18327394f, -0.63140267f, 0.15682323f, 0.02459609f, -0.21210510f, 
    0.38071850f, -0.28580418f, -0.63851786f, 0.23620506f, -0.03653786f, 0.25624529f, -0.18065904f, 0.01139248f, 
    -0.18468037f, -0.19615604f, 0.09848146f, 0.05965919f, 0.12563953f, -0.16084556f, -0.14258164f, -0.12582278f, 
    0.34546328f, -0.09916467f, -0.23153783f, -0.33438814f, 0.32220688f, -0.06249768f, -0.43630138f, 0.32503253f, 
    -0.52092981f, 0.22827758f, -0.31837094f, -0.02046857f, 0.19366406f, 0.12942776f, -0.27315059f, -0.23156856f, 
    0.07345100f, -0.15709893f, -0.26421207f, -0.18943332f, 0.09316215f, 0.03443442f, -0.08241445f, 0.12728468f, 
    -0.17304905f, 0.31156218f, 0.04249049f, -0.07546379f, 0.11412711f, -0.01500233f, -0.66806757f, -0.10029120f, 
    -0.05227103f, 0.00936893f, -0.42311135f, -0.46444240f, -0.57693303f, 0.16679521f, 0.31600130f, -0.47870049f, 
    -0.30955461f, 0.21579836f, 0.26557234f, -0.38707227f, 0.24921867f, -0.15292887f, -0.15311123f, 0.24629334f, 
    -0.37848586f, -0.32828641f, 0.04011207f, 0.05299631f, -0.04600512f, 0.10836235f, -0.07627607f, -0.10353325f, 
    -0.08511438f, -0.03977763f, -0.05479891f, -0.10419563f, -0.06434201f, -0.12380061f, 0.40004930f, -0.03635351f, 
    0.04341916f, -0.51434672f, 0.34693754f, 0.15747197f, -0.02195699f, 0.09159754f, -0.42210847f, 0.03577573f, 
    0.51401627f, -0.56396925f, 0.12158960f, -0.34960374f, 0.13060598f, 0.13376389f, -0.15323775f, -0.02342816f, 
    -0.41049883f, -0.59707010f, -0.18330096f, 0.16749230f, 0.13826971f, 0.12238806f, -0.01641408f, 0.16197652f, 
    0.12989531f, -0.21482122f, -0.14141458f, 0.13293822f, -0.04285121f, -0.24188797f, 0.05341180f, 0.02900530f, 
    -0.27093825f, 0.14475134f, -0.29219830f, -0.20732203f, -0.06297682f, -0.11745781f, 0.01211110f, 0.23336014f, 
    -0.68438387f, -0.07502485f, 0.28588015f, -0.35524392f, 0.14567873f, 0.00827775f, 0.50877357f, 0.23807843f, 
    0.11028028f, -0.73549211f, 0.14976782f, 0.21359015f, -0.08294091f, 0.22928444f, 0.02188065f, -0.00930034f, 
    0.12763382f, 0.23484077f, 0.03676627f, -0.54181772f, -0.03982544f, 0.19555721f, -0.29070503f, 0.06196036f, 
    0.09833241f, -0.47308081f, -0.45324019f, 0.30471385f, -0.05847684f, -0.16706826f, 0.17986661f, -0.16352494f, 
    0.29323032f, 0.14843680f, -0.28276339f, 0.17709875f, 0.09686480f, 0.03156236f, 0.01395274f, -0.25219473f, 
    0.17776296f, -0.45308596f, -0.50937670f, 0.32498240f, -0.06014701f, -0.31203490f, -0.03359484f, 0.05012044f, 
    -0.15337276f, 0.05821767f, -0.00272850f, 0.05644475f, 0.09538794f, 0.37871778f, 0.04219828f, -0.05986749f, 
    0.20847565f, -0.30274859f, 0.28984597f, 0.09786799f, -0.09203073f, -0.10969850f, 0.39085782f, -0.12264767f, 
    0.00774880f, -0.30941704f, -0.16717207f, 0.40114799f, -0.04847381f, 0.05705882f, -0.34388867f, 0.11632366f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.05971434f, -0.01091634f, -0.09371332f, -0.12232570f, -0.15542623f, 0.18739264f, 0.19099517f, -0.11322147f, 
    0.00155044f, 0.11968247f, -0.04485062f, 0.08220318f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
