#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.21454251f, -0.96570611f, 1.55280483f, -0.97282225f, -0.90067208f, -0.92811346f, 0.56275767f, -0.39815396f, 
    0.00551027f, -0.45570341f, -0.60867453f, 0.53238004f, 0.44782618f, 0.33180478f, 0.83457351f, 0.01892382f, 
    0.03625483f, -0.01891148f, 0.06822226f, 1.53467810f, -0.37686113f, -0.94749165f, -0.08266617f, -0.28397146f, 
    -0.03077004f, 0.31839269f, 0.85150474f, -0.64531702f, -1.76978672f, -0.60121733f, 1.15537322f, 0.76165754f, 
    0.39132062f, -0.39659199f, -0.64716333f, -0.09153102f, 1.44964361f, -1.59868813f, 0.32049939f, -1.03240585f, 
    -0.53650719f, -0.87832135f, -0.57894552f, -0.12753277f, -0.76541620f, 0.91486907f, 0.51833659f, 0.54382443f, 
    -0.34742361f, -0.13929982f, 0.36598909f, 0.08415318f, 0.47831088f, 0.29597211f, -0.61139441f, 0.04830081f, 
    0.58520484f, 0.76742905f, 0.85872918f, -0.51189625f, -0.55394328f, 0.19477357f, -0.34439173f, -0.56428707f, 
    -1.17765784f, -0.95587820f, -1.40175092f, -1.48402190f, -0.88753897f, 0.13395122f, 0.06194999f, -0.16494566f, 
    -1.76893771f, 1.11540389f, 1.04472196f, -1.07750654f, -0.24919990f, 0.20654546f, -0.84863126f, -0.40266240f, 
    -0.57007194f, -0.77109683f, 0.25106788f, 0.73623514f, 0.76540208f, 0.15539527f, -0.17036316f, 0.36527589f, 
    0.07934426f, -0.04504087f, 0.71469617f, 0.00831382f, -0.19602446f, 0.57358897f, 0.75318557f, -0.27878767f, 
    -0.10429147f, 0.03932987f, 0.13603154f, 0.94140869f, 0.80329543f, -0.86618692f, -0.63000870f, -0.06700176f, 
    0.90907049f, -0.48068875f, -0.44162309f, -0.21822678f, 0.78224456f, -0.37578800f, -0.59315944f, -0.25158438f, 
    0.63798410f, -0.88538891f, 0.24618816f, 0.16566643f, 0.62040538f, 0.34719649f, -0.05251651f, 0.20450324f, 
    -0.86115211f, 1.01389289f, 0.40938070f, -0.17444369f, -0.43790054f, -0.11319841f, -0.94144315f, -1.01762724f, 
    -0.92103261f, 0.37953302f, 1.14958632f, 0.35215816f, 0.39102003f, 0.73111343f, -0.14938827f, 1.23267221f, 
    0.44411692f, -0.35892853f, 0.55247158f, 0.08221507f, 0.10415944f, 0.09914814f, -0.64433575f, -0.54102176f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.64550978f, -0.32012787f, 0.15977503f, 0.14493077f, 0.08755073f, -0.10553217f, 0.35438931f, -0.13817084f, 
    0.20568983f, 0.48289618f, 0.11647907f, 0.52439135f, 0.47978017f, 0.54298532f, 0.05030702f, 0.35601911f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.61528170f, 0.42203152f, 0.23760675f, -0.83804685f, -0.04615808f, 0.04176339f, 0.07618556f, -0.01745701f, 
    0.00121397f, 0.10878203f, 0.07335527f, -0.09027876f, -0.03240108f, -0.04065298f, -0.05485508f, -0.01076901f, 
    -0.01106197f, -0.10549198f, -0.03723338f, -0.12194520f, -0.09812398f, -0.08572686f, 0.03525719f, -0.03312879f, 
    0.08705097f, -0.02464490f, 0.06036612f, 0.08206273f, 0.07413091f, 0.06002655f, 0.04175452f, -0.16023442f, 
    -0.01122515f, -0.05196175f, -0.10138334f, 0.02367107f, 0.11429545f, 0.10860748f, 0.01083588f, -0.00229611f, 
    -0.01832557f, -0.04842480f, -0.22460939f, 0.05611088f, -0.22826311f, 0.06174714f, -0.57763952f, -0.13875495f, 
    0.05448274f, 0.08007148f, 0.01230645f, 0.02987653f, -0.05595683f, -0.00111560f, 0.04272804f, -0.01575029f, 
    -0.11906828f, -0.07840843f, -0.12716991f, -0.27432415f, 0.71803236f, -0.17054865f, -0.46878546f, -0.21351860f, 
    -0.14588878f, 0.19768114f, 0.24711218f, 0.21001688f, -0.29308072f, -0.03657373f, 0.00754524f, 0.09460036f, 
    -0.03667593f, -0.12716408f, 0.00580328f, 0.01306206f, 0.13367794f, 0.09555606f, 0.02184116f, 0.05120052f, 
    0.27507290f, 0.33783573f, 0.31039327f, -0.74742323f, 0.06933349f, 0.08395154f, -0.09240247f, 0.29222643f, 
    -0.24832140f, 0.16916740f, -0.09101760f, -0.07197926f, -0.13181312f, -0.02560882f, 0.00566963f, 0.02744140f, 
    -0.07555309f, -0.00813351f, 0.13954739f, 0.31002456f, -0.06255942f, -0.02815391f, -0.10837051f, 0.05407551f, 
    0.04834290f, 0.04821130f, 0.07583532f, -0.00545553f, 0.04567752f, 0.07654986f, -0.07606871f, 0.06690282f, 
    0.07783725f, -0.02272187f, 0.07027739f, -0.09203816f, -0.22314417f, -0.11115616f, 0.02101340f, -0.01020467f, 
    0.23216060f, -0.02030914f, -0.46754825f, -0.27560461f, -0.23747902f, 0.03830248f, -0.03478681f, 0.06988068f, 
    0.10643371f, 0.04598672f, -0.20642576f, 0.09222743f, 0.08144186f, 0.01253865f, -0.02840053f, -0.09850230f, 
    0.03545690f, -0.07378057f, 0.04447988f, 0.16711470f, 0.60810196f, 0.58725435f, 0.23569271f, -0.56110173f, 
    -0.25149408f, 0.17406021f, 0.21164310f, 0.05879074f, -0.10196906f, 0.10821641f, 0.05366355f, 0.00320167f, 
    -0.08944937f, 0.01411143f, 0.01706314f, -0.07567546f, -0.07466354f, -0.03080688f, 0.01699024f, 0.01400840f, 
    -0.38874164f, 0.37360072f, 0.46878597f, -0.16442773f, 0.18085974f, -0.39147925f, -0.39248472f, -0.13678867f, 
    -0.08963148f, -0.18327720f, 0.01453240f, -0.12038323f, -0.08362808f, -0.03753342f, 0.01318428f, -0.05855224f, 
    0.02476906f, -0.00185561f, -0.15520523f, -0.05480866f, -0.00754370f, -0.00272019f, -0.01131402f, -0.08224278f, 
    0.06803589f, -0.11941355f, -0.02548892f, 0.04367875f, 0.06562725f, 0.04812125f, -0.21842445f, -0.14482789f, 
    -0.45501292f, -0.22032002f, -0.18134208f, -0.05390413f, 0.02442830f, -0.05078479f, -0.01809484f, 0.07731175f, 
    -0.07143356f, -0.23944570f, -0.18166986f, 0.08556543f, 0.07275815f, 0.07844221f, 0.01295663f, 0.03176932f, 
    0.02771750f, 0.06400073f, -0.11186527f, -0.07984503f, -0.03405312f, -0.03636485f, -0.15356164f, -0.18220021f, 
    0.01336348f, -0.08781839f, -0.06387056f, -0.00345446f, -0.74893844f, -0.01295188f, -0.10798408f, 0.03490545f, 
    -0.54544556f, 0.05468718f, -0.01558283f, -0.11035944f, 0.06487732f, 0.01813780f, 0.07454885f, -0.05081769f, 
    -0.03433047f, 0.02505933f, 0.00441180f, 0.14472139f, 0.20127280f, -0.18417487f, 0.00816969f, -0.24089688f, 
    0.06656952f, 0.13726403f, -0.27082098f, -0.01052752f, -0.11730791f, -0.04865762f, 0.03227002f, 0.02027244f, 
    -0.03771988f, 0.02946344f, -0.17603220f, 0.08255538f, -0.22938740f, -0.03592294f, 0.00690804f, -0.14712907f, 
    -0.10206376f, -0.21561025f, -0.23347954f, -0.14706276f, -0.46954125f, -0.88299751f, 0.36829454f, -0.26107317f, 
    -0.61562580f, -0.02790711f, 0.00410443f, -0.07171948f, 0.04750292f, 0.13856930f, -0.04033191f, 0.04477876f, 
    -0.08547689f, 0.05176686f, 0.01708593f, -0.22966619f, -0.01281426f, -0.02066463f, -0.27878574f, -0.02437107f, 
    0.15974778f, 0.13073029f, -0.23525544f, 0.05453832f, 0.07904402f, 0.27808073f, 0.10393939f, 0.12648445f, 
    -0.03025585f, -0.03955637f, -0.00661565f, 0.02010859f, -0.11406332f, 0.15354046f, 0.03157563f, 0.07974013f, 
    0.10153594f, -0.06570765f, -0.04055726f, 0.05436781f, -0.67257977f, -0.42271954f, -0.41375878f, -0.06849656f, 
    -0.59083360f, 0.08673240f, 0.02611844f, 0.06166138f, 0.09833810f, 0.07363762f, 0.01525160f, 0.06845901f, 
    -0.06279635f, 0.04674149f, 0.02082620f, -0.01714795f, -0.01259535f, 0.16070503f, 0.11637246f, 0.04012958f, 
    -0.43730447f, 0.29386619f, -0.21056168f, -0.31263345f, 0.48576504f, -0.07615815f, 0.05401292f, -0.11145967f, 
    0.28649443f, 0.05255418f, -0.01717039f, 0.11052654f, 0.17745173f, -0.11119172f, 0.00947024f, 0.01633077f, 
    0.02151905f, 0.17627396f, -0.11486953f, -0.05901967f, -0.00411835f, -0.29110849f, -0.07931986f, 0.13497801f, 
    -0.04279983f, -0.11054256f, -0.06128258f, 0.00494179f, -0.08443279f, -0.00202722f, 0.00608956f, 0.02327770f, 
    -0.22201945f, -0.08309832f, -0.02534515f, -0.00378187f, -0.05665864f, -0.07618839f, -0.00821142f, -0.08975628f, 
    0.01394390f, -0.21228389f, -0.06339864f, -0.22236714f, -0.14717367f, -0.01848620f, -0.06070152f, -0.35649028f, 
    -0.03220980f, 0.04135443f, -0.01971080f, -0.05811343f, 0.11151996f, 0.30350727f, -0.01952363f, -0.09279504f, 
    0.06357978f, -0.18900698f, 0.12272433f, 0.09180354f, 0.52624321f, -0.08139735f, 0.27228954f, 0.10052095f, 
    -0.41188550f, 0.05056366f, -0.00176618f, 0.05269057f, 0.03078937f, -0.27620754f, 0.17474701f, -0.24120776f, 
    0.00911103f, -0.15890887f, -0.08296574f, 0.11248337f, 0.00304722f, -0.12522349f, -0.01875814f, -0.02913538f, 
    -0.11681338f, 0.34710228f, -0.40598774f, -0.27546102f, -0.16595632f, -0.04240003f, -0.00340331f, -0.23469432f, 
    -0.09152815f, 0.00868210f, -0.08955783f, 0.04960428f, -0.09637371f, -0.00841362f, -0.00235612f, -0.05011857f, 
    -0.18328273f, -0.03274662f, -0.27095827f, -0.37124053f, 0.10579646f, -0.01613919f, 0.08879717f, -0.03335139f, 
    0.11786041f, -0.05784215f, -0.10525482f, -0.07969443f, -0.10322039f, 0.00887509f, 0.02430522f, 0.05524383f, 
    0.02148679f, 0.10505760f, -0.05333376f, -0.18062897f, 0.14706902f, -0.08902226f, 0.01567937f, -0.00258427f, 
    0.14024591f, -0.33531192f, 0.04277074f, 0.15360555f, 0.27981025f, -0.06559487f, 0.08310956f, 0.03917955f, 
    0.07767380f, 0.03903453f, 0.14662407f, 0.00117857f, 0.08442511f, -0.10958609f, 0.10347786f, 0.19324394f, 
    -0.23176169f, 0.02949215f, -0.02174994f, -0.11778897f, -0.07934870f, 0.51786387f, 0.09641144f, 0.41814587f, 
    0.27275199f, -0.00089370f, 0.10653927f, -0.01877208f, -0.03676143f, -0.16212133f, -0.07736826f, -0.00288175f, 
    -0.00222054f, 0.02330462f, 0.14312139f, 0.07074604f, -0.02452843f, 0.11640946f, -0.29980576f, 0.08570792f, 
    -0.82119930f, -0.61230093f, -0.11351907f, -0.51648360f, -0.26261786f, 0.24847457f, -0.08761986f, -0.21237281f, 
    -0.13195252f, -0.04393693f, 0.11907658f, 0.11623014f, -0.01656637f, -0.07016477f, -0.00898005f, -0.12608188f, 
    -0.17429218f, -0.25794592f, -0.24111313f, -0.16246471f, 0.08084197f, -0.07132862f, -0.00527147f, 0.15084286f, 
    0.19724666f, 0.03198815f, -0.03315678f, 0.00821118f, 0.01872310f, 0.01525905f, -0.04962625f, 0.07043662f, 
    0.02377082f, 0.14580093f, 0.14106560f, -0.15253091f, -0.17971507f, 0.13712232f, 0.01011922f, -0.18882847f, 
    0.31792325f, -0.01798344f, -0.04567172f, 0.15917733f, 0.04765971f, -0.04281849f, -0.05647140f, 0.07913353f, 
    0.02599495f, -0.05231724f, 0.02123400f, 0.04142437f, -0.02140395f, -0.03575731f, 0.08004574f, 0.07297901f, 
    -0.06548390f, -0.22712514f, 0.03137989f, -0.05592886f, 0.45253640f, 0.20759144f, 0.35696051f, 0.33852917f, 
    -0.16517456f, -0.06167044f, -0.09645522f, 0.09201881f, -0.15873824f, 0.01981109f, -0.03223177f, 0.09030691f, 
    -0.07265762f, 0.12960425f, -0.00618834f, -0.13640264f, -0.12716511f, 0.01626644f, 0.13945165f, 0.00431693f, 
    0.12282505f, -0.14062497f, -0.22336140f, -0.04547890f, -0.09894025f, 0.03289763f, 0.01503254f, 0.08204143f, 
    0.09994776f, -0.02663044f, 0.23134352f, 0.11273956f, 0.22397827f, 0.06151989f, 0.05477391f, -0.11708883f, 
    -0.01511682f, 0.07863956f, 0.18557888f, 0.02460234f, 0.33628669f, -0.07374793f, 0.10803329f, 0.17999279f, 
    0.18954630f, -0.10113051f, -0.03547831f, 0.06767062f, 0.04793366f, 0.06927773f, -0.05421613f, -0.04814173f, 
    -0.07624345f, -0.06735558f, 0.07540845f, 0.15990454f, 0.09074990f, -0.13480040f, 0.12446218f, 0.03940250f, 
    0.15815237f, -0.37295470f, -0.28514773f, -0.06034235f, -0.14795658f, -0.14604440f, 0.11606536f, 0.06629463f, 
    0.06884044f, -0.06927866f, -0.08761414f, 0.12102523f, -0.03353312f, -0.04372137f, -0.05632305f, -0.08375976f, 
    -0.06347372f, -0.12351627f, 0.04443233f, -0.01736052f, 0.58962876f, 0.06405000f, -0.03784609f, 0.05272030f, 
    -0.04049224f, -0.02061741f, -0.11978603f, 0.03933793f, -0.06839527f, 0.00213884f, -0.03712387f, -0.00504193f, 
    0.08716016f, -0.03287955f, 0.11100829f, 0.07974844f, -0.17079444f, 0.02391716f, 0.23517242f, 0.05705808f, 
    0.72632885f, -0.16520013f, -0.52006918f, 0.08029121f, 0.16809992f, 0.01709933f, 0.17010474f, -0.22438063f, 
    0.21783866f, 0.20221476f, -0.03352882f, -0.03122854f, 0.09091475f, 0.06035371f, -0.22379485f, -0.01089303f, 
    0.07788097f, 0.09065040f, -0.21283914f, 0.07048908f, 0.11844326f, -0.31274688f, -0.01485080f, 0.00822941f, 
    0.20960085f, -0.00558836f, -0.00819218f, 0.02953690f, -0.03953935f, 0.00376630f, 0.10972659f, -0.11176427f, 
    -0.01489446f, -0.20306806f, -0.17438404f, -0.04149805f, -0.05496535f, 0.13474992f, -0.16051295f, -0.02997944f, 
    -0.03560525f, -0.29698089f, 0.15185559f, -0.10548453f, 0.17136547f, -0.02265977f, -0.15452494f, -0.41502598f, 
    -0.16041781f, -0.01556471f, 0.01138620f, -0.13971446f, -0.01940263f, -0.01937893f, -0.04393510f, 0.11419227f, 
    -0.22355168f, -0.25322324f, -0.02910281f, -0.10294262f, -0.30829364f, 0.02271730f, 1.64517486f, 0.41780347f, 
    0.34365287f, -0.37570781f, -0.08745302f, 0.17197049f, -0.18140073f, 0.05351792f, 0.12748684f, 0.06960176f, 
    0.14401871f, -0.29725766f, 0.08228047f, -0.08786474f, 0.09601124f, 0.06341103f, 0.03052848f, -0.09131766f, 
    -0.75377417f, 0.21985692f, -0.22491241f, 0.41830027f, -1.13008118f, -0.13621859f, -0.06243672f, -0.44607642f, 
    -0.04936692f, -0.03902448f, 0.01032591f, 0.00669206f, -0.05415031f, -0.04680026f, -0.05963673f, 0.00875548f, 
    0.04478056f, 0.02823015f, 0.13389605f, 0.20442934f, -0.32612872f, -0.01262753f, 0.14021482f, -0.15862906f, 
    0.08883556f, -0.05774345f, -0.05027047f, -0.03061590f, 0.00087716f, 0.13574451f, 0.01509630f, -0.12258451f, 
    -0.09161383f, 0.04825933f, -0.12406923f, -0.21125272f, -0.29180476f, -0.12218191f, -0.09782212f, -0.07114118f, 
    0.02404587f, 0.14370500f, -0.45429704f, -0.19836238f, 0.17170589f, 0.12169151f, 0.02075693f, -0.01993583f, 
    0.13329427f, -0.06126934f, 0.06046301f, -0.07401894f, 0.07942540f, -0.22489943f, 0.04457689f, 0.15338071f, 
    0.04747128f, 0.01815328f, 0.11855665f, 0.01178273f, -0.85094863f, -0.83391428f, -0.86095941f, 0.40853310f, 
    -0.79344255f, -0.03145879f, -0.06300326f, -0.11740647f, -0.08947348f, -0.04686430f, -0.02720791f, 0.01087938f, 
    0.03981537f, 0.05211452f, -0.06603843f, -0.09432156f, -0.04024645f, -0.05020573f, -0.15928371f, 0.16615896f, 
    0.57280219f, 0.30837911f, -0.10558701f, 0.05828480f, 0.41723084f, -0.16185011f, 0.21089469f, -0.04634848f, 
    0.07079057f, 0.06228534f, -0.04349185f, -0.01569953f, 0.00648722f, 0.02167891f, -0.01638149f, 0.07700287f, 
    0.12248843f, 0.10909428f, 0.06030548f, 0.27271739f, 0.35600936f, 0.05294959f, 0.03762822f, -0.09520741f, 
    0.20039366f, 0.16453467f, -0.10563881f, -0.01381798f, 0.12085809f, 0.06438635f, -0.26694673f, -0.04233889f, 
    0.24266221f, 0.14333458f, -0.08314937f, 0.10329489f, -0.02357596f, -0.01000587f, 0.09999765f, -0.03461773f, 
    -0.07670259f, 0.03599271f, -0.03986073f, -0.22138096f, 0.08012863f, 0.00398121f, -0.12204216f, -0.00868822f, 
    0.03956941f, 0.03543192f, -0.06165553f, 0.00502511f, 0.14768030f, -0.04375102f, 0.15130748f, 0.02465432f, 
    -0.03556481f, 0.00377208f, 0.12736747f, -0.00910231f, -0.12961164f, -0.32210088f, -0.08052386f, 0.33409002f, 
    -0.49112424f, -0.02531117f, 0.04556344f, -0.00253613f, -0.02295521f, 0.11404943f, -0.01920755f, -0.04801244f, 
    -0.09079273f, 0.06168406f, 0.05562872f, 0.15794867f, -0.04157721f, -0.03856340f, 0.18834059f, -0.28654918f, 
    -0.12344404f, -0.03273894f, 0.01495630f, -0.03142368f, 0.03722676f, 0.02189680f, -0.14019206f, -0.06342389f, 
    -0.04797176f, -0.07344119f, -0.09164238f, -0.09069574f, 0.13943252f, -0.03109702f, -0.02174932f, 0.02799815f, 
    -0.01057765f, -0.15639672f, 0.13853525f, -0.10562345f, 0.00400178f, -0.23074897f, -0.46450227f, -0.15796591f, 
    0.08937283f, 0.03019710f, 0.03904145f, -0.03771095f, -0.02457581f, 0.14620140f, -0.02093552f, 0.00816126f, 
    0.01267145f, 0.08171489f, -0.05966713f, 0.30550143f, -0.07903776f, -0.26534018f, 0.30092955f, -0.00466766f, 
    0.08423914f, 0.15199439f, 0.57951260f, -0.04783605f, 0.33018172f, -0.09467160f, -0.13309789f, 0.04510575f, 
    0.18854508f, -0.23345549f, 0.05993409f, 0.01765613f, -0.01824035f, 0.06228647f, 0.05631582f, 0.09801352f, 
    -0.09391294f, -0.06832005f, 0.01056932f, -0.12464666f, -0.30677125f, -0.06143552f, 0.00982941f, -0.83436662f, 
    -0.13310041f, 0.03938919f, 0.01785402f, 0.02447427f, -0.03287710f, 0.07745468f, 0.02657096f, 0.05363887f, 
    -0.04924765f, 0.03828245f, -0.08521405f, 0.19379243f, -0.11385126f, -0.01282850f, 0.21435292f, -0.10274385f, 
    -0.15357070f, 0.09494516f, -0.06965603f, -0.02196488f, 0.32082954f, 0.06686196f, 0.16487528f, -0.27095640f, 
    -0.05951748f, -0.09159726f, 0.07857964f, -0.09084848f, -0.19646430f, -0.13798617f, -0.03217486f, -0.04988299f, 
    -0.09028166f, 0.08490612f, -0.24057825f, 0.09086466f, 0.19954543f, 0.49067265f, 0.02589095f, -0.31632847f, 
    -0.36933652f, 0.78925747f, 0.36547178f, 0.13795209f, 0.18313453f, -0.15228830f, -0.41056678f, -0.17832644f, 
    -0.04396189f, -0.11303910f, 0.07580593f, -0.09052847f, 0.27790308f, -0.26452044f, -0.00316983f, -0.27590191f, 
    -0.61572671f, 0.11424881f, 0.95977044f, -0.17069946f, 0.57413024f, 0.14377497f, 0.06897438f, -0.15791538f, 
    -0.08372005f, 0.21984576f, 0.14797980f, -0.07883066f, 0.04724872f, -0.08715021f, 0.06449894f, -0.13654664f, 
    -0.09058867f, -0.02658853f, 0.05522174f, -0.13010055f, -0.64414841f, 1.01922536f, -0.10678085f, -0.18899953f, 
    0.57181621f, 0.39289773f, 0.12807110f, -0.03281503f, -0.01742146f, 0.17317474f, -0.27509448f, 0.00143081f, 
    0.01473577f, 0.10495018f, 0.19618438f, -0.12327674f, 0.09578096f, 0.22267930f, -0.00143094f, -0.08798885f, 
    -0.82754368f, 0.00608992f, -0.31529549f, 0.47502670f, 0.16487360f, -0.05623321f, 0.13547944f, 0.22100250f, 
    -0.08182865f, 0.19148010f, -0.14189003f, 0.13012874f, -0.00476682f, -0.13074851f, 0.00299285f, 0.08594004f, 
    0.02926119f, 0.20898026f, -0.02711711f, -0.09556992f, -0.27581695f, -0.54231101f, -0.19475967f, -0.10577013f, 
    -0.45410150f, -0.16564120f, -0.11879689f, -0.07482186f, -0.05464281f, -0.14016698f, 0.04281282f, 0.17458461f, 
    -0.01415609f, 0.09528291f, 0.20693013f, 0.08006480f, 0.01394213f, 0.09508427f, -0.12487284f, -0.32698518f, 
    0.14006208f, 1.37242579f, -0.69749516f, -0.19540769f, -0.76405358f, 0.23278965f, 0.23990394f, 0.01531477f, 
    0.04178182f, 0.17554259f, -0.28002623f, -0.12156279f, 0.01633002f, -0.22453760f, -0.08105398f, -0.20397119f, 
    -0.19684888f, -0.04770044f, 0.22206320f, -0.04788448f, -0.00174620f, -0.20446657f, -0.43166208f, 0.00729459f, 
    0.41706401f, 0.05158421f, 0.03549191f, 0.05359240f, 0.20764564f, 0.06647968f, 0.01767697f, -0.03484247f, 
    0.03607127f, -0.09030616f, 0.02792498f, -0.02892766f, -0.09760788f, 0.05864833f, -0.23513438f, 0.09612931f, 
    0.92468238f, 0.49487069f, 0.19904307f, -0.84008169f, 0.24223725f, -0.17442891f, 0.16059610f, -0.05601194f, 
    -0.11274043f, 0.08418563f, -0.12619331f, -0.00822209f, 0.07058088f, 0.22434802f, 0.01504587f, 0.09535089f, 
    -0.08132250f, -0.05628563f, 0.24497582f, 0.01595405f, 0.08881801f, 0.60806227f, 0.16409142f, -0.58052152f, 
    -0.53557593f, -0.04624678f, 0.14834113f, -0.13888744f, -0.33640453f, -0.47267368f, -0.10388125f, -0.16565804f, 
    0.05773252f, -0.16530392f, -0.07295115f, -0.00427485f, 0.11714733f, -0.36183056f, -0.15059885f, -0.18903072f, 
    -0.53897023f, -0.33889520f, -0.50019532f, 0.21438250f, -0.04814540f, 0.45265001f, 0.10502685f, 0.23958851f, 
    0.13872120f, 0.14586596f, -0.02471129f, -0.05845325f, -0.03141657f, -0.10472484f, -0.13907863f, -0.02835624f, 
    -0.05020924f, -0.09328941f, 0.08484046f, -0.17801046f, 0.24580963f, -0.49672759f, 0.27033964f, 0.26495898f, 
    0.24139935f, -0.13387324f, -0.04975895f, -0.13852169f, 0.02700726f, -0.19004671f, -0.05916157f, 0.10689668f, 
    -0.00920800f, -0.06199051f, -0.05261355f, -0.03659963f, -0.10738138f, 0.13185100f, -0.12849090f, 0.03097144f, 
    -0.46658432f, 0.05971889f, -0.46844229f, 0.04956986f, -0.05841415f, 0.32348323f, -0.22012095f, 0.31761152f, 
    0.05236795f, 0.13343468f, -0.03797532f, -0.11682732f, 0.06340221f, -0.25044113f, -0.29211080f, 0.17205714f, 
    0.02959187f, 0.16823810f, 0.09886498f, -0.35721719f, -0.12606099f, 0.49475947f, -0.33653954f, -0.37061435f, 
    -0.96519125f, 0.14283292f, -0.19414386f, 0.11328764f, 0.14603449f, -0.01164481f, -0.06664717f, -0.25383198f, 
    -0.04210022f, -0.29729557f, -0.25107571f, -0.11408774f, 0.06603134f, -0.21265547f, 0.27738765f, 0.04678336f, 
    -0.37321392f, 0.16915196f, -0.36893928f, -0.06702819f, 0.58588642f, 0.29593045f, -0.19422683f, 0.11880627f, 
    -0.25992870f, -0.05631226f, -0.21041891f, 0.02688675f, 0.07545093f, 0.05208702f, 0.04464443f, -0.00420302f, 
    -0.08172992f, -0.08604234f, 0.19318123f, 0.16095409f, -1.22601235f, -0.38906237f, -0.11244228f, 0.36638877f, 
    -0.11461003f, 0.08483047f, -0.04264584f, -0.26784682f, 0.15632404f, 0.20991269f, 0.10868955f, 0.06617837f, 
    0.26172313f, -0.01013517f, 0.06864835f, -0.04190803f, 0.10564153f, -0.01809651f, -0.11040751f, 0.01359677f, 
    -0.11121317f, 0.13923717f, 0.15173359f, 0.45855215f, -0.06296789f, -0.34973049f, -0.01176373f, -0.08831964f, 
    -0.22238454f, -0.14458084f, -0.05994497f, 0.03530727f, -0.03646774f, 0.04841647f, -0.01363645f, -0.00295487f, 
    -0.13186374f, -0.20334864f, -0.27353978f, -0.07448639f, 0.29085374f, 0.26981094f, -0.02546286f, 0.02336847f, 
    -0.00408843f, -0.08911599f, -0.03699981f, 0.09540643f, 0.11880958f, 0.16358374f, -0.08239991f, 0.02548673f, 
    -0.01028938f, -0.02426832f, -0.07160649f, 0.05496429f, 0.01061856f, 0.03529991f, 0.00994952f, 0.02226505f, 
    0.16011687f, 0.09653722f, -0.05713096f, 0.05566970f, 0.19993387f, 0.12750192f, 0.42877206f, 0.20785779f, 
    -0.05066333f, 0.08146376f, 0.12543981f, -0.08901457f, -0.05947568f, -0.31941915f, 0.07564156f, -0.17375579f, 
    -0.33031026f, -0.22056460f, -0.14735669f, -0.25969130f, -0.46036130f, -0.52330667f, 0.17532748f, 0.16076723f, 
    0.14218892f, -0.49722174f, 0.03072911f, -0.12774462f, -0.12845549f, 0.10048417f, -0.11869638f, 0.08517358f, 
    -0.11394379f, -0.00574155f, 0.02325439f, -0.09954394f, 0.05964333f, 0.07037137f, 0.00711802f, -0.02827355f, 
    0.31821865f, 0.04026102f, 0.37676179f, -0.06316482f, 0.19467647f, -0.02259645f, 0.32019368f, 0.09507948f, 
    0.18020362f, -0.14776343f, 0.05177723f, 0.02221016f, -0.02514959f, -0.02002213f, 0.01783951f, 0.18800868f, 
    0.25510088f, -0.36936083f, 0.06868444f, 0.35706949f, -0.04953863f, -0.07484572f, -0.10238827f, -0.05409445f, 
    0.10480598f, 0.18630920f, 0.13531961f, 0.09365644f, -0.05768725f, 0.04452227f, 0.08773554f, 0.02024070f, 
    -0.04858621f, -0.13151081f, 0.15893766f, 0.32434037f, -0.02842173f, -0.07058281f, -0.02572150f, 0.09113623f, 
    0.31896839f, -0.52566379f, 0.17845011f, -0.05554484f, -0.34901345f, 0.17085196f, 0.00844841f, -0.00043056f, 
    -0.12432989f, 0.18116964f, -0.03191740f, -0.15076080f, 0.00121900f, -0.01821695f, -0.18699473f, -0.25912884f, 
    -0.08589835f, -0.01100764f, -0.31715605f, 0.10810314f, -0.04264227f, 0.08424657f, 0.49375525f, 0.21121725f, 
    0.21924646f, -0.27067995f, 0.07602068f, -0.07540867f, -0.01001448f, 0.19596171f, 0.06607377f, -0.01908008f, 
    0.00785775f, 0.04762000f, 0.01202703f, -0.03838733f, -0.03673388f, -0.11753814f, 0.10010076f, -0.03804704f, 
    0.37564385f, -0.47361144f, -0.18126325f, 0.67316341f, -0.17068988f, 0.10154518f, -0.10630152f, 0.18917316f, 
    -0.08816025f, 0.09404429f, 0.08455209f, -0.22393963f, -0.02232607f, 0.04840495f, 0.03747485f, -0.03007083f, 
    0.08680015f, 0.19122826f, 0.06454845f, 0.15532807f, -0.02246816f, -0.09126902f, -0.07305354f, -0.04509790f, 
    -0.11727216f, 0.14436486f, 0.00885177f, -0.09185559f, -0.09194407f, 0.01144880f, -0.14071386f, 0.00632453f, 
    -0.09661562f, 0.13824150f, 0.10682495f, 0.20852828f, 0.05703942f, -0.01543290f, -0.15349001f, -0.05080802f, 
    0.11484324f, -0.00901848f, -0.07764339f, -0.21358567f, -0.24138036f, 0.09846238f, 0.11293180f, 0.03746529f, 
    -0.01176615f, 0.00328431f, 0.11531304f, 0.01821724f, 0.02134634f, 0.01342194f, -0.01648924f, 0.07400646f, 
    0.01686227f, -0.11710571f, -0.15394349f, 0.02754097f, -0.81853443f, 0.35104117f, -0.54547393f, -0.72224438f, 
    -0.16109060f, 0.04107721f, -0.04294048f, -0.07674062f, 0.07143379f, 0.01910021f, -0.02719998f, -0.04909193f, 
    0.02842912f, -0.08454807f, 0.04349432f, 0.01006897f, 0.09564130f, 0.20839894f, -0.25376236f, 0.05410150f, 
    0.12445259f, -0.05442992f, -0.01165216f, -0.03858054f, -0.05096377f, 0.00832056f, -0.02503030f, 0.01585459f, 
    -0.02071762f, 0.12927999f, -0.01283019f, -0.05937845f, -0.00197906f, 0.02225108f, 0.04875712f, 0.03701811f, 
    -0.27013397f, -0.16815406f, -0.31715059f, -0.40598470f, -0.52961731f, 0.45154190f, -0.27924880f, -0.63054425f, 
    -0.35501125f, 0.19907707f, 0.05054352f, -0.06694105f, 0.15157105f, -0.00290009f, 0.15752544f, -0.09211179f, 
    -0.15531580f, -0.06347936f, 0.09779586f, -0.00589682f, -0.02336217f, 0.21420425f, -0.19745590f, 0.00860654f, 
    0.12918095f, -0.06935076f, 0.18405475f, 0.06530783f, 0.12005365f, -0.06827033f, -0.05278470f, -0.02437202f, 
    -0.01846042f, 0.08012309f, 0.14857793f, -0.23751803f, -0.09462216f, -0.02559878f, 0.07330517f, 0.13837957f, 
    0.06544634f, 0.08597892f, -0.14671870f, -0.09137373f, 0.10995869f, 0.26406044f, -0.17831644f, 0.00200554f, 
    0.00264195f, 0.09376548f, 0.00148189f, -0.03251054f, 0.07777355f, 0.06235078f, 0.17142510f, 0.03231336f, 
    -0.04212481f, 0.01468177f, -0.05302722f, 0.03434313f, 0.05781712f, -0.13814837f, -0.08558856f, 0.12165622f, 
    0.07319061f, -0.32208103f, 0.50181055f, 0.14899239f, -0.69293433f, 0.24294196f, -0.00083602f, 0.20407647f, 
    -0.01448022f, -0.00120853f, 0.05520029f, -0.04649206f, -0.08553373f, 0.03247095f, 0.14328758f, -0.05727224f, 
    -0.01950874f, -0.02744378f, 0.09838996f, 0.07075104f, -0.15227723f, -0.22045581f, -0.31721860f, -0.00738149f, 
    0.02487626f, 0.08640168f, -0.02506834f, -0.09169759f, 0.07821483f, -0.09665046f, -0.12670106f, 0.00038609f, 
    0.01820137f, 0.13676003f, 0.10663255f, -0.08997964f, 0.06864105f, 0.09583203f, 0.06515940f, 0.06885932f, 
    -0.00639853f, 0.21173528f, -0.39524984f, 0.21813680f, 0.13325799f, -0.16866390f, -0.06073013f, 0.22906616f, 
    0.11525434f, -0.08866300f, -0.12815553f, 0.02908699f, 0.00532734f, -0.18186584f, -0.06839000f, 0.22213182f, 
    0.03894405f, 0.36886045f, -0.13084961f, 0.05901216f, -0.34783250f, -0.11558950f, -0.40043974f, -0.31649584f, 
    -0.38996878f, 0.01898907f, -0.17346257f, -0.10897592f, -0.24871477f, 0.10482550f, -0.10033993f, 0.08731620f, 
    -0.25592795f, -0.03604172f, 0.09693924f, -0.13040808f, -0.26099646f, -0.08137150f, -0.06464025f, -0.02510727f, 
    0.53822559f, -0.10847352f, 0.52338719f, 0.10260694f, -0.11917997f, 0.00974947f, 0.05146988f, -0.13076948f, 
    0.23926814f, 0.03072971f, 0.16599369f, 0.01255369f, 0.13307264f, -0.00755907f, 0.07618752f, -0.18900605f, 
    -0.07139018f, -0.24375102f, -0.03332584f, -0.38693121f, -0.01241741f, -0.11356775f, -0.13428180f, 0.17919770f, 
    -0.02521107f, 0.15682720f, 0.05898890f, 0.03096942f, -0.00783448f, 0.08865228f, -0.07447378f, -0.04819947f, 
    0.11511409f, -0.10756573f, 0.01496037f, 0.07775851f, -0.01361427f, 0.05970265f, -0.12884834f, 0.00579082f, 
    -0.27054691f, 0.19160502f, -0.22724323f, -0.07654043f, -0.18680759f, -0.01652247f, -0.16685763f, -0.06923812f, 
    -0.07528391f, -0.17701671f, 0.13838203f, 0.12084982f, -0.26310042f, 0.03459324f, 0.14217035f, -0.11902596f, 
    -0.00374379f, -0.00432342f, 0.23532431f, -0.12487357f, 0.26302564f, -0.19992913f, 0.30230749f, 0.02442380f, 
    -0.37001586f, 0.15872812f, 0.13276741f, 0.13864808f, -0.09122805f, -0.06477037f, 0.11965710f, 0.03328425f, 
    0.04950021f, 0.06544408f, 0.06016277f, -0.03520819f, 0.06304342f, -0.10929906f, 0.08605142f, -0.12046983f, 
    -0.85005116f, 0.12648897f, 0.35327768f, 0.30340329f, -0.53344280f, 0.13655435f, -0.14805833f, -0.11298168f, 
    0.20186158f, 0.01217233f, -0.03636693f, 0.04469369f, -0.10990614f, 0.02565199f, -0.00379978f, 0.02535144f, 
    -0.07400458f, 0.08377860f, -0.29152581f, -0.25211746f, -0.11316022f, -0.06223594f, -0.12065474f, 0.07251820f, 
    -0.02600287f, 0.06145721f, 0.01943458f, -0.12039036f, 0.05427718f, 0.03647969f, 0.42764351f, -0.05679600f, 
    0.06182214f, 0.00610821f, -0.09101272f, -0.04689949f, 0.19299211f, -0.07685879f, 0.04044606f, 0.03605497f, 
    -0.22038491f, -0.17911188f, -0.33553064f, -0.04806245f, 0.23011033f, -0.04537045f, 0.01003778f, -0.03239473f, 
    -0.18054515f, 0.01634310f, 0.22953205f, -0.05384048f, -0.12606022f, -0.05597292f, -0.00152682f, -0.18644933f, 
    -0.05160043f, 0.31468830f, 0.05976584f, 0.10430484f, 0.64445728f, -0.01843561f, -0.33665630f, -0.28822008f, 
    0.27966127f, 0.21247408f, 0.02805855f, -0.16495807f, 0.03870973f, 0.06055547f, 0.11554275f, -0.00342426f, 
    -0.04895889f, -0.13920622f, 0.13440414f, -0.16342002f, -0.08825181f, -0.02830069f, 0.16571541f, 0.07364032f, 
    0.08855589f, 0.00559543f, 0.16173488f, -0.16887914f, 0.31230590f, -0.00709100f, 0.05839515f, -0.03319293f, 
    -0.09625477f, 0.08182754f, -0.07151763f, -0.18381399f, -0.14968956f, -0.12091138f, -0.13189703f, 0.13450569f, 
    0.17278351f, 0.16982193f, 0.03013304f, 0.29046267f, 0.28068292f, -0.45651641f, -0.14689870f, 0.24362469f, 
    0.26756102f, 0.06460796f, -0.09933549f, 0.00097408f, -0.18678075f, -0.01645445f, 0.04733535f, 0.13159065f, 
    0.12861000f, 0.20698661f, 0.16733842f, -0.12319108f, -0.01612355f, 0.17351930f, -0.08336101f, -0.06470367f, 
    -0.40655166f, 0.13219297f, -0.29395828f, -0.18833011f, -0.18467709f, 0.17157866f, -0.03903237f, -0.03227946f, 
    -0.04450571f, 0.17326878f, -0.01122626f, -0.03046864f, -0.02322515f, 0.01235056f, -0.12983774f, -0.04028349f, 
    -0.00873898f, 0.12108150f, -0.08139492f, 0.04995950f, 0.08695959f, -0.07943497f, -0.14696233f, -0.39608693f, 
    0.46011043f, 0.16471493f, 0.06422332f, -0.09684848f, -0.02330627f, -0.02277243f, 0.09258336f, -0.07207642f, 
    -0.01712205f, 0.08147046f, 0.08421098f, -0.19785167f, 0.07570488f, 0.04611389f, -0.12104140f, -0.18473890f, 
    -1.09287524f, -1.96367610f, -0.51962990f, -0.06647911f, 0.64452279f, 0.10268397f, -0.07794177f, -0.25500935f, 
    -0.26045749f, -0.30100271f, 0.00259458f, -0.03284192f, -0.08380840f, 0.02622754f, 0.08224443f, 0.04017494f, 
    0.06511223f, -0.04611928f, 0.35833493f, 0.05498666f, -0.31789070f, 0.07198424f, 0.08133797f, -0.03095695f, 
    0.12688710f, -0.01897377f, -0.02398541f, -0.10223160f, -0.00961617f, 0.22782926f, -0.07369209f, 0.12692159f, 
    0.29290390f, 0.24958104f, 0.11624566f, 0.07766717f, 0.03055626f, -0.08936393f, 0.07091551f, 0.12593874f, 
    0.24697860f, -0.21256693f, -0.31738272f, -0.10666750f, 0.21010487f, 0.05561731f, 0.02675689f, 0.29548243f, 
    0.21676821f, -0.12532593f, 0.04609868f, 0.01617238f, -0.25285080f, -0.06091534f, 0.01078385f, -0.03293315f, 
    -0.06648265f, 0.19806379f, 0.07459549f, -0.03701568f, -0.39746353f, 0.52682692f, 0.33397132f, -0.48978972f, 
    0.71991867f, -0.10764693f, -0.11972613f, -0.09537813f, 0.11401869f, 0.17869626f, 0.06678851f, 0.16437866f, 
    0.04624375f, 0.11930520f, -0.16477863f, 0.00398642f, 0.05742943f, 0.05910755f, 0.19679254f, 0.10344212f, 
    -0.67693621f, -1.15601730f, -0.94973826f, 0.00594827f, -0.28301153f, -0.02891048f, 0.20448174f, 0.18140890f, 
    -0.11828925f, -0.47233766f, 0.01129394f, -0.04641190f, -0.01337606f, 0.13159116f, 0.07251823f, -0.00560138f, 
    -0.01747659f, 0.47023690f, 0.20720595f, 0.17162053f, 0.31800628f, -0.12240560f, -0.28049007f, -0.22550617f, 
    0.14703286f, -0.08829818f, -0.00556824f, 0.09932124f, 0.03046870f, 0.00172766f, -0.11444301f, -0.11352551f, 
    -0.29125690f, -0.22314493f, -0.09998020f, -0.29635367f, -0.37498081f, -0.17922869f, 0.03983778f, 0.04211559f, 
    0.09129459f, -0.17331122f, 0.30168828f, 0.01715504f, -0.01528555f, -0.01198114f, 0.07917541f, -0.08983652f, 
    -0.13564920f, 0.03521670f, 0.14193933f, 0.02895192f, 0.06683411f, 0.17905980f, -0.22584921f, 0.10647263f, 
    0.08594278f, 0.08842755f, 0.11971098f, 0.15017757f, -1.29433131f, -1.11342371f, -1.10155118f, -0.51546907f, 
    0.13258806f, -0.29673880f, -0.01671505f, -0.21588977f, -0.09330192f, -0.53834337f, 0.04894860f, -0.06592789f, 
    -0.05609420f, -0.08880473f, -0.04737227f, -0.06340750f, -0.08248999f, 0.09365924f, 0.17637904f, -0.02687855f, 
    -0.30489787f, -0.18825231f, -0.90498322f, -0.23421343f, 0.60512954f, -0.22959797f, 0.28829926f, 0.05782992f, 
    -0.14137049f, 0.21929324f, -0.10340246f, -0.01126534f, 0.05118604f, 0.04947214f, 0.01251136f, 0.00039033f, 
    -0.01912496f, -0.09199641f, 0.21730162f, -0.05315915f, -0.12417939f, -0.12795125f, 0.12700114f, 0.03576892f, 
    -0.04419085f, 0.02412361f, -0.03287177f, 0.00359503f, 0.00605643f, 0.18712090f, 0.19645125f, 0.13413143f, 
    0.08902836f, -0.03818109f, -0.25311986f, -0.00881364f, 0.04793894f, -0.11520097f, -0.01023983f, -0.03593550f, 
    0.05597840f, -0.14553457f, 0.15657450f, -0.02204045f, -0.01644268f, 0.00643372f, 0.05871839f, 0.00789128f, 
    -0.01092745f, 0.06049418f, -0.04582972f, -0.03330446f, 0.10857196f, 0.04687461f, -0.07897609f, 0.05637105f, 
    -0.08722673f, 0.06071424f, -0.17161244f, -0.05924147f, -0.04454504f, 0.17737187f, -0.23877589f, -0.41900760f, 
    0.09115913f, -0.14186297f, 0.00152743f, 0.08456909f, 0.09813807f, -0.12925461f, 0.02311591f, -0.00845452f, 
    0.17585619f, -0.05119120f, -0.09945226f, 0.13082892f, 0.14783961f, -0.10943931f, 0.04806548f, 0.28466991f, 
    0.07342070f, 0.22664224f, 0.06867813f, 0.12481778f, 0.09070874f, -0.04964316f, -0.09732291f, -0.13944677f, 
    -0.10209241f, -0.08714834f, 0.01609179f, 0.17974347f, -0.28534007f, 0.00279995f, 0.08487802f, 0.01229929f, 
    -0.12005799f, 0.10569547f, -0.27948329f, -0.27210617f, -0.15318157f, 0.00308158f, -0.09963626f, -0.11493361f, 
    0.17576487f, -0.01087506f, 0.01310298f, 0.04495118f, -0.07829566f, 0.15060858f, 0.19043458f, -0.10292403f, 
    0.10857088f, -0.01037884f, -0.13469487f, -0.03208028f, 0.29395661f, -0.20234613f, 0.07514952f, 0.17647253f, 
    -0.74194157f, 0.47483313f, 0.74370080f, 0.11587906f, 0.17562428f, -0.16425870f, -0.15671250f, -0.12724520f, 
    -0.24302146f, 0.10898989f, -0.23370560f, -0.02370228f, 0.11109954f, 0.01996285f, 0.17962284f, 0.01995559f, 
    -0.04874364f, -0.15223268f, -0.06493014f, -0.07460627f, -0.17231184f, 0.11305285f, -0.08165582f, -0.24369459f, 
    -0.07082307f, 0.07813380f, 0.00264164f, 0.04362473f, 0.00898750f, -0.07368173f, 0.01234424f, -0.00029799f, 
    0.02294090f, -0.17972572f, -0.09992976f, 0.13338381f, 0.11229087f, -0.25716412f, -0.11608706f, 0.21767227f, 
    0.25747761f, -1.32757640f, 0.12074458f, 0.93131536f, 0.11137490f, -0.17822510f, 0.06310939f, -0.11443938f, 
    0.09765268f, 0.08093442f, 0.13228042f, 0.08883821f, -0.11498885f, -0.01625432f, -0.03288651f, -0.11999731f, 
    -0.02978903f, -0.14286348f, -0.02618252f, -0.13925968f, 0.18903862f, 0.33777148f, -0.16535105f, -0.08184872f, 
    -0.22160904f, 0.01368879f, 0.07866375f, -0.09621741f, -0.04032031f, -0.03033710f, 0.28489313f, -0.03547169f, 
    -0.17543006f, -0.19656809f, -0.02116133f, 0.08976653f, -0.04706971f, 0.03207899f, 0.06181020f, 0.04589958f, 
    -0.08606724f, 0.11059543f, -0.09052046f, 0.02686512f, -0.34933415f, -0.08333747f, -0.04348454f, 0.04706570f, 
    0.00295108f, 0.00708818f, 0.12619366f, -0.05684332f, 0.08928723f, 0.02680979f, 0.01984399f, 0.02998252f, 
    -0.14148013f, 0.07907785f, -0.17787942f, 0.06203559f, 0.68450451f, -1.49801636f, -1.34652817f, -0.48778501f, 
    -0.18885721f, 0.25588620f, 0.07063168f, 0.04846075f, 0.27787903f, -0.10836258f, 0.02680076f, 0.12022278f, 
    -0.01334488f, 0.14467648f, -0.01739909f, -0.11547375f, -0.09492051f, -0.17957693f, 0.08990081f, 0.15216394f, 
    -1.39350724f, -1.43427336f, 0.62010646f, -0.17996229f, 0.61513984f, 0.12882325f, -0.15511906f, 0.24366532f, 
    -0.23703022f, 0.14185598f, -0.01659212f, 0.00323226f, -0.10505475f, 0.02906592f, -0.04563407f, 0.28622624f, 
    0.19586076f, 0.04104471f, 0.10517510f, 0.05236247f, -0.05153618f, 0.13425310f, 0.00218912f, 0.04202226f, 
    -0.15908319f, 0.05131662f, -0.05410928f, 0.00782970f, -0.01007497f, -0.10950094f, 0.09700304f, 0.06143209f, 
    0.07047391f, 0.02570026f, -0.07529599f, -0.07896858f, -0.11942661f, 0.17676806f, 0.10175878f, 0.04379981f, 
    0.09245939f, 0.06588493f, -0.04194889f, -0.04276573f, -0.06425819f, 0.00215615f, 0.05558694f, 0.03604602f, 
    0.06579032f, -0.00270772f, -0.14268529f, 0.01162640f, -0.05769945f, -0.40073597f, -0.19990417f, -0.32877180f, 
    0.14095671f, -0.20002189f, -0.12578519f, 0.07189225f, -0.02001034f, -0.78428549f, -0.30845943f, 0.26239008f, 
    -0.05267036f, 0.07432356f, 0.12096407f, -0.07173567f, 0.08703852f, 0.39596042f, 0.07787766f, 0.03533266f, 
    0.00542573f, -0.17177242f, -0.02123667f, -0.11275861f, -0.02063396f, 0.04915213f, 0.07672124f, -0.12263756f, 
    0.15518352f, 0.54379892f, -0.85247189f, 0.58749515f, -0.78239787f, 0.01395973f, 0.07528668f, -0.33262390f, 
    -0.14493653f, -0.05465957f, -0.12590650f, 0.03975463f, -0.03749142f, -0.05019881f, -0.03327372f, -0.06344582f, 
    -0.13232413f, -0.09880327f, 0.04971131f, 0.03943584f, 0.07169879f, 0.11667250f, 0.10557365f, -0.17567441f, 
    -0.12623738f, -0.12257900f, 0.12695993f, 0.02155560f, 0.00448860f, -0.21487300f, -0.14875275f, -0.08127898f, 
    -0.19655712f, -0.39602998f, -0.15047202f, 0.00447535f, 0.03937571f, 0.02497968f, -0.06098402f, -0.10476293f, 
    -0.04845807f, 0.19908448f, 0.14134525f, 0.05335161f, -0.06871712f, -0.01397531f, -0.05359179f, 0.02509143f, 
    -0.02080579f, -0.05928390f, 0.04164414f, -0.05350497f, 0.01431213f, 0.02137997f, -0.12202874f, -0.12854224f, 
    0.01784014f, -0.02369033f, 0.03711526f, 0.01921175f, -0.45132491f, 0.13592112f, -0.09237448f, 0.09337890f, 
    -0.34558561f, -0.00537302f, 0.08299770f, 0.11970600f, -0.13317515f, -0.06262948f, 0.11285090f, 0.05970109f, 
    0.09770682f, 0.02204372f, 0.00354372f, 0.14719352f, 0.05357628f, 0.14042231f, -0.16835932f, 0.08887900f, 
    -0.26656437f, -0.07965988f, 0.20367989f, -0.10834040f, 0.10463174f, -0.03229311f, 0.00153087f, 0.06524296f, 
    0.01482555f, 0.02477145f, -0.21682994f, 0.07361728f, 0.00809605f, 0.06904908f, -0.02230889f, -0.03764844f, 
    -0.11693383f, -0.06717804f, -0.10424197f, -0.00837404f, -0.05204003f, 0.22508579f, -0.04646957f, 0.23935923f, 
    -0.49947464f, 0.03903449f, 0.12781724f, 0.08407709f, -0.16707458f, -0.02548097f, -0.19690460f, 0.08123533f, 
    0.07327481f, 0.01636595f, 0.02628733f, -0.29043424f, -0.24058805f, 0.14710303f, -0.12178202f, 0.09039579f, 
    0.53200603f, 0.10569541f, -0.22106360f, -0.27750561f, -0.31376609f, 0.07982257f, -0.08720727f, -0.00932487f, 
    -0.07641820f, 0.00776098f, 0.12819554f, 0.01457123f, 0.31617507f, 0.11853653f, 0.09231808f, 0.03946539f, 
    0.09233315f, 0.03352269f, 0.09112500f, -0.00478214f, -0.12666339f, 0.01178255f, 0.18729979f, 0.19124001f, 
    0.04377212f, 0.02249316f, 0.09984226f, 0.07291339f, -0.06750157f, -0.08839852f, 0.11709172f, 0.06783071f, 
    0.13779084f, -0.03302592f, -0.04447851f, 0.13299796f, -0.16711110f, -0.21790709f, 0.10168564f, 0.00811088f, 
    0.31339946f, -0.23626433f, -0.50917149f, -0.28533286f, -0.00452811f, 0.16325673f, -0.24407361f, -0.01774251f, 
    0.11751235f, -0.04639040f, 0.05867795f, 0.06239083f, 0.17887035f, 0.03323568f, 0.07241308f, 0.13031034f, 
    0.11601329f, 0.06408425f, 0.18647856f, -0.01921941f, -0.20466772f, -0.29299375f, -0.27377260f, -0.14466853f, 
    -0.20722239f, -0.18820289f, -0.03301613f, 0.06526641f, 0.08697530f, -0.07464217f, 0.30089086f, 0.12323169f, 
    0.28198382f, 0.10869931f, -0.00704499f, -0.03981366f, -0.02990840f, -0.11148020f, 0.06661089f, -0.00179837f, 
    -0.08239369f, 0.04228933f, -0.03038477f, 0.18554777f, -0.20654321f, -0.08310359f, -0.03674724f, -0.11172903f, 
    0.04523820f, -0.23663422f, -0.14550045f, 0.10841163f, 0.04575495f, 0.08835430f, 0.04847032f, 0.05687607f, 
    0.17826949f, 0.09465802f, 0.27949017f, 0.14211874f, 0.19827308f, -0.56326640f, -1.15649545f, 0.05175956f, 
    0.64324033f, -0.03882010f, -0.03619759f, 0.17138815f, 0.17193538f, 0.00636992f, 0.05653591f, -0.11905564f, 
    -0.05888228f, -0.02750210f, 0.02183474f, 0.01502814f, 0.03866392f, -0.00728566f, -0.28103587f, -0.22989468f, 
    1.34033692f, -0.91743255f, -0.07812911f, 0.00033900f, 0.14440155f, 0.18733615f, -0.14732948f, -0.12850824f, 
    -0.04893949f, 0.00313445f, 0.09241699f, 0.00514646f, 0.04652057f, 0.02998022f, 0.01610371f, 0.00522125f, 
    -0.02461682f, -0.10424119f, -0.47995704f, -0.50205517f, -0.26709485f, 0.21220861f, 0.17225589f, 0.10017498f, 
    -0.18826365f, -0.02819775f, -0.06235002f, -0.06764201f, -0.07656035f, -0.06328305f, -0.09555992f, -0.15230197f, 
    -0.09282203f, 0.02873524f, -0.06751677f, -0.00192689f, 0.17430873f, 0.09404940f, 0.04805240f, -0.00022263f, 
    -0.18868504f, 0.18966882f, 0.22615917f, 0.13258396f, -0.18897998f, -0.17767468f, -0.05342418f, -0.10970006f, 
    -0.00093727f, -0.15158179f, -0.04214731f, 0.08889356f, 0.18825433f, 0.08730862f, 0.14786226f, -0.02363125f, 
    -0.06216964f, -0.01300214f, -0.15150273f, -0.22022639f, -0.20136186f, -1.22291446f, -1.20995331f, -0.54846352f, 
    -0.30614492f, -0.21860370f, -0.22648662f, 0.09045231f, 0.09512931f, -0.25936782f, -0.06014505f, -0.03040231f, 
    0.00468366f, 0.01448518f, 0.08505190f, 0.02057026f, 0.08500177f, 0.10346257f, -0.06674944f, -0.00763598f, 
    0.78044558f, 0.42190543f, 0.24909510f, 0.07854711f, -0.01452166f, 0.10605738f, -0.09564876f, -0.06570221f, 
    0.22693646f, -0.10216074f, 0.14924015f, -0.03990879f, 0.08449309f, 0.10613366f, -0.01485698f, 0.07278302f, 
    -0.13887656f, -0.33135778f, -0.03914241f, -0.19604416f, 0.00036112f, 0.07415760f, 0.04265079f, -0.11874858f, 
    -0.20435789f, 0.00073439f, -0.07539219f, 0.05861054f, 0.11600469f, -0.03699059f, 0.09655054f, 0.10099735f, 
    0.13701148f, 0.08116779f, 0.17834249f, -0.02370664f, -0.00180192f, 0.02698940f, 0.14260612f, 0.22189441f, 
    -0.32520354f, 0.16516341f, 0.21022098f, 0.10921457f, -0.12670356f, -0.07588882f, -0.05105703f, -0.05599025f, 
    0.02880961f, -0.06865045f, -0.09057198f, 0.08909401f, -0.00312287f, 0.15338372f, 0.11995000f, -0.00808211f, 
    -0.02889396f, -0.02891031f, 0.01536067f, 0.08113475f, -0.85708606f, 0.10516222f, 0.50072807f, 0.46490669f, 
    0.43310511f, 0.00560788f, 0.10098853f, -0.06684925f, -0.04227376f, -0.15611058f, -0.04629421f, -0.12411686f, 
    0.11175013f, -0.02431941f, -0.01450940f, -0.29035074f, -0.22594392f, -0.32688466f, -0.08057190f, -0.25118604f, 
    -0.02663112f, -0.12319024f, -0.11316338f, 0.06713489f, -0.03852688f, -0.02945944f, 0.01566003f, -0.10663646f, 
    -0.02296378f, 0.02686896f, 0.00188971f, 0.18509960f, -0.00772986f, 0.05471192f, -0.00044599f, 0.02361150f, 
    0.23066206f, 0.20533331f, 0.13023120f, 0.25635621f, -0.20792037f, 0.29628989f, 0.38256198f, 0.03479819f, 
    -0.04482223f, -0.16211745f, -0.00325525f, -0.22237399f, 0.01366211f, -0.03745473f, 0.00325841f, 0.06272787f, 
    -0.01593655f, -0.05713127f, 0.14684966f, -0.10498361f, -0.00102467f, -0.18568237f, -0.07390554f, -0.31004304f, 
    -0.33545887f, -0.43276429f, -0.34273162f, -0.11271898f, -0.11564035f, -0.12303420f, 0.11616208f, 0.22657560f, 
    0.14518301f, 0.10761839f, 0.11999675f, 0.04802316f, 0.14978303f, -0.20645733f, -0.03719353f, -0.04300096f, 
    0.11204368f, -0.02635078f, 0.14181723f, -0.05186687f, -0.91876554f, 0.22777295f, 0.45974889f, 0.30568963f, 
    0.08944406f, -0.08359508f, -0.09896240f, -0.11846129f, -0.08781992f, -0.06912094f, -0.08047960f, -0.21504018f, 
    -0.01256722f, -0.09555133f, -0.08656923f, -0.19614945f, -0.03916406f, 0.02543616f, -0.18896146f, -0.00269657f, 
    -0.35542658f, -0.19358975f, -0.69211602f, 0.24671328f, -0.41077942f, -0.07223442f, 0.08751690f, -0.03281441f, 
    0.09986091f, 0.10385484f, 0.02155362f, -0.07037541f, -0.01609000f, -0.07130917f, -0.07399125f, 0.00782021f, 
    0.01133546f, -0.02880113f, 0.08144036f, -0.05870843f, 0.06317542f, 0.59673452f, 0.24563894f, 0.42889935f, 
    0.06580623f, -0.18363903f, -0.19178353f, -0.34789395f, 0.03217819f, -0.43666819f, -0.10675701f, -0.00267117f, 
    0.11214226f, -0.20758730f, -0.08527979f, 0.09625479f, -0.03175591f, -0.13361423f, -0.03429130f, -0.01405402f, 
    -0.62593454f, 0.66806823f, -0.50349307f, -0.28398329f, -0.09147066f, 0.07660755f, -0.06127003f, 0.18239932f, 
    0.01339904f, 0.04490137f, 0.11571554f, -0.13566656f, -0.14162266f, -0.18036655f, 0.01212165f, -0.01991519f, 
    -0.17968494f, -0.36160350f, -0.08026017f, -0.22479177f, 0.15086034f, 0.21138284f, 0.00082149f, 0.69813526f, 
    -0.72872221f, 0.04006756f, 0.01154239f, -0.58363771f, 0.44887710f, -0.26714605f, 0.06810080f, -0.11760874f, 
    0.14374219f, 0.13715291f, -0.04982157f, 0.18178099f, 0.14852527f, 0.09345377f, 0.11536877f, 0.14692962f, 
    0.60540456f, -0.95164317f, -0.35943252f, -0.06994765f, 0.05192352f, 0.03228537f, -0.41861069f, -0.22463965f, 
    -0.09947539f, 0.14733058f, -0.00754811f, 0.03312918f, 0.13271292f, -0.04171399f, -0.01770994f, 0.07930276f, 
    0.18752939f, -0.05268014f, 0.08397771f, 0.18657942f, -0.16418442f, 0.00407169f, -0.30764559f, 0.01771131f, 
    -0.04976203f, 0.16073063f, 0.23149119f, 0.33081821f, 0.14397016f, -0.03557762f, 0.19242766f, -0.19035381f, 
    0.05600176f, -0.08171027f, -0.13199620f, 0.18303274f, 0.09386282f, -0.03415174f, 0.01806143f, 0.01279176f, 
    -0.25928599f, -0.01468029f, 0.11103784f, -0.00071942f, 0.55964363f, -0.24359994f, 0.00801616f, -0.30192685f, 
    0.07303488f, 0.02094458f, 0.04511545f, -0.07356765f, 0.04973700f, -0.00626022f, -0.10768269f, 0.19650342f, 
    0.13547051f, 0.00780291f, -0.03851730f, 0.08439894f, -0.41522756f, -0.16033813f, 0.26427346f, 0.28902820f, 
    -0.34707171f, 0.19488451f, -0.47381130f, 0.25261316f, 0.22843823f, 0.43345290f, -0.05099568f, 0.13577886f, 
    -0.00452260f, 0.00141451f, -0.14128405f, 0.01299549f, 0.13726972f, 0.03882947f, 0.14994867f, 0.01226010f, 
    -1.12570572f, 0.12061315f, -1.53248906f, 0.03950291f, -0.12704091f, 0.24804208f, -0.21963544f, 0.20364967f, 
    -0.07374629f, 0.11522782f, 0.06241510f, -0.24417895f, 0.01866945f, -0.00391184f, -0.00476001f, 0.04354940f, 
    0.00388051f, 0.17573608f, 0.25343749f, 0.29149199f, -0.27486053f, -0.03657088f, 0.07387439f, 0.26639131f, 
    0.37181005f, -0.16152887f, 0.13236466f, -0.19090329f, -0.15555939f, -0.25295162f, -0.15936434f, -0.07525422f, 
    0.17870182f, -0.36054602f, 0.17976630f, 0.19304915f, -0.04855630f, -0.02564397f, -0.17591135f, -0.04422137f, 
    -0.03709242f, -0.28482026f, 0.04988723f, -0.16028427f, 0.22612405f, -0.00892942f, -0.01339664f, 0.15969975f, 
    0.01025796f, -0.05147675f, 0.10528612f, 0.15012324f, -0.01119584f, 0.14872865f, -0.01541005f, 0.09659165f, 
    -0.04749118f, 0.08798485f, -0.14246982f, 0.11139122f, -0.43201733f, -0.16340484f, -0.91729945f, -0.11245637f, 
    0.05841327f, 0.01542412f, -0.20858099f, 0.26049539f, -0.00702286f, -0.08042175f, -0.14270347f, -0.07894038f, 
    -0.09705978f, 0.01155792f, 0.02846608f, 0.08308234f, 0.14655034f, 0.11593366f, -0.11934932f, 0.12208595f, 
    0.16326585f, 0.23623559f, 0.26947534f, -0.39869928f, -0.12933716f, 0.05022099f, -0.07010248f, -0.08999142f, 
    0.02528600f, 0.04024724f, 0.10405092f, -0.02932149f, 0.07249324f, 0.04360361f, -0.02095338f, -0.18727961f, 
    -0.02974885f, -0.19416972f, -0.20686318f, 0.00592180f, -0.31052676f, -0.20255178f, -0.37928963f, -0.35471618f, 
    0.38560668f, 0.08532820f, 0.06464027f, 0.21289289f, 0.12220844f, -0.25185311f, 0.19746377f, 0.02269347f, 
    0.00242015f, -0.17901509f, 0.01032881f, 0.02807350f, 0.00998698f, -0.02731272f, -0.10269267f, 0.05131708f, 
    0.19735733f, 0.11709960f, 0.34877422f, 0.30003470f, -0.45295620f, 0.30054581f, -0.11003751f, -0.38508052f, 
    -0.19802310f, -0.35616681f, 0.01883879f, 0.13047279f, 0.01256607f, 0.20185645f, 0.14958692f, 0.03529101f, 
    -0.03000313f, -0.09438087f, -0.01471909f, 0.01147400f, 0.15640345f, -0.32913205f, -0.35548568f, -0.57357770f, 
    0.43280017f, -0.04743453f, 0.08735581f, 0.27472973f, 0.05642590f, 0.11143842f, -0.09439249f, -0.03805142f, 
    -0.03143644f, -0.04925961f, -0.03874223f, 0.03812799f, 0.07997640f, 0.26373833f, -0.07657471f, 0.04486868f, 
    -0.45171791f, 0.18487102f, 0.01684848f, -0.15236565f, 0.21127406f, -0.05820820f, -0.14909674f, 0.30450156f, 
    -0.00972833f, 0.23314974f, -0.25571951f, 0.13827892f, -0.16789006f, 0.23605821f, 0.00893338f, 0.13253927f, 
    -0.07114794f, -0.00260884f, -0.02097850f, 0.09263646f, 0.34911293f, -0.42419463f, 0.70528829f, 0.22848974f, 
    -0.29309487f, 0.31615666f, -0.18101940f, -0.10519980f, 0.21132724f, -0.13526104f, 0.00483620f, 0.00081096f, 
    -0.29183066f, 0.08483837f, -0.20586580f, -0.07557929f, -0.29798305f, 0.13575473f, 0.05120293f, -0.25852025f, 
    -0.62619805f, -0.63532239f, 0.28325781f, 0.26275581f, -0.24086857f, -0.06854364f, 0.19668889f, 0.39234799f, 
    0.03907622f, -0.00156192f, -0.20910059f, -0.24447502f, 0.09141082f, 0.01720651f, -0.13116260f, -0.08873424f, 
    0.15106151f, 0.29784298f, 0.04636591f, 0.26141334f, -0.25958917f, 0.30218476f, -0.38514256f, 0.17956105f, 
    0.12427971f, 0.15542832f, -0.11862443f, -0.01386187f, 0.10899124f, 0.02929428f, -0.26840988f, 0.13311613f, 
    -0.15527627f, -0.10378285f, -0.17856409f, -0.05140993f, -0.14117149f, -0.16123897f, 0.02287816f, -0.21371420f, 
    -0.92855889f, 0.48060951f, -0.34783432f, 0.43802628f, -0.05780433f, 0.18881540f, -0.06898718f, -0.12557797f, 
    0.59559917f, -0.03863445f, -0.13425307f, 0.24214761f, 0.07303346f, -0.07706653f, 0.14903410f, -0.00561321f, 
    -0.15209927f, -0.55018681f, -0.16704027f, -0.18756789f, -0.27849808f, -0.78972685f, -0.57213068f, -0.44545019f, 
    -0.46834385f, -0.06320318f, -0.08851357f, -0.05607719f, 0.25111303f, 0.06954791f, -0.27252388f, 0.17442407f, 
    0.10316864f, -0.21879064f, -0.07848687f, 0.05927099f, -0.09329183f, 0.20212990f, 0.24539095f, 0.10416327f, 
    0.34984505f, -0.21619174f, 0.69562262f, 0.16983631f, -0.34906775f, 0.15002513f, -0.11046714f, 0.01597873f, 
    -0.16330816f, -0.10103082f, -0.01313504f, 0.00400248f, 0.04371678f, 0.35199109f, 0.01034667f, -0.06816684f, 
    0.03965871f, -0.07499769f, -0.15062958f, -0.26058882f, -0.62673885f, 0.00554480f, -0.81630033f, -0.01139627f, 
    0.15421924f, 0.09693619f, -0.22159433f, -0.33050010f, -0.00342659f, -0.17806511f, -0.04244742f, 0.24905190f, 
    0.06071736f, 0.04924009f, 0.02577758f, 0.11877196f, -0.04308635f, -0.20565745f, -0.02370392f, -0.15541932f, 
    0.43995872f, -0.30787984f, 0.02923279f, 0.25939652f, 0.20213640f, -0.25581524f, 0.22812147f, 0.00444609f, 
    0.17796022f, -0.24839661f, -0.04556058f, 0.15161701f, -0.04763927f, 0.00686158f, 0.05936124f, 0.10401677f, 
    -0.35131341f, -0.20709729f, 0.03221336f, -0.59389973f, 0.47948736f, -0.34707218f, -0.06848640f, 0.14182052f, 
    -0.17423028f, 0.03553296f, -0.10331448f, 0.13977282f, -0.09262606f, 0.11508397f, -0.04227881f, 0.06618360f, 
    -0.14983533f, 0.10365514f, 0.15312675f, -0.13274288f, -0.12721051f, 0.19286862f, 0.14869678f, 0.31089306f, 
    -0.14314631f, -0.25148183f, 0.31553784f, -0.25903282f, -0.45994303f, 0.03889152f, 0.00018444f, -0.15408888f, 
    0.12305264f, 0.09504826f, -0.15130286f, -0.03486483f, -0.20937294f, 0.15241623f, -0.08740558f, -0.14259009f, 
    0.29973212f, 0.30746579f, 0.21101382f, 0.08922914f, -0.21339147f, -0.17687495f, 0.09814063f, -0.06309998f, 
    0.03703637f, -0.07611579f, -0.04424845f, 0.18110478f, -0.14917542f, -0.05456892f, 0.02842360f, 0.18673941f, 
    0.07435642f, 0.11177404f, 0.16012675f, 0.01188483f, -0.21990018f, -0.02057709f, -0.32816255f, -0.37307277f, 
    -0.30062744f, 0.12378513f, 0.33228132f, 0.41111609f, -0.07123734f, -0.05358029f, 0.20313478f, -0.06069536f, 
    0.14571106f, 0.19106884f, -0.15999703f, -0.27772805f, 0.09447563f, 0.03506458f, 0.16751468f, 0.08111095f, 
    0.15447029f, 0.10974221f, 0.37243211f, 0.47054085f, -0.25751129f, -0.25929281f, 0.45656955f, 0.09115446f, 
    0.12284791f, -0.05625802f, 0.06408243f, 0.01238565f, 0.17155859f, -0.23877394f, -0.05004314f, 0.05309284f, 
    -0.09148797f, 0.07890870f, 0.03966734f, -0.16360272f, 0.07078697f, 0.09670654f, -0.12226121f, -0.30495477f, 
    0.09404774f, -0.03855049f, 0.28860816f, -0.13224344f, -0.18652724f, 0.04505450f, 0.08317202f, -0.31667808f, 
    0.13197701f, 0.08322212f, -0.07467191f, 0.11712815f, -0.17369415f, -0.07422068f, -0.05932630f, 0.01581632f, 
    -0.08615640f, -0.10890591f, -0.04945301f, -0.03748501f, -0.06892456f, -0.22824541f, -0.51757455f, 0.42180789f, 
    -0.37236455f, -0.14003050f, -0.26861051f, -0.05061003f, -0.22800840f, 0.20355015f, 0.09813158f, 0.20279907f, 
    -0.27650541f, 0.02135659f, 0.15002634f, 0.00816580f, 0.00732103f, -0.01106667f, -0.22551174f, 0.11345593f, 
    -0.02379883f, -0.54909390f, 0.07695211f, 0.39764494f, 0.22391857f, -0.13777950f, -0.45959517f, 0.31142944f, 
    -0.26774013f, 0.05056291f, 0.10063808f, 0.03719481f, 0.14425634f, -0.12719974f, -0.07942101f, 0.02157355f, 
    -0.17809118f, 0.08177815f, 0.11110270f, -0.03433890f, -0.69554681f, -0.35120028f, -0.01444263f, -0.10983006f, 
    -0.16532600f, 0.03206515f, 0.10299091f, 0.20602684f, -0.10351477f, 0.00423714f, 0.03339389f, -0.02418215f, 
    0.08836082f, 0.01597274f, 0.15502258f, 0.04110125f, -0.13376580f, -0.04256967f, -0.03612924f, 0.03861067f, 
    0.75416273f, 0.13486958f, 0.90999711f, 0.21715976f, 0.19041862f, 0.16630475f, 0.09153299f, -0.30337507f, 
    0.20198902f, -0.02604209f, -0.03853201f, 0.29287809f, -0.05688281f, 0.15491648f, 0.09235542f, -0.31911102f, 
    0.23082404f, -0.18029544f, -0.00578328f, 0.05632496f, -0.63150144f, 0.11819483f, -0.33198225f, 0.19862837f, 
    -0.92537278f, 0.20356622f, 0.08775637f, 0.06423425f, -0.12110645f, 0.05951441f, -0.16917846f, -0.26107380f, 
    0.20585684f, 0.12349492f, 0.02127856f, 0.05586840f, -0.10600872f, 0.14828777f, -0.06819201f, 0.16482426f, 
    -0.51588869f, -0.20151711f, -0.34858495f, 0.39058271f, -0.02136043f, -0.08084511f, -0.33219656f, 0.17295127f, 
    0.05571716f, -0.26601815f, -0.05981928f, 0.06547365f, 0.01407864f, 0.12212108f, 0.03392712f, 0.17885786f, 
    -0.15959014f, 0.23961203f, 0.35056561f, -0.02588623f, 0.49161184f, 0.36890265f, 0.37462908f, 0.09168875f, 
    -0.39500445f, -0.15000749f, 0.15858920f, -0.12556481f, 0.09393732f, -0.02960588f, -0.19317697f, 0.03551577f, 
    0.04475794f, 0.00306102f, -0.14436142f, -0.00312881f, 0.05645848f, 0.10095109f, -0.21488871f, 0.14574867f, 
    -0.81342703f, 0.13329732f, -0.52561945f, -0.12484212f, 0.40325615f, 0.05699820f, 0.15171283f, 0.17720525f, 
    -0.29766291f, 0.06578279f, 0.00430202f, 0.03702481f, -0.05348732f, 0.28719372f, 0.21519697f, 0.11697179f, 
    -0.02031658f, 0.21251357f, 0.27384940f, -0.06972745f, 0.19150372f, -0.38911486f, -0.29027188f, -0.39021772f, 
    0.09814639f, -0.19195974f, -0.41450623f, -0.15564822f, -0.11397293f, -0.25618610f, -0.10385206f, 0.07323112f, 
    0.02745821f, -0.10244484f, -0.00644911f, 0.09589987f, -0.02776655f, 0.02474589f, 0.11985395f, -0.14566696f, 
    0.32129839f, -0.95961344f, 0.29223490f, -0.57092071f, 0.51671398f, -0.05690297f, 0.08020756f, 0.05784733f, 
    0.15433002f, -0.11930792f, -0.09479947f, 0.10077216f, 0.20919707f, 0.10635558f, 0.10557597f, -0.03457455f, 
    0.31976533f, 0.09453871f, -0.20165686f, 0.12701398f, -0.48356569f, -0.03020959f, -0.19966091f, 0.09260380f, 
    -0.05128217f, -0.03745679f, 0.08250902f, 0.25886929f, -0.13917619f, 0.14885324f, -0.10622343f, 0.15947071f, 
    0.03086798f, 0.11216544f, -0.11454736f, 0.13435695f, -0.10704388f, -0.10182145f, -0.03734277f, -0.08870627f, 
    -0.01498094f, 0.22257817f, -0.15997349f, 0.01960154f, 0.02314757f, -0.01857399f, 0.23704283f, 0.09274606f, 
    0.12635419f, 0.12985483f, -0.36920607f, -0.05941309f, -0.13512354f, 0.00411921f, -0.05560610f, 0.05400181f, 
    0.03007965f, -0.04831622f, -0.20784439f, -0.15615742f, 0.80270284f, -0.54443520f, 0.33055821f, -0.00734799f, 
    0.19392125f, -0.03998960f, 0.10942803f, -0.44747609f, 0.26335368f, -0.28943858f, -0.09349459f, -0.08858493f, 
    -0.16994530f, -0.14068507f, -0.19091927f, 0.07107553f, -0.01561542f, 0.10804685f, 0.10236818f, -0.08381933f, 
    -0.22131297f, 0.01972755f, -0.10953026f, 0.50106627f, 0.08738069f, -0.20389652f, 0.10432864f, -0.07435561f, 
    -0.00092066f, -0.15062222f, -0.06859304f, -0.03002365f, -0.13010141f, 0.03546130f, 0.25564948f, -0.02595431f, 
    -0.08748513f, -0.10548721f, -0.09784271f, -0.17008832f, 0.27211380f, 0.10568280f, -0.23435906f, 0.35021821f, 
    0.38204086f, 0.01568375f, 0.07445974f, -0.03787015f, 0.00758991f, -0.37978393f, -0.04531133f, -0.08975496f, 
    -0.04863368f, -0.11478440f, -0.32748243f, 0.25055516f, -0.20441395f, 0.05796961f, -0.08275008f, 0.14515200f, 
    -0.52457225f, 0.06211020f, -0.47455513f, 0.40243644f, -0.11146248f, -0.01604393f, -0.05859216f, -0.24850769f, 
    -0.05379968f, 0.10121976f, 0.02519220f, -0.08805531f, -0.00357145f, -0.10024267f, -0.13832141f, -0.08282290f, 
    -0.08906286f, -0.07294829f, -0.12596849f, -0.01607364f, 0.20772205f, -0.04463205f, 0.02981555f, 0.24886018f, 
    -0.25180623f, -0.22201346f, -0.06492715f, -0.18583784f, -0.09151097f, 0.03792947f, -0.23905502f, -0.08829004f, 
    0.07183728f, -0.02112387f, -0.19184889f, 0.15579934f, 0.09716136f, -0.02924099f, -0.07260019f, -0.18750514f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.30613491f, 0.21089497f, 0.11605681f, -0.11230899f, -0.11873568f, -0.02318343f, 0.06313229f, -0.23001242f, 
    0.10268658f, 0.06981225f, 0.08286959f, -0.01720133f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
