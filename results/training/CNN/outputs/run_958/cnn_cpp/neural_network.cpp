#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.24415560f, -1.20486438f, 0.36572981f, 0.39383379f, 0.09651179f, 0.08418983f, 0.82572615f, 0.66070360f, 
    -0.64105219f, -0.07359856f, -0.09010787f, -0.06668243f, 0.27935761f, 0.03680905f, -0.26748043f, -0.29526371f, 
    -0.22816715f, -0.34680513f, 0.08907674f, -0.29849339f, -0.08645616f, -0.00921110f, 0.12701900f, 0.02773852f, 
    0.16772711f, 0.93194914f, 0.22324756f, -0.24615371f, -0.71567953f, 0.16749844f, 0.31844234f, -0.59716219f, 
    0.53254724f, 0.51193148f, 0.40093669f, -0.45431492f, 0.06605835f, 0.19862127f, -0.36251262f, 0.03814309f, 
    0.01427664f, 0.09880503f, 0.18514748f, 0.17122926f, -0.16937332f, -0.17526908f, 0.05531338f, 0.22765058f, 
    0.04947086f, -0.36864999f, -0.27064139f, -0.15959142f, 0.84584868f, 0.17986055f, -0.15191929f, -0.40000677f, 
    0.84068674f, -0.56863052f, -0.09780183f, -0.21854480f, 0.12153587f, -0.04399803f, -0.10464660f, 0.11527654f, 
    -0.00605983f, 0.19528732f, 0.17603609f, -0.26107624f, -0.10176893f, -0.03971726f, -0.22824505f, -0.12539987f, 
    0.43931273f, 0.28872025f, 0.01316383f, -0.29763770f, 0.74223363f, 0.21974899f, -0.24975812f, 0.64688748f, 
    -0.24841712f, 0.91320431f, 0.20372622f, -0.50152373f, 0.40698189f, -0.29003105f, -0.02623835f, 0.18800095f, 
    -0.58128464f, -0.00406611f, 0.00113201f, -0.10799803f, 0.00418557f, 0.09231340f, -0.20526861f, 0.41624647f, 
    0.14382964f, 0.42039615f, 0.19965948f, -0.08389816f, -0.12372020f, -0.47471505f, -0.64552760f, 1.05633950f, 
    0.98022956f, 0.46573228f, 0.49745765f, -0.44419336f, 0.51576215f, -0.16856848f, -0.11397901f, -0.23988348f, 
    -0.13680604f, 0.04088639f, -0.31912851f, -0.27154455f, -0.16007714f, -0.29855862f, -0.40987253f, -0.24867103f, 
    -0.09072943f, -0.01519515f, 0.02105068f, 0.14487155f, -0.04626659f, 0.63070321f, 0.79556507f, 0.72611344f, 
    0.16337192f, -0.19467144f, -0.25381249f, 0.09613658f, 0.37352833f, -0.28264090f, 0.41412657f, 0.39888427f, 
    0.35724729f, -0.03232893f, 0.10046764f, -0.18100795f, 0.36040625f, -0.07223481f, 0.36772358f, 0.26865396f, 
    0.20142347f, 0.13846855f, 0.34497386f, -0.25264877f, 0.00489795f, 0.26622671f, -0.87738210f, 0.41795877f, 
    0.55126530f, -0.35017893f, 1.04379356f, 0.79253978f, 0.02629978f, -0.71666175f, -0.03571863f, -0.53308773f, 
    -0.06396190f, 0.08506339f, 0.26321816f, 0.17585570f, -0.16496871f, -0.42685536f, 0.10380611f, -0.03567041f, 
    -0.21930222f, 0.10976334f, 0.18467553f, -0.18608545f, -0.33840388f, -0.21911690f, -0.23554869f, 0.04803783f, 
    -0.42449266f, 0.25303552f, 0.56115496f, 0.33442143f, -0.81055820f, -0.95435101f, -0.69912881f, -0.32817718f, 
    -0.24919555f, 0.11588222f, 0.14337733f, 0.15419452f, -0.01457470f, -0.08940751f, -0.23652442f, 0.25843066f, 
    -0.10896277f, -0.04283814f, 0.27331385f, 0.18799241f, 0.02236081f, 0.06857312f, 0.00281015f, -0.00197165f, 
    0.56498080f, -0.60065907f, -0.51559335f, -0.04091380f, -0.41220093f, 0.20713750f, -0.52436310f, -0.70276600f, 
    -0.17023325f, -0.31889704f, 0.17689376f, 0.35689265f, 0.23959412f, -0.30203927f, 0.08941852f, -0.10613122f, 
    0.24207214f, 0.38573009f, 0.14894438f, -0.14673223f, -0.25621012f, -0.03175709f, 0.35078159f, -0.07918449f, 
    0.24198093f, 0.20684862f, 0.39713183f, 0.54144973f, 0.59579307f, 0.69554770f, -0.02312801f, -0.51397145f, 
    -0.24931876f, -0.25493997f, -0.60364515f, -0.25150132f, 0.17806034f, 0.36808956f, -0.04332675f, 0.06224329f, 
    0.14359961f, 0.31905150f, 0.05982465f, -0.05948092f, 0.24532181f, -0.24742086f, -0.39411238f, -0.38911781f, 
    -0.13180916f, -0.14762427f, 0.75102085f, 0.32492405f, 0.05277240f, -0.03468566f, 0.46711066f, -0.22551748f, 
    -0.29894096f, -0.06216569f, -0.28492466f, -0.50989330f, -0.20900734f, -0.13540202f, -0.37132090f, -0.10018767f, 
    0.27012977f, -0.17750311f, -0.41068053f, -0.48840728f, -0.23163246f, 0.21519604f, -0.41667321f, 0.35000691f, 
    -0.28682172f, 0.00143826f, -0.01893829f, 0.45515954f, 0.43513185f, 0.28343168f, 0.57974684f, -0.81925875f, 
    -0.35289824f, -0.71288949f, 0.18800490f, 0.02703188f, 0.07310718f, -0.36264959f, -0.12718502f, 0.03169625f, 
    -0.17177722f, 0.07817115f, -0.27790329f, -0.32582295f, 0.10750155f, -0.21295863f, 0.19419333f, 0.38522896f, 
    -0.17730470f, 0.30928114f, -0.29283223f, 0.00642328f, -0.46591410f, -0.57863647f, -0.05769540f, -0.19938304f, 
    -0.37624592f, -0.48963737f, -0.22778122f, 0.42423320f, 0.01952817f, -0.56487614f, 0.16700695f, 0.22298217f, 
    -0.10456983f, 0.34470695f, -0.44025317f, -0.17556979f, 0.11569889f, 0.00998214f, 0.12142268f, 0.16769223f, 
    -0.22800583f, -0.29640061f, 0.36208370f, -0.14538524f, -0.27009460f, 0.59046096f, 0.02538124f, 0.93969917f, 
    0.14047328f, -0.65444690f, -1.04191959f, 0.01545386f, -0.41609651f, 0.32704318f, -0.11198061f, -0.13696213f, 
    0.24822269f, -0.51333511f, 0.12876810f, -0.06955095f, -0.16523658f, 0.16490020f, 0.00338265f, 0.24228889f, 
    0.16096400f, -0.22884817f, -0.13454063f, 0.03258898f, 0.03006601f, -0.14111717f, 0.08269744f, 0.17128898f, 
    0.24715944f, 0.28462094f, -0.22059682f, 0.15399407f, 0.24388352f, 0.15753298f, 0.18441541f, 0.44018874f, 
    0.30433410f, 0.06003069f, -0.40722278f, 0.06002356f, -0.27067569f, 0.45892450f, 0.08973756f, -0.60639018f, 
    -0.25786254f, 0.06546208f, 0.39777777f, -0.26470134f, 0.12924722f, 0.34476504f, 0.14113358f, -0.63231689f, 
    -0.49607885f, -0.51036179f, 0.12813391f, -0.41398993f, -0.19382967f, -0.41089749f, -0.27741367f, -0.29834682f, 
    -0.32484168f, 0.26282865f, 0.49256626f, 0.01048708f, 0.44559845f, 0.10668282f, 0.15476610f, -0.15992300f, 
    0.24808833f, 0.17637807f, 0.41776589f, -0.14336543f, -0.40448019f, -0.13486642f, -0.19217764f, 0.21875204f, 
    0.77887762f, -0.07066417f, -0.25864771f, 0.32096609f, -0.62622130f, -0.51509577f, 0.06588941f, -0.51055479f, 
    0.61649358f, -0.40759304f, 0.01173284f, -0.29868025f, 0.20227920f, 0.15267161f, -0.15512168f, -0.23952064f, 
    -0.40559676f, -0.56932014f, -0.09668331f, -0.00149288f, 0.14201781f, 0.07905539f, -0.08479975f, -0.19037306f, 
    0.20663831f, 0.55982620f, -1.02182806f, 0.70755911f, 0.39194626f, -0.40253270f, 0.65105838f, -0.53643930f, 
    0.35250276f, -0.31023073f, -0.07180091f, 0.18575391f, -0.37475714f, 0.07711104f, 0.37220702f, -0.15288828f, 
    -0.22972015f, -0.06496871f, -0.28171080f, -0.11753016f, 0.09716989f, 0.24029863f, 0.11062085f, 0.23017351f, 
    -0.07085562f, -0.08531980f, 0.75650162f, -0.20166706f, -0.52581894f, 0.79734915f, -0.28309646f, 0.24509971f, 
    -0.00048791f, -0.04435059f, -0.20177576f, -0.28914815f, 0.30288216f, -0.27912378f, -0.29854599f, -0.04897888f, 
    0.35305938f, 0.07774868f, -0.34641629f, 0.21773028f, 0.38550475f, 0.32680142f, 0.38386169f, -0.10510413f, 
    0.37109685f, -0.27711490f, -0.11184701f, 0.77566010f, 0.66994244f, 0.69687319f, 0.48526493f, 0.13474350f, 
    0.08067666f, 0.00391868f, -0.21564677f, 0.35129946f, 0.51391238f, 0.35177320f, 0.35550460f, 0.08131079f, 
    0.17188460f, -0.24946126f, 0.34287146f, -0.15266804f, 0.12892540f, 0.14913763f, -0.36313039f, -0.04805372f, 
    -0.03170379f, -0.06262614f, 0.17503354f, -0.17168054f, -0.31760943f, -0.58420128f, 0.38388026f, -0.01451117f, 
    -0.39480233f, -0.33994401f, 0.15360634f, 0.02073857f, 0.02980258f, -0.25064707f, -0.26058775f, -0.19686984f, 
    0.10689297f, -0.20357943f, -0.06194929f, -0.21008885f, 0.19346985f, 0.47877669f, 0.15207161f, -0.24867438f, 
    0.50567269f, 0.55391318f, -0.45460948f, 0.13416111f, -0.53876066f, 0.55362380f, -0.45950860f, 0.27431044f, 
    -0.49193692f, -0.35141581f, -0.26571810f, -0.52330452f, -0.00939904f, -0.54183847f, -0.02028294f, -0.01600447f, 
    0.41111356f, 0.20569733f, 0.29350063f, -0.32196909f, 0.26162398f, 0.16238825f, 0.26744196f, 0.32428747f, 
    -0.43580556f, 0.02300289f, 0.22456302f, 0.37905055f, 0.08521624f, 0.21282728f, 0.04419857f, 0.62156838f, 
    0.07645573f, -0.53632301f, -0.58009028f, 0.03854077f, 0.28236631f, -0.15608197f, -0.03919496f, 0.46903655f, 
    -0.39580661f, -0.14491759f, -0.54013181f, -0.38642335f, -0.49088541f, -0.24243695f, 0.05807111f, -0.40636647f, 
    -0.26547036f, -0.34689242f, -0.38423103f, -0.36058155f, -0.15847988f, -0.31974939f, -0.14042729f, -0.39075112f, 
    -0.63211417f, -0.37350103f, 0.30781138f, -0.35909709f, 0.51881450f, 0.69509405f, 0.21650854f, -0.00255809f, 
    0.51991194f, -0.11130441f, -0.01904389f, -0.07492048f, 0.01129504f, 0.02811237f, 0.00965886f, -0.12643224f, 
    0.11863887f, 0.14317738f, -0.02200796f, 0.39543629f, -0.24959227f, -0.21065378f, 0.03182159f, 0.00200793f, 
    0.45297128f, 0.00024353f, -0.33722311f, -0.36412540f, 0.14159846f, 0.58826059f, 0.32405645f, 0.73054445f, 
    -0.10252581f, 0.02959220f, 0.35460508f, 0.35295996f, 0.10465309f, -0.42281511f, -0.21767715f, -0.50052506f, 
    0.06704281f, 0.26980531f, 0.03853741f, -0.42031425f, -0.15490934f, 0.31919065f, 0.30650070f, -0.33858338f, 
    0.18255812f, -1.24234378f, 0.70389050f, 0.23504564f, -0.79984987f, -0.80014753f, 0.96351069f, 0.35030419f, 
    -0.43216389f, 0.56631464f, 0.53213227f, 0.26034820f, -0.30241874f, 0.09544414f, 0.19191238f, -0.11291528f, 
    -0.00656830f, 0.02683474f, 0.03200301f, 0.03749495f, -0.12867464f, -0.01075365f, -0.02446397f, 0.18539597f, 
    0.18437034f, 0.11352327f, -0.02798615f, 0.56722444f, 0.65292120f, 0.25243217f, 0.67223728f, -0.32751998f, 
    -0.26246798f, -0.63822925f, -0.82786030f, 0.07419088f, 0.45124915f, 0.28064868f, 0.11644173f, 0.21334678f, 
    -0.31105483f, 0.36276183f, -0.35333711f, -0.12244657f, -0.01222670f, -0.18726206f, 0.12396217f, 0.12505919f, 
    0.05310302f, 0.18358564f, -0.08340470f, 0.59209943f, 0.31876290f, 0.53635550f, 0.79636401f, 0.75294101f, 
    0.37873691f, 0.04483016f, -0.08964527f, -0.59806442f, -0.48613372f, 0.20205916f, 0.22130719f, 0.20957875f, 
    0.39122900f, 0.10928446f, -0.16934267f, 0.18787076f, 0.51681817f, 0.27032503f, 0.12144929f, -0.06548221f, 
    0.30657297f, 0.16377285f, 0.03362538f, 0.02434995f, -0.38252634f, 0.21190012f, -0.46936530f, -0.35879529f, 
    -0.66161478f, 0.42408913f, 0.32242838f, 0.55862010f, 0.06299163f, 0.02564689f, -0.17938471f, 0.16857070f, 
    -0.54581904f, -0.18594052f, -0.00049721f, 0.00152639f, -0.13361831f, -0.20930792f, 0.12927751f, 0.26368010f, 
    -0.10381901f, -0.17746821f, 0.30088788f, 0.07334692f, -0.20207430f, 0.70861506f, -0.01965432f, -0.54378819f, 
    -0.20464762f, -0.28287631f, 0.31749198f, 0.50203425f, -0.13512979f, 0.51056981f, 0.26706403f, 0.34870535f, 
    -0.15961105f, -0.43558586f, -0.24168773f, 0.08742379f, -0.02272621f, -0.47403124f, 0.11661408f, -0.17688091f, 
    0.04397055f, -0.13614903f, 0.12923807f, 0.18276359f, 0.31667313f, -0.52308029f, -0.90111977f, 0.08616499f, 
    0.06658711f, -0.52243537f, 0.19847798f, -0.00377455f, 0.36982098f, 0.21671787f, 0.14437221f, 0.62093240f, 
    -0.04473170f, -0.02706857f, 0.38545635f, -0.40057895f, -0.49951047f, -0.22630690f, -0.30731690f, 0.20367663f, 
    0.11738198f, -0.00722804f, 0.20603445f, -0.16840649f, -0.41511631f, 0.08031820f, -0.11447421f, 0.28636724f, 
    0.72470313f, 0.81521487f, 0.55029833f, 0.12922539f, 0.58414525f, -0.08974374f, 0.22179286f, -0.11252763f, 
    0.45425832f, -0.45869523f, -0.15150298f, -0.28213140f, -0.10348494f, -0.10922262f, -0.14532402f, -0.02604314f, 
    0.18867047f, -0.11406147f, -0.32089767f, -0.06411117f, -0.12039917f, -0.34345800f, -0.09131662f, -0.04047437f, 
    -0.27602735f, -0.86095554f, -0.72388524f, 0.04804566f, -0.05523979f, -0.64790916f, 0.21611783f, 0.47370538f, 
    -0.36186779f, 0.14460984f, 0.39857870f, 0.20820007f, 0.12715922f, -0.30413631f, 0.43602055f, -0.12560931f, 
    0.18240412f, 0.06420936f, -0.04162664f, 0.08793008f, 0.12444180f, -0.23424861f, -0.20968963f, -0.16585585f, 
    0.11344393f, 0.89718240f, 0.11309853f, 0.31320116f, 0.96523046f, 0.93059975f, 0.51031446f, 0.31257576f, 
    0.35163021f, 0.14218767f, -0.09136416f, -0.30177620f, 0.18381162f, -0.38144648f, -0.11353702f, -0.34678760f, 
    0.03573740f, -0.05577445f, 0.04955739f, 0.06352521f, -0.36968592f, 0.10033359f, -0.07423165f, 0.13596255f, 
    -0.09445655f, -0.08248551f, 0.04358448f, 0.33414909f, -0.59139645f, -0.44860145f, 0.39426172f, 0.13059610f, 
    -0.15429826f, 0.77734548f, 0.56339425f, 0.35893929f, 0.05505589f, -0.34150779f, -0.09540877f, -0.27881038f, 
    0.40749896f, 0.10155603f, -0.03523630f, -0.12355478f, 0.38347268f, 0.54036736f, -0.15404260f, -0.07048818f, 
    -0.35530588f, 0.00920344f, -0.08487967f, -0.34927341f, -0.50870734f, -0.89485657f, -0.40153116f, -0.21402448f, 
    -0.54288089f, 0.24994193f, 0.42469513f, -0.07834581f, 0.47763416f, 0.48784134f, -0.06443217f, 0.08694854f, 
    -0.01998368f, 0.01871131f, 0.05159970f, -0.03146636f, 0.03259578f, -0.09861948f, -0.15203871f, -0.16667202f, 
    0.18369021f, -0.01114614f, -0.13958143f, 0.25610676f, 0.00216794f, 0.64921421f, 0.56553024f, -0.79356647f, 
    -0.51130676f, -0.41425848f, -0.36265406f, -0.39979172f, -0.73317558f, -0.39184463f, 0.13655889f, 0.22699940f, 
    -0.13599177f, 0.20535606f, -0.26075891f, 0.12204932f, -0.27511591f, 0.32891625f, -0.38831621f, 0.54300225f, 
    -0.14327613f, 0.34253475f, 0.22622767f, -0.22936733f, 0.33796427f, -0.47486654f, -0.26388851f, -0.76211059f, 
    -0.55335301f, 0.53850555f, -0.21372478f, -0.22112116f, 0.37087488f, 0.25919920f, -0.03327205f, -0.30599135f, 
    0.08622563f, 0.24088705f, 0.08320596f, -0.10592272f, 0.29180998f, 0.14505717f, -0.16321804f, -0.07559086f, 
    -0.09411550f, 0.21314102f, -0.32839945f, 0.22766200f, -0.15959831f, -0.27449241f, 0.75103736f, -0.60605490f, 
    0.46426290f, 0.21928571f, 0.32863438f, 0.44641989f, 0.28742689f, 0.54666406f, 0.69279212f, 0.56636512f, 
    -0.55541247f, 0.35930455f, -0.29680058f, 0.54063427f, 0.13963680f, 0.07344255f, -0.00598492f, 0.02091086f, 
    0.00754945f, 0.12502693f, 0.21611382f, 0.00198850f, 0.09237015f, -0.10423195f, -0.05587028f, 0.04590796f, 
    -1.20440388f, -0.67133677f, 0.30708465f, -0.11268815f, -0.49048987f, 0.28178227f, 0.19152321f, -0.11804151f, 
    0.41603193f, -0.00542381f, 0.34040865f, -0.31414732f, 0.42859894f, 0.15816271f, 0.03678704f, 0.04642113f, 
    0.10266965f, 0.07914148f, 0.00064927f, -0.01266161f, 0.05810251f, 0.01669424f, -0.01085637f, -0.22926733f, 
    -0.39645013f, -1.17612100f, -0.15070999f, 0.54309541f, 0.42996961f, 0.11669496f, 0.89457202f, 0.11525463f, 
    -0.17119619f, 0.16236375f, 0.25288194f, 0.28141770f, -0.17261924f, -0.02938175f, 0.20161825f, -0.16444319f, 
    0.23846579f, 0.18474315f, 0.00683227f, 0.08197653f, 0.12661828f, 0.00884811f, 0.25962621f, -0.25578722f, 
    0.05343178f, 0.05819320f, 0.73334074f, 0.41092002f, 0.27939600f, 0.40189180f, -0.99336523f, 0.59694153f, 
    0.28895620f, -0.52850181f, -0.12097944f, -0.19951709f, -0.22169054f, -0.16069283f, 0.16678834f, 0.05806889f, 
    -0.07949018f, -0.10360416f, 0.41988182f, -0.20509164f, -0.34470847f, -0.29481527f, 0.13365667f, 0.02945751f, 
    -0.10550082f, 0.12031553f, 0.92344046f, 0.02509589f, 0.57749838f, -0.00755606f, -0.51597118f, 0.73471981f, 
    0.25512263f, -0.79970562f, -0.14497685f, -0.38827556f, 0.45375755f, 0.39147916f, -0.13759679f, -0.04415787f, 
    -0.02501095f, 0.17434129f, -0.02399208f, -0.03136225f, 0.08799011f, 0.30958083f, 0.09758423f, 0.22661597f, 
    0.09672906f, 0.10540506f, 0.09590032f, -1.05659378f, 0.35447690f, 0.34702119f, -0.86479479f, 0.49357927f, 
    0.78755713f, -0.41178575f, 0.63192737f, 0.40100881f, -0.07642800f, 0.29249674f, -0.22185269f, -0.12979983f, 
    -0.20492630f, -0.26155522f, 0.10086498f, -0.05663391f, -0.20131922f, -0.35537142f, -0.02858019f, 0.02825194f, 
    0.13117082f, 0.08577214f, -0.13772000f, 0.00769597f, 0.64062560f, -0.68050230f, -0.78438038f, -0.75438529f, 
    0.62160277f, 0.83317810f, -0.47831941f, -0.00816617f, 0.30380288f, 0.02735049f, -0.60038221f, 0.17042856f, 
    0.19508721f, 0.19058360f, -0.22500038f, -0.22278930f, -0.29219741f, -0.07308809f, 0.11943810f, 0.03504091f, 
    0.02884454f, 0.13038957f, -0.17923906f, 0.04387233f, 0.06891289f, -0.02744982f, 0.29566005f, 0.67841440f, 
    -0.24389285f, -0.67400670f, 0.66418779f, -0.70186096f, -0.50683194f, -0.33885536f, 0.09115518f, -0.48984146f, 
    0.24911560f, 0.09776282f, 0.46651331f, -0.03453425f, 0.01660470f, 0.25469235f, -0.03804781f, 0.03408227f, 
    -0.29074025f, -0.05566468f, 0.26707870f, -0.27015442f, -0.37450859f, 0.29608682f, -0.33461043f, 0.38571995f, 
    -0.62852538f, -0.40779445f, 0.20521972f, 0.34577918f, -0.39679837f, -0.43995807f, 0.17513274f, -0.27539313f, 
    -0.38169709f, -0.25939128f, -0.38514182f, -0.04702133f, -0.43983912f, 0.38475627f, -0.07972146f, 0.44567278f, 
    0.35340276f, -0.13173664f, -0.39550182f, 0.24869266f, 0.06260586f, -0.23825848f, 0.09749084f, -0.05397801f, 
    -0.54919076f, -0.44888622f, 0.01986177f, 0.14746374f, 0.60810435f, 0.13909170f, 0.43925488f, 0.42651898f, 
    -0.13526373f, -0.19155867f, -0.43815461f, -0.23708242f, -0.48386773f, -0.42514241f, 0.15814784f, 0.29337186f, 
    -0.05179111f, 0.23492722f, -0.35863394f, -0.18239465f, 0.21659566f, -0.14236106f, 0.24767035f, 0.48508546f, 
    0.75897616f, 0.84850597f, 0.38544649f, 0.32697317f, 0.54441118f, -0.45599067f, -0.45150971f, -0.25597379f, 
    0.37254861f, -0.09428833f, 0.08802239f, -0.07239582f, -0.11928660f, 0.32534641f, -0.12550917f, -0.11996177f, 
    -0.03306687f, -0.05837924f, 0.03738611f, -0.23877452f, 0.31778413f, 0.21354571f, 0.07346405f, -0.06439314f, 
    -0.02404934f, 0.28554848f, -0.47759253f, 0.13462718f, -0.03067577f, -0.11244957f, -0.66861671f, -0.40959188f, 
    -0.19313113f, -0.04798961f, -0.28931335f, 0.22193496f, -0.01479947f, 0.18082345f, -0.34742874f, -0.36009300f, 
    -0.12219551f, 0.08197493f, -0.35355622f, -0.01574668f, -0.57299691f, -0.35712475f, -0.19072782f, 0.09560446f, 
    0.31994984f, 0.42844188f, -0.58299732f, -0.80610639f, -0.74808544f, -0.36631918f, 0.09749426f, -0.67057127f, 
    0.67646563f, 0.55777925f, 0.34690484f, -0.12672593f, 0.13740574f, -0.14898358f, 0.13492846f, 0.05810905f, 
    0.14324631f, 0.08877607f, -0.25084066f, -0.21897544f, -0.09038088f, -0.06232391f, 0.04631927f, -0.02133664f, 
    0.18956752f, 0.10130662f, 0.16826753f, 0.68888730f, 0.01785733f, 0.73866057f, 0.58550537f, 0.70570588f, 
    0.44753909f, 0.34331533f, 0.10152832f, 0.23163645f, -0.11668267f, 0.20812866f, 0.23797865f, -0.05744798f, 
    -0.23789425f, -0.38440633f, -0.24914901f, -0.01585282f, -0.16630007f, 0.05162077f, 0.02357808f, -0.21712014f, 
    0.18320237f, 0.21170564f, 0.09980838f, 0.35857481f, -0.05964151f, -0.65401322f, -0.66021478f, -0.92541128f, 
    -0.28012469f, -0.32208613f, 0.57711989f, 0.39500260f, 0.10158668f, 0.15220241f, -0.48984435f, -0.31433177f, 
    -0.35199878f, -0.34108162f, -0.40535453f, -0.00659893f, 0.22949864f, 0.00085557f, -0.11830381f, -0.13695456f, 
    -0.08975861f, -0.10469803f, 0.18264553f, -0.31002524f, 0.01997722f, -0.27357033f, -0.87955672f, 0.05149164f, 
    -0.24638005f, -0.06649622f, 0.62532765f, 0.07112803f, 0.45625824f, 0.55835754f, 0.07900933f, 0.40674743f, 
    -0.34006950f, -0.04630370f, 0.32236803f, -0.02493450f, 0.28661570f, 0.25735405f, 0.01659328f, -0.25444093f, 
    0.04950378f, -0.20017092f, -0.15594056f, 0.19885798f, 0.05425380f, 0.39705566f, 0.24263531f, -0.29987645f, 
    0.09095609f, 0.62333673f, -0.26025283f, -0.51316035f, 0.71298790f, 0.39687994f, -0.72403020f, 0.39786336f, 
    0.38795054f, 0.08532567f, -0.40005735f, -0.17073910f, 0.26666808f, -0.40268055f, -0.31090316f, -0.05466602f, 
    0.37112093f, -0.56577337f, -0.18706663f, -0.14490941f, -0.11191248f, 0.32593364f, 0.04340895f, 0.73936969f, 
    0.78198588f, -0.36358112f, -0.54949403f, -1.10372102f, -0.16697745f, -0.11724699f, 0.02607093f, 0.01489594f, 
    -0.44529238f, 0.42513666f, 0.26292443f, -0.19145396f, -0.12927587f, 0.21274042f, -0.11474266f, -0.00981343f, 
    0.01594123f, -0.11721952f, -0.32931560f, -0.09378652f, 0.23034681f, -0.01044491f, 0.21238309f, -0.05064287f, 
    -0.76369053f, -0.34093159f, -0.37094098f, -0.47187620f, 0.00955662f, 0.45364982f, -0.37552533f, -0.45355269f, 
    -0.58035886f, -0.21561405f, 0.14311747f, 0.22648729f, 0.23306616f, 0.38830936f, -0.36611530f, -0.05874360f, 
    -0.06558483f, -0.47939581f, -0.18800595f, -0.12262590f, 0.09425923f, 0.03314144f, 0.00054746f, -0.19161798f, 
    0.22721760f, -0.41522375f, -0.34781468f, -0.81651646f, -0.65961480f, -0.24723412f, 0.42314303f, 0.50151563f, 
    -0.31120661f, 0.30211768f, 0.35604972f, -0.33454990f, 0.26822364f, 0.05922964f, -0.09027130f, 0.24524230f, 
    0.22347507f, -0.01873691f, 0.06391705f, 0.48641723f, -0.27072668f, -0.22400355f, -0.25043184f, -0.24870920f, 
    0.25810075f, 0.31710470f, -0.48559442f, -0.60519534f, 0.90320683f, 0.84881026f, -0.62267601f, -0.64548647f, 
    0.04556656f, 0.59941238f, 0.29220191f, -0.40264598f, 0.07804401f, -0.26494768f, -0.08920322f, -0.34342450f, 
    -0.09834427f, 0.24086763f, 0.42682263f, -0.04957424f, -0.03177060f, -0.02453315f, -0.11876183f, 0.11738963f, 
    0.01318762f, -0.20715807f, -0.09751137f, -0.26747268f, 0.03557140f, -0.27665603f, 0.06953534f, 0.59206963f, 
    -0.56377226f, -0.06822991f, -0.41650471f, -0.44997704f, -0.57059872f, 0.49456280f, 0.57359064f, -0.22520885f, 
    -0.05200187f, 0.36124319f, 0.04245526f, -0.16037898f, 0.07642863f, -0.00547250f, 0.18296205f, 0.23554270f, 
    0.28530371f, -0.40285107f, 0.31041086f, 0.29047170f, -0.69964778f, -0.00064119f, -0.23276521f, -0.17257069f, 
    0.18401881f, 0.25652966f, 0.21377897f, 0.22412284f, -0.23685636f, 0.51204312f, -0.48554528f, -0.10903585f, 
    -0.63063067f, -0.38124636f, -0.16931069f, 0.33093116f, -0.26028904f, 0.33434552f, -0.28513318f, 0.04846679f, 
    -0.53978103f, -0.15432476f, -0.20648094f, -0.23577860f, -0.10891908f, 1.03342605f, 0.66714054f, -0.16736501f, 
    -0.18165204f, 0.04394034f, -0.12150645f, -0.03321449f, -0.33650666f, 0.17785813f, 0.18329696f, 0.05572415f, 
    -0.16613393f, 0.20264442f, 0.19084011f, 0.05437840f, 0.21465577f, 0.28318721f, -0.31749481f, -0.11064654f, 
    0.28823316f, -0.21648268f, 0.29928210f, 0.05237876f, -0.10637332f, 0.03160209f, 0.54571247f, 0.47935790f, 
    -0.74599779f, -0.35140729f, -0.60450155f, -0.38328525f, 0.48563537f, -0.03938108f, -0.10091104f, 0.53900576f, 
    0.50724256f, -0.03188653f, -0.15540162f, -0.41190165f, -0.08506791f, 0.10474802f, 0.35559070f, 0.06058316f, 
    -0.06635674f, 0.33548689f, -0.38780245f, 0.03399590f, 0.02680641f, -0.02647735f, 0.14792155f, -0.92177045f, 
    -0.63547558f, 0.08565791f, 0.47266993f, -0.47181144f, -0.03510576f, -0.00383265f, -0.30798706f, 0.45868099f, 
    -0.30355370f, 0.35149077f, 0.09092962f, -0.36759740f, 0.28804103f, 0.04395811f, 0.34441647f, 0.06397899f, 
    0.02734518f, -0.39274320f, -0.27159145f, -0.05793939f, 0.00643754f, -0.01177632f, 0.12132617f, 0.03239056f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.19795515f, 0.11715245f, 0.02109162f, 0.20205776f, 0.15265420f, 0.25014958f, 0.08304595f, 0.07424334f, 
    -0.00798133f, 0.07458545f, 0.23298267f, 0.18765077f, 0.12752126f, 0.00646350f, 0.06549459f, 0.08634967f, 
    -0.05025319f, -0.01479596f, 0.20097099f, 0.22131516f, -0.03499594f, 0.33049414f, 0.08289877f, 0.22869873f, 
    -0.03109293f, -0.07448977f, 0.04577222f, -0.05639311f, 0.10953216f, -0.06437417f, -0.00080735f, 0.32029366f, 
    0.25875485f, 0.10266311f, 0.29327908f, 0.25959063f, 0.08038147f, 0.22511287f, 0.03330313f, 0.16302834f, 
    0.22613896f, -0.00222227f, -0.03645109f, 0.06128396f, 0.22401074f, 0.12421425f, -0.14390557f, 0.10546339f, 
    0.15552981f, 0.13316837f, 0.13443035f, 0.14140239f, -0.03397821f, 0.03756347f, 0.00968346f, 0.06958824f, 
    0.19320621f, -0.01548669f, 0.07500868f, 0.20285527f, -0.03168862f, 0.29293880f, -0.07735343f, 0.30644405f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.34233731f, 0.11650555f, -0.00434764f, 0.07516990f, -0.11528999f, 0.09108978f, 0.00896141f, -0.03005177f, 
    -0.02595670f, 0.08611621f, 0.00469480f, -0.00849999f, 0.22764212f, -0.06065071f, 0.03176931f, -0.26815200f, 
    -0.06020858f, 0.05654388f, 0.03343832f, 0.03924170f, -0.11506381f, 0.02037743f, -0.05084776f, 0.01388386f, 
    0.05244371f, -0.15282439f, 0.18855855f, 0.16419719f, -0.04269434f, -0.06152324f, 0.03749659f, -0.00624262f, 
    -0.00512451f, 0.04725987f, -0.02382130f, -0.05405077f, -0.10318098f, -0.02290248f, 0.16955359f, -0.19856313f, 
    0.03029159f, -0.11183648f, -0.01872590f, -0.10942240f, -0.03242580f, -0.01969431f, -0.09845197f, 0.11266305f, 
    -0.16887116f, 0.20324939f, 0.05705811f, 0.30440840f, 0.07317799f, 0.02703689f, -0.05455187f, -0.07177081f, 
    -0.14044623f, -0.04772236f, 0.00053394f, -0.10345354f, -0.02740168f, 0.08804191f, -0.07781039f, -0.14567302f, 
    -0.02283032f, -0.12431411f, 0.01926382f, 0.00489304f, -0.01039338f, -0.02416991f, -0.10263310f, -0.03315230f, 
    -0.47571865f, -0.26862684f, 0.28499997f, -0.07210305f, 0.02549320f, 0.03438673f, 0.16094458f, -0.14078481f, 
    0.06614662f, -0.07049032f, 0.02997738f, 0.03285407f, 0.16106777f, -0.19532335f, 0.00679197f, 0.14863178f, 
    -0.04518617f, -0.00017600f, -0.00545804f, -0.06322054f, -0.11771269f, -0.09618636f, -0.06329565f, -0.05583063f, 
    -0.17715704f, -0.29592901f, 0.15564016f, 0.08030576f, -0.12726210f, -0.01164751f, 0.05288209f, 0.01107423f, 
    -0.06533591f, 0.04522146f, -0.09697764f, 0.03490716f, 0.04098415f, 0.05866814f, 0.00416731f, 0.04639384f, 
    -0.01747709f, -0.01203419f, 0.09223814f, 0.06961362f, 0.07735074f, -0.02675543f, -0.13034415f, 0.03981312f, 
    0.26239929f, 0.12019338f, 0.01382456f, -0.20329347f, -0.13707668f, -0.06848235f, -0.08784588f, 0.11999176f, 
    -0.05113116f, -0.14397566f, -0.09535940f, -0.13424726f, 0.00565192f, 0.01627656f, -0.21952485f, 0.24125472f, 
    0.00449710f, -0.03045561f, -0.03262255f, -0.09166026f, -0.12547456f, -0.04603243f, 0.00075635f, 0.07726493f, 
    -0.12493479f, 0.15639929f, -0.24723074f, -0.01116670f, -0.03836166f, 0.01943159f, 0.17040630f, 0.07658851f, 
    0.19829388f, 0.01764657f, 0.00045743f, -0.10083675f, 0.10969374f, 0.06849763f, -0.16044916f, 0.17499231f, 
    -0.00989695f, -0.19556937f, 0.01952633f, -0.03467395f, 0.05880473f, 0.04965974f, 0.03036631f, -0.00365048f, 
    0.01509128f, -0.00868843f, -0.00254344f, 0.10919165f, 0.01515910f, -0.07833231f, 0.08472931f, 0.01613361f, 
    0.08320189f, 0.07006424f, -0.04928860f, -0.07439920f, -0.34636006f, -0.13479076f, -0.05173732f, 0.00877804f, 
    -0.02528064f, 0.09882590f, 0.10299669f, -0.02276176f, 0.13943107f, -0.03278640f, -0.04771896f, -0.10144945f, 
    -0.16097683f, -0.06243247f, -0.03404165f, 0.12483298f, -0.06957596f, 0.11911638f, -0.03565545f, -0.05051457f, 
    0.11180016f, -0.03764815f, -0.05224046f, 0.10270204f, -0.02844759f, -0.14299464f, -0.10384150f, 0.18240331f, 
    -0.00720224f, 0.02553420f, -0.00634455f, -0.07844210f, -0.21060142f, 0.12063796f, -0.09235089f, -0.05639757f, 
    0.17979212f, -0.06961193f, -0.08666845f, 0.20755680f, -0.14757358f, 0.09982076f, -0.07128477f, -0.02654342f, 
    -0.10454123f, -0.16353227f, 0.03833713f, -0.06091209f, 0.11074585f, -0.09567896f, -0.09905446f, 0.07369280f, 
    -0.16817732f, -0.06163352f, -0.05313262f, 0.09377348f, 0.00695340f, 0.08822866f, -0.04755373f, -0.08020192f, 
    -0.04918939f, 0.01364391f, 0.04107540f, 0.12881975f, 0.03637705f, -0.03065091f, 0.06968216f, 0.08106942f, 
    -0.09393185f, 0.00273626f, -0.10790543f, -0.00193444f, -0.12512000f, -0.09896394f, 0.15716039f, -0.07480225f, 
    -0.07729935f, -0.03936839f, 0.03472608f, 0.02364321f, -0.10892591f, 0.11876713f, -0.09733520f, -0.05562996f, 
    0.13411315f, 0.09202776f, 0.00466392f, -0.15119939f, -0.07832464f, 0.04483780f, 0.01179330f, -0.09507360f, 
    0.00090007f, 0.04507681f, 0.04934181f, 0.02146819f, 0.12545176f, 0.18147022f, -0.04507012f, -0.12074924f, 
    0.06529088f, -0.04092232f, 0.03441173f, 0.07372677f, 0.09639979f, -0.05106677f, -0.02314485f, -0.00365668f, 
    -0.01893026f, 0.07762820f, -0.02447670f, -0.11665805f, 0.06875204f, -0.03100342f, 0.07470842f, -0.02061281f, 
    -0.06460229f, 0.10542774f, -0.09779721f, -0.04825803f, 0.60895234f, -0.07164735f, -0.05178546f, -0.11720028f, 
    0.00916468f, 0.04402604f, -0.01593732f, -0.00305302f, 0.04575528f, -0.03893632f, -0.04076486f, 0.03826582f, 
    0.01970387f, 0.07520462f, 0.06432903f, -0.00476049f, -0.09583762f, -0.00822905f, -0.04086810f, 0.08753724f, 
    0.10584956f, -0.01927577f, 0.05704621f, 0.00028867f, 0.12025386f, 0.06515514f, -0.14078037f, -0.01687311f, 
    -0.22169410f, 0.02084802f, 0.01399804f, 0.00909041f, -0.02132344f, 0.05208846f, -0.02235120f, -0.01594318f, 
    0.12865703f, 0.08550519f, 0.03264323f, -0.27090666f, 0.02108164f, 0.07797453f, 0.09266516f, -0.05016508f, 
    -0.04312239f, -0.04464700f, -0.04260809f, -0.08667815f, 0.12727445f, 0.08560243f, 0.05502321f, -0.00468844f, 
    0.04644724f, 0.12435908f, -0.01244162f, -0.06841998f, -0.09614019f, -0.02045524f, 0.18091947f, -0.09196147f, 
    0.11508720f, 0.06981247f, 0.07767583f, -0.12224511f, 0.03365757f, 0.01952321f, -0.10111319f, 0.04304139f, 
    0.07527436f, -0.03746801f, -0.06957000f, 0.00535128f, -0.12935311f, 0.02099650f, -0.04745458f, 0.14230497f, 
    -0.20430937f, -0.15059088f, 0.08655881f, 0.01401565f, -0.07479119f, -0.02071933f, -0.08382583f, -0.05687382f, 
    -0.41782379f, -0.03988022f, -0.12699229f, 0.06237734f, 0.00318216f, -0.08280075f, -0.01136546f, 0.03113225f, 
    -0.01839335f, -0.04008029f, -0.12645046f, 0.08137034f, 0.13486357f, -0.03423982f, 0.04215207f, 0.29563683f, 
    -0.15586503f, 0.09765345f, 0.01255801f, 0.07261526f, -0.04548337f, 0.05326004f, 0.02312029f, -0.11791439f, 
    0.15997288f, 0.05824312f, 0.01315164f, -0.10076681f, -0.10185292f, 0.04065761f, 0.00699724f, -0.13826887f, 
    -0.00934922f, -0.03598573f, 0.08835043f, 0.08826603f, -0.22422765f, 0.15027180f, -0.11115980f, -0.07766657f, 
    -0.00789926f, -0.02484550f, 0.00323553f, -0.04822103f, -0.02835660f, -0.00614399f, -0.09125275f, 0.01942219f, 
    -0.32525566f, 0.16187055f, 0.15317255f, -0.15174137f, 0.04546943f, 0.11279119f, -0.13037527f, 0.13020374f, 
    -0.09713911f, -0.18560494f, 0.03631061f, 0.02493312f, -0.05347894f, 0.14752492f, -0.09369714f, -0.06186977f, 
    -0.06625614f, 0.13291273f, -0.05704111f, -0.05291217f, 0.00449053f, 0.00390082f, -0.04860013f, -0.03035056f, 
    0.27345425f, -0.16224864f, -0.15905377f, 0.12759620f, 0.07690943f, -0.03659333f, -0.09020203f, 0.04165190f, 
    0.00443739f, 0.05336164f, 0.07925270f, 0.04572693f, -0.01378591f, -0.17061849f, -0.02368357f, 0.10552148f, 
    0.02798450f, 0.01870658f, -0.10091564f, 0.00411472f, -0.07590815f, -0.00117179f, 0.07418425f, -0.00890926f, 
    -0.26679817f, 0.00273752f, 0.00801516f, 0.11591370f, -0.01085022f, 0.00074838f, -0.03895283f, 0.02869561f, 
    -0.01968023f, 0.04501105f, -0.02697757f, 0.06268895f, 0.02838014f, 0.08260859f, -0.07752794f, 0.16617858f, 
    -0.12006185f, -0.17924710f, 0.02468840f, -0.04691599f, -0.01261394f, -0.05965755f, 0.11441914f, -0.17310444f, 
    -0.02394820f, -0.00837549f, 0.12908514f, -0.09132712f, -0.19954766f, -0.08956195f, -0.01520925f, -0.00288360f, 
    -0.03042098f, 0.04609068f, -0.01108315f, 0.01930086f, 0.06174266f, -0.00956531f, 0.20501432f, -0.05213192f, 
    -0.07547471f, 0.14115950f, -0.00561872f, -0.06313579f, -0.02512240f, -0.04332424f, 0.01082810f, -0.07711487f, 
    0.31470278f, -0.14873157f, 0.08666033f, -0.27694258f, 0.06546094f, -0.03036534f, 0.16101302f, -0.17613961f, 
    -0.04447000f, -0.00670585f, 0.01731052f, 0.05320310f, -0.28611156f, 0.14939265f, 0.07642569f, 0.11176404f, 
    -0.06051965f, 0.02484130f, 0.01454288f, -0.01869930f, -0.07615379f, 0.08307293f, -0.12421813f, 0.01317178f, 
    0.08599138f, -0.08517233f, 0.14630277f, -0.10639086f, 0.07049512f, -0.08002927f, 0.10599691f, -0.09955898f, 
    0.11919224f, -0.01886890f, 0.06753028f, 0.00896836f, 0.08369065f, 0.10862112f, -0.05498377f, 0.01086658f, 
    0.14027922f, -0.02063882f, 0.06560934f, 0.03007980f, 0.02281419f, 0.02209623f, 0.12720008f, -0.01372493f, 
    0.16035506f, 0.07456667f, 0.06283192f, -0.10202851f, -0.07879462f, -0.02374149f, -0.05007479f, -0.02075124f, 
    0.07495598f, -0.03512492f, 0.01634173f, -0.03738699f, 0.06663433f, -0.22582775f, -0.00809494f, 0.17743170f, 
    -0.04541327f, -0.11056197f, -0.13739835f, -0.14116631f, -0.00136643f, -0.00340184f, 0.10593342f, -0.11700748f, 
    -0.28599769f, 0.36707786f, -0.11667709f, -0.21896455f, -0.01307240f, 0.00941900f, 0.00359660f, -0.01660221f, 
    0.07487770f, 0.04064807f, -0.05676186f, 0.02084813f, 0.13916554f, 0.03550294f, -0.04317912f, 0.13480681f, 
    -0.06025050f, -0.02116465f, -0.00287346f, 0.06069520f, -0.10099975f, 0.07853199f, -0.04387006f, -0.01596325f, 
    -0.08190941f, 0.12374692f, 0.05888104f, -0.39897591f, -0.03659136f, 0.07076288f, 0.10989282f, 0.04773829f, 
    -0.01286095f, 0.07133780f, 0.04626061f, 0.02861576f, 0.13833958f, -0.01458793f, -0.03533906f, -0.19587316f, 
    0.14784853f, 0.18175276f, -0.05344181f, -0.04498811f, 0.02744002f, 0.06113108f, -0.19423331f, 0.03772386f, 
    -0.11260663f, -0.03911660f, 0.03630869f, 0.07026085f, 0.00630072f, -0.03812862f, -0.04030457f, -0.09236144f, 
    0.02772440f, 0.00766904f, 0.05817132f, -0.00123043f, -0.41243476f, 0.11463632f, -0.05232094f, -0.14615072f, 
    -0.07900219f, 0.04936541f, -0.05916619f, -0.14415050f, -0.05943158f, -0.00857739f, -0.02353470f, 0.06484199f, 
    -0.36448801f, -0.23774202f, 0.02633579f, -0.10867769f, -0.02002386f, 0.05237210f, -0.02098710f, 0.00352952f, 
    -0.02941163f, -0.05703959f, -0.04493335f, -0.04519357f, 0.22950050f, -0.02071005f, 0.07663010f, -0.33528134f, 
    0.03672384f, -0.08889487f, -0.01199203f, 0.02854537f, 0.09527370f, -0.01836502f, -0.03291658f, 0.01596794f, 
    0.01510730f, 0.14843550f, -0.07369805f, 0.46460235f, -0.05323911f, -0.00723036f, 0.15440887f, -0.06528130f, 
    0.11205287f, 0.05337871f, 0.01405114f, -0.02939904f, -0.07271755f, 0.04659317f, 0.10624611f, 0.04648378f, 
    0.01061907f, -0.04859919f, 0.08349833f, 0.04783642f, 0.08991038f, -0.04584632f, -0.03510137f, 0.00350216f, 
    0.20371658f, 0.04318275f, 0.14147136f, -0.01423919f, 0.08854147f, 0.00131172f, 0.03647180f, -0.03725921f, 
    0.09176384f, -0.06834648f, 0.03532133f, -0.00817663f, -0.01294294f, -0.07758741f, 0.01305463f, -0.26459983f, 
    -0.14292403f, -0.09304015f, 0.03446460f, 0.13367790f, -0.01465496f, -0.05226708f, 0.03507816f, -0.03425569f, 
    -0.17653933f, 0.02361549f, 0.15982895f, -0.27010399f, -0.00420711f, 0.02004302f, 0.09462433f, -0.01741990f, 
    0.07790467f, 0.05945919f, 0.13468924f, -0.08940455f, -0.16943540f, -0.06008456f, -0.27296823f, 0.11556108f, 
    0.06074947f, 0.08926675f, 0.03782970f, 0.11605605f, 0.04327794f, -0.04803061f, -0.10032188f, -0.04324194f, 
    0.00408219f, 0.03268396f, -0.05824218f, 0.06575695f, -0.12520996f, 0.05180039f, -0.02184003f, -0.04857754f, 
    0.00661802f, -0.11882044f, -0.03489152f, -0.05290068f, 0.07940662f, -0.08044254f, 0.14363964f, -0.12033030f, 
    0.04519702f, -0.14739737f, 0.00399929f, 0.07079891f, 0.11943910f, -0.06884489f, 0.03752398f, -0.01419088f, 
    -0.19246468f, -0.00453443f, -0.17150944f, -0.08151697f, -0.06681748f, 0.00359915f, -0.02262358f, -0.10071703f, 
    0.13533920f, -0.06919105f, 0.06688624f, 0.05825015f, 0.14921860f, 0.25918922f, -0.00104891f, -0.09602989f, 
    -0.02778058f, 0.03991394f, -0.03197407f, 0.02747321f, 0.05546326f, 0.09275302f, 0.16957019f, 0.01085654f, 
    0.22940032f, -0.17087443f, -0.20693493f, 0.09910443f, 0.11438719f, 0.12708226f, -0.04634770f, 0.10168137f, 
    -0.10744239f, 0.03113612f, -0.09139188f, -0.06050482f, 0.06670797f, 0.04800879f, 0.03084323f, 0.12851839f, 
    -0.03558555f, -0.00392869f, 0.00021740f, -0.02400486f, -0.03364644f, -0.04045296f, -0.05534388f, -0.00571431f, 
    -0.03115210f, -0.04424901f, -0.22123274f, -0.09900635f, -0.05110315f, -0.04844541f, -0.03822822f, -0.04726826f, 
    -0.15645137f, 0.03839902f, 0.03553160f, -0.16530792f, -0.29337484f, -0.13819772f, -0.00385307f, -0.06655757f, 
    0.10173862f, -0.00338712f, -0.02151687f, 0.10151419f, -0.02967284f, 0.06524476f, 0.11853649f, 0.01365143f, 
    0.08992207f, 0.03173172f, 0.00548652f, 0.01241706f, 0.14343840f, 0.03113077f, -0.05988382f, -0.00446178f, 
    0.05929660f, -0.00735565f, 0.14990899f, -0.00144820f, 0.10411836f, 0.00689993f, -0.12626593f, 0.03873595f, 
    -0.03023001f, 0.08025423f, -0.02671060f, -0.06568384f, -0.04165911f, -0.06749582f, 0.02726795f, 0.00188849f, 
    0.03602546f, -0.15292129f, 0.05730864f, 0.08926926f, 0.07938196f, -0.00999061f, 0.05104682f, -0.02217784f, 
    -0.02798145f, 0.10209450f, -0.16124399f, 0.06458101f, -0.02195512f, -0.04265331f, -0.02768024f, 0.09594071f, 
    -0.05595597f, -0.03648857f, -0.02407847f, 0.06410009f, 0.04629274f, -0.13013667f, 0.01060227f, -0.00222444f, 
    -0.08433116f, -0.06169595f, -0.06771560f, 0.13434775f, -0.09313630f, -0.13264364f, 0.01778059f, 0.03911077f, 
    -0.13024312f, -0.04762168f, -0.05124571f, 0.12594226f, 0.07287847f, 0.00795760f, -0.36833388f, 0.06710801f, 
    -0.02725505f, -0.06699412f, -0.07875233f, -0.08112002f, 0.01872329f, 0.00290207f, -0.00846992f, -0.01232790f, 
    -0.01431698f, 0.05384653f, 0.08398686f, 0.05688840f, -0.11524926f, -0.02653741f, -0.09714232f, -0.10216721f, 
    0.00065019f, 0.03913890f, -0.03995194f, 0.06367477f, -0.12724490f, 0.09530664f, -0.07132310f, 0.12385409f, 
    0.03635895f, 0.04057272f, -0.04784658f, 0.05987588f, -0.07745942f, 0.13558728f, 0.07654858f, 0.12456376f, 
    0.26528502f, -0.33099720f, -0.17582308f, -0.11455393f, 0.01494134f, -0.05677899f, -0.02955685f, 0.21660371f, 
    -0.16189222f, -0.00386713f, -0.21924280f, -0.15099919f, -0.15649992f, 0.18028650f, 0.06258937f, 0.01451739f, 
    -0.01376094f, 0.04383151f, 0.02439689f, -0.07816730f, 0.07385483f, 0.05988161f, 0.06784115f, -0.09196198f, 
    0.08050975f, -0.15059830f, -0.00545416f, 0.13539837f, -0.02378236f, -0.01432373f, 0.03094632f, 0.06784890f, 
    -0.00774102f, 0.08507250f, -0.04415005f, 0.04494581f, 0.14524533f, 0.03236263f, 0.20957057f, 0.17515789f, 
    -0.07836612f, -0.12717144f, -0.03050598f, -0.04639430f, 0.01829832f, -0.02505163f, -0.06708362f, 0.07953538f, 
    -0.33123758f, -0.01125860f, -0.03069177f, 0.12960929f, -0.00591478f, -0.16535090f, -0.02817868f, -0.03734784f, 
    0.18135758f, 0.00268524f, -0.00786413f, 0.05974039f, 0.01870961f, 0.01334920f, -0.07817258f, -0.01130714f, 
    0.14379123f, -0.05439252f, 0.05852560f, 0.07449823f, 0.05605662f, -0.02190326f, 0.08408982f, -0.03443852f, 
    -0.16622120f, 0.11424201f, -0.01446983f, -0.07793707f, -0.02865964f, -0.14819147f, -0.02822365f, -0.11402652f, 
    0.00144870f, -0.12333015f, -0.12997343f, -0.29568431f, 0.08859370f, -0.05458716f, -0.03333700f, 0.05284271f, 
    0.05587185f, -0.00194203f, 0.06212934f, -0.07223363f, -0.00934444f, 0.10505098f, 0.00235627f, 0.09910589f, 
    0.28008699f, -0.10136469f, 0.03703826f, -0.07871833f, -0.03994009f, 0.02964781f, -0.16480482f, -0.04129058f, 
    0.00445221f, -0.29411095f, 0.10130902f, -0.08482926f, -0.75600082f, -0.06282766f, 0.02092070f, -0.09147325f, 
    -0.01291154f, -0.13805321f, -0.05297431f, 0.07683576f, 0.04774338f, -0.01617947f, -0.03922277f, -0.03763437f, 
    0.03272111f, 0.00289673f, 0.16733289f, -0.04961656f, 0.01452755f, 0.07606607f, 0.07173413f, -0.00326463f, 
    0.00092376f, 0.09020372f, -0.07973793f, 0.00584073f, 0.03476555f, 0.13890658f, 0.19475411f, 0.20354892f, 
    -0.00849670f, -0.04758766f, -0.01891482f, -0.01684082f, 0.00786233f, 0.02604964f, 0.05850158f, -0.05726107f, 
    -0.11790359f, -0.13966851f, -0.12585871f, -0.14927912f, 0.01105308f, -0.04209141f, -0.09259776f, -0.04111985f, 
    0.09710121f, 0.14553873f, -0.04390144f, -0.02601958f, 0.22889705f, -0.31951189f, 0.09269998f, -0.08803895f, 
    -0.03588172f, -0.05322500f, -0.02816008f, 0.02072776f, 0.03582605f, 0.03011992f, -0.22333449f, 0.09695005f, 
    0.00300495f, 0.01081893f, -0.09192849f, -0.07045673f, 0.05212814f, -0.05622876f, 0.07701370f, 0.15927994f, 
    -0.06658951f, -0.04761258f, 0.00163213f, 0.03774219f, 0.25762534f, 0.08042303f, 0.02472335f, 0.12803793f, 
    -0.04400165f, 0.03198940f, 0.02400638f, -0.04599477f, -0.00211960f, -0.04808565f, 0.04923715f, -0.05313276f, 
    0.24510652f, -0.08685544f, -0.02323936f, 0.05421583f, 0.03524986f, 0.02072998f, -0.05945249f, 0.03062487f, 
    -0.03872121f, -0.03096276f, 0.12327055f, 0.00852830f, 0.28146914f, 0.00402237f, 0.04325781f, 0.27794930f, 
    -0.09333940f, 0.01933952f, 0.01010587f, 0.01169320f, 0.02274449f, -0.06444529f, -0.03783266f, 0.00024365f, 
    0.09546784f, 0.07616007f, 0.08438779f, -0.09746353f, 0.05101067f, -0.00735779f, -0.00239055f, 0.10226890f, 
    0.01371782f, 0.04136813f, 0.01454533f, 0.01494816f, 0.24516046f, -0.07667200f, -0.11644736f, 0.01504642f, 
    -0.03130388f, -0.04654758f, 0.02992198f, 0.04979051f, 0.09780280f, -0.07652479f, 0.01132237f, 0.00316506f, 
    -0.08289488f, 0.09472150f, -0.28891996f, -0.26131806f, 0.08332835f, -0.03481666f, 0.10647659f, 0.00023301f, 
    -0.04331649f, 0.09169107f, 0.06592181f, 0.07927678f, 0.06166042f, 0.04755653f, 0.08739838f, -0.29783249f, 
    -0.04992516f, -0.06891380f, -0.00954939f, 0.11131802f, 0.07604709f, -0.00211903f, -0.01695045f, -0.05069001f, 
    0.48512870f, -0.02963048f, 0.07412953f, 0.02464707f, -0.01451918f, 0.03693856f, 0.00822687f, -0.02527648f, 
    0.11337959f, -0.03186140f, 0.03797150f, -0.10088539f, 0.18412142f, -0.14924963f, -0.08125449f, 0.05634884f, 
    -0.11425734f, 0.07167158f, 0.11817766f, 0.07263165f, -0.04026077f, 0.03505637f, -0.02732330f, 0.17521794f, 
    0.22897300f, -0.13318916f, -0.22635351f, 0.07306587f, -0.03094506f, 0.03696573f, -0.05664161f, 0.05791191f, 
    -0.00194283f, 0.04404375f, 0.13557021f, 0.00601680f, 0.04530576f, 0.15995228f, 0.02943536f, -0.06000117f, 
    -0.13851304f, 0.07338141f, 0.03939367f, 0.08387948f, -0.04732227f, -0.00836437f, -0.06747567f, 0.07681914f, 
    0.12341295f, -0.24976620f, 0.07145910f, -0.20493153f, -0.10684204f, -0.02548357f, -0.06874061f, -0.06684852f, 
    -0.13958359f, 0.07468005f, 0.02586302f, -0.09767186f, -0.29119718f, 0.03577559f, -0.02926172f, -0.16130039f, 
    0.04368220f, 0.03331172f, 0.02443581f, -0.10197202f, 0.20086993f, 0.09760983f, -0.03799571f, 0.00652980f, 
    0.14157334f, -0.38110638f, 0.14320338f, -0.32748002f, -0.01262396f, -0.01819057f, -0.05434115f, 0.01444425f, 
    -0.08956397f, -0.01325224f, 0.03974135f, -0.02919967f, 0.03341188f, 0.12605864f, 0.00264681f, -0.14174061f, 
    -0.12943222f, -0.03736838f, -0.00579348f, -0.00806000f, 0.11767972f, -0.00079034f, 0.04698263f, -0.09914780f, 
    -0.09516968f, -0.01568070f, -0.03021936f, -0.38555026f, 0.12969175f, 0.03708072f, 0.03527465f, 0.02564363f, 
    0.08646666f, -0.05139707f, -0.02558545f, -0.09743676f, -0.01818705f, -0.04769137f, 0.06257208f, 0.03754226f, 
    -0.07392363f, 0.09998421f, -0.16345027f, -0.00497439f, 0.15552899f, -0.00768188f, -0.04519757f, 0.06244029f, 
    0.10339265f, -0.06014144f, 0.02369583f, 0.19933419f, -0.06738617f, -0.03908606f, 0.10070178f, 0.04657551f, 
    0.03685734f, -0.06974155f, -0.04551841f, 0.06627135f, -0.14078864f, -0.11915069f, -0.12521729f, -0.03121948f, 
    0.01111451f, -0.00079646f, -0.01025761f, 0.18937050f, -0.02842405f, 0.01849720f, -0.13551383f, -0.03684821f, 
    0.25364447f, -0.08388937f, -0.00898035f, 0.01059243f, 0.08037011f, 0.06969713f, -0.03021641f, 0.09664272f, 
    0.02566466f, -0.08854163f, -0.03281650f, 0.01621584f, 0.15730304f, 0.05451661f, 0.16689135f, 0.22422646f, 
    -0.12307911f, 0.03165381f, 0.02145774f, 0.01186248f, -0.03200500f, -0.02133527f, 0.04016991f, -0.02816772f, 
    0.09192640f, -0.06918636f, 0.02982681f, -0.22657979f, 0.08695628f, -0.06635407f, -0.09037916f, 0.03016110f, 
    0.05110443f, 0.03420512f, -0.02020220f, -0.02563910f, -0.04348420f, 0.06030002f, -0.01262529f, -0.00462929f, 
    0.07644903f, 0.05420921f, 0.00320231f, 0.04767588f, -0.04555319f, 0.05432444f, 0.10525564f, 0.06451759f, 
    -0.02345035f, 0.01232635f, -0.02293266f, 0.19328541f, -0.24746475f, 0.07754631f, -0.03896034f, -0.01354441f, 
    -0.01834951f, -0.05061186f, -0.07916657f, 0.09752999f, 0.22524089f, -0.22458106f, -0.15995200f, -0.18195386f, 
    -0.09417970f, 0.03613444f, 0.05675903f, 0.09726713f, -0.03647278f, 0.05566201f, -0.03125718f, 0.09114101f, 
    0.11271580f, 0.07004699f, -0.10672572f, -0.05066503f, -0.02651729f, -0.04148189f, 0.08597888f, 0.06573617f, 
    -0.08745707f, -0.01934158f, -0.08470495f, -0.11046307f, 0.00423456f, -0.10082500f, 0.08495221f, -0.09088934f, 
    0.05828422f, 0.07571597f, 0.08470677f, 0.06363717f, -0.02825225f, -0.05459998f, -0.00130226f, 0.01854063f, 
    -0.49560681f, 0.03280359f, -0.19651294f, 0.01175378f, 0.00178886f, -0.12241468f, -0.09322134f, -0.09953247f, 
    -0.02158000f, -0.13550176f, -0.08890088f, -0.01908657f, -0.05894598f, -0.12895754f, -0.19533916f, -0.05466540f, 
    -0.01375272f, 0.10527995f, -0.14008638f, 0.01534920f, -0.02262482f, 0.12716749f, -0.01812692f, 0.01162717f, 
    -0.08478969f, -0.13986535f, -0.06084635f, -0.09681137f, 0.19096562f, 0.01937545f, -0.03953211f, -0.01720236f, 
    0.05286914f, 0.08428376f, -0.17173558f, -0.03005312f, 0.27350363f, -0.04209811f, -0.00767931f, -0.11069109f, 
    -0.05631756f, -0.13226457f, 0.04997127f, -0.01155645f, -0.14874023f, 0.08087338f, 0.07228956f, -0.00261821f, 
    0.41897690f, -0.12393000f, -0.21408942f, -0.25344548f, -0.16529542f, -0.09849072f, 0.05845731f, -0.02821992f, 
    0.00414435f, -0.02140297f, 0.04877899f, 0.08959094f, -0.20449366f, 0.12151358f, -0.21332780f, 0.09628353f, 
    -0.01853877f, -0.02726106f, 0.08831045f, 0.07746691f, -0.12045065f, -0.13173136f, -0.09594874f, 0.10817045f, 
    0.16501421f, -0.07609265f, 0.04923102f, 0.03592954f, -0.08371560f, -0.06130021f, 0.00851780f, 0.05370741f, 
    0.05307748f, 0.04088473f, -0.09593304f, 0.01433498f, -0.14826028f, 0.07522450f, 0.05126762f, 0.08644497f, 
    0.00719621f, 0.09785914f, 0.12051240f, 0.09526789f, -0.03977165f, 0.07409284f, -0.04251153f, -0.06639872f, 
    0.33752871f, -0.00168954f, -0.13354960f, -0.14311081f, -0.06504314f, -0.00833244f, 0.02066482f, -0.00856461f, 
    -0.05155443f, -0.02477520f, -0.03672189f, -0.10276820f, 0.24370758f, -0.08085892f, -0.08137622f, -0.03163512f, 
    0.08037434f, -0.03394877f, -0.01530789f, -0.14218293f, -0.04958518f, -0.05935343f, 0.02224056f, 0.08205187f, 
    -0.08820061f, -0.43240628f, 0.07244954f, -0.07226904f, -0.00282409f, 0.02211401f, -0.14666697f, -0.02499548f, 
    0.08155290f, 0.09633829f, -0.03427418f, 0.02326437f, -0.05023833f, 0.07048944f, 0.02067730f, -0.06652298f, 
    0.01388311f, 0.02461353f, 0.10539915f, -0.03557457f, -0.01069131f, -0.02405758f, -0.01947474f, 0.00297896f, 
    0.17492948f, -0.26504827f, -0.00545551f, 0.01345904f, -0.04143715f, 0.03945287f, 0.03175202f, -0.10482058f, 
    0.02562158f, -0.00001687f, -0.09324415f, 0.11226397f, -0.04559055f, -0.05260179f, -0.17223409f, -0.04389700f, 
    0.06190104f, 0.14062971f, -0.04474342f, -0.02255888f, -0.06182147f, 0.00106050f, 0.06230177f, -0.04851576f, 
    -0.29265746f, -0.15079293f, 0.04898210f, -0.31994587f, -0.00808026f, -0.02829041f, -0.12319304f, 0.02144764f, 
    -0.08615747f, 0.02905896f, -0.02865949f, -0.05160240f, -0.01980608f, -0.00597737f, -0.06998021f, 0.17844619f, 
    0.10784987f, 0.02464248f, -0.02344186f, -0.09373498f, -0.05170994f, -0.08778780f, -0.06753845f, -0.04241156f, 
    -0.15891473f, 0.05608144f, -0.14359556f, -0.20532231f, 0.09430879f, 0.04194111f, 0.08588062f, -0.02323284f, 
    0.06590877f, 0.06757620f, 0.08629445f, -0.02472795f, -0.30170617f, -0.03398206f, -0.04129901f, -0.16437024f, 
    -0.02516480f, 0.03113277f, -0.00913671f, -0.09076751f, 0.00675936f, 0.00553256f, 0.05686486f, 0.01848683f, 
    -0.11421263f, -0.06954309f, -0.19744208f, -0.06027025f, -0.03438134f, -0.02708857f, -0.03276968f, -0.00685299f, 
    -0.01609083f, -0.02540447f, -0.09598046f, 0.03259053f, -0.21583889f, 0.11106041f, -0.06875198f, -0.10065234f, 
    -0.06765742f, 0.03683393f, 0.01047018f, 0.14396766f, 0.01368844f, -0.00358330f, -0.04664461f, 0.02132173f, 
    0.13125464f, -0.04527853f, 0.08677498f, 0.00434348f, -0.02397638f, -0.07227948f, 0.01442014f, 0.01959448f, 
    0.00111286f, -0.03005125f, 0.02306352f, -0.12546284f, 0.05129113f, 0.01394930f, 0.00350937f, -0.12129133f, 
    0.01182808f, -0.06753197f, -0.06278606f, -0.06553528f, -0.16291037f, -0.04577452f, -0.08958632f, -0.19807261f, 
    -0.17462203f, 0.05852825f, -0.12830834f, -0.11184555f, -0.03060119f, -0.11414821f, 0.05275895f, 0.06715960f, 
    0.02977450f, 0.07159889f, 0.01448424f, -0.09511282f, -0.39981294f, 0.02199589f, -0.10213166f, -0.15979730f, 
    -0.08573238f, 0.10792554f, -0.09935847f, -0.04666996f, 0.03768050f, 0.02584878f, 0.02934561f, -0.08685084f, 
    -0.01620272f, -0.14062178f, -0.13052440f, -0.18645296f, -0.01548859f, 0.01954325f, -0.03442571f, -0.04381021f, 
    -0.02771414f, -0.09043687f, -0.00548033f, -0.03245731f, 0.07671072f, 0.08790892f, -0.00444017f, -0.00095745f, 
    0.00539814f, 0.03774305f, 0.03482869f, -0.05460435f, 0.03534543f, 0.01500764f, -0.00510699f, -0.09275363f, 
    0.03826836f, -0.12763140f, -0.11656499f, -0.11318662f, -0.23546843f, -0.00826397f, 0.03869926f, 0.03505057f, 
    0.00633504f, 0.01339952f, -0.07859188f, 0.06864806f, -0.30041537f, 0.01388650f, -0.02424571f, -0.20750125f, 
    -0.03888060f, 0.02926316f, 0.03877474f, -0.02667440f, -0.16736884f, 0.00927315f, -0.03816929f, 0.04044242f, 
    0.13255577f, -0.09456971f, -0.05394529f, -0.20250390f, 0.05665213f, 0.12964994f, 0.07233186f, 0.04791600f, 
    -0.09821864f, 0.05736534f, 0.11122204f, -0.05296142f, 0.16005564f, 0.01926996f, 0.08123925f, 0.07890338f, 
    -0.12511460f, -0.08571520f, 0.02187665f, 0.04849961f, 0.07039159f, 0.04055002f, 0.03582704f, -0.14129555f, 
    -0.01108565f, 0.04915553f, 0.16393588f, 0.13130248f, 0.06112286f, -0.08297278f, 0.06300618f, -0.05176979f, 
    -0.11777136f, -0.01747178f, -0.05853096f, 0.00104436f, 0.38849297f, 0.17583299f, 0.08322508f, 0.00397622f, 
    -0.05011562f, 0.07091226f, 0.03461555f, -0.05319112f, -0.09073491f, 0.09729820f, 0.04875050f, -0.03778786f, 
    0.22823818f, 0.12591220f, -0.18739784f, 0.11298289f, 0.07662172f, 0.06157150f, -0.02413579f, -0.17923312f, 
    -0.04163017f, -0.05393932f, 0.04401237f, -0.19127379f, 0.04860215f, 0.08196986f, 0.01682098f, 0.00860506f, 
    0.09221339f, 0.01325077f, -0.00079588f, -0.08182722f, -0.02386433f, 0.02420699f, -0.12156494f, 0.02096720f, 
    0.18044558f, 0.10827851f, 0.05579560f, 0.02416357f, -0.00617471f, -0.03905073f, -0.06062793f, 0.05908301f, 
    -0.02529334f, -0.11370637f, 0.11421595f, -0.02753317f, 0.14365186f, -0.06913707f, 0.13786997f, 0.07879799f, 
    -0.05717975f, -0.07062261f, 0.01248365f, 0.08102339f, -0.00268198f, -0.03963960f, 0.04835328f, 0.00995582f, 
    0.28704518f, 0.05731924f, -0.09091527f, 0.05395130f, -0.07057935f, -0.04205705f, 0.05054120f, 0.01146671f, 
    -0.00873467f, 0.08764631f, -0.01711054f, -0.00839987f, 0.00793158f, -0.06013767f, -0.00284307f, -0.03017675f, 
    0.02950388f, 0.03027843f, 0.03348740f, -0.01661850f, 0.00692836f, 0.06287010f, -0.01443832f, -0.01397147f, 
    0.52137619f, 0.01141462f, -0.01572502f, 0.05881594f, -0.06857530f, -0.02769604f, -0.04646056f, -0.04305443f, 
    -0.00146542f, -0.02510698f, 0.01041686f, -0.07937957f, -0.11386342f, -0.05253742f, 0.07864524f, -0.07471974f, 
    0.08546309f, 0.03072124f, -0.01832261f, 0.03372205f, -0.00876381f, 0.01857684f, 0.01121644f, -0.05745302f, 
    -0.07338633f, 0.11522394f, 0.01813301f, 0.17118391f, -0.03861753f, -0.03354725f, 0.09149216f, 0.02643980f, 
    -0.11396980f, -0.01731773f, -0.07334292f, 0.01755976f, 0.11394488f, 0.01715173f, 0.07364102f, 0.24229582f, 
    -0.07983543f, -0.04985060f, -0.01733227f, 0.01218470f, 0.00724193f, -0.03026718f, 0.02285437f, -0.03009956f, 
    -0.33179846f, 0.09095839f, -0.17194605f, -0.15571713f, 0.09878077f, 0.09302451f, 0.00689383f, -0.09271792f, 
    0.00338381f, -0.01781353f, -0.06594708f, -0.03581171f, 0.01372045f, -0.04493042f, -0.07416376f, 0.05420309f, 
    0.01211689f, 0.05691007f, -0.00621055f, -0.00986904f, 0.00621447f, -0.00451535f, -0.08411373f, 0.03033521f, 
    -0.04490432f, 0.08567250f, -0.04188948f, -0.02485972f, -0.03023723f, 0.03088586f, 0.03965647f, 0.04420957f, 
    -0.14039639f, -0.07858361f, 0.00731736f, -0.09260441f, 0.44184145f, -0.24888818f, -0.01686617f, 0.03670979f, 
    -0.13524169f, -0.05502857f, 0.00174435f, 0.00149570f, -0.01115829f, -0.05339199f, 0.02679359f, 0.01814147f, 
    0.37663007f, -0.24421793f, 0.14014445f, 0.05875992f, -0.10194452f, 0.00208563f, -0.08092011f, -0.01450514f, 
    -0.01606817f, -0.14828314f, -0.04760318f, 0.09069588f, 0.21067362f, 0.09839639f, -0.19239843f, -0.16004065f, 
    0.19297695f, 0.12204738f, -0.06171864f, -0.07171675f, 0.03640191f, 0.06551254f, -0.07076302f, 0.06790035f, 
    -0.05473668f, -0.15531474f, 0.09342395f, -0.17524996f, -0.00541476f, 0.07097554f, 0.07218073f, 0.09874042f, 
    0.10762572f, -0.10217877f, -0.01796648f, -0.06085217f, 0.14658570f, 0.14828056f, -0.02488618f, 0.17265493f, 
    -0.04361072f, -0.04090498f, 0.06221576f, 0.03480506f, -0.11510781f, 0.12346450f, -0.05942145f, -0.03946285f, 
    -0.35932744f, 0.04903489f, 0.12302521f, 0.01792664f, -0.03944269f, 0.04888471f, -0.01138138f, -0.00443787f, 
    -0.04438101f, -0.03098989f, -0.08824040f, 0.05266129f, -0.22841486f, -0.03658243f, -0.07588528f, -0.14350808f, 
    0.00183780f, 0.08169705f, 0.00309908f, 0.02127456f, -0.01648432f, 0.06337202f, -0.12561950f, -0.02245128f, 
    -0.19437540f, -0.21328744f, -0.09135922f, 0.02493377f, -0.03272573f, -0.01848501f, -0.04495723f, -0.09598873f, 
    -0.10865498f, 0.05047671f, -0.05844096f, 0.04395135f, -0.17421344f, -0.04139302f, 0.05057070f, 0.14193328f, 
    -0.02467283f, -0.08073049f, -0.12786476f, 0.00376166f, 0.03450250f, 0.01152604f, -0.07072984f, -0.02974927f, 
    -0.04623361f, 0.08211019f, -0.06656352f, -0.00008860f, 0.06209146f, -0.00935767f, 0.05059841f, -0.10173051f, 
    -0.00019993f, 0.04933524f, 0.00687732f, -0.01761699f, 0.00903640f, 0.02592910f, -0.05340056f, -0.12501588f, 
    -0.05416287f, 0.00035741f, -0.14902726f, -0.01133818f, 0.01328206f, 0.03740919f, 0.06172336f, -0.16436374f, 
    0.26705223f, 0.03614374f, -0.06769847f, 0.12463421f, -0.13173103f, -0.03674605f, -0.07246878f, 0.01061627f, 
    0.03429871f, -0.01082102f, 0.05805644f, -0.02014480f, 0.03648107f, 0.01088612f, -0.02988717f, 0.05165675f, 
    0.00512550f, 0.03053619f, 0.00464215f, 0.01378051f, -0.01130116f, 0.07429320f, -0.00843343f, -0.00565863f, 
    0.11762153f, 0.02810412f, -0.07934280f, 0.23834439f, -0.04268907f, -0.02596487f, 0.01036410f, 0.01550598f, 
    -0.04854894f, 0.08856388f, -0.06094670f, 0.08736688f, 0.06670784f, 0.10201865f, 0.08406802f, 0.12969704f, 
    -0.08068662f, -0.13202004f, -0.12249281f, 0.11015914f, -0.11875007f, 0.07889803f, 0.02977875f, -0.15143581f, 
    0.25703609f, 0.02647617f, 0.01667324f, 0.03599514f, 0.08625498f, -0.00808695f, 0.01000807f, 0.03825577f, 
    -0.04517413f, 0.06894604f, 0.04564238f, -0.06973264f, -0.19939345f, 0.03362232f, -0.00717122f, -0.21843250f, 
    -0.09244584f, -0.03124317f, 0.05839518f, -0.07257522f, -0.08291246f, 0.00183157f, 0.08851089f, -0.07760935f, 
    0.01863097f, -0.00912121f, 0.06166519f, -0.22253990f, 0.04611973f, -0.15351869f, -0.10502739f, 0.01961943f, 
    0.02229223f, 0.04831190f, -0.01783548f, -0.05446614f, 0.17076197f, 0.05129465f, 0.07784713f, 0.12957430f, 
    -0.06744179f, -0.06451426f, 0.00861061f, 0.16365752f, -0.06660534f, 0.03857797f, 0.06703766f, 0.01105530f, 
    -0.01315966f, -0.11679532f, -0.30380544f, -0.03921521f, -0.17293127f, 0.04724983f, -0.00910847f, 0.02270132f, 
    0.07028534f, 0.05137420f, -0.03404819f, -0.11719771f, 0.25582674f, -0.03735166f, -0.00469039f, -0.12558427f, 
    0.13549782f, -0.02738914f, 0.07167120f, -0.01271325f, -0.00851401f, 0.01324126f, 0.02959430f, -0.07997985f, 
    0.21200363f, -0.07261434f, -0.04719475f, 0.04844427f, 0.03750040f, 0.01560675f, -0.05538186f, 0.04634409f, 
    -0.01911379f, -0.00649484f, 0.04151674f, -0.03517218f, -0.03348352f, 0.02814302f, 0.03883718f, -0.10454592f, 
    0.05080511f, -0.08017711f, 0.04219672f, -0.02247986f, -0.07031292f, -0.03587250f, -0.01809799f, -0.05143515f, 
    -0.04903695f, -0.02516626f, 0.16930702f, -0.03674712f, -0.08620843f, -0.09600946f, 0.01662433f, 0.04263888f, 
    -0.03437187f, -0.03070795f, 0.05771240f, -0.07639202f, 0.24265869f, -0.23513857f, -0.12076934f, -0.03816597f, 
    0.01684260f, -0.00080372f, -0.13447073f, 0.02326562f, 0.04568358f, -0.01169220f, -0.01250248f, -0.06215994f, 
    0.16058624f, -0.00778320f, 0.15357311f, 0.02036523f, 0.06730586f, 0.04981561f, 0.02943859f, 0.04468971f, 
    -0.04222992f, 0.02886293f, -0.05303835f, 0.05729069f, -0.05673672f, 0.00459459f, -0.05040749f, -0.04452318f, 
    -0.05978729f, 0.07725441f, -0.06776430f, -0.02384843f, 0.00448043f, 0.08813122f, -0.12984705f, 0.00803213f, 
    -0.23562641f, 0.27798572f, 0.01870344f, 0.16236959f, -0.00969470f, -0.01987746f, -0.05605749f, 0.03967420f, 
    -0.04793078f, 0.06782856f, 0.03186965f, -0.07506393f, -0.41057470f, 0.03446967f, 0.17340441f, 0.02435922f, 
    0.09919570f, -0.03750225f, -0.03027057f, 0.01619727f, 0.00977574f, 0.08000939f, -0.09778469f, -0.02573619f, 
    0.26890209f, 0.07689599f, -0.02833709f, 0.18106066f, -0.00142024f, -0.04384189f, 0.06917320f, -0.01993180f, 
    0.04440597f, 0.08330084f, 0.11257300f, 0.00405915f, -0.37399232f, -0.30825827f, -0.09516344f, 0.16755392f, 
    -0.14112192f, 0.00467664f, -0.03558461f, 0.03516958f, -0.07846568f, 0.00525773f, -0.00154244f, -0.04070006f, 
    0.69578254f, 0.08234084f, 0.20034541f, 0.17012547f, 0.08615047f, 0.05705340f, 0.00610296f, 0.03296778f, 
    -0.02136530f, 0.04884226f, -0.15307608f, -0.07687152f, 0.12690535f, 0.06853086f, 0.12978524f, 0.28804994f, 
    0.06217399f, 0.06242503f, -0.02734598f, -0.10365874f, -0.03636612f, 0.02134512f, 0.01926420f, -0.14837667f, 
    0.25022945f, -0.07430453f, -0.01682395f, 0.09774033f, -0.08206802f, 0.01499167f, -0.03125482f, 0.03204645f, 
    0.06359176f, 0.01805643f, -0.06055332f, -0.01745128f, 0.04682986f, -0.25747794f, 0.10419147f, 0.26433545f, 
    0.03475004f, 0.06225954f, 0.06215343f, -0.03348100f, 0.04812320f, 0.03434623f, -0.07838551f, -0.10610472f, 
    -0.00543422f, -0.06317300f, -0.00635966f, -0.00563815f, -0.02755074f, 0.07225308f, -0.04498037f, 0.02345091f, 
    0.04714092f, -0.03351941f, 0.10482503f, -0.09697433f, 0.27645773f, -0.31293646f, -0.12623213f, 0.04428577f, 
    0.04700280f, 0.13376455f, -0.00737994f, 0.01881822f, 0.05061118f, 0.12632041f, -0.09281781f, 0.08196396f, 
    0.03544775f, 0.06248255f, 0.07442638f, -0.08708578f, -0.12397752f, 0.02037351f, -0.05887382f, 0.05679052f, 
    -0.03633672f, -0.04306516f, 0.07602458f, -0.06266213f, -0.28216356f, 0.35526237f, -0.04821261f, 0.01104748f, 
    -0.07757303f, 0.10057569f, 0.08382713f, 0.04732799f, 0.06311283f, -0.02951876f, 0.01616366f, 0.08843421f, 
    -0.20066057f, -0.03958748f, -0.10604099f, -0.18510330f, -0.05618732f, -0.02568359f, 0.06231127f, 0.02646947f, 
    -0.05884212f, 0.07776323f, -0.02664203f, 0.03131136f, -0.02615984f, 0.02185624f, 0.06047778f, -0.08728854f, 
    -0.05002973f, -0.04239237f, 0.04408835f, 0.05869166f, 0.00343857f, -0.02469002f, 0.04661192f, 0.01129065f, 
    0.23813707f, 0.05473626f, -0.02151291f, -0.12785149f, 0.08087660f, 0.07334793f, 0.00801311f, -0.09065437f, 
    0.07187670f, -0.03953876f, 0.16814609f, 0.03792516f, 0.24490553f, -0.07658150f, -0.05121223f, -0.00738969f, 
    0.04760511f, 0.13171676f, -0.01325023f, -0.01027682f, 0.07362641f, -0.04739209f, -0.02430899f, 0.05146125f, 
    0.18135840f, -0.06635768f, 0.06154828f, -0.10540927f, 0.04483631f, 0.04918901f, -0.04734714f, -0.00408932f, 
    -0.01485471f, -0.05522200f, 0.06613084f, -0.08384630f, -0.38021976f, -0.25335306f, -0.29874837f, 0.11415350f, 
    -0.16349229f, 0.01227248f, 0.08670261f, -0.04731157f, -0.02582027f, 0.07532770f, 0.00743428f, -0.01383589f, 
    -0.08905705f, 0.18081710f, 0.08327705f, -0.07627137f, -0.07958131f, 0.09025843f, 0.04842472f, 0.09387517f, 
    -0.08324994f, -0.00259592f, -0.10894645f, 0.12926860f, 0.05108263f, 0.07751065f, -0.01683094f, -0.01486467f, 
    0.08345314f, -0.00243495f, 0.03932107f, 0.04082065f, 0.02388141f, 0.02902457f, -0.06111204f, -0.00192537f, 
    -0.17030938f, 0.07422904f, -0.00217765f, -0.01603952f, -0.03278031f, 0.12179753f, -0.02130293f, 0.13621525f, 
    0.01826477f, 0.14472757f, -0.00861819f, 0.05075458f, -0.06576804f, -0.10218585f, -0.08426117f, -0.07926999f, 
    0.04322380f, -0.06942643f, -0.02638352f, -0.04809903f, -0.01722067f, -0.02833220f, 0.06936613f, -0.06849634f, 
    -0.07444738f, -0.10596714f, 0.01136659f, -0.00092625f, 0.00289625f, -0.03156293f, -0.01966993f, -0.02557841f, 
    0.02698997f, -0.01341576f, -0.15275833f, 0.08362773f, -0.08157568f, 0.29261228f, 0.03751251f, -0.30206066f, 
    0.01660319f, 0.04622262f, -0.05280759f, 0.09100150f, 0.02496532f, -0.13565442f, -0.06194477f, -0.00896342f, 
    -0.14534311f, -0.09788840f, 0.17211635f, 0.17855673f, 0.07899627f, 0.01637197f, -0.04944902f, -0.06546141f, 
    0.04356925f, 0.09251969f, -0.02174364f, -0.11047315f, -0.33140078f, -0.37757489f, 0.11281179f, 0.12904333f, 
    0.01384847f, 0.07812587f, 0.00345185f, -0.04454876f, -0.04333818f, -0.13349921f, -0.05189642f, -0.03210907f, 
    -0.14676465f, -0.06077329f, -0.00499860f, -0.13476644f, -0.05376623f, 0.01810736f, 0.09290808f, -0.02982405f, 
    -0.00877135f, -0.06370915f, 0.10646272f, 0.01524662f, -0.03439754f, -0.11519524f, -0.10856035f, -0.00969393f, 
    -0.08177687f, 0.09091353f, 0.04741036f, 0.09608663f, -0.03846272f, -0.04147081f, 0.15236959f, 0.02456239f, 
    -0.21058610f, 0.21550518f, 0.11834279f, -0.16050999f, -0.02337741f, -0.10821088f, 0.00489813f, -0.02425589f, 
    0.00444410f, -0.07381837f, -0.08891896f, 0.02728667f, -0.29845616f, -0.43777013f, -0.19835424f, 0.13998133f, 
    -0.16358101f, -0.11643354f, 0.07769821f, 0.03329841f, -0.03094355f, -0.02139261f, 0.04118941f, 0.07527719f, 
    0.10350776f, -0.05744627f, 0.00555519f, -0.05960027f, -0.03004051f, -0.08261700f, 0.04132486f, -0.08694684f, 
    -0.04675039f, 0.01410293f, -0.12420481f, -0.00526617f, -0.29391852f, -0.39264792f, -0.08651954f, 0.02776453f, 
    -0.08675990f, -0.00504190f, -0.02428944f, -0.01395671f, 0.05779919f, 0.02411387f, 0.07549863f, -0.02437508f, 
    -0.20010476f, 0.06742018f, -0.12481432f, -0.14066747f, -0.12862889f, 0.01346210f, 0.04697319f, -0.04119176f, 
    -0.02840050f, -0.05241789f, -0.02673548f, 0.05936264f, 0.04546409f, -0.09133877f, -0.03692714f, -0.10308520f, 
    -0.04938306f, -0.01877959f, -0.07730320f, -0.04127089f, -0.05345087f, 0.00791547f, -0.02308396f, 0.00184067f, 
    0.02615866f, 0.11058104f, 0.07535335f, -0.00598186f, 0.06763694f, 0.02867703f, -0.01817590f, 0.04002376f, 
    0.08957077f, -0.00386966f, 0.01252070f, -0.08654872f, 0.00395215f, 0.05444433f, -0.09760594f, 0.12686385f, 
    0.01770467f, -0.04948403f, 0.00422227f, -0.00088054f, -0.02486000f, 0.01303810f, 0.00945949f, -0.06957385f, 
    -0.27760988f, -0.10190896f, -0.25729421f, -0.14837976f, -0.00826601f, -0.00371107f, -0.18261601f, -0.10700056f, 
    -0.09827819f, -0.00969383f, 0.01918504f, 0.01390550f, 0.04302480f, -0.03376339f, 0.05501422f, -0.02454208f, 
    -0.00751069f, 0.05452073f, -0.04153713f, -0.01305114f, 0.05888577f, 0.01211478f, -0.02133870f, -0.00995999f, 
    -0.08082385f, 0.07445496f, 0.10126458f, 0.08873892f, -0.06446152f, 0.05070823f, 0.05955787f, 0.04529770f, 
    -0.07896078f, -0.01432048f, -0.00773107f, -0.00564756f, -0.67231673f, -0.08200427f, 0.17897341f, -0.01270161f, 
    0.02682482f, 0.00129280f, -0.01080247f, 0.01511270f, -0.04542068f, -0.11141267f, -0.00835604f, -0.00683496f, 
    -0.05401816f, -0.14984784f, -0.21439320f, 0.26755607f, -0.00462914f, -0.03177771f, -0.03542568f, 0.16086347f, 
    -0.21043128f, 0.03607927f, 0.04295211f, -0.06414861f, 0.01089548f, 0.07143001f, 0.01118098f, 0.13821080f, 
    -0.00499173f, -0.06679253f, 0.08966508f, -0.01142998f, 0.03581011f, 0.07421655f, 0.02236537f, -0.03951221f, 
    -0.06058515f, 0.09892745f, -0.03205403f, 0.12264816f, 0.00482781f, 0.00992466f, 0.08388286f, -0.04983561f, 
    -0.04447411f, -0.00917279f, 0.08510723f, -0.04281614f, 0.26410067f, -0.05244979f, -0.00987317f, 0.20320782f, 
    0.10586641f, -0.01005483f, 0.02909401f, 0.08140566f, -0.03352598f, -0.00922701f, -0.06145554f, 0.06569713f, 
    0.29919213f, 0.12140752f, 0.01491057f, 0.02189341f, -0.17477871f, 0.01484256f, -0.04241786f, 0.04727834f, 
    -0.03455212f, 0.02294966f, 0.00656643f, 0.02725128f, -0.03837257f, -0.08964513f, -0.07386932f, -0.02574157f, 
    -0.14468826f, -0.06506258f, 0.07995676f, 0.05747471f, -0.10863611f, -0.02951143f, -0.02820525f, -0.05738058f, 
    0.05831465f, -0.27612665f, -0.20964567f, 0.00111769f, -0.06802816f, 0.05221150f, 0.00111978f, -0.12789701f, 
    0.01491916f, -0.01433123f, 0.06572967f, -0.06491750f, 0.13320297f, 0.04072509f, 0.05594400f, 0.19525971f, 
    0.01273002f, -0.03392842f, 0.01941466f, 0.03673995f, 0.01298710f, 0.09430503f, -0.02842556f, -0.01131342f, 
    0.01292578f, 0.04836242f, -0.03828280f, 0.10885356f, -0.11420599f, -0.09393241f, 0.06330272f, -0.02236317f, 
    -0.09555374f, 0.01241489f, -0.04183850f, 0.00675268f, -0.39204738f, -0.26545289f, -0.16512327f, -0.11524323f, 
    -0.08515680f, -0.06043134f, -0.08677592f, 0.03743955f, 0.01766891f, 0.06193784f, -0.01576873f, 0.02125918f, 
    -0.05136087f, 0.00030465f, -0.04681402f, -0.04508866f, -0.12808736f, -0.09529597f, 0.05870787f, 0.04875331f, 
    -0.13494118f, 0.10161387f, -0.05842566f, -0.02241125f, 0.11495500f, -0.02296070f, -0.09445638f, -0.15035340f, 
    -0.03798722f, 0.01456525f, -0.09666148f, -0.09291714f, 0.04435109f, 0.08391988f, 0.03707364f, -0.06392127f, 
    -0.20152831f, -0.00785730f, 0.13065727f, -0.08318686f, -0.01636907f, -0.00788638f, 0.00642274f, -0.07008442f, 
    -0.01625387f, -0.01913673f, -0.00021256f, 0.04801126f, 0.05166081f, -0.26973423f, -0.07433013f, 0.00240394f, 
    -0.03302228f, 0.07779964f, -0.00037951f, 0.09406536f, -0.05631568f, 0.02090791f, -0.12289316f, -0.15872262f, 
    0.18805423f, 0.18046887f, -0.00005469f, 0.01483681f, -0.04564124f, -0.01485624f, -0.03295607f, -0.02681790f, 
    -0.08788808f, -0.00637001f, 0.00232448f, 0.01357149f, -0.02784629f, 0.03647957f, -0.07651690f, -0.07414038f, 
    -0.10621890f, -0.09159536f, 0.00484635f, -0.04204335f, -0.11536694f, -0.05313452f, 0.08813943f, 0.06132839f, 
    0.00254105f, 0.04343652f, 0.13619404f, -0.01254790f, -0.04322734f, 0.02011570f, 0.01737662f, 0.07988043f, 
    -0.11420824f, 0.06820198f, 0.01720599f, -0.05653626f, -0.06657871f, 0.12301283f, 0.15054604f, 0.06869930f, 
    0.05224261f, 0.01729639f, -0.01732868f, -0.02514516f, -0.09348048f, 0.04082019f, -0.02079765f, -0.14061730f, 
    -0.25551084f, 0.06584962f, 0.16518651f, 0.00003013f, -0.11539397f, -0.11860594f, -0.11513986f, 0.06071458f, 
    0.03232088f, 0.00267128f, 0.06595664f, 0.04373597f, 0.00151461f, -0.20962556f, -0.10952815f, -0.09355758f, 
    -0.11841056f, -0.03156583f, -0.08849697f, 0.09947970f, 0.05429367f, -0.06479809f, -0.02668520f, -0.00076012f, 
    -0.05295342f, -0.04925680f, -0.10850360f, 0.03157343f, -0.20264858f, 0.16255356f, -0.16693987f, 0.12486514f, 
    0.02042888f, 0.03629741f, -0.03162515f, 0.02352595f, 0.00169638f, 0.12572266f, 0.02349885f, -0.07409962f, 
    -0.00640473f, -0.02161493f, -0.02469791f, -0.02767434f, 0.11116041f, 0.03653780f, 0.02323162f, -0.04613774f, 
    -0.52261913f, 0.09770263f, -0.06124920f, -0.23078161f, 0.09447905f, -0.09910955f, -0.04489217f, 0.13156596f, 
    -0.03476965f, -0.03763065f, -0.02624658f, 0.05068180f, -0.08559480f, -0.34157383f, -0.11757866f, -0.03304920f, 
    -0.06894464f, -0.05208014f, -0.10345339f, -0.11723729f, 0.01717293f, -0.00495720f, -0.03845718f, 0.03329481f, 
    -0.28085956f, 0.06091423f, -0.05471322f, -0.10809934f, -0.04076548f, -0.05569205f, -0.05163763f, 0.08403184f, 
    -0.07952402f, 0.02271185f, -0.01131945f, -0.03395032f, -0.11690737f, 0.17826056f, -0.06199139f, 0.07794571f, 
    -0.10434408f, 0.00908838f, 0.03481324f, 0.01102367f, -0.00540122f, -0.07663450f, -0.02944046f, 0.00322567f, 
    0.07765055f, 0.08987833f, -0.17811309f, -0.13955662f, -0.05505811f, 0.01103765f, -0.01559633f, 0.04643054f, 
    -0.00281596f, -0.11659128f, 0.04169823f, 0.12753227f, -0.16467850f, -0.21129829f, 0.00422378f, -0.06887984f, 
    -0.06619127f, -0.16316165f, 0.08943538f, 0.05232396f, 0.09178342f, -0.06050150f, -0.10690992f, -0.14918020f, 
    -0.15499909f, 0.33787891f, -0.27759653f, -0.34161437f, 0.04908582f, -0.01509952f, 0.04874076f, 0.01549310f, 
    0.03536551f, 0.05525929f, -0.04505085f, 0.02374198f, -0.19280536f, -0.12012745f, 0.20721027f, 0.21062115f, 
    0.01022004f, 0.04114110f, -0.08827168f, -0.06221950f, 0.06669363f, 0.00733576f, -0.12628980f, -0.01544807f, 
    -0.09158149f, 0.23397551f, -0.00794248f, 0.09717249f, -0.11616336f, 0.10746552f, 0.09835761f, 0.04669276f, 
    0.09858084f, -0.04403267f, -0.03369980f, 0.10715616f, -0.14127402f, 0.06367841f, 0.05408636f, 0.01347421f, 
    -0.00046303f, 0.04786345f, -0.02093808f, 0.05333535f, -0.00370135f, 0.02317588f, 0.01687131f, -0.06778497f, 
    0.02125441f, -0.10102829f, 0.09520195f, 0.15110490f, 0.03660907f, -0.05141889f, -0.05658881f, -0.08720319f, 
    -0.01723381f, -0.01850894f, 0.07375674f, -0.01993358f, -0.01958193f, -0.22870174f, 0.15231943f, -0.05228084f, 
    0.01982046f, 0.02218158f, -0.02597732f, -0.10358940f, 0.05888630f, -0.03696252f, -0.02608211f, -0.04730546f, 
    0.12280300f, 0.02461186f, 0.05033700f, -0.00347990f, 0.02505232f, 0.01632272f, -0.02972147f, -0.01075649f, 
    0.01534757f, -0.02149105f, -0.03840513f, 0.04559017f, -0.06058080f, -0.04310488f, 0.08598036f, -0.04177928f, 
    0.03004099f, 0.06202566f, 0.06883483f, -0.06401459f, -0.00141032f, -0.03502461f, 0.10494558f, -0.05081895f, 
    -0.08625345f, 0.00551394f, -0.00222705f, 0.00267373f, -0.02778171f, 0.01685004f, -0.03906079f, 0.13523540f, 
    -0.17663126f, 0.00876867f, 0.04529191f, -0.13116966f, 0.06706624f, 0.06699345f, 0.07735913f, 0.06150375f, 
    0.17165785f, 0.03443876f, 0.03446801f, 0.08780936f, 0.05054300f, -0.00204493f, -0.06625755f, 0.03931971f, 
    -0.02240516f, 0.09484582f, -0.00253014f, 0.01371416f, 0.03311090f, -0.12088317f, -0.02611865f, -0.09032612f, 
    -0.01099991f, 0.00179727f, 0.10552589f, 0.00971123f, -0.43370479f, 0.15853094f, 0.10462008f, -0.33966354f, 
    0.06664756f, -0.02997486f, -0.08389539f, -0.03065499f, -0.08332198f, -0.12782373f, -0.07046951f, 0.00934835f, 
    -0.01255172f, 0.24080630f, 0.08073825f, -0.22255921f, 0.06821457f, 0.02192485f, 0.07551570f, -0.13753855f, 
    0.05454385f, -0.14099680f, 0.04292599f, -0.00657882f, -0.20773803f, -0.07273456f, -0.06903601f, 0.00748422f, 
    -0.08155956f, -0.05351198f, 0.04889983f, 0.12710854f, 0.08339832f, -0.01946663f, 0.02407433f, 0.08937901f, 
    0.12478698f, 0.00871935f, 0.02304977f, -0.15532213f, -0.03004890f, 0.09717824f, -0.00735549f, -0.02013936f, 
    0.01736938f, 0.05099307f, 0.07079742f, 0.04778511f, 0.08041320f, -0.07047124f, 0.13560390f, -0.01677937f, 
    -0.00764613f, 0.09048180f, -0.05178903f, -0.02289653f, 0.12409756f, 0.07393298f, 0.06480307f, 0.02728045f, 
    -0.08094205f, -0.15390867f, 0.14507136f, 0.16522525f, -0.00512596f, -0.04058353f, 0.11546819f, 0.13049427f, 
    -0.03830544f, 0.08536875f, 0.11896756f, 0.06799667f, -0.49004087f, 0.01959052f, 0.03668571f, 0.09310738f, 
    0.03490067f, 0.03278376f, -0.00529576f, 0.03143611f, -0.01596061f, 0.05664361f, 0.07878721f, -0.03635393f, 
    -0.19224828f, 0.05024377f, -0.07467575f, 0.01237185f, 0.01523120f, 0.03234052f, -0.02750413f, -0.19089122f, 
    -0.14794096f, 0.05784013f, -0.01620601f, 0.11360206f, 0.28629351f, 0.22561476f, 0.01454661f, 0.00516123f, 
    0.12480083f, 0.00785227f, 0.04005989f, 0.07474485f, -0.05196168f, 0.06272486f, 0.01154715f, -0.07395080f, 
    -0.49222946f, 0.10123745f, 0.13804819f, 0.16938595f, -0.12498390f, -0.11273562f, -0.03802995f, 0.03267613f, 
    0.04575022f, -0.02607518f, -0.04680220f, -0.03703668f, -0.14673992f, 0.08163315f, 0.10922030f, -0.01997428f, 
    -0.03193796f, -0.01354925f, -0.04377638f, 0.01418697f, -0.00197427f, -0.04891406f, 0.06763821f, 0.01358158f, 
    -0.03915309f, -0.04536819f, 0.07992797f, 0.17507465f, 0.06051193f, 0.11074970f, 0.00663883f, -0.00520927f, 
    0.00897963f, -0.00239446f, -0.03082263f, 0.05736639f, -0.20032293f, 0.04074623f, 0.05456307f, 0.01047924f, 
    -0.10621051f, 0.12761435f, -0.01449994f, -0.06181379f, -0.07057849f, -0.02513498f, 0.08864480f, 0.01756830f, 
    -0.18588880f, 0.19541223f, -0.01760719f, 0.12643008f, 0.05366446f, 0.02581574f, 0.02602906f, 0.09208917f, 
    0.01740405f, 0.02029503f, 0.07419555f, 0.02733901f, 0.06984044f, 0.11100416f, 0.04602166f, -0.06499410f, 
    0.02340938f, 0.00227334f, 0.01784940f, 0.18092510f, 0.06075687f, 0.00714413f, 0.03942412f, 0.18178923f, 
    -0.12867555f, 0.11193452f, -0.08399057f, 0.02487946f, 0.00603392f, -0.03182041f, -0.03545555f, 0.12309445f, 
    0.05647703f, 0.00828888f, -0.04715362f, -0.06617331f, 0.23033923f, 0.03124814f, -0.07063305f, -0.01205799f, 
    -0.01986527f, -0.01071849f, 0.04896054f, 0.09371731f, 0.05153502f, 0.06725259f, -0.09061396f, 0.04104785f, 
    0.18053824f, -0.20551643f, -0.04906026f, 0.10318327f, -0.05312060f, 0.04307124f, -0.04485382f, -0.10861931f, 
    0.05492104f, -0.00530057f, 0.03783621f, 0.08676039f, -0.08353648f, 0.05121204f, -0.01832235f, 0.11505142f, 
    0.14544892f, 0.09882239f, 0.12830213f, 0.08743805f, -0.06855014f, -0.06336696f, 0.05168363f, -0.01556849f, 
    -0.07863855f, -0.10395314f, 0.19051760f, -0.02380535f, -0.09881043f, -0.01484852f, 0.00570550f, -0.08183269f, 
    0.02729309f, 0.06429042f, 0.00867245f, -0.03395392f, 0.07796241f, -0.02265527f, -0.09183514f, 0.16646749f, 
    -0.02739043f, -0.03191542f, 0.10590599f, 0.04136305f, -0.02368543f, -0.06826042f, 0.03170851f, -0.04636900f, 
    -0.30896121f, 0.16994171f, -0.01621968f, 0.04452832f, 0.10595597f, 0.01934681f, 0.08280271f, -0.04167151f, 
    0.02316407f, 0.00665747f, 0.07246052f, 0.00642276f, -0.34463161f, 0.28207636f, -0.05337269f, 0.19158427f, 
    0.12746452f, -0.03615855f, 0.00918689f, 0.04625995f, 0.00784244f, 0.06702775f, -0.11288718f, -0.03421261f, 
    -0.62750238f, 0.14527142f, 0.00094834f, -0.14787208f, -0.02464584f, -0.01896406f, 0.00659974f, -0.09272591f, 
    0.02493310f, 0.01400163f, -0.06277964f, -0.09182566f, -0.02525081f, 0.01669209f, 0.25299311f, 0.12904747f, 
    0.05145138f, 0.10201355f, 0.08946908f, -0.09299540f, 0.03111830f, -0.04076144f, -0.11435978f, 0.08770218f, 
    -0.20661508f, 0.24340700f, 0.13540001f, -0.18553890f, 0.06308339f, 0.03905946f, -0.04125625f, 0.03668095f, 
    0.09014804f, -0.05953887f, -0.06433810f, -0.01189150f, 0.48885915f, 0.26849502f, -0.30724064f, -0.05129381f, 
    0.05891403f, -0.04816888f, -0.03513728f, -0.04804255f, -0.07721132f, -0.00684515f, 0.10629971f, -0.02421499f, 
    -0.23312758f, -0.14279586f, -0.25450414f, 0.14974958f, 0.09547464f, -0.07334993f, 0.03726261f, -0.05544529f, 
    -0.12145972f, -0.04890608f, -0.01392124f, -0.08812477f, 0.05485225f, -0.12904514f, 0.03196551f, -0.22216047f, 
    0.03486729f, 0.11280198f, -0.11051386f, -0.01037861f, 0.13302620f, -0.05498830f, 0.06982780f, 0.06760079f, 
    0.15796122f, 0.05959420f, -0.07674635f, 0.06080251f, -0.05170951f, -0.11234661f, -0.00268551f, 0.07219739f, 
    0.02121289f, -0.03079665f, 0.10165115f, 0.14319962f, -0.19825369f, -0.10949013f, -0.14385106f, 0.07934254f, 
    -0.01741094f, -0.05664566f, -0.05360708f, -0.11809245f, -0.06944621f, 0.05952562f, 0.00690078f, 0.03208029f, 
    -0.05240139f, -0.05661254f, 0.11692751f, 0.21500264f, -0.12347464f, 0.02811526f, -0.04910215f, -0.04952638f, 
    0.04442542f, 0.02166940f, -0.04806011f, -0.00771554f, -0.01475305f, -0.09636231f, 0.00478946f, 0.03841078f, 
    -0.07949635f, 0.05069881f, 0.08218911f, 0.04848335f, 0.01791838f, 0.05709454f, -0.00686742f, -0.09860770f, 
    -0.26924112f, 0.01812931f, -0.03697166f, 0.06963410f, 0.01617955f, 0.00285035f, 0.06829084f, 0.02683629f, 
    0.01168717f, -0.12866217f, 0.02632750f, 0.01755618f, 0.04141724f, 0.09550086f, -0.02903102f, -0.03473376f, 
    0.01614509f, -0.04568488f, 0.05060225f, 0.07284869f, -0.00890587f, -0.06487948f, -0.07045810f, -0.01857902f, 
    -0.34849936f, -0.14569138f, 0.25200909f, 0.20843117f, 0.00294533f, -0.02757997f, 0.03664359f, 0.03602290f, 
    0.00974275f, -0.05070775f, 0.04473512f, 0.02380605f, -0.12613784f, -0.02863476f, -0.15248318f, 0.08339747f, 
    0.04042007f, -0.08831941f, -0.08587036f, 0.03942157f, 0.02881292f, -0.10698843f, 0.00601219f, -0.04932880f, 
    -0.53169197f, -0.03446336f, 0.07717963f, -0.16672812f, 0.04972955f, -0.02969897f, 0.02419551f, 0.06915372f, 
    -0.03065228f, -0.01841287f, -0.04941890f, 0.06880786f, -0.13098101f, -0.17155962f, -0.01329438f, -0.22617884f, 
    0.04732472f, -0.07956153f, 0.12922861f, 0.00498143f, 0.01348975f, 0.05407151f, 0.04803329f, 0.11118901f, 
    -0.04423129f, 0.01111948f, 0.12233706f, -0.18408057f, 0.14335366f, -0.03483755f, 0.02040833f, 0.05639490f, 
    0.09939352f, 0.01329346f, 0.09240829f, 0.00739084f, -0.19376010f, -0.06038409f, 0.11967477f, 0.21340518f, 
    0.08304210f, -0.11394603f, 0.00636794f, 0.05502864f, 0.01715718f, 0.08291685f, -0.04344294f, -0.04118834f, 
    -0.02048354f, -0.14920196f, -0.06520288f, -0.10913931f, 0.03721337f, 0.17983584f, -0.05349115f, 0.06373470f, 
    -0.08812914f, 0.09661607f, -0.04795313f, 0.02874674f, -0.27888638f, -0.03339200f, 0.11774460f, -0.01668156f, 
    0.07846341f, -0.13097507f, 0.02504070f, -0.00411229f, -0.02495844f, -0.05737578f, 0.00615852f, -0.06966981f, 
    0.04548603f, -0.01728486f, -0.04715650f, 0.11796150f, -0.15021893f, 0.07016263f, 0.01300786f, 0.06859780f, 
    -0.10296819f, -0.00032556f, 0.09099489f, 0.24370077f, 0.07680113f, -0.14629337f, 0.00327780f, -0.00393411f, 
    -0.11201356f, 0.00614307f, -0.01979679f, 0.04054759f, 0.01058437f, 0.06140320f, -0.07165829f, -0.01847410f, 
    -0.04300224f, -0.08323890f, 0.02063578f, 0.11115779f, 0.08612773f, 0.06334812f, 0.06079226f, -0.03604995f, 
    -0.06973993f, 0.06357479f, -0.04642390f, -0.09627404f, 0.05503988f, -0.08147693f, 0.02135536f, -0.06446505f, 
    -0.04677537f, 0.09132341f, -0.09503589f, 0.02717980f, -0.03275343f, -0.05781193f, -0.06307672f, 0.03077790f, 
    -0.19673373f, 0.12799890f, 0.02731774f, 0.02621017f, 0.06028620f, -0.05509368f, -0.05226408f, 0.03611921f, 
    -0.06581900f, 0.00531994f, 0.13040249f, -0.14990009f, 0.23446490f, -0.07962609f, 0.05122397f, -0.04493172f, 
    0.01459961f, -0.09550539f, -0.03477308f, -0.19259056f, 0.01566490f, -0.02170024f, 0.07750478f, -0.09918995f, 
    -0.05938567f, 0.09731904f, 0.07643425f, 0.12120671f, -0.02906123f, 0.07209704f, 0.03567757f, 0.04560712f, 
    -0.01638602f, -0.02885396f, -0.13160218f, 0.16314751f, -0.21815628f, -0.13804166f, 0.16161044f, -0.09276573f, 
    -0.07554397f, 0.01214384f, 0.16507249f, 0.03117322f, 0.13520223f, 0.05264032f, -0.02310023f, -0.12806556f, 
    -0.19210978f, 0.12658390f, 0.20572831f, -0.60796791f, -0.16758205f, 0.02952901f, 0.15901576f, 0.01567782f, 
    0.15257420f, -0.00689535f, 0.06141320f, -0.00887759f, 0.12528586f, 0.06643037f, 0.10487232f, -0.06050471f, 
    -0.13985629f, 0.06497465f, -0.01354576f, -0.00296685f, 0.07461245f, 0.08370263f, 0.25686127f, 0.12272096f, 
    -0.21001302f, -0.18688327f, 0.21491572f, -0.00829958f, 0.09441543f, 0.05626289f, -0.04766104f, -0.00325659f, 
    -0.09967047f, 0.09884618f, -0.00936867f, -0.08527646f, 0.07924940f, -0.02944324f, 0.02091747f, -0.02431184f, 
    -0.10687332f, -0.20729747f, 0.06235139f, 0.03596465f, -0.03757433f, 0.09478382f, 0.13205253f, 0.28102225f, 
    -0.06243496f, -0.00105678f, 0.05944850f, 0.09543579f, 0.03622716f, 0.00547260f, 0.03111285f, 0.08286257f, 
    -0.05692166f, -0.00322346f, 0.10309786f, -0.00779429f, 0.09326842f, -0.04670355f, 0.07141643f, -0.08019406f, 
    0.07674236f, 0.00104682f, -0.00437696f, -0.03484312f, -0.19388272f, 0.02394688f, 0.17538071f, 0.18835673f, 
    -0.01191852f, 0.07048463f, 0.12870598f, 0.19162096f, -0.12503059f, 0.04916890f, 0.02000449f, -0.08551431f, 
    -0.15964642f, -0.04219232f, -0.00224454f, -0.01663470f, 0.25055218f, 0.11150140f, 0.05187227f, -0.04274849f, 
    0.00511840f, -0.14959779f, 0.05348616f, 0.16402917f, -0.04173481f, 0.04658781f, -0.12443244f, -0.15354919f, 
    -0.17084238f, -0.37408715f, -0.20639828f, 0.13428119f, 0.08884177f, -0.06006230f, 0.00240035f, -0.06499382f, 
    0.01974066f, 0.15733026f, -0.00225057f, 0.06059812f, -0.16493115f, -0.04675205f, 0.00388537f, -0.00236906f, 
    -0.08607090f, 0.01027925f, 0.07356697f, 0.13797550f, -0.10132800f, 0.04833758f, 0.03973125f, -0.11704126f, 
    0.07719303f, -0.03161093f, -0.07985474f, -0.07373030f, 0.03332967f, 0.02253000f, 0.02588485f, -0.01476424f, 
    0.14225703f, -0.05357119f, -0.16373150f, 0.13441329f, -0.09212530f, -0.09749661f, -0.11677569f, 0.00918795f, 
    -0.03251929f, -0.11717085f, -0.09269728f, 0.01614559f, 0.05452842f, 0.10373174f, 0.24222739f, 0.15143317f, 
    -0.00583317f, 0.05843807f, 0.11081079f, 0.30359498f, -0.08464923f, 0.04060231f, 0.11018808f, -0.06887773f, 
    -0.06102818f, -0.10993172f, -0.11721595f, -0.11047751f, -0.13541834f, -0.22982453f, -0.00270708f, 0.13997157f, 
    0.04725584f, -0.08272612f, 0.03507251f, -0.03440477f, 0.03906983f, 0.02771540f, 0.14077824f, -0.01110653f, 
    -0.06435487f, 0.03812288f, -0.02763604f, 0.00275525f, 0.01875119f, -0.10152088f, -0.21259676f, 0.08098778f, 
    0.07020401f, 0.11029434f, -0.03960859f, -0.02965092f, 0.04049410f, 0.01661582f, -0.00789837f, -0.09244936f, 
    0.03886573f, 0.05843233f, 0.07358310f, -0.08979432f, -0.03709400f, -0.12511140f, 0.02346018f, -0.01485336f, 
    -0.12128371f, -0.08617110f, -0.12767832f, 0.07764302f, 0.03513455f, 0.04197595f, -0.15374948f, 0.10961214f, 
    0.16035928f, 0.04321899f, 0.12100217f, -0.22187056f, 0.03586270f, -0.02475840f, 0.07754710f, 0.21288686f, 
    -0.03992460f, -0.12852980f, -0.08715667f, 0.09214563f, 0.14592913f, -0.15291891f, 0.05619297f, 0.11480390f, 
    0.16083780f, -0.05451411f, -0.16153631f, 0.00867152f, 0.14489800f, 0.02463204f, -0.19863515f, -0.02079375f, 
    -0.08702721f, -0.11706021f, -0.25798506f, -0.06947684f, -0.19132283f, 0.10339107f, -0.06870211f, -0.05916847f, 
    0.03899030f, 0.01423214f, -0.10513016f, 0.08245916f, 0.01606377f, -0.09258737f, 0.06104083f, -0.11125573f, 
    0.09857138f, 0.02317511f, 0.22007565f, -0.06187720f, 0.00240383f, -0.08115215f, -0.00990425f, 0.08741923f, 
    0.16394383f, -0.17209442f, 0.03177054f, 0.02881378f, -0.25824621f, -0.09819243f, -0.02310324f, 0.03545268f, 
    0.06617009f, -0.09471531f, 0.05852057f, -0.20425820f, 0.03101462f, -0.17710291f, 0.07013039f, -0.00172654f, 
    0.06930894f, -0.07395117f, 0.01935756f, 0.14438140f, -0.13350184f, -0.15028004f, 0.03690077f, -0.00807277f, 
    -0.14488755f, -0.00121032f, -0.02674118f, 0.20285119f, 0.01654162f, -0.01887038f, 0.14318398f, 0.05486239f, 
    -0.13333832f, 0.13965531f, 0.09585720f, -0.04825193f, -0.08642663f, 0.04865656f, 0.12903629f, 0.18936887f, 
    0.04173008f, 0.11627875f, -0.06839608f, -0.02668805f, 0.08548552f, -0.05232977f, 0.01065134f, -0.00710217f, 
    -0.03789625f, 0.04148674f, -0.10738140f, 0.04759169f, 0.07170608f, -0.05395691f, -0.25160241f, -0.04777842f, 
    0.06811497f, -0.20639004f, 0.07550315f, -0.14236240f, -0.02142285f, -0.05288393f, -0.15305047f, -0.10703845f, 
    -0.00859575f, -0.21142097f, -0.22159705f, 0.01753178f, 0.09295648f, 0.03004515f, -0.09432439f, -0.18909597f, 
    0.00314095f, -0.05388816f, 0.02843402f, -0.18410841f, 0.06848801f, 0.03704441f, 0.16802867f, 0.04112864f, 
    0.09679522f, 0.06367232f, -0.09922417f, -0.03594141f, -0.02724302f, 0.06233639f, 0.04412360f, -0.11567900f, 
    -0.51014352f, -0.08494744f, -0.14545599f, -0.09852996f, 0.07479004f, 0.05286321f, -0.04868785f, 0.10860557f, 
    0.06797924f, 0.00260943f, -0.04221145f, 0.00818619f, -0.11138691f, 0.07466997f, 0.24942885f, -0.08183254f, 
    0.05073601f, -0.03284643f, -0.07631808f, -0.11246523f, 0.10070673f, -0.03199812f, -0.08479366f, 0.15448613f, 
    0.04723613f, 0.09656487f, 0.06815354f, -0.06261710f, 0.13418509f, -0.02526722f, -0.18789692f, -0.16830394f, 
    -0.11492909f, 0.09884339f, 0.00375142f, 0.10873894f, -0.36147597f, -0.18154967f, -0.08141731f, 0.03303742f, 
    0.08729590f, 0.08399976f, -0.00836343f, 0.04993907f, -0.00340272f, 0.04919162f, -0.00762218f, 0.10729729f, 
    -0.07169998f, 0.09614597f, -0.00396666f, 0.19837059f, -0.22547625f, -0.06924587f, 0.03469982f, 0.00056816f, 
    0.00139792f, 0.06242207f, 0.03477129f, 0.00115066f, -0.09835198f, -0.22087169f, -0.02767928f, -0.19386795f, 
    0.09204751f, 0.13144208f, -0.03016277f, -0.13576266f, -0.01168521f, -0.00263158f, 0.02392069f, -0.01442361f, 
    -0.23074539f, 0.22373030f, 0.10241336f, -0.07905757f, 0.09439589f, -0.11267421f, -0.00305967f, -0.09188768f, 
    -0.02312832f, -0.04084180f, -0.08718005f, 0.04751539f, -0.58718127f, 0.04069371f, -0.04745682f, 0.00459767f, 
    0.14278540f, -0.09536992f, 0.00659845f, -0.00885665f, 0.06371689f, 0.03153437f, 0.04563050f, -0.08077618f, 
    -0.43664029f, 0.17182688f, 0.08555470f, -0.19305840f, 0.13752015f, -0.01994162f, 0.03510048f, -0.01182981f, 
    -0.00378689f, -0.07106070f, -0.00188406f, -0.03806605f, 0.05174936f, -0.01032682f, 0.00528037f, 0.08140679f, 
    -0.06701561f, -0.07636113f, -0.09856775f, -0.03157807f, 0.04135319f, -0.00916461f, 0.01143130f, -0.01809824f, 
    -0.17594504f, 0.13330503f, -0.07009235f, 0.30250481f, 0.06877775f, 0.09819487f, 0.15408777f, -0.03873125f, 
    -0.02141165f, 0.06297850f, -0.00738872f, 0.08888584f, 0.02814765f, -0.32471001f, 0.17465912f, 0.09108572f, 
    0.05723908f, -0.08717470f, 0.00957186f, -0.03583133f, 0.05601452f, -0.13278586f, -0.09004878f, 0.02163174f, 
    -0.05198902f, -0.04905055f, -0.11142818f, -0.02494102f, -0.00308199f, 0.13133149f, -0.14286426f, 0.07435978f, 
    0.18356712f, 0.07493650f, 0.11224504f, -0.04042134f, -0.11126065f, 0.06114460f, -0.02160244f, 0.08858381f, 
    0.04178860f, -0.03420773f, 0.07868270f, -0.01937329f, -0.00782605f, -0.09204402f, 0.03704589f, 0.07554203f, 
    0.14577687f, 0.01686017f, -0.00620252f, -0.02146004f, -0.01543821f, 0.00991317f, -0.03378807f, 0.00254563f, 
    -0.06991691f, -0.07069301f, 0.06373312f, 0.04571172f, 0.07377850f, 0.16035993f, -0.02549847f, -0.09081130f, 
    0.10019642f, 0.17254359f, 0.09062549f, 0.00080266f, 0.02200641f, -0.03596311f, -0.15065348f, -0.08544146f, 
    0.03656469f, 0.00215736f, 0.00704599f, 0.02057569f, -0.01212906f, -0.04331034f, 0.00641338f, 0.01503367f, 
    -0.07197347f, -0.03201745f, 0.00437428f, 0.08924185f, -0.06910412f, 0.18873218f, 0.15817691f, 0.15576485f, 
    -0.00676588f, 0.12525381f, 0.08979689f, -0.07796215f, 0.00054109f, -0.25000188f, -0.05530877f, 0.11781026f, 
    -0.37545589f, -0.18084724f, -0.16603784f, -0.08095542f, 0.05822455f, 0.09191126f, -0.00189227f, -0.03156169f, 
    0.06472020f, 0.16205160f, -0.08656177f, 0.09417940f, -0.12010314f, 0.07659361f, 0.19121630f, -0.03766252f, 
    0.02761092f, 0.00053336f, 0.02252255f, -0.08026008f, 0.05646048f, -0.09162425f, -0.01552046f, 0.05219749f, 
    0.18892276f, -0.05415342f, -0.44529334f, 0.02128132f, -0.03808142f, 0.16455412f, -0.01660508f, 0.00467249f, 
    0.09079817f, -0.05020698f, -0.14340802f, -0.04430966f, -0.33374828f, 0.02086791f, -0.09976205f, 0.08614515f, 
    -0.12175073f, 0.07742274f, 0.15350699f, -0.20146364f, 0.10727224f, 0.02530621f, -0.11834910f, 0.08436051f, 
    0.03799237f, 0.15910819f, 0.16845690f, -0.19407168f, -0.08405098f, -0.07336459f, -0.05931143f, 0.15821573f, 
    -0.07245439f, -0.17856817f, -0.06390901f, -0.30848292f, -0.00260775f, 0.18215120f, -0.03661308f, 0.11182828f, 
    0.15809128f, -0.11081681f, -0.00078427f, 0.10415068f, -0.01057243f, -0.07507931f, -0.05932869f, -0.22111182f, 
    -0.38310519f, -0.18465929f, -0.16425246f, 0.24669683f, -0.11869497f, 0.10458167f, 0.00362754f, -0.02953778f, 
    0.00482528f, 0.06575679f, 0.14218968f, 0.10102107f, -0.22245215f, -0.11051263f, -0.21874277f, -0.19667637f, 
    0.11540592f, 0.14535186f, 0.07652291f, -0.14041449f, 0.07263649f, 0.06553887f, 0.08445410f, -0.00467444f, 
    0.01314271f, 0.06097484f, -0.15585636f, -0.02222976f, 0.11931165f, 0.04612119f, -0.05953022f, 0.14528848f, 
    0.10568492f, 0.06909417f, -0.00282080f, 0.10027924f, 0.08119930f, -0.08488156f, 0.05121287f, -0.06648729f, 
    -0.05252340f, -0.04244886f, -0.06357817f, -0.04392432f, -0.08272330f, 0.01753717f, -0.03883763f, 0.19397250f, 
    0.10133173f, 0.28189534f, 0.07646663f, -0.00583279f, -0.01667408f, -0.04359910f, 0.05549283f, -0.07244259f, 
    0.02992260f, -0.10807288f, -0.09193872f, -0.12640588f, 0.12971671f, 0.10036288f, 0.04572906f, 0.08135886f, 
    -0.03559424f, -0.04609956f, 0.02124564f, -0.10163556f, 0.03217251f, 0.01133470f, -0.03296004f, 0.12651275f, 
    -0.00260660f, 0.00080162f, -0.06805865f, 0.10617756f, -0.05043350f, -0.03455171f, -0.12562998f, 0.02881784f, 
    -0.06277747f, -0.00752779f, -0.06283576f, 0.15460323f, -0.33524430f, 0.00986421f, -0.00747140f, -0.09272113f, 
    0.04555574f, 0.01042298f, 0.07198742f, 0.00345635f, 0.07970049f, 0.11439905f, 0.04908206f, 0.06990298f, 
    0.36461574f, -0.42872646f, 0.04597738f, 0.02562925f, 0.03615135f, 0.05692359f, 0.02548014f, -0.13569108f, 
    0.06778849f, -0.02458264f, 0.07943606f, 0.07093208f, -0.27693152f, 0.07365075f, 0.02011487f, 0.18019350f, 
    0.08214714f, 0.14379102f, 0.02947491f, 0.10254943f, -0.03979472f, 0.06090471f, -0.05971022f, -0.01187682f, 
    0.24768421f, -0.08619034f, 0.09663142f, -0.12931913f, 0.04628848f, -0.00171310f, 0.13527124f, 0.05927859f, 
    -0.09035739f, 0.07042688f, 0.12785590f, -0.20526600f, -0.06239126f, -0.12802628f, 0.00970629f, 0.16496405f, 
    0.04838299f, -0.02532363f, -0.01815640f, 0.01335980f, -0.07885833f, -0.09944629f, -0.11163043f, 0.02302751f, 
    0.21419367f, -0.23922010f, 0.02075931f, 0.03364305f, 0.00138525f, -0.02102803f, 0.07377020f, -0.06725005f, 
    0.04954551f, -0.06129521f, 0.00642749f, -0.05367124f, -0.12561108f, 0.14352196f, 0.07177460f, 0.10972158f, 
    -0.01867742f, -0.03372717f, 0.04218981f, -0.02686733f, -0.01199920f, -0.09714670f, -0.04709325f, -0.21620321f, 
    0.20758805f, -0.20074797f, 0.03283890f, 0.12362836f, -0.09980673f, -0.03932893f, -0.02059718f, 0.06671841f, 
    0.13145475f, 0.01938474f, -0.01355962f, 0.14897223f, 0.13827571f, 0.11963466f, -0.14891072f, -0.28734183f, 
    -0.01611294f, 0.08579794f, 0.04766487f, -0.07685883f, -0.07212951f, -0.23877709f, -0.07899676f, -0.07768667f, 
    -0.09195393f, -0.09504633f, -0.13549651f, -0.08970701f, -0.06988328f, -0.03418419f, -0.03563246f, -0.10838820f, 
    0.03065634f, 0.00531074f, -0.15295592f, 0.08437155f, 0.14506446f, 0.21894234f, 0.08274160f, -0.24451807f, 
    -0.16659459f, -0.02995180f, 0.03197388f, -0.07148228f, 0.12907851f, -0.01848746f, 0.00161728f, -0.08782027f, 
    -0.15403798f, 0.15153192f, -0.00514893f, -0.17596836f, -0.02309766f, -0.08191141f, 0.06392104f, 0.04868940f, 
    0.02870551f, -0.02153404f, 0.15135653f, 0.09734014f, -0.32065675f, 0.06365604f, 0.14704597f, -0.03246382f, 
    0.05491471f, 0.09035278f, 0.01599309f, 0.03814756f, -0.07423654f, -0.04513679f, 0.05966600f, 0.10743470f, 
    -0.21428491f, -0.07133526f, -0.01049988f, -0.10705409f, 0.07836798f, 0.12069666f, 0.01658379f, 0.05423151f, 
    -0.04168911f, -0.09295400f, -0.02356457f, 0.06489080f, -0.10702807f, 0.08253393f, 0.09007784f, 0.06586771f, 
    0.07991857f, 0.08079363f, 0.03210871f, -0.07761283f, -0.08373141f, -0.02424875f, -0.01138740f, -0.04204852f, 
    0.01157076f, 0.01313256f, 0.01230604f, 0.11995686f, -0.03520755f, 0.06744854f, 0.04593328f, 0.03189549f, 
    -0.08752611f, -0.03325878f, 0.18181695f, -0.11409126f, -0.06348306f, 0.13231535f, 0.12764756f, 0.03354450f, 
    -0.08876268f, -0.07789723f, 0.03179793f, -0.10277110f, 0.03865929f, -0.20423840f, -0.02582677f, -0.17140704f, 
    -0.26272628f, 0.08375494f, 0.03913407f, 0.00297511f, 0.08739833f, 0.00615145f, 0.04580761f, -0.04485440f, 
    -0.01158071f, -0.02410212f, 0.28107661f, 0.08106082f, 0.07794484f, -0.14418618f, 0.09590425f, -0.01822678f, 
    -0.00399203f, 0.08763164f, -0.02694966f, -0.04405875f, 0.03929191f, -0.10768380f, -0.05477618f, 0.02948939f, 
    0.04210749f, 0.05350568f, -0.03866906f, -0.06974840f, -0.09035984f, 0.12637612f, 0.03996590f, 0.09360297f, 
    0.03687378f, -0.02089627f, 0.05353151f, 0.04869830f, -0.14751685f, 0.20199504f, 0.16175866f, 0.11176088f, 
    -0.02220737f, 0.00281529f, 0.04804305f, 0.05111053f, 0.02803391f, 0.13951135f, 0.03931294f, -0.04387364f, 
    0.15462160f, -0.15827245f, 0.03011219f, -0.10297329f, -0.00384191f, -0.08142870f, 0.22010681f, -0.10365888f, 
    -0.19987506f, -0.10519385f, -0.06117350f, 0.12903173f, 0.01772681f, -0.05119969f, -0.15979731f, 0.03297770f, 
    -0.07150048f, -0.03171318f, -0.17404209f, -0.03834025f, -0.04037864f, -0.01888933f, -0.17196867f, -0.08309296f, 
    -0.17253335f, 0.04224250f, -0.02830152f, 0.24836996f, 0.01495187f, 0.07321552f, 0.08893172f, 0.04621519f, 
    0.04038693f, 0.04330269f, 0.05659794f, 0.06261241f, 0.02767552f, -0.21563390f, -0.01260698f, -0.01276975f, 
    -0.04795019f, 0.00479534f, 0.01241312f, 0.00298862f, -0.03868474f, -0.00551241f, -0.02036604f, 0.03280842f, 
    -0.04103632f, -0.18354119f, -0.26534209f, 0.10134568f, -0.02847197f, 0.04926398f, 0.06781484f, 0.01593319f, 
    -0.02419249f, 0.20498842f, 0.07903468f, -0.14886650f, 0.22656871f, -0.12861498f, -0.15870450f, 0.27610826f, 
    -0.17244120f, 0.07112911f, -0.03988073f, 0.05764687f, -0.16710828f, 0.08762316f, -0.06279544f, 0.03455157f, 
    0.07730125f, 0.12462792f, 0.03467110f, -0.31403691f, -0.01397047f, -0.02114063f, 0.08647469f, -0.00773541f, 
    -0.05439787f, -0.13350143f, 0.03416454f, -0.17440997f, 0.16212700f, -0.06494538f, 0.02109210f, -0.19961859f, 
    0.02015285f, 0.00970720f, 0.04916897f, 0.01218580f, 0.06064285f, -0.13811252f, -0.09160231f, -0.16434483f, 
    0.16297652f, -0.06263765f, -0.03619156f, 0.13023800f, -0.04817369f, -0.04591408f, 0.01839223f, -0.03342509f, 
    0.13865091f, -0.04054974f, 0.02486610f, 0.09125356f, -0.13359942f, 0.08987959f, -0.13738932f, 0.07693747f, 
    0.12628675f, 0.02008650f, -0.15232815f, 0.05367882f, -0.08514167f, 0.04290940f, 0.13963419f, 0.08313716f, 
    -0.05691186f, -0.26309961f, -0.05805995f, -0.06076645f, 0.01383319f, -0.13215251f, -0.03251927f, -0.19951898f, 
    0.00719720f, 0.12041871f, -0.02545710f, 0.24399684f, 0.09777894f, 0.18171641f, 0.08306500f, 0.00030521f, 
    -0.01599128f, -0.04687835f, 0.06002624f, 0.06315947f, 0.05698550f, 0.03314249f, 0.06773542f, 0.06400249f, 
    -0.06171213f, -0.05897193f, 0.13202845f, -0.09206268f, 0.00097118f, -0.01602565f, 0.10586682f, -0.00823883f, 
    0.01151881f, 0.02177573f, 0.00500054f, -0.08039049f, 0.06602504f, -0.03290367f, 0.11275664f, -0.30478343f, 
    -0.08013520f, 0.04388895f, 0.07526001f, 0.18864074f, -0.09224098f, 0.02738117f, 0.06695795f, 0.03109867f, 
    -0.48479411f, -0.24530990f, -0.10067758f, -0.03144865f, 0.09641977f, -0.02870855f, 0.15024722f, 0.06392393f, 
    0.07097871f, -0.05504321f, 0.00670807f, -0.12445034f, -0.25468811f, -0.00960295f, 0.02842792f, -0.16648972f, 
    0.02494586f, -0.01343090f, 0.01136969f, -0.08156669f, 0.05533262f, -0.04621327f, 0.10647981f, 0.03042893f, 
    0.09644128f, -0.19144090f, -0.32258144f, 0.14592288f, 0.03760738f, 0.06838959f, 0.05882049f, 0.02124764f, 
    -0.01313789f, -0.09313481f, -0.02577649f, -0.05766704f, -0.24444473f, -0.07274909f, 0.13880043f, -0.06616297f, 
    0.05181925f, -0.06804470f, 0.01807279f, 0.01401761f, 0.02971347f, 0.04388315f, 0.00607961f, 0.01489477f, 
    -0.21767485f, -0.02655935f, 0.26426262f, 0.16072623f, -0.04018262f, -0.11560173f, -0.04635869f, -0.02508114f, 
    -0.04522258f, -0.02988946f, -0.04906839f, -0.01556617f, 0.18731119f, 0.03247399f, -0.02187237f, -0.24111377f, 
    0.01777238f, -0.04301684f, 0.02246899f, -0.04550174f, -0.04426174f, -0.04380804f, 0.04334025f, -0.08061233f, 
    0.45649213f, -0.23110080f, -0.10337511f, -0.07200602f, -0.00733145f, 0.01008438f, -0.00176509f, 0.11119840f, 
    0.08145065f, 0.02833511f, -0.01682664f, 0.02100959f, -0.03914921f, 0.06380859f, 0.09905784f, -0.22426800f, 
    0.18331836f, 0.01402046f, 0.10532765f, 0.14643554f, -0.07280199f, 0.11196472f, -0.02247653f, 0.05360774f, 
    -0.20111056f, -0.17685170f, -0.04837548f, 0.09112261f, 0.06744219f, -0.01083737f, -0.05819354f, 0.07713497f, 
    -0.00591127f, -0.04395266f, 0.02859542f, -0.17884709f, -0.05622907f, -0.27397931f, -0.06237317f, 0.14018157f, 
    -0.01760443f, 0.09361570f, 0.07427874f, -0.04396484f, -0.20034657f, 0.02481905f, 0.03514586f, 0.05995175f, 
    -0.11668932f, -0.04580165f, -0.03936300f, -0.12587897f, -0.12597154f, -0.00103624f, 0.11806479f, -0.06085885f, 
    -0.01796375f, -0.03230052f, -0.05705334f, 0.05255723f, 0.06270126f, 0.13440746f, 0.06434963f, 0.19983511f, 
    -0.01430598f, -0.11783171f, -0.09674005f, 0.12449202f, -0.05227133f, 0.06879396f, 0.02078187f, -0.12663858f, 
    -0.20634718f, -0.12927276f, -0.04141043f, 0.08951805f, 0.00591061f, -0.02155832f, -0.03372170f, 0.00240410f, 
    0.05768725f, 0.18419021f, -0.10077301f, -0.03977937f, -0.07397373f, -0.21509278f, -0.03288196f, -0.23467642f, 
    -0.04521073f, -0.10990513f, -0.03671289f, 0.00240655f, -0.05020962f, 0.04309143f, 0.03712001f, 0.07702975f, 
    -0.19226155f, 0.23208220f, 0.12233157f, -0.18865427f, 0.05934725f, 0.08235761f, -0.05807152f, 0.05419435f, 
    -0.12909015f, 0.08143191f, 0.09169897f, 0.03749068f, 0.08770709f, -0.07373846f, -0.07755563f, -0.21111077f, 
    0.00316153f, -0.02570305f, -0.06474599f, -0.07193387f, 0.07699354f, 0.09190491f, -0.03883733f, 0.00998380f, 
    -0.08670677f, -0.11951977f, -0.00885287f, -0.16160905f, 0.04660809f, 0.01675704f, 0.11476914f, -0.12685445f, 
    0.02937684f, -0.10088246f, 0.13674609f, 0.00161211f, 0.11003315f, 0.02646608f, 0.03336018f, -0.10929731f, 
    -0.12014908f, -0.14558502f, 0.01263224f, 0.05535454f, 0.10431533f, 0.06946500f, 0.14313826f, 0.08778513f, 
    -0.08871449f, -0.14715655f, -0.17886212f, -0.17904763f, 0.02393236f, -0.08658728f, -0.02123848f, -0.01673567f, 
    0.00809617f, -0.04383873f, 0.12855798f, 0.16278881f, -0.11470736f, -0.09225020f, -0.14626414f, -0.13354497f, 
    -0.13222821f, 0.10187385f, 0.00291214f, -0.06030013f, -0.02334159f, 0.08865415f, -0.07285849f, -0.07767618f, 
    0.33839637f, -0.12384529f, 0.06531627f, -0.13997327f, 0.02032418f, 0.08655347f, 0.03651050f, 0.01164815f, 
    0.16088119f, 0.13591082f, -0.00300307f, 0.10616568f, -0.15774320f, -0.03311494f, -0.06212496f, 0.46216440f, 
    0.03085808f, 0.00476486f, -0.17154802f, -0.00793693f, 0.05913727f, 0.00732442f, -0.04424621f, 0.03419201f, 
    0.12580368f, 0.04957991f, -0.09283882f, -0.07322159f, 0.01737660f, -0.06661455f, -0.02192873f, -0.06595671f, 
    -0.01394882f, -0.03525380f, -0.01797037f, 0.04177279f, -0.07269511f, -0.11444337f, -0.37423649f, -0.12449949f, 
    -0.04538256f, 0.07439485f, -0.10773727f, -0.11922757f, -0.08037604f, 0.15680370f, -0.10871553f, -0.00024193f, 
    0.18537730f, -0.19199526f, 0.23587923f, -0.20829053f, 0.09856989f, 0.01254633f, 0.03615201f, -0.03599375f, 
    -0.01543561f, -0.07972670f, 0.01554795f, -0.06585747f, 0.05162064f, -0.02732808f, -0.00435683f, 0.07851913f, 
    0.11477600f, 0.06997946f, 0.06070624f, -0.02541930f, 0.02494961f, -0.09918428f, -0.00843090f, -0.03528943f, 
    -0.17322756f, -0.21236829f, -0.07779665f, -0.13685754f, -0.13808142f, -0.02257691f, 0.01446145f, 0.04910016f, 
    0.00249410f, 0.07053872f, 0.12739411f, 0.11304711f, -0.30448279f, 0.19808476f, -0.03609961f, 0.12893735f, 
    0.00827199f, 0.11761241f, -0.11762692f, 0.12660804f, 0.02883950f, 0.01028390f, 0.09153020f, -0.06028552f, 
    -0.31291702f, 0.00986678f, -0.07576711f, 0.25160059f, 0.15934427f, 0.05584827f, 0.02254866f, 0.09369042f, 
    0.03023433f, -0.02840357f, 0.03477744f, -0.22455607f, 0.12447936f, -0.00229630f, 0.00258717f, -0.26017600f, 
    0.08763947f, 0.00033222f, -0.02806094f, -0.08425391f, -0.06704229f, 0.06872170f, 0.06608614f, -0.11286347f, 
    0.19778199f, -0.24381106f, 0.12716965f, -0.10952077f, -0.05685344f, -0.00550461f, -0.00779940f, -0.00842579f, 
    0.04161205f, 0.05798942f, -0.06251837f, 0.00889011f, 0.09275585f, 0.05680094f, -0.23099896f, 0.00239266f, 
    -0.06058795f, -0.01267500f, -0.04253935f, 0.01498876f, -0.06396272f, 0.03240087f, -0.03198802f, -0.10778773f, 
    0.09653354f, -0.13360566f, 0.06595331f, -0.07909504f, -0.04685275f, -0.03558295f, -0.02230610f, -0.00659641f, 
    -0.08685751f, 0.05603634f, -0.02053754f, 0.01685812f, 0.11721180f, -0.19630709f, 0.07233703f, 0.05752252f, 
    0.03530302f, -0.04933848f, -0.11207976f, 0.00763649f, -0.06434084f, -0.03058140f, -0.04290819f, 0.00130240f, 
    -0.31905580f, 0.09428777f, 0.08304442f, -0.19632381f, 0.02184834f, -0.04963928f, -0.02852311f, -0.10960990f, 
    -0.08481372f, 0.04852132f, -0.03693577f, -0.02644393f, -0.08037856f, -0.04092789f, -0.10386800f, -0.17797308f, 
    0.02182471f, -0.04264182f, 0.04222072f, -0.00587314f, -0.02030873f, -0.08624657f, -0.04935957f, 0.01276044f, 
    -0.25919682f, 0.11856789f, 0.00585123f, 0.10902108f, 0.04186975f, -0.01215807f, 0.06823008f, -0.00958110f, 
    -0.03384608f, -0.07542352f, 0.02807651f, -0.09291306f, 0.12326737f, -0.00770986f, -0.08236206f, 0.05400485f, 
    -0.13550279f, -0.04500514f, -0.05029573f, 0.00068476f, 0.01218320f, -0.02397958f, 0.01890970f, -0.04865237f, 
    0.00766282f, 0.21615198f, -0.01135057f, 0.08591893f, -0.13052806f, 0.00833785f, -0.01072534f, 0.01373191f, 
    -0.08744746f, 0.04523166f, -0.10516071f, -0.12922841f, -0.29990098f, 0.10831051f, 0.00633643f, 0.04384270f, 
    0.01256299f, -0.07108520f, 0.01203275f, -0.05696112f, 0.01252670f, 0.03212955f, 0.01510208f, -0.13524440f, 
    -0.14229640f, -0.14052846f, -0.08304715f, 0.13000102f, -0.02144130f, -0.05257836f, -0.03621743f, -0.07254183f, 
    -0.09452361f, -0.03964372f, 0.05518254f, -0.04961456f, 0.05847527f, 0.01954895f, -0.09297167f, -0.02676335f, 
    -0.05415426f, -0.07384365f, -0.03231385f, -0.05375126f, -0.09411924f, -0.05363508f, 0.02326182f, -0.00655672f, 
    0.17806390f, -0.02257307f, 0.11214825f, 0.10960200f, 0.09771147f, 0.01727429f, -0.05478565f, -0.03949377f, 
    -0.05219239f, -0.00172438f, -0.07852948f, -0.12712464f, 0.14062935f, -0.18012814f, -0.02827249f, -0.01618554f, 
    0.01207994f, -0.06358273f, -0.01696519f, 0.02376006f, -0.06740224f, 0.00861031f, -0.04706811f, -0.08712358f, 
    -0.15943485f, -0.06822248f, -0.03373133f, -0.05999123f, -0.04680037f, 0.05738188f, -0.01593121f, -0.06573226f, 
    0.07957406f, -0.06279196f, -0.02103654f, -0.07219309f, 0.11247082f, 0.05193165f, 0.06155251f, 0.10169001f, 
    0.03227610f, -0.02141800f, -0.02850414f, -0.00001792f, 0.06549142f, 0.00783985f, -0.14172031f, -0.06894804f, 
    0.09657887f, 0.06333631f, -0.01602262f, -0.00102136f, -0.19145711f, 0.04462730f, -0.00526878f, -0.06171934f, 
    -0.03963907f, -0.05928992f, 0.05696028f, 0.01316316f, -0.00708591f, 0.01217680f, -0.09731581f, 0.01377722f, 
    -0.06433607f, -0.09856567f, -0.02100580f, 0.00097498f, 0.02647924f, 0.00971104f, -0.02216322f, -0.00196473f, 
    -0.04927489f, 0.13720152f, -0.00330293f, 0.01542389f, -0.16190654f, 0.01055833f, -0.02346742f, -0.04952874f, 
    0.03877037f, -0.02096336f, -0.04196227f, -0.09114770f, -0.16300014f, 0.00446923f, -0.09410693f, -0.18194117f, 
    -0.00062925f, -0.01590372f, -0.00647237f, -0.02051870f, -0.03795416f, -0.07993224f, 0.01225575f, -0.04444399f, 
    0.14652921f, 0.06115400f, 0.14164829f, 0.03116955f, 0.08242117f, 0.00667005f, 0.02334741f, -0.04280990f, 
    -0.04901814f, -0.06759909f, -0.03328140f, -0.00017661f, 0.01872324f, 0.07265805f, 0.07789149f, 0.04522050f, 
    -0.03789461f, -0.08662049f, 0.00867834f, -0.03555336f, -0.10904847f, -0.05017448f, -0.07346743f, -0.04334258f, 
    0.10202740f, 0.03541219f, 0.04391886f, 0.07565450f, 0.02316530f, -0.03897900f, -0.06863765f, -0.01575994f, 
    0.00598896f, 0.05311646f, -0.07056410f, -0.00108974f, 0.06164512f, 0.01184247f, 0.06719273f, 0.04364007f, 
    -0.05917935f, 0.01912883f, 0.03817944f, 0.01256010f, -0.03320045f, -0.01017834f, 0.00438093f, -0.01732050f, 
    -0.07624468f, -0.04030938f, -0.01897220f, -0.05623560f, -0.05587664f, -0.02118087f, -0.01709828f, -0.05229890f, 
    -0.04069456f, 0.12215090f, 0.01892714f, -0.00270709f, -0.01286755f, 0.14386664f, 0.00616725f, 0.18096226f, 
    0.09755829f, -0.06459122f, 0.07006636f, 0.07333148f, 0.07624359f, 0.03325396f, 0.02110421f, -0.04851579f, 
    -0.09321906f, -0.19834131f, -0.16892512f, 0.09564553f, -0.02888675f, -0.01144901f, -0.02093183f, -0.02535746f, 
    -0.00499499f, 0.03096339f, 0.00008169f, 0.04071431f, -0.20563680f, -0.05587963f, -0.15504876f, -0.06718070f, 
    -0.01996214f, -0.02342824f, 0.05244510f, -0.09312547f, -0.00744574f, 0.00555005f, -0.02788792f, 0.00050043f, 
    0.14456744f, 0.06938392f, 0.11356493f, 0.10675281f, 0.05557225f, -0.04420438f, 0.05207679f, 0.01434105f, 
    0.00888556f, -0.00230976f, -0.03136352f, -0.07613228f, -0.24104621f, 0.12308634f, -0.22372486f, -0.04536610f, 
    -0.17579524f, -0.04915756f, -0.04218357f, -0.04919563f, 0.01844805f, 0.04064266f, -0.00459506f, -0.02233377f, 
    -0.03292210f, 0.10569551f, 0.12974161f, 0.11015604f, 0.11224672f, 0.07134667f, 0.01253661f, -0.08037342f, 
    0.01237842f, -0.00522791f, 0.03469634f, -0.03679115f, 0.02458556f, -0.04277117f, -0.08177014f, -0.22407357f, 
    -0.05645412f, -0.04678841f, -0.01752136f, -0.07154144f, -0.07732681f, 0.02507463f, -0.06990556f, 0.00217105f, 
    0.19937821f, 0.01154195f, 0.16779560f, 0.02893090f, -0.08619217f, -0.00896940f, -0.00169039f, -0.05301423f, 
    -0.01000905f, 0.08826338f, -0.04914438f, -0.02790410f, 0.00596494f, 0.03498710f, -0.07809126f, -0.10485645f, 
    -0.04352820f, 0.00229944f, -0.07144128f, -0.09808371f, -0.09843926f, 0.01729889f, -0.06420647f, -0.04191827f, 
    0.04239234f, 0.05326594f, -0.06826890f, -0.04360650f, 0.05480082f, -0.04808884f, 0.02231872f, -0.11284658f, 
    0.00261448f, 0.01979042f, -0.04683789f, -0.08021839f, 0.09184103f, 0.14008570f, 0.17942655f, 0.07613146f, 
    -0.00065083f, 0.00679959f, 0.00887005f, -0.07937796f, -0.03823940f, -0.02838402f, -0.02665767f, -0.02617252f, 
    0.18561979f, -0.17252132f, 0.13250010f, 0.20301388f, -0.05654778f, -0.08527146f, -0.06619530f, -0.02777717f, 
    -0.04393552f, -0.03503632f, -0.03767444f, -0.12365902f, 0.03111674f, 0.03707196f, 0.07299047f, 0.17825533f, 
    0.05716303f, 0.03178115f, 0.01547597f, 0.00095506f, -0.01956323f, -0.03511030f, -0.02905814f, 0.02680299f, 
    -0.12656850f, -0.04658557f, -0.08091392f, -0.04581162f, -0.08640111f, 0.02472808f, -0.04723538f, -0.04189994f, 
    -0.01860802f, -0.09961148f, 0.03476362f, -0.13917230f, 0.20914041f, 0.01980156f, 0.16460975f, -0.07992328f, 
    -0.02606456f, 0.03455839f, -0.08930060f, 0.03160107f, -0.04584910f, 0.00049460f, -0.09412782f, -0.03082271f, 
    0.02668535f, -0.07186829f, 0.13924211f, -0.08592534f, -0.03280158f, 0.03620148f, 0.00386561f, 0.04252525f, 
    -0.08591375f, 0.06504393f, -0.08221861f, -0.07180396f, 0.22361834f, -0.40935442f, 0.14502840f, -0.01099642f, 
    -0.06770723f, 0.01882793f, -0.10493843f, -0.07899634f, -0.05614451f, -0.00053334f, -0.00386796f, 0.00699266f, 
    -0.23112847f, 0.01850229f, -0.17562808f, 0.09089282f, -0.12538609f, -0.04295874f, 0.00717240f, -0.02656279f, 
    0.02542214f, -0.01433503f, -0.11813854f, 0.06699018f, -0.07972005f, 0.21300572f, -0.03481292f, 0.04365255f, 
    0.04222634f, -0.09338773f, -0.02559998f, 0.00458150f, 0.01887301f, -0.04273243f, -0.00125660f, -0.05960711f, 
    0.24675037f, 0.12314250f, -0.03262018f, 0.14366208f, 0.01823044f, 0.06842232f, -0.00453982f, -0.11233456f, 
    0.02051442f, -0.00354427f, -0.07692426f, -0.04919014f, 0.04061750f, -0.02876559f, -0.11470284f, 0.15994740f, 
    0.05495770f, -0.04617355f, 0.07615569f, -0.01572271f, -0.03420042f, 0.08587578f, -0.03904673f, -0.00483333f, 
    0.11880799f, 0.19743782f, 0.05508287f, 0.17012414f, 0.02812508f, 0.00425373f, 0.01935186f, -0.01173696f, 
    0.02948040f, 0.04590624f, 0.07736303f, 0.02346843f, 0.13102378f, 0.18542618f, 0.08150150f, -0.02310441f, 
    -0.00931373f, -0.05830042f, -0.01350921f, 0.02139321f, 0.00309984f, 0.01150702f, 0.03206745f, 0.03962243f, 
    -0.24834959f, -0.03368931f, -0.18216284f, -0.14073940f, 0.04181855f, -0.00411372f, -0.05805203f, -0.05569312f, 
    -0.11017950f, -0.00344880f, 0.06542453f, -0.02303441f, 0.12656680f, 0.05443754f, -0.03790251f, -0.00760816f, 
    -0.07101260f, -0.06203848f, -0.05740613f, -0.07344024f, -0.03605685f, 0.06831868f, -0.01148293f, -0.10199672f, 
    0.11439553f, -0.02144116f, 0.18393776f, 0.00669027f, 0.00754252f, 0.06116252f, -0.02181524f, -0.00656770f, 
    -0.01092814f, -0.02865978f, 0.04195191f, -0.00181883f, -0.21226974f, -0.03414469f, -0.10623173f, -0.11105835f, 
    -0.04954800f, 0.01018789f, -0.07418114f, -0.07551140f, -0.07800864f, -0.00619398f, -0.02135406f, 0.03070990f, 
    0.13687237f, 0.13566381f, 0.23007485f, 0.20733194f, 0.01170682f, 0.08580775f, 0.03465217f, -0.00220613f, 
    -0.02298257f, 0.01003071f, -0.02728615f, -0.02646170f, -0.20592716f, 0.11467002f, 0.02709078f, 0.02910736f, 
    0.01118558f, -0.02811063f, -0.02432955f, -0.00439497f, 0.00532323f, -0.03244809f, 0.00296248f, -0.04955883f, 
    0.21549912f, 0.02672127f, -0.00387978f, -0.22453237f, -0.02530852f, -0.03530500f, 0.00793216f, -0.02866482f, 
    0.05571070f, -0.02099279f, 0.01061452f, -0.02282392f, -0.15148993f, 0.04943977f, -0.18375489f, 0.12547524f, 
    -0.04169309f, -0.07115021f, -0.07058106f, 0.00000388f, 0.03002967f, -0.04096097f, 0.06360605f, -0.02705714f, 
    -0.05617060f, 0.04051615f, 0.09544396f, 0.14134303f, 0.04545935f, -0.02298730f, -0.00102083f, 0.01422308f, 
    -0.00246903f, 0.05053430f, -0.05727929f, 0.00948594f, -0.04663508f, 0.17674555f, 0.08359431f, 0.09502120f, 
    0.08724047f, 0.03452531f, 0.04984017f, -0.03509516f, -0.00864008f, -0.02937014f, -0.01678310f, 0.00770450f, 
    0.26572478f, -0.10181998f, 0.04600674f, -0.02276067f, 0.01032606f, -0.00048149f, -0.00516105f, -0.08496512f, 
    -0.10039338f, 0.01313556f, 0.02607110f, -0.08582093f, -0.00539098f, -0.17987928f, 0.01900616f, -0.00139132f, 
    -0.04002845f, -0.10215757f, -0.05058737f, -0.06101759f, 0.01947998f, -0.00874364f, 0.01279192f, -0.04818336f, 
    0.01357974f, 0.07127014f, 0.09863471f, 0.05991631f, 0.05446666f, 0.01258570f, 0.03737284f, -0.00257316f, 
    -0.07244645f, -0.06779684f, 0.03725049f, -0.05362951f, -0.27036542f, 0.06827308f, -0.05159395f, -0.09870359f, 
    -0.06610280f, 0.04199606f, -0.13038050f, 0.01039438f, -0.04871745f, -0.04350453f, -0.00091584f, -0.07604911f, 
    -0.10289155f, 0.16506468f, 0.09784487f, -0.03334868f, 0.03609958f, 0.03237198f, 0.04420834f, -0.00994824f, 
    0.08482872f, 0.05384523f, 0.03353675f, -0.12933150f, 0.06859200f, 0.00247136f, 0.17401344f, 0.05760084f, 
    0.08597939f, 0.01492801f, 0.01565078f, -0.02211108f, -0.12636775f, -0.00976324f, -0.00591533f, -0.06501628f, 
    0.00420320f, -0.09330062f, 0.08725893f, -0.08420140f, 0.02326721f, -0.02354000f, 0.00328036f, 0.01541035f, 
    0.04170819f, -0.17254357f, 0.04104383f, 0.01286784f, -0.01305333f, 0.16059422f, -0.12203468f, 0.00456553f, 
    -0.00414034f, 0.06284737f, 0.00009530f, -0.00451420f, 0.03091240f, -0.04066284f, -0.01487602f, 0.04593465f, 
    0.00162772f, -0.19333994f, -0.21159478f, 0.00488367f, -0.02845486f, 0.01279257f, 0.03779060f, -0.11887082f, 
    -0.04364162f, -0.04706224f, -0.09806245f, 0.12793499f, 0.18878232f, 0.07967178f, -0.08244321f, 0.10282508f, 
    -0.04471287f, 0.02202572f, 0.04801707f, -0.08789732f, -0.06610008f, 0.01232086f, -0.06065130f, -0.07232286f, 
    0.06321590f, -0.18250336f, 0.16785921f, 0.13916665f, -0.04699969f, -0.08168785f, 0.04158488f, -0.10925619f, 
    0.01348846f, -0.00818870f, -0.07688083f, 0.01050236f, 0.15734249f, 0.04110600f, -0.07463726f, 0.10288250f, 
    0.10609323f, 0.05788757f, -0.07351424f, -0.00777132f, -0.02259467f, 0.09630452f, 0.06028058f, 0.08939641f, 
    -0.04834921f, -0.09005059f, 0.03296216f, -0.10118756f, 0.04656449f, -0.17409399f, -0.24755518f, -0.00981814f, 
    0.13943656f, 0.05513582f, -0.09731657f, -0.07592879f, -0.18694992f, -0.13696401f, -0.09880023f, -0.27468708f, 
    -0.03634262f, -0.04823254f, 0.04553556f, 0.02309872f, 0.04635093f, 0.09440450f, -0.03998236f, -0.04745439f, 
    0.07569232f, 0.10327473f, -0.07632689f, -0.23048921f, -0.06450229f, 0.05248750f, -0.01363225f, -0.05896718f, 
    0.12002555f, 0.11236052f, 0.08403528f, 0.00629771f, -0.10751405f, -0.25665730f, 0.07331151f, 0.12345613f, 
    0.06054953f, -0.05112337f, -0.09992982f, -0.02094732f, 0.00691367f, 0.11015786f, 0.07668135f, 0.01252767f, 
    -0.12814476f, -0.03050251f, -0.03583375f, 0.06003672f, -0.03168648f, 0.02953558f, -0.10097355f, 0.00832148f, 
    0.05859572f, 0.11508725f, -0.02851549f, 0.05106133f, 0.02164749f, -0.22330715f, -0.14648655f, -0.07468680f, 
    0.09387887f, -0.08304723f, -0.07448325f, 0.01219795f, 0.09175613f, 0.05692906f, 0.02581134f, -0.17470980f, 
    -0.13380358f, -0.20134737f, 0.09736812f, -0.15409070f, -0.02451116f, -0.01359765f, 0.06627638f, -0.01641189f, 
    -0.06827303f, -0.02784795f, 0.02497927f, 0.10266172f, 0.10026704f, -0.23500299f, -0.15051281f, -0.18190046f, 
    0.10159000f, -0.00498256f, -0.09635053f, -0.12735401f, -0.02211006f, -0.02972325f, -0.01560727f, 0.08628514f, 
    0.11357351f, -0.10414539f, -0.02157949f, 0.07000396f, -0.02803693f, 0.01716008f, 0.04873640f, 0.09186156f, 
    -0.01339039f, -0.14092875f, -0.13201575f, 0.15149626f, -0.05274937f, -0.21994601f, 0.04047402f, -0.20040444f, 
    -0.01714200f, -0.06715772f, 0.00217535f, -0.09634166f, -0.01784484f, 0.01391240f, 0.03018813f, 0.13790387f, 
    -0.02534431f, -0.17466953f, -0.16368063f, -0.02822199f, 0.07578890f, -0.07215419f, -0.12274578f, 0.07704811f, 
    0.01063439f, 0.13298520f, -0.02317791f, -0.14414449f, -0.04718134f, 0.09862635f, 0.00805043f, -0.06750106f, 
    -0.14123470f, -0.04853396f, 0.01804582f, 0.08914897f, 0.10809040f, 0.03319620f, 0.08868184f, -0.03513797f, 
    -0.06465297f, -0.04303715f, -0.13679391f, -0.07431934f, -0.04322615f, -0.05973544f, -0.01341444f, 0.00793148f, 
    0.01940351f, 0.05486943f, -0.07586882f, 0.03861438f, 0.05268163f, -0.03062142f, -0.05523697f, 0.06434944f, 
    0.04995405f, 0.01607810f, 0.00997631f, -0.00903980f, -0.04516440f, -0.03847232f, 0.10458308f, -0.01724864f, 
    0.02672695f, -0.04691113f, -0.03082420f, -0.25467297f, 0.01569725f, 0.04708874f, -0.08774632f, 0.09867381f, 
    -0.03677049f, -0.00658440f, 0.10753634f, -0.04936816f, -0.00839186f, 0.04915115f, -0.11527766f, -0.19856824f, 
    -0.03175896f, -0.01031346f, 0.03929140f, -0.08580420f, 0.12400663f, -0.06707496f, 0.07847082f, 0.06069675f, 
    0.13887779f, 0.04000087f, -0.28318745f, -0.19575152f, 0.02836008f, -0.02972512f, -0.08295837f, -0.08736064f, 
    -0.06802479f, -0.10865357f, -0.16228104f, -0.04940691f, 0.07686383f, -0.06261674f, 0.13818705f, 0.11268996f, 
    -0.09780840f, -0.00429430f, -0.01026419f, 0.05217757f, -0.02407178f, -0.00247221f, -0.01475321f, -0.02265629f, 
    0.04677993f, 0.22009230f, -0.15620768f, 0.07422772f, 0.00050890f, -0.00695132f, -0.08634439f, 0.06442641f, 
    0.03752166f, -0.03097178f, -0.02670836f, 0.05636142f, 0.15900362f, 0.10364491f, 0.01226185f, 0.06036129f, 
    -0.01748246f, -0.00546907f, 0.11476465f, 0.07044912f, 0.08895730f, -0.06690934f, 0.12179881f, 0.07523781f, 
    -0.13025820f, 0.00261148f, -0.09387562f, 0.09529039f, 0.08821558f, -0.01747294f, -0.04055457f, 0.02320519f, 
    0.00664701f, 0.06593490f, 0.08205650f, 0.00311925f, 0.07663383f, -0.06865486f, -0.07344586f, 0.18562074f, 
    0.06107168f, 0.08543398f, -0.03430707f, 0.04093926f, 0.09903353f, 0.01951341f, 0.06247300f, 0.06916638f, 
    0.03464768f, 0.07105961f, -0.05572858f, 0.01018887f, -0.03962186f, -0.04375043f, 0.05712588f, 0.01946672f, 
    -0.01798717f, -0.00505719f, -0.08948948f, -0.05772142f, 0.12482855f, 0.17762502f, -0.03104548f, 0.11085786f, 
    -0.00707716f, -0.02821523f, 0.03670344f, 0.00904712f, 0.06173655f, -0.07839852f, -0.08546968f, -0.14209421f, 
    0.08329374f, -0.06192251f, 0.18747868f, 0.20579427f, -0.13400990f, 0.02366069f, -0.07688434f, 0.00854763f, 
    0.03531349f, 0.00145348f, 0.02336659f, -0.19335841f, 0.10579949f, 0.01471301f, 0.01773332f, 0.07028668f, 
    0.08056006f, -0.03368157f, -0.09811249f, -0.07588961f, 0.03098425f, -0.02692273f, 0.02429935f, -0.17842616f, 
    -0.13967177f, -0.02767629f, 0.04656260f, -0.14006574f, -0.05929453f, 0.02388140f, 0.02782180f, 0.03607543f, 
    0.04363324f, 0.06778967f, -0.10012424f, 0.03924257f, 0.10129759f, 0.00409171f, 0.13686053f, 0.13592429f, 
    0.06722362f, -0.08492062f, -0.01511910f, -0.01352742f, -0.00608160f, 0.01091356f, -0.00237531f, -0.09590206f, 
    -0.02257337f, 0.05614338f, -0.00882998f, 0.14305288f, -0.07764160f, -0.06374171f, -0.02834971f, 0.01400504f, 
    -0.03876518f, 0.03430728f, -0.01902854f, -0.09876014f, -0.11163421f, 0.03460479f, 0.12336926f, -0.03947968f, 
    0.00044152f, 0.05286877f, -0.06177141f, 0.01807501f, -0.05501630f, -0.03006799f, -0.06360459f, 0.00235582f, 
    -0.00147551f, -0.12638356f, -0.21789266f, -0.37642708f, 0.02573215f, -0.05864722f, -0.05614179f, -0.00646007f, 
    0.01715832f, 0.07403030f, 0.04241483f, 0.11184777f, -0.26442912f, -0.03644627f, 0.07701717f, 0.00034594f, 
    -0.00987916f, 0.00391188f, -0.07778963f, -0.13073863f, -0.03994065f, -0.03156841f, -0.00928124f, 0.02781239f, 
    0.10182808f, -0.01043694f, 0.03821560f, 0.09450648f, -0.02877959f, 0.01159463f, -0.07297002f, 0.03920741f, 
    -0.00889662f, 0.02159416f, 0.01419967f, 0.00749080f, -0.16531304f, 0.04200364f, 0.14099476f, -0.12790059f, 
    0.00120783f, -0.02682420f, -0.06036164f, 0.08094352f, 0.09834234f, -0.02095664f, 0.05277207f, -0.02886216f, 
    -0.15875019f, -0.02983753f, -0.01334125f, 0.01507696f, -0.07546606f, -0.05793995f, 0.06536737f, -0.03711879f, 
    0.07969155f, 0.05664084f, -0.03505227f, 0.11953611f, 0.18736985f, -0.02962266f, -0.14715916f, 0.12496954f, 
    0.10102259f, -0.03137053f, -0.05533955f, -0.00266745f, 0.06840993f, 0.00829348f, 0.08043160f, 0.04494618f, 
    0.32144004f, 0.10285544f, -0.06497110f, 0.01606350f, -0.06468969f, 0.04668840f, 0.02582691f, -0.11803501f, 
    -0.01565086f, -0.00234398f, 0.02747560f, 0.06266020f, 0.11194957f, 0.13403666f, 0.15632571f, 0.07617398f, 
    0.03741419f, -0.15085809f, -0.16216348f, -0.03787237f, 0.02959970f, -0.06759868f, -0.03163328f, 0.00785499f, 
    -0.19598757f, 0.13047005f, 0.09598380f, -0.02991116f, -0.08334640f, -0.00772127f, 0.02061316f, 0.06975608f, 
    -0.00817506f, 0.00788548f, -0.04362384f, -0.05659234f, 0.00437318f, -0.07322292f, -0.14811581f, -0.11381576f, 
    0.02140044f, -0.02555366f, -0.08960714f, 0.02601795f, 0.06966583f, -0.07243902f, 0.09993602f, -0.03014916f, 
    -0.20313090f, -0.07309336f, -0.07911213f, -0.05416457f, 0.03427852f, 0.03723599f, -0.16381195f, 0.03098570f, 
    0.01952661f, -0.03837064f, 0.12303924f, -0.00527170f, 0.00222437f, 0.09125644f, 0.09578145f, -0.01377624f, 
    -0.09606901f, 0.05217358f, 0.04561172f, 0.00481330f, 0.01193011f, -0.06626901f, -0.00353796f, -0.03082386f, 
    -0.10134379f, -0.22953787f, -0.07753534f, 0.12328387f, 0.12097836f, 0.01227218f, -0.01074408f, 0.07704505f, 
    0.04651795f, -0.01184021f, 0.11069144f, -0.03427786f, -0.23003754f, -0.09995859f, -0.08420442f, -0.17044646f, 
    0.02688301f, 0.01609972f, 0.05115611f, 0.00849613f, -0.03954043f, -0.09679887f, -0.04474138f, 0.15012351f, 
    -0.12055159f, -0.06208635f, 0.13327548f, -0.04462929f, -0.05369993f, 0.02023978f, 0.07422388f, -0.09480155f, 
    0.02570434f, -0.00363932f, -0.01743354f, 0.02907877f, 0.12835416f, 0.01570521f, -0.00234793f, 0.15745448f, 
    0.12990130f, 0.03492913f, -0.05070616f, -0.14765877f, -0.02944399f, 0.01942829f, 0.04223922f, 0.03148479f, 
    -0.20258385f, 0.07123467f, 0.03646792f, -0.03682927f, -0.01964591f, 0.06311614f, 0.05860415f, -0.05694417f, 
    0.00103179f, -0.02268663f, -0.13280046f, -0.02250307f, -0.07891864f, -0.06304704f, 0.23101069f, 0.03916198f, 
    -0.10626908f, 0.02209103f, 0.02894945f, -0.25836328f, -0.10973463f, 0.03830407f, 0.00597640f, 0.02086466f, 
    0.11860282f, 0.03292828f, -0.17933227f, -0.00110366f, 0.05864328f, -0.10720058f, 0.02808039f, -0.06635166f, 
    0.00776774f, -0.01424442f, 0.08404008f, -0.02327749f, 0.22087091f, 0.31082466f, -0.19933520f, -0.17384022f, 
    0.03524483f, -0.03780406f, -0.01819978f, 0.05718625f, 0.05881946f, -0.09886517f, -0.06080209f, 0.10222127f, 
    -0.23848674f, -0.00160309f, 0.02577548f, -0.22151174f, -0.01360171f, 0.04821185f, 0.03007844f, -0.07190818f, 
    0.01227559f, -0.00441103f, 0.05494566f, -0.02404592f, -0.01662881f, 0.15105201f, -0.05429751f, 0.14075491f, 
    -0.06534975f, 0.08191437f, -0.01453281f, 0.00733016f, -0.03112977f, -0.03106215f, 0.10956921f, -0.01523849f, 
    -0.14760715f, -0.26819411f, 0.14034773f, -0.15766972f, -0.08040129f, -0.19352478f, -0.07726295f, -0.05265279f, 
    0.00117817f, 0.03398208f, -0.12331563f, 0.15063162f, -0.10232525f, 0.03612137f, -0.18449144f, -0.08755267f, 
    -0.05168023f, 0.00535234f, -0.14356060f, 0.08704963f, 0.04749877f, 0.03103156f, -0.02875148f, 0.13053016f, 
    0.02353755f, -0.04092188f, -0.02406861f, 0.02167877f, 0.06277332f, -0.12545268f, -0.00718565f, -0.17713477f, 
    -0.00041980f, 0.05030926f, -0.04882819f, 0.03073509f, -0.04011728f, 0.03591554f, -0.19883090f, 0.08371506f, 
    0.01498934f, 0.04574517f, -0.10158262f, -0.07017690f, 0.02511207f, 0.03867985f, -0.02825522f, 0.05410561f, 
    -0.01356666f, 0.23991695f, -0.25314775f, 0.01981442f, 0.02408206f, 0.03237255f, -0.15620904f, -0.04701599f, 
    0.01050613f, -0.01597590f, -0.04494421f, 0.12787962f, -0.13561033f, -0.31503278f, 0.20863014f, -0.11145297f, 
    0.01347270f, -0.07737252f, -0.03800194f, -0.12323749f, -0.00764656f, 0.04620435f, -0.10025808f, 0.06155122f, 
    0.36009762f, -0.01717824f, -0.19741088f, 0.04125101f, 0.02355443f, -0.01130906f, 0.03571559f, -0.08202065f, 
    -0.08449496f, 0.11505889f, 0.02290009f, 0.04331600f, 0.05551225f, 0.26480797f, -0.00793385f, 0.11722728f, 
    -0.08297890f, 0.04875642f, 0.07894136f, 0.16356549f, 0.01490294f, 0.06208974f, -0.04836912f, 0.04351916f, 
    0.03835087f, -0.11994257f, 0.11651587f, -0.12896906f, 0.10499190f, 0.03381318f, -0.14958102f, 0.07246815f, 
    0.03258451f, 0.00105841f, 0.02402776f, -0.04212547f, 0.35845780f, -0.35331845f, -0.04110745f, -0.06326593f, 
    0.09056669f, 0.02391943f, -0.03616094f, -0.01509169f, -0.11737894f, -0.04059653f, 0.02043272f, -0.07068142f, 
    -0.44357044f, 0.25574845f, -0.05172580f, 0.09012011f, 0.03398512f, 0.02964332f, -0.18739983f, -0.04422268f, 
    -0.08102388f, 0.03197045f, -0.01971537f, 0.02958898f, 0.03067160f, -0.07088791f, 0.21426508f, 0.03783656f, 
    0.11779771f, 0.11713318f, 0.04858524f, -0.05536687f, -0.10590180f, 0.04635889f, -0.03424638f, 0.03826912f, 
    -0.08599067f, 0.11183771f, -0.20160969f, -0.09928922f, -0.06053118f, 0.00297201f, -0.03605222f, 0.09208498f, 
    0.04729511f, -0.13531125f, 0.13646364f, 0.00044430f, -0.14996733f, 0.06079434f, 0.00461124f, -0.16915095f, 
    -0.06804941f, -0.02288317f, -0.03949532f, 0.00845903f, 0.07864172f, -0.06402431f, -0.00522714f, -0.08219420f, 
    -0.12682985f, 0.00491890f, 0.02494979f, -0.01068152f, 0.08950297f, 0.07878627f, 0.03490684f, -0.02455266f, 
    -0.15376429f, -0.06593703f, -0.04170029f, -0.09517608f, -0.00474004f, 0.03184425f, -0.14346682f, -0.14924295f, 
    -0.02810959f, -0.09588619f, 0.03596907f, 0.05807805f, -0.00499338f, 0.07557021f, -0.07247312f, 0.02115183f, 
    -0.10144658f, -0.01622975f, -0.18354654f, -0.03460595f, 0.03446943f, 0.10527183f, -0.01467075f, 0.07365644f, 
    -0.00112070f, 0.01593604f, -0.01463441f, 0.01815419f, -0.05092885f, 0.10394228f, 0.08573020f, -0.01423521f, 
    -0.03174603f, 0.02184298f, 0.11262733f, -0.05550298f, 0.01428709f, 0.02010970f, 0.07593593f, -0.03950056f, 
    0.21651268f, -0.11190917f, 0.05238714f, 0.17408991f, -0.05148713f, -0.00653698f, -0.09257311f, 0.03365039f, 
    0.06351066f, -0.01954093f, 0.05748443f, -0.01973799f, 0.13499795f, -0.13886054f, 0.19876708f, -0.05808724f, 
    -0.16679773f, 0.02388558f, -0.08901867f, 0.07109878f, 0.04407809f, -0.07377804f, -0.00305641f, 0.06821144f, 
    0.05369517f, 0.14101928f, 0.01571023f, -0.04727045f, 0.14565323f, -0.04739820f, -0.02306606f, -0.21777537f, 
    0.06315225f, 0.03883031f, 0.02406888f, 0.05195292f, -0.06393746f, -0.26332042f, -0.10712457f, 0.04484062f, 
    0.05040753f, -0.00123456f, -0.02995258f, -0.03447527f, 0.02843182f, 0.00187911f, -0.12481283f, -0.20835988f, 
    -0.09717756f, 0.08636553f, 0.05396054f, -0.04998082f, -0.07455394f, 0.04233110f, 0.06387175f, -0.18642001f, 
    0.00625728f, 0.01693633f, -0.12173028f, 0.18606792f, 0.58406693f, 0.16246119f, -0.17723560f, -0.11826164f, 
    -0.03909610f, 0.05579117f, 0.04531044f, 0.13749166f, -0.11623590f, -0.03357095f, 0.05392408f, 0.10714033f, 
    -0.21601622f, 0.15652357f, -0.09564116f, -0.07646040f, 0.05113548f, -0.02912897f, 0.10731943f, -0.00874503f, 
    -0.10962387f, 0.01984024f, 0.03869637f, 0.03789431f, -0.03603321f, 0.09578279f, 0.18168001f, -0.19563739f, 
    0.01231644f, -0.00518784f, -0.08690845f, -0.09154873f, -0.08401737f, 0.01795836f, -0.02450760f, -0.16436844f, 
    0.24229543f, -0.04464075f, 0.03328883f, -0.04140259f, 0.09295128f, 0.03246934f, -0.01377996f, -0.01751888f, 
    -0.03787270f, 0.00472961f, -0.15305644f, 0.12131991f, 0.12386851f, -0.00018741f, -0.09348897f, -0.03960684f, 
    -0.00041778f, 0.07318836f, 0.06370854f, -0.11131904f, -0.19711986f, 0.07902730f, -0.05999102f, -0.08361658f, 
    0.12749110f, -0.04997949f, 0.15227552f, -0.01795465f, -0.05844037f, 0.01579551f, -0.05101886f, 0.08884156f, 
    0.08439890f, 0.12800086f, 0.09380789f, 0.09338479f, -0.05837987f, 0.01186658f, 0.04406591f, -0.10788378f, 
    0.05362530f, 0.02724575f, 0.04050349f, -0.15943946f, -0.00138009f, 0.02918113f, -0.07212011f, 0.09251180f, 
    -0.01431866f, 0.15725565f, -0.01901941f, 0.19434410f, 0.05210710f, -0.03336634f, 0.08209601f, 0.09454843f, 
    -0.00752236f, 0.03013008f, -0.09989078f, -0.02604367f, -0.42280820f, -0.22309485f, 0.06150935f, -0.18460813f, 
    0.03618751f, -0.07778621f, -0.03134772f, -0.00851904f, 0.08505306f, -0.01652420f, 0.07312763f, 0.06188137f, 
    -0.03368274f, 0.03707807f, 0.00714207f, -0.39945707f, 0.10115631f, 0.10937348f, -0.02203364f, -0.05336186f, 
    0.01141811f, 0.03665702f, 0.03065697f, -0.04382201f, -0.06751371f, 0.22820796f, -0.45895344f, -0.36183295f, 
    0.15776576f, -0.08881241f, -0.00107790f, 0.17904127f, -0.14018981f, -0.00306752f, -0.20105493f, -0.22248232f, 
    -0.31597000f, -0.01601175f, 0.06931895f, 0.09688113f, 0.02893353f, 0.02925067f, -0.08457921f, 0.08683163f, 
    -0.04636572f, -0.09270392f, 0.10377036f, -0.05457030f, -0.21627373f, 0.35121024f, 0.09367690f, 0.10805183f, 
    -0.03486592f, 0.04774585f, 0.00149179f, 0.07671005f, 0.14030881f, -0.03502795f, 0.08567596f, 0.11204174f, 
    0.11180335f, -0.46703872f, 0.06398793f, -0.02173780f, 0.00597754f, 0.14657457f, 0.09056010f, -0.00197828f, 
    -0.07993042f, 0.00004241f, -0.02910032f, 0.01434933f, -0.12305953f, 0.02216120f, -0.00495282f, -0.05757060f, 
    0.06525364f, 0.04115333f, -0.00452031f, -0.05586603f, -0.04945345f, 0.04033240f, -0.02656989f, 0.04656718f, 
    -0.16073754f, -0.17590320f, -0.17298818f, -0.02540031f, 0.00664524f, 0.06157814f, 0.00147967f, -0.07822218f, 
    -0.02824545f, -0.04986535f, 0.01021622f, -0.06895165f, -0.22679724f, 0.31217134f, -0.32805991f, -0.12562267f, 
    0.13979250f, -0.01210408f, -0.00267849f, -0.12173809f, -0.10006396f, -0.01516767f, 0.07564909f, -0.05820839f, 
    0.07650241f, -0.05538045f, 0.06788500f, -0.06073161f, -0.06507115f, -0.06461989f, 0.06581967f, 0.17643984f, 
    -0.06145466f, -0.10278923f, 0.09737533f, -0.09581608f, -0.09679754f, -0.30698341f, 0.02031041f, 0.02282598f, 
    -0.13644803f, -0.05690005f, -0.01959675f, 0.03830222f, -0.00390467f, 0.05627759f, 0.00083596f, -0.05272894f, 
    0.03653838f, -0.17230183f, 0.10294872f, -0.21602121f, 0.06565200f, 0.01497509f, -0.08287617f, -0.10506053f, 
    -0.02159679f, 0.04819403f, -0.05837248f, 0.01157897f, 0.09063513f, -0.22035617f, -0.20449552f, 0.18994375f, 
    -0.02102266f, 0.09844144f, -0.11270059f, 0.04812079f, 0.04281462f, -0.03036514f, 0.00548929f, 0.06059340f, 
    0.17861377f, -0.01012940f, 0.01308068f, -0.12819310f, -0.05746204f, 0.06193523f, -0.06199897f, -0.04644699f, 
    -0.00860252f, 0.01746800f, 0.01975786f, 0.05873710f, -0.19491942f, -0.20967899f, 0.00865756f, -0.17080770f, 
    -0.07431433f, 0.09778137f, 0.02199868f, -0.08478296f, -0.05767968f, 0.02439993f, 0.03595650f, 0.05312619f, 
    -0.04388703f, -0.01477592f, -0.07912558f, 0.10657104f, 0.03698789f, -0.02617540f, -0.09499039f, -0.14609100f, 
    0.04532618f, -0.02710037f, -0.01034355f, -0.08235403f, 0.19279256f, -0.32714906f, 0.02738049f, -0.03161903f, 
    -0.07147125f, -0.01007055f, -0.04085961f, -0.07167699f, 0.03222769f, 0.01636912f, 0.11032195f, -0.03354018f, 
    0.13626759f, 0.23057525f, -0.15333611f, -0.08758683f, 0.01939187f, 0.06455602f, 0.01380777f, 0.06154668f, 
    -0.03733157f, 0.04102144f, 0.03796764f, 0.02548270f, -0.25120047f, -0.31467694f, -0.16376817f, -0.12136108f, 
    -0.03803239f, 0.02472758f, -0.06808263f, 0.19163106f, 0.10574264f, 0.02047544f, 0.08409248f, -0.00586646f, 
    -0.15983760f, 0.48487434f, 0.01732732f, 0.20684862f, 0.02706240f, 0.00320503f, -0.06834976f, 0.04189040f, 
    0.10887866f, -0.01917091f, -0.01345093f, 0.08926991f, 0.03619465f, 0.13003959f, 0.08825471f, -0.27951589f, 
    0.00831328f, -0.04890678f, -0.02509065f, 0.00784100f, -0.16674221f, 0.03780256f, -0.04301860f, -0.00509366f, 
    -0.26035994f, -0.12579866f, 0.07267341f, 0.07360573f, -0.04426819f, 0.07252497f, 0.05891496f, 0.05101743f, 
    -0.13471049f, 0.01122562f, -0.11420441f, -0.09504101f, 0.03935908f, 0.06568005f, -0.00148462f, 0.10403933f, 
    0.16460724f, -0.07099795f, 0.08693341f, 0.02801877f, -0.11141749f, -0.03923898f, 0.13452445f, 0.07588165f, 
    -0.13796012f, -0.09629681f, 0.11053859f, -0.16351709f, 0.00659031f, 0.00269848f, 0.01315196f, -0.06460640f, 
    0.00938143f, -0.06687105f, -0.08646645f, -0.02023551f, 0.00823688f, 0.03164950f, -0.19245628f, -0.10078047f, 
    0.01320230f, -0.08784726f, -0.05896304f, -0.03117047f, -0.08719627f, 0.01079802f, 0.15481758f, 0.04431557f, 
    0.07948998f, -0.19316521f, -0.07295841f, 0.25298646f, 0.02095684f, -0.03046427f, -0.10829128f, 0.01022642f, 
    -0.06253809f, 0.03996437f, -0.03589558f, -0.07309905f, -0.10072641f, 0.13112484f, -0.13361354f, -0.24259782f, 
    0.16624303f, -0.08258384f, 0.03702573f, 0.07090022f, -0.08221658f, -0.01656761f, -0.08632569f, 0.00034383f, 
    0.03139940f, -0.01561132f, -0.16954128f, 0.08246176f, 0.06803812f, 0.06808389f, -0.07675865f, 0.08422829f, 
    -0.13526297f, -0.05507179f, 0.08053726f, -0.03622114f, 0.42577183f, -0.09165598f, -0.03120752f, -0.04525543f, 
    0.08399225f, -0.12752727f, -0.00636479f, 0.09815701f, 0.02414593f, -0.08637381f, 0.06809998f, 0.02395150f, 
    -0.17265444f, -0.14164369f, -0.07372578f, 0.08284892f, 0.02460288f, -0.00357405f, -0.01691417f, -0.06164554f, 
    0.05255325f, 0.10095595f, 0.10431155f, 0.09056192f, 0.15453590f, 0.02052094f, 0.37270302f, 0.04273818f, 
    -0.00902511f, 0.05907931f, 0.04422124f, -0.04515272f, 0.04678484f, -0.00463475f, 0.08713310f, -0.01329920f, 
    -0.19403501f, -0.07931630f, -0.12980947f, 0.14399473f, 0.00030283f, -0.00300337f, 0.01658596f, -0.00559412f, 
    0.08716279f, 0.03110666f, -0.04457125f, 0.04716216f, -0.30160138f, -0.16696601f, 0.22368990f, 0.06354481f, 
    0.00937993f, -0.14212479f, 0.04124653f, 0.09549391f, 0.09302595f, -0.06486503f, -0.02658133f, -0.03578709f, 
    0.30768934f, 0.22239828f, 0.03315304f, 0.10394615f, -0.02675052f, -0.03472241f, 0.03501735f, -0.01711329f, 
    0.00121410f, -0.03059530f, 0.15019940f, 0.01829115f, -0.06344496f, 0.00355641f, -0.08522425f, 0.00582975f, 
    -0.06140239f, 0.03607034f, 0.04505983f, -0.01816493f, 0.16386814f, 0.02821775f, -0.00374851f, -0.17667779f, 
    0.08927013f, -0.26185220f, -0.11187595f, 0.02354140f, 0.03559127f, 0.04952400f, 0.06339069f, 0.05795835f, 
    0.08412278f, -0.09486055f, 0.07175897f, -0.06331859f, -0.19885227f, 0.10215425f, 0.13661866f, 0.07726277f, 
    0.06181653f, 0.07966445f, 0.00157656f, -0.11044849f, -0.03895495f, -0.14800377f, -0.04734436f, -0.07624444f, 
    -0.01638854f, -0.10098495f, 0.15007679f, -0.07588223f, 0.04214215f, -0.05969547f, -0.00894586f, -0.00994818f, 
    -0.03663518f, -0.01605833f, 0.01423105f, 0.06927226f, 0.11561586f, -0.02223678f, -0.14506957f, 0.28507864f, 
    -0.12424333f, -0.03840668f, 0.08653210f, -0.02596744f, 0.05417128f, 0.06615335f, 0.03842718f, -0.09504903f, 
    0.15024213f, 0.13079450f, 0.02092441f, 0.05323313f, -0.10116193f, -0.00043995f, -0.03156775f, 0.00965669f, 
    -0.00539441f, -0.06290510f, -0.05538648f, -0.13243312f, -0.33781445f, -0.30402490f, 0.11081140f, 0.09312584f, 
    -0.02354161f, 0.06312960f, 0.05261309f, -0.09862859f, 0.04826657f, -0.06451856f, 0.09611188f, 0.04286812f, 
    -0.24174342f, -0.00427431f, -0.02615818f, -0.03858634f, 0.05675265f, 0.09459437f, 0.11561497f, -0.03963128f, 
    0.16291746f, -0.03157230f, 0.00734968f, 0.07134256f, -0.18167700f, -0.01253086f, -0.19834207f, -0.08401102f, 
    -0.00743819f, 0.10359476f, -0.05952606f, 0.04412475f, 0.09334278f, 0.13842051f, 0.05558106f, 0.09549241f, 
    0.28790238f, -0.08842960f, -0.11235247f, 0.16142367f, -0.04597509f, -0.15353467f, 0.00492133f, 0.12808190f, 
    0.03275627f, -0.11030316f, -0.10845226f, -0.04008017f, -0.43473846f, -0.11401112f, -0.12358653f, -0.04420862f, 
    0.06457802f, -0.01498303f, -0.11104470f, 0.03513296f, 0.03971697f, -0.00825100f, 0.07717430f, 0.17020150f, 
    -0.16727598f, 0.13065454f, -0.22097634f, -0.14690153f, 0.14005539f, -0.06496203f, -0.09430934f, 0.06944059f, 
    0.06091027f, -0.09161587f, 0.00586655f, -0.01937160f, 0.33406371f, 0.26973116f, 0.12169410f, -0.09099098f, 
    -0.05494029f, 0.03971522f, 0.09774087f, 0.06059914f, 0.04080858f, 0.05433126f, 0.00153660f, 0.02896588f, 
    0.01430931f, 0.04499368f, -0.01130844f, -0.09624027f, 0.15308508f, 0.06851138f, -0.03502215f, -0.01608522f, 
    0.02412325f, 0.07460257f, 0.05379216f, 0.02061901f, -0.04551657f, -0.09366008f, -0.11674020f, -0.17379758f, 
    0.08821554f, -0.07943841f, -0.14102381f, 0.02734539f, 0.04880078f, -0.02521710f, 0.05619567f, 0.00065635f, 
    -0.06771006f, -0.01239935f, 0.12110205f, -0.09210694f, -0.00198263f, 0.03796702f, 0.07226513f, 0.05304659f, 
    0.07155978f, 0.06076976f, -0.15031746f, 0.09298627f, -0.33835742f, 0.00955844f, 0.10173254f, 0.11502807f, 
    0.01234779f, -0.03907505f, 0.04784212f, 0.03781122f, 0.05458056f, 0.05460081f, -0.00749239f, 0.07447046f, 
    0.21565388f, 0.18113099f, 0.09662218f, -0.17487948f, 0.13351946f, -0.00480126f, 0.05973608f, -0.00521334f, 
    0.04546276f, 0.05956159f, -0.06412656f, 0.00741826f, -0.31470662f, -0.05995014f, 0.15722390f, 0.01662863f, 
    0.13224408f, -0.09590562f, -0.01120517f, -0.08735654f, 0.04646821f, 0.04119651f, -0.12816182f, -0.00436050f, 
    -0.11054024f, 0.01432491f, -0.01655078f, 0.00632812f, 0.05385629f, -0.01905829f, -0.01155145f, -0.03838252f, 
    0.06411332f, 0.02196798f, -0.03138597f, 0.23251352f, 0.26671258f, 0.08184517f, -0.06997330f, -0.06856412f, 
    -0.03223107f, 0.00027486f, 0.04535723f, 0.04142262f, -0.05368033f, 0.08251537f, -0.00003885f, 0.17612663f, 
    -0.31468743f, -0.33500314f, 0.26325476f, 0.04689157f, -0.02050294f, 0.04193020f, -0.00202262f, 0.07007874f, 
    0.03409079f, -0.01941859f, -0.22872759f, -0.02186507f, -0.16874126f, -0.11941887f, 0.16926225f, 0.26780689f, 
    -0.07847212f, -0.02876263f, 0.08413891f, -0.11900758f, 0.11985061f, 0.10906173f, -0.02471248f, -0.11634208f, 
    -0.23325311f, -0.16647282f, 0.07296064f, 0.18974744f, -0.01770733f, -0.02895252f, 0.02826290f, 0.09126514f, 
    0.09011156f, 0.09860948f, -0.03831326f, 0.16761416f, -0.30803809f, -0.27052122f, -0.08045106f, -0.10978123f, 
    0.09462874f, 0.04383298f, -0.07093240f, -0.08558555f, 0.01580743f, -0.05261217f, 0.00719533f, 0.10398272f, 
    0.07609923f, 0.00927162f, -0.09817450f, 0.04077377f, -0.05203002f, 0.09908103f, -0.05068285f, -0.12226591f, 
    -0.08213443f, 0.09621734f, 0.15852478f, -0.04156913f, 0.02974320f, -0.01424023f, 0.10707503f, 0.07678298f, 
    0.06504680f, 0.05945802f, -0.04005781f, 0.09642287f, 0.04583237f, 0.07022873f, 0.18585867f, 0.01872475f, 
    -0.34806564f, 0.03498303f, -0.08411650f, 0.04951602f, 0.05448978f, -0.04002909f, 0.06211219f, -0.15201022f, 
    -0.07680520f, -0.37503576f, -0.19152740f, -0.12623785f, 0.19507128f, 0.06852607f, -0.05022023f, 0.07868243f, 
    -0.06135924f, -0.01578230f, -0.02288948f, 0.08325066f, -0.02972284f, -0.02920657f, 0.01976494f, 0.06860932f, 
    0.08163776f, 0.00147087f, -0.00970979f, -0.05646044f, -0.10762502f, -0.03679170f, -0.00699685f, 0.17243733f, 
    -0.00789138f, -0.12267200f, 0.09458569f, -0.01561570f, -0.15260886f, -0.09128122f, -0.13970442f, 0.06027300f, 
    -0.07370942f, -0.07233866f, -0.03151092f, -0.00050006f, 0.00936952f, 0.04986155f, 0.09078622f, -0.04975469f, 
    0.16732831f, -0.00775598f, -0.12011521f, -0.20068054f, 0.03519033f, 0.01127632f, -0.01833462f, 0.08011261f, 
    0.08488367f, -0.01133343f, 0.02391421f, 0.05385837f, -0.27764425f, -0.21355988f, -0.16082789f, -0.19102988f, 
    -0.04368705f, -0.04013229f, 0.00100341f, 0.08326384f, 0.03623612f, 0.11241997f, 0.14205642f, 0.04727739f, 
    0.11248627f, -0.00604991f, 0.10222424f, -0.04778966f, -0.14429790f, 0.00209270f, 0.01485126f, 0.06566899f, 
    0.02527115f, 0.07151469f, -0.15390116f, -0.02518712f, -0.10377075f, -0.25612074f, -0.01930583f, -0.07029629f, 
    -0.02739804f, -0.01970335f, 0.09604102f, -0.01914949f, 0.14192781f, -0.01981827f, -0.24057589f, -0.09265018f, 
    0.03197780f, 0.12794472f, -0.09494510f, 0.03466179f, -0.10932822f, -0.05247145f, -0.08694887f, 0.02852720f, 
    0.01480171f, 0.03843682f, 0.03576818f, -0.05943587f, -0.51830608f, -0.08532646f, -0.08181520f, -0.16392803f, 
    0.13331273f, 0.07150338f, -0.13314120f, -0.08959230f, -0.04228659f, -0.15338008f, -0.06068837f, -0.09604663f, 
    0.01845168f, 0.08604278f, 0.00849713f, -0.04222096f, -0.00368639f, 0.11465001f, -0.03082504f, 0.04684573f, 
    -0.01077831f, -0.00043885f, 0.04337747f, 0.12167750f, -0.43533814f, -0.22336045f, -0.14347412f, -0.27084452f, 
    0.02458378f, -0.03175698f, -0.02265883f, -0.09159035f, -0.05478626f, -0.08841485f, -0.10564928f, -0.00567518f, 
    0.21774575f, -0.13097341f, 0.05972540f, -0.07941724f, -0.01532663f, 0.01831622f, 0.04271749f, 0.00263537f, 
    -0.01258654f, 0.17322937f, -0.06738036f, -0.01971866f, 0.18620834f, 0.10497200f, 0.04313413f, -0.08732846f, 
    -0.00154437f, 0.02191509f, 0.03840425f, 0.00746321f, -0.04490914f, -0.01431139f, -0.00022109f, -0.00829817f, 
    0.01973280f, 0.17747310f, 0.07914855f, -0.05379508f, 0.06085764f, -0.09569673f, 0.02185390f, 0.06455596f, 
    0.01403225f, 0.07659753f, -0.04234445f, 0.05802809f, 0.13787486f, 0.04620002f, 0.08229700f, -0.10589974f, 
    -0.04353283f, -0.11036253f, -0.03654798f, 0.01587115f, 0.01830957f, 0.05142094f, -0.04215192f, 0.06976097f, 
    -0.05882344f, -0.18578379f, -0.05183579f, 0.00359825f, -0.01390990f, 0.05452446f, 0.10441870f, 0.09125179f, 
    0.00934034f, 0.03610471f, 0.09593452f, 0.08428978f, 0.14570501f, -0.04133044f, -0.06979603f, -0.02632377f, 
    0.01167224f, -0.02291183f, 0.07096692f, 0.00236366f, -0.02412582f, -0.03340927f, -0.02683369f, 0.12875947f, 
    0.21510229f, 0.04908816f, -0.12792116f, 0.06385980f, -0.03292274f, -0.09766843f, -0.03089830f, 0.03488789f, 
    -0.02692894f, 0.01688638f, 0.01863439f, 0.00293061f, -0.43030152f, 0.05577999f, -0.28945673f, 0.01193848f, 
    -0.02373687f, 0.05826546f, -0.05282202f, -0.02799580f, 0.04421054f, 0.06738345f, -0.01106595f, -0.04313248f, 
    -0.48817763f, -0.18689190f, -0.11125148f, -0.13896623f, 0.11319301f, -0.01249755f, 0.06986743f, -0.06295610f, 
    0.11223049f, 0.10652851f, -0.00360192f, 0.05814821f, 0.03695872f, 0.12788516f, 0.01759853f, -0.23343870f, 
    0.06523646f, -0.13285908f, -0.06203802f, 0.03217696f, -0.01218465f, 0.01579068f, -0.13460167f, 0.07871037f, 
    0.01557049f, -0.04072005f, 0.06124903f, 0.01524523f, 0.01015614f, -0.03579585f, 0.03953207f, 0.09203187f, 
    0.04624601f, -0.01309243f, 0.00537592f, -0.00242370f, -0.25314221f, -0.06227547f, -0.04740323f, 0.15395109f, 
    0.09654139f, 0.00550765f, -0.01235531f, -0.09910473f, -0.00199035f, -0.08382294f, 0.07595015f, -0.07389356f, 
    -0.30189794f, -0.03886857f, 0.07360125f, -0.05076958f, 0.10832223f, -0.09391686f, 0.04341301f, -0.14125226f, 
    -0.00998969f, -0.01006605f, -0.05181976f, -0.07350388f, 0.13808993f, -0.02278120f, 0.03454948f, 0.01286288f, 
    -0.00950911f, 0.01630767f, -0.00601313f, -0.02847648f, 0.10503877f, 0.02812188f, -0.03545366f, -0.03595048f, 
    -0.27056706f, -0.19513793f, 0.05650463f, -0.15515897f, 0.08452905f, -0.01434543f, 0.01717577f, 0.05764900f, 
    0.01741520f, 0.07053942f, 0.05117625f, 0.11443210f, 0.12598860f, 0.06112676f, 0.14873894f, -0.05254475f, 
    0.07436877f, 0.07559524f, 0.01723830f, -0.01716827f, 0.08517239f, -0.17071860f, -0.02765899f, 0.05315690f, 
    0.25851831f, -0.08341949f, 0.09921678f, -0.04714015f, -0.09816001f, 0.08201414f, 0.01188889f, -0.05449142f, 
    0.02585384f, 0.03638824f, -0.10541727f, 0.00417515f, -0.23811246f, -0.22935414f, -0.14696035f, -0.25446710f, 
    -0.02776981f, 0.12790060f, -0.02547968f, -0.06557173f, 0.05696000f, -0.01344926f, 0.04974538f, -0.02383500f, 
    0.23632589f, -0.01594193f, 0.09102718f, -0.15393957f, -0.13230258f, -0.04403182f, 0.03863476f, -0.07383005f, 
    0.05755587f, -0.11804607f, -0.02741309f, -0.08888599f, 0.12130092f, 0.07188244f, 0.11175674f, 0.03851533f, 
    -0.12511748f, 0.02704429f, 0.09566839f, 0.01434867f, -0.00482590f, 0.00554308f, 0.08875250f, 0.10385421f, 
    -0.00358259f, -0.05791524f, -0.11234939f, 0.05781579f, -0.00511547f, 0.12627803f, -0.03609014f, 0.00035282f, 
    0.04208504f, -0.04046678f, -0.17858483f, -0.04768287f, -0.34433362f, -0.00951871f, 0.16694807f, -0.04503246f, 
    0.02075799f, -0.06334555f, -0.05687325f, -0.05901061f, 0.10245370f, -0.06439506f, -0.08368657f, 0.08452434f, 
    0.17182881f, 0.08361242f, -0.03414537f, 0.00284081f, 0.01869491f, -0.03789789f, 0.09126475f, 0.03101842f, 
    0.02424949f, -0.11368115f, -0.02319964f, -0.01453329f, 0.12609453f, 0.08792357f, -0.03788945f, 0.00140573f, 
    -0.06629270f, -0.00386522f, 0.02300317f, -0.03951156f, -0.06535853f, -0.11467741f, 0.09861552f, -0.00951080f, 
    -0.32071713f, 0.03844088f, -0.03018555f, -0.08060193f, -0.00383722f, -0.07044097f, -0.02968115f, -0.06955746f, 
    0.00488887f, -0.02641582f, -0.03760547f, 0.10163613f, 0.24116461f, 0.04874310f, -0.00744579f, 0.03098578f, 
    0.02970304f, 0.15872405f, 0.01087122f, 0.14695519f, 0.08931895f, 0.08892368f, 0.06630974f, 0.13621199f, 
    -0.05554128f, 0.09562755f, -0.09653748f, -0.03746552f, -0.05246461f, -0.02741236f, 0.01745366f, -0.06478010f, 
    -0.01809503f, -0.09688701f, -0.13821211f, -0.10531207f, -0.35092533f, -0.28715664f, 0.01309950f, 0.04615371f, 
    0.13241468f, 0.04121475f, 0.11166540f, -0.02190015f, 0.07822894f, 0.04500043f, 0.01865914f, 0.08672846f, 
    -0.23648214f, -0.06141331f, 0.00690238f, -0.03360039f, 0.07324716f, -0.03619699f, 0.04812371f, -0.17940336f, 
    0.09722305f, -0.08808322f, -0.00932740f, -0.03634596f, 0.07326516f, 0.00093038f, -0.02090814f, 0.07504753f, 
    0.04522160f, 0.03320099f, 0.01459292f, -0.00444974f, -0.01242722f, -0.02497274f, 0.01580073f, 0.11265690f, 
    -0.45865273f, 0.00726883f, -0.05200632f, 0.07300775f, 0.00253471f, -0.03805981f, 0.03525959f, 0.01542965f, 
    0.03753700f, 0.00837377f, -0.00233581f, 0.08320196f, -0.05876838f, 0.28178826f, -0.12478944f, 0.03506599f, 
    0.10847934f, -0.08045969f, -0.11848069f, 0.04058997f, -0.01630211f, -0.04019316f, -0.02961905f, 0.02884738f, 
    0.23796879f, 0.08737580f, 0.07122337f, 0.21864547f, 0.07239541f, -0.04068518f, -0.09532344f, -0.00196668f, 
    -0.07407013f, 0.04266580f, -0.01611846f, 0.02966528f, -0.09864515f, 0.08639219f, -0.15545078f, 0.10284206f, 
    0.06631321f, 0.01442613f, 0.06221877f, 0.09815360f, -0.07335414f, -0.04216589f, 0.13124901f, 0.03407709f, 
    0.14107977f, -0.07183667f, 0.05064253f, -0.10727535f, 0.06838343f, -0.11560433f, 0.14569131f, -0.01421907f, 
    -0.03522126f, 0.12439767f, 0.00588277f, 0.05706817f, 0.38791904f, 0.00256075f, -0.16384764f, -0.11583171f, 
    0.05184962f, 0.02534581f, -0.00938019f, 0.05459708f, 0.01366222f, 0.02987709f, 0.00141080f, -0.07019115f, 
    -0.03916270f, -0.01886211f, 0.17557652f, 0.41111171f, -0.13141887f, 0.09489383f, 0.03403603f, 0.07985748f, 
    -0.02266366f, -0.03845767f, 0.08423379f, 0.13933252f, -0.05453544f, 0.01607767f, -0.14805587f, -0.00908007f, 
    0.14315690f, -0.03945355f, 0.05833264f, 0.10671724f, 0.07625260f, 0.03347699f, -0.01283987f, -0.12610066f, 
    -0.02739505f, -0.16018115f, -0.08632759f, -0.04856410f, 0.08643421f, -0.15248021f, -0.09829265f, -0.06678697f, 
    -0.07011167f, -0.07275190f, -0.05575324f, -0.03130938f, 0.03112040f, -0.08500688f, -0.03601960f, 0.03587197f, 
    -0.02473407f, -0.08101482f, -0.01852506f, 0.00660844f, 0.04012167f, 0.01333133f, 0.01279695f, 0.02871739f, 
    0.10314719f, 0.12035134f, -0.10438944f, 0.04563795f, 0.08088411f, -0.04377840f, 0.04345933f, -0.03182328f, 
    0.15404749f, 0.01249498f, 0.05319051f, 0.01818841f, 0.10275696f, 0.25616139f, 0.00831806f, -0.07508054f, 
    0.06836069f, 0.04774813f, -0.06769428f, -0.04962702f, 0.08160865f, 0.02929588f, 0.08100048f, -0.00225469f, 
    -0.24332857f, 0.22373846f, 0.02193775f, -0.19621268f, -0.06513184f, 0.04276554f, -0.10975512f, -0.01557850f, 
    0.09098987f, -0.02235444f, 0.06512307f, -0.26943451f, 0.33146527f, -0.00372738f, 0.04390641f, -0.14921896f, 
    0.05981883f, -0.01445562f, -0.06318614f, 0.03514793f, 0.12022881f, -0.03064934f, -0.01177382f, 0.08694491f, 
    -0.04165772f, -0.06804495f, -0.00359112f, -0.11274901f, 0.02702637f, 0.07496541f, -0.09776840f, 0.00647810f, 
    -0.08605651f, -0.03787701f, 0.00736041f, -0.16508128f, 0.02590614f, 0.02021840f, -0.03633695f, -0.05625795f, 
    -0.09010179f, 0.01349609f, -0.01412294f, -0.09589606f, -0.02474668f, -0.14579061f, -0.02102167f, -0.14170332f, 
    0.09557187f, 0.19352782f, 0.03337555f, -0.23137784f, 0.13112141f, -0.10113189f, -0.30297035f, 0.16870372f, 
    0.04511614f, 0.09981386f, 0.07236241f, -0.00740324f, 0.08844146f, -0.18851744f, 0.02166189f, -0.03980859f, 
    -0.03664673f, -0.13950092f, -0.03836720f, 0.15365028f, -0.04738122f, -0.01989598f, -0.03140237f, 0.03053565f, 
    -0.10886969f, -0.20396438f, 0.10210850f, 0.11173268f, 0.18572856f, -0.06948837f, 0.08404548f, -0.03216977f, 
    -0.06951603f, -0.08646566f, -0.00443840f, -0.02843245f, 0.35124272f, -0.00142269f, -0.07509866f, -0.17337330f, 
    -0.06088319f, 0.00500340f, 0.00903964f, 0.05479279f, -0.03046923f, 0.00629117f, -0.00268175f, 0.09868824f, 
    -0.20722480f, 0.11606598f, 0.07508537f, 0.03252429f, 0.03216965f, -0.01899750f, -0.10904414f, -0.28240377f, 
    0.01033120f, -0.14249641f, -0.08250798f, -0.13914971f, -0.03921872f, 0.06155451f, -0.13654418f, -0.03774144f, 
    0.02066226f, -0.09267730f, 0.03109433f, -0.01786203f, -0.07965752f, 0.00124795f, -0.00857546f, -0.04713877f, 
    -0.03564898f, 0.04293228f, 0.02326901f, -0.02822874f, -0.03959657f, -0.06452041f, -0.07247069f, -0.08548426f, 
    0.08248450f, 0.00485207f, 0.04605501f, 0.10106748f, -0.03568742f, -0.01202264f, -0.01418670f, 0.05281112f, 
    -0.00213442f, 0.08412297f, -0.01597035f, 0.01622057f, -0.08817948f, -0.08194330f, -0.13165903f, -0.01538027f, 
    -0.30773023f, -0.18265633f, -0.08061209f, -0.06477616f, 0.00771517f, 0.06740322f, 0.04238589f, -0.06621556f, 
    -0.02159505f, 0.12333968f, 0.00580062f, -0.07462170f, -0.04628925f, -0.29908541f, -0.05520001f, 0.06598518f, 
    -0.07369062f, 0.19416142f, -0.09358160f, 0.03508775f, 0.01775451f, 0.05140341f, -0.08003491f, 0.03440663f, 
    0.32180101f, -0.15479735f, -0.27821258f, 0.06973051f, -0.02418651f, -0.01508108f, 0.03836677f, 0.07851458f, 
    0.00024883f, -0.03741484f, 0.13316984f, 0.04044236f, 0.13925953f, -0.16183881f, 0.02971131f, -0.00868404f, 
    0.05065035f, -0.01860192f, -0.01990401f, -0.10280637f, 0.03007805f, -0.01027020f, -0.08654321f, -0.06186059f, 
    -0.15568671f, -0.05792989f, -0.03114127f, 0.01356946f, 0.01698452f, 0.09606529f, -0.05007795f, -0.01561399f, 
    -0.10537503f, 0.04459671f, 0.03994819f, -0.05999308f, -0.03924458f, -0.15801525f, 0.05377455f, 0.00616782f, 
    0.10234852f, -0.00542726f, -0.01518501f, -0.02325431f, -0.02994279f, 0.09446190f, -0.01853616f, -0.00670830f, 
    -0.19880553f, -0.03101097f, -0.04574188f, -0.03922703f, -0.12783191f, 0.06259164f, 0.11017529f, 0.18501711f, 
    0.06943838f, 0.00176349f, -0.05326567f, 0.04892777f, 0.04579740f, -0.18751541f, -0.04403353f, -0.33527619f, 
    -0.07538158f, 0.04952452f, 0.02553006f, -0.04075915f, 0.08301827f, 0.05907315f, -0.05400087f, -0.07017504f, 
    -0.11721708f, 0.16776039f, 0.07246748f, 0.02146894f, -0.02034105f, -0.00656371f, 0.10639446f, -0.18649174f, 
    -0.03720061f, -0.02285538f, 0.00095509f, -0.06045962f, -0.10127160f, -0.29354891f, -0.13535643f, -0.27716681f, 
    0.06979118f, -0.00306449f, 0.04605058f, 0.01056582f, 0.01061563f, 0.06981128f, -0.03464871f, -0.02011404f, 
    -0.17051148f, -0.01591676f, 0.01563222f, 0.07667919f, 0.03660007f, 0.11374795f, 0.05959713f, 0.02615949f, 
    0.00602685f, -0.04138143f, -0.02372259f, -0.02304627f, 0.07102598f, 0.14287417f, -0.01212095f, 0.01678037f, 
    -0.04091013f, -0.03972389f, -0.02278197f, -0.07382935f, -0.03503500f, 0.10290236f, 0.02851087f, -0.12325303f, 
    0.31336060f, -0.10081914f, -0.11435156f, 0.25527272f, -0.16141589f, 0.00173539f, -0.06460840f, 0.07249048f, 
    0.13490140f, -0.08044254f, 0.05496977f, -0.04324728f, -0.00896378f, 0.15481895f, -0.03482672f, -0.02341342f, 
    -0.00464506f, -0.02448921f, 0.09939533f, -0.04481226f, -0.01986390f, 0.04520439f, 0.03978740f, 0.04719140f, 
    -0.35468030f, -0.22408225f, -0.19425455f, -0.09439222f, -0.06008658f, 0.12428792f, 0.06324847f, 0.08756536f, 
    -0.04091492f, 0.01970916f, -0.03719634f, -0.02604145f, 0.06744553f, 0.16030674f, -0.09369317f, -0.07059263f, 
    0.00731380f, -0.04233381f, -0.00147141f, -0.03417702f, -0.00739723f, 0.05555148f, 0.03866943f, -0.00956346f, 
    0.01476221f, 0.07675552f, 0.05411319f, 0.03149975f, 0.01305759f, -0.04000885f, 0.08015959f, 0.03843888f, 
    -0.11026428f, -0.06782697f, 0.06232627f, 0.02900539f, -0.06259881f, 0.17366384f, -0.23748329f, -0.22469251f, 
    0.00734403f, -0.08697797f, -0.05895207f, 0.04830930f, -0.05290444f, -0.04093382f, -0.03824630f, -0.05159241f, 
    0.39836237f, -0.38081920f, -0.13630743f, 0.06610972f, 0.01194294f, -0.01990400f, -0.09506402f, -0.00137632f, 
    0.09673932f, -0.05643428f, -0.01865450f, -0.00485282f, -0.29184777f, -0.10818964f, 0.13514961f, 0.04133630f, 
    0.00104655f, 0.17334734f, -0.01989679f, 0.02574182f, -0.02842629f, 0.05511308f, -0.03553974f, -0.04161796f, 
    0.10887419f, -0.04436283f, -0.00215830f, 0.14187814f, 0.03047045f, -0.14183259f, -0.00769373f, -0.01382217f, 
    -0.00810835f, 0.07507885f, -0.04187254f, 0.05686167f, 0.10370151f, -0.21713717f, 0.02686256f, 0.06128161f, 
    -0.05107972f, 0.16893238f, 0.07791433f, 0.00889896f, 0.12551954f, 0.01730216f, -0.01023189f, -0.02897301f, 
    0.16523623f, -0.06635770f, -0.10238039f, 0.16665749f, -0.05614427f, 0.01974588f, -0.00116213f, -0.00202048f, 
    -0.08583203f, -0.21841636f, -0.02053764f, -0.09272853f, -0.07641701f, -0.20875266f, 0.09381138f, -0.05534841f, 
    -0.09274375f, -0.04292903f, 0.05486459f, -0.01139241f, -0.03851046f, -0.05621506f, 0.01795250f, -0.11146854f, 
    0.43025932f, 0.21676135f, -0.19785137f, -0.02329497f, 0.02732391f, 0.07190066f, 0.00139475f, -0.01364992f, 
    0.09094068f, -0.06831811f, -0.04714585f, -0.02995294f, -0.09690796f, 0.11323603f, 0.02768402f, -0.04930871f, 
    0.05182279f, -0.07732840f, 0.00874679f, 0.03182825f, -0.02673450f, 0.13152318f, 0.04059624f, 0.08850305f, 
    -0.21178880f, 0.15760441f, 0.08585799f, -0.11575189f, 0.03589262f, -0.10225617f, -0.06209777f, 0.02915608f, 
    -0.06784591f, 0.06027141f, 0.09173646f, -0.07569824f, 0.08399517f, -0.29909787f, -0.16212320f, -0.13911287f, 
    0.02958459f, 0.00865467f, -0.03888847f, 0.00445694f, 0.00734236f, 0.04923734f, -0.02461824f, -0.02790673f, 
    -0.14994250f, 0.16991176f, -0.07216672f, 0.07034366f, 0.03166918f, -0.16674320f, -0.09453525f, -0.20159800f, 
    0.00811814f, -0.00778927f, 0.09202094f, -0.01530158f, -0.04420449f, -0.04779780f, 0.03524810f, -0.02394628f, 
    0.01243829f, -0.10604929f, -0.01538089f, 0.15477374f, -0.10024452f, -0.08112487f, 0.01774175f, -0.14694561f, 
    -0.07389320f, 0.09377085f, -0.12901025f, 0.11796518f, 0.15430477f, -0.01592342f, 0.07796118f, -0.01542584f, 
    -0.06786633f, 0.04533333f, -0.00891116f, 0.01412289f, 0.16354808f, -0.02732521f, 0.04307017f, -0.05756149f, 
    -0.02501705f, 0.05260563f, -0.10868013f, -0.14866610f, 0.05091108f, 0.05058876f, 0.07285026f, -0.01248184f, 
    0.08042427f, -0.16071658f, -0.03703268f, 0.04252452f, -0.10267979f, 0.09369072f, -0.02973076f, -0.00544866f, 
    0.03595351f, -0.05112297f, -0.15325378f, 0.12134305f, 0.19674222f, -0.02268184f, -0.05052466f, 0.16737568f, 
    -0.17956607f, -0.08569252f, -0.02940163f, 0.04066529f, 0.01989175f, -0.07174854f, -0.04952945f, -0.11391765f, 
    -0.32670575f, 0.15730278f, 0.22680290f, -0.31290829f, -0.03200659f, 0.00124084f, -0.02906337f, 0.00240725f, 
    0.04575044f, -0.00174470f, -0.01612110f, -0.04748872f, 0.06943398f, 0.10206214f, 0.01932493f, 0.12434871f, 
    -0.00977989f, -0.00896624f, 0.07502850f, -0.02024835f, -0.13163231f, -0.07452821f, -0.02822570f, -0.10055986f, 
    -0.12790161f, 0.05587487f, -0.12563607f, -0.09732154f, -0.12055743f, 0.05247816f, 0.05266009f, 0.04879939f, 
    -0.12177016f, 0.07563679f, -0.03171833f, -0.14090879f, 0.29801649f, 0.10590915f, -0.04169473f, 0.17761812f, 
    0.07278894f, 0.02410687f, 0.01150143f, -0.05782984f, 0.04798706f, 0.11996527f, 0.01347248f, -0.00453908f, 
    0.12087900f, -0.01657820f, 0.09598703f, 0.04034228f, 0.02931904f, -0.03736145f, -0.01089152f, -0.07189832f, 
    0.01980427f, 0.06182553f, 0.00151356f, -0.03107010f, -0.05911637f, 0.10901318f, 0.01660938f, -0.18757039f, 
    -0.02491830f, -0.08163554f, -0.01902769f, -0.01660769f, -0.00835190f, 0.03672867f, 0.07038850f, 0.05918281f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04625862f, 0.04222425f, -0.00851860f, 0.00594394f, 0.02171059f, 0.00498690f, 0.01724148f, -0.07315956f, 
    -0.02194772f, 0.04266028f, 0.09272533f, -0.00484724f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
