#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.10841276f, 0.40232861f, 0.15777394f, 0.61293995f, -0.81142694f, 0.35392365f, 0.51889426f, 0.09649805f, 
    -0.06021104f, -0.81564069f, -0.16523644f, 0.38234457f, 0.10751551f, 0.67506325f, -0.67788213f, -0.05460382f, 
    0.03486761f, -0.33444062f, -0.41104439f, -0.16704170f, -0.38831407f, -0.64788800f, -0.17360502f, 0.35195193f, 
    0.01659721f, 0.27798796f, -0.35295248f, 0.68711984f, 0.50674140f, 0.41265312f, -0.65170389f, -0.41462755f, 
    0.41822711f, -0.14967069f, 0.01613352f, -0.43908742f, 0.59036893f, 0.41528752f, 0.49107569f, -0.37642306f, 
    -0.82265741f, -0.22893004f, -0.02147296f, -0.22118568f, 0.26018503f, -0.47092146f, 0.29410261f, -0.55707687f, 
    0.09284887f, -0.44955736f, 0.00101785f, 0.45498469f, 0.25841960f, 0.26718017f, -1.08804560f, -0.16708060f, 
    0.14055973f, 0.39200160f, -0.25875512f, 0.25609031f, 0.25966218f, 0.12786759f, 0.07315803f, -0.76029634f, 
    -0.52231055f, -0.39828035f, -0.20263831f, -0.12444599f, 0.22868720f, -0.36235777f, 0.58377486f, -0.05664882f, 
    0.58078772f, 0.28914270f, 0.62236631f, 0.02973112f, 0.02546988f, -0.05027472f, 0.52175385f, 0.02309343f, 
    -0.06447119f, 0.31384373f, 0.12872910f, 0.39911988f, 0.64944071f, 0.05130642f, -0.35538918f, 0.10124788f, 
    0.35657775f, 0.44035500f, -0.51933354f, -0.44806513f, -0.24047285f, 0.11202449f, -0.43152240f, -0.08467171f, 
    -0.31105077f, -0.09239494f, -0.52019930f, 0.45687401f, 0.47454605f, -0.37954697f, -0.03715622f, -0.62912732f, 
    -0.43703139f, -0.09289654f, 0.55215716f, 0.64464909f, -0.43174672f, -0.03443436f, 0.16096923f, -0.15951766f, 
    0.69952446f, 0.23250413f, -0.56867158f, 0.10163782f, 0.58182257f, 0.05134856f, -0.63158464f, 0.31942403f, 
    0.53266585f, -0.35698402f, 0.56716073f, 0.36379710f, -0.53916699f, 0.54902422f, 0.37164542f, 0.56232327f, 
    0.11380257f, -0.21792518f, 0.68141174f, 0.29999927f, 0.36781371f, 0.46669340f, 0.17290623f, -0.63346577f, 
    -0.58015889f, -0.33985385f, 0.77267915f, 0.76343024f, 0.48794404f, 0.12102152f, -0.07637044f, 0.18401572f, 
    -0.52714235f, 0.47413930f, -0.30519354f, 0.41374704f, -0.49416676f, -0.69766140f, -0.25436521f, 0.46568492f, 
    0.36510158f, 0.28353879f, 0.75225067f, -0.06095799f, -0.79942513f, -0.65786844f, -0.23034436f, 0.22909603f, 
    0.14018680f, -0.15681142f, -0.10233028f, -0.51987696f, 0.08330152f, -0.92121643f, -0.03197185f, 0.23114601f, 
    0.11101241f, 0.08213156f, 0.25692043f, 0.82797015f, -0.44557473f, 0.57168651f, 0.52957737f, 0.23670229f, 
    0.23632911f, -0.31580511f, -0.02715116f, 0.11994396f, -0.73781478f, -0.73648590f, -0.32859901f, 0.13751246f, 
    -0.43168154f, 0.27577001f, 0.14282086f, -0.26898423f, 0.12352572f, 0.70726418f, 0.66334027f, 0.08237656f, 
    0.23074369f, 0.32226187f, 0.07208685f, -0.23133029f, 0.04408718f, -0.22199929f, -0.47567213f, 0.82179928f, 
    -0.61670178f, 0.28347608f, 0.58572131f, 0.19758731f, 0.39181864f, -0.39423195f, -0.21214956f, 0.09312589f, 
    0.08410946f, 0.07130288f, -0.02282465f, 0.52069819f, 0.73653591f, -0.16665946f, -0.24469222f, -0.61742932f, 
    0.21995562f, -0.38299629f, 0.60799640f, -0.55114901f, -0.37443236f, -0.46840543f, -0.58140600f, -0.31428900f, 
    -0.41727632f, 0.62659132f, 0.26434308f, 0.73800433f, 0.13813236f, -0.11809536f, 0.15123637f, -0.01004903f, 
    -0.25628445f, 0.10276283f, 0.52388746f, 0.56484985f, 0.57671738f, -0.26346841f, 0.23462905f, -0.32724985f, 
    -0.07752675f, 0.18328609f, 0.33468306f, 0.02270850f, 0.27097940f, 0.60149258f, 0.50734520f, 0.48689699f, 
    0.24121040f, -0.19490790f, 0.13566494f, 0.15904163f, 0.46204287f, -0.87241727f, -0.28043559f, -0.46707356f, 
    -0.35150164f, 0.03872374f, -0.22086282f, 0.27762863f, -0.14631200f, 0.08074898f, -0.37370858f, 0.07022920f, 
    0.26985157f, -0.11177578f, -0.67605942f, -0.00805140f, -0.48547664f, -0.59224308f, 0.21405639f, -0.83624870f, 
    0.75599742f, -0.02833604f, -0.03113746f, 0.36317977f, 0.46591365f, -0.11223508f, -0.18139587f, -0.36858612f, 
    -0.76817256f, -0.63651836f, 0.21476847f, 0.67477077f, 0.44424349f, -0.16434734f, -0.04824262f, -0.32892045f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.15338701f, -0.13220046f, -0.19106509f, -0.19455038f, 0.08705502f, 0.17504635f, 0.11576120f, -0.18100373f, 
    0.14728035f, -0.04470619f, -0.23201579f, -0.03420133f, -0.02145469f, -0.28661779f, 0.02471177f, 0.03585556f, 
    -0.36312854f, -0.04520728f, 0.32053664f, 0.16659527f, 0.16539790f, 0.20487118f, -0.24963538f, -0.02704395f, 
    0.06209720f, 0.18965612f, 0.24475500f, 0.07917599f, 0.04247240f, -0.05456089f, -0.47742194f, 0.10055871f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.27808091f, -0.21054250f, -0.05923989f, 0.12242553f, -0.03124291f, 0.16254206f, -0.09762585f, -0.01140286f, 
    -0.16535352f, -0.36754948f, -0.22953519f, -0.30677730f, 0.06309796f, -0.00561181f, -0.18582827f, 0.03518777f, 
    -0.14591555f, 0.02531302f, -0.15817517f, -0.14067379f, -0.17640498f, 0.12196867f, 0.00504106f, -0.04946550f, 
    0.13423173f, -0.15183635f, 0.02464571f, -0.25272185f, 0.27622196f, 0.11116785f, -0.03624317f, 0.11723848f, 
    -0.04929441f, -0.00259875f, 0.12316269f, -0.12774937f, -0.07770834f, 0.19328849f, 0.12267770f, 0.09454753f, 
    0.04136588f, -0.01338228f, 0.00094344f, 0.03705427f, 0.05665660f, -0.17813759f, 0.03178779f, 0.07493931f, 
    0.05916173f, 0.03681949f, 0.00093517f, -0.04762588f, -0.08527914f, -0.00103076f, -0.45549515f, -0.33510581f, 
    -0.12336921f, 0.08069205f, -0.02766219f, 0.17106399f, 0.08467565f, -0.00165147f, 0.03749873f, 0.06050093f, 
    0.02671454f, 0.12803556f, 0.16741922f, 0.14185840f, -0.02691250f, 0.01642345f, -0.01342744f, -0.06607194f, 
    0.03200924f, 0.16150029f, 0.23349383f, 0.14993469f, 0.01160047f, 0.02094762f, 0.02434980f, 0.00419289f, 
    -0.03758026f, 0.21597601f, -0.10120158f, 0.06124933f, -0.04983592f, 0.05072746f, 0.04094362f, 0.00662742f, 
    -0.12625164f, 0.04955706f, 0.03932314f, 0.05585413f, 0.05702283f, 0.02864085f, 0.07273913f, 0.05321812f, 
    0.00016265f, 0.10244232f, 0.01756055f, 0.18618469f, -0.02874299f, 0.01925530f, -0.09803824f, 0.04259450f, 
    -0.02323367f, 0.01162608f, -0.02703522f, 0.04456494f, -0.23091954f, -0.11237761f, 0.02111036f, -0.09176908f, 
    0.01527227f, 0.13807254f, 0.01173328f, 0.01784774f, 0.11794538f, -0.05228682f, -0.39851823f, -0.13016625f, 
    -0.08122157f, -0.06841349f, 0.10937855f, -0.12584382f, -0.21176895f, 0.16613565f, -0.07681478f, 0.23770130f, 
    0.05736516f, 0.06470772f, 0.00387819f, -0.01606994f, 0.13578682f, -0.02265914f, 0.03948211f, -0.22958912f, 
    -0.40152845f, 0.01944680f, 0.05288024f, 0.08339393f, 0.05817224f, -0.03845689f, -0.01998694f, -0.06935880f, 
    -0.24361631f, -0.12162092f, 0.05912285f, -0.05190336f, 0.16552159f, 0.01527898f, 0.05226316f, 0.02059675f, 
    0.01510384f, -0.16957736f, 0.08236977f, 0.05380571f, -0.20920560f, -0.07901952f, -0.08625413f, -0.13278927f, 
    0.10761585f, -0.06814584f, -0.11048043f, -0.07663229f, -0.24769628f, 0.14041582f, -0.05611688f, 0.17359543f, 
    0.09756431f, -0.03074509f, 0.02873801f, 0.15201008f, 0.11610106f, 0.03067386f, 0.14488354f, 0.01506947f, 
    0.04627487f, -0.02303670f, -0.03995901f, 0.10192630f, -0.44325042f, -0.36278859f, -0.12313513f, 0.17167005f, 
    0.14312567f, 0.02614677f, -0.04400131f, 0.14313266f, 0.04073209f, 0.10007793f, 0.08616020f, 0.30158639f, 
    0.12491765f, 0.01405196f, 0.01387324f, 0.08769943f, 0.01727141f, -0.04833395f, -0.46403259f, 0.00104925f, 
    0.23656844f, 0.01518336f, -0.09419718f, 0.02225530f, 0.00795568f, 0.04805448f, 0.03705124f, 0.15876357f, 
    0.05259317f, 0.07748654f, 0.01845982f, 0.12144733f, -0.05036520f, 0.02937247f, 0.00826789f, 0.08375525f, 
    0.06825716f, 0.11354214f, -0.06370570f, -0.00124081f, 0.01774417f, -0.05435691f, -0.02977205f, 0.09656900f, 
    0.09933732f, 0.13840304f, 0.25792283f, 0.12983763f, 0.08239423f, 0.11265235f, 0.11816863f, 0.00523434f, 
    -0.08686438f, 0.03610583f, 0.10884616f, 0.10705650f, 0.15893556f, 0.04259384f, 0.08381298f, 0.08949482f, 
    0.04324504f, 0.00476589f, 0.00783063f, 0.07048461f, -0.12080424f, -0.07277745f, 0.13415655f, -0.05011170f, 
    0.09649081f, 0.15161870f, -0.00287028f, -0.00866556f, 0.04512675f, -0.02383731f, -0.13843311f, 0.00220453f, 
    -0.09755855f, -0.20122743f, 0.00322924f, -0.01606399f, 0.04568370f, 0.09037678f, -0.00429117f, -0.23356378f, 
    0.13468614f, 0.09317294f, 0.10892912f, 0.03813353f, 0.08239642f, 0.16375385f, 0.12651907f, -0.20128012f, 
    -0.01882960f, -0.00966722f, -0.11014545f, -0.14292239f, -0.03694827f, -0.16133280f, 0.05801452f, -0.03463733f, 
    -0.18374804f, 0.09737839f, 0.05883735f, -0.00967754f, -0.00618893f, -0.04553426f, 0.00551953f, -0.03086771f, 
    -0.10936565f, 0.14327763f, 0.19256142f, -0.00646939f, 0.15439598f, 0.08131604f, 0.04743304f, 0.10387130f, 
    -0.00671334f, -0.21193309f, -0.44934210f, 0.23855537f, 0.15895793f, 0.12525733f, -0.13615978f, 0.03819226f, 
    -0.15274847f, -0.04168131f, -0.24132286f, 0.23923442f, -0.06212415f, 0.02268391f, 0.03163976f, 0.07515226f, 
    -0.03825860f, 0.04272837f, -0.08857056f, 0.21628165f, 0.08018033f, 0.20407942f, -0.07959582f, 0.07060926f, 
    -0.04351840f, -0.04153267f, 0.12659322f, 0.04830321f, 0.06548756f, 0.16252424f, -0.00629983f, -0.12091119f, 
    -0.07635751f, 0.10448021f, -0.01469206f, 0.05707845f, 0.13086352f, -0.01501552f, -0.04769948f, 0.09935071f, 
    -0.01827070f, 0.07323541f, 0.06566599f, -0.05177442f, -0.09503659f, -0.16838992f, -0.28153282f, -0.18403921f, 
    -0.08441954f, 0.00448347f, 0.00111612f, 0.00349505f, 0.04321421f, 0.06779606f, 0.09260117f, -0.22747840f, 
    -0.12902731f, -0.09028391f, -0.02083461f, 0.08315084f, -0.15013082f, -0.05748767f, 0.16950732f, -0.03313746f, 
    0.13841401f, 0.13132487f, 0.08797240f, -0.13721073f, -0.04676941f, -0.04834476f, 0.08018007f, -0.01611610f, 
    -0.00283767f, -0.23824698f, -0.06826244f, 0.00629810f, 0.07994764f, -0.04613156f, -0.05413730f, 0.10336763f, 
    0.00375733f, 0.04170020f, -0.04218221f, 0.07538517f, -0.13172843f, -0.03962491f, -0.03217630f, -0.05833081f, 
    -0.02406280f, 0.13138038f, -0.13062957f, 0.16696854f, -0.09760661f, 0.03521934f, 0.01440878f, 0.02240251f, 
    -0.03052293f, -0.18615419f, -0.14853470f, -0.02489134f, 0.13426371f, -0.16047515f, 0.13047282f, -0.00534225f, 
    0.04418180f, 0.05234337f, 0.14053902f, -0.06757902f, 0.06463878f, 0.07130829f, -0.06976908f, -0.23346230f, 
    -0.01100865f, 0.00994392f, 0.09249499f, 0.14494997f, 0.01539977f, 0.00330338f, 0.11550945f, -0.03434383f, 
    0.00046576f, -0.13928364f, -0.05131752f, -0.11132482f, -0.03005349f, 0.00784481f, -0.11802484f, 0.03197826f, 
    -0.09979030f, -0.32175785f, -0.06383863f, 0.01674280f, -0.02533272f, 0.06769496f, -0.02286110f, -0.06663762f, 
    -0.08953077f, -0.01711339f, -0.01032816f, 0.15478398f, -0.05361192f, -0.02968708f, -0.06312429f, 0.11596300f, 
    0.13401434f, 0.20417421f, 0.01361949f, 0.03520795f, 0.00866686f, -0.14410482f, 0.08683655f, -0.06736811f, 
    -0.00844120f, 0.01537791f, -0.00692576f, 0.09217376f, -0.09224609f, 0.11242926f, 0.10647578f, 0.02071168f, 
    0.04416542f, -0.06918242f, -0.04148386f, 0.24494472f, -0.06865628f, -0.01402878f, -0.03501995f, 0.00905927f, 
    0.02183072f, 0.02702538f, -0.04411402f, 0.05905240f, -0.06861249f, 0.02054730f, -0.35313722f, 0.07360230f, 
    0.06019658f, 0.03788827f, 0.04744064f, 0.04124155f, 0.06870604f, -0.02321165f, 0.00472699f, 0.04962085f, 
    -0.01011991f, -0.00306985f, -0.07665253f, -0.03607455f, 0.06297345f, 0.04366287f, 0.02830057f, -0.17675470f, 
    0.16120306f, -0.02155280f, -0.06130038f, 0.05772251f, 0.00777487f, 0.03145589f, 0.00475607f, 0.04295409f, 
    -0.15057266f, 0.04285619f, -0.00558751f, 0.06662382f, -0.14478740f, 0.03899771f, -0.01066413f, 0.04748136f, 
    0.08147919f, -0.01757342f, -0.02800224f, -0.10736061f, 0.11426859f, 0.22264570f, -0.14739200f, 0.10866315f, 
    0.05518847f, 0.06798163f, 0.06874935f, 0.17934693f, -0.04804136f, -0.02638374f, 0.06750168f, 0.07203018f, 
    -0.00375318f, -0.00214806f, 0.21588178f, 0.11845091f, 0.09792146f, -0.08230039f, -0.03902417f, 0.02401079f, 
    -0.03130627f, 0.01540418f, 0.03447205f, -0.04060159f, -0.03952528f, 0.26589260f, 0.04586965f, -0.00933078f, 
    0.06450810f, -0.04090544f, -0.07117672f, -0.05469902f, 0.05671212f, 0.08562060f, -0.19203138f, 0.03137599f, 
    0.05628504f, -0.00861858f, -0.03027548f, -0.12338089f, -0.11235867f, -0.08372249f, -0.00597169f, -0.05223083f, 
    0.16214587f, 0.10041893f, 0.07317674f, 0.14522740f, 0.01760004f, 0.07739239f, 0.56069821f, -0.04980308f, 
    0.02815531f, -0.27003178f, 0.00642688f, -0.07932858f, 0.01409790f, -0.09542506f, 0.14176726f, 0.24793787f, 
    -0.15520082f, -0.45149568f, -0.00397971f, 0.08180601f, 0.05494229f, 0.10989974f, -0.02594975f, -0.04299803f, 
    0.00307719f, 0.06629986f, -0.03050193f, -0.05536909f, 0.01740583f, -0.00542098f, -0.04614769f, 0.01538960f, 
    -0.02387011f, 0.27553719f, 0.22291408f, 0.11452495f, 0.04638987f, 0.04559992f, 0.12421827f, -0.16065228f, 
    0.07643497f, -0.06301162f, 0.22485706f, -0.00107832f, 0.18160267f, -0.12039107f, 0.09998483f, -0.01299960f, 
    0.01654112f, 0.05633927f, 0.00443740f, -0.11740834f, 0.12494367f, -0.19462718f, -0.09701589f, 0.05758030f, 
    0.00107509f, 0.00691530f, -0.10692846f, -0.21286725f, 0.03418185f, 0.10194828f, -0.16075040f, 0.07566398f, 
    -0.04659599f, -0.02206465f, -0.03486506f, -0.01146149f, -0.05824664f, -0.05237650f, -0.04148990f, -0.01380186f, 
    -0.12123664f, 0.01395370f, -0.07036787f, -0.16839065f, 0.05939302f, -0.00958213f, 0.11888278f, 0.00521443f, 
    0.03652664f, 0.00947074f, -0.08044467f, 0.02696768f, -0.04588725f, 0.01402459f, -0.06641907f, 0.20224552f, 
    -0.10004868f, 0.13271603f, 0.14133796f, 0.01705475f, 0.08625130f, -0.13096531f, 0.00179415f, 0.08193434f, 
    0.00840958f, 0.03603105f, -0.03705974f, -0.03326567f, -0.15769985f, 0.08417316f, -0.06935996f, -0.12758365f, 
    0.01311625f, -0.00862817f, -0.09058087f, 0.00958847f, 0.00613697f, -0.01848488f, 0.08251867f, -0.04745940f, 
    0.00548755f, -0.20128176f, 0.01645937f, 0.10864568f, 0.30417955f, 0.10577725f, 0.01262398f, 0.07064731f, 
    -0.15515526f, 0.06977227f, 0.05504862f, 0.02231759f, 0.18441267f, 0.00423214f, -0.00971528f, -0.02720168f, 
    -0.07875350f, -0.19546518f, 0.04080295f, 0.06926991f, 0.10791078f, -0.17651053f, 0.07661059f, 0.00794326f, 
    0.07520482f, 0.00557555f, -0.02262968f, -0.11046412f, 0.04409742f, 0.03278085f, 0.09348518f, -0.11457840f, 
    0.01443630f, -0.07061020f, 0.00144397f, -0.02344756f, -0.04588476f, -0.02805559f, -0.05602267f, 0.20356712f, 
    0.09502855f, -0.02440512f, -0.11123131f, 0.00011820f, -0.04370782f, 0.02983456f, -0.00782893f, -0.02387500f, 
    0.01541436f, 0.15071398f, 0.09054584f, -0.04342135f, 0.17414990f, 0.07152887f, -0.01585906f, 0.11018847f, 
    0.01868070f, 0.15189600f, 0.11890264f, 0.00609375f, -0.14790376f, -0.09426410f, -0.07329769f, 0.01569047f, 
    0.06500715f, -0.07991792f, 0.10412037f, -0.22687294f, -0.06149386f, 0.04610197f, -0.06970273f, -0.00477346f, 
    0.01871154f, -0.08732758f, 0.13005182f, -0.21799979f, -0.01355350f, -0.05412461f, 0.00681423f, -0.03431739f, 
    -0.01520350f, -0.08253916f, -0.05494413f, 0.03397459f, -0.07207105f, -0.17832129f, -0.20403059f, 0.05391913f, 
    0.06330278f, 0.07780443f, 0.04052691f, -0.14789604f, 0.01665249f, 0.01674934f, 0.12282030f, 0.14268260f, 
    0.00360198f, -0.08362358f, 0.07707743f, -0.04690115f, -0.10192262f, -0.01920173f, 0.17429207f, -0.13078670f, 
    0.03940139f, -0.02677643f, 0.01979597f, 0.13828006f, -0.13012849f, -0.22941673f, -0.20689307f, 0.14541416f, 
    0.08948718f, 0.01133936f, 0.07273518f, 0.11206850f, -0.02871094f, -0.06747868f, -0.05303440f, 0.15366183f, 
    0.14174010f, -0.15488276f, -0.09662475f, 0.10605360f, 0.21864632f, -0.00191374f, 0.08480235f, -0.24020398f, 
    0.37569976f, -0.12172939f, -0.01850504f, -0.20527241f, 0.08745602f, 0.04473302f, 0.04888050f, 0.05633559f, 
    -0.01809723f, 0.15770054f, 0.13314947f, -0.18301439f, -0.08365393f, -0.04829081f, 0.10175151f, 0.00128806f, 
    0.00057216f, 0.05074205f, 0.05538084f, 0.06266481f, -0.01713972f, 0.05885949f, -0.02386731f, -0.04911001f, 
    -0.06605391f, -0.01521347f, -0.02499198f, 0.14485905f, -0.02124346f, -0.10979376f, -0.05869870f, 0.09522815f, 
    0.12964050f, 0.07422912f, -0.09881773f, -0.17588449f, 0.19454770f, 0.01280922f, 0.17712161f, -0.17156754f, 
    0.10163336f, -0.07979757f, -0.02254605f, -0.06973930f, 0.00090170f, -0.04425173f, 0.08408866f, 0.01910436f, 
    0.00597461f, 0.07316402f, 0.01850039f, 0.16582122f, 0.01255216f, -0.01981523f, 0.10321190f, 0.00362844f, 
    -0.05339668f, -0.02371519f, 0.09450024f, 0.12781984f, 0.00623484f, -0.18333139f, -0.01145385f, -0.00486345f, 
    0.10741378f, 0.25107569f, -0.02469285f, 0.06211276f, 0.12438257f, 0.02854604f, 0.03034215f, -0.01260726f, 
    -0.26542056f, -0.00780449f, 0.00020304f, -0.02874920f, -0.00479338f, 0.05870108f, -0.10138126f, 0.03454468f, 
    -0.00477529f, -0.14149047f, -0.15776286f, 0.18469569f, 0.11987291f, 0.01216505f, 0.08258915f, -0.16185892f, 
    -0.10736240f, -0.24563144f, -0.25813594f, -0.01494712f, -0.26404962f, 0.08213707f, 0.05441589f, 0.15068801f, 
    -0.08599456f, -0.13044377f, -0.06012827f, -0.11257869f, -0.01126556f, 0.10749751f, 0.01030439f, -0.25290030f, 
    -0.07335387f, -0.04502339f, -0.04785338f, 0.09558599f, -0.09893803f, 0.14072627f, 0.19736969f, -0.04185839f, 
    -0.20782553f, -0.07927213f, 0.02457866f, -0.01436674f, 0.09236542f, 0.02220560f, -0.08929296f, -0.14228377f, 
    -0.02712682f, 0.06655905f, 0.01173272f, -0.00249784f, 0.05441121f, -0.01447176f, -0.12786497f, 0.03139928f, 
    -0.11763610f, 0.09552585f, 0.04796786f, -0.03897923f, -0.05268124f, 0.17241310f, -0.01418382f, -0.13865991f, 
    -0.04685673f, -0.15011857f, 0.01037836f, 0.01066974f, 0.05725612f, 0.00722259f, 0.12910643f, -0.03806321f, 
    -0.00947341f, -0.09440359f, 0.18765675f, 0.02142398f, -0.07480439f, 0.05023225f, 0.01714993f, 0.01806055f, 
    -0.06771365f, -0.25511590f, -0.10733529f, 0.13567880f, -0.07717723f, 0.07093900f, 0.06187335f, 0.05397995f, 
    -0.06957649f, 0.04743563f, -0.07949629f, 0.03919958f, -0.13454892f, 0.01061661f, 0.18863451f, 0.10259406f, 
    0.11735509f, 0.06091265f, -0.13254239f, 0.10313594f, -0.15221156f, 0.15497917f, -0.07339059f, 0.05783286f, 
    0.07891514f, -0.12470876f, -0.11202582f, 0.05020665f, -0.29794663f, 0.24704139f, -0.12124342f, 0.04670553f, 
    0.07146620f, 0.05042332f, 0.04069788f, 0.09509008f, 0.06914146f, -0.18518896f, -0.05710031f, -0.02467579f, 
    0.09545166f, 0.11452466f, 0.02957413f, 0.11224372f, -0.04043756f, -0.00376581f, -0.05575280f, 0.13289165f, 
    -0.18291195f, -0.02927748f, 0.02201973f, 0.00093532f, -0.02486076f, 0.12744650f, -0.04377516f, 0.13075319f, 
    0.33203784f, -0.26637053f, 0.05352358f, 0.12886283f, 0.14612000f, 0.10415833f, -0.00884562f, 0.00140290f, 
    0.01833271f, -0.05676360f, -0.18154913f, 0.06095368f, -0.00031327f, -0.06861026f, 0.00222561f, -0.00523609f, 
    -0.07687096f, -0.07029418f, 0.05193140f, 0.14723745f, 0.00416742f, -0.17164640f, -0.00856896f, -0.12945417f, 
    -0.11275524f, 0.06215680f, -0.23994805f, -0.13010468f, -0.06220538f, 0.12132002f, -0.02239330f, -0.06366288f, 
    -0.02022518f, 0.06231035f, 0.00229980f, 0.03506925f, 0.03909801f, -0.03180136f, -0.02285236f, 0.19424564f, 
    0.06446557f, 0.13686615f, -0.06903151f, 0.04814412f, -0.00714247f, 0.36175251f, -0.17351519f, 0.02181717f, 
    0.05711903f, 0.11080265f, 0.14449002f, 0.03041913f, 0.05732187f, 0.09452601f, 0.03717256f, 0.03460408f, 
    -0.14245664f, -0.05171315f, 0.06963917f, -0.11253296f, 0.09145877f, 0.09509001f, 0.19294673f, 0.19084059f, 
    -0.35812229f, 0.05509707f, 0.05265288f, -0.06027340f, 0.09730256f, -0.00725740f, 0.04465016f, -0.04804973f, 
    0.13053223f, -0.22975850f, 0.10081141f, -0.08816259f, 0.08944990f, 0.21470055f, -0.12010060f, 0.10750642f, 
    -0.12745316f, -0.00590419f, 0.08763279f, 0.10714799f, 0.12473365f, -0.02543400f, 0.04376300f, 0.00855425f, 
    0.08759159f, -0.02154111f, -0.02900407f, 0.12540084f, -0.02618712f, -0.09334351f, -0.08055039f, 0.02910529f, 
    -0.05000163f, 0.03877702f, 0.10975105f, 0.15784524f, 0.07549404f, 0.02285220f, 0.02294890f, 0.15156816f, 
    -0.03444877f, -0.05065784f, 0.09456958f, 0.01637783f, 0.17157522f, 0.18642852f, -0.13359648f, 0.03813652f, 
    -0.12003522f, 0.05324763f, 0.08549292f, -0.01417252f, -0.14472330f, -0.23959666f, 0.13164696f, -0.10961463f, 
    0.07400186f, 0.00892149f, -0.10680868f, 0.09027876f, -0.19624576f, -0.06654523f, -0.19351305f, 0.11717524f, 
    -0.16654548f, 0.26756674f, 0.06590464f, 0.10999481f, -0.00930198f, 0.11254153f, -0.37614813f, -0.10405862f, 
    -0.13097861f, -0.03608083f, 0.05775905f, -0.13415477f, 0.00390001f, -0.10802767f, -0.00090466f, 0.15702572f, 
    0.06010308f, -0.43397090f, 0.13033587f, 0.08984131f, 0.11664142f, 0.07851522f, -0.03500053f, -0.03689544f, 
    0.32706836f, -0.05367254f, 0.00471446f, 0.13249503f, 0.01220343f, -0.07432405f, -0.02739862f, -0.02182932f, 
    0.09116472f, -0.46792644f, 0.01908108f, -0.24483223f, 0.01333147f, 0.05386812f, -0.03235806f, -0.07085812f, 
    -0.09687374f, 0.03496052f, -0.37027311f, 0.26409912f, -0.09330147f, 0.02433681f, 0.02023297f, -0.16790241f, 
    0.06128598f, 0.04865115f, 0.08495424f, 0.20347297f, -0.04129782f, 0.08002200f, 0.05437283f, 0.02415304f, 
    -0.06168798f, 0.07598668f, -0.04380397f, 0.00265580f, 0.24624784f, 0.15347107f, -0.06545046f, -0.02194653f, 
    -0.00005897f, 0.01002401f, -0.03617306f, -0.03803263f, 0.02277308f, -0.01575013f, 0.10875170f, -0.22198515f, 
    -0.03794792f, 0.04282039f, 0.00318199f, 0.02129941f, 0.06116438f, -0.05228838f, -0.18143551f, 0.14626803f, 
    -0.00654512f, -0.08294199f, -0.00019380f, -0.01415975f, 0.07540312f, 0.01414009f, 0.00853692f, -0.04704260f, 
    0.24306932f, -0.22800215f, 0.04339983f, -0.01019830f, -0.07575781f, 0.01711646f, -0.07646117f, -0.02845995f, 
    0.28462785f, -0.05380443f, 0.05999953f, 0.08679175f, -0.07275451f, 0.01846134f, 0.09412476f, 0.03834935f, 
    -0.01963798f, 0.09253701f, -0.04748793f, 0.02768449f, 0.01580207f, 0.09485429f, -0.06079289f, -0.07704741f, 
    0.03972220f, -0.03176951f, 0.00434825f, 0.25934985f, -0.18528929f, -0.17936820f, 0.09299235f, -0.00831177f, 
    -0.11499725f, 0.07581199f, -0.01958404f, 0.21340322f, -0.00533735f, -0.15455119f, 0.22478685f, 0.14224151f, 
    0.01230058f, -0.05971007f, 0.03071874f, -0.17829272f, 0.00411944f, -0.00414189f, 0.01136340f, 0.00228157f, 
    0.03217224f, -0.01752551f, -0.04695607f, 0.03016653f, -0.02752635f, 0.01439920f, -0.00951534f, 0.13994867f, 
    0.01146957f, -0.03751429f, -0.05619487f, 0.06931548f, -0.03764113f, -0.05101160f, 0.38417745f, -0.03344351f, 
    0.10554777f, 0.03385215f, 0.05397371f, 0.01171999f, -0.05804817f, 0.01913557f, 0.08413818f, -0.29438123f, 
    -0.11866616f, 0.10118081f, -0.07264141f, 0.01553932f, 0.11295291f, -0.11635537f, -0.02453027f, -0.02033154f, 
    -0.14179343f, -0.03632867f, -0.08641502f, 0.06328765f, 0.00025015f, 0.12924808f, 0.07178091f, 0.03578915f, 
    -0.07357479f, 0.11325656f, -0.06143589f, -0.31157607f, 0.11688063f, -0.00082095f, 0.09196613f, 0.00833665f, 
    -0.08181720f, -0.03311089f, -0.32352009f, 0.21058184f, -0.11503471f, 0.03460555f, -0.02151769f, 0.06596968f, 
    0.05863722f, 0.11876371f, 0.01400981f, -0.12751085f, -0.07964755f, 0.06914394f, 0.07974324f, -0.01310322f, 
    -0.01335014f, 0.01258114f, -0.01443551f, -0.09486330f, -0.09660152f, 0.23762830f, -0.10359352f, -0.09528532f, 
    0.03780640f, 0.02244431f, -0.09954532f, -0.00477102f, -0.06784882f, 0.11917810f, -0.07393647f, 0.01559951f, 
    0.01610802f, 0.03603258f, -0.07813882f, -0.01329441f, -0.08875769f, 0.03511227f, -0.12421376f, -0.17542124f, 
    0.05553289f, -0.00652016f, 0.01403885f, -0.19876312f, 0.00436756f, 0.17293622f, 0.05090328f, -0.12090340f, 
    -0.04297911f, 0.02585072f, 0.10561577f, -0.01989791f, 0.04628277f, 0.01205508f, 0.17269568f, -0.10679229f, 
    -0.12455074f, 0.03540623f, -0.06745784f, 0.06700692f, 0.04634255f, -0.06786196f, -0.15441906f, -0.08961469f, 
    -0.09146154f, 0.28499720f, 0.04906750f, 0.08235317f, -0.06441466f, -0.05489767f, -0.06425910f, 0.07630460f, 
    0.02805801f, -0.03118551f, 0.25912231f, 0.00056809f, 0.01040308f, 0.06206230f, 0.01899882f, -0.02392903f, 
    0.00455946f, 0.05271122f, 0.04443633f, 0.17804796f, -0.02896741f, 0.06651628f, -0.14487198f, 0.04242520f, 
    -0.05530785f, 0.03520565f, -0.02078177f, 0.00030920f, 0.23673388f, 0.19796048f, -0.34702596f, 0.10712780f, 
    -0.11155234f, 0.10409285f, -0.04728108f, -0.06307168f, -0.01449309f, 0.06034501f, 0.13512103f, -0.21543096f, 
    -0.07426688f, 0.17615448f, 0.08666678f, -0.01740291f, 0.01783379f, -0.07591813f, 0.13294268f, -0.05099288f, 
    0.16978212f, 0.11429173f, 0.02433760f, 0.02391599f, -0.00856891f, 0.06002514f, -0.02575108f, -0.16843152f, 
    -0.11912074f, 0.08258580f, 0.05144292f, 0.03956494f, -0.00530881f, -0.05629643f, -0.02087842f, -0.00032226f, 
    -0.07327817f, -0.02788970f, 0.00796088f, -0.01683199f, 0.01467313f, 0.01759358f, -0.00151220f, -0.02340574f, 
    -0.00028507f, 0.02330015f, 0.03814773f, -0.05449106f, -0.06203241f, 0.00559854f, 0.00366574f, -0.06679717f, 
    0.03704815f, 0.01911565f, -0.06470148f, 0.01415286f, 0.03264038f, -0.00324398f, -0.02460032f, 0.04235988f, 
    0.01179252f, 0.02057527f, -0.03226821f, -0.03443572f, -0.05459862f, 0.00723744f, 0.03211572f, -0.03964231f, 
    0.00817907f, 0.02332160f, -0.06231739f, 0.02514848f, 0.03139778f, 0.02533220f, 0.04602224f, 0.00377254f, 
    -0.03396866f, -0.01843510f, -0.05402220f, 0.03969772f, 0.01328688f, -0.05233270f, -0.01995953f, -0.02931272f, 
    0.02467873f, -0.02930742f, 0.01320536f, -0.02717183f, -0.00955328f, -0.02820434f, 0.04351509f, -0.00539794f, 
    -0.04582961f, -0.06462968f, 0.02907719f, -0.03248352f, -0.05600801f, -0.01061802f, 0.01473251f, -0.02771263f, 
    -0.04990378f, -0.02319058f, -0.06567785f, -0.07226562f, -0.02000085f, -0.05794952f, -0.03743536f, -0.05122651f, 
    0.00943231f, -0.05792548f, -0.06549522f, -0.01276758f, 0.01894760f, -0.04813592f, -0.05971481f, -0.01628969f, 
    -0.05742943f, -0.03516168f, -0.03945748f, -0.06471451f, 0.02649137f, 0.02966927f, -0.01598945f, -0.05198523f, 
    0.00765089f, -0.03321008f, -0.00517717f, -0.01762826f, 0.01190854f, 0.00416570f, 0.03615158f, 0.01807875f, 
    0.01632178f, 0.02289208f, -0.00081801f, -0.03189122f, -0.00278780f, 0.02207815f, -0.03155913f, 0.00519463f, 
    0.00675564f, -0.04906905f, -0.06296319f, 0.04550263f, -0.03084155f, -0.06401697f, -0.04219951f, -0.06227815f, 
    -0.04155452f, 0.04633313f, 0.02018287f, -0.05669306f, 0.02656101f, 0.02277432f, 0.00804574f, -0.04458002f, 
    -0.01731445f, 0.01941280f, -0.01409134f, -0.03836058f, 0.03139324f, 0.03441265f, -0.05325328f, -0.02630807f, 
    -0.01182560f, 0.00111435f, -0.00486986f, -0.00486422f, -0.02377967f, 0.04032883f, -0.00567773f, -0.05431628f, 
    0.00446647f, 0.04212499f, -0.00261038f, -0.02749845f, -0.06183493f, -0.04494256f, -0.01714867f, -0.05072412f, 
    -0.02549505f, -0.05345443f, 0.03792033f, -0.00721237f, -0.06007609f, -0.00585985f, -0.04906911f, 0.03319939f, 
    0.00730262f, 0.00922719f, -0.01383011f, -0.00726778f, -0.00909678f, -0.01388778f, -0.03197474f, 0.05652450f, 
    -0.01961088f, -0.03785926f, 0.00596488f, -0.04521591f, 0.00769911f, 0.02487885f, 0.00139834f, -0.06103610f, 
    -0.00347113f, -0.03123390f, 0.02744269f, -0.06211396f, -0.00828477f, 0.04893071f, -0.05035776f, 0.00085493f, 
    -0.01769618f, 0.05467128f, -0.01526454f, 0.01837076f, -0.05398839f, 0.02805435f, -0.00021822f, -0.00857517f, 
    -0.03919654f, 0.03006705f, -0.02518525f, 0.03046097f, 0.00631326f, 0.04142795f, 0.02616353f, -0.01058228f, 
    0.00698445f, 0.04462348f, -0.01142747f, -0.06380842f, 0.03232984f, 0.03567080f, -0.04906384f, 0.03861354f, 
    -0.03953417f, -0.04973131f, -0.04778508f, 0.02454384f, 0.00402146f, 0.01476721f, 0.02546984f, -0.04232424f, 
    0.03554630f, -0.04303203f, 0.01567975f, -0.04678082f, -0.02271762f, -0.01424913f, -0.06721339f, -0.05237128f, 
    0.00328236f, 0.02285985f, -0.02044782f, 0.02715533f, 0.04716471f, -0.06922187f, -0.02253735f, -0.03572353f, 
    0.02880041f, -0.01220454f, -0.06481434f, 0.04018650f, -0.04728795f, -0.03797640f, -0.05556566f, -0.05301900f, 
    -0.02360672f, -0.07224042f, -0.05701158f, -0.02194651f, -0.04318533f, -0.01761230f, -0.01446933f, 0.00015872f, 
    -0.05809219f, -0.04810193f, 0.02033289f, 0.02209268f, -0.02806921f, 0.01821796f, 0.04297910f, 0.01642946f, 
    -0.01850240f, -0.04843521f, -0.03448890f, 0.01335682f, -0.01089584f, -0.03318055f, -0.00791345f, -0.05120194f, 
    0.01546349f, 0.00277315f, 0.02367348f, -0.01415312f, 0.00425953f, -0.01058042f, 0.01761191f, -0.06062206f, 
    -0.03492629f, -0.05463123f, -0.03835662f, -0.06060041f, 0.00654445f, 0.00525145f, 0.02519863f, -0.05614308f, 
    -0.03328329f, -0.03556488f, 0.00064143f, 0.03081008f, -0.02439603f, -0.03333304f, -0.02355381f, -0.00743213f, 
    -0.01490764f, 0.00536703f, -0.06129105f, -0.04891972f, 0.03080145f, 0.01129273f, -0.01970660f, 0.01821356f, 
    0.17213640f, 0.15647542f, -0.14550173f, -0.19683830f, -0.02366580f, 0.20498691f, -0.05077154f, 0.04713280f, 
    -0.13761048f, -0.06203277f, -0.16079697f, -0.02405242f, -0.13089533f, -0.08577695f, 0.12716082f, 0.05300000f, 
    0.03168505f, 0.06306264f, -0.19387744f, -0.05502791f, 0.03180294f, -0.09505795f, 0.24185012f, -0.01297248f, 
    0.02562509f, 0.02708150f, -0.15045005f, 0.08636804f, 0.10922716f, -0.23947132f, 0.08423255f, 0.12983434f, 
    -0.06038612f, 0.01601739f, 0.14910854f, 0.04539700f, 0.20580453f, 0.21921067f, -0.17180581f, 0.20909286f, 
    -0.11681096f, -0.01872348f, 0.09884314f, 0.15096824f, -0.05602833f, 0.07065133f, -0.00217511f, 0.07095024f, 
    -0.16008845f, 0.15478152f, 0.07870163f, -0.04206861f, 0.06497813f, -0.03041634f, 0.07165594f, 0.01227308f, 
    0.09654464f, -0.11085385f, 0.08003974f, -0.01284235f, 0.04131440f, 0.00964093f, 0.03647950f, -0.21380907f, 
    0.03549494f, 0.14455681f, -0.39850619f, 0.01289378f, -0.04260219f, -0.01352493f, -0.03443947f, 0.06650673f, 
    0.13423535f, -0.01556643f, -0.00359472f, -0.05721153f, 0.07533590f, 0.00034542f, -0.07474858f, 0.03736052f, 
    0.01131498f, 0.15764207f, -0.13884878f, 0.03388906f, 0.07501029f, -0.03141697f, 0.14202136f, -0.07394697f, 
    -0.04280291f, -0.03168679f, -0.31281573f, -0.13338338f, 0.12193367f, -0.18313527f, 0.02699002f, -0.04297838f, 
    -0.10571756f, 0.04905583f, 0.09449006f, 0.08429506f, -0.06476337f, -0.00648464f, 0.05491116f, -0.04947016f, 
    -0.11866204f, 0.15331434f, 0.07419687f, -0.08319522f, -0.00204434f, 0.16624136f, 0.11400835f, -0.14199769f, 
    -0.13698180f, 0.05169537f, 0.14189808f, -0.05041100f, -0.00704620f, 0.16359045f, 0.07623912f, 0.13671090f, 
    -0.10172593f, -0.01516605f, -0.04067588f, 0.02937086f, 0.03173106f, -0.13676630f, -0.03147231f, -0.03332458f, 
    -0.00515887f, 0.14427434f, -0.04292528f, 0.02011664f, -0.08980138f, -0.03603361f, -0.01961448f, 0.04864538f, 
    -0.01309962f, 0.16950877f, -0.18208006f, -0.10938755f, 0.14559649f, -0.09340277f, -0.00084286f, 0.04520517f, 
    -0.04747928f, 0.02404683f, 0.15018126f, -0.05768128f, -0.10891221f, 0.16230355f, 0.02871833f, -0.17833434f, 
    -0.12450583f, 0.19002141f, 0.20569456f, 0.08760651f, 0.20627825f, 0.04173879f, -0.07591782f, 0.18843712f, 
    0.22473693f, 0.08217435f, 0.13101988f, 0.00369800f, -0.20432523f, -0.05600799f, 0.10051950f, -0.03430349f, 
    0.14475219f, 0.03012523f, -0.02721174f, 0.10507414f, -0.08564262f, 0.01169635f, 0.01963297f, 0.11905544f, 
    0.05441248f, -0.04768182f, -0.17329231f, -0.00148545f, -0.12066208f, -0.17764613f, 0.03501563f, -0.04293462f, 
    0.15334080f, -0.08498483f, -0.04602209f, 0.01431934f, -0.05325178f, 0.19174401f, -0.04498680f, -0.05783813f, 
    0.04670516f, 0.01133271f, 0.14170019f, 0.20443976f, 0.01895597f, -0.02043155f, 0.11106215f, 0.17077611f, 
    0.01944505f, -0.01504390f, -0.10994338f, 0.27700087f, -0.11524878f, 0.04584356f, 0.11971127f, -0.16630737f, 
    0.17291483f, -0.17633650f, -0.15731533f, 0.05344292f, 0.18445826f, 0.04243882f, -0.04693028f, -0.03173531f, 
    0.13051714f, -0.05505573f, -0.24811891f, 0.13214345f, -0.00994582f, 0.09757949f, -0.02876373f, 0.14804982f, 
    0.16919425f, 0.16130747f, 0.01266712f, -0.05723352f, 0.01991405f, 0.02846215f, 0.04765582f, 0.04211643f, 
    0.01955960f, -0.04924529f, 0.05965440f, 0.20279664f, -0.15482023f, 0.14276034f, -0.01683200f, 0.06098714f, 
    0.10820322f, -0.05952420f, -0.01086515f, -0.06025855f, -0.13546713f, -0.16916090f, 0.08516895f, 0.00153687f, 
    0.04747261f, 0.12577938f, -0.08941022f, 0.18424079f, -0.01042782f, -0.10956622f, -0.08841322f, -0.11876591f, 
    0.02248549f, 0.00812034f, 0.08430623f, -0.02005336f, 0.04742316f, 0.11011861f, -0.19662559f, 0.06546211f, 
    0.06220066f, 0.05235239f, 0.03426947f, 0.10119697f, 0.07056370f, -0.04354874f, 0.13640049f, -0.05965258f, 
    -0.34456819f, 0.04510860f, 0.02325951f, 0.03713309f, -0.23783733f, -0.06293480f, -0.22396743f, -0.12855428f, 
    0.14926066f, 0.13517098f, -0.16446951f, -0.03553785f, 0.13202207f, -0.02703764f, 0.06327305f, 0.01899341f, 
    -0.06278432f, -0.17026709f, 0.08324625f, 0.06524000f, 0.01640987f, 0.00898788f, -0.13090071f, 0.09019835f, 
    -0.07263671f, -0.05605638f, -0.07254522f, 0.02230023f, 0.08575607f, -0.03761901f, -0.11358270f, -0.03829775f, 
    0.13124658f, -0.05505805f, -0.03006034f, 0.01811457f, -0.04925224f, -0.02665893f, -0.06870408f, 0.07367352f, 
    -0.05148493f, 0.09398516f, 0.04610164f, 0.34015211f, 0.06164920f, -0.01637919f, 0.01596845f, -0.07154178f, 
    -0.10942536f, 0.20431212f, -0.00616989f, 0.09985973f, 0.31826359f, 0.11813188f, -0.04672526f, -0.12345967f, 
    -0.03109001f, -0.03466011f, 0.13619527f, 0.03516276f, 0.03509997f, 0.04919366f, 0.15202573f, 0.02819230f, 
    0.08673325f, 0.11352226f, -0.05167084f, -0.03890134f, -0.03453156f, -0.12373759f, 0.08546039f, -0.00708483f, 
    -0.01236182f, -0.00857349f, 0.16503605f, 0.09346563f, 0.08680835f, -0.07462377f, -0.09242082f, -0.04512360f, 
    0.20840810f, -0.07877156f, -0.09295473f, -0.04501627f, 0.08203831f, 0.03045063f, -0.03852723f, 0.01521560f, 
    0.16883521f, -0.08520994f, 0.01139512f, 0.08932880f, 0.01168626f, -0.08476762f, 0.12611334f, 0.22731493f, 
    0.03419727f, -0.16225287f, -0.17038584f, -0.25123963f, 0.02253022f, 0.04470685f, 0.06105003f, -0.00053319f, 
    0.08877476f, -0.25889784f, 0.09686406f, 0.11078840f, -0.02961121f, -0.11902709f, -0.18068612f, 0.02341706f, 
    -0.05870814f, -0.00630551f, 0.22381142f, 0.01763126f, 0.10764746f, 0.00381466f, -0.01977952f, -0.15937923f, 
    -0.02208916f, 0.15318002f, -0.07597550f, -0.01585567f, -0.37268484f, 0.11079537f, -0.05576109f, 0.11759020f, 
    0.06362973f, 0.04021463f, -0.11008698f, 0.01828740f, -0.25075424f, -0.26280043f, -0.30292237f, -0.10994545f, 
    0.20475441f, 0.02557086f, 0.10704213f, -0.00233770f, -0.15758486f, -0.21777220f, 0.17341402f, -0.15222052f, 
    -0.04887502f, -0.04849667f, 0.11879268f, 0.07222493f, 0.00164522f, 0.02910282f, -0.08106196f, -0.29451603f, 
    -0.12521824f, -0.06422137f, 0.33023202f, 0.24673276f, 0.15771183f, -0.17552045f, -0.05747455f, -0.01586722f, 
    -0.01370464f, -0.01262939f, -0.02137357f, 0.02466693f, 0.07752445f, -0.09231161f, 0.11076515f, -0.33851054f, 
    0.03810030f, 0.28453991f, 0.22546382f, 0.00463827f, -0.07481902f, -0.00806121f, -0.12738125f, 0.06438690f, 
    0.10729779f, 0.06231672f, -0.17480348f, 0.15791559f, -0.09032256f, -0.07357542f, 0.03257399f, 0.00813344f, 
    0.16301720f, 0.12583722f, 0.04492187f, -0.35144556f, 0.00910866f, -0.10008196f, 0.20371787f, 0.08615445f, 
    0.07225407f, 0.10315961f, 0.07218007f, -0.07800684f, 0.05440923f, -0.05184215f, -0.09587407f, -0.00125205f, 
    -0.05372003f, 0.09659082f, -0.01716147f, 0.01009902f, 0.13879426f, 0.19068828f, 0.13634537f, 0.02549220f, 
    0.28237346f, 0.09019200f, 0.03793328f, 0.01871628f, -0.01516967f, 0.07978773f, -0.19257875f, -0.06755991f, 
    0.19090202f, 0.05164148f, 0.07427634f, 0.12859719f, -0.10889974f, 0.04575348f, -0.03529040f, -0.29269499f, 
    0.00371500f, -0.05069254f, 0.03343153f, 0.13457812f, 0.16452849f, -0.08293565f, -0.05763815f, -0.08667238f, 
    -0.01928904f, 0.11590269f, -0.12531020f, -0.06860013f, 0.06958774f, -0.07224213f, 0.13259821f, 0.00877634f, 
    0.17777801f, 0.19346188f, 0.03840100f, 0.06944560f, 0.07293872f, 0.01351372f, 0.01619095f, 0.10210051f, 
    0.05074006f, -0.00371969f, 0.33857682f, 0.20960657f, -0.04054710f, -0.05214813f, 0.02753634f, -0.08266913f, 
    -0.10253633f, 0.05325178f, 0.09514214f, -0.11055218f, -0.23065937f, 0.07978287f, 0.20468821f, 0.09808724f, 
    0.07104539f, -0.08693424f, 0.01594089f, -0.07052020f, -0.03187973f, -0.00469548f, -0.13178639f, 0.01282384f, 
    -0.22869276f, -0.04178785f, 0.09492724f, 0.15345660f, 0.05312744f, 0.00204516f, -0.16445786f, -0.03912380f, 
    0.09187794f, -0.02288082f, 0.07197972f, 0.07684570f, -0.05782119f, 0.01828149f, -0.11556089f, -0.25448316f, 
    -0.20276217f, -0.06594519f, -0.01105457f, 0.02239158f, 0.02908464f, -0.06665935f, -0.06131122f, -0.30210572f, 
    -0.00781455f, 0.04260753f, 0.12542497f, 0.09555615f, 0.07365894f, -0.18085255f, -0.02749545f, 0.03831032f, 
    0.01662247f, -0.01303310f, 0.03948706f, 0.03674855f, -0.05725434f, 0.01740870f, -0.05348872f, 0.02310719f, 
    -0.04155089f, -0.01995142f, -0.02450024f, 0.01256232f, 0.05028209f, -0.04311307f, -0.02045927f, 0.01293603f, 
    -0.05459651f, 0.01430216f, -0.02313087f, -0.02499051f, 0.00082328f, 0.01207943f, -0.05025627f, -0.02516592f, 
    0.01404586f, 0.05037696f, -0.01332328f, 0.02506606f, -0.03488534f, 0.03773322f, -0.03280784f, -0.02751383f, 
    -0.01578205f, -0.01684047f, 0.04146123f, -0.04602389f, -0.04025745f, -0.02648555f, -0.02850123f, -0.05522304f, 
    -0.04803509f, 0.01335333f, 0.01500778f, -0.05857879f, -0.01931409f, -0.03357017f, -0.04696173f, -0.01390072f, 
    0.04354551f, -0.04711039f, 0.00607606f, 0.02236760f, 0.00805598f, -0.02475125f, -0.03379245f, -0.02883905f, 
    -0.06415819f, 0.02528916f, -0.01283991f, 0.03103195f, 0.05112499f, 0.01972754f, -0.02851849f, -0.00772739f, 
    -0.03096551f, -0.03442307f, 0.03240574f, 0.00078334f, 0.04652319f, 0.01782769f, -0.04240824f, 0.02533376f, 
    -0.04836622f, -0.03841743f, 0.04303862f, 0.04977243f, -0.06308147f, 0.04908095f, 0.05040557f, 0.00223016f, 
    -0.06172204f, -0.02985524f, 0.05075124f, -0.01906265f, -0.05341119f, 0.00965552f, -0.04415344f, -0.02028664f, 
    0.01946921f, 0.01468161f, -0.03908932f, -0.01407052f, -0.01027744f, -0.02502888f, -0.01291318f, 0.01750211f, 
    0.00262460f, -0.06297440f, 0.03570918f, -0.04618710f, 0.01312055f, 0.04163856f, 0.01431508f, -0.02226484f, 
    -0.04467802f, -0.06270982f, -0.00481070f, -0.04577727f, -0.03257607f, 0.01347226f, 0.02391406f, -0.03957123f, 
    0.00011456f, -0.01660830f, -0.03853593f, -0.00453865f, -0.05052626f, -0.04944533f, -0.04562830f, -0.03194012f, 
    -0.00683873f, -0.01492911f, 0.01652627f, 0.05006571f, -0.01439176f, -0.03753599f, -0.03895659f, -0.01153284f, 
    -0.02780167f, -0.03019572f, 0.02620764f, 0.04819550f, 0.00351481f, -0.01947597f, -0.06586337f, -0.05307472f, 
    -0.03899186f, -0.01219786f, -0.04842271f, -0.06099335f, 0.04337145f, 0.04478761f, -0.06260810f, -0.03826928f, 
    -0.03405321f, -0.01580999f, -0.02123559f, -0.05798359f, -0.04545892f, -0.01056973f, 0.00336712f, -0.05282239f, 
    0.04828411f, 0.04155038f, -0.02399255f, -0.04268555f, 0.00751650f, 0.05140888f, -0.00168260f, -0.03702800f, 
    -0.02204926f, 0.01412717f, 0.04136935f, 0.01696715f, 0.01646035f, 0.03468332f, 0.01479926f, -0.05738115f, 
    -0.01799511f, 0.02785652f, -0.00800259f, -0.05304177f, 0.01527398f, -0.01530165f, 0.03209899f, -0.03693303f, 
    -0.02661831f, -0.01920899f, -0.06562085f, -0.03638541f, 0.01303605f, -0.03992791f, 0.02017418f, 0.02287890f, 
    -0.04031258f, 0.04324907f, -0.02046391f, -0.05450220f, -0.02741794f, 0.04748770f, -0.04490782f, 0.01483052f, 
    -0.01894463f, -0.03511885f, 0.00578241f, -0.06196286f, 0.03305953f, 0.03103775f, 0.01109494f, 0.05413635f, 
    0.03505281f, 0.04884818f, 0.03167580f, 0.04857979f, 0.03590511f, 0.03720794f, 0.00106730f, 0.03731187f, 
    0.00921686f, 0.04576392f, -0.04324964f, 0.04646042f, -0.05423088f, -0.02629140f, 0.03670013f, 0.00299911f, 
    0.04706654f, 0.03370705f, -0.04380537f, 0.02882620f, -0.00071070f, -0.00690505f, 0.02253683f, 0.05115462f, 
    -0.04726021f, -0.03459828f, 0.00166878f, 0.03810799f, -0.03916687f, 0.02980556f, -0.05140015f, 0.04515273f, 
    0.04682638f, 0.04388207f, 0.03251800f, -0.01468156f, -0.01643556f, -0.00027629f, 0.01146853f, 0.03665572f, 
    -0.04057720f, 0.00046630f, -0.04523100f, -0.03496580f, -0.00676032f, -0.00136710f, -0.01955787f, -0.01500668f, 
    0.03470719f, -0.06656449f, -0.00461862f, -0.01767109f, 0.02224212f, 0.04199264f, -0.05613172f, -0.02637332f, 
    -0.05638691f, -0.03675501f, 0.04721505f, 0.02489683f, 0.00927340f, -0.00281987f, -0.04078174f, 0.03070381f, 
    -0.03942723f, 0.00908557f, -0.02575351f, 0.00801574f, -0.00050681f, 0.04545032f, 0.01939020f, 0.02645422f, 
    -0.01601953f, 0.02620952f, 0.03537309f, -0.03298342f, -0.04200770f, -0.01811030f, 0.02665555f, -0.00963498f, 
    0.03168422f, -0.05195903f, -0.03363360f, -0.05595673f, -0.02202664f, -0.01340706f, -0.01709809f, -0.00657016f, 
    -0.05420388f, -0.03516992f, -0.06119318f, 0.09702080f, 0.06452308f, 0.04748121f, 0.07200180f, -0.09614740f, 
    0.11640032f, -0.33123320f, -0.20604627f, 0.21242119f, -0.09471849f, 0.15293887f, -0.05253316f, -0.19387306f, 
    -0.05741869f, 0.01389267f, -0.30114609f, 0.06071424f, -0.13037990f, -0.08025091f, 0.01003520f, 0.24286257f, 
    0.03977336f, -0.08328413f, -0.02773510f, 0.07236602f, -0.16425468f, 0.02090539f, -0.02006559f, 0.11412964f, 
    -0.03284400f, 0.18362409f, 0.05663434f, 0.00918495f, 0.14747533f, -0.05457090f, 0.07196549f, -0.03387815f, 
    0.02625903f, 0.03073267f, 0.00622490f, 0.03423546f, 0.14684966f, -0.29503676f, 0.03087818f, 0.10388723f, 
    0.05856201f, 0.03293832f, 0.05019573f, -0.01587351f, -0.09325787f, 0.17702107f, -0.48875284f, -0.11170772f, 
    0.02803541f, 0.01640962f, -0.01646886f, -0.07643168f, 0.00578866f, 0.02163857f, 0.08222838f, -0.27520454f, 
    0.03596796f, 0.02167477f, 0.05022352f, 0.07507528f, 0.08000837f, -0.06335708f, -0.06049580f, 0.02444443f, 
    0.08002272f, 0.09645344f, -0.01067999f, 0.14454737f, 0.01671641f, 0.05018350f, 0.01227899f, 0.07485320f, 
    0.02285394f, -0.07125519f, 0.06262873f, 0.28344432f, 0.07337274f, 0.04598579f, 0.06825002f, -0.08112919f, 
    0.07171028f, 0.05528462f, 0.05533552f, 0.08613286f, 0.01371719f, -0.05767747f, 0.09532946f, 0.06658804f, 
    0.16264182f, 0.08119626f, -0.16572806f, 0.00246851f, -0.00425320f, -0.14314042f, 0.06700935f, -0.03889846f, 
    0.05114178f, 0.02221897f, 0.11979493f, 0.05405534f, 0.02945967f, -0.21096559f, -0.15166570f, 0.11143135f, 
    -0.00063317f, 0.06244560f, -0.00877766f, 0.19734013f, -0.04315009f, -0.13075189f, -0.19435242f, 0.10558012f, 
    0.03383534f, 0.09025474f, -0.01851574f, -0.09656019f, -0.14497319f, -0.08813769f, 0.36512798f, 0.00360936f, 
    -0.24456307f, -0.01795372f, -0.07990751f, -0.06846022f, 0.00909462f, -0.05954688f, -0.04273643f, 0.06939725f, 
    0.04515213f, -0.22622314f, 0.01003563f, 0.05714768f, 0.02268913f, -0.02086561f, -0.09529229f, -0.11503386f, 
    -0.51240242f, -0.06385557f, -0.03088774f, 0.08426818f, -0.02600724f, -0.03560625f, -0.05188141f, 0.13755526f, 
    0.02649597f, 0.03739024f, -0.05491066f, -0.07566796f, 0.12355128f, 0.05322421f, 0.11487378f, 0.22150497f, 
    -0.13701075f, 0.15406233f, -0.03489670f, -0.05924971f, -0.04213853f, 0.01388855f, 0.14667138f, 0.10540688f, 
    0.01643052f, -0.05407880f, 0.11076753f, -0.01357487f, 0.01356884f, 0.16712049f, -0.05768731f, -0.05085550f, 
    0.01337675f, 0.02069655f, 0.01791944f, 0.02990137f, -0.21954714f, 0.02050323f, 0.05357710f, -0.01633819f, 
    0.00328797f, -0.08007158f, -0.15491401f, 0.09437453f, -0.05504805f, 0.07961479f, 0.00138222f, -0.15716268f, 
    -0.05024876f, -0.02517808f, -0.10141429f, 0.11911138f, 0.04598187f, -0.00498204f, 0.11506827f, -0.01445320f, 
    -0.11578550f, -0.07127397f, -0.04502908f, -0.06490199f, 0.05439024f, 0.00612648f, 0.00355504f, 0.15701772f, 
    -0.09998424f, -0.10748013f, 0.04830569f, -0.01133017f, -0.03488534f, 0.12990284f, -0.03523176f, -0.11136822f, 
    -0.04600976f, -0.06880871f, 0.06326836f, -0.02381005f, 0.01722305f, 0.13512081f, 0.19063947f, -0.02402301f, 
    -0.00843265f, 0.02353999f, 0.13588756f, 0.08283808f, -0.09075371f, 0.05202129f, 0.06114060f, 0.05675033f, 
    0.05035616f, -0.06080158f, 0.24657612f, 0.07965776f, -0.03286559f, 0.03104008f, 0.04544911f, 0.06644631f, 
    0.00365202f, 0.01608413f, 0.11721028f, 0.18907464f, 0.18608665f, 0.23828791f, -0.03391085f, 0.03507066f, 
    -0.01519230f, -0.03186126f, 0.04949293f, -0.05054902f, -0.02260854f, -0.07711309f, 0.05036371f, -0.05175238f, 
    -0.00614907f, 0.10040724f, -0.10630120f, 0.06498870f, 0.08930045f, 0.00647584f, -0.27100641f, -0.03928353f, 
    -0.14039454f, -0.07580713f, 0.04116918f, 0.30623186f, -0.06631697f, 0.10815603f, -0.16258478f, -0.15217255f, 
    0.11356116f, -0.04980804f, -0.10568738f, -0.06060684f, -0.04474476f, -0.10806985f, -0.03770824f, 0.13383901f, 
    -0.12949222f, -0.30267441f, -0.03851523f, 0.01716114f, 0.00738005f, -0.00405269f, -0.09531494f, -0.14484821f, 
    0.00974126f, 0.01506917f, -0.08151444f, -0.05484978f, -0.03880377f, 0.00412402f, -0.00957587f, 0.02491947f, 
    -0.05307826f, -0.07415167f, -0.04110846f, -0.03483026f, -0.02908373f, 0.01311023f, -0.02111216f, -0.09899813f, 
    -0.01652513f, -0.00692335f, -0.06335670f, -0.03031731f, 0.04981281f, -0.04163960f, -0.00668566f, 0.01284976f, 
    0.01351351f, -0.00493337f, -0.00207595f, -0.02883535f, 0.07783930f, 0.04067839f, -0.04191796f, -0.00628538f, 
    -0.01651978f, -0.05724422f, -0.00029075f, -0.02972692f, -0.02800125f, 0.04422811f, 0.04893167f, 0.02052947f, 
    -0.07497668f, -0.01765119f, -0.07512103f, -0.07860651f, -0.02825706f, -0.08522016f, 0.00552450f, 0.02909821f, 
    0.00691245f, 0.00252211f, -0.00228720f, 0.02034043f, 0.01589961f, -0.05331419f, -0.00313336f, -0.02384962f, 
    0.02394867f, 0.02885395f, -0.04517004f, -0.04966529f, 0.02232954f, 0.00378819f, 0.01122738f, 0.01746477f, 
    0.00614191f, 0.00424844f, -0.03519454f, -0.07402802f, -0.00116966f, -0.00799207f, -0.10567172f, -0.00588942f, 
    -0.07447106f, 0.06553810f, 0.02992900f, -0.02302861f, -0.03469295f, -0.03082852f, 0.02840517f, -0.00853127f, 
    -0.03804221f, -0.06726137f, -0.02859732f, -0.05986929f, 0.00213902f, -0.01087932f, -0.08798256f, -0.01022780f, 
    -0.05823236f, -0.01416713f, 0.01895915f, -0.07205684f, 0.00313271f, -0.07576131f, -0.00857038f, 0.04949479f, 
    -0.03062299f, -0.09195621f, -0.00778930f, -0.04513358f, -0.02506392f, 0.02698774f, -0.00383831f, -0.03378623f, 
    -0.01700966f, -0.02305057f, -0.08133945f, -0.02041763f, -0.01789659f, 0.04090106f, -0.06612799f, 0.01164037f, 
    -0.03851598f, -0.01317665f, -0.06691156f, -0.04131752f, 0.01493502f, 0.01231140f, 0.02036000f, -0.02720042f, 
    -0.06883717f, -0.03151081f, 0.04223788f, -0.07824455f, 0.01450646f, -0.05346821f, 0.00703022f, 0.01093540f, 
    -0.03161259f, -0.01935263f, 0.03903622f, -0.06135320f, -0.05794154f, 0.01193297f, -0.05946530f, 0.02490416f, 
    -0.05983361f, -0.01902764f, -0.05577669f, 0.00274133f, -0.00590423f, -0.00664402f, -0.06750172f, -0.07068995f, 
    -0.02839416f, -0.04497483f, 0.04448944f, -0.03349072f, -0.01409114f, -0.00820610f, -0.04072571f, -0.02575910f, 
    -0.07969928f, -0.06796100f, 0.05471862f, 0.04778085f, 0.01433420f, -0.00716065f, -0.05058457f, 0.02417856f, 
    -0.03235068f, -0.02693750f, -0.03039707f, -0.03066393f, -0.06826834f, 0.04051425f, 0.03868403f, 0.02835008f, 
    -0.05369574f, -0.05598183f, 0.00440821f, -0.04315504f, -0.01348150f, 0.01099938f, -0.05948888f, -0.01637283f, 
    -0.04445233f, -0.04162968f, 0.02734238f, 0.02687205f, 0.03925839f, 0.02078879f, -0.02211835f, -0.00245496f, 
    -0.07630351f, 0.01379757f, -0.05125604f, -0.03410015f, 0.00637993f, 0.02371962f, -0.01851935f, 0.05125270f, 
    -0.03816851f, -0.02673037f, -0.01492625f, 0.03229388f, -0.04434571f, 0.00979345f, 0.02091749f, 0.00381246f, 
    -0.08788702f, -0.00815440f, -0.01406141f, -0.05366773f, -0.01905662f, -0.04721157f, -0.01037194f, -0.04495521f, 
    -0.05286066f, -0.04611498f, 0.00449792f, -0.04984497f, -0.04132160f, -0.01219447f, 0.03601421f, 0.00060702f, 
    -0.01827279f, -0.03592093f, 0.01643591f, 0.01406028f, 0.00392566f, 0.01026839f, 0.01996620f, -0.04524286f, 
    0.00424943f, 0.00233177f, 0.01638323f, -0.00453570f, -0.06463405f, 0.02071016f, 0.00313545f, -0.04820379f, 
    -0.05274344f, 0.03981763f, -0.05091019f, -0.01258049f, 0.00167375f, -0.03108963f, -0.05471365f, 0.02454145f, 
    0.02196978f, -0.07018300f, -0.07496753f, -0.03876504f, -0.04198835f, -0.04779825f, 0.00877564f, 0.01573208f, 
    -0.01168156f, 0.03759708f, -0.03969549f, 0.00258471f, -0.06927259f, -0.05833567f, 0.01700347f, -0.08024832f, 
    -0.03148297f, 0.03123558f, 0.02063627f, -0.03818988f, -0.00847708f, 0.01924634f, 0.00675243f, -0.00645517f, 
    -0.00388230f, 0.02166490f, -0.03494434f, -0.07261376f, 0.04776607f, 0.03621012f, -0.00382998f, 0.01479189f, 
    -0.00389087f, 0.01112078f, 0.02489688f, 0.04015728f, -0.05407153f, -0.06617465f, -0.03230553f, -0.00349619f, 
    0.02797052f, -0.00963809f, -0.05538001f, 0.03879490f, 0.00343119f, -0.05284024f, 0.03038594f, 0.01515733f, 
    0.04370337f, 0.00096138f, -0.00587939f, 0.01613629f, -0.02811399f, 0.02544045f, 0.02354746f, 0.02988919f, 
    -0.00740762f, -0.01632039f, 0.03678082f, 0.04470966f, -0.03891803f, -0.01176118f, 0.02424976f, -0.02793498f, 
    -0.00506734f, 0.00611365f, 0.04487204f, 0.02305074f, -0.06390662f, -0.06358583f, 0.03551177f, 0.04666299f, 
    -0.01200349f, -0.03312435f, -0.00144492f, -0.01595740f, -0.02472192f, 0.01708171f, 0.04930280f, -0.01513646f, 
    0.04328819f, 0.02759404f, -0.00054683f, -0.04260375f, -0.02060279f, -0.00338064f, 0.00231647f, -0.00188916f, 
    -0.01965470f, 0.01763009f, 0.01824411f, -0.06888188f, 0.04469415f, -0.01974974f, -0.02633366f, 0.02076736f, 
    0.02833646f, 0.01000298f, -0.02338741f, 0.03725346f, -0.06236561f, -0.00463060f, -0.06091239f, 0.01705098f, 
    0.04087244f, 0.00297662f, -0.03963627f, -0.01160074f, -0.00169958f, -0.03753011f, -0.05129969f, -0.06047436f, 
    0.02478207f, -0.06363687f, -0.04700949f, 0.02505550f, 0.01497568f, 0.03626363f, -0.02113481f, -0.03170796f, 
    -0.05373624f, -0.01443212f, 0.03651726f, -0.00915006f, -0.00176771f, -0.01808289f, 0.02885731f, -0.06102017f, 
    -0.05292473f, 0.02090525f, 0.02260838f, 0.05136444f, 0.02944702f, 0.02420983f, -0.03690767f, -0.04406830f, 
    0.00079792f, -0.01195459f, -0.01286957f, 0.04791219f, -0.05350361f, 0.02316088f, 0.01505201f, -0.05560404f, 
    0.02040490f, 0.03594366f, 0.02857756f, -0.04371652f, -0.06301995f, -0.00297801f, -0.06615235f, 0.03492429f, 
    0.02109673f, 0.03220675f, 0.01420294f, 0.03872943f, -0.05835387f, 0.01924968f, -0.03659545f, -0.01523026f, 
    0.01859216f, 0.01871747f, -0.00664980f, 0.00480020f, -0.01695493f, 0.02404574f, 0.00517668f, -0.02335320f, 
    -0.04846543f, -0.00619147f, 0.02864534f, 0.04027668f, 0.01111634f, -0.01048046f, -0.04494046f, -0.03610979f, 
    -0.03227611f, 0.05151607f, 0.02974051f, -0.01979559f, -0.02233922f, -0.05119652f, -0.06087584f, 0.05196561f, 
    -0.05772297f, 0.03924559f, 0.02804040f, -0.03572612f, -0.02971995f, 0.02481478f, 0.02386669f, -0.05753887f, 
    -0.04284350f, -0.00087789f, -0.05120813f, 0.00818059f, 0.04945677f, 0.04402329f, -0.04648501f, -0.04980801f, 
    -0.05930058f, 0.01503083f, 0.05100406f, -0.02640159f, -0.03977128f, -0.02420759f, -0.02919575f, -0.01292510f, 
    -0.02319890f, -0.01369412f, -0.05392468f, 0.02030268f, 0.03129261f, -0.05770753f, 0.05144000f, 0.02485188f, 
    -0.06442424f, -0.01107264f, -0.03401052f, 0.03560673f, 0.00043321f, -0.06822456f, -0.03471197f, 0.03292816f, 
    -0.00294272f, -0.00795619f, -0.00060376f, -0.05973365f, -0.05917570f, -0.01186229f, -0.00071214f, 0.02725849f, 
    0.03518661f, 0.01693333f, -0.04692965f, -0.04611385f, 0.04153087f, -0.03735171f, -0.05592929f, -0.05301805f, 
    -0.04682169f, 0.02040921f, 0.04631969f, 0.00246738f, -0.00074193f, 0.04702307f, 0.02137089f, -0.05050593f, 
    -0.02830416f, 0.02486032f, 0.02442248f, 0.01633423f, 0.00172946f, -0.04761351f, -0.01713846f, -0.03435630f, 
    0.01826277f, -0.01827771f, -0.06421580f, 0.01223618f, 0.02664894f, -0.02464282f, -0.03557250f, -0.01633619f, 
    -0.05759772f, -0.00351540f, 0.01413910f, -0.00836230f, -0.01783854f, -0.03516028f, -0.04775011f, -0.02060740f, 
    -0.01386638f, 0.04242683f, -0.01583327f, -0.05293432f, -0.05408263f, -0.06114651f, -0.02860061f, -0.06105625f, 
    -0.06168707f, 0.02804613f, -0.05815650f, -0.04546132f, -0.06032214f, 0.02913352f, -0.01122661f, -0.02152064f, 
    -0.06193733f, -0.00793799f, 0.03979675f, 0.00810170f, 0.00148480f, 0.03233912f, -0.00345654f, -0.03475521f, 
    0.00170896f, -0.06392448f, -0.05113602f, 0.03808630f, -0.06079661f, 0.01920178f, -0.06508771f, 0.04659238f, 
    0.00586727f, 0.03841791f, 0.02758535f, -0.00724355f, -0.02591783f, -0.03259655f, -0.00548999f, -0.02699396f, 
    -0.03948234f, -0.05495088f, 0.03653689f, 0.01936515f, 0.03233746f, -0.03465382f, 0.01306330f, -0.05934691f, 
    0.00799961f, 0.04277385f, 0.01041478f, 0.02085662f, -0.05382307f, 0.00860837f, -0.02632796f, -0.00543256f, 
    0.00353151f, 0.00809492f, 0.00334361f, 0.02989860f, 0.03042895f, -0.03417779f, -0.01537105f, -0.00470425f, 
    0.20177522f, 0.00203239f, -0.08445860f, -0.11002390f, -0.13837902f, 0.06790748f, 0.05346111f, -0.08833610f, 
    0.09163876f, 0.00192720f, -0.18029131f, -0.15083940f, 0.08944425f, 0.05693163f, -0.09432296f, 0.05012667f, 
    0.04353848f, -0.01431733f, -0.07801467f, -0.01376184f, 0.04493266f, -0.00169232f, -0.02646979f, -0.07548764f, 
    -0.03917905f, 0.07643420f, -0.11435708f, -0.47552171f, -0.03745241f, -0.01170874f, 0.23932260f, 0.07187985f, 
    -0.01735560f, 0.04822862f, -0.07462186f, -0.08608267f, -0.24037988f, 0.16850957f, -0.03124439f, 0.11306950f, 
    -0.04139031f, -0.04367943f, -0.12160903f, 0.02630640f, -0.05415364f, 0.10839614f, -0.09621350f, 0.01416504f, 
    -0.07823880f, -0.07049260f, -0.02345795f, 0.01885364f, 0.03430661f, 0.07409327f, 0.20232342f, -0.08412468f, 
    -0.02361460f, -0.04699874f, -0.03640780f, 0.01752099f, 0.02693525f, -0.07871984f, 0.08411341f, -0.09016680f, 
    0.10132591f, 0.23337302f, 0.20626932f, -0.13412277f, -0.01553777f, 0.04477813f, -0.11634459f, 0.04258922f, 
    -0.00414295f, -0.03435434f, -0.00631331f, 0.15197277f, 0.09090927f, -0.03577405f, -0.12628995f, -0.22106718f, 
    -0.03971599f, 0.01325166f, -0.00626435f, -0.13494714f, -0.01060796f, -0.03350161f, -0.00893636f, -0.03602558f, 
    0.06955782f, 0.11437065f, -0.09546108f, 0.04349660f, 0.04043256f, 0.02848282f, 0.04238790f, 0.23344234f, 
    -0.02484198f, -0.05311002f, -0.03306924f, 0.02283644f, -0.00502543f, 0.05146036f, -0.04728948f, 0.00258561f, 
    -0.08060914f, -0.11646671f, 0.02346146f, 0.12451373f, -0.20020562f, -0.05764170f, 0.07534476f, -0.03660861f, 
    -0.10344633f, -0.05448125f, -0.07867415f, 0.07058675f, 0.02108014f, 0.13991487f, 0.05746190f, -0.04384756f, 
    -0.13241856f, -0.26452276f, -0.19789417f, -0.09022375f, 0.07273436f, 0.06771676f, -0.00344951f, -0.07689168f, 
    0.19543901f, -0.09332640f, 0.05797900f, 0.19753514f, 0.01471901f, 0.05010988f, -0.06371405f, 0.10166604f, 
    0.13464919f, 0.34354866f, -0.07674840f, -0.00015391f, 0.01077169f, 0.06732413f, 0.02153377f, -0.06370745f, 
    -0.00244694f, -0.00433536f, -0.03921512f, 0.05034636f, -0.24521999f, -0.20475034f, 0.09769864f, -0.01793183f, 
    0.08649357f, -0.30834877f, -0.20907238f, -0.15273330f, 0.09923282f, -0.00665800f, -0.12462924f, -0.08464185f, 
    -0.14683644f, -0.07613569f, 0.08953440f, 0.07043146f, 0.00670133f, -0.10154783f, -0.03789511f, 0.01227327f, 
    -0.02419206f, 0.10829698f, 0.11634379f, 0.17825367f, 0.14668204f, -0.01899992f, 0.00173972f, 0.03533817f, 
    -0.02383419f, -0.03527175f, 0.14270672f, 0.05513301f, -0.19217162f, -0.03670769f, 0.20276789f, 0.12316072f, 
    -0.05598368f, -0.20608123f, -0.00221069f, 0.00425986f, -0.06050139f, -0.11532232f, -0.14640404f, -0.07790225f, 
    0.17387240f, -0.00439757f, 0.08657236f, -0.17105140f, -0.02051233f, -0.00972631f, 0.11461917f, 0.06204557f, 
    0.14175525f, -0.13975470f, 0.09121004f, -0.01464585f, 0.14242502f, -0.11562087f, -0.02341383f, 0.16248599f, 
    0.08376061f, 0.15677752f, 0.06007992f, -0.15896624f, 0.07584690f, -0.10410718f, -0.10597598f, -0.07279713f, 
    -0.09776247f, 0.21747054f, 0.02346117f, 0.04323498f, 0.02954474f, -0.04815380f, -0.13239875f, -0.04293559f, 
    0.11715750f, -0.04584360f, 0.04386306f, -0.13277714f, 0.14289515f, 0.01179981f, 0.01478479f, -0.11006549f, 
    0.01963906f, -0.03135590f, -0.27632642f, -0.08342858f, 0.13511804f, 0.15639196f, 0.04696379f, 0.04491383f, 
    0.07032269f, -0.02382094f, -0.01295665f, 0.17383873f, -0.02653298f, 0.02466073f, 0.03813028f, -0.01152608f, 
    0.07376418f, 0.01642281f, 0.13505407f, -0.04342977f, 0.10448787f, 0.04456581f, 0.00943424f, -0.05173932f, 
    0.08495845f, 0.06822040f, -0.03701265f, 0.06356336f, -0.10172886f, -0.19529861f, -0.07520709f, 0.29202205f, 
    0.00277450f, 0.06252231f, 0.02168625f, -0.01073463f, -0.03680686f, 0.06911690f, 0.02719548f, -0.09912121f, 
    0.07166124f, -0.14853698f, -0.05888678f, -0.16126020f, 0.03625981f, -0.00872501f, -0.11470495f, 0.09108091f, 
    0.08281383f, 0.40924782f, -0.01037789f, -0.00010906f, 0.02393222f, -0.00840561f, 0.00002522f, -0.03919401f, 
    -0.09533267f, -0.17924696f, -0.17213510f, 0.17399924f, 0.12691593f, 0.23968099f, -0.12710965f, 0.04266560f, 
    -0.00379221f, 0.04942217f, 0.34016171f, 0.15803789f, -0.02493690f, 0.07003734f, -0.06324206f, -0.12031382f, 
    -0.00319211f, -0.18933801f, 0.07819925f, 0.10484823f, 0.14845872f, 0.13754024f, 0.07701845f, -0.09744723f, 
    -0.14087389f, -0.17405067f, 0.03337413f, -0.08438201f, 0.05048600f, 0.03214115f, -0.14119516f, 0.00552639f, 
    0.05834680f, -0.18740281f, 0.00340890f, 0.11972558f, -0.17492850f, -0.06941957f, -0.32082313f, 0.02215463f, 
    0.04180227f, 0.06981549f, 0.04475747f, -0.03804141f, -0.08725187f, -0.12891060f, 0.01185373f, 0.16958554f, 
    0.00722006f, -0.06780164f, 0.06429189f, -0.01745226f, -0.04004353f, 0.04302734f, -0.09337085f, 0.04443723f, 
    0.23384576f, -0.07255355f, -0.09159147f, 0.04170059f, -0.01064589f, -0.13936764f, 0.07423802f, 0.11283703f, 
    0.16775054f, 0.23997512f, 0.14201255f, -0.03950655f, 0.11315677f, -0.00366978f, 0.02574714f, -0.07321524f, 
    0.11729455f, -0.20374086f, 0.07859609f, 0.01494559f, -0.12365560f, -0.07492735f, 0.04042298f, 0.02061369f, 
    0.01231609f, 0.06754346f, -0.03300143f, -0.19524428f, -0.20415308f, 0.02680985f, 0.04958016f, -0.14402030f, 
    0.03158152f, -0.07880450f, 0.23836932f, 0.11047784f, 0.06386662f, 0.11917221f, 0.06042967f, 0.13321270f, 
    0.01461169f, 0.09435052f, -0.15016708f, 0.17999189f, -0.01656022f, 0.06512553f, -0.04693988f, -0.02642070f, 
    0.05872012f, -0.02330876f, -0.18010247f, -0.15978947f, -0.07251962f, -0.06867597f, -0.13871993f, -0.10851590f, 
    0.11643630f, -0.11408197f, -0.14571783f, 0.05021061f, 0.01150257f, -0.02854410f, -0.09579515f, -0.22482103f, 
    0.01221970f, 0.04327700f, -0.14140172f, 0.29487765f, 0.10439439f, -0.06898808f, -0.11082857f, -0.09000261f, 
    0.11870506f, 0.10310172f, -0.07654240f, -0.02348583f, -0.08991531f, -0.05501648f, -0.04223828f, 0.13139124f, 
    0.20354255f, 0.07638051f, -0.03884877f, 0.09723298f, -0.06679925f, 0.02986748f, 0.07279758f, -0.03103607f, 
    -0.05149709f, 0.01982357f, 0.19133291f, 0.07004195f, -0.17008857f, 0.06201461f, -0.02328814f, -0.03971583f, 
    -0.09479039f, -0.21707815f, -0.29564396f, -0.10655838f, 0.05265627f, -0.02887759f, 0.07593620f, -0.25082940f, 
    0.04574706f, -0.15947846f, -0.04901640f, -0.05013344f, 0.08318452f, -0.12056779f, -0.04474353f, -0.09187495f, 
    -0.10963485f, 0.10312191f, -0.03096743f, 0.26012963f, 0.00570380f, -0.03326758f, 0.05420421f, -0.00124564f, 
    -0.10313640f, 0.07811541f, -0.05856740f, 0.15297766f, 0.20222835f, 0.22658825f, 0.23687024f, 0.06268892f, 
    -0.02289371f, 0.01721499f, 0.06093813f, 0.07144387f, -0.06239715f, 0.18104559f, 0.03685197f, 0.12304231f, 
    0.04717985f, -0.18075609f, 0.02549309f, 0.08455799f, 0.03779197f, 0.06328626f, -0.25370088f, 0.02676638f, 
    0.11666419f, -0.02608962f, 0.01797632f, -0.07125432f, 0.13451104f, 0.00663555f, 0.09074785f, 0.08185604f, 
    -0.19782032f, -0.09235013f, 0.16563238f, -0.05916364f, -0.11397842f, -0.05499057f, 0.01716839f, 0.16727652f, 
    0.01847309f, -0.14280580f, -0.17196819f, -0.20521812f, -0.05911422f, 0.06387092f, -0.05314218f, 0.07536738f, 
    0.00633559f, 0.09309959f, -0.06166066f, -0.07390849f, -0.04037396f, -0.09602357f, -0.10603958f, 0.02733856f, 
    -0.01057364f, 0.01827981f, -0.20471402f, -0.11414107f, -0.09283233f, -0.02458417f, -0.08916913f, 0.06188215f, 
    0.01878494f, -0.05187983f, -0.06905942f, 0.05832568f, -0.04833110f, -0.12005986f, -0.07384575f, -0.07677889f, 
    -0.07091679f, 0.14318098f, 0.06466342f, 0.11293736f, 0.30024108f, 0.19557312f, 0.21840142f, -0.00972052f, 
    -0.06456048f, -0.08445226f, -0.03605036f, -0.07703613f, 0.04310522f, 0.08143143f, 0.01435398f, 0.04566243f, 
    -0.08416625f, 0.04907066f, -0.06212847f, 0.05141831f, 0.08791180f, -0.28015408f, 0.14707489f, 0.12279007f, 
    -0.10313305f, 0.05041331f, 0.00664640f, 0.01759228f, 0.02454156f, 0.05485060f, 0.27493650f, 0.30139118f, 
    0.19425170f, 0.11242951f, 0.02042484f, 0.07232739f, -0.01714609f, 0.02638157f, 0.07311232f, -0.01876093f, 
    -0.02466010f, 0.20749803f, -0.03697044f, 0.04872011f, -0.01758389f, -0.06508630f, 0.05692248f, -0.05071554f, 
    0.03764556f, 0.29315433f, -0.11447097f, -0.30264649f, -0.08037242f, 0.02571131f, 0.01466460f, -0.03110757f, 
    0.08554821f, -0.06000383f, 0.06003810f, -0.30941445f, -0.04756291f, 0.13009037f, -0.00953057f, -0.05893338f, 
    -0.03679916f, 0.12177435f, 0.17007762f, -0.36592105f, 0.09582735f, -0.31038523f, -0.03349919f, 0.03137103f, 
    0.02084904f, -0.03365709f, 0.10594136f, 0.07053831f, -0.33759981f, 0.04480493f, -0.27215272f, 0.03334688f, 
    -0.00569246f, -0.00301369f, -0.06434711f, 0.08465379f, 0.11930515f, -0.02390259f, 0.07179924f, -0.04016864f, 
    0.08562876f, -0.04000976f, 0.05860204f, 0.05190566f, -0.05148034f, -0.11626089f, 0.29156828f, 0.19959834f, 
    0.19941236f, 0.05509671f, -0.03212131f, 0.11060245f, -0.13242862f, -0.00774780f, -0.19212379f, 0.31248018f, 
    0.07089682f, 0.08179390f, -0.10880627f, -0.09488472f, 0.01289805f, -0.00740896f, -0.04501102f, -0.12762173f, 
    0.01466268f, 0.08830732f, 0.02553299f, -0.02222683f, 0.02343364f, -0.07884590f, 0.04723903f, -0.03947604f, 
    0.14623865f, -0.05074686f, -0.01919957f, -0.01982596f, -0.06586390f, 0.11636820f, -0.21672429f, 0.04696093f, 
    0.11049096f, -0.12555192f, -0.01528911f, 0.00888828f, 0.13043864f, -0.03536146f, 0.03721213f, -0.10764179f, 
    0.04014654f, -0.00625963f, 0.02475728f, -0.21709591f, 0.04206091f, -0.05077158f, 0.07413386f, 0.06983806f, 
    0.08397221f, -0.15501338f, -0.04170272f, -0.11354291f, -0.03976519f, 0.14791578f, -0.02171296f, -0.00880555f, 
    0.02494628f, -0.05297453f, -0.01499199f, -0.04440538f, 0.07028405f, -0.26069754f, 0.11895424f, 0.02279984f, 
    -0.01619189f, -0.02214300f, -0.03502049f, 0.00197873f, -0.15252274f, 0.03771987f, 0.05192190f, 0.12168697f, 
    0.01337276f, -0.00642404f, 0.02076003f, 0.04074812f, -0.14979400f, 0.04960972f, 0.04022976f, 0.36923149f, 
    0.26386425f, 0.23666342f, 0.03421823f, 0.07120991f, 0.02543930f, 0.10120295f, -0.02215036f, -0.06141947f, 
    -0.13593495f, -0.12552141f, -0.24008013f, -0.03064692f, 0.03237034f, -0.02960601f, -0.02891647f, 0.07902986f, 
    -0.12107404f, -0.21933156f, -0.09747183f, -0.08746246f, -0.10023586f, -0.00164086f, 0.08746190f, -0.03568545f, 
    -0.00096712f, 0.00535279f, 0.54196447f, -0.18377073f, -0.24338138f, 0.02119026f, 0.10436570f, 0.06024826f, 
    -0.19093579f, -0.00338476f, -0.01629941f, -0.42465445f, 0.21147002f, 0.03609934f, 0.03698741f, -0.05894643f, 
    -0.07442762f, -0.02733251f, 0.13139278f, 0.05414106f, 0.07657778f, 0.24261740f, 0.07003544f, 0.08447229f, 
    -0.02384664f, -0.01401705f, 0.02492422f, 0.02175892f, 0.04530552f, 0.23087603f, -0.05939201f, -0.04391569f, 
    -0.08543234f, -0.06039352f, 0.09869070f, -0.11768087f, 0.07800099f, -0.05686413f, 0.10001990f, 0.17748713f, 
    -0.24913895f, -0.02687809f, 0.05204323f, -0.09272956f, 0.13404079f, -0.01728252f, 0.01005522f, 0.06039236f, 
    0.12468839f, -0.21364768f, -0.01326511f, -0.06994478f, 0.00198836f, 0.11338299f, -0.18251510f, 0.10666032f, 
    -0.34693089f, -0.01648152f, -0.11365935f, -0.00909431f, 0.14607173f, 0.01943804f, -0.12054823f, 0.01181741f, 
    -0.12532933f, -0.03827559f, -0.00404609f, -0.04317072f, -0.04033809f, 0.04461925f, 0.02134275f, -0.04509270f, 
    -0.03870814f, 0.16361234f, -0.09099196f, 0.10817505f, -0.08582781f, -0.00463591f, 0.03989371f, 0.01679907f, 
    -0.01801277f, 0.08794788f, -0.02060394f, 0.14286664f, -0.06264391f, 0.02301885f, -0.10540365f, 0.03914982f, 
    0.04153523f, 0.01249098f, 0.08037067f, 0.17345409f, 0.06449065f, 0.00560220f, 0.00472746f, 0.14579049f, 
    0.05472748f, 0.05413142f, -0.10380439f, -0.04601917f, -0.15428637f, -0.21905892f, -0.16623078f, -0.01619929f, 
    0.00989028f, 0.15758668f, 0.09598529f, -0.08942827f, -0.15878166f, 0.03525144f, -0.42199370f, 0.27783030f, 
    -0.05800173f, -0.09069917f, 0.01135586f, -0.11209848f, 0.03556939f, -0.09162247f, 0.13945429f, 0.25869659f, 
    0.08792831f, 0.19311827f, 0.03706211f, 0.06746398f, 0.06567650f, 0.12078973f, -0.00062752f, 0.06020822f, 
    0.00925044f, 0.04452256f, 0.04497795f, 0.00871587f, -0.04354276f, -0.00619006f, -0.00424570f, -0.04255964f, 
    0.01433978f, -0.05970806f, -0.03735652f, -0.05389648f, -0.01570459f, -0.00619107f, 0.00597781f, 0.04919504f, 
    -0.01557896f, -0.03471240f, -0.03153227f, -0.03907826f, -0.06685964f, -0.03414497f, -0.01957542f, -0.00069850f, 
    -0.05851622f, -0.01567604f, -0.00491342f, 0.03668767f, -0.04368233f, -0.01819266f, -0.04898554f, -0.00213225f, 
    0.02453026f, 0.00334834f, -0.01383759f, -0.02498772f, -0.01143611f, -0.05971508f, -0.02650760f, -0.03111866f, 
    0.00286561f, 0.00772575f, 0.01597090f, -0.03849876f, -0.04337777f, 0.01216011f, -0.01935649f, 0.03246376f, 
    0.02272251f, 0.00322310f, -0.03424025f, -0.02670229f, -0.01507060f, -0.03803728f, -0.03561091f, 0.01686697f, 
    -0.01637964f, -0.04304404f, -0.01715349f, 0.02171909f, -0.01666513f, -0.03322335f, 0.02882333f, 0.01246724f, 
    -0.02196905f, 0.02855238f, 0.01992244f, 0.03121651f, -0.01940344f, -0.06252545f, -0.00537205f, -0.00164616f, 
    -0.03743960f, -0.03713673f, 0.04732165f, 0.01699204f, 0.01802225f, 0.02794394f, -0.01963336f, 0.03611842f, 
    0.04076063f, -0.00013638f, -0.05187278f, -0.03924699f, -0.03187233f, -0.01979865f, 0.01317044f, 0.01968117f, 
    0.02320319f, 0.02686333f, -0.07002806f, 0.01231964f, -0.02643426f, 0.01912142f, 0.04683170f, 0.01076934f, 
    0.03053552f, 0.01510978f, 0.00592445f, -0.02819991f, -0.01045550f, -0.04275434f, 0.00178884f, 0.02112977f, 
    -0.02548113f, -0.06633121f, -0.01502922f, 0.04753808f, 0.03663797f, 0.04078585f, 0.02235790f, 0.01985144f, 
    -0.05235348f, -0.00799451f, -0.05104765f, -0.00750102f, -0.02682275f, 0.04763990f, -0.03173509f, -0.06240261f, 
    -0.04542961f, 0.03099334f, 0.04982113f, 0.02903653f, -0.04013966f, 0.00933029f, 0.04530751f, 0.01993988f, 
    -0.02434124f, -0.04005278f, -0.04304909f, 0.05205398f, -0.03428109f, -0.05422962f, -0.03212847f, -0.01863226f, 
    -0.00123144f, 0.03905743f, 0.01816839f, 0.02959015f, 0.02461075f, -0.02413056f, 0.02668932f, -0.04050881f, 
    0.04851989f, -0.01024061f, 0.02704713f, -0.02176549f, -0.04238221f, 0.04211165f, -0.06359120f, -0.05507417f, 
    -0.03409190f, -0.05834559f, -0.05202501f, -0.04885842f, -0.02793826f, -0.05740717f, 0.01304840f, -0.01296598f, 
    0.04825509f, -0.04194300f, 0.00802718f, -0.06148056f, -0.03010167f, 0.01079090f, 0.01366270f, 0.05258931f, 
    -0.02391449f, -0.01359814f, 0.03327926f, 0.01810039f, -0.04653443f, -0.01476836f, 0.02148623f, 0.00766027f, 
    0.01262370f, 0.00874962f, -0.00909295f, 0.03269925f, -0.00399184f, 0.02559044f, -0.02047934f, 0.01071853f, 
    0.01749041f, 0.03471260f, -0.03449450f, 0.01878620f, 0.03662934f, -0.01483339f, -0.04245410f, 0.02407955f, 
    0.03505065f, -0.04668834f, -0.00925448f, 0.01397292f, -0.00037363f, 0.01825631f, -0.02350922f, 0.00363091f, 
    0.03984536f, -0.04223522f, -0.05204633f, 0.01752481f, 0.05348505f, -0.02436179f, 0.00331268f, 0.03611755f, 
    0.02163428f, 0.02966505f, 0.01317938f, -0.02504021f, -0.03907626f, 0.00681228f, 0.04920335f, 0.01509285f, 
    -0.04992395f, -0.05182250f, -0.01968035f, 0.04547067f, 0.01288806f, -0.06392036f, -0.02339352f, 0.04083114f, 
    0.03858817f, 0.01138985f, -0.05536719f, 0.03198705f, 0.04118451f, 0.04893948f, 0.01703048f, 0.02010361f, 
    -0.02788873f, -0.03624069f, -0.03623360f, -0.03665119f, -0.02392346f, -0.01568753f, 0.00456547f, -0.06092250f, 
    0.03865615f, -0.00825570f, -0.04916701f, 0.00918035f, -0.01679304f, 0.00758371f, 0.03673949f, -0.03285442f, 
    -0.04930437f, -0.00497151f, 0.05329674f, -0.00047736f, 0.04446391f, 0.02511738f, 0.00097531f, -0.02088661f, 
    0.02898544f, 0.04193093f, -0.06370854f, -0.04890945f, -0.06568851f, -0.04848529f, -0.03555594f, -0.01484236f, 
    -0.05404162f, -0.05896894f, 0.00690816f, -0.04646572f, 0.00499120f, -0.05407596f, -0.03110590f, 0.01961610f, 
    0.03463911f, -0.00354091f, -0.05732881f, 0.03153167f, -0.03605530f, -0.00686424f, -0.03847357f, 0.02745720f, 
    -0.01686087f, 0.03050804f, 0.03383491f, -0.02744917f, 0.03664203f, -0.03202671f, 0.04000446f, 0.01975753f, 
    -0.22519852f, -0.08636941f, -0.09337801f, 0.09769540f, -0.07553519f, 0.02691615f, 0.05442303f, 0.01898062f, 
    -0.00317801f, 0.27674568f, 0.16241492f, 0.00929212f, -0.08229867f, -0.19590253f, -0.05819289f, -0.00358549f, 
    0.17570777f, -0.09942161f, -0.06196687f, 0.05005051f, -0.19691829f, 0.08104979f, 0.01461069f, -0.11436345f, 
    0.03567478f, 0.10273194f, 0.06119268f, -0.06201506f, -0.07306603f, -0.17824124f, -0.09496834f, -0.03673353f, 
    0.04416594f, -0.01695116f, 0.01069519f, 0.03791511f, 0.12817010f, -0.10873521f, -0.05335478f, -0.13456424f, 
    -0.05198734f, 0.08181903f, 0.00304786f, -0.02590095f, 0.01550934f, -0.08688732f, -0.07343214f, 0.02438342f, 
    0.03930635f, -0.03963226f, -0.03498560f, 0.07225496f, -0.01913428f, -0.06769487f, 0.11331452f, 0.06469022f, 
    0.02756914f, 0.04091367f, 0.12287675f, -0.12571396f, 0.03607363f, -0.06056735f, 0.00606167f, 0.04635892f, 
    0.10255484f, 0.05287284f, 0.02200250f, 0.04729076f, -0.13894041f, -0.00584972f, -0.04411514f, -0.04217941f, 
    -0.22892219f, 0.02101669f, 0.00337209f, -0.02871587f, -0.00998257f, -0.03611708f, 0.05078189f, -0.00826609f, 
    0.02837528f, -0.13864601f, -0.16916615f, 0.17131469f, 0.01663813f, -0.06073068f, 0.11788164f, 0.06624904f, 
    -0.08751982f, 0.07278883f, 0.34429821f, 0.09539556f, 0.20673503f, 0.07047935f, -0.05628969f, 0.00464116f, 
    -0.00043229f, 0.01707804f, 0.11173806f, 0.16843000f, -0.22496475f, 0.20906059f, -0.12709028f, 0.01920023f, 
    -0.03179416f, 0.04154031f, -0.09752833f, 0.06992821f, -0.05477589f, 0.01239942f, -0.08231004f, 0.03229384f, 
    -0.08639570f, 0.00091583f, -0.02637835f, -0.03334154f, 0.12909806f, -0.14373726f, -0.22277030f, -0.04762521f, 
    -0.00795891f, -0.13280174f, 0.05962128f, 0.07130771f, 0.01311195f, 0.01559709f, 0.06479821f, 0.07946826f, 
    0.08529085f, -0.03057098f, 0.00496244f, 0.13713923f, 0.16130313f, -0.08311073f, -0.11853854f, -0.01403555f, 
    0.03162770f, 0.10385642f, 0.17195013f, 0.15800025f, -0.08128068f, -0.03916771f, 0.10847319f, 0.07567942f, 
    0.05989596f, -0.09258504f, 0.33424038f, -0.00623409f, 0.01167957f, -0.06164895f, 0.09980157f, -0.20825514f, 
    0.01372632f, 0.10827634f, 0.03198246f, -0.04041951f, -0.00326458f, -0.12707724f, 0.00266335f, -0.05185418f, 
    -0.00960075f, 0.02225996f, -0.01547632f, 0.04614298f, -0.11998807f, -0.09649122f, -0.07820383f, 0.02422612f, 
    0.11552694f, 0.01342955f, 0.11851121f, -0.40784389f, 0.02910347f, -0.25564542f, 0.11576210f, 0.03883031f, 
    0.03129476f, 0.06089897f, -0.13375387f, 0.01679121f, 0.14653307f, 0.13195345f, -0.01017289f, 0.07889517f, 
    0.12299483f, -0.12094330f, -0.01835608f, -0.03229226f, -0.12817642f, 0.03033566f, 0.05289521f, 0.04916188f, 
    0.14095967f, -0.02627833f, -0.04905423f, -0.00697246f, 0.10394670f, -0.08512560f, -0.27581155f, -0.02657619f, 
    0.17071570f, 0.16847000f, -0.07404610f, 0.00936856f, 0.06531779f, 0.00276238f, -0.05023604f, -0.26930034f, 
    -0.09693705f, -0.12025477f, 0.04443527f, -0.05317659f, -0.02112977f, 0.02339553f, 0.08930802f, -0.02412249f, 
    0.05384151f, -0.12995405f, 0.10149577f, -0.01039714f, -0.08409604f, 0.18038057f, -0.15711933f, -0.09202770f, 
    0.10587568f, -0.05146709f, 0.08406308f, -0.17056885f, 0.08456986f, -0.09266341f, 0.07980203f, 0.00269975f, 
    -0.11733807f, 0.03509520f, 0.09361155f, -0.00641918f, 0.04536812f, -0.14627355f, 0.12143393f, -0.00034207f, 
    -0.01807646f, -0.00389302f, 0.05033046f, -0.25358272f, 0.08600052f, -0.12739740f, 0.19138430f, 0.00308471f, 
    0.09237923f, 0.00460434f, -0.02230866f, 0.16547988f, 0.11597685f, -0.04157794f, -0.10361712f, -0.13412675f, 
    -0.07215199f, 0.00286954f, 0.06409872f, -0.05416274f, -0.01471583f, -0.03403445f, 0.02017840f, 0.07773673f, 
    -0.05321075f, 0.10611871f, -0.07454991f, -0.12314936f, 0.02077707f, -0.02366198f, -0.15534222f, -0.02936199f, 
    -0.10679042f, 0.09627984f, -0.13157417f, 0.11857519f, 0.00177940f, -0.01630028f, 0.07012721f, 0.08169668f, 
    0.03478574f, 0.17190593f, 0.08275361f, 0.01849662f, -0.12053670f, 0.00241990f, 0.08263101f, 0.13196507f, 
    0.06644097f, 0.01805519f, -0.12107056f, 0.14623134f, -0.02658897f, -0.00093183f, -0.02379776f, -0.09401988f, 
    0.02081803f, 0.04636060f, 0.16522038f, -0.11597082f, -0.09959887f, -0.03074758f, 0.05522243f, -0.07198332f, 
    0.05840281f, 0.10123730f, -0.13442911f, 0.06961735f, -0.11433273f, -0.19015090f, 0.05565918f, -0.01213177f, 
    -0.01421574f, 0.07105375f, -0.01089088f, -0.11960685f, -0.59924376f, -0.09987386f, 0.02342035f, 0.11255347f, 
    0.04665256f, 0.09529807f, 0.01142517f, -0.03656264f, 0.13772762f, -0.23900431f, -0.16811724f, 0.00665667f, 
    0.02939413f, -0.03978235f, 0.02742609f, 0.09577221f, 0.00382937f, 0.06641078f, 0.01709428f, 0.01606018f, 
    0.01147995f, 0.14590161f, 0.03087445f, -0.01194058f, 0.10785045f, -0.00564609f, 0.05325710f, 0.10918559f, 
    -0.07484524f, 0.02905688f, -0.04989374f, -0.00863707f, -0.00338911f, -0.00474110f, 0.14602698f, -0.08110947f, 
    0.07345837f, -0.03170193f, -0.18717556f, 0.04816919f, -0.02848267f, -0.07285377f, 0.08819622f, -0.05447369f, 
    -0.25257781f, -0.15768754f, 0.03230140f, 0.04895567f, 0.08186112f, -0.01035971f, 0.04817177f, 0.04488118f, 
    -0.09634370f, -0.06623708f, -0.21076049f, -0.00608107f, -0.02323452f, -0.13474062f, 0.05824866f, -0.01725205f, 
    -0.01426143f, -0.13126637f, -0.02644471f, 0.12244749f, -0.00090391f, -0.03401918f, -0.01834590f, 0.05108220f, 
    0.03606967f, -0.00336228f, 0.13868855f, 0.10278928f, -0.13782157f, -0.04813618f, 0.03138491f, 0.04958970f, 
    -0.13092482f, 0.03155619f, 0.12288179f, -0.00867315f, -0.11777649f, 0.01784739f, 0.08056169f, 0.07016408f, 
    -0.03715653f, 0.12179945f, 0.04291838f, 0.04942972f, -0.03606731f, 0.12165479f, -0.14925711f, -0.10520087f, 
    -0.04222625f, 0.07687172f, -0.02169172f, 0.04278608f, -0.14497058f, -0.10720319f, 0.10364000f, -0.06872520f, 
    0.03350006f, -0.01202475f, 0.13709618f, -0.16482604f, 0.04655734f, 0.14163944f, -0.06888903f, 0.03396824f, 
    0.18653893f, -0.06590817f, 0.14237615f, 0.14668109f, 0.09516986f, -0.03823573f, 0.14094318f, 0.13630719f, 
    0.35421255f, -0.07973147f, 0.16422772f, -0.03375098f, -0.10096138f, -0.07504095f, 0.11753147f, 0.06587463f, 
    -0.12385046f, 0.02555012f, -0.13344653f, -0.26378086f, -0.00060668f, 0.01489633f, -0.06477092f, -0.03849692f, 
    0.02942164f, -0.00261397f, 0.03496829f, 0.09807415f, -0.08721717f, -0.08050316f, -0.12795703f, -0.03925937f, 
    0.10597274f, 0.09464412f, 0.14244710f, -0.32396057f, -0.13778511f, -0.16979463f, 0.05007720f, -0.00530589f, 
    0.07591095f, 0.05300448f, 0.09018338f, 0.00933612f, 0.13564461f, 0.05768372f, -0.07979379f, 0.01800397f, 
    0.06302331f, -0.14294802f, 0.00462489f, 0.00859795f, -0.01741055f, -0.05149433f, -0.15533717f, -0.02181474f, 
    0.03645252f, 0.00219950f, -0.10648055f, -0.06417237f, 0.08484154f, 0.00140802f, -0.13226987f, 0.10311645f, 
    0.04458993f, 0.07495111f, -0.02801891f, -0.03673545f, -0.05944332f, 0.00969297f, 0.03257502f, -0.13058169f, 
    -0.00897147f, 0.07442189f, 0.06601068f, 0.04279190f, -0.09398818f, 0.17433026f, 0.04396413f, 0.07222467f, 
    -0.10147698f, 0.04941076f, 0.02188163f, 0.18665296f, 0.06958442f, 0.08021693f, 0.04903784f, 0.04030265f, 
    -0.00671269f, -0.33773360f, -0.29101360f, -0.02039444f, -0.00420806f, 0.08003753f, 0.14312313f, 0.03199815f, 
    0.03546653f, 0.08225732f, -0.09627829f, -0.14915034f, 0.10316501f, -0.00817139f, 0.01363259f, 0.02295069f, 
    0.02589157f, 0.00165950f, 0.00757799f, -0.11651815f, -0.00778788f, -0.07152790f, 0.01237090f, -0.05883403f, 
    0.16319327f, 0.04832242f, 0.03115044f, 0.01434075f, -0.00292824f, 0.12086293f, -0.19375108f, -0.07899207f, 
    -0.10489424f, -0.11073322f, 0.15382482f, 0.08831625f, -0.01692950f, -0.13206156f, 0.00540852f, -0.17603004f, 
    -0.05606188f, 0.14789572f, -0.14275101f, 0.05949607f, 0.01543745f, 0.02932713f, 0.06759109f, -0.20711836f, 
    -0.05233121f, 0.03420236f, -0.11967292f, 0.02229639f, 0.03245902f, 0.06593352f, -0.03735097f, -0.04994136f, 
    0.12712727f, -0.16625971f, 0.06880078f, 0.11149631f, 0.03885334f, -0.01635631f, 0.06530734f, 0.09744976f, 
    0.10769161f, -0.03287578f, -0.10226748f, 0.17282429f, -0.13208538f, 0.12287847f, -0.07510479f, -0.11213653f, 
    0.04930485f, 0.00204933f, 0.21823315f, -0.00787724f, -0.03402736f, -0.06069891f, 0.05303196f, -0.24282075f, 
    -0.01975668f, 0.05273304f, -0.25280628f, 0.04642768f, 0.06420852f, 0.06039398f, -0.04413522f, -0.13488860f, 
    0.00825208f, -0.14508750f, 0.07597214f, -0.34519383f, -0.19335528f, 0.16047585f, -0.02336630f, -0.03105291f, 
    0.04877317f, -0.02160557f, -0.05436212f, 0.14112750f, 0.13790198f, -0.24978489f, 0.02150311f, 0.02644280f, 
    0.08701713f, 0.11876353f, -0.18699932f, -0.04251954f, 0.02128338f, 0.14176832f, 0.04185504f, -0.09426014f, 
    -0.05754023f, -0.07005806f, 0.09066977f, 0.06293263f, 0.05430292f, -0.02719323f, -0.21448801f, 0.04387392f, 
    -0.01128053f, -0.10727891f, -0.05850728f, -0.10488391f, -0.09986046f, 0.03993455f, 0.12738238f, -0.04270299f, 
    0.23670073f, 0.07530068f, 0.00322554f, 0.00346386f, -0.09048799f, 0.02710106f, 0.04405781f, 0.06027265f, 
    -0.15714838f, -0.09113996f, 0.14308067f, -0.03392673f, 0.12588052f, -0.00745580f, -0.03084638f, 0.13925040f, 
    0.01973713f, -0.07298747f, -0.14668268f, 0.06555440f, -0.06348625f, 0.15859629f, -0.06023414f, 0.16097586f, 
    0.07374633f, 0.02571225f, -0.01769541f, 0.14046122f, 0.04564660f, 0.06290544f, 0.14342269f, 0.06192589f, 
    0.00908945f, 0.07515873f, -0.16656992f, 0.11791378f, -0.21962073f, 0.01605659f, -0.05163878f, 0.06643957f, 
    0.04447587f, -0.04585528f, -0.06343745f, -0.05908877f, -0.16473307f, -0.00196322f, -0.01528201f, -0.12467928f, 
    -0.02302210f, 0.04332646f, 0.06709407f, -0.04196465f, -0.00331267f, 0.16020921f, -0.01030125f, -0.18617757f, 
    0.06073843f, -0.03058353f, -0.10530791f, 0.01058914f, -0.04233255f, -0.12708911f, -0.33115724f, -0.06626470f, 
    -0.03942994f, -0.01893230f, -0.10621138f, -0.03330797f, 0.06457899f, 0.00996184f, 0.09708393f, 0.08882493f, 
    0.07428537f, 0.00091596f, -0.06159657f, 0.14258344f, -0.05452855f, 0.16093946f, 0.10782356f, -0.03395737f, 
    0.27548152f, -0.11700691f, -0.11010046f, -0.12291199f, 0.13460176f, 0.04765453f, 0.00580266f, 0.04454850f, 
    -0.02753408f, -0.09406774f, -0.28673908f, -0.03212550f, -0.08056471f, 0.00810189f, 0.06930813f, -0.16500142f, 
    -0.11672236f, -0.13592650f, -0.16745041f, 0.22125530f, -0.02578498f, -0.05269277f, -0.16334623f, 0.03756709f, 
    0.11431883f, 0.03753904f, 0.04070025f, -0.02752238f, -0.10486792f, -0.08339424f, 0.07228855f, 0.05794467f, 
    -0.05281617f, 0.09546076f, 0.13472655f, 0.19486128f, 0.09426328f, 0.25761047f, -0.11113754f, -0.00733721f, 
    -0.01354227f, 0.08403607f, -0.04892737f, 0.12066093f, 0.03758002f, -0.19709121f, -0.12091020f, -0.08850425f, 
    -0.18889984f, -0.04998265f, -0.11487502f, -0.01735345f, 0.05759881f, 0.06170573f, 0.01063086f, -0.04216841f, 
    -0.01334769f, 0.12081651f, -0.07814785f, 0.02657850f, 0.15583926f, -0.05050509f, -0.04758221f, 0.06663913f, 
    -0.04033113f, 0.17098789f, 0.25933206f, 0.05070589f, -0.07190662f, 0.22325543f, 0.09316971f, 0.14308801f, 
    0.13853969f, 0.16312453f, 0.06764732f, 0.04093991f, 0.09213870f, 0.08434390f, -0.23153788f, -0.09127827f, 
    -0.21084687f, -0.19878496f, -0.03474419f, 0.05993095f, 0.07488304f, 0.06564809f, -0.03571068f, 0.02013103f, 
    0.01703838f, 0.00157009f, -0.12865113f, -0.24025214f, 0.07849541f, -0.02967382f, 0.10735191f, 0.11958333f, 
    -0.06776698f, -0.09230819f, 0.10205956f, -0.13773474f, 0.01430684f, -0.03908055f, -0.07798553f, -0.04648682f, 
    -0.01357357f, 0.10059381f, 0.09033012f, 0.00577226f, 0.13543712f, 0.23934630f, -0.02318868f, 0.04276036f, 
    -0.09857208f, 0.01463752f, -0.04548133f, -0.06156746f, -0.18785273f, 0.03709778f, 0.00050260f, 0.06868488f, 
    0.11944275f, 0.09613641f, 0.18498944f, -0.08648969f, -0.12305447f, -0.18061873f, -0.12962051f, -0.09963382f, 
    0.04994914f, -0.06741294f, -0.06799743f, -0.11697504f, -0.03958087f, -0.07083330f, -0.12108419f, 0.10985558f, 
    0.14734299f, -0.10236795f, 0.09363777f, 0.06315411f, -0.11898117f, 0.09847527f, -0.00865478f, 0.08786734f, 
    -0.17519552f, 0.08234590f, -0.04588788f, 0.07792084f, -0.04251606f, 0.04119985f, -0.09045506f, 0.18672395f, 
    0.02729420f, 0.05340688f, -0.18507186f, -0.18380149f, -0.08228860f, 0.01162373f, 0.14108744f, 0.06507499f, 
    -0.04703267f, 0.09160484f, 0.06150276f, -0.06854630f, -0.08814596f, 0.02201846f, 0.10393208f, 0.18674994f, 
    -0.01233486f, 0.05428887f, -0.00409677f, -0.19431382f, 0.09316870f, -0.24299692f, 0.01488198f, 0.03937082f, 
    0.12515698f, 0.04366638f, -0.09687179f, -0.00182816f, 0.15590356f, 0.16387665f, -0.00412990f, 0.02525010f, 
    0.14236295f, -0.04460690f, -0.04158623f, -0.13115071f, 0.04276438f, 0.05845665f, 0.04964713f, -0.01889071f, 
    0.01408474f, -0.02262893f, 0.11743847f, 0.11783142f, 0.08805616f, -0.18373907f, 0.10345013f, 0.04030372f, 
    -0.03013473f, -0.17659691f, -0.04229850f, 0.07236350f, 0.06030575f, 0.02323752f, -0.08369119f, 0.09433699f, 
    0.02372407f, -0.13638324f, -0.22926004f, -0.08752123f, 0.00605011f, -0.05374343f, 0.05444623f, 0.03676612f, 
    -0.28123051f, -0.17058541f, -0.03180506f, 0.07463043f, 0.06818946f, 0.05645486f, 0.00993285f, 0.01113590f, 
    0.06457488f, -0.24927175f, -0.00073597f, -0.05017268f, 0.02863014f, 0.02975342f, -0.01338802f, -0.12199579f, 
    -0.00832526f, -0.00708358f, -0.20422423f, -0.11732306f, -0.01278519f, -0.15733330f, 0.12608761f, 0.10252116f, 
    -0.06426065f, -0.01031795f, 0.03784164f, 0.10443190f, 0.02401822f, 0.01665383f, 0.06175836f, -0.06554238f, 
    0.06727462f, -0.08185770f, 0.06784820f, -0.03822226f, -0.01016829f, 0.13066573f, -0.00028842f, -0.05312116f, 
    -0.13534731f, -0.02903721f, 0.08589692f, 0.01949912f, -0.00981372f, -0.11513629f, 0.19238172f, 0.17031163f, 
    0.10005556f, -0.09701320f, -0.12682420f, -0.00003303f, 0.05308331f, -0.04671119f, -0.12332311f, 0.10019004f, 
    -0.15933709f, -0.00625437f, -0.10730693f, -0.10645285f, -0.09297808f, 0.00816128f, 0.03592990f, 0.28182769f, 
    0.11566893f, -0.01009775f, -0.08523931f, -0.02426968f, 0.04630611f, -0.01741911f, 0.00469006f, -0.05597466f, 
    -0.03557472f, -0.08644573f, -0.08380252f, -0.10027883f, -0.01133884f, -0.05909778f, -0.00144388f, 0.06680248f, 
    -0.02949541f, 0.34166130f, 0.20144981f, -0.01522661f, 0.08821586f, -0.05095808f, 0.04693540f, -0.00699435f, 
    -0.08561872f, 0.00193980f, 0.26843265f, 0.07706166f, 0.03537076f, -0.00274061f, 0.11408655f, 0.04943356f, 
    0.04567333f, 0.08014987f, -0.06770782f, -0.44770470f, 0.05725763f, 0.10184812f, 0.04996103f, 0.02596582f, 
    0.09732495f, 0.07079360f, 0.02714244f, -0.04116212f, -0.11855887f, 0.03510503f, -0.01011717f, -0.18765379f, 
    -0.08597137f, -0.04464630f, -0.02791278f, -0.00007191f, 0.12049036f, -0.38036606f, -0.02062668f, 0.03398320f, 
    0.03706471f, -0.01886087f, 0.08278541f, 0.04048124f, -0.07176977f, 0.00273322f, 0.05550905f, -0.02324038f, 
    -0.18920088f, -0.04754615f, -0.05441127f, 0.01344652f, -0.00696859f, 0.14248633f, 0.05101974f, 0.01350678f, 
    -0.08123958f, -0.02930710f, -0.01611565f, -0.14126845f, 0.08202998f, -0.08552640f, 0.07759703f, 0.04909187f, 
    -0.10686285f, 0.20113090f, 0.12682666f, -0.11195090f, 0.07466754f, 0.00599964f, 0.00289915f, -0.03435603f, 
    0.05066527f, -0.30496144f, -0.18344651f, 0.10176716f, 0.02786643f, 0.14753343f, 0.09348395f, -0.10180093f, 
    -0.13055030f, -0.07670087f, -0.02066827f, 0.00456495f, -0.10472448f, 0.08788603f, 0.10693402f, 0.09132962f, 
    0.03613226f, -0.11417855f, 0.01381773f, -0.06853721f, 0.05590880f, 0.02733737f, -0.00182057f, 0.02732486f, 
    0.10776486f, 0.04233521f, -0.02118865f, 0.02818009f, 0.07866115f, -0.14834489f, 0.02937114f, 0.15307671f, 
    -0.06083689f, 0.10428929f, 0.07976071f, -0.10923352f, 0.12706964f, -0.24736255f, -0.01897726f, 0.08840277f, 
    -0.12456346f, 0.04462012f, 0.15593551f, -0.00957478f, -0.01788284f, -0.06683067f, -0.11438182f, 0.08483883f, 
    0.13214520f, -0.13777478f, 0.04600533f, -0.23841701f, -0.16760011f, 0.13746339f, -0.06791709f, 0.25599808f, 
    0.06882106f, -0.12880644f, -0.04669207f, -0.05723611f, 0.07157654f, -0.03285150f, -0.02407041f, -0.06530018f, 
    0.00050789f, -0.03577693f, 0.03875885f, 0.02097179f, -0.01379674f, -0.04538286f, -0.01962903f, -0.05433841f, 
    0.03216164f, 0.01330008f, 0.05600464f, -0.04823771f, 0.02727873f, -0.05302155f, -0.07137097f, -0.00951625f, 
    0.04757887f, -0.01440579f, -0.02239198f, -0.00434606f, 0.03258590f, -0.04474260f, 0.01908377f, -0.02742854f, 
    -0.00446489f, -0.03007135f, -0.04358930f, -0.01595664f, 0.04135908f, -0.03683208f, 0.02270840f, 0.00857949f, 
    -0.00517523f, 0.00379909f, 0.03223816f, -0.04064647f, -0.05624230f, 0.04861585f, -0.03171273f, -0.03927555f, 
    -0.05670817f, 0.04326572f, 0.02516682f, 0.02522274f, 0.03832525f, 0.00075702f, -0.05120942f, -0.04263101f, 
    -0.04919465f, 0.03535523f, 0.05716463f, -0.04393811f, 0.00100547f, -0.03516765f, -0.06001299f, -0.03864926f, 
    -0.06180330f, 0.04926940f, 0.04008352f, -0.05608712f, 0.04517746f, -0.04384096f, 0.03279258f, -0.04187465f, 
    -0.03845701f, 0.01204426f, -0.02583316f, -0.03780852f, 0.00593417f, 0.01456835f, 0.04124356f, 0.04954064f, 
    -0.01342841f, -0.04970654f, -0.05160630f, -0.01257559f, -0.04715670f, -0.02111079f, 0.02609628f, 0.03491373f, 
    -0.03984869f, 0.03216650f, -0.06125478f, 0.05946007f, 0.05196537f, 0.01298026f, 0.01564078f, -0.02321992f, 
    -0.01786133f, -0.01650704f, 0.00154108f, -0.00631083f, -0.03178495f, 0.02037423f, -0.03359654f, 0.00976192f, 
    -0.01905862f, 0.04494169f, 0.03587999f, 0.04715944f, 0.02172857f, 0.03382154f, 0.00192964f, 0.01018735f, 
    0.01008211f, 0.00497297f, 0.03915611f, -0.03035186f, -0.00378057f, 0.03673749f, 0.01050064f, -0.01433733f, 
    -0.02705896f, 0.03883232f, -0.00038346f, -0.00815881f, 0.00100960f, 0.01930006f, -0.01653640f, 0.00346214f, 
    0.02828354f, 0.03942507f, 0.01698558f, 0.01626927f, -0.02419705f, -0.04814421f, 0.05690627f, -0.00036588f, 
    -0.03595536f, -0.05247687f, 0.04879203f, 0.06007480f, -0.04959326f, 0.05228330f, -0.02275843f, -0.02701674f, 
    -0.06126856f, 0.02093260f, -0.05150671f, -0.00068024f, 0.05400641f, -0.03831540f, -0.05061882f, -0.01795681f, 
    0.01115688f, 0.00959441f, 0.03361846f, 0.03745935f, -0.02931840f, 0.02530853f, -0.03339862f, 0.00975546f, 
    -0.05111343f, -0.00434601f, -0.03947805f, -0.01333524f, 0.01672100f, 0.03604019f, -0.02346130f, 0.03291178f, 
    0.00839714f, -0.03766763f, -0.05160084f, 0.03089958f, -0.02011837f, 0.02405389f, 0.01994688f, -0.05403599f, 
    0.00525940f, -0.03653699f, -0.04576811f, 0.04252287f, 0.04689614f, -0.02126799f, -0.05462591f, 0.02873771f, 
    -0.00864963f, 0.01289000f, -0.04691478f, 0.05584544f, -0.03617916f, 0.04952334f, 0.04899141f, -0.03945415f, 
    -0.00116754f, -0.01911365f, -0.05051939f, 0.00064561f, -0.00471797f, -0.00104264f, 0.00432310f, -0.00936197f, 
    0.02685616f, 0.01817454f, -0.02156001f, -0.02515048f, -0.05800284f, -0.03329119f, 0.04035481f, 0.03134148f, 
    -0.00991134f, 0.03116078f, 0.03829727f, 0.04198102f, -0.05450674f, 0.00101502f, 0.02718738f, 0.02191265f, 
    0.04903376f, 0.03560794f, -0.04251262f, -0.00020170f, -0.04514829f, -0.01390705f, -0.04313624f, 0.03105765f, 
    0.01327782f, -0.03922928f, -0.05200250f, -0.06237926f, 0.04121959f, -0.04607851f, -0.01317432f, -0.01499781f, 
    0.00380040f, -0.00519393f, 0.00131512f, -0.01051547f, -0.01076775f, -0.03956979f, -0.06200742f, -0.02155849f, 
    0.05086556f, -0.01952299f, -0.02688991f, -0.02376542f, 0.03421133f, 0.04610203f, -0.01076982f, 0.04843429f, 
    -0.00142618f, -0.03762883f, -0.04213301f, 0.03912654f, 0.02780995f, 0.03633594f, 0.04428419f, 0.02681633f, 
    0.01019590f, 0.03062861f, 0.03044292f, -0.04096242f, -0.00434960f, -0.02805132f, -0.02232603f, 0.02272129f, 
    -0.06256713f, -0.04528712f, -0.00295337f, -0.00815841f, -0.03516196f, 0.02083226f, -0.04636247f, -0.05683843f, 
    0.02007208f, -0.05846782f, -0.05295278f, -0.03271599f, 0.00496328f, -0.02041290f, -0.00202364f, -0.01694109f, 
    0.02176082f, -0.01467791f, -0.05322109f, -0.03513609f, -0.05263908f, -0.01121221f, 0.00777214f, 0.01384611f, 
    -0.02786893f, -0.00730963f, 0.02446483f, -0.06870882f, -0.03086005f, -0.04795140f, 0.01835287f, -0.03724387f, 
    0.09016624f, 0.05792207f, 0.09156673f, 0.05023339f, 0.22259690f, -0.00577500f, 0.05583965f, -0.06687444f, 
    0.05940130f, -0.18203264f, -0.40466598f, -0.08667491f, -0.00539835f, -0.04184744f, -0.01303798f, 0.04778896f, 
    0.05136321f, 0.02476693f, 0.20261410f, -0.06684275f, -0.09383655f, 0.06607740f, 0.09403169f, 0.03240193f, 
    -0.08697261f, 0.06420870f, 0.15181234f, 0.30685595f, 0.02555402f, 0.00120165f, -0.04500058f, 0.02744223f, 
    0.17689636f, 0.00043228f, 0.03401225f, 0.03429445f, 0.13758853f, 0.08243307f, 0.03474247f, 0.08178397f, 
    -0.04134371f, 0.06567569f, 0.04623820f, -0.03316324f, 0.09450408f, 0.08447149f, 0.04452884f, 0.06456634f, 
    0.07372811f, -0.02846290f, 0.07540283f, 0.05117497f, -0.05868962f, -0.09238495f, -0.02420711f, 0.00912369f, 
    -0.05122454f, -0.07311872f, 0.05543103f, 0.01728051f, -0.06206064f, 0.06171242f, -0.07906320f, 0.22196825f, 
    -0.11995693f, -0.05261052f, -0.08483840f, -0.07702536f, 0.06033026f, 0.07232913f, 0.01590957f, -0.04043579f, 
    0.20020473f, 0.15467535f, 0.10625125f, 0.00018603f, -0.12188520f, 0.06302126f, 0.16587467f, -0.00383978f, 
    -0.03887552f, -0.14690833f, -0.08216684f, 0.08179724f, -0.11522000f, -0.00494144f, -0.02639874f, 0.17114627f, 
    -0.14908780f, 0.10829626f, 0.12041576f, 0.00013735f, -0.09581166f, -0.06225688f, 0.00081579f, 0.07247335f, 
    0.02546538f, -0.01475316f, -0.15716092f, 0.10588803f, -0.01078383f, -0.02954331f, 0.07875029f, -0.12583141f, 
    -0.00144010f, -0.01647010f, 0.00098499f, -0.01876216f, -0.22444935f, 0.10971795f, -0.05656438f, -0.06103013f, 
    -0.00204462f, 0.02315355f, -0.06431694f, -0.15009147f, 0.07735927f, -0.43270901f, 0.14103833f, 0.32697508f, 
    0.07464301f, -0.03955604f, -0.04895692f, -0.07786009f, 0.02018208f, 0.10625384f, 0.39062172f, 0.14593108f, 
    -0.05045583f, -0.10343621f, 0.01299041f, -0.00362638f, -0.03973150f, 0.02313562f, -0.09737368f, -0.24736696f, 
    -0.14094752f, -0.08946492f, -0.19323036f, -0.04465960f, -0.13782136f, 0.14183645f, -0.00334327f, -0.05887740f, 
    -0.05655790f, 0.13184848f, -0.04670954f, -0.08148982f, -0.02313549f, -0.00169186f, -0.21008131f, 0.04643438f, 
    0.03188922f, 0.19536786f, -0.07718173f, -0.16976860f, 0.11128987f, -0.00638907f, -0.00299585f, 0.15388343f, 
    0.09893321f, -0.07185840f, 0.10140564f, -0.04661013f, 0.10840049f, -0.03029788f, -0.01656421f, -0.06366597f, 
    -0.13712598f, 0.01931324f, -0.02702197f, 0.06997101f, -0.10176739f, 0.01185052f, -0.03734117f, -0.02945954f, 
    0.11410201f, 0.01584234f, -0.00311583f, 0.03029163f, 0.01514658f, 0.23588841f, -0.00018412f, -0.13209529f, 
    -0.10028678f, -0.03356135f, 0.03216537f, 0.00783147f, -0.04915405f, 0.33253351f, 0.01915150f, 0.02875427f, 
    -0.12863512f, 0.06441627f, 0.04528536f, -0.26328298f, -0.00355172f, -0.05768511f, -0.28370729f, -0.05313007f, 
    0.11934678f, -0.01065339f, 0.03484585f, 0.01238655f, -0.04056178f, 0.06532705f, 0.04262662f, -0.10494597f, 
    0.05665325f, 0.04772135f, 0.02677500f, -0.12734312f, -0.09484719f, -0.06530672f, 0.02969515f, 0.10892302f, 
    -0.21966384f, 0.00002045f, -0.14060909f, 0.12464043f, 0.08024240f, 0.01404798f, -0.15432532f, -0.10198766f, 
    -0.13715582f, 0.25012657f, 0.11518492f, 0.10492856f, 0.07502005f, -0.06236875f, 0.03198579f, 0.00320037f, 
    0.07211799f, 0.00765945f, 0.38615805f, 0.17374587f, 0.01331109f, 0.01261916f, -0.06515793f, 0.00283832f, 
    0.11759961f, -0.04861218f, -0.01261363f, 0.06202064f, 0.03349929f, 0.06688459f, -0.04264510f, -0.03519278f, 
    0.02858046f, -0.12928498f, 0.04711930f, -0.07452741f, 0.21823263f, 0.04667415f, -0.12483779f, -0.04860494f, 
    0.02948702f, 0.06361756f, 0.09184766f, 0.00608231f, 0.10398869f, -0.08342222f, 0.01041091f, -0.22495528f, 
    0.04663046f, 0.15000094f, -0.02045512f, 0.01196867f, -0.01621661f, 0.00856532f, -0.14345746f, -0.05165485f, 
    0.18937500f, 0.06534956f, -0.11526680f, 0.04612992f, -0.00721652f, 0.08335888f, -0.02920661f, -0.22105241f, 
    -0.11625417f, -0.05496583f, -0.20234734f, 0.00487419f, -0.14140317f, 0.08216840f, -0.05772145f, 0.04691206f, 
    0.02709489f, 0.00077856f, -0.03350880f, -0.01514661f, -0.06225201f, 0.04368960f, -0.00713083f, -0.00676354f, 
    -0.04607790f, 0.00584298f, 0.04519083f, -0.05908285f, 0.04492716f, 0.00780119f, 0.03793545f, -0.01569589f, 
    -0.06049633f, -0.04524622f, -0.02397824f, -0.01402976f, -0.02497200f, 0.03787662f, 0.02653510f, 0.01796907f, 
    -0.04103878f, -0.03737812f, -0.03927835f, 0.00625077f, 0.05094140f, 0.02275135f, 0.00584245f, -0.06404474f, 
    0.03963966f, 0.01976327f, 0.04429977f, -0.00442795f, -0.03144336f, 0.02214282f, 0.00369113f, -0.05317431f, 
    -0.01030101f, -0.01806786f, 0.02711500f, -0.01134823f, 0.00581117f, 0.01776758f, -0.04524323f, -0.05791988f, 
    -0.05342517f, -0.04835986f, -0.04059307f, -0.05329254f, 0.03610454f, -0.07075595f, -0.02216476f, 0.03267051f, 
    0.03863918f, 0.01779456f, -0.01157675f, -0.05901046f, 0.03496167f, -0.02643110f, 0.04507359f, -0.06163867f, 
    -0.01743265f, -0.02605877f, -0.01526236f, -0.04745844f, -0.02666055f, -0.02921377f, -0.05382212f, -0.03824843f, 
    -0.05621187f, 0.03006720f, -0.01523061f, 0.02013393f, 0.00713399f, -0.01950139f, -0.00565682f, -0.03817726f, 
    -0.03054460f, 0.02594123f, -0.06396304f, -0.04858572f, -0.00733835f, -0.04444809f, 0.02121797f, 0.01490848f, 
    -0.03086844f, 0.03601035f, 0.03635639f, 0.03180845f, -0.03242192f, 0.03094375f, 0.03407674f, -0.00306963f, 
    0.01025211f, -0.04005437f, 0.02294511f, 0.04063456f, 0.04247164f, -0.03183050f, -0.05287278f, 0.04535609f, 
    -0.01998214f, 0.03907267f, -0.06580082f, -0.05915291f, -0.02024036f, -0.03455194f, -0.00945449f, 0.03410319f, 
    0.01940772f, -0.05874130f, 0.04433519f, -0.03858462f, 0.04166711f, 0.04371208f, 0.01976516f, -0.01150582f, 
    -0.04732307f, 0.04073390f, -0.05163557f, 0.04159873f, -0.06135092f, -0.00882731f, -0.03022558f, 0.01649844f, 
    -0.01251245f, 0.01284138f, 0.03190351f, -0.02016283f, 0.02532057f, -0.02570876f, -0.06344381f, -0.04552047f, 
    0.04223549f, 0.03789674f, -0.00735840f, -0.03474200f, 0.01017146f, -0.01634760f, 0.03501246f, -0.04097242f, 
    -0.02954309f, -0.06528255f, 0.04341793f, -0.04390518f, 0.02828158f, 0.01625278f, 0.02084420f, -0.06401540f, 
    0.03507926f, -0.02713755f, -0.03113599f, 0.00591131f, 0.01073924f, -0.07024603f, 0.00373253f, -0.00130369f, 
    -0.04815366f, -0.05454982f, -0.00302778f, -0.01234071f, -0.05949159f, 0.00033096f, -0.02137750f, 0.03467945f, 
    -0.04841621f, 0.03441706f, -0.00407918f, -0.04532392f, 0.01476055f, -0.03933435f, -0.00346202f, -0.04418613f, 
    -0.05736212f, -0.01667904f, -0.04090763f, -0.03639251f, -0.03592644f, -0.01890816f, 0.03900329f, -0.05371490f, 
    0.00130608f, 0.00343906f, 0.01403835f, 0.04163060f, -0.05971600f, -0.05824716f, 0.03195247f, -0.05083782f, 
    -0.01635126f, -0.04977970f, 0.04091066f, 0.02281200f, -0.02909162f, -0.00584498f, 0.04025973f, 0.01711721f, 
    -0.04261648f, 0.03476800f, 0.02609086f, 0.03901834f, -0.03569276f, -0.01562522f, 0.00461964f, -0.01022027f, 
    -0.03724315f, -0.02991140f, -0.02062722f, -0.01778194f, -0.01615105f, -0.04549224f, -0.02989261f, -0.02447931f, 
    0.02419175f, 0.04854234f, -0.00665757f, 0.03705413f, -0.06757881f, 0.02193713f, -0.00174712f, 0.02831072f, 
    0.01181493f, 0.00856711f, 0.03104330f, -0.04658266f, -0.01915270f, -0.05916249f, 0.04499085f, 0.00318313f, 
    -0.05371909f, -0.04956162f, 0.04245822f, 0.02993395f, -0.06536559f, -0.00032565f, -0.05326373f, 0.02732177f, 
    -0.00457947f, 0.00092968f, 0.02247428f, 0.04914746f, -0.02678337f, -0.00033816f, 0.01389959f, -0.06339724f, 
    -0.00215316f, -0.00939945f, 0.04012436f, 0.04832887f, 0.03176620f, -0.03301439f, -0.04195881f, -0.01465448f, 
    0.04451274f, -0.01657452f, 0.02730373f, 0.00542942f, -0.02000665f, -0.00867613f, -0.04352583f, 0.03314079f, 
    0.00887122f, -0.04540012f, 0.02992348f, -0.00444074f, 0.02061006f, -0.02905667f, -0.01604594f, -0.04691453f, 
    -0.02772006f, 0.00793303f, 0.02948533f, -0.00319738f, 0.04746751f, -0.05066726f, -0.05290514f, -0.05701875f, 
    -0.00811658f, -0.06158620f, -0.04613292f, -0.00026299f, -0.04583449f, 0.03106202f, -0.00609274f, 0.02681334f, 
    -0.05864317f, -0.21774386f, 0.01461221f, -0.00765391f, 0.02781299f, -0.00216732f, -0.03467364f, 0.12253914f, 
    -0.03197369f, 0.11463039f, 0.00503281f, -0.17581692f, 0.15647632f, -0.11275116f, 0.07691809f, 0.10040791f, 
    -0.10509031f, 0.15316297f, 0.17577936f, 0.14917606f, 0.07306512f, 0.05743181f, 0.00675403f, 0.18938528f, 
    0.02161051f, 0.13319032f, 0.28868523f, -0.33477667f, 0.06268599f, 0.23087467f, 0.05431423f, 0.16894311f, 
    -0.04979585f, 0.03418689f, -0.05388152f, -0.08794299f, -0.14671360f, -0.05163232f, 0.22816834f, 0.18963179f, 
    0.12737253f, -0.28555506f, -0.03694210f, 0.05717708f, -0.08307814f, 0.09174667f, -0.07585985f, 0.02094993f, 
    -0.00917252f, 0.02196675f, 0.02628022f, 0.04539161f, 0.14867391f, 0.06701281f, 0.23363158f, -0.07931732f, 
    -0.06718051f, -0.00238052f, -0.04914716f, -0.11464122f, 0.04003663f, 0.07697748f, -0.10520135f, 0.15529205f, 
    0.02669878f, 0.19100851f, -0.02505363f, -0.19690408f, 0.07878035f, -0.04815380f, -0.15875259f, 0.21727815f, 
    -0.22768725f, 0.10193335f, 0.25948271f, 0.14850199f, 0.11798021f, -0.02811437f, -0.09606958f, 0.06501442f, 
    -0.00945301f, -0.08465011f, -0.01285456f, -0.10884663f, 0.03969036f, -0.06204356f, 0.11793350f, 0.08953746f, 
    -0.02895731f, -0.01329050f, 0.00777814f, -0.13125807f, 0.11908948f, -0.00508013f, -0.10840594f, 0.14260791f, 
    -0.02345877f, -0.19836490f, 0.10425710f, -0.10631119f, 0.08043230f, -0.11001667f, 0.00878640f, -0.04942377f, 
    0.00671805f, 0.03061679f, 0.07871523f, 0.08475988f, 0.07770797f, 0.00033971f, -0.08556083f, -0.02432361f, 
    -0.02610665f, 0.00106665f, 0.01848590f, 0.05649402f, -0.11042500f, 0.16514510f, -0.13311982f, -0.03889637f, 
    -0.01784915f, -0.06344450f, -0.21310110f, 0.03879244f, -0.05451837f, -0.14098908f, -0.15815936f, 0.09707935f, 
    -0.07922627f, 0.02708217f, -0.09010223f, -0.04533675f, 0.04711878f, -0.06751395f, -0.06377478f, 0.10856912f, 
    -0.20322484f, -0.17494412f, 0.00989320f, 0.02790321f, -0.06318548f, 0.12989214f, -0.00147675f, -0.05934126f, 
    0.40752152f, 0.05278070f, 0.11538613f, -0.18784069f, -0.10559449f, -0.03850219f, -0.00998916f, 0.06961314f, 
    0.16832836f, -0.19839130f, -0.02214612f, -0.01254088f, 0.12089530f, 0.10609858f, -0.09535722f, -0.03966705f, 
    0.15015459f, -0.09100161f, 0.17495455f, -0.07822993f, 0.20862517f, -0.03869569f, -0.00389793f, -0.03206434f, 
    -0.00563372f, 0.07457294f, -0.02211221f, -0.03493780f, 0.11433014f, -0.08984622f, 0.01664089f, -0.02682965f, 
    0.06366657f, 0.16361773f, 0.10059411f, 0.01992248f, 0.11819743f, -0.09757168f, 0.20673969f, 0.01117914f, 
    -0.09595636f, -0.03726135f, 0.08495186f, -0.02604678f, -0.07204566f, -0.22569022f, 0.15604207f, 0.09142368f, 
    -0.02126418f, -0.11552081f, 0.23358031f, 0.04713287f, 0.07369485f, 0.01703882f, -0.00769338f, 0.05353692f, 
    -0.20047596f, 0.16313702f, 0.01198572f, 0.10890374f, 0.11837684f, -0.00686287f, 0.05172508f, -0.23523672f, 
    0.13905740f, -0.21292937f, -0.08471707f, 0.11565375f, 0.17768556f, 0.13048746f, 0.08441041f, 0.03523602f, 
    0.29800522f, 0.07914779f, 0.33874434f, 0.00928874f, -0.07109535f, -0.09572972f, 0.21485628f, 0.10623138f, 
    0.01232344f, -0.12333375f, 0.11781847f, 0.21105270f, -0.07206913f, 0.09474833f, 0.12833712f, 0.04554126f, 
    0.17793486f, 0.07983448f, -0.02143302f, 0.10446646f, 0.14623700f, 0.04215568f, 0.01861885f, 0.02764464f, 
    0.01266637f, 0.00509686f, 0.01438234f, -0.05707897f, -0.09589877f, -0.03518265f, -0.00553881f, 0.00281535f, 
    0.08617537f, 0.04566275f, 0.07115144f, -0.15250166f, 0.15090205f, 0.08914445f, 0.20986143f, 0.02322984f, 
    0.04778716f, 0.05420638f, -0.04445510f, 0.01931742f, 0.15925081f, 0.00842720f, 0.04977799f, 0.03685404f, 
    0.08105487f, -0.12225651f, 0.08811838f, 0.10248388f, 0.10534375f, 0.11297209f, 0.08035398f, -0.33848017f, 
    -0.04339025f, -0.27042297f, 0.30149430f, -0.10126364f, 0.00970382f, -0.10505255f, 0.09807062f, -0.01864137f, 
    -0.21457514f, 0.03163834f, -0.08328564f, 0.08162979f, -0.00376999f, -0.01530848f, 0.04733193f, 0.14277227f, 
    0.12129010f, -0.09118156f, -0.15913512f, 0.12998083f, 0.13239424f, -0.03530765f, -0.02891847f, -0.02250608f, 
    -0.04009048f, -0.13467103f, -0.12332583f, 0.02391745f, 0.04955973f, -0.09482829f, -0.01975660f, 0.11075140f, 
    -0.03766670f, -0.02184487f, 0.02687475f, -0.10621947f, 0.04473440f, -0.06331724f, 0.13365901f, -0.11401737f, 
    -0.01068460f, -0.01577108f, -0.00121547f, 0.07835869f, -0.07019092f, 0.05878425f, 0.14340705f, 0.02706842f, 
    0.05344268f, 0.04096266f, -0.16391596f, -0.01715429f, 0.04655506f, 0.04064589f, 0.10642162f, 0.18780585f, 
    0.12629528f, 0.12876485f, -0.10940295f, -0.05889748f, 0.06833973f, 0.23794600f, 0.11188859f, 0.05586474f, 
    -0.01050090f, 0.08618168f, 0.11680178f, 0.09211417f, 0.08237509f, 0.00281573f, 0.06904238f, -0.04362226f, 
    -0.15301566f, -0.06888286f, -0.05275726f, -0.05642908f, 0.08207818f, 0.01241483f, 0.15583836f, -0.00723002f, 
    0.09280196f, -0.13423389f, 0.07225885f, -0.25639093f, -0.07683492f, 0.08813013f, 0.15224990f, -0.00375491f, 
    -0.33356556f, -0.30593550f, -0.03822817f, 0.05301455f, -0.01949097f, 0.06422196f, -0.03467387f, 0.08560632f, 
    -0.03742931f, -0.12222160f, -0.19744197f, -0.11952011f, -0.13262346f, 0.09805645f, 0.01177721f, 0.02589005f, 
    0.02332973f, 0.20212916f, -0.17476851f, -0.04438350f, -0.03844523f, -0.00955392f, -0.06583165f, 0.11983221f, 
    -0.04451743f, -0.07401574f, 0.00879488f, 0.05020526f, 0.02622810f, 0.10940485f, 0.02485012f, 0.08377770f, 
    -0.01971805f, -0.03581044f, 0.14033315f, 0.08221008f, 0.23750687f, -0.04540438f, -0.04853858f, -0.11870492f, 
    -0.09542413f, -0.02164337f, 0.25379252f, -0.00578787f, 0.01248338f, 0.03650044f, 0.04411526f, -0.03847437f, 
    0.02104002f, -0.09956218f, -0.01470947f, -0.12782891f, 0.12162440f, 0.04893475f, -0.37485477f, -0.07895163f, 
    -0.17410387f, -0.08370438f, 0.02262011f, -0.01872676f, -0.01849251f, 0.11665741f, 0.09409364f, 0.15786164f, 
    0.13324195f, -0.00627359f, 0.01545919f, -0.02049934f, -0.00473798f, -0.14530048f, -0.00574808f, -0.08195857f, 
    0.28161129f, -0.03270941f, -0.04177645f, 0.04971684f, -0.18590310f, 0.06573420f, -0.05186644f, 0.08158182f, 
    0.21674697f, 0.23255464f, 0.21478505f, 0.13747041f, 0.10638074f, -0.09691424f, -0.00458032f, 0.02820296f, 
    -0.00160650f, 0.05287610f, 0.08777523f, 0.13283415f, 0.15043613f, 0.01928375f, -0.00903368f, -0.08334044f, 
    0.12512869f, 0.04426948f, 0.08994780f, -0.14150701f, -0.19888178f, -0.03003432f, 0.08603608f, 0.13785861f, 
    0.09049666f, 0.06590461f, -0.01976087f, -0.02840780f, -0.02084190f, -0.00408896f, -0.15596054f, -0.17099269f, 
    -0.12876277f, 0.05186842f, -0.06550305f, 0.08730388f, 0.09031232f, -0.30887678f, -0.25810859f, -0.11499392f, 
    0.07186820f, -0.00275099f, -0.02400337f, -0.05036380f, -0.10088465f, -0.03052575f, 0.10775121f, -0.06242375f, 
    -0.21049060f, -0.09055486f, 0.14954288f, 0.02481864f, -0.00849960f, -0.09096741f, -0.07597788f, 0.10218306f, 
    -0.08081461f, 0.00131571f, -0.04525268f, 0.03253839f, -0.01137730f, -0.05894217f, 0.08668727f, -0.07374665f, 
    0.01326407f, 0.30514744f, 0.06866958f, 0.01983605f, 0.03602507f, 0.08490132f, -0.09089513f, -0.14543980f, 
    -0.14536877f, -0.58206177f, -0.45134282f, 0.00225575f, 0.06962328f, 0.12715755f, 0.07738150f, -0.02833681f, 
    -0.11782853f, -0.01649306f, -0.16259776f, -0.17646308f, 0.01034262f, 0.13477077f, 0.12043699f, 0.03924456f, 
    -0.04712903f, -0.04909187f, -0.05683896f, -0.36085856f, -0.12940219f, -0.05963768f, -0.01480718f, 0.16956151f, 
    0.03008506f, 0.07730160f, -0.01244198f, 0.04805412f, 0.00914998f, 0.04203801f, 0.04951581f, 0.11198750f, 
    0.00216049f, 0.00535889f, 0.23035617f, -0.11301596f, 0.08481520f, -0.19710901f, -0.02928993f, 0.07293516f, 
    -0.03015028f, -0.01411072f, 0.14439416f, -0.03945278f, -0.19891898f, 0.00176342f, -0.00540381f, 0.05855413f, 
    0.01227217f, -0.03842665f, -0.10538039f, -0.15925905f, 0.04185601f, 0.20390865f, -0.15064169f, 0.24979569f, 
    0.09912112f, 0.04876472f, 0.00218069f, -0.05508717f, -0.10124420f, -0.03053026f, 0.05809418f, -0.07969473f, 
    0.12960039f, -0.00854447f, 0.07229218f, -0.10948846f, -0.02977533f, 0.02487716f, -0.06916146f, -0.19231577f, 
    0.03801445f, -0.36397034f, 0.08709216f, 0.34037685f, 0.04421940f, 0.02871574f, 0.11259663f, -0.15076967f, 
    0.03922765f, -0.06723448f, 0.01635459f, 0.24376130f, 0.15734261f, -0.17142957f, -0.00077327f, 0.16829610f, 
    -0.04457073f, -0.04897225f, 0.07295732f, -0.27994063f, -0.18747318f, 0.04053946f, 0.07286244f, -0.01971609f, 
    0.10804693f, -0.00607462f, -0.03856589f, 0.01252863f, 0.10178295f, -0.38077575f, 0.09951378f, 0.01930120f, 
    0.07379570f, 0.05820865f, 0.02104555f, 0.05883107f, -0.10377800f, 0.02436565f, 0.10131232f, 0.02141832f, 
    -0.21669436f, -0.00833107f, -0.10423468f, -0.03246326f, -0.03570783f, 0.03331248f, -0.13320288f, 0.16554421f, 
    0.03671899f, -0.00444682f, 0.08786584f, -0.14846170f, 0.02347533f, -0.09455854f, 0.11425990f, -0.14316674f, 
    0.23601660f, 0.11454868f, 0.10539767f, 0.00274841f, -0.01226003f, 0.18964094f, -0.03604116f, 0.03612782f, 
    0.03231580f, -0.22357106f, 0.15274666f, -0.03322820f, 0.12560883f, -0.02398973f, -0.08637624f, -0.03337340f, 
    0.00578480f, 0.02891493f, 0.01875952f, 0.18710762f, -0.06853488f, -0.05434341f, -0.00924351f, -0.16512766f, 
    0.12114201f, -0.05095412f, -0.09987476f, 0.24671280f, -0.15204489f, 0.16753915f, -0.08322378f, -0.02326565f, 
    0.00882403f, -0.07558868f, -0.01613702f, 0.26688829f, -0.21183157f, -0.11895569f, 0.05654901f, 0.01333950f, 
    -0.07036606f, 0.03419161f, 0.06596766f, 0.07909694f, 0.05926362f, 0.21054181f, 0.06080926f, 0.09104414f, 
    -0.13748315f, -0.10550612f, -0.06869207f, 0.04728884f, -0.09434640f, -0.02561791f, 0.07066789f, 0.05892892f, 
    -0.19491270f, 0.09590327f, 0.00242575f, -0.13081844f, 0.07039192f, 0.03450911f, 0.07242329f, -0.30007198f, 
    0.02999531f, 0.03960808f, -0.05537882f, 0.07037568f, 0.04557451f, 0.10374863f, -0.05355953f, -0.07459645f, 
    0.24240093f, 0.19049342f, -0.04350985f, 0.11190017f, -0.07706687f, -0.05127340f, 0.02352536f, 0.02026167f, 
    -0.09391292f, 0.00068191f, -0.06461594f, 0.05454545f, -0.22194919f, -0.10968105f, 0.00673011f, -0.06332245f, 
    -0.11206134f, 0.04214118f, -0.44572583f, -0.29765862f, -0.03265551f, 0.14746530f, 0.03057995f, 0.12249621f, 
    -0.10281112f, 0.01888419f, -0.20794123f, 0.30035681f, -0.04358110f, -0.00732640f, -0.00473995f, -0.05559853f, 
    -0.00712226f, -0.10333231f, 0.07769615f, -0.04218708f, -0.01109548f, -0.04467887f, -0.11907081f, -0.09615479f, 
    -0.10954403f, -0.04324865f, 0.23581547f, -0.11254303f, -0.20484179f, 0.38364488f, -0.05781812f, 0.03526025f, 
    -0.08310387f, -0.09126712f, 0.01542189f, 0.03331010f, 0.01970550f, -0.04454755f, -0.18078101f, 0.22296628f, 
    0.05218477f, -0.02905257f, -0.08168278f, -0.09103957f, -0.09534368f, -0.07238457f, 0.01320357f, 0.12609096f, 
    0.10020595f, -0.04201556f, -0.19112705f, 0.01449397f, -0.09658168f, 0.00912748f, 0.08775819f, 0.03737767f, 
    -0.03048193f, 0.05239339f, -0.05221359f, 0.04058426f, 0.05063741f, 0.02005961f, -0.08839320f, 0.08954968f, 
    -0.05838977f, 0.16146828f, -0.05933569f, -0.02606588f, -0.04748439f, -0.12797339f, 0.07710281f, 0.03477346f, 
    0.06016658f, -0.05952698f, -0.12567118f, 0.05281499f, -0.02926040f, -0.03420829f, -0.00492210f, -0.07346597f, 
    0.19928226f, -0.02858431f, -0.14376518f, -0.27155519f, 0.18637423f, -0.00253380f, 0.03096364f, 0.04255397f, 
    0.03762751f, 0.03283579f, -0.11790004f, 0.08006518f, -0.00392263f, 0.07167020f, 0.05506250f, -0.09991783f, 
    -0.05749152f, -0.03647640f, 0.07231001f, -0.18053640f, 0.08410626f, 0.19435273f, -0.20542718f, 0.01880854f, 
    -0.15728039f, 0.03723415f, -0.01803179f, -0.05814854f, -0.06454916f, 0.01641435f, 0.13614306f, 0.09309009f, 
    0.17003064f, -0.02295362f, 0.02349361f, 0.05496800f, 0.09429236f, 0.01242102f, 0.07434375f, -0.01296185f, 
    0.09841975f, -0.17325367f, 0.03105043f, -0.14077452f, -0.05260443f, 0.18129250f, 0.03153088f, 0.15552513f, 
    0.12842068f, 0.19518313f, -0.09495230f, 0.00672644f, 0.04453421f, -0.14093088f, 0.04052106f, -0.05566888f, 
    0.14137200f, 0.11759935f, -0.06736772f, -0.10212106f, -0.07213099f, 0.12726043f, 0.04589789f, -0.15910347f, 
    0.06084802f, -0.30596703f, -0.56164443f, -0.26691854f, -0.00415972f, 0.07049911f, -0.02262862f, -0.05308801f, 
    -0.11848278f, -0.04938538f, -0.27177101f, -0.23885854f, -0.18405922f, 0.03407451f, 0.02856381f, 0.02173623f, 
    -0.01345386f, 0.07135926f, -0.08530369f, -0.07497063f, -0.14631541f, 0.18113650f, -0.14788647f, 0.25076577f, 
    0.12603208f, 0.04557578f, -0.00836926f, 0.17469697f, -0.11274574f, 0.05510174f, 0.05226469f, -0.07450765f, 
    0.11770920f, 0.06880561f, -0.04527929f, 0.06136108f, -0.08728131f, -0.15475796f, -0.10651670f, -0.10518189f, 
    0.00157502f, 0.07449153f, 0.00762413f, 0.05298338f, -0.01550308f, 0.05689120f, 0.31428444f, -0.14751582f, 
    0.17209931f, 0.15826918f, -0.12341915f, 0.06905433f, -0.08967593f, -0.07931298f, -0.00543776f, -0.27613989f, 
    -0.00402688f, -0.00263664f, 0.02520874f, -0.17363763f, -0.13942426f, 0.10420726f, 0.17231612f, -0.06562559f, 
    0.03421850f, 0.11334714f, 0.00790789f, -0.08542286f, 0.00623700f, -0.04636330f, 0.03684700f, 0.02200545f, 
    -0.04736269f, 0.21304178f, 0.13497065f, -0.12144054f, -0.14122263f, 0.05720804f, -0.12454228f, -0.12470325f, 
    -0.11257034f, 0.01979912f, 0.07594372f, -0.11863320f, 0.09853853f, -0.08661480f, 0.11266316f, 0.07786987f, 
    0.14527555f, 0.05007832f, -0.03031527f, -0.17065136f, 0.20553282f, -0.21262227f, 0.00486328f, 0.04357781f, 
    -0.11913421f, -0.07800668f, 0.03833590f, -0.12751868f, 0.25198466f, 0.00212159f, -0.11319187f, 0.00131017f, 
    -0.01173215f, -0.11055274f, -0.02506303f, 0.08503672f, -0.03004795f, 0.25164604f, 0.18090680f, -0.05068466f, 
    -0.01094115f, 0.07050020f, -0.07445671f, 0.05214523f, 0.04380928f, 0.08839715f, 0.25216585f, 0.20464474f, 
    0.04154128f, -0.13471091f, -0.03914422f, 0.17711854f, 0.00411870f, -0.13413127f, -0.07159577f, 0.19051884f, 
    -0.13101403f, 0.19518380f, -0.05423183f, -0.11057563f, -0.02338053f, 0.08157703f, 0.02355772f, 0.11046326f, 
    -0.29573393f, -0.25185803f, -0.42343676f, -0.04326608f, 0.06494407f, 0.05479676f, 0.03258329f, 0.01596125f, 
    0.04327881f, -0.17943378f, -0.11746767f, -0.23911539f, -0.01493282f, 0.09724934f, -0.06137582f, 0.15043253f, 
    0.12241937f, -0.00318761f, -0.19473217f, -0.12786296f, 0.07102882f, 0.06315535f, -0.13450561f, -0.02328760f, 
    -0.03790930f, -0.03550608f, 0.05566011f, -0.09814049f, -0.02038884f, -0.00515638f, 0.05800717f, 0.02343122f, 
    0.09517282f, 0.14282317f, 0.04916056f, 0.00298070f, 0.29646802f, 0.01039986f, 0.24135914f, -0.06911670f, 
    -0.20828950f, 0.16492626f, 0.07070768f, 0.12638235f, 0.04982692f, 0.07451957f, 0.14751089f, 0.01824809f, 
    0.08140736f, -0.11158428f, 0.12271190f, -0.06509960f, 0.07027102f, -0.00153899f, 0.05502990f, -0.14951539f, 
    -0.11834720f, -0.00318702f, 0.01652901f, -0.13704972f, 0.07115291f, 0.00461044f, 0.10461499f, 0.11002061f, 
    0.04279918f, 0.27867407f, -0.09008154f, -0.15457283f, 0.08897557f, 0.12787397f, 0.20024076f, 0.01513521f, 
    -0.16010734f, -0.31422403f, 0.08769697f, 0.08292042f, 0.04816619f, -0.01990015f, -0.09762470f, -0.01812068f, 
    0.09772053f, 0.00090130f, 0.05553611f, 0.00186771f, -0.04926326f, -0.00454379f, 0.13008735f, 0.02771473f, 
    0.04648821f, -0.01950830f, 0.06567550f, 0.04251954f, 0.06748682f, -0.09335874f, 0.02101745f, 0.00064231f, 
    -0.11965027f, -0.12014142f, -0.03525097f, 0.26140898f, 0.09418449f, -0.06536459f, -0.01518375f, -0.04089433f, 
    -0.02724599f, 0.20643446f, 0.10671814f, 0.06613320f, -0.04520374f, 0.23777394f, 0.00759245f, 0.28060558f, 
    0.10695542f, -0.01198544f, -0.08013844f, 0.01595545f, 0.04431988f, -0.07962233f, -0.21269065f, -0.03971066f, 
    -0.04065650f, -0.00257845f, 0.02363233f, 0.11843760f, 0.09641243f, 0.10746603f, -0.05254732f, 0.00181710f, 
    -0.24405715f, -0.21757403f, 0.02126216f, 0.13193020f, -0.09965646f, -0.02170057f, -0.01519077f, -0.09373254f, 
    -0.10564749f, 0.12595330f, -0.04921631f, 0.01130421f, 0.03996295f, 0.09329979f, 0.11590920f, -0.01489187f, 
    0.00448477f, 0.11927798f, -0.45611596f, -0.00529302f, 0.13608085f, 0.19632368f, 0.00292301f, 0.04693159f, 
    -0.03567683f, -0.27689382f, -0.03791595f, 0.03611141f, -0.03597539f, -0.15806885f, 0.11862239f, -0.02771623f, 
    -0.01397916f, -0.05545329f, -0.22934462f, -0.05712702f, 0.01864488f, -0.05175444f, 0.01633034f, -0.02143888f, 
    -0.10326812f, -0.05356945f, -0.07947204f, -0.15955247f, 0.05962993f, -0.14145996f, 0.11661844f, 0.10597771f, 
    -0.01259554f, 0.06031635f, 0.06759333f, -0.13340074f, 0.11192776f, 0.16140831f, -0.13084809f, 0.18378267f, 
    -0.05583315f, 0.00463630f, 0.14707558f, -0.00834239f, 0.02875548f, -0.17884892f, 0.18861964f, 0.01925133f, 
    0.01645565f, 0.07650378f, 0.06939393f, 0.05663585f, 0.11392073f, 0.00248178f, -0.04735851f, -0.20785151f, 
    0.23533079f, -0.06360322f, 0.03545557f, 0.08287325f, -0.11687732f, 0.08183169f, 0.07891240f, -0.27273163f, 
    -0.27147627f, 0.32524550f, -0.12041231f, 0.04240946f, -0.18820129f, 0.01575661f, -0.11791945f, -0.15782316f, 
    0.06673340f, 0.07593094f, -0.07157014f, 0.07214852f, 0.03832849f, -0.11844598f, 0.00520606f, 0.05418149f, 
    -0.05096983f, 0.26961097f, -0.18881012f, -0.34341788f, -0.04948770f, 0.12068977f, 0.14917782f, 0.00793779f, 
    -0.08144400f, -0.04431419f, -0.06414653f, -0.23112550f, 0.17299001f, 0.09640479f, -0.12084801f, -0.01944415f, 
    0.01728811f, -0.03084004f, -0.03609002f, 0.14447604f, 0.01659709f, -0.27755928f, 0.06414787f, -0.05182768f, 
    -0.00622519f, 0.02562133f, -0.10693312f, 0.02253695f, 0.03372918f, -0.09945653f, 0.12779664f, -0.12794934f, 
    -0.20343670f, 0.10971002f, 0.06749474f, -0.07562853f, -0.04320195f, 0.04037711f, 0.15428016f, 0.11927728f, 
    -0.08149696f, 0.09989090f, 0.02742032f, 0.06568941f, 0.01636551f, -0.01221622f, -0.05141526f, 0.13912082f, 
    -0.13390283f, 0.04065909f, -0.20698951f, -0.01297500f, -0.02654957f, 0.03575909f, -0.07229935f, -0.02390796f, 
    -0.23892599f, 0.25872824f, -0.19272222f, -0.02962135f, 0.02732302f, -0.12674569f, -0.05359184f, 0.00233832f, 
    -0.06531562f, -0.10375711f, -0.23862380f, 0.03889324f, 0.05963086f, 0.13017121f, -0.02240767f, -0.08042663f, 
    -0.04014914f, 0.04057734f, 0.22029953f, -0.31662345f, 0.14641613f, -0.06398758f, 0.01575099f, 0.06521446f, 
    0.11346492f, -0.07929315f, -0.03478531f, 0.28988269f, 0.10588407f, 0.05057105f, -0.05341335f, 0.12201232f, 
    0.17915030f, -0.03220021f, 0.18099885f, 0.05648119f, -0.18771054f, 0.14771041f, 0.03297154f, 0.14426348f, 
    0.09352934f, 0.04875304f, 0.03576479f, 0.04098833f, -0.22452633f, -0.26799750f, 0.22770374f, 0.05688111f, 
    0.05266452f, 0.01298822f, -0.08952028f, 0.14269550f, 0.05771288f, 0.25853050f, 0.10002150f, 0.01379337f, 
    0.11454958f, -0.08638036f, -0.02280926f, 0.02417943f, 0.07705148f, -0.02051335f, -0.12802996f, 0.03157737f, 
    -0.22673884f, -0.01920407f, -0.03831451f, -0.02707714f, -0.18047169f, 0.20426059f, 0.08074824f, -0.07070000f, 
    -0.20072366f, -0.11000151f, -0.03542839f, -0.02906021f, -0.02159664f, -0.09750170f, 0.10745790f, 0.07737464f, 
    -0.13220376f, 0.01393414f, -0.31940559f, 0.00077474f, -0.01139764f, 0.14638361f, -0.10420213f, 0.07444245f, 
    0.09934025f, -0.17024234f, 0.08951903f, -0.11026739f, 0.02718289f, 0.12812009f, 0.00551729f, 0.03161479f, 
    0.04868051f, -0.10054373f, -0.07979422f, 0.04229218f, -0.30429050f, 0.22834094f, -0.06331560f, 0.09457128f, 
    0.01481115f, 0.01371804f, 0.03497147f, 0.04323659f, 0.10339419f, -0.25846308f, -0.00437718f, -0.10418077f, 
    0.01595208f, 0.10357958f, -0.01319178f, 0.21803612f, 0.08374947f, 0.05919904f, 0.15191746f, 0.15410933f, 
    -0.06416333f, 0.04158793f, 0.00981395f, 0.01287204f, 0.00583837f, 0.07201225f, -0.08218330f, -0.04098874f, 
    -0.08624142f, -0.03395330f, 0.06802479f, 0.07229876f, 0.00595472f, 0.14107981f, -0.20971860f, 0.09022080f, 
    -0.21366973f, 0.10397249f, 0.07671306f, -0.28841075f, 0.03931509f, -0.05580448f, 0.08136199f, 0.03645356f, 
    -0.11686505f, 0.15592375f, -0.09371205f, -0.04626503f, 0.04311396f, -0.12590590f, 0.01809115f, -0.00359786f, 
    -0.03636751f, 0.08987688f, -0.05317620f, 0.04737173f, -0.10725247f, 0.01546641f, 0.10719428f, -0.04674647f, 
    0.07145349f, -0.34158862f, -0.12835512f, -0.14303474f, 0.08067153f, -0.01616990f, 0.02860941f, 0.08217798f, 
    -0.10110744f, -0.00813444f, -0.05755953f, -0.03358233f, -0.11566731f, 0.09504955f, -0.16712742f, 0.11357927f, 
    0.06196851f, 0.09216207f, -0.17492680f, -0.15036000f, -0.15198207f, -0.13065588f, 0.15408282f, 0.04324815f, 
    0.15799408f, 0.00932310f, 0.06323241f, 0.03120370f, -0.00671623f, -0.09593730f, 0.05938606f, 0.11783492f, 
    0.08086851f, 0.04829900f, -0.02058190f, -0.08339707f, 0.08470302f, 0.09846574f, 0.02625515f, -0.06173795f, 
    0.02659366f, 0.03345563f, 0.09414042f, 0.17527756f, -0.10467052f, 0.11251295f, -0.15130793f, 0.03401851f, 
    0.11430448f, 0.06982549f, -0.02564182f, 0.11742858f, 0.07356191f, 0.00019661f, 0.05738160f, 0.02191911f, 
    -0.14651054f, -0.06965684f, 0.16082732f, 0.04249625f, 0.08425798f, 0.09224931f, -0.04736130f, -0.09064617f, 
    0.15723775f, -0.11280981f, 0.02602275f, 0.10411239f, 0.00146771f, -0.05688687f, -0.01829997f, 0.00049104f, 
    0.07015833f, -0.10588688f, 0.13272534f, 0.11816376f, 0.19018961f, 0.12050097f, -0.07815118f, 0.10824899f, 
    0.07879389f, 0.17342426f, 0.24712749f, 0.18186831f, 0.00647933f, 0.14759538f, -0.00737598f, 0.11383050f, 
    0.02579514f, 0.07536776f, -0.09115724f, -0.10437340f, -0.06100741f, -0.06728125f, 0.09526741f, 0.15298581f, 
    0.06612749f, 0.15503706f, -0.13664688f, 0.20561205f, -0.01806883f, 0.11555420f, -0.01525463f, -0.00293223f, 
    0.04856012f, 0.00275679f, 0.00759344f, 0.04672173f, -0.03090557f, -0.16029598f, 0.16891015f, 0.17008014f, 
    0.00646173f, -0.11490744f, -0.00871544f, 0.18323608f, -0.06315237f, 0.01770055f, 0.11034521f, -0.12735496f, 
    -0.01498105f, 0.04854830f, -0.15187544f, 0.02772119f, 0.03478088f, 0.00976600f, 0.23325616f, 0.13888711f, 
    0.14569627f, 0.14763613f, -0.08950432f, -0.02124626f, -0.22294676f, -0.07286936f, 0.07766457f, 0.02171871f, 
    -0.02006036f, -0.29621124f, -0.29963022f, -0.03580736f, 0.09459691f, -0.00083769f, 0.03858598f, 0.05684567f, 
    0.11088134f, -0.09427744f, -0.03083644f, -0.10307150f, 0.16172056f, -0.01288502f, 0.14401288f, 0.02444089f, 
    -0.17770390f, -0.05108888f, -0.07037974f, 0.16744751f, -0.01685717f, 0.06356725f, -0.05982210f, 0.20770143f, 
    0.10257183f, 0.03221815f, 0.05876447f, -0.07736295f, 0.14943871f, 0.09636478f, 0.02634771f, 0.01928017f, 
    -0.07049218f, -0.01906725f, 0.10760614f, 0.09566619f, 0.07548685f, 0.19761100f, 0.12359624f, 0.13258900f, 
    0.18838342f, -0.04034387f, 0.14874981f, 0.12512894f, 0.01251372f, -0.08825310f, -0.03962123f, -0.07388937f, 
    0.09192078f, 0.05446217f, -0.00552737f, -0.08386443f, 0.02046069f, 0.05872544f, 0.19325876f, -0.10164895f, 
    -0.13121004f, -0.01149131f, -0.01791315f, -0.23138876f, 0.04078706f, -0.07986224f, 0.04967679f, 0.14321697f, 
    0.18685301f, 0.00671759f, 0.04566473f, -0.03628299f, -0.25813764f, 0.21453613f, 0.01730315f, -0.03894360f, 
    -0.09318514f, -0.10447235f, -0.14743118f, -0.02076914f, 0.08691492f, 0.14059682f, -0.24575171f, -0.07160989f, 
    -0.14227073f, 0.04048494f, 0.05477067f, 0.08742889f, 0.10056578f, -0.01921954f, -0.12192832f, 0.00209751f, 
    -0.02356753f, 0.09408364f, -0.07515293f, -0.11724126f, -0.08483672f, 0.04439260f, 0.09416975f, 0.00153075f, 
    -0.01668159f, 0.04097293f, 0.19844216f, 0.04236184f, 0.18321832f, 0.16307797f, 0.10195988f, -0.06295558f, 
    -0.08382005f, -0.09140722f, 0.10619278f, 0.11120728f, -0.36014801f, -0.16722366f, 0.00810679f, 0.21393347f, 
    0.02691703f, 0.13570170f, 0.07916562f, -0.05268041f, -0.09073067f, 0.02684424f, -0.14984015f, -0.02078267f, 
    0.10009502f, 0.17088152f, 0.04378769f, 0.01659446f, -0.12321597f, -0.16223030f, -0.21510732f, 0.08282581f, 
    0.02823886f, 0.09349442f, -0.21930380f, -0.29403371f, 0.16064227f, 0.01255697f, 0.01185756f, 0.23755224f, 
    0.01611963f, 0.00956731f, -0.06035086f, 0.01921811f, -0.30602974f, 0.06976707f, -0.03152034f, -0.09754848f, 
    -0.26004910f, -0.04194045f, -0.20478664f, -0.05352377f, 0.09791923f, 0.15589099f, -0.10391435f, 0.08526033f, 
    -0.00141158f, -0.09559803f, -0.06344315f, 0.07020473f, 0.04206849f, -0.02146005f, 0.11828330f, -0.09806772f, 
    -0.10232838f, -0.11947302f, -0.13705178f, -0.10184397f, -0.13264392f, -0.05952650f, -0.03175507f, -0.04914364f, 
    0.09237064f, 0.06075303f, -0.01494412f, 0.12038927f, -0.08187016f, 0.12385235f, -0.12257364f, -0.22823381f, 
    -0.17067382f, -0.07163823f, 0.16802369f, 0.14946696f, -0.11237959f, 0.01777963f, 0.08760356f, -0.18713184f, 
    -0.05010566f, -0.00895830f, -0.04504514f, 0.13442643f, 0.05764820f, -0.11741346f, -0.07067624f, -0.13462222f, 
    -0.00411944f, 0.09449867f, 0.10254085f, 0.03311534f, -0.11761176f, -0.08439100f, 0.10335369f, 0.07947299f, 
    0.10485235f, -0.02022246f, 0.13731356f, -0.07293379f, -0.08256736f, -0.01181100f, -0.04656729f, -0.26582697f, 
    -0.03815672f, -0.10869215f, -0.03922416f, -0.00221640f, -0.02399608f, 0.06389158f, -0.00700638f, -0.01886874f, 
    0.12087025f, -0.02573127f, 0.08860348f, -0.09892087f, -0.13404223f, 0.12190851f, 0.01408423f, -0.00939638f, 
    -0.01386591f, 0.04360658f, -0.02597536f, 0.01710451f, -0.09516318f, -0.07199555f, 0.01158680f, 0.06204411f, 
    0.11714410f, -0.09430239f, -0.11874598f, -0.00409011f, -0.02422163f, -0.03168593f, 0.12582655f, -0.04438657f, 
    -0.08427119f, -0.11681266f, -0.08454294f, -0.09516349f, 0.02480133f, 0.01374885f, -0.03987063f, -0.03650787f, 
    -0.17821282f, -0.06577755f, 0.04279712f, -0.01233872f, 0.16521208f, 0.04661665f, 0.06153492f, 0.10532138f, 
    0.00735249f, 0.02192397f, -0.01066186f, 0.21852212f, -0.06692070f, 0.20615958f, -0.15364635f, -0.14523928f, 
    0.16856347f, 0.06847205f, -0.12399841f, -0.11781597f, -0.02525125f, -0.25512984f, -0.30563226f, 0.02689661f, 
    -0.14648674f, 0.01599663f, 0.01603039f, -0.06328249f, -0.05924967f, 0.03871633f, 0.00863201f, 0.30971429f, 
    0.12545763f, -0.12706371f, 0.25061852f, 0.12094368f, 0.07935356f, -0.09096016f, -0.05522780f, -0.03056821f, 
    -0.26638570f, -0.14082451f, -0.08401104f, 0.13024059f, -0.00791010f, -0.14207411f, 0.05542758f, 0.15175258f, 
    -0.01006636f, -0.07054154f, 0.10705034f, 0.21966365f, -0.13095392f, -0.14846945f, -0.08066290f, -0.04842550f, 
    0.06178207f, 0.11915621f, -0.09094141f, -0.17067358f, -0.06293188f, -0.06560808f, -0.00230242f, -0.05377391f, 
    -0.00377091f, -0.03192281f, 0.08372918f, 0.34867054f, 0.06155604f, 0.03204384f, -0.02031991f, -0.11745197f, 
    -0.02231289f, 0.15632549f, 0.04491218f, 0.02832738f, 0.13417719f, 0.01364602f, -0.08959021f, 0.12150285f, 
    0.05150064f, -0.01615939f, 0.04133155f, -0.00817033f, 0.05578028f, 0.10452107f, 0.21561609f, 0.06356139f, 
    0.00450816f, -0.08449512f, -0.04006194f, 0.06307141f, 0.05946777f, 0.07428245f, 0.27082264f, 0.14280200f, 
    -0.17119402f, -0.12403844f, 0.04279300f, 0.01228308f, -0.10399528f, -0.02242032f, -0.06324042f, -0.00853204f, 
    -0.04097407f, 0.00010913f, -0.18980347f, 0.10084632f, 0.00641016f, 0.07575943f, 0.07099053f, -0.01845998f, 
    0.07743695f, 0.11866841f, 0.11703613f, -0.05547805f, -0.12077692f, 0.00366627f, 0.12307192f, 0.02190747f, 
    0.09050475f, 0.06097323f, 0.00024768f, 0.10328504f, -0.11248910f, -0.07781694f, -0.06448422f, 0.05675054f, 
    -0.02915131f, -0.02379624f, 0.05188595f, 0.14063525f, 0.10407981f, -0.10313562f, 0.00052258f, -0.05663937f, 
    -0.04248697f, 0.07642429f, -0.15509355f, 0.04196847f, 0.07605981f, 0.31327966f, -0.01688334f, 0.03815879f, 
    0.01972918f, 0.12565038f, 0.08387312f, -0.04772613f, 0.07682534f, -0.00712108f, 0.01994867f, -0.09688105f, 
    0.13802820f, 0.07559044f, 0.02152479f, 0.04000071f, -0.01525139f, -0.03516225f, 0.12799530f, -0.15007362f, 
    0.01878726f, -0.01798934f, -0.02211379f, 0.03404775f, -0.02370682f, 0.00451611f, 0.04536179f, -0.28878453f, 
    -0.06893624f, -0.06801290f, 0.15556255f, -0.07473472f, -0.04297509f, -0.06888612f, -0.22872989f, 0.18681636f, 
    -0.02071701f, -0.25505108f, 0.11618935f, 0.17801562f, 0.19504899f, 0.06182894f, -0.03962180f, 0.05951434f, 
    -0.03889045f, 0.03515179f, -0.03501874f, -0.03134285f, -0.00265402f, 0.04957668f, -0.04405956f, 0.04959240f, 
    -0.03476915f, -0.01646430f, 0.01381885f, -0.01180450f, -0.04109902f, -0.01667048f, 0.01837869f, -0.02437170f, 
    -0.04692078f, 0.02228323f, 0.03074169f, 0.04975026f, -0.02857517f, 0.03836922f, -0.02990934f, -0.04658404f, 
    0.04443165f, -0.05031313f, 0.02035484f, 0.05518034f, 0.00738171f, -0.03754397f, -0.03910361f, 0.04351660f, 
    0.01042039f, -0.06631137f, 0.03981146f, -0.01383710f, -0.02316655f, -0.05440552f, 0.03979915f, -0.02397358f, 
    -0.06090952f, 0.00370753f, 0.03120098f, 0.03282952f, -0.06136557f, 0.02843888f, -0.02506516f, 0.01678203f, 
    0.04289155f, -0.03629430f, 0.01470435f, -0.06079418f, -0.02346696f, 0.04260376f, -0.01411970f, -0.03445096f, 
    -0.05426493f, -0.01884387f, -0.01675342f, 0.04827204f, -0.03165539f, 0.03027187f, 0.04721681f, 0.02122952f, 
    0.01257401f, -0.01938778f, -0.04841464f, -0.01011771f, 0.04530346f, 0.04151748f, -0.06569207f, -0.00159220f, 
    0.03052217f, -0.01885476f, -0.03880838f, -0.00424810f, -0.04143213f, -0.00148239f, -0.04728702f, 0.03784221f, 
    -0.03876307f, -0.03943252f, 0.02848662f, -0.04717790f, -0.06211698f, -0.04904950f, 0.03226027f, 0.01716927f, 
    -0.05775526f, -0.05806297f, -0.06234388f, 0.00774132f, -0.01739522f, 0.04515212f, -0.05247145f, -0.05878033f, 
    -0.06705127f, -0.04562753f, 0.00451088f, -0.01191593f, 0.04196882f, -0.05079094f, -0.04833783f, 0.03866212f, 
    -0.01591390f, 0.04945111f, 0.00025149f, 0.04782138f, -0.00727693f, -0.03269652f, -0.00216131f, -0.04311356f, 
    -0.04957848f, -0.00732240f, -0.01685007f, -0.02258512f, 0.03711995f, 0.02034142f, 0.02281639f, -0.02540626f, 
    0.01705039f, -0.04891034f, -0.01178511f, -0.00068887f, 0.00547698f, 0.04644582f, -0.02816413f, 0.04576606f, 
    -0.00001689f, -0.04147373f, -0.06576701f, -0.00374472f, 0.03538978f, -0.06148029f, -0.02448699f, -0.04526910f, 
    -0.06255565f, 0.02983272f, 0.03276145f, -0.03987690f, 0.03421589f, 0.00554313f, -0.00816720f, -0.04842763f, 
    -0.06168838f, 0.02176408f, -0.00293922f, -0.01050995f, -0.04633754f, 0.03760058f, -0.01959075f, 0.01669704f, 
    0.04897235f, -0.05081731f, -0.03544496f, -0.03589930f, -0.06104416f, -0.06041098f, -0.05800284f, 0.02969093f, 
    -0.00704640f, 0.04521490f, -0.02649421f, -0.01526401f, -0.03021908f, -0.05063184f, -0.03309787f, 0.02709087f, 
    0.02843911f, 0.01226475f, -0.04516653f, -0.01133642f, -0.01194706f, 0.04649972f, -0.06025887f, -0.05636613f, 
    -0.00029122f, 0.04004179f, 0.04795578f, -0.04688579f, -0.01796150f, 0.01102877f, 0.03084451f, 0.00139593f, 
    -0.03730502f, -0.05522168f, 0.04365478f, -0.01498570f, -0.05130105f, -0.00186550f, 0.03714264f, -0.02347442f, 
    -0.04755423f, 0.02291880f, -0.04267386f, 0.02366472f, -0.03102304f, -0.04972201f, 0.02447954f, 0.00639022f, 
    -0.03836667f, -0.00107562f, -0.00463356f, -0.00132183f, 0.01044985f, -0.03297893f, 0.03511209f, -0.06254767f, 
    -0.05982178f, -0.00758147f, 0.01948872f, 0.00490687f, -0.04081285f, 0.00182970f, -0.01065972f, 0.03269329f, 
    -0.01526331f, -0.02621467f, -0.04886581f, 0.00682087f, -0.04989871f, -0.00432362f, 0.04267099f, 0.00330689f, 
    0.03770001f, -0.00242986f, 0.02121739f, 0.04246110f, 0.02189663f, -0.02695600f, -0.01546179f, -0.02611859f, 
    0.02550202f, 0.04955570f, -0.04850977f, -0.05062189f, 0.02738427f, -0.03139698f, -0.00624923f, -0.04488678f, 
    -0.06361976f, -0.06384762f, -0.02770037f, 0.04224934f, -0.01169237f, 0.00553006f, -0.04731638f, 0.00133489f, 
    0.03137439f, 0.01938138f, 0.02424454f, 0.04687512f, -0.02120206f, 0.02635740f, -0.02469534f, -0.01716473f, 
    -0.02167384f, -0.00271067f, 0.00068480f, 0.02803969f, 0.01897556f, 0.01348174f, 0.00384171f, 0.04423759f, 
    0.00006929f, 0.03946423f, -0.05267424f, 0.01739387f, -0.00491048f, -0.00171422f, -0.03342038f, 0.04444060f, 
    0.02376996f, -0.05071959f, -0.03030944f, 0.02921359f, -0.05496125f, -0.00470500f, -0.05343636f, 0.04907055f, 
    0.03462413f, -0.02728423f, -0.01515559f, -0.04499884f, 0.01243162f, -0.02442493f, -0.00996522f, -0.04868237f, 
    -0.02471426f, 0.05293674f, -0.03028956f, -0.02644217f, 0.01056118f, -0.03600360f, 0.00568732f, 0.03850449f, 
    0.04103164f, -0.01381619f, -0.06104666f, 0.01820972f, -0.03062934f, -0.00399075f, 0.01652769f, -0.03529551f, 
    -0.00208928f, -0.03066972f, 0.03299305f, -0.01107482f, 0.03355622f, 0.00753765f, -0.01683872f, 0.02254166f, 
    -0.05292341f, 0.00436560f, -0.00358809f, 0.03151206f, -0.01326787f, -0.06074675f, -0.06180725f, -0.01866709f, 
    -0.01366761f, 0.00488935f, -0.05145252f, -0.00473603f, -0.04949364f, -0.00378053f, -0.05000077f, 0.03362889f, 
    0.05075825f, 0.02047995f, -0.03871962f, 0.04361231f, -0.03026511f, -0.03341110f, 0.04307244f, 0.00735168f, 
    -0.01335136f, 0.02047921f, -0.01533521f, 0.04853900f, 0.02269596f, -0.06285903f, -0.05961635f, -0.05418162f, 
    0.02897221f, 0.00341288f, 0.03822803f, 0.04981027f, 0.03949698f, -0.05734711f, -0.00978473f, -0.02985743f, 
    -0.05701393f, 0.02883285f, -0.04298570f, 0.02299474f, -0.01853013f, 0.01463800f, -0.01472269f, 0.02297397f, 
    0.04637774f, -0.00498689f, 0.04877543f, 0.02723195f, -0.02357896f, 0.02922176f, -0.04198918f, -0.05039972f, 
    0.01089472f, 0.03872673f, -0.04880999f, 0.04594495f, 0.00578516f, -0.02852181f, 0.03936758f, -0.06381235f, 
    0.05091922f, -0.02930375f, 0.04638898f, 0.04232391f, 0.04996953f, -0.04976192f, -0.02797598f, -0.01679788f, 
    -0.05235234f, -0.00344372f, -0.04946246f, 0.01078573f, -0.04849111f, 0.03863627f, -0.01876005f, 0.00778968f, 
    -0.05820059f, -0.05510348f, -0.04756159f, -0.05982306f, 0.02504097f, -0.01460245f, -0.01035114f, 0.03879241f, 
    -0.02803869f, -0.05271135f, -0.04477865f, -0.05588735f, -0.05497031f, 0.03589671f, -0.05568662f, 0.04895345f, 
    0.05155892f, -0.01430160f, 0.00453860f, 0.02282197f, 0.02010144f, -0.04193539f, 0.04403619f, -0.01372180f, 
    -0.01760884f, 0.00818634f, 0.02051314f, -0.00295976f, 0.00045389f, -0.04708128f, -0.04382797f, -0.04827199f, 
    -0.01250726f, -0.06319761f, -0.01065672f, -0.03772796f, -0.04092905f, 0.03707504f, -0.05484061f, 0.00622906f, 
    -0.05573357f, 0.02128361f, 0.00354017f, 0.00589781f, -0.03919314f, 0.01563094f, 0.03064536f, 0.00852194f, 
    -0.04502344f, -0.00733626f, 0.00316941f, -0.05568250f, -0.05783590f, -0.01951694f, -0.03296793f, 0.02116925f, 
    -0.05224878f, -0.00912372f, -0.05276145f, -0.03846591f, -0.01538329f, -0.05900469f, -0.02604202f, -0.01058629f, 
    -0.00049269f, 0.01457116f, 0.03509826f, 0.01216386f, 0.04333221f, -0.04693268f, 0.03343749f, -0.04761102f, 
    0.04131222f, 0.01566109f, -0.02508768f, -0.02941039f, 0.00953690f, -0.02871039f, -0.03836276f, -0.05972359f, 
    0.04091253f, 0.01467178f, -0.03438649f, 0.04570765f, 0.00796201f, 0.02779146f, 0.01334244f, 0.03139601f, 
    -0.06440596f, 0.00199208f, -0.00198463f, -0.03254953f, 0.03969861f, -0.02318165f, -0.01534705f, -0.02703207f, 
    0.04654481f, -0.01318235f, 0.00704326f, -0.06059961f, -0.01188905f, -0.03670789f, -0.02455615f, -0.00152896f, 
    0.04429216f, -0.04304263f, -0.02700826f, -0.05894860f, 0.00666141f, 0.05088036f, -0.04253396f, 0.04251184f, 
    -0.01388022f, -0.00941859f, -0.03155639f, -0.06345568f, -0.06069112f, 0.01070298f, 0.05561726f, 0.02877596f, 
    -0.00061588f, -0.00410630f, -0.06314819f, -0.03640769f, 0.00367834f, -0.04159903f, -0.00720107f, 0.01775911f, 
    0.02977163f, -0.01688957f, -0.05942576f, -0.01858232f, -0.04680559f, -0.04605275f, -0.05995710f, 0.00302179f, 
    0.01834241f, -0.02570158f, -0.04692649f, -0.03638680f, 0.04848438f, 0.03435757f, -0.06384341f, 0.03436083f, 
    -0.05776027f, -0.01805658f, 0.03247970f, 0.04533524f, 0.00426805f, 0.00416233f, -0.00744074f, 0.01667174f, 
    -0.05016477f, 0.00990302f, -0.00947265f, 0.04962606f, -0.04966465f, 0.00144737f, -0.04091396f, 0.04687883f, 
    0.01233985f, -0.05237828f, 0.04037003f, -0.01945098f, -0.00317370f, 0.00312952f, 0.02499355f, -0.02948235f, 
    0.04868967f, -0.05817143f, 0.00219264f, -0.03491248f, 0.01063933f, 0.02920889f, -0.04441967f, 0.03914376f, 
    -0.03365232f, -0.03278006f, 0.01321657f, -0.02922916f, 0.02370218f, -0.06233637f, 0.00964455f, 0.03825893f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.09302819f, -0.04635798f, -0.03441937f, 0.04617833f, 0.05009803f, 0.02544961f, 0.13517790f, 0.02891049f, 
    0.02596127f, 0.04530028f, -0.01619888f, -0.03358552f, 0.06170983f, -0.07336942f, -0.05765970f, 0.00245349f, 
    -0.01047718f, 0.01021943f, -0.03831235f, 0.12883797f, -0.02378010f, -0.00367177f, 0.03281096f, 0.10254249f, 
    0.07348806f, -0.08141568f, 0.03093968f, 0.09664840f, 0.13437220f, 0.00666144f, -0.05926850f, -0.06202680f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.24620773f, -0.02256479f, -0.26884943f, -0.08205083f, 0.51839024f, -0.14975882f, 0.13303328f, 0.02139554f, 
    -0.08868242f, -0.10188415f, 0.12092923f, 0.07744997f, -0.16677852f, 0.12995298f, -0.07931593f, 0.01461402f, 
    0.07275792f, -0.07950485f, -0.01295864f, 0.46365896f, -0.09549771f, 0.24252966f, -0.07655347f, -0.01212429f, 
    0.61371785f, 0.04680730f, 0.49428734f, 0.31543916f, 0.06899948f, -0.29617459f, 0.11603807f, -0.03483954f, 
    -0.42442462f, -0.13215721f, 0.25863749f, -0.40216815f, 0.35342747f, 0.06666768f, 0.32284975f, 0.22432400f, 
    0.09879096f, -0.00343213f, 0.00892133f, -0.05734013f, -0.17504860f, 0.26358327f, 0.25952408f, -0.06166456f, 
    0.13758035f, -0.29661483f, -0.31869784f, 0.12184325f, -0.05739407f, 0.07955810f, 0.04591539f, -0.11945699f, 
    -0.06425685f, -0.14913118f, 0.03578556f, 0.38210326f, -0.06003591f, -0.19694228f, -0.03272178f, -0.08580857f, 
    -0.05278397f, -0.15520298f, -0.12784836f, -0.04633321f, 0.03685186f, 0.09664845f, 0.13663068f, -0.16605386f, 
    -0.01695812f, -0.17330360f, 0.00353890f, -0.11677446f, -0.03724557f, -0.09502011f, -0.17050619f, 0.01051665f, 
    0.02574747f, -0.12812193f, 0.08062576f, -0.12863210f, -0.13262579f, 0.13068396f, 0.16575314f, -0.02101884f, 
    0.13839647f, -0.02606509f, -0.12948264f, 0.06979845f, -0.11247898f, -0.06303727f, -0.13328852f, -0.06612714f, 
    -0.14299543f, -0.15659758f, 0.02094082f, -0.00875725f, -0.07985950f, -0.12646642f, 0.04098175f, -0.20480464f, 
    -0.01850759f, -0.09001179f, -0.00054658f, -0.00879834f, 0.01220649f, -0.14672451f, 0.06110866f, -0.13827929f, 
    -0.10186362f, -0.15820402f, 0.08570871f, 0.10693216f, -0.10832325f, -0.18437828f, 0.00767462f, -0.02362528f, 
    -0.14510119f, 0.02046066f, -0.12045882f, -0.02197293f, -0.04876174f, -0.09832507f, -0.03108943f, -0.05604976f, 
    0.01147092f, -0.07074766f, 0.14427850f, -0.20086080f, -0.01048219f, -0.04080639f, 0.01494133f, 0.16050850f, 
    0.09691204f, 0.03269018f, -0.16391343f, 0.01539331f, -0.04718993f, 0.12293480f, 0.05083384f, 0.03297679f, 
    -0.32400599f, -0.48167324f, -0.33836117f, -0.34724176f, 0.01252830f, -0.04849228f, 0.03751915f, 0.04970752f, 
    -0.19985880f, 0.33252940f, -0.04710630f, 0.09090806f, -0.14020310f, -0.14268804f, -0.16422826f, -0.12500173f, 
    -0.16193041f, 0.09272645f, -0.20058449f, -0.03415888f, -0.18707065f, -0.10912139f, -0.09560188f, -0.13401017f, 
    0.10803326f, -0.01670494f, -0.08939866f, -0.17314242f, 0.09085984f, 0.00277500f, 0.00474774f, -0.08077596f, 
    0.02735170f, 0.06541958f, 0.06301098f, 0.00357836f, 0.13867801f, -0.02498876f, 0.11418825f, -0.22196089f, 
    0.11190474f, 0.00595610f, -0.05801737f, -0.08559828f, -0.15399706f, 0.08092643f, -0.14190508f, -0.01191707f, 
    0.19638745f, 0.01203638f, 0.10326277f, 0.07693767f, 0.29316998f, -0.04777617f, 0.03645635f, 0.29194272f, 
    -0.11176109f, 0.18246378f, -0.06516775f, 0.05512531f, 0.10193909f, -0.27993298f, -0.07732005f, 0.02653494f, 
    0.26486167f, -0.03765552f, 0.01637733f, -0.07607438f, 0.09391816f, 0.09351289f, -0.08567742f, 0.01809035f, 
    -0.07630727f, 0.33628359f, -0.47367984f, -0.25598022f, -0.14492540f, -0.04770871f, -0.07020042f, -0.10023387f, 
    -0.21217334f, -0.14644143f, 0.08750315f, -0.13864146f, 0.46141717f, 0.11976023f, -0.17316526f, 0.00226349f, 
    -0.02731064f, 0.03930060f, -0.03789000f, -0.13803193f, 0.21961597f, 0.37278003f, 0.00430930f, -0.04494533f, 
    0.02644510f, 0.13438456f, 0.13872974f, -0.20445244f, 0.11478692f, 0.08933857f, 0.16670701f, -0.07441612f, 
    -0.12830533f, 0.14099762f, 0.58139342f, -0.16599050f, 0.18708500f, -0.10895505f, 0.10424132f, -0.01340392f, 
    0.05059724f, -0.34666461f, -0.02969733f, 0.15999678f, 0.24511173f, 0.05201932f, -0.04227168f, 0.06679557f, 
    -0.09368578f, -0.02783767f, -0.14123967f, -0.08881865f, 0.48426747f, -0.08932712f, -0.33040518f, -0.07673255f, 
    -0.07052297f, 0.33247733f, 0.07203871f, 0.05621313f, 0.16432197f, 0.02011599f, 0.01927550f, 0.13967578f, 
    0.06425516f, 0.64010727f, 0.23511867f, -0.02768216f, 0.10516145f, -0.28818232f, 0.15957241f, 0.02501138f, 
    -0.11072741f, -0.14090589f, -0.05786594f, 0.29619324f, -0.14465663f, -0.12535457f, -0.05966221f, 0.15707155f, 
    0.03634069f, 0.46124998f, 0.05804697f, -0.16424803f, -0.22364691f, 0.28216901f, 0.06365214f, -0.02338885f, 
    0.21119004f, 0.05339308f, 0.13759321f, -0.08904902f, -0.14680006f, -0.08830411f, -0.02000086f, 0.04895626f, 
    -0.44570705f, 0.00230412f, 0.03089558f, -0.47525322f, 0.19332300f, -0.01816740f, 0.09695939f, 0.11503828f, 
    -0.01587787f, -0.10714661f, -0.20875213f, 0.08824080f, 0.20528986f, 0.07550099f, 0.09367377f, -0.03825791f, 
    0.00043539f, -0.04548826f, -0.10350938f, 0.15798955f, -0.11559321f, 0.36782923f, 0.28346500f, -0.05409784f, 
    -0.13784270f, -0.18521497f, -0.14890854f, 0.30711704f, 0.02666329f, 0.07393385f, -0.07814906f, -0.23148642f, 
    0.05132823f, -0.13701212f, 0.36332610f, 0.45665470f, 0.24322718f, 0.18302779f, -0.07041601f, -0.07899010f, 
    -0.06831858f, -0.14618051f, -0.20772049f, 0.34244370f, -0.07883581f, -0.07159161f, 0.15473349f, 0.17847377f, 
    -0.10652504f, -0.11412738f, 0.09261099f, -0.00586503f, -0.25539759f, -0.13553225f, -0.23600404f, -0.02031527f, 
    -0.02423824f, 0.30225593f, -0.06438781f, 0.16442807f, 0.04228048f, 0.01224437f, 0.11149371f, 0.13312949f, 
    0.07396694f, -0.14419839f, -0.00781894f, 0.08283432f, -0.03677600f, 0.16910724f, -0.16009691f, -0.13125511f, 
    -0.02040396f, -0.12137833f, -0.14801548f, 0.04011817f, 0.02597735f, -0.16548061f, -0.09173039f, -0.12210272f, 
    -0.01629857f, 0.03311739f, -0.05165775f, -0.12940368f, -0.00401595f, -0.16296276f, -0.09466187f, -0.09891147f, 
    -0.15715799f, -0.17311427f, -0.12516090f, -0.13459328f, 0.14161992f, -0.07475109f, -0.07073627f, 0.02518650f, 
    -0.02710112f, -0.10525137f, 0.03226041f, 0.13498650f, -0.03708887f, 0.12659414f, -0.16215944f, -0.08026983f, 
    -0.09066769f, -0.09339857f, -0.09469520f, -0.17489797f, -0.10419828f, -0.01854432f, -0.16151935f, 0.06365230f, 
    -0.14216690f, -0.16814664f, -0.10611656f, 0.13145170f, -0.14520799f, -0.06926556f, 0.06172800f, 0.16624531f, 
    0.00850711f, -0.08322962f, -0.10898979f, -0.04570288f, -0.04172390f, 0.11943532f, -0.16606054f, -0.00390720f, 
    -0.14111273f, -0.14860812f, 0.07624695f, 0.09532108f, 0.01471926f, -0.02119293f, 0.03908551f, 0.01431256f, 
    -0.21561226f, 0.12604375f, 0.38978398f, -0.02187498f, -0.32211721f, -0.09674977f, -0.07324586f, -0.24815355f, 
    0.16122986f, 0.19048546f, 0.10037701f, -0.10001262f, 0.15029049f, 0.25747156f, 0.32519501f, -0.03062397f, 
    -0.04531143f, 0.07579599f, 0.15084568f, 0.05912049f, 0.00484903f, -0.10999214f, -0.02228295f, 0.20026620f, 
    -0.18536758f, -0.17786786f, 0.41948470f, -0.15972868f, -0.03060922f, 0.22994755f, 0.06136398f, -0.09686260f, 
    0.29787695f, 0.34597191f, 0.13408850f, 0.05666595f, -0.22101864f, -0.09687569f, 0.06438214f, 0.03652230f, 
    0.04702547f, 0.10462628f, 0.05897715f, -0.05660305f, -0.13717723f, 0.14961161f, -0.32491556f, -0.06180498f, 
    -0.20063061f, -0.09965394f, 0.28053308f, -0.36118317f, -0.12785017f, 0.12631658f, 0.08771946f, 0.27789816f, 
    -0.32551056f, 0.33261469f, -0.12564039f, 0.20198524f, -0.14828706f, 0.33070144f, 0.10166163f, 0.02476894f, 
    -0.15140152f, 0.07032639f, 0.01286215f, 0.22691824f, -0.18367979f, 0.04456584f, -0.13911191f, 0.01019716f, 
    0.02555954f, 0.18424152f, -0.04270921f, 0.16266240f, -0.12833880f, 0.32825533f, 0.19741380f, 0.14046638f, 
    0.31504124f, 0.09232891f, -0.00331629f, -0.19619478f, 0.11237150f, -0.10279871f, -0.14971979f, -0.07296173f, 
    -0.28658068f, -0.18113495f, -0.00501637f, -0.27105314f, 0.27525905f, 0.29101619f, -0.10291533f, -0.12583986f, 
    -0.10648135f, -0.23604070f, 0.14617421f, -0.00899342f, -0.03065986f, 0.11256883f, -0.00202496f, 0.03263860f, 
    0.08304904f, -0.11579331f, -0.18343289f, -0.03991909f, 0.43404713f, 0.03842724f, -0.08995286f, 0.02095604f, 
    0.37566912f, 0.10676739f, 0.05151968f, 0.02138590f, 0.09620806f, -0.31545696f, -0.14189699f, 0.07422928f, 
    0.20104299f, 0.00308309f, 0.02264423f, 0.08928704f, 0.24046171f, -0.16439994f, 0.17461433f, -0.15257114f, 
    -0.27357692f, -0.18690629f, 0.16244496f, -0.28336424f, 0.50277400f, -0.02990388f, 0.31048200f, 0.16606119f, 
    -0.08269702f, -0.07136787f, -0.01654249f, -0.13326477f, 0.18657434f, -0.27662027f, 0.27567074f, 0.12664498f, 
    0.26573142f, 0.05101484f, 0.05135632f, 0.15857802f, 0.08422851f, 0.16041492f, 0.13728313f, -0.16942050f, 
    0.08230048f, -0.00715183f, -0.06868602f, 0.16899550f, 0.02790578f, -0.37064070f, 0.17607896f, 0.07591727f, 
    0.06422549f, -0.07040588f, 0.08936004f, 0.09310756f, -0.11445662f, 0.10464074f, -0.17119105f, 0.01072735f, 
    -0.02569889f, 0.11876700f, -0.08398177f, -0.14314769f, -0.00091829f, -0.02440865f, -0.06154054f, 0.01628243f, 
    -0.18100862f, -0.08095943f, -0.11922669f, -0.02096184f, -0.04004643f, 0.07897140f, 0.07797917f, -0.22675906f, 
    0.07172916f, 0.08551429f, -0.08356968f, -0.10596987f, -0.19106638f, -0.04718156f, 0.10456333f, -0.12866314f, 
    0.03882824f, -0.20703332f, 0.01324064f, 0.22354518f, 0.39023390f, -0.00757785f, 0.00955080f, 0.00987439f, 
    0.01961623f, 0.28161237f, -0.07526057f, -0.06320383f, -0.02114730f, 0.06278893f, -0.41397932f, -0.08443281f, 
    0.07862642f, 0.20564440f, 0.29219106f, -0.12069642f, 0.01637330f, 0.07434703f, -0.12273625f, 0.00641725f, 
    0.02078240f, 0.32841930f, 0.07520745f, -0.02275394f, 0.21869551f, -0.29444385f, 0.01830405f, 0.05621070f, 
    0.07172582f, 0.32567590f, 0.12383575f, -0.35891521f, 0.12823772f, -0.02012718f, 0.36004794f, 0.14672033f, 
    -0.00010889f, 0.13998744f, -0.13831702f, -0.10995152f, -0.27385375f, -0.06206778f, -0.22407702f, 0.11598852f, 
    -0.15759146f, -0.14600885f, -0.24795891f, -0.11484163f, -0.12520528f, -0.18460195f, -0.01428043f, -0.08678453f, 
    0.15135713f, -0.08493890f, -0.07147946f, 0.19764632f, -0.05265641f, 0.14909409f, 0.05308678f, -0.10210820f, 
    -0.04307868f, -0.02109444f, -0.18578392f, -0.12259014f, -0.17316431f, -0.01324659f, -0.02869589f, -0.19722386f, 
    -0.16156058f, 0.13245359f, -0.01553668f, -0.04244059f, 0.04244436f, -0.14129750f, -0.09519060f, -0.13043007f, 
    0.05086573f, -0.13315338f, 0.07003088f, 0.16092364f, -0.10519350f, 0.05034387f, 0.08722206f, -0.15105508f, 
    0.17282535f, -0.05396108f, 0.11573250f, -0.05986151f, -0.16716236f, -0.04164473f, -0.07727607f, 0.02842379f, 
    0.43959743f, 0.33789310f, -0.09347000f, -0.31580886f, -0.00786666f, 0.07471500f, 0.24992490f, -0.11163888f, 
    0.08111692f, 0.02396673f, 0.12692297f, -0.12843877f, -0.07039811f, 0.05113157f, -0.15990044f, -0.09169638f, 
    -0.18458389f, -0.00168127f, -0.07060442f, -0.02925974f, 0.17340051f, -0.15245585f, -0.04836829f, -0.15675938f, 
    0.24482426f, -0.11996014f, 0.04129892f, 0.44367567f, 0.11700828f, -0.01462936f, 0.01593477f, -0.11467978f, 
    0.11037520f, 0.33826831f, -0.09220343f, 0.13957591f, -0.35914806f, -0.08111005f, 0.19594456f, 0.07599331f, 
    0.16114888f, 0.31265110f, 0.18129666f, 0.05148781f, -0.27093348f, 0.07813642f, -0.03590566f, 0.03752314f, 
    0.02983791f, -0.24498752f, -0.27251977f, -0.13646585f, 0.12272645f, -0.17362554f, -0.07901013f, 0.27169874f, 
    -0.37719518f, -0.16889776f, 0.12057277f, -0.02184115f, -0.02827851f, 0.49565685f, -0.10311411f, 0.13206646f, 
    0.14219894f, 0.09019809f, -0.16253063f, -0.13589177f, -0.11520534f, 0.13814156f, -0.10055544f, -0.06383509f, 
    -0.13836205f, 0.02113284f, -0.04321218f, 0.15357025f, 0.09956533f, -0.06030412f, -0.16063738f, -0.03237840f, 
    0.12792681f, 0.03971571f, -0.11260712f, -0.10915524f, -0.07815277f, 0.03920826f, 0.16484994f, -0.16236976f, 
    -0.09518990f, -0.16611746f, 0.15173210f, -0.06698236f, -0.13836528f, -0.09923051f, 0.14089487f, 0.11868289f, 
    0.13399914f, 0.26070070f, -0.15005606f, 0.00559564f, -0.14853796f, -0.13515672f, 0.18915953f, 0.01407910f, 
    -0.15074061f, 0.23034006f, -0.16356380f, -0.08677384f, -0.15335470f, 0.35216939f, 0.16633536f, -0.11950750f, 
    -0.15362976f, -0.25918594f, -0.12202642f, -0.24136665f, -0.02020741f, -0.28139287f, 0.08013754f, 0.05058955f, 
    -0.37438989f, 0.08665904f, -0.05307971f, 0.21314734f, 0.19003743f, 0.37196395f, -0.05346667f, -0.12577020f, 
    0.07272328f, 0.00123788f, 0.18096329f, 0.06486931f, -0.46894744f, -0.11319851f, -0.04101647f, -0.09122003f, 
    -0.02705111f, 0.02758693f, 0.03883608f, 0.05754641f, 0.22999224f, -0.31265476f, 0.13423556f, -0.12148653f, 
    0.07742906f, -0.07545760f, -0.29423994f, 0.31042463f, -0.03550421f, -0.13630395f, 0.06492592f, 0.14633533f, 
    0.13131467f, 0.13371311f, -0.09113473f, 0.12568471f, -0.15619615f, 0.08518583f, 0.16710228f, -0.00325049f, 
    0.26271784f, -0.00251929f, -0.19161309f, 0.17966338f, 0.03792860f, -0.12985730f, 0.12513535f, 0.30552444f, 
    -0.11148227f, -0.06647093f, -0.04791549f, 0.00881257f, 0.09160075f, -0.31046537f, 0.10520166f, -0.08440609f, 
    0.12350763f, 0.17671843f, 0.15333202f, 0.20035668f, 0.09202269f, 0.03820056f, -0.03210164f, 0.10142530f, 
    0.23822378f, -0.20742477f, -0.56617248f, -0.00799632f, -0.02814216f, -0.40383023f, -0.00634510f, 0.03361843f, 
    -0.32676679f, -0.05583731f, 0.12396431f, 0.12387118f, -0.37660146f, -0.14403318f, 0.10326786f, -0.13194774f, 
    0.03350116f, 0.16681825f, -0.01862122f, -0.01353797f, -0.16869597f, -0.30549613f, -0.00885235f, 0.17280151f, 
    -0.00804620f, -0.00839728f, 0.05935478f, 0.08113170f, -0.09220732f, -0.14894737f, 0.04938591f, 0.13879120f, 
    -0.03999069f, 0.14444992f, 0.26406831f, -0.00656550f, 0.06010379f, 0.19691756f, -0.06814469f, -0.16392396f, 
    -0.13926493f, 0.17473565f, -0.19415504f, 0.09366398f, -0.06038711f, 0.03278126f, -0.15549174f, -0.11329294f, 
    0.02292294f, 0.29018259f, -0.06690466f, 0.07979567f, 0.10824049f, 0.15162109f, 0.25011280f, 0.04147748f, 
    -0.09838342f, -0.14408053f, 0.25750539f, 0.01998171f, -0.01263647f, -0.01254061f, -0.03208567f, 0.01113071f, 
    -0.03132116f, -0.10311417f, 0.00963931f, -0.11000573f, 0.37817863f, -0.02111906f, -0.13220572f, -0.07813098f, 
    0.41093186f, 0.23106170f, 0.00178740f, -0.00134731f, 0.20251641f, -0.10087058f, -0.17999855f, 0.31433943f, 
    0.16798654f, -0.18592453f, -0.17434298f, 0.02051614f, 0.11886799f, 0.23343110f, 0.03958552f, 0.05222356f, 
    0.07822701f, 0.05511985f, -0.25376478f, -0.13731429f, -0.16610698f, 0.00130610f, 0.11822405f, -0.13873464f, 
    -0.08439869f, -0.03651724f, -0.33968222f, 0.40443981f, 0.00738936f, 0.05069458f, 0.12783553f, 0.10587751f, 
    -0.04012027f, -0.16864334f, -0.14774288f, -0.01092936f, -0.17981133f, 0.10998665f, -0.19576256f, 0.00214941f, 
    0.04581651f, -0.13135247f, -0.07052553f, 0.14715752f, 0.01486060f, -0.03412421f, -0.08469503f, 0.12875922f, 
    -0.00259872f, -0.03950711f, -0.15178458f, 0.12419865f, -0.03594398f, -0.01815027f, -0.11932136f, -0.05781950f, 
    -0.11449745f, 0.08754312f, -0.06300185f, -0.11469190f, 0.09516260f, -0.14372337f, 0.16246599f, 0.10795234f, 
    0.38695809f, 0.22025643f, 0.10695212f, 0.11410952f, -0.14162262f, 0.11085017f, 0.23675975f, -0.07972728f, 
    -0.07774814f, 0.07954776f, -0.14659807f, 0.15431064f, -0.32920763f, 0.29194587f, 0.32386345f, 0.15556908f, 
    -0.20822173f, -0.31280205f, -0.31673059f, -0.03634768f, -0.06138946f, -0.34410629f, -0.13312399f, 0.06161004f, 
    -0.24609208f, -0.26155579f, 0.14209759f, 0.32941705f, -0.09369147f, 0.43105263f, -0.02521357f, 0.12745516f, 
    -0.01910141f, -0.00653076f, -0.04126297f, 0.11934353f, -0.00465943f, -0.13418926f, -0.12588847f, -0.07633341f, 
    0.07768548f, -0.08143313f, 0.07962412f, 0.02131425f, -0.00949102f, 0.00000652f, -0.02975103f, 0.00631047f, 
    -0.10416502f, -0.05375115f, -0.12565678f, 0.02557993f, -0.12194022f, -0.14897373f, -0.10743844f, -0.01212035f, 
    -0.00130389f, 0.06301137f, 0.11247322f, -0.06441668f, -0.09673146f, 0.04293832f, -0.16161403f, -0.00581500f, 
    0.16043124f, -0.12132653f, -0.07692422f, 0.06190451f, -0.16715004f, 0.16932207f, 0.04959717f, 0.06650258f, 
    -0.03947994f, 0.01103709f, 0.13213414f, 0.12951927f, -0.17534350f, 0.01195676f, -0.15733032f, 0.03624558f, 
    0.05407509f, -0.17117341f, -0.03182955f, -0.02514120f, -0.05313169f, -0.15324451f, 0.17650586f, -0.08443778f, 
    -0.00384521f, -0.06693073f, -0.06182436f, -0.08539542f, -0.01880983f, -0.07022925f, -0.16670237f, -0.08187927f, 
    0.13540968f, 0.05153392f, -0.18999451f, 0.00680680f, -0.02374949f, 0.13021582f, -0.08829012f, -0.04746443f, 
    -0.07425626f, -0.14899200f, 0.07358651f, 0.08813701f, 0.00865118f, -0.07432462f, 0.09565873f, 0.07727076f, 
    -0.14460286f, 0.13493849f, 0.08460487f, 0.01097551f, -0.18018915f, -0.07942276f, -0.12032718f, -0.14027619f, 
    -0.18125173f, -0.03289486f, 0.07854159f, -0.10182697f, -0.09877994f, 0.04248679f, -0.02360175f, 0.04410196f, 
    0.26540315f, 0.17043152f, -0.35872915f, 0.01127302f, -0.00008691f, -0.10069819f, -0.09389061f, -0.18687855f, 
    -0.11665276f, 0.33561778f, 0.05776601f, 0.07267460f, 0.07374379f, 0.21075989f, -0.15997528f, 0.08705363f, 
    0.01668180f, -0.05219875f, 0.41297805f, 0.12400761f, 0.04635124f, 0.10450403f, -0.12059540f, -0.13517970f, 
    0.42801237f, -0.07259756f, 0.01387767f, 0.14045495f, 0.36908492f, -0.36745396f, -0.05992157f, 0.06006562f, 
    0.10945848f, -0.15892529f, 0.25712997f, -0.06348122f, -0.07896666f, -0.12527731f, 0.20660217f, -0.11404368f, 
    -0.09855328f, -0.18524341f, -0.06091456f, -0.09127175f, 0.32522783f, 0.03278945f, -0.18254682f, 0.15545161f, 
    -0.24387157f, -0.21365967f, -0.01654050f, -0.39406875f, 0.16773017f, 0.17518452f, -0.04288863f, 0.15979318f, 
    0.00312019f, 0.21061644f, 0.35878798f, -0.06211157f, -0.12222017f, -0.07325559f, -0.09290364f, 0.16814844f, 
    -0.13390523f, 0.19355035f, 0.27309349f, -0.09279872f, 0.02781748f, 0.03924562f, -0.05657372f, 0.09017336f, 
    -0.09356617f, 0.02190924f, 0.14218654f, -0.04013999f, 0.25056246f, -0.21725923f, 0.22203961f, 0.02212574f, 
    0.02679332f, -0.05613043f, -0.14795391f, 0.11650128f, 0.12780841f, 0.34578267f, -0.13984604f, 0.17726143f, 
    -0.01114190f, 0.10528953f, -0.11571374f, -0.07740646f, -0.22666089f, -0.06257257f, 0.05070736f, 0.08027687f, 
    0.09622969f, -0.17061181f, -0.30720872f, 0.24593557f, 0.39656356f, 0.03423310f, -0.18295619f, 0.32921419f, 
    -0.06242189f, 0.09529015f, 0.15934847f, 0.08567081f, -0.09175058f, 0.22821872f, -0.07737929f, 0.11959018f, 
    -0.06953719f, -0.22507682f, 0.03308865f, 0.23720005f, 0.14246750f, 0.27566171f, -0.00652413f, -0.16641313f, 
    0.05073274f, 0.38840005f, -0.06816623f, 0.14172623f, 0.23751986f, -0.06205475f, 0.00726726f, 0.06367059f, 
    -0.02124055f, -0.12084766f, 0.09822228f, -0.16286550f, -0.13046329f, 0.04807274f, -0.00989774f, -0.02166222f, 
    0.09309665f, -0.15407906f, 0.13380253f, -0.15563636f, -0.09231886f, -0.15595227f, -0.07036082f, -0.01375483f, 
    0.13504411f, -0.04787654f, -0.10061470f, -0.03429778f, 0.17442594f, -0.04332156f, 0.07128404f, 0.08327726f, 
    0.02313332f, -0.14336577f, -0.14539808f, 0.10621838f, -0.11612158f, -0.19172324f, 0.10110395f, 0.15833287f, 
    0.24036424f, 0.40929088f, -0.05534442f, -0.21439193f, 0.43700552f, 0.14533183f, 0.08711523f, -0.06603140f, 
    0.04452115f, 0.11710705f, 0.00256804f, -0.10596687f, -0.28070748f, 0.00447318f, -0.18014015f, -0.17806120f, 
    -0.02260142f, -0.25977826f, 0.05145393f, 0.05127640f, -0.01514157f, 0.12443160f, -0.17106260f, 0.15191156f, 
    -0.01603946f, -0.20489281f, -0.55415142f, -0.21875748f, -0.02537706f, -0.00115615f, -0.15161712f, -0.05599657f, 
    -0.04651048f, 0.29820561f, 0.05868175f, 0.13068211f, -0.19271289f, 0.00149505f, 0.25586259f, -0.12272052f, 
    0.08030627f, -0.15345587f, 0.14984542f, 0.02139413f, 0.10284696f, -0.21039036f, -0.04680995f, 0.12717076f, 
    -0.09931330f, 0.00133023f, -0.18312249f, -0.13646200f, -0.01586458f, -0.09754065f, 0.07505506f, 0.11536021f, 
    0.06189259f, 0.09159100f, -0.16001150f, -0.05643662f, 0.04583952f, 0.04939216f, -0.06239131f, -0.10161818f, 
    -0.10679723f, 0.09892131f, 0.14817365f, 0.05111419f, 0.11163783f, -0.10475949f, -0.18128608f, -0.14631967f, 
    0.00803475f, 0.14837353f, -0.13078324f, -0.05126808f, -0.12009710f, 0.07455855f, -0.08767586f, 0.11367258f, 
    -0.01576670f, -0.23918056f, -0.12936285f, -0.03183284f, -0.17119007f, -0.08914874f, 0.07622818f, -0.12494627f, 
    -0.15414555f, -0.19848499f, 0.16193549f, -0.04146595f, -0.15905745f, -0.01593653f, 0.00930141f, -0.05794406f, 
    0.41648445f, -0.13116850f, 0.18919733f, -0.04209633f, -0.15181473f, 0.16579509f, -0.06354386f, -0.03975140f, 
    -0.00881136f, -0.17683908f, 0.14088494f, -0.03502897f, -0.07732233f, 0.26093000f, -0.27721140f, 0.07400837f, 
    -0.05491989f, 0.16548349f, 0.25604075f, -0.12978095f, -0.13774695f, -0.05792950f, 0.02422488f, 0.27703518f, 
    0.11663578f, 0.00641267f, 0.17552906f, -0.04691083f, -0.16414075f, 0.07211915f, -0.12784375f, 0.03943565f, 
    -0.08952538f, -0.16727570f, -0.02679508f, -0.02854542f, -0.01191528f, -0.04887446f, 0.07311206f, -0.19222039f, 
    -0.03300706f, 0.15660186f, 0.09921037f, 0.13031840f, -0.05646059f, -0.02106143f, -0.15452144f, 0.02846596f, 
    0.04322596f, -0.11216749f, -0.01907962f, 0.08679725f, 0.17366333f, 0.08375206f, -0.14912739f, -0.10326316f, 
    -0.12334918f, -0.08512160f, -0.10904296f, 0.12609001f, -0.03638234f, 0.08067193f, 0.06544165f, 0.13137721f, 
    -0.11361057f, 0.14173265f, -0.20096381f, -0.18005572f, 0.03435494f, -0.16652426f, -0.02788547f, 0.11271670f, 
    0.15646455f, -0.05655002f, -0.07090259f, 0.18172449f, -0.17527877f, 0.00444920f, -0.17597748f, -0.03536197f, 
    -0.05930760f, -0.04522383f, 0.14081997f, 0.00267144f, 0.04193625f, -0.03658183f, 0.10452686f, -0.08867949f, 
    0.01995919f, 0.01396330f, 0.04762116f, 0.11980870f, -0.09710404f, -0.12086417f, 0.11426092f, -0.02709370f, 
    0.35100871f, 0.04285282f, -0.09323421f, 0.19502975f, 0.04054442f, 0.08510793f, -0.21375917f, -0.04792715f, 
    0.17041583f, -0.09827893f, -0.07625253f, 0.08387803f, -0.28547958f, 0.09041633f, 0.00224717f, -0.05642430f, 
    0.10920402f, 0.12170952f, 0.37984312f, 0.05028811f, 0.06079962f, -0.38532507f, -0.08330038f, 0.04344367f, 
    0.00010589f, -0.11760967f, -0.36880428f, -0.39170209f, 0.10290433f, 0.23624465f, -0.13563114f, -0.13644785f, 
    0.04063254f, -0.00571654f, 0.31557962f, -0.12216699f, 0.13750522f, -0.05838998f, -0.13141608f, 0.15939407f, 
    0.09032597f, -0.28256041f, 0.09888732f, -0.05571062f, 0.22486974f, -0.30172014f, 0.11934595f, 0.10696071f, 
    0.16512585f, 0.15877496f, -0.07981841f, 0.42461735f, -0.06153774f, 0.38786545f, -0.15123726f, 0.17794767f, 
    0.29631731f, -0.09729989f, -0.13430916f, -0.12389609f, -0.09425850f, -0.42637759f, -0.13764158f, 0.05290240f, 
    0.34786320f, 0.07354096f, -0.06019645f, -0.00523097f, -0.15989329f, 0.00803934f, 0.05318902f, -0.06412810f, 
    -0.08046731f, 0.19416657f, 0.03897348f, 0.09476445f, -0.20690344f, -0.06406953f, -0.28114492f, -0.12785183f, 
    -0.10685743f, -0.30048475f, -0.06886046f, -0.02470693f, 0.06716077f, 0.03084503f, -0.15326552f, -0.15035295f, 
    -0.38037771f, -0.51226485f, 0.17164172f, 0.30131102f, 0.21832231f, 0.06871457f, -0.09267748f, 0.01482739f, 
    0.01600208f, 0.00313685f, -0.00502718f, -0.13019688f, 0.08739968f, -0.03641772f, -0.05655929f, 0.08572027f, 
    0.08148833f, -0.16028695f, 0.09121136f, -0.13942795f, -0.05014074f, -0.29136792f, 0.36026123f, 0.05134140f, 
    -0.26541355f, 0.07946339f, -0.05761480f, 0.42983824f, -0.08798862f, 0.46027792f, 0.02400498f, 0.24367628f, 
    0.37268278f, -0.07628327f, 0.26745814f, -0.17503303f, -0.21604870f, -0.06159087f, 0.12764345f, 0.15684003f, 
    0.19376446f, -0.08465051f, 0.21504824f, 0.01754595f, -0.31141114f, 0.08928151f, -0.06708082f, -0.09461620f, 
    -0.07505941f, -0.27318820f, 0.08366138f, 0.05564828f, -0.15412490f, 0.28166997f, 0.11649672f, 0.15394299f, 
    0.40607178f, 0.30634642f, -0.03993972f, 0.00357378f, 0.14512588f, -0.59004670f, 0.13354596f, 0.10175250f, 
    0.12968369f, -0.17432734f, -0.13310860f, 0.13027900f, 0.04661039f, 0.36473826f, 0.11005155f, -0.00910659f, 
    0.00428299f, -0.13089660f, -0.15824664f, 0.26894692f, -0.03048176f, -0.14840288f, -0.23118037f, 0.10992303f, 
    0.17013511f, 0.09182731f, 0.04168195f, 0.13492444f, 0.06879785f, -0.17447823f, -0.23783533f, 0.14493674f, 
    -0.43115658f, -0.25987250f, -0.03490414f, 0.13437699f, 0.02971412f, 0.07174309f, -0.10298894f, 0.22505550f, 
    0.19206737f, 0.14832889f, 0.34785318f, 0.37466222f, 0.12101800f, 0.17745531f, 0.15157460f, -0.14461426f, 
    -0.01347982f, -0.09849156f, -0.15262869f, 0.19079749f, 0.17929998f, -0.13340676f, -0.05593751f, 0.11918820f, 
    0.00214024f, 0.10773424f, 0.02885921f, 0.00058030f, -0.03118771f, 0.05775480f, 0.02971609f, -0.00831903f, 
    -0.22065713f, 0.05839778f, -0.13543911f, -0.13247557f, -0.14706951f, 0.09818363f, 0.00207795f, 0.03147807f, 
    0.07838561f, -0.00063976f, -0.06629039f, 0.05691412f, -0.09837428f, 0.10502579f, -0.12935285f, 0.10255923f, 
    0.33018023f, 0.00799333f, 0.01157709f, 0.19193658f, 0.04136644f, -0.13818818f, -0.19324856f, -0.07632932f, 
    0.13133544f, -0.00198638f, -0.03965363f, -0.17933284f, -0.01086013f, 0.21323858f, -0.23646970f, 0.13446969f, 
    -0.22493236f, -0.28327119f, -0.07189992f, -0.06100493f, 0.12662549f, 0.22945854f, -0.04590289f, 0.08999897f, 
    0.19998366f, -0.07356505f, -0.01877576f, 0.41707256f, 0.22358598f, -0.08783104f, 0.16156547f, 0.03488393f, 
    -0.22389801f, 0.24450234f, 0.12484235f, 0.26613823f, -0.07842117f, -0.13399518f, -0.22163494f, 0.05440372f, 
    0.16121264f, 0.32304841f, -0.02983996f, -0.16128221f, -0.19117230f, 0.15848127f, -0.02950496f, -0.12766244f, 
    0.01990175f, 0.13899291f, 0.22428837f, -0.10671329f, 0.12363724f, 0.14371277f, -0.02349218f, -0.11260284f, 
    -0.00848216f, -0.00793880f, 0.07401188f, -0.39610365f, 0.20070849f, 0.12325596f, -0.12031964f, -0.16764756f, 
    0.27900031f, -0.02687437f, 0.06817139f, -0.19647697f, -0.19708264f, 0.03890119f, 0.06380188f, 0.17040917f, 
    0.08554810f, -0.46451595f, -0.11840477f, 0.08213720f, -0.00247459f, 0.12874217f, -0.31223530f, 0.02779014f, 
    0.11074223f, 0.10013196f, 0.09433612f, 0.06507826f, -0.01986748f, -0.30302441f, 0.00632827f, 0.22634405f, 
    0.33675951f, -0.16826838f, -0.01554750f, 0.26413640f, -0.06484690f, -0.19828194f, -0.05078561f, 0.14875072f, 
    0.12678482f, 0.25192517f, -0.18431813f, 0.11096212f, 0.12512925f, -0.08722737f, -0.26566035f, 0.10427583f, 
    -0.01864405f, 0.03414808f, 0.00300830f, -0.15430877f, -0.14592671f, 0.34547323f, 0.14935386f, 0.05753425f, 
    -0.16703364f, -0.18396361f, 0.16352241f, -0.19026822f, -0.12273823f, 0.23989080f, 0.06695935f, -0.13992502f, 
    0.09924547f, -0.22837123f, 0.47032133f, -0.14480770f, -0.00402627f, 0.09612785f, -0.00929558f, 0.01148626f, 
    0.05898421f, 0.21755040f, 0.10098980f, -0.07272427f, -0.09760513f, 0.10503229f, -0.11975144f, -0.09017143f, 
    -0.08598589f, -0.27334142f, 0.22584334f, 0.00438110f, 0.06532530f, 0.49954134f, 0.25655830f, -0.08053527f, 
    0.30551985f, 0.18571588f, 0.12073957f, -0.23540650f, -0.08326600f, -0.42951086f, 0.07269569f, 0.01003637f, 
    0.17502512f, -0.01360816f, -0.06675828f, -0.26206580f, -0.15819766f, 0.15277524f, 0.11136127f, -0.12364209f, 
    -0.06529172f, 0.09365768f, -0.15530731f, 0.04193044f, -0.18127868f, -0.08913749f, -0.14948571f, -0.07867141f, 
    -0.00602011f, -0.15977998f, -0.15228456f, -0.05461962f, 0.09206161f, -0.15948370f, -0.04743244f, 0.13941975f, 
    -0.14685802f, -0.11295849f, 0.08244657f, 0.13012761f, -0.14391387f, -0.01320881f, -0.08659601f, 0.07953727f, 
    -0.09935568f, 0.07246096f, -0.09139947f, 0.11564345f, -0.12404028f, 0.01267296f, -0.09630500f, 0.02357318f, 
    -0.18887857f, 0.36741728f, -0.07946914f, 0.09254892f, 0.16846353f, -0.15982881f, 0.09676576f, 0.13621211f, 
    0.10386195f, -0.14637300f, 0.15050679f, -0.08620414f, -0.13214785f, 0.05224384f, -0.26883626f, -0.06079935f, 
    -0.32244775f, -0.25687534f, 0.01747083f, 0.22896373f, 0.00731283f, 0.04964284f, -0.06004147f, -0.00095476f, 
    0.40875328f, 0.05308284f, -0.04998177f, 0.23206387f, 0.01833847f, -0.06486791f, -0.09522834f, -0.02572077f, 
    -0.06945217f, -0.19926783f, 0.30157191f, -0.31043148f, 0.00178940f, -0.10290704f, -0.13524811f, -0.17635269f, 
    0.10736822f, -0.31675985f, 0.04685819f, 0.01441441f, -0.03504244f, 0.54196513f, 0.14625464f, 0.00238320f, 
    0.20116749f, -0.00729155f, 0.28306794f, 0.25609195f, -0.01009569f, -0.04653880f, -0.01118395f, 0.08392742f, 
    0.41737282f, -0.00429256f, -0.01117533f, 0.13002738f, -0.06652547f, -0.01065462f, 0.18034473f, 0.01839474f, 
    0.49508995f, 0.11735901f, 0.18765713f, 0.10925163f, -0.27441376f, -0.06344690f, 0.16995452f, 0.29081044f, 
    0.05926818f, 0.04312630f, 0.12744540f, 0.17552447f, 0.04109173f, -0.14853370f, -0.15503657f, 0.04573416f, 
    0.03785023f, -0.02454180f, -0.01409258f, -0.15403594f, 0.04105451f, -0.19788240f, 0.12406124f, 0.23788454f, 
    -0.30905297f, -0.15862428f, -0.40931496f, -0.31786349f, 0.00800319f, -0.12671714f, -0.15866457f, -0.11282577f, 
    -0.09282804f, 0.13677704f, 0.03923642f, -0.09478188f, -0.15888688f, 0.11858772f, 0.00750419f, -0.09109662f, 
    0.17515370f, 0.03443254f, 0.15856887f, -0.13567147f, -0.05910113f, -0.01437982f, 0.01420351f, -0.06227171f, 
    -0.04141485f, 0.08082287f, 0.03357667f, -0.13952143f, -0.07527155f, -0.03414517f, -0.00060228f, -0.13308431f, 
    -0.04410309f, 0.03686950f, 0.01150289f, -0.02582143f, -0.02625057f, -0.01322836f, 0.12537187f, 0.02475495f, 
    -0.20767838f, -0.20879526f, 0.21383692f, 0.09515390f, -0.26306096f, -0.12224905f, 0.16616219f, -0.13460545f, 
    0.12781063f, 0.05734736f, 0.01158632f, 0.04779403f, 0.10457912f, -0.15186428f, 0.25107139f, -0.03286364f, 
    0.16001859f, 0.27775389f, 0.17860422f, 0.23659240f, 0.12121737f, -0.05897842f, -0.10883205f, 0.17909336f, 
    -0.18973748f, -0.09959789f, -0.11487560f, -0.39076340f, 0.20653786f, 0.07871902f, 0.09196073f, 0.14988911f, 
    0.18224274f, 0.32656574f, -0.29338795f, 0.12160952f, 0.16646397f, 0.05781347f, 0.22763920f, 0.22454681f, 
    -0.15195741f, 0.10300920f, -0.04634666f, 0.16593048f, -0.23798002f, 0.01652515f, 0.05122765f, 0.04554467f, 
    -0.16976090f, -0.26008213f, -0.19409324f, 0.03666797f, 0.11660974f, 0.24149223f, -0.07786042f, 0.05701777f, 
    0.21778721f, 0.05777713f, -0.45828876f, 0.46324345f, 0.17719702f, -0.08876345f, -0.05774559f, 0.06202269f, 
    0.01792310f, 0.01764089f, -0.04584366f, -0.28625697f, 0.42024237f, 0.16623904f, 0.08857665f, 0.26104686f, 
    0.13991594f, -0.05131632f, 0.07087512f, -0.15839960f, -0.04378470f, -0.18205810f, -0.17193495f, -0.13654073f, 
    0.27356881f, 0.29216629f, -0.12996103f, -0.04223240f, -0.03284917f, 0.25243208f, -0.14216290f, 0.10901055f, 
    0.19697054f, 0.02448861f, -0.27499676f, -0.09486644f, -0.26980019f, 0.14319977f, -0.00142718f, 0.00921332f, 
    0.30562583f, 0.32419586f, -0.18430410f, -0.02981949f, -0.07802719f, -0.06460062f, 0.01239552f, -0.05956784f, 
    0.07129113f, 0.15493143f, -0.00476484f, 0.16616580f, -0.04620560f, -0.03856416f, -0.00157784f, 0.06993623f, 
    -0.06059134f, -0.26600364f, 0.15731427f, -0.10791457f, 0.15124312f, -0.15145546f, -0.01470174f, -0.00987606f, 
    -0.09191322f, 0.31936091f, -0.20438945f, 0.17452084f, 0.11882711f, -0.16593477f, 0.03098513f, 0.15682857f, 
    0.20007996f, -0.01461105f, -0.23719347f, 0.25626689f, 0.37368035f, 0.17703401f, -0.06901789f, 0.26329771f, 
    0.02488277f, 0.42639464f, -0.11156328f, 0.12422482f, -0.27880412f, 0.16378903f, 0.18963115f, 0.02263486f, 
    -0.13736089f, -0.33777890f, -0.13133344f, 0.11919875f, -0.05706825f, 0.19170815f, 0.16760595f, 0.04238177f, 
    -0.21976204f, -0.05393740f, 0.10205691f, -0.06863804f, 0.14961541f, 0.08160390f, -0.07389215f, -0.00342971f, 
    -0.14936164f, 0.09665232f, 0.09237989f, -0.19216435f, 0.10909847f, 0.13478465f, -0.19385724f, -0.16456023f, 
    -0.13389216f, -0.12513620f, 0.11678194f, -0.14921251f, -0.11260830f, 0.12807356f, -0.14849627f, -0.13372079f, 
    0.10216273f, -0.06596196f, -0.07047001f, -0.08469778f, 0.06154015f, -0.18675029f, -0.17184998f, -0.17710900f, 
    0.11969458f, 0.08187004f, 0.08371875f, 0.01732119f, -0.06289342f, 0.00703389f, 0.01916482f, 0.13799867f, 
    -0.28364235f, 0.03216333f, 0.02212125f, 0.09691814f, 0.16417761f, -0.02476247f, 0.13589285f, -0.17003128f, 
    0.07480206f, 0.00619041f, 0.04033792f, 0.15095805f, 0.08093048f, -0.30267245f, 0.22959758f, 0.07273374f, 
    -0.03758614f, -0.06335772f, -0.30746117f, 0.24319293f, -0.13874154f, -0.07193208f, -0.01372831f, -0.01162093f, 
    0.00718623f, 0.33814979f, 0.45005813f, 0.40188083f, -0.11184088f, 0.34113643f, 0.13441990f, 0.01290045f, 
    0.05038644f, -0.00623637f, 0.15741621f, 0.25136426f, 0.12690838f, -0.13243975f, -0.11965842f, -0.10064694f, 
    -0.04594263f, 0.14370182f, 0.16672610f, 0.05033426f, -0.17601521f, 0.30799031f, -0.07135015f, 0.06949855f, 
    0.21636476f, 0.27804276f, 0.25605446f, -0.02730456f, -0.11639483f, -0.05089596f, -0.07103816f, 0.12746835f, 
    -0.08978429f, -0.29494458f, -0.06450000f, -0.37680614f, 0.25935233f, -0.21678433f, -0.08326871f, -0.12775789f, 
    0.23057459f, -0.05813357f, -0.20803285f, -0.14784083f, 0.27636087f, -0.08481991f, 0.36730176f, -0.10214569f, 
    0.04279977f, 0.19465993f, -0.17471364f, 0.00964540f, -0.02648267f, -0.08571023f, -0.10256586f, 0.11106816f, 
    -0.10538030f, -0.09363253f, -0.11240334f, -0.12079819f, 0.05906513f, -0.22147225f, 0.08573878f, -0.22240514f, 
    -0.08086371f, -0.00380574f, 0.43040013f, 0.48699439f, 0.24289879f, -0.34968454f, -0.10430735f, -0.01413415f, 
    -0.05662525f, 0.03797754f, 0.11418238f, -0.14870848f, -0.14457852f, 0.10225105f, 0.01188433f, -0.09676885f, 
    0.14193000f, -0.14849544f, 0.01434957f, -0.11150132f, 0.05261923f, 0.13416067f, -0.14467688f, 0.04016645f, 
    -0.06343092f, 0.08040948f, -0.04269890f, -0.14756735f, -0.15152395f, -0.09372315f, 0.14626242f, -0.13865861f, 
    -0.12811428f, -0.13153100f, -0.03848068f, -0.13028342f, -0.00680879f, -0.08128359f, 0.14652461f, 0.11177165f, 
    -0.01493152f, -0.20439379f, 0.28521836f, 0.09737872f, -0.19735689f, 0.12268738f, 0.21472770f, 0.12605429f, 
    -0.02788291f, -0.06740835f, 0.11744724f, -0.15083399f, -0.21737120f, 0.13419697f, -0.43488806f, -0.07361975f, 
    0.36933604f, 0.37527218f, -0.27045339f, -0.26357961f, -0.11871330f, -0.01085545f, -0.04882722f, 0.21586446f, 
    0.00847660f, -0.07653506f, 0.12627226f, 0.19543166f, -0.08639833f, 0.08722749f, -0.01220704f, 0.08488995f, 
    0.11914611f, -0.04326119f, 0.30163348f, 0.03242374f, -0.42081973f, 0.09787382f, 0.20168014f, 0.19853161f, 
    0.01994751f, -0.14633964f, 0.01258520f, 0.05857584f, -0.11897450f, -0.06396035f, -0.27086926f, -0.07394288f, 
    0.08958592f, 0.21104425f, -0.17375922f, -0.20132600f, 0.04113466f, -0.34805974f, 0.07074526f, 0.32666969f, 
    -0.39308673f, 0.01379384f, -0.16124648f, -0.18607831f, 0.07381158f, 0.28052771f, -0.04321708f, 0.14829092f, 
    -0.64829320f, 0.16264716f, -0.06748528f, -0.10463783f, -0.13187973f, -0.08864194f, 0.18319514f, 0.17007084f, 
    -0.03936486f, 0.20038685f, 0.07174136f, 0.16557023f, -0.11643703f, 0.08984325f, -0.38994613f, -0.17799523f, 
    -0.13125300f, 0.22850513f, 0.06170803f, -0.00860749f, 0.14812897f, -0.04199610f, 0.13740216f, 0.03844837f, 
    -0.03740106f, 0.34067568f, 0.17558743f, 0.24399012f, -0.06227367f, 0.37348902f, -0.12647584f, 0.09672838f, 
    0.34785527f, 0.10373627f, 0.01315471f, -0.09863667f, 0.38966966f, -0.11919831f, 0.04234012f, 0.19104603f, 
    0.10247567f, -0.34849250f, 0.03329581f, 0.12619147f, 0.28161412f, 0.14434348f, -0.33650738f, -0.08986091f, 
    -0.09559070f, 0.03956141f, 0.10597394f, 0.04314237f, -0.10246670f, 0.17643902f, 0.16333391f, 0.06103012f, 
    0.05890331f, 0.50353003f, 0.05877444f, 0.33503580f, -0.21439092f, -0.20578571f, 0.09848271f, 0.16256461f, 
    0.04602483f, -0.01579234f, 0.05130709f, -0.05257991f, -0.15570284f, 0.15335160f, 0.10782603f, -0.06723048f, 
    0.07637244f, -0.19020176f, 0.08800924f, -0.11560322f, -0.09993353f, -0.04678541f, 0.10189646f, 0.07609116f, 
    -0.00280203f, -0.20860501f, -0.10212537f, 0.00628482f, -0.16836312f, -0.06577294f, 0.11858588f, -0.26439276f, 
    0.05940973f, -0.09002697f, -0.19847548f, -0.10501509f, 0.00543434f, -0.06652619f, -0.14343295f, 0.15329334f, 
    -0.52341861f, 0.08932153f, 0.05938289f, 0.08027977f, -0.14792176f, 0.06236269f, 0.16565871f, -0.12840478f, 
    0.13878702f, -0.06968971f, -0.14037943f, -0.06330842f, -0.10723541f, 0.00841217f, -0.22006720f, -0.11291760f, 
    0.12607609f, 0.10882984f, 0.43249628f, 0.08195530f, -0.03019870f, -0.17535298f, -0.01290994f, -0.02051583f, 
    0.26564217f, 0.04265638f, 0.04692419f, -0.15453970f, 0.24074928f, 0.12184504f, -0.04914792f, 0.04039874f, 
    0.28122473f, -0.00128945f, -0.17906807f, -0.35280445f, 0.00477940f, -0.06926438f, 0.04137139f, 0.23395264f, 
    0.00885252f, -0.26537788f, -0.17522559f, 0.15781626f, -0.16437593f, 0.22511671f, -0.03844361f, 0.14696962f, 
    -0.23017980f, -0.22901537f, -0.04294334f, -0.07830129f, -0.11282161f, 0.05352169f, 0.01732505f, -0.02350590f, 
    0.17056775f, 0.20246391f, 0.03456056f, 0.08562585f, -0.00712552f, 0.26419798f, -0.15168889f, -0.04520435f, 
    -0.33570108f, -0.24687818f, -0.26603171f, 0.27875957f, 0.14565283f, 0.15871651f, -0.06161840f, 0.06301565f, 
    0.01192713f, -0.00352356f, -0.01811360f, 0.05202162f, 0.27940792f, -0.08621369f, 0.24922508f, 0.00608495f, 
    0.04408297f, -0.08487073f, 0.08683690f, 0.38469419f, 0.07525252f, 0.24091303f, 0.16569860f, -0.00007378f, 
    0.24430469f, -0.05786584f, 0.04834809f, 0.05987740f, 0.33296058f, -0.16592987f, -0.02553053f, -0.02312482f, 
    0.15774032f, -0.20971209f, -0.11447941f, 0.03864919f, 0.38286075f, -0.12853442f, -0.14115795f, -0.08305740f, 
    0.11964736f, -0.01466654f, -0.01568205f, 0.03897440f, 0.29199323f, 0.44248196f, -0.14996518f, -0.14452673f, 
    -0.13191548f, 0.18166582f, 0.34275717f, -0.29687545f, -0.09418112f, 0.14183626f, 0.14848988f, -0.02716973f, 
    -0.18651453f, 0.24961174f, 0.43431714f, 0.05126391f, 0.10683006f, -0.17214173f, 0.06265150f, 0.04763508f, 
    0.02457843f, 0.19732206f, 0.21063982f, 0.27284646f, -0.29211169f, -0.06792544f, -0.17262629f, 0.16489117f, 
    0.08789879f, -0.20831920f, 0.15849209f, 0.05178368f, 0.02244413f, 0.04618085f, 0.21710789f, -0.13079977f, 
    -0.16007149f, -0.31422210f, -0.36701363f, -0.22880349f, -0.15587986f, -0.01600400f, 0.10946736f, 0.18270274f, 
    -0.06642491f, -0.20909187f, 0.26694468f, 0.24823439f, -0.02612644f, 0.38379765f, 0.00871871f, 0.02575286f, 
    0.02978312f, 0.08439146f, -0.15099505f, 0.10088655f, 0.07224390f, 0.07592285f, -0.17925952f, 0.06246849f, 
    0.04441702f, -0.01182395f, 0.06862782f, -0.12599277f, -0.14284013f, 0.16749659f, -0.11393075f, 0.04568722f, 
    0.12358593f, -0.17226097f, -0.09114382f, 0.08051213f, 0.03492340f, -0.17463800f, 0.13645248f, -0.16697295f, 
    0.02960785f, 0.11149293f, -0.10543075f, -0.21991591f, -0.07977789f, -0.00874714f, 0.14436737f, -0.00386310f, 
    -0.13185930f, 0.01274367f, -0.06599654f, -0.12617165f, -0.13859583f, 0.05994865f, -0.07432647f, 0.11468187f, 
    0.00342755f, -0.14021243f, 0.09075763f, -0.03874178f, -0.00985832f, -0.05488446f, -0.13449237f, -0.16235539f, 
    -0.18742560f, -0.05226020f, 0.09707650f, 0.09796895f, -0.03542537f, -0.12141858f, -0.16136408f, -0.18418592f, 
    -0.04607603f, 0.03717291f, -0.13826726f, 0.04229074f, -0.08941195f, 0.01355723f, -0.01703949f, 0.03412375f, 
    0.29849187f, -0.16509558f, 0.15631492f, -0.27226749f, 0.30795866f, 0.06797020f, 0.12967053f, 0.06465903f, 
    -0.04338963f, -0.45777100f, -0.09752443f, 0.10031967f, 0.42623770f, 0.10869314f, -0.05054342f, 0.05866955f, 
    0.03405327f, 0.09293502f, 0.17745750f, 0.11814536f, 0.08153444f, -0.01311480f, 0.13091202f, 0.08924995f, 
    0.33635387f, 0.11124737f, -0.05547453f, 0.35020626f, -0.12230082f, -0.25505543f, 0.14394529f, 0.06722261f, 
    -0.06317808f, 0.04662022f, -0.11189005f, 0.33675283f, 0.13768677f, 0.16934426f, -0.01690114f, 0.03914769f, 
    -0.06336625f, 0.16530620f, 0.03986072f, -0.02570022f, -0.23889691f, 0.19608697f, -0.32091883f, 0.02115258f, 
    -0.25294632f, 0.03666475f, 0.38944164f, -0.01441117f, 0.13338859f, 0.16094080f, 0.11804409f, 0.18796460f, 
    -0.33279884f, 0.45773855f, -0.13138531f, -0.15771909f, 0.14039983f, 0.20185190f, 0.15774564f, -0.01421449f, 
    0.12216267f, -0.00746921f, -0.01156743f, 0.03666831f, -0.22192948f, 0.06764849f, -0.15943530f, 0.06372620f, 
    0.10727989f, -0.17864724f, -0.17376041f, -0.05898576f, 0.12412822f, -0.08715785f, 0.06631233f, -0.15573104f, 
    -0.17402418f, 0.06887669f, 0.03577862f, -0.18843395f, -0.16216654f, -0.05079044f, 0.11864738f, 0.10088943f, 
    -0.18796460f, -0.14714968f, -0.23738742f, -0.04937163f, -0.15115066f, 0.13716109f, 0.04333627f, 0.03734259f, 
    0.19409247f, 0.27843753f, -0.18734963f, 0.29187518f, 0.16406652f, -0.14961347f, -0.13159707f, 0.23919187f, 
    -0.12894487f, 0.52134359f, -0.10829768f, 0.05867265f, -0.37587973f, -0.03078329f, -0.11010706f, -0.02162158f, 
    0.02783970f, -0.14673594f, -0.11125525f, 0.02580277f, 0.00568229f, 0.14249392f, -0.04126914f, -0.16940401f, 
    -0.06267443f, -0.24128768f, -0.07171216f, -0.50740629f, 0.16142665f, -0.01734074f, 0.10506297f, 0.02460194f, 
    -0.26251033f, 0.25073606f, -0.19799788f, 0.12141410f, 0.30328727f, -0.01035115f, 0.23458853f, -0.02019465f, 
    -0.16710302f, 0.22331797f, -0.08942842f, 0.07612606f, -0.23068313f, -0.21103920f, -0.01471987f, 0.06244975f, 
    -0.08909766f, 0.08197626f, -0.07456049f, 0.51046932f, -0.05105142f, 0.44205827f, -0.12683396f, 0.12125481f, 
    0.53287333f, -0.18056110f, -0.23915969f, 0.14348713f, 0.09677730f, -0.31188628f, 0.01348283f, 0.03699429f, 
    0.19015659f, -0.01789993f, 0.37328085f, 0.16940111f, -0.36856014f, -0.01339145f, -0.16424738f, -0.08137013f, 
    -0.11874954f, 0.02532109f, -0.09823243f, 0.14139557f, 0.02626885f, 0.25581390f, -0.03496880f, -0.02335454f, 
    -0.07787351f, 0.14087071f, 0.19426875f, -0.34314737f, -0.07556014f, -0.02710918f, -0.16657808f, 0.30684879f, 
    -0.15231809f, 0.19301574f, 0.30058810f, -0.14757958f, -0.17145653f, 0.15633829f, -0.10376447f, 0.07103509f, 
    0.17238864f, -0.03031088f, -0.32536098f, -0.11367083f, -0.05955466f, -0.17435019f, 0.32020402f, 0.09955230f, 
    -0.17116301f, 0.39085051f, 0.07099006f, 0.02674742f, 0.05639327f, -0.44439968f, -0.43174276f, 0.08477212f, 
    -0.16004820f, -0.10783271f, -0.29197893f, -0.18668051f, 0.12131932f, -0.15270874f, -0.06558195f, 0.17693499f, 
    -0.12297863f, -0.35673982f, 0.10468391f, 0.20888020f, 0.03493571f, -0.31133521f, -0.10566176f, -0.06963015f, 
    -0.08370338f, -0.17388706f, 0.24120730f, -0.01872708f, 0.14625821f, 0.10821815f, 0.30927989f, -0.02875867f, 
    -0.02745344f, -0.16425386f, -0.00047263f, 0.01818284f, 0.32509980f, -0.22117394f, -0.04188498f, 0.13650364f, 
    0.25531402f, 0.35489002f, 0.34419915f, 0.02209583f, -0.14639564f, -0.25807086f, 0.03915828f, -0.10739524f, 
    0.14959751f, -0.01192533f, 0.03289166f, 0.21145728f, 0.13033928f, -0.26153910f, 0.15111300f, 0.07909986f, 
    -0.15395457f, 0.11410358f, 0.32270393f, 0.18699250f, 0.12489939f, 0.09684870f, -0.02870890f, 0.36470562f, 
    0.11968842f, 0.18882723f, 0.10467900f, 0.10560244f, -0.21231657f, -0.16866753f, 0.20346576f, -0.00484264f, 
    0.04403983f, -0.08745567f, -0.46887088f, 0.09608065f, -0.18390888f, 0.15318161f, 0.09893161f, 0.17061387f, 
    -0.26746875f, -0.06777991f, 0.01329156f, -0.25820780f, -0.16512761f, 0.35327914f, 0.09604230f, -0.00606198f, 
    0.19713752f, 0.34204850f, -0.17465524f, -0.22338049f, 0.23323683f, 0.06658901f, 0.28239924f, -0.14840445f, 
    -0.10440186f, -0.34371164f, 0.06329308f, 0.03313657f, -0.18351838f, -0.10631682f, 0.05488584f, 0.11981787f, 
    -0.12824054f, -0.11150824f, 0.15138762f, 0.30975905f, -0.08357397f, 0.15954095f, 0.08774790f, 0.07616348f, 
    0.54060578f, -0.20291205f, -0.14740269f, 0.44909644f, -0.11762075f, -0.04977973f, -0.16673249f, 0.06992865f, 
    -0.08158494f, -0.29213393f, 0.21340716f, -0.14487036f, -0.39143971f, 0.13698162f, 0.00772785f, 0.25387120f, 
    0.11511718f, -0.08015485f, -0.09879786f, -0.04280350f, -0.08269811f, 0.01507141f, -0.13509659f, -0.10290828f, 
    0.12178304f, 0.33923689f, 0.13645521f, -0.15882419f, -0.03297106f, -0.41541025f, -0.06946239f, 0.32002580f, 
    0.16623838f, -0.21545276f, 0.05876208f, 0.11097252f, -0.17259698f, -0.03384408f, 0.12974159f, 0.02840672f, 
    -0.04176364f, -0.16935715f, 0.09240858f, -0.09799068f, 0.11427265f, 0.12130880f, 0.20110555f, -0.19105108f, 
    -0.11014534f, -0.13127391f, -0.01437915f, 0.14755203f, 0.33359793f, -0.36109146f, 0.08148943f, 0.13662525f, 
    -0.10671568f, -0.02469154f, -0.13954169f, -0.30284464f, -0.09549403f, 0.00162461f, 0.09177651f, 0.26022303f, 
    -0.00763053f, 0.01022032f, 0.46141231f, 0.21180928f, -0.11690146f, 0.11299781f, -0.00669386f, -0.01641057f, 
    -0.18586153f, 0.19663233f, 0.09676123f, 0.19201714f, -0.28243965f, 0.15871021f, 0.04678499f, 0.17682822f, 
    -0.13676852f, 0.02375278f, 0.15730041f, 0.01832512f, -0.02518581f, -0.05601253f, 0.38818187f, -0.09109243f, 
    -0.37065148f, -0.32917458f, -0.24828272f, 0.02321353f, 0.07434157f, -0.06108368f, -0.00698232f, 0.25286531f, 
    -0.06137431f, -0.26889363f, 0.05641101f, -0.25291815f, 0.03501816f, 0.37382343f, -0.02069832f, 0.10120937f, 
    -0.12950854f, -0.13197225f, 0.25057763f, -0.16052887f, 0.09320042f, 0.01052154f, -0.15304211f, -0.06276473f, 
    0.12569308f, -0.46702427f, -0.04338039f, 0.02987440f, 0.35142958f, 0.33927771f, 0.23144704f, -0.10169327f, 
    0.08684088f, 0.16954403f, 0.12477443f, 0.02409448f, -0.16305713f, -0.25028953f, 0.08859202f, 0.16825800f, 
    0.07181843f, 0.08942478f, -0.22230858f, -0.02053368f, 0.09681733f, -0.27037886f, -0.11637023f, -0.15487459f, 
    -0.42239651f, -0.21891996f, 0.30926302f, -0.22042212f, 0.09699197f, 0.09028519f, 0.17108348f, 0.13596457f, 
    -0.17077395f, 0.00756071f, -0.18773104f, 0.09032174f, -0.04019496f, 0.24609551f, 0.27056140f, 0.02790716f, 
    0.25165763f, 0.16958497f, 0.15266669f, 0.29111671f, -0.16847441f, -0.16033338f, 0.11541836f, -0.15814483f, 
    0.11254839f, -0.13139004f, 0.18045360f, 0.08853331f, 0.19487955f, -0.17986463f, -0.10586116f, -0.06116022f, 
    0.01355190f, -0.13981232f, -0.14855047f, -0.11292196f, -0.00432422f, -0.06553279f, -0.09476896f, 0.00664702f, 
    0.11206900f, -0.07494614f, -0.06507082f, 0.10413510f, -0.13453881f, -0.13663612f, -0.13282062f, 0.00871782f, 
    0.13215330f, -0.07352185f, -0.14822765f, -0.15884563f, 0.03537640f, 0.01044572f, 0.08806799f, 0.05212063f, 
    0.11075783f, -0.03500620f, 0.15882812f, 0.13033766f, -0.15705746f, -0.14105378f, -0.08784817f, -0.11160313f, 
    -0.30049694f, 0.00544006f, 0.21905203f, 0.16610184f, 0.41900903f, -0.08176026f, -0.15083022f, 0.38557538f, 
    -0.05260175f, 0.07082883f, -0.16770536f, 0.05543856f, -0.37097770f, -0.17972837f, -0.13941585f, -0.11107281f, 
    0.15834086f, 0.15203840f, -0.25796810f, 0.02327266f, 0.00719720f, 0.34330586f, -0.00937426f, -0.04435442f, 
    0.01433628f, 0.17206825f, -0.09513087f, 0.02106954f, -0.18657216f, 0.16780376f, -0.05376625f, 0.12840027f, 
    0.06526648f, -0.18274222f, 0.05628618f, -0.14721443f, 0.07305773f, -0.15743521f, 0.00091776f, -0.15109323f, 
    -0.05338720f, -0.02705248f, -0.11837937f, 0.06284492f, 0.10064538f, -0.17959088f, 0.06689525f, -0.10115736f, 
    0.07797439f, 0.04215200f, 0.09229377f, -0.02522582f, -0.16080539f, 0.04201014f, 0.02330949f, -0.13024995f, 
    -0.10759448f, 0.00590050f, 0.12707315f, -0.15017559f, -0.14051068f, -0.13498054f, 0.05843033f, -0.02826758f, 
    0.57833439f, 0.29345852f, 0.25109985f, -0.28858224f, 0.14172855f, -0.06965413f, 0.21507463f, 0.00091487f, 
    -0.17376670f, 0.09314118f, -0.08330423f, 0.00282427f, -0.23005800f, 0.00683273f, 0.00459405f, -0.14088626f, 
    -0.05479630f, 0.15549067f, -0.05875278f, -0.29949898f, -0.01230473f, -0.19699770f, -0.04085004f, 0.27389270f, 
    -0.12958512f, -0.09565476f, -0.29454309f, -0.13721338f, -0.14915264f, -0.00562982f, -0.07319808f, -0.12436600f, 
    -0.36641786f, 0.00908818f, 0.20239523f, 0.17227665f, -0.18328968f, 0.00158853f, 0.04487282f, -0.14953791f, 
    0.04662313f, 0.33467478f, 0.02590865f, 0.04648413f, -0.16429776f, -0.09945024f, 0.32098833f, -0.14584330f, 
    -0.05813725f, 0.13520396f, 0.00224126f, 0.28976658f, 0.08366143f, -0.03367826f, -0.07061948f, 0.20583835f, 
    0.13263822f, -0.43844399f, -0.13461579f, -0.29633510f, 0.20161800f, 0.08948587f, -0.02682708f, -0.15983625f, 
    0.07412320f, -0.22517130f, 0.13491702f, 0.01145844f, -0.03994634f, 0.10184566f, 0.29071093f, 0.31415546f, 
    -0.10996997f, -0.02980946f, 0.04800596f, -0.00293230f, -0.07239851f, -0.24680194f, 0.25833771f, -0.16518717f, 
    0.30431566f, 0.10971435f, -0.43586388f, 0.05099450f, 0.07922928f, -0.23056743f, 0.08198857f, -0.18107909f, 
    0.07880184f, -0.34943575f, 0.13344750f, 0.14202152f, -0.01825820f, 0.14340484f, 0.13198738f, 0.04268370f, 
    -0.11315943f, 0.17193089f, -0.05497486f, 0.19193615f, 0.31767875f, -0.08814271f, -0.02410105f, 0.22068904f, 
    -0.18065254f, 0.46613106f, -0.06368595f, 0.15975648f, -0.33108839f, 0.29156625f, -0.09042564f, -0.01167429f, 
    -0.01617477f, 0.15637188f, 0.21552886f, 0.07602002f, -0.03906849f, 0.29066867f, 0.13096412f, -0.15037748f, 
    0.00797269f, 0.23517786f, -0.08241439f, -0.25258973f, -0.01545967f, -0.25848183f, -0.02005333f, 0.10132993f, 
    0.05557391f, -0.05032930f, 0.12703563f, -0.32490334f, -0.10718933f, -0.10604841f, 0.27557641f, 0.29795709f, 
    -0.08563074f, -0.37387154f, 0.15882757f, -0.09540241f, -0.09306490f, -0.21975036f, -0.09420883f, 0.16851208f, 
    0.02075772f, 0.11112369f, -0.02497455f, 0.19381458f, -0.07908490f, -0.11265980f, 0.09835674f, 0.32821265f, 
    0.02295517f, -0.21480833f, -0.16103442f, 0.36296943f, -0.15942594f, 0.02777375f, -0.09205801f, 0.08037096f, 
    0.28851929f, -0.21049979f, 0.03106259f, -0.03241323f, -0.05174293f, 0.08213623f, 0.05857450f, 0.13746783f, 
    -0.09191498f, -0.28429824f, 0.08307520f, 0.09091149f, -0.07675437f, -0.01440399f, -0.29204983f, -0.13623625f, 
    0.14153275f, 0.31116930f, 0.16276041f, 0.05092789f, 0.04736158f, 0.18626337f, -0.00699503f, 0.33422917f, 
    0.16354674f, 0.16091889f, -0.16902658f, -0.01805934f, -0.21666563f, -0.27044255f, 0.09997364f, 0.01496455f, 
    -0.14528921f, 0.21554784f, 0.13045627f, 0.10758941f, 0.19717778f, 0.04294417f, 0.09436167f, 0.00695822f, 
    0.07455878f, 0.13232236f, 0.13061291f, 0.04996805f, -0.18184648f, -0.05160764f, -0.14761162f, -0.01090735f, 
    0.21484217f, -0.11485326f, 0.16892724f, -0.03135377f, 0.13924062f, 0.06865540f, -0.11389044f, -0.18722878f, 
    -0.41724810f, 0.53314126f, -0.09295265f, 0.26276270f, 0.14706270f, 0.15299596f, 0.12149242f, -0.10095020f, 
    -0.25349408f, -0.03937821f, 0.08958378f, 0.37026697f, -0.17749643f, 0.04897060f, 0.16333145f, 0.22360373f, 
    -0.11444948f, 0.13753144f, -0.08784376f, 0.10949132f, -0.20583184f, 0.09886691f, -0.18924351f, 0.03406964f, 
    0.19434586f, -0.08233396f, -0.35870844f, -0.10871634f, -0.05997484f, -0.05407233f, -0.05935288f, -0.06888217f, 
    -0.12909120f, -0.09378185f, 0.23239648f, 0.08822519f, 0.07952329f, 0.49309239f, -0.08745163f, -0.04073874f, 
    0.23488520f, -0.00399677f, -0.01299807f, 0.02626638f, -0.11210614f, 0.06365160f, -0.03783271f, 0.08452170f, 
    -0.13283180f, 0.37262714f, -0.04456444f, 0.15514015f, -0.04111945f, -0.07453415f, -0.49499181f, -0.10310999f, 
    -0.34599578f, -0.23794657f, -0.23286590f, -0.22866248f, -0.01536317f, 0.12872307f, -0.04910000f, 0.14231128f, 
    0.14335065f, -0.54330850f, 0.23401888f, 0.41428059f, -0.09677504f, -0.04888032f, -0.13530892f, -0.00403854f, 
    0.29459372f, 0.16342254f, -0.00636241f, 0.08753540f, -0.28317633f, 0.04993081f, 0.30494568f, 0.25673857f, 
    -0.03023257f, -0.10418590f, -0.13101593f, -0.10774301f, -0.27883688f, 0.13561933f, -0.16018176f, -0.14374316f, 
    0.20931625f, 0.11476516f, -0.12440827f, -0.19923186f, -0.16565788f, -0.23866095f, -0.16238032f, -0.03550915f, 
    -0.19861725f, -0.15623103f, -0.27677840f, 0.17157288f, -0.07581107f, 0.33321375f, 0.06772429f, -0.09471811f, 
    0.12237930f, 0.35112515f, -0.27124768f, 0.32991627f, 0.13313873f, 0.07926777f, 0.11197922f, 0.06837168f, 
    0.15049717f, 0.10406193f, 0.14939135f, -0.04808793f, -0.37026465f, -0.00212746f, -0.08229578f, 0.02734230f, 
    -0.15443935f, -0.26089090f, -0.00129362f, 0.20425363f, -0.05698536f, 0.19602054f, 0.04125438f, 0.24515158f, 
    0.21738292f, 0.03526483f, -0.16563649f, -0.09269308f, -0.01271172f, -0.04716811f, 0.11942947f, 0.10562845f, 
    0.20757060f, -0.29918650f, 0.24062344f, -0.06454984f, -0.30136395f, -0.04578996f, 0.15671131f, -0.17019524f, 
    -0.03514969f, -0.38028938f, -0.07555399f, -0.08200606f, 0.18680859f, 0.09007774f, -0.03973136f, 0.13302216f, 
    -0.04102317f, 0.25952232f, -0.20551270f, -0.15724753f, -0.16752505f, 0.02641538f, 0.01438019f, 0.29908362f, 
    -0.03012032f, -0.34984380f, 0.40770996f, -0.04120448f, -0.05899863f, 0.17073531f, -0.15182027f, -0.08700694f, 
    -0.00092022f, -0.05014480f, -0.00138758f, 0.06892320f, 0.24460450f, -0.03069164f, -0.21235444f, -0.21219206f, 
    0.17297654f, 0.30059570f, 0.16055992f, -0.15303668f, 0.32843933f, 0.02047212f, 0.37390724f, -0.03352191f, 
    -0.19704965f, -0.13793074f, 0.23194885f, 0.22292495f, 0.12250038f, -0.11593575f, -0.10665028f, 0.05257237f, 
    -0.07325822f, -0.25288978f, 0.43381315f, -0.15617265f, 0.34258923f, -0.28653356f, -0.12983364f, 0.07132144f, 
    -0.04829664f, -0.12814087f, -0.10216025f, 0.05956864f, -0.03579015f, 0.02106669f, 0.19167118f, -0.38562736f, 
    -0.00995282f, -0.10397990f, -0.02896924f, -0.11603740f, 0.50525385f, -0.33564758f, 0.27548444f, -0.03273113f, 
    -0.35931936f, 0.20320018f, 0.09205803f, 0.15380847f, 0.02870453f, 0.14060968f, 0.14974108f, 0.01110690f, 
    0.28569347f, 0.21380155f, 0.06765785f, -0.01744719f, 0.28473607f, -0.25405014f, -0.04216188f, 0.12542191f, 
    -0.12748368f, 0.32433620f, -0.22486003f, 0.38325572f, -0.33633938f, 0.04726563f, -0.07989849f, 0.10156624f, 
    0.15192160f, 0.32199368f, 0.04442808f, 0.01462751f, -0.18381479f, 0.04121852f, -0.01579072f, 0.04301217f, 
    -0.19520995f, -0.19092792f, 0.07245865f, 0.18093006f, 0.03856629f, -0.11024346f, 0.12023476f, 0.12523234f, 
    -0.03018206f, -0.28072914f, -0.43574429f, 0.04796626f, 0.29561338f, 0.32769749f, 0.16748072f, -0.09065882f, 
    -0.32633126f, 0.09245580f, -0.28543293f, 0.17253333f, 0.32390481f, 0.07842405f, 0.10161633f, 0.14305960f, 
    0.17807962f, 0.12122532f, -0.05563775f, -0.16501328f, -0.23968402f, -0.17173377f, -0.09647992f, 0.07539763f, 
    0.05902539f, -0.02344310f, 0.00775651f, 0.09961054f, -0.06735107f, 0.02808576f, -0.10626880f, -0.13390222f, 
    0.24281074f, 0.19035557f, -0.09696552f, 0.24495278f, 0.29665956f, 0.06727462f, -0.16543438f, 0.18134241f, 
    0.23422804f, -0.13236794f, 0.27156043f, 0.02454184f, -0.15617102f, -0.04280276f, 0.16230533f, -0.05186120f, 
    0.09754696f, -0.02982973f, 0.13223752f, -0.08476061f, -0.00360777f, -0.02515997f, 0.03084560f, 0.12820955f, 
    0.28964275f, 0.18818818f, -0.16522035f, -0.19564563f, 0.05860667f, -0.12378393f, 0.06962406f, 0.24100651f, 
    -0.32561818f, 0.16325796f, -0.40428913f, -0.31041262f, 0.02688850f, 0.13444425f, 0.13967733f, -0.01600866f, 
    0.02839928f, 0.00425823f, 0.11788712f, -0.11435097f, 0.28817433f, 0.13764882f, -0.04426197f, 0.08412182f, 
    0.10341622f, -0.24551676f, 0.10151211f, 0.12214115f, 0.21846013f, 0.02223312f, 0.25512132f, -0.15521407f, 
    0.19537422f, -0.15541574f, -0.36751133f, 0.01713738f, -0.13137217f, 0.02792092f, -0.04516696f, -0.08468194f, 
    0.22925872f, -0.23119359f, 0.02190558f, 0.21377285f, 0.11969583f, 0.07934804f, 0.15802941f, -0.03016068f, 
    -0.06198518f, -0.14185144f, 0.06090692f, -0.19290173f, 0.00399641f, -0.04375860f, 0.21803211f, 0.07280971f, 
    -0.10376047f, -0.44969478f, -0.04908661f, -0.04084988f, 0.36898303f, -0.09401094f, -0.03313040f, 0.08383568f, 
    0.31463349f, 0.23695554f, -0.19215514f, 0.33674982f, -0.05507891f, 0.08966994f, 0.10623171f, 0.29287007f, 
    0.12667273f, 0.04008386f, 0.10446545f, 0.36133385f, -0.06803436f, -0.14860734f, 0.11155639f, 0.03232408f, 
    0.03046565f, -0.03230230f, 0.24243088f, 0.08021120f, -0.23541875f, 0.02968266f, 0.08333149f, -0.13325045f, 
    0.17736025f, 0.18592861f, 0.14176883f, 0.11949954f, -0.13233024f, 0.28658962f, 0.38971859f, 0.11625601f, 
    -0.14733373f, -0.15005954f, -0.08709715f, 0.01982827f, 0.08747868f, 0.04481193f, 0.04687275f, 0.09494536f, 
    -0.23555084f, -0.11280928f, 0.52477551f, -0.25995719f, -0.07524063f, 0.26291683f, 0.01022724f, -0.00436052f, 
    -0.11754564f, -0.15424356f, -0.14926490f, -0.04971463f, 0.51920539f, 0.13962448f, -0.05394912f, 0.37945908f, 
    0.17425644f, 0.33743808f, 0.09131103f, -0.04922866f, -0.04971719f, 0.03515308f, 0.07680114f, -0.08313394f, 
    0.30135569f, -0.18123455f, -0.11618881f, 0.24213603f, 0.09912947f, 0.17108314f, -0.16298747f, -0.04033828f, 
    0.01620425f, 0.16846447f, -0.03164797f, -0.30597177f, 0.01745035f, -0.21578734f, 0.15848473f, 0.04527320f, 
    -0.10707015f, 0.21754959f, 0.04557158f, -0.35194585f, 0.24503696f, 0.02802951f, 0.10910681f, 0.28778324f, 
    0.14102100f, 0.11872330f, -0.00738658f, -0.07199790f, -0.26807925f, -0.13736014f, 0.04396401f, 0.16323763f, 
    0.08623032f, -0.19858286f, -0.34690136f, 0.22707371f, 0.14003837f, -0.02933821f, -0.01537244f, -0.14548713f, 
    0.02194519f, 0.08153208f, 0.04316449f, 0.28467485f, 0.03050733f, -0.02185562f, 0.08051499f, -0.10233223f, 
    0.27851889f, 0.35218823f, -0.26599145f, -0.09748050f, 0.21773691f, -0.08051877f, -0.09954521f, 0.11983207f, 
    -0.09190413f, 0.41821584f, 0.19073236f, -0.13388735f, -0.22022904f, -0.06981202f, 0.15884067f, -0.08570285f, 
    -0.41310498f, -0.26390713f, -0.12927870f, -0.15634105f, -0.04401537f, 0.43725717f, -0.07610296f, -0.05274802f, 
    0.06550854f, -0.07661472f, 0.04587955f, -0.16366403f, 0.01536126f, 0.15630382f, -0.07438259f, -0.06483962f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13833539f, 0.11014478f, -0.05665912f, -0.19528276f, 0.10140654f, -0.08510118f, -0.00458130f, 0.03433732f, 
    0.08634551f, -0.07229733f, -0.00132314f, 0.36268356f, -0.00878831f, -0.09112149f, -0.08495159f, 0.03960412f, 
    0.16706733f, 0.08438746f, 0.07232345f, -0.09455562f, 0.08416139f, -0.10527460f, -0.12487678f, -0.04241827f, 
    0.20224579f, 0.12960982f, 0.16866070f, 0.11140014f, 0.36833620f, 0.15728128f, 0.20655289f, 0.23557609f, 
    0.08783573f, -0.02504554f, -0.14134370f, -0.00723732f, -0.02821315f, 0.22168092f, -0.01760928f, -0.10700409f, 
    0.12954235f, -0.14691663f, 0.15948716f, -0.15563506f, -0.12443367f, 0.04534889f, 0.07271245f, -0.15480879f, 
    0.04899848f, 0.02373743f, -0.03882708f, -0.13874863f, 0.13425444f, 0.18393290f, -0.13393372f, 0.18019521f, 
    -0.13515629f, 0.27217078f, -0.17658775f, -0.16330908f, 0.00428469f, 0.12319361f, 0.02624495f, 0.24744116f, 
    -0.09424876f, 0.11722615f, 0.17704073f, 0.04709899f, -0.02009468f, -0.08856879f, 0.02733106f, 0.00227402f, 
    0.01372744f, 0.22709392f, -0.15353619f, 0.04468020f, 0.14358781f, -0.08640838f, -0.23547645f, 0.03461876f, 
    -0.15444088f, -0.08071125f, 0.29651195f, -0.15483920f, 0.01140866f, -0.16645122f, 0.05336912f, 0.10535461f, 
    -0.08090230f, -0.14794886f, 0.15440395f, -0.06161913f, -0.08762887f, 0.06665550f, -0.03464128f, 0.13773407f, 
    0.18692154f, 0.23281780f, 0.13158545f, 0.05653485f, 0.11854372f, 0.02826054f, -0.07846142f, 0.07955974f, 
    0.02577997f, -0.05350687f, 0.27001193f, 0.18186091f, -0.02945295f, 0.29953820f, 0.12742913f, -0.06252295f, 
    0.24962367f, 0.19482981f, 0.21971497f, 0.10541728f, -0.10354656f, 0.08491641f, -0.15711787f, 0.18468075f, 
    0.24497113f, 0.19257215f, 0.02402314f, 0.11106014f, 0.08170021f, -0.13591596f, -0.05529566f, -0.12776434f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.34135911f, -0.12515156f, 0.08563090f, -0.02397981f, -0.60616356f, -0.03149343f, -0.15552329f, -0.26286983f, 
    -0.15745385f, 0.18833804f, -0.12121039f, 0.15175730f, 0.02831330f, -0.08149271f, 0.19612019f, 0.17813362f, 
    0.25004464f, -0.04392314f, -0.41512376f, -0.02445529f, -0.14025220f, -0.04525096f, -0.00942403f, -0.54319823f, 
    0.26005051f, 0.04035566f, 0.15552567f, 0.33002853f, -0.16513632f, 0.37258825f, 0.04621497f, -0.23079580f, 
    -0.09081914f, 0.06657518f, -0.05733809f, -0.06061241f, 0.03937863f, -0.46165505f, -0.16142800f, -0.01276877f, 
    -0.17884722f, -0.10400593f, -0.35480154f, 0.22719932f, -0.08865359f, -0.08037165f, 0.02472595f, -0.01107529f, 
    -0.21284771f, -0.22345041f, -0.15049455f, -0.14314623f, -0.04543034f, 0.01739510f, -0.04844905f, -0.18894002f, 
    0.11720369f, -0.29121563f, -0.38019603f, -0.30841184f, 0.01261532f, 0.04214763f, -0.43165973f, 0.04577439f, 
    0.00416943f, 0.21337463f, -0.01399764f, -0.14566244f, 0.04890008f, -0.06352639f, 0.00272634f, 0.14089644f, 
    0.00272263f, -0.36665061f, -0.00449070f, 0.10101901f, 0.26231664f, 0.51530635f, -0.44015422f, 0.05896556f, 
    0.22248408f, -0.16216867f, -0.05075866f, -0.40325540f, 0.18889517f, -0.11250087f, -0.04391027f, -0.41810879f, 
    0.16360134f, -0.18019152f, -0.21916798f, -0.05985324f, 0.12188839f, -0.38689899f, -0.10411715f, 0.19606678f, 
    -0.19215654f, 0.03864606f, -0.02142228f, 0.23632066f, -0.60839707f, -0.04004678f, -0.01941426f, 0.13401087f, 
    -0.01581059f, -0.12200221f, 0.22701678f, 0.04934989f, -0.12459062f, -0.05600047f, -0.18678068f, 0.17774726f, 
    0.30188215f, -0.58436692f, 0.12851739f, 0.05149893f, 0.04210676f, -0.14576438f, 0.03598101f, 0.26041514f, 
    0.03329574f, 0.15967822f, -0.18436176f, -0.01527726f, 0.13110754f, -0.45489454f, -0.10018615f, -0.62422562f, 
    0.18805681f, -0.37610906f, -0.03566417f, 0.07159946f, -0.30063283f, 0.09276667f, -0.30721897f, 0.30181175f, 
    -0.02277883f, 0.22378340f, 0.17631467f, 0.06948970f, 0.01941078f, 0.00332046f, 0.08760340f, -0.02890042f, 
    0.14853904f, -0.14337112f, -0.44582236f, 0.09309141f, 0.09631734f, -0.66548955f, -0.05636398f, -0.39006180f, 
    0.08147146f, 0.04891251f, 0.02021807f, -0.11633278f, -0.33586043f, 0.03294871f, 0.11177558f, -0.13023584f, 
    0.02219171f, 0.00955493f, -0.01765740f, 0.05182699f, -0.03450768f, 0.04829199f, -0.21344353f, -0.13699357f, 
    0.10882580f, -0.10350376f, -0.49975565f, -0.42407626f, 0.02753746f, 0.02753126f, -0.04280024f, 0.07061230f, 
    -0.32339385f, -0.18516381f, 0.07166540f, 0.01513982f, -0.16517551f, 0.31627765f, 0.13354948f, 0.12250494f, 
    0.14614172f, -0.18363880f, 0.43554059f, -0.01034708f, -0.01169507f, 0.01075004f, 0.28903377f, -0.31767866f, 
    0.00590145f, -0.05499378f, -0.01558999f, -0.46163434f, -0.26052111f, 0.20374325f, -0.07675572f, -0.00740660f, 
    0.10550537f, -0.19840097f, 0.04050389f, -0.02314351f, -0.21386379f, -0.01777355f, -0.13262832f, 0.00599266f, 
    0.06120774f, -0.09379452f, 0.08134312f, 0.23450077f, 0.12695944f, -0.03652100f, 0.02134283f, -0.22496180f, 
    0.16349052f, -0.03390215f, 0.18518974f, -0.00708035f, 0.08697606f, -0.12981832f, -0.34374690f, 0.05014196f, 
    -0.21094884f, -0.27107042f, -0.18263236f, 0.09230546f, 0.09406339f, -0.06964716f, 0.00494677f, 0.15974356f, 
    -0.07376631f, -0.27605030f, 0.00053832f, -0.16640586f, 0.15493657f, -0.94917816f, -0.16432990f, -0.07941268f, 
    0.14429139f, 0.00858648f, -0.29623473f, 0.09226675f, -0.00603328f, 0.21868964f, -0.08753604f, 0.04445916f, 
    0.03267593f, -0.24420013f, -0.06212507f, -0.32384324f, 0.23566304f, 0.11285271f, -0.23709497f, 0.26009807f, 
    0.12546282f, 0.31619820f, -0.01059798f, -0.02836495f, -0.27296677f, 0.03918687f, -0.10255013f, -0.10708656f, 
    -0.49701351f, -0.24313575f, 0.16490038f, -0.27253833f, -0.06544483f, 0.05216404f, 0.12633073f, -0.32029489f, 
    -0.09836525f, -0.27859327f, 0.36566997f, 0.04165215f, -0.51272720f, -0.10322763f, -0.09495486f, 0.01324822f, 
    -0.00778217f, 0.05569144f, -0.03882704f, 0.09213053f, -0.03179458f, -0.00873108f, -0.06838188f, -0.12564555f, 
    0.04735396f, 0.23259397f, -0.04401732f, 0.03347612f, 0.04201451f, -0.25028020f, -0.14055410f, 0.29031029f, 
    -0.17411713f, -0.08562736f, 0.05571802f, -0.00204010f, -0.04126929f, -0.40895069f, 0.09429304f, -0.02733848f, 
    -0.51859534f, 0.15001065f, -0.17935456f, 0.47044665f, -0.51553577f, -0.38735506f, -0.10696324f, -0.26652902f, 
    -0.18428427f, -0.42740867f, 0.16292456f, -0.20415232f, -0.06736432f, -0.06016554f, -0.34142530f, -0.20258336f, 
    -0.04974371f, 0.00854238f, 0.10153969f, -0.04348064f, -0.03574194f, 0.12434735f, 0.04969303f, 0.27193314f, 
    -0.41644382f, 0.06726649f, -0.07282204f, -0.45284790f, -0.34787279f, -0.47099489f, -0.24637118f, 0.00451423f, 
    -0.14945944f, -0.30971488f, 0.03071132f, -0.43499649f, 0.16161288f, 0.00526787f, -0.06688958f, -0.06495410f, 
    -0.56998187f, -0.00432560f, -0.22430260f, 0.07436729f, -0.22211079f, -0.41220343f, -0.13269700f, 0.23563023f, 
    0.17333852f, -0.46394947f, 0.20393606f, 0.21604231f, -0.62106705f, 0.09431120f, 0.06168865f, -0.04605626f, 
    0.04991348f, 0.05564296f, 0.13194121f, 0.27004665f, -0.25854963f, -0.00225034f, -0.36045417f, -0.17569026f, 
    -0.17028721f, -0.52800786f, -0.35552439f, 0.05713482f, 0.01868464f, 0.22578011f, 0.19901964f, -0.07771508f, 
    -0.05346273f, -0.14234585f, 0.21738617f, 0.03129618f, 0.32045075f, 0.14637862f, 0.25380144f, 0.17217450f, 
    0.18931428f, -0.08844880f, 0.06754410f, 0.06152966f, -0.25916940f, 0.06197783f, -0.06672592f, 0.06012836f, 
    0.24695513f, -0.31198385f, -0.49782816f, 0.12075473f, 0.00980380f, 0.03588316f, -0.02661676f, 0.09546858f, 
    -0.57930177f, 0.06434572f, 0.06803650f, -0.06055179f, 0.19051753f, -0.36368036f, -0.16494194f, -0.15474692f, 
    -0.35314432f, -0.04454110f, -0.67372161f, -0.29773703f, 0.08483809f, 0.11590008f, -0.27783734f, -0.43010142f, 
    0.06819770f, -0.58153576f, 0.03939634f, -0.02727939f, 0.03359948f, 0.14107646f, 0.00820087f, 0.01166112f, 
    -0.24307097f, -0.05449073f, -0.03226452f, 0.01585567f, 0.03534329f, 0.17541878f, -0.05201207f, -0.08256427f, 
    -0.02473873f, 0.17407185f, -0.12139686f, 0.21997939f, -0.18336089f, -0.25843623f, -0.00428071f, -0.13483192f, 
    -0.09355646f, 0.21560307f, -0.23398912f, -0.32567921f, -0.03174720f, 0.06229959f, 0.04214020f, 0.00564466f, 
    -0.07306150f, 0.04401692f, -0.07192111f, 0.12974808f, 0.04795038f, -0.43595326f, 0.05035590f, -0.15933660f, 
    0.07533028f, -0.19020419f, 0.01813778f, 0.13365823f, 0.00996302f, 0.17003509f, 0.19853626f, 0.08154027f, 
    0.16665940f, -0.08213563f, -0.12954794f, 0.13729888f, -0.53832078f, -0.05476713f, 0.07620156f, 0.20656869f, 
    0.12991628f, -0.01738172f, -0.01381332f, 0.11806577f, 0.08500022f, -0.36072484f, 0.21201150f, -0.48601082f, 
    0.16133527f, 0.29059273f, 0.26022664f, -0.35052016f, 0.06926213f, -0.04318090f, 0.01279738f, -0.17400332f, 
    -0.07550083f, 0.02401320f, -0.01513637f, -0.25092643f, 0.00494904f, 0.26065046f, 0.25210202f, -0.03825159f, 
    -0.37981358f, -0.58960307f, -0.10195012f, -0.03573169f, 0.14158031f, -0.09539538f, 0.19843656f, -0.19817360f, 
    -0.08413430f, -0.02610457f, -0.36622354f, 0.17409879f, -0.30403402f, -0.24152416f, -0.34641656f, -0.02267163f, 
    -0.26014325f, -0.47225615f, -0.03479901f, -0.10763995f, 0.37078074f, -0.02732539f, 0.06317572f, -0.08004706f, 
    0.21077654f, -0.03962346f, -0.14195114f, 0.10934372f, 0.03669286f, 0.03197046f, -0.11323157f, 0.07273258f, 
    -0.08995647f, 0.13863514f, -0.22574885f, -0.00373274f, 0.04520134f, -0.34829962f, -0.04488448f, -0.14355715f, 
    0.02512729f, -0.00343555f, -0.06083494f, 0.15114188f, 0.10677913f, -0.09900630f, -0.18405570f, 0.05120119f, 
    0.05918105f, 0.02751591f, 0.03680352f, -0.03509081f, 0.06066946f, -0.22812268f, 0.32393509f, -0.04718629f, 
    -0.04297778f, -0.03087360f, -0.33779752f, 0.02110721f, -0.00511642f, 0.16004062f, -0.03603826f, -0.06450980f, 
    -0.00155054f, -0.01678696f, -0.40787545f, -0.02087403f, 0.17934620f, 0.04658490f, -0.12959342f, 0.06525677f, 
    -0.25736156f, 0.16365153f, -0.29432872f, -0.10003413f, 0.05572551f, -0.20387544f, -0.25194582f, 0.30120406f, 
    -0.01460026f, 0.04824343f, -0.01178480f, -0.03092795f, -0.27007785f, -0.01509641f, -0.04874864f, 0.01624131f, 
    -0.07096696f, 0.10270701f, 0.02808541f, 0.18719099f, 0.27439308f, -0.44345367f, 0.06480778f, 0.03290069f, 
    -0.41636693f, -0.05646627f, -0.07923945f, 0.09637204f, 0.16623470f, -0.12810412f, -0.01757941f, 0.14112158f, 
    -0.12549505f, -0.03343407f, -0.69659162f, -0.25101984f, 0.14167927f, 0.09005133f, 0.03661829f, 0.06769013f, 
    -0.20531559f, 0.21362166f, 0.45605457f, 0.06046537f, -0.03035181f, -0.19910605f, -0.06608549f, -0.20766927f, 
    0.04841643f, 0.07143834f, -0.13949253f, 0.19157825f, -0.36436239f, 0.20988286f, 0.20328070f, -0.28810361f, 
    0.09099992f, -0.11085635f, 0.09102912f, -0.11403114f, 0.30082023f, 0.13377044f, 0.05424584f, -0.10247721f, 
    -0.16336748f, 0.19874363f, 0.06983316f, 0.18890084f, 0.00736721f, -0.27714393f, -0.31689292f, -0.63987446f, 
    -0.37021443f, -0.06762143f, 0.07929477f, -0.00307245f, -0.26395857f, 0.03389044f, 0.06911066f, -0.14633739f, 
    -0.25476450f, 0.29619750f, -0.12233417f, -0.04686314f, 0.06497438f, 0.00555134f, -0.05257889f, 0.10098886f, 
    0.27128983f, -0.02554545f, 0.17765625f, -0.03717677f, 0.11064062f, 0.20672172f, -0.08186628f, 0.11415414f, 
    0.13221356f, 0.00877419f, 0.16366789f, -0.21146350f, 0.15778990f, -0.42768174f, 0.16450843f, 0.02278871f, 
    0.05877368f, 0.06971505f, -0.04178656f, 0.03809627f, -0.04433422f, 0.22463161f, -0.56533509f, -0.30004352f, 
    -0.03667829f, 0.06830094f, 0.34926933f, -0.00131345f, -0.13287640f, -0.03532568f, -0.04290864f, 0.04836354f, 
    0.37740040f, -0.38916868f, 0.19381030f, -0.45077404f, 0.20097478f, -0.30651397f, -0.15267806f, -0.03267185f, 
    0.11612412f, -0.20382817f, 0.01144211f, 0.20745134f, -0.05782623f, -0.10054244f, -0.09747943f, 0.31007236f, 
    0.03616187f, 0.05859353f, 0.09085895f, -0.46835870f, 0.24901900f, 0.12573315f, 0.03145855f, -0.36043364f, 
    0.24474700f, 0.26039636f, -0.03277862f, -0.16689986f, 0.11264120f, -0.57075858f, -0.28910092f, -0.01743623f, 
    0.05206243f, -0.39049405f, -0.14643480f, -0.08089468f, -0.11390750f, -0.03168507f, -0.08271483f, -0.29411468f, 
    0.15335034f, 0.02373150f, 0.31039992f, -0.06697695f, 0.01591021f, 0.61774272f, -0.04107516f, -0.09757187f, 
    -0.12549321f, -0.25024986f, -0.39604583f, -0.03680032f, 0.09254695f, -0.12870365f, 0.03924567f, -0.33635092f, 
    -0.08855677f, 0.18526451f, 0.06345896f, -0.04303639f, 0.16885950f, -0.65167779f, -0.15361539f, 0.03397732f, 
    -0.04754861f, 0.17511407f, 0.19455752f, 0.10796683f, -0.24788783f, 0.09087847f, -0.19843282f, 0.23280875f, 
    0.01087893f, 0.11939297f, -0.17565788f, -0.51516664f, -0.02490758f, 0.07149761f, 0.00541381f, 0.12575406f, 
    -0.19036002f, -0.37638563f, 0.03281106f, -0.05271168f, -0.45995942f, 0.00481604f, 0.30328026f, -0.64064252f, 
    -0.04916359f, -0.14278629f, -0.23476441f, 0.00772005f, -0.02901186f, 0.01372326f, -0.27340338f, 0.25560939f, 
    -0.24204822f, -0.38738167f, -0.29737741f, 0.05897614f, -0.04697710f, 0.06336752f, -0.03148359f, -0.15033138f, 
    0.04560177f, -0.01067607f, -0.07032993f, -0.26025614f, 0.14582197f, -0.51650852f, -0.09188861f, 0.18221883f, 
    -0.08035395f, -0.05773074f, -0.00715955f, -0.04700350f, 0.06121236f, -0.14131781f, -0.12441213f, 0.28095773f, 
    0.12948659f, 0.00065196f, 0.37997705f, 0.05356038f, -0.03421137f, 0.02857589f, -0.06105154f, 0.06682262f, 
    -0.16872633f, 0.22334018f, -0.51112902f, 0.24360065f, -0.96488994f, 0.06445359f, 0.11565920f, 0.10376695f, 
    0.02386309f, -0.04957809f, -0.05769010f, -0.61729336f, 0.01088168f, 0.17975637f, -0.82958168f, 0.19604672f, 
    -0.00418655f, -0.14410415f, 0.20291556f, 0.21752776f, 0.15145855f, 0.11246603f, -0.07009303f, -0.13366808f, 
    -0.11906502f, -0.73354113f, 0.06567481f, -0.11399848f, 0.03192474f, 0.01649728f, 0.25141564f, 0.01599006f, 
    -0.20879196f, 0.15698168f, -0.14676192f, -0.24063309f, 0.07694789f, -0.01772927f, -0.02526527f, -0.01731850f, 
    0.17465630f, -0.11897066f, 0.11683955f, 0.10143235f, -0.01743692f, -0.27958146f, -0.43529940f, 0.20743859f, 
    0.09489103f, -0.35262930f, -0.32136407f, 0.12956838f, -0.34184560f, -0.64911067f, 0.02627238f, 0.21047823f, 
    0.01562271f, 0.19975449f, -0.10938407f, -0.17208074f, 0.12748736f, 0.05241539f, 0.18434471f, -0.00008782f, 
    -0.16135029f, -0.07048369f, -0.04522049f, 0.24717154f, -0.18937472f, -0.27608144f, -0.25106001f, 0.10995142f, 
    -0.03278638f, 0.05532565f, -0.06195622f, -0.09962814f, -0.14443175f, 0.07033736f, 0.03108110f, 0.34860209f, 
    -0.34772798f, 0.16036735f, 0.05599252f, -0.11103256f, -0.26662481f, 0.04065320f, -0.12782052f, 0.27430174f, 
    0.01931313f, 0.08562540f, -0.18408930f, -0.40791905f, 0.05473151f, 0.07819193f, 0.28091952f, -0.02582726f, 
    0.09353801f, 0.17163429f, -0.03614296f, 0.07272916f, -0.05465636f, -0.34989205f, -0.00576664f, 0.10960353f, 
    -0.37231445f, -0.09504379f, -0.04168281f, 0.10274898f, -0.39179739f, -0.06751164f, -0.07592022f, -0.05183086f, 
    0.08692891f, -0.05860345f, -0.08177970f, -0.02835273f, -0.01652960f, -0.16212703f, 0.26746511f, 0.11422187f, 
    -0.31581983f, -0.06066985f, -0.19944350f, -0.06893308f, -0.11563049f, 0.11235297f, 0.00438256f, -0.03373180f, 
    -0.34052327f, 0.09557500f, -0.08820048f, -0.24492164f, 0.24395159f, -0.43973440f, -0.10752778f, -0.33098823f, 
    0.10159633f, 0.05011133f, -0.10230780f, 0.25947928f, -0.01891435f, -0.50499302f, 0.24386369f, -0.13136248f, 
    0.05530231f, 0.14174210f, -0.47255436f, -0.03850685f, 0.25759324f, -0.31634894f, -0.05572380f, -0.03332789f, 
    0.16077881f, 0.08986785f, 0.07941096f, 0.09779267f, 0.08495163f, 0.04930318f, 0.06115009f, -0.08592362f, 
    0.07740510f, -0.27648020f, -0.32617912f, 0.18614508f, -0.18717353f, -0.03552729f, -0.02524623f, 0.14147998f, 
    -0.08330753f, 0.01459094f, -0.30365789f, -0.58634317f, 0.25297052f, -0.29032162f, 0.14719737f, -0.10423944f, 
    -0.47689888f, 0.25667635f, 0.05286305f, -0.19598898f, 0.26084787f, 0.20935833f, -0.02820933f, -0.09820651f, 
    -0.08120123f, 0.11186165f, -0.05194686f, -0.28345823f, -0.02146257f, -0.02768144f, 0.04853315f, 0.03429065f, 
    -0.35688198f, -0.58250731f, -0.10598228f, -0.58816153f, 0.18583195f, 0.14330231f, 0.11656280f, -0.54363263f, 
    -0.56884032f, 0.16626520f, -0.02352078f, 0.04359160f, 0.12564825f, -0.29217169f, -0.36077020f, 0.45432502f, 
    0.14056109f, 0.04045135f, -0.00497467f, -0.02766823f, 0.26186517f, -0.03517801f, -0.08126037f, 0.23817065f, 
    0.25183985f, -0.13387805f, 0.18165676f, -0.28480202f, 0.02690046f, -0.00414167f, -0.26450032f, 0.08802316f, 
    -0.05003485f, 0.05659214f, 0.11191663f, 0.04177368f, 0.16958320f, -0.21868724f, 0.00760346f, 0.12285698f, 
    -0.27798650f, -0.08365215f, 0.11024299f, -0.33270240f, -0.34340343f, -0.24413538f, 0.13310103f, 0.06946836f, 
    0.08490889f, -0.12291179f, -0.00399456f, -0.04723648f, -0.03352395f, 0.22165203f, 0.13653845f, -0.21936698f, 
    0.23795910f, -0.03265185f, -0.36507028f, 0.00646328f, -0.10126030f, -0.13521057f, 0.01486360f, -0.05255632f, 
    0.09941069f, -0.38970631f, -0.34152371f, -0.40008855f, -0.02320142f, 0.18269181f, 0.00895997f, 0.15068069f, 
    0.00643291f, -0.34321305f, 0.13247679f, -0.03415879f, -0.05895925f, 0.12792429f, -0.18336141f, -0.54267955f, 
    -0.00988556f, -0.27175504f, 0.12531327f, -0.30473435f, 0.32741526f, 0.12030283f, -0.03545099f, 0.15883900f, 
    -0.19724829f, 0.43371695f, -0.06641434f, -0.39856967f, -0.42071751f, 0.09382992f, 0.21919213f, 0.01245108f, 
    0.03643260f, 0.13190937f, 0.03746221f, 0.31236812f, -0.03896737f, -0.09097289f, 0.04577347f, 0.04320138f, 
    0.14717025f, -0.04912681f, -0.18417975f, -0.12384791f, -0.14120239f, -0.20534724f, 0.04811398f, -0.43423045f, 
    -0.00867926f, -0.42635763f, 0.07985091f, -0.23260070f, -0.19603035f, -0.11058059f, 0.04308765f, -0.08225048f, 
    0.04829659f, -0.30949298f, -0.47113812f, -0.21120957f, 0.04183121f, -0.35585260f, -0.30534765f, 0.30021381f, 
    -0.14771539f, -0.40716624f, -0.33459818f, -0.03105508f, -0.38667485f, 0.14907007f, 0.18963368f, -0.01014221f, 
    0.18370657f, -0.25823048f, -0.03313980f, -0.20009132f, -0.19126128f, -0.00217151f, 0.19548577f, 0.06181861f, 
    0.03796111f, 0.35228595f, -0.02976961f, 0.03966350f, -0.06763490f, 0.05831235f, -0.30706775f, -0.17904642f, 
    -0.45382869f, -0.39997655f, 0.15703145f, 0.02101613f, -0.02487190f, -0.00286670f, -0.10646724f, 0.19668168f, 
    -0.06870188f, -0.16738667f, -0.13108307f, 0.02938801f, -0.21492802f, 0.41256547f, -0.01887215f, 0.44070697f, 
    0.17866616f, 0.08227413f, 0.22828123f, -0.24687909f, -0.21165805f, -0.20271008f, -0.29195181f, 0.14407474f, 
    0.00549845f, 0.26126769f, -0.05946104f, -0.04367085f, 0.01683933f, -0.12243731f, 0.07436159f, -0.17346771f, 
    -0.14894940f, -0.04592493f, 0.02812538f, 0.07584160f, -0.03318634f, 0.09252560f, 0.00838080f, -0.01187306f, 
    0.31590816f, -0.27478290f, 0.16109283f, -0.22805636f, 0.35196176f, -0.01338099f, -0.04656067f, 0.11665241f, 
    -0.22944458f, 0.17422560f, -0.07690363f, 0.32460812f, -0.02573513f, 0.13618235f, 0.13694015f, -0.08251435f, 
    0.02267156f, -0.30494949f, 0.13975482f, -0.07690237f, 0.10877899f, -0.07593805f, -0.05778572f, 0.04386770f, 
    -0.13623399f, 0.24758774f, 0.05491165f, 0.13091131f, 0.03847763f, 0.07669722f, 0.10488163f, -0.00587690f, 
    0.01011720f, 0.34008107f, -0.44969347f, -0.14435303f, 0.14486946f, -0.17139976f, -0.02480059f, 0.07207813f, 
    -0.10262934f, -0.01347092f, -0.40016609f, -0.07034914f, -0.06497621f, 0.26363853f, -0.14907503f, -0.05994953f, 
    0.30650121f, -0.20093855f, 0.01672195f, -0.05997211f, -0.06314717f, -0.15652594f, -0.02531831f, -0.08985843f, 
    -0.06783397f, 0.16287135f, -0.19707154f, 0.08445219f, -0.21670088f, 0.05009076f, -0.11337826f, 0.05229605f, 
    0.11080444f, 0.42058626f, 0.28896144f, -0.01131172f, 0.05244912f, -0.44889313f, -0.68050897f, -0.00405686f, 
    -0.02276547f, -0.11946855f, 0.08600080f, -0.02704022f, -0.06945737f, -0.42380303f, 0.20351149f, -0.14905052f, 
    0.24589725f, -0.00012044f, 0.01847795f, 0.00381146f, -0.07002786f, -0.07152698f, -0.34062341f, -0.07827657f, 
    -0.00152989f, -0.16818048f, 0.19569808f, 0.03955730f, -0.03134049f, -0.07702992f, -0.16804595f, -0.77024829f, 
    -0.09424983f, 0.22226030f, 0.15635559f, 0.01805715f, -0.04094812f, -0.30068621f, 0.10768140f, 0.12917666f, 
    -0.68105572f, 0.05121083f, -0.50929141f, -0.04527568f, 0.26488388f, -0.06983609f, 0.19484913f, -0.09751847f, 
    0.04930314f, -0.50694925f, 0.02574605f, -0.07580850f, -0.06018063f, 0.34027630f, -0.55638516f, -0.06345124f, 
    0.06043795f, 0.02533988f, -0.10036509f, -0.07929306f, -0.05901316f, -0.10654866f, 0.05184031f, 0.03215553f, 
    -0.18058001f, 0.20377168f, 0.13572451f, 0.08089794f, -0.13023768f, 0.04870356f, 0.00955338f, 0.08210843f, 
    -0.07514834f, 0.10454646f, -0.10855452f, -0.35403606f, -0.07079109f, 0.12633163f, 0.09427115f, -0.36114869f, 
    -0.00973094f, 0.14803341f, 0.09548487f, -0.22014895f, -0.31911191f, -0.14888041f, -0.07498649f, -0.08841133f, 
    0.07973891f, -0.17407414f, -0.06286533f, -0.15571541f, -0.33855405f, -0.42425594f, -0.11311288f, -0.09680453f, 
    0.14019626f, -0.31918705f, 0.34578076f, -0.16757578f, -0.29769164f, -0.01050002f, -0.02453438f, 0.16590527f, 
    -0.29648653f, -0.12573802f, -0.05931841f, 0.21639024f, -0.53572226f, -0.15298490f, 0.16459581f, -0.40517348f, 
    0.23756209f, -0.06082440f, -0.25717935f, -0.09778897f, 0.16518243f, 0.20603772f, -0.02082468f, -0.22429149f, 
    -0.07815464f, -0.51162982f, 0.18662231f, 0.02434881f, -0.02587176f, 0.00922770f, -0.05091271f, -0.39280611f, 
    -0.29508060f, 0.08834421f, -0.31935379f, 0.02049456f, -0.13772871f, 0.26160026f, 0.33950785f, 0.12872797f, 
    0.09193256f, -0.18433100f, 0.15570138f, 0.15299544f, -0.37108403f, -0.06245195f, -0.15026578f, -0.20029172f, 
    0.21324550f, 0.32855162f, -0.07646713f, 0.02426148f, -0.13282613f, 0.01605699f, 0.29665896f, 0.13053867f, 
    0.04746027f, 0.16479333f, -0.07988215f, 0.15060322f, 0.02416933f, -0.02061237f, -0.44390413f, -0.26911965f, 
    0.05100969f, 0.04553114f, 0.32726163f, 0.00605014f, 0.14180951f, 0.15574034f, -0.13477883f, -0.42861474f, 
    -0.13654228f, -0.02252222f, -0.26952133f, -0.19943225f, 0.14403208f, -0.19238466f, -0.34388009f, 0.03378548f, 
    -0.07812689f, -0.41444626f, -0.09532435f, 0.07691915f, -0.07517524f, -0.21108490f, -0.24328505f, 0.07326710f, 
    0.14296843f, 0.05462409f, 0.29768831f, -0.29324764f, -0.08523636f, -0.22681305f, 0.11201684f, 0.04143034f, 
    -0.16596504f, 0.08791036f, -0.36796266f, -0.07440265f, -0.42264241f, -0.37000200f, 0.03450571f, -0.27974880f, 
    0.00698492f, -0.12252907f, -0.25345805f, -0.46911675f, -0.04077781f, -0.01731154f, -0.37171909f, 0.03825661f, 
    0.00747888f, -0.01526468f, 0.05998699f, 0.37579653f, -0.29905683f, 0.07481382f, 0.07138152f, -0.00124998f, 
    0.01573884f, -0.08926085f, -0.05332496f, 0.16642357f, -0.06808146f, 0.00024143f, 0.05718276f, 0.01288308f, 
    0.01465924f, -0.08832842f, 0.02435392f, -0.03637469f, -0.29260302f, -0.04870607f, 0.02592692f, -0.00321326f, 
    -0.06390812f, -0.11931112f, 0.15901318f, 0.11184619f, -0.41727930f, -0.09093019f, 0.11582123f, 0.21921262f, 
    -0.14748636f, -0.16553915f, -0.29181001f, -0.20057218f, -0.34884840f, 0.11300170f, 0.00986773f, 0.44429481f, 
    0.05030469f, -0.14309184f, -0.11647503f, 0.26074448f, 0.25472578f, 0.05279919f, 0.04369515f, 0.17642823f, 
    0.21324490f, -0.60236478f, 0.08417115f, -0.07105794f, -0.26736590f, -0.27105215f, -0.35607958f, -0.17188960f, 
    0.13299784f, 0.04017922f, 0.11627359f, 0.11475245f, -0.36614019f, 0.45681006f, 0.26982552f, -0.47588190f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.04190896f, -0.07540123f, 0.01352074f, -0.14943162f, 0.18819404f, 0.08550402f, 0.00252645f, -0.13871703f, 
    -0.17681372f, -0.01923047f, 0.07875288f, 0.07988045f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
