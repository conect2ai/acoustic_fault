#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.04290056f, 0.56139082f, 1.13820207f, 0.52617061f, 0.72995311f, 1.05592883f, -0.75302905f, -0.82157749f, 
    -0.78580141f, -0.66952097f, 0.38211930f, 0.28228271f, -0.12962227f, 0.19657978f, 0.16400293f, 0.61088663f, 
    0.31533462f, 0.09539768f, 0.23299871f, 0.61347055f, 0.38495970f, 0.22602570f, 0.05412358f, -0.00179397f, 
    0.51901186f, -0.13208441f, 0.49570760f, -0.78199273f, -0.81056178f, -0.17748821f, 0.98439711f, 0.56204277f, 
    0.85302091f, 0.99177402f, 1.21071947f, -0.02731956f, -0.44960487f, 0.13227911f, -0.44743955f, -0.15751542f, 
    -0.01446310f, -0.42665020f, -0.45624778f, 0.29071414f, -0.08371198f, -0.15999418f, -0.49908832f, -0.31463337f, 
    -0.05631352f, 0.21146245f, 1.46071124f, -0.67086613f, -0.67142135f, 1.15000010f, -0.56980592f, -0.54790437f, 
    -0.60443580f, 0.42275387f, -0.97378039f, -0.03927638f, -0.50715947f, -0.32193005f, 0.62197608f, -0.01928505f, 
    0.41571164f, 0.11285239f, 0.32980379f, 0.03502207f, 0.38318813f, 0.25961268f, 0.26616618f, 0.04176835f, 
    0.28899503f, 0.12882462f, -0.29970923f, 0.58072656f, 0.36383563f, -0.88452059f, -1.51205087f, -0.69434458f, 
    0.25744283f, -0.19375965f, -0.81553650f, -0.58349311f, -1.05833805f, -0.22838381f, 0.72776735f, 0.43126336f, 
    0.28053114f, -0.04597996f, -0.31428808f, -0.01512594f, -0.17019561f, 0.25496861f, 0.36225089f, 0.24568769f, 
    -0.14633524f, -0.06366996f, 0.02820271f, 0.44175935f, 0.89292109f, 0.29987952f, 0.32264292f, 1.75458133f, 
    1.44329190f, 0.53022748f, 0.48751602f, 0.21318637f, 0.23019360f, 0.61744684f, -0.80176431f, -0.11481292f, 
    -0.40714219f, 0.12503932f, -0.17023303f, -0.10552455f, -0.08324137f, 0.23337007f, -0.05447590f, -0.29638058f, 
    -0.10814692f, -0.45818639f, -0.13509777f, 0.08530995f, 0.40076143f, -0.85620862f, 0.66248035f, -0.12884262f, 
    1.27073717f, 0.64574605f, 0.07507243f, 0.84603840f, 0.61792010f, 1.00408304f, 0.41717058f, -0.52958441f, 
    -0.61186010f, 0.02343732f, 0.29905251f, -0.58951008f, -0.27096975f, -0.16610472f, -0.14668183f, -0.33377144f, 
    -0.29602578f, 0.31038171f, 0.30097565f, -0.16871738f, -0.03201653f, -0.30864897f, 1.33684969f, -2.09385300f, 
    1.48104644f, 1.14034152f, -0.13656282f, 0.09884321f, 0.54660654f, 0.28519416f, 0.00520300f, -0.35202107f, 
    -0.09485155f, -0.27734640f, -0.26754838f, -0.09926434f, -0.30940753f, -0.25577456f, -0.12559123f, -0.23986764f, 
    0.03208612f, -0.18799789f, -0.39436084f, 0.08850694f, 0.12053919f, -0.05109885f, 0.08320518f, -0.96753883f, 
    -0.57281435f, -1.15076756f, -1.09689081f, -0.93404639f, 0.95052677f, 0.44883728f, -0.40938848f, 0.27613831f, 
    0.65402591f, 0.29070431f, -0.28136030f, 0.48747402f, -0.13158403f, -0.66914731f, 0.08407362f, 0.24316540f, 
    0.35428691f, 0.19655496f, -0.00387632f, -0.11256660f, -0.00858413f, -0.09360190f, -0.29670846f, 0.17835502f, 
    1.48390090f, 0.68100595f, -1.39266074f, 0.06333573f, -0.98966503f, 0.13571000f, 0.85152704f, -0.68750399f, 
    0.56516671f, 0.23630267f, 0.45059446f, 0.08339322f, -0.01862644f, -0.02784130f, -0.12026099f, 0.09242583f, 
    0.00883034f, -0.15583973f, 0.18918709f, 0.15533412f, -0.38369140f, 0.11119176f, 0.20701511f, -0.09193110f, 
    0.06303928f, -0.70400226f, 0.62664020f, 0.43672571f, 0.17755483f, 0.41884002f, -1.56185675f, -0.80171770f, 
    0.00596698f, -0.78324980f, -1.11601031f, -0.40965110f, 0.77512097f, -0.21568288f, 0.15636615f, 0.32534808f, 
    0.04904356f, -0.11490732f, 0.04894484f, 0.29007709f, 0.62304598f, 0.05973594f, 0.05489198f, -0.02767057f, 
    0.57389712f, -0.46928412f, 1.29075158f, 1.44734669f, 1.05503106f, 0.64096278f, 0.32109287f, -0.98086709f, 
    0.00152780f, -0.85641706f, -0.14824602f, 0.38071090f, 0.79417861f, 0.08029824f, 0.35873589f, 0.34040812f, 
    -0.72879428f, -0.57635200f, -0.39647678f, 0.20736094f, 0.19366896f, -0.40998977f, 0.02693070f, 0.20131096f, 
    -0.14219007f, 0.01772576f, -0.15743551f, -1.61353397f, -0.58662939f, 0.54205853f, -0.28664207f, 0.98084801f, 
    1.11623597f, 0.44182035f, 0.55126840f, -0.12929665f, -0.55226690f, -0.15052976f, 0.57962734f, -0.07064497f, 
    0.37254894f, -0.03006450f, 0.50022286f, 0.09314588f, 0.25238711f, -0.24259123f, 0.26364928f, -0.07887513f, 
    0.00412556f, 0.30902547f, 0.43839943f, 0.31363124f, -0.37104541f, -0.20646016f, -1.03886926f, -0.93190193f, 
    0.23654442f, -1.11182487f, 1.26257050f, 1.18628788f, -0.24178095f, 0.32960477f, -0.16510606f, -0.19968571f, 
    0.04255606f, -0.87504721f, -0.35046428f, -0.13797973f, 0.07064693f, -0.04683288f, 0.11565062f, -0.50939834f, 
    0.08474352f, 0.14853406f, -0.24256568f, -0.52115220f, -0.28753829f, 0.48972169f, 0.34163886f, -1.07019711f, 
    -0.26081556f, -0.17631063f, -0.40567213f, -1.45283508f, -0.68091857f, -0.70389944f, -0.36187035f, -0.65796292f, 
    -0.35269552f, 0.07164663f, 0.34612337f, -0.34093562f, -0.04394080f, -0.32509235f, -0.81376070f, -0.48448387f, 
    0.15552185f, -0.01658790f, 0.43617934f, 0.33349445f, -0.07792264f, -0.19096991f, 1.21357942f, -0.96497923f, 
    -1.86358595f, 0.00667701f, -0.06984169f, -1.16860914f, 0.65342838f, 0.74557769f, -0.08450979f, 0.45267376f, 
    0.17586164f, -0.17970525f, 0.00299238f, -0.35255197f, 0.28287137f, -0.04831383f, -0.28966528f, -0.26535758f, 
    -0.06773277f, -0.01115048f, 0.18545231f, 0.36548632f, 0.23665567f, 0.43905070f, 0.19722585f, 1.66732848f, 
    0.74888307f, 1.11558545f, 0.01752331f, -1.03410733f, 0.01393883f, -0.44032106f, 0.49962121f, 0.78934628f, 
    0.63825303f, -0.00725554f, 0.17524531f, 0.16888987f, -0.01915979f, -0.41965958f, 0.47485369f, 0.21662185f, 
    0.08560693f, -0.28374451f, -0.16472507f, 0.19331339f, -0.49445781f, -0.19769451f, -0.27499929f, -0.06337466f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25351226f, 0.32022980f, 0.24912167f, 0.84781307f, 0.23805317f, 0.24021792f, -0.02512520f, 0.28401679f, 
    0.50619769f, 0.47719166f, 0.04887894f, 0.31420830f, 0.14658991f, 0.54680336f, 0.34917673f, 0.53568488f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.10439960f, -0.06402101f, 0.20435710f, -0.34544751f, -0.16724098f, -0.10493540f, 0.07279794f, 0.04102151f, 
    0.17468525f, 0.14067324f, 0.01616839f, 0.06746493f, 0.60610133f, 0.14644131f, -0.02792537f, -0.39186919f, 
    0.21490978f, -0.03852084f, 0.22515425f, -0.01709655f, 0.00525611f, 0.01627978f, 0.02025069f, 0.07487403f, 
    0.07628246f, -0.41543326f, 0.17550772f, 0.57433200f, 0.07031127f, 0.01131332f, -0.17768000f, -0.02110087f, 
    -0.21693718f, -0.01611721f, 0.13988651f, -0.08984850f, -0.78120530f, -0.04549456f, 0.31324854f, -0.58004838f, 
    -0.05952659f, 0.09875472f, 0.17014645f, -0.03239671f, -0.20592576f, -0.08932358f, -0.00072566f, 0.13692835f, 
    0.09121396f, -0.27749127f, -0.05534020f, 0.52897817f, -0.14038652f, 0.10956628f, 0.05797186f, 0.16871612f, 
    -0.07778341f, 0.00515347f, -0.02379488f, -0.08289994f, 0.02438099f, 0.35176462f, -0.02148134f, 0.21383975f, 
    -0.01015342f, 0.08848812f, 0.00959736f, -0.18497671f, -0.02082277f, -0.19901173f, -0.19898844f, 0.02711415f, 
    0.47955224f, -0.13097765f, -0.26943582f, 0.75286347f, -0.36144134f, -0.17055473f, 0.14077622f, -0.12941079f, 
    -0.09783472f, 0.06092355f, -0.02235765f, -0.17222539f, 0.67030334f, -0.04987479f, -0.09205160f, -0.52609909f, 
    0.14788409f, -0.02695172f, -0.07079805f, 0.13365002f, 0.00539586f, -0.07811295f, -0.08454978f, -0.00910436f, 
    -0.13000885f, -0.26862288f, 0.16482358f, -0.17959145f, -0.20249006f, -0.01841610f, 0.07552020f, 0.03831408f, 
    0.08112651f, 0.09436927f, -0.00062552f, 0.12719366f, -0.13353483f, 0.17240706f, 0.02287343f, 0.17138463f, 
    0.06322127f, 0.03419038f, -0.12299279f, -0.06136946f, 0.00099519f, -0.38148725f, -0.12748559f, -0.28554961f, 
    0.42421487f, 0.21612462f, -0.09107964f, 0.10611100f, -0.29489979f, -0.27475482f, -0.02222403f, 0.10657273f, 
    0.04750328f, 0.09785952f, 0.12451079f, -0.06684764f, -0.84632820f, 0.10157870f, 0.25909191f, -0.22042811f, 
    0.23821320f, 0.10070378f, -0.09046050f, 0.10225819f, 0.01447727f, 0.01560568f, 0.11266009f, -0.19816159f, 
    -0.75119990f, 0.37897927f, 0.14119442f, -0.58845890f, -0.21705873f, -0.08405851f, -0.11260579f, -0.02708696f, 
    0.03804376f, -0.00190870f, -0.01062328f, 0.07756273f, 0.07710274f, -0.36478412f, 0.14409643f, -0.03409785f, 
    -0.03882133f, 0.06932122f, -0.10140795f, 0.04332525f, 0.06794397f, -0.04724352f, 0.03940341f, 0.07180743f, 
    -0.50640446f, -0.01247762f, 0.10565653f, 0.10682667f, 0.09519114f, -0.09459510f, -0.00602436f, -0.27016786f, 
    -0.17554082f, -0.03357473f, 0.03442432f, 0.04779585f, 0.15364352f, 0.05319777f, -0.36172509f, -0.01302265f, 
    -0.08724481f, -0.29304007f, -0.09204017f, 0.02588132f, -0.16093893f, 0.16349339f, 0.01979577f, -0.09740585f, 
    -0.04812981f, 0.02746105f, 0.27017918f, 0.26715323f, -0.17295995f, 0.09738457f, 0.06795498f, -0.03187994f, 
    -0.05982825f, 0.11840417f, 0.07753341f, 0.12900294f, -0.10112405f, -0.14000703f, 0.11661978f, -0.25254264f, 
    0.11805954f, -0.00883048f, -0.18128070f, 0.11845752f, 0.09987871f, 0.05438464f, -0.05641755f, 0.10082263f, 
    -0.06152021f, -0.09973992f, 0.06077335f, 0.12858053f, -0.19710113f, -0.06745735f, 0.16948874f, 0.06645210f, 
    0.23308912f, 0.28530851f, -0.11102249f, 0.08473927f, 0.20474389f, -0.24046837f, 0.11195926f, -0.25278017f, 
    -0.00336670f, -0.08024842f, 0.07438120f, 0.20319515f, -0.18457149f, 0.26206145f, 0.08597626f, -0.25360873f, 
    0.67169118f, 0.06256782f, 0.08584160f, 0.46499580f, -0.11496831f, 0.15955910f, 0.08033286f, 0.12489311f, 
    0.04567003f, -0.05270486f, 0.00788363f, -0.04822315f, 0.09651912f, 0.02750061f, -0.30350757f, 0.30475396f, 
    0.08442548f, 0.15035598f, -0.15917917f, 0.07317304f, 0.13196936f, 0.18838063f, 0.20115161f, -0.20519619f, 
    -0.00149959f, -0.24256663f, -0.02415615f, 0.12420461f, -0.11438391f, 0.05162974f, -0.03326072f, -0.07662133f, 
    0.08596390f, -0.03404474f, 0.13738257f, -0.14361547f, -0.33796701f, -0.31980553f, 0.08711016f, -0.24572745f, 
    0.05197895f, -0.19434173f, 0.28378743f, 0.07938634f, 0.03421506f, -0.01510284f, 0.04113093f, -0.12100087f, 
    0.67905784f, -0.58752722f, -0.16366276f, -0.25916746f, 0.05861779f, -0.38280091f, -0.03664818f, 0.01892084f, 
    -0.23750977f, -0.11973805f, -0.11202998f, 0.17104110f, -0.43690395f, -0.05638400f, -0.33154419f, -0.40015638f, 
    0.12317126f, -0.05828556f, -0.13930935f, -0.16472907f, -0.19846146f, 0.28270602f, 0.02814894f, 0.28059718f, 
    0.49739143f, -0.11116783f, 0.18721472f, 0.11356255f, -0.19985250f, -0.02625884f, 0.04323993f, 0.03047400f, 
    0.02926853f, -0.25319955f, 0.15008183f, -0.18802093f, -0.06441442f, -0.05690368f, -0.64921594f, -0.22814040f, 
    -0.07203092f, 0.16939718f, 0.07097959f, -0.03565700f, 0.00571127f, 0.29115927f, -0.23574677f, 0.12270351f, 
    0.43780366f, 0.10662943f, -0.01389829f, -0.41978645f, 0.28862691f, -0.23544234f, -0.26955074f, 0.01066652f, 
    0.06771688f, -0.12464727f, -0.12219221f, -0.18193942f, -0.21528907f, -0.35486332f, 0.12911411f, -0.82321805f, 
    0.01413006f, -0.25168192f, 0.18710025f, 0.09643675f, -0.21345581f, 0.08491392f, -0.11096171f, -0.21227384f, 
    0.58024901f, -0.92346740f, 0.06801764f, -0.10256714f, -0.28853518f, 0.10481999f, -0.11709963f, 0.13189872f, 
    -0.03788754f, -0.00035253f, -0.14071052f, 0.16649826f, 0.29705665f, 0.05430294f, 0.00259106f, 0.05784687f, 
    0.03825993f, -0.29078379f, -0.07776398f, 0.02071621f, 0.01889230f, -0.27634972f, -0.04516781f, 0.01185390f, 
    -0.01811996f, -0.07276790f, 0.11472098f, 0.04230011f, 0.18475692f, 0.18544061f, 0.01318949f, -0.15537274f, 
    0.00238579f, -0.20350660f, -0.06666002f, -0.05630297f, 0.17463398f, 0.29719388f, 0.12609006f, 0.46915770f, 
    -0.12954953f, -0.15902644f, 0.19312315f, 0.28511807f, -0.09275577f, 0.09470062f, 0.02213449f, -0.00507299f, 
    0.54806352f, -0.05033430f, -0.21069033f, -0.24295679f, -0.30506375f, 0.22819069f, -0.12842010f, 0.04557395f, 
    -0.00984980f, -0.16628928f, -0.06938604f, 0.24284481f, -1.23339462f, 0.30910239f, 0.04243645f, -0.75437391f, 
    -0.00073607f, 0.10024999f, 0.03916819f, -0.11562410f, -0.16711789f, -0.02807161f, -0.14038458f, 0.10890528f, 
    0.12641452f, -0.32726064f, 0.04717129f, -0.10804809f, 0.05235735f, 0.03965139f, -0.14564081f, -0.01815021f, 
    0.05781126f, 0.05955412f, -0.11098170f, 0.01220426f, 0.23679470f, -0.18290837f, -0.15546156f, -0.18196329f, 
    -0.08466127f, 0.14216901f, -0.12399545f, -0.37187475f, -0.00665285f, 0.14965069f, 0.23981507f, -0.01414423f, 
    -0.90305656f, 0.29837501f, -0.42822891f, -0.42685029f, -0.01119892f, 0.09868272f, -0.19699202f, 0.27513507f, 
    0.29680389f, 0.24394406f, 0.09868979f, -0.32255578f, 0.26350555f, -0.18452106f, 0.28474358f, 0.14277014f, 
    -0.01443120f, -0.44007802f, -0.03844089f, -0.12839818f, 0.04985885f, -0.07740758f, -0.04596553f, 0.03115419f, 
    0.27662721f, -0.15752536f, 0.20167944f, -0.29742563f, 0.17573273f, -0.22921085f, 0.10398911f, 0.12445199f, 
    -0.19487813f, -0.15823902f, 0.03983292f, -0.16300656f, 0.04815114f, 0.19559219f, -0.55372679f, -0.10333560f, 
    0.19004937f, 0.08818008f, 0.19309230f, -0.22278009f, -0.11251894f, -0.18833336f, -0.01974575f, -0.07087100f, 
    0.04209683f, 0.30622566f, -0.18062589f, -0.01036869f, 0.15120006f, 0.06969663f, 0.05368299f, -0.11698855f, 
    -0.10118258f, 0.27845347f, -0.19152558f, -0.05288095f, 0.57808584f, -0.35054216f, 0.09091280f, 0.13776617f, 
    -0.47336504f, -0.38662037f, -0.17979315f, -0.14530894f, -0.02130379f, -0.00604374f, -0.25147140f, 0.05537013f, 
    0.58440316f, 0.29537767f, -0.32581320f, 0.28289419f, -0.14145368f, 0.14489199f, -0.06353361f, 0.09490356f, 
    -0.05539909f, -0.05470875f, -0.05336607f, 0.14860398f, -1.28513479f, -0.14059104f, -0.58896565f, -0.46858644f, 
    0.00069595f, -0.09283596f, 0.01359512f, -0.37504375f, 0.00288244f, 0.16648337f, -0.06257415f, -0.00068531f, 
    0.71177489f, 0.00355451f, -0.01887046f, 0.44867748f, 0.02397917f, -0.13563949f, 0.27949435f, 0.03252536f, 
    -0.01221793f, 0.07277941f, -0.01069612f, 0.18184109f, -0.26595724f, 0.11914468f, -0.02984960f, -0.11531627f, 
    0.09804425f, -0.08129197f, 0.16453731f, 0.11658861f, -0.18501760f, -0.00699236f, 0.02717987f, -0.23899034f, 
    -0.00501058f, -0.69945455f, -0.36083901f, 0.59787899f, 0.03394066f, 0.01087599f, 0.02091851f, 0.08586024f, 
    -0.29703015f, -0.23912805f, -0.07419557f, -0.26222083f, -0.55979747f, 0.37426969f, -0.03350950f, -0.51457506f, 
    -0.24653791f, 0.08524392f, -0.24226800f, -0.11481469f, -0.04839948f, -0.24511637f, 0.03925335f, -0.06346817f, 
    0.67723715f, -0.24350353f, 0.41416782f, -0.04310400f, 0.10506787f, 0.28336814f, 0.16456537f, -0.04522272f, 
    0.19357249f, -0.15651312f, 0.00255424f, 0.08765421f, 0.22242832f, 0.01500892f, 0.28234303f, -0.03667126f, 
    0.03470417f, -0.15292192f, 0.10106530f, 0.07485484f, 0.01873866f, 0.13530570f, -0.10445761f, 0.13968837f, 
    -0.87097687f, -0.56170720f, -0.43757752f, 0.03102608f, -0.06871891f, -0.02645436f, 0.05347387f, -0.17941739f, 
    0.00932658f, -0.22421624f, 0.04671689f, 0.10747191f, -0.13715994f, 0.57690614f, -0.27381375f, -0.18913695f, 
    -0.23857760f, -0.07380024f, 0.07367367f, -0.05917096f, -0.05481387f, 0.04741571f, 0.18411298f, -0.04666205f, 
    -0.07705273f, -0.24576084f, -0.19112237f, -0.09429608f, -0.09743951f, 0.24574357f, -0.04555301f, 0.23039064f, 
    -0.02904446f, 0.04752866f, -0.18282843f, -0.06299908f, -0.12615873f, 0.09453377f, -0.34629554f, -0.20944218f, 
    -0.34916136f, -0.12588321f, 0.01222739f, -0.09258516f, -0.07277685f, -0.14544234f, -0.06835078f, 0.06264271f, 
    0.20506719f, -0.34561363f, -0.34091964f, 0.02240274f, -0.34353915f, 0.18771586f, -0.28251746f, 0.18744771f, 
    0.08755372f, 0.01138124f, 0.05042816f, 0.11088697f, -0.03729877f, 0.40986982f, 0.30398288f, 0.23574384f, 
    0.21375400f, 0.10555355f, -0.06443449f, 0.10914157f, -0.08697439f, -0.13036430f, -0.01625451f, -0.07912013f, 
    -0.33904961f, -0.43760461f, -0.23449668f, 0.53508812f, 0.14264947f, 0.26475203f, -0.02205809f, -0.12133690f, 
    -0.07182059f, 0.10451715f, 0.08403193f, -0.13850856f, 0.05340235f, 0.18004236f, -0.01808649f, 0.13037877f, 
    0.06203723f, -0.39506638f, 0.04613904f, 0.00723169f, 0.03311815f, -0.22689323f, -0.06110324f, -0.09270891f, 
    -0.48406804f, -0.03834547f, 0.12507357f, 0.09394509f, -0.02997702f, -0.07640274f, 0.17311443f, 0.11070363f, 
    -0.30651399f, 0.22132723f, -0.14023738f, 0.08455235f, 0.60706627f, 0.16519761f, 0.09649716f, 0.22543991f, 
    -0.29464346f, 0.28436217f, 0.00049846f, 0.28961849f, 0.24028066f, 0.04323114f, 0.16418755f, -0.01961202f, 
    0.25245354f, -0.07068552f, 0.09637018f, 0.15162243f, -0.06487925f, 0.03552264f, -0.00771435f, -0.07998572f, 
    -0.08244633f, 0.09526388f, 0.07905015f, -0.11187327f, -0.17138188f, -0.59439778f, -0.50413954f, 0.15366641f, 
    -0.14970897f, 0.14209141f, 0.00732701f, 0.07625552f, 0.01502750f, 0.12273174f, -0.27336201f, 0.11998086f, 
    -0.42420056f, 0.21112545f, 0.29551932f, -0.14779209f, 0.01348273f, -0.02000969f, -0.23433717f, 0.05630751f, 
    0.26152509f, -0.34139210f, -0.08655179f, -0.28216690f, -0.49690303f, -0.32774973f, 0.02868909f, 0.31329298f, 
    0.19039428f, -0.08035053f, -0.07368486f, 0.09310323f, -0.07962945f, 0.01920666f, 0.20276925f, 0.09778228f, 
    0.00306653f, 0.16835994f, -0.18023777f, 0.00933672f, -0.11147376f, 0.11153790f, -0.02462592f, -0.44043717f, 
    0.09250749f, -0.08592328f, 0.10991042f, -0.17005664f, -0.01154149f, -0.08300216f, 0.07541616f, -0.02120829f, 
    0.07326378f, 0.04145413f, 0.10945372f, 0.10092163f, -0.01124265f, -0.10475804f, -0.11430317f, -0.03281576f, 
    0.42703453f, 0.27117956f, -0.23852685f, 0.11238216f, -0.09641070f, -0.25180617f, 0.10322420f, 0.12176506f, 
    -0.21935976f, 0.08319065f, 0.08912904f, 0.18792716f, 0.16754538f, -0.06549238f, -0.03210458f, 0.21650393f, 
    0.07477195f, 0.39646047f, 0.22886030f, 0.01282411f, 0.12286656f, -0.03215436f, -0.09240916f, -0.00876842f, 
    -0.66060460f, 0.62956679f, 0.23243761f, -0.55174357f, 0.19717480f, 0.11156981f, 0.02077269f, 0.15142448f, 
    -0.09662873f, -0.07137675f, -0.15927880f, 0.01859240f, -0.12166011f, 0.11384128f, 0.13828102f, 0.46039590f, 
    0.08867445f, 0.05957985f, 0.15128900f, 0.14986536f, -0.12945789f, 0.22237228f, 0.14334737f, 0.15495868f, 
    -0.13559783f, 0.17054430f, -0.11250300f, -0.01247482f, -0.11332190f, 0.14054175f, 0.10279394f, -0.13765408f, 
    -0.10928187f, -0.01023778f, -0.04297442f, -0.05955741f, -0.27678308f, -0.18789898f, 0.35456711f, 0.13778706f, 
    -0.12978545f, -0.00347517f, 0.10030942f, -0.22299793f, -0.01244167f, -0.14065681f, 0.05889473f, 0.00946098f, 
    -0.80609310f, -0.43665314f, 0.16821913f, 0.27332592f, -0.37313440f, -0.08681539f, -0.12805173f, 0.01780212f, 
    0.25218803f, -0.11836639f, -0.15646778f, 0.06396710f, 0.03465458f, 0.12982871f, -0.41204557f, -0.51550364f, 
    0.14364590f, -0.28494465f, 0.03928553f, 0.18900092f, -0.14847805f, -0.19208843f, 0.09213066f, 0.03616137f, 
    -0.37445450f, -0.01853174f, 0.26548418f, 0.01697221f, -0.23453695f, 0.27067751f, 0.17418984f, -0.24900208f, 
    0.13523357f, 0.11895096f, 0.08743197f, 0.07267651f, 0.08974922f, -0.06147197f, -0.13758712f, 0.35265261f, 
    -0.02928963f, -0.12245814f, 0.06161425f, -0.03410203f, -0.15368591f, 0.05931302f, 0.12880149f, 0.11625686f, 
    0.07221260f, 0.36626023f, -0.26867208f, -0.06453182f, 0.01844677f, -0.03419164f, -0.00690025f, -0.01906896f, 
    -0.05065750f, -0.04681849f, -0.03647191f, -0.20610210f, -0.14292376f, -0.39291233f, 0.24633768f, -0.45124790f, 
    -0.22255346f, 0.13665730f, 0.11497797f, 0.02908155f, -0.06490908f, 0.24169207f, 0.08964390f, 0.11368950f, 
    0.08766992f, 0.10642260f, -0.15468597f, 0.42591164f, -0.17139207f, 0.08027185f, 0.10840090f, -0.00773735f, 
    0.06242852f, 0.27321172f, 0.09800436f, 0.39741927f, 0.25070804f, 0.07776380f, -0.15902710f, -0.31753322f, 
    -0.02554795f, 0.06645405f, -0.15923893f, -0.28429756f, -0.04265448f, -0.10806181f, -0.08825622f, -0.05469654f, 
    -0.00470930f, 0.00207694f, -0.09349708f, -0.16750045f, -0.02401083f, -0.22619210f, -0.23622973f, 0.21743156f, 
    0.02977812f, -0.06368502f, 0.17239441f, -0.00275009f, -0.08134685f, -0.03960846f, 0.09954078f, 0.26774490f, 
    0.04493430f, -0.06150175f, -0.11066192f, 0.17501803f, 0.05446776f, -0.07592814f, 0.26639956f, 0.01266364f, 
    0.09868240f, 0.06848433f, 0.28093955f, -0.60887063f, 0.08284777f, 0.09345387f, -0.07530624f, -0.08334882f, 
    0.15192650f, -0.00867143f, -0.05812134f, 0.04354268f, -0.21482739f, 0.23702848f, 0.33608463f, -0.14280783f, 
    -0.00132705f, -0.07560719f, -0.01161268f, -0.00709409f, 0.01893111f, -0.14307931f, -0.09017321f, -0.19101988f, 
    -0.73456746f, 0.35190091f, 0.09895976f, 0.42034984f, -0.13099796f, -0.00459342f, -0.02074184f, -0.04232662f, 
    -0.18696256f, -0.14458716f, -0.09203316f, -0.08888205f, -0.30790186f, -0.43315658f, -0.41550285f, 0.09398706f, 
    0.16326791f, 0.22203395f, -0.20610890f, -0.08865108f, 0.12884936f, -0.28751862f, 0.05799892f, -0.11582571f, 
    -0.04914226f, 0.13783623f, -0.21526836f, -0.09505168f, -0.11005712f, -0.10365941f, -0.10044199f, -0.09403111f, 
    -0.08711016f, -0.02676954f, -0.05697323f, 0.03070143f, 0.15157346f, -0.00096004f, -0.08788453f, 0.13803779f, 
    -0.11790280f, -0.31293812f, 0.14400120f, 0.12078973f, -0.14905760f, 0.04289425f, 0.02540159f, 0.11699691f, 
    -0.21172704f, 0.02703585f, 0.06931149f, 0.11628740f, -0.02408996f, -0.02624040f, 0.12863860f, -0.09602343f, 
    -0.11205395f, -0.33363563f, -0.05429417f, 0.06489414f, -0.40674257f, -0.05235493f, 0.46980247f, 0.09923921f, 
    0.07788619f, 0.21798328f, 0.18126252f, -0.06276698f, 0.20617323f, 0.08515271f, 0.12981956f, 0.07501750f, 
    -0.23766975f, -0.31078389f, -0.24263805f, -0.04096697f, 0.02319258f, 0.06952064f, -0.13395062f, -0.09469842f, 
    0.09640507f, 0.05194018f, -0.02462307f, -0.13200457f, -0.02903034f, 0.21028657f, 0.30371878f, 0.27979657f, 
    0.07399871f, -0.04035210f, 0.14987804f, -0.03350171f, 0.12067223f, -0.05999791f, 0.02521108f, -0.00585281f, 
    -0.44064346f, -0.38176605f, -0.16031060f, -0.23046318f, -0.00532201f, 0.00085268f, -0.04941792f, 0.10990339f, 
    -0.00193245f, -0.02752764f, 0.00719837f, -0.13308173f, 0.44551110f, 0.30971706f, -0.00833359f, 0.19523166f, 
    -0.19691207f, 0.16580315f, -0.15417640f, -0.01897245f, 0.01178443f, -0.06881642f, 0.14194827f, 0.10132679f, 
    -0.02919593f, 0.21929528f, 0.03170180f, -0.23455502f, -0.06323399f, -0.01359341f, -0.14778119f, 0.04530271f, 
    -0.04471904f, -0.17382906f, -0.03144059f, -0.38957435f, -0.58276147f, -0.23631610f, -0.40089387f, 0.15648188f, 
    -0.05341094f, -0.05046780f, 0.12235563f, -0.11515780f, -0.03249308f, 0.08639573f, 0.09506784f, 0.16050798f, 
    0.06364848f, -0.18992189f, 0.36382368f, -0.11324900f, 0.16997609f, -0.13013676f, -0.08320580f, 0.09413781f, 
    -0.25894868f, -0.14320563f, -0.03573255f, 0.01984026f, 0.16531451f, -0.59102726f, -0.46063116f, 0.32114968f, 
    -0.02527447f, 0.05588881f, 0.08803201f, -0.04168373f, 0.06688639f, -0.25107837f, -0.11270266f, 0.03930243f, 
    0.06749652f, 0.03341752f, 0.19295438f, -0.58089179f, -0.09178370f, -0.02017623f, -0.00459083f, 0.19926897f, 
    0.06926139f, 0.02286384f, -0.01560710f, 0.14036411f, 0.11688995f, -0.25997549f, 0.33845526f, -0.10963616f, 
    -0.03437980f, -0.21177857f, -0.01985968f, 0.07724252f, -0.36325219f, 0.04701740f, -0.02933102f, 0.17376596f, 
    0.97829664f, -0.46150103f, 0.30726779f, -0.21538185f, 0.01403652f, 0.05305209f, 0.09758795f, -0.06121223f, 
    -0.07047745f, -0.00917817f, 0.09298766f, 0.04402973f, -0.06106200f, -0.13038322f, -0.46701536f, -0.39370418f, 
    -0.46680260f, 0.07032597f, -0.04498462f, -0.26295462f, -0.13071805f, 0.32978070f, -0.10640965f, 0.14593825f, 
    -0.39423656f, 0.00881292f, 0.08634454f, 0.53974766f, 0.28646404f, 0.31294858f, -0.16300747f, 0.08467039f, 
    0.11597197f, 0.00615008f, -0.07712551f, -0.13465802f, -0.06811982f, -0.03510907f, 0.10027004f, -0.12290167f, 
    -0.03114658f, 0.30459720f, 0.01505149f, -0.07680358f, 0.07244392f, -0.25575277f, 0.05403141f, -0.05666651f, 
    0.06253871f, 0.53067017f, 0.12543994f, -0.28856969f, 0.09053549f, 0.03935818f, -0.01832316f, 0.07877021f, 
    -0.07599287f, 0.30899116f, 0.05393626f, 0.15595144f, 0.22401318f, -0.64761591f, -0.16100679f, 0.17436908f, 
    -0.36507368f, 0.19441900f, -0.10566497f, -0.16868284f, 0.09255502f, -0.00777779f, -0.11900983f, -0.11723980f, 
    -0.42362604f, -0.44136664f, 0.02410429f, 0.03119446f, 0.12260105f, -0.08165888f, 0.14890245f, 0.14800701f, 
    -0.01540477f, -0.21093282f, 0.12207005f, 0.31140032f, -0.28621876f, 0.17421271f, -0.46320090f, 0.01874829f, 
    0.11557715f, -0.06225561f, -0.35439509f, -0.04177318f, 0.15425968f, -0.15184860f, 0.13383184f, 0.00857049f, 
    0.09544379f, -0.12478186f, 0.17131813f, -0.24222352f, 0.16412672f, -0.03871154f, 0.07999868f, -0.23961811f, 
    0.11359821f, -0.02756671f, 0.20144545f, -0.15898813f, -0.67987442f, 0.38575473f, 0.05710324f, 0.52173531f, 
    -0.07102278f, 0.04178122f, 0.25193200f, 0.16779944f, 0.24390037f, -0.05480549f, 0.02759543f, -0.13166527f, 
    -0.66640598f, 0.11668970f, -0.42107525f, -0.09226243f, 0.05857719f, -0.09766607f, -0.09678821f, -0.07121114f, 
    0.10887162f, 0.01672063f, -0.13294785f, -0.10868819f, -0.20127162f, 0.33011055f, -0.13352646f, 0.01647163f, 
    0.10144411f, -0.26233417f, 0.17246975f, 0.04230487f, 0.18711410f, 0.02015110f, 0.10835017f, -0.09426421f, 
    0.15073282f, 0.39983711f, 0.11045218f, -0.13825300f, -0.27566421f, 0.03498652f, 0.02669282f, 0.05702600f, 
    -0.30007479f, -0.22773544f, 0.01351759f, -0.27781236f, 0.20616481f, 0.23087427f, -0.22099346f, 0.38832718f, 
    0.01095709f, -0.18463452f, -0.19621420f, 0.03756883f, 0.19029814f, 0.05160100f, -0.15194243f, -0.15774165f, 
    -0.58543682f, 0.08780872f, 0.06961243f, -0.30637172f, -0.04494026f, -0.02872013f, -0.09715952f, -0.14195433f, 
    -0.18152289f, 0.05109093f, -0.08291221f, -0.20390952f, -0.52562988f, -0.03664868f, 0.06625468f, -0.35399920f, 
    0.03685314f, -0.06076487f, -0.14542045f, -0.31984690f, -0.01708426f, -0.13047093f, 0.08986252f, -0.06166367f, 
    0.41040656f, 0.05747806f, -0.14655861f, -0.09446885f, -0.07152484f, -0.09367923f, 0.02295392f, -0.12843604f, 
    -0.07443672f, 0.02723859f, 0.02657032f, -0.04573968f, 0.10012070f, 0.51206076f, 0.22242799f, 0.57569528f, 
    0.39578950f, -0.01757438f, 0.05822697f, 0.06008940f, -0.02788813f, 0.05208867f, 0.06356350f, -0.18128891f, 
    -0.57830137f, 0.32206082f, -0.00223075f, 0.05638761f, -0.14285487f, 0.08810836f, 0.06632440f, -0.14352635f, 
    0.11438859f, 0.02101323f, 0.07551747f, -0.04625428f, 0.29724318f, -0.49296060f, 0.01181564f, 0.01321771f, 
    -0.07559582f, -0.16928019f, -0.11577322f, -0.08627908f, 0.00991736f, -0.01556555f, -0.18602699f, -0.31389841f, 
    -0.30250472f, -0.19272880f, -0.04093896f, -0.20758347f, -0.02658256f, -0.07400317f, 0.04360534f, 0.03774577f, 
    -0.25300601f, -0.00049113f, 0.07550231f, -0.10077095f, 0.01105939f, 0.00203221f, 0.25879142f, 0.10665654f, 
    0.10542134f, -0.01054988f, -0.05074313f, 0.00308347f, -0.04500940f, -0.00474736f, 0.02505101f, -0.22026280f, 
    0.70547199f, -0.00747135f, 0.50805604f, 0.41808873f, 0.06288591f, 0.01313012f, 0.18855743f, -0.08968177f, 
    -0.04830578f, 0.08644667f, -0.04951910f, -0.02645308f, -0.02976462f, 0.09070344f, -0.08342113f, 0.47063288f, 
    -0.04835567f, 0.04493632f, -0.16246332f, -0.01305473f, -0.16027740f, -0.12321583f, 0.05304050f, 0.09694601f, 
    0.02499604f, 0.31604886f, 0.27191278f, -0.22301795f, -0.19388604f, 0.07537892f, -0.10968188f, -0.08120546f, 
    0.05469406f, 0.00599379f, 0.03621699f, -0.13094939f, -0.42696860f, -0.08986705f, -0.24883693f, -0.43663064f, 
    0.04984311f, 0.06734772f, 0.07405833f, -0.00273866f, -0.01925663f, -0.18494225f, -0.08092455f, -0.20064791f, 
    -0.05308702f, 0.19789991f, 0.02678216f, 0.39061216f, -0.11335051f, 0.10950550f, -0.07891212f, -0.13989836f, 
    0.11333523f, 0.16275308f, 0.04900428f, 0.06949843f, 0.15068573f, 0.28306583f, 0.00512599f, 0.34917691f, 
    -0.23777866f, 0.15412520f, -0.00652492f, -0.05056118f, -0.18990621f, -0.11663308f, -0.02480896f, -0.22120252f, 
    -0.22320721f, -0.07859643f, -0.27297294f, -0.50346321f, -0.08486596f, -0.29169372f, 0.24470574f, 0.04899991f, 
    0.22765094f, 0.09067520f, -0.02170150f, 0.18214002f, 0.28013083f, 0.26818958f, -0.42193294f, -0.26662207f, 
    0.07965094f, -0.10809845f, -0.26511300f, -0.15182465f, 0.13974403f, -0.08878868f, 0.17223695f, 0.24391019f, 
    0.15454525f, -0.00888029f, 0.15178075f, 0.35507458f, 0.18214829f, -0.04303076f, -0.04263532f, -0.14901090f, 
    -0.05562875f, -0.07226136f, 0.11336019f, -0.15816428f, 0.54982871f, -0.23307417f, 0.12594678f, 0.15686405f, 
    -0.02295073f, -0.04396988f, -0.33371246f, -0.07558261f, 0.26630339f, -0.14338183f, 0.00333552f, -0.46512166f, 
    0.05835239f, -0.01306515f, 0.04264987f, 0.04907582f, 0.05695735f, -0.22075653f, -0.08128575f, -0.28997433f, 
    0.04128023f, -0.17154776f, 0.22395512f, 0.10505124f, -0.44155124f, 0.19829114f, 0.32502565f, -0.07963980f, 
    -0.16811572f, 0.14958961f, -0.37711534f, -0.10084665f, 0.09311632f, -0.15905868f, 0.01815453f, 0.18501419f, 
    0.15022504f, 0.35131761f, -0.34842700f, 0.16081469f, 0.14575315f, -0.18691273f, -0.15886775f, -0.00596559f, 
    0.10739172f, 0.02835858f, 0.03702574f, 0.02290026f, -0.31565905f, -0.29842663f, -0.23909234f, -0.50701815f, 
    0.13018237f, -0.28836539f, -0.01559206f, -0.00964302f, 0.11005377f, 0.29114613f, -0.19938220f, 0.30529028f, 
    -0.15263762f, -0.33214182f, -0.48963317f, 0.31402379f, 0.33172032f, -0.04964279f, -0.10539182f, -0.06788535f, 
    -0.04052201f, 0.00026189f, 0.39288798f, -0.13544248f, -0.15422879f, -0.20991497f, 0.13554998f, 0.05036399f, 
    -0.18294019f, 0.13147989f, 0.07883184f, -0.35360008f, -0.12131213f, 0.00551923f, 0.04481925f, 0.14507379f, 
    -0.15216739f, 0.24937734f, -0.23249535f, -0.11612470f, -0.19988172f, -0.25272870f, 0.00594925f, 0.03883058f, 
    -0.02737021f, 0.02754216f, -0.32338786f, 0.00301799f, -0.53447992f, 0.16954930f, -0.36339903f, -0.49644494f, 
    -0.22045159f, -0.11148827f, -0.03025462f, 0.10847034f, 0.08724529f, -0.07728591f, -0.02871677f, -0.64322340f, 
    -0.35362986f, 0.62218148f, -0.06640588f, -0.23325466f, -0.07871053f, -0.03673412f, 0.01518264f, 0.26610830f, 
    0.12825428f, 0.02607643f, -0.20183732f, 0.08351288f, 0.30248719f, 0.06437298f, -0.35521150f, -0.02155356f, 
    0.09366568f, 0.01765593f, -0.23496647f, 0.04056510f, 0.08741225f, 0.12866437f, -0.15350835f, 0.13632739f, 
    0.08887027f, 0.36064753f, -0.25568035f, -0.72448796f, 0.06679773f, -0.13339630f, -0.09568389f, -0.03935864f, 
    -0.32107908f, -0.09191576f, -0.07250566f, -0.27814957f, 0.00364533f, -0.08195683f, 0.29724836f, -0.15160258f, 
    0.17113215f, -0.00741016f, 0.20616785f, 0.11140734f, 0.07293152f, 0.20541924f, 0.14105991f, -0.05373817f, 
    -0.55727309f, 0.08770807f, -0.58540958f, -0.03567151f, 0.04180540f, 0.05828755f, 0.05843448f, -0.23936655f, 
    -0.36112201f, -0.04102021f, -0.09859194f, 0.12166005f, -0.14142577f, 0.20499557f, 0.18133043f, 0.12613592f, 
    0.13978104f, -0.15448688f, -0.05905235f, -0.08593057f, 0.10474519f, -0.03461153f, -0.00614634f, 0.08752663f, 
    -0.84511596f, 0.35486573f, -0.21220005f, -0.27496132f, 0.27553710f, -0.07467259f, -0.00235308f, -0.32349417f, 
    0.03273854f, 0.06703904f, 0.12520428f, -0.33534274f, 0.00057274f, -0.06056358f, 0.11423075f, 0.11981251f, 
    0.02098189f, -0.07251921f, -0.00009411f, -0.06255905f, -0.05213324f, 0.10610571f, -0.10582615f, 0.40211493f, 
    0.64472979f, -0.25829998f, -0.17245708f, -0.42916834f, 0.09012397f, -0.08114646f, 0.09507998f, 0.11754705f, 
    0.05290345f, 0.01027157f, -0.07417679f, 0.43712884f, -0.61976558f, -0.78947979f, 0.20571032f, -0.17680041f, 
    0.20127286f, 0.08679879f, -0.06339946f, 0.22402079f, 0.08054264f, 0.07465272f, -0.17213148f, 0.06036057f, 
    -0.55379224f, 0.27471900f, 0.49951729f, -0.11677148f, -0.05564767f, 0.03870609f, 0.02125862f, -0.06189395f, 
    0.13688667f, 0.02240780f, 0.19526885f, -0.16074947f, 0.27070218f, -0.39743921f, 0.05978057f, -0.08777077f, 
    -0.15953334f, 0.14077328f, -0.17461495f, 0.02309077f, 0.22664750f, 0.15569684f, -0.00797212f, -0.09960505f, 
    -0.39561915f, -0.05411870f, 0.21071586f, -0.62839460f, 0.04106947f, -0.01771597f, -0.06776760f, 0.05099715f, 
    -0.20447837f, 0.11802708f, -0.20368835f, 0.05530977f, 0.35408324f, 0.08563502f, -0.43795946f, 0.28047633f, 
    0.28652361f, -0.08672035f, -0.18622452f, 0.06731941f, -0.05470862f, -0.17277546f, -0.09598859f, -0.13846667f, 
    0.58733016f, -0.47764882f, -0.34520286f, 0.18265705f, 0.12366089f, -0.07612216f, -0.08522814f, 0.28014290f, 
    -0.16303192f, 0.10433820f, -0.02550880f, -0.13810375f, -0.38636991f, -0.25029242f, 0.15805423f, 0.05885454f, 
    0.03085907f, 0.22123472f, -0.04741416f, -0.22190386f, -0.14756161f, -0.06092760f, -0.01309610f, 0.12820628f, 
    -0.62493211f, 0.41867459f, -0.04552792f, 0.34161487f, 0.04532811f, 0.08325811f, -0.24840756f, -0.17744489f, 
    -0.01862768f, 0.07187575f, 0.04853741f, 0.23699296f, 0.43440977f, -0.10338262f, 0.34396800f, 0.14696036f, 
    0.14645100f, 0.16324297f, -0.00612153f, -0.04232654f, 0.18181996f, 0.04700967f, 0.09456600f, -0.10436360f, 
    -0.39589539f, -0.25841644f, -0.00546091f, -0.52468574f, 0.24385262f, 0.08204047f, 0.27010217f, 0.08994126f, 
    0.12441898f, 0.22145759f, 0.24335326f, 0.29930726f, 0.33692384f, -0.27636373f, -0.05120545f, 0.00353078f, 
    -0.26561636f, 0.18151107f, 0.01482927f, -0.11510235f, -0.10766935f, -0.02625525f, -0.27353582f, -0.01582293f, 
    -0.35678020f, -0.23388748f, 0.07000331f, 0.11772163f, 0.16218977f, 0.15058321f, 0.31292352f, -0.10376451f, 
    0.14240189f, 0.16171111f, -0.11499185f, 0.02367290f, 0.16060193f, -0.13391052f, 0.10282423f, 0.00971332f, 
    0.08835080f, 0.28597909f, -0.06380972f, 0.15286583f, 0.06011642f, 0.09363567f, 0.12458621f, -0.11032566f, 
    -0.81729025f, -0.37289459f, -0.33119980f, -0.33492249f, 0.02651615f, 0.02536508f, -0.09713717f, 0.07262225f, 
    -0.05146560f, -0.27510202f, 0.07560796f, -0.14513956f, 0.27716056f, -0.31766400f, -0.24984126f, -0.17924352f, 
    -0.04504703f, -0.25130856f, -0.11105178f, 0.30124795f, 0.09540938f, -0.18328457f, -0.13032144f, -0.00875278f, 
    -0.69385886f, -0.33788484f, 0.14369521f, -0.04468603f, -0.03171705f, -0.08992742f, 0.03131888f, -0.32226217f, 
    0.05676713f, 0.06485722f, 0.01936364f, -0.18408458f, 0.20717661f, 0.29306597f, -0.15633187f, 0.09277491f, 
    -0.39888558f, -0.27691799f, 0.11746567f, -0.16904694f, 0.08483571f, -0.17489469f, 0.33300880f, -0.02205092f, 
    -0.49275103f, -0.30139166f, 0.01708768f, 0.08088120f, 0.18936658f, 0.01714199f, 0.27922934f, -0.10497894f, 
    0.39645028f, -0.07734020f, 0.08550987f, 0.13110475f, 0.49310917f, 0.36855534f, -0.06275968f, 0.00104289f, 
    0.03983963f, 0.01667479f, 0.02251371f, 0.17704067f, 0.11718455f, 0.17828839f, -0.06108265f, 0.11416504f, 
    -0.63841891f, -0.37680221f, -0.07347912f, -0.24578391f, 0.12429396f, 0.07564567f, -0.06888908f, -0.02333287f, 
    0.09551854f, -0.08363686f, -0.02948857f, -0.12297472f, 0.32155618f, 0.46287596f, 0.21191333f, -0.04558175f, 
    0.08228992f, 0.25022396f, 0.02470796f, -0.00291458f, 0.06518199f, 0.09444743f, 0.11862674f, 0.13911520f, 
    0.37501320f, -0.10888042f, 0.24872909f, -0.14905681f, -0.42379141f, -0.06923750f, -0.20163743f, 0.03942647f, 
    -0.03469645f, -0.34912005f, -0.04056682f, -0.26609513f, 0.47505769f, -0.05700511f, 0.24513786f, 0.00901257f, 
    0.12778340f, 0.35422885f, 0.12216405f, -0.16889797f, -0.02623967f, -0.02465313f, -0.20972233f, -0.15203920f, 
    -0.07376599f, -0.45066795f, -0.05517742f, -0.04183255f, -0.02277737f, 0.17128904f, 0.10560855f, 0.11616401f, 
    0.13036244f, -0.08877669f, -0.22382720f, 0.09881382f, -1.36334157f, -0.70936185f, 0.29351220f, 0.01177808f, 
    0.35870352f, -0.05745282f, -0.23753215f, -0.27656469f, -0.04594095f, -0.34795985f, -0.03732512f, 0.36373040f, 
    0.48596367f, -0.66546857f, -0.05519827f, 0.17213775f, -0.12318756f, -0.18016291f, -0.06456707f, -0.09846221f, 
    -0.05379266f, 0.02639681f, -0.11384896f, -0.11583234f, -0.51911205f, -0.42252842f, 0.04032122f, 0.20102613f, 
    0.00573994f, -0.08620743f, 0.09432050f, 0.14944392f, 0.04584070f, 0.11615811f, -0.03314435f, -0.16378787f, 
    -0.57460004f, 0.19676088f, 0.23054928f, 0.24505723f, 0.30177850f, -0.31615430f, 0.12898642f, 0.17117536f, 
    0.17936406f, -0.14578947f, -0.11519133f, -0.00148116f, 0.21048500f, 0.02931018f, -0.26983452f, 0.31453693f, 
    -0.31812841f, -0.01052561f, -0.07468070f, -0.09941434f, 0.06116309f, 0.15989888f, -0.15960765f, -0.00435160f, 
    -0.22574738f, -0.25684431f, 0.11531074f, -0.47817045f, 0.02508357f, -0.00660704f, 0.17906806f, 0.09099485f, 
    -0.01825306f, 0.08166607f, -0.20754568f, -0.03294328f, -0.73666644f, -0.06342017f, 0.00125725f, -0.50219566f, 
    -0.01908139f, -0.02042871f, 0.16904895f, 0.14622650f, -0.00185987f, 0.01420814f, -0.08893666f, 0.03777704f, 
    -0.50337470f, -0.28720155f, 0.07975901f, -0.23788029f, 0.22333516f, -0.20269918f, -0.17642918f, 0.02989505f, 
    0.07670327f, 0.12988055f, 0.02988372f, 0.27301961f, 0.54236740f, -0.27401790f, -0.18405105f, -0.10024942f, 
    -0.17137478f, -0.07160469f, 0.05676337f, -0.18053840f, -0.15263636f, -0.10241548f, -0.28328896f, 0.01345832f, 
    0.15100963f, -0.17662047f, 0.10149029f, -0.02265108f, 0.13441606f, -0.07296723f, -0.13436945f, -0.05377083f, 
    0.09549971f, 0.13291858f, 0.07204087f, 0.05101572f, -0.13396637f, 0.25250855f, -0.01969036f, 0.13060091f, 
    -0.06390094f, -0.00478214f, -0.01379331f, 0.29566616f, 0.13812728f, -0.22669545f, -0.37735462f, -0.44188562f, 
    0.98656654f, 0.05176290f, -0.58470726f, -0.18043427f, 0.03974452f, -0.11569076f, -0.07705721f, 0.03799947f, 
    0.19390170f, 0.08715070f, 0.10044681f, 0.15172237f, -0.17670614f, 0.11387254f, 0.33901495f, -0.03547142f, 
    -0.08251854f, 0.03749475f, -0.10489065f, 0.12155926f, -0.29721695f, -0.01541770f, 0.14560656f, -0.11146327f, 
    -0.52846289f, 0.27475056f, -0.24001673f, 0.23789045f, 0.09763638f, -0.06589566f, 0.19028345f, -0.21592392f, 
    -0.18630169f, 0.11711415f, 0.20391691f, 0.05274041f, 0.27390561f, 0.18557459f, -0.32652465f, -0.18566048f, 
    -0.01042956f, -0.21753892f, 0.03435969f, 0.08308110f, 0.05630535f, -0.04703451f, 0.01451910f, 0.12810066f, 
    -0.52163792f, 0.50290573f, 0.18782082f, 0.09515339f, 0.33952549f, -0.05176078f, 0.15182628f, -0.02931212f, 
    0.02403766f, 0.11381359f, 0.05919539f, 0.02776209f, 0.12288754f, 0.30028716f, -0.07827945f, -0.53354114f, 
    -0.00999988f, 0.09067236f, -0.01921852f, 0.13360654f, -0.00574861f, 0.06815070f, -0.12241510f, -0.01224200f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17118251f, 0.08707871f, -0.05225740f, -0.01407518f, 0.11129154f, -0.00358642f, 0.02722307f, -0.13647930f, 
    -0.04158871f, 0.02423692f, 0.19993718f, 0.05742012f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
