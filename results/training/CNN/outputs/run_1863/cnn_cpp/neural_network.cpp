#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.07774365f, -0.33984560f, -0.32055843f, -0.09004014f, -1.05063772f, 0.50007904f, 0.39769152f, 0.07824246f, 
    0.13820660f, -0.10540016f, 0.09029695f, 0.19037466f, -0.01275462f, -0.34418097f, 0.06954319f, 0.09277415f, 
    -0.41091368f, -0.03023898f, -0.16676900f, 0.11259714f, -0.27581009f, -0.28492251f, -0.15717709f, 0.03854092f, 
    -0.11802228f, 0.05355142f, -0.43218336f, -0.28837746f, -0.31851169f, -0.21864377f, -0.76309961f, -0.41156876f, 
    -0.18317209f, -0.21656479f, -0.85232896f, 0.60870129f, -0.78966218f, 0.05675820f, 0.38223889f, 0.11245291f, 
    0.01269789f, -0.11056021f, 0.02617564f, -0.07559706f, -0.06801759f, 0.01964792f, 0.11589816f, 0.33148098f, 
    0.15098602f, 0.31481928f, -0.85696954f, -0.17166299f, 0.32331631f, 0.60849667f, 0.20202114f, 0.29439574f, 
    -0.06150171f, -0.53071064f, -0.35777214f, -0.17417485f, 0.35855240f, -0.14300592f, -0.21794237f, 0.17087963f, 
    -0.23764543f, -0.21688570f, -0.01443158f, -0.06897976f, 0.11246219f, -0.13633463f, 0.07317066f, -0.28453961f, 
    -0.21298981f, -0.35250267f, -0.75917345f, 0.28861293f, 0.59621358f, 0.11569645f, 0.03323170f, 0.15962113f, 
    -0.24033934f, -0.11672324f, -0.04022281f, -0.12886125f, -0.15166937f, -0.00352110f, -0.39415246f, -0.14252666f, 
    -0.08995923f, -0.15388159f, 0.04326641f, 0.02037896f, 0.03198312f, -0.22413637f, 0.19203915f, 0.15990320f, 
    -0.04539384f, -0.18068051f, 0.39171869f, 0.33591205f, -0.06412989f, -0.02723520f, 0.19686401f, -0.42970723f, 
    0.28664127f, -0.64980775f, 0.03810849f, 0.57613015f, -0.31740329f, 0.11222702f, 0.42422992f, -0.11624613f, 
    -0.49936125f, 0.07604460f, 0.38058984f, 0.04163678f, -0.15549891f, -0.12104003f, 0.02030149f, 0.08023459f, 
    -0.39698008f, 0.19957602f, 0.12515491f, -0.05442368f, 0.35038435f, 0.56073666f, 0.52095133f, -0.08735804f, 
    -0.00230401f, 0.01199879f, 0.36928555f, 0.52640671f, -0.22378138f, -0.14000072f, 0.10893217f, 0.07965885f, 
    0.45447880f, -0.20741132f, -0.44937381f, -0.00133167f, 0.22263600f, 0.05538173f, -0.13994329f, -0.12227850f, 
    -0.37239364f, -0.33003619f, 0.32291570f, -0.02425911f, -0.12313185f, -0.06957269f, -0.08170627f, -0.86889452f, 
    -0.07945501f, 0.18059215f, 0.79055136f, -0.34347349f, -0.06300385f, -0.08841826f, 0.47452506f, 0.42093217f, 
    0.21409006f, 0.26042992f, -0.23093337f, -0.26667020f, -0.27183858f, 0.07475699f, -0.16920747f, 0.05176801f, 
    0.25034475f, -0.43008873f, -0.05854643f, -0.03465171f, -0.25033465f, 0.20148613f, 0.45982572f, -0.37889427f, 
    -0.86140662f, -0.54359943f, 0.54796928f, 0.81145489f, 0.42884132f, 0.39761543f, 0.25042439f, 0.00768251f, 
    0.25185835f, -0.13873306f, -0.37894100f, -0.04861408f, 0.01688954f, 0.13054375f, 0.31346735f, -0.11264628f, 
    -0.09583549f, 0.02975004f, -0.21606457f, -0.03643746f, -0.34752250f, -0.20754495f, -0.00881432f, -0.32736930f, 
    -1.33823383f, -0.56092197f, -0.29015204f, -0.62082714f, -0.31663632f, 0.85295570f, 0.19356631f, -0.67524445f, 
    -0.46586946f, 0.14193657f, -0.35606256f, -0.21047994f, -0.21303390f, -0.34610596f, -0.31256488f, 0.13448077f, 
    -0.03279663f, -0.11875368f, -0.07451615f, -0.13417134f, 0.06669873f, 0.04349677f, -0.07247102f, -0.15618025f, 
    0.11886773f, -0.32560420f, -0.35159495f, -0.98453224f, -0.77762181f, 0.57240629f, -0.64130718f, -0.31729817f, 
    -0.03067124f, 0.38378835f, -0.28169331f, 0.21697119f, 0.17334427f, 0.35579386f, -0.06672628f, 0.07295146f, 
    -0.19865555f, -0.34273350f, -0.44092494f, 0.09163420f, -0.18370926f, 0.03989016f, 0.03132702f, -0.32313848f, 
    0.09678356f, 0.34671208f, 0.66587967f, 0.91353905f, 0.26833004f, -0.46546209f, -0.82296556f, -0.15737721f, 
    -0.00131578f, -0.20363458f, -0.28332153f, 0.35709766f, 0.16831023f, 0.17904671f, -0.16103652f, -0.05502867f, 
    -0.20173779f, 0.20345381f, -0.16914795f, 0.23721047f, 0.08004384f, -0.31683037f, 0.03001298f, 0.04008519f, 
    0.07442070f, -0.35817856f, 0.31186968f, -0.74450088f, 0.14123432f, 1.00958836f, -0.50258416f, -0.04977093f, 
    -0.24911630f, -0.19803153f, -0.42935595f, 0.01986303f, 0.13709547f, 0.41399521f, -0.31577265f, -0.09017306f, 
    -0.06504738f, 0.09756006f, 0.07337961f, -0.11194058f, 0.20051134f, -0.13247903f, -0.30486035f, 0.11244306f, 
    0.37140787f, 0.25949392f, 0.25388920f, 0.11296847f, -1.33173823f, -0.28178361f, -0.72115558f, -0.15878178f, 
    0.13761815f, 0.17603305f, -0.02633231f, 0.65410912f, 0.62641031f, 0.42121318f, 0.03133582f, 0.19492640f, 
    -0.20863052f, 0.33024719f, -0.27301377f, -0.06141960f, -0.07435265f, -0.07411186f, -0.32506055f, 0.11545717f, 
    -0.05357786f, 0.25378010f, 0.05737834f, -0.00316545f, 0.02544047f, 0.61613834f, 0.76547199f, 0.15446021f, 
    0.52094078f, -0.42488894f, -0.61578572f, -0.40299180f, 0.23589286f, 0.17321478f, -0.17867242f, 0.00268845f, 
    0.11851212f, 0.39398184f, -0.27109975f, -0.33238414f, -0.16652267f, 0.27559021f, -0.08004903f, -0.01379399f, 
    -0.09903893f, 0.10931924f, 0.00004059f, 0.02620531f, 0.16988683f, -0.22330754f, 0.31446931f, 0.24631254f, 
    0.18679777f, 0.11315179f, -0.37094912f, 0.07235409f, -0.23594974f, 0.40775150f, 0.16260867f, 0.02456320f, 
    -0.11444152f, 0.24732395f, -0.06930891f, 0.06051021f, -0.36177412f, -0.38737556f, 0.16521046f, -0.09920688f, 
    -0.26939842f, 0.40791020f, -0.22215575f, -0.02253973f, -0.28933710f, 0.10814440f, 0.44377419f, 0.64815837f, 
    -0.02835187f, -0.43228650f, -0.28864166f, 0.01887539f, -0.29059801f, -0.15320614f, -0.90508240f, -0.71863520f, 
    -0.89507699f, 0.24043962f, 0.61043566f, -0.14689656f, -0.12923896f, -0.30364868f, -0.27058798f, 0.35403508f, 
    -0.03096466f, -0.04190939f, -0.01030198f, -0.04792370f, -0.17135148f, -0.07222377f, 0.03039133f, -0.39057994f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.35060370f, 0.08606191f, 0.01511108f, 0.20345861f, 0.15986468f, 0.27718464f, 0.18984506f, 0.20871566f, 
    -0.11504332f, 0.30270988f, 0.42611364f, -0.01578741f, 0.51234686f, 0.23758720f, 0.38028994f, 0.20710510f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.31650892f, -0.15852368f, 0.19357492f, 0.05121871f, 0.01980543f, 0.01992236f, -0.13020878f, 0.14231604f, 
    -0.11732095f, -0.07928903f, -0.13163379f, -0.03280882f, 0.04165384f, 0.06756736f, -0.20449151f, 0.23443703f, 
    0.04871128f, -0.00804745f, -0.15977755f, 0.28760535f, 0.05543200f, 0.06497251f, -0.07285033f, 0.08796775f, 
    0.21586213f, -0.06176233f, -0.16765134f, 0.04765353f, -0.10438868f, 0.00854738f, -0.14103854f, -0.06032199f, 
    -0.03038907f, 0.06717259f, -0.17978500f, 0.02702326f, -0.01360254f, 0.06020306f, 0.08297256f, 0.10930872f, 
    0.01009095f, 0.08092697f, -0.15558375f, 0.03253653f, 0.09157165f, 0.04003152f, 0.07518600f, 0.03777662f, 
    -0.15203032f, 0.13859436f, 0.06551760f, 0.02127063f, 0.10343303f, -0.11692727f, -0.04495320f, 0.06050609f, 
    0.12530515f, -0.01593995f, -0.15540425f, 0.01445484f, -0.26010489f, 0.15253478f, 0.18660551f, 0.04141914f, 
    -0.07397936f, -0.05995585f, 0.02979567f, 0.04130423f, 0.06376891f, -0.08941478f, 0.03130384f, 0.19853297f, 
    0.24816917f, -0.07555924f, 0.05943315f, -0.32156491f, -0.11814471f, 0.07786799f, -0.08793662f, -0.09693821f, 
    0.19903530f, -0.10007499f, 0.10208407f, -0.07726122f, 0.00617030f, -0.27946502f, 0.12948705f, -0.09617592f, 
    -0.07232796f, -0.01688664f, -0.04946536f, -0.05608766f, 0.18383536f, 0.09932923f, -0.02362090f, -0.02567576f, 
    0.17338465f, -0.11627667f, -0.38770798f, -0.25954717f, -0.26192236f, 0.07071398f, -0.07729788f, 0.15472429f, 
    -0.01330247f, -0.12841079f, 0.03935702f, -0.02504113f, 0.20215937f, -0.13252047f, -0.12960409f, -0.06393544f, 
    -0.06245364f, -0.00089931f, 0.04721344f, -0.15260659f, -0.02710774f, -0.05026199f, 0.04662479f, 0.02632290f, 
    -0.48152173f, 0.12997384f, -0.04022266f, 0.25781775f, 0.11758748f, 0.00371988f, -0.02873640f, 0.07401095f, 
    0.03467451f, 0.12074479f, -0.04465325f, 0.19781019f, 0.13980472f, 0.00253809f, -0.11559116f, 0.07144319f, 
    -0.04447995f, 0.21929044f, 0.14502297f, -0.05041696f, 0.05497152f, -0.01421453f, -0.02475575f, 0.05654183f, 
    0.58087838f, 0.17128308f, -0.02886472f, -0.01183128f, -0.10599394f, 0.06422389f, 0.09747036f, 0.05386489f, 
    0.12674864f, 0.00745561f, -0.12454136f, 0.08205366f, -0.30409458f, 0.31089479f, -0.02969827f, 0.32011664f, 
    0.04292960f, 0.08409265f, -0.07254463f, 0.08683026f, 0.15006480f, 0.00361663f, 0.02684536f, 0.02789559f, 
    -0.02332857f, 0.02350510f, -0.12235264f, 0.13698818f, 0.03946244f, 0.00648405f, -0.06207355f, 0.03442604f, 
    0.07836482f, 0.04379489f, 0.12269345f, -0.16349024f, 0.10749719f, 0.19937830f, 0.13144004f, -0.11019916f, 
    0.19373631f, -0.03510677f, 0.00059426f, 0.14694828f, 0.04162604f, -0.04298154f, 0.20707132f, -0.15535328f, 
    0.01998164f, -0.07034257f, -0.05215374f, -0.04509186f, -0.07866193f, -0.03293973f, -0.06376766f, 0.02702967f, 
    -0.03136491f, 0.01703344f, -0.04085690f, -0.04821065f, 0.00039780f, 0.04830330f, -0.03519427f, 0.01568459f, 
    -0.03623204f, -0.00469500f, -0.06871358f, 0.02889196f, -0.00030391f, 0.04702287f, 0.02578096f, 0.01189374f, 
    0.03269265f, -0.01479467f, -0.07987090f, 0.02832031f, -0.01364955f, 0.04046417f, -0.07381785f, -0.06016232f, 
    -0.03376121f, -0.03140291f, -0.05706686f, -0.02371710f, 0.04100525f, 0.00837979f, 0.02961376f, 0.05467282f, 
    0.04466194f, 0.00363013f, -0.04584945f, 0.04995012f, -0.02868599f, -0.07661152f, 0.01743451f, 0.01100352f, 
    -0.02340149f, -0.00298640f, 0.01278371f, 0.02198344f, -0.04910359f, -0.04568337f, -0.04851642f, -0.03734186f, 
    -0.07669146f, 0.02952264f, -0.01442783f, 0.02407527f, -0.03803842f, 0.05873463f, 0.03496331f, -0.00721065f, 
    -0.04798012f, -0.05498760f, 0.00953407f, -0.05507857f, -0.00533807f, -0.00494505f, -0.07548004f, 0.03167401f, 
    -0.04585204f, 0.02293157f, 0.03312827f, -0.02628947f, 0.04952337f, -0.02299568f, -0.01871937f, -0.05430089f, 
    0.02051629f, -0.07941788f, 0.02350696f, -0.05182744f, 0.04823436f, -0.04152171f, 0.06108129f, 0.04086893f, 
    0.02854645f, 0.00237425f, -0.01654296f, -0.06548516f, -0.01830139f, 0.00551227f, -0.00014594f, -0.00334156f, 
    0.02793565f, 0.00480146f, -0.06138364f, 0.06258717f, -0.04295893f, -0.04692937f, -0.05917148f, -0.07877705f, 
    -0.00352957f, 0.01150302f, -0.06182500f, -0.06815967f, -0.01661767f, 0.05530672f, 0.00740788f, 0.00086383f, 
    -0.05339858f, -0.00324379f, 0.01111616f, 0.00946247f, -0.05819944f, -0.07161861f, 0.01643626f, 0.01537587f, 
    -0.02239542f, -0.00949024f, 0.03492218f, 0.01385425f, -0.05383008f, 0.03482774f, 0.00160319f, -0.06530999f, 
    -0.04880834f, 0.02479782f, -0.06862526f, -0.03720779f, 0.06076706f, 0.01170916f, 0.01964837f, -0.01680061f, 
    0.04590981f, -0.06346831f, -0.00808879f, 0.05125337f, 0.04948747f, 0.03058400f, -0.05008584f, 0.05401225f, 
    0.04400517f, -0.05500593f, 0.00707650f, 0.04630907f, 0.04202264f, -0.01507601f, -0.01398234f, -0.06102020f, 
    0.02251782f, 0.01938917f, -0.01826779f, 0.02928002f, -0.04373539f, 0.03537678f, -0.02637612f, -0.00457658f, 
    -0.00357141f, -0.05406919f, -0.06778865f, -0.03459021f, 0.01018429f, -0.04426383f, 0.04108818f, -0.07720935f, 
    -0.01085256f, 0.02829655f, -0.01935467f, -0.02341397f, -0.07371321f, -0.06359985f, -0.02950777f, -0.07231072f, 
    -0.04895683f, -0.07602789f, -0.07185333f, -0.03098639f, 0.04878046f, 0.05939580f, 0.01927454f, -0.05145063f, 
    -0.01853926f, 0.05993885f, 0.00749962f, 0.05755503f, -0.03873537f, 0.00031288f, -0.07881825f, -0.02057836f, 
    0.21988925f, -0.15789634f, -0.10981429f, -0.27043861f, -0.05077446f, -0.13885084f, 0.06050136f, -0.12126521f, 
    0.04967766f, 0.11805440f, 0.06624066f, 0.10243465f, 0.10288821f, 0.35456136f, 0.43541685f, -0.00136365f, 
    -0.17185783f, -0.13356720f, 0.29409277f, -0.04721429f, -0.02684451f, 0.00198413f, 0.08491044f, -0.19892880f, 
    0.06533418f, 0.14956684f, 0.03655892f, 0.06875452f, -0.05981007f, -0.18592304f, -0.09024061f, -0.08713335f, 
    -0.06995012f, 0.04793704f, 0.04499751f, 0.16492409f, -0.14556806f, -0.14834292f, 0.01426692f, 0.11392720f, 
    0.12857138f, -0.03091250f, 0.14972867f, 0.18477887f, -0.04420182f, -0.01126571f, -0.17145112f, -0.12705193f, 
    -0.11168767f, -0.05326155f, -0.27476102f, -0.22384363f, 0.32167020f, 0.28831658f, -0.06122463f, -0.15521534f, 
    0.04421901f, 0.18261386f, -0.03309276f, -0.05897585f, -0.03422561f, -0.47700104f, -0.54961848f, -0.36903200f, 
    0.02208439f, 0.12460968f, -0.09620057f, 0.02934636f, 0.02533870f, 0.26028997f, 0.00760532f, 0.16407831f, 
    -0.19134203f, -0.00852103f, -0.07059193f, -0.03244118f, -0.06184950f, 0.05491818f, 0.07169496f, -0.07748235f, 
    -0.22357371f, 0.08713502f, -0.07850695f, -0.03891882f, -0.04325114f, -0.21829206f, 0.05076715f, 0.16062675f, 
    0.04879541f, -0.08003213f, 0.11540359f, -0.12917031f, -0.07382680f, 0.05951687f, 0.04261729f, 0.04144629f, 
    0.27599311f, 0.22735624f, 0.24216118f, 0.46522614f, -0.00090635f, 0.13664368f, -0.19278336f, 0.08665971f, 
    0.06144987f, 0.02603941f, -0.02745663f, 0.04818285f, 0.17880645f, 0.27389470f, 0.13268922f, 0.36275393f, 
    0.05732495f, 0.06323282f, -0.11238839f, 0.09571574f, 0.08717042f, 0.05953174f, 0.03635839f, -0.00651004f, 
    -0.04212383f, -0.27837503f, 0.14731248f, -0.28726724f, 0.03158793f, 0.23841408f, -0.16461073f, 0.03792914f, 
    0.16934554f, 0.06351125f, 0.08670731f, -0.05567303f, 0.20880531f, 0.33947650f, 0.29789284f, 0.19828348f, 
    0.04346699f, 0.09331651f, -0.00235890f, 0.29802111f, 0.03814565f, 0.08461601f, 0.11836630f, -0.14184812f, 
    0.15029292f, 0.11590854f, 0.10920643f, 0.19502866f, 0.09413422f, 0.07604139f, 0.07275118f, 0.12212441f, 
    0.07397515f, -0.00050707f, 0.08951386f, 0.15439516f, -0.37074909f, -0.27746123f, -0.09014729f, -0.02120455f, 
    0.11741687f, -0.24427035f, -0.12192391f, -0.10833674f, 0.14220990f, 0.03333572f, 0.03817217f, 0.09032535f, 
    -0.15658915f, -0.35912356f, -0.08742847f, -0.41317642f, 0.12482942f, 0.01682013f, -0.07077426f, 0.08204806f, 
    0.03813664f, 0.00091142f, -0.12916586f, 0.01054741f, 0.20674051f, 0.34349746f, -0.14637361f, 0.12957071f, 
    -0.19307829f, -0.08551900f, -0.03203503f, 0.20441405f, -0.07074974f, -0.01538106f, -0.15373093f, 0.03505404f, 
    -0.16779828f, 0.01360475f, -0.22997561f, 0.01248083f, -0.25188231f, 0.14005642f, -0.07813402f, 0.07986458f, 
    0.23496518f, 0.05554613f, -0.07187968f, -0.18518870f, 0.12619452f, 0.09438365f, -0.08068958f, 0.23851900f, 
    0.18020433f, 0.46729240f, 0.23738548f, -0.04310996f, 0.09500653f, 0.00389531f, -0.06222211f, 0.12036495f, 
    0.05726903f, 0.41168195f, 0.13075030f, -0.10323257f, 0.06037432f, -0.09772750f, -0.03212487f, 0.15369552f, 
    0.02798150f, -0.27181357f, -0.24664387f, -0.04142508f, -0.00553147f, 0.01233807f, 0.08469677f, 0.10898470f, 
    -0.12297591f, -0.04006669f, -0.15884201f, -0.06261884f, -0.10532010f, 0.12666309f, 0.07350893f, 0.16163999f, 
    -0.06177362f, 0.08457116f, 0.13102745f, 0.13663390f, 0.02993839f, -0.08795089f, -0.13297664f, -0.20598468f, 
    0.14292027f, 0.13218771f, -0.02608732f, 0.18412711f, 0.01938666f, 0.16468677f, 0.02134799f, 0.19147891f, 
    -0.04842033f, -0.19982931f, -0.07659012f, -0.08147012f, 0.16513576f, -0.09882828f, -0.19708446f, -0.00212910f, 
    0.00268793f, -0.10690001f, 0.22366752f, -0.04861499f, -0.10754202f, -0.01460646f, -0.14106508f, -0.01950874f, 
    0.15361314f, -0.02686572f, 0.09668152f, 0.23939545f, 0.07430855f, 0.10666230f, 0.04591374f, -0.22866252f, 
    -0.16529341f, -0.15398721f, -0.03708988f, -0.19620538f, 0.08400355f, -0.06239790f, -0.22689542f, -0.22065505f, 
    0.13299535f, 0.39544445f, 0.32742676f, -0.04821303f, 0.24874175f, 0.04888167f, 0.03762490f, 0.21178544f, 
    0.02226556f, -0.01371703f, -0.00232224f, 0.01209370f, 0.34177965f, -0.01402092f, -0.25913328f, 0.12278767f, 
    0.16883276f, 0.56981486f, 0.29073232f, -0.03179940f, 0.15287584f, -0.00202096f, 0.03193269f, 0.08641289f, 
    -0.18381774f, 0.19503179f, 0.13510671f, 0.22856481f, -0.06615068f, 0.06909163f, -0.26690328f, 0.07164879f, 
    0.13265125f, -0.03451085f, 0.06062145f, 0.10669132f, -0.03991291f, -0.23484121f, 0.13847964f, -0.20182367f, 
    0.14412835f, 0.10590102f, 0.10197163f, 0.27593094f, 0.10889460f, 0.12506483f, 0.13486999f, 0.23500663f, 
    -0.10392472f, -0.22128467f, -0.41583019f, -0.17979731f, -0.07940685f, 0.07170288f, -0.04046388f, -0.02784564f, 
    0.14101407f, 0.03853708f, 0.11677869f, 0.02390124f, -0.14799142f, 0.12543230f, 0.20699659f, 0.36157066f, 
    -0.04310901f, -0.05460428f, -0.35349548f, 0.01507413f, -0.12160426f, -0.19688283f, 0.04824571f, -0.07789326f, 
    0.09809173f, 0.15810725f, 0.05306438f, 0.24974856f, -0.08308695f, -0.12394930f, -0.17220315f, -0.11722133f, 
    0.23658478f, 0.00788380f, -0.04493026f, 0.17765985f, -0.02772792f, 0.25743109f, 0.22727813f, 0.05765893f, 
    0.12166453f, -0.01438382f, 0.09203124f, 0.04108398f, -0.10090216f, -0.12193964f, 0.05249458f, 0.10512028f, 
    0.17218292f, -0.21203870f, 0.06948954f, -0.21672241f, -0.04778174f, -0.05686405f, 0.07966094f, 0.19675711f, 
    -0.03068071f, -0.05180582f, 0.28814542f, -0.03555109f, -0.04216518f, -0.05599552f, -0.10597565f, -0.23333283f, 
    0.13462177f, -0.29487821f, -0.02791745f, 0.05100105f, -0.11041792f, -0.08362532f, -0.08072690f, -0.14931153f, 
    -0.23785934f, -0.05147090f, 0.00512656f, 0.16277452f, -0.14186396f, 0.24857093f, 0.07642642f, 0.06101261f, 
    0.08270695f, 0.12103679f, 0.34510353f, -0.05731238f, 0.19566114f, 0.01106300f, -0.14804783f, -0.06494351f, 
    0.02289509f, -0.04393332f, 0.07184066f, -0.28438208f, -0.02592845f, -0.05422970f, -0.08057462f, -0.07339188f, 
    -0.01478679f, -0.14180420f, -0.02345533f, -0.02434848f, 0.04878389f, -0.07458572f, -0.18634558f, -0.10560323f, 
    -0.16606189f, -0.05190318f, 0.08649888f, 0.00928534f, 0.01933752f, 0.10979589f, 0.15090930f, 0.03539079f, 
    -0.18234530f, 0.23491876f, -0.08398251f, 0.12542611f, -0.06152112f, 0.12517799f, 0.27273360f, -0.07295169f, 
    0.10671161f, 0.05734681f, 0.16512078f, 0.15560047f, 0.28634080f, 0.05557179f, -0.02780237f, -0.19922802f, 
    0.05710708f, 0.20776443f, -0.03946460f, -0.05119469f, 0.20356327f, 0.21078540f, -0.19413973f, 0.24462281f, 
    0.11330619f, 0.03884638f, -0.03047026f, -0.09332522f, -0.05172763f, 0.01230054f, 0.12066510f, 0.15179397f, 
    -0.02151183f, 0.05089773f, -0.31786969f, -0.45964766f, -0.05172940f, 0.00058451f, 0.05700866f, 0.18804374f, 
    0.02337204f, -0.10774948f, 0.06227429f, 0.15680543f, -0.32088462f, -0.00688169f, 0.13867439f, -0.20788045f, 
    0.16018337f, -0.41234547f, 0.11500277f, 0.04005787f, -0.11807022f, -0.02883723f, -0.11664776f, 0.14763345f, 
    -0.11057410f, 0.24912299f, 0.02356815f, 0.02529751f, -0.31186515f, -0.07051086f, 0.27729172f, 0.05098263f, 
    -0.21549888f, 0.05856910f, 0.07461140f, -0.09001403f, -0.00120184f, 0.01198602f, -0.17038321f, 0.07988004f, 
    -0.10649517f, 0.16437843f, -0.06315535f, -0.17926650f, -0.09148996f, -0.04713570f, -0.16397706f, -0.26889542f, 
    0.34596583f, -0.19409092f, 0.03399685f, -0.07965215f, 0.09538610f, -0.18501569f, -0.15217644f, -0.18188930f, 
    -0.06909600f, -0.03044336f, 0.17029594f, 0.01889298f, 0.24057086f, 0.10839721f, -0.05162369f, -0.00556743f, 
    0.15467429f, 0.06310260f, 0.19601798f, -0.09696600f, -0.05568567f, 0.03954009f, 0.00294627f, 0.07763954f, 
    0.11272065f, -0.03185410f, -0.16553986f, -0.02675371f, 0.08841590f, -0.11512781f, 0.15095271f, 0.14837378f, 
    -0.12128863f, 0.17639145f, -0.09684240f, -0.02903646f, 0.05121511f, -0.06936187f, 0.18480223f, 0.05802317f, 
    -0.13121387f, 0.00187678f, 0.20486546f, 0.31021097f, -0.04132627f, 0.11098506f, 0.00456522f, -0.04321936f, 
    0.05880723f, -0.00851204f, -0.02350477f, 0.05631454f, -0.04700041f, 0.02838007f, 0.04597904f, 0.05091028f, 
    -0.07126824f, -0.06899466f, -0.02586801f, 0.04164772f, -0.07599280f, -0.03013062f, -0.06779271f, -0.04375099f, 
    -0.07145016f, -0.02087738f, -0.07513873f, 0.03958057f, 0.00338742f, 0.01055139f, -0.03822672f, 0.05496920f, 
    -0.02316148f, -0.01517867f, 0.03398852f, -0.07407056f, -0.03188321f, 0.05865180f, 0.05734977f, -0.00045633f, 
    -0.00318004f, 0.05794949f, -0.06806738f, 0.05313314f, 0.04788195f, -0.01410328f, -0.00292799f, 0.02799855f, 
    -0.03404689f, 0.01799114f, -0.02429882f, 0.05862522f, -0.04545466f, -0.05054783f, -0.02407197f, 0.05733893f, 
    0.06602734f, -0.05815425f, -0.06798951f, -0.02586892f, 0.03071943f, -0.03341549f, -0.01028682f, -0.06773754f, 
    0.04337354f, -0.03453838f, -0.07438561f, 0.01728718f, 0.03367478f, -0.05337068f, -0.05909420f, 0.00844192f, 
    0.02669564f, -0.04823750f, -0.03274377f, 0.01496326f, 0.05498323f, -0.01757153f, -0.06378496f, 0.02475838f, 
    0.04714414f, -0.06015719f, 0.03936034f, 0.01369328f, 0.06000638f, 0.06077104f, -0.03830730f, 0.00586407f, 
    -0.06036658f, -0.03192945f, 0.03527421f, 0.06108430f, -0.06565776f, 0.01940825f, 0.03377206f, -0.03393916f, 
    -0.05235067f, 0.02647396f, -0.00472482f, -0.04370844f, 0.02613716f, -0.06419909f, -0.06976341f, 0.04120684f, 
    -0.01744028f, 0.00151864f, 0.02296106f, -0.01223880f, -0.07513583f, -0.02729418f, 0.00348803f, 0.03755534f, 
    -0.06417058f, 0.02724743f, 0.01949276f, -0.07571454f, 0.03244659f, 0.04930392f, 0.04718209f, -0.03712429f, 
    0.04092118f, 0.05253049f, 0.04610127f, 0.04092145f, 0.00516276f, -0.03905426f, -0.06787432f, -0.04182871f, 
    0.04272863f, -0.02186210f, -0.04621125f, 0.04100932f, -0.02319300f, -0.03178415f, 0.04068614f, 0.02795206f, 
    0.01567172f, 0.01826248f, -0.05738470f, 0.01304713f, -0.07117933f, 0.00872371f, -0.04384031f, 0.01973344f, 
    -0.04224810f, 0.00531194f, -0.05559002f, -0.05003386f, 0.04221131f, -0.04592946f, 0.00083965f, 0.03695462f, 
    -0.01190310f, -0.06655516f, -0.05494102f, -0.06506668f, 0.00163305f, -0.03727319f, 0.00084630f, -0.01155494f, 
    0.00438431f, 0.05481784f, 0.04573377f, -0.06645838f, 0.05164158f, -0.05244108f, -0.00137031f, 0.00226765f, 
    0.05911466f, 0.05393659f, -0.06328463f, -0.02176034f, -0.01792523f, -0.07914807f, -0.02860173f, 0.02461429f, 
    0.00051589f, 0.00701167f, 0.00594300f, -0.03175448f, 0.05689300f, 0.01869197f, -0.06306286f, -0.07102520f, 
    -0.07449450f, 0.01430479f, -0.00556825f, -0.01594010f, -0.04390249f, 0.03246199f, 0.02124831f, -0.03069429f, 
    -0.07935830f, -0.00567555f, -0.02982723f, 0.02956644f, -0.06386407f, -0.02193880f, -0.06326041f, -0.02539621f, 
    -0.07599761f, -0.18453170f, -0.26031709f, 0.05610824f, -0.03510209f, 0.00920906f, -0.07665255f, 0.03996956f, 
    0.15776524f, -0.15889031f, -0.17339647f, -0.13456696f, 0.33272636f, 0.15726918f, 0.01035420f, 0.04133200f, 
    0.24985681f, 0.28778121f, 0.05684555f, 0.15615128f, 0.03806158f, 0.08941319f, -0.02252123f, 0.14147604f, 
    0.21025001f, 0.15453762f, -0.02018208f, -0.08232788f, -0.06682426f, -0.03806893f, 0.04175434f, 0.03726030f, 
    -0.03472635f, -0.21897535f, -0.21108820f, -0.03472161f, -0.12339916f, 0.03423583f, 0.02309273f, 0.13445713f, 
    0.09822568f, -0.05900575f, -0.11888181f, 0.05009354f, 0.02630336f, -0.04417800f, 0.02336792f, 0.17923084f, 
    -0.23047470f, 0.00979778f, 0.11961887f, 0.01394595f, 0.04669640f, -0.16327184f, -0.11308023f, 0.15965824f, 
    0.19932128f, -0.13364984f, 0.01206360f, 0.07098048f, -0.24177022f, -0.05723230f, -0.11253831f, -0.08562501f, 
    0.05519953f, -0.03451372f, 0.11965661f, -0.09087433f, 0.07396039f, 0.05565675f, -0.08468019f, -0.00701940f, 
    0.18420197f, 0.08462997f, 0.08839740f, -0.23346020f, -0.09827863f, 0.00298873f, 0.01880294f, 0.08929074f, 
    0.13901229f, 0.01582153f, 0.11076371f, 0.18776472f, -0.25470319f, -0.02036790f, -0.07401595f, -0.24035703f, 
    -0.18758044f, -0.02939976f, 0.08143090f, 0.06678379f, 0.05278211f, -0.10591137f, -0.26449850f, -0.09844357f, 
    0.35306019f, 0.35340983f, -0.07203146f, -0.29829898f, 0.16346790f, 0.06126693f, 0.16227163f, 0.10711028f, 
    -0.08180062f, -0.01095462f, -0.05998277f, -0.05006336f, 0.37563372f, 0.13035810f, -0.08649573f, -0.09810076f, 
    -0.07551652f, 0.27540538f, 0.15663430f, -0.09443313f, 0.03265213f, -0.07137208f, -0.01897538f, -0.06323833f, 
    -0.19551070f, 0.06071306f, -0.23372319f, 0.19787826f, 0.07325617f, -0.09550665f, -0.14124668f, 0.03616575f, 
    -0.05120072f, 0.11444739f, 0.02132952f, 0.03064523f, 0.04813180f, 0.03556302f, 0.16224538f, -0.08369944f, 
    0.11812132f, 0.10715240f, -0.03412637f, -0.16784553f, 0.07039306f, 0.06935947f, 0.11801421f, 0.09840702f, 
    0.00392064f, 0.05057866f, -0.08769430f, -0.12796220f, 0.06447628f, 0.21260001f, 0.20266023f, 0.13103408f, 
    0.14357431f, 0.14469223f, -0.08919432f, -0.03608028f, -0.23890762f, 0.03963280f, -0.11917813f, 0.07259946f, 
    0.02346837f, 0.08329171f, -0.07023018f, -0.03656388f, -0.04053035f, 0.04664002f, 0.07427763f, -0.03926013f, 
    -0.12644832f, 0.04541996f, -0.12570739f, 0.01425190f, -0.09109183f, -0.00031412f, -0.06726019f, -0.06977361f, 
    0.10698732f, -0.05083983f, 0.02738939f, 0.18304475f, 0.25623903f, 0.27466729f, -0.11645011f, -0.10550603f, 
    0.19543324f, -0.07010770f, -0.04946544f, 0.04746232f, 0.01705587f, 0.01175633f, 0.07836736f, 0.07922779f, 
    0.06395160f, 0.06183559f, -0.43014547f, 0.12610559f, -0.00111735f, 0.12888013f, 0.05540246f, -0.08764211f, 
    0.20881169f, -0.02489267f, 0.09830169f, -0.16660258f, 0.04608318f, -0.04928110f, -0.14809175f, 0.14851128f, 
    0.33454493f, 0.38885492f, 0.07116658f, -0.20197044f, 0.00270092f, 0.07042125f, 0.01705663f, 0.09379679f, 
    -0.01407143f, 0.35326013f, 0.03080538f, -0.17403966f, 0.02502371f, 0.02031316f, 0.09584188f, 0.11924969f, 
    -0.01737235f, -0.23852290f, -0.06859190f, -0.05943916f, 0.03131770f, 0.11435711f, 0.09997497f, 0.05632333f, 
    -0.02953381f, -0.08975028f, -0.09255175f, -0.12660985f, 0.03286550f, -0.00691317f, 0.05042996f, 0.06146910f, 
    0.09729122f, 0.15280536f, 0.06829244f, 0.32066607f, 0.20578849f, -0.14059339f, -0.09816979f, 0.04480986f, 
    0.14047259f, 0.08116526f, 0.02532784f, 0.05277236f, -0.07442290f, 0.17931218f, 0.03269155f, 0.03451204f, 
    0.08791387f, -0.05907784f, -0.05885499f, 0.05597537f, 0.11972503f, -0.11848919f, -0.11721585f, -0.06611932f, 
    0.20492692f, 0.02900500f, 0.38546044f, 0.02572061f, 0.08744577f, -0.14608999f, -0.00451249f, -0.04797016f, 
    0.10203037f, 0.10243395f, -0.00086245f, 0.32026502f, -0.05215191f, 0.03800713f, -0.13792337f, -0.27837932f, 
    0.02071867f, -0.04000324f, 0.03912837f, 0.03616198f, 0.01865918f, 0.03880014f, -0.19618158f, -0.25702113f, 
    0.10490038f, 0.27103963f, 0.10758608f, -0.24317706f, 0.35188165f, -0.04622517f, 0.12625898f, 0.16595572f, 
    -0.08670225f, -0.01981912f, -0.12341499f, 0.02385677f, 0.07636513f, -0.03383658f, -0.24878883f, 0.04009060f, 
    0.16507848f, 0.34904459f, 0.25163293f, -0.19568703f, 0.15821566f, 0.05819173f, 0.02428604f, 0.04439141f, 
    -0.01405963f, 0.00167893f, -0.07360478f, 0.24834757f, -0.00389820f, 0.13654099f, -0.03696428f, -0.07663570f, 
    0.05012200f, -0.03877302f, 0.07485727f, 0.17182490f, -0.01934020f, 0.04006986f, 0.22533640f, -0.19836754f, 
    -0.11600972f, 0.15301029f, -0.09140458f, 0.23102623f, 0.02654863f, 0.16615105f, 0.07833322f, 0.02230080f, 
    0.06854872f, -0.34311217f, -0.21891262f, -0.28891924f, 0.18641970f, 0.15426834f, -0.00472146f, -0.07652685f, 
    -0.06697072f, 0.21967430f, 0.13273674f, -0.11960148f, 0.05988356f, -0.10961752f, 0.13806587f, 0.08092725f, 
    0.03909286f, 0.00013851f, -0.14902215f, -0.04238465f, -0.05273978f, 0.03197832f, 0.01582371f, -0.01672374f, 
    -0.02848188f, 0.09271451f, 0.11188959f, 0.09325486f, -0.01644420f, -0.09532259f, -0.12891684f, -0.15320277f, 
    0.05506557f, 0.13154007f, 0.06656330f, 0.26159784f, -0.06123712f, 0.02945449f, 0.11709014f, 0.15218794f, 
    0.02233769f, 0.05662420f, 0.16124634f, -0.06395511f, -0.13206345f, -0.20289488f, -0.00593233f, 0.13788989f, 
    -0.04070326f, 0.00463150f, 0.03053845f, 0.02759635f, 0.00064540f, 0.04643000f, -0.03658915f, -0.03299074f, 
    0.05835572f, 0.04622556f, 0.01492354f, -0.00837581f, 0.03044346f, 0.05743315f, -0.01287093f, 0.00185213f, 
    -0.06248239f, -0.03234087f, 0.05698780f, -0.07302687f, 0.01935427f, 0.06059619f, -0.03257349f, -0.02559578f, 
    0.04077659f, -0.02400931f, -0.06738731f, -0.05504050f, -0.02423575f, 0.03901317f, -0.01932774f, -0.03166608f, 
    0.05156079f, 0.02140224f, 0.06444554f, 0.02100906f, -0.00154783f, -0.00872174f, 0.00445012f, -0.01973478f, 
    -0.00261399f, -0.02751999f, -0.05643606f, -0.02342991f, 0.01013373f, 0.00252514f, -0.02362092f, -0.05402936f, 
    0.01781981f, -0.07713986f, -0.05144706f, -0.05838333f, -0.03703256f, 0.06221275f, -0.04601536f, -0.05986238f, 
    0.01605741f, -0.05418619f, -0.02172196f, -0.05139952f, 0.05270234f, -0.02891811f, 0.04771631f, -0.01785509f, 
    0.01477418f, 0.02512816f, 0.02388936f, -0.07670805f, -0.03489154f, -0.02569460f, -0.04275551f, 0.04447617f, 
    0.01377346f, -0.02959503f, -0.00097455f, -0.02068011f, 0.05819496f, -0.00873420f, 0.05295727f, -0.07278255f, 
    -0.07718424f, 0.03679306f, 0.05800762f, 0.00000419f, 0.03213156f, 0.04327786f, -0.00315975f, 0.02273307f, 
    0.04674584f, -0.06152138f, 0.02668480f, -0.06837919f, 0.05032191f, -0.05382133f, 0.01530530f, -0.00940321f, 
    0.02653389f, -0.01474292f, -0.04123304f, 0.02082815f, -0.06327216f, -0.02319296f, -0.04097635f, -0.02948099f, 
    -0.01596398f, 0.04626626f, -0.06764217f, -0.01380074f, 0.05909125f, -0.01050700f, 0.00785401f, -0.04311225f, 
    -0.02477972f, 0.05020887f, -0.03639723f, 0.01281489f, -0.00676126f, -0.06908967f, -0.05518278f, 0.05512251f, 
    -0.06613597f, -0.02077778f, 0.02199638f, -0.07287440f, -0.07038832f, -0.06148972f, 0.05026003f, 0.06001467f, 
    0.02488574f, 0.04566846f, -0.04972226f, -0.05262399f, -0.00591842f, -0.00468419f, -0.05588199f, 0.05040086f, 
    -0.01945875f, -0.03167953f, 0.00099150f, 0.00444740f, -0.02865358f, -0.02408301f, 0.03501725f, 0.03813388f, 
    0.00441795f, -0.03604518f, 0.04849079f, -0.04800571f, -0.06541821f, -0.03677628f, 0.02694841f, -0.07588429f, 
    -0.00487319f, 0.06186212f, -0.03730014f, -0.00495526f, 0.01682198f, -0.03811740f, -0.06928503f, -0.02052902f, 
    -0.01036888f, 0.02321979f, 0.01519920f, -0.02459984f, 0.01369512f, -0.06312571f, 0.03325199f, -0.07235642f, 
    -0.01801541f, -0.02433877f, 0.02550793f, -0.06466005f, 0.03741078f, 0.04371771f, -0.05291156f, -0.03513037f, 
    0.05059946f, 0.04835474f, 0.00336219f, 0.03400175f, -0.02321362f, -0.06486458f, -0.04140018f, 0.03506970f, 
    0.01888592f, -0.06328268f, 0.02981640f, -0.07049444f, 0.01151022f, -0.06034012f, -0.00474315f, -0.03637133f, 
    -0.30588511f, -0.49658537f, -0.17953019f, -0.06821373f, 0.01677817f, -0.07351790f, 0.08866993f, -0.01609023f, 
    -0.04610330f, 0.15761004f, 0.14598447f, -0.19136928f, 0.62488383f, 0.28493071f, 0.29848918f, 0.07566302f, 
    0.01454568f, 0.14285044f, 0.22521332f, 0.27787030f, 0.03429166f, 0.05357926f, -0.02775742f, -0.22160171f, 
    0.07652751f, 0.20450425f, 0.32744604f, 0.50354749f, -0.01270834f, 0.19229554f, 0.03769327f, -0.02459280f, 
    0.21961851f, 0.07438146f, 0.14199609f, 0.24285090f, 0.00840478f, -0.09817586f, -0.18666667f, 0.07139357f, 
    0.00051602f, -0.12348468f, -0.02747892f, 0.14698650f, -0.03617240f, -0.15170814f, -0.16414149f, -0.17336561f, 
    -0.26530594f, -0.23163651f, -0.07405242f, -0.23703940f, 0.16758472f, -0.26306751f, -0.19054045f, -0.27340028f, 
    0.11785254f, -0.27430406f, -0.03282083f, -0.04116982f, -0.19817071f, -0.05365344f, -0.38605091f, 0.08858737f, 
    0.04939231f, 0.05241785f, -0.07814033f, -0.01230892f, 0.07170936f, 0.06642579f, -0.02479457f, -0.01455421f, 
    -0.31653732f, -0.27925968f, 0.28572488f, 0.11025369f, 0.07853975f, -0.10401928f, 0.04246180f, -0.12114344f, 
    -0.22170024f, 0.08270915f, -0.09571500f, 0.07061955f, -0.04416658f, 0.22256739f, -0.17657553f, -0.15209492f, 
    0.09653399f, 0.07743972f, 0.08056602f, -0.02635274f, -0.09068764f, 0.04439525f, 0.13904253f, 0.22159140f, 
    -0.02443524f, 0.23645289f, -0.14827365f, -0.23552112f, -0.06653775f, 0.05730164f, -0.01026108f, 0.06343275f, 
    0.00346826f, 0.06286383f, 0.05996836f, 0.26356149f, 0.33416846f, 0.33787429f, 0.36626130f, -0.02769626f, 
    0.17270644f, -0.06526480f, 0.15881224f, 0.12165666f, 0.05082313f, -0.00210963f, -0.06179046f, -0.07461818f, 
    -0.38726860f, 0.07914761f, -0.63380384f, 0.37928417f, -0.16388330f, -0.14647496f, 0.12471031f, -0.06626708f, 
    -0.07668752f, 0.01055682f, -0.07343938f, -0.01240389f, 0.15673466f, 0.23572089f, 0.24211386f, 0.05049084f, 
    -0.17574799f, 0.08570591f, -0.11039664f, -0.14939709f, 0.20751747f, -0.10420985f, -0.15638261f, -0.37177327f, 
    0.31054237f, -0.23102403f, 0.02818045f, -0.02478966f, 0.21455088f, 0.11756488f, -0.06572121f, -0.05816763f, 
    0.05459440f, 0.01429675f, 0.08452604f, 0.01492451f, 0.15073301f, -0.20523185f, -0.25701770f, 0.23712727f, 
    0.09443294f, -0.00523816f, -0.05716294f, -0.03179776f, 0.09168918f, 0.03937900f, -0.07823523f, 0.00863353f, 
    -0.24443865f, -0.51303715f, -0.28007513f, -0.01537580f, -0.05891815f, -0.10739002f, -0.02030285f, 0.15875122f, 
    -0.11058937f, 0.09265504f, -0.05928903f, -0.09244904f, 0.47234559f, 0.48797524f, 0.24955277f, 0.00295240f, 
    -0.03801625f, -0.12055610f, 0.21969047f, 0.41538456f, -0.03006027f, 0.31744757f, 0.01666783f, -0.03028339f, 
    0.30514795f, -0.19557247f, -0.07693045f, -0.15095367f, -0.05158064f, -0.08735060f, 0.02042247f, -0.02162296f, 
    0.13503221f, 0.00261661f, -0.01731931f, -0.12257242f, -0.11312576f, 0.02921162f, -0.43727133f, 0.11777478f, 
    0.15718640f, 0.23131102f, 0.21057092f, -0.05443291f, -0.15531312f, 0.03770836f, -0.05132937f, -0.18879583f, 
    0.18932393f, 0.12329044f, 0.11221537f, 0.04266099f, 0.03927223f, 0.01532125f, 0.00430838f, -0.05080817f, 
    0.12058236f, 0.08473726f, -0.01608100f, -0.06739946f, 0.23556024f, 0.13689719f, 0.09561624f, 0.08435743f, 
    -0.09218946f, 0.02237493f, -0.05025937f, -0.03035375f, -0.06828858f, -0.00663297f, -0.11663248f, 0.00414849f, 
    -0.03241730f, 0.01021933f, 0.03931685f, 0.12001564f, 0.04016031f, 0.02471821f, 0.05634757f, -0.18918888f, 
    -0.00467884f, 0.11429204f, 0.02624224f, 0.06370936f, 0.51295459f, 0.16190635f, 0.14084221f, 0.16948369f, 
    -0.06464846f, 0.00661631f, -0.06384647f, 0.00924579f, 0.17373112f, -0.04929935f, -0.02332862f, 0.03333873f, 
    -0.00784652f, 0.17112166f, 0.08023106f, 0.04532849f, -0.06107770f, 0.12556091f, -0.05001095f, -0.13629901f, 
    -0.08877592f, -0.06407288f, -0.08497692f, 0.05367343f, 0.29047585f, -0.02179369f, 0.03835952f, -0.01125352f, 
    -0.11634792f, 0.00435749f, -0.03091138f, -0.15763991f, 0.02324193f, -0.09411937f, -0.06193908f, -0.03159503f, 
    -0.25109994f, -0.40338698f, -0.14538318f, -0.39376217f, 0.33492920f, -0.06192029f, -0.35785985f, 0.22197916f, 
    0.05989921f, -0.04526382f, -0.06457381f, -0.07108217f, -0.26814219f, -0.40330613f, -0.27740431f, -0.08244845f, 
    0.06651595f, 0.28569308f, -0.02040611f, -0.02141507f, 0.02105055f, -0.01710391f, -0.10112283f, 0.01802042f, 
    0.22217070f, 0.13930969f, -0.01073230f, 0.09045509f, -0.04115656f, -0.00532627f, 0.01254020f, -0.01273971f, 
    0.05705179f, -0.06185432f, -0.00842295f, -0.01049608f, -0.22610582f, -0.08498347f, -0.09501160f, 0.08178853f, 
    0.02647939f, 0.20210738f, -0.03195948f, -0.06787281f, -0.05938020f, -0.05592956f, 0.07668955f, -0.07687190f, 
    0.28877309f, -0.29238173f, -0.53102559f, -0.72326630f, -0.08977684f, -0.12045925f, -0.04873290f, -0.17602941f, 
    0.09538727f, -0.19417836f, -0.12027235f, -0.00759682f, 0.17876595f, 0.09253167f, 0.12255894f, 0.03123876f, 
    -0.05780656f, -0.20406681f, -0.03971542f, 0.01588435f, 0.06970023f, -0.02350133f, -0.04965785f, -0.04385570f, 
    0.28892592f, 0.16308132f, 0.16689943f, -0.03440796f, 0.00775180f, -0.04776246f, -0.06940356f, -0.04626596f, 
    0.08340167f, -0.03725848f, -0.07158235f, 0.02559736f, -0.01643164f, -0.05581814f, 0.18630584f, -0.02736102f, 
    0.00274966f, -0.06414658f, 0.04609574f, 0.18952392f, -0.01100309f, 0.08494061f, 0.05303438f, 0.01109942f, 
    0.12970433f, -0.25949782f, -0.11133790f, -0.14967813f, 0.03475979f, 0.02340381f, -0.07778138f, -0.01000278f, 
    0.03414664f, -0.03427650f, 0.06473984f, -0.13903819f, 0.38170305f, 0.39467260f, 0.44780755f, -0.03611587f, 
    0.17981485f, 0.07200351f, 0.33370697f, 0.35240954f, 0.03367755f, -0.02742596f, 0.00719198f, 0.06330903f, 
    -0.02867996f, 0.02570700f, 0.09531181f, 0.02296917f, 0.12159968f, 0.01207651f, -0.01382195f, -0.03864713f, 
    -0.01744293f, -0.09435187f, -0.04509991f, -0.14979525f, -0.35033026f, -0.07270762f, -0.10537903f, 0.07065236f, 
    -0.05097923f, -0.07385900f, -0.01110327f, -0.12776375f, -0.00975783f, 0.04054308f, 0.03255639f, 0.06193659f, 
    -0.22997843f, -0.07597955f, -0.14022440f, -0.07712040f, 0.24614733f, -0.16102354f, -0.08340125f, 0.09308957f, 
    0.11523163f, 0.01546812f, 0.06627629f, 0.12591787f, -0.29233402f, -0.22179255f, -0.30124250f, -0.18046726f, 
    -0.14446624f, -0.03555073f, -0.04162948f, 0.02721886f, -0.03829807f, 0.01721685f, -0.25286549f, 0.00083345f, 
    0.18798165f, 0.01790098f, 0.17573245f, 0.10646094f, -0.16126578f, -0.09395863f, -0.05332441f, -0.02701723f, 
    0.18488409f, 0.17811826f, 0.00915543f, 0.26122421f, -0.02524544f, -0.02131867f, -0.06499615f, -0.07573629f, 
    -0.00835570f, -0.08591980f, -0.09789606f, -0.08783358f, 0.02676863f, -0.03286868f, -0.07783125f, -0.10479712f, 
    0.04572627f, 0.37180355f, 0.07605281f, -0.12861258f, 0.13141467f, 0.16884764f, 0.04819870f, 0.01798827f, 
    0.12170751f, -0.07570820f, -0.02225273f, 0.08159976f, 0.21732247f, 0.25323263f, 0.19863996f, 0.06742466f, 
    0.07750615f, 0.00945930f, 0.18935077f, 0.22121359f, 0.09106635f, 0.01309741f, 0.08658674f, 0.06942160f, 
    -0.32449871f, 0.04117795f, -0.02381225f, 0.00177549f, -0.02399634f, -0.07802603f, -0.11654428f, -0.00209297f, 
    -0.06958496f, 0.00038625f, -0.05138353f, 0.05235412f, 0.03008180f, 0.04462802f, -0.05762074f, -0.14046149f, 
    0.03460480f, 0.09708775f, 0.00851952f, 0.12373860f, 0.04641097f, 0.10194135f, 0.02346556f, 0.04692530f, 
    0.00971803f, -0.15220088f, -0.16187656f, 0.12065116f, 0.10114861f, -0.06262483f, 0.07063752f, -0.02207844f, 
    0.02307551f, -0.07931681f, -0.09308945f, 0.10881473f, -0.25415778f, -0.10344478f, -0.35068256f, -0.01099568f, 
    0.05454602f, -0.10428227f, -0.06808393f, -0.21828945f, -0.00025108f, -0.00494221f, -0.04717227f, 0.01911236f, 
    -0.11516512f, -0.18099335f, -0.22576721f, -0.06677408f, -0.00186885f, -0.12387547f, -0.03944086f, -0.13752940f, 
    -0.14860921f, -0.13708197f, 0.05860505f, 0.16525292f, 0.54331839f, 0.40026835f, 0.03830189f, -0.12020270f, 
    -0.17782453f, 0.03922861f, 0.06721207f, 0.27957612f, -0.05669856f, -0.10759355f, -0.02769072f, 0.13272072f, 
    -0.04843239f, -0.03072370f, 0.12573734f, 0.01945370f, 0.02163988f, 0.05177952f, -0.03355854f, -0.06265190f, 
    -0.00942934f, -0.00650023f, 0.13842385f, -0.11491917f, 0.07828567f, 0.05549308f, 0.19145957f, 0.19106841f, 
    -0.01131754f, -0.01277144f, 0.19023213f, 0.34227103f, 0.00707549f, -0.06683408f, -0.03449132f, -0.06945795f, 
    0.00213432f, 0.22469658f, -0.06497622f, 0.08182625f, -0.10110886f, -0.05322466f, 0.03050224f, -0.02443996f, 
    0.01409518f, -0.09132087f, -0.00193607f, 0.01353246f, 0.16780923f, 0.12667508f, 0.13841559f, 0.07278239f, 
    -0.06591752f, -0.04946799f, -0.09353150f, -0.05969639f, -0.09738669f, 0.02120879f, -0.05201945f, -0.08972589f, 
    0.19348344f, 0.01908749f, 0.02627652f, -0.16493095f, 0.07667196f, 0.31835583f, -0.01372521f, -0.03359580f, 
    0.00739782f, 0.02673888f, -0.08521330f, 0.03445280f, -0.04282773f, 0.11549625f, -0.03385930f, 0.06769796f, 
    -0.06184081f, -0.06022114f, -0.04787413f, -0.02200349f, -0.18351667f, 0.09126445f, -0.11995780f, 0.19509301f, 
    -0.06371528f, 0.26343003f, -0.12641503f, 0.07716985f, -0.04998810f, 0.13270445f, -0.03299872f, -0.13840318f, 
    0.09934357f, 0.07566395f, 0.00160828f, 0.00686789f, -0.08530501f, 0.05748826f, -0.18880245f, 0.03172299f, 
    -0.01869107f, 0.03007441f, -0.04732823f, -0.14875050f, -0.02489948f, -0.12662326f, 0.02496522f, -0.09228235f, 
    0.30670172f, -0.00494756f, -0.09652545f, 0.34389499f, -0.00538267f, 0.08151454f, -0.13552946f, -0.02666554f, 
    0.08012991f, 0.01788271f, -0.00744718f, -0.01117653f, -0.02339692f, -0.32478136f, -0.12899874f, 0.22077797f, 
    0.12899175f, 0.03280278f, -0.05669976f, -0.00847778f, 0.11651056f, 0.13455015f, 0.08394970f, 0.02783009f, 
    -0.17158838f, -0.00012953f, 0.63162529f, 0.14465331f, -0.07543062f, 0.07267053f, -0.17346574f, 0.07118569f, 
    0.01296602f, 0.00525775f, 0.08488131f, -0.06759991f, 0.06475653f, 0.12551923f, -0.06732116f, -0.06937937f, 
    0.12774251f, 0.01220961f, 0.06247212f, 0.05688352f, -0.13830909f, 0.03785783f, -0.02279957f, 0.05186592f, 
    0.20414652f, -0.22753333f, -0.24051851f, -0.31785882f, 0.06858450f, 0.08941373f, 0.05563230f, 0.00430401f, 
    -0.01454844f, 0.01665290f, -0.05746497f, -0.05602500f, 0.11468021f, 0.36731845f, 0.42099571f, 0.19159259f, 
    0.00688435f, -0.09340773f, -0.13791943f, -0.01948537f, -0.02089781f, 0.01807321f, 0.08535937f, -0.00110493f, 
    0.17784242f, 0.17249756f, 0.10720551f, -0.07686327f, 0.01769500f, 0.04427227f, -0.08810680f, 0.06924689f, 
    -0.01700522f, 0.05148124f, 0.03136136f, 0.00933863f, 0.06306212f, 0.16754584f, -0.21779795f, 0.20882457f, 
    -0.24741922f, -0.03541500f, 0.01167952f, 0.12416244f, 0.02199902f, 0.01806109f, -0.09846526f, 0.15016574f, 
    -0.49972805f, 0.32472110f, -0.09765316f, 0.19856285f, 0.05311515f, 0.06963062f, -0.01815531f, -0.03419705f, 
    0.10550851f, 0.06680635f, 0.11566342f, 0.12577684f, 0.08287244f, -0.22141117f, -0.08790545f, 0.31019881f, 
    0.02823612f, 0.12508225f, -0.14378251f, 0.05933387f, 0.06812430f, -0.01156626f, -0.08154681f, 0.04393597f, 
    -0.14032996f, 0.15978365f, 0.13196355f, 0.31124553f, 0.00353014f, 0.04808290f, -0.00598485f, -0.20116915f, 
    0.07229666f, 0.12786718f, -0.01358620f, 0.14788938f, -0.06082425f, 0.07097375f, 0.05733290f, 0.13143657f, 
    0.07958647f, 0.03817135f, -0.17860734f, 0.05188613f, 0.06426515f, -0.07806461f, 0.08229712f, -0.10576265f, 
    0.13605265f, 0.04063780f, -0.00503348f, -0.07128709f, 0.12010434f, 0.08471151f, -0.01846027f, 0.10920057f, 
    0.15064013f, -0.14927992f, 0.10782278f, 0.10807756f, -0.27977967f, -0.01759095f, -0.11438025f, 0.04130310f, 
    0.19083537f, -0.03433552f, -0.10225373f, -0.00626013f, 0.04921121f, -0.00223447f, 0.05178234f, 0.14120476f, 
    0.06712589f, 0.03942802f, 0.10364261f, 0.04338629f, -0.03273924f, -0.29404536f, -0.01405817f, 0.18325788f, 
    0.10070278f, 0.09786405f, 0.22908154f, 0.06359854f, -0.07124050f, 0.53506184f, -0.06391658f, -0.43905380f, 
    -0.04048849f, 0.03187734f, -0.08925191f, 0.01420047f, -0.26481339f, -0.03292925f, -0.05673547f, 0.07451896f, 
    -0.41207963f, -0.15035538f, -0.09545506f, 0.07890033f, 0.06837502f, -0.20378847f, -0.01932285f, -0.26381588f, 
    -0.14176436f, 0.00130613f, -0.10869817f, 0.09695473f, 0.13206799f, 0.03909862f, -0.03488560f, -0.08317439f, 
    -0.02475162f, 0.06292270f, 0.10585979f, 0.00459442f, 0.05543187f, -0.02448878f, 0.13039520f, -0.16660923f, 
    -0.15463822f, 0.09128868f, -0.44476324f, 0.26763564f, 0.02021003f, -0.13555598f, -0.03856446f, 0.09540733f, 
    -0.03800347f, -0.00257880f, 0.00272754f, -0.07761678f, 0.25310534f, -0.03033518f, 0.04238296f, 0.01202450f, 
    0.14392751f, -0.19171096f, 0.12651052f, -0.35077333f, 0.22339705f, 0.06604797f, -0.09810800f, 0.06994010f, 
    -0.11365067f, 0.02093807f, 0.13214771f, 0.28821576f, 0.09190194f, 0.09710906f, -0.01858697f, 0.19962433f, 
    0.06455848f, 0.12832730f, 0.06797878f, -0.04770192f, 0.21084182f, -0.12165809f, -0.05254596f, -0.02100079f, 
    -0.12900537f, 0.17765149f, 0.05766996f, -0.00624070f, 0.00327875f, 0.04620795f, -0.08253701f, -0.13701777f, 
    -0.29489717f, 0.00473799f, -0.02046713f, 0.12958470f, -0.09765240f, -0.14280847f, -0.00084297f, -0.03798799f, 
    -0.00989796f, -0.01448613f, 0.02416632f, 0.04851013f, -0.00655075f, 0.03752637f, 0.24340378f, 0.27151966f, 
    0.16711918f, 0.15092428f, 0.09399406f, -0.11637908f, 0.02743743f, -0.02980531f, 0.09213877f, -0.04328811f, 
    0.18254563f, -0.43668035f, -0.11078929f, -0.03152321f, 0.03485160f, -0.04179714f, 0.23087713f, 0.14459810f, 
    -0.14151898f, 0.13909400f, -0.05802223f, 0.24324748f, 0.30276346f, 0.20502625f, 0.39511877f, -0.37916318f, 
    -0.18279544f, -0.15128429f, 0.27848998f, -0.02536778f, 0.07443254f, -0.05845831f, 0.05631495f, -0.10441407f, 
    -0.10773513f, -0.05237954f, -0.00195764f, -0.06282961f, 0.01749499f, -0.08590077f, -0.07258172f, 0.02118255f, 
    0.08610324f, 0.01437935f, 0.17391148f, 0.10788541f, 0.20851637f, -0.03970211f, 0.02632547f, -0.00574673f, 
    0.05058959f, 0.02049105f, 0.02831600f, 0.19990036f, -0.07031029f, -0.03719556f, -0.20117705f, -0.05294364f, 
    0.01187707f, 0.12510473f, 0.09593423f, -0.08828846f, 0.04256906f, -0.09838470f, -0.13489936f, -0.10936271f, 
    -0.05866430f, 0.02397209f, -0.10499220f, -0.07009105f, 0.02322013f, -0.03439565f, -0.45317101f, 0.04180315f, 
    0.01154117f, 0.24559310f, 0.08161087f, -0.01633419f, -0.08552818f, 0.04277990f, -0.02631023f, -0.17109320f, 
    0.12958258f, -0.03747014f, -0.12508307f, 0.07792681f, 0.07830788f, 0.23883186f, 0.02998572f, 0.07145537f, 
    0.04497922f, -0.11381612f, -0.12528497f, -0.03840347f, -0.11171341f, -0.25236222f, 0.06628186f, 0.43142289f, 
    0.16041167f, -0.09720082f, 0.18595743f, -0.00415190f, 0.13075516f, 0.11182786f, 0.20160797f, 0.19746166f, 
    0.12026048f, 0.44564229f, 0.16096549f, -0.04733760f, 0.00698728f, 0.22380833f, 0.14995003f, 0.07814869f, 
    0.11482453f, -0.01519968f, 0.05919929f, -0.01669234f, 0.17052887f, 0.01666059f, -0.02427598f, -0.21690060f, 
    0.15985034f, -0.07982176f, -0.27417883f, 0.08686835f, -0.01164833f, -0.10129830f, -0.07273185f, 0.01859601f, 
    -0.03217822f, -0.12449365f, 0.07136555f, -0.07231647f, -0.02030663f, 0.09662955f, -0.02309147f, -0.06313336f, 
    -0.04414278f, -0.08566077f, 0.09933042f, -0.08313156f, -0.14668323f, 0.16882047f, 0.01471535f, -0.07663526f, 
    -0.09162159f, -0.04149680f, 0.01615889f, 0.14729325f, 0.07364517f, -0.19622293f, -0.14420371f, -0.29715884f, 
    -0.14345638f, -0.31892648f, 0.02117470f, 0.11428536f, 0.14597291f, -0.00204812f, -0.07110664f, 0.03612080f, 
    0.01297358f, -0.11740474f, 0.00391508f, 0.05349780f, 0.28961867f, 0.10284578f, 0.30354574f, -0.07555878f, 
    0.22126749f, -0.04606976f, 0.05188395f, 0.04360836f, 0.01246229f, -0.07181027f, -0.05621497f, 0.08785092f, 
    0.20273475f, -0.19875637f, -0.09550337f, -0.08298641f, 0.05919120f, 0.04490328f, 0.09161044f, 0.18128909f, 
    -0.21546234f, -0.00560519f, -0.16195539f, 0.06184927f, 0.16343020f, 0.10047765f, -0.25555086f, -0.10112794f, 
    -0.14472149f, -0.06123606f, -0.10933889f, 0.07552241f, -0.10145107f, 0.10583383f, 0.01922435f, 0.05106088f, 
    -0.24041024f, -0.07285482f, -0.32063249f, -0.05963074f, -0.03776258f, 0.12086384f, 0.03497729f, -0.02106178f, 
    0.04688879f, 0.10353012f, -0.19650203f, -0.00592330f, 0.28992039f, 0.16528010f, -0.05238251f, -0.02576559f, 
    0.03539238f, 0.34708843f, 0.09598436f, -0.18677363f, 0.12215787f, 0.03952995f, 0.02295271f, -0.04239160f, 
    0.02093419f, 0.25319621f, 0.04881489f, 0.06001550f, 0.09389257f, 0.01133955f, -0.13146228f, 0.01283576f, 
    0.16720867f, -0.22718482f, -0.04576889f, 0.13706416f, 0.16258475f, -0.13070880f, -0.04923669f, -0.09189431f, 
    0.00872835f, 0.01873084f, -0.15392862f, -0.00833576f, -0.09232372f, -0.04397982f, -0.08134455f, 0.07421860f, 
    -0.08104256f, 0.01398390f, 0.21769513f, 0.26122084f, 0.10390075f, -0.10285114f, 0.00741370f, -0.17340423f, 
    0.14263555f, 0.09328525f, -0.17396934f, 0.06404435f, -0.01187538f, 0.04118599f, -0.21477292f, 0.17562748f, 
    0.02135466f, 0.00338417f, -0.13273810f, -0.04066992f, -0.00357580f, -0.17828742f, -0.09767758f, -0.18360223f, 
    -0.18275109f, -0.07906293f, 0.01226924f, 0.21861789f, 0.07447395f, -0.02096839f, -0.10321079f, -0.00220139f, 
    0.06807049f, -0.19577327f, 0.04754392f, 0.17557915f, -0.22949675f, 0.02859823f, -0.05000640f, 0.12021331f, 
    -0.04715252f, -0.01284881f, -0.01259642f, -0.05169408f, 0.04664325f, 0.09167089f, -0.11745565f, 0.02195616f, 
    0.03698677f, 0.46229818f, 0.17283972f, -0.06091336f, 0.12480924f, 0.23953108f, 0.08730043f, 0.07247028f, 
    0.04231305f, -0.00405759f, 0.02684702f, 0.11141321f, 0.31991896f, 0.02954754f, -0.00135454f, -0.13426708f, 
    0.17941782f, 0.35490492f, 0.16114013f, 0.04861299f, 0.09566715f, -0.09618297f, 0.03220606f, 0.00787059f, 
    0.02855653f, 0.01136129f, 0.01932068f, 0.07287163f, 0.04405854f, -0.02120020f, -0.00761280f, -0.05828836f, 
    -0.14846571f, -0.00625437f, -0.00102926f, -0.04890740f, -0.08843671f, 0.04580023f, 0.21951720f, -0.27781850f, 
    0.04265754f, -0.01711078f, 0.29662347f, -0.10300051f, -0.01441385f, -0.03018781f, -0.17043680f, -0.10586472f, 
    -0.25223950f, -0.07953037f, 0.17262189f, 0.14792934f, 0.08349765f, 0.11189701f, -0.01422727f, -0.12844019f, 
    0.01086151f, -0.02476199f, 0.13614333f, -0.06021180f, 0.28572875f, 0.00268458f, 0.39215785f, 0.32779899f, 
    0.00087518f, -0.04537547f, -0.17636245f, 0.11708738f, -0.06276269f, -0.09174117f, 0.04219417f, -0.06223197f, 
    0.05361095f, -0.06400308f, -0.01440828f, 0.35231724f, -0.05834336f, -0.08512491f, -0.09657970f, 0.00199425f, 
    -0.06635466f, -0.06273767f, -0.00863848f, 0.12979746f, 0.14091632f, 0.23443885f, 0.00801537f, -0.27814612f, 
    -0.02881915f, 0.03197879f, 0.04236296f, 0.01482004f, -0.00100904f, -0.07076582f, 0.13128987f, -0.03424717f, 
    0.45322141f, 0.15676136f, -0.02182843f, -0.01596881f, 0.01581913f, 0.10454164f, 0.04727545f, 0.01462402f, 
    0.03861089f, 0.05728350f, 0.11892319f, 0.20389575f, 0.05823398f, 0.03644861f, 0.32167843f, 0.03237036f, 
    0.01481946f, -0.17301038f, 0.10930388f, -0.00421996f, 0.13211036f, 0.00891310f, 0.05474512f, 0.01310564f, 
    -0.14974992f, -0.01814234f, 0.27300519f, 0.07892213f, 0.15736236f, 0.11777204f, 0.11637896f, 0.09678174f, 
    0.17678110f, 0.05298605f, 0.18896762f, -0.18748631f, 0.05601716f, 0.00976415f, -0.08944618f, -0.07736200f, 
    0.03957121f, -0.00977392f, -0.04473719f, -0.01634606f, -0.06637759f, -0.02079918f, -0.09122373f, 0.03631681f, 
    0.08511335f, -0.09338841f, 0.08106477f, -0.08655293f, 0.05274367f, 0.01764415f, 0.02238038f, 0.09005722f, 
    -0.01420866f, -0.04282939f, 0.09298846f, -0.10138831f, 0.19886680f, 0.09572754f, -0.10265447f, 0.00921712f, 
    -0.02154030f, 0.07693540f, -0.03625602f, 0.01832326f, -0.01506259f, -0.05501636f, 0.01107056f, -0.10892545f, 
    0.03672918f, -0.01846085f, -0.04163766f, 0.47291347f, 0.03535760f, -0.07828443f, 0.01019896f, 0.02438290f, 
    -0.05786641f, 0.24477550f, 0.13763760f, 0.15818135f, 0.00773907f, 0.14959808f, 0.10420278f, 0.12500860f, 
    0.03266148f, -0.11313137f, -0.12356599f, 0.02942404f, -0.03275115f, 0.08348969f, 0.03255108f, 0.05216414f, 
    -0.43118551f, 0.05001278f, 0.14048243f, -0.05686081f, 0.05122868f, -0.11374843f, 0.10275549f, -0.25646290f, 
    0.10783958f, 0.13568531f, -0.01149922f, 0.03247147f, -0.19394898f, -0.19030946f, 0.19377930f, -0.04553624f, 
    -0.04480474f, -0.08862066f, -0.07302833f, 0.23783483f, 0.22742966f, 0.23569445f, 0.05012514f, 0.10150549f, 
    0.19539182f, 0.00509190f, -0.06200982f, -0.07787002f, -0.01929102f, 0.06361538f, 0.20723163f, -0.00871627f, 
    0.03100526f, -0.00987066f, -0.15502180f, -0.04963192f, -0.38372007f, -0.08101322f, -0.15197819f, -0.09282658f, 
    0.20901334f, -0.19213659f, 0.13738306f, 0.17388847f, 0.02912717f, 0.01017401f, -0.06725440f, -0.10133307f, 
    -0.61649841f, -0.26645169f, -0.00510484f, 0.17777738f, 0.05981031f, -0.13027918f, -0.14472964f, 0.02336906f, 
    0.00068522f, 0.11142482f, 0.27037743f, 0.02327831f, 0.56616586f, -0.06914800f, 0.09083468f, -0.17261545f, 
    -0.04424059f, -0.02951403f, 0.09418341f, -0.04974848f, -0.11415704f, 0.00531519f, -0.01475766f, -0.00747905f, 
    0.17344508f, -0.04521795f, 0.07173948f, 0.11735488f, 0.00797480f, -0.11707904f, 0.05581352f, -0.05284819f, 
    -0.01936798f, 0.00888304f, -0.06674196f, 0.10220741f, 0.07289783f, -0.00191799f, -0.01592713f, 0.01910979f, 
    -0.19195957f, 0.14737989f, 0.04186233f, -0.00899073f, 0.05294729f, 0.09395808f, -0.07741690f, 0.11032528f, 
    -0.53860193f, 0.27055624f, -0.07088894f, 0.48910663f, -0.13372467f, 0.07063791f, 0.12713329f, -0.08951686f, 
    0.10262860f, 0.27616924f, 0.15427195f, 0.15024973f, -0.16499530f, -0.36045048f, 0.12824939f, 0.32268667f, 
    -0.13351177f, 0.00432426f, -0.18479265f, -0.02866883f, 0.03168093f, -0.11077581f, -0.03198571f, -0.07786119f, 
    -0.28002569f, 0.11127339f, -0.02601242f, 0.15388584f, -0.08260629f, 0.12790288f, 0.15456386f, -0.04591770f, 
    0.14016475f, 0.18043381f, 0.23405379f, 0.19599561f, -0.00426631f, 0.02440637f, 0.25934619f, -0.09451932f, 
    0.06822914f, -0.21039721f, -0.15522148f, 0.16271026f, -0.22048995f, -0.12113396f, -0.13182662f, -0.31629121f, 
    0.48031193f, 0.17217883f, -0.14304422f, 0.10494537f, -0.00177718f, 0.35768902f, -0.07294607f, 0.00667533f, 
    0.11847243f, -0.20709603f, 0.06430207f, -0.06441268f, -0.18257454f, 0.15365450f, 0.00544086f, 0.01260830f, 
    0.04406276f, -0.00847796f, -0.14199707f, 0.03820153f, -0.16890801f, 0.04119447f, 0.15296979f, -0.11345598f, 
    0.08957279f, -0.00025765f, -0.29855311f, -0.08383547f, 0.04000791f, -0.26169869f, 0.12701668f, 0.18292567f, 
    0.15587060f, 0.18650708f, 0.11313849f, -0.03268135f, -0.18014167f, 0.25085488f, -0.39487877f, -0.42134354f, 
    0.10022335f, 0.05061802f, 0.14053193f, 0.07297599f, 0.01812563f, 0.17769691f, 0.12325732f, 0.29984376f, 
    -0.26946488f, -0.26093578f, 0.04612035f, 0.26567963f, 0.02478730f, -0.11926445f, 0.05778251f, -0.11745586f, 
    -0.06648933f, 0.06092971f, -0.06899431f, 0.05527908f, 0.10908207f, -0.17286640f, -0.06453291f, 0.07430429f, 
    0.09792028f, -0.12399614f, -0.09833436f, 0.03267101f, 0.12908646f, 0.10041436f, 0.17648520f, -0.11243299f, 
    -0.13829173f, 0.10361642f, 0.14318268f, 0.14842539f, -0.05864336f, 0.10673413f, -0.12029962f, -0.08385058f, 
    -0.19319849f, -0.06774072f, 0.13788921f, -0.11532237f, 0.28974268f, 0.08788812f, 0.02579696f, 0.17323549f, 
    0.17407127f, -0.01693034f, 0.07313501f, -0.30353770f, 0.02340092f, -0.10658577f, -0.07926536f, -0.08022494f, 
    0.16555385f, -0.32775158f, 0.06725534f, 0.12422379f, 0.11307529f, 0.05248540f, -0.00538677f, 0.35724595f, 
    0.06158479f, 0.11458594f, 0.06179133f, -0.01920023f, 0.25240546f, -0.07096335f, 0.23261370f, -0.29134488f, 
    -0.08000987f, -0.04537898f, 0.00301451f, 0.10553370f, 0.05919107f, 0.01632991f, -0.09471229f, -0.07542510f, 
    0.03842534f, 0.06741282f, 0.16331525f, -0.15988281f, -0.09161908f, -0.10719218f, -0.16838616f, 0.11174967f, 
    -0.19480917f, 0.15892424f, -0.16959657f, -0.05191305f, -0.34102044f, -0.01031801f, 0.18363442f, 0.41017118f, 
    -0.02189053f, 0.12571974f, 0.14942960f, -0.03858327f, 0.09968000f, 0.00389937f, 0.03341819f, 0.06727592f, 
    -0.54950333f, 0.19367655f, 0.10553475f, -0.02662640f, 0.11163135f, -0.14764346f, 0.10103323f, -0.09757247f, 
    -0.01297864f, 0.32866508f, 0.06262750f, 0.21573076f, 0.08174998f, 0.01024704f, 0.23658027f, -0.02523638f, 
    -0.09996280f, 0.05006180f, 0.11880500f, 0.28134656f, 0.01699571f, -0.03961030f, 0.09164914f, -0.35017520f, 
    0.22765042f, 0.02378515f, 0.09443670f, 0.32396886f, 0.09017242f, -0.03373623f, 0.12486064f, -0.02717935f, 
    0.14452356f, 0.32663709f, 0.01131736f, 0.35972679f, 0.05687866f, 0.08370981f, 0.34144634f, 0.25833780f, 
    0.03991520f, -0.16848208f, -0.07938588f, 0.37527761f, -0.28986919f, -0.18734711f, -0.11744910f, -0.66619003f, 
    -0.03588888f, -0.12233362f, -0.30665728f, -0.26107398f, 0.11486828f, -0.08637523f, -0.12861933f, -0.15557285f, 
    -0.07493362f, -0.17557776f, -0.33075780f, -0.30967018f, 0.07768392f, -0.27724862f, -0.21962945f, -0.13083240f, 
    0.08074439f, -0.06242411f, -0.17136210f, -0.11511860f, -0.05828432f, 0.02743147f, 0.20999983f, 0.27981064f, 
    -0.15160418f, 0.08522211f, -0.19619936f, 0.04675834f, -0.22641152f, -0.08001653f, -0.04851002f, 0.15002039f, 
    -0.23038480f, 0.18038587f, -0.16180734f, -0.27756763f, 0.01613484f, -0.09149957f, 0.11611578f, 0.22050145f, 
    0.01989174f, 0.09471223f, 0.16145086f, 0.00883991f, -0.09397300f, 0.03952380f, 0.16700709f, 0.36503753f, 
    -0.05081538f, -0.18267493f, 0.00362816f, 0.30662525f, -0.16216072f, -0.02917894f, -0.04166912f, -0.00899871f, 
    -0.00620760f, 0.21647695f, 0.13004646f, 0.10973480f, 0.27503687f, 0.11048941f, 0.12406112f, 0.18406281f, 
    -0.00199141f, -0.20208517f, 0.01627638f, 0.09024913f, 0.11695975f, 0.00472789f, 0.12137515f, -0.22404200f, 
    -0.20225422f, 0.00448904f, 0.11715794f, 0.10868833f, 0.17996261f, 0.07508535f, -0.23190336f, -0.02467525f, 
    -0.03699690f, -0.16482794f, 0.05094106f, -0.17884247f, 0.17312120f, 0.17849961f, 0.01895883f, 0.26529104f, 
    0.05497091f, 0.10870090f, -0.14943540f, -0.29319733f, -0.18362634f, -0.21509300f, -0.14316523f, -0.53679353f, 
    0.28117231f, 0.06031377f, 0.28433129f, 0.38400504f, -0.02411529f, 0.12133522f, 0.12836970f, 0.12046345f, 
    -0.02326607f, -0.12180392f, -0.25052905f, 0.06065100f, -0.16308653f, 0.16207482f, 0.16865970f, 0.27392685f, 
    -0.03415627f, 0.04810040f, -0.16282456f, -0.00841863f, 0.10596963f, -0.11570909f, -0.18162382f, -0.05220804f, 
    -0.15050940f, -0.15305461f, -0.13909349f, -0.41207328f, 0.03001972f, -0.02249953f, -0.21455720f, 0.37221324f, 
    -0.29636550f, -0.02956906f, -0.13900991f, -0.27959263f, 0.04190589f, 0.15810201f, 0.08313532f, 0.12604535f, 
    0.08896437f, -0.05241010f, 0.00635579f, 0.22567731f, 0.21038450f, 0.25461900f, 0.13593580f, 0.00708879f, 
    -0.16056848f, 0.33033979f, -0.13613071f, 0.11165576f, -0.20749055f, -0.11336783f, 0.19543152f, -0.09440883f, 
    0.07930695f, 0.12312623f, 0.23404285f, 0.25496814f, -0.20400245f, -0.16338529f, -0.25696516f, 0.09650350f, 
    0.17852792f, 0.08849403f, 0.00402404f, -0.09196817f, -0.24010606f, -0.12231611f, 0.01196514f, -0.25561795f, 
    -0.11293151f, 0.13388433f, 0.13260634f, 0.29105014f, 0.01788515f, 0.26397711f, 0.16075969f, 0.18322057f, 
    0.16056786f, 0.14863798f, 0.16187935f, 0.29468933f, -0.28194568f, -0.05558897f, 0.14390266f, -0.00780844f, 
    0.09647368f, -0.23650262f, 0.10620484f, 0.13887225f, -0.22946206f, -0.22288887f, -0.00191783f, -0.42459083f, 
    -0.17217989f, 0.00573561f, -0.44686839f, 0.28041202f, 0.23363598f, -0.10350084f, -0.09699004f, -0.35721889f, 
    -0.02912065f, -0.05120227f, -0.08892962f, -0.06616654f, 0.15543339f, 0.09022406f, 0.14850385f, -0.10965031f, 
    0.13329610f, -0.03508651f, -0.14057511f, -0.06778122f, 0.00340750f, -0.07534801f, 0.13575131f, 0.00119415f, 
    -0.07086594f, 0.06013246f, 0.37413490f, -0.14583458f, 0.05881701f, -0.01456797f, 0.14251158f, -0.00048396f, 
    -0.08671380f, 0.17486551f, -0.19566199f, 0.06933548f, 0.39159659f, 0.47146028f, -0.16398710f, -0.24867363f, 
    0.03287303f, -0.04705873f, 0.14153983f, 0.00388664f, 0.03575352f, 0.23010394f, 0.15874432f, 0.12723736f, 
    -0.15139034f, -0.06920706f, 0.02521939f, -0.00449837f, 0.16045658f, 0.07267883f, -0.07289995f, 0.26843962f, 
    0.01847307f, 0.05959921f, -0.05566318f, 0.32800853f, -0.03779722f, 0.24694197f, -0.08669117f, 0.06395385f, 
    0.15231231f, 0.04734592f, 0.12216191f, -0.00961599f, -0.13399634f, -0.02352874f, -0.13317260f, -0.15674874f, 
    -0.06762741f, 0.13173331f, -0.10685320f, -0.02065003f, 0.09074872f, 0.11303739f, -0.15073752f, -0.01848444f, 
    -0.03286462f, -0.16844161f, 0.08662748f, -0.06206388f, 0.14507940f, -0.18902732f, -0.01772423f, 0.00488377f, 
    -0.05767887f, 0.07127082f, -0.27222979f, -0.06228991f, 0.09399056f, -0.32627967f, -0.24316464f, -0.29397300f, 
    0.26548201f, 0.20965746f, 0.14201398f, 0.23867130f, 0.08394183f, 0.06371843f, 0.05402215f, 0.12481886f, 
    -0.10446560f, -0.01679427f, -0.19391912f, -0.08193185f, -0.27004492f, -0.13684280f, -0.22080366f, 0.07633779f, 
    -0.01923637f, 0.00535185f, -0.02905727f, -0.23657767f, 0.14925167f, -0.06487278f, -0.24095964f, -0.09681249f, 
    -0.14146566f, -0.05079568f, -0.12851696f, -0.26279357f, -0.13647144f, -0.15192851f, 0.05945303f, 0.05243542f, 
    -0.13545673f, -0.00486850f, -0.16449998f, -0.06301975f, -0.08758102f, 0.05796375f, 0.16237728f, 0.33506647f, 
    0.20273110f, -0.06226773f, 0.17454171f, 0.14017589f, 0.12192784f, 0.04303789f, 0.13170595f, 0.22992584f, 
    0.09175339f, -0.23489982f, -0.10967434f, 0.21611352f, -0.06193966f, 0.07657716f, 0.00574207f, 0.09362022f, 
    0.06451651f, 0.08025408f, 0.07853024f, 0.11185332f, 0.28128442f, 0.04088256f, 0.33939520f, -0.28670889f, 
    -0.12168401f, -0.02372312f, 0.20190747f, 0.08602712f, -0.05464223f, -0.01432223f, 0.00051745f, 0.00616417f, 
    -0.08520048f, 0.19318627f, -0.05121810f, 0.12959073f, 0.02325687f, 0.00199100f, 0.09940974f, 0.08936795f, 
    0.00708313f, -0.03339435f, 0.09136949f, 0.11794225f, 0.17207381f, 0.09812471f, 0.18882641f, 0.06065877f, 
    -0.11060778f, -0.06347819f, -0.06843729f, -0.00269366f, -0.04978146f, -0.02285766f, -0.03321776f, -0.00502599f, 
    0.10338169f, -0.01198424f, 0.06922518f, -0.14209351f, -0.04267047f, 0.20043197f, -0.07279608f, 0.01443902f, 
    0.11036730f, -0.04317523f, -0.00215453f, 0.08440244f, -0.11382214f, 0.07798686f, -0.15693514f, 0.18453532f, 
    -0.04491477f, 0.07547729f, 0.03446921f, -0.05868096f, -0.08860584f, 0.15761745f, -0.12056434f, -0.01349427f, 
    -0.11371884f, 0.24052595f, -0.13787363f, 0.18186852f, 0.00786123f, -0.03232689f, 0.00241723f, -0.03447517f, 
    -0.01626116f, 0.15883033f, 0.13143156f, 0.02920915f, -0.21747585f, 0.14807035f, -0.19037218f, 0.06134782f, 
    -0.01662164f, 0.04975230f, 0.05212127f, 0.06236965f, -0.08271331f, -0.09738504f, 0.05356001f, 0.19262962f, 
    0.36733806f, 0.41659233f, -0.03172108f, 0.22526971f, 0.18322346f, 0.15587087f, 0.11976403f, -0.24042925f, 
    0.00180994f, 0.00025039f, -0.06008860f, 0.02258858f, 0.22282518f, -0.19137587f, -0.04436862f, -0.00543563f, 
    0.18676913f, -0.01119030f, -0.17373487f, 0.12151675f, 0.08129461f, 0.03751974f, 0.07578657f, -0.03388880f, 
    0.00993734f, -0.17941530f, 0.24413992f, 0.09372482f, -0.04107483f, 0.06556662f, -0.13093266f, -0.07181986f, 
    -0.08534532f, -0.05459885f, -0.05640017f, -0.12815897f, 0.00716523f, -0.00284279f, 0.02125652f, -0.32014987f, 
    0.15834968f, -0.06145242f, 0.12327331f, -0.05031861f, -0.05811432f, -0.04262187f, 0.01380398f, -0.15600079f, 
    -0.38027197f, -0.46561828f, 0.09332623f, -0.22130354f, 0.05233970f, 0.09376141f, 0.07921331f, 0.12788010f, 
    0.02076525f, 0.03025073f, 0.05346974f, -0.03950462f, 0.35581335f, 0.09705329f, 0.37098339f, -0.02801031f, 
    0.05408425f, -0.10552270f, 0.02800341f, 0.00851120f, -0.10883600f, -0.00030701f, -0.06698555f, 0.06146996f, 
    0.11129305f, 0.00912991f, 0.14729300f, 0.07395926f, 0.04596373f, 0.04922427f, -0.04754462f, 0.11095703f, 
    -0.06048671f, 0.00850270f, -0.11628537f, 0.02473792f, 0.17646927f, 0.07910272f, -0.50155479f, 0.16196926f, 
    -0.12195326f, -0.02882539f, -0.04880340f, 0.01980850f, 0.02737662f, 0.03288799f, 0.01104124f, 0.14305839f, 
    -0.20107867f, 0.04720193f, -0.14111358f, 0.16394231f, 0.00918672f, 0.07002723f, -0.02655414f, 0.00406425f, 
    0.14118965f, 0.12164580f, -0.17125943f, 0.25399205f, 0.04432891f, -0.14464864f, 0.18213965f, 0.12234667f, 
    -0.05030996f, 0.07707885f, -0.07476998f, 0.00240480f, -0.01058620f, -0.12795262f, -0.07460662f, 0.12830302f, 
    0.09704086f, -0.05480431f, 0.06701162f, -0.09249561f, 0.14199939f, -0.13328247f, -0.08327894f, -0.08475693f, 
    0.06357636f, 0.01031419f, 0.06746594f, 0.02137985f, 0.02190316f, 0.09214837f, 0.17525056f, -0.11037582f, 
    0.08426295f, -0.07217425f, -0.18246256f, 0.09721292f, -0.11368948f, -0.02179774f, 0.00317778f, -0.05380146f, 
    0.15758371f, 0.30200288f, 0.15339588f, 0.13336569f, -0.10928961f, 0.04940119f, -0.10553604f, 0.20203663f, 
    0.24808650f, 0.05013460f, 0.06066770f, 0.01101505f, 0.00224863f, 0.18123960f, -0.05082786f, 0.19970575f, 
    -0.06544734f, -0.03683640f, 0.00764862f, 0.09195453f, -0.03177447f, -0.10217030f, 0.07516446f, 0.05698828f, 
    0.19410937f, -0.11184757f, -0.24911334f, 0.04117139f, -0.09334639f, -0.02053433f, -0.20630130f, 0.00171362f, 
    0.09037782f, 0.05668566f, 0.34268567f, 0.06017673f, -0.20819749f, -0.35311928f, 0.01307588f, -0.15837231f, 
    -0.15195391f, -0.15373284f, -0.08339320f, 0.01062474f, 0.08531812f, 0.07306483f, -0.02386097f, 0.18468733f, 
    -0.29668221f, -0.06723680f, 0.29877335f, 0.20872718f, -0.00619837f, -0.15284491f, 0.15928000f, -0.07744632f, 
    -0.13180314f, -0.12002572f, -0.06869549f, -0.05685302f, 0.20503141f, -0.36816660f, -0.01485703f, 0.01920456f, 
    -0.10056710f, 0.25699142f, -0.15259570f, 0.25775123f, 0.18446070f, 0.09864995f, 0.10155348f, -0.10448743f, 
    -0.01345390f, -0.06515342f, 0.26554176f, 0.20566198f, 0.07665302f, 0.00232373f, -0.01796354f, 0.15070120f, 
    -0.02456515f, 0.07455292f, 0.01493469f, 0.04377731f, -0.19197516f, -0.11206242f, -0.26332057f, 0.01018322f, 
    0.28228191f, -0.17478575f, 0.20852603f, -0.05195541f, -0.03841576f, 0.02600037f, 0.02336838f, -0.05447853f, 
    -0.28405038f, -0.07290296f, 0.12137743f, 0.27206734f, -0.16082641f, 0.10968313f, -0.01826467f, 0.05754347f, 
    0.19618681f, 0.01314780f, 0.09735521f, 0.07192438f, 0.40409797f, 0.12029451f, 0.45234233f, 0.08214488f, 
    -0.10569014f, -0.07019238f, 0.12278135f, 0.13598789f, 0.00521941f, -0.07026311f, -0.03436033f, -0.05076887f, 
    0.16414183f, 0.12478750f, 0.08236440f, 0.25766575f, 0.00620935f, -0.03177552f, -0.07228975f, 0.06254010f, 
    0.10741379f, -0.00195412f, -0.03256970f, 0.04747557f, -0.14180607f, 0.10114654f, -0.01256285f, -0.04692173f, 
    0.05964984f, 0.15980576f, 0.00704596f, -0.02413762f, 0.03400623f, -0.06182095f, 0.06529656f, 0.00022263f, 
    -0.43585971f, 0.12652759f, 0.09084018f, 0.15978470f, 0.01630051f, 0.06959841f, 0.12206683f, -0.11391175f, 
    0.02701336f, 0.15230225f, 0.26587150f, 0.06206793f, -0.00959812f, -0.31824791f, 0.00798475f, 0.11870173f, 
    0.05832723f, -0.05048620f, -0.11084091f, 0.02858748f, 0.05703304f, -0.05572835f, -0.00864022f, -0.00177465f, 
    -0.19581152f, 0.17183399f, 0.06692623f, 0.30627215f, 0.03629120f, 0.10889778f, 0.10199320f, -0.06296519f, 
    0.05025641f, 0.02142776f, 0.10565710f, 0.05633077f, 0.01639112f, -0.03704906f, 0.12566604f, 0.00326015f, 
    0.02681426f, 0.00357580f, 0.04426821f, 0.08385598f, 0.02067627f, 0.01809642f, -0.08552187f, -0.04456524f, 
    0.26158258f, -0.01230795f, -0.20869128f, -0.07896050f, -0.06803713f, 0.08614809f, 0.00022645f, 0.04098990f, 
    -0.01918495f, -0.11662808f, -0.02810999f, 0.04694862f, -0.30778447f, 0.15991208f, 0.10970480f, -0.02885836f, 
    0.10831647f, 0.00273115f, -0.03821985f, -0.04665296f, -0.08702823f, -0.01465350f, 0.03830240f, -0.04159530f, 
    0.29547280f, -0.20063217f, 0.00788680f, 0.02245443f, 0.12516607f, -0.18972273f, -0.07831325f, -0.06837578f, 
    -0.15695651f, 0.21329030f, 0.16089736f, 0.08659733f, 0.18470128f, 0.28181931f, -0.27464548f, -0.21721251f, 
    0.07910392f, 0.01475304f, 0.02124049f, -0.00635642f, -0.06219408f, 0.11886369f, 0.18733464f, 0.09957451f, 
    -0.26279518f, -0.23432291f, -0.02702342f, 0.05646734f, 0.06974094f, -0.15786718f, 0.03883583f, -0.14016657f, 
    -0.07230660f, 0.07961696f, -0.01543084f, 0.16998464f, 0.06663988f, -0.07946054f, -0.01131041f, 0.03485461f, 
    0.14622521f, -0.09655678f, 0.11398778f, 0.10983414f, 0.03259142f, 0.08725388f, 0.17280616f, -0.00513402f, 
    -0.19491933f, 0.03729489f, -0.04328594f, 0.11243121f, 0.03667942f, -0.05818034f, -0.02181684f, 0.01205389f, 
    -0.13780239f, 0.05654066f, -0.00147527f, -0.05804721f, 0.09312496f, -0.09303683f, -0.06727738f, -0.01382139f, 
    0.08709165f, -0.01412897f, -0.17093541f, -0.06924745f, 0.11493060f, 0.05396144f, -0.01267642f, -0.01508677f, 
    0.19114834f, -0.43001491f, -0.12586249f, 0.17564841f, 0.18004240f, 0.02911030f, 0.01997469f, 0.08031194f, 
    0.03227394f, 0.10096403f, -0.00895693f, 0.05535873f, 0.21517199f, 0.00084993f, -0.05284279f, 0.00619183f, 
    -0.05101754f, 0.06213247f, 0.11580013f, -0.05963467f, 0.00485175f, 0.01039960f, -0.15971695f, -0.15065156f, 
    -0.07683066f, -0.01967054f, 0.01471370f, 0.04098328f, -0.03011720f, -0.05433738f, 0.01637002f, -0.03314427f, 
    -0.10782468f, 0.16785757f, -0.14542383f, -0.02449845f, -0.17118531f, -0.05933936f, 0.16849431f, 0.33621827f, 
    -0.03010165f, 0.10978104f, 0.24248146f, -0.01218765f, 0.08237121f, 0.02496011f, 0.11220474f, 0.05680196f, 
    0.04776964f, -0.21723132f, 0.05382692f, -0.00314873f, -0.09948989f, -0.06226962f, 0.00866872f, 0.02265944f, 
    0.36215743f, 0.08186908f, 0.02737715f, -0.11419471f, 0.09789252f, -0.28940302f, -0.21005838f, -0.02376091f, 
    0.02495202f, -0.36786646f, -0.10233709f, 0.07838862f, -0.17432465f, -0.01433859f, 0.08903181f, -0.02313754f, 
    -0.06194144f, -0.10143820f, -0.08397479f, -0.15490671f, -0.06795181f, 0.01998011f, 0.14063026f, 0.10122240f, 
    0.00087645f, 0.02672488f, 0.24066700f, -0.25759873f, 0.08472135f, 0.15866560f, 0.14782831f, 0.14546984f, 
    -0.20094413f, -0.13057350f, -0.04682479f, -0.08785882f, 0.04080161f, -0.00530758f, 0.03372622f, 0.01400033f, 
    0.13164176f, 0.03148626f, 0.06772419f, 0.07251930f, -0.07385586f, 0.30374441f, 0.12420879f, -0.02935518f, 
    0.11291359f, 0.09098074f, 0.13912894f, 0.07409347f, 0.21087882f, 0.15987143f, 0.34257677f, 0.22305237f, 
    -0.04080616f, 0.01302771f, 0.06519581f, 0.00171937f, 0.10537931f, 0.41070500f, -0.15183198f, 0.09529159f, 
    0.50614095f, 0.01648159f, 0.01993713f, -0.19838992f, 0.01902303f, 0.03489710f, 0.01596399f, -0.01030082f, 
    0.06061576f, 0.02208688f, 0.07443807f, 0.07379221f, 0.22017708f, -0.12051234f, -0.20296283f, -0.23047461f, 
    0.00608820f, 0.01183653f, -0.08094389f, -0.05411524f, 0.02370839f, -0.11815022f, 0.06172798f, -0.08587465f, 
    -0.00759741f, -0.46678114f, -0.71100068f, -0.60770965f, 0.12336630f, -0.10901669f, 0.04708736f, 0.09220108f, 
    -0.05923650f, -0.11717735f, -0.07361205f, 0.00334255f, -0.25979930f, -0.40731969f, -0.22050714f, -0.02722950f, 
    0.05356668f, 0.12835164f, -0.06167967f, -0.01154847f, -0.08618581f, -0.02784023f, -0.10778291f, 0.00458612f, 
    0.14285420f, 0.14815702f, 0.39099205f, 0.34191048f, 0.01420174f, -0.01708927f, 0.00539734f, 0.06228596f, 
    0.19162348f, 0.14268728f, 0.03444596f, 0.10239001f, -0.01559114f, -0.13475583f, -0.19145703f, 0.01354011f, 
    0.09280540f, -0.12432776f, -0.19363776f, 0.01899109f, -0.04049100f, -0.07882555f, 0.03708263f, -0.06092775f, 
    0.16045538f, -0.35960928f, -0.45021936f, -0.51332104f, -0.09091081f, -0.05858786f, 0.05681327f, -0.03528436f, 
    0.25232902f, 0.00170005f, -0.08254597f, 0.06384156f, 0.27920198f, 0.47203928f, 0.23170227f, 0.21910298f, 
    -0.05402257f, -0.08435196f, 0.04560613f, 0.01551550f, 0.02744824f, 0.04854339f, -0.08929058f, -0.03765250f, 
    0.11893763f, 0.38632521f, 0.24390034f, 0.02544694f, -0.08157069f, -0.06898547f, -0.01019713f, 0.05728523f, 
    0.13992682f, 0.15033869f, -0.03731472f, -0.04021129f, 0.08140503f, 0.08325103f, -0.06362615f, 0.20649517f, 
    -0.11275891f, -0.08808551f, 0.02762717f, 0.02410459f, -0.10323595f, -0.01204478f, -0.02564414f, 0.12254880f, 
    0.45131087f, 0.26839083f, -0.17713661f, -0.06616853f, -0.03942578f, 0.12093498f, 0.09012383f, -0.01293336f, 
    0.28944349f, 0.06237659f, -0.00889585f, 0.13585538f, -0.18132327f, -0.03107481f, -0.00637731f, 0.10663375f, 
    0.13021675f, -0.00427864f, 0.11814350f, -0.23351535f, 0.00561125f, -0.11371394f, -0.01059116f, 0.08467994f, 
    -0.01221075f, -0.03683892f, 0.07094794f, -0.33102921f, 0.06986646f, -0.00218579f, -0.02007516f, 0.06867510f, 
    0.15019691f, -0.00748787f, 0.13674946f, -0.19295269f, -0.06880372f, -0.04112337f, -0.04930925f, -0.09320655f, 
    -0.04093357f, -0.13875332f, -0.03999051f, -0.07767495f, -0.09262513f, -0.02673178f, -0.01314027f, -0.00967797f, 
    0.10106815f, 0.12046933f, -0.13641952f, 0.10930328f, -0.02439758f, -0.01765282f, -0.04230729f, 0.03680758f, 
    0.08266908f, 0.07096487f, 0.03846527f, 0.07640183f, 0.24245180f, 0.10305945f, 0.23636740f, -0.09766804f, 
    -0.12785974f, -0.04078207f, 0.02600933f, -0.07330238f, 0.15096198f, -0.08286176f, -0.00239896f, -0.10948991f, 
    0.16562253f, -0.07525589f, -0.04716570f, 0.23578298f, -0.02929995f, -0.07744763f, -0.10552054f, -0.04162424f, 
    0.05019179f, -0.01723404f, 0.12105010f, 0.22303179f, 0.04313059f, -0.31156775f, 0.20046778f, -0.08608555f, 
    -0.02631935f, -0.04836666f, 0.01668843f, 0.00162981f, 0.22209710f, 0.01899317f, -0.08767968f, -0.16822486f, 
    -0.18303645f, 0.02941035f, 0.46086240f, 0.15439571f, 0.14321779f, -0.13184918f, 0.09131227f, 0.03567532f, 
    0.06136267f, 0.01934008f, -0.13979964f, -0.00797140f, -0.10679890f, -0.14817451f, -0.02152374f, 0.13020061f, 
    -0.01425576f, 0.29111394f, 0.05568698f, 0.23875134f, 0.16514120f, 0.18196407f, -0.03843059f, 0.16638692f, 
    0.29192647f, -0.03793898f, 0.18699874f, -0.13746600f, 0.03292195f, -0.02190164f, 0.03167870f, 0.17124556f, 
    0.08805114f, 0.04681679f, -0.03289586f, 0.11255714f, -0.20455138f, -0.16025612f, -0.15315120f, -0.04712483f, 
    0.07603939f, -0.19654267f, -0.07991498f, 0.38040274f, -0.00520357f, 0.00581703f, 0.06406303f, -0.02886095f, 
    -0.40667337f, 0.02648390f, -0.16190070f, 0.10823963f, -0.06262475f, -0.02715175f, -0.07290244f, -0.01055742f, 
    0.00445431f, 0.03710292f, 0.21185492f, 0.02772186f, 0.23448418f, 0.01217329f, 0.04288396f, -0.13127157f, 
    -0.01174558f, -0.10032222f, -0.06494537f, -0.03732833f, -0.13732938f, -0.01430648f, -0.09514305f, -0.08314796f, 
    0.20804916f, 0.24916522f, 0.19049191f, -0.00703446f, 0.05224423f, -0.13764292f, 0.04060192f, -0.05808139f, 
    0.15515047f, 0.02287381f, -0.08998162f, 0.05142446f, -0.18989404f, -0.03290553f, 0.10033942f, -0.11997851f, 
    -0.00040742f, 0.11771963f, 0.07691842f, -0.17889281f, 0.00049374f, -0.14748296f, 0.00153731f, 0.19548196f, 
    -0.15243348f, 0.03527214f, 0.05082582f, 0.06966009f, -0.09173585f, -0.09422202f, -0.17629677f, -0.10550117f, 
    0.12165049f, -0.06305294f, 0.09917527f, -0.20866644f, -0.05795112f, 0.07780968f, -0.23325731f, 0.19171973f, 
    0.09662192f, 0.13493083f, 0.11597644f, 0.13282281f, -0.10121913f, 0.08554573f, -0.00107254f, -0.03756943f, 
    0.04294796f, 0.37938750f, -0.05391514f, -0.02566074f, -0.14265160f, 0.06951568f, 0.07709563f, -0.04442498f, 
    -0.15561508f, -0.07323942f, -0.09483377f, -0.11574978f, -0.03463515f, 0.05477493f, 0.06461683f, 0.05490169f, 
    -0.21189938f, -0.19735928f, 0.05992291f, -0.22298181f, -0.05767215f, -0.02828894f, 0.05489110f, -0.06037427f, 
    0.08680479f, -0.18022457f, -0.23702134f, -0.11675459f, 0.13915953f, 0.15747868f, 0.08266748f, -0.11229607f, 
    0.00846344f, 0.22409363f, -0.04720492f, 0.17981297f, -0.09489013f, 0.02245737f, 0.32342267f, -0.03026252f, 
    -0.07139168f, -0.18403915f, -0.05555409f, -0.08569829f, -0.03598142f, 0.07849988f, -0.16988802f, 0.06679632f, 
    -0.07174013f, 0.28454751f, 0.17481510f, -0.20719610f, -0.00616700f, -0.04421868f, 0.08998585f, -0.26778838f, 
    0.07771569f, 0.06264392f, -0.08018216f, 0.14739017f, 0.05690815f, 0.33994976f, -0.27132487f, -0.30256152f, 
    -0.00581553f, -0.02800859f, 0.01422878f, -0.24066575f, -0.05976909f, -0.05271250f, -0.16272824f, -0.29684409f, 
    0.30825183f, 0.14557368f, -0.13311978f, 0.07214719f, 0.16336197f, 0.10325338f, -0.19754183f, 0.19681007f, 
    -0.18621273f, -0.00615846f, -0.03497769f, -0.07628410f, 0.00484694f, 0.06644031f, -0.30719388f, 0.21156211f, 
    0.12529072f, 0.13615729f, 0.24753752f, -0.11822222f, -0.14207235f, 0.03585307f, 0.04772387f, 0.02873489f, 
    -0.17865427f, 0.16397493f, 0.25974646f, 0.07606417f, -0.15899149f, -0.02009192f, -0.13520017f, -0.08166383f, 
    0.01923812f, 0.02864882f, 0.05756926f, 0.08738124f, 0.48522145f, -0.04522964f, 0.07604984f, -0.04483103f, 
    -0.01304640f, 0.15179347f, -0.07463509f, 0.20525533f, 0.02165507f, 0.11303620f, 0.14081068f, 0.21075286f, 
    0.33715665f, 0.07782879f, -0.21663718f, -0.32929215f, 0.04507862f, 0.10470012f, 0.09571054f, 0.01592254f, 
    -0.03166345f, 0.14392306f, -0.07899053f, 0.09784456f, -0.36619866f, 0.02221167f, -0.02983844f, 0.14874054f, 
    -0.19066139f, -0.13759267f, -0.33824533f, -0.16074629f, -0.06812809f, 0.10435248f, -0.06904812f, 0.11584257f, 
    0.03476513f, 0.23423932f, 0.11663753f, -0.06012124f, -0.15894683f, -0.03402025f, -0.13656060f, -0.19645402f, 
    0.18863037f, 0.01649678f, 0.06211447f, 0.10879239f, -0.04765863f, -0.11109921f, 0.13142063f, 0.20523277f, 
    0.08130872f, -0.10663698f, 0.16520153f, 0.04995989f, -0.09500431f, -0.10765435f, -0.06491321f, 0.15528676f, 
    0.37127671f, 0.08331566f, -0.16402382f, -0.00302317f, -0.12175602f, 0.13670340f, 0.07971408f, 0.04515848f, 
    0.20934652f, -0.01962577f, 0.01299481f, -0.07763357f, -0.05659194f, -0.01645179f, -0.00842606f, -0.03070961f, 
    0.07444209f, 0.17598845f, 0.13694087f, -0.11041940f, -0.00848535f, -0.08471894f, -0.02591758f, 0.09325215f, 
    0.04008326f, 0.23589888f, 0.07677714f, -0.24219657f, 0.02353997f, -0.05037329f, -0.07841949f, 0.10503305f, 
    0.01346253f, -0.20242675f, -0.00828120f, -0.18189357f, 0.04941888f, 0.06265814f, -0.04363487f, -0.10340077f, 
    -0.06607240f, -0.06106775f, -0.11592618f, -0.12239296f, -0.04984382f, -0.03002807f, -0.08825730f, 0.05335488f, 
    0.03977737f, 0.01180513f, -0.01243275f, 0.11680833f, 0.02319066f, 0.06195945f, -0.07462842f, 0.14944609f, 
    0.15056255f, 0.21078129f, 0.07616602f, 0.10729007f, 0.07014721f, 0.09418516f, 0.11293845f, 0.06209671f, 
    -0.10177117f, 0.01222205f, 0.03740315f, -0.03127878f, 0.08590007f, 0.05674558f, -0.15587208f, 0.10024796f, 
    0.20606372f, -0.08135121f, -0.01394207f, 0.22615030f, -0.17062561f, -0.00011988f, -0.18768327f, -0.03910855f, 
    0.10710183f, -0.05378377f, 0.15233690f, 0.35917541f, -0.07643849f, -0.09065166f, 0.12732032f, -0.13768817f, 
    -0.16507758f, -0.13613302f, -0.11092902f, -0.01454857f, 0.23088059f, -0.11567280f, -0.23127571f, -0.34055781f, 
    -0.00771094f, 0.33136666f, 0.44961673f, 0.17877617f, 0.23250912f, -0.04102502f, 0.14290072f, 0.11983990f, 
    0.00020374f, -0.14830139f, -0.09593435f, -0.09557775f, 0.06145709f, -0.10392174f, -0.20783754f, 0.15956922f, 
    0.03278351f, 0.42703775f, 0.15815827f, 0.12039897f, 0.07464748f, 0.07795214f, -0.05354964f, 0.19061430f, 
    0.17483760f, -0.03176691f, 0.31147751f, -0.06513269f, -0.01197092f, 0.00189010f, -0.04973377f, 0.11765115f, 
    0.12023465f, 0.11631431f, -0.00911156f, 0.00588210f, -0.15296784f, -0.17994840f, -0.05525301f, -0.29214910f, 
    0.05770637f, -0.19329810f, -0.05816161f, 0.40776354f, -0.11594104f, 0.05845153f, 0.04879803f, 0.04582896f, 
    -0.41686931f, -0.10430747f, -0.24647945f, -0.03593941f, -0.16482568f, -0.09812610f, -0.02066588f, 0.01529537f, 
    0.16882943f, 0.19901818f, 0.12433374f, 0.12892941f, 0.06769314f, 0.07193107f, 0.15802771f, -0.00898846f, 
    0.01318363f, -0.15680230f, -0.13952065f, -0.13658708f, -0.09180298f, -0.06275535f, 0.03333021f, -0.03242170f, 
    0.26536435f, 0.36830389f, 0.16332047f, 0.22867844f, -0.04749132f, -0.03120543f, -0.00878926f, -0.13749185f, 
    0.23987758f, 0.00566147f, -0.00987736f, 0.24059589f, -0.09970833f, 0.02702022f, 0.01651486f, -0.07171370f, 
    -0.18580832f, 0.08389756f, 0.06547074f, -0.14690737f, -0.10360809f, -0.12013429f, 0.09229160f, 0.24709997f, 
    0.63683891f, -0.09206957f, -0.16014491f, -0.25116482f, -0.01551459f, -0.06302185f, 0.10817157f, 0.08231828f, 
    0.02727372f, 0.03588362f, -0.18596520f, 0.14339475f, 0.10260332f, 0.24892297f, 0.18989794f, -0.11586389f, 
    -0.05878135f, -0.06368592f, 0.14668456f, -0.05007866f, 0.09217352f, 0.03673475f, -0.07599518f, -0.01036775f, 
    0.08190580f, -0.38708860f, 0.17857419f, -0.14449039f, 0.07571759f, -0.16232120f, -0.03145442f, 0.08637667f, 
    0.10688869f, 0.06030289f, 0.04647588f, 0.04863071f, 0.02164658f, -0.02668429f, -0.14743242f, 0.13205793f, 
    0.11316074f, 0.14640835f, 0.00717052f, 0.00710461f, 0.05432372f, 0.04779874f, -0.06580868f, 0.13244775f, 
    -0.25396219f, 0.11660625f, 0.11128379f, 0.18613507f, -0.13452205f, -0.28770357f, -0.15354547f, 0.03973180f, 
    0.09887058f, -0.06612313f, 0.06568505f, 0.00927186f, 0.51100004f, -0.11755110f, -0.00645901f, -0.10537828f, 
    0.08953758f, -0.00494416f, 0.06884417f, -0.00069167f, 0.14560771f, 0.07244685f, 0.11682919f, -0.11773162f, 
    0.10338762f, -0.22524446f, 0.13000673f, 0.19670348f, 0.05181829f, 0.17277084f, -0.09856358f, 0.17264679f, 
    -0.13791990f, -0.09187295f, -0.00253179f, -0.03082692f, 0.12837477f, -0.53204626f, 0.49359655f, 0.18923850f, 
    -0.15835491f, -0.10968652f, 0.05388645f, 0.15398933f, 0.14169520f, 0.10098575f, -0.03898593f, 0.12964618f, 
    -0.00044685f, 0.02714310f, 0.23102452f, -0.08110974f, -0.05323537f, -0.01215439f, 0.12266974f, -0.02921126f, 
    0.00853091f, -0.06327281f, 0.05798448f, -0.10218674f, -0.01482472f, 0.15923683f, 0.14968109f, -0.04789798f, 
    -0.11545584f, 0.00991715f, -0.17337312f, 0.03361999f, 0.16913770f, -0.06155910f, -0.09055163f, 0.06143291f, 
    0.41213173f, -0.03182606f, -0.46128389f, -0.24325372f, 0.12363563f, -0.06220116f, 0.14609133f, 0.02689152f, 
    0.14325909f, 0.26963726f, -0.03704256f, 0.06035648f, -0.49399441f, -0.02119693f, -0.02809251f, 0.04957253f, 
    0.04092347f, 0.07874011f, 0.11084524f, -0.01298438f, -0.01218468f, -0.08565895f, 0.03190482f, -0.08102722f, 
    -0.39295673f, 0.14987546f, 0.04681140f, 0.07815709f, -0.13093008f, -0.10004196f, -0.10238923f, 0.02459832f, 
    0.10215486f, -0.12343494f, 0.02614873f, 0.03019703f, 0.17652619f, -0.04156361f, -0.22323585f, -0.01484140f, 
    0.08429153f, 0.04027661f, 0.08392434f, 0.01604183f, 0.07986206f, 0.00526934f, 0.06231091f, 0.06682196f, 
    0.08260631f, -0.07971755f, -0.05534759f, 0.18217874f, 0.08877586f, -0.01550409f, 0.14842187f, 0.06852810f, 
    0.05614543f, -0.06605209f, -0.07633272f, 0.13819660f, 0.17114340f, 0.12832436f, 0.03349662f, -0.31306869f, 
    0.02377200f, 0.07306952f, -0.03707045f, -0.04051178f, -0.11404271f, 0.02125694f, 0.04602795f, -0.11150701f, 
    0.28478098f, 0.25858968f, 0.15925001f, -0.14411534f, -0.00666293f, 0.00017568f, 0.08361672f, -0.03598415f, 
    0.11916307f, 0.04108628f, 0.01944412f, 0.32153106f, -0.17528687f, -0.14736171f, -0.11854579f, -0.60634130f, 
    -0.07867777f, -0.19449484f, -0.06561252f, -0.34809899f, 0.04402778f, -0.13551816f, -0.00602842f, -0.09499598f, 
    0.00862552f, -0.12379128f, 0.05543138f, -0.03148939f, 0.07981170f, 0.02811163f, -0.04677836f, 0.03717460f, 
    0.04071999f, 0.25315282f, 0.31036907f, -0.07001697f, -0.04631063f, -0.11326589f, -0.13720870f, -0.08121755f, 
    0.08771005f, 0.17688233f, 0.16685459f, 0.02319712f, -0.08035262f, -0.09295533f, -0.02688050f, 0.04647122f, 
    0.04266381f, -0.06857316f, -0.02266697f, -0.03103494f, -0.05895343f, 0.20351739f, 0.10437407f, 0.13754949f, 
    0.11313260f, 0.10383511f, 0.19111237f, 0.05843040f, 0.29773888f, -0.27725220f, 0.00437282f, -0.05298989f, 
    -0.01500276f, 0.09963622f, -0.00463182f, 0.05339380f, 0.01794445f, 0.11827675f, 0.23351674f, 0.08715390f, 
    -0.08611583f, -0.02103634f, -0.01465378f, 0.54541016f, 0.05325835f, -0.00313901f, -0.08679967f, 0.14252710f, 
    0.09011181f, 0.09046046f, 0.31292760f, -0.11472058f, 0.04977030f, -0.06473392f, 0.33230656f, 0.23851608f, 
    0.08535964f, 0.03801428f, 0.02130260f, 0.07263657f, 0.02416952f, 0.11291612f, 0.37905157f, 0.13448854f, 
    -0.15091901f, -0.02691648f, 0.27162018f, 0.17259465f, -0.11554638f, 0.17931488f, 0.06554651f, -0.07783804f, 
    0.00938150f, 0.15510856f, -0.00178336f, -0.01012099f, -0.16095081f, 0.23281503f, 0.18755367f, -0.04489340f, 
    0.11127528f, -0.17789173f, -0.08728206f, 0.34707204f, -0.07987625f, 0.11408044f, 0.00328011f, -0.04894443f, 
    0.34246629f, -0.17306024f, 0.12022355f, -0.38880613f, -0.00608531f, -0.04160380f, 0.18352872f, 0.09954631f, 
    0.05024539f, 0.09011548f, -0.08561443f, -0.10348015f, -0.18887611f, -0.26469994f, -0.22550738f, -0.06986745f, 
    0.10872284f, -0.19617629f, -0.10669013f, 0.10303407f, 0.05486735f, -0.17656097f, 0.01042952f, -0.06731510f, 
    -0.48452064f, 0.43128809f, 0.42641798f, 0.58280915f, -0.09795807f, -0.13970566f, -0.04615373f, 0.02792751f, 
    0.03238137f, 0.06025199f, 0.20270871f, 0.24353708f, 0.02609530f, -0.10721269f, 0.00033014f, -0.18520565f, 
    0.03435517f, 0.04935884f, 0.17692916f, 0.06085601f, -0.10142938f, -0.04418375f, -0.06845722f, 0.01398371f, 
    0.00567398f, 0.11246587f, 0.09163304f, 0.10178018f, -0.01614741f, 0.05625727f, 0.18584017f, 0.06335481f, 
    0.01366282f, -0.04911894f, -0.04811208f, 0.08112400f, -0.25325352f, -0.37233141f, -0.35437459f, -0.21405372f, 
    0.02016791f, 0.29683205f, -0.04591522f, -0.24237318f, 0.10270154f, 0.11539060f, -0.11997329f, 0.02901541f, 
    0.22724071f, -0.21742712f, 0.01167873f, -0.09848716f, -0.10389102f, -0.00682569f, -0.03363275f, 0.08194175f, 
    0.02137950f, 0.16582085f, 0.02782231f, -0.34517637f, 0.33983952f, 0.15524717f, -0.16243181f, 0.09702113f, 
    -0.06449023f, 0.01472232f, 0.21778546f, 0.28255388f, -0.11760506f, -0.08533158f, -0.00801812f, -0.09073643f, 
    0.21233490f, 0.18809898f, 0.02489008f, 0.17568208f, 0.05874278f, 0.06896642f, -0.03813149f, 0.13386139f, 
    0.09004188f, 0.07267307f, 0.16906123f, 0.01095458f, 0.22816880f, 0.15768917f, 0.11402403f, 0.15284358f, 
    -0.21640144f, -0.12856036f, -0.12426105f, -0.12694085f, -0.11481800f, -0.05813674f, -0.12053920f, -0.12757121f, 
    0.04888889f, -0.08741862f, 0.22703224f, 0.02862817f, -0.03521581f, -0.01649879f, 0.01325941f, -0.08574144f, 
    -0.12161133f, -0.02533776f, 0.04324329f, 0.00520473f, 0.28222933f, 0.16014259f, 0.07998995f, 0.29847091f, 
    -0.13521978f, 0.04455731f, 0.07535747f, -0.03226243f, 0.19022515f, 0.30936500f, 0.03740974f, 0.13794440f, 
    -0.07001214f, 0.32268187f, 0.14534976f, 0.21504433f, -0.04017074f, 0.03936086f, 0.00023162f, -0.05542663f, 
    -0.02072807f, 0.11987821f, -0.08183784f, 0.11972683f, 0.16821589f, 0.34764165f, -0.02992622f, 0.09622817f, 
    0.02419936f, 0.07414661f, 0.01916708f, -0.06403978f, -0.11647183f, 0.02767898f, -0.07737850f, 0.07077299f, 
    -0.06182462f, 0.01495053f, -0.83618814f, -0.44915649f, -0.02597924f, 0.11269926f, -0.09446994f, 0.04131329f, 
    0.00458173f, 0.08821976f, 0.09116578f, -0.00541744f, -0.23294310f, -0.33656403f, -0.23404442f, -0.27824169f, 
    -0.11644439f, -0.04843029f, -0.01111765f, -0.00484670f, 0.15657273f, 0.06883068f, -0.07221597f, 0.05310861f, 
    0.24793677f, 0.31580201f, 0.18809371f, 0.17924239f, -0.03917293f, 0.06397086f, 0.03004239f, 0.01788163f, 
    -0.03805577f, -0.09878573f, 0.00594653f, -0.01354923f, -0.16909704f, -0.07070918f, -0.08914126f, -0.00016991f, 
    0.00865926f, 0.09362759f, 0.26965448f, -0.09078877f, -0.03802914f, -0.11665948f, -0.07790361f, -0.13349043f, 
    0.13153154f, -0.42805615f, -0.31690428f, -0.45920250f, 0.03874852f, -0.02370730f, -0.03940992f, -0.05814775f, 
    -0.01598218f, -0.00390780f, 0.02559319f, -0.08411129f, 0.41286793f, 0.24294993f, 0.29025748f, 0.16397925f, 
    0.04794602f, -0.04676821f, -0.00770693f, -0.08339398f, -0.01253820f, -0.12216394f, -0.03000438f, -0.08800014f, 
    0.21021369f, 0.10361592f, 0.21514797f, 0.09682237f, -0.04678568f, -0.07203892f, -0.04447322f, 0.00306640f, 
    -0.04132828f, -0.00877654f, -0.04527475f, 0.04380864f, 0.26301870f, 0.23606309f, -0.10594750f, -0.11736506f, 
    -0.28385711f, -0.17011991f, 0.12212858f, 0.32070383f, 0.01856376f, 0.09342442f, 0.04132582f, 0.14027706f, 
    -0.11526346f, 0.32495788f, -0.04382839f, 0.10670619f, -0.02162942f, 0.13851215f, 0.01955209f, -0.01125304f, 
    0.20905824f, 0.10458560f, 0.05969835f, -0.00887801f, -0.22219734f, -0.17132033f, -0.06455233f, 0.32579395f, 
    0.04077552f, 0.00198783f, -0.04789506f, -0.17013782f, -0.04932198f, -0.06325097f, 0.02210717f, 0.07631287f, 
    -0.22137168f, 0.02122677f, 0.10651105f, -0.02963698f, 0.08499628f, 0.20960769f, 0.03566314f, 0.00818496f, 
    0.12858050f, -0.05992502f, 0.11026711f, -0.04692519f, -0.16246128f, -0.05225524f, -0.03061015f, -0.14493099f, 
    0.01824091f, -0.10859246f, -0.19396175f, 0.00226689f, -0.03700431f, 0.04038539f, -0.00616444f, -0.03631884f, 
    0.19374743f, 0.00446611f, -0.06454708f, 0.17053223f, -0.00116986f, 0.00348802f, -0.01305559f, -0.06043245f, 
    0.03031750f, -0.04401660f, -0.01182338f, 0.15202500f, -0.06838600f, 0.18565890f, 0.16779912f, -0.18014649f, 
    -0.00902470f, -0.10008714f, -0.15403193f, -0.03869376f, 0.11949532f, -0.19844159f, -0.00986806f, -0.19441295f, 
    0.18211061f, -0.31384093f, 0.10683043f, -0.06087767f, 0.08611781f, -0.13911483f, -0.17112342f, 0.02466305f, 
    0.10672712f, 0.06673496f, 0.09006856f, 0.09936352f, -0.01389871f, 0.12563670f, -0.15055923f, -0.21154064f, 
    0.01019948f, -0.04308878f, -0.09099398f, -0.03166523f, 0.01730720f, 0.09588296f, -0.01958620f, -0.03641961f, 
    -0.45582125f, -0.18792799f, 0.11365607f, -0.08673033f, -0.00087324f, -0.03703484f, 0.03156647f, 0.10455215f, 
    0.00057392f, -0.06630917f, 0.00144350f, 0.04210266f, -0.09263971f, -0.20504680f, 0.04209138f, 0.07773275f, 
    0.05892920f, 0.14582022f, 0.23825420f, 0.08402847f, 0.06093735f, 0.11065731f, 0.03629768f, -0.08184832f, 
    -0.09462434f, 0.18898349f, -0.06475139f, 0.05387220f, 0.04404904f, 0.01929848f, -0.08824561f, 0.00946517f, 
    -0.00071553f, -0.05840737f, -0.09908046f, 0.11886364f, -0.05525139f, -0.13718250f, -0.07954281f, 0.10538421f, 
    0.07621466f, -0.03999932f, 0.10398427f, 0.08019511f, 0.07316309f, -0.05275472f, -0.06711073f, 0.08584462f, 
    0.07360367f, -0.15232950f, -0.05855721f, 0.11365307f, 0.06602518f, -0.10196009f, -0.14789473f, -0.03423287f, 
    0.13681273f, 0.09658838f, 0.22354522f, 0.01739285f, 0.11107029f, -0.14390066f, -0.18475640f, 0.09685869f, 
    -0.05366825f, -0.05532406f, -0.07175888f, 0.03047558f, -0.01615676f, -0.00560389f, -0.12474786f, -0.09944658f, 
    -0.05734135f, -0.01791031f, 0.00663579f, 0.13523062f, -0.01324277f, -0.19803171f, -0.03272394f, -0.12900749f, 
    -0.05967780f, 0.13865638f, 0.06410063f, -0.00458697f, -0.17077458f, -0.03541698f, 0.42337957f, 0.06272176f, 
    0.02562664f, 0.17726305f, 0.24183129f, -0.08196255f, -0.01323702f, -0.11351353f, 0.04254799f, 0.07494707f, 
    -0.02821260f, -0.04453278f, 0.02543621f, 0.04582947f, 0.01409759f, -0.07134707f, 0.01149247f, 0.02101524f, 
    -0.03604142f, -0.04811296f, 0.03048403f, 0.04817797f, -0.04245605f, -0.02174458f, 0.01075120f, -0.04076644f, 
    0.01072329f, -0.04799678f, 0.04937588f, 0.01933069f, 0.04813221f, 0.06228925f, -0.01378252f, -0.02399524f, 
    -0.06234149f, 0.05780460f, -0.04446596f, 0.06279908f, -0.03132131f, -0.06688689f, 0.04929858f, -0.04247499f, 
    -0.01373262f, -0.07073904f, -0.02068553f, -0.02430426f, -0.05356779f, -0.06221320f, -0.05544125f, 0.01513046f, 
    0.04703613f, -0.02621131f, -0.01825866f, -0.07238748f, -0.02353820f, -0.02374539f, 0.00989112f, 0.00505908f, 
    -0.01992037f, -0.06155085f, -0.06367264f, 0.06246052f, -0.00479429f, 0.06154259f, 0.04356616f, 0.03403058f, 
    -0.01569556f, -0.06798220f, 0.04333525f, 0.01209904f, 0.00308522f, -0.02079917f, 0.02403518f, -0.07237519f, 
    0.06386156f, -0.02087696f, 0.01135086f, -0.00988907f, 0.05352731f, 0.03796042f, 0.02786537f, -0.06651792f, 
    0.07051606f, -0.04503277f, 0.04038153f, -0.01306757f, 0.00485053f, -0.04730646f, -0.02130782f, -0.07946127f, 
    -0.02789604f, -0.00255128f, -0.02828577f, 0.02238085f, -0.04784438f, 0.01993938f, -0.03591001f, 0.00440233f, 
    -0.00208404f, 0.00607808f, -0.05389785f, -0.00766327f, 0.06345688f, -0.01108646f, -0.01974644f, 0.01243418f, 
    -0.02061550f, -0.08017907f, 0.05680085f, -0.05016674f, -0.06777910f, -0.04721320f, -0.02857389f, -0.04596660f, 
    -0.04162778f, -0.05337279f, 0.02361422f, -0.07643750f, -0.00958379f, -0.05109162f, -0.03861570f, -0.06682759f, 
    -0.06650409f, 0.06285132f, -0.03769111f, 0.02566508f, 0.02832563f, 0.02566688f, -0.00657590f, -0.04743292f, 
    0.04890840f, -0.03010751f, -0.00132375f, 0.05456186f, 0.04039780f, -0.05580810f, -0.04123833f, -0.00454732f, 
    -0.03781404f, -0.00638963f, -0.00333623f, -0.07840793f, 0.00813068f, 0.00427787f, -0.06940749f, -0.04405862f, 
    -0.03987630f, -0.04494574f, 0.02935290f, -0.00716680f, -0.02542564f, 0.05027861f, -0.06888098f, -0.05132241f, 
    -0.04919106f, 0.05528033f, 0.02391444f, 0.03094929f, 0.01275264f, -0.03234698f, -0.01699482f, 0.04464425f, 
    0.04145867f, -0.03608895f, 0.00013384f, -0.02144606f, 0.01052083f, 0.04514657f, 0.03709907f, 0.02803780f, 
    -0.03745179f, -0.05043037f, 0.03849424f, -0.03534113f, -0.06046013f, -0.05959043f, 0.06267672f, -0.05839039f, 
    0.03743388f, -0.03154256f, 0.05066390f, 0.04283733f, -0.05123165f, -0.04282592f, -0.06205515f, -0.04737778f, 
    -0.07510386f, -0.02571440f, -0.03429354f, 0.01446336f, 0.05554111f, 0.00270799f, -0.01394104f, -0.02457580f, 
    -0.02343909f, -0.00093736f, -0.02595783f, 0.01620825f, -0.04913683f, -0.05587750f, -0.06560837f, -0.02625598f, 
    0.21359922f, -0.10375281f, 0.34925282f, -0.26366457f, -0.00331031f, 0.02939281f, -0.23195013f, 0.10190088f, 
    -0.16673926f, 0.00836502f, 0.02107910f, -0.22315195f, -0.02654199f, 0.20893013f, 0.16877660f, 0.29479980f, 
    -0.06155438f, -0.09901223f, 0.15557420f, 0.40510142f, -0.11111363f, 0.01923830f, -0.04841326f, 0.13828105f, 
    -0.00167828f, -0.12690352f, -0.09803304f, 0.05740002f, 0.03347204f, 0.00230892f, -0.06306345f, -0.11729474f, 
    -0.01218266f, -0.04525154f, -0.03389344f, -0.21944791f, -0.04620536f, -0.02201477f, -0.13571191f, -0.12418348f, 
    -0.05437662f, 0.04353869f, -0.05145038f, -0.04306887f, -0.02977425f, -0.04662341f, -0.00147317f, -0.04751303f, 
    -0.09015780f, -0.12018588f, 0.23125465f, -0.11992526f, -0.09099074f, 0.13283624f, 0.05644557f, 0.06271298f, 
    -0.05618045f, 0.22595099f, -0.07837230f, 0.02190383f, 0.00028701f, 0.10242702f, 0.19745024f, 0.03164214f, 
    -0.17903025f, -0.00950392f, -0.07052547f, 0.02548235f, -0.03273970f, -0.06617489f, 0.06418779f, 0.11745641f, 
    -0.03571009f, -0.07794092f, -0.02740191f, 0.00233680f, -0.10634531f, 0.22634403f, -0.04800613f, -0.21195674f, 
    0.08656717f, 0.09917229f, -0.02924555f, -0.00438065f, -0.06075776f, -0.18104711f, 0.08573423f, 0.24750455f, 
    -0.12564237f, -0.06847291f, -0.27811751f, -0.23025301f, -0.03379678f, -0.05014040f, -0.00630548f, -0.10727834f, 
    0.00672986f, -0.20432051f, -0.01360030f, 0.03165161f, -0.14045940f, -0.00495825f, -0.02122455f, 0.04053885f, 
    0.18034934f, -0.15706837f, 0.00088413f, -0.08226995f, -0.15432310f, -0.20011227f, 0.23537929f, 0.04959473f, 
    -0.04880625f, -0.06309828f, 0.07256345f, 0.05863304f, 0.04981239f, 0.11233972f, 0.02627784f, -0.00738889f, 
    -0.14701892f, 0.25312263f, 0.21771896f, 0.08582557f, -0.04653699f, 0.01095592f, 0.06603524f, 0.04946433f, 
    -0.02434880f, 0.06136133f, 0.00966060f, 0.13068853f, -0.28616363f, 0.17143297f, -0.31037167f, 0.19418611f, 
    0.06106633f, 0.11060385f, 0.35517365f, 0.16752705f, -0.11026307f, 0.05783115f, 0.05323465f, 0.15469812f, 
    0.26852280f, 0.10941640f, -0.09532808f, -0.16892505f, -0.03602063f, -0.19672875f, 0.00130569f, -0.13945313f, 
    0.11366311f, -0.09643590f, 0.09240542f, 0.01758071f, 0.00979979f, 0.38352284f, -0.14462301f, 0.18035822f, 
    0.16147134f, -0.05306663f, -0.11202694f, 0.02329231f, -0.03280286f, -0.04763436f, 0.09478723f, 0.11818621f, 
    0.24765290f, -0.03766340f, 0.09919352f, 0.01488531f, 0.10142174f, -0.01588597f, -0.11230940f, -0.09822191f, 
    -0.01991729f, -0.04291333f, 0.02717068f, -0.02450294f, 0.19370921f, 0.11607970f, 0.11303824f, -0.01824640f, 
    -0.14564629f, -0.03000212f, 0.02213507f, 0.23607764f, 0.03630131f, 0.07942656f, 0.00180672f, -0.15002595f, 
    -0.21900614f, 0.27918005f, 0.14128469f, 0.04567948f, 0.04685569f, 0.01384034f, -0.04892345f, 0.09115657f, 
    -0.00095249f, 0.02622315f, -0.03416224f, -0.01838258f, -0.07046863f, -0.11794621f, -0.07857447f, 0.48893273f, 
    0.06795811f, 0.04617100f, -0.13029355f, 0.20523590f, 0.04206124f, 0.08541693f, -0.04582200f, 0.25220829f, 
    -0.02526811f, -0.05610431f, 0.07896683f, 0.11423912f, 0.00227677f, 0.15676767f, 0.08392376f, -0.12545893f, 
    0.14801586f, -0.00972804f, 0.02636382f, -0.02131112f, -0.03729466f, -0.05136189f, -0.02433017f, 0.05266067f, 
    0.08988280f, 0.11990191f, -0.13580458f, -0.10639405f, 0.04678018f, -0.03553931f, 0.09522194f, -0.02085089f, 
    0.11618948f, -0.03128376f, 0.07439641f, -0.00677011f, 0.02253064f, -0.16942114f, -0.02474414f, 0.12761690f, 
    0.05120117f, -0.10143627f, -0.03400154f, 0.00833190f, 0.01201642f, 0.31003648f, 0.21692026f, 0.04064710f, 
    -0.06738845f, -0.03961080f, -0.08924792f, -0.02317972f, 0.06351783f, -0.13737795f, 0.06658751f, -0.10380945f, 
    0.20085625f, -0.27862397f, 0.16589762f, -0.07207479f, 0.05823240f, -0.08477029f, -0.08285177f, -0.07065657f, 
    0.02820187f, 0.09999721f, 0.14834845f, 0.00605040f, 0.04642266f, -0.00959036f, 0.03280823f, -0.15031767f, 
    -0.01052312f, -0.05245692f, -0.04738416f, 0.02471319f, -0.02956186f, 0.07639132f, -0.02729260f, 0.06401318f, 
    -0.48604897f, -0.24734299f, 0.06000802f, -0.15872689f, -0.09385494f, -0.22792771f, -0.01899881f, -0.08286727f, 
    -0.01992600f, -0.07682218f, 0.07014667f, 0.13006768f, 0.03922185f, -0.16525511f, 0.18287352f, -0.03599802f, 
    -0.07398185f, 0.02008009f, 0.08861410f, 0.00881820f, 0.05601367f, 0.07537791f, 0.10596234f, 0.10158545f, 
    -0.15435019f, 0.17788206f, -0.20664309f, 0.33854207f, 0.03077029f, -0.05195688f, 0.08540188f, 0.00236181f, 
    -0.00332077f, 0.17036752f, -0.06115557f, 0.18807110f, -0.06966850f, -0.00079848f, -0.06598562f, 0.19576895f, 
    0.16482788f, 0.08969185f, 0.22469267f, -0.15886720f, -0.02645505f, -0.01358675f, -0.05296514f, 0.18675181f, 
    0.21016727f, 0.12603137f, -0.04946368f, 0.01982182f, -0.02980992f, -0.14035499f, -0.14824437f, 0.04559299f, 
    0.14253779f, 0.15703334f, 0.11119267f, -0.04201800f, 0.17506823f, 0.13499995f, -0.22134072f, 0.24390422f, 
    -0.08298043f, 0.05373859f, 0.06780111f, -0.00689331f, 0.09240429f, -0.00537043f, 0.02439076f, -0.17310062f, 
    -0.04537554f, -0.08443427f, -0.08514149f, 0.22077999f, 0.07818197f, -0.13305238f, 0.04286214f, -0.09840028f, 
    -0.01170013f, 0.05422681f, 0.15582618f, -0.03328664f, -0.04681452f, 0.02149983f, 0.46349433f, 0.17608203f, 
    0.15437689f, 0.14102159f, 0.04943760f, 0.06985199f, 0.04544399f, 0.07473245f, 0.23807599f, -0.18260385f, 
    -0.07290170f, -0.19049697f, 0.16481917f, -0.14684041f, 0.02741857f, -0.08219469f, -0.05599624f, -0.02515887f, 
    -0.05360721f, 0.15866667f, -0.11929360f, 0.17426175f, 0.28017789f, 0.20551863f, 0.16691102f, 0.12959057f, 
    0.15277712f, 0.06893620f, -0.02133929f, 0.22354329f, -0.22020592f, 0.01739503f, -0.06237243f, -0.12193733f, 
    0.27233568f, -0.05825410f, 0.24496278f, 0.20574494f, 0.11674330f, 0.16847526f, 0.12025629f, 0.30795884f, 
    0.17258991f, 0.23015195f, 0.14366326f, 0.12347296f, -0.11150707f, 0.10219465f, 0.03575521f, 0.05762205f, 
    0.25226927f, -0.09992870f, -0.14216650f, 0.17399332f, -0.35404557f, -0.21781303f, -0.29400489f, -0.51789725f, 
    -0.32194784f, 0.16382191f, 0.22813146f, 0.22191745f, -0.00053994f, -0.44103184f, -0.17144550f, -0.33586878f, 
    0.02135082f, -0.23621364f, -0.32668486f, -0.41157418f, 0.06361500f, 0.19361095f, 0.15296134f, 0.08891424f, 
    0.11077127f, -0.03381084f, -0.05355755f, -0.22702411f, 0.05873623f, -0.00445632f, 0.33683556f, -0.11024524f, 
    0.04603033f, 0.01398481f, 0.09362499f, -0.29420626f, -0.07758652f, -0.03630159f, -0.17277575f, -0.05110322f, 
    -0.18940155f, 0.03838589f, -0.06775714f, -0.11269084f, 0.11679368f, -0.23524590f, -0.15201557f, 0.09335686f, 
    -0.18756974f, -0.08185994f, -0.21786328f, -0.05324796f, 0.13381524f, 0.22797383f, 0.09600044f, 0.28177473f, 
    0.00066386f, 0.02771788f, -0.05017703f, -0.17183279f, -0.06434799f, 0.17435311f, 0.15983686f, 0.25028732f, 
    0.18907069f, 0.07902526f, 0.16241027f, 0.17203814f, 0.19264196f, 0.10593611f, 0.14312622f, -0.10026578f, 
    0.22117524f, -0.08242726f, -0.03248023f, -0.11084267f, -0.08189238f, -0.00708830f, -0.12618601f, -0.11767174f, 
    -0.21451254f, 0.19728954f, -0.26329452f, 0.36102626f, -0.04013815f, 0.06271145f, 0.01235561f, -0.02248663f, 
    -0.01212307f, -0.12857874f, -0.02282976f, 0.02913257f, -0.46318877f, 0.03932945f, -0.20362294f, 0.47235221f, 
    0.07264022f, 0.24885973f, -0.17011222f, -0.10180973f, -0.01467893f, -0.37117863f, -0.19854531f, -0.61161864f, 
    0.39877722f, -0.04671790f, 0.04044746f, 0.02214863f, -0.05092681f, 0.00027478f, -0.09300129f, 0.04992678f, 
    0.16746312f, -0.11305575f, 0.05957354f, -0.07663148f, -0.05047774f, 0.29253748f, -0.04247138f, 0.32560658f, 
    0.13882044f, -0.02638812f, 0.03880713f, 0.01404521f, 0.13493107f, -0.22785795f, -0.04757088f, -0.01928243f, 
    0.06030213f, -0.06948333f, -0.06025662f, -0.17815803f, -0.05624717f, -0.07496858f, -0.02310721f, 0.05150956f, 
    -0.29639009f, -0.03034476f, -0.01568494f, -0.21787146f, 0.20642076f, 0.37419897f, 0.24536057f, 0.10577382f, 
    0.23250090f, -0.00553735f, 0.11647671f, 0.27275878f, 0.07917920f, 0.20578767f, 0.08159529f, -0.14894314f, 
    -0.17366801f, 0.11666194f, 0.28201893f, 0.16883691f, -0.01086512f, -0.02966099f, -0.01415811f, -0.01097890f, 
    0.09579574f, 0.14675070f, 0.01398285f, 0.05696157f, -0.24905458f, -0.01202352f, -0.09693738f, 0.25534981f, 
    -0.19194061f, -0.07930034f, -0.03005881f, 0.12722430f, 0.03895160f, -0.01928599f, 0.01541257f, -0.01513674f, 
    0.04180840f, 0.18450610f, -0.22431360f, 0.13432595f, -0.02229759f, -0.07055125f, 0.02548209f, -0.03647814f, 
    -0.10140595f, 0.07874758f, 0.00800570f, -0.00111068f, 0.11715329f, 0.04121616f, 0.06323751f, -0.28189111f, 
    -0.12384722f, -0.02492210f, 0.02345200f, 0.03807240f, -0.01728821f, -0.03094645f, -0.06268574f, -0.05959985f, 
    0.23870607f, 0.05147104f, -0.09924182f, -0.03295414f, -0.08941519f, 0.36254203f, 0.24247846f, 0.05377532f, 
    0.11685500f, 0.29048812f, 0.03377835f, 0.10042749f, -0.21831197f, -0.14500718f, 0.16194582f, 0.04093291f, 
    -0.04614141f, -0.04224391f, -0.02971248f, -0.02870576f, -0.20515327f, 0.02236105f, 0.00932048f, 0.30120683f, 
    -0.31119761f, 0.36902738f, -0.56978822f, -0.11409403f, -0.09680038f, 0.16675507f, 0.06060352f, -0.17887114f, 
    0.03214240f, 0.00776683f, 0.05081994f, -0.13063969f, -0.13803875f, 0.02489750f, -0.20977388f, -0.02848319f, 
    0.07816762f, 0.09343211f, -0.05519381f, -0.07319795f, -0.04220684f, -0.16939297f, 0.04196157f, 0.02829125f, 
    0.17672557f, -0.20863138f, 0.05595991f, 0.42508700f, -0.11972674f, -0.02657540f, -0.06373333f, 0.00987336f, 
    -0.01167878f, -0.00596508f, 0.03430077f, 0.01761921f, -0.02812986f, -0.14054187f, -0.13860621f, 0.29761636f, 
    0.04614686f, 0.00010105f, -0.00452298f, 0.18541397f, 0.05298646f, 0.16274503f, 0.07158866f, 0.04053660f, 
    -0.15012565f, 0.05232492f, 0.77395147f, -0.07625513f, -0.06376614f, -0.00108706f, -0.14014833f, 0.00009665f, 
    0.05746813f, -0.11857946f, 0.05543881f, 0.01664336f, 0.20830470f, -0.05616891f, -0.20545702f, 0.09968788f, 
    0.03426178f, -0.10596182f, 0.13278225f, 0.09474362f, -0.05446358f, 0.02485307f, 0.10000216f, 0.10037670f, 
    0.33756191f, 0.14271960f, 0.06299758f, 0.01423991f, -0.03938443f, 0.13496055f, 0.17060965f, 0.01569755f, 
    -0.05884004f, 0.10738704f, -0.12844437f, 0.00847648f, -0.14705755f, 0.06700692f, 0.46336368f, -0.29104847f, 
    -0.23055072f, 0.00977977f, 0.03481407f, 0.10723738f, -0.06701726f, -0.03635426f, 0.06785157f, 0.05119612f, 
    0.12433041f, 0.13480119f, 0.30979639f, -0.24363509f, -0.03876264f, 0.06279623f, -0.09967814f, -0.02504157f, 
    0.12221008f, -0.01682220f, 0.02050076f, -0.21051879f, -0.14031397f, -0.24711384f, 0.08519278f, 0.37200996f, 
    -0.13848065f, -0.04788397f, -0.06600589f, -0.07860040f, 0.10335061f, 0.12756790f, -0.03391325f, 0.09992378f, 
    0.11646920f, -0.07103565f, 0.15631965f, -0.03077450f, -0.01343545f, 0.02645487f, -0.07666816f, 0.11848079f, 
    -0.04507952f, 0.12278566f, -0.19060332f, 0.12305705f, 0.02603533f, 0.26524273f, 0.09898271f, -0.12431417f, 
    -0.08597434f, -0.04183717f, 0.21218210f, 0.18669342f, 0.02656477f, 0.05149464f, 0.06469215f, 0.01009729f, 
    0.21127047f, -0.07721491f, -0.14540176f, -0.08517771f, 0.01067999f, -0.12455550f, -0.02542149f, 0.09171795f, 
    -0.00600479f, 0.06415962f, 0.04908603f, 0.17153676f, -0.03778027f, -0.01473524f, -0.08434695f, -0.01770678f, 
    -0.01068565f, 0.08156873f, -0.02979633f, 0.09404554f, -0.04035350f, 0.07159179f, -0.01487987f, -0.06199551f, 
    -0.18198754f, -0.02779068f, 0.08990140f, -0.16193239f, -0.16569754f, 0.13257994f, 0.06645709f, -0.05594199f, 
    0.08845429f, 0.15496793f, -0.11360691f, 0.02545770f, 0.04360790f, -0.34994718f, -0.18475050f, -0.08454391f, 
    -0.00212449f, 0.00384934f, 0.16202080f, 0.07921549f, -0.22122762f, 0.14351450f, -0.04638693f, 0.10273816f, 
    -0.42358083f, 0.22002491f, -0.38983005f, -0.09419742f, -0.19693702f, 0.28421491f, -0.09350981f, -0.06582866f, 
    0.12422846f, -0.18455669f, 0.02958081f, -0.06193947f, -0.30585030f, -0.30717626f, 0.10938404f, 0.30956730f, 
    -0.05051535f, 0.12569976f, -0.02846897f, 0.05011863f, 0.16400884f, -0.03034883f, 0.10716149f, 0.18297067f, 
    0.44542935f, 0.03284707f, 0.04974448f, 0.20597884f, -0.05241358f, 0.20449150f, -0.05288218f, 0.11633710f, 
    0.00672603f, 0.04126257f, -0.00326265f, -0.05509129f, 0.04129558f, 0.10847972f, 0.02398125f, 0.18804529f, 
    -0.11638133f, 0.08623999f, -0.19826657f, 0.08492533f, -0.06670152f, -0.01167859f, -0.01532925f, -0.07625993f, 
    -0.00528017f, -0.17846224f, 0.41692588f, -0.34308207f, 0.03222003f, -0.00365942f, -0.11151188f, 0.08584101f, 
    0.01338758f, -0.09605256f, -0.01307403f, -0.14671332f, -0.00340912f, 0.05409753f, -0.06825402f, 0.08811720f, 
    0.08214519f, 0.16570637f, 0.02190201f, 0.00962255f, -0.16188766f, 0.01999639f, -0.00316255f, -0.02948489f, 
    -0.00624641f, 0.43302751f, 0.27924979f, 0.12958184f, -0.16206616f, 0.03603181f, 0.17993665f, 0.13708666f, 
    0.05495191f, -0.01188979f, -0.16292326f, -0.05849928f, -0.35474202f, -0.10086671f, 0.14998347f, -0.26320162f, 
    -0.06824533f, -0.00796014f, 0.00442516f, 0.08267498f, -0.03465367f, -0.09796585f, 0.13553570f, 0.09464937f, 
    0.04476418f, -0.00498110f, -0.10391004f, -0.29421559f, -0.01972313f, 0.08440402f, 0.05687794f, 0.06122232f, 
    -0.05304809f, -0.11306529f, 0.09762947f, -0.11325206f, 0.19508903f, -0.03114218f, -0.21725987f, -0.15750456f, 
    -0.03181542f, -0.07515340f, -0.11526095f, 0.08986188f, -0.01905088f, 0.05692296f, -0.00411430f, -0.03560680f, 
    0.01249703f, 0.00289657f, -0.00739689f, -0.03147139f, -0.04730824f, -0.07502094f, -0.05871322f, -0.04809351f, 
    -0.01906175f, -0.03849132f, -0.03718339f, 0.02079922f, 0.03404985f, 0.02431382f, -0.08268692f, -0.09173290f, 
    -0.07434271f, -0.05135990f, 0.01958225f, -0.06197595f, 0.01200736f, 0.00330133f, -0.05242580f, 0.04109199f, 
    -0.05932030f, -0.02781908f, -0.04885594f, 0.03353874f, -0.06014833f, 0.00856020f, -0.04618984f, -0.06923419f, 
    -0.02395182f, -0.02872219f, -0.09419467f, -0.04194995f, -0.01854166f, -0.04106317f, 0.03743278f, 0.03947977f, 
    0.03240266f, -0.03888113f, 0.01306991f, -0.02824487f, -0.05924078f, -0.00817113f, -0.04103391f, -0.06598061f, 
    -0.00773779f, -0.02089240f, 0.01010351f, -0.09464132f, -0.04469114f, -0.00402609f, 0.00563314f, 0.03859602f, 
    -0.04517557f, 0.00446856f, 0.02357141f, 0.01553768f, 0.02072002f, -0.04340196f, 0.06619728f, 0.00459256f, 
    -0.06483012f, -0.07655583f, -0.03560723f, 0.00324008f, 0.02875201f, 0.01983187f, -0.08597248f, -0.02717456f, 
    -0.05017845f, -0.08079537f, -0.02016447f, -0.04045716f, 0.02228052f, -0.01888362f, -0.05105917f, -0.08777110f, 
    -0.06509530f, 0.00884532f, -0.08195382f, 0.02926902f, -0.04841691f, -0.01586449f, -0.04127525f, -0.03966279f, 
    -0.08690119f, -0.06341340f, -0.02734616f, 0.06338144f, -0.02404836f, -0.06317011f, -0.08185539f, -0.03013642f, 
    -0.02189581f, 0.01184936f, -0.09431066f, -0.05556357f, 0.04277079f, 0.01952377f, 0.00656742f, 0.00148693f, 
    -0.06534977f, -0.03486572f, -0.05123039f, -0.03052633f, 0.00841200f, -0.03462964f, -0.04191421f, -0.03504138f, 
    -0.07048673f, -0.06634910f, 0.03524505f, -0.08427324f, 0.02153609f, -0.04736771f, -0.03642996f, -0.02129263f, 
    0.00740615f, -0.07176016f, -0.02698616f, -0.08408974f, -0.07010058f, 0.01960437f, 0.03096010f, -0.07083210f, 
    -0.00919285f, -0.06296765f, -0.08779691f, -0.07739642f, -0.02399955f, 0.06826877f, -0.03592630f, 0.04521762f, 
    -0.08265036f, 0.04374386f, -0.01721037f, -0.00763950f, 0.01422034f, -0.08334022f, -0.03811784f, 0.03322534f, 
    -0.03203622f, -0.03466247f, -0.06535362f, -0.01185690f, -0.00113846f, -0.07532822f, -0.02502844f, 0.04750782f, 
    -0.03358370f, 0.01848794f, -0.07836297f, -0.03936529f, 0.01600715f, 0.07146341f, -0.08110918f, -0.07903884f, 
    -0.03152667f, 0.03885190f, 0.02501928f, -0.07698605f, -0.03963403f, -0.04525449f, -0.03247751f, -0.07270354f, 
    -0.07092936f, -0.00293971f, 0.04022378f, -0.08560139f, -0.01254174f, -0.08736134f, -0.08920695f, -0.01683859f, 
    -0.05891535f, -0.04093330f, -0.03604020f, -0.04224285f, -0.04189178f, -0.03768642f, 0.01731781f, 0.00180345f, 
    0.02424678f, -0.08481013f, -0.07633869f, -0.06081438f, -0.02806687f, -0.09297099f, -0.00966515f, -0.04965603f, 
    0.00015897f, -0.05562473f, -0.03612939f, 0.03714140f, 0.05629499f, 0.05155335f, -0.00887872f, -0.02251887f, 
    -0.05615488f, -0.07722332f, 0.01596552f, 0.00722865f, 0.04144102f, 0.01270845f, 0.00378493f, 0.03746748f, 
    -0.02068389f, 0.06047335f, 0.05314251f, 0.03618989f, 0.03253169f, -0.05580340f, 0.05308165f, -0.00594441f, 
    -0.05944276f, 0.03237604f, -0.06884462f, 0.00270928f, -0.02344051f, 0.05178246f, 0.05274404f, -0.01106672f, 
    0.01031340f, -0.03341348f, -0.06107857f, -0.05768320f, -0.03440000f, -0.01415065f, 0.02392971f, -0.05479594f, 
    0.02473188f, -0.03613849f, -0.04217642f, -0.07499638f, -0.05181836f, 0.04244633f, -0.06550529f, -0.05641055f, 
    0.05554456f, 0.03265319f, 0.04530535f, 0.00821470f, -0.01076426f, -0.00146705f, 0.05078489f, -0.02459287f, 
    -0.01198860f, 0.04063204f, -0.01589920f, -0.04467562f, -0.04798248f, 0.06585018f, -0.03107328f, 0.00694734f, 
    -0.03120094f, 0.05508252f, 0.05297141f, 0.00088494f, -0.01338484f, -0.07379406f, -0.01895430f, -0.07797354f, 
    -0.02496221f, 0.01257449f, -0.04518289f, 0.03529865f, -0.06323124f, -0.01251219f, -0.05610912f, 0.06081354f, 
    0.01374216f, -0.00186622f, -0.06542888f, -0.02896798f, 0.03959348f, -0.05936028f, -0.02556956f, 0.05828051f, 
    -0.05437509f, -0.03768704f, -0.02242498f, -0.03446102f, -0.02770400f, 0.01772589f, 0.00148848f, -0.04282608f, 
    -0.06032631f, 0.00890955f, 0.05038174f, 0.05174556f, 0.03018265f, 0.06124546f, -0.06150228f, -0.07928772f, 
    -0.04611946f, 0.03412479f, 0.03845132f, -0.04187595f, 0.03483765f, -0.07296305f, 0.04303681f, 0.02274955f, 
    0.00130616f, 0.00485514f, -0.05713816f, -0.02037640f, -0.07967462f, -0.01668502f, -0.00307373f, -0.05621540f, 
    0.02966863f, -0.01006458f, -0.00878590f, 0.06343243f, -0.00388837f, -0.06522591f, -0.06542060f, 0.05131306f, 
    -0.05336275f, 0.02044499f, 0.02169228f, 0.03359032f, 0.05006064f, 0.04083292f, 0.05112999f, 0.00293008f, 
    0.02572405f, 0.03672365f, -0.07808113f, 0.03788922f, 0.01901504f, -0.04790900f, -0.03278119f, 0.02477118f, 
    0.03094842f, -0.00887547f, -0.02885355f, 0.03606298f, -0.06615130f, 0.02804576f, -0.06774881f, -0.06827650f, 
    -0.03493204f, 0.05947668f, -0.00297845f, -0.05647860f, -0.06008009f, -0.01338067f, -0.02750154f, -0.07809523f, 
    -0.03445797f, -0.07081693f, -0.01113760f, -0.01070456f, -0.07137000f, -0.07280835f, -0.05301517f, 0.02426836f, 
    -0.05538650f, 0.01324249f, -0.04565408f, -0.04271215f, 0.02548310f, -0.04472428f, -0.01733333f, 0.03061291f, 
    0.04514073f, -0.07752603f, -0.05538663f, -0.01330031f, 0.03638832f, -0.03780187f, -0.08184231f, -0.06368679f, 
    -0.07924148f, 0.05553376f, 0.01524447f, -0.08345138f, 0.05879032f, 0.03030413f, -0.00198149f, 0.01277995f, 
    0.06103611f, 0.11777903f, 0.08763301f, 0.08283196f, 0.08786460f, 0.00126001f, -0.02725096f, -0.05276169f, 
    -0.11107646f, -0.06038696f, 0.11509611f, -0.16066848f, 0.08667366f, 0.27329510f, 0.19109425f, 0.23831718f, 
    -0.05747567f, 0.20622264f, 0.05226207f, 0.16744852f, -0.05020435f, 0.08457026f, -0.01311004f, -0.11509033f, 
    0.07277013f, 0.11652293f, -0.20054452f, -0.06964770f, -0.16279376f, -0.09600043f, 0.01206928f, -0.04750933f, 
    -0.10174409f, -0.10261808f, -0.03427729f, 0.07256288f, -0.30335379f, -0.22460721f, -0.12727933f, -0.00098227f, 
    -0.09071681f, 0.02682548f, 0.06134253f, -0.10360219f, 0.07182009f, -0.01714899f, 0.05145763f, 0.03002830f, 
    0.02314838f, -0.20762551f, -0.11575918f, -0.16356243f, -0.02235007f, 0.15273181f, -0.00417555f, -0.09731748f, 
    -0.10084224f, 0.11571522f, -0.17143689f, -0.05709466f, -0.35487014f, -0.27167705f, -0.00009692f, -0.17307675f, 
    0.05512107f, -0.02826206f, 0.03602273f, -0.08009121f, -0.29145053f, 0.04926836f, -0.12939921f, -0.07448734f, 
    -0.61129028f, 0.48433924f, 0.03694464f, -0.13314810f, -0.16178530f, -0.00298263f, 0.06709863f, -0.06691398f, 
    -0.13164046f, 0.03647649f, -0.06358545f, -0.03252884f, -0.30023301f, 0.23838124f, -0.04399489f, 0.09492724f, 
    0.02845976f, 0.08525783f, -0.00253085f, 0.02911811f, 0.00176812f, -0.03967303f, -0.08375319f, -0.17289965f, 
    0.62721831f, 0.23285228f, 0.11846538f, 0.32514340f, 0.03944493f, 0.18145581f, 0.13731505f, 0.02876885f, 
    -0.00238175f, 0.05608029f, 0.01634992f, -0.06696102f, 0.11819766f, 0.34319416f, 0.03012199f, 0.32230946f, 
    -0.13002810f, 0.10133714f, -0.02644314f, 0.09179611f, 0.01887704f, 0.04666894f, 0.21152782f, -0.14332622f, 
    -0.07422550f, -0.33067489f, 0.23293683f, -0.24240388f, 0.10664312f, 0.18081437f, 0.04823875f, -0.19059147f, 
    0.00325032f, 0.04979600f, 0.09272528f, -0.09747975f, 0.31585535f, 0.17757225f, 0.24838436f, -0.00160697f, 
    -0.14130992f, 0.08867152f, 0.03552407f, -0.02182447f, -0.14454550f, 0.10239248f, -0.01346442f, 0.13917533f, 
    0.29953721f, 0.31959698f, 0.16325177f, -0.17906204f, 0.09393007f, 0.14025617f, 0.19621857f, 0.05261159f, 
    -0.12432635f, 0.16319658f, 0.02303282f, 0.10797619f, -0.86771601f, -0.38644660f, 0.13403347f, -0.38580352f, 
    -0.05300084f, -0.02809245f, -0.19672596f, -0.05858990f, -0.02787524f, 0.04184658f, 0.15652268f, 0.16122828f, 
    -0.13774429f, -0.30266392f, 0.10187975f, -0.37735903f, -0.01787472f, 0.09388486f, -0.06156259f, -0.14576510f, 
    -0.00531964f, -0.11486638f, -0.04426601f, -0.00017864f, 0.12239829f, -0.15954633f, -0.12454991f, 0.26139766f, 
    0.13622443f, -0.06264377f, 0.01080327f, 0.10770287f, -0.04677065f, -0.04212015f, 0.02863933f, 0.07994633f, 
    0.05604239f, -0.32681954f, 0.06068462f, 0.04096893f, 0.00199876f, -0.20942973f, -0.18235180f, 0.13363449f, 
    -0.00768432f, 0.07571059f, -0.05257565f, 0.19168875f, 0.31717089f, 0.21162827f, 0.12615295f, -0.02306609f, 
    0.00096664f, 0.15524521f, 0.06284633f, 0.20331268f, 0.04847241f, -0.04956495f, -0.00149618f, 0.00648668f, 
    0.43014559f, -0.10132004f, 0.11529385f, 0.21054277f, 0.13710119f, -0.06285017f, -0.11417367f, 0.14062658f, 
    0.13163605f, 0.30334720f, 0.11645493f, 0.26167932f, -0.42070785f, -0.10910092f, -0.33228949f, 0.03278247f, 
    0.22003612f, -0.01858536f, -0.08200675f, 0.22896066f, -0.16154270f, -0.36347446f, -0.39123178f, -0.53195685f, 
    -0.72959232f, 0.15235475f, 0.39404073f, 0.03372675f, 0.02308565f, -0.40177685f, -0.12400669f, 0.10854319f, 
    0.05197468f, -0.14390741f, -0.25327313f, -0.28575701f, 0.02139975f, -0.15429646f, -0.23246382f, 0.55304402f, 
    0.03569382f, -0.16933233f, 0.21041122f, -0.19215514f, -0.10059888f, 0.03173678f, 0.16040210f, -0.00327456f, 
    0.03657820f, 0.13725954f, 0.06434990f, -0.28726962f, -0.23367630f, -0.14089581f, 0.02640008f, -0.16901341f, 
    -0.20521927f, -0.10292685f, 0.07577274f, -0.25727752f, 0.17185283f, -0.34218290f, 0.10427541f, -0.00045411f, 
    -0.35138437f, -0.03600981f, -0.21069503f, -0.08439428f, 0.18966267f, 0.21591084f, 0.21387330f, 0.32878244f, 
    0.24430358f, 0.03804996f, -0.16013514f, -0.12081145f, -0.05079414f, 0.18095227f, 0.11174442f, 0.04554506f, 
    0.14207993f, 0.11248689f, 0.18543254f, 0.12361422f, 0.23329172f, 0.12014384f, 0.17147546f, -0.11046711f, 
    -0.04811157f, 0.00747190f, -0.10639263f, -0.06519689f, 0.06387834f, 0.04392105f, 0.03965493f, -0.09224164f, 
    -0.14099610f, -0.35324979f, -0.68706280f, 0.47266963f, 0.02909998f, -0.07589731f, 0.12815870f, -0.02337316f, 
    -0.04817259f, -0.01537037f, -0.02979409f, -0.05100526f, -0.47370389f, 0.01897002f, -0.13135678f, 0.04472862f, 
    -0.03652016f, 0.37638929f, 0.14194052f, -0.16028716f, -0.20514038f, -0.41423252f, -0.13454740f, -0.61823237f, 
    0.23856808f, 0.20276597f, 0.19546002f, 0.02301868f, -0.20115176f, 0.07532757f, -0.07115029f, -0.07519504f, 
    0.15755694f, 0.07111833f, 0.01254894f, -0.04420952f, -0.06478592f, -0.26628631f, -0.17130160f, 0.16506666f, 
    -0.00382882f, 0.14258648f, 0.32067120f, -0.05939592f, -0.00038825f, -0.29978946f, -0.09605313f, -0.22240865f, 
    -0.19784193f, -0.32216471f, -0.06862745f, -0.05474980f, -0.18101719f, -0.01168584f, -0.00771064f, 0.15405184f, 
    -0.08875230f, -0.20911400f, -0.07865738f, -0.31410053f, 0.36949381f, 0.22143640f, 0.03401216f, 0.14544994f, 
    0.26753077f, 0.06013347f, -0.01124102f, 0.21837734f, 0.09727287f, 0.20083708f, 0.05367552f, -0.10973693f, 
    -0.06813453f, 0.02262353f, -0.04366831f, -0.02520732f, -0.02350562f, 0.04887947f, -0.05288629f, 0.00927193f, 
    -0.05800119f, 0.01080761f, -0.00115782f, 0.00019937f, 0.04857445f, 0.05284829f, 0.02534323f, -0.01261991f, 
    -0.01137448f, -0.06143006f, -0.06165994f, 0.05665419f, -0.02774581f, -0.06319288f, -0.03606808f, -0.05766099f, 
    -0.03224393f, -0.00446270f, -0.06179770f, -0.06249702f, -0.02378470f, -0.06614736f, -0.03759849f, -0.00323921f, 
    -0.01131243f, -0.04368630f, 0.02520216f, -0.05364243f, 0.00922775f, -0.05429568f, 0.04800450f, -0.06400622f, 
    0.04274952f, 0.00809611f, 0.02310416f, 0.05611234f, 0.02758598f, 0.05217062f, -0.04585590f, -0.03741929f, 
    0.04979070f, 0.01219091f, -0.02748073f, 0.00142312f, -0.04895880f, -0.03200417f, 0.06161638f, -0.02908023f, 
    0.00616713f, -0.05268108f, -0.06444181f, -0.05691916f, -0.05751513f, 0.01270202f, -0.04342622f, 0.00595084f, 
    -0.04823745f, -0.03865396f, 0.05182245f, 0.03505550f, -0.01808427f, -0.07803117f, -0.06668787f, -0.06268909f, 
    -0.02855055f, -0.06834703f, -0.00221977f, 0.00187712f, -0.04436350f, -0.03156211f, 0.04884858f, -0.02692375f, 
    0.06201333f, 0.06082602f, -0.02696704f, 0.03031728f, 0.02341268f, 0.04704294f, -0.06344972f, 0.02037836f, 
    0.00025466f, -0.03998120f, 0.04598355f, -0.05715602f, -0.02032346f, 0.02366060f, 0.03658057f, 0.00889155f, 
    0.05363112f, -0.00739939f, -0.01073084f, 0.01315750f, 0.02060419f, 0.00287739f, 0.03356519f, 0.03529313f, 
    -0.02126327f, 0.06255703f, 0.02145717f, -0.02703819f, 0.01283277f, -0.02424702f, 0.05332795f, -0.00254533f, 
    -0.01437006f, -0.05596090f, -0.07313071f, -0.02791825f, -0.07062206f, 0.01281496f, -0.05029264f, -0.01548330f, 
    0.04345768f, 0.02469533f, 0.01008974f, -0.01043595f, 0.00372941f, 0.01379568f, -0.04552950f, -0.03274972f, 
    0.02347180f, -0.03102938f, 0.01986785f, -0.03956895f, -0.01553131f, -0.05250897f, -0.06853000f, 0.01763757f, 
    -0.03465578f, 0.05939685f, 0.00417743f, 0.00158481f, -0.03664188f, -0.04584638f, 0.00407084f, -0.01985626f, 
    -0.03205761f, -0.01273899f, -0.03723623f, -0.03952846f, -0.06184960f, 0.01972437f, 0.03323637f, -0.02645917f, 
    -0.00783467f, -0.05338928f, -0.00039964f, -0.02984261f, -0.04274562f, 0.04561659f, -0.04584000f, -0.05309737f, 
    0.01339564f, -0.05878852f, 0.05320663f, 0.04719725f, 0.04445148f, 0.03805837f, -0.07193610f, 0.04400273f, 
    -0.04034849f, -0.03701966f, -0.05793155f, -0.04415630f, -0.07528931f, -0.02440451f, -0.01661777f, 0.01542684f, 
    0.05201760f, 0.01184773f, 0.00664818f, 0.04806161f, -0.05032856f, -0.04267970f, 0.00581673f, -0.01329969f, 
    0.02056614f, -0.04095497f, 0.03255554f, -0.05343710f, -0.01566117f, 0.03670454f, 0.04249056f, 0.00564414f, 
    -0.03759523f, 0.00462055f, -0.04121286f, 0.04223962f, -0.04982681f, 0.06238264f, -0.03103222f, -0.01835112f, 
    0.05653212f, -0.05267202f, -0.06368055f, 0.05719387f, -0.06548933f, 0.06242058f, -0.05696894f, -0.05529068f, 
    0.02284812f, -0.05999116f, 0.00282274f, 0.01869624f, -0.00584768f, 0.02626340f, -0.01209919f, -0.02312596f, 
    0.04925771f, 0.01027501f, -0.04683351f, -0.06061646f, 0.06543574f, -0.05521205f, 0.06200359f, 0.06571052f, 
    0.04229421f, -0.06644328f, -0.05823363f, 0.00325167f, 0.06729444f, -0.05951969f, -0.01427741f, -0.05353310f, 
    0.02901628f, -0.02472064f, 0.01378773f, 0.04336130f, -0.01023967f, -0.06651898f, 0.05518434f, 0.01262815f, 
    0.02250303f, -0.07112360f, -0.01382329f, 0.02437183f, -0.05382252f, -0.07677931f, -0.05522987f, -0.00335176f, 
    -0.04672756f, -0.00904175f, -0.01448278f, 0.02288395f, -0.07095749f, -0.02186780f, 0.05219151f, 0.00487082f, 
    -0.04677394f, -0.02840214f, 0.05176674f, -0.03817621f, -0.07735384f, 0.05575835f, -0.05701224f, 0.04859602f, 
    -0.01710626f, 0.01375193f, 0.05025112f, -0.00241825f, 0.00845365f, 0.04391649f, 0.05286558f, 0.04273025f, 
    -0.07111693f, 0.04221532f, -0.02742871f, -0.05859428f, 0.06379409f, -0.03028151f, -0.00995475f, 0.00208387f, 
    -0.05539925f, 0.02136261f, -0.01113112f, 0.03924840f, -0.04605746f, -0.07263559f, 0.05679112f, -0.07037549f, 
    -0.02444785f, 0.01767688f, -0.04712337f, 0.02102739f, -0.05391537f, -0.00002315f, -0.03895528f, 0.06330901f, 
    -0.07434936f, 0.02488003f, 0.00476407f, -0.02894572f, -0.07613099f, 0.02418734f, -0.06745555f, -0.03277731f, 
    -0.04879198f, -0.04244497f, 0.01082405f, 0.00516387f, 0.01693764f, 0.01120941f, -0.03239333f, -0.06388406f, 
    -0.04278899f, -0.02953416f, 0.00570890f, -0.05936114f, 0.04712678f, -0.05798321f, -0.04045023f, -0.04901120f, 
    -0.05612297f, -0.02895071f, -0.04184465f, -0.05968636f, -0.07399993f, -0.00457675f, -0.03959569f, 0.03825986f, 
    0.04160655f, 0.03185968f, -0.04474999f, -0.07710741f, -0.07500636f, -0.06071461f, -0.04087767f, 0.00379706f, 
    0.00475553f, -0.00962823f, 0.05580170f, -0.05522625f, 0.00768583f, 0.04296499f, -0.05778490f, 0.00560219f, 
    -0.02807897f, -0.01786388f, 0.04977151f, -0.05722109f, 0.02044367f, -0.06999746f, 0.02357559f, 0.02623086f, 
    -0.04827646f, -0.03183430f, 0.01180029f, -0.04150273f, -0.04605260f, 0.00581112f, 0.04235855f, 0.01475525f, 
    0.06428839f, 0.01726590f, 0.05329632f, -0.06179291f, -0.04616738f, 0.00451540f, -0.05430220f, -0.03572155f, 
    -0.04851608f, -0.00117600f, 0.01036709f, -0.05918628f, 0.06595314f, -0.04466315f, -0.01301217f, 0.01874369f, 
    0.05204620f, -0.02967639f, 0.02481380f, 0.01539221f, 0.05090205f, -0.01469355f, -0.07327250f, -0.00828247f, 
    -0.00173933f, 0.06560825f, 0.15193580f, -0.01573346f, -0.06043928f, -0.24049485f, -0.11373023f, -0.07727657f, 
    -0.10007451f, -0.03245787f, 0.16964447f, 0.12718701f, -0.07091165f, 0.15219933f, -0.27071425f, -0.27292040f, 
    0.07860642f, -0.07018501f, -0.01248790f, 0.07866774f, -0.01785940f, 0.06467050f, -0.13196072f, -0.30708194f, 
    0.25227714f, 0.17703594f, 0.05026635f, 0.01488441f, -0.14425604f, 0.19742966f, 0.07647845f, 0.23265246f, 
    -0.03820756f, 0.11381098f, 0.09047572f, 0.15510590f, -0.13144580f, -0.00551258f, 0.01407643f, -0.10948852f, 
    0.05805126f, -0.06423081f, 0.20541592f, -0.06826615f, -0.14004147f, -0.11720903f, 0.09466216f, -0.03119180f, 
    -0.26437107f, -0.07283565f, -0.10252992f, 0.16050270f, -0.04664887f, -0.27397445f, -0.04885211f, -0.10739378f, 
    -0.00958691f, 0.12221820f, -0.10674561f, -0.13771954f, 0.00676118f, -0.08211656f, 0.40661377f, 0.13109332f, 
    -0.02567316f, -0.25663912f, 0.04728130f, -0.10826854f, -0.25250491f, -0.02506098f, -0.04565814f, 0.05746515f, 
    -0.11971575f, 0.21341899f, 0.14616543f, -0.04930443f, 0.10317046f, -0.03884506f, 0.31408870f, -0.12514441f, 
    0.00849945f, 0.03135999f, 0.04414226f, -0.14525151f, 0.35030454f, 0.04828325f, -0.02514893f, 0.30260941f, 
    0.02563391f, -0.10194227f, 0.03543478f, -0.20798518f, 0.16277829f, 0.11948833f, 0.27954441f, 0.14536837f, 
    0.40053746f, 0.11172177f, -0.24221110f, -0.16249095f, -0.07481872f, 0.18841831f, 0.10261215f, 0.34375244f, 
    0.03835121f, 0.08192603f, 0.09140854f, -0.04389463f, 0.10021078f, 0.11329035f, -0.07484791f, 0.02267621f, 
    0.10659330f, -0.05039956f, 0.11019018f, -0.02351113f, -0.04041809f, -0.07002529f, 0.03043795f, -0.01002126f, 
    -0.21153343f, 0.02430140f, 0.28872323f, 0.03995381f, -0.07964522f, 0.08580096f, -0.09433679f, -0.13650088f, 
    -0.15285677f, 0.00589414f, 0.09150305f, 0.00948065f, 0.10200869f, -0.02932592f, 0.05438143f, -0.18899304f, 
    -0.14652614f, 0.12307031f, -0.22520660f, 0.02738274f, -0.09460171f, -0.00710829f, 0.05006703f, -0.10595936f, 
    0.57711852f, 0.22582120f, 0.18218210f, -0.17173387f, 0.07570722f, -0.03541834f, 0.13341117f, -0.01067204f, 
    0.02581801f, 0.10818670f, -0.08214111f, 0.17750944f, -0.41789019f, 0.02940105f, 0.01351450f, 0.07731491f, 
    0.02526513f, -0.05802355f, -0.20506084f, -0.17803890f, -0.15175551f, 0.12763536f, -0.12749715f, 0.08955877f, 
    -0.01639181f, 0.12610973f, -0.00464861f, -0.21118613f, -0.07455295f, 0.11009833f, 0.11797751f, 0.01346378f, 
    -0.13861917f, -0.08972886f, 0.06657705f, -0.01164872f, 0.07229767f, -0.05270543f, -0.10148669f, -0.01948271f, 
    0.03553047f, 0.01630887f, -0.00175886f, 0.18225528f, 0.09759151f, 0.06421259f, -0.00777757f, -0.04123731f, 
    0.28831995f, -0.02609728f, 0.02020223f, -0.26008174f, -0.03962795f, 0.01674110f, -0.07408412f, 0.08703382f, 
    -0.02560281f, -0.02475077f, -0.07557002f, 0.06319485f, 0.14450954f, 0.26556444f, -0.06374520f, -0.06939053f, 
    0.10379584f, 0.03831826f, 0.05064953f, 0.12336223f, -0.03893849f, 0.09732091f, -0.03697143f, 0.12538414f, 
    0.10572678f, -0.32259449f, 0.06486469f, 0.11154193f, 0.15194695f, 0.10928886f, -0.11158007f, -0.02295879f, 
    -0.00143292f, 0.05142007f, 0.00079008f, 0.02049522f, -0.10053007f, -0.30341804f, -0.32255250f, 0.10176098f, 
    0.04250135f, 0.14097019f, 0.11167897f, -0.05370140f, -0.04896755f, -0.08754084f, -0.02714933f, 0.05111296f, 
    -0.27525690f, -0.08653225f, 0.32229972f, 0.14102949f, -0.04884037f, -0.23059332f, 0.03140271f, 0.09969058f, 
    -0.06148106f, 0.10507231f, -0.03926893f, -0.04072519f, 0.31306863f, -0.17079988f, 0.01888471f, 0.01870197f, 
    -0.12494275f, -0.04994110f, 0.06790438f, -0.02213927f, 0.05689053f, -0.04384369f, 0.20758699f, 0.07477893f, 
    -0.10874636f, -0.03967437f, 0.38247877f, 0.26123184f, 0.01523572f, 0.12930585f, -0.07072462f, 0.05907033f, 
    0.18758154f, -0.10101084f, 0.09565108f, 0.13999604f, 0.09938474f, 0.03328757f, 0.36385715f, 0.23161301f, 
    -0.11032205f, 0.02864685f, -0.19927701f, 0.12922235f, 0.20608979f, 0.03778702f, 0.05423300f, 0.02743179f, 
    0.06992937f, 0.12111877f, -0.07663687f, -0.26120895f, 0.00217689f, 0.08921460f, 0.07338174f, -0.00989334f, 
    0.07831900f, -0.00335876f, -0.01223720f, 0.05083267f, -0.01165712f, 0.21283051f, 0.26757312f, -0.08349064f, 
    -0.00184633f, 0.04364824f, 0.04191877f, -0.03658979f, -0.04747253f, -0.09685487f, -0.15074754f, -0.03451456f, 
    0.18346497f, 0.02603864f, -0.42685351f, -0.06145934f, 0.00383919f, -0.13064191f, 0.30028167f, 0.03954217f, 
    0.02620886f, 0.06661797f, -0.16452616f, 0.07984463f, -0.38042727f, -0.04657625f, 0.01687683f, -0.00505044f, 
    0.07544118f, 0.06168487f, 0.21795398f, -0.11969186f, 0.00118897f, -0.12270246f, -0.10426405f, 0.04449669f, 
    -0.13671345f, 0.51545507f, 0.34038037f, 0.22350846f, -0.17455141f, -0.18291557f, -0.06165172f, -0.00684462f, 
    0.13865167f, 0.01621080f, 0.05350810f, -0.01204779f, -0.05394182f, -0.15033948f, -0.34487084f, 0.22493534f, 
    -0.02917530f, 0.21157026f, 0.16728395f, 0.06443638f, -0.06946208f, -0.23188849f, 0.13678092f, -0.05177703f, 
    -0.16685022f, -0.11588392f, -0.13155393f, 0.16965853f, -0.12613869f, 0.09015511f, 0.09971973f, -0.00997300f, 
    0.01356895f, -0.14585847f, 0.19244547f, -0.07598769f, 0.31975022f, -0.02667910f, 0.18290000f, -0.31328043f, 
    0.13467681f, 0.09717384f, -0.10739674f, 0.06794371f, -0.02621195f, -0.01409027f, 0.09500563f, -0.14687485f, 
    -0.30435699f, -0.02451629f, -0.21405354f, -0.19866414f, -0.08988047f, 0.06050740f, -0.13410129f, -0.09056690f, 
    -0.06173437f, 0.09234739f, -0.05133531f, -0.22309007f, 0.04367857f, 0.04718565f, -0.19290204f, 0.02857976f, 
    0.09453522f, 0.34577113f, 0.09756928f, 0.03687124f, 0.07763172f, -0.01191077f, -0.10444014f, -0.16355099f, 
    0.00852389f, 0.27211410f, 0.11699737f, 0.11333137f, -0.06434035f, -0.04259133f, -0.18856369f, -0.09795236f, 
    0.08113822f, -0.17790195f, -0.14645906f, 0.25796148f, 0.02542677f, -0.16055642f, -0.14525419f, -0.02706403f, 
    -0.14949176f, 0.03725423f, 0.12757242f, 0.00424429f, -0.05615230f, 0.12109385f, -0.04583357f, -0.03110291f, 
    -0.07609048f, -0.15826610f, 0.03989254f, -0.00074400f, 0.25105837f, 0.15332603f, 0.09773570f, -0.14048755f, 
    0.13951607f, 0.30228639f, -0.05321170f, 0.09504778f, 0.01336008f, -0.22713844f, -0.30304179f, -0.00386088f, 
    -0.11414795f, 0.06140754f, -0.06580688f, 0.04631234f, 0.03192285f, -0.06862239f, -0.07894430f, 0.23938274f, 
    -0.42166996f, 0.04562176f, 0.12236609f, 0.27759707f, 0.00162164f, 0.15141112f, 0.02243271f, -0.00844366f, 
    0.06460596f, -0.05458395f, -0.08477567f, 0.20525232f, -0.16696753f, 0.37550098f, 0.09045124f, 0.13581194f, 
    0.03367135f, 0.05433961f, -0.03449597f, -0.01816518f, -0.10747667f, -0.15897597f, -0.14181858f, -0.04288560f, 
    -0.12980992f, 0.29499701f, 0.16661511f, 0.12578812f, 0.09914605f, 0.08429314f, -0.16215725f, -0.02304839f, 
    0.06131183f, 0.02237581f, 0.02374586f, 0.10678572f, 0.07764278f, 0.15192994f, 0.02654835f, 0.15326785f, 
    0.11434598f, 0.23406132f, 0.32491615f, 0.08678802f, 0.06676503f, 0.03501924f, -0.08058813f, -0.16902661f, 
    -0.01252848f, 0.16696066f, 0.01853220f, -0.06535016f, -0.11301999f, -0.03502630f, -0.05602071f, 0.09368256f, 
    0.06091586f, -0.05702978f, -0.03322496f, -0.01159067f, 0.19211558f, 0.02037076f, 0.27565491f, -0.09339289f, 
    0.06423546f, -0.06530369f, 0.31056479f, 0.11050182f, 0.06860092f, -0.04372567f, -0.06072082f, 0.13126808f, 
    -0.00717216f, 0.26200080f, 0.30460680f, 0.38922244f, 0.22515352f, 0.05562742f, 0.04179984f, -0.09645040f, 
    -0.01460320f, -0.02433859f, -0.00071543f, 0.09483509f, -0.19888240f, -0.17580587f, 0.03658370f, 0.40473139f, 
    -0.11697506f, 0.11979093f, -0.25375101f, 0.02285547f, 0.04685546f, -0.06389219f, 0.04346069f, 0.01611240f, 
    -0.12720139f, -0.02592273f, -0.16372016f, 0.02633321f, -0.09620681f, -0.08130264f, 0.00964354f, 0.04476509f, 
    0.02116180f, 0.04844781f, 0.02974738f, 0.20302103f, -0.06083137f, 0.16572274f, 0.18153642f, -0.04923788f, 
    -0.02469412f, -0.11101476f, 0.07814889f, 0.19214426f, 0.00731381f, -0.08287702f, -0.07357323f, -0.08392162f, 
    0.11505278f, 0.15691243f, -0.02752025f, 0.15639766f, 0.01503266f, 0.07395058f, 0.02284243f, -0.15319562f, 
    0.05082727f, 0.05916356f, -0.00166844f, -0.00485944f, -0.12772095f, 0.07727364f, 0.09538484f, 0.46215877f, 
    -0.13205153f, 0.14368007f, 0.00306180f, 0.09928016f, -0.00774452f, -0.07555555f, 0.00970691f, 0.00909094f, 
    -0.04939868f, -0.05548819f, -0.01512408f, 0.13008992f, -0.09302270f, -0.05511340f, 0.00902964f, -0.04363638f, 
    0.01621236f, 0.07878484f, -0.04600624f, 0.00305429f, 0.28395796f, 0.01270893f, 0.17565399f, -0.08285898f, 
    -0.12312388f, 0.05122600f, -0.04026981f, -0.04598828f, -0.04463341f, -0.07003757f, 0.01596114f, -0.00205959f, 
    0.18837163f, -0.00680330f, 0.11414699f, -0.01587286f, -0.04935755f, 0.15463136f, 0.12346470f, -0.04941562f, 
    -0.08237062f, 0.11738399f, -0.17829011f, -0.05755563f, 0.24372496f, -0.04687912f, 0.06455167f, 0.13461189f, 
    0.09525990f, 0.03809712f, 0.08437514f, 0.04359349f, -0.10024395f, 0.08235828f, -0.00559216f, -0.01356143f, 
    -0.49217761f, 0.37690839f, -0.21239215f, -0.10911166f, -0.00678247f, 0.11029191f, 0.08112680f, 0.12441465f, 
    -0.16528392f, -0.17882800f, -0.07470980f, -0.06642386f, -0.42958567f, 0.16651714f, -0.01139464f, -0.07354096f, 
    0.10192537f, 0.12404714f, 0.07429438f, 0.01184462f, -0.09037303f, -0.06994650f, -0.18161878f, 0.21218435f, 
    0.06630208f, -0.15399620f, 0.25949416f, 0.44158399f, 0.04876261f, -0.10032783f, 0.00745469f, -0.12221873f, 
    -0.19467659f, 0.01823611f, 0.14211281f, -0.03791826f, -0.07247200f, -0.02866689f, -0.02595603f, 0.21016717f, 
    -0.29151893f, 0.17094520f, -0.28832185f, 0.02793297f, 0.28366354f, 0.05803183f, 0.11675568f, -0.10875385f, 
    0.48584396f, -0.06413755f, 0.30320361f, -0.09887367f, -0.00084591f, 0.02738433f, 0.12769321f, -0.10364954f, 
    0.11440918f, -0.04304945f, 0.11751459f, -0.02996613f, -0.02503321f, 0.01310969f, -0.04369057f, 0.04818480f, 
    0.01795285f, 0.03563573f, 0.37971494f, -0.19123407f, -0.14955427f, -0.14314598f, -0.06973165f, 0.00155476f, 
    -0.15918434f, 0.33086789f, 0.07455725f, -0.17966540f, -0.22929087f, 0.07405430f, 0.04689799f, 0.18660612f, 
    0.01846494f, -0.00621475f, -0.10122368f, -0.10266887f, 0.19983128f, -0.06596329f, 0.48307371f, -0.21292324f, 
    -0.22994210f, -0.10707446f, 0.09150648f, 0.14517823f, -0.10788712f, 0.08012830f, 0.07356299f, 0.01132982f, 
    0.23092905f, 0.06444349f, 0.23813431f, -0.05654019f, -0.07789002f, -0.02825416f, -0.04635783f, 0.06590427f, 
    0.08000339f, -0.04489530f, 0.05834181f, -0.06374176f, -0.09969036f, -0.06533222f, 0.08564438f, 0.22023511f, 
    0.13878751f, -0.02044266f, -0.08140195f, -0.06638512f, -0.11170288f, -0.04119974f, 0.04922198f, 0.07820964f, 
    0.10309567f, 0.20491450f, 0.09993718f, -0.07157348f, -0.00166694f, -0.06452458f, 0.01597281f, 0.06639741f, 
    -0.13647303f, -0.03438641f, 0.04461399f, 0.05486590f, -0.10727077f, 0.01210419f, -0.15316632f, 0.23259783f, 
    0.08961052f, -0.12325697f, -0.08991092f, 0.04438983f, 0.08842187f, 0.02560981f, -0.01571392f, 0.03690933f, 
    0.09922540f, -0.33950022f, 0.22949126f, 0.14925976f, -0.04098321f, 0.01431824f, -0.02265029f, -0.13043913f, 
    0.10484099f, 0.17584489f, -0.02061544f, 0.02149800f, -0.10348321f, -0.09793187f, -0.12245641f, 0.00160062f, 
    0.16166289f, 0.15133348f, 0.12425194f, 0.02565484f, 0.07999294f, -0.02008161f, 0.03211051f, 0.01366233f, 
    -0.06443773f, 0.01188740f, -0.00011013f, 0.10695510f, 0.07409469f, -0.25389445f, -0.04001679f, -0.00674434f, 
    -0.10565839f, -0.11792200f, 0.03140078f, -0.10037781f, 0.18666451f, 0.11250433f, 0.24641521f, -0.04052505f, 
    0.08811637f, -0.04894543f, -0.00748797f, 0.02598746f, 0.20576125f, -0.10477323f, 0.15150300f, -0.13070223f, 
    0.14048058f, -0.27806675f, 0.24714832f, -0.05324636f, 0.01034757f, 0.00733304f, -0.07311967f, 0.01755280f, 
    -0.16136669f, -0.11737660f, -0.05781193f, -0.14142729f, 0.22035824f, -0.13148052f, 0.17529069f, 0.01174252f, 
    -0.07752618f, 0.02965166f, -0.00220182f, -0.07557835f, 0.01788514f, 0.04812982f, -0.05682829f, 0.01642412f, 
    -0.32105559f, -0.35725144f, -0.01291362f, -0.13795084f, -0.05508231f, -0.17299305f, -0.04810188f, 0.13430569f, 
    -0.03042060f, -0.05559294f, 0.15095413f, 0.11770947f, -0.07612033f, 0.09479059f, 0.25110713f, 0.05877473f, 
    -0.06620290f, -0.11701678f, 0.13642316f, -0.07089719f, 0.06220268f, 0.02609235f, -0.00764390f, 0.09267917f, 
    0.14355664f, 0.19035713f, -0.39967483f, 0.03198809f, 0.04777529f, -0.07257642f, 0.19621514f, 0.00068455f, 
    0.07359590f, 0.26885614f, -0.01764455f, 0.06461946f, -0.08076097f, 0.00578818f, -0.06415717f, 0.18769807f, 
    -0.07992661f, 0.09027740f, 0.06098168f, 0.02554417f, 0.06486458f, 0.02157614f, -0.01972772f, -0.04668845f, 
    0.39782831f, 0.41618201f, 0.13491608f, 0.10161873f, -0.14180914f, -0.16132990f, -0.12556170f, -0.05209181f, 
    0.12700540f, 0.04822640f, 0.02625026f, 0.16944827f, 0.06646408f, 0.03049336f, -0.38152397f, 0.08062873f, 
    0.10388408f, 0.12165605f, -0.01198804f, -0.03143827f, 0.10672276f, 0.03539407f, -0.01417979f, -0.14296094f, 
    -0.03820091f, -0.06566732f, -0.09407932f, 0.11315496f, 0.01206357f, -0.02443233f, 0.05305603f, -0.04089319f, 
    -0.01549259f, -0.05487758f, 0.03108189f, -0.07986056f, 0.05187915f, 0.00721885f, 0.41918680f, -0.11100733f, 
    0.18849264f, 0.11843137f, 0.06190855f, 0.07847825f, -0.03051097f, 0.04076163f, 0.14939834f, -0.23317002f, 
    0.27309597f, 0.11051296f, 0.06319840f, -0.25754592f, 0.04008138f, -0.05806321f, -0.09284709f, 0.01554480f, 
    -0.02416122f, 0.01272055f, -0.01146130f, -0.08871252f, -0.10863273f, 0.19932371f, 0.23255642f, 0.46040955f, 
    0.01832039f, 0.02553967f, 0.22075464f, 0.19167456f, -0.03359562f, -0.02163980f, 0.00403437f, -0.02449325f, 
    -0.03991083f, -0.17707685f, 0.22406510f, 0.15519173f, 0.04970035f, 0.09589826f, -0.09937253f, -0.08634711f, 
    0.08744084f, -0.02669564f, -0.02654992f, -0.02783317f, 0.01455986f, -0.05160535f, -0.27273366f, -0.00415421f, 
    0.07807823f, 0.07805973f, 0.01669714f, 0.00319655f, 0.00189012f, -0.02973936f, -0.00859817f, -0.00414113f, 
    -0.12858525f, -0.07734164f, -0.04379012f, 0.03357717f, 0.07306483f, 0.04093540f, 0.04079992f, -0.06937766f, 
    -0.10240193f, 0.11841694f, 0.01415705f, -0.01288410f, 0.32778135f, -0.00045136f, 0.10840665f, -0.19488612f, 
    -0.05978941f, -0.07996338f, -0.08984827f, -0.02937042f, 0.18484004f, -0.07297082f, 0.18551625f, 0.16048682f, 
    -0.10814703f, -0.25476754f, 0.18972521f, 0.09008521f, -0.15823726f, 0.14465317f, -0.06024339f, -0.05924602f, 
    0.03317342f, 0.06086812f, -0.29221854f, 0.05079087f, 0.23872210f, 0.03155473f, 0.25921500f, 0.11447062f, 
    -0.04147307f, 0.05592418f, -0.18843341f, -0.15915573f, 0.05901795f, 0.08339247f, -0.06076578f, -0.14330950f, 
    -0.38911623f, -0.27781868f, 0.25487173f, 0.07023177f, -0.04037743f, -0.07887961f, -0.17022419f, 0.08327112f, 
    0.22481073f, 0.00146293f, -0.04836757f, -0.00668158f, -0.06128779f, 0.00701337f, 0.27094659f, 0.16970272f, 
    0.01204776f, 0.02090820f, 0.06724132f, 0.13878064f, 0.01816580f, 0.05194868f, -0.10911325f, 0.04182922f, 
    0.05080007f, 0.29664057f, -0.14859100f, -0.07390129f, 0.03946369f, -0.15136233f, 0.10399558f, 0.11076446f, 
    0.19392627f, -0.02123022f, -0.12706615f, 0.18902667f, -0.04453689f, 0.11171471f, -0.08293632f, 0.37557548f, 
    0.04849601f, 0.08429421f, 0.22364572f, 0.17822798f, -0.00600228f, 0.09737010f, 0.02017758f, -0.02479060f, 
    0.20225918f, 0.15904877f, -0.12286190f, 0.22178434f, -0.15430281f, -0.18462078f, -0.17623995f, -0.12397273f, 
    0.00104630f, -0.13018003f, 0.04178071f, 0.01837026f, -0.21821778f, -0.04385748f, -0.39096004f, 0.28419292f, 
    0.05667341f, -0.05078316f, -0.12580761f, -0.03279469f, 0.21102692f, -0.11656257f, 0.09056824f, -0.06717976f, 
    -0.01814325f, -0.09204485f, -0.22522816f, -0.14491935f, 0.04051363f, -0.08051458f, -0.00957680f, -0.00772786f, 
    -0.02949878f, 0.09467398f, 0.01006505f, -0.09426139f, 0.06390325f, 0.24003480f, 0.45502841f, -0.03689705f, 
    -0.05836176f, -0.05456293f, 0.10454176f, 0.18836579f, 0.11160734f, -0.01653471f, 0.03713161f, -0.04903194f, 
    0.15864103f, -0.02319585f, 0.06756505f, -0.05482420f, -0.02613418f, -0.01416201f, 0.04048726f, 0.05335892f, 
    -0.00324831f, 0.03724042f, -0.10113050f, 0.20441970f, 0.00612112f, 0.11523217f, 0.30605948f, -0.01480665f, 
    -0.03472628f, -0.04850698f, 0.19720179f, 0.14628981f, 0.05461896f, 0.08532507f, 0.03012527f, 0.12468456f, 
    0.31893986f, -0.04657280f, 0.14727478f, -0.07293298f, 0.08846864f, -0.16241449f, 0.02062811f, -0.00300176f, 
    -0.03816579f, 0.07053719f, -0.04912667f, 0.13551556f, -0.10739116f, 0.13353242f, 0.04906491f, 0.16834879f, 
    0.14751618f, 0.02214918f, -0.03152295f, 0.02640210f, -0.04501459f, 0.00227499f, -0.04637502f, 0.01651471f, 
    -0.34347528f, 0.10359098f, -0.28761315f, -0.10984872f, 0.09666218f, -0.20185135f, -0.06165000f, 0.06944477f, 
    0.16655059f, -0.01753987f, -0.12710670f, -0.07520205f, -0.06325251f, -0.34342504f, -0.14872241f, -0.12394673f, 
    -0.10830955f, -0.10416406f, 0.12367062f, -0.11233506f, 0.04300171f, 0.01453468f, -0.06601014f, 0.05544193f, 
    0.40828797f, -0.10686183f, -0.33335972f, -0.02702384f, -0.33429536f, 0.18006526f, -0.22975007f, 0.11368088f, 
    0.03655838f, -0.01017354f, -0.07486410f, 0.05904605f, 0.20279400f, -0.52744472f, 0.38236105f, 0.12553580f, 
    -0.14812425f, -0.01560001f, -0.08888271f, -0.01547928f, 0.30706558f, -0.04919950f, 0.02732954f, 0.05805438f, 
    -0.01384575f, -0.09059220f, 0.16673581f, 0.21913281f, -0.05161051f, -0.03971735f, -0.06407532f, -0.08184227f, 
    0.16573331f, -0.00371371f, 0.05718259f, 0.08489995f, 0.21138667f, 0.00470440f, -0.07570668f, 0.12140296f, 
    -0.03124365f, 0.03404215f, 0.03480265f, 0.19287893f, 0.13191745f, 0.17217623f, 0.02700516f, 0.13180374f, 
    -0.12535737f, -0.04088781f, 0.20477211f, -0.30868775f, 0.15912563f, -0.10565730f, -0.16262926f, 0.16812341f, 
    0.19138788f, -0.02736624f, 0.02012145f, 0.01225491f, -0.22930950f, 0.06028470f, -0.26546407f, 0.02596282f, 
    0.24065541f, 0.02382538f, -0.09075303f, 0.21581982f, -0.04646502f, 0.05404130f, 0.11802473f, -0.00772261f, 
    -0.17623059f, 0.19474326f, -0.01014402f, 0.24711554f, -0.16333641f, -0.00671736f, 0.07530037f, -0.03360766f, 
    0.13570726f, -0.13216653f, -0.14431307f, 0.21062025f, -0.38132972f, 0.07594515f, -0.09007017f, 0.01167354f, 
    -0.10183310f, -0.07476836f, -0.16115247f, -0.12588112f, -0.03654417f, -0.22654575f, -0.01660869f, -0.11318284f, 
    -0.16571032f, 0.13039441f, -0.22600970f, -0.13265623f, 0.05454958f, 0.05980914f, -0.08531560f, 0.00080054f, 
    0.05039578f, -0.20778935f, -0.06812387f, -0.03572735f, 0.20220506f, 0.18295182f, -0.11326554f, -0.25977889f, 
    0.04386811f, 0.03109358f, -0.03365263f, 0.05301701f, 0.05731505f, 0.00968094f, -0.00173335f, 0.09930670f, 
    -0.36291236f, 0.18132125f, 0.37396979f, 0.15479836f, -0.01784530f, 0.05667077f, -0.03965500f, -0.04038398f, 
    0.01632331f, 0.09567548f, 0.19682765f, 0.11872274f, -0.24832845f, -0.23757397f, -0.27157712f, -0.03277170f, 
    -0.01308217f, -0.03760532f, -0.06763767f, 0.04208272f, 0.04518836f, 0.06365433f, 0.01443606f, -0.00552789f, 
    -0.00195979f, 0.22718565f, 0.00592095f, 0.11055336f, -0.05159195f, 0.06148194f, 0.10771828f, 0.01707533f, 
    -0.07294587f, 0.17239103f, 0.10383119f, 0.15518573f, -0.16394611f, -0.06727413f, 0.00841347f, -0.07571762f, 
    -0.07776362f, -0.09911302f, 0.02438864f, 0.00547229f, 0.04271274f, 0.01257410f, 0.08000714f, -0.04811007f, 
    0.21545401f, -0.08055108f, -0.21401317f, -0.14279716f, -0.07895005f, 0.20002036f, 0.00731042f, -0.03859701f, 
    0.06940671f, 0.14181940f, 0.02380153f, -0.01717804f, -0.24733226f, -0.02587574f, 0.32811451f, -0.16369383f, 
    -0.06356806f, -0.05514470f, -0.03887026f, 0.00605300f, -0.15056233f, -0.02485021f, 0.01966205f, 0.20612775f, 
    -0.01335474f, 0.04291968f, -0.12808442f, -0.02488695f, 0.06463362f, -0.09946817f, 0.04293639f, -0.04476421f, 
    0.18819754f, 0.12000207f, 0.07983709f, -0.18778411f, 0.10042948f, 0.25517532f, -0.12590174f, -0.01938520f, 
    0.11730727f, -0.04142122f, -0.05346795f, -0.03571351f, -0.04485002f, 0.06975220f, 0.21598668f, 0.05569257f, 
    0.05966784f, -0.14231363f, -0.19328386f, 0.19402261f, -0.06449863f, -0.02858236f, -0.10520362f, 0.21402831f, 
    -0.04291558f, 0.01543902f, 0.02563900f, 0.03219308f, 0.05027227f, -0.02457465f, -0.17327678f, 0.22257496f, 
    0.16979507f, -0.12273453f, 0.20849444f, 0.17165938f, -0.19056290f, 0.07758611f, 0.12369146f, -0.08720925f, 
    -0.29613248f, 0.11688199f, 0.45466813f, -0.04072456f, -0.07587014f, -0.01193463f, -0.09203707f, 0.00528603f, 
    -0.08985320f, -0.01314866f, 0.09562065f, -0.04526282f, 0.43880433f, -0.12701583f, -0.10901237f, -0.06905387f, 
    0.04098762f, -0.05178984f, -0.21241492f, 0.09339621f, 0.05429839f, 0.14591210f, 0.07829600f, 0.07190385f, 
    0.41060632f, 0.20124879f, 0.09903385f, 0.25754818f, 0.05435734f, -0.02289383f, 0.09916224f, 0.02243167f, 
    0.00900841f, 0.04606624f, 0.01276578f, 0.09739703f, -0.35389146f, 0.15814321f, 0.04239623f, 0.04823050f, 
    -0.03434402f, 0.07216259f, -0.00540685f, -0.09303407f, 0.08425546f, 0.03385618f, -0.11698144f, 0.01743398f, 
    -0.16725628f, 0.20347679f, 0.03871319f, -0.23884121f, -0.00210774f, -0.02167245f, -0.02697562f, -0.00713430f, 
    0.00798953f, 0.07337537f, -0.08693413f, -0.04966762f, -0.35906178f, -0.31190640f, 0.03672019f, 0.18935743f, 
    0.06436620f, 0.10991893f, 0.20328423f, 0.05670811f, 0.05025169f, 0.16661315f, -0.00198467f, 0.00701998f, 
    -0.00252325f, -0.06580433f, -0.00024638f, -0.06042130f, -0.03112280f, -0.02235830f, 0.02540461f, -0.07061105f, 
    -0.01477296f, 0.01898398f, -0.01742106f, 0.03274924f, 0.03745673f, 0.01850832f, -0.06034449f, -0.07550211f, 
    0.02270140f, -0.04578916f, 0.00287525f, 0.05057940f, -0.06449959f, -0.04428530f, 0.02661980f, -0.06701275f, 
    0.02571668f, -0.04300681f, 0.04092367f, -0.03859412f, -0.00480446f, -0.04820053f, 0.04269371f, 0.04618419f, 
    -0.02381353f, -0.05395554f, -0.06742793f, 0.01988978f, -0.06876034f, -0.01756793f, 0.00429714f, -0.06964269f, 
    0.05050215f, 0.01013330f, -0.08034828f, -0.06945483f, 0.05597436f, -0.04452488f, -0.01138219f, -0.06560834f, 
    -0.01384225f, 0.03555819f, -0.01849437f, 0.03356958f, 0.04539116f, 0.02192938f, 0.00159358f, -0.01137174f, 
    -0.05461060f, 0.01573879f, -0.03036602f, 0.01756002f, 0.04128101f, -0.01029672f, -0.07095728f, 0.01218220f, 
    -0.04027214f, 0.04185871f, 0.00324138f, -0.08549465f, -0.00477338f, -0.00682532f, -0.01504718f, -0.03564512f, 
    -0.03048993f, -0.00867125f, -0.00411458f, -0.06346238f, 0.03825605f, 0.02576060f, 0.03249671f, -0.03581918f, 
    -0.07016025f, 0.05203598f, 0.02510309f, 0.05059069f, 0.05101855f, 0.05715434f, -0.04740970f, 0.04462386f, 
    -0.03343828f, 0.01937638f, 0.01828486f, 0.01185008f, 0.01445135f, -0.03171772f, 0.04102584f, -0.02695566f, 
    0.04428383f, 0.01601666f, 0.05131540f, 0.01089097f, -0.05582962f, -0.02651368f, 0.01565739f, -0.01268845f, 
    -0.01024384f, -0.06274686f, 0.03392641f, -0.06076820f, 0.02360955f, -0.00880228f, 0.00450917f, 0.02480494f, 
    0.04792501f, -0.05665193f, 0.02004551f, -0.02405822f, -0.06749909f, -0.02656226f, 0.04396834f, -0.04184132f, 
    -0.06854779f, -0.02438257f, 0.01337222f, -0.04471010f, -0.02452484f, -0.06512450f, -0.03572945f, 0.05177465f, 
    -0.01140161f, 0.04763312f, -0.08501256f, 0.05666486f, 0.01447544f, -0.01136092f, 0.01151470f, -0.02120540f, 
    -0.04693103f, -0.05112663f, 0.02011623f, 0.02227591f, -0.03320464f, 0.03613093f, -0.06520227f, 0.04881909f, 
    -0.07706874f, -0.04890788f, 0.02420560f, 0.04654481f, -0.00303991f, 0.05396919f, -0.00700566f, -0.05251319f, 
    -0.00226039f, -0.01349945f, -0.01784017f, -0.03094703f, -0.02062474f, -0.03266273f, -0.00072007f, 0.00597897f, 
    -0.03437389f, 0.05072801f, -0.06487361f, 0.03056891f, 0.00376339f, -0.00078756f, 0.04688702f, -0.03632710f, 
    -0.00598375f, 0.03713251f, 0.03931740f, -0.04676167f, -0.05640236f, -0.03231011f, -0.06090950f, -0.04636906f, 
    -0.04652735f, -0.04472930f, 0.05082230f, -0.07717483f, 0.01017972f, 0.04812922f, -0.08410848f, -0.03782638f, 
    -0.06580577f, 0.02460947f, 0.04995842f, -0.02665511f, -0.01125074f, 0.00410046f, -0.06327019f, -0.03625780f, 
    0.15966012f, -0.03913582f, 0.18130621f, -0.00917895f, 0.00339781f, 0.11817859f, -0.10754232f, 0.12748064f, 
    0.04383601f, -0.02844816f, 0.11005805f, -0.21102861f, 0.05262789f, 0.08815995f, -0.01390992f, 0.21495247f, 
    0.06508387f, 0.02390108f, -0.16533990f, 0.18725622f, 0.02222472f, 0.03064491f, -0.13706735f, 0.08136893f, 
    -0.25343102f, 0.00481684f, -0.06552907f, 0.23452155f, 0.12119893f, 0.14158721f, 0.01723174f, -0.05485661f, 
    0.13909921f, -0.05911292f, 0.07289899f, -0.10666531f, 0.08327106f, -0.21149877f, -0.25461295f, -0.15963252f, 
    -0.19716167f, 0.05440767f, -0.01715632f, -0.22220838f, 0.07392640f, -0.06138396f, -0.00093376f, 0.04741968f, 
    0.06784742f, -0.20000406f, 0.34175983f, -0.04076919f, -0.01120222f, 0.21477987f, 0.19526611f, 0.12498224f, 
    -0.00765143f, 0.03571953f, -0.03649579f, 0.09306742f, 0.00529458f, 0.21435753f, 0.01078597f, 0.03124043f, 
    -0.14925984f, -0.03632055f, -0.05449283f, -0.07408761f, -0.20895822f, 0.01830346f, 0.00719649f, 0.07819463f, 
    -0.54288352f, 0.12381876f, -0.01308084f, 0.32474697f, 0.04511499f, 0.00828844f, 0.01074781f, -0.14008318f, 
    0.12318653f, -0.10087963f, -0.00936301f, 0.05180259f, -0.35025564f, 0.48026583f, 0.00521602f, 0.14423224f, 
    0.05120944f, 0.03831024f, -0.16678031f, -0.04372036f, -0.15105656f, -0.03651984f, 0.00500320f, -0.02789020f, 
    -0.00339982f, -0.00358748f, -0.21622038f, -0.11976036f, -0.11607859f, 0.08345962f, 0.11705729f, -0.04883065f, 
    0.09418192f, 0.10334267f, 0.14164153f, 0.00600817f, -0.15166007f, -0.11235268f, 0.23335682f, -0.05867459f, 
    0.00182432f, 0.09639627f, 0.04505019f, 0.05895796f, 0.04482478f, 0.01331073f, 0.09984653f, 0.03690502f, 
    0.12957071f, 0.14429723f, 0.08123915f, 0.03728106f, -0.16053313f, 0.00715698f, 0.23798946f, -0.12865645f, 
    -0.05240979f, -0.05397888f, -0.09633312f, 0.02471216f, -0.19723621f, -0.12830791f, -0.00397000f, -0.13078749f, 
    -0.11955673f, -0.04667009f, 0.48622096f, -0.12917538f, -0.06209409f, -0.05327199f, -0.08769236f, 0.14525476f, 
    -0.07611672f, 0.25699010f, 0.15699974f, -0.12713951f, 0.07732415f, -0.17430341f, -0.15889736f, -0.04278986f, 
    0.00408712f, 0.25019759f, 0.25305927f, -0.13144891f, 0.39115202f, 0.05924485f, 0.10919765f, -0.11331654f, 
    -0.08821370f, -0.02987935f, 0.04905296f, 0.02627966f, -0.15379936f, -0.04244749f, 0.13649078f, -0.03598063f, 
    0.15144771f, -0.12593932f, 0.17009281f, 0.20501712f, -0.03366455f, -0.07267986f, -0.05327241f, -0.15877822f, 
    -0.04177013f, 0.04639744f, 0.11973716f, -0.04131028f, 0.14168829f, -0.15838134f, 0.15754135f, 0.10645425f, 
    -0.12315749f, -0.10684630f, 0.04132176f, 0.06587350f, 0.06693012f, 0.04677519f, 0.04231073f, 0.03510170f, 
    0.25272837f, 0.25779608f, 0.06156326f, -0.17161943f, -0.00528069f, -0.05446197f, 0.00083574f, -0.11231577f, 
    0.28400022f, 0.12811428f, 0.19272505f, 0.02376265f, -0.37634534f, -0.17174266f, -0.26640010f, -0.27395475f, 
    0.07053997f, -0.01718553f, 0.14999466f, -0.02825566f, -0.08059854f, -0.13342625f, 0.00036849f, -0.07732711f, 
    -0.12878881f, 0.01344651f, 0.06986295f, 0.04845426f, 0.07557405f, 0.10514045f, -0.08144528f, -0.08091597f, 
    0.03037378f, 0.05145656f, 0.08636850f, 0.14064552f, -0.20355175f, -0.05937512f, -0.05788040f, 0.06523823f, 
    -0.13345708f, -0.00056333f, 0.07982513f, -0.15327691f, -0.03823627f, 0.03042161f, 0.01922576f, -0.04322893f, 
    -0.07417354f, -0.26826942f, -0.29524374f, -0.12605631f, 0.19192941f, 0.25541526f, 0.01357729f, -0.07251660f, 
    -0.04269664f, 0.08001584f, 0.12379086f, 0.09740886f, 0.24655016f, -0.25617042f, 0.10610200f, -0.22238506f, 
    -0.03215441f, -0.03362006f, -0.12680770f, -0.09535135f, 0.13230103f, 0.18758932f, -0.02660984f, 0.27782199f, 
    -0.05018065f, 0.06884347f, 0.30230820f, 0.20580108f, -0.14437479f, 0.05239652f, -0.15201655f, 0.04518425f, 
    -0.00909516f, 0.14659131f, -0.13612908f, 0.18102853f, 0.23875766f, 0.37560338f, 0.24775925f, 0.10809830f, 
    0.03239185f, -0.07707926f, -0.10020672f, -0.04608859f, 0.03149313f, 0.04789379f, 0.15575987f, -0.11762768f, 
    -0.12124105f, -0.04938976f, 0.23895147f, 0.35469511f, 0.16765957f, -0.02470340f, -0.18393493f, 0.04480117f, 
    0.07277831f, 0.01524485f, -0.11287665f, 0.04938763f, -0.26838505f, 0.27212059f, -0.08878614f, 0.15334390f, 
    0.07190467f, 0.06652399f, 0.28580844f, 0.33455506f, -0.11776135f, 0.03909468f, -0.08162900f, 0.10852243f, 
    0.18360978f, 0.11519684f, 0.11668361f, -0.38192528f, 0.05080482f, -0.07549756f, 0.02371210f, 0.06629977f, 
    0.28037548f, 0.08453999f, -0.01956189f, -0.02314927f, 0.18249118f, -0.17652953f, -0.02948425f, -0.12965104f, 
    0.04606017f, -0.09283287f, -0.13515316f, 0.19319470f, -0.01980622f, -0.04752370f, -0.06598926f, -0.01686689f, 
    -0.17351717f, 0.42763397f, 0.15780941f, 0.39281833f, -0.05539471f, -0.13578512f, -0.02589054f, 0.01474872f, 
    0.00828227f, -0.01493518f, 0.03691601f, 0.30512688f, -0.42212278f, -0.08542193f, -0.36346388f, 0.07638532f, 
    -0.11750977f, 0.02738948f, -0.14451610f, -0.26099059f, 0.09680759f, 0.01472272f, -0.06239334f, 0.07525761f, 
    -0.16112944f, 0.26273945f, -0.05554289f, -0.03751515f, -0.04602617f, 0.00017784f, 0.01494984f, -0.02299677f, 
    0.16855484f, -0.04789409f, -0.02237025f, 0.15490256f, -0.14076823f, -0.18467394f, 0.04644870f, -0.02938427f, 
    0.11267801f, 0.02485445f, 0.12185847f, 0.04787344f, 0.08612414f, -0.00490389f, -0.05258776f, 0.13115259f, 
    0.10696974f, -0.04016725f, 0.15045947f, 0.23014349f, -0.09614661f, 0.00945872f, -0.02788324f, 0.02933665f, 
    0.01116105f, -0.02962002f, 0.02794166f, 0.01578029f, 0.00517169f, -0.03419053f, 0.07932781f, -0.24338432f, 
    -0.18169425f, -0.12590542f, 0.01451112f, 0.03297467f, -0.03271573f, -0.01330915f, -0.03769045f, -0.07873566f, 
    -0.00434850f, 0.15722932f, -0.18877655f, -0.07971849f, -0.10525879f, -0.08129326f, -0.01745875f, -0.00272289f, 
    -0.04930399f, 0.06992615f, 0.18678375f, -0.12171555f, 0.23407713f, 0.00030205f, 0.09181236f, -0.09415329f, 
    -0.15944323f, -0.02905453f, -0.04660308f, -0.09875043f, -0.07930949f, 0.04024334f, 0.02028758f, -0.02824057f, 
    0.28043219f, -0.03253256f, -0.01221904f, -0.09123731f, -0.10845366f, 0.34563777f, 0.17849083f, 0.17171773f, 
    0.06468344f, 0.21724367f, 0.08967435f, 0.07090552f, -0.10311040f, 0.01429175f, -0.07132932f, 0.14274848f, 
    -0.12632771f, 0.08520474f, -0.05964603f, -0.04306870f, -0.25757441f, 0.15398575f, -0.03567254f, 0.12428704f, 
    -0.20212731f, 0.45757055f, -0.25221556f, 0.05495711f, 0.06524792f, 0.03228899f, 0.09552176f, -0.12781812f, 
    0.17856979f, 0.09136764f, 0.05763144f, -0.03523703f, -0.32483792f, 0.05782884f, -0.19346488f, 0.09303300f, 
    0.05848712f, 0.07147969f, 0.04054934f, -0.05283085f, 0.17216587f, 0.00181480f, 0.17585960f, 0.19925576f, 
    0.56839806f, 0.21826705f, -0.08582749f, 0.14388630f, 0.06151234f, 0.17822839f, 0.21340644f, 0.00970543f, 
    -0.12089523f, 0.07136622f, -0.08045109f, -0.24053398f, 0.03591597f, -0.03888112f, -0.13999864f, -0.05455874f, 
    0.12542181f, -0.06161500f, -0.12071325f, 0.09704807f, 0.05728743f, 0.04887338f, 0.06828047f, -0.01260252f, 
    0.03783269f, -0.21194203f, 0.58380109f, -0.06227196f, -0.10634276f, 0.05357953f, 0.11446229f, -0.13494328f, 
    -0.16728276f, -0.02234487f, 0.14688493f, -0.15212952f, 0.10522808f, -0.05618469f, -0.07903508f, -0.29299256f, 
    -0.06586730f, 0.00744695f, 0.09691620f, 0.06796864f, -0.15524769f, 0.06326902f, 0.08070174f, 0.02350470f, 
    -0.13448766f, -0.03055346f, 0.25249067f, -0.26086420f, 0.11811838f, 0.02304575f, 0.09266841f, 0.11664972f, 
    -0.08808427f, 0.09037151f, 0.00697055f, 0.00722329f, 0.27666757f, 0.14323808f, 0.43465632f, -0.34216765f, 
    -0.06288798f, -0.11525118f, 0.10422254f, -0.06971627f, -0.25041640f, 0.10959430f, 0.06026476f, 0.12305451f, 
    0.28312504f, 0.12204205f, 0.20863551f, 0.00006360f, -0.00235439f, 0.03291960f, -0.05309826f, 0.01904969f, 
    0.01002425f, 0.01530694f, -0.00990010f, 0.01946753f, 0.05964927f, -0.11389333f, -0.46475381f, 0.21657860f, 
    0.01165226f, -0.02168139f, -0.15892249f, -0.08490071f, -0.10117207f, 0.17750460f, -0.05870567f, 0.12561321f, 
    0.00373873f, -0.04685351f, -0.15154766f, 0.22456843f, 0.03199653f, 0.19049916f, -0.12117918f, 0.16324311f, 
    0.12765960f, 0.01738674f, -0.03103574f, -0.01097001f, 0.22959091f, -0.05711914f, -0.19090919f, 0.10388381f, 
    0.14676271f, 0.11219004f, -0.24752349f, 0.09780695f, -0.04583652f, -0.06845789f, -0.08566280f, 0.18915787f, 
    -0.22515915f, 0.10945135f, -0.01514272f, 0.09887331f, 0.05083181f, 0.08122475f, -0.03625935f, -0.04286518f, 
    0.03603888f, 0.02302890f, 0.09747488f, -0.14932285f, -0.02835886f, -0.13486294f, -0.17877288f, -0.03952377f, 
    -0.06332944f, 0.03508012f, -0.26709285f, -0.27972198f, 0.00774443f, 0.00496748f, 0.01532992f, 0.10665408f, 
    0.14264555f, -0.04104104f, 0.29573250f, 0.06488975f, -0.17132211f, 0.01939535f, 0.09938479f, 0.27066109f, 
    0.19393656f, -0.03311704f, 0.20867556f, 0.19843873f, -0.24056242f, 0.22028546f, -0.04196210f, 0.24109340f, 
    -0.03646557f, -0.00544732f, -0.06542546f, 0.03988551f, -0.11099228f, 0.02374957f, 0.06374308f, 0.11590499f, 
    0.05591929f, 0.01814465f, 0.13583952f, 0.10668727f, 0.11065394f, -0.10578560f, -0.03114170f, -0.08882049f, 
    0.35185000f, -0.14288977f, 0.25083932f, 0.15352502f, -0.25773376f, 0.31451952f, -0.16774739f, -0.31976432f, 
    -0.08809691f, -0.13974525f, -0.15550506f, -0.13261905f, 0.15490696f, 0.00943402f, -0.00473691f, -0.00227356f, 
    -0.00766760f, 0.19472638f, -0.27198035f, -0.36337978f, 0.08430398f, 0.07359780f, 0.30354637f, -0.12161773f, 
    -0.17882854f, 0.00102765f, -0.06961785f, 0.06234271f, 0.02161043f, -0.09353293f, 0.13596949f, -0.24961904f, 
    -0.01185660f, 0.25699458f, 0.03669535f, 0.02033845f, -0.06263139f, -0.07870390f, 0.13878749f, -0.17205340f, 
    0.00282765f, -0.01757072f, -0.23834300f, 0.20590676f, -0.12239631f, -0.12188013f, 0.27599755f, 0.04247684f, 
    -0.16526157f, -0.01101518f, -0.10627528f, 0.04867560f, -0.12684651f, -0.19892924f, -0.02516674f, -0.24344797f, 
    0.05597247f, 0.03197768f, 0.24525096f, -0.13626014f, 0.14378150f, 0.00884817f, -0.07671729f, 0.16245864f, 
    -0.24291661f, 0.06834708f, 0.11505751f, -0.18981896f, 0.02875187f, 0.00735538f, -0.07557882f, -0.01168982f, 
    0.05828843f, 0.18204457f, 0.29329789f, -0.20732312f, 0.40440387f, -0.09354978f, 0.12987657f, -0.03619538f, 
    -0.05822800f, 0.09256823f, 0.29162633f, 0.05797748f, -0.15857935f, 0.01197617f, 0.09143779f, -0.01619746f, 
    0.01861690f, -0.03892402f, 0.20178774f, 0.41730192f, -0.21994805f, -0.00417733f, 0.01554975f, -0.14834270f, 
    0.17991051f, 0.06113027f, 0.23990992f, 0.14737421f, 0.11115351f, -0.20644686f, 0.08741427f, 0.12678243f, 
    0.19654524f, 0.24473484f, 0.10877425f, -0.02292599f, -0.12698342f, -0.00539115f, 0.15251392f, 0.07845918f, 
    -0.11743718f, 0.20730005f, -0.09315024f, 0.11828166f, 0.01512156f, 0.00704505f, 0.03842115f, -0.05388454f, 
    0.19717577f, 0.26455566f, 0.03654290f, 0.28171247f, -0.42811406f, -0.52223748f, -0.44034809f, -0.43126458f, 
    0.22230873f, -0.07925779f, 0.01363030f, -0.30093855f, -0.02785026f, -0.13606440f, -0.05045668f, -0.09415895f, 
    0.11194699f, 0.08537653f, 0.16074815f, -0.15650797f, 0.13904893f, -0.16510728f, -0.02604852f, 0.07310673f, 
    -0.05307652f, 0.11628251f, 0.20550393f, 0.16834092f, -0.11896632f, 0.02149770f, -0.00594969f, -0.15441938f, 
    0.09102941f, -0.06728794f, 0.13511406f, 0.07108261f, -0.05916535f, 0.08048218f, -0.06813188f, 0.02311971f, 
    0.22208944f, 0.15871350f, -0.23934266f, 0.18136697f, 0.20497501f, 0.01352487f, 0.03772130f, -0.02103709f, 
    0.17133129f, 0.15342100f, 0.13666058f, 0.04486299f, 0.00158324f, -0.02681520f, 0.07043723f, -0.03636594f, 
    -0.00195922f, -0.11195278f, -0.11292829f, 0.07197616f, 0.04308729f, -0.02828524f, 0.09262706f, -0.04148816f, 
    0.36621311f, -0.04955792f, -0.03572506f, 0.27583432f, 0.18742600f, -0.09653246f, -0.03519811f, 0.04469284f, 
    0.12798499f, 0.25438660f, 0.25878975f, 0.20216781f, 0.36556742f, -0.09763838f, -0.00035073f, -0.06021897f, 
    -0.03622392f, -0.00551515f, 0.08839275f, 0.04474983f, 0.11908052f, 0.05009795f, 0.15445223f, 0.12965596f, 
    -0.34794921f, -0.10407959f, 0.07913187f, 0.04162427f, 0.09031378f, -0.02649574f, -0.08120311f, 0.14260566f, 
    0.04555477f, 0.01969090f, -0.12835340f, 0.04217650f, 0.02045993f, -0.09290561f, -0.32969350f, -0.15341212f, 
    0.14968498f, -0.00091440f, 0.14700077f, 0.20340163f, -0.13532022f, 0.08353079f, -0.05228926f, -0.01675219f, 
    0.02265378f, 0.03004991f, 0.22986023f, -0.07914530f, 0.09241449f, 0.11191832f, 0.01771769f, 0.17386311f, 
    -0.00839236f, -0.07509196f, 0.17987688f, -0.08973237f, -0.07837441f, -0.15648164f, -0.00757275f, 0.01064544f, 
    0.07824724f, -0.06722234f, -0.32864982f, 0.32719019f, 0.04859398f, -0.08702755f, 0.00230591f, -0.05092070f, 
    0.06758483f, -0.02367624f, 0.16516696f, 0.34778383f, 0.01065469f, 0.05258633f, -0.06592017f, -0.04854866f, 
    0.08262059f, 0.14079505f, 0.18435857f, 0.11321150f, -0.00300354f, -0.19020554f, 0.05814927f, -0.06505995f, 
    0.06529216f, 0.04064432f, -0.00815449f, -0.00127773f, -0.07274812f, -0.07902217f, -0.04245954f, 0.00466838f, 
    -0.14395460f, 0.27753770f, 0.07228617f, 0.04540741f, 0.07424681f, 0.09395705f, 0.11589587f, -0.00308860f, 
    0.08416733f, 0.03067647f, -0.12164687f, 0.10370895f, -0.48083809f, -0.26962578f, -0.27816471f, -0.07972420f, 
    0.19718938f, 0.34303856f, 0.23645888f, -0.05965674f, -0.00849210f, -0.03633216f, -0.03567836f, 0.08235844f, 
    0.17021783f, 0.32485411f, 0.17755081f, -0.02290963f, 0.04110609f, -0.14219514f, 0.12029806f, -0.07514257f, 
    0.23351727f, 0.21594760f, 0.20269291f, 0.15999231f, -0.33676100f, -0.10954265f, 0.12744129f, 0.04351107f, 
    -0.05942912f, -0.34560874f, 0.08636732f, -0.04150046f, -0.06523447f, -0.19798760f, 0.00634536f, -0.20143741f, 
    -0.08796603f, -0.07484248f, 0.01197435f, 0.09592018f, 0.10412039f, 0.26124260f, 0.08945271f, -0.13719805f, 
    0.10389037f, 0.33570260f, 0.30292729f, 0.10068906f, 0.16625388f, 0.04458550f, 0.11195414f, -0.08413599f, 
    -0.15449730f, -0.03398504f, 0.14874838f, -0.13070355f, 0.06479151f, -0.11664844f, -0.20103796f, -0.24560513f, 
    0.36398396f, -0.11142416f, -0.41804019f, -0.15018524f, -0.00783883f, 0.37850347f, 0.05408834f, -0.16066433f, 
    -0.21926048f, -0.18265259f, -0.15902543f, -0.07175501f, 0.37982291f, -0.22046115f, 0.03072285f, -0.18035071f, 
    -0.09400614f, 0.06368950f, -0.16390763f, 0.04741457f, 0.02625157f, 0.19884656f, -0.00844100f, 0.10282912f, 
    -0.13257563f, 0.04917321f, -0.00358929f, 0.09290547f, 0.02804602f, -0.07278851f, -0.00813746f, -0.07516494f, 
    -0.07243323f, 0.22599111f, -0.12263180f, -0.21465766f, 0.08484901f, 0.14912033f, 0.01008979f, -0.01946135f, 
    0.04108663f, 0.07764000f, 0.07111628f, 0.05745107f, 0.16826250f, 0.08984728f, 0.38659900f, -0.02459220f, 
    -0.30287480f, -0.37343079f, 0.08006269f, 0.32954460f, 0.02541151f, 0.01605140f, 0.03320915f, -0.04642920f, 
    0.04998014f, -0.09567688f, -0.05311467f, -0.17695192f, -0.34027031f, -0.04083524f, 0.16135831f, 0.12959965f, 
    0.01234584f, -0.27973381f, -0.14041252f, 0.25884181f, 0.12636723f, -0.03231290f, 0.02178168f, -0.00464347f, 
    0.34036523f, 0.04195169f, 0.33101889f, -0.23264629f, 0.09787932f, 0.10351703f, 0.08447243f, 0.18384466f, 
    0.11128272f, 0.15594628f, 0.02910033f, -0.05373098f, -0.03560870f, -0.11289843f, -0.27048773f, 0.20695755f, 
    0.00025283f, -0.02323633f, -0.15312533f, -0.32739377f, -0.29878560f, -0.23464197f, 0.00887756f, -0.11025807f, 
    -0.01326888f, 0.07733259f, 0.16213261f, 0.26313218f, -0.15067555f, -0.22370647f, -0.01831790f, 0.08499274f, 
    0.04082233f, -0.10802168f, 0.05366940f, 0.03241264f, 0.29246604f, -0.03324431f, -0.11493873f, -0.35424799f, 
    0.00170549f, 0.01492695f, 0.20755340f, -0.09418287f, -0.01950487f, -0.00719548f, -0.21322548f, 0.10427313f, 
    0.27331153f, 0.10280364f, 0.14302884f, -0.17908245f, 0.08044560f, -0.07300389f, 0.02734864f, 0.11503653f, 
    0.05335010f, 0.09548209f, -0.25006232f, -0.06181514f, -0.22661418f, -0.14985473f, 0.12848669f, 0.35320044f, 
    0.13418105f, 0.08720881f, 0.16971780f, 0.09974822f, 0.21393119f, 0.17003556f, -0.00575827f, -0.05987504f, 
    0.25881779f, -0.07379641f, 0.01568427f, -0.06998538f, -0.00209428f, -0.06238412f, 0.11269508f, 0.09617226f, 
    0.11871348f, 0.06523228f, -0.01757843f, -0.17095064f, -0.17827693f, -0.19849661f, -0.30945921f, 0.04180082f, 
    0.09888831f, -0.12382364f, -0.00546647f, -0.09477973f, -0.11489128f, 0.04514756f, 0.03484147f, -0.04733947f, 
    -0.10156331f, -0.10563091f, -0.03569777f, -0.02971801f, 0.09346240f, 0.07463252f, 0.13670321f, 0.14456160f, 
    0.11863891f, -0.00100982f, 0.26057294f, -0.14433554f, 0.08806687f, 0.16469111f, 0.01656123f, 0.03662251f, 
    -0.21469259f, 0.03721210f, -0.00522718f, -0.13570178f, -0.06551645f, -0.02961418f, -0.08304937f, -0.01847757f, 
    0.05571329f, -0.00774766f, 0.16089791f, 0.12568636f, -0.04080485f, 0.03057998f, 0.04590163f, -0.10990452f, 
    -0.02783434f, 0.13024867f, 0.02627709f, 0.14809181f, 0.43862277f, 0.30099547f, 0.25554055f, 0.15043628f, 
    0.01926759f, -0.01678464f, -0.01964252f, 0.05251037f, 0.14639163f, 0.19087772f, -0.00893501f, -0.00687415f, 
    0.12412387f, 0.27744281f, 0.15293249f, -0.03271507f, 0.13365622f, 0.15829097f, -0.00357027f, 0.06931560f, 
    -0.00109783f, -0.01841392f, 0.00891051f, 0.16031972f, 0.17382592f, 0.07624113f, -0.04057492f, -0.10695377f, 
    0.00131132f, -0.01945481f, 0.06630382f, -0.00548441f, -0.04249554f, 0.07043856f, -0.05967199f, -0.02162924f, 
    -0.66743743f, -0.62043118f, -0.43912321f, -0.91993487f, 0.24183138f, -0.13885885f, 0.02889738f, 0.14545357f, 
    -0.12437929f, 0.01332320f, -0.07120503f, -0.09072501f, -0.55759352f, -0.26656494f, -0.09959646f, -0.41476825f, 
    -0.06507149f, 0.16497201f, -0.12139985f, 0.01106688f, 0.02224453f, -0.08877815f, -0.12916370f, -0.02035568f, 
    0.38887802f, 0.05020849f, 0.06489142f, 0.15433213f, 0.03417534f, 0.01595204f, 0.17276038f, -0.09541535f, 
    0.01019258f, -0.05229151f, 0.11155625f, 0.12479544f, -0.09001695f, 0.01786718f, 0.00393783f, 0.08613224f, 
    -0.12757294f, 0.23971291f, 0.23893148f, 0.08429117f, -0.08476975f, -0.00582959f, 0.03651604f, 0.01308910f, 
    0.31603909f, -0.14875215f, -0.20616326f, -0.71067321f, -0.08465561f, -0.02015086f, -0.12442008f, -0.01817430f, 
    -0.06713783f, -0.03479993f, 0.22402260f, -0.17209023f, 0.36836058f, 0.10721848f, 0.14577980f, 0.01015621f, 
    0.01582789f, -0.11559337f, -0.01727430f, -0.01719277f, -0.02137723f, 0.05505015f, 0.10956166f, 0.00640710f, 
    0.28766671f, 0.23192024f, 0.22746204f, 0.06599393f, 0.00656533f, 0.01293475f, 0.07780267f, -0.06917829f, 
    0.03495061f, 0.10217721f, 0.10680039f, -0.01271986f, -0.28458780f, -0.36786142f, 0.22068366f, 0.14895199f, 
    -0.02791612f, -0.08461639f, 0.13705145f, 0.00115234f, -0.05785618f, -0.11617554f, -0.08716242f, 0.11787831f, 
    -0.17321068f, 0.14034896f, -0.07041235f, -0.22219813f, 0.05943762f, 0.08774396f, 0.03425697f, 0.10556218f, 
    -0.00856461f, 0.13143659f, -0.05065659f, -0.04100442f, -0.01204547f, -0.04255871f, 0.00242348f, 0.37869069f, 
    0.06145833f, 0.03568846f, -0.10660263f, 0.14116599f, -0.03274649f, -0.12779218f, -0.17053050f, -0.00819719f, 
    -0.23464692f, -0.07540870f, 0.17743626f, 0.34584522f, 0.09492809f, 0.30499652f, -0.02558319f, -0.09753666f, 
    0.08091931f, 0.09693967f, 0.04796281f, 0.04184822f, -0.05274743f, -0.19242068f, -0.25018936f, -0.02562547f, 
    0.09745914f, -0.00191128f, -0.14637154f, 0.01681103f, -0.00186553f, 0.00606410f, -0.04532739f, -0.10003282f, 
    -0.00406878f, 0.08385868f, 0.30796263f, 0.20485765f, 0.00358373f, -0.06693770f, -0.00338984f, 0.05409353f, 
    0.02834152f, -0.10501892f, 0.18523428f, 0.01056154f, -0.01370939f, 0.12306033f, -0.05552520f, -0.07967867f, 
    -0.07215378f, 0.00632164f, -0.13961965f, -0.06188252f, 0.09464914f, -0.05976973f, 0.31966332f, -0.00789811f, 
    -0.08130197f, -0.20959064f, 0.26914564f, 0.19832374f, 0.14663711f, -0.02469560f, -0.01861655f, 0.11544169f, 
    -0.05094093f, -0.02274573f, 0.05223821f, 0.09654403f, -0.14861588f, 0.28868589f, -0.12407503f, -0.25978407f, 
    -0.01482162f, 0.08505804f, -0.21240273f, 0.01797438f, -0.12940486f, 0.11290332f, -0.01145296f, 0.09488197f, 
    -0.47483775f, -0.18692794f, -0.00670552f, -0.14467874f, -0.05657510f, -0.10733193f, -0.07178968f, 0.01823737f, 
    0.02754422f, -0.03309047f, 0.11123915f, 0.18689808f, -0.04379272f, -0.09178116f, 0.26576853f, 0.02300769f, 
    0.01984994f, -0.08595310f, 0.13363351f, 0.08562525f, -0.10640795f, 0.04458010f, -0.12866084f, -0.10198088f, 
    0.15499742f, 0.24720295f, -0.53983873f, 0.22474748f, -0.02298445f, -0.05001165f, 0.23793794f, -0.06400629f, 
    0.05710054f, 0.08396318f, -0.03881091f, 0.00963855f, -0.05437928f, 0.07140553f, 0.11006519f, 0.18799581f, 
    -0.00269791f, -0.05404164f, 0.21180481f, -0.21794882f, 0.08514689f, 0.03201995f, -0.19839175f, -0.03239496f, 
    0.19228573f, 0.11410410f, 0.14681490f, 0.16841289f, 0.08948553f, -0.03550312f, -0.15894717f, 0.14434969f, 
    -0.07607814f, 0.05010541f, 0.08610822f, -0.21886003f, 0.38240224f, -0.08409315f, -0.36603376f, 0.24240510f, 
    -0.02770136f, 0.27003324f, 0.09293001f, 0.03128170f, 0.09416743f, -0.00200195f, 0.13369593f, -0.21325980f, 
    -0.16461281f, -0.22206259f, -0.17970964f, 0.18812478f, -0.05088630f, -0.19903249f, 0.04797557f, -0.01282667f, 
    -0.01964070f, 0.02119447f, 0.21157914f, -0.09281546f, -0.00868226f, 0.14321083f, 0.57116812f, 0.04309575f, 
    0.14156926f, 0.08016772f, 0.18786561f, 0.14491270f, 0.03162605f, -0.04815923f, 0.07676067f, -0.17777199f, 
    -0.02663908f, -0.01672379f, -0.05855436f, -0.08413990f, -0.09091800f, 0.05523309f, -0.12064959f, -0.10279682f, 
    -0.02106865f, -0.08190502f, 0.04652961f, 0.01946804f, -0.05120258f, -0.01079742f, 0.00112458f, -0.06299596f, 
    0.05144774f, -0.06931636f, -0.03475194f, 0.02392636f, -0.03333387f, 0.01579427f, -0.07701781f, -0.04657081f, 
    -0.06776726f, 0.00271957f, -0.02598771f, -0.10159731f, -0.04568060f, -0.02058486f, -0.06860802f, -0.10349632f, 
    -0.00282491f, -0.07081933f, -0.01372765f, -0.02031514f, -0.07285073f, -0.07814864f, -0.04521356f, -0.01820886f, 
    0.03974770f, -0.02085233f, -0.08920289f, -0.09075357f, 0.04694228f, -0.04364086f, -0.09275354f, -0.07912932f, 
    -0.08910892f, -0.06978167f, 0.00137027f, -0.02064950f, 0.00833284f, -0.06747501f, 0.03624208f, 0.05294068f, 
    -0.09247227f, -0.04145011f, -0.12814614f, -0.06565750f, 0.03841951f, -0.06241587f, 0.00836609f, -0.05831607f, 
    0.00945679f, -0.07687381f, -0.00351850f, -0.04147442f, 0.06639726f, -0.13867527f, 0.07571951f, -0.07878884f, 
    -0.02745025f, -0.08615112f, -0.02850102f, -0.01267387f, -0.01192871f, -0.09200271f, -0.06868758f, -0.02161115f, 
    -0.11364879f, -0.05330808f, -0.08467096f, -0.07838374f, -0.02522015f, -0.08217954f, -0.05500047f, -0.00588332f, 
    -0.09329052f, 0.00449434f, -0.05035925f, 0.01500888f, -0.00661253f, 0.01553812f, -0.00832636f, -0.04815077f, 
    -0.04652870f, -0.03822265f, -0.03947751f, -0.02881203f, -0.09116060f, -0.05396893f, -0.04688977f, -0.01378097f, 
    0.01427419f, -0.07507976f, 0.02108794f, -0.08240033f, -0.08661414f, -0.03604664f, -0.07073746f, -0.10080039f, 
    0.04729255f, -0.07026566f, -0.09531992f, -0.02858070f, -0.03851727f, -0.01931822f, -0.05371106f, -0.01344918f, 
    -0.05924143f, 0.01448520f, 0.05726912f, -0.09594852f, -0.06106994f, 0.03711487f, -0.01672730f, -0.05005529f, 
    0.03386794f, -0.01509839f, -0.03320196f, -0.12100652f, -0.05774464f, 0.01590540f, -0.06469148f, -0.05596001f, 
    0.02359778f, -0.02064812f, -0.01088784f, -0.01846144f, -0.11985217f, 0.02772156f, -0.00442821f, -0.02239949f, 
    0.06206658f, 0.01704982f, -0.04636871f, 0.04274066f, -0.02972964f, -0.08477595f, -0.08464073f, -0.02751121f, 
    0.04160495f, -0.00585617f, -0.01302564f, -0.00708767f, -0.06381078f, 0.02571238f, -0.07159692f, -0.00051624f, 
    -0.00881669f, -0.04976787f, 0.03123064f, -0.08513594f, 0.02172787f, -0.06063937f, 0.02977648f, -0.05540061f, 
    -0.01248601f, -0.02901102f, -0.04702102f, -0.07148414f, -0.03892150f, -0.01461382f, 0.03406908f, -0.02785524f, 
    -0.10753386f, -0.09014717f, -0.01791938f, -0.08859226f, 0.04290002f, 0.01526867f, -0.08899432f, -0.04909774f, 
    0.04460764f, -0.08433451f, -0.06153574f, -0.05891932f, -0.09885532f, -0.08949003f, 0.07086665f, -0.05848845f, 
    0.36388436f, 0.23168969f, 0.25675404f, -0.05884988f, -0.09968246f, -0.10595299f, -0.06573219f, -0.02924932f, 
    0.04401956f, 0.02696868f, -0.09931073f, 0.09601154f, -0.27199030f, 0.05071511f, -0.31577817f, -0.02291900f, 
    -0.06525961f, -0.04025850f, 0.00593339f, -0.02797694f, -0.06643661f, -0.03131155f, -0.03705829f, 0.06406116f, 
    0.22915231f, -0.18628550f, -0.00244422f, -0.15774286f, -0.01176026f, -0.06826348f, -0.03444180f, 0.12878193f, 
    -0.02679368f, 0.15577742f, 0.08557095f, 0.09003060f, -0.14923523f, -0.11854787f, -0.27791438f, -0.10698760f, 
    -0.04005529f, 0.05238865f, 0.08680215f, -0.16337210f, 0.05526313f, 0.01815012f, 0.04409340f, 0.00571426f, 
    -0.12826167f, -0.01965878f, -0.06870230f, 0.11195979f, -0.15730682f, 0.00900371f, 0.13048476f, 0.23362955f, 
    -0.04937467f, 0.11059764f, 0.13189134f, -0.06673494f, 0.26999336f, -0.26429176f, 0.40750369f, -0.03072998f, 
    0.01625611f, -0.10450433f, 0.10657272f, -0.00808731f, -0.02083941f, 0.10459094f, -0.00322607f, 0.03440899f, 
    -0.14458933f, 0.18469177f, -0.04174914f, -0.11522117f, -0.08055580f, -0.00034366f, 0.06261879f, -0.07034038f, 
    0.11866813f, -0.17176837f, 0.10098465f, -0.06754822f, 0.20113158f, -0.10450379f, 0.34184733f, 0.00836219f, 
    -0.10441796f, 0.09720392f, -0.09260212f, 0.00030424f, 0.27841586f, 0.05197510f, 0.03887052f, 0.01913064f, 
    0.30850098f, -0.26160368f, 0.03576822f, 0.23368017f, -0.04589916f, 0.01386613f, 0.05791825f, 0.22011317f, 
    -0.07956535f, 0.02559395f, -0.04743668f, -0.06810841f, -0.09433718f, 0.28777021f, -0.02546780f, 0.11971015f, 
    -0.20387110f, 0.03250840f, 0.07108881f, 0.08562663f, -0.01359946f, 0.00110977f, -0.08418853f, 0.02235650f, 
    0.31628475f, -0.07642003f, 0.05998555f, -0.32886237f, 0.04279587f, -0.08846813f, 0.17559206f, -0.00390433f, 
    0.11535636f, 0.03428742f, 0.04591254f, 0.05807620f, -0.14445399f, -0.19225790f, -0.12770453f, 0.10846475f, 
    -0.06705087f, 0.00525770f, -0.14184041f, 0.08176092f, -0.19368988f, -0.02430685f, -0.01502113f, 0.13149484f, 
    -0.01472426f, 0.76214361f, 0.25126886f, 0.07652358f, -0.28350621f, 0.00912799f, -0.02567624f, 0.04759752f, 
    -0.06792789f, 0.11506033f, 0.01735032f, 0.13786967f, -0.46549863f, -0.17122373f, -0.10220770f, -0.29666111f, 
    -0.15565850f, 0.11164713f, 0.02633407f, -0.05810674f, -0.05827129f, -0.08316162f, 0.03270546f, 0.03360344f, 
    -0.02482516f, 0.29692507f, 0.13715068f, -0.20636357f, -0.05226192f, 0.09166515f, 0.11321802f, -0.04708073f, 
    0.17385095f, -0.13279867f, 0.06392301f, -0.03577664f, -0.05662439f, -0.28360295f, 0.02217994f, -0.04940532f, 
    0.30349749f, 0.12599832f, -0.01530112f, -0.11420412f, -0.07416946f, 0.05837991f, 0.05065879f, -0.07773658f, 
    0.15437390f, -0.42725042f, -0.06899337f, -0.08953293f, 0.01103821f, 0.01286389f, -0.08605529f, 0.03024000f, 
    0.09746927f, -0.08066252f, 0.13435452f, -0.04698616f, 0.25532982f, 0.07681250f, 0.02827940f, -0.45959976f, 
    0.16228579f, 0.00288170f, 0.17748010f, 0.16950293f, -0.07944605f, 0.03578059f, 0.10063553f, -0.06886167f, 
    0.00048920f, -0.03497920f, -0.09922595f, 0.04029448f, 0.08420859f, 0.09057310f, -0.01467672f, -0.00662929f, 
    -0.00271781f, -0.00760751f, -0.02472944f, -0.00107995f, -0.19115099f, 0.16532601f, 0.09698653f, 0.15554105f, 
    0.04091835f, -0.07272149f, -0.06881685f, -0.06723793f, 0.02984164f, -0.03099153f, 0.06439450f, 0.09269901f, 
    -0.15913610f, 0.07210956f, -0.06482346f, -0.11721905f, 0.16289197f, 0.01753568f, -0.04391273f, 0.06826273f, 
    0.02740261f, -0.06810373f, 0.12452424f, 0.12927938f, -0.24188198f, -0.06682890f, -0.18689443f, -0.04212392f, 
    -0.01247970f, 0.01249651f, -0.00184112f, -0.09495424f, 0.09705764f, 0.23107806f, -0.10103328f, 0.20055684f, 
    0.38946143f, -0.01560341f, 0.24935323f, 0.07308088f, -0.11812785f, -0.05881777f, 0.00917944f, -0.02977541f, 
    0.13665746f, 0.18837668f, 0.05694346f, 0.28241250f, 0.16676381f, -0.00548325f, 0.00616199f, 0.11207966f, 
    -0.05883297f, -0.12335489f, -0.04295936f, -0.09338596f, 0.11595437f, 0.05090816f, 0.07579259f, -0.07214340f, 
    0.34263316f, 0.42187119f, -0.18281375f, -0.34205738f, 0.06279445f, 0.28872129f, 0.07559919f, 0.05084018f, 
    -0.02321977f, -0.03349608f, -0.10206628f, -0.04717368f, 0.08192053f, 0.20388596f, -0.00804744f, -0.17625709f, 
    0.20587024f, -0.06412471f, 0.24831484f, -0.02370982f, -0.06653190f, -0.13873440f, 0.03230102f, 0.01975754f, 
    -0.25233647f, -0.05359303f, -0.17161207f, 0.10310313f, -0.04843389f, 0.06852084f, -0.01881393f, -0.10678226f, 
    0.02106736f, 0.12575516f, -0.07857191f, 0.01227323f, 0.05955727f, 0.07654896f, 0.02478565f, -0.13469245f, 
    0.06696355f, 0.04576991f, -0.17445529f, 0.05244237f, 0.04565101f, 0.04875937f, 0.00558338f, -0.09711074f, 
    -0.06643827f, -0.19970402f, -0.02916099f, -0.00230805f, 0.12419090f, -0.04785029f, 0.13984671f, -0.07274323f, 
    0.05562508f, 0.04002380f, 0.01539348f, 0.15420446f, -0.18099385f, 0.14403766f, -0.17049864f, 0.26034394f, 
    0.13029064f, 0.03413621f, 0.02632714f, -0.08053704f, -0.05776426f, -0.00001727f, -0.01607291f, 0.13760678f, 
    -0.14505316f, 0.07340370f, 0.01928748f, 0.09133717f, 0.10515756f, 0.02831998f, 0.06383760f, -0.06383038f, 
    -0.02792626f, 0.06955800f, -0.03063058f, 0.16782898f, 0.26657999f, 0.14760394f, -0.35906905f, -0.11183848f, 
    -0.05727519f, -0.05695917f, 0.18658054f, 0.16849872f, 0.02940525f, 0.02766241f, -0.06244575f, 0.14030334f, 
    -0.18613799f, 0.16337192f, 0.27830854f, 0.05906046f, 0.06601769f, -0.11143941f, 0.07074106f, -0.05285385f, 
    -0.07299186f, 0.19919825f, 0.08578046f, 0.19760533f, -0.03437167f, -0.19705904f, 0.05636148f, 0.24495311f, 
    -0.22758408f, -0.25984246f, -0.11976152f, 0.16020374f, 0.04538879f, -0.11676658f, -0.12616195f, -0.03610986f, 
    -0.11790863f, -0.23178306f, -0.00803836f, 0.38434523f, 0.08154899f, 0.09764609f, 0.03679908f, -0.08104257f, 
    0.02009237f, 0.29360953f, 0.22111265f, 0.27993920f, 0.10769539f, -0.11724862f, -0.07149616f, -0.03163608f, 
    0.04930235f, 0.10443674f, 0.02967042f, 0.10732368f, -0.00687175f, -0.04881242f, -0.00550696f, -0.12184947f, 
    0.13106616f, -0.12786038f, -0.03869043f, -0.09731311f, 0.00426449f, 0.19419442f, 0.03217097f, 0.10284635f, 
    -0.17169812f, -0.10719788f, -0.04367089f, -0.08682235f, 0.06996505f, -0.06328728f, 0.09966994f, -0.16550171f, 
    0.03131639f, 0.10275429f, -0.05803974f, -0.06188772f, -0.11254217f, 0.02819768f, 0.26311666f, 0.06061871f, 
    -0.20953171f, -0.02331334f, -0.22679137f, 0.01052708f, 0.11492333f, -0.01793053f, -0.05353575f, 0.04791547f, 
    -0.20438530f, 0.10961796f, 0.01772363f, -0.22764662f, -0.00114394f, 0.12261929f, -0.04889139f, 0.00115730f, 
    0.02462124f, 0.00299487f, -0.09912933f, 0.00582868f, -0.02863880f, 0.16343860f, 0.30698246f, 0.34523517f, 
    -0.33099750f, -0.40436119f, -0.16934206f, 0.22501792f, -0.24444400f, -0.06378940f, -0.06143613f, -0.25828087f, 
    -0.00363215f, 0.02438633f, 0.12083138f, -0.01953309f, -0.13712792f, 0.10180425f, 0.29008168f, 0.01552005f, 
    -0.06815062f, -0.39458388f, -0.06120307f, 0.08649658f, 0.04335807f, -0.02784665f, 0.04083185f, -0.15750803f, 
    0.08696907f, 0.07870446f, -0.05839011f, -0.04361669f, -0.02501649f, 0.04439517f, 0.14724435f, 0.01688651f, 
    -0.10129572f, 0.00239189f, -0.01340780f, -0.09400030f, 0.10222030f, 0.00549547f, -0.18573478f, 0.18399547f, 
    0.12680015f, 0.00890171f, 0.19750120f, -0.22539568f, 0.00381954f, -0.08409899f, -0.11370029f, -0.07423294f, 
    0.37829778f, 0.25311601f, 0.43238288f, 0.34179458f, -0.02985316f, -0.06594471f, -0.10691446f, 0.10117270f, 
    -0.10507569f, -0.07203090f, -0.06544987f, 0.07267203f, 0.16951045f, 0.08844794f, -0.05252650f, -0.14490750f, 
    0.03504750f, 0.06971885f, 0.13808946f, 0.07227822f, 0.03231653f, -0.00875447f, -0.03035687f, 0.00023936f, 
    0.00721422f, -0.15126640f, -0.11109212f, -0.17519173f, 0.09858277f, -0.04691121f, 0.07516113f, 0.07582131f, 
    -0.11080065f, 0.08803398f, 0.02134966f, -0.21226020f, -0.08147798f, -0.05924707f, 0.20165871f, 0.11356356f, 
    0.13252358f, 0.05436086f, -0.00933544f, 0.06932212f, 0.04325952f, 0.18809673f, 0.04396042f, -0.16240554f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04773970f, 0.05158260f, -0.05726966f, 0.10334454f, -0.03250635f, -0.07975654f, 0.09726748f, -0.01374433f, 
    0.02230845f, -0.13502569f, -0.02787199f, 0.11206488f, -0.01293016f, 0.12814261f, -0.03653511f, 0.11306059f, 
    0.09251475f, 0.07983906f, -0.00189537f, -0.01159577f, -0.00749153f, 0.28608814f, 0.07642029f, 0.13359670f, 
    0.26856562f, 0.03675498f, 0.31352669f, 0.03373375f, 0.21315899f, 0.03238671f, 0.08715559f, 0.02067120f, 
    0.01177647f, 0.07297820f, -0.14722446f, 0.06322120f, 0.08134375f, -0.09526750f, 0.04851371f, -0.09939282f, 
    -0.06643604f, -0.01409923f, 0.04021055f, -0.13577504f, 0.14393701f, 0.05596660f, 0.05501389f, 0.00255246f, 
    0.08267665f, 0.12367115f, 0.04444487f, -0.00181550f, 0.02884090f, 0.16052248f, 0.09471539f, 0.06109791f, 
    0.21991016f, 0.12372854f, -0.00754418f, -0.01659801f, -0.11894796f, 0.05614054f, -0.01540765f, 0.03458210f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.13118429f, -0.00772996f, 0.07514907f, -0.05224249f, 0.06968348f, -0.02518040f, 0.23555076f, -0.01034554f, 
    0.04600413f, 0.22332339f, -0.23054592f, 0.03360976f, -0.08497948f, -0.15842362f, 0.18894297f, 0.15574336f, 
    -0.35149172f, -0.41821378f, 0.10541254f, 0.13005818f, 0.18066368f, -0.36669344f, -0.27655452f, -0.14236124f, 
    -0.39825907f, 0.04431093f, -0.26821449f, 0.09407660f, -0.07436873f, -0.67445874f, -0.60509765f, -0.04139250f, 
    -0.38460934f, -0.52875340f, 0.23838660f, -0.16220589f, 0.23958255f, -0.07854454f, -0.02103621f, 0.16242084f, 
    0.39214194f, 0.08456475f, -0.09705993f, 0.51215839f, 0.12754095f, 0.01052655f, -0.05716892f, -0.16748726f, 
    -0.43980622f, -0.09868079f, -0.11830939f, -0.03747655f, -0.16947228f, -0.32177410f, 0.25131634f, 0.02902644f, 
    -0.09440328f, -0.84657758f, -0.30474693f, -0.45981568f, 0.05854429f, 0.02017710f, 0.24752356f, -0.21357106f, 
    -0.20218974f, 0.08755454f, 0.21329378f, 0.08216505f, 0.13881272f, 0.01935496f, 0.01122106f, 0.01526446f, 
    -0.00468199f, -0.20147371f, 0.44432196f, 0.16896214f, 0.15878856f, -0.47740501f, 0.03020751f, -0.03755745f, 
    0.10012649f, -0.71911305f, -0.41757670f, -0.57448131f, 0.15619260f, -0.07159337f, -0.24739900f, 0.24426694f, 
    0.17687522f, 0.13545331f, 0.25925529f, 0.08624282f, 0.03376956f, 0.40403688f, -0.20291504f, -0.05317635f, 
    0.15325668f, -0.37975338f, -0.67359841f, 0.07708880f, 0.23409852f, -0.07033548f, -0.12778397f, 0.36160973f, 
    -0.41526335f, 0.11794348f, -0.00101163f, 0.07477862f, -0.00415171f, 0.00734666f, 0.09278973f, -0.19420929f, 
    0.04071835f, 0.19208570f, -0.20764019f, 0.11265392f, 0.04499178f, 0.15544927f, 0.26693994f, -0.11601402f, 
    -0.08043563f, 0.17040671f, 0.33916599f, -0.58373016f, 0.02796369f, 0.09032231f, 0.02165452f, -0.36114404f, 
    0.01943846f, 0.02066344f, -0.00256713f, 0.02156341f, -0.62103301f, 0.00200397f, -0.08240369f, -0.12349406f, 
    0.02134925f, -0.65353209f, -0.06124267f, -0.18407364f, -0.15320401f, -0.01781384f, -0.01056591f, 0.11565202f, 
    -0.16013344f, 0.13129205f, 0.32213360f, 0.33024922f, -0.24396685f, 0.22706148f, -0.03589670f, -0.03623047f, 
    0.20459132f, -0.19399856f, 0.17363487f, 0.05808123f, 0.25988576f, -0.77273864f, 0.07435348f, -0.00831576f, 
    -0.31557676f, -0.15212579f, -0.15497936f, 0.16309515f, 0.18903162f, 0.06494269f, 0.04384575f, -0.29184088f, 
    -0.91699648f, 0.00289315f, 0.08220213f, 0.00826524f, -0.03689693f, 0.20533916f, -0.00354908f, -0.00196997f, 
    0.10733748f, 0.25921929f, 0.17653944f, 0.09015507f, -0.40505734f, 0.33104280f, -0.13227500f, -0.57886767f, 
    0.19285250f, 0.11648171f, -0.69308257f, -0.19057143f, -0.09947437f, 0.17547975f, -0.10684400f, 0.02697807f, 
    -0.20345153f, 0.06881653f, 0.12769990f, 0.04117311f, 0.10651216f, 0.10506736f, -0.00575012f, 0.15700433f, 
    0.10563008f, 0.22783761f, 0.00144319f, 0.07764842f, 0.17497106f, 0.30605224f, -0.23458534f, -0.04446205f, 
    -0.20357189f, 0.35082799f, 0.20280726f, 0.30706239f, 0.06429558f, -0.33744892f, 0.36765641f, -0.43102181f, 
    -0.28909329f, 0.44923705f, -0.24547400f, -0.72319621f, -0.49747235f, 0.23335677f, -0.04137828f, 0.06779272f, 
    -0.22412175f, -0.12426449f, -0.16234060f, 0.15512063f, -0.20720507f, -0.10463190f, -0.03669752f, 0.19591489f, 
    -0.18704310f, -0.11690266f, -0.03333201f, -0.01574834f, -0.31954554f, 0.19529526f, 0.02598604f, -0.24458274f, 
    0.00678345f, -0.30112493f, 0.31991422f, -0.00055932f, -0.06161839f, 0.09498649f, -0.08409999f, -0.11776731f, 
    0.12828167f, 0.13536535f, -0.48551115f, 0.08898044f, -0.09208067f, -0.49223801f, -0.01377625f, 0.09954344f, 
    0.12211903f, -0.04688996f, 0.11785861f, -0.17698570f, -0.83580494f, 0.02632016f, 0.02579454f, -0.23004697f, 
    0.02904110f, 0.16702186f, -0.26011837f, 0.06297152f, 0.00929639f, 0.08491739f, 0.02411452f, -0.10490181f, 
    -0.02651130f, 0.00518457f, 0.35026020f, -0.03298044f, -0.01066535f, 0.07878684f, 0.00583916f, 0.19548561f, 
    -0.16485789f, -0.48610437f, -0.33036679f, 0.21156240f, -0.21098332f, -0.21765238f, -0.20383668f, -0.02832261f, 
    0.08739714f, 0.13317303f, 0.31563881f, -0.08890589f, 0.08210571f, -0.03393038f, 0.09052482f, -0.05497433f, 
    0.38892275f, -0.07912911f, -0.10334180f, -0.21225217f, 0.07920645f, -0.03458393f, 0.15557633f, 0.22943309f, 
    0.24737322f, 0.25740150f, -0.34839210f, 0.06624927f, -0.13977081f, -0.27371085f, -0.36454967f, -0.21041925f, 
    -0.54554129f, 0.06007594f, 0.08397590f, 0.20251298f, 0.05245101f, -0.07291814f, -0.10405717f, 0.27662885f, 
    -0.07675657f, 0.10967746f, -0.09830166f, 0.27875122f, -0.34192708f, 0.07621977f, 0.14217503f, 0.23377943f, 
    0.01168408f, 0.13407287f, -0.05518195f, 0.19355594f, -0.13667385f, 0.11250903f, -0.02949183f, 0.32395265f, 
    0.15374531f, -0.37295032f, -0.46398449f, -0.07313054f, -0.02496797f, 0.02086710f, -0.02754079f, -0.31742647f, 
    0.14134090f, -0.13940810f, 0.18156298f, 0.20513144f, -0.11658201f, -0.05779678f, 0.13454957f, -0.06423270f, 
    -0.00274565f, 0.16031575f, -0.07439233f, -0.56183487f, -0.25258714f, -0.08933363f, 0.01027960f, -0.22368687f, 
    -0.06636323f, 0.02091351f, -0.04300159f, -0.45350182f, 0.21898089f, 0.16646090f, -0.13972756f, 0.09211212f, 
    0.17525759f, -0.05578741f, -0.45382831f, -0.00515820f, 0.07049647f, -0.03345665f, -0.51644611f, 0.26360390f, 
    0.01393276f, -0.65512198f, -0.06415391f, 0.35939285f, -0.05301822f, -0.26427490f, 0.07180805f, -0.38856784f, 
    -0.51361406f, -0.05248562f, -0.76870638f, -0.71322304f, 0.09937081f, 0.04487162f, -0.19986710f, -0.09245295f, 
    0.08615213f, -0.79346657f, -0.33595741f, -0.39770418f, -0.58747935f, 0.29259497f, -0.14575562f, -0.62339407f, 
    0.21106149f, 0.25510004f, -0.30212244f, 0.19756398f, -0.20698367f, -0.02257200f, 0.17064282f, -0.05708084f, 
    0.19338283f, -0.54896903f, -0.06322768f, 0.10047856f, 0.37080476f, -0.47933251f, 0.09176235f, -0.08749413f, 
    -0.43232098f, 0.03243348f, -0.34894076f, -0.12578490f, -0.24501427f, -0.09707178f, 0.01298881f, -0.25944117f, 
    -0.24930236f, -0.09909634f, 0.03679334f, -0.20767845f, 0.07691360f, -0.60939974f, -0.08547214f, 0.19461396f, 
    -0.16076775f, -0.21700191f, 0.06509612f, 0.03117672f, 0.00655076f, 0.19672720f, 0.05060600f, 0.31398311f, 
    0.17931117f, 0.36515796f, -0.03185333f, 0.18611506f, -0.10829421f, 0.25286290f, -0.13722715f, 0.25009882f, 
    0.23305546f, -0.03271928f, -0.35476938f, 0.03237101f, 0.17625201f, 0.11058716f, -0.13379018f, 0.17534883f, 
    0.07273862f, -0.02674896f, 0.24003503f, -0.30337957f, 0.01552065f, -0.42221197f, -0.08700331f, -0.38360482f, 
    -0.25827417f, 0.14835863f, -0.23652382f, 0.30257136f, -0.50675851f, -0.20094122f, 0.07858796f, 0.14099416f, 
    0.07652135f, 0.27700081f, -0.05763043f, -0.02016243f, -0.35436323f, -0.09513565f, 0.23136833f, -0.05688466f, 
    0.18855973f, 0.20679365f, 0.53511935f, 0.09820528f, -0.55703932f, 0.09047577f, 0.07595301f, -0.18850186f, 
    0.14530453f, -0.00088310f, -0.05147802f, 0.33992895f, -0.27162847f, -0.68249178f, -0.20159237f, 0.27170312f, 
    0.21641520f, -0.29493022f, 0.04476350f, 0.04592037f, -0.20003970f, -0.25852785f, -0.38882172f, -0.23589097f, 
    0.04347862f, -0.07905526f, 0.22390829f, 0.09700262f, -0.00302345f, 0.00644674f, -0.10353099f, -0.18590227f, 
    0.25832731f, -0.01628424f, -0.72701794f, 0.26767978f, -0.27188855f, 0.00524244f, 0.17294045f, 0.03668734f, 
    -0.08884467f, -0.62289512f, -0.28182140f, 0.16775523f, 0.21660700f, 0.18934667f, -0.30065313f, -0.20070565f, 
    -0.03298528f, 0.16002002f, -0.20498957f, -0.45686430f, 0.11836524f, 0.27610949f, 0.29229331f, 0.21989958f, 
    0.07196905f, 0.27025446f, 0.24500926f, -0.38034505f, -0.12499249f, -0.11324942f, 0.14344797f, 0.05404495f, 
    0.12704109f, 0.12028262f, -0.50411683f, 0.23109661f, -0.15418880f, 0.07476944f, -0.05107202f, -0.49221078f, 
    -0.21316633f, -0.05502430f, 0.01259910f, -0.11902742f, -0.52613890f, -0.36553010f, -0.38431665f, -0.28289738f, 
    -0.44073692f, 0.23620370f, 0.33849838f, 0.06717155f, -0.15343659f, -0.01898247f, 0.07738778f, 0.21560261f, 
    0.05472405f, -0.38896307f, -0.31055066f, -0.29785353f, 0.00250108f, -0.08604930f, 0.23697858f, -0.31420594f, 
    0.05482284f, 0.11207193f, 0.01907143f, -0.54255337f, 0.42143852f, -0.10099622f, -0.33358076f, -0.57856917f, 
    -0.06548756f, 0.19386579f, -0.14400388f, 0.24417341f, -0.10771624f, -0.23822354f, 0.03201000f, -0.30043119f, 
    0.06107683f, -0.43413392f, 0.09720086f, 0.05275578f, -0.37995213f, -0.40045458f, -0.07062872f, 0.01976945f, 
    -0.13599510f, -0.38421163f, -0.32397428f, 0.10785679f, 0.19825415f, -0.02233859f, -0.02839833f, -0.02208713f, 
    0.37226787f, 0.02286446f, 0.23493461f, -0.19498861f, -0.02871910f, -0.02962472f, 0.04843270f, -0.52791202f, 
    -0.17186652f, -0.04120171f, 0.08156777f, 0.20521182f, 0.27698267f, 0.08605132f, -0.65775311f, 0.24200520f, 
    0.38748962f, -0.00543474f, 0.12976405f, -0.06839910f, 0.09979136f, 0.24667658f, -0.28989950f, -0.19632460f, 
    -0.02485535f, 0.13874337f, -0.13275546f, 0.21583229f, 0.08590145f, 0.03133902f, 0.29592988f, 0.26453084f, 
    0.24208789f, -0.09001569f, -0.42414907f, 0.08243972f, -0.32493871f, -0.10437267f, 0.09328787f, -0.01588512f, 
    -0.05012343f, -0.44585913f, -0.35999396f, -0.12731856f, 0.05028687f, 0.15638034f, -0.81840760f, -0.00301504f, 
    -0.16433136f, -0.20671277f, -0.57177240f, -0.53919506f, -0.27519387f, -0.08476932f, -0.22985227f, -0.45243421f, 
    -0.09212797f, 0.34672987f, -0.02472021f, -0.29858959f, -0.15795358f, -0.13809495f, 0.02098160f, 0.00316541f, 
    0.23226263f, 0.28964084f, -0.68324089f, 0.35918000f, 0.22737458f, -0.03065262f, 0.09417744f, 0.38921326f, 
    -0.03895239f, -0.08811377f, 0.06379949f, 0.13994518f, 0.26645240f, 0.19702421f, 0.39253858f, 0.11007132f, 
    0.10756098f, -0.33033565f, 0.08633285f, -0.07448087f, 0.51581782f, -0.04412244f, 0.18852736f, 0.37826353f, 
    -0.32935646f, -0.25683519f, -0.25932068f, 0.31515726f, -0.00955642f, 0.34931144f, -0.43086913f, 0.08515973f, 
    -0.25704926f, 0.09529142f, -0.08952972f, -0.24959265f, 0.19433324f, -0.00951652f, -0.54479373f, -0.13519090f, 
    -0.07761810f, 0.10773148f, -0.16877533f, -0.37700021f, 0.18449961f, -0.05558458f, 0.32340989f, 0.28551012f, 
    0.24877258f, 0.50442380f, -0.05949308f, -0.46801224f, 0.42965838f, 0.32193926f, 0.19673495f, -0.07703655f, 
    0.01080812f, -0.52337444f, -0.06146761f, -0.24531083f, 0.08215462f, 0.00260273f, 0.11065471f, 0.07667707f, 
    0.15426816f, 0.00782063f, -0.03510157f, 0.30575708f, 0.05643412f, -0.04667154f, -0.04461493f, -0.79002327f, 
    -0.58529127f, -0.05054902f, 0.11174084f, -0.40617067f, -0.34661531f, -0.11554656f, 0.19424812f, -0.32998478f, 
    -0.26601043f, -0.54259294f, -0.00566725f, 0.02520313f, 0.31200501f, -0.43284729f, 0.54690975f, 0.21512760f, 
    -0.02218306f, 0.03762687f, -0.04116756f, 0.02954873f, 0.02067533f, -0.60585350f, -0.34026021f, 0.25899649f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.01349519f, 0.03770171f, -0.01370537f, -0.16333580f, 0.02191910f, 0.05157649f, 0.06379148f, -0.22383937f, 
    0.14740454f, 0.13089100f, -0.02826259f, 0.02072488f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
