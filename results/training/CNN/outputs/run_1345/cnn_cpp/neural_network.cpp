#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.54678464f, -0.67235464f, -0.25088611f, 0.02616330f, -0.79285461f, -0.21994385f, 0.72906297f, 0.24794513f, 
    -0.12139548f, -0.72431207f, -0.07037916f, -0.43396640f, 0.50478196f, -0.67212504f, -0.45103073f, -0.28199559f, 
    -0.22687757f, -0.33424243f, 0.60501456f, 0.69658709f, 0.15477011f, -0.56768739f, 0.65863973f, -0.07254531f, 
    -0.26442489f, 0.05487407f, -0.27859187f, -0.74050492f, 0.47094485f, 0.13201451f, -0.02011964f, 0.45660800f, 
    0.58386624f, -0.34993824f, -0.54630828f, -0.35045022f, -0.69585514f, -0.22540727f, -0.36324349f, 0.50899082f, 
    0.82956827f, -0.30627021f, -0.30176875f, -0.49909070f, -0.55057579f, 0.94477040f, -0.57223195f, 0.41741833f, 
    -0.34071833f, -0.04363267f, 0.10676049f, 0.58882165f, -0.42705366f, -0.29873958f, -0.13265842f, 0.52028251f, 
    0.31554258f, -0.56478971f, 0.37298816f, -0.26951897f, -0.15347990f, 0.43546492f, -0.19149920f, 0.60567617f, 
    1.11806428f, -0.79126769f, -0.70021313f, -0.71668196f, -0.05081304f, -0.12871584f, -0.22383769f, 0.38299540f, 
    -0.25828141f, -0.36340711f, 0.42223737f, -0.29326043f, -0.67387855f, -0.94145888f, 0.58418441f, 0.50162953f, 
    0.30298439f, -0.79630327f, -0.25984639f, -0.37181014f, -0.47037163f, -0.91662961f, 0.05525161f, -0.26334539f, 
    -0.29687706f, 0.37139225f, 0.09109085f, -0.14746454f, 0.57241881f, 0.20483990f, 0.29012635f, 0.19674893f, 
    0.06268939f, 0.33197522f, 0.04306106f, -0.35699475f, -0.44396126f, 0.45752171f, 0.55583525f, 0.37108558f, 
    -0.56605405f, -0.17815901f, 0.16663609f, -0.05151968f, -0.09619765f, -0.24605426f, -0.37094000f, -0.33301762f, 
    0.21001954f, 0.50050652f, -0.08382292f, 0.47308150f, 0.17693366f, 0.64091998f, -0.29212826f, 0.12394606f, 
    0.00509009f, -0.45529184f, -0.17971499f, -0.02444237f, 0.26653096f, 0.42527527f, -0.38465780f, 0.15040557f, 
    0.03485433f, 0.72761697f, -0.61933041f, 0.18221004f, -0.07705788f, 0.35730910f, 0.23335731f, -1.41527379f, 
    0.15251903f, 0.21028812f, -0.24428162f, 0.39002040f, 0.29022586f, 0.30134651f, 0.18810491f, -0.12472985f, 
    0.25319135f, 0.54082942f, -0.37451428f, -0.37864900f, 0.26093912f, -0.31918159f, -0.07580569f, 0.26358920f, 
    0.12657060f, -0.73475820f, 1.02587903f, -0.35292062f, -0.72262323f, -0.30314797f, 0.67385465f, -0.26990390f, 
    -0.06667884f, 0.40547943f, -0.67802691f, -0.95624644f, -0.46553150f, 0.72292137f, 0.34849617f, -0.63079774f, 
    -0.08474642f, -0.30112186f, -0.19286802f, -0.47712398f, 0.00327042f, -0.41224304f, 0.49026218f, 0.53642207f, 
    0.48069617f, 0.48476157f, -0.21458264f, 0.02908951f, -0.44107944f, -0.39542654f, -0.82073903f, -0.34504128f, 
    0.70233977f, -0.11453467f, -0.04776628f, -0.23887360f, -0.70933294f, 1.27559185f, -1.11581564f, 0.17244288f, 
    0.07805814f, 0.66049463f, -0.27181533f, -0.16407360f, -0.05838672f, -0.36707789f, -0.24292120f, 0.22485696f, 
    -0.69648570f, 0.57479393f, -0.39711732f, -0.10625110f, 0.37437209f, -0.09703646f, 0.35046366f, 0.72685343f, 
    0.39428937f, 0.38076264f, -0.09868108f, -0.65353650f, -0.46896350f, 0.07463124f, -0.10387176f, 0.47111869f, 
    0.39737517f, -0.95362687f, -0.53975892f, -0.15595150f, -0.46212494f, 0.91297400f, 0.07324579f, -0.07873037f, 
    -0.35656375f, -0.04186536f, 0.65536594f, 0.33740985f, -0.83086085f, -0.66960114f, 0.55661964f, 0.21311256f, 
    0.17779247f, -0.29294544f, 0.46348298f, -0.06212392f, -0.15982583f, 0.12096376f, 0.29324287f, 0.06753634f, 
    0.14449950f, 0.39572576f, -0.35150146f, 0.99328393f, -1.07108188f, -0.38631350f, 0.19918783f, 0.53127110f, 
    -0.31369743f, 0.00206332f, -0.64439869f, 0.46618605f, 0.64581943f, 0.30444661f, -0.68029195f, 0.60276902f, 
    -0.13061887f, 0.29578018f, -0.09416922f, 0.25308415f, -0.22204599f, 0.69431800f, -0.02484835f, 0.33296028f, 
    0.46268955f, -0.14801067f, 0.33180955f, 0.34407756f, -0.37374157f, -0.40814725f, -0.57924736f, -0.30286166f, 
    -0.47042003f, 0.72542226f, 0.50738001f, 0.25540712f, 0.26249477f, 0.20069788f, 0.02646386f, 0.21128647f, 
    0.35977378f, -0.24884892f, -0.23220932f, -0.53716087f, -0.63256168f, -0.26998752f, -0.42300311f, -0.55497068f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22946358f, -0.29059610f, -0.04021284f, -0.07602324f, 0.16469042f, 0.05905288f, 0.33470881f, -0.05316511f, 
    0.13396883f, -0.18378937f, -0.34363794f, 0.44741356f, -0.03873743f, 0.12307609f, -0.29394346f, 0.19361496f, 
    0.11670956f, 0.14118430f, -0.15959351f, -0.19214416f, -0.07619716f, 0.05004936f, 0.07541433f, -0.01979607f, 
    0.02155467f, 0.11237070f, 0.16145289f, 0.07290152f, -0.05720688f, -0.30443642f, -0.33946601f, 0.03816631f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.43436900f, 0.22638506f, 0.31780973f, -0.26106763f, -0.11396284f, 0.12258970f, -0.01012296f, 0.17399041f, 
    0.02996757f, 0.05385720f, 0.22312851f, -0.02214933f, -0.06024386f, -0.00301316f, 0.00422705f, -0.01714727f, 
    -0.05118722f, -0.05047705f, 0.05733344f, 0.02458856f, 0.30683336f, 0.34780172f, 0.24121222f, -0.34319127f, 
    0.00826413f, 0.02076222f, 0.15549211f, 0.12425939f, -0.08297207f, 0.09435079f, 0.11433771f, -0.13002339f, 
    0.04955303f, -0.03451639f, -0.00662635f, 0.04944386f, -0.11612605f, 0.01344501f, -0.08250351f, -0.02990215f, 
    -0.43370855f, -0.10761166f, -0.46377882f, 0.21243973f, -0.06149746f, 0.06954873f, 0.07376357f, 0.01442538f, 
    0.04625136f, 0.02015147f, 0.09080557f, 0.09591983f, 0.00217070f, 0.08948927f, -0.00292148f, -0.11401024f, 
    0.07411280f, 0.04295593f, -0.03230541f, 0.03395426f, -0.18522719f, 0.08717803f, 0.12196001f, 0.28838482f, 
    -0.01237864f, 0.07443394f, -0.00153454f, 0.04679931f, 0.09680366f, 0.07225541f, -0.08676965f, 0.08877815f, 
    0.07178354f, 0.05057308f, 0.04686232f, -0.06895372f, -0.07403671f, 0.13202836f, 0.13179967f, 0.09661001f, 
    0.08683298f, 0.10036983f, -0.28503358f, -0.12193761f, -0.22430809f, -0.12100976f, -0.03247898f, -0.00224109f, 
    0.10955129f, 0.07327836f, -0.08904998f, 0.01884785f, -0.12660979f, 0.04354881f, -0.02911304f, -0.10877346f, 
    -0.06342514f, 0.07852209f, -0.02093727f, -0.07319349f, -0.16967052f, -0.44386402f, 0.11083522f, -0.24480002f, 
    0.24246818f, -0.07251313f, 0.06714167f, 0.00917755f, 0.00487294f, -0.11238803f, 0.02823589f, 0.04703508f, 
    0.07529175f, 0.12188372f, 0.04481744f, 0.02380094f, -0.09072611f, 0.03361133f, 0.13555829f, 0.02812245f, 
    -0.43249458f, -0.03508973f, -0.22276421f, 0.12803645f, -0.27134132f, -0.02548405f, -0.00198827f, -0.02575206f, 
    0.04906205f, -0.03364575f, -0.02208560f, 0.09449700f, -0.03497648f, 0.02548617f, -0.11529928f, 0.03919737f, 
    0.01591153f, 0.06055940f, -0.11818413f, 0.02279648f, 0.03434715f, 0.63977253f, 0.01649483f, 0.00150369f, 
    -0.13728055f, 0.08254522f, -0.14669202f, 0.16249056f, 0.21161944f, 0.26450849f, 0.07085514f, 0.03122726f, 
    0.03772897f, 0.02985445f, 0.02646982f, 0.12093835f, 0.14985310f, 0.10138752f, 0.09724483f, 0.02882080f, 
    0.46623707f, 0.44621804f, 0.27107152f, -0.08903437f, -0.02045117f, -0.05122875f, 0.02728810f, 0.06268409f, 
    0.08362241f, 0.03186089f, 0.08106155f, -0.00396602f, 0.10304420f, -0.07340630f, -0.03433181f, 0.09023107f, 
    0.01511828f, -0.01042502f, 0.12091316f, 0.14127393f, 0.38786212f, 0.25662032f, 0.28026602f, -0.27023560f, 
    0.05842786f, 0.28394514f, 0.16891822f, 0.16718516f, 0.10922226f, 0.06508300f, 0.11226451f, -0.05810570f, 
    -0.05233244f, -0.03393919f, -0.07192128f, -0.03109681f, -0.06000477f, -0.02295380f, 0.16646515f, -0.12437371f, 
    -0.02611741f, -0.01082460f, 0.03419883f, 0.06271903f, 0.02684829f, 0.03847203f, 0.09529632f, -0.00800601f, 
    0.00066975f, -0.02275122f, -0.04699344f, -0.15611687f, -0.05617226f, 0.00860554f, -0.13462459f, 0.02265638f, 
    0.09114007f, 0.00725600f, -0.00113762f, 0.03467903f, -0.00259014f, 0.03137276f, -0.25964445f, -0.22689670f, 
    -0.09718519f, -0.18475361f, 0.03766051f, -0.00059236f, -0.08731418f, 0.08826555f, -0.07917747f, -0.03826745f, 
    -0.05970918f, -0.04877742f, 0.04112678f, -0.03871471f, 0.09047554f, -0.00014014f, -0.03740683f, 0.11702482f, 
    -0.04110196f, -0.07777939f, -0.13792752f, 0.07907087f, -0.01496457f, 0.09097146f, -0.01441430f, -0.02748538f, 
    0.02191425f, -0.02016960f, -0.16659537f, -0.03270641f, 0.02641493f, 0.09147198f, 0.01449371f, 0.05284378f, 
    0.05711796f, 0.07751001f, -0.04247919f, 0.12422781f, 0.15457509f, -0.06307836f, 0.14384979f, -0.03660279f, 
    0.06973698f, -0.09920263f, 0.12477174f, 0.08820999f, 0.09656904f, -0.06784100f, 0.00172324f, -0.04009954f, 
    0.04048914f, -0.12802678f, -0.07015172f, 0.02646140f, 0.03960878f, -0.05651053f, -0.05639205f, 0.04933232f, 
    0.07805283f, 0.04353140f, 0.05191950f, -0.10512254f, 0.04721924f, -0.02223365f, 0.09003858f, 0.07234333f, 
    -0.05954517f, -0.00061591f, 0.15352347f, -0.07135440f, 0.22450747f, 0.00883709f, 0.01595206f, 0.08856321f, 
    0.05677150f, -0.05494916f, -0.06780244f, 0.02797601f, -0.17746079f, 0.05383209f, -0.10063569f, -0.00515010f, 
    -0.14756908f, 0.16138761f, 0.07031853f, 0.06893130f, 0.17863984f, -0.07801198f, 0.02508813f, -0.17670307f, 
    -0.03037131f, 0.01100595f, 0.09052942f, 0.00114393f, 0.08920742f, 0.03375006f, -0.02456450f, 0.02734008f, 
    -0.08987312f, 0.18159482f, -0.11383732f, -0.00194309f, -0.10506988f, -0.10320642f, -0.03479861f, 0.10406733f, 
    0.10771383f, 0.08381400f, -0.00615691f, 0.03026900f, -0.02923232f, 0.05347455f, 0.01300460f, 0.11485980f, 
    0.12996836f, -0.05686907f, -0.06372219f, -0.07061531f, -0.26294076f, 0.33867741f, 0.27166837f, 0.18780780f, 
    -0.26303056f, 0.03624188f, -0.07391720f, -0.02048969f, -0.05894217f, -0.00659889f, -0.01980248f, -0.04658938f, 
    0.01256360f, 0.10311795f, -0.15711024f, 0.05543536f, 0.12466274f, -0.02301998f, -0.13296629f, 0.12093195f, 
    0.35001215f, 0.07117315f, -0.33448172f, -0.28892839f, -0.19810131f, -0.00699022f, 0.08811162f, 0.19751810f, 
    -0.07976665f, 0.13037542f, 0.05544988f, -0.07613540f, -0.03869448f, 0.09908594f, 0.11768831f, -0.01782642f, 
    0.02348877f, 0.03949607f, 0.03786987f, -0.00296838f, 0.12318092f, 0.15630823f, -0.38656563f, 0.04983054f, 
    -0.13104551f, 0.13346286f, 0.14597884f, 0.01922910f, 0.00439631f, 0.01233937f, -0.03000680f, -0.07216644f, 
    0.02391544f, -0.02707422f, -0.05201738f, 0.09559216f, 0.15234080f, 0.07502785f, 0.08530552f, 0.01789124f, 
    0.24542655f, 0.08617800f, -0.14440295f, 0.03367017f, -0.28322154f, 0.10527200f, -0.00603029f, 0.18037263f, 
    -0.01316598f, -0.04793090f, -0.03115686f, -0.01976311f, -0.07506143f, 0.08857151f, 0.05042682f, -0.00137337f, 
    0.08263983f, -0.05584882f, -0.06798879f, -0.02653947f, 0.09451351f, -0.83187431f, -0.00773663f, -0.15279016f, 
    0.31187916f, -0.00744735f, -0.07406808f, 0.19864438f, -0.06119044f, 0.06178684f, 0.10687470f, 0.10636117f, 
    0.03854770f, -0.05059774f, 0.04370544f, -0.17756796f, -0.06907394f, 0.12601776f, -0.06950874f, 0.10550021f, 
    0.13574392f, 0.09330557f, -0.15797305f, -0.20845324f, -0.01417186f, 0.13262013f, 0.18008550f, 0.10530013f, 
    -0.18448065f, 0.02242742f, 0.00594010f, -0.14529011f, 0.05297822f, -0.16015138f, -0.01383903f, -0.04266484f, 
    -0.01045737f, 0.01451912f, 0.04244694f, -0.04970971f, -0.05150904f, 0.02061186f, -0.15076041f, 0.16787753f, 
    -0.03693600f, 0.03456391f, 0.12691100f, 0.02049913f, 0.06956998f, -0.01648097f, 0.07712360f, -0.03653328f, 
    0.05749646f, 0.01854464f, 0.00185134f, 0.09396737f, 0.14162600f, -0.02758788f, -0.01594641f, 0.01831592f, 
    0.36623833f, -0.16306499f, -0.00037879f, -0.06616097f, -0.18809313f, 0.10954680f, -0.01308362f, 0.27897385f, 
    0.11556081f, 0.03566133f, -0.02310083f, -0.01492387f, -0.06977850f, 0.05034329f, 0.02382896f, 0.04121524f, 
    -0.07805756f, 0.06605614f, 0.03545510f, -0.01794023f, -0.49588713f, 0.38162071f, 0.08088253f, 0.20676556f, 
    -0.03063105f, -0.07075583f, -0.21494931f, -0.11512291f, -0.07073189f, -0.04923955f, 0.07293680f, 0.14540879f, 
    -0.03029184f, 0.04546529f, -0.01358352f, -0.06037638f, 0.21347927f, -0.00181554f, 0.05103641f, 0.14199440f, 
    -0.19022404f, -0.07385905f, -0.04126424f, -0.00095869f, 0.02954014f, 0.06939382f, -0.00429748f, -0.03151914f, 
    -0.00016016f, 0.04639706f, -0.12575744f, -0.07076044f, -0.12552534f, -0.16051242f, -0.08118501f, 0.07257069f, 
    0.01694529f, 0.09588218f, -0.08270975f, -0.00247551f, 0.22482492f, -0.17807393f, -0.11831995f, -0.07647815f, 
    0.06256722f, -0.00980314f, -0.05179981f, 0.09708157f, -0.10395931f, 0.06532213f, 0.03596679f, 0.11565617f, 
    -0.25520137f, 0.06489407f, 0.02121706f, -0.07286654f, 0.14008749f, 0.02169484f, -0.15212764f, 0.14202596f, 
    -0.22729965f, -0.15212934f, -0.11550290f, -0.02724140f, -0.04701384f, 0.03259176f, 0.13747714f, 0.14535522f, 
    0.00868080f, 0.07679486f, 0.00191014f, -0.12280166f, -0.00882667f, -0.18725954f, 0.01842388f, -0.01387231f, 
    0.07843098f, -0.09198157f, -0.00217331f, 0.04245832f, -0.24779160f, -0.22293808f, -0.08064124f, -0.08187727f, 
    0.10591404f, -0.01872286f, 0.10204063f, 0.08580473f, 0.01059942f, -0.05515236f, 0.06748875f, 0.02006354f, 
    0.06427243f, 0.05372867f, 0.01283382f, -0.12263648f, -0.03069145f, 0.10683133f, 0.10163998f, -0.06773555f, 
    0.23021680f, 0.04180858f, -0.42141128f, 0.05298163f, -0.08709297f, 0.08727565f, 0.18041982f, 0.06951720f, 
    -0.06404708f, -0.01763582f, -0.08665787f, -0.09939514f, 0.03441425f, 0.20644410f, 0.00221993f, 0.08854786f, 
    0.11242726f, 0.10006128f, 0.04219029f, 0.05485277f, 0.14080626f, 0.34819916f, 0.12952118f, 0.01560351f, 
    0.06611955f, 0.00307215f, -0.01870649f, 0.04976919f, 0.06413496f, 0.07276932f, 0.04782324f, -0.05978222f, 
    0.01671871f, 0.01281613f, 0.02105811f, -0.04657303f, 0.04682826f, 0.08554924f, 0.03601842f, -0.08203249f, 
    0.03141386f, 0.01649478f, 0.00049508f, 0.00275922f, -0.02930866f, -0.00189583f, -0.00686329f, -0.00756870f, 
    -0.01903953f, 0.00566896f, 0.02467926f, -0.00724620f, -0.00453455f, 0.02791627f, -0.02151287f, -0.04198353f, 
    -0.04346415f, -0.00777000f, 0.00365195f, -0.04026684f, -0.03825695f, -0.00437228f, -0.00782659f, 0.01485048f, 
    0.01935519f, -0.01408374f, -0.04068575f, 0.01711931f, -0.00132949f, 0.03574646f, -0.01694754f, -0.03277816f, 
    0.01341832f, -0.04344417f, -0.03808378f, -0.04133406f, 0.01216227f, 0.01030958f, 0.02689400f, -0.01414825f, 
    -0.02363105f, 0.01103890f, 0.02239258f, -0.04137709f, 0.00849184f, -0.04216177f, -0.02383708f, -0.03022095f, 
    0.02942793f, -0.00945129f, 0.00776317f, 0.01682267f, -0.04308271f, -0.02305151f, -0.00247075f, -0.01821684f, 
    0.02773473f, -0.00176932f, -0.01137072f, 0.00585874f, -0.01115126f, 0.00148795f, 0.01968784f, 0.00198191f, 
    -0.00343384f, 0.01541804f, -0.02009843f, 0.02814847f, -0.02074790f, -0.00854958f, 0.03282710f, 0.03119951f, 
    -0.02890047f, -0.00869372f, -0.00674281f, -0.02168695f, 0.00624486f, -0.02321861f, -0.00477967f, 0.00897933f, 
    -0.03221418f, 0.01841533f, -0.03805028f, 0.01650914f, -0.00721174f, 0.02370400f, -0.04513098f, -0.00509112f, 
    0.00609360f, 0.01720848f, -0.00275175f, -0.02315575f, 0.01089779f, -0.00965084f, 0.00724388f, 0.00935753f, 
    -0.02604730f, -0.01794566f, 0.02564523f, -0.00652861f, -0.01836210f, 0.02890043f, -0.04277227f, 0.03882968f, 
    -0.00224580f, -0.01903420f, -0.01059492f, -0.02201748f, -0.02665112f, 0.00790512f, -0.02281268f, 0.00447779f, 
    -0.03003186f, -0.04082193f, 0.01229407f, -0.01258102f, -0.00979873f, -0.01012572f, -0.00376840f, 0.02795355f, 
    -0.02228069f, 0.02082900f, 0.00287232f, 0.03493310f, 0.03115156f, -0.01355651f, 0.01686582f, -0.03976247f, 
    -0.00370716f, -0.00275942f, 0.01129927f, 0.01518033f, -0.04166270f, 0.00013180f, -0.03627781f, 0.03623165f, 
    -0.01327679f, -0.02461455f, -0.03519813f, -0.03336060f, 0.03925300f, -0.01046537f, 0.00660926f, -0.02510264f, 
    -0.01067091f, -0.00757416f, -0.04572001f, -0.02399036f, 0.02774747f, 0.00290881f, 0.02084425f, -0.03609545f, 
    -0.04072182f, 0.00689596f, -0.00233420f, -0.03242820f, -0.02729679f, -0.00947365f, 0.02943310f, 0.01494047f, 
    -0.03467315f, 0.02527739f, 0.01117614f, 0.00025886f, 0.02424742f, -0.03989071f, 0.03098083f, 0.00050489f, 
    -0.03707542f, -0.03065025f, -0.01345787f, -0.03066461f, 0.02063052f, 0.02447839f, 0.02638170f, 0.00919579f, 
    0.00007509f, -0.03695105f, 0.01365709f, 0.00161827f, -0.01492803f, 0.03241381f, 0.02425295f, -0.01274731f, 
    0.02329790f, 0.02739319f, -0.03714575f, 0.01543803f, -0.02866774f, 0.00798089f, 0.01259969f, 0.01026644f, 
    0.00717103f, -0.03667124f, 0.02770827f, -0.03288919f, -0.03513298f, -0.01612661f, -0.00062642f, -0.00479305f, 
    -0.02082841f, -0.03762336f, -0.04007064f, 0.01084578f, -0.00469057f, -0.02503203f, -0.00348055f, 0.04156176f, 
    -0.01651564f, -0.01890133f, 0.00963379f, -0.00439108f, -0.04065242f, 0.00385079f, -0.03665069f, 0.01578491f, 
    -0.03581292f, -0.00197945f, 0.02245261f, -0.01831875f, -0.00767627f, 0.00327766f, 0.02724694f, -0.03317381f, 
    -0.03356009f, 0.01935862f, -0.00425990f, 0.00577772f, 0.00199568f, 0.02491850f, 0.00368128f, 0.01368205f, 
    -0.00498107f, 0.01499919f, -0.02965164f, -0.04293079f, 0.03027407f, 0.01949497f, -0.03654571f, 0.02221361f, 
    -0.04542419f, -0.00734970f, 0.00653713f, 0.04178563f, -0.02771700f, -0.03156965f, 0.02373574f, -0.02818317f, 
    -0.03774135f, -0.01202955f, 0.03507820f, 0.03166334f, 0.01173905f, 0.01628035f, -0.04435826f, -0.01482544f, 
    -0.01999389f, -0.02908485f, -0.01914654f, 0.01392734f, -0.03161555f, -0.01104339f, 0.01385699f, 0.02438826f, 
    -0.03912374f, -0.01794133f, 0.02880363f, 0.03512981f, -0.00615965f, -0.03486662f, 0.02987535f, 0.03166500f, 
    -0.03130249f, 0.00260013f, -0.01749900f, -0.03052667f, 0.01313257f, 0.00331322f, 0.01704469f, -0.00483717f, 
    -0.02027098f, 0.00655659f, -0.02714598f, -0.01236198f, -0.03776746f, -0.01974458f, -0.00407645f, 0.01656446f, 
    0.00111319f, -0.03533479f, -0.02868463f, -0.00049754f, 0.03180980f, -0.04180839f, 0.01240567f, 0.03045739f, 
    0.02120808f, 0.00612380f, 0.01760245f, -0.00416749f, -0.01278753f, -0.00992253f, 0.03461127f, -0.01554912f, 
    -0.01733015f, -0.03520802f, 0.03676938f, 0.01616707f, -0.03930064f, -0.01947055f, 0.03703349f, 0.00556323f, 
    -0.03005925f, -0.00790029f, -0.03737610f, 0.00198734f, -0.02546977f, -0.00509030f, -0.01339455f, -0.01909018f, 
    0.03221769f, -0.00545099f, -0.01049733f, 0.01856735f, 0.01113650f, -0.00935639f, 0.02007146f, 0.01003041f, 
    0.02442860f, -0.04045498f, -0.04377609f, -0.01176829f, 0.01983213f, -0.02280316f, -0.00481360f, -0.01283453f, 
    0.00997303f, -0.02794417f, 0.02275357f, 0.01823952f, -0.01183086f, -0.01463252f, -0.02872349f, 0.00748879f, 
    0.01694245f, 0.00129842f, 0.01659083f, -0.00276791f, 0.03468971f, 0.02100851f, 0.01856476f, -0.03987354f, 
    -0.00858455f, 0.02604703f, -0.00949513f, -0.00216571f, -0.02664445f, -0.04226071f, 0.00570068f, 0.03869107f, 
    -0.02178643f, -0.01543887f, -0.00985099f, -0.03745904f, -0.00846168f, 0.00271239f, 0.01989294f, 0.00816119f, 
    0.01454809f, 0.02130996f, 0.02662746f, -0.02925015f, -0.00515749f, 0.03036629f, -0.03646211f, -0.03071742f, 
    0.03061408f, -0.01640163f, 0.01175459f, 0.01527498f, -0.02797150f, -0.01761664f, 0.00706795f, 0.01857052f, 
    -0.04173237f, 0.03923038f, 0.01883936f, -0.00584695f, 0.01930874f, 0.03096440f, -0.03278613f, 0.02643756f, 
    0.02805367f, -0.02786702f, 0.01553265f, -0.04434728f, -0.00010346f, 0.00005609f, -0.00579483f, -0.02618048f, 
    -0.00917846f, -0.01213992f, -0.02339973f, -0.01131173f, -0.01415837f, -0.02332627f, -0.02726407f, -0.04055035f, 
    0.02641463f, -0.01105936f, 0.00373666f, -0.00994469f, -0.00697905f, 0.00221501f, -0.02780624f, -0.00247338f, 
    0.00350586f, 0.03087264f, -0.03896156f, -0.03870189f, 0.01412518f, 0.02842805f, -0.00150409f, 0.02591963f, 
    0.01680022f, -0.04357242f, -0.00707801f, -0.01347637f, 0.02908199f, 0.01961199f, -0.04710314f, -0.01212244f, 
    -0.01505410f, -0.04646036f, -0.01251496f, -0.01134429f, -0.02557361f, 0.02855870f, 0.01829844f, -0.02250931f, 
    0.02703241f, 0.02403217f, 0.03448680f, -0.01328067f, 0.01010413f, -0.02336297f, 0.01211313f, 0.02609281f, 
    -0.02308092f, -0.03196317f, 0.01112617f, 0.03480229f, 0.00625485f, -0.01952302f, -0.01277102f, -0.01921746f, 
    0.00014720f, 0.02911310f, 0.01746856f, -0.02280289f, 0.01458184f, 0.00617638f, 0.02684953f, 0.00691353f, 
    0.01933885f, -0.03662930f, -0.04085879f, -0.02600349f, -0.00074827f, 0.02238497f, -0.00866708f, -0.00049603f, 
    -0.02014433f, -0.03430443f, 0.03815493f, 0.00487757f, -0.03082202f, 0.01896819f, -0.02818009f, -0.00438613f, 
    -0.03941803f, -0.01105283f, 0.00382396f, 0.02371692f, -0.01717630f, -0.04427867f, -0.03093781f, 0.02919369f, 
    0.03272688f, 0.00662937f, -0.01416560f, 0.02050183f, 0.02974547f, 0.02179367f, 0.01256450f, -0.02633282f, 
    -0.01350679f, 0.00848345f, -0.00798159f, -0.01270046f, 0.00439298f, -0.01417149f, -0.00014992f, 0.02155397f, 
    0.01122231f, -0.00163450f, -0.01493516f, -0.02475410f, 0.02408921f, -0.04192166f, -0.00573362f, -0.03117657f, 
    0.00538127f, 0.00070643f, 0.00755380f, 0.00116698f, 0.02902950f, 0.02406956f, 0.00705698f, -0.02367595f, 
    -0.04232302f, -0.01984141f, -0.04159446f, -0.02689264f, 0.02732745f, 0.02847445f, 0.01254868f, 0.00496461f, 
    -0.03163344f, 0.03498437f, -0.01134043f, -0.02930226f, -0.00393498f, 0.01892197f, 0.02750319f, 0.01693283f, 
    -0.01187956f, 0.01961154f, 0.00427595f, 0.01828166f, 0.01782143f, 0.01648523f, 0.00590931f, 0.00886137f, 
    0.00772894f, -0.04031983f, -0.01587521f, 0.01434239f, -0.00820902f, -0.01089429f, 0.00770316f, -0.00651439f, 
    -0.02837697f, -0.00673336f, -0.00279258f, -0.00082145f, 0.00024724f, 0.02350457f, 0.01855592f, -0.03722451f, 
    0.03390501f, 0.02709126f, 0.00832972f, -0.03374208f, -0.02649206f, -0.02934693f, -0.01776966f, -0.02532508f, 
    0.03930566f, -0.02511274f, 0.02695308f, -0.00851503f, 0.01074800f, 0.00038180f, 0.02728922f, 0.02900892f, 
    -0.00855460f, -0.03203921f, -0.02605823f, 0.03078016f, 0.02884776f, 0.02154371f, 0.02535210f, 0.00962110f, 
    0.02593249f, 0.03967723f, 0.04056560f, -0.03084718f, 0.01962542f, -0.00167119f, 0.03247152f, -0.03330522f, 
    -0.04023343f, -0.01239477f, -0.03696848f, -0.02263624f, 0.01457577f, -0.01521636f, -0.03639833f, -0.04080930f, 
    0.01346980f, 0.01989775f, 0.02596922f, 0.01869340f, 0.02550742f, -0.03489256f, -0.01373999f, -0.00073155f, 
    -0.02708766f, -0.01630574f, -0.02385821f, -0.00300642f, 0.02027437f, 0.03229147f, -0.01907434f, 0.00937220f, 
    0.01102774f, 0.03540925f, -0.01157067f, -0.02164848f, -0.02263752f, 0.00470389f, -0.02188579f, -0.03765558f, 
    0.03325553f, -0.02103695f, 0.01217032f, -0.00251484f, 0.01005615f, 0.03235620f, -0.04304273f, 0.01816602f, 
    0.02150574f, -0.02675549f, 0.00914434f, -0.00479430f, -0.01074387f, -0.01015460f, -0.02332121f, 0.02630906f, 
    -0.04055062f, -0.03082447f, 0.01603583f, -0.04793988f, 0.02489202f, -0.03192509f, 0.00227783f, 0.02920195f, 
    -0.03739747f, -0.00071825f, -0.00580414f, -0.01175989f, -0.01341356f, -0.05019551f, 0.01347750f, -0.04330890f, 
    0.00809392f, 0.01176419f, -0.03386321f, -0.01291133f, 0.01453180f, -0.05067143f, 0.01671562f, -0.02552355f, 
    -0.00371334f, 0.02453606f, -0.04387899f, 0.03104407f, 0.03313729f, 0.01329358f, 0.00168830f, -0.02214593f, 
    0.01857846f, -0.02096366f, 0.00062185f, -0.01562699f, 0.01843166f, 0.01927081f, 0.00757472f, -0.02407531f, 
    0.02309499f, -0.01974468f, 0.04144199f, 0.00438601f, 0.04803147f, 0.03114203f, -0.01596549f, 0.01868878f, 
    0.01059394f, -0.00479685f, -0.00919722f, 0.00509443f, -0.01418898f, -0.04505496f, -0.02553303f, 0.02669164f, 
    0.01023830f, 0.03342625f, 0.02565597f, -0.01120646f, -0.01422906f, 0.01908220f, 0.02926975f, -0.00116577f, 
    0.02528485f, -0.00571570f, -0.00076813f, -0.02301090f, 0.01094255f, -0.02129507f, -0.04938751f, -0.02567451f, 
    -0.03597174f, -0.00921045f, -0.01401585f, -0.02928605f, 0.00290988f, -0.03279675f, 0.01671810f, 0.02295151f, 
    0.00829709f, 0.01460859f, 0.00785138f, 0.02991059f, -0.00642135f, 0.00197289f, -0.00955061f, -0.03114141f, 
    -0.01859310f, 0.00778134f, 0.00553255f, 0.03150884f, -0.00364777f, -0.00408482f, -0.03560696f, 0.00774730f, 
    0.02319839f, -0.03345917f, 0.02187911f, -0.01466035f, 0.01887410f, -0.00066587f, -0.00534232f, 0.03875169f, 
    0.04556916f, 0.02466641f, 0.02638214f, -0.03858491f, 0.00895452f, 0.01319533f, -0.02426563f, -0.03123630f, 
    -0.04072526f, -0.03428859f, 0.01482660f, 0.01582958f, 0.00805270f, -0.00441617f, -0.00172437f, -0.00536672f, 
    -0.02400552f, 0.03499755f, 0.01280292f, -0.00177108f, -0.01743831f, -0.01134729f, -0.01213977f, -0.01040647f, 
    -0.02659627f, -0.00931708f, -0.03605489f, 0.00238023f, -0.03655670f, 0.01088528f, 0.03036959f, 0.01175824f, 
    0.00395009f, -0.02034835f, 0.02962437f, 0.00398239f, 0.02201535f, 0.02070543f, 0.01092555f, -0.03665759f, 
    -0.01707630f, 0.03369096f, -0.01708059f, 0.00241999f, -0.02359062f, 0.01250960f, 0.01864552f, -0.04432413f, 
    0.02823066f, -0.04178980f, 0.01580191f, -0.02430519f, -0.03910287f, 0.02225370f, -0.02293214f, 0.00439388f, 
    0.00921789f, -0.03658889f, 0.02373806f, -0.04479816f, -0.01704509f, -0.04282442f, -0.01509784f, 0.00548623f, 
    -0.03647119f, 0.01344102f, -0.00121289f, -0.00365635f, -0.00352414f, -0.00739114f, -0.02336837f, -0.01355777f, 
    -0.01472569f, 0.00532619f, -0.00904625f, 0.02302644f, 0.01581313f, 0.02092987f, 0.01794878f, 0.01380686f, 
    -0.01763856f, -0.02471207f, 0.00705489f, 0.00006473f, 0.02279839f, -0.02097765f, -0.04462524f, -0.03752032f, 
    -0.01920177f, -0.00018603f, -0.02847585f, 0.02035975f, -0.04210297f, -0.00101417f, -0.02979683f, 0.03110383f, 
    0.02706758f, -0.03835224f, 0.01913328f, -0.02025924f, -0.03041869f, 0.00628932f, -0.00033292f, -0.02651079f, 
    -0.00947580f, -0.04091806f, -0.04370296f, -0.05214795f, 0.04190713f, -0.00440659f, -0.02146293f, 0.01459741f, 
    -0.04691305f, 0.01631679f, -0.03501807f, 0.01268689f, 0.00164065f, 0.01702385f, 0.02558887f, -0.02694147f, 
    0.02063968f, -0.03599364f, 0.03022086f, -0.00200761f, -0.00663268f, 0.02974723f, -0.03455505f, 0.00074806f, 
    -0.04105395f, -0.04064991f, 0.00982479f, -0.02368841f, -0.03364466f, 0.00473094f, 0.02348310f, -0.00770825f, 
    -0.03434674f, 0.03286437f, -0.00200763f, 0.01153837f, -0.02769027f, 0.01983831f, 0.00738948f, 0.02162128f, 
    -0.02207580f, 0.02075033f, 0.00504082f, -0.01578875f, 0.01888449f, 0.00825624f, -0.02106180f, -0.01048728f, 
    0.03126248f, 0.01376400f, -0.02971406f, -0.00263285f, 0.03464957f, 0.01609843f, -0.04614136f, 0.01223410f, 
    0.01740877f, -0.00701716f, -0.02455688f, -0.02773775f, -0.03496565f, 0.02107795f, -0.02082011f, 0.02751513f, 
    0.02966367f, -0.01059857f, -0.02160201f, -0.02542004f, -0.02923518f, -0.00644057f, 0.00256893f, -0.01684086f, 
    -0.01218871f, -0.01090012f, -0.03283254f, -0.01041970f, 0.01289722f, 0.01353285f, -0.03485629f, -0.02861572f, 
    -0.01305642f, 0.00910236f, -0.00931625f, -0.00587618f, -0.01739614f, -0.00200214f, -0.00558972f, 0.02782637f, 
    0.02218969f, -0.01414372f, -0.03514252f, -0.02495621f, -0.03468251f, -0.00106693f, -0.01326205f, -0.01709820f, 
    -0.03577477f, -0.02152236f, -0.00135255f, 0.02292624f, -0.04289112f, 0.02365303f, -0.02365412f, 0.01156533f, 
    -0.01942240f, -0.03307636f, -0.01907653f, 0.00513652f, -0.00040657f, 0.01435993f, -0.02643264f, -0.00734224f, 
    -0.02402999f, -0.04540173f, -0.01673776f, -0.01051455f, -0.04285645f, 0.02650799f, -0.04211814f, -0.02509271f, 
    0.00211389f, -0.00049423f, -0.01521739f, 0.02432282f, -0.00862818f, 0.02413270f, -0.01598982f, -0.02909645f, 
    0.01543316f, 0.01796347f, 0.02146970f, -0.01732996f, -0.04145011f, -0.03709489f, -0.00116070f, -0.04437767f, 
    -0.00222371f, 0.01548640f, -0.03310884f, 0.01453310f, -0.02798716f, 0.00418022f, -0.04064490f, 0.02842364f, 
    0.02836208f, -0.04443868f, 0.00674479f, -0.00590712f, -0.02982092f, -0.03960729f, 0.02459742f, -0.03425891f, 
    -0.05110640f, 0.00204511f, -0.03147703f, -0.01144275f, -0.01252198f, 0.02381213f, 0.00853368f, -0.03815189f, 
    -0.02257285f, 0.01550906f, 0.00672230f, 0.02885257f, 0.02304182f, -0.01654616f, 0.02794627f, 0.01284756f, 
    0.00596776f, -0.00477997f, -0.04453430f, -0.00431705f, 0.01872475f, 0.03005682f, -0.01389743f, -0.04607565f, 
    0.03026256f, 0.00894902f, -0.01625630f, -0.01706973f, 0.03209028f, 0.00667851f, 0.01729637f, 0.02401146f, 
    0.01904144f, 0.02555210f, -0.02346943f, 0.03212195f, 0.02285201f, -0.02576335f, -0.00311720f, 0.00653187f, 
    0.01767805f, -0.00944039f, 0.00684751f, -0.02967149f, -0.04458127f, -0.00525448f, 0.01091217f, -0.00600631f, 
    -0.00587255f, 0.01776449f, -0.01411007f, 0.02240110f, 0.03278061f, 0.01809154f, -0.02627005f, 0.00341991f, 
    0.03173285f, -0.00787357f, -0.02978708f, 0.01734915f, -0.03388228f, 0.02158147f, -0.01338575f, -0.00653679f, 
    0.00752519f, -0.01333405f, 0.02244010f, -0.03408132f, -0.03792316f, -0.03005521f, -0.02598519f, -0.02636708f, 
    -0.01691793f, 0.02634057f, 0.01434916f, -0.00819459f, -0.00839060f, 0.01558799f, 0.01040948f, -0.02884746f, 
    -0.03657170f, -0.02126808f, 0.02928788f, -0.01680796f, -0.02421252f, 0.02585528f, 0.01198446f, -0.03183717f, 
    -0.03436191f, -0.00067845f, 0.00291562f, -0.02307939f, 0.03301134f, -0.00466341f, -0.00288172f, 0.01113117f, 
    0.03302611f, -0.03936318f, 0.01570350f, -0.01290234f, 0.03098506f, -0.02179431f, -0.02940195f, 0.03570763f, 
    -0.01153268f, -0.03733041f, -0.02707548f, 0.01854093f, 0.03448726f, -0.03937646f, -0.01874764f, 0.01522007f, 
    -0.03311035f, -0.02018746f, -0.01975490f, -0.04267492f, -0.02560359f, -0.03541775f, -0.00599291f, 0.02848671f, 
    0.01630946f, -0.02279738f, 0.02188670f, -0.01148595f, -0.00516944f, 0.01265192f, -0.04593143f, 0.03204482f, 
    -0.01069716f, -0.02186980f, -0.00889088f, -0.03509929f, 0.01538828f, 0.00204963f, 0.00314718f, -0.01122852f, 
    -0.00733145f, 0.01630414f, 0.03240235f, 0.02394670f, -0.01271044f, -0.00975554f, -0.00124938f, -0.01174845f, 
    0.02519027f, -0.00004476f, -0.02360004f, 0.01905784f, 0.00427866f, -0.03895089f, -0.01241228f, -0.04476161f, 
    0.01647624f, 0.01713431f, -0.01300763f, -0.01068630f, -0.02533126f, -0.04413071f, 0.01095143f, 0.02575661f, 
    0.02215165f, 0.00766686f, -0.00206025f, 0.00907946f, 0.01322267f, -0.00274185f, -0.00593327f, 0.00799858f, 
    -0.04591738f, -0.03411061f, -0.00555174f, -0.02092413f, 0.03837318f, 0.00183888f, 0.02034808f, -0.04477837f, 
    -0.03752287f, -0.03308807f, -0.02123892f, 0.00657839f, -0.04784327f, -0.04187069f, -0.03247753f, 0.00903527f, 
    -0.02370227f, -0.00023650f, 0.01031130f, 0.02880062f, 0.00392346f, -0.00062058f, -0.03545642f, 0.00453306f, 
    -0.00905160f, 0.02572116f, 0.02041245f, 0.02566391f, -0.01410238f, 0.00241892f, 0.03424633f, 0.01659711f, 
    -0.01255855f, 0.01603566f, -0.03451838f, -0.02908524f, -0.01515581f, 0.01243835f, -0.03866030f, 0.01466563f, 
    0.01345697f, -0.00032192f, -0.01100683f, 0.00149349f, 0.03367412f, -0.02967835f, -0.01087223f, -0.01574257f, 
    -0.04866012f, 0.00199851f, -0.03336512f, -0.00503714f, 0.02123594f, 0.00878663f, 0.01211296f, -0.01709123f, 
    0.01888713f, 0.02417184f, 0.00095478f, 0.02045260f, -0.00818055f, 0.02002308f, 0.02653895f, -0.02358580f, 
    -0.01421194f, -0.01200094f, -0.02475351f, 0.03053848f, -0.03940325f, 0.01204978f, -0.01250188f, -0.01355922f, 
    -0.02240145f, -0.03841383f, -0.00041735f, 0.01926918f, 0.00873216f, 0.01862237f, -0.01750384f, -0.00331910f, 
    -0.01838723f, 0.03112047f, 0.02721836f, -0.03156934f, 0.00634246f, -0.01245102f, -0.03273728f, -0.00167469f, 
    0.01509713f, -0.00589285f, 0.01094881f, -0.04472607f, 0.00186782f, 0.02362669f, 0.01987366f, 0.00246794f, 
    -0.02022748f, -0.01671483f, 0.02448379f, 0.02051283f, 0.01579910f, -0.00579704f, -0.04388416f, 0.01524583f, 
    -0.03453552f, -0.01167535f, 0.02668307f, 0.01880809f, 0.01605540f, -0.02227191f, 0.01592950f, -0.00367732f, 
    -0.00542200f, -0.20883258f, -0.10915196f, 0.07207700f, 0.11627845f, -0.01282483f, 0.12801991f, 0.09002457f, 
    0.03943483f, 0.05236346f, -0.04215407f, -0.03562858f, -0.02714127f, -0.00104378f, 0.01665931f, -0.06551947f, 
    0.07500591f, 0.02979742f, 0.04314146f, 0.09560668f, -0.25279531f, -0.16435494f, 0.23896362f, -0.04897168f, 
    -0.00382025f, 0.09826405f, -0.13918625f, 0.10035054f, 0.18724155f, -0.02912285f, -0.03946828f, -0.02725632f, 
    -0.13532512f, 0.00436767f, 0.01370405f, 0.02449173f, 0.10040692f, -0.09251865f, 0.11623579f, -0.07529451f, 
    -0.21649133f, 0.29780129f, 0.24053538f, 0.26701552f, -0.16847990f, 0.03543975f, -0.01275281f, -0.03536142f, 
    0.01845816f, -0.06992091f, -0.12055878f, -0.10435036f, -0.04959213f, -0.13812687f, 0.07169615f, -0.05873420f, 
    -0.29783753f, 0.03559796f, 0.05842235f, -0.25777259f, 0.07364730f, 0.35478121f, -0.19803974f, 0.01374709f, 
    -0.26677114f, -0.07487342f, -0.08833367f, -0.11953453f, -0.11368090f, -0.16344507f, -0.18768856f, -0.00917837f, 
    -0.17455846f, -0.10508487f, 0.05810118f, -0.09291162f, -0.13192095f, -0.02200274f, -0.00667466f, -0.23833764f, 
    -0.07744505f, 0.11887584f, -0.08092285f, -0.08466725f, 0.05832551f, -0.01324892f, -0.05319972f, 0.06231150f, 
    -0.06261920f, -0.03357887f, -0.16967970f, 0.03854356f, -0.14092609f, -0.00245896f, 0.09827195f, -0.05191058f, 
    -0.01922271f, 0.06790274f, -0.01559203f, -0.19319667f, 0.47084856f, 0.16632542f, 0.28263593f, 0.26924866f, 
    -0.05783357f, 0.18299024f, -0.08546454f, -0.05208344f, -0.11903012f, -0.00781200f, 0.01680997f, 0.02271678f, 
    -0.01357717f, 0.08739789f, 0.02600306f, -0.05250018f, 0.01694280f, 0.25766093f, -0.00618581f, -0.08580503f, 
    0.05201036f, 0.27920651f, 0.05490587f, 0.14826725f, 0.01196475f, -0.00353570f, -0.07338127f, 0.06713634f, 
    0.09268750f, -0.07446291f, -0.13048945f, -0.05621920f, -0.02522144f, 0.12110589f, 0.06680305f, 0.09495912f, 
    -0.01009915f, 0.29891342f, 0.12368152f, -0.08609951f, 0.25990909f, -0.05103157f, 0.03839533f, 0.30778819f, 
    0.31763881f, -0.01543702f, 0.19782658f, 0.09523162f, 0.13179548f, 0.11432841f, 0.03797336f, -0.01763399f, 
    0.04927861f, -0.12825906f, -0.06956029f, 0.09204752f, -0.15035459f, -0.05450618f, -0.10973749f, 0.18867002f, 
    0.09066129f, -0.44312382f, 0.00962764f, 0.25329867f, 0.05454315f, 0.07746853f, 0.02021601f, -0.00951036f, 
    -0.03295990f, 0.00741346f, 0.01682660f, 0.04259794f, 0.00992205f, -0.05461099f, 0.05685570f, -0.07878298f, 
    0.06756495f, -0.10146893f, 0.09347827f, 0.31057224f, 0.01934291f, -0.25871634f, -0.07376768f, 0.13391449f, 
    -0.07604937f, 0.22056116f, 0.00420930f, 0.09075236f, 0.12112425f, -0.06908192f, -0.02752172f, 0.04073283f, 
    -0.01851978f, -0.04808366f, 0.03068124f, 0.08950377f, 0.12751813f, 0.03918523f, -0.04383322f, 0.14991200f, 
    0.03206719f, 0.11577451f, 0.03573661f, 0.00234456f, -0.17196904f, -0.03554914f, -0.06270616f, -0.10073172f, 
    0.01213190f, -0.04068252f, 0.02420284f, -0.04318024f, -0.01338235f, 0.10503828f, 0.23027933f, -0.01252447f, 
    0.09935822f, 0.12891538f, 0.19090465f, 0.03411191f, -0.05981100f, 0.24059580f, -0.03617993f, 0.02956668f, 
    -0.08627088f, 0.13635349f, 0.02755551f, -0.06400682f, 0.13788475f, -0.05064373f, 0.11679073f, 0.05647734f, 
    0.00224189f, 0.05294977f, -0.02301726f, 0.01342532f, 0.05771343f, -0.05171970f, 0.16048536f, 0.09263172f, 
    0.02152559f, -0.08489352f, -0.16864388f, -0.00701263f, 0.03019170f, -0.03907624f, 0.06612813f, 0.09364787f, 
    0.03878273f, 0.18295629f, 0.11853504f, -0.07937809f, 0.15932488f, 0.02829272f, -0.11806978f, -0.04410268f, 
    0.10101340f, 0.16699633f, 0.01244293f, 0.04985158f, 0.06752339f, -0.12897640f, 0.13502707f, 0.29735628f, 
    -0.00534385f, 0.00507693f, 0.02255177f, -0.08565030f, 0.00275143f, -0.00847738f, 0.04218264f, -0.00826895f, 
    0.02079194f, 0.00268029f, 0.01413747f, 0.06860603f, 0.05015068f, 0.04807036f, 0.11173402f, 0.17610398f, 
    0.08972760f, -0.06810571f, -0.01310551f, -0.07512093f, -0.09732818f, -0.00482736f, 0.04615720f, -0.06988254f, 
    -0.00551009f, 0.04325226f, 0.20648159f, -0.06427412f, 0.06226137f, -0.07327344f, 0.04547675f, 0.03089371f, 
    0.22059555f, 0.10418450f, 0.09790152f, 0.02219265f, 0.49827346f, 0.09160597f, -0.37462407f, -0.11331897f, 
    -0.10072023f, 0.02360529f, -0.01027935f, 0.02195098f, 0.08727659f, 0.09535621f, 0.16536149f, 0.08275784f, 
    0.01662466f, 0.02076493f, -0.02896732f, -0.16987561f, -0.04837759f, 0.06922511f, -0.03403730f, -0.15373898f, 
    0.01289333f, 0.05716170f, 0.15014499f, 0.20695275f, 0.26641563f, -0.01340253f, -0.02074131f, -0.00654327f, 
    -0.00510679f, -0.04922254f, -0.14826746f, -0.05386187f, 0.10243253f, 0.05546306f, 0.02523888f, 0.16817132f, 
    0.06855806f, 0.14501695f, 0.09903913f, 0.10649298f, 0.69282234f, -0.00610632f, -0.09970787f, 0.29663616f, 
    -0.06242386f, 0.12173074f, 0.13879076f, 0.19416161f, 0.07721657f, 0.10188593f, -0.04904205f, 0.05246655f, 
    0.16247904f, -0.03247026f, -0.02417775f, 0.13055578f, -0.12830819f, 0.10837143f, 0.06222803f, 0.19412607f, 
    -0.37250009f, -0.01249040f, 0.01154165f, -0.10953593f, 0.09668617f, 0.08260503f, -0.03226802f, 0.09705835f, 
    0.10189028f, 0.13746345f, -0.13855265f, -0.02226492f, -0.12450012f, 0.05645118f, 0.01963253f, -0.03063780f, 
    0.00752388f, -0.14581293f, 0.07704034f, -0.00844383f, -0.09062078f, -0.24731179f, -0.39457259f, -0.29076833f, 
    -0.04958929f, -0.03391963f, 0.05784341f, -0.02649873f, 0.04605309f, 0.04589688f, 0.15739086f, 0.07466472f, 
    0.01108495f, 0.05857943f, 0.01582546f, -0.05932648f, -0.02357776f, 0.03948747f, 0.06083044f, -0.06905657f, 
    -0.07252649f, -0.01096522f, -0.10492045f, -0.03194502f, 0.18860038f, -0.12966485f, 0.00369324f, 0.08237337f, 
    0.05825866f, -0.09344984f, -0.04786694f, -0.07037813f, -0.00830440f, 0.11197251f, 0.08759899f, -0.03689063f, 
    -0.08803488f, 0.10142478f, -0.02011468f, -0.09500054f, 0.17705251f, 0.45580688f, 0.25119525f, 0.13461952f, 
    0.15011895f, 0.01208215f, 0.08769463f, 0.12367482f, -0.25274989f, -0.06525175f, 0.11310795f, -0.03425502f, 
    0.10599328f, -0.01085529f, -0.04825620f, 0.00347225f, -0.05436566f, 0.00934746f, 0.19438462f, -0.26533958f, 
    -0.13230035f, -0.17076597f, 0.04059204f, -0.03251985f, 0.11399142f, -0.01766173f, 0.11599789f, 0.13081808f, 
    0.05101049f, 0.26557010f, 0.10445994f, 0.07405381f, -0.04061410f, -0.10004582f, -0.13606322f, -0.09021904f, 
    0.05018477f, 0.07355499f, 0.22040437f, 0.16081353f, -0.27590668f, -0.00927854f, 0.31535670f, 0.14322998f, 
    -0.00385033f, 0.05003536f, -0.08310716f, -0.11378765f, 0.04339379f, -0.04826380f, 0.05933036f, -0.04106903f, 
    0.01420192f, -0.07783418f, -0.01582020f, 0.11193967f, -0.06709100f, 0.04498892f, -0.04455097f, 0.00885992f, 
    -0.03642412f, -0.13980833f, -0.05086166f, -0.04427713f, 0.16862482f, 0.03508806f, 0.09294485f, 0.07535920f, 
    0.01930520f, 0.07488921f, 0.00934231f, -0.03911003f, 0.15242302f, 0.05656053f, -0.09137101f, 0.01015294f, 
    0.05277723f, 0.20056184f, -0.10312416f, -0.07933360f, 0.23994224f, -0.01612126f, 0.11057387f, 0.19272450f, 
    -0.17233473f, 0.14800917f, -0.14192882f, -0.14226183f, 0.01605380f, 0.20991582f, 0.00275541f, 0.01865819f, 
    0.03731240f, -0.01529376f, 0.08539654f, -0.08869945f, -0.15042418f, 0.12977137f, -0.00520263f, 0.05392750f, 
    -0.17326063f, 0.07224350f, -0.01764774f, -0.05238957f, 0.01264594f, 0.11861023f, -0.01346057f, -0.04471205f, 
    -0.12447643f, 0.06666772f, 0.09100571f, -0.01119119f, 0.05062175f, 0.22892390f, 0.08503570f, 0.02006332f, 
    0.10713957f, 0.05801255f, 0.29800925f, -0.02101913f, 0.01192603f, 0.04504903f, 0.05097496f, -0.02335759f, 
    0.41780564f, 0.12394688f, 0.10468287f, 0.13287695f, -0.15359621f, 0.18200605f, 0.03099504f, 0.14021571f, 
    -0.05200426f, -0.12374602f, -0.03170146f, 0.22923270f, -0.00265329f, 0.02826708f, 0.19246703f, 0.11026690f, 
    -0.10495410f, -0.03626603f, 0.11138687f, -0.04311538f, 0.06985217f, 0.03313782f, 0.02923860f, -0.08065629f, 
    -0.10511553f, -0.08951741f, 0.11350993f, -0.03525866f, 0.07945033f, 0.15787713f, 0.24222080f, 0.04300623f, 
    0.09200000f, 0.02517840f, 0.11857988f, -0.02361390f, -0.06704208f, 0.19421758f, 0.31876913f, 0.02490950f, 
    0.04572975f, 0.03068264f, -0.03334004f, -0.10053926f, -0.06242578f, -0.06120085f, 0.03441397f, -0.14127289f, 
    -0.05894984f, -0.02835697f, 0.06516451f, 0.09749399f, 0.05540942f, 0.11298535f, 0.08767903f, -0.10036626f, 
    -0.04554272f, -0.25685090f, -0.27819309f, -0.21915250f, -0.08877946f, -0.10238979f, -0.01273895f, 0.00031468f, 
    0.06718001f, 0.07843683f, 0.19043557f, 0.06687360f, -0.05424060f, -0.05371977f, -0.00064959f, -0.12138274f, 
    -0.05477502f, -0.01986648f, 0.05459243f, 0.02618422f, 0.09836442f, -0.06899051f, 0.40274996f, 0.12725891f, 
    0.15659918f, 0.11365022f, 0.08047629f, 0.06901968f, 0.04852764f, -0.05545945f, 0.09694879f, 0.00924515f, 
    0.06123209f, -0.06836732f, -0.09469818f, -0.06803404f, -0.02861854f, -0.15610100f, -0.05906080f, -0.28081930f, 
    0.02901537f, -0.00097237f, 0.01145983f, 0.03078479f, 0.01206711f, -0.04512266f, -0.03532876f, -0.00901330f, 
    0.01550217f, -0.00561672f, -0.01066116f, 0.03156597f, -0.00497713f, -0.01543317f, -0.01413089f, -0.02286384f, 
    0.03040366f, 0.02453459f, 0.02542178f, 0.01381855f, -0.02251584f, 0.02901461f, -0.03705331f, -0.00976125f, 
    0.01389197f, 0.01371927f, 0.02478065f, 0.02248134f, -0.03427593f, -0.04384743f, 0.00525760f, -0.03757941f, 
    0.00731131f, -0.02312860f, 0.01917710f, 0.01555145f, 0.01770006f, 0.03243312f, -0.02739760f, -0.00586613f, 
    0.03123655f, -0.01954183f, 0.01001475f, -0.03393397f, 0.04107802f, -0.03227137f, 0.03035584f, 0.00168148f, 
    0.01172598f, 0.01350113f, -0.02107964f, -0.02273025f, 0.03012285f, -0.00471313f, -0.02575892f, 0.00034999f, 
    -0.04322239f, 0.01193734f, -0.04023639f, -0.04013786f, -0.04322463f, -0.02948913f, -0.01890905f, 0.00317101f, 
    0.03086423f, -0.01042302f, -0.03553867f, -0.00273853f, -0.02680431f, -0.02559229f, 0.01180791f, -0.01000035f, 
    -0.00472933f, -0.04105560f, 0.02724388f, -0.02631842f, -0.02013537f, 0.00662376f, 0.01021459f, -0.03117378f, 
    -0.04433012f, 0.01973947f, -0.02940877f, -0.03970965f, 0.01150929f, 0.03301951f, 0.01304428f, 0.03005834f, 
    0.02470118f, -0.02535318f, -0.03524981f, -0.01337629f, -0.03226214f, -0.04431584f, -0.02528791f, -0.00278515f, 
    -0.01738397f, -0.02874621f, -0.04162286f, 0.01248580f, 0.00740473f, -0.02563680f, -0.02451593f, -0.00602765f, 
    -0.03017233f, 0.02153608f, 0.01565875f, -0.03503971f, -0.03918969f, 0.03275383f, 0.01672116f, -0.02188390f, 
    0.00756881f, 0.01648123f, -0.03527844f, 0.02863450f, -0.01309529f, -0.02986367f, -0.02690494f, 0.01243397f, 
    -0.02074615f, -0.02526471f, -0.02020819f, 0.03035308f, 0.02428699f, 0.00136862f, 0.01262760f, -0.02966244f, 
    -0.01614679f, -0.03132717f, -0.01948954f, 0.01460061f, 0.02429860f, -0.01792349f, 0.01023360f, 0.02138862f, 
    -0.03722707f, -0.03439188f, -0.03905420f, -0.00096707f, -0.00684980f, 0.02598984f, -0.00012323f, 0.02439756f, 
    0.01264680f, 0.01706485f, -0.04295274f, 0.02583610f, 0.02423939f, -0.03338432f, -0.00850308f, -0.02069039f, 
    -0.01781272f, 0.02887398f, 0.02612255f, -0.02428123f, -0.01153982f, -0.04355986f, 0.01178619f, 0.02927995f, 
    -0.01207658f, -0.03739566f, 0.00150825f, 0.00397208f, 0.00172892f, 0.02405122f, 0.03350815f, -0.01935365f, 
    0.00300423f, -0.01028582f, -0.03416194f, -0.04481992f, 0.03174584f, 0.01635432f, -0.03931815f, -0.00161040f, 
    0.01865362f, -0.01299733f, -0.02165571f, -0.00951208f, -0.01620304f, -0.02721747f, 0.02908198f, 0.00939251f, 
    -0.01966953f, 0.00728147f, -0.02079060f, 0.02305188f, 0.02668748f, -0.04300827f, 0.00560949f, 0.00277288f, 
    0.03277616f, 0.01721395f, -0.03000973f, 0.01857170f, -0.00438503f, -0.04249338f, -0.03218551f, -0.02304554f, 
    0.02878519f, 0.01204811f, -0.03023644f, 0.03235295f, -0.03107010f, 0.03048108f, 0.02571873f, -0.00848135f, 
    0.03758643f, -0.02480901f, 0.02098393f, -0.03214908f, -0.04127277f, 0.01526103f, 0.02642432f, -0.03006406f, 
    0.00102008f, 0.03025865f, 0.00443494f, -0.01239846f, 0.01565861f, 0.01692148f, 0.02851261f, -0.02756576f, 
    0.00161318f, -0.01271541f, -0.04109386f, -0.00956383f, 0.02347919f, -0.04427914f, -0.01204782f, -0.02672404f, 
    -0.02934143f, 0.00830678f, 0.02504277f, -0.02035927f, 0.03012649f, 0.03223794f, -0.00951991f, -0.00481769f, 
    0.03070430f, 0.02847475f, 0.02471521f, 0.02445831f, -0.03018346f, 0.00292081f, 0.02302558f, 0.01368800f, 
    0.01211575f, -0.04472126f, 0.02061592f, 0.02523440f, 0.02562109f, 0.01235420f, -0.00342821f, 0.00524151f, 
    -0.02370394f, -0.03071336f, -0.02688037f, -0.01633276f, 0.00442126f, -0.02600029f, 0.03231973f, -0.04057334f, 
    -0.03461938f, -0.03371191f, -0.03102888f, 0.00902269f, -0.00924371f, 0.00161123f, -0.01003630f, -0.00218991f, 
    0.00493349f, -0.03416574f, -0.01658491f, 0.02154783f, -0.02178495f, 0.00832427f, -0.04370744f, -0.02228414f, 
    -0.01738663f, -0.00807250f, 0.00797544f, -0.02083597f, -0.04269707f, -0.02635369f, 0.02906277f, -0.02632451f, 
    -0.01088677f, -0.01902063f, 0.00656373f, 0.00927862f, 0.03262547f, -0.00184588f, 0.00623449f, -0.01789142f, 
    -0.01247928f, -0.03321137f, -0.01062977f, -0.03397164f, 0.03179973f, -0.00580168f, 0.00976358f, 0.02003156f, 
    -0.00673648f, -0.00503869f, -0.03726056f, 0.02035801f, -0.04373124f, 0.00427526f, -0.02233820f, -0.00820521f, 
    -0.01922896f, -0.00991648f, 0.01821293f, 0.02639395f, 0.00656834f, -0.02104017f, -0.03124224f, 0.00485109f, 
    0.02512197f, -0.00327200f, -0.01872151f, 0.01343438f, 0.02804686f, 0.00534732f, -0.03951151f, -0.01954894f, 
    -0.02551788f, -0.04548617f, -0.01854991f, 0.01668963f, -0.00573908f, 0.02501344f, -0.04094443f, -0.03206276f, 
    -0.03092526f, 0.00242448f, 0.02204969f, -0.03095301f, -0.03617736f, -0.02965906f, 0.02998038f, -0.02481573f, 
    -0.03907010f, -0.02272866f, -0.02150723f, -0.04370192f, -0.02765911f, -0.03333646f, -0.01769526f, -0.03472118f, 
    0.02003238f, 0.02958452f, 0.00290284f, 0.02301954f, 0.01088717f, 0.04364559f, 0.00042910f, -0.01245315f, 
    0.01723520f, -0.01313786f, 0.03090732f, 0.00139724f, 0.02094852f, -0.01793342f, -0.04166220f, 0.00885899f, 
    -0.00692141f, -0.02691483f, 0.00959716f, -0.00321346f, -0.00778045f, -0.03266861f, 0.00104267f, -0.00264334f, 
    -0.03723153f, -0.01395379f, -0.03851137f, 0.01232684f, 0.00249537f, -0.04025717f, 0.02969581f, 0.01857857f, 
    0.02788017f, 0.03051925f, 0.00584580f, 0.01404445f, 0.01153861f, -0.02459515f, -0.02959312f, 0.03143214f, 
    -0.00922891f, 0.00269655f, 0.02560479f, -0.03441804f, 0.03273725f, -0.01049112f, -0.02680491f, 0.01108433f, 
    -0.00532971f, -0.01959722f, -0.02402920f, 0.00557217f, -0.00274698f, -0.04495994f, -0.01275625f, -0.02865377f, 
    -0.03160301f, -0.04527469f, 0.01218834f, -0.00898919f, -0.03812844f, -0.01019497f, -0.04177316f, -0.01037751f, 
    -0.04042638f, -0.01602772f, 0.00835047f, -0.01151446f, 0.01771798f, 0.00136698f, -0.04282252f, -0.02585030f, 
    0.02728349f, -0.00539150f, -0.02775013f, -0.00676435f, -0.00799427f, -0.02035517f, 0.02153846f, 0.02633380f, 
    -0.00820135f, -0.04207283f, -0.03520335f, -0.03846454f, -0.03526624f, -0.02202637f, 0.00133958f, -0.01313524f, 
    0.02041115f, 0.00691147f, 0.01241480f, -0.01164735f, -0.01102813f, -0.02960077f, 0.02687757f, -0.00197039f, 
    0.00127973f, 0.01819310f, 0.02112983f, -0.00376431f, -0.01133672f, 0.02708550f, -0.00995882f, 0.00622056f, 
    0.00746727f, 0.00763844f, -0.00072513f, 0.01652138f, -0.01965754f, -0.03211395f, 0.02521794f, 0.00642115f, 
    -0.04356783f, -0.03260911f, 0.01793518f, -0.00157794f, -0.02570652f, 0.02040127f, -0.04102626f, 0.00507724f, 
    0.02354875f, -0.00115708f, -0.03757836f, -0.02042408f, -0.00697053f, 0.00564526f, 0.00281804f, 0.01529393f, 
    0.02245135f, 0.02679246f, -0.02787812f, 0.02018830f, -0.02115873f, -0.01435487f, -0.00563778f, 0.00478791f, 
    -0.03713293f, 0.02899196f, -0.04308433f, -0.02352186f, -0.01990533f, 0.01196342f, -0.01332023f, -0.03325548f, 
    -0.04495087f, -0.02685550f, -0.00492208f, -0.03422963f, 0.03098612f, 0.01624968f, -0.02532069f, -0.02647227f, 
    -0.04548577f, -0.03114082f, -0.00679043f, -0.03310593f, -0.01072712f, -0.02073663f, 0.02860134f, 0.01618206f, 
    -0.00704245f, -0.04237483f, -0.03117184f, -0.00938146f, -0.00803998f, -0.03544294f, -0.00494924f, -0.04200333f, 
    0.02090806f, 0.00484602f, 0.00958297f, -0.00754172f, 0.00451339f, -0.03953050f, -0.02340610f, 0.00244745f, 
    0.02211718f, 0.02269954f, 0.02021807f, -0.00968306f, 0.02570347f, -0.03583129f, 0.02782850f, 0.01627210f, 
    -0.01688520f, -0.02138859f, -0.01233538f, 0.02209059f, 0.01252512f, 0.02471792f, 0.01924110f, -0.02163466f, 
    -0.00439092f, 0.01778476f, -0.03421146f, 0.00699499f, 0.02568990f, -0.00874470f, -0.03221628f, -0.01614156f, 
    -0.04440765f, 0.02337637f, 0.03216669f, -0.04530722f, -0.01999838f, 0.00748717f, 0.02486964f, -0.01416476f, 
    0.02435418f, -0.03203656f, 0.01914171f, -0.04347326f, 0.01864418f, -0.00338047f, -0.04232258f, 0.01550928f, 
    -0.04202056f, -0.04342038f, 0.00597986f, -0.04372502f, 0.00471728f, -0.01268188f, -0.03111818f, 0.02406522f, 
    0.00029881f, -0.00259031f, -0.00328108f, -0.03212041f, -0.02468751f, 0.02096213f, -0.03383848f, -0.01293874f, 
    -0.00488559f, 0.00509508f, -0.01264661f, 0.01564646f, 0.01509139f, 0.00138101f, -0.02225202f, -0.02057713f, 
    -0.00713639f, -0.03216963f, 0.00096327f, 0.00807746f, 0.00317944f, 0.01140367f, -0.04436923f, 0.00982691f, 
    -0.04345168f, 0.00459860f, 0.04394840f, 0.02491677f, -0.01310260f, 0.00680606f, -0.04209777f, -0.02916302f, 
    0.01660464f, 0.01642813f, 0.00514945f, -0.01636470f, 0.00460935f, -0.00250038f, -0.01634191f, 0.00771362f, 
    -0.02732920f, 0.01239031f, -0.01181067f, -0.02449504f, 0.03045536f, 0.01751516f, -0.00085132f, -0.01677184f, 
    -0.00877797f, 0.00490339f, -0.01046115f, 0.02473548f, -0.03849677f, -0.01320202f, 0.00165618f, -0.03379858f, 
    0.02120845f, 0.03181264f, -0.02243572f, -0.03225059f, 0.01033775f, -0.00815218f, -0.03375789f, -0.03435269f, 
    0.01859659f, -0.00339860f, 0.00525932f, -0.02877125f, 0.00983064f, -0.02482082f, -0.01641746f, 0.02808475f, 
    0.00318410f, -0.00915702f, -0.02181889f, -0.03702973f, 0.03476344f, -0.03911123f, 0.00625397f, -0.02532952f, 
    0.00163376f, -0.01316993f, -0.03148676f, 0.01263607f, -0.03837530f, -0.04100443f, -0.00273024f, -0.06589490f, 
    -0.01384268f, -0.04817411f, -0.03084250f, -0.03429716f, 0.02952846f, -0.01153385f, 0.01475624f, 0.01643416f, 
    -0.00453712f, 0.02127232f, 0.02393012f, -0.00314369f, -0.02716244f, -0.01081932f, -0.00937677f, -0.02927730f, 
    -0.00147161f, 0.02135344f, -0.06127819f, 0.01094060f, -0.00582967f, 0.00995861f, -0.00012957f, -0.02057881f, 
    -0.02281788f, 0.03005015f, 0.00539787f, 0.03782967f, 0.01880573f, -0.03001603f, 0.01408647f, -0.02190779f, 
    -0.01703922f, -0.00170551f, 0.01696978f, 0.03474082f, -0.01962490f, -0.02002089f, -0.01388795f, -0.01605047f, 
    0.02022817f, 0.02965708f, -0.01875254f, -0.03388612f, -0.02592708f, -0.01588158f, -0.03169594f, 0.02388956f, 
    0.01101667f, 0.04930104f, 0.03651442f, -0.03144933f, 0.04624268f, -0.00120828f, 0.00091591f, 0.00966421f, 
    -0.03326136f, -0.03109710f, 0.01823114f, -0.04541785f, -0.03645016f, 0.02919977f, -0.01492518f, -0.01842453f, 
    -0.03428053f, -0.01941757f, -0.03453048f, 0.00906755f, 0.01467321f, 0.02409130f, 0.00585413f, -0.04136833f, 
    -0.02097160f, 0.02435071f, -0.02093761f, -0.03944701f, -0.00546656f, -0.02729922f, 0.00909323f, 0.00330946f, 
    0.05043922f, 0.03835671f, -0.01175782f, -0.01100727f, 0.01116120f, -0.02499225f, -0.00910657f, -0.00820409f, 
    -0.02377999f, -0.01681157f, 0.01420393f, 0.01752596f, 0.00024954f, -0.00576720f, 0.01273817f, 0.01956176f, 
    -0.04121700f, -0.02838705f, -0.01813138f, 0.03012488f, 0.00638013f, -0.03601553f, 0.01129275f, 0.01581913f, 
    -0.00866896f, -0.02703646f, 0.02649448f, 0.00392076f, -0.00646104f, -0.02397122f, 0.01635361f, -0.00809620f, 
    0.00318117f, 0.00602709f, -0.02819452f, -0.03242581f, -0.01393566f, 0.02692421f, 0.01322870f, 0.02433151f, 
    0.02971855f, -0.03652721f, -0.01630214f, -0.03795824f, 0.03473199f, 0.02377215f, 0.01278087f, -0.01317926f, 
    0.00045594f, -0.01155510f, -0.01925809f, 0.01454199f, 0.01896997f, 0.03051821f, -0.02216521f, -0.02896472f, 
    0.01860147f, -0.00606300f, -0.04803983f, -0.01249672f, -0.01129265f, -0.01610410f, -0.00576463f, 0.02473264f, 
    0.03156854f, -0.01559484f, -0.03053141f, 0.02549269f, -0.00605114f, 0.02832204f, 0.03425875f, 0.02296266f, 
    -0.01482879f, 0.01158575f, 0.01059201f, 0.02479761f, -0.01897155f, 0.01557325f, -0.01118904f, 0.00788663f, 
    -0.02830813f, -0.01234167f, 0.01084592f, 0.00586892f, 0.02078598f, -0.01320600f, 0.01749980f, 0.01256070f, 
    -0.03805206f, 0.00664607f, 0.03676638f, 0.04204760f, -0.01878472f, -0.03876222f, 0.04314812f, 0.03983752f, 
    0.00268565f, -0.00467507f, -0.01185442f, -0.04631440f, -0.02213833f, 0.02922961f, -0.03811930f, -0.04662340f, 
    -0.00257183f, -0.00934015f, -0.03415784f, -0.02327391f, 0.00226202f, 0.01469478f, -0.00075074f, -0.00261085f, 
    0.01978166f, -0.02962193f, -0.05549606f, 0.02817801f, -0.03998414f, -0.02628298f, -0.00277926f, -0.03548422f, 
    0.02181989f, -0.02598124f, -0.01656897f, -0.02670830f, 0.01673757f, -0.02721209f, -0.04646796f, 0.00122187f, 
    0.00520358f, 0.00276002f, 0.02960758f, 0.00222900f, 0.02554675f, -0.00678483f, 0.00984622f, -0.02525862f, 
    0.02604897f, -0.02780720f, -0.01768415f, -0.02844112f, -0.03422686f, -0.00629176f, 0.01990149f, -0.05073694f, 
    -0.02529821f, 0.01204030f, 0.01432674f, 0.01934002f, -0.03925222f, -0.02556392f, 0.02112415f, 0.02047862f, 
    -0.03622845f, 0.02226825f, -0.00709411f, 0.00262014f, 0.05366154f, -0.01576984f, -0.02329589f, -0.02773011f, 
    0.01218581f, -0.02625293f, -0.02373047f, -0.01497813f, 0.01182665f, -0.04315157f, 0.03222445f, 0.00229561f, 
    0.02543363f, -0.04618675f, -0.03182462f, 0.01723373f, -0.02057521f, 0.00000143f, -0.00227501f, -0.00910866f, 
    0.02852784f, 0.02328105f, -0.01991202f, -0.01809318f, 0.02659029f, 0.00462826f, -0.01166517f, -0.04102716f, 
    0.01493905f, 0.02513328f, 0.02283391f, -0.03183622f, -0.01223449f, -0.03151019f, 0.00702320f, -0.00005200f, 
    0.04090059f, 0.00825609f, -0.04562094f, -0.02932213f, -0.01311905f, -0.00425046f, 0.01012022f, 0.02355754f, 
    -0.00154294f, -0.00189111f, 0.01883272f, 0.02009134f, -0.01243255f, 0.01453497f, 0.02190044f, -0.04401070f, 
    -0.02851783f, 0.01016159f, 0.01368149f, 0.02625877f, 0.03220334f, -0.02114379f, -0.02491709f, 0.01122533f, 
    0.00331984f, -0.02743626f, -0.05198860f, -0.03482554f, 0.02954923f, -0.02056476f, -0.02515733f, -0.04172176f, 
    -0.01839550f, -0.02610549f, 0.02328813f, -0.02132253f, -0.00187616f, 0.01942366f, 0.03332707f, 0.00077966f, 
    0.02225848f, -0.02071862f, -0.03294556f, 0.00471271f, 0.00455451f, -0.00944103f, -0.03299408f, -0.01280405f, 
    -0.00495625f, 0.03849633f, -0.03604653f, -0.04928803f, 0.00922935f, -0.02112349f, 0.01474201f, 0.00463156f, 
    0.01410428f, -0.00197627f, 0.00583041f, -0.02400907f, 0.03367944f, -0.04819576f, -0.02471604f, 0.00231579f, 
    -0.05044206f, -0.02747606f, -0.01239271f, 0.01094573f, -0.01740411f, -0.04894783f, -0.01038669f, 0.04142210f, 
    0.02694068f, 0.02207754f, -0.03360005f, -0.00617007f, 0.01242447f, -0.01846693f, -0.02148805f, 0.01768524f, 
    -0.02773330f, 0.02454768f, -0.01292625f, 0.01340356f, -0.00597247f, -0.01366184f, -0.05688332f, -0.05775526f, 
    -0.01924023f, -0.03063696f, 0.03160024f, -0.01269011f, -0.02424126f, 0.00893397f, 0.00860457f, -0.01771480f, 
    -0.00660046f, -0.00085334f, -0.02741648f, 0.00434839f, 0.01367775f, -0.00042817f, 0.01169871f, -0.00743056f, 
    -0.03194351f, 0.00553586f, 0.00748115f, -0.05261764f, -0.03686569f, -0.00097302f, 0.02131836f, 0.00241844f, 
    0.03029221f, -0.03696952f, 0.00119278f, -0.01965650f, -0.03447102f, -0.02688303f, 0.00317397f, 0.01598425f, 
    0.04051230f, -0.00244391f, 0.01980526f, 0.00057592f, -0.01092003f, -0.02096196f, -0.04380227f, -0.02936625f, 
    0.03268785f, -0.02616487f, 0.03286784f, 0.03467592f, -0.04294040f, -0.03530283f, 0.04087069f, -0.00638802f, 
    0.00454123f, 0.03122982f, 0.00028567f, -0.00230497f, 0.00867533f, -0.00325348f, -0.01775207f, 0.02606756f, 
    -0.01724501f, 0.01184710f, 0.01624589f, -0.02772179f, -0.00406265f, 0.02144746f, -0.00894855f, -0.01773103f, 
    0.01863088f, -0.01236174f, 0.00868573f, -0.00979103f, 0.00340669f, -0.04544908f, -0.03797064f, -0.03811022f, 
    -0.03261801f, -0.02356930f, -0.02512861f, -0.00681081f, -0.00323846f, 0.01250907f, -0.04265798f, 0.02217683f, 
    0.02488977f, -0.00485758f, -0.03202495f, -0.01730953f, 0.01496052f, 0.02911091f, 0.01489113f, 0.02834543f, 
    -0.02503149f, -0.03161315f, -0.00430010f, -0.03304105f, 0.00003221f, 0.01498875f, 0.00777207f, -0.03322785f, 
    -0.00590497f, -0.05696976f, 0.00540286f, 0.00424085f, -0.03096309f, 0.01980942f, 0.01429454f, -0.04396248f, 
    -0.03310727f, 0.00144050f, -0.03182416f, -0.03827670f, 0.02303358f, 0.02777730f, -0.00263282f, 0.01566394f, 
    0.03492060f, -0.03384968f, 0.02609251f, 0.00796993f, 0.04342311f, 0.03577141f, 0.01293426f, 0.01316390f, 
    0.04868666f, 0.00934185f, -0.01264358f, 0.02902871f, -0.03481260f, 0.02794828f, 0.03497452f, 0.02881910f, 
    0.01605905f, -0.02191618f, -0.01611392f, -0.01228477f, 0.00075999f, -0.04335882f, -0.00850316f, 0.03074513f, 
    -0.01113087f, 0.03160327f, 0.02665239f, -0.03740312f, 0.00869487f, -0.00658985f, 0.00867927f, 0.00450011f, 
    -0.01132247f, 0.01231968f, -0.02495654f, 0.01195204f, 0.01734352f, -0.01086515f, 0.00339858f, 0.00344904f, 
    -0.01741027f, 0.00761646f, -0.00610706f, 0.04044670f, -0.03718622f, -0.04234057f, 0.01598205f, -0.03617773f, 
    -0.04023139f, 0.02512634f, 0.00606010f, -0.00954739f, -0.01044039f, 0.01814382f, -0.00564239f, -0.01270580f, 
    0.00383554f, -0.02442237f, 0.02264501f, -0.00989771f, -0.04158750f, -0.02830238f, 0.03011060f, 0.03245999f, 
    -0.04850219f, -0.02767371f, -0.01556067f, -0.05172740f, 0.03926279f, -0.00991831f, -0.02179378f, -0.01155075f, 
    -0.01202154f, -0.01174133f, -0.02158186f, -0.04214305f, -0.01955947f, 0.02011993f, -0.00358856f, 0.02242882f, 
    -0.03108429f, -0.02598962f, -0.00171501f, -0.03743789f, -0.02473440f, 0.03069893f, -0.01965122f, -0.02247405f, 
    0.04037811f, -0.01193354f, 0.03234132f, -0.03117135f, -0.01003648f, 0.02509020f, -0.04512960f, -0.02142761f, 
    0.01885585f, -0.01543511f, -0.03248589f, -0.01726457f, -0.01502670f, 0.01428719f, -0.02854333f, -0.03958101f, 
    0.02473954f, 0.00950228f, -0.03803352f, -0.04532984f, -0.05125292f, 0.03743521f, 0.00519032f, 0.01534845f, 
    0.01275179f, -0.02612924f, -0.05139983f, -0.00732590f, 0.00147871f, -0.00434520f, -0.00145356f, -0.01415869f, 
    0.02341520f, -0.03040433f, -0.03518609f, -0.02844842f, 0.00924645f, -0.04470094f, -0.03680146f, -0.03181135f, 
    -0.04612292f, 0.00138616f, -0.01401316f, 0.01290470f, 0.02926487f, 0.00141926f, 0.00200552f, -0.01797385f, 
    0.02893383f, 0.03404471f, -0.01464681f, -0.00625554f, -0.00473128f, 0.02444140f, 0.02012492f, -0.05060068f, 
    -0.16371900f, 0.21341245f, -0.12345645f, 0.15927583f, -0.03411894f, -0.06157648f, -0.09687992f, -0.07040304f, 
    -0.06534360f, 0.07110160f, -0.01018922f, -0.06590071f, 0.05492596f, 0.01483091f, 0.00148698f, -0.02333122f, 
    -0.00664921f, 0.00521572f, -0.06213700f, -0.06174265f, 0.02072018f, 0.28867286f, -0.21817726f, 0.24937309f, 
    -0.18728785f, 0.04728271f, -0.00782252f, 0.03768027f, -0.04214330f, 0.01063592f, -0.05493579f, 0.00034016f, 
    0.13749227f, -0.08844345f, 0.09034839f, -0.08413343f, 0.00289724f, -0.12054735f, 0.05495028f, 0.11274087f, 
    0.66230345f, 0.05464135f, 0.17470111f, -0.01138911f, 0.24668324f, -0.13223843f, -0.02464452f, -0.07814787f, 
    -0.00550108f, 0.03020398f, -0.01445493f, -0.00448546f, -0.02225105f, 0.01073808f, -0.00336808f, -0.00759865f, 
    0.09512902f, -0.10845549f, 0.03994463f, 0.13764222f, -0.36337966f, -0.59174609f, 0.14468400f, 0.06812058f, 
    0.48885584f, -0.01333999f, -0.00978730f, 0.12277254f, 0.01627254f, -0.04398854f, 0.26997289f, 0.18316671f, 
    0.06647336f, 0.03437037f, 0.01647432f, 0.33498216f, 0.01687951f, 0.09320869f, 0.06436095f, 0.03922114f, 
    0.05846081f, -0.12976177f, 0.11060493f, 0.16251107f, -0.07880564f, 0.12752318f, 0.14175880f, 0.02999338f, 
    -0.00610999f, -0.12922800f, 0.21391658f, 0.02398826f, 0.03621670f, -0.03135571f, -0.00172255f, 0.29132560f, 
    -0.06017300f, -0.11846591f, 0.04260841f, 0.13617338f, 0.09860267f, 0.48881233f, 0.04860358f, 0.22294453f, 
    0.17065684f, -0.16616262f, 0.13257106f, -0.02365687f, 0.08642885f, 0.05952283f, -0.05990072f, -0.08970795f, 
    0.01267467f, -0.03755241f, -0.04876712f, 0.22094670f, -0.04289243f, -0.05512626f, -0.06218493f, -0.11193787f, 
    0.36082515f, 0.01771214f, 0.25389218f, -0.00219486f, 0.14070520f, -0.07134493f, 0.11087011f, -0.06167334f, 
    0.06908122f, 0.08262708f, 0.08763613f, 0.04089652f, -0.03426192f, 0.00844671f, -0.01014628f, -0.03477267f, 
    0.23719761f, -0.11584820f, 0.13171372f, 0.11637762f, -0.04597206f, -0.21906047f, 0.44694987f, -0.21473217f, 
    -0.62067360f, 0.04180345f, -0.17879857f, -0.20176478f, -0.08581857f, 0.09112016f, -0.17472292f, -0.07024971f, 
    -0.08351290f, 0.13503805f, -0.04981498f, -0.08480895f, 0.10602239f, -0.11491548f, 0.16612317f, 0.03545137f, 
    -0.37167972f, 0.32313329f, -0.17616500f, -0.09459116f, -0.10089337f, -0.05944281f, -0.10478589f, -0.09135798f, 
    -0.00672214f, -0.06177870f, -0.01453352f, 0.05524414f, 0.01241047f, 0.02607002f, -0.09254896f, -0.06654421f, 
    -0.00669719f, 0.08550760f, -0.08557305f, -0.04950685f, -0.21916772f, 0.25465387f, 0.12633155f, 0.09753244f, 
    -0.00247590f, -0.26293924f, -0.03110548f, -0.15611930f, -0.19555788f, 0.10576377f, -0.13448626f, -0.01075572f, 
    0.05481006f, -0.15127321f, -0.01856370f, -0.04856531f, 0.00103052f, -0.00523060f, -0.09671659f, 0.01632066f, 
    0.06176948f, -0.01413642f, 0.04576408f, 0.14376597f, 0.15325096f, -0.03495429f, -0.00160360f, 0.04302562f, 
    0.02982238f, 0.06990107f, 0.16357565f, 0.22011299f, 0.09957444f, 0.04180145f, 0.09268975f, -0.06694096f, 
    -0.15170228f, -0.00314667f, -0.13399258f, -0.09988581f, 0.23048344f, -0.14621510f, 0.27891737f, 0.23766200f, 
    0.25750467f, 0.09871950f, 0.14670290f, 0.17663001f, 0.14325243f, 0.07361052f, 0.14749484f, 0.04723673f, 
    0.03915330f, 0.19008161f, 0.09370055f, 0.21162303f, 0.03818779f, 0.08607896f, 0.05466808f, -0.16480644f, 
    0.03019062f, -0.13333470f, 0.03209555f, 0.01788584f, -0.02278798f, -0.03209430f, 0.10849534f, 0.00493902f, 
    -0.01516514f, -0.07414312f, 0.07491899f, 0.09198470f, -0.10453041f, 0.04637044f, 0.02789743f, -0.11276849f, 
    -0.03788774f, -0.04526679f, 0.03547567f, -0.00106010f, -0.04493771f, 0.23876432f, -0.03105065f, -0.06737930f, 
    -0.07204866f, 0.06470777f, 0.04543898f, -0.01749501f, -0.08697031f, 0.13715792f, 0.01165880f, 0.05634131f, 
    0.13289307f, 0.18128952f, 0.03818734f, -0.05726376f, 0.12700014f, -0.02997703f, 0.11039414f, 0.05860763f, 
    -0.06885262f, 0.00375490f, -0.03619964f, 0.04565505f, 0.06812768f, -0.03453949f, -0.03659096f, 0.04240428f, 
    -0.02759755f, -0.07132122f, -0.20936869f, 0.16435738f, -0.06270842f, -0.03593004f, 0.02365781f, -0.16728370f, 
    -0.18641116f, -0.10466266f, 0.00692376f, 0.02565984f, -0.38304380f, -0.32827786f, 0.09121920f, -0.02137202f, 
    0.04697368f, 0.03428793f, 0.12776519f, 0.05980116f, -0.01153508f, 0.08155052f, -0.07241993f, 0.11427036f, 
    0.00752963f, -0.05318857f, -0.10783070f, 0.00530741f, -0.02952059f, 0.06385041f, 0.05106256f, 0.12441841f, 
    0.01622254f, -0.08677800f, 0.06066011f, -0.00396455f, -0.10351275f, -0.03477653f, 0.21077856f, -0.01976217f, 
    0.17287686f, 0.05204370f, 0.15458153f, 0.14589059f, 0.00667575f, 0.12744620f, 0.09929933f, -0.06369340f, 
    0.03494051f, -0.06709033f, 0.11229370f, 0.15809810f, -0.43245739f, -0.36728051f, 0.28348562f, -0.13759558f, 
    0.18056764f, 0.06156784f, 0.04091049f, -0.18210919f, -0.02105730f, 0.00663841f, 0.01654445f, 0.08063518f, 
    -0.08378293f, 0.11110598f, 0.06669831f, -0.19438520f, 0.07939868f, -0.07885282f, 0.02871986f, 0.15195321f, 
    0.39822897f, -0.06635687f, 0.16913462f, 0.20712820f, -0.26370856f, 0.06361151f, -0.01867197f, -0.06622547f, 
    0.13046475f, -0.10884467f, 0.05544649f, -0.11984632f, 0.06125986f, -0.17160790f, -0.02665595f, 0.08194481f, 
    0.04050425f, 0.04555902f, -0.02137067f, -0.09840614f, -0.15857120f, -0.20253879f, 0.07320013f, 0.10689014f, 
    -0.08007039f, -0.05869199f, -0.03834134f, -0.00666542f, 0.09345845f, -0.07951698f, -0.04009091f, 0.00557632f, 
    -0.04060007f, 0.10766413f, 0.04345949f, -0.00531179f, -0.07176677f, -0.14032626f, -0.14629903f, -0.01812573f, 
    0.04878157f, -0.01270124f, 0.21048464f, -0.01542255f, -0.21103273f, 0.03713980f, 0.03840966f, -0.13307557f, 
    -0.01046156f, 0.25396043f, -0.00661459f, 0.01951734f, -0.04477954f, -0.08405714f, -0.01425811f, 0.15561539f, 
    0.01069269f, -0.07751171f, 0.10196028f, 0.06173711f, 0.78318822f, 0.01964419f, -0.23412099f, 0.34230268f, 
    -0.09741140f, -0.14596015f, 0.10036568f, -0.20692526f, 0.20448433f, 0.10721686f, -0.21363784f, 0.13133502f, 
    0.05576605f, 0.06163380f, -0.06911516f, 0.19948299f, -0.06007944f, -0.00731985f, 0.05508808f, 0.05801063f, 
    -0.09238678f, -0.01598434f, -0.18967287f, 0.18800943f, -0.07349653f, -0.03977566f, -0.09531905f, -0.01146779f, 
    0.23790349f, -0.20460208f, -0.10291316f, 0.18912578f, -0.07082386f, 0.12561823f, 0.03437628f, -0.02545356f, 
    0.04420926f, 0.01088965f, -0.11713452f, -0.00697625f, 0.26310602f, 0.25519821f, 0.15626143f, -0.15156995f, 
    -0.14444712f, -0.07336015f, -0.10420705f, -0.07951371f, -0.02339202f, -0.00660026f, -0.07140185f, 0.02535351f, 
    0.02868677f, 0.09713496f, -0.00867618f, -0.13687503f, 0.07373776f, -0.07565753f, 0.10517854f, 0.06851227f, 
    0.02886973f, 0.25074914f, 0.03289639f, 0.21695884f, -0.09281512f, 0.00789180f, -0.10925053f, 0.00614177f, 
    -0.03495053f, 0.13370112f, 0.00823449f, -0.02678829f, -0.11814561f, 0.03594374f, 0.05674189f, -0.00294769f, 
    0.19549058f, -0.11487162f, -0.06651744f, 0.10338764f, 0.18257502f, 0.04143249f, 0.52219790f, 0.05738109f, 
    0.18618619f, 0.00900535f, 0.11051513f, 0.01845456f, 0.03263574f, -0.02764042f, -0.09967317f, -0.05982838f, 
    -0.05300927f, 0.04871878f, -0.01333920f, 0.18170008f, 0.15372251f, 0.00293277f, -0.06974246f, 0.02021493f, 
    0.30949405f, 0.04598042f, 0.09180483f, 0.18630674f, 0.04993258f, -0.07695670f, 0.11478594f, 0.01398446f, 
    0.15674672f, 0.00912629f, 0.06502083f, 0.13825372f, -0.01684827f, 0.04498544f, 0.06433604f, -0.06191592f, 
    -0.05095943f, 0.01575700f, -0.12770113f, 0.00713466f, 0.40166110f, -0.14141157f, 0.23102635f, 0.20595449f, 
    -0.44915083f, 0.01218981f, 0.13230579f, 0.04242073f, 0.15695982f, -0.18918034f, -0.06068145f, -0.13786881f, 
    0.26178926f, -0.05085064f, -0.08112837f, 0.03157133f, 0.11036651f, -0.07608304f, 0.02235510f, 0.02760669f, 
    0.32018620f, 0.02712793f, -0.06198735f, 0.20142150f, 0.00618403f, -0.05550048f, -0.05229693f, 0.05531472f, 
    0.19026472f, 0.01188009f, -0.13064490f, 0.25130364f, -0.19883756f, 0.02565657f, -0.07319937f, 0.00150079f, 
    -0.06497629f, 0.08566203f, 0.06853991f, -0.06502186f, 0.31479475f, -0.01265080f, -0.03754405f, 0.20106423f, 
    0.05605916f, -0.11962437f, -0.00339821f, 0.01933347f, 0.06300373f, 0.07771049f, -0.03908225f, 0.09629849f, 
    0.03674028f, 0.04389719f, -0.03910676f, -0.00048474f, -0.00743437f, -0.02103694f, -0.05599605f, -0.12517564f, 
    -0.11999495f, -0.19509615f, -0.20168665f, 0.10412682f, -0.10764749f, -0.11708821f, -0.05558234f, -0.00583473f, 
    0.07200059f, -0.10554340f, -0.05561090f, 0.01399546f, -0.03912416f, 0.01877771f, -0.05158029f, -0.07068612f, 
    -0.05540328f, -0.09221043f, -0.07848935f, -0.07916617f, -0.06800658f, 0.13447906f, -0.30701897f, -0.21037646f, 
    -0.35846147f, 0.02745014f, -0.18072076f, -0.07916572f, 0.03066737f, 0.10336722f, -0.16276598f, -0.01451937f, 
    0.00082677f, 0.03873332f, 0.07593957f, -0.04298190f, -0.06999131f, -0.22960073f, -0.05780976f, 0.11398200f, 
    -0.07852914f, -0.06491062f, -0.29222152f, -0.05857912f, 0.22236423f, 0.03405486f, -0.03412218f, 0.00277992f, 
    0.10102674f, -0.03016851f, -0.00799563f, -0.09409749f, -0.01994474f, 0.09053174f, 0.03319306f, 0.04553895f, 
    0.03116783f, 0.10473625f, -0.13695814f, 0.10967179f, -0.01951316f, 0.18309775f, -0.23305355f, -0.00802891f, 
    0.03032268f, 0.07124539f, -0.05347621f, 0.12443510f, -0.06405798f, -0.07061008f, -0.03617543f, 0.06061969f, 
    -0.08219437f, -0.10458201f, 0.02914285f, -0.01237344f, -0.08654797f, 0.00445039f, -0.07659429f, 0.01383624f, 
    -0.12146794f, -0.00732427f, 0.36256206f, 0.12562013f, 0.05979337f, -0.12682533f, 0.09660383f, -0.15554039f, 
    0.01612516f, -0.08531936f, -0.26670992f, -0.06111320f, -0.07811567f, -0.00433499f, -0.01973892f, 0.11039107f, 
    0.06065533f, -0.18389724f, 0.08749269f, -0.08738479f, 0.23494531f, -0.13327122f, 0.01918575f, -0.00556963f, 
    0.12842041f, -0.02621793f, 0.05371829f, -0.02115744f, -0.04741545f, -0.04717596f, -0.05784624f, 0.01269812f, 
    0.04221593f, 0.07585306f, 0.01654212f, 0.10610490f, 0.05136231f, -0.06089162f, 0.01131405f, -0.17505179f, 
    0.20736355f, 0.25466678f, -0.03120335f, 0.01613336f, 0.02964478f, 0.13403499f, 0.11014989f, 0.03027146f, 
    -0.03336380f, 0.04757599f, 0.04086326f, 0.03375651f, -0.02991282f, 0.02362430f, 0.05887584f, 0.13474393f, 
    0.00082272f, 0.02805889f, -0.00100834f, -0.01762063f, -0.37398499f, 0.36572573f, 0.20197313f, 0.35935971f, 
    -0.07449333f, 0.02293126f, 0.07988194f, -0.11103147f, -0.00000343f, 0.04653122f, -0.18314680f, 0.00866612f, 
    -0.02705915f, 0.06652992f, -0.04747374f, 0.08469752f, 0.03734282f, 0.23684001f, -0.04973542f, -0.16881460f, 
    0.13562422f, 0.15995912f, 0.32049459f, -0.15621731f, 0.06208051f, -0.10490406f, 0.02773792f, -0.08660256f, 
    0.05208179f, -0.03362433f, -0.08591818f, 0.01363190f, -0.06092811f, 0.06810216f, 0.03843947f, -0.04053064f, 
    0.18226293f, -0.02197984f, 0.04852775f, 0.01267412f, 0.00106586f, -0.40007499f, 0.53590792f, 0.14461933f, 
    0.10891730f, -0.04995645f, 0.03908427f, -0.04356292f, 0.02268472f, 0.08644856f, -0.10165203f, -0.03894942f, 
    0.02555393f, 0.17727672f, 0.05094753f, 0.04936360f, -0.02270852f, -0.00634923f, -0.03205082f, 0.05503801f, 
    0.08694973f, 0.09161025f, -0.29185778f, -0.07558168f, 0.02671391f, 0.03078015f, 0.01388064f, -0.00130613f, 
    0.16786323f, 0.01830970f, 0.06714927f, 0.00699009f, 0.02309127f, 0.02676013f, 0.00958775f, 0.05564665f, 
    0.09434105f, 0.11442005f, -0.04549469f, 0.16992125f, 0.03260863f, -0.00645129f, -0.19678226f, -0.09160841f, 
    0.03537308f, 0.01058055f, -0.02886055f, -0.07011304f, 0.05085441f, -0.21062228f, -0.06997936f, 0.08677389f, 
    -0.00982088f, -0.04336174f, 0.05131431f, 0.03638301f, 0.08937389f, 0.03463637f, -0.19292012f, -0.08424808f, 
    -0.19903144f, -0.04829938f, -0.05352304f, -0.04009879f, -0.22145329f, -0.31637502f, -0.11173066f, -0.05590508f, 
    -0.07049397f, -0.20060831f, -0.16718410f, -0.06435946f, -0.05805361f, -0.10229841f, 0.02764046f, -0.21380800f, 
    0.03148361f, -0.01555697f, 0.03275902f, -0.13074760f, -0.08547838f, 0.55722064f, -0.08501539f, 0.05348570f, 
    0.04354179f, 0.04751764f, -0.02912920f, 0.12186977f, 0.13546306f, -0.01247825f, 0.06426650f, -0.04426115f, 
    -0.05159955f, 0.01043282f, 0.02411974f, -0.04506476f, 0.07602046f, -0.03057662f, 0.09078700f, -0.07405933f, 
    -0.07955853f, -0.17746426f, -0.23214291f, 0.00503899f, -0.06865434f, -0.04015464f, 0.07919363f, -0.03937449f, 
    -0.09965732f, -0.10944533f, 0.08817660f, 0.04353623f, -0.04630997f, -0.02161448f, 0.03565525f, 0.08877548f, 
    0.08446918f, -0.06728398f, 0.06157706f, -0.04385094f, 0.01170089f, 0.04033840f, -0.10509935f, 0.14000872f, 
    -0.22251117f, -0.08235247f, 0.03985294f, -0.02841974f, -0.01544787f, 0.06257424f, -0.03514514f, 0.00284301f, 
    0.14972682f, 0.10201415f, -0.01519065f, 0.05682817f, 0.05634719f, 0.10531742f, 0.06246094f, 0.12443385f, 
    0.00590818f, -0.17085221f, -0.20141093f, -0.17871861f, -0.18368456f, -0.14922546f, 0.07594242f, -0.10743550f, 
    -0.01157995f, -0.08473292f, -0.03545575f, 0.04553005f, -0.23124786f, -0.05902227f, -0.01701337f, -0.21777888f, 
    0.15595560f, 0.09833497f, 0.08298168f, 0.02506936f, 0.23324773f, -0.02525858f, -0.21120559f, -0.36573333f, 
    0.16633455f, 0.08002434f, 0.05175044f, 0.01165238f, -0.06689747f, -0.09504991f, -0.07499776f, 0.07465396f, 
    0.05890593f, 0.02248309f, 0.00026413f, 0.04815615f, 0.06128739f, -0.01860413f, -0.00027651f, 0.06046956f, 
    -0.15591264f, -0.08263712f, 0.13193195f, 0.08992564f, 0.07272071f, -0.03610302f, 0.05743512f, -0.11941326f, 
    -0.00094597f, 0.01021840f, -0.18581197f, -0.07403459f, -0.02531583f, 0.11875362f, 0.07863265f, -0.00148616f, 
    0.19091234f, -0.14212860f, 0.15269046f, 0.17970638f, 0.45825574f, -0.14372471f, 0.23906666f, -0.00423716f, 
    0.07418857f, 0.05723583f, 0.15904237f, -0.00809303f, 0.05475082f, -0.03280341f, -0.01305948f, 0.08336030f, 
    0.07365700f, 0.08244096f, 0.03797654f, -0.01599159f, 0.06517814f, -0.03759491f, 0.14033847f, 0.05591885f, 
    -0.01730921f, 0.40057564f, 0.00820563f, -0.00575402f, 0.19935794f, 0.16510992f, 0.02256903f, 0.24178112f, 
    0.03769384f, -0.04341303f, 0.02961352f, -0.02772922f, 0.01521852f, 0.04725457f, 0.15442793f, 0.08427204f, 
    0.00157733f, 0.06883284f, 0.00921820f, -0.01164677f, -0.21017575f, -0.39419961f, -0.41136840f, -0.09585385f, 
    -0.01032899f, 0.03824358f, 0.06781242f, 0.07716222f, -0.04928626f, -0.32804695f, -0.00187087f, 0.05136006f, 
    0.03818765f, 0.05892053f, 0.08447212f, 0.01369286f, -0.01514266f, -0.08647674f, -0.13009344f, -0.08483725f, 
    0.16112427f, 0.11316327f, -0.05459776f, -0.08079094f, 0.12379131f, 0.03129304f, 0.10670975f, 0.16812810f, 
    -0.02959099f, -0.05294532f, 0.01857316f, -0.03940571f, -0.06060032f, 0.02166758f, 0.13222295f, 0.19202082f, 
    0.05005484f, -0.03578191f, -0.05148366f, -0.00638712f, -0.03460483f, 0.46956268f, -0.22171392f, 0.33879772f, 
    -0.02269652f, -0.09391776f, -0.05912339f, -0.01707629f, -0.11038465f, 0.17352404f, -0.16303764f, 0.08105543f, 
    0.05321473f, 0.02226457f, -0.02656659f, 0.08230962f, 0.02167154f, 0.02888399f, 0.04328519f, -0.00125652f, 
    -0.15251186f, -0.26024434f, -0.37531912f, 0.10702408f, 0.21389683f, -0.07724673f, 0.01827598f, 0.11044233f, 
    -0.03492714f, 0.06451262f, -0.06419539f, 0.11588456f, -0.06725843f, 0.02827078f, -0.11782312f, -0.06686903f, 
    0.09609558f, 0.25286588f, 0.06124976f, 0.17173751f, -0.17650774f, 0.06553654f, 0.49520659f, -0.09000172f, 
    -0.10532214f, -0.04166177f, -0.09679201f, -0.02142311f, -0.07769638f, -0.05716577f, -0.05107489f, 0.03390273f, 
    0.05174647f, -0.00971946f, -0.03702471f, 0.03732082f, 0.00213673f, 0.10243850f, 0.05400929f, 0.02123703f, 
    0.14280684f, 0.20426066f, -0.04323551f, -0.03653788f, 0.21683811f, 0.26396206f, 0.02797590f, 0.04014783f, 
    -0.05643256f, -0.00508711f, 0.05871245f, 0.02941993f, -0.00559141f, 0.03899741f, 0.13518505f, 0.09042927f, 
    -0.02622015f, 0.02808941f, -0.13256969f, 0.00269724f, 0.14543748f, -0.03224255f, 0.60518706f, -0.00779524f, 
    0.12588459f, 0.12778230f, -0.00169956f, -0.09841298f, 0.12150381f, 0.00758957f, -0.06000902f, -0.05758916f, 
    -0.13235468f, 0.04022244f, 0.06519350f, -0.09171760f, -0.03760119f, 0.09680434f, -0.00681276f, -0.02749642f, 
    -0.14307462f, -0.08721587f, -0.06951319f, 0.12996542f, -0.06650672f, -0.15374263f, -0.03577718f, -0.13800111f, 
    -0.04235081f, -0.09990073f, 0.00622868f, 0.06320401f, 0.02714056f, 0.13953838f, -0.01194272f, 0.02680402f, 
    0.07683004f, -0.00724783f, 0.01249785f, 0.06991888f, 0.00672039f, 0.31530067f, -0.24255840f, 0.25432986f, 
    0.02923823f, 0.06417443f, -0.03094261f, 0.08602910f, -0.06696831f, 0.05346618f, -0.04584780f, 0.00018577f, 
    0.05469368f, -0.03008490f, -0.02333538f, 0.12249091f, 0.01358208f, 0.03481787f, 0.08155561f, 0.12247219f, 
    -0.09110484f, -0.27273333f, -0.07828923f, 0.16955170f, -0.01289920f, -0.15736626f, 0.05506197f, -0.06942610f, 
    -0.08872485f, -0.18108411f, -0.04550306f, 0.06246477f, 0.00635081f, 0.11813094f, 0.02842830f, 0.01559509f, 
    0.06118897f, 0.15084815f, 0.13796484f, -0.08242433f, -0.14551820f, -0.02343739f, -0.06582046f, 0.18851073f, 
    -0.02363935f, -0.02489031f, -0.09642465f, -0.15523443f, -0.05467491f, -0.10039684f, -0.23487043f, -0.13384192f, 
    -0.10894778f, 0.10563439f, -0.09890198f, 0.11367649f, 0.08557732f, 0.12385781f, -0.15450349f, -0.19035552f, 
    -0.16836227f, -0.30661538f, -0.52281123f, -0.14037867f, -0.04274161f, -0.04759929f, 0.03045586f, 0.03929481f, 
    -0.00973795f, -0.23978543f, 0.00370198f, 0.16896601f, 0.06580488f, 0.04000623f, 0.01241503f, -0.01813073f, 
    0.02932226f, -0.10144991f, 0.00806983f, 0.00059702f, -0.09002257f, -0.11235661f, 0.16819879f, -0.20405507f, 
    -0.02442189f, -0.03270996f, -0.14490440f, -0.01208836f, 0.00332760f, 0.09610976f, 0.11401870f, -0.04851562f, 
    0.03691643f, -0.08340010f, 0.04475112f, 0.06434947f, -0.14940238f, -0.02543300f, -0.06289414f, -0.13773416f, 
    -0.00931185f, -0.03194660f, -0.03818417f, 0.01229325f, -0.04216228f, -0.02208709f, 0.00611355f, -0.01878147f, 
    -0.02134061f, -0.03453822f, 0.02883611f, -0.02507500f, -0.00536585f, -0.04065840f, 0.00842659f, -0.02367439f, 
    -0.03223599f, -0.01834041f, 0.02586387f, -0.01536514f, -0.00382646f, 0.03062054f, 0.02682584f, 0.02588083f, 
    0.02031005f, 0.00167294f, 0.02896934f, -0.01301043f, -0.00017630f, 0.02698686f, -0.01016911f, 0.02544779f, 
    -0.04352507f, -0.01046506f, 0.01985547f, 0.01390536f, -0.04378989f, -0.03025885f, -0.03531111f, -0.03356284f, 
    0.02731414f, 0.01788219f, -0.03909628f, -0.01871007f, -0.00018760f, 0.02762848f, 0.03318154f, 0.01589044f, 
    0.01969135f, -0.00295500f, -0.03105805f, 0.02590830f, 0.02720994f, -0.04138923f, 0.03161465f, -0.00662775f, 
    -0.03526942f, -0.01603236f, 0.01266984f, 0.03295461f, 0.01234688f, 0.01917736f, 0.03544996f, -0.03574596f, 
    -0.02275530f, -0.00774634f, 0.01977350f, -0.01784959f, -0.03772616f, -0.00799820f, -0.03120990f, 0.02628267f, 
    -0.01857717f, -0.03578532f, -0.04011581f, 0.01110312f, 0.00215299f, -0.03383949f, -0.04550992f, -0.03211368f, 
    -0.02107172f, -0.02862701f, -0.03127255f, 0.00811701f, -0.02643250f, -0.02245780f, -0.01752012f, -0.03026298f, 
    -0.01233716f, -0.02505076f, -0.02458075f, 0.01799309f, 0.01222894f, -0.04112483f, -0.02723688f, -0.01836805f, 
    0.03080378f, -0.03278835f, 0.01739294f, -0.03741424f, 0.03903447f, 0.00928243f, -0.03911039f, -0.04116649f, 
    -0.03375874f, 0.02351493f, -0.04126917f, -0.01575438f, -0.01156293f, -0.00945253f, -0.00392436f, -0.03302320f, 
    0.02825030f, 0.01548953f, -0.00951092f, 0.00118647f, -0.01166451f, 0.01757649f, -0.01489444f, -0.03878349f, 
    0.02824803f, -0.04536982f, -0.01276026f, 0.00935341f, -0.00452612f, -0.03518583f, -0.02156308f, 0.03248836f, 
    0.01152134f, 0.00148961f, 0.01374399f, 0.01948741f, 0.01010233f, -0.02621537f, -0.02776347f, 0.02424823f, 
    0.00960892f, 0.01421993f, -0.00061747f, -0.03507821f, 0.03030547f, -0.03220312f, 0.02837315f, -0.00647909f, 
    -0.04413063f, -0.01684171f, -0.02588745f, -0.01903807f, 0.02775390f, -0.00862019f, -0.01566573f, -0.00523371f, 
    -0.01298145f, 0.03828761f, -0.00521703f, -0.02099461f, -0.04470765f, -0.03403658f, -0.01975310f, -0.02261696f, 
    -0.03381069f, 0.02414693f, 0.01650081f, -0.01550030f, -0.02268831f, -0.02004091f, 0.02414827f, 0.02893544f, 
    -0.00625655f, -0.03149626f, 0.01652333f, 0.00992461f, -0.04196550f, -0.02913436f, 0.02153167f, 0.02265061f, 
    -0.02419483f, 0.02949334f, -0.02976078f, 0.00860946f, -0.00665969f, -0.02249604f, -0.00346356f, 0.00322159f, 
    0.02933274f, -0.02618736f, -0.00375593f, 0.02036939f, 0.02390035f, -0.00166017f, 0.02443961f, 0.01110684f, 
    0.00124726f, -0.00900018f, -0.04529260f, -0.00141050f, -0.01517864f, -0.01066926f, 0.00578834f, -0.00672994f, 
    0.01941570f, 0.01115340f, 0.01641831f, -0.01923863f, 0.02848775f, -0.03507039f, -0.02088973f, -0.00248741f, 
    0.00605989f, -0.00642932f, 0.00006908f, 0.02714936f, 0.01173394f, -0.01428461f, 0.00234615f, -0.00708443f, 
    -0.01584510f, -0.01049667f, 0.01112603f, 0.00297688f, 0.02988027f, -0.02458483f, -0.02655637f, -0.00614859f, 
    0.02938639f, -0.00451010f, -0.01765907f, -0.04139575f, 0.01498629f, -0.03881456f, -0.03312046f, 0.00150425f, 
    -0.01481276f, 0.01798181f, -0.01002485f, 0.00836718f, 0.01154354f, 0.02548197f, 0.02312772f, -0.02723861f, 
    0.01037205f, -0.01940805f, -0.02586417f, -0.01685467f, 0.00018456f, 0.00976477f, -0.03240638f, 0.02965954f, 
    -0.01962441f, -0.03410329f, -0.01650150f, -0.02715030f, -0.02430377f, 0.03122391f, -0.01963476f, -0.04131689f, 
    -0.04014182f, -0.02200965f, 0.02347138f, -0.02774806f, -0.04000648f, -0.04123893f, -0.01854772f, -0.01508018f, 
    0.02870180f, 0.01836501f, -0.02709168f, 0.01953851f, -0.00260066f, 0.02187699f, -0.00766659f, 0.01680785f, 
    0.03334345f, -0.01962462f, 0.01114092f, -0.03601334f, -0.04248507f, 0.00993407f, -0.00534229f, -0.01301086f, 
    -0.01906160f, 0.02906431f, -0.01795820f, -0.02120991f, 0.03523063f, -0.03131585f, 0.01595736f, 0.01131986f, 
    0.01208376f, 0.03870607f, 0.02649892f, -0.00737599f, -0.00202133f, 0.00092785f, -0.01283396f, 0.01410426f, 
    0.02483810f, -0.03003480f, -0.00201967f, 0.03142636f, 0.00837748f, -0.03140334f, -0.02003461f, -0.00096663f, 
    0.01723101f, 0.02794875f, -0.03468095f, 0.00606507f, -0.02513037f, -0.01373468f, 0.02195514f, 0.00401842f, 
    0.02689909f, -0.03564349f, 0.01709798f, 0.02593870f, -0.00225577f, -0.00065255f, -0.00078038f, -0.03656896f, 
    -0.04309632f, 0.01602685f, -0.03032191f, -0.01127282f, -0.01998803f, -0.01240487f, 0.00688283f, -0.02351052f, 
    -0.00157810f, -0.01861487f, -0.02975358f, 0.01735013f, -0.00147002f, 0.03302913f, 0.03336184f, -0.00796890f, 
    0.03245315f, 0.02094716f, 0.00768184f, -0.01995726f, 0.02640642f, -0.00939588f, 0.02960344f, -0.02184851f, 
    0.01883102f, -0.02864815f, -0.03689124f, 0.03279299f, -0.02234140f, -0.00276444f, 0.01490144f, -0.01429165f, 
    0.02279713f, -0.04463335f, -0.00438018f, -0.00511246f, -0.02249615f, -0.02188255f, -0.03313273f, -0.02873488f, 
    0.01871890f, -0.01537065f, -0.00367887f, -0.00251067f, -0.02301090f, 0.01172724f, -0.03353268f, 0.01905971f, 
    0.01866994f, -0.01394239f, 0.00056379f, 0.01598252f, 0.02748038f, 0.03330553f, 0.00056858f, -0.03549344f, 
    0.01441966f, 0.02844863f, -0.01695041f, -0.01102127f, -0.03300349f, 0.02292727f, -0.03561065f, 0.00611781f, 
    -0.04333417f, 0.02196142f, -0.03289871f, -0.04290622f, -0.00793717f, 0.01123825f, -0.02221574f, -0.03566592f, 
    0.03218602f, 0.01821310f, 0.03147785f, 0.02280921f, -0.04160457f, 0.00264971f, 0.00721057f, 0.01491647f, 
    0.02919220f, -0.01129056f, -0.02675791f, 0.01375697f, -0.01285957f, -0.04327558f, 0.01229885f, 0.02404128f, 
    0.02397000f, -0.01248873f, 0.02367359f, 0.01509194f, -0.00279321f, 0.00277038f, 0.01205441f, -0.00842614f, 
    0.00403253f, 0.03220845f, -0.03371261f, -0.03177517f, -0.02595480f, -0.03315548f, -0.00896285f, -0.02833767f, 
    0.02089699f, -0.02354992f, 0.02880235f, 0.00399100f, -0.03133471f, -0.01641605f, -0.01594588f, 0.01613469f, 
    0.02356901f, 0.00369907f, -0.01604614f, -0.02544033f, 0.00064905f, -0.03812642f, -0.03139196f, -0.00348939f, 
    0.00064939f, -0.04321251f, -0.02038948f, 0.01382371f, 0.03145406f, 0.03041341f, -0.04194556f, 0.02083717f, 
    -0.01375361f, -0.01352910f, -0.00686383f, 0.02623298f, -0.02351585f, 0.01102003f, 0.02858845f, 0.02973532f, 
    -0.03085889f, -0.02243822f, 0.01561642f, -0.03594398f, -0.01255108f, -0.00976929f, -0.03177945f, 0.01065286f, 
    0.02739040f, 0.03410536f, -0.01498797f, -0.01155190f, -0.02210030f, -0.00122453f, -0.01786075f, -0.01945772f, 
    0.00307476f, -0.02038918f, 0.00335018f, -0.02966061f, 0.03079400f, 0.02713689f, -0.00468442f, 0.00190191f, 
    -0.02538496f, 0.01550644f, 0.00031606f, 0.03031034f, 0.00033893f, -0.04526297f, -0.02979675f, 0.01299524f, 
    -0.00946102f, -0.01862486f, -0.00397151f, -0.03569343f, 0.01309263f, -0.00145148f, -0.03431534f, -0.04162133f, 
    -0.00235680f, -0.00695035f, -0.00430581f, -0.00162030f, -0.02905961f, -0.03473825f, 0.00728292f, 0.01160624f, 
    -0.03983508f, 0.00238037f, -0.02178496f, -0.03595646f, 0.00907982f, -0.00965639f, -0.02356545f, -0.00858495f, 
    0.01497166f, 0.00943274f, -0.04378057f, -0.02147415f, -0.04526137f, -0.03678959f, -0.01538076f, -0.03782653f, 
    -0.02866724f, 0.00695333f, 0.02107169f, -0.03512255f, -0.03322397f, -0.04218767f, -0.01118725f, -0.02503986f, 
    -0.01723984f, 0.00286988f, -0.02831531f, -0.02747795f, -0.03192477f, -0.01032826f, -0.04271316f, 0.02543274f, 
    0.00191319f, 0.02044735f, 0.02351160f, -0.00059059f, -0.02536874f, 0.03135649f, 0.01754586f, 0.00279086f, 
    -0.04138126f, 0.01539791f, 0.00500271f, 0.00366955f, -0.03196242f, 0.00982439f, -0.00918151f, -0.02283944f, 
    -0.01587358f, -0.03716626f, 0.01587333f, 0.03142075f, -0.00837868f, 0.02236360f, -0.03592352f, -0.00029742f, 
    0.03473373f, 0.00931614f, 0.02693621f, -0.01670785f, -0.00381369f, 0.03542835f, -0.04072323f, -0.04417665f, 
    -0.02487385f, -0.00321938f, 0.00013292f, -0.01006929f, -0.01723214f, -0.04095227f, -0.02579825f, 0.03348657f, 
    0.00968203f, 0.01155913f, 0.03254500f, -0.00562739f, -0.01453446f, -0.02818894f, -0.01555547f, -0.03132793f, 
    0.03700180f, 0.02033646f, -0.03356868f, 0.01653018f, 0.00450000f, 0.00449008f, 0.01322733f, -0.01880840f, 
    -0.04273202f, -0.03148792f, -0.00199999f, 0.02548228f, -0.01413973f, -0.00453553f, -0.03789235f, -0.01583202f, 
    0.03912446f, -0.01693769f, -0.03934894f, 0.01807619f, 0.02101596f, 0.00560504f, -0.02946820f, 0.03427374f, 
    0.00477290f, -0.00192691f, 0.00331239f, -0.00407759f, -0.01176605f, 0.02902402f, -0.02478103f, -0.00762338f, 
    0.01246699f, 0.01322287f, -0.00612756f, -0.03151857f, -0.00441999f, -0.00666546f, -0.03960471f, -0.04098259f, 
    -0.03791863f, 0.01019852f, 0.00499531f, -0.01916904f, -0.01671188f, -0.03164858f, 0.00186620f, -0.01980543f, 
    -0.01390603f, 0.02348882f, 0.02535856f, 0.00515000f, 0.02345613f, -0.01431180f, -0.03123852f, -0.03678500f, 
    -0.04898391f, -0.03299378f, -0.18887675f, -0.05674045f, 0.05665492f, 0.12296594f, 0.06122018f, 0.12052462f, 
    0.05857288f, -0.01941061f, -0.15166554f, -0.20133883f, -0.10676511f, 0.05540103f, 0.04549229f, 0.07134508f, 
    0.11155357f, -0.06035286f, 0.05163288f, 0.09011362f, -0.21369776f, 0.24799888f, 0.05766447f, -0.03508575f, 
    0.03524914f, 0.17920725f, 0.07298766f, 0.17719644f, 0.00662131f, -0.17598853f, 0.03561402f, 0.03067069f, 
    -0.07030070f, -0.01617912f, -0.04020521f, -0.00073076f, -0.07936708f, -0.22496253f, -0.07386985f, -0.14043677f, 
    -0.47969615f, -0.05799412f, 0.18675940f, 0.06425832f, -0.16497688f, 0.03878131f, 0.02837363f, -0.13272502f, 
    -0.13360183f, 0.04801156f, -0.11673033f, -0.13962011f, -0.02095275f, 0.02139203f, -0.13095774f, -0.14175984f, 
    -0.14302936f, -0.04073352f, 0.10347795f, -0.17105693f, -0.01176115f, 0.26713422f, -0.06220152f, 0.11689824f, 
    -0.03563839f, -0.05034415f, -0.23138516f, -0.15635417f, -0.07882389f, -0.09741838f, 0.04015921f, -0.04342846f, 
    -0.13913898f, 0.03959533f, -0.00700146f, -0.16651419f, -0.13887735f, 0.00489942f, -0.11779412f, -0.22394726f, 
    0.09898664f, 0.33811539f, 0.14750175f, -0.04590553f, -0.03250464f, 0.02907974f, -0.04802253f, -0.00427667f, 
    -0.02111522f, -0.10118603f, -0.03068789f, 0.04061934f, -0.08805002f, -0.02111462f, -0.04486916f, -0.04968661f, 
    -0.14492163f, 0.03604801f, -0.12024699f, -0.23903774f, -0.10795764f, 0.06176778f, -0.16683970f, 0.00241006f, 
    0.05060404f, 0.05774552f, 0.06589296f, -0.00279487f, -0.04975114f, 0.04047193f, -0.13054025f, 0.08559401f, 
    -0.03363794f, 0.12276157f, 0.01863873f, -0.03102951f, -0.17456566f, 0.25950599f, 0.05451201f, 0.03363720f, 
    -0.29138064f, 0.08174431f, 0.16527756f, 0.02585744f, -0.01876675f, 0.04645110f, -0.04060718f, 0.01948514f, 
    0.13935813f, 0.04991867f, -0.06083644f, 0.02405431f, -0.00825771f, 0.11774436f, -0.02812190f, 0.10664625f, 
    0.07980233f, 0.14784680f, 0.09194743f, 0.06324879f, 0.03498179f, -0.00784416f, -0.23078661f, 0.04596045f, 
    -0.11320499f, -0.09086411f, 0.14013273f, 0.16539894f, -0.11152634f, 0.13652498f, 0.01457116f, 0.02099764f, 
    0.07470815f, 0.09667242f, 0.02236370f, 0.06234838f, 0.00642374f, 0.14708823f, -0.17481698f, -0.00006371f, 
    0.26210317f, -0.03262296f, -0.00829466f, -0.17600866f, -0.13271892f, 0.10815997f, -0.04146114f, -0.03311225f, 
    0.12125466f, -0.02379973f, -0.05428606f, -0.01208295f, 0.04674324f, 0.12690717f, 0.18993989f, 0.09886530f, 
    0.13937610f, 0.06760836f, 0.11955097f, 0.28689003f, -0.09994584f, 0.04646876f, 0.10706357f, 0.12825204f, 
    -0.05947804f, 0.17194386f, 0.07427884f, 0.01599233f, 0.22334327f, -0.09795921f, 0.01771026f, 0.09950918f, 
    -0.04379516f, 0.03370502f, -0.00056405f, 0.07074057f, 0.04667198f, 0.10305963f, -0.05731144f, 0.05295051f, 
    -0.01316779f, -0.08781920f, 0.03735052f, 0.07591049f, -0.07569474f, -0.09774474f, -0.09814183f, -0.09107122f, 
    -0.15954620f, -0.05056608f, -0.07435436f, 0.02724231f, 0.06081436f, 0.06545095f, 0.15574972f, -0.14064391f, 
    0.15915899f, 0.11500461f, 0.05019346f, 0.10052005f, 0.03728110f, 0.18199493f, 0.12693869f, -0.03523064f, 
    0.01242589f, 0.06249335f, -0.02319834f, -0.09271793f, 0.10430822f, -0.00650046f, 0.11440080f, 0.07944390f, 
    0.02706287f, 0.04458853f, 0.03495592f, 0.13899221f, 0.12259965f, -0.05018440f, 0.05593000f, 0.09045837f, 
    -0.09163953f, -0.19281870f, -0.09025405f, -0.09090567f, 0.13757770f, 0.05729339f, -0.00073586f, -0.10470837f, 
    0.09701108f, 0.16585968f, 0.08975364f, -0.05250715f, -0.02142723f, 0.05765349f, 0.02749106f, 0.10057205f, 
    0.28443193f, -0.00872540f, 0.14416964f, 0.27603135f, 0.07381295f, -0.06774842f, -0.18339811f, -0.04341773f, 
    -0.04832250f, 0.02581081f, 0.07660022f, -0.13537177f, 0.09631774f, -0.00450946f, 0.00799882f, -0.06833771f, 
    0.10072954f, 0.05746781f, 0.11278752f, 0.02170465f, 0.17903851f, 0.03142405f, 0.15034632f, 0.37036720f, 
    0.01280315f, -0.05320175f, -0.10130902f, 0.03999798f, -0.08062914f, -0.16147158f, 0.02297596f, -0.20571738f, 
    -0.18933357f, 0.05404599f, 0.09384058f, -0.04313910f, 0.13808952f, 0.01459454f, 0.02815962f, 0.13333388f, 
    0.24741487f, -0.00129933f, 0.14384139f, 0.25861761f, -0.12824361f, 0.00420781f, -0.12499853f, -0.09171107f, 
    -0.02181082f, 0.08965434f, 0.13955341f, 0.04669510f, 0.10151600f, 0.08238733f, 0.13981123f, -0.00570210f, 
    0.01463761f, -0.07086921f, 0.04427753f, 0.06445911f, 0.08485214f, 0.13127686f, -0.01786409f, 0.08739661f, 
    -0.10450199f, -0.02858771f, 0.03059856f, -0.00537471f, 0.07739826f, -0.03238487f, 0.03889787f, 0.12280329f, 
    -0.00878172f, -0.03325744f, -0.06440724f, -0.21856505f, 0.04402526f, 0.02291156f, 0.08429245f, 0.08565196f, 
    0.21840976f, 0.17176896f, 0.08461092f, 0.18918934f, 0.09948340f, 0.09427735f, 0.07123040f, 0.31263646f, 
    0.01951884f, 0.10570401f, 0.24698374f, 0.17727154f, 0.04928937f, 0.27363178f, -0.02885487f, 0.07943314f, 
    0.09502485f, 0.04082507f, -0.00768230f, 0.11966020f, -0.00732206f, 0.18538663f, 0.02941189f, 0.27666393f, 
    -0.05785894f, 0.24495353f, 0.08560190f, -0.11487072f, -0.04392922f, 0.09767647f, -0.02899079f, 0.09017070f, 
    -0.00790567f, 0.01293831f, 0.04319751f, 0.01313797f, -0.13003650f, -0.06732029f, -0.06128386f, 0.12369967f, 
    -0.14371875f, -0.13298959f, 0.03129885f, -0.07743060f, -0.17632823f, -0.32138982f, -0.49141765f, 0.13734256f, 
    0.07995450f, -0.04324288f, -0.06611953f, -0.28345004f, -0.13510668f, -0.12993282f, 0.10780294f, 0.08627082f, 
    -0.03239578f, 0.09585883f, 0.05135843f, 0.01832855f, -0.01558129f, 0.02094898f, -0.18465237f, -0.12698650f, 
    -0.03402355f, 0.20831765f, 0.11567889f, -0.02996593f, -0.00875914f, -0.00143534f, 0.05114848f, 0.08441390f, 
    0.05925983f, -0.12320234f, -0.01558108f, -0.16959986f, -0.08913318f, -0.04205543f, -0.03062676f, -0.05528935f, 
    -0.16032526f, -0.01577893f, 0.02586750f, -0.25816044f, 0.42431614f, 0.12528008f, 0.18027268f, -0.23435588f, 
    0.06663157f, -0.06802955f, -0.21307243f, -0.25019073f, 0.01697863f, 0.12677327f, -0.00380683f, 0.13933446f, 
    0.11320239f, -0.09147834f, 0.04754700f, -0.15673058f, -0.17600183f, 0.15735584f, 0.13494633f, -0.12172741f, 
    -0.33160806f, -0.06965030f, -0.28714144f, 0.02041812f, 0.01120255f, 0.10930653f, 0.08480546f, 0.24010925f, 
    -0.07660416f, 0.14098635f, -0.13250326f, 0.10333475f, 0.03176845f, 0.08607533f, 0.03110857f, 0.03509722f, 
    0.09132436f, 0.20791319f, 0.15940160f, 0.39852375f, -0.55820274f, -0.27459234f, -0.25082305f, 0.01446341f, 
    -0.02561438f, -0.03438373f, -0.06668226f, -0.02824093f, -0.01172778f, -0.08425038f, 0.07915679f, -0.12156880f, 
    0.01723307f, -0.08807388f, -0.00447654f, 0.06985363f, 0.05606412f, 0.19150451f, -0.05451781f, 0.11770309f, 
    0.17964272f, 0.13638139f, -0.01895611f, 0.01056305f, 0.13614768f, 0.10606162f, 0.03102502f, -0.00587152f, 
    0.13844882f, 0.05826145f, 0.01406916f, 0.02784043f, 0.00261711f, -0.05577872f, -0.02315512f, -0.08323389f, 
    -0.04276355f, 0.00017594f, 0.07430992f, -0.06774957f, -0.35451108f, -0.10072957f, 0.11103746f, 0.05947663f, 
    -0.06129917f, -0.04529211f, -0.09622106f, -0.03375065f, -0.06590914f, 0.15337308f, -0.04986463f, 0.19166659f, 
    -0.00804666f, -0.07742104f, 0.03839703f, 0.09307175f, -0.09100002f, 0.15743589f, -0.01476950f, 0.09038029f, 
    -0.27741855f, -0.03579613f, 0.01505101f, -0.14580762f, 0.04830861f, 0.05996968f, -0.07345238f, -0.16493204f, 
    -0.16796564f, 0.02952828f, 0.01693470f, 0.04260840f, -0.02498038f, 0.04600354f, 0.01152187f, -0.04805525f, 
    0.04806294f, 0.05943850f, 0.14353253f, 0.00282899f, 0.19688956f, 0.24539474f, -0.11041163f, -0.01572393f, 
    0.17364840f, 0.08377528f, -0.05578413f, -0.16524093f, 0.04817129f, 0.24817559f, 0.05256315f, 0.25911412f, 
    0.08358523f, -0.05359264f, -0.04476425f, 0.16126020f, 0.01348202f, 0.09477603f, 0.14499423f, 0.20199390f, 
    0.14336929f, -0.03721778f, 0.09601231f, -0.04174644f, 0.05826395f, -0.08969566f, 0.01939213f, -0.12561385f, 
    -0.18843853f, -0.26383516f, 0.13486786f, 0.06227178f, -0.04037689f, -0.14873557f, 0.18139280f, 0.00149743f, 
    -0.04602402f, -0.08772734f, 0.03940949f, -0.10894468f, -0.28147146f, 0.08711752f, -0.16445856f, -0.08168693f, 
    0.15479502f, -0.05057961f, -0.14237244f, -0.22410928f, -0.06073589f, -0.26483351f, 0.00894735f, -0.07529043f, 
    -0.08435296f, 0.04659216f, -0.00579314f, 0.03911540f, -0.03912937f, 0.21015306f, 0.04176202f, -0.07810290f, 
    -0.14175270f, -0.30820644f, -0.35669279f, -0.10165353f, -0.05610951f, -0.04576579f, -0.09576374f, -0.18115005f, 
    -0.13168040f, -0.07029322f, 0.05289571f, 0.23151197f, 0.05433081f, 0.04945723f, -0.06884618f, 0.06052118f, 
    0.00396912f, 0.08995330f, -0.06374623f, 0.05477798f, -0.03694686f, 0.01959694f, 0.09216337f, -0.08120307f, 
    -0.06006508f, 0.09809615f, 0.00518241f, 0.01902064f, -0.01518156f, 0.00930958f, 0.17829670f, 0.08514936f, 
    0.02728333f, 0.05821229f, 0.06110064f, -0.07692408f, -0.10096642f, -0.08809721f, -0.16944942f, -0.41697717f, 
    -0.30307785f, -0.36880791f, 0.12807892f, 0.02966427f, -0.14798754f, -0.07362112f, 0.25522336f, 0.08134580f, 
    0.17923860f, -0.11302290f, -0.04251349f, 0.09435216f, 0.02663504f, -0.03010642f, 0.02380371f, -0.04857905f, 
    0.13675573f, 0.09944381f, 0.00670833f, -0.13201813f, -0.15958443f, -0.40358394f, 0.03572640f, -0.00851168f, 
    -0.24945807f, 0.08150149f, -0.13514721f, -0.25691894f, 0.02918334f, -0.13651840f, 0.05989480f, -0.03910911f, 
    -0.09353559f, 0.04063099f, -0.04095846f, -0.08379678f, 0.00289727f, 0.18390746f, 0.10057393f, 0.04645321f, 
    -0.33083925f, -0.01685514f, -0.27557024f, -0.35606462f, -0.27840233f, -0.04784177f, -0.05308692f, 0.06743050f, 
    -0.10778607f, 0.07633202f, 0.01900070f, -0.05328197f, -0.10327941f, -0.06835879f, -0.03712481f, -0.12334604f, 
    -0.04962815f, -0.02398157f, 0.23075019f, -0.02519300f, -0.10081512f, 0.24701302f, -0.08571838f, 0.10898817f, 
    -0.04929666f, -0.06740315f, -0.01753899f, -0.06150445f, -0.08452110f, -0.00900044f, -0.04238910f, -0.09191893f, 
    0.12945636f, -0.14399888f, -0.11247430f, 0.16208279f, 0.23853490f, -0.07399434f, 0.06403232f, 0.14081216f, 
    0.13394895f, -0.31560352f, 0.23660770f, 0.22182828f, 0.30899557f, 0.02665838f, -0.07730835f, -0.11320030f, 
    0.13445255f, -0.00754928f, 0.13127285f, -0.01952117f, 0.16062757f, -0.00663655f, 0.13722703f, 0.14488950f, 
    0.15547711f, 0.09383307f, 0.08660180f, 0.04926132f, 0.12367511f, 0.02689248f, -0.29375413f, -0.29005104f, 
    -0.03112667f, -0.01755814f, 0.05107020f, 0.00985531f, -0.18523793f, 0.05557282f, 0.14811581f, -0.05544494f, 
    -0.00504083f, -0.00898441f, -0.11680698f, -0.05690251f, 0.05919183f, 0.09201648f, -0.00628049f, 0.22758032f, 
    0.04315194f, 0.02091599f, -0.08654290f, -0.08296724f, 0.06733312f, 0.06159311f, 0.18538861f, 0.00912906f, 
    0.15689710f, 0.11842728f, 0.07960086f, -0.02406837f, 0.05024044f, 0.08051810f, 0.00711111f, 0.08083698f, 
    -0.03582124f, -0.07938657f, 0.24136408f, -0.07643721f, -0.33284721f, 0.01202999f, -0.75850189f, -0.29664886f, 
    -0.04895174f, 0.01484935f, 0.01220138f, 0.04190405f, -0.03133362f, -0.26636696f, 0.09979665f, 0.05324796f, 
    -0.02743425f, -0.07911742f, 0.04166549f, 0.05086152f, -0.00318492f, -0.10651956f, -0.08360130f, -0.00027659f, 
    -0.15833549f, -0.52353770f, -0.20196874f, 0.18112771f, 0.13002552f, -0.02331553f, 0.07097688f, -0.05408838f, 
    0.12558194f, -0.12813890f, -0.01244551f, 0.04286866f, -0.02799224f, -0.04487258f, -0.04522986f, -0.02955356f, 
    0.08799737f, 0.06616870f, 0.09767177f, -0.05590799f, -0.17849624f, -0.31861416f, -0.38098449f, 0.21525265f, 
    -0.28084728f, 0.05470888f, -0.04053720f, 0.02250833f, -0.17494418f, -0.02057809f, -0.00674792f, -0.06493039f, 
    -0.08857598f, -0.05534441f, -0.06109862f, -0.06020645f, -0.06163713f, -0.05018425f, -0.01017910f, 0.10577178f, 
    0.01908247f, -0.05148328f, 0.02793635f, -0.09794548f, -0.08597080f, -0.05844098f, -0.16007392f, -0.15968786f, 
    -0.05638308f, -0.02829706f, 0.05230154f, 0.06111089f, 0.05275156f, 0.00119967f, -0.12359831f, 0.06795636f, 
    -0.02954490f, -0.04491290f, -0.02691155f, 0.04630558f, 0.19038667f, -0.20854780f, 0.16281605f, 0.09775225f, 
    0.28787386f, -0.02032008f, 0.17973100f, -0.11393986f, 0.14173754f, 0.01902269f, 0.17202565f, 0.19499993f, 
    0.11219029f, 0.03835801f, -0.03127612f, 0.18078294f, 0.15617965f, 0.07135635f, 0.04188632f, 0.14251991f, 
    -0.10512958f, 0.35197654f, 0.15969883f, 0.01260325f, 0.09924302f, -0.10551708f, -0.11819945f, -0.08424284f, 
    -0.11759232f, -0.04849763f, 0.02684766f, 0.11454688f, 0.06741650f, 0.18767989f, 0.11277629f, 0.01266215f, 
    -0.11776561f, -0.04238313f, 0.00728535f, -0.06109569f, -0.01158412f, 0.00439320f, -0.11968995f, 0.03884186f, 
    0.16838129f, 0.02033147f, -0.03566346f, -0.02356494f, -0.09801098f, -0.00069066f, 0.29216644f, 0.07242422f, 
    -0.05662268f, 0.04487766f, -0.01458744f, 0.06902529f, 0.00665936f, 0.12821260f, -0.00235464f, -0.00006348f, 
    -0.13301136f, -0.04589175f, -0.06440844f, -0.09790376f, 0.07382390f, -0.07229967f, -0.13653518f, -0.07414345f, 
    0.01911186f, -0.05789036f, -0.07685618f, -0.06434407f, 0.08720242f, 0.12574749f, -0.00855323f, -0.01528385f, 
    -0.03402556f, -0.03357121f, -0.01569411f, -0.02610506f, -0.10983789f, 0.16622892f, 0.38009205f, 0.46456599f, 
    0.02754206f, -0.03120343f, 0.03192703f, -0.09144864f, -0.12384019f, 0.18914233f, 0.15825918f, 0.07432269f, 
    0.21813892f, 0.07968835f, 0.22614811f, 0.01697172f, -0.05862463f, -0.08938587f, -0.04117133f, -0.07557471f, 
    0.03430752f, 0.05924149f, 0.00022578f, -0.09720115f, 0.07740252f, -0.00854588f, -0.08318740f, -0.06189317f, 
    0.16812223f, -0.01509921f, 0.25750190f, 0.11635884f, 0.02436903f, 0.08457129f, 0.03929753f, 0.08102598f, 
    -0.04185281f, 0.02296653f, 0.06916692f, -0.03211674f, -0.12701820f, 0.11528203f, -0.74266559f, 0.04092425f, 
    -0.01468799f, 0.08932556f, -0.03863502f, 0.00536016f, -0.17571592f, -0.00240854f, 0.16617039f, 0.01626866f, 
    0.06537676f, -0.11797518f, 0.05673456f, 0.02779736f, 0.01878736f, -0.04455978f, 0.23324986f, 0.00969513f, 
    0.03443194f, -0.52889538f, 0.42619208f, 0.10314603f, 0.16124578f, -0.03213152f, -0.00115353f, -0.21490960f, 
    0.27059260f, -0.05441411f, 0.12578271f, 0.02345518f, 0.05336866f, 0.06043546f, -0.04886795f, 0.02002233f, 
    0.01990624f, 0.10484342f, -0.03298438f, -0.00569708f, 0.07433943f, 0.16107816f, 0.47935677f, -0.01088994f, 
    0.23899066f, -0.12109718f, -0.15920021f, -0.06138188f, -0.08419906f, -0.14237975f, 0.04095893f, 0.04382245f, 
    0.09172053f, -0.03203036f, 0.15985200f, 0.11829213f, -0.01961273f, -0.08048587f, 0.11121334f, 0.01799472f, 
    0.01827568f, -0.20106854f, 0.24454060f, -0.00167664f, 0.13985164f, 0.12290739f, -0.04700747f, -0.12465049f, 
    0.08913093f, 0.02884676f, 0.04404886f, 0.00205706f, 0.13256417f, -0.04006536f, 0.00316403f, 0.01360028f, 
    0.00414476f, -0.11666613f, 0.07985138f, -0.03051758f, 0.07747404f, -0.09729568f, 0.17625888f, 0.03463448f, 
    0.02043901f, 0.06436571f, 0.02098417f, -0.12017626f, -0.17657147f, -0.02293362f, 0.20070441f, -0.12600845f, 
    0.16845387f, -0.08966316f, 0.09620655f, 0.15993896f, 0.14689524f, -0.04765662f, 0.00319946f, 0.00733789f, 
    -0.04328931f, 0.14218107f, 0.33395472f, -0.24211414f, 0.02064708f, 0.04852653f, -0.23798874f, -0.28191191f, 
    -0.01275718f, -0.23751895f, 0.17114496f, 0.05933237f, 0.20777875f, 0.09657621f, 0.06922249f, -0.01225201f, 
    -0.03518600f, -0.11943655f, -0.10854758f, 0.01431402f, -0.06738520f, -0.11351222f, -0.31494829f, -0.15918404f, 
    0.11492792f, 0.02612480f, 0.13715667f, 0.09461361f, -0.01900467f, 0.04299065f, 0.01869269f, -0.08908480f, 
    -0.16764516f, 0.02246897f, -0.05512319f, -0.00828379f, -0.04395103f, -0.08441129f, -0.02335756f, -0.00720488f, 
    -0.10489197f, 0.14723311f, -0.18313980f, 0.11124723f, 0.08128390f, -0.09712510f, -0.01083646f, 0.04040080f, 
    0.02168398f, 0.16240565f, 0.10946919f, 0.09824497f, 0.10260824f, 0.03427990f, -0.05398139f, -0.04294227f, 
    0.10425528f, -0.01466050f, 0.07115963f, -0.00278127f, 0.00171368f, 0.11066275f, -0.76283723f, -0.05171446f, 
    -0.10888848f, -0.04398127f, 0.39628965f, 0.22118865f, 0.05979745f, 0.14855962f, 0.12873410f, 0.05310791f, 
    0.08796810f, -0.07558498f, 0.05225561f, 0.03925496f, 0.14351547f, -0.12478807f, 0.26164478f, 0.05293711f, 
    0.10302736f, 0.14378011f, 0.11200266f, -0.13174550f, 0.01200084f, 0.04617226f, -0.08020634f, 0.00463580f, 
    -0.05619878f, -0.01021526f, 0.12358736f, 0.06775355f, 0.02598533f, 0.01171792f, 0.06280968f, 0.05576348f, 
    0.06650402f, -0.05462214f, 0.12883596f, -0.05561636f, -0.03695551f, -0.14710723f, 0.19902165f, -0.23073545f, 
    0.27658957f, 0.21205236f, 0.07241422f, 0.14595900f, -0.08659165f, 0.06963303f, 0.25548029f, 0.10851868f, 
    -0.03240981f, 0.19895160f, 0.00902333f, 0.01547329f, -0.00902168f, 0.09638785f, -0.08196004f, -0.11773068f, 
    0.04921138f, 0.30399337f, 0.34646544f, -0.26891366f, -0.00106403f, 0.02529187f, -0.22054297f, -0.07887811f, 
    -0.00331745f, -0.06768370f, -0.00414933f, 0.05499471f, 0.05144279f, 0.07179190f, 0.14619201f, 0.08909719f, 
    0.03122195f, 0.04126512f, -0.02930784f, 0.04503428f, -0.11610218f, 0.14129443f, 0.12351968f, -0.29930735f, 
    -0.03984435f, -0.06666609f, -0.00886923f, -0.05735132f, -0.06532270f, -0.06700856f, 0.02756130f, -0.11526990f, 
    -0.06721570f, -0.11503822f, -0.11529928f, -0.09548153f, 0.02070326f, 0.04016085f, -0.04294802f, -0.02884889f, 
    -0.07551497f, 0.08229740f, 0.62085915f, -0.01656255f, 0.13047171f, -0.12265521f, -0.10715851f, -0.07569338f, 
    -0.16416587f, -0.12605472f, -0.09077098f, -0.10817371f, 0.01851263f, 0.26012269f, 0.26966843f, 0.03094914f, 
    -0.03720386f, 0.00593663f, -0.00984625f, -0.03329865f, -0.11905246f, -0.18775974f, -0.16394918f, 0.04352871f, 
    -0.19705674f, 0.08727501f, 0.20251070f, 0.07847067f, 0.03479841f, -0.17386287f, 0.02451410f, 0.00004360f, 
    -0.02621231f, -0.01305826f, 0.01929672f, -0.01892729f, 0.08854581f, 0.17769727f, 0.05937640f, 0.02494160f, 
    -0.01695633f, -0.02510741f, -0.00209206f, -0.02344003f, 0.01750948f, 0.00575624f, -0.02571695f, 0.00955064f, 
    -0.00305417f, 0.03825788f, 0.02535361f, 0.02234595f, -0.01177454f, -0.02670717f, -0.00769786f, 0.02341459f, 
    -0.00632094f, -0.03099925f, 0.00479689f, -0.04413766f, -0.02413580f, 0.02806712f, -0.00481755f, 0.02583720f, 
    0.01977912f, 0.02795492f, 0.00225103f, 0.01786644f, 0.01089002f, -0.03768573f, -0.02801537f, -0.03574816f, 
    0.01867017f, -0.00062767f, 0.02976055f, -0.00832156f, -0.02722425f, 0.01565082f, -0.01530763f, 0.00921819f, 
    -0.00311872f, 0.00597512f, -0.01279941f, 0.01134344f, -0.02969463f, -0.01283139f, -0.03876911f, -0.01384296f, 
    -0.01120574f, 0.03196992f, -0.01796353f, 0.02884724f, -0.04020694f, 0.02606993f, 0.00063965f, -0.01214818f, 
    0.02880154f, 0.03515569f, -0.02666506f, 0.03646405f, 0.02472604f, 0.01385747f, 0.03012889f, 0.02448317f, 
    0.03687251f, -0.04414865f, -0.01598594f, -0.01977479f, 0.01121056f, 0.01842462f, 0.00727136f, 0.03230670f, 
    -0.04317478f, -0.04362346f, 0.01677393f, 0.00456737f, 0.02127477f, 0.00518192f, 0.01951800f, -0.02632752f, 
    0.00049652f, -0.02168509f, 0.02637680f, -0.00742948f, 0.02074987f, -0.04152252f, -0.01185174f, -0.01714672f, 
    0.00795402f, -0.02367666f, -0.03907553f, -0.03378533f, -0.02811398f, 0.01577863f, -0.00516895f, -0.00536539f, 
    0.01367347f, 0.03037298f, 0.00263099f, -0.01129484f, 0.02122850f, 0.03047174f, -0.02328416f, 0.01239907f, 
    -0.00700373f, 0.01493638f, -0.03181854f, -0.01387257f, 0.00523649f, -0.04330092f, -0.02885724f, -0.02336348f, 
    0.02094278f, 0.03113346f, 0.02690621f, 0.04362560f, 0.03046831f, 0.02138754f, 0.03706915f, -0.00097033f, 
    0.00273384f, 0.02480668f, 0.02590593f, -0.04217994f, -0.02367297f, 0.01006138f, -0.01682973f, 0.00101341f, 
    -0.01825987f, 0.02972681f, -0.02157370f, -0.04046852f, -0.00382172f, -0.04163709f, -0.04275183f, -0.01951859f, 
    -0.03716487f, 0.02423254f, -0.04344391f, -0.00791650f, -0.01017234f, 0.00803840f, 0.02759734f, -0.00644947f, 
    -0.02394363f, -0.00138626f, 0.02750313f, -0.03003173f, 0.03740589f, -0.02198654f, -0.01845390f, 0.01956095f, 
    0.02021840f, 0.01839723f, -0.02506631f, 0.02308330f, -0.02268834f, 0.00556438f, 0.02645306f, -0.02737837f, 
    -0.01141129f, -0.00486610f, 0.00265459f, 0.02473775f, 0.02675368f, -0.02107344f, 0.04498570f, 0.00354416f, 
    -0.01544604f, 0.02993753f, 0.02091687f, -0.04086921f, 0.02317404f, -0.02118950f, 0.03009457f, -0.00385659f, 
    0.00393322f, 0.01559160f, 0.01439632f, 0.03294449f, -0.00989646f, -0.01890839f, -0.00968412f, 0.03166619f, 
    0.01217977f, -0.03123578f, 0.02939833f, 0.00770047f, 0.01582380f, 0.01864394f, 0.02340290f, -0.02857401f, 
    -0.02416777f, -0.01074174f, -0.01217432f, -0.01577500f, -0.02763569f, -0.03640028f, -0.04350893f, -0.03667994f, 
    0.01204984f, 0.03284053f, 0.02152992f, 0.02842435f, -0.02231406f, 0.03705689f, -0.03269644f, -0.02914654f, 
    0.00110172f, 0.00965448f, -0.01428002f, 0.03878283f, -0.01280272f, -0.02474494f, -0.01325250f, 0.02234345f, 
    -0.03675852f, -0.00230406f, 0.01263300f, 0.02106653f, -0.04222277f, -0.02512797f, -0.00478914f, 0.01412534f, 
    0.00444805f, 0.02564766f, -0.03090930f, -0.00308316f, -0.04375842f, -0.01258701f, 0.01400140f, 0.02706811f, 
    0.00702855f, 0.01516900f, -0.03272719f, -0.01431129f, -0.04310989f, 0.00036872f, -0.00680971f, 0.01349225f, 
    -0.03860959f, -0.01021013f, -0.03523332f, -0.01887204f, -0.04449556f, 0.01011492f, -0.00283548f, 0.00699500f, 
    -0.01579202f, -0.02646664f, 0.00960238f, -0.00056364f, -0.03664377f, 0.04122285f, -0.01849690f, -0.04036032f, 
    0.03045170f, 0.01961471f, -0.00286126f, -0.03527159f, 0.02999624f, 0.03265147f, 0.01749497f, -0.00033490f, 
    -0.03568382f, -0.00072288f, -0.00920202f, -0.02888348f, 0.03295041f, -0.04087828f, 0.00303619f, -0.01491888f, 
    -0.03315649f, 0.00858286f, -0.01858526f, -0.03698910f, 0.01385583f, -0.02515873f, -0.03886406f, -0.03739543f, 
    -0.01325724f, 0.00291666f, 0.01816577f, 0.03018577f, 0.04273610f, 0.01237028f, 0.04010873f, -0.02697171f, 
    -0.03247286f, -0.01935801f, -0.00315465f, 0.02036295f, -0.01300728f, -0.02584939f, -0.00654839f, -0.02005937f, 
    0.01343123f, -0.01067479f, 0.00188642f, 0.02790476f, 0.01536058f, -0.03282467f, -0.02111760f, 0.02798248f, 
    -0.00170283f, 0.02341039f, -0.00835634f, -0.02645159f, -0.02153859f, -0.02664037f, 0.04036959f, -0.02915025f, 
    -0.04228832f, 0.02792839f, -0.04524339f, -0.02168805f, -0.02990903f, -0.01745607f, -0.01876871f, -0.03057932f, 
    0.02466329f, -0.00092203f, -0.04134289f, 0.02772074f, -0.00943509f, 0.00576962f, -0.04164848f, -0.04493253f, 
    -0.01006831f, -0.00792114f, 0.02702553f, -0.01492759f, -0.01025203f, -0.02599702f, -0.00017848f, 0.03100177f, 
    -0.04396370f, 0.00752063f, -0.01026837f, -0.00018976f, -0.00406783f, -0.03599520f, 0.01972913f, -0.00002910f, 
    0.00918108f, -0.02763353f, -0.02305672f, -0.03988368f, 0.02611204f, 0.00822629f, 0.00092245f, 0.00663794f, 
    0.03069870f, -0.01618177f, -0.01729311f, 0.00173824f, -0.04201724f, -0.01908650f, 0.02186448f, -0.01143012f, 
    -0.00166975f, 0.02340660f, -0.03557103f, -0.01835382f, -0.00420949f, 0.00883992f, 0.02148827f, -0.03023598f, 
    -0.03098074f, 0.03112712f, -0.01328348f, -0.02015899f, -0.01452604f, -0.03539931f, -0.02429463f, -0.03079701f, 
    -0.02958597f, 0.00576596f, -0.04298835f, 0.02017600f, 0.03168690f, 0.02135906f, 0.02725568f, -0.00902164f, 
    -0.04202997f, -0.00033961f, -0.04306259f, -0.02073030f, 0.01198337f, 0.00007419f, 0.00370489f, -0.00759632f, 
    -0.03894369f, -0.03669554f, 0.03520759f, 0.02825032f, -0.00538420f, -0.00519780f, -0.00765409f, -0.03469606f, 
    -0.01708889f, 0.02733241f, 0.01493238f, -0.00017574f, 0.01398764f, 0.00510157f, 0.01615072f, 0.01083950f, 
    0.01251994f, 0.00816962f, 0.01001664f, -0.04265906f, 0.01308989f, -0.00511240f, 0.00628137f, -0.02653804f, 
    0.02012883f, -0.01182342f, -0.00001697f, -0.00974809f, -0.03130085f, 0.00171043f, -0.01594137f, -0.02710615f, 
    0.02217180f, -0.04552003f, 0.00827085f, -0.03935794f, 0.00318457f, -0.02453896f, 0.00083601f, -0.00153109f, 
    -0.02807332f, -0.04330640f, 0.00445776f, 0.01495515f, 0.02069502f, 0.01985757f, -0.04517525f, 0.01335467f, 
    0.00458531f, 0.04268813f, -0.00261096f, 0.02470158f, -0.02518166f, 0.02992084f, 0.01648213f, 0.01817394f, 
    0.02823193f, 0.02300775f, 0.00466889f, 0.00000147f, -0.01984259f, 0.01764498f, -0.01340985f, -0.03124359f, 
    -0.00883755f, -0.00791967f, 0.00535841f, -0.00626113f, -0.00595152f, -0.04358980f, 0.00859850f, -0.02695803f, 
    0.01049111f, -0.04421369f, -0.02797661f, 0.02975381f, 0.02899216f, -0.00668488f, -0.03474351f, -0.01048224f, 
    0.00457124f, 0.00860648f, -0.03482318f, -0.01441053f, -0.02390935f, 0.01524032f, -0.04285876f, -0.02489741f, 
    0.03331501f, -0.01419888f, 0.01283811f, -0.02303669f, 0.00063263f, 0.01901866f, 0.01847537f, 0.01439775f, 
    -0.00145521f, 0.00636654f, 0.00094622f, -0.01565444f, 0.00974278f, -0.01816338f, -0.00709937f, 0.03298975f, 
    -0.00779509f, -0.02433003f, -0.03684469f, 0.00469673f, 0.04163608f, -0.02781978f, -0.02890628f, -0.00919121f, 
    -0.01290252f, 0.02867122f, 0.02046254f, 0.00203299f, -0.00920998f, 0.00765322f, -0.02040445f, -0.03910694f, 
    -0.04160091f, -0.04365381f, 0.02524465f, -0.02277742f, -0.01451434f, 0.01597117f, 0.03626215f, 0.00840519f, 
    -0.02208500f, -0.02023005f, -0.01985891f, -0.02517770f, -0.02299963f, -0.02765948f, 0.02221507f, 0.04174940f, 
    0.00055958f, -0.04190411f, -0.03047783f, 0.03500112f, -0.04503565f, -0.03109912f, -0.03067077f, -0.01485150f, 
    0.03323349f, 0.00935826f, 0.00964177f, 0.00617125f, -0.03787986f, 0.01401421f, 0.01817823f, -0.01561239f, 
    0.02008313f, 0.02202065f, -0.00032681f, -0.02759367f, -0.02891303f, -0.02813875f, -0.03445021f, 0.03069670f, 
    0.01769290f, 0.03255666f, -0.00937869f, -0.03706670f, -0.01368940f, 0.00119894f, -0.02734937f, -0.04153881f, 
    0.02437137f, 0.02278175f, -0.00232878f, 0.03211974f, 0.02353676f, -0.04327497f, 0.01973480f, -0.01360269f, 
    -0.04206823f, -0.03111847f, -0.00550226f, -0.01293045f, 0.02029037f, -0.03764026f, 0.02030352f, 0.00875120f, 
    0.02183493f, -0.00183011f, -0.00280746f, -0.03079922f, -0.01272209f, 0.02229280f, 0.03038259f, 0.01988599f, 
    -0.01018274f, -0.01282633f, 0.00050461f, -0.02868453f, -0.00212466f, 0.00178709f, -0.02517631f, -0.00881359f, 
    0.01101846f, 0.02795555f, -0.03513597f, 0.04290847f, 0.01324059f, 0.03080249f, -0.02628116f, -0.00875650f, 
    0.02456485f, 0.00978339f, 0.00481806f, -0.00340121f, -0.00777611f, 0.01924693f, 0.01807838f, -0.03297162f, 
    -0.03400045f, 0.02233831f, 0.02765929f, -0.02753419f, 0.03849959f, -0.00781620f, -0.01329009f, -0.04436839f, 
    0.02453372f, -0.00693837f, 0.01988069f, 0.03190709f, 0.00831850f, 0.01105621f, 0.00665460f, -0.00074865f, 
    0.00049979f, 0.02313836f, -0.02639161f, -0.04083457f, -0.03214288f, 0.01262705f, 0.02870566f, -0.00973580f, 
    0.01365906f, 0.02018667f, -0.04504668f, -0.02291066f, -0.00345192f, -0.00116420f, 0.03518770f, 0.04500634f, 
    0.24718411f, -0.13127312f, 0.45077863f, 0.08468310f, 0.05602049f, -0.00863077f, 0.03243973f, 0.07882852f, 
    0.00856161f, -0.01103834f, 0.13475475f, 0.12850511f, 0.02984655f, -0.07511411f, -0.09288990f, -0.00786854f, 
    -0.07712078f, 0.05839365f, 0.08080364f, -0.16913995f, 0.04182374f, -0.39999115f, 0.41597164f, -0.10869400f, 
    -0.08915582f, -0.08848535f, 0.02000288f, -0.13187918f, 0.21950984f, 0.13080814f, 0.05338498f, -0.13026054f, 
    0.02395100f, 0.16064686f, 0.00990565f, 0.18304698f, 0.18193522f, 0.17347042f, 0.25898588f, 0.15428229f, 
    -0.00028476f, 0.06971760f, -0.24687615f, 0.17919472f, 0.04876905f, 0.00255169f, -0.27162299f, -0.05977402f, 
    0.01895305f, 0.04215109f, 0.09058127f, 0.01268094f, -0.17216624f, -0.06559499f, -0.01405180f, 0.06676923f, 
    -0.05801744f, 0.10910905f, 0.04246667f, 0.03280865f, 0.03632802f, 0.08125149f, -0.22667561f, 0.05733868f, 
    -0.23210415f, 0.02857652f, -0.04261607f, -0.04613124f, -0.04634808f, -0.09431938f, -0.14363709f, 0.07454769f, 
    0.13837472f, -0.02905890f, 0.14067273f, -0.07076356f, 0.20816404f, 0.10898224f, 0.12991908f, 0.36932701f, 
    -0.19170059f, -0.21762003f, -0.02463927f, 0.10770420f, 0.05853593f, -0.05848436f, 0.03092933f, 0.01694780f, 
    0.02466122f, 0.03047676f, -0.03141433f, 0.01825212f, 0.12781154f, 0.04047612f, 0.17278160f, 0.06421835f, 
    0.23601416f, 0.02295920f, 0.24583666f, 0.16783692f, 0.12379292f, -0.23435195f, 0.17384133f, 0.11320684f, 
    -0.20413907f, -0.08899861f, -0.12927169f, -0.06270815f, -0.29194924f, -0.05801226f, 0.18785501f, -0.02378746f, 
    -0.11599250f, -0.04817335f, -0.08208060f, 0.03476938f, 0.17442305f, -0.08839294f, -0.04514175f, 0.03535253f, 
    -0.06929944f, 0.17072600f, -0.15001732f, 0.13690370f, 0.04144388f, 0.03173760f, 0.00260580f, -0.00187116f, 
    -0.07039136f, 0.15425685f, 0.04632314f, -0.03428825f, -0.04705153f, 0.09723124f, 0.04089675f, 0.19534960f, 
    -0.13825710f, -0.05692624f, 0.01377861f, 0.01551738f, 0.15361381f, 0.29653549f, 0.04200783f, 0.10967738f, 
    0.23269522f, 0.05722681f, 0.09832743f, -0.20039283f, 0.09225860f, -0.05587407f, 0.09008991f, 0.10239633f, 
    0.01096404f, -0.20847264f, 0.05851566f, 0.10811977f, 0.09645186f, 0.05407988f, 0.00581694f, 0.10516015f, 
    0.09110858f, -0.32374150f, 0.26486489f, 0.28452998f, -0.02882633f, -0.00757652f, 0.06648664f, 0.02934481f, 
    -0.08696124f, 0.01743226f, 0.13737662f, 0.02796541f, -0.11013367f, -0.16034786f, -0.16840333f, -0.11090034f, 
    -0.18738090f, -0.08565555f, -0.17271425f, -0.30586517f, 0.28498006f, -0.11915711f, -0.00840627f, 0.06321483f, 
    -0.11229321f, 0.17102545f, -0.00549886f, 0.08120562f, 0.02394912f, 0.11931828f, 0.08319366f, -0.16495410f, 
    -0.06462356f, 0.09641011f, 0.07121688f, 0.03481520f, -0.03050895f, -0.00448077f, 0.09763373f, 0.11468843f, 
    -0.02397501f, 0.13821812f, -0.11018215f, -0.21104869f, 0.06427182f, 0.04198092f, 0.01169291f, -0.15725152f, 
    -0.05625509f, -0.03516132f, -0.01236217f, -0.05198332f, -0.02458272f, 0.08245635f, 0.06780513f, 0.10447656f, 
    -0.02491108f, -0.25194392f, -0.19672272f, -0.19434218f, -0.13548140f, -0.00973579f, -0.10294639f, -0.00662880f, 
    0.08338945f, -0.04908749f, 0.07295911f, -0.04837415f, 0.00842039f, -0.04633712f, -0.07038748f, 0.09657688f, 
    -0.01507213f, 0.08275776f, 0.10439934f, 0.12537704f, 0.04051789f, 0.00617423f, 0.19531980f, 0.08406628f, 
    0.07808293f, 0.22643960f, -0.07513568f, 0.17204744f, 0.28646222f, -0.01301404f, -0.19259885f, 0.10047140f, 
    -0.03205656f, -0.14232896f, -0.17534047f, 0.14666688f, 0.07167289f, 0.02831610f, 0.04381860f, -0.17796369f, 
    -0.26915693f, 0.00948890f, -0.28463468f, -0.26631430f, -0.10090206f, -0.10392482f, 0.45560119f, 0.03903641f, 
    0.06026293f, -0.07052886f, 0.05340358f, 0.07807824f, -0.10340195f, -0.06363036f, 0.00984722f, 0.09202383f, 
    -0.07051887f, -0.11425648f, -0.01394933f, -0.01239518f, -0.12886639f, 0.04239246f, -0.32654685f, -0.30928272f, 
    0.02379700f, 0.03314320f, 0.10324688f, -0.21608910f, 0.16529627f, 0.02924975f, -0.18654339f, -0.04046813f, 
    0.08333291f, -0.09792256f, 0.13267142f, -0.18973464f, -0.00025530f, -0.02162538f, -0.14133608f, 0.22843453f, 
    -0.38103896f, -0.25650984f, -0.27818045f, -0.42170557f, 0.21327488f, 0.39805943f, 0.09205799f, 0.52205217f, 
    0.18837279f, 0.08260307f, -0.11109647f, -0.02737694f, 0.14890863f, -0.08097287f, 0.02598431f, -0.00437997f, 
    -0.04082492f, 0.14950684f, -0.00929731f, -0.10222358f, -0.03917242f, -0.04166450f, -0.15618750f, -0.02358824f, 
    0.18341516f, 0.09051674f, 0.16566126f, 0.02113116f, 0.22572096f, -0.05074020f, -0.05261803f, -0.13481089f, 
    -0.02543504f, 0.10166848f, 0.04397411f, 0.21764699f, 0.01800360f, -0.03888047f, -0.01547986f, 0.07465429f, 
    -0.15424295f, -0.13572675f, -0.08527908f, -0.24760740f, 0.13992134f, 0.39958644f, -0.28166160f, 0.15114801f, 
    -0.09835666f, 0.15688552f, -0.12850748f, -0.06769751f, -0.05810426f, -0.02849549f, 0.04699459f, -0.00457329f, 
    -0.02807865f, -0.13134424f, 0.06341092f, 0.09007359f, 0.10747410f, -0.04703586f, 0.08893218f, 0.03925766f, 
    -0.05378414f, -0.26394153f, 0.30876303f, 0.18411593f, 0.10653045f, -0.09853974f, 0.02151085f, -0.02724356f, 
    0.10569879f, 0.05211266f, -0.03012512f, -0.00946312f, 0.04344876f, 0.26328877f, 0.10244471f, -0.00818888f, 
    0.08349948f, 0.14768320f, 0.15441598f, 0.13991287f, 0.10427255f, 0.33678737f, 0.16526793f, -0.11106354f, 
    0.03895564f, -0.01234659f, -0.02238831f, -0.00999421f, -0.01380869f, -0.01961865f, -0.08984131f, 0.01613681f, 
    0.16064601f, -0.01201109f, 0.05985358f, -0.20374116f, -0.15222931f, -0.04296364f, 0.20170422f, 0.05352869f, 
    0.07455403f, -0.00234270f, 0.05991096f, 0.19030604f, 0.11644822f, 0.11416736f, -0.06104151f, -0.01982414f, 
    -0.00660645f, 0.04175205f, -0.08145051f, 0.02151277f, 0.18406293f, 0.16556488f, 0.17429180f, 0.02926084f, 
    0.20023347f, 0.03515107f, 0.04995823f, 0.28747579f, -0.50559354f, -0.13369146f, 0.03938241f, -0.03423612f, 
    0.04749244f, 0.05719038f, 0.08760055f, 0.21717563f, -0.17925011f, -0.19222441f, 0.04166817f, -0.01962118f, 
    -0.10000116f, 0.01186060f, 0.12080713f, 0.23822199f, 0.14164123f, -0.06067497f, 0.18468763f, 0.04223021f, 
    0.23051645f, -0.01048762f, 0.54221356f, -0.15686755f, -0.04071281f, -0.16217491f, -0.00651703f, -0.17385946f, 
    0.02767905f, 0.02929817f, 0.20448609f, -0.17344730f, 0.15097965f, -0.15861659f, -0.04791750f, -0.02409258f, 
    -0.23383886f, -0.25323302f, -0.05265898f, -0.39943895f, -0.13261707f, 0.13352624f, 0.22761628f, -0.01564983f, 
    -0.01899162f, 0.01651588f, 0.07138359f, -0.19918923f, -0.13729540f, 0.06146990f, 0.01880865f, -0.09652979f, 
    -0.03176188f, -0.12978488f, -0.11161128f, -0.03570982f, 0.05820606f, -0.03454836f, -0.26014724f, -0.18432340f, 
    0.03416598f, -0.17706209f, 0.21067263f, 0.04477647f, -0.12880136f, -0.02380591f, 0.08438301f, 0.07461395f, 
    0.02280249f, 0.03244754f, -0.02859433f, 0.01727117f, 0.16631341f, -0.05279084f, 0.11698468f, 0.05359066f, 
    0.00764562f, 0.02234461f, 0.08761114f, 0.14999615f, 0.15659386f, 0.17106655f, -0.25847930f, 0.40122014f, 
    -0.14474143f, 0.02674186f, -0.02071371f, -0.07703469f, -0.09458693f, 0.10477062f, 0.09230778f, 0.02235361f, 
    -0.08285265f, -0.03564966f, -0.01884932f, 0.01453563f, 0.10930877f, 0.00334432f, 0.01168449f, 0.12218640f, 
    -0.16625185f, 0.06861579f, -0.07926585f, -0.11538304f, 0.04761818f, 0.03718593f, 0.00135007f, 0.10624385f, 
    -0.13465272f, -0.02817718f, -0.06641265f, 0.08664443f, 0.00342276f, 0.09534290f, 0.13358210f, -0.00468895f, 
    -0.16458268f, -0.08914152f, -0.02598473f, -0.34011960f, -0.14788727f, -0.12991704f, 0.36880618f, -0.16991296f, 
    0.10851786f, -0.06003441f, 0.06779359f, 0.25639898f, -0.03846589f, 0.06468622f, -0.10641282f, -0.01377535f, 
    -0.15755950f, -0.08502701f, 0.18061833f, -0.00835955f, -0.00713868f, 0.05916626f, 0.11552127f, -0.08117161f, 
    -0.35839829f, 0.07764327f, 0.05104221f, -0.32164621f, -0.05121692f, 0.02568408f, 0.02777162f, 0.02247502f, 
    -0.00269017f, 0.05962727f, -0.01366541f, 0.00421884f, 0.11741254f, 0.10496008f, 0.16920918f, 0.01678924f, 
    -0.01323404f, -0.01270849f, 0.05755869f, -0.03386053f, -0.13308166f, -0.06594537f, 0.14802365f, -0.18185833f, 
    -0.09124222f, -0.18982404f, -0.04338779f, 0.02050478f, -0.16405503f, -0.00708136f, 0.06501625f, -0.04884730f, 
    0.07287669f, -0.05939683f, 0.02851758f, -0.02976851f, 0.00595624f, 0.05879502f, 0.01181859f, -0.18087803f, 
    0.09548979f, 0.21382919f, 0.35431248f, 0.07241098f, 0.31359333f, 0.04340040f, -0.13736165f, -0.05275832f, 
    0.01247163f, -0.16094863f, -0.01433821f, -0.09424577f, 0.06576941f, 0.02432518f, 0.08489640f, -0.17016551f, 
    -0.34944293f, -0.02959371f, -0.09999634f, -0.16362052f, 0.18649444f, -0.06044759f, 0.28255790f, 0.22083661f, 
    0.19314897f, 0.08264352f, 0.12110002f, -0.04327407f, 0.21382375f, 0.14605561f, 0.02192362f, -0.00919889f, 
    0.00826907f, -0.07352882f, -0.06837977f, 0.11947121f, 0.26764679f, 0.18919523f, 0.23113407f, 0.34240982f, 
    -0.03721426f, 0.04480296f, -0.35130185f, 0.07057945f, 0.20244983f, -0.03204806f, 0.06500672f, -0.09687716f, 
    0.07777486f, 0.03264397f, -0.14653702f, 0.05912878f, 0.00544448f, 0.11361896f, 0.01990408f, 0.09390280f, 
    -0.00700539f, 0.03978642f, -0.11748952f, 0.04702619f, -0.03833571f, -0.14221349f, -0.08880345f, 0.40441075f, 
    0.06262251f, -0.16107450f, -0.05064436f, 0.05123623f, 0.12677555f, -0.14924072f, -0.08629424f, 0.13410294f, 
    -0.04872062f, -0.07666362f, 0.01323108f, -0.02458725f, 0.12660450f, 0.09268694f, 0.01725519f, 0.09598830f, 
    0.05396199f, -0.29651988f, 0.24244063f, -0.18297374f, -0.12797536f, -0.04658689f, -0.08704216f, -0.04603422f, 
    0.08054710f, 0.04025401f, 0.01447456f, 0.01915077f, -0.01407296f, 0.03065252f, 0.03884497f, 0.07109254f, 
    -0.02027187f, -0.07746430f, 0.01491371f, 0.12736681f, 0.20482977f, -0.48580050f, -0.05735612f, -0.18446967f, 
    0.03267505f, -0.00638205f, 0.02332422f, 0.08105292f, -0.03017004f, -0.00246622f, 0.13231018f, -0.12368793f, 
    -0.07044227f, 0.08383362f, -0.05653085f, 0.01816574f, 0.09055974f, 0.05564051f, -0.16920434f, 0.06433477f, 
    0.09247408f, -0.07200629f, 0.44031030f, 0.18753064f, 0.15443021f, 0.11108050f, 0.00038171f, -0.04007267f, 
    -0.12394300f, -0.03993222f, 0.06063164f, 0.02369654f, -0.03781769f, -0.15376875f, 0.03295957f, 0.10043833f, 
    0.06422979f, 0.05946746f, -0.10272595f, 0.15297841f, -0.37090918f, 0.16037229f, 0.10568001f, 0.17082205f, 
    -0.25947621f, 0.06870794f, -0.02525736f, 0.07514823f, 0.13599487f, 0.10774371f, -0.05249830f, 0.07902360f, 
    -0.08199349f, 0.07984744f, -0.06518289f, -0.02374068f, 0.05734168f, -0.03111824f, -0.00653535f, -0.03821864f, 
    0.15330887f, -0.12458112f, 0.30776536f, -0.24812824f, -0.03006103f, -0.02424508f, -0.03931463f, 0.05210585f, 
    -0.02931045f, 0.03663229f, 0.04951579f, -0.09805702f, 0.03621414f, -0.02798352f, 0.08750053f, -0.03826195f, 
    0.01406929f, -0.15767059f, 0.01950518f, 0.06446511f, -0.67766601f, -0.72745699f, 0.23067455f, 0.06416070f, 
    -0.06485534f, -0.03801849f, 0.04500340f, -0.04227288f, -0.26327434f, -0.17025004f, -0.08479983f, -0.04489197f, 
    0.04511170f, 0.01358048f, -0.00903075f, -0.11252864f, -0.04514353f, -0.14825530f, -0.14363779f, 0.06034584f, 
    -0.22756392f, 0.09368932f, -0.05828804f, 0.03321794f, 0.07735968f, 0.06620853f, -0.01314345f, 0.07457302f, 
    0.09078050f, 0.13479945f, -0.07046340f, 0.05365244f, -0.02188911f, 0.11560799f, -0.02730392f, 0.01736704f, 
    -0.10548949f, 0.05433897f, -0.18341194f, -0.04962052f, -0.25754288f, -0.00338773f, -0.14596362f, 0.29502672f, 
    0.11557549f, -0.43603161f, -0.11684842f, -0.09965946f, 0.07752430f, -0.05295368f, -0.06884649f, 0.00904133f, 
    0.07954635f, -0.05486285f, 0.02093982f, 0.01496718f, 0.04865437f, -0.00134340f, -0.31394476f, -0.03382467f, 
    -0.06452629f, -0.11016009f, -0.07963005f, -0.09471899f, -0.01193965f, -0.01148274f, -0.12299456f, 0.21504097f, 
    0.06828317f, 0.12317243f, 0.03139916f, 0.08345754f, 0.06023477f, 0.00370758f, 0.15556899f, 0.07106967f, 
    0.01112822f, 0.13555275f, 0.09056167f, 0.02856942f, 0.18718733f, 0.03886550f, 0.27645701f, 0.00982821f, 
    0.10839773f, 0.11775822f, -0.14639933f, 0.11092523f, 0.12912421f, -0.18334402f, -0.01056233f, 0.02801612f, 
    0.12123103f, -0.02065001f, -0.06767966f, -0.06698206f, -0.11395592f, -0.03014522f, -0.02311185f, -0.13516669f, 
    0.02020091f, -0.02591845f, 0.09038088f, 0.02516158f, 0.10086571f, -0.04985088f, 0.08035681f, 0.11576045f, 
    0.02367815f, -0.08428077f, 0.14519678f, -0.01860786f, -0.01389644f, -0.17919300f, 0.07901035f, -0.02814298f, 
    -0.05327605f, 0.04917981f, 0.06591559f, 0.01501160f, -0.27158418f, 0.08180790f, -0.03220071f, -0.05134858f, 
    -0.09568547f, 0.20220594f, -0.12703896f, -0.20489599f, 0.02316384f, 0.05926757f, -0.07567749f, 0.08702330f, 
    0.03192943f, 0.13813496f, 0.07236598f, -0.05959884f, 0.00745862f, 0.04642250f, 0.09700236f, -0.00965937f, 
    -0.04122471f, -0.09273195f, -0.04765866f, 0.13840516f, 0.01529935f, 0.12646189f, -0.09960973f, 0.06496645f, 
    0.10188375f, 0.05475657f, -0.24234621f, 0.08362056f, -0.18457977f, 0.15818815f, 0.02227036f, 0.07249755f, 
    -0.10378038f, 0.09403242f, 0.09336558f, 0.00740070f, 0.61021560f, -0.03624031f, 0.02579514f, -0.10676722f, 
    0.33988798f, -0.13692187f, -0.00530065f, 0.04783402f, -0.03897164f, -0.05298977f, -0.12467407f, 0.03912550f, 
    -0.05824305f, 0.06990176f, -0.16144091f, 0.02569512f, 0.03095378f, 0.01687242f, -0.02375192f, 0.11897913f, 
    -0.16666701f, -0.28344783f, 0.17790519f, -0.04218293f, -0.03282532f, 0.14656150f, -0.11634688f, -0.14455186f, 
    -0.10459073f, 0.03273613f, 0.01004817f, 0.02695683f, 0.04648084f, -0.09001238f, -0.04780863f, -0.08176792f, 
    -0.04765452f, -0.00984581f, 0.09697003f, 0.10643637f, 0.25411212f, -0.19756567f, -0.05128399f, -0.00463727f, 
    0.17009154f, -0.10637296f, -0.08778414f, 0.14573146f, 0.01980324f, -0.09940106f, -0.05383021f, 0.01140894f, 
    -0.00184209f, -0.08241484f, 0.06910121f, -0.09786788f, -0.17230023f, 0.02262291f, -0.06606438f, -0.02548399f, 
    0.02202610f, 0.13669686f, 0.56362343f, 0.34538367f, 0.27308536f, 0.05425994f, -0.09172631f, -0.02312888f, 
    0.15245177f, -0.15355484f, -0.03598484f, 0.03392587f, 0.05736600f, -0.18297915f, -0.04171035f, 0.07646506f, 
    0.02107336f, 0.10925726f, 0.05490413f, -0.03644652f, 0.08455892f, -0.20585123f, 0.24793723f, 0.12496242f, 
    0.12731242f, -0.05804845f, -0.04388132f, 0.10554828f, 0.10185529f, -0.04933644f, 0.08177744f, 0.00323198f, 
    -0.16234216f, 0.02806948f, 0.14182575f, -0.02541944f, -0.04653695f, 0.02590301f, -0.01055406f, -0.01628291f, 
    -0.04898191f, 0.06017023f, 0.28866380f, 0.04263292f, 0.21120016f, -0.01072692f, 0.00259989f, -0.06117316f, 
    0.01141882f, 0.12754452f, -0.03479428f, 0.03976178f, 0.00542222f, -0.17016238f, 0.05900692f, 0.06799499f, 
    0.04882956f, -0.02347393f, -0.09947505f, 0.16696113f, -0.29381192f, 0.52074552f, 0.06228739f, 0.07871743f, 
    -0.29646683f, 0.12374734f, -0.11442380f, -0.12600718f, 0.15104756f, 0.11676996f, -0.27168572f, 0.09067564f, 
    -0.18456721f, 0.04960953f, -0.05364841f, -0.02416158f, -0.01664227f, -0.12233888f, 0.09477670f, -0.02681756f, 
    0.11256123f, -0.15585518f, 0.03243942f, 0.37005943f, 0.05213720f, 0.00658521f, -0.10530993f, -0.06358235f, 
    0.19633870f, -0.14808466f, -0.06259006f, 0.18707611f, -0.02432850f, 0.09033682f, -0.05321279f, 0.02555068f, 
    -0.01865134f, 0.06896680f, 0.09914074f, 0.02793142f, -0.41225779f, -0.02851850f, 0.33464473f, -0.17931418f, 
    -0.08970325f, -0.11186448f, -0.19853908f, -0.10883231f, -0.07442370f, 0.05084254f, 0.00144281f, 0.02058993f, 
    0.05798644f, 0.01099738f, 0.07461544f, -0.01677770f, -0.07924025f, -0.06010976f, 0.15244694f, 0.00671572f, 
    -0.25980866f, 0.39056224f, 0.06561273f, 0.13975675f, 0.27209696f, -0.05243783f, -0.02009764f, -0.02858767f, 
    -0.13957818f, 0.07559852f, 0.03343523f, 0.07146199f, -0.00911505f, -0.13244659f, 0.04727119f, 0.07179806f, 
    0.02434360f, -0.12955759f, -0.03494104f, -0.03540850f, -0.03935475f, -0.42261070f, 0.34859961f, -0.20521487f, 
    0.00466997f, -0.01799655f, 0.18604285f, 0.21175811f, 0.00143052f, 0.03182497f, 0.06856981f, -0.07181710f, 
    0.01426687f, 0.07735524f, -0.05957269f, 0.05703270f, -0.11720800f, 0.08892629f, -0.18801226f, -0.23289579f, 
    0.06369670f, -0.09869345f, 0.12297601f, -0.04240322f, -0.05937381f, -0.10653570f, -0.09944729f, -0.01080746f, 
    0.08240923f, 0.01334025f, 0.13095477f, -0.01344511f, 0.05363365f, 0.10366607f, 0.10724991f, 0.04853437f, 
    0.05492556f, -0.05536720f, 0.10632564f, 0.06980201f, -0.11949923f, 0.15713766f, 0.38819441f, 0.19588676f, 
    -0.24023050f, 0.04016018f, -0.02786568f, 0.11285721f, 0.08572473f, -0.03229702f, -0.07056618f, -0.19991738f, 
    0.28009570f, -0.21990526f, 0.01931992f, -0.10376203f, -0.02857620f, -0.05992845f, 0.21093133f, -0.23660611f, 
    -0.08245033f, 0.02377201f, 0.01387449f, 0.20217763f, -0.15905483f, 0.03836615f, -0.04433002f, 0.06625514f, 
    -0.08089248f, 0.04229624f, -0.04967173f, 0.08259656f, -0.01782904f, 0.19262990f, 0.04349850f, 0.03466164f, 
    0.02849050f, 0.10613732f, 0.20684627f, 0.04189739f, -0.03122331f, -0.14325148f, -0.14663893f, 0.08932740f, 
    -0.09311744f, -0.00642154f, -0.07632715f, 0.06979863f, 0.04826812f, 0.04960181f, -0.07507072f, 0.12472092f, 
    -0.16531646f, 0.12496308f, -0.02548518f, 0.03979212f, 0.03274802f, 0.03725827f, 0.14047608f, 0.09599846f, 
    0.08870088f, -0.14599995f, 0.26609382f, 0.09445942f, 0.12137780f, -0.05393765f, -0.04660375f, 0.11640885f, 
    0.21176693f, -0.02931949f, 0.08999503f, 0.08243594f, -0.12110802f, -0.17867373f, -0.00300380f, -0.00980175f, 
    -0.03003725f, 0.01548339f, 0.06743442f, -0.00571917f, -0.22030561f, -0.26249906f, 0.01290799f, -0.05829939f, 
    -0.03186571f, 0.01684258f, 0.05536173f, 0.04653246f, -0.00464206f, 0.15813529f, -0.02791483f, 0.01445281f, 
    -0.06818057f, -0.01436069f, 0.06026808f, 0.00960836f, 0.04072351f, 0.00220318f, -0.04540002f, 0.20415072f, 
    0.02111094f, 0.03526050f, 0.01648294f, -0.00028484f, 0.02431595f, -0.00497364f, -0.03992637f, 0.03540498f, 
    0.01451966f, 0.01796308f, -0.00556444f, -0.01438963f, -0.02528836f, 0.02985233f, 0.02469938f, -0.03679373f, 
    0.02327115f, -0.02397686f, -0.04135063f, -0.04166372f, 0.02187404f, 0.03540012f, 0.00729373f, 0.02184623f, 
    -0.02793784f, 0.02234267f, -0.02704295f, 0.00406284f, 0.01385141f, 0.02320185f, -0.00708323f, 0.01271240f, 
    -0.03438168f, 0.00570685f, 0.02698815f, -0.02977542f, 0.03481155f, -0.01480819f, -0.00282137f, -0.03554555f, 
    0.00051416f, -0.00096646f, 0.03385757f, -0.00282076f, 0.01076224f, -0.01812272f, -0.04004704f, 0.00602927f, 
    -0.01053775f, -0.01658629f, 0.01954793f, 0.03382346f, 0.03083777f, 0.02453286f, 0.03517785f, 0.00539048f, 
    -0.00021129f, -0.02466895f, 0.01024453f, -0.02288201f, 0.01647814f, -0.01852597f, -0.02761727f, -0.00480528f, 
    -0.02690329f, 0.01969545f, -0.03587808f, -0.03200237f, 0.01808413f, -0.00508436f, -0.02363395f, -0.02939815f, 
    -0.02809746f, 0.02178027f, 0.01760754f, -0.00925421f, 0.01114162f, 0.03380042f, 0.02625336f, 0.00761924f, 
    -0.03652427f, 0.03767906f, 0.01011510f, 0.00077775f, -0.00287136f, -0.03354103f, -0.02129199f, -0.03200728f, 
    0.02347632f, 0.01776230f, -0.03958472f, 0.02094270f, 0.01832480f, 0.02029395f, 0.03098641f, -0.01755811f, 
    0.02465947f, -0.01257249f, 0.00470804f, -0.02296455f, 0.00398704f, -0.00360988f, 0.02020256f, -0.00016808f, 
    0.00609080f, 0.01304064f, -0.04371437f, -0.00345806f, -0.04472351f, -0.02529739f, -0.02528280f, -0.03873079f, 
    -0.03080222f, -0.01521697f, 0.01107516f, -0.01110672f, 0.01090373f, 0.01599707f, 0.00918039f, 0.00348107f, 
    -0.00581121f, 0.00379249f, -0.01115529f, -0.04134494f, 0.01973972f, 0.02549456f, 0.01007263f, -0.04164624f, 
    0.00083062f, 0.02600871f, -0.03465922f, 0.01540235f, -0.02691636f, 0.02772312f, -0.02316842f, -0.03534760f, 
    0.01246974f, 0.01410248f, 0.01644318f, 0.01930075f, 0.00347037f, 0.01774516f, 0.02779693f, 0.01747537f, 
    0.03122178f, 0.00950515f, -0.02068997f, 0.00240410f, 0.02217880f, 0.01117907f, -0.02654069f, 0.02568133f, 
    -0.03234366f, 0.02256540f, -0.02136699f, 0.01451057f, -0.01976373f, -0.00377848f, 0.00629506f, -0.00724444f, 
    0.01313111f, -0.02701882f, 0.01678224f, 0.00167114f, -0.00475002f, -0.02281541f, 0.02345511f, -0.01912843f, 
    0.01517905f, -0.01205886f, 0.00061198f, 0.01263961f, 0.01143205f, -0.00760713f, 0.02482525f, -0.00189066f, 
    0.00356003f, -0.00483841f, -0.03770452f, 0.01271978f, -0.03369042f, -0.02619204f, 0.01620394f, -0.03134057f, 
    0.01742745f, 0.02585354f, 0.01875228f, 0.00428890f, -0.01830429f, -0.01295378f, -0.00849535f, -0.01788294f, 
    -0.00948562f, -0.01505608f, -0.02699114f, 0.03485272f, -0.03409179f, -0.02202823f, 0.00261748f, 0.03121818f, 
    0.03204348f, -0.00227104f, -0.02997756f, -0.00471857f, -0.01739842f, 0.03234345f, 0.02435534f, -0.04366471f, 
    -0.02174120f, 0.01190523f, -0.04400782f, 0.00926764f, -0.00276576f, 0.02356404f, 0.00807902f, 0.00297217f, 
    0.00464165f, -0.02097175f, -0.01170985f, -0.01191945f, -0.01498033f, -0.01688533f, -0.04067429f, -0.00964202f, 
    -0.02751104f, -0.00684011f, 0.01777530f, -0.02536960f, 0.00363272f, 0.00430916f, 0.00318474f, 0.01554344f, 
    -0.02579287f, -0.01929249f, -0.00442708f, -0.03663858f, -0.02470573f, -0.04015170f, 0.02974402f, 0.02846704f, 
    0.01804807f, -0.01490470f, -0.03603425f, -0.02107733f, -0.02300248f, 0.00063112f, 0.02113513f, 0.03894722f, 
    0.00277596f, 0.02223242f, 0.02506886f, 0.01934519f, -0.01117038f, -0.00156855f, -0.01958861f, 0.02270112f, 
    -0.00987195f, 0.01274647f, 0.01631054f, -0.04268837f, 0.02082714f, -0.02003484f, -0.04383667f, -0.00673529f, 
    0.02107392f, 0.01036960f, -0.03198554f, -0.02338842f, 0.01391335f, 0.01219055f, -0.01305800f, 0.00049780f, 
    -0.04290921f, -0.03718899f, -0.02606885f, 0.00579535f, 0.02901357f, 0.01660916f, -0.04130840f, 0.02747180f, 
    -0.02457509f, 0.01742173f, 0.03281983f, 0.02058455f, -0.02880281f, -0.04206856f, -0.01348303f, -0.01113154f, 
    0.04369738f, -0.01623305f, -0.02972486f, -0.02022559f, -0.03380404f, -0.02140240f, -0.02423788f, -0.01801384f, 
    -0.04145166f, 0.02835499f, -0.03819775f, -0.03411900f, 0.02866640f, 0.01997635f, 0.03420224f, -0.03671532f, 
    -0.01820599f, 0.02962530f, 0.01486812f, -0.01018769f, -0.03373206f, 0.00386008f, -0.02187443f, -0.02899797f, 
    -0.02144106f, -0.00923025f, 0.02838506f, -0.01457784f, -0.04218626f, -0.00862623f, 0.03238598f, 0.02722958f, 
    -0.00494491f, 0.02859327f, 0.01277655f, -0.02412936f, 0.00160150f, 0.00025177f, -0.01766533f, -0.01189719f, 
    0.02357339f, 0.03614875f, 0.00802794f, -0.03512856f, -0.00904769f, -0.01698052f, -0.01105429f, -0.03544347f, 
    -0.00769809f, -0.02510403f, 0.01121610f, -0.01997817f, -0.00733775f, 0.01580993f, -0.03841403f, 0.02687291f, 
    -0.03389122f, 0.02065988f, -0.02743826f, 0.00019742f, -0.00733421f, 0.03182874f, -0.01139704f, 0.00094130f, 
    -0.00596936f, -0.01653375f, -0.00011485f, -0.03022508f, -0.01913946f, -0.00252386f, 0.01373588f, -0.02213551f, 
    0.02597993f, -0.02250667f, -0.02043957f, -0.01356067f, -0.00986457f, 0.00389312f, 0.00350403f, 0.02923230f, 
    -0.00492208f, -0.02282715f, -0.03743477f, -0.02220041f, 0.03483079f, 0.01451686f, 0.00805399f, 0.00450744f, 
    -0.03178136f, -0.01516812f, 0.02214108f, 0.00858088f, 0.01167918f, -0.03050389f, -0.04167384f, -0.02828410f, 
    -0.01198917f, -0.01329744f, -0.01673311f, 0.00454352f, -0.01381397f, -0.03922198f, -0.01678591f, 0.02410226f, 
    -0.00836866f, 0.03060518f, -0.02953807f, 0.00771490f, 0.02755301f, 0.02642760f, -0.03599717f, -0.00863281f, 
    0.01999459f, -0.00750311f, -0.00936576f, 0.01980368f, -0.02652357f, -0.00933710f, 0.00867315f, -0.03184360f, 
    -0.01372007f, -0.00712892f, 0.00413467f, 0.02559263f, 0.01613687f, 0.03453963f, -0.01701672f, -0.00609347f, 
    -0.02922327f, -0.03231869f, -0.01738493f, -0.02577898f, -0.00437566f, 0.02078505f, -0.00062354f, 0.02534601f, 
    -0.01083057f, -0.00935331f, -0.04211356f, 0.02786293f, -0.01738191f, -0.00924419f, -0.03687207f, -0.01261951f, 
    -0.01465047f, 0.01943966f, -0.00886161f, -0.01866126f, 0.00495138f, 0.00008385f, -0.03361903f, -0.04143474f, 
    0.02853869f, -0.00898691f, -0.01712563f, 0.02474669f, -0.03595145f, -0.01058597f, -0.02552293f, -0.01828065f, 
    0.02093774f, -0.00953722f, -0.04337421f, -0.01197890f, 0.00900079f, 0.03341596f, 0.03451777f, 0.03884877f, 
    -0.00847887f, -0.03355572f, -0.00546593f, -0.00208232f, -0.00602120f, 0.00333802f, -0.01057301f, 0.01814830f, 
    -0.00215657f, 0.02658110f, 0.03324949f, 0.00488432f, -0.00991935f, -0.00470909f, 0.00957124f, -0.03956458f, 
    0.01746230f, -0.01706281f, -0.00514194f, 0.01227731f, 0.00562049f, -0.03925921f, 0.02208097f, -0.00171182f, 
    0.04135840f, 0.02715366f, 0.02134563f, -0.02528654f, -0.03946958f, -0.00390651f, -0.01016448f, 0.01569113f, 
    -0.01042061f, 0.01579871f, -0.03842718f, 0.03146325f, 0.01235394f, 0.02425243f, -0.02178521f, 0.00230594f, 
    -0.02571204f, -0.00978431f, 0.01214431f, -0.00821042f, -0.02459355f, -0.02075323f, -0.03247676f, -0.02365464f, 
    -0.01136377f, -0.00881629f, -0.03548430f, 0.01182414f, -0.01088032f, 0.02163418f, 0.00551084f, -0.01087535f, 
    0.02552094f, -0.04056811f, 0.03325302f, -0.01123666f, -0.02253385f, 0.02026739f, -0.00062808f, -0.03647396f, 
    0.02200786f, -0.00242204f, -0.00974764f, -0.01101390f, -0.01627649f, 0.01371794f, -0.02760050f, -0.04084768f, 
    0.02359816f, 0.00445152f, -0.00979733f, 0.00873609f, -0.00898119f, -0.00622841f, -0.02337841f, -0.01792200f, 
    0.02781702f, 0.00185826f, 0.00943492f, 0.00018065f, 0.01103208f, -0.01573334f, -0.03613143f, -0.01126750f, 
    0.03144025f, -0.03073037f, -0.01418005f, -0.03639046f, -0.02001123f, 0.01026168f, 0.01695517f, -0.03558340f, 
    -0.01327770f, -0.03003234f, -0.02438389f, -0.01002733f, -0.03803231f, 0.02805852f, 0.00167951f, -0.04003251f, 
    -0.02859313f, 0.00537116f, -0.02516060f, 0.01437416f, -0.04217500f, -0.02636955f, -0.02694851f, 0.02047482f, 
    0.01293653f, -0.02256422f, 0.00567585f, -0.00164963f, 0.00693540f, -0.03442306f, 0.01726778f, -0.04177272f, 
    -0.02285401f, -0.03040780f, -0.02820991f, 0.02158590f, 0.00266752f, -0.03187161f, -0.04175315f, 0.00512860f, 
    -0.02981596f, -0.03262603f, -0.03854986f, -0.02042650f, -0.00570314f, 0.02152355f, -0.01370598f, 0.01825137f, 
    0.01867647f, 0.01978514f, 0.00281321f, 0.03136170f, 0.02836273f, 0.02169183f, -0.00650379f, -0.00268369f, 
    -0.02515561f, -0.02107777f, 0.00464810f, 0.03168821f, 0.01401745f, -0.03856403f, -0.01859776f, -0.03939883f, 
    0.03013881f, -0.02909178f, -0.02639316f, 0.00087698f, 0.03285531f, 0.03755757f, 0.00803628f, -0.02438327f, 
    0.01539170f, -0.01503563f, 0.01069294f, -0.02010394f, -0.02700906f, -0.02512205f, -0.01337089f, 0.01390234f, 
    -0.00036517f, -0.02104437f, -0.00429562f, -0.00535801f, 0.01645648f, -0.02727363f, -0.03764066f, 0.03377295f, 
    0.01563611f, -0.03759231f, -0.03519423f, -0.01826254f, -0.01769190f, -0.01924608f, -0.02306361f, -0.01694149f, 
    0.02974906f, -0.08295128f, -0.25638717f, 0.06804300f, 0.32051030f, 0.09623643f, 0.04278908f, -0.03601368f, 
    0.10528878f, 0.08420609f, -0.07698917f, 0.04687771f, 0.04052890f, 0.00752538f, 0.02600748f, 0.11292204f, 
    -0.07946227f, 0.00726705f, -0.01714463f, -0.00932657f, 0.18426563f, -0.15504417f, -0.25206044f, 0.12011257f, 
    0.35379812f, -0.03142768f, -0.02670151f, 0.00738291f, -0.01530070f, 0.08676893f, -0.07316229f, 0.08014073f, 
    -0.06765307f, -0.05054810f, -0.05742686f, 0.01226178f, 0.10736248f, 0.21902061f, 0.04710888f, 0.00577149f, 
    -0.27745005f, 0.11015347f, 0.38787115f, -0.02091921f, -0.11372626f, -0.15669347f, -0.08153000f, -0.04226611f, 
    0.10027433f, -0.05290148f, -0.01652415f, 0.05033669f, 0.09515188f, 0.02225562f, 0.12628236f, 0.08103281f, 
    0.09477167f, -0.11011695f, -0.12085542f, 0.03424464f, 0.61993271f, -0.01267934f, 0.16511613f, -0.19971296f, 
    -0.27852792f, 0.08642811f, 0.16282706f, 0.07209650f, 0.05672209f, 0.09767009f, -0.05944564f, -0.05866990f, 
    0.06264413f, 0.01398382f, 0.04311710f, 0.03978628f, -0.01118961f, -0.13258801f, 0.06074548f, 0.07520161f, 
    0.26917419f, 0.12355947f, -0.03791421f, 0.10291642f, 0.10278981f, 0.19795755f, 0.16993400f, 0.07091527f, 
    -0.05290984f, 0.12288773f, -0.10276868f, -0.04677552f, -0.04990118f, 0.02970211f, 0.05301649f, -0.05577611f, 
    0.05052327f, -0.06600318f, 0.05228709f, 0.11948737f, -0.47786963f, 0.09401790f, 0.34253973f, 0.24957404f, 
    -0.24726839f, -0.08893722f, -0.07360090f, 0.00608765f, 0.00455976f, -0.07804342f, -0.00458508f, 0.15575184f, 
    0.04591703f, 0.00331581f, -0.01751230f, 0.00175590f, 0.13555995f, 0.11825313f, -0.00025862f, 0.00165372f, 
    0.17811136f, 0.14724468f, 0.28500167f, -0.20293556f, -0.09778894f, -0.19673713f, -0.01981813f, 0.03623461f, 
    -0.12939979f, -0.00743892f, -0.00166984f, -0.03865599f, 0.03289945f, 0.00487879f, 0.13907136f, -0.04903338f, 
    0.07613407f, -0.00351141f, -0.04650893f, -0.01702964f, -0.12470322f, -0.12452630f, 0.33903855f, 0.24431542f, 
    0.48346868f, -0.06484847f, -0.06359534f, -0.06108290f, 0.07684474f, -0.04860143f, 0.14487030f, 0.01431584f, 
    0.02765186f, 0.07066367f, 0.02214376f, -0.04776857f, 0.00208312f, 0.08730382f, 0.05590114f, 0.00498102f, 
    -0.12728156f, -0.21247527f, -0.31928709f, 0.09401656f, 0.25002259f, 0.20879674f, 0.05946881f, 0.15149780f, 
    0.09581701f, 0.17740454f, 0.06599801f, 0.08175854f, 0.02368788f, 0.00241248f, -0.02950234f, 0.02592754f, 
    -0.06907412f, 0.01065614f, -0.01497052f, 0.08018508f, 0.09962070f, -0.12638296f, -0.27088851f, -0.13699964f, 
    0.23470736f, 0.00183911f, -0.05466145f, -0.13464434f, 0.02625378f, -0.06672687f, -0.00246418f, 0.01310446f, 
    -0.00998585f, 0.04586891f, 0.01165156f, 0.01315505f, -0.03472107f, 0.01508547f, -0.02353055f, -0.09622237f, 
    -0.22722596f, 0.07512429f, -0.04383352f, -0.26212478f, -0.30906117f, -0.08463819f, 0.02442438f, 0.08167170f, 
    0.02756811f, -0.12883881f, -0.09679807f, 0.02689898f, -0.09937990f, -0.19363704f, 0.00579013f, -0.02878805f, 
    -0.03954322f, -0.03682762f, 0.03267128f, -0.11022738f, -0.17829622f, 0.51464510f, -0.01889584f, 0.05889465f, 
    -0.04654472f, 0.09838516f, -0.02071234f, 0.05954806f, -0.05686823f, -0.04395360f, -0.18097165f, -0.03225800f, 
    -0.07669794f, -0.05528933f, 0.03156230f, -0.21107845f, -0.01776508f, -0.04837974f, 0.05278861f, -0.05806867f, 
    -0.07966805f, 0.01942954f, -0.02208475f, -0.06372634f, -0.00593869f, -0.01844911f, 0.03093049f, 0.02799603f, 
    -0.06010953f, 0.04140664f, -0.03956056f, 0.02590277f, 0.09592526f, -0.19710964f, 0.03837810f, 0.10732643f, 
    -0.04771621f, 0.01427906f, 0.07399562f, -0.15820117f, -0.20760620f, -0.13211843f, -0.01801477f, 0.13569169f, 
    -0.17466354f, 0.19076495f, 0.04900285f, 0.18845449f, 0.04878064f, 0.11276201f, -0.02230203f, 0.13343734f, 
    -0.03886045f, 0.06297486f, 0.03230666f, 0.07571497f, -0.06392079f, 0.08965330f, 0.02975458f, -0.08041361f, 
    -0.08609997f, -0.07755552f, -0.07692262f, -0.04074413f, -0.15672442f, 0.04595350f, 0.09654958f, 0.08627397f, 
    0.06466921f, 0.07836094f, -0.08267608f, 0.06056315f, -0.22947337f, -0.01990005f, -0.07704054f, -0.05916801f, 
    0.04412512f, 0.07293846f, -0.00831228f, -0.07571971f, 0.83122718f, 0.16194770f, -0.01818875f, -0.21970586f, 
    0.18536863f, 0.04301652f, -0.09772574f, -0.03699894f, -0.18898614f, -0.09038326f, -0.20115963f, 0.11356284f, 
    0.05549857f, 0.06482534f, -0.04915173f, 0.05122913f, 0.01647919f, -0.08697809f, 0.09268188f, -0.01156446f, 
    -0.20121692f, 0.02556896f, 0.21543400f, 0.16820261f, 0.05793333f, 0.10796405f, 0.04338058f, -0.00894270f, 
    -0.07567824f, 0.05118107f, -0.06286273f, 0.05635057f, 0.04001134f, 0.02426752f, 0.00558448f, -0.13304088f, 
    -0.01793335f, 0.01649388f, 0.03695706f, -0.01012091f, 0.53479087f, 0.03201383f, 0.01469286f, -0.20889932f, 
    0.20797162f, -0.06191043f, -0.01259495f, 0.06039015f, 0.01366303f, -0.12243668f, 0.17335469f, 0.00068251f, 
    -0.02189205f, 0.00125543f, 0.06301945f, -0.03081879f, 0.00977868f, 0.09703659f, 0.00412080f, -0.16479695f, 
    -0.02908254f, 0.31729248f, -0.18184666f, 0.24471375f, 0.46163169f, 0.06098231f, 0.06422111f, 0.04946064f, 
    -0.04419779f, 0.03567174f, -0.13386850f, 0.05342367f, 0.05113384f, 0.11382001f, 0.09332194f, 0.02386394f, 
    0.03801659f, 0.03607380f, -0.00436208f, 0.00069267f, 0.32212982f, 0.09345684f, 0.10007135f, -0.12774807f, 
    -0.16328929f, 0.08830814f, 0.08405636f, 0.08222745f, 0.02856482f, 0.08536782f, -0.08967736f, -0.10384995f, 
    -0.02655099f, -0.04852463f, -0.00765726f, -0.09534319f, -0.07429840f, -0.20974910f, -0.05610500f, 0.02046157f, 
    0.18997717f, 0.07918109f, -0.15569784f, -0.02971280f, 0.26591229f, 0.04987191f, 0.07780156f, 0.00609961f, 
    -0.03230326f, 0.01140564f, 0.02174167f, 0.07780075f, -0.03667228f, 0.02768653f, 0.03541541f, 0.07871699f, 
    0.04637848f, 0.00672118f, -0.10518247f, 0.05525446f, -0.96162415f, 0.55562812f, -0.03450663f, 0.50464451f, 
    -0.02373724f, 0.01967294f, -0.06822652f, 0.24875705f, -0.04718210f, -0.05185564f, -0.11680828f, 0.09602594f, 
    0.04760960f, 0.08343308f, -0.09192421f, 0.05199000f, 0.16624805f, -0.05367181f, 0.01002256f, -0.00225171f, 
    -0.03227978f, -0.30729818f, 0.02617825f, 0.18227591f, 0.32410508f, -0.01042768f, 0.01115907f, -0.04131700f, 
    0.02572137f, 0.23024508f, 0.05736817f, 0.02528348f, 0.07226802f, 0.07689994f, -0.06293689f, 0.02795990f, 
    -0.00405522f, 0.11161519f, -0.01347434f, -0.01130561f, -0.16994467f, -0.02516404f, 0.47591150f, -0.01916589f, 
    -0.18512142f, 0.08041266f, -0.09692701f, 0.15250722f, 0.00665360f, 0.05069415f, 0.10484534f, 0.14792925f, 
    0.05082564f, -0.02619399f, 0.10700206f, 0.04373226f, -0.07686635f, 0.11034942f, 0.11384920f, -0.07697850f, 
    -0.11575530f, 0.06427254f, 0.01272026f, 0.00981920f, 0.30571729f, 0.12117088f, 0.03206142f, -0.16734461f, 
    -0.05913088f, -0.04416181f, 0.08778945f, -0.00964016f, -0.00257267f, -0.04441113f, 0.13164891f, 0.17825584f, 
    -0.09119638f, 0.13928387f, -0.13221313f, -0.00519638f, 0.34139830f, -0.08071416f, 0.17312951f, -0.27607521f, 
    0.05380421f, -0.01030811f, -0.09718832f, -0.05501457f, 0.11107279f, -0.12263282f, -0.01236524f, 0.00146230f, 
    -0.01696112f, 0.04731115f, 0.11158302f, -0.10382504f, 0.02865375f, 0.13119444f, -0.09515170f, -0.03288015f, 
    -0.21383254f, 0.00959766f, 0.07900564f, -0.00848038f, -0.26769286f, -0.01582925f, -0.09245135f, 0.02163221f, 
    0.04855058f, -0.05531148f, 0.03109694f, -0.05365681f, 0.10552768f, 0.01979512f, -0.05664093f, 0.05321543f, 
    -0.00404716f, -0.13989213f, 0.01166122f, 0.04648763f, -0.37868443f, 0.34317929f, -0.18459576f, 0.37525263f, 
    0.29478455f, 0.05457370f, -0.00294841f, 0.05802695f, -0.06341498f, 0.03086735f, -0.06249063f, -0.11577067f, 
    0.06296853f, -0.01357880f, 0.06916066f, 0.05263286f, -0.00473846f, 0.03018732f, 0.03099861f, 0.04691742f, 
    -0.35206655f, -0.17868653f, 0.09952106f, 0.20182812f, -0.10403761f, 0.06248708f, 0.03506603f, 0.04028437f, 
    -0.00264102f, -0.01958142f, 0.10424519f, 0.04444257f, 0.17756106f, 0.12148969f, -0.18866366f, -0.01141135f, 
    0.00217870f, 0.18681282f, -0.09722240f, 0.03728377f, -0.17349613f, -0.05124224f, 0.11261802f, 0.16996729f, 
    -0.21978883f, 0.04850901f, -0.05367861f, 0.01155996f, -0.07666519f, 0.08200527f, 0.00000216f, 0.07915828f, 
    0.04422890f, 0.07250098f, -0.02209212f, 0.02485869f, 0.00360615f, 0.01667934f, -0.14918475f, 0.04483574f, 
    0.28092781f, 0.15604796f, 0.05733484f, -0.04063343f, -0.01149212f, 0.13543288f, 0.00137704f, 0.02875308f, 
    0.00641098f, 0.08638415f, -0.07962811f, -0.04410634f, 0.00635749f, -0.02299085f, 0.03999961f, -0.02197146f, 
    -0.02422336f, -0.19945021f, 0.04955162f, -0.03334535f, -0.02552187f, -0.24059099f, 0.05244086f, 0.01812077f, 
    0.28390253f, -0.09267024f, 0.00542721f, 0.03492919f, 0.06161346f, 0.09228294f, 0.03891279f, -0.09115815f, 
    -0.02911939f, -0.11782790f, -0.02877482f, 0.17325625f, 0.02037281f, 0.09736624f, 0.08200648f, 0.12884684f, 
    0.00390704f, -0.04181292f, -0.03085064f, -0.02337194f, -0.00692477f, 0.00680617f, -0.02320893f, -0.00542444f, 
    -0.05587372f, 0.00449779f, -0.06199504f, -0.05912411f, -0.04112934f, -0.05293707f, -0.02624540f, 0.00097014f, 
    0.00692002f, 0.00675313f, -0.05688277f, 0.00017544f, -0.03428556f, -0.02313462f, -0.00227756f, -0.05287018f, 
    -0.03735673f, -0.05163084f, -0.00898375f, 0.00259592f, -0.06315148f, -0.04132859f, -0.03434744f, -0.04315276f, 
    -0.05512483f, -0.06351683f, -0.01367909f, -0.03588958f, 0.00335155f, -0.00175349f, -0.03517820f, 0.00283690f, 
    -0.05702306f, -0.01693388f, 0.01487809f, 0.02042367f, -0.02632108f, 0.01187639f, -0.00893968f, -0.03377845f, 
    -0.04770038f, -0.03128928f, -0.02827798f, -0.02851387f, -0.06331738f, -0.04975394f, -0.05451430f, -0.02578917f, 
    0.00470672f, -0.01612733f, -0.01465013f, -0.01976879f, -0.01629826f, 0.02415478f, -0.01841360f, -0.05833024f, 
    -0.01848556f, -0.05820398f, -0.02779892f, -0.00083469f, -0.01943360f, 0.00202243f, -0.01130491f, 0.00302491f, 
    -0.01599121f, 0.00554622f, 0.00143696f, -0.02825100f, -0.06210867f, -0.05057615f, -0.05666370f, -0.01644225f, 
    -0.06293006f, -0.05452209f, -0.03970674f, -0.06340825f, -0.02771404f, -0.05149741f, -0.00205622f, -0.04844186f, 
    -0.05410025f, -0.04342131f, -0.02884050f, 0.00670503f, -0.04636873f, -0.03252768f, 0.00175784f, -0.06303150f, 
    -0.04989179f, -0.04231567f, -0.01211620f, -0.01534348f, -0.03141940f, -0.03255809f, 0.00064754f, -0.06446742f, 
    -0.04750626f, -0.06190120f, -0.05753410f, 0.00969059f, -0.01803831f, 0.00113180f, 0.00145617f, -0.03698120f, 
    -0.04646672f, 0.00522222f, -0.05128993f, 0.00407230f, -0.02952963f, -0.06296392f, -0.04982413f, -0.05383985f, 
    -0.00997491f, -0.05017669f, 0.01043815f, -0.05687315f, -0.06361124f, -0.04826586f, -0.03922596f, -0.05457983f, 
    -0.05416587f, -0.03950198f, -0.03683788f, -0.03731332f, -0.04289104f, 0.00914066f, -0.03194946f, -0.04744102f, 
    -0.00337402f, -0.00261764f, -0.05581410f, -0.02966293f, -0.01603293f, -0.04282747f, -0.06274427f, -0.00364120f, 
    -0.06037285f, -0.01792042f, -0.04639816f, -0.02852632f, -0.00087320f, -0.05869874f, 0.00337202f, -0.05174801f, 
    -0.01179382f, 0.00712015f, -0.06426377f, -0.05692047f, -0.05849231f, -0.01971849f, -0.04189792f, -0.01155840f, 
    -0.06016298f, -0.00038584f, -0.03719243f, -0.01434618f, -0.02330758f, -0.05759212f, -0.00572493f, 0.00412486f, 
    -0.04896272f, -0.02523424f, -0.00907784f, 0.00837240f, -0.01659339f, -0.02424357f, -0.03778141f, -0.00101546f, 
    -0.05759981f, -0.01481479f, -0.03145673f, -0.02872021f, -0.01776228f, -0.06759458f, -0.06307435f, -0.00623923f, 
    -0.00488706f, -0.03012614f, -0.01058479f, -0.04175081f, -0.00922699f, -0.00575462f, -0.02534230f, 0.00158309f, 
    0.00676604f, -0.03113271f, 0.00512582f, -0.05776402f, 0.00744410f, -0.03908168f, -0.04689325f, -0.01252869f, 
    0.01958126f, -0.01765154f, 0.01084685f, -0.03886734f, 0.02756726f, 0.00130161f, -0.00226495f, 0.01054676f, 
    -0.02508437f, 0.00984999f, -0.03685395f, -0.01563128f, -0.04386217f, -0.04021126f, -0.04366585f, -0.01117348f, 
    -0.02475189f, -0.06818666f, -0.02387108f, -0.02761818f, -0.05418193f, -0.04256831f, -0.03711620f, -0.05572974f, 
    -0.04934832f, -0.06831784f, -0.02047617f, -0.00960847f, -0.06403312f, -0.02486713f, -0.05081862f, -0.05259985f, 
    -0.05692468f, -0.05220044f, 0.00458697f, -0.06684383f, -0.05336462f, -0.01247181f, -0.03675123f, -0.02728811f, 
    -0.01292457f, -0.04177141f, -0.01357384f, -0.01454438f, -0.05841849f, 0.00030325f, -0.05956379f, -0.04286056f, 
    -0.06563944f, -0.00495435f, -0.03784617f, 0.01939050f, -0.04022760f, 0.01035319f, 0.00708768f, 0.00960015f, 
    -0.06205521f, -0.00348865f, -0.00238578f, -0.01262826f, -0.04443664f, -0.03299381f, -0.04669134f, -0.01784036f, 
    -0.04034472f, 0.00023397f, -0.06130220f, 0.00793507f, -0.06253632f, -0.02887052f, -0.01849405f, -0.01480060f, 
    -0.04040912f, -0.04548579f, -0.03900653f, -0.01478789f, -0.06776739f, -0.05932109f, -0.06569016f, -0.06818190f, 
    0.03659869f, -0.03871107f, 0.01214228f, -0.04828009f, -0.05455979f, -0.06171273f, -0.02254958f, -0.03021645f, 
    -0.00089625f, -0.02319984f, -0.05374662f, -0.01157775f, -0.00624093f, 0.01025809f, -0.02064643f, -0.03351147f, 
    -0.04764403f, -0.05538904f, -0.03841543f, -0.03319135f, -0.01050604f, -0.02130727f, -0.03677344f, -0.00654359f, 
    -0.02848587f, -0.06071945f, 0.00790006f, -0.03575315f, -0.02003725f, -0.00971348f, 0.00659566f, -0.05448570f, 
    -0.03646006f, -0.00037254f, -0.04048040f, 0.00097947f, -0.05443648f, -0.02000003f, -0.04467205f, -0.02696467f, 
    -0.05967355f, -0.05739920f, 0.00977466f, -0.01955486f, -0.01921640f, -0.05654797f, -0.03625070f, -0.06709182f, 
    -0.01971680f, -0.05229695f, -0.06644567f, 0.00133939f, -0.00395300f, -0.06315264f, -0.01838164f, -0.00874025f, 
    -0.02847765f, -0.02670786f, -0.02035939f, -0.04247427f, -0.05129360f, -0.06450920f, -0.02658315f, -0.04643149f, 
    0.00869629f, -0.01319253f, -0.04959146f, -0.00213194f, -0.02833373f, 0.00519731f, -0.02986654f, -0.02251871f, 
    -0.02096519f, -0.02393399f, -0.02092004f, -0.00121936f, -0.04445701f, -0.01792182f, -0.00175171f, -0.04884027f, 
    -0.05707991f, -0.01261261f, -0.03186824f, -0.06667355f, -0.04299058f, -0.04000257f, -0.04992345f, -0.02638298f, 
    0.03349995f, -0.05432376f, -0.05275611f, -0.02606350f, -0.05300359f, -0.03290695f, -0.03208802f, -0.04704534f, 
    -0.02686820f, -0.05932476f, -0.01158326f, -0.03265432f, 0.03715290f, 0.01875632f, 0.00696917f, 0.00182052f, 
    0.00040202f, -0.01107321f, -0.00695851f, -0.02892513f, -0.02016486f, -0.00062245f, -0.05946783f, -0.05179909f, 
    -0.06171665f, -0.02523893f, -0.06292047f, -0.06739821f, 0.00403972f, -0.05845486f, -0.04654854f, -0.06409387f, 
    -0.03513226f, -0.04819000f, -0.00136150f, 0.00685905f, -0.01432904f, 0.00757140f, -0.05996190f, -0.04889303f, 
    -0.03959830f, 0.00982627f, 0.00465359f, -0.00729983f, -0.02836950f, -0.03221893f, -0.01556680f, 0.00337229f, 
    -0.01812845f, -0.06082728f, -0.04872895f, -0.02334557f, -0.04176432f, -0.04039520f, 0.01416572f, -0.04115875f, 
    -0.05688438f, -0.06105120f, -0.01410863f, 0.00231181f, -0.06439490f, -0.04268322f, -0.06563361f, -0.00330272f, 
    -0.02838195f, -0.04820680f, -0.03512763f, 0.00377693f, -0.02930650f, -0.02166707f, -0.05290654f, -0.06338574f, 
    -0.05908771f, -0.03924552f, -0.05628027f, -0.05141742f, -0.06736850f, -0.02534390f, -0.04252267f, -0.01325123f, 
    -0.04151355f, -0.06228760f, -0.02969773f, -0.05495030f, -0.00726665f, -0.03619546f, -0.01952402f, -0.01142153f, 
    -0.05628539f, -0.01874596f, -0.00939646f, -0.01916788f, -0.00424668f, -0.03497630f, 0.00981543f, -0.02864007f, 
    -0.01963815f, -0.04318658f, -0.03236084f, -0.04770351f, -0.03246211f, -0.04145855f, -0.00331500f, -0.00564874f, 
    -0.05152478f, 0.00850777f, 0.03334366f, 0.00507688f, 0.01218351f, -0.02502620f, -0.02027152f, -0.01543491f, 
    -0.04885374f, -0.04545248f, 0.00210477f, -0.03870973f, -0.02841049f, -0.00460194f, 0.00732190f, 0.00140212f, 
    -0.01124943f, 0.00575525f, -0.00215838f, -0.06419716f, -0.05835176f, -0.04399763f, -0.01886765f, -0.06509969f, 
    -0.02259757f, -0.05539981f, -0.03945942f, -0.04877883f, -0.06799819f, -0.05282572f, -0.04475480f, -0.01356135f, 
    -0.05798840f, -0.05191293f, 0.00967212f, -0.05711964f, -0.06719129f, 0.00970976f, -0.02705229f, -0.05515874f, 
    -0.05939561f, -0.03872002f, -0.03056730f, -0.02855244f, -0.06392938f, -0.05689405f, -0.05680496f, -0.05284751f, 
    0.01093262f, 0.00546356f, 0.01716089f, -0.05320282f, 0.03548340f, -0.02830246f, -0.00136628f, -0.02556773f, 
    -0.05348907f, -0.03601440f, -0.03539006f, -0.04623674f, -0.00854135f, -0.06397571f, -0.03164196f, -0.00598767f, 
    -0.03232372f, -0.06051895f, -0.06689856f, -0.03865258f, -0.05738998f, -0.03694759f, -0.04605336f, -0.02199603f, 
    -0.06415343f, -0.01686921f, -0.05156283f, -0.01642327f, -0.06044082f, -0.04031179f, -0.05495797f, -0.01631551f, 
    -0.04363469f, -0.02869077f, -0.06355055f, 0.00093756f, -0.04410284f, -0.05163965f, -0.06004510f, -0.05310238f, 
    0.00490512f, 0.03433386f, -0.00658308f, -0.02656435f, -0.02767584f, -0.04073079f, -0.03835714f, 0.00452015f, 
    -0.06608440f, -0.01205440f, -0.04768220f, -0.04801292f, -0.02755758f, -0.02558307f, -0.04536774f, -0.02161404f, 
    -0.06788914f, -0.03898686f, 0.00458331f, -0.02021121f, -0.03715844f, 0.02185185f, -0.03283050f, 0.03757199f, 
    0.00118149f, 0.01321372f, -0.02531086f, -0.03647060f, -0.03748638f, -0.02066828f, -0.00528466f, -0.02235128f, 
    0.00969222f, -0.03314875f, -0.01197846f, -0.02820227f, 0.00871822f, -0.03107870f, 0.00068787f, -0.02530525f, 
    -0.00443221f, 0.03892110f, -0.06185787f, -0.05311693f, -0.01844145f, -0.06602377f, -0.00890897f, -0.06460781f, 
    -0.00451663f, 0.01071364f, -0.05291714f, -0.03415060f, -0.06404836f, -0.01429619f, 0.00169674f, -0.02692049f, 
    -0.02693553f, 0.00068066f, -0.03298461f, -0.02782261f, 0.00183619f, -0.03307211f, 0.00542135f, -0.02936770f, 
    -0.04260921f, -0.00105563f, -0.00286590f, -0.03477452f, -0.04445197f, -0.06317789f, -0.04835802f, -0.00160676f, 
    -0.03304229f, -0.03486076f, -0.03925835f, -0.01595990f, 0.00645073f, -0.05443858f, -0.01674868f, 0.00595045f, 
    -0.01970458f, 0.03278569f, -0.03287831f, 0.01731612f, 0.00619360f, -0.01455921f, 0.01668564f, -0.02653346f, 
    0.00240289f, 0.02635536f, -0.02417027f, -0.03732681f, -0.01723758f, -0.00387007f, 0.02527437f, 0.02472946f, 
    -0.00995460f, -0.01761398f, -0.00381323f, -0.04108435f, 0.00957500f, -0.02893975f, -0.00789627f, 0.00501298f, 
    0.01470146f, 0.03728835f, 0.03168539f, -0.03486205f, -0.01195978f, 0.01610671f, -0.01673941f, 0.01059020f, 
    -0.02493109f, -0.03855815f, 0.00583541f, -0.00386342f, 0.03263096f, -0.00250128f, -0.01904134f, -0.01446944f, 
    -0.02707008f, 0.00464392f, 0.02378081f, 0.00791207f, -0.02209178f, 0.03192860f, -0.03658727f, 0.02535465f, 
    -0.03652050f, -0.01783568f, -0.00059513f, -0.02486309f, 0.02028312f, 0.02453827f, 0.01258836f, 0.01566706f, 
    -0.03168341f, -0.03203000f, 0.02001283f, -0.02823415f, -0.01927322f, 0.02564808f, -0.02377028f, -0.01529052f, 
    0.02841979f, 0.02260139f, -0.00510960f, -0.01305722f, -0.03657074f, 0.01208771f, -0.02265206f, -0.02544057f, 
    -0.02616356f, 0.00534512f, 0.01421520f, 0.01382102f, -0.04158333f, -0.03156420f, 0.00558654f, 0.01108287f, 
    0.01773834f, -0.03424972f, -0.00269529f, -0.02816041f, -0.01205977f, -0.01725934f, 0.00807941f, 0.01416367f, 
    -0.01153806f, -0.03257045f, -0.02120363f, 0.03254057f, -0.03740887f, -0.02762339f, 0.02754866f, -0.00391493f, 
    0.02721644f, -0.02457817f, -0.02010378f, -0.02130693f, 0.02805213f, 0.03547570f, -0.02456389f, 0.00405949f, 
    0.02678014f, 0.00337647f, -0.03219908f, 0.00295522f, -0.02758688f, 0.00991688f, 0.00264953f, -0.01913114f, 
    -0.02228339f, -0.03421229f, -0.04234593f, -0.00772047f, 0.01759946f, -0.00608524f, -0.04276641f, -0.02505119f, 
    0.03189694f, -0.00946455f, -0.00677381f, -0.00235105f, -0.03287536f, 0.02887212f, -0.02472651f, -0.03729335f, 
    0.00975366f, -0.03368317f, 0.00773746f, -0.02244637f, -0.04172460f, -0.01119859f, 0.02705643f, 0.03385437f, 
    -0.01581723f, 0.01743846f, -0.00307364f, -0.02008569f, -0.03654194f, 0.00090385f, 0.01960559f, -0.04184134f, 
    -0.00440117f, -0.04141722f, 0.01265427f, -0.04311341f, 0.02021809f, 0.00107428f, 0.00314789f, -0.02192871f, 
    -0.02001932f, -0.02970076f, 0.02655181f, 0.01195055f, 0.02238729f, -0.03149567f, 0.03239188f, -0.01979522f, 
    0.00832020f, 0.01041819f, -0.00361418f, -0.04428406f, -0.02411595f, -0.03146664f, 0.00061464f, 0.01542881f, 
    -0.01159221f, -0.01250404f, -0.00689176f, 0.02231034f, -0.03252602f, 0.00102460f, -0.02902160f, -0.03234647f, 
    0.01542545f, -0.04298425f, -0.02724195f, -0.04102211f, 0.01981162f, -0.01705912f, -0.02114487f, 0.00839779f, 
    -0.03040671f, -0.04392006f, 0.02692353f, 0.00728628f, -0.02638451f, -0.02280634f, -0.01936203f, -0.02267805f, 
    -0.00324411f, 0.02631081f, 0.01883796f, -0.03309055f, 0.03730088f, -0.03281173f, -0.01713501f, 0.00041752f, 
    0.01196200f, 0.01053265f, -0.01787236f, -0.00835324f, -0.00247270f, -0.02227991f, 0.03513629f, -0.02693759f, 
    0.02868247f, -0.02107790f, -0.01838689f, -0.01574316f, 0.01888555f, 0.01789076f, -0.01407739f, -0.00059541f, 
    0.01440278f, -0.00589003f, -0.03426662f, -0.04137599f, 0.01037788f, 0.01757148f, 0.00937149f, -0.03380604f, 
    -0.02096402f, -0.03609265f, -0.01437750f, -0.02440143f, 0.00050587f, -0.02950967f, -0.03638477f, 0.00500379f, 
    -0.00073574f, -0.02990193f, -0.02962939f, 0.02591958f, 0.02851585f, 0.00845930f, -0.04353508f, -0.04335255f, 
    -0.01795405f, -0.01600044f, -0.02550915f, -0.02990714f, -0.01084793f, 0.01335374f, -0.00369537f, 0.01281054f, 
    0.01891996f, -0.00285153f, -0.01137251f, 0.02849072f, 0.00767508f, -0.03016763f, 0.00748493f, -0.01865989f, 
    -0.01450714f, -0.01620208f, 0.01161372f, 0.00915121f, -0.03532954f, -0.03122178f, -0.00314797f, -0.04202033f, 
    -0.03941701f, -0.02927850f, -0.00050547f, 0.02231285f, 0.02105203f, -0.03733186f, -0.02868214f, -0.04330835f, 
    0.01018147f, -0.01760515f, 0.01375283f, -0.03453633f, -0.02363169f, -0.01643398f, -0.02788767f, -0.01709250f, 
    0.00847918f, -0.01284844f, -0.01078841f, -0.02365656f, 0.00545330f, 0.02127531f, 0.03396874f, 0.00729980f, 
    0.01060533f, 0.01783398f, 0.02991315f, -0.01471329f, 0.03100980f, -0.00373379f, 0.01878180f, 0.02732257f, 
    -0.02307374f, 0.03300657f, -0.01632203f, 0.03004166f, 0.02259035f, 0.01497614f, -0.04367516f, 0.02744881f, 
    0.02475948f, -0.04260301f, -0.00404614f, 0.00139303f, -0.03649505f, -0.01342273f, -0.04315674f, -0.01047318f, 
    0.02700337f, 0.01084286f, -0.03613953f, -0.04251504f, -0.01071814f, -0.01847307f, 0.03066647f, -0.01162435f, 
    -0.02016207f, -0.03404259f, 0.02696759f, 0.00043276f, -0.04006476f, -0.02937338f, 0.00245792f, -0.03739326f, 
    -0.03712687f, -0.01517537f, -0.00056217f, 0.00239392f, -0.01601540f, -0.00337001f, 0.02781650f, 0.01754594f, 
    0.00698983f, 0.03343245f, 0.03134741f, 0.03173734f, -0.03026130f, 0.02609826f, 0.01615632f, 0.03273238f, 
    -0.02466435f, -0.02200871f, -0.02002459f, 0.02068740f, -0.04198380f, -0.04048167f, 0.02464016f, 0.01935171f, 
    0.00925373f, 0.02381206f, 0.02084452f, 0.00184923f, -0.01439239f, -0.02632193f, -0.04119688f, -0.03066288f, 
    -0.03052435f, -0.00851604f, 0.00350006f, 0.02819684f, 0.03325914f, 0.00457232f, -0.04354266f, -0.00307580f, 
    0.01996019f, 0.00900093f, -0.00559984f, 0.01042287f, 0.02953421f, -0.03126222f, 0.00521113f, -0.02683392f, 
    0.00285964f, 0.01944957f, 0.00048945f, -0.02152991f, 0.00138486f, -0.02450030f, 0.00117469f, -0.03040323f, 
    -0.03461519f, -0.01802847f, -0.03538144f, -0.00897736f, 0.00059730f, -0.03348862f, -0.00610617f, -0.00630338f, 
    0.02716952f, 0.01624151f, 0.00281929f, -0.00190034f, 0.02555504f, -0.04354410f, 0.02615413f, -0.04460007f, 
    -0.00293961f, 0.02711926f, -0.03965572f, 0.03255711f, -0.02962064f, 0.00287140f, -0.00790358f, -0.04311903f, 
    -0.03725437f, -0.04311705f, -0.00994109f, 0.01373185f, -0.01388990f, -0.01446572f, 0.01352294f, -0.01895792f, 
    -0.03418869f, -0.01096853f, -0.01681776f, 0.02033727f, -0.01381866f, -0.01097100f, 0.01582534f, -0.01867386f, 
    -0.00139741f, -0.00658363f, 0.00257059f, 0.03155671f, -0.03714700f, -0.02772210f, -0.01050393f, -0.00422259f, 
    -0.02150669f, 0.00221095f, -0.04470652f, 0.03319507f, -0.00938169f, -0.02408856f, 0.00764835f, -0.01044940f, 
    0.01032083f, 0.01256430f, -0.00220964f, 0.01079864f, -0.01048155f, 0.02973424f, -0.01920567f, 0.01808458f, 
    0.01746055f, -0.00419853f, -0.00834075f, 0.01530938f, -0.00392945f, 0.01705140f, 0.00135261f, 0.01817170f, 
    -0.04008453f, 0.03354338f, -0.01898763f, -0.04152459f, -0.03115419f, 0.01726260f, 0.00439917f, 0.02604685f, 
    0.00360480f, 0.00164615f, 0.02720818f, 0.02183849f, -0.01953949f, -0.03669926f, 0.00891038f, -0.02066968f, 
    0.01610970f, -0.02128968f, 0.00694325f, -0.01924417f, -0.01447462f, 0.02292832f, -0.01770353f, -0.04444138f, 
    -0.02304833f, 0.00856796f, 0.01736512f, -0.01292856f, -0.02134947f, -0.01736952f, 0.03156638f, 0.01883179f, 
    0.02857062f, -0.00975123f, 0.02559069f, -0.01180016f, 0.00629249f, 0.00480395f, -0.02716139f, 0.00908463f, 
    -0.00216396f, 0.01320717f, -0.01185625f, 0.02647532f, 0.02336517f, -0.03135819f, 0.02718484f, -0.00707473f, 
    -0.02615858f, 0.02532108f, 0.00873378f, -0.03241093f, 0.01934301f, -0.03333362f, 0.03296975f, -0.00031409f, 
    -0.03109183f, -0.01903450f, -0.02008996f, -0.04345865f, -0.01101675f, 0.02846231f, 0.02074691f, -0.02114648f, 
    0.00645187f, -0.00097001f, 0.00349187f, 0.02460726f, 0.03332674f, -0.01498312f, 0.03314682f, -0.00613700f, 
    -0.01728290f, -0.03726755f, 0.03209865f, -0.00367332f, 0.01212324f, -0.04194958f, -0.00159374f, -0.02078241f, 
    -0.02746014f, 0.01063587f, 0.00105335f, -0.02989277f, -0.02776480f, 0.00751037f, -0.03147393f, 0.00071616f, 
    -0.00685650f, -0.01672904f, -0.01718185f, 0.00402168f, -0.04036313f, -0.01437563f, -0.02140797f, -0.04424752f, 
    0.03253746f, 0.01933177f, -0.01913894f, 0.00331360f, 0.02803926f, -0.00077779f, 0.00038343f, -0.00286098f, 
    -0.04237362f, -0.02280944f, -0.01283285f, -0.03011768f, 0.02225029f, -0.03613762f, 0.02129608f, -0.02009705f, 
    0.00442328f, 0.00288317f, 0.02664079f, -0.01671794f, -0.02302503f, -0.02410198f, 0.02110890f, -0.02919806f, 
    -0.04027091f, -0.01732704f, -0.01192934f, -0.03993792f, -0.03116174f, 0.01708904f, 0.03443380f, -0.02820593f, 
    -0.02150642f, 0.03028837f, 0.03360321f, -0.02040524f, -0.02311574f, 0.03330101f, -0.02187504f, -0.03751654f, 
    0.02907764f, 0.01203308f, -0.03958308f, -0.01586875f, 0.02285485f, 0.02651470f, -0.02168784f, -0.03378269f, 
    -0.02347076f, 0.02347693f, -0.02353311f, -0.02683703f, -0.02805920f, -0.03225446f, 0.02845581f, 0.02660131f, 
    0.03201647f, -0.03760332f, -0.02730076f, -0.00562041f, 0.00489162f, 0.02081776f, -0.03887536f, -0.03412540f, 
    0.00618794f, -0.03608022f, -0.02504303f, -0.03843693f, 0.01703050f, -0.01557632f, -0.01472089f, -0.01569615f, 
    -0.02393723f, 0.02590974f, -0.01266581f, -0.01407140f, 0.00563643f, -0.03569113f, -0.03674621f, -0.00220278f, 
    -0.00372840f, 0.01362988f, 0.02985372f, 0.02937409f, -0.01296707f, 0.01801813f, -0.01286507f, 0.01837458f, 
    -0.03129074f, -0.03943766f, 0.02537321f, 0.01661661f, -0.04049506f, 0.00685299f, -0.03014180f, 0.01447679f, 
    -0.01312741f, 0.02401013f, -0.00597351f, 0.02787657f, 0.00271658f, 0.02327775f, 0.01622778f, 0.01187690f, 
    -0.01262698f, 0.00926610f, -0.01767293f, 0.03310700f, -0.00316707f, -0.01324869f, 0.00707757f, -0.04161055f, 
    -0.03141760f, -0.00077754f, -0.03833700f, 0.00646907f, -0.03370393f, -0.01909166f, 0.03245855f, 0.01891313f, 
    0.02879417f, 0.00099518f, -0.00042852f, -0.00850769f, -0.03386113f, -0.04381937f, -0.00005925f, 0.02165571f, 
    0.02024390f, 0.00692195f, -0.00934146f, -0.00011626f, -0.03108998f, 0.00520332f, -0.01227461f, 0.01036227f, 
    0.02562490f, -0.02251754f, 0.03247600f, -0.01752360f, -0.00975866f, 0.01229812f, -0.03009240f, -0.01478589f, 
    0.01214779f, -0.02990796f, -0.03394516f, -0.04441781f, 0.01976025f, 0.03123027f, -0.04514049f, 0.01670822f, 
    0.01767704f, -0.02546696f, -0.01979992f, 0.00155022f, 0.00051133f, -0.01763512f, 0.03336615f, -0.03783479f, 
    -0.02859879f, -0.00850898f, 0.01995132f, 0.02000962f, 0.01102452f, 0.00666874f, -0.00339697f, -0.01746395f, 
    -0.04494538f, -0.04118974f, -0.00334163f, -0.00017844f, 0.02100861f, -0.02080456f, -0.00841074f, -0.01935039f, 
    -0.01710017f, 0.01757320f, -0.02253816f, 0.00325865f, 0.00677522f, 0.00257745f, -0.03393126f, -0.02727214f, 
    -0.03566124f, -0.00091153f, 0.00647346f, -0.04132248f, 0.02200871f, 0.02680379f, 0.01188444f, 0.00861576f, 
    -0.03309583f, -0.01289029f, -0.02063912f, -0.01132547f, -0.04531518f, -0.01419368f, -0.00782336f, 0.00784221f, 
    0.03141008f, 0.01298955f, 0.00427715f, 0.00738318f, -0.01813062f, -0.00590139f, -0.00828990f, -0.01308085f, 
    -0.03424783f, -0.01487360f, -0.02424701f, 0.01971686f, -0.04073273f, -0.00520806f, -0.03918752f, 0.02982638f, 
    -0.01262446f, -0.03095923f, -0.03645181f, -0.00951313f, 0.00867950f, 0.00428379f, 0.00094049f, 0.00818830f, 
    0.02106980f, 0.01793325f, -0.01075522f, 0.02754307f, -0.01339947f, -0.03954053f, -0.02717974f, -0.01622557f, 
    0.03000592f, 0.02037134f, -0.00864124f, -0.03436647f, -0.02673133f, -0.03953745f, 0.01808844f, -0.00133119f, 
    0.00554735f, 0.02830606f, -0.00136244f, 0.02219162f, -0.00412610f, 0.02154988f, -0.04075404f, 0.03348257f, 
    -0.02890685f, -0.01382991f, 0.02349404f, -0.00174805f, 0.02816384f, -0.04510479f, 0.02926896f, -0.03243799f, 
    0.02583240f, -0.02352934f, -0.00127266f, -0.01367182f, -0.03144627f, 0.00268792f, 0.02997540f, 0.00127571f, 
    0.01653335f, 0.00639855f, -0.01824740f, -0.02637623f, -0.00945666f, -0.00235821f, 0.02069802f, -0.01331504f, 
    -0.01506295f, 0.00857293f, -0.02369067f, 0.02071979f, -0.02739418f, -0.02492227f, 0.00629412f, -0.00176054f, 
    -0.03235023f, 0.01765786f, 0.01742339f, -0.00846721f, -0.00601937f, -0.00019317f, -0.00506597f, 0.01417426f, 
    -0.00220468f, -0.01713939f, 0.00441321f, -0.03114152f, 0.01855579f, 0.00053864f, -0.02612098f, -0.00177148f, 
    0.00384461f, 0.01610066f, 0.02776563f, -0.00166511f, 0.01520064f, -0.02795832f, -0.04463193f, 0.01421311f, 
    -0.01469158f, 0.00531720f, 0.01107386f, 0.03124253f, -0.02933720f, 0.01586439f, -0.01850348f, -0.01475391f, 
    -0.01057466f, 0.03174672f, -0.00541829f, -0.04428819f, 0.02989097f, -0.01127288f, -0.00566595f, 0.02513250f, 
    -0.00969485f, -0.00392722f, -0.03981809f, -0.02853692f, -0.01493536f, 0.01791633f, -0.00569273f, 0.00989158f, 
    -0.00974833f, -0.02233322f, 0.03243475f, -0.04419980f, 0.00267939f, -0.00597393f, -0.04062582f, -0.01014062f, 
    -0.02457145f, -0.04254350f, 0.00376141f, -0.02190421f, -0.03804566f, 0.00154553f, 0.00091504f, -0.01746728f, 
    0.00902404f, -0.01225242f, 0.02434169f, -0.00284841f, 0.01469543f, 0.00304439f, 0.02887204f, -0.01909491f, 
    -0.04524172f, -0.01518414f, -0.00402682f, -0.04423726f, 0.02264663f, -0.00694438f, -0.02094599f, -0.01212566f, 
    0.01196207f, 0.00714633f, -0.03396509f, 0.02984946f, -0.04540567f, -0.02625248f, 0.02864492f, 0.00734908f, 
    -0.01867731f, 0.02039608f, 0.00505593f, -0.03213101f, -0.00772725f, 0.01909533f, -0.03523382f, -0.04509806f, 
    -0.00576206f, -0.00861632f, -0.00046291f, 0.00159695f, 0.00501475f, 0.00287004f, -0.00629188f, 0.02744349f, 
    0.02892422f, -0.03302988f, -0.02245240f, 0.02288429f, 0.00421543f, 0.00866826f, -0.02014115f, -0.04500822f, 
    0.02097707f, -0.02537043f, -0.03651056f, 0.01677288f, -0.00386587f, -0.02666284f, -0.01594171f, -0.01270098f, 
    -0.04331326f, 0.01970801f, -0.00608635f, 0.00994106f, -0.02416831f, -0.00165657f, -0.01790238f, 0.01632061f, 
    0.02509400f, -0.01243783f, -0.03993303f, 0.01433276f, -0.04070562f, 0.03183291f, -0.02827013f, 0.02014069f, 
    -0.00118770f, -0.01928686f, 0.00803603f, -0.03273832f, -0.00219053f, 0.01814637f, 0.00324697f, 0.01876501f, 
    -0.01829837f, -0.02391742f, -0.03402467f, -0.02739870f, -0.02022468f, -0.02283879f, 0.02635599f, 0.00439542f, 
    -0.01546457f, -0.03611083f, -0.00547356f, 0.02713684f, 0.03128657f, -0.00847002f, -0.01062468f, 0.00961358f, 
    0.00437021f, -0.02356137f, -0.02223539f, 0.00923823f, -0.01928224f, 0.00766792f, 0.01829999f, 0.02888542f, 
    0.00763883f, 0.02358489f, 0.01469770f, 0.02341902f, -0.03520740f, 0.02608391f, 0.01380456f, 0.03043789f, 
    0.02902966f, 0.00144256f, -0.02649739f, -0.03967730f, -0.01814953f, -0.03093599f, -0.04315138f, -0.01433418f, 
    -0.00704046f, 0.00878419f, 0.00162248f, -0.00715224f, -0.03058831f, 0.01299928f, -0.00541454f, 0.03053656f, 
    -0.00817617f, -0.03206331f, -0.04451367f, 0.02201834f, -0.00898402f, 0.02385474f, 0.00487325f, -0.02605168f, 
    -0.01326561f, -0.03065203f, 0.02274438f, -0.01600456f, -0.04393118f, -0.03240813f, 0.00311128f, 0.01299379f, 
    -0.03865878f, -0.02576081f, 0.02120112f, -0.00310376f, -0.01368349f, -0.03471723f, -0.04031676f, 0.00310956f, 
    -0.03284349f, -0.00134554f, 0.02858517f, -0.00565541f, 0.02033610f, 0.00803253f, 0.01413825f, -0.03771857f, 
    -0.03934672f, -0.01582434f, -0.02346305f, -0.00573058f, 0.02887758f, -0.02175845f, -0.00778553f, 0.00115433f, 
    -0.00312956f, 0.00435247f, 0.02842399f, -0.01534690f, -0.01660054f, -0.03768332f, 0.01638837f, 0.02592098f, 
    -0.01476294f, 0.01249404f, -0.02901169f, -0.01354288f, 0.01041545f, -0.03878571f, 0.02586587f, 0.00578593f, 
    0.01693339f, -0.03254834f, -0.00844167f, 0.00269878f, -0.03224728f, 0.00376692f, -0.03911968f, -0.01607453f, 
    -0.00497561f, 0.00231541f, -0.00202260f, -0.01691523f, -0.00766615f, 0.00345663f, 0.01554068f, -0.02912688f, 
    -0.00736585f, 0.03079445f, -0.04022890f, 0.02091536f, -0.01078846f, 0.01368624f, 0.00113414f, -0.02559818f, 
    -0.00409137f, 0.02745788f, -0.04128201f, -0.00111709f, 0.02027935f, -0.04308383f, -0.00422575f, -0.01660855f, 
    0.02150706f, -0.02227391f, -0.00951870f, 0.00177938f, -0.00458148f, 0.01938890f, -0.02529022f, -0.00910151f, 
    0.00032035f, 0.03221983f, -0.01558072f, 0.02468024f, -0.01395218f, 0.01207559f, 0.01106848f, 0.01082809f, 
    0.01729984f, 0.01850198f, 0.02378442f, -0.02510447f, 0.00663436f, -0.04468828f, -0.00407362f, -0.02461000f, 
    0.00979658f, 0.02292709f, -0.02658949f, 0.01416291f, -0.04134977f, 0.00260724f, -0.01911104f, -0.01815915f, 
    0.00049035f, -0.03427364f, 0.02812370f, 0.02539575f, -0.02711789f, -0.03685323f, -0.01383144f, -0.00061570f, 
    -0.02820728f, 0.01784841f, -0.03942170f, 0.01182743f, -0.01289688f, 0.01402508f, -0.02594518f, 0.00073701f, 
    -0.02959685f, -0.03941907f, -0.01982276f, -0.03920654f, -0.03321627f, 0.01085462f, -0.04375303f, -0.02347676f, 
    -0.00799919f, -0.01604201f, 0.00266361f, -0.03811305f, 0.02515328f, -0.02650526f, -0.04506306f, -0.04434762f, 
    -0.03472216f, -0.02880956f, -0.02908742f, -0.00034199f, -0.01912712f, -0.01874093f, -0.04478907f, 0.01937825f, 
    -0.03376645f, 0.03052874f, -0.00740700f, 0.00398149f, 0.02781828f, -0.01561902f, -0.01983049f, 0.01922946f, 
    0.01171515f, 0.00710875f, -0.00905692f, -0.00548456f, 0.00920519f, -0.01878412f, -0.03013716f, -0.03450642f, 
    -0.02105182f, 0.00821699f, -0.03188652f, 0.01411899f, -0.01846524f, -0.00139917f, 0.01342923f, -0.02288162f, 
    0.04020973f, 0.00797334f, 0.00538024f, -0.01235514f, -0.03386989f, -0.01486892f, -0.00818224f, 0.02676395f, 
    0.02868709f, 0.03182078f, -0.04129982f, 0.02701532f, -0.00300566f, -0.03371154f, -0.03356238f, -0.01525208f, 
    -0.03863812f, -0.03644073f, -0.00916979f, -0.03935157f, -0.04457141f, 0.03081862f, -0.00169441f, -0.00380068f, 
    -0.01382500f, -0.01135894f, 0.01306851f, 0.02028831f, -0.04027616f, -0.01036252f, 0.01574959f, 0.02291243f, 
    0.01456744f, 0.00406971f, 0.00826732f, 0.00258547f, 0.02437065f, -0.00958544f, -0.04040565f, 0.02688516f, 
    0.00431996f, 0.01660844f, -0.02696777f, 0.01703925f, 0.02921908f, -0.00351614f, 0.02565338f, -0.03229158f, 
    -0.03269146f, 0.03308213f, 0.01247417f, 0.01772931f, -0.03926964f, -0.04459197f, 0.00111546f, 0.02876518f, 
    -0.00257342f, -0.00116970f, -0.01058542f, -0.03602553f, 0.02302920f, 0.01925119f, -0.01230715f, -0.01175210f, 
    -0.00791716f, -0.01040742f, -0.01466903f, -0.02781418f, -0.01028713f, -0.02158242f, -0.02868244f, -0.02501768f, 
    0.19711904f, 0.25644293f, 0.25308058f, 0.05931743f, 0.01513082f, 0.13685726f, 0.01958273f, 0.07859334f, 
    0.04042290f, 0.08636110f, 0.11079702f, 0.05801583f, -0.00094653f, 0.02527637f, -0.03163114f, 0.11063559f, 
    0.01077013f, -0.16280195f, -0.01029782f, 0.13356377f, 0.18349349f, 0.09707236f, 0.25731707f, 0.11947340f, 
    0.19063511f, -0.04814189f, 0.29523075f, 0.02985995f, -0.04898340f, 0.19617651f, 0.08439288f, -0.00379207f, 
    0.04901806f, 0.11072622f, 0.04166985f, 0.06184014f, 0.02754606f, 0.10793948f, -0.02106761f, 0.12565869f, 
    0.05215167f, -0.20022468f, -0.37792966f, -0.01291636f, 0.21863806f, 0.02777803f, -0.01822729f, 0.03270458f, 
    -0.05028670f, -0.00572425f, 0.17089860f, 0.00945300f, -0.03354606f, 0.16909133f, -0.02271796f, 0.18826678f, 
    0.12442594f, 0.22304887f, 0.10889108f, 0.15959686f, -0.06652267f, -0.13904007f, -0.05390161f, 0.17936285f, 
    -0.03436797f, -0.05770981f, -0.15782714f, 0.03250803f, -0.03240022f, -0.10375845f, 0.07964776f, 0.05183242f, 
    0.08716669f, -0.05636802f, 0.03165459f, 0.04300460f, 0.17292202f, 0.25830954f, 0.08494320f, 0.27443299f, 
    -0.13313797f, 0.00066272f, 0.02326222f, 0.03537608f, -0.02723039f, -0.00453975f, 0.00413654f, -0.12222082f, 
    0.07669007f, 0.00725469f, 0.08302730f, 0.03956031f, 0.00404272f, -0.01045918f, 0.08217777f, 0.01408124f, 
    0.12603988f, 0.14167891f, 0.11623392f, 0.15359443f, -0.42967871f, -0.39197806f, -0.15237284f, -0.24736941f, 
    0.13632001f, -0.18103155f, -0.00532732f, -0.04319280f, 0.08065846f, -0.14365259f, 0.01890644f, -0.02795280f, 
    -0.05415114f, -0.09150641f, -0.09358943f, 0.12312049f, 0.01622433f, -0.04851414f, 0.16674307f, 0.05587163f, 
    -0.25147948f, 0.04619346f, -0.20501420f, 0.09172145f, -0.02888937f, 0.04027419f, 0.04729668f, -0.05519680f, 
    -0.07814864f, -0.05859856f, 0.06847393f, -0.00788500f, -0.08106765f, -0.11765207f, 0.01161634f, 0.11073484f, 
    -0.03942920f, -0.08623824f, -0.07657717f, 0.05466954f, -0.15100439f, 0.44214636f, 0.01023231f, 0.18228158f, 
    0.13645774f, -0.05853435f, 0.12706046f, -0.03032793f, -0.08679819f, 0.22268945f, -0.03439389f, 0.10498557f, 
    0.02354124f, -0.03037274f, 0.04595449f, -0.05867461f, 0.04120362f, -0.05748571f, -0.03590473f, -0.08959688f, 
    0.15712735f, 0.48298311f, 0.22182944f, -0.01784531f, -0.03978631f, 0.02298896f, 0.06999024f, 0.12328511f, 
    0.06046546f, 0.25746116f, -0.03744553f, 0.05069753f, -0.00743562f, 0.01532033f, -0.14209501f, 0.03446028f, 
    -0.21587385f, -0.03721685f, -0.13518025f, -0.18940505f, 0.08182629f, 0.27322933f, 0.32050017f, 0.17869340f, 
    0.29939914f, 0.02746929f, 0.09311590f, 0.08417725f, 0.04699526f, 0.16666128f, 0.07543059f, 0.04829539f, 
    -0.02123266f, -0.00734544f, -0.05270111f, 0.05058281f, 0.05349313f, 0.00493468f, 0.04150166f, 0.01901201f, 
    -0.00312095f, -0.03606865f, -0.09727321f, 0.01748367f, 0.35789117f, 0.14764519f, 0.05574911f, -0.22184515f, 
    -0.20585941f, -0.22716190f, 0.18955092f, 0.12996396f, 0.14912193f, 0.17556167f, 0.02698664f, 0.19272514f, 
    0.09120484f, -0.07700319f, -0.15909828f, -0.05839607f, -0.05157863f, -0.01236904f, 0.01496641f, -0.17529535f, 
    0.11531547f, -0.07228505f, -0.01668287f, -0.06670537f, -0.05470581f, 0.00267462f, -0.02436937f, 0.05912419f, 
    0.01472262f, 0.00842420f, 0.07983683f, -0.01033300f, 0.08901306f, 0.02974356f, 0.10185970f, 0.18275300f, 
    0.08439745f, -0.03356368f, 0.07728740f, -0.04042397f, -0.21815798f, -0.02273729f, -0.21088964f, -0.04292905f, 
    -0.13516986f, -0.22552085f, -0.01321894f, 0.05911273f, 0.01007775f, 0.02752440f, 0.15000002f, -0.02197962f, 
    -0.13472226f, -0.12616941f, -0.07393308f, -0.16122808f, -0.21936810f, -0.03854261f, 0.15132406f, -0.17973347f, 
    0.09364738f, 0.00565191f, 0.16783659f, 0.05084944f, -0.09117106f, 0.11617001f, -0.05808362f, 0.00063438f, 
    -0.05055313f, -0.11220334f, -0.16781102f, -0.09814896f, -0.16476496f, -0.13193974f, -0.17133972f, -0.16021113f, 
    -0.03356892f, 0.27592227f, -0.03312001f, -0.06882492f, 0.05229870f, 0.01583045f, -0.06067083f, 0.02736776f, 
    -0.03054740f, -0.00076601f, 0.10155252f, -0.01130366f, 0.10076762f, 0.14902641f, -0.02687444f, 0.19668919f, 
    -0.38156557f, -0.02059730f, -0.09473956f, -0.18836990f, -0.17287256f, 0.13119479f, 0.05098493f, 0.33358160f, 
    -0.01411007f, -0.00323389f, -0.11086682f, -0.13553295f, -0.02824883f, -0.21538520f, 0.05123883f, -0.06165050f, 
    0.00477376f, 0.03391827f, 0.00419039f, 0.08538586f, 0.05061179f, 0.06354351f, -0.12989338f, -0.00541450f, 
    -0.12762201f, 0.13977547f, -0.13887912f, -0.20902975f, -0.14179043f, 0.05099268f, 0.08002698f, -0.01450326f, 
    -0.02916960f, 0.15539880f, 0.05265888f, -0.00994231f, -0.02576051f, 0.05978757f, -0.02755536f, 0.00159797f, 
    -0.08866479f, -0.14973152f, -0.00464333f, -0.21197259f, -0.41947648f, 0.22120695f, 0.14047751f, 0.11039453f, 
    0.01984193f, 0.07466670f, -0.04854073f, -0.01065394f, -0.14487748f, -0.00166734f, -0.01428293f, -0.01622308f, 
    -0.07409818f, -0.01485950f, 0.04260732f, 0.04832841f, 0.09022604f, 0.01492960f, -0.11846143f, 0.04949595f, 
    0.11700712f, 0.04188685f, 0.11761940f, 0.10921176f, 0.01957561f, -0.02107128f, 0.11929077f, -0.11191925f, 
    -0.12300988f, -0.06164417f, 0.08244965f, 0.04500294f, 0.07319661f, 0.00258223f, 0.14728847f, -0.01608915f, 
    0.08353941f, 0.04784523f, 0.03459082f, 0.02833664f, 0.40776539f, 0.50270569f, 0.16406322f, 0.27762976f, 
    -0.09495988f, -0.11880129f, -0.23133673f, -0.13319157f, -0.15776609f, -0.30803448f, 0.08364932f, 0.05268156f, 
    0.02531802f, 0.07694086f, 0.09365283f, 0.04452005f, 0.07110152f, 0.06850059f, 0.02477772f, 0.01308813f, 
    0.09456302f, 0.14487849f, 0.06005583f, 0.25850606f, -0.02785889f, 0.23373692f, -0.00812534f, -0.04337566f, 
    -0.04038984f, 0.17323913f, 0.04807566f, 0.01506937f, -0.01433768f, 0.00710433f, 0.22751647f, 0.03019549f, 
    0.19018064f, 0.06987844f, 0.00875538f, 0.14015843f, 0.03628507f, -0.43914399f, -0.10205561f, -0.44507107f, 
    0.12297940f, -0.04088011f, -0.15481935f, -0.13898237f, 0.11780419f, -0.00789603f, 0.07266787f, 0.09064613f, 
    -0.18739662f, -0.00206465f, -0.06129816f, 0.05165124f, 0.07921173f, 0.05978957f, 0.22775050f, 0.18427779f, 
    0.15471861f, 0.15317379f, 0.03548698f, -0.12009154f, -0.21160775f, 0.00913812f, 0.02335178f, -0.09834267f, 
    -0.13887097f, 0.07676544f, 0.06718108f, 0.00679641f, 0.10077502f, -0.02297394f, 0.08848910f, 0.09874679f, 
    -0.07610334f, -0.11665060f, -0.17141332f, -0.39266956f, -0.28234655f, -0.04105812f, -0.38420105f, 0.17524201f, 
    -0.01170427f, 0.06884898f, 0.17617795f, 0.13143502f, -0.23396856f, 0.15839542f, -0.10826587f, -0.09979720f, 
    -0.01756968f, -0.10696885f, -0.05151262f, -0.08501191f, -0.01933289f, -0.14035794f, -0.06526723f, -0.12081473f, 
    0.12013476f, -0.06851499f, 0.15238763f, 0.26813006f, -0.09751662f, 0.06141148f, -0.02246035f, 0.09629770f, 
    0.12674256f, -0.01752060f, -0.16090930f, -0.00690737f, -0.04854590f, 0.02942654f, 0.33998314f, 0.05840997f, 
    0.08457095f, -0.07403579f, 0.02160997f, 0.09103148f, -0.39553967f, 0.16653025f, -0.13229381f, 0.25635809f, 
    0.05245805f, -0.07171486f, 0.05433498f, 0.08138550f, -0.12252730f, -0.15205498f, 0.05631077f, -0.00347704f, 
    -0.10158753f, -0.07222512f, -0.02565114f, 0.08530495f, 0.16975513f, -0.01964500f, 0.04657640f, 0.06658044f, 
    -0.01427453f, -0.07662492f, 0.00912967f, -0.23700322f, 0.14110324f, -0.13190863f, -0.05494856f, -0.13501129f, 
    -0.03792915f, -0.19220810f, 0.04494896f, 0.09702101f, -0.05636309f, -0.03810163f, 0.12317981f, 0.14123167f, 
    -0.14207341f, -0.01359795f, -0.12653299f, -0.09056216f, 0.23378630f, -0.11303116f, 0.14311376f, -0.19738370f, 
    -0.19301753f, -0.04566509f, -0.03005536f, 0.15288888f, 0.12723084f, 0.00839686f, 0.03366650f, -0.04091137f, 
    -0.11025256f, -0.00518796f, 0.14143631f, -0.16951430f, 0.06349839f, 0.11171179f, 0.13944654f, -0.08498901f, 
    0.04444870f, 0.13177931f, -0.10719185f, -0.18479976f, -0.14421576f, -0.15379941f, -0.12725744f, 0.06664422f, 
    -0.03702376f, 0.10696197f, 0.12167145f, -0.00007974f, -0.01729529f, -0.05333323f, 0.03788891f, 0.21730082f, 
    0.05652915f, 0.03590102f, -0.09479995f, 0.01529241f, -0.05233318f, -0.29654247f, -0.26740256f, -0.15340051f, 
    0.27594054f, -0.33697820f, 0.00485228f, 0.15059617f, -0.02646657f, -0.17062375f, 0.06978694f, 0.16044021f, 
    0.09164658f, 0.05908719f, 0.18047746f, 0.25267038f, 0.08793314f, 0.26346099f, 0.18918824f, 0.01762174f, 
    0.45820302f, 0.43036437f, 0.20715949f, 0.23643672f, -0.04593603f, -0.00952601f, -0.25464073f, -0.17192349f, 
    -0.13468641f, -0.23328611f, 0.09805833f, 0.05547525f, 0.13449802f, 0.17160995f, 0.04270327f, -0.00884328f, 
    -0.02954644f, 0.10908042f, -0.07905989f, -0.07504581f, 0.11331566f, 0.28869128f, 0.08999061f, 0.21919933f, 
    0.26690045f, 0.01013639f, 0.06086065f, 0.06996401f, 0.18729794f, 0.35624909f, -0.08383477f, 0.09758519f, 
    -0.08104633f, -0.05708795f, -0.10177449f, 0.02837917f, 0.16416922f, 0.02466806f, 0.08598538f, 0.23987892f, 
    -0.02568237f, 0.00685951f, -0.04405140f, -0.00144511f, 0.02932088f, -0.03364878f, 0.02240991f, 0.00888657f, 
    0.02387649f, 0.02108160f, 0.02651085f, 0.02491942f, -0.03562560f, -0.03377516f, -0.00699910f, -0.01422724f, 
    -0.04149967f, -0.02765415f, -0.02976485f, -0.01818514f, -0.00459121f, -0.02190692f, 0.01244905f, 0.00694583f, 
    0.02343548f, -0.00833248f, -0.00885620f, 0.02686899f, -0.00785791f, -0.02088391f, -0.00876677f, -0.01359768f, 
    -0.03580786f, 0.02312970f, 0.00956125f, -0.01052268f, 0.01747677f, -0.03050128f, -0.03493566f, -0.00857155f, 
    0.02163594f, -0.03513525f, 0.02741870f, 0.03086937f, -0.02880775f, -0.02029813f, -0.02290457f, 0.00399052f, 
    -0.02219374f, 0.03210541f, 0.03361522f, 0.00829463f, 0.01898298f, 0.02243820f, -0.02845914f, 0.02818171f, 
    0.00175040f, -0.02202515f, -0.01698466f, -0.03800043f, -0.03136206f, -0.04245444f, -0.03807183f, -0.00257976f, 
    0.02395608f, -0.03458640f, -0.01688472f, 0.00004098f, 0.01722977f, 0.00891244f, 0.00304909f, -0.03016606f, 
    -0.03615710f, 0.00281246f, 0.04268815f, -0.02256069f, -0.03066641f, -0.03552597f, -0.02111869f, 0.01458792f, 
    -0.02763425f, -0.00941114f, -0.04069351f, -0.01418728f, -0.03286831f, -0.01751160f, -0.03521241f, -0.00957643f, 
    0.00659263f, 0.01559554f, -0.02287494f, 0.02821348f, -0.01704042f, 0.01995892f, 0.00150835f, -0.02453724f, 
    -0.02116277f, -0.04374942f, 0.00216687f, 0.03235564f, 0.03179085f, -0.02234088f, 0.02065116f, -0.02700462f, 
    0.00577713f, -0.03053096f, -0.01018627f, -0.03658085f, -0.01238338f, -0.01438424f, -0.03535962f, 0.03608985f, 
    -0.03330735f, 0.03342968f, 0.00772887f, 0.02519400f, -0.01270399f, -0.01225059f, -0.00516660f, -0.03671659f, 
    -0.02904073f, -0.03480401f, -0.00979829f, 0.02161906f, -0.00025307f, 0.02029858f, -0.00552668f, 0.01191325f, 
    -0.03446214f, -0.02903269f, -0.02017770f, 0.02204037f, -0.03624133f, -0.01102713f, 0.02863470f, -0.00944581f, 
    -0.04096274f, 0.02395317f, -0.01439251f, -0.00858035f, -0.03547906f, -0.02022500f, -0.02245598f, -0.00319089f, 
    -0.00161140f, 0.02721437f, 0.00213239f, -0.04277976f, -0.02962069f, -0.03020600f, 0.02965216f, 0.00021688f, 
    0.03725616f, -0.00888095f, -0.02788715f, 0.02063111f, -0.00775122f, -0.01850436f, -0.00007080f, -0.01155272f, 
    0.02524115f, 0.01337233f, -0.01606990f, 0.02582224f, -0.03398598f, -0.00583591f, 0.02789487f, 0.02721532f, 
    -0.02692742f, -0.03363620f, 0.02718917f, -0.03775942f, -0.02547666f, 0.00150786f, -0.02198014f, 0.02273737f, 
    0.01113856f, -0.04089586f, 0.01960912f, 0.04081253f, 0.02815215f, 0.00542324f, -0.00277470f, -0.00471336f, 
    -0.04048606f, -0.03346739f, 0.02192358f, -0.01552342f, 0.02440806f, 0.02107335f, 0.01469379f, -0.01538729f, 
    0.01338532f, 0.00175163f, -0.03879110f, 0.00431706f, -0.03279388f, 0.00369953f, 0.00834492f, -0.01117925f, 
    0.02276629f, -0.04427183f, 0.03118733f, 0.01203755f, -0.02006121f, -0.03164810f, 0.01348760f, 0.01888762f, 
    -0.04227898f, -0.01422240f, -0.03271049f, -0.01425168f, 0.00134580f, 0.00711409f, 0.01306051f, -0.03959850f, 
    0.01905719f, 0.00968271f, -0.01847558f, -0.01880884f, -0.03056496f, -0.04335033f, 0.00670423f, -0.01028195f, 
    0.02993009f, 0.01766544f, 0.03056664f, 0.00626088f, 0.03494410f, -0.03101862f, -0.03793470f, -0.02397611f, 
    -0.02195253f, -0.03513747f, -0.01994544f, -0.00597060f, 0.00209276f, -0.03243966f, 0.03042309f, 0.03380785f, 
    -0.02021686f, 0.03245500f, -0.01368196f, 0.02871177f, 0.00385817f, -0.02137995f, 0.01576107f, 0.02502711f, 
    0.02366945f, 0.00851892f, -0.00438713f, 0.02980317f, 0.03075689f, -0.01259448f, -0.04295344f, 0.00604857f, 
    -0.01423776f, 0.03607418f, 0.02242335f, -0.03478236f, 0.00317887f, 0.02380508f, 0.02861912f, -0.00094455f, 
    -0.03583792f, 0.01988333f, -0.01129708f, -0.02212706f, -0.03214047f, -0.00441703f, 0.00585549f, -0.02869813f, 
    -0.03128717f, 0.00178996f, 0.02589456f, -0.00449597f, 0.02592145f, -0.00246922f, 0.01949392f, -0.01549318f, 
    -0.01838070f, 0.02523400f, 0.00293698f, -0.02139881f, -0.03126259f, 0.03315618f, 0.01006062f, -0.00478325f, 
    -0.02401620f, -0.00593398f, 0.00497238f, -0.00290652f, -0.01062616f, -0.01554133f, 0.03142105f, -0.03061308f, 
    -0.00301400f, -0.02854046f, 0.01936055f, -0.01437542f, -0.01180565f, -0.03768356f, -0.02801580f, 0.02166686f, 
    0.01822555f, 0.00288672f, -0.00967384f, 0.00596849f, -0.01002510f, -0.02717621f, 0.01533562f, 0.02197577f, 
    -0.00363528f, 0.01409024f, 0.01722817f, -0.02152966f, -0.00436517f, -0.01885219f, -0.03352061f, 0.00687445f, 
    0.02237079f, 0.00126925f, -0.03890464f, 0.03207044f, -0.01185136f, 0.02747702f, 0.01881875f, 0.01584696f, 
    0.02882093f, -0.01501269f, -0.00752700f, 0.02004340f, -0.01324353f, 0.00990986f, 0.01279102f, 0.01152026f, 
    0.00300693f, 0.02679647f, -0.02317817f, 0.03392157f, 0.03472531f, 0.02528939f, 0.02059001f, -0.00047418f, 
    0.00557308f, -0.02687581f, 0.02054021f, 0.00764315f, 0.01563562f, 0.02126225f, 0.00880487f, -0.00777824f, 
    0.01491962f, 0.00985763f, 0.01998477f, 0.00585637f, -0.03771944f, -0.01583543f, -0.01544348f, 0.01038307f, 
    -0.03640771f, 0.03180664f, 0.01976180f, 0.00218360f, 0.02208826f, 0.00606618f, -0.02761051f, -0.02615457f, 
    -0.00015005f, 0.01821418f, -0.01962821f, 0.03045952f, -0.00979718f, 0.00800019f, 0.02563283f, -0.00174939f, 
    -0.00016225f, 0.03118794f, 0.01095604f, -0.00037984f, 0.00968659f, -0.00959357f, 0.02339979f, -0.03287376f, 
    -0.02695727f, 0.02736123f, -0.01713647f, -0.00014517f, 0.01834308f, 0.01221427f, 0.01087113f, 0.00383872f, 
    -0.01772801f, 0.00699825f, 0.00146830f, -0.03626871f, -0.01210186f, -0.00273555f, 0.03726678f, 0.00823295f, 
    0.02983043f, -0.01767153f, -0.01454117f, -0.03993503f, -0.00188618f, 0.03071233f, -0.00323783f, 0.00472235f, 
    -0.01592147f, 0.00285000f, -0.01167086f, 0.02677014f, -0.03116916f, 0.02790942f, 0.02724283f, -0.03641860f, 
    0.00320753f, 0.01462528f, -0.00949629f, 0.01566245f, -0.00905054f, 0.01544604f, 0.02447497f, -0.02773153f, 
    0.03269281f, -0.01730435f, 0.00928734f, 0.02021165f, -0.04282990f, 0.00119960f, 0.00062305f, 0.01817230f, 
    -0.04104375f, -0.04052791f, -0.02687093f, -0.03157492f, -0.01127144f, -0.03024919f, -0.02167137f, 0.03298121f, 
    -0.02405879f, -0.03405502f, 0.02275494f, -0.00716883f, 0.00362467f, -0.04141632f, -0.02779772f, -0.03292778f, 
    0.01484294f, -0.03355986f, -0.01035360f, 0.01636797f, -0.02276087f, 0.00102208f, -0.03892241f, 0.00032315f, 
    -0.01847833f, 0.02341689f, 0.01587247f, 0.02843202f, -0.03192120f, -0.03277728f, -0.04064514f, -0.04033851f, 
    0.03115470f, -0.01675217f, -0.02109858f, 0.01148973f, -0.01806709f, -0.03527181f, -0.03563052f, 0.03333766f, 
    0.02264008f, 0.01533913f, -0.00557265f, -0.01692364f, -0.03004786f, -0.01090632f, -0.01042506f, 0.01129735f, 
    -0.04259108f, -0.00688877f, -0.00502690f, -0.00046136f, -0.03137714f, 0.02227122f, -0.01820563f, -0.04372193f, 
    -0.03503497f, -0.00601327f, -0.02575190f, -0.00403162f, 0.00720583f, -0.01060793f, -0.02810034f, 0.01484409f, 
    -0.02608184f, 0.00772819f, -0.01901451f, 0.00811920f, -0.00590478f, -0.01888934f, 0.01826366f, -0.01461970f, 
    0.01038664f, 0.00356539f, -0.02291390f, -0.02151929f, 0.00146874f, 0.01750427f, -0.02367657f, -0.02595404f, 
    -0.00461831f, 0.00410498f, -0.04113144f, -0.01682403f, -0.00569100f, -0.03659578f, -0.02800106f, -0.01048579f, 
    -0.00456480f, 0.02712072f, 0.00632445f, -0.00810185f, 0.02310500f, 0.03269983f, -0.01047320f, -0.02582249f, 
    0.03338773f, -0.02931718f, 0.01030233f, -0.02359122f, 0.01131012f, 0.01604632f, 0.01164133f, -0.02679009f, 
    0.03767733f, -0.01162586f, -0.00958106f, 0.02758939f, 0.00227155f, -0.00743949f, -0.02510085f, 0.00915891f, 
    0.02099201f, -0.03953332f, -0.03446832f, -0.00795563f, 0.02748304f, 0.01624672f, -0.01591846f, 0.00198192f, 
    -0.03979019f, -0.03982205f, 0.01276714f, -0.00832978f, 0.01885910f, 0.01658303f, 0.02952018f, 0.03268104f, 
    -0.00398754f, 0.01740197f, -0.00047428f, -0.02366628f, -0.01963522f, 0.00712159f, -0.00458428f, 0.01555267f, 
    -0.01592684f, -0.03404977f, 0.00051879f, -0.02562650f, -0.00941396f, 0.01270598f, 0.01613675f, 0.01556256f, 
    0.01654404f, -0.01509418f, 0.02986959f, 0.03644885f, -0.01864935f, -0.01503026f, -0.03995957f, -0.01300343f, 
    -0.04542965f, 0.02294208f, 0.01781433f, -0.00342791f, 0.00139275f, -0.02629524f, -0.04075079f, -0.01462254f, 
    0.00052362f, -0.01975156f, -0.00140762f, 0.02990407f, 0.02052595f, -0.03192740f, 0.01702805f, 0.03075939f, 
    -0.01280438f, 0.02232539f, 0.02009035f, -0.03294024f, -0.00919882f, -0.02582985f, 0.01732893f, -0.00911628f, 
    -0.03282744f, -0.03234507f, -0.00773061f, -0.01283988f, -0.00848894f, -0.02417487f, -0.02476342f, -0.00014586f, 
    -0.00373816f, -0.01913210f, 0.00307981f, -0.03395555f, -0.04361627f, 0.01250107f, 0.02757904f, -0.00604148f, 
    -0.02387427f, 0.02222290f, -0.04241861f, -0.01111651f, 0.00825571f, -0.03410871f, -0.02662366f, 0.02499840f, 
    -0.01896712f, 0.00380797f, -0.03496105f, 0.02238592f, -0.03723818f, 0.02977964f, 0.00743322f, 0.00294844f, 
    0.00081694f, 0.01469296f, -0.03899648f, -0.03530486f, -0.01820740f, 0.02157664f, -0.01434171f, 0.02846764f, 
    -0.03239053f, -0.01303060f, -0.02828676f, 0.00405472f, 0.01468267f, -0.00138128f, -0.01852066f, -0.03263939f, 
    0.00940285f, 0.01990757f, -0.02796565f, -0.02809195f, -0.03404729f, -0.00086460f, -0.03642513f, 0.00188846f, 
    -0.01226035f, -0.00292235f, -0.01557020f, -0.00710860f, -0.00891203f, 0.00368549f, -0.04115072f, -0.03898482f, 
    -0.03125222f, 0.02112861f, -0.04197268f, 0.00553268f, -0.03691295f, -0.01824776f, -0.03785444f, 0.00116762f, 
    0.01869950f, 0.01516996f, -0.04449786f, -0.02813785f, -0.03825684f, 0.01473405f, -0.03638387f, -0.02671366f, 
    -0.00529999f, 0.02973857f, 0.00615524f, 0.00097684f, -0.04332909f, 0.01997509f, 0.02157546f, 0.01502872f, 
    -0.02137187f, 0.01309984f, -0.04256509f, -0.03309341f, -0.00727157f, 0.01988901f, -0.03868246f, -0.00674544f, 
    0.03017822f, 0.01401063f, 0.00262172f, 0.00988157f, -0.00855033f, -0.03859971f, -0.01225130f, 0.01729643f, 
    -0.00965330f, 0.02113360f, -0.00658703f, 0.02726465f, -0.00578056f, 0.00692842f, 0.02071966f, -0.01632785f, 
    0.01525620f, -0.00296049f, -0.03316021f, -0.03370305f, -0.04366589f, -0.03125846f, -0.01688724f, 0.02452660f, 
    -0.02433923f, 0.02523699f, -0.03126074f, 0.02987695f, -0.02087870f, 0.02476671f, 0.02432934f, -0.01731461f, 
    -0.01906942f, 0.01775239f, -0.01655729f, -0.00801294f, -0.04013656f, 0.01875841f, 0.01705644f, 0.00735925f, 
    0.02066798f, -0.01428656f, 0.00662989f, -0.01682432f, 0.00677337f, -0.01556707f, -0.00145237f, 0.02650166f, 
    -0.01271473f, -0.04044506f, 0.02413995f, -0.03413245f, 0.02049484f, 0.03005338f, 0.00528267f, 0.03066058f, 
    -0.04324811f, -0.03378142f, -0.00335095f, -0.01807756f, -0.02875177f, 0.02298068f, -0.03301942f, 0.00311271f, 
    0.02656545f, 0.00458861f, -0.02713441f, -0.03776176f, -0.02433135f, 0.02360513f, -0.02125899f, -0.01027201f, 
    -0.00664011f, -0.03055245f, -0.03455300f, -0.00402485f, -0.03823643f, 0.00641330f, -0.00771439f, 0.01792472f, 
    -0.03996310f, -0.03813281f, -0.00587523f, 0.00048856f, -0.03473624f, -0.02412902f, -0.01979866f, -0.03334410f, 
    0.01102436f, -0.02817139f, 0.00420971f, -0.01909571f, -0.01626532f, 0.00157958f, -0.01258479f, -0.02720437f, 
    0.00502872f, 0.02686668f, -0.03575467f, 0.00945891f, -0.01191559f, 0.02272721f, -0.03140324f, 0.00692301f, 
    0.02737823f, 0.01230292f, 0.02992612f, 0.01109746f, -0.02066008f, -0.01899854f, -0.02016660f, -0.02345234f, 
    -0.01075846f, 0.00938061f, 0.03135670f, -0.03956572f, 0.02538867f, 0.00997177f, -0.01285285f, -0.02259066f, 
    0.01867812f, 0.02748494f, -0.00042376f, -0.01896725f, -0.00885522f, -0.00661382f, 0.02257901f, -0.04539362f, 
    0.00094533f, 0.00548173f, 0.00835721f, 0.01661466f, -0.03530103f, 0.00646258f, 0.01641965f, 0.00867489f, 
    -0.04535015f, 0.00191469f, -0.02457157f, 0.01131486f, 0.02632125f, 0.02449760f, -0.03376751f, 0.02915358f, 
    -0.04256393f, -0.00753295f, -0.00612301f, -0.02654684f, -0.04399340f, 0.02594396f, -0.00608388f, -0.01595894f, 
    -0.02881238f, -0.00217366f, 0.01975165f, -0.01749819f, -0.03699262f, 0.02388986f, 0.02386515f, -0.00691660f, 
    -0.04067194f, -0.03496122f, -0.00637903f, 0.03201251f, -0.04463871f, -0.01708051f, 0.02594610f, 0.01088579f, 
    -0.04170676f, -0.03629706f, -0.03380810f, -0.01474334f, -0.02809255f, -0.02609028f, 0.02685042f, -0.02350541f, 
    -0.01023174f, 0.02563761f, -0.01936812f, 0.01476263f, -0.03967650f, -0.02650744f, 0.02005706f, 0.02788084f, 
    -0.02869302f, -0.00174810f, 0.00893213f, 0.01198767f, -0.01055384f, 0.02313648f, -0.02451632f, -0.03796613f, 
    -0.02681725f, 0.02846611f, 0.01314918f, -0.04194249f, -0.01861212f, -0.02537449f, -0.01215741f, -0.02798056f, 
    0.00598585f, -0.01628470f, -0.02523061f, 0.01395596f, -0.02919013f, -0.00574719f, 0.02034016f, 0.02889734f, 
    -0.02887960f, -0.02540692f, -0.03491402f, -0.03178912f, 0.00013033f, -0.03564747f, -0.01618095f, -0.03042338f, 
    0.01105766f, 0.00477952f, -0.02371198f, -0.00853414f, -0.00450882f, 0.03287828f, 0.00107564f, -0.03587108f, 
    -0.01860274f, -0.02060150f, 0.00105193f, -0.04246828f, 0.02157621f, 0.01147762f, 0.00175459f, 0.02259945f, 
    0.00567100f, 0.03009401f, -0.03928419f, -0.02540589f, 0.00237156f, -0.03700290f, 0.02475885f, -0.02705680f, 
    -0.00528105f, 0.01794207f, 0.02403859f, 0.01129013f, -0.04097050f, 0.00424978f, -0.00839421f, -0.01838862f, 
    -0.02756417f, -0.00662880f, -0.00378499f, 0.02446574f, -0.01254177f, -0.04485552f, 0.02134254f, 0.01048884f, 
    0.02061431f, -0.03142937f, 0.01086850f, -0.03106596f, -0.00592595f, -0.03794262f, -0.02484893f, -0.03021712f, 
    -0.01021086f, -0.04653979f, 0.00188596f, 0.01902574f, 0.00179514f, 0.01585767f, -0.00214025f, 0.00547784f, 
    -0.02247482f, -0.02462351f, 0.00703677f, -0.03778935f, 0.02593843f, -0.01620979f, -0.03252182f, -0.02963901f, 
    0.02205189f, 0.00532810f, 0.00671318f, -0.00815565f, -0.02723565f, -0.02207185f, 0.02783423f, 0.02793484f, 
    0.00567828f, 0.02713738f, -0.00798973f, 0.00500857f, 0.02976253f, -0.03261064f, -0.02015881f, -0.01912300f, 
    0.02446437f, 0.00707291f, -0.00491581f, -0.02558557f, -0.01605116f, 0.01510153f, 0.02009337f, 0.00491299f, 
    -0.01006004f, -0.03046000f, 0.01719318f, -0.01659755f, -0.00103551f, 0.00053301f, 0.01847120f, -0.04254983f, 
    -0.00016226f, 0.01494020f, 0.01135809f, -0.00777470f, 0.02517092f, -0.04079703f, -0.01510749f, 0.02776034f, 
    -0.02547249f, 0.01851704f, 0.00701210f, -0.01620245f, 0.00602160f, -0.02293463f, 0.01442215f, 0.01642739f, 
    0.01738782f, -0.04279665f, 0.01044646f, 0.01879941f, -0.01870749f, -0.01747873f, 0.00456244f, 0.01852768f, 
    0.00875850f, 0.02564728f, 0.02996100f, -0.02343653f, -0.00611408f, -0.03195568f, 0.00314964f, -0.00146741f, 
    0.02748560f, -0.00918929f, -0.01035609f, -0.01219058f, -0.03696438f, 0.00085987f, -0.00451302f, 0.01988983f, 
    0.00560379f, -0.00409960f, -0.01189830f, -0.03469019f, -0.03239078f, -0.00514394f, -0.02236368f, 0.00443417f, 
    -0.00835895f, 0.01307562f, -0.00660487f, 0.02689582f, -0.01453907f, -0.04262836f, -0.00312350f, -0.00449331f, 
    -0.03153365f, 0.00364929f, -0.01828152f, -0.03152411f, -0.02316995f, -0.04365210f, 0.00260350f, -0.01723283f, 
    -0.01217374f, -0.01552124f, 0.02092623f, -0.01584678f, -0.02669290f, 0.02421484f, -0.00666725f, -0.00243020f, 
    0.02757911f, -0.00537686f, 0.02332256f, -0.01156889f, 0.01255213f, -0.00818964f, -0.01814015f, -0.03749875f, 
    -0.04050348f, -0.02054159f, -0.01886256f, -0.00464796f, -0.01939215f, 0.00184288f, -0.01011003f, 0.00781359f, 
    -0.00046498f, -0.03275772f, 0.02624984f, 0.02415469f, -0.03961987f, -0.03228548f, -0.01747169f, -0.02208071f, 
    0.00188844f, -0.01457887f, 0.00150113f, -0.03487135f, 0.02231033f, -0.00140370f, -0.00211908f, 0.00579096f, 
    0.01189656f, -0.02999584f, -0.02204095f, 0.00010258f, -0.04290104f, -0.00935625f, 0.02040693f, -0.01869442f, 
    -0.03735746f, -0.03509121f, 0.01008391f, 0.01157848f, -0.04116336f, -0.01794429f, 0.00306122f, 0.03296006f, 
    -0.03168078f, 0.00390189f, -0.00718356f, 0.02642195f, -0.00681653f, 0.01476689f, -0.01427822f, 0.00185731f, 
    -0.03608213f, -0.04142848f, -0.01760079f, -0.01322524f, -0.02293921f, 0.02175970f, 0.02267698f, -0.04423375f, 
    -0.04100640f, 0.01506755f, 0.02883782f, -0.03260689f, 0.00183555f, -0.03716604f, -0.03178456f, -0.01426671f, 
    -0.00778205f, -0.00077827f, 0.02260772f, -0.00245287f, 0.00847279f, -0.03191552f, -0.00586651f, -0.03821656f, 
    0.00132505f, -0.04086825f, -0.00895318f, 0.02203412f, 0.01491451f, -0.00909733f, 0.00779763f, 0.02103767f, 
    0.02902310f, -0.00500122f, -0.02819452f, 0.01894458f, -0.00745622f, -0.00983968f, -0.01305981f, 0.01784735f, 
    0.00831242f, 0.00960489f, -0.02834313f, -0.02283089f, -0.02777511f, -0.00716568f, 0.03265703f, 0.01532324f, 
    -0.03966878f, -0.01024695f, -0.03963064f, -0.03130351f, -0.03105572f, 0.00609236f, -0.01903378f, -0.03723092f, 
    0.02136141f, -0.03150989f, -0.03529111f, 0.00182267f, -0.03548047f, 0.00341087f, 0.02861795f, -0.00293047f, 
    -0.01257594f, 0.02555427f, -0.03969108f, -0.03662731f, -0.00445989f, -0.02087424f, 0.01769575f, -0.01813892f, 
    0.02469285f, -0.02719067f, -0.01426160f, -0.01894105f, -0.03176918f, -0.04055240f, 0.01046270f, 0.01177775f, 
    -0.03198213f, -0.04120852f, 0.00092264f, 0.01573515f, -0.02114726f, 0.00423640f, -0.03474253f, 0.02217541f, 
    -0.00739136f, 0.01678125f, -0.02120082f, 0.00062975f, 0.02543877f, -0.03839635f, -0.04443546f, -0.02013056f, 
    -0.02879095f, -0.04239267f, -0.02033610f, -0.00651360f, -0.04102370f, -0.03245538f, -0.00999708f, 0.02452075f, 
    0.00840368f, -0.02010714f, -0.01552003f, -0.02996217f, 0.01967960f, 0.01134369f, 0.00953451f, 0.03115425f, 
    0.00561391f, 0.02615435f, -0.03712158f, 0.03284972f, -0.01937039f, 0.02436296f, -0.03984032f, -0.02494116f, 
    -0.04346928f, 0.02172234f, -0.00592254f, -0.01259145f, 0.00096110f, -0.02503028f, 0.02927322f, -0.01384844f, 
    0.03188626f, 0.01803079f, -0.02730818f, 0.03008354f, -0.04347489f, 0.00633946f, 0.01826971f, 0.02393964f, 
    -0.01644824f, -0.00495505f, 0.01528219f, -0.00881379f, 0.00988735f, -0.01386674f, 0.02915098f, 0.02697453f, 
    0.01647029f, -0.03319178f, -0.04524560f, -0.00061013f, 0.02445834f, -0.00721580f, -0.03322045f, -0.00689741f, 
    0.03394908f, -0.00498368f, 0.01601467f, -0.03973262f, -0.03479812f, 0.03104865f, -0.02991474f, -0.01472776f, 
    -0.03401002f, 0.00520574f, 0.01971833f, 0.01163364f, -0.00505443f, 0.00431707f, -0.03624143f, -0.03619024f, 
    0.02102048f, 0.02717969f, 0.02819623f, -0.00272325f, -0.01570306f, 0.02639794f, -0.04444725f, 0.02701537f, 
    0.00911886f, 0.01893066f, 0.02222231f, 0.00468997f, -0.00228209f, -0.03280422f, 0.02090356f, -0.03840850f, 
    0.01594440f, -0.03149314f, 0.03244579f, -0.03121236f, -0.00437637f, -0.00476695f, -0.01130288f, 0.00942145f, 
    0.02972394f, 0.01343541f, -0.02941829f, 0.00717010f, -0.03200012f, 0.02434842f, -0.03701889f, -0.00978446f, 
    -0.00528151f, 0.00014259f, -0.02019167f, -0.02946584f, 0.01717825f, -0.00231600f, 0.02491563f, 0.02909243f, 
    -0.00116064f, -0.02804170f, 0.01651218f, -0.04008403f, 0.00830670f, 0.00402471f, -0.03003329f, -0.01395523f, 
    0.00137464f, -0.02986183f, -0.03925633f, -0.04385591f, 0.01212253f, 0.01606030f, -0.00846306f, -0.03133626f, 
    0.00151570f, 0.01777788f, 0.03196080f, -0.04091155f, 0.01217824f, -0.00487425f, -0.02393114f, -0.04144270f, 
    0.01978253f, 0.00108297f, 0.02435572f, -0.03238246f, -0.01788407f, -0.02763529f, -0.04338569f, -0.00314006f, 
    -0.02767873f, -0.01708086f, 0.02943468f, -0.02208998f, -0.00692880f, 0.01840703f, -0.04464815f, 0.03345962f, 
    -0.04307284f, -0.04419031f, -0.00037886f, -0.01188178f, -0.00597504f, -0.02959507f, 0.03334567f, -0.01338228f, 
    -0.01320035f, -0.00322800f, -0.00644309f, 0.02335352f, -0.02767088f, 0.01111890f, -0.01686048f, -0.04455912f, 
    -0.03977318f, 0.02440932f, -0.00872852f, -0.02542300f, 0.02342979f, -0.00513720f, -0.04489411f, -0.02593151f, 
    -0.04045275f, 0.01184700f, -0.00949380f, 0.01812149f, 0.00783918f, -0.01851416f, 0.02891101f, 0.02064259f, 
    0.00014918f, -0.03405156f, 0.01768867f, 0.01431781f, 0.03054911f, -0.01978619f, 0.03098843f, -0.02357947f, 
    -0.01585514f, -0.03913386f, -0.02725151f, 0.02395424f, 0.00632165f, -0.01161115f, -0.01069883f, -0.01097850f, 
    -0.00901780f, 0.01411637f, 0.02821259f, 0.02165929f, 0.03256059f, -0.03233237f, -0.00795356f, 0.01871886f, 
    -0.00377510f, -0.04266170f, 0.00321321f, -0.02197753f, -0.02573047f, -0.01573790f, -0.02191242f, -0.02227085f, 
    -0.04481758f, 0.00157294f, -0.04124142f, 0.01653585f, 0.01943478f, 0.01283933f, -0.03733130f, 0.02374431f, 
    -0.01777980f, 0.02971413f, -0.03137538f, -0.03950367f, 0.02523825f, 0.01100170f, -0.02422077f, -0.01712448f, 
    -0.02459965f, 0.02387489f, -0.03670267f, 0.00206113f, -0.03536935f, 0.00110535f, 0.02617090f, -0.02926001f, 
    -0.03856924f, 0.00817643f, -0.00704700f, -0.01245073f, 0.03604750f, -0.03413643f, -0.02364225f, -0.03193686f, 
    0.00967108f, -0.00182200f, 0.00600403f, 0.03342641f, 0.00030376f, 0.02426360f, 0.00451155f, -0.01666981f, 
    0.02294728f, 0.02451438f, -0.02031932f, -0.02307631f, -0.01172715f, -0.00418348f, -0.03735770f, -0.01387191f, 
    -0.01504716f, 0.02298195f, 0.02389134f, 0.01303006f, 0.02743591f, -0.02378167f, -0.04539523f, -0.01967608f, 
    -0.00151755f, -0.00055573f, -0.00169216f, 0.02769534f, 0.02588401f, -0.02368155f, 0.02026331f, 0.01580760f, 
    -0.00064355f, 0.01186504f, 0.01810103f, 0.00282865f, -0.03207977f, -0.01095700f, -0.02704677f, 0.00408497f, 
    -0.02191158f, -0.02598918f, -0.01770517f, 0.03058418f, 0.01163560f, -0.00673542f, 0.02111318f, -0.03779110f, 
    -0.00041834f, -0.01219313f, 0.00195045f, -0.03113112f, -0.00279019f, -0.03944865f, 0.02006177f, -0.03750391f, 
    -0.04239675f, 0.00308150f, 0.02089846f, -0.01982177f, -0.02801495f, 0.00488902f, 0.01800107f, -0.01301120f, 
    -0.04054720f, -0.02460728f, 0.02670535f, -0.00806975f, -0.01949534f, -0.03119213f, -0.00848462f, 0.01361304f, 
    0.03537181f, 0.03380367f, 0.02498850f, 0.03222482f, -0.01367386f, -0.00266954f, 0.01480494f, -0.00138189f, 
    -0.02538376f, 0.02695825f, 0.02673189f, -0.00079435f, -0.04106403f, -0.03269599f, 0.00029097f, 0.01500639f, 
    -0.03081520f, 0.03686295f, -0.03498380f, -0.01738961f, -0.00841120f, -0.02738066f, -0.04176289f, -0.00346354f, 
    0.01256711f, -0.00427630f, -0.00910744f, 0.01791026f, 0.02767471f, -0.00594199f, -0.02261336f, -0.01933340f, 
    -0.00412050f, -0.03003712f, -0.02903697f, 0.01951983f, -0.02951129f, -0.03651533f, 0.02791495f, 0.00170181f, 
    0.01286888f, -0.01992165f, 0.01748118f, 0.00315565f, -0.00424318f, -0.00000140f, 0.03108029f, 0.01051820f, 
    -0.02004907f, -0.03736169f, -0.02202873f, -0.00777462f, -0.02391563f, -0.02103950f, -0.02636257f, -0.01833976f, 
    0.00855289f, -0.03807534f, -0.02441384f, 0.01494153f, 0.00360133f, -0.00564258f, -0.02088697f, -0.02060698f, 
    -0.03684808f, -0.00947276f, -0.02331378f, -0.02099111f, -0.01983658f, -0.02014274f, 0.00070142f, -0.03783955f, 
    -0.03049575f, 0.00590686f, -0.03017754f, 0.00800456f, -0.00906425f, 0.00803190f, 0.00790155f, -0.03828690f, 
    0.02342732f, -0.02055923f, -0.01096215f, -0.03701242f, 0.03266408f, 0.02002248f, -0.03124888f, 0.02536556f, 
    -0.00123929f, -0.00436062f, -0.02594179f, -0.01425988f, -0.01400208f, 0.01742520f, -0.02652161f, -0.01558470f, 
    -0.02095542f, -0.00110262f, -0.04077557f, -0.02416218f, -0.03897114f, 0.02947641f, -0.04144415f, -0.02272904f, 
    -0.03155565f, 0.00798588f, -0.03521280f, 0.03192811f, 0.00971940f, -0.03246545f, -0.02036746f, 0.00750029f, 
    -0.03310392f, 0.00937935f, 0.00818278f, 0.00312553f, 0.00308424f, -0.04459922f, 0.02677567f, 0.00385357f, 
    -0.04440167f, -0.04020262f, -0.01077466f, 0.00617753f, -0.03628891f, -0.03151057f, 0.01190995f, 0.00195827f, 
    -0.02071891f, 0.01013977f, -0.00626041f, -0.01510532f, -0.01107129f, -0.03001362f, -0.01815679f, 0.02054170f, 
    -0.00582048f, -0.01210526f, -0.00899386f, -0.01395592f, 0.00305853f, -0.02213999f, 0.00121216f, 0.01009428f, 
    -0.03129040f, 0.01025566f, -0.01954586f, -0.00841666f, 0.02528279f, -0.00922073f, 0.03091661f, 0.03299401f, 
    0.00935861f, 0.02570239f, -0.03470282f, -0.02867672f, -0.00245831f, -0.00267053f, -0.02343248f, -0.03474289f, 
    -0.03094630f, -0.01114989f, 0.02622564f, 0.01025809f, 0.01456547f, 0.01921771f, -0.02367100f, -0.00627204f, 
    -0.02533038f, -0.00599274f, -0.00424382f, -0.00258462f, -0.03134691f, -0.01226413f, -0.02958029f, 0.00297543f, 
    -0.00681943f, -0.00324565f, 0.01132186f, 0.01058603f, -0.01073004f, 0.01144089f, -0.02264466f, 0.03920508f, 
    -0.03841209f, -0.00169830f, 0.03186287f, 0.00959850f, 0.02154941f, 0.02741594f, -0.01294542f, -0.02053380f, 
    0.01279230f, 0.01198046f, -0.01532388f, 0.01170816f, 0.00658382f, -0.03727900f, -0.01038446f, -0.01619783f, 
    -0.03409094f, -0.03029480f, -0.03850529f, 0.01364475f, 0.01489925f, 0.03219933f, -0.00442031f, -0.02344965f, 
    -0.00066756f, -0.02853097f, -0.02330507f, -0.02032066f, -0.01479376f, -0.01551284f, -0.03578563f, 0.02808725f, 
    -0.02252014f, -0.01761600f, -0.04443924f, -0.00436087f, 0.03196061f, -0.03997302f, -0.00228495f, 0.00068630f, 
    -0.01417262f, -0.04295617f, -0.02432318f, 0.02546417f, 0.00228213f, 0.01081143f, -0.00394185f, 0.01033895f, 
    0.01996805f, -0.03071227f, -0.03497172f, 0.03214906f, -0.03448771f, 0.02302953f, 0.01082337f, -0.00779049f, 
    0.03303339f, -0.02721567f, 0.00408888f, -0.00886069f, 0.02771323f, -0.01150256f, -0.03670963f, -0.00398256f, 
    0.01998447f, 0.03147300f, 0.00869842f, 0.01075549f, 0.01408746f, 0.02816638f, -0.01326678f, 0.00344628f, 
    -0.00671197f, -0.00228027f, -0.03592278f, 0.02512125f, -0.03652764f, -0.00759323f, -0.00102484f, 0.00663306f, 
    -0.01534277f, 0.00614952f, 0.02459964f, -0.00668986f, -0.04251492f, 0.03226528f, 0.00651071f, -0.00364607f, 
    0.01203057f, -0.02581198f, -0.01183029f, -0.02325315f, 0.01742765f, -0.03092887f, 0.03199051f, -0.03191036f, 
    0.02072353f, -0.03622384f, -0.02837666f, -0.03854171f, -0.01220303f, -0.03770715f, 0.02844835f, -0.02869561f, 
    0.00964518f, 0.02093725f, -0.01989603f, 0.01214799f, 0.01452456f, -0.02818872f, -0.01541137f, -0.03170312f, 
    0.00192639f, -0.00053877f, -0.01910345f, -0.01490017f, 0.01240044f, -0.02832593f, -0.01632217f, -0.02572822f, 
    0.02195194f, -0.02609035f, -0.02052072f, 0.00523487f, -0.00207491f, 0.01350934f, 0.02376546f, -0.03626340f, 
    0.02808656f, -0.03948249f, 0.03934512f, -0.01278917f, -0.01815310f, 0.01207619f, 0.02694334f, 0.02476712f, 
    -0.02479992f, -0.03546346f, 0.00692747f, 0.01835291f, -0.01195349f, -0.03463889f, 0.00828420f, 0.02165342f, 
    -0.01750387f, -0.03656249f, -0.01202536f, -0.02681224f, 0.00675231f, 0.00393188f, 0.01765178f, 0.01296867f, 
    -0.03647262f, 0.00219369f, -0.04456563f, 0.01748394f, -0.02987568f, 0.02194814f, 0.01178953f, -0.00849756f, 
    -0.03143298f, -0.01550979f, 0.02486290f, 0.00893532f, -0.00778339f, -0.00694303f, -0.02194265f, -0.03440267f, 
    0.03054109f, 0.03071183f, -0.02890977f, 0.01391630f, -0.00826138f, 0.00745286f, 0.02596361f, -0.00170080f, 
    -0.01769030f, 0.01116411f, 0.02271103f, -0.02623897f, 0.01116438f, -0.02355748f, -0.00779645f, -0.04235913f, 
    -0.01555385f, -0.04469616f, -0.02719615f, -0.03065003f, -0.01108870f, -0.04268606f, -0.00175501f, -0.01614265f, 
    -0.00694048f, -0.01301028f, -0.02947906f, 0.02588057f, 0.03030544f, -0.01179528f, 0.00359521f, 0.00069895f, 
    -0.04065406f, 0.00145688f, 0.01280215f, -0.02047781f, -0.03255571f, 0.00943446f, -0.00690861f, 0.02623087f, 
    -0.03932361f, 0.01985401f, -0.02285290f, -0.01136846f, -0.04614386f, -0.03590046f, -0.01016974f, -0.03247499f, 
    0.02216122f, -0.03874288f, 0.01415936f, -0.00846218f, 0.02554948f, 0.00719245f, -0.04817367f, 0.01661450f, 
    0.05115795f, 0.00224837f, 0.03043494f, -0.03967580f, 0.00691753f, -0.02744723f, -0.00412942f, -0.04614034f, 
    0.02336311f, 0.00426615f, -0.00075329f, 0.02547058f, -0.03424783f, 0.02639054f, 0.01179732f, -0.03141849f, 
    -0.04750207f, -0.04084500f, -0.04614517f, -0.03345605f, 0.03849887f, -0.02962736f, -0.03840759f, -0.01428983f, 
    0.02447961f, -0.03399137f, -0.00503391f, 0.04307349f, -0.02789493f, -0.02674151f, 0.00119243f, -0.01315054f, 
    -0.03603390f, -0.02715624f, -0.02408259f, -0.02378031f, 0.02389632f, -0.02571232f, -0.00467764f, -0.04146055f, 
    0.00857418f, -0.01042672f, 0.02667402f, -0.02208241f, 0.02008418f, 0.01454071f, -0.01683193f, -0.03054065f, 
    0.02773734f, -0.02511655f, -0.00155600f, -0.00803893f, -0.02134411f, -0.02755983f, 0.05257405f, 0.01381981f, 
    -0.00805386f, -0.01661487f, 0.00141406f, 0.00013919f, -0.00767453f, -0.03035334f, -0.00077220f, -0.02461410f, 
    -0.00216261f, -0.00914935f, -0.01917681f, 0.01356768f, 0.04311287f, -0.01756115f, -0.01908715f, -0.02049253f, 
    -0.01902665f, -0.02727484f, 0.02577586f, -0.00351766f, 0.01692289f, -0.02200511f, 0.01979290f, -0.02444027f, 
    -0.00033186f, -0.01518862f, -0.00300465f, -0.02528227f, 0.02131872f, 0.02015634f, 0.01342732f, 0.01893271f, 
    0.02178072f, -0.02488518f, 0.03401585f, -0.03131154f, 0.00780292f, -0.03335704f, 0.03154932f, 0.03124507f, 
    0.01959166f, -0.00811785f, -0.02334422f, 0.00220838f, -0.04475521f, -0.02261267f, 0.01665331f, 0.00262294f, 
    -0.02359410f, -0.01706551f, -0.00031626f, 0.04608885f, -0.04642181f, -0.03064197f, -0.01810781f, -0.03533049f, 
    -0.02934084f, -0.01732006f, 0.01435057f, -0.03408690f, 0.00054260f, 0.01893706f, -0.04019125f, -0.03450838f, 
    -0.02223381f, -0.03860191f, -0.03279727f, 0.00893794f, 0.03206408f, -0.03398111f, -0.01154916f, -0.02893866f, 
    -0.04511948f, 0.01005498f, 0.00244917f, 0.01144257f, -0.00818818f, -0.00998569f, -0.04093416f, 0.02437680f, 
    0.00910647f, -0.00623743f, -0.02287013f, 0.02332380f, 0.02076169f, -0.01561072f, -0.01681328f, -0.03406619f, 
    0.01655993f, 0.01373887f, 0.02055507f, -0.04597146f, -0.01105203f, -0.04170708f, 0.00107471f, -0.01723588f, 
    -0.04551645f, -0.02039127f, -0.04165198f, 0.05238096f, -0.02382936f, -0.01093820f, 0.00207836f, -0.01215211f, 
    0.02840125f, -0.00916040f, -0.01568422f, 0.01986529f, 0.01384680f, 0.00129487f, -0.02354950f, 0.04374423f, 
    -0.00176686f, -0.03705471f, -0.00693932f, 0.03052595f, -0.03214994f, -0.01304053f, -0.00278228f, 0.01506410f, 
    0.00184421f, -0.04255585f, 0.01724409f, 0.01257635f, -0.04557968f, -0.03403886f, 0.03173788f, -0.02102047f, 
    -0.02410466f, 0.02968203f, 0.02426391f, 0.00106858f, 0.01448273f, 0.01165082f, -0.00379180f, -0.02098437f, 
    -0.04072329f, -0.02673135f, -0.02026673f, 0.01691342f, 0.00215554f, -0.02109948f, 0.01018185f, 0.02371730f, 
    0.00066803f, -0.03999404f, 0.02151882f, 0.02054722f, 0.02797858f, -0.00285383f, 0.01678515f, -0.04355825f, 
    -0.02068268f, -0.02791697f, 0.01210618f, -0.03230215f, 0.00583798f, 0.02994927f, -0.02521813f, -0.03434904f, 
    -0.02892759f, -0.02802643f, -0.02085386f, 0.01545744f, 0.03136900f, 0.01602215f, -0.03573038f, -0.04350883f, 
    -0.03035950f, -0.03211805f, 0.03042458f, 0.01336721f, -0.00984672f, 0.00508030f, -0.01540863f, -0.04070643f, 
    -0.02539762f, 0.00818743f, -0.03521824f, -0.02395165f, -0.00508760f, 0.02191341f, 0.00165613f, 0.00030517f, 
    0.01938471f, 0.02840145f, 0.01009935f, 0.03909575f, -0.02387380f, -0.00220455f, -0.01883687f, 0.02949730f, 
    0.01535674f, -0.03997323f, -0.00143401f, 0.01234998f, 0.02016585f, -0.00927877f, 0.01074111f, 0.00150763f, 
    -0.04055938f, -0.03571505f, -0.04026687f, 0.03122602f, -0.01066030f, -0.02946496f, 0.02737207f, -0.01621349f, 
    -0.02549458f, -0.02533029f, 0.03092373f, -0.03206874f, 0.01531972f, 0.01944347f, 0.02839961f, -0.03340428f, 
    0.01142326f, -0.02096979f, 0.01920789f, -0.01532739f, -0.04021479f, 0.00044485f, -0.04305733f, 0.01740498f, 
    0.02785650f, -0.00926406f, -0.00274735f, 0.02770077f, 0.01855253f, -0.01726685f, -0.03861148f, 0.02349273f, 
    0.03318519f, 0.01195156f, 0.03683858f, -0.01442251f, 0.02739946f, -0.04166663f, -0.00123829f, 0.00514920f, 
    0.00230580f, 0.02330256f, -0.00164941f, 0.01968973f, -0.00439512f, -0.02923541f, -0.00998115f, 0.02000034f, 
    -0.04496574f, -0.02893406f, -0.00306910f, 0.02924421f, 0.01987327f, -0.02328745f, -0.03620087f, -0.02754935f, 
    0.01165369f, -0.01772051f, 0.02663304f, -0.00991699f, -0.01213421f, 0.00386514f, -0.02200046f, 0.01894574f, 
    -0.04368118f, -0.02160850f, -0.00526825f, -0.03267754f, 0.00664338f, 0.03096555f, -0.03360000f, 0.01330617f, 
    -0.04416272f, 0.02186606f, -0.03451083f, -0.01145039f, -0.03036343f, -0.00243030f, -0.02081698f, 0.00102214f, 
    -0.04743029f, -0.00643131f, -0.00451072f, -0.00508622f, 0.01100139f, 0.00802744f, 0.00965652f, -0.01739943f, 
    -0.00215606f, 0.03308394f, 0.00061525f, -0.03249729f, 0.00533736f, 0.00629545f, -0.03704593f, 0.02139465f, 
    -0.02391566f, -0.00333248f, -0.04634577f, 0.00042810f, -0.03745465f, 0.02596243f, -0.00867600f, -0.04020498f, 
    -0.03676632f, -0.01202667f, -0.01355359f, -0.03853223f, -0.01371958f, -0.00752709f, -0.01819803f, -0.04038342f, 
    0.00713351f, 0.00605043f, -0.01423254f, 0.01520622f, -0.02154444f, -0.01825581f, -0.03301592f, 0.00843057f, 
    -0.00337126f, 0.02529875f, -0.03431435f, 0.00409619f, -0.01545173f, -0.00848665f, 0.02282351f, 0.01883231f, 
    -0.03471336f, 0.01774706f, 0.00967646f, 0.00838565f, -0.01569252f, 0.02004041f, 0.01111059f, -0.01371550f, 
    -0.04223201f, -0.04062094f, -0.03231339f, 0.00845176f, -0.01490023f, -0.02179520f, -0.00232558f, -0.04270559f, 
    0.00110728f, -0.04436195f, -0.03275637f, -0.01709198f, -0.02034864f, 0.03433466f, -0.02257553f, -0.02810148f, 
    0.02386484f, 0.01910031f, -0.02845959f, 0.00370718f, -0.03177660f, -0.01699679f, 0.04268586f, 0.00745151f, 
    -0.03583933f, 0.01134257f, -0.03215791f, -0.01902637f, 0.01760027f, 0.00340639f, -0.03124656f, -0.02148768f, 
    0.00333072f, -0.01506387f, 0.01596460f, 0.00323287f, 0.03700852f, -0.00290096f, -0.02676432f, 0.00994308f, 
    -0.03239223f, -0.01420963f, -0.02818042f, 0.03191848f, -0.00155028f, -0.03657738f, 0.00125531f, -0.04350411f, 
    0.01812622f, -0.00868690f, 0.01767343f, -0.00185848f, 0.00548706f, 0.01875212f, -0.00250400f, -0.00258261f, 
    -0.02286934f, -0.04029759f, -0.01906522f, 0.02527716f, 0.01117765f, -0.03282485f, -0.00475248f, -0.04503560f, 
    0.01487981f, 0.00905214f, -0.00027624f, -0.02137278f, 0.02692107f, -0.04000568f, -0.00325984f, -0.01213913f, 
    0.01770886f, -0.01608067f, 0.03350476f, -0.00741276f, -0.03704444f, 0.01280549f, -0.00581456f, -0.02932170f, 
    0.00346878f, 0.00484461f, -0.04155102f, 0.03459601f, 0.02090564f, -0.00520472f, -0.04208658f, -0.02155142f, 
    -0.03072772f, 0.01457443f, 0.02566656f, -0.01808284f, -0.00805396f, 0.00857686f, -0.00178508f, -0.01882655f, 
    -0.01018095f, -0.00527027f, -0.04162917f, 0.03096137f, -0.02363179f, -0.01168850f, -0.03960836f, -0.00528589f, 
    -0.02159731f, 0.01239942f, 0.00407715f, -0.01094460f, -0.03482495f, -0.00425909f, -0.03710605f, -0.03949906f, 
    -0.00698842f, -0.02903385f, 0.00330147f, -0.01347096f, 0.02711202f, -0.04618149f, -0.03862196f, -0.03793037f, 
    -0.01983583f, -0.00869315f, -0.00739730f, 0.00362242f, -0.02098232f, -0.03640425f, 0.01965638f, -0.00700890f, 
    -0.00340438f, -0.04485693f, 0.03513162f, 0.03912166f, -0.02989732f, -0.02688183f, -0.01681935f, -0.02784681f, 
    0.04597931f, 0.00995586f, 0.01361545f, 0.02763008f, -0.00450933f, -0.00924224f, 0.01513327f, 0.02968619f, 
    0.04030527f, -0.00074870f, -0.03877501f, -0.02594438f, 0.02431903f, -0.00491777f, 0.03880921f, 0.04330627f, 
    -0.03175249f, -0.00774169f, 0.00923979f, 0.01831586f, 0.03004519f, -0.00865265f, 0.03700208f, 0.03648141f, 
    -0.01753269f, -0.01210674f, -0.00071679f, -0.01806867f, -0.00182469f, 0.01860295f, -0.03711898f, -0.00568931f, 
    -0.04088192f, -0.00920348f, -0.00073350f, 0.01440034f, 0.00519325f, -0.01354943f, 0.01958479f, -0.02085954f, 
    -0.04208795f, 0.01022127f, -0.00947674f, 0.02845244f, -0.04219024f, -0.02530567f, 0.01744612f, -0.04880932f, 
    -0.04396475f, -0.00752684f, 0.02563998f, 0.00565713f, 0.02023624f, -0.02618236f, -0.01660868f, -0.03053360f, 
    -0.02001554f, 0.02205962f, -0.03077573f, -0.02360155f, 0.00729315f, -0.02377749f, -0.03593957f, 0.01016600f, 
    -0.03085846f, 0.49108288f, 0.15921669f, 0.24137527f, 0.00368276f, -0.04886371f, 0.04380196f, 0.00261716f, 
    -0.03921527f, -0.06116997f, 0.06580873f, 0.05020044f, 0.02587304f, 0.05629544f, -0.01320481f, 0.02125384f, 
    0.02841151f, -0.06259906f, -0.06118821f, 0.18562251f, -0.03786236f, 0.14682473f, 0.27314487f, 0.39444304f, 
    -0.01277442f, 0.00140615f, 0.13000430f, 0.06770346f, 0.07314302f, -0.08754715f, 0.05118709f, 0.03500275f, 
    0.08710595f, -0.03529697f, 0.09165625f, 0.06291732f, 0.07784434f, -0.19698735f, -0.13438107f, 0.08362935f, 
    0.43155852f, -0.36778092f, -0.26081562f, -0.05583776f, 0.29089096f, 0.06935495f, -0.01037512f, -0.03620445f, 
    -0.00109414f, 0.05441766f, 0.06650658f, -0.00906983f, 0.03121260f, 0.02427866f, -0.00149373f, -0.01135245f, 
    -0.10109511f, 0.14939408f, 0.01198093f, 0.04013276f, -0.36751413f, -0.38239732f, 0.07575835f, 0.04749552f, 
    0.41774219f, 0.01103010f, -0.13731742f, 0.05087619f, -0.00039140f, 0.00689374f, 0.33914614f, 0.08441792f, 
    -0.08131471f, -0.06794891f, 0.03143830f, 0.09773602f, -0.10823248f, 0.15581469f, 0.00665650f, 0.03409539f, 
    -0.11942904f, 0.06006052f, 0.50910008f, 0.14445823f, 0.06154544f, 0.11139688f, 0.01515125f, 0.17897175f, 
    0.14316379f, -0.15809791f, 0.18824568f, 0.02430985f, -0.04266989f, 0.00341637f, 0.01979757f, 0.14895359f, 
    0.01531509f, 0.01687249f, -0.02051889f, -0.05567739f, -0.06057847f, -0.01392204f, -0.27608523f, -0.19891116f, 
    0.20352951f, 0.05590112f, 0.03689548f, 0.00140326f, 0.14311855f, 0.08186969f, -0.06113752f, -0.02968114f, 
    -0.02301184f, 0.00594075f, 0.06979696f, 0.04994971f, -0.09188156f, -0.06694379f, 0.11628699f, -0.03738070f, 
    0.10138853f, -0.28667936f, -0.06745808f, 0.06815891f, 0.15329292f, 0.27308917f, -0.06573781f, -0.11180947f, 
    0.06727782f, 0.04780575f, 0.10670099f, 0.08429684f, 0.04172971f, -0.06203939f, 0.03962141f, -0.01085404f, 
    -0.00888769f, -0.02063937f, 0.07822461f, -0.00803176f, -0.09580814f, -0.05255374f, -0.08683656f, -0.11986814f, 
    -0.47607979f, 0.04992800f, 0.23552382f, 0.02577151f, -0.16298360f, 0.32608566f, -0.11851804f, 0.02277249f, 
    0.04604277f, 0.11162658f, -0.03526333f, -0.05988899f, -0.08676185f, -0.15584621f, -0.01665857f, 0.07239121f, 
    -0.12949687f, 0.52161700f, 0.29733288f, -0.10852375f, -0.08085279f, -0.01008926f, -0.03668929f, 0.06279708f, 
    0.09557442f, 0.06259859f, -0.01110065f, 0.02285499f, 0.02998832f, 0.18376623f, 0.03510504f, -0.00233554f, 
    0.00391120f, 0.04214177f, 0.00292868f, 0.07269951f, -0.22326243f, 0.29862913f, 0.38653827f, 0.44198769f, 
    0.07377669f, -0.25525883f, 0.03916419f, 0.02665790f, -0.01647430f, 0.11571266f, 0.05704461f, 0.13882521f, 
    0.12049590f, -0.06833024f, 0.02567979f, 0.02278909f, 0.07258902f, -0.00604254f, -0.12528694f, 0.06089779f, 
    0.07925669f, -0.19853434f, -0.09853231f, 0.08504473f, 0.18141276f, 0.04260835f, -0.05400226f, 0.01016687f, 
    -0.02563696f, 0.07548388f, 0.12693368f, 0.22824989f, 0.10297263f, 0.09979130f, 0.04315871f, 0.00558454f, 
    -0.06626974f, 0.00741142f, -0.04948371f, -0.00590091f, 0.29475048f, -0.42316636f, 0.30686808f, 0.05625184f, 
    0.13258916f, 0.08643619f, 0.01536925f, 0.01097324f, 0.01043320f, 0.08598708f, 0.22298153f, 0.06186214f, 
    0.10413934f, 0.11248811f, 0.05245875f, 0.15313093f, 0.03998337f, -0.00099399f, -0.07363328f, 0.03169133f, 
    0.16233201f, -0.12516713f, 0.01511936f, 0.02459714f, 0.00055316f, 0.02794694f, -0.01597186f, -0.04562461f, 
    0.05497542f, 0.04974847f, 0.16153501f, -0.00791098f, -0.04710650f, 0.08357725f, -0.10832536f, -0.04163526f, 
    -0.01725747f, -0.01439284f, -0.05494202f, 0.11880106f, 0.07895950f, 0.11984470f, -0.15988268f, -0.20050107f, 
    0.09154306f, -0.00699747f, 0.07729164f, 0.02780410f, 0.04174364f, 0.09576030f, -0.04682417f, -0.10261601f, 
    0.08699923f, 0.01056328f, 0.08854467f, -0.01675716f, 0.00200429f, -0.13460588f, 0.10261451f, 0.06790193f, 
    -0.09259415f, -0.00237750f, -0.03887772f, 0.08135547f, 0.06181751f, 0.03278114f, -0.07212623f, -0.03818630f, 
    -0.02846073f, 0.00394460f, -0.14519459f, 0.11587725f, 0.07992011f, 0.02607021f, 0.10634992f, 0.05894916f, 
    -0.14959556f, -0.02751790f, -0.02054610f, 0.02414733f, -0.58467638f, -0.27237588f, 0.14352189f, 0.14273050f, 
    0.07191540f, -0.03887591f, -0.09473237f, 0.07194108f, 0.24452676f, 0.06079362f, 0.02805867f, 0.02729620f, 
    0.00907659f, -0.01013871f, 0.01589627f, 0.08291940f, 0.09923578f, 0.08650070f, -0.03481511f, 0.06856704f, 
    0.22042626f, -0.17153643f, -0.17647231f, -0.15339944f, -0.09511542f, 0.11415074f, 0.15399416f, 0.03685492f, 
    0.08353069f, -0.03630707f, 0.07339578f, -0.05484924f, 0.07689188f, -0.02517170f, -0.02324479f, 0.03277618f, 
    -0.05856702f, -0.01068143f, -0.00114233f, 0.04456549f, -0.53136045f, -0.04398603f, 0.24266863f, 0.40690300f, 
    0.06769567f, -0.00819151f, 0.08144714f, 0.03610852f, 0.07899021f, 0.14828171f, -0.10610519f, 0.10351089f, 
    -0.02738110f, -0.01604379f, 0.04037962f, -0.07755661f, -0.02462385f, 0.01131616f, -0.16135336f, 0.14613238f, 
    0.11996195f, -0.07280346f, 0.59615487f, 0.21506923f, -0.20315079f, 0.11651800f, 0.05977758f, -0.05999963f, 
    0.07135970f, -0.11803081f, 0.17521335f, -0.01136137f, 0.02849965f, -0.19101393f, -0.02229919f, 0.05337990f, 
    0.00981896f, -0.02551771f, -0.01046783f, -0.04578973f, -0.05680621f, -0.05321460f, 0.03172283f, 0.15242878f, 
    0.00454550f, -0.03715662f, -0.08068345f, -0.05951210f, 0.00051029f, 0.03535786f, 0.07199535f, 0.04444861f, 
    -0.07675054f, 0.10174311f, 0.05565078f, 0.01664106f, 0.02024000f, 0.07146405f, -0.01790988f, -0.05311536f, 
    -0.25694314f, 0.08481999f, 0.50499403f, 0.22191551f, -0.10214543f, 0.07249363f, -0.06435711f, -0.01626365f, 
    0.05580228f, 0.14015724f, 0.09879980f, -0.00549895f, -0.08154420f, -0.04978388f, -0.01301077f, 0.01961089f, 
    0.01278705f, -0.06643175f, -0.03739156f, -0.04304107f, 0.81762260f, -0.20687975f, -0.11219770f, -0.40088546f, 
    -0.13767581f, -0.09268662f, 0.02856563f, -0.25492355f, 0.23438618f, 0.04287838f, -0.00220200f, 0.08354825f, 
    -0.11012298f, 0.01173349f, 0.03702802f, -0.06906706f, -0.09045300f, -0.02341873f, 0.13246225f, 0.04566139f, 
    0.01659255f, 0.30138502f, -0.06130116f, 0.07530525f, -0.19851062f, 0.06743026f, 0.01267054f, 0.06537822f, 
    0.07060811f, -0.13201258f, -0.04309874f, -0.03116835f, 0.00526963f, 0.11388353f, 0.02905497f, 0.11139320f, 
    0.01360253f, -0.13223727f, 0.00668922f, 0.11171158f, 0.01161920f, -0.11312311f, -0.31708238f, -0.07214005f, 
    0.17287251f, -0.03310160f, 0.08060537f, -0.27945638f, 0.03759201f, -0.02805994f, -0.09844998f, -0.03791848f, 
    0.04629323f, 0.04034537f, -0.01752826f, -0.08726256f, -0.10236026f, -0.07149227f, 0.04025159f, -0.04954198f, 
    -0.08857249f, 0.32877484f, 0.23557951f, 0.34400919f, -0.09361968f, -0.15008982f, 0.04039947f, 0.04908877f, 
    0.04182532f, 0.07805683f, -0.04367324f, -0.00799813f, -0.03119744f, 0.07418972f, -0.12263542f, 0.02313163f, 
    0.16324143f, -0.11158431f, 0.02069722f, 0.06956200f, -0.43247610f, -0.19993883f, 0.07173513f, 0.22418176f, 
    0.05309082f, 0.05915643f, -0.04575500f, 0.04076757f, -0.04172385f, 0.16430859f, 0.03689973f, 0.03192333f, 
    0.02125359f, 0.03375925f, 0.03693686f, 0.11081823f, -0.13487358f, 0.03090206f, 0.03023248f, -0.05119884f, 
    0.30977610f, -0.02897542f, -0.07616598f, -0.04373001f, 0.10584844f, -0.03086977f, 0.04070696f, -0.07448930f, 
    0.02682599f, -0.01772952f, 0.05776168f, 0.03159427f, -0.04870204f, -0.12557469f, 0.08268695f, 0.00741925f, 
    -0.07661276f, 0.01300664f, 0.01230415f, 0.00017077f, 0.50205368f, 0.03839497f, 0.39190325f, -0.13206287f, 
    -0.40335050f, -0.09096720f, 0.19831884f, -0.00307944f, 0.26035604f, -0.14487295f, 0.10752008f, -0.08552328f, 
    0.25711641f, 0.01503715f, 0.01003584f, -0.11056972f, 0.03617906f, -0.09181166f, 0.07481208f, -0.04518753f, 
    0.46860459f, 0.06985474f, -0.24931042f, -0.05767155f, -0.04555757f, -0.04858025f, 0.02357600f, 0.02662789f, 
    -0.03176554f, 0.01178525f, -0.03959014f, 0.03238061f, -0.07254895f, -0.01661850f, 0.04223956f, -0.01486167f, 
    -0.01615324f, -0.03079393f, 0.07034675f, 0.03952719f, 0.13534233f, -0.09583755f, -0.26783901f, -0.01676655f, 
    0.08173919f, 0.00596775f, -0.00271377f, -0.07297873f, 0.00849635f, 0.07291334f, -0.02608378f, 0.04272832f, 
    0.00673471f, -0.01807992f, 0.10756306f, 0.02094744f, 0.00028393f, -0.08414190f, 0.12890033f, 0.00026201f, 
    -0.06272192f, -0.07499559f, 0.02326671f, 0.11510292f, -0.06473443f, -0.00640985f, -0.03674854f, -0.09361701f, 
    0.03812132f, 0.04297421f, -0.02238001f, 0.13002059f, 0.04146961f, -0.04428414f, -0.10100856f, 0.02698661f, 
    0.03870147f, 0.04373508f, -0.05046684f, -0.06261320f, -0.06426267f, 0.29200751f, -0.21948919f, 0.00848018f, 
    -0.21699487f, 0.18799429f, -0.02797503f, -0.04195786f, 0.01825172f, -0.09549125f, -0.06245514f, 0.10714407f, 
    0.00464236f, 0.09587090f, 0.03802918f, -0.25352457f, -0.04101879f, -0.24896242f, -0.12774937f, 0.08524882f, 
    0.00471352f, 0.02505360f, -0.01533965f, 0.01847309f, -0.03837242f, 0.01011707f, 0.00097594f, -0.02487636f, 
    0.01050312f, 0.00624652f, 0.01177574f, -0.02644628f, 0.00014071f, -0.03448485f, 0.02478394f, -0.00162128f, 
    -0.00995036f, -0.02183104f, -0.01223308f, 0.01458723f, -0.03448417f, -0.03709994f, -0.04169820f, 0.02558617f, 
    -0.01383738f, -0.04034120f, -0.00631880f, 0.00925018f, 0.02854524f, 0.02995872f, -0.03409281f, 0.02198899f, 
    0.00414495f, 0.01968477f, 0.02054731f, -0.02360558f, -0.01943720f, -0.03451372f, -0.01418099f, 0.02483658f, 
    -0.00273486f, 0.03187993f, -0.01008831f, -0.04491973f, 0.04328270f, 0.00157231f, 0.00691339f, 0.01533045f, 
    -0.03620741f, -0.01251259f, -0.03023462f, -0.03069657f, -0.01151040f, 0.02689355f, 0.03176045f, 0.01798153f, 
    -0.02288576f, -0.02406365f, -0.03415239f, 0.02660208f, 0.03613300f, -0.02151728f, 0.00221279f, -0.02354260f, 
    0.00010368f, 0.02045018f, 0.01042089f, 0.02998870f, -0.02983415f, -0.03104387f, 0.03468496f, -0.02494583f, 
    -0.00155435f, 0.02372081f, -0.00488191f, 0.00880277f, 0.02606448f, -0.00798146f, -0.03757224f, 0.02646253f, 
    -0.04342711f, -0.00205954f, -0.03875580f, 0.02519459f, -0.01621365f, 0.00224349f, -0.04000418f, -0.04131858f, 
    0.01372852f, -0.00045862f, -0.02973756f, 0.02024451f, 0.02667600f, -0.01343626f, 0.01392827f, 0.02598556f, 
    -0.03498571f, -0.00503875f, 0.00337753f, 0.01710940f, -0.01933696f, 0.02089315f, 0.00877045f, 0.00602906f, 
    -0.01472138f, -0.03820370f, -0.00921589f, 0.01799843f, 0.00689837f, 0.00858784f, 0.00392384f, -0.00107870f, 
    0.03349387f, 0.02765350f, -0.04258036f, -0.00392394f, -0.02731523f, -0.02088472f, -0.03282800f, -0.00435125f, 
    0.00528143f, -0.01883357f, -0.00173577f, 0.00959484f, 0.01209624f, 0.00976317f, -0.03343631f, -0.04045385f, 
    -0.03814629f, -0.03743847f, 0.01605640f, 0.01526116f, -0.01672596f, 0.01858627f, -0.03588301f, -0.03995483f, 
    -0.00276826f, 0.01424407f, 0.01316671f, -0.04573543f, 0.01000671f, -0.00000673f, -0.02491451f, -0.02991618f, 
    0.00488801f, -0.03158940f, -0.04032087f, 0.01607538f, -0.03278026f, 0.00223152f, -0.01663238f, -0.03431892f, 
    0.02909309f, 0.01746122f, -0.01365713f, -0.00348532f, -0.00194077f, 0.02482705f, -0.00470753f, 0.01418495f, 
    -0.00957036f, -0.03103779f, -0.00741749f, 0.03076208f, 0.01152482f, 0.01882980f, 0.00310823f, -0.02336601f, 
    -0.03055626f, -0.01470818f, -0.03462044f, 0.02586249f, -0.01519186f, -0.00366194f, -0.03275657f, -0.02177744f, 
    0.00736867f, -0.01441380f, -0.01438003f, -0.02315947f, -0.02056890f, 0.01693618f, -0.03376919f, -0.00444620f, 
    -0.00686860f, -0.00092203f, -0.04866203f, 0.01799386f, -0.02952992f, -0.02760741f, 0.00308495f, -0.02349510f, 
    -0.02057499f, 0.01683886f, -0.00331778f, 0.00923674f, -0.04095739f, 0.01492095f, -0.01437941f, 0.00753097f, 
    0.01035748f, -0.00572753f, 0.00610537f, 0.02905471f, 0.00420616f, 0.00136033f, 0.01797190f, 0.01184474f, 
    -0.03305502f, -0.03068689f, -0.00288881f, 0.02399295f, -0.00739186f, 0.01286077f, 0.00410363f, -0.03807555f, 
    -0.00133751f, 0.00254629f, -0.02402415f, -0.02132408f, 0.01323542f, -0.02500022f, -0.03730884f, -0.04104555f, 
    0.03559742f, 0.01516490f, -0.01433852f, 0.01126546f, 0.02194803f, -0.03405694f, -0.01643799f, -0.03407937f, 
    0.00953282f, 0.00674893f, -0.01937427f, 0.01694717f, -0.01123077f, -0.00966338f, -0.02761283f, -0.02711453f, 
    -0.04051636f, 0.01224463f, -0.01263233f, 0.02642923f, 0.01772322f, -0.00765213f, 0.00624057f, 0.02162183f, 
    0.00396755f, 0.00830657f, 0.02182713f, -0.00083177f, -0.01864329f, 0.01547242f, -0.02244082f, 0.02433448f, 
    0.01260970f, -0.00985364f, -0.00949020f, -0.00842541f, -0.03867998f, -0.02255480f, -0.03427862f, 0.00913211f, 
    -0.04062146f, 0.00994033f, -0.02113781f, 0.02685395f, 0.00867480f, -0.02500087f, -0.01830786f, 0.02534198f, 
    0.01801648f, -0.01115130f, 0.00831730f, -0.02620962f, -0.01841567f, 0.02905060f, 0.02482950f, 0.00174205f, 
    -0.03402947f, -0.00466818f, 0.04014121f, -0.04468133f, -0.02505092f, -0.00247160f, 0.01537330f, -0.01219492f, 
    0.02972870f, -0.00095693f, -0.03229662f, -0.03538195f, -0.02822700f, -0.00809308f, 0.01451488f, -0.03548378f, 
    -0.04404493f, 0.02185644f, -0.04615280f, 0.00324328f, -0.00826764f, -0.01495798f, -0.02155555f, -0.03313787f, 
    -0.02796981f, -0.02902114f, -0.00280282f, 0.00923862f, -0.01120539f, 0.02026794f, -0.02061260f, 0.02906865f, 
    0.02666349f, 0.02760612f, 0.01392029f, -0.01859200f, -0.02254367f, -0.01543240f, -0.00570843f, -0.03534371f, 
    0.02276841f, 0.02198449f, -0.03464247f, -0.03205221f, 0.01645063f, 0.02556561f, 0.00237438f, 0.02365011f, 
    -0.03960615f, -0.02761054f, -0.02116582f, -0.02213490f, 0.02603466f, -0.00711805f, 0.00864563f, -0.04608357f, 
    0.01843572f, 0.02398130f, 0.01931001f, -0.03736556f, 0.00482483f, -0.04262850f, -0.04294240f, -0.02784902f, 
    -0.01564745f, -0.00067023f, -0.03465353f, 0.03176150f, 0.01426384f, 0.03425875f, -0.03811844f, -0.03401084f, 
    0.02894278f, -0.00002694f, -0.01017429f, -0.02725392f, 0.01966092f, -0.01212972f, -0.00344715f, -0.04235326f, 
    0.02372338f, 0.02798856f, -0.01018318f, -0.00149554f, -0.02458924f, -0.01311412f, 0.01348196f, -0.02452502f, 
    0.01252779f, 0.02822868f, -0.02438294f, 0.01957341f, 0.01933862f, -0.02732066f, -0.01142905f, 0.02495394f, 
    -0.02894952f, -0.03616966f, -0.03462852f, 0.03057559f, 0.00779519f, -0.00930039f, 0.01596482f, 0.01514024f, 
    -0.03859866f, 0.02660797f, -0.02121864f, 0.02287679f, -0.00053719f, -0.00503352f, 0.01529141f, -0.00911825f, 
    -0.01361352f, -0.03492347f, 0.00860000f, 0.01609835f, -0.01929813f, -0.02166739f, -0.00976196f, -0.03553605f, 
    -0.03893098f, 0.01339883f, -0.02874728f, 0.01515111f, 0.02852036f, 0.00318073f, -0.02950941f, 0.01502129f, 
    -0.02473315f, -0.02395531f, 0.00686340f, -0.01449735f, -0.01003804f, -0.02750306f, 0.03220613f, -0.01453924f, 
    0.03081448f, 0.01731129f, -0.00063787f, 0.02919181f, -0.01304551f, -0.00818120f, -0.00466354f, 0.02027455f, 
    -0.00236067f, 0.01841630f, -0.00383306f, -0.04021655f, -0.00167976f, 0.02825639f, -0.03719645f, 0.02450483f, 
    -0.00943336f, 0.00997203f, -0.03669365f, -0.00915395f, -0.02544918f, 0.02635299f, 0.01451370f, 0.00173429f, 
    -0.00630613f, -0.00039225f, -0.03910013f, 0.01579629f, -0.04535136f, -0.04066749f, 0.02857934f, -0.02278342f, 
    -0.03326872f, 0.00691642f, 0.02795840f, -0.03305430f, 0.02057670f, 0.01755228f, -0.01890755f, 0.01284691f, 
    0.00182246f, 0.01573572f, -0.03006159f, -0.03609635f, -0.00802225f, 0.00912120f, 0.01877953f, -0.01644829f, 
    -0.00089096f, -0.03105983f, 0.00496793f, -0.02416724f, 0.02182837f, -0.03546577f, 0.00820339f, -0.01871238f, 
    -0.02122707f, -0.02282429f, -0.04117815f, 0.02790953f, -0.00124059f, 0.02041064f, -0.04109198f, -0.03205734f, 
    -0.01962231f, -0.00863207f, 0.02996245f, 0.02062919f, -0.02158292f, 0.03093342f, 0.02398891f, 0.02164751f, 
    0.01005722f, 0.01360159f, -0.00206420f, 0.02632986f, -0.01540926f, 0.01268400f, -0.02496180f, 0.01814790f, 
    -0.04271130f, -0.03436976f, -0.02712544f, -0.00575266f, -0.00372320f, 0.01215644f, 0.00326986f, -0.00104945f, 
    0.00844723f, 0.01233777f, 0.00536774f, -0.03946670f, 0.00595200f, -0.02997386f, -0.02282117f, -0.00394635f, 
    -0.03633602f, -0.03657576f, 0.00133780f, -0.02412277f, 0.01586879f, -0.01292603f, 0.02614494f, 0.01599720f, 
    0.00645883f, 0.01185282f, 0.02414898f, -0.01131772f, -0.03210512f, -0.01424740f, -0.03220435f, 0.01497786f, 
    0.00845592f, 0.01548838f, 0.00407062f, 0.01167288f, 0.00023127f, -0.04123089f, -0.03277640f, -0.04321374f, 
    -0.00721561f, -0.02521389f, -0.02052680f, 0.00418519f, -0.04438863f, -0.04466539f, 0.00878754f, 0.01665374f, 
    -0.02757193f, -0.00454855f, -0.01945820f, 0.01525164f, 0.02742082f, 0.01476819f, -0.00957069f, 0.00942415f, 
    0.02911685f, -0.02933331f, -0.01069700f, -0.00459970f, 0.03290508f, 0.01211132f, -0.02182643f, 0.02590070f, 
    -0.00311636f, 0.00187697f, 0.02406730f, -0.03267416f, 0.02034006f, 0.02061929f, 0.02092713f, 0.00490825f, 
    -0.01521021f, 0.02331733f, -0.00111558f, 0.01306065f, 0.02940577f, -0.04235642f, -0.00597319f, 0.00984356f, 
    0.02351187f, -0.02421526f, -0.00553221f, -0.02106239f, -0.00957472f, 0.01999460f, 0.01962200f, -0.02347795f, 
    -0.01879827f, 0.01808948f, -0.03554099f, -0.04176193f, -0.03961885f, -0.00294038f, 0.02667816f, -0.04386467f, 
    -0.00289515f, -0.02991099f, 0.01583183f, 0.02288625f, 0.02581703f, -0.03037697f, -0.00022916f, -0.02322921f, 
    0.02938901f, -0.00351588f, 0.00896830f, 0.00107922f, -0.01394449f, -0.01698733f, -0.01620855f, 0.00461953f, 
    0.02885116f, -0.02060706f, -0.03645678f, 0.01749110f, -0.01460674f, 0.02424893f, 0.00823397f, -0.03387372f, 
    0.02402171f, 0.00164738f, 0.01491640f, -0.04708119f, -0.01110460f, 0.02061824f, -0.02359072f, -0.00995522f, 
    -0.03781994f, -0.01775108f, 0.00649422f, -0.03454829f, -0.02379589f, -0.04147089f, 0.00616657f, 0.03145214f, 
    0.00243369f, -0.02786371f, 0.02274530f, -0.01136526f, 0.01856771f, 0.03141212f, 0.02118604f, -0.01104454f, 
    -0.16330068f, -0.06667490f, 0.13229248f, 0.31625098f, -0.03358505f, -0.02356826f, -0.14931755f, -0.10796477f, 
    -0.23623399f, -0.04123273f, -0.02911961f, 0.05591905f, 0.02478512f, -0.06904794f, -0.10846883f, 0.07682396f, 
    0.02867615f, -0.02193293f, 0.22299777f, -0.06422182f, -0.30426744f, -0.57589477f, -0.23666796f, 0.18427283f, 
    0.06886517f, -0.13794228f, -0.23755972f, -0.05019123f, -0.00455063f, -0.01681053f, -0.06533361f, 0.00332866f, 
    0.00693403f, 0.19581521f, -0.05719762f, 0.21107274f, 0.04594966f, -0.03704609f, 0.14297314f, -0.06119958f, 
    0.22874524f, -0.19910526f, 0.23626733f, 0.04214782f, 0.34111193f, 0.08861744f, -0.01619435f, 0.04137331f, 
    0.04976167f, -0.07759688f, -0.04681014f, -0.15459441f, -0.06702352f, -0.08779338f, -0.11868604f, 0.03196024f, 
    -0.06350390f, 0.23944119f, -0.16629279f, 0.02361681f, 0.10010877f, 0.05710049f, -0.14225562f, -0.48743111f, 
    0.06059026f, -0.03334396f, -0.06348329f, -0.03711841f, -0.00629018f, 0.01163270f, 0.03804384f, 0.03360044f, 
    -0.02500115f, 0.07001775f, 0.00943668f, -0.14006275f, 0.12003912f, 0.06972627f, -0.11917765f, -0.06777176f, 
    -0.39877346f, 0.10793050f, 0.05990414f, 0.04881200f, 0.13784496f, 0.07042976f, 0.10303032f, 0.01754371f, 
    -0.12397999f, 0.09518769f, -0.10318311f, 0.07475425f, 0.17187265f, 0.06550352f, 0.13504378f, 0.01426022f, 
    0.07458343f, 0.17921087f, 0.01198921f, -0.02871576f, 0.45421451f, -0.19920006f, -0.13720113f, 0.36504242f, 
    -0.24110116f, 0.15772885f, -0.12953433f, 0.14495651f, 0.18651602f, 0.04986760f, 0.01916464f, -0.05341303f, 
    -0.09174315f, -0.11523700f, 0.00931751f, 0.03425870f, 0.12754221f, -0.01448045f, -0.21937287f, 0.19956098f, 
    0.07925329f, -0.12893932f, 0.08418693f, 0.25558537f, 0.25903910f, 0.13749509f, 0.07241706f, 0.22237195f, 
    -0.09593780f, -0.00146117f, -0.05933474f, -0.06248769f, 0.04292243f, 0.03238096f, 0.05975347f, 0.04386762f, 
    -0.04767415f, 0.00968239f, 0.00709601f, 0.04031576f, 0.93646818f, -0.16873218f, 0.17925893f, -0.22635926f, 
    0.34955156f, 0.14451297f, 0.18558377f, 0.13841425f, 0.23444133f, -0.18361188f, 0.01312883f, 0.01535498f, 
    -0.09656148f, -0.10933573f, -0.00249692f, -0.01485093f, 0.06930780f, 0.13415857f, 0.17985587f, 0.10309597f, 
    0.01959180f, -0.09584855f, 0.09251568f, -0.01242091f, -0.03975277f, -0.01620972f, 0.05174474f, 0.04618381f, 
    -0.24349411f, 0.05030526f, -0.06859544f, -0.02945184f, -0.03888963f, -0.08307827f, -0.02334456f, 0.04660625f, 
    0.00756099f, 0.02370846f, 0.04002059f, -0.10601687f, -0.17144153f, -0.33504274f, 0.10296596f, -0.09104575f, 
    0.07896292f, -0.00225640f, -0.22675271f, -0.04673256f, 0.06596020f, 0.05392556f, 0.02532214f, 0.02522848f, 
    -0.00359080f, 0.15158029f, 0.07693498f, 0.07963549f, 0.06001670f, -0.12582843f, 0.28975818f, 0.02802014f, 
    -0.14516509f, -0.11835074f, -0.26295584f, -0.07067194f, 0.00310782f, 0.06135882f, 0.00466121f, -0.02573901f, 
    -0.01935583f, 0.07424901f, -0.16107824f, 0.10407765f, 0.07509587f, 0.11501113f, 0.14867625f, 0.13372873f, 
    0.09120596f, -0.03011080f, -0.01005202f, 0.00127423f, -0.31492010f, -0.15439941f, 0.01189757f, 0.23360340f, 
    -0.23635183f, 0.16198429f, -0.05355794f, 0.04022976f, -0.21112919f, 0.09731051f, 0.02288572f, 0.12542848f, 
    0.13493751f, 0.10979893f, 0.08986434f, 0.10283247f, -0.05930452f, 0.06677786f, 0.04891612f, 0.04034532f, 
    -0.08925959f, 0.09431476f, 0.20209637f, 0.00332450f, 0.11323728f, -0.06512395f, -0.03147310f, -0.14083591f, 
    0.08980288f, -0.06252476f, 0.03162192f, 0.06713030f, -0.03863677f, -0.12195554f, -0.00191013f, 0.02742315f, 
    0.02499998f, 0.00725539f, -0.09661230f, -0.06988462f, 0.30356854f, 0.11469818f, 0.04391854f, -0.04625355f, 
    0.00929822f, 0.11579503f, -0.04759276f, 0.11649012f, 0.10752463f, -0.05731357f, -0.09879073f, 0.04579354f, 
    -0.10425118f, 0.03248720f, 0.17120568f, 0.03609675f, -0.09306969f, 0.07815894f, -0.09842449f, -0.04772428f, 
    -0.24932763f, -0.00637063f, 0.00424333f, 0.23092915f, -0.00683608f, -0.08936539f, -0.09676501f, -0.06774609f, 
    -0.10426820f, 0.00097258f, 0.16989668f, -0.01010041f, -0.20099625f, 0.01512270f, 0.04362453f, 0.15692283f, 
    -0.00328552f, -0.06972253f, -0.04829691f, -0.01533506f, -0.66008067f, -0.08851200f, 0.30274239f, 0.13451990f, 
    0.22277355f, -0.17853154f, 0.00594338f, -0.11981462f, -0.11853533f, 0.25508755f, 0.04656941f, 0.04480836f, 
    -0.02915816f, -0.10372382f, 0.01703643f, -0.05480811f, 0.01000164f, 0.02679956f, -0.01278548f, 0.01745101f, 
    0.44097751f, 0.05051740f, 0.05469122f, 0.14049436f, 0.22688752f, 0.15720324f, 0.05819163f, 0.31523746f, 
    -0.17476776f, -0.06012288f, -0.02551197f, -0.01202557f, -0.04339540f, -0.10725856f, 0.02513783f, 0.05180402f, 
    -0.03267587f, 0.30056360f, -0.08219195f, -0.01436218f, 0.25764373f, -0.05371789f, 0.06768805f, -0.34081918f, 
    0.37329102f, 0.12630321f, 0.06962518f, 0.08430380f, 0.44389331f, 0.18285067f, 0.12765983f, -0.04669077f, 
    -0.07937307f, -0.03860490f, 0.03942233f, 0.13298503f, 0.16376886f, 0.02595308f, 0.21914901f, -0.04821344f, 
    -0.64617711f, -0.08572882f, -0.03361620f, 0.23092037f, 0.00308205f, -0.02647949f, 0.00128018f, -0.10554995f, 
    -0.25321576f, 0.15248302f, -0.09518824f, 0.09088100f, 0.05639009f, 0.15360640f, -0.01990441f, 0.05469195f, 
    0.05542322f, 0.03579446f, -0.02958502f, -0.00662180f, -0.43791530f, -0.11243910f, 0.14784694f, -0.04765564f, 
    0.09920758f, 0.01298684f, -0.02476906f, -0.02623200f, -0.03422480f, 0.20879790f, -0.01814846f, 0.09608450f, 
    0.10859171f, 0.09214061f, -0.06101865f, -0.10076154f, -0.02836434f, 0.17196587f, -0.10092909f, 0.03984414f, 
    -0.42070889f, -0.10708447f, -0.02636155f, 0.16330858f, 0.18837687f, -0.10508920f, 0.07365214f, -0.10431501f, 
    -0.04746412f, -0.12397867f, 0.06192699f, -0.03893850f, 0.12289438f, 0.04076562f, 0.00747279f, -0.08054531f, 
    -0.00911922f, 0.15405348f, 0.07503398f, 0.01043686f, -0.60023731f, 0.41452283f, 0.01577971f, 0.03134829f, 
    -0.09700572f, 0.12738582f, 0.10279660f, -0.06704997f, 0.31447202f, -0.18919060f, 0.11600441f, -0.05919921f, 
    -0.11545280f, -0.08310702f, 0.12726896f, 0.20420250f, 0.13054021f, 0.11209649f, 0.08495829f, 0.11041051f, 
    -0.17417374f, 0.21910028f, 0.34561455f, 0.31563070f, -0.09467932f, -0.19018485f, -0.20199364f, -0.06854479f, 
    0.11839601f, 0.13220342f, 0.06768505f, -0.12993231f, -0.00988800f, -0.06010158f, 0.06194035f, 0.10048715f, 
    0.04595564f, 0.09416822f, 0.08066023f, 0.00045478f, 0.38923219f, -0.08979014f, 0.11859490f, -0.05902183f, 
    0.08127831f, 0.01060359f, 0.26032209f, 0.34220102f, 0.08487604f, 0.00729181f, -0.08203342f, 0.01889455f, 
    -0.08666370f, -0.11327163f, 0.08540482f, -0.06553970f, -0.01506915f, 0.09328085f, -0.11611583f, 0.01292252f, 
    -0.35206717f, -0.35417670f, 0.41570356f, 0.03525617f, -0.00715999f, -0.06766772f, 0.08828647f, -0.37884724f, 
    0.15376733f, -0.16175357f, 0.09129585f, -0.08510836f, 0.10613063f, -0.03691398f, -0.09235816f, -0.10066107f, 
    -0.00939910f, 0.04120605f, 0.26840463f, 0.00601777f, 0.61532640f, -0.29815015f, -0.25104046f, -0.12789737f, 
    0.23006453f, 0.12591495f, 0.08643492f, 0.17449611f, 0.22156045f, 0.03943670f, -0.10693302f, -0.10526608f, 
    0.04413590f, -0.08717447f, -0.08916830f, 0.10426133f, -0.06526934f, -0.05606812f, 0.03551341f, 0.18516551f, 
    -0.05868383f, -0.08316732f, -0.15248534f, -0.01743074f, 0.00610682f, 0.00869954f, 0.06297721f, 0.08215121f, 
    -0.05972993f, 0.06409811f, -0.05086437f, 0.08463723f, 0.13778394f, 0.09200037f, 0.04975900f, -0.01950606f, 
    0.01042440f, 0.18046068f, -0.13006888f, -0.07180903f, -0.42447138f, 0.29489058f, -0.33737984f, 0.20266931f, 
    0.01077200f, 0.05706928f, 0.02709973f, -0.40464646f, 0.27632377f, 0.08012208f, -0.06329799f, 0.11054953f, 
    -0.06593172f, 0.13476323f, 0.16187598f, 0.22539887f, -0.12369037f, 0.08796234f, 0.13470381f, 0.04538352f, 
    -0.07152861f, -0.12449181f, -0.22078431f, -0.01202357f, 0.11535373f, 0.00111376f, 0.05591932f, -0.16751100f, 
    -0.02875809f, -0.02023774f, -0.03031762f, 0.06392246f, 0.17714731f, 0.19177596f, 0.01584721f, 0.01847730f, 
    -0.04411061f, 0.13448817f, -0.15297301f, 0.02494714f, -0.09239931f, -0.02990100f, -0.09128834f, 0.07650775f, 
    -0.14195995f, 0.04644622f, -0.05257574f, 0.00397104f, -0.02606783f, 0.02166361f, -0.06926653f, -0.06301370f, 
    -0.09850898f, -0.08079295f, -0.10084789f, 0.05775551f, 0.06864052f, -0.02256563f, -0.21557887f, 0.12391362f, 
    -0.62958258f, 0.08437315f, 0.27860433f, -0.00279783f, 0.05354777f, -0.03188821f, -0.11035489f, -0.07029071f, 
    -0.03448709f, 0.14081514f, 0.05975663f, -0.01932885f, 0.02279503f, -0.13888673f, -0.03460242f, -0.03786612f, 
    -0.07407247f, 0.03626143f, -0.16835031f, -0.05105649f, 0.16995826f, -0.17343879f, -0.12118643f, 0.17630222f, 
    0.15322813f, -0.02130246f, 0.11539534f, 0.09701839f, 0.02544586f, -0.04712814f, 0.06053071f, 0.04615136f, 
    0.03763160f, -0.01844129f, -0.05145000f, 0.29371035f, 0.06504938f, 0.01750438f, 0.11570883f, 0.18817882f, 
    -0.00135386f, 0.00976591f, 0.00965428f, 0.00959791f, -0.00142531f, -0.01188707f, 0.02811275f, -0.03186432f, 
    -0.04002961f, 0.02323217f, -0.01223970f, -0.01493035f, -0.02272131f, -0.03369577f, 0.02095962f, 0.01235677f, 
    0.02012257f, 0.01497307f, -0.02157027f, -0.03501863f, 0.02788928f, -0.01495308f, -0.02840003f, 0.00200177f, 
    0.02492575f, -0.04276986f, 0.03121113f, 0.00444240f, -0.00635211f, 0.02394580f, -0.01953373f, -0.01192669f, 
    -0.01534236f, -0.01281141f, -0.01801410f, -0.00281692f, 0.01596697f, -0.03081183f, 0.00120005f, 0.01243705f, 
    0.02146120f, -0.02263920f, -0.03829860f, 0.02180667f, -0.00201484f, 0.01405413f, 0.00662903f, -0.01576730f, 
    0.02148310f, -0.04228275f, -0.03652291f, 0.01965035f, 0.00617410f, 0.00204484f, 0.01011658f, -0.03343235f, 
    -0.00943911f, 0.02254429f, -0.02334133f, -0.02698501f, 0.01342064f, 0.01938452f, 0.00623720f, 0.03773041f, 
    -0.03094606f, 0.03239169f, -0.00152452f, -0.04352784f, 0.03889658f, 0.03188150f, 0.01228481f, -0.01434268f, 
    -0.01505948f, -0.00622814f, -0.00452224f, 0.01595258f, -0.03793943f, 0.02918554f, -0.01218729f, -0.01882853f, 
    0.00159164f, -0.04039379f, 0.01392552f, 0.00663429f, 0.02039942f, 0.02130679f, 0.02053407f, 0.02739399f, 
    -0.04033397f, -0.02447260f, -0.02579416f, 0.02440487f, -0.03890294f, -0.02695618f, 0.00876461f, 0.00704768f, 
    -0.00692442f, 0.01514109f, -0.03748700f, 0.01172726f, -0.01062735f, 0.00592191f, -0.04014568f, 0.03784097f, 
    -0.01172425f, 0.02615750f, 0.01948365f, 0.02448584f, -0.01630072f, 0.02551350f, -0.00114025f, -0.00665244f, 
    0.00803810f, -0.00002749f, -0.01736328f, 0.03092032f, -0.00222549f, -0.04371174f, -0.03752333f, 0.01962771f, 
    0.00011364f, 0.02230223f, -0.01833412f, -0.01538612f, -0.00002235f, -0.02390704f, 0.00028643f, 0.02713199f, 
    -0.03413979f, -0.04595829f, -0.03603856f, 0.02693433f, -0.00846566f, 0.00873209f, -0.01842875f, -0.01154281f, 
    -0.02292577f, 0.01841292f, 0.02370788f, -0.02399594f, 0.01835816f, 0.02798729f, 0.00114134f, 0.00449521f, 
    0.01855878f, -0.03435273f, -0.02450094f, -0.01989155f, -0.00217289f, 0.01630192f, -0.03754080f, -0.03831497f, 
    0.00365208f, -0.04577819f, 0.03085013f, -0.02693617f, 0.00608996f, -0.04108576f, -0.04316198f, -0.01457088f, 
    -0.02984570f, -0.02461525f, -0.00169443f, -0.03797849f, -0.00082362f, 0.01927109f, -0.01415508f, 0.03539250f, 
    -0.01820349f, 0.00541671f, 0.00536261f, 0.02517696f, -0.00177681f, -0.03932184f, -0.01933310f, 0.02603953f, 
    -0.00371548f, -0.02981963f, -0.04364308f, 0.03127453f, 0.01328795f, 0.01124605f, -0.04225290f, -0.04271887f, 
    0.01764681f, -0.04656853f, -0.03286178f, -0.01018612f, 0.00824066f, -0.01258853f, -0.00728479f, -0.02090688f, 
    -0.03149788f, 0.00563266f, -0.01784788f, 0.03045204f, -0.00818603f, -0.04097490f, 0.02484854f, -0.04455679f, 
    -0.01975176f, -0.02732796f, -0.01818654f, 0.04659166f, 0.02949817f, -0.01898969f, -0.01434954f, -0.00830539f, 
    -0.02857618f, 0.03298379f, 0.00363535f, 0.02657584f, -0.00865808f, -0.02911531f, -0.00745499f, 0.00940276f, 
    0.03392688f, -0.01749778f, 0.00117125f, -0.04430172f, 0.00292428f, -0.00380963f, -0.03224821f, -0.02118518f, 
    -0.03854665f, 0.02890843f, 0.01677915f, 0.00568099f, -0.03482133f, -0.02657265f, 0.02302724f, -0.00606498f, 
    -0.00713848f, 0.02341738f, -0.01419145f, -0.02282038f, 0.01661194f, -0.01796430f, 0.01894218f, 0.02958170f, 
    0.01571383f, 0.01492617f, 0.01263728f, -0.00153629f, -0.03512479f, -0.02569451f, -0.04236099f, -0.01970966f, 
    -0.01919913f, -0.00633931f, -0.04061456f, -0.02425712f, 0.03021168f, 0.01953110f, -0.02045605f, -0.02583994f, 
    0.03027189f, -0.01802124f, 0.01630818f, 0.03341324f, -0.00209834f, -0.02224703f, -0.04465041f, -0.03581553f, 
    -0.03469286f, 0.01680873f, 0.02505928f, -0.03547828f, 0.02240288f, -0.00199308f, -0.01769304f, 0.02660996f, 
    -0.00400428f, -0.03690314f, 0.00703654f, 0.02260341f, 0.02979527f, -0.04635751f, -0.04007397f, 0.02042029f, 
    -0.03433389f, 0.00095239f, -0.02456185f, 0.01959961f, -0.00322064f, 0.02314701f, -0.03081682f, -0.00889370f, 
    -0.00747137f, -0.03017224f, 0.02645613f, -0.00352901f, 0.01951839f, -0.00491232f, -0.02137948f, 0.00816471f, 
    0.03198813f, -0.02354292f, 0.00553476f, 0.00648555f, -0.03022029f, -0.03776401f, -0.02828969f, -0.03598402f, 
    0.02707453f, 0.00905647f, 0.00993386f, 0.00945718f, 0.01754320f, -0.03212370f, -0.02297353f, -0.01504589f, 
    -0.02042148f, 0.00894160f, -0.03376590f, -0.02769670f, -0.03726116f, -0.03884263f, -0.03624967f, -0.03808846f, 
    -0.02604539f, 0.02143381f, 0.02705340f, -0.00179137f, 0.01250748f, 0.03106391f, 0.02691232f, 0.00020766f, 
    0.00035059f, 0.02685145f, 0.02449843f, -0.00273049f, 0.03232465f, -0.03770898f, -0.00008627f, 0.00645818f, 
    -0.03752250f, -0.01586554f, -0.01697074f, -0.01928083f, -0.01259976f, -0.02540768f, -0.00390079f, -0.00821502f, 
    0.01867052f, 0.00185087f, -0.01194310f, -0.04042544f, -0.00611297f, -0.01751123f, -0.04650030f, 0.01342768f, 
    0.00382908f, -0.04251179f, -0.04222346f, 0.01318785f, -0.04362301f, -0.02071967f, -0.01082613f, 0.01924594f, 
    -0.03926685f, 0.00542057f, 0.03086012f, -0.00961312f, -0.02122232f, -0.04319388f, 0.02397209f, -0.03515431f, 
    -0.00680298f, 0.02418209f, -0.02448217f, -0.02458074f, 0.02134560f, -0.00975865f, -0.03120974f, -0.01576455f, 
    -0.03745143f, 0.01993416f, 0.02732114f, 0.02238777f, 0.00517854f, -0.02654170f, -0.03895075f, -0.01434235f, 
    -0.01074492f, -0.03459671f, -0.01098641f, -0.03935002f, 0.04179574f, -0.00071688f, -0.03144447f, 0.01826845f, 
    -0.03644527f, -0.03662647f, 0.00183976f, -0.01979718f, 0.02000264f, 0.00181380f, -0.00018948f, -0.00586425f, 
    -0.00724552f, -0.02833728f, 0.01257812f, 0.00580009f, -0.01663120f, 0.01673230f, -0.00254256f, -0.03353267f, 
    -0.03386136f, -0.01510722f, 0.02083058f, 0.00382796f, 0.00487460f, -0.00535791f, 0.01552858f, 0.00052234f, 
    -0.02089510f, 0.00546231f, -0.01677870f, 0.00183792f, -0.02391976f, -0.00672386f, 0.01426286f, -0.03484402f, 
    -0.02893662f, 0.03596147f, 0.00925603f, -0.02032599f, 0.00281837f, 0.01781875f, 0.01463950f, 0.02119464f, 
    -0.02366532f, -0.02037386f, 0.01933278f, 0.02755577f, -0.02710192f, -0.02007243f, 0.02537162f, -0.03051531f, 
    0.02648635f, 0.01512277f, 0.01555194f, 0.02131050f, 0.02390999f, 0.00664279f, -0.04261267f, 0.00079727f, 
    0.01668480f, -0.01830566f, 0.00348867f, -0.02617346f, -0.00435368f, 0.03609034f, -0.01465648f, -0.03040995f, 
    -0.02439039f, -0.01037627f, 0.00674191f, 0.03352864f, -0.02439765f, -0.02701960f, -0.01592695f, 0.02414221f, 
    0.02053192f, 0.03693217f, 0.03282580f, -0.01326707f, 0.00051429f, 0.04583675f, 0.00042867f, -0.03590822f, 
    -0.03002517f, -0.02769541f, -0.04644785f, 0.03713817f, 0.03069369f, -0.04256574f, 0.02815059f, -0.02729480f, 
    -0.02953320f, 0.02798071f, 0.00696946f, -0.03689167f, -0.02582609f, -0.02108228f, 0.01958541f, -0.01630160f, 
    -0.03188028f, 0.01826935f, -0.01538408f, 0.02749427f, 0.02759678f, -0.03932485f, 0.02348352f, -0.03378531f, 
    0.01797369f, -0.02957522f, -0.00671349f, 0.00926624f, 0.01959021f, 0.00845452f, 0.01252741f, -0.00569898f, 
    0.02033792f, -0.02826917f, 0.01506476f, 0.02179644f, -0.01838553f, -0.02437468f, -0.01360568f, 0.03124050f, 
    -0.01611012f, 0.01367671f, -0.00669715f, 0.02692670f, -0.02515117f, 0.02566432f, -0.01806325f, 0.01652710f, 
    0.03075842f, 0.02474983f, 0.00180260f, 0.00187589f, 0.00072608f, 0.02601909f, 0.01704930f, 0.01768040f, 
    0.00103365f, -0.03674097f, -0.03180562f, 0.01561057f, 0.01094354f, -0.00987215f, 0.01631807f, 0.02734627f, 
    0.00860267f, -0.00713278f, -0.01339823f, -0.02834752f, -0.03016917f, -0.00400065f, 0.02645493f, 0.00299496f, 
    0.01200677f, -0.01547868f, -0.03844726f, 0.01966319f, 0.00852763f, -0.04163337f, -0.02957202f, -0.00289608f, 
    -0.00401795f, -0.04441059f, 0.01880491f, 0.01558985f, -0.01224446f, -0.01893022f, -0.01842677f, -0.01746334f, 
    0.03881620f, 0.03507636f, 0.01266339f, -0.01404659f, 0.04148904f, -0.01935006f, 0.01006362f, -0.02450112f, 
    0.01791974f, -0.02969141f, 0.01549602f, -0.01106752f, 0.01059589f, 0.02468412f, -0.00471331f, 0.00117380f, 
    0.01313435f, -0.02700819f, -0.03302398f, 0.00166033f, 0.00379437f, -0.02974488f, -0.01015268f, -0.02825244f, 
    -0.01895769f, -0.03646953f, -0.00220134f, 0.03894459f, 0.01211176f, 0.02977457f, -0.02951961f, -0.00317820f, 
    -0.02552340f, -0.03654742f, 0.02195163f, 0.00854700f, 0.00381219f, -0.03423811f, 0.01772133f, 0.02131718f, 
    0.00293601f, 0.04526417f, 0.01057802f, 0.01267479f, -0.01752788f, 0.01111999f, 0.01654177f, 0.03860176f, 
    0.02804424f, -0.02522379f, -0.02206795f, -0.01526454f, -0.03551270f, -0.01841530f, 0.00795801f, -0.04490413f, 
    -0.04934149f, -0.00227322f, -0.01669160f, 0.02604090f, -0.02591842f, -0.01795867f, 0.00147591f, 0.02788285f, 
    0.02627383f, -0.03326760f, 0.00456226f, -0.01646583f, -0.02230860f, 0.02092652f, 0.00476523f, -0.00659754f, 
    -0.01253252f, 0.00599524f, -0.03792793f, 0.02358760f, -0.01316778f, -0.04553653f, 0.00278833f, -0.00412367f, 
    0.01906736f, 0.03486301f, -0.03320772f, -0.02997404f, 0.01608573f, 0.01539213f, -0.00784916f, -0.01237270f, 
    -0.01613514f, 0.00990240f, -0.01751682f, -0.03927609f, 0.02377741f, 0.02076484f, -0.01399861f, 0.00963628f, 
    0.03149178f, 0.00560555f, 0.02746826f, -0.02996232f, 0.00607266f, -0.01851186f, 0.00982917f, -0.03236125f, 
    -0.02144943f, 0.02513621f, 0.00546007f, 0.00983155f, 0.03792830f, 0.00463464f, -0.01159425f, 0.00928997f, 
    -0.04104630f, 0.01309471f, -0.03263972f, -0.02580157f, 0.00461125f, -0.03188711f, 0.02370396f, 0.02130527f, 
    0.02965281f, 0.02650798f, -0.00742161f, 0.02569458f, 0.03050072f, 0.03177910f, 0.03845190f, 0.03167488f, 
    -0.01794642f, -0.01299281f, 0.01038698f, -0.03797718f, 0.01117796f, -0.02596849f, -0.00499168f, 0.01975364f, 
    0.02400375f, -0.00845699f, 0.00132013f, -0.00729841f, 0.00200297f, 0.03515809f, 0.02380855f, -0.01424280f, 
    0.00030678f, 0.03109214f, -0.01985675f, 0.01157962f, -0.00661798f, 0.00975877f, -0.00659579f, -0.02663347f, 
    -0.01470685f, -0.02751204f, -0.02876414f, 0.01370082f, -0.03582854f, -0.02845604f, 0.02675128f, -0.00498092f, 
    0.00357870f, 0.03231475f, -0.00359052f, -0.02452988f, 0.00722263f, -0.03879989f, -0.01713222f, -0.01005916f, 
    0.01266737f, -0.02742294f, -0.01667697f, -0.02738455f, -0.01314259f, 0.02855548f, 0.00307871f, -0.01810738f, 
    0.00177820f, 0.02736816f, -0.01146053f, -0.00485715f, 0.01385190f, -0.04028552f, -0.02849509f, -0.02789176f, 
    0.00755896f, -0.00804475f, -0.00124752f, 0.00120118f, -0.01552053f, -0.01853910f, 0.02338336f, 0.01955980f, 
    0.01581345f, 0.00053973f, -0.04056041f, 0.00555340f, -0.04822677f, -0.04428178f, 0.01104995f, -0.03522919f, 
    -0.01782816f, 0.02066533f, -0.04410002f, -0.00585233f, -0.04278262f, -0.02796433f, 0.02156279f, 0.02181580f, 
    0.01084048f, 0.00878170f, -0.03749568f, 0.02825618f, -0.01848990f, -0.02968684f, -0.03976655f, -0.03671648f, 
    0.00579319f, 0.00481976f, 0.02965748f, -0.03531999f, 0.03612569f, -0.03424550f, -0.04236728f, 0.01458800f, 
    0.00700951f, 0.02659013f, 0.03235805f, 0.01564826f, 0.00707196f, -0.01585989f, -0.03295871f, 0.02166043f, 
    -0.03414105f, 0.02407160f, -0.01154230f, -0.01797479f, -0.00624408f, -0.00222577f, -0.02854430f, 0.03276327f, 
    -0.03264964f, -0.03172908f, 0.00223689f, -0.00521228f, -0.02639724f, 0.00161508f, -0.00868826f, 0.02242507f, 
    0.02720737f, 0.02874602f, 0.01293107f, -0.01201033f, -0.00206789f, -0.02073427f, 0.02293996f, -0.00819387f, 
    0.00013900f, -0.01877797f, 0.01461239f, 0.00418490f, 0.03366949f, -0.03666248f, 0.01993535f, 0.02826716f, 
    -0.00807342f, -0.00622381f, -0.00323624f, 0.02164948f, 0.00546328f, 0.02983287f, 0.00506508f, 0.01121614f, 
    0.03240057f, 0.00660738f, -0.04398872f, 0.00171971f, 0.01826738f, -0.00506175f, -0.01542887f, -0.03912263f, 
    0.01799583f, -0.01945635f, 0.01582712f, 0.00118461f, 0.02344928f, 0.00457908f, 0.00706928f, 0.02842637f, 
    -0.01488022f, -0.01891133f, -0.01598663f, 0.01012150f, 0.03424532f, 0.00760242f, -0.03454261f, -0.02419594f, 
    0.02161179f, 0.01766054f, -0.04028549f, 0.00795919f, -0.03827602f, 0.01449486f, 0.01122042f, -0.02383325f, 
    -0.02432408f, 0.02312278f, 0.03329223f, -0.02132329f, 0.02941964f, -0.02662728f, 0.02111785f, 0.00774658f, 
    -0.03089099f, -0.03497868f, -0.04175662f, -0.03480864f, -0.00609070f, 0.01392986f, -0.02631010f, 0.02235313f, 
    -0.00777964f, -0.00872701f, -0.03461450f, -0.00673863f, -0.01331565f, 0.02751248f, -0.02997100f, -0.02933807f, 
    0.00203279f, 0.01069051f, -0.01335295f, 0.01698582f, -0.01985595f, 0.02949660f, -0.04186034f, 0.00442064f, 
    -0.01913655f, -0.01509006f, -0.02891883f, -0.02140096f, -0.03015801f, 0.00873250f, -0.02306381f, 0.01738528f, 
    0.01354026f, 0.00081669f, -0.01441301f, -0.02279511f, 0.02684061f, -0.00527088f, 0.00191885f, 0.01372560f, 
    -0.00618471f, 0.02415869f, -0.02146620f, 0.02497104f, -0.03466773f, -0.02509771f, -0.02392181f, -0.04325002f, 
    -0.02433836f, 0.01413297f, 0.04426602f, -0.03762596f, -0.03966961f, -0.03585995f, -0.01182899f, 0.02449091f, 
    -0.03021711f, 0.01627386f, 0.02378171f, -0.02917733f, -0.00618820f, 0.02434349f, 0.01190988f, -0.03790549f, 
    -0.02187702f, -0.02850488f, -0.03826140f, -0.03553472f, 0.01577477f, 0.00186320f, 0.03501179f, 0.00303888f, 
    -0.03094181f, 0.01794615f, 0.00250703f, 0.00654928f, -0.01249098f, -0.03769572f, -0.04770523f, -0.00419841f, 
    0.01261915f, 0.01983856f, -0.01893986f, 0.01590267f, -0.02775994f, 0.00990622f, -0.01664492f, -0.02825388f, 
    0.01287375f, 0.01461787f, -0.00303629f, 0.01848759f, -0.03071288f, 0.01867826f, -0.01896479f, 0.01797982f, 
    0.01033210f, 0.02479327f, -0.03274946f, 0.00194251f, -0.00009530f, 0.00883884f, -0.02699500f, -0.01053736f, 
    -0.03491458f, -0.03952280f, 0.00403592f, -0.01699793f, -0.03195012f, -0.02588256f, 0.03527044f, 0.00772817f, 
    -0.00912997f, -0.02950302f, -0.04010345f, -0.02395182f, -0.02240264f, -0.03859742f, -0.01297311f, -0.00854601f, 
    0.01221697f, -0.04670843f, 0.00480847f, 0.00244126f, 0.01059177f, 0.02207611f, -0.03014740f, 0.01997044f, 
    -0.02377096f, -0.01019685f, -0.02291198f, -0.01025778f, 0.00918663f, 0.02479410f, -0.03462211f, -0.00450002f, 
    0.02226929f, -0.02144399f, -0.03661404f, 0.01727120f, 0.03215240f, -0.04334866f, 0.02186819f, -0.02041645f, 
    -0.02173828f, -0.01928452f, 0.03617710f, -0.00393627f, -0.02753149f, 0.02233350f, -0.02323665f, 0.01038134f, 
    0.00701937f, 0.02285684f, -0.03438283f, 0.02015631f, -0.01753433f, -0.00019528f, 0.02504161f, 0.01365280f, 
    -0.01829806f, -0.00565542f, 0.03284367f, -0.03562426f, 0.01886763f, 0.01040154f, 0.02872189f, 0.00940617f, 
    0.02237142f, -0.04134026f, 0.01879175f, 0.01005195f, -0.02461460f, -0.02196827f, 0.03103626f, -0.01038092f, 
    -0.01809390f, 0.02074422f, 0.02030535f, 0.01707441f, 0.02949762f, -0.01534454f, -0.03001260f, -0.03049663f, 
    -0.03199641f, 0.02096174f, -0.03451660f, -0.00031529f, -0.02459075f, -0.03059048f, -0.03441115f, -0.02924293f, 
    -0.00109222f, -0.00408746f, 0.03277639f, -0.01736078f, 0.03153366f, -0.00499051f, 0.03788802f, -0.04225384f, 
    -0.02301014f, 0.01072000f, -0.00849340f, -0.02595086f, 0.00167315f, 0.02606489f, 0.01463597f, 0.02749587f, 
    -0.03273585f, -0.00639402f, -0.03683624f, 0.00754814f, -0.04270382f, -0.03133359f, 0.01450790f, -0.01568060f, 
    -0.01473530f, 0.01212980f, 0.02734781f, -0.00631286f, 0.02956116f, -0.00826105f, -0.02751706f, 0.00161236f, 
    0.00804314f, -0.04339936f, 0.02539928f, -0.00673812f, -0.01812171f, 0.03487118f, 0.00251063f, 0.03102651f, 
    -0.03035384f, -0.03108368f, 0.03457678f, -0.00161105f, 0.00418403f, -0.02172567f, -0.00771755f, -0.02587758f, 
    -0.00092534f, -0.03431876f, -0.03984579f, -0.03856169f, 0.02738473f, -0.04850895f, -0.04456446f, -0.02132084f, 
    0.00263364f, -0.00061093f, 0.00264206f, -0.03086196f, 0.00389219f, 0.02557265f, -0.01432984f, 0.03106423f, 
    0.01448947f, 0.00482546f, -0.01729624f, -0.03407335f, -0.00395811f, 0.01979907f, 0.03409880f, -0.01775330f, 
    0.02918096f, 0.01424515f, 0.02098623f, -0.01825905f, 0.00950560f, 0.01698169f, -0.00957726f, -0.02585624f, 
    0.00721572f, 0.02742250f, 0.02968890f, -0.00894606f, -0.02676979f, -0.01675828f, 0.01846278f, -0.04061759f, 
    0.02519220f, -0.02827653f, -0.01701575f, -0.00104925f, 0.00471112f, 0.01971681f, 0.00513881f, -0.00025358f, 
    0.02593779f, -0.00057856f, 0.01799654f, 0.02667630f, -0.00134934f, -0.00476596f, -0.02778908f, -0.00009848f, 
    -0.04209467f, -0.04437076f, -0.01387694f, 0.03117024f, -0.00107216f, -0.01220609f, -0.02544086f, 0.02196531f, 
    0.00249464f, -0.02277272f, -0.01442767f, -0.00686878f, -0.03756420f, -0.00024716f, 0.01355096f, 0.00471006f, 
    -0.00425107f, 0.01088403f, 0.03329311f, -0.02092964f, 0.03387498f, 0.01378772f, -0.02550514f, -0.03041019f, 
    -0.02536838f, -0.01476786f, -0.00418655f, -0.04206147f, 0.02135736f, 0.02799802f, -0.00859545f, -0.00434755f, 
    0.02383278f, -0.02091180f, -0.03127260f, -0.00175889f, 0.03745001f, 0.00833111f, 0.02832766f, -0.04355744f, 
    -0.00220392f, -0.03137914f, -0.03616364f, -0.00635421f, -0.00559890f, 0.02628218f, 0.03253317f, -0.00782347f, 
    -0.04013536f, -0.02807484f, -0.01397693f, 0.01035302f, 0.04355240f, -0.03135471f, -0.01906414f, 0.01432685f, 
    0.03711037f, -0.00472577f, -0.02285655f, 0.01025574f, -0.04861808f, -0.04338899f, 0.01684644f, -0.01028294f, 
    0.01800662f, 0.03222587f, 0.02643379f, 0.01406632f, -0.00593223f, 0.01483649f, -0.01740115f, 0.02485109f, 
    -0.01239305f, 0.01917646f, 0.00613802f, -0.03528490f, -0.03582614f, 0.02564323f, -0.03886903f, 0.02193023f, 
    -0.00018011f, 0.02945673f, -0.01268086f, 0.00998604f, -0.01679644f, 0.01692428f, 0.01875295f, 0.03063697f, 
    -0.00926743f, -0.00638161f, -0.00001207f, 0.02199700f, -0.01068105f, 0.02291961f, 0.02943417f, 0.00582151f, 
    -0.02005464f, -0.00659317f, 0.00756570f, -0.01662549f, 0.02587990f, -0.03230254f, -0.03728726f, 0.03002748f, 
    -0.03988047f, -0.02830504f, -0.01807080f, 0.01217370f, 0.01133697f, -0.03279864f, 0.01895115f, -0.02781126f, 
    -0.20455304f, -0.35163221f, -0.12713706f, 0.01086786f, -0.25287476f, -0.06263472f, -0.01028619f, 0.11938260f, 
    0.14878777f, 0.20175080f, -0.01333784f, 0.00024596f, 0.12987167f, -0.07881403f, 0.03028915f, -0.05007347f, 
    0.09932896f, 0.07465044f, 0.05912758f, 0.07152525f, -0.03394499f, 0.17261070f, 0.02739293f, -0.08988589f, 
    -0.14213072f, 0.25189444f, -0.10601740f, -0.02814833f, -0.05102340f, 0.17530018f, 0.10321842f, -0.02525648f, 
    0.09225719f, 0.05403399f, 0.10797656f, 0.04074201f, -0.03310553f, -0.01353286f, 0.03762798f, -0.07637607f, 
    0.28997052f, 0.50961691f, 0.02947299f, 0.11868606f, 0.02864592f, -0.10876569f, 0.03153495f, 0.09395106f, 
    -0.04908676f, -0.04238736f, -0.01867041f, 0.02143104f, -0.01450361f, 0.03181871f, 0.03161614f, -0.09509509f, 
    -0.01464349f, -0.06261037f, 0.11844373f, -0.03938586f, -0.32719922f, 0.09538404f, 0.06171994f, 0.29136157f, 
    0.00432881f, -0.08283612f, 0.03328672f, 0.01845455f, -0.06286179f, -0.03195388f, -0.22211744f, -0.03934537f, 
    -0.01667478f, 0.07916781f, 0.15514335f, 0.31860328f, -0.02929175f, -0.17541414f, 0.08695720f, -0.05482652f, 
    -0.03476076f, -0.25514361f, -0.29860038f, -0.00379285f, -0.01326358f, -0.09199874f, -0.07400934f, -0.05187066f, 
    0.15198547f, 0.07422465f, 0.03376220f, 0.02181569f, 0.01990535f, -0.00687643f, -0.06447981f, 0.15495527f, 
    -0.11730214f, -0.14876199f, 0.15790641f, 0.15407576f, 0.60324365f, 0.31436375f, 0.15092398f, 0.17120087f, 
    0.36361986f, -0.02261203f, 0.07708056f, -0.01290905f, -0.10160643f, -0.09351402f, 0.07578659f, -0.04936238f, 
    0.08646950f, 0.00965168f, -0.02318058f, 0.04078762f, -0.05185570f, 0.16011722f, 0.18288712f, -0.05611668f, 
    0.15174754f, 0.30002338f, 0.08357494f, 0.09649730f, -0.06381661f, -0.13686801f, 0.03240878f, -0.01808333f, 
    0.16038172f, -0.03631966f, 0.02710602f, 0.03976581f, 0.03849146f, 0.10642068f, -0.02434907f, -0.02263213f, 
    0.16185488f, 0.14617895f, 0.11345098f, -0.05547733f, -0.01387672f, 0.19370943f, -0.37159237f, 0.01495120f, 
    -0.20921712f, 0.05617044f, -0.14747775f, 0.05264840f, 0.22269467f, 0.07694981f, -0.00791342f, -0.01780940f, 
    0.02005435f, 0.01293447f, -0.02001079f, 0.21749175f, 0.13835771f, -0.10776275f, -0.03202294f, -0.01315304f, 
    -0.24332771f, -0.34862390f, -0.09943656f, 0.12603249f, -0.10403189f, 0.00015279f, -0.11762287f, -0.10095911f, 
    0.03740554f, -0.02452985f, -0.06420438f, 0.04309760f, 0.12183753f, -0.05252294f, 0.08529358f, -0.00903822f, 
    0.10228676f, -0.01003564f, -0.05949571f, 0.00127992f, 0.06932592f, -0.13364342f, -0.10534929f, -0.08936867f, 
    -0.20500606f, 0.22513577f, 0.00830682f, 0.01084246f, -0.15737855f, 0.24644633f, 0.10162225f, 0.04168553f, 
    0.01784804f, -0.03147058f, 0.04493136f, 0.06269599f, 0.03058541f, 0.06376133f, 0.08364802f, 0.12525901f, 
    0.13334453f, 0.21262331f, 0.21941715f, 0.09035953f, -0.03242427f, -0.04959984f, -0.04189534f, -0.06752474f, 
    -0.03882423f, -0.08391262f, 0.34693775f, -0.00877645f, 0.07110795f, 0.09794881f, 0.07699583f, -0.18874797f, 
    -0.10956757f, 0.05576030f, 0.03706504f, -0.02936156f, 0.24171858f, -0.10930638f, -0.03905734f, 0.16800261f, 
    0.13454351f, -0.00917966f, 0.25151542f, -0.05117396f, 0.22454107f, 0.07744358f, 0.09659903f, 0.09072924f, 
    -0.08459559f, 0.01251915f, 0.05966787f, 0.05172060f, 0.15072174f, 0.12170390f, 0.05599828f, 0.13871291f, 
    -0.06042161f, -0.01683737f, -0.12542798f, -0.01712419f, -0.22805160f, -0.03226442f, -0.02440471f, 0.01681901f, 
    0.01264356f, 0.02806730f, 0.07295471f, 0.02838206f, 0.10507071f, 0.16975728f, -0.06183282f, -0.04781620f, 
    -0.02074612f, -0.03247374f, 0.03959265f, 0.02704061f, -0.03483204f, -0.02350469f, 0.13032022f, 0.16160691f, 
    -0.04358406f, -0.03500224f, 0.01482611f, 0.03275996f, 0.07718061f, 0.04461119f, 0.10574532f, -0.05188797f, 
    0.07968959f, -0.00561253f, 0.06701235f, 0.00083882f, 0.10922740f, 0.01806457f, 0.06672859f, 0.02192285f, 
    0.06336713f, 0.02328888f, 0.04903289f, -0.12301813f, -0.02021149f, -0.06325195f, -0.04111643f, -0.01124122f, 
    -0.02742039f, -0.05453588f, 0.09520350f, -0.04317248f, 0.18909170f, 0.01218235f, -0.07522015f, -0.18393624f, 
    0.12177915f, 0.03248793f, -0.01789313f, 0.04786270f, 0.07095660f, -0.15264694f, -0.23318067f, 0.02073888f, 
    -0.41035676f, 0.00558884f, -0.02468361f, -0.06748056f, 0.01925507f, 0.12157942f, 0.17777260f, 0.10179335f, 
    0.14665386f, -0.01565357f, 0.04628011f, -0.02392908f, 0.00627169f, 0.01701394f, 0.09572913f, -0.06952481f, 
    -0.05498863f, 0.15649754f, 0.11711418f, 0.08782569f, 0.00515571f, -0.17160806f, 0.07966296f, 0.00107016f, 
    0.25455555f, -0.00009823f, 0.09276422f, 0.12763418f, 0.00433099f, 0.22882965f, 0.03662544f, 0.03781378f, 
    0.09528227f, -0.08562225f, 0.00869431f, 0.06688611f, -0.01432356f, -0.19785574f, -0.07210866f, 0.03357698f, 
    -0.17185409f, 0.15464818f, 0.00312350f, 0.03564226f, -0.17097841f, 0.05898816f, 0.02976195f, 0.08531082f, 
    0.11855159f, 0.09294546f, -0.04041808f, 0.04328393f, 0.06577816f, 0.02663891f, 0.26824048f, 0.12907267f, 
    0.16478786f, -0.36362568f, -0.39826187f, -0.14789174f, -0.28648019f, -0.05098883f, -0.08513004f, -0.14045343f, 
    0.26753390f, 0.08168110f, 0.05701960f, -0.01312597f, 0.04213027f, -0.09454194f, 0.01114835f, 0.00836102f, 
    -0.04977725f, -0.05453312f, 0.14641167f, 0.11293990f, 0.10691784f, 0.05593255f, -0.09851805f, -0.07426139f, 
    -0.18869916f, -0.13381222f, -0.05368500f, -0.10968999f, -0.07346663f, -0.16316515f, 0.11587062f, 0.00215677f, 
    0.07197323f, 0.05672373f, 0.04822467f, 0.03334713f, -0.07494157f, -0.10776429f, 0.07925980f, -0.00281929f, 
    0.04995072f, -0.23824474f, -0.10937640f, -0.18993534f, -0.19806564f, -0.06498477f, -0.10223819f, -0.17422509f, 
    0.03457819f, 0.05349165f, -0.03791023f, -0.04945830f, 0.05154929f, -0.05522368f, -0.04952779f, 0.10424833f, 
    -0.05546838f, 0.12711263f, 0.13351712f, 0.05647309f, 0.87659317f, -0.18520783f, 0.29225293f, 0.19995497f, 
    0.21546914f, 0.00897882f, 0.15891674f, -0.00368162f, -0.06373751f, -0.02155426f, -0.00446367f, -0.01673328f, 
    0.25824922f, 0.07368866f, -0.00006216f, 0.04369467f, -0.01284760f, 0.10028894f, 0.05009999f, -0.14227763f, 
    -0.12534554f, -0.11278956f, -0.08605731f, -0.28874049f, -0.08492815f, -0.03368198f, 0.01504499f, 0.03222284f, 
    0.03813577f, 0.01786880f, -0.08089841f, -0.00145977f, 0.12121657f, 0.07999057f, 0.02265563f, -0.03360247f, 
    -0.00037660f, 0.01062862f, -0.05123323f, 0.12223091f, 0.26923925f, 0.28805399f, 0.04264525f, 0.14822038f, 
    -0.04002373f, -0.03519222f, -0.16029070f, -0.07549648f, 0.11269614f, -0.02885535f, -0.01701256f, -0.06469063f, 
    0.01086300f, 0.02931692f, -0.05309219f, -0.00609907f, -0.03919024f, -0.08874276f, -0.00745580f, 0.05378990f, 
    0.04488376f, -0.24897186f, -0.25474665f, -0.06076284f, -0.26492116f, -0.01568792f, -0.19076762f, 0.12908210f, 
    0.04151829f, 0.14708117f, 0.04090156f, 0.00932254f, 0.04189772f, -0.02215059f, 0.00465022f, -0.05243325f, 
    0.06638172f, 0.18690045f, 0.05895188f, 0.09090898f, 0.26864898f, 0.37881202f, -0.03123858f, 0.27997267f, 
    -0.02419084f, 0.01068656f, 0.08494705f, 0.03651373f, 0.08761378f, -0.04674809f, -0.00654444f, 0.08098456f, 
    0.10655425f, 0.00985830f, 0.01077268f, 0.08977348f, 0.23919876f, -0.11325143f, 0.17181163f, 0.00209666f, 
    0.12969483f, 0.17735106f, 0.16813445f, 0.13117105f, 0.01856240f, 0.05515347f, 0.07404007f, -0.01217243f, 
    0.01334811f, -0.02012731f, 0.11030179f, 0.09925671f, 0.03988923f, 0.04924150f, 0.07246968f, -0.19501467f, 
    -0.05125592f, 0.03938469f, 0.05772389f, -0.00878141f, 0.36573198f, -0.49929726f, 0.15451330f, -0.09801633f, 
    -0.02814107f, 0.03646715f, 0.03459455f, 0.13312253f, 0.07806938f, 0.06141551f, 0.20355600f, 0.13444109f, 
    0.03147503f, -0.05618411f, -0.05753160f, 0.04693232f, -0.01826281f, 0.10094655f, -0.06428628f, 0.10927477f, 
    0.29651183f, 0.24469745f, 0.27516872f, -0.02822492f, 0.06012764f, -0.04833632f, -0.04192423f, 0.06747738f, 
    0.14018264f, -0.09262341f, 0.09477397f, 0.11302775f, -0.09624809f, -0.04972735f, 0.08066425f, -0.10973021f, 
    -0.02348940f, 0.03332292f, -0.03256191f, 0.05537967f, 0.33400831f, 0.32131848f, 0.35982242f, 0.10396361f, 
    0.14767569f, -0.07547849f, 0.04514838f, -0.01054340f, -0.04695695f, -0.08118329f, 0.10257269f, -0.00509720f, 
    0.10751055f, -0.00123473f, 0.01110760f, 0.06812804f, -0.05482708f, -0.09881087f, 0.12155765f, -0.12454722f, 
    0.14802368f, -0.13475651f, -0.21464954f, -0.07665525f, -0.26748487f, -0.14728287f, -0.01460599f, -0.03718857f, 
    -0.02048144f, -0.09761759f, 0.14361942f, -0.01309240f, -0.08098552f, 0.07247569f, -0.02977683f, -0.06014781f, 
    -0.02149149f, -0.05344489f, 0.01120822f, 0.01341610f, 0.04281111f, 0.05841454f, -0.17039636f, 0.03130678f, 
    -0.05316717f, 0.12716870f, -0.05571891f, -0.13397707f, -0.15559535f, -0.09289400f, 0.01647454f, 0.07012378f, 
    0.09696819f, 0.11491296f, 0.12843651f, -0.08604933f, -0.18532835f, -0.07568074f, -0.09194684f, -0.20669723f, 
    0.03311045f, 0.01030441f, -0.03956367f, 0.03025034f, -0.03990491f, -0.00003760f, -0.04193905f, 0.00747406f, 
    0.02196774f, -0.04364612f, 0.01274959f, -0.03118972f, -0.02985384f, -0.02215579f, -0.02353783f, -0.03250753f, 
    0.00138171f, 0.01322206f, -0.03380995f, -0.03109074f, 0.03579676f, 0.00599038f, 0.00844295f, -0.01790811f, 
    -0.02475904f, -0.01837708f, -0.00795809f, -0.02664515f, 0.00775080f, 0.02531146f, 0.02226589f, -0.00825081f, 
    -0.00092747f, -0.04400583f, 0.01185534f, 0.02759807f, 0.03005212f, -0.01543199f, 0.02914669f, -0.02044465f, 
    -0.02938635f, 0.03279749f, 0.02228042f, 0.02151853f, -0.00965561f, 0.00455738f, -0.03163861f, 0.02371859f, 
    -0.00927124f, -0.04175889f, -0.02040095f, -0.04045369f, -0.02386085f, 0.02090992f, -0.03477246f, -0.00452099f, 
    0.00274717f, -0.02926765f, -0.01593756f, 0.02509944f, -0.04031126f, 0.01268298f, -0.02617266f, 0.01768772f, 
    -0.04103923f, -0.00653676f, -0.02656603f, 0.01455658f, -0.04326857f, -0.02043668f, -0.03274674f, 0.03173602f, 
    -0.00030106f, -0.03095188f, 0.00676548f, -0.03861602f, -0.03746952f, -0.01409209f, -0.02012907f, 0.02772801f, 
    -0.02468550f, 0.00685892f, -0.04006411f, -0.03125211f, -0.00584002f, 0.01801238f, -0.04145748f, -0.00929000f, 
    0.01241843f, -0.02331689f, -0.01037045f, -0.04294940f, 0.00971768f, -0.01084453f, 0.00342893f, -0.00988907f, 
    -0.03358945f, -0.01949070f, 0.01797561f, 0.01703226f, -0.00273075f, 0.02081946f, -0.04122674f, 0.03103580f, 
    -0.00579674f, 0.00569348f, -0.00767285f, 0.01662744f, -0.02521998f, -0.00689524f, -0.00432885f, 0.01165923f, 
    0.02497636f, -0.00737326f, -0.01483382f, 0.00660664f, -0.01966212f, -0.02014910f, -0.03188347f, -0.00273131f, 
    0.01037896f, 0.00497876f, -0.02600831f, 0.01216609f, 0.02755719f, -0.00167786f, 0.02723720f, 0.00311107f, 
    -0.03707211f, -0.00782416f, 0.03380334f, 0.01015341f, -0.01202043f, 0.00911465f, -0.02677850f, 0.01293252f, 
    0.02456467f, -0.02847809f, -0.01815187f, -0.01640001f, 0.01573378f, 0.01101772f, -0.00754988f, 0.01491981f, 
    0.00907650f, -0.03502316f, -0.02972245f, 0.02923038f, 0.03297523f, -0.03132532f, 0.02240426f, -0.01818666f, 
    0.03186346f, 0.02563103f, 0.00425939f, -0.00675649f, 0.01414413f, -0.03963346f, -0.03078945f, -0.02287013f, 
    -0.03638588f, -0.00746900f, 0.02241604f, -0.01396702f, 0.00906600f, -0.03761727f, -0.00545806f, 0.03145926f, 
    -0.02720216f, -0.02993076f, 0.02180915f, -0.00881912f, -0.03514934f, -0.03594951f, -0.03953671f, 0.02969511f, 
    0.02981154f, -0.00472872f, -0.01694552f, 0.03297327f, -0.02956911f, 0.04023139f, 0.00921917f, -0.03193137f, 
    0.01615940f, -0.00852784f, 0.01837366f, -0.00164246f, -0.01833337f, -0.01492954f, -0.04278971f, -0.01722803f, 
    0.00733900f, -0.01289351f, -0.03013668f, 0.01942184f, -0.03165349f, 0.03277437f, -0.03230236f, -0.04462458f, 
    -0.02949020f, -0.01123970f, -0.03229714f, -0.04313010f, -0.00115414f, 0.02690977f, 0.00313193f, 0.02734082f, 
    -0.01744287f, 0.02178993f, 0.03192796f, -0.02985312f, -0.02046095f, 0.02919403f, -0.01464231f, -0.03152537f, 
    -0.01171195f, -0.01952035f, -0.00557274f, -0.01995694f, -0.01023521f, -0.03771801f, -0.03749666f, 0.00733439f, 
    -0.00560130f, -0.01747178f, 0.03425549f, -0.02471102f, 0.01647916f, -0.03367312f, 0.00066991f, 0.02451058f, 
    0.00610226f, -0.02761521f, 0.02748382f, -0.04411617f, -0.03902063f, -0.03883736f, -0.03497534f, 0.02479237f, 
    0.03021223f, -0.00733281f, 0.00274334f, 0.00875762f, 0.01659405f, -0.00708400f, -0.03661935f, -0.03328492f, 
    -0.01109209f, -0.02627002f, -0.00509684f, -0.04499447f, 0.01955883f, 0.03110536f, -0.02501523f, -0.02705598f, 
    0.02222104f, 0.01518675f, -0.00029311f, -0.01071932f, 0.00951117f, -0.02914300f, -0.01494074f, -0.00592793f, 
    0.01027046f, -0.00780797f, -0.01972186f, -0.01955979f, -0.02645816f, 0.01833165f, -0.03703474f, -0.03259308f, 
    0.00998020f, -0.01232515f, 0.00395300f, -0.02805817f, -0.03796931f, 0.02084373f, -0.00247137f, -0.01107612f, 
    0.01892200f, -0.02150220f, -0.01703160f, -0.01804003f, 0.00541064f, -0.03289856f, 0.01267961f, -0.01231224f, 
    -0.00621877f, 0.03496763f, -0.04494974f, 0.01568716f, -0.00697503f, 0.03349099f, 0.02669495f, -0.00100939f, 
    -0.02011437f, -0.01356418f, 0.00250739f, -0.01281059f, 0.01696089f, 0.01568460f, 0.02855158f, -0.01427414f, 
    -0.00697456f, 0.02838777f, -0.00269056f, -0.03897361f, -0.02427286f, -0.01298311f, -0.00186020f, -0.00362762f, 
    -0.02820294f, -0.04312870f, 0.02270382f, -0.03025593f, -0.02626060f, -0.03833951f, 0.03441502f, -0.03543767f, 
    -0.03691751f, -0.03547152f, -0.02751944f, -0.00973434f, -0.03546826f, 0.02039298f, -0.03878167f, 0.01767499f, 
    -0.02966519f, 0.02823942f, -0.03783496f, 0.03021350f, 0.01636907f, -0.01227690f, 0.02320838f, -0.01054697f, 
    -0.03964770f, 0.02312831f, 0.02644991f, 0.01621208f, -0.01147226f, 0.03120585f, -0.00677464f, 0.00430821f, 
    -0.02110893f, 0.02203240f, 0.01683602f, 0.01869764f, -0.02708717f, 0.01994065f, -0.02642679f, -0.01505299f, 
    0.01188169f, 0.01878108f, 0.02268292f, 0.02690291f, -0.00698916f, 0.00183644f, 0.02853804f, 0.00536911f, 
    -0.02671052f, -0.03237633f, -0.00590534f, 0.00624886f, -0.04506283f, -0.00651681f, -0.01356088f, -0.01292843f, 
    -0.04261395f, 0.01918132f, 0.00251343f, -0.04251503f, -0.00645626f, 0.02154785f, 0.00136216f, -0.01512091f, 
    -0.01252288f, -0.00753095f, -0.00263585f, -0.00109766f, -0.00584349f, -0.01797984f, -0.02932742f, -0.03515571f, 
    -0.02136922f, -0.00687553f, -0.00058223f, -0.01379737f, 0.02311019f, 0.00940574f, 0.02832984f, 0.02754210f, 
    0.02195351f, 0.00052322f, 0.00222217f, -0.02108213f, 0.00947754f, -0.02987839f, -0.01513850f, -0.00957339f, 
    -0.03881318f, 0.00096488f, 0.01472212f, -0.01750890f, 0.02347042f, 0.02566977f, -0.03718090f, -0.01411396f, 
    -0.02281024f, 0.02563830f, -0.02200634f, -0.00308847f, 0.02494145f, -0.02188816f, 0.03144296f, 0.01731175f, 
    -0.04368485f, -0.03190658f, -0.02988102f, 0.00743247f, -0.00006271f, 0.00071135f, 0.01262195f, -0.02526472f, 
    0.02780786f, -0.03382462f, -0.03116618f, -0.01510370f, 0.01873660f, -0.01598836f, 0.00741179f, 0.01194045f, 
    0.03089944f, -0.03928816f, 0.00373120f, -0.01219307f, 0.00694598f, -0.04425821f, -0.01938310f, -0.01454351f, 
    0.00186521f, -0.00790618f, 0.02585881f, -0.04075125f, 0.01921442f, 0.00163202f, 0.01031863f, -0.01709575f, 
    -0.01212943f, 0.01359172f, 0.00769729f, 0.00310288f, -0.03227668f, 0.03237875f, -0.01586047f, 0.01867882f, 
    -0.03468142f, 0.00741799f, -0.03086658f, -0.01417803f, 0.00992301f, 0.01688921f, -0.01673384f, 0.03326510f, 
    0.02688314f, -0.02676526f, -0.03675064f, 0.02162822f, 0.00402713f, -0.01842526f, 0.02479769f, 0.00197167f, 
    0.00497150f, 0.01072042f, 0.00406137f, 0.01853878f, 0.01638707f, -0.03407799f, -0.01936650f, 0.03065015f, 
    -0.00889777f, 0.00290503f, 0.01203795f, 0.03190114f, -0.01831957f, -0.03700859f, -0.02398838f, -0.04352572f, 
    -0.04441286f, -0.00289637f, -0.00791994f, -0.00453752f, 0.03046649f, -0.00717750f, 0.02558547f, 0.00058361f, 
    -0.02265853f, 0.00855026f, -0.00940154f, -0.00299991f, -0.02433161f, -0.03621143f, 0.03426548f, 0.00235899f, 
    0.01201656f, 0.03213384f, 0.00542653f, 0.01644808f, 0.01902588f, -0.03795642f, -0.03948376f, 0.03275504f, 
    0.01856330f, 0.02564479f, -0.01313640f, -0.00149464f, -0.00775432f, -0.01907904f, -0.01130343f, 0.01032080f, 
    -0.00986259f, -0.02877814f, 0.01221146f, 0.01095589f, 0.03110214f, -0.02662985f, 0.02148864f, -0.03638082f, 
    -0.01587661f, 0.00752563f, -0.04209467f, -0.02493237f, -0.00692943f, 0.00098859f, 0.02425436f, 0.00132007f, 
    0.03438692f, 0.03315123f, 0.00135354f, 0.01821391f, -0.04269417f, -0.04476047f, -0.01322630f, -0.02070535f, 
    -0.03143661f, -0.03745090f, -0.04444760f, -0.01235302f, 0.01345916f, -0.00895662f, -0.03862480f, -0.03230272f, 
    0.03078942f, 0.02737525f, 0.00069432f, -0.03840021f, -0.01940423f, 0.02694897f, -0.01674983f, 0.01750391f, 
    0.01895503f, 0.02137510f, 0.03174561f, -0.02266332f, -0.01101129f, -0.00917203f, -0.01878142f, 0.00120761f, 
    0.01151882f, 0.01911692f, -0.01488135f, 0.02594544f, -0.00349430f, 0.01364789f, 0.02956144f, 0.02951647f, 
    -0.01886670f, 0.01374633f, -0.02145724f, -0.00924442f, -0.00990374f, 0.01348182f, 0.01992185f, 0.00066416f, 
    0.02313011f, 0.01599096f, 0.00088090f, 0.01390155f, -0.00884844f, -0.02703004f, 0.00822421f, 0.02608651f, 
    -0.01669058f, 0.00815743f, -0.02564976f, 0.01570593f, -0.00118499f, 0.02689269f, -0.01809109f, -0.01465102f, 
    -0.00400335f, 0.02797971f, -0.03410856f, -0.02226759f, 0.01819589f, -0.00187677f, -0.00399530f, 0.00587682f, 
    0.01435909f, 0.03319436f, -0.02188748f, 0.03231500f, -0.00562047f, -0.00036966f, -0.02601151f, -0.03168477f, 
    0.02045403f, 0.02133833f, 0.01028862f, -0.00587678f, 0.01337137f, -0.02466725f, -0.02915444f, 0.00276017f, 
    -0.01658121f, 0.00840146f, -0.01520385f, 0.01634206f, -0.03371800f, -0.01387076f, -0.01127227f, 0.02643010f, 
    0.00351645f, -0.00821648f, -0.03337666f, -0.01337814f, -0.03642785f, 0.01959517f, -0.00423261f, 0.03313014f, 
    0.00533675f, 0.03453801f, 0.01719046f, 0.01712062f, 0.03487634f, -0.01306549f, 0.02766951f, 0.00424778f, 
    0.03094746f, 0.02875756f, 0.00006277f, 0.01149002f, -0.00810395f, -0.03976560f, -0.02230112f, 0.01339063f, 
    0.00472692f, -0.01229320f, 0.00328809f, 0.01225544f, 0.00744708f, -0.02093397f, -0.00274031f, -0.00449612f, 
    -0.03023724f, -0.00362303f, -0.00058077f, -0.02182069f, 0.00250873f, -0.01415515f, -0.00670246f, 0.03512298f, 
    0.01838554f, 0.00157562f, -0.02146777f, 0.00829404f, -0.01177459f, -0.00743368f, -0.00067135f, -0.01339654f, 
    -0.01403315f, -0.03603975f, -0.03786241f, -0.03425926f, -0.00822317f, 0.03314240f, 0.02424975f, 0.00326622f, 
    -0.03534747f, -0.03548451f, -0.02300187f, 0.01631981f, 0.01252438f, 0.02960686f, 0.00597713f, -0.01211645f, 
    -0.01646939f, -0.03413508f, -0.01542861f, -0.01203852f, -0.02421185f, 0.00922928f, -0.03404404f, 0.00179316f, 
    -0.01464100f, 0.02111468f, -0.02268698f, 0.00703375f, 0.01512012f, 0.01237336f, 0.02099435f, 0.01342328f, 
    -0.03198804f, -0.00650092f, -0.02620606f, -0.03594510f, -0.02491855f, 0.03328959f, -0.02081105f, 0.02784797f, 
    0.00665785f, -0.00643027f, 0.03487944f, -0.00036021f, -0.00013614f, -0.01841772f, -0.03390528f, -0.00679454f, 
    0.01803230f, 0.00193741f, -0.03633421f, 0.02357880f, 0.02052225f, -0.01947680f, 0.01049097f, -0.04184568f, 
    -0.02137513f, 0.00644742f, -0.03241837f, -0.04274464f, -0.00419779f, 0.00687872f, -0.01428143f, -0.01061113f, 
    -0.02622503f, 0.00963401f, 0.01420613f, -0.00982016f, 0.02760096f, -0.02991549f, 0.00308205f, -0.00131679f, 
    -0.00330644f, -0.00270122f, -0.01480173f, 0.01308231f, -0.02531741f, 0.00964788f, 0.03677577f, 0.00614973f, 
    -0.01729782f, 0.01495480f, 0.01239947f, 0.00097853f, -0.01087046f, -0.02886946f, 0.02949105f, 0.01789464f, 
    0.00396783f, -0.04399073f, -0.02266601f, 0.00656021f, -0.01493833f, -0.02213699f, 0.01330313f, -0.04139084f, 
    0.02764883f, 0.02640033f, 0.01334693f, 0.00766740f, -0.01402968f, 0.03794298f, -0.01942966f, 0.00128758f, 
    0.02255414f, -0.02123912f, -0.04188123f, -0.02140457f, 0.02484330f, -0.03582034f, -0.04524938f, 0.00687170f, 
    -0.01644536f, -0.02179391f, -0.04791289f, 0.01797711f, -0.01081882f, -0.03459314f, 0.00973181f, 0.01036619f, 
    -0.02721607f, -0.00015291f, 0.01863012f, -0.01635570f, 0.00406343f, 0.01157351f, 0.01832341f, -0.03046880f, 
    -0.01716839f, 0.02214028f, -0.04363656f, 0.02146744f, -0.04212026f, -0.02514309f, -0.01114414f, -0.01347736f, 
    0.00581247f, -0.03224456f, -0.02840016f, 0.01707820f, 0.00557544f, 0.02024606f, 0.00833916f, 0.02700456f, 
    -0.03782837f, -0.01961672f, 0.03554972f, 0.02698091f, -0.01813248f, -0.02852534f, 0.01922176f, -0.03771105f, 
    0.01148379f, -0.04576618f, -0.03350139f, -0.04580842f, -0.00881591f, -0.01799000f, -0.03806629f, 0.02094217f, 
    0.00491010f, 0.03549932f, 0.03054160f, 0.04068165f, 0.01582309f, 0.01690297f, 0.01283521f, 0.02118088f, 
    0.00244063f, 0.00629283f, 0.01134050f, -0.03759311f, 0.01309519f, 0.02481360f, 0.02855330f, 0.01118673f, 
    -0.02485879f, 0.01875252f, -0.00276395f, 0.01183523f, -0.01889636f, 0.02276285f, 0.03254724f, 0.02352027f, 
    -0.03202656f, 0.01947219f, -0.03516569f, 0.01684164f, 0.01926490f, 0.01670105f, -0.00620201f, -0.03352664f, 
    0.02429881f, -0.00152980f, 0.00285881f, 0.01340577f, 0.02122932f, -0.02716618f, 0.02419689f, 0.01710362f, 
    0.00804451f, -0.00213721f, 0.00981349f, -0.01096576f, 0.02171873f, 0.02931365f, -0.03261437f, 0.02993020f, 
    0.02384384f, 0.00006119f, -0.01231163f, 0.00081244f, -0.00403958f, 0.03186770f, -0.00155399f, 0.02107875f, 
    0.02162938f, -0.01166060f, -0.01955209f, 0.00015081f, 0.02696308f, -0.01163929f, -0.01194729f, -0.00099988f, 
    0.03118604f, -0.01084169f, 0.02501281f, -0.00000532f, -0.01122240f, 0.00565504f, 0.01788957f, -0.01602893f, 
    -0.04377392f, -0.02625261f, -0.00747858f, -0.02891270f, -0.01204479f, -0.01950988f, 0.02324745f, -0.00512987f, 
    0.00365463f, -0.00164808f, -0.03100850f, -0.03179190f, 0.00495071f, 0.00404536f, -0.00892551f, -0.01739715f, 
    -0.03684327f, 0.02587146f, -0.03070389f, 0.02588624f, -0.03582824f, 0.00409037f, -0.02916591f, 0.00151445f, 
    0.01274363f, -0.02604637f, 0.00132837f, 0.00965819f, 0.02488016f, 0.01663541f, 0.02831128f, -0.01564836f, 
    -0.03542553f, -0.01550119f, -0.01616796f, 0.00324684f, 0.01764270f, -0.03432107f, 0.02524032f, -0.00713372f, 
    0.02601838f, -0.03632540f, -0.02642979f, -0.00308548f, -0.03050437f, -0.01772751f, -0.03407391f, -0.03148745f, 
    0.02629667f, -0.00259194f, -0.02909631f, -0.02448218f, 0.01324756f, -0.02780701f, -0.03378782f, -0.01750287f, 
    -0.01857773f, -0.03222086f, -0.00944511f, -0.03103068f, 0.03306639f, -0.01174165f, 0.01859105f, -0.03838248f, 
    -0.03727516f, 0.00110227f, -0.03615977f, -0.03838269f, -0.03253706f, 0.00349809f, -0.02653605f, 0.01329255f, 
    -0.02805021f, 0.00965407f, 0.01822121f, -0.02357496f, -0.03410839f, 0.03220708f, 0.00577048f, -0.00309158f, 
    -0.03199594f, -0.01943939f, -0.03474133f, -0.01155102f, -0.01082071f, 0.03101770f, -0.04147735f, -0.04020387f, 
    -0.00478018f, 0.01795982f, -0.02862561f, 0.03175206f, -0.01952505f, -0.01488972f, 0.01146110f, -0.02699827f, 
    0.03014816f, -0.01337291f, -0.02762528f, -0.02580939f, 0.00690143f, 0.03177032f, -0.03937904f, 0.00033218f, 
    -0.00073699f, -0.02851560f, 0.01787424f, 0.00210945f, -0.01410256f, 0.02137301f, 0.03198411f, 0.00980212f, 
    0.01035018f, -0.00171849f, 0.01249507f, -0.01529796f, 0.01994315f, -0.00021912f, 0.01151629f, -0.01745277f, 
    -0.04662085f, -0.00355944f, 0.01791887f, 0.00694165f, -0.00944538f, -0.01434896f, -0.02195408f, 0.01085466f, 
    -0.01499682f, -0.03760566f, 0.01602297f, -0.02220113f, -0.03390969f, -0.00847276f, -0.02276691f, 0.00524136f, 
    -0.03334141f, 0.03171031f, 0.02858671f, 0.03445976f, -0.03699923f, 0.01328658f, -0.00780278f, 0.00225392f, 
    0.03615207f, -0.03893267f, -0.03624518f, 0.01951433f, 0.02076399f, -0.03702802f, -0.02183061f, 0.02913812f, 
    0.01190692f, -0.03388259f, -0.04052115f, -0.01327871f, -0.01386339f, -0.03643525f, -0.01981812f, 0.01244457f, 
    -0.03598792f, -0.03353220f, -0.04250247f, -0.00394376f, 0.00625857f, -0.04017590f, -0.03181366f, -0.03655408f, 
    0.04139379f, -0.03793952f, -0.02044803f, 0.04603738f, -0.01184534f, -0.02758388f, -0.03355651f, 0.00468396f, 
    -0.01535249f, 0.02343889f, 0.03022767f, 0.01504740f, -0.02076045f, -0.02777618f, 0.03085129f, -0.04176914f, 
    0.03378957f, 0.00620102f, -0.01542683f, -0.02659659f, -0.03355194f, 0.00815889f, 0.03359115f, -0.02330044f, 
    -0.02153486f, -0.01850392f, 0.02909680f, -0.03130687f, 0.00497217f, 0.00763382f, 0.02136819f, -0.01485344f, 
    -0.03868145f, -0.03062993f, -0.04097429f, -0.04180430f, -0.01783130f, 0.02282068f, 0.00123710f, 0.01937854f, 
    -0.00883264f, 0.03402086f, 0.01573640f, 0.01257415f, 0.00153033f, -0.03634969f, -0.00941232f, 0.00834310f, 
    0.00390228f, -0.00613022f, 0.01097228f, -0.02736223f, -0.00762855f, 0.01146854f, -0.01153473f, 0.00367958f, 
    -0.00024997f, -0.02022689f, 0.03167062f, -0.02099461f, 0.02852472f, 0.00149473f, -0.00312815f, 0.01470234f, 
    0.01833468f, -0.01703739f, -0.04309713f, 0.02291567f, 0.02966366f, -0.02908000f, -0.02595667f, -0.02638770f, 
    -0.01983997f, 0.01477890f, 0.00502235f, -0.01233944f, 0.02950748f, 0.00073221f, 0.01471492f, -0.00826868f, 
    -0.03814856f, -0.03262367f, -0.02595914f, -0.04095375f, -0.00329921f, -0.02727572f, 0.02994788f, 0.01936833f, 
    -0.02236258f, -0.00503846f, -0.01189256f, -0.01290230f, 0.01489739f, 0.00598206f, -0.00304272f, -0.02038653f, 
    -0.01003168f, -0.03940951f, -0.01584017f, 0.01085291f, -0.02273443f, 0.02358818f, -0.03238426f, 0.02220531f, 
    0.02376939f, 0.02427661f, -0.03387951f, 0.00461920f, -0.02675951f, 0.00487349f, 0.00732128f, -0.02161473f, 
    0.03426948f, -0.04343617f, -0.00010654f, -0.00535002f, -0.03971232f, -0.03615156f, -0.03390695f, -0.00958541f, 
    -0.03574102f, -0.02403888f, 0.03078478f, 0.02708398f, -0.03784182f, 0.02132928f, -0.04168439f, -0.01901040f, 
    -0.02505273f, -0.03012243f, 0.02057315f, 0.00431765f, -0.01983338f, -0.00393587f, -0.04586977f, -0.01587896f, 
    0.00675439f, -0.00730703f, -0.01773681f, 0.01521546f, -0.02351325f, -0.03408238f, 0.00387030f, 0.01537287f, 
    -0.00308436f, -0.03767646f, -0.03034094f, 0.03737587f, 0.01013929f, 0.02358187f, -0.04141086f, -0.03108856f, 
    0.00789339f, -0.03750977f, 0.03085919f, -0.00842921f, 0.01595409f, 0.00619161f, 0.02756996f, -0.03553502f, 
    0.02858230f, -0.01778569f, 0.00578867f, 0.02290821f, 0.00065010f, -0.00953856f, -0.02541943f, -0.00904580f, 
    -0.00339677f, -0.03053919f, -0.00987703f, 0.00194381f, -0.01257921f, 0.02436844f, -0.02922508f, 0.00479273f, 
    0.03308156f, 0.01917291f, 0.03705441f, 0.00110393f, -0.00153974f, -0.01177298f, 0.02564559f, -0.01341322f, 
    -0.01855534f, 0.00465556f, -0.01295406f, -0.02981299f, -0.00832166f, 0.02441026f, -0.00252104f, 0.02126862f, 
    0.00152832f, 0.02541222f, 0.02533984f, 0.01591208f, -0.02281459f, -0.01061921f, -0.02750774f, -0.02516019f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06364842f, 0.00560326f, -0.01646451f, 0.09213573f, 0.02451561f, -0.03194679f, 0.15916996f, -0.00130984f, 
    0.00903025f, 0.05425012f, 0.14261228f, -0.00043533f, 0.06926902f, -0.04597304f, -0.01270048f, -0.10274703f, 
    -0.06143316f, -0.00897043f, -0.03330538f, 0.02922479f, -0.01150855f, 0.02119625f, 0.00147760f, -0.02157251f, 
    0.11963832f, 0.02963527f, 0.09201269f, -0.04543470f, -0.02150058f, 0.11276425f, -0.00678376f, -0.01786842f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.34315056f, 0.07538673f, 0.00738163f, -0.14778142f, -0.16565073f, 0.06065777f, 0.42886081f, 0.32681206f, 
    0.00810120f, -0.11096339f, 0.03954956f, -0.13350213f, -0.32220012f, 0.18735656f, -0.14049077f, 0.06080642f, 
    -0.10873941f, 0.09206145f, 0.04470897f, -0.03150837f, -0.03655966f, -0.01557826f, 0.09520084f, -0.13186914f, 
    0.22302869f, -0.03951119f, -0.25306454f, 0.01350411f, -0.06607381f, 0.01934892f, -0.08732781f, 0.13086535f, 
    0.24555485f, -0.15015981f, -0.00904667f, -0.14409940f, 0.16384256f, -0.08095992f, 0.05876742f, 0.32558122f, 
    0.08578862f, 0.14750022f, -0.26725477f, -0.10747621f, -0.07108954f, -0.22676669f, 0.12490701f, -0.02262433f, 
    -0.15926209f, 0.02503025f, -0.10381313f, 0.19994904f, 0.11322454f, 0.02139505f, 0.09009441f, 0.02465726f, 
    -0.00551472f, 0.02177888f, -0.26768106f, 0.04245768f, -0.08105148f, -0.23963183f, 0.15451159f, -0.17336003f, 
    -0.25581786f, 0.17333505f, -0.00277173f, -0.15029760f, -0.03941737f, -0.07020760f, 0.48223248f, -0.09939919f, 
    -0.07367189f, -0.42912489f, 0.21993832f, 0.14612652f, 0.29146197f, -0.27298605f, -0.14526245f, -0.18848313f, 
    0.16483538f, 0.02680244f, 0.07368943f, -0.07976474f, 0.10928015f, 0.09100263f, 0.16107252f, 0.07311900f, 
    0.03444716f, 0.16902883f, 0.28360215f, 0.01303335f, -0.02152669f, 0.10059205f, -0.13356161f, -0.08387748f, 
    0.13537900f, 0.06621058f, 0.09633143f, 0.14268360f, 0.17314048f, 0.17619714f, -0.14354107f, -0.29784217f, 
    -0.17354059f, 0.44187599f, 0.39299306f, -0.02245405f, -0.09928421f, -0.33098024f, -0.01503134f, -0.26554143f, 
    0.06562254f, 0.09775496f, 0.01246555f, 0.09094278f, -0.08300378f, 0.03398923f, -0.12088866f, -0.06906892f, 
    0.21339187f, 0.08125240f, 0.08843214f, -0.05939692f, 0.13777803f, 0.17938468f, -0.13649556f, -0.05817551f, 
    0.13492253f, 0.13489455f, -0.09354251f, 0.24689820f, -0.05574403f, -0.11485025f, 0.29256669f, 0.21677604f, 
    -0.08305599f, 0.32147518f, -0.16470709f, -0.00228090f, -0.00532921f, -0.10561784f, -0.02742877f, -0.47934249f, 
    0.00057458f, -0.05073300f, 0.10320488f, -0.17301865f, 0.04367676f, 0.13080187f, 0.16028762f, 0.14977668f, 
    0.18972179f, -0.16320144f, -0.09072344f, -0.03226124f, -0.12449852f, 0.17140906f, 0.05044078f, -0.10216546f, 
    -0.23723274f, -0.00800496f, -0.06578367f, -0.34810144f, -0.16157724f, 0.05944005f, 0.00433547f, -0.04540296f, 
    -0.05431634f, -0.17543894f, 0.25274074f, -0.18155308f, -0.07177405f, 0.10254503f, 0.05395842f, 0.25837353f, 
    -0.08103420f, -0.07787720f, 0.16791487f, 0.25278917f, -0.07831140f, -0.06289778f, 0.10224862f, 0.10813039f, 
    0.18717605f, -0.01631054f, 0.39966983f, -0.15222977f, 0.02571877f, -0.07924484f, 0.04322201f, 0.03169554f, 
    0.04467630f, 0.01405661f, -0.04156611f, -0.04103301f, -0.08751599f, 0.10928775f, 0.26225546f, 0.01024189f, 
    0.00999403f, -0.00918044f, -0.17791134f, 0.00811127f, -0.03092533f, 0.31123623f, 0.10768762f, 0.39854267f, 
    0.03026186f, 0.10612056f, 0.07619695f, 0.14345531f, 0.13326766f, -0.10956039f, 0.06150078f, -0.00887927f, 
    0.26884374f, 0.02294235f, -0.26630056f, -0.17286019f, 0.11445866f, -0.18690647f, -0.14974584f, 0.09357836f, 
    -0.10223173f, 0.15430588f, 0.15949343f, 0.19481431f, -0.11682460f, 0.15976842f, -0.05028084f, 0.05146160f, 
    0.00277501f, -0.01466989f, 0.18999687f, 0.04325930f, 0.15234095f, -0.24179237f, 0.03686507f, 0.00749011f, 
    0.15499356f, -0.01773238f, -0.08986518f, -0.46668008f, -0.00577928f, -0.00389039f, -0.15782398f, -0.14557269f, 
    -0.00952406f, -0.09424979f, 0.34235910f, 0.05441910f, -0.07355546f, 0.26309356f, -0.12286653f, -0.14915061f, 
    -0.04323697f, 0.01746230f, -0.17334364f, 0.08975256f, -0.17034097f, -0.13636756f, 0.34465879f, -0.29897600f, 
    -0.12214416f, -0.40209189f, 0.05927828f, -0.17290851f, -0.22745210f, -0.37812981f, 0.05720611f, 0.07054497f, 
    0.09447978f, -0.06140433f, -0.09609406f, -0.09269987f, -0.00801492f, 0.04682070f, -0.03289273f, -0.02283813f, 
    -0.05767867f, 0.16941722f, 0.23083408f, -0.08475821f, 0.00834278f, 0.34021255f, 0.11814941f, -0.08212073f, 
    0.17334311f, -0.14459091f, -0.14776808f, -0.18473715f, 0.15989561f, 0.06881608f, 0.31748760f, 0.15429324f, 
    -0.17161153f, 0.09791344f, 0.06778828f, 0.12822470f, -0.21365558f, 0.17735320f, -0.15555438f, -0.14887734f, 
    -0.10475053f, 0.14648119f, 0.03361938f, -0.23444439f, 0.03070963f, -0.13908255f, -0.14594375f, -0.04999316f, 
    0.20730220f, 0.04553307f, -0.15543054f, 0.04413116f, -0.04497359f, -0.11147563f, -0.05143603f, 0.03014737f, 
    -0.18585035f, -0.00988291f, 0.11087906f, 0.10822854f, 0.08934868f, -0.01592513f, 0.11671470f, -0.31764421f, 
    -0.01041458f, 0.11797870f, 0.49927545f, -0.02390023f, 0.00107930f, 0.15757698f, -0.00175195f, -0.07703581f, 
    -0.11987954f, 0.14354499f, 0.02120104f, 0.07435891f, 0.04003594f, 0.07546873f, 0.16683227f, -0.06516673f, 
    0.25155130f, 0.13967089f, -0.09171747f, 0.01979407f, 0.13253444f, 0.17831421f, -0.02388366f, 0.04678668f, 
    -0.39035487f, -0.13679075f, 0.10376725f, 0.34301600f, -0.12037181f, 0.08616386f, 0.26514807f, 0.43749389f, 
    -0.02896987f, 0.15733305f, -0.00427259f, 0.01172128f, 0.00779203f, 0.47945532f, 0.00151559f, 0.28043374f, 
    -0.14410368f, 0.10616028f, 0.03494385f, -0.08094537f, -0.09109357f, -0.05300934f, 0.05514095f, 0.00685618f, 
    -0.16755860f, 0.05071348f, -0.37719649f, 0.03645045f, 0.00958478f, 0.13840614f, 0.15487781f, 0.18084265f, 
    0.13647270f, -0.14393155f, 0.04106313f, 0.23581721f, 0.03732294f, -0.08957976f, -0.11819413f, -0.36685902f, 
    -0.06582218f, -0.33704853f, -0.23652373f, 0.07496028f, 0.36041334f, -0.33095798f, 0.10030594f, 0.09102558f, 
    0.04905307f, 0.05579069f, -0.09285548f, 0.13913965f, -0.15397824f, -0.06915633f, 0.12993853f, 0.14603677f, 
    -0.09727409f, -0.11178096f, -0.15122192f, 0.11665458f, 0.12285446f, 0.28186250f, 0.10528534f, 0.12700976f, 
    0.28004646f, 0.01241860f, 0.00003023f, 0.09399705f, -0.04111452f, -0.01711613f, 0.14435506f, -0.13788731f, 
    -0.17227903f, -0.10562464f, 0.07100196f, -0.08840270f, 0.54662037f, -0.28023231f, -0.12048601f, -0.13940153f, 
    0.14044382f, -0.04901798f, 0.12644050f, 0.52276742f, -0.01350444f, -0.07870353f, 0.15196316f, 0.10237319f, 
    0.17239772f, -0.10588564f, -0.41955093f, 0.14098017f, -0.08532029f, 0.11253546f, 0.13767354f, 0.11333244f, 
    -0.33207604f, 0.01455145f, 0.14776923f, 0.26799595f, 0.07358106f, -0.13804722f, -0.07168295f, 0.06243315f, 
    0.16596456f, 0.30816993f, -0.08570265f, 0.16715172f, -0.07787369f, 0.05689729f, -0.14562345f, -0.02567248f, 
    -0.08707439f, 0.09810606f, 0.15826595f, -0.11631957f, -0.08217864f, 0.13659668f, -0.15773438f, -0.13464770f, 
    0.27900553f, -0.00050284f, 0.47074884f, -0.10515200f, -0.02135147f, -0.13814460f, -0.03371063f, 0.03689661f, 
    -0.29469022f, -0.08235491f, 0.05275304f, 0.22150604f, 0.06238377f, -0.08940858f, 0.09796081f, 0.31857783f, 
    -0.01873369f, -0.02030729f, -0.16594611f, 0.07999203f, -0.02364325f, 0.42586103f, -0.15329760f, 0.25626352f, 
    -0.01870489f, 0.03766264f, 0.11301700f, -0.27859855f, 0.08376461f, -0.14673898f, 0.05985703f, 0.08352036f, 
    0.07787751f, 0.01069585f, 0.24004740f, 0.09632749f, -0.17226255f, -0.07642834f, -0.00918691f, 0.18176864f, 
    -0.39260361f, 0.00000938f, -0.08442442f, 0.08022739f, -0.08710188f, -0.05222134f, 0.08695313f, 0.19536880f, 
    -0.13794002f, 0.19918565f, 0.18607417f, -0.17186935f, 0.07681729f, 0.04729962f, -0.00366703f, 0.25592217f, 
    -0.00843095f, 0.13798206f, 0.02180772f, -0.47734353f, -0.09870283f, -0.03786326f, -0.00130569f, -0.00726392f, 
    -0.15344025f, 0.16935483f, 0.40941331f, -0.07279641f, -0.07799342f, -0.15308110f, 0.10849263f, 0.04131084f, 
    0.02432326f, -0.05168533f, 0.14502668f, 0.02829028f, 0.13405880f, 0.07492130f, 0.29657272f, -0.16501607f, 
    0.08487906f, -0.41822624f, 0.27442610f, 0.11949509f, 0.44890192f, 0.16435060f, -0.05692845f, -0.03933703f, 
    -0.11151947f, 0.04192710f, 0.08556295f, 0.10730617f, -0.16554664f, 0.14910242f, -0.02753945f, 0.09830280f, 
    0.07443698f, 0.14568679f, -0.09723318f, 0.13395511f, 0.01634584f, -0.00317727f, 0.07722838f, 0.15162285f, 
    0.20034552f, -0.00579237f, 0.07213292f, 0.32510310f, 0.14271256f, 0.17586167f, -0.36291638f, 0.01919922f, 
    -0.06507051f, 0.20210078f, -0.26073128f, 0.07610763f, 0.31092113f, -0.31209019f, 0.09850972f, 0.27154458f, 
    0.07766031f, -0.03953362f, -0.12772758f, 0.27602282f, -0.09514681f, 0.01044589f, -0.16984269f, 0.07406574f, 
    -0.06733198f, -0.13891399f, 0.36876941f, -0.15975393f, 0.15511987f, -0.25309822f, -0.12178735f, -0.06329691f, 
    -0.22202209f, -0.09470958f, 0.06736436f, 0.41042775f, -0.03627302f, -0.11982609f, 0.10391696f, 0.45545089f, 
    0.06489382f, 0.35606259f, -0.23420872f, -0.00032924f, -0.10583149f, 0.09289095f, -0.07214128f, -0.27515119f, 
    -0.01964442f, -0.08110676f, -0.12741400f, -0.14348444f, 0.06715533f, -0.02202906f, -0.05667426f, 0.16803715f, 
    0.07746451f, -0.07905946f, 0.02020903f, 0.01143601f, 0.03247061f, 0.03960608f, -0.15031967f, -0.06229139f, 
    -0.19980615f, 0.13438080f, -0.11786546f, 0.01565593f, -0.06224651f, 0.10228905f, -0.32016793f, 0.01873785f, 
    0.04928547f, -0.24388999f, 0.22334298f, -0.02091973f, 0.37701815f, 0.04401308f, 0.14678733f, 0.41486949f, 
    0.10258844f, 0.08691107f, 0.03439916f, 0.12905794f, -0.09905485f, 0.10770056f, 0.05050988f, -0.14083761f, 
    -0.18294485f, 0.10984741f, 0.43879715f, -0.03074905f, 0.02662746f, -0.21886201f, 0.03015500f, -0.13023901f, 
    0.10356604f, 0.00789967f, 0.08128601f, 0.18956344f, -0.04034585f, -0.05569428f, -0.38396192f, 0.21565577f, 
    0.01703677f, -0.00065615f, 0.13041404f, -0.00123046f, 0.09786538f, 0.13653827f, -0.09420248f, 0.52241558f, 
    0.06795072f, 0.14123942f, 0.15762809f, -0.01609380f, -0.03766276f, 0.06332512f, 0.16187207f, 0.12000267f, 
    -0.24633984f, 0.12711596f, -0.28101286f, 0.15185568f, -0.07811834f, 0.00120574f, -0.05886939f, 0.10112399f, 
    0.18628080f, -0.14626451f, 0.02537525f, -0.13185576f, -0.14762235f, 0.00285608f, -0.15244617f, -0.23646966f, 
    -0.02514527f, -0.17280984f, -0.20780818f, 0.09678954f, 0.06551240f, 0.11399344f, -0.08185127f, -0.09062651f, 
    -0.11138940f, -0.06482209f, 0.15757185f, -0.07275067f, 0.07650789f, 0.11527892f, 0.15285654f, 0.05092968f, 
    -0.12428058f, -0.10886861f, -0.10492416f, -0.12956791f, -0.10603131f, 0.09230692f, -0.10222174f, 0.16465108f, 
    0.10808032f, 0.06232811f, -0.16738698f, -0.03683248f, -0.00370311f, -0.03817857f, -0.08308119f, -0.03724209f, 
    0.10255365f, -0.19551727f, -0.12196708f, -0.02407655f, -0.21390225f, 0.00972148f, -0.12806310f, 0.03644408f, 
    -0.02767438f, -0.06754751f, -0.00647468f, -0.02694991f, -0.03720412f, -0.10060303f, -0.14228773f, 0.06685295f, 
    0.06407123f, 0.08529004f, 0.15836245f, 0.00001191f, 0.05431991f, -0.11426590f, 0.08130380f, 0.13073935f, 
    -0.10440983f, 0.09994102f, 0.07335979f, -0.14523776f, 0.14167149f, 0.13909528f, 0.18372138f, 0.11882631f, 
    -0.08626846f, 0.41258401f, 0.02714823f, -0.15370138f, 0.01381487f, 0.26283386f, -0.06582014f, -0.05910509f, 
    0.12535483f, 0.17113383f, -0.16050407f, 0.55356830f, -0.04037011f, 0.14738172f, 0.10415176f, -0.08457683f, 
    0.31348401f, -0.15732384f, -0.05541282f, 0.14181320f, -0.12841773f, -0.23570523f, 0.10783206f, 0.01864701f, 
    -0.57107943f, -0.15623249f, -0.08061442f, 0.19193223f, 0.02176856f, -0.07594534f, -0.12644796f, 0.07219950f, 
    0.05217965f, -0.32431826f, 0.24772370f, -0.08610924f, 0.39776570f, 0.23129253f, -0.14235558f, 0.22982991f, 
    0.09836054f, -0.03841517f, 0.12106413f, 0.02636144f, 0.02845822f, -0.11714018f, -0.03044743f, 0.15097682f, 
    0.00053544f, 0.14760455f, 0.34352496f, -0.02433895f, 0.12170696f, -0.22940232f, -0.07157303f, 0.01017807f, 
    -0.09079643f, 0.00763946f, -0.10628682f, 0.20809208f, -0.08773008f, -0.18307142f, 0.28793022f, 0.57543164f, 
    -0.15293749f, 0.21976715f, -0.41221109f, 0.03844516f, -0.36733440f, -0.08009265f, -0.06844297f, 0.37624705f, 
    -0.06347080f, -0.03006223f, 0.00570373f, -0.15321785f, 0.03625643f, -0.02865917f, -0.10225306f, 0.08101401f, 
    -0.02676496f, -0.06969841f, 0.11171409f, 0.11196337f, 0.05482346f, 0.05476422f, 0.09155261f, 0.02024518f, 
    -0.36743662f, -0.05641971f, 0.06900398f, 0.17543599f, -0.08117539f, 0.09824342f, 0.27172902f, 0.01143031f, 
    0.04634161f, 0.48720938f, 0.50299060f, 0.01203558f, -0.03130119f, -0.40096709f, 0.04966930f, -0.12783596f, 
    -0.12803844f, -0.00860322f, -0.14548935f, -0.05954111f, 0.03265126f, -0.00455916f, -0.13703059f, -0.14744663f, 
    0.05680333f, 0.17029488f, -0.16790736f, 0.08187445f, 0.13790876f, 0.21343112f, 0.12523083f, -0.13029240f, 
    0.06220597f, 0.13552958f, -0.01646697f, -0.19951425f, 0.15166155f, -0.01852897f, 0.47279051f, -0.01040669f, 
    0.05775923f, -0.16471183f, -0.24140111f, 0.02152210f, 0.10636237f, 0.17557806f, 0.02820101f, -0.09983341f, 
    -0.15792461f, -0.00892514f, 0.15709749f, 0.38655370f, 0.09574321f, -0.09572775f, 0.00185593f, -0.13176517f, 
    0.34289104f, 0.02652664f, 0.26143134f, 0.16644160f, 0.15563658f, -0.06983980f, 0.11719384f, 0.07276373f, 
    0.01122081f, 0.11783605f, -0.03929995f, 0.23632210f, -0.04809146f, -0.09552535f, -0.32462403f, 0.29621196f, 
    -0.09177577f, 0.22480604f, 0.25992122f, -0.08593408f, 0.25852931f, -0.16268733f, 0.13562503f, 0.32096815f, 
    -0.03084632f, -0.02878633f, 0.07802105f, -0.11857706f, 0.04426665f, 0.13531032f, -0.00689377f, 0.10241904f, 
    -0.20741546f, 0.09289449f, -0.38764533f, -0.04639399f, -0.00868874f, 0.09615525f, 0.13025402f, 0.17082664f, 
    -0.18465009f, -0.16654783f, 0.11056056f, 0.18224411f, 0.16753450f, 0.02227125f, 0.23779364f, 0.18127505f, 
    -0.15763779f, -0.07156034f, -0.28347996f, -0.09388693f, -0.27391994f, 0.12789102f, 0.03444679f, 0.35628483f, 
    0.15298247f, -0.04770872f, -0.09252728f, -0.22876224f, -0.07217672f, -0.08087972f, 0.03949507f, -0.13750406f, 
    -0.18716596f, 0.13413197f, 0.08144808f, -0.03091200f, 0.00395964f, 0.13617519f, -0.12956576f, -0.12523268f, 
    -0.09916583f, -0.08308165f, -0.09346360f, 0.13598940f, 0.08942868f, -0.00636543f, -0.06514938f, 0.04782502f, 
    -0.16185525f, 0.02326948f, -0.25946406f, 0.17598133f, -0.38523400f, 0.21665114f, 0.15699872f, 0.11149956f, 
    -0.05674691f, -0.12890264f, -0.16921873f, -0.48198387f, 0.01810763f, -0.08324113f, 0.07601302f, -0.05299821f, 
    -0.18502630f, 0.12986735f, -0.26841295f, 0.10421051f, 0.04880584f, 0.31520864f, -0.05828561f, 0.08637760f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.14927535f, -0.09969199f, 0.18473971f, 0.31189242f, -0.13781500f, 0.00763891f, -0.11617842f, -0.04122891f, 
    0.09221179f, -0.22444737f, 0.20349838f, -0.15103908f, 0.29180807f, -0.07982687f, -0.02459481f, 0.13695705f, 
    -0.12834856f, 0.16497599f, 0.19724345f, 0.26411834f, 0.21178637f, -0.21455860f, -0.11490817f, -0.29312441f, 
    0.28810456f, 0.18294971f, 0.09103760f, 0.15993886f, 0.24790470f, -0.01505873f, 0.07132342f, 0.06808814f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.05139319f, 0.46335039f, -0.17043760f, -0.20859247f, -0.06156617f, 0.04703040f, 0.20555124f, -0.46502981f, 
    -0.35033846f, -0.14990583f, -0.47171164f, -0.23282647f, -0.03255548f, 0.26951849f, -0.47409269f, -0.28740299f, 
    -0.10912102f, 0.14707042f, -0.07736585f, -0.28011572f, -0.31367105f, 0.06400736f, -0.01429811f, -0.00949216f, 
    0.27659419f, -0.83137023f, 0.13261221f, -0.51544374f, 0.26773682f, 0.05634382f, -0.40335223f, -0.53717077f, 
    0.64243186f, 0.00005895f, 0.03945743f, 0.02820761f, 0.19381447f, -0.10416529f, 0.27264482f, -0.25719461f, 
    0.27802563f, 0.03919421f, 0.14142372f, 0.15547140f, -0.06824850f, 0.02113684f, -0.15585864f, -0.08842096f, 
    -0.35029370f, -0.12235545f, -0.35365206f, 0.23160763f, -0.94188046f, -0.28529111f, 0.11536162f, -0.04010092f, 
    0.17359310f, -0.37823853f, 0.13083683f, 0.24413991f, 0.01319918f, -0.01459071f, -0.13341066f, 0.03053175f, 
    0.13214180f, -0.28992069f, 0.14094576f, -0.24284178f, -0.03634283f, -0.02488263f, -0.14984703f, -0.10058302f, 
    -0.75891304f, 0.07116635f, 0.28658938f, 0.37773308f, -0.43717977f, -0.12370372f, -0.07742631f, 0.21486378f, 
    0.17878498f, 0.26331934f, -0.34850648f, 0.05029160f, -0.10568240f, -0.02430701f, 0.15320452f, 0.18558259f, 
    0.12034795f, 0.43260619f, -0.56895083f, 0.15829882f, 0.05913034f, 0.11050779f, -0.40743849f, -0.39521593f, 
    -0.06978233f, -0.06139084f, -0.42539278f, -0.59996021f, -0.50238115f, 0.11948004f, 0.01385288f, -0.37040859f, 
    -0.76628619f, 0.02494408f, -0.74090034f, 0.15171696f, -0.15977195f, -0.03250457f, -0.07843273f, 0.06295069f, 
    0.02226200f, -0.15359308f, 0.34969544f, 0.02459461f, 0.38813081f, 0.53692925f, -0.53947729f, -0.30108255f, 
    0.09013855f, 0.28389248f, 0.19624574f, -0.28436840f, -0.17283688f, 0.32123283f, -0.03357302f, 0.12858914f, 
    -0.01653680f, -0.51866329f, -0.42608818f, 0.04908551f, -0.12201317f, 0.12429450f, 0.07698039f, -0.17511784f, 
    0.27035043f, -0.20935212f, 0.07319815f, -0.28321785f, 0.27256560f, 0.13479668f, 0.11124516f, -0.05050962f, 
    -0.58252227f, 0.04842432f, 0.24227522f, -0.21586263f, 0.17372842f, -0.17632024f, -0.05084878f, 0.00611251f, 
    0.09535093f, 0.27527225f, -0.40599364f, -0.81833005f, 0.24108240f, -0.46325919f, 0.01339677f, 0.18015042f, 
    -0.91920090f, -0.14416502f, -0.16184111f, 0.36195567f, 0.27225786f, -0.15160476f, -0.21907264f, 0.10664660f, 
    -0.12193146f, -0.46331668f, -0.10543959f, -0.15005086f, -0.09017053f, 0.06187176f, 0.31657046f, -0.14807209f, 
    -0.12391417f, -0.35865080f, 0.27046812f, 0.31896085f, -0.52862799f, -0.39153627f, 0.18216513f, -0.04914003f, 
    0.16273978f, -0.31442353f, -0.09443644f, 0.09941491f, -0.00403072f, 0.03796966f, -0.39876771f, -0.09449697f, 
    -0.16714889f, -0.55886477f, 0.13731553f, 0.28538615f, -0.14127742f, 0.14231576f, -0.04068769f, 0.31298205f, 
    0.20069464f, 0.02781709f, 0.13898773f, -0.49559119f, -0.20664203f, -0.25231570f, 0.12631172f, -0.13119046f, 
    0.52068853f, -0.03147209f, -0.31456399f, -0.62217760f, 0.20315515f, -0.22509852f, 0.28808835f, 0.03700233f, 
    -0.49219429f, 0.34982079f, -0.43484044f, 0.15471064f, -0.19517606f, -0.23501961f, -0.39912623f, -0.17754984f, 
    0.05119184f, 0.00140789f, -0.09629381f, -0.03678735f, -0.10334688f, -0.41067711f, 0.09928274f, 0.15693748f, 
    -0.15903352f, -0.10892028f, 0.09706090f, 0.19780464f, 0.49530697f, 0.32869956f, -0.54652888f, -0.19117849f, 
    -0.38068122f, 0.17681637f, -0.12501375f, -0.21948858f, -0.12330214f, 0.18973841f, -0.21994682f, -0.17561117f, 
    -0.72103000f, 0.18075614f, -0.38526633f, 0.09799308f, -0.35721669f, 0.37804967f, -0.01503997f, -0.10187344f, 
    -0.08157522f, -0.41652954f, -0.28036162f, 0.08285850f, 0.21264224f, -0.28308082f, -0.33776620f, 0.22735700f, 
    -0.24401909f, 0.32325765f, -0.12150400f, 0.25968722f, -0.33843383f, -0.35092208f, -0.10698533f, 0.11575121f, 
    0.20800094f, -0.34791836f, -0.13501550f, 0.26702434f, -0.15076110f, 0.21615283f, -0.36667320f, 0.11650182f, 
    -0.45457906f, -0.36226943f, 0.21051486f, 0.15236437f, -0.55873668f, 0.23553765f, 0.26077795f, -0.06589290f, 
    -0.09690633f, -1.16953468f, 0.27603078f, 0.23567742f, -0.28391829f, 0.25621945f, -0.82230055f, -0.09714077f, 
    0.10748238f, -0.07277004f, 0.21290548f, -0.44981927f, 0.07686463f, 0.28131554f, -0.43068558f, -0.41172948f, 
    -0.54385966f, 0.31522229f, -0.05095593f, -0.69025064f, 0.16914462f, -0.23752390f, -0.53048563f, -0.38638592f, 
    0.02904505f, -0.15032795f, -0.46242675f, 0.07582858f, 0.13365449f, -0.03775070f, -0.22361241f, -0.34291631f, 
    0.33451623f, -0.60404652f, -0.54996997f, -0.18877418f, -0.23037821f, 0.18392219f, 0.13951617f, -0.17921329f, 
    -0.40207249f, -0.32146591f, 0.15378925f, 0.17187220f, -0.55844283f, -0.67917842f, 0.33655706f, 0.25219479f, 
    0.15394388f, -0.72318923f, -0.18705259f, 0.17836098f, -0.21627480f, -0.25652772f, -0.46587259f, -0.07395349f, 
    0.22662142f, -0.01216849f, 0.25128877f, -0.16044796f, 0.16670179f, -0.14264825f, 0.39236322f, -0.32169932f, 
    0.04775776f, 0.10590433f, 0.30507258f, -0.53435510f, -0.03712375f, -0.00313777f, -0.43344155f, 0.24281350f, 
    0.02170723f, -0.06480380f, -0.48211163f, 0.06306558f, -0.14131656f, -0.21522222f, 0.12025461f, 0.12326755f, 
    0.33596534f, -0.01023469f, -0.05787500f, 0.06370059f, 0.03731995f, -0.50886971f, -0.52897948f, -0.17852670f, 
    -0.36614931f, 0.17475320f, 0.18623717f, -0.23705354f, 0.19009306f, -0.20589872f, 0.37360111f, -0.41074696f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.30133906f, -0.09449179f, 0.11950359f, 0.07658099f, 0.30161145f, -0.01211653f, -0.13457195f, -0.07944158f, 
    -0.11555951f, -0.01837461f, -0.10040037f, 0.02021560f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
