#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.50147718f, -1.58531499f, 1.01055443f, 0.89297497f, 0.24536271f, -1.04290795f, 0.48745868f, 0.52406526f, 
    -0.39594927f, -0.35892069f, 0.13842256f, 0.27430615f, 0.17002062f, -0.16496663f, 0.17136724f, -0.26197210f, 
    0.29996973f, 0.01868751f, 0.06163147f, 0.10187126f, -0.00866460f, 0.25628197f, 0.13083182f, 0.20087782f, 
    0.00067599f, 0.33441493f, -0.44846326f, -0.01032565f, -0.11467604f, -0.59361768f, -0.74490088f, 0.41937760f, 
    0.15352567f, -0.73625314f, -0.24576288f, -0.76517034f, -0.07996046f, -0.57551754f, -0.61135525f, -0.02515582f, 
    -0.00223375f, -0.13008751f, -0.05831985f, 0.42627212f, 0.25386503f, -0.04474870f, -0.36805323f, -0.38731113f, 
    -0.52129096f, 0.18550834f, 1.52973282f, 0.27071562f, 0.25814620f, 0.96905804f, 0.25313079f, -0.01814944f, 
    -0.33895347f, 0.41742447f, -0.74621981f, -0.20123126f, -0.32259294f, -0.29854536f, 0.41692439f, -0.10340140f, 
    0.18456823f, 0.11522118f, -0.02752263f, 0.26296297f, 0.23825866f, 0.13594496f, -0.37767372f, 0.07370403f, 
    -0.37041160f, -0.07246874f, 0.14640962f, -0.77223140f, 0.05701800f, 1.08908653f, 0.61015421f, -0.00539114f, 
    0.71768534f, -0.26646563f, 0.14659852f, 0.15658420f, -0.48693758f, -0.68650997f, -0.17744979f, -0.51597226f, 
    -0.04122294f, -0.11421932f, 0.40682468f, 0.21915023f, -0.40886465f, 0.02771165f, -0.35510325f, -0.01686598f, 
    -0.44913334f, -0.00486017f, -0.04744810f, -0.28230458f, 0.17306630f, -0.86919612f, -0.40297830f, -0.60300475f, 
    0.85277307f, 0.30593121f, -0.64234078f, -1.00233746f, -0.20422618f, 0.17097640f, -0.34644502f, 0.41717684f, 
    0.04583658f, 0.11730020f, 0.29511714f, -0.28720793f, -0.50062734f, 0.36449847f, 0.09387714f, 0.01051173f, 
    0.18775980f, 0.03219863f, -0.26770115f, -0.02930731f, 0.21429366f, 1.36723828f, -0.65876764f, 0.67930526f, 
    0.62590539f, -0.45184186f, 1.06867433f, -0.39801842f, 0.18527631f, -0.00499504f, -0.51379395f, 0.16905598f, 
    -0.11084213f, -0.39168090f, -0.04230984f, -0.42159051f, 0.15163033f, -0.04575949f, -0.41176814f, -0.17916368f, 
    0.30278721f, -0.23253992f, 0.03032098f, 0.51313943f, 0.19022621f, 0.10195097f, 0.14021748f, 0.78345084f, 
    0.70595080f, -0.35838553f, -0.73718005f, -0.13175483f, 0.56995600f, 0.68130308f, -0.31405097f, 0.28344432f, 
    -0.35259104f, 0.49208799f, -0.42264879f, -0.24017717f, -0.57354063f, 0.36303017f, 0.19366179f, 0.16421621f, 
    -0.04043242f, -0.64614350f, 0.18670468f, -0.35446069f, -0.54644436f, -0.78824627f, -0.20876518f, -0.25453845f, 
    -0.84104705f, 0.41403583f, 0.14514111f, 0.55885696f, -0.38613570f, 0.38688120f, 0.94732535f, -0.50140744f, 
    0.20021288f, 0.51987803f, 0.31101733f, -0.46114942f, -0.29427680f, 0.22265454f, 0.10533521f, -0.23709090f, 
    -0.17057446f, -0.24539396f, 0.23522002f, -0.18876429f, -0.60999554f, -0.19387290f, -0.37324944f, 0.28000352f, 
    0.56129348f, -0.89393085f, -0.82742840f, 0.40574351f, -0.41103601f, -0.76149821f, 0.65310603f, 0.18817161f, 
    -0.09131060f, 0.51171339f, 0.20880072f, 0.54575604f, -0.03475277f, -0.53186685f, 0.42141259f, -0.07807513f, 
    -0.55315650f, -0.41637793f, -0.25357017f, -0.15267912f, 0.13547978f, 0.24120553f, -0.03462881f, 0.03887614f, 
    0.01763225f, -1.13784373f, -0.65238506f, 0.06644559f, 0.54566687f, -0.16583690f, 0.74071324f, -0.02496866f, 
    -0.89013577f, 0.51729423f, -0.42075035f, 0.49535555f, 0.25784236f, -0.47190210f, 0.47136745f, 0.00863845f, 
    0.05158662f, 0.36677629f, 0.19025566f, -0.46300039f, 0.01463750f, -0.13238731f, 0.05219819f, -0.17564653f, 
    0.30289429f, 0.01762203f, 0.65118802f, 0.00848522f, 0.46245942f, 1.13315558f, 0.97367442f, 0.82509816f, 
    0.76695722f, 0.34489626f, 0.17350516f, 0.63775986f, -0.65141946f, -0.31105503f, -0.51655823f, 0.30374229f, 
    0.13615645f, -0.41511381f, -0.26290214f, 0.03659679f, 0.16364928f, -0.12589435f, 0.06361795f, -0.05292251f, 
    -0.14023316f, -0.38908881f, 0.10916915f, -0.59075737f, -0.97766894f, -1.15764475f, -0.46309599f, -0.51455605f, 
    -0.52437127f, 0.08930676f, -0.24588783f, -0.46508113f, 0.53849828f, 0.43985179f, -0.16912942f, 0.25169334f, 
    0.42083260f, 0.24329732f, 0.33175203f, 0.21741052f, 0.29080153f, 0.57554096f, -0.19133015f, -0.13980633f, 
    -0.19580224f, 0.30868703f, -0.14200205f, 0.36158389f, 0.88071609f, 0.82672507f, 0.38095254f, 0.82831031f, 
    0.47181791f, -0.10187758f, 0.34505111f, -0.03235644f, -0.52602625f, -0.03664361f, 0.32471353f, 0.38123822f, 
    0.14779124f, 0.30500779f, 0.31908444f, -0.26735413f, -0.21250309f, 0.34701923f, 0.29224348f, 0.47358081f, 
    0.00332096f, 0.06561749f, -0.19888602f, 0.24378571f, -0.18145995f, 0.48821798f, 0.68089300f, 0.97776520f, 
    0.37872019f, 0.62835717f, -0.22164527f, -0.35233578f, -1.00499487f, -1.06489706f, -0.57670027f, 0.18747090f, 
    0.34038934f, 0.06812067f, 0.34470206f, -0.11637189f, 0.27538139f, 0.36682099f, -0.01615769f, -0.12403969f, 
    0.46613798f, 0.10926596f, 0.03252376f, 0.09821319f, -0.16228466f, 0.11296456f, 1.21333873f, 0.76637882f, 
    0.33605638f, 0.15394469f, -1.20294690f, -1.09051967f, 0.12616991f, -0.44452405f, 0.39091972f, -0.39847347f, 
    0.00210009f, -0.00263396f, 0.12186996f, -0.17315447f, -0.25768587f, -0.01062220f, -0.41301677f, 0.07380971f, 
    0.03865720f, -0.14457901f, -0.32133284f, 0.35317761f, 0.11494222f, -0.10599647f, -0.07095513f, 1.03454125f, 
    0.34185517f, -0.61670166f, -1.26527131f, -0.19436793f, 0.15667972f, 0.05636259f, 0.83265519f, 1.11684930f, 
    0.16492294f, -0.55251205f, -0.25678116f, -0.41848686f, -0.25278962f, 0.18033382f, -0.11928059f, -0.08945437f, 
    -0.17124985f, 0.14941251f, 0.17439452f, -0.35283744f, 0.27157062f, -0.48257682f, -0.21061566f, -0.25718078f, 
    -1.24823213f, -0.01836292f, -0.99700159f, 0.68059981f, 1.06947744f, -0.54160064f, 1.22349894f, 0.75436944f, 
    -0.32049152f, -0.08372634f, -0.00465161f, 0.02907220f, 0.16035412f, -0.07183735f, 0.39215755f, -0.34820837f, 
    0.16581507f, 0.20458023f, 0.24476831f, 0.01081637f, 0.23370633f, 0.19000846f, -0.07972496f, 0.26586035f, 
    -0.24156487f, 0.28559566f, -0.95546603f, -0.42970794f, -0.87904418f, 0.29495457f, 0.25700244f, 0.18591563f, 
    -0.88530332f, -0.70133513f, -0.50873572f, 0.04696767f, 0.14429541f, 0.57796502f, 0.13489947f, -0.02752385f, 
    0.10910597f, 0.11501105f, -0.27092984f, 0.08931673f, -0.15591396f, 0.09351869f, -0.14603257f, 0.03159630f, 
    0.16102409f, -0.09721381f, 0.61087769f, 0.78128588f, -0.58661705f, 0.09993904f, 0.58225858f, 0.49535528f, 
    0.54133528f, 0.75395155f, 0.59698600f, 0.82287949f, -0.05835169f, -0.14708479f, -0.58986992f, 0.01515430f, 
    -0.48081183f, 0.12963651f, -0.02239523f, -0.14656350f, 0.30871019f, -0.30367249f, -0.45994002f, -0.25780952f, 
    -0.42228141f, 0.12865394f, -0.23578641f, -0.27787733f, -0.72949374f, 0.40468287f, 0.38451591f, -0.86636907f, 
    -0.32390934f, -0.00406133f, 0.85500610f, -0.95097363f, -0.68225539f, -0.56251466f, -0.23275025f, -0.33160070f, 
    0.34519932f, 0.03927451f, -0.41307491f, -0.11621659f, 0.05241579f, -0.42850453f, -0.37842605f, 0.36198565f, 
    0.22464219f, -0.18124184f, 0.09897802f, -0.06460075f, 0.78231728f, 1.00057423f, 0.72634262f, -0.67570257f, 
    -0.05559185f, -0.97281510f, 0.79039001f, 0.11439561f, -0.62482458f, -0.31554693f, 0.13195717f, -0.01855799f, 
    -0.15780120f, -0.19222313f, 0.24831434f, 0.01626007f, 0.07560438f, 0.15978822f, 0.29505616f, 0.09849491f, 
    0.25444549f, -0.02412215f, 0.36230025f, 0.30329272f, 0.25948888f, -0.29204187f, -1.19778478f, -1.01949394f, 
    -0.88386399f, -0.36691499f, -0.20096208f, 1.13417172f, 0.56208515f, -0.04415638f, 0.70240992f, -0.09201608f, 
    -0.26437774f, 0.16246957f, -0.31279927f, -0.07945514f, -0.36252826f, -0.08595220f, -0.12702319f, -0.19403410f, 
    -0.27615720f, -0.11535893f, 0.28517222f, 0.04618840f, 0.12618537f, 0.12929961f, 1.19163942f, 0.80779809f, 
    -0.28492665f, 0.79195720f, 1.10311985f, 0.51719016f, 0.34658208f, -0.16609684f, 0.56477946f, -0.38629109f, 
    -0.65085107f, 0.22393773f, -0.07726263f, -0.26793802f, -0.02827604f, 0.03048242f, 0.32174909f, 0.49061969f, 
    0.11366084f, 0.10319094f, 0.28909653f, -0.15094800f, -0.15401986f, -0.05580801f, 0.11416782f, -1.03826952f, 
    -0.49805450f, 0.23310015f, -0.09215157f, -0.29679915f, -0.12812147f, 0.00629081f, -0.06593368f, -0.37607223f, 
    -0.34935561f, -0.01463446f, 0.59934604f, 0.22096494f, 0.55825108f, 0.44587022f, -0.35693386f, -0.42960382f, 
    0.23649497f, 0.41011953f, 0.44151115f, 0.08474103f, 0.02553116f, -0.23969398f, 0.50025183f, -0.11690306f, 
    -1.09609056f, -0.25962114f, -0.53326327f, -0.51119268f, -0.49631327f, -0.56670117f, -0.31808165f, -0.08775990f, 
    0.72752059f, 0.71313846f, 0.10257234f, 0.55368066f, -0.28242204f, -0.00461378f, -0.74901253f, 0.02004016f, 
    0.28303510f, 0.36896664f, 0.32087016f, -0.15221310f, -0.18034798f, -0.04227650f, 0.06435452f, -0.41742674f, 
    0.39788589f, -0.01897887f, 0.68398845f, -0.85243368f, -0.94421822f, -0.73142982f, 1.13526595f, 0.72938108f, 
    -0.50194657f, 0.07410655f, 0.33561662f, 0.29530221f, 0.00539987f, -0.00155753f, 0.00181863f, 0.15170021f, 
    0.08375291f, -0.04089674f, -0.01342368f, 0.02922043f, 0.11205956f, -0.01886531f, -0.31495753f, -0.01327570f, 
    -0.04783143f, 0.37501204f, -0.28208971f, 0.08618452f, -0.70771295f, 0.94064867f, -0.77494818f, 0.16352975f, 
    0.47008911f, -0.65999061f, -0.02274615f, -1.08663249f, -0.20629238f, 0.41474721f, -0.41665936f, 0.45812446f, 
    0.15474765f, -0.26875809f, 0.14326780f, -0.51922500f, -0.21065973f, 0.00720845f, 0.10724657f, -0.44243047f, 
    0.40369776f, 0.23972538f, 0.03554777f, 1.35977316f, 0.68765068f, 0.34613976f, 0.69533771f, 0.94268525f, 
    0.27206182f, -0.60402036f, -0.04590469f, 0.49056101f, 0.58662140f, 0.30879173f, 0.27403820f, -0.27485660f, 
    -0.04648699f, 0.05628628f, 0.06346082f, 0.03401262f, -0.08386975f, -0.26246452f, -0.38631782f, 0.23422723f, 
    0.08654571f, 0.17006527f, -0.09803426f, 0.21667227f, 0.13024205f, 1.01240337f, 1.01459825f, 0.61110818f, 
    0.24796246f, -1.09246516f, 0.00969338f, -0.42890707f, -0.59689951f, 0.42691833f, 0.20156193f, -0.04435939f, 
    -0.42393517f, 0.30380112f, 0.40020189f, -0.02556228f, -0.32639441f, -0.19218431f, -0.15300770f, -0.04687336f, 
    0.00795079f, 0.33883521f, 0.02782570f, 0.23284729f, 0.51638979f, 0.59596425f, 0.17886905f, 0.52575028f, 
    1.32957458f, 0.07837531f, -0.24186197f, -0.67665309f, 0.16627906f, 0.36838809f, 0.23095439f, -0.11405386f, 
    -0.42377797f, -0.06801503f, -0.26114914f, -0.00449716f, -0.06881399f, -0.09270580f, -0.45210898f, 0.04746141f, 
    0.23021074f, 0.80884171f, 0.04340133f, 0.26787531f, -0.39538163f, -0.04083772f, 0.91570085f, -1.36315727f, 
    -0.64906752f, 0.84546787f, 0.40160197f, -1.07657170f, 0.73528612f, 0.26729462f, -0.19248657f, 0.19370773f, 
    0.33335790f, 0.15090519f, -0.15736665f, -0.05806312f, -0.13672765f, -0.26057598f, 0.25533217f, -0.19300878f, 
    -0.02481570f, -0.17914666f, 0.08240682f, 0.17796457f, -0.04559062f, 0.14886911f, -0.06064829f, 0.96200460f, 
    0.45855218f, -0.04718174f, -0.58208680f, -0.55936128f, 0.08809996f, 0.46874768f, 0.51542968f, 0.06258978f, 
    0.45540637f, 0.69988817f, 0.05456700f, -0.01372534f, -0.03679335f, 0.36934423f, 0.52378160f, 0.23778273f, 
    -0.37789986f, -0.04100942f, 0.50503337f, -0.08272120f, 0.37106562f, 0.10782882f, -0.35667738f, -0.10100982f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18566673f, 0.00683202f, -0.00457163f, -0.20959583f, 0.47678897f, 0.17853808f, 0.19182560f, 0.18968779f, 
    0.15808935f, 0.30644208f, 0.07200071f, 0.31335887f, -0.01123896f, 0.22517249f, 0.03803806f, 0.18267034f, 
    0.41756961f, 0.27540573f, 0.02847324f, 0.23531707f, 0.15823695f, 0.22247662f, 0.43991637f, 0.40460742f, 
    0.32841489f, 0.11803674f, 0.25719002f, 0.19989328f, 0.22497195f, 0.21367402f, 0.18066232f, 0.44083127f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.53079021f, -0.02167366f, -0.33268985f, 0.41108468f, -0.12917030f, 0.03552083f, 0.01508913f, -0.07127680f, 
    0.02602933f, -0.09070563f, -0.15565147f, -0.10222477f, -0.12215406f, 0.03203044f, 0.05335495f, 0.10216313f, 
    -0.20341668f, 0.08758696f, 0.09812553f, 0.00172181f, 0.14972614f, -0.03578116f, 0.15160665f, -0.00634202f, 
    0.41230524f, -0.01922297f, -0.24437757f, 0.01172373f, 0.00408046f, -0.07195745f, -0.13547005f, 0.21742344f, 
    0.03461467f, -0.10544179f, 0.02860021f, -0.07226171f, -0.19013026f, 0.11923939f, -0.00564360f, 0.33805332f, 
    -0.00075207f, 0.07204144f, 0.15944049f, 0.13354690f, -0.01285641f, -0.13859986f, 0.00783487f, -0.14363433f, 
    -0.13288958f, -0.52262062f, 0.16155019f, -0.24560533f, -0.06244633f, 0.13076919f, 0.18332294f, -0.05931317f, 
    -0.06185330f, -0.07242776f, -0.05152188f, -0.00759742f, 0.42838940f, -0.24128567f, -0.11023760f, 0.32120955f, 
    -0.15530145f, -0.00978897f, -0.11917771f, 0.04452180f, -0.15427038f, -0.14274980f, -0.08505491f, -0.18622166f, 
    -0.29324225f, 0.16480157f, 0.04375654f, -0.01240664f, -0.08902812f, 0.08562202f, 0.13164921f, -0.15394978f, 
    -0.00680455f, -0.01018038f, -0.09778613f, -0.04824823f, -0.37662566f, -0.01943887f, -0.08041559f, -0.07373813f, 
    -0.09228014f, 0.02570620f, 0.11099916f, -0.09224242f, 0.12013685f, -0.07887242f, 0.12557459f, 0.18368134f, 
    -0.38468850f, -0.17315602f, -0.12834936f, 0.04738862f, 0.04127865f, -0.21584257f, 0.00917096f, -0.25852796f, 
    0.02078956f, 0.03466348f, 0.12825033f, -0.00030167f, -0.55546451f, -0.25679338f, -0.25361037f, 0.20127243f, 
    -0.00321504f, -0.10463454f, 0.13955599f, 0.06735256f, 0.13820159f, 0.11995882f, -0.00452298f, -0.04837488f, 
    0.05756981f, -0.16735861f, 0.00174932f, 0.42097989f, -0.11430902f, -0.00769168f, 0.02949715f, 0.02794682f, 
    -0.00183900f, -0.01905013f, -0.07219564f, -0.01904778f, -0.21904875f, -0.09411522f, 0.00122124f, -0.17930627f, 
    0.10898837f, -0.05006687f, 0.04542854f, 0.05291681f, 0.07328393f, 0.05249290f, -0.13414258f, 0.02731884f, 
    0.19567040f, 0.21347252f, -0.11875573f, -0.04843180f, -0.19518124f, 0.06894944f, 0.01257166f, 0.07252713f, 
    0.10219777f, -0.03050724f, -0.05272982f, -0.02391564f, 0.12853706f, 0.21875969f, 0.13911521f, -0.21405971f, 
    -0.07783613f, -0.12425471f, 0.03490422f, 0.08250368f, 0.02989637f, -0.07010187f, -0.13314624f, 0.06940664f, 
    -0.05687350f, 0.25214741f, -0.09081969f, 0.19051898f, 0.04369362f, -0.03376867f, -0.42668489f, 0.04656551f, 
    0.05042032f, -0.08373292f, -0.00554743f, -0.10100443f, 0.38263661f, -0.04412847f, -0.13852507f, -0.49310049f, 
    0.06067637f, -0.09411658f, 0.13057566f, -0.14543402f, -0.07787786f, -0.06577184f, 0.10084492f, 0.08954609f, 
    -0.44616175f, 0.48389739f, 0.07397430f, -0.11272092f, 0.04946190f, -0.05600414f, -0.18824004f, 0.15175994f, 
    -0.01804189f, -0.13709933f, -0.12314556f, 0.08137115f, -0.71478587f, -0.41026491f, 0.23115797f, -0.29254928f, 
    -0.07002225f, -0.00360935f, 0.02291489f, -0.02481646f, -0.13670002f, -0.01739599f, -0.00463432f, -0.11414576f, 
    0.30237466f, 0.03700868f, 0.10084373f, -0.03837323f, -0.08312102f, 0.14785868f, 0.25213891f, 0.10634311f, 
    -0.04295506f, 0.07430881f, -0.00839115f, -0.02218668f, -0.33762649f, 0.15736625f, -0.11724511f, 0.20713359f, 
    -0.07739606f, -0.01948084f, -0.11841897f, -0.09599818f, -0.03578577f, 0.02422633f, 0.09508236f, -0.03212462f, 
    0.13451019f, 0.14323546f, -0.01002367f, -0.45563349f, -0.13255113f, -0.01058315f, 0.02909562f, -0.04333770f, 
    -0.12474971f, -0.14959238f, 0.03697456f, -0.19731033f, -0.19386518f, 0.22707509f, 0.02882548f, -0.46961030f, 
    0.15784831f, -0.00046278f, 0.07636283f, -0.04675587f, -0.05146853f, 0.03102593f, -0.08289120f, 0.12652132f, 
    0.07765007f, -0.08080388f, -0.14017613f, 0.03476539f, -0.15832269f, 0.01280776f, -0.01185306f, 0.20607154f, 
    -0.07264902f, 0.15080029f, 0.01033264f, -0.03823522f, -0.72565663f, -0.12765461f, -0.02701776f, 0.08841493f, 
    0.06151455f, 0.07596543f, 0.10535441f, 0.03118007f, 0.11956146f, -0.01063812f, 0.04337943f, -0.07044055f, 
    0.16147660f, 0.05278048f, -0.48951212f, -0.19685414f, 0.02459046f, 0.00947992f, 0.07044979f, 0.09489879f, 
    -0.00104974f, -0.02618042f, -0.05679306f, -0.15912074f, 0.56774837f, -0.22628762f, 0.04765415f, -0.36495098f, 
    0.01005872f, -0.06870775f, 0.10323559f, 0.06820150f, 0.04568122f, 0.04978890f, 0.05212463f, 0.26217642f, 
    -0.14555554f, 0.24517113f, -0.04823086f, -0.02535466f, 0.02992055f, 0.08711020f, -0.17450966f, 0.00617611f, 
    0.00981451f, -0.01672995f, 0.14229922f, -0.13055082f, 0.42595518f, -0.15912884f, 0.14016496f, 0.19802696f, 
    -0.28785393f, -0.02977198f, -0.00098101f, 0.08868558f, -0.04747396f, 0.05240785f, 0.14946657f, -0.14775322f, 
    0.16291849f, 0.03809714f, -0.13734610f, 0.14694192f, -0.09163009f, 0.02816570f, 0.03711705f, -0.14439966f, 
    -0.13052313f, -0.00734041f, -0.03180424f, -0.06399371f, 0.15935419f, 0.03384010f, -0.24113950f, 0.47551405f, 
    0.07854193f, 0.14756969f, -0.04024683f, -0.14646128f, -0.07421289f, -0.13736521f, 0.00277749f, -0.05459125f, 
    0.05788537f, 0.04351634f, 0.01984426f, 0.43741405f, -0.04368950f, 0.05678520f, -0.07421834f, -0.03123021f, 
    -0.12365152f, 0.05411211f, -0.01033395f, -0.02957896f, -0.25998735f, -0.29073277f, -0.02820588f, -0.20963137f, 
    -0.14740250f, 0.02159959f, 0.14715314f, 0.07804954f, -0.11233857f, -0.08254274f, 0.04147177f, 0.07983320f, 
    -0.76677054f, -0.18475661f, 0.04265868f, 0.04848112f, -0.12821741f, 0.01891224f, -0.04484480f, 0.01202305f, 
    0.08199331f, 0.05852789f, 0.06883012f, 0.10106204f, 0.10630694f, -0.08140151f, -0.28004679f, -0.17638303f, 
    0.16850071f, -0.18002389f, -0.05855894f, -0.06208238f, -0.20758265f, 0.04891505f, -0.08158415f, 0.01628106f, 
    0.20016252f, 0.04388259f, 0.12317354f, 0.31288660f, -0.16689332f, 0.12785535f, 0.06414252f, -0.04002298f, 
    0.11443891f, 0.05682831f, -0.06185890f, 0.01375807f, 0.12076236f, 0.05194499f, -0.18121663f, -0.00248504f, 
    -0.10562081f, 0.16666810f, -0.00115980f, -0.17672053f, 0.04099867f, 0.02567316f, -0.24608706f, 0.01637311f, 
    0.19628143f, -0.10007567f, 0.07285811f, -0.10381923f, -0.05194809f, -0.04304059f, -0.24607581f, 0.17707749f, 
    -0.10645503f, -0.01226910f, -0.00635088f, -0.00361802f, 0.11584417f, 0.04372200f, 0.12720665f, 0.05335806f, 
    -0.09083150f, -0.13854076f, 0.13556060f, 0.02163064f, 0.04255726f, 0.04759267f, 0.15514715f, 0.00824734f, 
    -0.14492743f, 0.21754006f, -0.08020394f, -0.18206766f, 0.26866722f, -0.12722576f, -0.20623901f, -0.04614379f, 
    0.12916175f, -0.24712786f, 0.16709866f, -0.19912469f, -0.13702314f, -0.02936428f, -0.00617175f, 0.10377262f, 
    -0.06712680f, -0.05320174f, -0.11896268f, 0.00924256f, -0.26449591f, -0.15098052f, 0.02726563f, -0.08111605f, 
    0.31686297f, -0.32978448f, 0.04334251f, -0.01435295f, -0.09270953f, 0.09237736f, -0.08108377f, 0.09168968f, 
    -0.14094248f, -0.01997905f, -0.31477576f, 0.05314795f, -0.16710658f, 0.10606868f, -0.36791039f, 0.04344868f, 
    0.17569318f, 0.04366853f, 0.02514864f, 0.07819603f, 0.06610605f, -0.13501351f, 0.06869051f, 0.10971344f, 
    0.59122717f, -0.01687541f, 0.08277214f, 0.21217488f, -0.20040075f, 0.05846930f, 0.05539184f, 0.06678634f, 
    -0.03384456f, 0.21499693f, 0.02568834f, -0.03471108f, 0.26123342f, 0.13309276f, -0.17464395f, 0.06526696f, 
    -0.14795025f, 0.04761098f, 0.17596675f, -0.02629383f, -0.00327402f, 0.04717861f, 0.05117078f, 0.16773269f, 
    0.06913968f, 0.01247101f, 0.20912857f, 0.19639675f, -0.04128907f, -0.17417422f, -0.10673949f, -0.04184788f, 
    -0.02596009f, 0.16890967f, 0.02799253f, 0.07268897f, -0.05716488f, -0.11772563f, 0.02546662f, -0.02750037f, 
    -0.03502842f, 0.06020916f, 0.03231888f, -0.08021229f, -0.04564697f, 0.03132874f, 0.08077044f, 0.02696231f, 
    0.42581198f, -0.38614622f, -0.35308495f, -0.15896502f, 0.09646481f, -0.27858728f, 0.25830179f, 0.09026615f, 
    -0.15976702f, -0.12314531f, -0.11388244f, 0.03450003f, 0.18290022f, -0.22620206f, 0.18636042f, -0.19911790f, 
    0.10294488f, -0.26952219f, 0.02078728f, -0.03050715f, -0.10946725f, 0.07872281f, 0.05702801f, -0.02279685f, 
    0.27758074f, 0.04385315f, -0.29052392f, -0.06707319f, -0.02833022f, 0.17769361f, -0.15308271f, -0.05430821f, 
    0.01902701f, -0.00943548f, 0.19992080f, -0.03256704f, 0.27488369f, -0.04747975f, 0.00974216f, -0.14636189f, 
    -0.02053557f, 0.03974468f, 0.10233764f, -0.07455028f, 0.21117988f, 0.00144295f, 0.00724226f, -0.09564751f, 
    0.15729339f, -0.03169939f, 0.13913877f, 0.11651017f, 0.16668136f, -0.06014046f, -0.20295545f, -0.05415173f, 
    0.11066831f, -0.22346383f, -0.00548536f, -0.02502497f, -0.39295802f, -0.05531169f, -0.26919743f, 0.28690526f, 
    -0.13286301f, 0.00795781f, -0.12473655f, -0.03897145f, 0.11923997f, -0.06621110f, -0.04011162f, -0.12483466f, 
    -0.08059052f, 0.37670320f, -0.27479932f, -0.12211875f, 0.06383477f, -0.00465990f, -0.04598766f, 0.03821280f, 
    0.15483677f, 0.19814195f, 0.03707781f, 0.26365763f, 0.42232737f, -0.28485978f, -0.06212681f, -0.10936277f, 
    -0.01077124f, -0.02952668f, -0.02896301f, 0.01636033f, 0.06727314f, -0.10766876f, 0.02295499f, -0.00811430f, 
    0.16807303f, 0.03020707f, 0.00569461f, 0.32268587f, -0.05395412f, -0.04204408f, -0.15768161f, 0.04288691f, 
    -0.03874637f, -0.09560968f, 0.04493135f, -0.20927976f, -0.16888940f, 0.05205628f, -0.13958158f, 0.03036637f, 
    0.00008804f, -0.20279887f, -0.10041107f, -0.12617379f, -0.15544996f, 0.11101142f, 0.05413594f, -0.01568113f, 
    -0.27882150f, -0.16324809f, -0.16991851f, -0.01581070f, -0.03778709f, -0.09829488f, -0.04268105f, 0.18239389f, 
    0.22051650f, -0.18148528f, 0.08903193f, 0.09026756f, -0.22574349f, -0.44701493f, 0.11304983f, -0.39241955f, 
    -0.11847547f, -0.00536802f, -0.02310726f, 0.00212751f, -0.20492060f, -0.03388717f, 0.00711007f, -0.03326327f, 
    -0.19441098f, -0.38754523f, -0.62462252f, -0.06320786f, -0.02310341f, 0.09641352f, 0.02418054f, -0.02019886f, 
    0.00602842f, 0.08432719f, -0.13723229f, 0.15568577f, 0.16149682f, 0.03322127f, 0.23717727f, 0.25331280f, 
    -0.06624566f, -0.07725433f, 0.01112666f, 0.04175662f, -0.00729386f, -0.10700738f, -0.20293410f, -0.00470072f, 
    -0.03765921f, 0.01745769f, -0.09390800f, -0.07726414f, 0.03313428f, 0.13371840f, 0.13017046f, 0.03756186f, 
    0.02269095f, -0.02016651f, -0.08195086f, 0.00592414f, 0.13575755f, 0.00254261f, 0.00188701f, 0.29358765f, 
    -0.02540047f, -0.03330695f, 0.04749610f, 0.01117577f, -0.08038709f, -0.04761619f, 0.11520609f, 0.02272482f, 
    0.31741041f, -0.71268976f, 0.00026101f, 0.16700713f, -0.14500545f, -0.04696295f, -0.01941757f, 0.13116238f, 
    0.13121191f, -0.02652216f, 0.00561876f, -0.01165578f, 0.34972769f, 0.02685001f, 0.02221407f, -0.19899738f, 
    -0.19707285f, -0.32721463f, -0.00862609f, -0.00846692f, -0.19282921f, 0.12911341f, 0.05444785f, 0.03018385f, 
    0.51055330f, 0.12479018f, -0.17356554f, -0.01601243f, 0.04110977f, 0.07740074f, -0.03702125f, -0.03741121f, 
    -0.00119704f, 0.00007314f, -0.14081608f, -0.12327619f, 0.19454618f, -0.01504040f, -0.13277532f, -0.12773748f, 
    -0.05909635f, 0.03277021f, -0.07420386f, 0.01272244f, 0.06976855f, 0.00741385f, 0.00557041f, -0.00630945f, 
    -0.27167013f, 0.23905823f, -0.04810486f, -0.07188239f, 0.07508778f, 0.07478154f, -0.06350122f, 0.07025068f, 
    -0.14719094f, 0.15025456f, 0.04132011f, 0.00488552f, -0.03302176f, -0.17832710f, -0.25226733f, 0.00526377f, 
    -0.08268284f, 0.07033963f, -0.11827054f, -0.01439938f, 0.10363011f, -0.07724121f, -0.04155937f, -0.20095427f, 
    -0.42856863f, -0.28593931f, 0.14255513f, -0.19002990f, 0.05065335f, 0.01788880f, 0.11158185f, -0.06840310f, 
    -0.05577980f, 0.04428003f, -0.02862705f, 0.03440860f, -0.48654193f, -0.11666087f, -0.05145972f, -0.04769952f, 
    0.04959820f, 0.00487144f, -0.24665271f, 0.13532077f, -0.02889550f, 0.06643540f, -0.06661914f, -0.18135406f, 
    0.12863301f, 0.08555829f, -0.21030696f, -0.02987092f, 0.01173828f, -0.01088794f, 0.23706785f, 0.00453824f, 
    -0.20398121f, -0.18948700f, 0.03865282f, -0.09883435f, 0.26545730f, -0.02543768f, -0.06135543f, -0.09585978f, 
    -0.06175720f, -0.03593676f, -0.05448978f, -0.06809843f, -0.00595524f, -0.07935243f, -0.02715161f, -0.11555938f, 
    0.53593606f, -0.18609107f, 0.25982097f, 0.04302125f, 0.03990373f, 0.02313902f, 0.15728347f, -0.01773251f, 
    0.04876550f, 0.02550253f, 0.18643543f, -0.18802845f, 0.54854923f, -0.36751318f, -0.00496737f, -0.07008288f, 
    0.04836207f, -0.05646518f, -0.15027060f, 0.08541246f, -0.04760446f, -0.06462583f, -0.17108896f, -0.06575128f, 
    -0.19192995f, -0.01147413f, 0.21603648f, -0.12618285f, 0.06814397f, 0.00883455f, -0.08491582f, -0.03749573f, 
    0.13070185f, 0.13576184f, 0.03973457f, 0.03560754f, 0.17385605f, -0.17710602f, -0.01606143f, 0.12133336f, 
    -0.11387399f, -0.06242538f, -0.05411039f, -0.03903438f, -0.18633287f, -0.03843410f, 0.00048072f, -0.06262217f, 
    0.16201861f, 0.06518921f, -0.01227991f, 0.07987830f, 0.15930395f, 0.04507484f, 0.07644723f, -0.06325475f, 
    -0.04537135f, -0.05925475f, -0.02994160f, -0.02723500f, -0.07831749f, 0.11869881f, -0.22006170f, 0.15761742f, 
    0.07596805f, 0.01236844f, -0.05900082f, -0.15576768f, -0.12161034f, -0.00059812f, -0.09194010f, -0.10969900f, 
    -0.43567699f, 0.13306868f, -0.12670974f, -0.23410830f, -0.07887851f, 0.13501857f, 0.01715886f, 0.04042953f, 
    -0.12135873f, 0.01915551f, -0.00636087f, -0.05406741f, -0.29294065f, 0.26237148f, -0.06079711f, 0.41047421f, 
    -0.08206616f, -0.09410971f, 0.22233173f, 0.12629721f, -0.04297340f, -0.12834105f, -0.04808064f, 0.00005372f, 
    0.39130720f, -0.09433048f, -0.04282906f, 0.09836303f, -0.02675154f, 0.12809119f, -0.13912573f, -0.05045538f, 
    0.06123996f, -0.13695148f, 0.03945757f, 0.11845011f, -0.05693324f, -0.24121252f, 0.04299227f, -0.46553975f, 
    -0.00289453f, -0.12777457f, -0.12180599f, -0.04834442f, -0.04617314f, -0.09129425f, -0.03454512f, -0.11090053f, 
    0.30423680f, -0.04126319f, 0.03413241f, 0.09271078f, -0.12980852f, -0.01195312f, 0.08860487f, 0.09808314f, 
    -0.02019910f, -0.05308424f, 0.03890177f, -0.05782671f, -0.11660324f, 0.04438264f, -0.36706501f, -0.41624814f, 
    -0.21380617f, -0.05592009f, 0.06817643f, 0.03876143f, 0.35688654f, 0.07345707f, 0.03605637f, -0.19199306f, 
    0.07178750f, 0.08432350f, -0.30925500f, -0.29149055f, 0.13477710f, -0.03213612f, 0.02068704f, 0.04908868f, 
    -0.28073215f, -0.09422344f, 0.04005153f, -0.11688646f, 0.33945692f, 0.18925755f, 0.30784586f, 0.33327049f, 
    -0.25828272f, -0.25265554f, 0.00969503f, 0.13410164f, 0.01121142f, 0.08847009f, 0.03301845f, 0.03304206f, 
    0.01089464f, -0.08871163f, 0.04773340f, 0.03434884f, 0.15260807f, -0.03316773f, 0.08987625f, -0.13484402f, 
    -0.10520245f, 0.00986823f, -0.03965237f, 0.05006757f, 0.13193949f, -0.10288081f, -0.10516220f, -0.27711847f, 
    -0.09623418f, -0.01986437f, -0.05120019f, 0.05713566f, 0.03691593f, -0.09675360f, -0.01706016f, -0.14676893f, 
    -0.12833223f, -0.29878718f, 0.10224824f, 0.16256240f, -0.23330693f, 0.03105199f, -0.00116942f, 0.11616868f, 
    -0.02163657f, -0.04281178f, -0.05574117f, -0.03397263f, 0.28228024f, 0.04479033f, 0.27104896f, -0.11308475f, 
    -0.01370556f, -0.22745314f, 0.02081744f, -0.07747976f, -0.04175625f, 0.01072129f, 0.18189624f, -0.21405274f, 
    0.13098714f, -0.08417968f, -0.47069201f, -0.30893308f, -0.11610513f, 0.04513380f, -0.06593994f, -0.08558850f, 
    -0.00809668f, -0.10591823f, -0.06279176f, -0.00167421f, 0.10979512f, 0.16499108f, -0.04327156f, 0.05387907f, 
    -0.02946540f, -0.00473104f, 0.04289948f, -0.10583525f, -0.02480990f, 0.05654313f, 0.09035374f, 0.01290138f, 
    0.18036671f, 0.03962880f, -0.27566704f, 0.05755638f, 0.02867230f, 0.16574623f, -0.07738927f, -0.04043324f, 
    0.01930073f, 0.00622139f, 0.02072793f, -0.02096116f, -0.27782634f, 0.12608202f, -0.33099341f, -0.01524567f, 
    -0.04484924f, 0.06561571f, -0.10088119f, -0.07212889f, 0.12117155f, 0.03287192f, 0.26646855f, -0.01921652f, 
    0.62159055f, -0.22740771f, 0.03978674f, -0.13723545f, -0.01792481f, -0.01229953f, 0.08012317f, 0.08458143f, 
    -0.11876970f, 0.05431829f, -0.04162534f, -0.01297283f, -0.00010283f, 0.15079607f, 0.15535854f, 0.07154711f, 
    -0.20097956f, -0.07997923f, 0.02391198f, 0.02627357f, -0.02714659f, -0.17678855f, -0.05542342f, -0.09150777f, 
    -0.34993428f, 0.32240865f, 0.21676277f, -0.00063042f, -0.05232266f, 0.19333923f, -0.07724473f, 0.04904632f, 
    -0.13766900f, -0.05759244f, -0.10018945f, -0.03070210f, -0.10617612f, 0.24390587f, 0.22930980f, -0.01936529f, 
    0.21125820f, -0.04771182f, 0.06469339f, -0.00112504f, 0.06050117f, 0.01209280f, 0.15263124f, 0.01970416f, 
    0.57142442f, -0.63206744f, 0.14300209f, 0.18644385f, -0.06008664f, 0.00875709f, 0.22890095f, -0.04549164f, 
    -0.05633435f, -0.18221536f, -0.03138905f, 0.08720350f, -0.34905887f, -0.23073937f, -0.18153872f, 0.21205936f, 
    0.05443183f, -0.15157454f, 0.09397258f, 0.07261938f, 0.18239109f, 0.09287617f, 0.19355424f, 0.09119087f, 
    0.15793781f, 0.26548088f, -0.02942572f, 0.23712438f, -0.03970272f, 0.14858049f, -0.02602008f, -0.28379488f, 
    -0.01038794f, 0.05733067f, -0.06810778f, -0.04411358f, 0.17706229f, -0.19557230f, -0.29074338f, -0.02828723f, 
    -0.11635683f, -0.03390069f, -0.15001278f, 0.26114267f, 0.18242139f, 0.01130349f, -0.06430172f, 0.05773880f, 
    -0.47963813f, 0.16558735f, 0.22067039f, 0.17382231f, -0.10952489f, 0.00188771f, 0.02760908f, 0.04348775f, 
    0.01151307f, 0.21598399f, -0.07694963f, 0.14362177f, 0.11269020f, 0.11674125f, 0.33004996f, 0.02652135f, 
    0.21482794f, 0.02726888f, -0.01938486f, -0.02398228f, 0.01888140f, 0.00429188f, -0.06161423f, -0.10112026f, 
    0.12153843f, 0.09235650f, 0.03688293f, 0.04376529f, -0.02993048f, -0.00531028f, -0.12663370f, -0.08828869f, 
    0.06585234f, 0.01872686f, 0.06339004f, 0.00511075f, 0.17453402f, 0.03469086f, -0.07116849f, -0.18507905f, 
    0.17054737f, -0.06724731f, 0.10642649f, 0.14711556f, 0.03728237f, 0.06809147f, 0.03669966f, -0.07794186f, 
    -0.90865147f, -0.47026116f, -0.30195385f, -0.04811705f, -0.09173696f, -0.00062330f, -0.07505900f, -0.21041806f, 
    0.18053754f, -0.16968629f, 0.11815063f, 0.08998851f, 0.13228458f, -0.12156273f, -0.14609873f, -0.26153198f, 
    -0.23673831f, -0.17462236f, -0.03161209f, -0.09974429f, 0.07000741f, -0.01234301f, -0.02998162f, -0.09932368f, 
    -0.25226626f, -0.41939786f, 0.20722653f, 0.04499013f, -0.05219921f, -0.05965246f, 0.00022309f, 0.00716490f, 
    0.03329516f, -0.04869289f, -0.00906349f, -0.11298147f, 0.03093058f, -0.22764432f, 0.12981629f, 0.35383239f, 
    0.02757227f, 0.11283600f, 0.00514169f, -0.06069291f, 0.00394613f, -0.09773372f, -0.15376657f, -0.19407405f, 
    -0.00730313f, 0.02651748f, -0.41197622f, -0.08212061f, -0.09800713f, 0.26767468f, -0.01963925f, 0.04669189f, 
    0.11019789f, 0.08942945f, 0.07677822f, 0.00509522f, -0.19197425f, -0.35897321f, -0.00340808f, -0.06535430f, 
    -0.02170494f, 0.04654638f, 0.12738049f, 0.04440932f, -0.08948202f, 0.10236950f, -0.03379087f, 0.03816725f, 
    -0.47948682f, 0.23206499f, 0.17374912f, -0.08179197f, -0.16225371f, 0.00348865f, 0.22774868f, -0.00386966f, 
    -0.11730793f, 0.08741733f, -0.28680596f, 0.12582074f, 0.07417076f, 0.03822804f, 0.16695198f, 0.27240565f, 
    0.02076756f, 0.12127490f, -0.06783553f, -0.07519234f, 0.00875947f, 0.16323173f, 0.00495203f, 0.02403389f, 
    -0.26308987f, 0.06100323f, -0.26894599f, -0.43319535f, -0.19495879f, -0.04700894f, -0.05004142f, 0.02541364f, 
    0.02056607f, 0.03283311f, 0.08686730f, -0.03689288f, 0.26284906f, -0.01058104f, 0.27426672f, 0.05060713f, 
    0.03512223f, 0.08131994f, 0.04949909f, 0.07789948f, -0.01746365f, -0.04606856f, -0.00248958f, 0.04399766f, 
    -0.68480402f, 0.12933722f, 0.14777410f, -0.04922475f, 0.08386523f, 0.04248186f, 0.01290150f, 0.05910986f, 
    0.02619241f, -0.10357041f, -0.02860264f, -0.11061415f, 0.21377645f, -0.06743027f, -0.06789973f, 0.04134652f, 
    -0.04491910f, 0.00599217f, -0.02049874f, 0.00521412f, -0.22366618f, 0.02266709f, -0.00895378f, 0.01986210f, 
    0.01663619f, -0.56549484f, -0.27228433f, -0.06055895f, -0.12465937f, -0.13469502f, -0.07195289f, -0.08029161f, 
    0.01004439f, -0.06078091f, 0.16290541f, 0.13401446f, 0.07341755f, 0.23660934f, 0.16554794f, -0.19202274f, 
    -0.05101553f, -0.19738580f, -0.12723210f, -0.09676863f, -0.05960744f, -0.11452244f, -0.00407800f, 0.11470266f, 
    -0.07733558f, 0.26395047f, 0.00788769f, -0.14758135f, -0.27525917f, 0.06125300f, -0.05528507f, 0.07594744f, 
    -0.06099671f, -0.01408632f, -0.01479602f, 0.04473821f, -0.06574851f, 0.02651830f, 0.09546195f, 0.02450397f, 
    -0.19644892f, 0.00524134f, -0.02872946f, 0.05782777f, -0.05172963f, -0.17160307f, -0.14783670f, -0.01880106f, 
    0.30113015f, 0.11972585f, 0.15486407f, -0.00537979f, 0.13624494f, 0.01405353f, -0.01521936f, -0.04716282f, 
    0.02683236f, 0.00657448f, 0.19000803f, 0.06735293f, -0.16189456f, -0.24093661f, -0.49110609f, 0.19685687f, 
    -0.06814615f, 0.11807659f, 0.06871688f, -0.17962173f, 0.03084889f, 0.01454689f, 0.00614826f, -0.10788801f, 
    -0.64539576f, -0.09909861f, 0.00160150f, 0.15836474f, 0.04955751f, -0.06190152f, -0.03086014f, -0.01079050f, 
    -0.04041278f, -0.14456956f, -0.00913915f, -0.08063723f, 0.24566795f, -0.18112968f, -0.13114592f, 0.25237828f, 
    0.05185717f, -0.01127727f, 0.03889409f, -0.10167807f, 0.00418456f, 0.17316489f, -0.00538525f, -0.06625555f, 
    -0.03452381f, 0.13771524f, 0.27872699f, 0.00717968f, 0.02772242f, 0.05160910f, 0.07879834f, -0.01980764f, 
    -0.11032651f, 0.14095354f, -0.09555820f, 0.00225600f, -0.29536578f, -0.37345585f, -0.24090688f, -0.15766847f, 
    -0.08715361f, 0.06495092f, -0.22787605f, 0.14579217f, 0.03933436f, -0.02106336f, -0.12547339f, -0.08632624f, 
    -0.51828098f, 0.04462476f, -0.03542057f, -0.31477782f, -0.03243612f, -0.00561320f, -0.00747943f, 0.01502478f, 
    -0.07084995f, 0.00546069f, 0.02406805f, -0.09080154f, -0.12049770f, -0.12543441f, 0.40581709f, 0.22854266f, 
    -0.01692974f, 0.13170409f, 0.01797455f, 0.04045251f, 0.12947787f, -0.02215228f, 0.08555640f, 0.03872512f, 
    0.16135521f, 0.26107070f, 0.06372149f, 0.04746142f, -0.00679220f, -0.09460043f, -0.08047263f, 0.02738434f, 
    -0.00268586f, 0.04260952f, 0.07411109f, -0.13443969f, 0.30439880f, 0.11001740f, -0.10125925f, -0.41897991f, 
    -0.01266771f, 0.16982703f, 0.03954425f, 0.25411814f, -0.00683343f, 0.02572034f, 0.06685496f, 0.09829149f, 
    -0.30484009f, -0.17559361f, -0.03553931f, 0.00256103f, 0.07333767f, -0.18954733f, -0.02804266f, 0.00610380f, 
    -0.02199758f, -0.14356165f, -0.00567181f, 0.04508946f, -0.24785922f, 0.57200140f, 0.10965344f, -0.16581345f, 
    -0.10043724f, 0.07893516f, 0.05725364f, -0.05271721f, 0.00354395f, -0.09562918f, -0.07675533f, 0.00366179f, 
    -0.03183466f, -0.30503297f, 0.29238585f, -0.04657281f, -0.08260400f, 0.19428383f, 0.15284528f, 0.24589643f, 
    -0.15199436f, 0.17389169f, -0.09113754f, 0.17670585f, -0.26759338f, -0.06041621f, -0.14993624f, 0.04390411f, 
    0.09178621f, -0.05751659f, -0.01377486f, 0.16727954f, -0.06008885f, 0.05649676f, 0.03124641f, -0.00124586f, 
    -0.22779351f, 0.36482900f, -0.01538616f, -0.01473320f, -0.17127123f, 0.04109646f, 0.06575141f, -0.05506321f, 
    -0.11340886f, -0.08766180f, 0.04980001f, -0.17086221f, 0.03150813f, 0.25552413f, 0.26035464f, -0.49708596f, 
    -0.11317921f, -0.01080047f, -0.18529549f, -0.03436001f, 0.09099237f, -0.32624879f, -0.08478212f, -0.00249780f, 
    -0.06503425f, 0.28335753f, -0.29680914f, 0.13612944f, 0.03700233f, -0.02765110f, 0.14637390f, 0.07649688f, 
    -0.01709860f, 0.08418445f, 0.04142682f, 0.09799507f, 0.00819397f, -0.05053395f, 0.19739524f, 0.19296341f, 
    0.17164165f, -0.01312161f, 0.17903277f, 0.23509026f, 0.04462575f, 0.02336399f, -0.02916963f, -0.14303954f, 
    -0.24965756f, -0.25170112f, 0.08511946f, 0.02757383f, -0.12102351f, -0.01763210f, -0.09312605f, -0.02345455f, 
    0.00936599f, -0.05000117f, -0.02968950f, -0.08978787f, -0.60140771f, 0.02188474f, 0.26111346f, 0.05227794f, 
    -0.02626149f, -0.00194808f, -0.05251395f, -0.07156377f, -0.00874325f, -0.01329460f, 0.03543909f, -0.19499125f, 
    -0.08683173f, -0.21110341f, -0.01446214f, 0.01881513f, -0.13511755f, -0.06454670f, 0.13225532f, -0.09893239f, 
    0.05190913f, 0.10427860f, -0.00867271f, -0.18290651f, -0.11663375f, -0.18910657f, 0.10414500f, 0.17025337f, 
    -0.13625702f, 0.12608068f, -0.03548001f, -0.04452980f, 0.11597664f, 0.01776177f, 0.06829197f, 0.08094113f, 
    -0.22107954f, -0.11732116f, -0.07765403f, -0.14380167f, -0.03459558f, -0.04761590f, 0.14644907f, -0.21611218f, 
    0.00690717f, -0.06554857f, -0.08604327f, -0.06044401f, -0.13468003f, 0.04724116f, 0.18051142f, -0.02851157f, 
    0.08254758f, -0.07728209f, -0.07631865f, 0.04439382f, 0.12389242f, -0.05608493f, -0.12013442f, 0.14496839f, 
    -0.14167486f, -0.38286433f, -0.07937011f, 0.20859222f, -0.12180236f, -0.01573213f, -0.03572187f, 0.06034580f, 
    0.04519039f, 0.09653731f, 0.06326538f, 0.12259621f, -0.03059268f, -0.00030320f, 0.00509448f, -0.42580396f, 
    0.13066010f, 0.15058696f, 0.00529950f, -0.01004892f, -0.24603069f, -0.03530410f, 0.09131329f, 0.23176354f, 
    -0.30941543f, -0.14148067f, 0.31421441f, -0.07188793f, -0.17612740f, -0.12053799f, -0.03762665f, -0.11897200f, 
    0.15459600f, -0.12778494f, -0.13345419f, -0.23534596f, -0.76737684f, 0.00765774f, 0.11485577f, 0.18591261f, 
    0.02052809f, 0.06684057f, 0.07645213f, 0.09844914f, -0.12327139f, -0.06672835f, -0.07419156f, -0.02074451f, 
    0.61997259f, -0.09817132f, -0.06893105f, -0.09077559f, -0.08044943f, -0.09453761f, 0.15272607f, 0.00915220f, 
    -0.04172510f, 0.03204079f, -0.05378009f, -0.06761000f, -0.14348136f, 0.08227079f, 0.13368545f, -0.08994360f, 
    0.05350079f, 0.01789438f, -0.07503802f, 0.10893578f, -0.10376486f, -0.12904447f, 0.02008973f, -0.02687132f, 
    0.49612385f, 0.08077400f, 0.01785322f, 0.26938719f, 0.08418953f, 0.20825137f, -0.05050951f, 0.18404336f, 
    -0.05326009f, 0.20856744f, 0.22981599f, 0.06363650f, -0.34256914f, -0.06109286f, 0.10607079f, 0.28796920f, 
    0.12024982f, 0.00445640f, 0.12377389f, -0.02095008f, 0.04892485f, -0.02419370f, 0.01275025f, -0.01919508f, 
    0.03515215f, 0.34230629f, -0.06781594f, -0.38131675f, 0.11928969f, -0.19864337f, -0.03536979f, 0.00197029f, 
    -0.17708845f, -0.00419730f, 0.09619184f, 0.01034619f, 0.06701953f, -0.30227831f, -0.03816981f, 0.02680267f, 
    -0.06174022f, -0.04814000f, 0.01954429f, 0.00827999f, 0.16361642f, 0.03924486f, -0.16127227f, -0.07443110f, 
    -0.47010666f, 0.05898770f, 0.25400710f, 0.26788798f, -0.12242979f, -0.09423532f, -0.03431604f, -0.00203099f, 
    0.21055603f, 0.05045547f, 0.03740289f, -0.01183683f, 0.07828475f, -0.00206778f, 0.23967229f, 0.00375585f, 
    -0.02010455f, 0.14528112f, 0.06146770f, -0.10605864f, -0.03904529f, -0.08138644f, 0.00733691f, -0.05919326f, 
    -0.30896670f, 0.23960020f, -0.11901879f, -0.02514803f, 0.01062349f, 0.01744521f, -0.02753577f, -0.14130135f, 
    -0.02784757f, -0.02727809f, -0.03511738f, -0.01803763f, -0.05684809f, -0.14513628f, 0.16176000f, -0.13687891f, 
    -0.06736104f, 0.11504482f, -0.01903590f, -0.05031892f, 0.10069954f, 0.02278949f, -0.03530005f, -0.01620042f, 
    -0.14904299f, -0.03141885f, 0.04119121f, 0.01166394f, 0.03964682f, -0.09753478f, -0.03642085f, 0.07923191f, 
    -0.00553524f, -0.06066228f, 0.10951388f, -0.05711317f, 0.15018931f, 0.13301264f, -0.41628417f, 0.06165445f, 
    -0.20431811f, -0.04992481f, -0.08162895f, 0.16798697f, -0.10838208f, 0.08083054f, -0.13123739f, -0.24121518f, 
    -0.07114000f, 0.05332491f, 0.09951174f, -0.07549315f, -0.13179639f, -0.01579577f, 0.03598150f, -0.06261373f, 
    -0.16646652f, -0.06772536f, 0.05213022f, 0.19070864f, -0.30619991f, 0.08170699f, 0.21045211f, 0.21189836f, 
    0.14502376f, -0.25050759f, 0.04695703f, -0.04296528f, -0.06262888f, 0.08385105f, -0.19228579f, -0.08208498f, 
    0.01981584f, 0.01031362f, -0.26273328f, 0.04117611f, -0.08949006f, 0.15772299f, -0.08023731f, 0.09730648f, 
    0.03400831f, 0.13721487f, 0.21023655f, -0.01592414f, -0.26000983f, -0.12496781f, -0.03191393f, 0.26441169f, 
    -0.02272568f, -0.02587882f, 0.15653625f, -0.17455792f, 0.08512250f, 0.03287452f, -0.12298227f, 0.05691542f, 
    0.33968505f, -0.00535288f, -0.09822942f, 0.07607807f, -0.06945274f, -0.08857713f, -0.22740550f, 0.02923884f, 
    0.09714616f, 0.05316243f, -0.06125014f, 0.09995788f, -0.08073472f, 0.15114886f, 0.02084770f, -0.10144481f, 
    -0.04374607f, 0.17245439f, 0.01764147f, -0.22976251f, 0.03526110f, 0.10942463f, -0.13562497f, 0.10860137f, 
    -0.27253208f, -0.25836551f, -0.05791559f, -0.04147785f, -0.07841904f, -0.09407542f, -0.06324165f, 0.04494834f, 
    0.00103713f, -0.06738102f, -0.20856000f, -0.14077911f, -0.49483871f, -0.10173692f, 0.18562546f, -0.06037817f, 
    -0.08063428f, -0.00465658f, 0.05638878f, -0.14691044f, -0.00722693f, 0.15379080f, 0.11192529f, -0.07525543f, 
    -0.10074083f, 0.10964163f, 0.24349852f, -0.13656236f, 0.03477332f, 0.09041128f, -0.01213813f, -0.02779018f, 
    0.09413107f, -0.11876667f, -0.03123330f, -0.15434526f, -0.67850286f, -0.18106365f, -0.14004338f, 0.07614133f, 
    0.17763197f, 0.07853124f, -0.25396279f, 0.01388110f, 0.09851304f, -0.17714667f, 0.07092046f, 0.16450869f, 
    -0.06681804f, 0.03525047f, 0.14223692f, -0.10133439f, 0.04942778f, 0.12627408f, 0.20809679f, 0.06586579f, 
    -0.18634871f, 0.00623689f, 0.13772452f, 0.11865277f, 0.20129965f, -0.00466227f, 0.11781834f, 0.28774253f, 
    -0.10952296f, 0.04184608f, 0.10834610f, -0.04667889f, -0.14421563f, 0.13691357f, 0.15065481f, 0.35167155f, 
    -0.00525079f, 0.31676972f, 0.00949155f, 0.12555121f, -0.07144730f, -0.05959272f, 0.02561565f, 0.13112698f, 
    0.01970046f, -0.04407752f, 0.05173836f, -0.05241421f, 0.38307303f, -0.13459152f, 0.00115645f, -0.12480133f, 
    -0.02425757f, -0.04159423f, -0.14101352f, -0.23631172f, -0.09144165f, -0.06520316f, -0.05186825f, 0.03893130f, 
    -0.44880480f, 0.11159943f, 0.16895217f, -0.46758282f, 0.11878358f, -0.03026602f, 0.04309224f, -0.04339340f, 
    0.08986947f, 0.09137594f, 0.08818992f, -0.13271056f, 0.10971073f, 0.19674459f, -0.06463137f, 0.36029804f, 
    0.01994302f, 0.10945974f, 0.01432541f, 0.15715744f, 0.00839686f, 0.15327092f, 0.15949160f, 0.19621249f, 
    0.27324504f, 0.22936876f, 0.23457645f, -0.27503803f, 0.03820805f, 0.06240785f, -0.19088209f, -0.26741475f, 
    -0.15996034f, -0.17202571f, -0.02869882f, 0.09848561f, 0.15040907f, 0.02545676f, -0.16012548f, -0.07297044f, 
    0.12314256f, -0.00543861f, 0.07592436f, 0.18035302f, -0.08365001f, 0.05323465f, -0.01747599f, -0.29799503f, 
    -0.13576460f, -0.08624053f, 0.07192945f, 0.10100913f, -0.12535304f, 0.04553980f, 0.12931089f, -0.04623472f, 
    0.12900680f, 0.08241559f, 0.06531510f, 0.05257546f, -0.48983976f, -0.30823204f, -0.39603224f, -0.15707017f, 
    0.10557194f, 0.03788657f, 0.09233767f, -0.00906202f, -0.04870972f, 0.06812335f, -0.00556138f, -0.12623727f, 
    0.00003037f, -0.01911169f, 0.35410249f, -0.27102450f, 0.14885974f, 0.15706901f, 0.00361722f, -0.08683109f, 
    0.08248185f, 0.10999081f, 0.12793528f, 0.25949451f, -0.07940125f, -0.27167216f, -0.17693010f, 0.22107857f, 
    0.02067637f, -0.01413069f, 0.14485264f, 0.09485849f, -0.03438649f, 0.18862753f, 0.12057544f, 0.19054891f, 
    0.14226252f, -0.18563832f, -0.19053650f, 0.01371517f, 0.16911691f, 0.07360446f, -0.09353813f, -0.17772603f, 
    -0.01336500f, -0.12883697f, -0.18414076f, 0.15336755f, -0.20125106f, 0.02037170f, -0.33371279f, -0.06776766f, 
    -0.02221152f, 0.12996802f, -0.04878905f, -0.09846468f, 0.00410675f, -0.01665829f, -0.03763216f, -0.07580452f, 
    -0.26005006f, -0.01977874f, 0.25563020f, -0.04875299f, -0.07565195f, 0.07064591f, 0.08373963f, 0.12230852f, 
    -0.07058436f, -0.08686119f, -0.08440314f, 0.02278855f, -0.09061307f, 0.03811185f, -0.14714198f, -0.06660242f, 
    0.13899788f, -0.00831083f, -0.02587746f, -0.06258579f, 0.03024848f, 0.00144639f, -0.08092063f, 0.09764968f, 
    0.26913834f, 0.03293488f, 0.04130467f, 0.05904188f, -0.21261285f, -0.09147645f, -0.09760579f, 0.03900421f, 
    -0.20601572f, 0.01568436f, 0.11746495f, 0.04966481f, 0.01379742f, -0.02416573f, 0.08525051f, -0.25902933f, 
    -0.02742087f, -0.25273666f, -0.11010922f, 0.30022031f, 0.06300808f, 0.15843436f, -0.20627682f, 0.03163911f, 
    -0.52876163f, -0.06910344f, 0.02134393f, -0.29463002f, 0.00781518f, -0.01936827f, -0.08321216f, 0.07548270f, 
    0.05511390f, -0.22377577f, -0.05376048f, 0.06309981f, 0.08274463f, 0.15522861f, -0.08904802f, 0.05081130f, 
    0.10948613f, -0.09908909f, -0.03021469f, -0.20857430f, 0.01058721f, 0.15095790f, -0.10285600f, 0.12169400f, 
    0.67783409f, -0.10692688f, 0.22815274f, 0.00532306f, 0.12342880f, 0.04099460f, 0.11956224f, -0.04624472f, 
    -0.08734912f, 0.09428148f, -0.11435580f, -0.09665103f, 0.06215374f, -0.29753682f, -0.06848099f, -0.08858167f, 
    -0.07083253f, 0.20131394f, -0.01008927f, -0.06212998f, -0.17109075f, -0.04080703f, 0.06744328f, -0.02162458f, 
    0.11584231f, 0.04986271f, 0.19665812f, -0.24814808f, -0.10133023f, 0.02654688f, -0.11449181f, 0.00617930f, 
    -0.04828505f, 0.06048708f, 0.06232503f, -0.06512924f, 0.08996049f, -0.09852903f, -0.03930449f, -0.13710058f, 
    -0.14277260f, 0.08135612f, -0.02289758f, 0.07500152f, -0.02332262f, -0.00685931f, 0.07444386f, 0.07714034f, 
    -0.08032092f, 0.16134171f, 0.05138939f, -0.17386711f, 0.11575739f, -0.05423943f, -0.01273450f, -0.05230048f, 
    -0.07908580f, -0.15129027f, -0.09448086f, 0.12648638f, -0.04573837f, -0.11919028f, 0.10045644f, -0.19415316f, 
    0.02038324f, 0.13534276f, -0.00315697f, -0.04178872f, -0.10778858f, -0.01558727f, -0.01357487f, 0.06931043f, 
    -0.13813053f, -0.11917114f, -0.04634482f, 0.24563846f, 0.10695118f, -0.11719469f, 0.00624404f, 0.16446693f, 
    0.05243582f, -0.10105163f, 0.02030330f, 0.04312643f, 0.34259182f, -0.18174964f, 0.21202543f, 0.21571098f, 
    0.07162347f, 0.02253271f, 0.16724631f, 0.10870124f, 0.19004010f, 0.02037755f, 0.13232827f, -0.08697830f, 
    0.22635163f, -0.09044872f, 0.17214124f, -0.18066193f, -0.03949762f, -0.10347668f, -0.01597372f, -0.07134325f, 
    -0.04651916f, -0.05700369f, 0.21773680f, 0.07861672f, 0.25903836f, -0.09686292f, -0.11767253f, -0.21078631f, 
    -0.00443200f, 0.14066775f, -0.04187677f, 0.11539426f, -0.01419632f, 0.11408600f, -0.08957828f, -0.23393866f, 
    0.05598132f, -0.05659491f, 0.22759876f, -0.26890400f, -0.04085978f, -0.05585008f, -0.03117022f, 0.13584062f, 
    0.01028556f, -0.05932604f, -0.06277994f, 0.11956751f, -0.46669182f, 0.02618074f, -0.32446441f, -0.17862093f, 
    -0.09871380f, 0.03610298f, 0.01474421f, -0.02322039f, 0.00021013f, 0.04971790f, -0.07861257f, -0.16575000f, 
    0.14339696f, 0.19535629f, 0.06774966f, -0.23965135f, -0.16377412f, -0.03304759f, -0.13564479f, -0.04005672f, 
    0.05831340f, -0.11759483f, -0.23197518f, -0.12547150f, 0.14783971f, 0.11884382f, -0.04149831f, -0.42947823f, 
    -0.08409995f, 0.01915536f, -0.04670950f, 0.01028447f, 0.07278190f, -0.10892487f, 0.01901234f, -0.17687136f, 
    -0.34459960f, -0.06975231f, 0.20295155f, 0.10421953f, 0.20045744f, 0.17935266f, 0.06625394f, 0.04237938f, 
    -0.01308197f, 0.07737178f, -0.05659360f, 0.01023575f, -0.64507830f, 0.07130075f, -0.28014898f, 0.26315445f, 
    0.04581987f, -0.01595314f, 0.18144798f, 0.10108713f, 0.15747888f, -0.01004052f, 0.07074267f, 0.04013431f, 
    -0.15309328f, -0.13836324f, 0.03354324f, 0.24605212f, 0.02769793f, 0.04827685f, 0.04972567f, 0.09716874f, 
    -0.03579336f, -0.06751564f, -0.04871507f, 0.03586318f, 0.08060895f, -0.03450943f, -0.29307395f, -0.25707686f, 
    -0.09328976f, -0.14985229f, -0.08098089f, 0.00607763f, -0.03086156f, -0.22306226f, 0.05585323f, 0.00948183f, 
    -0.56478018f, -0.05131077f, 0.07489082f, 0.04632224f, 0.10818536f, 0.00715291f, -0.00100387f, 0.17906807f, 
    0.04284758f, 0.10552788f, -0.04471340f, 0.18048409f, -0.11646897f, -0.25976747f, 0.22122777f, -0.12734808f, 
    0.05961788f, -0.09816009f, 0.06809764f, -0.12404238f, -0.07500993f, 0.01252370f, 0.00127586f, 0.27934793f, 
    -0.08245768f, -0.07217012f, 0.00652543f, 0.26401171f, 0.12749809f, -0.14799602f, -0.10632673f, 0.09826288f, 
    -0.09292420f, 0.09632991f, -0.22880797f, -0.05118851f, -0.09576697f, -0.08945033f, -0.09153591f, -0.28069127f, 
    -0.01233292f, 0.06326699f, -0.05518139f, -0.22167213f, 0.01260419f, -0.06229375f, 0.17048737f, 0.22439614f, 
    -0.39726055f, 0.22570276f, 0.01407156f, -0.16985720f, -0.16464016f, 0.06116122f, 0.11832242f, 0.09688246f, 
    0.06344967f, -0.07882775f, -0.20436481f, -0.07112418f, -0.03448413f, -0.14867368f, 0.03654560f, -0.09271595f, 
    -0.07322312f, 0.13932398f, 0.00492926f, -0.11793282f, 0.20689110f, -0.03104830f, -0.12906450f, -0.15828292f, 
    -0.65099996f, -0.09225576f, -0.06429900f, -0.18695687f, 0.05689432f, -0.14894313f, 0.04534008f, -0.21118733f, 
    -0.06908634f, 0.11083248f, -0.01102096f, -0.08306112f, 0.01527405f, -0.11822630f, -0.39669847f, 0.42630133f, 
    -0.04760133f, 0.12522340f, 0.01847713f, 0.00876923f, -0.10308149f, 0.07081594f, -0.09739723f, -0.10688176f, 
    0.23990050f, 0.03254424f, 0.33008698f, 0.19573021f, 0.13625665f, -0.05795435f, -0.07135332f, -0.15000424f, 
    0.05831279f, -0.11131179f, 0.06979385f, -0.08339013f, -0.15259530f, 0.27300897f, 0.26744720f, -0.22167549f, 
    -0.20780969f, 0.02066668f, -0.00659408f, 0.06283238f, 0.13283682f, 0.15024595f, 0.24819411f, -0.04613517f, 
    -0.03539176f, 0.17454389f, 0.05655825f, -0.35284346f, 0.06468166f, 0.04528623f, 0.05391369f, 0.02463516f, 
    0.00408855f, 0.06447008f, -0.01982166f, -0.12638550f, 0.04730277f, 0.15716211f, 0.03465444f, -0.61909461f, 
    -0.00547831f, 0.13838553f, 0.03709191f, 0.00771009f, -0.07047524f, -0.05524983f, 0.10521633f, -0.00276426f, 
    0.50466514f, 0.11786867f, 0.16881566f, -0.22068365f, 0.03341519f, -0.04489419f, 0.09272466f, -0.04273614f, 
    -0.06050790f, 0.06934546f, 0.02515827f, 0.00607478f, -0.48623836f, 0.09634105f, -0.30515864f, 0.28838518f, 
    -0.00121634f, 0.10956116f, -0.04335346f, 0.22206892f, 0.04008153f, -0.24558927f, 0.21104184f, -0.18070367f, 
    0.53517354f, -0.13045228f, 0.01824613f, -0.03853730f, -0.09604579f, -0.04903057f, -0.00173917f, -0.03651564f, 
    -0.07739304f, 0.05604394f, -0.09425621f, -0.00377465f, 0.24583592f, 0.03110808f, 0.22569413f, 0.16223086f, 
    -0.12951232f, 0.00313424f, 0.09786163f, 0.03964576f, -0.18504797f, 0.07087212f, -0.18516938f, -0.12429036f, 
    -0.34045452f, 0.06314359f, 0.00924210f, 0.02598288f, -0.05718101f, -0.08466724f, 0.02345282f, -0.09058606f, 
    -0.10090672f, -0.08774725f, 0.06350982f, -0.04323116f, 0.10694104f, 0.13210280f, 0.14446354f, 0.17270164f, 
    0.00585163f, -0.07569008f, 0.05243546f, -0.09328567f, -0.11261927f, 0.08726034f, 0.12233606f, 0.06288070f, 
    -0.08838282f, -0.02712806f, 0.02716142f, 0.07123646f, -0.10356386f, 0.00872110f, -0.10211174f, -0.07650670f, 
    -0.04946719f, -0.09292465f, -0.13785644f, -0.07208105f, -0.23470691f, -0.01360070f, -0.05668117f, -0.09322102f, 
    -0.13289198f, 0.08007110f, -0.13515656f, -0.06727631f, -0.02446759f, 0.05022877f, -0.00759850f, -0.06323531f, 
    0.12640920f, -0.28300002f, 0.06621750f, -0.13976863f, 0.11310361f, -0.03076135f, 0.03941538f, -0.06919748f, 
    0.01955346f, -0.06876832f, -0.08778166f, 0.00987740f, 0.23855273f, -0.11264255f, 0.00531277f, 0.02225234f, 
    -0.08705572f, -0.02851826f, -0.01192635f, 0.01203152f, -0.06887500f, 0.05936538f, -0.00302610f, 0.04419731f, 
    0.21554966f, 0.12711324f, 0.18603766f, 0.00045538f, -0.16500792f, 0.03567978f, -0.06896536f, 0.04019000f, 
    -0.01692467f, 0.06946991f, 0.05283733f, 0.08529031f, -0.09382609f, 0.22316229f, 0.21186312f, 0.19212528f, 
    0.06800172f, 0.07865421f, -0.07350472f, -0.03687987f, -0.11352922f, -0.04548427f, 0.09927672f, -0.13655846f, 
    -0.12457138f, 0.05633704f, -0.13524021f, -0.11717620f, -0.07715660f, -0.03770912f, -0.03979157f, -0.09495971f, 
    -0.02721089f, 0.02207281f, -0.02395684f, -0.14236969f, 0.09351879f, 0.18579353f, 0.20197839f, 0.06691029f, 
    0.12443141f, 0.04703533f, 0.02448554f, -0.11158623f, -0.05249653f, 0.00311412f, -0.08654641f, -0.06978751f, 
    -0.18051754f, 0.12727474f, -0.08578831f, -0.02862917f, -0.09169168f, 0.02608798f, 0.06012994f, 0.00254328f, 
    -0.08055330f, -0.06512960f, -0.02845169f, 0.00453791f, 0.04007249f, -0.35617551f, -0.14418249f, 0.11916977f, 
    -0.14147763f, -0.08960987f, -0.01796818f, -0.01325154f, 0.06471755f, -0.00807753f, 0.03675382f, -0.05998659f, 
    0.00663724f, -0.15431824f, -0.20065701f, 0.14649631f, -0.16606647f, -0.06257091f, -0.11717406f, -0.05756659f, 
    -0.05633770f, 0.05710513f, 0.07830856f, -0.07849548f, 0.15684479f, 0.15613131f, -0.18139370f, 0.07694986f, 
    0.00537992f, -0.01326353f, 0.01053868f, 0.01511532f, 0.01050481f, -0.00334195f, -0.01830513f, -0.06290494f, 
    0.19295689f, -0.60019749f, 0.09692653f, -0.21065345f, 0.01119821f, 0.02688184f, -0.04571091f, 0.04300700f, 
    -0.00294238f, 0.04158318f, -0.09574460f, -0.03601386f, -0.05772742f, 0.03895477f, 0.08602992f, 0.05112530f, 
    -0.14012082f, -0.01677027f, -0.13862845f, -0.06455080f, 0.01112425f, -0.00624409f, -0.06635647f, -0.03924081f, 
    -0.14134429f, 0.07063911f, -0.02467492f, -0.05238672f, -0.03942295f, -0.03432197f, 0.01056855f, -0.00524578f, 
    0.00575911f, 0.05546406f, -0.03278006f, -0.01395152f, 0.29324946f, -0.02734957f, 0.23728120f, 0.23274371f, 
    -0.05505408f, -0.02831547f, 0.09718157f, -0.03497966f, 0.12548174f, 0.11969771f, -0.06343200f, -0.05935496f, 
    0.16278064f, -0.58311701f, 0.01816057f, -0.07692812f, -0.04697543f, 0.00900604f, -0.03164477f, -0.06675874f, 
    -0.01998429f, -0.01850692f, -0.04073873f, -0.04274026f, 0.10455743f, 0.21498762f, 0.28110099f, 0.18924332f, 
    0.00505066f, 0.04470791f, 0.07689687f, -0.03452604f, -0.07799494f, 0.03059402f, -0.11360884f, -0.02251834f, 
    -0.23754464f, 0.33315447f, 0.09951087f, -0.10746058f, -0.10450167f, 0.01454778f, -0.00361173f, -0.11076964f, 
    -0.00337014f, 0.01475719f, -0.04828178f, -0.03841703f, 0.29775521f, 0.00686531f, 0.11099166f, 0.11305848f, 
    0.14807206f, 0.05304240f, 0.01209267f, -0.02993692f, 0.07906542f, -0.05613866f, -0.08971731f, -0.14524227f, 
    0.08895490f, 0.28350541f, 0.23167773f, 0.13925238f, 0.19832082f, 0.04129803f, 0.05106434f, -0.11145251f, 
    -0.02034646f, 0.01680464f, -0.06007797f, -0.14988774f, -0.22804381f, 0.35846925f, -0.12477925f, 0.15576474f, 
    0.09309964f, -0.07273918f, -0.04379708f, -0.00246633f, 0.09524717f, -0.06664361f, 0.02584651f, 0.00692304f, 
    -0.01324287f, -0.04626464f, 0.05408925f, 0.16069171f, -0.18009932f, -0.16208105f, 0.07360176f, -0.04167978f, 
    -0.01334610f, 0.03320769f, -0.01154009f, -0.13188349f, -0.47798434f, 0.06733310f, -0.14764194f, -0.22720106f, 
    0.04757461f, 0.11517195f, -0.06577659f, -0.06601605f, -0.23254393f, -0.01812836f, -0.01540860f, -0.04387927f, 
    0.02847761f, -0.37191802f, -0.09301292f, -0.21137211f, 0.10741710f, -0.13095561f, -0.10300467f, -0.04204801f, 
    0.01843142f, 0.05665885f, 0.02154230f, 0.01807205f, 0.00348239f, 0.04836379f, -0.19325665f, -0.39178720f, 
    -0.02567924f, -0.00364522f, -0.00035509f, -0.20800874f, -0.05865340f, -0.06555648f, -0.01537150f, -0.04279610f, 
    0.18609516f, 0.16943543f, 0.10734652f, -0.14534064f, -0.20445740f, -0.02935813f, -0.11757881f, -0.12582944f, 
    -0.08591895f, 0.06281240f, -0.08055805f, -0.02007400f, -0.41888011f, -0.04608005f, 0.02025802f, -0.03977580f, 
    0.07628462f, 0.14582798f, -0.10719825f, -0.07228495f, 0.03682514f, -0.12565035f, -0.01985602f, -0.12805600f, 
    -0.06058989f, -0.26163504f, -0.00406567f, -0.13662550f, 0.20101421f, -0.06501423f, 0.05707844f, -0.08861132f, 
    0.00902890f, -0.00151255f, 0.08172546f, 0.06779210f, -0.17851833f, -0.06190581f, -0.20730293f, -0.39647692f, 
    0.08808415f, 0.03236542f, 0.09382053f, -0.12420890f, 0.13096118f, 0.09716171f, 0.14639926f, -0.01051179f, 
    -0.02347472f, -0.08462052f, 0.03921404f, 0.04904848f, 0.08254556f, 0.02258782f, -0.01590423f, -0.02201683f, 
    0.12716758f, 0.12586175f, 0.23498815f, 0.03791706f, -0.00053100f, -0.37745291f, 0.05976212f, -0.07365887f, 
    -0.06048714f, -0.04598182f, -0.06976029f, -0.27893203f, 0.15931492f, -0.04979009f, -0.00105109f, 0.15874702f, 
    -0.32946584f, 0.16203278f, -0.03611741f, -0.07630400f, -0.17511295f, 0.06237160f, -0.13023613f, -0.12239880f, 
    0.02738628f, 0.03268167f, 0.02356128f, -0.03073184f, 0.12806243f, 0.28608018f, 0.17786390f, 0.06149966f, 
    -0.05804460f, -0.12507309f, -0.03053172f, -0.19416980f, 0.07732593f, 0.06756563f, 0.06031690f, 0.05744390f, 
    0.24445632f, 0.11566237f, -0.17696819f, 0.07872669f, 0.00747066f, -0.02740470f, -0.07546645f, -0.14872739f, 
    -0.10766709f, 0.08573277f, -0.01405863f, 0.04236989f, 0.00754214f, -0.10448184f, -0.02321305f, -0.02819228f, 
    0.12012874f, -0.08247586f, -0.00910943f, -0.39249763f, 0.07303999f, 0.10485990f, -0.21300331f, 0.13253340f, 
    0.02549794f, 0.38797313f, -0.17994992f, 0.02041030f, -0.01577702f, 0.04304134f, -0.10898700f, 0.18384443f, 
    0.05429976f, 0.12672013f, -0.05744696f, 0.00432831f, -0.13588354f, -0.53170383f, 0.23209856f, -0.17626537f, 
    -0.29920796f, -0.21796280f, -0.12811577f, -0.19814675f, -0.08108739f, 0.08053771f, -0.14088798f, 0.26598239f, 
    0.37080857f, 0.20908886f, 0.12920441f, 0.21896683f, 0.05983370f, -0.07211675f, -0.06266646f, -0.05988964f, 
    0.04735510f, -0.06742799f, 0.03803664f, -0.22070165f, -0.24261421f, -0.01102282f, 0.28716770f, -0.21272057f, 
    -0.12386499f, -0.04128104f, -0.09546790f, -0.26263720f, 0.01335673f, -0.02306584f, 0.16524667f, 0.07939858f, 
    0.13468504f, -0.12781155f, -0.21951894f, 0.22224356f, 0.11435826f, -0.06885208f, 0.00607569f, -0.00707225f, 
    0.06097111f, 0.08557532f, 0.06705244f, 0.02370210f, -0.09860393f, -0.27861404f, -0.49104792f, 0.00151219f, 
    0.04000896f, -0.00658897f, -0.04322292f, -0.04664896f, 0.05938271f, 0.14888328f, 0.04251545f, 0.10909295f, 
    0.12890068f, -0.25505835f, -0.09775811f, -0.06299082f, 0.00313104f, 0.01632682f, -0.07132501f, -0.05742021f, 
    0.08263712f, 0.02352362f, 0.06736985f, -0.03753904f, -0.03176485f, 0.30119219f, -0.09849577f, -0.05122980f, 
    -0.17555103f, 0.12806086f, -0.13919464f, 0.06873155f, 0.01885091f, -0.04895981f, -0.20503408f, -0.28127965f, 
    0.08934330f, -0.02248818f, -0.01566591f, 0.17284919f, -0.19177637f, -0.09136824f, 0.04865669f, -0.25701597f, 
    0.16663085f, 0.00723095f, -0.05912973f, 0.08788741f, -0.20917518f, 0.10486843f, -0.25781116f, -0.26233047f, 
    -0.12598981f, 0.07133350f, 0.07432062f, -0.08132683f, 0.02278595f, 0.01100592f, -0.00093650f, -0.03632877f, 
    0.27295750f, 0.10727810f, -0.14110304f, 0.19987763f, -0.23435405f, 0.00954488f, -0.18310848f, -0.23172733f, 
    -0.18190464f, -0.09908061f, -0.02550880f, 0.01266009f, -0.11089329f, -0.27379593f, -0.07975121f, -0.26735845f, 
    -0.11600260f, -0.06674090f, -0.04849996f, 0.14598677f, 0.13284321f, 0.01553225f, -0.15417044f, -0.04656163f, 
    0.11579854f, -0.01326854f, -0.17829737f, 0.00984282f, -0.00509915f, 0.08161927f, 0.06945773f, -0.18791704f, 
    0.08303128f, -0.00470384f, 0.00925617f, 0.15648602f, -0.18521428f, 0.29455900f, 0.13339408f, 0.08075643f, 
    -0.19643196f, 0.03156444f, 0.03460024f, -0.00899295f, -0.00982324f, -0.02216295f, -0.10664319f, -0.14142726f, 
    0.22103651f, -0.24557029f, 0.12168909f, 0.28607547f, 0.11190867f, -0.04338124f, -0.02987140f, -0.02560654f, 
    -0.01392786f, -0.06078184f, 0.16625024f, 0.03535370f, 0.11671703f, -0.21009982f, 0.05835628f, -0.23602405f, 
    0.09697222f, -0.01356553f, 0.14290635f, -0.12325255f, 0.07393471f, 0.06362741f, 0.13327061f, 0.04391432f, 
    -0.29346105f, -0.03339492f, 0.22555821f, 0.00671229f, -0.14152029f, -0.00456384f, -0.26849607f, -0.20163579f, 
    0.10425342f, -0.26716205f, -0.07439905f, 0.16982979f, 0.11062843f, 0.44052178f, -0.26190743f, 0.07734331f, 
    -0.03705849f, -0.05002596f, -0.15202934f, -0.05488422f, -0.08103790f, -0.08918454f, 0.03201870f, 0.17652448f, 
    0.25165564f, -0.29995787f, -0.19604951f, -0.18077509f, -0.00800520f, -0.12091564f, -0.02255074f, -0.03913110f, 
    0.01552454f, -0.00484762f, -0.03828440f, 0.02079689f, -0.20785978f, -0.17377347f, 0.14166792f, 0.17426087f, 
    0.09607223f, 0.03851649f, -0.01182874f, 0.01904319f, -0.04340761f, -0.03935955f, -0.04019664f, -0.01283023f, 
    -0.04103555f, -0.18961017f, -0.24283499f, 0.13734482f, -0.00148922f, -0.07747060f, -0.02855551f, -0.04370871f, 
    0.10347553f, 0.07629256f, 0.07777080f, 0.03509033f, -0.05227280f, -0.31544483f, 0.07086302f, 0.20190118f, 
    -0.00169429f, -0.11465705f, 0.00102246f, 0.00165176f, -0.00233578f, 0.21845160f, -0.22740975f, -0.19690053f, 
    -0.11373316f, 0.22483590f, -0.00705830f, -0.17095141f, 0.04067862f, -0.07795011f, -0.00371621f, 0.07259692f, 
    0.02829405f, -0.17003390f, -0.02927298f, 0.03454129f, 0.18292244f, 0.32175741f, -0.04676771f, 0.05625605f, 
    0.02094683f, 0.11705321f, 0.06498809f, -0.06601487f, 0.07725271f, 0.04222203f, -0.08424250f, 0.01960747f, 
    0.08187041f, 0.09475706f, -0.15081322f, -0.20198801f, 0.11384124f, -0.15643986f, -0.10703294f, 0.00947301f, 
    -0.07967695f, -0.10310411f, -0.03099921f, 0.20474987f, -0.04057891f, 0.13893507f, -0.19500539f, -0.10673734f, 
    -0.00278231f, -0.24155530f, 0.11352351f, 0.02679898f, 0.02043201f, -0.13812132f, -0.00586748f, 0.21810713f, 
    -0.22004466f, -0.06710236f, -0.32325587f, -0.11592008f, -0.01228595f, -0.12381342f, 0.16441326f, 0.02204640f, 
    -0.11660797f, -0.12849836f, -0.12452440f, -0.14568797f, 0.27771869f, 0.05600103f, 0.01464118f, 0.07979020f, 
    0.20215395f, -0.19379637f, -0.17136717f, -0.06812191f, -0.04140871f, -0.04145021f, 0.13441841f, 0.02660839f, 
    -0.12851505f, 0.26842469f, -0.21620342f, 0.01418715f, -0.04193458f, -0.05283273f, 0.10670649f, -0.11959047f, 
    0.22458906f, 0.07741676f, -0.03998967f, 0.01003886f, 0.58811635f, 0.11653751f, -0.19243793f, -0.28029361f, 
    0.12959617f, 0.04550966f, 0.04133362f, 0.15465435f, -0.14200613f, -0.07945746f, 0.21854655f, 0.06662698f, 
    0.34295851f, -0.12149738f, 0.20267606f, 0.10840102f, 0.01744451f, 0.06354351f, 0.10338149f, -0.13917921f, 
    0.04374072f, 0.19198735f, 0.19008729f, -0.10055084f, 0.09342413f, -0.12101438f, -0.15730867f, 0.00402171f, 
    0.06231987f, -0.10466225f, 0.07831396f, 0.00800919f, 0.15607738f, -0.14141746f, 0.10085161f, -0.22854029f, 
    -0.64366251f, -0.08253788f, -0.29000968f, 0.01485549f, -0.02051047f, 0.12605089f, 0.04375549f, -0.02100101f, 
    0.16872825f, 0.06933375f, 0.05025293f, 0.10186883f, 0.03745609f, 0.04409800f, -0.39050058f, 0.51906103f, 
    0.03470564f, 0.04608222f, 0.04508496f, -0.04180184f, 0.17753635f, 0.04584556f, -0.02654697f, -0.15987492f, 
    -0.47842509f, 0.27306175f, -0.25367132f, -0.19969723f, 0.27752826f, -0.06805668f, -0.03029674f, -0.10419898f, 
    -0.11440299f, -0.08839628f, -0.01184465f, -0.00145037f, 0.04455202f, -0.53035545f, -0.11353942f, 0.00326360f, 
    -0.17072716f, -0.10635582f, 0.05954093f, -0.04235738f, -0.02444547f, 0.14471194f, -0.00666747f, -0.13455990f, 
    -0.24444619f, 0.05554115f, -0.34280255f, -0.29669556f, 0.18939167f, -0.03016964f, 0.12912875f, 0.06958224f, 
    -0.08264109f, 0.02813441f, -0.04648957f, -0.19185375f, -0.20224452f, 0.22581102f, -0.05554809f, -0.55747825f, 
    0.15841441f, -0.00795398f, -0.21305639f, 0.14802602f, -0.02406325f, 0.04954954f, -0.12935865f, -0.19912359f, 
    0.03264850f, 0.11130819f, 0.27374941f, -0.08791246f, -0.15305956f, 0.05132814f, -0.09482715f, -0.03229409f, 
    0.02930148f, 0.02515531f, 0.05915218f, 0.06907490f, -0.06358825f, 0.34535220f, 0.14049365f, 0.13810396f, 
    0.02532226f, -0.04128623f, -0.06398056f, 0.24818996f, -0.05924582f, -0.07031392f, -0.00293423f, -0.00688505f, 
    0.65906042f, -0.43752110f, -0.11401726f, 0.17105682f, -0.06929789f, -0.03389410f, -0.04908206f, 0.05671370f, 
    -0.11211512f, 0.00739383f, -0.08197688f, -0.18118766f, -0.26132086f, -0.01216983f, -0.17010045f, 0.17593808f, 
    0.07596488f, 0.15004595f, 0.00183210f, -0.00373780f, -0.19019252f, -0.02365710f, 0.04940694f, -0.11241990f, 
    -0.13801940f, 0.10465641f, -0.15060182f, -0.00913317f, 0.02659407f, 0.00257380f, 0.08075761f, 0.08809969f, 
    0.15017416f, 0.21336459f, 0.18639366f, -0.04577957f, 0.32450449f, 0.24023797f, -0.21303999f, 0.08263805f, 
    0.06555134f, -0.10159205f, 0.01928710f, -0.13722838f, -0.04811000f, 0.12432172f, -0.11415169f, 0.07915918f, 
    0.38019189f, -0.33636758f, -0.01250220f, 0.17090110f, 0.11757531f, 0.15462764f, -0.14755583f, 0.02595831f, 
    -0.10806888f, -0.08809699f, 0.11966489f, 0.01207843f, -0.14878923f, -0.15159841f, 0.02710752f, 0.18802465f, 
    -0.09918424f, -0.01418692f, -0.17736563f, 0.17990921f, 0.04222519f, 0.20947818f, -0.06702682f, 0.00584985f, 
    -0.54624063f, 0.50531864f, -0.23891099f, 0.06695021f, 0.10387698f, -0.07065906f, -0.04551922f, -0.01588568f, 
    -0.05188791f, 0.11166809f, -0.10856299f, -0.06282863f, 0.23040034f, -0.09460715f, 0.00711202f, 0.07699716f, 
    0.09649655f, 0.06856102f, -0.03397356f, 0.01291458f, -0.03858793f, -0.14952879f, -0.30322054f, -0.04785175f, 
    -0.17839931f, -0.58624899f, 0.03331149f, 0.11107782f, 0.00340685f, -0.00741865f, -0.01040769f, 0.05036447f, 
    -0.12028884f, 0.13777581f, -0.03966449f, -0.08535852f, -0.39870045f, 0.02468070f, 0.51344675f, -0.08372400f, 
    0.03262444f, -0.03166604f, 0.05328764f, 0.10788878f, 0.09937052f, -0.05314516f, -0.06346259f, -0.02019442f, 
    -0.49915579f, 0.05629088f, 0.04860276f, 0.36085504f, -0.07294272f, 0.11757102f, 0.01897385f, 0.06995884f, 
    -0.10090372f, 0.10496679f, 0.09448408f, -0.02439469f, -0.18438789f, 0.30401170f, 0.00412269f, -0.41411254f, 
    0.12450472f, 0.14096707f, 0.13196842f, -0.09775971f, -0.07914349f, -0.24603859f, 0.10018724f, -0.11141050f, 
    0.08844097f, -0.23249958f, 0.12582326f, -0.42949539f, 0.11864526f, 0.12062389f, -0.11309317f, -0.18425992f, 
    0.05126538f, -0.09528092f, 0.09849258f, -0.05883094f, -0.17886610f, 0.09585468f, 0.03814871f, -0.05513389f, 
    -0.09875465f, -0.02541123f, -0.07032564f, -0.12511329f, 0.02140842f, -0.01267350f, -0.01586222f, 0.04365827f, 
    -0.53413135f, -0.12618302f, -0.04718022f, 0.13439591f, 0.04249734f, 0.05000192f, -0.05369528f, 0.01377559f, 
    -0.14963262f, 0.05024185f, 0.12305801f, 0.08241764f, 0.18517628f, 0.08273187f, 0.16083844f, 0.14991966f, 
    0.20062666f, 0.12368917f, -0.00299020f, -0.01722851f, -0.00275223f, -0.08214290f, -0.01430301f, 0.01085646f, 
    -0.24165511f, 0.03374831f, 0.00762031f, -0.07972758f, -0.00430078f, -0.04681511f, 0.05244674f, -0.00601528f, 
    0.05787288f, 0.10075430f, 0.11018762f, 0.10927326f, -0.07266600f, -0.25493562f, -0.01783008f, -0.10687306f, 
    0.06701817f, 0.11781807f, -0.18541369f, -0.02342598f, 0.12411641f, -0.00868043f, -0.10587193f, -0.10537178f, 
    -0.90535986f, -0.63728559f, -0.02813722f, -0.26529667f, 0.07915948f, -0.02414908f, -0.10386448f, -0.08191028f, 
    0.13528630f, 0.09958539f, 0.04092263f, 0.06584828f, -0.40280280f, 0.02798394f, -0.02185199f, -0.09516876f, 
    -0.04860772f, -0.11341684f, -0.21917102f, -0.19641270f, -0.09689926f, -0.25849715f, -0.07854942f, -0.23020415f, 
    0.29154626f, 0.07221807f, 0.07137141f, -0.09062187f, 0.14172669f, 0.17166367f, 0.09782707f, 0.12290194f, 
    -0.01077097f, 0.07976934f, 0.21020080f, 0.00382721f, -0.69894487f, -0.21644431f, 0.24586459f, -0.18688296f, 
    0.12389025f, -0.01553390f, 0.06590055f, -0.21062496f, 0.19578674f, 0.20604904f, -0.10389261f, 0.00062012f, 
    -0.37213004f, -0.08530803f, -0.10896818f, -0.07300688f, 0.11138678f, 0.09120183f, -0.30326700f, -0.03275923f, 
    -0.09740821f, -0.37732667f, 0.09972637f, 0.01822791f, 0.07000036f, 0.17447780f, -0.06675471f, -0.11673916f, 
    0.06320152f, -0.08046636f, -0.16788867f, 0.03378005f, 0.01400339f, -0.06453093f, -0.11698348f, 0.19332306f, 
    -0.00351498f, -0.24370660f, -0.03241165f, 0.05320478f, 0.13709098f, 0.03640534f, 0.04981930f, 0.09088781f, 
    0.06544968f, -0.12673956f, -0.14812119f, -0.03079173f, 0.13204136f, 0.02757918f, -0.14912416f, 0.17457943f, 
    0.01036192f, 0.13048033f, 0.03417536f, 0.03857264f, -0.00268456f, -0.04012940f, 0.02007436f, 0.19154160f, 
    -0.10394236f, -0.03810686f, -0.17348650f, -0.24798697f, 0.05642044f, -0.02465036f, -0.02792162f, 0.07362441f, 
    0.02059046f, -0.09036826f, -0.00264533f, -0.10223711f, 0.14104794f, 0.06331059f, 0.04860414f, -0.02389632f, 
    -0.00552248f, 0.23665562f, 0.04131627f, -0.05952641f, -0.07745500f, 0.00104249f, 0.07318301f, 0.21349177f, 
    -0.43421352f, -0.22837144f, -0.13509181f, -0.19210668f, -0.02054725f, -0.03585173f, -0.20053685f, -0.04502688f, 
    0.11850209f, 0.13824320f, 0.07960428f, 0.15999985f, -0.06232324f, 0.22828981f, -0.02026254f, -0.45265350f, 
    0.10127154f, -0.00342394f, 0.03491420f, 0.06346235f, -0.02751283f, 0.11885509f, 0.00744131f, 0.18810563f, 
    -0.81996346f, -0.26826689f, 0.63613498f, -0.03568741f, 0.26179963f, 0.00734832f, 0.10806773f, -0.10220870f, 
    0.01634553f, -0.10794318f, -0.12908188f, 0.02055235f, -0.04695408f, -0.35197523f, 0.15715876f, -0.05817172f, 
    -0.06980319f, 0.13279335f, -0.01903264f, -0.11615764f, -0.03234255f, -0.04647680f, 0.01848037f, -0.25534362f, 
    0.40622944f, -0.11158774f, -0.23133126f, 0.27331665f, -0.02850430f, 0.07308031f, -0.15689634f, 0.07726539f, 
    0.00882469f, 0.16137451f, 0.04654512f, 0.07977320f, 0.30574173f, 0.25356716f, -0.10149360f, -0.04931258f, 
    0.12435178f, 0.01165447f, 0.13463783f, 0.01299669f, 0.00510680f, 0.00824557f, -0.01675068f, -0.03797745f, 
    -0.14308874f, -0.19218338f, -0.34780127f, 0.00961796f, 0.09713154f, 0.00679353f, 0.03204537f, -0.20030572f, 
    -0.08115087f, -0.16875228f, -0.18488772f, -0.04545962f, 0.12833168f, 0.03337470f, 0.06108259f, 0.09271090f, 
    -0.04949475f, 0.04290720f, -0.02680570f, 0.04089243f, 0.00669431f, 0.03651308f, -0.06861611f, -0.13104768f, 
    -0.52093393f, -0.01794602f, 0.05874888f, -0.00115201f, -0.05704540f, 0.08805175f, -0.00285084f, 0.00715845f, 
    0.01489477f, 0.01273263f, 0.10504778f, 0.21789992f, 0.42104778f, -0.03586065f, -0.12788115f, -0.08901128f, 
    -0.17542204f, -0.03933911f, 0.11685119f, -0.02168685f, 0.10819938f, -0.05032379f, 0.04568856f, -0.10504269f, 
    -0.77633750f, -0.50357300f, -0.05849985f, -0.12801978f, 0.04880047f, 0.11153976f, -0.03583658f, 0.13701802f, 
    -0.02336593f, 0.01589488f, 0.09903357f, 0.03539194f, 0.26338848f, 0.07340030f, -0.17125550f, 0.04928088f, 
    -0.10187063f, 0.01098865f, 0.09052895f, 0.04257572f, 0.07172862f, 0.18475263f, 0.10209757f, 0.06229653f, 
    0.15567836f, 0.10607425f, 0.04744034f, -0.09227296f, 0.15509464f, -0.08890194f, 0.22692493f, -0.09947889f, 
    -0.00679667f, -0.04637777f, 0.11724995f, -0.04205205f, -0.07874471f, -0.00205779f, -0.19679011f, -0.08512475f, 
    -0.06730366f, -0.12599117f, 0.02822871f, 0.09363863f, 0.15082766f, -0.00078649f, 0.14987238f, 0.03835094f, 
    0.03355519f, 0.01869016f, 0.08757070f, 0.20285438f, -0.01613213f, -0.04895752f, 0.07736827f, 0.10167952f, 
    0.22043091f, 0.20202518f, -0.25873065f, 0.12731747f, -0.82250202f, -0.58908463f, -0.14996412f, -0.20865758f, 
    0.24681956f, -0.04218446f, 0.00237656f, -0.03396241f, -0.00019221f, -0.02985308f, -0.11613253f, 0.16713166f, 
    -0.10496578f, 0.39799571f, -0.08088049f, -0.01796937f, 0.14614874f, 0.09886715f, 0.01177477f, 0.06563781f, 
    0.02456561f, 0.06646696f, -0.06545012f, 0.12277598f, -0.20808397f, -0.18531553f, -0.08148585f, -0.18416809f, 
    0.02076331f, -0.10310055f, -0.02502394f, -0.06298129f, 0.09490126f, 0.10044440f, -0.05385698f, 0.13638885f, 
    -0.06982724f, -0.24365814f, -0.15987796f, 0.08027243f, -0.01521792f, 0.06100585f, 0.06578089f, 0.11651609f, 
    -0.01415004f, -0.18162768f, -0.02680180f, -0.01004803f, -0.04845989f, -0.10943130f, 0.09651471f, 0.11620952f, 
    0.13089052f, -0.00747316f, 0.09433572f, 0.01168004f, 0.08185012f, 0.10441728f, 0.07911205f, 0.31614718f, 
    -0.36782873f, 0.07686619f, -0.04226448f, -0.01291175f, 0.13942926f, -0.08390038f, -0.10838860f, 0.00123434f, 
    -0.04947375f, -0.00258689f, 0.01524548f, -0.01309894f, -0.50765979f, 0.18103863f, -0.11788745f, 0.07565833f, 
    0.09605634f, -0.00417083f, -0.07017937f, -0.08746230f, 0.07346006f, 0.02282764f, -0.10599289f, 0.05364725f, 
    -0.38925892f, 0.07130422f, -0.07941380f, -0.00833251f, 0.20112926f, -0.13410181f, 0.01223136f, -0.00182319f, 
    0.10972337f, -0.02740259f, -0.16433212f, 0.00732565f, -0.15596704f, -0.30645993f, 0.25895852f, -0.30230817f, 
    -0.26960406f, 0.06987663f, -0.05022055f, -0.02128305f, 0.00584789f, -0.06915801f, 0.10408843f, -0.05464162f, 
    0.17205825f, 0.01374880f, -0.10063528f, 0.27497163f, -0.01466486f, -0.16852023f, 0.05031563f, 0.09682759f, 
    0.06786901f, 0.00719894f, -0.16447037f, 0.05097013f, -0.00446441f, -0.45022011f, 0.05763618f, -0.29625437f, 
    0.20817654f, -0.12224886f, -0.12939365f, 0.12127028f, -0.05546436f, -0.06829733f, -0.01454419f, 0.01265693f, 
    -0.24041452f, 0.11059721f, -0.07835933f, -0.18538566f, -0.21058534f, 0.10167024f, 0.05636617f, 0.03637170f, 
    0.03176123f, 0.10260083f, -0.05112367f, -0.10978577f, -0.43750712f, 0.23815650f, -0.12979417f, -0.02556380f, 
    0.01483231f, 0.14096950f, 0.03860239f, 0.04772424f, -0.10512637f, 0.05469187f, 0.12589984f, 0.02749941f, 
    -0.27114421f, 0.28843704f, -0.06432624f, 0.04678556f, 0.32922739f, -0.03433016f, 0.10785851f, -0.02043263f, 
    0.00555266f, 0.07423106f, -0.01636161f, 0.09316375f, 0.03064307f, -0.05730810f, 0.05493585f, 0.05261530f, 
    0.01932032f, -0.08072121f, 0.02647820f, -0.07247211f, -0.06654948f, -0.11090258f, -0.06917346f, 0.11859994f, 
    -0.22566994f, -0.71318680f, -0.18847470f, -0.52258092f, -0.07943758f, -0.09349218f, 0.02743988f, -0.00522101f, 
    -0.17082228f, -0.00184723f, -0.00821116f, 0.01403340f, 0.23182227f, 0.13283007f, -0.02916913f, -0.09824922f, 
    -0.01910465f, -0.05502869f, -0.07354960f, -0.15899162f, -0.07631501f, -0.00251696f, -0.06631832f, -0.22842644f, 
    0.26613724f, -0.22080122f, -0.15899375f, 0.14126544f, 0.13913566f, -0.00827138f, 0.08807947f, -0.12563527f, 
    -0.14404421f, -0.10317162f, 0.01558345f, -0.03586269f, 0.37073660f, -0.21492638f, -0.36177674f, 0.31678569f, 
    -0.00303481f, -0.11872307f, -0.03577964f, 0.03811923f, 0.07790095f, -0.08266912f, -0.08150110f, -0.07681463f, 
    0.39587453f, 0.22620116f, 0.05921962f, -0.20864309f, 0.03750382f, 0.02043216f, -0.24304660f, 0.06676189f, 
    0.08624801f, 0.13335729f, 0.05366318f, -0.00149970f, -0.33332902f, 0.30366629f, 0.02471052f, 0.01416500f, 
    0.11316752f, 0.04523962f, -0.09496188f, -0.04593353f, -0.05583310f, -0.01271330f, -0.00818262f, 0.07456258f, 
    -0.30307841f, 0.07677622f, 0.21367642f, 0.00372064f, 0.14086989f, -0.14234379f, 0.11003816f, -0.02838750f, 
    -0.02564109f, -0.11527708f, 0.12401458f, 0.03378237f, 0.09882687f, -0.18932611f, -0.18779020f, 0.11613964f, 
    0.08137705f, -0.01599647f, 0.14950755f, -0.00858002f, -0.08769261f, 0.10738789f, -0.08372108f, 0.08031306f, 
    -0.27955636f, -0.21562113f, -0.16491830f, 0.03238412f, -0.03573602f, 0.08368121f, 0.12497725f, 0.16401328f, 
    0.04989624f, 0.04991218f, -0.03320915f, -0.18261744f, -0.50076252f, 0.00526184f, 0.22366093f, 0.10022207f, 
    -0.10960207f, 0.00479340f, 0.03599017f, -0.05858427f, 0.26699239f, -0.14265393f, 0.16224504f, -0.00293804f, 
    0.48735365f, 0.18884118f, -0.12889075f, 0.19354573f, -0.01735964f, -0.06419091f, 0.13645804f, 0.04746493f, 
    -0.19568832f, 0.07409745f, -0.01910888f, -0.01080861f, -0.07978778f, 0.03922705f, -0.07916814f, 0.10646248f, 
    0.10840470f, 0.00087144f, 0.00086523f, -0.05999270f, 0.10107934f, -0.05327224f, 0.12115445f, -0.13377662f, 
    -0.07932251f, -0.00474113f, 0.06495157f, 0.06998021f, 0.09568895f, 0.07834962f, -0.00497601f, -0.06127671f, 
    -0.03190518f, -0.05314299f, -0.08945515f, -0.08360996f, -0.13774458f, 0.25045288f, -0.01277606f, 0.15940695f, 
    -0.04447279f, 0.12307923f, -0.09668199f, 0.04971811f, 0.04528311f, -0.10827801f, 0.03103397f, -0.14863192f, 
    0.12537801f, 0.26752356f, -0.00064431f, -0.29656157f, -0.24903314f, -0.05842935f, 0.17811126f, -0.09395795f, 
    -0.10937577f, 0.14027603f, -0.04404538f, -0.13574205f, 0.15617958f, -0.44424787f, -0.24171026f, 0.12159342f, 
    0.08466269f, 0.12442434f, -0.01217289f, -0.04118209f, 0.10932493f, 0.06166166f, -0.03511028f, -0.03734182f, 
    0.13063070f, -0.14862427f, 0.10113604f, -0.03194682f, 0.02644399f, -0.03677617f, 0.01309433f, -0.01756797f, 
    -0.03355333f, 0.11543132f, 0.01435291f, -0.00510018f, 0.43620041f, 0.01893352f, -0.19672625f, -0.27016479f, 
    0.03691208f, -0.05363588f, -0.02361001f, 0.07084538f, -0.07457694f, 0.06128309f, -0.00132007f, 0.03537669f, 
    0.58662832f, 0.01327761f, -0.19926561f, -0.05617661f, 0.00155611f, -0.13827910f, 0.02134568f, 0.06141972f, 
    -0.01898536f, -0.02467546f, -0.04538329f, 0.01023883f, 0.03025061f, 0.00505104f, -0.09710590f, -0.59317642f, 
    -0.00693802f, -0.07181435f, 0.09141731f, 0.19839306f, 0.03771647f, -0.22879261f, 0.20637070f, 0.19207717f, 
    -0.50008899f, 0.36266959f, -0.19705088f, -0.06440450f, 0.28245717f, -0.08405857f, 0.07373178f, -0.06992474f, 
    0.04319987f, 0.18220921f, 0.08651363f, -0.04750853f, 0.05897600f, -0.08773763f, 0.06694980f, 0.08521049f, 
    0.17833582f, 0.06422609f, 0.05427969f, 0.06414554f, -0.07187652f, -0.09612466f, 0.02514571f, -0.19727316f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12290538f, 0.06686286f, -0.10290627f, -0.03350865f, 0.00221422f, -0.01456881f, 0.02477220f, -0.11149172f, 
    -0.06081282f, 0.02196627f, 0.12958352f, 0.03621313f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
