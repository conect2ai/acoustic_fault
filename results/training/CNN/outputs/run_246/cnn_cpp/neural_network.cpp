#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.11025469f, 0.49559036f, -0.85205030f, -0.08126388f, -0.07730132f, 0.34729597f, -0.45553428f, -0.06487362f, 
    0.00983273f, -0.55265397f, -0.28194347f, -0.18531741f, 0.17739566f, 0.10765252f, -0.55640227f, -0.08767170f, 
    0.34321982f, -0.25955710f, -0.56878108f, -0.46783808f, -0.13268025f, 0.04729044f, 0.26367953f, 0.36814958f, 
    0.09604438f, -0.63117778f, -0.02240421f, 0.19663005f, 0.29574707f, 0.24698007f, -0.69253892f, 0.84757417f, 
    -0.30630514f, -1.10369301f, 0.25517929f, 0.19217810f, 0.33495381f, 0.20366244f, 0.11120515f, -0.10871570f, 
    0.07813653f, -0.13821429f, 0.22625025f, 0.06013130f, -0.11561827f, -0.02982708f, 0.11614545f, -0.26468432f, 
    0.02254645f, -0.04774093f, -0.25591096f, -0.28600177f, -0.43003637f, -0.40713668f, -0.03951637f, 0.00077883f, 
    1.09199440f, 0.74536610f, -0.05632383f, 0.03755607f, -0.11029294f, -0.19832230f, -0.00906514f, -0.30428588f, 
    0.00580938f, -0.09155563f, -0.23181050f, 0.07599494f, 0.12946436f, -0.19557938f, -0.02566754f, -0.04343991f, 
    -0.12516342f, -0.21855004f, 0.18618880f, 1.00887096f, 0.76322484f, -0.46461526f, -0.37794489f, 0.24302098f, 
    0.28959829f, 0.31459618f, -0.40067124f, 0.10233635f, 0.26974306f, 0.25840583f, 0.48344165f, -0.00343822f, 
    -0.05224978f, -0.01914589f, 0.13377093f, 0.03712051f, -0.04153286f, -0.00691425f, 0.34443656f, 0.07766923f, 
    0.01387134f, 0.21488254f, -0.09572875f, 0.13100508f, -0.09903560f, 0.39105624f, -0.41595623f, 0.54270953f, 
    0.49903309f, 0.00521476f, -1.03459585f, -0.77614063f, -0.61799246f, -0.19382326f, 0.09061855f, 0.19316395f, 
    0.28959084f, -0.04035951f, 0.11283203f, 0.16004398f, -0.11971508f, 0.09133729f, 0.00077526f, -0.26261035f, 
    0.00427123f, 0.21503888f, 0.12735006f, -0.04331532f, -0.11508757f, -0.17187877f, 0.19174662f, 0.18000336f, 
    -0.87936145f, -0.84556180f, 0.23355368f, -0.06432477f, -0.46321589f, -0.87440282f, -0.20408450f, 0.05423820f, 
    0.56946915f, -0.02393340f, 0.38657328f, 0.34219721f, 0.06827842f, 0.17481838f, 0.05228906f, 0.15228845f, 
    0.16965312f, 0.12218814f, 0.11707150f, 0.11015939f, 0.22927245f, 0.11971398f, 0.12325718f, 0.49488306f, 
    0.62647074f, 0.10040477f, 0.05036425f, -0.71060556f, -0.78284061f, -0.31505993f, 0.17211345f, 0.27166370f, 
    -0.18140323f, 0.37522870f, -0.39167362f, 0.22323583f, -0.28878248f, 0.00362040f, 0.24620308f, -0.02603995f, 
    0.16471180f, 0.16245130f, -0.27152237f, -0.16049030f, 0.33248982f, -0.37357479f, -0.12561141f, -0.03197226f, 
    0.29691768f, -0.58311385f, -0.61328894f, -0.05081695f, 0.37377235f, -0.48103151f, -0.49347642f, -0.08851992f, 
    -0.10471452f, -0.30370644f, -0.21073553f, 0.03202154f, 0.06547100f, -0.29736242f, -0.05370179f, 0.01188956f, 
    -0.36535060f, 0.20829894f, 0.77224183f, 0.04277415f, -0.06206823f, -0.05619653f, -0.25390720f, -0.36367455f, 
    -0.67362410f, -1.12802589f, -0.26835632f, 0.55924708f, 0.37987745f, 0.37093219f, 0.74824905f, -0.20808704f, 
    0.23749700f, -0.01488458f, -0.03713301f, 0.07224464f, 0.04383830f, 0.26973811f, -0.00912042f, -0.24592435f, 
    -0.00670773f, -0.40343848f, -0.29423422f, 0.13415597f, -0.10422519f, -0.18183650f, -0.28928199f, -0.12482099f, 
    -0.08737324f, -0.03336079f, -0.60105336f, -0.67938793f, -0.37094828f, 0.16240485f, -0.04220179f, 0.06403555f, 
    -0.25243929f, 0.24735311f, 0.34509605f, 0.18331906f, 0.46041667f, 0.50754285f, -0.15709923f, -0.16477565f, 
    -0.32889113f, 0.32997197f, 0.40303493f, 0.16550116f, -0.34510189f, -0.19084114f, -0.41386363f, 0.26684687f, 
    0.00863957f, 0.17830467f, 0.85951406f, -0.40497005f, 0.67195636f, -0.01629486f, -0.15410887f, 0.90866417f, 
    0.31912494f, 0.39236936f, 0.12274960f, 0.11311802f, -0.01870688f, 0.10791606f, -0.20678574f, -0.02503208f, 
    -0.31025961f, -0.25115809f, -0.05269692f, -0.20842303f, -0.27373558f, -0.14392892f, -0.21879703f, 0.07335807f, 
    -0.14855234f, -0.43760836f, -0.28596821f, -0.11220621f, -1.36698604f, 0.50708175f, 0.91504288f, -0.20069492f, 
    -0.27715734f, 0.06715410f, 0.68965995f, -0.22065538f, -0.09852907f, 0.07898259f, -0.35208735f, -0.21800019f, 
    0.06734649f, 0.03945315f, -0.03363623f, 0.22659080f, -0.00552758f, 0.00350943f, -0.14170989f, -0.05185660f, 
    0.20644407f, 0.13495770f, -0.06352352f, -0.02374135f, -0.21067159f, 0.89754623f, 0.07058264f, -0.55395091f, 
    -0.42304334f, -0.58030671f, 0.09022792f, -0.10319808f, -0.35689646f, -0.17360711f, -0.01274960f, 0.09704757f, 
    -0.46545741f, -0.12769200f, -0.30995125f, -0.18694092f, -0.18922728f, 0.14183462f, 0.02422652f, -0.48111680f, 
    0.01949802f, -0.15598242f, 0.20467012f, -0.12255573f, 0.20407547f, -0.83608669f, -0.23185742f, -0.74337107f, 
    -0.02917551f, -0.42434710f, 0.65828520f, 0.26252213f, -0.41437542f, 0.36714682f, -0.10164770f, -0.35326198f, 
    0.08377631f, -0.03894189f, 0.16825882f, 0.23646697f, -0.12966824f, 0.19752295f, 0.12533340f, 0.00557177f, 
    -0.26334161f, 0.04874231f, -0.21033642f, 0.04144627f, -0.19600944f, 0.08120824f, 0.89419281f, 0.87001485f, 
    1.18330753f, 0.52095467f, 0.44519114f, 0.18158218f, -0.27099606f, -0.11967287f, 0.05342001f, -0.10794426f, 
    0.18824616f, 0.25825223f, -0.07343502f, -0.02341403f, 0.12423265f, 0.10948797f, 0.17364328f, -0.03746809f, 
    0.02087520f, -0.04945704f, 0.19717728f, 0.14520960f, 0.14897092f, 0.12035441f, 0.31473711f, -1.00780475f, 
    -0.07323256f, -0.51179481f, -0.48999333f, -0.61221313f, 0.29806972f, 0.55877841f, -0.00323746f, 0.52118742f, 
    0.52615261f, 0.25068051f, -0.26160139f, 0.23444097f, -0.09017968f, 0.16557303f, 0.26146027f, -0.12764344f, 
    0.08682700f, 0.18679966f, 0.05344646f, 0.17430493f, 0.06133014f, 0.08178139f, 0.22522275f, 0.07746915f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12522119f, 0.07735044f, 0.08368532f, 0.47362405f, 0.32289326f, 0.22143100f, 0.27920932f, -0.07820273f, 
    0.05705258f, 0.26979452f, 0.15886593f, 0.02088169f, 0.06709272f, -0.05734083f, 0.38248223f, 0.17188530f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.43147293f, -0.13010314f, 0.06752957f, 0.11310618f, 0.21559063f, 0.03867315f, 0.03675222f, 0.29607558f, 
    0.05785075f, -0.21154463f, 0.10291887f, 0.02333434f, 0.80393219f, 0.18936126f, -0.36973047f, -0.41863841f, 
    -0.08113791f, 0.10875559f, -0.08992312f, 0.26233771f, -0.02670422f, 0.05300848f, 0.05570543f, 0.03276152f, 
    0.44793105f, 0.10129129f, 0.00070390f, 0.30772576f, 0.21923777f, 0.09686610f, 0.00392146f, 0.28954437f, 
    -0.07289536f, 0.15776758f, 0.00882727f, -0.04858503f, 0.23215567f, 0.18438309f, 0.18918939f, 0.07772637f, 
    0.20178719f, 0.07130192f, 0.09793030f, -0.18852226f, -0.05650921f, -0.03331227f, 0.08039565f, 0.12303776f, 
    -0.01552664f, -0.11956010f, -0.13328193f, -0.22141504f, 0.11133751f, 0.09499626f, 0.13930920f, -0.05001243f, 
    0.03337764f, 0.20747387f, 0.32490534f, 0.02529860f, -0.24538803f, -0.05026080f, 0.09355835f, -0.14643952f, 
    0.10085820f, -0.12415461f, -0.13072698f, 0.23354238f, -0.00966117f, 0.12616253f, -0.02538244f, 0.04579574f, 
    0.19664197f, -0.10859192f, 0.28065470f, -0.16492133f, 0.10141218f, 0.06410412f, -0.09427660f, 0.04173848f, 
    0.07737605f, -0.00227992f, 0.01329053f, 0.05981385f, -0.24898846f, -0.14912319f, 0.41036585f, 0.01220112f, 
    0.15483777f, 0.02686908f, -0.11306509f, 0.19742042f, -0.08427201f, 0.25269079f, -0.10466801f, 0.03977477f, 
    0.45590088f, 0.15380441f, 0.02318718f, -0.07921813f, 0.26993492f, -0.00398083f, -0.01630818f, 0.05176066f, 
    -0.05424946f, 0.13998440f, -0.06274043f, 0.08402455f, 0.32061926f, -0.18742229f, 0.10372673f, 0.20720030f, 
    0.23854937f, 0.01561464f, 0.09746593f, 0.32926267f, -0.04395869f, -0.21657668f, 0.12582536f, 0.01491468f, 
    0.37307179f, 0.00037488f, 0.06167935f, -0.08770909f, 0.11132545f, 0.19421880f, 0.07533485f, -0.06653094f, 
    -0.00881757f, 0.09790082f, 0.17118263f, 0.03680180f, 0.07874120f, 0.41229585f, -0.23444511f, 0.17171632f, 
    0.08090117f, -0.06201714f, -0.06693919f, 0.20260157f, 0.12150166f, 0.09419252f, 0.24897383f, 0.10723396f, 
    0.36552840f, -0.28189132f, -0.01333049f, 0.09975956f, -0.14608908f, 0.09682860f, -0.13799910f, 0.16455014f, 
    -0.10213999f, 0.16392545f, 0.13351232f, 0.29528093f, -0.44668514f, -0.03063064f, -0.20969878f, 0.21136026f, 
    0.24325657f, -0.06897603f, 0.12710187f, -0.11112190f, 0.03884230f, 0.00947112f, 0.15783024f, -0.05025237f, 
    0.03148068f, -0.08354272f, 0.07068741f, -0.15436414f, 0.20185274f, 0.30125609f, 0.04467084f, -0.12608323f, 
    -0.09887113f, -0.05489416f, 0.01578246f, -0.00589412f, -0.21962065f, -0.31059298f, 0.01892469f, 0.07016045f, 
    0.12500212f, -0.18441440f, 0.11287999f, 0.12943913f, 0.08987501f, 0.07371277f, 0.06211911f, 0.14530076f, 
    -0.01043516f, 0.01714732f, 0.05261662f, -0.04041952f, -0.04547811f, -0.04608773f, -0.07862599f, -0.05295197f, 
    -0.02517623f, 0.01524686f, -0.00631766f, 0.03545169f, 0.06016307f, 0.05591466f, 0.05400249f, -0.00527111f, 
    0.04579182f, 0.05113242f, 0.00091462f, -0.06432470f, -0.04881232f, 0.03404460f, -0.00394819f, -0.05520402f, 
    0.02926374f, -0.06266181f, -0.05685465f, 0.03888450f, -0.06562848f, -0.02510837f, 0.04209180f, -0.04165734f, 
    0.03944943f, -0.06609374f, 0.02773559f, 0.01482024f, 0.02468707f, -0.04483122f, 0.02761587f, 0.01950699f, 
    -0.06591897f, 0.02005925f, -0.08274568f, -0.01129770f, -0.02760340f, -0.07332358f, -0.05143143f, 0.02437316f, 
    -0.07066205f, -0.06916617f, 0.00832233f, -0.00407273f, -0.06677341f, 0.00245667f, 0.00124646f, -0.06203005f, 
    0.04999160f, 0.02345927f, 0.04531520f, 0.05379298f, -0.02657730f, -0.07971496f, -0.01172253f, -0.03516617f, 
    0.01928117f, 0.05033828f, -0.00436849f, 0.03976318f, -0.03036580f, -0.05434662f, 0.02756917f, -0.00023207f, 
    0.05627235f, -0.08285970f, -0.01996841f, -0.03753494f, -0.03188761f, 0.02804069f, -0.00999580f, 0.05157436f, 
    -0.04968427f, -0.05400283f, 0.02631115f, 0.04771316f, -0.00460011f, 0.03928456f, -0.00080820f, -0.01044471f, 
    -0.03601877f, 0.01990191f, -0.06778613f, 0.04769223f, -0.01762290f, 0.05486450f, 0.03231503f, -0.08139323f, 
    0.05418529f, -0.06873617f, -0.00682627f, 0.00218397f, -0.03663877f, -0.04354980f, 0.04048384f, 0.03710774f, 
    0.00931659f, 0.03302392f, -0.03194605f, -0.02760936f, 0.03740529f, -0.02948042f, -0.05182567f, 0.00062809f, 
    -0.06576945f, -0.02131006f, 0.01429142f, -0.01943673f, 0.04791377f, 0.00253103f, -0.05878216f, -0.06658588f, 
    -0.07245246f, 0.00638802f, 0.00736779f, -0.06530038f, -0.06786694f, -0.07585893f, 0.06215174f, -0.04944213f, 
    -0.05662176f, 0.01109364f, -0.04532498f, 0.03910991f, -0.06757011f, -0.06191592f, -0.06063457f, -0.06137981f, 
    -0.04046579f, 0.01950632f, -0.01810994f, 0.04717746f, 0.06186205f, -0.00615697f, 0.04059661f, -0.05313940f, 
    -0.02882787f, 0.04261250f, -0.04427045f, 0.03581752f, -0.00025739f, 0.06078877f, -0.01026530f, -0.03867960f, 
    0.04349365f, 0.00959464f, 0.03278049f, -0.02660381f, -0.04767850f, -0.00980112f, -0.00379499f, -0.01064117f, 
    0.02876055f, -0.03309141f, -0.01345798f, -0.02150147f, 0.05148743f, -0.07210893f, 0.00345397f, 0.04271821f, 
    -0.04342410f, 0.02185279f, 0.00070355f, -0.02383392f, -0.01073595f, -0.00496645f, -0.07529783f, -0.00129840f, 
    0.00965200f, -0.03943991f, 0.05250255f, -0.05331390f, 0.02465010f, -0.02593156f, -0.07469613f, 0.01803404f, 
    0.04039250f, 0.01905418f, -0.06998397f, -0.06479600f, 0.01200304f, -0.08182345f, -0.04460555f, -0.00744533f, 
    -0.05990413f, -0.05954667f, -0.00215511f, 0.01838654f, 0.04867182f, -0.02136822f, -0.00418018f, -0.02116363f, 
    -0.03381516f, 0.01962072f, -0.05313499f, -0.05041626f, 0.02475137f, -0.03460914f, 0.00701613f, -0.00085835f, 
    -0.02052914f, -0.07912070f, -0.04502270f, 0.00032850f, 0.03881047f, 0.04705534f, -0.07459461f, -0.00780027f, 
    -0.01843314f, 0.00011610f, 0.04569211f, -0.03183902f, 0.04006223f, 0.01127306f, -0.03231294f, -0.04924902f, 
    0.03565683f, -0.05916652f, -0.02448933f, -0.05623336f, 0.02330193f, 0.02492266f, 0.00674780f, -0.04044171f, 
    -0.04359714f, 0.01855951f, 0.01011067f, -0.06398536f, 0.02026552f, 0.03848484f, -0.00704620f, -0.03751747f, 
    -0.00924634f, -0.00175817f, -0.02302508f, 0.04911837f, -0.02874750f, -0.04185693f, -0.06482393f, 0.02158351f, 
    -0.01274448f, 0.02544255f, -0.02349909f, 0.05962163f, -0.06116936f, 0.04637406f, 0.05219264f, 0.00206664f, 
    -0.03796941f, -0.08001634f, 0.00131292f, -0.04587372f, -0.04963897f, -0.01594784f, -0.04535740f, -0.05556776f, 
    -0.01361299f, -0.03994226f, 0.05594162f, -0.01988128f, -0.07598837f, -0.03605010f, -0.06421948f, 0.01339961f, 
    0.00233589f, -0.07672554f, -0.07737061f, -0.01304699f, -0.06154564f, 0.03264982f, 0.00669788f, 0.03768352f, 
    0.03769392f, -0.05952762f, -0.01049956f, -0.05055809f, 0.05233211f, -0.04164810f, 0.02468318f, -0.00278038f, 
    -0.00287107f, 0.03455364f, 0.05050691f, -0.07517475f, 0.01832114f, 0.02397929f, -0.01561317f, -0.01234588f, 
    -0.00885592f, -0.02122771f, -0.05222639f, 0.00300289f, -0.06711066f, 0.01205137f, 0.02887078f, -0.07728527f, 
    0.00154982f, -0.03605705f, 0.05056934f, 0.02214159f, -0.06860332f, -0.00867458f, 0.04641529f, -0.00090897f, 
    -0.00008164f, 0.04795102f, -0.02807828f, -0.00901506f, 0.00712166f, -0.06621715f, -0.03967459f, -0.04081756f, 
    0.02390530f, -0.00291432f, 0.03116767f, -0.06269520f, -0.00901333f, 0.04205396f, -0.01567917f, 0.00092327f, 
    0.04742442f, 0.05732869f, -0.00834598f, -0.01905725f, 0.01860632f, -0.06438772f, 0.00132065f, -0.00884909f, 
    -0.02038319f, -0.05224910f, -0.06507666f, 0.05333846f, 0.00046834f, -0.01512390f, 0.06060987f, 0.03133965f, 
    -0.01724778f, -0.02965529f, -0.04506283f, 0.05570586f, -0.04122438f, -0.00245418f, -0.05783604f, 0.03865748f, 
    0.03199912f, -0.02150137f, 0.04503146f, 0.00588800f, -0.04420725f, -0.00153165f, 0.01119353f, 0.02754150f, 
    0.05259613f, -0.07963084f, 0.02876814f, -0.07192049f, -0.00045788f, 0.02099382f, -0.04881538f, -0.06346837f, 
    -0.05896084f, 0.03854918f, -0.07167385f, -0.03856066f, 0.02521577f, -0.04970339f, -0.08136699f, -0.01648016f, 
    -0.00903498f, -0.03601065f, 0.05885204f, -0.07790117f, 0.02823550f, 0.04063741f, -0.04168239f, 0.02140664f, 
    0.03620449f, 0.00617841f, 0.00729957f, 0.02485544f, 0.04668073f, 0.00634847f, 0.04578890f, -0.03737683f, 
    -0.00232563f, -0.02539430f, -0.05806273f, -0.04770664f, 0.04643505f, 0.02188014f, 0.01723475f, -0.06222742f, 
    -0.02019983f, -0.01878112f, -0.03379459f, -0.03992018f, -0.07840372f, 0.02775606f, -0.04510846f, -0.04959016f, 
    -0.07791045f, -0.02773635f, -0.02145400f, 0.04824063f, 0.00373364f, 0.03770071f, 0.00157718f, -0.06783724f, 
    0.06408406f, -0.04502264f, -0.02376829f, 0.02549171f, -0.07866415f, 0.05748630f, 0.01563267f, 0.05772485f, 
    0.03835702f, -0.00184665f, 0.02587222f, -0.02096977f, -0.02208141f, 0.00267204f, -0.05616701f, -0.02058572f, 
    0.00928169f, -0.07817989f, 0.02830923f, -0.02270150f, 0.05213016f, 0.04570946f, 0.02502421f, -0.02522447f, 
    -0.07382546f, 0.04308041f, 0.00317449f, 0.02069027f, -0.00813127f, -0.07538864f, -0.01873002f, -0.01644338f, 
    -0.02018516f, 0.00382752f, -0.03106281f, 0.01059944f, 0.00146816f, 0.02081938f, 0.03904426f, -0.05979958f, 
    -0.04981710f, -0.03548401f, 0.04790580f, -0.00797078f, 0.05468030f, 0.00227131f, 0.00667728f, -0.06399454f, 
    0.02489175f, -0.04897860f, -0.02230607f, -0.07577690f, 0.00074674f, 0.00193841f, 0.04980202f, -0.01108776f, 
    -0.06338607f, 0.05223336f, 0.00413265f, 0.04212905f, 0.01245732f, 0.05879352f, -0.07133438f, -0.02348199f, 
    -0.03442162f, -0.05436785f, -0.05766944f, -0.07178919f, -0.07589589f, -0.07706694f, 0.04294815f, 0.05097216f, 
    -0.03671340f, 0.00986171f, -0.08141355f, -0.02290064f, -0.02738600f, 0.00117056f, 0.00306751f, 0.05655784f, 
    -0.06087110f, -0.04100797f, 0.03556112f, 0.01379819f, 0.03803614f, -0.06016816f, -0.01830026f, -0.04944357f, 
    0.02054556f, -0.07026801f, 0.04236601f, -0.00651198f, 0.00892510f, 0.01140659f, -0.04522500f, 0.00286266f, 
    0.02506885f, -0.04271389f, 0.01116509f, -0.03214582f, -0.06474672f, -0.04907270f, -0.05275289f, 0.00441513f, 
    -0.01332664f, -0.04537803f, 0.00017093f, -0.00040738f, 0.05460677f, 0.03218479f, -0.00303905f, -0.04578975f, 
    0.05722984f, -0.03669853f, -0.04129385f, -0.07342234f, 0.04894562f, -0.03136767f, -0.00949921f, 0.00607365f, 
    -0.05093971f, -0.00718238f, 0.00177879f, -0.06409854f, -0.06933353f, 0.00328140f, 0.03435320f, -0.05297769f, 
    -0.06485429f, 0.03435443f, -0.05350172f, 0.01222211f, 0.03994288f, -0.06488924f, -0.04914925f, 0.02558097f, 
    0.00009469f, 0.02478272f, -0.00214831f, 0.01525388f, 0.02666469f, -0.01671439f, 0.01586519f, 0.02506185f, 
    0.05544926f, 0.03994036f, 0.02959823f, -0.01313120f, 0.00009348f, 0.01398918f, 0.03019889f, 0.03186192f, 
    0.04554418f, 0.04199263f, -0.07727696f, -0.04762090f, -0.04299174f, 0.05257396f, -0.02559234f, -0.03343568f, 
    0.01754926f, -0.01722310f, -0.02407733f, -0.00207056f, 0.03040156f, -0.05019050f, 0.05290472f, -0.00151305f, 
    0.00782992f, -0.04983127f, 0.00447541f, 0.01555195f, 0.05516892f, -0.01932033f, -0.06381212f, -0.01443945f, 
    -0.03247321f, 0.01139410f, 0.05200988f, -0.00118653f, -0.01290875f, -0.00086279f, 0.01458036f, -0.05877797f, 
    -0.06979926f, -0.02166643f, -0.00150669f, -0.06344218f, -0.08417018f, 0.05437493f, -0.03724268f, -0.06572688f, 
    -0.02040434f, 0.01758687f, -0.05507951f, -0.05041997f, 0.03908822f, 0.03722026f, 0.00102681f, -0.00650917f, 
    -0.00057030f, -0.05486543f, -0.07413451f, -0.02609853f, -0.01999740f, 0.01219715f, -0.00806240f, 0.03956869f, 
    -0.02657243f, 0.01107069f, -0.05686554f, -0.02034157f, -0.05112025f, -0.07879391f, 0.03759192f, -0.01954790f, 
    0.01612948f, -0.06592757f, -0.00370567f, -0.07334237f, -0.04240042f, 0.02501460f, 0.05688418f, -0.05195159f, 
    -0.01933172f, 0.03784413f, -0.00466737f, -0.02851750f, -0.07269965f, -0.04921929f, 0.02171429f, -0.03761654f, 
    -0.07385231f, -0.04198483f, 0.04186333f, -0.06287186f, 0.04652641f, -0.02748824f, -0.04799778f, 0.05468682f, 
    -0.05895789f, -0.04664701f, 0.02670998f, -0.03791252f, 0.03982493f, -0.06803992f, -0.00628539f, 0.02189557f, 
    0.00323666f, -0.00341354f, 0.03387460f, -0.00378829f, -0.03450891f, -0.06261939f, 0.01355354f, -0.02594906f, 
    0.04341301f, 0.02226812f, 0.04506706f, 0.01385651f, 0.01044331f, 0.05842571f, -0.07997034f, -0.00437856f, 
    0.00903785f, -0.01515148f, 0.04418151f, -0.07966422f, -0.02191995f, -0.01818384f, -0.01355127f, -0.03954190f, 
    0.00005964f, -0.05322383f, 0.03975646f, -0.01506437f, -0.04515886f, -0.07016125f, -0.04472813f, -0.06396788f, 
    0.03339964f, 0.00588250f, -0.00347588f, -0.02487905f, -0.03899797f, -0.05878674f, -0.02800678f, -0.04751436f, 
    -0.03133486f, -0.02750319f, 0.00233173f, 0.01847291f, -0.05126820f, 0.04315642f, -0.00342164f, -0.06049862f, 
    -0.00332337f, -0.02634507f, -0.04522130f, 0.01220505f, 0.00536089f, -0.00405808f, -0.08140706f, 0.00882978f, 
    -0.02300365f, -0.07152188f, -0.03312412f, -0.00168390f, 0.04880106f, 0.00692795f, -0.06548992f, 0.02061152f, 
    -0.02351097f, -0.04250659f, -0.01429355f, 0.01476188f, -0.05609849f, 0.03071889f, -0.02954612f, 0.04853543f, 
    0.03441619f, -0.07157983f, -0.01083227f, -0.04775104f, -0.04626488f, -0.03051509f, -0.00822297f, -0.08661437f, 
    -0.02601127f, 0.05183633f, 0.02984453f, -0.03768904f, 0.04251122f, -0.04445964f, 0.00269008f, 0.00719726f, 
    0.00100572f, -0.06475278f, -0.07933708f, 0.02076738f, 0.02841828f, -0.02040687f, -0.02986142f, -0.04783397f, 
    0.02936071f, -0.06398612f, 0.02636069f, 0.05808294f, -0.08203875f, -0.01297698f, -0.04279681f, -0.02580127f, 
    0.14663269f, 0.25182506f, 0.03838461f, 0.38735265f, -0.19042940f, 0.11082204f, -0.03096214f, -0.09379936f, 
    0.11872075f, -0.03786810f, -0.08497882f, 0.12655018f, -0.17369437f, -0.17792904f, 0.16664679f, 0.03479240f, 
    0.12733059f, -0.06086816f, 0.07000061f, -0.04168640f, -0.07672215f, -0.05930362f, 0.11384736f, 0.06443767f, 
    -0.06868065f, -0.02630171f, -0.22155838f, -0.00798286f, 0.00935124f, -0.02802705f, 0.13507496f, -0.00864505f, 
    0.06502427f, 0.09446724f, -0.00235755f, -0.03772212f, -0.05722753f, 0.14025213f, -0.19884479f, 0.23228700f, 
    0.11911751f, -0.00265616f, -0.12734623f, 0.00970440f, 0.03633742f, 0.01285124f, -0.05753066f, -0.08914141f, 
    0.12536734f, 0.05642414f, -0.02347403f, 0.17220335f, -0.16157277f, 0.01734667f, 0.01095247f, 0.08446498f, 
    -0.07283235f, 0.03507956f, 0.07695188f, 0.14384750f, 0.55961984f, 0.01753652f, -0.07241324f, 0.25975326f, 
    -0.04727019f, -0.11932582f, -0.11909737f, -0.08574883f, 0.04172380f, -0.00197599f, 0.00549701f, 0.04885362f, 
    0.05765009f, 0.16161166f, -0.06571569f, 0.05969381f, 0.06732376f, -0.03955545f, -0.02907916f, 0.17087761f, 
    -0.00339570f, 0.03292635f, -0.05320903f, 0.09422044f, 0.21631424f, 0.28754765f, -0.14384478f, 0.26342538f, 
    -0.02261575f, -0.12688924f, 0.08132214f, -0.12038726f, 0.00520632f, 0.02599153f, 0.00458331f, 0.00134787f, 
    -0.13009544f, 0.02173995f, 0.04719643f, -0.23846281f, 0.07117880f, 0.02797822f, 0.06741174f, -0.12166252f, 
    0.03490797f, 0.03573876f, 0.16077495f, -0.05903512f, -0.16427001f, 0.23996820f, -0.03723586f, -0.11526407f, 
    -0.09718587f, 0.11821067f, 0.13301027f, -0.17781262f, 0.23753794f, -0.00571215f, 0.03791264f, 0.07903910f, 
    -0.02751318f, 0.11558027f, -0.06219016f, 0.18385947f, -0.10227311f, -0.05290924f, -0.10574749f, -0.13890927f, 
    0.16523345f, -0.01728626f, 0.00058049f, -0.02952886f, -0.00861239f, -0.01529968f, 0.24947001f, -0.28516647f, 
    0.17513736f, -0.20846583f, 0.04099624f, 0.06002764f, -0.06491624f, 0.05484002f, -0.10273667f, 0.01435965f, 
    0.02072022f, 0.06153722f, 0.09305660f, 0.45662719f, 0.14126928f, -0.02303066f, -0.13116530f, 0.13751929f, 
    0.17180842f, 0.07254337f, -0.12327627f, -0.01389748f, -0.21959564f, -0.09790285f, 0.30529746f, -0.31582004f, 
    -0.07029516f, 0.20948046f, 0.05065026f, -0.12147868f, -0.05323063f, -0.04910558f, 0.04817037f, -0.12364542f, 
    0.10403093f, -0.05372298f, 0.02680876f, 0.10699961f, 0.09258246f, 0.02731730f, 0.07861034f, 0.00158505f, 
    0.03239965f, 0.13714322f, -0.01763103f, 0.08287329f, -0.46187291f, -0.01978678f, 0.08972454f, -0.00638257f, 
    -0.02531118f, 0.02254206f, 0.08706792f, -0.15108049f, 0.04475316f, -0.01093621f, -0.00205410f, -0.07729635f, 
    0.04327565f, -0.18758497f, 0.13307118f, -0.12929632f, -0.28875136f, 0.21568385f, 0.11423535f, -0.00573047f, 
    -0.01182647f, 0.08141073f, -0.03871593f, -0.04885546f, -0.60553634f, -0.09607127f, 0.19198881f, 0.01960344f, 
    0.01734593f, -0.11247618f, -0.01993356f, -0.11713750f, -0.01335383f, 0.11049588f, -0.07238363f, 0.08337603f, 
    -0.51664239f, 0.39646316f, 0.04011467f, -0.02645035f, -0.00018975f, 0.05308365f, 0.04173263f, -0.20917401f, 
    0.13960379f, 0.01165428f, 0.13429239f, -0.02713980f, -0.20088629f, -0.13834850f, 0.14653239f, -0.32425326f, 
    0.01793083f, 0.12851135f, -0.08654191f, 0.09400458f, 0.21879062f, -0.04907390f, -0.01613484f, 0.04885371f, 
    0.05620294f, 0.28147545f, 0.46381345f, 0.21314402f, -0.12242307f, 0.01830288f, -0.06729063f, -0.02230113f, 
    -0.08206671f, -0.04533517f, -0.11931480f, 0.21256311f, -0.58944666f, -0.06087345f, 0.44935989f, -0.01089147f, 
    0.03735489f, 0.13404663f, 0.12530485f, -0.07982975f, -0.11574464f, 0.03327874f, 0.02494595f, 0.10815322f, 
    0.08814271f, -0.25839350f, 0.26240510f, -0.04521705f, -0.05872716f, -0.06595803f, -0.05295513f, 0.13983586f, 
    0.10182142f, 0.03654433f, -0.08426183f, 0.02141781f, 0.00642117f, -0.15059371f, 0.00523408f, -0.03390498f, 
    0.03897978f, -0.08531751f, 0.09072396f, -0.00905636f, 0.15183769f, -0.04033125f, 0.09597077f, -0.01796906f, 
    -0.99190146f, 0.23470849f, -0.34783474f, 0.09035268f, -0.00966607f, 0.00885951f, -0.02670236f, 0.10164187f, 
    0.02195070f, -0.00166549f, 0.03826422f, 0.01680584f, -0.20590442f, 0.06831228f, 0.01449184f, 0.07976407f, 
    0.30339116f, 0.16263621f, 0.18267338f, -0.04814247f, 0.13834105f, 0.07483652f, -0.09535053f, -0.06104938f, 
    0.07919332f, 0.23220871f, 0.09901276f, -0.02268210f, 0.13779436f, 0.00937340f, 0.18799621f, 0.01356141f, 
    0.07712496f, 0.09600814f, -0.13818294f, 0.12752584f, -0.26252684f, 0.38757515f, -0.23149431f, 0.04776561f, 
    0.04395743f, 0.13965952f, -0.00483645f, 0.02506266f, -0.06874174f, -0.02937217f, -0.10622907f, 0.11708815f, 
    -0.01490117f, -0.10164142f, 0.21759742f, -0.08544549f, -0.03315022f, 0.07304262f, 0.09267332f, 0.00157205f, 
    -0.10875548f, -0.18329394f, -0.09638786f, -0.10786301f, -0.15751386f, -0.16377771f, -0.09123458f, 0.12410289f, 
    -0.03837646f, 0.02182650f, -0.00973898f, -0.04254900f, 0.24561214f, -0.02128764f, -0.02395781f, 0.14263061f, 
    0.04815385f, 0.12269305f, 0.22879365f, 0.09129529f, -0.00659783f, -0.05480728f, -0.02443612f, 0.12256557f, 
    -0.07239082f, 0.07718696f, 0.07380614f, 0.07659711f, 0.34606066f, -0.02998329f, -0.03334308f, -0.06906021f, 
    0.07139581f, -0.01252456f, 0.06453018f, -0.05780625f, 0.08832596f, -0.11986344f, 0.05951517f, -0.05349882f, 
    0.00434113f, 0.13068670f, 0.28125528f, 0.17703000f, 0.04627391f, 0.04046856f, -0.05853546f, -0.01645820f, 
    -0.13940200f, 0.12158281f, 0.24507581f, 0.09064752f, 0.28178740f, -0.30949828f, -0.05700421f, -0.10961763f, 
    0.20603862f, -0.00947753f, 0.00211432f, 0.04508388f, 0.08071789f, -0.02965229f, 0.01108962f, 0.10788383f, 
    -0.15673001f, 0.22381644f, -0.05026427f, 0.17791319f, 0.16967459f, 0.09758772f, -0.00230735f, 0.07682917f, 
    0.03079200f, 0.07028283f, 0.10353599f, 0.12976256f, -0.12433472f, 0.39234221f, 0.19795120f, -0.01350522f, 
    0.10316534f, 0.05452264f, -0.19672272f, -0.10484030f, -0.02370819f, -0.04432823f, -0.07056624f, -0.11090255f, 
    -0.36020464f, 0.06970257f, 0.05186597f, -0.18428315f, -0.12215914f, 0.07120121f, 0.05098180f, 0.01589833f, 
    -0.03811020f, 0.00184960f, -0.13291456f, -0.05115908f, -0.09772194f, -0.14029269f, 0.33421269f, -0.24579503f, 
    0.01297322f, 0.08853275f, -0.09340469f, 0.02434296f, -0.01738917f, -0.23869139f, -0.15468168f, -0.12117218f, 
    0.19632311f, -0.28828335f, 0.39549097f, -0.12075906f, -0.08907354f, 0.20791109f, -0.31817088f, 0.23096158f, 
    0.14438005f, -0.03337296f, -0.14780748f, -0.17179154f, -0.12742852f, 0.13404806f, 0.16943610f, 0.07079292f, 
    -0.00160959f, 0.02313063f, -0.06536416f, 0.07230694f, -0.06768455f, 0.13160282f, -0.05654871f, 0.13901453f, 
    -0.59001726f, 0.20252880f, 0.22377482f, -0.15266666f, 0.14997098f, -0.01298167f, -0.02260352f, -0.05874658f, 
    0.17264073f, 0.22066899f, 0.04761566f, 0.14040476f, -0.15423079f, 0.22261266f, 0.04197226f, 0.06378454f, 
    0.16656183f, 0.08090660f, 0.13601954f, 0.20728061f, -0.02417912f, 0.32874799f, -0.14395396f, -0.17798644f, 
    0.31201741f, 0.01584742f, -0.13375100f, -0.01492626f, 0.21786663f, 0.13391750f, 0.11412238f, 0.07719961f, 
    0.00376888f, 0.21020745f, 0.03744473f, 0.18100089f, 0.40125740f, 0.16884783f, -0.16259100f, -0.04595039f, 
    0.10776617f, 0.12869684f, -0.07437731f, 0.01970946f, -0.10058687f, -0.12341277f, 0.14035842f, 0.09266270f, 
    0.55863047f, -0.42171142f, 0.27430734f, 0.12956104f, -0.01510593f, 0.00602020f, -0.04551948f, -0.02010377f, 
    -0.01239635f, 0.06917948f, 0.06947783f, 0.02375582f, -0.29254249f, -0.21013536f, 0.23764294f, 0.08973366f, 
    0.20974229f, -0.04152007f, 0.07499111f, -0.14230882f, 0.00166078f, -0.06942482f, 0.07717142f, 0.10293167f, 
    0.51388538f, 0.20031607f, 0.15249087f, -0.29883808f, 0.04063585f, 0.08240512f, -0.12868650f, -0.12060568f, 
    -0.21161635f, -0.09557546f, 0.01017489f, -0.08424395f, 0.06472766f, -0.30941942f, 0.12659988f, -0.09223521f, 
    0.01823970f, 0.04975830f, 0.06239422f, 0.12622832f, -0.02101695f, -0.16236059f, 0.00499388f, -0.08317105f, 
    0.19026582f, -0.02480311f, -0.16039696f, -0.00669321f, -0.02795461f, -0.11187228f, -0.02734662f, 0.15174380f, 
    0.07915726f, 0.01155945f, -0.21514428f, -0.09133539f, -0.67185789f, 0.22861218f, 0.05136244f, 0.09445684f, 
    -0.04516472f, 0.12837531f, 0.06555320f, 0.05555645f, 0.11713031f, 0.02531648f, -0.16314246f, -0.06346711f, 
    -0.09053201f, 0.05803356f, -0.01391882f, -0.40458471f, -0.02347053f, -0.08215349f, -0.05001033f, 0.09159958f, 
    0.12212426f, -0.11072935f, 0.06837945f, 0.11558662f, 0.20700043f, -0.26672077f, 0.03834445f, -0.29897845f, 
    -0.42412195f, -0.01495242f, 0.06464422f, 0.02053845f, -0.10249238f, 0.13416858f, -0.02100645f, 0.02157070f, 
    0.35951632f, 0.25720856f, 0.11197233f, 0.10549158f, 0.13639095f, 0.01621561f, 0.01596289f, 0.06606668f, 
    0.05152394f, 0.05079981f, -0.17953989f, 0.05660484f, -0.26016721f, -0.06995294f, -0.02193260f, -0.00901974f, 
    -0.01844996f, 0.17483044f, 0.09786782f, 0.06676486f, -0.00034544f, -0.02364169f, -0.07317150f, -0.13081303f, 
    -0.04694630f, 0.23770039f, -0.29597420f, 0.16746713f, 0.06900253f, -0.14721595f, 0.19917451f, -0.07167543f, 
    -0.07296444f, -0.08569816f, 0.04170883f, -0.07256664f, -0.01463405f, -0.10337729f, -0.02350625f, -0.17727761f, 
    0.10929050f, 0.07863667f, 0.08557460f, 0.04349644f, -0.01620399f, -0.12112013f, 0.16153377f, 0.03454377f, 
    0.04490588f, 0.14905085f, -0.11060423f, -0.07756835f, 0.10834608f, 0.08992305f, -0.22555941f, 0.12576558f, 
    -0.01722190f, -0.09996270f, 0.09305170f, 0.07591607f, 0.09621314f, -0.18487953f, -0.01543518f, -0.14665107f, 
    0.00896825f, -0.07006621f, -0.04080115f, -0.10811911f, -0.07573713f, 0.01137731f, 0.09270171f, -0.02758980f, 
    0.22699471f, 0.01590734f, 0.13196328f, 0.00034684f, -0.04149219f, 0.00804981f, -0.11124861f, 0.00132306f, 
    -0.00907739f, 0.01385067f, 0.08398870f, -0.00080960f, -0.17397214f, 0.02719533f, 0.06245406f, 0.35239655f, 
    -0.03090488f, 0.15316226f, -0.03536480f, -0.01176705f, 0.00112578f, -0.07680731f, -0.06820497f, -0.02394291f, 
    -0.34990072f, 0.18763559f, -0.05817679f, -0.15007773f, 0.08656528f, 0.13174158f, 0.07846802f, 0.04502126f, 
    0.10282569f, 0.00599496f, -0.02216751f, 0.00959561f, 0.42127317f, 0.38470617f, -0.12115876f, -0.20288774f, 
    0.05909791f, 0.08779483f, -0.07475612f, 0.20293958f, 0.13551161f, 0.14310132f, 0.02605643f, 0.07779297f, 
    0.10904575f, 0.03599821f, 0.11521903f, 0.47499916f, -0.19223015f, -0.22062112f, 0.03029393f, -0.00083533f, 
    -0.07441451f, -0.00071095f, -0.00316994f, 0.00545977f, 0.36488757f, 0.36244178f, -0.08541200f, -0.43304041f, 
    0.09377455f, 0.15938967f, 0.04768817f, -0.00885380f, 0.03509623f, 0.17628118f, -0.04780571f, -0.04124480f, 
    0.04453435f, -0.07173544f, -0.07748299f, -0.01223284f, -0.04810725f, 0.00047237f, -0.07087006f, 0.03873791f, 
    0.06224752f, 0.01740532f, -0.01602298f, -0.03333292f, -0.02469146f, -0.02648436f, -0.03070551f, -0.01980876f, 
    -0.05205525f, -0.01521241f, -0.04946883f, 0.03905949f, -0.01002533f, -0.05956404f, -0.07687540f, -0.03475920f, 
    0.02654739f, -0.05359162f, 0.03722013f, -0.05481933f, 0.06218853f, -0.01947489f, 0.01516119f, 0.04704351f, 
    0.01668380f, -0.04486962f, -0.05966558f, 0.00503149f, -0.02816199f, -0.05704423f, -0.07757082f, -0.03312372f, 
    -0.07079431f, 0.00380279f, 0.02603902f, 0.05320993f, -0.07158623f, -0.06885483f, 0.03551776f, -0.07408626f, 
    -0.06936905f, 0.05808572f, -0.07562700f, -0.02064162f, 0.05951296f, -0.00847062f, -0.02745767f, -0.06325413f, 
    -0.06277665f, 0.00914618f, 0.01927459f, -0.04462764f, 0.01638593f, -0.07258852f, 0.03412573f, -0.00035445f, 
    -0.01054801f, -0.06631885f, -0.06299740f, 0.00640537f, -0.07874902f, -0.04821273f, -0.00853219f, -0.00139515f, 
    0.05371869f, -0.01776560f, -0.07087018f, 0.03896388f, -0.05226013f, 0.04485638f, -0.00858448f, -0.05292064f, 
    0.02312955f, -0.00183090f, -0.06030097f, -0.02931187f, 0.02395352f, 0.03202136f, -0.00530633f, 0.04444290f, 
    0.04706226f, 0.04719657f, -0.07741465f, 0.03615107f, 0.03599056f, -0.07717460f, 0.01884378f, -0.04490031f, 
    -0.02231624f, -0.02076069f, 0.01702536f, 0.04377561f, -0.06698404f, -0.04165736f, 0.03388889f, 0.06069560f, 
    -0.02134226f, -0.04870095f, 0.00831197f, 0.03614166f, 0.02317308f, -0.05431793f, 0.00151408f, 0.04711865f, 
    -0.01708653f, 0.03461534f, -0.07404255f, -0.02789024f, -0.04483324f, -0.07185855f, -0.04696662f, -0.03337571f, 
    -0.06338155f, -0.02690179f, 0.04181530f, 0.05333400f, 0.04371837f, -0.06481250f, 0.05979463f, 0.01887828f, 
    0.04018042f, -0.02606711f, -0.02551835f, 0.03636071f, -0.04264773f, 0.01711101f, 0.06288639f, -0.04604411f, 
    0.04299502f, 0.03567334f, -0.04194598f, -0.01764441f, 0.04511023f, 0.01344323f, 0.02815299f, -0.05075304f, 
    -0.01117642f, -0.06071363f, -0.00323097f, 0.05195813f, -0.01753138f, 0.00389097f, 0.00428546f, 0.02232458f, 
    -0.03122077f, 0.04012083f, -0.05371590f, 0.00096339f, -0.00036714f, 0.02651236f, -0.03190595f, -0.01658539f, 
    0.01957249f, 0.05054147f, 0.05355198f, -0.02593044f, 0.02309992f, 0.00398946f, -0.04636765f, 0.03650046f, 
    0.01166417f, 0.06136864f, -0.03849297f, -0.04311043f, -0.04382287f, 0.05387393f, -0.06978154f, -0.05591464f, 
    0.00930836f, -0.04072486f, -0.03981170f, -0.04141513f, -0.02465707f, 0.01828436f, -0.01247827f, -0.04223309f, 
    0.01540360f, 0.02960687f, -0.03847728f, -0.01135933f, -0.03068229f, -0.04748400f, -0.07334562f, 0.02399217f, 
    0.04296017f, 0.06548274f, 0.04472991f, -0.04090116f, 0.05712869f, 0.05262037f, -0.00175689f, -0.06287897f, 
    -0.06205356f, -0.06594635f, -0.01453364f, -0.01930887f, 0.05268250f, 0.02817243f, -0.03263540f, 0.04853023f, 
    -0.01982873f, -0.00232333f, -0.05239154f, -0.05213688f, 0.04164531f, 0.04431932f, 0.02352079f, -0.03552373f, 
    -0.02623216f, -0.06792397f, -0.07684232f, -0.04948637f, 0.05027989f, -0.00882290f, -0.00039088f, -0.02488050f, 
    0.06253015f, -0.06344835f, -0.06300407f, -0.07311779f, 0.03671379f, -0.03580532f, -0.04933862f, 0.02640939f, 
    0.03909446f, 0.02791016f, -0.02474864f, -0.03281933f, 0.05805025f, 0.00787673f, -0.01933371f, -0.00482963f, 
    -0.04395898f, 0.00518495f, -0.03474207f, 0.01183796f, -0.01688243f, 0.01511626f, -0.02659037f, 0.01437500f, 
    0.01176220f, 0.04145406f, 0.02882966f, 0.04868576f, 0.05023175f, -0.05822983f, -0.06208058f, -0.02840800f, 
    0.01009918f, 0.00074369f, 0.02376547f, -0.04927567f, -0.08102824f, -0.00816463f, -0.07610779f, 0.05406814f, 
    0.01751144f, -0.06753105f, 0.02681869f, -0.03253383f, -0.03729092f, 0.04083727f, -0.01256040f, -0.06476858f, 
    -0.02487415f, -0.06056876f, -0.02884011f, 0.02553397f, 0.00123292f, 0.04957040f, -0.02752013f, -0.06921074f, 
    -0.05586091f, -0.00222238f, 0.04378348f, 0.01388499f, -0.05882171f, -0.04273440f, 0.04303165f, -0.05197446f, 
    0.02998112f, -0.04418138f, -0.02861426f, -0.04439213f, -0.02237603f, 0.02061150f, 0.02360376f, -0.06543696f, 
    0.01221283f, 0.01154902f, -0.06216010f, -0.00641625f, 0.05137609f, -0.04260027f, 0.04911265f, -0.01807879f, 
    -0.02284585f, -0.05807196f, 0.02945476f, 0.02888948f, -0.01370156f, 0.04372286f, -0.07512271f, -0.07588216f, 
    -0.00165492f, -0.00456072f, -0.08021322f, -0.01286983f, 0.00987825f, 0.04027322f, -0.05230644f, 0.06087170f, 
    0.02299176f, -0.02264991f, -0.07550132f, -0.00911551f, 0.00317582f, 0.06223391f, 0.05702995f, -0.02390021f, 
    0.05722248f, -0.03985186f, -0.02521775f, 0.06424199f, -0.06129900f, -0.00640231f, 0.04858088f, 0.01952294f, 
    0.05119726f, -0.06878143f, -0.04543801f, -0.05127555f, -0.07296225f, -0.08341873f, -0.04991614f, -0.01495695f, 
    -0.02046362f, -0.05925757f, 0.01502128f, -0.06482805f, -0.04745482f, 0.03035784f, 0.04041866f, -0.07364909f, 
    -0.04599101f, -0.05785463f, -0.05760987f, -0.03445190f, 0.03048715f, 0.00874021f, -0.06157337f, -0.00412459f, 
    0.05459692f, -0.07126163f, 0.03336035f, -0.01356729f, -0.04713919f, -0.03987301f, -0.01984496f, 0.02705990f, 
    -0.03896445f, 0.04892966f, 0.03291391f, -0.00783925f, -0.02358710f, 0.05369759f, -0.00974854f, -0.00507074f, 
    0.03942013f, 0.03343559f, -0.03998045f, 0.04836530f, 0.00650396f, -0.07810113f, 0.01040337f, 0.01836267f, 
    0.01284894f, -0.00517559f, -0.04322143f, -0.03288338f, -0.05066245f, 0.05012418f, 0.03144006f, 0.06084948f, 
    0.01401775f, -0.03902079f, -0.06056028f, 0.02004005f, -0.05784539f, -0.04122659f, -0.03365879f, 0.00988045f, 
    0.04980131f, -0.02166491f, 0.04119242f, -0.01301337f, -0.00258455f, -0.02360424f, -0.06990273f, -0.00680077f, 
    -0.04546745f, -0.00664051f, -0.03350922f, 0.01403118f, 0.00931682f, 0.05150866f, 0.03603552f, -0.06273662f, 
    0.06293426f, 0.04405732f, -0.04095394f, -0.01916843f, -0.02279345f, 0.01093209f, -0.07740278f, -0.04978522f, 
    -0.00785775f, 0.02187132f, -0.04871060f, -0.04547820f, -0.05096138f, 0.00499792f, 0.04934824f, 0.06274475f, 
    -0.00718351f, 0.00614073f, -0.04741687f, -0.01810849f, 0.00803646f, -0.01904912f, -0.02468099f, 0.03599998f, 
    -0.02477960f, -0.04619491f, 0.02262202f, -0.02125964f, 0.01255612f, 0.04300176f, 0.03783036f, -0.03833230f, 
    -0.01046697f, -0.00476724f, 0.05035054f, -0.00152091f, 0.01147707f, -0.05557157f, 0.05285577f, -0.07917293f, 
    -0.05269067f, 0.00306707f, 0.03565529f, -0.02009366f, -0.06345285f, -0.00968939f, -0.05957220f, 0.04004806f, 
    0.04800468f, 0.04563504f, 0.03263848f, -0.00300775f, -0.06773937f, -0.07320455f, 0.03671325f, -0.05875175f, 
    0.00427695f, -0.02561208f, 0.03471078f, 0.03250729f, -0.00052168f, -0.02477489f, -0.01150016f, 0.02370724f, 
    0.02139330f, -0.04554413f, -0.03742469f, 0.00178778f, -0.07265998f, -0.05818764f, -0.06556766f, -0.06099574f, 
    0.01401204f, -0.04044296f, -0.05033502f, -0.01066225f, -0.01997291f, 0.03187126f, -0.02538936f, 0.02984961f, 
    0.00658373f, 0.00930461f, 0.00223592f, -0.06646277f, -0.04007004f, -0.03371881f, -0.05340290f, 0.05103594f, 
    -0.04716329f, -0.02114262f, -0.03279339f, 0.02543675f, 0.01971511f, 0.05998671f, -0.01092150f, -0.07397298f, 
    -0.04896389f, -0.07432315f, -0.06518653f, -0.03215585f, -0.02005438f, -0.07523444f, -0.06135758f, 0.00555383f, 
    0.00613669f, -0.06143631f, -0.02687918f, -0.06958653f, -0.01082094f, 0.04770519f, 0.01964113f, -0.07097401f, 
    0.03639877f, 0.05171126f, 0.00583935f, 0.06453234f, 0.01119122f, -0.01051120f, 0.00270377f, -0.07678159f, 
    -0.05354704f, 0.03326946f, 0.02891073f, 0.05839036f, -0.00939317f, -0.03998477f, -0.04587818f, -0.03080324f, 
    0.03116047f, 0.04003976f, -0.06111766f, -0.06682633f, 0.01327298f, -0.03731407f, -0.07480751f, -0.01217267f, 
    -0.07438710f, -0.04227383f, 0.05120417f, 0.02684867f, -0.05411413f, -0.04176365f, 0.05511937f, 0.03175357f, 
    -0.04101763f, 0.03293443f, -0.03056047f, -0.06995711f, 0.02001118f, -0.01722083f, 0.04190414f, -0.03737120f, 
    0.02969519f, -0.03310613f, 0.00752603f, 0.00938622f, -0.00718991f, 0.00854784f, -0.00521868f, -0.03062080f, 
    0.02340797f, -0.04758405f, 0.03985128f, -0.07666802f, -0.01480419f, -0.03222795f, -0.05800804f, 0.01990028f, 
    0.03338637f, 0.03661507f, 0.02944401f, -0.00251820f, -0.03595085f, -0.04774723f, 0.01121182f, 0.01252307f, 
    0.06311949f, 0.02033854f, -0.01908810f, 0.03024612f, -0.04673073f, -0.05884095f, 0.00605331f, 0.06080239f, 
    0.02403445f, -0.02095306f, -0.07159121f, -0.05005044f, 0.01649888f, -0.05972461f, 0.02000232f, -0.02381028f, 
    -0.02967930f, 0.03692750f, 0.04929902f, -0.02008393f, -0.05846657f, 0.01638206f, 0.06141463f, -0.01151599f, 
    0.05423575f, -0.07087094f, -0.06623984f, -0.05329175f, -0.01905969f, -0.05845190f, -0.06127578f, -0.05807873f, 
    0.01172915f, -0.01956469f, -0.03228487f, 0.02445539f, 0.01295409f, -0.01430310f, 0.03542007f, -0.06799671f, 
    -0.03711021f, -0.05349750f, 0.03811430f, 0.01778852f, -0.04899559f, -0.01386552f, -0.02647153f, 0.05178208f, 
    0.02612408f, 0.01273033f, -0.05443275f, -0.06421749f, -0.02907699f, -0.00570205f, -0.01832396f, 0.05649801f, 
    0.00699330f, 0.03350460f, 0.02395781f, -0.06439646f, -0.06943858f, -0.04187270f, 0.02728311f, 0.01660127f, 
    0.05415880f, 0.00031156f, -0.02660233f, -0.03708884f, -0.05563134f, 0.03409139f, -0.04101581f, -0.03983987f, 
    0.00087333f, 0.00634206f, 0.00942786f, -0.02428254f, -0.01100236f, -0.03420593f, -0.00546888f, -0.05758787f, 
    0.04437229f, -0.05137541f, 0.05140814f, 0.00746461f, -0.02356475f, -0.00803478f, 0.03776604f, 0.05005078f, 
    -0.01048767f, -0.06976751f, 0.01143867f, 0.03311564f, -0.00146565f, 0.00282139f, -0.00380712f, -0.02154849f, 
    -0.03651657f, 0.02272766f, -0.01856260f, -0.05036386f, -0.06433281f, 0.01759777f, -0.01987213f, 0.01047726f, 
    -0.00007679f, 0.01939889f, -0.05772218f, -0.00555034f, 0.02983940f, -0.01057514f, 0.01944022f, -0.02733046f, 
    -0.02969222f, -0.06572552f, -0.02609256f, 0.00005487f, 0.01212475f, -0.05831705f, -0.03732626f, -0.02689398f, 
    -0.02652717f, -0.07635083f, 0.02378515f, -0.00853107f, -0.04786782f, -0.01345225f, -0.04923802f, -0.02047518f, 
    -0.01215722f, 0.06225988f, -0.03576234f, 0.01822077f, 0.05734150f, -0.03236004f, -0.07527784f, -0.04652961f, 
    -0.06511339f, -0.02988609f, -0.04392625f, -0.05138274f, -0.03525088f, 0.01141148f, 0.04196193f, -0.04416051f, 
    -0.06448584f, 0.00112274f, 0.00572360f, -0.05518737f, 0.00440073f, -0.01261285f, -0.00504683f, 0.06060022f, 
    0.03977580f, 0.00404141f, -0.00051865f, 0.00706621f, -0.03586341f, -0.07709523f, -0.04746393f, -0.02891150f, 
    -0.03402461f, 0.04695005f, 0.03777926f, -0.03880687f, 0.01782511f, -0.04077960f, 0.02634635f, 0.04512155f, 
    0.04732593f, -0.01939249f, -0.03158212f, 0.05092936f, 0.01214938f, 0.00780808f, -0.06652036f, 0.06015670f, 
    -0.03551006f, 0.06683183f, -0.02195078f, -0.02261464f, 0.04306343f, 0.01816000f, -0.01784613f, -0.06542884f, 
    -0.06886087f, -0.07444821f, -0.03963242f, 0.04833362f, 0.05471076f, -0.05675838f, 0.05347178f, 0.03862679f, 
    -0.04498304f, -0.05621549f, -0.03700271f, -0.03738029f, -0.06357618f, -0.04663008f, 0.06293073f, -0.07524122f, 
    -0.06472323f, -0.04551807f, -0.00467710f, -0.04559925f, 0.01848176f, -0.03155148f, 0.02855510f, 0.03884896f, 
    0.01568481f, 0.05580593f, -0.03331077f, 0.06864392f, -0.05659601f, -0.01886030f, 0.03709047f, 0.03317968f, 
    -0.05187790f, -0.02904682f, 0.01357121f, 0.02856817f, -0.03953360f, -0.06415611f, 0.05933709f, 0.04542768f, 
    -0.06531803f, 0.03619679f, -0.01302536f, -0.03447661f, -0.01493313f, -0.06795317f, -0.05362182f, -0.02380398f, 
    0.02070458f, 0.02734536f, -0.06592454f, 0.05614274f, 0.01225670f, 0.01987643f, -0.03145907f, -0.01242168f, 
    0.02127534f, -0.05413441f, 0.01007347f, -0.06991819f, -0.00736890f, 0.03744730f, 0.04264723f, 0.01865624f, 
    0.05822840f, -0.01950677f, 0.02472363f, 0.04447632f, 0.01093210f, -0.00033506f, -0.01679650f, 0.00038566f, 
    0.02706359f, 0.05447791f, 0.02565911f, -0.05284901f, 0.02045380f, 0.01843514f, -0.01610933f, 0.00432980f, 
    0.00095328f, -0.04274340f, -0.02625247f, -0.02917770f, -0.06973933f, -0.05292294f, -0.02335371f, 0.02807106f, 
    0.02670195f, 0.04672874f, 0.03974711f, -0.06546078f, 0.03434976f, -0.04072914f, 0.01453022f, -0.02126988f, 
    -0.01756671f, 0.01545203f, 0.04750339f, -0.04041089f, -0.07158780f, -0.03018929f, -0.00067681f, -0.05826668f, 
    -0.04347088f, 0.02372614f, 0.02301735f, 0.05538750f, -0.03010328f, -0.03091346f, -0.00200617f, 0.01349387f, 
    0.05251055f, -0.00502176f, -0.04825207f, -0.06411454f, -0.03381443f, -0.00444647f, -0.00284344f, -0.05286783f, 
    -0.01385869f, 0.05104212f, 0.03892491f, -0.03748695f, -0.06445251f, -0.02306136f, -0.01097250f, -0.04968861f, 
    -0.00004584f, -0.05373074f, 0.06125676f, -0.06014489f, -0.03570552f, -0.00979350f, 0.01803115f, 0.05094543f, 
    -0.05164273f, 0.06231232f, 0.00943016f, 0.00222558f, -0.04771268f, -0.02431107f, 0.01100956f, -0.03083286f, 
    0.01767896f, -0.01184555f, -0.07234585f, 0.02046762f, 0.05657129f, -0.01641060f, 0.03928607f, -0.03024797f, 
    -0.00226472f, 0.02841570f, -0.04203178f, 0.00068716f, -0.02310915f, 0.05722551f, 0.05361246f, -0.01150086f, 
    0.02019424f, 0.00057549f, 0.03321201f, 0.01825069f, -0.06549562f, 0.04225952f, 0.04261407f, -0.06465016f, 
    -0.01102237f, -0.02280516f, -0.02860311f, 0.05498901f, -0.05685606f, -0.04852436f, -0.05651239f, 0.05821319f, 
    -0.02632172f, -0.04060825f, -0.00765021f, -0.03071880f, -0.07561073f, -0.03219182f, 0.03712044f, -0.03587523f, 
    0.34541512f, -0.11037475f, -0.48998410f, -0.20837902f, 0.02928367f, -0.00533059f, 0.12112239f, 0.27785137f, 
    0.00170861f, 0.13062914f, 0.11299939f, 0.12541199f, -0.54967034f, 0.37617147f, 0.25154316f, 0.02353496f, 
    -0.03568313f, -0.08091604f, 0.00087679f, 0.17000979f, -0.18025555f, 0.16594593f, -0.12012701f, 0.03061220f, 
    -0.35661668f, 0.02689447f, 0.14569019f, 0.13738139f, -0.03118492f, 0.03360124f, 0.14196165f, 0.07796177f, 
    -0.00309186f, 0.02899304f, 0.16920398f, 0.03394959f, 0.03009882f, -0.30688262f, 0.17480272f, -0.23165004f, 
    -0.29979888f, 0.03150570f, 0.01406838f, -0.10218325f, 0.01478767f, -0.05500464f, -0.11544854f, -0.08655876f, 
    -0.02160278f, 0.07204747f, 0.20426710f, 0.24942559f, 0.15958482f, 0.02715153f, -0.09490264f, -0.02026741f, 
    0.15335995f, -0.11958443f, -0.06621652f, -0.04987847f, -0.00671874f, -0.13215065f, 0.23300922f, -0.07064296f, 
    0.08698754f, 0.14469270f, 0.04681723f, 0.23326671f, 0.16280161f, 0.01268119f, 0.00894575f, 0.00903032f, 
    -0.01642303f, -0.07477914f, -0.14921227f, 0.26636866f, -0.13019907f, 0.18126130f, -0.02930148f, -0.18987869f, 
    0.08904088f, -0.10978238f, -0.08111207f, 0.15980342f, 0.17561714f, 0.13256499f, 0.03914245f, 0.26327851f, 
    0.02913675f, 0.24340239f, 0.19526945f, 0.05499322f, 0.10074612f, -0.13308761f, 0.09840830f, 0.09392180f, 
    -0.20577155f, 0.32668066f, -0.35380927f, 0.14488839f, 0.00951990f, -0.21991403f, 0.16566080f, 0.41240892f, 
    -0.12899753f, -0.08232670f, 0.05587966f, 0.10515305f, 0.52905035f, -0.11279761f, 0.20956346f, 0.28689355f, 
    -0.05469485f, -0.10593881f, 0.10456774f, 0.07430676f, -0.06601292f, -0.05729143f, 0.00593155f, -0.09722284f, 
    -0.40979356f, 0.02658919f, 0.07450816f, -0.24564780f, 0.07241757f, 0.18256533f, 0.01715845f, 0.24064898f, 
    0.00276499f, 0.16117267f, 0.11748809f, 0.13968068f, -0.19711795f, 0.20175186f, -0.13247865f, 0.02681873f, 
    -0.11897971f, 0.11477257f, -0.19544709f, 0.18826459f, 0.02551742f, 0.13389097f, 0.02201058f, -0.12655111f, 
    0.01194299f, 0.25859889f, 0.17695379f, -0.30536023f, -0.11427862f, 0.25615501f, 0.08271091f, 0.01948343f, 
    0.05135553f, 0.07761001f, 0.15988742f, 0.18150011f, 0.30100310f, 0.04321856f, -0.24380372f, 0.12557381f, 
    -0.03595420f, -0.11949966f, 0.21165669f, 0.27691674f, -0.03824501f, -0.07630734f, 0.10272455f, 0.20286274f, 
    -0.12905242f, -0.19231100f, 0.02964910f, 0.16672421f, -0.14094163f, 0.03238131f, -0.02668853f, 0.12653099f, 
    0.00187013f, -0.03833734f, -0.02981573f, -0.13472360f, 0.25747636f, 0.17032084f, 0.09040236f, 0.26970264f, 
    0.13038084f, -0.05436013f, -0.04959238f, 0.19131710f, -0.07591023f, -0.00681640f, -0.00723824f, -0.07034795f, 
    -0.04018473f, 0.05198654f, 0.00963311f, 0.03507840f, 0.02370455f, 0.05124494f, 0.04971591f, 0.01670301f, 
    -0.07638611f, -0.02421710f, -0.05660329f, 0.01750675f, 0.03499202f, 0.00546659f, 0.02002188f, -0.01097823f, 
    -0.06462256f, 0.00478466f, -0.00235889f, 0.02507648f, -0.06168832f, 0.02327370f, -0.05446903f, 0.05753159f, 
    -0.04208922f, 0.01191447f, 0.03632434f, 0.03322313f, 0.01166629f, 0.03638586f, 0.04722047f, -0.05319298f, 
    -0.04587478f, -0.06883601f, 0.00401351f, -0.01652995f, 0.05778309f, 0.03198298f, -0.01058656f, 0.07435900f, 
    0.00741352f, -0.02861905f, -0.00443181f, 0.05323448f, -0.01281084f, -0.03031439f, 0.03617463f, 0.01938809f, 
    -0.00960552f, 0.03626293f, 0.01967457f, -0.02677777f, -0.06819387f, 0.05491253f, 0.01821924f, -0.06748562f, 
    -0.01152982f, -0.08598447f, -0.04032812f, -0.02001844f, -0.06062124f, -0.07199767f, -0.01131561f, 0.04550432f, 
    0.01255799f, 0.01689869f, 0.00856087f, -0.04499622f, -0.06068920f, -0.01980887f, -0.06973874f, 0.03625445f, 
    -0.01968290f, 0.05920020f, -0.03141332f, 0.04556724f, -0.00293692f, -0.02957804f, -0.07722363f, 0.05672750f, 
    -0.07651011f, 0.02415033f, -0.04399737f, 0.05090203f, 0.02014971f, 0.02631220f, -0.02459987f, 0.02202635f, 
    -0.00020685f, 0.01620126f, 0.02327134f, -0.04658193f, -0.04062494f, -0.00716918f, -0.01876685f, -0.06218991f, 
    0.00349887f, -0.04661480f, 0.01522810f, -0.02304053f, -0.03736385f, -0.02264223f, -0.05717294f, -0.04887378f, 
    0.03405793f, -0.03021075f, 0.05911157f, 0.03395976f, 0.02968544f, -0.01453032f, 0.00229905f, 0.05348596f, 
    -0.00078290f, 0.03796021f, 0.02431292f, -0.00316970f, -0.01042161f, -0.04306590f, -0.05058778f, -0.07596637f, 
    -0.00774434f, 0.03060794f, -0.04529589f, 0.06200446f, -0.03520446f, 0.01306015f, -0.00650198f, -0.01775790f, 
    -0.03089398f, -0.06241003f, -0.00177235f, -0.00866933f, -0.05956399f, -0.00333477f, -0.04185158f, 0.04105156f, 
    -0.03954805f, 0.01345651f, -0.04932284f, -0.03805315f, -0.02908479f, 0.02067313f, -0.00360041f, 0.00288085f, 
    -0.04719003f, -0.00088900f, -0.05748094f, -0.05908238f, 0.04281176f, 0.01196684f, 0.01938575f, -0.07589793f, 
    -0.02489502f, -0.06390075f, 0.02933617f, 0.06451888f, 0.03659407f, 0.04243571f, 0.05903900f, 0.01285258f, 
    0.06164764f, -0.00784296f, 0.00431947f, -0.01320555f, -0.02658747f, 0.02609632f, -0.03281187f, 0.01075442f, 
    -0.01881071f, 0.01764756f, -0.02857427f, -0.06107423f, 0.03512443f, 0.02582573f, 0.00025714f, -0.06058432f, 
    0.01370879f, -0.07908235f, 0.02021370f, -0.01205324f, 0.01792372f, -0.04295598f, -0.04859517f, -0.03205573f, 
    -0.05838577f, -0.06237158f, -0.08222731f, 0.04110145f, 0.03034174f, -0.05634397f, -0.05068285f, 0.06227991f, 
    0.32211208f, 0.15473980f, -0.01501957f, 0.24370098f, -0.19169323f, 0.06760558f, 0.02548436f, 0.09486323f, 
    -0.03472454f, -0.02302237f, 0.04966203f, 0.09710037f, -0.31403396f, 0.10659431f, 0.06320621f, 0.02960198f, 
    -0.04298038f, -0.12342323f, 0.03100622f, 0.07437938f, -0.13619286f, 0.02070053f, 0.01498260f, 0.03711359f, 
    -0.04467208f, -0.08853501f, 0.06950013f, 0.11801194f, -0.11190809f, 0.04541459f, 0.07956618f, -0.25478423f, 
    0.04917620f, 0.02233396f, -0.06831381f, -0.11103224f, -0.26557660f, -0.08098400f, -0.18707439f, 0.41455123f, 
    0.03971577f, 0.07091940f, -0.04482912f, 0.05095512f, 0.08575365f, 0.02821106f, -0.15191635f, -0.03931642f, 
    0.05262108f, 0.09108317f, -0.08591720f, 0.29631078f, 0.07777112f, -0.17742723f, 0.01249493f, 0.20643891f, 
    -0.03234658f, -0.05963631f, 0.14849955f, -0.07987189f, 0.42766884f, -0.10319468f, -0.18654230f, 0.52333659f, 
    -0.05528610f, -0.15473408f, 0.02996580f, -0.03199685f, 0.09504276f, 0.23052464f, -0.07845761f, -0.04585584f, 
    0.18022889f, 0.04461356f, -0.22942224f, -0.02476137f, -0.01701938f, -0.03489166f, -0.12276147f, -0.01290142f, 
    -0.00132837f, 0.04528779f, -0.05216152f, 0.16434929f, 0.42579570f, 0.39423859f, -0.35091838f, 0.70913625f, 
    -0.02764671f, -0.05335085f, 0.03784574f, 0.04759210f, 0.07525185f, -0.07535179f, -0.06396699f, -0.05487458f, 
    0.04184450f, 0.34787297f, 0.02783793f, -0.05895202f, 0.02339082f, -0.08583244f, 0.03469321f, 0.07151208f, 
    -0.00325293f, -0.08930623f, -0.04529685f, -0.08103538f, 0.32313409f, 0.14704147f, 0.02547647f, 0.14855844f, 
    0.02388467f, 0.06330718f, 0.06316208f, -0.26417473f, 0.11454380f, -0.05833988f, 0.02907624f, 0.01348372f, 
    -0.48367485f, -0.23445769f, -0.17846468f, -0.22566107f, -0.09769928f, -0.11658882f, -0.00156144f, -0.12778254f, 
    0.16610947f, -0.06411301f, -0.01578726f, 0.00051615f, -0.13111156f, 0.22586937f, 0.11127728f, -0.16578074f, 
    0.22080505f, -0.18216044f, 0.05482180f, 0.04704635f, -0.05471309f, 0.06963025f, -0.08789765f, -0.00620822f, 
    0.14046054f, 0.23602723f, 0.23499918f, 0.33077535f, 0.10159429f, 0.03897203f, -0.15526219f, -0.00424432f, 
    0.15118900f, 0.06588954f, -0.18585627f, -0.02671744f, 0.14322543f, 0.09180106f, 0.20703948f, 0.11910236f, 
    0.06530915f, 0.07887749f, 0.21669902f, -0.09540033f, -0.00337763f, 0.01916145f, 0.11511283f, -0.06125956f, 
    0.05301195f, -0.26272941f, -0.08902001f, -0.20573008f, -0.01617479f, -0.15611139f, -0.07305365f, 0.07809902f, 
    0.06303499f, 0.09308447f, 0.05936699f, 0.20339650f, -0.26402324f, 0.26622319f, 0.05477788f, 0.25645465f, 
    0.10340475f, 0.12343821f, 0.14582260f, -0.18995507f, -0.06540913f, 0.00704949f, 0.10072166f, -0.00802773f, 
    -0.05809057f, -0.06953534f, -0.00206377f, 0.00649080f, -0.04783235f, 0.00200920f, 0.04330925f, 0.03907290f, 
    -0.05232475f, 0.01093612f, -0.02991413f, -0.01475690f, 0.05431092f, -0.07513437f, -0.01577427f, -0.00869006f, 
    -0.02300130f, -0.01400611f, -0.05275709f, -0.02310184f, 0.00136176f, -0.06762685f, -0.05000159f, -0.01971513f, 
    0.04664360f, -0.00277652f, -0.06603017f, 0.04759103f, -0.03054884f, 0.06641601f, 0.02173120f, 0.00218921f, 
    -0.08210000f, 0.04901631f, 0.00258623f, 0.00648458f, -0.06807902f, -0.02051582f, 0.01440524f, -0.01455266f, 
    -0.00062693f, 0.03713538f, -0.01326623f, 0.01833341f, -0.01033933f, 0.00910871f, -0.02884089f, 0.05367206f, 
    0.04525604f, 0.04646640f, -0.05452402f, 0.00058559f, -0.01213556f, 0.05348986f, -0.06317330f, 0.05732837f, 
    0.05236569f, -0.01008449f, -0.02447772f, 0.00981125f, 0.03029344f, -0.06880487f, -0.07744881f, -0.04790076f, 
    -0.05952208f, 0.02620488f, 0.03328343f, 0.05741969f, -0.01108886f, -0.06924909f, 0.05871651f, -0.05309291f, 
    -0.04075260f, 0.03047240f, 0.00132182f, 0.01284600f, -0.05404929f, 0.00098880f, 0.00713737f, -0.05955321f, 
    0.02913976f, 0.02655442f, 0.03704491f, -0.06880954f, -0.05674772f, -0.02322668f, 0.05939439f, 0.00024979f, 
    -0.04872045f, 0.00436406f, -0.07730114f, 0.03426003f, 0.02687338f, -0.05770344f, 0.06472553f, -0.05218227f, 
    -0.05962975f, 0.05547333f, 0.05217062f, -0.04705163f, 0.05241688f, 0.03791920f, -0.03457867f, 0.04749347f, 
    -0.01080666f, 0.04079654f, -0.06022535f, 0.06447890f, -0.06961808f, -0.04816436f, -0.01415779f, -0.07269379f, 
    0.00577628f, -0.02065845f, 0.05189906f, -0.02894345f, -0.02323436f, 0.02833542f, -0.05194601f, 0.03299042f, 
    -0.00212645f, -0.04192671f, 0.04664735f, -0.00642096f, -0.04894212f, 0.02725452f, -0.05895070f, -0.03802786f, 
    0.04617890f, -0.03601327f, -0.04364064f, -0.03507066f, -0.03813667f, -0.03353631f, 0.04296473f, -0.03081151f, 
    -0.00919222f, 0.01654863f, 0.05914773f, 0.02183845f, -0.02993193f, 0.04479811f, -0.05588146f, 0.03812237f, 
    0.05630467f, 0.04698604f, 0.00735544f, 0.03146445f, -0.07998737f, 0.04794575f, -0.01212711f, -0.04540244f, 
    -0.00620747f, 0.01256933f, -0.00563009f, -0.01852041f, -0.05897925f, 0.06106213f, -0.06064994f, -0.03269766f, 
    0.01846915f, 0.06084618f, -0.07274683f, -0.07387429f, -0.07633684f, 0.02516328f, -0.02216994f, 0.00975212f, 
    -0.04139962f, -0.04984116f, -0.08099739f, 0.02287369f, 0.04963573f, -0.02851538f, -0.00110815f, 0.05528955f, 
    -0.02466448f, 0.01221783f, -0.02280779f, 0.02762865f, 0.06334095f, 0.04181351f, -0.03257707f, -0.05698055f, 
    0.02877389f, -0.05832525f, -0.04088630f, -0.03227213f, -0.05687304f, -0.07643006f, -0.03952947f, -0.04782124f, 
    0.01573344f, 0.11763779f, -0.10090010f, -0.17082129f, -0.04140024f, -0.08016863f, 0.11182939f, 0.04562998f, 
    0.12741564f, -0.14482650f, -0.12034336f, -0.14014128f, -0.15968871f, 0.27459180f, -0.12090982f, 0.25451151f, 
    0.01506105f, 0.03327257f, -0.05892137f, -0.06714738f, -0.07001127f, -0.11251532f, 0.09257294f, -0.09887399f, 
    -0.33032653f, 0.13854058f, -0.09178735f, -0.21872847f, 0.03124291f, 0.08783788f, -0.01126838f, 0.08888090f, 
    0.17179699f, -0.00954497f, 0.05918916f, -0.12353995f, 0.49894932f, -0.10940468f, -0.04072050f, 0.04840533f, 
    -0.04532386f, -0.09126589f, 0.14983280f, -0.01739732f, -0.03697160f, 0.06676138f, -0.13730422f, 0.12865326f, 
    0.05158466f, -0.01225636f, 0.03591057f, 0.18790789f, 0.14270857f, 0.05532933f, 0.06798486f, 0.07859562f, 
    0.01230553f, 0.02306810f, 0.11657654f, 0.24151960f, -0.15053360f, 0.02275451f, -0.14035544f, 0.15330574f, 
    -0.12464141f, -0.02516456f, 0.14029269f, -0.01580238f, 0.20197828f, 0.16398381f, 0.06887150f, -0.01956548f, 
    0.19496208f, 0.22348395f, -0.38548175f, 0.14257431f, -0.00090509f, -0.06481031f, 0.13766305f, 0.00468269f, 
    -0.10110822f, -0.07802137f, 0.11673623f, 0.12339041f, 0.03770790f, -0.08413862f, -0.03054042f, 0.10520172f, 
    -0.05306875f, -0.22859286f, -0.08963083f, -0.15085527f, -0.00524158f, -0.02434391f, 0.20666423f, 0.07611214f, 
    -0.17142852f, 0.10515382f, -0.01177410f, -0.17767775f, 0.13846217f, 0.21444575f, 0.13784054f, -0.11601977f, 
    -0.07630489f, 0.03306310f, 0.06139218f, 0.02334941f, 0.17843582f, -0.17181519f, -0.02714177f, -0.15418451f, 
    0.12482617f, 0.04842323f, 0.00048586f, -0.09780370f, 0.01319222f, -0.17941564f, 0.06434806f, 0.13663311f, 
    0.06201836f, -0.30204275f, 0.21525110f, 0.09866648f, -0.14158113f, -0.09497894f, -0.11259641f, 0.07272412f, 
    -0.00553675f, -0.12659493f, 0.08467206f, -0.07854392f, -0.75623244f, 0.18650989f, 0.05263547f, 0.22981207f, 
    0.12429624f, -0.03890705f, -0.03363494f, 0.02380472f, 0.06065721f, 0.04124827f, -0.03139983f, -0.13367608f, 
    -0.10068415f, 0.30568397f, -0.10106632f, 0.04758126f, 0.09144706f, 0.01026198f, -0.09988225f, 0.00000281f, 
    0.21007922f, -0.02454699f, -0.06014829f, 0.06073967f, 0.14128330f, -0.17008297f, -0.16689906f, -0.20945735f, 
    0.04794963f, 0.22676723f, -0.07731922f, 0.01185811f, 0.03638078f, 0.12344728f, 0.08252288f, -0.07838421f, 
    0.74107987f, 0.18894546f, -0.07956466f, 0.48954061f, -0.13330185f, -0.13309130f, 0.04233297f, 0.11736938f, 
    0.09332355f, -0.01429129f, -0.06656908f, 0.08722284f, -0.05093099f, 0.09429794f, -0.14476724f, -0.14020111f, 
    0.01793525f, -0.01415928f, -0.06368835f, -0.11818652f, 0.15737264f, -0.02183091f, -0.05456913f, -0.00004541f, 
    0.23723681f, 0.03454107f, 0.25650227f, 0.39077845f, -0.23826207f, 0.09043495f, 0.00150523f, 0.04193627f, 
    0.01499789f, 0.11104056f, 0.00435269f, 0.02364394f, -0.32593781f, -0.17420086f, 0.26437369f, -0.17782244f, 
    0.09625851f, -0.06764556f, -0.04457435f, 0.12331297f, -0.04462605f, 0.07645219f, 0.01054506f, 0.18328109f, 
    -0.15497333f, -0.11089592f, -0.15752836f, 0.15675054f, 0.01978761f, 0.02462303f, 0.04530695f, -0.27398437f, 
    0.01706251f, 0.19328386f, 0.00628728f, 0.06528629f, -0.39728716f, 0.02702581f, 0.06512284f, 0.03753440f, 
    0.08188506f, 0.21034390f, -0.15087035f, 0.12036499f, 0.19902351f, -0.16257149f, -0.07051717f, -0.10009762f, 
    0.34383443f, 0.13914895f, 0.15533631f, 0.18557468f, -0.07024352f, 0.04464450f, 0.07490415f, 0.04211710f, 
    -0.08952499f, -0.04639887f, 0.05081858f, 0.08543914f, -0.01665136f, -0.23266646f, 0.28061968f, 0.42161039f, 
    -0.00356556f, -0.01335459f, -0.20520002f, -0.08940008f, -0.04576876f, 0.06393036f, -0.01876646f, -0.00584527f, 
    0.09474690f, -0.01230125f, 0.31802312f, 0.01503810f, -0.00167723f, -0.03395306f, -0.02178599f, 0.19169925f, 
    0.06393810f, 0.12670211f, -0.13606231f, 0.00133534f, 0.36441740f, 0.12369104f, -0.05790422f, 0.16231336f, 
    0.02381466f, -0.00172265f, -0.01547358f, 0.04356357f, 0.06551502f, -0.05964483f, 0.07213250f, 0.06561788f, 
    -0.32625827f, 0.29570422f, -0.33336964f, -0.05769913f, -0.02815988f, -0.16852753f, 0.03012931f, 0.02489005f, 
    0.07845921f, -0.00453651f, 0.07113121f, -0.03494487f, -0.15136883f, 0.20412029f, -0.11743370f, 0.02277691f, 
    0.05478337f, 0.14492206f, 0.18692707f, -0.01297582f, 0.20443137f, 0.12879716f, -0.01666120f, -0.03259839f, 
    -0.24753252f, 0.06918386f, -0.03524275f, 0.11704596f, 0.12623428f, 0.08694632f, 0.12052005f, -0.06005510f, 
    0.07855051f, -0.10163873f, -0.05362826f, 0.18452069f, 0.23452625f, 0.16008225f, 0.04397580f, -0.22777967f, 
    0.17118613f, -0.02211870f, -0.02619390f, 0.03956170f, -0.07367308f, -0.07417142f, -0.05493670f, 0.09888993f, 
    0.01897244f, -0.25794843f, 0.14157452f, 0.30855197f, 0.12428761f, 0.03192524f, -0.03462336f, 0.10856166f, 
    0.10761437f, 0.08107135f, -0.08482509f, 0.07596696f, -0.35255873f, -0.03004032f, 0.07849500f, -0.09788904f, 
    -0.03170042f, -0.01029831f, 0.11279473f, -0.19717406f, 0.03009025f, -0.05078468f, 0.07171445f, 0.09526667f, 
    -0.37742203f, -0.15821354f, 0.15368821f, -0.22871576f, 0.13040414f, -0.00885764f, -0.07032680f, 0.04738932f, 
    -0.10417746f, 0.07705557f, -0.07074515f, 0.06225316f, -0.26198184f, -0.14234917f, -0.00048221f, -0.13666251f, 
    -0.07602254f, -0.00146347f, 0.08331235f, -0.15201451f, 0.05730379f, -0.06605953f, 0.03104364f, 0.07393593f, 
    -0.06801042f, 0.02466638f, -0.01163921f, 0.05520408f, 0.05849943f, 0.00398279f, -0.01553604f, -0.06605617f, 
    -0.02358798f, -0.06797008f, 0.05396258f, -0.02185537f, 0.01525335f, -0.05201680f, -0.03426153f, -0.02280564f, 
    0.06236751f, 0.05828173f, 0.00635751f, 0.06559384f, 0.00084076f, -0.05007549f, -0.06913178f, 0.00659071f, 
    -0.06989953f, -0.00475998f, -0.04644154f, 0.05823362f, -0.00824852f, 0.02239012f, -0.00671285f, -0.04714951f, 
    0.06230818f, -0.06499915f, -0.05599194f, 0.01284966f, 0.04963161f, -0.00685645f, 0.02234766f, 0.02140951f, 
    -0.01269838f, -0.06055574f, 0.03468569f, -0.05103777f, -0.06418342f, -0.03583391f, 0.06346435f, -0.04263383f, 
    -0.03936660f, 0.06313665f, -0.04509453f, 0.06135306f, -0.06371625f, -0.02245352f, 0.03049879f, -0.02299564f, 
    -0.00519067f, -0.00817724f, -0.01468554f, 0.00427651f, -0.00261287f, 0.03487317f, -0.03536561f, -0.00889735f, 
    -0.00865736f, -0.01697123f, 0.02654148f, -0.03989199f, 0.04231293f, 0.02578037f, 0.01635665f, -0.04076749f, 
    0.02621316f, -0.02576718f, 0.03885575f, -0.03748155f, -0.05250051f, -0.06688504f, 0.03120700f, -0.06778113f, 
    0.00780048f, -0.07054093f, 0.00800873f, -0.04945230f, -0.00943547f, 0.01675555f, 0.01754726f, 0.02955728f, 
    -0.03828831f, -0.02276213f, 0.00364418f, 0.00550092f, 0.04438592f, -0.07016502f, 0.00472441f, -0.06601031f, 
    -0.05382101f, -0.02136383f, 0.01632247f, 0.05285200f, -0.04454375f, -0.01495958f, -0.04909837f, 0.06849764f, 
    -0.01237139f, -0.00457807f, 0.05175890f, -0.01297022f, -0.06928344f, -0.06123668f, -0.00736666f, -0.00059572f, 
    -0.06102689f, -0.06967372f, -0.04113939f, 0.02514521f, -0.03639409f, -0.05304804f, -0.01080572f, -0.05316430f, 
    0.03162283f, -0.04380668f, 0.03842579f, -0.04796486f, 0.01787119f, -0.00523508f, -0.07488202f, -0.03629611f, 
    -0.05489898f, -0.01100057f, -0.06219527f, -0.03959908f, 0.05202203f, -0.05931854f, 0.03476368f, -0.04929018f, 
    0.02449471f, 0.04421765f, -0.01963735f, 0.02308427f, 0.06083484f, 0.04358941f, -0.00907367f, -0.05683096f, 
    0.01708396f, -0.06791855f, -0.01000514f, -0.07271449f, 0.02654855f, 0.00287450f, -0.00795545f, 0.02200903f, 
    0.04047339f, -0.03963521f, 0.05346050f, -0.03996726f, 0.03228337f, 0.02908622f, -0.03039571f, -0.05665014f, 
    0.01314758f, -0.01601779f, -0.02117927f, -0.07623055f, -0.00160676f, 0.03411183f, -0.00508182f, 0.00847423f, 
    0.01628244f, 0.00676286f, -0.06218841f, -0.03508525f, 0.00501482f, 0.03027925f, 0.04475853f, 0.04293755f, 
    -0.01111140f, 0.06290477f, -0.07665017f, -0.04352253f, -0.01936912f, -0.01072443f, 0.01563803f, -0.05298271f, 
    0.06527983f, 0.00328258f, -0.07214123f, 0.02465743f, 0.01469532f, -0.05724085f, 0.03219277f, 0.04667648f, 
    -0.21415462f, -0.05003420f, -0.06789358f, -0.17155084f, 0.29420269f, -0.12500766f, -0.02145270f, 0.02904656f, 
    0.12466206f, -0.12040790f, 0.06139854f, 0.18631537f, 0.38298327f, 0.27035743f, -0.40513396f, 0.05975007f, 
    -0.07489324f, 0.18215311f, -0.00906291f, 0.06116970f, -0.02251722f, -0.11654264f, 0.03678190f, -0.05901960f, 
    0.48107421f, 0.15620469f, 0.11023264f, 0.15181945f, -0.05301991f, 0.00786889f, 0.06185499f, 0.17601274f, 
    -0.09110390f, -0.00716894f, 0.03818032f, -0.10761430f, 0.24782051f, -0.08632004f, -0.17110114f, 0.37695134f, 
    0.32814831f, 0.02770836f, 0.20375162f, -0.16077863f, 0.05136150f, 0.12118033f, 0.04000985f, 0.01069954f, 
    -0.07504874f, -0.07955801f, -0.28945342f, -0.00915665f, 0.17615534f, -0.06426580f, 0.12112872f, -0.04424579f, 
    0.14321463f, 0.02569640f, 0.10214265f, -0.20536867f, 0.22109780f, -0.05785482f, -0.38436779f, -0.19573557f, 
    -0.00320604f, -0.11691858f, -0.00898864f, -0.07354661f, 0.17381963f, 0.10441909f, 0.02333324f, 0.13248789f, 
    -0.01556257f, 0.00430391f, -0.21204901f, 0.04637204f, 0.10720883f, -0.02242612f, -0.14064859f, -0.01427472f, 
    0.10037339f, 0.05714259f, 0.08593366f, 0.00042555f, -0.13660470f, 0.01269437f, 0.07649052f, -0.02188936f, 
    0.08672545f, 0.06049777f, -0.14863575f, -0.01617544f, 0.04583507f, 0.13161156f, -0.16603585f, 0.12137143f, 
    0.48215476f, -0.09666231f, 0.36661676f, 0.18877880f, 0.01292657f, -0.11083210f, 0.04299893f, -0.04719306f, 
    0.03732236f, 0.02805602f, -0.13914743f, 0.12335187f, 0.29858994f, 0.00973990f, 0.07257760f, 0.11779122f, 
    -0.02258212f, -0.06439021f, -0.08533191f, 0.12103994f, -0.10470186f, -0.06676569f, 0.14309458f, 0.04058097f, 
    0.14127655f, -0.26854271f, -0.02736513f, -0.35548159f, 0.06873170f, 0.04200798f, 0.09306982f, -0.10546306f, 
    -0.05472636f, 0.02185220f, 0.13910139f, -0.14814509f, -0.23446788f, -0.02407219f, 0.08831616f, 0.16837795f, 
    -0.07098097f, -0.12589614f, -0.11221201f, -0.06142789f, 0.11734200f, 0.13309684f, 0.09717873f, -0.05112623f, 
    0.08497901f, 0.14356188f, -0.01219590f, -0.15347284f, -0.18805344f, 0.00874542f, -0.00226628f, -0.18038531f, 
    -0.01045506f, 0.03247752f, 0.14761005f, 0.13316128f, 0.41054586f, 0.08878499f, -0.13078164f, 0.30499011f, 
    -0.03923122f, -0.07556484f, 0.07177947f, -0.03265903f, 0.06323840f, -0.01636937f, 0.06460320f, -0.04672825f, 
    0.22017665f, -0.10216983f, -0.37041703f, -0.22752406f, 0.06853741f, 0.07548255f, 0.02800361f, -0.05298771f, 
    0.19911322f, 0.02012054f, 0.05945877f, 0.09708361f, 0.24571741f, 0.16816048f, 0.03020792f, 0.18899323f, 
    -0.11759565f, 0.08498702f, -0.11172082f, 0.13671838f, 0.03411151f, 0.08063804f, 0.03368992f, -0.04451608f, 
    -0.16401054f, 0.01266985f, 0.26646692f, 0.07519656f, -0.14825450f, 0.15035889f, 0.15471126f, -0.18589622f, 
    0.24581845f, -0.05236304f, 0.01332074f, -0.00055551f, 0.00746363f, -0.21816403f, -0.15985391f, 0.03649025f, 
    -0.02083056f, 0.06164647f, 0.11270531f, -0.10172089f, 0.14951172f, -0.03725860f, 0.28538853f, 0.14830653f, 
    0.12078027f, 0.04014146f, -0.23667511f, -0.15946154f, -0.04690457f, -0.00337488f, -0.09193528f, 0.01225752f, 
    0.06936584f, -0.07379094f, 0.03150756f, -0.03887840f, -0.09464069f, 0.11190045f, -0.35424989f, 0.13773252f, 
    0.06554847f, 0.14940089f, 0.05736857f, 0.09781949f, 0.14015731f, -0.00877737f, -0.06264404f, 0.16182083f, 
    -0.00131691f, -0.10070365f, 0.01227726f, -0.08529556f, -0.17889805f, -0.03064717f, -0.03928441f, 0.13176221f, 
    -0.00117707f, 0.03810029f, 0.18486367f, 0.15651277f, -0.09531598f, 0.15500373f, -0.25483143f, -0.01251302f, 
    0.07479566f, 0.12096515f, 0.14765300f, -0.16644262f, -0.02122468f, 0.03813609f, 0.18380886f, 0.12511246f, 
    -0.06919454f, 0.18224977f, 0.21224578f, -0.22301345f, 0.09493972f, -0.09378803f, 0.08698971f, 0.13046549f, 
    -0.09427755f, 0.13758503f, -0.01483976f, 0.10726772f, -0.11368233f, -0.19690967f, -0.07951418f, -0.13719848f, 
    -0.04939049f, 0.00450339f, 0.13287115f, 0.20681386f, 0.10475234f, 0.07430200f, 0.10685910f, -0.07500787f, 
    0.02168032f, -0.17568253f, -0.05362061f, 0.11148763f, -0.08581375f, 0.16591689f, -0.03910678f, -0.01592151f, 
    0.09202011f, -0.01650440f, -0.03986371f, -0.01621634f, -0.43200523f, -0.03489128f, -0.17653348f, -0.10843655f, 
    0.19311205f, 0.10437512f, -0.05522112f, -0.08657574f, 0.05796810f, 0.05170754f, 0.09021981f, 0.08644672f, 
    0.19401924f, 0.38558412f, 0.25123808f, 0.36549249f, -0.04484499f, -0.02442504f, -0.02668528f, -0.16260372f, 
    0.02169740f, -0.15556173f, -0.01329706f, 0.22921875f, -0.21038459f, -0.24301045f, 0.19254121f, -0.17548299f, 
    0.28030947f, -0.19340722f, 0.03906853f, 0.08134225f, 0.18083914f, 0.00579615f, -0.14791659f, 0.06556815f, 
    -0.16288723f, -0.00167906f, -0.00691931f, -0.09419503f, 0.11996970f, -0.01991922f, 0.03838759f, 0.02152551f, 
    0.02895585f, 0.02995494f, -0.13824727f, 0.07571859f, -0.17087704f, -0.30337954f, 0.11523038f, -0.27048045f, 
    -0.17495371f, 0.21502180f, -0.08131958f, -0.00833787f, 0.01206571f, 0.16340595f, -0.00711009f, 0.01477747f, 
    -0.09436771f, 0.49917603f, 0.45107955f, 0.25394595f, 0.10328207f, 0.12975533f, -0.01181671f, 0.03955949f, 
    0.10680582f, 0.05739359f, 0.12438115f, 0.14128233f, -0.10967892f, -0.27163228f, -0.18690401f, 0.11925816f, 
    -0.02958748f, -0.09248682f, 0.25102699f, -0.20215312f, 0.11430784f, 0.07754286f, 0.12447026f, 0.08019957f, 
    -0.22456975f, 0.02934326f, 0.00360842f, -0.07550947f, -0.13834888f, 0.10072400f, 0.16480075f, 0.09422710f, 
    0.07950482f, -0.27446029f, -0.02343524f, 0.05162534f, 0.09912747f, -0.07878689f, 0.08310913f, -0.09464448f, 
    -0.00138303f, -0.06752215f, 0.05648420f, -0.11309574f, 0.02792609f, 0.05238136f, 0.00382401f, -0.11956817f, 
    0.09954447f, 0.39969406f, 0.00994159f, 0.03681293f, -0.14661509f, 0.02782019f, 0.04330693f, -0.01389936f, 
    0.04183498f, -0.04619694f, -0.05310781f, -0.24608560f, 0.22019306f, 0.25519770f, -0.23659883f, -0.16126460f, 
    -0.18135171f, -0.02766403f, -0.00930186f, -0.10829740f, 0.05142767f, 0.02794387f, -0.02052629f, 0.15699218f, 
    -0.50112849f, -0.27308157f, -0.02073969f, -0.00012491f, -0.04637955f, -0.07148145f, -0.20790176f, 0.04439647f, 
    0.06214958f, -0.02249651f, 0.00855714f, 0.01875675f, 0.12145540f, 0.44435173f, 0.11362159f, -0.36423418f, 
    0.07840261f, -0.15267363f, 0.29720664f, 0.06454717f, 0.12825032f, 0.22714749f, 0.03598903f, 0.15785663f, 
    -0.04785790f, -0.30766582f, -0.06307475f, -0.01674519f, -0.03095205f, -0.09358080f, 0.02418124f, -0.10606473f, 
    0.03740504f, -0.03038685f, -0.05463763f, 0.13970229f, -0.09490894f, 0.14335427f, 0.15084796f, -0.08385070f, 
    -0.01374455f, -0.11901782f, 0.09601096f, 0.28343490f, -0.01485245f, 0.06965623f, 0.03978656f, -0.17604387f, 
    -0.30042720f, 0.06848241f, 0.17127566f, -0.05097395f, 0.12344098f, 0.14652413f, 0.05163972f, 0.03540839f, 
    -0.09701617f, -0.02965482f, -0.07280765f, -0.22699273f, 0.06744617f, 0.06381493f, 0.09820318f, 0.13870724f, 
    0.01042455f, 0.08568977f, 0.02469428f, -0.02863530f, 0.00172289f, -0.10047120f, 0.18703349f, 0.07975491f, 
    0.49390465f, 0.40795895f, 0.26234716f, 0.26516363f, 0.09654888f, -0.02304416f, -0.29585981f, -0.04607659f, 
    0.08153458f, 0.05784503f, 0.06182835f, -0.14412582f, -0.62434793f, 0.10556741f, 0.02361941f, -0.12727062f, 
    0.06726488f, -0.10784264f, -0.04721330f, 0.07871430f, -0.00008797f, 0.17531140f, -0.10307892f, -0.06224534f, 
    -0.15928309f, 0.00293709f, 0.04946759f, -0.23612070f, 0.10649031f, 0.05950948f, -0.15015800f, 0.18648449f, 
    -0.08103701f, -0.09257150f, 0.15445635f, 0.02111590f, -0.21775252f, 0.03613683f, 0.15738454f, -0.10504560f, 
    0.17707098f, 0.11548177f, 0.13961740f, 0.08196031f, 0.13821238f, 0.06109101f, 0.11575074f, -0.17325301f, 
    0.11757214f, 0.00065562f, 0.15029034f, 0.67143810f, 0.06101187f, 0.12086962f, 0.05556883f, 0.05695360f, 
    -0.04589751f, -0.02172142f, -0.02686493f, 0.02039920f, -0.29542279f, 0.01277088f, 0.09711097f, 0.30819398f, 
    0.20879804f, -0.03425385f, 0.21053818f, 0.06145694f, 0.14807571f, -0.02306107f, 0.08291768f, -0.03070234f, 
    -0.05749979f, -0.05927169f, -0.05580684f, -0.00806401f, -0.06274495f, -0.01224125f, -0.05442021f, -0.02240096f, 
    -0.01114075f, 0.01705989f, -0.03357084f, 0.05246332f, -0.05175465f, -0.07065029f, 0.03522174f, -0.06599246f, 
    0.02988330f, -0.02958872f, 0.00043756f, 0.01618155f, -0.05370589f, 0.02295406f, -0.06733980f, -0.00690154f, 
    0.03830937f, 0.00649584f, 0.06457052f, -0.07167728f, 0.03361559f, 0.05496398f, 0.04153937f, 0.05056340f, 
    -0.03120799f, -0.01413782f, -0.02151351f, -0.04081862f, 0.04860713f, 0.00291276f, 0.00115223f, -0.04254652f, 
    -0.01932120f, -0.02005419f, 0.01430598f, -0.00160271f, 0.06265444f, -0.05679468f, -0.03670844f, 0.02014801f, 
    0.02842495f, 0.07029983f, -0.01253744f, 0.06155242f, -0.00297215f, -0.04093894f, -0.04936599f, 0.01087347f, 
    0.01738151f, -0.06830508f, 0.04545544f, 0.03507081f, 0.06710196f, 0.03357092f, 0.02107807f, -0.00418679f, 
    -0.05926183f, -0.02942396f, 0.04039713f, 0.07114854f, -0.05346238f, 0.07192819f, 0.03428429f, 0.00974012f, 
    -0.00352346f, -0.00724868f, 0.03991906f, -0.04507024f, -0.05046249f, 0.01969039f, -0.02942882f, -0.04623101f, 
    -0.00849229f, 0.02289606f, -0.07211973f, 0.02054442f, -0.04364851f, -0.03557821f, 0.04331156f, -0.05879102f, 
    -0.05248391f, 0.05205971f, -0.01874907f, -0.06956697f, -0.01261212f, -0.02176423f, -0.06157428f, -0.04591619f, 
    0.00114621f, -0.03888914f, -0.01595023f, -0.03980482f, -0.02791557f, 0.06987759f, -0.05105185f, 0.02744847f, 
    -0.02783806f, 0.05973988f, 0.01180100f, 0.07150970f, -0.04097955f, 0.00717467f, 0.03218190f, 0.04549884f, 
    0.04725690f, -0.05142699f, -0.00433552f, 0.01014956f, 0.05361198f, -0.04051506f, -0.05348605f, 0.02021460f, 
    -0.01660761f, 0.01748342f, -0.06473862f, -0.05085285f, 0.02213245f, 0.01012609f, -0.06429131f, 0.02092879f, 
    -0.06534402f, -0.03052858f, 0.03860392f, -0.02762566f, -0.03736798f, -0.04914828f, 0.00531050f, -0.05847283f, 
    -0.03231057f, 0.00423378f, -0.01968770f, 0.04013108f, -0.05326882f, -0.04888045f, -0.06711916f, -0.05735998f, 
    -0.02416618f, -0.01981671f, -0.01077680f, 0.01516667f, -0.03746595f, 0.06160263f, -0.04202772f, -0.00827887f, 
    -0.01204450f, -0.02473717f, -0.05668128f, -0.04722484f, 0.04772461f, 0.06036058f, 0.06303203f, 0.01529042f, 
    -0.07080099f, 0.00158442f, -0.06662934f, 0.04757483f, 0.01320382f, -0.01801497f, -0.05369426f, 0.00623130f, 
    -0.02168436f, -0.01521849f, -0.02424004f, -0.02943544f, -0.01128251f, 0.03469751f, -0.03586004f, 0.03653196f, 
    0.06352348f, -0.03148090f, -0.01111667f, -0.06020945f, 0.02232428f, -0.00891863f, -0.06459896f, -0.05751796f, 
    -0.05491529f, -0.05967763f, -0.00778178f, -0.01537491f, -0.04100468f, -0.01835230f, -0.00619766f, 0.02214240f, 
    0.14987133f, 0.00327974f, -0.00339681f, 0.17529307f, -0.04492922f, 0.07307434f, -0.20081039f, 0.04111760f, 
    -0.07310615f, 0.22907667f, -0.08371025f, 0.06027070f, -0.15433982f, -0.14087221f, 0.33848560f, 0.05731189f, 
    0.16154787f, -0.02963736f, 0.05528538f, 0.02730926f, 0.17610209f, 0.02369416f, -0.08685707f, -0.01194171f, 
    0.09408673f, -0.43786550f, -0.05955347f, -0.10470486f, 0.06537130f, -0.03052120f, -0.10175025f, 0.22568254f, 
    0.05534424f, -0.11220858f, 0.05196761f, 0.38711426f, 0.12611978f, 0.28525871f, 0.25623900f, -0.16978599f, 
    -0.31298667f, 0.01935587f, -0.03918183f, 0.31617621f, -0.17198583f, 0.05238646f, 0.18979350f, -0.15186119f, 
    0.16649835f, 0.10534199f, -0.00662045f, -0.23161748f, -0.07971735f, 0.22651787f, -0.08042626f, 0.10779998f, 
    -0.03313048f, 0.05115578f, -0.08666044f, 0.19140838f, 0.00722595f, 0.20251997f, 0.29288626f, 0.17947587f, 
    0.01241795f, 0.09107183f, -0.02536558f, 0.06116710f, -0.14498378f, -0.17483330f, -0.10476670f, -0.06098243f, 
    -0.12273362f, 0.27968797f, 0.16945401f, 0.07812917f, 0.04435536f, 0.10186596f, 0.31201154f, -0.02493591f, 
    -0.07706938f, -0.12775087f, 0.00577783f, -0.06687369f, 0.02492350f, 0.03041430f, -0.10236136f, -0.51519054f, 
    -0.11649218f, -0.04961878f, 0.10189349f, -0.05288875f, -0.08385878f, 0.01387280f, 0.26794636f, 0.13246201f, 
    0.34577438f, -0.17811924f, -0.07798452f, 0.06637654f, -0.15473317f, 0.15851156f, 0.04859529f, 0.07058919f, 
    0.01597233f, 0.13615142f, 0.22916755f, -0.03380447f, -0.17322561f, -0.06537796f, -0.04662989f, -0.32335487f, 
    -0.18521221f, -0.18705718f, -0.12939893f, 0.02768868f, 0.08878399f, 0.11931616f, -0.04129304f, 0.12514885f, 
    0.33325914f, 0.23011313f, 0.20945741f, 0.60265201f, -0.11678069f, 0.12601584f, 0.07121935f, 0.22934140f, 
    -0.03074336f, 0.15362677f, 0.02405027f, 0.02239253f, 0.70968622f, -0.24863887f, 0.16775367f, -0.07892658f, 
    -0.10484350f, 0.05577578f, 0.19146220f, -0.03008403f, -0.10032184f, -0.13022089f, -0.04213434f, -0.05290252f, 
    -0.27573079f, -0.03651467f, -0.26447159f, -0.02090812f, 0.07906174f, 0.09730484f, 0.10527259f, 0.19910261f, 
    -0.09152011f, 0.15640852f, 0.14850481f, 0.07346465f, 0.07195659f, 0.21331520f, 0.10927553f, -0.31915081f, 
    -0.02981921f, -0.03115471f, -0.20860566f, 0.11995808f, -0.07979907f, 0.18085994f, 0.03858512f, 0.14979829f, 
    -0.17904814f, 0.29794103f, 0.37681058f, 0.46170872f, 0.01390151f, -0.02276061f, 0.17579490f, 0.18926218f, 
    -0.21309319f, -0.02876320f, -0.07338836f, -0.17150174f, 0.04986412f, 0.21602495f, 0.15728819f, -0.40152210f, 
    0.04871200f, -0.12814675f, -0.05653552f, -0.05381592f, -0.01666273f, -0.00209890f, 0.05058946f, 0.14726818f, 
    -0.08289444f, -0.08351695f, 0.00990905f, 0.01351585f, 0.01579546f, -0.02786378f, -0.05081767f, -0.07610705f, 
    -0.02594578f, -0.08238675f, -0.12647352f, 0.03372348f, -0.00092781f, -0.06690053f, -0.05931183f, -0.00179318f, 
    -0.01135180f, 0.02120252f, -0.05131771f, 0.03902341f, -0.03489766f, -0.01460679f, 0.04474524f, 0.04781951f, 
    -0.05096660f, 0.02582406f, -0.03285797f, -0.06490967f, -0.06182632f, 0.02487066f, -0.06169608f, -0.01936750f, 
    -0.07209742f, -0.01600312f, 0.05067673f, -0.05417574f, -0.00917307f, -0.01315828f, -0.03280769f, -0.01006031f, 
    -0.06475919f, -0.05285757f, -0.01450823f, -0.09519916f, 0.05361229f, -0.02832155f, 0.02189197f, 0.03120801f, 
    -0.03565868f, -0.07421733f, -0.09794304f, -0.02719851f, -0.03188377f, 0.02674317f, -0.06395463f, -0.04073287f, 
    -0.08349748f, 0.03316316f, -0.02808529f, 0.03408283f, 0.03644238f, -0.05696465f, -0.08338289f, 0.02517440f, 
    -0.02181871f, -0.05734271f, -0.04686539f, -0.00766810f, 0.04010713f, -0.01208594f, -0.06588918f, -0.07346848f, 
    -0.06598272f, -0.06876817f, -0.01806716f, 0.00177929f, -0.05008347f, -0.08452894f, -0.05116302f, 0.03936857f, 
    -0.12051104f, -0.09093438f, 0.00461938f, 0.03204197f, -0.10945278f, -0.01836669f, -0.04918449f, -0.02992513f, 
    0.01761397f, -0.06239470f, 0.03281279f, -0.10524086f, 0.03380321f, -0.02624831f, -0.00074039f, -0.00477160f, 
    -0.00737803f, 0.04593249f, 0.00724340f, -0.06744126f, -0.03534525f, -0.08143464f, -0.04117364f, 0.00659368f, 
    -0.05822718f, 0.01974027f, -0.03494414f, 0.06205776f, -0.02704394f, -0.01363705f, -0.09052177f, -0.07497248f, 
    -0.04774189f, -0.09010704f, -0.09522425f, -0.02186196f, 0.02943758f, -0.02592055f, -0.01174086f, -0.02916478f, 
    -0.01502962f, -0.01635273f, 0.03291903f, -0.08790646f, -0.01658862f, -0.05481365f, 0.03831332f, -0.00708408f, 
    0.04749792f, -0.05946653f, 0.01734275f, -0.07772419f, -0.06254597f, -0.02272788f, -0.01111664f, -0.02306943f, 
    -0.09036776f, 0.02736422f, 0.00109020f, -0.08493351f, -0.06489080f, -0.08633493f, -0.02249277f, 0.00823434f, 
    -0.00788037f, 0.01642685f, -0.05809372f, -0.06837645f, 0.01694698f, 0.02142770f, -0.00640782f, 0.03546932f, 
    -0.01130498f, -0.07214694f, -0.07432836f, -0.07220420f, 0.04509223f, 0.00616761f, -0.09488335f, -0.06183102f, 
    0.01341970f, 0.00901411f, -0.03855247f, -0.02612548f, -0.06624376f, -0.02142510f, 0.03970569f, -0.04300236f, 
    -0.06053038f, -0.02282186f, 0.03432573f, 0.05436303f, -0.07583500f, -0.06249944f, 0.06572148f, -0.03120247f, 
    0.02774292f, -0.05676148f, -0.04234008f, 0.03716346f, -0.08181665f, -0.10576861f, -0.03698577f, 0.01777214f, 
    -0.04754288f, -0.07883525f, -0.02814277f, 0.04636881f, 0.04927529f, -0.03209738f, -0.00670944f, -0.06521047f, 
    0.07430893f, -0.05186988f, -0.00087756f, -0.05579325f, 0.24613784f, 0.02019345f, -0.14039868f, -0.09125041f, 
    0.13445951f, 0.15366647f, 0.05455039f, -0.01923897f, 0.16148125f, -0.00956820f, -0.15768979f, 0.14284153f, 
    -0.07964707f, 0.12264929f, 0.02140414f, 0.04042936f, 0.13839813f, -0.00216939f, 0.03434920f, 0.05470582f, 
    0.47990936f, -0.22249949f, 0.04387000f, 0.06742711f, -0.09343206f, -0.05469237f, 0.11396640f, 0.07389057f, 
    -0.07784631f, -0.07365710f, -0.07068183f, 0.03749239f, -0.24973866f, -0.21935236f, -0.08293504f, 0.11950852f, 
    0.14919777f, -0.04740298f, 0.09664256f, 0.11578442f, 0.14639957f, 0.20106675f, 0.30384040f, 0.04993403f, 
    0.33747357f, 0.15547390f, 0.09127375f, -0.08761163f, 0.10932192f, -0.00558955f, 0.03747774f, 0.03922083f, 
    -0.04375637f, 0.05802041f, -0.00033698f, -0.11488737f, 0.03376332f, 0.01932128f, -0.27914110f, -0.10413215f, 
    0.09584209f, 0.06921131f, 0.06675018f, -0.13727011f, -0.00236740f, -0.08053112f, -0.06615093f, -0.06429537f, 
    -0.10111240f, 0.14740211f, 0.01605432f, 0.06296167f, 0.12048093f, -0.17245176f, 0.04462229f, -0.01079511f, 
    0.03307325f, 0.13309616f, 0.08550594f, 0.04136460f, 0.06523734f, -0.00744590f, -0.12414706f, -0.21959133f, 
    0.02203487f, 0.09697713f, 0.07224897f, 0.11465821f, 0.08061046f, -0.07214590f, -0.08486509f, -0.04324046f, 
    0.57771498f, -0.20595393f, 0.16967419f, 0.29460996f, -0.22747040f, -0.15222855f, -0.06855851f, 0.25733161f, 
    0.14808956f, -0.11262710f, -0.01624781f, -0.00648930f, -0.21618210f, 0.06313057f, 0.09252517f, -0.00689727f, 
    -0.11160137f, 0.05832210f, -0.11860333f, 0.00633144f, -0.11197807f, 0.02281733f, 0.01118648f, -0.06281080f, 
    -0.15027680f, 0.04883110f, -0.13324785f, -0.04722891f, -0.06895149f, 0.14184421f, 0.17512225f, -0.09871814f, 
    -0.04825226f, -0.00218714f, -0.05734880f, 0.02905186f, 0.50945008f, -0.37686241f, 0.13848840f, 0.08701991f, 
    -0.06766129f, -0.04465470f, 0.15751612f, 0.03378051f, 0.05821210f, 0.11410141f, 0.03420862f, 0.08571105f, 
    -0.17554715f, 0.12809585f, -0.16855559f, -0.21956307f, 0.10792398f, -0.13629103f, 0.22694212f, -0.20967808f, 
    -0.13290311f, -0.06851403f, 0.02805898f, -0.05191337f, 0.48083875f, 0.15323479f, 0.10973909f, 0.24442539f, 
    -0.10314908f, -0.10770082f, -0.01965511f, 0.09293848f, -0.03586379f, 0.06244137f, -0.11407173f, 0.01367820f, 
    -0.59505576f, 0.11176570f, -0.07395352f, -0.37367755f, -0.01010053f, 0.07132525f, -0.07945249f, 0.00146428f, 
    0.32652438f, 0.15199468f, 0.07389908f, 0.09443401f, 0.58598173f, 0.28309226f, 0.07884810f, 0.12391882f, 
    -0.08253083f, 0.09766091f, 0.03055663f, 0.10394046f, -0.16217682f, 0.15551329f, 0.05628459f, 0.01977255f, 
    -0.01529615f, 0.04549785f, 0.04914356f, 0.02232759f, 0.04215073f, -0.00697345f, 0.01216422f, -0.03165791f, 
    0.02369065f, -0.04421329f, -0.05492218f, 0.01861098f, -0.04585454f, -0.07143213f, -0.02293864f, 0.03971569f, 
    -0.06986400f, -0.01958966f, 0.06281295f, 0.04636917f, -0.03091127f, -0.02382942f, 0.04264876f, -0.06734010f, 
    -0.07941765f, -0.01487381f, -0.03283064f, -0.04299843f, -0.08010530f, -0.00641318f, 0.05196625f, 0.02045650f, 
    -0.02459949f, 0.05198047f, 0.00270749f, -0.05610005f, 0.00623534f, 0.01926605f, 0.00884934f, 0.02803239f, 
    -0.01813513f, 0.02167636f, -0.02424555f, -0.06465878f, 0.06008064f, 0.04095768f, 0.00987311f, -0.04458536f, 
    0.03758422f, -0.05053032f, 0.05733246f, 0.05463044f, -0.01207874f, -0.03193541f, 0.05990946f, 0.04647666f, 
    0.01467700f, -0.00397244f, -0.06835610f, -0.07427523f, -0.00480410f, -0.01786183f, -0.01761232f, -0.02126695f, 
    0.01662730f, -0.07735221f, 0.01710422f, 0.05929026f, 0.05631607f, 0.01896449f, 0.05205170f, -0.03011492f, 
    -0.07987610f, -0.03694648f, -0.06866995f, 0.05295346f, -0.05212696f, -0.00172578f, 0.02454635f, -0.08039062f, 
    0.06102843f, 0.01542773f, 0.05631887f, 0.01701638f, -0.03974555f, 0.00952869f, -0.01523401f, -0.01049728f, 
    -0.02175706f, -0.04191236f, 0.03679312f, -0.04535584f, -0.04920958f, -0.05744525f, 0.04952852f, -0.00803376f, 
    0.05574181f, -0.07452787f, -0.04959028f, -0.02831724f, -0.00399559f, 0.06114082f, 0.06073277f, 0.00640507f, 
    -0.04081716f, 0.04347714f, -0.06137441f, -0.03569880f, 0.03338686f, 0.00294166f, 0.04094000f, 0.05226323f, 
    0.00526786f, 0.02854456f, -0.03576443f, 0.00543227f, -0.03607573f, -0.04816854f, -0.01588033f, 0.03263739f, 
    -0.02254085f, -0.05130991f, -0.05981475f, -0.06088270f, -0.05759044f, -0.06720306f, -0.05568890f, -0.01995176f, 
    -0.06918266f, 0.01071839f, -0.04163093f, -0.01303886f, -0.02356979f, -0.05449453f, -0.01219041f, -0.07954990f, 
    -0.03210362f, 0.02412515f, -0.01329382f, -0.04385747f, -0.03023414f, 0.01978500f, -0.03600357f, 0.01977606f, 
    -0.02559246f, -0.06472848f, -0.00711212f, 0.00468490f, 0.03644001f, -0.05524643f, -0.01632240f, -0.07040492f, 
    -0.01475171f, -0.00257668f, 0.04909232f, -0.05860555f, -0.03327755f, -0.02318484f, -0.00325803f, 0.04743593f, 
    0.02497060f, 0.01812160f, -0.05791007f, -0.07792657f, 0.01229764f, 0.01378800f, -0.00187900f, -0.03075313f, 
    -0.02705961f, 0.02112649f, -0.01102084f, -0.02636551f, 0.01787113f, 0.02990193f, 0.02643584f, -0.06407674f, 
    -0.01958129f, -0.07157882f, -0.07344011f, 0.03863845f, -0.06240718f, 0.03939126f, 0.02608693f, 0.02027366f, 
    0.03641538f, 0.03104718f, 0.01207017f, -0.00310404f, -0.07672065f, -0.06617308f, 0.05690466f, 0.00766199f, 
    0.42915991f, 0.16527224f, -0.19747177f, 0.06617290f, 0.09233090f, -0.00702791f, -0.08942182f, -0.03128316f, 
    -0.07783744f, 0.29440010f, 0.24173774f, 0.42182568f, -0.29019198f, -0.12645699f, 0.14989379f, 0.19935971f, 
    0.07213416f, -0.15182105f, -0.02992424f, 0.07549889f, -0.00428251f, 0.07578881f, -0.01391291f, 0.05559549f, 
    -0.43041164f, -0.31657463f, 0.03319000f, 0.25940973f, -0.00449312f, -0.03267317f, 0.17811462f, 0.10664887f, 
    -0.19269057f, -0.03765766f, 0.15543537f, 0.26189762f, -0.19012143f, 0.16089426f, -0.07075278f, 0.26076955f, 
    0.11113407f, 0.03236985f, -0.16873075f, 0.05469299f, -0.08082210f, 0.02864845f, -0.00197173f, -0.18401644f, 
    -0.38135234f, -0.10289475f, -0.17281854f, 0.24965669f, 0.06766623f, 0.03196301f, -0.13468964f, 0.00186921f, 
    0.26870373f, -0.08262178f, -0.12030762f, -0.18456015f, 0.64900839f, -0.16596791f, -0.05191445f, 0.04207809f, 
    0.02987502f, 0.12459352f, -0.18103802f, -0.02367866f, 0.04099792f, -0.27135348f, -0.02577580f, -0.10132093f, 
    -0.00649381f, 0.12229681f, -0.10102757f, 0.16776320f, -0.02042081f, 0.31523681f, -0.18050608f, 0.02532830f, 
    0.06584243f, 0.03727483f, 0.06112278f, 0.04438841f, 0.26423645f, 0.26641253f, -0.36761039f, 0.22571281f, 
    -0.06808008f, 0.27944097f, 0.10385019f, 0.07902911f, 0.06156335f, -0.05272981f, -0.00506776f, 0.09087016f, 
    -0.08086775f, -0.06846661f, 0.18097691f, -0.03094834f, -0.09050561f, -0.15946370f, 0.12567990f, 0.13109069f, 
    0.09178145f, -0.09122097f, 0.12621102f, 0.13286416f, 0.03034960f, 0.30211890f, 0.09158264f, 0.11753023f, 
    -0.14798513f, -0.07169130f, -0.02645507f, -0.01752640f, 0.05452777f, 0.32596979f, -0.11321247f, 0.04600254f, 
    -0.41323182f, 0.10541418f, -0.21294443f, -0.15605123f, 0.06987603f, -0.07301746f, 0.06652871f, 0.13587637f, 
    0.14822744f, 0.14429407f, 0.13929889f, 0.21066459f, 0.57028371f, -0.26424319f, 0.30602774f, -0.34582004f, 
    0.03859029f, 0.11350587f, -0.07905067f, 0.10572005f, -0.03145927f, 0.04260077f, -0.02355156f, 0.05503970f, 
    0.21450144f, -0.04530333f, 0.06666496f, 0.06202419f, 0.05155276f, -0.01069856f, 0.24602148f, -0.07483297f, 
    0.11559473f, 0.22065026f, -0.05459353f, 0.14795770f, 0.29243326f, -0.09965990f, 0.23450339f, -0.03259931f, 
    -0.12587444f, -0.11391836f, -0.00741705f, 0.17915688f, -0.06414295f, -0.03334315f, 0.03903206f, 0.25431132f, 
    0.14782006f, 0.21044193f, -0.04641349f, -0.27360040f, -0.00841253f, -0.02958076f, -0.11662813f, -0.03406268f, 
    0.07721217f, 0.00755774f, -0.02703483f, -0.15221944f, 0.03186724f, 0.10089803f, 0.06744280f, 0.17670389f, 
    -0.06818434f, 0.09559809f, -0.05783349f, 0.13424063f, -0.17505765f, -0.12853557f, -0.04869326f, -0.09091686f, 
    -0.14482233f, -0.11386427f, 0.00480043f, -0.05783220f, 0.14407596f, -0.03041640f, 0.04998073f, -0.04622479f, 
    0.14170560f, 0.03807914f, -0.00374018f, -0.05858099f, 0.01921449f, 0.24343516f, -0.15636653f, 0.05132330f, 
    0.08085339f, 0.17061579f, -0.07401789f, -0.01683947f, 0.06141484f, -0.07230138f, 0.04250490f, 0.12656623f, 
    -0.12080487f, -0.04615868f, -0.14132982f, -0.09672710f, 0.28956807f, 0.08494501f, -0.00382708f, 0.18503889f, 
    0.15587862f, 0.00225168f, 0.04141721f, 0.07699741f, 0.31766725f, -0.10277161f, 0.05069041f, 0.02546474f, 
    0.14042914f, 0.03994014f, 0.27912092f, -0.00536304f, 0.13715477f, 0.00133461f, 0.02198195f, 0.06596709f, 
    0.48816669f, 0.20938000f, 0.23698290f, -0.09928330f, 0.04735091f, 0.14418040f, 0.11291359f, 0.06463784f, 
    0.01983725f, 0.03209805f, -0.02533533f, 0.34365949f, -0.40423718f, -0.05531695f, -0.16861825f, 0.01411259f, 
    -0.22221451f, 0.11463239f, 0.04818266f, -0.14448115f, 0.02422977f, -0.03948472f, 0.16518401f, 0.03273804f, 
    0.27488443f, 0.24090183f, 0.27599701f, -0.01220508f, -0.02517538f, -0.08214642f, 0.05271789f, 0.02416776f, 
    0.03872706f, 0.19088553f, 0.13438722f, 0.05610272f, -0.03219387f, -0.26867837f, 0.19526120f, -0.01002872f, 
    0.01838273f, -0.14385852f, 0.02598394f, -0.18230048f, 0.16897006f, 0.06308559f, 0.14055179f, 0.15385932f, 
    0.37591466f, -0.20159942f, -0.25560024f, 0.07719120f, 0.04237667f, 0.07463975f, 0.02061225f, 0.04171985f, 
    0.04843961f, 0.06210914f, 0.02795498f, 0.17153984f, 0.01742796f, -0.24910913f, -0.09031369f, -0.12000346f, 
    0.25602219f, 0.05960312f, -0.05230599f, 0.12005801f, 0.02636046f, -0.02614082f, -0.04599322f, -0.01680571f, 
    -0.07746041f, -0.29815149f, 0.02456106f, 0.13569170f, 0.03338670f, 0.20094760f, 0.18617912f, 0.13482764f, 
    0.01466248f, -0.04692478f, 0.02140634f, 0.15590793f, -0.31468925f, -0.04014916f, 0.00110852f, 0.23238797f, 
    0.11317620f, -0.08706795f, -0.04532792f, 0.16064687f, 0.18479273f, -0.06893317f, -0.05754513f, 0.14578865f, 
    -0.03105627f, 0.05493187f, -0.14462124f, -0.09010378f, -0.16574207f, 0.02247602f, -0.09461343f, 0.07691154f, 
    0.13326035f, 0.08926246f, 0.04714496f, 0.03338002f, 0.15109825f, -0.21825828f, -0.36431149f, -0.06361172f, 
    0.01958229f, 0.17915139f, -0.06883717f, 0.01592940f, 0.03830838f, 0.11409568f, -0.07811598f, -0.03700380f, 
    0.54302478f, 0.46138877f, 0.26590991f, -0.00008397f, -0.05554039f, 0.04367312f, -0.01822639f, 0.09496333f, 
    0.15919659f, 0.10999509f, 0.09136006f, 0.11993052f, 0.12576653f, -0.32722777f, -0.15798596f, -0.19947517f, 
    -0.11946741f, -0.05229976f, -0.06087533f, -0.09839933f, -0.02068178f, 0.07373517f, -0.10699043f, 0.01938324f, 
    0.05750960f, 0.03857493f, 0.20469992f, 0.23269261f, -0.06707213f, 0.12865570f, 0.01128366f, -0.01592139f, 
    0.19719335f, 0.13740681f, 0.02469421f, -0.02597758f, -0.39979166f, 0.09722479f, 0.13511094f, 0.04305109f, 
    -0.02393035f, 0.06246190f, 0.01279168f, 0.17000417f, -0.03110979f, -0.01507958f, -0.00558438f, -0.01951825f, 
    0.19644536f, 0.09134068f, -0.20013185f, -0.46962479f, 0.04001796f, 0.16683745f, 0.12244471f, 0.04036633f, 
    0.00448033f, 0.07737898f, -0.13659148f, -0.05688647f, -0.17495409f, -0.12675944f, 0.07822020f, -0.37741524f, 
    -0.14516635f, 0.05349195f, 0.01159928f, 0.11699264f, 0.09205152f, 0.07580666f, 0.07911209f, 0.00325014f, 
    0.59718221f, 0.22757044f, 0.21145451f, 0.20551470f, 0.02901312f, -0.16214265f, -0.02897343f, -0.04366731f, 
    -0.17442524f, 0.21026506f, 0.01349803f, 0.03754533f, -0.16672082f, 0.04253872f, 0.10402819f, 0.06631269f, 
    0.06417170f, -0.06854848f, -0.03765221f, 0.04559100f, -0.05201943f, 0.00697327f, 0.03470274f, 0.20574577f, 
    -0.05392723f, -0.00720312f, -0.03307762f, 0.04558024f, 0.04643053f, -0.31116104f, -0.17270933f, 0.13233039f, 
    0.00753336f, 0.02206475f, 0.09355275f, -0.04653618f, 0.03520751f, -0.01769694f, 0.11042126f, -0.31187841f, 
    0.02408704f, 0.11319399f, 0.12540685f, 0.03657829f, 0.18556173f, -0.12849091f, 0.04519235f, 0.00786373f, 
    -0.19370206f, 0.12364736f, 0.07867128f, -0.02558098f, 0.05782409f, -0.14235978f, 0.14384140f, 0.04625062f, 
    -0.01301234f, -0.13924915f, 0.04406109f, -0.25157967f, -0.21069519f, 0.19089678f, -0.02221784f, -0.15795553f, 
    -0.16464326f, 0.08626392f, -0.10835996f, 0.03535898f, 0.23051739f, 0.05264093f, -0.11404505f, 0.06045460f, 
    0.18043615f, 0.10782839f, -0.06013150f, -0.03581794f, -0.01434148f, -0.04161270f, 0.00250055f, -0.25419858f, 
    0.08638552f, -0.01405047f, -0.00325747f, -0.14614791f, 0.14595410f, 0.15551010f, 0.00634891f, 0.36941195f, 
    -0.01440070f, -0.01000087f, 0.06856925f, 0.00570144f, -0.03726674f, -0.09150314f, -0.05398375f, -0.05861419f, 
    -0.19972242f, 0.22478090f, 0.12284598f, 0.08029260f, 0.23121911f, 0.08920453f, -0.09532684f, 0.06551191f, 
    -0.23057774f, -0.10977343f, 0.01449964f, 0.05374307f, 0.41095439f, 0.29927942f, -0.05284109f, -0.12263194f, 
    -0.08759317f, 0.15040784f, 0.14858128f, 0.01376590f, 0.12089149f, -0.11692887f, -0.14390211f, 0.12834063f, 
    -0.39141682f, -0.47673050f, -0.37581754f, -0.21845795f, -0.04963618f, -0.03621182f, -0.13416311f, -0.17108111f, 
    -0.02870371f, 0.00425944f, -0.11021156f, 0.06312984f, 0.51724255f, 0.26565582f, -0.11855254f, -0.45134854f, 
    0.15579861f, 0.20836347f, 0.04119039f, -0.00027205f, -0.01658080f, -0.01415312f, 0.03728189f, -0.03329648f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.18446030f, -0.06500010f, -0.05145834f, 0.03810322f, -0.05127357f, -0.01693793f, -0.02155248f, -0.07443131f, 
    -0.02093472f, 0.05554063f, -0.03789176f, 0.01789916f, 0.04434452f, -0.07544560f, 0.05453363f, 0.02418432f, 
    0.01839673f, 0.06321000f, 0.07049626f, 0.02426402f, -0.04704130f, 0.08913670f, 0.17317365f, -0.01898274f, 
    -0.03137066f, 0.00121758f, -0.01118061f, 0.02668124f, -0.04905508f, -0.06253164f, 0.27805689f, 0.02322127f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.08808437f, -0.14395766f, -0.11282061f, 0.07083945f, 0.04524793f, 0.17163177f, 0.30689767f, -0.02041053f, 
    0.21291433f, 0.07615680f, 0.14618768f, 0.04589438f, 0.01426525f, 0.03633688f, 0.04317506f, -0.09227957f, 
    0.28754893f, 0.06535111f, 0.07772296f, 0.63084483f, -0.02852212f, -0.57548040f, 0.26000348f, -0.30076140f, 
    -0.05379929f, 0.34450752f, -0.06465592f, -0.00628970f, 0.12790643f, 0.18036570f, 0.06075414f, 0.08744194f, 
    -0.08200841f, 0.05665636f, 0.00538382f, -0.07236353f, 0.04631024f, 0.26360101f, -0.03109035f, -0.14635025f, 
    0.14665344f, -0.06942859f, 0.16471002f, 0.07414947f, -0.14580284f, -0.02138268f, 0.37321779f, 0.06021869f, 
    0.53688985f, -0.08959602f, -0.44013390f, 0.13758501f, 0.00411916f, -0.00013492f, -0.32221493f, 0.42453930f, 
    -0.02580881f, -0.04537025f, -0.20339419f, 0.14211339f, 0.14168824f, 0.25598955f, -0.34640950f, 0.30902904f, 
    -0.09103163f, -0.08034669f, 0.11620539f, -0.00030468f, -0.09986909f, 0.26707780f, -0.00764867f, -0.18447484f, 
    0.22938277f, -0.08808436f, -0.08175026f, -0.12053274f, -0.03182193f, -0.06031235f, -0.05804358f, 0.08931764f, 
    0.25488332f, -0.03743230f, 0.10251579f, 0.29016340f, -0.08344615f, -0.05284480f, 0.03286473f, 0.13049802f, 
    -0.05482578f, 0.11487717f, 0.09934425f, -0.13913842f, 0.16677625f, -0.22354256f, -0.10085923f, 0.37729254f, 
    0.01310575f, -0.02012659f, -0.04963965f, 0.03579325f, -0.12919000f, -0.01409711f, -0.02220975f, -0.19903222f, 
    0.19911392f, 0.01563172f, -0.00009607f, 0.05847024f, -0.16848785f, 0.09059811f, 0.20772339f, 0.01025570f, 
    -0.01618120f, -0.05100934f, -0.00706808f, 0.08927074f, 0.02455328f, -0.05894850f, -0.11957520f, 0.24635781f, 
    0.03108010f, 0.11200380f, 0.10021237f, -0.08282025f, -0.05139150f, -0.10989042f, -0.11314773f, -0.11658753f, 
    -0.25417417f, -0.03848057f, -0.09153590f, 0.12487483f, -0.15516777f, 0.09741376f, 0.30234572f, -0.02673245f, 
    0.39577478f, -0.09748270f, -0.01582934f, 0.03990868f, -0.06877656f, -0.16375194f, 0.15258712f, -0.01869923f, 
    0.41924673f, 0.11457206f, 0.21570808f, -0.08996013f, -0.16686359f, 0.09627344f, -0.04732074f, 0.06791261f, 
    0.16804473f, 0.08040146f, -0.06860644f, 0.32596079f, -0.17512621f, 0.16940662f, -0.13550746f, 0.60487407f, 
    -0.12019084f, 0.11910255f, -0.00437795f, -0.14806062f, 0.09217849f, 0.49105194f, -0.18572775f, 0.00150547f, 
    -0.27214471f, 0.01831035f, -0.00972676f, 0.01815001f, 0.06387556f, -0.02845486f, -0.15767622f, -0.00751438f, 
    0.22804333f, -0.17632052f, 0.03287373f, 0.17964666f, -0.11200945f, 0.13844661f, 0.51493835f, 0.19957943f, 
    0.02355187f, -0.11773347f, -0.08703431f, -0.14588450f, 0.11807565f, 0.54427707f, 0.11026136f, -0.46636283f, 
    -0.12878126f, 0.09775968f, 0.13674490f, -0.10804640f, 0.14290288f, -0.08094967f, -0.12003420f, -0.31046650f, 
    0.37881112f, -0.08963040f, -0.03664900f, -0.09337058f, -0.05825040f, -0.11894677f, 0.27644566f, -0.07354009f, 
    0.16379920f, 0.02607301f, 0.55139005f, -0.27752373f, -0.16211967f, 0.29246643f, 0.05059395f, -0.26466495f, 
    -0.14655522f, -0.13602374f, 0.05107297f, 0.37339064f, 0.15706770f, 0.44355458f, 0.23494457f, -0.15844022f, 
    0.11435118f, 0.04974515f, 0.11235079f, 0.10434407f, 0.10483860f, -0.06277563f, 0.01252460f, 0.36919308f, 
    -0.10386786f, -0.02727761f, 0.14500183f, 0.06561705f, 0.11198500f, 0.16656879f, 0.41536927f, 0.11284215f, 
    0.22249858f, -0.05458251f, -0.16592829f, -0.11092272f, 0.13748026f, 0.07321219f, -0.52564365f, 0.25767547f, 
    0.11194496f, 0.00249792f, -0.10817601f, -0.29276028f, 0.13633634f, 0.48739561f, -0.24068505f, -0.13611430f, 
    0.14994319f, -0.16056639f, -0.11227913f, 0.13352254f, -0.00392335f, -0.25788376f, 0.07920896f, 0.24873979f, 
    -0.08233920f, -0.03878134f, -0.08521464f, 0.09344587f, 0.04808069f, 0.16321385f, 0.24574389f, 0.18303040f, 
    0.26482677f, 0.15278871f, 0.00762719f, 0.00656162f, 0.12904380f, 0.34050494f, -0.43776926f, -0.54990751f, 
    0.08559953f, -0.46163413f, -0.12871608f, 0.00748643f, -0.00856380f, 0.38034531f, 0.15625212f, 0.05773306f, 
    0.21145961f, -0.08577938f, 0.11382081f, 0.03689142f, -0.00066688f, -0.15281013f, -0.17722487f, -0.14903024f, 
    -0.18192561f, -0.09692812f, 0.15093105f, -0.06295473f, -0.05322944f, -0.10350956f, 0.41112304f, -0.04428662f, 
    0.15351073f, 0.09222789f, -0.53351545f, 0.29127431f, -0.13816191f, 0.09566164f, -0.13000549f, -0.27890521f, 
    0.02692083f, 0.06761951f, -0.13523817f, 0.16636436f, -0.06092108f, 0.35587075f, -0.17388682f, -0.21750483f, 
    -0.08140333f, 0.08486129f, -0.09326768f, -0.12603930f, -0.13183722f, 0.04204789f, -0.17427455f, 0.01353215f, 
    -0.08188189f, 0.11560464f, 0.06159075f, 0.02649108f, 0.07835679f, 0.11084484f, -0.10634119f, -0.06071722f, 
    -0.13910575f, 0.11666810f, -0.05162476f, 0.06837136f, -0.01586184f, -0.08888750f, 0.01040868f, -0.07042670f, 
    0.11259362f, 0.03886044f, 0.00000354f, 0.03170378f, 0.15722036f, 0.04729058f, -0.08597939f, 0.06613947f, 
    -0.02473645f, -0.03144005f, 0.06959620f, 0.00558768f, -0.02007867f, 0.15122698f, 0.12447878f, 0.02117034f, 
    0.07472276f, -0.02218804f, 0.01079322f, -0.14023937f, -0.15013307f, 0.11568306f, -0.12246213f, -0.01237674f, 
    -0.15903516f, 0.07250592f, -0.10483228f, -0.07160248f, -0.10660457f, -0.02345592f, -0.01477462f, -0.05260251f, 
    0.15525955f, -0.11120296f, -0.09447077f, -0.05747996f, 0.02041503f, 0.03771216f, -0.05435245f, 0.06687122f, 
    0.11413979f, 0.00082325f, 0.08798180f, -0.01409702f, 0.15643992f, 0.05527342f, -0.02166386f, -0.17082562f, 
    -0.15777124f, -0.08145039f, 0.08775734f, -0.05474766f, -0.13227737f, -0.08691649f, -0.12422471f, 0.13787553f, 
    0.04715026f, -0.15075921f, -0.01622296f, -0.01482270f, 0.04706469f, -0.12061918f, -0.09477524f, 0.03586487f, 
    0.16834694f, -0.07566808f, 0.15749823f, 0.01694658f, 0.01149994f, -0.00250430f, -0.09306485f, -0.00710709f, 
    0.17421155f, -0.00294007f, 0.12047098f, -0.15783980f, -0.09648416f, -0.59566170f, 0.22840908f, -0.02606230f, 
    0.33526346f, 0.06541266f, 0.05498418f, -0.05217776f, -0.04088442f, 0.15058905f, 0.18916823f, 0.15756883f, 
    -0.57340044f, 0.04132134f, -0.00168035f, -0.45393270f, -0.13511160f, 0.34270412f, 0.20727028f, 0.44500566f, 
    -0.14034329f, 0.12785426f, -0.21674010f, 0.20205270f, 0.14552127f, -0.17040911f, -0.09201542f, 0.00211085f, 
    0.34581164f, -0.07911936f, 0.17646563f, -0.05088540f, -0.04553536f, -0.11883102f, 0.42495343f, -0.15117437f, 
    0.45230389f, -0.11759156f, -0.05017982f, -0.00494022f, 0.14696734f, 0.15787148f, 0.38774917f, -0.00669415f, 
    -0.08076347f, -0.04118101f, 0.29938456f, 0.41465878f, 0.16190678f, 0.00433224f, -0.18718567f, -0.09864224f, 
    -0.08186112f, -0.02924714f, -0.02268962f, -0.25084934f, 0.10113592f, -0.49443609f, 0.30669969f, 0.75007206f, 
    0.10175150f, -0.09959233f, -0.15666790f, 0.13686658f, -0.16300528f, 0.09675000f, 0.06513581f, -0.48325881f, 
    0.20773765f, -0.13538346f, -0.08845417f, 0.00224145f, -0.14526291f, -0.07510959f, 0.00185132f, 0.15535995f, 
    0.34460348f, -0.04822631f, -0.01247124f, 0.20297918f, -0.00016318f, 0.40945986f, -0.19769639f, -0.34695485f, 
    -0.13248599f, -0.09036502f, 0.19504705f, 0.48203060f, -0.15164016f, -0.35637498f, -0.06012411f, 0.88534874f, 
    0.13381185f, -0.13213150f, -0.14812127f, -0.04619896f, -0.00432037f, 0.10633726f, 0.01659901f, 0.34091872f, 
    0.01327485f, 0.10066189f, 0.08015429f, 0.15111446f, -0.11189645f, 0.09923320f, -0.17838813f, -0.06170240f, 
    0.31472507f, 0.10014305f, -0.13636780f, 0.03332481f, -0.12378278f, 0.01827276f, -0.51903707f, -0.18948005f, 
    0.15289083f, -0.05230111f, 0.06899029f, -0.06127586f, 0.05553748f, 0.15911685f, -0.63817048f, 0.07697403f, 
    0.30025896f, -0.00713975f, 0.08797571f, 0.08038294f, -0.13703389f, -0.00562674f, -0.38200116f, 0.30148357f, 
    -0.49561000f, 0.10672414f, -0.11997153f, -0.07853888f, -0.14503723f, 0.04255993f, -0.12711082f, -0.16453452f, 
    0.19203468f, -0.01553246f, -0.50008249f, 0.13929126f, -0.15756083f, 0.40869990f, -0.05754748f, -0.17824531f, 
    0.00787876f, -0.02994679f, -0.10442351f, 0.44582236f, 0.01015260f, 0.11601439f, 0.00475770f, -0.11155599f, 
    0.11593492f, 0.02676129f, 0.17236724f, 0.09509854f, 0.07425415f, 0.41923827f, -0.32640317f, -0.12298255f, 
    0.08714125f, 0.07284461f, 0.02287349f, -0.08814577f, -0.17314367f, 0.07433418f, 0.23363663f, -0.13383931f, 
    0.32946604f, -0.08452209f, 0.52377284f, -0.08391356f, -0.04642981f, 0.13448866f, 0.05578801f, 0.29045695f, 
    0.07365423f, -0.02384843f, -0.14164621f, -0.28966382f, -0.15370825f, 0.41403005f, -0.21828991f, -0.55956697f, 
    0.03098411f, -0.13541032f, -0.08218486f, -0.04170013f, 0.09872467f, 0.07543338f, -0.01021176f, -0.19602831f, 
    -0.17171809f, -0.00900425f, -0.14681678f, -0.00271972f, -0.16339478f, 0.11859979f, 0.04830592f, 0.09352492f, 
    -0.10240461f, -0.09023004f, 0.02573675f, -0.15859935f, -0.12519225f, -0.05581372f, 0.02822435f, -0.00190413f, 
    0.09567267f, -0.19350928f, 0.01130264f, -0.10098274f, -0.04511584f, 0.07212132f, 0.05076250f, -0.01435601f, 
    0.12400294f, -0.14792728f, 0.06442457f, -0.02233750f, 0.02602147f, 0.33158314f, -0.43426785f, 0.16217908f, 
    -0.07773052f, 0.05603139f, -0.14524907f, -0.15090263f, 0.00628258f, -0.16408440f, -0.31759095f, 0.05969643f, 
    0.22997195f, 0.01363423f, 0.04082320f, 0.28672606f, -0.06162820f, 0.12690161f, -0.06787395f, -0.28385600f, 
    0.06777283f, 0.36846191f, -0.03256231f, -0.13567588f, 0.17990534f, 0.36139622f, -0.13327438f, 0.01179019f, 
    -0.00022063f, -0.08809408f, -0.13268852f, 0.10177522f, 0.03639603f, -0.10480425f, -0.19138731f, 0.20012988f, 
    0.43964189f, 0.11413220f, 0.11699825f, 0.03525188f, -0.15292843f, -0.11628683f, 0.19905099f, -0.12873977f, 
    -0.47978073f, -0.07273281f, -0.04388754f, -0.28236279f, -0.07277719f, 0.04682324f, -0.20178097f, -0.30814931f, 
    0.04258975f, 0.38129583f, -0.10614730f, 0.18354197f, -0.17124635f, 0.06278671f, 0.22885735f, 0.28355578f, 
    0.07819331f, 0.09324129f, 0.00855664f, 0.11865006f, -0.01378012f, 0.17934720f, 0.48411343f, 0.47616076f, 
    -0.36378714f, 0.08715393f, 0.13369922f, 0.02952117f, -0.03136322f, -0.08126844f, 0.07168820f, 0.05905117f, 
    0.26273492f, -0.02694952f, -0.36921853f, 0.61843336f, 0.01522966f, -0.16385937f, 0.33846861f, 0.13368061f, 
    -0.09512404f, -0.16412351f, -0.06033689f, -0.02441530f, -0.11467094f, 0.06997349f, -0.07550718f, 0.28208339f, 
    0.06796981f, -0.06244483f, 0.05096385f, 0.01734159f, 0.10110792f, 0.05726147f, -0.37440288f, -0.16870573f, 
    0.29059204f, -0.06924289f, 0.09468358f, -0.11287164f, -0.07192515f, 0.12760969f, -0.01285864f, -0.16311008f, 
    -0.35009345f, 0.00871832f, -0.35114530f, -0.26321942f, -0.06196397f, 0.10394704f, 0.04928392f, 0.22735703f, 
    0.07961523f, 0.45305669f, 0.07976164f, 0.55704463f, 0.12015462f, 0.25967574f, -0.18330069f, 0.51798141f, 
    -0.13315974f, 0.12224535f, -0.12923436f, -0.01619615f, -0.16000220f, -0.16490732f, -0.15623297f, -0.14105247f, 
    -0.02050105f, 0.07552306f, 0.16972660f, 0.13064608f, -0.02496687f, -0.14816447f, 0.13791275f, 0.09864122f, 
    -0.08763921f, 0.06920923f, -0.03664237f, -0.14569402f, -0.05252783f, 0.13120350f, 0.05169109f, -0.03282388f, 
    -0.10734309f, -0.04253694f, 0.10735999f, -0.17193210f, 0.11042940f, 0.03446232f, -0.13003556f, 0.08270408f, 
    0.22786821f, 0.02339595f, -0.02525594f, -0.11596762f, -0.05628155f, 0.19640233f, 0.07248142f, -0.16503260f, 
    0.37869909f, -0.05566647f, -0.06602742f, -0.08277826f, 0.13074966f, 0.17340451f, 0.19954503f, 0.12022720f, 
    0.22849254f, 0.02807752f, 0.53749990f, -0.04170910f, -0.08601467f, -0.17542829f, 0.17110741f, 0.56104988f, 
    -0.00935213f, 0.16054216f, -0.03753623f, -0.46203753f, 0.04619452f, -0.48535496f, 0.11975373f, -0.34517866f, 
    0.08618075f, -0.08657807f, 0.09482643f, 0.13942730f, 0.10158584f, 0.08750729f, 0.15010151f, 0.08049995f, 
    -0.26351312f, 0.12850700f, 0.17510247f, 0.00377774f, 0.09571391f, 0.15691167f, 0.00196900f, 0.03912333f, 
    -0.18726812f, -0.03103836f, -0.59240085f, 0.34830880f, 0.03909126f, -0.14763305f, 0.08843088f, -0.30458808f, 
    0.06712452f, 0.15734723f, -0.12739591f, 0.41877905f, -0.05713040f, 0.47729906f, -0.03190577f, 0.22233176f, 
    0.48922691f, 0.07513955f, 0.08774992f, 0.04181112f, 0.11292204f, 0.08407339f, -0.14592704f, 0.33720875f, 
    -0.41153100f, 0.15423751f, 0.11960860f, 0.06809472f, -0.03322356f, -0.00113879f, -0.17803706f, 0.09698381f, 
    -0.09918822f, 0.16634789f, 0.25714672f, -0.24030317f, -0.11687704f, 0.37292594f, 0.22315966f, 0.12850937f, 
    0.05262013f, -0.00141285f, -0.01537196f, 0.03493002f, 0.07343969f, -0.20914957f, 0.40795580f, -0.46676034f, 
    -0.05082409f, 0.05762593f, 0.01580145f, 0.03583938f, 0.09896187f, 0.08530659f, 0.37529609f, -0.01404688f, 
    0.40044710f, 0.08156015f, -0.06571885f, -0.04214038f, -0.03194992f, 0.10544305f, 0.03887804f, -0.11659569f, 
    -0.28882217f, 0.08004208f, 0.55788738f, -0.03508994f, 0.14656581f, 0.08962329f, 0.28359979f, 0.30806816f, 
    0.06759204f, 0.18677326f, 0.06331412f, -0.03120918f, -0.13552724f, -0.07993724f, 0.33728451f, 0.01228092f, 
    0.27588254f, 0.15287018f, -0.15446332f, -0.07943909f, -0.13206638f, -0.14133199f, 0.11910190f, 0.17002308f, 
    0.11947299f, 0.10039234f, -0.16789033f, 0.09109413f, 0.05450266f, -0.15570211f, -0.04600239f, -0.16037655f, 
    -0.23806156f, -0.14899477f, 0.07275410f, -0.11453098f, 0.09020597f, -0.02299241f, 0.43981853f, 0.05769039f, 
    -0.03712334f, 0.22878303f, -0.14891967f, 0.03566142f, 0.09092736f, -0.24077490f, 0.32275724f, -0.55286491f, 
    -0.15800124f, -0.00265364f, 0.06611449f, -0.05003802f, -0.02174281f, 0.07827161f, -0.04731285f, -0.44414672f, 
    0.43808636f, -0.02482760f, 0.03087187f, 0.04321092f, 0.00706393f, -0.09568147f, 0.21483363f, 0.12078985f, 
    0.48122916f, -0.04293895f, 0.21226010f, 0.14762285f, 0.11597460f, 0.04371107f, -0.04115271f, -0.61057132f, 
    -0.07157923f, 0.16586131f, -0.18171166f, 0.31639305f, -0.11185143f, 0.31508917f, 0.27878386f, -0.12121117f, 
    -0.08900324f, 0.07148609f, -0.01926762f, 0.15371627f, 0.12587510f, 0.15356517f, 0.65629941f, 0.55872899f, 
    0.17795524f, 0.07132502f, -0.09854057f, 0.14937235f, 0.00841938f, 0.13083684f, 0.26099667f, 0.03484134f, 
    -0.15781648f, -0.05235088f, 0.05624184f, 0.30396503f, 0.13065614f, -0.22200346f, -0.19723490f, -0.08882725f, 
    0.09818125f, 0.26556599f, -0.08245077f, -0.26722544f, -0.08088885f, 0.45853955f, 0.02124883f, 0.22581591f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.15470254f, -0.03430359f, -0.22458667f, 0.01570041f, -0.12978771f, 0.23532058f, 0.20321187f, -0.19362877f, 
    -0.04125872f, 0.20868278f, -0.04569957f, -0.02538315f, 0.12847489f, -0.15701480f, 0.08739456f, 0.22982550f, 
    -0.31187260f, 0.10267360f, -0.08375646f, -0.05348363f, 0.06405106f, 0.18920629f, 0.13876230f, 0.13100459f, 
    -0.12147531f, 0.00192654f, 0.10645928f, 0.01129695f, -0.01951725f, 0.27978393f, 0.07894481f, -0.04836601f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.00285285f, -0.55946177f, -0.15193774f, 0.19653668f, 0.51818305f, -0.57105058f, 0.03471477f, -0.22160029f, 
    0.03742577f, -0.75856847f, -0.03252029f, -0.10538404f, 0.14208111f, 0.27871239f, 0.33285803f, -0.11386712f, 
    0.05018632f, -0.62140888f, -0.55629158f, -0.13769044f, -0.52448845f, 0.30675003f, 0.01807262f, 0.23202257f, 
    -0.00275594f, -0.04978802f, -0.17281775f, -0.27765486f, 0.10915852f, -0.09530178f, -0.10601883f, 0.37135610f, 
    -0.19973512f, 0.47704336f, -0.40560439f, 0.08923654f, -0.32599986f, -0.29001379f, 0.06288753f, 0.32671079f, 
    -0.23152901f, 0.10499109f, 0.01054241f, 0.05752809f, 0.14892790f, 0.13093191f, 0.25670692f, -0.16807841f, 
    0.17085007f, -0.41911820f, 0.12075116f, -0.03871491f, -0.32212934f, 0.16782808f, -0.56790137f, -0.09311951f, 
    0.11468425f, 0.39398375f, -0.79031324f, 0.12985136f, 0.13156126f, 0.30095771f, -0.00657287f, -0.33898658f, 
    -0.64370805f, -0.92161977f, -0.64589894f, -0.11450722f, -0.43699116f, -0.33558020f, 0.15416130f, 0.20562598f, 
    0.10751884f, 0.40564668f, 0.01431798f, 0.12730415f, 0.02188647f, 0.39576548f, 0.00498743f, -0.28332347f, 
    -0.75384462f, 0.29263499f, -0.25821692f, 0.09872390f, -0.41198096f, 0.50984615f, -0.51113325f, 0.41841665f, 
    -0.07214876f, -0.20287363f, 0.15157671f, 0.20661417f, -0.08366141f, -0.02613943f, -0.30878949f, -0.23572798f, 
    0.15894000f, 0.31181732f, 0.11136664f, 0.15688545f, -0.00897760f, -0.04673439f, -0.01885980f, 0.14222081f, 
    -0.16284241f, 0.04951417f, 0.01329327f, 0.06388735f, 0.07578494f, -0.74489832f, 0.09978627f, 0.18138452f, 
    -0.79125243f, -0.23049603f, 0.17447104f, -0.12639120f, 0.29250136f, 0.20766264f, -0.33666986f, 0.20146947f, 
    0.09718772f, -0.03044404f, 0.16712086f, -0.55595261f, -0.16297144f, -0.63461643f, 0.14629750f, 0.17456041f, 
    0.21046507f, 0.18939155f, -0.36419979f, -0.08845355f, 0.06778570f, 0.12388691f, 0.05584068f, 0.20893820f, 
    0.04674101f, 0.12459175f, -0.10223297f, 0.12864748f, 0.05629386f, 0.25276974f, 0.05956111f, -0.86227453f, 
    -0.65325534f, -0.35496888f, 0.06057215f, -0.08178478f, -0.43188608f, -0.26806900f, 0.35481364f, -0.45468828f, 
    0.15471290f, 0.05031147f, 0.19897281f, -0.31564718f, 0.00729523f, -0.04143603f, 0.05049306f, 0.26996282f, 
    0.21137190f, 0.12937932f, 0.18761311f, -0.14853936f, -0.22831489f, 0.11648335f, -0.34904706f, -0.45127618f, 
    -0.57096875f, -1.14501536f, 0.06934982f, -0.12878926f, -0.01709017f, -0.56442249f, 0.33036825f, 0.29515600f, 
    -0.12910394f, -0.25015336f, 0.18128969f, 0.07940011f, 0.06433457f, -0.38581711f, 0.22733442f, -0.56690252f, 
    0.17169070f, 0.40958238f, -0.32026675f, 0.24723120f, 0.08292615f, -0.00505484f, -0.23701818f, 0.13826120f, 
    0.36175573f, -0.78794420f, -0.38666639f, -0.33719283f, -0.14779574f, 0.21544047f, 0.14176214f, -0.83149213f, 
    -0.38628829f, -0.13156180f, 0.04645333f, 0.08916842f, 0.14371257f, -1.11329365f, -0.33282748f, -0.44776976f, 
    -0.07266194f, -0.02518857f, -0.12689853f, 0.10493004f, 0.34016088f, 0.32928398f, 0.02224554f, 0.13177663f, 
    -0.09941868f, -0.19652851f, 0.35106543f, -0.03153963f, 0.01468831f, 0.15868644f, 0.35919222f, 0.06370386f, 
    -0.01131196f, 0.23049037f, 0.12964515f, -0.01040370f, 0.25647679f, -0.16252679f, -0.28468934f, 0.26590109f, 
    0.10335150f, 0.13277870f, -0.04675033f, 0.17124274f, -0.06664868f, 0.35710081f, -0.63000429f, -0.16497247f, 
    1.10959983f, 0.24737810f, 0.15483636f, 0.04316951f, 0.30912545f, -0.24300225f, -0.06451477f, 0.15454863f, 
    0.13669239f, -0.16430812f, 0.03055633f, -0.33099222f, -0.42945194f, -0.28180942f, -0.03136805f, -0.04916201f, 
    -0.54893440f, -0.14462870f, -0.04884724f, -0.03848680f, -0.11547636f, 0.51299381f, 0.08656886f, -0.09295920f, 
    -0.61107689f, -0.59193814f, -0.16587408f, -0.11817121f, 0.11580563f, 0.13367699f, -0.78353888f, -0.24518059f, 
    -0.48194763f, 0.16111273f, 0.44362864f, -0.05766148f, 0.07695834f, -0.72412664f, 0.09143272f, 0.25293559f, 
    -0.04218362f, 0.08510777f, -0.18288347f, 0.23563866f, 0.13287917f, 0.07610527f, -0.55010605f, -0.49747196f, 
    -0.07296525f, -0.40791243f, -0.55263275f, 0.10244437f, -0.65730202f, -0.08550603f, -0.73602623f, 0.24569327f, 
    0.12876254f, 0.11019477f, -0.08282878f, 0.01297118f, 0.17354929f, -0.07508162f, 0.04736763f, 0.02197941f, 
    -0.33672762f, 0.36299169f, -0.45537841f, -0.10172735f, 0.21800588f, 0.03469449f, 0.38718855f, -0.38332075f, 
    0.00741940f, -0.23119518f, 0.35061261f, 0.24741797f, -0.10484838f, 0.13209240f, -0.42329118f, 0.26440343f, 
    -0.02271735f, 0.08863488f, -0.09022313f, -0.25444403f, 0.12340323f, 0.00740203f, 0.16270588f, -0.75319570f, 
    0.15684499f, 0.15097572f, -0.02901387f, 0.17238998f, 0.04504050f, -0.10103810f, 0.12407041f, 0.73377103f, 
    -0.28615123f, 0.31852359f, -0.41236269f, 0.06104422f, -0.24621636f, -0.31853914f, 0.17698964f, -0.05837360f, 
    -0.13654877f, -0.21147339f, 0.21043237f, -0.13021420f, -0.24564719f, -0.12378345f, 0.24121097f, -0.64965522f, 
    -0.24978299f, -0.35211295f, -0.44205254f, -0.42168272f, 0.06904051f, 0.14373574f, 0.49941108f, 0.25082579f, 
    0.59223396f, -0.25614813f, -0.10682961f, 0.05135092f, 0.00563577f, -0.56033599f, -0.03172478f, 0.03930486f, 
    0.24078086f, 0.05552168f, 0.40661249f, 0.07924000f, 0.15569672f, -0.10242982f, -0.31277436f, -0.57509643f, 
    -0.00537669f, -0.05928311f, -0.40830177f, 0.10673869f, -0.09245134f, -0.28105620f, 0.21253847f, -0.00573443f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.03533813f, -0.08825256f, 0.00915388f, -0.12086079f, 0.12052599f, -0.00019672f, 0.04573760f, -0.31018323f, 
    0.05466786f, -0.10091910f, 0.04671725f, 0.20126639f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
