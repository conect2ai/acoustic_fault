#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.15892725f, 0.11793749f, -0.35338315f, -0.73036861f, -0.11771879f, -0.04522740f, -0.48964658f, -0.61291105f, 
    -0.52655703f, -0.42197779f, 0.22224437f, 0.49292943f, 0.01510290f, 0.26076385f, 0.23098536f, 0.28491959f, 
    0.12615691f, 0.26200882f, 0.18641677f, 0.44567207f, -0.04675287f, 0.16756384f, 0.01024226f, -0.29779616f, 
    0.47848380f, 0.09001014f, -0.73039490f, -0.40414611f, -0.03331748f, -0.60978574f, -0.08206904f, 0.91872871f, 
    0.58486795f, -0.38386440f, 0.39179179f, 0.10971166f, -0.26479733f, -0.27606198f, -0.22262253f, -0.30813989f, 
    -0.30495238f, -0.15761131f, -0.05674215f, -0.04246208f, -0.10322031f, -0.11215093f, 0.15453856f, 0.15824659f, 
    -0.25596943f, -0.05752711f, -0.36297336f, -0.58410490f, -0.88825870f, -0.01950525f, -0.30315307f, -0.59076583f, 
    -0.21965054f, -0.08274882f, -0.10445704f, 0.26090062f, 0.15041432f, 0.45133153f, 0.46432608f, 0.51907235f, 
    0.23940851f, -0.47923729f, -0.00905572f, 0.10883106f, -0.22446479f, -0.00105675f, 0.08740462f, -0.03964195f, 
    -0.11201385f, 0.13929342f, -0.10038617f, 0.90911114f, 0.41273427f, -0.04277257f, -0.10489552f, -0.26792699f, 
    0.49825296f, 0.62080288f, 0.39602038f, 0.73119777f, 0.55368650f, -0.09393459f, 0.13489650f, -0.24434318f, 
    -0.22725549f, 0.00544988f, -0.07003414f, -0.20463753f, -0.23168872f, 0.02490227f, -0.05724716f, -0.25021449f, 
    -0.07199007f, 0.01454928f, -0.02886345f, 0.01486435f, -0.46863079f, 0.95803040f, 0.46331945f, -0.63256288f, 
    -0.61892796f, 0.44288167f, -0.55747604f, -0.33044955f, -0.23497507f, -0.19824831f, 0.17185624f, -0.21022092f, 
    0.03564527f, -0.11836168f, -0.10049080f, -0.35580549f, -0.30796054f, -0.12861004f, -0.30418366f, 0.08026288f, 
    -0.03444452f, 0.23741789f, 0.02376195f, 0.03538900f, 0.07506014f, -0.65443170f, -0.01616423f, 0.45552322f, 
    -0.23127575f, 0.46713728f, -0.56060696f, -0.30160546f, -0.06048685f, -0.86399198f, 0.07160589f, -0.50025374f, 
    -0.13598183f, 0.33100161f, 0.13445835f, -0.17314529f, -0.40970862f, -0.45447266f, 0.11330181f, -0.10409940f, 
    -0.09140699f, 0.17977116f, -0.03515883f, -0.09651259f, 0.01255615f, 0.13479459f, -0.15183808f, -0.66927379f, 
    -0.80915630f, -0.43655148f, -0.05599035f, 0.49977031f, 0.53887379f, -0.02526525f, 0.34088591f, 0.51350820f, 
    -0.17354883f, -0.12692894f, 0.34072167f, -0.12460379f, 0.26438960f, -0.31409922f, 0.19824526f, 0.47101617f, 
    0.38397855f, -0.41272962f, -0.00288576f, -0.31628084f, 0.10673822f, 0.18613201f, 0.06888438f, 0.71447951f, 
    0.89676011f, 0.83833790f, 0.56025118f, 0.68991518f, -0.26561311f, 0.09597518f, -0.53585595f, 0.08403252f, 
    -0.14419368f, 0.23420791f, -0.14952293f, 0.12867622f, 0.12507394f, 0.05126626f, 0.01367452f, 0.00004743f, 
    0.18939230f, 0.02691654f, 0.19798127f, -0.13081135f, -0.09645742f, -0.23098710f, 0.06014668f, -0.06925521f, 
    -0.77761120f, -0.68972909f, -0.76894271f, 0.03241662f, 0.47286060f, -0.81316185f, 0.50643831f, 0.69000202f, 
    -0.39453739f, -0.17937097f, 0.20138043f, -0.20259854f, 0.02918654f, -0.19946939f, 0.21426755f, 0.00031838f, 
    0.09069677f, -0.28127238f, -0.03129677f, -0.25512022f, -0.26161903f, -0.19146825f, -0.04326256f, 0.09518652f, 
    -0.21474192f, -0.26626289f, -0.35792124f, 0.04510950f, -0.53959650f, -0.59679407f, -0.12410081f, -0.34014907f, 
    0.09542785f, -0.09459855f, 0.15799059f, 0.41606623f, 0.35754535f, -0.31995633f, -0.13721044f, -0.04398154f, 
    0.18710135f, 0.05913594f, -0.18753648f, -0.08693384f, -0.31105024f, -0.02123016f, -0.00213115f, 0.42497742f, 
    0.33995360f, 0.24621272f, 1.16364646f, 0.39138421f, -0.14110678f, 0.82446438f, 0.74921089f, 0.67095292f, 
    0.14846161f, -0.63975602f, 0.54414850f, 0.02743510f, -0.19913818f, 0.12564352f, -0.24043250f, 0.12860595f, 
    -0.36721712f, 0.00910687f, 0.05684182f, -0.04638439f, -0.04586888f, -0.01472533f, 0.32965371f, 0.31244621f, 
    0.25234053f, 0.01352586f, 0.21960275f, -0.13033213f, 0.66019654f, 0.71751946f, 0.88698810f, -0.80138457f, 
    -0.32597363f, 0.04008333f, 0.46975777f, 0.39794654f, 0.03218733f, -0.18081199f, -0.01085627f, 0.27759171f, 
    0.26288247f, -0.16935048f, -0.08605773f, 0.06323537f, 0.02493140f, 0.01828150f, -0.20333992f, 0.27000475f, 
    -0.08266313f, -0.31151482f, 0.21875091f, -0.08131564f, -0.58590341f, -0.59437817f, -0.49177220f, -0.43748963f, 
    -0.11396401f, 0.03270442f, 0.70777333f, -0.38232189f, 0.00654205f, 0.54214239f, -0.17550063f, -0.18857366f, 
    -0.36066613f, -0.27724063f, -0.39367658f, 0.01129476f, 0.04483100f, 0.05636736f, -0.30353966f, 0.08597605f, 
    -0.10237203f, -0.13046585f, 0.02948483f, 0.08493173f, 0.00851792f, -0.06743802f, 0.06159938f, -0.62378991f, 
    -0.54741728f, 0.26165760f, 0.32631794f, -0.38146749f, -0.40363598f, 0.16151595f, -0.38382038f, -0.52181947f, 
    -0.38044193f, 0.05992780f, 0.32756382f, -0.32070082f, -0.44409147f, -0.09799895f, -0.06244547f, -0.28730762f, 
    0.04670674f, 0.22529657f, -0.01790283f, -0.13364236f, -0.07513756f, -0.30859214f, 0.58758682f, -0.31787533f, 
    0.04747740f, 0.69316018f, -0.21039113f, -0.64243174f, -0.64238662f, 0.16396213f, -0.24237265f, -0.45209345f, 
    -0.27504894f, -0.56508094f, -0.09396488f, -0.38337302f, 0.28003898f, -0.36999971f, -0.20441951f, -0.06070058f, 
    -0.19666785f, -0.24128835f, 0.14054056f, 0.07973203f, 0.18753584f, -0.20253472f, -0.16888285f, -0.58065122f, 
    -0.85122591f, -0.44527817f, 0.11154006f, 0.23684718f, -0.41534755f, 0.14641552f, 0.52900147f, -0.02989927f, 
    -0.66923714f, -0.24103799f, -0.21412104f, -0.10312517f, 0.44136465f, 0.08585841f, 0.29265487f, 0.20498759f, 
    0.33102837f, 0.07543416f, 0.08458400f, -0.03205047f, -0.30647933f, -0.05318846f, -0.09035639f, 0.26316607f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22626676f, -0.03170354f, 0.42458284f, 0.05311804f, -0.00533418f, 0.47552690f, 0.18289588f, 0.02245122f, 
    -0.14456758f, 0.03405640f, 0.11751204f, 0.20449457f, -0.02488242f, 0.18465483f, 0.18918042f, 0.22399168f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.12069306f, 0.01807487f, -0.20966108f, -0.25722331f, 0.36122668f, 0.23330148f, 0.01899207f, 0.02093487f, 
    0.15525028f, 0.15719117f, 0.02792250f, 0.13854380f, 0.40369385f, -0.17621970f, -0.15775263f, -0.06322746f, 
    -0.09651916f, -0.04006542f, 0.18503505f, 0.03529441f, 0.13100633f, -0.17605124f, 0.05388231f, 0.10875396f, 
    0.27144933f, 0.00054827f, -0.22010577f, -0.19583416f, -0.04505814f, 0.17696287f, 0.13504367f, -0.00375497f, 
    0.06875359f, -0.14265510f, -0.14982828f, -0.06274774f, -0.00840268f, -0.09031712f, 0.07308124f, -0.05203958f, 
    0.01783019f, -0.01176840f, 0.35234037f, 0.09152074f, 0.20079158f, 0.09282439f, 0.21544245f, 0.09630125f, 
    -0.31797341f, 0.06739674f, -0.13650078f, -0.39207828f, -0.12958458f, 0.17335209f, 0.01662806f, 0.05428581f, 
    0.08163744f, 0.15282689f, 0.11274411f, 0.13248934f, 0.26257178f, 0.49163389f, 0.03181588f, -0.26272097f, 
    0.01915400f, 0.21024518f, 0.02024769f, 0.21775986f, 0.11327539f, 0.07124715f, 0.02746481f, 0.20194396f, 
    0.62865537f, 0.02427207f, 0.04483619f, 0.01504036f, -0.03626160f, 0.08521345f, 0.05844679f, 0.28406507f, 
    0.12240899f, -0.01375884f, 0.14776477f, 0.08327660f, 0.25558183f, -0.08040715f, -0.18370862f, -0.09839985f, 
    -0.08894471f, 0.04754654f, -0.04176424f, 0.09972315f, 0.17681439f, 0.05850640f, 0.00702414f, 0.07120888f, 
    0.23423359f, 0.07562092f, -0.08254439f, 0.22175676f, -0.10651874f, -0.05360817f, -0.00365364f, 0.12475996f, 
    -0.05762276f, -0.08081397f, 0.15649189f, 0.07514225f, -0.26689023f, -0.03142183f, 0.01905943f, -0.40224832f, 
    -0.02396556f, 0.02160268f, -0.11468578f, -0.09521677f, 0.07930719f, 0.01255146f, 0.15638402f, 0.08951116f, 
    0.24310777f, -0.52581120f, 0.14980303f, 0.00041977f, 0.21789417f, 0.01359283f, 0.01281306f, 0.11789700f, 
    0.14967482f, 0.14491206f, 0.21506990f, 0.21541215f, -0.34882078f, 0.12767182f, -0.18234284f, 0.22770949f, 
    -0.03122083f, 0.12884623f, -0.05672630f, 0.10174040f, 0.10037166f, 0.10278959f, -0.03444216f, -0.01095855f, 
    0.03396373f, -0.25923669f, -0.23259786f, -0.09494426f, -0.12109358f, -0.16044344f, -0.00079686f, -0.01612355f, 
    0.14383478f, -0.09048915f, 0.04427208f, 0.07304903f, -0.05382329f, -0.30964622f, 0.14343920f, -0.14345384f, 
    0.01990269f, -0.16382979f, -0.01048567f, 0.03355172f, 0.12858492f, 0.15114175f, 0.07057329f, 0.06059080f, 
    -0.45537695f, -0.04253204f, 0.26252899f, 0.07846470f, 0.06053735f, 0.15604116f, 0.03454613f, 0.17146203f, 
    0.14779532f, 0.10217165f, 0.02530605f, 0.16489254f, 0.09848953f, -0.14917138f, -0.04263869f, 0.10722116f, 
    -0.12770671f, -0.02468037f, 0.00300679f, 0.28455180f, 0.04685568f, 0.12824826f, 0.11787917f, -0.09842255f, 
    0.04559505f, -0.17109138f, -0.05546487f, 0.18705024f, 0.05519510f, -0.09919781f, 0.10054816f, 0.14368148f, 
    0.12356915f, -0.16544276f, -0.01721857f, -0.16070734f, -0.16223885f, -0.12725984f, -0.11547835f, 0.17135587f, 
    0.16241039f, 0.06973517f, -0.00039192f, 0.00211188f, 0.03778484f, 0.00053325f, 0.04574428f, 0.09416318f, 
    -0.22464617f, 0.25305495f, -0.09498087f, -0.04060231f, 0.13122858f, 0.25500581f, 0.10768030f, -0.17953150f, 
    0.12872905f, 0.00092243f, -0.04650981f, 0.00359625f, -0.56830609f, 0.15689644f, 0.12330447f, 0.22211811f, 
    0.05694904f, 0.04625119f, 0.05381766f, 0.21616472f, 0.25449005f, -0.05233770f, 0.08294608f, 0.05553877f, 
    0.35028243f, -0.11722529f, 0.01236595f, 0.03725914f, 0.06333462f, -0.01818503f, -0.21533513f, 0.03108574f, 
    0.10290281f, -0.10237187f, 0.08225108f, 0.10314519f, -0.17540012f, -0.05651560f, -0.01440866f, 0.00837962f, 
    -0.04108615f, 0.08571449f, 0.02211009f, -0.01527040f, 0.16898921f, 0.10068756f, 0.01777307f, 0.23268545f, 
    -0.08507936f, -0.17292097f, 0.01267459f, 0.31029198f, -0.06704383f, -0.19574954f, 0.06670348f, 0.11688464f, 
    0.02743238f, 0.02234151f, -0.04662594f, 0.07270500f, 0.08028520f, 0.30457139f, -0.08979361f, -0.11662538f, 
    0.23409675f, -0.03234255f, -0.01048749f, -0.04777315f, -0.02619627f, -0.03913460f, 0.06199619f, 0.08441628f, 
    -0.06361660f, -0.27823031f, -0.13703291f, 0.22580391f, -0.03066833f, -0.12063124f, 0.19918977f, 0.08682165f, 
    0.01572265f, 0.05842775f, 0.26863343f, -0.18493842f, 0.29937521f, 0.14611794f, -0.06521697f, -0.21616223f, 
    -0.07394879f, 0.01534153f, -0.06774582f, -0.00888437f, -0.11937387f, 0.04217144f, 0.11565094f, -0.05875199f, 
    -0.06379316f, 0.20663601f, -0.09077685f, -0.42828760f, 0.12816145f, 0.12544510f, -0.01268576f, -0.00093666f, 
    0.02891153f, 0.03292006f, -0.14311594f, -0.05235051f, 0.41835475f, -0.08610163f, 0.32280403f, -0.33836707f, 
    -0.02981854f, 0.08826035f, 0.09786992f, 0.05008345f, 0.18723258f, 0.11505352f, -0.03842292f, 0.12915362f, 
    -0.30187750f, -0.30703232f, -0.10866300f, 0.25815398f, -0.10429336f, -0.08626276f, -0.06937808f, -0.04022201f, 
    -0.12571029f, -0.12951377f, -0.00604475f, 0.04464247f, 0.09469777f, 0.15264846f, -0.12144128f, 0.34213579f, 
    -0.04752024f, 0.01038284f, -0.04086420f, -0.08191146f, 0.14474066f, 0.07553750f, 0.18964873f, 0.03328636f, 
    -0.36750004f, -0.00916707f, 0.16483706f, -0.27886567f, 0.31618759f, 0.02938453f, 0.08486412f, 0.12121296f, 
    0.05126735f, -0.05648811f, 0.17322451f, 0.10554276f, -0.17202446f, 0.26126471f, 0.14406751f, 0.07094396f, 
    0.00178018f, -0.02786481f, 0.15564449f, -0.09868434f, 0.05050281f, -0.17385696f, -0.03250142f, -0.10278252f, 
    0.41032064f, 0.10584620f, -0.25069439f, 0.27715829f, 0.18968140f, -0.01345183f, 0.00319677f, -0.13380173f, 
    -0.19182076f, 0.34479845f, 0.11521447f, 0.21418776f, 0.51846683f, 0.12807554f, -0.18803975f, 0.08044156f, 
    0.06165484f, -0.16781402f, 0.14154273f, -0.00966100f, -0.05690917f, -0.07803526f, -0.09418393f, -0.12980515f, 
    0.16560978f, -0.05235022f, 0.04252558f, -0.02514700f, 0.18826886f, 0.06430756f, 0.14503598f, 0.18429358f, 
    0.01654832f, -0.00194964f, 0.04471812f, -0.00991366f, -0.10462407f, -0.00039706f, 0.03955870f, -0.16542813f, 
    0.05996591f, -0.06585506f, 0.09181049f, -0.08421341f, 0.15447767f, -0.12721042f, -0.14915238f, -0.02558558f, 
    -0.70397449f, -0.11599948f, -0.02021854f, 0.53943759f, 0.02666788f, -0.00267989f, 0.05658582f, -0.04251135f, 
    -0.02571050f, 0.00179343f, -0.01960711f, -0.14109313f, 0.57923722f, 0.14264613f, -0.16191693f, -0.04555583f, 
    0.02148658f, 0.03208520f, 0.12922478f, 0.20300737f, -0.11417450f, 0.06283607f, 0.26906550f, -0.12208512f, 
    0.14890176f, -0.11250810f, -0.05935241f, 0.07012258f, 0.17022119f, 0.28023934f, 0.06465098f, 0.18228103f, 
    -0.00862995f, -0.10896663f, 0.11891987f, -0.03625904f, -0.07791219f, -0.07658566f, -0.02747245f, -0.37239361f, 
    -0.11546624f, 0.01070521f, -0.03202367f, -0.10361569f, 0.11625550f, 0.07796314f, 0.01966608f, 0.28859949f, 
    0.52635223f, -0.09737644f, 0.04777190f, -0.15066415f, 0.17757115f, 0.19655859f, -0.27434802f, 0.10303886f, 
    -0.07840396f, -0.12958786f, -0.00790774f, -0.03154574f, -0.06547985f, 0.27525303f, 0.19794507f, 0.33790016f, 
    0.09382817f, 0.07515343f, 0.06006331f, 0.00344474f, 0.18131097f, 0.01675776f, 0.00995336f, 0.05129712f, 
    -0.57150835f, 0.08877543f, 0.00400740f, -0.41351828f, 0.10564926f, -0.00280208f, 0.17070803f, 0.11328269f, 
    0.12888406f, 0.11833573f, 0.07823274f, 0.15588394f, -0.30451670f, 0.33179671f, 0.16865171f, -0.32851881f, 
    -0.18047918f, 0.03109804f, -0.11658471f, -0.00449118f, -0.00734766f, -0.06059621f, 0.09870751f, -0.04186330f, 
    0.34441918f, 0.10891100f, -0.08939938f, -0.03683810f, 0.19855115f, 0.07143733f, 0.16075177f, -0.25618607f, 
    0.12229319f, 0.00344100f, -0.19461830f, -0.19905369f, -0.04730809f, 0.23674026f, -0.07111516f, 0.10874198f, 
    0.00154781f, -0.06684725f, 0.19763480f, 0.15453175f, 0.01092259f, 0.01414832f, -0.02526269f, -0.16949305f, 
    -0.29198581f, 0.38424170f, 0.10368168f, 0.02980477f, -0.19727114f, -0.17484541f, 0.13417308f, 0.09663127f, 
    0.01767945f, -0.09377614f, 0.08148497f, -0.01053674f, 0.71643209f, -0.13562910f, -0.02354455f, 0.23279446f, 
    0.00753250f, 0.26650754f, -0.03060496f, 0.02749380f, 0.10942985f, 0.16908342f, 0.07752378f, -0.02137546f, 
    -0.14446749f, -0.05419452f, 0.18823104f, 0.02545460f, 0.10150278f, -0.12790523f, -0.16461468f, 0.03578854f, 
    -0.02716589f, -0.34271684f, -0.15258935f, -0.13604236f, -0.05044437f, 0.12260621f, 0.07787734f, 0.24786970f, 
    0.04703671f, 0.19635172f, 0.29508662f, 0.23207889f, -0.24730714f, 0.09756380f, 0.04687442f, -0.10300275f, 
    0.35033655f, -0.03560364f, -0.06874260f, -0.18053375f, -0.04804038f, 0.07015578f, -0.01693224f, -0.10162992f, 
    0.04616119f, 0.06747931f, -0.14343765f, 0.02099077f, 0.03929859f, 0.12735014f, -0.01119054f, -0.01101321f, 
    0.07034107f, 0.24217694f, 0.08931900f, 0.37277982f, 0.07714311f, 0.05505538f, 0.24887860f, -0.03845515f, 
    0.23027150f, 0.14761487f, 0.05372412f, -0.31798470f, 0.15514646f, 0.18101546f, -0.16572365f, -0.02113320f, 
    0.12582423f, 0.11452763f, 0.18838634f, 0.24257651f, 0.01644847f, -0.12528147f, -0.08252403f, 0.19166207f, 
    -0.02325324f, -0.15357572f, 0.22023688f, -0.04077686f, 0.10421029f, 0.07290272f, -0.02746627f, 0.26887789f, 
    0.01765468f, 0.28356901f, 0.15215985f, 0.40313977f, -0.04692008f, -0.22010466f, 0.17346670f, 0.03725353f, 
    0.02142741f, 0.13032749f, -0.18470150f, 0.09845156f, -0.01144597f, -0.19159123f, -0.29797941f, 0.21682896f, 
    0.18500088f, 0.12771238f, -0.03203532f, -0.08861695f, -0.00032593f, -0.02451247f, 0.07165960f, -0.09256904f, 
    0.39769182f, -0.03979613f, -0.06519298f, 0.11117159f, -0.08530586f, -0.13966167f, 0.14153095f, 0.21840088f, 
    -0.08771331f, -0.03682445f, 0.08041178f, 0.01763487f, 0.26386648f, -0.22607943f, 0.26887381f, -0.06122368f, 
    0.04331371f, -0.07818728f, -0.06681369f, -0.10809927f, -0.00817326f, 0.06035430f, 0.12937103f, -0.05683412f, 
    0.30849439f, 0.13763088f, -0.13426802f, 0.01611722f, 0.27325380f, -0.01084412f, -0.02852626f, -0.10646603f, 
    -0.00126658f, -0.12909503f, 0.01768102f, 0.11040056f, -0.09570815f, 0.07714216f, -0.41614646f, -0.15625797f, 
    -0.08541775f, 0.31295088f, 0.04396912f, -0.16777943f, 0.07564900f, 0.06804186f, -0.11921646f, 0.11507954f, 
    0.03299124f, 0.03511273f, 0.21591641f, 0.17028798f, -0.10116353f, 0.01597504f, 0.10682369f, 0.26861116f, 
    -0.03638202f, 0.02030318f, 0.23996881f, 0.00851819f, -0.03415018f, 0.37794116f, -0.05148922f, 0.28628495f, 
    0.03893522f, 0.23881121f, -0.01357715f, -0.08125014f, -0.04735856f, -0.04551204f, 0.09935730f, 0.25259525f, 
    0.26856712f, 0.19671305f, -0.21827333f, -0.08268041f, 0.09121587f, 0.09374268f, -0.09946384f, -0.09398651f, 
    0.22782016f, 0.05473003f, 0.08695781f, 0.04543766f, 0.21763797f, 0.00156167f, -0.13620068f, 0.14011461f, 
    0.04157614f, -0.13433850f, 0.15166636f, 0.05464906f, 0.03033515f, -0.08394138f, -0.00656710f, 0.04788068f, 
    -0.01828843f, 0.22823785f, 0.00802159f, -0.27235493f, -0.19000027f, -0.00686778f, 0.05758272f, 0.05848747f, 
    0.05755684f, 0.13917500f, 0.28105551f, 0.16051583f, -0.15814270f, 0.01722707f, -0.10557295f, -0.01785138f, 
    0.06694041f, 0.09584203f, -0.22051866f, 0.00963321f, 0.17172682f, -0.05364003f, 0.06680596f, 0.26980585f, 
    -0.36204505f, 0.01544659f, 0.20775354f, 0.07823183f, 0.10457338f, 0.06972881f, 0.08223747f, 0.05735217f, 
    0.07724784f, 0.14551638f, -0.03528458f, -0.04030833f, 0.08286667f, 0.19576262f, 0.05772594f, 0.21372089f, 
    0.04683072f, -0.18711025f, 0.10860187f, -0.18813898f, 0.22566354f, 0.01197367f, -0.07801824f, 0.22775087f, 
    -0.07464495f, -0.00659225f, 0.21600780f, -0.29582080f, 0.02575153f, -0.02054061f, 0.00133470f, 0.00523467f, 
    0.00285344f, -0.01932361f, 0.15192604f, -0.00070243f, 0.02093713f, -0.08302917f, -0.08276959f, -0.26584208f, 
    0.13708831f, 0.12958199f, -0.12734468f, 0.14423610f, -0.00322722f, 0.04904644f, 0.14406797f, 0.04952368f, 
    -0.34542909f, -0.07607218f, 0.00219297f, 0.04305378f, 0.16698173f, 0.24345443f, -0.00514152f, 0.05455012f, 
    0.13798276f, 0.04805621f, -0.01346606f, -0.00227000f, 0.15178736f, 0.18062143f, 0.22590028f, -0.09380304f, 
    0.15986064f, 0.02115908f, -0.11498716f, 0.04517872f, -0.00028554f, -0.03149444f, 0.05826784f, -0.03969948f, 
    -0.33909911f, -0.02787443f, -0.01816634f, 0.00787415f, -0.12096076f, 0.14775728f, 0.03616285f, 0.09997971f, 
    0.09259377f, 0.04381295f, 0.23032039f, 0.21867995f, 0.02949268f, 0.19317190f, -0.15641376f, 0.01062272f, 
    0.10993838f, 0.02292869f, -0.02082734f, -0.06553695f, -0.01589109f, -0.05995203f, 0.02760835f, 0.29457533f, 
    -0.38158855f, 0.23554912f, 0.28999597f, -0.08759595f, 0.00333263f, 0.13187993f, 0.00399020f, 0.12713566f, 
    0.00435858f, -0.03526609f, 0.15028846f, -0.05123736f, 0.45664412f, -0.15428276f, 0.58144981f, -0.00854742f, 
    0.32133743f, -0.18716191f, -0.06548578f, 0.23122312f, 0.14997129f, 0.19094464f, 0.07941849f, 0.00039880f, 
    -0.12495567f, -0.16446783f, 0.05073328f, 0.08969430f, 0.01586899f, 0.02841501f, -0.06082942f, -0.10728285f, 
    0.13747914f, -0.05573362f, -0.05040734f, 0.24628481f, -0.40443864f, -0.23544990f, 0.24400063f, -0.19725357f, 
    -0.09255704f, 0.00995091f, -0.04123687f, 0.15575552f, 0.14892083f, 0.04355879f, 0.12337876f, -0.12726437f, 
    -0.35591152f, -0.16927056f, 0.18011531f, -0.13027573f, 0.12760705f, -0.09630358f, 0.02820404f, 0.10585362f, 
    -0.02937732f, 0.06531628f, -0.01667419f, 0.10072470f, -0.15318343f, -0.09403852f, -0.07580139f, -0.01464512f, 
    0.01754090f, 0.04696803f, 0.11602899f, 0.00916857f, -0.03248119f, 0.11804996f, 0.01180822f, 0.16104999f, 
    0.16656607f, -0.03337212f, -0.05663374f, 0.09683984f, -0.03967916f, -0.07814544f, -0.19747387f, -0.03600615f, 
    -0.18800251f, 0.12501225f, 0.22295150f, 0.33452410f, -0.40157393f, 0.22361182f, -0.17109106f, -0.07994418f, 
    -0.02466695f, -0.10147884f, 0.02177840f, 0.09392255f, 0.10651965f, -0.15166454f, 0.11270061f, -0.15713646f, 
    -0.08722287f, -0.11173459f, -0.17578965f, -0.03338903f, 0.13750760f, -0.08402175f, -0.02242043f, 0.12690349f, 
    0.01775864f, 0.31740907f, 0.18875450f, 0.08200823f, 0.26627696f, -0.15757096f, -0.07298961f, -0.27338699f, 
    0.05961990f, 0.01968342f, 0.15624000f, -0.10845926f, -0.06247946f, -0.01236990f, -0.17361960f, 0.11681727f, 
    -0.25568163f, 0.08570983f, 0.24272676f, 0.27964219f, 0.02976887f, -0.07948869f, -0.19736063f, 0.06785212f, 
    0.01519880f, -0.05375379f, -0.13158005f, 0.02733640f, 0.12866288f, 0.21294078f, 0.18976748f, 0.25262398f, 
    -0.16136016f, -0.14714164f, 0.03135353f, 0.12094038f, -0.13424128f, 0.00904068f, 0.27124959f, -0.15354468f, 
    -0.00459100f, 0.13389054f, 0.08608074f, 0.24327840f, 0.05824072f, 0.07427378f, 0.03732586f, -0.10722523f, 
    0.15388109f, -0.15749525f, 0.15336449f, -0.07562122f, -0.01248884f, -0.17491968f, -0.01389052f, 0.09128664f, 
    0.03485867f, 0.02170255f, -0.09510647f, -0.03681985f, -0.07499894f, 0.12975653f, 0.21997008f, 0.35792178f, 
    -0.68447232f, 0.06892186f, -0.30793649f, -0.44699347f, 0.13107578f, -0.10812560f, 0.08378941f, 0.05904635f, 
    0.07594433f, -0.03723124f, -0.13580894f, 0.16098809f, -0.12074397f, -0.03870676f, 0.08654180f, 0.08546047f, 
    0.10152593f, 0.10156967f, 0.18053907f, 0.02313727f, 0.08103315f, -0.00736661f, -0.11404384f, 0.23458689f, 
    0.24843165f, -0.34004560f, 0.16507122f, 0.03831253f, 0.14306590f, -0.17085715f, 0.12202547f, -0.02472506f, 
    0.19357948f, 0.08616263f, -0.09000750f, 0.23632383f, 0.08973177f, -0.06380033f, -0.00242217f, -0.06270779f, 
    -0.09021544f, 0.10784682f, -0.14210533f, 0.19564949f, -0.04351976f, 0.05856605f, 0.00297716f, 0.00143854f, 
    0.06751174f, 0.39516100f, -0.04589920f, 0.18803036f, -0.01123429f, -0.03326599f, 0.19847161f, -0.05367605f, 
    -0.04294470f, -0.25685242f, -0.23503341f, -0.01891749f, 0.07992806f, -0.10529490f, 0.08213650f, 0.04904433f, 
    0.14496230f, 0.03699921f, 0.06906010f, 0.18076299f, 0.02359213f, 0.00421665f, 0.20646234f, 0.08783495f, 
    -0.04439839f, 0.07194509f, 0.01970009f, 0.33201042f, 0.00066286f, -0.10603485f, -0.10826794f, 0.13091178f, 
    0.07397880f, -0.00250256f, 0.00056618f, -0.06569566f, -0.25961512f, -0.05182727f, -0.03955783f, -0.22943406f, 
    0.07211705f, -0.05026779f, 0.03581969f, -0.29103428f, 0.10076562f, 0.05845013f, 0.12648608f, 0.11693346f, 
    0.15641084f, -0.01886351f, 0.31804308f, 0.26316035f, 0.02365551f, -0.12635785f, 0.06525503f, 0.04757975f, 
    0.04078783f, 0.00316977f, 0.01493022f, -0.00657768f, -0.60029691f, 0.04443842f, 0.07942002f, 0.08835389f, 
    0.03437161f, 0.18055886f, -0.02830723f, 0.05602944f, -0.13678132f, 0.01158003f, 0.05336390f, -0.18880098f, 
    0.16098259f, 0.09133674f, -0.07979394f, 0.24475323f, 0.08842036f, 0.02569916f, 0.02781094f, 0.03506817f, 
    0.03516384f, 0.07038616f, 0.16636667f, 0.16630307f, -0.28389028f, -0.03281419f, 0.21137135f, -0.03110896f, 
    0.00966121f, 0.24260765f, -0.06384101f, -0.03331477f, -0.03966513f, 0.00180906f, -0.07041509f, 0.00191601f, 
    -0.08278016f, 0.00389472f, 0.17253534f, 0.01873824f, 0.06449631f, -0.11070746f, 0.02350210f, 0.14136983f, 
    -0.02493167f, 0.06044857f, -0.11295042f, -0.13765225f, 0.10368267f, 0.06063519f, 0.26198971f, 0.19679777f, 
    0.17609853f, -0.03035262f, -0.01527100f, -0.12544373f, 0.09464035f, 0.05275203f, 0.07410032f, 0.04491211f, 
    -0.34635478f, 0.03126217f, -0.10742945f, 0.26461872f, 0.05856663f, -0.29136971f, 0.00065979f, -0.00494122f, 
    0.14988112f, -0.01747617f, 0.00844215f, -0.06614086f, -0.54329675f, -0.18640357f, 0.33971944f, 0.14672810f, 
    -0.06277081f, 0.18865608f, 0.08758330f, 0.05862770f, -0.15491089f, -0.03604545f, 0.03223412f, 0.00651956f, 
    -0.06710406f, -0.23091730f, -0.33321524f, 0.03894486f, 0.13058349f, -0.05181185f, 0.16476224f, 0.12638579f, 
    -0.12006118f, -0.10108387f, -0.15194315f, -0.08690347f, 0.47536471f, -0.19648629f, -0.23040974f, 0.17313825f, 
    0.10487751f, 0.04931462f, 0.21443370f, 0.02302037f, 0.03138788f, 0.02847558f, -0.18491632f, 0.21251926f, 
    0.20424280f, 0.13229956f, -0.01258200f, -0.03612883f, -0.04582536f, 0.07166076f, 0.10058453f, -0.04344949f, 
    0.09814146f, -0.03714884f, -0.11302977f, 0.15359822f, -0.42662549f, -0.31211582f, 0.04963290f, -0.28233990f, 
    -0.12203077f, 0.16835724f, 0.16699231f, 0.08734389f, 0.05777087f, -0.09131449f, -0.06622843f, 0.05230899f, 
    -0.40811455f, -0.01829004f, 0.03791640f, 0.42611256f, 0.05314475f, 0.02028372f, -0.06166704f, 0.22507192f, 
    -0.00522000f, -0.14083305f, 0.14758942f, -0.03520436f, 0.38837647f, 0.00208029f, -0.31296301f, 0.20117502f, 
    0.11555746f, 0.02185561f, 0.11107016f, 0.00773450f, -0.16397049f, -0.08511820f, -0.04835723f, -0.08158018f, 
    0.37153733f, -0.08763048f, 0.19736077f, 0.19287711f, -0.00715768f, 0.19626252f, -0.01739111f, -0.10553785f, 
    -0.06484861f, 0.00826353f, -0.05544122f, -0.03657296f, -0.09531458f, 0.18826483f, -0.29099837f, 0.05259280f, 
    0.23348224f, -0.26069507f, 0.09987160f, 0.02697295f, -0.11764285f, -0.03492973f, 0.02330279f, 0.07130328f, 
    -0.03460097f, 0.00561717f, -0.04416525f, 0.02371512f, -0.02134374f, -0.08928539f, -0.04274957f, 0.01652478f, 
    -0.04208176f, -0.03186969f, 0.04452577f, 0.02475172f, 0.02284271f, 0.03032069f, -0.02759905f, -0.01731862f, 
    -0.04846593f, -0.03833514f, 0.00006151f, -0.00054971f, -0.01254022f, 0.05137824f, 0.00579349f, -0.02104748f, 
    -0.06789606f, 0.02556956f, -0.06441653f, -0.01661135f, 0.04937590f, -0.07516107f, -0.06817483f, -0.03667196f, 
    -0.04669029f, -0.07354545f, -0.07840094f, -0.02846277f, 0.01092615f, 0.02410080f, -0.06340177f, -0.00426171f, 
    -0.07524723f, -0.02286368f, 0.03660337f, 0.01743454f, -0.01337374f, 0.04160507f, -0.04189306f, -0.00291669f, 
    0.01481631f, 0.08622139f, 0.04664868f, -0.07661046f, -0.07327331f, 0.05624035f, 0.04477833f, 0.01374649f, 
    0.04441584f, 0.04162797f, 0.02400260f, 0.01898260f, 0.01069064f, 0.04165300f, 0.03126196f, -0.01747808f, 
    0.00134857f, -0.02062751f, 0.00054012f, -0.00506140f, -0.04727112f, -0.03376795f, 0.05241194f, 0.01711887f, 
    0.00371794f, 0.05410298f, -0.04302306f, -0.01761124f, 0.01100208f, -0.01487055f, -0.06937782f, 0.03481362f, 
    0.00686412f, 0.06114339f, -0.06017097f, -0.08513768f, 0.04144094f, -0.06445868f, -0.06868046f, -0.06075862f, 
    0.03410467f, -0.06620921f, -0.06696068f, 0.04616514f, 0.05636457f, -0.05572082f, -0.03624905f, -0.07148351f, 
    -0.00910508f, -0.03150625f, -0.03928287f, -0.05874949f, 0.05175325f, -0.06626076f, -0.07155009f, 0.02832105f, 
    0.02673237f, 0.03803188f, 0.05326385f, -0.08306502f, 0.03546599f, -0.03021348f, 0.06945194f, 0.05331489f, 
    0.03501588f, -0.00005505f, -0.07927918f, 0.04535030f, -0.01047890f, -0.03072922f, -0.08773329f, 0.03912698f, 
    -0.06867301f, -0.05100256f, -0.00652769f, -0.05515375f, 0.04893783f, -0.05570675f, 0.02961342f, -0.08284821f, 
    -0.00569902f, 0.02172414f, 0.05610112f, 0.03565060f, 0.00490628f, -0.06222760f, 0.02370497f, -0.04422108f, 
    0.01522772f, -0.05486450f, 0.00438080f, 0.01376073f, -0.00873385f, -0.07464792f, 0.04194896f, -0.02925660f, 
    -0.05675075f, 0.05339607f, 0.06307489f, 0.05170171f, 0.00537769f, 0.04489038f, -0.06093857f, -0.07172906f, 
    0.05671929f, -0.01853582f, 0.02118175f, 0.00333459f, -0.02776549f, 0.04115316f, -0.01122365f, -0.06123547f, 
    -0.02461519f, 0.04432067f, -0.03284848f, 0.01941351f, 0.03688438f, 0.03482666f, 0.02335298f, -0.04532089f, 
    -0.05755911f, -0.04620667f, -0.02660009f, -0.01346468f, -0.01784241f, -0.02891570f, -0.04726925f, -0.02951598f, 
    -0.05485703f, 0.04868777f, 0.00211101f, -0.05840476f, 0.01322998f, 0.01247233f, 0.02297919f, -0.00211839f, 
    -0.05224255f, -0.04592824f, 0.05320852f, -0.01030363f, 0.04363607f, 0.04536206f, -0.06275786f, -0.08550257f, 
    0.12816374f, -0.09563807f, -0.10484521f, 0.29600075f, -0.06510358f, -0.14956111f, 0.09464011f, -0.02622781f, 
    -0.02137420f, -0.11307762f, -0.03133226f, -0.22670379f, -0.10056569f, -0.08352533f, 0.21548489f, -0.04804718f, 
    0.12285800f, 0.08200706f, -0.05989792f, -0.09862298f, 0.10410158f, 0.07266483f, -0.06313965f, 0.03958262f, 
    -0.00833405f, 0.22771646f, -0.13917340f, 0.01810299f, 0.03426820f, 0.08537474f, -0.19182457f, -0.21648130f, 
    0.02516239f, 0.10401734f, 0.10863519f, 0.20310512f, -0.43778756f, -0.10175936f, 0.00185188f, -0.03196062f, 
    0.07401165f, 0.09968446f, -0.03879838f, 0.03828786f, -0.27035412f, 0.12207960f, 0.12229270f, -0.17417614f, 
    0.64711779f, -0.20690192f, -0.18776487f, 0.53311259f, -0.03391370f, 0.13248751f, -0.08862484f, 0.03944375f, 
    0.06932364f, -0.02448120f, -0.18769218f, 0.08138440f, -0.46209738f, -0.08869680f, 0.10212921f, 0.33837169f, 
    -0.18742482f, -0.12882544f, -0.04572412f, -0.06599669f, -0.00465031f, -0.03299069f, 0.02571169f, 0.01442549f, 
    0.15140674f, 0.00414546f, -0.00984941f, -0.02217340f, -0.01750313f, -0.01371187f, 0.08361267f, -0.06476947f, 
    0.02858189f, 0.10707823f, -0.06091031f, 0.01408080f, 0.29167709f, 0.11214156f, -0.28480572f, 0.10238183f, 
    0.01094136f, 0.00196960f, 0.12092627f, 0.14367515f, 0.15064737f, 0.01931779f, 0.08666830f, 0.00310554f, 
    -0.45061240f, 0.30643973f, 0.18033041f, -0.14272727f, 0.13629313f, -0.14476953f, 0.20767015f, -0.06541412f, 
    0.03789958f, 0.02793818f, -0.08674937f, 0.04098341f, 0.03710619f, 0.00653021f, 0.00599148f, 0.00064942f, 
    -0.08550102f, 0.12524404f, -0.01150094f, 0.05091950f, -0.03611834f, 0.10748345f, -0.04990470f, -0.21619038f, 
    0.32098573f, -0.17063539f, -0.07698335f, 0.11980248f, -0.09367901f, 0.02858304f, 0.01936797f, 0.06711375f, 
    0.02068514f, -0.02239976f, -0.19134621f, -0.13891704f, 0.40201351f, 0.12722117f, -0.01167795f, -0.08291156f, 
    -0.08897457f, -0.07406428f, 0.00776901f, 0.01122450f, 0.05831115f, 0.11180533f, -0.07464640f, 0.10147777f, 
    0.05910470f, 0.33359018f, -0.01777130f, 0.02198364f, -0.12942886f, -0.00787462f, 0.03750708f, 0.01388334f, 
    -0.28815335f, -0.13376859f, -0.04026796f, 0.05706725f, 0.37970597f, 0.23141961f, 0.00447491f, 0.34672764f, 
    -0.05232012f, 0.01374591f, -0.03814939f, -0.11766026f, -0.03569629f, 0.04001175f, 0.03019491f, 0.27413782f, 
    0.20360982f, 0.06958432f, -0.16805600f, -0.27897513f, 0.15556985f, -0.04324029f, 0.04305893f, 0.03448686f, 
    0.04423792f, -0.02046799f, 0.18488988f, 0.02141730f, -0.16247174f, 0.28860590f, 0.39573392f, -0.12627390f, 
    0.07712285f, -0.01678372f, 0.02206329f, -0.24488206f, 0.09732916f, -0.09849908f, 0.16092011f, -0.10058897f, 
    -0.17734432f, -0.04077440f, 0.02077615f, 0.19099809f, 0.06090483f, -0.05082582f, 0.20218353f, -0.03871560f, 
    0.15804629f, -0.20404394f, 0.05093609f, -0.14329578f, -0.36303496f, 0.03410114f, 0.13358001f, 0.03634362f, 
    0.16954212f, 0.22710012f, -0.00335397f, -0.11685677f, -0.06661687f, 0.07058771f, 0.05509989f, 0.02011863f, 
    -0.03592378f, -0.02121818f, -0.12430935f, -0.04946038f, 0.12259758f, 0.26292372f, -0.05714867f, -0.02912425f, 
    -0.01867109f, -0.01397624f, -0.13847607f, -0.13640299f, -0.52013397f, 0.02129415f, 0.15670061f, 0.19009382f, 
    0.01579803f, 0.04993626f, 0.08540322f, 0.26623189f, -0.03644275f, 0.03281623f, 0.23365632f, -0.08417235f, 
    0.23431468f, -0.10480338f, -0.21806110f, 0.06597323f, -0.11996032f, 0.08147433f, 0.02971962f, -0.14329776f, 
    -0.13022013f, 0.09381901f, 0.16449998f, 0.07654310f, -0.22667030f, -0.07082208f, -0.09109123f, 0.10086671f, 
    -0.04630519f, -0.05576919f, -0.01862601f, -0.10898604f, 0.15363953f, 0.02837990f, 0.03933651f, 0.24450386f, 
    -0.15687348f, -0.08988842f, 0.11145696f, 0.09974620f, 0.07267119f, -0.09314799f, 0.02092036f, -0.02012157f, 
    -0.09848756f, 0.08690647f, -0.19976835f, 0.10313560f, 0.48314372f, 0.72925675f, 0.15257382f, 0.00266417f, 
    0.00486878f, -0.10517291f, 0.03882124f, 0.05016989f, 0.14557034f, -0.07443098f, -0.17840125f, 0.00807386f, 
    -0.05841723f, 0.16193907f, -0.16375375f, 0.03695558f, 0.04118518f, 0.12221780f, 0.03303491f, 0.13844608f, 
    0.06884553f, -0.00043871f, 0.17113064f, 0.00930335f, -0.11000103f, -0.07405186f, -0.31587061f, -0.13207570f, 
    -0.13452373f, 0.17647982f, 0.04069923f, 0.00294537f, -0.16904657f, 0.04807302f, 0.07050666f, -0.23246862f, 
    0.20717487f, 0.17208296f, 0.14367752f, -0.04086551f, 0.07033869f, -0.00266059f, -0.05939891f, 0.15426347f, 
    -0.01390574f, 0.03362029f, -0.04480770f, -0.01318565f, 0.06807943f, 0.19566669f, 0.05886789f, 0.04036810f, 
    0.11302052f, 0.20878887f, 0.16597085f, -0.03360599f, -0.00556236f, 0.14258803f, -0.04270034f, 0.03871601f, 
    0.15049104f, -0.22453691f, 0.05249054f, 0.02807950f, -0.11215410f, 0.05644867f, -0.07513993f, 0.10906029f, 
    -0.21255058f, 0.08834624f, 0.06521110f, 0.13420878f, -0.05047396f, -0.05436033f, 0.01374075f, -0.03087275f, 
    -0.03663219f, 0.07832015f, 0.03649024f, -0.11693515f, 0.10661791f, -0.00332185f, 0.09181891f, 0.15899844f, 
    -0.07903035f, 0.26446810f, -0.10375898f, -0.03099404f, 0.21838257f, -0.05448940f, 0.05418531f, -0.12949818f, 
    -0.09125070f, -0.00484869f, 0.02953190f, 0.05056056f, -0.07651286f, 0.37335685f, -0.18126839f, -0.05004836f, 
    0.04601410f, -0.05057727f, -0.17384005f, 0.12358452f, 0.04609738f, -0.09275883f, 0.03074759f, -0.07163797f, 
    -0.30101475f, 0.06873020f, 0.30734527f, -0.17140050f, -0.02286978f, 0.16361150f, 0.00359099f, 0.02526183f, 
    0.11375208f, 0.08392215f, 0.20593572f, 0.14211385f, -0.62001896f, 0.33801860f, 0.03001117f, 0.20759299f, 
    -0.03931759f, 0.01441843f, -0.06603309f, 0.08329198f, -0.02144072f, 0.00200356f, 0.08966960f, -0.13931395f, 
    0.02687222f, -0.20624548f, 0.09847371f, 0.10730775f, 0.31211475f, -0.08728567f, -0.05903872f, 0.11216141f, 
    0.05306376f, 0.02811832f, -0.10359672f, -0.10452694f, 0.40898231f, -0.12536785f, 0.12317114f, 0.08459660f, 
    0.18293518f, 0.09325561f, 0.06962715f, -0.01668844f, -0.08551110f, 0.04236752f, -0.01811656f, 0.01375740f, 
    -0.17173657f, 0.00152077f, 0.27723968f, -0.57620049f, -0.06419342f, -0.00336950f, 0.10448629f, -0.29060036f, 
    0.04056291f, 0.02498478f, 0.08430169f, 0.05715373f, -0.22669870f, -0.13818452f, 0.05434427f, -0.07345255f, 
    -0.07400629f, -0.03746492f, -0.05427307f, -0.05695939f, -0.03140137f, -0.04087117f, 0.08060959f, -0.03699112f, 
    -0.07919528f, 0.06386287f, 0.12808897f, 0.20293160f, 0.24342556f, -0.13916297f, 0.03584504f, -0.00895008f, 
    0.10891830f, -0.08621997f, 0.06821655f, 0.01394381f, 0.29412243f, -0.02483203f, -0.08284718f, 0.31984729f, 
    -0.15217394f, -0.01182831f, -0.16180992f, 0.02840287f, 0.20361483f, 0.17977588f, 0.04766420f, -0.03557066f, 
    -0.21504608f, 0.27374831f, -0.17109710f, 0.05290426f, 0.02657414f, 0.12979268f, -0.02399143f, 0.10104027f, 
    0.00956999f, -0.01088532f, 0.04751835f, -0.00435532f, -0.03786393f, -0.17886451f, -0.17113084f, -0.10874048f, 
    0.12521057f, 0.06026066f, 0.14414924f, 0.05488117f, -0.06886793f, -0.07370221f, 0.11951977f, 0.18608573f, 
    0.71628565f, -0.08401863f, 0.18036771f, 0.47052589f, 0.10005344f, -0.09809510f, -0.01586255f, 0.17381001f, 
    0.09956927f, 0.09306053f, 0.07046521f, 0.13087223f, -0.12868115f, -0.12222864f, -0.29374498f, 0.20372172f, 
    -0.12921084f, 0.15606588f, -0.15954329f, -0.02790391f, -0.12118335f, 0.03956256f, 0.06787780f, -0.14304391f, 
    0.05101969f, 0.04371143f, 0.26917490f, 0.09357631f, 0.15010603f, 0.03281295f, -0.01807665f, 0.01584818f, 
    0.06510931f, -0.01306274f, -0.05009103f, 0.00684324f, -0.30061126f, -0.33363885f, 0.25081721f, -0.27789032f, 
    0.08647187f, 0.12114258f, 0.01420988f, 0.11159980f, -0.00794152f, -0.12854289f, 0.04549318f, -0.00004744f, 
    0.05895285f, 0.00936663f, -0.06032931f, 0.42613754f, -0.04807673f, 0.04120035f, -0.26803762f, -0.07069060f, 
    0.05120305f, 0.04472468f, -0.12517659f, 0.00461030f, -0.17190696f, 0.04864973f, -0.14079428f, -0.02844690f, 
    0.13371120f, -0.03151371f, -0.06127403f, 0.16772348f, 0.06373463f, 0.08635935f, 0.07766993f, 0.18972997f, 
    -0.00010543f, -0.05074358f, -0.05273597f, -0.05592482f, -0.02714233f, 0.03294863f, -0.07853906f, 0.03926691f, 
    0.06429751f, -0.02131332f, 0.01697359f, -0.02157047f, -0.02632350f, 0.03461501f, 0.01851117f, -0.04938698f, 
    0.03575934f, -0.02259086f, -0.05520350f, 0.00954225f, 0.05018237f, -0.00204248f, -0.06756229f, 0.05422492f, 
    0.06047446f, -0.07938013f, -0.05379185f, -0.02016671f, 0.03167568f, -0.01198600f, 0.06069861f, -0.04966076f, 
    0.04351607f, -0.00399913f, -0.06520353f, 0.00523261f, -0.01089348f, -0.05249192f, -0.03858078f, -0.07129519f, 
    -0.05889635f, -0.03488652f, -0.05139044f, -0.02866742f, 0.03489738f, -0.00412370f, -0.05152999f, -0.04127814f, 
    0.05086586f, 0.01237262f, -0.02975978f, 0.05282505f, 0.06115618f, 0.05509799f, -0.07245580f, -0.00738892f, 
    0.02711215f, -0.06273295f, -0.04589340f, 0.00542471f, 0.03730013f, 0.03459255f, 0.00252846f, -0.03045814f, 
    0.00843589f, -0.01298278f, 0.02311542f, -0.00105440f, -0.00423089f, 0.05056318f, 0.06081700f, -0.00534284f, 
    0.04432217f, -0.07405591f, -0.04090473f, 0.02166847f, 0.03173204f, -0.04261261f, 0.03026930f, 0.04873217f, 
    -0.04500953f, 0.05410732f, -0.00052813f, 0.04285458f, -0.00075200f, 0.04033046f, -0.03151872f, 0.01981367f, 
    0.03502068f, -0.04649067f, -0.04091446f, 0.05306249f, 0.03522999f, 0.05122445f, -0.07153720f, 0.02070440f, 
    -0.00865684f, 0.00499921f, -0.07703929f, 0.04151713f, 0.04219021f, 0.03513007f, -0.08369606f, 0.01601487f, 
    -0.03620354f, 0.05479034f, -0.06508196f, -0.06328709f, 0.04915607f, -0.01181399f, 0.03565129f, -0.00048226f, 
    0.02068961f, -0.00139675f, -0.00261303f, -0.01893675f, -0.00975959f, -0.06038981f, 0.01280369f, 0.01801083f, 
    -0.05779433f, -0.03141924f, -0.04861102f, -0.05283834f, -0.06329722f, 0.05556428f, 0.01115214f, -0.01045946f, 
    -0.00143795f, 0.01923235f, 0.05759620f, -0.05234083f, -0.05546892f, 0.01235574f, 0.00961429f, -0.02598459f, 
    0.05560652f, -0.02032168f, 0.04300198f, -0.07695903f, -0.07127545f, -0.01047285f, -0.05625424f, -0.01328978f, 
    0.05155388f, 0.03008023f, 0.01253938f, -0.04431776f, -0.03066786f, 0.04516192f, 0.03162629f, 0.03308791f, 
    -0.00510275f, -0.06208749f, -0.06421858f, -0.04084701f, 0.00106991f, 0.03538770f, 0.04961720f, 0.02068374f, 
    -0.01984177f, 0.00786807f, -0.01887356f, -0.03990068f, -0.07366312f, -0.01744831f, 0.01452065f, -0.06419867f, 
    0.06051381f, 0.02255083f, 0.01036479f, -0.01550586f, -0.05658861f, -0.04665895f, 0.03700754f, -0.03486802f, 
    -0.00651179f, -0.00916731f, -0.05245408f, 0.01238057f, -0.04237903f, 0.03580989f, -0.02115659f, -0.06585792f, 
    0.04916390f, -0.07001711f, -0.07608760f, -0.05600262f, -0.02768621f, -0.05697020f, -0.02657088f, 0.01628758f, 
    -0.07607871f, 0.05995817f, -0.00879083f, 0.03079370f, 0.06277457f, -0.02565464f, -0.06491218f, -0.03215956f, 
    -0.04707149f, -0.03804854f, -0.05301197f, -0.00855360f, 0.00822536f, 0.02706255f, 0.05170622f, -0.02677359f, 
    -0.03566270f, -0.04341767f, 0.05144887f, 0.04958969f, 0.01535709f, -0.02240681f, -0.07594296f, -0.02226141f, 
    0.03015237f, 0.00318920f, -0.06444193f, 0.01196231f, -0.03275421f, -0.04196401f, 0.05645029f, -0.03404558f, 
    0.06016154f, 0.01369860f, 0.01757528f, 0.03337956f, 0.03383982f, -0.07422527f, -0.03527030f, 0.04306626f, 
    -0.02642617f, -0.00487483f, -0.01355540f, -0.05015086f, -0.04728091f, -0.05334889f, -0.02873480f, 0.03510997f, 
    -0.04638973f, -0.04318738f, 0.05540851f, -0.01138844f, -0.05680704f, -0.05004566f, 0.04430304f, 0.01012709f, 
    0.01009297f, 0.03391370f, -0.00950858f, 0.00767522f, -0.07218200f, -0.04507158f, -0.06457641f, 0.04702676f, 
    -0.04268673f, -0.04831671f, 0.04420453f, 0.03482459f, 0.00720732f, 0.03334536f, 0.05875611f, 0.00926374f, 
    -0.03479363f, 0.04697657f, -0.02418201f, 0.05946494f, 0.03940411f, -0.03202262f, 0.01378745f, 0.02779670f, 
    0.05330748f, 0.02936268f, 0.00493398f, -0.02017173f, -0.05917435f, -0.07944473f, -0.03200519f, 0.07001786f, 
    -0.01725039f, -0.07307439f, -0.06256942f, -0.06606813f, 0.00103675f, -0.06790440f, 0.04419971f, -0.06478374f, 
    0.01929231f, 0.03217046f, 0.02837458f, -0.03079161f, -0.01074499f, 0.00347804f, -0.03829190f, 0.06004969f, 
    -0.05993848f, -0.01798004f, 0.01090951f, -0.07334058f, -0.04358162f, 0.01215651f, 0.05560794f, -0.01137541f, 
    -0.00008365f, -0.05449390f, 0.04551077f, -0.06397393f, 0.00539999f, 0.05604562f, -0.01522944f, -0.04166843f, 
    -0.02175554f, 0.02646735f, -0.07076068f, -0.07296911f, 0.04323447f, 0.02988428f, 0.00550946f, -0.05844544f, 
    -0.01413335f, -0.06312506f, 0.03522889f, -0.00193290f, 0.05735971f, -0.02218125f, -0.05113009f, 0.02438022f, 
    -0.04436012f, -0.01282428f, -0.04783044f, 0.01274439f, -0.06478204f, -0.04647861f, 0.04602370f, 0.02015347f, 
    -0.02555902f, -0.03238821f, -0.01539958f, 0.03287308f, 0.01083974f, 0.02935204f, -0.03600303f, -0.05434604f, 
    -0.00444262f, 0.00010960f, -0.04868192f, 0.00547286f, -0.07900331f, -0.06817357f, 0.00160748f, -0.03166389f, 
    0.05621422f, -0.00903043f, -0.05910750f, -0.01105285f, -0.08499830f, -0.06593090f, 0.00618877f, -0.05107991f, 
    0.03680430f, 0.03258067f, -0.02011215f, -0.02939108f, 0.05823221f, 0.01569645f, 0.03012107f, -0.05964830f, 
    0.00474695f, 0.06023975f, 0.01722141f, 0.00611688f, 0.05277115f, 0.01494400f, -0.06388747f, 0.05037177f, 
    -0.01158631f, -0.00030818f, 0.04232848f, 0.06308332f, -0.04874434f, -0.04597752f, -0.00127564f, -0.06534640f, 
    0.17574860f, -0.00994997f, 0.17044504f, 0.02907294f, -0.05587321f, -0.15555516f, 0.00176317f, -0.01275317f, 
    0.02099745f, -0.08840398f, -0.02503205f, -0.09831455f, -0.17612433f, -0.02042160f, 0.05462440f, -0.21386026f, 
    -0.03136070f, 0.19263394f, -0.01164670f, -0.02420180f, 0.00890440f, 0.10581506f, 0.16420291f, 0.12220698f, 
    -0.23867580f, 0.12356229f, -0.01227244f, 0.05642474f, -0.13416052f, 0.05797004f, 0.12517314f, -0.13060157f, 
    0.07058525f, 0.13286914f, 0.02498114f, 0.11839383f, -0.34512913f, 0.11767657f, -0.10237411f, -0.02869894f, 
    0.04432215f, 0.17566803f, 0.03147357f, -0.09320193f, 0.24056433f, 0.02256334f, -0.04444025f, 0.07248463f, 
    0.18102001f, 0.19258817f, 0.14387386f, 0.28065181f, 0.15011230f, -0.12849939f, -0.13343295f, 0.10561571f, 
    -0.06258568f, -0.02328048f, -0.02658759f, 0.07043302f, 0.00223912f, -0.02499824f, 0.12693834f, 0.20634520f, 
    0.10649679f, 0.07615934f, 0.00968055f, -0.05110485f, 0.08440641f, -0.00756767f, -0.08868724f, -0.00378262f, 
    -0.38239190f, 0.15751204f, -0.06742501f, 0.01261451f, -0.04622852f, 0.02190908f, 0.10665834f, -0.06920968f, 
    -0.12942952f, 0.12444212f, -0.03009984f, -0.15592310f, -0.54545712f, 0.13341178f, 0.31813794f, -0.28800625f, 
    0.11510254f, -0.05051439f, -0.03865047f, 0.03662709f, -0.15699597f, -0.08388158f, 0.20094152f, -0.03787840f, 
    -0.30495653f, -0.19312134f, -0.05069616f, -0.11033448f, 0.06757283f, -0.00210491f, 0.14021324f, 0.11241396f, 
    -0.03162846f, 0.08849316f, 0.03899407f, 0.15795138f, 0.39762411f, 0.03596240f, -0.07878178f, 0.27234757f, 
    0.03713880f, 0.07079556f, 0.01900749f, -0.04679461f, 0.02828151f, 0.07693832f, -0.13975307f, 0.03870423f, 
    -0.45497528f, 0.27196401f, -0.09010914f, -0.34662798f, -0.03646145f, -0.00122758f, 0.13011917f, -0.18368487f, 
    0.10704366f, 0.00551451f, 0.11455934f, 0.03296663f, 0.27202997f, -0.04210237f, 0.39926833f, -0.05370945f, 
    0.21217510f, -0.05785421f, 0.10350293f, -0.05934138f, 0.05859337f, 0.06066142f, 0.05670643f, 0.14054060f, 
    -0.16526844f, 0.17065513f, 0.01061062f, 0.22011943f, 0.01383672f, -0.00617922f, -0.09457570f, 0.18168660f, 
    -0.01598179f, -0.11815360f, 0.07972285f, 0.13505355f, 0.31014436f, 0.36582413f, -0.12955439f, 0.22142665f, 
    0.03490069f, -0.07037519f, 0.01154591f, 0.03047693f, 0.10761946f, 0.09289164f, 0.04717288f, 0.01346716f, 
    0.29092029f, -0.00411331f, 0.16776808f, 0.06300867f, 0.01863020f, -0.00678983f, 0.10650871f, -0.05153226f, 
    -0.08251052f, -0.03580321f, 0.07168687f, 0.16046293f, -0.08091909f, 0.05182962f, 0.00976051f, -0.06383798f, 
    0.05928749f, -0.12418683f, 0.13733333f, -0.15618744f, -0.03758588f, 0.07796536f, -0.05238519f, -0.06654321f, 
    -0.00093171f, -0.04638115f, 0.00162288f, -0.06458832f, 0.05566479f, 0.06618515f, -0.02832252f, 0.01421205f, 
    -0.03946288f, -0.06309318f, -0.00845029f, 0.03028660f, -0.05171193f, -0.00335135f, 0.01573236f, 0.02876165f, 
    -0.05464699f, -0.04406621f, 0.02599040f, -0.07960010f, 0.04384775f, -0.06876487f, 0.02318794f, -0.02503625f, 
    -0.02588609f, 0.06836084f, 0.05147077f, -0.01889831f, -0.04486953f, 0.00014822f, -0.04324901f, 0.00345205f, 
    -0.06039866f, 0.03574080f, 0.01571174f, -0.06205515f, -0.03464522f, 0.04637681f, -0.02984876f, 0.02915807f, 
    0.04972107f, 0.03428405f, 0.05740197f, -0.05700875f, 0.05332061f, -0.08242174f, -0.06505904f, -0.04814430f, 
    -0.07203849f, -0.03496756f, -0.06269185f, -0.00025625f, 0.05017699f, 0.06260581f, 0.05215948f, 0.01733596f, 
    0.05678161f, 0.00911788f, 0.01105345f, -0.05672104f, -0.06647548f, 0.00532250f, 0.03573151f, -0.02795367f, 
    -0.07153782f, 0.03467133f, 0.03899941f, 0.05203522f, -0.03379879f, -0.03472073f, 0.02384490f, -0.02933548f, 
    -0.06757258f, 0.05225911f, -0.05755601f, -0.03335186f, 0.00374169f, -0.07264035f, 0.06254940f, 0.03785067f, 
    0.06513812f, 0.02768790f, 0.04723660f, -0.07883145f, -0.02436918f, -0.07623763f, -0.02867175f, -0.05209805f, 
    0.03634278f, -0.00420559f, -0.05275457f, -0.05335874f, -0.07286220f, -0.02038643f, -0.03875705f, 0.02877620f, 
    0.00441376f, 0.00616017f, -0.06692806f, 0.03422246f, -0.02564006f, -0.07397532f, -0.01768270f, -0.04393876f, 
    -0.01838993f, -0.02254901f, -0.06782804f, 0.01814024f, -0.07847109f, 0.04576749f, 0.04004842f, 0.02737569f, 
    0.04835708f, -0.05875317f, 0.01280867f, 0.01463163f, -0.00345716f, 0.01500852f, 0.02425868f, 0.02983541f, 
    0.06348217f, 0.03251932f, 0.02872756f, 0.03760986f, -0.06871890f, -0.01666840f, -0.06691732f, 0.06493285f, 
    -0.04276239f, -0.00305264f, 0.04765918f, -0.06500976f, -0.03061466f, -0.05306483f, -0.00134446f, -0.00747353f, 
    -0.03099388f, 0.00386371f, -0.05888216f, 0.01244892f, 0.01791826f, 0.05664575f, 0.04999589f, 0.03101902f, 
    0.05946875f, -0.08029431f, 0.00070575f, 0.03909376f, -0.00532903f, 0.04908863f, -0.02229441f, -0.02857881f, 
    -0.06291845f, 0.02922763f, 0.02758810f, -0.03934405f, 0.05228028f, 0.03237044f, -0.05930873f, -0.02445108f, 
    -0.00325763f, -0.04201287f, -0.05859305f, 0.01015727f, -0.01165585f, -0.00539617f, -0.02695387f, 0.06185837f, 
    0.06029449f, 0.02172377f, 0.01252040f, -0.07668350f, 0.06171170f, -0.06170431f, 0.03303497f, -0.06093056f, 
    -0.02086035f, 0.00790435f, -0.04753786f, 0.02191799f, -0.06108778f, -0.01204867f, -0.07154471f, 0.03851196f, 
    0.01043681f, -0.05650817f, -0.04294394f, -0.03645394f, -0.01516626f, 0.00078748f, -0.05711845f, -0.07432873f, 
    0.04753494f, -0.03052542f, -0.04212253f, -0.06829150f, 0.03939506f, -0.06780083f, -0.05543525f, 0.05897939f, 
    0.02045744f, 0.01214431f, 0.06131683f, 0.04039519f, -0.01593077f, -0.00823350f, 0.06467856f, 0.02427387f, 
    0.02959270f, -0.06431723f, -0.04625876f, 0.01044106f, 0.04916634f, 0.04268912f, 0.04212930f, 0.02022412f, 
    -0.08023170f, -0.03373839f, -0.00686965f, -0.07238355f, 0.02909071f, 0.02512687f, -0.04771090f, 0.05131330f, 
    0.05023829f, -0.04002705f, 0.06264889f, -0.05725838f, -0.05263913f, -0.02828835f, 0.01617648f, 0.04580596f, 
    0.01430122f, -0.01350161f, 0.04438115f, -0.03931173f, -0.04832810f, -0.00750614f, -0.00156284f, 0.04204638f, 
    0.00012475f, -0.03864424f, -0.03374211f, 0.06252876f, -0.05075110f, -0.06617737f, -0.05756491f, -0.06978101f, 
    0.02151297f, -0.06958125f, 0.03349666f, 0.03875592f, -0.03743956f, -0.06514187f, 0.03970438f, -0.04592975f, 
    0.01548538f, -0.04252523f, 0.03507776f, 0.00530959f, 0.01470662f, -0.00120692f, -0.03614767f, 0.00201599f, 
    -0.02085669f, -0.00928218f, 0.01633330f, -0.03891109f, -0.05796273f, 0.03418148f, 0.01301633f, -0.05142105f, 
    0.05780473f, -0.04213642f, 0.04075495f, -0.03301967f, -0.01384462f, -0.06428275f, -0.06028201f, 0.00645211f, 
    -0.07856392f, -0.05446431f, -0.07608517f, -0.02046003f, 0.05395000f, -0.06489018f, 0.04324170f, 0.02319958f, 
    -0.02183092f, 0.05918000f, 0.06013681f, -0.00549906f, -0.04284847f, 0.05180588f, -0.00511136f, -0.05525533f, 
    -0.06277630f, -0.02780166f, 0.03720745f, -0.04027906f, -0.01733301f, -0.00830548f, -0.05318747f, -0.04189339f, 
    0.06038997f, -0.06285454f, 0.04611626f, 0.00825904f, -0.06315987f, -0.03864233f, -0.04445200f, -0.05297326f, 
    -0.06410822f, 0.04762160f, -0.05118304f, 0.00433531f, 0.06572281f, 0.01356400f, 0.03465579f, -0.05592848f, 
    0.00844044f, -0.06497113f, -0.07088310f, -0.00931051f, -0.00105602f, -0.06989741f, -0.03968547f, 0.01741798f, 
    -0.06500272f, 0.02909738f, 0.01136501f, -0.02100816f, 0.03193912f, -0.00323117f, -0.01886606f, -0.04550715f, 
    0.01169164f, 0.02909638f, -0.05674373f, 0.02559803f, -0.02276413f, 0.00366881f, -0.06480728f, -0.01703791f, 
    -0.04333931f, 0.00959795f, -0.04669345f, -0.03597411f, 0.07384261f, -0.00987148f, -0.07352123f, 0.04591118f, 
    0.02971854f, -0.00107585f, 0.00599341f, -0.04560436f, -0.04954413f, -0.03168238f, -0.06967409f, -0.06448363f, 
    -0.01396796f, -0.03283213f, 0.00045420f, -0.03570707f, 0.02248172f, 0.03382362f, -0.02066850f, 0.01494593f, 
    -0.05252871f, 0.01312067f, -0.03225020f, 0.05664768f, -0.04976695f, -0.02184603f, -0.06105227f, 0.06550158f, 
    -0.06896821f, 0.04577467f, 0.02416626f, -0.04668999f, -0.01250742f, -0.04191374f, 0.03934668f, 0.02065603f, 
    -0.05921545f, -0.01448101f, -0.00560861f, 0.04837287f, 0.04219122f, -0.06796706f, 0.04298675f, 0.01605670f, 
    -0.02178000f, 0.03584319f, 0.00758967f, -0.04295028f, 0.00811918f, -0.03607247f, 0.00988095f, -0.05811509f, 
    -0.06053966f, -0.04268369f, -0.01910474f, -0.04549672f, -0.02415954f, -0.00454396f, -0.06771671f, -0.06799998f, 
    0.00322905f, -0.05412325f, -0.04546921f, 0.05119117f, 0.00664304f, 0.04903410f, 0.00424524f, -0.04750121f, 
    0.05889124f, 0.01451516f, -0.05137926f, -0.00387018f, 0.00534479f, -0.02531208f, -0.00362325f, -0.01903105f, 
    -0.06345063f, 0.02199320f, 0.03396820f, -0.03648682f, -0.07069931f, 0.05619921f, 0.06055576f, 0.02674677f, 
    -0.02785210f, 0.03213087f, 0.03743766f, -0.05718098f, -0.00411283f, -0.01309833f, 0.05992950f, 0.03447953f, 
    0.05921528f, 0.05425134f, 0.02391376f, 0.00281427f, -0.05254658f, 0.05461572f, 0.06060056f, -0.07522914f, 
    -0.05992551f, 0.06043451f, 0.02806545f, 0.01197006f, -0.04765895f, -0.07616870f, 0.02434352f, -0.01974363f, 
    -0.07505313f, -0.04676570f, 0.00666901f, 0.01060559f, 0.05689142f, 0.05301461f, -0.05977030f, 0.00003931f, 
    -0.02510075f, -0.01024511f, 0.01607899f, -0.04098628f, -0.00154243f, -0.07100192f, 0.05727994f, -0.03700251f, 
    0.04149299f, -0.05835498f, -0.00577337f, 0.02733846f, -0.06344941f, 0.00032444f, -0.06200152f, -0.03174463f, 
    -0.00120735f, 0.03289094f, -0.01489243f, -0.02473397f, -0.02705432f, 0.05960326f, 0.00681139f, -0.03975203f, 
    -0.05181365f, 0.05845700f, 0.02042489f, -0.04369466f, -0.06288629f, -0.04388534f, 0.05312590f, -0.07050972f, 
    -0.00045982f, 0.01512219f, 0.02352000f, 0.05733210f, -0.02072184f, 0.04347625f, -0.02151557f, 0.03844950f, 
    -0.05219370f, 0.03542629f, -0.04521875f, 0.03467483f, 0.01226843f, 0.05782438f, -0.08029200f, 0.06062661f, 
    -0.02278663f, 0.04738624f, 0.04933733f, -0.01464386f, 0.06307692f, 0.05535362f, 0.02097262f, 0.00936182f, 
    0.04276162f, 0.05752651f, -0.00498599f, -0.04350841f, 0.04334950f, -0.08022118f, -0.05196796f, -0.07222188f, 
    0.04754998f, -0.01486398f, -0.06118440f, -0.07695568f, -0.02792313f, 0.02050018f, -0.06729625f, -0.02229286f, 
    0.03351996f, -0.07268364f, -0.08085268f, -0.00626937f, -0.00100044f, 0.02123941f, -0.02990703f, -0.01949810f, 
    -0.07104158f, 0.05196097f, 0.02711315f, -0.01039946f, -0.01558499f, -0.07230721f, -0.06258402f, 0.04442780f, 
    -0.05530542f, -0.02724555f, -0.06419969f, -0.05647376f, -0.01801518f, -0.03832835f, -0.02621259f, 0.01683608f, 
    -0.07003214f, -0.02830661f, 0.02964590f, 0.00436739f, -0.03842652f, 0.03806956f, 0.01465179f, -0.00635300f, 
    0.00473950f, -0.07805683f, -0.07193229f, -0.03448271f, 0.05472463f, 0.05747247f, 0.02900057f, -0.05827526f, 
    -0.18881120f, 0.01099385f, -0.16249874f, -0.16521762f, -0.06137862f, -0.00350697f, -0.02605301f, -0.07935135f, 
    -0.09614483f, 0.22583050f, 0.25554872f, 0.31326464f, 0.00230078f, -0.09349629f, -0.21100552f, -0.08357989f, 
    0.06040378f, -0.07959409f, -0.14471288f, 0.07988199f, 0.16289639f, -0.07497755f, 0.08407748f, 0.10660055f, 
    -0.40405753f, -0.11375674f, 0.12197699f, -0.05476535f, -0.01900502f, -0.08836883f, 0.03576717f, 0.21866074f, 
    -0.10842324f, 0.10618915f, 0.10681007f, 0.07140253f, 0.56347990f, 0.09346802f, -0.00116015f, 0.10414934f, 
    -0.10600359f, -0.26844615f, 0.08496016f, -0.21933179f, -0.06238877f, 0.00900622f, -0.20593677f, 0.12172231f, 
    -0.12114568f, -0.04236744f, 0.07003603f, 0.44553575f, 0.11897084f, -0.12796217f, -0.03119096f, 0.08714812f, 
    -0.03765939f, -0.26287773f, 0.02339455f, -0.14558958f, 0.18001108f, -0.12366881f, -0.08498362f, 0.04433456f, 
    0.07540268f, 0.04704934f, 0.02279735f, -0.07553053f, -0.20884486f, 0.04070204f, 0.19196643f, -0.21362865f, 
    -0.23086227f, -0.14260268f, -0.00974479f, -0.14324228f, 0.14925854f, 0.23862876f, -0.00934402f, 0.08082844f, 
    0.07318763f, -0.14287566f, 0.10940538f, 0.06960662f, 0.13923417f, 0.13765781f, 0.44196114f, 0.23235035f, 
    0.27269477f, 0.30250579f, 0.16969427f, -0.00641740f, -0.05299969f, 0.05303517f, -0.02855709f, 0.21693322f, 
    -0.14650983f, -0.04492695f, -0.12407269f, -0.30315223f, 0.02328980f, 0.22046795f, 0.01586358f, -0.05812571f, 
    0.08633658f, 0.06100724f, -0.08160447f, 0.11758296f, -0.29309103f, -0.03045949f, -0.04485935f, 0.11031006f, 
    0.11765030f, -0.13949960f, 0.08395585f, 0.12436102f, 0.08239997f, -0.10222252f, -0.18786143f, 0.09622405f, 
    -0.19160768f, 0.14880231f, 0.21002133f, -0.02775195f, 0.00982757f, 0.11102160f, 0.08443671f, 0.02529269f, 
    -0.00992479f, 0.01734476f, 0.02564333f, 0.08282857f, 0.39675972f, 0.21677957f, 0.36024860f, 0.08752339f, 
    0.21771365f, -0.04965220f, 0.00376634f, 0.17847306f, -0.01542024f, 0.04633775f, 0.12413232f, 0.01006386f, 
    0.12986417f, 0.05631688f, -0.14190766f, -0.14842863f, 0.11400320f, 0.07676858f, 0.04128924f, -0.04153395f, 
    0.17149103f, -0.03628818f, -0.10477017f, -0.08373313f, -0.25911978f, -0.21709046f, 0.06820631f, -0.23526832f, 
    0.08944814f, -0.06845264f, 0.01190351f, 0.05505113f, 0.02408335f, -0.01605821f, 0.06295662f, -0.06851278f, 
    -0.09013810f, -0.04594126f, -0.03528630f, -0.04015247f, -0.06242458f, 0.05671695f, 0.10099540f, 0.19663890f, 
    -0.11231100f, 0.07600959f, 0.04925704f, -0.01421409f, -0.11601321f, -0.12746911f, -0.20087343f, -0.11979957f, 
    0.11334548f, 0.19544432f, 0.00622748f, -0.15996923f, 0.08120470f, 0.13615672f, -0.03924196f, 0.04967706f, 
    -0.07490151f, -0.03427429f, 0.03442141f, 0.00724002f, 0.00675677f, -0.07080590f, -0.00362182f, 0.04376890f, 
    -0.01820679f, 0.00493506f, 0.03843041f, 0.06500856f, 0.00223097f, -0.05005009f, -0.03123940f, -0.04806164f, 
    -0.00447859f, 0.06178238f, -0.03500013f, 0.01632777f, 0.02204619f, -0.00340829f, 0.01404672f, 0.06169134f, 
    -0.00950448f, -0.04395868f, 0.00589670f, 0.00069790f, -0.07554453f, -0.02882589f, 0.04128326f, -0.00601288f, 
    0.02800675f, -0.02594918f, -0.00603839f, 0.05542912f, 0.00875883f, -0.04045660f, -0.06021846f, 0.05653791f, 
    0.02654108f, -0.00241508f, -0.03421664f, 0.00492253f, -0.02775296f, 0.04527932f, -0.01683234f, -0.02684029f, 
    -0.02647962f, -0.07430921f, 0.00165721f, 0.03022850f, 0.00590446f, -0.03244575f, 0.05584901f, -0.02694994f, 
    -0.03499227f, -0.01562724f, -0.06229333f, 0.02587054f, 0.00951565f, 0.04841105f, -0.00018712f, -0.03578213f, 
    -0.06233156f, -0.02813969f, -0.04161225f, 0.01643427f, -0.02394778f, -0.02241495f, -0.06687511f, -0.00313634f, 
    -0.03687471f, 0.04737680f, -0.03426306f, -0.05836939f, 0.00472800f, 0.03001714f, -0.02176851f, 0.00987190f, 
    0.01975237f, 0.04684934f, -0.04068397f, -0.05275804f, 0.02378459f, 0.01480596f, -0.04438181f, 0.01420647f, 
    0.00496459f, -0.07307332f, -0.07826288f, -0.06155422f, 0.04359506f, -0.00253835f, -0.06124083f, -0.03162223f, 
    0.01803446f, -0.02336016f, -0.06027645f, 0.05077182f, 0.05650442f, 0.02318439f, 0.00583092f, -0.01755340f, 
    0.00537667f, -0.03358514f, -0.00396060f, -0.04798044f, 0.05788895f, -0.01734680f, 0.04013709f, -0.02913970f, 
    -0.05337626f, 0.02667985f, -0.01911738f, -0.00012070f, 0.03430898f, 0.03544922f, -0.06025613f, -0.02519990f, 
    0.02389171f, -0.05014629f, 0.01602555f, 0.05412483f, 0.01780176f, 0.03648105f, -0.04388046f, 0.06222430f, 
    -0.07345745f, -0.02000264f, 0.00851635f, -0.07072343f, 0.01780481f, -0.04656054f, -0.05301152f, -0.03260263f, 
    -0.00685748f, 0.01747426f, -0.01096510f, 0.03975454f, 0.04614740f, 0.04299301f, 0.02597547f, 0.02034182f, 
    -0.00590709f, -0.05611949f, 0.03497272f, 0.01493152f, 0.02185471f, -0.04268151f, -0.03518171f, -0.05676855f, 
    0.04068688f, -0.05706846f, -0.02057731f, 0.02364388f, -0.00456220f, -0.06193131f, 0.00461061f, -0.02626051f, 
    -0.02037802f, 0.00459086f, -0.04765604f, -0.04658733f, 0.03277319f, -0.01307869f, -0.03305630f, -0.05125661f, 
    -0.03422510f, -0.07140011f, -0.01932864f, 0.00552169f, 0.01593908f, -0.02603899f, 0.01964891f, -0.00141182f, 
    -0.03448336f, 0.04125962f, 0.03820202f, -0.03691132f, -0.03652459f, -0.01280446f, -0.02104140f, 0.06196949f, 
    0.05231826f, 0.04798312f, -0.06512656f, -0.05741702f, -0.00061634f, -0.00095544f, -0.04927683f, 0.03149697f, 
    -0.07816290f, 0.01058383f, 0.03793905f, -0.04757995f, 0.03012861f, -0.06699426f, -0.07753022f, -0.05643731f, 
    0.04104621f, -0.07361782f, 0.04087789f, 0.06423946f, -0.00195304f, 0.01175241f, -0.07554282f, -0.04059619f, 
    0.04870431f, -0.02685254f, 0.02339285f, -0.07067563f, 0.02377178f, -0.06624752f, 0.03688035f, 0.00581865f, 
    -0.04601143f, -0.04062684f, -0.02898616f, 0.02731405f, 0.02338956f, -0.02096608f, -0.07578697f, -0.07245260f, 
    -0.06623314f, -0.05461948f, 0.04755300f, 0.02585361f, -0.05475032f, 0.02030919f, -0.07089867f, -0.01915977f, 
    -0.06607134f, -0.04766923f, -0.02671892f, -0.00013586f, 0.03480345f, -0.05770482f, -0.04374953f, 0.04374782f, 
    -0.06811143f, 0.03684618f, -0.00188765f, -0.00962408f, 0.01446591f, -0.07032465f, 0.01953387f, 0.00694487f, 
    -0.02427093f, 0.02137095f, -0.02791412f, 0.00352109f, 0.03412097f, 0.02444538f, -0.04090283f, -0.05935793f, 
    -0.03016621f, 0.02003435f, -0.06246515f, -0.00810835f, -0.01400426f, -0.01330145f, -0.03242708f, -0.03373275f, 
    -0.04815047f, -0.04777353f, -0.02115059f, -0.02987288f, -0.03128344f, -0.00040121f, -0.05370303f, 0.02147991f, 
    -0.07462126f, 0.06551369f, -0.02057814f, -0.02673409f, 0.01231268f, 0.05308065f, -0.06968811f, 0.00077413f, 
    0.00896803f, 0.02426081f, -0.04482419f, -0.00619395f, 0.05715745f, 0.01718474f, -0.02005195f, 0.00934377f, 
    -0.03859014f, -0.04319528f, -0.07274354f, -0.03240119f, 0.06498498f, -0.01579410f, -0.05148286f, 0.00196185f, 
    0.05415448f, 0.03480618f, 0.02367783f, -0.04464489f, -0.06954039f, -0.04832010f, -0.03304468f, -0.06140803f, 
    0.01227257f, 0.05685322f, 0.04623653f, 0.06589370f, -0.05128895f, 0.03562481f, -0.07433336f, -0.04842647f, 
    0.02465106f, -0.05100103f, -0.01478572f, -0.00090904f, -0.04731116f, 0.00307136f, 0.06379715f, -0.01534710f, 
    -0.04056241f, 0.05469374f, -0.00200866f, 0.01532111f, 0.02900600f, 0.05516792f, -0.00399015f, 0.03444385f, 
    -0.00024345f, -0.07220642f, -0.04437501f, -0.05153253f, 0.02124702f, -0.06507260f, 0.05309244f, -0.05056855f, 
    0.00868224f, -0.04324397f, -0.06191403f, 0.02447985f, -0.04926701f, 0.04462791f, 0.00614470f, 0.03061162f, 
    -0.03531596f, -0.02792313f, 0.00188881f, -0.01214047f, -0.02276334f, -0.03943140f, -0.05583522f, -0.04385031f, 
    -0.04970123f, -0.05959911f, 0.06394225f, 0.02957667f, 0.04963446f, -0.06773200f, -0.06453466f, -0.00260215f, 
    -0.00190980f, 0.03614083f, -0.01623193f, 0.03934256f, 0.05992264f, 0.00355359f, 0.01537405f, -0.01113112f, 
    0.05744180f, 0.04340691f, -0.05377634f, 0.06366532f, 0.03384502f, -0.02798646f, 0.00391975f, -0.00313036f, 
    0.06267969f, 0.01388410f, 0.05001717f, 0.01637538f, -0.04686054f, -0.01653530f, 0.01055559f, -0.07033053f, 
    0.25478697f, -0.04031425f, -0.11906336f, 0.02262428f, 0.05700820f, -0.00960755f, -0.12769534f, 0.08579487f, 
    -0.06470709f, 0.18598346f, 0.04338768f, 0.16876633f, 0.33061740f, -0.20806520f, -0.11146937f, 0.15948011f, 
    -0.15032811f, -0.10397734f, 0.03341687f, 0.16410407f, 0.07149061f, -0.05106752f, -0.08473940f, -0.16599943f, 
    0.49202898f, 0.20803373f, -0.09098267f, -0.16936594f, 0.02384899f, 0.03738547f, -0.17225029f, 0.08434400f, 
    0.18372701f, -0.02975032f, 0.13288726f, 0.03598152f, 0.09444835f, -0.08572395f, 0.11380958f, -0.09560166f, 
    0.04213567f, -0.04647451f, 0.14266051f, 0.16059467f, -0.16686612f, 0.05327973f, -0.00569012f, 0.02079793f, 
    -0.00489812f, 0.10494470f, -0.10226917f, -0.18766594f, 0.17686062f, 0.12196033f, -0.07684383f, 0.25399646f, 
    0.20308448f, 0.00706428f, -0.13378337f, -0.08612053f, 0.11846952f, 0.15021218f, 0.12471637f, -0.03825762f, 
    -0.10681688f, 0.01223926f, -0.02613139f, -0.00637119f, 0.03497076f, 0.08388841f, 0.13981307f, -0.00785278f, 
    0.33903328f, 0.06857003f, 0.07326946f, 0.27626884f, -0.20344844f, -0.08532395f, -0.02943965f, 0.12105446f, 
    0.17192346f, -0.00037036f, 0.04634997f, 0.01568621f, 0.06392033f, -0.28752312f, -0.18172984f, 0.40755865f, 
    0.22768596f, 0.10220628f, -0.03272253f, 0.00153578f, -0.11745586f, 0.11180382f, 0.03050559f, 0.03242235f, 
    0.27265498f, -0.10898575f, 0.14959636f, -0.02393274f, -0.08820292f, -0.00733826f, 0.15309693f, -0.13366428f, 
    -0.00012308f, -0.02779705f, -0.05522557f, -0.02698439f, 0.05342811f, 0.07688709f, 0.32614323f, -0.18367130f, 
    0.05497953f, 0.03692037f, -0.13525061f, 0.05471158f, 0.14262520f, -0.08675270f, 0.12098955f, 0.10325700f, 
    0.39458326f, -0.50717425f, 0.13136610f, 0.19475366f, 0.05480228f, 0.07260249f, 0.06666715f, -0.00969954f, 
    0.05804174f, -0.00674409f, 0.01788549f, 0.14927140f, -0.10796905f, -0.15523620f, -0.22436178f, -0.18205585f, 
    -0.29383829f, -0.04324656f, -0.06491768f, 0.13079254f, 0.09941002f, 0.01460219f, 0.01324239f, 0.02432949f, 
    -0.05669468f, 0.04125724f, -0.13159427f, 0.10161846f, -0.17366031f, -0.07930468f, 0.13575046f, -0.09140303f, 
    0.14018732f, -0.14074166f, -0.03530074f, 0.02925789f, 0.16371168f, -0.12188168f, -0.09759897f, 0.05475082f, 
    -0.01956019f, -0.00718251f, -0.02679463f, 0.07950293f, -0.04623564f, 0.01033286f, 0.17102316f, -0.05100628f, 
    -0.20399162f, -0.08546890f, 0.16553466f, -0.21561258f, 0.08158171f, 0.06111076f, 0.00206609f, 0.17439707f, 
    0.25789568f, 0.09733094f, 0.04731076f, -0.08734630f, -0.14516264f, -0.12092914f, 0.20280775f, -0.13551511f, 
    -0.03507617f, -0.00376251f, 0.01493043f, -0.11264372f, -0.08197591f, 0.04487387f, 0.10816227f, -0.00555697f, 
    -0.35714892f, -0.04921790f, 0.16806571f, -0.07650012f, 0.00454690f, 0.09970971f, 0.13966359f, 0.23245679f, 
    0.04057176f, 0.18539713f, -0.04064357f, 0.04124915f, -0.03973576f, -0.15881121f, -0.13538219f, -0.06886836f, 
    0.16514193f, 0.13594835f, -0.17827216f, 0.16924450f, 0.10177490f, -0.05672340f, 0.01400616f, 0.25870419f, 
    -0.11333130f, -0.09961223f, 0.02728107f, 0.15165998f, 0.03530709f, -0.04608211f, 0.17789769f, 0.16564329f, 
    -0.14646983f, -0.05263947f, -0.01066568f, 0.01890003f, 0.40313831f, 0.00001846f, 0.21942425f, 0.06380461f, 
    0.10819934f, -0.11492769f, -0.06672439f, -0.00184283f, -0.08287948f, 0.12510447f, -0.02383088f, 0.13281123f, 
    0.01913857f, -0.42130089f, 0.22841907f, -0.25345409f, -0.19117181f, -0.02474416f, 0.36578900f, 0.09337595f, 
    -0.04482285f, -0.04003935f, 0.00838126f, -0.05416926f, -0.21902835f, -0.00258961f, 0.05315316f, -0.24657419f, 
    0.16437118f, 0.20722860f, 0.02014392f, 0.16016468f, -0.26495239f, 0.14364022f, -0.09689456f, 0.10219977f, 
    0.31894177f, -0.07943446f, -0.17847477f, -0.35450625f, 0.24824543f, 0.05164731f, -0.18503870f, 0.17947949f, 
    0.24754328f, -0.08853614f, 0.13790052f, 0.05850688f, 0.68724334f, 0.08759629f, 0.14419277f, 0.12328438f, 
    -0.24898158f, 0.00142041f, 0.14646968f, 0.11913917f, 0.10427529f, -0.05765216f, -0.08438879f, -0.12613024f, 
    -0.09066987f, 0.39122346f, -0.00749722f, 0.33576384f, 0.00151495f, 0.11980981f, -0.04050096f, 0.09576280f, 
    0.02780672f, -0.03662027f, -0.02085867f, -0.04931869f, -0.27956784f, -0.11112364f, -0.22491962f, -0.00351533f, 
    0.00100280f, -0.04346627f, 0.01012219f, 0.27728757f, 0.08474775f, -0.00396670f, 0.01560172f, 0.02396308f, 
    0.42571798f, 0.10982662f, 0.03095982f, 0.35529822f, -0.30833444f, -0.01407139f, -0.20396955f, 0.02967850f, 
    -0.10912969f, -0.01759950f, 0.00482831f, -0.09535817f, 0.01461153f, 0.10020864f, 0.04038940f, 0.28590423f, 
    0.01953213f, -0.11613584f, 0.12465385f, 0.13648532f, 0.01584694f, -0.12368461f, 0.05995791f, 0.09619323f, 
    0.13038857f, -0.13801309f, -0.16072199f, -0.14307012f, 0.16283114f, 0.09071707f, -0.00043213f, 0.25339121f, 
    -0.02986330f, 0.07013826f, 0.02773906f, -0.01176850f, 0.03280743f, -0.43024179f, 0.03631507f, -0.13036412f, 
    -0.00043816f, -0.05037982f, 0.08300131f, 0.02880494f, 0.02479114f, 0.01550629f, 0.02388758f, 0.04660269f, 
    0.04413848f, -0.21372537f, -0.05589932f, 0.07642205f, 0.06061649f, 0.05469979f, 0.05710225f, 0.00980258f, 
    -0.05892373f, 0.02846146f, 0.08022485f, -0.04040464f, -0.07936250f, 0.31624740f, -0.06879422f, 0.27005321f, 
    0.07744364f, 0.04380918f, 0.03430047f, 0.27699071f, 0.00886378f, 0.08677135f, 0.06011374f, -0.07384566f, 
    -0.08154583f, 0.01306396f, 0.02405717f, 0.04525101f, 0.04604495f, 0.02370444f, -0.03036384f, -0.01147807f, 
    -0.02272427f, 0.01981690f, -0.04646899f, 0.04940942f, -0.03847829f, -0.03429343f, 0.02675034f, 0.01458242f, 
    -0.07064297f, 0.05020506f, 0.01309248f, -0.01788919f, 0.05969673f, -0.02729364f, -0.04502063f, -0.07223809f, 
    -0.06355468f, -0.01151635f, -0.04309198f, 0.05953590f, -0.02507040f, -0.06401901f, 0.05029849f, 0.01682695f, 
    0.03390688f, 0.05622997f, 0.03558146f, -0.05727769f, -0.07292935f, -0.07122125f, 0.01980386f, 0.03434204f, 
    0.02727953f, 0.04288419f, -0.04428682f, 0.01695952f, -0.04551875f, -0.06500547f, -0.02095746f, 0.05729114f, 
    0.03005187f, 0.05982170f, 0.03489065f, 0.06723327f, -0.01050169f, -0.05563338f, 0.02778236f, 0.06516006f, 
    -0.07842750f, 0.00506493f, -0.07221380f, 0.04014464f, -0.00973590f, -0.02102609f, 0.03195741f, -0.05346107f, 
    0.00147854f, -0.04202609f, -0.05357459f, 0.01320155f, 0.02012884f, -0.03295013f, 0.00924252f, -0.05333658f, 
    -0.01381282f, 0.02569059f, -0.04057145f, -0.02071871f, 0.02963395f, -0.06916583f, 0.05334409f, 0.00372541f, 
    0.01044193f, 0.05955730f, -0.02194455f, -0.06479282f, -0.02929455f, -0.07821985f, 0.02001613f, 0.05935554f, 
    -0.08741713f, -0.05713706f, -0.00053275f, -0.01707719f, -0.00590162f, -0.06902511f, -0.00404347f, -0.04144488f, 
    0.05320292f, -0.00872418f, -0.01390139f, 0.05567545f, -0.01222397f, -0.04343197f, 0.02658357f, -0.05239483f, 
    -0.07832698f, 0.04033228f, 0.02789320f, -0.07106066f, 0.01893326f, 0.03359146f, -0.03896641f, 0.01371396f, 
    -0.03075625f, 0.03917121f, 0.03800718f, 0.00714721f, 0.05616985f, -0.05511183f, 0.00222644f, -0.00263533f, 
    -0.04887457f, 0.02728657f, -0.05847203f, 0.04993279f, -0.02789664f, -0.02073855f, -0.08057266f, -0.05506169f, 
    0.02950808f, 0.02877077f, 0.03673089f, 0.00816758f, -0.04235014f, -0.04808147f, -0.09003638f, -0.05905016f, 
    0.01216453f, 0.03843697f, -0.00786027f, -0.01120788f, 0.06150823f, 0.04794690f, 0.02086457f, 0.00415684f, 
    0.05570137f, -0.01723619f, -0.00213217f, 0.06155828f, -0.02165309f, -0.05601465f, 0.02902088f, -0.03421680f, 
    -0.06699791f, -0.01037131f, 0.01854081f, -0.04375566f, -0.03666625f, 0.00795347f, -0.07921617f, -0.05755724f, 
    0.02809010f, 0.01963953f, -0.00279760f, 0.01626351f, 0.02737233f, 0.05406170f, -0.00075807f, 0.05540010f, 
    0.05747296f, -0.07156776f, 0.01254009f, -0.08062622f, 0.00649399f, -0.03655434f, 0.05819879f, -0.05900000f, 
    0.01499748f, 0.00654435f, -0.05444570f, 0.02329407f, -0.06374810f, -0.02024162f, 0.05992104f, -0.03172226f, 
    0.02613894f, -0.06008988f, -0.07715172f, -0.07568147f, 0.00872937f, -0.06538796f, -0.07983062f, -0.03455465f, 
    -0.05076490f, -0.04809414f, -0.01569722f, 0.06240520f, -0.01083632f, -0.05655949f, -0.06213481f, 0.04103170f, 
    -0.00158348f, 0.01817863f, -0.02892154f, -0.00195801f, 0.03053572f, 0.04210504f, 0.04853537f, -0.00505341f, 
    -0.01039934f, -0.07913424f, -0.05897883f, 0.03795032f, 0.00341879f, -0.03323307f, 0.03151576f, 0.04206265f, 
    -0.00285842f, 0.04057243f, -0.01627874f, 0.00052699f, -0.04383013f, -0.02525563f, 0.06267016f, -0.00235172f, 
    -0.07188375f, -0.05891238f, -0.06102660f, -0.02564522f, 0.03055431f, -0.01561797f, -0.03583575f, -0.00220993f, 
    -0.03875526f, -0.04172716f, -0.01283777f, 0.04867479f, 0.02704268f, -0.01667755f, -0.06622079f, -0.00544615f, 
    -0.04137497f, -0.02862488f, -0.01335973f, 0.00658959f, 0.03014153f, 0.05987910f, -0.04979292f, -0.07427166f, 
    0.05900724f, -0.06362961f, -0.04252388f, -0.05450974f, -0.04063403f, 0.00600066f, -0.02286481f, 0.03804506f, 
    0.02768489f, 0.04146856f, 0.01936983f, 0.00802713f, -0.05671938f, -0.03332277f, -0.03661298f, -0.06458100f, 
    -0.01993069f, -0.06092879f, 0.00028253f, -0.05447860f, 0.02349148f, -0.05880381f, 0.02074484f, -0.01696481f, 
    -0.04150185f, -0.04237014f, 0.05590987f, 0.06174751f, 0.00492876f, -0.04999247f, -0.01008589f, 0.00325385f, 
    -0.04989209f, -0.06820083f, -0.00846698f, -0.07440055f, -0.01717990f, -0.06952413f, -0.01814028f, 0.04388484f, 
    -0.00007729f, 0.03606592f, 0.02717052f, -0.06635530f, 0.02443376f, -0.06691009f, -0.00781334f, 0.02736910f, 
    -0.07291495f, 0.02091390f, 0.03019927f, 0.03588640f, -0.04030843f, -0.00660021f, 0.04621678f, -0.04370053f, 
    -0.07461344f, -0.06927186f, -0.01771337f, -0.00784093f, 0.00386342f, -0.04506765f, -0.03199508f, -0.02393468f, 
    0.03409217f, -0.02003375f, -0.03379597f, -0.00717998f, 0.04725353f, -0.03962509f, 0.00139112f, -0.01976347f, 
    -0.05841603f, -0.02896884f, -0.03025154f, 0.03886541f, 0.00873371f, 0.04144846f, 0.05629951f, -0.07127072f, 
    0.01374157f, -0.05860095f, -0.00202110f, -0.07072455f, 0.03850116f, 0.03028997f, -0.02860643f, -0.00312134f, 
    -0.02176490f, -0.01412760f, 0.05179314f, -0.07460555f, -0.02904120f, -0.07444587f, 0.04784386f, -0.01778184f, 
    0.05300791f, -0.04199431f, -0.04676132f, 0.02408554f, 0.01239491f, -0.01980324f, -0.00681899f, 0.00439688f, 
    -0.02640523f, -0.04926094f, -0.00182090f, 0.03783807f, -0.07875622f, -0.06329594f, 0.06368958f, -0.04678341f, 
    0.00766578f, 0.05591312f, 0.01672022f, -0.02372272f, 0.05254706f, 0.03933996f, 0.00445908f, -0.01952052f, 
    -0.03900354f, -0.00704218f, 0.04400273f, 0.06153842f, 0.03477957f, -0.05403945f, -0.06428996f, 0.05983174f, 
    -0.02091239f, -0.04152612f, 0.05341769f, -0.01800558f, -0.06163617f, -0.07915144f, 0.03156191f, 0.01773587f, 
    -0.29892293f, -0.08213563f, 0.19350031f, -0.06330504f, -0.03491263f, -0.07177844f, -0.09875863f, -0.02127615f, 
    -0.16569473f, -0.16971391f, -0.15478341f, -0.11647826f, -0.15399745f, 0.19669226f, -0.15033908f, 0.13087930f, 
    0.11208161f, -0.06322835f, -0.05935774f, 0.12674063f, -0.13245642f, -0.01295913f, 0.08721286f, -0.07955275f, 
    -0.38638407f, -0.36458001f, 0.15731190f, -0.07759485f, 0.05286900f, -0.19535720f, 0.08336383f, -0.03601759f, 
    -0.02220128f, 0.12544613f, -0.15483496f, -0.00806683f, 0.18778157f, 0.20007342f, -0.12905544f, -0.01574916f, 
    0.08444771f, 0.10405493f, -0.03604280f, 0.20772699f, 0.11404921f, -0.02378084f, 0.07383387f, -0.01764210f, 
    0.02494303f, -0.26566285f, 0.27811548f, -0.19434842f, -0.06103509f, 0.08545163f, -0.04791448f, 0.01359601f, 
    -0.04090824f, -0.05162042f, 0.16446392f, 0.19922823f, 0.01806361f, -0.33788317f, -0.32742298f, -0.00397159f, 
    0.04485118f, 0.02884341f, 0.11915130f, 0.05167927f, -0.16059148f, -0.00437824f, -0.08031613f, 0.01765345f, 
    -0.04462579f, 0.12239777f, 0.21572854f, 0.01212618f, 0.15614389f, 0.12116591f, 0.04958074f, 0.10291173f, 
    0.01707157f, -0.01380352f, 0.00021526f, 0.15465733f, 0.11676524f, -0.03114115f, -0.19893228f, -0.21643421f, 
    0.15281789f, -0.05028778f, -0.04829217f, -0.06069956f, 0.19302689f, 0.02139399f, -0.10948081f, -0.04549808f, 
    0.06280778f, 0.35446593f, -0.27305475f, 0.19465706f, 0.03312695f, -0.01259758f, -0.01673418f, -0.05154325f, 
    0.05930801f, 0.00735876f, 0.15352768f, -0.03232283f, -0.01246907f, -0.11322047f, 0.10228375f, 0.19274868f, 
    -0.14409791f, -0.10667551f, 0.03137991f, 0.01760006f, 0.06338238f, 0.03351913f, -0.00189286f, 0.05665342f, 
    -0.32142735f, 0.61905223f, -0.27776712f, -0.14258841f, 0.23226568f, 0.06691635f, 0.05308453f, -0.16193759f, 
    -0.00228979f, -0.11480237f, 0.02057340f, -0.03879020f, 0.10130915f, 0.18676111f, -0.04584613f, 0.15808603f, 
    0.12975788f, 0.28022161f, 0.08053629f, -0.18922916f, 0.01203671f, 0.04133376f, -0.06812485f, 0.06615140f, 
    0.36736065f, -0.02683804f, 0.09817578f, -0.12601900f, 0.17728566f, 0.19503447f, 0.16965199f, 0.15185899f, 
    -0.10817912f, 0.18350615f, 0.09293333f, -0.13665414f, -0.28698364f, 0.25321373f, 0.17684378f, 0.08000246f, 
    -0.00705378f, 0.17507982f, 0.00942601f, -0.02579215f, 0.10547587f, 0.03545633f, -0.09427710f, 0.14166079f, 
    0.05541100f, 0.15162167f, -0.35247022f, -0.05502837f, 0.02490476f, -0.00522223f, -0.02716376f, 0.01350398f, 
    0.03558464f, -0.03132297f, -0.05376038f, -0.11755612f, 0.45071965f, 0.28717980f, -0.25432882f, 0.42208007f, 
    -0.10060254f, -0.03708086f, 0.15353501f, -0.07913660f, 0.13310874f, -0.12184566f, -0.05037394f, 0.05657844f, 
    0.16027060f, 0.06096105f, 0.12593122f, 0.21883965f, -0.00696845f, 0.04942928f, 0.04325254f, 0.00555240f, 
    0.02059049f, -0.08845064f, 0.03473317f, -0.04667199f, -0.25084943f, -0.05705053f, 0.13211069f, -0.35339525f, 
    0.12062478f, 0.14226320f, -0.09636841f, -0.04665857f, 0.07250842f, 0.04522457f, 0.07133853f, 0.10963215f, 
    -0.13702559f, 0.04378926f, -0.17505674f, 0.29889324f, -0.05933003f, -0.00755522f, 0.02312714f, -0.11056095f, 
    0.10717611f, -0.01268669f, 0.16552347f, 0.12788741f, -0.27795941f, -0.32229450f, -0.08648478f, -0.30774274f, 
    -0.03559573f, 0.18881272f, 0.07728842f, 0.00420505f, -0.06956380f, 0.03890077f, 0.05033056f, 0.05956847f, 
    0.17591810f, 0.12634763f, 0.08616043f, 0.53702110f, -0.09920228f, 0.04354727f, -0.01809029f, 0.06652338f, 
    -0.09304334f, 0.07135042f, -0.10862011f, 0.00430542f, -0.11365339f, 0.38392398f, 0.42855659f, 0.27313265f, 
    0.03501344f, 0.08453257f, 0.00761128f, 0.04267695f, 0.00090775f, -0.08549510f, 0.02838217f, -0.03120370f, 
    0.15763442f, -0.00645695f, -0.19330187f, -0.27421588f, 0.00357696f, 0.22770973f, 0.07689752f, -0.07648414f, 
    0.07204416f, -0.11440985f, 0.00002979f, -0.02509750f, 0.03139122f, 0.22030334f, 0.18011324f, -0.26336470f, 
    -0.19143349f, -0.01918651f, 0.14737456f, 0.13954321f, 0.00264910f, 0.07850561f, 0.12244874f, -0.03063496f, 
    -0.74732345f, 0.45589533f, -0.17768501f, 0.05767461f, 0.07486123f, -0.10064445f, 0.16671979f, -0.00789299f, 
    0.15028787f, 0.06645712f, -0.19366351f, 0.22184236f, -0.13140249f, -0.06733239f, -0.26486251f, 0.07589187f, 
    -0.03062509f, 0.10267287f, 0.26305738f, 0.04263013f, 0.05150339f, 0.01295940f, -0.27716798f, -0.08130980f, 
    0.05767775f, -0.39483669f, -0.05694904f, 0.08104985f, -0.13487379f, -0.16971813f, -0.01617532f, 0.16208373f, 
    0.15118600f, 0.03749614f, 0.10890175f, 0.01854255f, 0.00625428f, 0.14582713f, 0.19355115f, 0.17313462f, 
    0.08548778f, -0.05601681f, 0.22512160f, 0.21969797f, 0.03065607f, -0.01063125f, -0.00743973f, 0.16312830f, 
    0.03995295f, 0.40644431f, -0.25502935f, 0.07703955f, -0.12917465f, 0.04422137f, -0.03889005f, 0.03135369f, 
    -0.16301471f, -0.07699877f, -0.01159971f, 0.04399667f, 0.60030770f, 0.00315918f, 0.19696209f, 0.12682332f, 
    -0.06427914f, -0.00384257f, -0.04181897f, 0.01844223f, 0.07473170f, 0.06149483f, 0.10203165f, 0.09057230f, 
    0.47097185f, 0.10308870f, 0.03443969f, 0.20517942f, 0.02167900f, 0.10386954f, -0.00185754f, -0.05958587f, 
    -0.08532998f, -0.07180829f, 0.05245280f, 0.10927557f, -0.29556817f, 0.45071992f, 0.22357205f, -0.09808823f, 
    0.10244416f, -0.06138858f, -0.00267964f, -0.00711244f, 0.11990931f, 0.11746393f, -0.02308466f, -0.18861139f, 
    0.02062462f, 0.05695952f, -0.01794624f, -0.04746509f, 0.02284865f, -0.03010833f, 0.05006089f, 0.04876650f, 
    -0.01813206f, 0.03734356f, 0.04897709f, -0.03701704f, 0.02027822f, -0.05736684f, 0.02557307f, -0.01378275f, 
    -0.04819450f, -0.00890185f, -0.06626329f, -0.02040617f, 0.01454200f, -0.03262736f, -0.07533356f, 0.02144811f, 
    -0.02048626f, 0.02567200f, -0.05790331f, -0.04803173f, -0.00247283f, -0.03298074f, 0.03307870f, 0.04370276f, 
    -0.07583185f, -0.06053609f, 0.00174296f, 0.06867947f, -0.08559627f, -0.06681191f, -0.07296530f, -0.05778850f, 
    0.05907814f, 0.05825480f, 0.00496399f, 0.03922149f, 0.06301725f, 0.06061647f, -0.02606748f, -0.01100261f, 
    -0.01159037f, -0.01199149f, 0.04075054f, 0.02649112f, -0.08901672f, 0.04220212f, -0.06647749f, 0.05967483f, 
    -0.01516800f, 0.01493289f, -0.03686573f, -0.02954221f, -0.03180422f, -0.08590721f, -0.02708925f, 0.02914731f, 
    -0.02525602f, -0.01358143f, 0.05604894f, -0.00299928f, -0.02883758f, 0.02567279f, -0.04824163f, -0.00693868f, 
    -0.06693570f, -0.01539708f, 0.00067803f, -0.07539397f, 0.03561912f, 0.00455005f, 0.01590655f, -0.07772788f, 
    0.05135447f, 0.02628673f, -0.01837244f, -0.01840638f, 0.04116805f, 0.00251106f, -0.04320516f, -0.04664282f, 
    0.00264657f, -0.01644919f, 0.00113441f, -0.03069971f, 0.04657875f, 0.02596212f, -0.04765380f, 0.02095106f, 
    0.00726382f, -0.07594016f, -0.03609250f, -0.02336293f, 0.04307641f, 0.03305536f, -0.07957278f, -0.07178374f, 
    -0.03094300f, -0.03957372f, -0.04437064f, 0.05304984f, 0.06228385f, 0.04301003f, 0.05647383f, -0.05216883f, 
    0.01168143f, -0.08437884f, 0.02711723f, -0.08397660f, -0.02945782f, -0.05233485f, -0.06327974f, 0.01970072f, 
    -0.06087401f, -0.05312578f, 0.06468294f, 0.02690443f, -0.04522321f, -0.00738936f, 0.05461256f, 0.04581777f, 
    -0.06637637f, -0.01448976f, 0.02103137f, 0.03544864f, 0.00537857f, 0.02298649f, -0.08041941f, 0.01104973f, 
    -0.07068375f, 0.01675572f, -0.02771980f, 0.03964573f, 0.03538036f, -0.03979949f, -0.00395084f, 0.02784122f, 
    -0.02564519f, -0.02233943f, -0.04709031f, 0.00324092f, 0.06034553f, -0.07366572f, 0.03668235f, -0.06788690f, 
    0.03329718f, -0.06600779f, 0.00294759f, -0.07038019f, 0.02190491f, 0.00572124f, -0.04604170f, -0.04556793f, 
    0.01192439f, -0.07616428f, -0.03471093f, 0.02077016f, 0.03148521f, -0.01109273f, 0.03041892f, -0.06740149f, 
    0.01915139f, 0.04912273f, 0.05882874f, -0.01514438f, -0.08388475f, -0.03595497f, 0.04175571f, 0.03486672f, 
    -0.06157109f, -0.02470094f, 0.02763008f, -0.07653553f, -0.07374594f, -0.02792920f, -0.04621420f, -0.00512680f, 
    -0.03543169f, -0.06687927f, -0.07217332f, 0.03827270f, -0.02546868f, 0.01353837f, -0.06780425f, -0.02901354f, 
    -0.06303634f, 0.04918702f, -0.00020125f, -0.12757270f, -0.09651576f, 0.04953354f, -0.12303837f, -0.06272788f, 
    -0.09563042f, 0.14174476f, 0.00609130f, -0.01559737f, 0.40415877f, 0.18543801f, 0.17320874f, 0.10464607f, 
    -0.19959752f, -0.14053224f, 0.10479028f, 0.04510071f, 0.09587430f, 0.19070126f, 0.01785215f, 0.04313805f, 
    0.45643762f, 0.05435206f, 0.23740685f, 0.08910654f, -0.16709122f, -0.15794931f, -0.08320061f, 0.14308821f, 
    0.00624009f, 0.01356501f, -0.05280583f, 0.03534751f, 0.43753365f, 0.08259020f, -0.03818175f, -0.03686912f, 
    0.03844725f, -0.02916479f, -0.06204776f, -0.05759578f, -0.07324766f, 0.04288916f, -0.04805122f, 0.03743614f, 
    -0.05609689f, 0.12948623f, 0.09249827f, -0.24652918f, 0.22036812f, -0.00403010f, 0.00806174f, -0.01909562f, 
    0.04500797f, 0.11597790f, -0.02050387f, 0.00590506f, 0.00354130f, -0.24033709f, -0.06689870f, -0.04782268f, 
    -0.02613040f, -0.07498603f, 0.01659594f, 0.04775770f, 0.06868902f, 0.00780184f, -0.04159870f, -0.13952646f, 
    0.23013672f, 0.28762162f, 0.14249372f, 0.14704469f, -0.08346020f, 0.02619137f, 0.02202959f, 0.00808245f, 
    -0.07389264f, 0.05966804f, 0.00638113f, -0.06077306f, -0.20924520f, -0.26813626f, -0.20668039f, 0.14717197f, 
    -0.03974400f, 0.03002261f, -0.06342063f, 0.08207420f, -0.09863822f, 0.09041695f, 0.01931323f, -0.06990603f, 
    0.41956416f, -0.00337650f, 0.35201028f, -0.01936658f, -0.02604080f, 0.02535805f, 0.03221085f, -0.10044087f, 
    -0.04728323f, 0.05679945f, -0.07507617f, 0.09211814f, 0.13756989f, 0.27271545f, 0.31027085f, 0.15705028f, 
    0.14021486f, 0.02381937f, -0.02486393f, -0.02139753f, 0.21775140f, 0.08976444f, 0.06927234f, 0.17240381f, 
    0.24607046f, -0.01209207f, 0.01860321f, 0.27102834f, -0.11236370f, 0.06291363f, -0.00985659f, 0.03005874f, 
    -0.03208473f, 0.02937379f, 0.21674258f, 0.03934116f, 0.02664871f, -0.12358411f, -0.25379542f, -0.05921011f, 
    -0.06315432f, -0.04504736f, -0.08584590f, -0.05743448f, -0.01796066f, -0.09629041f, 0.11801837f, -0.09539031f, 
    -0.12280937f, 0.30001193f, 0.32473448f, 0.00488437f, 0.03729285f, 0.03666669f, 0.12787876f, -0.01202809f, 
    0.16425221f, 0.10659031f, 0.08982724f, 0.00786705f, 0.05978496f, 0.16395086f, 0.00859593f, -0.09960457f, 
    0.07712507f, 0.05798414f, 0.08954044f, 0.00218836f, -0.08744534f, -0.05633166f, -0.07793293f, -0.07205493f, 
    0.27107486f, -0.06907160f, -0.08027539f, 0.08317325f, -0.18640631f, 0.05744261f, 0.10983562f, -0.05685305f, 
    0.10956560f, 0.05846450f, -0.05629846f, 0.01589167f, 0.26918808f, -0.24550143f, 0.17666011f, -0.05711247f, 
    0.05314768f, 0.07505010f, 0.09049681f, 0.08762988f, -0.04891101f, 0.04238545f, -0.02120890f, 0.20355913f, 
    -0.00049176f, 0.04417504f, -0.02729852f, 0.00193696f, -0.05780063f, 0.04919805f, -0.02180301f, -0.01631172f, 
    0.01218218f, 0.04310387f, 0.05526723f, -0.04576086f, 0.00028480f, -0.01012624f, 0.05452305f, -0.05961509f, 
    -0.05106742f, 0.00540455f, 0.03659108f, -0.02864232f, -0.01522475f, -0.00129012f, -0.01354966f, 0.04011298f, 
    -0.02537524f, -0.01759086f, -0.01291677f, -0.05939621f, 0.02380810f, -0.03911004f, 0.02879235f, -0.03456056f, 
    -0.01803537f, -0.01077601f, -0.03061113f, 0.03868421f, 0.05634537f, 0.04726914f, 0.00653772f, -0.06442843f, 
    -0.04369326f, -0.06190814f, 0.00104858f, -0.02823134f, -0.06592000f, 0.05876890f, -0.00220220f, -0.04846192f, 
    0.02381685f, 0.01980834f, 0.06579471f, -0.05565124f, -0.07057945f, -0.04113625f, 0.05748670f, 0.06866345f, 
    0.05603629f, -0.06643941f, 0.01873576f, -0.00932963f, -0.06383152f, -0.02036653f, -0.02668897f, 0.03739452f, 
    0.01396397f, 0.03517599f, -0.05252390f, -0.00676096f, -0.05427931f, 0.06661116f, -0.00234776f, -0.02649174f, 
    -0.07139535f, -0.04380057f, 0.07174824f, 0.04827444f, -0.00784324f, -0.04756574f, -0.01462582f, -0.05055530f, 
    0.00225065f, 0.01716963f, 0.06554826f, -0.00892115f, 0.04732525f, 0.03898153f, -0.06566218f, -0.01533549f, 
    0.01686548f, -0.06249689f, 0.02834570f, -0.01436495f, -0.06303824f, 0.01344663f, -0.02964657f, 0.06997068f, 
    -0.02199288f, 0.07089203f, 0.01602144f, -0.02688110f, -0.03930712f, -0.05365759f, -0.03823274f, -0.01129222f, 
    -0.01727250f, 0.06854974f, 0.01849113f, 0.06351756f, -0.06617802f, -0.06056416f, -0.00463905f, 0.01717654f, 
    -0.00638664f, 0.01127716f, 0.03045051f, -0.06003784f, 0.01682598f, -0.01296493f, -0.05867000f, -0.03916300f, 
    0.06917693f, 0.04990134f, -0.05903029f, -0.03914591f, -0.04460565f, -0.03839525f, -0.00907811f, 0.00507293f, 
    -0.00081685f, -0.02738705f, 0.03596657f, -0.05333982f, -0.05088217f, -0.07034873f, -0.04777315f, -0.03662363f, 
    -0.02192605f, -0.05357181f, -0.05112062f, 0.02886487f, -0.01103481f, -0.06991612f, -0.03959157f, -0.02425618f, 
    -0.03493581f, -0.01905085f, -0.04245206f, -0.04232845f, -0.05456008f, -0.00364477f, -0.06152709f, 0.02378020f, 
    -0.03333800f, 0.06546333f, -0.06439213f, 0.02713172f, -0.02854533f, -0.01979621f, 0.00989617f, 0.05656512f, 
    -0.03544618f, 0.02820351f, 0.02237555f, -0.03997762f, 0.03775706f, 0.04940036f, -0.02753043f, 0.05534776f, 
    0.05944759f, 0.00656348f, 0.03590991f, -0.03289661f, -0.04745103f, -0.01509581f, 0.05040018f, -0.00111569f, 
    -0.03466689f, -0.05818648f, -0.06885321f, 0.02480884f, -0.05454971f, 0.06070344f, -0.02418152f, -0.00775702f, 
    0.02117645f, -0.05361958f, -0.03059322f, 0.00691477f, 0.00110847f, -0.03941815f, -0.00949073f, 0.05862822f, 
    -0.06126167f, 0.03124644f, 0.00184774f, -0.07474190f, -0.06326862f, 0.01107909f, -0.06652163f, 0.02767466f, 
    -0.00440497f, 0.04514274f, -0.03557261f, 0.05111054f, 0.04597711f, -0.04292507f, 0.03744233f, 0.02730197f, 
    -0.03923525f, -0.04387234f, 0.05631855f, -0.02951700f, 0.01418316f, 0.04796174f, -0.06838527f, 0.03091007f, 
    -0.07655475f, -0.04953438f, -0.05520845f, -0.07215032f, -0.04352908f, 0.05188042f, 0.02382559f, 0.01959744f, 
    0.03523196f, -0.04168500f, -0.05959755f, -0.06107289f, 0.06229485f, -0.04618700f, 0.03946583f, -0.03056647f, 
    0.00914946f, 0.06036327f, -0.07054932f, -0.07029293f, -0.03530271f, 0.01651420f, -0.07871009f, -0.02201369f, 
    -0.03276978f, -0.07230110f, -0.01918970f, 0.04583766f, -0.06948211f, -0.00444866f, -0.04691932f, -0.05183203f, 
    0.01678354f, -0.05018551f, 0.03002403f, 0.05862218f, -0.03542215f, -0.05969939f, -0.07529719f, -0.02776655f, 
    0.05975341f, -0.04785785f, 0.00938937f, 0.05148773f, 0.03180685f, -0.04053257f, -0.01295854f, -0.06655687f, 
    -0.06023692f, -0.04669497f, 0.00856257f, -0.06760266f, -0.03345750f, -0.03760597f, 0.04019039f, -0.06657267f, 
    0.00460684f, -0.06204823f, 0.00945732f, 0.02803244f, 0.02755743f, -0.00843468f, 0.01319324f, -0.04875550f, 
    -0.00822407f, -0.00232812f, -0.07610764f, 0.02306011f, -0.04968010f, -0.02969388f, -0.07230645f, -0.02404951f, 
    0.04179970f, -0.02705404f, 0.03167033f, -0.07422137f, 0.00773289f, 0.03963246f, -0.04352630f, 0.03812983f, 
    -0.06118339f, 0.06049915f, 0.05074629f, -0.00988183f, -0.03594451f, 0.00818495f, -0.01003965f, -0.04249233f, 
    0.04526767f, -0.00051118f, -0.06094305f, -0.01414736f, 0.02545627f, -0.02755651f, 0.04890839f, 0.05057324f, 
    0.05777067f, 0.02336800f, 0.02128734f, -0.04207094f, 0.06399223f, 0.03456116f, 0.02790982f, 0.01404388f, 
    -0.04889572f, -0.07628848f, -0.06162265f, 0.03353737f, 0.06133045f, 0.05011987f, 0.04013712f, 0.05809975f, 
    -0.01198645f, 0.03280111f, 0.04439292f, -0.02506293f, -0.01767649f, -0.07429548f, 0.01220645f, -0.05785874f, 
    0.02036701f, -0.00101538f, 0.05030788f, -0.03675482f, -0.01133496f, 0.05734453f, 0.04458443f, -0.02037480f, 
    -0.03281273f, -0.00875285f, 0.03958166f, -0.00541155f, -0.00264403f, 0.05812091f, -0.00848108f, -0.04087448f, 
    0.06036008f, -0.08026918f, -0.04870955f, -0.05616402f, -0.03104258f, -0.00798521f, -0.07105097f, -0.02111784f, 
    -0.01905345f, -0.00747373f, -0.00641742f, -0.07887683f, -0.00216031f, -0.02236954f, 0.02221934f, -0.04614785f, 
    0.03481570f, -0.03416982f, -0.04574366f, -0.03654207f, 0.02271972f, -0.03598395f, -0.00169768f, -0.05265023f, 
    0.00597288f, 0.04059937f, 0.04677023f, 0.02441668f, -0.05420984f, 0.00852460f, -0.03279916f, -0.07099825f, 
    0.05871730f, 0.03218249f, -0.07148246f, -0.07292085f, 0.00211064f, -0.03149404f, 0.00951544f, -0.04412140f, 
    0.04809410f, -0.01782271f, -0.01115799f, -0.03110024f, -0.01111878f, 0.00552860f, 0.03279168f, -0.02413923f, 
    -0.01515473f, 0.06330721f, 0.00695732f, 0.05339890f, 0.00493206f, -0.01769069f, -0.06696688f, 0.01888856f, 
    0.00612719f, -0.00894376f, 0.00026103f, -0.04879046f, 0.02938267f, 0.03498212f, 0.02697359f, -0.06837638f, 
    0.02056321f, -0.06171801f, -0.05264654f, 0.06275965f, -0.01619506f, -0.01298022f, -0.06048557f, 0.05096852f, 
    -0.02065608f, 0.01605187f, -0.01515554f, -0.03651608f, -0.01532896f, 0.00342229f, 0.00972034f, -0.05127268f, 
    0.05929399f, 0.00251352f, 0.03203585f, 0.04319008f, -0.04628020f, -0.05020634f, 0.05212206f, -0.04970833f, 
    -0.04436557f, -0.07495518f, -0.07551180f, -0.00601442f, 0.03156727f, 0.05706669f, -0.06900792f, -0.02558113f, 
    0.06260293f, -0.05335546f, 0.04194691f, -0.02591382f, -0.00209564f, -0.07411668f, -0.03252263f, -0.05329116f, 
    -0.05343155f, -0.01386975f, 0.05974487f, -0.03990928f, -0.05128234f, -0.04315264f, 0.05982803f, -0.04570154f, 
    -0.04754077f, -0.04914213f, 0.06275520f, 0.01873738f, -0.00512762f, -0.04852670f, -0.04465290f, -0.05528642f, 
    -0.03540914f, -0.04068776f, 0.04931466f, -0.02428674f, -0.04499203f, 0.02229361f, 0.01232079f, -0.00746872f, 
    0.04057134f, 0.06558891f, -0.05821735f, -0.01474749f, 0.02370573f, 0.06210228f, -0.00578675f, 0.06576020f, 
    -0.06912325f, -0.07740305f, -0.04023914f, -0.02967906f, 0.02562891f, -0.03846712f, -0.03397113f, -0.04692280f, 
    -0.02724443f, -0.00101979f, -0.01666268f, -0.03725757f, 0.05230743f, -0.01979991f, -0.01650829f, 0.01585422f, 
    -0.07733886f, -0.07068644f, -0.00872648f, 0.00443864f, 0.05617593f, -0.07293312f, -0.05417750f, 0.01562799f, 
    -0.03163318f, 0.01306931f, 0.01646769f, -0.00820715f, 0.04841001f, -0.02825038f, -0.05312011f, 0.04473085f, 
    0.02652337f, -0.05242321f, 0.02432727f, 0.04014570f, -0.02413784f, -0.01743414f, 0.00782080f, 0.06068659f, 
    0.00768019f, 0.03666903f, -0.04001521f, 0.01825089f, -0.06493217f, -0.06405311f, -0.05184530f, 0.00852021f, 
    0.02740784f, -0.04176123f, -0.00004960f, -0.05152965f, -0.00741310f, 0.01647556f, -0.07177392f, -0.03948420f, 
    0.04809793f, -0.02659794f, -0.06435517f, -0.02247972f, 0.02689120f, 0.02913992f, -0.04660731f, -0.07261980f, 
    0.05052123f, -0.07628145f, 0.01637555f, 0.01313363f, 0.03961633f, 0.05659787f, -0.06482720f, -0.00645362f, 
    0.02421113f, -0.00565694f, -0.01667385f, -0.07571208f, -0.00323282f, -0.00049816f, 0.03820562f, 0.02953153f, 
    -0.05004188f, -0.01282967f, 0.02354025f, 0.05342727f, -0.04728779f, -0.03940269f, -0.05587602f, -0.01003394f, 
    0.07239915f, 0.17080466f, 0.19815761f, 0.05891875f, 0.16373605f, -0.00951702f, 0.13656241f, 0.04165401f, 
    0.11541558f, -0.27157554f, -0.21857396f, -0.08736055f, 0.03415291f, 0.00993289f, 0.13214484f, 0.01448529f, 
    0.02759261f, 0.26365328f, 0.20001082f, -0.05427278f, -0.17444856f, 0.09605689f, 0.09001785f, 0.24846542f, 
    0.02925034f, 0.01073593f, -0.06297955f, 0.21174204f, -0.22647133f, -0.00857855f, 0.15374938f, -0.18977346f, 
    0.01685754f, -0.13236745f, -0.00100896f, 0.08679640f, -0.35364881f, 0.01720018f, -0.10786188f, 0.14507857f, 
    -0.06361677f, 0.22931828f, -0.03813917f, 0.15195909f, 0.16180436f, -0.04163208f, 0.13546275f, -0.07784786f, 
    0.17295182f, 0.26101533f, -0.00368544f, -0.06694398f, 0.02547113f, -0.01666360f, 0.03349650f, 0.12373595f, 
    -0.12790459f, 0.13823196f, 0.02993498f, 0.10966066f, 0.10214049f, 0.07845608f, 0.12357651f, 0.00951100f, 
    0.12086727f, 0.07736325f, -0.00531826f, -0.12393514f, 0.18137275f, -0.06690282f, -0.25357869f, 0.27859771f, 
    -0.09822019f, 0.10563606f, -0.04953412f, -0.08796635f, -0.01002693f, -0.04483153f, 0.10508566f, -0.01861876f, 
    -0.10663990f, 0.11037584f, -0.07293328f, 0.17027973f, -0.45515963f, 0.15810473f, 0.19362153f, -0.30375987f, 
    -0.05471951f, -0.05802153f, 0.00044154f, 0.09156594f, -0.12190601f, -0.09186780f, -0.05298874f, -0.31688330f, 
    0.33703238f, -0.17745450f, -0.15863536f, 0.23807099f, -0.06667399f, 0.05117312f, 0.01982247f, 0.09710781f, 
    -0.06430706f, -0.02421730f, 0.04139341f, 0.07846948f, 0.33444911f, -0.05442744f, -0.21704938f, 0.07126360f, 
    -0.09260698f, 0.00699991f, -0.08625342f, -0.11341774f, -0.02372645f, 0.08979204f, -0.10205849f, -0.06231628f, 
    -0.31272891f, 0.35031244f, -0.18469857f, -0.09335294f, -0.01069827f, -0.03138869f, -0.03347161f, -0.07134238f, 
    -0.01195023f, -0.07505244f, 0.11894984f, -0.06823729f, -0.22876146f, -0.09391339f, 0.13993359f, 0.24055259f, 
    0.24683997f, 0.09381037f, 0.26694182f, -0.04190478f, 0.01168234f, 0.09019279f, -0.02420992f, 0.07620285f, 
    -0.08828153f, -0.11802193f, 0.01509286f, 0.01019637f, -0.03869062f, 0.00604230f, -0.12615584f, 0.24999030f, 
    -0.04779540f, 0.16927569f, 0.32202888f, 0.14733115f, 0.31894332f, 0.34252822f, -0.13221020f, -0.01887676f, 
    -0.02198672f, 0.05817738f, 0.01938154f, -0.03026249f, 0.13672389f, -0.01386905f, -0.13771808f, -0.00366044f, 
    0.47527012f, -0.01104903f, 0.08442404f, -0.04817059f, -0.11556243f, 0.16136548f, 0.13959095f, -0.22921740f, 
    -0.11254352f, 0.02617010f, 0.03184311f, 0.10800138f, 0.17680313f, 0.00780098f, -0.12345690f, 0.16519165f, 
    -0.04858172f, -0.11407333f, 0.15721856f, 0.17959794f, -0.02621774f, -0.00004747f, 0.01145281f, 0.00085448f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.30154622f, 0.17330711f, 0.14882974f, -0.06970949f, 0.06677930f, 0.06855886f, -0.02812301f, -0.06165919f, 
    -0.04874926f, 0.01347888f, -0.08720791f, -0.01510382f, -0.02225181f, 0.01697234f, -0.01534205f, -0.04455452f, 
    0.03078430f, 0.00762696f, 0.05120291f, 0.03054229f, 0.24319945f, 0.14250395f, -0.01740807f, 0.02443641f, 
    -0.16792117f, 0.02590204f, 0.04504495f, -0.07676041f, 0.05248553f, 0.05354065f, -0.06319623f, -0.09422016f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.41603112f, -0.17141756f, 0.14519335f, 0.39342716f, -0.22470212f, 0.08818708f, -0.47722605f, -0.12605372f, 
    -0.02872694f, 0.23726824f, -0.11546836f, 0.10771932f, 0.05909722f, 0.25731829f, -0.07201003f, -0.03329103f, 
    0.10928340f, -0.24311581f, 0.11902892f, -0.13078599f, -0.11179451f, -0.30054194f, -0.03432062f, 0.07108600f, 
    0.42525372f, 0.11378076f, -0.04704755f, -0.05530260f, 0.13954054f, -0.15632366f, -0.14821124f, 0.25927457f, 
    -0.13206400f, 0.22411121f, -0.18278418f, 0.06032280f, 0.22605005f, 0.03184718f, -0.17280664f, 0.00276417f, 
    0.31896067f, 0.33226264f, 0.07581615f, -0.17317462f, 0.02915492f, 0.01739961f, -0.10695777f, 0.00660469f, 
    0.11035797f, 0.28464517f, -0.14512618f, 0.10040408f, -0.04675596f, 0.40235212f, 0.05956768f, 0.00873626f, 
    0.68003243f, 0.24145357f, -0.15559077f, -0.08853790f, -0.13023987f, -0.15782857f, 0.08338341f, -0.01233915f, 
    -0.16670974f, -0.43271077f, 0.21492495f, -0.05773989f, 0.03195890f, 0.28306663f, -0.04491592f, 0.03148925f, 
    0.27517694f, 0.23314384f, 0.47546723f, -0.10608375f, -0.07398321f, -0.32448658f, -0.09923075f, -0.14691436f, 
    -0.00839514f, 0.07675741f, 0.12485168f, -0.12638821f, 0.21931522f, 0.19353643f, 0.14259706f, 0.03631906f, 
    -0.23539317f, 0.13060348f, 0.02087146f, 0.37862802f, 0.16803132f, 0.09361961f, -0.09974907f, -0.43892902f, 
    -0.31382313f, -0.17002790f, -0.26980013f, 0.08996233f, -0.05584194f, 0.35707441f, 0.01857347f, -0.03298208f, 
    0.53795028f, 0.13308689f, -0.14114131f, 0.02025615f, 0.13805883f, 0.30178502f, 0.07152345f, 0.10827376f, 
    0.09555810f, 0.44931194f, 0.13242614f, 0.02408766f, 0.28873059f, 0.14372826f, -0.04686284f, -0.04995596f, 
    -0.29433772f, 0.30974305f, -0.14003269f, 0.08519008f, 0.05753032f, -0.06525271f, -0.11698198f, -0.07351495f, 
    0.06245165f, 0.60205919f, -0.20892794f, 0.01448560f, 0.13385940f, -0.24324778f, 0.05400060f, 0.04662923f, 
    0.15397000f, -0.19501744f, -0.38118595f, -0.04160098f, -0.00218957f, 0.35435614f, -0.16583486f, -0.05662292f, 
    0.08777861f, -0.39730439f, -0.09654892f, -0.06983208f, 0.19848359f, 0.11731231f, 0.15180013f, -0.15957877f, 
    -0.02348331f, 0.05287848f, 0.06380840f, 0.22020341f, -0.08366010f, -0.15898493f, -0.06379429f, 0.25271297f, 
    -0.10063177f, -0.04732887f, -0.07450572f, -0.17469329f, -0.13203575f, -0.12287781f, -0.07723471f, -0.14938016f, 
    0.10988767f, -0.14801572f, -0.16109949f, -0.00528498f, -0.11235934f, 0.10477325f, 0.08583332f, -0.00998415f, 
    0.06980637f, 0.12738739f, 0.17636883f, 0.11841241f, -0.01810127f, -0.05858641f, 0.11862180f, 0.09010819f, 
    0.05249078f, -0.13986240f, 0.01130644f, 0.10321575f, 0.08795175f, -0.08078626f, -0.09567132f, -0.12314957f, 
    0.03643874f, 0.69491535f, -0.10825117f, 0.33216020f, 0.18092309f, 0.16066125f, 0.35844165f, 0.10119083f, 
    0.00513556f, 0.22037219f, 0.23144931f, 0.00342882f, 0.08215586f, 0.20525767f, 0.01998569f, 0.10423514f, 
    0.10126179f, -0.37905696f, 0.03276792f, 0.06580066f, 0.38181487f, -0.35787636f, -0.02060102f, -0.13512987f, 
    -0.20017479f, -0.25490257f, 0.08458924f, -0.06282155f, 0.04865948f, 0.14560366f, 0.15740523f, 0.00049503f, 
    -0.11213132f, 0.02856139f, -0.11411615f, -0.00234440f, 0.03613010f, -0.22241358f, -0.15653087f, -0.12512483f, 
    -0.15471117f, -0.04957056f, -0.10697388f, 0.14950289f, -0.15992311f, -0.13999277f, -0.16179946f, 0.08877248f, 
    0.11464984f, 0.11728691f, 0.08987790f, 0.09312921f, 0.00746571f, -0.13553745f, -0.06830656f, 0.02572989f, 
    -0.13192846f, -0.14828296f, 0.01792069f, 0.15785731f, -0.03746355f, 0.10561570f, 0.04551446f, -0.16136460f, 
    -0.15946166f, -0.21486446f, 0.33791837f, -0.09035710f, 0.06547759f, -0.22501864f, 0.06154336f, -0.04083933f, 
    -0.00910426f, -0.52687138f, -0.61164016f, -0.10131095f, -0.08131959f, 0.46095130f, -0.07944459f, -0.00897798f, 
    0.04435165f, 0.01217522f, -0.10264130f, -0.15969105f, 0.01952414f, -0.11915820f, 0.12700449f, -0.06890426f, 
    -0.07109571f, 0.25999689f, 0.07036238f, 0.45207208f, -0.15332618f, -0.07093142f, 0.04447467f, 0.54776186f, 
    0.25120926f, -0.16914444f, 0.18502089f, 0.24944940f, -0.04343810f, -0.03809008f, -0.22018449f, 0.19198880f, 
    -0.14327818f, -0.31351802f, -0.26652676f, -0.11898366f, 0.16452989f, 0.01839265f, -0.02316287f, -0.12758163f, 
    0.01885451f, 0.13681668f, -0.02437105f, -0.15042874f, 0.60159433f, -0.25933930f, 0.13983545f, 0.02715919f, 
    -0.26781791f, -0.21289173f, 0.02745253f, 0.46713376f, -0.09184139f, 0.06098380f, -0.07680639f, 0.11583929f, 
    0.05603271f, 0.20411699f, -0.32597759f, 0.12570229f, 0.13673279f, 0.21070488f, 0.19398752f, 0.07641402f, 
    -0.24119204f, -0.01873933f, 0.27113596f, -0.05298626f, -0.05920005f, 0.13014883f, -0.05570768f, -0.14775616f, 
    -0.03716682f, 0.08189876f, -0.13095205f, 0.10318724f, 0.09432188f, 0.05422568f, 0.10394561f, 0.08941235f, 
    -0.30685210f, -0.25877410f, -0.09521195f, 0.00794852f, 0.04100990f, 0.10253873f, 0.05751403f, -0.41039941f, 
    0.15410995f, 0.33144501f, 0.31216964f, 0.08091589f, 0.21326749f, -0.15707289f, 0.10655552f, -0.09829383f, 
    0.05503639f, 0.65202200f, -0.12313550f, -0.18493952f, -0.10068012f, -0.12997258f, -0.07722609f, 0.00052804f, 
    -0.05223230f, 0.01840813f, -0.16521102f, 0.01540013f, -0.21386077f, 0.31197506f, -0.01898815f, -0.04179720f, 
    -0.15662777f, 0.24388450f, 0.03557722f, -0.30833080f, -0.09701901f, -0.14626516f, 0.02765414f, 0.32202509f, 
    0.04721932f, 0.11980440f, -0.13643017f, -0.07270715f, 0.42636395f, 0.36791807f, -0.08555041f, -0.04220691f, 
    -0.04663593f, -0.01971578f, 0.15880746f, -0.06688907f, 0.12656951f, 0.31755769f, 0.00084560f, 0.18673024f, 
    0.15717217f, 0.14153783f, 0.10520896f, -0.14689888f, -0.27819392f, 0.18214974f, 0.03369809f, -0.03828963f, 
    0.28807971f, 0.42257720f, -0.06854118f, -0.43280563f, -0.09645437f, 0.08817896f, -0.14750005f, -0.06778137f, 
    0.21470965f, -0.18769348f, 0.39142683f, 0.02876787f, -0.15140079f, 0.19822854f, 0.25028425f, 0.13151528f, 
    -0.36020091f, 0.14034365f, 0.13149932f, 0.04016112f, -0.01342677f, -0.23081155f, -0.13579960f, 0.08850356f, 
    -0.05881837f, 0.05504080f, -0.00695560f, 0.14971876f, 0.15500383f, 0.40459141f, 0.13895871f, 0.10597372f, 
    0.25707126f, -0.08608205f, 0.03728123f, -0.07479945f, 0.04613345f, -0.03107125f, -0.05856592f, -0.24122171f, 
    0.01560762f, 0.19669816f, 0.25274426f, 0.17471053f, -0.24659801f, 0.37547609f, 0.13297506f, 0.00222740f, 
    0.42864892f, -0.08595384f, -0.32770187f, 0.12857200f, -0.10721273f, -0.02566841f, -0.14256246f, 0.00711574f, 
    0.02957019f, 0.12362725f, -0.01988919f, -0.00072167f, 0.40397343f, -0.26207203f, 0.04783487f, 0.01626838f, 
    0.26453555f, 0.21862893f, 0.11512891f, -0.21000990f, 0.00432022f, 0.06732933f, 0.17359205f, -0.19826493f, 
    -0.01680805f, -0.36535221f, -0.24937643f, 0.09454833f, 0.13399555f, 0.31439221f, 0.29757434f, -0.13521551f, 
    -0.06966326f, -0.19583446f, 0.32730070f, 0.11511566f, 0.11100186f, 0.10258981f, -0.00867851f, 0.15752448f, 
    0.06693435f, -0.05303671f, -0.15885946f, 0.08934025f, 0.23906033f, -0.05838313f, -0.07549831f, -0.12028826f, 
    0.21620440f, 0.26797318f, 0.09300463f, 0.26090488f, -0.17600170f, -0.08030728f, -0.11316313f, 0.02714218f, 
    0.47677198f, -0.63439435f, 0.09984242f, -0.05900996f, -0.04578055f, 0.32177943f, -0.24637944f, -0.01035710f, 
    -0.23917037f, -0.42880511f, 0.30902618f, -0.05641475f, 0.16036358f, -0.38248602f, 0.17600773f, 0.06671346f, 
    -0.01504969f, -0.21564281f, 0.03995612f, 0.11811298f, 0.30861196f, 0.34084296f, -0.01843473f, 0.08288900f, 
    -0.22356619f, 0.32244179f, 0.00104828f, 0.23847796f, 0.02664300f, -0.01707061f, 0.14989424f, -0.13844401f, 
    -0.12557377f, 0.02089464f, -0.00442843f, -0.12557310f, -0.04575085f, -0.05148446f, 0.02547248f, -0.04331765f, 
    -0.15322162f, 0.08653136f, -0.10403286f, 0.16403659f, 0.16216920f, 0.02473403f, 0.16105823f, -0.13991453f, 
    -0.04248379f, 0.00342053f, -0.13261425f, 0.11549313f, -0.02677033f, 0.01912889f, -0.05264862f, 0.12240667f, 
    0.10750013f, -0.06494688f, -0.05601261f, 0.10177370f, 0.00595078f, -0.03540487f, -0.02966719f, -0.06050587f, 
    0.26124343f, -0.14260255f, 0.47465563f, -0.18881755f, 0.14085616f, 0.38202596f, 0.09314231f, -0.15585834f, 
    -0.47819224f, -0.43816391f, 0.09029932f, -0.11147734f, 0.00052120f, 0.13636518f, -0.07561361f, 0.13382024f, 
    0.06558460f, 0.23542193f, -0.08569842f, 0.13013467f, 0.28137985f, -0.10011952f, 0.05707655f, 0.12123537f, 
    -0.25035632f, -0.05503938f, 0.12965557f, -0.08192991f, 0.04742226f, -0.14864007f, 0.06272254f, -0.38029227f, 
    0.12189112f, 0.15070304f, 0.10041218f, -0.22522980f, 0.21478826f, 0.47282666f, 0.02744517f, 0.05924049f, 
    0.18906650f, -0.13224857f, 0.04047835f, 0.08965255f, -0.14629801f, 0.05502788f, -0.15501657f, 0.17118675f, 
    -0.03371638f, 0.03558926f, 0.06935544f, 0.02688542f, 0.09256755f, -0.28474614f, -0.01086528f, 0.09411124f, 
    -0.44277412f, 0.23097722f, 0.09949674f, 0.10405567f, 0.16699965f, -0.03370415f, 0.05825904f, -0.06423628f, 
    0.25329697f, -0.25628835f, -0.47650167f, 0.01046292f, 0.06986400f, 0.22350264f, -0.02449473f, -0.10862136f, 
    -0.18191923f, 0.00792237f, 0.58106703f, -0.05237724f, 0.09016692f, -0.34172514f, 0.04610260f, -0.08095394f, 
    0.10295545f, 0.26876912f, 0.13254561f, -0.17065322f, 0.17124864f, 0.44153932f, -0.16038376f, 0.16705494f, 
    -0.14587893f, -0.23307405f, -0.07160878f, 0.13291903f, 0.14756374f, -0.04904159f, 0.16835664f, -0.28506735f, 
    -0.28659296f, 0.09447943f, -0.15424955f, 0.22111543f, 0.02127404f, 0.19313589f, 0.33439603f, -0.10719811f, 
    0.29507527f, -0.27826151f, 0.12093861f, -0.09717155f, -0.08865798f, 0.26478854f, -0.08172215f, -0.13807774f, 
    0.16336600f, 0.10554959f, -0.09335821f, 0.14716908f, -0.15048790f, 0.23924910f, -0.12365016f, 0.15072715f, 
    0.74308830f, 0.13015880f, 0.16143550f, -0.08202313f, -0.06153440f, 0.07049512f, -0.11678477f, -0.00261367f, 
    -0.08319703f, 0.09977806f, 0.49305093f, -0.18223785f, 0.32092834f, 0.16495188f, 0.38185266f, 0.17465901f, 
    -0.62237376f, -0.24780889f, -0.01205115f, -0.14988440f, 0.11568858f, 0.41722786f, -0.09879207f, 0.09642077f, 
    -0.16636486f, 0.45691344f, -0.14835390f, 0.15488526f, -0.30452549f, -0.04504174f, -0.11732388f, 0.14673702f, 
    0.27756658f, 0.12152924f, -0.13286155f, -0.21849294f, -0.05853679f, -0.02454175f, 0.15227105f, 0.19630191f, 
    0.05722985f, 0.29413170f, 0.21373764f, -0.20281228f, 0.23583992f, 0.09584866f, -0.69892150f, -0.14465593f, 
    0.45885873f, 0.12584803f, -0.03885223f, -0.13764727f, 0.13069609f, -0.14481796f, -0.06073004f, -0.11989021f, 
    0.12429363f, 0.14170507f, -0.15734756f, 0.09145865f, 0.05179393f, 0.09925080f, -0.16369058f, 0.11216441f, 
    0.36122340f, 0.04676617f, 0.13814719f, 0.05022886f, 0.04854944f, -0.12176435f, 0.16030742f, -0.39009711f, 
    0.08751044f, -0.03824313f, -0.01471385f, 0.33891565f, 0.41989636f, -0.12346472f, -0.27752855f, 0.16153358f, 
    -0.57783884f, -0.00844523f, 0.23394372f, 0.12073702f, 0.04219834f, -0.18100372f, 0.17805029f, -0.10209041f, 
    0.00496504f, 0.42841715f, 0.05147646f, -0.09848949f, 0.08658430f, 0.10194612f, 0.03234593f, -0.16396286f, 
    0.65524709f, -0.68727785f, 0.13880117f, 0.34532970f, 0.08682885f, 0.15226275f, -0.09092550f, -0.05002558f, 
    0.29131469f, 0.22252826f, 0.04779308f, -0.05130849f, 0.44794586f, -0.25522086f, -0.26582450f, -0.01166162f, 
    -0.30783415f, 0.55083245f, 0.34752196f, -0.03112459f, 0.16587044f, 0.14879633f, 0.09660615f, 0.00296414f, 
    -0.08728668f, 0.07105634f, 0.11372548f, -0.02601532f, -0.14400262f, 0.45091727f, 0.02364327f, -0.11148399f, 
    0.01238550f, 0.11567283f, 0.11737872f, -0.29841086f, 0.03916487f, -0.09012235f, 0.04404215f, 0.24912760f, 
    0.09034397f, 0.24381411f, 0.47920072f, 0.28816596f, -0.14137937f, -0.10007687f, -0.32020214f, 0.17996456f, 
    0.19760376f, -0.23166288f, -0.03906187f, -0.08061253f, 0.09869447f, -0.15209571f, -0.03959836f, -0.05983143f, 
    -0.15284668f, -0.15925039f, -0.02725440f, -0.00074185f, 0.36589229f, -0.01192975f, 0.04371042f, 0.16060756f, 
    0.18134287f, -0.29162729f, 0.00577419f, 0.23289087f, 0.15397321f, 0.16276112f, -0.12968311f, -0.18526950f, 
    0.25334802f, 0.21271187f, -0.01573890f, 0.21603949f, -0.33409777f, -0.01866667f, 0.64371014f, -0.07445628f, 
    0.02940706f, 0.18651116f, -0.01206399f, -0.00501797f, 0.03854229f, 0.00998570f, 0.06549978f, -0.06019485f, 
    -0.14684406f, -0.45067707f, 0.01756706f, 0.13205482f, 0.09974565f, 0.24704610f, -0.10302497f, -0.13939498f, 
    -0.07761452f, 0.32418382f, -0.07762246f, -0.16901709f, 0.13866861f, -0.07189121f, -0.15231472f, 0.37519112f, 
    0.43218270f, 0.03616203f, -0.40433094f, -0.02550388f, 0.11204627f, -0.04299093f, -0.17553067f, -0.15690273f, 
    0.38019055f, -0.11761632f, 0.36883083f, 0.07601185f, 0.02941962f, -0.05257585f, -0.09183606f, -0.12206386f, 
    -0.11930060f, 0.01069547f, 0.00601122f, 0.08498348f, 0.50552034f, 0.29635552f, -0.14678153f, 0.07712176f, 
    -0.32086623f, 0.34712353f, 0.04687329f, -0.03305225f, -0.09757885f, 0.15761144f, 0.02005572f, -0.15407887f, 
    -0.29639068f, -0.05029520f, -0.20159559f, 0.34186476f, -0.18672881f, 0.26347840f, 0.54625982f, -0.11237416f, 
    0.40980020f, 0.07909444f, 0.43273941f, 0.04438186f, -0.07699246f, 0.28646928f, -0.00967258f, 0.05203867f, 
    -0.05171988f, -0.44778618f, -0.16794948f, -0.08370706f, -0.10682283f, -0.13416331f, -0.05282202f, -0.13453785f, 
    0.15155059f, 0.35934082f, 0.03064441f, 0.30393654f, -0.01156185f, -0.17080133f, -0.04404579f, 0.13568552f, 
    -0.03893777f, 0.05778558f, 0.08056069f, -0.10223772f, 0.21575420f, 0.30575699f, -0.26442495f, 0.14170404f, 
    0.28730193f, 0.04624809f, -0.02978509f, 0.13471103f, 0.05165809f, 0.41382116f, 0.03332083f, -0.05085287f, 
    0.01092357f, 0.35745901f, -0.06246497f, -0.08203140f, -0.32190359f, -0.13868783f, 0.16394427f, -0.09733087f, 
    -0.00004147f, 0.33869699f, -0.16123767f, 0.04074548f, 0.08858321f, 0.15094741f, 0.03970863f, -0.19401133f, 
    0.15969284f, 0.56163383f, -0.11998525f, -0.07737239f, 0.11750124f, 0.17799586f, 0.00518918f, 0.09426367f, 
    0.46655285f, 0.21179096f, -0.32579610f, 0.01210030f, -0.05081043f, 0.09984462f, -0.09341684f, -0.13758144f, 
    -0.09778151f, 0.15078738f, -0.16167860f, -0.01631125f, 0.32656190f, -0.00406541f, 0.02951559f, -0.05545510f, 
    -0.48543820f, 0.34612912f, 0.07923859f, -0.42392600f, 0.10106369f, -0.10414964f, 0.11590508f, -0.14780565f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.07491494f, -0.02552099f, 0.12024915f, 0.01402064f, -0.02672336f, -0.11826066f, -0.00919316f, 0.07215736f, 
    -0.04677254f, 0.25589338f, 0.15941437f, 0.19927156f, 0.07862036f, 0.15989707f, 0.09614509f, 0.06211415f, 
    0.24953641f, -0.17094333f, 0.13405137f, -0.07619298f, -0.02157190f, -0.26146528f, -0.13171931f, 0.01121244f, 
    0.21992189f, 0.21020366f, -0.02147105f, 0.16163622f, 0.19390754f, -0.08399873f, -0.07845251f, 0.08344171f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.32041615f, 0.19304660f, 0.31387392f, -0.13212982f, -0.61775041f, -0.00945695f, -0.80279022f, 0.00853793f, 
    -0.62076491f, -0.98648471f, -0.43120417f, 0.03180661f, 0.22397940f, 0.04672796f, -0.54765385f, 0.23129754f, 
    0.39663023f, 0.08036232f, -0.73216271f, -0.09563282f, 0.14580894f, 0.18840814f, -0.14284776f, -0.04875905f, 
    -0.12045666f, 0.08572683f, -0.45546922f, 0.04835812f, 0.19961721f, 0.21972845f, 0.05687140f, -0.56127065f, 
    -0.60194945f, -0.02738990f, 0.32608372f, -0.14543468f, 0.20978035f, -0.07861450f, -0.40905496f, -0.00862113f, 
    0.30260557f, -0.07270376f, 0.23465452f, 0.12524690f, -0.06880023f, 0.28120926f, -0.35660347f, -0.29435951f, 
    0.35926554f, 0.03161523f, 0.16072612f, -0.23643237f, 0.37157309f, -0.16888480f, -0.05020520f, 0.01592923f, 
    0.09793635f, 0.04313501f, 0.20338103f, -0.00159449f, 0.14735460f, -0.24490826f, -0.31119126f, -0.03246407f, 
    0.26161540f, 0.07373073f, 0.06353376f, -0.37880269f, -0.40680155f, -0.04056428f, 0.19636163f, -0.15300216f, 
    -1.06709218f, 0.47038403f, -0.36369225f, 0.13558495f, -0.43885800f, 0.10360027f, 0.03283348f, -0.15588826f, 
    -0.04332840f, -0.04579091f, -0.22795294f, -0.50525820f, -0.00138087f, -0.20841877f, -0.35681248f, -0.11900483f, 
    0.53815347f, -0.01918340f, 0.49065429f, 0.02915693f, -0.03876518f, -0.08230960f, -0.94743884f, -0.64348805f, 
    -0.03897311f, 0.03319110f, -0.48929358f, 0.08917014f, 0.42655620f, -0.16542296f, 0.03087381f, -0.01787864f, 
    0.17520662f, 0.12990874f, -0.12947147f, -0.10547671f, -0.14319225f, -0.14293510f, 0.17292410f, 0.15215899f, 
    0.22060968f, -0.11817932f, -0.19598030f, -0.08767597f, -0.47135329f, 0.23115021f, -0.43820894f, -0.82505453f, 
    -0.79207844f, -0.25329840f, -0.05625809f, 0.28455752f, 0.30948314f, 0.14929888f, -0.35002381f, 0.16525058f, 
    -0.15924856f, -0.03410167f, -0.01941123f, -0.03514516f, -0.03111802f, -0.07035846f, 0.53405088f, 0.16073932f, 
    -0.05976086f, -0.50239307f, 0.38671714f, 0.20468612f, 0.05409760f, -0.02734728f, -0.15981868f, -0.06190522f, 
    -0.48996443f, 0.16087984f, -0.60672611f, 0.07376502f, 0.35182291f, 0.03332265f, 0.05536243f, -0.71447289f, 
    -0.18061423f, 0.05254722f, -0.54719138f, 0.24354091f, -0.06552220f, 0.41982254f, -0.13173829f, 0.12703183f, 
    -0.37747547f, 0.17372139f, 0.06257958f, 0.24863705f, -0.86260980f, -0.09641232f, -0.37386364f, -0.02882073f, 
    -0.03234026f, -0.26745570f, 0.11586925f, -0.00115182f, 0.20919685f, 0.12605162f, 0.41141564f, -0.06972250f, 
    -0.17304485f, 0.13896762f, 0.34926131f, 0.20148325f, -0.16160493f, 0.33335438f, 0.44551247f, 0.13057937f, 
    -0.06081231f, -0.14181100f, -0.21639416f, -0.13078120f, -0.17133071f, -0.06507247f, 0.26228639f, 0.15108968f, 
    0.05602808f, 0.21537328f, -0.35446760f, 0.08694827f, 0.19672897f, 0.04572417f, -0.25899017f, -0.12897746f, 
    0.04480765f, 0.05128266f, -0.49968541f, 0.36752015f, 0.19265129f, -0.10905027f, -0.35668188f, -0.79614359f, 
    -0.62087327f, -0.03850443f, -0.64500546f, 0.00602983f, -0.60729533f, -0.22472738f, 0.17554200f, 0.23497842f, 
    -0.26858938f, 0.34524739f, -0.59164578f, -0.07084355f, 0.13529699f, -0.41751510f, 0.29387018f, 0.44971222f, 
    0.31801656f, -0.17565237f, 0.13935092f, 0.25969124f, -0.00992348f, 0.04915890f, -0.08656473f, 0.03732543f, 
    0.46950591f, 0.27817234f, -0.30252859f, -0.06948327f, -0.58648235f, -0.32860777f, 0.08042581f, -0.09059942f, 
    -0.59672123f, -0.06441971f, -0.02882299f, 0.17257905f, -0.06697785f, 0.11243598f, 0.13957691f, 0.01456677f, 
    -0.05227344f, -0.52041101f, 0.25364301f, -0.01917381f, -0.78392303f, 0.33869526f, 0.28481016f, -0.46886170f, 
    -0.59163052f, -0.11417498f, 0.20023926f, 0.15094426f, 0.06719601f, -0.03760721f, 0.38175935f, -0.13753861f, 
    -0.04401893f, 0.23953822f, 0.43828401f, -0.56644583f, 0.00526486f, -0.44594517f, -0.36092561f, 0.21681920f, 
    0.07964957f, -0.01257055f, 0.36180827f, 0.34048033f, 0.26232418f, -0.11751893f, -0.19269903f, 0.11720593f, 
    0.30378881f, -0.21651916f, -0.04534759f, -0.72911954f, 0.25860891f, -0.16716951f, 0.17114253f, -0.01540018f, 
    0.12762330f, 0.23898076f, -0.77715194f, -0.75478536f, 0.07891248f, 0.12454263f, 0.08916142f, -0.04119317f, 
    0.25546530f, -0.42622635f, 0.07503977f, 0.15347640f, 0.26766208f, 0.05600984f, -0.23801884f, -0.35989645f, 
    -0.33574963f, 0.01621429f, -0.11341803f, -0.63386136f, -0.28998235f, 0.34226719f, 0.37824526f, 0.07337430f, 
    0.41926157f, 0.19774286f, 0.07956312f, 0.06086091f, -0.52577209f, -0.04292945f, -0.09290298f, -0.37784296f, 
    0.24619561f, -0.49181217f, -0.20231740f, -0.60470176f, -0.03612223f, 0.11668452f, 0.19452888f, -0.01652348f, 
    0.20703350f, 0.29935637f, 0.03282497f, -0.00944837f, -0.14364223f, 0.08341747f, 0.15815793f, -0.08944761f, 
    0.31683692f, -0.16314116f, 0.63111407f, 0.41213900f, -0.18934555f, -0.58494890f, 0.34901208f, -0.20364723f, 
    -0.12987810f, -0.15667680f, 0.20273697f, 0.10725312f, -0.13764751f, -0.19686900f, 0.07126734f, -0.00005482f, 
    0.22744673f, 0.10006067f, 0.14798985f, -0.13228783f, 0.07563319f, 0.14813137f, 0.32216305f, -0.12018709f, 
    -0.81795698f, -0.34156504f, -0.27102911f, 0.10312340f, 0.01265082f, -0.07001830f, 0.47272471f, -0.45923203f, 
    -0.17315242f, -0.04958440f, -0.14330682f, 0.07737129f, -1.02565455f, 0.03019921f, -0.63786602f, 0.52229285f, 
    -0.70440000f, -0.16470709f, 0.34182677f, 0.11785287f, 0.13249837f, 0.07998816f, 0.03735955f, 0.40573049f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.17287925f, 0.17037666f, -0.00485289f, 0.05801579f, -0.03837041f, -0.18383251f, -0.02646189f, -0.28195220f, 
    -0.20247576f, 0.12619312f, -0.06652872f, 0.00179148f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
