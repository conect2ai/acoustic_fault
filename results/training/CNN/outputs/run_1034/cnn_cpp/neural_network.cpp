#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.18423344f, 0.17226562f, -0.17662992f, 0.26144591f, -0.10076271f, 0.10370786f, -0.33561155f, -0.10758795f, 
    0.26773655f, -0.01901225f, 0.08086010f, 0.03100074f, 0.10197141f, -0.00824351f, 0.12479587f, -0.09686195f, 
    0.12041413f, 0.12359617f, 0.04348736f, 0.21318677f, -0.00782211f, 0.09200885f, -0.15438814f, 0.31185609f, 
    0.06503923f, -1.10113013f, -0.05583907f, -0.42266974f, -0.58810449f, 0.09186406f, 0.19856866f, 0.08617895f, 
    0.29200128f, 0.69844061f, 0.27954698f, 0.22844815f, -0.10977615f, 0.23623180f, -0.19089656f, -0.03030555f, 
    -0.09876356f, 0.13807897f, -0.04000524f, 0.00331499f, 0.11845407f, -0.04180413f, -0.02235329f, 0.03718593f, 
    -0.12926604f, -0.00414151f, 0.21738712f, 1.08096945f, 0.17831111f, -0.45539191f, -0.64122802f, -0.43649030f, 
    -0.11247028f, 0.10298775f, -0.26954770f, -0.50468004f, 0.15760972f, 0.49316001f, -0.07119339f, 0.22527182f, 
    0.10291038f, 0.02154384f, -0.04131761f, -0.22199962f, -0.12168008f, -0.20945315f, -0.01265386f, 0.13395579f, 
    -0.04722337f, -0.21491978f, -0.00352134f, 0.10804014f, 0.31317449f, 0.11611617f, -0.46035111f, 0.14149661f, 
    0.01022224f, -0.20898043f, 0.13905646f, -0.16210338f, 0.11746795f, 0.08397146f, -0.11613224f, -0.28399697f, 
    0.42766589f, 0.01845124f, -0.01449988f, -0.04010947f, -0.31280765f, 0.01568040f, 0.13554730f, -0.09193866f, 
    0.13467322f, 0.21452275f, 0.21438687f, 0.31474152f, 0.18635787f, 0.17853209f, 0.37393516f, 0.33968106f, 
    0.09881362f, -0.06436005f, 0.02338183f, 0.27713478f, 0.33705866f, 0.03363756f, -0.24682735f, -0.11365772f, 
    -0.04498804f, 0.04928550f, -0.00267261f, 0.11390810f, -0.09512486f, -0.11314586f, 0.05648698f, 0.08098535f, 
    -0.21814643f, 0.04070039f, -0.39424300f, -0.12205877f, -0.38097611f, 1.18589449f, -0.64126676f, -0.63424456f, 
    -0.49115852f, -0.18781126f, 0.23167452f, 0.30647308f, 0.23078910f, 0.18480152f, -0.31697953f, 0.12079684f, 
    0.35058525f, 0.03302686f, -0.20128773f, -0.10231075f, -0.32750836f, -0.06416244f, -0.14760871f, 0.09161508f, 
    -0.13079621f, 0.41267517f, 0.08099907f, -0.13372907f, -0.02163016f, 0.04098135f, -0.10489380f, -0.10564379f, 
    -0.58265871f, -0.39925337f, -0.15870935f, 0.00410312f, -0.21116123f, 0.27049223f, -0.56602257f, -0.20174296f, 
    -0.23730232f, -0.05520296f, -0.14957853f, 0.34587535f, -0.23559873f, -0.10500752f, -0.65478569f, 0.13501120f, 
    -0.22849676f, -0.41720164f, 0.09364017f, 0.13671225f, -0.25506395f, -0.09209765f, 0.05563900f, -0.92141718f, 
    -0.02057049f, -0.42005739f, -0.17883240f, 0.09903491f, 0.36873552f, -0.16022256f, 0.07457475f, 0.10831462f, 
    0.47531292f, 0.32470185f, -0.06501783f, 0.16202867f, -0.22079517f, -0.08428667f, -0.25107646f, -0.12958159f, 
    -0.29738894f, 0.36081025f, -0.09833239f, 0.22936584f, 0.29869711f, 0.34730980f, -0.14075929f, -0.39495900f, 
    0.20190176f, -0.80320060f, -0.22926940f, -0.22032015f, -0.95703524f, 0.87222743f, 0.24631025f, -0.27219537f, 
    0.01147994f, 0.30209449f, -0.23948909f, -0.05150658f, -0.17990120f, 0.11264859f, 0.47835356f, -0.30748791f, 
    0.20828679f, -0.02593371f, -0.06475487f, -0.27171090f, 0.09450089f, -0.15412472f, 0.25268105f, 0.09378792f, 
    -0.12964973f, 0.52173257f, 0.33171266f, 0.26475635f, -0.39376187f, 0.09037642f, 0.34368491f, -0.39981842f, 
    -0.03275020f, 0.23303528f, -0.25086880f, 0.32066292f, -0.28569058f, -0.13925050f, -0.04840844f, 0.17736852f, 
    0.32237807f, 0.10366226f, -0.05413019f, 0.10920248f, -0.38740140f, -0.03190552f, 0.21477321f, 0.01037424f, 
    -0.07641201f, -0.03631649f, -0.50381327f, -0.46324459f, -0.85179484f, -0.51008427f, -0.45775750f, 0.25622013f, 
    0.49474478f, 0.43552101f, 0.20715074f, 0.00054066f, 0.13050550f, -0.02428468f, -0.10496391f, -0.02890996f, 
    -0.27189183f, -0.13773189f, 0.18995966f, -0.12906846f, -0.01268189f, -0.28898597f, -0.22544645f, -0.35527813f, 
    0.07671254f, -0.13817520f, -0.38643792f, -0.12433521f, 0.23922271f, 0.48403975f, 0.69202751f, -0.61163777f, 
    -0.05821079f, 0.06014713f, 0.25276038f, -0.56816143f, -0.46698612f, -0.04491036f, 0.15415373f, -0.11372908f, 
    0.13522702f, -0.06013346f, -0.26180881f, 0.23169912f, 0.16100150f, -0.08968305f, 0.05614350f, -0.04163343f, 
    -0.14293890f, -0.10401250f, -0.07978684f, -0.30795684f, 0.25694081f, -0.44893372f, 0.11386804f, 0.08026430f, 
    -0.73788583f, -0.45643917f, -0.17510363f, -0.54101509f, -0.64504921f, -0.59527302f, 0.10246350f, -0.08308437f, 
    -0.20530680f, -0.20326626f, -0.31136534f, -0.04070444f, -0.05262903f, -0.03833367f, 0.05057544f, -0.17360425f, 
    -0.23485796f, -0.33991745f, -0.14146192f, 0.19655320f, 0.24456783f, -0.20394401f, 0.47878513f, -0.25297326f, 
    -0.55756885f, 0.39205879f, 0.05346326f, 0.25049549f, 0.11891064f, 0.08851402f, 0.01842414f, -0.13124670f, 
    -0.08291229f, -0.26623192f, -0.03800010f, -0.18934904f, 0.24674179f, 0.02351103f, -0.36971229f, -0.08463138f, 
    -0.26533967f, 0.23206086f, 0.13465659f, 0.30806503f, 0.24259032f, -0.11801466f, -0.33929607f, -0.29243889f, 
    -0.35625505f, 0.44752240f, 0.46269816f, -0.12246778f, 0.08912444f, -0.04130517f, -0.15868348f, 0.32083225f, 
    -0.02519787f, 0.29941091f, -0.05664579f, -0.06547017f, 0.00018720f, -0.19829576f, -0.38070989f, 0.48744965f, 
    -0.33643603f, -0.53552794f, -0.13646871f, 0.25953725f, 0.28645036f, 0.26550511f, 0.21748583f, -0.08154842f, 
    -0.47662595f, -0.56930667f, -0.69214922f, -0.18501306f, -0.02346441f, 0.18018487f, 0.60061264f, 0.26551813f, 
    -0.24733500f, 0.01775911f, 0.29449520f, 0.16269612f, 0.14397413f, 0.14769280f, 0.08217727f, 0.20302954f, 
    -0.04070341f, 0.17892097f, 0.31233537f, 0.12171847f, -0.36752608f, -0.16693737f, 0.23833144f, -0.18303178f, 
    0.72177583f, -0.09352281f, 0.16656984f, -0.24652089f, -0.01564881f, 0.41796291f, 0.40672493f, 0.11111432f, 
    -0.45437691f, 0.09883559f, -0.16835459f, 0.07523542f, 0.19824558f, -0.17184936f, 0.04715201f, -0.03983220f, 
    -0.09021986f, -0.02379830f, 0.00438881f, -0.21676157f, -0.03507413f, -0.10152794f, -0.25634098f, -0.21459424f, 
    0.01791037f, -0.84811395f, 0.24545641f, 0.04667041f, 0.21282595f, 0.51439273f, 0.24623871f, -0.23442493f, 
    -0.42973867f, 0.32467151f, -0.05980171f, -0.03650413f, -0.12433083f, -0.00271779f, -0.18921228f, 0.27591923f, 
    0.26596066f, -0.16459282f, -0.17843752f, -0.29809019f, 0.27323511f, 0.21787746f, 0.14745323f, -0.30900744f, 
    -0.05130101f, -0.10550819f, -0.69132763f, -0.42760667f, -0.27179277f, 0.08542912f, -0.24216311f, -0.29388407f, 
    -0.62436610f, 0.00311254f, 0.09548412f, 0.42451802f, 0.00691111f, -0.24363802f, 0.08795296f, -0.10863513f, 
    -0.28671670f, -0.13938363f, -0.36766446f, -0.27173096f, -0.20422474f, -0.48137206f, 0.13864936f, -0.10430828f, 
    0.06787826f, -0.12361818f, 0.38826057f, 0.03089242f, 0.33984789f, 0.30972159f, -0.11417639f, -0.58162105f, 
    -0.20674279f, -0.39033768f, -0.04764726f, 0.33806604f, -0.32631338f, 0.27092323f, 0.13426377f, 0.02889372f, 
    0.39730975f, -0.46634364f, -0.10850677f, 0.08741482f, -0.15567903f, 0.02950115f, -0.33721343f, 0.23337615f, 
    0.26957810f, 0.01452049f, -0.08419748f, 0.20497504f, 0.53745031f, 0.66266441f, 0.33618408f, 0.06634922f, 
    0.26030716f, -0.54202032f, -0.39128426f, -0.25479817f, -0.33028722f, -0.31336650f, -0.09704722f, -0.21657801f, 
    0.00076101f, 0.16347224f, -0.14551292f, -0.08114994f, -0.04882622f, 0.37777588f, 0.01545214f, -0.19284238f, 
    -0.05379236f, 0.01975653f, -0.08043053f, 0.06609150f, -0.01527210f, -0.18466286f, -0.19428989f, 0.10838278f, 
    -0.02087051f, 0.16288169f, 0.10546529f, -0.34814262f, 0.26080278f, 0.12255695f, -0.09279320f, -0.25159082f, 
    -0.25097194f, 0.41794479f, -0.29129139f, 0.39659822f, -0.35366359f, -0.07547863f, -0.12176017f, 0.25533134f, 
    0.22327977f, -0.05730912f, 0.18280929f, -0.07204561f, -0.00686379f, 0.19593976f, 0.03747254f, 0.24456236f, 
    0.30931452f, -0.38334033f, 0.17076336f, -0.31896335f, 0.23182411f, 0.22456680f, -0.28745601f, -0.40915111f, 
    -0.29913455f, 0.47904107f, 0.14831643f, -0.40516803f, 0.23457219f, 0.11296370f, 0.20171161f, 0.02310799f, 
    0.16977820f, -0.18344325f, 0.05132990f, 0.07191788f, -0.30837166f, 0.02053660f, 0.27778256f, -0.44156897f, 
    -0.36035827f, -0.29586375f, -0.25520632f, -0.36958218f, -0.27524674f, -0.37969318f, -0.65583432f, -0.08933411f, 
    -0.64027047f, 0.30715907f, 0.05236273f, 0.45970890f, 0.21818054f, 0.21209319f, 0.19303733f, -0.20827298f, 
    -0.20476766f, -0.17581713f, 0.04073332f, 0.28525636f, -0.05212253f, -0.02264750f, 0.01734899f, -0.16654289f, 
    0.61987090f, -1.17363966f, -0.27590519f, 0.64047152f, 0.02066153f, 0.28567213f, -0.11361165f, -0.11340446f, 
    -0.26883978f, 0.05538513f, -0.40286490f, -0.05206438f, -0.28362104f, -0.32410440f, 0.38221014f, -0.20932670f, 
    0.00413374f, 0.20444480f, -0.01308296f, 0.09889189f, 0.05346300f, -0.42844275f, -0.32702658f, -0.46856049f, 
    -0.42375207f, 0.28731802f, -0.09573068f, 0.21980157f, -0.28720692f, 0.18066660f, 0.21745194f, -0.41441321f, 
    -0.11857876f, 0.08985336f, 0.45156947f, -0.13090968f, 0.23875578f, -0.45213220f, -0.37603083f, 0.27605075f, 
    -0.03366132f, 0.16684304f, 0.15366822f, -0.21811420f, -0.33754838f, -0.02138833f, -0.33304569f, -0.27334133f, 
    -0.27033713f, -0.19072305f, -0.15287933f, -0.21181013f, -0.45567858f, -0.16420299f, 0.72299576f, 0.27649835f, 
    0.19320299f, 0.21014820f, 0.03882528f, -0.27638674f, -0.18226801f, -0.33301574f, 0.15301490f, 0.14108406f, 
    -0.05344457f, -0.18778075f, 0.23384014f, -0.25065455f, -0.04243226f, 0.35270172f, 0.14076893f, -0.44674662f, 
    -0.30466923f, 0.14757936f, 0.18442094f, 0.11189292f, 0.11440472f, 0.26851016f, 0.27408192f, 0.15134983f, 
    -0.60653591f, -0.41086802f, 0.49044245f, 0.44955376f, 0.21080980f, 0.06102880f, 0.18547429f, -0.06147069f, 
    0.06018819f, 0.07117371f, -0.13880162f, 0.11883982f, -0.09583692f, -0.13887453f, -0.21650112f, -0.16142923f, 
    0.13453726f, -0.11527015f, 0.16788484f, -0.20478642f, 0.69308704f, -0.48070869f, -0.50304306f, 0.40966764f, 
    0.60909742f, -0.56276774f, -0.08160365f, -0.06500444f, 0.07453512f, -0.47537416f, -0.18271935f, -0.04900834f, 
    0.09448367f, 0.16428092f, -0.26315150f, 0.00272471f, 0.12144446f, 0.09219450f, 0.04859211f, -0.03911595f, 
    0.09731173f, 0.06330175f, -0.02838036f, 0.21700770f, 0.03702074f, 0.52385861f, -0.92185599f, -0.59661150f, 
    -0.59829956f, 0.20814748f, 0.12006584f, 0.22778706f, 0.51530296f, 0.45204332f, 0.33781168f, 0.01217164f, 
    -0.09442417f, -0.06831219f, -0.03110729f, 0.23845115f, 0.12482376f, -0.17101035f, 0.03966283f, 0.16638072f, 
    -0.09562190f, -0.13343769f, -0.19512814f, 0.18067549f, 0.03799812f, 0.21240833f, -0.65960282f, -0.36066476f, 
    -0.33868000f, 0.14703025f, -0.15431240f, 0.57060057f, -0.45646098f, -0.42562348f, -0.65214080f, -0.33712170f, 
    -0.41311160f, -0.12979402f, 0.15351368f, -0.41151839f, -0.22643435f, 0.15044589f, -0.12540893f, -0.00733166f, 
    0.28877661f, 0.18529320f, 0.05475843f, 0.04164702f, -0.35953149f, -0.28020817f, -0.29063246f, -0.61590195f, 
    0.41350234f, 0.20388851f, 0.08171880f, 0.10541170f, -0.52392900f, -0.41104174f, 0.61429656f, 0.26738459f, 
    0.26611817f, 0.45952219f, -0.21711046f, -0.17475969f, -0.39195818f, -0.19217075f, 0.28142723f, 0.01809808f, 
    -0.04386896f, 0.11609133f, -0.02263184f, -0.10737530f, -0.21908517f, -0.07021233f, 0.25843143f, -0.16804826f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08144490f, -0.00514123f, 0.23826733f, 0.09433804f, -0.10983688f, 0.23438981f, 0.19097818f, 0.09627178f, 
    -0.05868713f, 0.14650162f, -0.17025158f, -0.06452795f, 0.15818889f, 0.09626532f, -0.00174994f, 0.18098398f, 
    0.19157384f, 0.26878381f, 0.02664245f, 0.18581395f, 0.01447664f, 0.29187021f, 0.13663921f, 0.12651908f, 
    -0.09005212f, 0.16226462f, 0.35380781f, 0.18018967f, -0.07254245f, 0.09576357f, -0.15060231f, 0.09833599f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08408932f, -0.08333413f, -0.03919121f, 0.00489601f, -0.07290437f, 0.12027751f, 0.09362660f, 0.11077683f, 
    0.15924452f, 0.07313804f, 0.03367482f, -0.02739661f, -0.57393575f, -0.10818615f, 0.01120499f, -0.23720515f, 
    -0.11556942f, -0.04302425f, -0.07588985f, -0.10133180f, 0.05778374f, -0.01921836f, 0.22612098f, -0.06911403f, 
    0.06145138f, 0.02779310f, 0.17403586f, 0.01962264f, 0.04855083f, 0.09283427f, 0.00238926f, 0.15835695f, 
    -0.10126037f, 0.20266965f, 0.06139121f, 0.02761086f, -0.10179041f, -0.06117037f, 0.09516894f, -0.10843404f, 
    0.04963289f, -0.00700120f, -0.02297633f, 0.02118201f, 0.11140058f, 0.18488714f, 0.04768674f, 0.13190417f, 
    -0.08596403f, -0.08303702f, -0.00469783f, -0.21541622f, -0.07901920f, -0.08589821f, -0.03696110f, -0.11021613f, 
    -0.06817792f, -0.07581758f, -0.23186304f, -0.16834316f, -0.19366510f, -0.31109357f, -0.09342750f, 0.13285674f, 
    -0.07006443f, 0.06431402f, -0.13742533f, 0.17396812f, 0.00920810f, 0.04538779f, 0.16514024f, 0.05669619f, 
    0.10922346f, 0.09738245f, 0.09157038f, -0.14547966f, 0.12176401f, 0.14753123f, -0.04322514f, 0.02903002f, 
    0.09517997f, -0.04748349f, -0.01854754f, -0.07504029f, -0.40946069f, -0.05799706f, -0.00254195f, 0.05413244f, 
    -0.10601550f, -0.09912915f, 0.05921426f, 0.00463215f, -0.06372350f, 0.16865022f, 0.03580995f, -0.03328893f, 
    0.08767699f, 0.14232485f, -0.21115020f, 0.05707620f, 0.12201653f, 0.03254867f, 0.02782024f, 0.19013713f, 
    0.01727655f, 0.11156558f, -0.03797489f, -0.11172296f, -0.05989370f, 0.04692374f, -0.09628402f, 0.10674501f, 
    -0.05602470f, 0.07145071f, -0.06173947f, 0.01167136f, 0.03007797f, -0.11799300f, 0.12182954f, -0.02678132f, 
    -0.06610883f, 0.03491693f, -0.33820236f, -0.27326226f, -0.00040420f, -0.00972311f, -0.20763215f, -0.00062288f, 
    -0.00543034f, -0.09464390f, -0.01591259f, -0.22698933f, -0.26138037f, -0.17012547f, 0.04510863f, -0.13281086f, 
    0.11047349f, 0.03332121f, 0.05405609f, 0.05233049f, -0.07191955f, -0.01863871f, -0.05277833f, -0.19347785f, 
    0.24338098f, 0.12125728f, -0.01883562f, -0.06933455f, 0.10860683f, -0.00269808f, 0.05104195f, -0.02272184f, 
    0.06790456f, -0.00006004f, 0.06492016f, 0.02569978f, -0.29059243f, 0.04136702f, -0.01959790f, -0.04919593f, 
    -0.20371775f, 0.15884256f, -0.13564253f, -0.09574902f, -0.14820062f, 0.11251011f, -0.06617001f, 0.16998790f, 
    -0.07573496f, 0.12502915f, -0.23370762f, 0.04839516f, 0.00354965f, 0.03830155f, -0.03069689f, -0.02095949f, 
    0.11320492f, 0.01171483f, 0.11275271f, 0.05053645f, 0.13905042f, -0.11448309f, -0.10883932f, -0.11752870f, 
    0.02514424f, 0.14758477f, -0.11315526f, 0.24039969f, 0.08265913f, 0.06760615f, -0.02251972f, -0.00685053f, 
    -0.30206963f, 0.02256915f, 0.03473957f, 0.05183043f, -0.11189171f, 0.04249953f, -0.00832367f, 0.07424845f, 
    -0.08135436f, -0.01502563f, 0.01468695f, -0.00556549f, -0.11930249f, 0.32015547f, 0.27677456f, 0.03651174f, 
    -0.11515693f, 0.10323332f, 0.15091668f, -0.06366766f, 0.08454861f, -0.13572586f, 0.15596984f, -0.02083830f, 
    -0.00709869f, -0.15865676f, 0.12679826f, -0.18363033f, 0.13668011f, 0.05159955f, 0.03883644f, 0.15118219f, 
    0.12688227f, -0.11906342f, 0.01195867f, 0.02073205f, 0.13483880f, 0.05668924f, 0.11419955f, 0.11271706f, 
    -0.04644844f, 0.07968354f, 0.18984047f, -0.04107817f, -0.03716653f, 0.12557635f, 0.12919594f, 0.04771615f, 
    0.28154716f, 0.02719862f, -0.01497611f, -0.19699845f, 0.09766526f, -0.06373885f, -0.20408154f, 0.04965433f, 
    -0.08396701f, 0.01964642f, -0.03322865f, -0.08957513f, 0.04321958f, 0.03265128f, 0.25592548f, 0.07655974f, 
    0.06743418f, 0.09181622f, 0.17558295f, -0.05612311f, 0.06707735f, 0.05591651f, 0.02829363f, 0.15227418f, 
    -0.14469920f, 0.10902961f, -0.05546347f, -0.02224777f, 0.10241755f, 0.16206908f, 0.06118563f, 0.22882499f, 
    0.01277479f, 0.07562766f, 0.27237022f, 0.18057792f, 0.11413142f, 0.01399704f, 0.15210021f, -0.12413254f, 
    0.03427213f, 0.07365984f, 0.08733851f, -0.06061482f, -0.06178150f, -0.05123211f, 0.00560226f, -0.05592469f, 
    0.00718897f, 0.08467575f, 0.01492456f, -0.03388277f, 0.14479898f, -0.02032967f, 0.06465441f, 0.17815652f, 
    -0.22676641f, -0.08778211f, 0.04101968f, -0.23715524f, -0.23454851f, 0.23214139f, -0.03119469f, 0.08912481f, 
    -0.04329846f, -0.03290081f, 0.06790392f, -0.00203176f, 0.00053743f, -0.11507346f, -0.01588634f, -0.03960889f, 
    0.03750106f, -0.03093026f, 0.01682723f, -0.04454987f, -0.00732682f, 0.14085387f, -0.12916946f, -0.01604311f, 
    -0.07259157f, -0.01992782f, 0.05338750f, 0.27233073f, 0.18136056f, 0.11619572f, 0.09803525f, 0.04117041f, 
    0.09223802f, 0.04169629f, -0.01484406f, 0.01264647f, -0.07125600f, -0.00723453f, 0.10483240f, -0.00505287f, 
    0.12585121f, 0.07739735f, -0.21163054f, -0.24556507f, 0.07595436f, 0.18852510f, 0.04554334f, 0.21165545f, 
    0.08772167f, 0.06708591f, -0.08753984f, 0.01969361f, 0.00088326f, -0.38233605f, 0.07461663f, -0.09906761f, 
    -0.04292375f, -0.13571881f, -0.17970306f, 0.10242104f, 0.17343909f, 0.09810606f, 0.04324928f, 0.12259501f, 
    0.20452827f, 0.24751453f, -0.03963818f, -0.04401555f, 0.04448602f, 0.16997933f, 0.12870198f, -0.10454277f, 
    -0.11645801f, 0.05332148f, -0.07190605f, -0.05624931f, -0.08623152f, 0.06555859f, 0.11288323f, 0.04532109f, 
    -0.06339753f, -0.00317195f, -0.11367256f, -0.04734460f, 0.04182592f, -0.11606352f, -0.00142836f, 0.14179233f, 
    0.02270074f, 0.06942092f, 0.02712943f, 0.01685317f, 0.00008478f, 0.04378381f, 0.03761225f, -0.02241995f, 
    0.02303177f, 0.02822379f, -0.06801939f, -0.06192130f, -0.37021378f, -0.02947905f, -0.11968569f, -0.07007209f, 
    -0.06719929f, -0.11190387f, -0.07875033f, -0.05398243f, -0.12951826f, -0.00645431f, 0.07740439f, -0.02727148f, 
    -0.03081574f, -0.22077712f, -0.01989318f, 0.01581250f, 0.03473831f, 0.02553068f, 0.04646447f, -0.06344871f, 
    -0.08713647f, -0.02615363f, -0.11192161f, 0.00953675f, -0.04734452f, -0.02487762f, 0.04944876f, -0.02987094f, 
    0.10085578f, -0.00668800f, -0.06324103f, -0.07679641f, 0.01216948f, -0.07303895f, -0.04976951f, -0.00891664f, 
    0.09897014f, 0.03245833f, 0.08649921f, 0.11100587f, 0.03998459f, -0.03923782f, -0.04535628f, 0.00323388f, 
    -0.03180439f, -0.10016906f, -0.00849439f, -0.07202882f, 0.45514092f, 0.05740727f, -0.01426069f, 0.06073209f, 
    0.04136161f, -0.02781067f, -0.10844345f, 0.10825208f, 0.11811353f, -0.08700189f, 0.02012254f, -0.07429104f, 
    0.03174722f, -0.10440438f, -0.02379755f, -0.13273834f, 0.07660720f, 0.17470217f, -0.05028179f, 0.14760588f, 
    -0.00478787f, -0.05337612f, 0.09867544f, 0.08155206f, -0.40709382f, 0.09787129f, -0.18493035f, 0.07269482f, 
    0.12451381f, 0.06725432f, 0.06537685f, -0.00389729f, -0.05830350f, 0.03960543f, 0.02807239f, -0.07893576f, 
    -0.16586468f, -0.23246436f, -0.01139956f, -0.30197048f, 0.19054154f, -0.02068917f, -0.35043213f, 0.07285136f, 
    0.06080709f, 0.04848632f, 0.04387137f, -0.11242398f, 0.18777037f, 0.07036663f, 0.01779725f, 0.14647338f, 
    0.05153374f, 0.04501566f, 0.02961319f, 0.03201872f, -0.09005548f, 0.06812641f, -0.05992042f, 0.01114323f, 
    -0.26109174f, -0.26563665f, -0.20433138f, -0.04229504f, 0.06598619f, -0.14657100f, 0.01304638f, -0.00258185f, 
    0.02558695f, -0.16146280f, 0.08245470f, -0.10909311f, 0.08288917f, 0.00642311f, 0.16847087f, 0.10445508f, 
    0.15191960f, 0.01481454f, 0.03758016f, 0.10941755f, -0.04106735f, -0.14146826f, 0.00365082f, -0.01627698f, 
    0.08104141f, 0.12596397f, -0.04793327f, -0.07958936f, 0.23053427f, 0.13620828f, -0.08939409f, 0.08523889f, 
    0.05070806f, 0.02874162f, 0.11270986f, 0.03504845f, 0.06730843f, 0.11968633f, 0.02770663f, 0.15024662f, 
    0.03398593f, -0.05694908f, -0.00768353f, -0.01596578f, -0.01110435f, -0.09854615f, -0.07026178f, 0.13064457f, 
    -0.03361570f, 0.07064161f, 0.12195251f, 0.08266278f, -0.09102990f, -0.04881490f, -0.06286121f, -0.14850703f, 
    -0.02560967f, -0.08129083f, -0.12955144f, 0.01157797f, -0.12157556f, -0.17935346f, -0.09302933f, -0.15298004f, 
    0.05690025f, -0.08011150f, -0.12003884f, -0.12179866f, -0.08680813f, -0.01150892f, -0.03013700f, -0.05997201f, 
    0.30405864f, 0.07084881f, 0.10344750f, 0.17088321f, 0.04118104f, -0.01319706f, -0.00602427f, 0.01635879f, 
    0.01424458f, 0.01298564f, -0.14676237f, 0.00594284f, -0.03280820f, 0.24979496f, 0.11470441f, 0.30872393f, 
    -0.01711706f, 0.09288643f, 0.05312758f, 0.11545269f, 0.00673065f, -0.12246078f, -0.12116432f, 0.08460968f, 
    -0.30919054f, 0.10367648f, -0.01792344f, -0.25923979f, 0.04917357f, 0.20744543f, 0.05603146f, 0.01040363f, 
    0.03727430f, 0.06736939f, -0.00633901f, 0.04601159f, 0.02212095f, 0.02275622f, -0.01894906f, -0.04565056f, 
    -0.18823677f, 0.06862180f, 0.05596905f, 0.02094563f, 0.03553564f, -0.05780051f, -0.04827775f, -0.07402030f, 
    0.35692233f, 0.18909319f, 0.19010767f, 0.16877671f, 0.12996577f, 0.04409802f, -0.01472822f, 0.03040601f, 
    -0.01754977f, -0.04443225f, -0.02018707f, -0.07954052f, -0.06577299f, -0.02425925f, 0.10829443f, 0.02530285f, 
    -0.00168284f, 0.13886333f, -0.04011966f, -0.07853238f, 0.07465629f, -0.02080683f, -0.05246916f, -0.11731619f, 
    0.05773496f, -0.03119597f, -0.01526219f, 0.05222208f, 0.11772377f, 0.05684995f, -0.02529247f, 0.03480817f, 
    -0.05838463f, -0.01833958f, -0.07315255f, 0.01233414f, -0.00141394f, 0.07449271f, -0.15541391f, -0.12082043f, 
    0.01661949f, 0.03862889f, 0.07582609f, 0.08147004f, 0.04111610f, 0.01313617f, -0.02477934f, -0.00682825f, 
    0.13399298f, 0.18811984f, 0.07982638f, -0.00581144f, -0.02438688f, 0.00412101f, -0.02392612f, -0.01196724f, 
    -0.08064734f, 0.18507114f, -0.08480112f, -0.07303008f, 0.07127809f, 0.17541727f, 0.07394203f, 0.09125974f, 
    -0.04351525f, -0.00527480f, -0.05199364f, 0.03116723f, -0.06240334f, -0.10439143f, -0.13278382f, 0.21784505f, 
    -0.05621196f, 0.10791320f, 0.09599212f, 0.11525396f, -0.14781687f, 0.02447020f, -0.08145408f, -0.04667196f, 
    0.12032827f, -0.01371227f, 0.04123201f, -0.00893152f, -0.05204539f, 0.03782472f, 0.12852322f, 0.16250299f, 
    0.01256777f, -0.04532377f, -0.02274430f, -0.01800975f, -0.08029193f, 0.03002789f, -0.05569408f, -0.05020494f, 
    0.01830291f, 0.13168849f, 0.03453565f, 0.13641658f, -0.16521229f, 0.19459020f, 0.00704046f, -0.10203904f, 
    -0.08956096f, -0.06875082f, 0.01938193f, -0.05497421f, 0.06148878f, 0.01028027f, 0.10876132f, -0.10157238f, 
    -0.07334625f, -0.08084546f, -0.02602489f, -0.16598977f, 0.00574010f, -0.04599411f, -0.09666142f, -0.18127927f, 
    -0.11856096f, 0.01064576f, -0.26092190f, -0.08604259f, 0.06040992f, -0.14207980f, -0.23322052f, 0.03296529f, 
    -0.04310679f, 0.06487760f, 0.05706138f, 0.08423876f, -0.23840404f, 0.07069630f, 0.17151116f, 0.20767674f, 
    0.05776929f, -0.05832775f, 0.04883420f, -0.12036385f, 0.00924566f, 0.03713202f, -0.04870036f, 0.08731571f, 
    -0.02694542f, -0.04909120f, -0.02993887f, -0.00105763f, 0.02524062f, -0.02179146f, -0.00592477f, -0.01056460f, 
    -0.01979414f, -0.05414455f, -0.02308017f, 0.05007929f, -0.00417656f, 0.00683598f, 0.00022753f, -0.02311771f, 
    -0.01641580f, -0.01623951f, -0.02329067f, 0.01925463f, -0.04472781f, -0.01814984f, 0.00568434f, -0.00355965f, 
    -0.00940657f, 0.01391137f, -0.04606090f, -0.00333173f, 0.01102277f, 0.02994955f, 0.02816789f, 0.02386635f, 
    -0.04554442f, -0.04949539f, -0.02824509f, -0.03183272f, -0.04558454f, 0.03623130f, 0.04932272f, -0.03693499f, 
    0.01306781f, 0.00256749f, 0.00080230f, 0.02833987f, 0.02270213f, -0.05822616f, -0.00091106f, -0.04815930f, 
    -0.03303434f, -0.00849979f, -0.02908786f, -0.04367000f, -0.02113931f, -0.03060859f, -0.04210218f, -0.03556935f, 
    -0.05500768f, -0.01840204f, 0.00356991f, -0.02856163f, 0.01584163f, 0.04187240f, -0.02723665f, 0.03964290f, 
    -0.00292714f, 0.00752778f, 0.03115396f, -0.03529593f, 0.04304465f, -0.01789783f, 0.02379740f, 0.02301703f, 
    0.02301470f, 0.03844267f, -0.05344309f, -0.03875862f, -0.03444115f, 0.00422180f, 0.01896401f, -0.02330420f, 
    0.03888174f, -0.02928953f, -0.00768701f, 0.01757091f, -0.04692713f, 0.00055789f, -0.04475209f, 0.03741750f, 
    -0.01122986f, 0.02213305f, -0.01471759f, -0.01907806f, -0.01846202f, -0.01800802f, 0.04100960f, -0.02832621f, 
    0.00217945f, -0.01351897f, -0.04438583f, 0.03452455f, 0.02715192f, -0.03262312f, -0.05247819f, 0.03748207f, 
    -0.03960244f, -0.05535230f, -0.00340845f, -0.03879438f, -0.00953986f, -0.04951365f, -0.01211626f, -0.00841709f, 
    -0.04727239f, -0.01617793f, -0.00213668f, -0.02924142f, -0.01800976f, 0.02839648f, -0.03131057f, -0.05547428f, 
    -0.01778962f, 0.02518728f, 0.03151355f, 0.00174350f, -0.03640788f, -0.02767877f, -0.01474030f, -0.02742160f, 
    -0.03948626f, 0.03636301f, -0.00772636f, 0.02185528f, 0.01474921f, -0.05032678f, 0.04693184f, 0.00816249f, 
    -0.02711149f, 0.01992544f, -0.03402435f, 0.03193860f, -0.04207035f, 0.04139161f, -0.01417882f, -0.05388048f, 
    0.00338803f, 0.03887064f, -0.05804231f, 0.00982711f, 0.01331549f, -0.03464488f, -0.02934094f, -0.01441465f, 
    -0.04885782f, -0.05020827f, 0.01135489f, -0.01554105f, -0.04272060f, -0.05285325f, -0.04031201f, -0.01700911f, 
    0.03525027f, 0.01890098f, 0.03024274f, -0.01797464f, -0.05524977f, -0.01029407f, -0.04318999f, -0.05579681f, 
    -0.05427274f, -0.01774414f, 0.04034701f, 0.03211873f, -0.04364096f, 0.01925546f, -0.03104513f, -0.00910564f, 
    0.00842189f, 0.01589789f, 0.03341791f, -0.03012250f, -0.01527045f, 0.00310518f, 0.01600615f, -0.00203362f, 
    0.01189572f, 0.02234032f, -0.00292270f, 0.02702568f, -0.05097709f, 0.00090336f, -0.04131019f, 0.03757773f, 
    -0.00728773f, -0.05399138f, -0.00243001f, -0.02590656f, -0.02470048f, -0.04964849f, -0.05242899f, 0.02815672f, 
    0.03187373f, -0.03335375f, -0.05674681f, -0.01252930f, -0.00972949f, 0.00172271f, -0.03665528f, 0.04084522f, 
    0.04244601f, 0.01939302f, -0.03373302f, 0.03955952f, -0.03800477f, -0.04439184f, -0.05773809f, -0.00586998f, 
    -0.04134553f, 0.04293132f, -0.04775489f, 0.01848049f, 0.01965007f, -0.01614179f, 0.00742736f, 0.01270319f, 
    0.02608197f, -0.05694941f, 0.03489290f, -0.02266100f, -0.02110518f, 0.04294346f, 0.00810982f, -0.00543706f, 
    0.01191001f, -0.02540851f, -0.05418641f, -0.03318638f, 0.01555401f, -0.05471775f, -0.02714177f, -0.04176084f, 
    -0.02884030f, -0.05002331f, -0.01875851f, 0.01735556f, 0.03310918f, 0.00663710f, 0.01832355f, 0.00196562f, 
    -0.00894593f, -0.02318920f, -0.04414855f, 0.03769636f, 0.02249509f, -0.05446534f, -0.00944597f, 0.01275115f, 
    -0.04331603f, -0.02551277f, -0.02470857f, -0.00982416f, 0.02679858f, -0.05788444f, 0.04121350f, -0.04801882f, 
    0.01618064f, -0.02645367f, -0.02313273f, 0.03277152f, -0.03193742f, 0.04199047f, -0.01944094f, 0.03427793f, 
    -0.02908851f, 0.02761482f, -0.02878685f, -0.01012056f, 0.02804678f, -0.02216002f, -0.05151011f, 0.02722024f, 
    -0.05024903f, -0.01378590f, -0.04160566f, -0.01870678f, 0.01054666f, 0.03293576f, -0.01915388f, -0.02048173f, 
    0.01832128f, -0.02749960f, 0.03461371f, -0.02144088f, -0.02366979f, 0.02494061f, -0.05571325f, -0.01515323f, 
    -0.05898451f, -0.02463759f, 0.02794633f, -0.05435662f, 0.02052558f, -0.00443841f, 0.01949669f, -0.01715745f, 
    0.00995030f, -0.03234728f, -0.04612664f, 0.02408702f, 0.00555837f, 0.03898321f, 0.03277960f, -0.00014343f, 
    0.00855471f, -0.03264350f, -0.02043308f, -0.04636336f, 0.04397433f, 0.00557967f, -0.01589907f, 0.02819415f, 
    -0.05069055f, -0.04560135f, -0.05903500f, -0.02258528f, -0.02785200f, -0.04607723f, -0.05451036f, 0.00419431f, 
    0.01316560f, 0.01533389f, -0.03796905f, -0.00743006f, -0.01516119f, -0.04898930f, 0.00616446f, 0.03773347f, 
    0.03219559f, -0.00198834f, 0.04217518f, 0.02525306f, -0.04239158f, -0.00190670f, 0.03434534f, -0.00857390f, 
    -0.04949827f, 0.02800923f, 0.03021612f, -0.01809558f, -0.00098024f, -0.01017984f, 0.02224839f, -0.01538763f, 
    -0.05209184f, -0.02109035f, 0.01929200f, -0.05705321f, 0.01699201f, -0.01320843f, 0.03582195f, 0.01160622f, 
    -0.00745929f, -0.00080599f, 0.02293439f, -0.03391529f, -0.03495691f, -0.00275454f, 0.03184894f, 0.00608690f, 
    -0.04487641f, 0.01085892f, -0.02873757f, 0.03718469f, 0.02397165f, 0.00453181f, -0.03663091f, 0.02274694f, 
    0.01722065f, 0.02986759f, 0.00064170f, 0.02519241f, 0.01255365f, 0.00087645f, 0.00374970f, -0.03331937f, 
    -0.09019242f, -0.10877228f, 0.05499224f, -0.04629067f, -0.04166927f, 0.00228105f, -0.01519518f, -0.00354235f, 
    0.02141784f, 0.06858759f, 0.05572245f, -0.02693773f, 0.38567963f, -0.16033147f, -0.22835000f, -0.11516087f, 
    0.13677511f, -0.00023334f, 0.12514520f, 0.03240537f, 0.06016373f, 0.02332303f, -0.06766732f, -0.01410672f, 
    -0.21115540f, 0.16457945f, 0.10341094f, 0.14970879f, 0.09227914f, -0.02996551f, -0.23786773f, 0.18012595f, 
    0.00064159f, 0.01118565f, 0.04383722f, 0.01321361f, -0.13403435f, -0.01608981f, -0.01852140f, -0.05259468f, 
    0.03867741f, -0.03753176f, -0.13865632f, 0.01040982f, 0.03358825f, 0.00661843f, 0.09554807f, -0.00792414f, 
    -0.06580166f, 0.00035713f, 0.02539731f, -0.06202877f, 0.01760732f, 0.00737515f, -0.00208574f, -0.05566576f, 
    -0.03147291f, -0.08644200f, 0.04628003f, 0.04544916f, -0.41893694f, -0.06277001f, -0.11267106f, 0.27177727f, 
    -0.01580564f, -0.02105711f, 0.04648544f, -0.20076516f, 0.04368464f, 0.07355689f, 0.14851095f, 0.15571427f, 
    0.06244210f, -0.04611235f, -0.15068045f, 0.04198313f, 0.14889565f, 0.02425448f, 0.06192496f, 0.00717666f, 
    -0.01009147f, -0.00389677f, 0.17084180f, 0.00845647f, 0.27978876f, -0.37983477f, -0.02692152f, -0.09108883f, 
    0.07686440f, -0.03952248f, 0.13855231f, -0.00842107f, 0.12011819f, 0.06654879f, 0.19214560f, -0.06248575f, 
    -0.34160715f, -0.47268072f, 0.05570440f, 0.21773849f, -0.08395654f, 0.08848034f, -0.03184687f, -0.13618746f, 
    0.07827580f, -0.04424145f, -0.10282194f, 0.10280683f, -0.43611622f, 0.03823007f, 0.15273951f, -0.16433549f, 
    -0.00376633f, -0.02489812f, -0.04069651f, 0.02285200f, 0.06270143f, -0.05843435f, 0.13179801f, 0.03106432f, 
    0.00487020f, -0.21894526f, -0.12072293f, 0.02416900f, 0.12223657f, 0.13793291f, 0.13571306f, 0.04197521f, 
    0.01886211f, 0.01292543f, -0.10638116f, 0.04461791f, -0.18620758f, 0.38224593f, -0.14204131f, 0.18402226f, 
    -0.01069851f, -0.14120904f, -0.03728521f, 0.08635543f, -0.00236242f, 0.03494778f, -0.04803330f, 0.04174392f, 
    -0.08934991f, -0.00627224f, -0.01938059f, 0.17577940f, 0.01080071f, 0.02192738f, 0.05176009f, -0.04006786f, 
    -0.06019783f, -0.02481216f, 0.02469714f, 0.00191055f, -0.13818830f, 0.02599162f, -0.09730063f, 0.01291834f, 
    -0.01982255f, -0.03236185f, -0.03725367f, -0.02293967f, -0.07454112f, 0.09589244f, 0.06467825f, 0.12703384f, 
    0.29084820f, -0.07921281f, -0.01372227f, -0.37054747f, 0.12186150f, -0.04552188f, 0.05647712f, -0.06753255f, 
    0.11626310f, 0.07450411f, 0.03341725f, 0.22818667f, 0.06106676f, -0.10172512f, -0.18211250f, 0.09833861f, 
    0.04053235f, 0.03058748f, 0.16121812f, 0.06795752f, 0.03827818f, -0.11147591f, -0.05228969f, -0.01384541f, 
    -0.38486984f, -0.06894481f, -0.02793921f, 0.04916511f, -0.04585012f, 0.00478939f, -0.03443405f, -0.03699477f, 
    0.06664491f, -0.05035188f, 0.02678940f, -0.12728852f, 0.17194495f, 0.20840077f, 0.16127545f, -0.61577249f, 
    0.05858934f, -0.04434354f, 0.04834967f, 0.03079556f, -0.10329200f, 0.06359312f, -0.08952954f, 0.02744185f, 
    0.13161963f, -0.06761146f, -0.10282202f, 0.05151750f, 0.18305163f, 0.02055616f, -0.01921996f, 0.04891761f, 
    -0.03861725f, 0.09288661f, -0.00129814f, 0.13733554f, -0.01990511f, -0.09147414f, -0.02068627f, 0.10076596f, 
    0.06361654f, -0.07234147f, -0.02125566f, -0.04986759f, 0.03876295f, 0.03141383f, 0.12409065f, 0.04542878f, 
    -0.32375714f, -0.06102372f, 0.42376956f, 0.13325782f, 0.02325235f, 0.02029392f, -0.03785629f, 0.00680397f, 
    -0.02164299f, 0.00533941f, 0.00898772f, -0.05807849f, 0.19354115f, -0.04176937f, -0.05482527f, -0.20796265f, 
    0.10057035f, 0.03118321f, -0.13140124f, -0.01035263f, -0.06127170f, 0.02621360f, -0.02053347f, 0.04717501f, 
    -0.05101679f, 0.07720231f, -0.00569470f, 0.02300110f, -0.07733335f, 0.09343635f, -0.09193391f, 0.03817582f, 
    0.02356836f, -0.02819407f, 0.04088851f, 0.09524807f, 0.04839144f, -0.19565405f, -0.24073279f, -0.08847642f, 
    0.13397647f, 0.08661792f, 0.25784916f, 0.06887919f, -0.00576977f, 0.00681010f, 0.01594528f, -0.00819723f, 
    -0.09693312f, -0.02179319f, -0.13367209f, 0.10949896f, 0.02354083f, -0.04998764f, 0.04770342f, -0.01510023f, 
    -0.01102608f, 0.09544822f, -0.06256695f, -0.03756073f, -0.24792752f, -0.13792984f, 0.05078241f, -0.01061718f, 
    -0.00032979f, -0.02306508f, -0.03275684f, -0.03963947f, 0.17924739f, 0.10739750f, -0.13836960f, -0.05826260f, 
    0.36078668f, 0.03512269f, -0.25520581f, -0.03229595f, 0.05213179f, -0.07704080f, 0.04039248f, 0.15229663f, 
    0.02193281f, -0.04564595f, -0.06884037f, 0.11012459f, 0.10715123f, 0.06294653f, 0.00161631f, 0.00529429f, 
    0.02671443f, -0.09960613f, -0.04039863f, -0.02503054f, -0.00518730f, 0.07385681f, -0.03972883f, 0.01811633f, 
    0.09660659f, -0.04129946f, -0.00134755f, 0.13826318f, 0.16206551f, -0.16624632f, 0.15331207f, -0.17920057f, 
    0.06829618f, 0.01305683f, -0.00783781f, -0.02074646f, 0.08579046f, -0.12748097f, -0.06364168f, -0.06346332f, 
    0.14712560f, 0.05406683f, 0.06295091f, -0.07988943f, -0.00363550f, 0.00284953f, -0.01577781f, 0.09100533f, 
    0.03659160f, 0.17564294f, -0.10146007f, 0.02273583f, 0.09661803f, -0.03346931f, 0.01281013f, 0.00809478f, 
    -0.11081828f, 0.00308827f, -0.03903482f, 0.05474741f, 0.40746358f, 0.11083209f, -0.08852147f, -0.23346514f, 
    -0.01994334f, -0.08401363f, -0.09856298f, 0.01847603f, 0.00284749f, -0.01675458f, -0.06620111f, -0.01946736f, 
    -0.03575427f, -0.00954705f, -0.00857911f, 0.00824506f, -0.00305017f, -0.05070167f, 0.03628532f, -0.05314472f, 
    0.00035567f, -0.04327658f, -0.02796547f, -0.03266889f, -0.03536399f, 0.03726035f, 0.03679808f, 0.03638642f, 
    0.01237491f, -0.00249162f, -0.01773265f, 0.03999951f, 0.00036919f, 0.00919582f, 0.01623858f, -0.03392644f, 
    -0.02086321f, -0.03359156f, -0.00733810f, 0.02616412f, 0.01876462f, 0.01612338f, 0.01195966f, 0.00796420f, 
    -0.02879903f, -0.03973483f, -0.01579996f, -0.05084330f, -0.02928026f, 0.03428856f, -0.00873016f, -0.04368927f, 
    0.02235399f, 0.00515251f, -0.03878907f, -0.00716651f, -0.02609810f, -0.05027768f, -0.04082636f, -0.03632822f, 
    0.03150382f, -0.05423302f, 0.02362922f, -0.03822146f, 0.04326564f, -0.00701285f, -0.02731356f, -0.00503212f, 
    0.02467617f, -0.03773807f, -0.00796172f, -0.05462266f, -0.01631105f, -0.03407410f, 0.01697667f, 0.01427686f, 
    0.04478116f, -0.03595820f, 0.03544879f, -0.03000259f, -0.02694152f, 0.03845130f, 0.00860922f, -0.05253868f, 
    0.03418307f, -0.04457484f, -0.02570765f, -0.01790643f, 0.01918613f, 0.01952631f, -0.02146157f, -0.05491998f, 
    -0.01645530f, 0.03525478f, -0.03488791f, -0.00824417f, -0.04206441f, -0.02141554f, -0.02934975f, -0.04374209f, 
    -0.03074723f, 0.00406232f, 0.03977454f, 0.04005224f, 0.02635475f, 0.02444443f, -0.03322765f, 0.04002319f, 
    -0.01332341f, -0.00406481f, -0.02246818f, -0.02138053f, -0.05238713f, 0.03881858f, -0.01451734f, -0.02074024f, 
    0.02571580f, -0.05016964f, 0.01866863f, -0.04893494f, -0.04445687f, -0.03669355f, -0.01345234f, 0.01436286f, 
    -0.00833643f, -0.03990833f, 0.02272355f, -0.00866773f, 0.03975781f, -0.00023362f, -0.04285534f, -0.00785410f, 
    -0.02501593f, 0.04839141f, -0.03700154f, -0.01871513f, -0.00526615f, -0.02078956f, -0.02259064f, 0.04056530f, 
    0.02046180f, -0.04604378f, 0.04232500f, 0.02130077f, -0.03908120f, -0.02274037f, 0.00350391f, -0.04899352f, 
    0.02187423f, -0.03465897f, -0.01763090f, -0.01477056f, -0.03841245f, -0.03095062f, 0.03581468f, 0.01213206f, 
    -0.00642194f, -0.01287392f, 0.01944984f, -0.05353247f, -0.01907403f, 0.02564541f, 0.01812124f, -0.01026608f, 
    0.02810500f, 0.03092820f, 0.00412978f, 0.03622948f, -0.04940867f, -0.05415822f, -0.02994334f, 0.02970623f, 
    0.01326187f, 0.02003367f, -0.00210704f, -0.03619494f, -0.03474717f, 0.03512574f, 0.02849779f, 0.01523867f, 
    0.02973757f, -0.03112562f, 0.03743260f, -0.04538913f, -0.00949935f, 0.02334384f, 0.01262164f, -0.01971149f, 
    -0.03192490f, -0.01335492f, 0.01165493f, 0.03007646f, 0.00684125f, -0.03654850f, -0.02931279f, -0.05084420f, 
    0.02297899f, 0.04282622f, -0.03426136f, -0.01404228f, 0.02805475f, -0.03836705f, 0.04489733f, 0.01795767f, 
    -0.04409489f, -0.00093923f, -0.04050016f, -0.01829241f, 0.02302590f, 0.01932995f, 0.04318944f, 0.00882209f, 
    -0.00502201f, 0.04277183f, -0.05552825f, -0.03075385f, 0.02878512f, -0.05659494f, -0.02038593f, -0.03087403f, 
    0.00292315f, -0.00489512f, 0.02838277f, -0.04885419f, -0.05284994f, 0.01167353f, 0.04094227f, -0.03980741f, 
    -0.01066126f, -0.04762771f, -0.00655702f, 0.04293253f, -0.01619730f, -0.04842847f, 0.01291489f, 0.01909544f, 
    -0.01900462f, 0.01168501f, 0.03580319f, -0.03174314f, -0.04907855f, 0.02352123f, 0.03814598f, 0.00679192f, 
    -0.05180983f, 0.03019019f, 0.02269587f, -0.04079039f, 0.01960417f, 0.01784022f, 0.02655240f, -0.05147360f, 
    -0.01937730f, -0.00423173f, -0.03772339f, 0.03241059f, -0.05540582f, -0.04369329f, 0.03992354f, 0.00539629f, 
    0.02355205f, 0.00563549f, -0.03743828f, -0.03279780f, 0.02430032f, 0.03401856f, -0.01720207f, -0.03643841f, 
    -0.01798589f, -0.04874159f, -0.04721590f, 0.01968774f, 0.03482171f, -0.02196814f, 0.00513312f, -0.02855976f, 
    0.02851385f, -0.05287600f, 0.02338542f, 0.04035072f, -0.03408337f, 0.01166516f, -0.05258935f, -0.01789147f, 
    -0.04113850f, -0.04064373f, -0.02869338f, 0.02845317f, 0.01954787f, 0.03810114f, 0.03158370f, 0.01891641f, 
    -0.03732052f, 0.03579439f, -0.03917242f, -0.01045270f, -0.00509590f, -0.04369109f, 0.01291758f, 0.03436661f, 
    0.02591190f, -0.05378179f, 0.04421176f, -0.03624673f, -0.01457826f, -0.01915701f, -0.04548682f, 0.03110710f, 
    0.00681793f, -0.03240445f, 0.04476497f, -0.01651043f, -0.02255210f, -0.00395401f, -0.03666475f, -0.03892281f, 
    -0.04928648f, -0.03717636f, -0.04978758f, 0.01708113f, -0.02645765f, -0.04505181f, 0.00549500f, 0.01897708f, 
    0.01484375f, -0.04247693f, -0.01702456f, -0.03349841f, -0.05602582f, 0.01244064f, -0.03136307f, -0.04754049f, 
    -0.05550659f, 0.01184249f, 0.02069275f, -0.01854144f, 0.02751639f, -0.00823161f, 0.00336194f, 0.03004182f, 
    0.04480071f, 0.04138614f, 0.03249085f, 0.03907261f, -0.02419164f, 0.02430461f, 0.04481981f, 0.03019450f, 
    -0.02835690f, -0.00657144f, 0.03992132f, 0.00083999f, 0.00756271f, -0.05409662f, 0.01709892f, -0.05267980f, 
    0.02310760f, -0.04906796f, -0.03503243f, -0.04778344f, -0.04407794f, 0.00637727f, 0.01650790f, 0.00692697f, 
    -0.04518820f, -0.02206123f, 0.03477287f, -0.01066814f, 0.02611139f, 0.01578042f, -0.01663187f, 0.03690987f, 
    -0.04853855f, 0.03508047f, -0.04412803f, 0.01836206f, -0.02215347f, 0.00561350f, -0.04596167f, -0.02183431f, 
    -0.04028564f, -0.03138571f, -0.03087851f, -0.02452406f, 0.03128536f, -0.00401729f, -0.02866977f, 0.00526061f, 
    0.01319932f, 0.01215594f, -0.00927203f, -0.04620638f, -0.04073099f, -0.05308831f, -0.05645015f, -0.03929415f, 
    -0.09757516f, -0.06104226f, -0.10644549f, 0.02414868f, 0.01925884f, -0.04920879f, 0.06537434f, -0.02786828f, 
    -0.02284817f, -0.04980160f, -0.02086607f, -0.00579054f, -0.40329129f, 0.10635635f, 0.08487952f, 0.17307647f, 
    -0.04453744f, -0.06865297f, 0.04038519f, -0.03088775f, -0.17812906f, -0.01298940f, 0.00655718f, 0.04958656f, 
    0.03173014f, 0.09512980f, 0.02927053f, 0.03396547f, 0.16543145f, -0.01203532f, 0.16058704f, 0.05616535f, 
    0.06845409f, -0.04676677f, -0.02202069f, 0.12758407f, -0.05343277f, -0.05627453f, 0.00293988f, 0.03807307f, 
    0.05455457f, 0.00243320f, 0.00121296f, -0.05091115f, 0.00926564f, 0.06231063f, -0.01157137f, 0.00197744f, 
    -0.06602678f, -0.00645307f, -0.07425068f, -0.05955660f, -0.08659749f, -0.03829078f, -0.00454457f, -0.02978108f, 
    -0.00631106f, -0.15278344f, -0.10283698f, 0.02775653f, -0.03172838f, 0.34708273f, 0.34401807f, -0.14450981f, 
    -0.02890443f, 0.05183426f, -0.13009049f, 0.01327119f, 0.24110359f, 0.03651236f, 0.05742742f, -0.04454101f, 
    -0.15750250f, -0.07674951f, 0.00333854f, 0.00990949f, -0.02895862f, 0.00473337f, 0.09709116f, 0.03075833f, 
    0.15001449f, 0.11602634f, 0.09396712f, 0.12675993f, -0.30578449f, -0.04552687f, 0.18149029f, 0.23190922f, 
    -0.05645533f, -0.12190053f, -0.08180881f, -0.11013147f, -0.01332970f, 0.24758430f, 0.00908436f, 0.05825934f, 
    -0.23297629f, 0.17155108f, 0.04127091f, 0.04731309f, -0.10451527f, -0.14675730f, 0.22363287f, 0.11587540f, 
    0.01919662f, 0.00056537f, 0.02327668f, 0.02963321f, -0.04676698f, -0.02253549f, 0.00969666f, -0.04216932f, 
    0.12900160f, -0.08511201f, 0.09120462f, -0.09886979f, 0.02257902f, 0.00571681f, -0.11884306f, -0.04243982f, 
    -0.34129053f, 0.28278098f, 0.29311594f, 0.05979858f, -0.07861353f, -0.00302744f, 0.12670222f, 0.09365164f, 
    -0.05825772f, -0.04516234f, 0.00456318f, -0.02767643f, 0.04738791f, -0.12430342f, -0.16820845f, 0.23815492f, 
    0.07242154f, 0.29800341f, -0.06292015f, 0.01011227f, -0.02502020f, -0.05345914f, -0.04741463f, 0.00167178f, 
    -0.18566152f, -0.08831794f, -0.01483439f, 0.08486450f, 0.07967964f, 0.10648310f, 0.06595439f, -0.05249862f, 
    0.06888115f, 0.08454880f, 0.15197121f, 0.08966652f, -0.00023932f, -0.10683024f, -0.05776729f, -0.14761271f, 
    0.01504498f, -0.05252903f, -0.01962304f, -0.03195243f, -0.00087215f, 0.05645596f, 0.08106798f, 0.00468492f, 
    0.12122225f, -0.16204065f, 0.03404143f, 0.05622700f, -0.03381084f, -0.05146522f, -0.04597801f, -0.02738017f, 
    -0.02995974f, 0.03943881f, 0.05509396f, 0.11538263f, -0.11502711f, 0.13458796f, 0.07053500f, 0.04707019f, 
    -0.10275783f, -0.04679685f, 0.00455164f, 0.12103883f, 0.03278887f, 0.06394581f, -0.03053036f, -0.00278282f, 
    0.02235196f, 0.01323196f, 0.12630387f, -0.10511821f, -0.04223147f, -0.07641422f, 0.02131512f, -0.00948654f, 
    0.17348991f, 0.07812146f, 0.07260601f, 0.07507572f, 0.16421163f, -0.15064898f, -0.03066831f, 0.22479956f, 
    0.00395646f, 0.00455731f, -0.02045306f, 0.01453897f, 0.02988480f, -0.12160812f, 0.04588642f, 0.16415098f, 
    -0.21778546f, -0.07786600f, -0.04036591f, 0.13358881f, -0.19554688f, -0.00078359f, 0.01324988f, 0.16190116f, 
    0.02773300f, 0.05190265f, 0.14573069f, 0.16434155f, 0.03435379f, 0.10486940f, -0.32452074f, -0.16964677f, 
    0.11942431f, 0.03960503f, -0.04154839f, 0.01064335f, 0.04736122f, 0.04112687f, 0.00659520f, 0.03713755f, 
    -0.11287345f, -0.18308610f, -0.00415440f, 0.21615320f, 0.10030629f, 0.20377082f, 0.31244597f, -0.01187744f, 
    -0.07863668f, -0.07384311f, -0.10376658f, -0.02050760f, -0.07478040f, -0.02388431f, -0.02085740f, 0.07245924f, 
    -0.01744498f, -0.09881038f, 0.03292089f, 0.00043501f, 0.03865217f, 0.00627204f, 0.03028764f, 0.11988822f, 
    -0.09020867f, -0.10219648f, 0.03468896f, -0.02429131f, 0.08742696f, 0.20535341f, 0.12386239f, 0.11438499f, 
    0.01375033f, -0.08514572f, 0.06680627f, -0.03581869f, -0.21371807f, 0.00323534f, 0.13641950f, 0.11150742f, 
    0.01553295f, 0.04627890f, 0.05563831f, 0.00055156f, 0.09749358f, 0.05786723f, -0.02851111f, 0.03393718f, 
    -0.08393991f, -0.01985804f, 0.02290432f, 0.12443068f, 0.03397643f, 0.12153354f, 0.06775935f, 0.16581608f, 
    0.00753169f, -0.01738841f, -0.07918189f, -0.13490435f, 0.19296737f, -0.03909880f, -0.10077492f, 0.08060067f, 
    0.03870845f, -0.03197204f, 0.03084200f, 0.02212564f, 0.01672022f, -0.04328312f, 0.06181828f, 0.08780494f, 
    0.00308283f, 0.16977136f, 0.14343822f, 0.00548268f, -0.00766865f, -0.08977412f, 0.02441697f, 0.18401670f, 
    0.12422507f, 0.11589614f, 0.09159372f, 0.11357442f, -0.03111788f, 0.05476085f, -0.10721187f, -0.00131855f, 
    -0.08469881f, -0.04111400f, -0.02030691f, -0.01606566f, -0.11140453f, 0.00809351f, 0.04364673f, -0.02061670f, 
    -0.29175016f, -0.05886204f, -0.08430217f, 0.05927788f, 0.02604138f, 0.03081040f, 0.09218252f, -0.05185593f, 
    0.00357719f, -0.00973196f, 0.01900973f, 0.00791156f, -0.15121879f, 0.17846769f, 0.06986061f, -0.02286718f, 
    -0.09958164f, 0.00289848f, -0.08494546f, 0.09426352f, 0.03609775f, 0.02328043f, -0.01154965f, -0.03971880f, 
    -0.26361632f, -0.37098739f, 0.12400955f, -0.04853599f, -0.04711091f, -0.03340633f, 0.06374495f, -0.07534863f, 
    0.06740488f, 0.07206783f, 0.12106055f, 0.02073466f, 0.36486754f, 0.00635871f, -0.23401064f, 0.23235683f, 
    0.03257844f, 0.02963166f, -0.02375640f, -0.02589099f, -0.01423662f, 0.07402099f, 0.12194134f, -0.06280804f, 
    0.03318259f, -0.03816744f, -0.03846120f, -0.02392148f, -0.06089694f, 0.01585087f, -0.01050491f, 0.00167524f, 
    -0.05575649f, -0.06378804f, -0.10042285f, -0.05590001f, -0.00514437f, -0.02845736f, 0.15677597f, -0.03497297f, 
    -0.03296189f, -0.07920096f, -0.18988119f, -0.11954486f, -0.15825953f, -0.05860592f, 0.03069272f, 0.05912453f, 
    0.15859836f, 0.21468775f, -0.06664303f, -0.14959046f, -0.18649387f, 0.05898587f, 0.19061089f, 0.13089435f, 
    0.04192245f, -0.03665756f, -0.00144306f, -0.11014690f, 0.02498365f, 0.01201599f, -0.00237243f, 0.00977993f, 
    -0.06129961f, -0.01942360f, 0.00239636f, -0.05248215f, -0.07318570f, -0.10144655f, -0.08945661f, -0.15580752f, 
    0.01759559f, 0.02977064f, -0.02404363f, 0.03709791f, -0.04483261f, -0.03974533f, -0.02125606f, -0.07827845f, 
    0.06172137f, 0.04627246f, 0.08584443f, -0.00538932f, 0.28171125f, 0.06840967f, 0.32452711f, -0.08950692f, 
    0.03974417f, -0.13681899f, -0.04655921f, -0.04857136f, 0.06402488f, 0.26602516f, 0.01584984f, 0.02152163f, 
    -0.41285574f, -0.10086861f, -0.19308016f, -0.19465351f, -0.05624604f, -0.24583541f, -0.09451277f, -0.08607806f, 
    -0.05598035f, -0.05564486f, -0.10262945f, -0.05478210f, 0.11695329f, 0.06281914f, -0.01059024f, -0.16749209f, 
    -0.02832172f, 0.04482422f, -0.24412744f, -0.00585106f, -0.10551737f, -0.01388876f, -0.00276863f, -0.03722532f, 
    0.17823428f, -0.28047186f, -0.26614264f, -0.28683162f, -0.10222463f, -0.00945786f, -0.00955144f, -0.02244658f, 
    -0.06379207f, -0.01662492f, 0.01666580f, 0.00009331f, 0.18855074f, -0.03130214f, -0.01253905f, 0.03944737f, 
    -0.08555494f, -0.08384442f, -0.01662070f, 0.00561978f, 0.01652021f, -0.01368669f, -0.07025062f, -0.13127428f, 
    -0.06169280f, -0.16961075f, 0.09037246f, -0.04340311f, -0.07271746f, -0.09626559f, -0.19692576f, 0.04081205f, 
    0.05075968f, 0.02253200f, 0.09293945f, 0.08329482f, -0.06591906f, -0.08340433f, 0.03351627f, 0.02769959f, 
    -0.04762523f, 0.10135682f, 0.30270657f, -0.12444051f, 0.01752145f, -0.04137524f, -0.01587568f, 0.05310308f, 
    -0.16497502f, -0.23618808f, -0.08510572f, -0.03776052f, -0.07614640f, -0.10173800f, -0.04386059f, 0.07671128f, 
    -0.05593206f, -0.04567754f, -0.10252755f, -0.06551643f, 0.14657491f, 0.02685043f, 0.00352858f, 0.04013304f, 
    -0.10031457f, -0.13115746f, -0.05583147f, 0.00278922f, 0.00349208f, -0.06601904f, -0.09378755f, -0.21566747f, 
    0.05421545f, -0.12500085f, 0.15866749f, 0.19981492f, 0.00858520f, -0.06157492f, -0.07203775f, -0.02292632f, 
    -0.07626763f, -0.02791860f, -0.23889437f, -0.25761175f, -0.16705108f, -0.03716604f, 0.05131838f, -0.14625011f, 
    0.05945053f, -0.06296676f, -0.02004925f, -0.01109956f, -0.17556693f, -0.08625606f, -0.05464145f, -0.02477912f, 
    0.15843247f, 0.00685026f, 0.14742693f, -0.04475429f, -0.01087867f, -0.04002229f, -0.07611976f, -0.11925550f, 
    0.12646461f, 0.20514764f, 0.07955606f, 0.11661125f, 0.07844356f, -0.01345920f, 0.00212415f, 0.29093543f, 
    -0.00629054f, 0.04764754f, -0.04690083f, -0.09517565f, 0.06611449f, -0.03517221f, -0.01838966f, -0.12654731f, 
    -0.26855254f, -0.21443452f, -0.07083999f, -0.17460081f, 0.01371691f, -0.19525181f, -0.01806641f, -0.07732606f, 
    -0.02537236f, -0.05632061f, -0.13880540f, -0.15385382f, 0.04396486f, 0.12217350f, -0.03178672f, -0.05046218f, 
    0.01610091f, 0.04703996f, 0.03933672f, 0.02442156f, -0.07069645f, -0.17760132f, -0.12778400f, -0.08719940f, 
    0.37321839f, 0.02522289f, -0.17541538f, 0.10087619f, -0.02686330f, 0.02126012f, 0.01403619f, -0.13891733f, 
    -0.07389992f, -0.02207866f, -0.04954129f, 0.01504317f, -0.01557742f, 0.06834670f, 0.02801092f, -0.03254596f, 
    0.05885693f, 0.03394540f, -0.06394969f, 0.00145747f, -0.05227343f, -0.06271017f, -0.04840919f, -0.00828243f, 
    0.01483178f, -0.01593926f, -0.00284862f, -0.03756576f, 0.11657711f, -0.04962767f, -0.05964563f, -0.15033288f, 
    -0.04803476f, -0.00890182f, -0.13335164f, -0.05923594f, -0.18061544f, 0.16824748f, -0.04849945f, -0.05149223f, 
    0.07988728f, -0.04775180f, -0.20754270f, 0.04243467f, -0.11135193f, -0.11440615f, -0.04872097f, -0.05390178f, 
    0.06293294f, -0.21647722f, 0.04613041f, 0.01871562f, -0.08816652f, -0.00881713f, 0.04437127f, -0.09550867f, 
    0.15862232f, 0.04386419f, 0.25097212f, 0.26756841f, 0.14386721f, -0.04213918f, 0.05190396f, -0.03173484f, 
    -0.00634054f, -0.02295417f, -0.03055385f, 0.00630803f, 0.23771286f, 0.37295806f, 0.14649504f, 0.05932759f, 
    -0.11515307f, -0.01174903f, 0.16322841f, 0.00097257f, -0.03032607f, 0.00529883f, 0.00538146f, -0.08946607f, 
    -0.04341527f, 0.03027215f, 0.03746016f, 0.12156124f, 0.05527919f, -0.01395672f, -0.04523166f, -0.06009897f, 
    -0.02970930f, 0.05232737f, 0.00851068f, -0.10665563f, -0.02524509f, -0.11933866f, -0.02459755f, -0.02220501f, 
    -0.06430382f, -0.10770944f, -0.06438983f, 0.01945924f, 0.05093267f, -0.15380687f, -0.00524692f, 0.13515100f, 
    -0.14783715f, -0.07297924f, -0.12406433f, -0.11962588f, 0.07959597f, -0.06188341f, 0.04259587f, -0.03497756f, 
    -0.06516700f, -0.16115837f, -0.06392679f, 0.10951170f, -0.19857267f, -0.03624547f, 0.18965535f, 0.06144976f, 
    -0.13025817f, -0.17688769f, 0.12478885f, -0.16874321f, -0.02496559f, 0.01348376f, -0.11993077f, -0.03141887f, 
    0.06065087f, -0.03068589f, -0.18804871f, -0.06150853f, -0.11509766f, 0.01515358f, 0.07041295f, 0.03555803f, 
    -0.06733429f, -0.03412865f, -0.00010807f, 0.02139371f, -0.07039327f, 0.14687780f, 0.05857489f, -0.03851880f, 
    -0.04824157f, -0.06431538f, -0.02069783f, -0.02771585f, 0.14080411f, 0.06433462f, -0.03724035f, -0.02875205f, 
    -0.00925316f, 0.03771559f, -0.09154497f, -0.01645480f, 0.02752548f, 0.01192889f, 0.01630356f, -0.01264819f, 
    0.06648564f, 0.07187128f, 0.07643165f, 0.01268237f, 0.01588183f, 0.01386477f, -0.04122651f, 0.05757714f, 
    -0.09296287f, 0.53503191f, -0.15708327f, 0.19558708f, 0.06856998f, 0.00582150f, 0.01329329f, -0.12846780f, 
    0.01512807f, 0.02972660f, -0.09355291f, -0.03806045f, -0.14854249f, -0.10474915f, -0.17336386f, -0.01510435f, 
    0.16729042f, -0.02429328f, 0.04293127f, 0.00351632f, -0.00466190f, -0.17689613f, -0.05329586f, -0.07033298f, 
    -0.26930529f, -0.21584159f, -0.10460494f, -0.05392982f, 0.04916913f, -0.05598973f, -0.00740791f, 0.01266915f, 
    0.14276549f, 0.08438455f, 0.19302611f, 0.18852554f, 0.17101111f, -0.24614634f, 0.24139500f, -0.27907059f, 
    0.03318048f, 0.03856481f, -0.01362993f, -0.00827426f, -0.12541568f, 0.04528500f, -0.03788538f, 0.02881086f, 
    0.05171209f, 0.07046704f, 0.11485673f, 0.13304678f, -0.03749507f, -0.01927881f, -0.00811987f, 0.08720846f, 
    -0.02897651f, -0.02066438f, 0.04497413f, -0.00337804f, 0.06936193f, 0.14648636f, 0.04104983f, 0.01249800f, 
    0.09485238f, 0.09307288f, -0.07367491f, -0.09355003f, 0.07595058f, -0.15101503f, -0.00213824f, 0.04200361f, 
    0.46301064f, -0.17651790f, 0.21615675f, -0.17180313f, -0.17509098f, 0.05373454f, -0.06676829f, 0.03599449f, 
    -0.01049502f, -0.07504879f, 0.01582173f, 0.03548180f, -0.20981926f, -0.25456616f, -0.36183402f, -0.09677500f, 
    0.06864347f, 0.00478688f, 0.02583625f, -0.03884336f, -0.06330883f, 0.04915095f, -0.01641884f, -0.04816046f, 
    0.27414867f, 0.21372558f, 0.22651929f, 0.23999541f, 0.13167778f, 0.08416680f, 0.15389338f, -0.03929421f, 
    -0.02865632f, 0.05501738f, 0.01523759f, 0.01259269f, -0.08596555f, -0.12901019f, -0.18079038f, -0.08867367f, 
    0.12622361f, -0.13296948f, -0.10961484f, 0.09694016f, -0.04271085f, 0.06017635f, -0.07190724f, 0.01824605f, 
    0.10899714f, 0.30627477f, 0.26882952f, 0.05607814f, 0.04206057f, 0.00598624f, 0.02291401f, 0.17589062f, 
    -0.02732959f, -0.01368920f, 0.02721585f, 0.00946124f, -0.19964162f, 0.03594949f, -0.05123617f, 0.04033582f, 
    0.09446637f, -0.12670811f, 0.04622346f, -0.05355355f, -0.01182575f, -0.01793104f, -0.05294438f, -0.13833176f, 
    0.18474002f, -0.13108961f, 0.23352253f, 0.01905799f, -0.02413277f, -0.07598204f, -0.07276136f, 0.02424457f, 
    -0.11505777f, -0.02612538f, -0.18480766f, -0.02652468f, 0.14156783f, -0.02406309f, 0.10465831f, 0.06020858f, 
    0.15649672f, -0.00456823f, 0.10574358f, -0.09374257f, 0.00036542f, 0.02001646f, -0.01226262f, 0.03914219f, 
    -0.06554676f, -0.34447387f, -0.18402317f, -0.24024041f, 0.07629908f, -0.02739498f, -0.15102990f, -0.10781243f, 
    -0.12683342f, 0.12533715f, 0.06208017f, 0.13493797f, -0.26539537f, -0.26329428f, -0.15312037f, 0.11833552f, 
    0.08110112f, -0.09104333f, -0.15215293f, 0.01672943f, 0.00152327f, 0.04392938f, -0.05296642f, 0.17435928f, 
    0.18772656f, 0.27194500f, 0.03901540f, 0.17716534f, -0.04726618f, 0.06603362f, 0.03494169f, -0.02739266f, 
    0.05674420f, -0.00600664f, 0.03649898f, -0.04584403f, -0.15763482f, 0.11193838f, -0.13447022f, 0.02815146f, 
    0.03592496f, 0.03096366f, 0.04706940f, 0.11708255f, 0.10302238f, -0.13738139f, -0.08729661f, -0.10453419f, 
    -0.04735056f, 0.35346383f, -0.04374972f, 0.09639293f, 0.11470091f, -0.01262224f, 0.06309977f, 0.14827305f, 
    0.02060170f, -0.03992705f, -0.01361719f, -0.05223830f, 0.02652987f, -0.17295679f, -0.20214584f, -0.13773470f, 
    0.01898220f, -0.02293506f, -0.11912715f, 0.02676145f, -0.01259514f, -0.04923468f, -0.09897249f, -0.02396918f, 
    -0.07043681f, -0.03993503f, -0.11933865f, -0.06218172f, 0.04941413f, -0.02130152f, 0.05972277f, 0.04344095f, 
    0.00941535f, 0.01629783f, -0.22661117f, -0.15742823f, 0.17226718f, 0.22426043f, 0.19876023f, 0.26090080f, 
    -0.06177331f, -0.03132417f, 0.07409143f, 0.18175621f, 0.03495727f, 0.01057756f, 0.01004697f, 0.02511269f, 
    0.19474609f, -0.30174175f, 0.20527285f, -0.21667147f, -0.13388923f, -0.08074310f, -0.05072851f, -0.13618700f, 
    0.16452670f, -0.18016274f, -0.07792093f, 0.28379884f, 0.02132285f, -0.23487350f, -0.06836046f, -0.09218020f, 
    0.01075457f, 0.01130528f, -0.11868700f, -0.13505457f, -0.15812476f, 0.02482510f, 0.14136082f, 0.07621451f, 
    -0.02965787f, -0.09204948f, 0.03903114f, 0.07411192f, 0.00661941f, -0.01951245f, -0.04898927f, -0.00042553f, 
    0.04663163f, -0.00800319f, -0.00270608f, 0.04689280f, -0.24978741f, -0.21360695f, -0.11875919f, 0.05050594f, 
    0.07378076f, 0.02283347f, -0.00223851f, -0.14675492f, 0.14369376f, -0.02883222f, -0.00561061f, 0.07949899f, 
    0.18741959f, -0.39543539f, 0.15020569f, -0.28710875f, 0.05803922f, -0.03349863f, 0.21568047f, -0.06967226f, 
    -0.02928137f, -0.04610271f, -0.03435896f, -0.09295706f, 0.26982507f, -0.20011006f, 0.16966090f, 0.01027894f, 
    0.05082920f, -0.03361209f, 0.04120402f, -0.03314164f, -0.07036879f, -0.05493720f, -0.00612823f, 0.04782620f, 
    0.15335636f, 0.10174967f, 0.22628042f, -0.05919639f, -0.27978128f, -0.02627072f, 0.04408918f, 0.20658182f, 
    0.08648988f, -0.08442689f, -0.05035901f, 0.05703160f, -0.37657434f, -0.15046728f, -0.19178626f, -0.06523191f, 
    -0.01298873f, -0.04928130f, 0.04909945f, -0.00508942f, 0.12611535f, 0.00934531f, 0.05651966f, -0.05631684f, 
    0.02984047f, 0.00269264f, 0.04777775f, 0.01120899f, 0.09280211f, 0.02091530f, 0.07686880f, 0.03537375f, 
    -0.03584854f, 0.03682545f, 0.01401343f, -0.00453797f, -0.34491533f, -0.18719220f, -0.17540447f, -0.10735729f, 
    -0.09812833f, -0.03019170f, -0.06413253f, 0.02394582f, -0.00692362f, 0.02242980f, 0.02469213f, -0.12770282f, 
    0.13200803f, -0.12109847f, 0.13386877f, -0.11775651f, 0.10972022f, 0.11442352f, 0.00114196f, 0.19755389f, 
    -0.12898473f, -0.00426956f, 0.02143875f, 0.11004191f, 0.06989301f, -0.08985621f, 0.02870727f, -0.00327395f, 
    0.17428200f, -0.00073444f, -0.03721518f, 0.01544536f, -0.07649232f, 0.04840625f, 0.08230101f, -0.01996275f, 
    -0.00460551f, -0.02071793f, 0.05254825f, -0.12376129f, -0.02914170f, -0.06088590f, 0.01105755f, -0.04125587f, 
    0.01752561f, -0.12498450f, 0.02027886f, 0.02080094f, 0.39451864f, 0.02102317f, 0.08586616f, 0.07257468f, 
    -0.09675091f, 0.04522246f, 0.00773066f, 0.03222335f, 0.02706058f, 0.24740976f, 0.18493110f, 0.00948929f, 
    -0.07408654f, -0.06608451f, 0.17663766f, 0.07205879f, 0.05102295f, 0.04783962f, 0.00655480f, 0.19176041f, 
    0.10554322f, 0.11203697f, 0.14096208f, 0.05583419f, -0.38432992f, 0.11242229f, -0.25854400f, 0.12299106f, 
    -0.06536935f, 0.04786924f, 0.06678049f, 0.19909279f, -0.21654414f, 0.18724890f, 0.05712523f, -0.02088538f, 
    -0.09930258f, 0.08141284f, 0.16465645f, 0.12236065f, 0.06630477f, 0.01658188f, 0.29030621f, 0.23321791f, 
    0.00073025f, -0.01225636f, -0.06643321f, -0.06238219f, 0.12548569f, 0.03266372f, 0.12738407f, -0.02237833f, 
    0.04843557f, 0.04408665f, 0.00201816f, -0.05511726f, -0.07074511f, -0.01215865f, 0.04105177f, -0.01288302f, 
    -0.24891342f, 0.04022672f, 0.02220608f, -0.09332613f, -0.10637555f, -0.00101391f, 0.03748899f, 0.00869756f, 
    0.00323251f, -0.09899020f, -0.00393108f, -0.12168070f, -0.10013419f, 0.06987744f, 0.00506603f, 0.04005264f, 
    0.03341926f, 0.00309369f, 0.06415270f, -0.08284335f, 0.01740233f, -0.05242478f, 0.00369637f, -0.02834280f, 
    0.01595460f, 0.00938512f, 0.17386413f, 0.02863399f, -0.07183127f, -0.01527587f, -0.03656133f, -0.19443446f, 
    0.04038100f, -0.00923440f, 0.06782492f, 0.07137520f, -0.08994941f, -0.05676346f, 0.10916484f, 0.06551756f, 
    -0.11492321f, -0.06213663f, -0.06889877f, 0.03106583f, -0.12561619f, 0.07737646f, 0.03642404f, 0.09339210f, 
    0.05032451f, 0.03924651f, -0.18784520f, 0.13545631f, -0.14009668f, -0.08457839f, -0.04975459f, 0.02485185f, 
    0.02003719f, 0.04422215f, 0.00293066f, 0.11497577f, -0.05612949f, -0.12746039f, -0.10341929f, -0.05571977f, 
    -0.14013340f, 0.13298494f, 0.18757311f, 0.00510449f, -0.00411749f, -0.13887653f, -0.06364831f, -0.10350234f, 
    0.16339459f, 0.06160657f, 0.03664750f, -0.01396571f, -0.05593873f, 0.03047967f, -0.06122656f, -0.05192722f, 
    -0.07054038f, 0.00012144f, 0.04089388f, 0.04272803f, -0.05391712f, 0.02570211f, 0.12087201f, 0.20690255f, 
    0.03206296f, -0.00807172f, -0.05177679f, 0.01631839f, 0.04251286f, -0.00337043f, 0.08657498f, 0.19038014f, 
    -0.12921618f, -0.19463259f, -0.10152414f, 0.06994429f, 0.08935838f, 0.01390533f, 0.08814553f, 0.06764271f, 
    0.16673055f, 0.09637717f, 0.18434417f, -0.00124676f, 0.04451832f, 0.03825736f, 0.05815291f, -0.11561173f, 
    0.15476003f, 0.05255454f, 0.10676879f, 0.12187441f, -0.07332877f, 0.03340086f, 0.10880332f, 0.07000072f, 
    0.53121018f, 0.18161680f, 0.10987887f, -0.12801149f, 0.00490960f, 0.00562592f, -0.08682649f, -0.12777002f, 
    -0.05988941f, -0.08243042f, 0.01383822f, -0.02664327f, -0.00499233f, -0.03928897f, -0.02449843f, 0.04189340f, 
    0.13293770f, 0.15392052f, 0.00501817f, -0.05598275f, 0.01005812f, 0.02203158f, -0.00611079f, 0.09754059f, 
    0.00182194f, 0.02001453f, -0.01380165f, 0.02413518f, 0.08404905f, 0.24314259f, 0.06328955f, 0.02925624f, 
    0.00126267f, 0.08729988f, 0.04590908f, 0.03047285f, -0.16697794f, -0.10236925f, 0.19115120f, 0.10918871f, 
    0.07366295f, -0.01341508f, -0.00562289f, -0.05088901f, -0.07567398f, -0.07440443f, -0.05937892f, -0.04447739f, 
    0.02341834f, 0.11514355f, -0.21879691f, 0.07367779f, -0.01456830f, 0.10201729f, 0.10960118f, 0.07470697f, 
    -0.00647367f, -0.12507065f, -0.03419393f, -0.16867879f, 0.07825875f, 0.07370435f, -0.06180106f, 0.01967627f, 
    -0.00594802f, -0.00071049f, 0.03673474f, -0.05468304f, -0.06885241f, -0.01423279f, -0.04862321f, 0.00321906f, 
    -0.03356780f, 0.12296849f, 0.08693589f, -0.00620903f, 0.06727155f, -0.02663591f, 0.00095721f, 0.07753825f, 
    0.15940897f, 0.13392849f, 0.10281529f, 0.12588036f, 0.09721403f, 0.07719976f, 0.07766300f, -0.02509635f, 
    -0.05281088f, -0.01086407f, -0.05344212f, 0.02338654f, 0.00737640f, 0.06573237f, 0.10410164f, 0.03653307f, 
    0.07480758f, 0.17180321f, -0.00636396f, 0.04141478f, 0.07505022f, 0.17297652f, 0.03374700f, -0.12735730f, 
    -0.02001466f, -0.04000819f, 0.03880530f, 0.04617000f, 0.02747293f, -0.04504776f, -0.03835318f, -0.08509253f, 
    -0.05509698f, 0.01008147f, -0.05557102f, 0.11071605f, 0.12525274f, -0.06273416f, 0.06349293f, 0.01501094f, 
    -0.06575755f, -0.08631048f, 0.15554141f, 0.11639401f, -0.05649904f, -0.13452782f, 0.11229234f, -0.14159866f, 
    -0.01992400f, -0.06522167f, -0.03022158f, 0.02589153f, 0.31275019f, -0.02440116f, 0.03370596f, 0.12256866f, 
    -0.01038114f, -0.10783993f, -0.06274886f, 0.03857113f, 0.07505953f, -0.02856324f, -0.04110603f, -0.02505314f, 
    -0.01771125f, -0.01624677f, -0.02090855f, 0.01200319f, -0.03087976f, -0.02406538f, -0.00047423f, 0.03037960f, 
    0.04112677f, -0.05274934f, -0.02069107f, 0.02751091f, 0.01202508f, -0.01052830f, -0.03872654f, -0.03052330f, 
    -0.02075361f, 0.03614751f, -0.05299401f, -0.00114818f, 0.04849216f, 0.02574426f, -0.00383997f, 0.03282694f, 
    -0.00889346f, 0.00089661f, 0.03240269f, -0.03055799f, -0.03981680f, 0.03777861f, -0.01630396f, -0.03678595f, 
    -0.03301807f, -0.01306616f, -0.02006757f, 0.00212358f, 0.04219631f, 0.03143204f, -0.03917943f, -0.01611647f, 
    0.01434008f, -0.01942244f, -0.00690433f, 0.02091599f, 0.02468769f, -0.01494755f, -0.02147743f, -0.01271417f, 
    0.00047983f, -0.02327905f, -0.00844436f, 0.04339663f, -0.01250329f, -0.03758101f, 0.00846128f, -0.04837285f, 
    -0.04987089f, 0.03537109f, 0.00340820f, 0.01184071f, -0.04658333f, 0.04106747f, -0.01695911f, -0.01812666f, 
    -0.05708598f, -0.01765476f, 0.01570714f, -0.02209004f, -0.02392101f, 0.01551989f, -0.02377971f, 0.02732879f, 
    -0.04574058f, -0.00168943f, -0.02770568f, -0.03471742f, -0.01526500f, 0.03145699f, 0.00331497f, -0.03700006f, 
    -0.01186984f, 0.01740795f, -0.05167507f, -0.05370055f, 0.00514143f, 0.01483415f, 0.02450055f, 0.01767462f, 
    0.02439689f, -0.03636776f, 0.03836234f, 0.03164369f, 0.00064536f, 0.03848455f, -0.03588171f, 0.04170059f, 
    -0.01672188f, 0.03188250f, 0.02452250f, -0.00129673f, -0.02999418f, -0.03140684f, 0.01729927f, -0.03593860f, 
    -0.00956951f, -0.00115828f, -0.02170640f, -0.00440430f, 0.02004903f, -0.04664455f, -0.00463890f, -0.02583599f, 
    -0.01797766f, 0.01730585f, -0.01150232f, -0.01922737f, 0.03206539f, 0.02395506f, 0.01285246f, 0.00124801f, 
    0.05193605f, -0.02472316f, 0.01819266f, -0.01157300f, 0.01524874f, -0.04276210f, -0.00723740f, -0.00115393f, 
    -0.00581519f, -0.03248030f, 0.00061895f, 0.01378584f, 0.00368918f, -0.04460295f, 0.03234692f, -0.00944729f, 
    -0.00158024f, 0.04149643f, -0.04260645f, -0.01796615f, -0.05265855f, 0.00512584f, 0.00969778f, -0.05316994f, 
    -0.02038710f, -0.05104519f, -0.02249048f, 0.03245110f, -0.04164629f, 0.03952832f, 0.04116825f, -0.05163020f, 
    -0.01819834f, 0.00283267f, -0.02464496f, -0.01579752f, -0.01309810f, 0.00407250f, 0.02358596f, 0.01341738f, 
    -0.03190472f, 0.01067873f, 0.00730208f, -0.03439165f, 0.01279116f, 0.01216447f, 0.00475731f, -0.04613851f, 
    0.01700671f, -0.04732957f, -0.05318673f, 0.02402149f, -0.02066011f, 0.00819745f, -0.01598613f, 0.00314442f, 
    -0.02699164f, 0.02141304f, -0.04517694f, -0.01479546f, 0.03592628f, -0.03934760f, -0.01525818f, 0.01826878f, 
    -0.00251048f, -0.01068279f, -0.05837216f, 0.00244054f, -0.03656867f, -0.03446940f, 0.00799366f, -0.04574336f, 
    -0.01530267f, -0.01135966f, 0.02379803f, 0.02074321f, 0.00101650f, 0.00552714f, -0.01895165f, -0.04726125f, 
    0.01052688f, 0.03901576f, 0.04389824f, -0.00643253f, 0.03320134f, 0.02488378f, 0.00915111f, 0.00531105f, 
    0.02443445f, -0.01856810f, 0.03477329f, -0.01436766f, 0.04080733f, 0.03647710f, -0.05876245f, -0.04900998f, 
    -0.00130724f, -0.03610728f, -0.03392542f, 0.01939563f, 0.03401813f, -0.04169113f, 0.04277211f, 0.02444714f, 
    0.01140521f, -0.01586978f, -0.01718467f, -0.05599385f, -0.01349451f, -0.03653388f, -0.03237480f, 0.02980274f, 
    0.01123961f, -0.00472942f, 0.01514289f, -0.02117613f, -0.01315363f, 0.03474166f, -0.02784525f, 0.01637254f, 
    0.00915034f, -0.04465757f, 0.02832727f, 0.01246061f, -0.02108962f, 0.01722744f, 0.03418258f, 0.00853215f, 
    -0.01415878f, 0.04010510f, -0.05334282f, 0.02080650f, 0.00681533f, 0.01724893f, 0.03018764f, 0.01893990f, 
    -0.01793681f, 0.04389482f, -0.02578755f, -0.05160233f, -0.02334464f, 0.03924351f, 0.01764169f, 0.03485378f, 
    0.00004919f, 0.00785123f, -0.01582290f, -0.04953451f, 0.03001965f, 0.01735337f, -0.05728466f, 0.01612273f, 
    0.03206191f, -0.00905340f, -0.04902077f, 0.00409240f, 0.00179919f, 0.03372714f, -0.00671556f, -0.05580835f, 
    0.00609965f, -0.05180858f, 0.01843251f, 0.01105866f, 0.01495108f, 0.00069823f, -0.03414716f, -0.02564178f, 
    0.04404377f, 0.01388630f, -0.03252694f, 0.00875514f, 0.04030564f, -0.01306506f, -0.00292546f, -0.03862244f, 
    0.01179482f, -0.02785408f, -0.00086866f, -0.00217415f, -0.03236670f, -0.01244145f, -0.03989087f, -0.02298079f, 
    -0.01832430f, -0.04714490f, -0.00540834f, -0.00833393f, 0.00007158f, -0.01277116f, 0.00629482f, 0.03364241f, 
    -0.01101680f, -0.02258200f, 0.00370479f, 0.02961066f, 0.03582452f, 0.01657786f, 0.02298384f, 0.01499846f, 
    -0.03096075f, -0.03615951f, 0.00884666f, -0.02713676f, -0.03698908f, -0.03115640f, 0.02809297f, -0.03678749f, 
    0.03520240f, -0.02786096f, 0.01886096f, -0.05081084f, -0.05604962f, -0.03417774f, -0.04959554f, 0.03221045f, 
    -0.01030487f, 0.02176596f, -0.03464181f, -0.04918122f, -0.02143684f, -0.02302865f, -0.05709323f, 0.03051817f, 
    -0.01469270f, -0.04098134f, -0.00631074f, -0.05017611f, -0.05177805f, 0.03549087f, 0.00111122f, 0.02602959f, 
    0.03010562f, 0.01318720f, 0.02528641f, -0.01467443f, -0.01737827f, -0.04244535f, 0.01016229f, -0.01796528f, 
    -0.04386625f, -0.02779922f, -0.05780748f, 0.00081661f, 0.00524317f, 0.01417573f, -0.05653827f, 0.02669392f, 
    0.02713499f, -0.03421700f, 0.03409947f, -0.01022218f, -0.01080971f, -0.05153811f, -0.04110651f, -0.01508131f, 
    0.01000928f, 0.03344288f, 0.00985814f, 0.03041215f, -0.02740812f, -0.02041238f, -0.00708527f, -0.03880106f, 
    -0.04513830f, 0.11252513f, 0.15836726f, -0.05076895f, 0.04721595f, -0.09988314f, -0.16275725f, 0.03716384f, 
    -0.10746970f, 0.06973233f, -0.13998443f, -0.04192930f, 0.37765568f, -0.08801389f, -0.22890396f, -0.20806982f, 
    -0.01218871f, 0.03949222f, -0.04676569f, -0.15704869f, 0.18861139f, 0.22058165f, 0.06224355f, -0.07658331f, 
    -0.17737108f, -0.31821322f, 0.40434650f, -0.00139240f, 0.07787783f, 0.08979005f, -0.14831257f, 0.08689786f, 
    -0.01217719f, 0.18209979f, 0.09497123f, 0.17084363f, 0.12489826f, -0.11629915f, 0.04011872f, -0.20427337f, 
    -0.00240488f, -0.01917191f, -0.09980042f, 0.11289914f, 0.00434600f, -0.12055806f, -0.02639325f, 0.11045730f, 
    0.05589165f, -0.09680435f, 0.02495308f, -0.08095846f, -0.13140404f, -0.15910375f, -0.08832853f, -0.14625144f, 
    -0.01076854f, -0.01104756f, 0.00020392f, -0.12089663f, -0.17971684f, -0.01194127f, -0.12503958f, 0.48803520f, 
    -0.08983193f, 0.12950037f, 0.05961259f, 0.23468915f, -0.02329393f, 0.03387232f, -0.02814323f, -0.00108437f, 
    0.09157032f, -0.19001502f, 0.02612807f, 0.08434945f, -0.02901063f, 0.12779148f, -0.02996171f, 0.01178964f, 
    0.02739967f, -0.03265640f, 0.03687890f, -0.06388190f, 0.11707129f, 0.04996965f, -0.30893278f, 0.18756059f, 
    0.10595728f, -0.05011102f, 0.15129599f, -0.01666570f, -0.05681677f, 0.03202751f, 0.02355889f, -0.04070756f, 
    -0.01006112f, 0.13779162f, 0.32607532f, 0.41609141f, 0.06756601f, 0.06592602f, 0.08860954f, -0.02037028f, 
    -0.08695703f, -0.05801965f, -0.01763197f, 0.12173934f, -0.05207296f, 0.16824199f, 0.15963826f, 0.17869857f, 
    -0.11708400f, 0.00307177f, -0.26181516f, 0.00512470f, -0.15724906f, 0.06405725f, -0.05357775f, 0.01468118f, 
    0.28698167f, -0.01368251f, 0.01358580f, 0.05239423f, 0.06879431f, 0.06369626f, 0.03070747f, -0.02759329f, 
    -0.00623943f, -0.01533330f, -0.04990565f, 0.03002557f, -0.01693877f, 0.42888197f, 0.34058186f, -0.23602378f, 
    -0.02997279f, -0.20587476f, -0.02260501f, 0.03990571f, 0.01513980f, 0.00231778f, -0.05971089f, -0.01677906f, 
    -0.01616455f, -0.06060127f, -0.11649372f, -0.05732070f, -0.12214268f, -0.01135289f, -0.04084099f, 0.07417874f, 
    -0.13517767f, -0.06128682f, -0.02444206f, -0.07212311f, -0.00332445f, -0.16034356f, 0.07066185f, 0.09163940f, 
    -0.12437280f, 0.22229540f, -0.11086107f, 0.05462403f, -0.10616456f, -0.02511659f, 0.00060444f, 0.07192211f, 
    -0.07634595f, 0.28661835f, -0.20361479f, 0.09147935f, 0.06161804f, 0.11012388f, -0.03212227f, -0.10989253f, 
    -0.16544564f, -0.10634632f, -0.00950706f, -0.10712645f, 0.07718012f, -0.24429725f, 0.08848364f, 0.18002525f, 
    -0.04694705f, -0.02083898f, 0.05865361f, -0.02429214f, 0.12939127f, 0.09737652f, -0.08129885f, -0.02973500f, 
    -0.11485220f, 0.11169178f, 0.04992211f, 0.10780213f, -0.11875122f, -0.01558900f, -0.10632931f, -0.12049226f, 
    -0.11758015f, -0.12302203f, 0.07001359f, -0.07412299f, 0.02945808f, 0.29778239f, 0.01037881f, -0.17920996f, 
    0.02781168f, -0.11279948f, 0.02834059f, -0.01059570f, -0.15600687f, -0.03815730f, 0.00118987f, 0.02626796f, 
    0.16426805f, 0.11329680f, -0.16691908f, -0.10747552f, 0.23798384f, 0.10018183f, 0.16657317f, -0.01962769f, 
    -0.07174736f, -0.01912472f, 0.11253978f, -0.08039809f, -0.16732922f, -0.11780021f, 0.35336024f, 0.03140480f, 
    0.15580240f, 0.00233009f, -0.02450037f, 0.08531578f, 0.00645300f, -0.01988188f, 0.06356711f, 0.05359449f, 
    0.22222190f, 0.48670816f, 0.55928004f, -0.15730569f, -0.14293206f, -0.16037850f, -0.19196387f, 0.08254987f, 
    -0.03399687f, -0.01142766f, 0.08751145f, -0.09831630f, 0.12253197f, 0.04425419f, -0.05440448f, -0.12854640f, 
    -0.01688715f, 0.09378367f, 0.03143698f, 0.15610547f, 0.11547584f, 0.08441540f, -0.00848813f, -0.19628322f, 
    0.10733890f, 0.15752023f, 0.10137361f, 0.11766670f, -0.25553375f, 0.04805614f, 0.07619610f, 0.02443798f, 
    0.20049383f, 0.15809464f, -0.06457968f, -0.21538192f, 0.17590576f, -0.18168059f, -0.09107129f, -0.10170522f, 
    -0.06979770f, -0.04826450f, 0.03663367f, 0.09603719f, 0.00313679f, 0.09188286f, -0.12144285f, 0.01567367f, 
    0.00363644f, 0.31217504f, -0.23958531f, 0.00473631f, 0.01747085f, 0.03444303f, 0.05417277f, -0.00432934f, 
    0.15261523f, 0.07597904f, -0.00633366f, 0.18893045f, -0.20910646f, 0.29576409f, -0.02842177f, 0.04584184f, 
    -0.05688211f, -0.00003969f, 0.03430635f, -0.14457671f, -0.07699781f, 0.07351203f, -0.17884803f, -0.00138243f, 
    0.11673902f, -0.04669081f, -0.05833359f, 0.12476198f, 0.10693352f, 0.09844296f, 0.08477149f, 0.08343048f, 
    0.11492960f, 0.11698573f, 0.12137705f, -0.00117351f, 0.12213777f, 0.16607387f, 0.23006284f, -0.03896291f, 
    -0.03215188f, -0.00247762f, -0.16522476f, -0.09109736f, -0.12835771f, -0.06621823f, -0.01831193f, -0.00138001f, 
    0.34929737f, 0.29207188f, -0.00028386f, 0.19764860f, -0.04254117f, 0.10569517f, -0.03661883f, 0.16818324f, 
    -0.09380411f, -0.02534871f, 0.02149941f, -0.07043010f, -0.22400542f, -0.02409244f, -0.15672696f, -0.09700572f, 
    0.03422927f, 0.02070817f, -0.10439659f, -0.17054828f, -0.03709678f, 0.04799268f, -0.09067449f, 0.12765928f, 
    0.41921782f, 0.04498743f, -0.27706182f, 0.10275987f, 0.03482641f, -0.06547876f, 0.16247624f, 0.02513307f, 
    -0.05948194f, -0.20685774f, 0.03330564f, -0.02954954f, 0.29055065f, 0.01492663f, 0.20790622f, -0.17430013f, 
    -0.10280663f, -0.05417155f, -0.05419113f, 0.04630172f, 0.12515001f, -0.02568169f, -0.06936925f, 0.07953593f, 
    -0.02841866f, -0.02029524f, 0.04748343f, -0.00499571f, -0.02021245f, 0.03428024f, -0.04588735f, -0.05642161f, 
    -0.02503351f, -0.01670930f, -0.04484104f, 0.00194026f, -0.03302930f, -0.00190138f, -0.00394340f, -0.05479979f, 
    -0.00770197f, -0.01297461f, 0.00162599f, -0.02217335f, -0.02797047f, 0.01703301f, 0.02971416f, 0.02952480f, 
    0.03236295f, -0.03743796f, -0.02770136f, 0.03588185f, -0.00647712f, -0.05295057f, -0.04189245f, 0.03360024f, 
    0.02877561f, 0.01316761f, 0.01565053f, 0.04070169f, -0.03284184f, 0.03376432f, 0.00191529f, -0.00650459f, 
    -0.04358171f, -0.05204408f, 0.01336145f, -0.05264089f, -0.01813212f, 0.03907608f, -0.05387362f, -0.02690072f, 
    -0.04011551f, 0.01945421f, 0.01087068f, -0.03609151f, 0.00259493f, 0.02603214f, 0.03133052f, 0.01813026f, 
    -0.00533369f, 0.03180231f, 0.02451529f, -0.02726629f, -0.05039299f, 0.02354893f, 0.00084819f, -0.02046356f, 
    -0.04408591f, 0.04486373f, -0.00127792f, -0.05015061f, 0.01020221f, -0.03762290f, 0.02990282f, 0.01056161f, 
    -0.00874538f, -0.03461452f, -0.03859833f, -0.03259886f, 0.02989238f, -0.03677310f, -0.00398173f, 0.02332073f, 
    0.00938905f, 0.00309791f, -0.03730115f, -0.02353210f, 0.03082011f, 0.01424539f, -0.01457743f, -0.02853935f, 
    0.00610913f, -0.03299678f, 0.04172419f, -0.01154776f, -0.02051142f, 0.03202087f, -0.01245029f, 0.01897758f, 
    0.00256292f, -0.05270173f, -0.00055000f, -0.01518936f, -0.00937157f, -0.01209638f, 0.03038041f, -0.02588781f, 
    -0.03435387f, -0.02361952f, -0.02013605f, 0.01042559f, -0.01340873f, -0.03259907f, 0.02708118f, 0.00042670f, 
    -0.01525672f, -0.02128675f, 0.00861987f, 0.02676096f, -0.01352505f, -0.05356669f, -0.05074343f, 0.03281363f, 
    0.03918278f, 0.04076612f, -0.01188460f, 0.02796813f, -0.05088278f, 0.03856093f, -0.02848588f, -0.00614852f, 
    0.02047117f, -0.00172770f, -0.01744390f, -0.02729619f, -0.01457202f, -0.01029158f, 0.03234907f, 0.04746513f, 
    0.04407092f, -0.05473847f, 0.00523604f, 0.03142250f, -0.04185072f, 0.00846333f, 0.02182284f, -0.04204445f, 
    0.04195282f, 0.04314496f, 0.02407323f, -0.04146992f, -0.03537921f, -0.03667798f, 0.02928596f, 0.03839688f, 
    0.00273944f, -0.01007451f, -0.00708508f, -0.02086459f, -0.04438310f, 0.00230464f, -0.02715602f, 0.02329144f, 
    0.00782492f, 0.03860172f, 0.01984060f, -0.04631656f, 0.02537473f, 0.02625781f, -0.00875606f, 0.00867909f, 
    0.00590551f, -0.02104411f, 0.01114628f, 0.03337931f, -0.03211949f, -0.03045847f, -0.05134797f, -0.00342876f, 
    -0.02221180f, -0.01596766f, -0.02986966f, 0.04443669f, -0.00781049f, -0.01194642f, 0.03031375f, -0.02210718f, 
    -0.02805649f, -0.00340954f, -0.01902735f, 0.01430705f, -0.02489557f, -0.04164319f, -0.02734989f, 0.02728604f, 
    -0.03832512f, 0.02780958f, -0.04953765f, -0.03049859f, 0.00393267f, 0.03309467f, 0.02537328f, -0.02503119f, 
    0.03647904f, 0.00545519f, 0.00381110f, -0.02268336f, 0.00696318f, -0.05155483f, -0.00653436f, -0.01495140f, 
    0.02680841f, 0.01588668f, 0.00783507f, 0.04631151f, -0.05611511f, -0.02636095f, -0.02156651f, -0.03074618f, 
    0.02045087f, 0.00968368f, -0.02586347f, 0.04308413f, -0.05376988f, 0.00533747f, -0.05535854f, 0.03900819f, 
    0.02857121f, 0.02465595f, 0.00860473f, -0.01851103f, 0.02560506f, -0.01479765f, -0.00051932f, -0.03928154f, 
    0.02610596f, 0.01463862f, 0.03170351f, -0.01621947f, 0.01819678f, -0.02400816f, 0.01240071f, -0.05534901f, 
    -0.02714849f, -0.01252576f, -0.04240094f, 0.03121166f, -0.05207810f, 0.04170267f, 0.04329349f, -0.04699275f, 
    0.01550057f, -0.01996757f, -0.00996679f, 0.04361927f, -0.03340847f, -0.03853734f, -0.01332769f, -0.00247734f, 
    0.01984652f, -0.04424214f, -0.03255236f, -0.01640161f, 0.04079169f, -0.05101852f, -0.01401690f, -0.04425069f, 
    0.00758815f, -0.04406615f, 0.01795617f, -0.04110588f, 0.04158959f, -0.01527442f, 0.02869544f, 0.02289039f, 
    -0.04001980f, -0.01273801f, -0.03627307f, -0.02103169f, -0.03269363f, 0.04516397f, -0.05012150f, 0.00563171f, 
    -0.01022713f, 0.03205426f, 0.02997691f, -0.02769381f, 0.00423314f, -0.05409665f, -0.04016707f, -0.02799388f, 
    -0.04363338f, -0.04480336f, 0.02480912f, -0.05003007f, -0.01930212f, -0.03801941f, -0.00512004f, 0.02426525f, 
    0.03318336f, 0.03175025f, -0.04198847f, 0.02919129f, 0.03777873f, 0.01600694f, -0.00030804f, -0.02036573f, 
    0.00866610f, -0.01020793f, 0.01929675f, -0.00360185f, -0.05702700f, -0.01080811f, 0.00773970f, -0.04685063f, 
    -0.05479606f, -0.00569895f, -0.02799512f, 0.04351003f, -0.00640942f, 0.02994015f, -0.01308991f, 0.04384979f, 
    -0.04323414f, -0.03520421f, 0.03291249f, -0.02742419f, -0.00300918f, -0.00334778f, 0.01138789f, 0.04600042f, 
    0.04387425f, 0.03843280f, -0.03319369f, -0.01885077f, 0.00308379f, -0.00971027f, 0.03194607f, -0.04993365f, 
    -0.01620714f, -0.04107172f, 0.00560563f, 0.02860759f, 0.02632482f, -0.04315966f, 0.02470737f, -0.05149357f, 
    0.02140772f, -0.04100723f, -0.05210689f, -0.05594567f, -0.03133104f, 0.02777287f, 0.02213452f, 0.01142252f, 
    -0.04128670f, -0.02416808f, 0.02525827f, 0.00109668f, 0.03560417f, -0.00448833f, 0.01506780f, -0.05737891f, 
    0.04015203f, -0.01048651f, -0.05639981f, -0.03465261f, -0.03743266f, 0.03426613f, 0.00397886f, -0.01824263f, 
    -0.01602351f, 0.00537289f, -0.02821993f, 0.03852338f, -0.05467276f, 0.01158811f, 0.04050794f, -0.04700517f, 
    0.01693490f, -0.04795039f, 0.00105057f, -0.04735954f, -0.02897331f, -0.00806576f, -0.01815067f, 0.02811801f, 
    0.00151673f, -0.04477957f, -0.03327752f, 0.10158224f, -0.09734859f, 0.05610564f, 0.04111198f, -0.01128983f, 
    0.03355430f, -0.04737184f, -0.02408675f, 0.07675036f, -0.58716834f, 0.15234004f, 0.24939045f, 0.05682370f, 
    0.00311871f, 0.06628093f, 0.06367764f, 0.06883927f, 0.02475095f, -0.04730394f, 0.11546025f, 0.09155424f, 
    0.13338833f, -0.05191002f, -0.29770681f, 0.08767828f, -0.00814446f, -0.05550845f, 0.07673743f, -0.16867231f, 
    -0.00606149f, -0.00682810f, 0.02635363f, -0.12014081f, -0.14833535f, 0.04230404f, 0.03627365f, 0.11657352f, 
    -0.02824628f, -0.07531606f, -0.05639116f, -0.04300150f, 0.07840469f, 0.03507380f, 0.01215687f, 0.06061948f, 
    -0.02079430f, -0.01860081f, 0.01565572f, 0.11357001f, 0.05716822f, 0.02331669f, -0.06651596f, -0.03272223f, 
    -0.07616443f, -0.06245974f, -0.14369549f, -0.10254347f, 0.05677142f, -0.05197418f, -0.28085017f, -0.19409023f, 
    0.07444736f, 0.00722078f, -0.13030471f, -0.27791396f, 0.10598450f, -0.07397977f, 0.01480870f, -0.09888366f, 
    0.02130105f, 0.14654388f, -0.11144613f, -0.21069776f, 0.07319860f, 0.02827043f, -0.00418145f, -0.08927666f, 
    -0.04081570f, -0.08503266f, -0.17113183f, -0.10769223f, -0.46274579f, -0.05156948f, 0.27158180f, -0.12333370f, 
    -0.06253783f, 0.08798319f, 0.06692187f, -0.09119119f, 0.16346672f, 0.19892892f, 0.08031268f, 0.06360376f, 
    0.11690478f, -0.17336845f, -0.28189108f, -0.27709258f, 0.15289018f, 0.12731294f, -0.20744973f, -0.04535019f, 
    0.05561224f, 0.06044520f, 0.07909611f, -0.06002648f, -0.11303576f, -0.08182598f, -0.12258471f, 0.02320543f, 
    0.10384626f, 0.12301077f, 0.09778205f, -0.03423727f, 0.07517968f, -0.11590637f, 0.01707285f, -0.03540439f, 
    -0.03398749f, 0.06672246f, -0.32323346f, -0.12097143f, 0.04982885f, 0.13505366f, -0.08548242f, -0.09442111f, 
    0.05223149f, -0.05331443f, 0.12912528f, 0.00009214f, 0.02302246f, -0.38643926f, -0.17616612f, 0.17820735f, 
    0.20091242f, 0.19897163f, -0.21713084f, -0.13939917f, 0.03002397f, -0.01953156f, -0.02868079f, -0.08659640f, 
    0.27707973f, 0.18324023f, -0.03141235f, -0.16141453f, 0.19926843f, 0.06242144f, 0.05662687f, 0.01272547f, 
    0.04964516f, 0.06767871f, 0.10861351f, 0.03768060f, -0.08688548f, 0.22652496f, -0.06782475f, -0.09032597f, 
    -0.01055688f, -0.04962470f, -0.00764331f, -0.01646139f, 0.07068449f, -0.00591288f, 0.02761382f, -0.04454470f, 
    -0.08802252f, -0.05632494f, 0.21400958f, -0.11408681f, -0.09478896f, -0.07529430f, 0.00040208f, 0.06156052f, 
    0.09868819f, 0.04321159f, -0.02437635f, 0.01035787f, 0.05227857f, 0.15101050f, -0.09653053f, -0.02249023f, 
    0.10970785f, 0.14510980f, -0.18660995f, 0.07309015f, -0.06158955f, 0.02195279f, -0.01581427f, 0.08900037f, 
    0.02592004f, -0.17301482f, -0.06295793f, 0.10888381f, 0.04055872f, 0.05769025f, -0.01723072f, -0.03401211f, 
    0.10715196f, 0.05369433f, 0.00395582f, 0.07765366f, -0.13442847f, 0.08166785f, 0.26263970f, 0.29134843f, 
    -0.03155017f, 0.01496468f, 0.05478692f, -0.02987284f, 0.10851551f, -0.03144844f, 0.09649494f, -0.04778098f, 
    0.04112909f, 0.03409801f, 0.16180412f, -0.14403249f, 0.03061902f, 0.04076336f, 0.00066757f, 0.02579729f, 
    -0.04974260f, -0.11086352f, -0.15545681f, 0.02196898f, 0.13701603f, 0.09516937f, -0.19734630f, -0.02276502f, 
    -0.12788765f, 0.10695142f, 0.02488054f, -0.13423891f, 0.07761179f, 0.07048741f, -0.12179144f, -0.13135751f, 
    -0.25177503f, -0.17273791f, -0.21822010f, 0.19602640f, 0.18524696f, 0.11140301f, -0.00594971f, 0.10285214f, 
    -0.04210579f, -0.00225241f, -0.09454065f, 0.09438849f, -0.13320693f, -0.06790536f, 0.15362638f, 0.22169018f, 
    -0.07705765f, -0.14837869f, 0.07781208f, 0.03854596f, -0.05680460f, 0.02587232f, -0.04488991f, 0.19852601f, 
    -0.12857877f, -0.14105137f, -0.02452407f, 0.02204487f, 0.15646829f, 0.03974296f, -0.09435564f, 0.01689124f, 
    -0.01476408f, -0.04458982f, 0.03708946f, 0.08687522f, 0.18376625f, 0.21229203f, -0.14841400f, -0.21521667f, 
    0.05910041f, 0.05895541f, -0.03502331f, -0.03597284f, 0.07437775f, 0.00579644f, -0.00558210f, -0.02069749f, 
    0.08684532f, -0.15809177f, 0.20172612f, -0.11879504f, -0.01632963f, -0.05066608f, 0.01002230f, -0.07749062f, 
    -0.18171401f, -0.03255270f, -0.03806721f, -0.07896532f, 0.00278577f, -0.05254876f, 0.03547207f, 0.07438806f, 
    0.00817897f, 0.10371996f, 0.01877506f, 0.15524055f, 0.09845416f, 0.02494906f, 0.13400014f, 0.10819430f, 
    -0.12630120f, 0.02876187f, -0.02017550f, 0.06585494f, -0.12535951f, -0.00044302f, -0.07979904f, 0.02493892f, 
    -0.05220128f, -0.03897011f, -0.10288426f, 0.23838511f, -0.15428834f, -0.00251923f, -0.05247613f, 0.17373963f, 
    0.10224520f, 0.04266331f, 0.04680504f, -0.00443869f, -0.04103089f, -0.01922078f, 0.01791571f, -0.10035130f, 
    -0.01137594f, -0.12899488f, -0.00466788f, -0.14167711f, 0.03882305f, 0.01533941f, 0.08858857f, -0.01619143f, 
    0.02453136f, -0.01257667f, -0.03205056f, 0.01282924f, 0.05508636f, -0.07888945f, 0.11065539f, 0.10954220f, 
    0.00140077f, -0.06780341f, -0.06957272f, -0.01018190f, 0.12793565f, -0.03245228f, -0.01870243f, 0.08246682f, 
    0.11740065f, 0.21447560f, -0.00882057f, -0.13081600f, 0.10642044f, 0.14243080f, 0.04735153f, -0.01142484f, 
    -0.03642770f, 0.07352197f, 0.05343668f, 0.02643664f, -0.29602307f, 0.28516591f, -0.08243975f, 0.21821165f, 
    0.04653087f, 0.03437714f, -0.00501098f, 0.05342491f, 0.00826514f, -0.00211338f, 0.09249901f, -0.08448245f, 
    0.01177206f, 0.07022768f, 0.00993202f, -0.00125556f, 0.17654200f, -0.00196632f, 0.14956819f, 0.08085243f, 
    0.02049088f, -0.11542600f, -0.10990772f, -0.03805928f, -0.41414580f, 0.17586361f, 0.08663946f, 0.19174053f, 
    -0.14076933f, -0.06142744f, -0.05481392f, 0.10641928f, 0.09176714f, 0.06924362f, 0.00318214f, -0.06244340f, 
    0.19434674f, -0.15776478f, 0.04947854f, -0.15224430f, 0.09005832f, 0.09214584f, 0.00393980f, -0.02176402f, 
    0.07564891f, 0.04177807f, 0.00466626f, -0.01847573f, 0.10726936f, -0.00083719f, 0.05075902f, 0.00837252f, 
    0.05559077f, 0.12893765f, 0.00114903f, 0.04525389f, -0.16619447f, -0.15145119f, -0.10791066f, -0.13213286f, 
    0.05317625f, 0.10204114f, 0.03603645f, -0.07215320f, 0.01108501f, -0.01103538f, 0.00553348f, 0.01143230f, 
    0.12699038f, 0.02251418f, 0.12176733f, 0.11666210f, 0.17775892f, 0.21692589f, 0.13344991f, -0.10285754f, 
    0.05672580f, 0.09554698f, -0.09881040f, 0.11141390f, 0.10075556f, -0.02352028f, -0.16387139f, -0.02740960f, 
    -0.18110107f, -0.08655930f, 0.17250216f, -0.04862810f, -0.14317486f, 0.00621018f, 0.06436299f, 0.06921811f, 
    -0.02901839f, -0.05084926f, -0.00031292f, 0.05710120f, -0.23194481f, 0.33440155f, 0.01414038f, 0.07739814f, 
    -0.03482055f, 0.07338731f, -0.05117049f, 0.08186301f, 0.17546229f, 0.06971102f, -0.12029680f, 0.11489578f, 
    -0.02461983f, 0.26797128f, 0.15511233f, 0.13460207f, 0.00136402f, -0.10784006f, 0.30716205f, 0.10345538f, 
    -0.04395946f, -0.12458573f, -0.00146027f, 0.05260558f, 0.36025271f, -0.02615566f, 0.09195838f, 0.07465135f, 
    0.16312154f, 0.00699110f, 0.09888048f, -0.04818941f, -0.02124606f, 0.02169942f, -0.09125495f, -0.02156788f, 
    -0.15402876f, 0.25666878f, 0.31102353f, 0.11188710f, -0.15884319f, -0.06487385f, 0.04736997f, 0.04550781f, 
    0.04191174f, 0.02081024f, 0.05628248f, 0.13104284f, 0.14084253f, -0.02777066f, 0.11608194f, 0.01709860f, 
    0.12941240f, -0.07596536f, -0.07863549f, -0.23416591f, -0.03788049f, -0.07138733f, -0.00014026f, -0.06014919f, 
    -0.11529134f, -0.05129000f, 0.00279585f, -0.03391736f, -0.01634284f, 0.07454162f, -0.04790299f, -0.04764976f, 
    -0.07571253f, -0.12835734f, -0.08686058f, -0.05996809f, 0.12906370f, -0.18052329f, 0.06319935f, -0.00755170f, 
    0.12182866f, -0.07517777f, -0.11081272f, 0.09282179f, 0.02580289f, 0.00101376f, 0.04784817f, -0.10516734f, 
    -0.12217520f, -0.05741966f, -0.16671637f, 0.17700525f, -0.02640728f, 0.02527105f, -0.14159974f, -0.07718141f, 
    -0.18464971f, -0.06598911f, -0.05865067f, -0.09895129f, -0.03417573f, 0.07319628f, 0.19660595f, 0.06036558f, 
    -0.20367643f, 0.01011357f, 0.05760334f, -0.09417978f, 0.01269496f, -0.07183280f, -0.11062120f, -0.11499099f, 
    0.27852398f, 0.08500261f, -0.03949189f, -0.12147190f, -0.04992500f, 0.03466779f, -0.06906772f, 0.00922597f, 
    -0.14562647f, 0.10386314f, 0.10939440f, 0.16015171f, 0.08899146f, -0.33738708f, -0.12269856f, 0.41695628f, 
    0.10785270f, -0.07727651f, -0.08017959f, 0.07718573f, 0.07470404f, -0.02652010f, 0.12691492f, 0.24936052f, 
    -0.08712374f, -0.00301250f, -0.04559469f, 0.06968420f, -0.06601758f, -0.02425148f, 0.09682625f, -0.03513151f, 
    -0.10829289f, -0.04808845f, 0.09038785f, -0.01404414f, 0.01447641f, -0.08775780f, 0.07389789f, -0.13452104f, 
    0.22078285f, 0.11338502f, -0.00012886f, 0.06620678f, -0.02769362f, -0.11243382f, -0.06671074f, -0.13642797f, 
    0.36075318f, 0.22396572f, -0.02660352f, -0.00751361f, 0.09882347f, 0.04507812f, 0.10778804f, 0.01564513f, 
    -0.03437436f, -0.02790294f, -0.10091698f, -0.01007239f, -0.12717238f, 0.04612959f, -0.00145539f, 0.12062075f, 
    -0.02515879f, 0.01811964f, 0.02346148f, -0.04503103f, 0.04765551f, -0.09646386f, -0.03637975f, -0.03090747f, 
    0.10799600f, -0.08628865f, -0.02828152f, 0.05897693f, 0.07038330f, 0.05445475f, 0.11153440f, -0.03265959f, 
    0.08668216f, -0.08407457f, -0.04513361f, -0.13596877f, -0.16088711f, 0.00757643f, 0.06795103f, 0.08666585f, 
    -0.08742265f, -0.10161943f, -0.09770578f, -0.06389588f, -0.04929207f, -0.08141756f, -0.16171312f, -0.07377906f, 
    0.00879439f, -0.08509937f, -0.11559162f, 0.01553383f, -0.03245042f, 0.02907942f, 0.05436210f, -0.08680775f, 
    0.28329414f, -0.00001523f, 0.13866761f, 0.22172299f, 0.31184924f, 0.01221387f, -0.30519336f, 0.06001289f, 
    0.00866086f, -0.00011990f, -0.02124374f, -0.07831495f, -0.00052584f, 0.09293944f, 0.16627076f, 0.22397792f, 
    -0.20918404f, -0.07857072f, 0.22733562f, 0.01760853f, -0.03113991f, 0.08447475f, -0.03379364f, 0.12501150f, 
    0.18458626f, 0.21853535f, 0.06244216f, -0.02478329f, 0.11451261f, 0.15916301f, -0.03063062f, 0.00068028f, 
    0.00457353f, 0.02947435f, 0.02670969f, 0.05828166f, 0.06118598f, 0.01679287f, 0.04240408f, 0.15767734f, 
    -0.00945925f, 0.00856114f, 0.12766361f, -0.01853717f, -0.02864524f, 0.18348856f, -0.05863889f, 0.00967543f, 
    -0.06089075f, -0.15916504f, -0.04379081f, -0.04308620f, -0.13339126f, 0.30670914f, 0.08310582f, 0.05129665f, 
    -0.11535994f, 0.05947783f, -0.01975618f, 0.20528685f, 0.00031558f, -0.10834973f, 0.00914808f, 0.04209906f, 
    -0.14629160f, -0.34859169f, 0.12530190f, 0.04096798f, -0.02773265f, -0.15296541f, 0.15207492f, -0.11323379f, 
    0.04400339f, -0.05789648f, -0.07783365f, -0.13974312f, 0.36670601f, -0.01033097f, -0.21206866f, 0.05579819f, 
    -0.04084518f, -0.07661974f, 0.06127699f, 0.11306636f, 0.14518531f, 0.05890275f, 0.11389400f, -0.17266016f, 
    -0.14737381f, -0.01825374f, 0.00712455f, -0.00925299f, -0.09419872f, 0.05805433f, -0.12958716f, 0.04185453f, 
    -0.08927041f, -0.03619084f, 0.03282332f, 0.01654726f, 0.41273993f, 0.10053757f, 0.06645274f, 0.16202947f, 
    0.11864295f, 0.07154224f, 0.01570819f, -0.02434676f, -0.05739603f, 0.11781799f, 0.01555891f, 0.09171773f, 
    -0.08827361f, -0.21328378f, -0.13629796f, -0.19474877f, -0.02062119f, 0.04088229f, -0.10293995f, -0.15048511f, 
    0.08057747f, -0.03343336f, -0.20803221f, 0.01450312f, 0.00578969f, -0.00924000f, -0.14171812f, 0.08533093f, 
    0.06111385f, -0.02042182f, 0.06013701f, 0.03539095f, -0.06339310f, -0.06979673f, 0.04509992f, 0.01525771f, 
    -0.09796953f, 0.08442601f, 0.02647245f, 0.18472432f, 0.05286683f, 0.06820215f, -0.00637428f, 0.05846148f, 
    0.02978433f, 0.02240159f, 0.17613511f, 0.07186636f, 0.17618303f, 0.36194956f, -0.25024575f, -0.01554331f, 
    0.11150124f, -0.06282067f, -0.04125948f, -0.09471809f, -0.14039914f, 0.10023282f, -0.01047691f, -0.08388820f, 
    0.12210258f, 0.02615578f, -0.00926986f, 0.08551408f, 0.01703889f, 0.04581492f, 0.01950154f, 0.00083381f, 
    -0.16072327f, -0.17190498f, 0.00673669f, -0.15064214f, 0.19654375f, -0.02702710f, -0.04080573f, -0.00257724f, 
    0.18108661f, -0.04609130f, -0.02553480f, 0.10789966f, -0.05612233f, -0.08092860f, -0.09424765f, 0.13306487f, 
    0.17542244f, -0.09937885f, 0.31250435f, -0.06027079f, -0.03919625f, 0.16767813f, -0.16219389f, -0.19666414f, 
    -0.08629611f, -0.04703302f, 0.05010241f, 0.13703759f, -0.12436079f, -0.11268404f, -0.06175308f, -0.06717046f, 
    -0.06432211f, -0.03732153f, 0.03341750f, -0.04949179f, -0.03706387f, 0.12561443f, -0.07271434f, 0.08223495f, 
    0.33489829f, 0.06498766f, 0.08979212f, 0.22560528f, 0.10061946f, 0.04650185f, 0.03965367f, -0.13030002f, 
    0.06841493f, 0.01814944f, -0.05917808f, 0.14620137f, 0.00428627f, 0.10160920f, -0.06239158f, -0.13460009f, 
    -0.06378341f, -0.12132553f, 0.00362919f, 0.13376984f, 0.00536295f, 0.00845730f, -0.02864587f, 0.10283675f, 
    -0.08278806f, -0.04016384f, -0.00714731f, -0.07427660f, -0.00853784f, 0.00316235f, 0.07849480f, 0.02127684f, 
    -0.03166976f, -0.06684970f, -0.06901778f, -0.04544778f, 0.03494781f, -0.18458261f, 0.01489425f, 0.06598184f, 
    0.00414712f, -0.20939448f, 0.20713902f, 0.04117146f, 0.04387913f, 0.02544426f, -0.00842398f, 0.15062214f, 
    -0.06772818f, -0.02495355f, 0.22486678f, -0.04180377f, -0.04388711f, -0.02343930f, 0.11443828f, -0.00645998f, 
    -0.02929954f, 0.10880934f, -0.05477679f, 0.09408763f, 0.06132223f, 0.04251504f, 0.06972613f, 0.15243457f, 
    0.10794919f, 0.00348509f, 0.10159373f, -0.11376861f, -0.04477138f, 0.05817664f, 0.05010976f, 0.04353008f, 
    0.12895809f, -0.06154447f, -0.04008662f, 0.03651023f, -0.02864326f, 0.04044018f, -0.01254425f, 0.01282786f, 
    0.00220313f, 0.08421095f, 0.04258009f, -0.05716708f, -0.00552836f, 0.15928447f, -0.15935913f, 0.02855950f, 
    0.06869811f, 0.00421831f, 0.11390433f, 0.14327469f, -0.07011816f, 0.02576512f, -0.12744494f, -0.07293042f, 
    0.07175130f, 0.13418184f, -0.00705876f, 0.08798289f, 0.06654067f, 0.10808653f, -0.00271281f, -0.15425707f, 
    -0.13456467f, -0.04571490f, -0.09708796f, -0.20420463f, -0.07981878f, -0.11221084f, -0.12857561f, -0.00351126f, 
    -0.03351259f, -0.00713714f, -0.15915076f, 0.11711418f, 0.12199654f, -0.00999397f, -0.07205781f, 0.01411646f, 
    -0.34644032f, 0.02336973f, 0.05284037f, 0.02246518f, 0.06320126f, 0.11036251f, 0.08839336f, 0.03772045f, 
    0.02431310f, -0.01187638f, 0.06201951f, 0.08558734f, -0.00923844f, 0.11810453f, -0.16171534f, -0.00964854f, 
    0.01002869f, 0.01862065f, -0.13678686f, 0.19564569f, 0.06352030f, 0.06597111f, 0.03664950f, -0.05959131f, 
    0.05565252f, -0.04106996f, 0.04042947f, 0.03363133f, -0.16697587f, -0.09091211f, -0.03658071f, -0.06153300f, 
    0.11451443f, -0.05205037f, -0.15877086f, -0.02337026f, -0.03599694f, -0.07325540f, -0.17607464f, -0.02382894f, 
    0.05229847f, 0.00986003f, 0.08415839f, 0.06533222f, -0.08127003f, 0.00577469f, 0.04883835f, -0.03961192f, 
    0.02062928f, 0.02004231f, -0.04179535f, -0.03512369f, 0.01854618f, -0.04253112f, -0.14602540f, -0.12833935f, 
    0.15615147f, 0.00146588f, -0.03726720f, 0.09295443f, -0.02984640f, -0.11941842f, 0.18103838f, -0.15397272f, 
    0.05934063f, 0.02482724f, -0.13373061f, -0.02721030f, -0.01515720f, 0.02828163f, -0.04121983f, 0.04389413f, 
    0.23703445f, -0.04159596f, -0.05522221f, 0.18582231f, 0.03398827f, -0.11490256f, 0.17346378f, -0.03228930f, 
    0.22611982f, -0.08572830f, 0.17376156f, -0.17702574f, -0.19431862f, 0.04569176f, 0.10217623f, 0.12414436f, 
    -0.03577954f, -0.00997576f, 0.05776893f, 0.04451587f, 0.07497075f, 0.05740923f, -0.13525172f, 0.15772596f, 
    -0.09732403f, -0.00516402f, -0.02039045f, 0.14450401f, -0.09000704f, -0.22260231f, 0.17494325f, -0.11290169f, 
    0.01632611f, -0.02260644f, 0.00119810f, 0.06456487f, 0.35128203f, 0.33177778f, 0.11275920f, 0.14747000f, 
    0.03970222f, 0.10281556f, 0.09601477f, -0.22089013f, -0.12456892f, 0.01676251f, 0.21605627f, -0.02142179f, 
    0.02702712f, 0.11335608f, -0.23003839f, 0.05057944f, 0.01602924f, 0.04072339f, -0.06902559f, 0.22796947f, 
    0.07736559f, 0.02730212f, -0.00509425f, -0.00039455f, -0.24019584f, 0.09596612f, 0.12203054f, -0.07334615f, 
    0.04410072f, -0.03131172f, 0.07864602f, -0.09439208f, 0.12360995f, -0.11034961f, -0.10749110f, 0.12405825f, 
    -0.10923231f, 0.01739408f, -0.04092376f, -0.09338938f, -0.02162554f, -0.08791766f, -0.11554531f, -0.03945424f, 
    -0.04929823f, 0.06136012f, 0.03599858f, 0.00131634f, 0.32362327f, -0.22751571f, -0.27404723f, -0.22474562f, 
    -0.04816337f, 0.00454394f, 0.07032012f, -0.06322054f, 0.10775460f, 0.09098677f, 0.00770799f, -0.09383390f, 
    -0.13014592f, -0.21341684f, 0.15568827f, 0.02732766f, 0.10133407f, 0.01200610f, 0.02535277f, 0.14004119f, 
    -0.04138206f, 0.03553151f, 0.07687891f, 0.15900530f, 0.05725256f, -0.00057260f, -0.10287358f, -0.04159505f, 
    0.06619093f, -0.18292703f, -0.09782916f, -0.01311486f, -0.00721450f, 0.11064780f, 0.12921506f, 0.10167443f, 
    -0.04350963f, 0.07449359f, 0.02128897f, -0.02024254f, -0.15341678f, -0.13560350f, -0.09974907f, -0.10385041f, 
    -0.07247708f, -0.08370720f, -0.09593526f, -0.10393848f, 0.19713695f, 0.27658594f, -0.28687400f, 0.28035849f, 
    -0.09161981f, -0.00944062f, 0.08235137f, 0.03884102f, 0.04833925f, 0.24229650f, 0.16622071f, 0.15990558f, 
    0.14867856f, 0.00786234f, -0.04600702f, 0.11933632f, 0.20974746f, 0.17309552f, 0.09862581f, 0.07659095f, 
    0.04470957f, 0.02463459f, -0.01061125f, -0.03445375f, 0.26335123f, -0.10211176f, -0.21266922f, -0.04998136f, 
    0.02049652f, -0.02056397f, 0.03640621f, 0.21854797f, -0.21919033f, 0.15172042f, 0.17339392f, 0.01340581f, 
    -0.00793613f, -0.17803313f, 0.20287210f, 0.10828292f, 0.09424017f, 0.13242498f, 0.04934792f, 0.01088408f, 
    -0.02837935f, 0.03874871f, 0.05554476f, -0.08641311f, -0.17599495f, 0.07903933f, 0.17000987f, -0.05823138f, 
    -0.12163532f, -0.08921956f, -0.06375098f, -0.03490501f, -0.00957481f, 0.08834475f, -0.01609627f, -0.00277691f, 
    0.25224885f, -0.18626641f, -0.23195745f, -0.12165361f, 0.02863141f, 0.03523242f, 0.04043375f, 0.02807353f, 
    0.07280741f, -0.04915302f, -0.14561397f, -0.20119068f, -0.12689047f, 0.19895108f, -0.05758188f, -0.05660501f, 
    -0.19602092f, -0.06702483f, 0.07714906f, -0.03748789f, -0.00279999f, 0.04391589f, -0.02812874f, 0.01707586f, 
    0.09421551f, -0.05771722f, -0.03350912f, 0.07097075f, -0.01968422f, 0.05107651f, -0.09332006f, -0.13854802f, 
    -0.01956183f, -0.05057408f, 0.03319357f, 0.10206083f, -0.11737800f, -0.06641392f, 0.02516050f, 0.16925474f, 
    -0.18685229f, -0.11694144f, 0.02025073f, -0.07033876f, -0.09131750f, 0.11772215f, 0.18567158f, 0.20186216f, 
    0.18342923f, 0.10790322f, 0.08647840f, -0.16261303f, -0.17291994f, -0.05607735f, 0.02929830f, -0.03038952f, 
    0.01303028f, 0.14153196f, 0.08991862f, 0.34730351f, -0.00499555f, -0.25972697f, -0.20823242f, 0.00437049f, 
    0.15087423f, 0.11703347f, 0.20442048f, 0.08951619f, -0.01685831f, -0.05174656f, 0.00850903f, -0.04816106f, 
    -0.00477733f, 0.04950580f, 0.03000482f, 0.09339764f, -0.06743527f, -0.07482494f, -0.09557638f, -0.06283189f, 
    0.10139186f, -0.17738014f, -0.01158843f, -0.12067050f, 0.21715866f, 0.34963262f, 0.11251450f, -0.25132939f, 
    -0.03004991f, -0.07896741f, 0.05298080f, -0.02111866f, -0.07789166f, 0.01473120f, -0.10349164f, -0.10736004f, 
    0.12470956f, -0.04093933f, -0.15090701f, -0.04884987f, 0.23580077f, 0.17536706f, 0.12867852f, 0.13265407f, 
    0.08473243f, 0.05005605f, 0.05579257f, -0.03460113f, -0.03856085f, 0.02078181f, 0.00386594f, -0.12312241f, 
    -0.01752893f, 0.00075457f, -0.00028430f, 0.07808774f, -0.04245672f, 0.11918845f, 0.13277243f, 0.08648998f, 
    -0.18037887f, 0.03288466f, 0.22494552f, -0.09253632f, -0.17987882f, -0.19930437f, -0.12050784f, -0.15002917f, 
    -0.06319679f, -0.00359868f, -0.00651439f, -0.00829438f, -0.00104625f, 0.03519296f, -0.04291837f, 0.00568142f, 
    0.02954844f, 0.03068008f, 0.01705749f, 0.09800445f, -0.02101443f, 0.12171333f, 0.10765630f, 0.02321868f, 
    0.00720617f, 0.02127570f, 0.03327381f, 0.06175018f, -0.08771321f, 0.07305767f, 0.02869177f, -0.00900671f, 
    -0.00236994f, 0.09571572f, 0.05694287f, 0.08131439f, 0.00040921f, -0.13022691f, -0.15501136f, -0.00362161f, 
    0.13698724f, 0.13885097f, 0.11589143f, 0.00766125f, -0.19715251f, -0.08391093f, -0.02761099f, -0.00023045f, 
    -0.01171075f, 0.12849404f, -0.14905441f, 0.09191697f, 0.07173883f, 0.08311994f, -0.01711451f, -0.04509340f, 
    -0.08097696f, -0.11550499f, -0.03777082f, -0.29666170f, -0.15022896f, 0.04581947f, 0.18369040f, -0.10942475f, 
    0.01240201f, -0.08914851f, -0.12183352f, -0.06380051f, -0.02144428f, -0.06818896f, -0.15250996f, -0.06450959f, 
    0.23088102f, 0.15532792f, -0.11716354f, 0.14243613f, 0.00361934f, -0.02875215f, 0.12138076f, -0.03491032f, 
    0.15241592f, -0.03908497f, 0.14760932f, -0.09832299f, 0.02322860f, 0.08101070f, 0.04406316f, -0.14254707f, 
    -0.02345059f, -0.14406078f, -0.11566357f, -0.09332930f, -0.03667736f, -0.00595743f, 0.00909056f, 0.00073890f, 
    -0.06065906f, 0.25392029f, -0.12999897f, 0.15407385f, 0.12996845f, -0.00606494f, 0.07542337f, -0.24588871f, 
    -0.09131632f, 0.06769879f, -0.01469874f, 0.00005489f, 0.18121956f, -0.09200379f, -0.19085501f, -0.03403518f, 
    -0.05092671f, -0.03944753f, 0.00117993f, -0.06132438f, 0.14271981f, 0.14899796f, 0.07506960f, 0.04498724f, 
    0.22570905f, 0.21649492f, -0.09103614f, 0.18561527f, 0.16604707f, 0.04134982f, -0.03018097f, 0.10478975f, 
    -0.13893865f, -0.14586353f, 0.00595797f, -0.01441349f, 0.19172946f, 0.14039926f, 0.28854114f, -0.07811628f, 
    -0.00926752f, -0.09813146f, -0.18550037f, -0.09096131f, -0.01675605f, -0.16271646f, -0.18621346f, 0.10406531f, 
    0.03061997f, 0.03645409f, -0.05189332f, -0.00666744f, -0.02247646f, 0.04320837f, -0.04345386f, -0.00259156f, 
    0.04163902f, -0.02844635f, -0.00677190f, -0.05454514f, 0.02849361f, -0.00927870f, -0.03134400f, -0.03208343f, 
    0.01967872f, -0.05700348f, 0.02654752f, -0.04103012f, -0.04756630f, -0.02910483f, 0.02943027f, 0.02408097f, 
    0.03681811f, 0.00799235f, 0.02678293f, 0.00762736f, 0.03485033f, -0.03149408f, -0.03531705f, -0.04474866f, 
    0.01192531f, -0.05382751f, -0.02293541f, 0.02417188f, 0.00975759f, -0.04088507f, -0.02201190f, -0.02746845f, 
    0.03017545f, 0.03710929f, 0.03703874f, 0.00800795f, 0.00706830f, 0.04492286f, -0.03847563f, -0.03575621f, 
    -0.03500076f, 0.03482606f, -0.04009932f, 0.00682248f, 0.02348952f, -0.03431103f, 0.03820588f, 0.02601218f, 
    -0.00590294f, -0.02243733f, -0.04648905f, 0.01746153f, -0.03689032f, -0.03313618f, -0.01433112f, 0.00481414f, 
    -0.02311111f, 0.02777148f, -0.01354410f, -0.04015378f, -0.02434190f, -0.05234233f, -0.03205225f, 0.01783613f, 
    -0.03066770f, 0.03412240f, -0.03126430f, -0.00858524f, -0.00548760f, 0.05023782f, 0.01729250f, -0.00414180f, 
    0.02031928f, -0.04210701f, -0.00418844f, 0.00950564f, -0.00201360f, 0.00603295f, -0.01667567f, -0.02398721f, 
    -0.03365839f, -0.03331699f, 0.00534578f, -0.03218452f, -0.04832141f, 0.02832832f, 0.00712658f, 0.03173700f, 
    0.04398768f, -0.04307206f, -0.04908899f, 0.04408485f, -0.04258680f, -0.02837919f, 0.03879963f, -0.05091238f, 
    -0.02675415f, 0.00754557f, -0.00446228f, -0.03441584f, -0.02057694f, 0.02441398f, -0.04089151f, 0.03243538f, 
    -0.03204742f, 0.01914763f, 0.04478627f, 0.01189368f, -0.02602911f, -0.00030663f, -0.03729364f, -0.01353398f, 
    0.03794534f, 0.01039371f, 0.00386455f, -0.02141433f, -0.00066631f, 0.03830324f, -0.02213620f, 0.01679859f, 
    0.01097676f, -0.01391259f, 0.01694886f, -0.03071717f, 0.01725428f, 0.02051569f, -0.01376089f, 0.03850168f, 
    -0.05261225f, -0.04154880f, 0.03284666f, 0.02124101f, -0.01337177f, -0.01532662f, 0.01604716f, -0.02961534f, 
    0.00715634f, -0.01329440f, 0.03179755f, -0.03516259f, 0.01197760f, -0.01746645f, -0.05677254f, -0.03449313f, 
    -0.04328373f, 0.02549412f, -0.02859025f, -0.00349878f, 0.02891737f, -0.01563092f, 0.02414761f, -0.01963064f, 
    -0.01806870f, 0.04313175f, -0.00296756f, 0.00090558f, -0.02767342f, 0.03346266f, 0.00245702f, 0.01383295f, 
    0.03658986f, 0.00893489f, 0.03457354f, -0.05551912f, -0.01592509f, -0.04794767f, -0.03648616f, -0.05233069f, 
    -0.00353223f, 0.03897088f, -0.03575817f, -0.01250110f, -0.01223000f, -0.03233204f, -0.02810083f, -0.02355319f, 
    0.04380348f, -0.01727775f, -0.00178512f, -0.04344039f, 0.01323116f, -0.03803603f, 0.00075624f, 0.02352542f, 
    -0.02936401f, -0.04116160f, -0.02329048f, -0.03845563f, 0.02076565f, -0.03309327f, -0.05342052f, 0.02862032f, 
    0.01442475f, -0.02444461f, -0.04503424f, 0.04086455f, 0.02260768f, 0.00221135f, -0.04559255f, 0.02314562f, 
    -0.04670047f, 0.02157238f, -0.00397110f, -0.02991481f, -0.01793660f, -0.03253237f, -0.00469664f, -0.01909409f, 
    -0.00556270f, -0.03652800f, -0.04684159f, -0.03271943f, -0.03380886f, -0.02535283f, -0.01016378f, -0.01074899f, 
    0.03505273f, 0.03395606f, 0.05141977f, -0.01072265f, -0.01797828f, -0.04187348f, 0.04140106f, -0.05621049f, 
    0.03277705f, 0.04089293f, 0.01233376f, 0.00946408f, 0.02929284f, 0.00551594f, -0.03638411f, -0.03494878f, 
    0.01822215f, 0.01025819f, -0.00788247f, -0.02590372f, -0.02941129f, -0.04278043f, 0.00964080f, 0.03162636f, 
    -0.00408724f, 0.00175922f, -0.00987467f, -0.02143972f, 0.03986594f, -0.00213652f, 0.04053505f, -0.00378593f, 
    -0.02473234f, -0.04650596f, 0.03042726f, 0.04247206f, -0.01108937f, -0.03786971f, -0.01986501f, -0.01106878f, 
    0.03617020f, -0.05695621f, -0.04469388f, 0.00534986f, -0.03289149f, -0.04717415f, -0.03996013f, -0.01054718f, 
    -0.01181799f, 0.03682749f, 0.03504868f, 0.02255631f, -0.03756737f, 0.02722551f, -0.03481751f, -0.00961296f, 
    -0.01065954f, -0.04533719f, -0.02268073f, -0.02749684f, 0.02058601f, -0.05058778f, -0.04728728f, -0.03674129f, 
    -0.05533585f, -0.04132311f, -0.01640536f, 0.01859789f, 0.00973570f, 0.00391454f, -0.04122200f, 0.03320033f, 
    -0.02512022f, 0.02047825f, -0.05653988f, -0.03917658f, 0.03245076f, -0.05524454f, -0.04647471f, -0.00481503f, 
    0.03189863f, 0.02810765f, -0.00845259f, -0.04272673f, 0.03300530f, 0.02583142f, 0.01859090f, 0.01527005f, 
    -0.05531517f, 0.04489193f, -0.00619366f, 0.02696276f, -0.05061278f, 0.00480116f, -0.04508866f, 0.03187745f, 
    -0.00685629f, -0.03094480f, -0.01888571f, 0.00562036f, -0.05274548f, -0.05491950f, 0.01656265f, 0.00604782f, 
    -0.04589100f, 0.00776324f, -0.02778413f, -0.02449296f, 0.00610139f, 0.01798271f, -0.05428589f, -0.01588565f, 
    0.01444325f, 0.02848411f, -0.05497584f, 0.04074757f, -0.04306033f, -0.02395378f, -0.04287991f, 0.03172026f, 
    0.02553006f, 0.01493834f, -0.01423705f, 0.01750064f, -0.04008942f, 0.00608700f, 0.03417987f, -0.02846786f, 
    -0.01583678f, 0.01194510f, 0.01162166f, -0.00603785f, -0.03567947f, 0.00512321f, -0.03641537f, 0.02934603f, 
    -0.05160203f, 0.04238792f, 0.03743959f, 0.00315368f, 0.04125978f, 0.01462326f, -0.00437248f, 0.03445925f, 
    0.00925046f, 0.03546989f, 0.03598592f, -0.01816734f, -0.04158546f, -0.02003569f, 0.02410071f, 0.01018505f, 
    -0.03799002f, 0.04423876f, 0.01471504f, -0.03808324f, -0.04328390f, 0.02020307f, -0.05636892f, 0.03775930f, 
    0.13638298f, 0.06354058f, 0.07615782f, 0.02938957f, 0.00994844f, -0.01881200f, -0.01173165f, 0.01311824f, 
    -0.04422294f, -0.04821701f, -0.00815755f, -0.05306583f, -0.01434803f, -0.44039607f, -0.15281335f, -0.17447174f, 
    -0.05832117f, 0.06059482f, -0.08528569f, -0.00567692f, -0.01879736f, -0.04757800f, 0.01774547f, -0.10569799f, 
    0.09670022f, -0.06506000f, 0.11147986f, 0.01768935f, -0.14782773f, 0.02573388f, -0.04892995f, 0.02418797f, 
    -0.04863721f, 0.08067014f, 0.04235563f, 0.08210795f, 0.10297065f, 0.06097785f, 0.03792596f, 0.02720979f, 
    -0.01821461f, -0.03657094f, 0.00950474f, -0.04357576f, -0.04657473f, -0.02768881f, -0.05760024f, -0.04977893f, 
    0.16059582f, 0.08783510f, 0.08872902f, 0.11401657f, -0.00322557f, 0.06231532f, 0.01470227f, 0.01860670f, 
    0.09533039f, 0.16002403f, 0.04743558f, 0.04479782f, 0.25589725f, -0.25790697f, -0.15802909f, -0.07685501f, 
    -0.03467059f, 0.05932964f, 0.01882447f, 0.11548811f, 0.08229335f, 0.02922806f, 0.03707984f, -0.05439277f, 
    -0.29679364f, -0.11173714f, 0.01484672f, -0.22803998f, -0.03845885f, -0.08662102f, -0.14178263f, 0.00108467f, 
    -0.08310858f, 0.01459092f, -0.04173763f, 0.01525878f, -0.06166330f, 0.00347014f, -0.47211963f, -0.32692987f, 
    0.05733940f, 0.02444703f, 0.01415404f, 0.09608351f, -0.07578095f, 0.08878025f, 0.05964709f, -0.06826906f, 
    -0.29006633f, -0.13180378f, -0.39416811f, -0.16785669f, -0.05070417f, -0.03573402f, 0.08096416f, 0.06936372f, 
    0.00211584f, 0.01097703f, 0.07311404f, 0.00562668f, 0.35614601f, 0.17001429f, 0.08197363f, 0.18659785f, 
    -0.00505965f, 0.06326870f, -0.04041653f, 0.04229536f, -0.01050752f, 0.08798210f, -0.00183073f, -0.02794909f, 
    -0.23813874f, -0.66027218f, -0.33850843f, -0.43926936f, -0.09492561f, -0.11711118f, 0.02122709f, 0.10610386f, 
    0.08903471f, 0.04244015f, 0.07223897f, 0.08135623f, 0.11323921f, 0.00979127f, 0.19094969f, 0.01116396f, 
    -0.00852084f, -0.08459761f, 0.20353894f, 0.02613172f, 0.03176872f, 0.10818925f, 0.04714439f, 0.02061853f, 
    -0.07263850f, -0.17561547f, -0.05653441f, 0.00870198f, -0.06330791f, -0.09714361f, -0.09482942f, 0.00949765f, 
    -0.00485908f, -0.06008713f, -0.06811026f, 0.03724721f, 0.15032981f, 0.02930077f, 0.10747857f, 0.15189122f, 
    -0.05781811f, 0.03834332f, 0.00903774f, 0.01699351f, -0.02548955f, -0.03185295f, -0.12714878f, -0.09300894f, 
    -0.04050966f, 0.20745388f, -0.13414215f, 0.19002035f, -0.08599836f, -0.03174898f, -0.00732019f, 0.05305603f, 
    -0.03202082f, -0.11868969f, -0.04819710f, -0.18881375f, -0.03351410f, -0.22023490f, -0.04535373f, -0.11996729f, 
    0.10300077f, 0.04158641f, -0.01188635f, -0.12088600f, -0.09138539f, -0.07682621f, -0.03758371f, -0.02140729f, 
    0.17428485f, 0.21569477f, 0.00091569f, 0.16147019f, -0.00768662f, -0.02509928f, 0.06703340f, -0.02082458f, 
    0.09836937f, 0.08435135f, 0.07185267f, 0.03151624f, 0.01960596f, 0.17078897f, 0.19730230f, 0.16929917f, 
    0.05737786f, 0.08011905f, -0.03118877f, 0.03805010f, 0.05633809f, -0.00193195f, 0.09356782f, 0.01367627f, 
    -0.23819812f, -0.26454365f, -0.17079136f, -0.19315469f, 0.09471655f, -0.03290561f, -0.06512051f, -0.00756294f, 
    0.05699559f, 0.02461729f, 0.04853182f, 0.04473377f, 0.02941503f, -0.01092683f, 0.18631151f, -0.00583383f, 
    0.03915987f, 0.05328385f, -0.05409775f, -0.00898904f, -0.00563639f, -0.05076168f, -0.03043569f, -0.08113174f, 
    0.67925030f, 0.30729261f, 0.23194455f, 0.09944463f, -0.09242643f, -0.12414110f, -0.14191712f, 0.06140312f, 
    0.01881503f, 0.04828992f, 0.01950390f, -0.00793239f, 0.03018527f, 0.06941997f, 0.06215217f, 0.00307055f, 
    0.01610344f, 0.04182664f, -0.01089851f, 0.02343722f, 0.02821924f, -0.01013609f, -0.00307301f, -0.10172784f, 
    0.14692622f, 0.06640194f, -0.00386989f, 0.00281721f, 0.05768134f, -0.06441893f, -0.06584404f, -0.13430649f, 
    -0.04800300f, 0.05336064f, 0.03284119f, 0.03283956f, -0.13864595f, -0.07106980f, 0.09030593f, -0.13624719f, 
    0.11531134f, -0.16465870f, -0.09613095f, -0.01284708f, -0.04265519f, -0.02118574f, 0.01934846f, -0.02551258f, 
    0.03852608f, 0.08546178f, -0.06057362f, -0.05370182f, -0.04141533f, 0.07707828f, 0.05812509f, 0.19356535f, 
    0.03723450f, 0.08788452f, 0.17309928f, 0.24240476f, 0.05241327f, 0.04780458f, 0.06826364f, 0.03017394f, 
    -0.05696298f, -0.01095327f, 0.03866684f, 0.00655906f, 0.02247888f, 0.19655357f, 0.02515598f, 0.02685904f, 
    -0.12884967f, -0.00246851f, -0.07192577f, -0.05429509f, 0.04580102f, 0.07308293f, -0.01174962f, 0.02117892f, 
    -0.16919985f, -0.14196464f, 0.01509458f, 0.10717336f, 0.09655502f, 0.06030008f, 0.17237471f, 0.05134334f, 
    0.02271144f, 0.03694474f, 0.01153418f, -0.02560693f, 0.00333731f, 0.05923731f, 0.03666960f, -0.01583663f, 
    0.18914260f, 0.11798806f, 0.14770997f, 0.03533380f, -0.04389517f, 0.03424574f, -0.14135264f, 0.21043801f, 
    -0.05490063f, -0.06882590f, -0.06549033f, 0.03940960f, -0.07112882f, -0.19827192f, -0.20492049f, -0.13600466f, 
    -0.05734102f, 0.04195489f, -0.05251946f, -0.01059884f, -0.15740077f, -0.05589425f, -0.02426316f, 0.05879111f, 
    -0.08000288f, -0.06889758f, 0.07657234f, -0.32938874f, 0.15419921f, -0.16405758f, -0.02061317f, -0.05271320f, 
    -0.07125025f, -0.02259565f, -0.01732700f, 0.00039892f, -0.00279749f, -0.18831557f, 0.28454027f, 0.03440761f, 
    -0.01967028f, 0.03422934f, 0.06986866f, 0.04618699f, -0.00912629f, 0.16053261f, 0.10412447f, 0.10359719f, 
    -0.20395286f, -0.02899601f, 0.06051934f, -0.22736216f, 0.01777231f, -0.26938310f, -0.29684862f, -0.11613413f, 
    -0.15393381f, 0.00273151f, -0.21539263f, -0.03697056f, 0.78832698f, -0.15718955f, -0.29519829f, -0.00145580f, 
    0.18209238f, -0.05997828f, 0.00483807f, -0.03172903f, 0.00620652f, 0.03002177f, -0.12719503f, 0.04157241f, 
    -0.37693533f, 0.26111037f, 0.28458941f, 0.17441179f, 0.10780165f, 0.02632460f, -0.07842196f, 0.03810772f, 
    -0.00800611f, -0.07375903f, 0.02987627f, 0.08227874f, 0.04859490f, -0.01192421f, -0.15628327f, -0.13034327f, 
    0.02772656f, -0.12249603f, 0.05744551f, -0.02902325f, -0.05893886f, -0.15700628f, -0.00132301f, -0.07074492f, 
    -0.10138833f, 0.00082445f, -0.15365459f, -0.07055304f, -0.14554149f, -0.07496407f, 0.03471113f, -0.02869878f, 
    0.07220744f, 0.08614794f, 0.10104807f, 0.09211332f, -0.22415136f, 0.11844236f, 0.37062779f, 0.21982183f, 
    -0.05750483f, 0.01216112f, 0.24183623f, 0.05219129f, -0.05640391f, 0.05915743f, 0.10799547f, 0.06755406f, 
    -0.05488133f, -0.04033294f, 0.01276270f, 0.25497749f, -0.01636018f, 0.05245902f, 0.06335451f, 0.07372974f, 
    0.07832623f, 0.00254113f, 0.15401299f, 0.07293916f, 0.46887147f, -0.09895793f, -0.12121444f, 0.07344764f, 
    0.12142919f, 0.01963913f, 0.04918053f, -0.05997790f, 0.08253648f, -0.13482092f, 0.05255125f, 0.04463182f, 
    -0.29948857f, -0.11731306f, 0.28896976f, 0.25454602f, -0.14616056f, 0.04545018f, 0.15206632f, -0.00586113f, 
    -0.08611315f, -0.11293872f, -0.09604142f, 0.17881344f, -0.22314166f, 0.08195461f, 0.11929774f, -0.14662224f, 
    -0.22347645f, -0.19656923f, -0.27530727f, -0.07813767f, -0.07928851f, 0.12401816f, -0.10031568f, 0.07831957f, 
    0.10675414f, -0.08641555f, 0.17001855f, 0.15207526f, 0.07457375f, -0.05875164f, 0.22293133f, -0.06740844f, 
    0.04713605f, 0.07743188f, -0.10191960f, 0.08402889f, 0.08517855f, 0.67813420f, 0.00751663f, 0.15471496f, 
    -0.08651007f, -0.24198049f, 0.04336781f, 0.09223019f, 0.06893152f, 0.11914574f, -0.13091083f, 0.05033841f, 
    -0.35891756f, -0.17668544f, 0.10625349f, 0.24103020f, -0.12198795f, 0.06842393f, 0.05947060f, 0.10511042f, 
    -0.04230872f, 0.08657160f, -0.04441030f, -0.06802280f, 0.33855528f, 0.03046311f, 0.05060237f, 0.03707374f, 
    0.01222079f, 0.05589378f, 0.08127042f, 0.01832948f, -0.02719118f, -0.06003974f, -0.01385955f, 0.01771177f, 
    0.29728726f, -0.06501223f, -0.05057439f, -0.08331499f, 0.15696129f, -0.02373797f, -0.01867484f, -0.03067530f, 
    -0.14429882f, 0.01385091f, 0.12937222f, 0.00285778f, -0.07433712f, -0.14205353f, 0.06438676f, 0.21838681f, 
    -0.01644304f, -0.20210625f, 0.19028088f, -0.07204068f, -0.00995869f, 0.09107640f, -0.04040063f, 0.06927752f, 
    -0.11936487f, -0.02597734f, 0.08573979f, -0.07979945f, -0.01890117f, -0.12451188f, -0.12540038f, -0.07206221f, 
    0.07623339f, 0.04876899f, 0.05092379f, -0.08011111f, 0.22121403f, -0.02535174f, -0.14334738f, -0.41927794f, 
    0.02304814f, -0.11651892f, -0.07204051f, -0.01274254f, -0.19052489f, -0.05406775f, -0.20999755f, 0.14994408f, 
    0.06717678f, -0.06035708f, -0.19504221f, 0.24071369f, 0.01851862f, 0.11468329f, -0.02976795f, -0.04162674f, 
    -0.03944946f, 0.12009539f, 0.10432717f, 0.04664671f, -0.19997227f, -0.06665947f, -0.00012089f, 0.13031313f, 
    0.16581988f, 0.00581030f, -0.07016529f, 0.13227922f, -0.04985121f, 0.03754454f, 0.06853198f, 0.07524435f, 
    0.01491349f, 0.15521409f, 0.42847389f, 0.06151745f, -0.16958268f, -0.04882241f, -0.11491589f, 0.03773171f, 
    0.08760957f, -0.01870071f, 0.10044339f, 0.01792019f, 0.15636873f, -0.01383667f, -0.23033035f, -0.23626111f, 
    0.06431357f, 0.09711269f, -0.10468507f, 0.13946795f, 0.05351049f, 0.00708315f, -0.00622168f, -0.23246206f, 
    0.03891429f, 0.00044002f, 0.11895007f, -0.02290964f, -0.19221446f, -0.12222503f, -0.00134620f, -0.06502599f, 
    0.03071717f, -0.00922042f, -0.30515835f, -0.05953682f, -0.07712160f, -0.26243451f, 0.02948307f, 0.23583837f, 
    -0.02653737f, 0.06051366f, 0.20099914f, 0.20656435f, 0.02301753f, 0.15595967f, 0.02350423f, 0.05827826f, 
    -0.17086215f, 0.18588313f, -0.09308790f, 0.01574408f, 0.01243026f, 0.12785393f, -0.06246088f, 0.03942101f, 
    0.07743367f, 0.20278282f, -0.08621113f, 0.15782954f, -0.09291764f, -0.14238971f, 0.12996587f, -0.08658836f, 
    -0.01115494f, 0.06597104f, -0.03523709f, -0.18883967f, 0.03953066f, 0.17309248f, -0.11415323f, -0.01518456f, 
    0.21822135f, 0.05031994f, -0.06867808f, -0.06209583f, 0.14229877f, -0.01130818f, 0.10148841f, 0.06167953f, 
    0.08470747f, 0.09310224f, 0.00775236f, -0.09591758f, -0.03279142f, -0.10393473f, -0.06971982f, -0.13064817f, 
    -0.20420572f, -0.11980198f, -0.02478709f, -0.11190180f, 0.02545875f, -0.01643868f, -0.08222334f, -0.02061986f, 
    0.26125750f, 0.13881980f, 0.21442221f, 0.37245736f, 0.02460775f, -0.03602131f, 0.03524073f, 0.09060516f, 
    -0.16264792f, 0.09343011f, 0.01150681f, -0.03460269f, -0.18651946f, 0.05677241f, -0.08603097f, -0.11054993f, 
    0.09590457f, 0.07770996f, 0.17225212f, -0.40768492f, -0.13925281f, 0.03034756f, 0.02301775f, 0.00730427f, 
    -0.27053979f, -0.14095530f, -0.05810947f, 0.02168060f, -0.05042471f, -0.00654882f, -0.01336891f, 0.21761017f, 
    -0.00702873f, -0.11550108f, 0.04035976f, 0.04496323f, 0.45514938f, -0.13823490f, -0.04591136f, -0.22904769f, 
    0.05455377f, 0.02652949f, 0.11070178f, -0.03526445f, 0.07405608f, 0.07891962f, -0.00336083f, -0.02666484f, 
    0.02286943f, 0.04389657f, 0.04396261f, 0.01544867f, 0.01135246f, 0.03118693f, 0.01088470f, -0.01421336f, 
    0.03145149f, -0.04465642f, 0.04102121f, -0.02342643f, -0.00164173f, -0.03459667f, -0.01379957f, 0.00901838f, 
    -0.00460850f, -0.04261245f, -0.02878346f, -0.01883228f, -0.00694499f, -0.03927287f, -0.05948887f, -0.05600635f, 
    0.01723255f, 0.00153314f, -0.03069737f, 0.03896733f, 0.01127609f, -0.05768133f, -0.01074802f, -0.01715286f, 
    -0.05338937f, -0.00272992f, -0.03496359f, 0.00719686f, 0.01914839f, -0.02911364f, 0.00979683f, -0.01551533f, 
    -0.01842359f, -0.03017707f, 0.03876944f, -0.03940220f, 0.04206167f, -0.04102020f, -0.03716201f, 0.00168507f, 
    0.03462057f, -0.05147927f, 0.01813442f, -0.04438202f, 0.03752304f, 0.03498488f, 0.02719007f, 0.04665374f, 
    0.00437693f, -0.02860294f, -0.00114280f, -0.01605361f, 0.01517578f, -0.05013770f, 0.00162697f, 0.01669628f, 
    -0.02642716f, 0.04598440f, 0.00193619f, 0.02841140f, 0.03935754f, -0.01438076f, -0.02428710f, 0.04583622f, 
    0.03791452f, -0.03176983f, -0.02211960f, 0.02496103f, -0.00906572f, -0.01343083f, -0.01795202f, -0.02652046f, 
    -0.01507626f, -0.05591215f, -0.05228385f, 0.00580206f, 0.03518670f, -0.01763032f, 0.03626692f, -0.01499359f, 
    -0.05091225f, 0.02250127f, 0.01094497f, 0.00597173f, -0.00958039f, -0.02228191f, 0.02886339f, -0.03588704f, 
    -0.00339860f, 0.02818295f, -0.02497695f, 0.00501521f, -0.04438076f, 0.02920065f, 0.00621266f, 0.04176622f, 
    0.02772954f, 0.03257342f, 0.04236306f, -0.02482440f, 0.00493446f, 0.02626832f, -0.01580347f, -0.04200796f, 
    -0.02001617f, -0.01213919f, 0.01610438f, -0.04212485f, -0.04149054f, 0.03172869f, -0.01939609f, -0.02601619f, 
    0.02167641f, -0.00015613f, -0.03122326f, 0.01499922f, 0.01064908f, -0.04793156f, -0.05703391f, -0.02873530f, 
    -0.03331371f, 0.01869459f, -0.04645547f, -0.04809843f, 0.01616297f, -0.04344342f, 0.04546682f, 0.00497505f, 
    -0.05772208f, 0.02860272f, -0.01007065f, -0.02526410f, 0.00397768f, -0.03071097f, -0.04128300f, -0.04256887f, 
    -0.01433956f, -0.02341100f, -0.03057735f, -0.04608114f, -0.02883088f, 0.03096033f, -0.03759146f, 0.03418902f, 
    0.02811652f, 0.03875881f, -0.02384557f, 0.03568195f, -0.03683563f, -0.00156067f, 0.02386707f, -0.03438248f, 
    0.03071432f, -0.06283727f, 0.04192261f, 0.04320313f, -0.04700474f, -0.01809285f, 0.01165179f, -0.04602339f, 
    -0.03881491f, -0.01071264f, 0.01434378f, -0.01585989f, -0.05396805f, -0.05101343f, -0.04935913f, 0.04393557f, 
    -0.04648875f, -0.03457770f, -0.00596470f, 0.00725335f, -0.02568027f, -0.02245177f, -0.01789672f, 0.04468964f, 
    0.00550712f, -0.06075011f, -0.00665178f, -0.02155939f, 0.03035846f, -0.02977016f, -0.05496989f, 0.03533969f, 
    0.02766067f, -0.05004940f, -0.00552546f, 0.01066887f, 0.00824847f, 0.00788756f, -0.00843562f, 0.01494574f, 
    0.01647772f, -0.00107623f, -0.01994517f, 0.02771967f, -0.00836735f, 0.03145943f, 0.03481542f, -0.04183703f, 
    -0.05318123f, -0.01765786f, 0.01630227f, -0.02994156f, -0.03813936f, -0.05373402f, -0.03621870f, -0.04521626f, 
    0.03797292f, -0.03763544f, -0.01372736f, -0.04365556f, -0.02438423f, 0.01139295f, 0.00379745f, 0.03411074f, 
    -0.03822639f, 0.00469423f, 0.02974656f, -0.03597308f, 0.00195103f, -0.00055656f, -0.00194883f, 0.01845411f, 
    -0.00870745f, -0.03127657f, -0.02476981f, -0.02749863f, 0.01720394f, -0.03440800f, -0.04446854f, -0.04029643f, 
    0.03840337f, -0.02354374f, -0.01482643f, -0.05409142f, 0.02283194f, -0.05536854f, -0.02239046f, -0.03030220f, 
    0.00549153f, 0.03020562f, -0.06075164f, -0.00355097f, 0.00914861f, -0.02956801f, 0.00420994f, -0.01926563f, 
    -0.01377512f, 0.01830305f, 0.00036576f, 0.01318644f, -0.00680342f, 0.00911496f, -0.04205561f, 0.00740849f, 
    0.02653331f, 0.01954819f, 0.01613905f, 0.00978867f, -0.03948543f, -0.03484117f, 0.00884698f, -0.00064099f, 
    -0.04298887f, 0.04249787f, 0.02660498f, 0.01514485f, -0.02390951f, -0.01313243f, -0.00214447f, 0.02559658f, 
    0.01135205f, -0.04490228f, 0.03981489f, -0.06182664f, -0.04362186f, -0.04137526f, 0.00720176f, 0.01649366f, 
    0.03006323f, 0.03583222f, -0.01352700f, 0.04367217f, -0.03441687f, -0.05682094f, 0.00468734f, 0.03540118f, 
    0.02432545f, -0.02522958f, -0.00416317f, 0.01590007f, -0.05921277f, -0.03822934f, 0.01291792f, -0.01384365f, 
    -0.04637863f, 0.00833304f, -0.02407214f, -0.05383252f, -0.03394482f, 0.03906163f, -0.03692934f, 0.01502313f, 
    -0.03274448f, -0.00815855f, -0.05163889f, 0.03164630f, -0.03206616f, -0.01653677f, 0.02897095f, -0.01606367f, 
    -0.04540134f, -0.05253365f, 0.02932082f, -0.00619386f, -0.01953440f, 0.03129470f, 0.01143254f, -0.00759655f, 
    -0.06148512f, 0.00347041f, 0.03517934f, 0.01476208f, 0.01802767f, -0.05333834f, 0.01351465f, -0.05462191f, 
    0.00638624f, 0.00028734f, 0.04269605f, 0.04829695f, -0.01659442f, -0.06063667f, 0.00794102f, 0.00900945f, 
    -0.02731380f, -0.01291661f, -0.03553929f, -0.01762127f, -0.00013312f, -0.04589948f, 0.00282628f, -0.01850878f, 
    -0.05363845f, -0.03714772f, -0.00134475f, -0.04321036f, 0.03081173f, 0.03132481f, 0.03826275f, 0.01374902f, 
    -0.04986494f, -0.01513330f, -0.02901527f, -0.00826519f, -0.05110062f, -0.00990093f, -0.03774848f, 0.00779838f, 
    -0.00927089f, 0.00867783f, 0.03565316f, -0.05320049f, 0.00457271f, 0.02586361f, -0.00178992f, -0.00739296f, 
    -0.01246809f, -0.01264848f, -0.01948503f, -0.00816573f, -0.02501463f, -0.04849232f, -0.05535357f, 0.03811871f, 
    -0.00743667f, -0.03039172f, -0.03732050f, 0.03397604f, 0.02215457f, 0.01136822f, -0.03318455f, 0.00828270f, 
    -0.01704987f, -0.01586392f, -0.05733661f, 0.00998264f, -0.01097234f, -0.03694569f, 0.02364769f, -0.01214172f, 
    -0.01560046f, -0.02788516f, -0.00846568f, 0.02344562f, -0.00672109f, 0.00738664f, -0.03984048f, -0.05150726f, 
    -0.04820343f, -0.02336055f, -0.03712381f, 0.00384198f, 0.02028700f, -0.04368709f, -0.03111979f, -0.01094953f, 
    -0.04000464f, 0.01979666f, 0.03301898f, 0.01102055f, 0.01926587f, 0.04283508f, 0.02920306f, -0.03910511f, 
    -0.04746439f, -0.03439895f, 0.04053093f, -0.03376464f, -0.05783403f, -0.00368415f, -0.04612514f, -0.05505190f, 
    -0.01747902f, 0.00908350f, 0.00945147f, 0.01251541f, -0.03801552f, 0.02119791f, -0.02664677f, -0.04384303f, 
    -0.02176296f, -0.04841955f, 0.01239103f, -0.05616020f, -0.03835846f, -0.02088755f, -0.02443371f, -0.05214534f, 
    -0.00768008f, -0.05505222f, -0.01362993f, -0.01328130f, -0.05863950f, -0.04739367f, -0.04001107f, -0.03363104f, 
    -0.01306582f, 0.00946877f, -0.02443430f, 0.02502917f, 0.00313179f, 0.01375984f, -0.00137823f, -0.02429587f, 
    0.02071195f, -0.01652117f, -0.04137110f, 0.01738443f, 0.03060842f, 0.04103660f, 0.04281606f, -0.01684314f, 
    0.02621246f, -0.05576101f, -0.02733026f, -0.01056418f, 0.03317982f, 0.04050010f, -0.05351324f, 0.00854826f, 
    -0.01829158f, -0.04912553f, 0.03597189f, -0.01262730f, -0.00820009f, -0.05322411f, 0.00352285f, -0.05076601f, 
    0.03686079f, -0.00027279f, -0.04671758f, -0.02454716f, 0.01729666f, 0.01344871f, 0.01252011f, 0.00656070f, 
    -0.02487219f, -0.03435861f, 0.00408795f, 0.04092085f, 0.02312189f, -0.01154136f, 0.02594043f, -0.03447756f, 
    -0.02172175f, 0.02967785f, -0.00544627f, 0.00861563f, 0.04434968f, 0.00735016f, 0.04773656f, -0.04718337f, 
    -0.01752436f, 0.03908462f, 0.02301932f, 0.00435387f, -0.04702435f, -0.00256554f, -0.04171094f, -0.04258556f, 
    0.01202178f, 0.04501135f, -0.02045877f, 0.04149211f, 0.01052287f, 0.01643012f, -0.01691666f, -0.01315772f, 
    -0.02167583f, 0.01418461f, 0.00823259f, -0.04285945f, -0.00155107f, -0.05544617f, 0.04222498f, 0.00731142f, 
    0.01444788f, -0.04030915f, 0.00276569f, -0.02313313f, -0.03212938f, 0.03083530f, -0.00094645f, 0.02391357f, 
    0.01194100f, -0.04474841f, -0.01716361f, 0.00649737f, -0.04937156f, -0.01957357f, 0.02222314f, -0.00782392f, 
    -0.03347306f, -0.00369499f, 0.02988711f, -0.01204226f, -0.01781054f, -0.03243238f, 0.03287457f, -0.04049984f, 
    -0.04457740f, 0.04600814f, 0.04318899f, 0.03271611f, 0.01616134f, -0.05224245f, 0.01910280f, -0.01442283f, 
    -0.01945086f, -0.02906125f, -0.00636049f, 0.00480830f, -0.02804509f, -0.04035746f, -0.01416839f, -0.04632444f, 
    0.00839669f, -0.03518068f, 0.02253117f, -0.03881891f, -0.01644504f, -0.01562797f, 0.01519457f, 0.01059828f, 
    0.02103204f, 0.01502353f, -0.01522642f, -0.02824430f, 0.00762224f, 0.02736715f, -0.01564085f, -0.00082316f, 
    -0.01836799f, -0.05665778f, -0.04853644f, 0.01666026f, 0.02699381f, 0.00213988f, -0.04521852f, -0.05082083f, 
    0.01530873f, 0.02704204f, 0.00365434f, -0.04979884f, 0.03633713f, 0.01047581f, -0.02226109f, 0.03097697f, 
    0.00181064f, -0.04437236f, -0.02278185f, 0.03051968f, 0.00833013f, 0.03963277f, -0.00437052f, -0.03936734f, 
    -0.01672373f, -0.03953274f, -0.02281312f, -0.03614686f, 0.01382837f, 0.00639483f, -0.00643171f, 0.00868519f, 
    0.02601619f, 0.04239030f, -0.02601593f, -0.03800287f, -0.02678975f, 0.03697214f, 0.04341773f, -0.05380032f, 
    0.00387823f, 0.04032540f, -0.04472400f, 0.02348786f, -0.00166400f, -0.04092067f, -0.01133886f, 0.00864339f, 
    -0.00448454f, 0.00077334f, -0.03340754f, 0.02159423f, -0.03373369f, 0.00550974f, 0.03679227f, -0.05957446f, 
    0.03304604f, -0.00335682f, -0.01507671f, 0.01850001f, -0.05157131f, -0.01011996f, 0.00751338f, 0.00157371f, 
    -0.00321638f, -0.02399723f, -0.03080597f, -0.02142613f, 0.01659169f, 0.00209025f, 0.00762758f, -0.00586622f, 
    0.03326219f, -0.01796864f, 0.02526040f, -0.01376236f, -0.00120589f, 0.00801028f, -0.04797106f, 0.00712006f, 
    -0.01376739f, 0.03418138f, -0.03028798f, -0.05552908f, 0.00240924f, -0.04269548f, -0.01382386f, 0.03716003f, 
    0.01097440f, -0.01662655f, -0.00330043f, 0.01912544f, -0.03809714f, 0.03415404f, -0.01474152f, -0.02267666f, 
    -0.01425750f, 0.01623987f, -0.01309594f, 0.01593988f, -0.00666079f, 0.03883274f, 0.02560101f, 0.02628872f, 
    0.01869312f, -0.04306044f, -0.03516686f, -0.00880864f, -0.04006891f, -0.05096978f, -0.04733805f, -0.04066833f, 
    -0.01259066f, 0.00106253f, -0.04683233f, 0.00563438f, 0.04231025f, -0.03373896f, -0.05417312f, -0.02669991f, 
    0.04245294f, -0.05831070f, -0.03311322f, 0.01622361f, 0.03238286f, -0.03592706f, 0.04031417f, -0.00185484f, 
    0.00864480f, -0.05007116f, -0.04762163f, 0.02158768f, 0.01735054f, -0.03040998f, -0.00885066f, 0.02018620f, 
    -0.00044646f, -0.02615095f, 0.02039696f, -0.00409894f, -0.03654702f, 0.03459065f, 0.00504854f, -0.02157330f, 
    -0.03080443f, -0.01012591f, -0.04452150f, -0.05495072f, -0.01394233f, -0.00162740f, -0.04730645f, -0.02504321f, 
    0.02015023f, -0.05474911f, -0.02689712f, 0.03674774f, 0.00607020f, -0.05638850f, -0.02592887f, -0.00287983f, 
    0.03617604f, 0.01102397f, -0.02507325f, -0.01157819f, -0.04114222f, -0.04013623f, -0.01932148f, -0.01507853f, 
    0.00450415f, 0.03477510f, -0.00512934f, -0.03060680f, -0.01188671f, 0.00827900f, -0.02602286f, 0.03746841f, 
    -0.31103855f, -0.22388048f, -0.08021384f, -0.02662353f, -0.02263466f, 0.08338504f, -0.19401005f, 0.06794121f, 
    0.16526973f, 0.08252972f, 0.04694931f, -0.06084633f, -0.18963581f, 0.04178431f, -0.01810556f, -0.00531320f, 
    -0.03205493f, -0.03957221f, -0.03551042f, -0.10261112f, 0.11503737f, 0.00033010f, 0.03174046f, 0.19612060f, 
    -0.11993434f, 0.19997242f, -0.12197839f, 0.18957984f, 0.11283883f, -0.07606783f, -0.10377418f, -0.12523192f, 
    0.11014573f, 0.09616679f, -0.23260209f, 0.06998846f, -0.20374186f, -0.12123261f, -0.30694392f, -0.03476025f, 
    0.12357804f, -0.11663590f, -0.02805973f, 0.02712439f, 0.06735383f, -0.04615370f, -0.15465151f, 0.02743592f, 
    -0.19953953f, -0.19670095f, -0.01969877f, 0.40882680f, -0.02194267f, -0.02874637f, -0.14990139f, -0.07487952f, 
    0.06957141f, -0.00617311f, 0.05091188f, 0.07779837f, 0.20598498f, -0.03805330f, -0.22892509f, -0.18304347f, 
    -0.07306989f, -0.11542421f, -0.02415477f, -0.06749026f, 0.12517698f, -0.02992922f, -0.00383455f, 0.10773115f, 
    0.17174220f, 0.19551839f, 0.12688701f, -0.00056129f, 0.23254129f, 0.15773438f, -0.04008378f, 0.08293609f, 
    -0.08482102f, -0.06843217f, 0.07358966f, -0.00759760f, -0.13312139f, 0.04378255f, -0.01525255f, 0.03673169f, 
    0.13479303f, -0.09006187f, 0.03863188f, 0.04179160f, 0.23818545f, 0.00109665f, 0.13938287f, -0.04452422f, 
    0.34074542f, -0.19530021f, 0.33983532f, -0.30732784f, 0.01022228f, 0.07228038f, -0.28715831f, -0.03646789f, 
    0.05465547f, -0.00296814f, 0.03920514f, -0.03296946f, -0.39031550f, -0.25469789f, -0.13508534f, 0.11563546f, 
    -0.04454769f, -0.01561170f, -0.06878799f, 0.10566331f, 0.08634674f, 0.02783170f, 0.06973457f, 0.03884856f, 
    0.21300091f, 0.15030429f, -0.02157518f, -0.01758401f, 0.06854828f, -0.03538603f, 0.06470856f, -0.06391909f, 
    0.05864721f, -0.00118729f, 0.07163016f, 0.06307924f, -0.10568703f, -0.15142067f, -0.22917008f, -0.07469659f, 
    0.19396627f, -0.26247695f, -0.07590365f, 0.28281218f, 0.04629667f, 0.00048877f, -0.10166628f, 0.02667685f, 
    0.24297211f, 0.26565230f, 0.10650583f, -0.14255853f, 0.12770455f, 0.15745434f, 0.15344043f, 0.19374670f, 
    0.02210437f, 0.02535071f, 0.05167388f, 0.01624691f, -0.13604823f, -0.01823735f, -0.09703628f, 0.12285245f, 
    0.10577844f, -0.16436335f, 0.05267614f, -0.15408292f, 0.07502124f, -0.07075166f, -0.18479761f, 0.03497638f, 
    -0.06702266f, -0.05097001f, 0.24455707f, -0.10937054f, 0.02760805f, -0.08887376f, 0.03709370f, -0.11980037f, 
    -0.09636598f, -0.18413538f, -0.05166670f, -0.19021453f, 0.11689468f, -0.01545503f, -0.04436788f, -0.08181406f, 
    0.08224991f, -0.00889913f, 0.16960225f, 0.01130135f, -0.01940947f, 0.13222750f, 0.02230855f, 0.22795741f, 
    0.01751678f, -0.21125017f, -0.10611523f, 0.03969341f, -0.02582004f, -0.01253199f, -0.12298008f, -0.14979932f, 
    0.19825850f, 0.13816655f, 0.09017517f, -0.00113326f, -0.19454816f, 0.18385333f, 0.04449636f, 0.37590414f, 
    0.13765423f, -0.04882480f, -0.06156322f, 0.12395394f, 0.08704485f, 0.05084135f, -0.00490223f, 0.06217171f, 
    0.11353941f, 0.17719468f, 0.25001174f, 0.06387781f, 0.16082956f, 0.25086308f, 0.05065990f, 0.08102027f, 
    0.05286576f, -0.04757608f, -0.04845747f, -0.08004306f, -0.09743211f, 0.06164483f, -0.20526588f, 0.02619618f, 
    0.03975997f, -0.01959053f, -0.03047042f, 0.04877096f, 0.13552670f, -0.26575482f, -0.04402031f, -0.04084672f, 
    -0.37087432f, 0.09129715f, 0.12253445f, 0.09559423f, 0.09831921f, -0.16614732f, -0.17093551f, 0.21344861f, 
    -0.09303446f, -0.13343672f, -0.00679395f, -0.21263717f, -0.02024564f, -0.07344664f, -0.21379673f, 0.02099275f, 
    0.01391622f, 0.04010650f, -0.07774518f, 0.05095707f, 0.10844464f, 0.09830531f, -0.03969008f, -0.10341163f, 
    0.00212901f, -0.04778083f, -0.24662049f, 0.02976556f, 0.19447252f, -0.03466783f, -0.09459677f, 0.28127754f, 
    0.06735396f, 0.04649263f, -0.02397828f, -0.04441287f, 0.22968563f, 0.23047361f, 0.01493259f, -0.13877238f, 
    0.10620346f, 0.05850142f, 0.17724244f, 0.11853339f, 0.06829467f, -0.00511200f, 0.02632835f, -0.03779966f, 
    0.34924749f, -0.14152086f, 0.27704057f, -0.25918117f, 0.04879604f, -0.08255685f, -0.03030202f, 0.05545121f, 
    -0.12877974f, 0.09121101f, 0.08305549f, 0.09412137f, -0.11804482f, -0.08819657f, 0.25022408f, -0.01634687f, 
    0.01509884f, 0.08124345f, -0.17083155f, -0.00166884f, 0.10228784f, 0.04876317f, 0.08298317f, 0.09447512f, 
    0.09907991f, -0.03340461f, -0.04933839f, 0.23996855f, -0.02127077f, -0.02473710f, 0.05568394f, 0.08092570f, 
    0.13899438f, 0.05645110f, -0.05512897f, 0.23989534f, -0.47786987f, -0.23849627f, 0.20101193f, 0.46552426f, 
    0.04170457f, -0.02516301f, -0.13837110f, -0.19327843f, 0.09400258f, -0.05020800f, -0.04474214f, 0.06234320f, 
    0.00263166f, -0.15594098f, 0.13100095f, -0.12182541f, -0.05822476f, -0.04417323f, 0.31052360f, -0.01896382f, 
    0.04585038f, -0.07910533f, -0.02744299f, -0.13135333f, 0.33784229f, -0.25936037f, 0.21019785f, -0.03190709f, 
    -0.03903403f, -0.16734207f, 0.00302909f, -0.34869790f, 0.01512696f, 0.06103969f, -0.02347323f, 0.11524801f, 
    0.15342481f, 0.39183694f, 0.03961845f, -0.14901255f, 0.12510200f, 0.06266966f, 0.02328702f, 0.23316658f, 
    -0.02417321f, 0.05224267f, 0.10809992f, 0.10268863f, -0.57444209f, 0.02442076f, 0.07864585f, 0.14154051f, 
    0.05393581f, -0.11152139f, 0.01558287f, -0.22530860f, 0.11224979f, -0.00896920f, 0.05841644f, 0.09455904f, 
    -0.00815330f, -0.00223568f, -0.06839927f, 0.02304362f, -0.02089326f, 0.05855703f, 0.03474140f, 0.03502731f, 
    -0.02641610f, -0.05356386f, -0.04340189f, 0.04120613f, -0.52256775f, 0.08260401f, 0.02978111f, 0.15464868f, 
    -0.03939294f, -0.04154433f, -0.03034659f, -0.05279487f, -0.12723018f, 0.00158517f, 0.13788699f, 0.13533923f, 
    0.16737559f, -0.12598570f, -0.11040116f, -0.40938023f, -0.02138034f, 0.06131613f, -0.04321158f, 0.12453492f, 
    0.05421114f, -0.05428127f, -0.17962877f, 0.21061055f, 0.10429509f, -0.07474141f, 0.00662434f, -0.04050461f, 
    0.19529496f, -0.02334912f, -0.00941318f, 0.02370612f, -0.03203024f, -0.06358271f, 0.01201089f, -0.01842164f, 
    -0.01064240f, 0.07302868f, 0.01896308f, 0.05912611f, -0.05404475f, -0.05259919f, -0.02460131f, -0.04193767f, 
    0.03521501f, -0.07246429f, 0.18408537f, 0.01649847f, 0.41263559f, 0.28413454f, 0.01779517f, -0.12592831f, 
    0.07027109f, -0.06178344f, -0.05616321f, 0.01996705f, 0.04058816f, 0.36877897f, 0.19251460f, -0.04713410f, 
    -0.04571747f, -0.02862944f, 0.11445145f, -0.08849288f, 0.05932459f, -0.08686607f, 0.10604861f, 0.08267728f, 
    -0.07586199f, 0.02482368f, 0.01113090f, -0.08415817f, -0.43162525f, -0.03334149f, 0.08491912f, 0.19397721f, 
    0.04595291f, 0.11647262f, -0.07627303f, 0.05446638f, -0.08392290f, 0.03599535f, 0.11670519f, 0.04155263f, 
    0.24806543f, -0.19817956f, 0.17953929f, -0.18865810f, -0.05158925f, 0.13597469f, 0.03477274f, -0.04293903f, 
    -0.05327024f, -0.03711198f, 0.00150935f, -0.03978049f, 0.19871964f, -0.12614430f, 0.02808728f, -0.13153383f, 
    -0.10269646f, 0.01072106f, -0.03528815f, -0.01872387f, -0.07169782f, 0.03234753f, 0.09870277f, -0.04366301f, 
    -0.17562293f, 0.17047049f, 0.12415867f, 0.01751825f, -0.09730301f, -0.05915677f, -0.08229739f, -0.17820659f, 
    -0.02951549f, 0.02450703f, 0.03532578f, 0.06450507f, -0.09738120f, -0.00806274f, -0.14398552f, -0.16503131f, 
    0.07789514f, -0.19554342f, 0.13775952f, 0.06403043f, 0.05022092f, -0.05747736f, -0.08864586f, 0.14082430f, 
    -0.11402213f, -0.07443442f, -0.01068790f, -0.11467288f, -0.07803239f, -0.02924211f, 0.06180751f, -0.16705239f, 
    0.01043572f, -0.02322257f, -0.04219739f, -0.00624954f, -0.02217476f, -0.13592395f, 0.04215785f, 0.07315715f, 
    -0.04606240f, -0.15660226f, -0.00959665f, 0.04868886f, 0.02206320f, 0.00550138f, 0.12884194f, 0.02247221f, 
    -0.03691776f, -0.19052863f, 0.15945655f, 0.13999052f, -0.02568487f, -0.11608751f, -0.04904969f, 0.09074141f, 
    -0.07763203f, 0.19399606f, -0.11525008f, -0.07943358f, -0.06852392f, 0.12294756f, 0.03547434f, -0.03476933f, 
    -0.05042463f, 0.01553654f, 0.31834781f, -0.06820216f, -0.05801882f, -0.10167538f, -0.05395410f, -0.01869497f, 
    0.26456007f, 0.00256633f, 0.04976937f, -0.00710971f, -0.02825538f, -0.02167514f, -0.03380321f, -0.04333469f, 
    0.09271581f, 0.16386595f, 0.22421013f, 0.17258681f, -0.19099602f, 0.06430084f, -0.02002330f, 0.52324021f, 
    0.06702291f, 0.02975268f, 0.00314815f, 0.09256225f, 0.11808854f, -0.08704269f, 0.14101498f, -0.06256641f, 
    -0.10564573f, -0.03001726f, -0.04404264f, 0.08435938f, 0.09320430f, -0.03733027f, 0.02129209f, -0.03466615f, 
    0.02601033f, 0.16764213f, -0.03273226f, -0.13739517f, 0.06825042f, -0.02292404f, -0.03404550f, -0.12518086f, 
    0.08621951f, 0.02383535f, 0.13125616f, 0.21013480f, 0.03355071f, 0.00060752f, -0.03730564f, 0.02450786f, 
    0.14517023f, -0.18661895f, -0.22077464f, -0.26533312f, 0.10149020f, -0.01615445f, 0.10364470f, -0.12564747f, 
    -0.02840109f, -0.03662946f, -0.02740667f, 0.07598597f, -0.02281754f, 0.07161721f, -0.08549294f, 0.14840145f, 
    0.18976468f, 0.15156277f, -0.06804072f, 0.02957175f, 0.07890780f, 0.11160437f, 0.04155748f, 0.12033262f, 
    0.07377559f, -0.10490333f, -0.11169022f, -0.03066706f, 0.09397668f, 0.19534364f, 0.02004617f, -0.07177936f, 
    0.01880335f, 0.03019218f, -0.11398248f, 0.11783227f, -0.36913547f, -0.11155813f, -0.11226305f, -0.06141451f, 
    -0.01364694f, 0.00486651f, 0.03803288f, -0.04930003f, -0.02297760f, -0.04872016f, 0.06343710f, -0.05870638f, 
    -0.03423207f, -0.05862576f, -0.09009612f, 0.09420548f, -0.02877164f, 0.05715779f, 0.01862482f, 0.04172017f, 
    0.00591242f, 0.00594765f, 0.14957464f, 0.05998632f, 0.20434605f, -0.12436367f, 0.10083475f, -0.06288103f, 
    0.00733739f, 0.00843837f, -0.12541966f, 0.02310301f, 0.07362769f, 0.14132524f, 0.15923516f, 0.14998798f, 
    0.18899520f, 0.22055140f, 0.07026386f, -0.00316103f, 0.14564939f, -0.18467855f, 0.29763576f, 0.11066063f, 
    0.28594440f, 0.01570145f, 0.05951972f, 0.27246734f, 0.04616804f, -0.02334309f, -0.02047582f, 0.17442936f, 
    -0.01502279f, 0.07226180f, 0.01402663f, -0.00400204f, 0.03802194f, 0.06812558f, -0.04685874f, 0.03199456f, 
    -0.00023725f, 0.03826542f, -0.22163314f, 0.09241391f, -0.03153664f, -0.09490358f, 0.21792574f, -0.08729337f, 
    -0.10474061f, -0.02337488f, -0.06337056f, -0.07026324f, 0.20971754f, 0.20176220f, 0.15228795f, 0.10237999f, 
    0.04139551f, 0.05194709f, 0.01123473f, -0.03382829f, -0.08358031f, -0.00074035f, 0.15696608f, -0.08116327f, 
    -0.29105410f, 0.10003916f, -0.05761083f, 0.07386747f, -0.04678408f, -0.03299992f, -0.03165444f, 0.01201040f, 
    -0.00486857f, 0.08310449f, -0.06006851f, 0.00844851f, -0.27736190f, 0.15858476f, 0.09818584f, 0.31652063f, 
    -0.01288133f, -0.03580190f, 0.11427582f, -0.12681457f, 0.05273755f, 0.10949510f, 0.08400676f, 0.06490166f, 
    -0.03769355f, 0.02622846f, 0.04876994f, -0.02003485f, -0.01822585f, -0.03509645f, -0.07443232f, -0.03643882f, 
    -0.06910620f, 0.06011017f, 0.14076126f, 0.08437689f, 0.25082886f, -0.11411148f, -0.22461422f, -0.13388878f, 
    -0.09621885f, 0.01823352f, 0.15236789f, 0.15722397f, -0.04527007f, -0.11083919f, -0.12470877f, -0.13820672f, 
    -0.10603677f, -0.08687874f, -0.08136352f, 0.36383280f, 0.15544875f, 0.06048422f, 0.11179005f, -0.07215119f, 
    -0.11257941f, 0.08779308f, 0.07571352f, 0.03489554f, -0.12479995f, 0.12667209f, 0.02210239f, 0.12295504f, 
    -0.00978745f, -0.08119344f, -0.03542984f, -0.02033082f, 0.07577537f, 0.13832974f, 0.04472235f, 0.09857719f, 
    0.04446043f, 0.00162656f, 0.15791732f, 0.08285084f, -0.02217942f, 0.00996001f, -0.08165590f, -0.12525462f, 
    -0.10210104f, 0.01792742f, -0.06559616f, -0.10993218f, 0.20018236f, -0.13371246f, -0.33511588f, 0.03075081f, 
    -0.04160164f, 0.00001705f, 0.11002678f, 0.04342395f, 0.12353798f, -0.01558873f, 0.01132659f, 0.00073470f, 
    0.03463647f, 0.22935285f, 0.12720963f, -0.02136095f, 0.17839424f, 0.20179513f, 0.00909083f, 0.13611035f, 
    0.05642543f, -0.03805323f, -0.04410933f, 0.10083233f, 0.07005405f, -0.12060352f, -0.24050321f, -0.24048612f, 
    -0.08287605f, -0.13282625f, 0.21221520f, 0.32949907f, -0.09478807f, 0.05419713f, 0.10995078f, -0.11141767f, 
    0.02302300f, 0.12708710f, 0.16745235f, -0.09159554f, 0.08974266f, 0.19984417f, -0.10478941f, 0.13727665f, 
    0.06390648f, -0.00786218f, -0.00818014f, -0.10521128f, -0.15576400f, 0.17397451f, 0.10296451f, 0.04940590f, 
    0.09229798f, -0.05665336f, -0.06652551f, 0.02645053f, 0.03556824f, -0.05328101f, 0.00428654f, 0.14302133f, 
    0.01350095f, -0.17023769f, -0.34044769f, -0.24160433f, -0.01351927f, 0.00038444f, 0.06849284f, 0.19249836f, 
    0.02658005f, -0.13695051f, -0.05719256f, -0.11931740f, -0.03129311f, 0.04578971f, -0.02381191f, -0.08045349f, 
    -0.11266907f, -0.04563798f, -0.17639291f, 0.04627958f, -0.01717651f, 0.09067795f, 0.10993827f, -0.10006249f, 
    0.28208134f, 0.18648691f, 0.05022065f, -0.07357178f, 0.14113124f, 0.21341786f, -0.05618007f, 0.05318863f, 
    0.06252464f, -0.04179099f, -0.00809027f, 0.05580674f, -0.10991832f, 0.06283733f, 0.14526847f, 0.14009522f, 
    -0.09395728f, -0.04533393f, 0.08061879f, -0.00921237f, 0.05608937f, 0.02392086f, -0.02565107f, 0.18474719f, 
    0.09488527f, 0.19525917f, 0.13918412f, -0.19060816f, -0.19241290f, 0.07053676f, 0.07010748f, 0.00860366f, 
    0.11463519f, -0.02231589f, 0.01224687f, 0.25757146f, 0.12168866f, -0.13840602f, -0.13082699f, 0.01974401f, 
    0.08308510f, 0.23189867f, 0.00420867f, 0.06557691f, -0.02166378f, -0.02285426f, 0.00266455f, -0.05508254f, 
    0.04221067f, -0.04886563f, -0.04131909f, 0.10838097f, -0.04528380f, 0.00159551f, 0.02067562f, -0.04848717f, 
    0.11114906f, -0.02699890f, 0.00774062f, -0.20764206f, 0.28558800f, 0.10896473f, 0.15067150f, 0.03959145f, 
    -0.02102493f, -0.13646160f, -0.04839838f, 0.08589610f, 0.03084857f, 0.18793474f, 0.01095565f, 0.05071157f, 
    0.06456643f, 0.04609900f, 0.13679290f, 0.00374321f, 0.07252019f, 0.31762168f, -0.03238662f, 0.12395308f, 
    0.05911190f, -0.05712868f, -0.00872794f, 0.04684638f, -0.04743857f, 0.09825100f, 0.00636795f, 0.02952465f, 
    -0.15773426f, 0.05378290f, -0.09035129f, -0.02823145f, -0.12676962f, -0.01922286f, 0.16489650f, 0.15052253f, 
    -0.23063362f, 0.25099427f, 0.10775234f, 0.15625601f, -0.06576998f, -0.14133346f, -0.28864825f, -0.04104721f, 
    -0.02581730f, -0.06148736f, 0.00711887f, 0.00657975f, 0.03678366f, 0.00523539f, 0.06219329f, 0.18730140f, 
    -0.06951167f, -0.03183795f, 0.04247759f, -0.07128023f, -0.00689882f, 0.16215688f, 0.06532785f, 0.04063898f, 
    0.05985393f, 0.06709686f, -0.02975507f, 0.15222120f, 0.08493388f, -0.00075036f, -0.06064651f, 0.08063415f, 
    -0.04283823f, 0.07682882f, 0.13114411f, 0.00269269f, 0.18413475f, 0.03438636f, 0.01491756f, 0.02660222f, 
    0.08566944f, 0.15256102f, -0.01595785f, 0.06443944f, -0.00101531f, 0.02621216f, 0.02760843f, -0.04148552f, 
    0.11600757f, 0.00004102f, 0.06449986f, -0.15897956f, -0.00432226f, -0.01893799f, -0.06481978f, -0.01711606f, 
    -0.13122885f, -0.10851092f, -0.08103377f, -0.21684842f, -0.14029816f, -0.02024778f, 0.17525701f, -0.01415075f, 
    0.05634901f, 0.03538942f, -0.00633336f, -0.05697765f, -0.03817877f, -0.22206701f, -0.11878817f, 0.03843179f, 
    0.02163069f, -0.08817932f, -0.12163558f, 0.10963548f, -0.24401908f, 0.16756046f, 0.01040231f, -0.02142653f, 
    0.07978033f, 0.02078116f, -0.05342375f, -0.00426300f, -0.06390716f, -0.02799546f, 0.13084945f, 0.03760324f, 
    0.08087415f, -0.11605584f, -0.04776254f, -0.01102214f, 0.01521362f, 0.13017723f, 0.14165938f, 0.01514702f, 
    0.01794191f, 0.15406342f, 0.24130709f, -0.08624127f, -0.00206165f, 0.14917941f, -0.09691792f, -0.27113184f, 
    0.06106972f, 0.04460514f, 0.09831364f, 0.15439281f, 0.19000475f, -0.19668396f, -0.20799668f, -0.07962644f, 
    -0.13318083f, 0.07371555f, 0.03486741f, -0.01249207f, 0.22644237f, -0.00224842f, -0.06482007f, -0.11071139f, 
    0.25756153f, 0.19407685f, 0.10436610f, -0.11036767f, 0.07081161f, 0.09537291f, 0.05001549f, 0.10029931f, 
    -0.05322149f, -0.11031365f, 0.02943104f, 0.05151925f, 0.09376504f, 0.11873437f, 0.22846220f, 0.07841418f, 
    0.04810067f, -0.01373974f, -0.15418918f, -0.04655148f, 0.02668536f, -0.06760238f, 0.03927673f, 0.13952330f, 
    -0.04468387f, 0.01760122f, 0.04362718f, -0.02455199f, -0.01620756f, 0.03281178f, 0.04610343f, -0.01628681f, 
    -0.03463180f, -0.00878460f, 0.00246757f, 0.02514056f, 0.01869718f, 0.01268763f, -0.02865362f, -0.01696254f, 
    -0.00457707f, -0.04884343f, 0.01090307f, 0.01698490f, -0.05131615f, 0.04086918f, 0.00676578f, -0.05432003f, 
    -0.03513376f, 0.03637756f, 0.01798233f, -0.05164586f, 0.01019505f, -0.04440608f, -0.03668520f, -0.03453610f, 
    -0.04643543f, -0.01010700f, 0.02041230f, 0.03365077f, 0.03030575f, -0.05108576f, 0.03715618f, 0.04321279f, 
    0.02410228f, 0.03560748f, -0.02158821f, -0.05187256f, -0.04045643f, 0.02900269f, 0.00775753f, -0.02310077f, 
    0.00394831f, 0.03720569f, -0.02899529f, -0.02870535f, 0.02490274f, -0.05136537f, 0.03155455f, -0.01138088f, 
    -0.04918101f, -0.04329299f, 0.01495773f, -0.03810237f, 0.02027876f, 0.04221650f, -0.04180347f, -0.01531989f, 
    0.03203607f, 0.01929245f, -0.03359147f, 0.04340240f, -0.00108869f, -0.02601081f, -0.00987245f, -0.00773378f, 
    0.00967329f, 0.01822372f, 0.02343386f, -0.05488535f, -0.01982368f, 0.01838287f, 0.04153619f, 0.01762860f, 
    -0.03345243f, -0.03079643f, -0.00638838f, -0.00760780f, -0.04856284f, -0.01871707f, 0.02635752f, -0.04508971f, 
    -0.02422809f, 0.05599554f, 0.01336879f, -0.03934990f, -0.04077032f, -0.01512492f, -0.04367629f, -0.02726129f, 
    0.00318343f, -0.01171232f, 0.03082834f, 0.00726732f, -0.02593173f, -0.04278623f, -0.00190238f, -0.02668408f, 
    0.02106938f, 0.04343318f, 0.02169343f, -0.05451347f, -0.02802431f, 0.03874208f, -0.05697006f, 0.02397440f, 
    0.02707543f, 0.04099301f, -0.02558439f, 0.00498601f, 0.04277031f, -0.03395329f, 0.00396563f, 0.00075374f, 
    0.03019388f, -0.02537551f, 0.00850821f, -0.05215579f, 0.02267967f, 0.02828520f, -0.00726646f, 0.03614576f, 
    -0.03980885f, -0.01632546f, 0.04259364f, -0.02963647f, -0.00055635f, -0.02906770f, -0.03774440f, 0.02861767f, 
    -0.03443159f, 0.02256552f, 0.01562969f, -0.04141777f, 0.01437109f, -0.00284283f, 0.00918242f, 0.00243805f, 
    0.01087520f, 0.00781235f, -0.04789970f, 0.01884920f, -0.01733934f, 0.01229842f, 0.04121113f, 0.01034418f, 
    -0.04354803f, -0.00118303f, 0.00725608f, -0.02512709f, -0.00729131f, -0.02985421f, 0.02560974f, 0.00003057f, 
    -0.00803256f, -0.00182170f, -0.00533502f, 0.00208530f, 0.04343967f, -0.03557964f, -0.03992664f, -0.05601752f, 
    -0.01747163f, -0.01087180f, 0.04319096f, -0.02809188f, 0.01135503f, 0.02206790f, 0.01361929f, 0.01444760f, 
    -0.02224299f, -0.00296843f, 0.00975337f, -0.00549698f, -0.00882977f, -0.04042145f, 0.00001373f, -0.00338773f, 
    -0.04370613f, -0.01362970f, 0.02753487f, 0.02267851f, -0.04549686f, 0.00926034f, -0.04257500f, -0.02497101f, 
    -0.02277105f, 0.01633684f, 0.02539898f, -0.05527842f, 0.00049989f, -0.01760192f, 0.03959721f, -0.03419795f, 
    -0.02930835f, -0.03476726f, 0.01345599f, -0.03718235f, 0.03926711f, -0.00764993f, 0.01037020f, -0.01545039f, 
    0.01880845f, 0.00397780f, 0.00236206f, -0.00881657f, -0.02790303f, 0.01972362f, -0.01645791f, -0.04489232f, 
    -0.02200504f, -0.00372595f, 0.01414817f, 0.00897602f, -0.04618680f, 0.01293887f, 0.03493501f, 0.00717726f, 
    0.00384455f, -0.03428647f, -0.03371292f, 0.04506037f, -0.00792109f, -0.01750305f, 0.02683076f, -0.00866697f, 
    0.04313333f, 0.00358331f, -0.03485022f, -0.04624350f, -0.00672175f, -0.02986146f, -0.04974627f, -0.04423237f, 
    -0.02069159f, 0.03059414f, -0.04744579f, -0.01485069f, -0.03873307f, -0.04935069f, -0.02015520f, -0.02749252f, 
    0.01216266f, 0.02801685f, 0.03322292f, 0.01138227f, -0.01295074f, 0.00573351f, -0.00933788f, -0.03013321f, 
    -0.04982036f, -0.05544689f, -0.04191133f, 0.00935988f, 0.02111745f, -0.04309686f, -0.04029269f, 0.02209251f, 
    -0.03287030f, -0.00267274f, 0.01166436f, -0.02719190f, 0.04452703f, -0.00178242f, -0.01924462f, 0.01757520f, 
    0.04231546f, -0.05425493f, 0.03373446f, 0.00731615f, 0.00925144f, 0.01298630f, -0.03080348f, 0.01898441f, 
    0.00268194f, -0.03233405f, 0.01982875f, 0.02209765f, -0.02804706f, -0.01619336f, 0.04263432f, -0.04700386f, 
    0.02182464f, -0.01942335f, -0.00489004f, -0.01681710f, -0.05637631f, -0.03025256f, 0.02299015f, 0.02667724f, 
    0.00781195f, 0.00173578f, -0.01395949f, -0.04316687f, -0.00969682f, -0.03786848f, 0.01014219f, -0.04083382f, 
    -0.04121841f, -0.00159139f, 0.01193343f, 0.00304409f, -0.01973825f, -0.03328049f, 0.02988391f, -0.01851902f, 
    -0.05592189f, -0.04751929f, -0.00430590f, -0.02295582f, -0.05105360f, -0.03335527f, -0.01747520f, 0.00630693f, 
    -0.03395140f, 0.03196130f, 0.00672896f, -0.04338519f, -0.05572160f, -0.02374009f, 0.03335479f, -0.02867370f, 
    -0.03521184f, -0.01602768f, -0.04631559f, -0.01615593f, 0.01142089f, 0.01485619f, -0.02427834f, -0.02381393f, 
    -0.02864901f, 0.02365691f, -0.02130882f, 0.02037671f, 0.01797110f, 0.00961324f, -0.03416002f, 0.02124627f, 
    0.03819014f, -0.00951349f, 0.02093477f, 0.01025438f, -0.04345610f, -0.04548253f, -0.00781668f, 0.01913494f, 
    0.03685379f, -0.04244842f, 0.01112359f, -0.03892093f, 0.04108511f, -0.03983722f, -0.02890613f, 0.00913895f, 
    -0.00914758f, -0.01286035f, 0.04078263f, -0.00172689f, -0.05182227f, 0.01862226f, 0.04409130f, -0.02685772f, 
    -0.02037933f, -0.05468028f, 0.01872523f, 0.00226150f, -0.04778870f, 0.01397753f, -0.01245095f, -0.00228572f, 
    0.01030261f, 0.01344474f, 0.03953026f, -0.00352922f, 0.00891014f, 0.02091118f, -0.01614240f, -0.01390002f, 
    -0.05588767f, -0.17101640f, -0.29797927f, -0.01310011f, -0.05077793f, 0.13314612f, 0.08774126f, 0.03001788f, 
    0.19184770f, -0.01090764f, 0.11873438f, 0.05430697f, -0.10515437f, 0.10153820f, 0.13497451f, 0.01773843f, 
    0.04185396f, -0.03528729f, -0.02370559f, 0.02815853f, -0.10342815f, -0.04329805f, 0.09503598f, -0.06706218f, 
    -0.03902415f, 0.29318851f, 0.11692680f, 0.31850317f, 0.07874922f, 0.02224153f, 0.29842517f, -0.05725754f, 
    -0.08384846f, -0.11769056f, 0.04367759f, -0.03999183f, -0.14244737f, 0.08112161f, 0.08057252f, 0.12971486f, 
    -0.00983300f, 0.05905256f, 0.12875681f, -0.03065021f, 0.19398358f, 0.25640178f, -0.04583139f, 0.06157895f, 
    -0.31154877f, -0.27246371f, -0.09850638f, -0.13638604f, -0.11770030f, 0.03667258f, 0.04447579f, 0.04112393f, 
    0.06308715f, 0.01205626f, -0.23958585f, 0.00814223f, 0.09882173f, -0.05577950f, 0.27677131f, -0.09847455f, 
    -0.04326748f, 0.03867188f, -0.20642953f, 0.02116711f, 0.10872274f, -0.08949741f, 0.15196745f, -0.00455398f, 
    0.04451582f, 0.11001222f, 0.03503403f, 0.01760654f, 0.06977216f, 0.07646713f, -0.01001235f, 0.10389866f, 
    0.08775451f, 0.06395382f, 0.06320662f, -0.00595942f, -0.12047619f, 0.04369819f, 0.23716849f, 0.10841189f, 
    -0.03087538f, -0.13261524f, -0.01505211f, 0.04190201f, -0.03083646f, 0.13179484f, 0.13677512f, 0.03916306f, 
    -0.13756528f, 0.31905299f, -0.11021551f, 0.09367941f, 0.06068349f, -0.09952978f, 0.05596211f, 0.20152417f, 
    0.05224970f, 0.08732276f, -0.03798854f, -0.16357680f, -0.13214926f, -0.04286927f, -0.53250533f, 0.03470974f, 
    -0.04466145f, -0.07422473f, 0.03259967f, 0.01552673f, 0.10568915f, -0.05723977f, -0.04118098f, -0.01503096f, 
    -0.21444885f, 0.02517477f, -0.01282610f, -0.02804863f, 0.02170496f, -0.14377263f, -0.11361354f, 0.04420213f, 
    -0.02281623f, -0.12077844f, -0.02923341f, -0.22949684f, 0.16560191f, -0.36760834f, -0.04013146f, 0.36996835f, 
    0.13423790f, 0.33559415f, 0.02650775f, 0.06929561f, -0.07103252f, 0.00846691f, -0.06787693f, -0.21905920f, 
    0.05887816f, 0.11921743f, 0.16882837f, 0.23577186f, 0.18733938f, 0.09812082f, 0.04858479f, 0.06784520f, 
    0.06654012f, 0.02966148f, 0.02723817f, 0.00138820f, 0.08818085f, 0.24826698f, -0.11382685f, -0.19261259f, 
    -0.07331501f, -0.01880372f, -0.02536743f, -0.12377727f, 0.19189273f, 0.03724293f, -0.07024287f, 0.14050859f, 
    0.11279232f, 0.13198858f, 0.03009449f, 0.08334513f, -0.04888343f, 0.07419866f, -0.03226922f, -0.03934804f, 
    0.16114977f, -0.03506318f, 0.17821784f, 0.08826896f, -0.04983485f, 0.07754505f, 0.07145685f, -0.04678391f, 
    0.02362281f, -0.05058756f, -0.17364208f, 0.10633609f, -0.07600065f, 0.21326378f, 0.07691706f, 0.02786708f, 
    -0.24278851f, -0.08000647f, -0.17223793f, -0.10021131f, -0.06829015f, -0.06915519f, 0.08764129f, 0.06419090f, 
    0.00132728f, 0.06732111f, -0.05370477f, -0.01063122f, 0.01221188f, -0.11146396f, 0.25574872f, -0.02987855f, 
    -0.04990764f, 0.13545835f, -0.01904678f, 0.03608146f, 0.03499784f, -0.02173836f, 0.08167017f, 0.09479605f, 
    -0.12091736f, -0.01589729f, 0.16708730f, 0.07090899f, -0.10924464f, 0.04683486f, -0.02488085f, 0.12342319f, 
    0.08058485f, -0.01502727f, -0.05110943f, 0.01929439f, 0.19112627f, 0.20197682f, -0.13502157f, 0.25124136f, 
    -0.20381309f, 0.16870777f, 0.08095508f, -0.03235687f, 0.04654062f, 0.24450338f, 0.10769735f, 0.02003275f, 
    0.14226910f, -0.39061221f, -0.21104622f, 0.29691175f, -0.07227449f, 0.18515615f, 0.05307533f, -0.09504478f, 
    -0.03322170f, -0.05760261f, 0.00680358f, 0.00947203f, -0.09994788f, -0.03860303f, 0.31156051f, 0.13524547f, 
    0.04968638f, 0.00113281f, 0.00865789f, -0.06221152f, 0.10296703f, 0.06288014f, 0.05625642f, 0.14179683f, 
    -0.18712509f, -0.13071871f, -0.03580579f, -0.07011773f, 0.28154817f, 0.13307823f, 0.18619944f, 0.26303014f, 
    -0.12989490f, -0.11378180f, 0.17693625f, 0.20225854f, 0.11652995f, 0.15065533f, 0.26318622f, 0.22033405f, 
    0.06202038f, 0.07677656f, -0.04269544f, 0.08472052f, 0.10649775f, -0.01711393f, -0.02286470f, -0.02606478f, 
    -0.18799748f, 0.07194714f, 0.15958366f, -0.06637124f, 0.03559447f, 0.02716087f, -0.19963279f, 0.15125139f, 
    -0.32602268f, -0.01548843f, -0.21686435f, -0.20441289f, -0.08133949f, -0.00056972f, -0.15473226f, 0.00848328f, 
    -0.02701806f, -0.06737454f, 0.08902765f, 0.01413624f, 0.00803312f, -0.22634529f, 0.04602645f, 0.01020499f, 
    -0.17480700f, 0.15120600f, 0.14595681f, -0.16256514f, -0.10680658f, 0.10504618f, -0.22601540f, 0.00129975f, 
    -0.15526952f, -0.08895586f, -0.04016544f, 0.09469613f, -0.45775652f, -0.31802830f, -0.08787055f, -0.00533773f, 
    -0.12384805f, -0.08988239f, -0.02311385f, -0.08824121f, -0.09048744f, -0.00798901f, 0.16277434f, 0.01042926f, 
    -0.20786765f, 0.02037218f, -0.02430804f, -0.08871437f, -0.12571999f, 0.16380164f, -0.00871932f, 0.21343568f, 
    0.08985350f, 0.15047786f, 0.01067343f, 0.11558524f, -0.18880361f, -0.10643093f, 0.04193408f, -0.17183702f, 
    0.00474694f, -0.03540245f, -0.09372535f, 0.08941171f, 0.10383356f, 0.07848451f, 0.08459105f, 0.10642248f, 
    -0.20188391f, -0.21060561f, 0.26233020f, -0.07384656f, -0.00154237f, 0.03950441f, -0.06158183f, -0.03257359f, 
    0.01319230f, 0.03998253f, 0.00799402f, -0.05402318f, -0.09927024f, -0.17157005f, -0.06974474f, 0.18946157f, 
    -0.03258135f, -0.01518979f, -0.09871832f, 0.00701946f, -0.07931010f, -0.08226819f, 0.00182108f, -0.09172732f, 
    -0.03393586f, -0.04518307f, -0.06858870f, -0.09040522f, 0.09780441f, -0.04523191f, 0.02356611f, -0.07957239f, 
    -0.00445184f, 0.05524743f, 0.02245488f, 0.12654196f, 0.03407680f, -0.28954339f, -0.29813248f, -0.24705343f, 
    -0.13432777f, -0.10868862f, -0.01614728f, -0.11539976f, 0.08708534f, -0.03158865f, -0.06318959f, -0.01913116f, 
    -0.14389308f, 0.17749855f, 0.11866069f, 0.21538624f, 0.07210258f, 0.13689563f, 0.14843354f, 0.29513443f, 
    -0.08135873f, 0.04265106f, 0.09762330f, 0.04759153f, -0.07722935f, 0.07605679f, -0.02147703f, -0.00685425f, 
    0.02957274f, -0.14344880f, -0.03756232f, -0.09305305f, 0.05153338f, 0.16872913f, 0.17894365f, 0.19116196f, 
    0.04105041f, 0.03675964f, 0.13665994f, -0.04951375f, -0.03970575f, -0.07255898f, -0.15273869f, -0.14602192f, 
    -0.02749456f, -0.12690413f, -0.06825297f, -0.19662644f, 0.40668610f, -0.09291755f, 0.15725788f, 0.03420219f, 
    -0.06998276f, 0.03743590f, -0.00184541f, -0.05059604f, 0.06783034f, 0.12096927f, 0.17540701f, 0.08875931f, 
    0.12432363f, 0.12226311f, 0.11433402f, 0.21696937f, 0.14204828f, 0.22535689f, 0.01502118f, 0.16006744f, 
    0.01098166f, 0.11140828f, 0.01247134f, -0.05401687f, -0.03674126f, -0.11956571f, -0.16349630f, 0.02386343f, 
    -0.11004790f, 0.04691680f, 0.01251754f, 0.16754849f, -0.18370056f, 0.18597943f, -0.04498135f, 0.08692380f, 
    0.00275104f, -0.04897409f, -0.07206555f, 0.05544395f, 0.04351939f, -0.05940413f, 0.10850628f, 0.26197931f, 
    -0.02651227f, 0.10652398f, 0.02142020f, -0.12521064f, -0.11692438f, 0.09916326f, 0.01209090f, -0.02114609f, 
    0.10264291f, 0.01321469f, -0.02879464f, -0.05704866f, -0.04055825f, 0.02905561f, 0.00507282f, -0.03658736f, 
    0.05498209f, -0.16996126f, -0.25888693f, -0.14030303f, -0.09488743f, -0.15371732f, -0.10676511f, 0.05514101f, 
    0.03688844f, -0.16414285f, -0.20759611f, -0.33948833f, -0.06304406f, 0.07452119f, -0.11019538f, 0.00618437f, 
    -0.03578481f, 0.24558821f, -0.06064000f, 0.04755551f, -0.01890609f, -0.01818003f, -0.00458312f, -0.11810087f, 
    0.21102925f, 0.14160632f, 0.22505577f, 0.15969574f, 0.01378205f, 0.11247346f, -0.10055572f, -0.03439315f, 
    0.05473408f, 0.02541294f, 0.04450789f, 0.06710862f, -0.22106801f, 0.16729017f, 0.08328218f, 0.10617912f, 
    -0.19113144f, -0.08731138f, -0.02036006f, -0.17479016f, -0.02426039f, 0.15663619f, 0.06749909f, 0.17471960f, 
    0.25871029f, 0.07427473f, 0.06149455f, -0.10812943f, -0.24842204f, -0.02577718f, -0.00941224f, -0.01179568f, 
    0.13563395f, 0.08081713f, 0.12982655f, 0.41677612f, -0.05558175f, -0.30232942f, -0.26519793f, -0.01998519f, 
    -0.06947485f, 0.05358518f, 0.05957889f, 0.18103664f, 0.03951463f, -0.09968688f, 0.03129121f, -0.02365543f, 
    0.12312524f, -0.07849008f, 0.02969575f, 0.16933079f, -0.05260937f, 0.03744981f, -0.03875192f, -0.02621520f, 
    0.05420657f, -0.10249183f, -0.18227242f, -0.11365775f, 0.11094222f, 0.07179690f, 0.08397352f, -0.10798239f, 
    -0.11926081f, -0.01808353f, 0.05144040f, -0.05830169f, -0.06476747f, 0.01986228f, -0.12462401f, 0.00116720f, 
    -0.04680009f, -0.11761080f, -0.11279410f, 0.10607947f, 0.10027061f, 0.20548281f, 0.11357284f, 0.16962959f, 
    0.19914164f, 0.04165653f, 0.10759716f, -0.04351385f, 0.03030462f, 0.14464645f, -0.02304225f, 0.08728541f, 
    -0.03304821f, 0.01471398f, 0.06501321f, 0.06088898f, -0.03267165f, 0.11782251f, 0.16998781f, 0.09386626f, 
    0.05168401f, 0.14780043f, -0.03769341f, 0.15185210f, -0.04447078f, -0.12745614f, -0.15420058f, -0.16150306f, 
    -0.04647841f, -0.08747339f, -0.03230599f, -0.01170467f, 0.06740317f, -0.00492268f, 0.05572350f, 0.06488878f, 
    0.17117102f, 0.02263602f, 0.07308974f, -0.05764574f, -0.06758627f, 0.14628516f, 0.13200305f, 0.13940464f, 
    0.01792407f, -0.05178635f, -0.03461698f, -0.01629897f, 0.11384984f, 0.14566407f, -0.00976683f, -0.02023804f, 
    0.02340411f, -0.02215422f, 0.05701664f, 0.13139795f, 0.01350868f, -0.00055083f, 0.15141556f, 0.20014311f, 
    0.07674984f, 0.13189343f, 0.07025356f, 0.13694303f, -0.12006050f, -0.02533052f, 0.08264426f, -0.03307341f, 
    0.10610644f, 0.04051818f, -0.04305365f, -0.13477640f, 0.03366606f, -0.01487540f, -0.11156988f, -0.05701946f, 
    -0.26521689f, -0.29060107f, -0.13616757f, -0.48146570f, -0.04551641f, 0.02098040f, 0.16441688f, -0.08823054f, 
    -0.02123456f, -0.08604863f, -0.02748152f, -0.06756271f, -0.03377702f, -0.26629770f, -0.19636455f, -0.10413425f, 
    0.05550163f, 0.07618020f, -0.01890777f, 0.04936889f, -0.11484437f, 0.04605406f, -0.07580002f, -0.05590376f, 
    0.10501000f, 0.03120667f, 0.14353676f, 0.02444137f, 0.01900902f, 0.05186693f, 0.06408903f, -0.10364299f, 
    0.05961201f, -0.11145679f, -0.08095798f, -0.04198686f, -0.02475168f, -0.02783569f, 0.11088142f, -0.03668305f, 
    -0.00852897f, 0.16819744f, -0.05945205f, 0.00330935f, 0.12623797f, 0.19002451f, 0.10943636f, -0.15526854f, 
    0.00142398f, 0.01952418f, 0.04314565f, 0.11969389f, 0.24769105f, -0.36489418f, -0.11215001f, -0.20206398f, 
    -0.13738543f, -0.08471978f, -0.04337204f, -0.09780868f, 0.13250415f, 0.03217201f, -0.03309374f, 0.09053956f, 
    0.03873284f, 0.16244023f, 0.29603869f, 0.11627252f, -0.05660187f, -0.04992103f, -0.08392378f, 0.07930574f, 
    -0.00104661f, -0.10614911f, -0.06532396f, -0.05283016f, 0.02238738f, -0.01988969f, 0.09781468f, 0.03448743f, 
    -0.05423751f, 0.00559874f, -0.14179520f, -0.06962317f, -0.04920807f, -0.10830912f, -0.18089114f, 0.03216483f, 
    0.17431325f, -0.10621820f, -0.11944307f, 0.07061803f, -0.08524380f, 0.16696340f, -0.03140604f, -0.04008526f, 
    0.10198957f, -0.01262430f, -0.06530943f, -0.14502601f, -0.40372431f, 0.04868602f, 0.37220001f, -0.00305072f, 
    0.07551307f, 0.03503778f, -0.03359276f, 0.04669850f, 0.01254079f, -0.05519347f, 0.07213865f, -0.03161428f, 
    0.01460818f, 0.37679842f, -0.10501048f, 0.16472299f, -0.09478085f, 0.05422749f, 0.02643079f, -0.04182252f, 
    0.02011494f, 0.00128250f, -0.08744755f, -0.02495288f, -0.10067625f, -0.03525762f, -0.00689814f, -0.10031418f, 
    0.04732816f, -0.03504652f, -0.05769069f, -0.09411201f, -0.11338706f, -0.17255138f, -0.25584549f, -0.21905562f, 
    -0.06092751f, -0.21031886f, -0.23306465f, 0.07985068f, 0.12653647f, 0.17858362f, 0.16014150f, 0.10824616f, 
    0.13263498f, 0.11557392f, 0.00247330f, 0.00888845f, -0.23033199f, -0.39687064f, 0.21146661f, -0.25330645f, 
    0.00618972f, -0.01290953f, -0.02379030f, 0.07611775f, 0.02551762f, -0.01519592f, 0.02336819f, -0.04773493f, 
    0.02514695f, 0.07304376f, 0.02781937f, -0.17409675f, -0.04419554f, 0.02313097f, -0.02694048f, -0.01076213f, 
    0.00009136f, -0.04490484f, 0.02237272f, 0.01145448f, -0.20127580f, 0.07081861f, 0.21485499f, 0.08234209f, 
    0.02991414f, -0.06937266f, 0.07035368f, 0.01835619f, 0.10021368f, -0.06020002f, 0.00685933f, -0.07741529f, 
    0.27087131f, -0.03955100f, -0.21092285f, -0.13313071f, -0.00315704f, 0.05548069f, -0.14826681f, 0.04936057f, 
    -0.03103645f, -0.05810407f, -0.11889448f, 0.10821119f, 0.07129997f, -0.15657450f, -0.37259123f, 0.16557218f, 
    -0.03981265f, -0.01739468f, 0.00644794f, 0.00171357f, -0.00529975f, -0.15930001f, 0.07521375f, 0.02685818f, 
    -0.01450208f, 0.08601216f, -0.05479884f, -0.02482442f, 0.11490651f, -0.00398758f, -0.01360899f, 0.12763214f, 
    -0.04608258f, 0.04198651f, 0.16709572f, 0.18556994f, -0.04541954f, -0.21948011f, 0.18043976f, -0.05533259f, 
    0.26290140f, 0.03193510f, -0.01606530f, 0.19912362f, 0.05481987f, 0.00427562f, -0.01411922f, -0.04218249f, 
    0.21533075f, 0.15455870f, 0.05544090f, -0.01416034f, 0.05685414f, 0.03708784f, 0.08582292f, 0.27749842f, 
    0.03554719f, 0.10036388f, 0.07839642f, 0.08304834f, -0.16554038f, 0.09031738f, -0.06326020f, -0.04032692f, 
    0.06965124f, 0.06590551f, -0.12961139f, -0.03867020f, -0.06290697f, -0.11288067f, -0.17680973f, -0.08417646f, 
    -0.12983233f, 0.11474738f, 0.06688915f, 0.12432030f, 0.14263555f, 0.04714344f, -0.23411578f, -0.19097254f, 
    -0.13242862f, -0.17460141f, -0.13869047f, -0.27932653f, 0.02164621f, 0.13524923f, 0.13157524f, -0.19286956f, 
    0.04498971f, 0.07991922f, -0.05277460f, 0.02330311f, -0.06222779f, 0.06423704f, -0.02308647f, -0.09745154f, 
    -0.22204097f, -0.19074209f, 0.02131324f, -0.13958259f, -0.00964809f, 0.05021287f, 0.10831192f, -0.07512842f, 
    0.00113464f, 0.20023452f, 0.04117569f, 0.04641379f, -0.19722344f, 0.11852138f, 0.08309905f, 0.23528133f, 
    0.02835378f, 0.11982418f, -0.14027318f, -0.20979902f, 0.06082970f, -0.04591976f, 0.09921142f, 0.09233523f, 
    0.11057688f, 0.09567878f, 0.17583682f, -0.17057706f, 0.05407176f, -0.07428192f, -0.00729599f, -0.00362901f, 
    0.09900583f, -0.05689770f, 0.01939233f, 0.06839488f, -0.00279268f, 0.03407483f, 0.02257182f, 0.28001040f, 
    -0.04833427f, 0.02045291f, 0.14489615f, -0.04963054f, 0.04652945f, -0.11680374f, -0.14854033f, -0.23065285f, 
    0.25464854f, 0.17212045f, 0.02341050f, 0.10974055f, 0.18712297f, 0.04963480f, -0.03106722f, 0.06052527f, 
    -0.09368940f, 0.00093430f, -0.05989223f, -0.09334368f, 0.11220350f, -0.10384165f, 0.11314220f, -0.08959381f, 
    0.06975445f, 0.01334706f, -0.03152110f, -0.06838427f, -0.00827243f, -0.18165424f, -0.15777248f, -0.08849251f, 
    -0.24985076f, 0.09893096f, -0.17351249f, -0.11321267f, 0.13167243f, 0.04519212f, 0.04498981f, 0.12744133f, 
    -0.06159737f, -0.05953617f, -0.02038899f, -0.12001013f, 0.30520090f, 0.20308712f, 0.03508440f, -0.07642247f, 
    0.02707248f, -0.01385226f, 0.06739263f, 0.07517861f, 0.10309947f, -0.04327394f, -0.13497847f, -0.09313323f, 
    0.09772092f, -0.27278271f, 0.22112277f, -0.14973885f, 0.12331437f, -0.13543719f, 0.01442796f, 0.22458641f, 
    -0.01715979f, 0.18787949f, -0.01478702f, 0.28467324f, -0.08991249f, -0.03300687f, -0.07272001f, 0.08155341f, 
    -0.00926001f, -0.00881425f, 0.01139434f, -0.07691827f, 0.13009188f, 0.12936790f, 0.16702561f, 0.07894918f, 
    -0.09527908f, -0.10501090f, 0.00675893f, -0.12391479f, 0.02786128f, 0.00158036f, -0.12099355f, 0.01080603f, 
    -0.06495114f, -0.03827984f, -0.14191817f, 0.12498213f, -0.07469857f, -0.16567445f, -0.09814239f, 0.26663840f, 
    0.11998889f, 0.20376398f, -0.00740089f, -0.13939318f, -0.04890293f, 0.03353595f, 0.04979084f, 0.02486023f, 
    0.18956470f, -0.37414545f, -0.01777590f, -0.21998404f, 0.08888707f, -0.03950312f, -0.00408728f, 0.19131012f, 
    0.04236380f, -0.00954315f, -0.20589593f, -0.20491479f, -0.02588859f, -0.25269565f, 0.28713748f, -0.06383711f, 
    0.15148672f, -0.12897901f, 0.00128665f, -0.05993844f, -0.13942803f, -0.04687511f, -0.00295734f, -0.01007623f, 
    0.16695590f, 0.14462605f, -0.01634367f, -0.15190792f, -0.02032917f, 0.05779479f, 0.03868396f, 0.10936657f, 
    0.07874101f, 0.05018087f, 0.06476567f, 0.10812894f, -0.36535648f, -0.06410959f, 0.01213162f, 0.15962198f, 
    -0.04871360f, 0.01985668f, 0.05081649f, -0.03193708f, 0.06352227f, 0.15205678f, 0.14253797f, 0.03476038f, 
    -0.00373208f, -0.01357162f, -0.03362005f, 0.03240759f, -0.03147280f, 0.03979158f, -0.01944717f, -0.04159334f, 
    -0.04605482f, 0.03197914f, 0.04290686f, -0.04484911f, -0.03831491f, -0.01369208f, 0.01286613f, 0.00827332f, 
    0.01240687f, 0.03741064f, -0.00977334f, 0.01568710f, 0.04066180f, 0.00621903f, -0.00919497f, -0.05041136f, 
    -0.00419782f, 0.04274726f, 0.02674272f, -0.01580796f, -0.04306800f, 0.01092414f, -0.04138348f, 0.02289342f, 
    0.04156502f, -0.03314636f, -0.02047012f, 0.01147929f, -0.05123426f, 0.00830551f, 0.03488177f, -0.00974328f, 
    -0.05224039f, 0.00768835f, 0.04268316f, 0.03761522f, -0.05498602f, -0.05178960f, -0.01331509f, 0.00951211f, 
    -0.03893949f, -0.05056832f, -0.03278184f, 0.00922093f, 0.00177256f, -0.01370549f, -0.03498188f, -0.00561179f, 
    -0.02546630f, -0.02012039f, 0.00403412f, -0.01888554f, -0.04512551f, -0.03582466f, -0.00117669f, -0.00171000f, 
    -0.01572960f, -0.01345696f, -0.01303829f, -0.01112484f, -0.03743544f, -0.03286889f, -0.00257417f, 0.04365576f, 
    0.01073124f, -0.03756620f, -0.01204974f, -0.00404740f, -0.01831063f, -0.00906518f, -0.03902059f, 0.03476837f, 
    0.03969163f, -0.00468930f, 0.01318248f, -0.03073114f, 0.01353746f, 0.04235523f, 0.02204695f, -0.01906795f, 
    -0.05140859f, 0.04399369f, -0.01998134f, -0.04158051f, -0.05585798f, -0.00777744f, -0.04199168f, 0.03999803f, 
    0.04010601f, -0.04555128f, 0.01685365f, 0.02527246f, -0.05389442f, -0.00387661f, 0.04330879f, 0.00782807f, 
    -0.02805507f, 0.02036317f, 0.03983025f, -0.01024194f, 0.00249471f, 0.01541880f, -0.00609936f, -0.01128260f, 
    -0.04690876f, -0.00902570f, 0.04261895f, 0.03164843f, -0.01917319f, 0.00114997f, -0.05094266f, 0.04019301f, 
    0.00433222f, -0.02718186f, 0.03799618f, -0.01921128f, -0.05057730f, 0.00568922f, -0.03379525f, 0.02868615f, 
    0.01474640f, 0.03776254f, 0.01630335f, -0.02347897f, -0.04954797f, 0.03082801f, 0.02623623f, -0.05035661f, 
    -0.03294462f, -0.03372982f, 0.02460417f, 0.02607152f, 0.01190652f, 0.02090671f, 0.04526423f, 0.00393849f, 
    -0.00751110f, 0.04382172f, 0.04435280f, 0.03452229f, 0.03085135f, -0.00491784f, 0.00251963f, 0.03827602f, 
    -0.02695647f, 0.00086226f, 0.02720537f, -0.02471684f, -0.01852374f, 0.04542426f, -0.04989995f, 0.01769040f, 
    -0.02169164f, 0.03133104f, -0.03915074f, 0.02648050f, 0.04312444f, 0.03572460f, -0.00080527f, -0.00005844f, 
    -0.02729031f, -0.00138968f, 0.03114076f, 0.00568810f, 0.01441646f, -0.00818220f, -0.05184272f, -0.02423912f, 
    -0.05371630f, 0.00434675f, 0.00409749f, -0.01827495f, 0.03463315f, -0.01850009f, -0.01318049f, -0.04505573f, 
    0.00519701f, -0.02963694f, 0.00052229f, -0.00440796f, -0.03945250f, 0.03947116f, 0.02366830f, 0.02911892f, 
    -0.02434064f, -0.01343614f, -0.00080465f, -0.00862921f, -0.01822472f, -0.04270716f, -0.03877105f, 0.03647629f, 
    -0.03117632f, -0.05173114f, -0.00465698f, 0.00825481f, 0.03370346f, 0.00471894f, -0.02491301f, 0.02859228f, 
    0.03575681f, -0.01391901f, -0.00642003f, -0.02439007f, -0.02149541f, -0.00516674f, -0.01517918f, 0.01748940f, 
    -0.03136288f, -0.01316704f, -0.00291331f, -0.00427825f, -0.03834213f, 0.00985515f, -0.04624905f, -0.05581219f, 
    0.01527413f, 0.04112529f, 0.01268807f, 0.02675066f, 0.02525593f, -0.01515427f, -0.00314554f, 0.04445751f, 
    -0.02654851f, 0.04189547f, 0.01693944f, 0.04271941f, 0.00694037f, -0.01733457f, 0.03910660f, -0.05215352f, 
    -0.00160625f, 0.02935684f, -0.01470516f, 0.00502488f, -0.04247764f, -0.03446753f, 0.01981264f, 0.00786020f, 
    0.00695047f, -0.02444648f, -0.04382611f, -0.00546515f, 0.03841280f, 0.04034602f, -0.01521182f, 0.01566210f, 
    -0.03140630f, 0.01058136f, 0.01948285f, -0.05340532f, -0.00480493f, 0.03006030f, -0.02988850f, -0.00363749f, 
    0.04020795f, -0.04348965f, 0.01802979f, -0.02588428f, -0.01847921f, -0.04331999f, -0.03053130f, -0.02618821f, 
    -0.05567632f, -0.03906586f, -0.05462745f, 0.01079135f, -0.02705267f, 0.04549666f, 0.04102724f, -0.00897584f, 
    -0.02675690f, 0.03528088f, 0.00804114f, -0.00140757f, 0.04113995f, -0.03671353f, -0.03457572f, 0.03059024f, 
    -0.02111809f, -0.01922242f, -0.03514391f, 0.03590698f, -0.01767548f, -0.01350505f, -0.02125211f, -0.04432734f, 
    -0.03322039f, 0.01899841f, -0.01963709f, -0.02547341f, 0.03859511f, -0.04144709f, -0.01004912f, -0.04283335f, 
    0.00157022f, 0.00305787f, -0.04804647f, -0.00494395f, 0.03760520f, 0.02672708f, -0.04773057f, -0.03183820f, 
    -0.03389089f, 0.02477241f, -0.02875199f, -0.04636580f, 0.02451934f, 0.00952602f, 0.00301758f, -0.01247361f, 
    -0.02121218f, 0.00358584f, 0.04302469f, 0.01049405f, 0.04346520f, 0.04421993f, -0.03118703f, -0.00669642f, 
    -0.01704622f, 0.00093831f, 0.03193835f, 0.03553307f, 0.01053467f, -0.01861399f, 0.01410232f, -0.03531523f, 
    -0.00583584f, 0.02550138f, -0.05331617f, -0.02193778f, -0.00303393f, -0.00158821f, 0.02829331f, -0.04535254f, 
    0.00370445f, -0.03018008f, -0.04834707f, -0.01378547f, -0.03211419f, -0.00028154f, -0.05283095f, 0.02459337f, 
    0.01572163f, -0.02264858f, 0.04204320f, -0.01846635f, 0.04282759f, -0.00473318f, -0.05202529f, -0.02829510f, 
    -0.02277985f, 0.00156362f, -0.00069424f, -0.02425874f, -0.01408562f, -0.01134412f, 0.00615994f, -0.01616137f, 
    -0.00879991f, -0.04066272f, 0.03555033f, -0.04662040f, -0.03911250f, -0.05034607f, -0.01324239f, -0.03059184f, 
    0.01058077f, -0.03063282f, 0.00734972f, -0.02511972f, -0.02816410f, -0.00864083f, -0.01557829f, -0.04660243f, 
    -0.05891393f, 0.05008512f, 0.08161256f, 0.01569145f, 0.16479142f, 0.04028870f, 0.02673471f, 0.02540319f, 
    -0.05215923f, 0.03228729f, 0.01644808f, -0.02646289f, -0.11772128f, 0.02519441f, -0.10972196f, -0.18980947f, 
    -0.08458598f, 0.06959373f, 0.04415442f, -0.03813991f, -0.00100081f, 0.03020964f, -0.00594950f, -0.04395980f, 
    -0.13983904f, -0.17741559f, -0.16969936f, -0.08863389f, 0.00876745f, 0.07295963f, -0.06166426f, 0.08486374f, 
    0.03468211f, 0.12579069f, 0.03186775f, 0.14387015f, 0.01430559f, -0.02291707f, -0.07107466f, 0.06497319f, 
    0.11535126f, -0.17925011f, -0.07909632f, -0.03807237f, -0.03800207f, -0.03859814f, 0.15002334f, 0.06371983f, 
    -0.08330831f, 0.07099225f, 0.09778507f, 0.03839991f, 0.01293312f, -0.01655651f, -0.02215044f, -0.10281246f, 
    0.11784879f, 0.01894871f, 0.11825017f, 0.03543499f, 0.27608237f, 0.07001988f, -0.11053994f, -0.11685169f, 
    0.01888429f, -0.03296087f, 0.00993274f, -0.01460946f, 0.01496184f, 0.25106567f, -0.16561577f, 0.06000508f, 
    0.07539175f, 0.00160950f, -0.04739704f, -0.00879128f, 0.10964277f, 0.18942721f, -0.01820276f, 0.11955690f, 
    -0.04294759f, -0.03118006f, -0.01608565f, 0.06545643f, -0.15188661f, -0.01624909f, -0.16486511f, -0.02961686f, 
    0.04368021f, 0.08635756f, -0.00422453f, 0.21312673f, -0.18008325f, 0.07141194f, -0.04383368f, 0.04511409f, 
    0.32754034f, -0.20969065f, 0.07676271f, -0.18434021f, 0.11196870f, 0.13929854f, -0.07782868f, -0.02407932f, 
    -0.08904209f, -0.08150559f, 0.08693626f, -0.05214732f, -0.03653733f, 0.12002849f, 0.15589422f, 0.04096042f, 
    0.08246648f, -0.05942886f, 0.05577957f, -0.03751824f, -0.04037353f, 0.08614436f, 0.03229821f, 0.01344957f, 
    0.19799967f, 0.04702876f, -0.02306661f, 0.03508248f, 0.02184627f, 0.10555089f, 0.02254449f, 0.07159313f, 
    0.08735565f, -0.05652167f, -0.13692030f, -0.07574750f, -0.06041681f, -0.13141043f, 0.04542310f, -0.31365991f, 
    -0.12221996f, 0.00361847f, -0.04941738f, -0.03973899f, 0.01567377f, -0.06728255f, -0.04114792f, 0.01313971f, 
    0.18582934f, 0.07332510f, -0.03481511f, -0.33278167f, -0.03242446f, -0.02248528f, -0.00684851f, 0.03039042f, 
    0.02829602f, -0.00842388f, 0.14786144f, 0.08481298f, -0.21640973f, -0.07435474f, 0.25586271f, 0.12914264f, 
    -0.05162020f, -0.17258951f, 0.10836807f, -0.07236858f, -0.05397619f, 0.08398908f, 0.17911631f, 0.10092909f, 
    0.02189078f, 0.04446509f, 0.21021327f, -0.08455434f, -0.11191432f, -0.01061269f, 0.01417004f, -0.06263636f, 
    -0.05368862f, 0.13186756f, -0.16130880f, 0.21041179f, -0.03392390f, -0.22563908f, -0.16667403f, -0.08211965f, 
    0.08800383f, 0.18452585f, 0.23349902f, 0.07115189f, -0.05235619f, -0.14397013f, 0.00235880f, -0.06569567f, 
    0.15328003f, -0.09395783f, 0.06807961f, 0.12041280f, -0.10867607f, 0.04148281f, -0.02446931f, -0.15318197f, 
    0.09859207f, 0.03546844f, 0.01641112f, 0.02851852f, 0.04120721f, 0.22652282f, -0.09103527f, 0.25501457f, 
    0.04548419f, -0.03425086f, 0.08426162f, 0.01401353f, 0.04261755f, 0.04273408f, -0.00546764f, -0.06563666f, 
    0.15157011f, 0.17080586f, -0.07246874f, -0.06212458f, 0.22169389f, 0.24150011f, 0.28519985f, 0.12904923f, 
    0.06858077f, 0.03408906f, 0.08425599f, -0.04766506f, -0.09581650f, 0.13619736f, -0.07061516f, -0.20474595f, 
    0.06002736f, 0.05669999f, -0.09611376f, 0.12203325f, -0.02390702f, -0.13468935f, 0.07482826f, 0.07289928f, 
    -0.17213620f, 0.43124503f, 0.01707465f, -0.00166978f, 0.01378120f, -0.18523592f, 0.03347373f, -0.05861382f, 
    -0.07364213f, 0.01236488f, -0.04462628f, 0.01609896f, -0.01372422f, 0.04961170f, -0.04300391f, 0.11187404f, 
    0.13668841f, -0.08400535f, 0.00234223f, 0.01629558f, 0.09584429f, 0.09822037f, -0.05095284f, 0.03440062f, 
    -0.06210343f, -0.02448608f, -0.02973707f, 0.10136724f, 0.01767384f, 0.01571186f, -0.01348843f, -0.09982494f, 
    0.14884156f, 0.07586231f, -0.10293791f, -0.01745115f, 0.00569255f, -0.00194545f, -0.18411353f, -0.14280999f, 
    -0.09014553f, 0.01436979f, 0.00780006f, 0.01051427f, -0.18077242f, -0.03396440f, 0.08158002f, -0.07751382f, 
    0.37294140f, -0.13874069f, -0.04958450f, -0.08149269f, -0.00548437f, 0.07521560f, 0.01722388f, -0.16060156f, 
    0.13138518f, -0.19075851f, 0.12513700f, 0.03094706f, -0.00913111f, 0.00066233f, 0.20509173f, 0.02546930f, 
    0.04109508f, -0.03736182f, -0.08822837f, 0.05962710f, -0.07419795f, 0.03942930f, -0.04331787f, 0.01727946f, 
    0.15708782f, 0.00070149f, 0.00198131f, 0.29317400f, 0.02755351f, -0.00725581f, 0.06955685f, -0.00828056f, 
    0.30689242f, 0.02133994f, 0.22950435f, -0.10976224f, 0.03180865f, 0.20578469f, 0.13227880f, 0.01521080f, 
    0.10552497f, 0.04117489f, 0.01649490f, -0.06657855f, 0.06501227f, -0.05936534f, -0.04511392f, 0.13966194f, 
    -0.02259728f, 0.07522131f, -0.11129554f, -0.07990081f, 0.07863113f, -0.08120767f, 0.07815512f, -0.27589321f, 
    -0.11233599f, -0.00400135f, -0.00540590f, -0.03251356f, 0.39432108f, -0.01087838f, 0.02935847f, 0.00446537f, 
    -0.12410821f, 0.01732440f, 0.05488701f, -0.08201510f, 0.08927479f, 0.02297988f, -0.00791061f, -0.03959531f, 
    0.38831046f, 0.26380667f, -0.18774503f, 0.12137907f, -0.00435638f, 0.09254985f, -0.03113674f, 0.03560985f, 
    -0.03410691f, -0.10091712f, 0.05897231f, -0.00360458f, -0.10421491f, 0.29607543f, 0.19743496f, 0.05151042f, 
    -0.07500422f, -0.04225080f, 0.01866511f, -0.05836311f, 0.18446204f, 0.00297325f, 0.01217214f, 0.10828492f, 
    0.06692318f, 0.11887975f, 0.04018583f, -0.00558900f, -0.03180324f, -0.00459213f, 0.03433689f, 0.07117964f, 
    0.02971901f, 0.06604549f, -0.09577853f, -0.09431785f, 0.35325706f, -0.10745511f, 0.02343229f, -0.01689715f, 
    0.16191429f, 0.12426268f, 0.02378905f, -0.06228863f, 0.05434530f, 0.15390550f, 0.05825649f, -0.10477715f, 
    0.19112256f, -0.38770846f, 0.49141693f, -0.18087292f, 0.02364731f, 0.15483117f, -0.04348404f, 0.14758189f, 
    -0.11008441f, -0.06925925f, 0.00559307f, 0.01339825f, 0.16332826f, -0.02380584f, 0.08141277f, -0.16689421f, 
    0.04302068f, -0.00044723f, -0.03589988f, 0.01871938f, -0.06976566f, -0.16828318f, -0.04202368f, 0.07859329f, 
    -0.00717787f, -0.02694622f, -0.07427559f, -0.19859195f, -0.12074439f, 0.04659573f, 0.15933983f, 0.10195078f, 
    0.07841006f, 0.13737059f, 0.12610349f, 0.11645944f, -0.17956141f, 0.20228560f, -0.06971554f, 0.46925071f, 
    -0.12848918f, 0.04059143f, -0.01230305f, 0.18735898f, -0.16121580f, 0.02865476f, 0.01472801f, -0.03454057f, 
    0.18037012f, -0.18492290f, -0.08789944f, 0.16602412f, -0.04230764f, -0.02986003f, 0.04042169f, 0.02644603f, 
    0.05240212f, 0.03915860f, 0.05092350f, -0.02208851f, 0.07115043f, 0.09833661f, 0.08647554f, 0.14456052f, 
    0.09817880f, 0.10975482f, 0.03964467f, -0.12438631f, -0.05755422f, 0.00742836f, 0.00039865f, -0.04198889f, 
    -0.04446899f, 0.16843717f, -0.03519469f, 0.36856869f, 0.01517989f, -0.09506084f, 0.17017776f, -0.04943320f, 
    -0.18929389f, -0.02198927f, -0.03042495f, 0.07975804f, 0.05348817f, -0.05965246f, -0.08765618f, 0.09075971f, 
    -0.21998146f, 0.11885885f, -0.05946130f, 0.08560558f, -0.11266286f, 0.07896419f, 0.06771241f, 0.04927106f, 
    0.22594218f, -0.08423645f, -0.00321246f, 0.09075183f, 0.16593412f, 0.02907509f, 0.04731167f, -0.05312724f, 
    -0.06339965f, 0.15154427f, -0.03786812f, 0.17523015f, -0.08664881f, 0.12666689f, 0.38307914f, 0.02505989f, 
    -0.11756231f, 0.00811557f, 0.14341471f, -0.07927658f, -0.01312742f, -0.11082084f, -0.03750167f, 0.04103076f, 
    -0.09848251f, -0.17005961f, -0.13674352f, 0.13215826f, -0.10956214f, -0.11239745f, 0.04135840f, 0.03254554f, 
    -0.12293417f, -0.01358343f, 0.01104630f, -0.10430323f, 0.17324132f, -0.15694264f, 0.05153877f, 0.03780044f, 
    -0.05082005f, 0.15315755f, -0.16630492f, -0.01132861f, -0.18670297f, 0.02527734f, 0.22223109f, 0.12939395f, 
    -0.09185781f, 0.23653232f, -0.18278818f, 0.15676831f, 0.13198175f, 0.10776237f, -0.15092425f, -0.06488474f, 
    -0.13305373f, 0.10549862f, 0.08230701f, -0.02313734f, -0.06585246f, -0.05119108f, 0.13145915f, 0.07016574f, 
    0.05577150f, -0.02553200f, 0.03501330f, 0.01373677f, -0.00180897f, 0.04235059f, -0.04389308f, -0.08262517f, 
    -0.21970779f, 0.13405608f, -0.00846046f, -0.13866903f, -0.02885971f, -0.07621945f, -0.02601862f, 0.06661392f, 
    -0.11753896f, -0.05993044f, -0.03407671f, 0.09375314f, -0.17967178f, 0.12916890f, 0.00709703f, -0.34168005f, 
    -0.05667646f, 0.11671589f, 0.09523954f, -0.08301733f, -0.14829074f, -0.18433681f, -0.01815626f, -0.05313402f, 
    0.02485619f, -0.02373804f, -0.10512845f, -0.01821639f, 0.14929917f, -0.07742929f, 0.06480785f, -0.10850625f, 
    -0.06074749f, 0.01079089f, 0.13171485f, -0.01450248f, 0.02784313f, -0.19567475f, 0.34061956f, 0.02233000f, 
    0.10181937f, 0.07952607f, 0.10535765f, 0.02855827f, -0.00247055f, 0.11663833f, 0.02110564f, 0.02634710f, 
    0.18354841f, -0.07481423f, 0.24465375f, -0.08812108f, -0.18064967f, 0.04765288f, -0.00818244f, 0.04504926f, 
    -0.02563309f, -0.06517352f, -0.02795563f, 0.03148571f, -0.03277796f, 0.05408880f, 0.09003128f, -0.20505393f, 
    0.07692423f, 0.11686636f, 0.03833098f, 0.11849693f, 0.06776059f, -0.13446163f, 0.00724513f, -0.12891370f, 
    -0.02775787f, -0.04332306f, 0.20066147f, -0.09700868f, -0.19044811f, 0.10078418f, 0.19561712f, -0.00392435f, 
    -0.00244055f, 0.04060692f, -0.16060625f, -0.01606197f, 0.01599235f, -0.17605948f, -0.00467609f, -0.01899292f, 
    0.06530648f, -0.09045675f, 0.02151712f, 0.03617806f, -0.05718224f, -0.02325381f, -0.09608853f, -0.05853669f, 
    -0.25629228f, 0.53000957f, -0.33235326f, 0.25224274f, -0.06805643f, 0.10030565f, -0.02264812f, 0.04344425f, 
    0.17175144f, 0.20341603f, 0.05375910f, 0.16889042f, -0.20261212f, 0.20801386f, -0.26620159f, 0.03698146f, 
    -0.12064070f, -0.06725319f, 0.06141971f, -0.04130815f, -0.01576391f, 0.08820909f, -0.14412893f, 0.01285205f, 
    0.15134528f, 0.10584743f, -0.00060904f, -0.13836166f, 0.23837209f, 0.02683018f, 0.02113588f, -0.01049699f, 
    0.04296426f, -0.07111840f, 0.11220372f, -0.09883453f, 0.06419636f, 0.00321539f, -0.04235033f, -0.12620375f, 
    -0.07988749f, 0.05302954f, 0.06297134f, 0.03541980f, -0.06358688f, 0.11199270f, -0.02476336f, 0.12178447f, 
    0.11871404f, 0.25206107f, -0.26261333f, 0.24123560f, -0.00546207f, 0.01419190f, -0.07843180f, 0.12676358f, 
    -0.16741401f, 0.07288972f, -0.10267249f, -0.12724994f, -0.29774189f, 0.39318538f, -0.19558278f, 0.02638882f, 
    0.08336950f, 0.10212345f, -0.04163206f, -0.04752410f, -0.04545394f, -0.04151665f, 0.01589036f, 0.03656368f, 
    0.05505245f, -0.02034359f, -0.20681584f, 0.23367919f, 0.05353503f, -0.00945181f, -0.03574623f, -0.07092666f, 
    -0.10609168f, -0.03000281f, -0.05378046f, 0.07128886f, 0.23410827f, -0.12643436f, 0.01761989f, -0.36885825f, 
    -0.06910554f, -0.06109883f, 0.04432512f, 0.00386054f, 0.08919588f, 0.01017184f, -0.03036502f, 0.03463270f, 
    -0.01955897f, -0.00441150f, -0.03059269f, -0.01496614f, -0.03465480f, 0.02193846f, 0.01004684f, -0.00549641f, 
    -0.04400133f, 0.00926561f, -0.05508737f, -0.00627172f, 0.00492260f, -0.03996957f, 0.01322586f, 0.01467935f, 
    -0.04679220f, 0.03831015f, -0.01716315f, 0.01180781f, 0.00300674f, -0.01005129f, 0.00478838f, 0.02858440f, 
    -0.00901142f, -0.00811336f, -0.02883476f, -0.00892471f, -0.02936586f, 0.01530323f, 0.01526826f, -0.04487656f, 
    -0.01746440f, -0.00269147f, -0.03799952f, -0.04476524f, -0.03430973f, 0.00753044f, 0.01824903f, -0.01224410f, 
    -0.00139267f, -0.04660654f, 0.02086064f, -0.04922055f, 0.02810792f, -0.02379782f, -0.00988606f, -0.00427740f, 
    0.02649112f, -0.00664763f, 0.01829295f, 0.01881745f, -0.05282525f, -0.05153706f, 0.00880133f, -0.03688490f, 
    -0.01016993f, 0.03798150f, -0.03871050f, -0.01459662f, -0.01931095f, 0.03481013f, 0.03413394f, 0.02878232f, 
    -0.03338558f, -0.05212093f, -0.04180561f, 0.02926278f, -0.05002045f, -0.04278653f, -0.01962200f, 0.02705970f, 
    0.04379676f, -0.00409602f, -0.04991716f, 0.02267469f, 0.04812029f, -0.02007223f, -0.01070035f, -0.03279609f, 
    -0.04344950f, -0.02584342f, 0.03981590f, -0.01762530f, 0.03336915f, -0.00840328f, 0.00660763f, 0.02046171f, 
    0.00176081f, -0.00223315f, 0.00549514f, -0.04748644f, -0.05472012f, -0.01008401f, 0.00566759f, -0.02194651f, 
    0.01844357f, -0.05341058f, -0.01546867f, -0.00730129f, 0.00709691f, -0.00474083f, 0.01145363f, 0.02181665f, 
    0.02825999f, 0.00083335f, 0.02709058f, -0.03615532f, 0.03635756f, -0.01514468f, -0.05152640f, -0.01446254f, 
    -0.04641030f, -0.02604539f, -0.04461943f, 0.00732244f, -0.04106840f, -0.00111170f, 0.01111650f, 0.01630393f, 
    -0.02090983f, 0.02514332f, -0.00075506f, -0.00694223f, -0.04135104f, 0.04062185f, -0.01361399f, 0.03241278f, 
    -0.02724404f, 0.02426057f, -0.01651294f, 0.03893639f, 0.03350799f, -0.05463782f, 0.03510600f, -0.03352485f, 
    -0.01500327f, 0.02829724f, 0.02789733f, -0.01992152f, 0.03924403f, -0.00949867f, 0.04456245f, 0.02643023f, 
    0.00622354f, 0.02365178f, 0.03710480f, -0.04613244f, -0.02924526f, 0.00096997f, 0.00771444f, -0.05407000f, 
    -0.01483196f, 0.01600216f, -0.02777559f, 0.00568893f, -0.01625665f, -0.01921434f, 0.01142266f, 0.04148046f, 
    -0.03969243f, 0.04121073f, -0.02690777f, -0.00280851f, 0.04107608f, 0.02693832f, 0.03573330f, 0.03536440f, 
    -0.04875799f, 0.02444008f, -0.02503389f, -0.03454138f, 0.01246473f, 0.01635979f, 0.02510216f, -0.02746893f, 
    0.00692377f, 0.02651503f, 0.02175873f, 0.00765522f, 0.02462287f, -0.00022247f, -0.03362055f, 0.02398119f, 
    -0.01691401f, 0.01023002f, -0.02030045f, -0.04156086f, -0.06061771f, -0.00464196f, -0.00230904f, 0.02692870f, 
    -0.04707690f, -0.04942553f, 0.03946101f, 0.03876551f, -0.01643709f, 0.00604078f, -0.01619354f, -0.03125634f, 
    -0.02813378f, -0.00948881f, 0.00212325f, -0.00135140f, -0.03824638f, -0.00519386f, -0.01546979f, 0.04052157f, 
    -0.02861585f, -0.01628580f, -0.01671254f, -0.00882449f, -0.04048819f, 0.03937307f, -0.04244962f, 0.03979690f, 
    0.02349431f, -0.03129556f, 0.03086979f, -0.03706336f, 0.02145366f, 0.03686541f, -0.01946104f, 0.00715491f, 
    0.02578473f, 0.03716284f, 0.00439884f, 0.00331214f, -0.04214373f, -0.01590364f, -0.03818942f, -0.02795845f, 
    -0.03827170f, -0.01099230f, 0.01329167f, -0.00821314f, 0.00946961f, -0.01908651f, 0.02451675f, -0.02050573f, 
    -0.01621283f, 0.03093819f, -0.00635487f, -0.02719594f, 0.00502665f, 0.02097463f, 0.01683889f, -0.05072521f, 
    0.02151376f, -0.04829704f, -0.03162363f, 0.03163676f, 0.02798143f, -0.03564679f, 0.00164553f, 0.00593423f, 
    -0.05932612f, 0.02484254f, 0.00840413f, 0.04260687f, -0.04857556f, -0.04456175f, -0.04151648f, -0.04269220f, 
    0.00442206f, 0.03758204f, 0.01160817f, 0.03444362f, -0.05673029f, -0.02155767f, 0.03290457f, -0.00421572f, 
    0.03454000f, 0.01951811f, -0.01642927f, -0.04304602f, 0.02632959f, -0.01262616f, 0.03847688f, 0.02326642f, 
    0.04398986f, 0.01630679f, 0.01072634f, 0.00841272f, -0.05720881f, 0.03304122f, -0.01816329f, -0.05067457f, 
    0.02651291f, -0.00804686f, 0.01476730f, -0.05017976f, 0.02899147f, 0.02710302f, -0.00862128f, 0.02059795f, 
    -0.01206492f, 0.00938868f, -0.04858098f, 0.03638862f, -0.00440306f, 0.00173814f, -0.04412847f, 0.02110576f, 
    -0.00507649f, 0.00933763f, 0.00793513f, -0.02770336f, 0.00582870f, -0.02384880f, -0.01960281f, 0.03941490f, 
    0.01247908f, -0.01242363f, -0.02193428f, -0.04263772f, 0.03414313f, -0.03118043f, -0.04769028f, 0.02192101f, 
    -0.04264914f, -0.00974677f, 0.01812976f, 0.00162740f, 0.03541741f, -0.04339035f, -0.04569828f, 0.00605670f, 
    0.02453218f, -0.02580743f, -0.00710563f, 0.00106008f, 0.01807701f, -0.01472531f, -0.01450080f, 0.02024438f, 
    -0.05420538f, -0.01482178f, 0.00694199f, -0.03078437f, -0.04501166f, -0.04426143f, 0.02659604f, -0.00043498f, 
    -0.03567378f, -0.00632597f, -0.04179551f, 0.03075555f, 0.01433748f, 0.01608474f, 0.01641423f, 0.01844429f, 
    -0.02368499f, -0.02146154f, -0.04278982f, -0.04278100f, -0.00109756f, 0.02520502f, 0.02958887f, -0.04449020f, 
    -0.02746544f, 0.03209075f, 0.03489058f, -0.03891976f, -0.00896678f, -0.02384686f, -0.00067209f, 0.00251203f, 
    -0.05636697f, 0.03386978f, -0.00564953f, -0.00711983f, 0.02899801f, -0.03060631f, 0.03955120f, -0.05568169f, 
    -0.04532825f, 0.01925775f, 0.04406081f, -0.01250168f, -0.03597246f, -0.00643104f, -0.03098725f, -0.02991427f, 
    0.02910255f, 0.02057364f, -0.03996357f, 0.05304088f, 0.18575834f, 0.08642398f, 0.16905963f, 0.02220923f, 
    0.12585519f, 0.04799151f, 0.02743713f, 0.12500414f, -0.35468349f, -0.17747760f, 0.04630111f, -0.07833596f, 
    0.01101850f, -0.09437308f, 0.03892540f, -0.02546853f, 0.05477203f, -0.07354859f, 0.05236642f, -0.03266872f, 
    -0.11428766f, 0.46766239f, 0.10859699f, 0.22566234f, 0.06293090f, 0.02472101f, 0.09125773f, 0.24585174f, 
    -0.04608458f, 0.06289837f, 0.20716023f, -0.03540008f, -0.07796098f, 0.01250813f, 0.02850972f, 0.03626543f, 
    0.11767727f, 0.01652518f, -0.02410047f, 0.03314085f, 0.13526233f, 0.15945502f, 0.15256156f, 0.07153074f, 
    0.00506330f, -0.04117183f, 0.05693692f, -0.07472631f, 0.08036079f, 0.00377061f, 0.06403028f, 0.00424342f, 
    -0.00870459f, -0.05244898f, 0.01369318f, 0.03296502f, 0.04587932f, -0.23725061f, 0.59513551f, -0.02782256f, 
    0.04568493f, 0.14111090f, -0.01191189f, -0.05658893f, 0.08614487f, 0.06446791f, 0.16026853f, 0.16091910f, 
    -0.02865277f, -0.01024794f, 0.00667872f, 0.02563109f, 0.00914605f, -0.04727369f, 0.04174666f, 0.02703307f, 
    0.06204868f, 0.17021650f, 0.07622069f, 0.01997432f, -0.25360557f, -0.05433964f, 0.15827027f, 0.09284440f, 
    -0.19314480f, 0.10204292f, -0.00332726f, -0.03579864f, 0.03802342f, 0.10477347f, 0.08013030f, 0.04079952f, 
    -0.06142513f, -0.13151149f, -0.31384957f, 0.09298987f, -0.00614657f, -0.01415093f, 0.08380790f, 0.16735950f, 
    0.04556319f, 0.09522319f, -0.03238736f, -0.04450450f, -0.02087486f, 0.11269388f, -0.12591198f, 0.03354024f, 
    0.07456172f, -0.03359142f, 0.05321790f, 0.03144727f, 0.01513306f, -0.04617165f, 0.07913249f, -0.04086031f, 
    -0.18841973f, -0.00648804f, -0.04054096f, -0.09394050f, 0.03817593f, -0.04329331f, -0.07688986f, -0.01910014f, 
    0.00222083f, -0.09925941f, -0.05266356f, -0.16567382f, -0.07300772f, -0.07718182f, -0.08878914f, 0.32074279f, 
    0.18677010f, 0.31061387f, 0.07410440f, 0.04376961f, -0.05650971f, -0.07545039f, -0.02165145f, -0.10163524f, 
    -0.00824362f, 0.07659426f, 0.11590514f, 0.18879995f, 0.01349666f, -0.01042934f, -0.01708237f, -0.08352993f, 
    0.11309285f, 0.11640145f, 0.11659389f, 0.02543256f, -0.17145646f, 0.28333488f, -0.00889320f, 0.02050594f, 
    -0.01834559f, 0.10598523f, -0.00707391f, 0.02867599f, 0.00722759f, 0.08479213f, 0.09312900f, 0.00361988f, 
    0.23040873f, -0.02271714f, -0.05557557f, 0.00977483f, 0.00586636f, -0.02205282f, -0.05467586f, 0.13396497f, 
    0.12091598f, 0.11333412f, 0.13054256f, 0.26534799f, -0.02487265f, -0.10552315f, -0.09123869f, -0.06440410f, 
    -0.08297585f, 0.03974747f, -0.02357541f, 0.18071190f, 0.02367668f, -0.03380784f, 0.01572355f, 0.02509541f, 
    -0.07090137f, -0.07089293f, 0.07393900f, -0.04007027f, 0.01445166f, 0.07247455f, 0.02081924f, -0.01382630f, 
    0.01877725f, 0.00626845f, -0.08852241f, 0.10684980f, -0.07711885f, 0.01926149f, 0.30266023f, -0.04477656f, 
    0.02293952f, 0.04761139f, 0.04197278f, -0.06448727f, -0.02369240f, -0.06263802f, 0.02405136f, 0.09735305f, 
    -0.10994101f, -0.21929634f, -0.00849125f, 0.04843950f, -0.01867626f, -0.04362093f, 0.11380737f, 0.15482998f, 
    0.21974713f, 0.05026571f, 0.09454168f, 0.17540637f, 0.10407984f, 0.20031342f, -0.09090099f, 0.18233076f, 
    0.11940070f, 0.05972634f, 0.14825788f, 0.02631047f, -0.02613624f, 0.10793098f, 0.09474123f, 0.01488071f, 
    0.28718975f, -0.03061635f, -0.10897310f, 0.12324082f, 0.13437119f, 0.07591174f, 0.09886755f, 0.00617519f, 
    -0.08234951f, 0.00845537f, -0.08834067f, 0.00929629f, 0.14824976f, -0.09262381f, 0.16290189f, 0.02912882f, 
    0.24638627f, 0.00748097f, 0.15458134f, 0.03402048f, 0.01736629f, 0.01750498f, 0.08456439f, 0.23629010f, 
    -0.14995250f, 0.07419498f, -0.03034205f, -0.04532157f, 0.15060814f, 0.26983291f, 0.13438867f, 0.12154359f, 
    0.00140179f, 0.04397028f, 0.01195388f, 0.11797412f, 0.04284760f, 0.09349760f, 0.21197933f, 0.11059237f, 
    -0.00655896f, 0.07009847f, 0.01487476f, 0.05619374f, -0.01901137f, 0.05597222f, 0.07953459f, -0.00577026f, 
    -0.10572276f, -0.07987140f, 0.08613732f, 0.01282196f, 0.09227338f, 0.00203620f, 0.09376220f, 0.04968991f, 
    -0.13906555f, -0.10602425f, -0.09556874f, -0.11186070f, 0.06433758f, -0.05261263f, -0.07999720f, 0.07121824f, 
    -0.02708388f, -0.00238574f, 0.05567165f, 0.04708372f, 0.08519374f, -0.00754764f, 0.05495474f, -0.02358096f, 
    -0.00168474f, 0.11309671f, 0.17689490f, -0.10611805f, 0.02524718f, -0.05372849f, -0.10804719f, 0.02909444f, 
    -0.01451548f, 0.04974204f, -0.00711534f, 0.16610166f, 0.17507337f, 0.03980481f, -0.04891833f, 0.00085219f, 
    0.13583136f, 0.04283315f, 0.04770163f, 0.00951834f, 0.09191103f, 0.04253813f, 0.16938548f, -0.04932345f, 
    0.18836837f, -0.08061092f, -0.08654691f, -0.04104640f, 0.22578898f, 0.12652667f, 0.08454078f, 0.14346591f, 
    0.05837426f, 0.08560759f, 0.03255671f, 0.08885172f, 0.07408621f, -0.31283456f, 0.14947709f, -0.03230121f, 
    0.02026740f, -0.02004679f, -0.10714348f, 0.09469374f, 0.07745994f, -0.02362345f, -0.01729339f, 0.10071176f, 
    -0.09654944f, -0.08667676f, 0.14953923f, -0.11135627f, -0.14438705f, -0.07415490f, -0.07542969f, -0.14897794f, 
    0.05564035f, 0.06674665f, 0.08086971f, -0.02195689f, 0.27512488f, -0.06954765f, -0.24007276f, 0.05353219f, 
    -0.04275389f, -0.00544798f, -0.08790093f, 0.07865743f, 0.08098279f, 0.05009107f, 0.04218191f, -0.10648043f, 
    -0.07158492f, -0.26622301f, -0.11516954f, -0.09368462f, -0.25201094f, -0.02228495f, -0.16556294f, 0.01037443f, 
    0.05200750f, -0.13544564f, -0.16810524f, -0.22012782f, 0.29702362f, 0.18147565f, 0.18793643f, 0.11965922f, 
    0.15178449f, 0.04369406f, 0.00853710f, 0.22155525f, -0.06321049f, 0.03065271f, 0.08880913f, 0.09704806f, 
    0.10530123f, -0.01775911f, 0.13614115f, -0.07087350f, 0.13169312f, 0.06960738f, 0.07278637f, -0.14770889f, 
    -0.00255309f, -0.08789480f, -0.04242664f, -0.03562965f, 0.01757752f, 0.02437224f, -0.00730946f, -0.04905300f, 
    0.08698147f, 0.06437905f, -0.19154966f, -0.18378575f, -0.19581959f, -0.26459110f, -0.25194165f, -0.17061183f, 
    -0.11313280f, -0.18180469f, -0.23093456f, -0.10645790f, -0.23993440f, 0.06364348f, 0.10886355f, -0.02310185f, 
    0.05325972f, 0.04031256f, 0.01651288f, 0.04464346f, -0.48867619f, 0.41245520f, -0.07737541f, 0.10354016f, 
    -0.13935828f, -0.10981457f, 0.04881698f, -0.02544053f, -0.00074862f, 0.01582720f, 0.14547956f, 0.00326792f, 
    0.05911781f, -0.00164548f, -0.15579569f, -0.05464415f, 0.09220383f, -0.11245189f, 0.08122960f, -0.00286467f, 
    0.03227325f, -0.07367571f, 0.13920869f, 0.05407934f, 0.20129885f, -0.03546903f, 0.23383752f, 0.03086189f, 
    0.02602778f, -0.08875579f, -0.00044224f, 0.01538663f, 0.22327517f, -0.01387504f, 0.25473869f, -0.03347467f, 
    -0.20097086f, -0.03249227f, -0.00551741f, 0.18849301f, -0.02179808f, 0.09977193f, 0.02579344f, -0.11001587f, 
    -0.04563311f, -0.08275971f, -0.14937592f, 0.22125600f, -0.18265232f, -0.06180203f, 0.11762282f, -0.06027982f, 
    -0.16816209f, 0.00191694f, -0.14503762f, -0.08220015f, -0.02332348f, -0.07004396f, 0.09097668f, 0.02562663f, 
    -0.03313354f, 0.07874270f, 0.06220102f, 0.06214756f, 0.07256594f, 0.02408866f, 0.10669041f, 0.07342726f, 
    0.05203468f, 0.20079780f, 0.07764682f, 0.22593756f, -0.01192915f, 0.29075536f, 0.09473790f, 0.34550503f, 
    0.00783000f, -0.02633860f, 0.15174603f, -0.07457932f, 0.06962550f, 0.01747203f, -0.16199948f, -0.03456821f, 
    -0.23903260f, -0.13385786f, -0.06473655f, 0.15980913f, 0.07818526f, 0.03798748f, 0.14582334f, 0.07476316f, 
    -0.07784721f, 0.08902053f, -0.01024941f, -0.02010280f, 0.33719739f, -0.05008149f, -0.16861257f, -0.02967567f, 
    0.11540853f, 0.11810042f, -0.11059933f, 0.00777411f, -0.05308867f, -0.14273746f, -0.10639915f, 0.07501063f, 
    0.09177322f, 0.08527251f, 0.02810362f, -0.02389040f, 0.23389663f, -0.06733182f, -0.10943674f, -0.14264089f, 
    -0.20299058f, -0.01666266f, 0.09048854f, -0.09879301f, 0.00719513f, 0.37841064f, 0.10723889f, 0.07691988f, 
    0.03428344f, -0.04764039f, 0.06210607f, 0.11205673f, -0.19309936f, -0.03330722f, -0.08758670f, -0.06096082f, 
    -0.36449179f, 0.20885198f, -0.07957564f, -0.21807514f, -0.01403260f, -0.14881982f, 0.07904773f, 0.10032568f, 
    0.05342902f, 0.18271127f, 0.17763841f, -0.01299926f, 0.15870167f, 0.22635548f, 0.20291856f, -0.16323976f, 
    -0.08366533f, -0.00326026f, -0.14804678f, 0.01832874f, -0.10830524f, -0.09254199f, 0.09390034f, 0.04579198f, 
    0.02068487f, -0.01307019f, -0.00644222f, -0.02772008f, -0.03998579f, -0.11725339f, -0.07121311f, 0.02713066f, 
    -0.07765515f, 0.07835671f, -0.03283002f, 0.08730308f, 0.19245273f, -0.11531549f, 0.05705621f, -0.09862349f, 
    0.06562535f, 0.16796018f, 0.05875204f, -0.11158270f, -0.00602378f, 0.04255072f, -0.06156470f, -0.19568047f, 
    -0.13814309f, -0.42045352f, 0.35334948f, 0.22010428f, 0.04929965f, 0.14485964f, -0.06439017f, 0.04648032f, 
    0.04439257f, -0.04088844f, -0.00939118f, -0.05073883f, -0.00167180f, 0.06635242f, -0.01207165f, -0.09767257f, 
    0.01803312f, 0.09631332f, -0.02675279f, 0.03211364f, 0.06312465f, -0.20443575f, -0.09062888f, -0.01328011f, 
    -0.06426456f, -0.05540677f, 0.04176804f, -0.10339192f, 0.08805416f, 0.00449469f, -0.01432183f, 0.18703981f, 
    -0.07815353f, -0.07862869f, -0.09942555f, 0.07953359f, 0.01508072f, -0.08602408f, -0.14268215f, -0.06272330f, 
    0.10852725f, 0.05228726f, 0.08226721f, 0.02295493f, 0.04614789f, -0.00636240f, -0.06082143f, -0.07203649f, 
    -0.43056092f, 0.15475030f, -0.04860269f, 0.38197958f, 0.03393597f, 0.06779809f, 0.09526806f, 0.17936875f, 
    0.19484390f, 0.38688156f, 0.06479364f, 0.21415235f, -0.17130284f, -0.15219937f, -0.08062326f, 0.06386842f, 
    -0.13456954f, 0.03870152f, 0.08736166f, 0.09015624f, 0.23685634f, 0.22407058f, 0.11768768f, 0.17974444f, 
    0.17877959f, 0.18966621f, -0.05463161f, -0.19605373f, 0.18640454f, -0.10754884f, 0.07481655f, 0.12076388f, 
    -0.03608437f, 0.00058000f, -0.03924337f, 0.11344799f, 0.06682114f, -0.25359136f, -0.19892606f, 0.06478658f, 
    -0.25975379f, -0.05293886f, -0.06794861f, -0.03566357f, -0.01156606f, 0.05599201f, -0.08029199f, 0.04801360f, 
    -0.07092353f, -0.16387413f, -0.00482406f, 0.38589758f, 0.02813325f, -0.18829921f, -0.04053975f, 0.18513569f, 
    -0.08245165f, -0.03813792f, -0.19172968f, -0.17790198f, -0.33501858f, 0.37107730f, -0.14404315f, 0.04776641f, 
    0.07552281f, -0.01449850f, 0.10443208f, 0.13117422f, -0.00606711f, -0.01274142f, 0.14428900f, -0.05013256f, 
    -0.20278792f, -0.01414175f, -0.20318602f, 0.02003796f, 0.15490291f, 0.03919782f, 0.02367242f, 0.02801181f, 
    -0.14227934f, 0.07205132f, 0.01824269f, 0.14491361f, 0.36342907f, 0.06208600f, -0.06671187f, -0.07961166f, 
    -0.04963332f, -0.05284605f, 0.14642797f, 0.13515778f, 0.04891952f, 0.08444317f, 0.13090983f, 0.03923369f, 
    -0.03795888f, -0.16791034f, -0.13501225f, -0.05268713f, -0.07485196f, 0.04950413f, -0.08499396f, -0.08830321f, 
    0.11564292f, -0.04676138f, 0.11853533f, -0.04754538f, 0.22948664f, 0.00924039f, 0.26714367f, -0.12465106f, 
    0.02994613f, -0.10250133f, 0.00037641f, 0.03250232f, -0.06767139f, -0.03289591f, 0.00117793f, 0.03767930f, 
    -0.17050415f, 0.53102487f, -0.23969191f, 0.33090034f, 0.00561708f, -0.03342361f, 0.21859284f, 0.11740951f, 
    0.11349306f, 0.00680503f, 0.04918075f, -0.06363293f, -0.21815076f, 0.12507397f, -0.11150639f, 0.07347502f, 
    -0.03438102f, -0.12938015f, 0.05080799f, -0.15327165f, 0.06416240f, 0.08885588f, 0.12475432f, 0.04998840f, 
    -0.11936426f, -0.11845863f, -0.06439576f, 0.05900455f, -0.04067609f, -0.02649657f, -0.00578532f, -0.13144396f, 
    -0.04248922f, 0.05878469f, -0.06225083f, -0.02090661f, -0.19865687f, -0.05575671f, 0.26337907f, -0.14255047f, 
    0.12791660f, -0.29425102f, 0.09393307f, -0.03325830f, 0.00959750f, 0.05503001f, 0.06480953f, 0.08112448f, 
    0.15656665f, 0.26191601f, -0.28343910f, -0.04872183f, 0.10907950f, 0.04877292f, -0.01657687f, -0.03757959f, 
    -0.01137946f, -0.04229910f, -0.10163355f, -0.00032838f, 0.26127759f, -0.21498218f, 0.21904743f, 0.03466523f, 
    -0.07218224f, -0.05856178f, -0.07039614f, 0.07206179f, 0.06452879f, 0.01548568f, 0.03578918f, 0.01321478f, 
    0.27838564f, -0.13722774f, -0.47218898f, -0.22861987f, -0.14223132f, 0.03764541f, -0.11964090f, 0.06056751f, 
    0.02975632f, 0.06490424f, -0.08259381f, 0.02375220f, -0.19332272f, -0.04844148f, -0.22458556f, 0.04687266f, 
    -0.05725125f, -0.11569844f, 0.06979429f, 0.04476809f, 0.02442196f, -0.09071767f, -0.06126085f, -0.03123320f, 
    0.13942406f, -0.13669153f, -0.27642754f, -0.08367166f, 0.10758501f, -0.06606439f, -0.19410965f, 0.29057816f, 
    0.02129197f, -0.02850625f, 0.02254361f, -0.11182959f, -0.16624033f, -0.28617543f, -0.05592778f, 0.07206088f, 
    -0.01495556f, 0.36292553f, 0.09003241f, 0.28512868f, -0.11258637f, 0.01918148f, -0.24061827f, 0.04804111f, 
    0.10032592f, 0.08480233f, -0.02101066f, -0.05149731f, 0.18217084f, -0.00904929f, 0.07606836f, 0.19035545f, 
    0.05322114f, 0.01966015f, 0.06818464f, -0.02832077f, -0.25253540f, 0.25381550f, -0.10524012f, 0.03331169f, 
    -0.12109061f, -0.14960639f, 0.22322018f, -0.19945386f, -0.00550172f, 0.09320782f, -0.03594467f, 0.01877141f, 
    0.25485846f, -0.04196380f, 0.38849127f, -0.05829089f, 0.15259822f, 0.07094503f, -0.05107586f, 0.00069641f, 
    0.18617651f, 0.05657855f, 0.18210086f, 0.03943790f, -0.03721934f, -0.07173036f, -0.11369117f, -0.29446322f, 
    0.11129525f, -0.02807166f, -0.11592945f, 0.16091812f, -0.07812110f, 0.05683745f, 0.06456366f, -0.02115808f, 
    -0.28170612f, -0.07821013f, 0.05407784f, -0.04619200f, 0.01930664f, -0.04825540f, -0.01404989f, -0.05602465f, 
    0.15790631f, 0.09936245f, 0.04502029f, 0.05821340f, 0.10727926f, 0.22142753f, 0.13540967f, -0.08040667f, 
    -0.15818891f, 0.09944952f, 0.07006164f, -0.16718769f, -0.03618694f, 0.00722502f, 0.04995894f, -0.11497568f, 
    0.16380617f, 0.05029477f, 0.19976847f, -0.09957925f, 0.06723984f, -0.00645002f, -0.01670879f, 0.16899922f, 
    0.08805142f, -0.07899552f, -0.09701748f, 0.04037744f, 0.03117775f, 0.29879344f, -0.28582084f, 0.19498460f, 
    -0.18680841f, 0.09808940f, 0.05768176f, 0.01604222f, 0.08566637f, 0.06040241f, -0.02220384f, -0.00566243f, 
    -0.34331506f, -0.10881685f, -0.18752638f, 0.10843522f, 0.09103680f, 0.03593950f, 0.16990112f, 0.12059485f, 
    0.00295889f, 0.03121744f, -0.08008381f, -0.07438242f, 0.10536052f, 0.02315141f, 0.20017411f, -0.07813898f, 
    0.10545045f, -0.05557293f, -0.00539537f, 0.02775374f, 0.07391252f, -0.00630107f, -0.02263092f, 0.24070127f, 
    -0.38633010f, 0.03066199f, -0.01940868f, -0.11747529f, 0.14592087f, 0.07002010f, 0.12683055f, 0.17166321f, 
    -0.07272371f, -0.05013115f, 0.00960196f, 0.14013101f, 0.18032800f, 0.23510867f, -0.12618737f, -0.20806494f, 
    -0.00826828f, 0.12174229f, 0.04236811f, 0.09607057f, 0.00116906f, -0.07866234f, 0.03692272f, -0.05263931f, 
    0.03767871f, -0.30803660f, 0.18870947f, -0.20771585f, 0.07192419f, 0.05325954f, 0.06035780f, 0.13690139f, 
    -0.13146324f, -0.01283146f, 0.07585461f, 0.01845474f, -0.11139992f, -0.10507350f, 0.17334838f, 0.00841090f, 
    -0.06298104f, -0.04222703f, 0.03956872f, 0.06877250f, 0.17861009f, -0.02951057f, 0.16641913f, -0.02444137f, 
    0.16876946f, 0.10158537f, -0.08638118f, -0.06724061f, -0.11656843f, -0.12272385f, -0.12040000f, -0.04055498f, 
    -0.09036179f, -0.13366497f, 0.00032379f, 0.16555296f, -0.01931515f, -0.09299106f, -0.18606573f, 0.06978410f, 
    -0.02436482f, 0.04501294f, 0.08368422f, -0.13915631f, -0.01500220f, 0.00971876f, 0.03064011f, -0.11199208f, 
    -0.14100486f, -0.46873489f, -0.12853341f, -0.25524539f, 0.25242105f, -0.14632440f, 0.12221110f, 0.04435533f, 
    0.13099602f, 0.11544129f, -0.15508673f, 0.00771631f, 0.22494832f, -0.38738760f, 0.13064697f, -0.04826136f, 
    -0.02167768f, -0.23550624f, 0.08757941f, 0.02864018f, 0.12247238f, 0.18289445f, 0.11771365f, -0.00375550f, 
    0.14179973f, 0.19119561f, -0.02014090f, -0.25565374f, -0.02649807f, 0.26573366f, -0.06951379f, 0.11673734f, 
    0.00976835f, 0.08670773f, 0.01072803f, 0.05344813f, -0.28209028f, 0.12726413f, 0.14266016f, 0.07308115f, 
    -0.10073588f, 0.12556674f, -0.14680982f, -0.04752769f, 0.08009870f, 0.08928853f, 0.15015289f, 0.06862365f, 
    0.17572673f, 0.15549375f, -0.06365234f, -0.00069743f, 0.04172454f, -0.02216562f, 0.09012748f, -0.04321338f, 
    -0.13900830f, -0.13437299f, -0.10408324f, -0.16387936f, -0.06292841f, 0.03937783f, 0.09804123f, 0.02479577f, 
    -0.05336278f, -0.14264275f, -0.12871283f, -0.14628080f, -0.00235436f, 0.01861551f, -0.04946237f, -0.11753372f, 
    0.24588437f, -0.11107577f, 0.10927375f, -0.33100772f, 0.01093776f, 0.23742089f, 0.16472614f, 0.04925224f, 
    -0.10245091f, -0.08472266f, -0.06941715f, 0.09022754f, 0.29064432f, -0.03835163f, 0.07613774f, -0.01853450f, 
    -0.13148569f, 0.09183834f, 0.03391090f, 0.13444248f, -0.26612622f, -0.24426536f, -0.17600572f, -0.18729064f, 
    0.19418789f, 0.12125654f, -0.07557530f, -0.06329781f, -0.04392450f, 0.02402039f, 0.08784652f, 0.07574693f, 
    0.16260482f, 0.14340778f, 0.24653800f, 0.19608864f, 0.11613356f, 0.20866095f, 0.29742402f, 0.15589099f, 
    -0.17045236f, -0.00089505f, -0.04710402f, 0.15663879f, -0.00138871f, 0.00278333f, -0.03824099f, 0.02303040f, 
    -0.05631634f, -0.18273337f, 0.10214797f, 0.06303650f, -0.21841334f, -0.05154828f, 0.01098452f, -0.00217993f, 
    -0.01653120f, 0.14784735f, -0.00751815f, 0.11118442f, -0.05022088f, 0.27450293f, 0.18201752f, 0.13895524f, 
    -0.01502753f, -0.00082846f, -0.16311269f, -0.00922726f, -0.06239804f, -0.13365647f, -0.04502071f, 0.04100620f, 
    -0.04642014f, 0.23931982f, 0.06148674f, 0.10758182f, -0.08261310f, -0.13525918f, 0.11524813f, 0.04900319f, 
    -0.06135232f, -0.08289052f, -0.02446558f, -0.05570638f, 0.56845593f, 0.02104127f, 0.00320716f, 0.09840669f, 
    -0.02171485f, 0.12708658f, -0.00445662f, -0.04659467f, -0.10387540f, 0.02335003f, -0.00655675f, -0.09085337f, 
    -0.08353677f, 0.07217567f, 0.30069569f, 0.08073134f, -0.00380776f, -0.12413736f, -0.09672725f, 0.01748758f, 
    0.01452882f, 0.18092459f, 0.13612400f, 0.13685943f, 0.05691312f, 0.05928745f, 0.37180635f, -0.16240291f, 
    0.05817157f, 0.09700709f, 0.12445804f, -0.00294493f, 0.06125914f, -0.03338309f, 0.01042406f, 0.02787424f, 
    -0.28763717f, -0.19501773f, -0.07324519f, 0.06324485f, -0.05549414f, -0.02665293f, 0.05300117f, 0.06876704f, 
    -0.02916173f, 0.03117258f, -0.00939352f, -0.05650962f, 0.22381842f, -0.13583419f, 0.21749669f, 0.05961499f, 
    -0.01214772f, 0.03704275f, -0.13335128f, 0.09629925f, 0.06804779f, 0.01963680f, 0.07737197f, -0.33179930f, 
    -0.14099428f, 0.15943690f, -0.18742201f, 0.23754597f, -0.07922886f, -0.00285805f, -0.23205137f, 0.07783671f, 
    -0.09247581f, -0.10333353f, -0.19258511f, -0.14420167f, -0.19545478f, 0.01021736f, 0.18334121f, -0.04035212f, 
    -0.03945620f, -0.06199147f, -0.05185484f, -0.23527004f, 0.02288721f, -0.00660935f, -0.08250163f, -0.13580342f, 
    0.32849106f, 0.23722105f, 0.14440331f, -0.06945425f, 0.07746241f, -0.00092009f, -0.00126342f, 0.07341334f, 
    -0.00829067f, 0.08208014f, 0.06874653f, 0.18301082f, -0.07046796f, -0.14532626f, -0.12514891f, 0.26106167f, 
    0.02865170f, 0.13939686f, -0.13651307f, -0.15590262f, 0.04726939f, 0.07321892f, 0.16706680f, 0.08084428f, 
    -0.17990042f, 0.00306760f, -0.13050477f, -0.02926440f, -0.09531404f, -0.12116846f, 0.14420854f, 0.00628127f, 
    -0.10939424f, 0.10510520f, 0.21258759f, 0.02237401f, -0.00675670f, -0.06007962f, 0.24827448f, -0.07644425f, 
    0.07341334f, 0.11478499f, 0.11531872f, 0.03699068f, -0.02039972f, -0.10040109f, -0.07272524f, 0.02496203f, 
    0.54927373f, 0.15004605f, 0.00173627f, -0.15910622f, -0.12172198f, 0.10283960f, 0.09077611f, 0.01672029f, 
    -0.06293491f, -0.05648829f, -0.07916976f, -0.02178743f, -0.17241313f, -0.02495900f, 0.02299590f, -0.03804181f, 
    0.01453453f, 0.16879788f, 0.04648128f, -0.04958162f, -0.04301812f, -0.17653799f, 0.00968130f, -0.04138625f, 
    0.14574340f, -0.07193351f, 0.10965217f, -0.13244013f, -0.04415426f, 0.03610928f, 0.14744824f, -0.19948420f, 
    0.03807223f, -0.13529575f, -0.12355760f, -0.16016285f, -0.22003314f, -0.05215970f, 0.09116431f, 0.05285305f, 
    -0.07145437f, -0.14144740f, -0.12238919f, -0.05472646f, 0.00233840f, 0.03572424f, 0.00279222f, -0.04530310f, 
    -0.07790334f, 0.22663730f, -0.12294307f, 0.05685768f, -0.07772078f, 0.13682103f, 0.00129181f, 0.15656577f, 
    0.16057947f, 0.16978149f, 0.27935249f, 0.33252448f, 0.22617601f, 0.14293239f, -0.18168689f, 0.06319123f, 
    -0.05586468f, 0.04035893f, 0.14977150f, 0.05930205f, -0.01246721f, 0.24452397f, 0.22894466f, 0.06531817f, 
    -0.08373899f, 0.02225219f, 0.12306429f, -0.01528458f, 0.09866461f, 0.14882399f, 0.08360060f, -0.01287172f, 
    0.04545838f, 0.16916853f, 0.05640855f, -0.04481795f, 0.07973544f, 0.04461805f, 0.00170129f, -0.02469180f, 
    -0.06541756f, 0.08689091f, 0.03102611f, 0.03804909f, -0.06129982f, 0.04867370f, 0.09232449f, -0.03109742f, 
    0.06899355f, 0.03590937f, -0.13209802f, 0.00796694f, -0.03707119f, 0.18992874f, -0.10534237f, 0.22246090f, 
    -0.16108549f, -0.18900530f, -0.09881020f, -0.18630020f, -0.30714849f, 0.36432377f, -0.00866812f, 0.06505019f, 
    -0.03122096f, -0.00675454f, -0.06813115f, -0.02133165f, -0.09115013f, -0.02789804f, -0.00338588f, -0.06795809f, 
    -0.15614323f, -0.33834395f, -0.03085543f, 0.08338306f, -0.02395166f, -0.05323666f, 0.03155331f, -0.05994490f, 
    -0.00950448f, -0.02469480f, 0.02698543f, -0.01623300f, 0.10019256f, -0.11148451f, 0.07750659f, -0.01867394f, 
    -0.01374907f, 0.05336259f, 0.07180567f, 0.08510920f, 0.05678936f, 0.19803095f, 0.05368727f, -0.16241075f, 
    0.12803297f, 0.06204416f, -0.01126615f, -0.00545554f, 0.03722837f, 0.07642425f, -0.01126262f, -0.00856102f, 
    0.00314677f, 0.00281117f, -0.01003025f, 0.00278653f, 0.09155256f, -0.28135684f, -0.04059150f, -0.10967486f, 
    -0.02358818f, -0.04014912f, -0.13884465f, -0.07955664f, -0.07940715f, -0.01815570f, 0.04436369f, -0.04392361f, 
    -0.09167440f, 0.29814914f, 0.00028976f, 0.17850432f, -0.20137428f, 0.12970963f, 0.07301912f, 0.12224098f, 
    -0.09078864f, 0.00974425f, 0.00520626f, 0.09467176f, 0.12151846f, -0.01114166f, -0.00222716f, -0.03162852f, 
    0.02083377f, -0.00597133f, 0.00198940f, -0.03865202f, -0.00692620f, -0.01555601f, -0.03495208f, 0.00550826f, 
    0.13798511f, 0.04636126f, 0.07400901f, 0.13912222f, 0.03428101f, -0.01133856f, 0.01305960f, 0.01232074f, 
    0.13094173f, 0.07486036f, 0.12346803f, 0.13897356f, 0.40853289f, -0.15450853f, 0.35238492f, 0.05392125f, 
    -0.05450934f, -0.06874995f, 0.05222466f, 0.15937752f, 0.04321980f, 0.19011994f, 0.03973762f, -0.11091053f, 
    -0.04782094f, 0.05462228f, -0.09185289f, -0.12945838f, -0.07140782f, -0.01534065f, -0.14943594f, 0.04919760f, 
    -0.00092330f, 0.04798230f, -0.01747789f, 0.05095813f, 0.12449199f, 0.03992630f, -0.14176729f, 0.18987930f, 
    -0.04175972f, 0.01427430f, -0.01848019f, 0.04867273f, -0.05507367f, -0.01254520f, 0.00053408f, -0.07938664f, 
    0.12968935f, -0.19255500f, -0.18998532f, -0.41244361f, -0.16527072f, -0.05707911f, -0.19172013f, 0.16104221f, 
    -0.01943965f, -0.03518129f, 0.00920690f, -0.05319055f, 0.23011842f, 0.08814979f, -0.12598477f, 0.18134046f, 
    -0.14662741f, 0.06829327f, -0.04477466f, 0.06733573f, -0.06009564f, 0.04030810f, 0.09496049f, 0.05464728f, 
    0.09373578f, -0.24143355f, -0.06684219f, -0.16093257f, -0.01986303f, -0.14218852f, -0.01656518f, 0.18658578f, 
    0.02437328f, -0.07735572f, 0.00734500f, -0.13725796f, 0.02014221f, 0.11175175f, 0.17516275f, -0.14782846f, 
    0.01725996f, 0.06710742f, 0.21539114f, 0.14989768f, 0.07191572f, -0.03623013f, 0.05083045f, 0.04668923f, 
    -0.05251129f, -0.04153903f, 0.02578833f, 0.09231459f, -0.10123330f, -0.10804501f, -0.07318775f, 0.14261666f, 
    0.00827240f, 0.00243304f, -0.01587251f, 0.06853265f, 0.07931329f, 0.11617938f, 0.17981970f, 0.15335336f, 
    -0.06463059f, 0.02989212f, 0.06909173f, -0.05940032f, -0.01915145f, -0.02057156f, -0.00418737f, -0.09708486f, 
    0.03073275f, 0.05447279f, 0.18212958f, 0.15519392f, -0.04186793f, -0.03917499f, -0.02913475f, -0.07366353f, 
    -0.00633248f, -0.08491212f, -0.06553850f, -0.17729810f, -0.13589142f, -0.14677083f, 0.00083574f, -0.12074872f, 
    -0.00257103f, -0.03877773f, 0.06470617f, -0.06361506f, -0.03009259f, 0.06718484f, -0.05820549f, 0.00225116f, 
    0.19561788f, 0.10139775f, 0.12267210f, 0.09718096f, -0.01995911f, -0.03757163f, 0.01462144f, -0.03127141f, 
    0.12831952f, 0.08920965f, -0.04392005f, 0.00842394f, -0.03571530f, 0.09187318f, 0.01017579f, 0.17643452f, 
    0.05576798f, 0.20417982f, 0.00440470f, -0.04373651f, -0.06466256f, -0.03569870f, 0.02611749f, -0.04175153f, 
    -0.23162696f, -0.03350905f, -0.13526805f, -0.17568658f, 0.07080954f, -0.11459377f, -0.00932625f, 0.01816507f, 
    0.11864758f, 0.14347006f, -0.00168264f, -0.03871561f, -0.14151695f, 0.08638159f, 0.12416258f, 0.14761259f, 
    -0.06558260f, -0.03453945f, 0.15581830f, 0.07748516f, -0.05864316f, -0.04309418f, -0.05177293f, -0.02125395f, 
    0.64324588f, 0.27468917f, 0.07289360f, -0.03603847f, 0.01502962f, -0.09087820f, -0.05395744f, -0.01448467f, 
    -0.02958879f, 0.08248377f, 0.05744386f, 0.02745905f, 0.11387900f, 0.02055929f, 0.02275462f, -0.11389542f, 
    0.10788636f, 0.14324799f, -0.00578079f, 0.03030654f, 0.08884631f, 0.01634903f, -0.06183384f, -0.08273024f, 
    -0.02168246f, 0.06014780f, -0.03182763f, -0.05693880f, 0.05895564f, 0.01645155f, 0.06199174f, -0.03215921f, 
    -0.02157087f, 0.05253807f, -0.08501036f, -0.03933291f, -0.06902805f, 0.14211266f, 0.07064679f, 0.02144651f, 
    -0.04996600f, -0.05903378f, 0.01962027f, 0.16452390f, -0.05131268f, -0.08727686f, 0.05347300f, -0.01374933f, 
    0.09935678f, -0.00882632f, 0.09701373f, -0.25371140f, 0.04759438f, 0.12003167f, -0.04419073f, 0.12578060f, 
    -0.12719434f, 0.05100382f, 0.03801260f, 0.20698555f, 0.06393941f, -0.03304431f, 0.12718937f, 0.00147756f, 
    -0.00375085f, 0.00339554f, -0.00081186f, -0.05437193f, 0.07511153f, 0.02642461f, -0.02299173f, -0.05389532f, 
    -0.03372210f, 0.03879396f, 0.02393038f, 0.00314150f, 0.01782607f, 0.01624255f, -0.06213593f, -0.11295171f, 
    0.04210988f, -0.12290137f, -0.04222250f, -0.05001038f, 0.06572973f, 0.04061264f, 0.09770949f, 0.07535892f, 
    0.08616086f, 0.03670755f, 0.03129675f, -0.01553101f, -0.02241640f, -0.00090760f, 0.07072880f, -0.00099446f, 
    0.16361235f, -0.03116591f, -0.03904309f, -0.03199431f, 0.06748686f, -0.03694186f, 0.07361617f, 0.10686104f, 
    -0.08364038f, 0.02342151f, -0.08236618f, 0.02372765f, 0.14783229f, -0.19215284f, 0.13570891f, -0.16734998f, 
    0.03643362f, -0.13914971f, 0.05655067f, -0.17208776f, -0.12664749f, -0.00080872f, -0.03896730f, -0.13507850f, 
    -0.07633895f, 0.02523319f, 0.07220542f, -0.26360393f, -0.22651409f, -0.13328649f, -0.16544600f, 0.13079034f, 
    0.05945460f, 0.00019297f, 0.02639970f, 0.07317397f, -0.40618345f, -0.13828549f, 0.23413086f, 0.10869347f, 
    -0.04515583f, 0.02850739f, -0.00679812f, -0.20101789f, -0.04047547f, 0.21981715f, 0.06761269f, 0.13702105f, 
    -0.12771840f, -0.09494768f, -0.07055917f, -0.08722462f, -0.02671393f, -0.00151209f, 0.02646785f, 0.01724952f, 
    0.04087556f, 0.00089862f, 0.01322834f, -0.05241257f, -0.40085268f, 0.06781681f, -0.00039572f, 0.19843495f, 
    -0.04675347f, -0.16691357f, -0.00486171f, 0.08261117f, 0.00547763f, -0.06708097f, -0.05140249f, 0.06485755f, 
    -0.23842753f, 0.49725577f, -0.25727525f, 0.09556905f, 0.10031112f, 0.03013068f, 0.01862191f, -0.11003920f, 
    0.08376895f, 0.05001711f, 0.06515799f, 0.06202881f, -0.13492145f, 0.03154844f, 0.10927349f, -0.13705646f, 
    -0.02962852f, -0.01951317f, 0.01485219f, -0.12217857f, -0.04827715f, 0.04955239f, 0.00089967f, -0.09243333f, 
    -0.21758336f, -0.08107555f, -0.20389344f, -0.14669847f, -0.07267808f, -0.09053709f, -0.00266984f, -0.05806171f, 
    0.06463145f, -0.05158815f, -0.10528640f, 0.03124589f, -0.22178023f, -0.13431826f, 0.67014402f, -0.31287932f, 
    -0.05051533f, 0.03550362f, -0.00915932f, -0.09245656f, 0.19999455f, 0.04237564f, 0.14347225f, 0.10901780f, 
    -0.19107032f, 0.05817414f, 0.08329254f, -0.11814927f, -0.00046259f, 0.05066274f, 0.12450012f, 0.00454653f, 
    0.10796714f, -0.04119510f, 0.03756080f, 0.07827590f, -0.24589424f, -0.07542288f, 0.09656737f, 0.10810173f, 
    -0.17658800f, -0.10457185f, 0.07212611f, 0.07394352f, 0.17368855f, 0.08610848f, 0.08602992f, 0.05571846f, 
    -0.03218265f, -0.00180897f, 0.18131964f, 0.02372956f, -0.04327694f, 0.13932101f, 0.14842702f, 0.15476465f, 
    -0.04210991f, -0.06187119f, -0.19508794f, -0.07438083f, -0.06838341f, 0.08584778f, -0.05601751f, -0.19163243f, 
    0.11317185f, -0.13760783f, 0.00528218f, -0.01370753f, 0.08052601f, -0.20709117f, 0.07796927f, 0.11391468f, 
    -0.32283920f, 0.26513422f, 0.22651657f, 0.00120688f, -0.18700923f, -0.16736773f, 0.07389842f, 0.10320789f, 
    0.07492533f, -0.00500216f, 0.04810587f, -0.00194498f, 0.00468759f, 0.21833636f, -0.29452288f, 0.01479087f, 
    0.05373507f, -0.06852311f, -0.04217714f, -0.02290298f, 0.01260143f, 0.12329608f, 0.04906615f, -0.20072471f, 
    -0.08775121f, 0.11431925f, 0.06986202f, -0.03836926f, 0.00430971f, 0.14298296f, 0.06462856f, 0.05524215f, 
    0.05110516f, 0.00734126f, 0.06585806f, -0.00520480f, -0.04299983f, 0.14334916f, -0.02654135f, -0.15201199f, 
    0.07223287f, -0.05820268f, -0.01335448f, -0.07115327f, 0.07215297f, 0.05378595f, -0.11942183f, -0.01406455f, 
    0.25641754f, -0.29898793f, 0.02111041f, -0.11973553f, 0.13998559f, -0.05159603f, -0.08138593f, -0.01742986f, 
    0.02105537f, -0.00889625f, 0.17246132f, -0.09149455f, -0.09690576f, 0.17012453f, 0.21571212f, -0.00441485f, 
    -0.16369523f, -0.01095842f, 0.17043094f, 0.20577665f, -0.06779493f, -0.00909517f, -0.05566361f, -0.05647283f, 
    -0.21534832f, -0.12328719f, 0.11759426f, -0.35301131f, -0.17853704f, 0.03780788f, 0.01789091f, 0.02557709f, 
    0.03931118f, 0.27538782f, 0.07205617f, 0.13323742f, 0.18826465f, -0.11712302f, 0.02861714f, 0.25984958f, 
    0.01940009f, -0.01146374f, -0.08600949f, 0.04245921f, -0.03073576f, 0.06944216f, 0.10986481f, 0.29198441f, 
    -0.09221315f, -0.09130730f, -0.04983717f, 0.10157052f, -0.06912503f, -0.02092402f, -0.02025091f, 0.14862415f, 
    0.08599056f, -0.05696423f, 0.05888963f, 0.06175093f, -0.12984987f, 0.23281321f, -0.31319240f, 0.09719577f, 
    0.07770956f, 0.05311455f, -0.01951984f, -0.09118351f, -0.02142986f, -0.05640355f, 0.10057268f, 0.02405581f, 
    0.10892158f, 0.17292437f, 0.06737996f, 0.08284162f, 0.20035721f, -0.06080338f, -0.00453181f, -0.06225710f, 
    -0.16134487f, -0.07788116f, 0.08734182f, -0.03725143f, 0.13091822f, 0.02873503f, -0.02475249f, 0.10886849f, 
    0.00714870f, -0.03956815f, 0.07700016f, -0.06701203f, -0.06987451f, -0.03129562f, -0.05414211f, 0.26090178f, 
    -0.11550146f, 0.20886907f, -0.20357859f, -0.09856179f, 0.12979673f, 0.09641524f, -0.07033831f, 0.05875829f, 
    -0.12831256f, -0.01588440f, 0.04057691f, -0.06049431f, -0.14211407f, -0.05297207f, 0.15419476f, 0.12294646f, 
    0.02582230f, 0.05663364f, 0.18352492f, -0.06798948f, 0.01586717f, -0.01890878f, -0.06747618f, -0.08810547f, 
    0.01563643f, -0.41782305f, 0.19048265f, -0.13552509f, 0.09949867f, 0.02015986f, 0.09045798f, 0.08367017f, 
    -0.08238383f, 0.12560980f, -0.01269344f, 0.03984604f, 0.21621798f, -0.14934017f, 0.02974789f, -0.01436556f, 
    0.07893836f, 0.10076018f, 0.03212921f, -0.09087705f, 0.15602656f, 0.15846656f, 0.20813179f, 0.06625474f, 
    -0.03697359f, -0.05225060f, 0.15430760f, 0.02930951f, -0.03221503f, -0.04728990f, 0.05985023f, 0.13183901f, 
    0.08097433f, 0.22722384f, -0.06097066f, 0.28956872f, 0.10146913f, 0.08816768f, -0.22861382f, 0.06253476f, 
    0.00869246f, -0.05582567f, 0.06126526f, -0.03332458f, 0.03234549f, -0.02060971f, 0.13763061f, 0.00186065f, 
    0.06730626f, -0.23212801f, 0.12989244f, -0.14104782f, -0.01166008f, -0.03336185f, 0.09096918f, 0.06801245f, 
    0.07124653f, -0.06550558f, -0.00200998f, 0.10288730f, -0.06979798f, -0.21001996f, 0.36291161f, -0.06710586f, 
    -0.00424180f, -0.02604273f, -0.04677800f, 0.09616810f, -0.00711839f, 0.11012462f, 0.02492686f, 0.02949444f, 
    -0.24958417f, -0.19645697f, 0.17809489f, -0.11829075f, -0.10148095f, -0.05138692f, 0.02789598f, 0.05939686f, 
    0.04433115f, 0.06748239f, -0.02978622f, -0.09408188f, 0.33693647f, -0.03778357f, -0.35531044f, 0.28516042f, 
    -0.00874526f, 0.01436456f, -0.00605210f, 0.03652646f, 0.14809179f, 0.10950553f, 0.22813334f, -0.08960735f, 
    0.11056385f, 0.01592406f, 0.01074690f, 0.02222847f, 0.13292874f, -0.05960091f, 0.05500762f, -0.04748302f, 
    0.01735064f, -0.02623212f, -0.03051710f, -0.07217682f, -0.24194430f, -0.09178476f, 0.01956665f, 0.03687498f, 
    -0.07802036f, -0.13783632f, -0.06323633f, 0.02390494f, 0.01058675f, -0.19784401f, -0.01989147f, 0.13147624f, 
    -0.08142962f, 0.51839393f, -0.24564169f, 0.16827241f, -0.03142410f, -0.05865912f, -0.05431905f, 0.05383220f, 
    0.17339878f, 0.03533566f, -0.01601190f, 0.03187539f, -0.00648365f, -0.05663222f, -0.02947837f, -0.05181703f, 
    -0.08855996f, 0.16681057f, 0.04745215f, -0.00090765f, -0.07838241f, -0.03317228f, -0.11578088f, -0.13124949f, 
    0.15888317f, 0.07745786f, -0.00765546f, 0.06805211f, 0.05657963f, 0.02086396f, -0.06661801f, 0.00631615f, 
    0.08519820f, 0.00381425f, 0.08031572f, 0.17076872f, 0.05164997f, -0.27124488f, 0.41050348f, -0.25946286f, 
    0.04734151f, -0.00961583f, 0.03792908f, 0.03008720f, 0.12542367f, -0.05898382f, -0.02702737f, 0.04347443f, 
    -0.12688036f, 0.06064205f, 0.21205372f, -0.08221933f, -0.04285749f, -0.03817137f, 0.04542731f, -0.05334456f, 
    0.01349799f, 0.06302462f, 0.01440198f, 0.06644215f, 0.09542744f, 0.09808103f, 0.00361350f, 0.01956560f, 
    -0.06532422f, -0.02477946f, -0.06086279f, -0.08661783f, 0.22441952f, -0.06180656f, -0.04899338f, -0.00433549f, 
    0.05065286f, -0.10848369f, 0.04383918f, -0.18966985f, -0.14106071f, -0.15027173f, 0.08964821f, 0.04819569f, 
    0.10534385f, -0.06181822f, -0.01170880f, 0.00916828f, 0.25071639f, 0.07075109f, 0.04603357f, -0.00028694f, 
    0.07864081f, -0.02577772f, 0.00421158f, -0.02784048f, 0.03872586f, -0.00436882f, 0.00846432f, -0.01733226f, 
    -0.19580223f, 0.11685363f, 0.25287083f, -0.08416480f, -0.24582337f, -0.22575898f, 0.02807545f, 0.06824297f, 
    0.02110907f, -0.08101845f, 0.12536155f, 0.10260770f, 0.13577740f, 0.10776743f, -0.15359291f, 0.03802303f, 
    -0.03375603f, -0.04867304f, 0.03946434f, 0.06552884f, 0.06773323f, 0.17504531f, 0.05921964f, 0.02188398f, 
    -0.04356346f, 0.17982222f, 0.11905090f, 0.10897275f, 0.02764571f, 0.08347082f, 0.03832815f, 0.02867355f, 
    -0.06193935f, -0.04232818f, -0.05213996f, 0.06094225f, 0.10452939f, 0.07885166f, -0.07198491f, 0.05351924f, 
    0.17986128f, -0.00670424f, 0.00117524f, 0.08733906f, 0.09662534f, -0.05409336f, -0.18764314f, -0.17542173f, 
    0.18340197f, -0.20118061f, 0.01063680f, 0.20065889f, 0.14680958f, -0.10918385f, 0.00788534f, 0.06483440f, 
    -0.01625943f, -0.13402927f, -0.03733006f, -0.28910401f, -0.08303616f, 0.04585672f, 0.08509248f, -0.04663356f, 
    -0.10823784f, -0.11855602f, 0.09148352f, -0.03882069f, 0.01636824f, -0.00987993f, -0.03278974f, 0.05259821f, 
    0.22069201f, 0.02672758f, 0.12814990f, -0.06927130f, 0.01965504f, 0.03410710f, -0.00467863f, 0.00170268f, 
    0.01039033f, 0.11408905f, 0.04600456f, 0.02724976f, 0.13756558f, -0.30863589f, -0.08905608f, 0.37780586f, 
    0.11443800f, 0.01332891f, -0.16599028f, -0.04026384f, 0.04549934f, 0.03286335f, 0.01569416f, 0.25956059f, 
    -0.05198739f, 0.02144379f, 0.06040438f, 0.16458899f, -0.05632978f, -0.08327895f, -0.08564006f, 0.00887532f, 
    0.00786437f, -0.02636197f, 0.05364616f, 0.00206432f, -0.02292761f, 0.02724947f, -0.00329493f, 0.04732603f, 
    0.12146879f, -0.10375684f, -0.03586002f, 0.12439882f, 0.06473958f, -0.18621323f, -0.07846057f, -0.01632195f, 
    0.41670519f, 0.28047785f, 0.03221599f, 0.03373896f, 0.07749795f, -0.05248643f, 0.08306912f, 0.03334810f, 
    0.02820864f, -0.03990902f, 0.05235532f, 0.00804605f, 0.10673627f, -0.06776354f, -0.20286734f, -0.05967957f, 
    -0.04732479f, -0.03039496f, 0.05829048f, -0.05565578f, -0.02649131f, -0.05827385f, -0.03462795f, -0.03081524f, 
    0.01553669f, 0.17620009f, -0.11084295f, 0.00589618f, 0.09982806f, 0.01054622f, -0.15713570f, -0.02268491f, 
    0.02934854f, -0.01341853f, 0.05702725f, -0.07333481f, -0.01110721f, 0.14275795f, 0.20746449f, 0.15371007f, 
    0.00958151f, -0.11212247f, -0.02793618f, 0.06294360f, 0.03471655f, 0.02665683f, 0.00398702f, 0.00848573f, 
    0.14311351f, -0.41697967f, 0.08892552f, -0.17058793f, 0.02497809f, -0.12866621f, 0.02340671f, 0.04784778f, 
    0.05082045f, 0.01904546f, 0.05937799f, 0.19866414f, 0.32111630f, -0.19154897f, 0.03592467f, -0.04463807f, 
    0.03955697f, 0.00715053f, -0.01206315f, -0.05039086f, 0.07309557f, 0.11022651f, 0.17529680f, 0.07136109f, 
    -0.13481531f, -0.16148052f, 0.15835801f, -0.01624975f, 0.03430666f, 0.05153062f, -0.06302539f, 0.14317408f, 
    0.02334210f, 0.11617707f, -0.04108478f, 0.16033146f, 0.10170666f, -0.06820604f, -0.04912534f, 0.07552294f, 
    0.08851390f, 0.01240325f, -0.01011711f, -0.01623086f, 0.06781826f, -0.07142833f, 0.04594758f, 0.04242281f, 
    0.10847217f, -0.28659886f, 0.17859544f, -0.16807421f, -0.09907562f, -0.02264229f, 0.04339305f, -0.03341786f, 
    0.01223236f, -0.11239154f, 0.03251463f, -0.00183872f, -0.01454113f, -0.20761584f, 0.05008975f, -0.05722119f, 
    -0.09930976f, -0.01827823f, 0.00621028f, 0.02063054f, -0.15608482f, 0.01504841f, -0.02189518f, -0.04980596f, 
    -0.12998429f, -0.15864934f, 0.31394276f, -0.03852785f, -0.08320896f, -0.13064469f, 0.04634001f, 0.12276956f, 
    0.01572568f, -0.08801522f, -0.06118683f, -0.11549480f, -0.08823480f, -0.15391922f, -0.11728961f, 0.19844307f, 
    0.03143907f, -0.00090965f, 0.04074045f, 0.00582766f, -0.05304024f, 0.12333303f, 0.17514308f, -0.10679025f, 
    -0.01483329f, -0.18138346f, 0.00409303f, -0.04100568f, -0.06326111f, 0.07762915f, -0.01478162f, 0.04804060f, 
    0.01290534f, 0.06629770f, 0.02666950f, -0.09601474f, 0.36635852f, -0.20001616f, -0.03248448f, 0.11253180f, 
    0.09260906f, 0.08582173f, 0.00277374f, 0.19462541f, 0.11044716f, -0.00578464f, 0.04749812f, 0.02382943f, 
    -0.02012076f, 0.47475925f, 0.00702072f, 0.39805281f, 0.05641637f, -0.17412519f, -0.05634052f, -0.05419338f, 
    -0.07893465f, -0.12333410f, 0.10582601f, -0.13458885f, -0.23789530f, 0.11247518f, 0.01126516f, -0.07984993f, 
    0.00845304f, 0.09585674f, -0.15481247f, -0.19936402f, -0.08160371f, -0.02761517f, -0.18012466f, -0.26372716f, 
    -0.12067178f, -0.18615861f, -0.07214960f, 0.04593889f, -0.02204206f, 0.23781903f, 0.14716084f, 0.06686997f, 
    0.16535351f, 0.06470863f, -0.03514185f, 0.10633083f, -0.34717733f, -0.13007966f, 0.00839715f, -0.06804524f, 
    0.04679626f, -0.05275371f, 0.04297674f, -0.22074208f, 0.08429129f, -0.05580580f, 0.11783863f, -0.05234078f, 
    -0.02378291f, 0.16115625f, -0.04644772f, 0.00146871f, 0.00398101f, -0.09485046f, 0.04516217f, 0.04372043f, 
    -0.01208337f, -0.12911001f, 0.03778529f, 0.07512500f, 0.23161709f, -0.04884592f, 0.06710897f, -0.07316253f, 
    0.04873173f, -0.04463194f, -0.04501987f, 0.02000803f, 0.28213668f, 0.00530800f, 0.24737521f, -0.10544358f, 
    -0.23156939f, 0.06114920f, -0.12589213f, 0.16033934f, 0.05056112f, 0.03586818f, 0.04730646f, 0.05104152f, 
    0.03223346f, -0.01442852f, -0.14869963f, 0.18099946f, -0.14352919f, 0.01709339f, 0.09218487f, -0.05951855f, 
    -0.02932796f, -0.01039339f, -0.00112087f, -0.03376243f, 0.04905163f, -0.17738415f, 0.04289006f, 0.01829581f, 
    -0.08005876f, -0.16420789f, -0.02938928f, 0.15915133f, 0.12982310f, 0.04006950f, 0.17651331f, 0.15744370f, 
    0.09997946f, 0.12508322f, 0.15135427f, 0.19900066f, 0.09648009f, 0.09259575f, -0.18403468f, 0.52588677f, 
    0.13203786f, 0.11158808f, 0.14515533f, 0.08084645f, -0.01597951f, 0.06280360f, -0.01003616f, -0.16360620f, 
    0.00866758f, 0.10236844f, 0.12714766f, 0.33292449f, 0.06279335f, 0.05058862f, 0.03299261f, 0.16341107f, 
    -0.01268004f, 0.06709570f, -0.03656483f, -0.00640684f, 0.16382439f, 0.16719183f, -0.27509710f, -0.04108742f, 
    0.15766768f, 0.07668062f, -0.05305367f, 0.00934223f, 0.06702758f, -0.20959687f, -0.11057782f, -0.02807119f, 
    0.15754341f, -0.02739441f, -0.09041068f, -0.02609966f, 0.21889128f, 0.02955549f, -0.07646696f, -0.10502164f, 
    -0.13051766f, -0.15943184f, 0.01319898f, -0.11925090f, 0.04214647f, 0.08397426f, 0.03347386f, -0.02722051f, 
    0.06016113f, -0.02890129f, -0.04655861f, 0.16128950f, -0.01986386f, -0.02234200f, -0.11275575f, 0.10857205f, 
    -0.20856121f, 0.03625635f, -0.18320037f, -0.03666332f, 0.15462862f, -0.17365952f, 0.04950443f, 0.02213172f, 
    0.03245336f, 0.21197392f, 0.04446907f, -0.00110335f, 0.19358549f, -0.05361832f, 0.20099851f, -0.28045017f, 
    -0.09922461f, 0.01208861f, -0.08967493f, -0.02015755f, -0.09414738f, -0.05563396f, -0.06797048f, 0.04509740f, 
    0.03408636f, -0.03576347f, 0.14323793f, 0.15934904f, -0.07638510f, -0.03969444f, -0.23406976f, 0.07517131f, 
    0.08687403f, 0.06113649f, -0.14484960f, 0.12455263f, 0.08576213f, -0.06369718f, -0.02446367f, 0.25684956f, 
    -0.00270367f, 0.10680974f, 0.03459192f, -0.11652065f, -0.07504551f, -0.10612440f, -0.07304507f, -0.21652196f, 
    0.10575743f, -0.09251568f, 0.28190115f, 0.29870862f, 0.17797272f, 0.06038441f, -0.06882701f, 0.23099121f, 
    0.05996915f, -0.02460760f, 0.02002050f, 0.05819057f, 0.01566041f, 0.01319764f, 0.10631845f, -0.20230277f, 
    0.00816053f, -0.09552130f, -0.14465129f, -0.03842165f, -0.06459483f, -0.20283385f, -0.06004015f, -0.00061329f, 
    -0.15606798f, 0.13653539f, -0.15131156f, -0.04585808f, 0.16161323f, -0.07891895f, -0.05354410f, 0.20901820f, 
    -0.16058476f, -0.02807429f, 0.01694847f, -0.06770468f, 0.19252384f, 0.03595501f, 0.08119831f, 0.14296880f, 
    0.09072234f, 0.06194723f, -0.02293012f, 0.06257261f, 0.14574397f, 0.03243055f, -0.14994994f, 0.00995943f, 
    -0.26782745f, -0.15886582f, 0.18343785f, 0.09969772f, 0.11071664f, 0.03228651f, 0.01716680f, 0.11856363f, 
    -0.02421135f, 0.28082600f, -0.15740472f, 0.12224289f, -0.03242134f, -0.24500397f, -0.04381405f, -0.01356671f, 
    -0.14917007f, 0.05702790f, 0.15178731f, 0.02570126f, 0.20404147f, 0.04820770f, 0.02915595f, 0.06272692f, 
    -0.03351150f, -0.06684310f, -0.10618594f, -0.36076885f, -0.05747123f, -0.07748774f, -0.18350084f, 0.04661556f, 
    -0.14570113f, 0.05128819f, -0.17553499f, 0.05475175f, 0.01952314f, -0.26882929f, -0.03061565f, 0.03755135f, 
    -0.11248784f, -0.07252154f, -0.06909477f, -0.06116190f, 0.02946157f, -0.00376947f, 0.02183047f, -0.00660587f, 
    0.11255949f, -0.31887707f, 0.55408424f, -0.08879223f, 0.15928245f, 0.01831843f, 0.00037208f, 0.16116068f, 
    0.08976575f, 0.07434762f, -0.14482938f, -0.11019755f, -0.22755840f, -0.38634622f, -0.29673582f, -0.10635354f, 
    0.04270042f, -0.04091328f, 0.06337430f, 0.01740987f, -0.00072247f, 0.06552969f, 0.10117134f, -0.09978633f, 
    -0.23178376f, -0.13994575f, 0.27894393f, -0.07111366f, 0.06119232f, -0.01699313f, -0.03432491f, 0.08665427f, 
    -0.12684090f, 0.13963941f, -0.01892306f, 0.10213919f, 0.32064536f, -0.05564788f, -0.00151848f, 0.04827444f, 
    -0.02024298f, -0.06681514f, 0.06494424f, 0.25452965f, 0.10093100f, 0.06417392f, 0.07603837f, -0.00054667f, 
    -0.02066052f, -0.18500018f, -0.10859743f, -0.04951995f, -0.02500956f, -0.03479595f, 0.00696633f, -0.03894827f, 
    0.03438739f, -0.05123263f, -0.00217668f, 0.03092985f, -0.18222417f, 0.10606763f, 0.11155244f, 0.13386172f, 
    -0.07970408f, 0.01849168f, 0.00031532f, 0.09566960f, 0.06866516f, 0.03407604f, 0.03845471f, -0.01474841f, 
    0.21802820f, -0.09894159f, -0.20457356f, -0.01701619f, -0.03698052f, -0.01723927f, 0.05999435f, -0.06550562f, 
    -0.04751946f, -0.04958146f, -0.12033815f, -0.04285822f, -0.13773888f, -0.12434810f, -0.05301632f, 0.05524438f, 
    0.05203391f, 0.08488769f, -0.06892480f, 0.01967826f, -0.04921505f, -0.08465336f, -0.09492777f, -0.01020102f, 
    0.01078087f, -0.06249294f, -0.13687249f, -0.11266151f, -0.00410540f, 0.00469161f, -0.08365713f, -0.10162550f, 
    -0.14447662f, -0.04214931f, 0.02096523f, 0.00016625f, 0.37182677f, 0.21296144f, -0.19726400f, -0.02867785f, 
    0.01701204f, -0.04893233f, -0.08843090f, -0.08777194f, 0.04111690f, -0.15032038f, -0.07020602f, -0.05676897f, 
    -0.00811824f, 0.12925227f, 0.26820838f, 0.12366249f, 0.16536708f, 0.04327662f, 0.05770866f, -0.01716833f, 
    -0.03598778f, 0.00480394f, -0.05446082f, -0.11195493f, -0.12711790f, 0.16568944f, 0.15584485f, 0.11962182f, 
    -0.01396667f, -0.03230114f, -0.11873169f, 0.09601399f, -0.07276185f, 0.06842755f, -0.08261016f, 0.00298687f, 
    0.33999062f, 0.14063074f, 0.21268679f, -0.17787103f, 0.00831515f, 0.07777708f, 0.03927838f, 0.03870079f, 
    0.02531992f, -0.02036028f, 0.02907295f, -0.14993562f, -0.14446719f, -0.24533473f, -0.09986676f, -0.10401125f, 
    0.01092937f, 0.03947910f, -0.07556259f, -0.03562048f, -0.04861842f, 0.02684067f, 0.02737583f, -0.05250460f, 
    0.10075761f, 0.23486984f, 0.16989736f, 0.02496895f, -0.04482315f, 0.04361311f, -0.04960091f, -0.12161491f, 
    0.17058577f, 0.03030121f, 0.03900401f, 0.03211891f, -0.00966609f, -0.31385577f, -0.28216127f, -0.12804006f, 
    0.02469883f, -0.10818196f, -0.03353706f, -0.06778400f, 0.01819820f, -0.12506570f, 0.06261089f, 0.01407764f, 
    0.21384899f, 0.18615812f, 0.20540258f, -0.09151234f, 0.05204593f, -0.06622639f, 0.02059144f, -0.02130956f, 
    0.02478636f, -0.02003579f, -0.11712146f, 0.01429056f, -0.10530426f, -0.09534346f, -0.05442928f, 0.03530088f, 
    0.05860909f, -0.08841297f, -0.13048117f, -0.03750437f, -0.03019589f, -0.03566865f, 0.01912955f, -0.06325386f, 
    -0.09812028f, -0.08637197f, 0.15223160f, 0.00635101f, -0.06562591f, -0.10650081f, 0.02356816f, 0.06721694f, 
    -0.04172595f, -0.04366574f, -0.08846612f, 0.04241104f, -0.04840756f, 0.13235019f, -0.03110528f, 0.03180206f, 
    -0.04135558f, 0.06327498f, 0.03454651f, 0.06112552f, 0.09528989f, -0.08118048f, 0.00621818f, -0.00547896f, 
    0.18780193f, -0.11093961f, -0.18103020f, -0.09711272f, -0.02453319f, -0.06301103f, -0.04792952f, -0.04654274f, 
    -0.12441766f, -0.16445769f, -0.09811970f, 0.05072831f, -0.14375515f, -0.27316689f, -0.04499443f, 0.26930910f, 
    0.03579211f, -0.12575312f, -0.12161185f, 0.01995205f, 0.01194632f, 0.02466297f, 0.09427620f, 0.05763265f, 
    -0.04535543f, 0.18417653f, 0.18664655f, 0.25777498f, 0.08421700f, 0.13217349f, 0.02975409f, -0.05451857f, 
    -0.04855937f, -0.05166104f, -0.09750205f, -0.12563239f, 0.04674216f, -0.04901535f, -0.07021469f, -0.16890910f, 
    0.06004024f, 0.02657749f, 0.00672329f, 0.02845887f, -0.07028433f, -0.08164569f, -0.11439814f, -0.02732992f, 
    -0.30749908f, -0.28585890f, -0.47208560f, 0.04943326f, 0.11894847f, -0.05349560f, -0.07538518f, -0.16826557f, 
    0.01231081f, 0.00224891f, -0.04341797f, 0.05435046f, -0.15879764f, -0.10014912f, -0.09063189f, 0.14164893f, 
    -0.09061024f, 0.04684528f, 0.02342621f, -0.15254915f, -0.02185650f, -0.02569106f, -0.05116873f, 0.03678865f, 
    -0.07894418f, -0.24972031f, -0.15611959f, -0.03095784f, 0.07498477f, 0.03616773f, -0.02688765f, -0.05848879f, 
    0.03173441f, -0.04374850f, -0.05806277f, 0.00412839f, -0.12579717f, 0.27078953f, 0.11397912f, 0.10512998f, 
    0.14617147f, 0.11072983f, -0.03718231f, 0.04977532f, -0.03422312f, -0.02519997f, 0.01442689f, 0.03082096f, 
    0.01427110f, -0.07475334f, 0.02390411f, -0.06820291f, -0.11608412f, -0.03343865f, -0.03876696f, -0.01922897f, 
    0.04833614f, -0.09829807f, 0.20075704f, -0.02393587f, 0.07687254f, -0.09963897f, -0.12724066f, -0.13583294f, 
    -0.04588245f, -0.01701602f, -0.13798627f, 0.05610240f, -0.04980463f, -0.01564856f, 0.19038223f, 0.06448479f, 
    0.03881345f, 0.02710924f, 0.03552409f, 0.03166583f, -0.13341087f, -0.01981968f, -0.01799823f, -0.03593215f, 
    0.06057832f, -0.06399792f, 0.00255121f, 0.07268528f, -0.24424705f, -0.18926090f, -0.15620041f, -0.20041509f, 
    -0.02896906f, -0.09263785f, -0.10515379f, 0.02223085f, 0.01938941f, -0.04527934f, 0.08513129f, 0.00209103f, 
    -0.17753716f, -0.18790950f, 0.00500160f, -0.11203140f, -0.01747487f, 0.09830394f, -0.00325338f, -0.22045012f, 
    -0.01033130f, -0.02247528f, -0.03005636f, -0.03449394f, 0.17568211f, 0.18646668f, -0.08677609f, 0.13996364f, 
    -0.11192140f, -0.10018931f, -0.06257861f, 0.07709417f, 0.16957332f, -0.01966961f, 0.00910064f, 0.02658321f, 
    -0.03859871f, 0.17878276f, 0.17055362f, 0.14362411f, 0.08661063f, 0.10379699f, 0.00335612f, -0.00486689f, 
    0.01077673f, -0.03275219f, -0.09533034f, -0.01106169f, -0.08963791f, 0.07743972f, -0.06898692f, 0.04085775f, 
    0.03617919f, -0.05258226f, -0.11118966f, -0.08711863f, -0.06903900f, -0.04548834f, 0.09581874f, 0.02401960f, 
    0.09632985f, -0.00088693f, 0.03694761f, 0.01869677f, 0.03196056f, -0.00143821f, 0.00078149f, -0.02356149f, 
    -0.02300675f, 0.05193706f, -0.05363512f, 0.00974905f, -0.01621955f, -0.13741355f, -0.00281622f, -0.21004710f, 
    -0.01752746f, 0.03512280f, -0.03153487f, 0.10019180f, 0.08095233f, -0.01539958f, 0.08930998f, -0.14684410f, 
    0.03877496f, 0.06269375f, 0.14627013f, 0.26915523f, 0.11458895f, -0.02244857f, 0.03847600f, 0.01804008f, 
    -0.06951255f, 0.06927671f, 0.08590613f, -0.15602881f, -0.10206459f, -0.04222959f, 0.05300795f, -0.07716858f, 
    -0.00822594f, -0.02211312f, -0.08564276f, -0.09579194f, -0.03619579f, 0.04118747f, -0.07759608f, 0.06339908f, 
    -0.04429939f, -0.12682240f, -0.01202233f, -0.13128480f, 0.01702559f, -0.02197268f, 0.04115766f, -0.00783561f, 
    -0.01200106f, 0.03299272f, -0.08110270f, -0.08166832f, -0.18278332f, -0.32455376f, -0.08867764f, 0.13904220f, 
    -0.05587739f, 0.10170107f, -0.05940950f, 0.04328787f, -0.07186367f, -0.12349200f, 0.02057299f, -0.07932989f, 
    0.15271211f, 0.09690861f, 0.03021760f, -0.04531117f, -0.01656721f, 0.03122100f, -0.07121406f, -0.05193154f, 
    0.05073261f, -0.01942673f, 0.00964873f, 0.00618030f, -0.08170940f, 0.04577001f, 0.04644205f, -0.03370237f, 
    -0.17553866f, -0.03585048f, 0.05620422f, -0.03606655f, 0.01011986f, 0.03455509f, -0.02118254f, -0.11144012f, 
    -0.02030216f, 0.17062227f, -0.35515615f, 0.08841230f, -0.00603716f, -0.10210483f, -0.00144025f, 0.17594658f, 
    0.03586148f, 0.01843264f, -0.13453984f, -0.08137434f, -0.01600935f, 0.10596149f, -0.14920598f, 0.22897114f, 
    -0.04728211f, 0.03237466f, -0.02709418f, -0.00852977f, -0.03206391f, -0.04655077f, 0.01491051f, 0.03727020f, 
    0.01075663f, -0.10302575f, -0.35337555f, -0.25141758f, 0.09625210f, 0.00963257f, -0.09000808f, 0.13774666f, 
    0.03883550f, 0.00897559f, 0.06171573f, 0.03230578f, -0.04717236f, -0.03096958f, 0.27915892f, 0.16413778f, 
    0.10691502f, 0.14876854f, -0.00730266f, -0.06801574f, -0.08162834f, 0.00064754f, 0.03755954f, -0.11853308f, 
    0.29674825f, 0.22667661f, 0.05848207f, 0.13450173f, 0.07269631f, 0.07916547f, 0.04492344f, 0.19212830f, 
    -0.04011700f, 0.06484323f, 0.05155620f, -0.02521084f, -0.06547485f, 0.11023127f, -0.05759820f, 0.01307383f, 
    -0.05178082f, 0.20945823f, -0.14812209f, -0.06132649f, -0.04490183f, -0.07603556f, -0.09532659f, 0.02233759f, 
    -0.06743997f, 0.33305812f, -0.13536571f, 0.01951318f, -0.02501511f, 0.11783761f, -0.06117307f, -0.05838140f, 
    0.02329940f, -0.18698598f, 0.18284908f, 0.08077195f, 0.05336346f, -0.10793704f, -0.05866646f, -0.09602087f, 
    -0.00618585f, 0.08377921f, -0.09493982f, 0.19908729f, -0.03304897f, -0.00327976f, -0.07716367f, -0.00611331f, 
    -0.15205036f, -0.00882560f, -0.08153208f, 0.05931162f, -0.04526622f, -0.02022829f, 0.04035884f, -0.02221237f, 
    -0.05743071f, -0.02333442f, -0.10714798f, -0.00421381f, -0.16635218f, 0.11438649f, 0.24259925f, -0.10943787f, 
    -0.10187923f, 0.03684455f, 0.01050698f, -0.09246328f, -0.01421275f, -0.05725371f, 0.15209429f, -0.00111626f, 
    0.09004464f, 0.01989442f, 0.22561742f, -0.12729774f, 0.05002483f, 0.03999674f, -0.02073685f, 0.02892290f, 
    0.09255347f, -0.03886670f, 0.02555936f, 0.04407106f, 0.06548653f, 0.02138508f, 0.10190822f, 0.14088388f, 
    -0.02238774f, 0.01877252f, 0.15570769f, -0.20624377f, -0.04549418f, 0.05187631f, 0.01669945f, -0.01407362f, 
    0.28164819f, 0.09812187f, 0.17331131f, 0.09257592f, -0.00709706f, -0.00843528f, -0.11680223f, 0.07407656f, 
    -0.02607893f, -0.01850527f, -0.08870522f, -0.06631184f, 0.01402020f, -0.11651397f, 0.20144063f, -0.04276367f, 
    -0.00873437f, -0.05460446f, 0.11065149f, -0.10010867f, -0.06238509f, -0.07867941f, -0.02175949f, -0.04492339f, 
    -0.10210090f, 0.01287616f, -0.01136830f, -0.04990535f, 0.11320476f, -0.00389096f, 0.06170426f, 0.20809852f, 
    -0.12705207f, 0.04689839f, 0.04394047f, -0.05953835f, 0.33841905f, 0.17259647f, 0.24504046f, -0.06550957f, 
    0.07417189f, -0.02014861f, -0.04029654f, -0.00469690f, 0.08235724f, -0.00204186f, -0.07629701f, -0.02839703f, 
    -0.09267934f, 0.13362184f, 0.06790773f, -0.10396049f, -0.05573138f, 0.00749826f, 0.05129113f, 0.08133571f, 
    -0.21123843f, 0.10971212f, -0.02681966f, -0.12946729f, -0.16740838f, 0.15166286f, -0.15462081f, 0.10631333f, 
    -0.07552493f, -0.06666984f, 0.07148045f, -0.00624746f, -0.00843914f, -0.06558271f, 0.00140157f, -0.08375242f, 
    -0.18304130f, -0.01204359f, 0.02457359f, -0.13280806f, -0.08018281f, 0.12967192f, -0.19749658f, 0.03553678f, 
    -0.20283554f, -0.05065486f, -0.02904262f, 0.07085346f, 0.02940990f, -0.00736805f, 0.02385820f, -0.00200375f, 
    0.03696724f, -0.05055215f, -0.02641010f, -0.06837484f, -0.11940611f, -0.00099083f, 0.07306216f, 0.02792725f, 
    0.08689990f, -0.04553767f, 0.01537529f, -0.08683836f, 0.04075105f, 0.20527881f, -0.11095466f, 0.24904533f, 
    0.02106118f, 0.01935159f, -0.09267565f, -0.02516616f, -0.22429852f, -0.27173188f, -0.14661425f, -0.16242877f, 
    -0.01107496f, -0.09594741f, -0.12339731f, 0.07540359f, 0.01629008f, -0.03825346f, -0.13859421f, 0.11437047f, 
    0.24275795f, 0.13685822f, 0.14066805f, -0.11992200f, 0.02435716f, 0.15183899f, 0.03926376f, -0.04082579f, 
    -0.02163788f, -0.03151896f, 0.05089256f, 0.01586304f, -0.06063203f, -0.08689615f, 0.06554969f, -0.08524717f, 
    -0.09469189f, -0.02580259f, -0.10742983f, 0.08162464f, 0.04363269f, 0.01441494f, 0.04150187f, -0.00343478f, 
    0.02529385f, -0.01751943f, -0.09697120f, -0.00246705f, -0.04214005f, 0.00170568f, 0.05935235f, -0.05436528f, 
    -0.07803462f, 0.00547554f, 0.01019037f, -0.06422063f, -0.46255425f, 0.07223556f, 0.25329342f, 0.01440529f, 
    -0.17933716f, -0.11645479f, -0.21057111f, -0.08474341f, 0.04406270f, -0.12728529f, 0.07152407f, 0.03614336f, 
    0.03847234f, 0.00857645f, -0.13331695f, -0.17135419f, -0.09240752f, 0.06122999f, 0.05135902f, -0.03749196f, 
    0.02131980f, 0.04065941f, -0.09161723f, 0.02889616f, -0.04451949f, -0.16237091f, 0.03655249f, -0.17531042f, 
    -0.10915794f, 0.03308969f, -0.02781724f, -0.00987061f, -0.05800834f, -0.02004061f, -0.08784781f, -0.00711916f, 
    -0.00417623f, -0.13233581f, -0.17486958f, 0.00180676f, 0.01123069f, 0.00451610f, 0.07910706f, -0.00813014f, 
    -0.07702486f, 0.03415660f, -0.03879629f, -0.10936452f, 0.04907025f, -0.28970513f, 0.12637696f, -0.12179217f, 
    0.00425445f, -0.06163520f, -0.09912246f, 0.26054659f, -0.00929863f, -0.08053249f, -0.02527107f, -0.15208818f, 
    0.02901046f, 0.09842453f, 0.09083530f, -0.16242319f, -0.08730439f, -0.01948265f, -0.15353893f, -0.06586783f, 
    -0.02855919f, -0.07191245f, -0.07843207f, -0.11613128f, -0.40355065f, 0.12285294f, 0.06365916f, 0.26368371f, 
    -0.03186355f, -0.15779288f, -0.07045639f, 0.03058101f, -0.05887198f, -0.16586366f, -0.12231056f, -0.03525727f, 
    0.40534377f, 0.21933757f, -0.07152089f, -0.25700971f, -0.13491094f, 0.02221680f, -0.00868307f, 0.12708107f, 
    -0.06416450f, 0.01474639f, 0.01216782f, -0.11333568f, 0.25352117f, -0.08452809f, -0.35059869f, 0.08350840f, 
    -0.09175815f, -0.01965833f, -0.04740980f, -0.02687050f, -0.03415998f, -0.08128654f, -0.06282560f, -0.05107839f, 
    0.01640869f, 0.22261724f, -0.10425500f, -0.23953083f, -0.08442289f, -0.18186587f, -0.18086378f, -0.01602541f, 
    -0.04624765f, -0.10272138f, 0.04049825f, 0.00344743f, -0.13669643f, -0.34793463f, 0.19163097f, -0.46961132f, 
    0.10895851f, -0.05444945f, 0.07550260f, 0.02647765f, -0.11560629f, -0.15147331f, 0.08034725f, -0.16770755f, 
    0.15643682f, 0.14706314f, -0.03569977f, -0.24122991f, -0.02157137f, -0.05317550f, -0.02511739f, 0.06166987f, 
    0.01158527f, 0.00309970f, -0.03733894f, -0.07408224f, -0.18032964f, -0.16121806f, 0.04181502f, -0.10395689f, 
    -0.08485481f, -0.02471527f, -0.08162893f, -0.02260683f, -0.05227921f, -0.00639415f, -0.09586383f, -0.14198446f, 
    -0.24469970f, 0.03654149f, -0.06709698f, 0.09136686f, -0.07642110f, -0.00536656f, -0.11215191f, -0.01394449f, 
    -0.06530382f, -0.11619029f, -0.05593030f, -0.33257020f, -0.02367442f, 0.04246528f, 0.12828904f, -0.16610429f, 
    -0.09475177f, 0.06632777f, -0.08765968f, -0.01273687f, -0.09453305f, 0.06910187f, 0.00283324f, -0.06474815f, 
    0.09868047f, -0.01723009f, 0.07761144f, -0.12173218f, -0.08075857f, -0.00331251f, -0.03373966f, 0.03894167f, 
    -0.16154544f, -0.02833959f, 0.06102888f, 0.05842835f, -0.32968572f, 0.07221272f, -0.07004692f, 0.45418966f, 
    -0.03961994f, 0.10202717f, -0.07378364f, -0.14298952f, 0.09956180f, -0.06142009f, 0.15968427f, -0.10072719f, 
    -0.05213892f, 0.01914093f, 0.15119119f, -0.15982588f, 0.06701273f, -0.04941411f, 0.01007755f, -0.08088513f, 
    0.06285612f, -0.07961407f, -0.02031209f, -0.15309978f, -0.07001051f, 0.04267136f, 0.07590074f, 0.08946269f, 
    -0.07643246f, -0.04492833f, 0.12576002f, -0.00345791f, -0.03629401f, -0.14033756f, -0.09919059f, -0.02260692f, 
    0.24468644f, 0.13957003f, -0.21397686f, -0.22888473f, 0.09720819f, -0.04769662f, -0.10087351f, 0.01326139f, 
    -0.06263115f, -0.05789489f, -0.05214899f, -0.08587475f, -0.04628163f, -0.01820273f, 0.08473400f, 0.07909399f, 
    -0.04938528f, 0.01553842f, 0.11073793f, -0.11668199f, 0.00614307f, 0.05828781f, -0.03229177f, -0.01737772f, 
    -0.02415983f, 0.08743070f, -0.14269149f, -0.14699872f, 0.02082621f, 0.06509361f, 0.05302135f, 0.08925601f, 
    -0.03118651f, 0.02433758f, 0.00149075f, -0.09468607f, -0.08828866f, 0.17374979f, 0.21531937f, -0.15023281f, 
    -0.10850450f, -0.08329657f, -0.04621411f, -0.04967891f, -0.00102073f, -0.10914999f, -0.10946917f, -0.01497408f, 
    0.18560514f, -0.15311736f, 0.11470170f, -0.19197930f, 0.02023884f, -0.02986281f, -0.03357306f, 0.04224380f, 
    -0.07233541f, 0.05477704f, 0.06780040f, 0.02915626f, 0.09021519f, 0.18311667f, 0.06611620f, 0.03746305f, 
    -0.02761713f, 0.00118466f, -0.00410007f, -0.00770418f, 0.01344459f, -0.03137958f, 0.02788350f, -0.01336650f, 
    -0.08893336f, -0.14950939f, 0.14268771f, 0.07104336f, -0.07900471f, 0.10323770f, -0.07709445f, -0.00734850f, 
    0.04476747f, -0.02704580f, -0.04537871f, 0.05722750f, -0.03112424f, -0.11466473f, -0.05172857f, 0.11245003f, 
    0.07412961f, 0.09036591f, -0.04553335f, -0.04779732f, -0.08686311f, -0.04525552f, -0.02320144f, -0.02922791f, 
    0.03731917f, -0.14665242f, -0.20008515f, -0.34001887f, -0.04416479f, 0.14957438f, -0.05509670f, 0.26067647f, 
    0.01091361f, -0.07972051f, -0.10745776f, -0.09550362f, 0.00814669f, -0.15588643f, 0.26530847f, -0.05478539f, 
    -0.08235520f, -0.08567460f, -0.00648492f, -0.06930328f, -0.02920244f, 0.04960174f, -0.03513123f, -0.03115129f, 
    0.04793298f, 0.06701089f, 0.02838611f, -0.08299836f, -0.07376757f, 0.04622398f, 0.03128255f, 0.08575328f, 
    0.12386888f, -0.03082146f, -0.03825939f, -0.05509727f, -0.45234779f, -0.08456751f, 0.10651238f, 0.13684507f, 
    -0.05899642f, 0.02892204f, -0.02697877f, -0.21781580f, -0.02592980f, -0.03859447f, -0.01582729f, 0.01599500f, 
    -0.01166251f, -0.04695842f, 0.06326625f, 0.01234360f, -0.16806158f, -0.02686303f, -0.01970472f, 0.07898754f, 
    -0.09294192f, -0.01243194f, -0.02172472f, 0.05329616f, -0.20974520f, -0.08980948f, -0.15027612f, -0.01297221f, 
    0.03662823f, 0.10607668f, 0.17115413f, 0.20781451f, -0.01402973f, 0.09456693f, 0.09725882f, -0.07103244f, 
    0.41862139f, -0.46724588f, 0.20638947f, -0.07807981f, 0.11880390f, 0.01452310f, -0.01250353f, 0.10236993f, 
    -0.08706419f, 0.00541558f, 0.03713583f, 0.12620401f, 0.06442896f, -0.03155275f, 0.11526453f, 0.05655875f, 
    0.04863366f, 0.00680112f, -0.12351571f, 0.05275687f, -0.03471022f, 0.08078723f, 0.00046420f, 0.06559712f, 
    0.10439797f, -0.03153207f, 0.07368979f, -0.02347802f, -0.07921138f, -0.00259358f, -0.00104385f, 0.03527867f, 
    -0.12934177f, -0.07779833f, -0.05604038f, -0.14195426f, 0.00986515f, 0.12559426f, -0.58071619f, 0.32170391f, 
    -0.10853888f, 0.08153220f, -0.05789419f, -0.04279639f, 0.01285283f, 0.04266359f, 0.22608906f, -0.05645809f, 
    0.00618017f, 0.04239361f, 0.10115726f, -0.09771237f, 0.19833168f, 0.01195149f, 0.01945275f, 0.07215597f, 
    -0.02120117f, -0.02174933f, -0.06048439f, 0.04480574f, -0.16231687f, -0.05012852f, -0.05327696f, -0.12542804f, 
    0.05367503f, 0.01847118f, 0.22594868f, 0.24439098f, -0.11219358f, 0.16423787f, 0.25658226f, -0.12888922f, 
    -0.21280919f, 0.07192203f, 0.11111139f, 0.19081655f, 0.28293389f, 0.10862650f, 0.12611625f, 0.01261689f, 
    0.01434829f, -0.04792151f, 0.00608579f, -0.02451094f, 0.00953066f, 0.03927915f, 0.29322430f, -0.05765345f, 
    0.01354586f, 0.14915057f, -0.09855022f, 0.03145218f, -0.02705142f, -0.05427773f, 0.15612735f, -0.00835408f, 
    -0.18304756f, -0.10895455f, -0.29341707f, -0.15754709f, 0.05910485f, 0.19099504f, 0.09606802f, 0.06730351f, 
    -0.03051013f, 0.06402195f, 0.04553242f, -0.01495604f, -0.03595752f, 0.05006256f, -0.02914532f, 0.04209804f, 
    0.06829412f, -0.06090496f, 0.00503055f, -0.06455016f, 0.02748430f, -0.04877527f, 0.09121236f, -0.06281496f, 
    0.18187582f, -0.07964347f, -0.04956632f, -0.00198141f, 0.10963723f, 0.11056240f, 0.01822086f, -0.19801678f, 
    -0.00075358f, 0.02267091f, 0.05558538f, 0.01851542f, 0.00373060f, -0.13293678f, -0.08216644f, -0.03254787f, 
    -0.10351265f, 0.08999155f, -0.12849618f, 0.05640439f, -0.04897115f, 0.00891684f, 0.11917672f, 0.14056922f, 
    -0.13799836f, 0.16765638f, -0.15496695f, -0.05344447f, -0.18869607f, 0.04974625f, 0.09063196f, 0.12850794f, 
    0.06504869f, 0.09013715f, 0.00558537f, 0.11205460f, 0.06263979f, 0.02725869f, -0.06911661f, 0.10839496f, 
    -0.02666601f, 0.20409676f, 0.09162563f, 0.01867672f, 0.02228299f, -0.03584490f, -0.09171718f, -0.00045146f, 
    0.01169349f, 0.17981504f, -0.10288636f, 0.18862569f, 0.04725698f, -0.01148760f, 0.06289361f, 0.13254955f, 
    0.08719659f, -0.05468129f, 0.02920495f, -0.11674207f, 0.13218547f, 0.26447478f, 0.32172489f, -0.05501796f, 
    -0.02622389f, 0.00455647f, 0.11636900f, 0.14149131f, 0.06394310f, 0.00891460f, 0.14750147f, -0.06699139f, 
    0.04694503f, -0.09330098f, 0.03585263f, -0.10626940f, 0.07336768f, 0.14861342f, -0.04969347f, -0.00167857f, 
    0.05710120f, 0.07844623f, -0.04353362f, 0.03539132f, 0.21235947f, -0.17146665f, 0.30667087f, -0.08675665f, 
    -0.07459398f, -0.01260661f, -0.02177532f, -0.07128532f, -0.10643268f, 0.04303654f, 0.11050867f, 0.04325326f, 
    -0.07611133f, -0.22208962f, 0.13430801f, -0.08282373f, 0.00160786f, 0.01221869f, -0.15435159f, -0.00136211f, 
    0.01507593f, 0.03450121f, 0.02693053f, 0.08816713f, -0.04477583f, 0.07702398f, 0.19518661f, 0.24409114f, 
    -0.00349754f, 0.14018014f, -0.02669105f, -0.05457436f, -0.04484945f, 0.01437030f, 0.01654324f, 0.07921847f, 
    0.12497780f, -0.02169041f, 0.03348567f, 0.19290821f, 0.09796610f, 0.03710853f, -0.11623580f, 0.05239141f, 
    -0.06092977f, 0.03338360f, 0.15853767f, 0.13706590f, -0.04129228f, -0.08393724f, -0.06989192f, -0.09307872f, 
    0.14530814f, 0.10767597f, 0.01312334f, -0.12788820f, 0.01081221f, 0.06052264f, -0.02856307f, -0.03370331f, 
    -0.08716179f, 0.29916319f, -0.13623942f, 0.21013544f, 0.07297657f, 0.08109159f, 0.18038869f, 0.07504938f, 
    0.00639068f, 0.08898894f, 0.12796824f, -0.19965655f, -0.17428753f, 0.12085849f, 0.05334901f, 0.05704540f, 
    0.02279586f, 0.06025613f, -0.00527242f, 0.09698640f, 0.07055844f, 0.01329264f, -0.06003074f, 0.07550224f, 
    0.07784328f, 0.14881709f, -0.08885470f, 0.03626229f, -0.02474744f, 0.10896339f, 0.10968731f, 0.14228205f, 
    0.06453650f, 0.06359297f, -0.00709551f, 0.11392794f, 0.12017980f, 0.01526159f, 0.25343975f, -0.01578773f, 
    -0.05591356f, -0.05459851f, -0.00304935f, 0.08369068f, -0.14677851f, 0.04420267f, 0.00493497f, -0.05108785f, 
    0.00185617f, 0.36731008f, 0.00130578f, 0.09814417f, 0.00146240f, 0.08205571f, -0.01371062f, -0.02147163f, 
    0.01625245f, 0.02592283f, -0.01899522f, 0.11700466f, -0.14573267f, 0.11503485f, -0.25520691f, 0.01841335f, 
    -0.05301782f, 0.09852744f, 0.05342433f, 0.20700040f, 0.14860767f, -0.02799500f, 0.03550817f, -0.00439385f, 
    0.04869144f, 0.23826776f, -0.12083397f, 0.11726151f, 0.22202061f, 0.09633046f, 0.15230861f, -0.14953226f, 
    -0.10472925f, 0.11199622f, 0.03468137f, 0.04020474f, 0.27642870f, 0.18266204f, 0.34172195f, 0.02517815f, 
    0.00273701f, -0.08085874f, -0.08985613f, 0.09334577f, -0.05090082f, -0.05102265f, 0.05511797f, 0.06942177f, 
    -0.03118852f, 0.07653904f, -0.04685100f, -0.05119059f, 0.05242107f, 0.00297395f, 0.05666981f, -0.14735721f, 
    -0.10736161f, -0.11251053f, 0.01842692f, -0.01817504f, 0.19502462f, 0.12243173f, 0.14472860f, -0.04434307f, 
    -0.11008830f, -0.08951563f, -0.13728221f, -0.18570423f, -0.12159941f, -0.00411622f, -0.01703633f, 0.03318654f, 
    0.02021297f, -0.05378726f, -0.04703736f, -0.15146290f, 0.03050035f, 0.08595634f, 0.26500851f, 0.07200004f, 
    0.03000478f, -0.07507689f, 0.01164723f, 0.04609983f, 0.05942625f, 0.02595653f, -0.03679958f, -0.00640133f, 
    -0.08982213f, 0.01805926f, 0.05813440f, 0.01550687f, -0.05056050f, -0.12644096f, -0.00136805f, -0.13993616f, 
    0.06834244f, 0.09457026f, -0.11199825f, -0.06042316f, -0.03682001f, -0.13650273f, -0.05851885f, -0.09416715f, 
    0.13637772f, 0.14078420f, 0.09907070f, 0.08810249f, 0.41739964f, 0.22486825f, 0.36656371f, -0.03735681f, 
    0.04334113f, -0.16573192f, -0.06095134f, 0.10571318f, 0.04224719f, 0.08160536f, -0.13619809f, 0.01439193f, 
    -0.01489927f, 0.02614342f, 0.05186760f, 0.13783747f, -0.14632754f, -0.00156388f, 0.01393408f, 0.06119999f, 
    0.04193147f, 0.09028294f, -0.11345540f, 0.10292488f, 0.15297242f, 0.27632871f, 0.07740276f, 0.10421521f, 
    -0.02655872f, 0.07191235f, -0.26226395f, 0.04669909f, -0.16173476f, -0.03285590f, -0.08049850f, 0.20509830f, 
    0.16726050f, 0.36669925f, 0.00693720f, -0.06345298f, -0.06801119f, -0.06784703f, 0.08241417f, 0.09985999f, 
    0.02760958f, -0.07218187f, 0.03971189f, -0.10817128f, 0.34017360f, 0.02603227f, -0.11177742f, 0.04162254f, 
    0.05458158f, -0.05614595f, 0.08479175f, -0.08322982f, -0.07909431f, 0.09050217f, -0.11812221f, -0.05196918f, 
    0.05976269f, 0.12479535f, 0.26974502f, 0.16860519f, -0.03353227f, -0.08094890f, -0.05291148f, 0.02634132f, 
    0.07073859f, 0.03919181f, 0.03489497f, -0.02430841f, 0.07986645f, -0.22898276f, 0.06585640f, -0.26144630f, 
    -0.16052286f, 0.20710856f, 0.08818319f, -0.10036054f, -0.04035581f, -0.00402324f, 0.04341165f, 0.08353627f, 
    -0.10044946f, -0.02738486f, -0.00479952f, -0.04013027f, 0.00048874f, 0.05720199f, -0.05967644f, 0.08410478f, 
    -0.01615476f, -0.00855526f, -0.04923816f, 0.01347493f, 0.10668053f, -0.11511037f, 0.19594766f, 0.05301282f, 
    0.04626875f, -0.05203332f, 0.08249392f, -0.00717307f, 0.09581183f, 0.00306480f, 0.06742634f, -0.19928572f, 
    -0.02209173f, 0.09848613f, 0.14056805f, 0.23797673f, -0.01601852f, 0.01925349f, -0.08856779f, 0.02254122f, 
    -0.09476978f, -0.06522176f, -0.15606251f, 0.01405962f, -0.16308561f, -0.04966918f, 0.07727354f, -0.05945250f, 
    0.02739998f, -0.08310924f, -0.07465547f, -0.06044636f, 0.00328000f, 0.02214837f, -0.00826260f, -0.12158360f, 
    0.30628070f, 0.10022727f, 0.16371752f, -0.08079337f, -0.08547225f, -0.01066378f, -0.10827510f, -0.04793763f, 
    -0.03532275f, 0.02546925f, -0.04702229f, 0.12623622f, 0.10206684f, -0.25991014f, -0.32850882f, 0.20203573f, 
    -0.02420761f, 0.00272297f, 0.00279312f, -0.12539937f, 0.00986292f, 0.08081350f, -0.00993124f, 0.00754031f, 
    -0.00543411f, 0.13136312f, -0.00302792f, 0.07810871f, -0.10474699f, -0.01358123f, 0.10609625f, 0.06227853f, 
    -0.03420667f, 0.04725665f, 0.10169640f, -0.05296334f, -0.15974367f, 0.06991377f, -0.00564995f, -0.09835169f, 
    -0.01312275f, 0.03727528f, 0.04719274f, 0.10993835f, -0.01860095f, -0.06176818f, -0.00062673f, 0.05445408f, 
    0.11840457f, 0.11285274f, -0.36212260f, -0.11134775f, -0.04965033f, -0.01880723f, 0.11876106f, -0.14810212f, 
    -0.01037032f, -0.06340826f, -0.07635460f, -0.00442336f, -0.16392715f, 0.04084907f, -0.00376367f, 0.03533452f, 
    0.00218011f, 0.01948966f, 0.07188424f, -0.04674544f, 0.08077672f, -0.00912414f, 0.01570272f, -0.13452838f, 
    -0.00469386f, -0.07456770f, 0.08203796f, -0.11607573f, -0.07625259f, -0.04121488f, 0.14345525f, -0.12319086f, 
    0.09114776f, -0.08985988f, -0.11928184f, -0.13817839f, -0.16256320f, 0.09487462f, 0.09699178f, 0.10714356f, 
    -0.08985479f, -0.03793116f, -0.18624540f, 0.06858304f, 0.00228967f, -0.01897548f, 0.01149383f, -0.01049754f, 
    0.15484843f, -0.05958743f, -0.02846967f, -0.12387935f, -0.04438387f, 0.12472870f, -0.02461888f, -0.08156228f, 
    0.26141906f, -0.09665692f, 0.15545414f, 0.09779041f, 0.25047931f, 0.06300971f, -0.04839772f, -0.00515096f, 
    0.03635607f, -0.07768384f, 0.05933611f, -0.01972214f, -0.11317709f, -0.02175461f, 0.16939931f, -0.02553286f, 
    -0.03156902f, -0.08618360f, 0.18421997f, 0.02852250f, -0.06584530f, 0.00475538f, 0.04650421f, -0.06619683f, 
    0.10067955f, 0.18457705f, 0.07910170f, -0.17477164f, -0.08156349f, 0.02375741f, -0.09105913f, -0.18311726f, 
    -0.11532495f, -0.01188811f, 0.00062849f, -0.08225268f, 0.01927522f, -0.07390841f, 0.00311279f, 0.08147039f, 
    -0.21539804f, 0.02407626f, -0.09140801f, -0.09603514f, 0.06000589f, 0.19270998f, -0.10103294f, -0.03229969f, 
    -0.08277036f, -0.04484309f, -0.04158937f, -0.08079495f, -0.02359458f, 0.23964658f, 0.01101862f, -0.01689974f, 
    -0.10570291f, -0.01512797f, -0.02248968f, -0.09330199f, 0.06271897f, 0.00527308f, 0.05030142f, -0.08058154f, 
    -0.03385715f, -0.28399736f, 0.08880367f, 0.07202356f, -0.07686695f, 0.05448077f, -0.00172425f, -0.01911706f, 
    0.07972686f, -0.12371100f, -0.06896225f, -0.11650971f, -0.06938288f, 0.06748919f, 0.04749638f, 0.10092743f, 
    -0.08779555f, 0.09961038f, -0.02269582f, -0.11103588f, -0.00117350f, 0.09454547f, 0.03096888f, -0.05707423f, 
    0.00355598f, -0.05353759f, -0.04217821f, -0.00249542f, 0.03513315f, 0.02185524f, 0.00852192f, 0.00078399f, 
    0.01770238f, 0.04157305f, -0.00618810f, 0.03172558f, 0.02764200f, 0.04362477f, 0.00581978f, -0.05035768f, 
    -0.03571476f, -0.01756046f, -0.04327911f, -0.02736555f, -0.02957884f, 0.03329015f, 0.03876670f, 0.04018410f, 
    -0.02368367f, 0.02826518f, 0.00607553f, -0.00367813f, -0.04479332f, 0.00001045f, -0.04544792f, -0.03273442f, 
    -0.00229059f, -0.01599712f, -0.01475395f, 0.01780955f, 0.03101287f, -0.03662803f, 0.03059601f, -0.05428169f, 
    0.01519191f, -0.00251484f, 0.01063859f, -0.05238301f, 0.02462544f, -0.01905561f, 0.00970393f, -0.03780178f, 
    0.00646262f, 0.01569062f, 0.03746571f, -0.03771796f, 0.00832882f, -0.01806249f, -0.04890918f, -0.05531901f, 
    -0.02483052f, -0.00232899f, -0.03250618f, 0.00407415f, 0.02416205f, -0.02712196f, -0.05550975f, -0.01719356f, 
    0.03067896f, 0.00652358f, -0.05180875f, -0.04637683f, 0.01951577f, 0.00975118f, 0.03900759f, 0.02885901f, 
    -0.02736827f, 0.03647507f, 0.00327507f, -0.03336342f, 0.01874308f, -0.00148836f, 0.01217411f, 0.01667842f, 
    -0.04693290f, -0.01597475f, 0.00655346f, -0.04609401f, -0.03047042f, 0.03659561f, -0.04515492f, 0.01122578f, 
    -0.04677933f, -0.02902819f, 0.01549352f, 0.04141815f, 0.00470630f, 0.00122274f, 0.03755450f, -0.02210198f, 
    0.02781401f, -0.02303614f, -0.04983741f, -0.02326041f, 0.03429866f, -0.04315872f, 0.02752584f, 0.00732537f, 
    -0.04285194f, 0.00266584f, 0.03951163f, -0.04392548f, -0.01808877f, 0.02354798f, -0.04662026f, 0.03747933f, 
    -0.03790668f, -0.03930367f, 0.01694798f, -0.01870902f, -0.03884863f, 0.02425153f, -0.03608880f, 0.01290644f, 
    0.01353691f, 0.03289067f, -0.02268217f, 0.04792113f, 0.02618511f, -0.02313081f, 0.02793668f, 0.02415606f, 
    -0.03819778f, 0.00955744f, -0.04630611f, -0.04017993f, -0.05368372f, -0.04155293f, -0.03723604f, -0.03038874f, 
    0.00886990f, 0.03610891f, 0.02897056f, 0.01241309f, 0.02814062f, 0.00593622f, -0.05539312f, 0.01948517f, 
    0.01712030f, 0.03541082f, -0.00414998f, -0.04619401f, -0.03522348f, -0.02371359f, -0.04403775f, 0.00493090f, 
    0.02589728f, 0.04013295f, 0.02593756f, 0.01650049f, -0.05183414f, -0.03917768f, 0.00918828f, 0.02595012f, 
    0.02479189f, -0.02556370f, 0.04415593f, -0.03908899f, 0.00167459f, 0.03476129f, -0.05997559f, -0.00812952f, 
    0.04430743f, 0.02444874f, -0.01113012f, -0.01928395f, -0.03253353f, -0.04742077f, -0.00412964f, -0.04739735f, 
    -0.01749896f, 0.01323765f, -0.01913298f, -0.00582776f, 0.01435935f, -0.00537798f, -0.05840309f, 0.01711508f, 
    -0.01744081f, 0.03067153f, -0.02237013f, -0.04375060f, -0.00080178f, 0.01542112f, 0.03440572f, -0.00763083f, 
    -0.04280612f, 0.02137783f, -0.04859919f, 0.00647326f, 0.03441489f, -0.02629861f, 0.01480206f, -0.02814737f, 
    -0.02288847f, -0.04332935f, -0.02627428f, 0.01724471f, -0.01597297f, -0.00145473f, -0.05782252f, -0.00517537f, 
    0.03001711f, 0.01869952f, -0.05586053f, 0.03016673f, -0.01553879f, -0.00710196f, -0.04045510f, -0.05156760f, 
    0.02776269f, 0.04724639f, -0.00524539f, 0.04144283f, 0.02106308f, 0.03715939f, -0.04346102f, 0.02780353f, 
    0.03911773f, -0.02125610f, 0.01638923f, 0.03647909f, 0.01547384f, -0.03798617f, -0.05430096f, -0.04072941f, 
    0.00990379f, 0.00992655f, -0.02522199f, -0.04455379f, -0.05738962f, -0.05515453f, -0.05758854f, -0.00777443f, 
    0.04230776f, -0.01274073f, -0.01576706f, -0.03687533f, -0.03236010f, 0.00822094f, 0.02122222f, 0.00306711f, 
    0.00203024f, 0.01898263f, 0.02028476f, 0.03307258f, 0.00458451f, -0.05016587f, 0.00121043f, -0.05346499f, 
    -0.04302454f, -0.00144382f, -0.04785673f, 0.00318648f, -0.03264514f, -0.03935646f, 0.01356621f, -0.01628966f, 
    -0.01876503f, -0.03045960f, -0.00570143f, -0.03872493f, 0.02344796f, 0.02992913f, 0.02729972f, 0.03448696f, 
    -0.04812043f, 0.02452313f, -0.03078439f, -0.03342294f, 0.02241070f, 0.04307876f, -0.00983960f, -0.05490915f, 
    -0.02402462f, -0.05130151f, -0.04189074f, 0.03110871f, -0.02709649f, -0.04105864f, 0.02361587f, 0.02251127f, 
    -0.04596758f, -0.00097260f, 0.00917935f, 0.02789729f, 0.01575667f, -0.00779843f, 0.03996810f, 0.03862676f, 
    -0.01000265f, 0.00556672f, 0.04611745f, -0.02360997f, 0.01186693f, -0.04363144f, -0.04425384f, -0.03973348f, 
    -0.00984214f, -0.03942765f, 0.03858082f, 0.03534055f, -0.03004786f, -0.03080734f, 0.02576103f, 0.00339512f, 
    0.02083438f, -0.00681141f, -0.02708452f, 0.01046547f, -0.01278869f, 0.02975616f, -0.04099468f, -0.03968373f, 
    0.04824256f, -0.04179186f, 0.00982049f, -0.05834539f, 0.02621127f, 0.03598862f, -0.02700767f, -0.03493977f, 
    0.03688634f, 0.00941588f, -0.05703488f, -0.05395627f, -0.02250103f, 0.02918608f, -0.01387384f, 0.04393230f, 
    0.02098576f, -0.02062276f, -0.01325582f, -0.05824996f, 0.05087908f, 0.02625097f, -0.00536079f, 0.04804497f, 
    -0.04165432f, -0.03222167f, 0.01683625f, -0.03651926f, 0.03400106f, 0.01142569f, 0.03272273f, 0.01548211f, 
    -0.00291508f, -0.01512817f, -0.04515048f, 0.03256563f, 0.03554877f, 0.01697616f, -0.02038521f, -0.03032588f, 
    -0.04995040f, 0.02466392f, -0.02089217f, 0.00933155f, -0.02575842f, 0.00066411f, -0.02699827f, -0.02542718f, 
    0.01620806f, -0.05826564f, 0.01170655f, -0.04531864f, -0.01118609f, -0.04182993f, -0.01240591f, -0.01910880f, 
    -0.03926466f, 0.01830642f, -0.01828266f, 0.00246714f, -0.02846626f, -0.05568045f, -0.01166873f, 0.02617578f, 
    0.14129578f, -0.20129962f, -0.06145551f, -0.18559650f, -0.03580981f, 0.10911336f, -0.18899240f, -0.12697341f, 
    -0.11419272f, -0.22425690f, -0.23223776f, -0.43366981f, 0.53778636f, -0.18311284f, 0.14391237f, -0.05967814f, 
    -0.06541979f, 0.04551194f, -0.11201034f, -0.18279137f, 0.13907780f, 0.11819349f, 0.09892855f, 0.04846711f, 
    -0.02273714f, 0.47766006f, -0.18235363f, 0.48950994f, 0.00380773f, 0.04285567f, 0.10907954f, -0.04520715f, 
    0.15178421f, -0.09033255f, -0.01971141f, -0.10825374f, -0.22822726f, 0.03536372f, -0.15083209f, -0.11908781f, 
    0.07547189f, 0.07489918f, -0.07573450f, -0.17618553f, -0.34382388f, -0.40484688f, -0.46677780f, -0.59930825f, 
    0.00861305f, -0.11192644f, -0.04093548f, 0.19611101f, 0.04928548f, 0.17040128f, 0.03422067f, -0.07606589f, 
    0.16972418f, 0.13267735f, 0.16413666f, 0.13796389f, -0.36175242f, -0.14082938f, 0.25355303f, -0.03373991f, 
    0.07111373f, -0.21400003f, 0.20369455f, -0.11897931f, -0.02067803f, -0.03556058f, -0.11241651f, -0.09603960f, 
    0.05661706f, 0.19095418f, -0.01637883f, 0.19057822f, 0.06517191f, 0.07885681f, 0.10795107f, 0.04010903f, 
    0.02811440f, -0.06401397f, 0.06296325f, 0.14688204f, 0.40135998f, 0.06634094f, 0.06833906f, -0.05088721f, 
    -0.12161049f, 0.05483526f, -0.14473678f, -0.14976791f, 0.23117159f, -0.09596579f, 0.08124963f, -0.01255594f, 
    0.10770539f, 0.00477897f, -0.25759578f, 0.11416487f, -0.12186081f, 0.05810391f, -0.11400723f, -0.10770691f, 
    0.18738988f, -0.08470578f, -0.12597653f, 0.26265222f, 0.02142104f, 0.12582494f, -0.04987789f, 0.19768994f, 
    0.01989159f, -0.00123713f, -0.06613623f, -0.22588471f, -0.17518975f, -0.26437303f, -0.12119646f, -0.16340287f, 
    0.29851085f, -0.18287815f, 0.04643818f, 0.33255753f, 0.15819135f, 0.00202778f, -0.00235355f, 0.08966708f, 
    0.12600155f, 0.21472608f, 0.16671062f, 0.31066105f, 0.10885397f, 0.11514087f, 0.04479261f, 0.31709644f, 
    0.24157529f, 0.18734404f, 0.06673088f, 0.10030435f, -0.09890291f, 0.07914795f, -0.12709613f, 0.09758054f, 
    0.11842633f, 0.19786398f, 0.12380616f, 0.19633414f, 0.13783437f, 0.04231150f, 0.12936033f, 0.41854662f, 
    -0.04924722f, 0.15586710f, 0.02319137f, 0.03077601f, -0.02988778f, 0.09407269f, -0.06344506f, 0.12932427f, 
    0.21365981f, 0.05333773f, 0.03101594f, -0.20861827f, -0.11937465f, -0.28309068f, -0.24205332f, -0.20779593f, 
    -0.00409183f, 0.10639412f, 0.25189218f, -0.01825000f, 0.26121119f, 0.01133431f, -0.10302706f, -0.19504438f, 
    -0.27104372f, -0.19378798f, -0.06559024f, -0.30508360f, 0.11851998f, -0.11280909f, 0.04146906f, -0.18504468f, 
    0.02915700f, -0.04922881f, -0.11041357f, -0.00470312f, 0.08260965f, 0.04063139f, -0.12141217f, -0.06644149f, 
    -0.06244517f, 0.01082227f, 0.04911413f, 0.07414068f, 0.01563552f, -0.24159202f, -0.16644223f, -0.31130779f, 
    -0.02636559f, 0.10647371f, 0.05105345f, 0.06966690f, 0.27934214f, -0.02548985f, 0.07225593f, -0.29681906f, 
    -0.04262758f, 0.04602712f, -0.13508408f, -0.21351907f, -0.09235846f, -0.03762044f, 0.04728433f, 0.11127593f, 
    0.24220271f, 0.14453767f, 0.18703851f, 0.12357974f, 0.12163839f, 0.00264720f, 0.02913378f, 0.03590361f, 
    -0.01865330f, 0.07770740f, 0.00195358f, 0.06112005f, -0.21533684f, -0.05633269f, -0.15085632f, 0.15986632f, 
    0.03835235f, 0.12073700f, 0.00634950f, -0.01556095f, -0.21429929f, -0.17518981f, -0.18452600f, -0.28694126f, 
    0.20294826f, 0.34766445f, 0.31137374f, 0.40499058f, 0.18740985f, 0.15780005f, 0.11321051f, 0.13137783f, 
    -0.09441551f, 0.03073486f, -0.15665096f, -0.13325894f, -0.00673789f, -0.08759759f, -0.07734095f, -0.42620853f, 
    -0.02106713f, -0.10282811f, -0.15822898f, -0.10119800f, -0.10306952f, -0.27616984f, -0.19980417f, -0.19249263f, 
    -0.25282073f, 0.08007181f, -0.13706240f, -0.20675029f, 0.15330184f, -0.23587050f, 0.03415281f, 0.01086858f, 
    -0.02123724f, -0.14736609f, -0.27427319f, -0.35910884f, 0.38922074f, 0.18064970f, 0.01722952f, 0.02748327f, 
    -0.04909020f, 0.07328741f, 0.06333364f, 0.16903414f, 0.09219249f, 0.00447183f, -0.12391939f, 0.08078571f, 
    0.02714835f, -0.15474513f, 0.20094287f, -0.24766172f, 0.02687529f, 0.12167609f, 0.17297530f, 0.05021261f, 
    0.13640206f, 0.32824221f, 0.08913498f, 0.32551762f, 0.14013116f, -0.14725606f, 0.14250013f, -0.06697182f, 
    -0.08470631f, 0.04365293f, 0.07132257f, -0.13146277f, 0.12688373f, 0.12732606f, 0.13844173f, 0.16344097f, 
    -0.01561927f, -0.10015852f, -0.03051903f, -0.24228549f, -0.00783367f, -0.06955288f, -0.12525003f, -0.15043701f, 
    0.02747484f, 0.08815610f, -0.00752969f, -0.05574067f, 0.00704672f, -0.18694718f, 0.07944013f, 0.09865972f, 
    -0.19238515f, 0.04390971f, -0.21941775f, -0.34353459f, 0.00362179f, -0.03205042f, 0.00924977f, 0.05302737f, 
    0.20277147f, -0.58248216f, 0.51748455f, -0.29883868f, 0.28527904f, 0.03370098f, 0.04692850f, 0.02908796f, 
    -0.18892747f, -0.03034483f, -0.35847756f, -0.28004399f, -0.00200871f, -0.35262960f, -0.06623451f, 0.00323192f, 
    0.01908350f, -0.06654599f, -0.07953154f, -0.36088690f, 0.03427872f, 0.11551248f, 0.10467342f, -0.03839492f, 
    0.23561057f, 0.11238217f, 0.05499883f, -0.18933785f, 0.08524526f, 0.21976592f, 0.14637376f, 0.20750916f, 
    0.02534402f, 0.12620801f, 0.01830494f, 0.13489084f, 0.12021662f, 0.06163838f, 0.05519783f, -0.02276435f, 
    -0.10511667f, 0.01015304f, 0.11949585f, 0.06681027f, 0.11108182f, 0.30616045f, 0.09912086f, 0.03116003f, 
    -0.06261009f, -0.06630185f, -0.05345425f, -0.03803168f, -0.04886339f, 0.01637341f, 0.05406792f, 0.02903710f, 
    0.12402585f, 0.00382204f, 0.00502171f, 0.04968401f, -0.22183554f, 0.03862703f, 0.03917215f, 0.11994524f, 
    0.04357066f, -0.16943286f, 0.00521094f, 0.06902884f, -0.06540094f, -0.03666699f, 0.10871977f, 0.14542666f, 
    0.08291966f, 0.19498484f, 0.22109011f, -0.07199237f, 0.23776481f, -0.00335936f, 0.15316488f, 0.06205625f, 
    -0.01474507f, -0.08400074f, 0.03488515f, 0.02302637f, -0.04568052f, -0.08110441f, 0.02748181f, -0.08668654f, 
    0.11999732f, 0.08383776f, -0.01133910f, -0.00775366f, -0.00694982f, 0.02676273f, 0.07992122f, -0.06390608f, 
    0.02939953f, -0.05822342f, -0.15354829f, -0.13115388f, -0.06587578f, -0.08216473f, -0.03319191f, -0.03361320f, 
    -0.01550523f, -0.06616618f, -0.10133200f, -0.02207836f, -0.21455555f, 0.35626230f, 0.41210467f, 0.03359070f, 
    0.00893634f, -0.02560041f, -0.00178317f, -0.08312307f, 0.15032473f, 0.06879285f, 0.33892322f, 0.04101351f, 
    -0.12110909f, 0.00738458f, -0.03548964f, 0.03671274f, 0.02783782f, -0.08873995f, 0.18635274f, 0.06429898f, 
    0.04181709f, 0.11389495f, 0.10831153f, 0.03894280f, -0.12616426f, -0.18746112f, 0.34378284f, 0.24394101f, 
    -0.08199192f, -0.08409452f, -0.00566389f, -0.04973271f, 0.16651066f, 0.00917010f, 0.24375093f, 0.01344415f, 
    -0.34092751f, 0.01725039f, 0.00149802f, 0.20047651f, -0.05995009f, -0.00548848f, 0.23388638f, 0.16389348f, 
    -0.03501529f, -0.01174771f, -0.09844260f, -0.02121986f, -0.00095819f, -0.09178732f, 0.01086311f, -0.13628004f, 
    0.01392071f, -0.03585037f, 0.00880462f, -0.02295107f, 0.10019033f, -0.04428434f, 0.03051964f, -0.02402641f, 
    -0.32659367f, 0.20094429f, 0.15963791f, -0.04009031f, -0.05978814f, -0.10826845f, -0.04831913f, -0.00913387f, 
    -0.03738590f, 0.09865239f, 0.11016239f, 0.04466572f, -0.02673233f, 0.20041563f, -0.10373728f, 0.19801813f, 
    0.01231434f, 0.14921561f, 0.13922441f, -0.04433104f, 0.06927306f, -0.01283608f, -0.08109056f, -0.07279707f, 
    -0.19705899f, -0.13458540f, -0.00752845f, 0.21034983f, 0.08014585f, 0.11918970f, 0.13592330f, -0.03713401f, 
    -0.02023662f, 0.04357647f, -0.00881204f, -0.03761908f, 0.13215354f, -0.00993656f, -0.04830802f, -0.16952252f, 
    -0.00088667f, -0.00137435f, -0.03592363f, -0.08550924f, 0.04500953f, 0.01516269f, 0.07752508f, 0.05242084f, 
    0.24502589f, -0.16888136f, -0.06017226f, 0.03047474f, 0.10361081f, -0.05087819f, -0.10135307f, 0.00249634f, 
    -0.02224525f, 0.05480296f, 0.19458155f, 0.06959836f, -0.16641928f, 0.12112438f, 0.00454596f, -0.03200236f, 
    -0.08567414f, -0.06161119f, 0.05180819f, 0.18299033f, -0.01164075f, -0.01201157f, -0.03795145f, -0.00409154f, 
    -0.15697891f, 0.14262186f, 0.10418246f, -0.23246261f, -0.05858890f, -0.05173025f, 0.02232474f, 0.01241581f, 
    0.08259042f, 0.07974033f, 0.07638060f, 0.01748742f, 0.09402079f, 0.03904980f, 0.23440395f, -0.08547229f, 
    0.00136709f, 0.03347328f, -0.02049862f, -0.01045341f, -0.02327378f, -0.11980779f, 0.03313494f, 0.03536088f, 
    -0.21349256f, -0.24027123f, -0.08612362f, 0.08278340f, -0.04546295f, -0.08964550f, -0.08249202f, 0.05995391f, 
    0.00430928f, 0.03201701f, 0.05603763f, 0.13579360f, 0.12868908f, 0.03937380f, -0.09263904f, 0.03857392f, 
    0.07787553f, 0.02204800f, 0.15225345f, -0.01758300f, -0.04928495f, 0.10896498f, -0.01539947f, 0.00929324f, 
    0.02086435f, -0.58713359f, 0.08779161f, 0.09627900f, 0.03966898f, 0.18876988f, 0.12486239f, -0.02039815f, 
    -0.07584498f, -0.07146334f, -0.01581982f, -0.01401533f, 0.07403886f, 0.00467388f, 0.03455509f, 0.02019671f, 
    0.07733221f, 0.06767828f, 0.07005438f, 0.06577630f, 0.03846283f, -0.01662645f, 0.00492854f, 0.18745977f, 
    -0.07983512f, -0.10938229f, -0.04532273f, -0.12814662f, 0.13902928f, 0.13367072f, 0.10808612f, 0.14019653f, 
    -0.02843807f, -0.00502031f, 0.05668597f, 0.11577111f, -0.19145590f, -0.08646449f, 0.04161286f, 0.07155770f, 
    0.10963014f, 0.02253814f, 0.07658753f, -0.05611452f, 0.01270007f, -0.00535786f, -0.07593977f, -0.01257622f, 
    -0.32822943f, 0.06667285f, -0.06851690f, 0.14389306f, 0.03734944f, 0.01056388f, -0.03345446f, 0.28064170f, 
    -0.00612714f, 0.18034589f, 0.01271980f, -0.17349316f, -0.00512644f, -0.01846054f, -0.10228336f, -0.01969167f, 
    -0.07301703f, 0.01632635f, 0.00646996f, 0.04497793f, 0.18177994f, 0.15028915f, 0.08381882f, 0.03725001f, 
    0.11673289f, 0.34137422f, 0.07211187f, -0.07510094f, 0.12978891f, -0.12963195f, 0.01282228f, 0.10463972f, 
    -0.03341564f, 0.13988411f, 0.01043433f, 0.20557728f, 0.11541557f, 0.00582906f, -0.19124372f, 0.03612600f, 
    -0.03223546f, -0.05802118f, 0.05324028f, -0.01650626f, -0.02407840f, 0.01402392f, 0.02881374f, -0.00866391f, 
    -0.16101784f, -0.02456447f, -0.21536832f, 0.17639911f, 0.10479129f, 0.03042567f, 0.02233068f, 0.19874167f, 
    0.00678988f, 0.00787005f, -0.05640798f, -0.05805511f, -0.23385063f, 0.10960419f, 0.03984363f, -0.04893972f, 
    -0.03352997f, -0.03939518f, -0.02793379f, 0.12849151f, 0.06804045f, 0.15644151f, 0.15940282f, -0.01652313f, 
    -0.41712511f, -0.24559003f, -0.00780071f, 0.04550410f, 0.08111972f, 0.01134010f, 0.02613298f, -0.08049528f, 
    0.00758278f, 0.07269448f, -0.04483980f, -0.08492760f, 0.44076484f, 0.00355214f, -0.23010777f, 0.16735511f, 
    0.03247645f, 0.06030697f, -0.09848446f, -0.05087423f, 0.00695582f, 0.10583176f, 0.14738014f, 0.00244170f, 
    -0.04158056f, -0.00344446f, -0.01090744f, 0.03426574f, -0.04590290f, 0.00104759f, 0.02441470f, -0.04863339f, 
    0.01798403f, -0.03541919f, 0.02745432f, 0.02126377f, 0.04188858f, -0.03322798f, -0.04545426f, 0.01909341f, 
    0.01018076f, -0.00129639f, -0.03527785f, -0.05686332f, -0.03908582f, 0.05025107f, 0.03163691f, 0.02387360f, 
    0.02057703f, 0.03558510f, -0.04726988f, -0.06022207f, -0.00252417f, -0.05111618f, -0.02666584f, 0.03816781f, 
    0.01761157f, 0.02529527f, -0.00393067f, 0.02086222f, -0.05410888f, 0.02489885f, -0.02821407f, -0.03955903f, 
    -0.03793033f, -0.00090623f, 0.01847309f, -0.02078187f, -0.00444383f, -0.05489941f, -0.01538697f, 0.04033878f, 
    0.00269899f, -0.02491082f, -0.01904744f, 0.01143479f, 0.03250713f, 0.01139196f, 0.03958765f, 0.00039092f, 
    -0.01639321f, 0.00703011f, 0.03855627f, -0.04631285f, -0.05055522f, 0.01752926f, 0.02095175f, -0.01612348f, 
    0.03354390f, 0.02256328f, 0.01394838f, 0.04163940f, 0.03465361f, 0.00177678f, 0.04266017f, -0.04696205f, 
    -0.01852587f, -0.00335301f, 0.04368795f, -0.02023138f, -0.01698974f, -0.03286701f, 0.01965790f, -0.02495151f, 
    0.04935691f, -0.04495030f, -0.04377777f, 0.04632222f, -0.05327157f, -0.04765400f, 0.01828748f, -0.01123889f, 
    0.03544152f, -0.01189819f, 0.00343513f, 0.00377731f, -0.04571997f, -0.04883240f, 0.01651696f, 0.04568393f, 
    -0.04716386f, -0.04506475f, 0.02031164f, -0.00435099f, 0.00242204f, -0.03707382f, -0.02138707f, 0.04516698f, 
    0.03786084f, 0.02714975f, -0.05695411f, -0.04188896f, -0.03796420f, -0.04223800f, 0.00789263f, 0.00294881f, 
    0.03879025f, 0.02683849f, -0.01801272f, -0.05887257f, 0.01639912f, -0.02038027f, 0.02631756f, -0.03245063f, 
    -0.00612176f, 0.04952635f, -0.03352141f, 0.02654170f, -0.00941126f, -0.00396496f, 0.02844791f, 0.02982771f, 
    -0.04691044f, 0.01938982f, -0.02107509f, -0.00659120f, 0.02395297f, 0.00665226f, -0.00982643f, -0.00586068f, 
    -0.00786927f, -0.04895535f, -0.00809327f, 0.01516396f, 0.02083222f, -0.02208257f, -0.01359516f, 0.02332448f, 
    -0.03185150f, 0.04267060f, 0.03968310f, 0.04350208f, 0.04679014f, -0.01810383f, 0.01728112f, 0.04610565f, 
    0.03885086f, 0.04106566f, 0.02448161f, -0.01041517f, -0.01927739f, 0.04059954f, -0.03284656f, -0.01627864f, 
    0.04175271f, 0.02714279f, -0.03056704f, -0.02598394f, -0.05421223f, 0.03939023f, 0.02907675f, -0.04106115f, 
    -0.00847605f, -0.03316544f, -0.01837741f, 0.00484773f, -0.00709370f, -0.03203480f, 0.01817568f, 0.01251497f, 
    -0.05748277f, 0.01659390f, 0.01633101f, -0.02693585f, -0.01551747f, 0.03586685f, 0.00240303f, -0.02916106f, 
    0.00156631f, -0.04820223f, 0.02869426f, 0.04564283f, 0.01782428f, -0.04390004f, 0.00957681f, 0.03531309f, 
    0.02738271f, -0.01758051f, -0.01683532f, -0.04076497f, 0.03539982f, -0.00888753f, 0.03171338f, 0.02683368f, 
    -0.04777994f, -0.05033361f, 0.02888975f, -0.03310256f, -0.02646154f, -0.01032230f, 0.03573865f, 0.02117393f, 
    -0.03333280f, 0.03007397f, -0.01204832f, -0.02086021f, -0.00933912f, -0.02275703f, -0.03184265f, -0.01656502f, 
    0.04158389f, -0.00873485f, -0.00521837f, 0.00675117f, -0.01596722f, -0.01095018f, -0.04150677f, 0.03193114f, 
    -0.00198079f, -0.01944864f, -0.03661882f, -0.01316422f, 0.00067943f, -0.01561645f, -0.05578591f, -0.01156725f, 
    0.01441541f, 0.02687530f, 0.03457585f, -0.00313233f, -0.02310718f, 0.03102803f, -0.00994350f, 0.02603327f, 
    0.02416941f, -0.00223740f, -0.02410069f, -0.01415705f, -0.02342228f, -0.02301957f, 0.00147326f, -0.03229350f, 
    -0.03156931f, -0.00861318f, -0.01632302f, 0.00678442f, 0.03159492f, 0.01404415f, -0.05236313f, -0.00988618f, 
    -0.04653215f, -0.01244188f, -0.00951920f, 0.03734322f, -0.05018529f, -0.04050416f, -0.00695742f, -0.01177649f, 
    0.00078539f, 0.04012567f, -0.05449409f, -0.03921992f, 0.04240875f, 0.04078833f, -0.01536378f, -0.01618201f, 
    0.02345027f, 0.00344183f, 0.01827065f, -0.03804433f, -0.03612193f, -0.01656118f, -0.00639042f, -0.01874867f, 
    0.04525621f, -0.03605623f, 0.01055805f, -0.04744834f, -0.01540179f, 0.01369078f, -0.01154467f, -0.05078661f, 
    -0.05445287f, -0.03510327f, -0.01101797f, -0.02783211f, -0.01100830f, -0.02769964f, -0.02434121f, 0.02117735f, 
    -0.02525330f, -0.01796889f, -0.01759035f, -0.03549865f, -0.02047828f, 0.01606575f, -0.02164580f, -0.03380097f, 
    -0.04797897f, -0.01874567f, -0.02513379f, -0.03368660f, -0.04650703f, 0.01432511f, -0.00180683f, 0.04487554f, 
    -0.05247631f, 0.04190965f, -0.04610599f, -0.05260479f, -0.05272891f, 0.00859301f, -0.05169518f, -0.03881299f, 
    -0.04083860f, 0.00314317f, -0.03400224f, -0.03985138f, -0.00462975f, 0.01406114f, -0.05547811f, -0.03454739f, 
    -0.00421536f, -0.03551483f, -0.04328005f, -0.01271977f, -0.02805207f, -0.05082072f, -0.00216315f, 0.04966493f, 
    0.01896576f, 0.02050052f, 0.01802621f, -0.02760171f, 0.04419562f, -0.00601830f, 0.00192713f, 0.02157165f, 
    0.02407563f, 0.00167507f, 0.03183461f, 0.03506068f, -0.01257930f, 0.04334107f, 0.00732951f, 0.00465326f, 
    -0.02221846f, -0.04224069f, 0.00636886f, 0.02283788f, 0.00433357f, -0.01339695f, -0.03728845f, 0.03722017f, 
    -0.04854205f, -0.00656189f, -0.03721122f, 0.03854418f, -0.00139736f, 0.02508960f, -0.01120519f, -0.04623899f, 
    -0.04039472f, -0.01593649f, 0.02753699f, -0.01198521f, 0.00677947f, -0.02816735f, 0.04189824f, 0.02851579f, 
    0.00202324f, -0.02366043f, -0.00078425f, 0.01757088f, -0.00994450f, -0.02406164f, -0.03295499f, -0.00810826f, 
    0.01893025f, 0.06625602f, -0.06630354f, -0.03570792f, 0.07862650f, 0.06365123f, 0.06724185f, -0.00495367f, 
    0.00918039f, -0.04825436f, 0.00021849f, -0.03239252f, 0.34643292f, 0.27981806f, 0.20453309f, 0.17439882f, 
    -0.01795088f, -0.04760424f, -0.05719952f, -0.05888215f, 0.12178217f, 0.14550604f, -0.03634157f, 0.05510763f, 
    -0.13637723f, -0.02021734f, 0.10075765f, -0.02924311f, -0.00613213f, -0.05847190f, 0.22798298f, -0.13035950f, 
    0.11200152f, 0.08440283f, 0.06295329f, -0.11130965f, 0.03759282f, -0.03833083f, -0.04707582f, 0.02044291f, 
    -0.11988211f, 0.06518627f, 0.14951709f, -0.01947806f, -0.03312993f, 0.01953352f, -0.10590899f, -0.04245033f, 
    -0.05891321f, 0.09486837f, -0.01236427f, -0.02980749f, 0.00020863f, 0.04219242f, 0.03053510f, -0.05667395f, 
    0.24585305f, 0.15649866f, 0.01557381f, 0.19459336f, -0.31705752f, 0.29260966f, 0.39140686f, -0.04875838f, 
    0.06988669f, -0.07929139f, -0.00673885f, 0.14056401f, 0.02045832f, -0.10408017f, -0.18765202f, 0.13526194f, 
    -0.01836339f, -0.12202662f, -0.05857063f, 0.11494909f, -0.10810286f, -0.00785089f, 0.03960303f, -0.06880304f, 
    0.03655387f, 0.02457248f, 0.02020012f, 0.14581381f, 0.36985719f, 0.20133224f, 0.20358534f, 0.19105829f, 
    0.10149617f, -0.07628660f, -0.07286531f, -0.16941190f, 0.13304666f, -0.11645748f, -0.31289187f, 0.13315855f, 
    0.01420305f, 0.33735347f, 0.00735977f, 0.13456550f, -0.10526756f, -0.24055971f, 0.12238051f, 0.05840848f, 
    -0.06397662f, 0.04881192f, 0.00043510f, 0.10904562f, 0.00711536f, 0.03962928f, -0.07066042f, 0.16801941f, 
    0.07059243f, -0.07827741f, 0.20689113f, -0.00908309f, 0.06539186f, 0.04814573f, -0.13880867f, -0.04248699f, 
    0.13478586f, 0.14888971f, 0.40214542f, 0.27817231f, -0.01460116f, -0.11837741f, 0.04060478f, 0.11711983f, 
    -0.00866170f, 0.07505906f, -0.01890237f, 0.07177797f, 0.07133360f, -0.14264356f, 0.21298231f, -0.01848860f, 
    -0.12476517f, 0.23972021f, -0.00320533f, 0.02074826f, -0.07590463f, 0.03514224f, 0.02663438f, 0.03395857f, 
    -0.21323092f, -0.13742249f, -0.13814333f, -0.04478852f, -0.03772962f, 0.06027481f, -0.02522623f, 0.20581710f, 
    -0.06826045f, -0.02630193f, 0.03060159f, 0.00197434f, 0.19049080f, -0.01631999f, 0.01562947f, -0.11883575f, 
    0.14379121f, -0.05796659f, 0.12634543f, 0.01570831f, 0.07376339f, -0.04108670f, -0.05171090f, -0.16807580f, 
    0.05685297f, 0.00891882f, -0.02522212f, 0.11379666f, 0.24057704f, 0.16879214f, -0.05885266f, -0.08491065f, 
    -0.08606935f, -0.09214050f, 0.03643012f, -0.07851100f, -0.01634625f, 0.06752589f, 0.23262557f, 0.00311370f, 
    -0.05053709f, -0.11878154f, -0.12628770f, 0.04381345f, 0.10304780f, 0.10213137f, 0.08304466f, -0.05049808f, 
    -0.04195283f, -0.03816025f, 0.20970900f, -0.09751040f, 0.03933495f, -0.00633268f, 0.00058291f, 0.02521439f, 
    -0.02303854f, 0.00572699f, -0.07813505f, 0.07848646f, 0.31835130f, -0.14631043f, -0.37763965f, -0.04048748f, 
    0.01403340f, 0.04173626f, -0.03858370f, -0.09580760f, -0.10455528f, 0.03583839f, -0.16429478f, 0.19202687f, 
    0.09007379f, 0.14663060f, -0.05992829f, 0.06162261f, -0.18069364f, 0.00216161f, 0.11947487f, 0.03630117f, 
    -0.19905102f, -0.16371085f, 0.07518794f, 0.02429394f, -0.12181219f, 0.08084056f, -0.14639139f, 0.03888316f, 
    -0.01567711f, 0.04097247f, -0.03915861f, 0.09379893f, 0.07393555f, -0.03686031f, -0.01233269f, -0.06595813f, 
    -0.19891723f, 0.15171275f, -0.13268653f, 0.08053047f, -0.03405632f, 0.18089597f, 0.29466462f, 0.06636633f, 
    0.02037887f, 0.00452707f, 0.05194203f, 0.03710385f, 0.00453265f, 0.05824748f, -0.07595316f, -0.06493085f, 
    -0.06535505f, -0.13810040f, 0.05592512f, 0.00406468f, 0.04321857f, -0.06281217f, 0.00280181f, -0.14155607f, 
    -0.09352891f, -0.00214888f, 0.21127348f, -0.10639394f, -0.09465992f, -0.10348817f, 0.20559128f, -0.01015411f, 
    0.11560361f, -0.10099262f, -0.04088056f, -0.13985778f, 0.02662450f, 0.04863143f, 0.01945329f, 0.14089677f, 
    -0.18004438f, -0.07740769f, -0.13088895f, 0.07457576f, 0.01849665f, 0.00995844f, 0.00918898f, 0.06289884f, 
    -0.04373249f, 0.01371052f, 0.02700767f, 0.06218813f, -0.03160996f, 0.08701713f, -0.14986788f, 0.01893843f, 
    0.20735408f, 0.07803975f, 0.00880954f, 0.30219969f, 0.09396724f, 0.01657006f, -0.03017627f, 0.03594260f, 
    -0.03771266f, -0.04923461f, 0.09211646f, -0.07846456f, -0.08788313f, 0.02864912f, 0.09009496f, 0.04670950f, 
    -0.10902895f, -0.12221368f, 0.12016596f, 0.08846258f, 0.03889284f, 0.06025682f, -0.05220477f, 0.05689615f, 
    0.02851707f, 0.08053382f, 0.12748410f, -0.26343492f, -0.08522302f, 0.06459657f, -0.11647610f, -0.04702177f, 
    -0.08317630f, -0.00771238f, 0.00037540f, -0.02125398f, -0.00159086f, 0.02245258f, 0.01235413f, 0.05988541f, 
    -0.23157476f, -0.13608404f, -0.04896182f, 0.03738641f, 0.04815071f, 0.12443716f, 0.00447431f, 0.12640101f, 
    0.00960107f, -0.01826016f, 0.00439094f, 0.00758566f, -0.23248605f, 0.21706757f, 0.12600160f, 0.05316327f, 
    -0.04482818f, -0.02436587f, 0.01963235f, 0.01514795f, -0.06035042f, 0.13003911f, -0.02433245f, 0.11395823f, 
    0.00801232f, -0.33369613f, -0.07954019f, 0.00835679f, -0.07550459f, 0.00306643f, -0.03613705f, 0.05018639f, 
    0.03356244f, 0.00378708f, 0.01297320f, -0.07519523f, 0.13355961f, -0.00841280f, -0.14064050f, -0.10343062f, 
    -0.06003055f, 0.12252160f, 0.05381113f, 0.01111420f, 0.00585123f, -0.04824860f, -0.07951190f, -0.06719325f, 
    0.00610179f, -0.21182175f, -0.14547093f, -0.13148321f, 0.11616564f, 0.07136776f, -0.03344158f, 0.03664315f, 
    0.13563927f, 0.08871323f, -0.03678478f, 0.05692583f, 0.13319246f, -0.23517245f, -0.13437662f, -0.12180179f, 
    0.19984809f, 0.19702558f, 0.03745966f, 0.04645242f, 0.10813310f, 0.10470545f, 0.05213186f, -0.06168060f, 
    0.38000080f, 0.31627512f, 0.16061793f, 0.24152723f, -0.01639583f, 0.02598789f, -0.03876507f, 0.09548464f, 
    -0.08937684f, -0.03580418f, 0.08121948f, -0.01118415f, -0.06878997f, 0.01488762f, -0.16541289f, 0.06722028f, 
    0.25635469f, -0.01495844f, -0.09611993f, -0.01493865f, 0.00546928f, -0.13385577f, -0.00946231f, -0.07120089f, 
    -0.21309909f, -0.29452655f, -0.09932179f, -0.06817863f, 0.00422396f, 0.00718463f, -0.09982010f, 0.02448153f, 
    0.15861721f, 0.07283965f, 0.17034514f, 0.07417051f, 0.09345025f, -0.33929777f, -0.34773481f, -0.01836159f, 
    0.06107854f, 0.00056524f, 0.03381397f, -0.16297165f, -0.05496027f, 0.16155916f, 0.06733225f, 0.03962497f, 
    0.25767562f, 0.22905971f, 0.23192169f, 0.18212512f, 0.08744092f, -0.00208641f, 0.07732160f, 0.15738183f, 
    -0.08052470f, -0.01372886f, 0.10413318f, 0.08133664f, 0.20135555f, 0.18071193f, 0.05577899f, -0.13714752f, 
    0.11680361f, 0.33617055f, -0.02295575f, -0.06168946f, 0.00979580f, 0.16848409f, 0.09894788f, -0.01822244f, 
    0.40056434f, -0.07576732f, -0.06218323f, 0.06653525f, 0.11661809f, -0.01726197f, 0.05042070f, -0.03302775f, 
    0.03515816f, -0.05134510f, 0.07308320f, 0.11687948f, -0.20428680f, -0.14304285f, -0.18350656f, -0.21844748f, 
    -0.11403629f, 0.01566528f, -0.01697809f, 0.00568214f, -0.03988436f, 0.08796576f, 0.13339359f, -0.06703778f, 
    0.37079653f, -0.03775056f, -0.11764650f, 0.12012109f, 0.18897119f, 0.22404459f, 0.11949664f, 0.01197988f, 
    0.10643561f, 0.15291350f, 0.17472233f, 0.12355003f, -0.15019448f, -0.33363506f, -0.24845888f, 0.22552413f, 
    0.08235934f, -0.04317295f, -0.06597375f, 0.01771933f, 0.08262681f, -0.02234048f, -0.03021972f, 0.05592008f, 
    0.47417518f, 0.30804121f, 0.37907690f, 0.31247035f, 0.03997179f, -0.07286382f, 0.12901410f, 0.08759268f, 
    -0.00729028f, 0.00366831f, -0.00857826f, 0.06363724f, -0.13684101f, 0.07390675f, -0.18402159f, 0.10029193f, 
    0.04226924f, 0.09296377f, -0.13059913f, -0.00169766f, -0.05534589f, -0.02959184f, 0.14375901f, 0.00444211f, 
    -0.04274043f, 0.15450293f, 0.15195483f, 0.04197091f, 0.00732803f, -0.09355178f, 0.00427595f, 0.00937883f, 
    -0.05894932f, -0.02048538f, -0.16963649f, 0.05636003f, 0.25401670f, -0.05111341f, -0.11110745f, 0.03247032f, 
    0.23353264f, 0.14759152f, 0.02602159f, -0.09883126f, -0.01569485f, -0.11428463f, -0.04591026f, 0.12192026f, 
    -0.31748241f, -0.35695156f, -0.43084341f, -0.06274327f, 0.06868465f, -0.03708540f, 0.00078035f, -0.14985970f, 
    0.04663693f, 0.06026475f, 0.00772006f, 0.06406116f, -0.37466815f, -0.22487289f, 0.02292496f, -0.18740217f, 
    -0.08345626f, -0.02600284f, -0.11182870f, -0.00502268f, 0.01829673f, -0.03321399f, 0.05115951f, 0.00094307f, 
    0.26723415f, 0.26504651f, 0.27011061f, 0.25320226f, 0.09464421f, 0.06297097f, 0.04766182f, 0.02801405f, 
    0.01937288f, 0.09362256f, 0.03860037f, 0.14983949f, 0.08630542f, -0.08527034f, 0.21592340f, 0.12172189f, 
    0.11160582f, 0.02973942f, 0.04927594f, 0.02363227f, 0.04987913f, 0.02950979f, -0.15622251f, -0.08098805f, 
    0.40298444f, 0.28536761f, 0.03682975f, 0.02378863f, -0.18995415f, -0.09811977f, -0.05630237f, 0.05364787f, 
    0.07410150f, 0.01198312f, -0.01202969f, 0.07531477f, -0.15028566f, -0.15320742f, -0.09629451f, -0.16416317f, 
    -0.01666665f, 0.06125362f, -0.14066961f, -0.04219781f, 0.07871570f, -0.10497294f, -0.10533375f, -0.01838391f, 
    -0.01745601f, -0.09129250f, -0.21945035f, -0.11285449f, 0.05367202f, -0.09923688f, 0.04356608f, -0.02750340f, 
    0.03124713f, 0.05841361f, -0.08246024f, 0.08517770f, 0.50699568f, 0.49358556f, 0.23507804f, 0.10434353f, 
    0.13116767f, 0.03739766f, -0.01901586f, 0.12481158f, 0.03528361f, -0.00796954f, 0.05806473f, 0.05875098f, 
    0.14966230f, 0.05901965f, 0.01564260f, -0.00721903f, -0.02946742f, -0.09844063f, -0.02199380f, -0.03146649f, 
    0.02286406f, -0.18577413f, 0.07013458f, 0.18078949f, -0.17040084f, -0.22369720f, -0.22485730f, -0.10326659f, 
    -0.09172078f, -0.01573451f, -0.08049095f, -0.03064275f, -0.05791180f, -0.05092176f, 0.00190198f, 0.02031158f, 
    -0.23989782f, -0.01987601f, -0.16346502f, -0.11117516f, 0.01016827f, -0.00108736f, -0.06400290f, -0.00089008f, 
    -0.08326964f, -0.17775738f, -0.15169001f, 0.09440252f, -0.33137169f, -0.31756493f, -0.10190736f, -0.14398648f, 
    -0.08085924f, -0.04859750f, -0.07900307f, -0.05377969f, 0.08985842f, 0.09713361f, 0.04285515f, 0.06225151f, 
    0.37772605f, -0.10914121f, 0.18629391f, -0.24985565f, -0.01251141f, -0.17697871f, 0.05162417f, -0.24820058f, 
    -0.02359123f, 0.02950369f, -0.09386297f, -0.01068895f, 0.07369232f, -0.17917207f, -0.29792598f, -0.00396180f, 
    0.20176585f, 0.09290063f, -0.03735835f, 0.07906415f, 0.03567185f, -0.15269028f, -0.01330524f, 0.09456245f, 
    0.47235185f, 0.63108832f, 0.39038047f, 0.24915595f, -0.04745958f, 0.03321658f, 0.05131719f, 0.08227639f, 
    -0.05701922f, -0.02480314f, -0.03433242f, 0.18246308f, -0.31608486f, -0.05741858f, -0.03574664f, -0.21695475f, 
    -0.01011552f, -0.08047552f, -0.00828773f, 0.09459789f, 0.05195435f, 0.00142844f, -0.00666853f, -0.07470655f, 
    -0.04904374f, -0.00722228f, -0.02014413f, -0.04610168f, 0.00201578f, 0.04135305f, -0.04211923f, -0.01219945f, 
    0.03634586f, -0.05424799f, 0.04475514f, 0.03624375f, 0.02064532f, -0.04190660f, 0.04812298f, 0.02787428f, 
    -0.01705903f, 0.01326227f, -0.04763780f, 0.03897715f, 0.01683893f, -0.01961087f, 0.00196826f, 0.03149728f, 
    0.00718588f, 0.00657588f, -0.05083236f, 0.01061903f, -0.04375445f, -0.04459522f, -0.00938075f, -0.01663879f, 
    -0.02311525f, 0.03945212f, -0.01022097f, -0.01561233f, -0.04615482f, 0.04064753f, 0.04163025f, 0.01201441f, 
    -0.04482622f, 0.03659837f, -0.02149770f, 0.00083622f, -0.01770824f, -0.03849541f, 0.01419015f, 0.03367399f, 
    0.04309370f, -0.01832701f, -0.04801018f, 0.04424198f, -0.02713157f, -0.00920626f, 0.00145563f, -0.04986067f, 
    0.00822896f, 0.01583282f, -0.01904605f, -0.00763151f, 0.03753930f, -0.02287588f, -0.00776591f, -0.00995036f, 
    0.02219214f, 0.02436457f, 0.03882944f, -0.03745164f, 0.00752909f, 0.03699889f, -0.04469854f, 0.00671170f, 
    0.01700037f, -0.00297603f, -0.02122388f, -0.00545887f, -0.02349097f, -0.05602734f, -0.00509764f, 0.03606360f, 
    -0.05192079f, -0.01502863f, -0.03625207f, 0.01789378f, -0.01089404f, -0.00186889f, -0.04256659f, -0.00478755f, 
    -0.03140934f, -0.01714150f, -0.04384303f, -0.03684896f, -0.04544967f, -0.00810407f, 0.00579225f, -0.04770460f, 
    0.02739887f, -0.00170683f, -0.05639621f, -0.02353137f, -0.04879584f, 0.03939838f, -0.01050997f, 0.05535527f, 
    -0.00218070f, 0.00826582f, -0.04848727f, -0.01314234f, 0.02640750f, 0.03308879f, 0.02996257f, -0.04072037f, 
    0.02262609f, -0.01518009f, -0.00202068f, -0.01889729f, -0.00586927f, 0.02163523f, -0.01742539f, -0.04244828f, 
    0.00656308f, -0.00546048f, 0.04524080f, -0.00043282f, 0.01348938f, 0.01130226f, 0.00977509f, -0.05111018f, 
    -0.04121754f, 0.01677347f, 0.03553443f, 0.02720022f, -0.02296669f, -0.00999769f, -0.00662777f, 0.02650949f, 
    0.02694949f, -0.02942829f, -0.00879923f, 0.00446678f, -0.04622613f, 0.00591405f, 0.01190699f, 0.00527280f, 
    -0.03893325f, 0.00884981f, 0.02382034f, -0.03543416f, -0.02517790f, -0.02012089f, -0.05303449f, 0.03659467f, 
    -0.01333882f, 0.01556212f, -0.05832935f, 0.03176285f, 0.02348756f, 0.02627684f, -0.00943951f, 0.01267318f, 
    0.01161977f, -0.01494382f, -0.05160919f, -0.01073998f, 0.04157132f, -0.04155289f, -0.03813738f, -0.00360072f, 
    -0.04185845f, -0.01208347f, -0.05713830f, -0.05287867f, -0.01659240f, 0.03602139f, 0.02057532f, -0.05521802f, 
    0.02544773f, 0.02838234f, 0.03872285f, -0.00667301f, -0.03291960f, 0.01940433f, -0.03309508f, 0.01361820f, 
    -0.05387596f, -0.04453588f, 0.00413931f, -0.02330191f, -0.04649706f, 0.04189656f, -0.02866851f, -0.00305040f, 
    -0.01609155f, 0.04326384f, -0.05176092f, 0.01934320f, -0.02202752f, 0.01386279f, -0.05369199f, -0.02557698f, 
    0.03973218f, -0.05186858f, 0.04177806f, -0.02973225f, -0.02774937f, -0.01890102f, 0.00855928f, -0.02716229f, 
    0.04422481f, -0.05205327f, -0.05234208f, -0.05638108f, 0.00482345f, 0.01065518f, 0.02762857f, 0.00982121f, 
    -0.03806234f, 0.03046142f, 0.03982073f, 0.04010589f, -0.01431361f, 0.01977985f, -0.00191250f, -0.04715521f, 
    0.02576614f, -0.01073407f, 0.04011711f, -0.04173937f, -0.01714334f, -0.00654636f, 0.02947409f, -0.00803202f, 
    0.04102323f, -0.01842094f, 0.01321106f, -0.01222147f, -0.00050061f, -0.04354045f, -0.00933877f, -0.04421627f, 
    -0.04763469f, -0.02416580f, -0.04174516f, 0.00650659f, -0.02343239f, -0.01102595f, -0.02874490f, -0.01093807f, 
    -0.05159548f, -0.01436508f, -0.01821503f, 0.00970181f, -0.00770447f, -0.02857580f, 0.03608746f, -0.01124847f, 
    0.01514969f, 0.01034698f, -0.05194245f, 0.00162900f, 0.01168033f, -0.03019444f, -0.05001146f, -0.01613997f, 
    0.00177014f, 0.00147055f, 0.05367348f, -0.01572607f, -0.03538102f, 0.02385218f, 0.02557270f, -0.05098250f, 
    -0.03713125f, -0.04002367f, -0.02103548f, -0.01322871f, -0.03419405f, -0.00415842f, -0.02569770f, -0.01787737f, 
    0.04149622f, -0.03473714f, -0.04540448f, 0.02198111f, -0.02980009f, 0.03896103f, 0.02147468f, -0.00855376f, 
    -0.01816126f, -0.00370726f, 0.01734501f, -0.02107215f, 0.04305662f, -0.02899477f, 0.03500911f, -0.03036400f, 
    0.04222710f, -0.03252992f, -0.01082696f, -0.02287904f, -0.03320013f, -0.01454738f, -0.00375919f, 0.03071236f, 
    0.01131136f, -0.03439100f, -0.02953044f, 0.01121017f, 0.00465319f, -0.02845337f, 0.02526559f, 0.02437334f, 
    -0.03817084f, -0.00557822f, -0.03972073f, 0.02986372f, -0.01915901f, 0.02558679f, 0.02662781f, 0.00316023f, 
    0.01124399f, 0.00916585f, 0.00308114f, -0.04053306f, -0.05184755f, -0.03892095f, 0.02502989f, -0.00440266f, 
    0.04161028f, -0.00633175f, 0.00298552f, -0.01444965f, 0.00650847f, -0.04153077f, -0.01440285f, -0.01624625f, 
    -0.02066521f, 0.02394036f, 0.02036252f, -0.00580515f, -0.00157314f, 0.00235525f, 0.01912027f, -0.04958095f, 
    -0.01532117f, -0.04744764f, 0.03904411f, 0.02678986f, -0.02391754f, -0.04509435f, 0.01942188f, -0.04567060f, 
    -0.03400577f, -0.01861160f, -0.04476152f, -0.05491078f, -0.01591539f, 0.00409881f, -0.03758793f, 0.01833753f, 
    0.01789030f, -0.03853687f, 0.03007003f, -0.00649718f, 0.02446599f, -0.05355551f, 0.03746958f, -0.03658031f, 
    0.01010944f, -0.01224498f, 0.02165141f, -0.03866747f, 0.00900361f, -0.02688424f, 0.03673355f, -0.02575884f, 
    0.03060607f, -0.02384387f, -0.04958512f, 0.00521837f, 0.02962398f, -0.05274594f, -0.01674092f, -0.04718059f, 
    0.03367814f, -0.07282226f, 0.07203458f, -0.04302756f, -0.08972269f, 0.05253080f, -0.01370968f, 0.07450143f, 
    -0.01814979f, 0.07840111f, -0.01691826f, -0.01320632f, -0.12319838f, -0.00972485f, 0.02370499f, 0.01276075f, 
    0.09293683f, -0.07111084f, -0.04667276f, 0.00096432f, 0.13168193f, -0.03341800f, 0.09151530f, 0.23570719f, 
    0.06103100f, 0.31186038f, -0.18799576f, -0.11162597f, -0.08453334f, -0.07669926f, -0.22581562f, 0.09559919f, 
    0.14361143f, -0.00501743f, -0.08251900f, -0.01531659f, -0.02651386f, -0.06972541f, 0.00239916f, -0.10712700f, 
    0.03412120f, 0.07252963f, 0.01301332f, 0.04282667f, 0.04074142f, -0.01874520f, -0.05892814f, -0.09594748f, 
    0.10908657f, 0.01385310f, -0.04610682f, 0.08418272f, 0.04567590f, 0.01351253f, 0.01987749f, -0.01460596f, 
    -0.12304021f, -0.01939549f, 0.13515535f, 0.00326670f, -0.32832471f, -0.20147493f, -0.00917420f, 0.02163580f, 
    0.04243152f, 0.02110223f, 0.04400340f, -0.11898424f, 0.06545989f, 0.01065016f, 0.10383569f, 0.13116241f, 
    -0.02048032f, 0.03790832f, -0.00028229f, -0.19666019f, 0.12380682f, -0.19029066f, -0.04929165f, -0.06811712f, 
    -0.12205631f, -0.00617713f, 0.02348256f, -0.09139767f, 0.11363351f, -0.17614187f, 0.03993960f, 0.02933899f, 
    0.06642082f, -0.00219568f, 0.07974533f, -0.04649533f, 0.27662516f, -0.06549954f, 0.06941316f, -0.00877785f, 
    0.01436295f, -0.36446118f, 0.09050380f, -0.06712974f, -0.04597900f, -0.00376328f, -0.09273710f, -0.16382022f, 
    0.08628511f, -0.07025931f, -0.03392299f, 0.08002488f, -0.03250063f, 0.00699033f, 0.09071783f, -0.15600048f, 
    -0.02939883f, 0.02804704f, -0.05699382f, 0.05447981f, 0.05796746f, -0.02886978f, 0.08385064f, 0.00909603f, 
    -0.04391484f, 0.07274964f, -0.02422091f, -0.05636862f, -0.01714298f, 0.02175550f, -0.03739357f, -0.02223706f, 
    0.08461220f, 0.03763089f, 0.14301856f, 0.18816771f, -0.10835625f, 0.19237962f, -0.10368216f, -0.04710496f, 
    0.09287212f, -0.16010498f, 0.10789289f, 0.09584240f, -0.02752758f, 0.04927589f, -0.01163081f, 0.07134931f, 
    0.05421651f, -0.01414076f, -0.03301308f, -0.04969104f, -0.00349011f, -0.07485198f, 0.08972792f, -0.03148331f, 
    -0.06912822f, -0.01280895f, -0.03170551f, 0.00615855f, -0.10812531f, -0.05018999f, -0.11006968f, -0.08160378f, 
    0.04361566f, -0.04308918f, -0.04676605f, -0.00179779f, 0.03676423f, 0.01033486f, -0.09349698f, -0.07204546f, 
    0.06295510f, -0.26430076f, -0.05593869f, -0.08969648f, 0.18559292f, -0.08779635f, 0.04259483f, 0.03855991f, 
    0.04242961f, 0.03060682f, 0.01759656f, -0.18512644f, 0.07735658f, 0.12119655f, -0.00780471f, 0.05319922f, 
    -0.03030289f, -0.03902519f, 0.08625654f, -0.00427355f, 0.07034261f, 0.00964683f, 0.00104215f, 0.07570474f, 
    -0.02316781f, 0.01552219f, 0.12402198f, 0.05987435f, 0.01147689f, -0.02007911f, -0.01231329f, -0.01529988f, 
    -0.00543956f, 0.14211927f, 0.09342982f, 0.02549353f, 0.07121744f, 0.12877235f, 0.09587603f, 0.07625245f, 
    0.17809351f, 0.02590791f, -0.00661064f, 0.05062140f, 0.07547232f, 0.06867988f, 0.12396690f, -0.02910373f, 
    0.06995599f, -0.05375564f, 0.00396813f, -0.06548896f, 0.14824784f, -0.07144043f, -0.11242888f, -0.02050295f, 
    -0.10574754f, -0.05705215f, -0.09026178f, -0.00139615f, 0.04975287f, -0.10001663f, 0.00664316f, -0.00801584f, 
    -0.00868047f, -0.16447276f, 0.03746551f, 0.06382163f, 0.03186471f, -0.03629761f, -0.03546413f, -0.04469806f, 
    -0.06883648f, -0.08889292f, 0.15921848f, -0.17002898f, 0.15676448f, 0.00837341f, 0.03710797f, 0.17929512f, 
    0.00457968f, 0.07591310f, 0.02271814f, 0.02781697f, 0.16734268f, -0.02329814f, -0.11773398f, -0.08930866f, 
    -0.00340571f, 0.03734758f, -0.04633759f, 0.04669859f, -0.10124882f, -0.01171874f, 0.02533578f, 0.07179442f, 
    0.02972906f, 0.17445081f, -0.10168348f, -0.00292251f, 0.06228166f, 0.03134357f, -0.16620159f, -0.01258227f, 
    0.02349992f, 0.05333296f, 0.01130999f, -0.02389207f, 0.00740818f, -0.03261239f, -0.16091278f, -0.22681461f, 
    0.00412472f, -0.03946816f, 0.10597738f, -0.07409188f, 0.00209654f, -0.05240893f, -0.02033543f, -0.03580960f, 
    0.07955119f, -0.27270532f, 0.02289183f, 0.07305346f, 0.09006920f, -0.10162862f, 0.09211446f, 0.01306644f, 
    0.00349244f, 0.12370235f, 0.19711247f, 0.10403097f, 0.03699924f, -0.11269792f, 0.18429066f, 0.05955779f, 
    -0.00264482f, 0.06538100f, 0.00870690f, 0.00764433f, 0.19181557f, 0.23079614f, 0.15747212f, 0.06367195f, 
    0.09187359f, -0.07659182f, -0.00319309f, -0.00512550f, 0.07824820f, -0.09807766f, 0.09970721f, 0.17233865f, 
    0.12846182f, 0.11882580f, -0.03472724f, 0.24389140f, 0.15150985f, 0.08644482f, -0.05209759f, 0.08599615f, 
    0.04230601f, 0.09820399f, 0.04487099f, 0.00517334f, 0.03596181f, -0.02111591f, -0.09397490f, 0.00510510f, 
    0.14462648f, -0.20472518f, -0.02365611f, -0.14857981f, 0.03713060f, -0.20274144f, 0.21183704f, 0.06537386f, 
    0.03437040f, -0.07169708f, -0.09329557f, -0.01849500f, 0.07623278f, -0.00971714f, 0.14757705f, 0.05730261f, 
    0.10734854f, -0.05245545f, 0.01089235f, 0.02357036f, -0.05037893f, 0.06941841f, 0.11052112f, 0.03890127f, 
    0.01802799f, 0.24461405f, -0.01148042f, -0.08120358f, 0.11491264f, -0.04669347f, 0.04719620f, 0.01574068f, 
    0.06356192f, 0.09308437f, -0.04271907f, -0.05833459f, -0.06952774f, 0.13498446f, 0.02746977f, 0.11296774f, 
    0.08557457f, 0.03114906f, -0.03117033f, -0.03641626f, -0.06826217f, -0.01478981f, 0.04936882f, 0.06424545f, 
    -0.17197196f, -0.08326472f, -0.14144939f, -0.14323044f, 0.05901325f, -0.01530650f, -0.00535425f, -0.08137830f, 
    -0.02103223f, 0.11831290f, 0.06068632f, -0.02077746f, -0.01661135f, 0.27084655f, -0.04473137f, 0.07266086f, 
    -0.01519272f, -0.01823808f, -0.10733806f, -0.00469766f, 0.01614234f, 0.04977135f, 0.00883387f, 0.11386801f, 
    0.14132024f, -0.26039657f, 0.24608400f, -0.08652265f, 0.07883351f, 0.05405364f, 0.02122059f, -0.13775313f, 
    -0.00685292f, -0.04320866f, -0.16737118f, 0.09087202f, 0.14506404f, -0.10053327f, -0.10403518f, -0.09648058f, 
    0.07569361f, -0.04708718f, 0.02296051f, 0.07981572f, 0.10639468f, -0.00985166f, -0.05990181f, -0.01447690f, 
    -0.15065102f, -0.28889394f, -0.20581730f, 0.02076246f, -0.10203444f, -0.10725892f, 0.00001953f, -0.06465841f, 
    0.01573535f, 0.01448183f, -0.06117378f, 0.00559324f, 0.31697387f, 0.31393066f, -0.31761155f, 0.09061770f, 
    -0.18486921f, 0.02473840f, -0.06269514f, 0.18187474f, 0.00215052f, -0.03934023f, 0.02575774f, -0.05472801f, 
    0.22607508f, 0.23180579f, 0.40900502f, 0.26170522f, -0.03288332f, 0.23609547f, 0.05298294f, 0.12638694f, 
    0.01970927f, -0.05731713f, -0.05636103f, -0.10983425f, -0.12856288f, 0.23471357f, 0.05661303f, 0.17476945f, 
    0.22920886f, 0.01042999f, -0.04541800f, 0.16915824f, -0.06329529f, -0.02208333f, 0.00388036f, 0.11128252f, 
    0.37730193f, 0.58943439f, 0.48001802f, -0.13429207f, -0.02696043f, 0.03930919f, 0.02809580f, 0.02887749f, 
    -0.11882550f, 0.02296951f, 0.14227468f, -0.21413422f, -0.09228809f, -0.21342325f, -0.20656928f, 0.07335254f, 
    -0.13930561f, -0.01847460f, -0.08685564f, -0.01427882f, -0.04428066f, 0.17764655f, 0.05830288f, 0.12584372f, 
    0.32659367f, 0.39765579f, 0.17524004f, 0.09731086f, 0.03706352f, -0.05679044f, 0.09897607f, -0.04539428f, 
    0.02269424f, -0.06551459f, -0.01521908f, 0.04614209f, 0.09326860f, -0.10293172f, 0.01335719f, -0.25894788f, 
    -0.03192566f, -0.24814117f, -0.08091725f, 0.15656292f, 0.10001820f, -0.08419026f, 0.05572636f, -0.02426194f, 
    0.14832285f, 0.16858710f, 0.25880125f, 0.00065166f, -0.06968822f, 0.13839054f, -0.03930757f, 0.16529222f, 
    0.00403045f, -0.06918497f, -0.00004384f, 0.04011597f, 0.08055661f, -0.09174260f, 0.00190369f, 0.03123419f, 
    0.00527793f, -0.04373845f, 0.10977244f, -0.09698484f, -0.00199543f, -0.04663402f, 0.09220757f, 0.15278262f, 
    -0.15918380f, 0.24420589f, 0.14707480f, 0.13120542f, -0.14386263f, -0.02942571f, 0.11241743f, -0.07585271f, 
    -0.05213999f, -0.09169424f, -0.01450983f, 0.02061809f, -0.00542663f, 0.09099748f, 0.05011971f, 0.03180023f, 
    0.07536165f, 0.08587781f, 0.11143672f, -0.04666258f, 0.06541417f, 0.18024169f, -0.02398649f, 0.02050711f, 
    0.12462799f, -0.10992846f, -0.24470443f, -0.10888862f, -0.08692664f, -0.01579774f, -0.13420005f, -0.08327091f, 
    -0.00277111f, -0.02831098f, -0.02221270f, -0.07725479f, -0.29715872f, 0.01524442f, -0.14753698f, 0.26959002f, 
    0.08216047f, -0.06606307f, 0.00889810f, 0.13704748f, 0.05558788f, -0.09045025f, -0.02535794f, 0.02124611f, 
    0.01162278f, 0.40419933f, 0.26825309f, 0.18547356f, -0.03999217f, 0.19973545f, 0.07801803f, -0.01471149f, 
    -0.15017590f, -0.07275136f, -0.04046994f, -0.03415587f, -0.00841920f, 0.00934282f, 0.05082495f, 0.02273464f, 
    -0.00051289f, 0.03103571f, 0.05471567f, 0.17321466f, 0.04210350f, 0.08057069f, 0.01536432f, 0.14641801f, 
    -0.05434235f, 0.02714287f, -0.07755016f, -0.03459483f, -0.28795558f, -0.13970272f, -0.23193690f, 0.06325331f, 
    -0.02337393f, -0.00652272f, 0.10589852f, -0.11913302f, -0.12479340f, 0.00315006f, -0.11509130f, 0.07138751f, 
    -0.02046847f, 0.10300487f, -0.02340898f, 0.00573801f, 0.09835471f, 0.10575713f, 0.02569992f, -0.17457326f, 
    0.24129897f, -0.10384367f, -0.03517703f, -0.04515328f, 0.05497328f, 0.07550771f, 0.09154895f, 0.07289090f, 
    0.01240085f, 0.03314161f, -0.00120423f, -0.02013547f, 0.01371461f, 0.18924324f, 0.26453683f, 0.15499237f, 
    0.04754971f, 0.08069683f, 0.04108401f, 0.16517486f, 0.02522077f, -0.01425831f, -0.04730514f, 0.07636687f, 
    0.04639375f, 0.34308577f, 0.01751668f, -0.06850420f, -0.02699881f, -0.15585917f, -0.21693985f, -0.01126953f, 
    -0.09554065f, 0.17112908f, 0.00377863f, 0.08875760f, -0.15978490f, 0.08478776f, 0.04037122f, -0.10109065f, 
    -0.04785753f, -0.06570178f, -0.14864929f, -0.00915966f, -0.00794427f, -0.13880087f, -0.05192198f, 0.25180846f, 
    0.00665788f, 0.02623157f, -0.06478474f, 0.22075081f, -0.04117211f, 0.06099646f, 0.12610920f, -0.00671411f, 
    0.12038282f, -0.05263962f, 0.07121706f, -0.04040276f, -0.46778202f, -0.32093969f, 0.09485891f, 0.07703172f, 
    -0.01680389f, -0.03800131f, -0.07609861f, -0.08898737f, 0.06239694f, 0.03272760f, -0.06334837f, 0.04893741f, 
    -0.28004864f, 0.33337975f, -0.04255372f, 0.09709645f, -0.31631228f, 0.10054154f, 0.05169060f, -0.00946606f, 
    -0.16061349f, -0.02123454f, 0.05423205f, -0.04106544f, 0.06290395f, 0.35434946f, -0.04983754f, -0.07013344f, 
    -0.00729528f, -0.00626585f, 0.11403494f, -0.16052687f, 0.07111074f, -0.01969361f, -0.09614303f, 0.05365649f, 
    0.02771419f, 0.16069601f, 0.14186020f, 0.24582447f, -0.01148053f, 0.01332460f, -0.00758023f, 0.32638195f, 
    -0.01086275f, -0.02918689f, 0.09344909f, 0.07448000f, -0.57376271f, -0.20743755f, 0.09818523f, 0.12185276f, 
    0.09849077f, -0.12770864f, -0.10744071f, -0.28394642f, 0.09962188f, -0.07058266f, -0.07716645f, 0.10517436f, 
    -0.13662560f, 0.00488540f, -0.00388532f, -0.07552411f, 0.10614157f, -0.11843640f, -0.01385625f, -0.02948664f, 
    -0.00130332f, 0.03103243f, 0.05778847f, 0.06472830f, 0.44333875f, 0.08125138f, -0.19797237f, 0.02766448f, 
    -0.01011431f, 0.03428591f, 0.02066427f, -0.04010688f, -0.00722108f, 0.19697480f, -0.09393029f, 0.04540788f, 
    -0.09363797f, -0.23380119f, 0.23710664f, -0.05024991f, 0.13669406f, 0.12561108f, 0.12935188f, -0.06154775f, 
    -0.03515753f, 0.01640117f, -0.04368441f, 0.07328904f, 0.05776140f, -0.16598055f, -0.07692959f, -0.07299599f, 
    -0.02951124f, -0.03375669f, 0.01891245f, -0.05042963f, -0.02812073f, -0.04337229f, 0.02977074f, 0.15487498f, 
    -0.18926312f, -0.11053257f, -0.15907413f, -0.12249784f, -0.15098482f, -0.11240974f, -0.07631686f, -0.04996049f, 
    0.05298435f, 0.07928109f, 0.11667786f, 0.07259272f, 0.29160661f, 0.17325746f, -0.00972105f, 0.14597589f, 
    -0.05255055f, -0.04284519f, 0.04842975f, 0.05551317f, -0.10206443f, -0.01042283f, -0.04048947f, -0.00040128f, 
    0.16161886f, 0.04636760f, 0.19087648f, 0.38453737f, -0.14875048f, 0.14821190f, 0.04642621f, 0.13091421f, 
    0.04898295f, -0.02120845f, 0.04980779f, -0.02162944f, 0.16024174f, 0.23075493f, -0.05954779f, 0.22307619f, 
    0.04336294f, 0.00155206f, -0.06706882f, 0.11749544f, -0.13036649f, -0.12506953f, -0.18807603f, 0.12032195f, 
    0.18090549f, 0.36409700f, 0.48999515f, 0.19510728f, 0.03741558f, 0.08589410f, 0.18150000f, 0.03693677f, 
    -0.09029017f, 0.03236383f, 0.05770387f, -0.06595849f, -0.15918137f, -0.22677901f, -0.12985180f, -0.03689570f, 
    -0.06631068f, -0.10505098f, 0.00350860f, -0.10967726f, -0.13935855f, 0.08765283f, -0.12129112f, 0.09480032f, 
    0.35370690f, 0.25709632f, 0.20857963f, 0.23069280f, -0.00595743f, -0.03336511f, 0.07544877f, -0.03878457f, 
    0.00379588f, -0.00207481f, -0.11532863f, -0.04818618f, -0.06235652f, 0.05063464f, 0.04121534f, -0.28820238f, 
    -0.12339070f, -0.02833751f, -0.22758034f, 0.00674030f, -0.01836636f, 0.00700330f, 0.01069092f, 0.03931801f, 
    -0.05770696f, 0.03451170f, 0.08511139f, 0.10850058f, -0.07947704f, -0.02191805f, -0.11678279f, -0.04738007f, 
    0.03850974f, -0.02641229f, -0.02277390f, -0.07191440f, 0.07096710f, -0.19482496f, 0.09030551f, 0.00398144f, 
    0.00924720f, -0.07397653f, 0.07569976f, 0.00840621f, -0.01659605f, 0.06090404f, 0.12666874f, 0.15550590f, 
    -0.09011725f, 0.15363374f, 0.06373568f, 0.14110164f, -0.16080056f, 0.02265647f, -0.01153093f, -0.05115636f, 
    -0.03946635f, -0.00278784f, 0.10110068f, 0.14425416f, -0.05633448f, -0.02392892f, 0.12810583f, 0.12134162f, 
    -0.00809912f, -0.01630729f, 0.08922069f, -0.08325837f, -0.00716735f, 0.07237139f, 0.06607876f, 0.00511499f, 
    0.05746054f, -0.14356518f, -0.11255799f, -0.11083059f, -0.04471636f, -0.11535940f, -0.18035792f, -0.10190929f, 
    -0.14161728f, -0.13466777f, -0.04826645f, -0.09027651f, -0.09213272f, -0.29469055f, -0.32267714f, -0.12991779f, 
    -0.02013803f, -0.12788534f, -0.06343018f, -0.02504065f, -0.08711136f, -0.00854293f, -0.08908936f, 0.05880863f, 
    0.14036518f, 0.31894609f, 0.03134492f, 0.28522009f, -0.04722341f, 0.13742703f, 0.10610012f, 0.07352320f, 
    0.02834673f, 0.11404517f, 0.08412167f, -0.14443091f, -0.14896384f, 0.01790532f, 0.05496491f, -0.08606441f, 
    0.04067503f, -0.00302099f, -0.07224278f, 0.14315276f, 0.02851445f, 0.04400983f, 0.05159101f, 0.15752003f, 
    -0.26743150f, -0.06966028f, -0.15678820f, -0.20865126f, -0.06964900f, -0.02577856f, -0.02019381f, -0.10927899f, 
    -0.00944004f, -0.07073746f, -0.04471174f, -0.00858857f, -0.13512722f, -0.01807868f, -0.12002788f, 0.00091728f, 
    -0.03518099f, 0.05927319f, 0.06225591f, 0.05788839f, 0.01670918f, 0.09133573f, 0.08342739f, -0.13612381f, 
    0.02609097f, -0.20058578f, 0.07765663f, -0.05880186f, -0.17108652f, -0.01960088f, 0.06974140f, -0.01619202f, 
    0.07099032f, 0.08446711f, -0.12873888f, -0.10554276f, 0.00551722f, 0.08514888f, 0.19778503f, 0.35113069f, 
    -0.07793687f, -0.01128863f, 0.07666721f, 0.10909304f, -0.04917723f, 0.03219325f, 0.02760194f, 0.07985544f, 
    0.04680254f, 0.22428061f, -0.13985646f, -0.09059911f, -0.05455595f, 0.06926161f, -0.17671992f, -0.14375913f, 
    0.12824334f, 0.01889303f, -0.10025740f, -0.02918604f, -0.03374669f, 0.00749910f, -0.03947285f, -0.06984881f, 
    0.04624016f, -0.12365229f, -0.11876740f, -0.08188435f, -0.20122048f, -0.10965654f, -0.11034377f, -0.06698764f, 
    0.04449585f, -0.00583085f, 0.04241845f, 0.05587777f, 0.00719489f, 0.07395478f, 0.03780708f, -0.10655652f, 
    0.13917235f, 0.14890307f, 0.09717415f, -0.29784310f, -0.26327872f, -0.13497683f, -0.04316985f, -0.20763250f, 
    -0.13792367f, -0.05669511f, -0.09645132f, -0.07465965f, 0.02658080f, -0.01269663f, 0.06838632f, 0.07975248f, 
    -0.13232724f, 0.10106255f, -0.13064352f, 0.14595458f, -0.10910078f, 0.12774584f, -0.10912868f, -0.05872801f, 
    -0.11910153f, 0.01104225f, 0.06055526f, -0.04130920f, -0.02412687f, 0.20505476f, -0.07581780f, 0.00754505f, 
    -0.05064927f, 0.03709298f, 0.00091851f, -0.13301729f, -0.02043865f, 0.02871667f, -0.00679555f, -0.05065849f, 
    0.05935623f, -0.11290293f, 0.09997242f, 0.28093627f, -0.12427047f, 0.01341177f, -0.06621514f, 0.09931341f, 
    -0.01934355f, -0.04460008f, -0.06005318f, -0.05729474f, -0.08729398f, -0.08205081f, -0.00931072f, -0.12455536f, 
    -0.01691073f, -0.06593963f, -0.07652595f, -0.09209501f, -0.02021110f, -0.06121626f, -0.11611766f, -0.02223096f, 
    -0.00497458f, -0.09836996f, -0.05582085f, -0.14507866f, -0.03302226f, -0.03653178f, 0.05020578f, -0.01474676f, 
    0.02227500f, -0.01289240f, -0.07199728f, 0.02671604f, 0.13449404f, -0.17850611f, -0.11890642f, -0.12235792f, 
    -0.03334027f, -0.15257277f, -0.09851773f, -0.16647281f, -0.00317042f, 0.00948284f, 0.09351485f, 0.14717482f, 
    0.02997205f, 0.45550659f, 0.20282505f, 0.09186080f, 0.15937175f, 0.03994700f, 0.05817576f, 0.36317688f, 
    -0.08050606f, -0.04286605f, 0.16477330f, 0.00601558f, -0.09268589f, -0.07166459f, 0.01403334f, -0.07993916f, 
    0.06066279f, 0.02930502f, 0.00512140f, -0.03416766f, 0.01618102f, 0.01241543f, 0.06895205f, -0.09590977f, 
    0.05593310f, 0.05726469f, -0.02960416f, -0.16057239f, -0.05144918f, -0.04644388f, -0.08626956f, -0.11534370f, 
    -0.06929836f, -0.08144335f, 0.03656983f, -0.01056565f, -0.12735677f, 0.12848973f, 0.45034602f, 0.26014245f, 
    0.00270265f, -0.00262720f, 0.02950349f, -0.10415716f, 0.02912537f, 0.13041691f, 0.26616994f, 0.25640318f, 
    -0.01750883f, -0.05380416f, -0.08121200f, 0.07262675f, 0.08649522f, -0.14349221f, 0.14919779f, 0.07006745f, 
    -0.00097124f, 0.15460081f, 0.03930783f, 0.10331131f, 0.28397492f, -0.22072375f, 0.22036785f, -0.00576626f, 
    -0.14814848f, 0.02279830f, -0.10690628f, -0.09298347f, 0.06414041f, 0.06678852f, 0.30010575f, 0.11890440f, 
    -0.26540762f, -0.24448358f, -0.20667137f, 0.13847043f, -0.10861132f, -0.09607760f, 0.20218174f, 0.14808437f, 
    0.06112362f, 0.00925502f, -0.05191974f, 0.04435961f, -0.02453083f, 0.05143887f, 0.08017095f, -0.22904438f, 
    -0.10900205f, -0.00376800f, -0.06509811f, -0.04142043f, -0.05443491f, -0.05174256f, 0.04117602f, -0.05082280f, 
    -0.18026142f, -0.20047453f, -0.03045393f, 0.02523033f, -0.06162161f, -0.05950872f, -0.05250460f, -0.03479004f, 
    0.05664181f, 0.09027277f, 0.07175893f, 0.02135617f, -0.11616258f, 0.21801259f, -0.06434358f, 0.36735490f, 
    -0.05116202f, 0.15761624f, 0.20158470f, 0.02339852f, -0.03592782f, -0.00217427f, -0.02640087f, 0.03866835f, 
    -0.13994956f, -0.05847820f, 0.08107712f, 0.30263630f, -0.02654911f, 0.01554829f, 0.01353522f, -0.09398976f, 
    -0.01246650f, 0.01574294f, -0.00842560f, -0.02065231f, -0.00395275f, 0.05617110f, -0.06163491f, -0.02899373f, 
    -0.11731290f, -0.00266652f, -0.07214202f, -0.01280799f, -0.05308019f, 0.03989769f, 0.14330424f, -0.10935990f, 
    0.33550930f, -0.09497663f, -0.07123896f, -0.04863734f, 0.05383339f, -0.06800487f, -0.07378590f, 0.07532529f, 
    0.05559802f, 0.02250309f, 0.09817625f, 0.22296725f, -0.07400025f, 0.00073217f, -0.14246613f, -0.04437143f, 
    -0.15377803f, -0.10013365f, 0.08763535f, 0.16542278f, 0.06840932f, -0.01470119f, -0.03921518f, -0.04781847f, 
    -0.13208289f, 0.16267359f, 0.19781469f, -0.08862479f, -0.02044466f, -0.03750558f, -0.04962194f, -0.00182196f, 
    0.09777196f, 0.06383958f, 0.05985654f, 0.04042035f, 0.16549988f, -0.03399427f, 0.18217069f, -0.33928531f, 
    0.05323175f, -0.03078084f, -0.09226781f, -0.03664254f, -0.01388168f, -0.06896052f, -0.05680433f, 0.04740475f, 
    -0.06113390f, -0.24253412f, -0.15589710f, 0.07785426f, 0.00490798f, -0.05999336f, -0.00451988f, 0.12281629f, 
    0.03322295f, 0.14796361f, -0.00857120f, 0.12124823f, 0.12388728f, 0.00379944f, 0.03320042f, 0.01539195f, 
    0.07786844f, -0.07971884f, 0.09952269f, 0.05754766f, -0.09905826f, 0.05240642f, -0.02205114f, 0.01636996f, 
    0.02463134f, -0.31718743f, 0.08031676f, 0.09330273f, -0.04071455f, 0.09379535f, 0.13864145f, -0.04032107f, 
    -0.05703837f, -0.02877604f, -0.04706146f, 0.03945474f, 0.15154660f, -0.05865104f, -0.05701565f, -0.09554149f, 
    0.18578465f, 0.01805984f, 0.00006361f, -0.01837956f, -0.03952901f, -0.06581781f, 0.03252780f, 0.11931565f, 
    -0.11538124f, -0.03608945f, -0.07072069f, -0.10554521f, 0.01811496f, 0.14802180f, -0.01136536f, 0.03304131f, 
    -0.06880314f, 0.02263538f, -0.04625846f, 0.07253562f, -0.17395501f, -0.21149516f, 0.02956777f, 0.05057238f, 
    0.13650723f, 0.07028889f, 0.07556145f, 0.03666063f, -0.05618262f, -0.02264042f, 0.01738917f, 0.01465835f, 
    -0.13698080f, -0.04409167f, -0.09774043f, 0.15995504f, 0.00767002f, 0.05260893f, 0.03054745f, 0.07334792f, 
    0.00194163f, 0.01183098f, 0.10797292f, -0.11447860f, 0.11008409f, -0.12253079f, 0.03211745f, 0.02581473f, 
    -0.02297720f, -0.02908093f, 0.04388960f, -0.06892005f, 0.20350888f, 0.13121161f, -0.00222061f, 0.01172788f, 
    0.24394724f, 0.23451357f, 0.04760426f, -0.18234994f, 0.16844887f, -0.15751755f, -0.01096574f, 0.01966498f, 
    -0.02371196f, 0.13116440f, -0.06084940f, 0.20617519f, 0.16735227f, -0.00018697f, -0.19754364f, -0.14724845f, 
    -0.08169165f, -0.07405262f, -0.03554135f, 0.00432956f, 0.03443884f, 0.00725983f, -0.01428074f, -0.08072647f, 
    -0.05707173f, -0.15795024f, -0.08095444f, -0.00342448f, 0.24994834f, -0.07000151f, 0.07482669f, -0.00769503f, 
    -0.00251903f, 0.04068954f, -0.05624976f, -0.04619487f, -0.07223698f, -0.12577519f, -0.02882905f, -0.11864237f, 
    -0.02723137f, -0.09697384f, -0.08703736f, 0.07885915f, 0.06267840f, 0.13129440f, 0.14830498f, 0.11006166f, 
    -0.21527533f, -0.08224335f, 0.14209692f, 0.02180349f, 0.02269453f, -0.04991540f, 0.00239792f, -0.11824952f, 
    -0.04672965f, 0.00402977f, -0.07748696f, -0.03459788f, 0.55953425f, 0.01105768f, -0.07113978f, 0.07761148f, 
    0.06511968f, 0.06079009f, -0.05355709f, 0.01695033f, -0.07205634f, 0.11039542f, 0.01992797f, -0.11837607f, 
    0.03678956f, -0.03198865f, -0.03895535f, 0.00895073f, -0.02594864f, -0.03694296f, -0.03935039f, -0.02383387f, 
    -0.04241125f, -0.00451327f, -0.03973556f, 0.03997613f, 0.02416781f, 0.04411894f, -0.02799136f, -0.04471065f, 
    -0.05128502f, -0.02808304f, 0.00215271f, 0.04235962f, 0.00441003f, -0.04513122f, -0.00490674f, 0.00265185f, 
    -0.03577417f, -0.00764174f, -0.03441732f, 0.02956773f, -0.00259561f, -0.04800839f, -0.05637025f, -0.04050490f, 
    0.02157238f, -0.01621483f, 0.04035402f, 0.03262262f, 0.03220531f, 0.03347926f, -0.00108532f, -0.02986974f, 
    0.02144945f, 0.02827406f, 0.00635656f, -0.00513736f, 0.00979945f, 0.00191034f, 0.02442464f, -0.02401566f, 
    -0.04357236f, -0.01881758f, -0.03297982f, 0.01444441f, -0.03010582f, 0.01329243f, 0.00204034f, 0.02951156f, 
    0.03394539f, 0.00339459f, -0.01205738f, 0.02135009f, -0.04510019f, -0.04395237f, 0.03756087f, -0.03849791f, 
    0.00387027f, 0.02019909f, -0.04107494f, 0.03924334f, -0.00423861f, -0.02226359f, 0.01913903f, -0.00731773f, 
    -0.03538083f, 0.00122761f, -0.05575624f, 0.01240489f, 0.03737782f, 0.03227315f, -0.04409631f, -0.05356786f, 
    -0.01857697f, 0.01563712f, -0.04469748f, 0.00980389f, 0.03825782f, 0.02987983f, -0.02360308f, -0.04769490f, 
    0.00019394f, -0.03076203f, -0.02595605f, 0.03265863f, 0.02376276f, 0.03793721f, -0.04691585f, -0.03917615f, 
    0.02277285f, -0.05236594f, -0.02056122f, -0.02073232f, -0.00685382f, 0.00157883f, -0.00931528f, 0.01776708f, 
    0.03949840f, -0.02255019f, 0.02458394f, -0.05553295f, 0.01856124f, -0.01906998f, -0.05575208f, 0.01028434f, 
    -0.03909299f, -0.04876151f, -0.02677824f, -0.04497866f, -0.04849289f, -0.03653800f, -0.05322758f, -0.04033561f, 
    0.03184910f, -0.02825571f, 0.04155473f, -0.04043562f, 0.03717151f, -0.01462642f, 0.00304779f, 0.03322731f, 
    -0.04179195f, 0.03900728f, -0.04186158f, -0.00897114f, 0.00639352f, 0.03294133f, -0.02096807f, -0.03882214f, 
    0.03013704f, -0.04147996f, -0.01972533f, -0.01897102f, -0.01379343f, 0.00246909f, 0.03155625f, -0.01971599f, 
    -0.00187578f, -0.05506979f, -0.04450724f, 0.02936040f, 0.02556485f, -0.03454219f, -0.02123683f, -0.00896039f, 
    -0.02846628f, -0.04103881f, -0.02311096f, -0.04578125f, -0.02892987f, 0.01657295f, -0.05080429f, -0.04880488f, 
    -0.04931251f, 0.00016398f, -0.02974782f, 0.00764491f, 0.01534024f, -0.02866294f, -0.02993400f, 0.04082812f, 
    -0.01235397f, -0.03620985f, -0.05630885f, 0.01530670f, 0.01684003f, -0.01702846f, -0.00883591f, -0.04876732f, 
    0.02319196f, -0.05041730f, 0.03340996f, -0.03495631f, 0.01416434f, -0.00777389f, -0.01543771f, -0.01058107f, 
    -0.01625661f, 0.04324290f, 0.02629080f, -0.03416374f, 0.04546308f, -0.01203987f, -0.04571670f, 0.01054652f, 
    -0.00748911f, 0.02646219f, 0.00009847f, 0.03836526f, 0.00964718f, -0.02759892f, -0.03402830f, -0.05205006f, 
    0.04165554f, 0.03749294f, 0.00116342f, -0.02193709f, 0.04020839f, 0.02261070f, 0.01928299f, -0.05272085f, 
    0.03364008f, 0.02060914f, -0.00627736f, 0.01402510f, -0.04684184f, -0.01915687f, -0.00556661f, 0.01660722f, 
    -0.01864546f, -0.00889784f, -0.05568127f, -0.03461897f, 0.03263347f, -0.02410037f, 0.01630420f, -0.00050612f, 
    0.01085892f, 0.01704873f, -0.04476705f, -0.00807313f, -0.00188918f, 0.04145170f, -0.02226369f, 0.02229695f, 
    0.00335407f, -0.03548142f, -0.03598347f, -0.02730290f, -0.00197802f, -0.04262881f, 0.02688005f, 0.03210411f, 
    0.02378584f, -0.03035219f, -0.02424294f, 0.00439024f, 0.02788433f, 0.04431063f, 0.04140643f, -0.01153785f, 
    -0.01289783f, -0.01309706f, 0.03908842f, 0.01495761f, -0.03045836f, 0.02319151f, -0.04186011f, -0.02737106f, 
    -0.00868100f, 0.01029057f, -0.00516385f, 0.04062700f, -0.02516950f, -0.00635686f, 0.03870836f, -0.03053083f, 
    0.01669619f, 0.00988185f, -0.01883578f, 0.00444788f, -0.01969661f, -0.02124017f, -0.01984829f, 0.01064053f, 
    -0.04876575f, -0.01304995f, -0.03223681f, 0.01804770f, 0.02441931f, 0.01746423f, -0.04431871f, 0.03574666f, 
    -0.03803786f, -0.00595846f, 0.02611607f, -0.03740468f, 0.00649365f, -0.05622492f, -0.01995432f, -0.00486719f, 
    -0.04115850f, -0.02723855f, 0.00195622f, -0.02847415f, 0.04252134f, -0.01941150f, 0.03565598f, 0.03339263f, 
    0.02538989f, 0.04408171f, -0.00678606f, 0.04320988f, -0.00379012f, -0.04322169f, -0.05457673f, 0.03271926f, 
    -0.03792313f, -0.04821783f, 0.02760546f, -0.02805694f, -0.01103223f, -0.02852618f, -0.02255965f, 0.03844311f, 
    0.02765712f, -0.03462310f, 0.00138652f, 0.02342134f, -0.01010918f, -0.03071784f, 0.01101069f, -0.01956926f, 
    -0.00641706f, 0.00528120f, 0.03210353f, 0.01949850f, 0.01087536f, -0.04717003f, -0.00667864f, -0.00078398f, 
    -0.00885941f, -0.02944559f, 0.03393538f, -0.01641792f, 0.00284633f, -0.05484219f, -0.03548036f, -0.01123324f, 
    -0.04738338f, 0.04519945f, -0.04082811f, -0.03213159f, -0.01347895f, 0.03684489f, -0.04844225f, 0.01688606f, 
    -0.00027012f, 0.01702652f, -0.01965690f, 0.04267345f, 0.04166374f, 0.02359075f, 0.02231117f, -0.03656301f, 
    -0.00516791f, -0.04834136f, -0.05115960f, 0.01272594f, 0.02414237f, -0.04387148f, 0.03239925f, -0.00344108f, 
    -0.03812605f, 0.02356078f, 0.01736896f, 0.01733756f, 0.02440464f, 0.01504571f, 0.01060982f, -0.00603702f, 
    0.00800226f, -0.03975594f, 0.00145987f, 0.01771360f, -0.03125516f, -0.02030261f, -0.04240511f, -0.01284800f, 
    0.02971447f, 0.03271598f, 0.02172019f, 0.02160336f, 0.02469985f, -0.01068519f, -0.04894288f, 0.01809780f, 
    0.00900015f, 0.04294069f, -0.00708998f, 0.03759323f, 0.01039273f, -0.03857727f, 0.03705782f, 0.04002105f, 
    -0.00027752f, 0.03136753f, 0.04165993f, 0.01929090f, -0.03428619f, 0.03331451f, -0.04389610f, 0.04282323f, 
    -0.04331134f, 0.04557674f, 0.00773509f, -0.03371035f, -0.01302382f, -0.01086575f, 0.03052004f, 0.03681085f, 
    -0.03352971f, -0.04748619f, 0.03662626f, -0.02275385f, -0.02533333f, 0.01339325f, -0.03755878f, -0.02547145f, 
    0.03019091f, 0.02824246f, -0.05279455f, -0.00682361f, 0.01846224f, 0.02718849f, -0.02405931f, -0.03912579f, 
    0.00329726f, -0.01046331f, -0.03422812f, -0.00670987f, 0.03171021f, -0.00163507f, -0.00507631f, 0.03764047f, 
    -0.01727640f, 0.04371797f, -0.00320204f, -0.01814217f, 0.04377089f, 0.02468483f, 0.03954264f, -0.04056370f, 
    -0.04051926f, 0.00108758f, -0.03303191f, 0.01126937f, 0.00061570f, 0.02166246f, -0.01215672f, 0.02559029f, 
    0.00382761f, -0.03389037f, -0.03323467f, -0.03111483f, -0.00775259f, -0.03021098f, -0.04007399f, -0.02195610f, 
    -0.04074200f, -0.01314885f, -0.04332952f, 0.00181336f, 0.03341402f, 0.02476736f, 0.03244329f, -0.04857337f, 
    -0.02875726f, 0.01358518f, -0.03381438f, 0.01015710f, -0.02313642f, -0.04355079f, -0.01315870f, 0.01568705f, 
    -0.03091639f, -0.03628576f, -0.01352328f, 0.02256570f, -0.00047151f, 0.04062234f, -0.01092524f, 0.03664638f, 
    -0.03586900f, 0.04535882f, -0.03180954f, 0.02672651f, 0.03232161f, -0.00101709f, 0.00949712f, -0.04104068f, 
    -0.03615172f, 0.02689445f, 0.02863600f, 0.01365294f, -0.00684215f, 0.04147550f, -0.01903241f, -0.00298044f, 
    -0.00688231f, -0.03750437f, -0.01471450f, 0.01101758f, -0.04365845f, -0.04764415f, -0.05380352f, -0.01300198f, 
    0.00893329f, -0.00926169f, 0.02302089f, -0.00110082f, 0.02067925f, -0.04354582f, -0.01601372f, 0.00401408f, 
    -0.04962344f, 0.04121239f, -0.04713930f, -0.01708800f, -0.03361108f, 0.01720290f, -0.03470846f, -0.01155340f, 
    0.01503340f, 0.01624164f, -0.04094129f, -0.01979635f, 0.00556654f, 0.01997451f, 0.01977086f, -0.04142580f, 
    0.00832710f, -0.04376913f, -0.01122842f, -0.04462057f, 0.03681759f, -0.01147540f, 0.03820645f, -0.00687159f, 
    -0.01634577f, -0.03024912f, -0.05246949f, -0.04949344f, -0.04089896f, -0.03876106f, -0.00575585f, -0.01331429f, 
    0.01141167f, -0.04116787f, 0.02214629f, 0.02631915f, 0.00170336f, 0.02239688f, -0.00641695f, -0.01376179f, 
    -0.00714028f, 0.00851079f, -0.03747436f, 0.01112242f, 0.02151573f, -0.03273398f, -0.03976756f, 0.04227878f, 
    -0.04261942f, -0.04216973f, 0.00413495f, -0.04718923f, -0.04858028f, 0.02822031f, -0.05369495f, 0.02067098f, 
    0.01481037f, -0.03557104f, -0.00727787f, 0.02953180f, -0.04191140f, -0.05490312f, 0.00997927f, -0.02348493f, 
    -0.03546203f, -0.02459695f, -0.04765977f, 0.01177520f, -0.04857612f, 0.00723614f, -0.03796288f, -0.00690911f, 
    -0.01788616f, -0.03955265f, 0.00054370f, -0.01305575f, -0.05186344f, -0.04418729f, 0.03561586f, -0.01160477f, 
    -0.03683202f, -0.05334548f, -0.04252275f, -0.02456793f, 0.01075781f, 0.00439344f, 0.04133214f, 0.02633553f, 
    0.03581500f, 0.00902827f, -0.01154355f, 0.03745899f, 0.01794194f, -0.04023812f, -0.01094774f, -0.01160757f, 
    -0.03344431f, -0.05531759f, 0.00059686f, 0.00196744f, -0.02761994f, 0.00163115f, -0.01224915f, 0.00467133f, 
    0.01970424f, 0.00568025f, 0.04005729f, -0.01241192f, -0.02777976f, -0.00107422f, 0.00486961f, 0.03924171f, 
    -0.00043203f, -0.01876740f, 0.02015981f, -0.00042466f, 0.03520792f, -0.04685079f, 0.02411070f, 0.03287795f, 
    0.02199247f, -0.04834774f, -0.04572023f, -0.04354687f, 0.04039591f, -0.05570180f, -0.01326280f, -0.01338615f, 
    -0.03892123f, 0.00723097f, -0.05045722f, 0.00269044f, 0.03206029f, 0.02732933f, -0.04395803f, -0.00473757f, 
    0.04419148f, 0.00882845f, 0.01519880f, 0.04076747f, -0.04724517f, 0.00204866f, -0.02095552f, 0.02329554f, 
    0.03369784f, -0.02619304f, 0.04112019f, 0.02729923f, 0.02659218f, 0.00327046f, 0.03932944f, 0.01729212f, 
    -0.02000147f, -0.01697942f, 0.03426676f, -0.03150445f, -0.04201551f, -0.01116281f, -0.01688031f, -0.03165650f, 
    -0.00829075f, -0.03859097f, 0.02980517f, -0.05135797f, 0.03131396f, -0.01863007f, -0.02358462f, -0.02991224f, 
    -0.02470738f, -0.00844182f, -0.02439700f, -0.04899745f, -0.04743759f, 0.03780794f, -0.05530396f, -0.01801529f, 
    0.00371968f, -0.01997611f, 0.02125082f, -0.03626379f, -0.05284750f, -0.01376602f, 0.02701433f, -0.04705059f, 
    0.03274897f, -0.04090215f, -0.00697698f, -0.00818823f, 0.03948865f, 0.03248635f, -0.04572377f, -0.03826745f, 
    0.04058742f, -0.04121752f, -0.00790768f, -0.02177260f, -0.05530759f, 0.02202595f, 0.04089184f, -0.04614255f, 
    0.03314660f, -0.01121313f, -0.04412472f, 0.03916469f, -0.04157737f, -0.05471325f, -0.04928287f, -0.01247419f, 
    -0.02189605f, -0.02783822f, -0.02309400f, -0.03225296f, -0.04496538f, -0.00075848f, 0.00914097f, 0.03218793f, 
    -0.01693180f, -0.02281933f, 0.00081115f, -0.03981984f, 0.02072419f, -0.02963035f, 0.02269950f, 0.02125737f, 
    -0.00795153f, -0.00027272f, -0.03600959f, -0.03931260f, 0.01179368f, 0.01130441f, 0.03229732f, -0.04930117f, 
    0.03807740f, -0.00952002f, -0.05374640f, -0.03632835f, 0.01043273f, -0.00122543f, 0.03389807f, -0.04537397f, 
    -0.03267136f, 0.03424829f, 0.00748899f, -0.05260434f, 0.03176182f, 0.02329671f, 0.00691791f, 0.00319448f, 
    -0.02505849f, 0.01103780f, -0.01664124f, 0.01454264f, -0.00666155f, 0.01110215f, 0.01056161f, -0.01552217f, 
    -0.07726757f, -0.01065932f, -0.12021289f, -0.11956576f, -0.05543703f, -0.04992728f, 0.01102490f, -0.05568698f, 
    -0.01717513f, -0.02105961f, -0.03689371f, 0.03468874f, -0.00790781f, -0.14212687f, -0.18703231f, -0.14845023f, 
    -0.05033786f, -0.05521518f, -0.00881159f, -0.02599394f, 0.03280047f, 0.06224762f, 0.04130702f, 0.09377620f, 
    0.13750760f, -0.27091855f, 0.09998570f, -0.23066005f, -0.02136200f, 0.10328565f, 0.02499945f, 0.17078517f, 
    -0.10859961f, 0.02699378f, 0.05956652f, 0.18111068f, 0.06809418f, -0.03403052f, -0.01196679f, -0.04417244f, 
    0.06413293f, -0.13957445f, -0.02411642f, -0.05375576f, -0.01863271f, 0.09828863f, 0.12222375f, 0.08637439f, 
    0.09696200f, 0.14491323f, 0.08168713f, -0.08915909f, -0.13127351f, -0.16474503f, -0.13600595f, -0.13898605f, 
    -0.18336460f, -0.10590126f, -0.09389176f, -0.15942687f, 0.32147089f, 0.32692865f, -0.15352401f, 0.23721637f, 
    -0.09215475f, -0.07510954f, 0.01487300f, 0.00003694f, 0.01454318f, 0.22073193f, 0.28514808f, 0.17542973f, 
    0.01051310f, 0.01210978f, 0.06250638f, 0.04809071f, 0.16180493f, 0.00992274f, 0.05454253f, 0.08931088f, 
    0.04280483f, 0.13644838f, 0.03011760f, 0.01161233f, -0.01098098f, -0.05851928f, -0.02346668f, -0.05010630f, 
    0.07047621f, 0.09028170f, -0.01700570f, 0.11536309f, -0.19685033f, 0.20314205f, 0.20975988f, 0.08711085f, 
    -0.07503926f, -0.10170252f, 0.08831203f, 0.00529924f, 0.11107516f, 0.08381654f, 0.16379152f, 0.08150055f, 
    -0.08025480f, 0.03567069f, 0.04569498f, -0.03972614f, -0.01534655f, 0.06700624f, 0.15455347f, -0.18815991f, 
    -0.07550081f, -0.01874902f, -0.08095995f, -0.01814878f, -0.03831815f, 0.05861757f, 0.04192333f, -0.08370998f, 
    0.00037790f, -0.14048500f, -0.11528867f, -0.07834804f, -0.04422783f, 0.04044409f, -0.06638435f, 0.01913358f, 
    0.04616971f, 0.05139202f, -0.05458958f, -0.18602505f, -0.12458374f, 0.05753439f, -0.09818544f, -0.05957316f, 
    -0.16707757f, 0.04005872f, 0.07783573f, -0.14455599f, -0.01663161f, -0.04248034f, 0.03544862f, 0.00230772f, 
    -0.00467149f, -0.06118907f, -0.01068999f, 0.01985844f, -0.00190481f, 0.03063023f, -0.01697871f, -0.21978244f, 
    -0.03935609f, 0.00776961f, -0.00054989f, 0.12334829f, -0.07269765f, -0.03207607f, 0.07780718f, 0.02881408f, 
    -0.27316043f, -0.13261823f, -0.05598502f, -0.09903538f, -0.08779817f, 0.11908240f, 0.24880062f, 0.08327204f, 
    0.15462656f, -0.07793473f, -0.01962454f, -0.06589756f, -0.23741765f, -0.10191328f, 0.07123558f, 0.04464818f, 
    0.12149596f, 0.18303649f, 0.03541924f, 0.26564398f, -0.11793514f, -0.16248967f, -0.24378330f, -0.08495543f, 
    0.06800861f, 0.11319984f, 0.15409966f, 0.04033259f, 0.00567934f, -0.10552040f, -0.02761307f, -0.01954927f, 
    0.16764690f, 0.21301216f, 0.11211231f, 0.06905545f, -0.05873614f, -0.08283318f, -0.10260986f, -0.04960045f, 
    0.08929370f, -0.06488055f, 0.08467450f, -0.08247338f, 0.11994310f, 0.28322539f, 0.19917552f, 0.05246796f, 
    -0.09268405f, -0.04190338f, 0.07766222f, 0.04532306f, 0.04165379f, -0.01693257f, -0.00882247f, -0.14424366f, 
    -0.02077127f, -0.17535295f, -0.09084334f, 0.00109310f, 0.12398700f, 0.08512866f, 0.06278814f, 0.10401434f, 
    0.08826496f, 0.10763392f, 0.04060985f, 0.09169767f, 0.09538158f, -0.03272165f, 0.06672867f, -0.14505802f, 
    0.00193594f, -0.02175763f, 0.03086247f, 0.05453900f, 0.00727051f, 0.10262807f, 0.09181777f, 0.11701617f, 
    -0.00170627f, -0.14085044f, -0.05011452f, -0.11837028f, -0.04170281f, 0.03020577f, -0.04842630f, -0.14720628f, 
    -0.03091755f, -0.00706673f, -0.09487024f, -0.00020044f, -0.00930538f, -0.01088961f, -0.03235883f, 0.13906598f, 
    0.18654893f, 0.09274844f, 0.03565345f, 0.02178526f, 0.03221025f, 0.15040058f, 0.11951616f, 0.11054020f, 
    0.04890054f, -0.04391724f, -0.01573328f, -0.00021615f, 0.04880006f, 0.15390064f, -0.04418726f, -0.05340794f, 
    0.03721779f, 0.02536662f, 0.04180641f, 0.14656210f, -0.19242790f, -0.08866787f, -0.08213728f, -0.07844312f, 
    0.10655663f, 0.10321141f, 0.07211969f, -0.03731517f, -0.16461378f, -0.02959379f, 0.05747702f, -0.06867445f, 
    -0.05149372f, 0.11764020f, -0.23886153f, 0.20827900f, -0.02662865f, -0.00451506f, 0.08912465f, 0.13022144f, 
    -0.04111705f, -0.14573063f, 0.14873441f, -0.33860540f, -0.01613265f, -0.02781167f, 0.17020339f, -0.01906690f, 
    -0.00333421f, 0.00582585f, -0.06704947f, 0.09653454f, -0.01982203f, -0.03536613f, -0.03126628f, -0.05268588f, 
    0.16537391f, 0.26759589f, -0.07186973f, 0.12927921f, 0.06420895f, -0.00699474f, 0.09096646f, 0.03076506f, 
    0.13607445f, -0.02228993f, 0.15529585f, 0.12389535f, 0.12872452f, 0.07104418f, 0.02081831f, -0.16389279f, 
    -0.07436228f, -0.04208444f, -0.08838078f, -0.03815516f, -0.00092685f, 0.00600121f, -0.02678894f, -0.03676496f, 
    -0.12121066f, 0.33494127f, -0.19818132f, 0.13179009f, 0.00390080f, -0.06005351f, 0.06504287f, -0.15991820f, 
    -0.09490059f, 0.02044532f, 0.03606736f, 0.02214706f, 0.09013041f, 0.03827535f, -0.27194998f, 0.00032469f, 
    -0.06542162f, -0.07059374f, -0.01093168f, 0.04409283f, 0.10327261f, 0.09548000f, 0.14447147f, 0.10720839f, 
    -0.04322370f, 0.22172874f, -0.01816462f, 0.16092166f, 0.16811238f, 0.02692803f, 0.04450933f, 0.02644873f, 
    -0.11179951f, -0.03478326f, 0.00117753f, 0.05931985f, 0.16417868f, 0.07914717f, 0.25357187f, -0.00342241f, 
    0.01376710f, -0.09013884f, -0.15748534f, -0.08623376f, -0.02441574f, -0.07174323f, -0.09537745f, 0.06598175f, 
    -0.00665584f, 0.03903227f, 0.04022766f, 0.04473707f, 0.06756293f, 0.01960877f, -0.04435439f, -0.05164805f, 
    -0.05370310f, 0.04646295f, 0.05687899f, -0.05626255f, 0.49171770f, -0.04515415f, -0.16683938f, 0.00274310f, 
    0.02230897f, 0.06058508f, 0.02135050f, 0.00157130f, -0.01936612f, 0.02718823f, -0.14702143f, -0.09382842f, 
    -0.06301557f, -0.12798589f, 0.07621992f, 0.05949045f, -0.11002063f, 0.01154328f, 0.01405648f, -0.18823801f, 
    -0.01244773f, -0.05965284f, 0.01600213f, 0.07714934f, 0.12882300f, 0.13581859f, 0.02214211f, 0.08112741f, 
    0.04993588f, 0.05485590f, 0.07654433f, -0.01791540f, -0.00829083f, -0.08606042f, -0.06169189f, -0.03153812f, 
    -0.01708237f, -0.01966043f, 0.10027478f, 0.09568330f, 0.01983762f, 0.00448998f, 0.03957682f, 0.03443357f, 
    0.13479805f, 0.17113298f, 0.10055044f, 0.15628573f, 0.38528308f, 0.00924830f, -0.05425578f, -0.01059015f, 
    -0.03242812f, -0.01694032f, 0.02025916f, 0.11600953f, -0.05800517f, -0.02022039f, -0.09107383f, -0.04325457f, 
    0.10120069f, 0.06011491f, 0.14749593f, 0.22012265f, -0.10911486f, -0.01700689f, -0.03041528f, 0.01896730f, 
    -0.06622821f, -0.10992023f, 0.02055639f, 0.06070378f, 0.34086758f, 0.19047818f, -0.23574854f, -0.14504613f, 
    0.13225472f, 0.09360906f, -0.03287306f, 0.11661715f, -0.16546834f, -0.13861820f, -0.08846708f, 0.04029009f, 
    0.12348524f, 0.21964140f, 0.16623524f, -0.01944078f, 0.01559328f, 0.11841054f, -0.04717413f, -0.04374386f, 
    -0.10719594f, -0.00413799f, 0.04786761f, -0.04855524f, 0.11398853f, 0.09509208f, -0.01241386f, 0.07872590f, 
    -0.00469867f, -0.05632147f, 0.02002545f, 0.01741879f, -0.04575374f, 0.17215385f, -0.05106072f, 0.01043272f, 
    0.30770096f, -0.14462797f, 0.15500562f, 0.15434068f, 0.07584962f, -0.05584798f, 0.03269519f, 0.02492031f, 
    0.01683510f, 0.02666048f, -0.06684981f, 0.05890834f, 0.08013631f, 0.12595889f, 0.08765512f, -0.05573963f, 
    -0.12619825f, -0.14594893f, 0.06122611f, 0.05202202f, 0.02387614f, 0.06561454f, 0.05686782f, 0.07160643f, 
    -0.00913267f, 0.03089338f, 0.07382351f, 0.04341220f, -0.00313485f, 0.02298087f, -0.12915932f, 0.06864612f, 
    -0.00393877f, -0.05641094f, -0.03238228f, -0.02322072f, 0.16109657f, 0.01684927f, 0.11845228f, 0.13951275f, 
    0.04120769f, -0.03835694f, 0.07902477f, 0.09439466f, 0.01916243f, -0.03112937f, -0.04917859f, 0.07315954f, 
    0.02887726f, 0.17070560f, 0.07867704f, 0.11109681f, -0.02679797f, 0.11669369f, 0.10821770f, -0.03230041f, 
    -0.08452795f, -0.10310693f, -0.10133871f, -0.05048502f, 0.02307194f, -0.07280643f, 0.13095777f, 0.01904131f, 
    0.10804944f, 0.06010904f, 0.00832351f, -0.22293985f, -0.08339744f, 0.02082871f, -0.01667600f, -0.01144855f, 
    0.07644764f, -0.06747852f, -0.08702659f, 0.07395408f, 0.06371582f, 0.02426535f, -0.05255854f, -0.04599017f, 
    0.01370839f, 0.02135127f, -0.07157382f, -0.12335433f, 0.03368420f, -0.13465713f, -0.14273822f, 0.04651094f, 
    -0.01271654f, -0.00715399f, -0.03373018f, 0.00357308f, -0.01800422f, 0.05830074f, -0.07104911f, 0.05940511f, 
    0.10051095f, 0.20431603f, -0.00311013f, 0.15160273f, -0.05020606f, 0.06830403f, -0.01814556f, -0.08878562f, 
    -0.07076205f, -0.00437423f, 0.03707578f, -0.10665255f, -0.08646912f, 0.02738990f, 0.08100847f, 0.07583445f, 
    -0.08833735f, 0.00332940f, -0.07126301f, -0.03353867f, 0.01467388f, -0.10221118f, -0.03752515f, 0.01220065f, 
    0.18250562f, 0.39229342f, 0.12810001f, 0.04434403f, -0.11570897f, -0.13134868f, -0.18124852f, -0.05465199f, 
    0.03207750f, 0.01374068f, 0.07261534f, 0.07556659f, -0.06242564f, 0.07165328f, -0.02609481f, -0.02912296f, 
    -0.09305224f, 0.07985469f, -0.06941912f, -0.03356777f, 0.06442768f, 0.00885879f, 0.02882616f, -0.17407790f, 
    0.13806245f, -0.02644178f, 0.00546913f, 0.10593606f, -0.15242299f, -0.15509747f, 0.04402245f, -0.19966397f, 
    0.02672707f, 0.06629124f, -0.04727075f, -0.04769207f, 0.16422290f, 0.07347272f, 0.16982080f, 0.23066172f, 
    0.03203892f, -0.01378716f, -0.00771706f, 0.13062932f, 0.00426210f, 0.03825933f, 0.00314520f, 0.06888591f, 
    0.08642250f, 0.08672262f, -0.02004811f, -0.16831033f, -0.07216211f, -0.04923658f, -0.09045769f, -0.09717055f, 
    0.06403836f, -0.09268235f, -0.06750570f, 0.16813791f, -0.04915838f, -0.04477589f, 0.00823168f, -0.16715565f, 
    -0.00356333f, -0.02101104f, -0.07615781f, -0.08042891f, -0.26318046f, -0.08065135f, -0.11023277f, 0.06433003f, 
    -0.07437792f, -0.15223001f, -0.01268806f, 0.09181087f, -0.02661580f, 0.15001924f, -0.00386795f, -0.07877585f, 
    0.01991638f, -0.11584987f, 0.03260432f, -0.25904974f, -0.11661329f, -0.05664002f, 0.12799469f, -0.09463569f, 
    -0.02377505f, -0.01462150f, -0.02002574f, -0.03617825f, 0.10542984f, 0.09629744f, 0.02954481f, 0.10011129f, 
    0.05483725f, 0.06376130f, 0.22617379f, 0.12134517f, -0.13078229f, -0.04013601f, -0.10752593f, -0.09435766f, 
    -0.07782765f, -0.02349588f, 0.06488844f, 0.00863702f, 0.09543813f, 0.05367545f, -0.04397337f, 0.00902016f, 
    -0.04145881f, 0.08339828f, 0.08218519f, -0.12497459f, -0.07965176f, -0.11246511f, 0.00351611f, -0.14604187f, 
    0.16882998f, 0.00917748f, 0.13125648f, 0.15521096f, -0.03223689f, -0.10291102f, -0.11220702f, 0.14939834f, 
    -0.03044046f, -0.07411252f, -0.03951583f, 0.04560961f, -0.07820765f, -0.17819880f, 0.18937059f, -0.18664689f, 
    -0.01863384f, 0.03543169f, 0.11754017f, -0.01312462f, 0.04138364f, -0.06378533f, -0.04209988f, 0.06676093f, 
    0.03590462f, 0.03451056f, -0.04770468f, -0.04913435f, 0.02069797f, -0.05060853f, 0.04147640f, 0.02056752f, 
    0.00455130f, 0.01838591f, 0.02517744f, 0.03017140f, 0.02074369f, -0.01212316f, 0.03312053f, -0.00098157f, 
    -0.01026810f, -0.02405453f, 0.03217631f, 0.00627328f, -0.03092789f, 0.00980124f, 0.03757687f, 0.00834227f, 
    -0.03548531f, 0.03381168f, -0.04657086f, 0.02002949f, -0.01037992f, 0.03803507f, -0.03325194f, -0.02927560f, 
    0.03225692f, -0.02244405f, -0.00730486f, 0.00391113f, 0.02740653f, 0.03527259f, -0.03420003f, -0.04214530f, 
    0.04398978f, 0.00417500f, -0.02719224f, -0.02044512f, 0.05318635f, -0.02140270f, -0.00781264f, -0.01818965f, 
    0.00981798f, 0.02944050f, -0.04468656f, 0.03185885f, -0.03978214f, 0.02340863f, 0.03680870f, 0.02957975f, 
    0.04122851f, 0.03075798f, 0.00143188f, 0.03092342f, 0.02509512f, -0.01387937f, -0.02089655f, -0.04954936f, 
    -0.02468021f, -0.00693955f, 0.00833563f, -0.00616247f, -0.01820417f, -0.01440789f, -0.01747560f, -0.02084267f, 
    0.00216409f, -0.05542958f, -0.02843500f, -0.00349635f, 0.02588578f, -0.03518579f, -0.05126201f, -0.05283337f, 
    -0.04520870f, 0.03817692f, -0.00176640f, -0.05104661f, -0.02008153f, -0.03378011f, -0.00262893f, -0.06018602f, 
    -0.03758562f, 0.01650950f, 0.01710724f, -0.01893131f, -0.01424158f, -0.01280965f, -0.02528038f, 0.01759703f, 
    0.02826466f, 0.01983750f, 0.03129204f, 0.01441741f, -0.01025128f, -0.00282497f, 0.03270123f, 0.03404028f, 
    -0.00394075f, 0.02800623f, -0.05989509f, 0.03653019f, -0.04060188f, 0.03589095f, -0.03570396f, -0.05691901f, 
    -0.00438536f, 0.03005128f, 0.01654259f, -0.05229012f, 0.00909839f, -0.01438242f, -0.04119211f, -0.01642772f, 
    -0.04873597f, 0.01420784f, 0.03421284f, -0.01766030f, -0.01246365f, -0.00850125f, 0.01110045f, 0.00326837f, 
    0.02880698f, -0.04347521f, -0.00901008f, -0.05284278f, -0.02216094f, 0.02054431f, 0.03953469f, -0.04449258f, 
    -0.05388539f, -0.00821026f, -0.02326447f, 0.05180776f, 0.01851962f, -0.00282069f, -0.03159296f, 0.01989879f, 
    -0.02158247f, 0.04506675f, 0.03324484f, -0.04741643f, -0.01220027f, -0.01576756f, -0.04913672f, -0.02837486f, 
    -0.03974666f, -0.03833665f, -0.00049603f, 0.00008253f, -0.04784434f, -0.01500366f, 0.03027888f, 0.01432663f, 
    -0.00743116f, -0.04865241f, 0.00991861f, -0.02718578f, 0.02958253f, -0.01672650f, 0.03221186f, -0.00347996f, 
    -0.03343780f, 0.02134152f, -0.05709961f, -0.02643087f, -0.02870788f, -0.04228050f, 0.00462963f, 0.03877154f, 
    0.00156855f, 0.03894520f, 0.00504073f, -0.01281490f, 0.00185458f, -0.03334687f, -0.04461279f, 0.03978428f, 
    0.01487033f, 0.03487043f, 0.04416540f, 0.02053929f, 0.01930740f, 0.04291782f, -0.01982622f, 0.02730142f, 
    0.02473432f, 0.02482144f, 0.02700905f, -0.00782258f, 0.02095891f, 0.03903778f, -0.01750473f, -0.02061511f, 
    0.02767641f, -0.02011961f, -0.04905997f, -0.00527407f, -0.04163412f, -0.03777996f, -0.00484134f, 0.00540285f, 
    -0.02234024f, -0.05039470f, -0.03550730f, 0.01501027f, 0.04108860f, -0.01777277f, -0.03607270f, 0.01845533f, 
    0.02677781f, 0.01737426f, -0.02571931f, -0.02140057f, -0.02789306f, 0.01552438f, 0.03657335f, 0.05627431f, 
    0.01834913f, 0.01642537f, -0.00374862f, -0.01255094f, -0.02012284f, -0.05473141f, 0.01354945f, 0.01990811f, 
    -0.04565334f, -0.03288865f, 0.03482012f, -0.01119411f, -0.05510276f, 0.04053181f, 0.03206602f, -0.04079549f, 
    0.03807387f, 0.01314498f, -0.04259558f, -0.03939474f, 0.02872651f, -0.01577488f, -0.01077066f, -0.04760819f, 
    -0.02369183f, -0.00988047f, -0.01995380f, -0.00832996f, 0.03194156f, -0.03448157f, -0.05285589f, -0.03386014f, 
    -0.01385554f, -0.00886187f, 0.01678230f, -0.02035655f, -0.03291416f, 0.01822127f, 0.00160198f, 0.00318812f, 
    -0.01656488f, -0.02674358f, 0.00971062f, -0.01047447f, -0.02225276f, 0.04592506f, 0.02739430f, -0.04534377f, 
    0.04365340f, 0.00544529f, -0.04097670f, -0.03967861f, 0.01838284f, 0.00277007f, -0.00252318f, -0.01599363f, 
    -0.00537310f, -0.03485661f, -0.00207496f, -0.02135808f, 0.02484674f, -0.03395070f, -0.02789327f, -0.00851566f, 
    0.03733632f, 0.01627890f, -0.00467609f, -0.03088101f, 0.02688887f, -0.04570837f, 0.02926200f, -0.04008015f, 
    -0.00231113f, -0.05079398f, -0.02941209f, 0.01212944f, 0.02018636f, -0.01064321f, 0.04147193f, -0.05283797f, 
    0.01085697f, 0.02577380f, -0.00657883f, 0.00614631f, 0.02979198f, -0.05226390f, -0.00303432f, 0.02520179f, 
    -0.00551712f, -0.01093867f, 0.02947862f, 0.00036117f, -0.01038277f, -0.05112642f, 0.01547997f, -0.02930703f, 
    0.01589414f, 0.01925232f, 0.00425820f, -0.04121403f, -0.01524579f, -0.05612469f, -0.01947238f, -0.05127393f, 
    -0.01008028f, 0.00873313f, -0.03867197f, 0.00201714f, -0.03921321f, 0.03152477f, -0.04349133f, 0.03529399f, 
    -0.01147208f, -0.01885234f, 0.01705192f, 0.03049527f, -0.04559440f, -0.01191290f, -0.05130120f, 0.02613923f, 
    -0.00304537f, -0.02978968f, 0.01483803f, -0.01005861f, -0.03098056f, 0.02375311f, 0.00990027f, -0.03510972f, 
    0.04144083f, -0.02713495f, 0.04251709f, -0.03205245f, -0.02700616f, -0.01677358f, 0.02444496f, -0.00013622f, 
    -0.01740314f, -0.01104865f, 0.03589471f, 0.00504170f, -0.05482749f, -0.02663430f, 0.04265634f, -0.03771484f, 
    0.00172626f, -0.01457753f, 0.02146770f, -0.01232472f, 0.00319692f, -0.03897608f, -0.04425940f, 0.02748152f, 
    0.03756647f, -0.05224899f, 0.03933676f, -0.04232987f, -0.03734665f, -0.02841058f, -0.05274728f, 0.01922566f, 
    -0.03211779f, 0.05024994f, 0.03673405f, 0.03707479f, 0.04054214f, 0.02927093f, -0.03684533f, 0.02432267f, 
    -0.04440133f, 0.03820804f, 0.01321760f, 0.00756327f, 0.01089687f, 0.01580672f, -0.05140904f, 0.00761463f, 
    -0.00548200f, 0.00307351f, -0.05092308f, -0.02995181f, -0.04142962f, -0.01030032f, 0.03527585f, 0.01835229f, 
    -0.04090805f, -0.00056591f, 0.01188332f, -0.05153016f, -0.04632754f, 0.00344423f, 0.00363923f, 0.03743990f, 
    -0.04642196f, 0.00876195f, 0.00176763f, -0.05041293f, -0.02913154f, -0.01213962f, 0.01028105f, 0.04372118f, 
    0.03341711f, 0.03583384f, -0.00610484f, -0.04857418f, -0.04141407f, 0.00322385f, -0.03273462f, -0.06105396f, 
    0.04477772f, -0.03769346f, 0.02812671f, -0.04423708f, -0.04208338f, -0.04590962f, -0.03179748f, 0.04964069f, 
    0.00300775f, 0.01730803f, -0.01592007f, -0.01277349f, -0.03188219f, 0.00762096f, 0.00349474f, 0.01100994f, 
    0.03708373f, -0.04619133f, 0.03168917f, 0.02357944f, 0.01309693f, -0.01199871f, -0.05170926f, 0.04128871f, 
    0.02675528f, -0.02371068f, 0.02717576f, -0.04702093f, 0.01391756f, -0.03675508f, 0.01444437f, 0.01754024f, 
    0.04053855f, 0.00134937f, -0.04817213f, -0.02649849f, -0.00699846f, 0.03971953f, -0.01451518f, -0.04096150f, 
    0.03616419f, -0.05358058f, -0.00182918f, -0.00478241f, 0.00901683f, 0.03608563f, -0.03951340f, -0.04718988f, 
    -0.02642852f, 0.01915346f, 0.00732952f, 0.01975265f, -0.04182282f, -0.01717876f, 0.03674442f, -0.00587032f, 
    0.00315149f, -0.05772285f, -0.03149978f, 0.00610490f, -0.02671105f, 0.05457962f, -0.04192912f, 0.05406422f, 
    -0.02557726f, 0.01933662f, -0.02710665f, 0.00196063f, 0.00240133f, -0.03142121f, -0.05633813f, -0.02583207f, 
    -0.04761343f, -0.03595354f, -0.00978848f, -0.04304846f, -0.04235138f, 0.01118759f, 0.03319982f, -0.02581789f, 
    0.00456985f, -0.00042727f, -0.00733019f, -0.04203987f, 0.02221275f, -0.03013422f, -0.03900091f, 0.03488571f, 
    -0.04504256f, -0.00032156f, -0.00762929f, -0.03634724f, 0.03753461f, -0.03816142f, 0.00722450f, -0.00394352f, 
    -0.00295201f, 0.02668761f, -0.02165882f, 0.01926536f, -0.04787994f, -0.02653780f, -0.05243660f, 0.02716835f, 
    0.04013278f, 0.00893983f, -0.00932035f, -0.00885271f, -0.05314445f, 0.02350975f, -0.01410677f, -0.04135355f, 
    -0.00345868f, 0.03468323f, 0.01734178f, -0.05131583f, -0.03280794f, 0.00435213f, -0.00969673f, -0.05305076f, 
    0.00742998f, -0.00283818f, 0.01405169f, 0.02156033f, 0.01212563f, 0.00254013f, 0.00950415f, -0.03312332f, 
    0.00975809f, -0.01867116f, -0.01200232f, 0.00373563f, 0.00320355f, 0.01895179f, 0.02989984f, 0.01583028f, 
    0.02077994f, -0.03470558f, -0.01107126f, -0.00468254f, 0.03221796f, -0.00930255f, -0.01774641f, -0.04823876f, 
    -0.00735784f, -0.01449379f, -0.04186675f, 0.00919296f, -0.01741211f, 0.03723374f, 0.01600953f, 0.01742400f, 
    0.02810053f, 0.01742764f, -0.02854466f, -0.01265609f, 0.05012808f, 0.03489727f, 0.00990694f, 0.00779950f, 
    0.00293669f, -0.05078739f, -0.02376850f, -0.01210098f, -0.02847896f, 0.01823769f, 0.00632387f, -0.04744078f, 
    -0.02960140f, -0.00691535f, -0.06222042f, -0.05375175f, -0.01690356f, -0.05769880f, 0.02848366f, 0.02638198f, 
    -0.02841985f, -0.03586289f, -0.01739373f, -0.03737158f, -0.02712882f, -0.00098286f, -0.02100821f, 0.02595670f, 
    -0.01897019f, -0.01230457f, 0.02241145f, 0.01891228f, -0.03901774f, 0.02210289f, 0.01078315f, -0.05185931f, 
    -0.02885762f, 0.00535846f, -0.01461285f, 0.00294504f, 0.01974390f, 0.02040226f, -0.02095510f, 0.04539125f, 
    0.04945734f, -0.00451272f, -0.00305353f, -0.03315652f, -0.02381173f, 0.01412314f, 0.00881806f, -0.02945504f, 
    0.00263573f, 0.01169980f, -0.03054318f, 0.02869678f, -0.04448337f, -0.00255929f, -0.02240745f, -0.03400030f, 
    0.00444775f, -0.05755166f, -0.04957725f, 0.00142979f, -0.04652785f, -0.03193181f, -0.05687020f, 0.01051526f, 
    -0.03049607f, 0.03662498f, -0.01813031f, -0.00089140f, 0.02799461f, 0.01165503f, -0.05323109f, 0.02943227f, 
    -0.01152686f, -0.05065569f, 0.02286108f, -0.03668384f, -0.00219885f, 0.03327010f, 0.00824825f, -0.04021465f, 
    -0.01253588f, -0.03820632f, -0.03457173f, 0.04962401f, 0.02872139f, -0.02428472f, -0.02612879f, 0.04259112f, 
    -0.01115036f, -0.03205969f, -0.00922586f, 0.02316388f, 0.02756674f, -0.02325379f, -0.04376252f, 0.02963204f, 
    -0.00250692f, -0.04784103f, -0.05189432f, 0.04102890f, -0.01004552f, 0.00657768f, -0.01749763f, -0.01097022f, 
    -0.05459747f, -0.00508455f, -0.00333609f, 0.00914713f, 0.00101260f, -0.04663778f, -0.05575390f, -0.02258687f, 
    0.03283155f, 0.03985577f, -0.01323951f, 0.03144684f, 0.01860592f, -0.01931117f, -0.03861170f, -0.00031362f, 
    0.04380621f, -0.02926835f, -0.03582970f, -0.00732665f, 0.00467969f, 0.03708873f, -0.03376608f, -0.01607502f, 
    -0.00345806f, 0.01521869f, -0.02671644f, 0.04131503f, -0.05148891f, -0.01333155f, -0.02749194f, 0.02183426f, 
    -0.02398322f, -0.02894788f, 0.01207598f, -0.03662767f, -0.01455895f, -0.04958878f, -0.04313717f, -0.02236245f, 
    0.02021807f, 0.01284026f, -0.02527687f, -0.04339727f, 0.03076169f, 0.00548739f, -0.05955939f, -0.00012993f, 
    0.00436914f, 0.01628264f, 0.03150097f, 0.04157899f, 0.03858794f, 0.01933732f, -0.02536788f, 0.01469625f, 
    -0.00586168f, 0.00487249f, -0.03512776f, -0.05091513f, 0.00221697f, 0.01449892f, 0.02840862f, 0.00668762f, 
    -0.02765051f, -0.01332792f, -0.00515346f, -0.03615671f, -0.00627311f, -0.01819937f, 0.01569555f, 0.03549976f, 
    -0.03755789f, -0.03533930f, -0.04418994f, -0.02726586f, -0.04593231f, -0.00870522f, -0.03460022f, -0.04806511f, 
    0.02347168f, -0.04776794f, -0.03755026f, -0.02554156f, 0.04190411f, 0.01391865f, -0.03686208f, 0.03456656f, 
    0.02004588f, 0.04334646f, 0.03608782f, -0.04403345f, 0.02526701f, 0.01062600f, 0.00678938f, -0.01690180f, 
    -0.05253977f, -0.01550920f, 0.01292591f, 0.04042957f, -0.00093380f, -0.01438196f, -0.00622123f, -0.00880846f, 
    -0.02938366f, 0.02344605f, 0.00020713f, 0.00995317f, 0.00471611f, -0.03156486f, -0.02242858f, 0.04065226f, 
    0.02664677f, 0.03563904f, -0.01793760f, 0.02278874f, -0.04195115f, 0.04505716f, -0.02296400f, -0.00267538f, 
    0.01676651f, 0.03377795f, 0.04718016f, 0.03121671f, 0.04554390f, 0.00451611f, 0.04268765f, 0.02041271f, 
    0.04202443f, 0.04324185f, -0.01047782f, -0.02444652f, 0.03004811f, -0.04687861f, -0.04201402f, 0.04394226f, 
    0.02170656f, 0.01748988f, 0.02289400f, 0.02655420f, -0.01614941f, 0.01330869f, -0.04642435f, 0.01856998f, 
    -0.01146346f, -0.03847539f, 0.02136367f, -0.00250037f, 0.02653980f, -0.01109884f, -0.01869203f, -0.02736306f, 
    0.01028659f, 0.00115838f, 0.00255866f, 0.00974394f, -0.01482721f, -0.00768783f, 0.01246723f, -0.04847747f, 
    0.01678553f, -0.02585895f, -0.00415995f, 0.00276763f, -0.00582797f, 0.02404064f, -0.03492557f, -0.01894521f, 
    0.02098263f, -0.03682908f, 0.01497012f, -0.01219101f, -0.03176589f, -0.01841322f, 0.02423083f, 0.03904943f, 
    -0.00092058f, -0.02579087f, 0.02781931f, -0.02458146f, -0.00221677f, 0.00069353f, -0.01648490f, 0.01750911f, 
    -0.01911442f, -0.00767312f, -0.04200667f, -0.01661028f, -0.01712851f, -0.00387733f, 0.02825218f, -0.02055053f, 
    -0.04923943f, -0.00493755f, 0.02648829f, 0.00512625f, -0.01843995f, 0.01355008f, 0.02601887f, -0.00917429f, 
    0.03096924f, 0.02800558f, -0.00365237f, -0.02188942f, 0.04667049f, 0.01856475f, -0.03760033f, 0.02157073f, 
    0.03779573f, -0.04706135f, 0.01338576f, -0.03454381f, -0.01688155f, 0.00026447f, -0.04816281f, -0.00209368f, 
    0.04291686f, -0.00241910f, -0.03211219f, -0.04798819f, -0.03369856f, -0.03784450f, -0.03527567f, -0.00813409f, 
    -0.03316471f, -0.02503361f, -0.02993281f, 0.03617816f, 0.00903335f, -0.04933360f, -0.02883645f, 0.02385536f, 
    -0.02541099f, 0.01768930f, 0.00699616f, 0.02505715f, 0.01204652f, -0.02751906f, -0.05523529f, 0.01989496f, 
    -0.05531419f, 0.04323943f, -0.04260286f, 0.03695846f, -0.00164485f, 0.04534013f, 0.00936042f, 0.01395244f, 
    -0.01870682f, -0.02300187f, -0.05088636f, 0.04320519f, -0.01735146f, -0.01941501f, -0.01555117f, -0.04751394f, 
    -0.04821021f, 0.03613095f, -0.03955147f, -0.00097212f, -0.04580951f, 0.00940977f, -0.05211296f, -0.01499065f, 
    -0.03074756f, 0.00213534f, 0.00340476f, -0.02565726f, -0.00028709f, -0.02756939f, -0.04593287f, -0.02744025f, 
    -0.02543148f, -0.01396944f, 0.01407686f, -0.03449614f, 0.03150930f, 0.01985316f, -0.02349533f, -0.04121530f, 
    -0.03930310f, 0.04205817f, 0.03520028f, 0.01194746f, -0.04584256f, -0.01305273f, 0.00943235f, 0.03671153f, 
    -0.02797680f, -0.02728708f, 0.01718262f, -0.00333886f, -0.03053072f, -0.00753205f, -0.00995616f, -0.04537946f, 
    -0.04722081f, 0.03575946f, 0.00191833f, -0.04688763f, -0.01652999f, 0.03024366f, -0.02283368f, 0.00555009f, 
    -0.04030272f, -0.02824605f, -0.04130885f, -0.03901417f, -0.02307118f, -0.01148373f, -0.03834118f, -0.02518079f, 
    -0.03944476f, -0.05385179f, 0.02117281f, 0.02159936f, -0.03507091f, -0.03403642f, -0.00741343f, -0.00304696f, 
    -0.00057253f, -0.04635984f, -0.02816679f, -0.03600598f, 0.04208725f, 0.02675006f, 0.02015237f, 0.02452031f, 
    -0.04422622f, -0.05342789f, 0.03141301f, -0.02759558f, -0.02427907f, -0.04794899f, -0.01594275f, 0.03351001f, 
    0.03342439f, -0.02918741f, 0.00650619f, -0.00415237f, -0.02917650f, 0.00048645f, 0.00065032f, 0.01821770f, 
    0.00131265f, -0.03195319f, 0.03741440f, 0.02786681f, -0.00996514f, 0.04321187f, 0.01908764f, 0.03878210f, 
    0.02393011f, 0.04024569f, 0.03327615f, 0.01903240f, -0.00254698f, -0.03270205f, -0.01147391f, -0.01531583f, 
    -0.01368775f, 0.02440404f, 0.03500448f, 0.00224998f, 0.03119926f, -0.00154156f, 0.03139444f, -0.04119375f, 
    -0.00622964f, -0.00001230f, 0.04147078f, -0.01250496f, -0.02155579f, -0.01044167f, -0.00129083f, 0.01652172f, 
    0.00777096f, -0.03021611f, -0.03994569f, 0.01835691f, 0.03261478f, -0.04147984f, 0.03024334f, 0.03130558f, 
    0.01685601f, 0.00360530f, -0.03868107f, 0.02491643f, 0.00184956f, 0.00692440f, -0.01099069f, -0.04563989f, 
    -0.03023138f, -0.03400560f, 0.00465574f, -0.01348193f, -0.01877782f, -0.00328289f, 0.02954617f, 0.00729229f, 
    0.01383273f, -0.01399336f, -0.01874491f, -0.05567313f, -0.04077916f, -0.01908304f, -0.00341388f, 0.03282981f, 
    -0.01708010f, 0.01309396f, 0.01110272f, 0.01229390f, -0.03821815f, 0.04533203f, -0.01191327f, -0.02712257f, 
    0.03706412f, -0.02834112f, -0.05320378f, -0.05046710f, -0.01641163f, -0.00127078f, -0.02097340f, -0.00516211f, 
    -0.00271101f, -0.03669355f, -0.01427281f, 0.02104802f, 0.03246078f, -0.01282963f, 0.03366036f, -0.02338774f, 
    0.04243992f, 0.01003866f, 0.03007025f, -0.04735507f, 0.00083273f, -0.04975935f, 0.01876166f, -0.00255885f, 
    -0.02738537f, -0.03760411f, -0.04863620f, 0.03886257f, -0.01738078f, 0.00842539f, 0.01047687f, -0.02534368f, 
    -0.03381910f, -0.03857194f, 0.04497448f, 0.01180435f, 0.03983424f, 0.01538066f, 0.03248529f, -0.02961232f, 
    0.08485831f, 0.08784690f, -0.05743881f, -0.00661849f, 0.10832705f, 0.09348371f, -0.01395780f, -0.03903311f, 
    -0.07748686f, 0.02239588f, -0.01167606f, 0.02870378f, 0.44529828f, -0.22815758f, -0.06159972f, -0.26449186f, 
    -0.09476145f, -0.06792120f, -0.10219415f, -0.15537432f, 0.03237281f, 0.03311811f, -0.00339655f, 0.02180122f, 
    0.06555687f, 0.35249111f, -0.16797842f, 0.25141135f, -0.11418962f, 0.01357827f, 0.22580875f, 0.17427957f, 
    0.03177378f, -0.12516740f, 0.01297148f, -0.09164356f, 0.03675975f, 0.10984496f, -0.16128962f, 0.11477958f, 
    0.04331704f, -0.18388823f, 0.05732602f, -0.14260677f, -0.04821520f, -0.04026766f, 0.02664189f, -0.19729964f, 
    0.10782129f, 0.12862472f, 0.12129557f, 0.15590382f, -0.04071224f, 0.02292793f, 0.02639728f, -0.07898565f, 
    0.16046727f, 0.02541556f, 0.15364642f, 0.17854208f, 0.36969522f, 0.12859032f, 0.23496863f, -0.11629495f, 
    0.05333108f, -0.16556537f, 0.04767724f, -0.07662659f, 0.06099802f, 0.30467692f, 0.01515125f, 0.04254946f, 
    0.00188091f, -0.02022523f, -0.30355722f, 0.04927732f, 0.13333550f, 0.05896556f, 0.06306231f, 0.16068833f, 
    -0.07299577f, 0.03231182f, -0.14111939f, 0.06438243f, 0.27403200f, -0.12946111f, -0.17406885f, -0.08509608f, 
    -0.07299729f, 0.20093782f, -0.12336814f, -0.09897555f, -0.04196493f, -0.00227981f, 0.00382566f, 0.12977953f, 
    0.01469320f, -0.48583725f, -0.65951079f, -0.38740167f, -0.00659848f, -0.07807312f, -0.08259238f, 0.06611870f, 
    0.11873394f, 0.05837449f, 0.03944416f, -0.01672473f, 0.25648221f, 0.15967216f, -0.03682365f, 0.07829525f, 
    -0.07130696f, 0.10795585f, 0.07674053f, -0.03459128f, -0.12219778f, 0.18597427f, -0.09036776f, -0.09668038f, 
    0.24756293f, -0.31704620f, -0.12831885f, -0.13467202f, -0.04120665f, -0.10737341f, -0.08941370f, 0.17953610f, 
    0.25602037f, 0.05138462f, 0.07113776f, 0.00188792f, 0.11742570f, -0.24173000f, 0.10164433f, 0.05116972f, 
    0.03509111f, 0.26046276f, 0.28353837f, 0.02039194f, -0.00982583f, -0.02331199f, -0.03630997f, 0.01087786f, 
    -0.20989996f, -0.16341741f, 0.01919742f, 0.05829278f, 0.18236977f, -0.01671335f, 0.00567369f, 0.22565378f, 
    -0.05269425f, 0.03024356f, -0.03882821f, 0.02871026f, -0.01215915f, 0.21925217f, 0.17175673f, 0.21324612f, 
    0.02050026f, -0.03793137f, 0.19546792f, -0.23002198f, -0.03952280f, 0.06622205f, 0.07996731f, -0.08980641f, 
    0.19335811f, -0.02464124f, 0.32512090f, 0.08251561f, -0.05447762f, 0.01880680f, -0.09895988f, -0.10114778f, 
    0.00186541f, -0.00902474f, -0.08401243f, 0.01409176f, -0.12489573f, -0.24233544f, -0.25119376f, -0.36026171f, 
    0.05592741f, -0.04897558f, 0.06514414f, -0.02859475f, 0.06216010f, -0.03626732f, -0.04291545f, -0.03839260f, 
    0.37016267f, 0.02690056f, 0.15201028f, 0.19187139f, 0.00369275f, -0.08394430f, -0.00395507f, -0.12735726f, 
    0.25276312f, 0.07231709f, -0.02801579f, 0.15452933f, 0.08394051f, 0.19106838f, 0.00561806f, 0.07608292f, 
    -0.14479637f, 0.24302900f, 0.07826547f, -0.19159275f, -0.06556309f, -0.00858608f, 0.04663364f, -0.08398963f, 
    -0.21695615f, -0.20966008f, -0.15370604f, 0.02818578f, 0.01026201f, 0.03646453f, 0.09312290f, 0.08474096f, 
    -0.06868266f, 0.10543332f, 0.00151850f, -0.01310957f, -0.02232000f, 0.13306479f, -0.17426364f, 0.17842264f, 
    -0.08304567f, 0.07113668f, 0.12967366f, 0.06070194f, -0.04466767f, 0.00855055f, -0.09109285f, -0.12077112f, 
    0.32782945f, 0.08106457f, -0.11341404f, 0.20995733f, 0.01039462f, 0.03862782f, 0.20218147f, 0.00642703f, 
    0.02288016f, -0.00628926f, 0.00032560f, 0.02720078f, -0.01323076f, 0.03658441f, 0.00855461f, -0.02492011f, 
    0.14064951f, 0.00376899f, -0.05866912f, -0.00954822f, 0.05488563f, -0.08341729f, -0.00501040f, -0.04284156f, 
    -0.08662964f, -0.04137990f, 0.11881860f, -0.04365792f, 0.06305856f, 0.02435406f, 0.17433918f, -0.12409133f, 
    0.01744223f, -0.15332361f, -0.10675580f, -0.06056083f, -0.14102812f, 0.08554491f, -0.28639156f, -0.15393117f, 
    -0.07583418f, 0.15749070f, -0.02560034f, 0.25169829f, -0.08871352f, -0.05412727f, 0.08873273f, -0.02023036f, 
    0.18654981f, -0.22118598f, 0.01999923f, -0.11984437f, -0.11924822f, 0.12805493f, -0.09557245f, -0.03499890f, 
    -0.12753904f, -0.09381796f, 0.25392333f, 0.13077067f, 0.22318737f, -0.11054774f, 0.11008988f, 0.02953228f, 
    -0.06397583f, 0.08093143f, 0.01904148f, -0.04911154f, 0.02128972f, 0.14169817f, 0.19034944f, 0.03976827f, 
    0.01279490f, 0.21603890f, -0.04381797f, -0.09412713f, -0.18075946f, -0.17208910f, -0.00427488f, -0.00432073f, 
    0.08017007f, 0.02304281f, 0.06726855f, 0.07055671f, 0.00276638f, 0.02832252f, 0.00738168f, 0.00930526f, 
    0.06242605f, -0.03412848f, 0.00109979f, -0.14709583f, 0.07171515f, -0.03903097f, -0.00047035f, -0.04040612f, 
    -0.07629647f, -0.10724506f, -0.04984589f, -0.23304059f, 0.24084228f, 0.06402729f, 0.11836106f, -0.08803626f, 
    -0.08158235f, 0.05086658f, -0.07125236f, -0.08805574f, 0.43894348f, -0.05113849f, -0.06387041f, -0.19289225f, 
    -0.13975586f, -0.14342307f, 0.05169572f, -0.19476649f, 0.05368471f, 0.05530475f, -0.00421559f, 0.00240446f, 
    -0.03753229f, 0.06459716f, 0.02308472f, -0.12785257f, 0.05109559f, 0.07525950f, -0.27839023f, 0.10999922f, 
    -0.00253730f, 0.00821185f, 0.04167648f, 0.00186126f, -0.19342928f, 0.11975434f, 0.09420913f, 0.10753272f, 
    -0.00625140f, 0.04555921f, -0.00967668f, -0.06734030f, -0.15670878f, 0.10332034f, 0.13022883f, -0.09395333f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.13047175f, 0.09312429f, -0.05305393f, -0.00240923f, -0.05478939f, 0.12712164f, 0.04319222f, -0.03410147f, 
    0.18530150f, -0.04671459f, 0.06042399f, 0.03944491f, 0.01938382f, 0.12913488f, 0.00558244f, 0.11025348f, 
    0.01592451f, 0.08455709f, 0.00921236f, 0.02186675f, 0.03638395f, 0.07476136f, 0.12469318f, 0.07930917f, 
    0.04229134f, 0.05988749f, 0.13140686f, 0.01603316f, -0.05267998f, 0.10112175f, -0.02740944f, -0.02488552f, 
    0.09735524f, 0.00332936f, 0.00544695f, 0.03896853f, 0.02565857f, 0.16521560f, 0.02050566f, -0.09487417f, 
    -0.00910336f, -0.02216613f, 0.05281468f, 0.08343397f, 0.02062506f, -0.05833354f, -0.07249806f, 0.08823249f, 
    0.00526041f, -0.01749094f, -0.06600012f, -0.04219927f, 0.03131681f, 0.06083953f, -0.04934416f, 0.06560226f, 
    -0.05621352f, -0.01628166f, 0.18120705f, -0.05911602f, 0.04467669f, -0.04589042f, -0.04051686f, 0.06842527f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.06932598f, -0.02679301f, -0.04623092f, 0.01693193f, -0.00715646f, -0.23886384f, 0.01173122f, 0.06160374f, 
    -0.29646024f, -0.02565463f, 0.11625826f, -0.09923172f, 0.17853142f, -0.18481733f, 0.18566674f, 0.04289688f, 
    0.07555594f, -0.21335553f, -0.47124228f, 0.02879700f, -0.03168659f, 0.26540935f, -0.17305221f, 0.15092680f, 
    0.05495812f, -0.21560416f, -0.17153156f, 0.17515419f, 0.06155129f, 0.27758324f, -0.02631934f, 0.10173294f, 
    -0.40626067f, 0.06259970f, 0.26726326f, -0.26091662f, 0.04055881f, -0.61702669f, -0.18782073f, -0.08874392f, 
    0.08743542f, 0.10940547f, 0.03870304f, 0.07306408f, -0.11808251f, 0.02118067f, 0.20005812f, -0.41234958f, 
    0.03378743f, -0.00790393f, 0.21768638f, 0.02183511f, 0.09105959f, 0.09863063f, -0.01828992f, -0.45840907f, 
    -0.11058120f, 0.04170543f, -0.11965162f, 0.03763167f, -0.02703592f, -0.02789685f, 0.08625142f, -0.37112910f, 
    -0.15245569f, 0.28197569f, -0.03686420f, -0.14544685f, 0.11835436f, -0.00203048f, 0.06326591f, 0.10765614f, 
    0.15034699f, -0.07453614f, 0.01250278f, 0.07951791f, -0.11527147f, 0.06359712f, 0.13586782f, 0.15094444f, 
    0.09778225f, 0.20640482f, -0.11536407f, 0.01363901f, -0.01754466f, 0.08344213f, 0.11798041f, 0.13567477f, 
    -0.01256220f, -0.15448503f, 0.20517138f, -0.36353987f, -0.10936542f, 0.27674997f, -0.12746538f, 0.04353078f, 
    -0.13795742f, -0.58215302f, -0.45849520f, 0.18414578f, 0.19912095f, -0.20060775f, 0.00489853f, -0.69880831f, 
    0.18539385f, -0.17981882f, -0.01121783f, 0.05821665f, 0.09343588f, 0.01802585f, -0.63131785f, -0.18435261f, 
    0.05134083f, -0.16559272f, 0.10759865f, 0.08558667f, -0.01856140f, 0.26175901f, 0.34109086f, -0.15358295f, 
    0.10633939f, 0.11095124f, 0.18790504f, 0.10910184f, 0.09653264f, -0.12096316f, 0.10202862f, 0.35412553f, 
    -0.39695671f, -0.02198532f, -0.02717860f, 0.02036536f, -0.01287633f, 0.17967117f, -0.09127781f, -0.00243401f, 
    -0.08112627f, -0.02040382f, 0.18185903f, 0.02506620f, -0.08125722f, 0.13749552f, 0.21759482f, -0.04841956f, 
    0.01525175f, -0.49849632f, 0.35392791f, -0.09077737f, 0.04291896f, 0.25042543f, 0.09910624f, 0.03480561f, 
    -0.00423322f, -0.15959902f, -0.32638296f, -0.15935613f, 0.00693985f, 0.04652081f, -0.04405274f, 0.09859928f, 
    -0.27007869f, 0.35532162f, -0.46095017f, -0.01408486f, -0.28550863f, 0.38588259f, 0.05081398f, -0.11081405f, 
    -0.01768439f, -0.26051599f, 0.02403360f, -0.04545465f, 0.00559638f, -0.02072016f, -0.31570771f, 0.14552313f, 
    0.06848302f, 0.20516860f, -0.61818957f, -0.03628123f, 0.10551789f, 0.23049158f, 0.08234362f, -0.09187742f, 
    -0.04494585f, -0.07672709f, -0.08142117f, -0.02317855f, -0.09906689f, -0.10234657f, -0.04809330f, -0.63251686f, 
    -0.33165896f, -0.22028668f, 0.05276032f, 0.38184914f, -0.05142393f, -0.04649159f, -0.52880520f, -0.01484162f, 
    -0.11100604f, -0.12641530f, 0.04267295f, 0.04210220f, -0.27747858f, -0.21872367f, 0.16154531f, 0.09830856f, 
    0.00591594f, -0.25563079f, 0.46343300f, -0.09916870f, 0.01395133f, -0.10377291f, -0.12726921f, -0.06998728f, 
    0.01178555f, 0.02296206f, -0.05609259f, -0.22176845f, -0.06480607f, -0.37688228f, 0.29982632f, -0.07872634f, 
    -0.06977922f, 0.39549863f, -0.19097742f, -0.10392981f, -0.21259098f, -0.36392158f, -0.31428954f, 0.21815598f, 
    -0.03120407f, -0.03437983f, -0.69563824f, 0.05749822f, -0.27871871f, -0.06204008f, 0.09541732f, 0.15808509f, 
    0.08549599f, -0.06087080f, 0.21681902f, 0.03956087f, -0.06506474f, 0.01534633f, 0.10821544f, 0.17669082f, 
    0.04555300f, 0.11856651f, 0.03755475f, 0.09979910f, -0.09987189f, -0.03671000f, -0.03585244f, 0.08048815f, 
    -0.18409374f, -0.21560502f, 0.10219491f, -0.28912941f, -0.12776957f, 0.07938433f, 0.03399567f, 0.19406086f, 
    -0.04253043f, 0.02148990f, -0.06719531f, 0.02498092f, -0.03925240f, 0.24697462f, -0.13229424f, -0.43277317f, 
    -0.04443999f, 0.24118033f, -0.14175311f, 0.07055011f, -0.00970793f, -0.05668233f, -0.37641463f, 0.04382301f, 
    0.09526336f, 0.15849124f, -0.13357444f, 0.12400817f, -0.05443459f, -0.25755417f, -0.16282152f, -0.05682785f, 
    0.05377162f, -0.08632931f, -0.21902007f, 0.09904790f, -0.18329400f, 0.14798446f, 0.21722755f, 0.20673785f, 
    0.08548084f, 0.10156991f, -0.02470516f, -0.11333201f, 0.11856584f, 0.02664758f, 0.25933591f, -0.12098875f, 
    -0.04614656f, 0.17976066f, 0.17682093f, 0.02600289f, -0.06313743f, 0.00830034f, 0.08673844f, -0.14896838f, 
    -0.02906802f, 0.05424364f, -0.46434081f, 0.11869080f, 0.01840749f, -0.05263203f, -0.06456436f, -0.67675513f, 
    0.24756853f, 0.30039090f, 0.04336486f, 0.00741426f, 0.02259743f, 0.06888298f, -0.12427250f, -0.01765333f, 
    0.04212538f, -0.07623438f, -0.34065515f, -0.03056814f, 0.26625600f, -0.20703162f, -0.15279190f, -0.05173417f, 
    -0.07965942f, -0.10328019f, -0.57279795f, 0.05935072f, 0.11959433f, 0.18302323f, -0.01706238f, 0.15188240f, 
    -0.11428366f, 0.30585387f, 0.17158106f, 0.03023203f, 0.05972653f, -0.13273552f, -0.38600826f, 0.01185612f, 
    0.20318386f, -0.17840832f, 0.24555513f, -0.61054736f, -0.10500330f, 0.22260772f, 0.02763814f, 0.01890574f, 
    0.10134076f, 0.11504280f, 0.00817675f, 0.08849644f, -0.26664588f, -0.11085524f, -0.33051902f, 0.10920155f, 
    -0.11233820f, -0.37192142f, 0.12002486f, -0.03179219f, 0.04844590f, 0.03267832f, -0.15666896f, 0.00360887f, 
    0.09943006f, -0.05080629f, 0.04604691f, -0.18567199f, 0.07956785f, 0.06967817f, 0.03078282f, -0.23264404f, 
    -0.21053568f, -0.15990172f, 0.04020864f, -0.19478199f, -0.11816837f, 0.20889884f, 0.18923531f, -0.52357644f, 
    0.04774776f, 0.06601276f, -0.47873065f, 0.09379963f, 0.10498347f, 0.29113230f, 0.01164784f, -0.22154184f, 
    -0.04722944f, -0.18235689f, -0.44764367f, 0.01580027f, -0.02690928f, -0.85659051f, 0.25352055f, -0.22903664f, 
    -0.06061113f, -0.15719901f, -0.35941330f, -0.10962258f, -0.04584684f, -0.07251317f, -0.03578715f, 0.01184331f, 
    0.06202057f, 0.29760882f, -0.07925914f, 0.27925199f, -0.26127237f, 0.12113573f, 0.04626361f, -0.14742869f, 
    0.17269795f, -0.33289257f, 0.06116879f, 0.06608394f, 0.16893277f, -0.07385492f, -0.36731803f, 0.31121913f, 
    -0.01095216f, 0.06207410f, -0.67222607f, -0.00654568f, 0.13063550f, -0.41983622f, -0.43558413f, 0.17338538f, 
    0.11348530f, -0.05501739f, 0.16817296f, -0.32403842f, -0.08815309f, -0.02246968f, -0.09092774f, -0.05982893f, 
    -0.31921235f, -0.19965753f, -0.09989810f, 0.06245371f, -0.05257323f, -0.27082074f, 0.17016253f, -0.47821912f, 
    -0.14711235f, 0.02922811f, -0.15543282f, -0.03988190f, -0.30145258f, -0.28885147f, 0.07413539f, 0.13571940f, 
    -0.06550799f, 0.16426189f, 0.31929842f, -0.07631121f, 0.09460799f, -0.16679306f, -0.15311936f, 0.17996313f, 
    -0.01534379f, -0.14055146f, 0.11034299f, -0.27906200f, 0.01836551f, -0.09439902f, -0.33453470f, -0.05533519f, 
    -0.08415004f, -0.01222990f, 0.36370340f, -0.26267421f, 0.22122897f, 0.07912170f, 0.18131834f, 0.41287723f, 
    -0.26723698f, -0.15683545f, -0.08050311f, -0.05262657f, 0.11458299f, 0.07034709f, 0.42795974f, -0.07681154f, 
    -0.06532525f, 0.03694671f, -0.47553682f, -0.10818667f, 0.13024545f, -0.53850633f, -0.16584924f, 0.13967292f, 
    -0.05151825f, 0.09721134f, 0.08949652f, 0.17092751f, 0.06584942f, -0.03867854f, 0.04998342f, 0.22775795f, 
    0.12468348f, -0.25139034f, 0.07923076f, 0.39339784f, -0.01356641f, 0.08744644f, -0.13622637f, -0.13301718f, 
    0.16896185f, -0.08965925f, 0.29371512f, 0.10112578f, -0.15909366f, -0.02843069f, -0.08918398f, 0.25399604f, 
    0.09589267f, -0.17052026f, 0.20733540f, 0.02689333f, -0.00987367f, -0.47457883f, -0.13610436f, 0.17744233f, 
    0.05074019f, -0.32865760f, 0.26137960f, -0.63040000f, -0.05208643f, 0.34272015f, -0.01291751f, 0.02163780f, 
    0.27484953f, -0.28295451f, 0.08822573f, -0.49163687f, -0.21325959f, 0.16252023f, -0.15307574f, -0.31874087f, 
    -0.30279791f, -0.04820317f, -0.39394504f, 0.07362860f, -0.12379245f, -0.07897499f, -0.36375475f, 0.02282748f, 
    0.10435914f, -0.05721909f, -0.27028409f, 0.00685808f, -0.00179332f, -0.67554635f, -0.02023213f, 0.17574787f, 
    0.11717550f, -0.11610892f, 0.16799474f, -0.18533494f, 0.07959954f, -0.05588515f, 0.02076574f, -0.04108021f, 
    -0.21050361f, -0.01297045f, 0.07580315f, -0.30787748f, 0.06238379f, 0.03192921f, 0.19959611f, 0.27921298f, 
    -0.22132851f, -0.03888559f, -0.44509327f, 0.09398735f, 0.00103654f, -0.13635692f, 0.09035330f, -0.52698040f, 
    0.01620739f, -0.33016196f, 0.01101781f, -0.12226182f, -0.05340377f, 0.02856784f, 0.12242460f, -0.42292717f, 
    -0.04431968f, 0.02000012f, -0.19738904f, 0.35424483f, 0.05254498f, 0.04093474f, -0.16693394f, -0.00714491f, 
    0.19636440f, -0.06237397f, 0.49576008f, 0.07951549f, 0.29378831f, 0.20869637f, 0.12051358f, -0.17386457f, 
    -0.04950260f, -0.22569227f, 0.23111232f, -0.67930073f, 0.17262639f, -0.00887048f, 0.16869771f, 0.03790215f, 
    -0.12742089f, 0.18987574f, -0.09112751f, -0.01639478f, 0.02932362f, -0.11651612f, -0.13049835f, -0.01844742f, 
    0.02143618f, -0.10566417f, -0.30100304f, -0.15333869f, 0.09252212f, 0.03280138f, 0.08856434f, 0.17289926f, 
    0.13828287f, 0.02017308f, -0.11826478f, -0.30277708f, 0.02376881f, 0.18825427f, -0.36721796f, -0.54688710f, 
    0.03131979f, 0.08899062f, 0.11515216f, -0.07017049f, -0.16711421f, -0.06129943f, -0.16303544f, 0.17237501f, 
    0.09402040f, -0.25985494f, -0.04070514f, 0.11473359f, -0.05770069f, -0.53793025f, -0.29195121f, 0.17314847f, 
    -0.02712984f, 0.36940429f, 0.18448976f, -0.46149576f, -0.03647071f, -0.16217130f, 0.24380808f, 0.01480813f, 
    0.04586938f, 0.01779011f, 0.08340412f, 0.14815664f, -0.19287716f, -0.22814879f, -0.53240609f, -0.31707668f, 
    -0.06758009f, 0.22164489f, 0.02098084f, 0.13189840f, 0.28069592f, -0.08602568f, -0.53853410f, 0.19755296f, 
    -0.04045955f, 0.27706605f, -0.36780328f, 0.04078883f, -0.52550238f, 0.23244013f, 0.27681008f, -0.03992440f, 
    -0.04669235f, -0.03307431f, 0.14572994f, 0.01894316f, -0.01053640f, -0.01565270f, -0.09329253f, -0.18345815f, 
    0.39136720f, -0.08917957f, 0.05856715f, -0.09355671f, 0.04431823f, -0.13720185f, 0.00308116f, -0.30850163f, 
    0.20868731f, 0.01372851f, 0.43364292f, 0.10381807f, -0.38418031f, 0.11603591f, -0.37520674f, -0.09087094f, 
    0.02460172f, 0.24019767f, 0.04195438f, -0.11167332f, -0.07487085f, -0.71949297f, -0.00330917f, -0.17788610f, 
    -0.02473865f, -0.22267088f, -0.11317705f, 0.20658232f, -0.03163026f, -0.29041222f, 0.39077070f, -0.10352406f, 
    0.06906573f, 0.09565365f, -0.73924130f, 0.36795878f, 0.16986035f, 0.04130274f, 0.03729991f, -0.05873251f, 
    -0.48858255f, 0.33814761f, 0.29120073f, 0.14698401f, -0.17195258f, 0.10148459f, -0.02729822f, 0.12136596f, 
    0.02419054f, -0.20050053f, -0.06983659f, -0.11062341f, 0.14557458f, 0.00569129f, -0.29544815f, 0.02521219f, 
    0.02204256f, 0.07681250f, -0.00116771f, -0.17469817f, -0.07677986f, 0.02392064f, 0.05642427f, -0.38239509f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.05599430f, 0.03473245f, 0.21609259f, -0.18384846f, 0.06670296f, -0.03758675f, 0.14189811f, -0.10738686f, 
    0.07841705f, -0.10806607f, -0.06310733f, -0.00870043f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
