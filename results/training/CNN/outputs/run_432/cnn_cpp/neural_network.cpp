#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.72084993f, -0.20660557f, 1.18144631f, -0.42658457f, -0.45009071f, 0.58152133f, 0.34455073f, 0.21999364f, 
    0.99225205f, 0.66091955f, 1.35799110f, 0.73628533f, -0.97162139f, 1.04807591f, 0.15805829f, 0.46623060f, 
    0.58996618f, 0.22418076f, -0.02233811f, 1.73712766f, -0.86804098f, 0.57798254f, -0.64696383f, -1.12045836f, 
    0.34832814f, -0.02070824f, -0.24327181f, 1.03518450f, 1.04247606f, 0.92031872f, -0.30192009f, -0.56482518f, 
    -0.61724037f, -0.30764902f, -0.11387403f, 0.36839399f, 0.32022005f, -0.56038940f, 0.78289235f, 1.28599441f, 
    1.17740917f, -1.21888888f, 0.43683997f, 0.22772500f, -0.06942332f, 1.23641419f, -1.13503218f, 0.26028964f, 
    1.04547739f, -0.85575414f, 0.18029760f, -0.09200975f, -0.11985555f, -0.01578544f, -1.51638138f, -1.10653722f, 
    -1.26494002f, 0.30041039f, -0.52710068f, 0.13354059f, -0.08158574f, 0.07430737f, 0.10703837f, -0.81959814f, 
    -0.83122087f, 0.30340832f, 1.37100971f, 0.92959893f, 0.68999928f, -0.38036388f, -0.01183960f, -0.54101896f, 
    0.21053764f, -1.66319442f, -1.09233069f, -0.90416712f, -0.42747739f, -0.29929164f, -0.10651410f, 0.04588991f, 
    0.44888186f, -0.72012043f, 0.82219827f, 0.47215900f, -1.00288832f, 0.31698775f, -1.49556422f, -0.38672245f, 
    0.11937652f, -0.01434527f, -0.30121264f, -0.88764918f, 0.13762107f, -0.91623127f, 0.65127355f, 0.15210256f, 
    -0.26481271f, -0.78583461f, -1.05303872f, -0.85885358f, -0.43825236f, -0.94968307f, 0.08289056f, 1.12537229f, 
    -0.18320915f, -0.13217451f, -0.15088589f, -0.51603687f, 0.89584500f, 0.97159678f, 1.27222180f, 0.33778921f, 
    -0.34421128f, 1.18593025f, 0.07914320f, 0.04075378f, 0.07927746f, -0.37421289f, -0.31860444f, 0.05053731f, 
    -0.12183198f, 0.73876953f, 1.56362104f, 0.28307110f, 0.04373239f, -0.14962047f, 0.96730393f, 0.00197454f, 
    0.54730219f, -0.42242178f, -0.48287401f, -1.12762070f, 0.56600881f, 0.78963286f, 0.14434318f, -1.01913869f, 
    0.55566782f, -0.98745096f, 0.46201810f, 1.14764798f, 0.61144632f, 0.21052420f, 0.17795613f, 0.53872371f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15941346f, -0.12318845f, 0.28935590f, -0.21963680f, -0.34096900f, -0.42841512f, 0.32927454f, -0.10583746f, 
    0.18742739f, 0.55570871f, 0.21348843f, 0.10239822f, 0.90863234f, -0.18134746f, 0.20721643f, 0.49209934f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.73131454f, -0.06049079f, 0.08109885f, -0.13427232f, 0.04837021f, -0.18830949f, -0.05303296f, -0.13186571f, 
    0.18094622f, 0.08223989f, 0.25856468f, -0.42578796f, -0.26397249f, -0.00793430f, -0.06333903f, -0.10231241f, 
    0.04603589f, -0.07905842f, -0.05475737f, -0.24130698f, 0.01599565f, -0.14791597f, 0.04410796f, 0.01525617f, 
    -0.11329320f, 0.03141134f, 0.32390922f, 0.16451891f, 0.02138740f, 0.14035116f, -0.43954667f, -0.16816194f, 
    0.14051847f, -0.14875947f, 0.21066783f, 0.02374213f, -0.15066130f, -0.97845817f, 0.31657210f, -0.10251597f, 
    0.26812685f, -0.13741246f, 0.00886862f, 0.29394281f, 0.04952814f, 0.39330265f, 0.03889100f, 0.01693635f, 
    -0.06081108f, 0.05393663f, -0.06111170f, 0.02741562f, 0.16625738f, -0.05669659f, -0.06486839f, 0.22835459f, 
    -0.18203060f, 0.04515951f, 0.01342657f, 0.27260140f, 0.06372959f, -0.28550059f, 0.05732524f, 0.50084984f, 
    0.13856378f, -0.03575728f, 0.18215686f, -0.03900717f, -0.13465165f, 0.14788182f, -0.05688947f, -0.03373824f, 
    -0.20975156f, -0.81933767f, 0.05513592f, -0.17736617f, 0.40996075f, 0.24769144f, -0.04179588f, 0.27451414f, 
    -0.43198961f, -0.26109248f, 0.12489355f, -0.20205475f, 0.05753979f, 0.00826908f, 0.11951301f, 0.02151329f, 
    0.26155996f, 0.19371830f, 0.19094793f, 0.03621045f, -0.21054484f, 0.03537501f, -0.02221984f, -0.10273674f, 
    0.36229813f, 0.01772879f, -0.06431311f, 0.29802316f, -0.19793794f, -0.98850232f, 0.09751693f, 0.05057026f, 
    0.12629341f, 0.23800424f, 0.13489550f, -0.13051654f, -0.05655249f, 0.17810711f, 0.38578981f, -0.09702454f, 
    0.06837155f, 0.27045071f, 0.22005129f, -0.13249567f, -0.17118229f, -0.04244944f, 0.34820640f, -0.60337245f, 
    -0.10898781f, -0.00227322f, -0.00813577f, -0.22066866f, -0.17756560f, -0.06680886f, -0.24178952f, 0.11981260f, 
    0.06518221f, -0.11185200f, 0.00202878f, 0.02622650f, 0.06911194f, 0.06741996f, -0.13252115f, 0.74234968f, 
    -0.03307445f, -0.16608793f, 0.14236587f, 0.00550375f, -0.07057745f, -0.10841316f, -0.18305643f, -0.10557777f, 
    -0.03945596f, -0.08880819f, 0.05933669f, 0.01254145f, 0.00794076f, -0.08488412f, -0.02355252f, -0.03956378f, 
    0.01949162f, -0.08397366f, -0.06104399f, 0.03839535f, -0.03418015f, -0.03879484f, 0.02811962f, 0.01381813f, 
    -0.01090187f, -0.06617592f, -0.02473588f, -0.07450373f, 0.03676700f, -0.04074737f, -0.05400218f, 0.07474309f, 
    0.06749431f, 0.01775485f, 0.05553934f, -0.05109787f, -0.03909072f, -0.08409218f, -0.03898057f, -0.01079219f, 
    0.05595482f, -0.06482264f, -0.00666691f, 0.05576666f, -0.07553593f, -0.04269000f, 0.00711887f, 0.07964291f, 
    0.04736261f, -0.08094725f, -0.04288454f, 0.03314034f, 0.01774752f, -0.06625141f, -0.06887427f, -0.01225362f, 
    0.02364099f, 0.06766521f, -0.07055011f, -0.04386857f, 0.05917017f, -0.04899474f, 0.00729602f, -0.03890904f, 
    0.00951597f, 0.06939310f, -0.04726338f, 0.04940850f, -0.01657178f, -0.07845087f, 0.05962338f, 0.07183394f, 
    -0.00620658f, 0.05594453f, -0.06942242f, -0.06436286f, -0.04065050f, -0.05078072f, 0.04368569f, 0.08013587f, 
    0.04460073f, -0.00712412f, -0.03212275f, 0.00371706f, 0.04455038f, -0.04187521f, -0.02524988f, -0.09195294f, 
    0.02471341f, 0.03657999f, -0.01015583f, -0.03093831f, -0.00311413f, -0.02856367f, -0.04076760f, 0.04254044f, 
    -0.00774008f, -0.07053430f, -0.07384427f, -0.08897328f, -0.04700076f, 0.01776595f, 0.01000015f, -0.00278774f, 
    -0.03697946f, -0.06361065f, 0.01916877f, 0.03041084f, -0.01753463f, 0.04130924f, -0.02123544f, 0.05046855f, 
    -0.08816663f, -0.01367190f, 0.00409271f, -0.03949381f, 0.01141515f, -0.04791105f, -0.01393141f, -0.00391155f, 
    -0.09254543f, 0.05083351f, -0.07527390f, 0.02346219f, -0.07121325f, -0.03270284f, 0.06619602f, -0.06431084f, 
    0.03294680f, 0.02271875f, -0.02192695f, -0.03416897f, 0.06700289f, -0.02833356f, 0.03074240f, -0.01760742f, 
    -0.02280533f, 0.03770650f, -0.04667822f, -0.08512134f, -0.05753289f, -0.07126520f, 0.05698999f, 0.04979009f, 
    -0.05096684f, 0.03561262f, 0.03492891f, -0.01241604f, -0.03795455f, 0.03061819f, -0.08861434f, -0.03180942f, 
    -0.16161375f, -0.24671806f, -0.01216884f, -0.17101230f, 0.02383539f, 0.05417122f, 0.28570256f, -0.06337742f, 
    0.07531868f, 0.40239236f, 0.11055317f, 0.06101098f, -0.00751772f, -0.15636817f, -0.23440349f, 0.00738028f, 
    -0.11663006f, 0.12385510f, -0.24407686f, -0.29091927f, 0.11093635f, 0.08538955f, 0.18587668f, 0.04699213f, 
    -0.01315582f, -0.05390601f, -0.05153329f, -0.08589043f, 0.07321699f, -0.14312474f, -0.03235151f, 0.05510860f, 
    0.20171778f, -0.35790607f, 0.10165147f, 0.07018742f, 0.02828311f, -0.03102717f, 0.20596261f, 0.21358463f, 
    0.19203193f, 0.38073966f, 0.08285438f, -0.00146701f, 0.17024276f, -0.06796630f, -0.03832117f, -0.13804854f, 
    -0.09669823f, -0.01124974f, 0.07825944f, 0.24228840f, -0.09930006f, 0.27223703f, -0.85644913f, 0.15577269f, 
    -0.10067988f, -0.31429297f, 0.21551983f, 0.20721897f, -0.08329335f, 0.38256487f, -0.11061637f, -0.03306853f, 
    0.09154038f, -0.38165182f, -0.38312337f, -0.19787812f, -0.21179403f, 0.08618882f, 0.01929775f, 0.01454904f, 
    -0.52621818f, -0.01339114f, -0.58130974f, 0.12145524f, -0.07001743f, 0.08892564f, 0.03736864f, 0.00576914f, 
    0.02271180f, 0.54270744f, -0.14260024f, -0.00791011f, -0.14411780f, -0.00438562f, 0.35956621f, 0.10712461f, 
    0.03192192f, 0.14021769f, 0.28859660f, 0.02162431f, -0.32097417f, 0.14617264f, 0.32655269f, -0.12255540f, 
    0.14352821f, 0.13926408f, -0.20389435f, -0.57042420f, -0.30971926f, -0.60182816f, 0.20219636f, 0.19490007f, 
    -0.29569271f, -0.18518020f, -0.14035928f, -0.39270025f, -0.14031310f, 0.11705190f, 0.08829246f, 0.19274643f, 
    0.13651191f, 0.25744149f, 0.22067581f, 0.19845058f, 0.14250353f, 0.20421347f, 0.01646457f, -0.16015312f, 
    0.10120964f, -0.29467413f, 0.02116178f, 0.25808838f, 0.00591181f, -0.33791500f, 0.63241345f, 0.42732608f, 
    -0.16564575f, -0.12678055f, 0.11323386f, 0.13958706f, 0.01160704f, -0.15313567f, -0.03083675f, -0.36405951f, 
    -0.04620693f, 0.07076732f, -0.02777606f, -0.10616830f, -0.14482877f, -0.04957036f, -0.06997696f, 0.19725893f, 
    0.08683793f, 0.33101273f, -0.18699504f, -0.11582182f, -0.23747404f, -0.03159438f, 0.11266936f, -0.00790625f, 
    -0.15248239f, 0.00203459f, 0.15216424f, -0.27114606f, -0.14713208f, 0.10868438f, -0.00415881f, -0.06883167f, 
    0.01984055f, -0.05039104f, 0.15594207f, -0.88524073f, -0.30109209f, -0.11732108f, 0.16158003f, 0.15588965f, 
    -0.11253750f, 0.05648226f, -0.05577283f, -0.35780865f, 0.00980507f, 0.13532139f, -0.10213449f, 0.12287058f, 
    0.22739263f, -0.19831428f, 0.00301507f, 0.00516527f, 0.09143165f, -0.64502364f, -0.17064302f, -0.12986162f, 
    0.02044552f, -0.00573258f, 0.17051642f, 0.19567099f, -0.12147538f, -1.48448598f, 0.21068746f, 0.06783870f, 
    0.28446218f, -0.00335810f, -0.12294867f, -0.12999873f, 0.11709289f, -0.14622186f, -0.33262232f, 0.22683041f, 
    0.56060743f, -0.19201864f, -0.02819872f, -0.12560278f, 0.09196501f, 0.12295633f, 0.18870348f, 0.79216427f, 
    0.14777102f, 0.10558902f, -0.06132201f, -0.03759559f, 0.05945813f, -0.10394301f, 0.19887348f, -0.03229524f, 
    0.55232590f, -0.43359426f, -0.01883981f, -0.12176598f, 0.18541788f, 0.19741550f, 0.04211380f, -0.15500623f, 
    0.06743369f, 0.14352810f, -0.06461734f, -0.78138483f, 0.12578878f, -0.10401357f, 0.23689049f, -0.06164825f, 
    -0.01526324f, 0.08523551f, -0.06832184f, 0.14508541f, -0.43906870f, 0.15888520f, -0.15167207f, -0.38801175f, 
    0.07107151f, -0.08110176f, -0.01818512f, 0.06024688f, -0.29828230f, -0.34037825f, -0.17723282f, 0.14738442f, 
    0.01098574f, 0.06288899f, 0.03984399f, -0.02384540f, -0.34532067f, 0.04670025f, -0.24934320f, 0.12513679f, 
    0.06370235f, 0.08126345f, 0.06584048f, -0.03407091f, 0.31367576f, 0.15592261f, 0.47771448f, 0.16200589f, 
    0.03628637f, -0.08330118f, -0.00650574f, -0.19814464f, 0.16456142f, 0.38717240f, -0.13235599f, 0.39546052f, 
    -0.12741289f, 0.32303259f, 0.13818501f, -0.13207003f, 0.08314238f, -0.07947443f, -0.08497835f, 0.65619940f, 
    0.29907793f, 0.07150249f, -0.19960988f, -0.09444880f, -0.12178951f, 0.16301373f, -0.10374307f, 0.17802718f, 
    0.22001332f, -0.08630522f, -0.08665942f, 0.03265824f, -0.21270497f, 0.20918648f, -0.19543220f, -0.16417663f, 
    -0.25352842f, -0.20190489f, 0.33336890f, 0.18111521f, -0.07146064f, 0.20954084f, 0.09847027f, -0.11311568f, 
    -0.07250911f, -0.11888262f, 0.75159824f, 0.04620628f, 0.12388728f, -0.02322510f, -0.06695454f, 0.13798805f, 
    -0.03204466f, 0.18005857f, -0.01646621f, -0.39503697f, 0.08741907f, -0.15118070f, 0.20113653f, 0.17555304f, 
    -0.14751555f, 0.11218954f, 0.08102468f, 0.04964619f, 0.10517715f, 0.15439667f, 0.09183029f, 0.17901415f, 
    -0.07961553f, -0.07597340f, -0.05108157f, 0.21175973f, -0.24696453f, 0.03419602f, 0.05413015f, -0.51541221f, 
    -0.11255252f, -0.09638289f, -0.26478904f, -0.20365058f, 0.17089435f, -0.16135003f, 0.01535292f, -0.13903518f, 
    0.01518688f, 0.01356467f, -0.07429513f, 0.01718010f, 0.14086613f, -0.28484586f, 0.21163867f, 0.07925508f, 
    -0.54336619f, -0.05922171f, 0.04632058f, 0.10295600f, 0.03715338f, -0.09366706f, 0.03439435f, -0.18135388f, 
    0.31130549f, -0.35343343f, 0.34950817f, -0.11853753f, -0.00306854f, -0.15434068f, 0.14659917f, 0.17799848f, 
    0.01401821f, 0.63250452f, 0.05936462f, 0.24526563f, 0.16265127f, -0.24466145f, -0.25251573f, -0.09873861f, 
    -0.05524990f, -0.08237770f, -0.09724641f, 0.03398296f, 0.02981194f, 0.03497705f, -0.10789974f, 0.27104834f, 
    0.15666547f, 0.03827741f, 0.12396196f, 0.04825675f, 0.18208055f, 0.19612516f, -0.26947173f, -0.20173216f, 
    -0.05280395f, 0.01252540f, 0.23501815f, 0.58240831f, -0.51486647f, -0.31741312f, 0.02270966f, -0.10841154f, 
    0.29581556f, 0.11379243f, 0.05974544f, 0.08394389f, -0.08364905f, 0.19369744f, -0.24638158f, 0.05640330f, 
    -0.19588414f, 0.10514130f, 0.07283837f, 0.05415798f, -0.14281158f, -0.35715196f, -0.14085090f, -0.11332361f, 
    0.17902625f, -0.13711372f, 0.09735290f, -0.37334287f, -0.09964862f, -0.18560031f, 0.10201075f, 0.22145005f, 
    -0.04279151f, 0.05139374f, 0.00870738f, 0.03532077f, 0.06134081f, 0.09168492f, -0.01692897f, -0.07601679f, 
    -0.03331629f, -0.05066248f, -0.07104249f, 0.04441730f, -0.03894146f, 0.00036607f, 0.02025102f, 0.06550550f, 
    -0.03162850f, 0.01486730f, -0.06850807f, -0.08642538f, 0.06170442f, 0.02832013f, -0.07438634f, 0.06477171f, 
    -0.04690732f, 0.05389793f, -0.01695232f, -0.07454100f, -0.07734159f, 0.04966455f, -0.09640643f, -0.02961693f, 
    -0.00259262f, -0.07789296f, 0.05675205f, 0.04294245f, 0.05929103f, -0.01034127f, -0.04524170f, -0.07810513f, 
    -0.04425494f, 0.01589283f, -0.09842268f, -0.06868527f, 0.04584995f, 0.03569644f, -0.04785884f, -0.06217527f, 
    -0.00461796f, -0.11235896f, -0.02805560f, 0.05511399f, 0.04785954f, 0.02011114f, 0.02226487f, -0.05886522f, 
    0.07146402f, 0.02303049f, -0.06462973f, -0.02939706f, 0.05343009f, 0.03280279f, 0.09698411f, -0.06634038f, 
    0.03283034f, -0.04321419f, -0.05634307f, -0.04699125f, -0.04220911f, 0.07796226f, 0.03804225f, -0.00044554f, 
    0.07308081f, 0.00038785f, -0.05977807f, 0.06156890f, 0.04585418f, -0.10337700f, 0.00339183f, 0.05787663f, 
    -0.05646432f, -0.07290285f, 0.01122196f, 0.01345440f, -0.02564340f, -0.00295597f, -0.03919263f, -0.02102291f, 
    0.04279271f, -0.02714214f, -0.04192657f, -0.10005306f, -0.08571788f, 0.02689131f, -0.09974422f, 0.05205378f, 
    -0.07963830f, -0.04408646f, -0.03576187f, -0.02586781f, -0.02327063f, -0.02585499f, 0.04422680f, 0.02329438f, 
    0.05498996f, 0.04972783f, -0.08558945f, -0.00184759f, -0.10619362f, -0.05025757f, 0.00828779f, -0.00874913f, 
    0.04040682f, -0.08120319f, -0.06263985f, 0.07615493f, 0.04086431f, -0.07242145f, 0.04413399f, 0.07562570f, 
    -0.00230944f, 0.00030182f, 0.02476010f, -0.01820328f, 0.03817230f, 0.00393137f, -0.01552498f, -0.09178149f, 
    0.06437756f, -0.05166037f, -0.03966343f, -0.08578454f, -0.08662641f, 0.06569080f, 0.03328552f, -0.10518736f, 
    0.02566059f, 0.06555440f, 0.06136679f, -0.06757789f, -0.07145716f, 0.00437288f, -0.01353813f, -0.04910788f, 
    -0.04867075f, -0.03497529f, -0.00704052f, -0.10388251f, -0.05152999f, 0.00719207f, -0.08613867f, 0.02729023f, 
    -0.55672991f, 0.05615415f, 0.08773549f, 0.05572710f, -0.16945176f, -0.01115200f, 0.19738743f, 0.05981228f, 
    -0.08236085f, 0.29740894f, -0.14452054f, -0.15455075f, -0.04406722f, -0.32675517f, 0.06950209f, -0.05897372f, 
    0.05718751f, 0.13145775f, -0.21407017f, 0.09275875f, 0.11508232f, 0.08906786f, 0.04788229f, -0.08167506f, 
    0.18671954f, 0.16781898f, -0.11247863f, 0.76104259f, 0.39193025f, -0.14991623f, -0.02599803f, -0.08608315f, 
    -0.05852588f, 0.15154065f, -0.01731577f, -0.18094108f, -0.18001682f, -0.21866830f, -0.15603867f, 0.16223572f, 
    -0.08890628f, 0.13679092f, 0.12774564f, 0.18179075f, 0.15422519f, -0.09325113f, -0.25374031f, -0.20107940f, 
    0.18328042f, 0.22263353f, 0.05567884f, -0.23111401f, -0.01007465f, 0.15128224f, 0.66417998f, 0.10554418f, 
    0.07892674f, -0.30983576f, -0.11936397f, -0.12126414f, 0.22846015f, -0.06569726f, -0.11623415f, -0.40689892f, 
    -0.50237560f, 0.10007027f, 0.02575213f, 0.22128530f, 0.08959151f, -0.03896130f, 0.16159070f, -0.13317084f, 
    -0.00928199f, -0.03209814f, -0.33310679f, 0.16444400f, -0.11932275f, 0.25914681f, -0.05077035f, -0.16197133f, 
    -0.00288172f, -0.08350646f, 0.18552704f, -0.03518583f, -0.03326101f, 0.26008663f, 0.06217187f, 0.10637078f, 
    -0.23126636f, -0.06065743f, -0.63022697f, -0.16483565f, -0.34397984f, 0.02301306f, 0.05237575f, 0.00421175f, 
    -0.27909026f, 0.03402549f, 0.46794885f, -0.47790191f, -0.28866097f, 0.26373026f, 0.15338202f, -0.15934511f, 
    -0.05154059f, -0.08533745f, 0.14793760f, 0.06411720f, 0.63231766f, 0.11819913f, -0.17904848f, 0.05140318f, 
    -0.10444690f, 0.06594499f, 0.22468977f, 0.02566725f, 0.06141845f, -0.47695324f, -0.04552313f, -0.08124379f, 
    -0.11999847f, 0.07693124f, 0.10513304f, -0.34407616f, 0.28164694f, 0.07759760f, 0.57064307f, 0.04657049f, 
    -0.37929493f, 0.18609370f, -0.07374388f, -0.03467055f, 0.28506228f, 0.21671124f, -0.17739256f, -0.24730894f, 
    -0.23421173f, 0.46842441f, -0.05286415f, 0.31671974f, 0.07961601f, 0.01341524f, 0.06475069f, -0.08581445f, 
    0.08399167f, 0.00777419f, -0.06383648f, -0.03691098f, -0.04539032f, 0.02249056f, -0.01080347f, -0.07416488f, 
    -0.08035791f, 0.02065942f, -0.04019532f, -0.05365755f, -0.07416832f, -0.04537966f, -0.08843056f, -0.04970726f, 
    -0.05405589f, 0.00317729f, -0.00633016f, 0.03955663f, 0.01535294f, 0.05604890f, 0.06141929f, -0.05580026f, 
    -0.04495323f, -0.07138409f, 0.03879776f, 0.04462486f, 0.00499148f, 0.00243864f, -0.07524614f, 0.01047389f, 
    -0.00994029f, -0.04078979f, -0.07520418f, -0.01465658f, 0.01042885f, -0.01187340f, -0.01443478f, -0.06158768f, 
    0.02914720f, -0.08610722f, -0.06046893f, 0.05261518f, -0.01612534f, 0.01744436f, -0.06312802f, 0.04428478f, 
    0.01637367f, 0.02507638f, 0.02139200f, -0.01361878f, 0.04686613f, 0.03710448f, -0.00813277f, -0.03961607f, 
    0.03777600f, 0.04851484f, -0.03952264f, 0.00257513f, -0.08115019f, -0.00349058f, -0.01029652f, -0.08594733f, 
    -0.01515553f, -0.08604477f, -0.05628093f, -0.06278366f, 0.03483446f, -0.00870896f, -0.03125762f, -0.06389386f, 
    -0.02237086f, 0.01525815f, -0.01943476f, 0.04586639f, 0.00007521f, 0.04510346f, 0.05304107f, 0.00718393f, 
    -0.00816920f, -0.01311501f, -0.00714315f, -0.04437630f, -0.06948029f, -0.03687275f, -0.04892325f, -0.00593148f, 
    0.00026764f, -0.03854804f, -0.08609585f, 0.06083240f, 0.00381533f, -0.06889168f, -0.00524976f, 0.02047418f, 
    -0.04580503f, -0.03299596f, 0.05910974f, 0.04965514f, -0.00455110f, -0.03515662f, -0.02083967f, 0.00881062f, 
    0.00620314f, 0.02624734f, -0.06125293f, -0.07465192f, -0.01086032f, -0.04910611f, 0.08851304f, -0.05550836f, 
    0.05040857f, -0.02562108f, 0.01520338f, 0.04340628f, -0.00053097f, -0.04213533f, 0.07172254f, -0.08130939f, 
    -0.05638319f, 0.04209530f, 0.06796233f, -0.03526928f, -0.07973425f, 0.00903024f, 0.01466416f, -0.02202564f, 
    -0.06578540f, -0.04637882f, 0.00493284f, -0.06914423f, -0.08098549f, -0.00549062f, -0.01058223f, -0.05398271f, 
    -0.06511568f, 0.00250606f, -0.09352790f, 0.03377954f, 0.01241776f, -0.08944530f, 0.08253386f, -0.01814443f, 
    -0.00935014f, -0.00918789f, -0.02875020f, -0.00337776f, 0.01764252f, -0.06633836f, -0.01997264f, -0.03966834f, 
    -0.04136423f, 0.00534561f, -0.10449619f, -0.07776634f, 0.04850143f, 0.02390805f, -0.06463778f, -0.01666038f, 
    0.05106880f, 0.04153644f, -0.01772949f, -0.06906388f, -0.07533260f, -0.01225804f, -0.02871210f, 0.05449509f, 
    -0.02828906f, -0.08617204f, -0.02129002f, -0.02678883f, -0.06140988f, -0.09094032f, 0.05977371f, -0.03185052f, 
    0.00989960f, 0.02786250f, -0.04069604f, 0.06748454f, -0.00741451f, -0.06917157f, 0.03906387f, 0.04100193f, 
    0.06793538f, -0.00608839f, -0.07873476f, 0.04126433f, -0.03808713f, 0.05848115f, -0.03149211f, -0.03742435f, 
    -0.07089245f, -0.03901398f, -0.08359032f, -0.03810923f, 0.04898118f, 0.00762563f, 0.00699013f, -0.05498217f, 
    -0.04433093f, -0.02275702f, -0.06175818f, -0.07036878f, -0.05754793f, 0.01031793f, -0.05714097f, -0.05686992f, 
    0.01665825f, -0.09318613f, -0.03138292f, 0.06558245f, -0.02064998f, 0.05266612f, -0.00054118f, -0.00527809f, 
    0.03388765f, -0.06000468f, 0.03033358f, 0.07434846f, 0.00735629f, 0.05627457f, 0.05183645f, 0.06334506f, 
    0.04037733f, -0.08866885f, 0.03489456f, -0.04801423f, 0.02976321f, -0.07064888f, 0.02119369f, -0.05161357f, 
    -0.02316104f, -0.07328195f, -0.03534650f, 0.00208880f, -0.05154390f, -0.01126351f, -0.05741378f, 0.02529160f, 
    -0.07405846f, -0.02040939f, -0.04334982f, 0.04688568f, -0.06274410f, -0.07401159f, -0.00888400f, 0.04644413f, 
    0.04026134f, 0.04101457f, -0.05375368f, -0.04615026f, 0.06109812f, 0.05808224f, 0.06237712f, -0.02053649f, 
    0.02648442f, 0.04695285f, 0.06880470f, -0.01779660f, -0.02089053f, -0.09028511f, 0.04026424f, 0.05298843f, 
    0.05647966f, 0.05790617f, 0.01256034f, 0.02319074f, -0.05634081f, 0.03955203f, 0.02443471f, -0.05200681f, 
    0.02766001f, 0.01135770f, 0.02639428f, -0.00982569f, 0.03285731f, 0.00415583f, -0.06716153f, -0.05373523f, 
    -0.09714771f, -0.03545732f, -0.09772427f, -0.01198483f, -0.07630763f, 0.01029974f, 0.04168379f, 0.05306289f, 
    -0.54914117f, 0.10809939f, 0.13191418f, -0.07176822f, 0.14670072f, 0.00763624f, 0.03200254f, -0.10612057f, 
    -0.12691684f, 0.79094988f, 0.05685741f, 0.21381649f, 0.03956257f, 0.00112311f, 0.03458888f, 0.22131795f, 
    0.01565630f, -0.07551254f, 0.38797745f, -0.45624194f, 0.02665406f, 0.21138984f, -0.02163411f, -0.22217396f, 
    0.05818013f, -0.07456384f, 0.06109457f, 0.64675939f, 0.08219654f, 0.29170778f, 0.12742737f, -0.01473147f, 
    0.07644171f, 0.11378380f, 0.15993232f, 0.31160554f, -0.19923186f, -0.08246867f, -0.29012758f, -0.10358373f, 
    0.07336090f, -0.03777347f, -0.15880542f, -0.01270567f, -0.08307534f, -0.48178446f, -0.51364917f, -0.22402591f, 
    0.24350119f, 0.19218525f, -0.00835853f, -0.18020859f, 0.07828517f, 0.03207443f, 0.09184537f, 0.39449495f, 
    -0.30710265f, -0.23801665f, -0.03256737f, 0.12970240f, 0.12186527f, 0.13381568f, 0.08633419f, -0.71921527f, 
    -0.19181135f, 0.04333229f, -0.07806473f, 0.29010516f, 0.06959206f, -0.03371329f, 0.30087355f, 0.11969570f, 
    -0.05741040f, 0.41278499f, -0.35178280f, 0.09559742f, -0.03810695f, -0.08522249f, -0.08927203f, -0.01275774f, 
    -0.08734564f, 0.04562018f, 0.04712978f, -0.22293216f, -0.14970295f, -0.15282907f, -0.11272381f, -0.18988030f, 
    -0.11992747f, 0.03196220f, -0.18395844f, 0.20123932f, -0.54788774f, -0.11232446f, 0.01864682f, 0.23067154f, 
    -0.00002386f, -0.00608229f, 0.05807601f, -0.02415715f, 0.32259509f, 0.06714889f, -0.14412481f, -0.08081618f, 
    0.16686913f, -0.05473094f, 0.14764616f, -0.07928316f, 0.32599464f, -0.00117333f, 0.06308568f, 0.03884441f, 
    0.13028674f, -0.08094935f, -0.04027916f, 0.11432131f, 0.16317029f, -0.24983995f, 0.19867325f, -0.15096754f, 
    0.26592153f, -0.02849883f, -0.14024918f, -0.00497108f, 0.00749613f, 0.09187495f, 0.26811174f, -0.06328119f, 
    -0.18933640f, 0.04808076f, -0.13027442f, -0.00324323f, 0.04932939f, -0.04789122f, -0.13017212f, -0.45513919f, 
    0.17717603f, 0.20779778f, -0.15639204f, 0.03540843f, -0.04643437f, -0.05183915f, -0.00303453f, -0.12874268f, 
    0.31265390f, 0.35532197f, 0.36794907f, 0.00530966f, -0.01330407f, 0.20583905f, 0.04910105f, -0.12160090f, 
    0.08006188f, -0.20255166f, 0.01938164f, -0.38046518f, 0.07752397f, -0.28109676f, -0.09098577f, -0.23221029f, 
    -0.01117889f, 0.00872873f, 0.18608074f, 0.45174062f, -0.66882676f, -0.06378912f, -0.12557694f, -0.06440812f, 
    -0.07765546f, 0.19395587f, -0.03653695f, 0.13418965f, -0.10262166f, -0.22463517f, 0.16661336f, -0.01575800f, 
    -0.03916650f, -0.10915803f, -0.12092474f, 0.18048096f, 0.24336247f, -0.43563849f, -0.42649969f, 0.04919925f, 
    -0.21045037f, 0.21639384f, 0.00530188f, -0.09259491f, 0.16451940f, 0.11642687f, -0.26230082f, 0.13612178f, 
    -0.16596968f, 0.40148801f, -0.00396665f, 0.07155739f, 0.18651524f, 0.18738219f, -0.55634427f, -0.44395798f, 
    0.50148392f, 0.17807174f, -0.13704726f, -0.07211173f, -0.14593749f, 0.05392008f, 0.07572632f, 0.27846989f, 
    0.18543859f, 0.20612746f, -0.31651872f, -0.20784096f, -0.03023993f, -0.08971535f, 0.01914995f, 0.13084257f, 
    -0.04139440f, 0.10951331f, 0.13042690f, -0.07537805f, -0.22839296f, -0.21755740f, 0.10509443f, -0.02228957f, 
    -0.07397685f, -0.31952325f, 0.19224243f, -0.60128784f, -0.12287321f, 0.01250143f, -0.14702223f, 0.03240111f, 
    -0.13325593f, -0.05323323f, -0.05403763f, -0.09065822f, -0.01767113f, 0.25544280f, 0.11439721f, 0.17960140f, 
    0.14315593f, 0.20839553f, 0.28907901f, -0.16145760f, -0.30151913f, 0.30470160f, -0.06998898f, -0.23682366f, 
    0.12085629f, 0.09569520f, 0.04265601f, -0.03554118f, 0.08293587f, 0.19766365f, -0.19774407f, 0.25729841f, 
    0.19973415f, -0.13018061f, 0.11987402f, 0.15985636f, -0.25925866f, 0.07834964f, -0.26421338f, 0.26030350f, 
    0.00869573f, 0.15764272f, -0.06195200f, -0.09029879f, 0.03708692f, -0.09551765f, 0.42389947f, -0.00170121f, 
    -0.48932800f, 0.12522651f, 0.12608841f, -0.06836390f, 0.05344824f, 0.02967822f, -0.21749991f, -0.08493996f, 
    0.28283405f, 0.17428604f, -0.01742276f, -0.12908211f, 0.10103436f, 0.01307411f, -0.22829425f, 0.18947029f, 
    -0.33374575f, -0.55116916f, -0.26299229f, 0.02331681f, -0.01715292f, -0.03304194f, -0.05180615f, 0.04724595f, 
    -0.04843538f, -0.68197906f, 0.60647899f, 0.17232572f, -0.15561362f, 0.02339151f, 0.03042433f, -0.03607064f, 
    0.00672716f, -0.17396195f, -0.10388142f, 0.32787091f, 0.34997651f, 0.01340246f, -0.04312441f, -0.15929663f, 
    0.18092775f, -0.05145155f, 0.18377361f, -0.15037695f, 0.17070988f, 0.59210545f, -0.30655822f, -0.02290913f, 
    -0.03557658f, 0.33258122f, 0.03783093f, -0.00790410f, -0.95840758f, -0.44087166f, -0.32324731f, 0.10916113f, 
    0.07583524f, -0.18764082f, 0.08361817f, 0.11105142f, 0.06592218f, -0.62172055f, -0.41687849f, -0.60810393f, 
    -0.20424484f, 0.20350207f, -0.01284137f, -0.09831922f, -0.06026212f, -0.12069866f, -0.74619436f, -0.28133497f, 
    -0.30092588f, 0.16361491f, 0.23886652f, 0.02004890f, 0.11393716f, -0.02978744f, 0.02456973f, 0.19074211f, 
    -0.05502949f, -0.33098140f, 0.14201801f, 0.32571900f, 0.19874002f, -0.09299359f, -0.14850108f, -0.17743793f, 
    -0.13411276f, 0.01957836f, 0.11510939f, 0.33709276f, -0.33296388f, 0.34451255f, 0.14233600f, -0.10028154f, 
    0.01880336f, -0.00718424f, 0.38348344f, 0.24030522f, 0.11938480f, 0.01681074f, -0.02248794f, 0.09238026f, 
    0.11025762f, 0.19213420f, -0.27747035f, 0.06293420f, -0.30495927f, 0.10906490f, 0.20566896f, -0.05618165f, 
    -0.00978280f, 0.16780643f, 0.13867396f, -0.09737936f, -0.09600671f, -0.24114242f, 0.13234982f, -0.06032896f, 
    0.22281998f, 0.13587429f, -0.16488704f, 0.10890177f, 0.16965552f, 0.19431028f, 0.59054202f, 0.24802324f, 
    0.10709631f, 0.17992206f, 0.19586444f, -0.04970171f, -0.10227382f, -0.01430892f, 0.00625364f, -0.11225661f, 
    0.08745851f, 0.35909161f, 0.01800597f, 0.11653041f, -0.08666576f, 0.14427666f, 0.23760195f, 0.21035996f, 
    0.11772793f, -0.27934301f, -0.15429142f, -0.04866702f, 0.01997226f, -0.04296056f, 0.11507830f, 0.15844078f, 
    0.20380051f, -0.41480902f, 0.10903202f, 0.10939800f, 0.18280551f, 0.01833121f, 0.11578980f, -0.03716704f, 
    0.09244776f, -0.55938411f, 0.40282583f, 0.21934742f, -0.11219557f, -0.00114741f, 0.10579406f, -0.00319295f, 
    0.04243940f, 0.05796506f, -0.38481390f, -0.22801515f, 0.08936847f, -0.02931507f, 0.05980743f, -0.07190062f, 
    -0.12237167f, -0.01498377f, -0.08715552f, 0.20343232f, -0.02188926f, -0.38262993f, 0.13250697f, -0.01115026f, 
    -0.04975812f, 0.03005624f, 0.14870451f, 0.34212723f, -0.11363868f, -0.09666391f, -0.10610228f, -0.11786454f, 
    -0.06977661f, 0.12303481f, 0.18864575f, 0.12444390f, -0.34347466f, -0.04294144f, -0.21049768f, -0.09418555f, 
    0.17712215f, 0.38811776f, 0.23245029f, -0.02071321f, 0.34226191f, -0.26488191f, -0.20824970f, -0.18693528f, 
    0.13158172f, 0.21953785f, -0.08455793f, 0.11563156f, -0.03521233f, -0.08988751f, 0.16788825f, -0.53484982f, 
    -0.08177116f, -0.01579706f, 0.10300806f, 0.18191595f, 0.10010853f, -0.00730329f, 0.05639232f, 0.31505504f, 
    0.41894573f, 0.15677340f, -0.01405981f, 0.03907412f, -0.15959899f, -0.05979956f, 0.23750052f, 0.17513981f, 
    -0.28786820f, -0.05352723f, -0.03350946f, 0.07978794f, 0.01235924f, 0.06197891f, 0.05682732f, -0.28144410f, 
    -0.09303257f, -0.18241380f, -0.06014601f, -0.05331198f, 0.03149178f, -0.02478611f, -0.11741079f, 0.04308358f, 
    -0.08219377f, 0.06931229f, -0.34034798f, -0.50539345f, 0.19393027f, -0.00840265f, 0.02634421f, -0.09909394f, 
    -0.04814017f, 0.14213912f, -0.02991527f, 0.56912887f, 0.15833934f, 0.15556456f, -0.07711714f, 0.01874208f, 
    -0.00704050f, 0.08758282f, 0.12817346f, 0.04124874f, 0.21374738f, -0.29312706f, 0.15212627f, 0.05941439f, 
    -0.08359855f, 0.05749701f, 0.03362435f, -0.09094240f, 0.02163218f, 0.11144596f, 0.21433358f, 0.04049681f, 
    0.11639859f, 0.33266151f, -0.14244869f, 0.05884358f, -0.01403532f, 0.00215246f, -0.21003513f, -0.04229126f, 
    0.33821911f, 0.01082337f, 0.21045277f, -0.01117196f, -0.04726670f, -0.16317719f, -0.06571801f, 0.13768503f, 
    0.30721399f, -0.54842967f, 0.06185468f, -0.01108597f, -0.05519848f, 0.07528613f, -0.12826854f, 0.25103906f, 
    -0.06645005f, 0.13442186f, -0.16105594f, 0.09435210f, -0.17685203f, -0.07209193f, 0.09448352f, 0.05944049f, 
    -0.04805241f, 0.09516339f, 0.11430876f, -0.35438934f, -0.02236926f, 0.10761034f, 0.22550949f, 0.03075124f, 
    -0.03538434f, 0.23224169f, 0.10207651f, -0.11838363f, -0.16863801f, 0.08729347f, -0.09623466f, 0.11557526f, 
    0.11845944f, -0.04027170f, -0.13556413f, 0.43518192f, -0.10979056f, -0.21819232f, -0.14816040f, 0.07085150f, 
    0.11698637f, 0.19474363f, -0.14268184f, 0.09125622f, 0.23713335f, 0.01578446f, -0.37002087f, 0.31359088f, 
    -0.05478166f, -0.10750636f, 0.23583783f, -0.02943764f, 0.04139389f, -0.33842966f, -0.75981134f, 0.05021615f, 
    0.08997410f, 0.11240409f, 0.00401843f, 0.19585657f, -0.10040536f, 0.00393628f, 0.31583682f, 0.44043311f, 
    0.34291378f, 0.03489758f, 0.27139485f, 0.01395062f, 0.49787259f, 0.05950933f, 0.11186907f, -0.02657996f, 
    0.00648429f, 0.09838204f, 0.38910094f, 0.13256289f, -0.06022901f, -0.12519193f, 0.34629351f, 0.40440908f, 
    0.00317270f, 0.09893177f, 0.03266597f, -0.17398055f, -0.43100649f, 0.14580959f, -0.00402858f, -0.10105968f, 
    -0.05449978f, -0.33347344f, -0.06991646f, -0.01519347f, -0.02806181f, -0.10332823f, -0.00324982f, 0.03245712f, 
    0.03100198f, 0.15072998f, -0.25662601f, 0.13151966f, -0.25586852f, 0.03697077f, -0.31699902f, -0.17619829f, 
    -0.03618863f, 0.07782266f, -0.10291792f, 0.28909481f, 0.61928046f, 0.13891284f, -0.09937190f, -0.13942632f, 
    -0.35750824f, -0.24036083f, -0.16815941f, 0.05102760f, 0.15250866f, -0.13715327f, -0.19833806f, -0.05648948f, 
    -0.07370138f, 0.10278187f, 0.07517253f, -0.14365634f, 0.14695232f, -0.27593008f, -0.15896611f, -0.11656654f, 
    0.11474143f, 0.18657511f, -0.26254195f, 0.04711834f, 0.10643683f, 0.07092440f, 0.18435530f, -0.42453992f, 
    0.16300972f, -0.19196768f, -0.01595935f, 0.03312555f, -0.04422941f, -0.13493387f, -0.01379748f, -0.22799967f, 
    0.04383909f, 0.05735643f, 0.27464077f, 0.26431718f, 0.03778339f, -0.17217872f, -0.08020849f, 0.04186520f, 
    0.04813655f, -0.27622324f, -0.28976414f, -0.14096747f, 0.11800090f, -0.18826431f, -0.19070831f, 0.03081748f, 
    -0.16660786f, 0.13249773f, 0.20324053f, 0.18175666f, 0.11539116f, 0.01628534f, 0.04773271f, 0.36703360f, 
    -0.04272952f, 0.07749221f, -0.65102243f, -0.00703451f, -0.27761042f, 0.00723369f, -0.16064462f, -0.21691453f, 
    -0.17758559f, 0.11471849f, 0.19563238f, -0.30145037f, 0.30558994f, 0.20807338f, 0.01919366f, 0.09199660f, 
    -0.06462749f, -0.03589202f, 0.30168369f, 0.02685799f, -0.01889978f, -0.23711781f, -0.14571868f, -0.22318605f, 
    -0.17811255f, -0.17533913f, 0.09021438f, -0.01479076f, 0.16183510f, 0.61719024f, -0.04176306f, -0.22068246f, 
    -0.06513897f, -0.04275150f, 0.15180455f, -0.32092038f, -0.05208046f, 0.01815977f, -0.41817504f, 0.24609073f, 
    0.68104893f, 0.39435774f, 0.06060317f, 0.15954976f, -0.10864272f, -0.02599715f, -0.05425880f, 0.21384348f, 
    0.04980211f, 0.00221788f, -0.02628067f, 0.08471557f, -0.01118363f, 0.13019218f, 0.00230222f, 0.04834892f, 
    0.74843556f, 0.31893337f, 0.32298753f, 0.10520569f, 0.01656797f, 0.01055373f, -0.24087954f, 0.08145770f, 
    0.06562737f, -0.46450537f, -0.40734446f, -0.23019929f, 0.14502282f, -0.07527272f, -0.10225017f, -0.04594152f, 
    -0.02912426f, 0.03731902f, -0.01954192f, 0.19632731f, 0.30178306f, -0.00748011f, 0.04413317f, -0.08668702f, 
    -0.12978742f, 0.15401368f, 0.14183512f, -0.66917551f, -0.12295073f, 0.56651288f, 0.30279800f, 0.05588686f, 
    -0.16826212f, -0.13740842f, 0.02068670f, 0.09594672f, 0.06258933f, 0.53298295f, 0.31064597f, 0.06620332f, 
    0.10137615f, -0.09796230f, -0.15776031f, -0.06065493f, 0.12633072f, 0.25380397f, -0.08381461f, 0.16631803f, 
    -0.02400798f, 0.15343797f, -0.07413327f, -0.07797190f, -0.04295903f, 0.00522703f, -0.19603619f, -0.09418032f, 
    -0.44772330f, -0.12532708f, -0.12753090f, -0.15890916f, 0.09313347f, -0.01404091f, -0.20471591f, -0.06865796f, 
    -0.52287793f, 0.03949038f, -0.01410400f, -0.04091291f, -0.04799329f, -0.14575687f, 0.23124644f, 0.03298325f, 
    -0.36802188f, 0.17498481f, 0.07287543f, -0.20313658f, -0.14880012f, 0.07266554f, -0.01908403f, 0.21992786f, 
    0.36261034f, -1.20726860f, -0.24165463f, -0.11028019f, -0.20693246f, -0.06357694f, 0.04153786f, -0.12946330f, 
    0.18200792f, -0.14901724f, 0.83619362f, -0.17073448f, 0.01764526f, -0.09158334f, -0.01526774f, 0.15444063f, 
    -0.02939221f, 0.16935304f, -0.13496700f, -0.85176420f, -0.94374633f, 0.28731272f, -0.02553266f, 0.07662790f, 
    0.03011625f, 0.06252331f, -0.20815277f, 0.14114633f, -0.53137696f, -0.04438883f, -0.64203668f, -0.06513254f, 
    -0.08585211f, -0.01903234f, 0.00700913f, 0.20857988f, 0.26494771f, -0.27046323f, -0.33161372f, -0.11384575f, 
    0.06694325f, 0.43416151f, -0.01897901f, -0.03408268f, -0.01204215f, 0.33000797f, 0.01535335f, 0.38717675f, 
    0.01401354f, -0.05394249f, -0.19362019f, 0.12387588f, -0.36832345f, 0.14812116f, -0.02768556f, 0.31116042f, 
    0.20597850f, -0.24184966f, -0.03599702f, 0.04184929f, -0.05189192f, 0.08493248f, 0.31528524f, 0.10987584f, 
    0.10684321f, 0.23589309f, -0.07345347f, 0.06384189f, -0.18588898f, 0.02452402f, -0.00863221f, 0.13691498f, 
    0.10526603f, 0.74578089f, -0.10955323f, 0.33211192f, 0.44656557f, 0.00116878f, 0.16205107f, -0.29064554f, 
    -0.10125644f, -0.02762749f, -0.13777366f, -0.20975621f, -0.02715092f, 0.03645471f, 0.06708255f, 0.02299323f, 
    0.03133707f, 0.00507854f, -0.45846096f, 0.14982726f, 0.39765903f, 0.17302984f, 0.10434704f, -0.10465408f, 
    0.05526121f, 0.00633928f, 0.14628556f, -0.18843709f, -1.12184882f, -1.07162929f, -0.12425359f, 0.18730716f, 
    -0.01990025f, 0.18312809f, -0.06527445f, -0.03365398f, -0.05013506f, 0.35887882f, -0.15316442f, -0.03633438f, 
    0.31035399f, -0.12369168f, -0.21232164f, 0.09881759f, 0.11398739f, -0.00813462f, 0.32771417f, -0.06758263f, 
    0.08825975f, 0.06135886f, 0.01425104f, 0.37931859f, 0.16321191f, 0.17428342f, -0.02560816f, 0.06524453f, 
    0.08814470f, 0.03490093f, 0.10508014f, 0.08017126f, -0.17762481f, 0.01353712f, 0.15027463f, 0.08071260f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.19923778f, 0.02560711f, 0.27287865f, 0.18359484f, -0.05885189f, 0.00505321f, 0.30280170f, 0.06010164f, 
    0.03603328f, -0.22322401f, 0.06694157f, 0.38380280f, 0.03439863f, -0.14994408f, 0.00019630f, 0.04858797f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.57296801f, 0.18235014f, -0.76621276f, -0.20528318f, -0.09787899f, 0.17943756f, -0.57898062f, -0.24678189f, 
    -0.04040318f, -0.45291448f, -0.24797848f, 0.32331964f, 1.03278613f, -0.09412318f, -0.30061984f, -0.14301427f, 
    0.83353513f, 0.01513335f, 0.22187974f, 0.28288379f, -0.50232047f, -0.23304617f, -0.04818107f, 0.09163797f, 
    -0.18432739f, -0.15262908f, -0.70893365f, -0.05411353f, 0.02069371f, -0.07364253f, 0.35832664f, -0.30138168f, 
    0.13528182f, 0.22236115f, -0.22163953f, 1.17621565f, 0.25120929f, 0.19409490f, 0.11965504f, -0.10288311f, 
    -0.05081946f, -0.08859425f, 0.02393952f, -0.53548890f, 0.10918235f, -0.67747045f, 0.08236638f, -0.90188098f, 
    -0.57781583f, 0.16877204f, -0.33704653f, -0.17108375f, 0.51774991f, 0.21740673f, -0.48530135f, 0.05895770f, 
    0.13275002f, 0.53921801f, 0.20619574f, -0.16609937f, -0.11201155f, -0.15527746f, -1.11085367f, 0.84189743f, 
    -0.44590181f, -0.02375978f, -0.52565694f, -0.36942136f, 0.47531268f, -0.17946325f, 0.00289775f, -0.19382688f, 
    -0.03167622f, -0.43631694f, 0.08806353f, 0.68460536f, -0.10088702f, -0.05396030f, 0.19363649f, -0.31847697f, 
    0.08446610f, 0.18072608f, 0.55989027f, -0.48742256f, -0.53386718f, 0.13573506f, -0.50537479f, -0.10988779f, 
    0.10561959f, 0.04939105f, -0.80458844f, 0.53925586f, 0.02409668f, 0.37219200f, -0.17685154f, -0.11949599f, 
    0.17589553f, 0.18254519f, 0.06142780f, -0.52595741f, 0.09244002f, 0.24508427f, 0.41852480f, -0.25972509f, 
    0.08979367f, 0.54391998f, -0.49943101f, 0.63621730f, -0.66262013f, -0.42359060f, -0.26014969f, -0.25988773f, 
    -0.28135380f, -0.07254492f, 0.03915981f, -0.29546997f, 0.25013351f, -0.26088864f, -0.98150361f, -0.13838127f, 
    0.15758917f, -0.18508081f, -0.27386910f, -0.39558068f, 0.16357973f, 0.57998109f, 0.76602447f, -0.01239534f, 
    -0.61442000f, -0.14036463f, 0.32759109f, 0.29109395f, -0.96958870f, -0.12633513f, -0.04254758f, 0.08995788f, 
    0.13948859f, 0.35473281f, 1.00664985f, -0.41477078f, -0.27327725f, -0.03566121f, 0.31872922f, -0.07435349f, 
    0.03074356f, 0.07017807f, 0.20303819f, -0.63080478f, -0.07813581f, 0.00815731f, 0.27654037f, -0.08267904f, 
    -0.14014131f, -1.06398571f, 0.72194678f, 0.21005504f, -0.34924424f, 0.15798900f, 0.46958855f, -0.31784552f, 
    -0.84346396f, -0.20955847f, 0.22817808f, 0.65373671f, -0.34509408f, 0.18720816f, 0.40601009f, 0.18785900f, 
    -0.04066981f, -0.46433088f, -0.06209160f, -0.67690480f, 0.05784267f, -0.00276580f, -0.72815371f, 0.68346304f, 
    -0.13176297f, 0.08260398f, -0.45417398f, -0.13430470f, 0.17294668f, 0.06369115f, 0.33926275f, 0.19821709f, 
    -0.17252767f, 0.94721305f, -0.25949165f, -0.35646784f, -0.26705283f, 0.64510041f, -1.09424627f, -0.21675792f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07519040f, 0.34752187f, 0.12109084f, -0.00636817f, 0.30075893f, 0.37261936f, -0.28343743f, -0.69606417f, 
    -0.49272314f, 0.11935114f, 0.45826882f, -0.05052854f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
