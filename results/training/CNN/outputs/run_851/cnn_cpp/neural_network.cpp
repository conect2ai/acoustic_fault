#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.51381707f, -0.89800423f, -0.78589648f, -0.36821845f, 0.38626713f, -0.71634007f, 0.56126904f, 0.26274440f, 
    -0.32261306f, 0.23506391f, 0.19033556f, -0.13751706f, 0.28471258f, -0.10805392f, 0.00582177f, -0.30699944f, 
    0.13926221f, 0.10588650f, -0.25284955f, -0.28572395f, 0.01486610f, 0.12763809f, 0.00741864f, 0.21741463f, 
    -0.20077780f, 0.84447616f, -0.13489912f, 0.28749177f, 0.26189661f, 0.21174547f, 0.28513125f, -0.34403849f, 
    -0.23768637f, -0.54088074f, -0.30771723f, -0.30532050f, -0.22493842f, -0.17572726f, 0.07832263f, 0.25130600f, 
    -0.19629997f, 0.00480028f, -0.18557833f, -0.12848508f, -0.11575834f, 0.27689570f, -0.08682375f, 0.43863961f, 
    0.27205962f, 0.13457263f, 0.59468842f, 0.32306078f, 0.75174397f, 0.68245065f, 0.74371564f, 0.67502660f, 
    0.36482590f, -0.59512579f, -0.36580098f, 0.00733940f, 0.15150830f, -0.01907272f, -0.05163668f, 0.00002260f, 
    -0.35552716f, -0.06776755f, 0.12488671f, 0.24602994f, -0.02266482f, 0.12506273f, 0.23023868f, 0.08748161f, 
    0.00688172f, -0.11738918f, 0.16115133f, -0.50065416f, 0.57413673f, 0.79447085f, 0.00500762f, 0.00232401f, 
    0.65119612f, -0.23718032f, -0.56368107f, 0.44076270f, -0.09984971f, -0.44805309f, -0.25265983f, 0.03593278f, 
    -0.06420588f, -0.18434785f, -0.26374036f, -0.07045621f, 0.21590710f, -0.27565256f, -0.06575808f, 0.22607051f, 
    0.19041337f, -0.19949089f, 0.35693604f, 0.32788777f, 0.61074567f, 0.59205908f, 0.03802373f, 0.71232742f, 
    0.50782764f, 0.01761055f, 0.32350859f, 0.20016722f, 0.28412575f, 0.45802623f, -0.37661502f, -0.22696611f, 
    0.08218751f, -0.34793323f, -0.21170972f, -0.28343558f, -0.38033316f, -0.15830690f, -0.40314215f, -0.12659675f, 
    0.08426970f, -0.35322016f, 0.21890937f, -0.22154634f, -0.21501765f, -0.98523051f, 0.29907581f, 0.28318024f, 
    -0.78637636f, -0.25427318f, 0.58662784f, 0.32771981f, -0.17949584f, 0.59531951f, 0.63016248f, 0.17427468f, 
    -0.05369306f, -0.09201074f, -0.14757322f, -0.37621498f, 0.08290959f, -0.04935049f, -0.20925739f, 0.00407652f, 
    0.03068711f, -0.29351521f, -0.15308957f, 0.02961530f, 0.03253580f, -0.04409989f, 1.05075002f, 0.84629661f, 
    -0.78198951f, -0.12831047f, -0.53807950f, 0.31573421f, 0.10922977f, -0.55181110f, -0.06276590f, -0.08456705f, 
    0.16483594f, 0.30915636f, 0.10099575f, 0.13713525f, -0.32400781f, 0.11605905f, -0.11314383f, -0.01647962f, 
    0.07689056f, -0.25452250f, -0.27389532f, 0.12315508f, 0.19776219f, -0.13800935f, 0.28202736f, -0.60761720f, 
    -1.19610262f, 0.19150758f, 0.75113904f, 0.26140681f, -0.13556884f, 0.65399224f, 0.92566931f, -0.08574356f, 
    -0.21656170f, 0.10962320f, -0.15784109f, -0.31259263f, 0.03268549f, -0.03428072f, -0.12646239f, 0.17792045f, 
    0.02707436f, -0.04156191f, -0.00487628f, -0.03997604f, 0.10138893f, -0.14981817f, 0.00629672f, -0.04981085f, 
    0.70805889f, 0.68689072f, -0.31872070f, -0.11209685f, -0.11862367f, -0.21249151f, -0.45365614f, -0.61025065f, 
    -0.55346048f, 0.54567158f, -0.02174494f, 0.38299301f, 0.45962843f, 0.09344616f, -0.09579957f, -0.33362323f, 
    -0.12522636f, 0.21035139f, 0.05509720f, 0.17724743f, 0.37271059f, -0.13746276f, 0.09054929f, 0.11131765f, 
    -0.28044012f, -0.57338023f, 0.14284234f, -0.06716511f, -0.49788073f, 0.20378858f, -0.12834804f, -0.11765335f, 
    -0.54362619f, -0.83498549f, 0.02278520f, -0.28704253f, -0.04116444f, 0.47337198f, 0.05197855f, 0.04381676f, 
    0.36220127f, -0.38651642f, -0.31177402f, 0.09059358f, 0.26076025f, 0.19504061f, -0.03224114f, 0.13758688f, 
    0.06517362f, -0.28874958f, 0.75963271f, 0.28840134f, -0.62233543f, 0.24525455f, -0.57205451f, 0.36211240f, 
    0.54388207f, 0.49449190f, 0.67473304f, 0.47857001f, 0.03361493f, 0.30217072f, -0.23188706f, -0.45222080f, 
    -0.25374570f, -0.09981998f, -0.08030330f, -0.40628120f, 0.09347919f, -0.01178267f, -0.27599159f, -0.24032904f, 
    -0.29041919f, -0.07077868f, -0.28645021f, 0.52929175f, 0.43752936f, 0.01061798f, 0.11361384f, -0.12426297f, 
    -0.46065173f, 0.58811778f, -0.08445013f, 0.20855276f, 0.42881474f, -0.46591893f, 0.41423780f, 0.09794462f, 
    0.03781815f, -0.20102948f, 0.48866972f, -0.21380216f, -0.20238484f, 0.12252428f, -0.31904840f, -0.06901693f, 
    -0.33472452f, -0.30431661f, -0.16110504f, 0.18555042f, -0.06184303f, -0.37548065f, 0.32187706f, -0.61180747f, 
    -0.17998505f, -0.41137874f, -0.51711375f, 0.72229081f, 0.01135019f, -0.72110957f, -0.36231798f, -0.38107985f, 
    0.07015410f, -0.60697585f, -0.05254241f, 0.46750483f, 0.15925965f, -0.34844500f, -0.26694825f, -0.31850445f, 
    0.04565487f, -0.06492047f, 0.22528119f, 0.04689202f, -0.14314570f, 0.44485533f, 0.12576945f, 0.15770073f, 
    0.80826902f, 0.78166354f, -0.05097562f, -0.11572743f, -0.04454536f, 0.21742146f, 0.10315563f, -0.08659606f, 
    0.16737875f, -0.01147418f, -0.00077220f, 0.19325383f, -0.31917676f, 0.28343892f, -0.07804956f, -0.13313943f, 
    -0.09636915f, -0.15575595f, 0.31219405f, 0.14044628f, -0.30824897f, 0.25246462f, -0.28453997f, -0.62801206f, 
    -0.74203932f, -0.57337123f, -0.32843339f, -0.24361034f, 0.72182304f, 0.58984149f, 0.02349249f, 0.45585176f, 
    -0.03308593f, -0.31193256f, 0.16391093f, -0.18242911f, 0.03294824f, -0.13935456f, -0.22658320f, -0.21736144f, 
    -0.10686588f, -0.21327098f, -0.14210416f, 0.12733749f, 0.07021866f, -0.07374768f, -0.00012299f, -0.00608588f, 
    -0.53578830f, -0.72886461f, -0.21900502f, -0.32009581f, 0.54892433f, -0.53867400f, -0.19682376f, -0.25486109f, 
    0.22940087f, 0.09251059f, -0.04611299f, -0.30117881f, -0.37416521f, -0.11831506f, -0.28713191f, 0.03269741f, 
    0.30878577f, -0.22845325f, 0.30166754f, 0.30930027f, -0.09063119f, 0.18693921f, 0.40639049f, 0.15288556f, 
    0.63282359f, -0.65285075f, -0.68152899f, 0.53857845f, 0.87130743f, -0.26930162f, -0.30907899f, 0.02161728f, 
    -0.13897152f, 0.04452723f, -0.14925888f, 0.04534140f, -0.35749319f, -0.24134161f, -0.02098686f, 0.05358420f, 
    -0.13441707f, 0.34584638f, 0.27766815f, 0.03557694f, -0.03009285f, -0.16000122f, -0.04721455f, -0.00615416f, 
    -0.15077028f, -0.42017740f, -0.65726703f, -0.62855405f, -0.65111816f, 0.06716744f, -0.25837278f, 0.52751243f, 
    0.32962143f, 0.07393584f, 0.08472446f, -0.25588816f, 0.10781028f, -0.00724098f, -0.21223174f, 0.01644368f, 
    0.16121991f, 0.13185704f, 0.12490039f, 0.42119926f, 0.08219033f, -0.24042954f, 0.24877818f, -0.39639309f, 
    -0.35999912f, 0.34685117f, -0.41808230f, -0.34201419f, 0.01776601f, -0.57581222f, -0.58522373f, -0.31903189f, 
    -0.66087323f, -0.37677240f, 0.45311949f, -0.11902381f, 0.38382435f, 0.06818898f, 0.03180992f, 0.19057114f, 
    -0.01914185f, 0.33919385f, 0.04271163f, 0.10912952f, 0.15032738f, -0.07035618f, -0.05514759f, -0.25188398f, 
    0.14701444f, -0.31265572f, 0.44921726f, -1.28862202f, 1.00208843f, -0.12992783f, -0.44288093f, -0.75314695f, 
    0.24111167f, 0.29311422f, -0.21783955f, 0.62110829f, -0.30809060f, -0.53389090f, -0.12834044f, 0.16889422f, 
    0.04162623f, -0.02979678f, 0.03840544f, -0.12707716f, -0.01706295f, -0.05089815f, -0.31398526f, 0.24885456f, 
    -0.00515504f, 0.22411576f, 0.10997236f, 0.40338257f, -0.55944139f, -0.22515132f, 0.07843320f, -0.12276916f, 
    -0.34417611f, -0.49506456f, 0.17167862f, -0.31980634f, -0.39494237f, -0.03452142f, -0.20090047f, 0.58487129f, 
    0.15581478f, 0.19339177f, -0.16609256f, 0.29661223f, 0.03439638f, 0.27383277f, 0.33555341f, 0.37668097f, 
    -0.27297670f, 0.13019302f, -0.06698553f, -0.24821259f, -0.08824019f, 0.01015196f, 0.53918743f, -0.77804470f, 
    -0.86430049f, -0.46813801f, 0.64715976f, 0.14873685f, 0.42608157f, 0.62130404f, 0.06346472f, -0.55450785f, 
    -0.10556740f, -0.50602692f, -0.27005157f, -0.40471563f, 0.07953687f, -0.05795912f, -0.14255589f, -0.13166848f, 
    0.27029356f, 0.13564906f, -0.20873937f, -0.13203850f, -0.26074305f, 0.27369776f, -0.25116524f, -1.37715018f, 
    0.84349924f, 0.35052109f, -0.34477848f, 0.60239327f, 0.34009445f, 0.35639364f, -0.37351525f, 0.21265112f, 
    -0.06725658f, -0.10649473f, 0.02515853f, 0.25142980f, -0.09727908f, -0.07737429f, -0.12920830f, -0.14355001f, 
    -0.17353469f, -0.20226762f, -0.20864573f, 0.14870150f, 0.23228574f, 0.01201617f, 0.03371797f, -0.61161530f, 
    0.08631179f, 0.56290489f, 0.74755371f, 0.33965155f, 0.41380319f, 0.43692094f, 0.40622100f, 0.26437664f, 
    0.40589789f, -0.58391523f, -0.34824625f, -0.38987404f, -0.17684782f, 0.09659775f, -0.21895231f, -0.06783663f, 
    -0.27498153f, -0.15541787f, -0.00404210f, -0.08063156f, 0.25864908f, 0.16466285f, -0.03618339f, -0.38120610f, 
    -0.54359871f, -0.15496551f, 0.50697023f, 0.78501058f, 0.27952218f, -0.23437966f, 0.17653067f, 0.11914819f, 
    0.52424234f, 0.18951790f, -0.09230465f, -0.32185903f, 0.39191511f, -0.01205697f, -0.29033315f, -0.23007187f, 
    -0.26276544f, -0.42935961f, 0.31936389f, 0.31109342f, 0.12820478f, 0.10116435f, 0.28578365f, 0.06286711f, 
    -0.16614074f, 0.82928383f, -0.47679675f, 0.32241452f, 0.91211814f, -0.45564076f, 0.32323530f, -0.65249693f, 
    0.16480383f, -0.30420205f, 0.43810382f, -0.07944639f, -0.09364115f, 0.19165915f, 0.22429666f, -0.04965854f, 
    0.02965682f, 0.01193838f, 0.28504163f, -0.11477873f, -0.08632580f, 0.01653248f, -0.06383761f, -0.20439969f, 
    -0.04225649f, -0.33929163f, 0.39517352f, 0.34202936f, 0.56487715f, 0.64890325f, 0.34942305f, -0.63935238f, 
    0.29496199f, 0.15719663f, 0.01719867f, 0.16686960f, 0.07959456f, 0.07499373f, -0.14788713f, -0.30070457f, 
    0.02834541f, -0.21990967f, 0.01287762f, 0.20104519f, -0.09270439f, 0.23478422f, 0.23395653f, 0.37848708f, 
    0.41539472f, 0.33678532f, 0.28219178f, 0.42963678f, 0.57859993f, 0.71433085f, -0.31947187f, 0.14390957f, 
    0.28668621f, 0.26956680f, 0.43746054f, 0.08931094f, -0.24988385f, 0.04168959f, -0.14737034f, 0.17804208f, 
    -0.08203045f, 0.26124704f, 0.32624835f, -0.02529379f, -0.43393525f, 0.05591499f, -0.33806431f, -0.11968833f, 
    0.19834243f, 0.34266973f, -0.37875444f, 0.24275173f, 0.78704274f, -0.63338310f, -0.99750245f, 0.42383885f, 
    -0.26913947f, -0.95138299f, 0.42194891f, 0.35065672f, 0.07539897f, -0.09593286f, 0.14219712f, -0.06666030f, 
    0.40081587f, -0.00646083f, 0.18890560f, -0.11828309f, -0.25802910f, -0.50811553f, -0.12459689f, -0.35156345f, 
    0.17678434f, 0.01435061f, 0.19261423f, 0.31944397f, 0.06078317f, 0.93626648f, 0.38471091f, -0.03814261f, 
    0.63741255f, -0.21621990f, -0.34190288f, -0.26197237f, 0.56591165f, 0.25883657f, 0.11076168f, -0.18970481f, 
    -0.01062151f, 0.19099218f, -0.33772367f, -0.29152888f, 0.42946184f, -0.07012035f, -0.40556380f, 0.06045519f, 
    0.49782464f, 0.10427502f, -0.22837454f, 0.35088867f, -0.25813898f, -0.06650869f, -0.66840577f, -0.17028564f, 
    -0.67981732f, -0.64289463f, -0.13337900f, -0.33297125f, -0.19298679f, 0.33412266f, 0.37982121f, -0.04669221f, 
    0.17597985f, 0.36511141f, 0.11438860f, 0.00485265f, 0.25394553f, 0.14825185f, -0.00946780f, 0.07904825f, 
    -0.08892559f, 0.09731781f, 0.17320673f, -0.46087354f, 0.26369584f, 0.02311775f, -0.41466087f, -0.45292845f, 
    0.59778965f, 0.32200173f, 0.50691396f, -0.17948310f, -0.46296558f, -0.42862549f, -0.72837269f, -0.48020470f, 
    -0.45394319f, 0.41962591f, -0.20021471f, -0.02537052f, 0.14401361f, -0.19395491f, -0.27116489f, -0.04201755f, 
    -0.26288056f, 0.15107398f, -0.02381811f, -0.11442280f, 0.12030835f, 0.29083517f, -0.29096127f, -0.20191243f, 
    0.19856867f, 0.55977190f, 0.72868752f, 0.42217010f, -0.51461303f, -0.00350002f, -0.43097737f, 0.07341807f, 
    0.18726011f, 0.66615385f, -0.08285259f, 0.22706386f, -0.26566637f, 0.01754824f, -0.04058543f, 0.05380591f, 
    0.05720796f, 0.00286061f, 0.32544386f, 0.28292388f, 0.05889517f, -0.41734275f, 0.05261707f, -0.30082408f, 
    0.20764491f, -0.41451705f, 0.68010348f, 0.60458219f, 0.12907726f, 0.11043899f, -0.11163449f, 0.34192854f, 
    -0.34841612f, 0.43010095f, -0.32896948f, -0.29420131f, 0.07780056f, -0.38387802f, -0.00576018f, 0.00630119f, 
    -0.09979428f, 0.12395874f, -0.16620708f, -0.34113830f, 0.34090686f, 0.20762989f, 0.36558622f, -0.19706525f, 
    0.32737571f, -0.02166552f, 0.21677330f, 0.61412954f, 0.48477989f, 0.36153784f, -0.31931299f, -0.19583535f, 
    0.80974579f, -0.10208449f, -0.43718520f, 0.73348671f, 0.00296796f, 0.34764746f, 0.15770765f, 0.26562008f, 
    0.46579185f, -0.22706833f, -0.65819937f, -0.18201798f, -0.01820428f, -0.35661793f, 0.13711654f, 0.14800449f, 
    0.31623250f, 0.29769406f, 0.04020991f, -0.10068538f, 0.41370034f, -0.72142726f, -0.67784935f, 0.30993181f, 
    0.20905882f, -0.21372962f, 0.42468128f, 0.54664123f, -0.06364152f, -0.03066577f, -0.42441764f, 0.14531060f, 
    -0.06442164f, -0.27041721f, 0.56166160f, -0.24857253f, -0.04418825f, 0.09124996f, -0.05968089f, 0.20772846f, 
    -0.19361688f, 0.47998419f, 0.11910283f, -0.07816810f, 0.59331197f, -0.26070571f, -0.35161218f, 0.58866829f, 
    0.14176448f, 0.17735249f, -0.13807639f, -0.35384586f, 0.32109407f, -0.00557925f, -0.40900606f, -0.00217433f, 
    0.18713251f, -0.18093979f, 0.05744233f, -0.19900185f, 0.27759409f, -0.44018596f, -0.18267731f, 0.20355558f, 
    0.14169480f, 0.04313546f, -0.10970816f, -0.58520722f, -0.09767734f, 0.88453931f, -0.03875756f, 0.60253537f, 
    -0.20696947f, -0.51079500f, 0.34786129f, -0.71601683f, 0.41326863f, 0.56435090f, 0.36595419f, 0.32564303f, 
    -0.26720819f, -0.24414594f, 0.01511652f, 0.09051771f, 0.18462518f, 0.14902368f, -0.15883674f, -0.06978795f, 
    0.15170045f, 0.45500231f, 0.33374551f, -0.06142907f, 0.23988679f, 0.17700671f, 0.66139060f, 0.57372445f, 
    0.59077579f, -0.48673403f, -0.69375503f, 0.51499003f, -0.08185804f, -0.58552396f, -0.63229895f, -0.29321313f, 
    0.15363578f, 0.03775483f, -0.27423462f, 0.18313292f, -0.48154163f, 0.20744546f, 0.30577946f, 0.09395837f, 
    -0.02139067f, -0.42089355f, -0.21723559f, -0.07238351f, -0.09710389f, -0.06829086f, 0.27176166f, 0.55632639f, 
    0.21112601f, 0.33431050f, 0.81706095f, -0.04484863f, 0.20252307f, 0.47492579f, 0.21223541f, 0.24189238f, 
    0.31234723f, -0.19049111f, 0.09933905f, 0.31012532f, -0.22319639f, -0.18017346f, 0.15098228f, -0.10518249f, 
    0.32952723f, 0.15101956f, 0.19158055f, -0.24075514f, -0.20784229f, -0.13230453f, 0.07818148f, -0.16944164f, 
    0.95958310f, 0.15363193f, 0.10914677f, -0.22709756f, 0.63451797f, 0.08004706f, -0.08845809f, 0.39958328f, 
    0.17466645f, 0.19881694f, -0.35589069f, -0.46523151f, 0.03525861f, 0.32807955f, -0.00416453f, 0.15476833f, 
    0.10008129f, 0.03507934f, -0.34139180f, -0.03295156f, 0.13908188f, 0.17677656f, 0.52399784f, 0.16277656f, 
    -0.19326653f, 0.59794253f, 0.56270540f, 0.03146739f, 0.15176624f, 0.81657630f, 0.13553286f, 0.13474141f, 
    0.75197750f, 0.69424540f, -0.15040973f, -0.42209718f, 0.12734622f, -0.03367138f, -0.25636539f, -0.07954041f, 
    -0.09371004f, 0.23133835f, -0.15821001f, -0.03747011f, -0.38870239f, 0.02736879f, -0.12155491f, -0.19201122f, 
    0.04618076f, -0.27101198f, 0.98851275f, 0.71805906f, 0.32394364f, 0.76351213f, 0.14802365f, -0.45946613f, 
    0.02103833f, -0.45308685f, 0.31775349f, -0.05313300f, 0.06539255f, 0.04546951f, -0.02550155f, 0.16848339f, 
    0.08714607f, 0.19160043f, 0.12654345f, 0.15013020f, 0.04528600f, 0.06169326f, -0.05413116f, 0.03117272f, 
    -0.15432231f, 0.06224056f, 0.10526998f, -0.65717036f, 0.12096934f, -0.12707229f, -0.53179592f, -0.48177615f, 
    0.20559527f, 0.80510581f, 0.30353269f, -0.27660900f, 0.50601226f, 0.08628925f, -0.16493517f, -0.29319978f, 
    -0.47294021f, -0.01926428f, -0.08013603f, -0.16083920f, 0.12062462f, 0.13822940f, 0.14080754f, -0.21968538f, 
    0.05823273f, 0.21204723f, -0.36172995f, 0.20556670f, 0.28426871f, 0.81451809f, 0.68361950f, 0.17077251f, 
    0.16567035f, -0.96702880f, 0.26612368f, -0.20833862f, -0.56669933f, -0.26460236f, 0.27735409f, -0.04806564f, 
    -0.42259640f, 0.21169984f, -0.22464986f, -0.05630383f, -0.16757588f, 0.38269973f, -0.21420012f, -0.23166497f, 
    -0.27219927f, 0.00069586f, 0.23060307f, -0.00301198f, -0.00987659f, 0.77597970f, 0.41175723f, 0.56183845f, 
    0.51042956f, 0.91510004f, 0.37711170f, 0.19041418f, -0.11789916f, -0.49928144f, -0.25997147f, -0.02850888f, 
    0.14901382f, 0.23793313f, 0.13510244f, 0.11609771f, -0.02030038f, 0.14137706f, 0.17754044f, 0.19394003f, 
    0.25786996f, -0.11048302f, -0.07216955f, 0.13377234f, 0.24002789f, 0.05785960f, -0.54457074f, -0.30833980f, 
    -0.09354752f, 0.46847031f, -0.23345551f, -0.68973893f, -0.42413300f, -0.38084087f, -0.16472648f, 0.12152736f, 
    -0.49157992f, 0.40908080f, -0.25924778f, 0.32568815f, -0.45728850f, 0.46006429f, 0.13437594f, 0.07047497f, 
    -0.22236557f, -0.42920035f, -0.02988977f, -0.08572023f, -0.11560635f, 0.02681562f, -0.23149391f, 1.03185749f, 
    0.57857943f, 0.68988472f, -0.68900013f, -0.91414589f, -0.40026432f, -0.03511425f, -0.11446635f, 0.02839610f, 
    0.13672571f, 0.17886953f, 0.38127518f, -0.38848007f, -0.17211910f, 0.09029267f, 0.06510345f, -0.17901230f, 
    -0.19675359f, 0.01464130f, -0.11962207f, -0.02932896f, 0.13147773f, -0.12541977f, 0.07555929f, -0.23360258f, 
    -0.94142491f, -0.47100627f, -0.44954729f, 0.03567781f, -0.30111697f, 0.61104959f, 0.83470684f, -0.67933828f, 
    0.41460297f, 0.22694138f, -0.28615335f, 0.14959884f, 0.19298054f, -0.26781270f, 0.38856015f, -0.23615538f, 
    -0.00383282f, -0.03244846f, -0.26570767f, -0.19116203f, 0.21172506f, -0.06188239f, 0.00362209f, 0.32840011f, 
    0.17948224f, 0.90982211f, -0.75895232f, 0.33372286f, 0.05391615f, 0.52917957f, -0.63329375f, 0.56454521f, 
    -0.20387889f, -0.04833088f, -0.24829555f, -0.16206211f, -0.18426824f, -0.07931186f, 0.30611452f, 0.19476485f, 
    -0.31982514f, -0.01660619f, -0.25084126f, 0.25739205f, -0.02690126f, -0.30352890f, -0.20626289f, -0.14202534f, 
    -0.04112839f, 0.07318085f, 0.70608574f, 0.63537806f, -0.89407420f, 1.07655489f, -0.04086851f, 0.63894469f, 
    0.09644029f, 0.03267130f, 0.11432438f, -0.52541602f, -0.10316679f, -0.29573920f, -0.03502353f, -0.24944794f, 
    0.07089682f, -0.16316618f, -0.11200899f, -0.04145721f, -0.03852486f, 0.02050556f, 0.30039853f, -0.03707244f, 
    -0.15472744f, -0.19506156f, -0.20196126f, -0.31697273f, 0.10497638f, -0.23855171f, 0.43243268f, -0.34879208f, 
    0.50343871f, -0.25912505f, 0.32552046f, -0.43233991f, 0.06434364f, 0.20857495f, -0.27908269f, 0.13662548f, 
    -0.06424164f, 0.40614372f, -0.18041176f, 0.01171587f, 0.09365712f, 0.33052257f, 0.22152628f, -0.05636908f, 
    0.71484780f, -0.09832278f, 0.54353517f, -0.59035659f, 0.68299156f, 0.31765354f, 0.06241816f, -0.30009690f, 
    0.19508682f, 0.00090672f, -0.53046960f, 0.11320531f, 0.06770257f, 0.20066428f, 0.31899297f, -0.11586479f, 
    -0.06075636f, 0.22638157f, 0.32150185f, 0.57155156f, 0.02312612f, -0.30376136f, -0.20034671f, 0.30098242f, 
    0.10110666f, 0.31487027f, -0.30006778f, -0.40344691f, 0.25891721f, -0.13079463f, -0.50821215f, 0.82977754f, 
    0.36963904f, -0.30828959f, -0.92900956f, 0.07241856f, -0.19147198f, -0.11653346f, -0.41456461f, 0.22379933f, 
    0.00012908f, 0.13515295f, 0.01090162f, -0.11634663f, -0.33787167f, 0.24851274f, 0.23996769f, -0.01993466f, 
    0.18522042f, -0.25135916f, -0.28079215f, -0.22922920f, -0.28669456f, 0.01427318f, -0.02529216f, -0.41747546f, 
    0.17391221f, 0.34560835f, 0.52967489f, -0.91487199f, -0.02185460f, 0.34819999f, -0.65115988f, 0.41994646f, 
    -0.04217844f, -0.03656004f, 0.15942264f, 0.10817789f, 0.30788994f, 0.20501517f, 0.35333776f, 0.39197466f, 
    -0.14821070f, -0.19022599f, 0.01945655f, -0.47442120f, -0.09734488f, 0.17597526f, 0.18937029f, 0.14028287f, 
    -0.91913611f, -0.48911914f, -0.37326616f, -0.08985277f, 0.41762948f, 0.04473689f, -0.01230211f, 0.31135371f, 
    0.47207406f, 0.07183018f, -0.15220919f, -0.09437319f, 0.27570790f, 0.02886034f, -0.06497051f, 0.34914073f, 
    0.14742844f, 0.37781256f, 0.40932587f, 0.13946074f, -0.35325629f, -0.29907987f, -0.29098168f, 0.15204474f, 
    -0.46236339f, -0.48861602f, -0.25116679f, -0.12535493f, -0.35373151f, 0.37647060f, 0.42133877f, 0.05796668f, 
    0.08683465f, -0.05157392f, 0.38244009f, 0.46561587f, -0.44315341f, -0.15618558f, 0.23638585f, 0.25307223f, 
    0.28457588f, 0.18387277f, 0.02195180f, 0.02801057f, -0.21181472f, 0.16754073f, 0.40616253f, 0.33469945f, 
    0.03337380f, 0.30867994f, 0.68997973f, 0.69560522f, 0.53307283f, 0.56581348f, 0.36299598f, -0.66868222f, 
    -0.70663673f, 0.15012816f, -0.39374933f, 0.41991609f, 0.10982981f, -0.34580961f, 0.00052483f, -0.16437969f, 
    0.37697321f, -0.24479161f, -0.10503236f, 0.04375127f, 0.00560309f, 0.20389932f, -0.15732679f, 0.37707779f, 
    0.06429907f, 0.18077524f, -0.65575117f, -0.67892271f, 0.32340130f, 0.94868779f, -0.35625201f, -0.43860924f, 
    0.49820849f, 0.60316163f, -0.35208648f, -0.49046791f, 0.07331483f, 0.27298123f, 0.47886842f, 0.05353140f, 
    0.33068267f, -0.18264303f, 0.24101855f, 0.14149641f, 0.16104056f, -0.23322441f, 0.07235303f, 0.12017535f, 
    -0.28565818f, 0.14254583f, 0.00674761f, -0.62054670f, -0.78580666f, -0.50376832f, -0.44482586f, -0.27813953f, 
    -0.66560489f, 0.05970037f, 0.44038409f, -0.13182601f, 0.28830013f, -0.01222011f, -0.01266782f, 0.13523220f, 
    -0.10898135f, -0.04699478f, 0.08188217f, 0.08235028f, 0.03143200f, -0.09892882f, -0.04459596f, 0.33485264f, 
    0.21038347f, 0.03794084f, 0.23161665f, 0.13049196f, 0.02263384f, 0.18778770f, 0.58133215f, -0.45799780f, 
    0.22093065f, -0.80779046f, -0.52834558f, -0.72706109f, -0.53859568f, -0.63252974f, 0.32063964f, 0.39549226f, 
    0.01184019f, -0.15483074f, 0.23283808f, -0.29909161f, -0.11264070f, -0.25994903f, 0.02549514f, 0.10653017f, 
    0.24911135f, 0.03234087f, -0.15585831f, 0.28197640f, 0.26916671f, -0.72737980f, 0.40353408f, 0.24123822f, 
    -0.59503883f, -0.24976130f, -0.52600867f, 0.52326894f, -0.16627842f, -0.51295781f, -0.06597367f, 0.21999942f, 
    0.46195358f, 0.14392284f, 0.24677372f, -0.05728488f, -0.07227188f, -0.13231632f, 0.15190598f, -0.27213132f, 
    -0.40439308f, 0.06200755f, 0.21868546f, 0.10616344f, 0.11112929f, 0.10425017f, -1.21988082f, 0.85724384f, 
    0.83627230f, -1.09974015f, 0.33320683f, -0.38101053f, 0.51179236f, 0.14813699f, 0.22058278f, -0.30015668f, 
    0.14044358f, 0.48099631f, -0.29655841f, 0.11087783f, -0.02190643f, -0.05593248f, -0.18795133f, -0.23342581f, 
    0.09753723f, -0.02565861f, 0.35518458f, 0.11528424f, 0.02439321f, 0.10080904f, -0.08789800f, -0.13926259f, 
    -0.88120723f, 0.78364623f, 0.09793269f, -0.30172777f, 0.41110101f, 0.12938321f, 0.08665759f, 0.38012293f, 
    -0.11642100f, -0.03551609f, 0.37063634f, 0.09057052f, 0.41641524f, 0.18283843f, 0.21525876f, -0.22420451f, 
    0.17716309f, -0.23042616f, -0.19708253f, 0.27267370f, 0.34626928f, 0.04420186f, -0.05478632f, 0.35430539f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.33392254f, 0.14918664f, 0.12336820f, 0.12322428f, 0.10097777f, -0.01054071f, 0.21462868f, 0.16291054f, 
    0.23823187f, 0.21025106f, 0.03459931f, -0.13297191f, 0.06645074f, 0.06954277f, 0.13375260f, 0.19112757f, 
    0.11693947f, 0.04691065f, 0.28062892f, 0.16944037f, 0.17424937f, 0.12134667f, 0.12794551f, 0.01148407f, 
    0.06023618f, 0.15587863f, 0.30399075f, 0.09670956f, 0.13392793f, 0.03184654f, 0.18452899f, 0.08205232f, 
    0.13927723f, 0.17028588f, 0.23313914f, 0.08393813f, 0.16469015f, 0.03565428f, 0.07566835f, 0.10410174f, 
    0.25578928f, -0.01589389f, 0.18241245f, -0.07955787f, 0.14298040f, 0.12028705f, -0.01945824f, 0.17003581f, 
    0.12380623f, 0.02594280f, 0.07043362f, 0.07575051f, 0.14149906f, 0.21054564f, 0.16203985f, 0.20107827f, 
    -0.09345467f, 0.08283948f, 0.31397927f, 0.21328837f, 0.00290266f, 0.07917305f, 0.08800115f, 0.14900059f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.31183740f, 0.07958295f, -0.05782893f, -0.04057522f, 0.08183841f, 0.00535617f, -0.12897716f, 0.00244452f, 
    -0.06735712f, 0.01088502f, -0.01563307f, 0.01164167f, 0.23122634f, -0.07015229f, -0.01519908f, 0.11891496f, 
    0.01469335f, -0.08342016f, 0.05533284f, -0.03076224f, -0.19294870f, -0.03588441f, -0.07117322f, -0.05451567f, 
    0.01553868f, -0.04234174f, 0.08123685f, 0.11063185f, -0.25147396f, -0.08655392f, 0.09126154f, 0.05164864f, 
    -0.01069312f, 0.07249002f, -0.11257555f, 0.01815193f, -0.03869386f, 0.08967990f, 0.08099458f, 0.13185728f, 
    -0.03618753f, -0.07463608f, 0.10714682f, -0.13440272f, -0.06625973f, 0.04923423f, -0.06142375f, 0.15447594f, 
    0.06032273f, 0.01441743f, -0.04154578f, 0.22106609f, -0.17344759f, 0.04829636f, -0.00106522f, 0.00309006f, 
    -0.04545011f, 0.03592465f, 0.01640752f, -0.04885198f, 0.39648291f, -0.02474111f, 0.03074267f, -0.12345580f, 
    -0.06110388f, 0.05256839f, 0.00839037f, 0.02627413f, 0.04604807f, 0.00705644f, 0.02044016f, -0.04883644f, 
    -0.07580953f, -0.07554346f, 0.13634075f, -0.15678361f, -0.11104716f, 0.09071334f, -0.10917415f, 0.11288469f, 
    -0.04637023f, -0.02981473f, -0.05506019f, -0.00637513f, -0.27458456f, 0.12882686f, -0.05555845f, 0.12787536f, 
    -0.01590799f, 0.05377942f, 0.04528759f, 0.04828699f, 0.01639958f, -0.20280351f, 0.00443237f, 0.03703669f, 
    0.04060642f, -0.01991601f, 0.14994216f, -0.19288653f, -0.07011621f, -0.09709460f, 0.06581287f, -0.02717898f, 
    -0.04615176f, -0.01263093f, -0.04815768f, 0.01561629f, -0.30104864f, -0.15077673f, 0.02501208f, -0.16571239f, 
    -0.00323278f, 0.03224751f, -0.05319825f, -0.00993552f, 0.08657258f, -0.03071140f, 0.03596895f, 0.03595655f, 
    -0.01901201f, 0.06299850f, -0.17503469f, 0.02515340f, 0.06875503f, -0.00348010f, 0.01054998f, -0.01308989f, 
    -0.10007153f, 0.05700896f, -0.06742774f, 0.08331294f, -0.06204256f, -0.07939274f, 0.00367567f, -0.08472373f, 
    -0.02481185f, 0.06533738f, 0.03758714f, 0.09759738f, 0.04235657f, 0.08511920f, 0.01761441f, -0.09863093f, 
    -0.28369701f, 0.05900677f, -0.02964298f, -0.00268418f, -0.03267249f, -0.03522341f, -0.06337253f, -0.09941319f, 
    0.03864419f, 0.11243832f, 0.00128257f, -0.15819785f, 0.10902255f, -0.04028366f, -0.04704390f, 0.20249054f, 
    -0.18833561f, -0.02716433f, -0.04396589f, -0.02266806f, -0.15375184f, 0.06326781f, 0.08430693f, -0.07397145f, 
    -0.07613965f, 0.20521086f, -0.04746263f, -0.32109302f, -0.05883427f, -0.08137748f, 0.02795570f, -0.00689121f, 
    -0.01493851f, -0.00978029f, 0.00671705f, 0.12130335f, 0.10289930f, -0.31164548f, -0.06081024f, -0.17286217f, 
    -0.00510249f, 0.01548917f, 0.01666045f, 0.13961805f, -0.23715536f, 0.02899270f, -0.03795998f, -0.05492132f, 
    0.10705690f, -0.15589365f, 0.05463642f, 0.29465210f, -0.11251702f, 0.06694173f, -0.02806542f, 0.01557050f, 
    -0.04069030f, -0.10248930f, 0.04272404f, -0.01105505f, -0.07616166f, 0.06965712f, 0.00569480f, -0.45005432f, 
    0.01961565f, -0.02581046f, 0.16538161f, 0.01001634f, -0.02157932f, -0.05850623f, -0.03536283f, 0.03328354f, 
    -0.20066373f, -0.11545012f, -0.18242875f, -0.00719025f, -0.12684143f, 0.01486885f, -0.07887429f, -0.02503019f, 
    0.13533880f, -0.01842501f, -0.08141346f, -0.07172045f, 0.60408795f, 0.20898110f, -0.10695090f, -0.17514290f, 
    0.03983686f, 0.04851933f, -0.03514992f, -0.10121984f, 0.03884053f, -0.04874059f, -0.02226149f, 0.00654114f, 
    -0.26205271f, -0.08826714f, 0.02980933f, -0.01885879f, -0.00487847f, 0.00037959f, -0.07624058f, 0.06404461f, 
    0.04310121f, -0.04295884f, -0.02859183f, -0.11260629f, 0.21233150f, 0.08499027f, -0.05701748f, -0.25593656f, 
    0.11570837f, 0.01196352f, 0.05392617f, -0.00390008f, -0.01450232f, 0.03989576f, -0.03603214f, 0.03347202f, 
    -0.20363641f, 0.12825733f, 0.07696979f, 0.11873788f, -0.02025613f, 0.07924935f, -0.00223906f, -0.06661315f, 
    -0.05321323f, 0.02350915f, 0.01858451f, -0.09094684f, -0.07840722f, 0.07545720f, 0.08138914f, 0.23309432f, 
    -0.10480148f, 0.07331101f, 0.00784989f, -0.06524929f, -0.10577476f, -0.12516682f, 0.02398294f, 0.05776709f, 
    0.02376209f, 0.05277444f, -0.26928189f, 0.27428085f, -0.03905046f, 0.07467959f, -0.03418585f, 0.04886541f, 
    0.00547079f, -0.03629516f, -0.06522818f, 0.05228708f, 0.12940560f, -0.11890952f, -0.20897827f, 0.34580490f, 
    -0.05922383f, 0.03610257f, 0.03541784f, -0.01025629f, -0.04566395f, 0.04006641f, -0.13237302f, -0.00593061f, 
    0.13080135f, 0.02979065f, -0.11534607f, 0.13940093f, -0.10781946f, -0.09374849f, -0.13964313f, -0.05515084f, 
    -0.01381720f, -0.07365964f, -0.01124743f, 0.05524084f, -0.11605084f, -0.04007376f, -0.00053196f, -0.06208698f, 
    -0.25364539f, -0.10816763f, 0.01881213f, 0.02531789f, 0.02650094f, -0.12504476f, 0.07574873f, -0.00356388f, 
    -0.26652741f, -0.07385420f, 0.04519794f, 0.14423022f, 0.01176608f, -0.09708189f, 0.04137985f, -0.13423596f, 
    -0.02819271f, 0.07906917f, 0.18101326f, 0.06903300f, 0.13077548f, -0.02713805f, -0.15370136f, 0.17663062f, 
    -0.00577207f, 0.03695379f, -0.11981034f, 0.07204502f, 0.01209530f, -0.03636854f, 0.04225942f, -0.07049716f, 
    0.01455144f, 0.08909968f, -0.10977232f, -0.03370756f, -0.06743994f, -0.02418520f, -0.05544690f, 0.02002193f, 
    -0.05244483f, -0.06470108f, -0.08725996f, -0.13056991f, -0.05081555f, 0.13937996f, -0.11378931f, 0.03066218f, 
    0.14240023f, 0.00042929f, -0.02400359f, 0.06883170f, -0.00346105f, -0.01908515f, -0.05956283f, 0.02597013f, 
    -0.00623864f, 0.13113162f, -0.20780684f, 0.20439023f, 0.06605378f, -0.21819958f, 0.05523127f, -0.05580710f, 
    0.05405965f, -0.07031381f, 0.01736649f, -0.02321274f, -0.10142072f, 0.06594841f, 0.12806770f, -0.02827523f, 
    0.00907123f, 0.02700852f, -0.00292296f, -0.08046051f, -0.08772376f, 0.03086542f, -0.14883684f, -0.00403461f, 
    -0.06238456f, 0.04877917f, -0.01562305f, -0.04653067f, -0.16783182f, -0.00470941f, -0.03227984f, -0.16209413f, 
    -0.08554234f, 0.08155470f, 0.05208395f, 0.01547866f, 0.13265635f, 0.11461230f, 0.07732627f, -0.27847394f, 
    -0.07948475f, 0.01230300f, 0.07049394f, -0.08409205f, -0.07644702f, 0.05043897f, 0.07702562f, -0.02441652f, 
    0.02102313f, -0.12889186f, -0.05194670f, 0.07806101f, 0.01477727f, 0.12149311f, -0.09080980f, -0.00849118f, 
    -0.03165227f, 0.00268421f, -0.04870803f, 0.06843124f, 0.18464613f, -0.22318575f, -0.09068167f, 0.06125250f, 
    0.03639289f, -0.01264820f, -0.02199251f, -0.10678685f, 0.01789581f, 0.07184381f, -0.00948656f, 0.09080015f, 
    -0.25777751f, 0.22983925f, 0.03866541f, -0.18155196f, -0.10592169f, -0.04351628f, 0.09158236f, 0.01028787f, 
    -0.12227391f, 0.12111172f, -0.03647173f, 0.00520259f, 0.08930974f, 0.10234624f, -0.14816172f, 0.18839557f, 
    -0.06513581f, 0.11581974f, -0.00959301f, 0.02095922f, 0.09162499f, -0.00239329f, 0.02287626f, 0.00553267f, 
    0.18250108f, 0.02223237f, 0.06894985f, -0.11058537f, -0.06699496f, 0.06443977f, -0.07341257f, 0.02036945f, 
    -0.13652563f, 0.03454415f, 0.03530100f, -0.14880092f, 0.05039306f, 0.18167441f, 0.09560144f, -0.01684475f, 
    -0.08406653f, 0.14155148f, 0.09015352f, -0.00950395f, -0.02688670f, 0.05596285f, 0.02069016f, -0.06005216f, 
    0.06486283f, 0.02381236f, -0.12240566f, 0.10192498f, -0.15081327f, -0.10160936f, -0.03696843f, 0.09643794f, 
    0.01384335f, 0.00521668f, -0.04196426f, 0.01714160f, 0.22758640f, 0.09645920f, 0.27570602f, -0.22905153f, 
    0.17953226f, -0.04306081f, 0.06048832f, -0.02916506f, 0.01961805f, 0.01981730f, 0.11479921f, 0.04537762f, 
    0.11182240f, 0.05981930f, -0.05526084f, -0.03855376f, -0.16052619f, -0.06925062f, -0.07287153f, -0.00299296f, 
    -0.04460115f, -0.02588959f, 0.02763495f, -0.13425815f, 0.19004436f, -0.06396596f, -0.05266934f, -0.03366996f, 
    -0.17648633f, -0.02585044f, -0.03465549f, 0.09671038f, 0.03407549f, -0.04295984f, -0.03353025f, 0.01811625f, 
    -0.14533737f, -0.20742027f, -0.12283602f, 0.22910607f, 0.01751933f, 0.08861151f, -0.02546234f, 0.04305438f, 
    0.01626432f, 0.05246722f, -0.11610393f, -0.05702491f, -0.15019639f, 0.15159583f, 0.01020904f, -0.18509637f, 
    0.05794442f, -0.04855429f, -0.14687870f, -0.01795658f, 0.01917085f, 0.01200568f, 0.00517593f, -0.04540056f, 
    0.36117578f, 0.09480317f, 0.11399246f, -0.11534536f, 0.02405948f, -0.00288175f, -0.03417652f, 0.04062090f, 
    0.00855733f, -0.03747971f, 0.03491724f, 0.01272574f, 0.28110328f, -0.03677754f, -0.04819175f, -0.02018650f, 
    -0.19285558f, -0.04663184f, 0.03082008f, -0.02320258f, -0.01264954f, -0.03577157f, -0.11506182f, -0.11819107f, 
    0.11951506f, -0.03102255f, -0.05796782f, 0.10394027f, -0.18416397f, 0.11317793f, 0.00758939f, 0.07133249f, 
    -0.03253137f, 0.06414221f, -0.06278148f, 0.06275544f, -0.09078244f, -0.01810308f, -0.05005161f, -0.03685268f, 
    -0.03122200f, 0.11798879f, 0.04517032f, -0.15688293f, -0.02704212f, -0.03142405f, -0.01452368f, 0.00154886f, 
    0.09120513f, -0.04558491f, 0.04127115f, -0.23988502f, 0.02454725f, 0.04978880f, 0.05590227f, 0.10309962f, 
    0.15591900f, 0.03552339f, 0.05692728f, 0.01804089f, 0.20566599f, -0.06130156f, -0.21232282f, 0.17667939f, 
    -0.01998859f, -0.11359734f, 0.13150094f, -0.14161748f, 0.03109068f, 0.01702539f, -0.10236587f, -0.00446954f, 
    -0.10585580f, -0.14088152f, -0.22913249f, 0.11498559f, -0.03127669f, -0.06025921f, 0.00837642f, -0.05733265f, 
    -0.05102264f, 0.04108134f, -0.02136472f, 0.06736112f, 0.09278411f, -0.14815412f, -0.03882149f, -0.19820057f, 
    0.09475259f, -0.08705755f, -0.02455316f, 0.01409509f, 0.00232285f, -0.03041411f, -0.00972754f, 0.07717201f, 
    -0.01285008f, 0.07058159f, 0.07953768f, -0.14791879f, 0.09857074f, 0.09241056f, 0.02587572f, 0.08795651f, 
    0.10423271f, 0.05425863f, 0.06629940f, -0.06020059f, 0.01874510f, 0.06577829f, 0.04621933f, -0.02786239f, 
    -0.14195821f, -0.12018543f, -0.03718121f, 0.04120585f, 0.07692472f, -0.11072149f, 0.05954120f, -0.06781384f, 
    -0.08873126f, 0.19642141f, -0.15730108f, 0.20807356f, -0.03592339f, 0.01763866f, 0.07535706f, -0.06011636f, 
    0.07623744f, -0.00999971f, -0.00340806f, 0.01257617f, -0.29476714f, -0.03679532f, -0.21997671f, -0.08497017f, 
    -0.03727183f, 0.02789215f, -0.00780759f, 0.06449293f, 0.03626919f, -0.07352643f, -0.02993288f, 0.03045131f, 
    -0.11440327f, 0.09336197f, 0.14750263f, -0.02475950f, -0.03831172f, -0.01576727f, 0.03347218f, -0.05490641f, 
    -0.01038920f, -0.09983533f, -0.01725768f, 0.02637416f, -0.25250247f, -0.12689236f, 0.10930455f, 0.05729124f, 
    0.05540003f, 0.01070192f, -0.01029279f, -0.00530730f, -0.01268338f, 0.04051444f, 0.00207861f, 0.08148973f, 
    -0.24238667f, -0.02659254f, 0.21969688f, -0.07566299f, 0.03583963f, 0.03258361f, -0.01967421f, -0.00115271f, 
    -0.00544912f, -0.14733505f, 0.03389790f, 0.02386246f, -0.07110380f, 0.03105576f, 0.03316186f, 0.13126490f, 
    -0.00069673f, 0.10698637f, 0.04894543f, -0.01399398f, 0.05421023f, 0.16129555f, -0.03009688f, -0.05631619f, 
    0.39786527f, -0.08877935f, -0.05573519f, -0.06938346f, -0.03095153f, -0.00493905f, 0.06629270f, 0.05602010f, 
    0.05970065f, -0.14622435f, -0.00746321f, -0.07843512f, 0.01982465f, 0.01994758f, 0.06061982f, 0.00289008f, 
    -0.06083295f, 0.02717836f, 0.08917203f, -0.02568963f, 0.04214720f, -0.03458615f, -0.00721964f, 0.03283830f, 
    0.21335830f, -0.10877942f, 0.11869060f, -0.04203534f, -0.15030076f, 0.00210167f, 0.00431903f, -0.00300557f, 
    -0.07157283f, -0.02158567f, 0.04752607f, -0.08838384f, -0.10644427f, 0.01796276f, -0.01114267f, 0.05018080f, 
    -0.14853449f, -0.00068069f, 0.07064587f, 0.02451300f, -0.11141841f, -0.00538662f, 0.15776579f, -0.19440652f, 
    0.30588090f, 0.05627204f, 0.13364084f, 0.17987490f, -0.10875343f, 0.08023988f, 0.02821724f, 0.02476363f, 
    -0.10547818f, 0.00465372f, -0.04503757f, 0.03985643f, -0.55952692f, -0.05787011f, -0.08029020f, -0.07801033f, 
    -0.05598635f, -0.08648366f, 0.01721254f, 0.02839939f, -0.08838514f, 0.02646100f, -0.02743140f, -0.11349858f, 
    0.35355893f, -0.17488174f, 0.03235318f, -0.20311984f, 0.01867974f, -0.17240125f, 0.00904136f, 0.03012724f, 
    -0.15845340f, 0.02124259f, 0.02659600f, 0.03590846f, 0.01485612f, 0.10742289f, -0.14876355f, 0.15663628f, 
    -0.05359020f, 0.03277721f, -0.08529946f, -0.04008998f, -0.04670242f, 0.03327436f, -0.03613002f, 0.04558614f, 
    0.14480558f, -0.14416173f, 0.12929808f, -0.15150611f, 0.01267843f, -0.02861138f, -0.00436624f, 0.01670144f, 
    0.03205926f, 0.06489090f, 0.08752560f, -0.00916271f, 0.09985958f, 0.03938849f, -0.01581978f, -0.10670030f, 
    -0.08016559f, 0.02073553f, 0.03787681f, -0.04928536f, -0.01943038f, 0.01921638f, 0.03913209f, -0.02201697f, 
    0.35019752f, -0.08204897f, 0.11613294f, 0.06850568f, 0.05312066f, -0.11972129f, -0.11009318f, -0.03856721f, 
    -0.08197252f, -0.01762447f, -0.14438403f, -0.01357413f, 0.35759008f, 0.13065821f, 0.01149085f, -0.03697967f, 
    0.10550017f, -0.02193426f, -0.18083563f, -0.00566067f, -0.02900540f, -0.25802085f, -0.07593653f, -0.00144351f, 
    -0.24738628f, -0.00089939f, -0.00422554f, -0.24877173f, -0.01925271f, -0.10505078f, -0.01670976f, 0.00019617f, 
    0.04016262f, -0.08942124f, -0.16729529f, 0.08454223f, 0.12525925f, 0.00954153f, 0.06323309f, 0.23989485f, 
    0.04254506f, 0.01173182f, 0.05180774f, 0.02163252f, 0.03527949f, -0.02316882f, 0.12357206f, -0.06937885f, 
    0.26778024f, -0.02535410f, -0.08955251f, -0.11924136f, 0.03694797f, -0.08022224f, -0.02167265f, -0.01536805f, 
    -0.00260935f, -0.02732631f, -0.05077247f, -0.00883970f, 0.04161632f, -0.02629290f, 0.03410463f, -0.14235151f, 
    -0.02241533f, -0.03439151f, -0.05499959f, -0.06792632f, 0.22542734f, -0.12962285f, 0.01626269f, 0.09941760f, 
    0.11807803f, -0.23809296f, 0.05357415f, -0.02288250f, 0.04280539f, 0.00487713f, -0.14583732f, 0.00554361f, 
    -0.04445801f, 0.03536512f, -0.03608853f, 0.06790081f, 0.17922972f, -0.01028529f, 0.00560543f, -0.09715383f, 
    0.09077917f, 0.03076033f, -0.02980315f, 0.03337470f, -0.00362563f, 0.10245588f, 0.05843441f, -0.02577542f, 
    -0.16789898f, 0.08248661f, -0.00501070f, 0.04101200f, 0.14408650f, 0.06138123f, 0.03714588f, 0.15439571f, 
    -0.13445362f, 0.09316532f, 0.10590466f, 0.05686770f, -0.69550979f, -0.17711516f, -0.00093705f, -0.22833578f, 
    0.04575934f, -0.02616287f, -0.00454312f, 0.14804243f, 0.12222332f, -0.05586492f, 0.00067132f, 0.02706350f, 
    -0.10297872f, 0.01607823f, -0.16274951f, -0.09949278f, -0.01965038f, -0.02030228f, 0.07369354f, -0.06196795f, 
    0.05316453f, 0.11292244f, 0.07882681f, -0.02174301f, -0.25658906f, -0.25022662f, 0.14182119f, -0.17680112f, 
    -0.01899243f, -0.08851428f, -0.01098466f, 0.04313770f, 0.11846281f, -0.01907914f, -0.01702734f, -0.00206135f, 
    -0.10158301f, 0.10980751f, -0.14053534f, 0.10500313f, -0.06727904f, 0.03357830f, 0.06968167f, -0.04612119f, 
    0.00473795f, -0.12583593f, 0.02099799f, 0.04177775f, 0.16488707f, 0.06364115f, -0.02016241f, 0.09010249f, 
    -0.00143368f, 0.06647019f, -0.01806908f, -0.04508830f, 0.03557158f, 0.11290038f, 0.06152514f, -0.08329649f, 
    -0.05876841f, 0.05149671f, -0.11426868f, 0.10071599f, 0.04144033f, 0.02859212f, -0.02439300f, -0.12114767f, 
    -0.01229951f, -0.00589211f, -0.03079707f, -0.02456341f, -0.01228694f, 0.09964793f, 0.05875150f, 0.09596126f, 
    -0.14363067f, -0.04518938f, 0.04029377f, -0.12065381f, 0.19240850f, -0.03561877f, 0.09593812f, 0.05560930f, 
    0.04213988f, 0.08695555f, 0.07230147f, 0.26201481f, -0.14318410f, 0.05572997f, 0.07397596f, 0.01125733f, 
    0.00960741f, 0.03842994f, 0.03149259f, 0.02304161f, 0.01243087f, 0.11857348f, 0.00126293f, -0.02709434f, 
    0.04952585f, -0.07744915f, 0.04558653f, -0.03196280f, 0.03031953f, -0.03082543f, -0.04164167f, 0.02317970f, 
    0.29777297f, -0.43787360f, -0.07329784f, -0.01724867f, -0.07093817f, 0.06230425f, -0.04069792f, 0.09233393f, 
    -0.07441805f, 0.06413054f, -0.25758377f, 0.01304783f, 0.20793885f, -0.06451121f, 0.06871594f, 0.10594414f, 
    -0.06403374f, -0.17242439f, -0.00019284f, 0.00847953f, 0.00106147f, 0.00643757f, -0.15973152f, 0.07137433f, 
    0.13993317f, 0.01481635f, 0.04498419f, -0.17882265f, -0.00385707f, 0.04506235f, 0.08901403f, 0.06195991f, 
    0.02914144f, -0.04864861f, 0.09350172f, 0.05603877f, -0.07566108f, -0.19871847f, -0.21848297f, -0.25125837f, 
    -0.00558914f, -0.00031319f, 0.04593979f, -0.05757773f, -0.03048445f, -0.00913961f, -0.01501467f, 0.00171481f, 
    0.03533312f, 0.02076644f, -0.03366598f, 0.01062395f, -0.03584855f, -0.01307102f, 0.00152923f, -0.01441987f, 
    -0.03603152f, -0.01194517f, 0.02811923f, -0.04042320f, -0.09302798f, 0.04395537f, -0.11222214f, -0.01697870f, 
    -0.09458325f, -0.01348663f, 0.08698691f, -0.04186023f, 0.02581523f, 0.05182780f, 0.14393114f, -0.02776481f, 
    0.07320388f, 0.14301530f, 0.01337129f, 0.08225887f, -0.01937617f, 0.05732024f, 0.08621424f, 0.07250204f, 
    0.08227953f, -0.00835157f, -0.10343756f, 0.02884940f, -0.10063677f, -0.08338476f, 0.08269770f, -0.18529715f, 
    0.01597396f, 0.02856104f, 0.10851825f, 0.03614023f, 0.18971159f, -0.01646535f, -0.08211896f, 0.04491417f, 
    0.05822742f, -0.17939334f, -0.04569352f, -0.01679950f, -0.03008736f, 0.01012827f, -0.09401666f, -0.03439730f, 
    -0.13255633f, 0.07362704f, 0.10787676f, -0.22822365f, 0.01866301f, 0.09679791f, 0.04989709f, -0.05419636f, 
    -0.11145869f, -0.07279243f, -0.11962356f, -0.00314393f, 0.03128171f, 0.03787279f, 0.08074242f, 0.06272507f, 
    0.21715471f, 0.09025937f, -0.03689883f, -0.05397177f, -0.09796838f, 0.03042304f, -0.04459548f, -0.03280756f, 
    0.00103615f, -0.12090553f, 0.01116656f, -0.06310769f, 0.22141211f, 0.05230308f, 0.09177419f, 0.15705395f, 
    -0.01543444f, -0.04276485f, 0.01981392f, -0.00901014f, 0.02388547f, -0.06326143f, 0.02958709f, 0.06816321f, 
    0.20118028f, 0.02437612f, 0.03335699f, 0.00900588f, -0.07152742f, -0.02331698f, 0.00223586f, -0.01449442f, 
    0.01083560f, -0.07242030f, -0.04504758f, 0.17301257f, -0.00598152f, 0.06739720f, -0.05413383f, 0.14584170f, 
    0.01314269f, -0.06898102f, -0.08217805f, 0.03703071f, 0.06272107f, -0.08469370f, -0.09881584f, 0.02317343f, 
    0.29568097f, -0.07636391f, 0.01346165f, 0.10822314f, -0.05212126f, -0.05555595f, -0.02040966f, 0.01723376f, 
    0.01607623f, 0.03068443f, -0.05466311f, 0.01822081f, -0.02834187f, 0.02816638f, -0.17262468f, -0.15059201f, 
    -0.14038740f, -0.04224509f, -0.02211213f, -0.11308691f, 0.07581436f, -0.03797922f, -0.09140715f, -0.02349940f, 
    0.03056444f, 0.17279859f, -0.06914324f, 0.04042335f, 0.00021011f, 0.06148104f, 0.11060701f, 0.07496638f, 
    0.01505833f, -0.10888595f, -0.03737853f, 0.19933946f, 0.13049236f, 0.13386488f, 0.09890792f, 0.07635503f, 
    -0.04149340f, 0.04055106f, -0.02680368f, 0.01823792f, 0.03455458f, 0.00565209f, -0.02674446f, -0.01483964f, 
    -0.20099223f, -0.01887272f, -0.05894933f, -0.05259145f, -0.12739360f, -0.03973702f, -0.16061045f, 0.07466730f, 
    0.00568282f, -0.20585525f, -0.04192966f, -0.03193565f, 0.12107655f, -0.02044789f, -0.17974928f, -0.09066152f, 
    0.02293925f, -0.13751909f, 0.06406929f, -0.02050038f, -0.11918508f, -0.01069014f, -0.05515098f, -0.04067022f, 
    -0.12091624f, 0.01210934f, -0.12741570f, -0.09138707f, 0.08846845f, -0.07318511f, -0.02810532f, 0.07919574f, 
    0.01764624f, 0.02005080f, 0.02029613f, 0.12371241f, 0.22598986f, -0.23823053f, 0.05236243f, 0.07498743f, 
    0.03064048f, -0.04033435f, -0.11860860f, -0.09374043f, 0.08495104f, 0.06068705f, -0.14149733f, -0.02205714f, 
    -0.10808848f, -0.35640249f, 0.02224218f, 0.10700569f, 0.01898253f, -0.04017285f, -0.09340785f, 0.11063770f, 
    -0.00398850f, 0.07358568f, -0.09661544f, 0.03863752f, 0.02324998f, 0.21114081f, -0.12190603f, 0.20189093f, 
    0.15435845f, -0.12463805f, -0.06247399f, -0.14702728f, 0.07300365f, 0.00768532f, 0.05575083f, 0.12446295f, 
    0.07138129f, -0.02243763f, 0.03259731f, -0.07280146f, -0.01664542f, -0.08710495f, -0.05657197f, -0.04069645f, 
    -0.15211722f, 0.02341467f, -0.02868458f, 0.05039859f, -0.47397086f, -0.02140217f, -0.12917332f, -0.02517728f, 
    -0.02653243f, 0.01807515f, -0.21454880f, -0.11682849f, 0.11005186f, -0.11014664f, -0.00108157f, 0.02252596f, 
    -0.01408647f, 0.07391131f, 0.07522301f, 0.07199450f, -0.04730361f, 0.07964094f, -0.15221885f, 0.07230289f, 
    -0.04461434f, 0.05193118f, 0.09569115f, 0.03978482f, 0.20169912f, -0.12117020f, 0.12094332f, -0.04730747f, 
    0.09566057f, 0.05214195f, -0.09395818f, 0.13383313f, -0.01564686f, 0.07891721f, 0.02269052f, 0.00216986f, 
    0.01895297f, 0.01871600f, -0.28950053f, 0.01428663f, -0.00459336f, -0.02519044f, -0.02634387f, -0.08410684f, 
    -0.02029782f, -0.01633211f, -0.03968081f, 0.07566298f, 0.06887223f, -0.09712034f, 0.17142493f, 0.17866208f, 
    -0.07422514f, 0.01951033f, 0.06127845f, 0.03246564f, -0.09086516f, 0.13812135f, -0.09447370f, 0.08303682f, 
    -0.31937748f, 0.03837387f, -0.10339237f, 0.15872423f, -0.05873217f, 0.03031446f, -0.12946853f, -0.07450302f, 
    -0.01196504f, -0.09187816f, 0.06901501f, 0.02191409f, 0.22861138f, -0.06839820f, -0.00717546f, -0.02082047f, 
    0.10240605f, -0.08998807f, 0.00123866f, 0.03321515f, 0.06829808f, -0.03085698f, -0.03212030f, 0.05708652f, 
    -0.30525061f, -0.13911954f, -0.16166286f, -0.11670814f, 0.09781609f, 0.06518668f, 0.02132636f, 0.11287088f, 
    0.13729838f, 0.15409024f, -0.06771761f, -0.06528831f, -0.23068602f, 0.11665849f, -0.18737797f, -0.17236872f, 
    -0.14715105f, 0.07549243f, 0.08696453f, 0.06342558f, 0.11854235f, -0.09665533f, -0.04170046f, -0.11974054f, 
    -0.39721909f, 0.19049188f, -0.19693507f, -0.22204326f, 0.02849556f, 0.05252647f, 0.00459789f, 0.07695775f, 
    0.02371423f, 0.11767205f, -0.16442087f, -0.11395469f, 0.06116193f, 0.03212216f, -0.08765468f, -0.02760280f, 
    -0.06898163f, 0.06897824f, 0.13083357f, 0.01846020f, -0.01082733f, -0.19206637f, 0.00872682f, 0.01672692f, 
    0.31802711f, -0.19971429f, 0.01032657f, 0.12012097f, -0.09912473f, 0.05581314f, -0.12503995f, -0.02562020f, 
    -0.02818954f, -0.03574674f, -0.07722431f, 0.07935840f, -0.32196009f, -0.04182089f, -0.11651511f, -0.21835683f, 
    0.02519641f, 0.02668719f, -0.08309171f, -0.01365924f, -0.00489471f, -0.04153636f, 0.03808168f, 0.03554565f, 
    0.02231188f, -0.13063841f, 0.10811487f, 0.09215226f, 0.13584313f, 0.04904562f, 0.00353165f, 0.02002598f, 
    0.06182901f, -0.00907951f, -0.04396149f, 0.05172196f, 0.04842148f, -0.02682301f, -0.01267376f, 0.01409853f, 
    -0.06184830f, 0.05715365f, -0.01287142f, -0.03053065f, 0.00419366f, 0.01778561f, -0.10378768f, 0.18203272f, 
    0.08101171f, -0.12163951f, -0.06937653f, -0.10243693f, 0.11479764f, -0.01899085f, 0.05383514f, -0.05558589f, 
    0.00105573f, 0.04946569f, 0.04248143f, 0.00162365f, 0.37848738f, 0.08679418f, 0.11184566f, 0.02792088f, 
    -0.01752405f, -0.02609427f, -0.03963301f, 0.09964956f, -0.04208066f, 0.15224846f, 0.03909866f, -0.04808746f, 
    0.11367913f, -0.10428363f, -0.02150561f, -0.24474162f, 0.04646614f, -0.06717007f, 0.08542283f, -0.07070041f, 
    -0.06674999f, 0.09112864f, 0.04846341f, -0.05328695f, 0.19999756f, -0.12391894f, -0.05457509f, 0.10335614f, 
    -0.05200600f, 0.02194379f, -0.00052131f, 0.01627072f, 0.08184617f, -0.04508169f, 0.01356837f, -0.02754899f, 
    -0.12393725f, 0.01347030f, 0.03712876f, -0.29639754f, -0.01096866f, -0.03643855f, 0.08067871f, -0.00657483f, 
    -0.10343964f, 0.03503806f, -0.06329191f, -0.05747396f, -0.07756985f, 0.01023389f, -0.07884614f, -0.25034097f, 
    0.06725939f, 0.00196241f, 0.00194377f, 0.03421822f, 0.01976657f, 0.09383702f, 0.05647783f, -0.02829626f, 
    0.12984310f, -0.01033078f, 0.04696728f, -0.01925224f, -0.08181015f, -0.05025818f, 0.02951420f, 0.13258481f, 
    0.00617617f, -0.00939177f, 0.12425963f, -0.12394783f, 0.10720534f, 0.10931505f, -0.03686628f, -0.05828545f, 
    -0.12958209f, 0.04018021f, 0.07762044f, 0.04153796f, -0.06001310f, 0.09050889f, 0.03998408f, -0.05572263f, 
    -0.22727847f, -0.05444362f, -0.30451715f, -0.00687106f, 0.01847671f, 0.01213800f, -0.08608606f, 0.01359242f, 
    0.02230667f, -0.02551021f, 0.03612481f, -0.06587921f, 0.06029953f, 0.04843840f, 0.00980973f, 0.04068325f, 
    0.02275043f, 0.05317273f, -0.03894632f, -0.07603797f, 0.04477428f, 0.07963596f, -0.06914081f, -0.06588141f, 
    0.18279289f, 0.09585582f, 0.14173312f, 0.30901745f, -0.23525080f, -0.12666138f, -0.01536893f, 0.09349816f, 
    -0.02258100f, -0.02235305f, -0.01752067f, 0.00252347f, -0.25457209f, -0.17804052f, 0.16489555f, -0.12686336f, 
    -0.06278551f, -0.02338327f, -0.12976682f, -0.01567202f, -0.07949196f, -0.02510484f, 0.09460226f, 0.00717661f, 
    0.08246113f, -0.11673419f, 0.03562421f, -0.03199757f, 0.05776010f, 0.06793729f, 0.03898638f, 0.04825849f, 
    -0.03665772f, -0.04006486f, -0.00924253f, -0.05029457f, 0.12767030f, 0.01756526f, -0.01933970f, 0.16194981f, 
    -0.12289904f, -0.18252139f, 0.05507546f, 0.00325242f, -0.04583362f, -0.08555050f, -0.03261265f, 0.03500627f, 
    -0.31864104f, -0.15048051f, 0.01072485f, -0.05138562f, 0.01052024f, -0.03552241f, -0.07610985f, 0.06373359f, 
    -0.05431132f, 0.06634301f, 0.01740959f, -0.08748383f, 0.06369346f, 0.12816523f, -0.33648431f, 0.02689669f, 
    0.00956982f, 0.03835459f, -0.00523451f, -0.04431763f, -0.07326733f, 0.08686090f, 0.01801546f, -0.00141487f, 
    0.07075683f, 0.06533070f, -0.02275733f, -0.11051182f, -0.08008470f, -0.03415278f, -0.00848141f, 0.00089681f, 
    -0.07866362f, -0.08606815f, -0.10080115f, -0.01809554f, 0.05056660f, 0.16087049f, -0.01437106f, 0.22499099f, 
    -0.06932755f, -0.01475698f, 0.04993271f, 0.04579913f, -0.04686568f, 0.01676998f, 0.05214524f, 0.06677227f, 
    0.09535982f, -0.07388940f, -0.04714708f, -0.05620435f, -0.15045351f, -0.02331700f, -0.07801230f, 0.06395460f, 
    0.06923030f, 0.07593698f, 0.01016258f, -0.11221907f, 0.09091684f, -0.14469095f, -0.07604447f, -0.00522166f, 
    -0.11193989f, 0.07770488f, -0.02966817f, -0.01880594f, 0.01400481f, 0.10948001f, -0.00535785f, -0.06684243f, 
    -0.03563042f, -0.00345093f, -0.11624347f, 0.09977417f, -0.06152584f, 0.00945572f, -0.00355745f, -0.03314075f, 
    0.03321740f, -0.01064913f, 0.13702415f, 0.03861315f, -0.22589256f, 0.00872901f, -0.05727489f, -0.12704498f, 
    -0.12769346f, 0.12224291f, -0.12612402f, 0.07540422f, -0.08547723f, 0.02483815f, -0.02737676f, -0.05666960f, 
    0.11655713f, 0.08066618f, -0.09754609f, 0.08782118f, 0.06006872f, -0.01269930f, -0.10093164f, -0.02658597f, 
    0.01174327f, 0.01397448f, 0.01625910f, 0.02604135f, -0.01290141f, 0.06466470f, -0.04387423f, 0.00868624f, 
    0.00968169f, 0.01882232f, -0.01701315f, 0.04922467f, -0.06295680f, 0.03199136f, 0.01041431f, -0.08394136f, 
    0.37641749f, -0.00444331f, -0.16004261f, 0.02875291f, -0.02647663f, -0.05639638f, -0.01155949f, -0.09558633f, 
    0.00275912f, 0.03272398f, -0.02378219f, -0.10652530f, -0.03621405f, 0.11806673f, -0.06858677f, 0.09089909f, 
    -0.04318612f, 0.07974113f, 0.05918169f, 0.08772019f, -0.02725858f, -0.08597961f, 0.01561516f, -0.06357755f, 
    -0.00199421f, 0.04489543f, 0.04006984f, 0.09075357f, -0.14213216f, 0.01778844f, -0.08374210f, 0.03777263f, 
    0.00654448f, 0.00931330f, -0.05141550f, -0.10823906f, -0.02867758f, 0.17167325f, -0.28606176f, -0.06646528f, 
    0.07132739f, 0.05628823f, -0.07433393f, -0.05288017f, -0.07298234f, 0.00344560f, -0.04878312f, -0.08131737f, 
    -0.01577322f, 0.01604060f, -0.00497100f, -0.05465583f, -0.11869197f, 0.10937531f, 0.02480473f, 0.01969875f, 
    -0.02344475f, -0.10074660f, 0.00447521f, -0.06398924f, 0.13591346f, 0.04904041f, -0.17499129f, 0.01827368f, 
    -0.07254111f, 0.05042828f, 0.01484078f, -0.10947160f, -0.02957736f, 0.01416511f, 0.03404889f, 0.00203968f, 
    0.10118869f, 0.02921787f, -0.03644860f, -0.11447304f, -0.09911983f, 0.04360915f, 0.00943262f, -0.05570726f, 
    -0.00501159f, 0.00620965f, 0.03861362f, -0.13185388f, -0.07709017f, 0.08370196f, -0.05563486f, 0.13976799f, 
    -0.11789642f, 0.01657571f, 0.02910972f, 0.02747888f, -0.01707956f, 0.04699418f, -0.01555970f, 0.01698597f, 
    -0.10796215f, -0.17812312f, -0.02692685f, -0.09892530f, 0.02216587f, -0.06685404f, -0.00319368f, -0.03228150f, 
    0.08218583f, 0.00800618f, -0.05115674f, 0.04154691f, -0.27230883f, 0.17212754f, 0.11396870f, 0.08122551f, 
    -0.01877503f, 0.03163690f, 0.08463892f, -0.00392489f, 0.01425378f, -0.19862333f, 0.06655808f, -0.02520483f, 
    -0.37269580f, -0.20903322f, 0.00113878f, -0.20446010f, 0.06959233f, 0.03225385f, 0.08403930f, -0.00133074f, 
    -0.07280738f, 0.05576630f, -0.02386431f, -0.08936266f, 0.08223100f, -0.00659556f, -0.01136533f, -0.07817069f, 
    -0.01463168f, 0.06639802f, -0.00526751f, 0.07422992f, -0.10447343f, 0.02947898f, -0.03621338f, -0.02454793f, 
    -0.22114794f, 0.06092975f, -0.03010546f, 0.05484615f, 0.13664880f, -0.10025801f, 0.08028062f, -0.08023968f, 
    -0.04841052f, -0.01744911f, -0.03558142f, -0.04472375f, -0.04015206f, 0.07061099f, -0.04953529f, 0.00205601f, 
    0.17280762f, 0.05392722f, 0.10461561f, -0.02922046f, 0.01324460f, -0.02947177f, 0.02922035f, -0.06225589f, 
    0.02432831f, 0.07759115f, -0.01748463f, -0.02386213f, 0.06889995f, -0.01097446f, 0.00253134f, -0.00552310f, 
    -0.02379965f, 0.02867866f, -0.08852467f, -0.10454843f, 0.21903531f, 0.05509309f, 0.10916252f, 0.11905235f, 
    -0.01376551f, -0.12447914f, -0.10875261f, 0.10106753f, -0.01184918f, 0.00613034f, 0.07315364f, -0.06328586f, 
    0.03729636f, 0.09825330f, -0.11435792f, -0.01291649f, 0.14010864f, 0.06523033f, -0.06742897f, -0.07416406f, 
    -0.05941907f, 0.00098770f, -0.04063318f, 0.09259302f, -0.01955105f, -0.06359447f, 0.05749602f, 0.09052636f, 
    0.10871067f, 0.05749074f, 0.01433360f, -0.01719714f, -0.07894725f, -0.00674156f, -0.04157945f, 0.01693864f, 
    0.00780376f, -0.06509759f, -0.17554441f, -0.16747263f, -0.00714298f, -0.00985332f, -0.16359790f, 0.00056050f, 
    -0.04011921f, 0.10834730f, 0.01290550f, -0.03678786f, -0.23718221f, 0.07015068f, 0.11999662f, -0.26522326f, 
    -0.09794879f, -0.00777111f, 0.07025087f, 0.00860377f, 0.07469270f, -0.06339953f, 0.04256262f, -0.05737323f, 
    0.26835629f, -0.06369554f, 0.09340633f, -0.01178558f, -0.02378803f, -0.08998729f, -0.09940279f, 0.10156038f, 
    -0.03644250f, 0.04566992f, -0.05021010f, -0.00247358f, 0.02386943f, 0.10362247f, 0.03726703f, -0.29779309f, 
    0.07078823f, -0.02359035f, -0.02425751f, 0.06347413f, -0.02366493f, 0.00884157f, -0.04381249f, -0.04054971f, 
    0.15657713f, -0.14172956f, -0.02845708f, -0.14695066f, 0.02937028f, -0.03215276f, 0.01585304f, -0.05079512f, 
    0.03535513f, -0.00946315f, 0.03790855f, 0.04773472f, -0.13572434f, 0.12247755f, 0.02858603f, -0.01223893f, 
    -0.12090389f, -0.06799755f, -0.06172739f, 0.04223781f, -0.05709503f, -0.09202908f, -0.02208568f, -0.02497965f, 
    -0.12534678f, 0.02460869f, -0.01589973f, -0.02918742f, 0.04250301f, -0.00148217f, 0.09016830f, -0.04041269f, 
    0.02700472f, -0.01685184f, -0.07849595f, -0.01817189f, 0.20492877f, 0.01980878f, -0.24251440f, 0.00313142f, 
    -0.06037654f, 0.05009637f, 0.06379090f, 0.08178693f, 0.03485746f, 0.06964418f, -0.11549404f, -0.08792820f, 
    0.35969448f, -0.11712259f, -0.13451056f, 0.05191812f, 0.01580570f, -0.00242545f, 0.04717044f, -0.02299062f, 
    -0.12540585f, -0.06307689f, -0.05824558f, -0.05856778f, -0.00800525f, -0.02087771f, 0.08456424f, 0.11471152f, 
    -0.09255805f, -0.02028584f, 0.06931421f, -0.03465386f, -0.05998123f, -0.10768349f, 0.02080642f, -0.06793982f, 
    0.10276174f, -0.12779832f, 0.18209846f, -0.02936435f, -0.15871820f, -0.05383352f, -0.03233008f, 0.05855994f, 
    -0.04865338f, -0.04084001f, 0.07517402f, -0.06419545f, 0.17950736f, -0.03361184f, -0.07876228f, 0.13647877f, 
    0.00002124f, 0.05567013f, 0.03422551f, -0.07471635f, -0.00863634f, 0.00301973f, -0.00791765f, -0.07656197f, 
    0.35340443f, -0.10489446f, -0.10676292f, -0.04460874f, -0.08656311f, 0.02813353f, 0.02168930f, 0.05259926f, 
    0.07317434f, -0.00243308f, -0.10737395f, -0.14388756f, 0.26758114f, -0.18683809f, 0.02415065f, 0.16037832f, 
    -0.17504033f, -0.08684658f, -0.11711338f, 0.00246285f, -0.08575310f, -0.07237198f, 0.02523096f, 0.00639867f, 
    0.06416707f, 0.04594728f, -0.20412651f, -0.22967449f, 0.04898635f, 0.11384942f, 0.02850140f, 0.07717074f, 
    0.07089915f, -0.06712523f, 0.06483731f, -0.17685719f, 0.18001786f, 0.01279345f, -0.23565286f, -0.19649607f, 
    0.12680559f, 0.10631402f, -0.06454258f, -0.07140378f, -0.01746514f, -0.08544258f, 0.02175828f, -0.04865011f, 
    0.35088903f, -0.07100467f, -0.25717962f, -0.07710973f, -0.03434452f, 0.05088874f, 0.07018977f, -0.12924804f, 
    -0.04700650f, -0.03785507f, 0.05216156f, -0.02641919f, 0.10176517f, 0.01978195f, -0.02957230f, -0.05481214f, 
    -0.11299694f, 0.00045334f, -0.01469050f, -0.00282383f, 0.00347480f, -0.04298314f, -0.05281735f, -0.07188338f, 
    0.02476945f, 0.04438974f, -0.00673360f, 0.09824035f, -0.03341147f, -0.08577165f, -0.01347524f, 0.05410901f, 
    -0.05508015f, 0.14022884f, -0.08654758f, 0.05719830f, -0.01735217f, -0.20409232f, 0.06462835f, 0.02075234f, 
    -0.05440396f, 0.13666551f, -0.07456577f, -0.01698462f, 0.02219656f, 0.02858956f, -0.05617832f, 0.00531795f, 
    -0.21444239f, -0.40624529f, 0.04708252f, 0.22138485f, -0.08708793f, -0.05368497f, -0.03737342f, -0.03101875f, 
    0.01615742f, -0.01619925f, -0.01930142f, 0.09098387f, 0.27756402f, -0.09229537f, -0.09204645f, -0.09990810f, 
    0.03779117f, -0.08503411f, 0.00435651f, 0.02846334f, -0.03287071f, -0.00392773f, -0.05317651f, 0.02559306f, 
    -0.07589775f, -0.32416815f, -0.12206922f, -0.08616804f, -0.03241658f, -0.05359305f, 0.02042450f, -0.05600842f, 
    0.10279571f, 0.03510493f, 0.02122859f, 0.05699561f, -0.08512967f, 0.14169396f, 0.07731676f, -0.16685207f, 
    -0.02752338f, -0.01001398f, 0.03737858f, 0.03742494f, 0.11894731f, -0.21434185f, 0.00079617f, -0.00267495f, 
    0.18734790f, -0.20237045f, -0.09732594f, 0.04167628f, -0.12107801f, 0.01195179f, -0.03012110f, 0.09255509f, 
    -0.01673027f, -0.01367198f, -0.07771698f, -0.00911166f, 0.02703177f, -0.00564738f, 0.25654474f, 0.02288364f, 
    -0.02453802f, -0.02996327f, 0.06634790f, -0.06057965f, -0.07313628f, -0.00249765f, -0.03770402f, -0.05289303f, 
    0.12508261f, -0.08099404f, -0.06639895f, 0.09637564f, 0.05613063f, 0.02737703f, -0.06853016f, -0.07365359f, 
    0.00624559f, 0.02751319f, -0.04140231f, 0.01490443f, 0.16615187f, 0.09280806f, 0.09447090f, 0.01631398f, 
    0.02953953f, 0.02801136f, -0.07148807f, 0.02536023f, 0.00094520f, 0.01533822f, -0.02208139f, 0.03108881f, 
    0.06028351f, -0.27524909f, -0.10724448f, 0.01045429f, -0.08100407f, 0.03479669f, -0.03205746f, 0.06158944f, 
    -0.02276180f, 0.04504071f, 0.07423422f, -0.00658171f, 0.05593576f, 0.07459506f, -0.08808076f, 0.09511294f, 
    -0.06254935f, -0.01993275f, 0.08743817f, -0.09950646f, -0.08877880f, 0.07296189f, 0.07531213f, 0.15017505f, 
    0.15590887f, -0.05528309f, 0.11417105f, 0.20795280f, 0.09041278f, -0.02189545f, -0.06466386f, -0.01401035f, 
    -0.05754637f, 0.13340048f, 0.02221707f, 0.04968581f, -0.16523004f, 0.01588216f, -0.05180195f, 0.22023638f, 
    -0.02334998f, 0.14675154f, 0.01078367f, -0.04477708f, 0.10752027f, -0.01882619f, -0.02762164f, 0.06329667f, 
    0.05594190f, -0.10425257f, -0.01161919f, -0.07008877f, -0.05904551f, -0.02325353f, 0.00644268f, -0.05579934f, 
    -0.12039223f, 0.01927990f, -0.00924050f, -0.00546876f, 0.10672166f, 0.06541069f, -0.12138393f, 0.10755489f, 
    -0.08493647f, -0.01112704f, 0.09096655f, 0.01532971f, -0.05284952f, -0.01436019f, 0.03185176f, -0.03981844f, 
    0.17295071f, 0.07584016f, 0.08104731f, 0.05923981f, -0.02817434f, 0.09315936f, 0.08193221f, -0.03691034f, 
    0.01533629f, 0.03164806f, 0.04078187f, -0.01847448f, -0.12977706f, 0.06822074f, -0.07608506f, 0.01393420f, 
    -0.10424609f, -0.17098516f, 0.02583530f, -0.01803273f, -0.01965287f, 0.00899572f, -0.02781338f, 0.03780831f, 
    -0.02842611f, 0.08122808f, -0.03847850f, -0.01919445f, -0.05209587f, -0.01075816f, -0.01716520f, -0.04077400f, 
    0.09673247f, -0.00566660f, 0.00263004f, -0.07794269f, 0.09004667f, 0.19655062f, 0.11410871f, -0.03738337f, 
    0.00589735f, 0.09993979f, 0.03765115f, -0.00691974f, 0.03117814f, 0.03411365f, -0.07619081f, -0.03249018f, 
    -0.17820933f, 0.19406784f, 0.08431702f, 0.07446710f, -0.04720771f, 0.02333016f, -0.08308869f, 0.06102854f, 
    -0.01444667f, -0.07765917f, -0.09470649f, 0.11112216f, -0.19831289f, -0.04329767f, 0.02607057f, -0.04152511f, 
    -0.05967033f, 0.11357332f, 0.03745887f, 0.06045031f, -0.07827309f, 0.02891962f, -0.04419675f, -0.02635565f, 
    0.22695673f, -0.08269910f, 0.02165774f, -0.09458635f, 0.09687650f, -0.00113623f, -0.06971557f, 0.04613695f, 
    -0.04381490f, -0.00631094f, 0.00195485f, 0.00941829f, -0.42151055f, 0.00377205f, -0.05887323f, -0.10204285f, 
    -0.08553158f, -0.13471127f, -0.05217308f, 0.01501085f, 0.04960039f, 0.00031455f, 0.12633631f, -0.06351043f, 
    -0.27231753f, 0.15516599f, 0.09141793f, -0.00263420f, 0.02731461f, -0.10161665f, 0.11806827f, 0.01871213f, 
    -0.00457679f, -0.00740309f, 0.03330209f, -0.02135350f, 0.31277615f, -0.13132243f, -0.10842820f, 0.17690216f, 
    0.01980774f, 0.12122750f, 0.12277877f, 0.03346930f, 0.00295047f, 0.02524454f, -0.05788786f, 0.06467018f, 
    -0.56914037f, -0.17011859f, -0.03083631f, 0.06836675f, 0.01011067f, 0.01308322f, -0.07747561f, 0.00484843f, 
    -0.09903853f, -0.02818471f, -0.04459633f, 0.02058945f, -0.41420075f, -0.35220277f, -0.05469957f, -0.08291997f, 
    -0.01479228f, -0.06151150f, 0.03209936f, -0.01149924f, 0.03383412f, -0.01829946f, -0.06377972f, -0.03631031f, 
    0.25364429f, 0.01977018f, 0.09525185f, 0.08345307f, -0.00934997f, -0.07374763f, 0.01476889f, -0.07462335f, 
    0.00469424f, 0.01185467f, 0.07660374f, -0.01601284f, 0.23796387f, -0.22913414f, -0.06333822f, -0.08493277f, 
    -0.03483308f, 0.01615492f, -0.04869016f, 0.00410254f, -0.06981724f, 0.02119072f, -0.06194677f, 0.03776389f, 
    -0.06156119f, 0.06379861f, -0.01120274f, -0.08363317f, -0.04469446f, -0.05403375f, 0.06397983f, 0.02410673f, 
    -0.00220596f, -0.08483167f, 0.03741884f, 0.00170774f, 0.06257762f, 0.09102865f, 0.01549470f, 0.16384658f, 
    0.11370528f, 0.11577546f, -0.08234779f, 0.06942315f, 0.00863482f, -0.07986706f, -0.05986498f, -0.10812324f, 
    -0.29791304f, -0.10610538f, -0.22403857f, 0.20352665f, -0.05525464f, 0.05950706f, 0.10338942f, 0.02139584f, 
    -0.04261040f, 0.05920343f, -0.01994638f, 0.03115277f, 0.05248287f, 0.07431180f, 0.02219751f, -0.01816730f, 
    -0.02742908f, -0.01454456f, 0.05037020f, 0.03916229f, -0.02666830f, 0.01372304f, 0.03426238f, -0.01191686f, 
    -0.42507631f, -0.13079463f, 0.02216283f, -0.08935963f, 0.01105628f, -0.08490586f, -0.09915839f, -0.09812107f, 
    -0.06597193f, -0.00385436f, 0.07975147f, 0.02636467f, 0.03910942f, 0.09669492f, -0.02895569f, 0.07058184f, 
    -0.08066859f, 0.01938836f, 0.13434651f, -0.02408672f, 0.03924432f, 0.09324559f, -0.03443955f, -0.11084897f, 
    0.23172189f, 0.02678560f, 0.00569426f, 0.18079430f, -0.00222893f, 0.00885347f, 0.06146586f, -0.11761208f, 
    0.01496728f, 0.06227757f, -0.06627569f, -0.00187104f, -0.15028144f, -0.20495319f, -0.16785555f, -0.17510639f, 
    -0.09854882f, 0.14172457f, 0.03599460f, 0.08209167f, -0.09569485f, 0.03241676f, -0.01508671f, -0.08853158f, 
    0.11831634f, -0.08184716f, -0.13135269f, 0.14583457f, -0.15985185f, -0.01481815f, -0.04188091f, 0.13271411f, 
    0.01508329f, 0.09012147f, 0.00143618f, -0.03867461f, -0.12988254f, -0.13270086f, -0.13942161f, -0.06146282f, 
    -0.07229575f, -0.09483872f, 0.04737650f, -0.03083976f, 0.02992445f, 0.02423107f, 0.02940210f, -0.05443224f, 
    -0.25330254f, -0.17889145f, -0.22099577f, -0.07577034f, -0.03095227f, 0.07892954f, -0.06208968f, -0.04246967f, 
    -0.04298502f, 0.02502954f, -0.07054359f, -0.04061930f, -0.25183538f, -0.24059851f, 0.01064551f, -0.25671747f, 
    -0.08224669f, -0.10201699f, 0.04321514f, -0.03496584f, -0.06427979f, 0.04543736f, -0.00848162f, 0.04035432f, 
    -0.17215084f, -0.42418703f, -0.28977695f, -0.02896364f, -0.07039563f, -0.07728429f, 0.11508857f, -0.06356569f, 
    -0.00649193f, -0.01701243f, 0.06897891f, -0.06643614f, -0.32190081f, -0.01960522f, 0.11456922f, -0.29339862f, 
    0.03368874f, 0.08844495f, -0.04110085f, -0.00680540f, 0.08602868f, -0.16731814f, -0.03662184f, 0.08972368f, 
    -0.49844608f, 0.02273632f, 0.02539849f, 0.14196102f, -0.00088642f, 0.05790946f, -0.05157744f, -0.00583116f, 
    0.03386451f, -0.03373870f, 0.06623681f, -0.08514342f, -0.38577050f, -0.38898057f, 0.10969611f, 0.08894111f, 
    -0.03008174f, 0.00311825f, -0.06214587f, 0.01392637f, 0.01251861f, -0.08387628f, -0.03902684f, 0.03035315f, 
    -0.00776690f, 0.12385318f, 0.17909577f, 0.09748129f, 0.04673392f, 0.00258269f, 0.01811095f, 0.07288028f, 
    -0.05040139f, -0.03761804f, 0.05961873f, 0.10233721f, -0.17710479f, 0.12488294f, -0.15003601f, 0.00188208f, 
    -0.04293943f, 0.00793367f, -0.00833473f, 0.07271377f, -0.02925814f, 0.06187655f, 0.01877621f, -0.08955242f, 
    -0.02609652f, 0.08074035f, -0.03786845f, 0.02476612f, 0.03066983f, -0.09347824f, 0.05354084f, 0.05149415f, 
    -0.04399133f, -0.04287114f, 0.00119106f, 0.02380043f, -0.21116823f, 0.09982122f, 0.16888139f, 0.11793138f, 
    -0.04324038f, 0.08704971f, 0.07024342f, 0.08358113f, -0.03421399f, 0.01719026f, 0.09089747f, 0.02791428f, 
    0.18997546f, -0.16362132f, -0.33984140f, 0.07587786f, -0.02420837f, 0.03883711f, 0.10612449f, -0.04998438f, 
    -0.03023572f, -0.05777048f, 0.05320856f, -0.03668016f, 0.17962842f, 0.14421330f, -0.06114263f, -0.07184512f, 
    -0.10686537f, -0.04199984f, 0.09339272f, 0.14010076f, -0.06253378f, -0.15741295f, -0.05327659f, 0.07244038f, 
    0.00401868f, -0.00521269f, -0.11906461f, 0.06083810f, -0.01025617f, 0.08521048f, 0.01727339f, -0.01231385f, 
    0.06405044f, 0.00952923f, 0.07760765f, -0.18102309f, -0.17760247f, 0.30504975f, -0.02572987f, 0.12103654f, 
    0.03087083f, 0.04548711f, 0.13960029f, 0.00144533f, -0.07444569f, -0.02989563f, -0.04316799f, 0.04451543f, 
    -0.16468047f, 0.05698872f, 0.21867286f, 0.23271076f, 0.12272004f, -0.07942382f, -0.00607220f, -0.14763382f, 
    -0.02510965f, -0.00761055f, -0.12278157f, -0.06149705f, -0.07351105f, 0.00666989f, -0.14047703f, -0.09565053f, 
    -0.08036749f, -0.05141226f, -0.03222951f, -0.09761293f, 0.04518706f, -0.00020124f, -0.02861296f, 0.07088418f, 
    0.03656105f, -0.06874888f, -0.06749613f, -0.15078634f, -0.13358292f, -0.07324334f, -0.05114201f, 0.01985245f, 
    -0.01044227f, -0.08824493f, 0.04249819f, -0.00966045f, 0.30928990f, -0.18977377f, -0.24490492f, 0.22131604f, 
    -0.03623105f, -0.01946169f, -0.02751668f, -0.09223001f, -0.01193425f, 0.02578120f, -0.03477913f, -0.13290544f, 
    -0.04695117f, 0.15379554f, 0.11226872f, -0.14215113f, 0.05460580f, -0.07862557f, 0.07220054f, -0.03243230f, 
    -0.14251111f, -0.01954021f, -0.08802044f, -0.00703414f, 0.20002827f, -0.03303710f, 0.04983553f, -0.07728060f, 
    -0.05290874f, -0.12025363f, -0.07555552f, -0.04187438f, -0.05508666f, -0.03842174f, -0.09249295f, 0.06775492f, 
    0.00945047f, 0.20023145f, 0.12757196f, 0.13447699f, 0.10726310f, -0.07859452f, 0.08069664f, -0.07555421f, 
    -0.03869342f, 0.03770288f, 0.02347827f, -0.15470028f, -0.03792799f, 0.17340086f, 0.19791174f, -0.05127603f, 
    0.02409033f, -0.05916184f, -0.04256164f, 0.00915716f, 0.05521052f, 0.09348574f, -0.06656219f, 0.10581647f, 
    -0.03756845f, 0.35594666f, 0.27082986f, -0.05382475f, 0.08115450f, 0.04652365f, 0.03997245f, 0.00951674f, 
    0.02626368f, 0.02682602f, -0.01781622f, 0.08309986f, 0.04117587f, -0.05220028f, 0.02199598f, -0.19073814f, 
    -0.01015728f, 0.05820113f, 0.07188990f, -0.02724650f, 0.01234211f, 0.02470030f, -0.01973966f, -0.05415266f, 
    -0.18684906f, 0.04365477f, -0.01292794f, -0.00556266f, 0.01965838f, -0.00894212f, 0.04819229f, -0.01819802f, 
    0.11465686f, -0.03472064f, 0.02985714f, 0.04147937f, 0.06389274f, 0.20651855f, 0.22302546f, -0.05187672f, 
    0.10444412f, -0.03063371f, -0.09561383f, -0.04691076f, -0.00017924f, 0.05623606f, -0.00959611f, 0.07137630f, 
    -0.10332259f, 0.10838521f, -0.14688580f, -0.10713600f, -0.01160535f, 0.00032938f, -0.01798190f, 0.02850616f, 
    -0.02109862f, -0.02511515f, -0.10107358f, 0.03250226f, 0.11313291f, 0.23887964f, -0.14724746f, -0.19745719f, 
    0.03950596f, -0.01026994f, -0.06671378f, 0.05968617f, 0.00194359f, -0.07103541f, -0.04466528f, 0.13878456f, 
    0.15123440f, -0.05995821f, -0.00208498f, 0.13525192f, 0.00172964f, 0.06165799f, 0.09898506f, 0.03068147f, 
    -0.00831355f, 0.00338860f, 0.01776618f, 0.10891639f, 0.22669835f, 0.24479793f, -0.01509900f, 0.11981411f, 
    0.10274159f, 0.00681788f, -0.02191794f, 0.11987974f, -0.03822381f, 0.12583177f, 0.07858697f, 0.06924672f, 
    -0.12994915f, -0.02519471f, -0.11269806f, -0.04155377f, -0.18460010f, 0.01342478f, 0.06062822f, 0.02654835f, 
    0.05011055f, -0.04092887f, -0.02258814f, -0.01924681f, -0.42558429f, -0.06955036f, -0.14601417f, -0.08051567f, 
    -0.02281114f, 0.09653091f, 0.00424859f, 0.03526949f, -0.09029951f, 0.03982901f, 0.01307970f, 0.01580858f, 
    -0.17499758f, -0.31378651f, 0.02960368f, 0.05063231f, -0.13050969f, 0.10108617f, -0.04697909f, -0.21432747f, 
    0.01905916f, -0.07387949f, -0.03431880f, 0.03399191f, -0.21159351f, -0.01954208f, 0.08334783f, 0.09282234f, 
    -0.06868115f, -0.07776780f, 0.04961335f, -0.02978035f, -0.05261226f, -0.07061636f, -0.10872965f, 0.06016529f, 
    -0.38684911f, 0.01489683f, 0.11455082f, 0.14332688f, -0.00805547f, 0.16947562f, 0.05256384f, -0.00011136f, 
    0.03545673f, -0.03994920f, 0.14138831f, -0.01472391f, -0.25560030f, 0.02188299f, 0.07170329f, 0.00043425f, 
    -0.02171416f, -0.01119557f, -0.00669054f, -0.12436087f, -0.00529836f, 0.08713152f, 0.04793951f, -0.06891727f, 
    0.24820681f, -0.08048550f, 0.10158972f, -0.03430219f, -0.07636751f, 0.02842842f, 0.03075935f, 0.00346320f, 
    -0.15135865f, -0.04651085f, 0.04315311f, 0.04078008f, 0.05731306f, -0.11469503f, 0.05709323f, 0.19744283f, 
    -0.04424060f, 0.00795540f, -0.04369075f, 0.00401058f, -0.00546237f, 0.02897277f, -0.08117117f, 0.13897362f, 
    -0.32674614f, -0.05400902f, 0.07435635f, 0.17536448f, -0.02240194f, 0.05170493f, 0.06069613f, 0.03621826f, 
    -0.01832086f, 0.01666321f, 0.04768741f, 0.04693506f, -0.22178489f, 0.02889048f, -0.08264133f, 0.20800318f, 
    0.02627867f, -0.00009168f, 0.08898011f, 0.04931118f, -0.09336371f, -0.08234484f, -0.03880753f, -0.01162011f, 
    -0.01912018f, 0.04295478f, -0.24822877f, 0.03101985f, 0.12353189f, -0.10602047f, 0.10270728f, -0.04750834f, 
    0.09070624f, -0.04301976f, 0.05598789f, -0.02541248f, -0.20681599f, 0.03644453f, 0.07664503f, 0.20607443f, 
    0.01464311f, -0.01265862f, 0.01113186f, 0.00900732f, 0.03009226f, 0.09413643f, 0.02134295f, -0.01271322f, 
    0.34787208f, -0.01343506f, 0.06888278f, 0.12277558f, -0.02727339f, 0.03458669f, 0.03064685f, -0.00978999f, 
    0.03041400f, 0.05294370f, -0.06780775f, -0.03064390f, 0.25791505f, -0.04035671f, -0.00627737f, -0.17562428f, 
    0.07682843f, -0.00665549f, 0.12091073f, 0.05131361f, 0.01943664f, 0.00333479f, -0.20470786f, 0.02598782f, 
    0.04643894f, -0.00780579f, 0.14596571f, 0.12373281f, 0.07841113f, 0.04652341f, 0.04855004f, 0.02125199f, 
    0.03570420f, 0.06009921f, -0.01741818f, 0.06690314f, -0.03769374f, -0.22468796f, -0.07024368f, 0.14020875f, 
    0.06684218f, -0.04742214f, 0.02804098f, 0.01169942f, -0.00059090f, -0.03304197f, 0.10696626f, -0.00602687f, 
    -0.40869978f, -0.03234918f, -0.05688672f, -0.37713066f, 0.00963711f, -0.05994672f, -0.12437275f, 0.18848744f, 
    0.11493334f, -0.05842774f, -0.09364431f, -0.00878884f, 0.01028475f, 0.16875553f, -0.12225529f, -0.01815465f, 
    -0.00640492f, 0.07655241f, 0.10502005f, 0.14164324f, 0.10750022f, -0.02947928f, 0.02306321f, 0.02898795f, 
    -0.06482540f, 0.06685332f, 0.00066712f, 0.06287620f, 0.05646592f, 0.12370504f, 0.00064113f, 0.03166189f, 
    0.01221350f, -0.08310527f, 0.03288021f, -0.05323165f, -0.18585028f, 0.01929695f, 0.00146973f, -0.18970786f, 
    -0.02219667f, 0.01944751f, -0.02018528f, -0.01846074f, 0.02828250f, -0.07127658f, 0.01358611f, 0.06072154f, 
    -0.12406183f, -0.01265865f, 0.20730539f, 0.04885262f, -0.05894709f, -0.04451574f, 0.05330838f, -0.00093779f, 
    0.03148744f, -0.02200842f, -0.08283603f, -0.09187019f, 0.09148071f, 0.15830363f, -0.00424813f, -0.05714527f, 
    -0.06783593f, -0.02815422f, -0.06999154f, 0.08791839f, -0.06586885f, 0.03713218f, 0.12635070f, -0.09941460f, 
    0.05948646f, 0.22608687f, -0.24842580f, -0.05121082f, 0.04272032f, -0.08049280f, -0.09680375f, -0.01613094f, 
    -0.15169941f, -0.02328029f, -0.04468245f, -0.00007254f, 0.05292521f, -0.04803270f, 0.14765738f, -0.04988346f, 
    -0.01999272f, 0.07057094f, 0.04191246f, -0.14769855f, 0.06634112f, 0.13379468f, -0.01496399f, -0.11284288f, 
    0.11114266f, 0.07519374f, -0.01835612f, 0.16690461f, -0.00132178f, 0.01618399f, 0.06176480f, 0.00780991f, 
    0.00722487f, -0.08216169f, -0.00482316f, 0.05349083f, -0.23604867f, -0.14430591f, 0.20221557f, 0.04467998f, 
    -0.10182624f, 0.05245670f, -0.02517822f, -0.05542994f, 0.14101976f, -0.02686062f, 0.00850396f, 0.00718207f, 
    -0.01693633f, -0.30607346f, 0.06548154f, -0.14870825f, -0.14262249f, 0.11859215f, -0.01502104f, 0.05607148f, 
    0.01568677f, 0.03696611f, -0.02893831f, -0.01592187f, 0.12150714f, 0.24611071f, 0.04828729f, -0.07745345f, 
    -0.02502104f, 0.01002398f, -0.05419928f, -0.08291893f, -0.01608758f, -0.05771022f, 0.05372056f, -0.05832475f, 
    -0.58163536f, 0.03669861f, -0.00197764f, -0.00943919f, 0.08034378f, -0.12156519f, -0.13815600f, -0.04115750f, 
    -0.00657825f, -0.04918289f, -0.00345424f, 0.05960346f, 0.19032337f, -0.08405206f, -0.21125123f, 0.15764360f, 
    -0.00317028f, -0.02979967f, -0.08669103f, 0.00718179f, -0.00458758f, -0.12151746f, -0.05633058f, -0.04527358f, 
    0.07422850f, 0.06301893f, -0.13163175f, 0.09715140f, -0.05400186f, -0.00064486f, 0.12806189f, 0.07900541f, 
    -0.02444892f, -0.05946453f, -0.00230540f, 0.02564692f, -0.07443232f, -0.06235152f, 0.15589193f, -0.02994433f, 
    0.05714916f, 0.02289734f, -0.11598587f, -0.20171417f, 0.04934319f, -0.07056926f, -0.06230681f, -0.05001563f, 
    -0.07308391f, 0.03552258f, 0.17803448f, -0.23505005f, -0.05316286f, 0.16817842f, 0.04221651f, 0.14131021f, 
    0.09726311f, 0.07357364f, -0.01372811f, 0.05286835f, -0.12642351f, 0.01165609f, -0.06881888f, 0.00555986f, 
    -0.05301851f, -0.02548108f, 0.01761633f, 0.13245457f, -0.04425312f, -0.08541717f, -0.01787967f, 0.04238238f, 
    0.14235793f, -0.23912258f, -0.06735925f, 0.00637898f, -0.02469001f, 0.01745212f, -0.08725773f, 0.08094284f, 
    0.09098531f, 0.15151329f, -0.05571501f, 0.08915006f, 0.29001501f, -0.30577224f, 0.01665822f, 0.01584571f, 
    -0.10563836f, -0.00050183f, 0.02801075f, 0.00070201f, 0.04004335f, 0.00390235f, 0.03948501f, 0.08648284f, 
    -0.05540897f, -0.00820481f, 0.09407950f, 0.17763899f, -0.04180145f, 0.04824204f, 0.05744036f, -0.01124531f, 
    0.11235002f, 0.04670554f, -0.04789532f, -0.07155388f, -0.32839045f, -0.04140779f, 0.12622291f, 0.17379278f, 
    -0.03120052f, 0.05696577f, 0.07107939f, -0.00906653f, -0.09131597f, 0.00772276f, 0.05994055f, 0.12980245f, 
    -0.31492606f, -0.17219472f, 0.23169483f, 0.05331883f, -0.06198028f, 0.04865356f, 0.02783027f, -0.07963500f, 
    0.10026517f, 0.03906770f, -0.07697750f, -0.09656098f, -0.03142168f, 0.05843637f, 0.05217978f, -0.05665896f, 
    0.10708723f, -0.07327712f, -0.03331560f, 0.11546156f, 0.00010414f, -0.13150845f, 0.04236073f, -0.06098038f, 
    0.10373963f, -0.02636587f, 0.18387710f, 0.07832561f, 0.04789575f, 0.09687509f, -0.03451583f, -0.01966489f, 
    0.03271236f, 0.10440376f, -0.08067587f, 0.21138065f, -0.19178300f, -0.27182746f, 0.21047482f, -0.20643400f, 
    -0.07271343f, 0.06013731f, 0.08467691f, -0.05980185f, 0.05516376f, 0.08920690f, 0.15081565f, 0.03263278f, 
    -0.42713964f, -0.09670112f, 0.01278839f, -0.01563290f, 0.02189744f, -0.04034744f, -0.03117025f, -0.03402333f, 
    -0.02298073f, -0.06928591f, -0.04739207f, -0.03034508f, -0.16203934f, 0.19732887f, 0.09178450f, -0.04780141f, 
    0.06327633f, -0.08707749f, -0.05800704f, 0.04981986f, 0.06629944f, -0.04770581f, 0.09062037f, 0.01390669f, 
    0.32440192f, 0.11967284f, -0.06476256f, -0.00371531f, 0.11648812f, 0.15742245f, 0.09932382f, -0.10823922f, 
    0.03633174f, -0.04106104f, 0.11535282f, -0.04930674f, 0.04229943f, -0.10674810f, -0.04863340f, -0.15555015f, 
    0.00650634f, 0.15983647f, -0.01971647f, -0.03789127f, -0.12351719f, -0.00784927f, -0.03705096f, -0.00983126f, 
    0.07114659f, -0.28286874f, -0.01928069f, 0.03891992f, -0.07995264f, -0.16088417f, -0.02142695f, -0.09206310f, 
    -0.04682586f, 0.04417514f, -0.05296265f, -0.10163698f, -0.16943286f, -0.21576492f, 0.03083043f, -0.15185297f, 
    0.05616284f, 0.03789700f, 0.01190860f, 0.02518267f, -0.02297404f, -0.05046902f, -0.08673355f, -0.05519754f, 
    -0.16336831f, -0.06514382f, 0.10354259f, 0.03501580f, 0.00892029f, -0.20081833f, -0.00263986f, 0.00575658f, 
    0.10887912f, 0.06116592f, -0.13111040f, -0.04703456f, -0.17389311f, 0.13579568f, 0.06702285f, 0.32280141f, 
    -0.00018737f, -0.11738959f, 0.07786875f, -0.01581622f, -0.00364140f, 0.02296865f, 0.00285788f, 0.02171284f, 
    -0.16778956f, -0.04961216f, 0.01345227f, -0.06602231f, -0.02351633f, 0.02892915f, -0.06419022f, 0.08000395f, 
    -0.08783458f, -0.03216039f, -0.06861279f, 0.04262903f, -0.14316723f, 0.15349407f, 0.21483600f, 0.02434902f, 
    -0.09864837f, 0.01757921f, -0.06621149f, -0.02007794f, 0.00340051f, -0.11398691f, 0.06612787f, -0.02118237f, 
    -0.41379592f, -0.07305781f, -0.03988578f, -0.22146177f, 0.02824035f, 0.00910342f, 0.05771733f, 0.12053985f, 
    -0.09027490f, 0.03499055f, -0.01822742f, 0.02520893f, -0.11444505f, -0.01325612f, 0.05705312f, 0.15036398f, 
    0.02614301f, 0.05410062f, 0.00113394f, 0.17572120f, 0.00409735f, 0.01016320f, 0.14637792f, -0.07640653f, 
    -0.25813797f, -0.22216687f, 0.17972685f, 0.06301451f, -0.05425006f, -0.02920656f, -0.15168397f, -0.17514698f, 
    0.02717621f, -0.01238172f, -0.01320454f, -0.00513758f, 0.01441054f, 0.04489890f, 0.21299165f, -0.06721093f, 
    0.02064790f, -0.03372981f, 0.06367761f, -0.04337640f, 0.04064031f, -0.03695108f, -0.12276225f, -0.03129257f, 
    0.37488663f, 0.33987463f, -0.14763275f, -0.08418639f, -0.12096491f, -0.13441871f, 0.10839341f, -0.10509393f, 
    -0.02069192f, -0.05620085f, -0.02850746f, -0.06271206f, -0.16129927f, 0.06273454f, -0.15831989f, -0.17584848f, 
    -0.01065811f, -0.01465019f, -0.05588331f, -0.04729973f, 0.05292666f, -0.10145929f, -0.02020419f, -0.01320907f, 
    -0.34412763f, -0.12652677f, -0.07387189f, -0.25309002f, 0.14203148f, -0.00294650f, -0.03369315f, 0.00886743f, 
    -0.05259128f, 0.01534922f, 0.02831078f, -0.01498687f, 0.03397910f, 0.02858345f, -0.01367106f, 0.21806313f, 
    -0.08299355f, 0.05410146f, 0.00140067f, 0.03589410f, 0.13740298f, -0.00440468f, 0.00665643f, -0.11944647f, 
    -0.03870794f, 0.01730623f, 0.15379307f, 0.11424017f, 0.02537183f, 0.00212376f, 0.03461904f, -0.03505875f, 
    0.08521675f, 0.10065677f, 0.02617483f, 0.12071250f, -0.06363116f, -0.22446258f, 0.17877895f, 0.25088221f, 
    0.04589830f, -0.00472696f, -0.03778962f, 0.01716874f, 0.08152703f, -0.01827626f, -0.05012866f, -0.12463009f, 
    -0.05029868f, -0.00890539f, 0.07867217f, -0.08529998f, -0.05511912f, -0.02325840f, -0.02065424f, -0.06845481f, 
    0.09380732f, -0.09385294f, -0.16805559f, -0.24275196f, 0.10988446f, -0.30642539f, -0.01692061f, -0.04731864f, 
    0.11583037f, -0.07678568f, -0.02401279f, -0.29475826f, 0.04521607f, -0.11273452f, -0.11145853f, -0.02538491f, 
    -0.15512280f, 0.11846153f, -0.04955164f, 0.10514733f, -0.09491879f, -0.00240523f, 0.04445716f, -0.04941764f, 
    0.00470075f, -0.17441623f, 0.00311100f, 0.08680505f, -0.37593302f, 0.25652447f, -0.08687558f, -0.30688149f, 
    0.12441491f, -0.03643852f, -0.03740499f, -0.01632165f, 0.00217283f, 0.01875519f, -0.10060472f, -0.01869727f, 
    0.00150575f, 0.07247389f, -0.01754752f, 0.02713358f, -0.10620614f, -0.04782771f, 0.15810347f, 0.13853568f, 
    0.00947688f, -0.09233426f, 0.02833497f, 0.02590773f, -0.15372892f, -0.19335172f, 0.05466102f, 0.19747785f, 
    0.12358107f, -0.03945803f, 0.07671587f, 0.01975273f, -0.16321574f, 0.13123959f, 0.05186321f, -0.02745496f, 
    0.30512881f, 0.17529181f, -0.08941933f, -0.13196036f, -0.06318452f, -0.11281117f, -0.15503271f, -0.20886019f, 
    -0.15089616f, -0.03517503f, -0.13498794f, -0.10503649f, -0.01995178f, -0.22290176f, 0.06205494f, -0.00933345f, 
    -0.15163884f, 0.02960047f, -0.09443890f, -0.05806294f, -0.02363569f, -0.00924678f, -0.04116115f, 0.12978765f, 
    -0.03074180f, -0.18964361f, 0.03738924f, 0.15411283f, 0.13986515f, 0.06242503f, 0.15619625f, 0.06446455f, 
    0.07011548f, 0.03203672f, -0.10957041f, -0.10456095f, -0.01285400f, -0.05201934f, 0.02926743f, -0.29492152f, 
    0.03273949f, -0.04620692f, 0.11208794f, 0.03806043f, -0.06876768f, -0.18080226f, -0.01575481f, 0.07015155f, 
    -0.33350882f, -0.17148751f, -0.27776086f, -0.14195035f, 0.09702375f, 0.06556199f, 0.02882753f, -0.05933034f, 
    -0.07896544f, 0.01730907f, 0.01151371f, -0.06049515f, 0.02982727f, 0.00766817f, -0.04757996f, 0.16997540f, 
    0.08523717f, -0.00157701f, -0.05081017f, 0.05310031f, 0.01656925f, 0.02558553f, 0.00919727f, -0.14365093f, 
    -0.21426320f, 0.08563468f, -0.10232840f, -0.41872409f, -0.05642957f, 0.01806472f, -0.14627081f, -0.04119953f, 
    0.03166408f, -0.01080219f, 0.04679677f, 0.02248664f, -0.11812133f, -0.13364051f, -0.17038654f, -0.16653991f, 
    0.07862572f, 0.12307222f, -0.22770168f, -0.01406764f, -0.01664857f, -0.04537791f, -0.02014902f, 0.06778666f, 
    -0.19099694f, -0.04152046f, -0.04084590f, 0.00609852f, 0.04462959f, -0.03589506f, -0.10082762f, -0.13156347f, 
    -0.00788190f, -0.13253829f, 0.03328390f, 0.18783259f, -0.18722878f, -0.17465414f, 0.01189857f, 0.19162190f, 
    -0.02910792f, 0.00633080f, -0.13006936f, -0.05643266f, 0.05702848f, -0.04510340f, 0.18659487f, -0.01599047f, 
    0.09862486f, -0.11527486f, -0.19138357f, 0.09983896f, 0.06440619f, -0.07251660f, -0.02748754f, 0.13288058f, 
    0.06736781f, 0.06080784f, 0.16583964f, 0.16129388f, 0.37100497f, 0.02767739f, -0.11823746f, -0.05973845f, 
    0.07436077f, 0.06970553f, -0.17115031f, -0.11012468f, -0.09000031f, -0.02243321f, -0.15270564f, -0.01708847f, 
    -0.27863553f, 0.09125232f, 0.05680830f, 0.11786114f, -0.05758708f, -0.04796784f, 0.06601793f, -0.04607601f, 
    0.00160579f, 0.01179927f, 0.03967782f, -0.12204869f, -0.17210938f, 0.18400028f, 0.16157100f, -0.09577869f, 
    0.07441816f, -0.09353011f, 0.16671486f, -0.05441229f, -0.03538281f, 0.03004169f, -0.08459327f, -0.13654229f, 
    -0.03600951f, -0.00593480f, 0.13455181f, -0.19042122f, 0.04089633f, -0.09579308f, 0.04694168f, 0.01280620f, 
    0.08168651f, 0.18644215f, -0.02319067f, -0.05620797f, 0.09596083f, -0.06625135f, -0.02139102f, -0.13846633f, 
    0.12858748f, -0.10710876f, -0.24509105f, 0.10319334f, -0.07629760f, -0.00149633f, 0.10662773f, -0.07406354f, 
    -0.10555141f, -0.01893020f, -0.00749539f, -0.18157621f, 0.04882019f, 0.05266370f, 0.04545933f, 0.07395504f, 
    0.15214986f, 0.00218078f, 0.12856643f, 0.04793737f, 0.12962449f, 0.01070010f, 0.03581670f, 0.16079071f, 
    -0.03918104f, 0.17762755f, 0.11035808f, -0.01108534f, -0.01784657f, -0.01423248f, -0.07680003f, 0.10232689f, 
    -0.31184193f, -0.01561675f, 0.09227476f, -0.11496481f, -0.03903468f, 0.00049554f, 0.00783734f, 0.09508614f, 
    0.01356640f, -0.15144561f, -0.02033778f, -0.08951662f, 0.10935546f, 0.02776188f, -0.05960453f, -0.07755698f, 
    -0.04470120f, -0.14595915f, 0.02720089f, -0.11535644f, 0.04029391f, 0.04509212f, -0.16947930f, -0.01330185f, 
    -0.24154788f, -0.41812670f, -0.04571322f, 0.06302498f, 0.09674398f, -0.10387825f, -0.05240677f, -0.04324451f, 
    0.05752693f, 0.16740471f, -0.04867078f, 0.12680516f, 0.08307883f, -0.03630080f, 0.21624662f, 0.14595401f, 
    -0.04686117f, -0.12601195f, 0.13635646f, 0.04309483f, -0.00077658f, 0.02369367f, -0.02489039f, 0.16534488f, 
    0.14418031f, 0.06362014f, -0.03994839f, -0.03449912f, 0.15748861f, 0.00745708f, -0.01091256f, 0.07094450f, 
    -0.09625214f, 0.07596594f, -0.00382161f, 0.02446997f, -0.04206369f, -0.03943066f, 0.15392745f, 0.17553791f, 
    -0.02197256f, -0.07890760f, -0.04458833f, 0.13017251f, 0.10213871f, 0.15027614f, -0.08631656f, 0.02271141f, 
    0.01494172f, -0.08735491f, 0.07233871f, -0.14363214f, -0.06014112f, -0.04606611f, 0.14503518f, 0.18037692f, 
    -0.03829991f, -0.07462006f, 0.02182204f, -0.09856655f, 0.07927038f, 0.02716827f, -0.03511382f, -0.04210639f, 
    0.10529367f, 0.02075754f, -0.00601543f, -0.00912877f, 0.07586475f, 0.00208237f, -0.04837273f, -0.08640965f, 
    0.13629602f, -0.02665262f, 0.13674274f, -0.11016658f, -0.02928473f, -0.07192323f, -0.07922184f, 0.06473520f, 
    -0.02974899f, -0.07573356f, -0.10157153f, -0.02427073f, 0.18470405f, -0.05021545f, -0.12485429f, 0.05797014f, 
    0.00894832f, -0.05713534f, 0.04263088f, 0.05954413f, 0.18543819f, 0.05041866f, 0.01068926f, 0.11448433f, 
    -0.22758816f, -0.00266562f, -0.00714341f, 0.16125840f, 0.03859811f, -0.00924777f, 0.01880268f, 0.00644147f, 
    0.00244845f, -0.04836235f, -0.00160518f, 0.06978547f, 0.04335338f, 0.08910671f, 0.12095485f, -0.03051218f, 
    -0.02538380f, -0.06158078f, -0.00412448f, -0.00885152f, 0.02501586f, 0.08490844f, 0.10213907f, 0.01430657f, 
    0.00204562f, 0.09249030f, 0.11296618f, -0.08722281f, -0.02119869f, -0.08662608f, 0.18336962f, -0.05743148f, 
    0.16999829f, -0.06701258f, 0.09404869f, -0.03308550f, 0.15484394f, 0.03799931f, 0.27307159f, 0.04192025f, 
    0.17259367f, 0.02266163f, -0.02492297f, -0.10996188f, 0.07558168f, -0.12441396f, -0.02042652f, -0.08236808f, 
    -0.00512738f, -0.01415103f, 0.13624731f, -0.05748673f, 0.01612718f, -0.01449911f, 0.01958905f, -0.07663621f, 
    -0.16166931f, -0.05197017f, 0.14886273f, 0.13641840f, -0.03212338f, -0.05615462f, -0.14231387f, -0.01832995f, 
    0.06209234f, -0.01452692f, 0.03535826f, -0.03712582f, 0.06437006f, -0.02618878f, 0.05437686f, -0.04400173f, 
    0.07587880f, -0.04867042f, -0.07315161f, 0.22368839f, -0.26041988f, -0.13540627f, -0.06418049f, -0.04262439f, 
    0.01475414f, -0.03716058f, 0.03932050f, 0.05841875f, 0.01291496f, 0.02118324f, 0.18390010f, 0.06626084f, 
    -0.07444573f, 0.03596734f, 0.11327058f, -0.10330120f, -0.05417497f, 0.10065457f, 0.11837552f, 0.16255480f, 
    0.21244386f, 0.15509596f, -0.08591522f, -0.03795155f, 0.02913103f, -0.06394686f, -0.04416336f, -0.11728566f, 
    -0.02342317f, 0.07670638f, 0.11334119f, 0.07049704f, -0.07126705f, 0.02663293f, -0.04399655f, 0.08975950f, 
    -0.07891424f, -0.09162214f, 0.03116394f, 0.11402468f, -0.06334710f, -0.08927524f, -0.08604538f, -0.08365321f, 
    -0.57519776f, -0.04692267f, -0.05912971f, -0.07448366f, -0.03231745f, 0.11593898f, 0.08564179f, -0.00439028f, 
    0.05192740f, 0.09730390f, 0.00326688f, -0.14713639f, -0.16053291f, 0.08400352f, -0.01771240f, -0.03899401f, 
    -0.02414599f, 0.19120216f, 0.03087417f, -0.02734371f, -0.06126753f, -0.03072759f, 0.07989269f, -0.04349858f, 
    -0.00817974f, 0.30273208f, 0.23615913f, -0.28017139f, -0.15247826f, -0.02702595f, -0.10514031f, -0.01211125f, 
    -0.07056881f, 0.04361926f, 0.02039071f, -0.15013425f, -0.08778142f, -0.02081785f, 0.16073911f, -0.19231845f, 
    0.06397541f, -0.06280696f, -0.10359633f, 0.13982247f, 0.12665907f, -0.03049246f, -0.07737731f, -0.21717258f, 
    0.06176836f, 0.19512661f, 0.02152255f, 0.05748365f, 0.03815908f, -0.02663275f, 0.09341437f, -0.09537925f, 
    -0.00732578f, 0.11611414f, 0.00573505f, 0.07006563f, -0.05562375f, 0.03926241f, -0.02143496f, 0.06507584f, 
    -0.00887304f, 0.06105556f, 0.02321066f, 0.08703414f, -0.07293183f, -0.04330038f, 0.17876761f, 0.06251908f, 
    0.05859359f, 0.15234500f, 0.01688028f, -0.30220142f, 0.03861472f, 0.08817258f, -0.04759379f, 0.02331428f, 
    0.05426961f, -0.16799571f, 0.01765278f, 0.06498946f, -0.22180696f, 0.00402027f, -0.21627815f, 0.05232909f, 
    -0.06003241f, 0.09107300f, -0.12979925f, -0.05722522f, 0.11028226f, 0.04549419f, 0.00181310f, -0.00496052f, 
    -0.22282842f, 0.01403829f, -0.07737009f, -0.01038750f, 0.10372586f, 0.03026816f, 0.07984599f, 0.06802944f, 
    0.09167911f, 0.01183014f, -0.04482933f, 0.08767348f, -0.00923237f, -0.06612443f, -0.03772494f, 0.16234851f, 
    -0.05564585f, 0.03170450f, -0.01460781f, -0.02845457f, 0.09711782f, 0.03390696f, -0.08059300f, 0.19066145f, 
    -0.14545655f, 0.00054681f, -0.06504601f, -0.05674746f, 0.05159830f, -0.02961186f, -0.10531591f, 0.12818712f, 
    -0.03926615f, -0.06737068f, 0.08680257f, -0.05821401f, -0.41562316f, -0.16558604f, -0.19721712f, -0.02367794f, 
    0.12096273f, 0.05921489f, 0.09740110f, 0.06757567f, 0.03953938f, 0.05684236f, -0.12238538f, 0.04105071f, 
    0.10610527f, 0.08764002f, 0.05475917f, 0.17556405f, -0.10412337f, -0.11165057f, 0.07129126f, 0.06091414f, 
    -0.26444948f, -0.03662001f, 0.00296215f, 0.14319614f, -0.12855978f, -0.10269213f, -0.06099075f, 0.27760524f, 
    -0.02024298f, -0.12759541f, -0.02672520f, 0.04783021f, 0.05934611f, 0.12691779f, 0.07264352f, 0.10205208f, 
    -0.00803419f, -0.18885684f, 0.15320919f, 0.02123846f, -0.08933083f, -0.05567800f, -0.07036863f, 0.01209660f, 
    0.04746393f, 0.04618547f, 0.04126482f, 0.06161987f, -0.32682744f, 0.09399147f, -0.02281080f, 0.18458974f, 
    0.03449263f, -0.10329632f, -0.02363684f, 0.05853236f, 0.05471346f, 0.06903104f, -0.00998881f, 0.17151579f, 
    -0.09065539f, 0.07906564f, 0.00917894f, -0.19651461f, 0.00499024f, -0.00860410f, 0.06848632f, 0.02305552f, 
    -0.03877158f, -0.03812250f, -0.03528380f, 0.11013258f, 0.03556594f, -0.10710370f, 0.01871021f, -0.24211234f, 
    0.03259078f, -0.05133909f, 0.00125189f, -0.02154091f, -0.03621510f, 0.02215195f, -0.01689951f, 0.02174356f, 
    0.08783215f, 0.03582149f, 0.03355959f, -0.26272362f, -0.01730141f, -0.08257326f, -0.02361112f, 0.05026618f, 
    0.03767101f, -0.09740391f, 0.02574901f, -0.09945474f, 0.18333657f, 0.02429581f, 0.08804350f, -0.01282455f, 
    -0.01844850f, 0.04796432f, 0.08453484f, 0.09117680f, 0.00669375f, 0.05366219f, 0.02389035f, 0.05465232f, 
    -0.27151868f, 0.23528063f, 0.02223372f, -0.19649215f, -0.03601144f, -0.09720627f, -0.01718373f, 0.07300802f, 
    -0.12066218f, 0.02269083f, 0.09008249f, 0.22515669f, 0.05586719f, -0.19472003f, -0.25920269f, 0.10263626f, 
    -0.18293366f, 0.09112488f, 0.06385277f, -0.03932919f, -0.11365993f, 0.10176159f, 0.01489946f, 0.19211392f, 
    0.01845077f, 0.01371814f, -0.00483731f, 0.32317597f, 0.08674245f, 0.04480956f, -0.15526588f, 0.02366817f, 
    0.03846622f, 0.12898903f, -0.07929743f, -0.06735817f, 0.28632110f, -0.60116088f, 0.15625618f, -0.01159862f, 
    0.01382357f, 0.01630263f, 0.11167857f, -0.00045857f, 0.01482854f, -0.02973436f, 0.01300502f, 0.02162194f, 
    -0.04145807f, 0.13229758f, -0.03536232f, 0.11223251f, 0.09071950f, 0.06695008f, -0.15512589f, -0.01503713f, 
    -0.06800520f, -0.02898824f, 0.01784408f, -0.01691665f, -0.00002793f, 0.05560990f, -0.06861022f, -0.13270943f, 
    0.08288901f, 0.08714245f, -0.06498657f, 0.07612699f, 0.03014495f, -0.13652085f, 0.04885999f, -0.06096135f, 
    -0.35816914f, -0.04341664f, 0.15394768f, 0.10516336f, -0.00105541f, -0.02020192f, 0.03533286f, 0.07422669f, 
    0.09949765f, 0.02123324f, 0.09898037f, 0.09150250f, -0.21436113f, 0.03668161f, 0.07602965f, 0.02205702f, 
    0.10889412f, 0.05836890f, 0.18555975f, 0.15045588f, 0.01584091f, 0.02806762f, 0.10430718f, -0.10718622f, 
    -0.20356189f, -0.05850753f, -0.15689343f, 0.07542379f, -0.11390526f, 0.00800574f, -0.13753177f, -0.13767998f, 
    0.02454534f, 0.19032109f, 0.04596979f, 0.05348192f, 0.06371982f, 0.16984919f, 0.06293997f, -0.28575385f, 
    -0.11034954f, 0.04471201f, 0.00746005f, 0.03759865f, 0.06386354f, 0.09708714f, 0.05128216f, -0.15762517f, 
    -0.13437802f, -0.14393704f, -0.05620974f, -0.19760205f, 0.00579900f, 0.06524958f, -0.00751672f, -0.05262048f, 
    0.11032990f, -0.07403150f, 0.06918647f, 0.11185509f, -0.08371764f, 0.17922588f, -0.27389067f, -0.23687962f, 
    -0.03327939f, 0.08600603f, 0.02909362f, -0.03746506f, -0.01474579f, 0.00087867f, -0.06299158f, 0.00301691f, 
    0.31374529f, 0.02982897f, 0.00814317f, -0.27539927f, -0.08857685f, -0.01733241f, 0.07362995f, 0.15148507f, 
    0.01579556f, -0.06081823f, -0.09742033f, 0.04367707f, -0.17263746f, -0.24836423f, -0.16464780f, -0.06846026f, 
    -0.03661226f, 0.04443108f, 0.10471421f, 0.06045790f, -0.02042095f, -0.08042797f, 0.03415018f, 0.01278666f, 
    -0.18904288f, -0.01483124f, -0.17040013f, 0.05155768f, -0.01546698f, -0.08024795f, 0.05188768f, -0.10285456f, 
    -0.04353085f, 0.02758340f, -0.04968680f, -0.12586904f, 0.14032483f, 0.02605584f, 0.05650448f, 0.14618585f, 
    -0.07817672f, 0.00765109f, 0.01602910f, -0.02855684f, -0.20859921f, 0.07975657f, -0.08868543f, -0.08511817f, 
    -0.10863119f, -0.01252302f, 0.02737822f, 0.00845485f, -0.07017972f, 0.01990925f, 0.07242470f, -0.06482266f, 
    -0.04259592f, -0.15138334f, -0.09741341f, -0.26291421f, -0.17487831f, 0.03097388f, -0.20438695f, 0.15411833f, 
    -0.01425636f, -0.03429635f, 0.15541935f, -0.11994903f, 0.04015609f, 0.00580284f, 0.08623029f, 0.01416697f, 
    0.22967935f, -0.36971453f, 0.04251012f, 0.08710963f, 0.09791370f, -0.02616383f, 0.04547695f, -0.01298266f, 
    -0.05912570f, 0.02507802f, -0.01221624f, 0.13192078f, 0.19016860f, -0.21511656f, -0.06882092f, -0.06463702f, 
    -0.02776100f, 0.01572184f, -0.02127796f, 0.13767800f, -0.08628253f, -0.12715402f, 0.08443788f, 0.09400130f, 
    0.20714621f, -0.18775640f, 0.06012024f, -0.10776678f, -0.02248452f, 0.01106819f, 0.01620331f, -0.00277741f, 
    -0.00864630f, -0.09061478f, -0.00991142f, -0.05347406f, 0.13131127f, -0.04846854f, 0.21646009f, -0.03642374f, 
    0.05011807f, 0.03140910f, 0.06865211f, 0.02406317f, -0.05268421f, 0.02800597f, -0.21893932f, 0.07533391f, 
    0.07352053f, 0.00594638f, 0.04704591f, -0.15915632f, 0.05806109f, -0.11439081f, 0.00219703f, 0.02029429f, 
    -0.14417759f, -0.02099378f, -0.01868367f, -0.00150468f, -0.15173589f, 0.11864135f, -0.08348319f, 0.12254276f, 
    -0.01660710f, -0.03576011f, -0.03447454f, 0.02982503f, -0.03822839f, 0.12279933f, 0.07081990f, -0.00896752f, 
    0.03845594f, -0.04509606f, 0.12191805f, -0.09336970f, -0.00443189f, -0.05405323f, 0.10330959f, -0.21976477f, 
    0.04566229f, -0.02740206f, 0.17636158f, -0.03426262f, -0.38541403f, 0.17734505f, 0.20161572f, -0.09893742f, 
    -0.01453538f, 0.10730203f, -0.02327966f, 0.06321715f, -0.09334265f, 0.07826275f, 0.12628447f, -0.01418457f, 
    -0.16999708f, -0.03866494f, -0.01172945f, -0.16135758f, -0.06873240f, 0.01132182f, -0.04432862f, -0.07146966f, 
    0.01217045f, 0.08979333f, 0.11016800f, -0.01927534f, 0.15778758f, 0.04020702f, 0.05302271f, -0.11259627f, 
    -0.03914234f, 0.01271434f, -0.02891129f, 0.06919206f, -0.00914835f, -0.01841196f, 0.02991484f, 0.07376049f, 
    -0.09401122f, 0.21195650f, 0.13273285f, 0.09281347f, -0.00827634f, -0.02998455f, 0.07713839f, 0.05154138f, 
    0.11128124f, -0.05385099f, -0.05718017f, -0.17725375f, 0.12064373f, 0.08767590f, -0.04226936f, -0.01295621f, 
    0.18104169f, 0.10511032f, 0.03689060f, -0.02246726f, -0.07175217f, -0.08038764f, 0.13256930f, 0.00076130f, 
    0.04846161f, 0.06532288f, 0.07172809f, 0.05673155f, -0.05552686f, -0.10344379f, -0.06585569f, -0.01390435f, 
    0.04107959f, 0.10441421f, -0.01711309f, -0.02373300f, -0.25448313f, -0.08023709f, 0.06230577f, -0.08356568f, 
    0.04407613f, -0.06746715f, -0.10788641f, -0.08844358f, -0.11977804f, -0.00599257f, 0.04927079f, 0.00312688f, 
    -0.06461145f, 0.08920152f, 0.06343388f, -0.17997426f, -0.14104830f, 0.04867791f, 0.01383824f, -0.04519481f, 
    -0.05200961f, -0.04652650f, 0.02572648f, -0.01929203f, -0.46633434f, 0.04848818f, -0.03304133f, 0.14192417f, 
    0.00229903f, -0.00002960f, 0.07012489f, 0.05389620f, -0.09020243f, -0.11499769f, 0.06906962f, -0.26265272f, 
    0.21491864f, -0.10063938f, -0.04029217f, 0.24737656f, 0.05244578f, -0.13103476f, 0.02047610f, 0.02661694f, 
    0.02851607f, -0.09654494f, -0.08866013f, 0.04488557f, -0.04874926f, 0.01686612f, 0.15767643f, -0.11451272f, 
    -0.07791711f, -0.02266386f, 0.01600992f, 0.02027436f, 0.01278661f, -0.06178364f, -0.05333614f, -0.04468063f, 
    -0.20239137f, 0.04764909f, 0.19713505f, 0.05426186f, 0.00656420f, -0.01864599f, -0.04236669f, -0.06657924f, 
    -0.07768589f, 0.04165364f, -0.00166175f, 0.08478733f, -0.50058109f, 0.06144563f, 0.02731544f, -0.06711698f, 
    -0.15479553f, -0.00147329f, 0.09825052f, 0.07225713f, -0.07172150f, 0.16253832f, 0.06657722f, 0.05073236f, 
    -0.10880990f, 0.24781239f, 0.12827079f, -0.10631020f, 0.04142255f, 0.11027925f, 0.04985863f, 0.02015468f, 
    0.01509858f, 0.04744911f, -0.07536957f, -0.09078542f, 0.00672058f, -0.26294285f, -0.26553151f, 0.17006733f, 
    0.01154708f, 0.01437843f, 0.09332852f, -0.07524297f, -0.03563333f, -0.09134325f, -0.02244380f, -0.03819848f, 
    0.00740683f, 0.10183883f, 0.04661662f, -0.24065337f, 0.19959444f, 0.00030826f, 0.10758209f, 0.10249270f, 
    -0.04999603f, 0.08661234f, -0.14704336f, 0.07020421f, 0.02289973f, 0.03918223f, 0.06836140f, -0.28816953f, 
    -0.11064401f, 0.00989184f, -0.11950699f, 0.03700563f, 0.04915479f, -0.01121244f, 0.00788118f, -0.18593977f, 
    -0.03614236f, 0.16143206f, -0.23160367f, -0.03144018f, 0.03604551f, 0.03183227f, 0.07891741f, 0.02379836f, 
    0.06364665f, 0.19077715f, 0.19747469f, -0.19571103f, -0.42781028f, 0.06534305f, -0.10555959f, 0.31497404f, 
    0.09992406f, 0.08088139f, 0.02527153f, -0.01458946f, 0.03704186f, 0.01818515f, 0.06795172f, -0.05477378f, 
    0.39304441f, -0.10722898f, -0.00644409f, -0.14216936f, -0.05479861f, 0.09929602f, 0.01866842f, -0.11517581f, 
    -0.08231482f, 0.03543299f, 0.00134628f, 0.10462245f, 0.26803094f, 0.08988075f, 0.07324200f, -0.08104670f, 
    -0.10249938f, -0.05304426f, -0.04149728f, -0.04546819f, -0.04312495f, 0.00361916f, 0.11891690f, 0.15546377f, 
    -0.07562089f, 0.05882788f, -0.06394473f, 0.32133037f, -0.04987113f, 0.13947059f, 0.11221042f, 0.00212038f, 
    0.00464421f, -0.09077811f, -0.06023843f, 0.02835415f, 0.17781842f, -0.17715223f, -0.03046392f, 0.03033009f, 
    -0.01902690f, -0.00414313f, 0.11504691f, 0.07993864f, -0.01934250f, -0.03929268f, -0.00853185f, -0.06502350f, 
    -0.10024294f, 0.08477540f, -0.01236417f, 0.11367556f, -0.01238234f, 0.10549413f, -0.11937832f, 0.06870335f, 
    0.09757596f, -0.11257488f, 0.15268704f, -0.09326436f, 0.24283762f, -0.04259158f, 0.10512815f, -0.12092462f, 
    -0.02402114f, 0.03682414f, 0.02280121f, 0.09752611f, 0.02941034f, -0.05741363f, -0.01500628f, -0.08301870f, 
    0.07278645f, 0.09266644f, 0.14765655f, -0.10302608f, 0.04929949f, 0.11786144f, 0.05359643f, 0.00465931f, 
    0.08893610f, 0.01859644f, -0.08301754f, -0.07758041f, -0.22107677f, -0.09803449f, -0.16234852f, -0.14190233f, 
    -0.06256735f, -0.08931860f, 0.06844987f, 0.01272207f, -0.03438096f, -0.03476751f, -0.02208304f, -0.10836596f, 
    0.08011565f, -0.00313026f, -0.01500285f, -0.09936379f, -0.01551052f, 0.03289675f, -0.04835191f, -0.19680153f, 
    -0.17745827f, 0.05696908f, -0.01959110f, -0.21531583f, 0.02800859f, 0.19730893f, 0.03939098f, -0.32725692f, 
    0.00067485f, -0.00939676f, 0.05181035f, -0.00090761f, -0.00290046f, 0.03322017f, -0.01174231f, 0.05319611f, 
    0.13077672f, -0.29645965f, 0.17490357f, -0.07908928f, 0.02406301f, 0.03566917f, 0.11554199f, 0.00770051f, 
    0.11687784f, 0.01309535f, -0.01114283f, -0.00840277f, -0.16396384f, -0.02218784f, -0.07234599f, -0.32517305f, 
    -0.14842924f, -0.04262480f, 0.00835761f, -0.20163344f, -0.10845368f, -0.07330824f, 0.01861719f, 0.01871346f, 
    -0.04466254f, -0.13656059f, -0.08306056f, -0.03576859f, 0.05463865f, 0.08379342f, -0.10694267f, 0.05181663f, 
    -0.00426502f, -0.16029090f, -0.03903968f, 0.08116843f, 0.03892994f, -0.24669309f, -0.11322831f, 0.00066792f, 
    -0.01710534f, -0.06995362f, -0.00276347f, -0.08938323f, -0.07960478f, -0.01292678f, -0.07712412f, 0.00153038f, 
    -0.05148359f, -0.28970054f, -0.12073537f, 0.21386844f, 0.12761399f, 0.05145361f, -0.09962510f, -0.03857879f, 
    -0.07169650f, -0.06039355f, -0.07234709f, 0.04945374f, -0.06300728f, -0.07426351f, 0.05938103f, 0.03603595f, 
    0.07030601f, -0.05288457f, -0.01409186f, -0.12020458f, -0.22858071f, 0.07564730f, 0.12202926f, -0.24244821f, 
    0.00388468f, 0.06715561f, 0.12175445f, 0.03074799f, -0.03986630f, 0.02477954f, 0.02406379f, -0.01377199f, 
    -0.06822719f, 0.07561872f, -0.03938860f, 0.00973924f, -0.07562421f, -0.03001188f, -0.14291662f, 0.08888593f, 
    -0.00924440f, -0.08343896f, -0.10911534f, -0.02094580f, -0.01401008f, -0.00373267f, 0.00176081f, 0.07063846f, 
    -0.24424143f, 0.13884038f, -0.16467950f, -0.10777237f, -0.08506478f, -0.00669196f, -0.01672541f, -0.01886267f, 
    -0.00089134f, -0.01544900f, -0.03565623f, -0.05581155f, -0.10022029f, 0.05328375f, -0.15067129f, -0.08588783f, 
    0.05070378f, -0.05787131f, -0.01116216f, 0.01484506f, -0.03746454f, 0.02856255f, -0.02096745f, -0.01512800f, 
    -0.18336141f, -0.01649541f, 0.02415372f, -0.13693586f, -0.00843368f, 0.01743620f, -0.05107616f, -0.08275281f, 
    -0.08618855f, -0.09180995f, -0.00980253f, -0.04672661f, -0.10396289f, 0.16991527f, 0.05687601f, 0.12802137f, 
    0.12323423f, 0.06874959f, 0.07545543f, -0.02774592f, 0.07718600f, 0.00210895f, 0.02614110f, -0.04209072f, 
    -0.33962351f, 0.16705012f, -0.07515841f, -0.00486697f, -0.07360891f, -0.01435882f, 0.00154491f, -0.01715447f, 
    -0.02019412f, 0.10167408f, 0.03753563f, -0.00903906f, 0.27854651f, -0.27406484f, 0.05277968f, -0.06704658f, 
    -0.01925744f, 0.05202156f, -0.00843819f, -0.02612719f, 0.02079067f, 0.12811810f, 0.04016617f, -0.04421497f, 
    -0.27705526f, 0.08732184f, -0.02912787f, -0.05190895f, -0.07491351f, -0.05549439f, -0.15162298f, 0.00756351f, 
    -0.01451217f, -0.00650495f, -0.02727372f, -0.04785094f, 0.11080831f, 0.02951852f, 0.03608802f, 0.12756623f, 
    -0.04492143f, 0.00880877f, -0.03162967f, 0.00838732f, 0.06897537f, -0.03551150f, -0.03674701f, -0.05949607f, 
    -0.15683991f, 0.04403871f, -0.03615250f, -0.06295941f, -0.06973152f, -0.02994949f, -0.06267483f, 0.03493287f, 
    0.01260642f, -0.03377235f, -0.05299389f, -0.04727707f, -0.10230011f, -0.05492241f, -0.06332730f, -0.11365831f, 
    -0.04060885f, 0.00691443f, 0.00477597f, 0.01089590f, -0.00830994f, -0.03871131f, -0.00817967f, -0.07276914f, 
    0.12309781f, 0.08900358f, 0.06793292f, 0.16048175f, 0.03073195f, -0.00903410f, -0.01617358f, 0.00643313f, 
    -0.06047206f, -0.03499364f, 0.03917565f, -0.04879751f, -0.14799586f, -0.04710215f, -0.12842277f, -0.14602545f, 
    0.00403269f, 0.00418505f, -0.08431254f, -0.03251874f, -0.01685841f, -0.01418172f, -0.02549494f, -0.09507675f, 
    0.03821172f, 0.09729212f, 0.17809752f, 0.06980085f, 0.05198127f, 0.03538140f, 0.06416122f, -0.05743818f, 
    -0.03797963f, 0.03730744f, 0.00774356f, -0.00342500f, 0.04453709f, 0.10623011f, 0.10245206f, 0.15918016f, 
    -0.00654107f, 0.04157550f, 0.00088594f, -0.04039377f, -0.02816992f, 0.01974762f, -0.02117248f, -0.12387967f, 
    0.01183830f, 0.05965523f, 0.12417752f, -0.00376200f, -0.04618360f, -0.00213271f, -0.02637166f, -0.06841197f, 
    -0.04037246f, -0.03267073f, -0.06216571f, -0.11821111f, 0.09992254f, 0.10643047f, 0.14847243f, 0.07198092f, 
    0.09177808f, 0.04339176f, 0.04602706f, -0.08603184f, -0.03237562f, -0.03062221f, -0.05559388f, -0.04226660f, 
    0.08435000f, 0.14416242f, 0.01207967f, 0.16139518f, 0.04026257f, -0.02393089f, -0.00113215f, 0.00656388f, 
    -0.01039079f, -0.03886351f, -0.04679349f, -0.07313022f, 0.05734909f, 0.03510138f, -0.03171778f, 0.16290900f, 
    0.06683374f, -0.07431667f, 0.03165512f, -0.09843297f, -0.02492503f, 0.03024630f, 0.01087725f, 0.00433508f, 
    0.17576635f, -0.06838606f, 0.10961781f, 0.00785730f, 0.09441829f, -0.03957593f, 0.00810133f, -0.04335593f, 
    -0.11129176f, -0.00461205f, -0.09270632f, -0.07490212f, 0.24494329f, 0.14388980f, -0.04502264f, 0.04418905f, 
    0.05090015f, -0.04270560f, 0.07211937f, -0.00559671f, 0.04738878f, 0.02553991f, -0.00013196f, 0.00030853f, 
    0.08704884f, -0.11557694f, -0.02058678f, 0.02072966f, 0.03098238f, -0.00984849f, -0.04078985f, -0.00255256f, 
    -0.01923592f, 0.05779508f, -0.06733118f, -0.02641399f, -0.07131470f, -0.12763795f, -0.08035453f, -0.12428883f, 
    -0.01109151f, 0.00212772f, -0.04611215f, -0.06628522f, 0.01444201f, 0.02904576f, 0.07267490f, 0.04759645f, 
    -0.05551793f, -0.05738993f, -0.02189408f, -0.22637331f, 0.01962683f, 0.00293737f, -0.09483685f, -0.11853316f, 
    0.00376361f, -0.02494405f, -0.01003527f, -0.02802252f, 0.02161330f, 0.12199712f, -0.15768886f, -0.20783706f, 
    -0.09452047f, -0.03265759f, 0.02617646f, 0.02170643f, -0.14377980f, -0.05531215f, -0.08070837f, -0.12130521f, 
    0.04391007f, -0.08768109f, -0.05643845f, -0.22910993f, 0.02941183f, -0.05102867f, -0.01341984f, -0.03468096f, 
    -0.02759138f, -0.00446458f, -0.01945576f, 0.01468333f, 0.02161658f, -0.21083330f, -0.02605357f, -0.01216823f, 
    -0.05634882f, -0.05967611f, -0.02856602f, -0.02689373f, -0.01973736f, -0.00969855f, -0.01564703f, -0.03950675f, 
    0.14045347f, 0.24342912f, 0.06610615f, -0.16073956f, -0.17871194f, 0.09678142f, 0.01788686f, -0.00042558f, 
    -0.02897213f, -0.04014828f, 0.02713488f, -0.01384400f, -0.04428212f, 0.07862148f, -0.00805884f, -0.15706141f, 
    -0.07790927f, 0.07025728f, -0.01686702f, -0.01468110f, -0.08972413f, -0.05626041f, 0.03401886f, -0.12189085f, 
    0.12694170f, 0.07687116f, 0.07343798f, 0.07759356f, 0.04562302f, -0.01675851f, -0.02638835f, -0.03603546f, 
    -0.04680144f, 0.00339803f, -0.00831028f, -0.00140087f, 0.05208813f, -0.18603507f, 0.03767265f, 0.18085073f, 
    -0.11386760f, -0.05954424f, -0.07054178f, -0.04876711f, -0.10210973f, -0.01641221f, -0.01361975f, -0.06465591f, 
    -0.09017731f, -0.08448777f, -0.06217925f, -0.19195174f, -0.03053991f, -0.03791534f, -0.00264346f, -0.05300739f, 
    0.04678154f, -0.05683405f, 0.00715955f, -0.01974586f, -0.07184401f, -0.22729303f, -0.01992556f, -0.08540560f, 
    0.06215512f, 0.00120182f, -0.02660240f, -0.02343080f, -0.00198752f, -0.07494079f, -0.03337577f, 0.03334152f, 
    0.07904547f, -0.14330275f, -0.05834988f, -0.15313362f, -0.04559279f, 0.02753752f, -0.00014646f, 0.01614449f, 
    -0.04979524f, -0.05930769f, -0.05284102f, 0.01265528f, 0.17035092f, 0.14961046f, -0.03338675f, 0.08317951f, 
    0.02367718f, -0.08787533f, 0.01007016f, -0.03028139f, 0.03607638f, -0.03446991f, -0.03432848f, -0.00572902f, 
    -0.01537968f, 0.12160105f, -0.02406406f, 0.02206543f, -0.00787528f, -0.01374700f, -0.01480835f, -0.00682432f, 
    -0.06679785f, -0.03738052f, -0.01491081f, -0.03670277f, -0.18119554f, 0.04406058f, -0.08819731f, -0.07453001f, 
    -0.02571477f, 0.03202435f, -0.07999185f, 0.00887073f, -0.06304450f, -0.06172859f, -0.02327140f, -0.03487338f, 
    -0.11763155f, -0.08983812f, -0.01184141f, 0.12358359f, 0.01738765f, -0.09186247f, 0.01229279f, 0.00891440f, 
    0.01506423f, 0.07287421f, -0.06163611f, -0.01005851f, -0.18829434f, 0.09640615f, 0.00023826f, -0.11255519f, 
    -0.00399495f, -0.02499308f, 0.02864246f, -0.04759241f, -0.02092480f, -0.02305273f, -0.07487218f, -0.07118018f, 
    -0.06662157f, -0.10403404f, -0.16856794f, -0.07510612f, -0.01506913f, 0.06026644f, -0.03346388f, -0.05622594f, 
    -0.06116135f, -0.01817575f, 0.04821552f, -0.01161668f, 0.21161304f, 0.06229177f, -0.04706756f, -0.03443013f, 
    -0.06190643f, -0.01824641f, -0.03663270f, -0.05294925f, -0.01511704f, -0.06830902f, -0.01185182f, 0.01154132f, 
    -0.28193125f, 0.08689349f, -0.11348057f, -0.07997064f, 0.02302156f, 0.01913952f, -0.00697793f, -0.01807357f, 
    -0.07294215f, -0.03992749f, 0.01496358f, -0.06681477f, 0.16826820f, 0.18336695f, 0.09230965f, 0.08883549f, 
    0.12295876f, 0.03605320f, 0.06805141f, -0.02375686f, -0.04147469f, 0.02036220f, 0.06369042f, -0.03333575f, 
    0.12147994f, -0.43279764f, 0.13954820f, 0.03672124f, -0.02951309f, -0.05041115f, -0.03040848f, -0.03654294f, 
    -0.01414037f, 0.01505820f, -0.02045771f, -0.00464169f, -0.18831556f, -0.00494345f, -0.13291089f, -0.01677084f, 
    -0.01214624f, -0.02434143f, 0.02479705f, -0.04018474f, -0.02884731f, 0.01044119f, -0.04561140f, -0.05845553f, 
    0.10572734f, 0.01361660f, 0.11367951f, 0.03323381f, 0.02878834f, 0.00206717f, 0.07480001f, -0.04267524f, 
    0.03321640f, 0.04215155f, -0.07526156f, -0.06973993f, -0.06572267f, -0.22743084f, -0.14102913f, 0.04185098f, 
    -0.01698494f, -0.05194924f, -0.01210716f, 0.02507307f, -0.03682857f, -0.00750821f, 0.01309342f, -0.04014291f, 
    -0.02310945f, 0.11130470f, 0.17490943f, 0.04609566f, 0.08812408f, 0.00234491f, 0.03638082f, 0.03852579f, 
    -0.10056043f, 0.03241009f, -0.00920709f, -0.04357427f, 0.15550418f, -0.15796672f, -0.07377467f, 0.00753792f, 
    -0.07166095f, -0.02055967f, 0.04564107f, -0.01251215f, -0.02245254f, -0.00551278f, -0.05894591f, 0.00907520f, 
    -0.16899246f, 0.19967967f, 0.19067046f, -0.04501417f, -0.10091474f, 0.02698292f, 0.03435468f, -0.02532329f, 
    -0.01106365f, -0.05757512f, -0.01714272f, 0.01496023f, -0.00508266f, -0.09660564f, 0.00495518f, 0.00450841f, 
    -0.01693686f, -0.00923825f, 0.00259120f, 0.04404580f, -0.11410838f, -0.03360233f, 0.06590375f, -0.15612808f, 
    -0.26667246f, -0.05456834f, -0.14722660f, 0.00500548f, 0.04844789f, -0.00133389f, -0.03866562f, -0.03237144f, 
    -0.04224307f, -0.01760762f, 0.01780500f, -0.06891397f, 0.24824020f, -0.19238819f, 0.13691469f, -0.03827977f, 
    -0.03166727f, 0.04270117f, -0.05040378f, 0.00861469f, 0.00006118f, -0.01917928f, -0.09125811f, -0.00467922f, 
    0.10229844f, -0.15256083f, -0.04699457f, -0.03285544f, -0.13140096f, 0.01088420f, 0.01825265f, -0.06401614f, 
    -0.01037534f, -0.02844226f, -0.00914444f, -0.00908567f, -0.07894740f, 0.13167128f, 0.02887140f, 0.05020102f, 
    0.04991756f, -0.01401238f, 0.03710934f, -0.08313591f, -0.02629840f, 0.01485983f, -0.08356515f, -0.00299995f, 
    0.08624879f, 0.17233886f, 0.16766366f, 0.12302160f, 0.13286033f, 0.08639465f, 0.02804268f, -0.00546057f, 
    -0.02515005f, 0.01433480f, 0.04650148f, -0.10699395f, -0.40222457f, 0.09217387f, -0.10414699f, -0.05458219f, 
    -0.05176231f, -0.05945605f, 0.00111812f, -0.04197698f, -0.06294820f, 0.00100136f, 0.08696118f, 0.00624003f, 
    0.28584638f, -0.12974404f, 0.11031993f, -0.06778912f, 0.01855535f, -0.03500981f, 0.01599679f, -0.08052412f, 
    -0.00364149f, 0.08182789f, -0.08284553f, -0.06303722f, 0.12384526f, 0.14643724f, 0.18044771f, 0.16884716f, 
    0.13138855f, 0.05196572f, 0.03521477f, 0.00312807f, -0.00422908f, 0.09523280f, -0.00098494f, -0.04842504f, 
    0.12825562f, -0.19006717f, -0.00057810f, 0.16007498f, -0.08928721f, -0.03863025f, -0.03238223f, -0.08315941f, 
    -0.01190811f, -0.01760248f, 0.06625434f, 0.01987279f, 0.25070080f, 0.04728043f, 0.17157987f, 0.17527412f, 
    0.09332996f, 0.02224999f, 0.00814149f, -0.03374322f, -0.03712035f, -0.05417573f, -0.04214314f, 0.00181262f, 
    0.30572709f, -0.21521373f, 0.14139807f, 0.20667389f, 0.05728225f, 0.06077091f, 0.01256988f, -0.08384896f, 
    0.02324546f, -0.18662386f, -0.00734412f, -0.04429433f, -0.00114102f, -0.05245171f, 0.02939742f, 0.03176669f, 
    0.06413342f, 0.02817860f, 0.02755765f, -0.00650885f, -0.00960761f, -0.05234247f, -0.00319565f, -0.02157157f, 
    -0.19904183f, 0.06194268f, 0.08663727f, -0.14555793f, -0.05990107f, 0.00622240f, -0.02304189f, -0.17520550f, 
    0.06775672f, -0.10152660f, -0.04232739f, -0.02732791f, -0.26832190f, 0.03097646f, -0.06143381f, 0.02903275f, 
    -0.09221619f, 0.04145449f, 0.06130880f, -0.00117007f, 0.05914044f, 0.09709659f, -0.05978389f, -0.08751194f, 
    0.07592015f, 0.08257671f, 0.00081760f, 0.25888211f, 0.17986813f, 0.02805392f, -0.05598494f, -0.04868026f, 
    0.07443941f, -0.04488349f, 0.08382076f, 0.04691848f, 0.09092160f, -0.15104119f, -0.00005280f, 0.01204540f, 
    0.07913353f, 0.02341303f, -0.06756590f, 0.06148700f, 0.09156087f, -0.00985813f, 0.06336743f, -0.12363245f, 
    0.22124560f, -0.08144717f, 0.00006626f, 0.15381108f, 0.15793845f, -0.04389123f, -0.07223264f, -0.08182675f, 
    -0.01259336f, -0.03825497f, -0.00721624f, -0.15655904f, -0.04758571f, -0.06567227f, 0.13301957f, 0.17116062f, 
    -0.00407398f, -0.12831497f, 0.07839396f, -0.03901567f, 0.10113611f, -0.19802412f, 0.00571261f, 0.05894648f, 
    0.07393266f, 0.11433006f, -0.16190973f, 0.04175487f, 0.04113217f, 0.00026557f, -0.05305749f, -0.05966869f, 
    0.04981358f, -0.09482631f, 0.09346317f, -0.03242662f, -0.06516699f, -0.18833038f, 0.18252850f, 0.05032664f, 
    -0.04639290f, -0.14543970f, 0.00263948f, -0.05083006f, 0.02448081f, 0.06235968f, -0.12554030f, 0.02755121f, 
    -0.04027920f, 0.06587732f, -0.30723989f, -0.04953393f, -0.06088369f, -0.03804229f, -0.06292946f, 0.00485570f, 
    0.07004734f, 0.03761823f, 0.11782887f, -0.06239788f, -0.08426619f, 0.07817793f, -0.01579567f, -0.22875755f, 
    0.00711800f, -0.10920743f, 0.08726765f, -0.10948624f, 0.00178305f, 0.03330135f, 0.02908713f, -0.16529766f, 
    0.18529250f, 0.01083558f, -0.05317923f, 0.07885598f, -0.04458092f, -0.10861829f, -0.09125907f, -0.05484313f, 
    -0.09200417f, -0.01430724f, -0.17174976f, 0.09543505f, 0.06023567f, 0.03090751f, -0.15715131f, 0.10081838f, 
    0.10831665f, -0.04954023f, -0.07593273f, -0.00523451f, -0.11548891f, -0.02423545f, 0.01898962f, 0.17164595f, 
    -0.21943213f, 0.00456057f, -0.06516895f, -0.26970783f, -0.02108795f, 0.02075764f, -0.04384929f, -0.00408012f, 
    0.02795900f, -0.11209174f, -0.14708555f, 0.10318187f, -0.13517265f, 0.00408005f, 0.07088329f, 0.21066016f, 
    0.06432032f, -0.00257623f, 0.00040975f, -0.00454412f, 0.01596947f, -0.01168003f, -0.11484715f, -0.00568307f, 
    -0.03038698f, 0.09653259f, 0.14062020f, 0.03456763f, -0.08560451f, -0.05536212f, 0.01326539f, 0.00213580f, 
    -0.02118886f, -0.00191827f, -0.00675495f, -0.13645273f, -0.18750648f, 0.17112561f, 0.05056005f, -0.17508624f, 
    -0.03523279f, -0.02993134f, 0.10891861f, -0.05077043f, 0.03165824f, -0.02806086f, -0.00201253f, 0.04520661f, 
    -0.29137692f, 0.09042604f, -0.05292010f, 0.07921711f, -0.11076250f, -0.06678466f, 0.04714754f, -0.04815788f, 
    0.04332763f, 0.04467019f, 0.11306155f, 0.03307946f, -0.22260933f, 0.04586071f, 0.06527966f, -0.07882641f, 
    -0.05335992f, 0.06608018f, -0.20436002f, -0.00188817f, 0.04718481f, -0.03874065f, 0.01940003f, 0.00988642f, 
    -0.02640720f, -0.13440922f, 0.05475540f, -0.20864858f, -0.07798365f, -0.03671422f, -0.13720919f, -0.03281119f, 
    -0.00187766f, -0.01527016f, 0.06702521f, 0.08734682f, -0.03821632f, 0.01745666f, -0.03277284f, -0.21096668f, 
    0.01825372f, 0.04624794f, -0.07443772f, -0.00213813f, 0.04267900f, -0.06499060f, 0.03375347f, -0.11753484f, 
    0.02959339f, -0.15310486f, -0.08839484f, -0.14550845f, 0.04159513f, -0.07903243f, 0.06684746f, -0.10536191f, 
    -0.02948212f, 0.02444546f, 0.06322941f, 0.12852293f, 0.06279328f, 0.14517352f, -0.07021276f, -0.02762844f, 
    -0.06569015f, 0.04777548f, -0.15820360f, -0.00821176f, -0.01301689f, -0.04553773f, -0.06222757f, -0.06329490f, 
    0.05366313f, -0.16195878f, 0.10237759f, -0.08962753f, 0.02509699f, -0.01819325f, 0.00657550f, -0.07783278f, 
    0.00331917f, -0.05137001f, 0.01682057f, 0.00466329f, 0.16859739f, 0.00728919f, 0.03951714f, 0.14841688f, 
    0.02693761f, -0.15697718f, 0.03182860f, -0.04601377f, -0.02286232f, -0.00947350f, -0.12912887f, -0.16143523f, 
    0.00081373f, -0.12887703f, 0.07658660f, 0.09798265f, 0.05923074f, 0.01618661f, 0.01942877f, -0.00349717f, 
    -0.03503256f, 0.03114268f, 0.02892002f, -0.01041630f, 0.00113610f, 0.04740620f, 0.06697604f, -0.02974312f, 
    -0.06492177f, -0.10569464f, -0.05331014f, -0.07123207f, 0.11162896f, -0.01342366f, 0.14470553f, -0.11198831f, 
    0.12696287f, -0.03438930f, 0.03767642f, 0.11592425f, 0.06435334f, 0.02507030f, 0.04259882f, -0.02902741f, 
    0.07499043f, 0.05623989f, -0.07524744f, 0.05168281f, 0.11532930f, 0.23594391f, -0.09933901f, 0.07499804f, 
    0.13199092f, 0.02485984f, 0.00551968f, -0.06362191f, 0.02939954f, -0.02327701f, -0.10735123f, -0.02200939f, 
    -0.14180896f, 0.17401242f, 0.02373672f, -0.19548318f, 0.00459800f, 0.00939996f, -0.02674035f, 0.17135826f, 
    0.05799878f, -0.13334943f, -0.02380895f, -0.03613155f, 0.03531068f, -0.05204733f, -0.00987376f, -0.00754132f, 
    0.08473603f, -0.08129705f, -0.06496365f, 0.01137540f, 0.02635504f, 0.08937075f, 0.01514088f, 0.14616215f, 
    -0.17642771f, 0.05220383f, 0.07119135f, 0.03921219f, 0.04691099f, -0.10385338f, 0.01218003f, -0.13807638f, 
    0.01237543f, 0.06323585f, -0.01044201f, 0.04394854f, -0.23891854f, -0.14573744f, -0.26703426f, -0.21385644f, 
    0.03350086f, -0.12428314f, 0.00267771f, -0.00655685f, 0.02182622f, 0.07853884f, -0.08292885f, -0.00185698f, 
    0.07249450f, -0.06783763f, 0.01640370f, 0.06610982f, 0.07246986f, -0.01614770f, -0.07283376f, -0.08614193f, 
    -0.05164519f, 0.03529407f, -0.01445897f, 0.07935725f, 0.08151578f, -0.07284444f, -0.11785662f, -0.01692319f, 
    0.10623325f, -0.05939584f, -0.09054249f, -0.01398775f, 0.10946169f, -0.00173194f, -0.12279233f, -0.00781026f, 
    0.20083922f, -0.00295502f, -0.21808320f, 0.07815295f, 0.04659289f, -0.01662013f, 0.03562990f, -0.04064591f, 
    0.01073141f, 0.07134830f, 0.10705574f, -0.08432593f, -0.07417464f, 0.06315185f, 0.03104983f, 0.07918976f, 
    0.05491863f, -0.06505518f, -0.04209627f, 0.03367077f, 0.01517967f, -0.06009277f, 0.05141219f, 0.01706429f, 
    -0.09327164f, -0.08568050f, 0.07776845f, 0.07258707f, -0.04893665f, -0.04718337f, -0.02150992f, 0.09630924f, 
    0.10160910f, 0.07536197f, -0.09530047f, -0.10210753f, 0.01746531f, 0.11299092f, 0.00254625f, 0.05952600f, 
    -0.02408809f, 0.03987018f, 0.03073183f, 0.06082652f, 0.04248610f, 0.08314683f, 0.01072798f, 0.02113637f, 
    0.08649079f, 0.11467128f, -0.33230737f, -0.01987031f, -0.01320834f, -0.05191768f, -0.07881187f, -0.04830332f, 
    0.02819410f, -0.08091599f, -0.00227663f, 0.08812169f, 0.17737389f, -0.07580224f, 0.02702115f, 0.15157321f, 
    0.07871781f, -0.09037291f, 0.01188497f, -0.12474498f, -0.05559819f, 0.00105693f, 0.10529298f, 0.03814564f, 
    0.00924638f, 0.03584628f, 0.05520565f, 0.00925544f, -0.02733026f, -0.04612390f, 0.03317160f, -0.03552062f, 
    0.04299569f, 0.03382665f, -0.08281978f, -0.11009031f, 0.17756769f, -0.10572597f, -0.00379766f, -0.01021622f, 
    0.02073001f, -0.08409280f, -0.01972831f, -0.04664368f, -0.08674978f, 0.09839561f, -0.07971726f, 0.06007579f, 
    0.05466718f, -0.23017919f, 0.04716486f, 0.13190304f, 0.05382863f, 0.03488809f, -0.07123452f, -0.05615100f, 
    -0.05262346f, -0.06221206f, 0.10175410f, 0.01602845f, 0.13889922f, 0.00065571f, 0.02768558f, 0.12729226f, 
    -0.01990141f, -0.11744433f, 0.01398813f, -0.02389148f, -0.03208194f, 0.00262663f, -0.00410730f, -0.00898964f, 
    -0.08760104f, -0.14137079f, -0.17803065f, 0.05380171f, 0.17403881f, -0.05231992f, 0.02253022f, -0.03913737f, 
    0.00168858f, 0.03063636f, 0.07129592f, 0.06840663f, -0.06179327f, -0.00870954f, -0.01181107f, 0.22068188f, 
    0.06267567f, 0.04693536f, 0.00322817f, -0.08045172f, 0.03070980f, 0.07010968f, 0.02955895f, 0.02223049f, 
    -0.22902639f, -0.27275726f, -0.10269806f, -0.34836715f, 0.02191370f, -0.06752565f, -0.06471439f, -0.05241433f, 
    0.05059354f, -0.14115646f, 0.07035463f, 0.07910796f, 0.26971659f, 0.14744079f, -0.34349954f, -0.14974183f, 
    -0.00881960f, 0.02711155f, 0.05157687f, -0.09416299f, -0.03104271f, -0.05018754f, -0.14262304f, 0.07823312f, 
    0.07460681f, -0.05262443f, 0.02008203f, 0.05199511f, -0.11796022f, 0.04829920f, 0.03457129f, -0.04950090f, 
    -0.00528998f, 0.02406684f, -0.12770195f, -0.02153311f, -0.23193826f, -0.11929977f, -0.22675140f, -0.05417853f, 
    0.08056603f, 0.00734504f, -0.13382098f, -0.06512272f, 0.01629962f, -0.01336724f, 0.06679501f, -0.10175018f, 
    0.21550919f, -0.03436718f, 0.01300011f, 0.00282115f, -0.03839267f, -0.16619934f, -0.14195047f, 0.01019823f, 
    0.06890043f, -0.00546688f, 0.08928069f, -0.14412473f, -0.05840096f, -0.03952256f, 0.00208354f, -0.10982008f, 
    -0.15795144f, -0.16852050f, 0.10376106f, 0.21721776f, -0.02008610f, 0.06675956f, -0.04069005f, -0.05397275f, 
    -0.09681531f, 0.06160147f, -0.06954931f, -0.08887873f, 0.02867834f, 0.02722897f, -0.08493119f, 0.00874807f, 
    0.09937617f, -0.02383970f, -0.06214261f, 0.02976005f, -0.02792802f, -0.30248335f, -0.10041442f, -0.13980439f, 
    0.07068435f, -0.01053132f, -0.08693811f, -0.17314512f, -0.12269524f, 0.05863330f, 0.02344381f, 0.03029705f, 
    0.00903195f, -0.02478773f, -0.01985512f, 0.07311745f, 0.01257454f, 0.04180726f, 0.00215099f, 0.00234630f, 
    0.03521143f, 0.02842894f, 0.04547249f, 0.02309802f, -0.12552297f, 0.06817635f, 0.17122574f, 0.10286261f, 
    -0.19528016f, 0.07443817f, -0.10287294f, -0.09913300f, -0.00697844f, 0.00437080f, 0.05864618f, -0.06563344f, 
    -0.07793633f, -0.04569600f, 0.01944299f, -0.07246084f, -0.09897413f, -0.04731338f, 0.05950659f, -0.10994332f, 
    -0.02889045f, 0.03734760f, 0.01033480f, 0.11509231f, -0.19291772f, -0.14103286f, 0.04490818f, 0.12895238f, 
    0.09076773f, 0.03431410f, -0.04365671f, -0.05274278f, 0.04037321f, 0.06761859f, -0.06722773f, 0.01621394f, 
    0.11872960f, -0.24386458f, 0.03315673f, -0.04432906f, -0.05912570f, -0.03798879f, -0.02389420f, -0.02425932f, 
    0.04478771f, 0.10969201f, 0.02041532f, 0.07256375f, -0.21523033f, -0.03665592f, 0.23950423f, 0.01095003f, 
    -0.06542012f, 0.09341905f, -0.01091481f, 0.03982517f, 0.01892480f, -0.01970391f, -0.01875232f, -0.00756813f, 
    -0.04693721f, -0.09102372f, -0.17315942f, -0.29050323f, -0.03651714f, -0.02298016f, 0.03893013f, -0.05498945f, 
    0.08940237f, 0.11564952f, -0.01921143f, 0.09811821f, 0.11691272f, 0.05429029f, -0.09987064f, -0.04420994f, 
    -0.08181542f, 0.09735558f, 0.01819433f, -0.11533507f, 0.04487073f, 0.05888255f, 0.15994518f, 0.06342728f, 
    0.12905942f, 0.02172713f, -0.07455818f, 0.01547916f, -0.00840472f, -0.01627215f, -0.06555450f, 0.02257587f, 
    0.05414877f, 0.02500740f, -0.00684380f, 0.04947262f, 0.07158443f, -0.06457230f, 0.11404828f, 0.05809822f, 
    0.05942648f, 0.03242329f, -0.05471059f, 0.04669667f, 0.00927065f, 0.01230691f, 0.08600923f, -0.01301320f, 
    0.07099061f, -0.32496974f, 0.00885574f, 0.21193431f, -0.08528519f, 0.09461201f, -0.06474295f, 0.05480561f, 
    -0.07192753f, 0.14994285f, -0.01578026f, 0.00073876f, -0.02265285f, 0.04840111f, -0.23684455f, -0.07416806f, 
    0.00438134f, 0.05902251f, -0.08754815f, 0.13672584f, -0.15913248f, -0.15487465f, 0.02362383f, 0.02965870f, 
    -0.23987213f, 0.31807035f, -0.19737048f, -0.25754103f, 0.11632438f, 0.05497136f, -0.03005698f, 0.04442970f, 
    -0.08585776f, -0.00898451f, -0.14386126f, -0.04583446f, -0.15743688f, -0.02957301f, 0.05763004f, -0.27467838f, 
    0.00393106f, -0.10149465f, -0.00845574f, -0.18640751f, -0.07766473f, -0.07972274f, 0.12899426f, -0.03591304f, 
    -0.08881665f, -0.04162938f, -0.01121361f, -0.09508801f, -0.04983427f, 0.03047885f, -0.03011854f, 0.01935260f, 
    0.08471908f, 0.06353793f, 0.08024894f, 0.04223983f, -0.38878512f, -0.35898614f, 0.01280358f, -0.22672808f, 
    0.06861924f, 0.02687071f, 0.00903550f, 0.08160535f, 0.03814819f, -0.04215420f, 0.09416646f, -0.01822883f, 
    -0.39543343f, 0.25414610f, 0.29640543f, -0.06263515f, 0.03568043f, 0.02727397f, 0.02126716f, -0.08613686f, 
    0.01678982f, 0.01215465f, -0.00140643f, -0.06901853f, 0.41355103f, 0.04539112f, -0.13973936f, 0.13267896f, 
    -0.03205961f, -0.02488814f, 0.03056909f, 0.02238088f, 0.07203187f, -0.04659551f, 0.07213372f, -0.01199651f, 
    -0.24688450f, 0.09861743f, 0.09947474f, -0.09378950f, 0.02432314f, 0.03560995f, 0.04884324f, 0.01643873f, 
    -0.02826596f, -0.00515520f, -0.14226219f, 0.02367605f, 0.16453490f, -0.20666489f, -0.06153665f, -0.01015011f, 
    -0.03994817f, 0.05263047f, 0.09631276f, 0.00338318f, 0.04636557f, -0.09917365f, -0.06118213f, -0.04329447f, 
    -0.23190017f, 0.09372938f, 0.05348081f, 0.08689940f, 0.06014639f, 0.14108363f, 0.12219226f, 0.07513160f, 
    0.17487387f, 0.08043306f, 0.01724633f, 0.04902381f, -0.01102880f, -0.06626628f, 0.17040206f, 0.00853465f, 
    -0.01037178f, -0.16578268f, 0.07329076f, -0.09441496f, 0.02045741f, 0.04279904f, -0.04190901f, 0.03501358f, 
    0.27975467f, 0.04221287f, -0.05865938f, 0.00042831f, 0.08617485f, -0.03250791f, -0.01727230f, 0.13226260f, 
    -0.04008377f, -0.03316168f, 0.16180314f, 0.06030837f, -0.22684641f, 0.08656347f, -0.09138497f, -0.22621679f, 
    0.13135834f, -0.06294831f, 0.00074191f, -0.06373301f, 0.02921746f, -0.00227688f, -0.01065264f, 0.03762966f, 
    0.00368302f, -0.04469299f, 0.01906174f, 0.06519192f, 0.02112423f, -0.01644876f, -0.11015166f, 0.08604411f, 
    -0.01195823f, 0.11238321f, -0.06132923f, 0.00222882f, -0.07705530f, -0.12224670f, 0.15010630f, 0.00381903f, 
    0.08408121f, 0.00390732f, -0.04623499f, -0.04532099f, 0.01805842f, 0.03067246f, 0.04596840f, 0.07633691f, 
    -0.28188628f, 0.14881103f, -0.03003877f, 0.07529327f, -0.08248248f, 0.02367152f, 0.08671299f, -0.05638991f, 
    -0.01438747f, 0.06648565f, 0.12621060f, 0.03494164f, -0.04230549f, -0.40835789f, -0.08147079f, 0.13554597f, 
    0.02986107f, 0.01951408f, 0.03212446f, -0.04937847f, -0.01866200f, 0.03942022f, -0.01092650f, 0.00619445f, 
    0.07300406f, -0.27424550f, -0.02313434f, 0.03392025f, 0.01010641f, -0.05844596f, 0.01156989f, 0.08984812f, 
    0.05562188f, 0.01278428f, 0.04451404f, -0.00281944f, -0.04617190f, -0.30170575f, 0.20183374f, 0.14483498f, 
    -0.02247940f, -0.15115821f, 0.12080241f, -0.01429773f, -0.00260819f, -0.02309232f, 0.06494384f, 0.09923045f, 
    -0.04860564f, -0.14266457f, 0.04077983f, -0.05618933f, -0.03379309f, 0.01929008f, -0.01631800f, -0.01819266f, 
    -0.02502637f, -0.01903372f, -0.15562439f, 0.02824254f, -0.30161542f, 0.09869045f, 0.29329950f, 0.00656565f, 
    -0.05889281f, -0.01164898f, 0.04080725f, 0.15767907f, 0.03049836f, 0.02227764f, 0.08005416f, 0.06676351f, 
    0.60921627f, 0.07443137f, -0.10117207f, -0.21339704f, 0.01678035f, 0.01728113f, 0.00259424f, -0.09526511f, 
    -0.05965779f, 0.10096968f, 0.00048112f, 0.10688164f, 0.08748362f, -0.10362580f, 0.09814630f, -0.08026287f, 
    0.14987759f, 0.05081927f, -0.14484428f, -0.15312497f, -0.02992537f, -0.06295310f, 0.04749005f, 0.12044960f, 
    0.10054155f, -0.03485855f, 0.15290105f, -0.02580789f, 0.01478126f, -0.02458346f, -0.03494953f, -0.04496799f, 
    -0.07244550f, -0.02036603f, -0.05982323f, 0.03249689f, 0.01950085f, 0.21963546f, -0.13486788f, -0.21483511f, 
    -0.01251564f, 0.03003175f, 0.10917283f, 0.05052561f, -0.03870276f, -0.01399385f, 0.02129841f, -0.01050989f, 
    -0.03286771f, -0.07121374f, 0.05459145f, -0.19558313f, 0.05707268f, 0.07344268f, -0.03245218f, -0.14460947f, 
    -0.07427584f, -0.12432303f, -0.06594454f, -0.06108141f, 0.07906350f, -0.21902269f, 0.16182980f, -0.04897796f, 
    0.12724130f, -0.00556259f, -0.06452510f, -0.06633482f, -0.01021248f, 0.06852084f, -0.03981193f, -0.03268993f, 
    -0.55706257f, -0.03484471f, -0.08052004f, 0.16476105f, -0.06573056f, 0.09344158f, -0.10547177f, -0.00592574f, 
    -0.07013546f, 0.16557936f, -0.00672803f, 0.10332315f, -0.15759291f, 0.03164696f, -0.06310929f, 0.02006345f, 
    0.07030617f, 0.04733297f, 0.04045805f, -0.02264148f, 0.04483203f, -0.18806036f, 0.08452076f, 0.00609870f, 
    -0.09521049f, -0.21939979f, 0.03175528f, 0.16735236f, 0.00019595f, 0.06568785f, -0.02901355f, 0.15904832f, 
    0.01506906f, -0.13691397f, -0.03453965f, -0.14676107f, -0.10053931f, 0.03467654f, -0.10661857f, -0.15955447f, 
    -0.07083270f, 0.04759098f, -0.08794724f, 0.02423324f, -0.01108152f, -0.09099655f, -0.00012772f, -0.06454318f, 
    0.01639932f, 0.00559214f, 0.17073199f, -0.02030529f, -0.07327897f, -0.02639871f, 0.07993496f, 0.02756222f, 
    0.05793596f, 0.12792496f, -0.06014807f, 0.03764504f, 0.04890088f, -0.20582253f, 0.03502246f, -0.03689000f, 
    -0.05496439f, -0.00024806f, 0.01678667f, 0.00046046f, -0.02589681f, -0.07371570f, 0.00734568f, 0.03712788f, 
    0.08503549f, -0.07182269f, 0.08752154f, -0.02032686f, 0.04001481f, 0.08591700f, -0.00524303f, -0.11077386f, 
    -0.07054399f, 0.07708693f, -0.05039279f, 0.12052491f, -0.11045390f, -0.18183979f, 0.01526044f, 0.09990649f, 
    -0.04596345f, 0.04589200f, -0.02672397f, 0.09472564f, -0.04847115f, 0.02415246f, 0.09568465f, -0.02825230f, 
    -0.35807702f, 0.16399790f, 0.00459567f, -0.01466032f, 0.14181302f, 0.02950001f, 0.06903355f, -0.07528140f, 
    -0.00610833f, -0.04843686f, 0.01668600f, 0.16381480f, 0.55798757f, 0.11338313f, 0.14536870f, -0.13270371f, 
    -0.01464002f, 0.05516257f, 0.05040216f, -0.01664654f, -0.17307191f, -0.11325326f, -0.08125938f, -0.13323784f, 
    0.06074564f, 0.08276515f, 0.13809074f, -0.19095902f, 0.10509121f, 0.05125936f, -0.06664172f, 0.05547560f, 
    0.01514016f, 0.10731494f, 0.12419469f, -0.05115566f, -0.04827305f, -0.00045878f, -0.08929990f, 0.03650317f, 
    0.08064280f, 0.10124651f, 0.09543653f, 0.03465607f, 0.06479701f, 0.01366987f, -0.07644897f, 0.02601317f, 
    0.09628680f, 0.09744149f, -0.24162446f, 0.08572628f, 0.00286096f, 0.11013889f, -0.09723267f, -0.06300180f, 
    -0.00574828f, -0.08874549f, -0.01741315f, -0.07759921f, -0.00042311f, 0.18819515f, -0.18689200f, 0.02715594f, 
    -0.02380733f, -0.04923445f, -0.06525461f, 0.01722669f, -0.02134743f, 0.06629365f, 0.05795071f, -0.05424619f, 
    -0.26577818f, 0.04953294f, 0.02125734f, -0.18070227f, -0.00137105f, 0.04234477f, -0.09353529f, -0.04148774f, 
    -0.06878208f, 0.01888014f, -0.03541395f, -0.09366561f, 0.05053397f, -0.07228266f, -0.02806233f, -0.08789593f, 
    0.05815006f, 0.09194751f, -0.14893633f, 0.10447712f, 0.00101085f, 0.07546592f, 0.02197572f, 0.03339297f, 
    -0.00167118f, -0.14664131f, 0.14509757f, -0.18895534f, -0.08621773f, -0.00187287f, -0.17707540f, -0.05149059f, 
    0.03813392f, 0.04126864f, 0.10399359f, -0.07108438f, -0.05140655f, 0.19303428f, -0.37057897f, -0.26883635f, 
    0.12599143f, 0.00489813f, 0.03541095f, 0.12626886f, -0.10832002f, -0.05036859f, -0.11414256f, -0.04131726f, 
    -0.14273517f, -0.11370737f, 0.08383299f, 0.00688795f, -0.02642269f, -0.01525172f, 0.03702374f, -0.02030908f, 
    -0.03266783f, -0.07615333f, -0.14169309f, 0.01888022f, 0.44797325f, -0.02543578f, 0.19344239f, 0.17949896f, 
    -0.00346061f, 0.06847669f, -0.06418641f, 0.01862512f, -0.01047746f, -0.01688250f, 0.03511073f, -0.00379850f, 
    -0.18251663f, -0.20503777f, 0.04573362f, 0.17138901f, 0.11151554f, -0.10853028f, 0.02616675f, -0.03186865f, 
    0.12818909f, 0.02573822f, 0.01971699f, 0.07976118f, -0.11454213f, -0.12937039f, -0.22202247f, 0.02812584f, 
    -0.01153350f, -0.04970301f, 0.04939752f, -0.03034239f, -0.07294769f, -0.00522295f, -0.00636561f, 0.09427251f, 
    -0.55854946f, 0.07076625f, -0.00406309f, -0.06468916f, 0.16702117f, -0.05498796f, 0.10073807f, -0.09981278f, 
    0.00800010f, -0.00067124f, 0.03381012f, 0.15891002f, -0.07494317f, 0.12645958f, 0.00709329f, -0.12426657f, 
    0.05599271f, 0.05991745f, -0.01120784f, -0.00882705f, -0.04164355f, -0.01433483f, 0.03802806f, 0.14990512f, 
    0.07961746f, 0.00520433f, 0.08587395f, -0.02662483f, -0.00542630f, 0.14232476f, 0.09251928f, 0.04369565f, 
    -0.04362305f, -0.04197844f, -0.01610365f, 0.02483671f, 0.09954022f, 0.03685029f, 0.09424571f, 0.03574555f, 
    -0.01916919f, -0.12199656f, 0.03395652f, 0.00424226f, 0.08005609f, 0.00739351f, 0.05790178f, 0.06188035f, 
    0.03942832f, -0.17790888f, -0.14372435f, -0.11988054f, -0.00754252f, -0.09857193f, 0.09035560f, -0.13172916f, 
    0.00628464f, 0.10697712f, 0.05367944f, -0.07408344f, 0.28782150f, -0.10303456f, 0.04124680f, -0.16030726f, 
    0.13065243f, 0.13927394f, 0.10541110f, 0.02417468f, -0.07129277f, -0.05963327f, -0.03449741f, 0.00521140f, 
    -0.17914483f, -0.04360746f, -0.13558739f, 0.17829621f, 0.10395456f, 0.03116968f, -0.01684643f, 0.03557839f, 
    0.07198884f, -0.11970611f, 0.08516736f, -0.13393559f, -0.13359646f, 0.12929568f, -0.03026917f, -0.32915792f, 
    0.04971971f, -0.01215948f, -0.00354077f, -0.04401904f, -0.08951709f, -0.08947019f, 0.08507215f, -0.19064835f, 
    0.19888438f, 0.03610083f, -0.20504484f, 0.13575505f, 0.08050868f, -0.03946466f, 0.00018452f, 0.04100227f, 
    -0.00428077f, -0.04332990f, -0.15819989f, 0.00340926f, 0.04040459f, -0.18884826f, -0.16928929f, 0.04971939f, 
    -0.01120900f, 0.02138939f, -0.02886117f, -0.05317730f, -0.11633900f, 0.02926864f, -0.04886016f, -0.04268953f, 
    0.08323944f, 0.00314149f, -0.17076842f, -0.30552593f, 0.03166321f, -0.06624418f, 0.06095222f, -0.07458567f, 
    -0.02834247f, -0.00914910f, 0.09793614f, -0.07271644f, 0.03027172f, -0.31258783f, 0.04259093f, 0.08002099f, 
    0.02716779f, -0.03490769f, -0.12573704f, 0.00409733f, -0.13889316f, -0.03601704f, -0.01040555f, 0.07848016f, 
    0.04581185f, -0.62203616f, 0.18060444f, -0.12319943f, 0.03652317f, -0.10288814f, 0.05595740f, -0.00375023f, 
    -0.11819682f, -0.01971236f, 0.18673907f, -0.09034064f, 0.33759928f, -0.01367094f, -0.05846735f, -0.11976080f, 
    0.03155556f, -0.15478507f, 0.08848129f, -0.18031871f, -0.02248789f, 0.13085744f, -0.16232309f, 0.08400501f, 
    0.15568069f, 0.04921569f, -0.00562472f, -0.03546476f, -0.03913957f, 0.08123819f, 0.04895346f, -0.00718753f, 
    0.02945131f, -0.02165797f, -0.00463127f, -0.02444774f, -0.07795085f, 0.11801482f, 0.12727417f, -0.02226922f, 
    0.04528026f, -0.04941867f, 0.04718079f, 0.03361329f, 0.08709227f, 0.04766979f, -0.03148326f, -0.06427215f, 
    -0.34802666f, -0.11848309f, -0.24388333f, -0.23429054f, 0.07799352f, 0.02046858f, -0.06349406f, 0.02376741f, 
    -0.04005168f, -0.06395896f, 0.13116828f, 0.04486009f, -0.42899975f, 0.11260732f, -0.03659717f, 0.01006492f, 
    0.05555095f, 0.07096633f, -0.12813817f, 0.01502997f, 0.03190997f, 0.00700144f, -0.02917796f, -0.01188334f, 
    -0.28016472f, -0.07995574f, -0.27938461f, -0.11462115f, 0.08252326f, 0.02589308f, -0.11805836f, -0.06037879f, 
    0.04566487f, -0.11352985f, -0.03764949f, -0.05864688f, -0.05274158f, 0.11636201f, -0.10073938f, 0.05014138f, 
    -0.02774723f, -0.11066820f, -0.04938260f, -0.04477788f, -0.09228058f, -0.00444200f, -0.08746654f, -0.00489268f, 
    -0.47369188f, -0.32782540f, 0.01693701f, 0.01438261f, 0.12713206f, 0.02756506f, 0.06353009f, -0.07291328f, 
    0.17352781f, -0.00467165f, 0.08303945f, -0.02104288f, 0.14000382f, -0.03382475f, -0.18239222f, 0.00687503f, 
    0.00612180f, -0.04988625f, -0.13742995f, 0.05616355f, -0.05075647f, 0.03407411f, 0.00581483f, -0.00228799f, 
    0.07378522f, -0.08033510f, -0.02007588f, 0.03333410f, 0.13037539f, 0.14135587f, 0.06985859f, -0.01490277f, 
    0.05875012f, 0.13923755f, 0.10666741f, 0.00293740f, 0.24195996f, 0.10801509f, -0.09751732f, 0.04423235f, 
    -0.07086844f, -0.00487337f, 0.01931052f, -0.06845567f, 0.01005364f, 0.10443521f, -0.03054995f, 0.08290166f, 
    -0.18228324f, -0.01620902f, -0.14034182f, -0.09055631f, 0.04945939f, -0.07342365f, 0.09243917f, -0.11175968f, 
    0.04106022f, -0.25579295f, -0.26327208f, 0.02436065f, -0.30756932f, -0.20324343f, -0.01945420f, -0.01746796f, 
    0.10706466f, 0.11381724f, -0.11328129f, 0.04861986f, 0.07854493f, -0.15389368f, 0.00186848f, -0.07196843f, 
    -0.08504120f, -0.01524093f, 0.11713354f, -0.12538074f, 0.04611370f, 0.05789112f, 0.10063909f, 0.04009737f, 
    -0.02300043f, -0.08028027f, -0.06446640f, 0.05579717f, -0.02687503f, -0.18945099f, -0.18464439f, -0.16868562f, 
    -0.04058772f, -0.07884248f, -0.02389544f, 0.05202949f, -0.02635634f, 0.00118667f, -0.00371327f, 0.02403085f, 
    0.29535815f, 0.04867766f, -0.02413716f, -0.09325294f, -0.13856474f, -0.05257687f, 0.11552689f, 0.00602059f, 
    0.00570495f, -0.03592323f, -0.05622618f, -0.11746173f, 0.07752836f, -0.00794288f, 0.01865435f, 0.07941462f, 
    -0.03478214f, 0.02494448f, 0.01914352f, -0.09757971f, 0.09502333f, 0.12378559f, 0.00025322f, 0.03898520f, 
    -0.01172169f, -0.15905428f, -0.03900049f, 0.13182865f, 0.05146931f, -0.08407015f, -0.08494562f, 0.11657955f, 
    -0.08077017f, 0.03029566f, -0.05903072f, -0.03112509f, 0.23941800f, 0.00104233f, 0.03108542f, -0.08882850f, 
    -0.04017227f, 0.08568177f, -0.10088213f, 0.00957592f, -0.00856590f, 0.08739700f, 0.02381226f, -0.03361751f, 
    0.14580992f, 0.18969238f, 0.04848554f, -0.11543822f, 0.10617362f, 0.06688041f, 0.06248438f, -0.02825342f, 
    -0.12741104f, 0.02060355f, 0.05244827f, 0.07090558f, -0.06004367f, -0.03381952f, -0.01193358f, -0.06534249f, 
    -0.09585156f, 0.13405594f, -0.00832630f, 0.00149620f, -0.07081757f, 0.05206036f, 0.13031000f, -0.03376189f, 
    0.13476962f, 0.06161240f, -0.08034857f, -0.01819933f, -0.01402093f, -0.02268529f, 0.07378745f, 0.00258393f, 
    0.02639333f, 0.02438613f, 0.14997093f, 0.03094020f, 0.06593357f, -0.14915231f, 0.05728024f, -0.08710632f, 
    -0.17476405f, 0.03824039f, -0.00595574f, 0.02957250f, 0.07466775f, -0.10794189f, -0.11936770f, -0.10374977f, 
    -0.00676566f, 0.06043367f, 0.08377334f, 0.29319406f, -0.11114392f, -0.05859059f, 0.03936836f, 0.02241663f, 
    0.12591420f, 0.00749354f, 0.08170611f, -0.12891290f, -0.06246864f, -0.06145968f, -0.19534832f, -0.11745240f, 
    0.02373473f, -0.12029372f, -0.05562992f, -0.02505049f, 0.04486801f, -0.01099830f, -0.13184053f, -0.03208745f, 
    0.06839214f, -0.07726495f, -0.08300719f, -0.15166669f, -0.05382095f, -0.09558574f, -0.14342313f, 0.06312949f, 
    0.12878111f, 0.07268983f, 0.01628523f, 0.06052348f, -0.42529255f, -0.24662727f, 0.04274874f, 0.15835659f, 
    0.01413805f, -0.07813876f, -0.06754445f, -0.15036871f, 0.06951400f, 0.07762404f, -0.01969540f, 0.08401822f, 
    -0.11713899f, 0.06684078f, -0.05800759f, -0.11738371f, 0.04347630f, 0.00065030f, 0.07399528f, 0.07717697f, 
    0.04017561f, 0.12050561f, 0.05186863f, 0.12769079f, -0.12446886f, -0.10425904f, 0.01246108f, -0.16147903f, 
    -0.01842648f, 0.04803462f, -0.04288963f, 0.00086148f, -0.01122764f, -0.12350785f, -0.02279412f, 0.19008920f, 
    -0.06368302f, -0.16693944f, 0.06605531f, 0.02459512f, 0.03166782f, 0.15898488f, 0.07036176f, -0.00536388f, 
    0.00632139f, -0.02798776f, -0.12196744f, 0.07176226f, -0.45701098f, -0.39169350f, -0.07675992f, -0.03759488f, 
    0.07161651f, -0.04019567f, 0.08500106f, -0.06774814f, 0.07684140f, -0.04164694f, -0.03151296f, 0.12226964f, 
    0.16228519f, 0.03710301f, 0.03108398f, -0.10766538f, 0.02535376f, -0.04914919f, -0.00084830f, -0.04671757f, 
    -0.03843358f, 0.08743711f, -0.01854632f, -0.01212492f, 0.10268255f, 0.20992596f, 0.09650369f, 0.03637137f, 
    0.10204215f, -0.05583324f, 0.08368747f, 0.06882493f, -0.00841629f, 0.04331014f, 0.05092106f, -0.00906566f, 
    -0.33313569f, 0.00521240f, 0.10214639f, 0.09312506f, 0.11553230f, -0.05871470f, -0.02862154f, -0.08622488f, 
    0.00563410f, 0.06762538f, 0.01692025f, 0.07673953f, -0.34507209f, 0.02260180f, -0.06095741f, -0.01159603f, 
    0.07169802f, 0.04918356f, -0.06578144f, 0.11511785f, 0.10216535f, 0.06183045f, -0.04759411f, 0.08869550f, 
    -0.15061112f, -0.01032958f, -0.09410430f, 0.13210644f, 0.01652094f, 0.04121244f, 0.09112529f, 0.02008632f, 
    0.05808577f, 0.07311148f, -0.00279284f, -0.05257972f, 0.03469647f, -0.15449837f, 0.02754687f, -0.03635655f, 
    -0.00540307f, 0.05259827f, -0.00587595f, -0.01134902f, -0.06280275f, -0.00346136f, -0.05639102f, 0.08989564f, 
    -0.03811540f, -0.16739547f, 0.01896496f, -0.03773134f, 0.01659773f, -0.06347989f, 0.01621435f, 0.08187211f, 
    0.09316001f, -0.02058288f, -0.03474501f, 0.02446516f, -0.35930905f, -0.22017391f, 0.08607923f, 0.13951038f, 
    0.08180617f, -0.03573595f, 0.01412381f, -0.03495597f, 0.06229059f, 0.20162804f, -0.01324184f, 0.14531943f, 
    -0.46256441f, -0.18618365f, -0.02341348f, 0.00554027f, 0.18521367f, -0.00942484f, -0.07156439f, -0.13056502f, 
    -0.05239749f, -0.15043463f, 0.00805504f, 0.01178892f, -0.37424520f, -0.21961394f, -0.06731550f, -0.13860910f, 
    0.06393469f, 0.05354111f, -0.07949472f, -0.09493118f, -0.03074820f, -0.00714213f, 0.04432572f, 0.11209270f, 
    -0.32434699f, -0.16195774f, 0.09711805f, 0.05575990f, 0.05337564f, -0.02593098f, 0.06673445f, 0.02648075f, 
    0.06995078f, 0.05361853f, 0.08302625f, 0.09944054f, -0.14589737f, -0.19734685f, -0.11300249f, -0.07239418f, 
    0.04007641f, 0.08011588f, -0.09375050f, -0.02123460f, -0.05402566f, -0.12838329f, 0.01350209f, -0.02999874f, 
    -0.53540123f, -0.38890207f, 0.10916111f, -0.03110019f, 0.12899347f, -0.05397212f, -0.12328638f, 0.01220618f, 
    0.06339114f, 0.09287622f, -0.01160127f, 0.05448585f, 0.08587304f, 0.01804194f, -0.09909532f, -0.00521302f, 
    -0.13095415f, -0.10789669f, 0.00017396f, -0.04086445f, 0.02302468f, 0.01902076f, -0.13444558f, -0.00705640f, 
    -0.20566097f, 0.19738807f, 0.00499969f, -0.19966017f, 0.12664668f, 0.06304839f, 0.06908233f, 0.01694753f, 
    0.00346331f, -0.00785012f, -0.06671594f, 0.06701751f, -0.24551234f, -0.16314574f, -0.18321645f, -0.20537990f, 
    -0.03960266f, 0.03582731f, -0.01861748f, -0.01639424f, 0.01423543f, 0.08695936f, 0.07955538f, 0.06203499f, 
    0.20525466f, 0.00834245f, 0.00271013f, 0.00215704f, 0.03292682f, -0.12971486f, 0.03708787f, -0.05401586f, 
    -0.06683958f, -0.23502833f, 0.02617670f, 0.00216061f, -0.32751045f, -0.10908029f, 0.13089532f, 0.10022240f, 
    0.08976930f, 0.09370132f, -0.01371568f, -0.06992722f, 0.04908248f, -0.03989539f, -0.18615423f, 0.12437305f, 
    0.22617553f, 0.20782964f, -0.18882602f, 0.14608651f, -0.08550888f, -0.03625660f, 0.03342200f, 0.02244540f, 
    0.06010383f, 0.03684957f, 0.05381110f, -0.14853309f, -0.25090224f, -0.15525256f, 0.01027268f, -0.04005581f, 
    -0.05747117f, 0.03993394f, -0.00369123f, 0.00312606f, -0.10758489f, 0.06416937f, -0.13088349f, -0.28058198f, 
    -0.20587645f, -0.31334412f, 0.07548472f, -0.15841055f, 0.02426723f, -0.12465189f, -0.16033845f, 0.02961441f, 
    0.06373052f, 0.02286733f, -0.06576435f, 0.08364353f, 0.08896034f, -0.05911901f, -0.02062995f, 0.08790907f, 
    -0.01185148f, -0.04833186f, 0.03691381f, 0.01409864f, 0.12169699f, 0.23472025f, 0.13470568f, 0.14547811f, 
    -0.14712656f, -0.08087086f, 0.10008394f, 0.07713323f, 0.07439854f, -0.08469821f, 0.06980186f, 0.12903087f, 
    -0.06912333f, -0.01648874f, -0.00318112f, 0.20866565f, -0.07200149f, 0.13652676f, 0.16457574f, -0.11314660f, 
    0.02851414f, 0.06288886f, -0.16006260f, 0.00964509f, 0.00948273f, 0.11584558f, 0.00757842f, -0.04556538f, 
    -0.11299425f, 0.06024109f, -0.08292699f, -0.01914163f, -0.05069987f, 0.09805159f, -0.00879570f, 0.13306722f, 
    -0.06962091f, 0.09315338f, 0.14632769f, 0.11901366f, 0.10201325f, 0.06951395f, 0.07606629f, 0.10605168f, 
    -0.00720786f, 0.04707470f, 0.05735926f, 0.07691710f, -0.04108384f, -0.03197854f, 0.04311573f, 0.03890381f, 
    0.08691163f, 0.06057693f, 0.02358631f, 0.08593961f, -0.06586579f, -0.00613675f, 0.04731860f, -0.05304293f, 
    0.08798030f, 0.09031248f, -0.03681333f, 0.18022677f, -0.30542934f, -0.05117174f, -0.03019765f, -0.32169870f, 
    0.04725824f, 0.00095860f, 0.01561722f, 0.06294555f, 0.06445757f, -0.07605774f, -0.06055905f, 0.05146725f, 
    -0.01128607f, 0.00495130f, -0.04687397f, 0.09378787f, 0.00269360f, 0.08306686f, -0.00909670f, 0.04935552f, 
    0.04393277f, 0.03818835f, 0.07367167f, 0.03326588f, 0.04823710f, 0.06646297f, -0.04587192f, -0.07543515f, 
    0.04153213f, 0.09224978f, 0.03720488f, -0.02210743f, 0.03742693f, 0.06895777f, 0.09258109f, 0.01043971f, 
    0.17657760f, 0.21010026f, 0.05939805f, -0.15735400f, 0.05131822f, 0.13288555f, -0.03306551f, 0.08410714f, 
    0.03694670f, -0.02916964f, -0.07787380f, 0.05260906f, -0.03952082f, 0.04315461f, -0.12124250f, -0.11561128f, 
    -0.07659914f, 0.07649874f, 0.11959244f, -0.00373623f, 0.01561255f, -0.04968229f, 0.08682861f, -0.14389816f, 
    -0.24153154f, 0.02170408f, -0.16694133f, -0.11591993f, 0.05761326f, -0.00346609f, -0.08663753f, -0.03601048f, 
    0.00586496f, 0.08537200f, -0.05974279f, 0.01690510f, 0.02384910f, 0.05108643f, -0.08022111f, 0.07064632f, 
    -0.00152426f, 0.07803009f, 0.05667250f, 0.04855466f, 0.06487051f, 0.07776771f, 0.11447130f, 0.06143754f, 
    -0.03999751f, 0.15613292f, 0.00165772f, 0.00637310f, 0.01078247f, -0.03106122f, 0.01324470f, -0.10530826f, 
    0.02258726f, 0.02639795f, 0.14673084f, -0.04578661f, 0.09606446f, -0.05387206f, -0.07501709f, 0.00301147f, 
    -0.02065489f, -0.07789062f, 0.07124844f, 0.02780307f, 0.08158374f, -0.04890886f, -0.00542374f, 0.10182599f, 
    0.27344370f, -0.15860438f, -0.26786232f, 0.06829418f, -0.00803961f, 0.02192862f, 0.04332640f, -0.04311094f, 
    -0.06935062f, -0.01497748f, -0.07808149f, -0.06607082f, 0.03440233f, -0.06685005f, -0.07313769f, -0.03626931f, 
    -0.06186639f, 0.08311924f, -0.01308363f, 0.03539220f, 0.11890336f, -0.10171336f, -0.03990621f, 0.03952073f, 
    -0.20202261f, 0.02830783f, -0.15926573f, -0.27417853f, 0.05115396f, -0.04626960f, -0.00602677f, 0.06161843f, 
    0.07502949f, -0.04385305f, 0.12363480f, 0.04517585f, -0.13557886f, -0.11595795f, -0.01932249f, 0.00388597f, 
    -0.04681525f, 0.16693765f, -0.06547430f, 0.12517935f, -0.05207636f, 0.01852787f, -0.04760535f, -0.05697215f, 
    0.21720302f, -0.08036549f, -0.13445914f, 0.04091265f, 0.02289006f, 0.00016236f, -0.11097612f, -0.10082810f, 
    0.02945889f, 0.05188343f, -0.04386834f, 0.02936588f, -0.39356101f, 0.17341660f, 0.07310253f, -0.15324022f, 
    0.02854635f, -0.06339567f, -0.06508228f, -0.02076212f, 0.01804672f, 0.01667587f, 0.04574825f, 0.01331370f, 
    0.23583427f, 0.16244982f, -0.17112710f, 0.16147213f, 0.17766580f, -0.04825924f, -0.14660384f, 0.13922176f, 
    0.04493722f, 0.03580235f, -0.03620405f, 0.03403942f, -0.04804707f, 0.10422200f, -0.18762025f, 0.19099021f, 
    -0.07954644f, 0.08565599f, 0.03154781f, 0.07710452f, -0.01138591f, -0.05931471f, -0.12648728f, 0.00039147f, 
    -0.44592959f, 0.01503466f, 0.00000767f, -0.18439217f, 0.06128550f, -0.00815778f, 0.05885819f, 0.14456357f, 
    0.11093740f, 0.06827189f, 0.05799147f, -0.03899891f, -0.02490884f, 0.21197934f, -0.15325034f, -0.01774508f, 
    -0.00913704f, -0.15108673f, 0.05180388f, 0.06748310f, 0.04600912f, 0.11618571f, -0.10382969f, -0.04637996f, 
    -0.16295618f, 0.20869698f, 0.06529646f, -0.10677711f, -0.11967252f, -0.04750323f, 0.00222003f, 0.07197990f, 
    -0.01817868f, -0.06048487f, 0.03724935f, -0.04089126f, -0.06793745f, 0.05964750f, -0.03643297f, -0.12177107f, 
    0.00882396f, -0.07864985f, 0.08143925f, 0.01728002f, 0.04442253f, 0.13458386f, 0.01837579f, 0.10080100f, 
    -0.14660990f, 0.04480144f, -0.04718564f, 0.12489587f, 0.04522244f, 0.03450462f, -0.01789003f, -0.02075251f, 
    0.04549025f, 0.08372785f, 0.11236122f, -0.06476012f, 0.15540773f, -0.09662573f, -0.00803179f, -0.06443848f, 
    -0.04194473f, -0.09202295f, -0.04029626f, -0.06699350f, -0.13289961f, 0.04694670f, -0.06876536f, -0.07715384f, 
    -0.07685541f, 0.04085950f, -0.02317655f, 0.16144376f, 0.12286590f, -0.03819887f, -0.02659165f, -0.05651933f, 
    0.01745631f, 0.07816124f, -0.06180211f, -0.02538777f, 0.02225758f, 0.16760711f, -0.07329970f, 0.06845418f, 
    -0.13035335f, -0.12705965f, -0.02240296f, -0.12765768f, -0.02240220f, -0.06394861f, 0.06111295f, -0.10647257f, 
    0.09719154f, 0.00733672f, 0.00090705f, -0.10245392f, -0.13606249f, 0.03606820f, 0.11080511f, -0.03895758f, 
    -0.02580323f, -0.12908010f, -0.09928414f, -0.05873545f, -0.25567541f, 0.05508464f, -0.04790981f, 0.05196745f, 
    -0.06400813f, 0.07137957f, -0.06059701f, -0.07080806f, -0.07738351f, 0.02792607f, -0.00546515f, 0.01341281f, 
    0.05340046f, 0.15388340f, 0.01005867f, 0.02450275f, -0.06982849f, 0.05507991f, -0.10771780f, -0.03032830f, 
    -0.02335083f, -0.06751076f, -0.09494279f, -0.17804953f, -0.24141084f, 0.01681640f, -0.02399255f, 0.08495836f, 
    0.04941764f, 0.06866488f, -0.00535230f, -0.14296539f, -0.07856161f, -0.06871502f, 0.04557490f, 0.03163223f, 
    -0.31899905f, -0.01992503f, 0.01668053f, 0.05209218f, 0.04865719f, 0.06031011f, -0.03769195f, 0.08364704f, 
    0.00188063f, -0.02643224f, 0.03676309f, 0.08503807f, -0.43470281f, -0.16936731f, 0.03507588f, -0.27825645f, 
    0.03603582f, 0.00783102f, 0.04005340f, 0.07839102f, -0.10228526f, -0.02258644f, -0.06857713f, 0.02620812f, 
    -0.01393858f, 0.12478135f, 0.02078875f, -0.24777958f, 0.00938495f, 0.00511597f, -0.01656142f, 0.08702410f, 
    -0.02180367f, 0.00169188f, 0.02313425f, 0.11443677f, -0.05902386f, -0.03603159f, 0.07371219f, -0.08795421f, 
    0.15039083f, -0.03693169f, 0.01128845f, 0.02910465f, 0.06344223f, -0.01049828f, -0.03974900f, -0.04310585f, 
    0.20569862f, 0.10479135f, -0.15622500f, -0.07779758f, 0.00438012f, -0.04790210f, -0.02201507f, 0.11120868f, 
    -0.01429199f, -0.00011144f, -0.03915404f, -0.15601902f, 0.06071705f, -0.18052469f, -0.13843706f, 0.05229186f, 
    -0.02133924f, 0.07486083f, 0.01149393f, -0.01523464f, 0.04768988f, -0.00599584f, 0.06900430f, -0.08559565f, 
    -0.25846553f, 0.23914404f, -0.04932052f, -0.03276651f, 0.26030514f, -0.01796561f, -0.00380675f, 0.04733224f, 
    0.10648869f, 0.08135662f, 0.04445209f, 0.00970731f, -0.06724788f, 0.23429751f, -0.07665467f, -0.10009254f, 
    0.09303248f, 0.03125113f, -0.06712867f, 0.05710628f, 0.00399706f, -0.07222796f, 0.10112306f, -0.07001416f, 
    -0.04956197f, 0.15887387f, 0.03670678f, -0.03333946f, -0.00348233f, 0.11905949f, 0.05402381f, -0.06735589f, 
    -0.00907170f, 0.08221847f, -0.00638741f, -0.06931365f, 0.22520435f, -0.09677437f, -0.08871987f, -0.02105216f, 
    0.00346922f, 0.02559494f, -0.02894622f, -0.06786460f, 0.02148956f, -0.03289283f, 0.16084032f, -0.05662718f, 
    0.24761309f, -0.07537968f, 0.06956637f, -0.23981412f, -0.01470256f, 0.02999689f, -0.06548539f, 0.03670207f, 
    0.00594598f, -0.08726554f, -0.00868864f, 0.07456511f, 0.01675926f, -0.00018206f, 0.02404636f, 0.09127562f, 
    -0.11800511f, -0.03671377f, -0.01974156f, 0.02667000f, -0.01078391f, -0.09410612f, -0.06685218f, 0.06825161f, 
    0.34567013f, -0.11137011f, -0.03993643f, 0.10604871f, 0.10041318f, -0.08408491f, -0.05955288f, 0.05928255f, 
    -0.06605437f, 0.02176552f, 0.01943187f, 0.03144560f, 0.02296205f, -0.01910332f, -0.02109474f, 0.14366007f, 
    0.02573851f, -0.04365334f, 0.01353940f, -0.00709416f, -0.06736349f, 0.04157004f, 0.05841675f, -0.02529953f, 
    0.02661795f, 0.06407728f, 0.05695995f, -0.00314857f, 0.00651499f, 0.00645325f, 0.03125116f, -0.04290520f, 
    0.14005166f, 0.04401604f, 0.06734658f, 0.08393708f, 0.11253123f, -0.05177139f, 0.01655393f, -0.21350048f, 
    0.12670468f, -0.04179659f, -0.07179260f, 0.13894352f, -0.08591922f, -0.02611165f, 0.02307441f, -0.01717286f, 
    0.28219873f, -0.27007726f, -0.13618419f, 0.02839668f, -0.00121538f, -0.05183141f, -0.06161238f, -0.12357237f, 
    0.03530901f, 0.12231404f, -0.02415877f, -0.01830649f, -0.13191190f, -0.25861892f, -0.04053666f, -0.23007382f, 
    0.02257294f, -0.04351082f, -0.03881429f, 0.01458268f, -0.01809822f, -0.04308187f, -0.08977327f, -0.07960155f, 
    0.08236365f, 0.07520635f, -0.06919293f, 0.04130860f, 0.05849325f, -0.03353160f, -0.00289386f, 0.11945597f, 
    -0.13551140f, -0.04637240f, 0.03840123f, -0.05353764f, -0.33266154f, 0.09952915f, -0.14239603f, -0.13037850f, 
    0.01554830f, 0.05627545f, 0.01675249f, 0.08519643f, 0.12459882f, 0.01706113f, 0.09001752f, -0.09317107f, 
    0.30976400f, 0.10831923f, -0.10516094f, -0.20064156f, -0.04053862f, 0.03829822f, 0.02946931f, -0.01132217f, 
    -0.02006745f, -0.09965164f, -0.04972077f, 0.07217362f, -0.27184814f, -0.10569277f, -0.02566432f, 0.04700096f, 
    -0.09047588f, 0.09831483f, -0.04279156f, 0.05617575f, -0.17115964f, 0.12990589f, 0.02869697f, -0.13407232f, 
    0.40541285f, 0.12811217f, -0.28484210f, 0.00771514f, -0.00128931f, -0.05155719f, -0.01900264f, -0.01477364f, 
    0.02593052f, -0.01363681f, -0.03527876f, -0.06782854f, 0.13994944f, -0.10294033f, -0.15710966f, 0.18848227f, 
    0.04682716f, -0.00052794f, 0.01193814f, -0.09846663f, 0.03549789f, 0.01937510f, -0.05765947f, 0.03794064f, 
    -0.10233843f, 0.03925811f, -0.15395527f, -0.30735248f, -0.15424903f, 0.07172884f, 0.14053760f, 0.03757290f, 
    -0.01838832f, 0.09833282f, -0.08068267f, -0.11840426f, 0.40386826f, 0.06833687f, 0.11332563f, -0.00866822f, 
    0.01690554f, -0.07601770f, -0.06801011f, -0.04534518f, 0.14523380f, -0.02417680f, 0.09123763f, 0.07966875f, 
    0.18272708f, -0.07737687f, 0.02888881f, 0.10072646f, -0.07767048f, 0.08261655f, 0.02818934f, -0.02884192f, 
    -0.05416755f, -0.01427605f, -0.01802941f, 0.01284857f, -0.21759750f, 0.02490813f, 0.02824231f, 0.00762237f, 
    0.17285432f, -0.10448439f, 0.02633676f, 0.01557073f, 0.07297657f, 0.12674369f, -0.05461375f, 0.13593522f, 
    -0.13299349f, -0.22189824f, 0.04494952f, -0.09750627f, 0.04507680f, -0.02799993f, 0.01300379f, -0.08050583f, 
    0.02500299f, 0.00832304f, -0.00193405f, 0.02754607f, -0.14970408f, -0.13144560f, 0.06373303f, 0.11785953f, 
    0.07747892f, 0.05845642f, -0.07988497f, -0.16626750f, 0.02329852f, -0.00981615f, -0.05574069f, -0.11947249f, 
    0.16648127f, -0.07137111f, 0.02868107f, 0.15677336f, 0.00113498f, 0.04332435f, -0.00489987f, 0.05965547f, 
    -0.00404439f, -0.04232727f, 0.02257501f, -0.03375604f, -0.14609095f, 0.13016041f, 0.01831758f, 0.08381620f, 
    0.06171767f, -0.15855007f, -0.04861534f, 0.01517135f, -0.03202686f, 0.04317949f, 0.01356505f, -0.01421272f, 
    -0.29430959f, 0.16930261f, -0.14113227f, -0.06372122f, -0.01528350f, -0.01957338f, 0.04924507f, 0.05085461f, 
    -0.10299776f, -0.06733220f, -0.04427307f, 0.04887185f, 0.10561249f, -0.11489966f, -0.09156592f, -0.07281471f, 
    -0.10574629f, -0.03838900f, 0.02776201f, -0.00613385f, -0.12531520f, 0.00757847f, -0.01502581f, -0.09680390f, 
    0.08647811f, -0.04369583f, 0.04067121f, -0.01360162f, -0.05249874f, -0.04889648f, -0.04190607f, 0.05941795f, 
    -0.03286576f, 0.02049327f, 0.00294244f, -0.24220109f, 0.28808650f, -0.21625902f, -0.18653657f, 0.00986235f, 
    0.02899130f, -0.10101680f, 0.00736053f, 0.01094727f, -0.02269525f, -0.08599921f, -0.00807084f, -0.05448883f, 
    -0.29038373f, 0.17024347f, 0.15520249f, 0.02728544f, -0.02485633f, -0.06233601f, -0.04143288f, -0.10602084f, 
    0.06263202f, 0.08252892f, 0.03550827f, -0.02136725f, -0.17747182f, 0.24797055f, -0.09921144f, -0.01654133f, 
    -0.15577149f, -0.06873729f, -0.11488441f, -0.15137661f, 0.00759105f, 0.08778153f, 0.05621838f, -0.14168550f, 
    0.19298372f, 0.05506088f, -0.14823888f, 0.24175730f, -0.05975652f, -0.06264405f, -0.02822932f, 0.06049900f, 
    0.07057781f, 0.00112184f, -0.14553393f, -0.13888454f, 0.03915361f, -0.02255148f, -0.10349983f, 0.11371110f, 
    -0.10981677f, 0.05819093f, -0.07760286f, 0.03986847f, -0.05857078f, -0.01072778f, 0.09241737f, 0.01932116f, 
    -0.29001597f, 0.10806958f, 0.02171589f, 0.20356716f, -0.09898300f, 0.10460107f, -0.01638179f, 0.15469527f, 
    0.01843194f, -0.00529104f, 0.10983862f, 0.00218186f, -0.17460608f, -0.07013715f, 0.08512624f, -0.08855507f, 
    0.06416442f, 0.02295143f, -0.03332815f, 0.08469599f, -0.01850802f, -0.11561590f, 0.04957536f, 0.01701488f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04139248f, -0.01263166f, -0.02736333f, 0.02555001f, -0.00891199f, 0.02688724f, -0.00498719f, -0.06860302f, 
    -0.04829305f, 0.01204789f, 0.06700955f, 0.02541735f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
