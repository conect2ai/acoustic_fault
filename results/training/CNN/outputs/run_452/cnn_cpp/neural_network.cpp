#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.69975609f, 0.99408501f, 1.03454256f, -0.46213114f, -1.32630837f, -1.05620801f, -0.67941630f, -0.37146479f, 
    -0.66894990f, -0.49711743f, 0.49393257f, 0.56358862f, -0.38566172f, -0.11476408f, -0.25016770f, -0.42972568f, 
    -0.26839921f, -0.28684831f, 0.06827714f, 0.07666799f, -0.07497511f, -0.02093655f, 0.09829658f, -0.14868553f, 
    0.16708317f, 0.04802136f, 0.56703925f, -0.44087628f, -1.01140583f, -0.15013863f, -0.65873015f, 0.32726040f, 
    1.32846892f, 0.62910110f, 0.51079816f, 0.13170926f, -0.10753825f, -0.28802043f, -0.97755712f, 0.41028151f, 
    0.17539203f, 0.12269965f, -0.22457643f, -0.08455537f, -0.33754453f, -0.41907659f, -0.19145119f, -0.31858778f, 
    -0.49547786f, -0.50715399f, -1.71715319f, 0.47771189f, 1.59324706f, 0.11301766f, 0.26059890f, 0.64446706f, 
    0.34552246f, 0.64508671f, 0.00382590f, -0.60974878f, 0.15071034f, -0.01211082f, 0.40992132f, 0.32834026f, 
    0.00470732f, 0.22405571f, 0.23239669f, 0.40357956f, -0.24885257f, 0.10898487f, -0.10770980f, -0.38098851f, 
    -0.38759142f, -0.48066014f, -0.20903835f, -1.09643698f, 1.94010925f, 1.00245190f, -0.86896545f, 0.67913556f, 
    -0.58394122f, 0.85249877f, -0.60003126f, -0.60881901f, -0.72792739f, 0.09352731f, 0.21598423f, -0.12154098f, 
    -0.19972196f, -0.05967381f, 0.31699187f, -0.15945269f, -0.24848181f, -0.17462744f, -0.22662610f, 0.07235345f, 
    0.12450512f, 0.25089449f, 0.46149600f, 0.20456560f, -0.70931280f, -1.53093290f, -0.92371231f, -0.95184553f, 
    -0.42920822f, -0.69819051f, 1.05928695f, 0.66984570f, -0.08909095f, -0.19227141f, 0.06246959f, -0.46679175f, 
    0.03638680f, 0.03344840f, -0.01340672f, 0.19013676f, 0.14651445f, -0.14318350f, -0.01267259f, 0.20556635f, 
    -0.04246578f, 0.22796683f, 0.24255365f, 0.19353822f, 0.08640915f, 0.48333707f, 1.29629695f, -0.02064919f, 
    -0.30190679f, -1.27810740f, 0.46974927f, -0.96832216f, -0.85268050f, -0.51343101f, -0.37345859f, 0.22267233f, 
    0.12490046f, 0.51509404f, 0.00008575f, 0.22184233f, 0.06530721f, -0.34951136f, 0.37015650f, 0.30386874f, 
    -0.36858025f, 0.16072185f, 0.13560745f, -0.23030065f, 0.00042652f, 0.12256467f, -0.78560007f, 1.60591054f, 
    -0.61011970f, -1.20600891f, -0.35787654f, 1.13607967f, -0.09531358f, 0.15169968f, 0.75065249f, 0.58913517f, 
    0.03355784f, -0.41445479f, -0.33133394f, 0.54529196f, 0.10723727f, 0.20692529f, 0.35097238f, 0.10594388f, 
    -0.00284065f, 0.42152190f, -0.02767897f, -0.10715454f, -0.10530352f, -0.04275180f, 0.26609758f, 2.00880218f, 
    0.10262747f, -0.37506643f, -0.94909459f, 0.60895151f, 0.33342874f, 0.44610643f, -0.29157478f, 0.17259975f, 
    0.64446080f, -0.58706230f, 0.20443371f, -0.08241995f, 0.34826332f, 0.15486303f, 0.02784319f, -0.15658778f, 
    0.09982774f, 0.29294795f, 0.44796780f, 0.24949394f, 0.48419529f, 0.15565205f, -0.02797998f, 0.34843072f, 
    -0.26339266f, -0.22768359f, 0.28573325f, -1.01010978f, 0.12037657f, 0.93415278f, -0.64249140f, -1.11844635f, 
    0.55213416f, 0.18466195f, 0.54471672f, 0.23835230f, 0.71836835f, 0.29126021f, 0.28020018f, -0.58487344f, 
    0.31055519f, 0.06933456f, 0.26978150f, 0.13041246f, 0.26243031f, 0.35747072f, -0.10067175f, 0.85914469f, 
    0.11002091f, -0.72660989f, 0.56309700f, -0.92398489f, 0.24992594f, -0.87394583f, 0.87768620f, -0.96066469f, 
    -0.29372352f, 0.09665688f, -1.19852841f, -0.64156789f, 0.20971709f, -0.39739105f, 0.21796091f, 0.41530246f, 
    -0.17113985f, 0.19117051f, -0.21089152f, -0.13195702f, 0.18403192f, -0.04256875f, 0.05408455f, 0.10148069f, 
    -0.32278025f, -0.34515032f, -0.96743441f, -0.80338329f, 0.03608456f, 0.16389133f, 0.22517407f, -1.35763860f, 
    -0.13034149f, -0.06127117f, -0.29155731f, 0.34184858f, -0.58629656f, -0.17443310f, 0.06151237f, 0.04623409f, 
    -0.48634368f, -0.17302695f, -0.73580432f, -0.18947940f, -0.65899640f, -0.62579387f, -0.33333874f, 0.39338332f, 
    0.24965116f, 0.51323456f, 0.10896222f, 1.62629819f, 1.26184237f, 1.72855723f, 1.26886511f, 0.36762521f, 
    0.00810287f, -0.91300279f, -0.34449530f, -0.11738658f, 0.63675076f, 0.26847628f, 0.49809635f, -0.36418721f, 
    -0.05473734f, 0.33514836f, 0.28043881f, 0.19608743f, 0.26168615f, -0.36935049f, 0.32373416f, 0.27021712f, 
    0.10143889f, 0.29487222f, 0.06773119f, 0.36362430f, 1.08173430f, 0.87908405f, 0.66520613f, 0.88246000f, 
    1.48458660f, 1.51253819f, 0.44211167f, -1.08379960f, 0.72134292f, 0.03977599f, -0.28801757f, 0.19505300f, 
    -0.35707796f, 0.08467187f, -0.81344193f, -0.28365573f, -0.01712911f, -0.16862494f, -0.50968885f, -0.54705524f, 
    0.15920541f, -0.07542646f, -0.19753592f, -0.10564068f, -0.03711291f, -0.48118454f, -1.33520269f, -0.05759801f, 
    -0.51908547f, -0.41633099f, -0.39036083f, -1.34576797f, -0.28474465f, 0.73420167f, -0.19000743f, 0.23273908f, 
    0.03797563f, -0.18741919f, -0.17701565f, -0.45897987f, 0.34206343f, 0.49152792f, 0.26105851f, 0.16632192f, 
    -0.39441672f, 0.66998482f, -0.04531903f, 0.49265450f, -0.15886183f, 0.04068252f, -1.69895470f, -0.53920114f, 
    -0.82061434f, -0.24683960f, -0.88105917f, 0.48362750f, 0.53732741f, -0.71293557f, 0.21751682f, 0.33056560f, 
    -0.18735240f, -0.09578454f, -0.21677716f, 0.36220840f, 0.44144744f, -0.26024547f, 0.00678065f, -0.49443814f, 
    -0.02926099f, -0.32383791f, 0.03452566f, -0.12169738f, 0.04811895f, -0.08670241f, 0.13970384f, -1.16361392f, 
    -1.31044662f, -0.72125286f, 0.17282511f, -0.17713208f, 0.93566960f, 1.71237659f, 0.09362917f, 0.48476177f, 
    0.60541213f, -0.43786955f, -0.31497923f, 0.20902114f, -0.35630184f, -0.34794638f, -0.09221870f, -0.04639497f, 
    0.69169933f, -0.12092415f, -0.15741861f, 0.10018274f, -0.52844769f, -0.10201049f, 0.05666877f, -0.03225150f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06486515f, 0.46200165f, 0.15699480f, 0.13325185f, 0.19473386f, 0.46614289f, -0.03022198f, 0.61181450f, 
    0.41102526f, 0.42301095f, 0.48837304f, 0.52772939f, 0.47576928f, 0.41879958f, 0.14613050f, 0.33995509f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.64113927f, 0.37510282f, 0.00530441f, 0.08889491f, 0.01230162f, -0.05001862f, -0.08696883f, -0.09003619f, 
    -0.15453383f, -0.07969940f, 0.06570747f, -0.02183052f, -0.31317824f, 0.03670214f, -0.15622950f, -0.40686497f, 
    -0.11079679f, -0.23418185f, -0.07584529f, -0.25414830f, 0.13095595f, -0.03939047f, -0.10180900f, 0.08434475f, 
    -0.62124902f, -0.02072209f, 0.05389985f, 0.42238414f, -0.04509397f, -0.06610779f, 0.29301086f, 0.06048448f, 
    0.11461161f, -0.08692969f, 0.04783530f, 0.03357320f, -0.42680791f, -0.01940831f, 0.36237580f, -0.39501369f, 
    0.02310741f, -0.00676673f, -0.02216940f, -0.07623851f, 0.03146940f, -0.19395234f, -0.05853871f, -0.10581780f, 
    -0.44478241f, 0.14205286f, 0.11138669f, -0.77264678f, 0.00340989f, 0.03518936f, 0.22661424f, -0.07285478f, 
    0.07926366f, -0.02989867f, 0.00516241f, 0.09939002f, -0.31055304f, 0.44891009f, 0.17569110f, -0.33705568f, 
    -0.21980627f, 0.17993693f, 0.00005341f, -0.24204500f, -0.28176823f, 0.04253982f, 0.02186577f, 0.02261044f, 
    0.60168016f, -0.06568234f, 0.00614260f, -0.22939393f, -0.12097767f, 0.07718273f, 0.30478469f, -0.16771045f, 
    0.04344589f, 0.11597337f, -0.06168611f, -0.15875658f, 0.29249597f, -0.38273588f, 0.09493824f, -0.46643096f, 
    0.07340438f, -0.09224001f, -0.10462273f, 0.15622212f, -0.12331124f, 0.15204108f, 0.02746538f, 0.21405450f, 
    -0.31803209f, -0.52673239f, 0.26524457f, -0.23285519f, 0.03839925f, 0.02937848f, 0.06929836f, -0.28317043f, 
    -0.13037474f, 0.01066857f, 0.09408126f, -0.03165336f, 0.07226722f, -0.08940662f, -0.09506440f, -0.06585531f, 
    -0.02749037f, -0.08915038f, -0.12538858f, -0.02948109f, 0.04227665f, 0.04753438f, 0.04814679f, 0.10433395f, 
    -0.15108341f, -0.18339501f, -0.09697633f, 0.43547377f, -0.08789479f, -0.04058717f, -0.27700663f, 0.10156526f, 
    0.04126107f, 0.09767604f, 0.19299267f, 0.11855330f, 0.48542374f, -0.20889699f, -0.29977801f, 0.14796500f, 
    -0.47745064f, -0.36449865f, -0.01053653f, 0.20144883f, 0.06804009f, -0.02161960f, -0.11815564f, 0.01480996f, 
    0.05084458f, -0.05760207f, 0.30652300f, 0.32215771f, -0.25614706f, -0.01862775f, 0.13641894f, 0.03466549f, 
    -0.17493393f, 0.26578790f, -0.08872432f, -0.04542389f, -0.36910078f, -0.06569820f, -0.03079556f, -0.00475344f, 
    0.05104743f, 0.02285216f, -0.01527853f, 0.17304608f, 0.06218235f, -0.03460154f, -0.05099330f, -0.13015661f, 
    0.60570228f, -0.20887497f, 0.16268578f, -0.26956609f, 0.05509343f, 0.16663231f, -0.09914887f, 0.11065097f, 
    -0.00051641f, -0.09687771f, -0.19896358f, 0.03075077f, 0.34692064f, 0.36551020f, 0.06620448f, -0.06119810f, 
    0.22001413f, 0.12821533f, 0.09155985f, 0.02384520f, 0.11463339f, -0.04739559f, -0.19185691f, 0.10825144f, 
    -0.42237887f, -0.05440960f, -0.79089195f, -0.30802464f, -0.10949260f, -0.08658809f, 0.12424483f, -0.15064833f, 
    -0.03989727f, 0.25191271f, 0.08783040f, -0.11967151f, 0.41611472f, 0.08129843f, -0.03702125f, -0.29772356f, 
    0.20141433f, -0.15091360f, -0.15310828f, 0.14227124f, -0.05723708f, -0.18594104f, -0.03121152f, -0.08209570f, 
    -0.32378113f, 0.38529211f, -0.11091644f, 0.23950984f, 0.01158407f, 0.10471450f, -0.26578704f, -0.19955662f, 
    -0.10140013f, -0.09714919f, 0.03879145f, -0.04726478f, -0.32890663f, 0.53352034f, -0.48462868f, -0.53798181f, 
    -0.15017194f, 0.21152069f, 0.04933383f, -0.25279295f, 0.16309322f, 0.16459669f, -0.03139051f, -0.03953061f, 
    0.52514803f, -0.19898072f, -0.02626808f, -0.01635471f, -0.08707660f, -0.05831034f, -0.11269037f, 0.11494924f, 
    0.04230847f, -0.03341858f, -0.07461386f, -0.01561151f, -0.11897282f, -0.30080163f, -0.19790104f, -0.13092233f, 
    0.11626898f, -0.00583930f, 0.10370376f, 0.18486264f, 0.18303610f, 0.13206013f, -0.03630503f, 0.21110465f, 
    -1.12236977f, -0.42007431f, 0.14556518f, -0.53709972f, -0.09325206f, -0.13617355f, -0.02763433f, 0.10090970f, 
    0.16363667f, 0.19048013f, -0.02402989f, -0.21925698f, 0.90980852f, -0.22672950f, 0.14188823f, -0.06442620f, 
    0.05931541f, -0.07458519f, -0.12048785f, -0.00415407f, -0.29950890f, 0.04546407f, -0.05458863f, 0.12575927f, 
    -0.45339105f, -0.01741574f, 0.32126105f, 0.10096389f, -0.04241294f, -0.05598263f, -0.20727566f, 0.17788953f, 
    0.05485987f, 0.01702358f, 0.04054388f, -0.01340435f, -0.36561814f, 0.09491125f, -0.33913717f, -0.18123472f, 
    -0.05914515f, -0.16281073f, 0.15663780f, -0.05108584f, 0.01295835f, 0.18047370f, -0.13586514f, -0.00429006f, 
    -0.27468142f, 0.07277587f, -0.08699290f, -0.33871698f, 0.02978875f, -0.03725562f, -0.23672953f, 0.06154362f, 
    -0.04310586f, -0.40054336f, -0.37092149f, -0.30230781f, 0.21543480f, 0.12178525f, 0.29901570f, 0.50998276f, 
    -0.10214681f, -0.07616343f, 0.07242382f, -0.03223803f, 0.02738990f, -0.05376308f, 0.07496659f, 0.07769649f, 
    0.40943125f, -0.02189233f, 0.27163061f, 0.22781986f, -0.10867003f, 0.11375777f, -0.03904104f, 0.13578106f, 
    -0.14517522f, -0.22808045f, 0.03627657f, -0.17039484f, -0.17305265f, -0.03969740f, 0.31394085f, 0.15316561f, 
    0.19963776f, 0.05219911f, 0.02926818f, 0.26400572f, 0.05413899f, -0.08074868f, 0.06375626f, 0.28557512f, 
    -0.23308077f, 0.22366215f, -0.24312420f, -0.08028507f, 0.14250939f, -0.10070877f, 0.15591769f, 0.07512182f, 
    -0.05932731f, 0.08222917f, -0.22934379f, -0.02777274f, 0.31137618f, -0.20093925f, -0.17214926f, -0.01845244f, 
    0.16708200f, -0.00628904f, -0.11677466f, -0.01843308f, 0.14390427f, 0.10129642f, 0.05099582f, 0.12831412f, 
    -0.58557409f, 0.24375810f, 0.00848428f, -0.50625283f, 0.00479183f, 0.25910279f, 0.06683923f, -0.11030278f, 
    0.01303267f, 0.10495376f, -0.03563044f, -0.09048242f, 0.05369462f, 0.30647230f, 0.05142482f, 0.24806680f, 
    -0.16683854f, 0.03695037f, 0.19378631f, 0.30416313f, -0.06006644f, -0.22836408f, 0.04582886f, -0.37337023f, 
    0.54725993f, 0.09321341f, -0.29741031f, 0.07915710f, -0.23818220f, 0.03991230f, 0.06384917f, -0.06531224f, 
    -0.08433217f, 0.00572737f, -0.18087809f, -0.08886468f, 0.70276779f, -0.29852411f, -0.61820346f, -0.41965339f, 
    0.28169212f, 0.17413487f, -0.15446362f, -0.27736536f, 0.15805943f, -0.13397108f, 0.01827860f, -0.08093550f, 
    0.32494530f, 0.07102041f, 0.02896473f, 0.58958215f, -0.39077413f, -0.15274832f, -0.29779488f, 0.15017895f, 
    -0.09855230f, 0.10005391f, 0.02864729f, 0.15027474f, -0.50736910f, 0.01359477f, -0.05622783f, -0.54383469f, 
    0.11184948f, 0.06148662f, 0.16806887f, -0.15146898f, -0.06387092f, 0.28589216f, -0.24666800f, -0.09297246f, 
    0.19149680f, 0.45499775f, -0.13426441f, 0.29946059f, 0.18206710f, -0.15910605f, 0.18434718f, -0.15376271f, 
    -0.21080545f, 0.07583344f, -0.03109240f, 0.10075125f, -0.38524169f, 0.05528999f, 0.01860292f, -0.13174871f, 
    0.28984067f, -0.01753465f, 0.12986170f, -0.26375026f, -0.29534778f, -0.03068122f, -0.18341000f, 0.28549340f, 
    -0.06799877f, 0.20203720f, 0.04472293f, -0.22388047f, -0.07536109f, 0.27802005f, 0.01656479f, 0.15398942f, 
    -0.13981411f, -0.15636840f, -0.09374441f, -0.12753373f, -0.59328896f, -0.00193495f, -0.35079277f, -0.53481096f, 
    0.02162265f, -0.17548867f, 0.11542861f, -0.04711544f, -0.26805398f, -0.19373320f, -0.04880132f, -0.10579655f, 
    0.61681437f, -0.39033419f, -0.43440765f, -0.15467368f, -0.17868710f, -0.10973100f, -0.28006157f, -0.20920227f, 
    0.08207798f, 0.12756607f, 0.06220819f, 0.02551943f, -0.30770996f, 0.20801581f, 0.03771535f, 0.04715582f, 
    0.00790680f, 0.18968536f, -0.01763589f, -0.02522546f, -0.17310755f, 0.10657362f, -0.03865278f, -0.17895392f, 
    0.25867745f, -0.70832378f, 0.13877007f, -0.05287811f, 0.30517262f, 0.06139280f, 0.09742527f, -0.23743412f, 
    0.12361559f, 0.16068053f, 0.05761699f, -0.07368599f, -1.08853567f, -0.35978854f, -0.18666035f, 0.01652692f, 
    -0.33794370f, 0.07273332f, -0.22187212f, -0.08634096f, -0.16784219f, 0.09233186f, 0.05425553f, 0.03479312f, 
    0.94190872f, -0.00473403f, -0.10045935f, 0.01401174f, -0.14423515f, -0.11484867f, -0.20872867f, 0.05597866f, 
    -0.12011355f, -0.28761977f, 0.08065765f, 0.15025933f, 0.55516148f, -0.03891791f, 0.35425067f, 0.34651884f, 
    -0.26802313f, -0.25476915f, -0.04722481f, 0.18866825f, 0.01386159f, 0.11615641f, -0.04366362f, -0.01376552f, 
    -0.29571509f, 0.05823870f, -0.00731120f, 0.27763045f, 0.00395727f, 0.02199527f, -0.09749261f, 0.17613710f, 
    0.02669757f, 0.05012635f, -0.10312600f, -0.22054318f, -0.23367959f, -0.05839981f, -0.01331217f, -0.29533058f, 
    -0.08514759f, 0.01421494f, -0.10459404f, 0.03318354f, 0.14716639f, 0.01912271f, -0.01548166f, 0.13314417f, 
    -0.29998130f, -0.07305646f, 0.18403134f, -0.03729105f, -0.04354529f, -0.08117946f, 0.38247481f, 0.05766049f, 
    0.07436510f, -0.06759735f, 0.07095056f, 0.06818442f, 0.16096278f, 0.49781209f, 0.24642675f, -0.06620779f, 
    0.00084618f, 0.09295099f, -0.04779522f, 0.24013095f, -0.17518108f, 0.13916166f, -0.00428500f, -0.02644092f, 
    0.33762649f, -0.12776309f, -0.30673757f, 0.09549187f, -0.11079149f, -0.30898541f, -0.00749543f, -0.02584464f, 
    -0.11003120f, 0.01573122f, 0.11758239f, 0.11187647f, 0.37583974f, -0.19492990f, -0.10245936f, 0.26277357f, 
    -0.07316601f, 0.11809542f, -0.18745513f, -0.09047568f, -0.08495456f, -0.01327939f, -0.11328222f, -0.00925862f, 
    0.32955021f, 0.52482575f, 0.29024702f, -0.44666603f, -0.04902159f, 0.06113152f, -0.05111030f, 0.10574123f, 
    0.06220875f, -0.25281253f, -0.15504469f, 0.08487576f, -0.43411863f, -0.24449316f, -0.09800671f, -0.08279665f, 
    0.03658419f, -0.12576328f, -0.00279659f, -0.04220376f, -0.21196672f, -0.07356247f, -0.16302150f, -0.07539707f, 
    0.40962055f, 0.06228092f, 0.10137893f, -0.12469606f, 0.08494600f, 0.09450672f, 0.20321478f, -0.07182044f, 
    -0.05321109f, -0.17286409f, -0.13470607f, 0.13147593f, 0.54400343f, 0.07614329f, -0.15537570f, 0.12708533f, 
    -0.03068181f, -0.04195328f, -0.08150999f, 0.18421102f, -0.00832049f, 0.04712967f, 0.18990707f, 0.09739224f, 
    0.24977259f, 0.42950633f, 0.29368180f, 0.33556139f, 0.03855347f, -0.19932479f, -0.08230517f, 0.06645783f, 
    -0.04488300f, -0.00920883f, 0.21490589f, 0.00694720f, -0.78422982f, -1.06644917f, -0.58910453f, 0.51358974f, 
    -0.14264920f, 0.04517573f, 0.07069910f, 0.00480965f, -0.01769026f, -0.05893450f, 0.02669349f, -0.20809634f, 
    0.41698298f, -0.66693169f, -0.64390683f, 0.04435636f, -0.18526301f, -0.03518461f, -0.10333572f, 0.11218514f, 
    -0.08919699f, -0.10982294f, -0.02992708f, 0.02933132f, 0.17283404f, 0.11307666f, 0.07793912f, 0.33647004f, 
    -0.20644629f, 0.03145481f, -0.13001083f, 0.17852110f, 0.01638270f, 0.35229874f, -0.00762955f, -0.04822095f, 
    -0.09638157f, 0.37829161f, -0.18148443f, -0.03670971f, -0.26397011f, -0.19255772f, 0.00642010f, 0.03295377f, 
    0.10829334f, -0.17230071f, 0.05485079f, 0.11346622f, -0.25244173f, -0.03810154f, -0.29686016f, -0.31022465f, 
    -0.10534767f, -0.38617685f, 0.01265964f, 0.16518837f, -0.15355170f, -0.02448153f, -0.01934463f, -0.24209200f, 
    -0.03337963f, -0.82499224f, 0.28211355f, -0.12726542f, -0.21231714f, 0.19289865f, -0.03137586f, -0.21980841f, 
    0.07187247f, 0.02884330f, 0.02915869f, 0.02518416f, 0.18855189f, -0.31054330f, 0.04218769f, 0.15157026f, 
    -0.23143338f, 0.16105986f, 0.17238221f, 0.00685076f, -0.01238816f, 0.14292298f, 0.19253920f, 0.16236964f, 
    0.36096731f, 0.37943342f, -0.31021315f, -0.57678777f, 0.12661898f, -0.07115123f, 0.18735434f, 0.30942127f, 
    -0.09855515f, 0.13647605f, -0.24975123f, -0.00627010f, -0.12094019f, 0.53727931f, 0.29458228f, 0.06145812f, 
    -0.24994123f, -0.17081480f, 0.01014729f, -0.18293282f, 0.01518158f, 0.05741215f, -0.05198960f, -0.07840866f, 
    -0.72952592f, -0.11829295f, 0.15053125f, 0.28915349f, 0.30385256f, -0.00993979f, -0.01336769f, 0.20152557f, 
    -0.08672889f, -0.23390794f, 0.14532709f, 0.16523358f, -0.33035448f, -0.25977710f, 0.24030516f, -0.20865011f, 
    -0.08006907f, 0.08947739f, 0.01896841f, -0.16281918f, 0.22961220f, -0.07153095f, 0.10874472f, 0.02158282f, 
    0.49905846f, -0.18731387f, -0.18899767f, 0.40838614f, 0.02663636f, -0.02218705f, 0.01286430f, 0.10379239f, 
    -0.01930971f, -0.22815046f, 0.05386273f, 0.00136714f, 0.01626886f, -0.23836954f, -0.21998744f, -0.21705182f, 
    -0.13236260f, 0.03932792f, -0.11639678f, -0.07936177f, 0.03460997f, -0.06113621f, 0.01461137f, -0.19867554f, 
    -0.05411198f, -0.04139736f, -0.15883085f, 0.01160523f, 0.08281272f, 0.29013297f, 0.00390063f, -0.00585955f, 
    -0.14172471f, -0.17354855f, -0.29886919f, -0.02324151f, 0.08879790f, 0.33632082f, -0.05531631f, -0.51087767f, 
    0.17398648f, -0.02421104f, -0.00551162f, -0.00572345f, -0.00600707f, -0.38790894f, 0.10557900f, 0.06261116f, 
    -0.07627056f, -0.10699630f, 0.20738176f, -0.03347963f, 0.05504454f, -0.10269697f, 0.13028808f, -0.01110580f, 
    -0.10685065f, 0.11975759f, -0.07348406f, 0.03045525f, -0.34516975f, -0.24343859f, 0.20198201f, 0.15377864f, 
    -0.21003827f, 0.15541117f, -0.15863664f, -0.05221154f, 0.09095465f, -0.03766326f, -0.02950054f, -0.09265596f, 
    0.31615335f, 0.08547533f, -0.24203058f, -0.00098221f, -0.07740726f, 0.07685223f, 0.18910353f, 0.24922296f, 
    -0.07440635f, 0.01409140f, -0.07734524f, 0.02687616f, 0.37887517f, 0.10805240f, -0.16335112f, 0.29615432f, 
    -0.09013839f, 0.11272223f, -0.18977843f, 0.18090701f, 0.05126595f, 0.13381262f, 0.07050828f, 0.12294258f, 
    0.08571682f, -0.18127528f, 0.04935910f, -0.12966445f, 0.19375294f, -0.08048633f, -0.00086255f, 0.28980500f, 
    -0.06953390f, -0.00762642f, -0.12158271f, 0.03434086f, -1.42977834f, -0.16957386f, 0.05744372f, 0.20673382f, 
    0.03328592f, -0.09508879f, 0.02576857f, 0.03741297f, -0.06568278f, 0.14393117f, -0.02818944f, 0.05332759f, 
    0.08365909f, 0.26954725f, 0.10222552f, 0.23276439f, -0.20131874f, -0.21189481f, -0.04883906f, 0.24016826f, 
    -0.02346202f, -0.31594464f, -0.13205892f, 0.15277530f, 0.12323121f, 0.02915360f, -0.13623518f, -0.06462074f, 
    0.02676014f, -0.05482608f, -0.19678688f, -0.13310617f, -0.10059842f, 0.09558975f, -0.29681808f, 0.15733586f, 
    -0.42182937f, -0.46794972f, 0.41068920f, -0.07924040f, 0.22968429f, 0.00396417f, -0.17175741f, -0.25521797f, 
    0.12833352f, 0.02780710f, 0.05377198f, -0.04398798f, -0.25910431f, -0.33137947f, 0.07228298f, 0.58340335f, 
    -0.21024214f, -0.02695620f, 0.07883090f, 0.18052432f, 0.02783601f, 0.09859876f, 0.04555119f, 0.04955995f, 
    -0.36564258f, -0.36260480f, -0.61468685f, -0.11863247f, 0.22705524f, 0.00163082f, 0.10412172f, -0.17339671f, 
    0.12191035f, 0.33374134f, -0.10271166f, 0.09781978f, -0.02874961f, 0.12125230f, 0.08130912f, 0.26110432f, 
    -0.15633719f, -0.10653300f, 0.04621687f, 0.10918746f, -0.20083314f, -0.17096497f, 0.11455233f, -0.01952443f, 
    0.25922474f, 0.09798180f, 0.16042611f, 0.12909964f, 0.00361246f, -0.00827711f, -0.12156157f, -0.21035436f, 
    0.06437471f, -0.03212085f, -0.00176109f, 0.03181350f, 0.00709153f, -0.04260081f, 0.05118556f, -0.19561680f, 
    -0.26711729f, 0.04308718f, 0.12700260f, 0.10511747f, 0.33446527f, 0.00962540f, 0.22235861f, -0.03345774f, 
    -0.29172501f, 0.21015106f, -0.46243671f, 0.17894796f, -0.15699716f, -0.22481890f, 0.18129054f, -0.05394039f, 
    0.02377856f, 0.11423463f, 0.01327661f, 0.13938966f, -0.48087436f, -0.02616379f, 0.39520332f, -0.11992672f, 
    -0.02832272f, 0.02610334f, -0.24273543f, 0.00848880f, -0.13206062f, 0.25205052f, -0.07649166f, -0.19187291f, 
    0.09799910f, 0.15097101f, -0.19982068f, -0.00266628f, 0.09820031f, 0.03574029f, 0.40183979f, 0.20109743f, 
    0.06451061f, -0.22048168f, 0.09553556f, -0.26925281f, 0.09928967f, 0.07205811f, -0.00803145f, 0.04606736f, 
    -0.00213474f, 0.07960545f, 0.03555505f, 0.10970213f, -0.07747651f, 0.19041947f, 0.07860555f, 0.29729879f, 
    -0.01732263f, -0.21611102f, 0.26452598f, 0.04035456f, 0.13271905f, -0.11494108f, -0.02852004f, -0.02176187f, 
    0.20038204f, -0.17530537f, -0.20847127f, -0.00035959f, 0.10482842f, -0.20041402f, -0.23825863f, 0.08511714f, 
    0.37664381f, 0.02185383f, 0.17020780f, -0.14667229f, 0.26515564f, -0.08156102f, -0.08910469f, 0.12696965f, 
    -1.19077957f, -0.35575712f, -0.13121894f, -0.17105275f, 0.06987986f, 0.04912475f, 0.30851081f, 0.01790136f, 
    0.02730802f, -0.06791199f, 0.15789787f, -0.14041562f, -0.45831794f, 0.28841600f, -0.19523151f, -0.31259808f, 
    0.08908381f, 0.06694981f, -0.03764299f, -0.21595410f, 0.05355572f, -0.38943845f, -0.03019379f, -0.25025254f, 
    -0.37177294f, -0.08422358f, 0.06066015f, 0.18335216f, 0.15716195f, 0.01367720f, 0.02389554f, 0.02852396f, 
    0.02566653f, 0.02681853f, -0.15903233f, -0.08352184f, -1.16256583f, -0.27835336f, 0.12274443f, 0.43919146f, 
    0.08675546f, -0.06829845f, 0.06979640f, -0.02279253f, 0.13061354f, 0.03804281f, 0.25382200f, -0.05117996f, 
    0.61638707f, -0.48585555f, -0.11333556f, 0.06579512f, -0.45591524f, 0.04403949f, 0.10253257f, 0.20909151f, 
    0.08433545f, 0.02942643f, -0.37077865f, -0.00306221f, 0.06988063f, -0.14766762f, -0.25682327f, -0.05421742f, 
    0.32630768f, -0.07031004f, -0.05365484f, 0.06482667f, -0.06215728f, 0.08093925f, -0.03904614f, 0.03214483f, 
    -0.08114700f, -0.00795995f, -0.12086222f, -0.64598405f, -0.05043596f, 0.26251531f, 0.04691077f, -0.13105382f, 
    0.02138211f, -0.27325743f, 0.03519253f, -0.19552077f, 0.26486376f, 0.08760015f, 0.03448210f, 0.57593894f, 
    0.00831944f, 0.13523003f, 0.05467483f, 0.34336612f, -0.03615880f, -0.06065659f, -0.08140293f, 0.11861616f, 
    -0.25677252f, -0.02827525f, -0.20207988f, 0.34705946f, -0.04631616f, -0.08262466f, 0.06288027f, 0.05307928f, 
    -0.08746658f, 0.02950871f, -0.12911581f, -0.11526317f, -0.36932898f, 0.15826106f, 0.26350564f, 0.22409885f, 
    0.07120941f, -0.02867089f, -0.12073068f, 0.03339734f, -0.00352368f, -0.10988344f, -0.04418273f, 0.07654590f, 
    0.02157917f, -0.11615022f, -0.25485462f, -0.18803772f, -0.14499381f, 0.08789267f, -0.09309783f, 0.06847609f, 
    -0.10736530f, 0.00918843f, 0.14199357f, -0.18640424f, 0.48256341f, 0.22338076f, 0.26178494f, 0.53436726f, 
    -0.22024632f, 0.14019881f, 0.00605229f, -0.05191844f, 0.12861072f, -0.21540277f, 0.14567281f, 0.21208170f, 
    0.23260564f, -0.15495825f, -0.12585378f, -0.50791872f, 0.10819746f, -0.00899790f, 0.04762298f, -0.26104921f, 
    -0.03296715f, 0.01456953f, 0.11128858f, 0.24670480f, -0.15427864f, 0.55001032f, 0.20494050f, -0.31423125f, 
    -0.07258818f, -0.02661508f, -0.01649454f, -0.05760875f, -0.01608657f, -0.03983604f, -0.10580520f, -0.19594838f, 
    -0.41220677f, 0.28883320f, 0.05116881f, -0.19414376f, -0.22238661f, 0.00278192f, 0.20932013f, 0.10357276f, 
    -0.06603938f, 0.18034719f, 0.24868748f, 0.18048868f, -0.20466337f, 0.01961785f, -0.44665149f, -0.60857946f, 
    -0.02331432f, -0.23454407f, -0.03000389f, -0.40038893f, -0.29710117f, 0.09067017f, -0.13911383f, -0.12957110f, 
    0.31899121f, 0.10869671f, -0.27579281f, -0.05416135f, -0.05874821f, 0.23250350f, -0.21082594f, -0.16660017f, 
    -0.19122052f, 0.13386440f, 0.18760757f, -0.04650570f, 0.23386112f, -0.76350009f, -0.13117011f, -0.47707090f, 
    -0.09714703f, 0.13452537f, -0.08530951f, -0.13484047f, 0.01051474f, 0.18388045f, 0.06477160f, 0.47418934f, 
    0.14057797f, -0.59563577f, 0.03680592f, 0.39516437f, 0.12928623f, -0.24550563f, -0.26414698f, 0.04076284f, 
    -0.07105113f, -0.16322252f, -0.07740127f, -0.06578612f, 0.07592843f, -0.09401065f, 0.00566461f, 0.08913045f, 
    0.15130158f, 0.10108941f, 0.00627585f, -0.22927476f, -0.07875389f, -0.07564823f, -0.09979006f, -0.12008143f, 
    0.54467553f, 0.11960307f, 0.14905268f, 0.12004554f, 0.33708024f, -0.08641123f, -0.09735989f, -0.14978030f, 
    0.01671528f, 0.10506000f, -0.04387755f, -0.17023404f, 0.32145414f, -0.72642916f, 0.42469993f, 0.27625281f, 
    0.10083397f, -0.24647821f, -0.07290363f, 0.09050092f, -0.21719171f, 0.08724367f, 0.01405994f, 0.09624958f, 
    0.15860599f, 0.27398691f, 0.32020953f, 0.01226527f, 0.27590209f, 0.30375788f, 0.10901953f, -0.09835571f, 
    -0.10955925f, -0.03366373f, -0.09185653f, 0.00465942f, -0.36138639f, 0.10513733f, -0.32106203f, 0.36238292f, 
    -0.08169256f, -0.31691563f, -0.13693632f, -0.01535494f, -0.28255537f, 0.07540966f, 0.01136256f, -0.06232592f, 
    -0.18425085f, 0.42033958f, -0.09648234f, 0.21204783f, 0.24728577f, -0.00131342f, -0.22106883f, 0.09176145f, 
    0.12772830f, -0.01612406f, 0.20349073f, -0.04150087f, -0.25369498f, -0.07126214f, -0.67841572f, 0.01100805f, 
    -0.20297650f, -0.00919880f, 0.00147717f, -0.08314094f, -0.09724703f, 0.04610430f, 0.09851259f, -0.22908485f, 
    -0.19025259f, 0.28188121f, -0.02778571f, 0.07128478f, -0.14138828f, -0.09171300f, 0.06101743f, 0.00056640f, 
    -0.08015016f, -0.05035996f, -0.11818662f, -0.22720911f, 0.34950474f, 0.39092797f, 0.00448401f, 0.35730460f, 
    -0.16192570f, -0.10042655f, -0.02199840f, 0.01381833f, -0.23283234f, 0.05869931f, -0.25531977f, -0.11008760f, 
    0.11450785f, -0.23076616f, 0.04494139f, 0.06649589f, 0.16171135f, 0.10621383f, -0.05980875f, -0.04586440f, 
    -0.44953963f, 0.27198586f, 0.07940203f, 0.00088797f, -0.50588262f, -0.06175065f, -0.66228104f, -0.78649473f, 
    0.04489570f, -0.04416500f, -0.04995633f, -0.17057271f, -0.18195722f, 0.01963349f, -0.08069520f, -0.12874080f, 
    -0.57864767f, 0.44130236f, -0.51781386f, -0.33548263f, -0.14223216f, -0.05278154f, 0.01914178f, -0.16834015f, 
    -0.07237457f, 0.09739420f, -0.05463510f, 0.00693791f, 0.05508446f, 0.14357620f, 0.13161607f, 0.28523749f, 
    -0.04325645f, 0.06546499f, 0.03834820f, -0.09315756f, -0.31246743f, -0.20274928f, -0.19186054f, -0.27540037f, 
    -0.04343015f, 0.15943821f, 0.16170068f, 0.38107777f, 0.39340276f, -0.07306629f, 0.28818932f, 0.01414324f, 
    -0.04295765f, -0.04713915f, 0.05018440f, -0.18044207f, -0.31558222f, 0.37354010f, 0.23462811f, -0.00420786f, 
    0.13834755f, -0.06052812f, 0.03860011f, 0.05985991f, -0.25689080f, 0.16112769f, 0.11978855f, -0.17996331f, 
    0.43187487f, -0.09747338f, -0.40516636f, -0.53768545f, 0.18337274f, -0.05683040f, 0.02219902f, -0.09586182f, 
    0.02829933f, 0.11352710f, -0.05343986f, 0.35250458f, 0.31236607f, 0.25710157f, -0.13738924f, 0.04318989f, 
    0.10678956f, 0.23057841f, -0.24599959f, -0.16519588f, -0.07003898f, 0.21665169f, -0.12703131f, -0.18496804f, 
    0.38518009f, -0.35405043f, 0.04902982f, -0.07288305f, 0.06100563f, -0.04066226f, -0.37794343f, -0.12818708f, 
    -0.09667408f, 0.07661051f, 0.32181090f, -0.01321234f, -0.25279808f, 0.01254836f, -0.34525338f, 0.12475020f, 
    0.12446235f, -0.05427641f, 0.00743452f, -0.09187145f, 0.21561278f, -0.01432670f, -0.28642914f, 0.08540149f, 
    -0.52835268f, 0.07064920f, 0.36449212f, -0.35826576f, 0.01632959f, -0.03175298f, 0.01643811f, 0.10223316f, 
    -0.00387127f, -0.18926711f, 0.03197686f, -0.06622949f, 0.22941524f, 0.12267867f, -0.77833104f, -0.37695646f, 
    0.11503455f, -0.15778473f, -0.16496705f, 0.08381698f, 0.13248481f, 0.17464964f, 0.19946939f, 0.00405099f, 
    -0.10885322f, 0.38613132f, -0.13396238f, 0.09197703f, -0.03297922f, -0.10422817f, -0.49574786f, 0.02839091f, 
    -0.00379236f, -0.08382568f, 0.02800871f, 0.06497480f, 0.10538606f, 0.40204051f, -0.23949441f, 0.01930519f, 
    0.01687848f, -0.05563428f, -0.08373402f, -0.35758790f, -0.05464251f, 0.23639071f, -0.02885230f, -0.18191586f, 
    0.14466074f, 0.05454384f, 0.06027474f, 0.10053622f, -0.02685554f, -0.16194035f, 0.26614586f, -0.07226601f, 
    0.00573652f, 0.21721925f, 0.22058870f, 0.31010339f, -0.42858371f, -0.40112436f, -0.27453914f, -0.76040691f, 
    0.13920055f, -0.30119136f, -0.44338998f, -0.03743646f, 0.12273905f, 0.19913480f, -0.22398606f, -0.10819006f, 
    -0.31248096f, -0.16927636f, 0.31752890f, -0.14479138f, 0.00674355f, -0.01225598f, 0.01121408f, -0.17212483f, 
    0.26695269f, -0.33421111f, -0.16880144f, -0.02526084f, -0.03928842f, -0.26722416f, 0.01823261f, 0.20367143f, 
    0.28224584f, -0.04876078f, -0.01154452f, -0.12493420f, 0.08224879f, 0.01919282f, 0.09455902f, -0.06574706f, 
    0.48435906f, -0.29693714f, 0.38029650f, 0.28239191f, 0.17160745f, -0.06558990f, -0.14205398f, -0.07432619f, 
    0.19171894f, -0.19374140f, 0.00339706f, -0.11701728f, -0.73838127f, -0.36183727f, 0.33105025f, -0.23068918f, 
    -0.12710044f, -0.14964049f, -0.05757152f, 0.20486219f, 0.07077022f, -0.17998429f, -0.12164705f, 0.14459275f, 
    -0.32320037f, -0.23963434f, 0.45333350f, -0.02113550f, 0.12227488f, 0.03467569f, -0.09004412f, -0.23161013f, 
    0.05576102f, -0.02458697f, 0.00311133f, 0.03036939f, 0.04713232f, -0.12355818f, 0.39289838f, 0.19491617f, 
    -0.25905961f, 0.02688888f, -0.00932318f, -0.07824542f, 0.08598383f, -0.26099086f, -0.15800461f, -0.34894612f, 
    0.39315045f, -0.08471971f, 0.15256429f, -0.19160584f, -0.05122090f, -0.05924525f, 0.08329635f, 0.01615216f, 
    -0.04020184f, 0.03712507f, 0.19365595f, 0.02427778f, 0.34335309f, -0.29329833f, -0.04292360f, 0.20700198f, 
    0.06108573f, 0.15618753f, -0.00695072f, 0.25715184f, 0.07229161f, 0.06630187f, 0.05449802f, -0.17196719f, 
    0.41792440f, 0.12380566f, -0.22836141f, 0.11675505f, 0.00714149f, 0.06699917f, 0.13929543f, -0.08725908f, 
    0.05118727f, 0.04149689f, -0.03801567f, 0.23395397f, 0.49671319f, -0.79185474f, -0.07571683f, -0.64901108f, 
    -0.01724908f, 0.04826160f, -0.23298216f, 0.12035393f, -0.17636433f, -0.22412975f, 0.09264012f, -0.08106975f, 
    0.12316014f, -0.27578425f, -0.07746807f, 0.28328124f, -0.07179678f, -0.02223931f, -0.10460008f, 0.08481729f, 
    -0.36671782f, 0.10732038f, -0.17752746f, -0.18488723f, -0.09775311f, 0.06060908f, 0.47050679f, -0.38890046f, 
    -0.11057413f, -0.01212061f, -0.10397915f, -0.01880920f, -0.24026109f, -0.07234812f, -0.12139664f, -0.25985050f, 
    -0.36777189f, -0.55480647f, 0.56229848f, -0.53039986f, -0.20222105f, 0.15284739f, -0.03575804f, 0.20264123f, 
    0.01524107f, -0.30607671f, 0.14915086f, 0.09987514f, -0.34260258f, 0.91262680f, -0.25200352f, 0.32780549f, 
    0.10499166f, 0.16733009f, -0.14670534f, 0.12355717f, 0.00593721f, -0.09604862f, -0.14717190f, -0.10291716f, 
    0.07804529f, 0.10916773f, 0.10005597f, -0.37647268f, 0.23005174f, -0.26569766f, 0.00357265f, 0.00307982f, 
    0.09530096f, -0.05945057f, 0.23258060f, 0.10265689f, -0.47268605f, -0.22484154f, 0.19802289f, 0.32938832f, 
    -0.05552601f, -0.08100036f, 0.21568841f, 0.11938270f, -0.00197779f, -0.09876695f, 0.11359571f, -0.08382325f, 
    0.17377514f, -0.18335555f, 0.05007451f, 0.00543024f, -0.05795150f, 0.09288900f, 0.00311736f, -0.14999439f, 
    0.04160661f, 0.18591093f, 0.06013875f, 0.15884796f, -0.11802550f, 0.02668866f, 0.17267360f, -0.61379343f, 
    0.07713589f, 0.26046112f, -0.14233251f, -0.20827362f, -0.17142338f, -0.17493042f, 0.13069384f, -0.23794395f, 
    -0.73114616f, 0.76125491f, -0.13232152f, -0.43545118f, 0.24848647f, 0.06769510f, -0.21579272f, -0.10895058f, 
    0.00707952f, -0.01268993f, 0.17649621f, -0.01173562f, 0.41051444f, -0.26815116f, -0.21414198f, -0.14394929f, 
    -0.07985899f, 0.00912007f, 0.26226142f, 0.08287366f, -0.12279718f, -0.10071103f, 0.14863110f, -0.06985492f, 
    -0.74300265f, -0.45017895f, -0.00159368f, 0.20809217f, -0.05076257f, -0.11433190f, -0.12046809f, -0.09575150f, 
    0.20040743f, -0.14553826f, 0.05104110f, -0.07066301f, 0.04827497f, -0.30041176f, 0.09172995f, 0.25156432f, 
    0.19040786f, -0.03793063f, -0.11986633f, 0.17638606f, -0.03372559f, 0.13248977f, -0.06145049f, 0.18173327f, 
    -0.18879795f, 0.48260805f, 0.32628313f, -0.10316943f, 0.18437958f, -0.24064727f, -0.06787866f, -0.10690147f, 
    -0.06134321f, 0.06060040f, -0.06259350f, 0.09850230f, 0.10575151f, 0.22017303f, 0.14965700f, -0.05283234f, 
    0.01237403f, 0.16441539f, 0.07648065f, 0.01384475f, -0.42378283f, -0.29100174f, -0.14847317f, 0.02716520f, 
    -0.98358870f, 0.03257788f, -0.29019639f, -0.12505928f, 0.03923598f, 0.02168041f, -0.21902636f, 0.04818397f, 
    -0.17818122f, -0.06182873f, 0.07071280f, -0.11294367f, -0.49945879f, 0.31693140f, -0.29531318f, -0.27850246f, 
    0.08942629f, 0.01231277f, -0.02384066f, 0.05746844f, 0.21374936f, -0.12161697f, -0.11872885f, 0.02281073f, 
    0.47388294f, -0.27061000f, 0.07612532f, -0.43172914f, -0.32070196f, 0.04232784f, -0.02712263f, -0.23515257f, 
    0.00567641f, 0.16507494f, -0.05645940f, -0.22601886f, -0.08391055f, 0.03557415f, 0.19458221f, -0.02839522f, 
    0.17397179f, -0.25575712f, 0.00716009f, -0.04686338f, -0.00017730f, 0.02428122f, 0.12041438f, 0.11810778f, 
    -0.34636006f, -0.25729939f, -0.21948670f, 0.04304566f, 0.07196773f, 0.08341134f, -0.01141586f, 0.20527630f, 
    -0.13352261f, 0.32093936f, -0.16857991f, 0.05271468f, -0.71412557f, -0.65159827f, 0.17518090f, 0.29799056f, 
    0.04362964f, 0.22106875f, 0.16463734f, 0.17683005f, 0.35432667f, 0.12196166f, 0.12328286f, 0.08978042f, 
    0.32774237f, 0.28361377f, -0.36802939f, 0.07292354f, 0.07181194f, 0.12825365f, -0.18732190f, 0.07959384f, 
    0.24233949f, 0.25940952f, 0.19495219f, 0.06492789f, 0.15921044f, -0.43763462f, 0.00892841f, 0.10470376f, 
    0.14927843f, -0.05598997f, 0.09537952f, -0.01568334f, -0.02591030f, 0.13422851f, -0.21508440f, -0.01196385f, 
    0.32019430f, 0.27162984f, 0.05705708f, 0.06400144f, 0.09860934f, 0.28276932f, 0.06943564f, 0.02572019f, 
    0.17304707f, -0.14103347f, -0.07419933f, -0.28150713f, -1.06669688f, -0.25778529f, -0.19817334f, -0.22835927f, 
    0.32926974f, -0.20414691f, 0.03191042f, -0.19031520f, 0.03664790f, 0.26129094f, 0.06327412f, 0.29038593f, 
    -0.90121949f, -0.43154103f, -0.20395008f, -0.51683640f, 0.27445468f, -0.05190099f, -0.00535877f, -0.06383131f, 
    0.05901759f, -0.40247992f, -0.01051102f, 0.06212470f, 0.10314710f, 0.37799355f, 0.37770230f, -0.26049757f, 
    0.18679066f, 0.00427164f, 0.07741907f, -0.05275719f, 0.10009670f, -0.02840814f, 0.21679100f, -0.01239687f, 
    0.36417046f, -0.07167490f, -0.16404551f, 0.12778109f, -0.32019332f, -0.23686785f, 0.00155591f, 0.07970025f, 
    -0.11046351f, 0.17794241f, -0.11100208f, 0.03374478f, 0.63064021f, 0.31166402f, -0.34464246f, 0.04425554f, 
    -0.43175355f, -0.09564410f, 0.01332924f, -0.11119863f, 0.03423553f, -0.01690340f, 0.04000936f, -0.16831505f, 
    0.76423252f, 0.01755319f, -0.14549877f, 0.02955903f, -0.00836695f, 0.20245978f, -0.05188679f, -0.03813300f, 
    0.28209782f, -0.03428216f, 0.28545961f, -0.14635798f, -0.58658808f, 0.41926697f, -0.06940276f, -0.26330757f, 
    -0.23009852f, 0.05535417f, 0.14171556f, 0.09157234f, 0.02546348f, 0.05898004f, 0.11621557f, 0.08192947f, 
    -0.63604432f, 0.17581272f, 0.09174853f, -0.10929710f, -0.14749628f, 0.10141306f, -0.27204219f, 0.08580612f, 
    -0.10798520f, -0.07813580f, 0.13713033f, 0.11526778f, 0.09769069f, -0.12933347f, 0.03959911f, 0.48298544f, 
    -0.26149499f, 0.01526677f, -0.11729369f, 0.13378251f, -0.05139909f, -0.11963661f, 0.29446396f, 0.03000514f, 
    -0.33260533f, 0.51915616f, 0.15632676f, 0.26264134f, -0.05301039f, -0.05241001f, -0.17391138f, -0.12030409f, 
    0.02857047f, -0.05734387f, 0.31680432f, -0.23249701f, 0.49828610f, -0.17058019f, -0.23631647f, 0.01378058f, 
    0.11891232f, -0.11404173f, -0.10243753f, -0.09787261f, 0.24614555f, -0.02336524f, -0.10899464f, -0.04705710f, 
    -0.18827416f, -0.33799410f, -0.17077395f, 0.12921156f, -0.00380781f, 0.18715835f, -0.04759258f, 0.03791063f, 
    -0.08491528f, 0.02631077f, -0.09852971f, 0.12738982f, 0.05691911f, 0.04429498f, -0.17630044f, 0.28918222f, 
    0.13616246f, -0.02959216f, 0.07481360f, -0.06050474f, -0.00486413f, 0.01668690f, -0.10196761f, -0.12134344f, 
    0.41116154f, -0.72825706f, 0.01445959f, 0.33120790f, 0.03986302f, 0.22334145f, -0.12866010f, 0.10967521f, 
    0.00054551f, -0.00307734f, -0.40262151f, -0.25705549f, 0.29892051f, -0.23719354f, 0.08631149f, 0.00589095f, 
    0.09966380f, 0.09439700f, 0.07719579f, -0.06427150f, -0.04938887f, -0.27340281f, 0.21291283f, -0.08456996f, 
    -0.72670120f, 0.20963638f, -0.36589777f, -0.15559281f, 0.21963450f, -0.23661087f, 0.06441890f, 0.09605703f, 
    0.00510985f, 0.20745866f, -0.09019694f, -0.12519217f, 0.68311042f, 0.16658089f, -0.31521609f, -0.58204752f, 
    0.13238715f, -0.06989767f, 0.03991322f, -0.03650376f, 0.16654542f, -0.12175813f, 0.02554148f, 0.01030140f, 
    0.12787001f, -0.47495583f, -0.40469211f, -0.22870988f, -0.19354776f, 0.13059889f, 0.00991318f, 0.02980272f, 
    0.09019356f, 0.08839331f, 0.07458317f, -0.19196570f, 0.20108843f, 0.18014926f, -0.28718603f, -0.54689479f, 
    -0.35670793f, -0.15379572f, -0.11946104f, -0.15768981f, -0.08895084f, -0.04727343f, -0.02083221f, -0.11781768f, 
    0.35300639f, -0.04535637f, -0.06561971f, 0.24504533f, -0.25358480f, 0.23919557f, -0.21362594f, -0.28377104f, 
    0.05463967f, 0.04949650f, 0.02556502f, 0.22340247f, -0.23296705f, -0.18308674f, -0.13934074f, -0.02449280f, 
    -0.01452862f, 0.09045520f, 0.19013748f, 0.01090250f, -0.19743700f, -0.02313802f, -0.20413269f, -0.13366006f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19757006f, 0.04717842f, -0.15499997f, -0.02728601f, -0.02967522f, 0.06602255f, 0.08702510f, -0.19364166f, 
    -0.02411935f, -0.03003042f, 0.26011941f, -0.03240550f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
