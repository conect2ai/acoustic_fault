#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.03175189f, -0.38888198f, 0.71072972f, 0.77789944f, 0.57700783f, -0.79316115f, 0.27417713f, -0.47691345f, 
    -0.80388534f, -0.25985160f, 0.21323858f, 0.14037783f, 0.39970163f, 0.51663327f, 0.06164612f, -0.14188002f, 
    0.32958394f, 0.09369528f, 0.17711148f, -0.02269966f, 0.01898599f, 0.20339191f, -0.06472111f, 0.04033022f, 
    0.01520603f, -0.50886869f, -0.97196674f, -0.29975677f, -0.22508855f, -0.03859862f, -0.22565696f, 0.62795633f, 
    0.03902958f, -0.20832674f, 0.00200575f, -0.17045610f, 0.08595469f, 0.28496894f, 0.11536036f, -0.47306862f, 
    -0.32283562f, -0.07958000f, 0.01251365f, -0.15414238f, 0.06605614f, 0.39684623f, 0.52686185f, -0.35124093f, 
    0.29087394f, -0.43406564f, -0.47483560f, -0.93784451f, 0.03014234f, 0.46129444f, 0.36288232f, -0.22387134f, 
    0.82608944f, -0.34760922f, 0.34986848f, 0.27666503f, 0.20523556f, 0.20393585f, -0.04352648f, 0.22525458f, 
    0.33434233f, -0.01375071f, 0.23230895f, 0.17553256f, -0.16221520f, 0.11293280f, -0.18596224f, 0.24121808f, 
    0.58534330f, 0.00387903f, 0.09643641f, -0.42379668f, -0.08667172f, -0.10940924f, -0.71548319f, -0.50605953f, 
    0.43601221f, -0.22371519f, 0.27855608f, 0.33400080f, -0.15986468f, -0.53204048f, 0.57174349f, 0.19819644f, 
    -0.07465060f, -0.56760263f, -0.18055406f, 0.07794859f, -0.08477183f, 0.06781181f, -0.39253074f, -0.29487720f, 
    -0.29788169f, 0.16053046f, -0.01185254f, -0.02483273f, 0.68016577f, 0.52639365f, -0.68570149f, 0.70781577f, 
    0.83136731f, -0.06114450f, -0.00004540f, 0.68759662f, 0.43362617f, 0.45137757f, -0.23397212f, -0.28822353f, 
    -0.14040196f, -0.48038909f, -0.11713156f, -0.06533158f, -0.28208762f, -0.20862523f, -0.18676357f, 0.00662652f, 
    0.04204523f, -0.04166944f, -0.13099934f, 0.04586572f, -0.02963851f, -0.66540921f, 0.86882102f, 0.02383556f, 
    -0.36102909f, 0.51643866f, 0.72171539f, -0.51469344f, -0.98360956f, -0.33258063f, -0.43644160f, -0.25592512f, 
    0.03271972f, -0.16553377f, 0.29000869f, -0.46883878f, -0.48848033f, -0.10694276f, -0.03642654f, -0.04919897f, 
    -0.09496254f, 0.00459271f, -0.11936457f, -0.07962228f, -0.06144163f, -0.03047456f, 1.22971797f, -0.03258685f, 
    0.27481157f, 1.13639903f, 0.86936551f, 0.57227868f, 0.35398030f, -0.06918200f, -0.13230814f, -0.19419701f, 
    -0.33647707f, 0.15440612f, -0.09931839f, 0.10765047f, -0.10763781f, -0.00397485f, 0.02972331f, 0.26637685f, 
    0.25508243f, 0.00291746f, -0.05084711f, 0.15919632f, 0.12785991f, -0.01314591f, 0.16530707f, 0.59674805f, 
    0.51057482f, -0.86005062f, -0.77974796f, -0.64242971f, 0.10768897f, -0.04454616f, -0.03182686f, 0.08769175f, 
    0.36730108f, 0.44337794f, -0.09580446f, 0.25424305f, -0.10693602f, 0.02260119f, 0.28798145f, 0.35508576f, 
    0.02518030f, 0.18368147f, 0.54895830f, 0.06701444f, -0.08164135f, 0.24371891f, -0.05231361f, 0.31910899f, 
    0.76258552f, -0.20649290f, -0.60096180f, -0.71409351f, 0.20172220f, 0.93632489f, 0.62675643f, -0.46120211f, 
    0.01615383f, 0.08857048f, -0.15800463f, 0.45003039f, -0.15090230f, 0.47399831f, 0.27314863f, -0.11860038f, 
    -0.04194334f, -0.13639109f, 0.12734833f, 0.28534099f, 0.09355044f, 0.12214915f, 0.00274727f, -0.15484296f, 
    0.06495737f, -0.55118638f, -0.50965863f, 0.29739401f, -0.02800185f, -0.45582345f, -0.75085449f, 0.39881527f, 
    0.33107567f, -0.75904429f, -0.68560368f, -0.14349252f, 0.37812170f, 0.06849420f, 0.13127172f, 0.40062630f, 
    -0.04742172f, -0.21938482f, -0.02889778f, -0.01061715f, 0.20062843f, -0.19561648f, -0.16023092f, -0.09109728f, 
    0.40278101f, 0.18585247f, -0.13336430f, -0.52588582f, -0.87079185f, -0.58421701f, -0.51343542f, -0.76466227f, 
    0.06180316f, 0.47503021f, -0.29612198f, 0.13660845f, 0.63194031f, -0.33091009f, 0.05193673f, -0.01300359f, 
    0.30720210f, 0.11580184f, 0.31838334f, 0.07130213f, 0.03135686f, -0.06000556f, -0.24912745f, -0.00951926f, 
    -0.12480918f, -0.09101591f, -0.14925446f, -0.17532508f, -1.14581072f, -0.38786054f, 0.15081610f, 0.65475452f, 
    -0.66980422f, 0.70764846f, 0.73399961f, -0.61757654f, 0.29954636f, 0.06510085f, 0.00581357f, 0.05233840f, 
    -0.26631731f, 0.10394724f, -0.11379758f, -0.16829215f, -0.09620373f, -0.12700546f, -0.23871385f, 0.09208962f, 
    -0.23524493f, -0.06408872f, 0.02997193f, 0.11484043f, 1.28871465f, 0.86874980f, 0.74738640f, 0.12465360f, 
    0.22574674f, 0.15220000f, -0.57855374f, -0.06216050f, 0.53526646f, 0.30984971f, -0.32591045f, -0.17454149f, 
    -0.01344144f, -0.15437706f, 0.13917339f, -0.31284440f, 0.08941949f, 0.03303357f, -0.23211835f, 0.15448791f, 
    0.32033071f, 0.05743372f, 0.11358266f, -0.07043332f, 0.21834265f, 0.76066023f, 0.32203013f, -0.46089780f, 
    -0.27138844f, -0.44555002f, -0.83527124f, 0.24315715f, -0.49762481f, -0.11409856f, -0.17585711f, -0.23186065f, 
    0.29486126f, 0.30815807f, 0.27206656f, 0.28322360f, -0.18934347f, -0.18852513f, -0.00822048f, 0.05748538f, 
    -0.20766751f, 0.40671518f, 0.10838649f, -0.23828924f, -0.17834161f, -0.29499689f, -0.38676307f, -0.17151700f, 
    -0.63145286f, -0.49301222f, -0.56538010f, 0.68288010f, 0.97638029f, 0.24424782f, 0.62181532f, 0.60665745f, 
    0.17128183f, -0.30525631f, -0.29591727f, -0.34011534f, -0.20813595f, 0.07240455f, -0.00300251f, 0.08451724f, 
    0.08465729f, -0.28849596f, -0.09827583f, -0.18294659f, -0.03262394f, -0.08369832f, -0.09166783f, 0.09918236f, 
    1.14328170f, 0.12512164f, -0.55221832f, -0.21861634f, -0.40099302f, 0.46108866f, -0.48621944f, -0.44118109f, 
    -0.38768739f, 0.19504283f, -0.03010460f, -0.15707037f, -0.35778517f, -0.04155720f, -0.08420153f, -0.26039428f, 
    -0.12788625f, -0.05007747f, -0.48829710f, 0.01135200f, -0.07865953f, -0.05001708f, 0.14320531f, 0.20466118f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15165417f, 0.28801757f, 0.30406824f, 0.01918541f, 0.17401755f, -0.00764744f, 0.17511667f, 0.24581461f, 
    0.38579729f, 0.13478559f, 0.34568858f, 0.23540953f, 0.47607756f, 0.28666618f, -0.05425217f, 0.22334859f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.25145406f, -0.15830988f, 0.04856285f, 0.05331149f, 0.04210363f, 0.06532454f, 0.01157322f, -0.09371830f, 
    0.06166456f, 0.09723018f, 0.13471562f, 0.11699145f, -0.29795930f, -0.04779314f, -0.01180720f, -0.21103202f, 
    0.14398383f, -0.16066353f, 0.06606854f, 0.14438759f, 0.11211371f, 0.04324243f, 0.07612553f, -0.10258247f, 
    -0.14774182f, -0.16226603f, 0.02451078f, -0.17783417f, -0.03125314f, 0.15469836f, -0.06633460f, -0.01487495f, 
    0.09089514f, 0.02104939f, 0.05669088f, 0.24635716f, 0.13106406f, -0.02846111f, 0.02645137f, 0.10099345f, 
    0.13866827f, 0.07724547f, 0.02078999f, -0.08304192f, -0.16332881f, -0.17968048f, 0.12316821f, 0.09795085f, 
    0.47849604f, 0.09690212f, 0.24499370f, 0.08339125f, -0.08481650f, 0.07012075f, -0.00171454f, -0.11828700f, 
    -0.12020382f, -0.10196294f, -0.07024134f, -0.12362793f, -0.31375659f, -0.19758791f, 0.26343051f, -0.25858489f, 
    0.09580778f, 0.01123399f, 0.20278880f, -0.01792374f, -0.10837494f, 0.21612237f, -0.05079497f, -0.03752983f, 
    0.54581761f, 0.24023478f, 0.33877298f, 0.16817290f, -0.03413540f, 0.15120260f, -0.04065192f, 0.02498835f, 
    0.05613855f, 0.06829172f, 0.12518735f, 0.08813057f, -0.05378576f, 0.26394215f, -0.06224800f, -0.09427682f, 
    -0.10877454f, -0.07676580f, 0.07327297f, 0.00860126f, -0.04654337f, -0.14350452f, 0.17450890f, 0.11963978f, 
    0.03791084f, 0.00337824f, 0.09157777f, -0.42651623f, -0.11754732f, -0.06710863f, 0.02490317f, -0.03185393f, 
    -0.05741317f, 0.02650728f, 0.05739637f, 0.12927842f, 0.03305485f, -0.36619237f, -0.20918810f, -0.02396889f, 
    0.04135884f, -0.04411209f, 0.14548539f, -0.13958959f, 0.03610738f, 0.28485298f, 0.15804586f, 0.07135385f, 
    -0.15130104f, -0.17072180f, -0.02552832f, 0.30359805f, 0.09122057f, -0.02852302f, -0.10274675f, 0.11282449f, 
    0.05477802f, 0.09698632f, -0.07947975f, 0.07423344f, -0.01716559f, -0.00146402f, 0.05663258f, -0.24630997f, 
    -0.11071397f, 0.20555647f, -0.04735444f, -0.04485039f, 0.04526160f, -0.15936361f, -0.07517149f, -0.03129060f, 
    0.06850886f, -0.13012096f, 0.22587526f, 0.30410922f, -0.04075558f, -0.07584944f, 0.09755880f, 0.07114714f, 
    0.01439304f, -0.08049364f, 0.01505192f, -0.05525449f, -0.00553657f, -0.04944943f, 0.02661218f, -0.11591467f, 
    0.08465737f, -0.10712636f, 0.06450208f, 0.10333562f, -0.04860224f, -0.07595252f, 0.21620370f, -0.15763800f, 
    0.23162682f, 0.21336006f, 0.05831061f, 0.13003162f, 0.05554957f, 0.07520650f, 0.07103346f, -0.05078481f, 
    0.12313067f, -0.03298490f, -0.08474305f, 0.03239152f, -0.19875830f, 0.14608519f, -0.06341011f, 0.03098597f, 
    0.04207338f, -0.04176961f, 0.04610224f, -0.03447673f, 0.10468837f, -0.03850364f, -0.12185629f, -0.09251806f, 
    -0.30530351f, 0.11586804f, 0.20415629f, 0.37194484f, -0.10394261f, 0.09349900f, 0.06103633f, -0.03543681f, 
    -0.00834680f, 0.00984995f, -0.02136600f, 0.04036190f, -0.11270640f, 0.23242939f, 0.03524915f, 0.13134311f, 
    -0.09943329f, 0.00613750f, 0.07102550f, 0.11826301f, -0.00946256f, -0.13043028f, 0.10328021f, -0.09529478f, 
    -0.13253050f, 0.27231172f, -0.13936542f, 0.21119162f, -0.02106126f, 0.03425792f, -0.09522577f, -0.00500590f, 
    0.03304884f, 0.04419453f, 0.00674745f, 0.05871655f, -0.13930099f, -0.02312413f, 0.11498238f, -0.15972866f, 
    0.00190868f, -0.01561270f, -0.05136777f, -0.01882809f, -0.12306553f, -0.05187536f, -0.07233644f, -0.10998247f, 
    0.23607849f, -0.18317412f, -0.04924950f, 0.19228458f, -0.17077024f, 0.04515288f, 0.10093424f, -0.04471289f, 
    0.02331643f, 0.08834164f, 0.05874594f, -0.00243352f, 0.40985140f, 0.03760931f, 0.10814186f, 0.00010284f, 
    0.00704851f, 0.14306521f, 0.04594070f, 0.05910898f, 0.06078903f, -0.01383551f, 0.04040528f, -0.08086228f, 
    0.12722637f, -0.31060630f, 0.11544611f, 0.55835611f, -0.09756675f, 0.14422800f, -0.00321362f, 0.10905007f, 
    -0.02829439f, 0.01467604f, 0.02549206f, 0.05872755f, 0.11126805f, -0.16733634f, -0.09745214f, -0.16888992f, 
    -0.01844158f, 0.03768049f, 0.07328859f, 0.06260872f, 0.03941846f, 0.00850611f, -0.04142160f, 0.03134693f, 
    0.00999123f, -0.31188059f, 0.04423466f, -0.18128251f, -0.01022832f, 0.00423109f, 0.01199598f, -0.01152278f, 
    -0.04152716f, 0.11368123f, 0.03412831f, 0.17123668f, -0.25852162f, 0.28151545f, 0.14570414f, -0.13826250f, 
    0.10215931f, -0.09647832f, -0.09193495f, 0.03386930f, -0.08554117f, 0.02493198f, 0.02379981f, 0.00711632f, 
    0.07979976f, -0.00746078f, -0.03893372f, 0.00784496f, -0.14901215f, -0.01178903f, 0.13035709f, -0.08214909f, 
    0.09054200f, -0.00198637f, 0.05522138f, 0.09992697f, -0.31961107f, 0.30584076f, -0.16995488f, 0.04046306f, 
    0.15995456f, 0.03395988f, 0.04760244f, 0.08872376f, -0.09144134f, 0.03439557f, -0.01946853f, -0.00622331f, 
    0.18337411f, -0.38086522f, -0.26109466f, -0.01061498f, 0.09078234f, -0.15356678f, 0.05250719f, 0.02615294f, 
    0.01293747f, 0.04602094f, -0.04123339f, 0.08329669f, -0.05106552f, 0.09131343f, 0.05880912f, -0.22450267f, 
    0.04579119f, 0.05075488f, -0.19325596f, 0.03556556f, 0.00757255f, 0.11424810f, 0.00427351f, 0.04258643f, 
    0.25558877f, 0.13066334f, 0.03268227f, -0.15837759f, -0.11961023f, -0.05078737f, 0.00057729f, 0.11760192f, 
    0.02999902f, 0.06609710f, -0.04795691f, 0.03815949f, -0.16799477f, 0.29866818f, 0.06762780f, -0.12144685f, 
    -0.07725733f, 0.03402017f, 0.11268684f, 0.00070271f, 0.04515220f, 0.07620110f, 0.02695780f, 0.03564645f, 
    -0.42006126f, 0.19750617f, 0.19639479f, -0.23083596f, -0.11666550f, -0.04764710f, -0.10630334f, 0.09374431f, 
    0.08075292f, -0.05818992f, -0.09869038f, -0.02446955f, 0.45357430f, 0.07142889f, -0.02020047f, 0.16457757f, 
    0.09653679f, 0.14445145f, -0.03208966f, -0.09876452f, 0.01035612f, 0.09670754f, 0.01321026f, 0.07573240f, 
    0.03726451f, -0.15228258f, -0.10860721f, -0.02078810f, 0.00569560f, -0.06474708f, 0.13632283f, 0.05167106f, 
    0.02686596f, -0.06042960f, 0.00516961f, 0.05893841f, 0.05292630f, -0.07592072f, 0.11801409f, 0.15807636f, 
    0.06331201f, -0.13873054f, -0.00049283f, 0.29401749f, 0.16440476f, 0.01575803f, 0.13004076f, -0.00693482f, 
    0.07205964f, -0.23297034f, -0.13975158f, -0.01916933f, 0.02328896f, 0.05307177f, 0.02771863f, 0.09632577f, 
    0.10944058f, 0.10013264f, -0.14628351f, 0.19121675f, 0.11622669f, 0.28234974f, -0.40356627f, -0.08983535f, 
    -0.00160338f, 0.10854995f, -0.03398222f, 0.10479682f, -0.12705778f, -0.07239155f, 0.10516444f, 0.07947197f, 
    -0.20350033f, 0.27395776f, -0.26572829f, -0.32765344f, 0.00108634f, -0.00770040f, 0.03754934f, 0.00212941f, 
    -0.05128849f, 0.05019696f, -0.09172830f, 0.04350794f, 0.09507792f, -0.33319595f, 0.23958625f, -0.00110131f, 
    -0.08770103f, 0.09042111f, 0.05405241f, 0.04845092f, -0.08546887f, 0.14399631f, 0.06737020f, -0.07531107f, 
    -0.08076075f, 0.18275498f, 0.12762821f, 0.26899809f, 0.22619294f, 0.07666041f, -0.03752016f, 0.07092983f, 
    0.04759949f, -0.03960349f, -0.12445946f, -0.14076322f, 0.06172996f, 0.15019813f, 0.08328180f, -0.02134524f, 
    -0.05146372f, 0.01428536f, -0.03967452f, 0.05799717f, -0.00161975f, -0.05742039f, -0.03969868f, 0.02741294f, 
    0.61755848f, 0.01889167f, 0.05679205f, 0.08841432f, -0.13213016f, 0.11879376f, 0.14058141f, 0.10575317f, 
    -0.00914555f, 0.07380462f, 0.19130981f, 0.01810802f, 0.42817771f, -0.22375444f, 0.03147312f, 0.15849072f, 
    0.02871762f, -0.05991812f, 0.08828197f, 0.05924895f, -0.11970983f, 0.00744022f, 0.02678378f, -0.04783072f, 
    -0.14569378f, -0.07511304f, 0.00117599f, 0.00246548f, -0.05964799f, 0.23156624f, -0.03011326f, -0.04898017f, 
    -0.02339212f, 0.10573874f, -0.02383712f, 0.11064737f, 0.18833756f, -0.32104984f, 0.17321941f, 0.15410975f, 
    0.00604152f, -0.03294160f, 0.02840419f, 0.03012122f, 0.00303512f, 0.04424585f, -0.04866348f, 0.08098452f, 
    -0.28985840f, -0.02239606f, -0.02166967f, 0.03438940f, 0.14409551f, -0.04092081f, 0.03576010f, 0.11851161f, 
    0.09121641f, 0.06370335f, 0.15019700f, 0.01801360f, -0.06458136f, -0.25437981f, 0.17877622f, -0.12840916f, 
    -0.05261013f, 0.06494013f, 0.00547949f, -0.06522955f, 0.20167029f, -0.03974833f, 0.09933531f, 0.03957956f, 
    -0.27701288f, -0.04566865f, -0.04092965f, 0.05317990f, -0.13398910f, 0.01717526f, -0.15918185f, -0.07237066f, 
    -0.03012878f, -0.01186903f, -0.24999817f, -0.00267552f, -0.20547073f, 0.21142498f, 0.32388717f, 0.19692263f, 
    -0.06972392f, 0.16651316f, 0.14163163f, 0.02325834f, -0.02128894f, -0.09190693f, -0.17676976f, -0.10307059f, 
    -0.43810880f, 0.13323358f, -0.00459329f, 0.00925583f, -0.01362919f, 0.01890373f, -0.23707449f, -0.05370101f, 
    -0.04576638f, 0.04586640f, -0.23198849f, -0.05027654f, 0.17032728f, 0.22366077f, 0.24639677f, 0.17392527f, 
    0.03367744f, 0.07971068f, 0.05107389f, 0.22023080f, -0.00108318f, 0.18753958f, 0.10866056f, 0.03082114f, 
    0.15250650f, -0.02961489f, -0.12579483f, 0.18861140f, -0.05724017f, 0.05982011f, -0.14641315f, -0.08082082f, 
    -0.01867500f, 0.20029981f, 0.26410252f, 0.20619708f, 0.03496965f, 0.28782380f, 0.05916608f, -0.17889942f, 
    -0.10329969f, 0.01072276f, -0.11746229f, 0.12777320f, 0.05169863f, 0.00908528f, 0.02544286f, 0.14138797f, 
    -0.10740947f, 0.22225985f, -0.33111662f, 0.17427741f, -0.06059544f, -0.12527172f, -0.07347231f, -0.02721507f, 
    -0.04882618f, -0.22252193f, -0.02966520f, -0.02124059f, 0.09328053f, -0.10443447f, 0.22713430f, -0.06475178f, 
    -0.06494081f, -0.02092929f, 0.12293658f, 0.20690805f, -0.12083360f, 0.03123733f, -0.15724398f, -0.04640272f, 
    -0.07228476f, 0.04632090f, 0.14399347f, 0.08275389f, 0.07496048f, -0.02547245f, 0.01835954f, 0.00932719f, 
    0.08093788f, 0.03361376f, 0.01643510f, 0.10165926f, -0.00985879f, 0.21287359f, 0.12939888f, 0.16378741f, 
    0.17580019f, 0.11561199f, -0.19011717f, 0.05515730f, 0.11200020f, -0.20190972f, -0.09205903f, -0.00042751f, 
    0.25429097f, 0.03916473f, -0.07732964f, 0.17445484f, -0.11154216f, -0.04739339f, 0.13833715f, -0.05865772f, 
    -0.05617751f, -0.02729459f, 0.11384206f, -0.05565698f, -0.28471228f, 0.04030101f, -0.15489763f, 0.06550579f, 
    0.06489009f, -0.08007156f, -0.12773751f, -0.05604761f, -0.05319882f, 0.11836714f, -0.00387769f, 0.03859380f, 
    0.42990020f, -0.06593695f, -0.28752011f, -0.03058223f, -0.07983933f, 0.05064864f, -0.01951298f, -0.21713018f, 
    -0.15591490f, -0.04528283f, 0.00694298f, 0.12168121f, -0.14343034f, 0.07244830f, 0.14302003f, -0.00720441f, 
    -0.02881446f, 0.04554731f, -0.03093966f, -0.12450808f, -0.02555942f, -0.02104359f, -0.03296131f, 0.03014926f, 
    -0.05970854f, 0.17025155f, 0.10491873f, -0.26085973f, 0.17568785f, -0.04104681f, 0.07441667f, 0.32757553f, 
    -0.04240165f, -0.03658233f, 0.12298078f, 0.16075085f, 0.16631387f, -0.08130416f, 0.37648815f, -0.16055591f, 
    -0.04006563f, -0.07331117f, 0.02702707f, -0.09799329f, -0.01464557f, 0.14250465f, 0.22496948f, -0.03003432f, 
    0.38729283f, -0.03457364f, 0.09599331f, 0.03358853f, 0.03683135f, -0.08262480f, 0.09786493f, -0.01424124f, 
    -0.06268576f, 0.06483106f, 0.12581040f, 0.11565190f, -0.45802507f, 0.06003837f, 0.02634809f, 0.01683713f, 
    0.25043443f, -0.05839888f, 0.06626873f, -0.01141843f, 0.05613999f, 0.01160563f, 0.07787757f, -0.10395915f, 
    -0.30405739f, 0.17484492f, -0.04568853f, -0.22519363f, 0.12309875f, 0.09134582f, 0.06167727f, 0.14576706f, 
    0.03337096f, 0.01818520f, -0.01296230f, -0.03120374f, 0.04497392f, -0.05847260f, -0.18811420f, 0.13712800f, 
    0.06660276f, 0.11459242f, -0.14061815f, -0.15494949f, 0.05231646f, -0.03078014f, -0.09289769f, -0.00470051f, 
    0.07523350f, 0.14209872f, 0.21562985f, -0.10443758f, 0.00109803f, 0.05049707f, -0.03909206f, -0.04573062f, 
    -0.05306894f, -0.02320138f, 0.05256173f, -0.06931146f, -0.19483332f, -0.06355928f, 0.48011205f, 0.13895035f, 
    -0.03002765f, 0.10408258f, 0.17892882f, 0.00175539f, 0.01433760f, 0.03133904f, 0.02751223f, 0.03808704f, 
    0.27682519f, -0.03831605f, 0.25254053f, -0.06965577f, -0.07479329f, 0.11046505f, 0.05247959f, -0.02416189f, 
    0.02228451f, -0.00452270f, -0.02021031f, 0.07347510f, 0.07601664f, -0.02726311f, -0.19952883f, 0.08160690f, 
    0.10201353f, -0.08357522f, 0.04486189f, -0.08129712f, -0.10499731f, -0.09176900f, -0.01091115f, -0.12219751f, 
    -0.07382958f, -0.48575419f, -0.01777527f, -0.17917413f, -0.11231442f, -0.07860810f, 0.02331719f, -0.00725605f, 
    0.02411993f, 0.07870971f, -0.01920472f, 0.08498634f, -0.05554560f, -0.05582584f, 0.13729329f, 0.31681508f, 
    -0.01714080f, -0.02722526f, 0.07213325f, 0.10994283f, -0.03279756f, 0.16531946f, 0.11559145f, -0.12546067f, 
    -0.14405911f, 0.12393704f, 0.02818689f, 0.25359681f, 0.18794423f, 0.00866142f, 0.00138596f, -0.01059284f, 
    0.18501812f, 0.09143857f, -0.16320892f, 0.04308592f, -0.40143827f, 0.15290447f, -0.14451008f, -0.35111955f, 
    0.02218015f, 0.09490445f, 0.07681493f, 0.04623577f, 0.08823253f, -0.14344977f, -0.00822131f, -0.08023205f, 
    0.47082207f, 0.11140745f, 0.13200271f, -0.04399981f, -0.19244428f, -0.09964239f, 0.01851010f, 0.21087894f, 
    0.00347452f, -0.11127025f, 0.16276577f, 0.16416657f, 0.16363475f, 0.01602372f, 0.17560153f, 0.11964213f, 
    -0.03846915f, -0.22755818f, -0.03103262f, -0.00160601f, -0.00958575f, -0.01614161f, 0.16606617f, -0.12808736f, 
    0.00662275f, -0.16397502f, -0.11555349f, -0.08875044f, -0.01710090f, 0.02478765f, 0.02755475f, 0.00224038f, 
    0.00435726f, 0.03675248f, -0.02668266f, -0.00425012f, 0.02446729f, 0.07938652f, 0.08353414f, 0.29705420f, 
    -0.00486318f, -0.06819122f, 0.07046016f, -0.04307989f, 0.00404164f, 0.00653238f, -0.12622277f, -0.15280792f, 
    0.29887509f, 0.07378659f, 0.01237341f, 0.17040476f, 0.03430869f, -0.08108574f, -0.02238193f, -0.18641417f, 
    0.13823517f, -0.02856702f, -0.25375393f, -0.05232058f, -0.00668583f, 0.22600234f, 0.08271485f, 0.04394957f, 
    -0.06711944f, 0.02774878f, -0.02290828f, -0.02377238f, -0.05507433f, -0.16033503f, -0.07997269f, 0.01751086f, 
    0.21479151f, -0.28070426f, 0.05525646f, -0.03010196f, 0.17067996f, -0.04816347f, -0.10566039f, -0.02199639f, 
    -0.10597936f, 0.10161983f, -0.15767598f, 0.01692560f, 0.41316870f, 0.25853604f, -0.05891487f, -0.13690241f, 
    0.07752923f, -0.05141919f, 0.08395676f, 0.31448153f, 0.22468153f, 0.30918309f, -0.12211109f, 0.01836833f, 
    0.08154576f, -0.07826967f, -0.00364006f, 0.49518791f, 0.17820349f, 0.01076455f, 0.09522163f, 0.08266892f, 
    0.09768262f, 0.09652361f, 0.18420430f, 0.26077378f, -0.12053797f, 0.31870657f, 0.12089428f, -0.34962395f, 
    -0.20249838f, -0.19682021f, -0.09973805f, 0.14134826f, 0.01016428f, 0.05953956f, -0.05789375f, 0.21566008f, 
    0.55072421f, 0.30463475f, -0.11794356f, 0.07868176f, 0.06797986f, -0.22435451f, -0.00636580f, -0.04461913f, 
    -0.04179415f, -0.01361709f, -0.15056641f, -0.01622810f, -0.12030563f, -0.13707420f, 0.13502464f, 0.01940699f, 
    -0.00611359f, 0.05532558f, 0.24204500f, 0.04853945f, -0.05548048f, -0.11994718f, 0.04365305f, -0.28847384f, 
    -0.25410566f, 0.08309864f, 0.14017057f, -0.31114429f, 0.14308429f, -0.06940782f, 0.05798268f, -0.05108759f, 
    0.17401838f, -0.14596058f, -0.19292285f, 0.03382566f, 0.02696862f, -0.18106955f, 0.03037883f, -0.09447489f, 
    0.04214915f, -0.01614010f, -0.07200660f, -0.06373914f, 0.07523872f, -0.26147333f, 0.04367109f, -0.11072143f, 
    -0.04132930f, 0.00750437f, 0.06859060f, 0.10137703f, -0.09627046f, 0.01275152f, 0.06098853f, 0.03674340f, 
    0.04439237f, -0.19087742f, 0.05965455f, -0.17747812f, 0.18442790f, -0.12489688f, -0.23569882f, 0.14914748f, 
    -0.04986174f, -0.13701889f, 0.05916043f, 0.00437260f, 0.06352039f, 0.04611427f, 0.19557399f, 0.21779950f, 
    0.08968650f, 0.15884788f, 0.20755598f, -0.08071541f, -0.17115335f, 0.05537221f, 0.01448823f, -0.27436924f, 
    0.05660303f, -0.04642125f, -0.01631277f, 0.10261603f, -0.10753235f, -0.22166483f, -0.05400104f, -0.00737155f, 
    -0.01694013f, 0.05910055f, -0.13609150f, -0.33059672f, -0.06210551f, -0.09096473f, -0.15943232f, 0.21832587f, 
    0.14989156f, -0.09671898f, 0.14115675f, 0.06322409f, 0.11912541f, 0.25832498f, 0.10912716f, 0.22671880f, 
    -0.02283426f, 0.02646445f, 0.04312325f, 0.21346655f, -0.15154874f, 0.00236067f, -0.08103553f, -0.25033554f, 
    -0.07035299f, -0.05058512f, -0.11132455f, -0.05252556f, -0.03219682f, 0.04784397f, 0.03459230f, 0.05329163f, 
    -0.43256894f, -0.04948115f, 0.00664814f, 0.11174367f, -0.01449426f, -0.09833225f, -0.15203810f, 0.11754986f, 
    0.03493632f, 0.03438338f, -0.09338073f, -0.05866101f, 0.26408449f, 0.20862816f, 0.22481942f, 0.11345194f, 
    -0.09469464f, 0.15655099f, 0.05174658f, -0.06979737f, 0.08621419f, -0.04668561f, 0.05774268f, -0.05973508f, 
    0.28637508f, 0.01269387f, -0.05495399f, -0.00415489f, -0.05911358f, -0.08717033f, -0.02540024f, 0.05511563f, 
    -0.11494565f, -0.00538924f, 0.03983210f, 0.06931791f, -0.07407510f, 0.14816992f, -0.09078128f, 0.01578384f, 
    -0.08318416f, -0.04202620f, 0.09835293f, 0.16978797f, -0.01420713f, 0.00934718f, -0.06211465f, -0.11174960f, 
    0.12285292f, -0.19138482f, -0.32063425f, 0.06661285f, 0.15195721f, -0.08257105f, -0.00523670f, 0.04220404f, 
    0.18383756f, 0.11165943f, -0.03865699f, 0.04936900f, 0.36270171f, 0.14926918f, -0.36610550f, 0.32590413f, 
    0.17046326f, 0.06283092f, -0.23168175f, 0.09583316f, 0.15337709f, -0.12998734f, 0.03019001f, -0.05800899f, 
    -0.24581659f, -0.28261358f, 0.02880729f, -0.07538556f, 0.03146198f, -0.05046841f, -0.11399306f, -0.09841187f, 
    -0.05419920f, -0.05721109f, -0.10020492f, -0.03327440f, 0.10024168f, -0.02077687f, -0.01993654f, 0.12079139f, 
    0.00159830f, 0.17869462f, -0.11652508f, -0.00234381f, -0.00881935f, 0.20277137f, -0.02718765f, 0.03096341f, 
    0.20919155f, -0.01318601f, -0.13256954f, 0.21064188f, 0.06240951f, 0.00590184f, -0.05319213f, 0.02682928f, 
    0.00501783f, -0.02705627f, -0.07573751f, -0.02599104f, 0.06606667f, 0.10500360f, 0.17517872f, -0.23429739f, 
    0.02377497f, -0.00206358f, 0.00692974f, 0.01543209f, 0.02248352f, -0.12005694f, -0.12522042f, 0.06132242f, 
    0.48098645f, 0.26037264f, 0.24760042f, -0.16327816f, -0.08664334f, 0.06277788f, 0.11992270f, 0.00397238f, 
    -0.21793944f, 0.12052592f, 0.01005866f, 0.05432271f, 0.30551314f, 0.05819361f, -0.01697809f, 0.17376918f, 
    0.05885989f, 0.00330084f, 0.15273574f, -0.01936324f, -0.01749608f, 0.02036882f, 0.11904614f, 0.05661245f, 
    -0.11343544f, -0.05961638f, -0.12080809f, -0.06424066f, 0.18748386f, 0.11911698f, -0.14907598f, -0.05060731f, 
    0.12591714f, 0.10690933f, 0.04188707f, 0.10003533f, 0.17590214f, 0.19303343f, -0.04169763f, -0.06911623f, 
    0.12863000f, 0.12707521f, -0.06945509f, -0.08728235f, 0.12575093f, 0.11282505f, -0.05447166f, -0.08905898f, 
    -0.09137601f, -0.13057861f, 0.09914538f, 0.31147954f, -0.11168706f, -0.22645028f, 0.09218474f, 0.12422404f, 
    -0.12507541f, 0.08092556f, 0.04460693f, -0.09126893f, 0.12085909f, 0.05748553f, -0.17832522f, -0.14537132f, 
    -0.02727901f, 0.10739351f, 0.04716249f, -0.06376716f, 0.12283727f, 0.01873963f, 0.11259669f, 0.22067948f, 
    -0.01688807f, -0.07597886f, -0.05298774f, 0.02239912f, 0.02020486f, -0.06064060f, 0.05890340f, -0.03256834f, 
    -0.06178953f, 0.03149655f, -0.04231195f, 0.04067308f, 0.05415158f, -0.07742647f, -0.04861066f, 0.04010690f, 
    0.06384882f, 0.00281251f, 0.01155652f, 0.03274518f, -0.05295877f, -0.02600956f, 0.01897393f, 0.02200513f, 
    0.02082175f, 0.03674368f, 0.00615674f, -0.05254738f, -0.01407304f, -0.06240342f, 0.02909835f, 0.05474056f, 
    -0.05478164f, -0.07322429f, -0.07180618f, 0.01814658f, 0.00962944f, -0.04651323f, 0.03138085f, 0.03659487f, 
    -0.03423038f, 0.00561671f, 0.05045738f, -0.05067196f, -0.04595132f, 0.04831502f, 0.06034222f, -0.02081338f, 
    -0.05040677f, 0.00552711f, -0.05443828f, 0.06399016f, 0.04063041f, -0.06546362f, -0.02761060f, 0.04388962f, 
    0.06170327f, -0.07829255f, -0.08093786f, 0.03138551f, 0.01886880f, -0.01122592f, 0.00620604f, -0.01945004f, 
    0.00877007f, 0.06220269f, -0.03778289f, -0.06477451f, -0.07801255f, 0.05681985f, 0.01991343f, 0.01640775f, 
    -0.06358301f, 0.02505539f, 0.02036159f, -0.02776170f, -0.04991319f, -0.04439642f, -0.04077719f, -0.06495300f, 
    -0.04414031f, -0.01851932f, -0.02465692f, 0.04465658f, -0.00764937f, 0.00225604f, 0.04687748f, 0.04025483f, 
    0.03004757f, -0.02296657f, 0.05071588f, -0.07563455f, -0.07145414f, -0.02525968f, -0.00555598f, 0.00125677f, 
    0.01872311f, -0.06653705f, -0.04721826f, -0.02281503f, -0.00222888f, 0.02462758f, -0.03734646f, 0.02368118f, 
    -0.00441290f, -0.02396630f, -0.02488820f, -0.04562804f, 0.01762731f, 0.00050624f, -0.01562816f, -0.07541707f, 
    -0.01278757f, -0.00461436f, -0.02017589f, 0.01263845f, 0.00433690f, 0.01527404f, 0.03916541f, 0.05699323f, 
    0.05142820f, 0.03443639f, -0.01805961f, 0.00285514f, -0.01760972f, 0.04099001f, -0.02642496f, 0.01964821f, 
    -0.02604455f, -0.02988380f, -0.04344535f, 0.00360978f, -0.00982741f, -0.04253059f, 0.06829562f, 0.03473146f, 
    0.00413145f, -0.01945317f, -0.02989819f, -0.02269538f, 0.01066723f, -0.00005899f, 0.02775729f, -0.00458702f, 
    0.04046465f, -0.00792499f, -0.02250535f, -0.00720235f, 0.01268346f, -0.04803335f, 0.02627774f, -0.07924108f, 
    -0.05396523f, -0.00530333f, -0.04485786f, -0.06860249f, -0.01760175f, -0.07382080f, 0.01680850f, -0.02490927f, 
    -0.03471197f, -0.03065786f, -0.06509686f, -0.00258615f, -0.06124573f, -0.04925621f, 0.01913998f, 0.00269245f, 
    0.04741340f, 0.02005900f, -0.06770692f, 0.03059403f, -0.02906576f, 0.02725313f, 0.01717518f, -0.00962248f, 
    0.05934184f, -0.00906786f, -0.02021826f, -0.08049701f, -0.02502528f, -0.06876519f, -0.01165342f, 0.02103143f, 
    0.01402712f, -0.08296742f, -0.05965691f, -0.04458179f, 0.05660558f, -0.06277836f, 0.06116841f, -0.06920273f, 
    0.12957560f, -0.02770741f, -0.14215226f, -0.04826234f, -0.17911470f, 0.00492866f, -0.09800312f, -0.20010933f, 
    0.21943909f, 0.15272343f, -0.13770707f, -0.07986309f, -0.19786043f, 0.08951851f, 0.13408169f, -0.02142733f, 
    0.13824219f, 0.01179822f, 0.02103463f, 0.06477363f, 0.11955306f, -0.17424048f, -0.03610234f, -0.19549128f, 
    0.04817186f, -0.12665914f, 0.02053550f, -0.01545647f, -0.01891206f, 0.04949523f, -0.13855922f, 0.00707033f, 
    -0.04324651f, -0.06199092f, -0.01667477f, 0.03807601f, 0.19190852f, 0.20587817f, 0.18241385f, -0.00723202f, 
    0.12836452f, -0.18879656f, -0.04569032f, 0.18679954f, 0.04708415f, 0.03606661f, 0.03191486f, -0.18009172f, 
    0.48457751f, -0.16309336f, 0.13916029f, 0.43877852f, 0.08540565f, 0.05856228f, 0.01976991f, 0.15138872f, 
    0.13063575f, 0.06583732f, -0.03823661f, 0.05023650f, -0.57872689f, 0.10399171f, 0.01669396f, -0.31854406f, 
    -0.05514318f, 0.07348540f, 0.10648036f, 0.04278485f, -0.11355025f, 0.14978318f, -0.00894877f, -0.02921676f, 
    0.48120654f, -0.00622550f, 0.08499663f, 0.34947902f, -0.10216753f, 0.02565886f, -0.04808719f, 0.09059078f, 
    -0.07728268f, 0.11076714f, -0.08004232f, 0.03581215f, 0.13630424f, -0.06456772f, 0.29124197f, -0.18726598f, 
    -0.07220522f, -0.12284131f, 0.15035664f, -0.06852686f, -0.14837380f, 0.08946680f, 0.10920668f, 0.02354927f, 
    0.15325323f, -0.06113268f, 0.14699377f, -0.28807113f, 0.03922692f, -0.12083931f, 0.10738579f, -0.07913986f, 
    -0.02600928f, 0.05998081f, -0.06875202f, 0.07828782f, 0.01461531f, -0.22424734f, -0.08392943f, -0.05426943f, 
    0.10231826f, 0.07581589f, -0.05036869f, -0.10102865f, 0.17508081f, 0.03420636f, 0.00082418f, -0.04918968f, 
    0.25070241f, 0.10792673f, 0.03463420f, 0.31421426f, -0.05092544f, -0.01195580f, 0.11301207f, 0.04607847f, 
    -0.00770541f, 0.03494665f, 0.03160116f, 0.02294343f, 0.11055813f, -0.12027353f, -0.10943168f, -0.03023452f, 
    -0.09962875f, -0.06248173f, -0.11412451f, -0.03621968f, 0.00543147f, 0.04694869f, -0.02725078f, 0.06983558f, 
    0.39113125f, -0.05090807f, 0.17301835f, 0.10443846f, -0.15337184f, -0.09673259f, 0.07772506f, 0.02396581f, 
    -0.14682254f, -0.08845777f, 0.02040448f, -0.03790326f, 0.07375904f, -0.11868639f, 0.03914485f, -0.11413290f, 
    0.15429905f, -0.10393439f, -0.12688988f, 0.03342482f, 0.03322608f, -0.13632622f, -0.14708310f, -0.05810809f, 
    0.34836039f, 0.19398510f, 0.13743320f, 0.24714822f, -0.04783637f, -0.05967312f, -0.04073207f, 0.17510264f, 
    -0.01514933f, 0.19972597f, -0.01917830f, 0.04669284f, -0.10084479f, 0.14977673f, 0.05824859f, -0.37916839f, 
    -0.04931625f, -0.04310228f, 0.06916068f, -0.18883251f, 0.06407674f, -0.08955029f, 0.00490425f, 0.00348262f, 
    0.07645386f, -0.08179356f, 0.27990779f, -0.08424632f, -0.07790823f, -0.12129004f, 0.01589212f, 0.05580052f, 
    -0.04177018f, -0.04236784f, -0.05252069f, -0.03030298f, 0.40780407f, 0.22395761f, -0.03589856f, 0.02713187f, 
    0.11732673f, 0.05067982f, 0.10564604f, -0.05169334f, -0.03636318f, 0.31054562f, 0.03317601f, -0.01581372f, 
    -0.38334858f, -0.04967951f, 0.02405673f, -0.03555499f, 0.13914067f, 0.16667081f, 0.03853161f, 0.07866106f, 
    0.00878370f, -0.03409379f, -0.01884966f, -0.05226658f, 0.27647629f, -0.09851529f, 0.02755254f, 0.26939628f, 
    0.17786399f, -0.08276134f, -0.03669550f, 0.12335673f, -0.02414784f, -0.01402397f, 0.18339597f, -0.05597819f, 
    0.08759321f, 0.06177131f, 0.16093551f, -0.10532052f, -0.18680963f, 0.04415410f, -0.12860471f, -0.07124608f, 
    0.00146743f, -0.29820251f, -0.04405727f, -0.22726309f, -0.08966549f, 0.22701673f, -0.03072107f, 0.03359983f, 
    -0.09336384f, -0.08726743f, 0.21261148f, -0.03758191f, -0.21030058f, -0.10492833f, -0.04494938f, -0.11740347f, 
    -0.16804229f, 0.13496566f, -0.03464743f, 0.23587056f, -0.19613580f, -0.04691067f, -0.04954973f, 0.03872483f, 
    -0.01505993f, 0.05291957f, -0.09199417f, -0.08817495f, 0.28476438f, -0.04707731f, 0.01677499f, -0.08102266f, 
    -0.06240688f, 0.05689450f, 0.02280436f, -0.00128951f, -0.07686540f, 0.07912159f, -0.00570941f, 0.01750645f, 
    0.23064990f, 0.03422486f, -0.15122333f, 0.01732279f, -0.02895783f, -0.01254435f, -0.11630139f, -0.01661139f, 
    -0.02107953f, 0.02727178f, -0.00625416f, -0.07672096f, 0.37896851f, 0.21261977f, 0.08551068f, 0.17140624f, 
    0.00352692f, 0.02615641f, -0.06658766f, 0.03975633f, -0.03957066f, 0.08898342f, -0.16193157f, 0.03321686f, 
    0.38379249f, -0.01227197f, 0.03533800f, 0.13702466f, 0.10227304f, 0.20522170f, 0.00222704f, 0.03096019f, 
    -0.04724628f, -0.10253242f, -0.02301890f, -0.08776505f, 0.28452873f, -0.03284544f, 0.25534180f, 0.05872500f, 
    -0.10195313f, 0.17470250f, -0.06205442f, 0.08430078f, -0.04490002f, -0.05634146f, -0.22612637f, -0.16524722f, 
    -0.08707021f, -0.33491418f, -0.01767320f, 0.08367318f, -0.26002666f, -0.14712566f, -0.05082978f, -0.03484778f, 
    -0.08869339f, -0.26733211f, -0.19297269f, -0.06303729f, 0.34218389f, 0.01618486f, 0.10914334f, 0.22329101f, 
    0.00109090f, -0.09723616f, -0.12355074f, 0.00014096f, -0.16089615f, -0.04019425f, 0.02932342f, -0.03844627f, 
    0.22688150f, 0.37825483f, -0.10075615f, -0.06488834f, 0.28282404f, 0.21095096f, 0.13151632f, -0.15818189f, 
    0.18701562f, 0.13539475f, 0.09878665f, -0.06510138f, 0.05891864f, -0.02240503f, -0.03292319f, 0.06776430f, 
    -0.18472634f, 0.02999776f, -0.17158499f, -0.02475969f, -0.09896161f, -0.05557407f, -0.01030354f, -0.05283989f, 
    -0.06701139f, 0.23083062f, 0.09076140f, -0.12258925f, 0.01666061f, -0.14734697f, -0.05836377f, 0.08179546f, 
    -0.10686369f, 0.07856973f, 0.03741897f, 0.07343607f, 0.06966995f, -0.13751884f, -0.25002706f, 0.17808308f, 
    0.06847374f, 0.11854912f, -0.01635724f, 0.08366270f, -0.12038814f, 0.17147684f, 0.05367402f, 0.12256284f, 
    -0.41800287f, 0.20129186f, -0.04942780f, 0.02948054f, 0.27222165f, 0.01307647f, 0.18789613f, 0.09529147f, 
    0.07888748f, 0.10209700f, -0.07851253f, -0.02948634f, -0.08990783f, -0.23394319f, -0.02754767f, -0.11619843f, 
    0.19067496f, 0.04783238f, -0.03754727f, -0.03648172f, 0.16378671f, 0.00135656f, 0.10146276f, 0.13217174f, 
    -0.19511247f, 0.01801943f, 0.14621100f, -0.11662974f, -0.01994972f, 0.02196908f, 0.01146644f, -0.03303962f, 
    -0.05515049f, 0.07075967f, 0.12307669f, 0.07539301f, -0.13595973f, 0.07125380f, 0.15582764f, -0.09755879f, 
    -0.09518648f, 0.09968178f, 0.17400852f, 0.12674439f, 0.01011727f, 0.02230452f, 0.11401302f, 0.10039465f, 
    -0.30524999f, 0.24608675f, -0.34559035f, -0.15488186f, 0.04521222f, 0.02708813f, 0.09108234f, 0.07892763f, 
    -0.09809700f, -0.05370897f, 0.10634888f, 0.04159239f, 0.09058330f, -0.28864700f, 0.18730533f, -0.10922949f, 
    0.05719730f, 0.04899076f, 0.16305681f, 0.07071910f, 0.05043138f, -0.00359532f, -0.08049902f, 0.04947807f, 
    -0.24810407f, 0.16668880f, 0.05273991f, 0.20947467f, 0.19207355f, 0.08660839f, -0.07435615f, 0.11228575f, 
    0.09101836f, 0.21487477f, 0.00122946f, -0.04843298f, -0.18353635f, 0.24570280f, -0.00786096f, 0.41261575f, 
    0.10807842f, 0.05470227f, -0.05935246f, 0.20757337f, -0.04843396f, -0.02385254f, 0.12567049f, 0.10731637f, 
    -0.21421349f, -0.08348432f, -0.13894354f, -0.02550193f, -0.05293648f, 0.07666628f, -0.04255303f, -0.05480845f, 
    0.00866079f, 0.01666031f, 0.08324986f, -0.01022075f, -0.57466382f, 0.09489357f, -0.22913079f, 0.11950332f, 
    0.18259341f, 0.03448188f, 0.06000733f, 0.15019169f, 0.00334613f, 0.01186832f, -0.01228532f, -0.09860304f, 
    0.18427351f, 0.06245412f, 0.09594524f, -0.11971062f, -0.03241577f, 0.11095687f, -0.02571980f, 0.02447388f, 
    0.02611534f, -0.04925516f, -0.08930354f, -0.02999398f, -0.13198420f, -0.14381942f, 0.25555581f, 0.26931620f, 
    -0.06832184f, 0.10249452f, 0.13162841f, 0.05865273f, 0.05379961f, 0.02416022f, 0.03471525f, 0.06244149f, 
    -0.19091515f, -0.08958896f, -0.07247846f, -0.34244329f, 0.13502346f, 0.12689988f, -0.00649511f, -0.00404972f, 
    0.10895097f, -0.07713290f, 0.01141026f, -0.00526284f, 0.13164948f, -0.16249910f, 0.42698076f, 0.28578585f, 
    0.02266591f, -0.04010565f, 0.00739656f, 0.03661155f, 0.00723097f, 0.08635818f, 0.14092161f, -0.09723838f, 
    -0.09309430f, -0.32049999f, 0.00881040f, 0.09559479f, -0.04307461f, 0.01903714f, -0.07038651f, -0.03472054f, 
    0.17547439f, 0.14474626f, 0.17144781f, 0.23314734f, -0.06787664f, 0.04471830f, 0.05713947f, 0.08105641f, 
    0.08327966f, -0.07260253f, -0.02775660f, 0.02180780f, 0.18969174f, 0.03260238f, -0.03555869f, -0.15535994f, 
    0.00046695f, 0.16918945f, -0.07785315f, -0.03285563f, -0.16064103f, 0.12063973f, 0.04447607f, 0.04510915f, 
    0.08379850f, 0.11296701f, 0.10203652f, 0.24622074f, -0.03819902f, 0.11909934f, 0.09185017f, 0.10887581f, 
    0.03734024f, 0.02303176f, 0.10900030f, 0.02377942f, -0.07806445f, -0.45772654f, 0.10752264f, -0.06590011f, 
    0.38712996f, -0.01470634f, -0.10644586f, 0.01030269f, 0.05428009f, 0.00804013f, -0.03331491f, -0.02165870f, 
    0.05090319f, 0.03970879f, -0.22216910f, -0.20383197f, -0.19364850f, 0.06499470f, -0.10884187f, 0.16220707f, 
    -0.01565157f, -0.01596640f, -0.04010128f, -0.13375407f, 0.01188705f, 0.06008325f, 0.11125303f, -0.14918610f, 
    0.03819904f, -0.17216662f, 0.27740020f, 0.34953320f, -0.16110225f, 0.01636160f, -0.03862084f, -0.08749173f, 
    0.08670758f, -0.01191098f, 0.07438422f, 0.21276261f, 0.07050882f, 0.27878642f, 0.02819249f, -0.07162663f, 
    0.00164930f, 0.00886835f, -0.18635850f, -0.03129753f, -0.00277122f, 0.14501593f, -0.00127889f, 0.18151735f, 
    0.38356978f, -0.11826590f, -0.12679997f, -0.11651266f, -0.20306616f, -0.02605361f, 0.06605968f, 0.05847522f, 
    -0.07947709f, -0.01752172f, 0.10511536f, 0.03056800f, 0.17017908f, -0.04596084f, -0.05802652f, 0.00967453f, 
    0.09705564f, -0.11884166f, 0.05371361f, -0.00828046f, 0.02915182f, 0.21298708f, 0.03782338f, 0.22182053f, 
    0.30829242f, 0.16361596f, 0.23807304f, -0.01236178f, 0.02793917f, -0.06269082f, -0.03683785f, -0.06049347f, 
    -0.09906264f, 0.13326345f, -0.22643729f, 0.07044264f, 0.09578549f, 0.09628196f, 0.05374537f, -0.17344606f, 
    -0.10147069f, 0.19914053f, -0.05033116f, -0.04350003f, -0.04383105f, 0.01876912f, -0.15685856f, -0.10247079f, 
    0.19695228f, -0.29866296f, -0.10264708f, 0.06133714f, 0.15094842f, -0.04196964f, 0.06327923f, -0.02531523f, 
    -0.04518054f, -0.05374771f, 0.04291042f, 0.05724749f, 0.17328396f, 0.18863662f, -0.18585338f, -0.27180895f, 
    -0.03017174f, -0.02313825f, -0.02081785f, 0.07554789f, 0.19221789f, 0.09050019f, 0.03705914f, -0.14361846f, 
    0.07363643f, 0.26738667f, 0.04415986f, 0.18526955f, -0.05865568f, -0.21969837f, -0.04259861f, -0.03877490f, 
    -0.01045663f, -0.11534544f, -0.11342656f, -0.16176623f, -0.13432361f, 0.25572786f, -0.06702200f, 0.08017691f, 
    -0.05808061f, 0.00764453f, -0.08121870f, -0.10370766f, 0.16029379f, -0.11582806f, 0.09019122f, 0.15943508f, 
    -0.52717942f, -0.17085379f, 0.19302508f, -0.00756177f, -0.05553024f, -0.04910634f, -0.06065297f, 0.11340749f, 
    0.13253103f, -0.07347143f, 0.01810486f, 0.07014690f, -0.10157241f, -0.22925806f, 0.11639702f, 0.12919363f, 
    -0.06032068f, 0.07886158f, 0.01199273f, 0.25221756f, 0.02944778f, 0.15533815f, -0.06951308f, -0.02427587f, 
    -0.23155917f, -0.07947239f, 0.13059704f, 0.03015423f, 0.01011279f, 0.02441500f, -0.01216701f, -0.12303759f, 
    -0.01226848f, -0.02534014f, -0.08147929f, 0.12869219f, -0.11807189f, -0.32879207f, 0.13548957f, 0.17907336f, 
    0.07918480f, -0.05319300f, -0.00102286f, 0.10713972f, -0.05455727f, -0.03911780f, 0.07608762f, 0.27118102f, 
    0.45991251f, -0.08299576f, 0.08335825f, -0.04751565f, 0.01355451f, -0.10223751f, 0.03035445f, -0.17403756f, 
    0.09029780f, 0.02118641f, -0.08731052f, -0.03667485f, 0.42185354f, 0.02127310f, -0.22776622f, -0.17062613f, 
    -0.06006156f, -0.05112677f, -0.13853453f, 0.07655016f, -0.07273047f, 0.15305611f, 0.05835573f, -0.05601581f, 
    -0.13434023f, 0.51764339f, 0.00586470f, 0.17499265f, 0.17674631f, 0.01627768f, 0.10354266f, -0.06963460f, 
    0.10684144f, -0.12358886f, 0.12271030f, 0.12943476f, 0.16518559f, 0.16702364f, 0.04517045f, -0.01178992f, 
    -0.14133312f, 0.10488721f, 0.03537656f, 0.18609382f, -0.09942058f, 0.07880101f, 0.04566507f, -0.00147625f, 
    0.10625283f, 0.49072990f, 0.12877990f, 0.19500747f, 0.17530105f, 0.08357979f, -0.19178464f, 0.15588331f, 
    -0.13339655f, 0.00274349f, -0.00794475f, -0.05957114f, -0.01631450f, -0.01347257f, -0.08629397f, -0.17674887f, 
    -0.01983410f, -0.19279207f, -0.04335071f, -0.01263234f, -0.07296050f, -0.07532545f, -0.00827937f, 0.28273845f, 
    0.22577457f, -0.36554176f, -0.07227515f, -0.00399574f, -0.10116334f, 0.16643962f, -0.00156324f, 0.31885272f, 
    0.05072019f, 0.06677178f, -0.09886754f, -0.00356015f, -0.16861981f, -0.10781598f, -0.09604470f, 0.05493684f, 
    0.03850586f, -0.00865566f, -0.00900930f, -0.11320759f, -0.01114523f, 0.07570803f, 0.05444638f, -0.07526649f, 
    0.03744072f, -0.19838785f, -0.00897174f, 0.15945970f, 0.07459360f, 0.10652378f, 0.01090584f, -0.09079669f, 
    -0.02432181f, 0.04136062f, -0.05753533f, -0.12472168f, 0.13122123f, -0.00679396f, 0.02678645f, 0.01248419f, 
    -0.07442643f, -0.05168323f, 0.08086749f, 0.00064827f, 0.24841805f, 0.06399035f, 0.09777047f, 0.08430675f, 
    -0.29775816f, 0.00898656f, -0.02948299f, 0.09655934f, 0.10030000f, -0.05234025f, -0.00325041f, -0.05854332f, 
    0.15326284f, -0.11637298f, 0.08512961f, -0.05264846f, -0.02264376f, 0.11958187f, 0.13044706f, -0.20419443f, 
    0.01457147f, 0.04585477f, 0.01636929f, 0.00963164f, 0.12205761f, 0.06503487f, 0.19577631f, 0.06026150f, 
    -0.10031420f, 0.08325867f, -0.13168894f, -0.06720043f, 0.00320515f, -0.06328955f, -0.12370110f, 0.14109015f, 
    0.11966874f, 0.06750035f, 0.13001505f, 0.03022278f, 0.39895132f, -0.00901995f, -0.04767621f, -0.00344172f, 
    -0.00695483f, -0.06796959f, -0.04751498f, -0.12671567f, 0.19790711f, -0.18436602f, 0.17073955f, -0.06884258f, 
    0.20044902f, -0.06953017f, -0.14867660f, 0.22159749f, 0.05160667f, -0.12389064f, 0.09820434f, -0.07517689f, 
    0.00994430f, 0.05557693f, 0.19907440f, 0.09417681f, -0.16903833f, 0.01247660f, -0.12749851f, 0.02895079f, 
    -0.18805890f, 0.02084455f, 0.14010340f, 0.08082239f, 0.06318620f, -0.24351165f, 0.04942660f, -0.05546646f, 
    -0.14415489f, 0.02944071f, -0.03487444f, 0.06912138f, 0.10086402f, 0.01266380f, -0.07794822f, 0.03525298f, 
    0.15272802f, -0.01175092f, -0.17411803f, 0.06730122f, -0.14169548f, -0.06875563f, -0.40601641f, 0.09919716f, 
    0.08643121f, -0.06948930f, -0.15835188f, -0.05718455f, 0.12556127f, -0.06401468f, 0.02197496f, -0.21563950f, 
    0.07194788f, -0.15332247f, -0.06878781f, -0.07049325f, -0.04081269f, -0.02070655f, -0.04202623f, -0.12185933f, 
    0.04666309f, -0.01713322f, -0.00382242f, 0.02689541f, 0.31424496f, 0.06690593f, -0.19615319f, 0.06693281f, 
    0.08324634f, 0.00925495f, -0.09059543f, 0.06569705f, 0.02756987f, 0.08236025f, 0.21460183f, 0.03408174f, 
    0.27519870f, 0.07787657f, -0.15527155f, 0.11753624f, 0.06804877f, 0.19507511f, 0.04129950f, 0.13394603f, 
    -0.03611644f, -0.00521580f, -0.02648963f, -0.07345709f, -0.37245941f, -0.03256937f, -0.02548536f, 0.08318336f, 
    0.04090826f, 0.02575104f, -0.08261343f, -0.14503556f, 0.02930338f, 0.13975298f, -0.06185244f, 0.08373392f, 
    0.10555536f, 0.12506635f, 0.07208202f, -0.29313016f, 0.05896721f, 0.11298078f, 0.04854042f, 0.04485091f, 
    -0.02554709f, 0.01568518f, 0.06353799f, 0.03298958f, 0.18165499f, -0.06408796f, 0.16111213f, 0.00996352f, 
    -0.06100699f, 0.00700817f, 0.07206587f, 0.14319333f, 0.07670543f, 0.02030973f, 0.08568972f, -0.01564534f, 
    -0.21708201f, -0.02661851f, 0.08539598f, 0.18080321f, 0.06432559f, 0.12447074f, -0.01932812f, 0.04324319f, 
    0.01958904f, 0.02661156f, 0.12806933f, -0.10098225f, 0.17950411f, 0.06965020f, -0.02463143f, 0.13077523f, 
    0.13832042f, 0.14505225f, -0.08585220f, 0.27910373f, 0.15706940f, 0.00996650f, -0.02346829f, 0.06075147f, 
    -0.10257623f, -0.27657187f, -0.21182713f, -0.08928960f, -0.01777059f, -0.11673339f, 0.04511659f, -0.08665542f, 
    -0.05146758f, -0.07426242f, -0.07906064f, -0.11832492f, 0.06552661f, 0.18775587f, -0.11510715f, 0.02548895f, 
    -0.08571117f, 0.05140237f, -0.02627266f, 0.00144533f, 0.06444254f, -0.12029681f, -0.08108702f, 0.35503876f, 
    0.13831253f, -0.02875562f, -0.01556350f, 0.11116849f, 0.16103753f, 0.03886560f, 0.22260363f, 0.11501537f, 
    -0.07614732f, -0.04303742f, 0.12627427f, 0.07827097f, -0.04550703f, 0.16773202f, -0.13676734f, -0.04745718f, 
    -0.10391384f, -0.08771231f, 0.04445751f, -0.04656665f, 0.02161928f, -0.04736333f, 0.15302832f, 0.16512966f, 
    0.20170122f, 0.33894703f, -0.06144413f, 0.14379443f, 0.05309974f, -0.00395458f, 0.11231850f, 0.09707113f, 
    -0.02174733f, 0.03533449f, -0.03029067f, -0.18003912f, -0.12337723f, 0.08166196f, -0.16550913f, -0.11824899f, 
    -0.15062600f, 0.19487177f, -0.01078508f, -0.27503586f, 0.00280964f, -0.06541456f, -0.00776996f, 0.00201279f, 
    -0.48155868f, 0.24877101f, -0.03528944f, -0.17387447f, 0.00014542f, -0.12560058f, -0.03058079f, 0.01112019f, 
    -0.12566110f, 0.01210166f, -0.05070131f, -0.05225949f, 0.16164581f, -0.17431413f, 0.26248577f, 0.36934337f, 
    0.03844372f, -0.05630600f, 0.00083849f, -0.02648197f, 0.10085222f, 0.04025261f, 0.10842807f, 0.02558824f, 
    -0.01398304f, -0.38802424f, 0.12873676f, 0.00290846f, -0.02373328f, 0.13886273f, 0.03446290f, -0.06173093f, 
    0.04822548f, 0.07000954f, 0.02403596f, 0.00701889f, -0.08237217f, 0.17249997f, -0.18156980f, 0.16700208f, 
    0.18988097f, -0.04467924f, -0.05064504f, -0.03493883f, 0.19588268f, -0.06199222f, -0.12071323f, 0.05625442f, 
    0.09132396f, -0.16486575f, -0.09388907f, 0.03339543f, -0.12400047f, -0.01926899f, 0.08247764f, 0.01452307f, 
    -0.02794468f, 0.03363081f, 0.15275240f, 0.02590120f, -0.03780699f, 0.18323831f, 0.04663814f, 0.16598824f, 
    0.02932951f, -0.00075263f, 0.13241237f, -0.01840374f, 0.09303176f, 0.15658811f, 0.04948682f, 0.05622280f, 
    -0.50944149f, 0.22662956f, -0.00746493f, -0.33993167f, 0.11015600f, -0.02744172f, -0.13943250f, -0.11275890f, 
    0.05325922f, -0.00435357f, -0.14523074f, -0.00645382f, -0.23052199f, 0.39817521f, 0.12899250f, -0.03038660f, 
    0.09644724f, 0.07146405f, -0.01210196f, 0.16696557f, 0.07618502f, 0.02828046f, -0.04204882f, 0.00671435f, 
    -0.07624017f, 0.03903624f, -0.08098539f, -0.05124917f, 0.06248603f, -0.03959438f, -0.09124921f, 0.11336947f, 
    0.13532348f, 0.05219583f, 0.16051289f, 0.10608287f, -0.17370160f, 0.25001684f, -0.07209515f, 0.03623276f, 
    0.05619116f, 0.16085330f, 0.01135546f, 0.05922361f, -0.04191867f, 0.02175499f, -0.00742431f, 0.00579785f, 
    0.21900970f, 0.00361235f, -0.10102890f, -0.05729413f, -0.16071709f, 0.07971130f, -0.02646263f, -0.11861794f, 
    -0.04181860f, -0.05813453f, -0.16702126f, -0.08372399f, 0.00683673f, 0.06352980f, -0.20192264f, 0.30438572f, 
    0.02990562f, -0.13564670f, 0.00851019f, 0.07438613f, -0.09014761f, 0.04339384f, -0.04138209f, 0.09236434f, 
    0.30749610f, 0.20534611f, -0.02198005f, 0.10647949f, 0.01506689f, 0.09471098f, 0.14367104f, -0.00637170f, 
    -0.06689649f, 0.04986666f, -0.12202562f, -0.10769363f, 0.16996692f, 0.09754360f, -0.00210554f, 0.05565383f, 
    -0.09760611f, -0.06335192f, 0.04973425f, -0.07379381f, 0.14005944f, -0.02694346f, -0.01801178f, 0.16984032f, 
    0.51337564f, -0.14167835f, 0.00429777f, 0.06827074f, -0.21186472f, -0.03911745f, -0.08278698f, 0.10297506f, 
    -0.10253478f, 0.01194152f, 0.01347098f, -0.11001515f, -0.27366728f, 0.10799416f, -0.01194960f, -0.07113662f, 
    -0.18408211f, -0.04151525f, 0.08073015f, 0.06365635f, 0.01505820f, 0.04401990f, -0.00524400f, -0.09263304f, 
    -0.17942576f, 0.18851417f, -0.14671092f, 0.03006139f, 0.02739138f, 0.01847517f, -0.00471038f, 0.04047700f, 
    0.01886680f, 0.08375374f, 0.04142087f, -0.02067557f, 0.19262291f, -0.08297893f, -0.05255895f, 0.21362559f, 
    0.12018777f, 0.02019454f, 0.01465777f, -0.07720774f, -0.04696230f, -0.01084433f, -0.04941588f, -0.09148110f, 
    0.01107077f, -0.48590145f, 0.27729523f, -0.00105606f, 0.01345229f, -0.03503620f, -0.13326751f, -0.01116683f, 
    0.03149356f, 0.05069168f, -0.06806927f, 0.04000252f, 0.07235497f, -0.20363805f, 0.09994509f, -0.13315052f, 
    0.13471021f, -0.08105360f, -0.03508642f, 0.03966695f, -0.08538407f, 0.04328061f, 0.12088731f, -0.01629756f, 
    0.28757095f, -0.36865297f, 0.09660225f, -0.14744191f, -0.02893179f, 0.00639498f, 0.06080810f, -0.12737937f, 
    -0.19451992f, -0.13439363f, 0.03078276f, 0.02800936f, 0.11391290f, 0.19482516f, -0.01324948f, -0.06912320f, 
    -0.05463485f, 0.05211270f, -0.03882261f, -0.02929945f, 0.07574545f, 0.09955750f, -0.14526252f, -0.28067389f, 
    0.24522775f, 0.10035759f, -0.04303115f, 0.14053044f, -0.02813222f, -0.06605525f, -0.04908625f, -0.07681626f, 
    -0.05675492f, -0.03298204f, 0.02836375f, -0.05097723f, 0.69945371f, -0.14021842f, 0.18976966f, 0.02490823f, 
    0.16828774f, 0.00158647f, 0.05723805f, 0.06180464f, 0.02457628f, 0.06162685f, -0.01755750f, 0.10100366f, 
    0.06965663f, 0.14899756f, -0.15614660f, -0.00529706f, -0.01379227f, -0.07070287f, 0.03173721f, 0.11883477f, 
    -0.02886610f, 0.01728918f, 0.15666452f, 0.07437416f, 0.08028806f, 0.20083441f, -0.11123108f, -0.21405275f, 
    0.10864943f, 0.06555725f, 0.02224649f, 0.15873176f, -0.08262514f, 0.06893259f, -0.14633834f, 0.04356148f, 
    0.25255421f, -0.00709428f, -0.03138269f, -0.02085155f, 0.06490607f, -0.14359975f, -0.00668330f, 0.09690589f, 
    0.00255767f, 0.00681718f, -0.10422006f, -0.07694411f, 0.22251305f, 0.19838282f, -0.39088655f, -0.18286172f, 
    -0.11871129f, 0.03813808f, 0.02774905f, 0.12412390f, 0.01706401f, 0.08493647f, 0.09887674f, 0.07316515f, 
    0.00765052f, -0.08625884f, 0.12897822f, -0.05905653f, 0.22053315f, 0.08119005f, 0.12106957f, -0.02439939f, 
    -0.05084448f, -0.06100568f, -0.24956448f, -0.11798970f, 0.00811117f, 0.09891819f, 0.30015951f, 0.03500226f, 
    -0.10527173f, 0.13088104f, 0.03036669f, 0.09563126f, -0.16530703f, 0.07209577f, -0.01391365f, 0.15072422f, 
    0.03671805f, -0.06308156f, 0.26752713f, -0.02799907f, 0.01142002f, -0.07260595f, -0.00759099f, -0.13660623f, 
    -0.13259864f, -0.03237149f, -0.10131850f, -0.12775096f, 0.28884834f, 0.02985526f, -0.01343501f, 0.13985871f, 
    0.09648993f, -0.06035712f, 0.05412485f, 0.12498576f, 0.01389725f, 0.40955344f, -0.08457665f, 0.23301487f, 
    -0.23942310f, 0.03797232f, 0.01385552f, -0.08665866f, -0.00150228f, -0.02956365f, 0.17811181f, -0.04385344f, 
    -0.06759951f, 0.06852458f, 0.22376662f, 0.10775239f, 0.57360947f, 0.14880446f, 0.08502360f, 0.07029823f, 
    -0.16837557f, 0.03976907f, -0.01626195f, 0.21214317f, -0.01021091f, 0.08870226f, -0.03996583f, 0.12991184f, 
    -0.17028575f, 0.21955596f, 0.02213648f, -0.27446434f, 0.18738176f, 0.03077896f, 0.05847703f, 0.01297302f, 
    -0.09161686f, -0.10086744f, -0.07352155f, -0.01833900f, -0.28231740f, 0.14460519f, -0.09877253f, 0.29946774f, 
    -0.00383044f, 0.15354821f, 0.05177757f, -0.04017884f, 0.08571514f, 0.00837408f, -0.15476732f, -0.13302022f, 
    -0.28180149f, 0.33529520f, -0.03020026f, 0.18862987f, 0.06383611f, -0.06938779f, -0.11173344f, -0.04214308f, 
    0.06622803f, -0.05700307f, -0.07343291f, 0.01537414f, 0.37520081f, 0.11682808f, 0.19580306f, -0.22225404f, 
    0.04997375f, 0.02123407f, 0.05435923f, -0.02488299f, 0.00755376f, -0.21106386f, 0.03078278f, -0.05729241f, 
    0.01421889f, -0.10500064f, 0.05264243f, -0.03436838f, -0.01612931f, -0.02448804f, -0.05790661f, 0.14551501f, 
    -0.00210349f, -0.06703760f, 0.03727156f, -0.06626949f, 0.30133677f, -0.10397541f, 0.28231412f, 0.15314329f, 
    0.15235437f, -0.12905864f, 0.03703062f, -0.08805475f, 0.11999779f, 0.06148527f, 0.08757255f, 0.19691803f, 
    -0.26877099f, 0.37490231f, -0.13828799f, -0.07634985f, -0.03389434f, 0.06161974f, -0.02150731f, -0.09673003f, 
    0.01082707f, 0.06358761f, 0.08426606f, 0.01943260f, -0.09857105f, 0.03905955f, -0.07489228f, -0.01602902f, 
    -0.04336385f, 0.01320555f, 0.01120912f, -0.24672332f, -0.06227008f, -0.12054118f, 0.01415653f, 0.10209856f, 
    -0.28941771f, 0.01058121f, 0.04521646f, 0.08754353f, -0.02067781f, 0.06245771f, 0.03226753f, 0.11409988f, 
    -0.06788906f, 0.04271831f, 0.25144622f, 0.12053920f, 0.04668614f, -0.25702649f, -0.10020594f, 0.04455341f, 
    0.14975101f, -0.10089204f, 0.08822455f, 0.13405564f, -0.04768341f, 0.13272284f, 0.01839594f, -0.08792857f, 
    0.34974426f, 0.19687864f, -0.06070435f, -0.04481462f, 0.01400152f, -0.01870989f, 0.05036511f, -0.03780083f, 
    -0.04503804f, 0.06317975f, 0.17742045f, 0.08030304f, -0.08410354f, -0.14552654f, -0.24970289f, -0.03095072f, 
    0.07861170f, 0.00900571f, 0.00003697f, 0.14676614f, -0.08921781f, 0.13400358f, 0.13685144f, 0.10545664f, 
    -0.17998672f, -0.01230632f, -0.04668965f, 0.09784984f, 0.14740556f, 0.06496392f, 0.11262961f, 0.00276534f, 
    0.18967488f, 0.04710606f, 0.12539645f, 0.00694881f, 0.09010500f, -0.06240631f, 0.06896701f, -0.04791471f, 
    0.12329626f, 0.09433472f, -0.05840557f, -0.07974032f, -0.05334670f, 0.07106106f, 0.20475817f, 0.10676944f, 
    -0.05798242f, 0.06500340f, 0.33247238f, -0.05238373f, -0.12556298f, 0.15224567f, 0.01903706f, -0.05935453f, 
    -0.14712706f, 0.04602854f, 0.07768976f, 0.08520349f, -0.26418400f, -0.04300331f, 0.33986476f, -0.33957869f, 
    0.04949133f, 0.08015584f, 0.29936367f, 0.03972480f, -0.04575552f, 0.09948211f, -0.01783739f, 0.13392282f, 
    0.29477394f, 0.28928876f, -0.15539192f, -0.11156134f, -0.02377476f, -0.00199325f, 0.01265461f, 0.16898759f, 
    -0.05779276f, 0.11610343f, 0.20922916f, -0.02719858f, -0.10713726f, -0.10772075f, -0.00597364f, -0.03956521f, 
    -0.02085677f, 0.06358125f, 0.12840070f, -0.05410773f, 0.00703462f, -0.17846735f, 0.04401567f, 0.02758102f, 
    -0.23546040f, 0.25790581f, 0.13173859f, -0.19947150f, 0.02592635f, -0.02040832f, 0.18774904f, 0.04602859f, 
    0.08845085f, 0.09547988f, 0.16158490f, 0.03778331f, -0.13866971f, -0.11169117f, -0.22849138f, 0.16633293f, 
    0.07202210f, 0.14346561f, 0.09717763f, 0.08018443f, -0.03272479f, 0.06334621f, 0.15642802f, 0.13259883f, 
    -0.48014775f, -0.13572091f, -0.05549220f, 0.17909423f, 0.14674336f, 0.11503652f, -0.08798639f, 0.12255554f, 
    0.08079372f, -0.01312678f, 0.15309794f, 0.11068121f, -0.33063063f, -0.02201021f, -0.13879304f, -0.08145266f, 
    -0.07267083f, 0.15508570f, -0.07310772f, 0.17153180f, 0.14167170f, -0.06261967f, -0.00166589f, -0.00219638f, 
    -0.20902340f, -0.05518850f, 0.32967630f, 0.11072982f, -0.08777773f, 0.08032003f, 0.13291214f, 0.11927103f, 
    0.14565647f, -0.03134397f, -0.10051799f, 0.02329051f, -0.22917195f, -0.24207360f, 0.34243801f, 0.32902938f, 
    0.07261796f, 0.07653416f, 0.09275526f, 0.15829656f, -0.05524749f, 0.01302157f, 0.11064275f, 0.05435396f, 
    0.22819212f, -0.03900860f, -0.13581991f, -0.13095483f, 0.11049315f, 0.23961264f, 0.01763993f, -0.02902676f, 
    0.18769892f, 0.07664771f, -0.10519484f, 0.06371085f, -0.14694534f, -0.04849910f, 0.32829431f, 0.23463374f, 
    0.08412224f, -0.04048859f, -0.08525790f, 0.02483331f, -0.02708479f, -0.01423662f, -0.10164651f, -0.08372402f, 
    0.02379134f, -0.00610144f, 0.04120990f, 0.03387305f, 0.00627166f, 0.00834884f, -0.00850591f, 0.00441054f, 
    0.00986493f, -0.00947279f, -0.02074616f, 0.03479175f, -0.04083793f, -0.02944465f, -0.03290905f, 0.00632826f, 
    0.01358091f, -0.07410709f, 0.02914841f, 0.02579033f, 0.06009002f, -0.02367268f, -0.05861517f, -0.04710360f, 
    -0.04003478f, 0.03504246f, 0.03098883f, -0.07695396f, -0.07670970f, 0.01669064f, 0.02112948f, 0.01101573f, 
    0.03381094f, 0.05972626f, 0.01685135f, -0.02715220f, 0.05207448f, 0.00384888f, -0.06845910f, -0.00058159f, 
    -0.01866895f, -0.02993629f, 0.01880036f, -0.03055512f, -0.04958086f, -0.03754546f, -0.07842683f, -0.01595389f, 
    -0.03540451f, 0.06023630f, -0.05584071f, -0.06311747f, -0.05883707f, -0.02017565f, -0.00798241f, 0.03851432f, 
    0.03979367f, 0.03192629f, -0.04096569f, -0.01370106f, 0.06370493f, 0.07665411f, -0.01033844f, -0.06725896f, 
    -0.03654588f, 0.05935194f, 0.01217704f, -0.03992982f, 0.04847514f, 0.01056455f, -0.07850160f, 0.05316530f, 
    -0.02423213f, -0.01876015f, 0.04808350f, -0.03235917f, 0.02200645f, -0.02185882f, -0.04267479f, 0.00004944f, 
    -0.06921107f, -0.07407618f, 0.01174612f, -0.01019271f, -0.07108068f, -0.04619434f, 0.01838596f, 0.05955986f, 
    0.05003105f, -0.03155142f, 0.02967710f, 0.04659031f, 0.03353235f, -0.05775134f, 0.03460926f, -0.02153161f, 
    -0.01581559f, 0.00252489f, 0.05091164f, 0.02053491f, -0.04694060f, -0.07682973f, -0.04911791f, 0.02781281f, 
    -0.05649222f, 0.03127081f, -0.04961194f, -0.04090859f, -0.02056413f, -0.06019381f, 0.01241810f, 0.04714482f, 
    -0.00539542f, -0.04340396f, 0.03587681f, -0.00062707f, -0.07812437f, -0.02848637f, 0.05568552f, -0.01788194f, 
    -0.00529142f, 0.02971595f, 0.03615786f, -0.07327627f, -0.05514288f, 0.04581896f, -0.07612973f, -0.06851029f, 
    -0.05873571f, -0.07558717f, 0.00288374f, -0.06271556f, 0.01301932f, -0.08344045f, 0.04258009f, -0.03866065f, 
    -0.04468018f, -0.01834451f, -0.04297809f, 0.03175465f, 0.00595260f, 0.05700254f, -0.06663374f, -0.04635542f, 
    -0.07374693f, -0.07721235f, 0.02481886f, -0.06543072f, 0.02180863f, -0.05671437f, 0.05617193f, 0.01466239f, 
    0.04369379f, -0.01437449f, -0.07569565f, 0.00718493f, -0.03507406f, 0.01330100f, 0.05417384f, -0.02215868f, 
    -0.08327943f, 0.00283531f, 0.04427939f, 0.00759996f, 0.01633812f, -0.01980833f, -0.03487136f, -0.00540435f, 
    0.00254210f, 0.05061256f, 0.00328849f, -0.07484429f, -0.01541997f, -0.03653511f, 0.04235943f, -0.04439740f, 
    0.06272200f, 0.04230548f, 0.04641389f, -0.02324581f, -0.01346328f, 0.07492974f, 0.04020225f, -0.06922161f, 
    -0.05573717f, 0.01935238f, -0.06587403f, -0.02972884f, -0.04848623f, -0.01919296f, -0.03149571f, 0.03741024f, 
    -0.02724929f, -0.02655957f, -0.00141854f, 0.04558825f, -0.03085672f, 0.04800958f, 0.00649704f, -0.07015670f, 
    -0.06718579f, 0.02965639f, -0.07394725f, 0.00246116f, 0.04021472f, -0.05862303f, 0.02631319f, -0.04375544f, 
    -0.00253941f, -0.03627914f, -0.04226619f, 0.05549463f, -0.06520016f, 0.00785598f, -0.06460823f, -0.02057615f, 
    -0.07038195f, 0.01209236f, 0.02561911f, -0.01367263f, 0.05042118f, -0.05582475f, 0.00987958f, -0.03885275f, 
    -0.06680985f, 0.04419009f, -0.07428781f, 0.00898509f, -0.06850783f, -0.04441614f, 0.04676215f, 0.02070976f, 
    -0.03133737f, 0.06444539f, -0.05473335f, 0.01100878f, 0.03651690f, -0.04200695f, 0.02538569f, 0.03165819f, 
    0.05110241f, -0.04632959f, -0.03324912f, -0.06508417f, 0.00143494f, 0.03091874f, 0.03620653f, -0.04036443f, 
    0.01383018f, 0.06053086f, 0.02796280f, 0.06056894f, 0.00278618f, 0.04413424f, 0.03336421f, -0.00996327f, 
    0.06406029f, 0.03325951f, -0.04373667f, 0.00415769f, 0.00677919f, -0.03804422f, -0.05568669f, -0.06178989f, 
    -0.02593116f, -0.07910001f, -0.04592307f, -0.05920321f, 0.05529341f, -0.07573202f, -0.06085474f, -0.03114611f, 
    0.00708886f, 0.02394347f, 0.00721317f, -0.02325367f, 0.03447162f, -0.01321523f, 0.05293602f, -0.06861541f, 
    -0.03567417f, -0.06505647f, -0.04998250f, -0.00926042f, -0.07929644f, -0.06799904f, -0.03057311f, 0.00598792f, 
    -0.00504438f, -0.04171184f, 0.03070457f, -0.06516849f, 0.03769913f, -0.04765885f, -0.03424537f, -0.03864766f, 
    0.04908841f, -0.05594670f, -0.01501074f, -0.05321477f, -0.07695549f, -0.01079294f, -0.06799989f, 0.03876550f, 
    -0.01310239f, 0.03876904f, -0.04115954f, -0.06211372f, -0.03507011f, -0.05592163f, -0.05247504f, 0.03551270f, 
    0.01090019f, -0.01561098f, -0.05577304f, 0.05800734f, 0.02769465f, -0.06200184f, -0.03566593f, -0.03996881f, 
    -0.00909234f, 0.06038926f, -0.00814016f, 0.03284810f, 0.03133002f, -0.03427650f, 0.03666819f, 0.00264347f, 
    -0.03452270f, 0.03434575f, 0.02488947f, -0.01453297f, 0.03457934f, 0.05142967f, -0.06660635f, -0.04549589f, 
    0.01924743f, 0.00850292f, -0.05299933f, -0.02471067f, -0.03181936f, 0.04309671f, 0.02909547f, 0.01357097f, 
    -0.05885570f, 0.03546330f, 0.00352893f, 0.03321427f, -0.02935763f, 0.03352689f, 0.05342580f, -0.04365312f, 
    -0.04686178f, -0.05992633f, 0.05385669f, -0.06964958f, 0.03302827f, -0.07391671f, -0.01267010f, 0.01755757f, 
    0.05392121f, 0.03213195f, 0.02683579f, 0.01568637f, -0.04725688f, 0.02317975f, 0.06836540f, 0.01025407f, 
    0.04466515f, 0.01239580f, -0.03273847f, -0.07446603f, -0.04453823f, 0.05605565f, -0.04883200f, -0.00151513f, 
    0.02161999f, -0.00404210f, 0.03135991f, 0.01632113f, 0.00517328f, 0.05876292f, 0.03178474f, -0.07836682f, 
    0.32831940f, -0.14331819f, -0.22681372f, -0.24154852f, -0.01810899f, -0.12268017f, 0.00518010f, -0.08993577f, 
    0.05251134f, 0.05906448f, -0.04280319f, 0.10902760f, 0.12909327f, -0.07310891f, 0.19085309f, -0.07838482f, 
    0.00313298f, 0.24498136f, 0.07417898f, 0.02086453f, -0.19388509f, -0.09854165f, -0.01196764f, 0.10170402f, 
    0.11268678f, -0.18751623f, 0.15481278f, 0.02437321f, -0.01326132f, -0.02824176f, 0.05857186f, 0.00274077f, 
    -0.10791133f, 0.05418288f, 0.02587485f, -0.04615067f, 0.39473978f, 0.33112946f, 0.05182490f, 0.11527642f, 
    0.02675431f, -0.02774956f, 0.10060576f, 0.14237720f, 0.04480290f, 0.23146100f, 0.03723794f, -0.01658804f, 
    -0.23267689f, 0.09493690f, -0.03471299f, 0.00598824f, -0.04605684f, -0.01595234f, -0.04228774f, 0.02172807f, 
    -0.01570006f, -0.03417418f, 0.05190824f, -0.02654426f, -0.42009977f, 0.18455206f, 0.02313374f, -0.01874100f, 
    -0.06147471f, -0.09732790f, 0.00241077f, 0.11732931f, 0.00302348f, -0.05223758f, -0.00447580f, 0.01222374f, 
    -0.28423667f, 0.27825150f, -0.24194701f, -0.20429274f, 0.09544894f, 0.00752247f, 0.06203040f, 0.05667904f, 
    -0.09378264f, -0.00773926f, -0.12466731f, -0.17486584f, -0.23981801f, 0.14199641f, 0.22567353f, 0.18373148f, 
    0.01208097f, 0.04225836f, -0.06231029f, -0.12090488f, 0.12324511f, 0.06900577f, 0.05093664f, -0.03065230f, 
    -0.13868394f, 0.48959365f, -0.05779726f, 0.16365474f, 0.00359711f, -0.00334649f, -0.00488309f, -0.11694888f, 
    0.16924125f, 0.09051493f, 0.03176650f, 0.09600183f, 0.42137045f, -0.07416602f, -0.03956979f, -0.06555323f, 
    0.18518038f, 0.13417770f, 0.11489226f, 0.04372322f, 0.04578687f, -0.14627844f, 0.05268148f, 0.00746655f, 
    -0.01910015f, 0.07859673f, 0.08916130f, -0.06354748f, 0.02804143f, -0.03250369f, 0.00295001f, -0.07946951f, 
    -0.09453436f, -0.05499109f, 0.16027425f, -0.05500069f, 0.26511863f, 0.11856447f, 0.05613570f, 0.23654224f, 
    -0.02944021f, -0.11090978f, 0.04327273f, -0.04912168f, 0.06213859f, 0.13460873f, 0.10295384f, 0.11987482f, 
    -0.19975249f, 0.24076675f, 0.12381803f, -0.13233069f, 0.06231064f, 0.16694205f, -0.08844628f, -0.07485837f, 
    0.15444183f, 0.07050364f, -0.12014939f, -0.07394259f, -0.20200336f, 0.13796195f, -0.08319148f, 0.06397458f, 
    -0.06549221f, 0.08497815f, 0.01387819f, -0.00548780f, -0.06659658f, -0.10088734f, -0.03576734f, -0.03134354f, 
    0.05392505f, 0.18947180f, 0.08332998f, 0.21855764f, 0.02383718f, 0.10731482f, 0.11184185f, 0.13158312f, 
    -0.00912221f, 0.02855816f, 0.08939339f, -0.06606599f, 0.24618107f, -0.25787717f, 0.06498231f, 0.10616050f, 
    0.13715982f, -0.01412825f, -0.03457343f, -0.12503947f, -0.15958187f, -0.08173192f, 0.06253425f, -0.04798792f, 
    -0.30460212f, 0.00226439f, 0.00863514f, 0.09233632f, 0.05230856f, 0.10686879f, -0.05621642f, -0.07095896f, 
    -0.06399284f, 0.03898404f, -0.10339791f, 0.11914071f, 0.16053298f, -0.15802580f, 0.05913952f, 0.17766114f, 
    -0.17582688f, -0.15428416f, 0.05119838f, 0.14856206f, 0.08176719f, 0.03900176f, -0.01353379f, 0.00959594f, 
    0.13252378f, -0.21035330f, -0.02985808f, -0.04789242f, -0.09202319f, 0.02232691f, -0.00579533f, -0.02562751f, 
    0.01213617f, -0.09394041f, -0.00364521f, 0.19059330f, -0.03263118f, 0.09867354f, 0.35365194f, -0.17456262f, 
    0.00546318f, -0.14787093f, 0.00081184f, 0.22220658f, -0.11664036f, -0.05579047f, 0.08146770f, 0.12335388f, 
    0.28306532f, -0.13369456f, -0.09828041f, 0.17502759f, 0.00833765f, 0.10883348f, 0.07478412f, -0.00900075f, 
    0.04813463f, 0.01848669f, 0.02587803f, 0.02888102f, 0.22805092f, 0.09495594f, 0.11565526f, -0.35443407f, 
    0.18144567f, 0.14240727f, 0.00106591f, 0.01144115f, -0.10535417f, 0.14541693f, -0.00679322f, -0.04849879f, 
    -0.14817832f, 0.14777873f, -0.20340620f, 0.31288388f, 0.09166604f, -0.02749098f, 0.04079680f, 0.04181203f, 
    -0.03948742f, 0.04035977f, 0.07911723f, 0.02199141f, -0.07248063f, -0.22708045f, 0.35716859f, -0.27190569f, 
    -0.24143739f, 0.01253205f, 0.22190540f, 0.08191143f, -0.24119753f, 0.02819927f, -0.09488755f, 0.07831505f, 
    0.01244934f, 0.24216563f, 0.26313877f, -0.14120281f, 0.01294888f, -0.05847429f, 0.07351234f, 0.13884190f, 
    -0.01827898f, 0.01306209f, 0.11432756f, 0.01745253f, -0.05908659f, 0.09756168f, -0.26979816f, -0.17386134f, 
    -0.00732463f, 0.01786522f, -0.03799684f, 0.06329594f, -0.06048884f, -0.03286441f, -0.16298996f, 0.16369128f, 
    0.35406065f, -0.32815015f, -0.08294172f, 0.20096950f, -0.26533353f, 0.05254915f, 0.13020526f, 0.03782919f, 
    0.02936626f, 0.04141391f, 0.14410363f, 0.09336668f, 0.22142388f, -0.14595479f, -0.15383491f, 0.10087387f, 
    -0.00620253f, -0.08069962f, -0.07879622f, -0.04034348f, 0.02241628f, 0.07343712f, -0.19211295f, 0.02070833f, 
    0.07170577f, -0.22332942f, -0.08934888f, 0.01413070f, -0.00364089f, 0.02617141f, 0.13156720f, -0.05096402f, 
    0.04589695f, -0.01756911f, -0.18442546f, 0.00145512f, -0.17168437f, -0.04571711f, 0.17053269f, -0.20001280f, 
    0.08291037f, -0.05089579f, 0.16425568f, 0.00157756f, 0.00084215f, 0.03525185f, -0.13439400f, 0.08233532f, 
    0.20985320f, 0.29062662f, 0.01073924f, -0.02174615f, 0.00893399f, -0.10459691f, -0.03556920f, 0.11138263f, 
    0.04208308f, -0.15332009f, 0.00704659f, 0.05782055f, -0.22367205f, 0.09554036f, 0.22271983f, -0.31787035f, 
    -0.01412065f, 0.11381173f, 0.00962450f, 0.03765605f, 0.16735618f, 0.05926660f, 0.22274621f, -0.12029483f, 
    -0.00006337f, -0.06822388f, 0.02514187f, -0.07286993f, 0.05382047f, -0.01827147f, -0.07261060f, 0.02290667f, 
    -0.00357884f, 0.02612766f, 0.01822629f, -0.02121950f, -0.02268909f, 0.03488345f, -0.06245084f, -0.00766896f, 
    -0.02452327f, 0.00957483f, 0.02568860f, -0.00922527f, 0.05779962f, 0.05073148f, 0.02389412f, 0.03950954f, 
    -0.00396539f, 0.01176310f, -0.00685629f, -0.06813446f, -0.02491677f, 0.00521115f, -0.04565470f, -0.00608181f, 
    0.00201224f, 0.03418265f, -0.06901610f, 0.02652593f, -0.02666165f, 0.05940320f, 0.03247761f, -0.05969715f, 
    -0.04910120f, 0.02018472f, 0.00899733f, -0.03358404f, 0.03309744f, -0.02388473f, 0.02860887f, -0.06975222f, 
    -0.06096868f, 0.00086936f, -0.02384049f, -0.07459099f, -0.04089696f, 0.01988033f, 0.06120338f, 0.02930332f, 
    0.04479228f, -0.04622381f, -0.05675997f, 0.00424089f, 0.00146344f, 0.05578577f, -0.05227208f, 0.06421082f, 
    -0.07622372f, 0.05883849f, 0.04891936f, 0.01351178f, 0.04856378f, 0.02487689f, 0.06745192f, -0.07164592f, 
    -0.04798307f, -0.06572717f, -0.05902087f, 0.03416664f, -0.00036124f, -0.05842550f, -0.07711163f, 0.00121414f, 
    0.00246921f, 0.00199174f, -0.01112911f, -0.02861407f, -0.06755333f, -0.07454745f, -0.05237887f, -0.07513182f, 
    -0.03883383f, -0.00008603f, -0.05854185f, -0.03639171f, -0.00930520f, 0.00727414f, -0.02219521f, -0.01876269f, 
    -0.03304361f, -0.05383100f, 0.05593757f, 0.03749549f, -0.04566729f, -0.01565965f, -0.02624106f, 0.02170342f, 
    0.04603938f, -0.06782739f, 0.04052575f, 0.04374457f, -0.00355695f, -0.02407294f, 0.02089250f, 0.03522920f, 
    0.00718334f, -0.07322361f, 0.01004378f, -0.01734025f, -0.06799103f, -0.04124695f, -0.06009188f, 0.05033237f, 
    0.01083670f, -0.05700829f, -0.04928081f, -0.06233248f, 0.03064525f, -0.00323291f, 0.00343705f, 0.05199619f, 
    -0.02294482f, -0.01501190f, 0.03746875f, 0.03657595f, -0.05677751f, 0.05923451f, 0.05018302f, -0.01065575f, 
    0.03908938f, 0.04190399f, -0.04657349f, -0.01768938f, -0.05110270f, 0.03947549f, 0.03787035f, 0.06397328f, 
    -0.05768289f, -0.04746384f, -0.02566429f, 0.01959718f, -0.01885405f, -0.01597958f, -0.07634613f, -0.03577146f, 
    -0.02626275f, 0.03650688f, 0.02734254f, -0.03914406f, -0.05053552f, -0.03616688f, 0.00630497f, -0.00139843f, 
    -0.05466476f, -0.03661261f, 0.01644190f, 0.03899821f, -0.04817239f, 0.00860604f, -0.02677949f, 0.02557057f, 
    0.00084433f, 0.04310089f, 0.02534423f, -0.06910005f, -0.04049869f, -0.08061719f, 0.02665333f, -0.01541792f, 
    -0.05825368f, -0.01865720f, 0.05295219f, 0.01231295f, 0.03473470f, 0.06873529f, -0.03725896f, -0.04314016f, 
    -0.02709974f, 0.01217095f, -0.06883620f, 0.05926557f, -0.06906240f, -0.07950716f, 0.05291353f, -0.00256223f, 
    0.03860397f, -0.00029477f, -0.02528628f, -0.07640022f, 0.02096072f, 0.00931363f, -0.03041420f, -0.02795241f, 
    0.05953748f, -0.00620401f, -0.05982405f, 0.00644454f, -0.07576501f, 0.02203652f, 0.00602904f, 0.02347525f, 
    0.01338543f, -0.04045644f, 0.01188126f, 0.06381191f, -0.03745522f, -0.03540064f, 0.03540006f, 0.01614147f, 
    -0.03494788f, -0.05187336f, -0.01882719f, -0.03308161f, -0.02980625f, 0.04002820f, -0.06395740f, 0.00218822f, 
    0.06348650f, -0.00797276f, 0.01466339f, 0.05552425f, -0.03425197f, -0.00721920f, -0.05459332f, 0.01808317f, 
    0.00038526f, 0.01660297f, -0.02508109f, -0.08555368f, -0.06558446f, 0.02016155f, -0.03669218f, -0.04889067f, 
    -0.02387979f, 0.00820212f, -0.03782272f, -0.08216375f, 0.02255140f, 0.00826742f, -0.04728274f, 0.04389699f, 
    -0.03261883f, 0.05967404f, -0.04538815f, 0.02573930f, -0.09003282f, -0.04225068f, -0.06646489f, -0.04578411f, 
    0.01361472f, -0.00951915f, -0.08638451f, 0.02162074f, 0.00637455f, -0.08048344f, -0.08599137f, -0.02264069f, 
    -0.09368122f, -0.00909737f, -0.03049289f, 0.01535855f, 0.03696132f, 0.05854531f, -0.00740352f, -0.02567277f, 
    0.02690070f, -0.05994951f, -0.03635604f, -0.00974928f, 0.02291864f, 0.04916689f, -0.08209217f, 0.02255765f, 
    -0.05033480f, -0.01236243f, 0.06258816f, 0.05997829f, 0.01558607f, -0.07447290f, 0.04853996f, -0.07477384f, 
    0.01742734f, -0.04221718f, -0.00869373f, -0.04606245f, -0.06573032f, 0.02883606f, 0.00769038f, 0.03260380f, 
    0.00607652f, 0.02574976f, -0.07354741f, -0.03348996f, -0.06412567f, -0.08009464f, -0.01140320f, 0.04770346f, 
    0.00409109f, -0.05534820f, -0.06327076f, -0.01910260f, 0.01170122f, 0.04516893f, -0.07740203f, -0.01033300f, 
    -0.01557747f, -0.02966045f, 0.02114236f, -0.04667737f, -0.05128380f, -0.08362396f, -0.01118805f, 0.00864433f, 
    0.04907193f, -0.00168211f, 0.02952114f, -0.04142953f, -0.06266037f, -0.00966367f, 0.03089931f, 0.00279466f, 
    0.04621578f, -0.02419490f, 0.05666704f, 0.02873314f, 0.04199212f, 0.04640346f, -0.07167504f, 0.00564032f, 
    -0.01977476f, 0.04375733f, 0.02090035f, -0.02305195f, -0.01059665f, -0.06408983f, 0.04014159f, -0.02658987f, 
    -0.00179538f, -0.05190689f, 0.05192278f, -0.02385806f, 0.04080460f, -0.06753478f, -0.04387526f, -0.06570100f, 
    0.01889858f, 0.05020981f, -0.05871636f, -0.01520367f, 0.04737289f, 0.01371590f, -0.00438698f, 0.01147777f, 
    -0.04027450f, -0.00347003f, 0.01971155f, 0.05830261f, -0.00202421f, 0.02090378f, 0.06246459f, -0.03457044f, 
    -0.07313795f, -0.04806402f, 0.02197875f, 0.04170873f, 0.01927386f, -0.05860464f, 0.01116668f, 0.01831711f, 
    0.03553855f, -0.07296173f, -0.08177947f, -0.05565497f, 0.05618942f, 0.03133168f, 0.01360706f, -0.02330098f, 
    0.24984844f, 0.24560840f, -0.06373583f, 0.00615389f, 0.15104291f, 0.03285875f, -0.04353610f, 0.07951252f, 
    -0.08931107f, 0.05988266f, -0.02889078f, -0.03288848f, 0.12400744f, -0.00207794f, -0.16905668f, -0.13684946f, 
    0.04694061f, 0.04114623f, 0.05524713f, -0.28626657f, 0.07652968f, 0.02672585f, 0.11849032f, 0.11072588f, 
    0.30491069f, 0.05987146f, 0.07847428f, 0.02447549f, 0.05484173f, -0.09036058f, 0.19593126f, 0.02062137f, 
    -0.09331866f, 0.00624153f, 0.03691981f, -0.24107780f, -0.19893038f, -0.04756057f, -0.15533465f, -0.11739714f, 
    0.00076829f, 0.10190926f, -0.03973654f, 0.03523314f, 0.09401958f, 0.11448251f, -0.06630893f, -0.00810330f, 
    -0.32712382f, 0.14155045f, -0.03859456f, -0.04079299f, 0.21698128f, -0.10617419f, 0.13720031f, 0.17254108f, 
    0.17215297f, 0.05663932f, 0.05166108f, 0.14715192f, -0.05345380f, -0.12541246f, -0.16704458f, 0.13234457f, 
    0.00362773f, 0.04888850f, -0.00226836f, 0.02812112f, -0.00008547f, -0.09489471f, 0.00623574f, 0.20431122f, 
    0.12812890f, -0.13421838f, 0.20835525f, -0.51543039f, 0.10743706f, 0.02985951f, -0.07554305f, 0.00742130f, 
    -0.02330540f, 0.01441042f, -0.20451102f, 0.08034512f, 0.18358348f, -0.16862141f, -0.18078092f, 0.21166025f, 
    0.16624528f, 0.00394246f, 0.07175130f, -0.17106391f, -0.06418985f, 0.01672367f, 0.08354513f, -0.16704306f, 
    0.10488930f, -0.18642417f, 0.06697641f, 0.17880826f, 0.15977331f, -0.00757095f, 0.01774554f, 0.02122828f, 
    0.00316510f, -0.09361417f, -0.09544141f, -0.12848179f, -0.21477348f, -0.00980230f, -0.00514430f, -0.03926462f, 
    -0.10782193f, -0.05034456f, 0.10230519f, 0.07233232f, -0.03174307f, 0.01602817f, 0.10316919f, -0.20011710f, 
    -0.01092194f, 0.08159399f, 0.01722226f, -0.02949684f, 0.07455855f, 0.09666868f, 0.09038175f, 0.12046666f, 
    0.12657128f, 0.13388634f, 0.02583642f, 0.08379824f, 0.09516595f, -0.01488280f, -0.00543771f, 0.02752849f, 
    0.10493233f, -0.10127848f, 0.19515745f, 0.04051601f, 0.07414019f, -0.09228436f, 0.20528427f, 0.09122115f, 
    0.11118664f, 0.52898681f, 0.18120795f, -0.02464169f, -0.05709413f, 0.15754722f, 0.02770978f, 0.06428851f, 
    0.07158732f, 0.01427918f, 0.11794219f, 0.07666186f, 0.15481576f, 0.11996796f, -0.08438413f, 0.15635677f, 
    0.08677908f, 0.02118570f, 0.04129261f, -0.00732826f, 0.03370869f, -0.10366748f, 0.00951252f, 0.00424330f, 
    -0.14681967f, -0.62752968f, -0.01986849f, 0.05854518f, -0.04132459f, -0.02829585f, 0.05557745f, 0.09618775f, 
    -0.15560089f, 0.12824170f, 0.05480763f, 0.08134329f, 0.22539459f, 0.10218543f, -0.16693379f, -0.00759237f, 
    0.03353653f, 0.14147744f, 0.05412503f, 0.13183327f, 0.03568495f, 0.02438456f, 0.03175993f, 0.08288193f, 
    0.06611041f, -0.07874724f, 0.03304090f, 0.05773780f, -0.00644738f, -0.07464097f, -0.05569957f, -0.00620481f, 
    0.05487276f, -0.05951932f, -0.04848396f, -0.00975276f, -0.03401559f, -0.01230255f, -0.01346734f, 0.06062830f, 
    0.05529772f, 0.05099265f, -0.01974315f, 0.02952941f, -0.04779580f, 0.02487831f, 0.03582066f, -0.01540161f, 
    0.04289254f, -0.02241677f, 0.04554044f, -0.04400764f, -0.03233653f, 0.00170459f, -0.00064416f, 0.04832437f, 
    0.03152178f, 0.02444764f, -0.02148555f, -0.00735416f, -0.00503291f, 0.03331196f, -0.04313233f, 0.05892883f, 
    -0.03270034f, 0.01765245f, -0.04389117f, -0.03920712f, 0.03951843f, -0.00799129f, -0.03619804f, 0.02309010f, 
    -0.05840066f, 0.03895291f, 0.02917364f, -0.06832965f, -0.07714324f, 0.04546117f, -0.01442855f, 0.03895386f, 
    -0.00968058f, -0.01023078f, 0.07060427f, -0.01850086f, -0.05917932f, 0.00794590f, 0.05893490f, -0.00631213f, 
    -0.08030506f, 0.04799151f, -0.02849978f, -0.01788993f, -0.00894968f, -0.03510245f, 0.05080321f, -0.00847588f, 
    0.03023054f, 0.03383831f, 0.00373378f, -0.04340767f, 0.02298438f, -0.04545022f, -0.06187743f, 0.06635090f, 
    0.00143269f, -0.05038383f, -0.07162694f, -0.01309232f, -0.02850557f, 0.02648081f, 0.01819742f, 0.00406867f, 
    -0.01839432f, -0.07593387f, -0.07254095f, -0.00198234f, -0.02986841f, -0.05293105f, 0.04475749f, 0.03895370f, 
    -0.07817277f, 0.02725262f, 0.00039782f, 0.00944263f, 0.02580108f, 0.00903426f, -0.04679605f, -0.00407571f, 
    -0.00404180f, -0.00723382f, 0.04573447f, 0.01941509f, -0.05860562f, 0.02088135f, 0.02791619f, -0.03935888f, 
    0.03597845f, 0.04248090f, -0.06781193f, 0.00883457f, -0.01739217f, 0.06993192f, -0.03122394f, 0.04313715f, 
    -0.05830301f, 0.00073770f, -0.03437408f, -0.05305717f, -0.06130331f, -0.04572276f, -0.05706609f, -0.05353896f, 
    -0.02415708f, -0.06050754f, -0.06317385f, -0.04495644f, -0.05662159f, 0.02966039f, 0.02852587f, 0.05481330f, 
    -0.05569055f, -0.05865608f, -0.00788364f, -0.04415957f, 0.00808711f, 0.03035428f, -0.03913241f, -0.06446886f, 
    -0.02962262f, -0.04958789f, -0.05987174f, -0.01539697f, -0.04051670f, -0.01295951f, 0.02125204f, -0.03052204f, 
    -0.06956478f, 0.05740071f, -0.06807501f, 0.02915034f, 0.00190811f, 0.04111324f, -0.02701331f, 0.01244738f, 
    -0.04578988f, 0.04901921f, 0.05651626f, 0.06232593f, 0.00325999f, 0.03646298f, -0.07592473f, -0.07305779f, 
    -0.06866898f, -0.00486280f, 0.00515656f, -0.00380371f, -0.05444545f, -0.01862872f, -0.00581364f, 0.05484847f, 
    -0.05345111f, -0.04979008f, 0.02377102f, -0.02842326f, 0.01003527f, -0.06978694f, 0.04248507f, 0.00807327f, 
    -0.04985067f, -0.05386367f, -0.06574447f, 0.04322344f, -0.05372325f, -0.01960703f, -0.03298571f, 0.05703257f, 
    -0.21575755f, 0.00269583f, 0.05624113f, -0.01943435f, 0.00565296f, -0.06041926f, -0.03371178f, -0.08086852f, 
    0.02109812f, 0.07557826f, -0.20161106f, 0.05788284f, 0.20984487f, 0.17108768f, 0.18309559f, 0.09788202f, 
    -0.00745902f, 0.09894459f, 0.08924326f, -0.04566873f, -0.06380346f, 0.07122160f, 0.08560818f, 0.07463501f, 
    0.12371404f, 0.02060952f, 0.00152543f, -0.04799027f, 0.07936884f, -0.13527654f, 0.04291691f, 0.05584408f, 
    -0.07850973f, -0.01092086f, 0.03634408f, 0.04161846f, 0.25600359f, 0.18420167f, -0.00978832f, 0.04300904f, 
    0.13872284f, -0.06885699f, -0.08293773f, 0.14836025f, 0.08345430f, 0.21117306f, -0.05561379f, -0.07863357f, 
    0.07664464f, -0.21510899f, -0.28618357f, -0.05426377f, -0.00980507f, 0.03848164f, 0.14773721f, -0.00597091f, 
    0.00759081f, 0.06795875f, -0.02188377f, 0.13991752f, 0.16954839f, 0.35290909f, -0.09150584f, 0.10249584f, 
    0.05002670f, 0.04473405f, -0.01153551f, 0.10799904f, -0.02388438f, 0.00003152f, 0.01058606f, 0.19087823f, 
    -0.40122464f, 0.06499700f, -0.17734702f, -0.30237031f, 0.19140819f, -0.08271115f, 0.05649641f, 0.00262696f, 
    -0.07259775f, -0.05513188f, -0.05469859f, -0.00697354f, -0.12113711f, -0.14205222f, 0.12915960f, 0.16127346f, 
    -0.11960530f, 0.11925039f, 0.12710702f, -0.03205816f, 0.05696890f, 0.05508553f, -0.03928194f, -0.07670426f, 
    -0.19483286f, 0.04241746f, -0.01574087f, 0.28253669f, 0.04339788f, 0.00585477f, 0.00965202f, -0.00148436f, 
    0.18786283f, -0.02631663f, -0.05176299f, 0.05987497f, 0.32328054f, 0.20802537f, 0.23158471f, -0.12226184f, 
    -0.00511935f, 0.01003958f, 0.02603732f, 0.16436592f, -0.00568249f, -0.22748581f, 0.04832317f, -0.08968443f, 
    0.47461838f, 0.18782181f, 0.21005791f, 0.04983410f, -0.10636728f, 0.04537967f, 0.14238888f, 0.05475684f, 
    -0.13899755f, -0.03909990f, 0.09122149f, 0.04149111f, 0.28421536f, -0.10143175f, 0.00057967f, 0.13748761f, 
    0.11138792f, -0.11286496f, 0.13613930f, -0.01721129f, -0.08116599f, 0.03174311f, -0.00009046f, 0.09926601f, 
    -0.25462604f, -0.00187590f, -0.06284097f, -0.18040268f, 0.09928607f, 0.16501687f, -0.06636562f, -0.11049999f, 
    0.05334822f, 0.02556317f, 0.04970048f, 0.15955843f, 0.01722994f, -0.02707682f, 0.13293673f, 0.10820223f, 
    -0.05050622f, 0.04868364f, 0.10297628f, -0.19108072f, -0.01272657f, 0.02502717f, -0.03428204f, -0.06962342f, 
    -0.27390879f, -0.02782148f, 0.10734953f, 0.19041371f, -0.09315722f, -0.08400647f, 0.08266845f, 0.14227799f, 
    -0.09846137f, 0.04625502f, 0.20344193f, 0.10304946f, -0.07199837f, -0.22300933f, 0.07875519f, -0.07192863f, 
    -0.04369286f, -0.02839760f, 0.05826233f, -0.04695352f, 0.09063003f, -0.00443193f, 0.04720809f, -0.12802283f, 
    -0.19543010f, -0.09832630f, 0.05958091f, 0.08344926f, 0.03803843f, 0.07633089f, 0.00171428f, 0.13821454f, 
    0.14157741f, -0.00026167f, 0.09291484f, 0.04524996f, 0.34622335f, 0.17137296f, 0.06904559f, 0.03343839f, 
    -0.07022032f, 0.00763073f, 0.05001799f, 0.06526992f, 0.05017711f, -0.01525739f, 0.11936258f, 0.04450653f, 
    0.13296305f, -0.00239291f, -0.00681601f, 0.01131166f, -0.04411297f, 0.06645404f, 0.07671268f, -0.02550451f, 
    0.01279980f, 0.02312861f, 0.05667403f, 0.01875350f, 0.06181924f, 0.13855572f, -0.07266018f, 0.08640430f, 
    -0.07884671f, 0.22935683f, 0.19961163f, -0.03793325f, -0.08280258f, 0.03596868f, -0.05589282f, -0.04667596f, 
    -0.24581356f, -0.12386002f, -0.14164205f, -0.18537411f, 0.03418301f, -0.07183469f, 0.05844098f, -0.16916597f, 
    -0.09170689f, -0.03947510f, -0.12544130f, -0.04700993f, 0.57282561f, 0.11950803f, -0.08725320f, 0.21861675f, 
    0.08231102f, -0.04267815f, -0.20556617f, 0.12815079f, 0.06655709f, -0.03308361f, 0.00709766f, -0.03203287f, 
    -0.40034989f, -0.09667885f, 0.01241372f, -0.14661413f, -0.11946693f, -0.06143665f, 0.02422264f, 0.00917700f, 
    0.03740549f, 0.00791553f, 0.08969253f, -0.04319164f, -0.23323637f, 0.17263651f, -0.19229116f, 0.39732632f, 
    0.03109144f, 0.08330876f, -0.18178916f, 0.03706221f, 0.13218974f, 0.00350025f, -0.08451360f, 0.04521927f, 
    -0.03530055f, -0.02037895f, -0.10182846f, 0.18930569f, -0.18698277f, -0.02449846f, 0.09772583f, 0.16829713f, 
    0.06528503f, -0.03557988f, 0.02232473f, 0.10079965f, 0.36832681f, 0.23655112f, 0.19258580f, -0.05530192f, 
    0.01537487f, 0.01816869f, 0.02842255f, -0.04268286f, 0.02230071f, 0.06821738f, -0.02517664f, 0.13652164f, 
    0.01277780f, 0.20027660f, 0.21455395f, -0.33848205f, 0.06987198f, 0.09726530f, -0.09303816f, -0.04600278f, 
    0.03773976f, 0.00579638f, -0.06982982f, -0.03494814f, 0.27931002f, 0.06835496f, 0.30230781f, 0.20885265f, 
    -0.09413224f, 0.07271463f, -0.02533475f, 0.12320662f, -0.00869980f, -0.02032075f, -0.01170116f, 0.01283999f, 
    -0.87671000f, -0.22911532f, 0.05835825f, -0.03521121f, 0.21614970f, 0.03269377f, -0.06703487f, -0.14103290f, 
    0.06810327f, 0.11635976f, 0.16654019f, 0.12338064f, 0.05118769f, 0.03538305f, 0.05123537f, 0.06145418f, 
    0.02494008f, 0.14227204f, 0.01969541f, 0.02760200f, -0.03222707f, 0.08007704f, 0.09624561f, -0.03568254f, 
    -0.03249443f, 0.12884314f, -0.08694292f, -0.02786633f, -0.11543410f, -0.04983853f, 0.09479955f, -0.21255560f, 
    0.03961839f, 0.05725292f, -0.14618497f, 0.10042322f, -0.20453423f, -0.09967842f, -0.02977472f, 0.35047069f, 
    0.03018390f, -0.03485817f, -0.05236297f, 0.17200007f, 0.05141501f, -0.04675002f, -0.21052963f, 0.04957794f, 
    -0.03538055f, 0.22934353f, 0.07895011f, 0.15056521f, -0.03175352f, 0.09394762f, -0.15348999f, -0.10881989f, 
    -0.21740906f, -0.04842319f, -0.00787316f, -0.08963195f, 0.05733218f, 0.23788673f, -0.08417261f, 0.06455556f, 
    0.07701081f, 0.17354165f, 0.11396611f, 0.12049594f, 0.05518470f, -0.06957132f, 0.17197227f, 0.13583690f, 
    -0.35999578f, 0.41801468f, -0.23392765f, 0.04248500f, 0.14474027f, -0.01988306f, -0.07998003f, 0.05848467f, 
    0.13232245f, -0.07340264f, -0.05708343f, -0.03834864f, -0.06819587f, 0.07266050f, -0.16730706f, -0.11204915f, 
    0.06672180f, 0.27363110f, 0.02933096f, -0.07496134f, -0.11104188f, -0.11831700f, 0.11921661f, -0.01458753f, 
    0.16849278f, -0.16020466f, 0.02299491f, -0.05204162f, -0.10495245f, 0.02317864f, -0.06669228f, -0.26369101f, 
    -0.07617363f, -0.00466419f, 0.02332719f, 0.00590262f, 0.33201769f, 0.09986575f, 0.31442156f, 0.09536628f, 
    0.00785532f, 0.04220181f, 0.24429283f, 0.03850529f, -0.15803084f, 0.13211493f, -0.14441086f, 0.16250849f, 
    -0.12608235f, -0.32075003f, -0.09636155f, 0.28834271f, -0.09221980f, -0.06040645f, -0.00151497f, -0.17962110f, 
    0.06151987f, -0.01905836f, -0.05804406f, -0.03721972f, -0.13065639f, -0.13178703f, 0.00927977f, -0.27118155f, 
    0.00007806f, 0.02085996f, -0.08719793f, -0.01328805f, 0.08726242f, 0.10971031f, -0.12967689f, 0.00500638f, 
    -0.07328900f, -0.39807266f, -0.24679066f, -0.30507132f, -0.12906475f, -0.14197463f, 0.06073493f, -0.05542675f, 
    -0.01469157f, 0.14860074f, 0.09057847f, 0.04323273f, 0.03094365f, 0.41187307f, 0.21243681f, 0.13748601f, 
    0.13154532f, 0.12782702f, -0.08778107f, 0.06560819f, 0.06045615f, 0.06866348f, 0.09431827f, 0.18457532f, 
    0.07319846f, -0.18271978f, 0.11357289f, 0.00528856f, 0.16394971f, 0.08731871f, 0.00149485f, -0.03141510f, 
    -0.01219493f, 0.00411002f, -0.02749266f, 0.22635654f, -0.36301205f, 0.35597408f, -0.08414192f, -0.09391332f, 
    0.13549662f, 0.11785002f, -0.10557273f, 0.08400731f, -0.04730587f, -0.10605254f, -0.10360523f, 0.08392455f, 
    0.25399840f, -0.49583194f, -0.31095204f, -0.07777693f, 0.02613570f, -0.18715583f, -0.05598403f, -0.14643538f, 
    0.07774901f, -0.02833826f, -0.05118681f, 0.10118683f, -0.11519042f, 0.23087659f, 0.31813711f, 0.00717811f, 
    0.11195561f, 0.11560371f, 0.00435164f, -0.09768590f, 0.02594103f, -0.11630326f, 0.06220895f, 0.06383438f, 
    0.48246545f, 0.23597664f, -0.41363949f, -0.60114694f, 0.06660970f, 0.11720742f, 0.12307116f, -0.01656275f, 
    -0.00054439f, -0.05300762f, -0.03379902f, 0.08172938f, -0.03711420f, 0.21843585f, 0.31093255f, 0.19993885f, 
    -0.07538984f, 0.06461027f, 0.09216280f, 0.17159240f, 0.00955578f, 0.06606252f, 0.02530076f, -0.01324176f, 
    0.41658401f, 0.28505024f, 0.16833292f, -0.12201114f, -0.20183705f, 0.14073734f, 0.08241112f, 0.05320513f, 
    0.04755724f, 0.06915236f, 0.16429690f, 0.00152832f, 0.03665317f, -0.06939014f, -0.27347857f, -0.03437233f, 
    0.13757080f, -0.08220309f, -0.01587998f, 0.03873283f, 0.01539129f, 0.17898329f, 0.10828649f, 0.13652836f, 
    0.23251279f, -0.05970941f, -0.04672876f, 0.01287468f, 0.01363795f, 0.11738494f, 0.07749616f, 0.19075088f, 
    0.06040583f, 0.04916403f, 0.08033784f, -0.11994869f, -0.35084939f, -0.32087657f, -0.13261241f, -0.12930252f, 
    -0.03525066f, -0.07979731f, -0.10415786f, -0.11222682f, 0.02669618f, 0.08032107f, -0.02964692f, -0.08896631f, 
    -0.14038335f, 0.30265698f, 0.04148947f, -0.32271066f, 0.00975761f, 0.10297387f, -0.04563810f, -0.01073163f, 
    0.15712437f, 0.05396133f, 0.06183217f, 0.06678891f, -0.09160206f, -0.38884333f, 0.15620108f, 0.16440462f, 
    0.00301815f, -0.02398693f, 0.10487743f, -0.05292348f, -0.01517610f, -0.06699894f, -0.06862149f, 0.13539377f, 
    0.11825430f, -0.00574006f, 0.27677757f, -0.32760113f, 0.01264357f, 0.05969091f, -0.07597512f, 0.02739874f, 
    0.11632825f, 0.08861559f, 0.08122002f, 0.17413463f, -0.02678514f, -0.29090887f, 0.01118479f, 0.09736441f, 
    0.04735962f, -0.04611881f, 0.19065733f, 0.08686207f, -0.08334154f, -0.04418793f, 0.04586089f, -0.11553279f, 
    -0.06803674f, -0.15251899f, 0.09483016f, -0.08871540f, 0.05458470f, 0.09277173f, 0.10895263f, 0.11851743f, 
    0.07796974f, -0.03525117f, 0.12272144f, -0.08154958f, -0.13392432f, 0.03504679f, -0.21776119f, -0.00146587f, 
    -0.09825166f, 0.07010882f, -0.00017413f, 0.05961224f, -0.03964660f, 0.01072382f, -0.07804551f, -0.27349287f, 
    -0.17515975f, -0.17995214f, -0.29999435f, 0.17222220f, 0.17438406f, -0.10164864f, -0.06251497f, 0.08787374f, 
    0.05421408f, 0.05626797f, -0.01293832f, -0.01986626f, 0.22303532f, -0.18126650f, -0.00657882f, -0.29242951f, 
    0.10542753f, 0.03842799f, -0.10447371f, 0.15899245f, 0.04034388f, -0.04113784f, 0.08839328f, -0.01654215f, 
    0.01484744f, 0.46688884f, 0.21465503f, -0.00868976f, -0.14250554f, 0.05147522f, 0.10019124f, 0.06319445f, 
    0.03978989f, 0.09937851f, 0.14918461f, 0.13176478f, 0.08336658f, -0.19627464f, 0.13633528f, 0.12162029f, 
    0.08803057f, -0.05857643f, 0.17425898f, 0.14915454f, 0.00966729f, -0.09673712f, -0.05176697f, -0.14671855f, 
    0.12513655f, -0.26691020f, -0.11909257f, -0.17255609f, 0.01156381f, -0.10712048f, 0.05962415f, 0.10504418f, 
    0.03274611f, -0.06212058f, -0.08611690f, 0.01373199f, -0.12998879f, 0.04240152f, -0.02702335f, 0.21483594f, 
    -0.05791888f, -0.04025892f, 0.02112771f, 0.07614727f, 0.08077011f, 0.04237017f, -0.06243286f, -0.09379771f, 
    0.24676184f, 0.30641776f, -0.14869109f, -0.01960135f, 0.03568766f, 0.04700146f, -0.04434116f, 0.07932577f, 
    0.08830373f, -0.00478560f, 0.09852432f, -0.09704551f, 0.29685575f, -0.03053276f, -0.23441720f, -0.01165593f, 
    0.00402954f, -0.15986197f, -0.05366509f, -0.09802239f, 0.08426919f, -0.17522679f, 0.05341453f, 0.10481479f, 
    0.33888423f, -0.14044979f, -0.19539763f, 0.05851978f, 0.03013830f, -0.02607623f, 0.00525196f, -0.06448078f, 
    0.04492127f, 0.01765491f, 0.01908479f, 0.03348787f, -0.20357496f, 0.00492355f, -0.02462487f, -0.02299274f, 
    -0.18330555f, -0.03111535f, 0.17121749f, 0.02574288f, 0.03716778f, 0.08704815f, 0.02735691f, -0.03541762f, 
    -0.06148981f, 0.09871731f, 0.08538351f, 0.14456461f, 0.11048947f, 0.06898002f, 0.11624536f, 0.17110485f, 
    0.05919239f, -0.00658676f, -0.11776831f, 0.24406782f, -0.12672974f, -0.18098050f, -0.27528188f, -0.08267146f, 
    0.11316124f, 0.03229314f, 0.03923802f, 0.02041866f, 0.04637821f, -0.06075787f, 0.05418986f, 0.07422926f, 
    0.36563584f, -0.20049344f, 0.09582422f, -0.07289796f, -0.03947761f, 0.02415554f, -0.05798960f, -0.01684287f, 
    -0.02278787f, 0.01837677f, -0.07916123f, 0.07406146f, 0.08863027f, -0.26557943f, -0.14215928f, 0.04704458f, 
    -0.04712834f, -0.00949137f, -0.04759004f, -0.04251629f, 0.01487480f, 0.06126174f, 0.26605919f, 0.05430865f, 
    0.26357460f, -0.11706674f, -0.02303988f, 0.00123068f, 0.00262509f, -0.02773655f, 0.06729926f, 0.07551480f, 
    -0.00091122f, -0.10361803f, 0.03670171f, -0.11734182f, -0.29383290f, -0.02819871f, -0.18153386f, -0.02143703f, 
    -0.01126495f, 0.22054386f, -0.02073572f, -0.15115580f, 0.09116867f, 0.04548202f, 0.08480088f, -0.02814778f, 
    0.04895440f, 0.04309931f, -0.06655616f, -0.05104726f, 0.03597026f, 0.14124754f, 0.00514724f, 0.08174227f, 
    0.12430470f, 0.04882761f, 0.14245041f, 0.00957891f, 0.38411322f, -0.18407232f, 0.04510272f, 0.01885911f, 
    -0.03861484f, -0.01300266f, 0.02833701f, 0.15142727f, 0.11306857f, 0.05466160f, 0.18056332f, 0.10897306f, 
    -0.24769175f, 0.20703445f, 0.18977170f, 0.19623876f, -0.10042480f, 0.07333362f, 0.08400330f, 0.06238087f, 
    0.03744376f, -0.06238014f, -0.05905829f, -0.07329622f, 0.07632471f, -0.12771896f, -0.06097049f, 0.08107413f, 
    0.11401686f, 0.12400865f, -0.00974301f, 0.15132968f, -0.00435870f, -0.05038114f, -0.10026171f, 0.04945192f, 
    0.15172307f, -0.33455652f, -0.08583103f, -0.08230981f, -0.03890169f, -0.05726796f, -0.07195169f, -0.08893578f, 
    -0.02882443f, 0.11435580f, -0.03101449f, 0.12672886f, 0.00739515f, 0.13316898f, -0.29184553f, -0.07087423f, 
    0.00942044f, 0.18357222f, 0.01713512f, 0.12869023f, 0.10616225f, -0.03435915f, 0.00225182f, 0.19149172f, 
    0.04372753f, 0.03550852f, -0.00810424f, 0.18369593f, -0.02360371f, 0.13111176f, -0.08500551f, 0.03899718f, 
    0.16664505f, 0.10789289f, 0.02844974f, -0.07967582f, 0.18339038f, 0.27522162f, 0.06125700f, 0.01839616f, 
    -0.05526775f, -0.04308311f, -0.00817574f, -0.19524722f, 0.10251778f, -0.16652501f, 0.16747688f, -0.06879719f, 
    0.35997540f, 0.02098183f, -0.15592511f, -0.01579013f, -0.06909768f, 0.02972805f, -0.04798647f, 0.10371985f, 
    -0.03601735f, 0.05447615f, 0.03869005f, 0.05687685f, 0.06369884f, 0.29957938f, -0.09065921f, -0.00610536f, 
    -0.04695720f, 0.11698679f, 0.08447304f, 0.07471325f, -0.09537896f, -0.13019542f, -0.09079652f, -0.34078437f, 
    0.22298740f, -0.17980880f, -0.40872765f, 0.05220867f, 0.06994157f, 0.04660407f, 0.14044791f, -0.02242771f, 
    0.08185751f, -0.10436798f, -0.15211919f, -0.00825794f, 0.01863566f, 0.15314005f, -0.00646628f, 0.19353214f, 
    0.14841963f, 0.02504717f, 0.05282334f, 0.00795833f, -0.03943074f, -0.07705180f, 0.00585797f, -0.04293537f, 
    0.01756224f, -0.44800222f, 0.20348951f, -0.15504625f, -0.09299473f, 0.01725514f, -0.13621542f, -0.02920328f, 
    0.07402340f, 0.14096005f, -0.03006586f, -0.01061733f, 0.00750121f, -0.07708304f, 0.06952526f, 0.14184836f, 
    0.11642173f, 0.03435606f, 0.02433450f, -0.11491286f, 0.04411846f, 0.12071159f, 0.19197996f, 0.01717930f, 
    0.04380775f, -0.40174931f, -0.10658512f, -0.05958352f, -0.12317138f, -0.01993072f, 0.20224987f, 0.00338296f, 
    0.04528920f, -0.06023868f, -0.00842620f, 0.04500449f, 0.16665944f, 0.04006294f, 0.12617177f, -0.00216606f, 
    0.08827721f, 0.03317908f, 0.05949426f, 0.04080531f, 0.11453478f, 0.11156189f, -0.00210302f, -0.15254082f, 
    0.45202041f, 0.38482445f, 0.29082811f, -0.00962665f, 0.07164437f, -0.02255871f, 0.05172608f, -0.07044040f, 
    -0.05923502f, -0.07475790f, 0.04631537f, 0.12174122f, 0.52457762f, -0.02896582f, 0.11647341f, 0.10844193f, 
    -0.04853985f, 0.02127985f, 0.00820288f, 0.22201496f, -0.07186630f, -0.04214120f, -0.05640637f, 0.12033119f, 
    -0.18799746f, -0.21739610f, -0.00244832f, -0.04131117f, 0.01421331f, 0.02134864f, -0.00238267f, -0.00808498f, 
    0.08499667f, 0.06049759f, 0.07844134f, 0.18630280f, 0.15556531f, -0.04258201f, 0.07857163f, -0.01245506f, 
    0.07328726f, -0.01680856f, -0.04301962f, -0.05550240f, -0.00888764f, 0.06673761f, -0.01697910f, -0.08331513f, 
    0.15503706f, 0.07097511f, 0.11512987f, 0.12517193f, -0.25990042f, -0.15345667f, 0.05626148f, 0.06529691f, 
    -0.09617902f, 0.11560125f, -0.00857604f, -0.02179168f, -0.30986583f, 0.11083774f, -0.05507512f, 0.01601585f, 
    -0.12631871f, 0.03256364f, 0.11206823f, -0.13165796f, 0.10464971f, -0.02077333f, -0.13075267f, 0.04173902f, 
    0.04035496f, -0.03826600f, -0.03640583f, -0.07568539f, -0.05298546f, -0.06517735f, -0.03737420f, -0.00248972f, 
    -0.02006365f, -0.06764118f, -0.04477516f, -0.04103396f, -0.04905593f, 0.00527442f, 0.02527439f, 0.04041237f, 
    -0.07102086f, 0.05495303f, -0.00201698f, 0.02798675f, 0.05509712f, -0.03075296f, 0.00580363f, 0.07119010f, 
    -0.08071737f, -0.03605547f, 0.03584833f, 0.05215921f, -0.03530014f, -0.02970332f, -0.06142964f, 0.00391060f, 
    -0.05315185f, 0.03538864f, -0.02553705f, -0.00848808f, 0.05772512f, -0.07310875f, -0.07215571f, 0.05729899f, 
    0.06155220f, -0.00350044f, 0.00700250f, -0.03209437f, -0.03707372f, -0.03792956f, -0.02318990f, -0.05769857f, 
    0.01901423f, 0.06974450f, -0.00605456f, -0.08391038f, -0.01540949f, -0.07392327f, 0.02880542f, -0.02310562f, 
    0.02816473f, -0.06521052f, -0.06102391f, 0.01502663f, 0.05412497f, -0.00739845f, 0.04054072f, -0.05510210f, 
    -0.04772367f, 0.05554455f, 0.05138324f, -0.07334704f, -0.04282464f, 0.05074861f, -0.01425429f, 0.03212707f, 
    -0.03502577f, -0.05122500f, 0.05711809f, -0.04024197f, 0.01033141f, -0.04928662f, -0.04804499f, -0.03311311f, 
    0.05388776f, -0.03721140f, -0.04154579f, -0.03500934f, 0.00801104f, -0.07428181f, -0.00014356f, 0.02171073f, 
    0.05986360f, 0.01431260f, 0.01183519f, 0.04932639f, -0.04888798f, 0.06124124f, -0.04152307f, -0.04324816f, 
    -0.01674973f, -0.07607107f, -0.07339388f, -0.06854189f, 0.04923686f, -0.04034923f, 0.01355513f, -0.07302340f, 
    0.04341506f, -0.04296817f, -0.02271070f, -0.00439755f, -0.00548737f, 0.02232640f, 0.02855725f, -0.01206332f, 
    0.00830069f, 0.00744815f, -0.03611336f, 0.05575803f, -0.01182502f, 0.06650114f, -0.00567605f, -0.03478794f, 
    -0.03096090f, -0.02482057f, 0.00909011f, 0.05617257f, -0.06970216f, 0.00598719f, -0.04071528f, -0.04771366f, 
    -0.03841820f, -0.03255551f, 0.06773636f, -0.01867197f, -0.06416234f, 0.05300107f, 0.05941719f, -0.00668526f, 
    -0.05911963f, -0.00648970f, 0.01876566f, 0.05531170f, -0.01855295f, -0.07240725f, 0.00539637f, -0.04610125f, 
    0.05676857f, -0.00542661f, -0.04614577f, 0.05096310f, 0.04673656f, 0.03934163f, 0.02411696f, 0.01847030f, 
    -0.02487804f, 0.01009224f, -0.00043238f, -0.01144252f, 0.01364368f, -0.02052208f, -0.05378466f, -0.03765307f, 
    0.00450295f, -0.03076346f, -0.07174750f, -0.06363311f, 0.05342477f, -0.01802896f, 0.01913023f, 0.00222798f, 
    -0.05600983f, -0.06497589f, -0.04771356f, 0.04497807f, 0.03229613f, 0.03512667f, -0.01963538f, 0.02112609f, 
    0.01388811f, 0.05426091f, -0.05445910f, -0.03634647f, -0.06401048f, -0.03357926f, 0.03089695f, -0.01616039f, 
    0.04126319f, 0.05602591f, -0.07165372f, -0.07043067f, 0.03479274f, -0.04672613f, -0.06539094f, 0.00969994f, 
    -0.27253178f, 0.00751123f, 0.16695197f, 0.20383985f, 0.07173552f, 0.07241648f, 0.07315422f, -0.02184609f, 
    -0.09663991f, -0.13842811f, -0.11355549f, -0.03739991f, 0.00786491f, 0.25408497f, 0.06874891f, 0.14901604f, 
    -0.01727505f, -0.13075615f, -0.01273916f, -0.07319066f, 0.01958863f, -0.02121079f, 0.13089949f, 0.04814396f, 
    -0.05375187f, 0.09246524f, -0.09808353f, 0.11137867f, -0.00260845f, -0.00329804f, -0.10806084f, 0.03685426f, 
    -0.14693573f, -0.03657907f, 0.00664934f, -0.15424713f, -0.02931043f, -0.12113279f, 0.04574620f, -0.05373469f, 
    -0.14184551f, -0.00271148f, 0.04665994f, -0.02110540f, -0.02814687f, 0.01742030f, -0.00542509f, 0.06442201f, 
    -0.09034149f, 0.02693902f, 0.04507725f, 0.17424923f, -0.02626843f, 0.14418322f, 0.09011345f, 0.10782026f, 
    0.09235947f, 0.06727422f, -0.02099878f, -0.07101334f, 0.32508114f, -0.00401873f, -0.03868544f, 0.14797774f, 
    0.01628210f, 0.06613637f, -0.02406164f, 0.08120114f, 0.01058033f, 0.14455022f, 0.02580422f, -0.06794347f, 
    0.24530682f, -0.46896511f, 0.10428926f, 0.21686226f, -0.11028514f, 0.18591203f, -0.07193159f, 0.10379158f, 
    0.14105012f, 0.03718020f, 0.01811268f, -0.02723452f, 0.16529645f, 0.01431391f, -0.24547064f, -0.11932749f, 
    0.08480063f, -0.01021093f, 0.02074202f, 0.05305837f, 0.02661370f, 0.12685032f, -0.00708368f, 0.04155324f, 
    0.23738842f, -0.42107588f, -0.13400082f, -0.09138025f, -0.08367424f, -0.07395362f, -0.04176582f, -0.01401858f, 
    -0.10615081f, 0.00103205f, 0.00849673f, 0.03510539f, -0.37674075f, 0.17447452f, 0.18355809f, 0.02789444f, 
    0.04740059f, -0.13092142f, -0.20336467f, -0.01655673f, -0.15992300f, -0.08601034f, 0.01137136f, -0.05197925f, 
    0.17544577f, -0.00730049f, 0.09595285f, 0.06255965f, -0.06922773f, -0.07753056f, -0.03494669f, 0.00288557f, 
    -0.06642145f, 0.07451160f, 0.12101717f, 0.11073605f, -0.11166855f, 0.00407152f, 0.28040886f, 0.02472281f, 
    0.03874402f, 0.06371539f, 0.14655942f, -0.02177110f, -0.08249895f, -0.00905828f, 0.13081597f, 0.12359636f, 
    0.25136688f, -0.14768611f, -0.28532144f, 0.07470852f, -0.05105256f, -0.03278241f, 0.12659161f, 0.12552856f, 
    -0.11038729f, -0.11304986f, 0.06651576f, 0.01149020f, 0.24464136f, 0.09711085f, 0.05375485f, 0.04645812f, 
    0.01613292f, -0.04710641f, -0.27621508f, 0.08546748f, -0.17667373f, 0.08625937f, -0.09014233f, 0.19985837f, 
    -0.18104076f, -0.10751138f, -0.07779869f, -0.22647947f, 0.21299519f, 0.09596257f, 0.00234027f, -0.05218869f, 
    -0.08360289f, -0.02921932f, 0.03887626f, 0.04284826f, -0.10848421f, 0.27677754f, -0.18091412f, -0.07447099f, 
    -0.10627510f, 0.08467130f, 0.09161207f, 0.13016167f, 0.05469265f, 0.05300262f, 0.12117057f, 0.07443844f, 
    0.32022023f, -0.02139531f, -0.06631787f, -0.10161167f, 0.20399894f, -0.08615780f, 0.11268377f, 0.07023133f, 
    -0.20958047f, -0.05107084f, -0.00473421f, -0.01515602f, -0.16299023f, 0.06377397f, 0.06894711f, -0.07685794f, 
    0.08665667f, 0.10232876f, 0.02638049f, -0.05368940f, -0.10177469f, 0.08284461f, -0.13380247f, 0.11758461f, 
    -0.07320426f, 0.22675826f, 0.18555015f, -0.08945399f, 0.11987579f, -0.10387677f, 0.02221481f, 0.14419560f, 
    0.00800538f, -0.04386314f, -0.10989269f, -0.20167048f, 0.08200192f, -0.06722021f, -0.05882581f, 0.13192791f, 
    0.05047397f, 0.04301628f, -0.10514475f, -0.08458697f, 0.05037691f, 0.16493042f, -0.12001514f, 0.15401566f, 
    -0.47670236f, 0.20737015f, 0.04574879f, -0.27253923f, 0.11791481f, -0.03828656f, -0.01710191f, 0.02439459f, 
    -0.16534293f, 0.07605050f, 0.30400884f, 0.03872475f, 0.04655743f, -0.07592031f, 0.37620947f, 0.40006915f, 
    -0.04734616f, 0.06991982f, 0.08363432f, 0.00664250f, 0.06374144f, 0.06873198f, 0.01001232f, 0.20077337f, 
    -0.33430886f, 0.05113907f, -0.01954172f, -0.17749859f, 0.17008698f, -0.05255609f, 0.09406266f, -0.11474127f, 
    0.02588634f, -0.04543207f, -0.12366182f, -0.07049602f, -0.07075644f, 0.10718131f, -0.10078461f, 0.08252477f, 
    0.19571157f, 0.01528037f, 0.00158290f, -0.02557292f, 0.08494964f, -0.01727779f, -0.24292907f, -0.04804837f, 
    -0.07682355f, -0.04642012f, -0.03987294f, 0.19749029f, -0.05947419f, 0.09844337f, -0.04547764f, -0.05372466f, 
    0.01100393f, -0.01735050f, 0.03732748f, -0.09608898f, 0.20429905f, 0.07902648f, 0.27335533f, 0.18457647f, 
    0.02346956f, -0.03233076f, 0.09106810f, 0.12921856f, 0.04557035f, -0.18831876f, 0.07739013f, -0.20405316f, 
    -0.16275200f, 0.03801730f, -0.06935252f, -0.02396044f, 0.02199952f, -0.12267419f, -0.15021531f, -0.13402323f, 
    -0.04034697f, -0.00117927f, -0.00427963f, -0.18766984f, -0.05621846f, 0.16145332f, 0.10737401f, -0.07499179f, 
    0.26744872f, -0.11368501f, 0.03057113f, -0.05683556f, 0.13323709f, -0.00918455f, 0.06368925f, 0.02410206f, 
    0.28329241f, 0.45896685f, -0.20161583f, -0.24685831f, 0.01800790f, -0.05284316f, -0.03716195f, 0.10429312f, 
    -0.00588409f, -0.00032870f, 0.07749549f, 0.09445963f, -0.03288788f, 0.22147693f, -0.04805251f, 0.13693348f, 
    -0.04702450f, 0.00263344f, 0.03243738f, -0.06642493f, -0.02470504f, -0.06383257f, 0.03869656f, 0.02422447f, 
    -0.10252584f, 0.00445195f, 0.00874941f, -0.04952148f, -0.02186003f, 0.18238696f, 0.00283818f, 0.09130894f, 
    -0.15348804f, 0.06593946f, 0.05114637f, 0.08046739f, 0.37615868f, -0.31564641f, 0.12510195f, 0.33501282f, 
    0.02349918f, -0.08535227f, -0.03874702f, 0.15698396f, -0.09726800f, 0.11021061f, 0.04188795f, -0.02224368f, 
    -0.00548158f, -0.01906627f, -0.04185322f, -0.02823064f, -0.03480398f, 0.06253441f, 0.01236877f, 0.01182428f, 
    0.05947424f, 0.05487091f, -0.03083257f, -0.00338474f, -0.00479093f, -0.03122612f, -0.02777510f, -0.06540421f, 
    0.00729077f, 0.04396847f, -0.07216562f, 0.00924451f, -0.01350186f, -0.01298142f, 0.02812859f, 0.03083792f, 
    -0.06121706f, -0.05922997f, 0.00477965f, 0.04939209f, -0.03298624f, -0.02877337f, 0.02407041f, 0.06459478f, 
    -0.05484568f, -0.03314401f, 0.01665543f, -0.06394805f, 0.02642231f, -0.03428627f, -0.01594433f, -0.00298017f, 
    -0.05766264f, 0.04552197f, -0.02751622f, -0.02414508f, -0.01446352f, -0.05346685f, 0.01160528f, 0.00250504f, 
    0.01050433f, -0.08178242f, 0.05493612f, -0.01135731f, 0.00619350f, 0.04949186f, 0.06131298f, 0.05449026f, 
    -0.01578785f, -0.06673984f, -0.01215685f, -0.00981585f, -0.05651504f, 0.05785431f, 0.02549732f, -0.08194571f, 
    0.03519983f, -0.04068477f, -0.05255050f, 0.04755370f, -0.00059962f, -0.03605783f, 0.04117638f, 0.02848760f, 
    0.00654752f, 0.00719615f, 0.02630201f, 0.05035620f, -0.02879295f, -0.03011385f, -0.04764533f, 0.01613034f, 
    -0.01492683f, -0.03976258f, -0.04206924f, -0.06006277f, -0.03308694f, -0.05028103f, -0.04412963f, 0.02435395f, 
    -0.01927743f, -0.04687162f, -0.05459504f, -0.02376073f, 0.06057375f, -0.05561441f, -0.00634844f, -0.06323473f, 
    0.01104774f, -0.05431611f, -0.04088921f, -0.06786900f, 0.00013999f, -0.06520154f, -0.07490908f, 0.02809649f, 
    0.04194573f, 0.01103844f, -0.05733507f, -0.04303829f, 0.02384578f, -0.04647971f, -0.05418292f, 0.02060601f, 
    -0.05303976f, -0.02423471f, -0.03847264f, -0.00918985f, -0.07439391f, 0.04296304f, -0.06570881f, -0.05936920f, 
    0.00526111f, -0.03436689f, 0.04189216f, -0.06866910f, -0.02911220f, -0.04726435f, 0.03553146f, -0.05652109f, 
    0.06012258f, 0.04314015f, 0.02893906f, -0.03994855f, -0.06248388f, -0.06079985f, 0.05944398f, -0.06593999f, 
    0.04528483f, -0.07131343f, -0.03641062f, -0.07100049f, 0.06456430f, -0.01947796f, -0.06462818f, 0.00218398f, 
    -0.00087588f, 0.02271802f, 0.00966563f, 0.03300903f, -0.06139633f, -0.00096344f, 0.04584055f, -0.06217164f, 
    -0.02059818f, -0.05631668f, -0.06960665f, -0.00125244f, 0.01382648f, 0.03559057f, -0.05911433f, 0.04467869f, 
    0.04386621f, -0.06265029f, 0.03856038f, -0.03955497f, -0.03760941f, -0.02310204f, 0.01629817f, 0.04844838f, 
    -0.07079370f, -0.04740280f, -0.02836214f, 0.00258548f, 0.03377484f, -0.05615340f, -0.03281410f, -0.00524968f, 
    0.04920432f, 0.02547854f, 0.04647848f, 0.02170267f, -0.00543144f, 0.06152464f, 0.03403738f, -0.01048659f, 
    -0.05918154f, 0.02603072f, -0.05042271f, -0.05185434f, -0.03579539f, -0.03459884f, -0.01830846f, 0.00964644f, 
    0.60207999f, 0.02060740f, -0.27387029f, -0.09495793f, 0.04435848f, -0.05200040f, -0.01193209f, -0.00568096f, 
    -0.02836244f, 0.02981330f, 0.07285877f, 0.10817450f, 0.14553967f, -0.06793290f, 0.06894924f, -0.10800442f, 
    0.01682518f, -0.10144646f, 0.07614089f, 0.14639764f, 0.03009397f, -0.02473548f, -0.10093960f, 0.02253908f, 
    0.23133709f, -0.04871623f, -0.00234468f, 0.09794322f, 0.02929603f, 0.01726096f, 0.06059143f, -0.04292486f, 
    0.09646358f, 0.13428080f, 0.00913694f, 0.04765030f, 0.07750865f, 0.31380099f, 0.03146442f, -0.06450365f, 
    -0.01332483f, -0.04582769f, 0.16637604f, -0.03402121f, 0.22225064f, -0.11198597f, 0.02020893f, -0.07122743f, 
    -0.38000861f, 0.12020073f, -0.06145220f, -0.10698085f, -0.06294216f, 0.10954800f, -0.15280701f, 0.02316364f, 
    -0.07697107f, 0.04105768f, 0.01936214f, -0.09914399f, -0.64748377f, 0.00275250f, 0.13013503f, 0.13437515f, 
    0.17033027f, -0.15766735f, 0.03370065f, 0.06176527f, 0.11481520f, 0.00940490f, -0.00418207f, -0.23175819f, 
    -0.15229453f, -0.16231266f, -0.23252143f, 0.00926668f, 0.03514251f, -0.07467072f, 0.15623546f, -0.09011949f, 
    -0.09699005f, 0.14560151f, 0.13111502f, -0.05872519f, -0.08448018f, 0.30977014f, 0.25577638f, -0.12660357f, 
    0.01458845f, -0.12979752f, -0.05848348f, 0.04157018f, 0.12030412f, -0.08200049f, 0.04866688f, 0.27104104f, 
    0.15887550f, 0.24146765f, -0.01869467f, -0.04624024f, -0.17902230f, 0.06317711f, 0.03236805f, 0.04939140f, 
    0.03964000f, 0.23708822f, 0.15130658f, 0.19660869f, 0.35180035f, -0.01164103f, -0.11361793f, 0.28229737f, 
    0.06202826f, 0.04609009f, 0.02993597f, -0.07542977f, 0.16819736f, 0.03984220f, -0.01044342f, 0.04087306f, 
    -0.23194195f, 0.16640514f, 0.03021741f, -0.19573608f, 0.02403205f, 0.02635202f, -0.13702163f, -0.10749862f, 
    -0.17047335f, -0.09988374f, 0.08408128f, 0.02634243f, 0.27450848f, 0.01076082f, -0.05513802f, 0.16205689f, 
    -0.02097891f, 0.11113832f, -0.10999841f, -0.00391042f, 0.05595122f, 0.05751320f, -0.05500947f, -0.11476808f, 
    -0.03868935f, -0.01834098f, -0.06983613f, -0.30753300f, 0.13007048f, 0.00936541f, -0.08053853f, 0.04612964f, 
    -0.06759576f, -0.04482003f, -0.00819907f, 0.07137794f, -0.18507862f, 0.19616574f, -0.08552612f, -0.00899508f, 
    0.10931968f, 0.21426530f, 0.06949656f, 0.23399436f, -0.11396536f, 0.10029976f, 0.10700651f, 0.03802808f, 
    0.48202425f, 0.32199299f, -0.11087546f, -0.19951825f, 0.11825708f, -0.04667108f, -0.02904079f, 0.00522692f, 
    0.04812535f, -0.08842942f, -0.09912391f, -0.04832227f, 0.22682837f, -0.01476829f, -0.00246857f, 0.15858954f, 
    0.18470162f, -0.01580079f, -0.11640339f, -0.02412991f, -0.07864407f, -0.09031505f, 0.12478047f, -0.02724570f, 
    -0.22260770f, 0.07539350f, -0.16898030f, 0.09571536f, 0.09071415f, -0.17341235f, -0.02647446f, -0.02451118f, 
    -0.07262410f, 0.02166723f, -0.11390658f, 0.04223864f, -0.20775759f, -0.00593550f, 0.15622392f, -0.01451883f, 
    -0.15637562f, 0.10981967f, 0.01925478f, 0.02273647f, -0.14355887f, -0.18491361f, -0.01179885f, -0.08791180f, 
    -0.20797300f, 0.20896265f, 0.07720722f, 0.25583139f, -0.01081445f, -0.13061123f, 0.00989302f, -0.06253735f, 
    -0.03985245f, -0.00459438f, 0.02893109f, -0.03314959f, -0.05303260f, 0.08478301f, 0.01967969f, -0.23051232f, 
    0.04189594f, 0.02932927f, -0.09116820f, -0.04931321f, 0.06219549f, 0.15533370f, -0.10774498f, 0.03396765f, 
    -0.11391322f, -0.05094757f, 0.01198929f, 0.22970665f, -0.00492483f, -0.00920922f, 0.01700011f, 0.10188613f, 
    0.03641196f, 0.17481628f, 0.17145631f, -0.01413647f, 0.06815472f, 0.07758269f, 0.04309651f, 0.08098918f, 
    0.00231907f, 0.01927707f, -0.11172713f, 0.08310627f, 0.14645936f, 0.04289111f, 0.09557345f, -0.08701121f, 
    0.06093236f, -0.04135729f, -0.20413698f, 0.36023369f, 0.02457091f, -0.06121517f, 0.09092261f, -0.06114386f, 
    -0.03283266f, -0.00063247f, -0.07995176f, -0.02864810f, 0.09628972f, 0.20862643f, -0.01839164f, -0.03565146f, 
    0.14655219f, 0.05745503f, -0.00045673f, 0.07412297f, 0.15996376f, 0.00552796f, -0.21153069f, 0.14088647f, 
    -0.00498233f, 0.20166644f, 0.03517340f, 0.12210906f, 0.00844897f, 0.02706914f, 0.01914483f, -0.02123815f, 
    0.02957908f, 0.19993007f, 0.00744315f, 0.11184739f, -0.18828553f, 0.05223903f, 0.17185731f, -0.06002218f, 
    0.24991015f, 0.05300182f, 0.01445488f, 0.10041856f, 0.05074072f, -0.01301265f, 0.07670888f, 0.14355461f, 
    -0.20245574f, 0.10658659f, -0.04465643f, -0.14466368f, -0.02807481f, 0.04109965f, 0.15225172f, -0.17232305f, 
    -0.04102618f, -0.03532822f, 0.07654274f, 0.04537730f, -0.64033300f, 0.28025010f, -0.18132721f, 0.21707252f, 
    0.12061093f, -0.09670848f, 0.09951018f, -0.01664337f, -0.02748494f, 0.09435228f, 0.09956902f, 0.08804834f, 
    0.32008171f, -0.08696544f, -0.09695023f, -0.06905568f, 0.13214549f, 0.00652013f, -0.03192899f, -0.03699918f, 
    0.05099245f, 0.05423812f, -0.00153502f, -0.07357581f, -0.20472227f, 0.29563549f, -0.20927399f, -0.17375125f, 
    0.04053131f, 0.10645454f, -0.08647785f, -0.04319332f, 0.16067839f, 0.15023550f, 0.00243787f, 0.04342707f, 
    0.08806591f, -0.06677276f, 0.08408630f, 0.05220689f, -0.01754477f, 0.07472072f, 0.03673780f, -0.00281826f, 
    -0.05080082f, -0.01919243f, 0.00596230f, -0.08914511f, 0.19826497f, 0.14121647f, 0.05123051f, -0.05923323f, 
    0.03518705f, -0.02443478f, 0.15159938f, 0.01467271f, -0.11590107f, 0.08365578f, 0.16801250f, -0.04152980f, 
    -0.01967503f, -0.18420589f, 0.12856567f, 0.18534955f, 0.02296283f, 0.13765794f, 0.06823396f, -0.08297023f, 
    0.13346665f, 0.05424017f, 0.21025851f, -0.02270565f, -0.26883411f, 0.19986589f, -0.07053841f, -0.14479710f, 
    0.06965941f, -0.12862059f, 0.04139325f, 0.06768019f, 0.17265919f, -0.15825976f, 0.14843491f, -0.15171234f, 
    -0.16291019f, 0.04970782f, -0.15324719f, -0.06803957f, 0.00762944f, 0.22512785f, -0.04951042f, 0.08093078f, 
    0.13220434f, 0.01971710f, 0.12808584f, 0.04583676f, 0.11482149f, -0.02150683f, -0.06138146f, -0.04610069f, 
    0.02101079f, 0.18572631f, 0.09223620f, -0.11243147f, -0.14596903f, -0.22610508f, 0.00322285f, 0.00057220f, 
    0.45123658f, -0.08472317f, 0.22206621f, 0.08580219f, 0.02919797f, -0.00050961f, 0.10296928f, -0.08700388f, 
    -0.04529940f, -0.04148019f, -0.18486395f, -0.04795344f, -0.01261994f, -0.09448583f, 0.11594658f, 0.02757125f, 
    0.08320820f, 0.02842909f, 0.06513485f, -0.07347088f, -0.02076281f, 0.06275529f, 0.02951968f, -0.06508131f, 
    0.65576315f, -0.11394957f, 0.47373325f, 0.21005963f, -0.19628897f, 0.08586350f, -0.04912559f, 0.04672685f, 
    0.12886269f, 0.11526587f, 0.17708762f, 0.04933892f, 0.19612844f, 0.16529442f, -0.24171850f, 0.12862895f, 
    0.04365490f, -0.06654914f, 0.07119774f, -0.00402454f, -0.01733126f, -0.02448508f, 0.09279601f, 0.05295081f, 
    0.17969321f, -0.37572265f, -0.07586157f, -0.28521466f, -0.15076946f, -0.08593983f, 0.07345508f, -0.06783230f, 
    -0.06807072f, -0.00384519f, 0.07942233f, 0.06812058f, -0.19331598f, -0.26799253f, -0.00963586f, 0.02038175f, 
    -0.00088248f, -0.07351940f, 0.06690630f, -0.07771526f, -0.00292224f, 0.30282715f, 0.18986590f, 0.01260917f, 
    -0.12213545f, -0.00755213f, 0.03112147f, 0.14038035f, 0.15819865f, -0.05380707f, -0.07357699f, 0.04046787f, 
    0.21053062f, -0.00519989f, -0.25460082f, 0.12950362f, -0.34159073f, 0.22257531f, 0.11093183f, -0.27643082f, 
    -0.11029098f, 0.09404207f, -0.03797697f, 0.02384133f, 0.07632253f, -0.19830413f, -0.01284177f, -0.00961788f, 
    0.08180741f, -0.14923400f, 0.15667674f, 0.18793337f, -0.12799996f, -0.05585721f, 0.04364251f, 0.05016557f, 
    0.00021830f, 0.02573770f, 0.16850117f, 0.04392490f, 0.12202414f, -0.12091770f, 0.08516721f, -0.04459662f, 
    0.02465817f, -0.15126787f, -0.10010623f, 0.02526749f, 0.01751723f, 0.06832530f, 0.13266142f, -0.06676773f, 
    0.02282350f, 0.03027287f, -0.04464551f, 0.15062548f, -0.13386022f, 0.06142484f, -0.01083088f, -0.09702464f, 
    0.07124224f, -0.01295452f, -0.11304988f, 0.04951144f, -0.35715938f, 0.30082583f, -0.08946890f, 0.17502156f, 
    0.04545980f, -0.02328681f, 0.17826137f, -0.00157451f, 0.10113245f, -0.08962461f, -0.18897684f, 0.11370841f, 
    0.03345347f, -0.04623306f, 0.01564178f, -0.00733802f, -0.04811457f, -0.04493667f, 0.02379896f, -0.06608344f, 
    0.02160339f, 0.00808148f, 0.05689812f, -0.06694604f, -0.08605184f, -0.03099935f, -0.01055071f, -0.00362302f, 
    -0.07067260f, -0.05942401f, -0.06920424f, 0.04816119f, -0.04435831f, 0.03128071f, -0.02192372f, 0.00839800f, 
    0.07666301f, -0.00455166f, 0.06877438f, -0.02251103f, 0.01260108f, -0.00463656f, -0.08041964f, -0.03195985f, 
    0.05557323f, 0.05556890f, 0.04306674f, -0.04827263f, 0.04022523f, 0.03430959f, 0.06239691f, -0.06797021f, 
    0.04309074f, -0.04563775f, 0.02229145f, -0.06323028f, -0.01460856f, -0.03745371f, -0.05116230f, -0.05141040f, 
    -0.07285574f, 0.05373493f, 0.00205177f, -0.00054724f, 0.02653844f, -0.04903467f, -0.05470650f, -0.04778957f, 
    0.05126433f, 0.01536001f, 0.03647893f, -0.04181888f, -0.07202546f, -0.03610280f, -0.03975476f, -0.01196141f, 
    -0.00694727f, -0.06615140f, -0.04519324f, -0.07136748f, 0.01463497f, -0.00745139f, -0.02367136f, -0.02137407f, 
    -0.01183034f, -0.05129936f, -0.07057449f, -0.03724822f, 0.01358321f, 0.04333602f, 0.04533037f, 0.01159212f, 
    -0.02072916f, 0.01093273f, 0.01674781f, -0.04692971f, 0.02928204f, -0.01331076f, 0.03417923f, -0.02448436f, 
    -0.05262920f, 0.01510047f, -0.00615117f, -0.01347824f, 0.00630004f, -0.06398354f, 0.04150357f, 0.01033257f, 
    -0.05349778f, -0.02078210f, -0.07275363f, 0.06709288f, 0.04351166f, 0.05487806f, -0.07876334f, -0.04060707f, 
    -0.04148759f, 0.04148458f, 0.00706648f, -0.01568138f, -0.06372683f, 0.04308022f, -0.02954281f, -0.08291209f, 
    -0.05350740f, -0.07011884f, 0.03722072f, 0.00758609f, -0.00741413f, -0.06843444f, -0.00670969f, -0.06583848f, 
    -0.05760081f, -0.03045739f, 0.03216987f, 0.04870462f, -0.00918320f, -0.05077564f, -0.03305198f, 0.04917286f, 
    -0.02268716f, -0.04755324f, 0.05370351f, -0.06830512f, 0.05452576f, -0.05015378f, 0.05361973f, -0.06579817f, 
    -0.04664627f, -0.00309640f, 0.01061419f, 0.00407169f, 0.00409810f, -0.03319277f, 0.06052791f, -0.02273748f, 
    -0.00255988f, 0.05628389f, -0.06101847f, 0.01716802f, 0.05509706f, -0.02070331f, -0.06864280f, -0.00031633f, 
    -0.05131706f, -0.06139711f, 0.05045128f, -0.03819450f, 0.03864741f, 0.05077560f, -0.06910609f, -0.06382583f, 
    0.03194739f, 0.05783829f, 0.05573343f, 0.05706506f, -0.01076537f, -0.07937048f, -0.02361513f, 0.04361077f, 
    -0.03035293f, -0.06437405f, 0.07667712f, -0.04784237f, 0.04171140f, 0.03001224f, -0.01285987f, -0.06802724f, 
    -0.08542016f, 0.04903764f, 0.02987420f, 0.00667126f, -0.05366264f, 0.05775597f, -0.07152198f, 0.04380978f, 
    0.07940399f, 0.01294337f, -0.07122241f, 0.02819524f, -0.03805794f, -0.04937946f, -0.02569763f, 0.06508016f, 
    -0.25520286f, -0.13484463f, 0.12409512f, -0.02097703f, 0.11144353f, -0.04642704f, 0.03590383f, -0.04562334f, 
    0.02755344f, -0.00833152f, -0.18449588f, -0.07803881f, -0.12335003f, 0.20491052f, 0.24807762f, -0.00513963f, 
    0.02814568f, 0.11741879f, 0.01112935f, -0.01832793f, -0.22028203f, -0.05396354f, -0.01348127f, 0.10611904f, 
    -0.23708740f, 0.09261579f, 0.14585888f, -0.08118337f, -0.00886265f, -0.00986551f, -0.13092913f, -0.16925320f, 
    -0.05600484f, -0.04477774f, -0.07916065f, -0.09477284f, 0.48241287f, -0.05410070f, 0.10292627f, 0.15436821f, 
    0.05671847f, 0.11222313f, -0.02392677f, 0.14469627f, 0.05569592f, 0.25639796f, -0.02003753f, 0.24897425f, 
    0.12761527f, -0.04435353f, 0.11596805f, 0.13765849f, -0.04643032f, 0.05025028f, 0.12203220f, -0.00803644f, 
    -0.11163390f, 0.03215934f, 0.12994651f, 0.13665695f, 0.45937997f, 0.29418582f, 0.06510031f, -0.01012896f, 
    -0.12124028f, 0.04332564f, 0.01701208f, 0.22198428f, 0.06472724f, 0.02311587f, -0.00951300f, 0.18639532f, 
    0.13205059f, 0.40703353f, -0.05272346f, -0.03748423f, 0.04423238f, -0.04052782f, 0.02169788f, 0.06140806f, 
    -0.01419301f, -0.04636123f, -0.07786104f, -0.10172568f, -0.24599907f, 0.13312386f, -0.21993443f, 0.28365058f, 
    -0.03490003f, 0.10545345f, 0.04473676f, -0.03571056f, 0.11070630f, -0.03321922f, -0.11891492f, -0.25073910f, 
    -0.26489013f, 0.25182095f, -0.10554344f, 0.12630317f, 0.00268529f, -0.03637592f, 0.03282240f, -0.13109006f, 
    0.16136593f, -0.01675284f, -0.04398010f, 0.06254504f, 0.10359249f, -0.08148971f, 0.35107410f, -0.21747364f, 
    0.05723135f, 0.01613718f, -0.00656126f, -0.01807002f, -0.06721450f, -0.13963251f, 0.06569302f, 0.02096132f, 
    -0.13129517f, -0.01946611f, 0.00952419f, 0.07716861f, -0.04760509f, 0.04575988f, 0.08969870f, 0.16826755f, 
    0.00095512f, -0.09889522f, 0.06947537f, 0.05161797f, -0.18929598f, -0.00697088f, 0.07617725f, 0.03394084f, 
    0.09716935f, -0.03875818f, -0.06095644f, -0.09134038f, 0.05835509f, 0.00708244f, 0.09793583f, 0.14442268f, 
    -0.24787551f, 0.04821455f, 0.07827970f, 0.04207494f, -0.03954926f, 0.17983325f, -0.02983080f, -0.07448858f, 
    0.04634527f, 0.00861822f, -0.04540880f, 0.07966947f, -0.08751993f, -0.15959206f, 0.12069077f, 0.16901845f, 
    -0.06002922f, 0.06841312f, -0.05933488f, -0.19659013f, -0.00888250f, -0.07745802f, 0.06002520f, 0.01906472f, 
    -0.29998463f, 0.15594231f, 0.13841422f, 0.13502853f, -0.01729167f, 0.17707933f, -0.00715080f, 0.04985471f, 
    -0.02508736f, 0.04603895f, 0.14202406f, 0.26044583f, -0.13852502f, -0.12101158f, 0.08997699f, -0.03689415f, 
    0.03034719f, -0.04818457f, 0.07764801f, -0.03669169f, -0.09075420f, 0.09475452f, -0.09587886f, -0.03858728f, 
    -0.04441547f, 0.02982295f, -0.01144719f, -0.01617450f, -0.01065876f, 0.01064982f, -0.02424466f, -0.02719735f, 
    -0.01309368f, 0.06136388f, -0.01471441f, 0.02974512f, -0.00285185f, -0.02980085f, -0.06927529f, -0.06999347f, 
    0.03405372f, -0.02989684f, -0.03141130f, 0.02406557f, -0.04654841f, 0.00638642f, 0.03287823f, -0.07248700f, 
    -0.01895812f, -0.02584659f, 0.05684959f, -0.00232278f, -0.06166565f, -0.06302214f, 0.04923707f, 0.02447105f, 
    0.01772901f, -0.01733010f, -0.08189590f, -0.03195005f, -0.01228931f, 0.00369381f, -0.00732535f, 0.00959710f, 
    -0.04483224f, 0.00427021f, 0.00015729f, -0.02359859f, -0.05175552f, 0.04697206f, 0.02813689f, -0.03657074f, 
    0.03233348f, 0.05068643f, -0.02125455f, -0.00429801f, 0.03435751f, 0.01016087f, 0.05462161f, 0.04777858f, 
    -0.01131855f, 0.01121088f, -0.03976020f, -0.05585199f, 0.01150151f, -0.03963844f, 0.06386200f, -0.06291033f, 
    -0.08125820f, -0.01878890f, -0.01943780f, -0.05520979f, -0.07599054f, 0.05494824f, -0.04842086f, 0.00626074f, 
    -0.04960215f, -0.07068644f, -0.05129633f, -0.01732433f, 0.01118424f, 0.04903775f, 0.05772837f, -0.05048991f, 
    -0.04915088f, -0.00110185f, 0.05598254f, 0.00625880f, 0.00922868f, 0.03674838f, -0.02914780f, -0.03424617f, 
    -0.06364536f, -0.05139665f, 0.05584536f, -0.01327068f, -0.06073894f, 0.04802010f, 0.00254230f, -0.06262065f, 
    0.05514283f, -0.00477505f, -0.01605352f, 0.02925010f, -0.01141736f, -0.00382365f, -0.00842133f, -0.05458977f, 
    0.04475265f, -0.06216134f, -0.01064970f, 0.01767857f, -0.02690735f, 0.05332786f, 0.03715453f, 0.00866381f, 
    0.03731620f, 0.01449265f, -0.04847581f, -0.02803523f, -0.07383979f, 0.05804455f, 0.04978824f, 0.02306388f, 
    0.06324579f, -0.05000014f, 0.00778787f, -0.06183426f, -0.00590960f, -0.01221037f, 0.06598171f, -0.03456996f, 
    0.05177865f, 0.03388462f, -0.00109366f, 0.01299911f, -0.02883174f, -0.03273605f, 0.02263378f, 0.04009569f, 
    -0.01607355f, -0.02056230f, -0.03547642f, 0.03392366f, -0.05507763f, -0.06977724f, 0.06126811f, -0.01647110f, 
    0.00055709f, -0.06460390f, 0.06295377f, -0.04659192f, -0.04392808f, -0.06496277f, -0.05059237f, -0.03333949f, 
    0.02486674f, -0.05325848f, 0.03837010f, -0.01009493f, 0.03288718f, -0.05747350f, -0.04410845f, -0.04136021f, 
    0.03265380f, -0.01311836f, 0.01737402f, 0.05630584f, -0.06431119f, 0.06786509f, -0.04376693f, 0.04838155f, 
    0.06095167f, -0.03376763f, -0.06267742f, 0.06436215f, 0.05207406f, -0.03368242f, 0.03044620f, -0.04169144f, 
    0.00086342f, -0.04579914f, -0.04831886f, 0.02252317f, 0.00194760f, 0.03381087f, -0.06311931f, 0.04301628f, 
    0.04892582f, -0.06188850f, 0.01783528f, -0.04390802f, -0.06675097f, -0.02223147f, 0.02172104f, 0.00620131f, 
    -0.13424286f, -0.16619499f, -0.03295986f, -0.05283157f, 0.05830294f, -0.06901149f, -0.03258373f, -0.05634279f, 
    -0.07355478f, 0.01044330f, -0.04978548f, 0.27292904f, -0.45553562f, -0.02740055f, 0.03050251f, -0.13830751f, 
    -0.00146485f, 0.02806892f, -0.03807802f, 0.08666645f, 0.03328408f, 0.12573853f, 0.07065909f, -0.04293798f, 
    -0.11048631f, 0.20161338f, 0.17239338f, -0.14419077f, -0.01404854f, -0.00279461f, 0.05644681f, 0.04903769f, 
    -0.01983387f, -0.04268168f, -0.07315058f, 0.18163061f, -0.00489981f, 0.04870068f, 0.00934022f, -0.15034662f, 
    0.20250325f, 0.11991318f, -0.15087399f, -0.07509176f, -0.16602191f, -0.04891049f, -0.13962853f, 0.03033055f, 
    0.23271334f, -0.11958504f, -0.15957904f, 0.02197730f, 0.13466567f, 0.03824507f, 0.13310014f, 0.03875481f, 
    0.06316829f, 0.02496939f, 0.05484253f, -0.12531480f, -0.21563053f, -0.06333596f, 0.03929910f, 0.03932907f, 
    0.01608850f, -0.00090468f, -0.05972343f, -0.08982953f, 0.08035856f, 0.08939887f, -0.01970800f, 0.12947410f, 
    -0.14073916f, 0.18192026f, 0.22408652f, 0.02434628f, 0.34130335f, 0.03604370f, 0.12076526f, -0.01788631f, 
    0.02924779f, -0.08057616f, 0.03985335f, 0.11392736f, 0.04471263f, 0.28916451f, 0.09005881f, 0.15688027f, 
    -0.10846122f, -0.12518859f, 0.00636251f, -0.04631011f, -0.12742600f, -0.05490777f, -0.06375419f, -0.01507791f, 
    0.04297798f, 0.23048352f, 0.11700714f, 0.05601072f, 0.09160747f, -0.08209196f, 0.05522626f, -0.05856222f, 
    -0.07237668f, -0.02407085f, 0.04248090f, 0.08776890f, 0.11085876f, -0.07094586f, -0.09073254f, -0.14795268f, 
    -0.08551294f, -0.28318185f, 0.12694396f, 0.09004489f, -0.22501682f, 0.02448747f, 0.03423169f, -0.05102512f, 
    0.02252175f, 0.13128179f, 0.06497072f, 0.20819068f, -0.03277180f, 0.03104203f, 0.07222079f, 0.10909706f, 
    -0.07887019f, 0.15404244f, -0.08735757f, 0.02108989f, -0.27716354f, 0.23182070f, -0.28359085f, -0.15529455f, 
    0.05814251f, -0.12865405f, 0.18139440f, -0.18078063f, -0.07140109f, 0.04964184f, -0.07536964f, 0.13273902f, 
    0.29348955f, 0.12097767f, -0.05121676f, -0.07603973f, 0.26225698f, 0.13094920f, 0.05381439f, 0.01223515f, 
    0.09784801f, -0.02843095f, 0.01005357f, 0.01228658f, 0.09563743f, 0.27370811f, -0.05730886f, -0.13558021f, 
    -0.06834319f, -0.12052840f, 0.09720791f, -0.26221094f, 0.19516899f, 0.03096175f, 0.11155163f, -0.21937543f, 
    -0.06400973f, -0.12987246f, 0.12165556f, 0.41978562f, -0.24025869f, -0.16969566f, 0.06022479f, 0.19693631f, 
    -0.01302290f, -0.05973579f, 0.11554053f, 0.00203529f, 0.08437259f, -0.02359951f, 0.03866856f, -0.02622535f, 
    0.17643251f, 0.02067599f, 0.03940598f, -0.16583836f, 0.13361312f, -0.00291586f, 0.10191952f, -0.04211851f, 
    -0.44908088f, 0.16805327f, 0.41180724f, 0.08084404f, 0.02284629f, 0.07530282f, 0.06546161f, 0.09577036f, 
    0.06577831f, 0.02060882f, 0.14892645f, 0.10998403f, 0.00438188f, 0.05957944f, -0.15183508f, 0.10441887f, 
    0.07430589f, -0.14456539f, -0.04386479f, 0.07337502f, -0.00926107f, 0.11366077f, 0.16562350f, 0.02181816f, 
    -0.15354151f, 0.24969514f, -0.19258182f, 0.05407871f, 0.03334318f, 0.11984053f, 0.04045011f, 0.02837420f, 
    0.19809651f, -0.04112854f, 0.11197085f, 0.13157590f, -0.21013775f, -0.26338631f, -0.09696395f, -0.07363135f, 
    0.09074359f, 0.21276285f, -0.01717693f, -0.06311355f, -0.08947250f, -0.23160252f, -0.03868860f, 0.13218813f, 
    0.18572721f, -0.34303728f, -0.10018384f, -0.06426681f, -0.08712775f, 0.05526568f, 0.15156396f, -0.09247599f, 
    0.02464267f, -0.06330736f, -0.07306385f, 0.07990659f, 0.46764785f, 0.02382210f, 0.08864842f, -0.02098892f, 
    -0.01180195f, 0.09569949f, 0.08709233f, 0.06992216f, -0.10943656f, -0.02202574f, 0.01047972f, 0.02629235f, 
    -0.01852943f, 0.06998434f, 0.06488921f, -0.14660220f, 0.01164793f, 0.03461965f, -0.06974397f, 0.08079608f, 
    0.17325670f, 0.06360430f, 0.18452154f, 0.17071487f, 0.09746915f, -0.06926641f, -0.20700951f, 0.19403574f, 
    -0.09193600f, 0.05223876f, 0.10717113f, 0.13484454f, 0.02402189f, 0.06202504f, -0.01919864f, 0.16701506f, 
    -0.06086122f, -0.13896400f, 0.00633198f, 0.00539292f, 0.05678876f, 0.09744662f, 0.16253166f, 0.21592221f, 
    0.12167040f, 0.03100149f, 0.08806363f, 0.08676688f, -0.22112356f, 0.24550378f, -0.01011470f, 0.00946046f, 
    0.01662348f, -0.10571130f, 0.05118307f, 0.04435763f, -0.18527175f, 0.01265084f, 0.12071109f, 0.15393797f, 
    0.06151113f, -0.14328462f, 0.11719096f, -0.04460074f, 0.05682791f, 0.11937264f, 0.10352784f, 0.21460137f, 
    0.05943511f, -0.02378592f, 0.00185314f, 0.11858220f, -0.43927446f, 0.17670232f, -0.01560569f, -0.01522404f, 
    0.09497830f, 0.16678888f, -0.03670229f, 0.13923162f, -0.02445227f, 0.01554744f, -0.04706440f, -0.09371021f, 
    -0.48963088f, -0.42922565f, 0.07730310f, 0.15746434f, 0.01009924f, 0.04473580f, -0.01654150f, 0.01028702f, 
    0.14734696f, 0.09244782f, -0.02342832f, 0.04683796f, 0.04517011f, -0.18687046f, 0.34894234f, 0.27329376f, 
    -0.06436660f, 0.08105978f, 0.00598431f, -0.06085736f, 0.04382914f, 0.06092243f, 0.11622097f, -0.01695882f, 
    -0.14031483f, -0.08985548f, -0.18308407f, -0.04818415f, -0.10836610f, 0.01819008f, 0.04572675f, -0.12140723f, 
    0.10688002f, -0.06942981f, -0.01722962f, -0.00806503f, -0.44442278f, 0.07714101f, 0.29022333f, 0.10833506f, 
    0.05968953f, 0.06096262f, -0.00326370f, 0.06387748f, 0.13878061f, 0.06067129f, -0.07269052f, -0.03554872f, 
    0.06825613f, -0.03727956f, 0.04138536f, 0.00378226f, -0.02333983f, -0.01413355f, -0.04687478f, -0.05379881f, 
    0.04130851f, 0.02772214f, -0.07035574f, 0.07138599f, -0.05936232f, -0.01165979f, -0.01686628f, 0.00792573f, 
    0.06050730f, -0.02771348f, -0.02314280f, 0.05950107f, -0.00884596f, 0.05060807f, -0.00881846f, 0.02446358f, 
    0.05707685f, -0.07073455f, 0.03577027f, 0.01798019f, 0.04049951f, 0.05649417f, 0.06191613f, 0.02302589f, 
    0.02007544f, -0.06390586f, -0.01561599f, -0.05634277f, -0.00830666f, -0.02295155f, -0.01100502f, 0.01463733f, 
    0.02556118f, -0.03769552f, -0.06235153f, 0.00368394f, -0.07597419f, 0.04201342f, 0.04885698f, -0.07634708f, 
    0.05152400f, 0.03120627f, 0.06996519f, -0.04118656f, -0.06537816f, -0.08027175f, -0.00468450f, -0.06698811f, 
    -0.07511007f, -0.02852290f, -0.01494655f, 0.06358062f, 0.04313076f, 0.06341111f, 0.06082566f, 0.05036232f, 
    0.01645999f, 0.06437940f, -0.07084242f, -0.00429753f, 0.02534783f, -0.07945643f, -0.02530486f, -0.02837586f, 
    0.00374116f, -0.06101263f, 0.00898900f, -0.05318934f, -0.06323558f, -0.05726993f, 0.02130274f, -0.04354171f, 
    0.00603403f, -0.05784316f, -0.00731195f, -0.06361508f, 0.05273757f, -0.01385614f, -0.06722051f, -0.06605253f, 
    0.00658924f, -0.07495723f, -0.04278764f, 0.01182439f, 0.02138259f, -0.03905542f, -0.05143321f, -0.03778239f, 
    -0.05396564f, -0.08102687f, -0.00021772f, 0.03152696f, -0.01369249f, 0.01537010f, -0.05952624f, -0.03889824f, 
    -0.07848404f, 0.01603892f, -0.03762085f, -0.04892512f, 0.05653266f, -0.00795340f, -0.00866335f, 0.00424549f, 
    -0.07013720f, 0.02983554f, 0.04642517f, -0.01520003f, 0.01793404f, -0.04657406f, -0.04031722f, -0.02732319f, 
    0.03465257f, -0.04824187f, -0.02304004f, -0.06793755f, 0.05278805f, 0.05353698f, -0.05064161f, 0.00950250f, 
    0.04920777f, 0.01190829f, -0.00372890f, -0.06022162f, 0.02788487f, -0.06036809f, -0.02600802f, 0.03948642f, 
    -0.02022206f, 0.04162641f, -0.04567621f, 0.01155933f, 0.05471163f, -0.07237821f, -0.02023989f, -0.02577160f, 
    -0.04071177f, -0.01136916f, -0.06762742f, -0.02481402f, 0.00731318f, 0.02406690f, 0.02660062f, 0.01831019f, 
    0.02082812f, -0.03126942f, -0.00323475f, -0.04922484f, 0.02467202f, 0.05451618f, -0.01561988f, -0.01096683f, 
    -0.01143491f, 0.01409816f, -0.04283704f, -0.01253112f, 0.06130521f, -0.01854684f, -0.04144061f, -0.00196339f, 
    -0.04956889f, -0.05364990f, 0.02937475f, -0.07088386f, -0.04649723f, -0.02606158f, -0.03772801f, -0.05362989f, 
    -0.05158820f, -0.03925194f, 0.01228799f, -0.06356340f, 0.04037881f, 0.04628477f, 0.05811504f, -0.05183048f, 
    0.01276814f, 0.03667334f, -0.06941836f, 0.02087406f, -0.04619077f, -0.01982602f, -0.03282013f, -0.02909156f, 
    0.02639811f, -0.08084422f, -0.05880401f, 0.02436186f, -0.07908178f, 0.01423848f, 0.01283378f, 0.00673958f, 
    -0.01837701f, -0.08257020f, 0.01014290f, -0.03911438f, 0.01333820f, -0.05640844f, -0.01111852f, -0.01753500f, 
    0.04398559f, 0.00023617f, -0.06930354f, 0.05593709f, 0.05951034f, -0.05110767f, -0.07949951f, 0.00735172f, 
    0.05002471f, 0.02489165f, -0.02860735f, -0.04065646f, -0.03364289f, -0.07226901f, 0.04314004f, -0.05211572f, 
    -0.05006656f, 0.03698858f, 0.02194672f, -0.04047443f, 0.01943103f, -0.03326302f, 0.03803286f, -0.03041046f, 
    0.04821902f, -0.00942410f, -0.02650110f, -0.06177974f, 0.04510472f, -0.02514798f, -0.03685692f, -0.02562600f, 
    0.00811538f, 0.02665698f, 0.02015195f, -0.04294759f, 0.05650628f, 0.03055750f, -0.06802446f, -0.05652785f, 
    -0.01620284f, -0.06143951f, -0.07735988f, -0.02816772f, -0.05852900f, 0.00345794f, -0.05766541f, 0.03552326f, 
    -0.03422445f, 0.00073524f, -0.03655508f, -0.07146196f, 0.00504510f, -0.00735319f, -0.04837942f, 0.04046652f, 
    0.05070317f, -0.02655919f, 0.01544423f, 0.00693517f, -0.03005270f, -0.03389972f, -0.05940891f, 0.04448936f, 
    -0.05954687f, -0.02670778f, -0.00447306f, 0.02379695f, 0.01356487f, 0.03714519f, 0.04687788f, -0.02589837f, 
    -0.05833468f, 0.01760696f, -0.05674258f, 0.00572075f, -0.00532424f, -0.03429854f, -0.02893572f, 0.01936547f, 
    -0.06866328f, -0.05656055f, 0.01157098f, 0.04600787f, -0.05341123f, -0.05219531f, -0.03358679f, -0.02672935f, 
    0.03890548f, -0.04641709f, -0.00421778f, -0.04579606f, 0.00989521f, -0.07372033f, 0.05786855f, -0.02427603f, 
    0.01873710f, 0.04815620f, -0.07703421f, -0.00163873f, 0.05069152f, -0.04578194f, -0.03024931f, 0.02320584f, 
    -0.02952860f, -0.07693770f, -0.01088414f, 0.02081885f, 0.00124486f, -0.00091253f, 0.03717299f, 0.03655143f, 
    0.02118692f, 0.06644970f, -0.06427474f, -0.02351003f, 0.05489483f, -0.04221520f, 0.06119589f, -0.01712203f, 
    0.05061710f, 0.06465580f, -0.05204855f, -0.05281196f, 0.04337307f, -0.00934931f, -0.03717470f, 0.01724114f, 
    -0.05638122f, 0.03788103f, -0.00581250f, -0.04037799f, -0.01933701f, 0.02152676f, 0.04378171f, 0.01284725f, 
    -0.05677737f, 0.01527916f, 0.01391033f, -0.03104536f, -0.07244798f, 0.02185074f, -0.07029599f, 0.01705460f, 
    -0.01232245f, -0.05056965f, 0.04915516f, -0.00251438f, 0.05637770f, 0.06508809f, 0.05112043f, -0.04189148f, 
    -0.03162206f, -0.04173380f, 0.01483884f, 0.04198045f, -0.02684566f, -0.00162601f, 0.03143600f, -0.09714031f, 
    -0.05128446f, -0.00520111f, 0.04731814f, -0.06651094f, 0.06384274f, 0.00777471f, 0.05572733f, 0.00159548f, 
    0.03291294f, -0.06836856f, -0.04396197f, 0.03765097f, -0.00635036f, -0.07015887f, 0.04567746f, -0.03765834f, 
    0.29694432f, -0.14239015f, -0.03340716f, 0.02940580f, 0.10231902f, 0.03299167f, 0.05681064f, -0.08085360f, 
    -0.18817405f, 0.00603722f, 0.04951321f, 0.10300609f, -0.23383443f, -0.11330446f, 0.09695296f, -0.10306773f, 
    0.09673560f, 0.04562153f, 0.00575991f, 0.09275840f, 0.01322989f, 0.21167664f, 0.00279448f, 0.00332668f, 
    -0.01627959f, 0.17067003f, 0.31916419f, -0.23010834f, -0.07764313f, -0.04202311f, 0.10018582f, 0.20142433f, 
    -0.00707961f, 0.03311980f, -0.08624271f, -0.06963418f, -0.12670961f, 0.01959596f, -0.11426510f, 0.05097331f, 
    0.11352286f, 0.12434088f, -0.20438015f, -0.12685649f, -0.05046641f, 0.05042307f, -0.05565330f, 0.08191581f, 
    -0.18220235f, 0.20791890f, -0.03269966f, -0.30113769f, 0.14274000f, 0.03220213f, -0.05978069f, 0.01051451f, 
    -0.07856550f, -0.08304717f, 0.16434671f, -0.06524442f, -0.02185115f, -0.29154879f, 0.32573336f, 0.32795814f, 
    -0.02650842f, 0.02467609f, 0.03707033f, -0.08985255f, -0.00704719f, 0.06233706f, -0.01417571f, 0.09881011f, 
    -0.33606008f, -0.01371409f, 0.26089793f, -0.17234686f, 0.23255865f, -0.00101164f, 0.09838850f, -0.09167371f, 
    0.00588419f, 0.03997415f, -0.07811590f, 0.07205966f, -0.17202869f, 0.20435761f, -0.00791228f, 0.06785452f, 
    0.17370923f, -0.16962163f, -0.10837908f, -0.05170939f, -0.00047334f, -0.04842570f, -0.11241680f, 0.00954307f, 
    0.00538747f, 0.10149068f, 0.06823441f, 0.04214079f, 0.02580448f, -0.04782737f, -0.01933520f, 0.02210309f, 
    0.00144154f, 0.08344837f, 0.03650326f, 0.07143500f, 0.36790973f, 0.03284525f, 0.00679787f, -0.02675061f, 
    0.02459898f, -0.11568520f, 0.19357488f, 0.10080384f, -0.01817062f, -0.01043564f, 0.03486238f, -0.12399601f, 
    -0.17414692f, 0.00374546f, -0.09615903f, 0.07754505f, 0.17483179f, -0.13271880f, -0.10245501f, 0.02508671f, 
    -0.08277346f, 0.18374102f, -0.11359847f, -0.11011424f, -0.09738146f, 0.14201960f, -0.05201449f, -0.10287227f, 
    0.07463819f, -0.04065612f, 0.09781288f, -0.05479984f, 0.05170773f, 0.05085111f, -0.01413448f, -0.05677412f, 
    0.31965464f, 0.25042376f, -0.16959551f, -0.21955225f, 0.06097052f, -0.03405528f, 0.02306491f, 0.07123723f, 
    0.03943188f, 0.00917331f, 0.14230077f, 0.04334390f, -0.00948167f, 0.41563961f, -0.15442382f, -0.00683795f, 
    0.03658301f, -0.03202619f, 0.19498922f, -0.07740876f, 0.06247777f, -0.04972449f, 0.07001911f, 0.00270758f, 
    -0.00060673f, 0.03685727f, 0.01490031f, 0.16595531f, -0.05002698f, -0.08809195f, 0.05183209f, 0.12263288f, 
    -0.02626575f, -0.00919830f, -0.07895239f, -0.07265233f, 0.38981327f, -0.17590448f, -0.07351654f, 0.38750088f, 
    0.18497096f, -0.05610325f, -0.06607945f, 0.00718636f, -0.06824862f, 0.16410992f, 0.11441477f, -0.09612808f, 
    0.04797100f, 0.06070214f, -0.01788070f, 0.05864199f, -0.06178631f, 0.01389732f, -0.02101881f, -0.04630152f, 
    -0.02686097f, -0.00581557f, 0.03828708f, -0.06621958f, -0.04098906f, 0.00238671f, 0.03874750f, -0.02253388f, 
    -0.00642265f, -0.05789097f, 0.05811607f, 0.01638891f, 0.01346514f, -0.03927376f, 0.01694484f, -0.00469443f, 
    0.03870215f, -0.01256976f, -0.02852544f, -0.00315543f, -0.01910229f, 0.04761366f, 0.05862248f, -0.00572803f, 
    -0.01781270f, -0.05609303f, -0.02871907f, -0.02763227f, -0.00576890f, 0.05771057f, 0.00292889f, 0.03830614f, 
    -0.02889948f, -0.01185442f, 0.02542328f, 0.04252822f, -0.04083349f, 0.06183525f, -0.07571552f, 0.02648656f, 
    -0.03377553f, 0.03213184f, 0.01901711f, 0.05176291f, -0.03107253f, -0.02264796f, 0.03218717f, -0.05187652f, 
    -0.05481079f, 0.02637166f, 0.03138613f, 0.04448182f, -0.01856995f, -0.04974546f, 0.01007151f, 0.01146977f, 
    -0.05971433f, 0.06270966f, 0.05777757f, -0.01928301f, -0.05841846f, -0.00352792f, -0.04753108f, -0.06911174f, 
    -0.07110403f, 0.05126514f, -0.02541391f, -0.01855275f, -0.01364452f, -0.01719440f, 0.01336189f, 0.02549560f, 
    -0.05632921f, -0.04140329f, -0.03549591f, -0.01548026f, -0.03844368f, 0.06067763f, -0.00742535f, -0.01257117f, 
    0.06093379f, -0.03011563f, -0.05641568f, -0.01439699f, 0.05150552f, -0.03156920f, -0.00151766f, 0.04664303f, 
    -0.03017808f, -0.06637686f, 0.05877287f, -0.03373670f, 0.00174564f, -0.04251587f, -0.01422707f, 0.01746685f, 
    -0.06398631f, -0.00225723f, 0.01696676f, -0.06770983f, 0.03787604f, 0.01911914f, 0.06441779f, -0.07685047f, 
    -0.00164470f, 0.03328759f, -0.04335779f, -0.06646496f, 0.05137319f, -0.01301224f, 0.01757579f, -0.03372435f, 
    -0.04880871f, -0.04040946f, 0.03924805f, 0.03391090f, -0.06969724f, -0.05887583f, -0.01439712f, -0.05863863f, 
    -0.05167579f, -0.00621251f, 0.01694765f, -0.07191544f, -0.05858069f, -0.05032782f, -0.02158194f, -0.02808052f, 
    -0.05146181f, 0.03843450f, -0.05480413f, 0.05125377f, 0.05461364f, 0.00827042f, 0.02255972f, -0.02084126f, 
    -0.03013776f, -0.07032885f, -0.03875032f, -0.02827266f, 0.02435411f, -0.01176947f, -0.01317131f, 0.05580878f, 
    -0.05395804f, -0.03840509f, -0.07135275f, 0.04311503f, -0.02101619f, 0.05844997f, 0.04902251f, -0.03417514f, 
    -0.03399795f, 0.03863784f, 0.00109309f, -0.07548042f, -0.04714721f, -0.01067253f, -0.00153588f, -0.07476120f, 
    0.05301720f, -0.00082214f, -0.06483911f, 0.05088066f, -0.01545338f, -0.03765323f, -0.02799611f, -0.04762828f, 
    -0.02487131f, 0.02084082f, -0.06922220f, 0.02954840f, -0.03094706f, 0.05247294f, -0.01414908f, 0.00403861f, 
    0.00756495f, -0.04315864f, -0.01041644f, -0.06914127f, -0.03444280f, -0.00284571f, 0.03301020f, -0.06645389f, 
    -0.00927541f, 0.00107711f, 0.05877908f, 0.00591061f, -0.00013567f, -0.05855471f, -0.06829908f, 0.05600501f, 
    0.04238126f, -0.02750957f, -0.00317782f, -0.08254524f, -0.06303444f, 0.04226926f, -0.04097160f, -0.05977612f, 
    0.03757207f, -0.02024433f, 0.01914305f, -0.00027995f, 0.04101301f, 0.05430603f, 0.05267636f, -0.05996208f, 
    -0.07378633f, -0.05843470f, -0.05596634f, -0.00660390f, -0.00874809f, 0.02033150f, 0.05680184f, -0.05317748f, 
    -0.03366699f, 0.04568896f, -0.05992022f, -0.02599050f, -0.00617218f, 0.04524048f, 0.04276086f, -0.01757961f, 
    -0.00934588f, -0.01561283f, -0.08010379f, 0.01098892f, -0.05086985f, 0.02850010f, 0.00580155f, 0.00585129f, 
    -0.06686328f, 0.00214833f, -0.05501124f, -0.05460693f, 0.04299844f, 0.05267510f, -0.00635868f, 0.02096134f, 
    -0.04098478f, -0.01818633f, -0.00079018f, -0.06481009f, 0.00013019f, 0.01689897f, -0.03792869f, 0.04421867f, 
    -0.05964636f, 0.04805284f, 0.04443922f, -0.03139778f, 0.04457659f, -0.01304111f, -0.06831616f, -0.00460874f, 
    -0.00235109f, -0.07116202f, -0.02539071f, -0.00056419f, -0.07938755f, 0.03132951f, -0.06273660f, 0.03678034f, 
    -0.02508334f, 0.03776476f, 0.05412934f, 0.00259074f, 0.00913379f, 0.02099504f, 0.03828715f, -0.06003791f, 
    0.00100423f, 0.00655354f, -0.01880415f, -0.08335978f, 0.03314417f, -0.04072717f, 0.03826814f, -0.07830301f, 
    -0.04231634f, -0.02276926f, -0.01781877f, 0.05196776f, 0.02511305f, 0.00841402f, 0.01566698f, -0.01564649f, 
    -0.07616863f, -0.07870387f, 0.00322397f, 0.04479688f, 0.05909951f, 0.01225298f, 0.06147419f, -0.07244949f, 
    -0.04395445f, 0.05196827f, 0.05405907f, 0.01526429f, -0.05684805f, -0.00540936f, -0.02975718f, 0.05498777f, 
    -0.05008524f, 0.00199912f, -0.01830824f, -0.01690788f, -0.02984382f, -0.05541469f, 0.01151885f, -0.02777582f, 
    0.06036149f, 0.00869851f, -0.05145187f, 0.05314886f, 0.03725241f, 0.02752540f, -0.07385385f, 0.03323952f, 
    0.01623253f, 0.00006670f, -0.01918516f, 0.04409764f, -0.01477515f, -0.05310654f, 0.00862298f, -0.02886426f, 
    -0.07293734f, -0.00481872f, -0.08088613f, -0.08226993f, -0.01736093f, -0.07441182f, -0.03147674f, -0.01709819f, 
    0.00706610f, 0.04692823f, -0.00375728f, 0.01129499f, 0.00225056f, -0.00805588f, -0.03312710f, 0.01211641f, 
    0.00074141f, -0.03732080f, 0.05147928f, -0.01629241f, -0.03537942f, -0.07539576f, -0.04364503f, 0.06230017f, 
    -0.04973959f, -0.04723111f, -0.02050328f, 0.03959960f, 0.05721389f, 0.02105970f, -0.06621417f, 0.03260583f, 
    -0.02002812f, 0.03070388f, -0.03346072f, 0.00541339f, -0.03838662f, 0.05387513f, 0.02802730f, -0.07332858f, 
    0.04275287f, 0.05132482f, -0.04422740f, -0.05981682f, -0.05401157f, 0.00921558f, -0.05624380f, 0.02192754f, 
    -0.05080374f, 0.04784580f, -0.06839925f, -0.04817572f, -0.02006872f, -0.04352039f, -0.08058690f, -0.00764077f, 
    -0.05848948f, -0.00270536f, 0.05819527f, -0.04790686f, 0.01140954f, 0.00837663f, -0.05449269f, 0.00046804f, 
    0.02222575f, 0.00625350f, -0.03172898f, 0.04015629f, 0.04307241f, 0.00551208f, -0.01335492f, -0.03970977f, 
    0.01573844f, -0.00068201f, 0.03728972f, 0.01952437f, -0.04380134f, 0.00104829f, -0.07488884f, 0.05773075f, 
    -0.02257498f, -0.00545057f, 0.00758665f, -0.03457581f, 0.01764041f, 0.01701788f, 0.00096221f, 0.04819705f, 
    0.01154186f, -0.04565112f, -0.02496764f, 0.00403812f, -0.07378318f, 0.01533948f, -0.00548958f, 0.05911863f, 
    0.00776884f, 0.02842649f, 0.01173102f, -0.01117119f, -0.05777261f, -0.01658175f, -0.04080243f, 0.04463993f, 
    -0.03469764f, -0.06582944f, -0.02980918f, 0.02206773f, -0.01930257f, -0.05854519f, 0.00626273f, -0.01128484f, 
    -0.04070293f, -0.02723089f, -0.06366424f, -0.02822131f, 0.00027681f, 0.05050628f, 0.02009376f, 0.06410023f, 
    0.06249810f, -0.01606025f, 0.02264770f, 0.01213859f, -0.03916906f, 0.03327657f, -0.01576909f, -0.02366819f, 
    -0.05361231f, 0.05536683f, 0.03349127f, -0.06713440f, -0.03586611f, 0.00501133f, 0.04098373f, 0.05724059f, 
    0.01609692f, 0.00305672f, -0.04621905f, -0.05217685f, -0.02793609f, 0.05027970f, 0.05391873f, -0.02114822f, 
    -0.07152589f, -0.03500720f, 0.04083086f, -0.08350547f, -0.01347050f, 0.03822096f, 0.07052417f, -0.05901638f, 
    -0.00625282f, -0.07824942f, -0.00346186f, 0.00039219f, -0.00236540f, -0.07731574f, -0.05185100f, 0.06565350f, 
    -0.07013093f, 0.01198602f, -0.03508247f, 0.03882563f, -0.03848030f, -0.06232576f, 0.03618593f, 0.05815891f, 
    0.02511116f, -0.00152155f, 0.00491262f, 0.00842608f, -0.06907761f, 0.04961216f, -0.02068296f, 0.05801209f, 
    -0.05433116f, -0.07073443f, -0.07083199f, -0.05876094f, 0.04335876f, -0.00084611f, -0.02347229f, 0.04052514f, 
    0.02185371f, -0.01750677f, 0.04614412f, 0.01496924f, 0.05471361f, -0.01639781f, -0.08631670f, -0.00170971f, 
    -0.03151285f, 0.04293116f, 0.01840051f, -0.03960595f, -0.01212760f, 0.02669052f, 0.01621445f, -0.04709626f, 
    -0.03929084f, -0.03824134f, 0.00413627f, -0.02225947f, 0.02545338f, -0.03501153f, -0.03513844f, -0.02226896f, 
    -0.06765194f, 0.01680385f, 0.00347639f, 0.05032116f, -0.03365912f, -0.04290575f, -0.00399172f, -0.02730195f, 
    -0.06192522f, 0.00123403f, -0.06103868f, -0.02224440f, 0.02683046f, -0.02398565f, -0.06218110f, -0.01480873f, 
    -0.05008448f, -0.03005318f, -0.04845970f, -0.05949388f, -0.01347174f, -0.07017387f, -0.04584593f, 0.04654279f, 
    -0.03518220f, 0.04756903f, -0.03383526f, 0.05640796f, -0.02112274f, 0.01188943f, -0.03196006f, -0.03525662f, 
    0.31201491f, 0.03388808f, -0.01348941f, 0.20938402f, -0.01004263f, 0.08672081f, 0.02781530f, -0.07558387f, 
    0.12351764f, 0.11145438f, 0.04497970f, -0.03888778f, -0.34790874f, -0.32248536f, -0.06387427f, 0.02193747f, 
    0.13053539f, -0.17428207f, 0.05182241f, 0.20253757f, 0.16903059f, 0.05753856f, -0.03086993f, -0.06545526f, 
    -0.01743608f, -0.19547278f, -0.04369561f, -0.03025024f, 0.02028858f, 0.09611311f, -0.16021952f, -0.12851895f, 
    0.12571181f, 0.10868279f, 0.02793723f, 0.01528421f, -0.13274872f, 0.06573185f, 0.07399511f, -0.14662416f, 
    -0.03569990f, 0.02919407f, 0.03110920f, -0.21175517f, 0.02839245f, -0.19170423f, 0.07699288f, 0.11118601f, 
    0.39930865f, 0.13304877f, 0.24044199f, 0.11925323f, 0.01851270f, 0.00195084f, -0.07294205f, -0.05817417f, 
    -0.06044154f, 0.06003086f, -0.01228507f, -0.07269453f, -0.03910930f, -0.14663571f, 0.23132528f, -0.16933268f, 
    0.20155442f, -0.01499156f, 0.09313196f, -0.00857699f, 0.06222064f, -0.06212645f, -0.12921807f, -0.11400878f, 
    0.46911639f, 0.02748914f, 0.07452645f, 0.58909917f, -0.07653568f, -0.00644791f, -0.03242330f, -0.03068163f, 
    -0.00577677f, -0.01093329f, 0.07861466f, 0.15348051f, 0.03070023f, 0.16560243f, -0.03671740f, -0.49311498f, 
    -0.13073179f, -0.11359268f, 0.14523797f, 0.15972486f, -0.04701643f, -0.08337197f, 0.12298705f, 0.13735551f, 
    0.13983826f, -0.01387084f, 0.06776141f, -0.52455461f, 0.00619603f, 0.02903699f, -0.00397597f, 0.04895553f, 
    -0.07090586f, -0.01851846f, 0.14917338f, 0.15720715f, -0.05371420f, -0.23022924f, -0.24490441f, 0.02767612f, 
    -0.05852592f, 0.11784085f, 0.03363971f, -0.10588939f, 0.22378451f, 0.08489233f, 0.04707167f, -0.04742995f, 
    -0.19359417f, -0.16995701f, -0.13568191f, 0.09904928f, 0.03809721f, -0.04402474f, -0.07335699f, 0.12824269f, 
    0.15603516f, -0.10048167f, -0.02905088f, 0.00177417f, -0.07826071f, -0.11872962f, -0.01986720f, -0.10841472f, 
    -0.10101696f, 0.11308806f, -0.06446765f, -0.12672539f, 0.14950570f, 0.03890870f, -0.03110844f, 0.00504756f, 
    0.26016304f, -0.01187809f, 0.04501177f, 0.28372610f, -0.00062769f, -0.16817793f, 0.08331808f, 0.08265477f, 
    -0.16605501f, -0.03359894f, -0.06117614f, -0.01303968f, -0.18987210f, -0.08810636f, -0.05595271f, -0.31342855f, 
    0.08774623f, -0.00928504f, 0.05022366f, 0.26127577f, 0.12471098f, -0.07220446f, -0.08566507f, 0.07195265f, 
    0.23827015f, 0.24003406f, -0.05229709f, -0.28567666f, 0.09299077f, 0.06706252f, -0.00059729f, -0.00846070f, 
    0.12914614f, 0.11052267f, -0.01652912f, 0.14876477f, -0.05591562f, 0.30761692f, -0.02143438f, -0.23428336f, 
    0.08910280f, 0.06999607f, 0.11153314f, -0.01796871f, -0.01630010f, -0.11077888f, -0.06212758f, -0.05228292f, 
    0.15993923f, 0.20219591f, -0.32510167f, -0.14349335f, -0.01542238f, -0.02449457f, -0.10029040f, 0.11368497f, 
    -0.00315802f, -0.04823282f, 0.13614734f, 0.04425325f, 0.08070634f, -0.34027103f, -0.03846927f, 0.23138915f, 
    0.06834246f, -0.06310549f, -0.09533984f, -0.04422176f, 0.11450255f, 0.06373122f, -0.17849705f, -0.03683863f, 
    0.17911169f, -0.08860335f, -0.02602673f, 0.10204794f, -0.02198536f, -0.19346927f, 0.02459451f, 0.06442209f, 
    -0.04069226f, -0.02585919f, 0.09629691f, 0.07175053f, -0.31472301f, -0.04193978f, 0.21437789f, -0.01593608f, 
    -0.03235311f, -0.09897113f, 0.00248625f, 0.12405322f, 0.10065055f, -0.08182899f, 0.06965329f, -0.04108458f, 
    -0.10489427f, 0.16376716f, -0.07349190f, 0.14688917f, 0.18775368f, -0.02535948f, -0.05813193f, 0.05706792f, 
    0.13328344f, 0.09870344f, -0.04093190f, 0.01424652f, -0.46914974f, -0.23150337f, -0.19062902f, -0.15443459f, 
    0.17856170f, -0.09403803f, -0.12320890f, -0.19678009f, 0.04053484f, 0.08459159f, 0.03945217f, 0.01507013f, 
    -0.08061045f, 0.04793201f, -0.26608014f, 0.01905766f, 0.19062611f, 0.00536475f, -0.06617486f, -0.13528170f, 
    0.04050342f, 0.04766244f, 0.08040021f, 0.14098765f, 0.35412204f, -0.08210693f, 0.41222295f, -0.34087077f, 
    0.03116889f, -0.04324663f, -0.01993480f, 0.05530469f, -0.13170572f, 0.01997996f, 0.03150728f, 0.07849410f, 
    0.32853580f, 0.12714978f, 0.19203915f, 0.02773108f, 0.13196765f, 0.06738248f, -0.10661491f, 0.03897624f, 
    -0.09030714f, 0.03400762f, 0.06389661f, -0.17306076f, -0.20015924f, 0.06143171f, -0.25401643f, 0.16926375f, 
    -0.15520477f, 0.02687542f, -0.06377800f, 0.09270643f, -0.01466837f, 0.02055322f, -0.05309721f, 0.06174209f, 
    0.19733399f, 0.02894122f, -0.13364229f, 0.06420169f, -0.15047023f, 0.02059520f, 0.04651294f, -0.08150808f, 
    -0.03738036f, 0.13889389f, 0.12759478f, -0.03431319f, 0.21790309f, -0.24353918f, -0.17856470f, 0.14639497f, 
    0.03893267f, -0.03255501f, 0.05847502f, -0.13525704f, 0.01259147f, 0.02402820f, 0.07643969f, -0.00495017f, 
    0.53732669f, 0.15690023f, -0.08701065f, 0.05662547f, 0.15457903f, -0.00367889f, -0.01227360f, 0.07338062f, 
    -0.13270983f, -0.06452834f, 0.01673877f, -0.01455482f, 0.16161259f, 0.08379416f, -0.03665008f, -0.12605257f, 
    0.05333573f, 0.04953387f, 0.07206615f, 0.21375684f, 0.06465883f, 0.07341484f, -0.12740402f, 0.08211152f, 
    0.21548024f, -0.18202724f, 0.02041385f, -0.09612393f, 0.20800427f, -0.14255373f, -0.07721169f, 0.07341275f, 
    0.04129075f, -0.08040523f, -0.01603854f, -0.16284700f, 0.44923717f, -0.01542651f, 0.06289467f, -0.11637380f, 
    -0.07964914f, 0.09029566f, -0.09239528f, -0.02260693f, 0.02273964f, 0.00201560f, 0.26220134f, 0.13402823f, 
    0.46452922f, 0.22224589f, -0.19116037f, -0.00372159f, -0.09406914f, 0.05819581f, 0.00890424f, 0.08670433f, 
    0.02915101f, 0.00478623f, 0.03344630f, 0.03318214f, 0.43799537f, -0.14554253f, -0.25462988f, -0.07953115f, 
    -0.09376877f, 0.04456575f, -0.02574509f, 0.03230858f, -0.04971656f, -0.05340638f, 0.04302624f, 0.17928049f, 
    0.26015520f, -0.26673275f, -0.08942536f, 0.25685585f, 0.07245358f, -0.01141379f, -0.01559660f, -0.03325574f, 
    -0.03076975f, 0.05270157f, 0.06144280f, -0.01945935f, -0.13140416f, 0.14756694f, 0.12830172f, -0.10341542f, 
    -0.00530216f, -0.05825228f, 0.05417821f, 0.10198069f, 0.04051485f, 0.09789586f, 0.11398055f, 0.00086946f, 
    -0.40818223f, 0.15978198f, 0.24381609f, 0.16210130f, -0.02154610f, 0.04321707f, 0.02973145f, 0.12615265f, 
    0.00675171f, 0.11052147f, 0.02530625f, 0.11176775f, -0.23913379f, -0.06586660f, 0.02615263f, -0.21770342f, 
    0.10160238f, -0.15633126f, -0.01472767f, 0.05498645f, 0.07285509f, -0.00851542f, -0.00031482f, 0.05380247f, 
    0.00009685f, -0.01472720f, -0.36673868f, -0.06342609f, 0.06535334f, 0.00234022f, 0.08021033f, 0.10885756f, 
    -0.04223603f, 0.03162340f, 0.00757932f, -0.08584487f, -0.18142751f, -0.08633195f, 0.16560151f, -0.12570140f, 
    0.08795144f, -0.00087850f, -0.01271628f, -0.01764507f, 0.05783867f, -0.11061389f, 0.06421289f, 0.01742367f, 
    -0.04440375f, 0.35262832f, 0.09898388f, -0.06175875f, 0.02680950f, 0.02024891f, 0.02479190f, -0.01822973f, 
    0.09866684f, 0.10528303f, 0.17515133f, 0.06046009f, -0.09138012f, 0.05080354f, -0.30639473f, 0.05550294f, 
    0.06666963f, 0.10696322f, -0.11910982f, -0.03892478f, 0.14338048f, 0.04711032f, -0.05171865f, 0.04513967f, 
    -0.34320575f, -0.15513027f, -0.17768565f, -0.08055540f, 0.00052896f, 0.09678166f, 0.01089491f, -0.03881471f, 
    0.02325677f, -0.07622856f, 0.20563908f, 0.00585113f, 0.32953966f, -0.02550847f, -0.06219605f, 0.13850062f, 
    0.02151213f, 0.02772686f, -0.00303477f, 0.09865420f, 0.17923529f, 0.07459357f, 0.01857675f, -0.03002917f, 
    -0.32505816f, 0.12556711f, 0.22133674f, 0.01743119f, 0.08878528f, -0.01198472f, 0.05114156f, 0.07105973f, 
    0.08824712f, 0.01760866f, -0.05753590f, -0.05371349f, -0.30518806f, -0.00810956f, 0.00208577f, 0.12946646f, 
    0.14923364f, 0.28752580f, 0.09098259f, 0.25786150f, -0.02868857f, -0.02281458f, -0.08531088f, 0.04472563f, 
    0.49213132f, -0.01708846f, -0.01705056f, -0.28271592f, 0.13174528f, 0.19436947f, -0.06957278f, -0.01559229f, 
    0.02377849f, 0.05295415f, -0.05835522f, -0.02713752f, 0.15404695f, 0.05865917f, 0.07268698f, -0.08436383f, 
    0.17990500f, 0.03894475f, -0.01989524f, 0.10508937f, -0.14652069f, 0.06188176f, 0.10045491f, 0.02852211f, 
    -0.42226082f, 0.04157138f, 0.35231724f, -0.03336464f, 0.17977302f, -0.01215890f, 0.06710924f, -0.03296667f, 
    0.06441174f, -0.04089134f, 0.04180951f, -0.02003830f, -0.20241222f, 0.04180998f, 0.01160876f, 0.04772964f, 
    0.02144867f, -0.08021310f, -0.01325595f, -0.07041466f, 0.05862710f, 0.12754461f, 0.01758891f, -0.03319339f, 
    -0.23759106f, 0.18185246f, -0.03459396f, -0.11170986f, -0.03034242f, -0.04007030f, -0.04090599f, -0.04539648f, 
    -0.06676240f, -0.01095125f, -0.03729289f, -0.00201147f, -0.06637181f, -0.33055979f, -0.07620981f, 0.18658218f, 
    -0.01934321f, 0.12383871f, -0.01087338f, -0.09238327f, -0.04009280f, -0.00064357f, -0.05543307f, 0.19697604f, 
    0.24911354f, -0.07776051f, 0.07779725f, -0.01337427f, 0.08294492f, -0.03800790f, 0.00509385f, -0.12175199f, 
    0.12206382f, 0.01355209f, 0.01437599f, -0.02794490f, 0.52685827f, 0.12743573f, -0.10534249f, 0.19134328f, 
    0.00152882f, 0.07021508f, -0.03231044f, 0.02849277f, -0.00143687f, -0.04287167f, 0.10186695f, 0.08150113f, 
    0.20837240f, 0.19522211f, 0.20941088f, -0.06751420f, 0.06235721f, 0.04196079f, 0.02615800f, 0.01943343f, 
    0.05232008f, -0.18855017f, -0.00488157f, 0.07256721f, 0.24865478f, -0.10281227f, -0.23925105f, 0.27478713f, 
    -0.06357847f, 0.10701161f, -0.04107084f, 0.09843162f, -0.07975478f, 0.07955000f, 0.02367741f, -0.07780260f, 
    0.06143397f, -0.18143880f, 0.01912248f, 0.18952747f, 0.10160202f, 0.08176127f, -0.13001429f, 0.03705599f, 
    -0.07466419f, -0.10368579f, -0.10886578f, -0.08723712f, -0.31666315f, -0.08148343f, 0.23879766f, -0.06550235f, 
    -0.10528697f, -0.08367056f, 0.03609375f, -0.02544216f, -0.14874014f, -0.01705824f, 0.04127476f, 0.06096484f, 
    0.18466517f, -0.15207651f, 0.01064809f, 0.05026957f, 0.05455880f, 0.05839404f, -0.03089454f, 0.17515321f, 
    0.13940549f, 0.12040798f, -0.05563894f, 0.10702711f, -0.30308875f, 0.00058974f, 0.09310456f, -0.09810456f, 
    0.10538404f, -0.00325025f, 0.08644850f, -0.02295082f, 0.00191485f, -0.14399777f, 0.04764891f, 0.04811062f, 
    0.17021139f, 0.08856034f, -0.00620759f, 0.08984445f, -0.06816554f, 0.11999954f, -0.00140361f, 0.05711705f, 
    0.02957924f, -0.04530723f, 0.06317370f, 0.06881619f, 0.32819581f, -0.06839176f, -0.00950378f, 0.13473134f, 
    -0.06611086f, -0.10891800f, 0.05781677f, -0.15670760f, 0.18021075f, 0.02710887f, 0.16716877f, 0.10403047f, 
    -0.50248051f, -0.31224161f, -0.12758176f, 0.04251722f, 0.05473161f, 0.05233708f, 0.03229739f, -0.04594659f, 
    0.02339831f, -0.01021937f, 0.13935569f, 0.14190698f, -0.12287097f, 0.13486347f, 0.05528364f, 0.12019136f, 
    -0.12781695f, 0.04647001f, 0.12576412f, 0.08837692f, 0.19140738f, 0.00877923f, 0.00831340f, 0.16091655f, 
    0.02457014f, -0.12078203f, -0.16917270f, -0.18067718f, 0.05313973f, -0.14118865f, -0.03184499f, 0.02007892f, 
    0.07116130f, 0.02446137f, 0.11129894f, 0.04012029f, -0.20196813f, -0.11360206f, 0.16554479f, -0.01238788f, 
    0.23811360f, 0.00977785f, 0.10193705f, -0.02618987f, -0.00896024f, 0.00566344f, -0.04431117f, -0.03545054f, 
    -0.19092570f, 0.09162291f, 0.02634968f, -0.10961924f, 0.06521585f, -0.18178885f, 0.10978670f, -0.05888204f, 
    0.04325747f, -0.00692333f, -0.05474883f, 0.04266874f, 0.03445340f, -0.04185181f, -0.10670412f, 0.24831420f, 
    -0.02367624f, 0.11433231f, 0.00750251f, 0.07105241f, 0.22951986f, -0.03510556f, 0.05556202f, 0.08333715f, 
    0.12341168f, 0.19642757f, 0.12537317f, 0.03422773f, 0.20948283f, -0.03062508f, -0.15144773f, 0.02205571f, 
    0.17233312f, -0.03835446f, -0.06269897f, -0.00888387f, -0.43936804f, -0.07143961f, -0.27990761f, 0.03086308f, 
    -0.09224767f, -0.11603837f, -0.13167770f, -0.00832211f, 0.17441744f, -0.03084725f, 0.16724519f, -0.01382732f, 
    0.33815414f, 0.29015729f, 0.11742311f, -0.09165198f, 0.00567574f, 0.07486957f, 0.08350770f, -0.09626619f, 
    -0.06660143f, -0.12005157f, -0.12399550f, -0.04395817f, 0.25106621f, 0.20698158f, -0.10595968f, 0.03287238f, 
    0.10783482f, -0.03978103f, -0.17710280f, -0.10034910f, -0.00770570f, 0.13114043f, 0.04925533f, 0.01752628f, 
    0.27729610f, 0.16584377f, 0.01786996f, 0.09143559f, 0.08695934f, 0.10900565f, -0.14541849f, -0.08912586f, 
    -0.04562147f, 0.02341981f, -0.17172180f, -0.14920169f, -0.21561077f, -0.35202217f, 0.01917657f, 0.21890052f, 
    -0.06500066f, 0.05134172f, -0.02262791f, -0.11240578f, 0.06365851f, 0.13390215f, 0.00445177f, 0.08189792f, 
    0.06185096f, 0.09935407f, 0.05018596f, 0.04659426f, 0.14314590f, 0.10225473f, -0.01574681f, 0.09711900f, 
    0.01436553f, 0.16021900f, 0.08049767f, 0.02002619f, -0.27657956f, 0.03145516f, -0.03900340f, -0.04636566f, 
    -0.06692916f, -0.02172564f, 0.12114941f, -0.03739747f, 0.09153590f, -0.16971281f, 0.14261854f, 0.02190830f, 
    0.46837798f, 0.42679551f, 0.24005993f, 0.08068625f, -0.01015368f, -0.01800974f, -0.06844127f, 0.01873795f, 
    -0.03639520f, -0.02822936f, 0.07121336f, -0.08263002f, 0.39622930f, 0.18946201f, -0.24003188f, 0.11011933f, 
    0.04001691f, -0.21241930f, -0.03730287f, 0.11222737f, 0.20264770f, 0.03749551f, 0.07301363f, -0.07185420f, 
    -0.31942582f, -0.28851581f, 0.05141391f, 0.19954705f, 0.05457503f, 0.01702587f, 0.02222573f, 0.02230652f, 
    0.00498851f, 0.04542350f, 0.07808466f, -0.00698589f, 0.40731782f, 0.09019271f, -0.08128095f, 0.15659253f, 
    -0.06942970f, 0.03621564f, -0.01203467f, -0.06684336f, 0.14687572f, -0.03802708f, 0.13843407f, 0.12130629f, 
    0.10287160f, -0.21970460f, -0.04974621f, -0.05655284f, 0.11381740f, 0.09870765f, 0.01180708f, 0.16089122f, 
    0.03867182f, -0.03454784f, 0.22616372f, 0.15909253f, 0.11323649f, -0.23184127f, -0.01676911f, -0.15074396f, 
    0.05775730f, -0.05713422f, -0.06105926f, -0.02485114f, 0.16576438f, 0.24298272f, 0.08600314f, 0.01677105f, 
    0.06376176f, -0.03289681f, 0.02869811f, -0.13504049f, -0.06365630f, 0.13496679f, -0.02445984f, 0.00492386f, 
    0.04844050f, 0.06612718f, 0.07478401f, 0.16872188f, 0.01905745f, -0.18803218f, 0.00337167f, 0.24093740f, 
    -0.03270047f, 0.03837002f, 0.10565242f, -0.20566691f, -0.03130669f, -0.21380657f, 0.08526123f, 0.06892902f, 
    -0.06738339f, 0.16190426f, -0.05519798f, -0.32050905f, 0.04961259f, -0.16741028f, -0.23853235f, -0.10412842f, 
    -0.05149368f, -0.00235465f, -0.17661092f, -0.10928782f, 0.04984449f, -0.11438835f, -0.07423189f, 0.09389956f, 
    0.00825245f, -0.14376454f, -0.00341468f, 0.05370278f, -0.05973653f, 0.01721929f, 0.01792663f, -0.04294809f, 
    -0.36170080f, 0.29739037f, 0.05993425f, -0.18351179f, 0.08240588f, 0.01124877f, -0.02026623f, -0.17060983f, 
    0.07943679f, 0.02984774f, 0.10046923f, 0.08348248f, -0.21914713f, 0.32986000f, 0.01339365f, -0.00156938f, 
    0.01033864f, -0.01276833f, -0.13227160f, 0.08203633f, -0.06375457f, 0.02388370f, 0.03169014f, 0.18521439f, 
    0.03338425f, 0.39263383f, -0.09042313f, -0.03564451f, -0.01356348f, 0.05520601f, -0.04147705f, 0.03685372f, 
    0.00749145f, 0.08532097f, 0.06097664f, -0.04038933f, 0.44252506f, -0.11940002f, -0.27404767f, 0.02197091f, 
    0.02077210f, -0.05107336f, 0.11166392f, -0.01746009f, 0.03444783f, 0.13068703f, 0.05326304f, 0.06171334f, 
    -0.12201020f, -0.16379723f, -0.02550552f, -0.07164975f, 0.06606605f, -0.00221345f, -0.18054335f, 0.28618619f, 
    -0.04608557f, 0.12625425f, -0.02917507f, -0.03017873f, 0.45243713f, -0.24426474f, 0.22368531f, 0.06688292f, 
    -0.01154071f, 0.19407763f, 0.03547749f, -0.04438693f, -0.00273909f, 0.07715174f, -0.00345665f, -0.06343614f, 
    -0.13806142f, 0.08108063f, 0.06552482f, 0.01154251f, 0.10732877f, 0.06452002f, 0.00485195f, -0.10966954f, 
    -0.01075407f, 0.06195453f, 0.03079771f, 0.00981664f, 0.16937789f, 0.01973997f, -0.18848865f, -0.03542513f, 
    -0.07934625f, -0.03575355f, 0.22694902f, 0.11717337f, 0.01657951f, 0.02582125f, 0.17449473f, -0.11922677f, 
    -0.14194794f, 0.13822609f, -0.14846589f, -0.00631408f, 0.01393773f, -0.11256246f, -0.08581407f, -0.10941190f, 
    0.16406851f, -0.09029707f, 0.04233247f, 0.03489043f, 0.11682698f, -0.08910879f, 0.06041265f, 0.26390883f, 
    0.12261061f, 0.03241927f, -0.06138812f, 0.00551209f, 0.01107124f, -0.02328308f, 0.06301165f, -0.03378807f, 
    -0.06242603f, -0.03845192f, 0.01554897f, -0.04778448f, -0.08063700f, 0.03146195f, 0.03985157f, 0.01017865f, 
    -0.05147962f, -0.00306053f, 0.05254645f, 0.04681721f, -0.06414456f, -0.00977570f, -0.05740959f, 0.02312418f, 
    -0.01440164f, -0.02619796f, -0.07879815f, -0.06818048f, 0.03780064f, 0.02847309f, 0.02871055f, -0.03878046f, 
    -0.05587811f, 0.01768957f, 0.02259578f, 0.01017517f, 0.03827660f, 0.04409998f, -0.04587470f, 0.02208020f, 
    0.03267981f, -0.07500664f, -0.05720735f, 0.05538364f, 0.00029581f, 0.00809268f, 0.03332407f, -0.03408538f, 
    -0.00968371f, 0.02585132f, 0.01324876f, -0.06399666f, 0.01377952f, 0.04969897f, 0.00033494f, 0.03227837f, 
    0.04208893f, -0.04489780f, -0.05384018f, 0.02799528f, -0.01861654f, -0.03237648f, 0.02115624f, 0.02634198f, 
    0.06173932f, 0.04248248f, -0.07054656f, -0.06593948f, 0.01406935f, 0.01876175f, -0.00798041f, 0.02480146f, 
    -0.06640863f, 0.02934128f, 0.04693544f, -0.04741855f, -0.06615024f, -0.04011281f, -0.07196343f, -0.07400861f, 
    0.02795107f, 0.00481752f, 0.05986947f, 0.04356883f, -0.02488597f, 0.01286417f, -0.01851901f, -0.07551376f, 
    -0.03993123f, -0.00459699f, 0.05518052f, 0.03926863f, -0.06114615f, -0.01467808f, 0.05285585f, -0.00671365f, 
    0.01164835f, -0.03832945f, 0.03127486f, -0.00761650f, -0.07127213f, 0.02529901f, -0.05107860f, 0.00009269f, 
    0.02829206f, 0.01205866f, -0.01277795f, 0.01066931f, -0.04782775f, -0.03854946f, -0.05960992f, -0.07599014f, 
    -0.03617364f, -0.02634104f, 0.01368026f, 0.03285328f, -0.04243951f, -0.03690689f, 0.02256683f, 0.05527521f, 
    -0.00001363f, -0.00009858f, -0.01683084f, 0.05579500f, -0.05017351f, -0.00877725f, -0.00078141f, 0.04217582f, 
    -0.05804168f, -0.03224654f, -0.07215106f, 0.01609093f, -0.01621768f, -0.00739849f, 0.01714771f, -0.07081402f, 
    -0.02812634f, -0.00596990f, -0.01707340f, 0.01788401f, -0.04550691f, -0.05857563f, -0.06870925f, 0.01085557f, 
    -0.02417526f, 0.00210385f, -0.00422444f, -0.04805383f, -0.07626026f, 0.03664706f, -0.01090308f, -0.06188199f, 
    0.03604197f, 0.02890284f, -0.00583930f, 0.00513549f, -0.01153193f, -0.00737642f, 0.03657585f, -0.07179952f, 
    -0.00318295f, -0.02265662f, 0.01583408f, 0.05875485f, 0.03689295f, -0.02339933f, 0.00793577f, 0.00910242f, 
    -0.06273493f, -0.03982180f, 0.01298591f, -0.07767654f, 0.02618906f, -0.03589457f, 0.00596995f, 0.03112301f, 
    -0.00451458f, -0.07433058f, 0.03850080f, -0.04426495f, 0.00707489f, -0.00791350f, -0.03086276f, -0.02358035f, 
    -0.03314755f, -0.07315466f, 0.01386425f, -0.04822658f, -0.04825349f, -0.04278611f, 0.05620091f, -0.00716095f, 
    -0.04467186f, 0.03931816f, -0.03272981f, 0.00656765f, -0.07589007f, 0.03561104f, -0.06874368f, -0.02368652f, 
    -0.17983991f, 0.09866747f, 0.09482801f, -0.01523913f, 0.03072605f, -0.07523666f, 0.03711462f, 0.04009708f, 
    -0.06599844f, 0.04193198f, -0.05209277f, 0.09552725f, 0.02699832f, 0.11347672f, 0.00877007f, 0.23050343f, 
    0.11840129f, 0.12688546f, 0.04506150f, 0.05855964f, -0.08802972f, 0.10543627f, -0.04195792f, 0.04823774f, 
    -0.29683405f, 0.30521575f, 0.03678567f, -0.04265951f, 0.18730660f, -0.05403623f, 0.11019080f, 0.10709968f, 
    0.02949874f, 0.05118564f, 0.00562976f, -0.09265061f, 0.14835827f, -0.14202543f, -0.03774418f, 0.00311019f, 
    0.10347246f, 0.08180868f, -0.12123010f, -0.05068855f, 0.26954159f, 0.07355980f, -0.00324564f, -0.03540491f, 
    -0.22053178f, 0.02291027f, -0.15216196f, -0.15746620f, -0.09066554f, 0.09709100f, -0.03332145f, -0.03810336f, 
    0.00917090f, 0.12985408f, 0.12808055f, 0.03793679f, -0.03318349f, 0.31162027f, 0.18307361f, 0.20252755f, 
    -0.03602549f, 0.10898264f, 0.09369626f, 0.10757235f, 0.02294865f, -0.09342922f, 0.04721972f, 0.19010490f, 
    -0.33940044f, 0.10894327f, -0.35357904f, -0.19318438f, 0.07168813f, 0.00284835f, 0.14653410f, 0.02132293f, 
    0.00700522f, -0.04209071f, -0.04704847f, -0.08029392f, 0.05568342f, -0.13691704f, 0.11511254f, -0.08892100f, 
    -0.04374064f, 0.08855622f, 0.14490308f, 0.01147417f, 0.13895617f, 0.03032025f, -0.11231526f, -0.05588955f, 
    -0.28874046f, 0.08430000f, 0.05867128f, 0.20992537f, 0.02441713f, 0.02494262f, -0.05783596f, 0.18810205f, 
    0.16251102f, 0.12489977f, -0.04864291f, -0.00862928f, -0.06281229f, 0.21973130f, 0.29390767f, 0.25409034f, 
    0.10532155f, -0.04236297f, 0.07665792f, 0.28406736f, -0.01814325f, -0.04225966f, 0.13109221f, 0.10282030f, 
    0.10161176f, 0.15335868f, 0.10159507f, -0.03616416f, -0.09904498f, -0.00691072f, 0.00280296f, -0.02861833f, 
    0.04332319f, 0.06468613f, 0.05548500f, -0.03145393f, -0.46255118f, 0.18820405f, -0.07912527f, 0.03674107f, 
    0.17583105f, -0.07710990f, 0.08654989f, -0.00258256f, 0.00178537f, 0.00977031f, -0.04442733f, -0.03879092f, 
    0.20462748f, -0.01731266f, -0.06463686f, -0.22775087f, 0.00105957f, 0.03070894f, 0.01133111f, -0.05591394f, 
    -0.01207949f, 0.07120481f, -0.08030309f, 0.17482688f, -0.03166098f, -0.02927450f, 0.13856874f, 0.20138940f, 
    -0.05922985f, -0.00991833f, 0.02809099f, -0.05227604f, -0.04112215f, 0.10097007f, 0.07149764f, 0.10551222f, 
    -0.24476333f, -0.02904850f, -0.09978351f, -0.15733559f, 0.10108361f, 0.08781176f, 0.02573041f, 0.06380183f, 
    0.06993791f, 0.06219956f, 0.03076546f, 0.00353945f, 0.05538410f, -0.21185903f, 0.39045891f, 0.29843011f, 
    -0.05498615f, -0.00776581f, -0.06324419f, -0.02627798f, 0.02810359f, 0.05080084f, 0.03571084f, -0.13902985f, 
    -0.03110607f, -0.01786871f, -0.02026601f, -0.05658860f, 0.06190318f, 0.02148607f, -0.03116121f, -0.05630430f, 
    0.05150370f, -0.01891355f, -0.01623184f, -0.00417218f, -0.07536433f, -0.05560986f, -0.00320352f, -0.07613583f, 
    -0.07425439f, -0.01067985f, -0.03232604f, -0.02613074f, 0.05599920f, -0.05520421f, 0.01014272f, 0.03607626f, 
    0.04054803f, 0.00845559f, 0.04938339f, 0.03543907f, -0.00804190f, -0.00596497f, 0.03140145f, -0.00397222f, 
    -0.04257483f, -0.04678708f, 0.00949859f, 0.04190790f, -0.07587367f, 0.02959859f, -0.02642495f, -0.07238927f, 
    -0.03638092f, -0.03926035f, 0.05545160f, -0.02335244f, 0.00043957f, 0.04203193f, -0.02180390f, -0.04760462f, 
    -0.07040744f, -0.05186924f, -0.07153586f, -0.08378471f, 0.04219104f, -0.04584919f, -0.06713101f, 0.06138509f, 
    0.06845268f, -0.06086927f, -0.02555421f, -0.06385803f, -0.01012515f, -0.04552909f, -0.04171054f, 0.05396441f, 
    -0.02770207f, 0.00615483f, -0.03800138f, 0.04201914f, -0.01726527f, 0.05520856f, 0.05131521f, 0.00920124f, 
    -0.02385196f, 0.00068293f, -0.00388719f, -0.05375569f, 0.04582569f, 0.02865868f, 0.02951615f, 0.00483452f, 
    -0.02304433f, -0.06525597f, 0.02958816f, -0.05289862f, 0.06349286f, -0.06756698f, 0.04065723f, -0.01644440f, 
    -0.04645434f, -0.06615242f, 0.06232371f, 0.00549661f, 0.00248259f, 0.00173440f, 0.02114090f, -0.02696499f, 
    -0.03420958f, 0.05076654f, 0.04022419f, 0.05592840f, 0.06701361f, -0.02517141f, -0.02049406f, -0.00687252f, 
    -0.00420609f, 0.03665028f, 0.03859456f, -0.03938849f, 0.04885638f, -0.04447634f, 0.03361346f, -0.02045937f, 
    0.02567534f, 0.06066606f, 0.05932978f, -0.06564791f, -0.04993740f, 0.05986304f, 0.01391371f, -0.00873239f, 
    -0.05473208f, -0.07657931f, -0.06261153f, -0.04318829f, -0.03920585f, 0.05317827f, 0.01579361f, 0.00883569f, 
    -0.06639172f, 0.04799248f, -0.07689204f, -0.02999813f, -0.06168705f, 0.01545032f, 0.00289004f, 0.05280738f, 
    -0.01822066f, -0.06987105f, -0.00339418f, -0.01297701f, -0.05543271f, -0.04156011f, -0.06706937f, -0.01536205f, 
    -0.04938547f, -0.03997578f, -0.06562274f, 0.01242943f, 0.02932793f, -0.06196738f, -0.01158203f, 0.00006418f, 
    0.04438781f, -0.07549395f, 0.02557219f, 0.04355899f, -0.05635385f, 0.06333472f, 0.04107035f, 0.04854566f, 
    -0.03705291f, 0.05688165f, 0.05747551f, -0.01282305f, -0.07212282f, 0.00962947f, 0.00143712f, -0.06430185f, 
    -0.02097622f, -0.02039738f, -0.07893616f, -0.03437086f, 0.04403696f, 0.02912218f, -0.01743628f, 0.04986705f, 
    0.04068118f, 0.02932467f, -0.05749395f, 0.05728585f, 0.06342215f, 0.01431228f, -0.06624247f, -0.04137231f, 
    0.05222338f, -0.06787552f, -0.06564467f, -0.04063016f, -0.03436078f, -0.06379116f, 0.05562390f, -0.00491348f, 
    -0.06392734f, -0.05709910f, -0.05729321f, -0.04629595f, 0.01082442f, -0.06850277f, -0.03360549f, 0.02436622f, 
    0.04850245f, 0.01211677f, 0.03948818f, 0.00502409f, -0.07202668f, 0.03664597f, -0.06718379f, 0.05882195f, 
    0.00692177f, 0.06453717f, -0.05134059f, 0.02234988f, -0.04779604f, 0.03888563f, 0.00000761f, -0.02947064f, 
    -0.02556172f, -0.00394681f, 0.02396870f, 0.01282584f, -0.06356738f, -0.07326619f, 0.01260105f, -0.07656087f, 
    0.02214645f, -0.07048007f, -0.01567531f, 0.02962221f, -0.05962491f, -0.04397278f, -0.02826261f, 0.03354116f, 
    0.02089668f, 0.03631438f, 0.02265500f, 0.06248474f, 0.06355596f, 0.06014024f, -0.06856422f, -0.03789360f, 
    -0.00467612f, 0.04914428f, -0.00442157f, 0.02006576f, -0.03845808f, -0.03544019f, -0.01396883f, 0.03343859f, 
    -0.07159499f, 0.05303891f, -0.01355540f, 0.03375995f, 0.00350318f, -0.03494659f, -0.06511038f, 0.05084976f, 
    0.04411235f, -0.07546726f, -0.02046265f, 0.04594070f, 0.02315798f, -0.07163973f, -0.03919851f, 0.02012532f, 
    -0.04989753f, 0.04587784f, -0.07165032f, -0.04743769f, -0.05364671f, -0.02959192f, -0.06782993f, 0.02071742f, 
    -0.01376061f, 0.03643706f, -0.02790543f, -0.07383235f, -0.03764207f, -0.07815182f, 0.05320147f, 0.05917459f, 
    0.02872294f, 0.05653198f, 0.06417553f, -0.00614695f, 0.00937490f, -0.07802420f, 0.01554601f, 0.04905594f, 
    0.01927488f, -0.05838105f, 0.03004109f, -0.00447394f, -0.07532085f, -0.06360853f, -0.06546926f, 0.04970162f, 
    -0.05551751f, 0.04175817f, -0.00845793f, 0.02715222f, -0.03575318f, 0.02348654f, 0.00686370f, 0.03270061f, 
    -0.02268283f, 0.03774372f, 0.04435596f, 0.01992682f, -0.03082645f, 0.00879843f, -0.00712107f, -0.04771438f, 
    -0.07354529f, -0.02691790f, -0.06078002f, -0.00250336f, 0.06356779f, 0.03088570f, -0.04849072f, -0.01888686f, 
    -0.06558545f, -0.02763781f, -0.05339966f, 0.02489448f, 0.00913141f, -0.05523678f, 0.05548794f, 0.05105403f, 
    -0.07769291f, -0.06247513f, -0.04397326f, -0.03799247f, -0.00496696f, -0.01684493f, -0.03830217f, -0.02609009f, 
    -0.05153630f, 0.04716701f, -0.03082539f, 0.03369590f, 0.00693776f, -0.01893886f, -0.03417226f, 0.01286449f, 
    0.04803042f, -0.05606850f, -0.01525279f, -0.04797589f, -0.05871871f, 0.06301499f, 0.02997436f, -0.04807452f, 
    -0.00560952f, -0.03322801f, -0.00518725f, -0.03848760f, -0.05977441f, -0.03593284f, 0.05384118f, -0.01493176f, 
    -0.04565954f, 0.01297581f, 0.02414737f, 0.06249416f, -0.06360408f, -0.00956238f, 0.02735498f, 0.05726695f, 
    -0.02713246f, -0.00526295f, -0.04510628f, -0.06723773f, -0.05616017f, 0.05888237f, -0.04879026f, 0.05131241f, 
    -0.05179660f, 0.06444672f, 0.01180664f, -0.07528541f, -0.07602879f, 0.01671513f, -0.01331084f, -0.03425487f, 
    -0.04016227f, -0.06952085f, -0.03262251f, -0.02582215f, -0.03588907f, -0.00084269f, 0.01549766f, -0.01841656f, 
    -0.07079059f, -0.01558049f, 0.03878763f, 0.03280300f, -0.05536288f, -0.03527659f, -0.05815244f, -0.04362999f, 
    0.00722739f, -0.08488786f, 0.01544284f, -0.01927925f, 0.05742359f, -0.04500443f, 0.03381742f, 0.04762961f, 
    0.04849428f, 0.05832260f, -0.06677928f, 0.06305631f, -0.06764491f, -0.03825842f, -0.03690490f, 0.05827165f, 
    -0.05066244f, 0.04851249f, -0.07890773f, -0.05710761f, -0.02032319f, -0.06173314f, -0.03772947f, 0.01553844f, 
    -0.02697848f, -0.07880294f, -0.07877286f, -0.00212588f, 0.01109353f, 0.05083388f, -0.05291770f, -0.02629805f, 
    -0.02832571f, 0.01269342f, 0.01109537f, 0.02166338f, 0.03791010f, 0.01126522f, -0.04462407f, -0.02383149f, 
    -0.05642992f, 0.00282933f, 0.02022779f, -0.04841955f, -0.06813223f, -0.07478785f, -0.01510289f, -0.07908057f, 
    0.03842002f, -0.06138866f, -0.02230578f, 0.02553156f, -0.04558548f, -0.04926756f, 0.00965773f, 0.04601727f, 
    -0.02727449f, 0.04979216f, 0.01712139f, 0.04823276f, 0.00104985f, 0.00270801f, 0.01723360f, 0.04477159f, 
    -0.08732583f, 0.04109785f, -0.06497311f, -0.02188903f, 0.04348234f, 0.00307720f, 0.01440198f, -0.07764845f, 
    -0.07721740f, -0.01604191f, 0.04446165f, 0.04328978f, 0.00744506f, -0.01853170f, 0.00370058f, 0.03821218f, 
    -0.06708454f, 0.00903442f, -0.01833093f, -0.03741196f, -0.02344775f, -0.06662154f, 0.04600628f, 0.00617597f, 
    -0.01231581f, 0.04968567f, -0.04076127f, -0.04482608f, 0.02741513f, -0.07147531f, -0.05228794f, 0.04649448f, 
    -0.06961583f, -0.04370096f, -0.05088278f, 0.03226869f, 0.04972085f, -0.03321503f, -0.00670427f, 0.04905580f, 
    -0.02931810f, -0.06474374f, -0.03346581f, 0.05602481f, 0.04631077f, -0.03837745f, -0.01941271f, 0.01133317f, 
    -0.04689403f, -0.00585245f, 0.02079457f, 0.04853424f, 0.06571855f, 0.03572970f, 0.02947965f, 0.03637630f, 
    0.02176395f, 0.04061301f, 0.00144123f, -0.04486265f, -0.01492563f, -0.01881056f, 0.00555735f, 0.03927571f, 
    -0.01843601f, -0.04439376f, -0.04747041f, 0.04605172f, -0.02418080f, -0.01466460f, -0.00059408f, 0.02632556f, 
    -0.04286891f, -0.04626565f, -0.08623087f, 0.00398690f, 0.00887917f, -0.00585054f, 0.00765733f, -0.05172611f, 
    -0.00189883f, -0.01833795f, -0.07901084f, 0.05932437f, -0.02914970f, 0.03593537f, -0.07709566f, 0.02505013f, 
    0.04130483f, -0.06067303f, -0.04415223f, -0.07493429f, -0.03557786f, 0.02666080f, 0.03364761f, 0.04998419f, 
    -0.00487643f, -0.06040910f, -0.06425130f, -0.03223068f, -0.03622732f, -0.05238058f, 0.00701746f, 0.05629925f, 
    -0.04931132f, -0.08275004f, 0.05497091f, -0.03043468f, 0.05492258f, 0.02429293f, 0.00598566f, -0.06572627f, 
    -0.00217559f, 0.03232367f, 0.15046021f, 0.03167350f, 0.14857174f, 0.16509497f, 0.15719731f, 0.07720688f, 
    0.07751054f, 0.01684162f, -0.00823859f, -0.10410122f, 0.08241440f, -0.06730470f, -0.02766441f, 0.21165554f, 
    0.08626419f, -0.16910733f, -0.07407014f, -0.01033980f, 0.12816156f, 0.09324932f, -0.13973664f, 0.21343172f, 
    0.11660437f, -0.09275839f, -0.00043449f, 0.07579232f, -0.08708423f, 0.05893399f, -0.10533886f, -0.11273646f, 
    -0.02557953f, -0.02633770f, 0.02941630f, 0.00971078f, -0.16283815f, -0.27452835f, 0.05291515f, 0.12449505f, 
    -0.11704139f, -0.09714549f, 0.04849873f, -0.22607493f, -0.03609878f, -0.00977718f, 0.02615407f, 0.15765819f, 
    -0.09255420f, 0.22827487f, 0.22135182f, 0.07754870f, -0.07035951f, -0.02482762f, -0.08256845f, -0.01839978f, 
    -0.02129687f, -0.03167951f, -0.24466166f, -0.04741488f, 0.43311036f, -0.23345506f, 0.02906893f, 0.08341289f, 
    0.09713898f, 0.02276031f, 0.05124617f, -0.06883756f, -0.07416376f, 0.00123108f, -0.02173991f, -0.02787571f, 
    0.24960870f, -0.17746425f, 0.23449878f, 0.08775818f, -0.09563778f, 0.01325801f, -0.13586329f, 0.03156108f, 
    0.03453641f, -0.09677570f, 0.02345291f, -0.01374758f, 0.20626704f, 0.02720958f, -0.21276280f, -0.19361585f, 
    -0.01410895f, 0.09973519f, -0.12738039f, 0.17080645f, -0.08461850f, -0.01138036f, 0.00465139f, 0.11836312f, 
    0.21748529f, -0.12510906f, 0.03759015f, -0.15779851f, -0.08414078f, -0.04728498f, -0.18580924f, 0.08181906f, 
    -0.15600477f, 0.01024141f, -0.01588858f, -0.13039447f, -0.20744692f, 0.04098372f, 0.08173514f, 0.01046155f, 
    -0.03314122f, 0.02022960f, -0.02187710f, -0.16283609f, 0.08503754f, -0.01228979f, -0.12466058f, -0.02687750f, 
    0.05737437f, -0.15658993f, -0.16778336f, 0.03815574f, 0.11085773f, 0.07437494f, -0.08527256f, 0.09000407f, 
    0.00771162f, 0.00347802f, -0.02135989f, 0.08614083f, 0.28088388f, -0.26330522f, 0.31675535f, -0.00497506f, 
    -0.01946220f, 0.08866200f, 0.06731085f, -0.04007091f, -0.01356766f, -0.04896832f, 0.05161354f, 0.14745396f, 
    0.12100492f, 0.20301722f, 0.03293968f, 0.23516375f, -0.15793504f, -0.15943477f, -0.01998466f, 0.01558222f, 
    -0.14900227f, -0.15239073f, -0.06951348f, -0.09577204f, 0.21903506f, -0.04931246f, -0.01360418f, 0.06610470f, 
    0.04877810f, -0.15298927f, 0.02995008f, 0.14592576f, 0.01389063f, -0.00972237f, -0.01801045f, 0.18671679f, 
    -0.22157653f, -0.11265393f, -0.09557454f, -0.24011533f, 0.24933383f, -0.03359278f, 0.03325698f, -0.04582685f, 
    0.09072203f, 0.08141968f, 0.02708480f, 0.11030815f, 0.16515553f, 0.14549425f, -0.36591205f, -0.00303101f, 
    -0.03902978f, 0.22786060f, 0.10957135f, 0.14876910f, -0.00003478f, 0.11305933f, -0.00328865f, 0.19066179f, 
    -0.14063118f, -0.13897142f, 0.02094426f, 0.32999331f, 0.10092913f, -0.05136555f, 0.04049141f, -0.05043743f, 
    0.04027348f, 0.16771676f, 0.02325475f, -0.00705198f, -0.38134941f, 0.19672249f, 0.09644321f, -0.03900169f, 
    -0.00070739f, 0.01574710f, 0.08936825f, 0.00241815f, 0.07618088f, -0.10628221f, 0.10819341f, -0.09011357f, 
    -0.13113411f, 0.22494338f, -0.14893806f, 0.07856791f, 0.04612865f, 0.03750736f, -0.06097447f, -0.02383996f, 
    0.06410710f, 0.05561203f, -0.04208158f, 0.11058488f, -0.06119056f, 0.13569152f, -0.02533176f, -0.16223760f, 
    -0.07068676f, 0.03178350f, -0.06752644f, -0.08887962f, -0.03048070f, -0.14068756f, -0.11030315f, -0.05814720f, 
    0.26169536f, -0.04664550f, -0.12168441f, 0.30615854f, 0.03187899f, 0.02286592f, -0.01453170f, -0.05381963f, 
    0.11612277f, -0.01181648f, 0.03806636f, -0.05257216f, 0.07025008f, 0.02378865f, 0.10985540f, 0.13528267f, 
    0.03045641f, 0.14762150f, 0.00539186f, 0.02600885f, 0.06434368f, 0.10132071f, 0.00541757f, -0.09126206f, 
    0.21361111f, -0.33562532f, 0.22899944f, 0.52915961f, -0.05401074f, 0.03726244f, -0.04903705f, -0.02711963f, 
    0.00157793f, 0.11870626f, -0.10599447f, 0.03239362f, 0.06726800f, 0.13193895f, -0.19264664f, 0.01456841f, 
    0.05672313f, 0.02252077f, -0.04988036f, 0.02277687f, 0.04395289f, 0.04438687f, -0.04097003f, 0.15906513f, 
    0.17269976f, -0.39968675f, -0.00455687f, -0.05558267f, -0.08649555f, -0.10733706f, 0.01286961f, -0.09647327f, 
    -0.05674637f, 0.04597038f, 0.05057818f, 0.17283987f, -0.29797673f, 0.03351991f, 0.17890310f, 0.03475085f, 
    0.08655676f, 0.02955454f, 0.10132932f, -0.02273055f, 0.04505056f, 0.07304279f, 0.07836434f, -0.02816211f, 
    0.00484268f, 0.24795048f, 0.07820549f, 0.01628270f, 0.03842959f, -0.03378406f, 0.04679893f, -0.15640543f, 
    0.02602957f, 0.07874478f, -0.02906685f, 0.12277389f, -0.50089246f, 0.32160500f, -0.05105210f, -0.08227513f, 
    0.12902388f, 0.04150031f, 0.01434218f, 0.00078597f, -0.04919557f, 0.01260805f, -0.05507491f, 0.10092287f, 
    0.36963743f, -0.21197762f, -0.16512765f, -0.04141639f, -0.01656004f, -0.12604927f, -0.05707746f, 0.09136087f, 
    0.04805540f, -0.01125734f, 0.04937353f, 0.08975152f, -0.06193635f, 0.25066233f, -0.08896772f, -0.21414798f, 
    -0.06863577f, -0.02678706f, -0.17255515f, -0.11019990f, 0.11892503f, 0.05252490f, -0.04525673f, -0.00784987f, 
    0.18748218f, 0.00090676f, 0.11364972f, 0.02080249f, -0.08776429f, -0.10396800f, -0.05279472f, 0.06338757f, 
    0.00133191f, 0.00191755f, 0.02427879f, -0.05986445f, -0.04113090f, 0.36119276f, -0.00289095f, -0.09899247f, 
    -0.17404211f, 0.04448056f, 0.13411233f, -0.08884249f, 0.06782543f, 0.09203809f, -0.00113465f, 0.01595937f, 
    0.02814043f, -0.04871190f, 0.11590896f, 0.02670581f, 0.07744997f, 0.11127508f, 0.09736174f, 0.06200938f, 
    -0.02445497f, -0.08856671f, -0.13417457f, -0.08010844f, 0.20099752f, 0.18556996f, 0.22091685f, 0.03270513f, 
    -0.09850610f, -0.05943854f, -0.10897575f, -0.06031819f, -0.01741608f, -0.00877197f, -0.06983170f, 0.26107290f, 
    0.44554943f, -0.24894270f, 0.04046447f, 0.03145043f, -0.19865546f, -0.03355251f, -0.21557960f, -0.16826931f, 
    -0.06746010f, -0.08177545f, 0.06022148f, -0.05779992f, 0.23137300f, 0.08689775f, 0.07204124f, 0.19238156f, 
    -0.09831575f, -0.15156752f, -0.00053678f, 0.11744408f, -0.09854745f, 0.35038906f, -0.12483893f, 0.12629724f, 
    -0.19609827f, -0.04128973f, 0.11266568f, -0.05100609f, -0.10593449f, 0.04629584f, 0.14496426f, 0.12681839f, 
    -0.09156314f, -0.06805644f, 0.07490567f, 0.05666444f, 0.51999485f, 0.04007893f, -0.09139727f, -0.11911114f, 
    0.13625474f, 0.04166342f, -0.03234771f, -0.09676988f, 0.00224992f, 0.12315728f, 0.00315630f, 0.03507815f, 
    0.13170791f, -0.21734391f, 0.15406078f, -0.00796554f, -0.07417208f, 0.06307686f, -0.08601483f, 0.20469639f, 
    0.00741368f, -0.10942987f, -0.02496418f, -0.00181363f, -0.14163986f, -0.05861659f, -0.15268911f, 0.12183021f, 
    0.01611790f, 0.10576569f, -0.02382853f, 0.09345330f, 0.04708285f, 0.00299246f, 0.15391624f, -0.13293375f, 
    -0.01197094f, 0.00540463f, 0.00594892f, -0.06459332f, -0.09931213f, -0.04687343f, 0.01523336f, -0.08293442f, 
    0.02557025f, -0.14738779f, 0.07512069f, -0.12759691f, 0.21706623f, 0.05636093f, 0.11937695f, -0.24744256f, 
    -0.04526234f, 0.05553458f, -0.06751855f, 0.02965492f, 0.09670307f, -0.03379092f, -0.11855538f, 0.00362790f, 
    0.15832497f, -0.11152887f, -0.10312517f, 0.07568263f, -0.03540338f, -0.06598268f, 0.08829483f, -0.07824730f, 
    0.04611290f, -0.05222781f, 0.10935134f, -0.00679004f, 0.69091457f, -0.29807493f, 0.33519474f, -0.00580016f, 
    0.04463686f, -0.03512334f, 0.00178812f, 0.05829581f, 0.09355212f, 0.16668183f, 0.19284929f, 0.17151171f, 
    -0.40945947f, 0.05990712f, -0.14760739f, 0.01557716f, -0.04648636f, -0.07668849f, 0.14917742f, 0.03013189f, 
    -0.08122120f, -0.07418318f, 0.01561555f, 0.07250641f, -0.01449038f, -0.18005349f, 0.04400648f, -0.07974187f, 
    -0.02715202f, 0.02872012f, 0.01754621f, -0.08030365f, -0.22709499f, -0.15037362f, 0.04336732f, 0.10733800f, 
    0.00056874f, 0.15232240f, -0.04761423f, -0.07432528f, -0.04403195f, 0.01992693f, 0.07879603f, -0.00846902f, 
    -0.05361133f, 0.07057451f, 0.05587932f, 0.14877218f, -0.05417546f, -0.00748865f, -0.14460604f, -0.19204994f, 
    0.18363647f, 0.01960291f, 0.11085331f, 0.13208681f, -0.05156237f, 0.06578135f, 0.00483871f, -0.03905737f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00496108f, 0.06816239f, 0.10486845f, -0.06761196f, -0.09201830f, -0.03204109f, 0.11376040f, -0.03089089f, 
    -0.07322095f, -0.02551943f, 0.05582384f, 0.02369091f, 0.04874931f, 0.12647979f, 0.02508230f, -0.03124029f, 
    0.00712963f, 0.14047313f, 0.01142258f, -0.00763177f, -0.02311273f, 0.01341760f, -0.07588101f, -0.02615261f, 
    0.15938246f, 0.02261674f, 0.09062335f, 0.06163942f, -0.00373631f, 0.11162069f, 0.17414176f, 0.01137182f, 
    0.04893699f, -0.00520364f, -0.05119596f, 0.04814971f, 0.00111002f, 0.01113318f, -0.05916236f, -0.01645201f, 
    0.00878030f, -0.06740868f, -0.04118611f, 0.14982098f, -0.05142352f, -0.01764473f, -0.12139536f, -0.07286311f, 
    -0.03330030f, 0.01125312f, -0.02354316f, 0.04729052f, 0.05838325f, 0.07224494f, -0.02854100f, -0.02096668f, 
    0.03597382f, 0.01898471f, -0.02625236f, 0.03865235f, 0.03285190f, 0.04341818f, 0.04239515f, -0.00391859f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.18277724f, 0.35688126f, -0.46917918f, 0.39689997f, 0.16947860f, 0.35601854f, -0.46408519f, -0.02823172f, 
    0.28691849f, -0.13032281f, 0.12752177f, -0.10969077f, -0.40222073f, -0.33575290f, 0.10374754f, -0.08181126f, 
    -0.32591915f, 0.23046848f, 0.08529219f, -0.03259966f, -0.04625560f, 0.12105739f, -0.12102023f, -0.08758686f, 
    -0.33078060f, 0.07526653f, -0.47370362f, -0.49036509f, 0.48303828f, -0.04970315f, -0.06488364f, -0.19871509f, 
    -0.00022313f, 0.14729612f, -0.07914068f, -0.10391715f, 0.33715519f, 0.23482460f, 0.18021481f, -0.07591075f, 
    -0.07766794f, 0.00720546f, -0.18418211f, -0.11329025f, 0.01114263f, -0.04823499f, -0.15540124f, -0.07640054f, 
    -0.11239158f, 0.08476012f, 0.43309388f, -0.05691316f, 0.22278067f, -0.31961334f, -0.18534084f, -0.66253448f, 
    -0.07584910f, 0.02177927f, -0.06675464f, -0.06203099f, -0.08833030f, -0.15214494f, 0.30929631f, -0.14605670f, 
    0.14399940f, 0.08557193f, 0.08148675f, -0.00897965f, 0.02779648f, -0.05334312f, 0.00466184f, 0.08465078f, 
    0.27454194f, 0.22532706f, -0.10804944f, 0.14085340f, 0.10512199f, 0.26726353f, -0.30659676f, 0.20277794f, 
    -0.51392555f, -0.05148868f, -0.08884442f, -0.03902562f, -0.45785701f, 0.09860207f, -0.05762404f, -0.08214556f, 
    -0.01605342f, -0.10995106f, -0.34717408f, -0.45009461f, -0.42803699f, 0.13450041f, 0.26377264f, 0.05210814f, 
    0.00985575f, 0.37981895f, -0.55632681f, 0.02685269f, -0.21988305f, -0.27062088f, 0.26710215f, 0.06517830f, 
    -0.38964728f, 0.06570923f, -0.17811134f, 0.02989273f, 0.01192562f, -0.01903572f, -0.49842265f, -0.01857308f, 
    -0.05054703f, -0.07828994f, 0.39055490f, 0.32049569f, -0.05311988f, 0.19012332f, 0.15793964f, -0.04052810f, 
    -0.06713274f, -0.24460341f, -0.05907195f, -0.11533846f, 0.00285424f, 0.56295663f, 0.05926532f, 0.10644463f, 
    0.19275056f, -0.21281020f, 0.01720968f, -0.34622377f, -0.34920779f, 0.31953585f, 0.12774387f, -0.02860423f, 
    0.37533030f, -0.27287069f, -0.47319642f, -0.08049321f, -0.15986420f, -0.32003316f, -0.41925845f, 0.51521838f, 
    0.17425790f, -0.08804941f, -0.01725744f, -0.11285740f, 0.23637241f, 0.33681378f, -0.07296498f, -0.04857535f, 
    0.07527363f, 0.04793373f, 0.15135281f, -0.26653066f, -0.35857451f, 0.17260966f, 0.08120749f, 0.22313477f, 
    0.04819962f, -0.43882626f, -0.22166224f, -0.02950440f, 0.05827910f, -0.42885461f, -0.12092623f, 0.08070648f, 
    -0.23342386f, 0.08916137f, 0.27177584f, -0.43761238f, -0.07059434f, -0.08762866f, 0.28484014f, -0.03062617f, 
    -0.03362885f, 0.02635039f, 0.02485537f, 0.17715326f, 0.13726676f, -0.43118718f, -0.27631450f, 0.11295136f, 
    0.05414650f, -0.53723145f, -0.11152187f, 0.01417494f, 0.08311637f, -0.13244796f, -0.24657038f, 0.39531645f, 
    -0.46447003f, 0.39266562f, 0.03226788f, 0.16833834f, -0.46031892f, -0.34616220f, 0.21627302f, -0.01156461f, 
    -0.83525538f, -0.07882719f, -0.06503112f, -0.04656964f, 0.41548979f, -0.17584096f, 0.09618567f, 0.17327584f, 
    0.28842762f, -0.35086176f, 0.04555712f, -0.07166174f, -0.33976188f, 0.31115404f, 0.12161014f, -0.06422648f, 
    -0.34430224f, 0.06343624f, 0.03527022f, 0.30176127f, 0.37901819f, -0.18470559f, -0.30270895f, -0.07148103f, 
    0.00502524f, 0.31257740f, -0.04451764f, 0.08365669f, -0.31633836f, 0.06117449f, -0.16384839f, 0.02263242f, 
    0.18280952f, 0.09229845f, -0.18246773f, 0.29146734f, 0.08851952f, 0.05279176f, -0.06537470f, 0.06104456f, 
    0.11214678f, 0.05817522f, -0.18736407f, -0.37014142f, -0.22072166f, 0.21760610f, -0.53128046f, 0.05199473f, 
    0.08452177f, 0.05594495f, 0.08529354f, 0.05138379f, 0.02867541f, 0.35471001f, 0.09571140f, 0.43554810f, 
    0.04912274f, 0.09775099f, 0.17536433f, 0.21014868f, 0.10246545f, 0.28039467f, 0.06490790f, 0.01877119f, 
    0.17871644f, -0.15117206f, 0.09742893f, -0.13899985f, 0.23794664f, -0.24562895f, -0.42542639f, -0.70996612f, 
    0.07861529f, 0.05073980f, 0.02324621f, 0.01738916f, -0.04612328f, 0.07407148f, 0.10170368f, 0.09562137f, 
    -0.05520326f, -0.00141068f, 0.20788723f, -0.02860236f, 0.01184149f, -0.10589781f, -0.13299392f, -0.00959089f, 
    -0.03029700f, -0.10778468f, -0.22302851f, 0.00383073f, -0.79264128f, 0.00105901f, 0.23107226f, 0.03066854f, 
    0.43582785f, -0.11736792f, 0.22933927f, 0.31068075f, -0.00190623f, 0.04953737f, -0.25571719f, 0.05931090f, 
    -0.04569825f, 0.11978883f, -0.29977527f, -0.52834499f, -0.29902050f, 0.32174614f, 0.06708923f, -0.32777834f, 
    -0.02362639f, 0.15822840f, -0.00498612f, 0.03884222f, 0.03271058f, -0.44091153f, 0.06433606f, -0.26135486f, 
    0.24134779f, -0.14731611f, -0.23276015f, -0.47063005f, 0.31303668f, -0.68695152f, -0.37332818f, 0.00045319f, 
    -0.27072048f, 0.42242873f, 0.22820786f, 0.00854960f, 0.02594528f, -0.19085675f, 0.15943822f, -0.24021742f, 
    -0.21159656f, 0.21843415f, 0.10854200f, 0.03475429f, -0.16418053f, -0.07781396f, 0.11341296f, 0.11218163f, 
    -0.04993292f, 0.04930973f, -0.30334467f, -0.12300242f, 0.42908818f, 0.27259442f, -0.14664300f, -0.29742029f, 
    0.10421214f, -0.21548939f, 0.14334719f, 0.02194292f, 0.09791104f, -0.20925428f, 0.22986203f, 0.04427761f, 
    -0.20957373f, -0.03743012f, 0.18052222f, 0.23075891f, 0.12579285f, 0.09346662f, 0.40712434f, 0.07636639f, 
    -0.06179213f, 0.10292208f, 0.01814600f, -0.03499559f, -0.06045390f, 0.11248821f, 0.03568898f, 0.34731096f, 
    -0.01125088f, 0.11572246f, 0.10651980f, 0.08916356f, -0.10045166f, 0.00000775f, -0.10262732f, -0.66468489f, 
    -0.05837926f, -0.47802266f, -0.11936325f, -0.73858833f, 0.02991846f, 0.23109314f, -0.15711072f, -0.06019399f, 
    -0.32609555f, -0.48636508f, -0.00202755f, -0.65490186f, -0.29839289f, 0.12788452f, 0.23601606f, 0.07309694f, 
    0.33069730f, 0.16454782f, 0.12241188f, -0.06502520f, 0.13631096f, -0.73587000f, 0.09075239f, -0.10187066f, 
    0.29405484f, 0.05926617f, -0.13042064f, 0.18811947f, -0.96375483f, 0.30690101f, 0.27920273f, -0.12623495f, 
    0.03777511f, -0.01177407f, 0.17772090f, 0.06819665f, -0.07102463f, -0.20192696f, 0.06190125f, 0.03993659f, 
    0.27117327f, 0.06304161f, -0.29209745f, -0.03969901f, -0.09909032f, -0.07909638f, -0.01997579f, -0.06782702f, 
    0.06393643f, -0.12847742f, -0.25620481f, -0.36984813f, 0.24401841f, 0.10667174f, 0.05411766f, 0.03236307f, 
    0.05335113f, -0.11097500f, 0.05897280f, -0.02809498f, -0.03117629f, 0.27947381f, -0.38604552f, 0.51708603f, 
    -0.05828435f, -0.37745777f, 0.09655663f, 0.31583014f, 0.09099612f, 0.07067851f, 0.06645879f, 0.08389165f, 
    0.08006173f, 0.37256822f, -0.23132046f, 0.18821880f, -0.37162793f, -0.22753549f, -0.17198162f, 0.03478595f, 
    0.25441369f, -0.35437542f, 0.01517825f, -0.07036041f, 0.31963500f, -0.21400216f, -0.07858533f, -0.02902474f, 
    -0.46842271f, 0.07976546f, 0.18180163f, 0.18928449f, -0.11518715f, -0.42051432f, -0.42005974f, 0.25747806f, 
    0.06370388f, -0.05334285f, 0.26539418f, 0.01155628f, 0.29782370f, -0.37016559f, -0.15351470f, 0.09061241f, 
    0.18958513f, 0.00401749f, -0.21711332f, -0.51319820f, -0.05588101f, -0.05229398f, 0.15873532f, -0.06977999f, 
    -0.00565969f, -0.00135155f, -0.21762656f, -0.23824959f, -0.32406074f, -0.15825623f, 0.06019670f, 0.30891386f, 
    0.10982335f, 0.15366378f, -0.00171434f, -0.05002363f, -0.08643813f, -0.20442466f, -0.19578619f, 0.23974146f, 
    0.23831376f, -0.09572588f, -0.49354291f, -0.21857736f, -0.27242622f, -0.31238389f, 0.20805910f, -0.05281798f, 
    0.06537949f, -0.39645442f, -0.37131399f, 0.42054436f, 0.32798275f, 0.22123049f, 0.15536161f, -0.26384684f, 
    -0.09456918f, -0.16201641f, 0.04529191f, 0.03536879f, 0.23517451f, -0.18433298f, -0.03945998f, 0.01768975f, 
    -0.28449038f, -0.10692544f, -0.41202444f, 0.11756290f, -0.40454352f, -0.65300292f, -0.06242540f, -0.16521606f, 
    -0.13570543f, -0.16145845f, -0.20879973f, -0.06390766f, 0.25904325f, 0.29546034f, 0.26344210f, 0.09540813f, 
    0.00817137f, -0.03272182f, 0.26917574f, -0.21753849f, -0.07427771f, 0.03400372f, 0.12704845f, 0.08510717f, 
    -0.06864683f, -0.03502890f, 0.19907254f, 0.04339991f, -0.02534689f, -0.06021826f, 0.33409807f, 0.29745877f, 
    -0.06944048f, -0.46295434f, -0.08492322f, -0.01887436f, -0.06660748f, -0.17168710f, 0.27500239f, -0.36062831f, 
    -0.28660274f, -0.44852310f, 0.31372315f, 0.28086987f, -0.31814027f, 0.15134783f, -0.04824585f, -0.08564892f, 
    -0.09656119f, 0.13160916f, 0.36902106f, -0.48051056f, 0.31186518f, 0.04269790f, -0.45776042f, -0.36004490f, 
    0.10409223f, 0.10571744f, -0.10467733f, -0.01144701f, 0.30051503f, 0.20083597f, -0.03844367f, -0.00037421f, 
    -0.02438154f, -0.11761555f, 0.06782085f, -0.20880137f, -0.46998179f, 0.00119178f, -0.02973803f, -0.60178483f, 
    -0.11518441f, -0.54905039f, 0.05999687f, 0.05841200f, 0.23620404f, 0.08922093f, -0.65020949f, 0.08965573f, 
    0.04345859f, -0.11959746f, -0.02215226f, -0.12759478f, 0.08012506f, -0.03329105f, -0.01751314f, 0.11711133f, 
    0.10842282f, -0.06170863f, -0.30153880f, 0.51742220f, 0.27704632f, -0.03421994f, 0.14067082f, 0.12901878f, 
    0.11614959f, 0.26255322f, -0.07792241f, 0.05212324f, 0.01450578f, -0.10815872f, -0.63064653f, -0.27609605f, 
    -0.30922836f, -0.00139775f, 0.19970733f, -0.27939180f, -0.27716246f, -0.48835704f, 0.26366347f, -0.00895113f, 
    -0.23978578f, 0.04017147f, 0.05282610f, 0.02531512f, -0.42432871f, 0.30038682f, 0.15775843f, 0.01758194f, 
    -0.27523276f, 0.07156314f, 0.09699243f, -0.11502157f, 0.13550697f, 0.03547367f, -0.11167005f, -0.13030894f, 
    -0.07628991f, 0.09945264f, 0.16435996f, 0.43106997f, 0.17481866f, -0.04131559f, 0.21400335f, 0.44102550f, 
    0.10787281f, -0.22960795f, -0.38535661f, 0.09755948f, 0.30677190f, -0.18612134f, -0.06900919f, 0.01423462f, 
    -0.28013775f, -0.08853191f, -0.27164155f, 0.32254606f, -0.07087772f, 0.02133506f, -0.43197578f, 0.07610448f, 
    -0.11406156f, -0.02529921f, -0.74728876f, -0.19235578f, 0.24206106f, -0.34074536f, -0.38716006f, 0.07000336f, 
    0.06748250f, 0.05155455f, -0.00985545f, 0.11152006f, -0.03791871f, -0.80980521f, -0.15165031f, -0.11155019f, 
    -0.49862361f, 0.11800864f, -0.13879338f, 0.08168523f, 0.19803961f, -0.24012400f, 0.28360179f, -0.05570645f, 
    -0.18933822f, -0.52747315f, 0.07391154f, -0.07683933f, -0.42732102f, 0.08706181f, 0.25449750f, 0.28237930f, 
    -0.09915002f, -0.31013608f, -0.11397316f, -0.04072421f, -0.11745361f, -0.51904005f, 0.09980963f, -0.05167381f, 
    0.36194405f, -0.01397310f, 0.02040059f, -0.21355624f, 0.03212476f, 0.01558643f, 0.03267747f, 0.10087609f, 
    0.00051012f, 0.18241572f, 0.32139477f, 0.09238077f, -0.03603737f, 0.24029467f, -0.10256196f, 0.01962840f, 
    -0.31177515f, 0.03040282f, 0.18504275f, -0.17995574f, -0.11041671f, 0.05986675f, 0.37453818f, 0.06656156f, 
    -0.02294520f, -0.00253148f, -0.83401716f, 0.28525060f, -0.17670964f, 0.13111326f, 0.23652612f, -0.35744947f, 
    0.06716766f, 0.18990950f, 0.08149817f, 0.04280103f, 0.04222078f, 0.07225741f, 0.33048293f, -0.48261666f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.00338620f, -0.10138348f, -0.03878134f, 0.02666014f, -0.00469881f, 0.02361387f, 0.12670711f, -0.18787183f, 
    -0.09785935f, 0.04512336f, 0.12600671f, 0.04405073f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
