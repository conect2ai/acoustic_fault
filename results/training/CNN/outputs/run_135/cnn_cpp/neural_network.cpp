#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.68129152f, 0.09533732f, 0.06783968f, -0.36462933f, 0.47778490f, -0.80590051f, -0.52142215f, -0.17653108f, 
    -0.76794040f, -0.81583929f, -0.09613826f, 0.29492635f, 0.26024899f, 0.29924026f, 0.24162489f, 0.22726192f, 
    -0.14707062f, 0.37864104f, 0.39400795f, 0.17904493f, 0.05912423f, -0.13950977f, 0.06305561f, 0.37144363f, 
    0.26957592f, 0.11436802f, -0.06179858f, 0.98165911f, 0.99489498f, 0.66213852f, 0.55419469f, 0.05281181f, 
    -0.04578602f, -0.49495429f, -0.07834130f, -0.24718787f, -0.10221207f, -0.07330250f, 0.38707858f, 0.18400156f, 
    0.20809837f, 0.05602837f, 0.07445794f, -0.02060035f, 0.11480636f, -0.01083428f, -0.01272635f, -0.12609936f, 
    -0.09999401f, 0.22194089f, 1.11105776f, 0.79651558f, -0.99304581f, -0.77097410f, -0.53984153f, -0.08713307f, 
    0.01182752f, -0.22691198f, 0.12353919f, -0.01567217f, -0.13092519f, 0.04779556f, 0.10206189f, 0.12748335f, 
    -0.00439505f, -0.10711991f, -0.07050426f, -0.07346587f, 0.00608845f, 0.16521576f, 0.24316631f, -0.09865136f, 
    -0.12083112f, 0.00877950f, 0.29393834f, 0.23642962f, -0.88459718f, 0.50267184f, 0.77570498f, 0.58618170f, 
    -0.93929940f, 0.34744343f, 0.07195065f, -0.30604786f, 0.36213785f, 0.41673273f, 0.39777961f, 0.14905688f, 
    0.04760126f, 0.14403695f, -0.59941244f, -0.07003046f, 0.08811547f, 0.19989255f, -0.15748899f, -0.12683992f, 
    0.02651221f, 0.07163406f, -0.13422586f, -0.14463457f, -1.23485208f, 1.28247762f, 0.51898324f, -0.78677285f, 
    0.24667828f, -0.13527009f, -0.16427630f, 0.07804117f, -0.07748096f, -0.39371216f, -0.32574889f, -0.11093856f, 
    -0.32996014f, 0.20585945f, -0.24310754f, -0.26513907f, -0.12910120f, -0.29599985f, -0.24451979f, -0.21001808f, 
    -0.03741753f, 0.02281063f, 0.14056896f, 0.21484220f, 0.09709279f, -0.48733971f, -0.98428386f, -0.84841555f, 
    -0.46898711f, -0.53453153f, -0.36571601f, 0.54902929f, 0.63856697f, 0.20475778f, 0.43830192f, -0.17563674f, 
    0.00102560f, 0.07776003f, 0.06182836f, -0.33391848f, -0.06340335f, -0.04307660f, 0.02036997f, -0.08881459f, 
    0.19676918f, -0.05334029f, 0.03911697f, -0.11047813f, -0.21020409f, 0.36717072f, -0.00743636f, 0.23394974f, 
    -0.52696717f, -0.63452458f, -0.09315688f, -0.09608657f, -0.76785541f, -0.25270665f, 0.58030844f, -0.40842807f, 
    -0.36351293f, -0.53650171f, -0.31737787f, -0.09177230f, -0.16547880f, 0.22655362f, 0.14985721f, -0.53314590f, 
    0.11904860f, -0.13845687f, -0.15850991f, 0.15894565f, 0.19012490f, 0.22929159f, 0.28458515f, -1.00367153f, 
    -0.68710124f, -0.26767164f, 0.30490798f, 0.55767471f, -0.45123255f, 0.92301130f, 0.42417392f, -0.35945657f, 
    0.07098808f, 0.06084920f, -0.19742973f, 0.30774054f, -0.05212004f, 0.20472066f, 0.13796115f, 0.29166332f, 
    0.32511318f, 0.00711358f, -0.20178278f, 0.10913671f, -0.13302907f, -0.20947717f, 0.14850686f, -0.19664584f, 
    0.14071485f, -0.25906524f, -0.02593406f, 1.02722955f, 0.12250865f, 0.48839179f, 0.68424922f, 0.20146187f, 
    0.18864007f, 0.36123490f, 0.06871051f, 0.29633886f, -0.05104088f, -0.22338367f, 0.22351444f, 0.16177166f, 
    0.02466829f, 0.20195128f, 0.24053510f, 0.19277714f, 0.38324976f, 0.40041891f, 0.15266660f, 0.31668484f, 
    -0.00400421f, -0.33534297f, -0.70893407f, 0.47864375f, 0.17201346f, -0.69855213f, 0.01113188f, 0.02044952f, 
    0.87253064f, 0.28386858f, -0.32220617f, -0.26645267f, -0.35544235f, -0.28589135f, -0.38005111f, -0.49129745f, 
    0.20782186f, 0.17207478f, -0.49494958f, -0.12165359f, -0.35115236f, -0.06699285f, -0.15024531f, 0.10150441f, 
    0.05515188f, -0.15098310f, 1.29612732f, 0.62607545f, 0.63464677f, 0.44856760f, 0.64752340f, -0.68566686f, 
    -0.32832992f, -0.16915852f, -0.01207411f, 0.18708050f, -0.33649901f, -0.42796201f, 0.24093202f, 0.13819633f, 
    0.08949960f, -0.18287440f, 0.05461686f, -0.12121390f, -0.20036978f, -0.04898022f, 0.20236744f, 0.04649584f, 
    0.20037772f, -0.03999949f, -0.15067853f, -0.93134475f, 0.89016962f, 0.85038692f, -0.76013458f, -0.42389938f, 
    0.51035380f, 0.58980381f, 0.03351003f, 0.35880452f, 0.10877810f, 0.40076700f, 0.21852241f, -0.19060151f, 
    -0.29217687f, -0.03907720f, 0.21725775f, -0.05621359f, -0.09233742f, -0.17334396f, -0.03526581f, 0.11510520f, 
    -0.03854594f, 0.07197738f, -0.07180912f, -0.13782914f, -0.86789930f, -0.27138728f, 0.48917335f, 0.14318572f, 
    -0.54794127f, 0.70177758f, 0.04605918f, -0.27964205f, -0.29284847f, 0.08128206f, -0.35691184f, -0.29686093f, 
    0.04416894f, 0.22559194f, 0.14841710f, -0.49554032f, -0.03495266f, -0.13144852f, -0.04688135f, -0.06303275f, 
    -0.20458674f, 0.09497133f, -0.18328789f, 0.27770433f, -0.49389568f, -0.71701539f, -0.59556007f, -0.01317157f, 
    -0.37575549f, 0.24632421f, -0.68651009f, 0.04283543f, -0.25306481f, -0.55548447f, -0.20280081f, -0.22902222f, 
    0.20366617f, -0.01009269f, 0.11355342f, 0.16703478f, 0.31772798f, -0.48529243f, -0.17273115f, -0.45530939f, 
    -0.29921272f, -0.14747341f, 0.34339586f, 0.17065841f, 0.28811428f, -0.24064405f, 0.76263165f, -0.38467169f, 
    -0.70807958f, -0.92319465f, -0.00057222f, -0.09479856f, 0.54961389f, -0.03319576f, -0.47308236f, 0.30504620f, 
    -0.34085286f, 0.11891447f, 0.33214086f, -0.08784114f, -0.10560615f, -0.01343660f, 0.24773382f, 0.22169760f, 
    0.03694809f, -0.04578421f, 0.10303945f, -0.02520738f, 0.01942669f, -0.08192134f, -0.28663388f, 0.19736591f, 
    0.15732619f, -0.11969550f, 0.34021673f, 0.41086167f, 0.51164508f, 0.77585793f, 0.66035295f, 0.61891079f, 
    0.47685903f, 0.35925883f, 0.03459086f, -0.45854607f, -0.21332107f, -0.02500361f, -0.15010934f, -0.42661735f, 
    -0.33777830f, 0.05986532f, -0.08842645f, 0.05005354f, 0.14520723f, 0.09293053f, -0.25734964f, -0.06531521f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.41289243f, 0.33971170f, 0.25147483f, 0.21831124f, 0.19210812f, 0.05436209f, 0.04176849f, 0.11709138f, 
    0.15821935f, 0.13335983f, 0.16446705f, -0.07632638f, 0.07099949f, 0.31323236f, 0.21886435f, 0.14280736f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06838980f, -0.10416603f, 0.03307516f, 0.07938740f, -0.03909947f, -0.12729084f, -0.02860132f, -0.01361246f, 
    0.13452697f, -0.14302258f, 0.08369106f, -0.07583936f, -0.15615334f, 0.20601341f, -0.23333940f, -0.08796456f, 
    0.27899262f, -0.19575636f, -0.05012686f, -0.02273847f, -0.07930680f, -0.16814952f, -0.07663047f, -0.01048705f, 
    -0.25493610f, -0.07590698f, 0.21469727f, 0.11095274f, -0.06380960f, -0.08615074f, 0.22851536f, 0.06483800f, 
    0.03815612f, -0.01018320f, -0.10058692f, 0.08106156f, 0.06047319f, -0.10568614f, 0.09249809f, -0.13044165f, 
    0.05005905f, -0.08803244f, -0.00662113f, -0.16796781f, -0.04379598f, 0.10858651f, -0.26386136f, -0.19442886f, 
    0.24005638f, -0.09298039f, 0.23085716f, -0.06141555f, -0.00883115f, -0.12410618f, -0.07422061f, -0.03717447f, 
    -0.15083769f, -0.03170008f, 0.11718339f, 0.14797087f, -0.04401829f, 0.10769772f, 0.14658059f, 0.15193231f, 
    0.06091534f, 0.22533485f, 0.13057733f, 0.18409273f, -0.02614275f, 0.13796563f, 0.18779227f, 0.03806312f, 
    0.16610953f, 0.08749496f, 0.21186545f, 0.17938666f, -0.04800069f, -0.02548419f, 0.06088635f, 0.05440491f, 
    0.11263569f, 0.14959504f, 0.23489690f, 0.14806180f, -0.16488792f, -0.08950255f, 0.01939939f, -0.01766815f, 
    0.09385672f, -0.15016581f, 0.01676157f, 0.10006273f, 0.04178206f, -0.00891948f, -0.08357965f, 0.00770156f, 
    -0.22146803f, 0.04868216f, -0.23800832f, -0.24706759f, 0.15606610f, -0.04282066f, -0.10713968f, -0.01168711f, 
    0.13184811f, -0.06179096f, 0.09149900f, -0.24099955f, 0.54015726f, 0.02074276f, 0.00767993f, 0.07582401f, 
    0.17223047f, 0.11826703f, 0.05541758f, 0.22914995f, 0.04591510f, 0.03155484f, 0.13313231f, 0.19391775f, 
    -0.18949592f, -0.13193025f, 0.18453749f, 0.09133721f, -0.07671586f, 0.09429593f, -0.06361217f, -0.18801810f, 
    -0.14494336f, -0.18224174f, -0.06044531f, 0.02689197f, 0.52383846f, 0.20835613f, 0.01581398f, -0.08021367f, 
    0.05328050f, -0.02145916f, 0.14081933f, -0.03264401f, -0.00892294f, 0.11984792f, 0.06197968f, -0.01845394f, 
    0.19284719f, 0.04287538f, -0.03530424f, -0.18879203f, 0.05683259f, 0.04649483f, 0.06755938f, 0.09721594f, 
    -0.02127602f, -0.04448977f, 0.13465948f, 0.20318022f, 0.09350228f, -0.18917136f, 0.10177612f, 0.35146040f, 
    0.06022464f, 0.01959576f, -0.17638586f, 0.05624096f, 0.01275358f, 0.06943958f, 0.14072227f, 0.04804145f, 
    -0.44982237f, -0.00204389f, 0.10697094f, 0.33122700f, 0.01913133f, -0.00989314f, -0.07647980f, -0.02168397f, 
    0.00467873f, 0.14849901f, -0.11543553f, 0.13426915f, -0.13097632f, 0.13580957f, -0.14156659f, -0.20805056f, 
    -0.01809182f, 0.05860715f, -0.06269853f, -0.12387317f, 0.01732970f, -0.01882550f, 0.22218521f, 0.01176253f, 
    -0.00256258f, -0.06432857f, 0.06499209f, -0.06418369f, 0.04136351f, -0.07358395f, -0.03225833f, 0.06297610f, 
    0.04149428f, -0.03883653f, 0.00667177f, 0.01114717f, 0.04660012f, -0.04700304f, -0.01058987f, 0.01691929f, 
    0.04031695f, -0.04300614f, -0.05222489f, 0.03195750f, -0.05336705f, -0.02806000f, -0.06456839f, -0.04744152f, 
    -0.02818214f, -0.04672832f, -0.02745950f, -0.05551764f, -0.02477924f, -0.02492291f, 0.00286322f, 0.03240422f, 
    -0.04169021f, -0.07378649f, 0.00290458f, -0.04695906f, 0.04886237f, 0.04553602f, 0.02855818f, -0.04908533f, 
    0.00746945f, 0.02815107f, 0.03352880f, -0.04611959f, -0.01624864f, -0.03168941f, 0.02539770f, 0.00451568f, 
    -0.00070903f, -0.04713845f, -0.02100989f, -0.02756856f, -0.05325633f, 0.06033454f, 0.01886371f, -0.01945922f, 
    -0.03613415f, -0.01788969f, 0.06018063f, 0.03190159f, -0.05530559f, -0.06038378f, -0.01194838f, -0.04041554f, 
    0.01437465f, -0.04032424f, 0.01030903f, 0.05667907f, -0.02078487f, -0.00466612f, 0.02392756f, 0.03878735f, 
    -0.00207465f, -0.05501127f, -0.02048573f, -0.06525434f, -0.00347730f, 0.00985586f, 0.01096095f, -0.07263181f, 
    -0.05791974f, -0.01814415f, -0.03780752f, 0.03161067f, -0.05435467f, -0.02742271f, -0.06220771f, -0.01667845f, 
    -0.07639454f, -0.07278212f, -0.04459636f, -0.06819841f, 0.04774318f, 0.00982959f, -0.07319564f, 0.06890849f, 
    -0.00161037f, -0.05696474f, -0.00926234f, -0.00349839f, 0.02897758f, 0.04419011f, 0.00378646f, -0.00344131f, 
    -0.02816017f, -0.03588978f, 0.00655358f, -0.06968459f, 0.00058788f, -0.01923985f, 0.01768506f, -0.00738779f, 
    -0.05910360f, -0.04839516f, 0.05554900f, 0.03281037f, -0.03783547f, 0.00357984f, 0.06042366f, -0.05983410f, 
    0.05004723f, -0.04238282f, -0.05084839f, 0.03523497f, -0.07365386f, -0.03603626f, 0.02616840f, 0.05595449f, 
    -0.06926772f, -0.07446161f, 0.05173352f, -0.05494326f, -0.01195461f, -0.00932885f, -0.03064834f, -0.00317573f, 
    0.06287929f, -0.07153226f, -0.06438890f, -0.03861118f, 0.02650535f, 0.02157651f, -0.00443463f, 0.03571427f, 
    0.02130183f, 0.03649756f, 0.05004656f, 0.02318569f, 0.04639722f, -0.05519164f, -0.01167562f, 0.06561722f, 
    0.03288214f, 0.03873318f, 0.05340428f, -0.07791127f, 0.01125169f, -0.05562060f, -0.03699251f, -0.01858573f, 
    -0.04448782f, 0.06286996f, 0.02653922f, 0.01971129f, 0.01920912f, 0.06200700f, 0.03089606f, 0.06514185f, 
    -0.04540198f, -0.01320308f, 0.00666718f, -0.01830902f, -0.02028549f, -0.03447012f, 0.03234271f, -0.06032714f, 
    -0.06659763f, -0.00907853f, -0.02622129f, -0.06949123f, 0.04904420f, -0.06124844f, 0.00261593f, 0.02457479f, 
    -0.07815803f, -0.03096358f, 0.05184541f, 0.04254109f, -0.04755312f, 0.00048113f, -0.04100833f, -0.07014742f, 
    0.01254462f, 0.17156026f, 0.29769504f, -0.01105741f, 0.00164292f, -0.02168061f, 0.07713784f, 0.02731189f, 
    -0.02554348f, 0.05203201f, 0.19261628f, 0.11183093f, -0.18096735f, 0.15297140f, 0.18250991f, 0.40472350f, 
    -0.03512412f, 0.10205102f, -0.08010205f, 0.06707514f, 0.01111382f, 0.07567682f, 0.11733773f, 0.07095528f, 
    0.07113610f, -0.50736576f, -0.13040772f, -0.12441353f, -0.19275317f, -0.03551568f, 0.09777649f, 0.12706399f, 
    -0.10317429f, -0.07210092f, -0.10303762f, 0.06424881f, -0.28143430f, -0.13891988f, 0.22054188f, 0.18740828f, 
    0.01249363f, 0.07076245f, -0.15570997f, 0.04193385f, 0.01199243f, 0.07472298f, 0.02099067f, -0.05497993f, 
    0.29444891f, 0.68238461f, -0.16094375f, -0.08504625f, 0.01256866f, 0.07005998f, 0.10081463f, 0.03942334f, 
    0.05485872f, 0.09455320f, -0.09318352f, -0.01931625f, -0.03562698f, -0.09479135f, -0.13117516f, -0.01014108f, 
    -0.08386859f, -0.09391005f, -0.03088809f, 0.16087994f, 0.01079082f, -0.11143315f, 0.16830300f, 0.06475896f, 
    0.00771007f, -0.21547562f, 0.03980877f, 0.04690406f, -0.00010623f, 0.05081880f, 0.10303607f, -0.04458772f, 
    -0.02167314f, -0.04512460f, -0.05605800f, 0.07422783f, -0.44972101f, 0.26227164f, -0.16727173f, -0.01336288f, 
    0.05447393f, -0.05379937f, 0.04339338f, 0.00756634f, 0.02767215f, 0.07921883f, -0.04555998f, -0.03885426f, 
    -0.22533320f, 0.18918110f, -0.00992485f, 0.02665119f, -0.08873799f, -0.17830859f, -0.07256848f, 0.20623048f, 
    0.19833313f, -0.00331165f, 0.04142680f, 0.15539213f, -0.34994948f, -0.22691941f, 0.06056353f, -0.05482493f, 
    -0.07613368f, -0.05395352f, 0.09441586f, 0.01909794f, 0.02280469f, 0.03478893f, -0.10686755f, 0.18416831f, 
    -0.07579251f, -0.20694095f, 0.36458495f, 0.27218074f, -0.05441013f, 0.11593884f, 0.00094386f, 0.03439473f, 
    0.14002150f, 0.11000395f, -0.00939084f, -0.01548203f, -0.10464007f, 0.42386189f, -0.06219194f, -0.18789187f, 
    0.02788921f, -0.04283972f, -0.08020480f, 0.05183150f, -0.01101695f, -0.00892580f, 0.06555836f, 0.12420390f, 
    -0.05835437f, 0.05779322f, 0.00826500f, -0.21042450f, -0.07194719f, -0.16449291f, 0.04906353f, 0.01084991f, 
    -0.16192247f, -0.02162656f, -0.09474977f, -0.12939201f, -0.00712412f, 0.14629066f, 0.12549071f, -0.05982503f, 
    0.06558721f, -0.02921990f, -0.00506805f, 0.13803349f, 0.00720299f, 0.11454272f, 0.00254595f, -0.01327950f, 
    0.14090447f, -0.26288152f, 0.30440453f, -0.18020350f, -0.00739232f, 0.04580540f, 0.05538606f, -0.06745867f, 
    0.19578151f, 0.00479695f, 0.09351740f, 0.11808869f, 0.24357098f, 0.07447284f, -0.04778668f, 0.05349744f, 
    -0.13159184f, -0.03825217f, 0.11570632f, -0.17522711f, 0.02322467f, -0.03623693f, -0.01536047f, 0.09947732f, 
    -0.01757668f, 0.00676677f, 0.04205609f, 0.04729375f, -0.03686574f, 0.05471186f, -0.02132918f, -0.04619341f, 
    0.01359697f, 0.04760218f, -0.01558409f, -0.04560880f, -0.05033650f, 0.07502017f, -0.02698839f, -0.05181113f, 
    0.01577228f, 0.02185068f, -0.02603305f, 0.07078603f, 0.02233815f, -0.06953816f, 0.04385635f, -0.05045383f, 
    -0.08570661f, 0.04471300f, -0.00708121f, -0.00243816f, -0.00455440f, -0.06363757f, -0.01556667f, -0.00715450f, 
    -0.07558093f, -0.02737165f, 0.00999856f, -0.03271425f, -0.01070637f, 0.06914573f, -0.03248188f, 0.00546924f, 
    0.00390003f, 0.04246219f, 0.00843788f, 0.02289920f, -0.01873000f, 0.03567345f, -0.05941065f, -0.00084728f, 
    -0.07138111f, -0.04538693f, -0.01110800f, -0.07654731f, 0.03749492f, 0.02909571f, -0.08237653f, -0.00710198f, 
    -0.01430388f, -0.03549818f, -0.08325440f, -0.03480747f, -0.01595320f, 0.04568353f, 0.01127606f, -0.08643272f, 
    -0.06028822f, 0.04813835f, -0.02648713f, -0.06413425f, 0.02625093f, 0.02801133f, 0.06831377f, -0.03313047f, 
    -0.04454937f, -0.07957032f, 0.00168767f, -0.02930858f, 0.03549931f, -0.07235689f, -0.03032277f, 0.00686975f, 
    -0.01155541f, -0.04336679f, -0.03577848f, -0.05569532f, 0.06648260f, -0.00367482f, 0.04069730f, -0.01304314f, 
    0.03028459f, 0.03221624f, 0.02665706f, -0.02878676f, 0.03141162f, -0.08985912f, 0.03372981f, -0.05983538f, 
    -0.03811809f, -0.06669720f, -0.05202876f, 0.03017676f, 0.03299142f, 0.03949549f, -0.04977581f, -0.01525092f, 
    0.02888096f, -0.03577236f, 0.05290142f, 0.05601235f, 0.01712236f, 0.00423810f, 0.03698365f, -0.01860633f, 
    0.01626022f, -0.00384915f, -0.00632022f, -0.00818713f, -0.04473415f, 0.04475980f, -0.04144336f, 0.04075688f, 
    0.00118006f, -0.01823895f, 0.00428114f, 0.05917991f, 0.04200043f, 0.02807356f, -0.03165480f, -0.00874097f, 
    0.02973999f, -0.07142571f, -0.01059492f, -0.00803130f, 0.03667462f, -0.04521891f, -0.03090453f, -0.03853687f, 
    0.00625828f, 0.03919254f, 0.02311839f, -0.04597756f, -0.01511805f, 0.02353244f, -0.07700599f, -0.07280075f, 
    -0.01742166f, -0.01448084f, 0.01697912f, 0.03739618f, -0.01745269f, 0.05234218f, -0.03634265f, -0.01921934f, 
    -0.06308651f, -0.04698322f, -0.03648550f, 0.02450675f, 0.03387835f, -0.05006273f, 0.03485161f, -0.08830318f, 
    -0.07134198f, -0.05899053f, -0.03980221f, -0.00350488f, -0.06516012f, 0.01653355f, -0.08114236f, -0.01176694f, 
    0.05800597f, -0.01882715f, -0.06522598f, 0.02157194f, 0.05028526f, 0.01381226f, 0.05832487f, 0.03677650f, 
    -0.02584677f, -0.05867540f, 0.01764349f, 0.06809372f, 0.00627383f, 0.00991140f, -0.01249558f, -0.05204136f, 
    -0.00092589f, -0.06723791f, -0.05658194f, -0.00332168f, -0.00489332f, 0.03200862f, 0.04846972f, 0.01451444f, 
    -0.29219332f, 0.16387843f, 0.16601172f, 0.21734640f, 0.06208933f, -0.00634514f, 0.12040238f, 0.13781646f, 
    0.08204883f, -0.08926415f, -0.19512293f, -0.21511415f, -0.05842879f, -0.07474256f, -0.15558134f, -0.03115396f, 
    -0.09864862f, 0.01688356f, -0.02865725f, 0.00044820f, -0.04680587f, -0.07191322f, -0.06778720f, 0.02524127f, 
    0.02734281f, -0.05267595f, 0.27107844f, -0.13984419f, -0.01210816f, -0.06679539f, 0.09302072f, 0.10176884f, 
    0.10385118f, 0.13952881f, -0.04039351f, 0.24457167f, -0.39417809f, -0.05557719f, -0.17531277f, 0.15359244f, 
    -0.05575715f, -0.00827822f, -0.00025577f, -0.14052173f, -0.04646995f, 0.05341789f, -0.07652661f, 0.07324378f, 
    0.23915659f, 0.23017065f, 0.01374856f, -0.21129419f, 0.07153238f, 0.04179715f, -0.05983493f, 0.08983850f, 
    -0.09246772f, 0.02059827f, 0.12612323f, 0.17010765f, 0.13949552f, 0.06212021f, -0.09900502f, -0.23595081f, 
    -0.16409439f, -0.04955684f, 0.15877497f, 0.15729871f, -0.14104454f, 0.10055461f, -0.03439869f, 0.00290181f, 
    0.30906570f, -0.01487437f, 0.10354012f, -0.09482130f, -0.13219444f, -0.04643242f, 0.15983556f, -0.03281043f, 
    0.02429058f, 0.07458444f, 0.26018974f, 0.01867458f, 0.08835913f, 0.30691776f, 0.11584533f, 0.12113017f, 
    -0.00522890f, 0.06155965f, -0.05302897f, 0.15307452f, -0.00329953f, 0.01851253f, 0.01258035f, 0.07699699f, 
    -0.24149309f, 0.02399567f, -0.17849647f, 0.10963615f, -0.02476864f, 0.02334150f, 0.08276413f, -0.08648606f, 
    -0.12750141f, -0.16516116f, -0.05692219f, -0.07226488f, 0.04105902f, 0.11747818f, 0.12045709f, 0.04125072f, 
    -0.10025575f, -0.00085074f, -0.12943624f, -0.06640727f, 0.00896137f, 0.16017070f, 0.14729948f, -0.08898746f, 
    0.29948059f, -0.08390221f, -0.22579248f, 0.21809937f, 0.01514763f, 0.10683707f, 0.05178407f, 0.04559106f, 
    -0.03281596f, -0.08686435f, -0.11125679f, 0.00048751f, -0.14270023f, 0.26361653f, 0.30110613f, -0.24140029f, 
    -0.02206462f, 0.18279546f, 0.01438135f, -0.02125760f, -0.00734854f, -0.05524644f, 0.00746242f, -0.17762738f, 
    -0.08113892f, 0.06195111f, 0.02731972f, 0.00700536f, 0.16133094f, -0.01082703f, -0.09370510f, 0.12089367f, 
    0.06592674f, 0.03438763f, -0.08367044f, 0.12386162f, -0.16157624f, 0.15748203f, -0.01858046f, 0.24879543f, 
    0.00522566f, -0.08871707f, -0.09023880f, 0.10660820f, 0.03254315f, 0.06410567f, 0.07593849f, -0.05522887f, 
    0.01853317f, -0.07143494f, 0.13572128f, 0.09150130f, 0.19329031f, 0.06816193f, -0.03758308f, 0.05420412f, 
    -0.23757353f, 0.17062908f, -0.04589549f, 0.11161871f, -0.35176900f, 0.03564933f, -0.08640309f, -0.10248589f, 
    0.19438353f, 0.26717997f, 0.04094605f, -0.10571379f, -0.12129276f, 0.04953965f, 0.23412834f, 0.06400648f, 
    -0.21015637f, -0.08533654f, -0.16472387f, 0.06088231f, 0.04416257f, -0.02997227f, 0.11595068f, -0.03079038f, 
    -0.05851778f, -0.12667216f, -0.04696824f, -0.06017296f, 0.39869288f, 0.02544791f, 0.05925170f, -0.11900768f, 
    0.17116851f, 0.02315217f, 0.07263021f, 0.05663081f, 0.06503731f, -0.03401273f, -0.11321169f, 0.09442007f, 
    0.08937354f, 0.39552525f, 0.00066248f, 0.26792148f, 0.16372186f, 0.10027117f, -0.01161960f, -0.11536370f, 
    0.10991914f, 0.06479894f, 0.09603171f, -0.08223828f, -0.03321376f, 0.14148314f, -0.08180892f, -0.07748404f, 
    0.29200718f, 0.04976990f, -0.01007546f, -0.03722186f, 0.16217604f, 0.01563840f, 0.13312468f, 0.14638375f, 
    0.01091304f, -0.30335361f, 0.02367950f, -0.00870905f, -0.06261437f, -0.07942470f, 0.05887637f, -0.01635333f, 
    0.04771526f, -0.01818263f, 0.21556312f, 0.17796668f, -0.50129491f, -0.02812625f, 0.12627517f, 0.29562974f, 
    0.01612896f, 0.04003087f, -0.01969173f, 0.02961064f, -0.00485305f, 0.15753201f, 0.08807759f, 0.00085524f, 
    -0.13072321f, -0.03226402f, -0.31423160f, 0.03223257f, -0.01290851f, 0.04960803f, -0.06191294f, 0.06600361f, 
    0.00790431f, -0.00951750f, 0.00613771f, -0.02905564f, -0.02187482f, 0.05500718f, 0.05985419f, 0.11109725f, 
    -0.05374652f, -0.02861764f, 0.14644571f, -0.07103131f, -0.00138572f, -0.03695867f, -0.02694718f, -0.02168006f, 
    0.04516663f, -0.00170909f, 0.03971437f, 0.13919975f, -0.03136492f, 0.08703941f, 0.07387296f, -0.09931061f, 
    0.00934043f, -0.06083736f, -0.17830345f, -0.16905950f, -0.05898853f, 0.02153577f, -0.06967915f, -0.15996604f, 
    0.01640149f, -0.04470778f, 0.01570558f, 0.00138911f, -0.09644356f, 0.11584281f, 0.15887891f, 0.13009737f, 
    0.19082750f, 0.38824436f, 0.02043754f, -0.00748384f, 0.15289350f, 0.13395302f, 0.04669581f, 0.11207214f, 
    0.16103286f, 0.06816819f, -0.01131166f, 0.08791789f, 0.32031709f, 0.00922745f, -0.08271080f, 0.15510051f, 
    0.02156198f, 0.13108243f, 0.18237497f, 0.08710237f, -0.05354238f, 0.10286329f, -0.00336537f, 0.02258234f, 
    -0.06615633f, -0.27345061f, 0.09090331f, -0.42208639f, -0.01629733f, 0.24624808f, 0.03719804f, 0.02139867f, 
    0.11168955f, 0.12400273f, 0.08258755f, 0.19195849f, -0.27043569f, -0.12318024f, -0.11783698f, -0.05112328f, 
    -0.04187091f, -0.04718262f, 0.22452432f, 0.00021448f, -0.00865917f, -0.01095239f, 0.15381029f, 0.10055368f, 
    -0.00588896f, 0.29536822f, -0.19500102f, 0.27071765f, 0.07956681f, -0.04075365f, -0.03621266f, 0.00072033f, 
    0.08860195f, -0.06756466f, -0.05393843f, 0.07685287f, -0.23868117f, -0.03451887f, 0.04960227f, 0.13776536f, 
    0.15551250f, 0.08327737f, 0.06937964f, 0.09656184f, 0.05180323f, -0.06375804f, 0.19797064f, -0.02096875f, 
    0.20891573f, 0.02405154f, 0.09488633f, -0.01973300f, 0.09732568f, 0.09744743f, 0.11543659f, 0.03033798f, 
    0.02662559f, -0.00586806f, -0.03025860f, -0.09538727f, -0.15908140f, -0.15040436f, 0.12813579f, -0.04138273f, 
    -0.00009667f, 0.16266030f, 0.04597348f, 0.03833972f, -0.09548734f, -0.08913023f, -0.05256849f, 0.01698662f, 
    0.13804305f, -0.17530164f, 0.46210256f, 0.03056956f, -0.01321345f, -0.07562074f, 0.21472126f, 0.10314736f, 
    0.03009720f, 0.10316797f, -0.01411919f, 0.11955412f, -0.17237909f, 0.13651662f, 0.23177239f, 0.06748608f, 
    -0.04917746f, 0.12005486f, 0.08161740f, 0.14184611f, 0.01270824f, -0.04524475f, -0.06205046f, 0.01334546f, 
    0.12507591f, -0.01048065f, 0.02248841f, -0.04913582f, 0.01379726f, -0.04282114f, 0.02457283f, 0.12451370f, 
    -0.00715870f, 0.08932180f, 0.16000600f, -0.03181823f, 0.39268637f, -0.31605136f, -0.34426937f, -0.39442322f, 
    -0.17050600f, -0.20005530f, 0.16866614f, 0.04267156f, -0.11635853f, 0.08579593f, -0.03871879f, 0.01441391f, 
    0.00819459f, -0.06572811f, 0.26217377f, -0.07265926f, -0.04828055f, -0.06496811f, 0.09594030f, 0.08376693f, 
    0.13190943f, 0.15103409f, 0.00955947f, -0.09586214f, 0.50653172f, 0.09787311f, 0.00063637f, 0.14322425f, 
    0.05570294f, 0.09462930f, -0.02628641f, 0.07833335f, 0.09460630f, 0.01768603f, 0.03080999f, 0.02615660f, 
    0.02227413f, 0.01864964f, -0.07706128f, -0.00237327f, 0.13313267f, -0.00093440f, -0.01112899f, -0.15355341f, 
    -0.13935910f, 0.10229459f, 0.04097259f, 0.03214735f, 0.28306627f, 0.04905502f, -0.07577507f, 0.02214890f, 
    0.06285109f, -0.10495435f, -0.05046875f, -0.07932939f, 0.00111850f, 0.13367036f, 0.01986918f, -0.09581714f, 
    -0.19165657f, -0.21825819f, -0.09048411f, 0.09181865f, 0.07339733f, -0.00435630f, 0.08862874f, 0.04268672f, 
    -0.16937365f, -0.11965901f, 0.06249644f, 0.17487326f, -0.67228872f, -0.27485067f, 0.20148192f, 0.00734473f, 
    0.02855485f, -0.07039321f, -0.21433266f, 0.03769908f, 0.09327384f, 0.01528281f, 0.06626572f, -0.14537236f, 
    0.20107983f, 0.11403218f, 0.04674480f, 0.30952513f, -0.04495425f, -0.05121805f, -0.05092892f, 0.07911826f, 
    0.00300473f, 0.02768391f, -0.01837922f, 0.24855842f, 0.29391792f, 0.29952887f, -0.03176054f, 0.14516805f, 
    0.05414333f, 0.05174100f, -0.31183931f, 0.10017321f, 0.08317987f, 0.13190749f, 0.04071856f, -0.07186189f, 
    0.08965356f, -0.16623324f, -0.14798744f, -0.06188350f, 0.25019333f, 0.27117276f, -0.00897439f, 0.20348664f, 
    -0.16665643f, 0.11457908f, 0.06024077f, 0.05397252f, -0.14663212f, 0.01383499f, -0.02082513f, -0.20769499f, 
    0.03036453f, 0.01864209f, -0.00862851f, -0.09247743f, -0.06316337f, 0.09316109f, 0.00603896f, -0.11150409f, 
    -0.03151454f, -0.01534783f, 0.00550401f, -0.22829248f, 0.04255785f, 0.07154749f, 0.05065250f, -0.07660015f, 
    -0.01542841f, 0.05982696f, 0.02928861f, 0.06019276f, 0.16700268f, -0.21183239f, 0.24397360f, 0.21318577f, 
    -0.03909953f, 0.04620697f, -0.04735063f, -0.05781686f, -0.03095161f, 0.01636999f, 0.01354054f, -0.02809676f, 
    0.41360149f, 0.01812977f, -0.18934840f, 0.07744976f, -0.02874647f, -0.01169397f, 0.00734195f, 0.11849128f, 
    0.00992151f, -0.02232578f, 0.03258776f, -0.10302938f, 0.25675684f, -0.04947502f, 0.22808035f, 0.16816777f, 
    -0.05715843f, 0.07804277f, -0.05017395f, 0.02305482f, 0.15667231f, -0.03289232f, 0.18076621f, 0.03865131f, 
    -0.04883004f, 0.14894043f, 0.00591828f, 0.07785356f, -0.00773693f, 0.00877657f, 0.04260952f, 0.01480128f, 
    -0.09678673f, -0.05371552f, -0.11230444f, -0.04673854f, -0.04350914f, -0.31030133f, -0.01687518f, -0.15069821f, 
    0.14055905f, 0.10079520f, -0.00416395f, -0.13419160f, -0.01394695f, -0.08216756f, 0.11848754f, 0.15809654f, 
    -0.22963426f, -0.16354991f, 0.05358865f, -0.21360682f, -0.06799291f, 0.08288700f, 0.07859784f, 0.17013367f, 
    0.05345580f, 0.05849970f, -0.08566641f, 0.04043851f, 0.03945722f, -0.00225797f, 0.03265729f, -0.05595170f, 
    0.02578409f, 0.03465791f, -0.08557764f, -0.01579023f, 0.13653523f, 0.05237230f, -0.05334186f, 0.08592252f, 
    0.35433170f, -0.07279298f, 0.07169487f, 0.10231768f, -0.15146822f, -0.00527152f, -0.05441706f, 0.02158340f, 
    0.00236578f, 0.04320536f, -0.10583226f, 0.00742173f, -0.23647965f, -0.13061462f, -0.11096031f, -0.02839920f, 
    -0.00201718f, -0.03250115f, -0.00769508f, 0.06969466f, 0.05722880f, 0.03883328f, -0.14769231f, 0.17974216f, 
    0.14596727f, 0.04987826f, 0.18781002f, 0.07284936f, -0.04386513f, -0.05582037f, 0.02910525f, -0.02800731f, 
    0.01999391f, 0.00513224f, 0.02688864f, 0.11940535f, -0.32254642f, -0.13598064f, -0.22266033f, 0.15333468f, 
    0.10402402f, -0.00357359f, -0.08036494f, -0.06202241f, 0.03003860f, -0.01711070f, 0.01328221f, 0.05059979f, 
    0.11412375f, -0.23252323f, 0.07649966f, 0.08629450f, -0.00951564f, -0.01043300f, 0.05083694f, 0.01842375f, 
    -0.05356934f, 0.10978977f, 0.04454508f, 0.04887852f, -0.11534834f, 0.10885657f, 0.05623570f, -0.15419747f, 
    0.12202743f, 0.02874457f, 0.04746310f, -0.15906438f, 0.05418149f, 0.02397479f, -0.01952524f, 0.02550941f, 
    0.26861435f, 0.10037308f, 0.04310833f, -0.23342472f, -0.03226367f, 0.10681070f, 0.06206684f, 0.06939892f, 
    0.15621915f, -0.10767597f, 0.02763884f, 0.03633983f, 0.29040208f, -0.03018893f, 0.06828189f, 0.08514550f, 
    -0.03587537f, -0.03232142f, -0.11684153f, 0.00378953f, 0.02656025f, 0.07851001f, -0.20958023f, 0.01494080f, 
    0.11605295f, -0.11137569f, -0.07579058f, -0.04269284f, -0.00345471f, -0.08054367f, -0.00992339f, -0.12689365f, 
    0.12038619f, 0.11314125f, 0.04775825f, 0.09087833f, 0.21279098f, -0.11274572f, -0.00369943f, -0.09317323f, 
    -0.02071319f, -0.19032899f, -0.08045956f, -0.06528468f, -0.04549698f, 0.10280999f, 0.13125877f, 0.03081212f, 
    0.23676920f, 0.52998155f, 0.11089460f, 0.06497305f, 0.01223097f, -0.01072180f, -0.14736483f, 0.14550097f, 
    0.10216768f, 0.13092160f, 0.17578004f, 0.03194630f, -0.33477604f, 0.03101201f, -0.04766858f, -0.27312192f, 
    0.20240943f, -0.04000393f, 0.04783509f, 0.14503168f, -0.12038305f, -0.05401901f, 0.04754125f, 0.03357432f, 
    -0.38671219f, -0.47216550f, 0.18257484f, 0.30321318f, -0.03357716f, -0.12202151f, -0.14722584f, -0.08434358f, 
    -0.04490979f, 0.05007519f, -0.05896575f, 0.07378414f, 0.02292646f, 0.16903138f, 0.29690635f, 0.02686007f, 
    0.09696631f, 0.05973554f, 0.03634614f, -0.18476717f, 0.01665190f, 0.04503485f, -0.15811941f, -0.09484305f, 
    0.09004388f, 0.15956371f, 0.12925096f, -0.11170992f, 0.02988908f, -0.00336147f, 0.01348294f, 0.17459112f, 
    -0.05846983f, -0.01713031f, -0.09120160f, 0.09443366f, 0.18701634f, -0.01707295f, 0.18383271f, 0.02795086f, 
    -0.05324435f, 0.03490589f, 0.10809363f, -0.14552027f, -0.02512743f, 0.07526609f, 0.08975590f, -0.10829770f, 
    0.19882087f, 0.00740611f, -0.02090695f, 0.18656074f, 0.04715246f, -0.05899596f, 0.15246198f, -0.09561974f, 
    -0.03714370f, -0.01991476f, -0.09167268f, 0.10193409f, 0.30609509f, 0.06483093f, 0.14828277f, -0.00703581f, 
    0.11000607f, -0.09640266f, 0.00595401f, -0.03695546f, -0.04246081f, -0.07536945f, 0.06217962f, 0.05023231f, 
    -0.08085326f, -0.08808612f, -0.26149505f, -0.04861283f, 0.01588360f, -0.02480481f, -0.03750019f, -0.05147214f, 
    0.06795958f, -0.13018702f, -0.03080280f, 0.07192671f, -0.40487984f, -0.17042920f, 0.00449956f, -0.06129320f, 
    0.14381705f, -0.02040247f, -0.02125274f, 0.02019060f, 0.00590729f, -0.04690342f, -0.10109714f, 0.11481606f, 
    -0.13537797f, 0.17122848f, 0.01983039f, 0.22502841f, 0.14860865f, -0.04368707f, -0.03777084f, -0.11531734f, 
    0.13030583f, 0.04974297f, 0.05563381f, 0.04388842f, 0.02854769f, 0.07808744f, -0.04437952f, 0.20857966f, 
    -0.12240394f, -0.02186300f, 0.16535306f, -0.18909580f, -0.08056849f, -0.02820231f, -0.06230300f, 0.18151656f, 
    0.25896755f, 0.26960972f, -0.17207669f, 0.18579772f, 0.14484607f, 0.16785571f, 0.11880022f, 0.07345172f, 
    0.05499323f, -0.09042321f, 0.08500727f, -0.10542256f, -0.02416773f, -0.01075349f, -0.16009866f, -0.00990030f, 
    0.04172348f, 0.05930183f, 0.02746754f, 0.05668395f, -0.07868963f, -0.02033965f, -0.19654547f, -0.14566126f, 
    0.18734556f, 0.03196448f, 0.01222646f, -0.03603369f, 0.04735623f, 0.10202891f, -0.13355631f, -0.16721517f, 
    -0.01926352f, 0.16351090f, -0.04452150f, 0.04235896f, -0.10447185f, -0.26330712f, 0.09328374f, 0.02654988f, 
    -0.07440528f, 0.04997894f, -0.04366940f, -0.03345731f, 0.05861857f, 0.02192739f, 0.13545123f, -0.11643837f, 
    0.09825729f, -0.09775250f, -0.28161311f, 0.32176262f, 0.09999023f, 0.06831513f, -0.07589494f, 0.01846571f, 
    0.03232463f, -0.01140613f, -0.02201213f, -0.14178507f, 0.46294740f, 0.09345612f, 0.03247047f, 0.02832486f, 
    -0.13110025f, 0.06927721f, -0.10274529f, 0.05006171f, -0.01533253f, 0.03481114f, 0.06532115f, -0.01494365f, 
    -0.00303375f, 0.22423604f, -0.01849401f, 0.11533305f, -0.03423974f, 0.10393748f, 0.11180475f, -0.02700911f, 
    0.03897597f, 0.06307809f, -0.16711602f, -0.03238440f, 0.49609342f, -0.06351204f, 0.14443278f, 0.01250727f, 
    0.04226002f, -0.00279992f, 0.05727657f, -0.11220844f, 0.13890749f, -0.10565498f, 0.12115161f, -0.02051646f, 
    -0.15606275f, 0.05299124f, -0.01657621f, 0.13745835f, 0.01386237f, 0.00157976f, 0.02603026f, -0.09658904f, 
    0.01147750f, 0.15299429f, -0.02060898f, 0.05494500f, 0.12511399f, -0.25121352f, 0.02659027f, -0.11952616f, 
    -0.02908068f, 0.10025384f, -0.06063980f, 0.05090127f, -0.09742397f, 0.03326891f, -0.00266855f, 0.04022243f, 
    0.49774656f, -0.22622398f, -0.00991343f, -0.15324542f, -0.07813222f, 0.00847033f, -0.04875167f, 0.02056799f, 
    0.02193471f, 0.18208486f, -0.01848074f, 0.03661765f, -0.27029860f, -0.29121512f, -0.02979548f, 0.01736565f, 
    0.05133538f, 0.09792214f, -0.00670502f, 0.04205189f, 0.19217166f, -0.03607111f, 0.00434285f, -0.00156038f, 
    -0.23394074f, 0.01674559f, 0.18860024f, -0.13691291f, 0.02922635f, -0.00352442f, -0.05046735f, -0.03518296f, 
    -0.16298029f, 0.03868729f, 0.11631902f, 0.01922896f, -0.18744758f, 0.05128866f, -0.22281159f, 0.19587120f, 
    0.02707216f, 0.05052725f, 0.05887388f, 0.07632791f, 0.00861057f, -0.00734034f, 0.07887202f, -0.04293596f, 
    0.24603762f, 0.01759364f, -0.13935466f, 0.30432922f, -0.05846929f, 0.03693586f, 0.13551448f, 0.08090954f, 
    0.07561591f, 0.06127592f, 0.05924940f, 0.09396792f, 0.26897636f, 0.22365849f, 0.09601544f, -0.18252946f, 
    0.01043130f, 0.06428567f, 0.07648527f, -0.16826543f, 0.16119194f, 0.03211195f, 0.00999856f, -0.07067165f, 
    0.34407443f, -0.12955126f, -0.00677753f, 0.00754324f, -0.02952121f, 0.08697506f, 0.02257344f, -0.03028517f, 
    0.05765086f, 0.02425060f, -0.02932928f, -0.05579229f, 0.28148025f, -0.20819661f, 0.07537235f, -0.04734679f, 
    -0.18952397f, 0.04547120f, 0.01689089f, 0.11202780f, 0.08248210f, -0.00916603f, -0.05963031f, 0.08262714f, 
    0.14218335f, 0.07725373f, 0.10509812f, 0.04595073f, -0.03889228f, -0.07180426f, 0.03725701f, 0.01197623f, 
    -0.03449716f, 0.13489272f, 0.19573313f, 0.10802689f, -0.09748811f, 0.19747089f, -0.09548525f, 0.02843408f, 
    -0.09561438f, -0.07627181f, -0.12001527f, 0.13397832f, -0.01340572f, 0.14319468f, 0.09368266f, 0.10823148f, 
    -0.05748434f, -0.27861968f, -0.09331682f, 0.01187798f, -0.08599491f, 0.00286494f, 0.05907137f, 0.08644997f, 
    0.01550630f, 0.04875526f, -0.09491154f, 0.05968541f, -0.04699342f, -0.12417137f, 0.03245198f, -0.03627000f, 
    -0.02720569f, -0.11566897f, -0.10988958f, 0.14924696f, -0.17905588f, 0.09989925f, -0.03940726f, -0.12375321f, 
    -0.23976976f, 0.32945374f, -0.10632142f, 0.09284857f, -0.00890856f, -0.00000667f, 0.10787544f, -0.06243256f, 
    0.10241323f, 0.05895297f, -0.05946742f, 0.00840958f, -0.07688273f, 0.12466419f, 0.02251450f, 0.03091949f, 
    0.20659745f, -0.02670291f, -0.06539437f, 0.10395216f, 0.03362219f, -0.07310675f, 0.10345308f, -0.09809005f, 
    0.15550669f, 0.01409544f, 0.03212737f, 0.11286305f, 0.17893530f, -0.05376217f, 0.21388166f, -0.04502174f, 
    -0.02942552f, -0.01309123f, -0.14312692f, 0.08568645f, -0.32114705f, 0.12714355f, -0.28420207f, -0.16379298f, 
    0.03534014f, 0.03191341f, -0.03894509f, 0.09381893f, -0.02005680f, -0.05011714f, 0.09340134f, -0.05807321f, 
    0.11870295f, 0.14132303f, 0.01011020f, -0.12050620f, 0.04739078f, 0.03691335f, -0.17517015f, 0.07609791f, 
    0.14047998f, 0.05310896f, -0.12460729f, 0.21158424f, -0.32654917f, -0.15051335f, -0.01679598f, -0.16330059f, 
    0.00583526f, 0.11778803f, 0.18141957f, 0.02262415f, -0.02305191f, -0.06111606f, 0.07877567f, 0.01092318f, 
    0.15257004f, 0.08590349f, 0.20758359f, 0.07907920f, -0.01913075f, -0.08901667f, 0.05223024f, 0.04180420f, 
    0.13585779f, 0.17734259f, 0.12886345f, 0.09771507f, -0.32612810f, 0.17928056f, -0.29848412f, -0.11716697f, 
    -0.03675859f, -0.00706578f, -0.06067865f, -0.01383330f, 0.00012784f, 0.12604439f, 0.13887078f, 0.09008785f, 
    -0.29855749f, 0.03691715f, -0.17810170f, 0.27660409f, 0.05436941f, 0.01322553f, 0.02495071f, -0.17618249f, 
    0.03471401f, -0.01974466f, -0.09235240f, -0.13110310f, 0.03943763f, 0.03439441f, 0.03694611f, -0.14226753f, 
    -0.02767337f, 0.09565407f, 0.19455552f, 0.13038844f, -0.16487366f, -0.02346542f, -0.05151768f, 0.12282988f, 
    0.22526425f, -0.36854923f, 0.26702437f, -0.09543706f, -0.01020928f, -0.03924220f, 0.11407300f, 0.01041565f, 
    0.22460921f, 0.02402633f, 0.05428717f, -0.12536488f, 0.18812159f, -0.02395699f, 0.00662415f, 0.00469542f, 
    -0.05234683f, 0.03408056f, 0.07810298f, 0.02366078f, 0.03747641f, -0.02779963f, -0.14203520f, 0.07341750f, 
    -0.04872733f, -0.03166125f, 0.05711610f, 0.07738087f, -0.10192089f, -0.07135381f, 0.00229823f, -0.04988269f, 
    0.06951139f, 0.03465382f, -0.04237375f, -0.02215766f, 0.08876117f, -0.06141905f, 0.05739156f, -0.07467174f, 
    -0.00352905f, 0.00287866f, -0.05303495f, 0.05631334f, 0.00386682f, 0.03837577f, -0.02121973f, 0.02891327f, 
    -0.00597344f, -0.04990916f, -0.06605241f, -0.06376463f, 0.00612809f, -0.00601852f, 0.03378042f, -0.04017283f, 
    -0.04523201f, 0.00161897f, -0.06622759f, 0.01471002f, -0.05269315f, -0.03516902f, 0.05293113f, 0.01745420f, 
    -0.03323256f, 0.04574579f, 0.00574901f, -0.06484703f, 0.02034996f, -0.04177579f, -0.05138847f, -0.04913151f, 
    -0.06593265f, -0.10060075f, -0.08483069f, -0.04448605f, -0.02429575f, 0.05145227f, -0.03374742f, -0.01421796f, 
    -0.01915612f, -0.06643727f, 0.02648108f, -0.02246121f, -0.02438131f, 0.01705849f, -0.03256898f, -0.03916892f, 
    0.00722058f, -0.00994579f, 0.03499289f, -0.03296653f, -0.06421301f, -0.05629718f, -0.06241150f, 0.01066349f, 
    0.06372074f, 0.03667654f, 0.01487841f, -0.01957291f, -0.04821408f, 0.02204624f, -0.08078732f, -0.01652035f, 
    -0.04506347f, -0.05416576f, -0.02234668f, 0.02585903f, -0.01942213f, 0.01115668f, -0.05905341f, -0.06864532f, 
    -0.06242061f, 0.06867530f, 0.02556807f, 0.01963118f, 0.04524672f, -0.06287310f, 0.03732449f, 0.02505363f, 
    0.01068454f, -0.00998167f, 0.00946094f, -0.06782899f, -0.04765437f, 0.00693870f, 0.04007076f, 0.02853948f, 
    0.04308419f, 0.04833459f, -0.02338537f, 0.04622069f, 0.03772162f, 0.01085573f, -0.06002375f, -0.01881733f, 
    -0.01845343f, 0.03056590f, -0.01464603f, -0.09584957f, 0.01467697f, -0.00106000f, -0.03445065f, -0.01833976f, 
    -0.05194169f, 0.02021419f, -0.08682087f, -0.00083442f, 0.05113051f, -0.05964432f, 0.05109437f, 0.03927650f, 
    -0.02613562f, -0.01611234f, -0.04524692f, 0.06025577f, -0.03083830f, -0.02088049f, -0.05317228f, -0.02849336f, 
    -0.05772917f, 0.02042333f, 0.06583300f, -0.06007042f, 0.00197286f, -0.08003307f, -0.06684306f, -0.01648760f, 
    -0.01503479f, -0.03808545f, 0.00692962f, 0.04263454f, -0.06508537f, -0.05326188f, 0.02714789f, 0.01768772f, 
    -0.06979553f, 0.04961299f, 0.05424096f, -0.03972691f, -0.07250417f, 0.05431398f, -0.03858464f, 0.00146683f, 
    -0.04070299f, -0.08257391f, 0.02490444f, 0.02429097f, 0.00577654f, -0.05018890f, -0.05088403f, -0.01450473f, 
    0.01334511f, 0.00515889f, -0.02831150f, 0.04855389f, -0.04539087f, -0.02217649f, 0.00912597f, -0.00022012f, 
    -0.05320171f, 0.02682851f, -0.03612778f, -0.00970777f, 0.01892375f, -0.07308308f, -0.07989844f, -0.05224262f, 
    0.04623870f, 0.08503537f, 0.03308502f, 0.02615403f, -0.07066946f, -0.01747897f, -0.07548483f, -0.04822371f, 
    0.13977356f, 0.08857049f, 0.21045040f, 0.04844574f, 0.03745082f, -0.13809958f, 0.10836647f, 0.02649440f, 
    -0.01855655f, 0.09514318f, 0.13999735f, 0.14793982f, 0.06502169f, 0.21022028f, 0.14527705f, 0.08504505f, 
    -0.11956598f, 0.04888945f, -0.05733959f, -0.01916591f, -0.12726924f, 0.06329338f, 0.02784227f, 0.06143148f, 
    0.25113791f, -0.26946038f, 0.15610495f, -0.21774948f, -0.19272156f, -0.03909019f, 0.09213687f, 0.19154735f, 
    -0.24141048f, -0.00189322f, 0.04132124f, -0.02264063f, -0.32673183f, -0.14446628f, 0.18771784f, 0.11646858f, 
    -0.02997572f, -0.07522275f, -0.03272058f, 0.05400790f, -0.05218478f, -0.01740205f, 0.02415573f, -0.01247799f, 
    0.12241576f, 0.35122782f, 0.02722930f, 0.21810742f, -0.14558007f, 0.01018844f, 0.09016238f, 0.05170267f, 
    -0.03050427f, 0.09850956f, -0.07687897f, -0.08565784f, 0.00154619f, -0.21478091f, -0.33683744f, -0.14307182f, 
    0.07026344f, 0.00718307f, -0.03123148f, 0.00351975f, 0.02324000f, -0.03396340f, 0.04001838f, 0.04759628f, 
    0.10080548f, -0.14449993f, 0.28523055f, -0.05088609f, 0.08994550f, -0.00284272f, 0.12413003f, 0.05385406f, 
    0.02007521f, 0.07525045f, -0.15143728f, 0.03495531f, -0.15027559f, 0.27727619f, -0.13894948f, -0.13081817f, 
    0.05903092f, 0.07741383f, -0.05677195f, 0.00226976f, 0.13416740f, -0.02172691f, 0.09809220f, -0.14039154f, 
    -0.10918880f, 0.14815168f, -0.00627771f, -0.00515967f, 0.04068888f, -0.06217058f, -0.09989663f, 0.04195575f, 
    0.01237154f, 0.03700646f, 0.04257357f, 0.08956783f, -0.16300081f, -0.04591407f, -0.14059633f, 0.00575534f, 
    0.05930253f, -0.10985255f, 0.04697198f, 0.02037806f, 0.05430594f, 0.16534044f, -0.11456759f, -0.02542466f, 
    0.42732772f, -0.04379422f, 0.11220679f, 0.34444329f, -0.05607164f, -0.19847549f, 0.11807481f, 0.08957687f, 
    0.02389783f, -0.04205167f, -0.08644301f, 0.13793924f, -0.66578019f, -0.09941620f, 0.06310183f, -0.10259455f, 
    -0.09224762f, -0.03204471f, -0.19160599f, -0.04147303f, 0.12565812f, 0.10388112f, 0.13746062f, -0.02757264f, 
    -0.22914533f, 0.14721964f, 0.07436106f, 0.17908618f, -0.03423028f, -0.00740886f, -0.02389150f, -0.11928488f, 
    -0.11881917f, 0.05731686f, -0.14252916f, -0.13419142f, -0.00333832f, 0.06113577f, 0.08024598f, -0.08252507f, 
    -0.05437271f, 0.02744287f, -0.01105312f, 0.18383792f, -0.06318054f, 0.13240167f, -0.04603793f, 0.00719249f, 
    0.36775920f, -0.30949673f, 0.30669314f, -0.38188627f, 0.20250767f, 0.11179099f, 0.03981753f, 0.09108454f, 
    0.15157251f, 0.00230169f, 0.03715215f, 0.08356663f, 0.21780309f, 0.08830196f, 0.04123745f, -0.11421205f, 
    0.00226271f, 0.06608711f, 0.13139534f, -0.04925498f, 0.00968593f, 0.01331764f, -0.17883608f, -0.09537321f, 
    -0.00716914f, 0.00851413f, -0.05524192f, 0.02191736f, -0.02097375f, -0.06915240f, 0.00530613f, 0.02463609f, 
    -0.05818202f, 0.01123882f, -0.06741470f, 0.04124238f, 0.02713469f, -0.03128410f, -0.02643105f, -0.02918879f, 
    -0.01474769f, -0.07086673f, -0.04760579f, -0.03251806f, -0.04004527f, -0.07638694f, -0.07755498f, -0.03454841f, 
    0.03903426f, -0.04193000f, -0.06789724f, 0.00951571f, -0.02617546f, -0.06378978f, 0.02235867f, 0.02165130f, 
    -0.05128814f, -0.06807125f, -0.04730357f, -0.03785908f, 0.04182430f, 0.03033609f, -0.05787218f, -0.06262585f, 
    -0.03388111f, -0.06390043f, -0.05627153f, 0.02288762f, -0.07409052f, 0.00112365f, 0.04228705f, -0.00371713f, 
    -0.04494739f, -0.06026538f, -0.04282832f, -0.01064781f, -0.07608572f, -0.05131133f, 0.03108329f, 0.03461803f, 
    0.05216191f, -0.02325494f, -0.04187086f, -0.00436686f, 0.01521642f, 0.06453022f, 0.06402956f, -0.07361137f, 
    -0.07398956f, -0.06298535f, 0.05035014f, 0.03674862f, -0.02931696f, -0.00474927f, 0.04968834f, -0.03090666f, 
    0.01964049f, -0.03384734f, -0.08092196f, -0.04427477f, -0.03165132f, -0.03645955f, -0.00181880f, -0.06121415f, 
    -0.00594073f, -0.05206899f, 0.06635564f, -0.02570837f, -0.03857750f, -0.00978012f, -0.01225965f, -0.04818590f, 
    0.05397303f, 0.06378090f, 0.04475965f, -0.03863655f, -0.07139880f, -0.06490011f, -0.03429000f, -0.00436590f, 
    0.00062866f, -0.05118421f, -0.02146788f, 0.00833501f, 0.06218038f, 0.03004755f, -0.02843632f, 0.00894879f, 
    0.02413461f, -0.03665806f, -0.05571122f, 0.02617995f, 0.03186438f, -0.03574023f, -0.00179018f, 0.06194429f, 
    0.05627585f, -0.07092514f, -0.01376962f, -0.03654420f, -0.05471443f, 0.05579912f, 0.03223300f, 0.02796593f, 
    -0.00945798f, -0.03878784f, -0.03491754f, -0.04385784f, 0.00399093f, -0.01591256f, 0.00444605f, -0.03574610f, 
    -0.04159778f, -0.01331363f, -0.00247427f, 0.00533577f, 0.04699873f, 0.03835568f, 0.03468923f, 0.04200360f, 
    -0.03555509f, 0.03874700f, 0.01718668f, -0.03326022f, 0.01220469f, 0.04972823f, 0.02080849f, -0.01800225f, 
    0.00651189f, 0.00123368f, 0.02012404f, -0.05285136f, -0.02579975f, -0.02952265f, 0.06484697f, 0.03432504f, 
    -0.05325044f, -0.06173795f, -0.04837368f, 0.01678269f, -0.00413998f, 0.03292325f, -0.05004577f, 0.00414140f, 
    0.00207234f, -0.04842294f, 0.04240661f, 0.05960999f, 0.05351686f, 0.04485170f, 0.03433975f, 0.03943869f, 
    -0.00512320f, 0.00404754f, -0.01652185f, -0.05312255f, 0.03479860f, -0.00110178f, -0.07161993f, 0.02326566f, 
    -0.01051590f, -0.07456098f, 0.05817708f, -0.03024889f, 0.06155578f, 0.05419710f, 0.01217202f, 0.00214719f, 
    0.05769103f, -0.00387248f, 0.03221747f, 0.06518304f, 0.00032216f, -0.04225909f, -0.07398916f, 0.04067114f, 
    -0.03776284f, -0.01754272f, -0.06266204f, -0.04680568f, -0.01807134f, -0.04230014f, 0.01479625f, 0.01274533f, 
    -0.02520669f, -0.04647911f, -0.03138691f, -0.03911555f, 0.00234848f, 0.01891581f, -0.04441160f, -0.04403592f, 
    -0.00892679f, -0.05682275f, 0.04564768f, 0.01370977f, 0.03874253f, -0.02346394f, 0.02550972f, 0.04565964f, 
    -0.03894666f, 0.03316442f, -0.05902884f, -0.06617922f, 0.03838107f, 0.02798702f, 0.04414173f, 0.00354566f, 
    -0.03825662f, 0.02765658f, 0.06662444f, 0.03769898f, 0.02164030f, -0.00504308f, 0.04004003f, 0.02094756f, 
    0.04001633f, 0.02576025f, 0.00390269f, -0.06480962f, 0.06102493f, -0.04948752f, 0.01990885f, -0.08127690f, 
    -0.02826697f, -0.05441653f, 0.00136245f, -0.00299641f, -0.06322438f, 0.03432091f, 0.03459375f, -0.00331236f, 
    0.05917570f, -0.06654803f, -0.02561478f, 0.01730334f, -0.02598460f, -0.05711532f, -0.02209494f, -0.06193746f, 
    0.05734397f, -0.07753535f, -0.00679684f, -0.03188690f, 0.01160239f, -0.03849292f, 0.00831204f, -0.02679232f, 
    0.06130036f, -0.01643019f, -0.01058449f, -0.07027393f, -0.00272070f, -0.08204934f, -0.00181277f, -0.03093505f, 
    -0.03752128f, 0.04794212f, 0.04439178f, -0.07236604f, -0.00068428f, -0.08411343f, -0.03028137f, -0.03513803f, 
    0.00636736f, -0.07767853f, -0.02062904f, -0.00526951f, 0.00568019f, -0.03986068f, -0.06031910f, 0.00066026f, 
    -0.06134100f, -0.03801019f, -0.01866749f, 0.05886703f, -0.04328794f, 0.00787884f, -0.03988457f, -0.03381747f, 
    -0.04432997f, -0.04488117f, -0.00539398f, 0.02406600f, 0.02758053f, 0.05700914f, 0.04018079f, -0.04156173f, 
    -0.06954743f, -0.03678854f, -0.02259052f, -0.04020043f, -0.01709089f, -0.05167684f, 0.01166577f, -0.05195612f, 
    0.05745640f, 0.02800450f, 0.03664004f, 0.05913920f, -0.03618777f, -0.06226678f, 0.04145767f, -0.00826218f, 
    0.02488510f, 0.05129994f, 0.05420151f, -0.06360617f, -0.03432163f, 0.05267338f, -0.04120287f, -0.07966055f, 
    -0.06378306f, 0.04078096f, 0.01495792f, 0.01407085f, -0.00523013f, -0.05371270f, 0.04388639f, 0.06564941f, 
    -0.03217606f, -0.06502061f, 0.03497253f, -0.03658636f, 0.02462780f, -0.03845417f, -0.02296512f, -0.06551042f, 
    -0.07257590f, -0.04974834f, -0.03573697f, 0.04131567f, 0.02906468f, 0.05873313f, 0.01170356f, 0.04348528f, 
    0.05318765f, 0.02325159f, 0.05332008f, 0.01901554f, -0.05879594f, 0.02853898f, -0.00936153f, -0.04009641f, 
    0.04200929f, -0.00644210f, 0.06129329f, -0.05927547f, 0.04008447f, 0.05673848f, 0.00955973f, -0.01667568f, 
    -0.06750082f, -0.00181157f, 0.02150828f, 0.04961186f, -0.00881555f, -0.05722351f, 0.04660133f, -0.03057130f, 
    -0.01749465f, -0.03316452f, 0.06988232f, -0.03666874f, -0.06911610f, 0.06344525f, -0.03264952f, -0.03373691f, 
    -0.00377395f, 0.04354268f, 0.03447029f, -0.05646354f, -0.03791030f, -0.01691408f, -0.07409094f, 0.01090827f, 
    -0.06878905f, -0.04488306f, -0.07876556f, -0.05519453f, -0.02061177f, 0.01630119f, -0.06393162f, -0.04252420f, 
    0.04584353f, -0.02378508f, 0.02846314f, -0.02348618f, -0.01881459f, -0.07472086f, 0.01354745f, -0.07037535f, 
    0.01811194f, 0.03027210f, 0.00546799f, 0.01563146f, -0.03957280f, -0.00499664f, 0.03943220f, 0.03722667f, 
    0.02504805f, -0.07427319f, 0.04173509f, 0.05528584f, 0.02716469f, -0.01304564f, 0.00086934f, 0.04757680f, 
    0.00676217f, 0.01097087f, 0.02743067f, 0.01505290f, 0.04938063f, -0.04896548f, 0.02671161f, -0.04956360f, 
    -0.02824719f, -0.04577397f, -0.07063806f, -0.00257238f, 0.03250090f, 0.04251475f, -0.02103934f, -0.01238888f, 
    -0.01777313f, -0.06744311f, 0.00683785f, -0.03741109f, -0.02433480f, -0.01525830f, 0.00165726f, -0.04963336f, 
    0.04833459f, -0.00764713f, -0.02750685f, -0.02677251f, 0.02587622f, 0.01423984f, 0.01619517f, -0.07795365f, 
    0.01546712f, -0.01167629f, 0.04514484f, 0.06285846f, -0.01615741f, -0.07841682f, 0.02851209f, 0.02065501f, 
    -0.06545567f, -0.04214565f, 0.01102603f, 0.05916020f, 0.03415264f, -0.04254375f, 0.02913983f, 0.03493693f, 
    -0.01875751f, 0.00784568f, -0.00297419f, 0.05674780f, -0.06399025f, 0.03657131f, -0.00532934f, 0.00358087f, 
    -0.02901804f, 0.01470753f, -0.03090997f, 0.05381350f, 0.00670951f, -0.06946708f, -0.04111870f, 0.02164111f, 
    0.06199927f, 0.01079463f, 0.04269352f, -0.06984850f, -0.01906842f, 0.00816876f, -0.04483568f, -0.03468053f, 
    -0.05084180f, -0.07559124f, 0.02196925f, 0.05672444f, 0.00394903f, -0.06966589f, -0.07441520f, -0.02812629f, 
    0.04159719f, -0.01057762f, 0.04836582f, 0.03860460f, -0.05242427f, 0.02454249f, 0.01293846f, -0.06025459f, 
    0.02089045f, 0.05559317f, 0.05919946f, 0.02194515f, 0.00729946f, -0.01943962f, -0.01925495f, -0.04905235f, 
    0.00616869f, -0.01731760f, -0.00875461f, -0.02687948f, -0.05517441f, -0.02249467f, -0.06273866f, 0.01487644f, 
    0.04720433f, -0.05725421f, -0.07067320f, -0.04928510f, -0.06940378f, 0.03525536f, -0.01280199f, -0.05396315f, 
    0.01356002f, -0.05412370f, 0.00085742f, -0.03937982f, -0.03454613f, -0.01770423f, 0.02800145f, -0.06122513f, 
    -0.02102700f, -0.04495127f, 0.05748402f, 0.02289674f, -0.00289546f, -0.06395105f, 0.01884678f, 0.01406475f, 
    0.04501631f, -0.00866123f, -0.01855925f, 0.05845171f, -0.07109588f, 0.02339261f, 0.00152759f, 0.03079037f, 
    0.02721042f, 0.04509967f, 0.06043410f, -0.02247904f, -0.06538942f, -0.02384066f, 0.01927903f, 0.03191815f, 
    -0.02322987f, -0.07156000f, -0.00888946f, -0.06039685f, -0.05846720f, 0.05154044f, 0.03317309f, 0.05882869f, 
    -0.01710226f, 0.21778439f, -0.12413520f, -0.05983187f, 0.09418431f, 0.14129333f, 0.23365031f, 0.19444105f, 
    0.09480526f, 0.00274755f, 0.02428875f, 0.06694379f, 0.11670907f, -0.03080810f, 0.04887259f, 0.04625253f, 
    -0.01830403f, -0.03568078f, -0.13007385f, -0.01944792f, -0.01325531f, -0.12656561f, 0.06663753f, 0.10893272f, 
    0.14473210f, 0.28927240f, 0.38911030f, -0.03499134f, 0.06675433f, -0.01944783f, -0.03837818f, 0.09825172f, 
    0.17322503f, 0.20877203f, 0.07913321f, 0.13798964f, -0.43445823f, 0.22887239f, -0.10152678f, 0.02615415f, 
    0.13646075f, 0.01567561f, 0.04463724f, 0.16063109f, 0.01222882f, 0.03154105f, 0.05472428f, 0.07144468f, 
    -0.12965344f, -0.08839221f, -0.01434917f, -0.07940386f, 0.04999274f, 0.08114552f, -0.10794219f, 0.12264412f, 
    0.02079775f, 0.01894590f, 0.13242948f, 0.03330197f, 0.05550195f, -0.10272394f, -0.10576154f, -0.32083058f, 
    -0.07368352f, -0.15913498f, -0.01289845f, 0.01349027f, -0.02183078f, 0.08040255f, -0.02692737f, -0.14726822f, 
    -0.12341155f, -0.13910656f, 0.20154728f, -0.23463120f, 0.08777776f, 0.04336298f, -0.01731578f, 0.22124414f, 
    -0.07601266f, -0.10361214f, -0.06763334f, 0.04450894f, 0.41051266f, 0.21617153f, -0.12147243f, 0.31813088f, 
    -0.04475037f, -0.00024333f, -0.04416033f, -0.08987838f, -0.04857362f, -0.00316076f, 0.03414166f, 0.00508355f, 
    0.02808565f, -0.02736452f, -0.13416299f, 0.19792086f, 0.08203687f, -0.15602812f, -0.01504516f, -0.17100014f, 
    -0.13184702f, -0.04182215f, -0.00609179f, 0.02767794f, -0.05049794f, 0.15868062f, 0.09749067f, -0.08579461f, 
    -0.07594228f, -0.19539073f, -0.02125745f, -0.02097145f, 0.01143830f, 0.09051870f, 0.10139254f, 0.05114319f, 
    0.03576259f, -0.04550196f, -0.33466935f, 0.08684118f, 0.11519058f, -0.04526071f, -0.02734584f, -0.03656170f, 
    0.19057325f, -0.06180900f, 0.00470091f, 0.02744328f, -0.46144781f, -0.35666159f, 0.15884486f, -0.22104852f, 
    -0.02918885f, 0.13046998f, -0.06087316f, 0.06711609f, 0.11192427f, 0.14361180f, 0.03666713f, 0.02383130f, 
    -0.16649762f, -0.06822190f, 0.06969683f, -0.03013741f, -0.05944300f, -0.00355128f, -0.02860908f, 0.03641279f, 
    0.04668547f, -0.01833265f, 0.04831793f, 0.13330421f, 0.00257419f, 0.18971576f, -0.11301265f, 0.12786135f, 
    0.07903203f, -0.06423941f, -0.00194058f, 0.07437343f, 0.08840947f, 0.05874039f, 0.13023534f, 0.11625367f, 
    0.07507579f, 0.20931153f, -0.25084531f, 0.09147151f, 0.28318349f, 0.13085973f, 0.02745077f, 0.07766218f, 
    -0.14581065f, 0.07699980f, 0.05487733f, 0.01940805f, -0.07339867f, -0.12872775f, -0.22774589f, -0.01170116f, 
    0.22709677f, 0.11319394f, 0.03642165f, 0.03860892f, 0.01003616f, 0.10263181f, -0.07125360f, -0.06805853f, 
    0.26338065f, 0.05011490f, -0.18399362f, -0.10848691f, -0.00594123f, 0.10430197f, 0.04609128f, 0.03716121f, 
    -0.06112356f, 0.23728390f, 0.18577741f, 0.21341223f, 0.10493523f, 0.13243315f, -0.15636012f, -0.17230423f, 
    0.06155271f, 0.10403097f, -0.13766454f, -0.00294413f, 0.02861105f, 0.00386473f, 0.14691423f, 0.17029251f, 
    -0.03869440f, 0.02112607f, 0.24129130f, -0.16467914f, 0.01172539f, 0.02272735f, -0.00580152f, 0.06339265f, 
    0.00068388f, 0.05195325f, 0.11152735f, -0.00000995f, 0.08957935f, 0.10769036f, 0.01136942f, -0.00214924f, 
    0.17639135f, 0.05330790f, 0.02801548f, 0.11439240f, 0.04008520f, 0.02466536f, 0.08024772f, -0.12327529f, 
    -0.27911547f, -0.06083582f, -0.31791541f, 0.05036215f, 0.02623719f, 0.18523172f, -0.05244340f, 0.03826845f, 
    0.04428853f, 0.13977456f, 0.02673527f, -0.07674149f, 0.30447170f, 0.01869646f, -0.06283459f, 0.01367923f, 
    -0.18171474f, -0.34400281f, -0.06043441f, 0.14147297f, 0.03540213f, -0.06809151f, -0.16697887f, -0.06181169f, 
    -0.27762896f, -0.20416358f, 0.28438592f, 0.19901989f, 0.07824850f, -0.00608527f, -0.02490345f, 0.11703233f, 
    0.06365136f, 0.00317020f, -0.17583042f, 0.07554721f, 0.58953363f, -0.14217055f, -0.19519608f, 0.08240450f, 
    -0.06647662f, 0.16736041f, -0.14254822f, -0.03775051f, 0.03477784f, -0.06851611f, 0.02851456f, -0.10718468f, 
    0.05474755f, -0.10110240f, 0.02987069f, -0.01743474f, 0.07925839f, -0.07033837f, 0.06134350f, 0.01289984f, 
    0.01240091f, 0.07625969f, 0.08846057f, 0.07280726f, -0.02649741f, 0.13995486f, -0.18514742f, -0.00433285f, 
    0.01872321f, 0.03459849f, 0.00518309f, 0.03764206f, 0.10095377f, 0.02142061f, -0.10906769f, -0.05677540f, 
    -0.40057898f, -0.20614946f, -0.23224041f, -0.24467474f, 0.14118256f, 0.03570633f, 0.08238137f, 0.01273701f, 
    0.00697295f, 0.09040348f, 0.09087382f, 0.13002862f, -0.32312477f, -0.35161534f, -0.06867240f, -0.37959611f, 
    0.01682052f, -0.10382622f, -0.05157667f, 0.02673654f, -0.01017047f, 0.04319933f, 0.14596322f, 0.05991963f, 
    -0.13055517f, 0.26634434f, 0.04853079f, 0.18097958f, -0.05942360f, 0.03975192f, -0.03326292f, -0.17788412f, 
    0.00229571f, 0.08740565f, -0.13215493f, -0.13223094f, 0.45643252f, -0.02644127f, -0.05876505f, -0.00279185f, 
    -0.19741488f, -0.00726812f, -0.00215686f, 0.04945866f, 0.05088764f, 0.09123428f, 0.03064912f, 0.02497491f, 
    0.15851003f, 0.05551114f, 0.04945754f, -0.12723295f, -0.11647856f, 0.05704872f, 0.12125044f, 0.09132251f, 
    0.04013480f, -0.04332223f, 0.06848391f, -0.06817899f, 0.44515559f, 0.00576625f, -0.10288871f, -0.09106041f, 
    0.07198864f, 0.03099292f, 0.11141581f, 0.06653772f, 0.02782296f, 0.04586521f, -0.08366580f, 0.05077092f, 
    0.04315567f, -0.00059319f, 0.30605295f, 0.33865380f, -0.04441318f, -0.18595818f, -0.02729215f, -0.06817173f, 
    -0.08453447f, -0.20588915f, 0.09832460f, -0.04683912f, -0.18678202f, 0.00560650f, 0.14015017f, -0.13129495f, 
    0.14810264f, 0.19486557f, 0.09305210f, 0.10969738f, -0.09479897f, 0.10824593f, -0.05068322f, 0.03215986f, 
    0.03515175f, -0.25578332f, -0.24383523f, 0.24629639f, 0.00367717f, 0.08956023f, 0.09424736f, -0.07075257f, 
    -0.09228882f, 0.05656378f, -0.07789282f, -0.12451711f, -0.33121434f, 0.08877812f, 0.18078071f, -0.13353957f, 
    0.01862125f, 0.01879163f, -0.00652951f, -0.01473143f, -0.02849051f, -0.05656577f, 0.05681158f, -0.02288517f, 
    0.32912725f, 0.11163940f, 0.17165935f, 0.32527357f, -0.08470570f, -0.09726049f, 0.13632071f, 0.01482768f, 
    0.06898776f, 0.04416097f, 0.10737329f, -0.02628427f, -0.09609473f, 0.06995498f, -0.03493248f, 0.37650907f, 
    -0.12984543f, -0.00741644f, -0.02696446f, -0.04745715f, -0.00084371f, 0.03525968f, 0.03840396f, 0.06842061f, 
    0.39396045f, 0.16468793f, -0.26949838f, 0.43303609f, 0.05196555f, 0.15338710f, 0.05412088f, -0.09527434f, 
    0.06090804f, 0.13422345f, -0.08284676f, 0.02797343f, -0.38757995f, 0.04301411f, -0.03064843f, -0.21764022f, 
    0.04016740f, -0.01905349f, 0.15099497f, 0.09125850f, 0.05582963f, 0.11862164f, -0.10563629f, 0.05595262f, 
    -0.27567029f, 0.14221610f, 0.11636057f, -0.25195962f, 0.08501337f, 0.02306251f, 0.02124932f, 0.13036944f, 
    -0.01762853f, -0.04421911f, 0.04817441f, -0.14478153f, 0.03792335f, -0.12328392f, 0.02574408f, 0.00177842f, 
    0.01203075f, 0.05668416f, 0.01614486f, 0.05592440f, -0.14428312f, 0.13894467f, 0.00676906f, -0.02291539f, 
    0.01751201f, 0.17426001f, 0.10168950f, 0.00967207f, 0.05737137f, 0.11906853f, 0.03442029f, -0.00542562f, 
    0.09406536f, -0.05235022f, -0.05025176f, 0.08113199f, 0.03762321f, 0.34562033f, -0.04919762f, 0.01551125f, 
    -0.00230430f, -0.00703121f, 0.05070994f, 0.06614134f, -0.06420576f, 0.01805949f, -0.00909010f, 0.08578796f, 
    0.03501888f, -0.09706514f, -0.17722651f, -0.19160280f, 0.00246166f, 0.15953776f, -0.06769783f, 0.11871826f, 
    0.03812177f, -0.04347665f, -0.04682764f, 0.07019614f, 0.16072638f, 0.05624826f, 0.11193696f, 0.06376182f, 
    -0.07888047f, -0.05552578f, 0.02533021f, 0.13772541f, -0.09411726f, 0.14347842f, 0.08572677f, 0.08725511f, 
    0.00918415f, -0.33802488f, 0.05211525f, 0.29995251f, 0.03825823f, -0.01589370f, -0.03244609f, 0.01507436f, 
    0.11897653f, -0.03523251f, -0.17560370f, 0.03903513f, -0.21265456f, -0.10603035f, 0.07740361f, -0.23512389f, 
    -0.14226808f, -0.01040790f, 0.08830515f, 0.07168720f, -0.01987202f, -0.03496953f, 0.04122156f, -0.04735260f, 
    0.03380894f, 0.00048390f, 0.05179691f, 0.04336448f, -0.01275066f, -0.00147197f, 0.01817388f, 0.05071538f, 
    0.03134049f, -0.03834117f, -0.02817665f, 0.03232378f, 0.01532202f, -0.05730735f, 0.01888509f, -0.07528320f, 
    -0.03021527f, -0.05531066f, 0.00898899f, -0.05823455f, -0.00902464f, 0.04696591f, 0.03519911f, 0.01033468f, 
    -0.01473703f, 0.03862565f, -0.01264758f, 0.01017669f, 0.00587659f, -0.07897258f, -0.07473672f, 0.03124691f, 
    -0.07855310f, -0.01355156f, -0.06549429f, 0.01922988f, 0.03507205f, -0.04941695f, -0.01679185f, 0.02691664f, 
    -0.03953680f, 0.01615220f, 0.03378696f, -0.02446633f, 0.04371662f, 0.00849526f, 0.04814393f, 0.01237122f, 
    -0.06134371f, 0.05374028f, 0.01850944f, -0.02592715f, -0.05207722f, 0.01511068f, -0.06298906f, 0.01385704f, 
    -0.01705006f, -0.05594305f, -0.06440360f, -0.00873302f, -0.00542324f, -0.07750227f, 0.01516305f, -0.01730281f, 
    0.01189299f, -0.04688229f, -0.05081749f, -0.05456775f, -0.00269163f, -0.06297829f, -0.05690933f, -0.06624154f, 
    0.01222510f, -0.03482533f, 0.01043408f, -0.03686102f, -0.02702509f, 0.04925512f, -0.06326794f, -0.00699523f, 
    -0.00301253f, 0.03692796f, -0.02686085f, 0.02434163f, -0.07525246f, 0.00108067f, 0.00086919f, -0.04824130f, 
    0.05645417f, -0.04862361f, -0.00764101f, -0.03948309f, -0.01933785f, -0.02977960f, 0.03305542f, 0.00440198f, 
    -0.02850757f, 0.03589392f, 0.03947511f, 0.00490356f, 0.03571697f, -0.00092545f, -0.05533532f, -0.06938335f, 
    0.02014782f, -0.01860300f, 0.03712539f, 0.01771125f, 0.04569392f, -0.05189730f, 0.03449593f, 0.05744066f, 
    0.03837185f, 0.02829129f, -0.06942049f, 0.03788144f, 0.05638446f, -0.00941369f, -0.02392972f, 0.02976170f, 
    0.01138807f, -0.04615249f, 0.00436019f, -0.05234762f, 0.05916017f, -0.04941928f, 0.00531330f, -0.00334038f, 
    -0.05702733f, -0.07120635f, -0.07309011f, 0.05227975f, -0.04668698f, -0.06181252f, -0.06661902f, 0.04872733f, 
    0.02194318f, -0.01422189f, 0.01784489f, 0.03373648f, -0.04915127f, 0.02756493f, 0.03536678f, 0.03738440f, 
    -0.00142361f, 0.05571283f, -0.01597321f, 0.02234733f, 0.06553076f, -0.06281941f, -0.04986504f, -0.05867761f, 
    -0.06009959f, 0.00388608f, 0.03975692f, -0.06764499f, 0.01198872f, -0.07449207f, -0.04768362f, -0.07079098f, 
    -0.00376153f, 0.04845755f, -0.03682324f, 0.05832258f, -0.02561213f, -0.04683762f, -0.07757465f, -0.04501884f, 
    0.00475252f, -0.01863150f, 0.00292383f, 0.00771794f, -0.02860750f, 0.06045453f, 0.02100759f, 0.06450150f, 
    -0.04727676f, 0.01660710f, -0.05707469f, 0.00416766f, -0.01955595f, -0.06224236f, 0.01610117f, -0.05775104f, 
    0.06359445f, 0.01584028f, -0.02500412f, 0.05715608f, -0.03850141f, 0.04497540f, -0.04011945f, 0.05430233f, 
    -0.05617642f, -0.02485208f, -0.04973816f, -0.03101270f, -0.02171368f, 0.00877811f, -0.00300703f, 0.01082233f, 
    0.04543347f, 0.02870123f, 0.04587094f, -0.00272603f, -0.01075256f, 0.05819699f, 0.00080306f, 0.04996870f, 
    0.04536115f, 0.00508427f, -0.07878042f, -0.06805009f, -0.05551546f, -0.07898872f, -0.05516432f, 0.03031823f, 
    0.03731883f, 0.02490856f, -0.04316662f, -0.03456299f, 0.01527011f, -0.01201833f, 0.02461403f, 0.03403232f, 
    -0.03555932f, -0.06802028f, -0.01656979f, -0.02746528f, 0.01792509f, -0.03790748f, 0.04085024f, -0.07106972f, 
    -0.01397123f, 0.03311056f, -0.06846253f, -0.06945261f, -0.06277809f, 0.01443692f, 0.04072488f, 0.05853200f, 
    0.01102095f, 0.03527498f, 0.03055088f, -0.01174012f, -0.01938912f, -0.05166642f, 0.03971619f, -0.00310077f, 
    -0.04508444f, -0.02005734f, 0.01944672f, 0.00281379f, 0.00884885f, -0.02229427f, -0.02945436f, 0.04184510f, 
    0.01744862f, 0.03774581f, 0.04760795f, 0.03821953f, 0.05499489f, -0.05613001f, -0.00330919f, -0.04686967f, 
    -0.04333315f, -0.06377860f, -0.06871086f, 0.05215646f, -0.00293644f, -0.04720056f, 0.06395349f, -0.06615632f, 
    0.04124234f, -0.07040349f, -0.08106916f, 0.01377648f, 0.02936085f, -0.03535198f, 0.02731818f, -0.04119147f, 
    -0.02079991f, 0.04361003f, -0.03607818f, -0.06525659f, 0.06016251f, -0.00624107f, -0.00294553f, -0.04917099f, 
    0.00595850f, 0.00802408f, -0.03209451f, 0.00220692f, -0.02815026f, 0.04913169f, 0.04688393f, 0.03625637f, 
    -0.07495575f, -0.00196555f, -0.03996574f, 0.02758914f, 0.04753688f, -0.04056757f, -0.01957176f, -0.02588866f, 
    0.05495704f, -0.07556675f, -0.04668207f, 0.04452907f, -0.05616454f, -0.02207660f, 0.00571724f, -0.04258635f, 
    0.05436170f, -0.01793978f, -0.00459179f, 0.03288953f, -0.02982157f, -0.05553832f, -0.04287937f, 0.04734127f, 
    -0.00119198f, 0.04738391f, 0.03647047f, -0.07188142f, -0.01434892f, -0.06415785f, -0.03725741f, -0.02172216f, 
    0.02295075f, 0.01029768f, -0.05847699f, 0.01211657f, -0.02425463f, -0.02979716f, -0.07898596f, 0.01181597f, 
    0.02391016f, 0.00694547f, -0.01719004f, 0.02359009f, -0.04263598f, -0.02388447f, 0.05088824f, -0.02418872f, 
    0.04086497f, 0.05773674f, 0.00619027f, -0.01932172f, 0.02024512f, -0.01283563f, 0.00145235f, 0.01348074f, 
    0.01831771f, -0.00882136f, 0.01737739f, -0.07157026f, 0.03476638f, -0.02880493f, -0.00968596f, 0.00544662f, 
    0.02280121f, 0.02281073f, -0.05482876f, -0.00941818f, 0.06357693f, -0.00864565f, -0.07487741f, -0.00267189f, 
    0.01257181f, 0.02913898f, -0.05417017f, -0.05831586f, 0.02627888f, -0.01128379f, 0.04155823f, -0.01598078f, 
    -0.01225030f, -0.04923477f, -0.01804516f, 0.04441711f, -0.07908449f, -0.02264216f, -0.03985481f, -0.00862311f, 
    -0.05603229f, -0.11730874f, 0.21641462f, 0.18543330f, 0.03133431f, -0.07184820f, -0.03387126f, 0.11192413f, 
    0.05344140f, 0.11063395f, 0.07700169f, -0.00935153f, 0.16464701f, 0.21473424f, 0.00200518f, 0.06961988f, 
    -0.15920292f, 0.02368118f, 0.06261263f, 0.03463927f, -0.09863236f, 0.07751083f, -0.00495101f, 0.19628444f, 
    0.18023100f, 0.10279022f, 0.12871879f, -0.37492448f, -0.11044713f, -0.15012117f, -0.01718524f, 0.15740596f, 
    -0.11960778f, -0.04496220f, 0.02225675f, 0.10994072f, -0.12447382f, -0.31156948f, -0.16040593f, 0.05108844f, 
    -0.10466669f, -0.10391600f, 0.07367187f, -0.07147612f, -0.02840143f, -0.00743384f, -0.06624790f, 0.03351424f, 
    -0.13385072f, 0.06456620f, 0.12109628f, 0.20598920f, -0.15169615f, -0.08841663f, 0.07345101f, 0.06624275f, 
    -0.10363054f, -0.02266705f, -0.03043084f, 0.00794827f, -0.11672247f, 0.03183844f, -0.17882295f, -0.13628851f, 
    0.17887998f, 0.07813816f, -0.06243810f, -0.00732753f, 0.01247070f, 0.10742490f, -0.07637214f, 0.04103725f, 
    0.20515448f, 0.13596343f, 0.12137713f, 0.02072074f, 0.05331673f, -0.16665395f, 0.05891314f, -0.10475979f, 
    0.00602451f, -0.04235697f, 0.03670151f, -0.02308836f, -0.23868221f, 0.22226515f, -0.02076512f, -0.17081577f, 
    0.15717983f, 0.05037731f, -0.02126171f, 0.10096134f, 0.08919249f, -0.06347670f, 0.14078595f, -0.05553960f, 
    -0.32875952f, 0.38711983f, 0.08363158f, 0.08448731f, 0.14369112f, 0.08018718f, -0.02393010f, -0.00439898f, 
    0.00185441f, -0.06726712f, 0.08457604f, -0.07943890f, 0.04864653f, 0.18879694f, -0.13729109f, 0.14896515f, 
    0.09773197f, -0.08542000f, 0.06216992f, 0.02423521f, -0.07625750f, 0.13413714f, -0.13000098f, -0.06772377f, 
    0.51797003f, -0.03970568f, -0.13476531f, 0.18085518f, -0.13737285f, -0.18879865f, 0.07884516f, 0.12835939f, 
    -0.12237395f, -0.02765786f, -0.14557581f, 0.05072919f, -0.01925495f, -0.17075711f, 0.28964052f, 0.00322172f, 
    -0.02310018f, -0.09938752f, -0.04891332f, -0.14402048f, 0.21433884f, -0.04699280f, 0.07671398f, -0.03758581f, 
    -0.22243704f, 0.19745488f, 0.12905124f, 0.20447814f, 0.09601524f, -0.12078211f, 0.08223794f, -0.09817527f, 
    -0.02971284f, 0.05007533f, -0.01647653f, -0.13504435f, -0.17411476f, -0.21687777f, 0.15112637f, 0.07359684f, 
    0.06865632f, 0.07476201f, -0.01672707f, 0.25525248f, -0.20762613f, 0.15960479f, -0.06532884f, 0.02983891f, 
    0.14867453f, -0.04199652f, 0.25778174f, -0.37140545f, 0.13944845f, -0.05978120f, -0.01592281f, -0.02363958f, 
    -0.02039238f, -0.04191931f, 0.04026929f, 0.02611791f, 0.00202432f, 0.25535086f, 0.13643445f, -0.09484433f, 
    0.08430580f, 0.07604451f, 0.09780431f, -0.03619483f, -0.06419559f, -0.02923149f, 0.00927214f, -0.05454433f, 
    -0.12885237f, -0.18701716f, -0.20945562f, -0.27976725f, -0.02017907f, 0.05332865f, -0.14628130f, -0.02016147f, 
    0.10910475f, 0.14963698f, -0.10820139f, -0.15736817f, 0.34516987f, 0.25592697f, -0.13955939f, -0.03736669f, 
    -0.02278722f, -0.09598566f, -0.00467915f, -0.09182493f, 0.07085643f, -0.04126912f, -0.03051954f, 0.02601700f, 
    0.06115898f, 0.22122338f, 0.13896079f, -0.18180403f, 0.02028442f, -0.03155256f, -0.06682999f, -0.06059980f, 
    0.07982291f, -0.03855870f, 0.05168208f, 0.01284381f, 0.42958963f, -0.26088345f, -0.14414285f, 0.10293566f, 
    -0.06722046f, -0.05684773f, -0.03254739f, -0.03979976f, 0.05444940f, 0.01193020f, -0.12809271f, 0.13051333f, 
    -0.11091218f, -0.31956834f, -0.08698235f, -0.34050894f, 0.15210198f, 0.07623472f, -0.08354677f, -0.11333845f, 
    -0.07238066f, -0.15470305f, -0.03626725f, 0.05786611f, 0.13421938f, 0.12306894f, 0.29385650f, -0.02585145f, 
    0.09029280f, 0.10354413f, 0.06447612f, 0.13616079f, 0.11343435f, -0.00028595f, -0.13464186f, 0.08987878f, 
    -0.27487782f, -0.02898989f, 0.04766629f, -0.14278299f, -0.20602776f, -0.15777636f, -0.07957500f, 0.10116313f, 
    -0.02892999f, -0.16756208f, 0.21990857f, 0.07652025f, 0.45679548f, -0.22717609f, 0.23514588f, 0.04660691f, 
    -0.03317648f, 0.07853571f, -0.05136881f, 0.11950845f, 0.03006220f, -0.05781765f, 0.10457336f, 0.12384428f, 
    0.30614963f, -0.02317829f, 0.00809909f, 0.24751835f, 0.02099999f, 0.09864868f, -0.05008937f, -0.01525567f, 
    0.08859961f, -0.02424880f, -0.02140952f, -0.04146028f, 0.15835522f, 0.17267634f, -0.02165410f, 0.26988575f, 
    0.05654981f, 0.12096897f, -0.00431370f, 0.08788978f, 0.08299112f, -0.10088097f, -0.04142231f, 0.12741435f, 
    0.10056135f, -0.13348190f, 0.13616635f, 0.14165339f, -0.09089303f, -0.03382740f, -0.02472900f, -0.04189108f, 
    -0.11277970f, 0.07117587f, -0.03038129f, -0.07210676f, 0.43905115f, 0.05313344f, 0.07366674f, 0.14523125f, 
    0.03942275f, 0.04203008f, 0.09355465f, -0.12311214f, -0.04337257f, -0.05322908f, 0.14534862f, -0.09551564f, 
    0.12239845f, 0.16007891f, 0.12888616f, -0.01040275f, 0.01050352f, -0.08790275f, 0.00124333f, 0.01420165f, 
    -0.07893546f, 0.01342530f, 0.16247196f, 0.00799597f, -0.24964216f, -0.25513124f, -0.00765398f, 0.04705047f, 
    0.07137360f, -0.01690994f, 0.01542035f, -0.03294848f, 0.09757344f, -0.13008019f, 0.02722814f, -0.03863385f, 
    -0.05768281f, 0.35543519f, 0.07904869f, -0.04903566f, -0.06590748f, -0.13609111f, -0.03529773f, -0.00200132f, 
    -0.11203934f, 0.03167943f, -0.00279813f, -0.04698193f, 0.25290465f, 0.20976055f, 0.20978291f, 0.41357535f, 
    -0.01638388f, 0.05574492f, -0.06381683f, 0.00157701f, 0.08329696f, 0.05827116f, 0.16287401f, 0.05730213f, 
    0.30404964f, 0.01269397f, -0.08081905f, -0.18983097f, -0.02216816f, 0.14151523f, 0.05330838f, 0.04219412f, 
    -0.00400464f, 0.24591704f, 0.10146502f, 0.20587942f, 0.14045727f, 0.35604164f, -0.18979311f, -0.12290889f, 
    0.11606268f, 0.08555305f, -0.09398184f, 0.08897378f, 0.11123447f, 0.08545590f, 0.08298531f, 0.00327192f, 
    -0.11443958f, -0.26382339f, 0.21993454f, 0.01731342f, -0.02932362f, -0.04168931f, 0.14479409f, 0.02007555f, 
    -0.07300058f, -0.02337909f, 0.05647711f, 0.04087955f, 0.09659620f, -0.06427848f, 0.28024408f, 0.10926563f, 
    -0.04865031f, -0.06282721f, -0.09639359f, 0.14763738f, 0.06830651f, -0.01515667f, 0.02782336f, -0.01699254f, 
    0.16512951f, 0.13017148f, -0.35280839f, -0.15706229f, 0.02389158f, 0.06907853f, 0.03006613f, 0.01109570f, 
    -0.04015468f, 0.02119506f, -0.04120855f, -0.05741725f, -0.04410237f, -0.21991667f, -0.09961168f, -0.07145061f, 
    0.08093537f, -0.13201939f, 0.05476982f, 0.25489828f, 0.05142036f, -0.04918051f, 0.03176532f, 0.02615089f, 
    -0.35528201f, -0.13332620f, 0.21876937f, 0.00553701f, -0.10265040f, -0.06836395f, 0.15725185f, 0.08122895f, 
    0.02663546f, -0.07609342f, 0.03090630f, -0.00127380f, 0.12658933f, -0.21253496f, -0.15148947f, 0.15413296f, 
    -0.02869551f, 0.05562827f, -0.12317089f, 0.16979764f, 0.05872428f, -0.06825394f, 0.04536335f, -0.04802930f, 
    0.12068292f, -0.01594492f, -0.16969395f, 0.08950547f, 0.01864870f, 0.03555074f, -0.05834463f, 0.05766235f, 
    0.08257607f, 0.09905638f, -0.03562595f, 0.16465548f, 0.15645908f, -0.11443409f, -0.08394873f, 0.05493704f, 
    0.03829862f, 0.04856539f, 0.06693005f, 0.03790982f, 0.04975168f, -0.15458730f, 0.08077082f, 0.19669625f, 
    -0.32163045f, -0.23185514f, 0.54640466f, 0.21538807f, 0.04492148f, 0.08148726f, 0.03966692f, 0.00646056f, 
    -0.09249856f, 0.03209162f, 0.06992985f, 0.04287327f, -0.39244449f, -0.12942092f, -0.15392642f, -0.04972468f, 
    0.01325949f, -0.13864020f, -0.06090268f, -0.03777532f, -0.03113679f, 0.09882363f, 0.20390263f, 0.01316611f, 
    0.00203754f, 0.22296990f, -0.03257429f, -0.07443155f, -0.11218435f, -0.06215090f, 0.01659104f, -0.08870748f, 
    -0.01219958f, -0.08449715f, -0.04781935f, 0.07593922f, 0.25883272f, -0.08562143f, -0.09860944f, -0.08954646f, 
    -0.02687521f, 0.11520825f, 0.15051772f, 0.06884257f, -0.05518483f, -0.03766906f, -0.00534128f, 0.06710176f, 
    0.03680071f, -0.00663589f, 0.15074910f, -0.00570852f, 0.01026990f, 0.00090796f, 0.08587431f, 0.02455185f, 
    0.14728624f, -0.03379302f, 0.15952349f, -0.07286458f, 0.44230491f, 0.04077579f, 0.04726255f, 0.20767894f, 
    -0.12700088f, -0.03477904f, -0.00205860f, -0.00121265f, 0.11943670f, 0.00755497f, 0.00982789f, 0.04147268f, 
    0.00408293f, 0.22692546f, 0.23957662f, -0.01657461f, 0.05873766f, -0.06873506f, 0.05329484f, -0.01689645f, 
    -0.04346849f, 0.20691387f, 0.09683654f, 0.09145936f, -0.36928964f, -0.38359669f, 0.18079610f, 0.44964409f, 
    -0.10323640f, -0.04503445f, -0.02629827f, -0.10097220f, 0.04751886f, 0.03854125f, 0.16647038f, 0.06230475f, 
    0.08997411f, -0.04043399f, -0.16554449f, -0.19501112f, -0.06903467f, 0.11228748f, -0.07795041f, 0.23100396f, 
    0.14672218f, 0.03965226f, 0.03053576f, 0.02702196f, 0.08150940f, 0.18944040f, -0.10692289f, 0.13097095f, 
    -0.00547851f, 0.00966101f, 0.06317715f, -0.00075321f, -0.03889530f, 0.09809136f, 0.09515364f, 0.00204256f, 
    -0.41597643f, 0.47333807f, 0.14513776f, 0.12260440f, 0.18606327f, 0.14503875f, -0.00575391f, 0.04127565f, 
    0.11682349f, -0.04727695f, -0.04589660f, -0.07265555f, 0.40646929f, 0.16066997f, 0.11958289f, -0.16071123f, 
    -0.06351238f, -0.04184000f, 0.05832400f, -0.06557865f, 0.02697907f, -0.11496031f, 0.06997793f, -0.12135088f, 
    0.23948081f, -0.09138843f, 0.14094377f, -0.03855516f, 0.06186354f, 0.03510881f, 0.04455908f, -0.09429359f, 
    0.03953529f, 0.05723359f, 0.04146637f, 0.03500203f, -0.15608332f, 0.18783069f, 0.11035567f, -0.03619007f, 
    -0.01467695f, -0.05919446f, -0.05112824f, -0.04949172f, -0.10616424f, 0.08019673f, -0.00156785f, -0.05779523f, 
    0.12827769f, -0.11383505f, -0.00872004f, -0.04038318f, 0.04923596f, -0.11992872f, 0.08155485f, 0.03108107f, 
    0.03908967f, 0.05773067f, 0.12087622f, 0.20770428f, -0.45762786f, -0.03279230f, 0.11576899f, 0.02373653f, 
    -0.13755400f, 0.03575437f, -0.05131405f, -0.03702388f, -0.00592862f, 0.07859926f, -0.03385659f, 0.04677383f, 
    0.03352956f, -0.18660860f, -0.21050914f, 0.07021219f, 0.11266285f, -0.02376002f, 0.01925538f, -0.08073718f, 
    0.01639269f, -0.05279576f, -0.00308648f, -0.01480000f, -0.21442913f, 0.15383831f, -0.07237802f, -0.01279770f, 
    0.05606563f, 0.03323949f, -0.03459263f, 0.09905084f, 0.13241896f, 0.08254410f, 0.01332247f, 0.05238990f, 
    0.03810139f, -0.02372685f, 0.10586951f, 0.33952552f, 0.04614055f, -0.05548246f, 0.16440360f, -0.05334958f, 
    -0.01575389f, -0.01661759f, 0.07359739f, -0.08515365f, 0.16323434f, 0.36832860f, 0.13409704f, -0.00578631f, 
    -0.00056349f, -0.00410306f, -0.12173161f, -0.05783532f, 0.04728679f, 0.08662777f, -0.03245261f, -0.04348737f, 
    0.17400639f, 0.08259626f, -0.04645253f, -0.13225684f, -0.00590006f, 0.12723027f, 0.03933993f, -0.03993076f, 
    -0.06096799f, -0.04106618f, 0.03512978f, -0.01963631f, 0.15082482f, -0.20366728f, -0.13269717f, -0.13316810f, 
    -0.02653709f, 0.04399432f, 0.09335985f, -0.09553910f, -0.04302770f, 0.00945521f, -0.12732162f, 0.07975459f, 
    0.22749676f, 0.06717199f, 0.03290391f, 0.09076642f, -0.04871296f, -0.14437173f, 0.02590831f, 0.13815707f, 
    -0.02979891f, 0.11085657f, 0.30171731f, 0.22652064f, 0.15830491f, 0.43475690f, -0.09437674f, -0.00156552f, 
    0.07217130f, -0.01560229f, -0.02764115f, 0.07202854f, -0.00937552f, 0.12081220f, 0.05289635f, 0.16259636f, 
    -0.10083391f, -0.11173832f, 0.19102822f, -0.09771045f, -0.06807697f, 0.00778706f, 0.01702971f, 0.03500664f, 
    -0.07889466f, 0.03348344f, 0.14583248f, 0.03029014f, -0.41865543f, 0.06218162f, 0.05827165f, -0.31036314f, 
    0.16443084f, -0.03191599f, 0.04455683f, 0.09565483f, 0.03325420f, 0.04195031f, 0.08081999f, -0.05007508f, 
    -0.17267983f, 0.03049142f, 0.00469227f, 0.30532193f, -0.10493947f, 0.09608147f, -0.00426817f, -0.02805523f, 
    0.06955720f, 0.01194117f, -0.01316034f, -0.09347033f, -0.49957636f, -0.03604496f, -0.16612585f, 0.21084806f, 
    0.25911811f, 0.09950867f, -0.05136595f, 0.10453270f, -0.04999983f, 0.05288482f, 0.00445089f, -0.01509673f, 
    0.10747132f, -0.05004611f, 0.18061931f, 0.22836639f, 0.26465741f, 0.00330808f, -0.03178509f, -0.04749763f, 
    0.08057866f, -0.04596809f, -0.26936010f, 0.02105931f, -0.28929138f, 0.04444062f, -0.39984596f, -0.14472874f, 
    0.24715929f, 0.07361721f, -0.02300852f, 0.08409155f, 0.07376472f, 0.02403169f, 0.10064519f, -0.14777525f, 
    -0.18854696f, 0.25101236f, 0.11869094f, -0.06857716f, 0.21286117f, -0.02880762f, -0.07049919f, 0.04628348f, 
    -0.04663594f, 0.02198508f, 0.13447838f, 0.14560109f, -0.05111663f, 0.16723134f, -0.03491561f, -0.03952845f, 
    0.12145795f, 0.01848880f, 0.05892198f, 0.01174060f, -0.07842954f, 0.05156797f, -0.09111091f, 0.05225989f, 
    0.20124492f, 0.07449011f, 0.04947246f, 0.04544366f, -0.03499434f, -0.16434959f, 0.01312128f, 0.09757173f, 
    0.11955868f, 0.06787915f, 0.08919101f, 0.03196530f, -0.33711740f, -0.21950096f, -0.04072653f, -0.19349493f, 
    -0.06902906f, -0.04912833f, -0.17249957f, -0.10664605f, 0.02563668f, 0.02907031f, -0.00911959f, 0.07540797f, 
    -0.56688052f, 0.00349128f, -0.19615509f, -0.05561027f, 0.17310411f, 0.10113271f, 0.06438871f, -0.27680400f, 
    -0.05323549f, 0.02011977f, -0.10172874f, -0.16333283f, 0.05095964f, -0.13985281f, -0.06509672f, -0.00270003f, 
    0.05593709f, 0.00741383f, 0.15258120f, 0.25790602f, -0.08350771f, 0.12318132f, -0.00592305f, 0.08797628f, 
    0.08510293f, -0.23979446f, 0.04251374f, 0.09697551f, 0.03273886f, -0.12465157f, 0.18201476f, -0.02276503f, 
    0.24065579f, -0.08414964f, 0.18521787f, -0.18289439f, 0.05398999f, 0.05440023f, 0.00790810f, -0.19105546f, 
    0.02923682f, 0.02148645f, 0.08639753f, 0.05204789f, 0.00984102f, 0.07971654f, -0.14999416f, 0.02087326f, 
    -0.36197874f, 0.10887796f, 0.13214992f, 0.09207270f, 0.06876955f, -0.05567914f, 0.15801966f, 0.02366911f, 
    0.04015388f, -0.00896244f, -0.01899490f, -0.01339196f, 0.06987271f, 0.14161184f, 0.11716759f, 0.15097651f, 
    -0.06301399f, -0.05826228f, -0.11727073f, 0.02035541f, -0.09964062f, 0.05036606f, 0.04946532f, 0.05059205f, 
    0.22826399f, 0.02357416f, 0.01305738f, -0.12965558f, -0.05205186f, -0.07844164f, 0.04356782f, 0.07725781f, 
    0.00145941f, 0.14557016f, -0.01743160f, 0.07471465f, -0.45783085f, -0.12654725f, 0.02842035f, 0.14106166f, 
    0.17295328f, -0.01369490f, -0.12491456f, 0.01511369f, 0.07688718f, 0.13841170f, -0.01830904f, -0.02799925f, 
    0.35795185f, 0.34606105f, -0.13842611f, -0.21008211f, 0.01512652f, 0.09180612f, -0.00437729f, 0.04629878f, 
    0.06134219f, -0.06682899f, 0.09097080f, 0.14328146f, -0.29715207f, -0.06585839f, -0.03949923f, 0.12454145f, 
    -0.01884456f, 0.05089669f, 0.01140554f, 0.12961243f, -0.02516459f, 0.06170465f, 0.14792749f, 0.08821346f, 
    0.10101385f, -0.15595384f, -0.05586796f, -0.17494339f, -0.09764629f, 0.00133839f, 0.04716864f, 0.13402720f, 
    -0.07399029f, -0.05522088f, 0.04696374f, 0.13551855f, -0.23525809f, 0.29708070f, 0.02688568f, 0.05482856f, 
    -0.06094991f, -0.08645443f, 0.02065776f, -0.05323622f, 0.04518721f, 0.01776725f, 0.01624790f, 0.03639160f, 
    -0.06758449f, 0.12837523f, 0.02444973f, 0.21893510f, -0.07557673f, -0.04339397f, 0.01757333f, 0.00364855f, 
    -0.01241075f, -0.16279602f, -0.11986722f, -0.06077584f, -0.42852157f, -0.05059396f, 0.13840720f, -0.20482391f, 
    -0.07398369f, -0.10449202f, -0.06356203f, -0.06179180f, -0.05546096f, 0.11377330f, 0.07064625f, 0.13623579f, 
    0.52949929f, 0.05166803f, -0.02577995f, 0.40297225f, 0.02723044f, 0.05362347f, 0.07414751f, -0.06442352f, 
    0.21492280f, 0.08040677f, -0.19155192f, 0.10054940f, -0.02405271f, 0.37900689f, -0.05215182f, -0.17589763f, 
    0.02349602f, 0.17532451f, -0.01449945f, 0.03420071f, 0.03921479f, 0.06961918f, 0.01996829f, -0.01698016f, 
    -0.20814781f, -0.14562127f, 0.03781613f, -0.37706304f, -0.03062667f, 0.09022013f, -0.00619777f, 0.10777933f, 
    0.04521761f, 0.07060041f, -0.04577095f, 0.04667917f, -0.38493487f, 0.09956662f, 0.00675317f, 0.01648575f, 
    0.02174293f, -0.04703035f, 0.01370269f, 0.00834383f, -0.04157452f, -0.03267848f, 0.03948512f, 0.16917299f, 
    0.14784445f, 0.08123758f, 0.13325316f, -0.09077149f, 0.22129084f, 0.01397901f, 0.10104597f, 0.05286533f, 
    0.09390468f, -0.03785492f, 0.03827184f, 0.04140189f, -0.10503341f, -0.01419414f, 0.04407384f, 0.22848220f, 
    0.14211434f, 0.09601239f, 0.11317436f, -0.05751045f, -0.07919351f, 0.14034861f, 0.08222689f, -0.03798999f, 
    -0.01033920f, 0.00111385f, 0.04796753f, 0.01291569f, 0.00542140f, -0.02001782f, 0.03964564f, -0.04418352f, 
    0.00958360f, 0.00017087f, -0.02116482f, 0.02809240f, -0.00671005f, -0.02854223f, 0.00360005f, -0.05517859f, 
    -0.00823596f, 0.06105473f, -0.04712263f, 0.00079520f, -0.03393973f, -0.03677800f, -0.06504444f, 0.04693614f, 
    0.04190149f, -0.06483775f, -0.04670710f, 0.01860655f, -0.05748073f, -0.01539598f, -0.04002021f, 0.02528888f, 
    -0.01954349f, 0.03769887f, 0.01538760f, 0.00182208f, 0.05001203f, -0.02718072f, -0.00268627f, -0.06097709f, 
    -0.06452913f, 0.01805509f, -0.01685372f, -0.05658868f, -0.01037151f, -0.04277895f, 0.03909456f, 0.04272170f, 
    -0.06785635f, -0.01457631f, 0.02521108f, 0.00038195f, -0.02253307f, -0.02748648f, -0.02191373f, 0.05774769f, 
    -0.07678200f, -0.06386158f, -0.04454688f, -0.01094730f, 0.04387631f, -0.04357228f, -0.02586653f, 0.04045497f, 
    0.00711116f, 0.02084169f, 0.06593799f, 0.02619319f, -0.06254185f, -0.03018199f, -0.07021298f, 0.04402987f, 
    -0.06869993f, 0.02208621f, 0.01656409f, 0.00940098f, 0.00175760f, -0.01493486f, -0.03162167f, -0.03914758f, 
    -0.02825386f, -0.04101853f, -0.05709089f, -0.06489125f, -0.02990488f, 0.03256261f, 0.03407784f, 0.02522270f, 
    -0.02055820f, 0.02598364f, 0.01544435f, -0.06437060f, 0.00369100f, 0.05547471f, 0.04931140f, -0.04144370f, 
    0.00138164f, -0.05487123f, -0.04591035f, -0.01256385f, -0.06046073f, 0.03033195f, -0.03427225f, 0.01344829f, 
    0.01361899f, -0.05984621f, -0.06091348f, 0.01682835f, -0.06748477f, 0.04365945f, -0.03292885f, -0.05862974f, 
    -0.05658497f, -0.02396285f, -0.01745396f, 0.03314048f, 0.04760448f, -0.00528213f, 0.05420063f, 0.06175217f, 
    -0.02704776f, 0.01293009f, 0.05802574f, -0.06560685f, 0.02179324f, -0.02425261f, 0.05538864f, 0.00492319f, 
    0.00853681f, -0.04371030f, 0.03658053f, 0.05330652f, 0.04697673f, -0.03642019f, -0.02290614f, -0.04264962f, 
    -0.07490687f, 0.04524531f, 0.04571138f, -0.00930014f, 0.01249110f, 0.01237184f, 0.05138030f, -0.01367703f, 
    0.03637207f, 0.04880802f, -0.06047421f, 0.00378935f, 0.04659122f, -0.07411412f, -0.06755102f, -0.03657648f, 
    0.06604034f, -0.07048492f, -0.07349031f, -0.05208187f, 0.03939768f, -0.00737728f, 0.05721484f, -0.07373002f, 
    0.02437844f, -0.05250623f, -0.05209006f, -0.06813783f, -0.06010223f, -0.06843839f, -0.07369762f, -0.03554261f, 
    0.01295599f, -0.05748834f, -0.06943263f, -0.07044788f, -0.02139634f, 0.01518379f, -0.07237843f, -0.00723705f, 
    -0.05095140f, 0.04417484f, 0.03964634f, -0.03295548f, -0.05297349f, -0.00191944f, -0.05258048f, -0.05151395f, 
    -0.00626646f, -0.04075356f, 0.01032709f, 0.02352478f, 0.03799677f, 0.01670593f, 0.00583477f, -0.01252367f, 
    0.29587200f, 0.03608396f, 0.12962210f, 0.07031829f, 0.02231721f, 0.05895293f, 0.00468072f, 0.00850884f, 
    0.12019559f, -0.08682087f, 0.03963581f, 0.04015293f, -0.11962494f, 0.24044676f, -0.31460112f, -0.27759102f, 
    0.11088534f, -0.15943161f, -0.09675635f, 0.07342064f, 0.04227301f, 0.07886101f, 0.02779884f, 0.06294721f, 
    -0.18408260f, -0.00730019f, 0.24145830f, 0.18507506f, 0.01509601f, -0.01560425f, 0.01407241f, 0.10102339f, 
    0.11831740f, 0.08533540f, -0.02351819f, 0.10493948f, -0.43434179f, -0.11408442f, 0.11440942f, -0.24198699f, 
    0.00945494f, 0.02559355f, 0.01554534f, 0.04431667f, -0.07326310f, 0.14965230f, -0.08631600f, -0.05448030f, 
    0.09824973f, -0.07519664f, 0.02827568f, -0.15570417f, 0.08537979f, -0.04024216f, -0.08515628f, -0.05795474f, 
    -0.02970845f, 0.08132852f, -0.05051693f, 0.00347174f, 0.12323929f, 0.06234782f, 0.42817777f, 0.01475633f, 
    -0.01351545f, -0.07714965f, 0.02252860f, 0.15889068f, -0.04254463f, 0.11581975f, -0.08627434f, -0.04653028f, 
    0.34970123f, 0.23291211f, 0.20351601f, 0.03332423f, 0.06265093f, 0.03000246f, 0.09676334f, 0.08781312f, 
    -0.06747217f, -0.08804003f, -0.01150698f, -0.06976742f, 0.05025285f, -0.11018838f, 0.06048167f, 0.04236805f, 
    -0.03404192f, 0.06132475f, 0.01861286f, -0.01102354f, -0.02627026f, -0.01999089f, 0.11884636f, 0.01084039f, 
    -0.14858696f, -0.04039089f, -0.18214339f, -0.07521993f, 0.15417923f, -0.13974486f, 0.04420230f, 0.12083617f, 
    -0.12037582f, -0.03785682f, 0.04041304f, 0.07279593f, 0.45736504f, -0.14509371f, 0.29885307f, -0.14065720f, 
    0.10728451f, 0.00446688f, 0.01032114f, 0.02981275f, -0.02460716f, -0.05527984f, 0.14632605f, -0.05090193f, 
    -0.43028647f, -0.37453443f, -0.09556646f, -0.00552247f, -0.15211403f, 0.16776331f, 0.06309663f, -0.04385409f, 
    0.01862905f, -0.08885145f, -0.04995572f, -0.09857350f, -0.31309351f, 0.16028224f, 0.19485335f, -0.20517813f, 
    -0.04732173f, 0.09340170f, 0.02358784f, 0.07846069f, -0.08291664f, -0.04664379f, -0.00585783f, 0.01025052f, 
    -0.00909392f, 0.36039883f, -0.13431656f, 0.06594731f, 0.10585823f, -0.04146617f, -0.04273484f, -0.08968984f, 
    -0.02098853f, -0.13043375f, -0.08310252f, -0.04819134f, 0.19567321f, -0.01671262f, 0.14273527f, 0.31110424f, 
    -0.09383926f, 0.05402900f, 0.00627230f, 0.00356638f, 0.02164369f, -0.02719274f, 0.07787844f, 0.06496580f, 
    -0.05473647f, 0.08982693f, -0.00308644f, 0.45088911f, 0.10445239f, 0.27000520f, 0.10238638f, 0.15965772f, 
    -0.10174210f, 0.14250335f, 0.02170249f, -0.10098264f, -0.25212964f, 0.03059999f, -0.20025440f, -0.14061362f, 
    -0.10629059f, 0.11831092f, -0.12493753f, -0.05299024f, -0.13217321f, 0.01935014f, -0.01293372f, 0.01302087f, 
    -0.14197935f, 0.12718952f, 0.04673458f, -0.10465611f, 0.05571012f, 0.05771180f, -0.01215856f, 0.08927040f, 
    -0.07297296f, 0.09356967f, -0.06474789f, -0.10175923f, 0.14201337f, 0.02352608f, -0.04959590f, 0.15233520f, 
    -0.23921016f, 0.12201039f, 0.03068409f, -0.08781283f, -0.09751428f, -0.05159190f, 0.04915383f, 0.05269571f, 
    0.14350195f, -0.21090071f, 0.17324446f, -0.47698045f, -0.19457600f, -0.14985776f, 0.16390602f, 0.07065090f, 
    -0.12113956f, -0.09956250f, -0.01360457f, 0.04662985f, 0.16318350f, -0.22381297f, 0.20049872f, 0.33753175f, 
    -0.21679616f, -0.04513279f, -0.01149687f, -0.05992511f, 0.08918005f, -0.03340396f, -0.10178524f, -0.06131766f, 
    0.21119648f, 0.35228935f, -0.25623569f, -0.35771817f, 0.01641126f, 0.03163553f, 0.08528282f, 0.07876997f, 
    -0.03587366f, -0.05236877f, 0.03473228f, -0.01806044f, 0.19148116f, -0.07155718f, -0.20602538f, -0.19936812f, 
    0.11284073f, 0.00516005f, 0.14705655f, 0.17518517f, 0.05781505f, 0.01730117f, -0.01026772f, 0.12934685f, 
    -0.26369470f, -0.27200511f, 0.20109102f, -0.24656363f, -0.03811078f, -0.08910292f, 0.07234149f, 0.02574455f, 
    0.09321742f, 0.04137082f, 0.21660379f, -0.08803567f, 0.24902175f, 0.11169105f, -0.05747322f, 0.13695438f, 
    -0.00587324f, 0.13193890f, -0.17001072f, 0.03916507f, 0.13447402f, -0.00027246f, 0.05347458f, 0.07302921f, 
    -0.01100267f, 0.05726247f, 0.01383055f, 0.04815601f, -0.04975519f, 0.07660600f, -0.03899066f, -0.03968893f, 
    0.03269024f, -0.02597416f, -0.05026545f, 0.00044693f, -0.18898967f, 0.10141196f, -0.17550901f, 0.29345667f, 
    -0.02421617f, -0.00070368f, -0.00134279f, 0.01656151f, 0.15182118f, 0.08970432f, 0.01195729f, 0.06218369f, 
    0.50408703f, -0.09159040f, 0.12075067f, 0.31460777f, -0.11651861f, -0.08795410f, 0.04659953f, -0.02558249f, 
    -0.08260451f, -0.02391774f, -0.05811411f, 0.10186427f, 0.02465812f, -0.12123972f, 0.05699525f, 0.01796827f, 
    -0.07955366f, -0.02031144f, -0.00237392f, 0.02123968f, 0.06929094f, 0.01752270f, 0.16949247f, -0.17631504f, 
    0.12999122f, 0.06472570f, 0.19669548f, 0.08573000f, 0.07347846f, -0.03983859f, 0.04717689f, 0.13626325f, 
    -0.05786650f, -0.06533948f, -0.00006345f, 0.05332778f, -0.12799576f, -0.08176426f, 0.00532853f, -0.01074573f, 
    0.13873747f, -0.05913933f, -0.25001219f, -0.03584697f, 0.14602320f, 0.00579242f, -0.00586017f, -0.13357334f, 
    0.18800430f, -0.00494087f, 0.22391923f, -0.44803241f, 0.06801078f, 0.05767845f, 0.01860083f, 0.08199482f, 
    -0.14766756f, 0.07418977f, -0.00780397f, 0.10917598f, 0.30316591f, 0.21847251f, 0.09063347f, 0.01421979f, 
    0.09299903f, 0.12548329f, 0.04870542f, -0.08432420f, 0.04728451f, 0.14138514f, 0.10359055f, 0.13372621f, 
    -0.04407574f, -0.04343666f, -0.07610036f, 0.00656058f, -0.02068096f, 0.02503528f, -0.01915365f, 0.02297525f, 
    -0.07428679f, -0.05075363f, -0.04209271f, -0.07517968f, 0.06073180f, -0.04357010f, 0.06044626f, -0.06174560f, 
    0.02495651f, 0.05511468f, 0.00166806f, -0.04199088f, 0.03934943f, -0.06654742f, 0.05497342f, 0.06388171f, 
    0.04467329f, -0.02269081f, -0.01511865f, 0.03645684f, 0.04642638f, -0.00769124f, -0.04373417f, -0.07615045f, 
    -0.07422116f, -0.05234051f, -0.02741292f, -0.07743410f, -0.06786991f, 0.05072800f, 0.05977786f, 0.02426982f, 
    -0.02802509f, 0.01194728f, 0.05637645f, -0.07128581f, 0.05259601f, -0.07736781f, -0.00934483f, 0.01906382f, 
    -0.01391097f, -0.06526415f, -0.04366078f, -0.06054987f, 0.05964025f, -0.05207983f, 0.02070646f, 0.03399131f, 
    -0.02858221f, -0.00402877f, -0.00944517f, 0.01480664f, -0.01492640f, -0.03615554f, 0.00420076f, 0.01362834f, 
    -0.03596758f, -0.01665582f, 0.00853530f, 0.01729258f, -0.02524344f, -0.02784909f, 0.03285147f, 0.06034198f, 
    0.01582252f, -0.00068893f, -0.03681392f, -0.00999134f, 0.05654755f, -0.03672373f, 0.00950664f, 0.00780717f, 
    0.01008327f, 0.00177062f, 0.02494895f, -0.04087463f, -0.02011234f, 0.00625885f, 0.01443800f, -0.07722571f, 
    0.02029725f, 0.05853573f, 0.00449599f, -0.03162664f, -0.02352780f, 0.02055121f, -0.06310911f, -0.02662816f, 
    -0.01741407f, 0.03922023f, -0.02975880f, -0.01039052f, -0.03223387f, -0.07760546f, -0.00225434f, -0.05387217f, 
    0.04951127f, -0.07580373f, -0.03615288f, 0.04665651f, 0.04475623f, 0.05164669f, 0.04283411f, -0.05239367f, 
    0.05282405f, 0.03521782f, 0.01967476f, -0.00673032f, 0.05595402f, 0.00729097f, -0.00768075f, 0.00809186f, 
    -0.05143610f, -0.03172150f, -0.05078944f, 0.03221169f, -0.03946845f, -0.03539980f, 0.06101361f, -0.04948279f, 
    0.03759516f, -0.05893918f, 0.00939279f, 0.04825285f, -0.03444376f, 0.01816256f, 0.05284214f, -0.07266729f, 
    0.06477857f, 0.04677632f, -0.04898873f, -0.06511840f, -0.07157496f, -0.06701095f, -0.07515476f, -0.04014402f, 
    -0.04884693f, 0.00580587f, 0.05924435f, -0.06329000f, 0.02869594f, -0.02139154f, -0.06175085f, -0.03604642f, 
    0.03437281f, -0.04748959f, 0.06103867f, 0.04519801f, -0.07128699f, 0.04555589f, 0.03980204f, 0.04636870f, 
    0.02081748f, -0.06689999f, -0.03856954f, 0.02337954f, 0.00553025f, -0.00854795f, 0.01834638f, -0.00326604f, 
    -0.00226423f, -0.04487832f, 0.02554091f, -0.00042372f, -0.01619169f, -0.03300419f, 0.01641880f, -0.06585830f, 
    0.00827906f, -0.01716693f, -0.00784198f, -0.04469166f, 0.00027438f, -0.04471043f, 0.05198955f, -0.01336536f, 
    -0.06028878f, -0.01730989f, -0.03996838f, 0.06459180f, -0.06819382f, -0.04966018f, -0.06805446f, -0.00851313f, 
    0.23515068f, 0.27395621f, 0.01152633f, 0.17161849f, 0.04655814f, 0.08834455f, 0.10094398f, 0.02102628f, 
    0.02500606f, -0.07188521f, -0.09026773f, 0.00618653f, -0.08653846f, -0.15534517f, -0.00751622f, -0.07817873f, 
    0.04428219f, 0.02525505f, 0.04837904f, 0.09527946f, 0.09914544f, -0.03051477f, -0.00973943f, -0.00488748f, 
    -0.17975456f, 0.21340942f, 0.01226199f, 0.42654273f, 0.20372459f, 0.20879826f, 0.01292446f, -0.02345351f, 
    0.18863425f, -0.05302659f, -0.07445519f, -0.05859778f, 0.43900344f, 0.38209951f, -0.07192687f, -0.08981974f, 
    0.01338128f, -0.01883179f, 0.11877573f, 0.20706941f, -0.05160361f, 0.00094240f, 0.07111998f, 0.12033761f, 
    -0.53201550f, -0.08117151f, 0.15405984f, 0.17768237f, -0.16766030f, -0.08673764f, 0.03626835f, 0.08711237f, 
    0.13996395f, 0.06248077f, 0.09510237f, 0.10411115f, 0.00578910f, 0.06497592f, -0.25797150f, -0.13168672f, 
    -0.04473964f, -0.06141918f, 0.02471967f, -0.12771566f, 0.11811260f, -0.01978138f, 0.06884960f, 0.02314948f, 
    -0.04340320f, 0.03970254f, 0.00386403f, 0.02242883f, 0.02602065f, 0.05829074f, 0.01982282f, -0.16955219f, 
    0.00550038f, 0.09231088f, -0.14528933f, -0.06917570f, -0.17105223f, -0.00865654f, -0.04901910f, 0.06051703f, 
    0.09541105f, -0.00657172f, 0.14480169f, 0.14511234f, -0.11156444f, -0.05106146f, -0.00363625f, -0.02805051f, 
    0.10250907f, -0.20377997f, -0.02789048f, -0.22361134f, 0.19740501f, 0.19197834f, 0.07938535f, -0.05201127f, 
    -0.09221538f, 0.10608654f, -0.01283183f, 0.00126502f, -0.00518291f, 0.09175511f, -0.06787136f, -0.09049337f, 
    -0.01351699f, 0.03225264f, 0.10331420f, 0.01390347f, 0.00151055f, 0.03711399f, 0.09431765f, -0.05929526f, 
    -0.14285934f, 0.42317763f, 0.04394970f, -0.39308012f, 0.07503986f, 0.04317759f, -0.01207849f, 0.09473562f, 
    -0.01480631f, 0.11822235f, 0.10900943f, 0.07812490f, -0.00295058f, -0.31152475f, -0.09444279f, 0.34159866f, 
    0.07801954f, -0.08565251f, 0.02245186f, 0.08857414f, -0.11624864f, 0.07582741f, 0.02768980f, -0.05322479f, 
    0.06933478f, -0.14413822f, -0.01281492f, 0.16458295f, -0.07144905f, 0.03645791f, 0.07284190f, 0.02681054f, 
    0.19308527f, -0.00781190f, 0.10219352f, 0.10312141f, 0.20274408f, 0.27021182f, -0.11678588f, -0.02710567f, 
    0.03140655f, 0.08487963f, 0.19926812f, 0.11750803f, 0.03637788f, -0.11468250f, 0.12103587f, -0.09559779f, 
    0.02407860f, -0.07407697f, -0.20951942f, 0.10856891f, -0.05047828f, 0.07002369f, -0.07173485f, -0.00577681f, 
    -0.07072538f, -0.03820256f, 0.01874426f, 0.04786902f, -0.29591689f, -0.27912188f, -0.04393350f, -0.17341100f, 
    -0.11897175f, -0.11601394f, 0.02990417f, 0.24098746f, -0.05926384f, -0.11730603f, -0.03210405f, 0.03635687f, 
    0.05932492f, -0.27526698f, -0.09299617f, 0.04571324f, -0.03497998f, 0.01139116f, -0.01991609f, -0.04280703f, 
    -0.01205870f, 0.05095079f, 0.02907395f, -0.19364169f, 0.57186812f, 0.31942949f, 0.17535704f, -0.13776641f, 
    0.03886765f, -0.12581795f, 0.04374393f, 0.00145122f, 0.01449480f, 0.08034407f, -0.07136340f, 0.01595745f, 
    0.02275833f, 0.34624955f, 0.02375477f, 0.10464647f, 0.04560813f, -0.09887598f, -0.05043446f, 0.05807010f, 
    0.12648940f, 0.04311962f, 0.00525262f, -0.03950235f, 0.32582024f, -0.03095671f, -0.08344107f, -0.27733421f, 
    -0.03592509f, -0.12144022f, 0.14667130f, -0.01710900f, 0.09944700f, 0.04548620f, 0.05645742f, 0.09482953f, 
    -0.23020139f, -0.62304723f, 0.29758447f, 0.44031927f, -0.07301109f, -0.08623739f, 0.00029629f, 0.01591400f, 
    -0.09017378f, 0.05560582f, 0.05619013f, -0.01611246f, -0.42354369f, -0.06730714f, -0.12573320f, -0.04353330f, 
    0.25789613f, 0.18618378f, 0.12551886f, -0.02552605f, 0.07112425f, 0.11307407f, 0.00563272f, 0.04972913f, 
    -0.00932109f, 0.15283193f, 0.09313826f, 0.04258952f, 0.07602558f, -0.14857639f, -0.16299187f, 0.00578532f, 
    0.06651936f, 0.03210006f, 0.02991591f, -0.19948974f, -0.01412828f, -0.07825835f, -0.13711607f, -0.07134844f, 
    0.19655186f, 0.02940288f, -0.02807387f, 0.10286907f, 0.14070435f, 0.02225330f, 0.09607028f, -0.14623693f, 
    0.13456140f, 0.06867267f, 0.15420347f, -0.01270645f, 0.08353735f, 0.16734509f, 0.06015372f, 0.02398061f, 
    0.03478843f, -0.01099156f, -0.06777135f, -0.07931586f, 0.30173337f, 0.22063057f, -0.28932741f, 0.15848002f, 
    0.17661630f, 0.11352178f, 0.09215367f, 0.06825959f, -0.09487203f, -0.03848736f, -0.02263889f, 0.07826268f, 
    0.35600108f, 0.33070794f, 0.26199043f, 0.11947452f, -0.13069309f, -0.08583749f, 0.07147103f, 0.01608670f, 
    -0.20035575f, 0.00397764f, 0.07994506f, 0.08670133f, 0.04984885f, -0.40430015f, 0.10420687f, 0.16085322f, 
    0.03303558f, -0.04751691f, -0.01034467f, -0.13313012f, -0.01501944f, 0.09438393f, -0.01812856f, -0.02194639f, 
    -0.05322619f, 0.04743168f, 0.09995238f, 0.05890458f, 0.03748458f, 0.04434559f, 0.03982630f, -0.06512515f, 
    0.12350075f, 0.13591519f, 0.07792336f, 0.00938444f, -0.24061364f, -0.19893000f, -0.14592206f, 0.04114808f, 
    0.06109256f, 0.04230079f, 0.01974359f, 0.06622527f, -0.09192976f, 0.01657260f, 0.04171017f, -0.01063811f, 
    -0.25698307f, 0.20358258f, -0.10183420f, 0.08936230f, -0.05837191f, -0.17012492f, -0.00276249f, 0.01738667f, 
    -0.08564509f, 0.03656089f, -0.06971680f, -0.08520118f, -0.03005338f, 0.12500334f, 0.14692837f, -0.09377389f, 
    0.16547187f, -0.08315696f, -0.13131094f, -0.00257807f, 0.10583597f, -0.15573622f, -0.05310744f, -0.01015244f, 
    -0.05384126f, 0.37943846f, 0.06162357f, 0.14965138f, 0.06300038f, 0.11665496f, 0.15166934f, 0.02793382f, 
    0.11387236f, -0.05829500f, -0.10112762f, -0.07271185f, -0.25148678f, -0.17543019f, 0.06544366f, 0.00216875f, 
    -0.02464984f, -0.05371115f, 0.07035256f, 0.18091507f, 0.03666032f, -0.13310581f, 0.12639651f, -0.13252048f, 
    0.01627512f, 0.09556899f, 0.11798185f, 0.35728595f, 0.19293627f, 0.10650817f, -0.06132649f, 0.09991981f, 
    0.23819517f, -0.02912699f, -0.09883806f, 0.11446610f, 0.18921055f, 0.26750591f, -0.06059048f, 0.20885538f, 
    -0.05949524f, -0.05220613f, 0.11022145f, 0.14611036f, 0.02207906f, 0.03202809f, -0.00879178f, 0.09583332f, 
    -0.46281856f, 0.18397562f, 0.22374599f, 0.06986067f, -0.04680813f, -0.16819890f, 0.02062666f, 0.12756884f, 
    0.12679265f, 0.00246084f, 0.10420962f, 0.18716535f, -0.04769734f, -0.11072404f, -0.31621912f, -0.47059873f, 
    -0.01142572f, 0.02569388f, 0.06406073f, -0.21365099f, 0.06640943f, -0.07340337f, 0.20685416f, 0.03084869f, 
    0.03456435f, -0.07027310f, 0.13923180f, -0.19400354f, -0.10838508f, -0.05322684f, 0.00161784f, -0.04691967f, 
    -0.02198507f, 0.06360517f, -0.06809761f, 0.05083781f, -0.36143783f, 0.18909688f, 0.02858575f, 0.20033765f, 
    0.13226932f, -0.10576474f, 0.16137776f, 0.12265674f, -0.17435780f, -0.01219334f, 0.02910107f, 0.01848021f, 
    0.02962774f, -0.09917612f, -0.11072168f, -0.04235389f, 0.12142384f, 0.14585306f, 0.02149649f, -0.03223487f, 
    -0.00870007f, -0.03810335f, -0.06393133f, -0.05920147f, -0.10320048f, 0.08986751f, 0.06298150f, -0.07240708f, 
    -0.04472840f, 0.02827636f, 0.15140173f, -0.19009420f, -0.01569309f, 0.12224042f, 0.07751347f, -0.00608711f, 
    0.14699036f, 0.28688151f, 0.06252448f, -0.09175525f, -0.10538490f, -0.08616807f, -0.00858958f, 0.09306396f, 
    0.03002801f, 0.00881463f, 0.04778461f, -0.01217880f, -0.06788385f, -0.16901432f, 0.02537891f, 0.34268016f, 
    -0.06026141f, 0.04783827f, -0.07364612f, -0.03820394f, 0.10192883f, 0.08519124f, 0.00146549f, -0.16579621f, 
    0.15507704f, -0.27093905f, 0.11391874f, 0.26904148f, -0.06435698f, -0.03206633f, 0.09736543f, -0.00041427f, 
    0.10126466f, 0.10525458f, 0.20458542f, 0.22037514f, -0.14289320f, 0.37349677f, -0.04871783f, 0.00679500f, 
    0.13694437f, -0.00893260f, 0.05248140f, 0.11401937f, 0.04783051f, -0.07820891f, 0.06365832f, 0.00808219f, 
    -0.02997629f, -0.02110418f, -0.18229556f, -0.15783043f, 0.10433512f, 0.15112045f, -0.03302236f, 0.07097522f, 
    0.00757657f, 0.05332727f, 0.09672070f, 0.23835665f, -0.38175300f, -0.28074932f, -0.13650219f, -0.11778019f, 
    0.07719156f, 0.13320273f, 0.03213636f, 0.15038030f, -0.12824471f, 0.01796617f, -0.01529735f, -0.01999520f, 
    0.00117845f, 0.01373976f, 0.02924934f, -0.03747787f, -0.00389752f, -0.02375934f, -0.06236618f, -0.03583748f, 
    -0.03612638f, 0.05308978f, -0.02172467f, 0.05146362f, -0.06266618f, 0.03304380f, -0.06962619f, -0.06703722f, 
    -0.06206507f, 0.00674602f, -0.02242619f, -0.02247616f, -0.03406803f, -0.06792931f, 0.00263698f, -0.06157082f, 
    -0.03748400f, -0.05914390f, 0.04982394f, 0.01658411f, -0.04236338f, 0.00696160f, 0.00960080f, -0.01634682f, 
    0.02097624f, 0.03456055f, 0.05832233f, 0.00246675f, -0.00243287f, -0.01183696f, -0.07084456f, 0.02936625f, 
    0.04974985f, -0.03058841f, 0.00614665f, -0.04438972f, 0.02308256f, 0.04665030f, -0.06041022f, -0.03505851f, 
    0.01080180f, -0.05809578f, -0.07319415f, -0.04086950f, -0.00309396f, 0.01442467f, -0.04149295f, 0.06293532f, 
    0.05150298f, 0.03399394f, 0.04868812f, -0.01156249f, 0.05997243f, 0.05728197f, -0.05733117f, 0.04697822f, 
    0.03584670f, 0.06125451f, 0.00306749f, 0.01716079f, -0.07414795f, 0.00694603f, -0.06390586f, 0.03379722f, 
    -0.06574310f, -0.02071846f, 0.03684491f, -0.03302040f, -0.04043806f, 0.02321393f, -0.00194285f, 0.02247022f, 
    -0.07744079f, 0.00565490f, -0.00634057f, -0.02318018f, -0.06758747f, 0.02154853f, -0.06315458f, -0.03792413f, 
    -0.06961619f, 0.02458265f, -0.05490876f, -0.06012810f, -0.01090470f, -0.02147391f, -0.03176812f, 0.06336385f, 
    -0.01668718f, -0.00632378f, -0.07264095f, -0.03498578f, 0.00666818f, -0.01986458f, 0.00191081f, -0.01865805f, 
    -0.02360225f, -0.04048978f, -0.00922176f, -0.05490006f, 0.06011604f, -0.03929020f, -0.06318281f, 0.04244605f, 
    -0.01360530f, -0.06359986f, 0.03759906f, 0.02889927f, -0.02203610f, -0.07166237f, -0.01665625f, -0.02476309f, 
    -0.07612623f, -0.04664051f, -0.00430599f, 0.03618639f, 0.05353250f, -0.06841304f, -0.02688070f, 0.03842920f, 
    0.06943630f, -0.02380728f, 0.05862991f, -0.02384839f, 0.06535045f, 0.01354669f, -0.00059786f, -0.04601218f, 
    -0.05474221f, -0.00485824f, 0.00349674f, -0.05817769f, -0.02651844f, -0.07224062f, -0.02686883f, 0.00769412f, 
    -0.02314055f, 0.02577592f, 0.03161700f, 0.05080492f, 0.04199383f, 0.00690404f, 0.06106033f, 0.00053916f, 
    -0.07711104f, -0.06268599f, -0.05841620f, 0.03485422f, 0.04521051f, -0.05461634f, 0.00878128f, -0.06778586f, 
    0.05211290f, 0.02823954f, 0.02704692f, 0.01018495f, -0.06320208f, -0.01945439f, 0.00168019f, -0.02657357f, 
    -0.03358898f, -0.07304291f, -0.07810787f, -0.00976615f, -0.00526966f, 0.05810328f, 0.01304658f, -0.07477985f, 
    0.02800808f, -0.07086323f, 0.01869834f, -0.05966975f, 0.06514085f, 0.00517633f, 0.05197249f, -0.02937002f, 
    0.05977856f, -0.05608452f, -0.02021017f, 0.02872023f, -0.06674530f, -0.04840954f, 0.04913931f, -0.02829788f, 
    -0.35040939f, 0.11402661f, 0.06323162f, 0.22328256f, 0.04737278f, 0.04194785f, 0.04484021f, 0.02188948f, 
    0.03473496f, -0.14154801f, -0.07050355f, -0.18521211f, -0.00701326f, 0.01677208f, -0.01765618f, -0.08301044f, 
    0.10329243f, 0.00272901f, 0.15487421f, 0.04934067f, 0.09540290f, -0.01368844f, -0.14611889f, -0.02710262f, 
    -0.05636293f, -0.09808920f, 0.17894544f, 0.12066265f, 0.09570583f, -0.01096229f, 0.14332068f, -0.12263960f, 
    0.10124308f, 0.01959638f, -0.10233166f, -0.00620735f, -0.34291032f, 0.10286014f, -0.03512822f, 0.07842261f, 
    0.12888220f, -0.00264541f, 0.01416887f, 0.01995984f, 0.06628584f, 0.09635215f, -0.11015441f, 0.10812366f, 
    0.33892593f, 0.08826473f, -0.03713571f, -0.33076206f, -0.00234221f, -0.13905047f, -0.03141253f, 0.14609234f, 
    0.03551682f, -0.06932627f, 0.15841077f, 0.11486081f, -0.36014012f, -0.02660697f, -0.02238097f, 0.13958201f, 
    -0.07647925f, -0.01175217f, 0.03403193f, 0.17371896f, -0.08159170f, 0.03500642f, 0.12846215f, 0.03549835f, 
    0.00460670f, 0.00374674f, -0.08743868f, -0.07570224f, -0.13736781f, -0.00357204f, 0.04948570f, 0.02854938f, 
    0.04784994f, -0.01880528f, 0.08676160f, -0.01825171f, -0.29112685f, 0.12292178f, 0.10677370f, 0.28991386f, 
    -0.05406516f, -0.11602956f, 0.22056001f, 0.16672866f, -0.05130334f, 0.03355572f, -0.06904121f, 0.13829030f, 
    -0.26192406f, 0.07641841f, -0.13385794f, 0.05404877f, -0.04867130f, 0.02237977f, 0.05263953f, -0.10509128f, 
    0.02415656f, -0.14012866f, -0.00399656f, -0.15896957f, -0.03602451f, -0.06333244f, 0.10554127f, -0.04570372f, 
    -0.02194465f, 0.03693987f, -0.07848696f, -0.04919800f, -0.12426666f, 0.11195818f, 0.23698901f, 0.03328140f, 
    0.09872912f, 0.06302260f, 0.12877427f, 0.07514722f, -0.02088705f, 0.24828559f, -0.00125074f, 0.05030116f, 
    0.09682839f, 0.10700960f, -0.05338920f, -0.07824571f, 0.31486771f, 0.36146247f, 0.14395554f, -0.02107483f, 
    0.04626467f, 0.09718873f, 0.07326437f, 0.04149423f, -0.01709513f, 0.04549037f, 0.08031747f, -0.04332203f, 
    0.03416208f, -0.17398416f, 0.04834422f, -0.36143568f, 0.00432700f, 0.06796802f, -0.15192516f, 0.21675806f, 
    0.05213661f, -0.09937600f, -0.04916162f, 0.27384746f, -0.31286258f, 0.10388350f, -0.07431116f, 0.12749004f, 
    0.01329021f, -0.11837272f, 0.07219429f, 0.01463346f, 0.00184824f, -0.00632153f, 0.13688947f, 0.09442396f, 
    -0.23172683f, -0.01186502f, -0.09244815f, 0.29540899f, 0.10646800f, -0.01976987f, -0.11348050f, -0.01953141f, 
    0.01059568f, 0.11146487f, -0.08692389f, 0.12033299f, -0.51720256f, -0.10020686f, -0.02567128f, 0.17275217f, 
    0.03902662f, 0.10181145f, 0.06473816f, 0.01756534f, -0.03039207f, 0.05961113f, 0.18766445f, 0.02008057f, 
    0.03028916f, -0.06925268f, 0.03035317f, -0.00627215f, -0.04287746f, -0.02728160f, 0.02979046f, -0.03751902f, 
    -0.07771891f, 0.02077740f, 0.03448499f, 0.05206674f, 0.03612798f, -0.05725035f, -0.08026278f, 0.00801382f, 
    -0.03099216f, -0.00236206f, 0.02571329f, 0.04693925f, 0.01642446f, 0.01786054f, -0.05005373f, 0.01440406f, 
    -0.06779632f, 0.02019145f, -0.04307999f, 0.06064779f, 0.03164554f, -0.07401984f, -0.00802179f, 0.04791744f, 
    -0.04189237f, -0.06501857f, 0.03432354f, -0.02284462f, 0.02634880f, 0.05260879f, 0.01159987f, -0.00977769f, 
    -0.04746210f, 0.03283209f, -0.07802018f, -0.05771591f, 0.04618162f, -0.01742931f, -0.03765675f, -0.04376203f, 
    -0.02492116f, 0.03813082f, 0.02758757f, -0.07561325f, 0.02652968f, 0.03097546f, -0.03988695f, 0.05216534f, 
    0.03013054f, -0.05615838f, -0.00511923f, -0.07224450f, 0.00360731f, -0.05637196f, 0.04678087f, 0.03001051f, 
    0.02660975f, 0.04029136f, 0.06039010f, 0.01619490f, -0.07723140f, -0.06057729f, -0.06257103f, 0.00959427f, 
    -0.07131465f, 0.06068024f, 0.04905378f, 0.03266203f, -0.02572474f, -0.02594605f, 0.05875986f, -0.02507897f, 
    0.04330778f, -0.06613756f, 0.01363822f, -0.02411789f, -0.00210975f, -0.03030447f, -0.02653427f, -0.06024576f, 
    -0.06633761f, -0.05971586f, -0.02857291f, -0.01363051f, -0.01074940f, -0.04342553f, 0.01522596f, -0.02691719f, 
    0.00033447f, -0.08041477f, -0.07992734f, -0.01283413f, -0.06233760f, 0.01941968f, 0.04752262f, -0.03746691f, 
    0.04135044f, -0.02049259f, -0.02929510f, -0.03449186f, -0.01289194f, -0.06546431f, 0.01740903f, 0.05446400f, 
    0.04826033f, -0.02702297f, -0.02838042f, 0.03604494f, 0.01437184f, -0.04995973f, 0.01564918f, 0.01491556f, 
    0.00340855f, 0.04715708f, -0.04259492f, -0.02631308f, -0.07645872f, -0.07250436f, 0.03096191f, -0.04313835f, 
    -0.05480272f, 0.02458269f, -0.03119923f, -0.04312519f, -0.07727784f, -0.05706164f, -0.06135339f, -0.02594144f, 
    0.03600134f, 0.05027003f, -0.04194910f, -0.00948200f, 0.04991657f, -0.02657000f, -0.06068897f, -0.05080966f, 
    -0.02387151f, -0.00280839f, -0.03356527f, 0.02213910f, -0.00356823f, -0.00312971f, 0.00728939f, 0.05128114f, 
    0.01320077f, -0.02253489f, -0.02758813f, -0.00402453f, -0.02257391f, 0.04967621f, -0.07282193f, -0.00538886f, 
    -0.08252228f, 0.04298929f, -0.07338358f, 0.03094821f, -0.08283114f, 0.06189696f, -0.05066450f, 0.05562833f, 
    0.03491468f, 0.04812987f, 0.01309639f, 0.01454832f, 0.01648521f, -0.01477224f, -0.01898149f, 0.03118582f, 
    0.02780687f, -0.06005737f, -0.07498797f, -0.07831120f, 0.00514819f, -0.03005956f, 0.01025637f, -0.01050887f, 
    -0.02781095f, 0.02519988f, 0.01940590f, -0.08214613f, -0.03564239f, -0.03847576f, -0.00599871f, -0.00439501f, 
    0.31607646f, 0.09113104f, -0.21207221f, 0.05342405f, 0.11312022f, 0.07775028f, 0.18005416f, 0.08857581f, 
    -0.12222616f, -0.02682605f, 0.06888317f, 0.12575851f, 0.22091630f, 0.00321394f, 0.10770975f, -0.18378381f, 
    0.03344224f, 0.13425773f, -0.06443831f, 0.17929694f, 0.02340612f, -0.10217030f, 0.03550955f, 0.05725596f, 
    0.05718042f, 0.11069167f, 0.19373961f, 0.27650803f, 0.21171930f, 0.01399169f, 0.04445453f, -0.10374870f, 
    0.07166062f, 0.03738182f, 0.05375479f, 0.01026846f, 0.07715922f, 0.18099990f, 0.06337256f, -0.17247452f, 
    0.13451259f, 0.06749909f, 0.16112961f, 0.17859335f, -0.00411789f, -0.08791726f, 0.07207902f, -0.07610265f, 
    -0.22418302f, -0.26112446f, -0.11553888f, 0.39744174f, -0.19353545f, 0.04656942f, 0.10389440f, 0.15630791f, 
    0.08717211f, 0.06478427f, 0.22267863f, 0.11539164f, -0.11055260f, -0.13910504f, -0.21306142f, 0.14989644f, 
    0.03585215f, -0.12967668f, -0.08290827f, -0.06968176f, 0.13182388f, 0.02568646f, 0.03464386f, -0.02633194f, 
    -0.07125304f, -0.06452804f, -0.02597738f, 0.21506418f, 0.25916803f, 0.08896507f, -0.04855832f, 0.01449127f, 
    -0.04592630f, 0.04628438f, -0.23818503f, -0.02604572f, 0.42860305f, 0.02428571f, -0.21403089f, -0.01940624f, 
    0.05967036f, 0.00692109f, 0.01435008f, 0.02229756f, -0.00658550f, -0.15343122f, 0.17230514f, -0.04418917f, 
    0.07114591f, -0.04230208f, 0.06100199f, -0.15246017f, 0.21180478f, 0.04057646f, -0.01853423f, -0.01798569f, 
    -0.12703994f, 0.00582639f, -0.05650878f, 0.03936216f, -0.01316529f, 0.13891058f, -0.26644504f, -0.13576134f, 
    0.02281661f, -0.03082316f, 0.09901359f, 0.03429172f, 0.02273021f, 0.08567214f, -0.04020313f, -0.05790079f, 
    0.05579654f, 0.39307582f, -0.00184041f, -0.28825429f, 0.16093417f, -0.10069055f, 0.14224523f, 0.05404291f, 
    0.07054021f, -0.05876934f, 0.09086837f, 0.15792939f, -0.38774425f, -0.49580380f, -0.10817733f, 0.08776627f, 
    0.05057820f, -0.08589247f, -0.11138337f, -0.06403767f, -0.02543396f, 0.03277081f, 0.02640383f, -0.09022106f, 
    -0.25324887f, -0.07686330f, -0.00085470f, 0.07582358f, -0.04001989f, 0.21946383f, -0.03309449f, -0.19518685f, 
    0.03609096f, 0.09712175f, -0.02745955f, 0.13720565f, 0.28760412f, 0.06750607f, -0.24934106f, -0.03979768f, 
    -0.19311827f, 0.06969383f, 0.13028239f, 0.09725811f, -0.12444066f, -0.06850642f, 0.10601120f, 0.04479313f, 
    0.30223298f, -0.03757234f, -0.17139854f, 0.07745332f, 0.11848465f, 0.03071716f, 0.06398249f, 0.04106396f, 
    0.11079622f, -0.04808620f, 0.03685140f, -0.09083736f, 0.01796891f, -0.09121504f, -0.01738817f, -0.11489255f, 
    0.11772767f, -0.00697325f, 0.02885004f, 0.17450145f, 0.08866721f, -0.00190091f, -0.16412733f, -0.13632151f, 
    0.09834726f, -0.14384145f, -0.39198244f, -0.32115617f, -0.00544427f, 0.10090217f, 0.07606188f, 0.07836568f, 
    0.12841377f, 0.15312295f, -0.04107906f, -0.04167992f, 0.22928910f, -0.04856583f, -0.03690919f, -0.11870114f, 
    0.07686724f, 0.16771644f, -0.10087970f, -0.07187057f, 0.15135188f, -0.02444148f, -0.01583544f, -0.07265288f, 
    -0.07062295f, -0.17029427f, 0.04479790f, -0.20764424f, -0.15053706f, -0.11463415f, 0.07475673f, 0.03202355f, 
    0.00775906f, 0.06646013f, 0.09657584f, -0.14478609f, -0.03736980f, -0.02683561f, 0.30015671f, 0.18112935f, 
    0.09938564f, 0.04127615f, -0.00679446f, 0.03830678f, 0.11952225f, 0.01265405f, 0.04928317f, -0.02492571f, 
    0.49279630f, -0.10970494f, -0.46124780f, -0.42400485f, 0.06550591f, 0.17808855f, -0.01591522f, -0.04155154f, 
    -0.10550974f, 0.03692099f, 0.08035013f, -0.01461355f, 0.30111313f, -0.07215542f, 0.32064173f, 0.29421788f, 
    -0.20085740f, -0.13145603f, -0.05616874f, 0.08056238f, -0.14555047f, 0.07696660f, -0.11687595f, 0.03931797f, 
    -0.44818333f, -0.06588314f, 0.01917306f, -0.10042582f, 0.04899162f, -0.00705359f, 0.02557501f, 0.27198607f, 
    -0.09965756f, -0.01980018f, 0.12671667f, -0.07138706f, 0.63680917f, -0.21882403f, -0.00463515f, 0.23956814f, 
    -0.10973300f, -0.01261743f, -0.17730032f, -0.09403372f, 0.12702888f, 0.00866174f, 0.04406537f, 0.02172656f, 
    0.21667832f, -0.13268811f, 0.14080031f, 0.05249070f, -0.02516785f, 0.03806940f, -0.04844577f, -0.13644218f, 
    0.03778484f, 0.03440349f, 0.03535022f, 0.11819610f, 0.17412174f, 0.06787349f, -0.12015269f, -0.02321567f, 
    -0.00548847f, 0.06386799f, -0.07276471f, 0.18339314f, 0.03341234f, -0.11073229f, 0.01546095f, 0.14877325f, 
    -0.23680684f, -0.23519392f, 0.02241746f, 0.26094738f, 0.05381270f, 0.14121614f, -0.00416796f, -0.15279651f, 
    -0.02164975f, 0.04888874f, 0.01333984f, -0.03369046f, -0.14389184f, 0.17003056f, -0.10656708f, -0.20125310f, 
    -0.02104091f, 0.08290843f, 0.14398685f, 0.13748856f, 0.01206584f, -0.10930277f, 0.10130844f, 0.10089357f, 
    0.22121860f, 0.26658109f, -0.11745542f, -0.24356470f, -0.12346737f, 0.12248640f, -0.18412626f, 0.12810999f, 
    -0.04685827f, 0.00167523f, -0.00424603f, 0.09545873f, 0.26677826f, -0.20355093f, -0.16897745f, 0.03680977f, 
    -0.08362766f, 0.16915774f, -0.08183187f, -0.13095035f, 0.09923637f, -0.01630477f, 0.03310360f, -0.04145770f, 
    0.15306112f, 0.14568481f, 0.05122394f, -0.02351797f, -0.06906196f, -0.12474688f, 0.19373816f, 0.07973998f, 
    0.01059708f, 0.05242581f, 0.02724277f, -0.11935476f, 0.35169253f, 0.05954344f, 0.07213835f, 0.22709599f, 
    -0.05874121f, -0.01174809f, 0.01537865f, -0.19648533f, 0.20054746f, -0.03593903f, 0.05448958f, 0.01849378f, 
    -0.29291815f, 0.00379517f, 0.03198223f, 0.10675783f, 0.06133835f, 0.03663102f, -0.10032560f, 0.06959670f, 
    0.01286493f, 0.00075377f, -0.21501319f, -0.07311966f, 0.29379651f, 0.19164000f, -0.10408692f, -0.18011709f, 
    -0.14475848f, 0.05997001f, -0.06296320f, 0.01204548f, -0.01568282f, 0.02138079f, -0.11362463f, -0.00784634f, 
    0.21640311f, -0.24692640f, 0.02942439f, -0.11559632f, 0.00743887f, -0.13765515f, 0.15648311f, 0.01142859f, 
    -0.20869206f, -0.07945338f, -0.02371159f, -0.10520945f, 0.05573588f, -0.34200728f, -0.01512154f, 0.31316766f, 
    -0.14151827f, -0.06735080f, 0.02843104f, 0.00361354f, 0.06120991f, 0.02091933f, -0.09304310f, -0.01768777f, 
    0.33059090f, 0.30368009f, -0.28691730f, -0.41647464f, -0.10616343f, -0.04184003f, 0.08189276f, 0.01013520f, 
    -0.05506400f, -0.04216034f, -0.06772853f, 0.10548584f, 0.10183059f, 0.08881717f, -0.07662521f, 0.22263898f, 
    -0.00261379f, 0.01270647f, 0.08150049f, 0.14803454f, -0.02394256f, -0.05252530f, 0.08853087f, 0.05056457f, 
    -0.16611454f, -0.05172684f, 0.01707615f, -0.12689681f, -0.15219016f, -0.23279990f, 0.10344626f, -0.05116932f, 
    -0.09889835f, 0.03901886f, 0.29313484f, 0.00253168f, 0.32348150f, -0.01601900f, 0.01873311f, 0.01885618f, 
    -0.13586339f, 0.09555987f, -0.17824453f, 0.15359733f, 0.06736960f, 0.05320026f, 0.09367746f, -0.02554428f, 
    0.13096420f, -0.07330491f, 0.02597360f, 0.18258131f, -0.09926365f, 0.19162451f, 0.01593731f, -0.13808838f, 
    0.01404016f, -0.01759033f, -0.07719801f, -0.04837223f, -0.19276655f, 0.01951280f, -0.07513125f, 0.15369552f, 
    -0.13796367f, -0.01457570f, -0.07721714f, -0.05070912f, 0.15339775f, 0.01338916f, 0.14215164f, 0.11317047f, 
    0.50046241f, 0.19097538f, 0.27487060f, 0.24574767f, -0.09554027f, -0.02667196f, 0.05792637f, -0.03201030f, 
    -0.13824128f, 0.12091360f, -0.05084397f, 0.10332209f, -0.02193874f, 0.12396156f, -0.04352498f, -0.03718931f, 
    -0.12558220f, 0.13257888f, 0.15181586f, -0.05174376f, -0.13848287f, -0.01435303f, 0.23505913f, -0.29619735f, 
    0.01868969f, 0.13768463f, -0.09013215f, -0.08387630f, 0.11637004f, 0.07983459f, -0.09170163f, -0.02480082f, 
    -0.07119983f, -0.07792566f, 0.01612476f, 0.18389058f, -0.16504745f, -0.09934089f, -0.03120213f, -0.23525760f, 
    0.06565659f, 0.03366242f, 0.01518453f, -0.01518959f, 0.08076425f, -0.11257319f, -0.04956502f, 0.01864013f, 
    0.27234441f, -0.19931808f, 0.37240452f, -0.07209437f, 0.15081783f, -0.04728578f, -0.00478945f, -0.04550481f, 
    -0.04556224f, -0.05720251f, -0.07015354f, 0.02388738f, 0.21905972f, 0.03753790f, 0.15566859f, 0.25169480f, 
    -0.02430637f, 0.09690802f, 0.05802532f, 0.06667241f, 0.07787006f, 0.04418411f, 0.18487716f, 0.01139657f, 
    0.19607809f, 0.19247608f, -0.22772494f, 0.15223850f, 0.04386685f, -0.05242852f, -0.12043411f, -0.02912437f, 
    0.02249436f, -0.17507386f, -0.23862721f, -0.04702017f, 0.01354773f, -0.03519708f, 0.02132563f, -0.11231985f, 
    0.10623512f, -0.01476960f, -0.01699076f, 0.09456142f, 0.07620928f, -0.18366085f, 0.02357246f, 0.04110403f, 
    -0.25096205f, 0.20035173f, 0.07062667f, 0.32413357f, 0.06741238f, 0.03621687f, 0.22336996f, -0.23309560f, 
    0.15429799f, -0.07546223f, 0.02888057f, 0.04524697f, 0.37545460f, 0.18302280f, -0.18671897f, -0.23361927f, 
    0.17673461f, -0.02822615f, 0.03342685f, 0.00076772f, 0.02965941f, 0.09766578f, -0.19224922f, 0.01404704f, 
    -0.19602799f, -0.30139711f, 0.12116901f, 0.07911044f, -0.08041584f, 0.03285758f, -0.11567535f, 0.06431926f, 
    0.05661398f, 0.03536706f, 0.31422463f, 0.32405394f, 0.18379739f, 0.21523583f, -0.12226520f, 0.01626509f, 
    -0.02968015f, 0.02526704f, 0.05421166f, 0.00173091f, -0.14309664f, -0.01758210f, -0.05738530f, -0.03587553f, 
    -0.00943768f, -0.07821869f, 0.02256335f, 0.13259093f, -0.03204018f, -0.04271858f, -0.10741744f, -0.13874085f, 
    -0.05000200f, 0.03858346f, 0.21720764f, 0.00919670f, 0.14594929f, -0.03036200f, -0.01606748f, 0.07094177f, 
    0.06109095f, -0.03781743f, 0.08434995f, 0.16465688f, -0.23721130f, -0.13265572f, -0.04020802f, 0.02529962f, 
    -0.07543831f, -0.12948908f, 0.01434572f, -0.33944204f, 0.22615203f, 0.17491378f, 0.01036151f, -0.08836246f, 
    -0.04332123f, 0.02265069f, -0.02042380f, -0.25410238f, 0.26236141f, 0.14782017f, -0.06014179f, 0.11313592f, 
    0.00858481f, 0.11357983f, 0.12040707f, 0.12171024f, -0.09244643f, 0.13188121f, 0.30085477f, 0.10409614f, 
    -0.08801091f, 0.43416703f, 0.00823582f, -0.33735242f, -0.01482862f, 0.04692636f, -0.16793983f, -0.04526179f, 
    -0.17833255f, -0.08951810f, 0.16184238f, 0.09457240f, 0.52315778f, -0.22325335f, -0.03574558f, 0.13974741f, 
    -0.03962044f, 0.10743621f, 0.03314997f, -0.01610823f, -0.14359216f, 0.19719125f, 0.02700386f, -0.04135449f, 
    0.34638134f, -0.00956825f, -0.04701192f, -0.03598408f, -0.13821544f, 0.01710227f, -0.17641929f, 0.20573530f, 
    -0.03012142f, 0.03420703f, 0.29032761f, 0.23373623f, 0.23972546f, 0.06303768f, -0.28864256f, 0.20958558f, 
    0.00805735f, -0.03489253f, 0.00996881f, -0.01376186f, 0.08391229f, 0.01268177f, 0.05341632f, 0.05483607f, 
    -0.17125931f, 0.05126087f, -0.14722155f, 0.23496990f, -0.03430919f, 0.04179489f, 0.03794474f, 0.09021316f, 
    -0.18594937f, -0.01075865f, -0.09215076f, 0.08046462f, -0.25024110f, -0.11764249f, -0.15734698f, -0.23205666f, 
    -0.06955931f, -0.05853470f, 0.02175589f, 0.10378019f, -0.09606962f, -0.09373479f, 0.29063547f, -0.00328340f, 
    0.01460722f, 0.10064013f, -0.04978649f, -0.08047757f, -0.00169661f, 0.14685652f, 0.09624910f, -0.00224859f, 
    0.01576349f, 0.15764052f, 0.17404059f, 0.24180256f, -0.23965108f, -0.07929282f, 0.07377508f, 0.33375397f, 
    0.10455640f, -0.04249795f, -0.02252363f, -0.03364241f, 0.07037397f, -0.01197492f, -0.00356159f, 0.08690041f, 
    -0.20376253f, 0.31500572f, -0.00885309f, -0.31538466f, -0.05784309f, 0.12010007f, -0.00765680f, 0.00505196f, 
    0.15332848f, -0.01763269f, -0.04460938f, 0.12963367f, 0.12926635f, 0.12044705f, -0.06350846f, 0.06617934f, 
    -0.02570734f, 0.07558895f, -0.06705918f, -0.10901126f, 0.14791383f, 0.00622646f, 0.08704596f, -0.00590768f, 
    -0.38909227f, 0.08731939f, 0.09572379f, 0.12924105f, 0.23178567f, 0.07070777f, -0.08298568f, 0.10041355f, 
    0.04338383f, -0.08177277f, 0.08508021f, -0.10146379f, 0.18317048f, 0.06211182f, 0.02054163f, -0.34568912f, 
    -0.08429474f, 0.01709471f, -0.01481395f, 0.03043774f, 0.03962102f, -0.05470989f, -0.09054586f, -0.03457573f, 
    -0.02746899f, -0.13214020f, 0.08822527f, 0.01174419f, 0.19318824f, 0.14324954f, -0.01598861f, -0.01752890f, 
    0.02658906f, -0.04846967f, -0.05422010f, -0.03952961f, -0.22092566f, 0.14774841f, -0.04141240f, 0.17740060f, 
    0.20687072f, -0.05530477f, -0.00394526f, -0.14893688f, 0.05038783f, 0.01639921f, -0.08604367f, 0.00801766f, 
    -0.27865711f, 0.08640099f, 0.00534013f, 0.05030487f, 0.16348544f, -0.07773396f, 0.07816957f, 0.15504609f, 
    0.15494874f, 0.03886209f, 0.14787354f, 0.07783896f, 0.17861789f, 0.31517553f, -0.00180801f, 0.05233410f, 
    -0.05002381f, 0.02586647f, 0.15423931f, 0.09112115f, 0.00121166f, 0.05523417f, -0.07421079f, -0.04425927f, 
    -0.29094487f, -0.22679691f, -0.23641501f, -0.12249146f, 0.07493953f, -0.10119411f, -0.04919391f, 0.07461463f, 
    0.16124082f, -0.01422058f, 0.04094085f, -0.07790296f, 0.41259906f, -0.16047965f, 0.19150645f, -0.05783934f, 
    -0.07963333f, -0.08659738f, 0.08265060f, 0.07398031f, 0.07497266f, 0.00215227f, -0.07631082f, 0.09811518f, 
    -0.10088920f, 0.03780915f, 0.11969824f, -0.01342642f, -0.14330678f, -0.19764248f, 0.06933127f, -0.05538885f, 
    0.09741052f, 0.06253537f, -0.03782288f, -0.29377848f, 0.08071531f, -0.00262455f, 0.01250446f, 0.14037171f, 
    0.12220809f, -0.07206501f, -0.15020075f, 0.14025412f, 0.06293305f, 0.09015634f, 0.08760542f, 0.03226005f, 
    -0.32988006f, 0.23827974f, -0.17344077f, -0.15472794f, -0.23324561f, 0.04656132f, 0.01989776f, 0.04196673f, 
    -0.01598900f, 0.07481419f, 0.19748779f, 0.07913642f, 0.04115383f, 0.19493304f, -0.15810867f, -0.12200715f, 
    0.05964135f, -0.16915460f, 0.06326690f, -0.02652706f, 0.00792785f, 0.00391997f, -0.03669194f, 0.09317335f, 
    0.19223861f, 0.08242120f, 0.03714374f, -0.10782497f, 0.06206238f, 0.18492931f, -0.05822433f, -0.07400639f, 
    0.00717782f, -0.04271822f, -0.05616510f, -0.08656164f, -0.17256027f, -0.02679635f, -0.07117990f, -0.25422218f, 
    0.11349863f, -0.07627504f, -0.03914890f, 0.13284281f, 0.21854649f, 0.00953801f, 0.05267469f, -0.18363112f, 
    -0.31240940f, -0.28171268f, -0.01478641f, 0.52220678f, 0.14401188f, 0.09332156f, 0.04682053f, -0.03405781f, 
    0.12783951f, 0.05212791f, -0.03040859f, -0.11873302f, 0.20751520f, 0.16728857f, 0.08119827f, -0.09513371f, 
    0.05249853f, 0.15475820f, -0.09725565f, 0.00484646f, 0.04477991f, 0.04094100f, -0.04168585f, 0.10207885f, 
    0.29943302f, -0.09306998f, -0.11167724f, -0.26721185f, 0.07567468f, 0.00383417f, -0.01004505f, -0.09526793f, 
    0.10270190f, 0.11771996f, 0.02418198f, 0.16626388f, 0.22656181f, 0.03967061f, 0.26836768f, 0.19458993f, 
    -0.11229302f, -0.07183369f, 0.12153104f, 0.12801632f, 0.10385966f, -0.04491581f, -0.00417029f, 0.01940497f, 
    -0.11115908f, 0.10427101f, -0.08167251f, 0.13520414f, -0.23392567f, 0.02894730f, -0.00598321f, 0.06929894f, 
    0.00004806f, 0.12730274f, 0.05667519f, 0.00863505f, 0.14419098f, -0.36144653f, 0.12908210f, 0.21099778f, 
    -0.17063732f, -0.01649967f, 0.13642000f, 0.17338997f, -0.12842819f, 0.05758537f, -0.05829443f, 0.15463053f, 
    0.25998098f, -0.19524759f, -0.11523432f, -0.02383127f, 0.03356935f, 0.14234386f, 0.10852188f, 0.02105889f, 
    -0.05982409f, 0.07041496f, 0.05465999f, -0.00808846f, 0.24430817f, -0.29005781f, 0.24902269f, -0.10552637f, 
    0.07214204f, 0.19234066f, 0.00384583f, -0.01164942f, 0.00073009f, -0.04876047f, 0.22061583f, 0.05839482f, 
    -0.65198541f, -0.10174327f, 0.15737833f, -0.11432049f, 0.00274733f, 0.35669374f, -0.02513945f, -0.03552398f, 
    -0.01957735f, 0.17457183f, 0.06758428f, -0.04132890f, 0.02332214f, 0.28761303f, -0.10774396f, 0.12598214f, 
    0.12015744f, 0.12196814f, 0.07838432f, 0.11879759f, -0.11411136f, 0.03326424f, 0.00276465f, -0.04986256f, 
    0.39812919f, 0.03258214f, -0.29523286f, -0.11893632f, -0.00218010f, 0.07914376f, 0.01928402f, 0.16711207f, 
    0.05035798f, -0.05396574f, 0.08700536f, 0.19583127f, 0.25098759f, 0.19407743f, 0.01799164f, -0.03279882f, 
    0.02704716f, 0.09498332f, 0.14362913f, -0.14390939f, 0.04378949f, -0.01647019f, 0.05079730f, 0.04469348f, 
    -0.07917854f, 0.01823483f, -0.12811565f, 0.41889009f, -0.07320946f, -0.02857693f, -0.05356713f, -0.07394417f, 
    -0.02856396f, 0.11040461f, -0.01062357f, 0.03013040f, -0.16208586f, -0.18366137f, -0.12000215f, 0.08613347f, 
    -0.16652769f, -0.04867548f, -0.06925216f, 0.06420986f, 0.06656399f, 0.00565329f, 0.18843101f, 0.08956993f, 
    0.17764963f, 0.05890640f, 0.03257994f, 0.12397023f, 0.01722038f, -0.07239579f, -0.08417569f, 0.10288979f, 
    0.08874183f, 0.17138119f, 0.36338359f, 0.26361045f, -0.06448021f, 0.35083997f, -0.11147773f, 0.15282172f, 
    0.12760460f, -0.02413425f, 0.04639997f, 0.06791625f, -0.10814875f, 0.18969330f, 0.10361727f, 0.08067080f, 
    -0.17757605f, 0.05098339f, 0.13576183f, -0.18015331f, -0.10862855f, 0.05635414f, -0.12747560f, 0.04923442f, 
    -0.07217362f, -0.05151651f, 0.07279127f, 0.10311268f, -0.20439568f, -0.06880386f, -0.12707600f, -0.20525225f, 
    0.11563577f, -0.16866247f, -0.00393982f, 0.02260822f, 0.00166848f, -0.04272641f, 0.07644242f, -0.04224522f, 
    -0.35923618f, 0.16202661f, 0.16690259f, 0.38230041f, -0.04352732f, 0.01352136f, 0.07288177f, 0.00250149f, 
    -0.02708071f, -0.00525796f, -0.10439624f, -0.17647626f, -0.20592846f, 0.17163847f, -0.00569501f, -0.08055164f, 
    0.09294771f, 0.00518647f, -0.14248158f, -0.01625185f, -0.04719268f, -0.01267079f, -0.04977188f, -0.06630053f, 
    0.26988652f, 0.04090378f, 0.10090158f, 0.06338963f, 0.29877761f, -0.02487989f, -0.01674219f, -0.01844631f, 
    0.06377925f, -0.14045899f, -0.23203789f, 0.00800093f, -0.35827440f, 0.26017138f, -0.29164973f, -0.18680936f, 
    0.15137902f, -0.02230965f, 0.03462944f, -0.01824133f, 0.05766123f, 0.03399065f, 0.06427731f, -0.04971352f, 
    -0.28242460f, 0.24526343f, 0.09680108f, 0.00398926f, 0.15758702f, -0.00439274f, 0.03028261f, 0.17316601f, 
    0.13017081f, 0.01210861f, 0.18587811f, 0.04475073f, 0.24719056f, 0.18427919f, -0.03603330f, 0.06189079f, 
    0.09359939f, -0.07839709f, 0.15940155f, -0.06050878f, -0.10654595f, 0.00247146f, -0.15336245f, 0.02362504f, 
    0.02922319f, -0.03173161f, 0.03338395f, 0.12071817f, 0.04625901f, -0.12262233f, 0.12797132f, 0.13027212f, 
    0.15042531f, 0.00137493f, 0.09096824f, 0.01995941f, -0.11052820f, -0.08358563f, 0.09258816f, -0.16209184f, 
    -0.02659069f, -0.06641903f, -0.06707437f, -0.01696594f, 0.05285911f, 0.00735602f, -0.02933452f, 0.17815626f, 
    -0.41114277f, 0.21055631f, -0.01775320f, 0.08678415f, 0.09461465f, -0.09417199f, 0.07193559f, -0.24661995f, 
    -0.08862953f, 0.00519053f, -0.05761681f, -0.20586559f, 0.00616519f, -0.10835605f, 0.10039725f, 0.15058021f, 
    -0.00708295f, -0.02960692f, 0.13244422f, 0.27302602f, -0.04183360f, 0.09531105f, 0.02644054f, 0.04272250f, 
    -0.14034715f, 0.01645972f, 0.08133319f, -0.14856583f, -0.11693956f, 0.01067684f, 0.06222619f, 0.01356970f, 
    0.22252640f, -0.12671849f, 0.20671666f, -0.09661967f, 0.01824840f, 0.26823002f, -0.03828197f, -0.15026253f, 
    0.02755605f, -0.07453883f, 0.11971095f, -0.04554182f, -0.07658008f, 0.07569687f, -0.19683985f, 0.09294584f, 
    -0.06479257f, 0.00620215f, 0.01668313f, 0.02098282f, 0.00797950f, 0.02950828f, 0.05932417f, -0.02375629f, 
    0.00066592f, 0.00677231f, 0.04131959f, 0.02189829f, 0.05308039f, -0.06723663f, -0.05895436f, 0.03748541f, 
    -0.00304541f, 0.01542794f, -0.01126815f, 0.00302838f, 0.00032735f, 0.05907867f, -0.03467260f, -0.03072159f, 
    -0.07050721f, -0.01692044f, 0.03379082f, -0.01079152f, -0.01444645f, -0.07132670f, 0.05046332f, -0.03381614f, 
    -0.06548351f, 0.01149866f, 0.06452941f, 0.06494777f, 0.02310571f, 0.00398154f, -0.03063176f, 0.03547977f, 
    0.00303191f, -0.07409935f, 0.06051727f, -0.00898493f, -0.06650185f, -0.05659133f, -0.03134339f, -0.07332396f, 
    -0.07592995f, -0.00333503f, 0.01934534f, 0.01957011f, 0.03193441f, -0.03869094f, 0.01040597f, 0.03914248f, 
    -0.02545686f, 0.05863561f, 0.02653703f, -0.01863726f, 0.04377564f, -0.01311540f, -0.02002499f, -0.05239668f, 
    -0.01368764f, 0.05922797f, -0.06988726f, 0.00083799f, -0.04478774f, -0.06303091f, -0.02001917f, -0.07523605f, 
    0.00425053f, -0.05584040f, 0.06202829f, -0.05065586f, -0.04273188f, -0.06644519f, -0.06709574f, -0.01857175f, 
    -0.07155767f, 0.01482160f, -0.01161185f, -0.03517043f, -0.05320005f, 0.01917582f, -0.07418987f, -0.06075896f, 
    0.02666143f, -0.06752519f, -0.01538975f, 0.04488108f, -0.01416798f, -0.01016104f, -0.03932562f, -0.01588709f, 
    -0.07315975f, 0.05285484f, 0.05768187f, 0.02323186f, 0.01978736f, 0.00108507f, -0.01078696f, -0.06334751f, 
    -0.04044506f, -0.03229732f, 0.01623391f, -0.06028218f, -0.01376393f, -0.07851554f, -0.04356416f, -0.07665874f, 
    -0.02075908f, -0.03526825f, 0.00693288f, -0.03896996f, 0.01262835f, 0.05193124f, -0.06711672f, -0.02308043f, 
    -0.05802317f, -0.01211430f, -0.07735368f, -0.05067366f, 0.03140040f, 0.02832082f, 0.01278405f, -0.03169445f, 
    0.01584324f, -0.06173094f, -0.07026166f, -0.03782519f, 0.02747342f, 0.03215614f, 0.03060287f, -0.04015999f, 
    0.04043828f, -0.04922786f, -0.03658680f, 0.03271893f, -0.05879905f, 0.03416014f, 0.04587238f, -0.01366023f, 
    0.01667829f, -0.00101192f, 0.01065631f, 0.02910542f, -0.01913874f, 0.06002111f, 0.05886314f, 0.02305576f, 
    0.00015079f, -0.07451676f, -0.00593365f, -0.03629766f, 0.05380413f, 0.00563698f, -0.02451141f, -0.02820250f, 
    0.06522121f, 0.05843192f, -0.04697452f, 0.02937518f, 0.01072981f, -0.06708899f, -0.00910882f, 0.04820668f, 
    0.00102633f, 0.06139188f, -0.05538949f, -0.00422075f, 0.01019602f, 0.01680370f, 0.02703994f, 0.04796956f, 
    -0.00496277f, -0.05519770f, 0.02949953f, -0.04284965f, -0.04041465f, -0.00364705f, -0.01380005f, -0.07190681f, 
    -0.00003672f, 0.00359929f, -0.07505548f, 0.01530320f, -0.07095669f, 0.02686472f, -0.06233857f, 0.04171761f, 
    -0.03662524f, 0.01895824f, 0.00009526f, -0.00204750f, -0.01525015f, 0.01487762f, -0.02525545f, -0.16977082f, 
    -0.12949651f, -0.01874286f, 0.01680109f, 0.14514343f, 0.03758752f, -0.21728235f, 0.21415623f, 0.29372686f, 
    -0.08097582f, 0.05408036f, 0.00643078f, -0.12995559f, 0.01870267f, 0.13407485f, 0.11702934f, -0.03415561f, 
    0.20190856f, -0.01232664f, -0.37796825f, 0.04472685f, 0.00145905f, 0.02289052f, -0.11475024f, -0.02038091f, 
    -0.11906804f, -0.13764958f, 0.00201277f, -0.18955518f, 0.52784258f, 0.03950044f, -0.00583404f, 0.19633387f, 
    -0.06021575f, 0.02277590f, -0.01251687f, 0.01132107f, 0.08260724f, 0.00130704f, 0.10082074f, -0.07541666f, 
    -0.06564666f, 0.36780891f, 0.10790947f, 0.29869995f, -0.07280839f, 0.17338215f, 0.12311278f, -0.05370579f, 
    0.09772613f, -0.06657696f, -0.07768674f, -0.02758087f, 0.05280082f, 0.03859492f, 0.01262575f, 0.28486124f, 
    0.05786099f, 0.10137288f, -0.08301424f, -0.15354906f, 0.07086806f, -0.19744746f, 0.14715010f, 0.00891473f, 
    -0.16461454f, 0.02700377f, -0.13268214f, 0.10208624f, 0.05977209f, 0.04012796f, 0.01953279f, -0.06177473f, 
    0.07552130f, 0.01077616f, -0.12196849f, 0.02104292f, -0.26546723f, 0.01185209f, 0.00904163f, -0.28878653f, 
    0.07733775f, -0.02815392f, 0.09071137f, -0.08356249f, 0.11065489f, 0.09897864f, -0.01737362f, 0.01867137f, 
    0.18580076f, -0.05005687f, 0.22849174f, -0.05999263f, -0.21648328f, 0.05015248f, 0.03093698f, 0.13098130f, 
    0.06295990f, 0.02191266f, -0.11508375f, 0.11852702f, -0.34571201f, -0.09910256f, -0.11681981f, -0.04809185f, 
    0.04638975f, 0.11050943f, 0.08963390f, 0.06642777f, 0.03808361f, 0.00840312f, -0.18355684f, 0.04905641f, 
    0.28848085f, 0.23265816f, 0.26945490f, -0.09204552f, 0.00914494f, -0.02674398f, -0.05631074f, -0.09103961f, 
    0.10160261f, 0.13425225f, 0.04237333f, -0.03255916f, 0.25190905f, 0.06799050f, -0.24207081f, 0.27387583f, 
    0.01163807f, -0.02493997f, 0.02749227f, -0.14703289f, -0.09355734f, 0.07971817f, -0.04719685f, 0.14745162f, 
    0.08277384f, -0.18400009f, 0.05577848f, 0.16577810f, -0.03345535f, -0.03220564f, 0.21868540f, -0.04463679f, 
    -0.05387448f, 0.07721932f, 0.04928686f, -0.19238168f, -0.09582317f, 0.03528729f, 0.11227517f, -0.25575560f, 
    -0.01352915f, 0.04873880f, 0.08930118f, 0.01212354f, -0.03464440f, -0.00856526f, -0.10853905f, -0.08311503f, 
    0.21701443f, 0.05123224f, 0.14391910f, -0.25821748f, -0.20431104f, 0.01253658f, 0.09538655f, -0.12736045f, 
    0.20627403f, -0.04649720f, -0.00953815f, -0.00689536f, 0.27858031f, -0.13687536f, 0.14920896f, 0.02180760f, 
    -0.03306844f, -0.06448881f, 0.09519622f, 0.16971983f, 0.07790843f, -0.14104359f, -0.06332177f, -0.00182013f, 
    0.02420297f, -0.00731308f, 0.05215472f, -0.01680595f, 0.00632086f, -0.04610517f, -0.05343245f, -0.07370379f, 
    -0.00165529f, -0.01488536f, 0.01304344f, -0.00003913f, 0.02497968f, -0.06123398f, -0.06991711f, -0.05554878f, 
    0.05515543f, -0.01241058f, 0.05125315f, -0.04586005f, 0.00229187f, -0.05616811f, -0.03979414f, -0.07479324f, 
    0.00619309f, 0.02188144f, -0.00752433f, -0.05498632f, -0.04944624f, -0.02219832f, 0.02410207f, -0.07072508f, 
    -0.07001836f, -0.03469515f, -0.04791661f, 0.02495531f, 0.01906427f, -0.02148863f, -0.00489697f, 0.00092467f, 
    0.00580035f, 0.03516883f, 0.00318267f, -0.01119527f, 0.04365283f, 0.03883203f, -0.05025016f, -0.04563323f, 
    -0.01964643f, -0.02798473f, -0.05977782f, 0.00661098f, 0.02695188f, -0.00800158f, -0.03163412f, -0.07163143f, 
    -0.02852284f, 0.05428921f, 0.01648408f, 0.05104476f, 0.04432935f, -0.04617287f, 0.01477685f, 0.00386523f, 
    -0.05443543f, -0.03690745f, -0.05634883f, -0.03532854f, 0.06264900f, -0.02868768f, -0.09097015f, 0.01713898f, 
    -0.06684951f, -0.03980466f, 0.06612558f, 0.06982186f, -0.00547754f, 0.05905227f, -0.06626201f, -0.05765019f, 
    -0.05016365f, 0.01338095f, 0.04716811f, -0.06981829f, 0.05608786f, -0.02117409f, -0.04084024f, 0.00127271f, 
    0.02691955f, -0.02771521f, -0.01268611f, 0.00647537f, 0.05598858f, 0.06426100f, -0.02786080f, -0.04862900f, 
    0.00812767f, -0.06395648f, -0.07413241f, 0.01882628f, -0.07308007f, -0.03141513f, 0.03720829f, -0.05940628f, 
    -0.06592158f, -0.03117458f, -0.03438081f, 0.06318372f, -0.03709130f, 0.01425683f, -0.05290373f, 0.04136495f, 
    0.02459338f, 0.05341820f, 0.03613874f, -0.06383755f, -0.00201380f, -0.00141290f, -0.01635814f, -0.05158157f, 
    -0.08431306f, 0.04367796f, 0.03179547f, -0.00756059f, 0.03289622f, 0.03456103f, 0.03036017f, -0.03819546f, 
    -0.04080088f, -0.07269233f, 0.03400815f, -0.06466217f, 0.01482480f, 0.00248513f, -0.05742718f, 0.00733223f, 
    -0.01095058f, 0.03417289f, 0.03603009f, 0.04488008f, -0.02281305f, 0.03769760f, -0.04326578f, -0.06661783f, 
    -0.05371908f, 0.06048750f, -0.07090242f, -0.02176120f, -0.01908201f, 0.05370254f, 0.02198750f, 0.03250136f, 
    0.05197363f, -0.06465241f, -0.03031954f, -0.03144411f, 0.04151834f, 0.03717415f, -0.06768369f, 0.00565045f, 
    -0.01407043f, 0.01883337f, -0.05794623f, -0.02796652f, 0.05169630f, -0.02629967f, 0.02042507f, -0.07660138f, 
    -0.05338757f, -0.07144234f, 0.06982498f, -0.03157686f, -0.04712161f, 0.02814415f, 0.00077322f, -0.06134536f, 
    0.03623943f, -0.02364966f, -0.07437921f, -0.03616149f, -0.03018324f, 0.02572955f, -0.01287129f, -0.00654504f, 
    -0.05684859f, 0.02001256f, 0.05040871f, -0.02206653f, -0.05107081f, 0.03028276f, 0.04553104f, -0.08107934f, 
    -0.01894516f, -0.07940120f, 0.00445820f, 0.22340813f, 0.05082491f, -0.02028239f, 0.05548846f, 0.01069664f, 
    -0.02425778f, -0.21185377f, -0.02700291f, 0.01362352f, -0.07731981f, 0.03926066f, -0.05646028f, 0.03087898f, 
    0.05821106f, 0.06685854f, 0.04978002f, -0.01952925f, -0.00524564f, -0.09246749f, -0.07193103f, -0.02475231f, 
    -0.21975201f, 0.11386449f, 0.13379407f, -0.17804603f, 0.04521079f, -0.02859931f, 0.13120744f, -0.03927328f, 
    -0.09385163f, 0.07006435f, 0.04731993f, 0.07340385f, -0.10532056f, -0.03007834f, -0.10876571f, -0.02428443f, 
    -0.05565243f, 0.04456718f, 0.18667552f, -0.14051560f, -0.08700636f, -0.09389454f, -0.07828298f, 0.02606298f, 
    0.05723653f, -0.06417035f, 0.22673297f, 0.18561734f, 0.11874123f, -0.07941222f, -0.02403944f, 0.00567074f, 
    0.06635965f, -0.10076510f, 0.05069998f, -0.11289489f, 0.20420089f, 0.30740011f, -0.01440434f, 0.11932442f, 
    -0.01983053f, 0.05056679f, 0.02917238f, 0.04510857f, -0.00454673f, 0.20178792f, -0.10515706f, 0.02488246f, 
    0.36792916f, 0.29920703f, -0.05712642f, 0.08874992f, 0.07509369f, 0.03620819f, -0.08767582f, -0.16531837f, 
    0.09648090f, 0.06768098f, 0.17622091f, -0.03675704f, 0.01756513f, 0.17015512f, 0.04558001f, -0.06129670f, 
    0.14258134f, 0.03452856f, 0.00840941f, 0.06064600f, 0.13359085f, 0.01814994f, -0.15867367f, 0.07315816f, 
    -0.42049280f, 0.16487518f, -0.02286728f, -0.06018454f, 0.10932318f, 0.01858065f, 0.04773993f, 0.11334947f, 
    -0.00851550f, 0.02179351f, 0.24220176f, -0.07636505f, 0.42314073f, 0.22142521f, 0.07044806f, 0.15195310f, 
    0.01020175f, 0.04941909f, 0.00167535f, 0.04804339f, -0.14518502f, 0.12804919f, 0.00711493f, -0.17189337f, 
    0.05114519f, -0.08472179f, -0.23355508f, -0.10403185f, 0.00601063f, 0.09400816f, 0.08433165f, 0.04157224f, 
    -0.08339638f, -0.06497260f, -0.05110440f, -0.13458849f, 0.39588389f, 0.10505878f, 0.32685083f, -0.03540202f, 
    -0.13045442f, 0.07742466f, 0.04627412f, -0.02827970f, 0.11155104f, 0.01882848f, -0.13897863f, -0.01731559f, 
    -0.01343654f, 0.20110586f, 0.06136422f, 0.03514384f, 0.15477087f, 0.00958861f, -0.06737123f, 0.00665869f, 
    0.05701131f, 0.05060880f, 0.01085250f, -0.12006997f, 0.01341031f, -0.08946674f, 0.12155896f, 0.31787497f, 
    -0.01292727f, -0.00234806f, -0.12304135f, 0.08403084f, -0.02264347f, 0.07432607f, 0.07620292f, -0.10043260f, 
    -0.16891338f, 0.00577987f, -0.02959052f, 0.10425578f, -0.01178689f, 0.07033129f, -0.07505931f, -0.10360673f, 
    -0.25551254f, 0.12128306f, -0.06887288f, 0.04313789f, -0.31267911f, 0.09381687f, -0.06884336f, -0.20947854f, 
    0.05717966f, 0.00347247f, 0.01163422f, -0.10916068f, -0.02085762f, 0.00899283f, 0.12984650f, 0.02275299f, 
    -0.08493882f, 0.02846486f, 0.22722641f, 0.14955860f, 0.18463378f, -0.09472317f, 0.01201379f, -0.03340756f, 
    -0.07022246f, -0.02153662f, 0.15106203f, 0.09124862f, -0.23938343f, -0.37546849f, 0.26216403f, 0.47942126f, 
    -0.05814954f, 0.10127618f, -0.09181213f, -0.19408797f, -0.01090355f, 0.01888563f, 0.09710766f, 0.05292355f, 
    0.14579955f, 0.12042323f, -0.25306731f, -0.26261514f, -0.15986808f, 0.01489996f, -0.01164655f, 0.10371734f, 
    -0.10127877f, 0.22865622f, -0.01245481f, 0.05277307f, -0.33713549f, 0.15698940f, -0.05020831f, 0.06040092f, 
    0.05925737f, 0.12561287f, 0.00227180f, -0.08437488f, -0.03511996f, -0.02820704f, 0.02045333f, -0.15201528f, 
    0.24052173f, 0.30790350f, 0.11190295f, 0.19627862f, 0.09017376f, 0.10991623f, -0.04662004f, -0.01094654f, 
    0.00080934f, 0.04163973f, -0.01018936f, -0.07650107f, 0.36080858f, 0.14721969f, 0.23660116f, 0.26986256f, 
    -0.08029404f, 0.03261818f, -0.01416115f, 0.01128461f, -0.11227260f, 0.00299691f, -0.08996211f, -0.08954693f, 
    0.36661941f, 0.01310402f, -0.01848293f, 0.15680122f, 0.28884968f, 0.24686635f, 0.08715751f, -0.04695929f, 
    -0.05358340f, 0.08405708f, -0.07090505f, 0.16316496f, -0.10536758f, 0.28522810f, 0.04686553f, -0.05873797f, 
    -0.04266417f, 0.02640813f, -0.00633395f, -0.18218395f, 0.00528500f, 0.19611585f, -0.08878804f, 0.00070998f, 
    -0.22314225f, 0.17291492f, 0.10254896f, -0.08564623f, -0.09013309f, -0.34806871f, 0.04205380f, 0.18112090f, 
    -0.04183614f, -0.10119081f, 0.17795108f, 0.07458990f, -0.24646924f, -0.07590853f, 0.20351936f, -0.14713179f, 
    -0.13713506f, -0.06381916f, -0.05272994f, 0.13809690f, 0.02834945f, 0.09966429f, -0.05120573f, -0.02659215f, 
    0.09984474f, -0.13442697f, -0.44430712f, 0.08993810f, 0.11983920f, -0.01066949f, -0.00848992f, -0.08373334f, 
    0.23673420f, -0.07643506f, -0.05907659f, -0.00427777f, 0.20638445f, 0.37807745f, 0.01839496f, -0.14463845f, 
    -0.05008709f, 0.03398798f, 0.04009685f, 0.15273082f, 0.08384735f, -0.02652563f, -0.20011513f, 0.16571653f, 
    -0.09997209f, 0.01882829f, 0.01902485f, 0.03939752f, 0.09641809f, -0.09980872f, 0.04029787f, 0.15023439f, 
    -0.04084118f, 0.05351610f, -0.00374544f, -0.19672738f, 0.13174666f, 0.19646613f, 0.18907721f, 0.07625330f, 
    -0.07571656f, -0.13930568f, -0.12482096f, -0.06674527f, 0.05495563f, 0.27411172f, -0.10700232f, 0.07716381f, 
    0.05102361f, -0.03501001f, 0.05425777f, -0.03649013f, 0.00994917f, 0.04002766f, 0.07880206f, 0.08875573f, 
    0.09979348f, 0.08301582f, 0.00440678f, 0.07133512f, 0.16665077f, 0.11393378f, -0.20746489f, -0.29979599f, 
    0.10528471f, -0.03110638f, 0.12866795f, -0.08467054f, -0.06843483f, 0.00461225f, -0.02479918f, -0.01351317f, 
    0.03204895f, -0.03045217f, -0.02690517f, -0.00803246f, 0.00650846f, -0.02132551f, 0.01306028f, 0.04982229f, 
    0.04263401f, -0.03952764f, -0.00905365f, -0.01628574f, 0.01886660f, 0.00196877f, -0.06166103f, -0.06036634f, 
    0.03979691f, 0.04118017f, -0.06608386f, 0.06006962f, 0.04973266f, 0.02890543f, -0.03187278f, -0.01144405f, 
    -0.05968831f, 0.00907969f, 0.05584842f, 0.02717552f, -0.07838621f, -0.03029664f, -0.02197290f, -0.02948285f, 
    -0.06029972f, 0.03408282f, 0.02853923f, -0.01181215f, -0.02322831f, 0.01053108f, -0.02283029f, 0.05340281f, 
    0.00475357f, -0.07200848f, -0.07571204f, -0.07432608f, -0.04932065f, 0.02902922f, 0.00887904f, -0.03125683f, 
    -0.04756846f, -0.06001236f, 0.01980034f, 0.00498789f, -0.04587354f, -0.01296956f, -0.03024923f, 0.06041766f, 
    0.04115076f, -0.01179517f, 0.03671758f, 0.01463861f, 0.07228294f, 0.04028536f, -0.04197572f, -0.02729510f, 
    0.00499053f, 0.02774869f, 0.06017277f, -0.02899615f, 0.00551127f, 0.04000565f, -0.00994333f, 0.04025170f, 
    -0.06768553f, -0.01013557f, 0.05802509f, -0.03780133f, -0.00940071f, 0.02759724f, -0.01073272f, -0.01792460f, 
    0.04699881f, 0.00344479f, -0.05089787f, -0.02568802f, -0.05212577f, -0.05966023f, -0.07313380f, 0.00627151f, 
    -0.02907389f, -0.06474949f, -0.03160602f, -0.00984345f, 0.06105221f, -0.05630122f, -0.05368726f, 0.02622810f, 
    0.05951241f, -0.03381613f, -0.02882536f, 0.04017482f, -0.04474590f, -0.02503177f, -0.02040173f, 0.03754944f, 
    0.05881072f, -0.05777184f, 0.04050824f, -0.04053870f, 0.01965271f, 0.03924125f, -0.05771878f, -0.03250805f, 
    -0.06364478f, -0.07838295f, 0.02764265f, -0.07329955f, -0.00295619f, -0.02733869f, -0.07782423f, -0.02022578f, 
    0.03179064f, 0.02363496f, 0.05278632f, 0.04423575f, -0.00585003f, -0.00691215f, 0.04551750f, -0.06550813f, 
    0.05879800f, 0.03399960f, -0.06096135f, 0.02135786f, -0.00601574f, -0.02935370f, -0.02652377f, -0.04591621f, 
    -0.04264792f, -0.06091163f, 0.04803399f, -0.04005494f, 0.02239881f, 0.00442310f, -0.05836133f, 0.04277687f, 
    0.06322473f, -0.04387060f, -0.04598250f, -0.03631227f, -0.05739986f, -0.01871007f, -0.07246397f, 0.02260375f, 
    -0.04619465f, -0.04119198f, -0.02604074f, 0.01612645f, -0.07461628f, 0.02916955f, -0.03065546f, -0.01499641f, 
    -0.03966478f, -0.07195757f, -0.06331100f, -0.06893925f, 0.04806284f, 0.00719674f, -0.02639370f, 0.03525934f, 
    0.06165508f, 0.01034663f, 0.05487710f, -0.06607319f, -0.00568002f, -0.01648048f, 0.05568168f, -0.02090969f, 
    -0.00220544f, 0.03908153f, -0.05974055f, -0.07214458f, 0.05758379f, 0.05143604f, 0.00960037f, 0.04992749f, 
    0.05790662f, -0.05979019f, 0.02989659f, -0.07261965f, -0.00725014f, -0.04870031f, -0.00449564f, -0.05281739f, 
    -0.12229308f, -0.21088736f, 0.01245984f, 0.14751108f, -0.00869176f, -0.04630959f, -0.00870330f, 0.15524729f, 
    -0.03686135f, -0.16660661f, -0.12233258f, -0.15168130f, 0.12406711f, -0.03581398f, -0.03322803f, -0.30375940f, 
    0.08622397f, 0.06712237f, -0.06734613f, 0.03593744f, 0.00035931f, 0.08302622f, -0.03574540f, 0.02417256f, 
    0.05655917f, 0.23365508f, -0.07114889f, 0.12473960f, 0.12685341f, 0.00280893f, -0.05729936f, -0.06495821f, 
    0.08124138f, 0.16661160f, -0.02995337f, -0.06096928f, -0.33309123f, -0.03139012f, -0.10748482f, -0.24154131f, 
    0.18742163f, 0.03181436f, -0.01078759f, 0.06852227f, -0.09089798f, 0.00327203f, -0.03122804f, 0.00729593f, 
    0.43733311f, -0.19216366f, -0.01799836f, -0.07899844f, -0.02147459f, -0.01621084f, -0.01497929f, 0.02982479f, 
    -0.02545555f, 0.03510436f, 0.09207773f, 0.11358722f, 0.00079855f, 0.21284868f, 0.36607021f, 0.51670909f, 
    -0.09143789f, -0.02855083f, -0.04189897f, 0.15183023f, -0.08327818f, 0.19617742f, -0.09898646f, -0.10111153f, 
    0.21541563f, 0.19826941f, -0.17467441f, 0.14221859f, 0.07080761f, 0.00003170f, -0.00961658f, 0.13340089f, 
    -0.11424519f, -0.01350682f, 0.11056463f, 0.03877173f, 0.49915272f, -0.14426650f, 0.09049446f, 0.00542857f, 
    -0.16671856f, 0.01449910f, 0.01326162f, 0.03176776f, -0.10665622f, 0.05698441f, 0.10028080f, 0.04114176f, 
    -0.01054806f, -0.06301386f, 0.04871437f, 0.04431592f, -0.00899452f, -0.02790034f, 0.04411062f, -0.15854031f, 
    -0.12002935f, -0.09224246f, -0.03398969f, -0.07635695f, 0.09867418f, -0.01303010f, 0.15429960f, -0.06532383f, 
    0.04087732f, -0.02003740f, -0.17898108f, 0.11680923f, 0.02406256f, 0.06334403f, 0.21474490f, -0.02276428f, 
    0.03372005f, 0.03160839f, -0.24450460f, 0.01948161f, 0.09614291f, 0.09265084f, 0.02227534f, -0.00658393f, 
    0.02468358f, 0.03988422f, -0.00902679f, -0.00854796f, 0.11593457f, 0.30222836f, 0.08432763f, -0.18374971f, 
    0.00782357f, 0.10221596f, 0.23146382f, 0.01194192f, -0.14843617f, -0.03139399f, -0.00196900f, -0.05365439f, 
    -0.09866571f, 0.07063498f, -0.17729302f, -0.13599466f, 0.04521154f, 0.24597585f, -0.07610283f, 0.06985743f, 
    0.01464996f, -0.07509263f, -0.05097124f, 0.21138673f, 0.08231168f, -0.16405126f, 0.04980245f, 0.05341718f, 
    -0.13990685f, -0.00561259f, 0.07405791f, -0.03125598f, -0.04137905f, -0.03770956f, 0.00237563f, 0.13605478f, 
    0.07108051f, 0.08725980f, -0.06422600f, 0.34442979f, 0.14100347f, -0.02206762f, 0.07514847f, 0.02316938f, 
    -0.06449946f, 0.02713921f, -0.16340911f, -0.05127298f, -0.14652210f, -0.07235115f, -0.06107694f, -0.04809288f, 
    0.02769907f, 0.15506490f, 0.02228539f, -0.02603065f, 0.01884822f, 0.06696722f, 0.24083391f, -0.04054661f, 
    0.00616630f, 0.02861707f, 0.02258446f, -0.01640526f, -0.05898625f, 0.03089360f, 0.05289435f, -0.07263485f, 
    0.04199791f, -0.03689789f, -0.01762154f, 0.04201530f, 0.04064113f, -0.07338933f, 0.03787307f, 0.04382975f, 
    0.05471895f, -0.05205541f, -0.00962318f, 0.03892276f, -0.05323958f, 0.00027388f, 0.02274080f, -0.04037350f, 
    -0.04471556f, 0.00308932f, -0.06103240f, -0.02198043f, -0.07126245f, -0.03799489f, -0.02613475f, -0.00143296f, 
    -0.03758411f, -0.05642219f, 0.05957253f, -0.05114895f, 0.00156006f, -0.05237885f, 0.02690910f, -0.05224540f, 
    0.03087496f, -0.07423002f, -0.07418156f, 0.01377782f, 0.05467949f, 0.02760489f, -0.01487321f, -0.03397525f, 
    0.01348477f, -0.00763956f, 0.03521452f, 0.02585824f, -0.04216033f, 0.00782090f, 0.06069060f, -0.04545536f, 
    -0.06700533f, 0.06336303f, -0.02762558f, -0.00961663f, 0.04562944f, -0.00756575f, -0.02127592f, -0.01767329f, 
    -0.02300914f, -0.07039909f, -0.00557831f, 0.05668402f, -0.02025550f, -0.02206643f, 0.03863804f, -0.06934347f, 
    0.02530017f, 0.03294736f, 0.00968093f, -0.05300638f, 0.01118472f, 0.01353088f, -0.00849092f, -0.03191152f, 
    0.02294270f, 0.06114950f, -0.05077247f, 0.01262937f, 0.05842892f, 0.04063423f, -0.00892738f, 0.04892960f, 
    0.00853162f, -0.06765628f, -0.02519393f, 0.01804699f, 0.03723394f, -0.07629674f, -0.04079010f, -0.03834126f, 
    -0.04993640f, -0.07785750f, -0.00314924f, 0.03090105f, 0.02452867f, -0.04275083f, -0.06469225f, -0.07310004f, 
    -0.00005588f, 0.01109427f, -0.03113891f, 0.03133873f, -0.04451259f, 0.05983292f, 0.03593470f, -0.06065957f, 
    -0.05714654f, 0.04873426f, 0.04462390f, 0.05052947f, 0.03829180f, -0.03542932f, -0.00033920f, -0.00235154f, 
    0.02657299f, -0.01958093f, -0.05793654f, 0.01766672f, -0.02992599f, 0.00575352f, 0.05051161f, -0.07028607f, 
    -0.03631234f, -0.03542854f, -0.04275003f, -0.01427433f, -0.02145409f, -0.04284448f, -0.07850371f, -0.01411368f, 
    -0.07017940f, -0.02270089f, 0.00053233f, 0.01792532f, 0.01957628f, 0.04524018f, -0.06187678f, -0.05765605f, 
    -0.01974732f, -0.07406512f, -0.05156440f, 0.00482461f, -0.03396387f, 0.01276094f, 0.05945461f, 0.03623043f, 
    0.02863584f, -0.01529440f, 0.05383870f, -0.04817275f, -0.03311475f, -0.08127482f, -0.07783595f, -0.06632245f, 
    -0.02447102f, -0.01761164f, 0.02882387f, -0.01754522f, -0.04910436f, -0.03015853f, -0.03197204f, 0.01302486f, 
    0.04986092f, 0.05552625f, 0.03412672f, 0.01193101f, -0.04725069f, 0.03609186f, -0.02849544f, -0.06641848f, 
    0.02718980f, -0.02508553f, 0.03734528f, -0.05897604f, 0.02879938f, 0.03293127f, 0.06278136f, 0.01545731f, 
    -0.01805387f, 0.03360324f, 0.02321656f, 0.00688862f, -0.07453438f, -0.07717343f, 0.00459220f, -0.00932157f, 
    -0.04752033f, -0.23486683f, 0.15562195f, 0.01733318f, -0.09975018f, -0.08878744f, 0.02798605f, -0.06226904f, 
    0.01021419f, -0.13840143f, 0.09487375f, 0.01301560f, 0.05453901f, 0.03593453f, 0.20624234f, -0.09340969f, 
    0.17198858f, 0.10109882f, 0.11189420f, 0.03335866f, -0.05328681f, 0.09497967f, -0.00564220f, -0.00194938f, 
    0.21453491f, 0.02185597f, -0.18725809f, 0.38772017f, 0.10372480f, 0.04896491f, -0.09939529f, -0.02266198f, 
    -0.01821227f, 0.10345151f, -0.01200844f, -0.12614541f, -0.39392218f, 0.09323198f, 0.31317329f, -0.14578755f, 
    0.16797677f, 0.05314225f, -0.03966586f, -0.01088521f, 0.09348413f, -0.10981857f, 0.15668160f, 0.09888822f, 
    0.43993050f, -0.19013672f, 0.17814063f, 0.32943526f, -0.12986465f, -0.11612985f, 0.10194111f, 0.00953702f, 
    -0.06694187f, 0.10611516f, 0.02456748f, 0.03497260f, -0.50096613f, -0.25689602f, 0.08670320f, 0.37869638f, 
    0.01078418f, 0.08122802f, -0.10472040f, 0.01356679f, 0.00462620f, 0.06013394f, 0.12604563f, 0.01327243f, 
    0.13231008f, 0.14074041f, -0.31123778f, 0.18981251f, -0.00324514f, 0.16578156f, 0.01356068f, 0.16403674f, 
    0.08793608f, 0.10343407f, -0.13156979f, -0.01991772f, -0.43210575f, -0.06408315f, 0.08786650f, -0.18780562f, 
    -0.03302935f, -0.15106395f, 0.11043944f, -0.13254233f, 0.02178174f, 0.16740687f, -0.00313496f, 0.01430325f, 
    0.03618090f, 0.11886806f, 0.14608690f, -0.11386991f, 0.02490520f, -0.14354406f, 0.03919787f, 0.06406736f, 
    0.01085680f, 0.08555599f, -0.09938797f, -0.06227455f, 0.09583617f, -0.28600839f, 0.12043914f, -0.21610908f, 
    0.16650429f, -0.01953145f, -0.07535983f, 0.01456654f, -0.13792051f, 0.08383299f, -0.02315160f, 0.16606168f, 
    -0.02470710f, 0.04827034f, 0.20506154f, 0.05107623f, 0.17444208f, 0.14861329f, 0.01254416f, -0.02018149f, 
    0.13153680f, 0.05594287f, -0.01022039f, 0.01527736f, 0.02747619f, 0.29662302f, -0.10960817f, 0.13395648f, 
    0.11680558f, -0.08804809f, 0.05234856f, 0.12358022f, 0.02472253f, 0.07907869f, -0.07592272f, 0.30345532f, 
    -0.06567771f, -0.16354261f, -0.01629373f, -0.43739268f, 0.08143352f, 0.05113718f, -0.04052698f, 0.06018901f, 
    -0.01067801f, 0.09934288f, -0.00680411f, 0.02981168f, -0.06323900f, -0.04453836f, 0.14328144f, -0.05343040f, 
    -0.07501042f, -0.01194084f, 0.18529125f, 0.02018658f, -0.08937699f, 0.12619320f, 0.00519035f, 0.16772260f, 
    0.04263203f, -0.04284836f, -0.12333718f, 0.32589170f, -0.09821681f, -0.01051689f, 0.03672397f, 0.12457953f, 
    0.30054706f, 0.00239128f, -0.03112842f, 0.02861419f, -0.14830591f, -0.10205758f, 0.14622279f, 0.14081508f, 
    0.03745952f, -0.02758439f, -0.03743219f, 0.06435872f, -0.01716093f, -0.03973779f, 0.01992318f, -0.05645751f, 
    -0.37761748f, 0.18925627f, -0.04831440f, -0.08035219f, 0.13175163f, 0.10802352f, 0.00449624f, 0.12417856f, 
    0.08794459f, 0.20034838f, 0.05004834f, 0.07516463f, -0.17361450f, 0.06557678f, -0.07764295f, 0.33719924f, 
    -0.18012111f, -0.25670514f, -0.11035142f, 0.03260245f, 0.04680689f, 0.03017044f, 0.07327674f, 0.16877596f, 
    -0.08385839f, -0.14864853f, -0.09696601f, -0.34232050f, -0.00112335f, -0.00706604f, -0.07939176f, 0.07324793f, 
    0.10568945f, 0.04769184f, 0.05052755f, -0.07133839f, 0.02235364f, -0.09038235f, -0.18535994f, 0.32599035f, 
    -0.01870649f, -0.13922273f, -0.09973641f, -0.13440043f, 0.06823274f, 0.20325051f, -0.13642380f, 0.10793795f, 
    -0.09738052f, 0.41620678f, 0.03595044f, -0.43080303f, 0.12914814f, 0.03593064f, 0.02254040f, -0.04802762f, 
    0.12609528f, -0.00679717f, -0.07621461f, 0.08681082f, 0.04339723f, 0.29099464f, 0.14355154f, -0.29385501f, 
    -0.00311846f, 0.08507844f, -0.00164489f, 0.06279569f, 0.10759685f, -0.11549757f, 0.02611820f, -0.13037319f, 
    -0.07437524f, -0.13729961f, 0.07046251f, -0.31966293f, 0.00145501f, -0.18311276f, 0.01744796f, 0.13263516f, 
    0.00160720f, -0.21943358f, 0.15235375f, 0.10360798f, -0.28755450f, 0.20967561f, -0.03791783f, 0.10491242f, 
    -0.06982361f, -0.10073256f, 0.07632840f, -0.00568169f, 0.02749362f, 0.09014927f, -0.07069296f, -0.02506466f, 
    0.15078023f, 0.14644586f, -0.12532265f, 0.35782680f, -0.23964469f, -0.02355112f, 0.09447616f, 0.01078964f, 
    0.12938422f, -0.15922339f, -0.07353366f, 0.15236862f, -0.25906199f, 0.09589699f, 0.23851049f, -0.09709886f, 
    -0.07734548f, 0.11718887f, 0.03276845f, -0.07234152f, 0.03646462f, -0.19385219f, 0.00788785f, 0.14199968f, 
    0.15028824f, -0.04253642f, 0.01980494f, 0.32900357f, -0.05912309f, 0.00444805f, -0.09914623f, 0.01390100f, 
    0.18789595f, 0.10500254f, -0.06897382f, -0.04119262f, 0.46977180f, 0.37409443f, 0.02924816f, -0.15709661f, 
    -0.14140464f, 0.09819893f, 0.07939344f, -0.13118863f, 0.01902297f, 0.13682795f, 0.10170179f, -0.11996219f, 
    -0.05777636f, -0.05494878f, -0.06375277f, -0.02494127f, 0.01707592f, -0.11286075f, 0.07726271f, -0.05914574f, 
    0.03805246f, 0.00698254f, 0.02331579f, 0.01806470f, -0.45493150f, 0.02810642f, -0.01138810f, -0.11103170f, 
    0.03158728f, -0.07730691f, 0.04583647f, -0.01586307f, 0.07981918f, -0.01215929f, -0.01405113f, 0.06931129f, 
    -0.06684601f, 0.23880970f, 0.06179305f, -0.25133112f, -0.11544562f, -0.02125327f, 0.01452827f, -0.03400640f, 
    0.03555895f, -0.06958184f, 0.11181607f, -0.16187561f, 0.13438104f, 0.08090144f, -0.00417564f, 0.31172466f, 
    0.14550972f, 0.08120814f, 0.03011170f, 0.00699227f, -0.07368282f, 0.04026170f, 0.05226649f, 0.15695013f, 
    0.34332052f, 0.00922881f, 0.14384104f, 0.00135894f, -0.10213152f, -0.04072197f, -0.11355793f, -0.10135607f, 
    0.11172950f, -0.06958757f, -0.08230803f, -0.05377412f, -0.22570972f, 0.01238042f, -0.21349753f, -0.17484020f, 
    -0.08525814f, 0.07849316f, 0.00486532f, 0.02293362f, -0.00638976f, -0.07638536f, 0.00312466f, -0.16010971f, 
    0.14881773f, -0.18661954f, -0.00616401f, 0.13007599f, -0.13460073f, -0.04795066f, -0.02056285f, 0.15543638f, 
    -0.08125741f, 0.05046843f, -0.03994414f, -0.01956563f, -0.26458648f, -0.16076010f, 0.29632878f, -0.10888991f, 
    -0.17783406f, -0.01387788f, 0.02949861f, 0.02353310f, -0.01206984f, -0.08646942f, -0.12184104f, -0.05400474f, 
    0.42279559f, -0.01318737f, 0.18474101f, -0.02374915f, -0.05977771f, -0.19378191f, -0.03318997f, -0.08965158f, 
    -0.06066037f, -0.03091298f, -0.02328914f, -0.09076096f, 0.37747771f, -0.05316277f, 0.29572114f, 0.08426519f, 
    0.09372091f, 0.13885126f, 0.12319533f, 0.03847139f, -0.29019088f, 0.03631696f, -0.19389267f, 0.11266000f, 
    0.26145291f, 0.17017096f, 0.21366751f, 0.21682267f, 0.03301319f, -0.08795198f, 0.15162477f, -0.06541175f, 
    0.10532632f, -0.07547075f, 0.15203671f, -0.01127599f, -0.06635033f, -0.12826625f, 0.24299370f, -0.04345142f, 
    0.09533591f, 0.03487675f, -0.00227117f, 0.17325658f, 0.06373240f, 0.01358408f, -0.06597928f, 0.06705645f, 
    -0.41473559f, -0.05111261f, -0.14103477f, -0.13414350f, 0.11241523f, -0.03083542f, 0.04023075f, 0.07119031f, 
    0.04580962f, 0.10884466f, 0.16183363f, -0.09061071f, 0.56773359f, -0.11010127f, 0.22395766f, 0.20955645f, 
    0.27163315f, 0.04618528f, 0.05861678f, -0.00340960f, -0.00140229f, 0.02204622f, -0.04716307f, -0.07012102f, 
    -0.36153197f, -0.44239154f, 0.16032819f, -0.04008984f, -0.20226346f, 0.14976209f, -0.04824383f, -0.14512084f, 
    -0.19387808f, -0.11446794f, -0.11845367f, 0.03379232f, -0.19245096f, 0.13229167f, 0.23056380f, -0.00091149f, 
    0.12650819f, -0.01501503f, -0.03484814f, -0.00177710f, 0.04785422f, -0.03242718f, -0.06891575f, 0.05573110f, 
    0.26814213f, 0.19760989f, 0.05714491f, 0.10417387f, -0.00414197f, -0.14822128f, 0.01066353f, 0.12488446f, 
    -0.05542405f, -0.09785165f, -0.12045093f, 0.15235412f, 0.25707352f, 0.15267086f, 0.30132255f, 0.25607216f, 
    -0.07585611f, 0.06418804f, -0.19334184f, -0.03400921f, -0.03610056f, 0.10572156f, 0.01629892f, 0.07376651f, 
    0.16303755f, 0.10614254f, 0.11833237f, 0.24629538f, 0.01370666f, 0.33686382f, -0.10267412f, 0.06342252f, 
    -0.05179363f, 0.13034089f, -0.13367125f, 0.03097212f, -0.29249719f, 0.10017318f, 0.00680661f, -0.16982713f, 
    -0.08953273f, 0.06177249f, -0.15459505f, -0.26899213f, 0.01785640f, -0.14305867f, -0.05016357f, -0.07628354f, 
    0.06071995f, 0.01127199f, -0.04230142f, 0.01673595f, -0.05198704f, -0.08164876f, -0.04129823f, 0.05018253f, 
    -0.05208643f, -0.07997136f, 0.05765478f, -0.00878404f, -0.04782324f, 0.00828366f, -0.02776772f, -0.00593380f, 
    -0.01833262f, -0.07627382f, -0.00930031f, -0.07569449f, -0.03801387f, -0.01010023f, -0.03722315f, 0.01058703f, 
    -0.07424454f, -0.01321741f, -0.07553646f, -0.06628656f, -0.01160961f, -0.07089675f, 0.04051888f, 0.02824408f, 
    0.05659521f, -0.03488327f, -0.06816157f, -0.02883290f, 0.04161947f, 0.00371918f, -0.06174707f, -0.01086978f, 
    -0.05451702f, -0.00629598f, -0.00830804f, -0.04003847f, -0.02268914f, 0.00977199f, -0.01955472f, -0.06659424f, 
    0.05765978f, -0.02835351f, -0.06733335f, -0.05411662f, 0.05828373f, 0.05039407f, -0.07420818f, 0.04332571f, 
    -0.05967607f, -0.07664911f, -0.05815000f, 0.02269363f, -0.04801548f, -0.03349295f, 0.04248799f, -0.05563546f, 
    -0.05999636f, 0.05250888f, -0.04186105f, 0.03070735f, -0.03798907f, -0.03955896f, -0.06065350f, 0.04146622f, 
    0.04597676f, -0.05401299f, -0.01247074f, -0.03589898f, -0.06268574f, -0.06356776f, 0.01751585f, 0.02479065f, 
    -0.06800626f, 0.03385058f, -0.06301077f, 0.00288057f, -0.06281278f, -0.07662199f, -0.04927861f, 0.00023228f, 
    -0.02300604f, 0.00276757f, -0.04513329f, -0.05508148f, 0.06464083f, -0.05760463f, -0.01464568f, 0.01177414f, 
    -0.01148431f, -0.06652089f, -0.00468009f, 0.04431926f, -0.05839757f, 0.04133119f, 0.03650448f, 0.03365355f, 
    0.05160174f, -0.06544950f, 0.02129842f, 0.06332073f, -0.01001606f, -0.01357825f, 0.00417667f, 0.06423273f, 
    0.06037560f, -0.06512582f, 0.03079266f, -0.03695313f, 0.00158608f, 0.04705252f, 0.02521377f, 0.06304869f, 
    -0.03975407f, 0.06349481f, 0.05464903f, 0.02009577f, 0.03839640f, 0.02517164f, 0.01106677f, -0.07055783f, 
    -0.02856583f, -0.07031599f, 0.00452767f, -0.04052630f, -0.07765373f, -0.07956737f, -0.07429331f, 0.01860051f, 
    -0.06342056f, 0.00087423f, -0.03080008f, 0.00716100f, -0.06101492f, -0.04012765f, 0.04497604f, -0.04976683f, 
    0.03903666f, 0.03034188f, -0.01498764f, -0.04201747f, -0.02919492f, -0.00821551f, -0.05190614f, 0.05877304f, 
    -0.04592929f, -0.00104963f, 0.05156599f, -0.06126538f, -0.04779263f, -0.07317778f, -0.04504098f, -0.02814080f, 
    0.02956952f, 0.00069094f, 0.00916625f, 0.01240094f, -0.05600376f, -0.03153061f, 0.01631849f, -0.04126928f, 
    0.02448290f, -0.07404478f, 0.00429413f, -0.01285964f, 0.03310627f, 0.03567579f, 0.03822883f, 0.03163284f, 
    0.04267107f, 0.02779964f, 0.03370669f, 0.00600682f, 0.03902233f, -0.02917056f, 0.02892140f, -0.02155187f, 
    0.06388244f, -0.00243839f, 0.01203222f, -0.07231735f, -0.06116403f, -0.05822239f, -0.00528393f, -0.03446218f, 
    0.06534822f, -0.02055738f, -0.00557065f, -0.00698510f, 0.01916248f, -0.05274461f, -0.00093226f, 0.06319159f, 
    -0.05928149f, -0.02464562f, 0.06466439f, -0.02488967f, 0.02626391f, -0.06818645f, 0.00227650f, 0.03481114f, 
    -0.02225514f, 0.04812531f, 0.04866548f, 0.04839003f, -0.06137210f, -0.07092775f, -0.02349058f, 0.02522388f, 
    -0.02542978f, -0.03280012f, 0.04197791f, -0.06818382f, 0.01470864f, -0.02078183f, -0.07039620f, 0.01779833f, 
    -0.04514318f, -0.00765593f, -0.02543727f, 0.05698949f, -0.02497799f, -0.04468496f, -0.05049713f, 0.04825591f, 
    -0.03735469f, -0.04417013f, -0.03258752f, -0.06099151f, 0.01288069f, -0.04862246f, 0.03310530f, -0.06806189f, 
    -0.04880162f, -0.05493439f, -0.03377614f, -0.06628511f, 0.01965269f, -0.02041567f, -0.02865047f, -0.03330026f, 
    -0.02120486f, -0.01883702f, 0.00165144f, -0.05549495f, 0.02816248f, -0.04874125f, 0.00465380f, -0.01672354f, 
    -0.06989672f, -0.05041407f, -0.02055064f, 0.01529263f, 0.00852423f, 0.02628561f, -0.04044946f, -0.02184216f, 
    0.04187468f, -0.00801680f, -0.03618863f, -0.02209212f, -0.06445432f, 0.04636199f, 0.02629672f, -0.04754540f, 
    0.04333666f, -0.01942236f, -0.06295753f, -0.01734567f, 0.05209762f, -0.07555775f, -0.06681858f, -0.05304990f, 
    -0.04136667f, -0.02807585f, -0.05601189f, 0.00525973f, -0.02118964f, -0.05187784f, -0.00911924f, -0.05107073f, 
    0.01973915f, -0.00393340f, -0.04589712f, 0.02760275f, -0.06595750f, 0.00720600f, 0.02615931f, 0.01805742f, 
    0.03222032f, -0.04055801f, -0.04993638f, 0.00820308f, -0.03772654f, -0.07722494f, 0.01134542f, -0.03781958f, 
    -0.00989604f, -0.04778126f, 0.00496829f, -0.06880873f, 0.00232002f, 0.04157078f, -0.04505064f, -0.01544149f, 
    -0.05532058f, 0.05107807f, -0.05037974f, -0.06429658f, -0.03527634f, 0.03074123f, 0.02467166f, -0.01501094f, 
    0.04267871f, 0.06193040f, 0.04912872f, -0.01984531f, 0.05238597f, 0.00111063f, -0.06403351f, -0.04118512f, 
    0.03733820f, -0.07091478f, 0.02299077f, 0.05637676f, 0.05296667f, 0.00054610f, -0.03935954f, 0.03583718f, 
    -0.00968801f, 0.06602263f, 0.03847989f, -0.07238938f, -0.07311885f, 0.02416062f, -0.05140765f, -0.02857546f, 
    -0.06713469f, 0.00836651f, 0.03059614f, 0.04391358f, -0.05636528f, -0.04089125f, 0.00352946f, 0.02011946f, 
    -0.01439379f, -0.00481232f, 0.02636401f, -0.06003325f, -0.01250242f, 0.05810256f, -0.03787319f, -0.00320956f, 
    -0.01960891f, -0.04292921f, -0.00381100f, -0.02393599f, -0.01556357f, -0.06822778f, -0.02552072f, 0.05912249f, 
    -0.04506522f, -0.01488839f, 0.04520680f, -0.00142867f, -0.00018666f, 0.06059485f, 0.00704318f, 0.04448916f, 
    0.02504550f, 0.02167233f, -0.04968544f, 0.06547538f, -0.07718033f, -0.02529287f, 0.06146735f, 0.02732890f, 
    -0.11649118f, 0.12298553f, 0.05056055f, 0.13223079f, -0.04846152f, -0.11725257f, -0.12354587f, -0.07598069f, 
    -0.06457599f, -0.00680446f, 0.03185854f, 0.10718657f, 0.12030983f, -0.17155457f, -0.03169373f, 0.25463173f, 
    -0.05235014f, -0.02863796f, 0.07096675f, -0.09908266f, -0.00724355f, 0.13192981f, 0.11919228f, 0.00456633f, 
    0.04512576f, 0.24350013f, -0.22473665f, -0.19775134f, -0.04041951f, 0.05661521f, -0.06817182f, 0.00787870f, 
    -0.07136412f, -0.07556616f, 0.03172944f, -0.01859605f, 0.43505019f, -0.04097183f, -0.32954717f, 0.05100387f, 
    -0.08263639f, -0.01374557f, 0.02964394f, -0.09793887f, -0.04165132f, 0.01379967f, -0.03952279f, -0.03498289f, 
    -0.41436371f, 0.21912758f, 0.22405808f, 0.34128150f, 0.01097492f, -0.06738603f, 0.05181339f, 0.04206743f, 
    0.08258605f, -0.07603763f, -0.05127583f, 0.00048683f, 0.18644689f, 0.31564575f, 0.05168746f, 0.10132664f, 
    0.11967607f, 0.12585126f, -0.04598109f, -0.08476260f, 0.19020417f, -0.01952926f, -0.01096992f, -0.08684905f, 
    0.22576571f, 0.17432882f, -0.03530339f, 0.00237052f, 0.19583604f, -0.08714878f, -0.11663030f, -0.21665974f, 
    0.03305277f, 0.00174446f, 0.01306912f, 0.10024413f, -0.32274723f, 0.22342862f, 0.08258914f, -0.34265545f, 
    0.12234404f, 0.13744967f, -0.04856218f, -0.00637095f, 0.03752561f, -0.04569063f, 0.08986808f, -0.06646255f, 
    0.00660351f, 0.09245400f, 0.19778523f, -0.11636958f, 0.01366064f, 0.09983703f, 0.07913532f, 0.05367615f, 
    0.03357714f, -0.06459149f, 0.05229463f, 0.01419861f, -0.25777176f, 0.16890088f, -0.03810996f, 0.20147957f, 
    -0.00046528f, 0.04789465f, 0.18180005f, -0.04319201f, 0.03549280f, 0.03609116f, -0.08849939f, -0.06173516f, 
    0.58493108f, 0.41797993f, -0.13471791f, -0.12001017f, -0.14318988f, -0.25248176f, -0.01192770f, 0.05811505f, 
    -0.04863862f, 0.03845816f, 0.03742992f, -0.01945280f, 0.35411412f, -0.09352047f, 0.08520588f, 0.16824006f, 
    0.00469771f, 0.01322092f, 0.00668827f, -0.07022979f, 0.01127555f, -0.02024911f, 0.01784514f, -0.08732058f, 
    -0.08961130f, -0.04398614f, 0.20977083f, 0.42039824f, 0.08286943f, -0.00574634f, 0.14883195f, -0.09495901f, 
    0.09588263f, 0.00169405f, 0.06866362f, -0.24077785f, -0.06473789f, -0.06730165f, 0.11460434f, 0.02833669f, 
    0.08773435f, -0.08396118f, -0.03251883f, -0.00955001f, -0.04733858f, 0.00290287f, -0.02570383f, -0.13352992f, 
    0.11534341f, -0.06193165f, 0.24580675f, -0.35267729f, -0.13905047f, -0.08910405f, -0.03518112f, -0.11596285f, 
    -0.04563075f, 0.01072586f, 0.06921044f, 0.03462946f, 0.04875204f, 0.10418940f, 0.09156752f, -0.16437060f, 
    0.03120389f, 0.02886295f, 0.03801957f, 0.04512371f, 0.03299972f, 0.01743196f, -0.00071182f, 0.09198121f, 
    -0.04818572f, -0.00353083f, 0.00713155f, -0.04369773f, 0.00552983f, 0.01529087f, 0.01974500f, 0.01624296f, 
    0.04765549f, 0.02744221f, -0.03301050f, -0.05782981f, -0.07124033f, -0.01003899f, -0.00578141f, -0.01630459f, 
    -0.07505631f, 0.01666295f, -0.04156056f, 0.00593962f, -0.07169162f, -0.03864078f, -0.01388251f, -0.03324713f, 
    -0.01082833f, -0.06228377f, -0.05029177f, -0.00354316f, 0.01605850f, 0.05928631f, -0.01182406f, 0.00510084f, 
    0.05620512f, 0.01160854f, 0.05900868f, -0.06965102f, -0.06110718f, 0.06024247f, 0.05203888f, 0.02075775f, 
    -0.02173361f, -0.01669396f, -0.02568276f, -0.04970582f, 0.04551311f, -0.04597855f, -0.04124260f, -0.04428459f, 
    -0.06009064f, 0.05209806f, -0.05298114f, 0.03695079f, 0.01860007f, -0.02410135f, 0.03121218f, -0.03550021f, 
    0.00887732f, -0.00950653f, -0.05931287f, 0.03621394f, -0.02461434f, -0.03295609f, -0.02184350f, -0.06442156f, 
    0.03917041f, 0.04563288f, -0.02715766f, 0.05264528f, -0.04579918f, -0.01233545f, -0.05941314f, -0.01657769f, 
    -0.07103362f, 0.01103305f, -0.04217618f, -0.07071894f, -0.01811230f, 0.01130349f, -0.00633857f, 0.00325913f, 
    0.06502555f, 0.04651095f, 0.01619859f, 0.06384802f, 0.00061724f, 0.06548984f, -0.02795510f, 0.06575792f, 
    0.04599674f, -0.01036783f, 0.00249687f, 0.07049939f, -0.03733188f, 0.04642715f, 0.02120436f, -0.06765168f, 
    0.04219595f, 0.05606378f, -0.00499845f, 0.00605824f, -0.02142455f, 0.01294073f, -0.02799325f, -0.03673137f, 
    -0.06058444f, 0.01668688f, 0.03697504f, -0.06261458f, -0.02979702f, -0.01110816f, 0.00373146f, -0.05565424f, 
    0.01838331f, 0.05844367f, -0.01205550f, -0.03899523f, -0.02861575f, -0.05131717f, -0.06584946f, -0.03783667f, 
    -0.07344707f, 0.03519380f, 0.00151185f, 0.01529835f, 0.04604300f, 0.03083043f, 0.03886073f, -0.02589243f, 
    -0.00493747f, -0.05806956f, 0.04553916f, -0.07025208f, -0.05732669f, 0.00408274f, -0.06635016f, -0.04508963f, 
    0.06611842f, 0.00236640f, -0.06768771f, -0.03210470f, 0.06594972f, -0.07043372f, 0.01370940f, 0.05733003f, 
    0.01456933f, 0.02837080f, 0.00269148f, -0.03431256f, 0.00949094f, 0.00292078f, 0.01671360f, 0.01849306f, 
    -0.01425504f, -0.07179830f, 0.00464518f, -0.05536615f, -0.00658324f, -0.02247141f, -0.04616441f, -0.02623777f, 
    -0.05018236f, -0.01986213f, -0.01704607f, -0.02786165f, 0.02843368f, -0.04346185f, 0.05590099f, 0.01274467f, 
    -0.04731777f, 0.04045784f, -0.02094562f, 0.04332077f, 0.01064900f, -0.06822713f, -0.00646858f, 0.04025546f, 
    -0.06521451f, -0.01975254f, -0.01813645f, 0.04977696f, 0.03370170f, -0.04644589f, -0.00073441f, -0.05300492f, 
    0.01259592f, 0.05136931f, -0.00226331f, -0.05921395f, -0.04639346f, -0.04607223f, -0.07118124f, -0.00079843f, 
    -0.02772972f, 0.01802609f, 0.18397097f, 0.27375981f, -0.07802840f, -0.09678472f, -0.12337516f, -0.01133259f, 
    0.18350558f, -0.15558109f, -0.02800493f, -0.11198971f, -0.15558894f, 0.00049169f, -0.01758501f, 0.02381402f, 
    0.19093105f, -0.11677252f, -0.00421098f, -0.07134572f, -0.01860242f, -0.04587660f, -0.06279936f, 0.02748499f, 
    -0.09359473f, -0.14578585f, -0.08283834f, 0.32243207f, -0.03704567f, 0.07783418f, 0.15324987f, -0.05156041f, 
    -0.01154796f, 0.06338249f, -0.06367155f, 0.01609339f, 0.13003567f, 0.03537717f, 0.03819029f, -0.12189236f, 
    0.06976390f, -0.00019368f, -0.05405750f, -0.11880721f, 0.11177640f, -0.01159841f, -0.11365946f, -0.03821896f, 
    0.11702697f, 0.10407329f, 0.31232816f, 0.15655892f, -0.20503826f, -0.07860816f, 0.10088445f, 0.09440978f, 
    0.00284948f, -0.08529262f, 0.02197128f, 0.19470072f, -0.12463637f, 0.12136468f, -0.11638500f, -0.06337791f, 
    0.02142474f, 0.18904831f, 0.12357436f, -0.04671434f, -0.14744069f, 0.11970607f, 0.11169154f, 0.14814855f, 
    0.51840866f, 0.11626579f, 0.05708819f, 0.13195609f, -0.07399561f, 0.01431945f, 0.02806789f, -0.13522507f, 
    0.14439960f, 0.16202489f, 0.05432926f, 0.09633109f, -0.62789249f, 0.14914344f, 0.03142865f, -0.18421617f, 
    0.06025393f, -0.09477597f, 0.08532620f, 0.08166470f, 0.12376045f, 0.00128167f, -0.04827139f, -0.09608857f, 
    -0.14747433f, 0.07416975f, -0.03562516f, -0.36071905f, 0.03702642f, 0.08630487f, -0.14852390f, 0.02267960f, 
    0.00365501f, -0.18273395f, 0.09901984f, -0.33848625f, -0.06235816f, -0.13777037f, -0.06050132f, -0.11050771f, 
    -0.03291170f, 0.15268376f, -0.01160784f, 0.14430526f, -0.05258863f, 0.09713519f, 0.08920656f, 0.19804378f, 
    0.23236573f, 0.07604597f, 0.15272258f, 0.07103213f, -0.04808499f, -0.00597868f, -0.09319647f, -0.11703148f, 
    0.02814158f, -0.08745330f, -0.03808802f, 0.00393204f, 0.36937749f, 0.38545775f, -0.15180030f, 0.10632008f, 
    0.13543330f, 0.08336321f, 0.04633410f, -0.12919714f, 0.07734594f, 0.05220440f, 0.01660870f, 0.05138921f, 
    0.23852149f, -0.19070303f, -0.04802615f, -0.07476582f, 0.13186972f, -0.09304477f, 0.09679560f, 0.13330579f, 
    0.00429840f, -0.04427786f, 0.02746059f, 0.21853051f, -0.10883081f, 0.08388927f, 0.19951469f, 0.24777013f, 
    -0.04183732f, -0.10164893f, -0.12655708f, -0.05663367f, 0.06393618f, 0.12988116f, -0.01215382f, 0.07718349f, 
    -0.15435022f, -0.31864068f, 0.09433569f, 0.08456816f, 0.02264648f, -0.03725399f, -0.05899677f, -0.04241537f, 
    0.08482280f, 0.04723727f, -0.10808269f, 0.16523953f, -0.28356099f, -0.02262559f, -0.04834234f, -0.44104981f, 
    0.07846292f, -0.02708452f, 0.13556109f, -0.02341644f, 0.02907453f, -0.14279221f, 0.11550919f, 0.08987398f, 
    0.18666494f, 0.22397846f, -0.05518771f, 0.01982534f, 0.10701585f, 0.14959753f, -0.10053306f, 0.15330595f, 
    -0.06109548f, 0.07718167f, -0.18060887f, -0.10379758f, -0.03577800f, -0.03504326f, -0.30569053f, -0.12600715f, 
    -0.19608799f, -0.15128165f, -0.06498358f, 0.13556102f, 0.10002208f, 0.01201629f, 0.08146294f, 0.04819947f, 
    -0.10845537f, 0.05177170f, 0.17892498f, 0.05550830f, 0.06475019f, -0.03195808f, 0.06654983f, -0.00966513f, 
    0.15698181f, 0.01911372f, -0.05170925f, -0.00707323f, 0.23945424f, 0.07654154f, -0.22356790f, 0.17455652f, 
    -0.21717411f, 0.04714967f, 0.04501306f, 0.10529435f, -0.03296696f, 0.14186014f, -0.07000655f, -0.00392944f, 
    -0.14501293f, 0.08661704f, -0.16888873f, -0.38443136f, 0.09187273f, 0.06930369f, -0.01546406f, 0.00276129f, 
    0.08818186f, -0.05780478f, -0.02196692f, 0.13436221f, 0.41316769f, 0.31618184f, 0.17822085f, 0.02583021f, 
    0.00566034f, -0.04601121f, 0.12334936f, 0.01498399f, -0.02775363f, 0.04439915f, 0.10980171f, -0.03452544f, 
    -0.02409699f, 0.02719103f, 0.10954593f, -0.05387788f, 0.01603480f, -0.24771310f, 0.07294267f, -0.15436654f, 
    -0.05682133f, 0.08119058f, 0.22754177f, -0.09152570f, 0.59910882f, -0.16688673f, 0.10034822f, 0.14635393f, 
    -0.18105824f, 0.01603435f, -0.05274722f, 0.12068749f, -0.05373314f, -0.01822134f, 0.09751259f, 0.00029531f, 
    0.26529348f, -0.19862190f, -0.11271513f, -0.02705353f, -0.00966447f, 0.19883318f, 0.00565993f, -0.18008803f, 
    0.03788388f, -0.05674926f, 0.01406802f, 0.03826490f, -0.04036596f, 0.07532458f, 0.06340572f, 0.13043004f, 
    -0.03303275f, 0.10503618f, -0.02824771f, 0.04233731f, 0.02991552f, -0.10084856f, 0.13945772f, -0.09112211f, 
    0.06630936f, 0.02962014f, -0.04283616f, -0.13610999f, 0.01732085f, -0.08546819f, -0.00136631f, -0.07375622f, 
    -0.13404602f, 0.15262115f, -0.03203557f, 0.10566058f, -0.07830828f, -0.05067938f, -0.09069721f, 0.01749423f, 
    -0.04647465f, 0.15610382f, 0.00796839f, 0.00020019f, -0.15467085f, 0.10926115f, 0.09525757f, -0.32261312f, 
    0.08244153f, 0.24430136f, -0.06226397f, 0.25906679f, 0.03887229f, -0.00808208f, -0.12093164f, -0.04202875f, 
    0.02826197f, 0.02544112f, 0.01593809f, 0.13658084f, 0.09066306f, 0.00841524f, -0.00952223f, -0.04748864f, 
    -0.06312686f, 0.06959860f, 0.03866984f, -0.08930096f, 0.04115435f, -0.13883691f, -0.05457687f, -0.06808415f, 
    0.18117486f, 0.05506726f, 0.05273930f, 0.03355037f, 0.10838343f, -0.00787315f, 0.05149632f, -0.09190244f, 
    -0.20921308f, 0.12567762f, -0.05720332f, -0.15142739f, 0.07365686f, -0.18744874f, -0.07317754f, -0.00559535f, 
    -0.01463777f, 0.20478791f, 0.06148437f, 0.21478291f, 0.16099773f, 0.02180532f, 0.08788884f, 0.16478799f, 
    0.09215862f, -0.15314204f, 0.17752147f, 0.07036944f, -0.05841184f, 0.04489332f, -0.03501889f, -0.03590537f, 
    -0.06515040f, -0.21610682f, -0.00588400f, -0.04809253f, -0.10835809f, 0.15633436f, -0.01851912f, -0.19124539f, 
    0.15283071f, 0.18538477f, 0.26048604f, 0.02808526f, -0.05110593f, -0.04400613f, -0.08142073f, -0.22896445f, 
    -0.04252277f, -0.23960933f, 0.02831989f, 0.29055047f, 0.06029131f, -0.00524275f, 0.10201799f, -0.00692930f, 
    -0.09662249f, -0.12089531f, -0.05823212f, -0.06112345f, 0.04734548f, -0.06853799f, 0.15643893f, -0.04374209f, 
    -0.19062166f, 0.11517067f, 0.05875037f, -0.05651870f, 0.07917256f, -0.02399769f, -0.05675847f, 0.17775963f, 
    0.30429021f, -0.21220402f, 0.23651648f, 0.07342687f, -0.04873962f, -0.22031112f, 0.15925647f, 0.09104350f, 
    -0.15270483f, -0.10118455f, 0.04952295f, 0.08712780f, -0.20262276f, -0.14952634f, -0.11662658f, 0.16301298f, 
    0.04685167f, 0.13837767f, 0.16393287f, -0.11771937f, -0.04533534f, 0.09087699f, 0.02747906f, 0.19670309f, 
    0.11137381f, 0.21329555f, -0.14433317f, 0.06167958f, -0.08795004f, 0.06780938f, -0.07168914f, -0.07283533f, 
    0.09118271f, 0.12974954f, 0.11822681f, -0.05513952f, -0.27257004f, -0.08587077f, 0.03863521f, -0.05036318f, 
    0.07306668f, 0.02011931f, 0.06891329f, 0.15875331f, 0.07534861f, 0.04467699f, -0.04565439f, 0.08111501f, 
    -0.20323865f, 0.02153314f, 0.06505105f, -0.06752221f, 0.09369176f, 0.22456735f, 0.09394825f, 0.14298606f, 
    -0.08087125f, 0.04218487f, 0.11609322f, -0.15461065f, 0.47794649f, -0.15682898f, -0.05345591f, 0.14207393f, 
    0.19254850f, 0.07747518f, 0.09618170f, -0.08303038f, -0.13066667f, 0.02120912f, -0.02227471f, 0.01721951f, 
    -0.12749736f, -0.00028275f, 0.31555390f, -0.05207110f, -0.11447445f, 0.14229044f, 0.01843015f, 0.02211238f, 
    -0.16137551f, -0.09804373f, 0.02645988f, -0.10927939f, 0.08372530f, 0.03494329f, 0.14739348f, 0.29561988f, 
    0.08322979f, -0.09638245f, -0.04425938f, -0.01122964f, 0.01852279f, 0.01396520f, -0.09216038f, -0.07249728f, 
    0.19652767f, 0.03537431f, -0.04579772f, -0.17915100f, 0.04408484f, -0.03351755f, -0.06288379f, 0.14604338f, 
    0.03501936f, -0.02579685f, -0.00068194f, 0.10952654f, 0.11356910f, 0.00971705f, 0.13596804f, 0.05176331f, 
    0.07676077f, 0.06980605f, -0.04584209f, 0.08377393f, -0.01716497f, 0.04247625f, 0.00176383f, -0.07210682f, 
    -0.21687724f, -0.17548998f, 0.11381114f, 0.21467057f, -0.01028509f, -0.09133052f, -0.24494465f, -0.02611673f, 
    -0.07300153f, 0.05918607f, -0.08372710f, 0.24006222f, -0.33207238f, -0.00753032f, 0.18173756f, -0.07057838f, 
    0.01262360f, -0.01610603f, -0.08784363f, 0.04805442f, 0.02284192f, -0.02461832f, 0.15064582f, 0.02602226f, 
    0.14435121f, -0.04755878f, -0.17798689f, -0.25774047f, 0.02337526f, 0.07489199f, 0.00211661f, -0.13896109f, 
    -0.09779564f, 0.12909561f, 0.23021032f, 0.29173562f, 0.12279750f, 0.13832922f, 0.05760861f, 0.18689398f, 
    0.02875932f, 0.04398803f, -0.03680799f, -0.08579573f, 0.00082614f, 0.05851211f, 0.07274960f, 0.00072715f, 
    -0.04777355f, 0.17434478f, -0.06115976f, -0.22505844f, -0.16676490f, 0.07344765f, 0.03202752f, -0.04863235f, 
    -0.05711628f, 0.03187012f, 0.09485777f, 0.06624082f, 0.40044409f, -0.05089594f, 0.04518330f, 0.01638715f, 
    0.06823387f, 0.02195720f, 0.05549763f, -0.01417840f, 0.06433763f, -0.01400818f, 0.01310982f, -0.05110995f, 
    -0.26477039f, -0.18017237f, -0.03303643f, 0.22418474f, 0.10069384f, 0.15981671f, 0.04432033f, -0.00965024f, 
    0.04133176f, 0.12517498f, -0.06060242f, -0.11617146f, 0.04486773f, 0.14328720f, 0.03335135f, 0.04948555f, 
    0.11865397f, 0.09222674f, -0.08935045f, 0.10364750f, 0.03492488f, -0.02033313f, -0.12771085f, 0.04351303f, 
    -0.33676708f, -0.10228706f, 0.05082478f, -0.00040658f, 0.17897187f, 0.09368563f, -0.13988681f, -0.01076401f, 
    -0.00288910f, -0.07156745f, 0.02578545f, 0.07734285f, 0.18022904f, -0.10013023f, -0.13006544f, 0.00952765f, 
    0.08888815f, -0.02695916f, -0.06513853f, -0.04772035f, 0.08086782f, -0.09922782f, 0.07716135f, -0.00772392f, 
    0.06610146f, 0.07625951f, 0.14618233f, 0.03594093f, 0.01794597f, -0.01336639f, -0.04509662f, 0.12560293f, 
    0.11028204f, 0.10629292f, 0.03227630f, 0.02949065f, 0.12000388f, 0.31073564f, -0.10960632f, 0.15936399f, 
    0.06419605f, 0.04199240f, 0.25958011f, 0.05623019f, 0.17044546f, -0.04237783f, -0.09017577f, -0.03645611f, 
    -0.10748723f, -0.04299770f, 0.13419403f, -0.01745829f, 0.07641162f, -0.16998233f, 0.03052293f, -0.01226176f, 
    0.03843558f, 0.04892384f, 0.03569844f, -0.06548493f, 0.30027422f, -0.32709503f, 0.01591098f, -0.02480358f, 
    -0.04733882f, -0.12657940f, 0.05921148f, -0.01787923f, 0.09397107f, -0.02417098f, -0.01480877f, 0.11081669f, 
    -0.18623872f, 0.07561357f, 0.25079158f, -0.10160378f, -0.01189409f, 0.01126969f, 0.05895102f, -0.06814520f, 
    -0.06424098f, 0.14055653f, 0.04535808f, -0.23128235f, 0.14557569f, -0.18828715f, -0.08855366f, -0.01827628f, 
    -0.01490832f, 0.07203870f, 0.01098020f, 0.02478197f, 0.00430751f, 0.08182010f, -0.07593822f, -0.02024834f, 
    0.00394021f, 0.18996944f, -0.10541454f, -0.25528353f, -0.25716665f, -0.01756322f, -0.01777792f, 0.03433827f, 
    -0.02067006f, -0.08750329f, 0.11524672f, -0.00098875f, 0.49895695f, 0.28041977f, 0.06832714f, 0.06617650f, 
    -0.03626182f, -0.19609141f, -0.01479923f, 0.07054052f, 0.08421168f, -0.07880554f, -0.14298730f, 0.12009004f, 
    0.07583180f, -0.17912751f, -0.05188596f, -0.13270614f, 0.00824093f, 0.23292460f, -0.08900500f, -0.11889321f, 
    -0.07199642f, 0.16120446f, 0.11942769f, -0.07814793f, 0.43360949f, 0.26890066f, 0.18244113f, -0.10959094f, 
    -0.06296191f, 0.20898417f, 0.15354042f, -0.08199223f, 0.03070758f, 0.01829415f, -0.07063749f, -0.02551265f, 
    0.00520911f, 0.03808041f, 0.30119196f, 0.07712342f, -0.04829980f, -0.02229509f, -0.04591711f, 0.15670690f, 
    0.07179991f, -0.12962310f, -0.04443800f, -0.05220683f, 0.41429466f, -0.07442711f, 0.24728844f, 0.09361104f, 
    -0.21170881f, 0.10694772f, 0.00154812f, 0.05973459f, 0.21182437f, 0.06840289f, -0.00707290f, 0.10828423f, 
    -0.18399778f, -0.23288572f, 0.11965286f, 0.06106747f, -0.00872870f, -0.02542286f, 0.14887258f, 0.00382149f, 
    -0.19992329f, 0.14639355f, 0.02970237f, 0.03856530f, -0.52996403f, -0.60752094f, -0.44881004f, -0.43158710f, 
    0.29192880f, 0.04857392f, 0.14688763f, 0.05210014f, 0.00102056f, -0.01749651f, -0.03750220f, -0.03669258f, 
    -0.35497865f, -0.09175437f, 0.16646768f, -0.05213642f, -0.04085559f, -0.01380622f, 0.05725032f, -0.01291688f, 
    0.15088393f, -0.02325438f, -0.03137199f, 0.00794578f, 0.00254474f, -0.24606019f, -0.24007341f, -0.12064022f, 
    0.29293561f, 0.08557633f, -0.07557362f, 0.15533769f, 0.13866685f, -0.00269946f, 0.01455182f, -0.08950912f, 
    0.27366310f, 0.10758046f, -0.00278528f, 0.12032618f, 0.00686128f, 0.19266024f, -0.01314531f, 0.07119220f, 
    -0.02261298f, 0.07227337f, -0.01135083f, 0.11868539f, 0.12467719f, 0.14922337f, -0.38827965f, 0.07795047f, 
    0.09724212f, 0.02247693f, 0.02261570f, -0.03700439f, 0.06080249f, -0.05192526f, -0.09653872f, 0.07107186f, 
    0.36196336f, 0.21823762f, 0.32000107f, 0.17018336f, -0.20892587f, -0.06003609f, 0.01414483f, -0.09453156f, 
    -0.13227755f, -0.01465533f, 0.16581394f, 0.18100622f, -0.14815694f, -0.54011762f, 0.11345514f, 0.21543901f, 
    -0.00363535f, -0.18289083f, 0.09004516f, -0.10116028f, 0.04330121f, -0.01594422f, 0.09093113f, 0.00932529f, 
    0.01652708f, 0.04056746f, 0.09011178f, 0.15844543f, -0.02962669f, -0.01041139f, 0.10923618f, 0.06109941f, 
    -0.00818093f, 0.10634631f, 0.13400689f, -0.11604322f, -0.22897808f, -0.14929466f, -0.17030106f, -0.02824936f, 
    0.26723945f, 0.25960824f, -0.07817788f, 0.06474973f, -0.07503082f, -0.00338950f, 0.04708086f, 0.02444300f, 
    -0.28544876f, -0.11721934f, 0.11340858f, -0.24589975f, 0.07569388f, 0.03515347f, 0.05059554f, 0.31718189f, 
    0.01101604f, -0.06213659f, 0.02226444f, -0.06207444f, 0.33063769f, 0.22499877f, 0.13535514f, -0.02263258f, 
    0.03850318f, -0.11659659f, -0.02844897f, 0.00888888f, 0.11467341f, -0.03346179f, 0.04414193f, 0.10603896f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03749623f, -0.07199814f, 0.12245867f, 0.05257969f, -0.05166024f, -0.02049041f, 0.02414217f, 0.12204021f, 
    0.08671517f, 0.09221096f, 0.05214873f, 0.00694389f, 0.15095468f, -0.00238951f, 0.04752389f, -0.01978491f, 
    0.20047900f, 0.04922397f, -0.00662988f, -0.02093258f, 0.01682139f, -0.00381196f, -0.09320027f, 0.07677648f, 
    0.07535187f, 0.01584909f, 0.00294625f, -0.01081548f, 0.14262244f, -0.02467893f, -0.00563291f, 0.02122689f, 
    -0.01569651f, 0.09979475f, -0.01441000f, 0.05858373f, -0.07129559f, 0.13814493f, -0.03425866f, -0.00829235f, 
    0.03484361f, 0.10264837f, 0.07469766f, 0.06346165f, 0.05602081f, 0.01001703f, 0.00830465f, -0.05676924f, 
    -0.03964477f, 0.00893258f, 0.04820570f, 0.01075735f, 0.05501193f, 0.05983002f, -0.04298235f, -0.01644879f, 
    -0.07050364f, -0.08288524f, -0.05258672f, 0.07582282f, -0.02231882f, -0.09712193f, -0.00530153f, 0.00958352f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.20611022f, 0.06832753f, 0.06214401f, 0.01701236f, 0.26552051f, -0.09697572f, -0.12609577f, -0.15658173f, 
    -0.57275862f, -0.36401320f, -0.04372851f, -0.01535233f, 0.00484298f, 0.00632736f, 0.12257173f, -0.01874921f, 
    -0.13200396f, -0.42275450f, -0.26576152f, 0.10511138f, 0.09228794f, 0.38436440f, 0.26159218f, -0.12257029f, 
    0.04861074f, -0.05001314f, 0.08593331f, 0.04261101f, -0.29266906f, 0.34949702f, 0.05865896f, -0.03079818f, 
    0.07775674f, 0.27625334f, -0.03566690f, 0.09511521f, -0.01405427f, -0.27285847f, -0.46995050f, 0.17302164f, 
    0.15223640f, 0.34947282f, -0.50122589f, 0.19499174f, -0.05922035f, 0.02430522f, -0.01000524f, 0.22322999f, 
    -0.10677163f, 0.05237078f, -0.57733536f, -0.04521156f, -0.52945322f, 0.40412512f, -0.53761458f, -0.08659147f, 
    -0.08246629f, 0.45921955f, -0.00616180f, 0.20019494f, 0.09529900f, -0.00824839f, 0.07433443f, 0.13492003f, 
    -0.76957518f, 0.07983626f, 0.17203510f, 0.11921500f, 0.06919101f, -0.14098237f, 0.12950288f, 0.28833058f, 
    0.14760497f, 0.09848566f, 0.19960184f, 0.01283220f, 0.39628425f, -0.00599975f, -0.09864234f, -0.04515374f, 
    0.09283883f, 0.12413732f, -0.25697902f, 0.01251606f, 0.10495746f, 0.17772433f, 0.09158283f, 0.25483751f, 
    0.03186996f, 0.19494809f, 0.21470866f, -0.06738900f, -0.01063121f, 0.36044791f, -0.02054669f, -0.31518185f, 
    0.00299283f, -0.11466374f, -0.08117357f, -0.24397305f, 0.06575185f, 0.09976210f, 0.20423938f, 0.40569007f, 
    -0.81555218f, -0.37871343f, -0.36952621f, -0.08288110f, -0.03523226f, 0.06219640f, -0.07745677f, -0.31595030f, 
    -0.07607547f, -0.08878205f, -0.13455556f, 0.11059534f, -0.13006920f, -0.00783347f, 0.18035157f, -0.08191962f, 
    -0.09042801f, -0.03059992f, 0.10796960f, -0.67613214f, 0.08370028f, -0.24578211f, -0.03789748f, 0.36943692f, 
    0.06271039f, -0.05431059f, -0.09389281f, 0.03784444f, -0.13093318f, 0.06045714f, -0.09911761f, -0.11650121f, 
    -0.61275113f, 0.22550742f, -0.35837847f, -0.08634521f, -0.44753766f, -0.10410514f, 0.02530225f, -0.09557771f, 
    -0.21594551f, 0.29483539f, 0.01522319f, -0.01717946f, -0.04666059f, -0.41506097f, 0.21342647f, 0.11131472f, 
    -0.10500537f, -0.48328725f, -0.13963294f, -0.09827708f, -0.69149303f, 0.27218065f, 0.00776185f, -0.03654747f, 
    -0.23746420f, -0.56438333f, 0.06035966f, -0.09992050f, -0.04410537f, 0.13366272f, 0.48982757f, 0.30200794f, 
    0.40611547f, 0.04025407f, 0.17718717f, -0.54060501f, -0.10444328f, 0.16072345f, 0.00127089f, 0.09107081f, 
    0.10682987f, 0.01922078f, 0.30549318f, -0.06568224f, -0.27183300f, -0.15033127f, -0.56644160f, 0.10417034f, 
    -0.07628669f, 0.02882232f, 0.09606000f, -0.44693345f, 0.32735056f, -0.08988866f, 0.28944522f, -0.16689834f, 
    0.09521214f, 0.06648222f, 0.34153777f, 0.08554014f, 0.33569708f, -0.25287634f, 0.38246697f, 0.01217459f, 
    -0.18625987f, -0.00585202f, -0.31504959f, -0.08450285f, 0.11184809f, 0.06270497f, 0.06568793f, 0.03098580f, 
    0.12281342f, -0.21357016f, 0.21166942f, -0.05339169f, -0.09670900f, -0.14529164f, -0.49833184f, -0.20984709f, 
    0.19547065f, -0.60825086f, 0.12023351f, 0.06961579f, 0.11905953f, 0.14720774f, -0.02752238f, -0.11649299f, 
    -0.92595547f, 0.17506970f, 0.10157371f, 0.21551155f, 0.07784659f, -0.22794844f, 0.03970421f, -0.37941787f, 
    -0.04309988f, 0.18476696f, 0.09354035f, -0.26018602f, -0.04677003f, -0.21069705f, 0.07881951f, 0.15156549f, 
    0.38212535f, 0.03872707f, -0.11664662f, 0.03481543f, 0.04541251f, -0.13093606f, 0.34274936f, 0.07343906f, 
    -0.02250969f, -0.38029173f, -0.01647178f, 0.23776183f, -0.25402355f, 0.11169377f, -0.49556667f, -0.58666110f, 
    0.25689542f, -0.07080015f, 0.37459013f, 0.11251778f, 0.09199090f, 0.14954728f, -0.27941373f, -0.22626051f, 
    -0.34897518f, -0.26488608f, 0.19715378f, 0.04287947f, -0.02735820f, -0.08619438f, -0.00974690f, -0.08280515f, 
    -0.27907562f, -0.52928090f, 0.33474910f, 0.00853834f, 0.10835449f, -0.03735673f, -0.04966939f, 0.11999030f, 
    -0.35843000f, 0.23641162f, 0.34501144f, -0.05149648f, 0.20429057f, -0.09680209f, 0.01040349f, -0.21840373f, 
    -0.17723775f, -0.17729130f, 0.01888894f, 0.39991248f, 0.10828466f, -0.14083663f, 0.04395719f, 0.27934781f, 
    -0.08297741f, -0.37669694f, 0.14655758f, 0.05088145f, -0.05547938f, -0.03980205f, -0.07464090f, -0.01038789f, 
    -0.06062534f, 0.03292229f, 0.23800807f, 0.07937359f, 0.33782828f, 0.23784287f, 0.08706038f, 0.09096639f, 
    -0.07605453f, -0.26225698f, -0.07967678f, 0.32671133f, -0.21703875f, 0.15692632f, -0.29467669f, -0.33857203f, 
    0.01150341f, -0.07605378f, 0.10841320f, -0.01973711f, -0.37285134f, -0.00328806f, -0.04772013f, 0.02863701f, 
    0.00160641f, -0.12410289f, 0.13178882f, 0.01772615f, 0.22132213f, -0.04232987f, 0.10246713f, 0.11374548f, 
    -0.18772958f, 0.11233158f, 0.22272728f, 0.06059786f, -0.11186463f, 0.21596953f, -0.23461312f, 0.02415115f, 
    -0.09099444f, 0.42313629f, -0.13834739f, -0.09375405f, -0.30868271f, -0.06395234f, 0.07072955f, 0.07560239f, 
    0.21615584f, -0.03473039f, 0.02466892f, -0.26547882f, 0.08115592f, 0.24732064f, -0.29223362f, -0.39612997f, 
    -0.10959981f, 0.21708477f, -0.41088754f, 0.38100111f, 0.10007302f, 0.18771762f, -0.08799688f, 0.10342119f, 
    0.06045972f, 0.09411562f, -0.37763211f, 0.05844923f, 0.19757679f, -0.58364660f, 0.01892716f, -0.00109969f, 
    0.10996167f, 0.16451627f, 0.07421654f, 0.10132701f, -0.64058858f, 0.10197112f, 0.25679004f, 0.22365460f, 
    -0.03825253f, -0.09376566f, -0.21556482f, 0.07006017f, -0.29714084f, 0.10981423f, -0.00125133f, 0.19099492f, 
    -0.24392977f, 0.42648351f, -0.13602145f, 0.09959645f, -0.33444321f, -0.12960738f, 0.06395546f, -0.01293689f, 
    -0.24971986f, -0.34491470f, 0.01333294f, 0.06583769f, 0.00210266f, -0.43887186f, 0.06769297f, 0.11812032f, 
    -0.14423291f, -0.34414083f, -0.24285460f, 0.08911508f, -0.48488072f, -0.05436801f, -0.01078178f, 0.41113791f, 
    0.19490524f, 0.38980854f, -0.04937123f, 0.06976809f, -0.09649758f, 0.12722179f, -0.21824673f, 0.01565272f, 
    0.33281651f, -0.28402281f, 0.37435418f, -0.47970092f, 0.08649752f, 0.23405190f, -0.12018690f, -0.23949769f, 
    -0.61969757f, -0.01826557f, -0.31904396f, 0.06909645f, 0.09235559f, -0.11947578f, -0.23375344f, 0.02209979f, 
    -0.00225207f, -0.04506565f, 0.09261876f, 0.12363419f, 0.11858303f, 0.26675543f, -0.11613671f, 0.30578509f, 
    0.23231399f, 0.01887778f, -0.48636028f, -0.04842024f, 0.03733888f, -0.23935744f, -0.09687742f, -0.28492340f, 
    0.27663055f, 0.22488321f, -0.08756399f, 0.07456357f, -0.33377355f, -0.00562192f, 0.02006052f, 0.01835842f, 
    -0.51020604f, -0.24033412f, 0.15105349f, -0.01491557f, 0.07749148f, 0.16160032f, 0.19094221f, -0.44256955f, 
    0.08446116f, -0.15278780f, -0.45620614f, -0.07368831f, 0.23238260f, -0.24378811f, 0.07450566f, -0.19273196f, 
    0.22615802f, -0.39837345f, 0.04043698f, -0.33128038f, -0.08832321f, -0.32092044f, -0.00110710f, -0.04400270f, 
    0.02984495f, -0.18405497f, 0.11744046f, 0.00880760f, 0.00904074f, 0.03678847f, -0.00933748f, 0.28280500f, 
    0.23172036f, 0.11420228f, 0.33791247f, 0.06731283f, 0.00500152f, -0.14293414f, 0.33472201f, -0.03973711f, 
    -0.08144769f, 0.31241715f, 0.04212561f, 0.24736033f, 0.19774880f, 0.13842756f, -0.15042035f, -0.28330618f, 
    0.00935237f, 0.01492374f, 0.04846416f, 0.03851932f, -0.38036302f, 0.24159405f, -0.53286719f, 0.27249336f, 
    0.30414611f, 0.00308078f, -0.24804109f, -0.10289460f, -0.45128316f, -0.09274925f, 0.11962283f, -0.08541682f, 
    0.07540767f, -0.12251244f, -0.40662277f, -0.04499546f, -0.07569602f, -0.40138751f, 0.33795369f, -0.06173628f, 
    0.12805499f, -0.34668997f, 0.25178215f, -0.03699508f, -0.05221510f, -0.11713274f, -0.07015173f, -0.32651502f, 
    -0.03602881f, -0.11684053f, 0.07632128f, 0.00178991f, -0.06460182f, -0.30117226f, 0.21626294f, -0.37438580f, 
    -0.39535141f, 0.36208904f, 0.01502528f, -0.02972279f, -0.04310631f, 0.23374316f, -0.05842819f, -0.22112612f, 
    0.24120201f, 0.08447682f, -0.04862688f, 0.02466495f, 0.23113903f, 0.36060309f, -0.20241891f, -0.02145432f, 
    0.08632267f, -0.01321061f, -0.07604071f, -0.39130908f, -0.37099859f, -0.35138389f, 0.29281902f, -0.13229413f, 
    0.24495810f, 0.02053917f, -0.56909734f, 0.07207272f, 0.15203734f, 0.16122487f, 0.22990707f, -0.29823846f, 
    0.35646990f, -0.51793575f, -0.55227220f, -0.02923489f, -0.24214898f, 0.08083253f, 0.01114245f, -0.10548078f, 
    0.25526762f, 0.18309404f, -0.17390950f, -0.08945604f, -0.04624221f, -0.02851859f, 0.25807545f, 0.15785378f, 
    -0.70545810f, 0.11525741f, -0.11084835f, 0.10189810f, 0.33162662f, -0.04037214f, -0.02250060f, -0.04158647f, 
    0.26918587f, -0.06177954f, -0.10361919f, 0.16932431f, -0.05427004f, 0.17211877f, 0.23827094f, -0.08135323f, 
    0.19010852f, 0.07597505f, 0.09554351f, -0.01133125f, 0.11552100f, -0.79320705f, 0.10315183f, 0.16990355f, 
    -0.48882818f, -0.09615330f, 0.20905149f, -0.04433255f, -0.02736015f, -0.23420289f, 0.21547355f, -0.11454558f, 
    -0.01103756f, -0.66587943f, -0.04694270f, -0.21167931f, 0.03598733f, 0.13427800f, -0.01081474f, 0.15444507f, 
    -0.08143517f, 0.02865532f, 0.18596803f, 0.00832970f, -0.17081577f, -0.37724739f, 0.07422188f, -0.25165486f, 
    0.13148154f, 0.28841305f, 0.43590626f, 0.00508073f, -0.08371182f, 0.02068683f, 0.03396253f, -0.00364261f, 
    0.06954991f, 0.46305737f, -0.15341413f, 0.02388407f, 0.09542345f, -0.46794665f, -0.20673466f, 0.38814062f, 
    0.26930824f, 0.28742775f, -0.38404724f, -0.12513305f, 0.34895521f, -0.28465170f, -0.08448735f, 0.25386640f, 
    -0.64407659f, 0.11739659f, -0.01404999f, -0.38740259f, -0.07560275f, 0.15216208f, 0.07273300f, -0.50244582f, 
    0.04284239f, 0.33562315f, 0.30062908f, 0.32418117f, 0.04205519f, -0.14701565f, 0.09673609f, -0.11800578f, 
    -0.00901247f, 0.05629091f, -0.26503769f, -0.06470320f, -0.40333328f, 0.09927952f, -0.00741680f, -0.03936620f, 
    0.05456002f, -0.20416422f, -0.01075528f, -0.36707661f, 0.33166277f, -0.34023532f, 0.13708331f, -0.58718926f, 
    -0.40740922f, -0.08127480f, -0.36535168f, 0.12540808f, 0.22448732f, 0.29777694f, -0.07382477f, -0.16645120f, 
    0.28161529f, -0.12969054f, -0.00492300f, 0.08274918f, -0.11971017f, 0.04436393f, 0.05739325f, 0.02122280f, 
    0.27217188f, -0.14546905f, 0.12654944f, -0.05300350f, 0.07076568f, 0.02329628f, -0.36570996f, -0.59889370f, 
    0.12524585f, 0.07082384f, 0.24097104f, 0.04993884f, -0.23515676f, -0.31734818f, -0.01135429f, 0.34608003f, 
    0.02925180f, 0.38275927f, 0.03078253f, 0.17769265f, -0.09310877f, 0.34774572f, -0.71460992f, -0.23115049f, 
    0.27566507f, -0.08350305f, -0.19560367f, -0.03916858f, 0.03777637f, 0.02599107f, -0.09894482f, 0.06107394f, 
    0.17408639f, 0.00022093f, 0.31699014f, -0.00653225f, 0.02092901f, -0.00512738f, -0.82598966f, 0.02595022f, 
    0.00576227f, 0.29161364f, 0.07638905f, 0.04234895f, 0.12117290f, -0.26852953f, -0.37704104f, -0.63756198f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.13968123f, 0.00486937f, -0.07996661f, -0.05049937f, 0.02027412f, 0.05321730f, -0.06082655f, -0.11336068f, 
    0.06069687f, 0.06838610f, 0.04809792f, 0.07408816f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
