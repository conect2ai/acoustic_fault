#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.65248972f, -1.04429257f, -1.57205355f, -0.64530653f, 0.27016732f, 0.82520443f, 0.35157990f, 0.17635456f, 
    0.74097037f, 0.68568748f, -0.36495164f, 0.14687988f, -0.36948770f, 0.56053460f, -0.20160651f, 0.21329339f, 
    -0.10372110f, 0.12766844f, 0.33692464f, 0.02527112f, 0.02172970f, -0.11118715f, -0.21037677f, -0.12223339f, 
    0.38502327f, -0.19129920f, 0.10164227f, -1.26387274f, -1.23844886f, -0.60058570f, 0.72504091f, -1.15022993f, 
    -0.79748780f, 0.08478241f, 0.10431791f, -0.32735977f, -0.44222909f, 0.64623827f, 0.26082882f, -0.22298162f, 
    0.36881414f, 0.14408733f, 0.29562297f, 0.23862281f, 0.18421713f, 0.31477699f, 0.05082119f, 0.46950397f, 
    0.31361252f, -0.28067714f, 1.61876094f, 1.63681877f, 0.07495381f, 0.21663639f, -0.36526164f, -0.71204823f, 
    0.18852744f, -0.23548588f, 0.57190174f, 0.65266019f, 0.19116941f, 0.06071177f, 0.08000834f, -0.33996677f, 
    -0.09991789f, -0.16646621f, -0.16976471f, -0.01969611f, -0.10525615f, 0.03027694f, -0.37712494f, 0.69400138f, 
    -0.09570380f, 0.29186130f, -0.12808831f, 0.86675036f, 0.27788889f, 1.04994059f, 0.75859076f, 0.99650681f, 
    0.76219928f, -0.41776660f, 0.47558370f, -0.67246902f, -0.58330071f, 0.56352037f, -0.44332293f, -0.17360570f, 
    0.31121519f, -0.23202014f, 0.30983871f, 0.42759809f, 0.20433962f, 0.47683844f, 0.44690582f, -0.03795889f, 
    0.05697010f, 0.37036875f, 0.42784545f, 0.13512528f, 0.68805206f, 0.69477910f, -0.74224263f, -0.44959354f, 
    -0.87751889f, 1.29139984f, 0.39551294f, 0.60007817f, 0.53081721f, 0.73143870f, -0.53079242f, -0.35863751f, 
    -0.00137019f, -0.58333749f, -0.64415765f, -0.41654077f, -0.04367879f, -0.27663794f, 0.24166518f, -0.03245784f, 
    -0.24835408f, -0.72313392f, -0.31497979f, -0.13153385f, -0.02670680f, 0.67574781f, 0.92789578f, 1.19459951f, 
    1.51623988f, 0.74027902f, -0.14076589f, -0.04603213f, -0.77836722f, -0.75664216f, 0.51486826f, 0.24834038f, 
    -0.21018553f, 0.27144226f, 0.05108428f, -0.06875361f, -0.29900253f, -0.20870489f, 0.11747494f, -0.04850313f, 
    -0.10888874f, 0.57140762f, 0.20227210f, -0.30519471f, -0.07671182f, 0.15732764f, 1.81039536f, 0.41129625f, 
    -0.41818860f, -0.24422289f, 0.18634662f, -1.01775992f, 0.16212195f, 0.28257102f, -0.20261133f, -1.10611427f, 
    -0.68374115f, -0.45009783f, -0.04211732f, -0.44971696f, -0.44480672f, 0.39735460f, -0.44157910f, -0.22273728f, 
    0.36178827f, 0.29407158f, -0.16453098f, -0.43844336f, -0.19014394f, -0.26271379f, -0.57141304f, 0.85733747f, 
    -0.27925032f, -0.99863583f, 0.28877690f, 0.84138221f, 1.15191460f, -0.49098217f, -0.61665612f, 0.01373449f, 
    -0.44867784f, -0.40205535f, -0.30499446f, -0.39381739f, -0.18472642f, 0.11251222f, 0.17877719f, 0.53834820f, 
    -0.22006032f, 0.28520718f, 0.16372989f, -0.58019602f, -0.53834939f, -0.49722415f, -0.13555676f, -0.09559733f, 
    -1.14354718f, -1.14906251f, -0.70715243f, -0.22990675f, -0.90928614f, 0.61883831f, 1.59198928f, -0.54370505f, 
    0.55367726f, 0.67352277f, 0.32833248f, 0.23034416f, -0.06386011f, -0.16006725f, 0.12855384f, 0.10729311f, 
    -0.04226204f, 0.03768461f, -0.18686774f, -0.27487317f, 0.08552326f, -0.20041920f, 0.32789651f, 0.07071103f, 
    0.20907865f, -0.03079478f, 0.65749985f, 0.32047299f, -0.57276750f, 1.16750610f, 0.26455235f, -1.11763668f, 
    -1.37709630f, -0.77808189f, -0.93441325f, 0.59575284f, -0.01591818f, 0.02587692f, 0.66816008f, -0.10736439f, 
    -0.05606776f, -0.08103241f, -0.15767148f, -0.06755502f, 0.48126623f, 0.14987138f, -0.07917010f, 0.28845185f, 
    -0.07232961f, -0.20020850f, -1.38770163f, -0.06047581f, 1.13524675f, 0.17136040f, 1.11299694f, 0.75242090f, 
    1.49688435f, 0.59877592f, -0.67551649f, 0.20028889f, -0.21439844f, 0.09085974f, 0.77031308f, 0.03588744f, 
    -0.22261067f, -0.18314390f, 0.06133648f, 0.02175805f, -0.04557891f, 0.00266443f, 0.23493032f, 0.14541306f, 
    -0.21114656f, 0.32239887f, -0.11878319f, 0.95613486f, 0.04565066f, -0.84813553f, -1.53276765f, -0.72604913f, 
    -0.03362659f, 0.19413635f, 0.34637448f, -0.06660348f, -0.21050613f, -0.38063416f, -0.13044232f, -0.33335775f, 
    -0.90512574f, -0.25933141f, -0.58293813f, 0.14189109f, -0.37006456f, -0.21207686f, -0.44220090f, 0.53452384f, 
    0.54846460f, -0.09147686f, -0.12566131f, 0.15957859f, -1.17100894f, 0.87887466f, 1.16922021f, 0.19595395f, 
    0.19326025f, -1.87308574f, 0.06144027f, -0.31028739f, -0.73053408f, -0.23909014f, 0.36853474f, 0.50409168f, 
    -0.04891708f, 0.05404543f, 0.12043398f, 0.34188402f, -0.18735836f, 0.03904613f, -0.07460503f, 0.11156432f, 
    0.58459365f, 0.17455696f, 0.07264834f, 0.30109724f, 0.17481701f, -1.41885424f, -0.86883414f, 0.19092116f, 
    -0.44034296f, -0.78983539f, -0.51107281f, -1.07629800f, 0.01780773f, -0.80585539f, 0.19831055f, -0.34195131f, 
    0.37109244f, 0.17633775f, 0.02562712f, -0.12877317f, -0.42469463f, -0.00349939f, 0.30956662f, 0.16036262f, 
    -0.37146378f, 0.55373257f, -0.54077363f, 0.16251633f, 0.24292052f, 0.23905347f, 1.19513094f, -0.05240599f, 
    -0.02765823f, 2.14397359f, 1.47781861f, 0.45364892f, 0.73897076f, 0.63596493f, 1.12993491f, 0.36349335f, 
    -0.37737072f, 0.14566189f, -0.14761162f, 0.23512900f, -0.08385073f, -0.03306898f, -0.26865846f, 0.31219125f, 
    -0.22272106f, -0.21560492f, -0.04386651f, -0.30638307f, -0.26130635f, -0.01337533f, 0.02178744f, 0.46807435f, 
    0.86019057f, 0.98960865f, -1.53934383f, -1.35913062f, 0.52316195f, -0.56593913f, -0.06138501f, -0.43245488f, 
    0.39037895f, 0.47721300f, 0.78984314f, -0.39282677f, 0.14809722f, 0.33392146f, -0.36784568f, 0.27868330f, 
    -0.01861373f, 0.15328328f, 0.45284739f, -0.02755362f, 0.04120323f, 0.11806185f, -0.07522701f, 0.29379436f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.53156996f, 0.59225500f, 0.22743717f, 0.14513429f, -0.08447842f, 0.06675243f, 0.25227767f, -0.09799340f, 
    0.06091922f, 0.11515483f, 0.16022576f, 0.38869748f, 0.43117258f, 0.29432774f, 0.56155938f, 0.13934827f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18343543f, 0.10598964f, -0.21090601f, -0.30342880f, 0.13045919f, -0.15863831f, -0.05553833f, -0.08671822f, 
    -0.00026494f, -0.09556214f, 0.05648736f, -0.16259269f, 0.34995198f, -0.46022072f, 0.01744519f, -0.32268742f, 
    -0.05252882f, 0.11248782f, 0.10427550f, 0.06862427f, -0.12689352f, 0.16702345f, 0.16601704f, 0.07860079f, 
    0.03166629f, 0.15863983f, -0.20223701f, 0.07273135f, -0.24068703f, -0.18177377f, -0.17669982f, 0.19464555f, 
    0.10335209f, 0.19386418f, 0.07148988f, 0.00772786f, 0.11915408f, -0.11485777f, -0.07888939f, -0.11321304f, 
    -0.27005541f, -0.06082358f, -0.02763435f, 0.07261996f, 0.06751045f, -0.11736947f, 0.01213408f, -0.16596998f, 
    0.36863917f, 0.11832145f, -0.19116302f, -0.28219679f, 0.25106046f, 0.03307294f, 0.04617678f, 0.07463303f, 
    -0.05890481f, 0.18752600f, -0.11756513f, 0.22840637f, 0.37280232f, 0.26906517f, -0.27536333f, 0.22493717f, 
    -0.43984285f, -0.07447171f, 0.11245324f, -0.09408626f, -0.12129425f, 0.11328299f, 0.07237425f, 0.03863373f, 
    0.24831273f, 0.26434594f, -0.19505936f, -0.11408613f, -0.36493325f, -0.19948609f, -0.26073191f, 0.11131126f, 
    -0.09096870f, -0.14038889f, 0.29543516f, -0.09477568f, 0.29402810f, -0.72190166f, 0.43570960f, 0.25437948f, 
    0.06042735f, 0.01777018f, 0.00796192f, 0.04196281f, 0.04626988f, 0.17079933f, 0.16768682f, 0.06437270f, 
    0.47920442f, 0.16357362f, 0.18087682f, -0.40363193f, 0.02195339f, 0.10560013f, 0.01001823f, 0.13324790f, 
    0.02057817f, 0.15813495f, -0.09505341f, 0.05700296f, 0.02652791f, 0.25153461f, 0.49027228f, -0.39684445f, 
    -0.16741259f, -0.02890065f, 0.03223309f, -0.04601270f, 0.15183586f, -0.17753947f, 0.00223280f, 0.01123141f, 
    -0.77020025f, 0.08984234f, 0.41237754f, 0.02776949f, -0.09630214f, -0.12752980f, -0.00193359f, -0.09788366f, 
    -0.08346217f, -0.14414799f, -0.14328809f, -0.00523710f, -0.52993351f, -0.19053575f, -0.08885759f, -0.58125728f, 
    -0.00733152f, -0.16260998f, 0.10113852f, 0.02243304f, -0.24964333f, 0.17804743f, -0.01194216f, -0.05098294f, 
    -0.45780209f, 0.04551246f, 0.01198448f, 0.25556874f, 0.07294385f, 0.10909206f, -0.12250788f, -0.01536553f, 
    -0.01672446f, -0.15357539f, 0.00115036f, -0.07469919f, -0.74152863f, -0.31581467f, -0.32587293f, 0.37265056f, 
    0.09445737f, 0.08321928f, -0.02091378f, 0.21067958f, -0.01776802f, 0.04924474f, -0.19391142f, -0.35513160f, 
    -0.05889964f, 0.09257293f, -0.38190880f, 0.71849203f, -0.31176576f, 0.05923172f, -0.10120266f, 0.02141402f, 
    -0.04214298f, 0.13446714f, -0.08898597f, -0.03010002f, -0.82387209f, 0.37552074f, 0.30631387f, -0.48125994f, 
    0.08030957f, 0.03402518f, 0.28922924f, -0.25160199f, 0.01746001f, -0.22293589f, 0.02364047f, 0.10218185f, 
    0.57047713f, -0.75856286f, 0.15603942f, -0.36967772f, 0.08772087f, -0.01021755f, -0.14437066f, 0.15519273f, 
    -0.16583246f, 0.10038424f, 0.03556369f, -0.01090487f, -0.47941172f, -0.08038317f, 0.20437269f, -0.41669479f, 
    0.08024995f, -0.24130416f, 0.26146907f, 0.07041398f, 0.10488857f, -0.05649868f, 0.14190501f, -0.13881721f, 
    0.70435768f, 0.02173091f, -0.07783596f, 0.20682584f, -0.02717777f, -0.24104503f, 0.13212049f, -0.02023573f, 
    -0.02140917f, -0.09446015f, -0.37847212f, 0.10445869f, 0.08975497f, 0.19667709f, 0.27734601f, 0.31366527f, 
    -0.11865979f, 0.17018211f, 0.14895488f, -0.03279677f, 0.03616101f, 0.19732673f, -0.00923942f, 0.33309031f, 
    0.00426761f, -0.05557654f, 0.34003058f, 0.05978231f, 0.11426323f, -0.06545319f, -0.02021255f, 0.00515178f, 
    0.09303374f, -0.14308856f, 0.04001340f, -0.30847707f, 0.34951767f, 0.12583286f, 0.28005499f, 0.41295278f, 
    -0.27335048f, -0.06486145f, 0.16501580f, -0.00487830f, 0.01076578f, 0.14300868f, -0.00529661f, -0.15446976f, 
    0.26814982f, -0.25239590f, -0.16078658f, -0.13725518f, 0.04281833f, 0.03316183f, 0.02354680f, 0.01839166f, 
    -0.06064280f, 0.03306550f, -0.39640769f, 0.10147694f, -0.10768893f, -0.40858883f, -0.14991236f, -0.29750299f, 
    0.12711039f, 0.20248011f, -0.23817243f, -0.04919792f, -0.29584369f, 0.02465237f, -0.24992460f, -0.11993525f, 
    -0.10917011f, -0.40027934f, -0.42780343f, 0.01964570f, 0.03601226f, -0.04706454f, -0.02484835f, -0.00702284f, 
    -0.02813516f, -0.05413948f, -0.18873753f, 0.07154953f, -0.14705470f, -0.22365943f, -0.08836114f, -0.20848018f, 
    0.07107166f, -0.15717012f, 0.00881766f, -0.07337889f, -0.13616702f, 0.09398601f, -0.03587529f, -0.08476800f, 
    -0.06674596f, 0.38766927f, -0.20434190f, 0.07283147f, -0.08380807f, 0.12080483f, -0.00116252f, 0.07205930f, 
    -0.14019148f, 0.16032758f, 0.05716446f, -0.20642027f, 0.40243617f, -0.31501773f, 0.09309851f, -0.48256278f, 
    0.19973335f, -0.20501225f, -0.00815788f, 0.06553346f, 0.07795125f, -0.13005297f, -0.10918250f, -0.08443766f, 
    -0.70358890f, -0.02026189f, -0.17142253f, -0.52913231f, 0.05679993f, -0.00928072f, -0.09600419f, -0.12171140f, 
    -0.00670456f, 0.16077225f, 0.05408034f, 0.04142844f, 0.19467242f, 0.12242854f, 0.18430416f, 0.03335371f, 
    -0.23266315f, -0.33270749f, -0.07044839f, 0.25984684f, -0.20006967f, 0.04220580f, 0.14728919f, 0.13769062f, 
    0.52223742f, -0.04187004f, -0.00138504f, 0.37883022f, -0.06834397f, 0.01618692f, -0.19345729f, 0.10376196f, 
    0.08243067f, 0.08875538f, 0.06442114f, -0.05496128f, -0.48071334f, -0.05445158f, -0.19921298f, -0.15347651f, 
    0.03331304f, -0.04357350f, 0.02637407f, -0.06341726f, -0.09749612f, 0.20250757f, 0.23026088f, -0.08332553f, 
    0.07363464f, -0.11881997f, 0.13120919f, 0.37832281f, -0.15458976f, -0.03057986f, 0.18896574f, 0.20680864f, 
    -0.24930583f, -0.23277447f, -0.11891310f, 0.01625057f, -0.78421074f, 0.22612795f, 0.05697060f, -0.02853573f, 
    0.16763102f, -0.02889228f, -0.20510887f, -0.18532734f, 0.02623248f, -0.15349182f, -0.14852577f, -0.03274658f, 
    0.25247598f, 0.25767437f, 0.16847837f, -0.14740880f, -0.00501281f, 0.00630577f, 0.18143336f, -0.00405373f, 
    -0.17710447f, 0.11832259f, -0.04005153f, -0.14611484f, -0.55684477f, 0.07286227f, -0.10711882f, 0.30963361f, 
    0.16331288f, 0.07062182f, -0.06457841f, -0.13474797f, -0.04951968f, -0.04928825f, -0.06157733f, -0.01858194f, 
    0.42394418f, -0.12992075f, 0.12462419f, 0.12628992f, 0.03896752f, -0.00148327f, 0.23424691f, 0.06431175f, 
    -0.31961370f, 0.01095927f, 0.12931705f, -0.18444316f, -0.11702880f, 0.03570188f, -0.11470819f, 0.22367866f, 
    0.18133257f, 0.15176408f, 0.00618693f, -0.20868908f, 0.15929087f, 0.12903409f, -0.12843978f, 0.03389667f, 
    -0.34536177f, 0.32059652f, -0.29578760f, -0.45951986f, 0.02460105f, 0.02375698f, 0.00141149f, 0.13522691f, 
    -0.00822280f, 0.07188698f, -0.09915831f, 0.10860668f, -0.73711002f, -0.52020723f, 0.28980920f, -0.26844528f, 
    0.26652139f, -0.06574683f, 0.12526879f, -0.06424137f, 0.07403798f, -0.25798255f, -0.20346333f, -0.06003591f, 
    0.90455663f, 0.01886391f, 0.52221018f, 0.15583028f, -0.21555398f, -0.30548811f, -0.15204629f, 0.28465068f, 
    0.00033428f, 0.08594242f, 0.14387749f, -0.15923734f, -0.05176856f, 0.26152515f, -0.25155890f, -0.30009490f, 
    0.20081538f, 0.11747895f, 0.17160979f, -0.18539757f, -0.13797814f, -0.00869341f, -0.12852034f, -0.28482446f, 
    0.55275983f, -0.32349685f, -0.04826215f, 0.00105338f, 0.09270217f, -0.03302644f, -0.03544749f, 0.00404372f, 
    0.26509532f, 0.10871865f, 0.09451969f, 0.17730696f, -0.14824852f, 0.19724871f, -0.10636104f, 0.06368393f, 
    0.02220846f, -0.39865166f, -0.03028354f, -0.16388905f, -0.01077050f, 0.00618805f, 0.00071268f, 0.03600175f, 
    0.75780964f, 0.30215237f, -0.76646239f, -0.22164458f, 0.05215226f, 0.11546660f, -0.04885336f, -0.06135135f, 
    -0.27138188f, -0.07185536f, -0.01207496f, -0.22454864f, -0.04358732f, -0.37810659f, -0.35572624f, -0.41471931f, 
    -0.17222118f, 0.04278911f, -0.24323651f, 0.00562998f, 0.01210241f, 0.21845616f, 0.07912792f, -0.01751962f, 
    -0.15711978f, -0.10504765f, -0.15793619f, -0.05986702f, 0.11544945f, -0.03100012f, -0.05660778f, 0.17583185f, 
    -0.19365695f, -0.04807890f, 0.07172695f, -0.16644251f, -0.31816378f, -0.06752562f, 0.19522528f, -0.59687179f, 
    0.00236974f, -0.00786488f, 0.03902964f, -0.00229762f, -0.10127066f, -0.11858381f, -0.12088309f, -0.09171066f, 
    -0.05935618f, 0.05300309f, -0.11141229f, -0.08237492f, -0.16472146f, 0.05362339f, -0.03104735f, -0.25377497f, 
    -0.18880494f, 0.04267254f, -0.05688369f, 0.01701805f, 0.24538738f, 0.06636070f, -0.06537471f, -0.21883327f, 
    -0.08508910f, -0.02045970f, -0.18895583f, -0.05268394f, 0.09872030f, 0.04942296f, -0.07836195f, 0.10197953f, 
    -0.60835451f, -0.65656370f, -0.76581591f, -0.14445829f, -0.05760807f, 0.28472772f, -0.06422539f, 0.13051446f, 
    -0.05081321f, -0.01906147f, 0.11248849f, 0.10879868f, -0.64651805f, -0.75603145f, 0.11633573f, 0.39206228f, 
    -0.06383033f, 0.00130962f, -0.07033795f, -0.08293223f, -0.16544101f, -0.31463844f, 0.06178594f, -0.03297217f, 
    -0.48827365f, 0.09452296f, -0.14492658f, 0.11867855f, -0.10516605f, -0.12116362f, 0.05675680f, 0.07735914f, 
    -0.06698518f, 0.09614041f, 0.03900137f, 0.08423324f, -0.71576530f, -0.79238838f, -0.07358473f, 0.41227150f, 
    -0.19057949f, -0.02210265f, -0.06889962f, -0.12487254f, 0.08062981f, -0.07178129f, 0.03964306f, 0.07043146f, 
    0.32762638f, 0.15903929f, 0.28082213f, -0.23275478f, 0.14946339f, 0.19751005f, -0.03200011f, 0.16077070f, 
    0.19336778f, 0.04108014f, 0.16033621f, -0.03115581f, 0.12292475f, 0.01770383f, 0.17869145f, 0.22236969f, 
    0.04062342f, 0.00911923f, 0.21785824f, -0.13931711f, 0.15096247f, -0.28221664f, 0.20757835f, 0.28941354f, 
    -0.08698314f, 0.07715837f, -0.08646902f, -0.03902350f, -0.17468497f, -0.22393374f, -0.08995187f, 0.02507849f, 
    -0.04922013f, -0.03061103f, -0.03658182f, -0.06322538f, 0.78731793f, 0.03028576f, 0.35868528f, 0.13012624f, 
    0.20058565f, 0.03967278f, -0.33840886f, 0.04036789f, 0.10089150f, -0.12813924f, -0.11155899f, -0.38491803f, 
    -0.49622482f, 0.19009763f, 0.51789629f, -0.11804167f, 0.11559790f, -0.18208763f, 0.26819089f, 0.22216573f, 
    0.11906016f, -0.02364196f, -0.14774573f, -0.02520609f, 0.06284868f, -0.14669840f, 0.31546047f, 0.19254796f, 
    -0.07578521f, 0.11101131f, 0.08973465f, 0.10406679f, -0.32767493f, 0.19204383f, -0.20698427f, 0.08504377f, 
    -0.98475695f, 0.49624953f, 0.28685245f, 0.03954698f, 0.05312446f, 0.02891050f, -0.01854938f, 0.04485099f, 
    -0.22098807f, -0.05463427f, -0.06963656f, -0.18218911f, 0.32014543f, 0.15766816f, 0.34385759f, -0.16029830f, 
    -0.16139232f, -0.05218062f, 0.09236089f, -0.08727517f, -0.15240791f, 0.03357883f, 0.03912303f, 0.08780312f, 
    -0.16631509f, -0.37706542f, -0.30371687f, -0.32488826f, -0.18004841f, 0.06107180f, 0.10903994f, -0.14976396f, 
    0.39797956f, 0.03947742f, 0.06132664f, -0.09331959f, -0.04368225f, -0.16797708f, 0.21774416f, -0.02928651f, 
    0.13485648f, -0.10069785f, 0.01928994f, 0.41940290f, 0.08226201f, -0.17885824f, -0.28800470f, -0.14120241f, 
    -0.66355902f, 0.26621890f, 0.01163858f, 0.32951191f, 0.02730409f, -0.24376659f, 0.14709824f, -0.08117329f, 
    -0.05132502f, -0.02065687f, 0.11272494f, -0.08503507f, 0.42201293f, -0.41628072f, 0.06946151f, 0.32738534f, 
    0.14695899f, -0.03475118f, 0.12863185f, 0.04654995f, 0.02899550f, 0.02710823f, -0.09631864f, 0.05176707f, 
    -0.29786503f, -0.43110573f, 0.04874526f, -0.08199801f, -0.32171646f, -0.15222056f, -0.04511458f, -0.04300372f, 
    0.06960613f, 0.01497638f, -0.06360998f, -0.00551275f, 0.26821169f, 0.21845442f, -0.00443503f, -0.15456343f, 
    0.00540470f, -0.00766949f, -0.16266549f, -0.02615648f, 0.08555141f, -0.09063105f, 0.13001092f, -0.29634169f, 
    -0.54500121f, -0.27455586f, -0.05303140f, 0.38779372f, 0.01949568f, -0.25464186f, 0.13996343f, -0.00428197f, 
    -0.17836817f, 0.13761757f, -0.06581588f, -0.00587862f, -0.35013589f, -0.05797565f, 0.41328433f, 0.13644502f, 
    -0.16530684f, 0.15921769f, -0.14195500f, 0.04201267f, 0.17295112f, -0.12425874f, 0.08580236f, 0.12152050f, 
    0.46678466f, -0.14532676f, 0.25352576f, -0.16150497f, -0.17078310f, -0.01625907f, 0.14517395f, -0.00970786f, 
    0.28824168f, 0.08405818f, 0.12044656f, -0.04754785f, 0.06634244f, 0.18697947f, -0.09715318f, -0.07935168f, 
    0.14884710f, 0.01388341f, 0.13673019f, 0.28148192f, 0.06921922f, -0.20942146f, 0.02913694f, -0.06539752f, 
    -0.76545751f, 0.00010277f, -0.01457702f, 0.09508462f, 0.02644986f, -0.05506411f, 0.02401319f, 0.04527382f, 
    -0.21417476f, 0.01930064f, -0.08175385f, -0.07289572f, -0.58333915f, -0.03045683f, 0.19460329f, 0.13079989f, 
    -0.10302151f, 0.11715472f, -0.19453590f, -0.17771822f, -0.16175084f, -0.13525672f, -0.02180255f, 0.02472322f, 
    -0.40268618f, 0.59772032f, -0.41869861f, -0.20212331f, -0.09742477f, -0.17415784f, 0.14718018f, 0.10398991f, 
    0.00519903f, -0.02070569f, 0.01546151f, 0.01402796f, -0.09648627f, -0.39444727f, 0.11988642f, -0.07634966f, 
    0.08953343f, 0.19923724f, 0.09749039f, -0.07711638f, -0.10437194f, -0.11695225f, 0.36030275f, 0.17208794f, 
    -0.38391098f, -0.07206271f, 0.13198432f, 0.38119414f, -0.16442333f, -0.18789896f, 0.14212814f, -0.16493714f, 
    0.04995660f, -0.08220875f, -0.16770209f, -0.15011100f, 0.12155163f, -0.17197406f, 0.28983089f, -0.13726583f, 
    0.12907059f, 0.13269737f, -0.03016525f, 0.23809434f, 0.16380359f, 0.00521093f, -0.14736010f, 0.21612409f, 
    0.53993529f, -0.02703772f, -0.23846668f, 0.00779065f, -0.08386306f, 0.02886505f, 0.24148624f, 0.02097378f, 
    -0.03485250f, -0.15372407f, 0.09042263f, 0.13803342f, 0.48299298f, -0.30442783f, 0.05249307f, -0.39804187f, 
    -0.07465217f, 0.02784533f, -0.19138114f, -0.16271469f, -0.02440577f, -0.05937963f, -0.04213430f, -0.06546698f, 
    -0.20188235f, -0.03277969f, -0.39315754f, -0.22159113f, 0.09972528f, 0.16864827f, -0.22462629f, -0.07445475f, 
    0.17845449f, 0.07098867f, 0.05811692f, 0.12388261f, -0.43415955f, -0.18243849f, -0.08025373f, -0.03338358f, 
    0.13099460f, -0.07076552f, -0.07972066f, 0.05885647f, 0.19121313f, 0.04818785f, 0.08581837f, -0.16023879f, 
    -0.00679198f, -0.01654985f, 0.11932512f, -0.20910943f, -0.03508104f, -0.09915933f, -0.09773761f, -0.02400330f, 
    0.03824417f, -0.21421151f, 0.14469723f, -0.24587217f, 0.14804690f, 0.01066776f, 0.17236426f, 0.15623832f, 
    0.03092913f, 0.08350897f, 0.14394182f, -0.06663285f, 0.14167209f, 0.12702180f, 0.04525744f, 0.40471482f, 
    0.76591367f, 0.33489883f, 0.02859020f, -0.38663429f, 0.02538227f, 0.15909852f, -0.34994659f, -0.35261238f, 
    -0.20530203f, -0.15114072f, 0.12143601f, -0.28287151f, 0.05472097f, -0.03782364f, 0.15476431f, -0.20693192f, 
    0.07165085f, -0.02811660f, 0.00934230f, 0.19748871f, -0.15010163f, -0.03237504f, -0.02438314f, 0.04333489f, 
    0.22013570f, -0.09722795f, 0.07822347f, 0.23017558f, 0.01208178f, -0.13078986f, -0.08790527f, -0.29746339f, 
    -0.23327863f, 0.05611771f, 0.09133566f, -0.11762371f, -0.18292077f, 0.30104461f, -0.07699428f, -0.29606906f, 
    0.01657657f, -0.16598080f, 0.03813467f, -0.16053563f, -0.03373205f, 0.17035368f, -0.03537365f, 0.10218070f, 
    -1.08870995f, -0.11317518f, -0.25231045f, -0.12828019f, 0.18350370f, 0.02790403f, -0.03190151f, -0.13347940f, 
    0.15882227f, -0.28580701f, -0.06348012f, 0.06607877f, -0.00960052f, -0.08479234f, -0.00926336f, 0.24494238f, 
    -0.17574887f, 0.06804576f, 0.18753843f, 0.07007761f, -0.30546042f, 0.12092385f, -0.10911933f, 0.40847006f, 
    -0.55316567f, 0.01083561f, 0.39745545f, -0.02859170f, 0.23556760f, 0.10864726f, 0.01630715f, -0.03349778f, 
    0.07330734f, 0.04100538f, -0.09614004f, -0.07889462f, 0.15054365f, -0.63458252f, -0.10866164f, 0.24874160f, 
    -0.02778907f, 0.15749346f, -0.05304496f, 0.23010498f, 0.21427542f, 0.01601708f, -0.21566394f, -0.11589183f, 
    0.24404654f, 0.00416188f, -0.20950422f, 0.38320804f, -0.20098072f, -0.17279248f, -0.07767753f, 0.16533883f, 
    0.06544825f, 0.03732606f, -0.08351221f, 0.25365147f, -0.22583506f, -0.13855231f, -0.42887685f, 0.24944212f, 
    0.08417333f, -0.00218618f, -0.10174191f, -0.07154179f, -0.10807209f, -0.18369220f, 0.35590008f, 0.19174108f, 
    -0.20259304f, 0.28344411f, 0.44655719f, -0.41524526f, 0.10299843f, -0.00056586f, -0.09578592f, -0.15323836f, 
    0.04419850f, 0.01163068f, 0.00397614f, -0.06002545f, -0.41902846f, 0.03883201f, -0.16693217f, 0.03256571f, 
    0.07549953f, -0.21784410f, 0.11890887f, 0.02163596f, -0.05832529f, 0.03961190f, 0.17234448f, 0.13063163f, 
    -0.66313469f, -0.29897416f, -0.18392660f, -0.38067445f, -0.00328389f, -0.06275486f, 0.07895882f, 0.08394945f, 
    -0.05834886f, 0.06039475f, 0.07491139f, 0.07559501f, 0.11118868f, -0.06548431f, -0.29069048f, 0.19213937f, 
    -0.12880579f, 0.11421470f, -0.27044272f, -0.20619206f, -0.28957185f, 0.01561122f, -0.07240569f, -0.02393753f, 
    -0.72080421f, 0.52920902f, 0.09476740f, 0.07368563f, 0.02927037f, 0.14002278f, 0.04626247f, 0.16933802f, 
    0.01318294f, 0.30148977f, 0.15013404f, 0.12854448f, 0.01770932f, 0.11339737f, 0.20175140f, -0.51335013f, 
    -0.15982547f, 0.07000436f, -0.00452895f, 0.06582092f, 0.00894344f, -0.13874166f, -0.18434729f, -0.18468948f, 
    -0.43854359f, -0.07009317f, -0.12641862f, 0.35504907f, 0.03424484f, -0.04110410f, -0.07737697f, -0.05346255f, 
    0.20002227f, 0.03809652f, 0.02738481f, 0.36295456f, 0.35626554f, 0.45211515f, -0.00244276f, -0.42072091f, 
    -0.07876047f, -0.18608493f, -0.06447940f, 0.10964088f, -0.04781453f, -0.09075730f, 0.18657400f, -0.07868609f, 
    -0.27270985f, 0.01391548f, -0.09692386f, 0.22414158f, 0.22154848f, 0.16481681f, 0.24871945f, 0.16465555f, 
    -0.31617045f, -0.12735985f, 0.08742513f, 0.29239175f, 0.22084339f, 0.02206798f, -0.51006889f, -0.09761691f, 
    -0.43357524f, -0.13107255f, -0.17739883f, 0.12624624f, 0.19563529f, -0.01937241f, -0.07828668f, -0.04108841f, 
    0.51234293f, -0.24611333f, -0.26944321f, -0.20108554f, -0.11224572f, 0.21656871f, 0.17701009f, -0.14188518f, 
    -0.20593135f, 0.14028519f, 0.12169284f, 0.00529326f, 0.19167238f, 0.02531754f, -0.09325867f, -0.20620909f, 
    -0.04423238f, 0.10660981f, 0.08077744f, 0.14772367f, 0.00365420f, -0.17845072f, 0.00842458f, -0.09385896f, 
    0.51768839f, -1.12810791f, -0.25192317f, 0.39233947f, -0.00868893f, -0.00933070f, 0.04706523f, 0.08720728f, 
    0.10706968f, 0.00899407f, -0.02146496f, 0.29189751f, -0.08505712f, 0.27081770f, -0.41075343f, 0.24932593f, 
    0.00347332f, -0.07051175f, 0.02603670f, -0.09858859f, 0.01393112f, -0.08282923f, 0.12317172f, -0.03023399f, 
    0.04782992f, -0.10812566f, -0.00945284f, -0.21090743f, 0.12607911f, 0.11356179f, 0.09948890f, -0.11894763f, 
    -0.01645663f, 0.04769775f, -0.12661928f, -0.21431099f, -0.48362347f, 0.03792146f, -0.12993534f, -0.45905885f, 
    0.15666367f, -0.08501630f, -0.09122526f, -0.30037850f, 0.07812178f, 0.13660717f, -0.03792426f, -0.01412702f, 
    0.12487733f, -0.02707379f, 0.47196627f, -0.42256558f, -0.13252459f, -0.01860103f, 0.15395829f, 0.27272472f, 
    -0.12253380f, -0.16364260f, 0.06428143f, -0.02784049f, -0.11928159f, 0.12064490f, -0.19359896f, 0.73713964f, 
    -0.03304886f, 0.26590866f, -0.08014453f, 0.12629178f, -0.15688024f, 0.04712287f, -0.23544092f, -0.36248073f, 
    -0.04262401f, 0.28535774f, 0.01774803f, 0.16382402f, 0.04838651f, 0.25528967f, -0.01506078f, -0.22991937f, 
    -0.06856311f, 0.19983402f, -0.19335428f, -0.13314393f, 0.17039301f, 0.33651367f, -0.08159531f, 0.60033238f, 
    0.16023718f, -0.07902474f, -0.38148114f, 0.13887994f, -0.18404558f, -0.02542209f, 0.00289230f, -0.19252776f, 
    -0.81748158f, 0.15145031f, -0.17760873f, -0.39762691f, 0.02023825f, 0.13631648f, -0.21360976f, -0.00935676f, 
    -0.38516200f, -0.01455793f, 0.07078555f, -0.00054006f, -0.33208111f, -0.11579359f, -0.37766171f, -0.03836833f, 
    -0.07669083f, -0.02296178f, 0.02292043f, -0.10826595f, 0.03759672f, -0.06578010f, 0.20744289f, -0.18737587f, 
    -0.01920976f, 0.11331145f, -0.26052317f, -0.15022576f, -0.12230693f, 0.02542408f, 0.19935897f, 0.13418646f, 
    0.18503456f, 0.07286623f, -0.02828432f, -0.04286454f, -0.41280070f, -0.23834954f, -0.14958173f, -0.18934840f, 
    -0.02346308f, -0.06647554f, -0.01956762f, -0.08721403f, -0.17121696f, 0.07466448f, -0.08372382f, -0.16446795f, 
    -0.09519111f, -0.20483084f, -0.12326230f, 0.18297355f, -0.12876421f, -0.20746537f, -0.01828762f, -0.13580155f, 
    -0.18385676f, -0.06302526f, -0.08596962f, -0.52837187f, 0.14784573f, 0.52357477f, 0.11143183f, 0.08932108f, 
    -0.22175799f, 0.07094045f, -0.02870600f, 0.01421621f, -0.07207673f, -0.03618141f, -0.09413753f, -0.06887374f, 
    0.01757509f, 0.60341477f, 0.45699799f, 0.22052754f, 0.18131286f, 0.14599097f, 0.23692635f, 0.09598698f, 
    -0.24795902f, 0.04086918f, 0.04101497f, -0.08641931f, -0.36015207f, -0.09013540f, -0.12207725f, 0.61817849f, 
    -0.12353725f, -0.17925346f, -0.24762373f, -0.05169810f, -0.16709585f, -0.00094613f, 0.03134051f, 0.06887937f, 
    0.27239373f, -0.50685412f, 0.17839848f, -0.05143567f, -0.01676514f, 0.09190915f, -0.02501174f, -0.13984536f, 
    0.15880220f, -0.14131908f, -0.02563069f, -0.11332072f, 0.00793479f, 0.21142450f, -0.06830083f, 0.37246996f, 
    -0.02709502f, -0.03002932f, 0.04871899f, -0.07866044f, 0.12737596f, 0.06080645f, -0.02647505f, -0.10386826f, 
    0.50396657f, -0.84343332f, 0.20947663f, 0.10049103f, 0.14385465f, -0.10782514f, -0.13044409f, -0.20219618f, 
    -0.05827173f, -0.07316247f, 0.15695710f, -0.11150610f, 0.29088190f, 0.05280756f, 0.14547013f, 0.48050225f, 
    0.23589154f, 0.15519558f, 0.04049744f, -0.05713516f, 0.10464009f, -0.04093341f, -0.16558999f, -0.41072205f, 
    -0.29455966f, 0.32266667f, -0.19594994f, -0.28555667f, -0.06402113f, 0.09287756f, -0.08194232f, -0.30751839f, 
    -0.20839022f, -0.13575533f, -0.13233575f, -0.22045061f, 0.13722146f, -0.00164749f, -0.22100490f, 0.28452072f, 
    0.10404234f, 0.07975886f, -0.10299352f, -0.06317981f, -0.03509005f, -0.13200141f, -0.08466186f, -0.09115762f, 
    -0.35026613f, 0.33221680f, 0.24046879f, 0.14485432f, -0.13221811f, 0.15253614f, -0.32511666f, -0.02533261f, 
    0.02758631f, -0.11724342f, -0.00133024f, -0.04731458f, -0.52444655f, 0.25621411f, -0.04039809f, -0.32657614f, 
    0.06358233f, -0.08623513f, 0.03382941f, 0.04176049f, 0.11695399f, -0.18110164f, 0.05908618f, -0.17742263f, 
    0.29676652f, -0.17045330f, -0.10150065f, 0.15747900f, 0.19024934f, 0.04199774f, -0.05190663f, -0.17185719f, 
    -0.09935806f, -0.08482371f, 0.02857416f, -0.05151231f, -0.23451896f, 0.29859042f, 0.12684010f, 0.38902685f, 
    0.08473700f, -0.02255174f, 0.00623112f, -0.04699206f, 0.09490886f, 0.10333333f, 0.12402403f, 0.32400912f, 
    0.33675960f, 0.25706872f, -0.23693013f, -0.00155653f, -0.25013798f, 0.10019183f, -0.34860080f, -0.18420458f, 
    -0.11353405f, -0.25017747f, -0.12012734f, -0.03063834f, 0.02613086f, -0.22463724f, -0.14762130f, 0.55012983f, 
    0.23535478f, -0.12324571f, -0.13424760f, 0.03491794f, 0.06414928f, -0.04842103f, 0.16942330f, -0.06019080f, 
    -0.49738833f, -0.52749652f, -0.21864547f, -0.25143769f, -0.12170880f, -0.13423364f, -0.15603638f, -0.02403898f, 
    0.12991303f, 0.21780904f, 0.05714780f, -0.01360278f, -0.28070790f, -0.30148485f, -0.11009169f, -0.16807194f, 
    -0.15707861f, -0.15202451f, 0.07486391f, -0.08082631f, 0.03755376f, 0.05335566f, 0.21305707f, 0.28407246f, 
    0.09949231f, -0.25043243f, 0.32390133f, 0.05216458f, -0.11371865f, 0.06875826f, -0.05627690f, -0.19122151f, 
    -0.02580005f, -0.10695684f, 0.10433758f, 0.23084438f, -0.13150787f, -0.30677146f, -0.54145902f, -0.21505915f, 
    0.09702934f, 0.00361847f, -0.16446243f, 0.11912300f, 0.18221319f, 0.26759627f, -0.02369058f, 0.03755230f, 
    0.25200632f, -0.04259285f, -0.02962114f, 0.12307031f, -0.03363580f, -0.13997149f, -0.09043254f, -0.25310546f, 
    -0.19197594f, -0.30897236f, -0.03259158f, -0.26839060f, -0.27084225f, 0.34308401f, -0.32459092f, -0.21417198f, 
    -0.23826192f, 0.09216730f, 0.09652194f, 0.32128525f, 0.12750472f, -0.07848672f, -0.31121737f, -0.28543779f, 
    0.07318260f, 0.04714723f, -0.02228899f, -0.20327187f, -0.01250831f, -0.10519406f, 0.09209038f, 0.01375811f, 
    0.37137517f, 0.14245112f, -0.01123273f, 0.21136291f, -0.37454551f, -0.28224447f, 0.36456111f, -0.16737059f, 
    -0.20159437f, 0.07707949f, -0.03248639f, -0.01630742f, 0.07380556f, -0.37066236f, 0.06334326f, -0.01664021f, 
    0.26613420f, -0.12664512f, 0.30062026f, 0.22811796f, 0.08098906f, -0.18824486f, 0.02620062f, -0.12802839f, 
    -0.12312708f, -0.08580095f, -0.06520075f, -0.29124138f, 0.63601786f, 0.36226073f, -0.55561727f, -0.18128212f, 
    -0.17113598f, -0.13444662f, -0.04995835f, -0.22328267f, 0.15772755f, -0.00910965f, -0.03511173f, 0.36440608f, 
    0.12441916f, 0.51538724f, 0.23104797f, 0.18104644f, 0.10036116f, 0.10599904f, 0.02382426f, 0.15751964f, 
    0.02204430f, -0.09661753f, -0.03781480f, -0.02483548f, -0.65297979f, -0.16219750f, 0.32582462f, -0.13258907f, 
    -0.07447062f, 0.19702804f, -0.02150370f, -0.00339274f, 0.01432554f, -0.10485474f, -0.07895278f, 0.07222366f, 
    -0.05504709f, 0.13867214f, 0.32888627f, 0.00245870f, -0.01725797f, 0.13978513f, -0.02861559f, -0.13182421f, 
    -0.09044624f, -0.06831503f, -0.02204754f, 0.07526393f, 0.49890798f, 0.14629631f, -0.59948540f, -0.35233060f, 
    0.11477070f, -0.08672244f, -0.10173879f, 0.19462965f, -0.11245295f, -0.01554274f, -0.29333892f, -0.26609185f, 
    -0.25034249f, -0.09721907f, 0.33924159f, 0.14477248f, -0.05916661f, 0.07207600f, 0.15554613f, 0.26677877f, 
    0.16412219f, 0.15046437f, 0.08439714f, 0.24777697f, -0.55879563f, 0.00873294f, -0.02020995f, -0.60460639f, 
    0.13191451f, 0.16972858f, -0.01288483f, 0.01674297f, -0.04076387f, 0.01792859f, -0.03160926f, 0.02675135f, 
    -0.49162817f, -0.06461585f, -0.19727747f, 0.26306283f, -0.08686587f, -0.02638975f, -0.14454222f, 0.07923441f, 
    0.01841771f, -0.02292434f, -0.17142679f, 0.22325751f, -0.06487424f, 0.49555314f, -0.23835100f, 0.05168652f, 
    0.05368381f, -0.12814958f, 0.19145280f, -0.06439228f, -0.02441405f, 0.10597111f, 0.08142645f, 0.05195924f, 
    -0.58515638f, -0.53940040f, -0.16987020f, -0.05493521f, 0.29867250f, -0.17902964f, -0.04335777f, -0.13062921f, 
    0.12395940f, 0.22410181f, 0.02545448f, -0.08611006f, -0.25789455f, -0.03484378f, -0.32575017f, -0.55242980f, 
    -0.21547385f, -0.02248077f, -0.10227244f, -0.00066439f, 0.01835706f, -0.17452434f, 0.13403101f, -0.08402504f, 
    0.81028354f, -0.14584339f, -0.31854618f, -0.06244229f, 0.03012303f, 0.15492880f, -0.18716602f, 0.00117686f, 
    -0.11069092f, -0.05525530f, 0.07708261f, 0.06251773f, 0.05358433f, 0.48275861f, 0.13733912f, 0.29681402f, 
    0.01275700f, 0.02513206f, -0.17927286f, 0.03469655f, -0.19288720f, 0.18101098f, -0.02769260f, 0.19165805f, 
    0.20581134f, -0.48006567f, 0.27781948f, -0.18965676f, 0.00762050f, -0.06125356f, 0.04261519f, -0.20856479f, 
    -0.04344721f, -0.31032085f, 0.04265040f, -0.19836716f, 0.09678280f, -0.15507869f, -0.53961551f, -0.05029954f, 
    0.06369337f, 0.11394228f, 0.13309723f, -0.35634610f, 0.04456599f, 0.03082711f, -0.09495700f, -0.03957699f, 
    -0.70544326f, 0.44397765f, -0.34161586f, -0.22705658f, 0.19422287f, -0.12237186f, 0.03369814f, -0.04782492f, 
    0.13746798f, -0.04033059f, 0.13568822f, 0.23019052f, 0.41115510f, -0.07084382f, 0.40348360f, -0.15174760f, 
    -0.09188106f, -0.08849239f, 0.02298323f, 0.13336614f, 0.06907637f, -0.06774921f, -0.13423663f, 0.12113263f, 
    0.14975633f, 0.01906105f, 0.08680686f, 0.17797738f, 0.06361699f, 0.00726236f, 0.07371207f, 0.08745872f, 
    0.17981127f, -0.16103810f, -0.00655807f, 0.01938230f, 0.05781177f, 0.09362032f, -0.00667692f, 0.08947332f, 
    0.15216455f, 0.26791173f, 0.17772706f, -0.26772550f, -0.01144900f, 0.39516482f, 0.16496453f, -0.16737033f, 
    -1.21004808f, -0.71941531f, 0.13082610f, 0.22906809f, 0.34306693f, 0.17094347f, 0.13469331f, -0.11560430f, 
    0.12631181f, 0.12330402f, 0.03246264f, -0.07567168f, -0.89054227f, -0.32867083f, -0.27880001f, -0.53074437f, 
    -0.02403829f, -0.09782781f, 0.08303546f, 0.16661006f, -0.06721243f, 0.28318873f, 0.11234433f, 0.16259186f, 
    -0.39574152f, -0.20751436f, -0.30466685f, -0.35519603f, -0.21308009f, 0.18496777f, 0.09147879f, -0.22062577f, 
    0.09060720f, -0.45376855f, -0.38932544f, -0.42961037f, -0.60702127f, -0.02818045f, -0.09021446f, -0.38630778f, 
    0.30892265f, -0.06876733f, -0.25550854f, 0.05453012f, 0.04270189f, -0.00520244f, 0.07901911f, 0.24572228f, 
    -0.99335951f, -0.62734169f, 0.33336347f, -0.04883095f, 0.10973633f, 0.08285095f, -0.06181297f, 0.09161981f, 
    -0.19148132f, -0.13571168f, -0.12171098f, 0.03314461f, -0.15691204f, -0.30337217f, -0.05627929f, -0.03540679f, 
    0.12860452f, -0.02731441f, -0.15013085f, 0.03967096f, 0.06471670f, -0.11534326f, -0.28548381f, -0.39938515f, 
    0.63409537f, 0.32024014f, -0.18677902f, 0.21952422f, -0.20551294f, -0.10845192f, 0.08205228f, -0.06306825f, 
    0.16458929f, -0.19259590f, 0.03574480f, 0.04057168f, 0.20155276f, 0.25902450f, -0.04149985f, -0.29661900f, 
    0.24644980f, -0.01192723f, 0.02032966f, 0.13719755f, 0.26750609f, 0.23057659f, 0.02304826f, 0.16070791f, 
    -0.12062779f, 0.44284001f, -0.01450190f, -0.14238432f, -0.20553491f, 0.09161999f, -0.06608509f, -0.09604773f, 
    0.11138204f, -0.09445369f, 0.19234611f, -0.01882842f, 0.00229736f, -0.10270142f, 0.27693671f, -0.15596853f, 
    -0.20639582f, -0.05160663f, -0.13599892f, -0.07271672f, 0.22578882f, -0.20036376f, -0.01296245f, -0.27419543f, 
    -0.04471244f, 0.58965248f, -0.16092503f, -0.13095695f, 0.04663447f, 0.14115490f, 0.26320106f, 0.10621025f, 
    -0.02445911f, 0.13253792f, 0.21191330f, 0.39628747f, 0.20605324f, 0.34829244f, -0.09235241f, -0.07530244f, 
    0.00045774f, 0.29919311f, 0.27128223f, -0.00041659f, -0.09557499f, -0.04879070f, 0.23180583f, -0.25510174f, 
    -0.46519721f, -0.34089908f, -0.47757751f, -0.05606817f, 0.08976402f, -0.04230982f, -0.21539694f, 0.06359842f, 
    -0.09880895f, -0.04544720f, -0.09057350f, 0.07006831f, -0.57672763f, -0.05445811f, -0.01903369f, 0.34494513f, 
    0.13971637f, -0.08076870f, -0.15137517f, -0.05623109f, -0.06291521f, 0.12951112f, -0.02521925f, 0.26172569f, 
    0.07332432f, -0.04931097f, -0.10857113f, 0.12892427f, -0.13028358f, -0.08367059f, -0.07770823f, -0.12102976f, 
    0.28676021f, 0.02291407f, -0.00483979f, -0.19382261f, 0.65749437f, 0.20921966f, -0.42154062f, 0.03102588f, 
    -0.04437606f, -0.13735907f, -0.36600989f, -0.09786300f, -0.20411903f, -0.18960634f, -0.16203731f, 0.09750632f, 
    0.78902006f, 0.17508253f, 0.03739826f, -0.00669785f, 0.15778860f, 0.24786893f, -0.09906861f, -0.05142213f, 
    -0.02330048f, -0.01700987f, -0.02709592f, 0.10317504f, 0.13986205f, -0.56373060f, -0.24731249f, -0.07489298f, 
    -0.06075799f, -0.10762141f, -0.11898150f, -0.05618071f, -0.24785742f, 0.05768077f, 0.00924963f, -0.34155470f, 
    -0.61264539f, -0.56177425f, 0.01208999f, -0.16158099f, 0.01767178f, -0.02866281f, -0.01082319f, 0.21016732f, 
    0.07451826f, -0.02866013f, 0.06281087f, -0.05201531f, 0.59633666f, 0.04360675f, -0.37012964f, -0.27387568f, 
    0.01233774f, -0.10397655f, 0.12870829f, 0.03989621f, 0.05447941f, 0.04974639f, -0.06824642f, -0.01637628f, 
    -0.39146692f, 0.47379872f, -0.37514338f, 0.08563725f, 0.13464239f, 0.19583467f, -0.00661882f, -0.20775256f, 
    0.14894292f, -0.05006516f, 0.04791584f, -0.02702606f, 0.22227745f, -0.36987710f, 0.14830516f, 0.36333972f, 
    -0.17528392f, 0.07132317f, 0.01260005f, -0.01011828f, -0.03779182f, 0.00374543f, 0.01416780f, -0.12618034f, 
    -0.00773221f, -0.01646220f, 0.01511327f, -0.03793507f, 0.08687914f, 0.23793462f, -0.01055324f, 0.04722921f, 
    -0.14760245f, -0.11463393f, -0.22475605f, -0.14212345f, 0.21707699f, -0.48451397f, -0.19058263f, 0.80392361f, 
    0.06865072f, -0.04363623f, 0.07562011f, -0.07882180f, 0.14197282f, -0.07493240f, 0.01263830f, 0.03823764f, 
    -0.65087938f, -0.33015913f, 0.03018644f, -0.06690522f, -0.16501422f, -0.01213158f, 0.21020837f, 0.03628275f, 
    -0.13281785f, 0.06944565f, 0.30126822f, 0.19860780f, -0.20429979f, 0.49293467f, -0.07327786f, 0.09056816f, 
    -0.08609623f, 0.11148543f, -0.07104353f, -0.48850474f, -0.14323948f, -0.02879793f, 0.40190560f, 0.14814225f, 
    0.17319222f, -0.07135823f, -0.06874941f, 0.13264209f, -0.22417858f, 0.13143483f, -0.05608800f, 0.31629094f, 
    -0.05242660f, -0.11900908f, -0.06668258f, 0.04374659f, -0.30952948f, 0.22602344f, -0.24806517f, -0.17773351f, 
    -0.46079743f, 0.21219510f, 0.10487990f, -0.03064861f, 0.17429227f, -0.10266135f, 0.01307336f, -0.30631360f, 
    -0.21545637f, -0.52049732f, 0.07997955f, -0.34647122f, 0.00033134f, 0.04354116f, 0.07758404f, 0.11505271f, 
    -0.02459291f, 0.03861752f, -0.19124569f, 0.13766387f, 0.56071806f, -0.32710540f, 0.16254997f, 0.22315238f, 
    -0.23728755f, 0.03412725f, -0.24511617f, -0.03764815f, 0.26924255f, 0.02583347f, 0.04573064f, -0.04083431f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18515313f, 0.07510592f, -0.13892020f, 0.05590063f, -0.03259958f, -0.03789532f, 0.02299589f, -0.20795944f, 
    -0.05468089f, 0.00138602f, 0.21098426f, 0.11157103f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
