#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.66188878f, 0.47018602f, 0.09159128f, -0.58233106f, 0.15587196f, 0.07171527f, -0.07354361f, -0.21199203f, 
    -0.18170805f, 0.05247544f, -0.40424484f, -0.19507101f, -0.53347933f, -0.29179907f, -0.38973624f, 0.13394462f, 
    0.00612854f, 0.10930555f, 0.46752250f, 0.45314986f, 0.04846604f, 0.54975384f, 0.40593225f, -0.00281705f, 
    -0.06112015f, -0.26655829f, 0.21631579f, 0.48224413f, 0.46709293f, 0.67539954f, 0.12097247f, 0.08259812f, 
    0.14766186f, 0.28079295f, 0.26179045f, -0.24876124f, 0.11838024f, 0.39001948f, -0.31164673f, -0.30481619f, 
    -0.34820494f, 0.42347127f, 0.19402477f, -0.45630214f, 0.32221049f, -0.62897456f, 0.75066155f, 0.29447326f, 
    -0.32255742f, 0.15612297f, -0.12712151f, -0.11207459f, 0.13219914f, -0.22527102f, -0.32740414f, -0.25366592f, 
    0.16151531f, -0.59245306f, -0.44017571f, 0.17215790f, 0.15623732f, 0.40580714f, -0.25849202f, 0.09757493f, 
    -0.47111458f, -0.08679731f, -0.56176949f, 0.37796846f, -0.24040204f, 0.25966340f, 0.41381910f, 0.08764442f, 
    -0.57858068f, -0.14387181f, -0.39532894f, 0.40881303f, 0.70925629f, 0.30819285f, -0.16441289f, 0.01500615f, 
    -0.06280664f, 0.22092555f, 0.37234902f, 0.46617478f, -0.47947386f, 0.20597309f, -0.31101766f, 0.12716098f, 
    -0.00913184f, 0.34399444f, -0.72818369f, -0.66725904f, -0.34895474f, -0.03097413f, -0.33837059f, 0.28756273f, 
    0.02581241f, -0.12925304f, 0.25238487f, -0.44989112f, 0.44404075f, 0.51446074f, 0.35186607f, 0.36066562f, 
    0.04892822f, -0.07882454f, -0.26259455f, 0.21423711f, 0.06243084f, -0.10260549f, 0.14080127f, 0.12953600f, 
    -0.82937336f, 0.34768364f, 0.01717933f, -0.22983435f, -0.32807085f, 0.19671372f, -0.27988261f, -0.52731287f, 
    -0.64139706f, 0.61031353f, -0.08613443f, 0.23747796f, -0.15093814f, 0.18408544f, -0.26403999f, 0.41488519f, 
    0.14552860f, 0.31951997f, 0.08900323f, 0.53189218f, 0.53846753f, -0.17655140f, 0.16299646f, 0.27852109f, 
    -0.84209365f, 0.14279477f, -0.00104264f, -0.62282258f, -0.05003383f, 0.34896380f, 0.04175086f, 0.15433218f, 
    -0.28323850f, -0.58443934f, -0.45698950f, 0.33744481f, -0.32541901f, 0.01689143f, -0.11430711f, -0.09026463f, 
    -0.43736511f, -0.48563278f, 0.39989412f, -0.35474688f, 0.68515056f, -0.30419889f, -0.22790271f, -0.07477299f, 
    -0.32965809f, -0.30808657f, 0.68676519f, -0.74647456f, 0.00229578f, 0.52277410f, 0.35506666f, 0.41575247f, 
    0.15658931f, -0.11511868f, -0.24150971f, 0.37918469f, -0.26413900f, 0.50208193f, 0.53847414f, 0.43040279f, 
    0.21033688f, -0.47323543f, -0.16902362f, -0.14705767f, 0.43788213f, 0.11350320f, 0.36872187f, 0.44147110f, 
    -0.01747972f, 0.04027463f, 0.30785975f, -0.52655971f, 0.36534443f, -0.40013614f, -0.18907985f, -0.04529181f, 
    0.44595411f, 0.71024549f, -0.38363478f, 0.08067469f, 0.21088672f, -0.22688197f, 0.58560079f, 0.56798649f, 
    -0.12042580f, -0.21679541f, -0.14627677f, -0.50525630f, 0.33704600f, 0.28647128f, 0.13833095f, 0.69017935f, 
    0.28064552f, 0.39354932f, -0.26166245f, -0.21531013f, 0.40297398f, -0.31945309f, 0.16060650f, 0.26693293f, 
    -0.38951781f, 0.21413307f, -0.36489460f, 0.41623569f, -0.24158943f, -0.25601223f, -0.26061973f, 0.01351361f, 
    0.44594797f, 0.04198167f, -0.36457768f, -0.01048620f, -0.38736111f, 0.19915652f, -0.36031738f, -0.35768560f, 
    -0.23677538f, -0.50939220f, -0.05670402f, -0.38292563f, -0.51525509f, 0.41500422f, 0.00970945f, 0.42787611f, 
    -0.29831845f, 0.05255818f, -0.06366149f, 0.04306292f, 0.12869719f, -0.10716368f, -0.53005350f, -0.47917247f, 
    -0.39912948f, -0.22342485f, 0.50105989f, 0.01267755f, 0.15234652f, -0.02692686f, 0.33732694f, 0.53734624f, 
    0.07457796f, -0.00707875f, 0.32943255f, 0.33384642f, -0.03849022f, 0.35590091f, 0.24405198f, 0.34833229f, 
    -0.13517903f, -0.53869325f, -0.07779527f, 0.08846149f, 0.06984887f, 0.06320732f, 0.74964833f, -0.28984958f, 
    -0.48677433f, 0.64150405f, -0.13291796f, -0.45020550f, -0.28356498f, -0.10654569f, 0.28420672f, -0.52193028f, 
    -0.54255873f, -0.65202558f, 0.30498612f, 0.32313570f, 0.33083278f, 0.38653067f, -0.17689303f, 0.13083266f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.29136920f, 0.32631525f, -0.26371297f, 0.26197997f, 0.11058559f, -0.09815217f, -0.01859125f, 0.15933108f, 
    0.14295021f, -0.02816766f, -0.03640319f, 0.11694597f, -0.05007973f, -0.22628872f, -0.32278731f, -0.07365701f, 
    -0.22039016f, -0.31317481f, -0.26924437f, -0.06161353f, -0.39443579f, -0.12552686f, -0.34311515f, -0.24049911f, 
    -0.14623016f, 0.20877947f, -0.07767379f, 0.01694725f, 0.09138385f, 0.05410850f, -0.29004502f, 0.21066287f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.08327734f, -0.05550764f, -0.22642182f, -0.03259123f, -0.07519601f, 0.10576496f, -0.01999660f, 0.00882828f, 
    0.01621713f, 0.06889996f, -0.00676104f, -0.24176697f, 0.06110928f, 0.04631080f, 0.09037224f, 0.02262783f, 
    -0.05957434f, 0.02051819f, 0.04094384f, -0.10899007f, 0.09304981f, -0.09168008f, -0.09995539f, -0.07102013f, 
    0.08862387f, 0.02036871f, -0.02377307f, 0.04227647f, 0.03048985f, 0.02922322f, -0.01557355f, -0.00524304f, 
    -0.00919393f, -0.09954709f, -0.03993864f, -0.03822390f, 0.13420427f, -0.15073957f, -0.08645166f, -0.00608399f, 
    0.05409326f, 0.12015162f, 0.00670018f, 0.07432192f, -0.00381469f, -0.26699781f, 0.09296119f, -0.32072508f, 
    -0.09042641f, 0.02982075f, 0.11200769f, -0.07445113f, -0.02598772f, -0.09554312f, -0.26552913f, 0.08080053f, 
    -0.16829017f, 0.04981747f, -0.09602820f, -0.03363840f, 0.04694379f, -0.12833031f, -0.04700034f, 0.14340971f, 
    -0.21104906f, -0.18721944f, 0.07807731f, -0.03551151f, -0.02774790f, 0.07259696f, -0.06688682f, 0.04267552f, 
    0.05331095f, 0.06657550f, -0.02682672f, -0.03977950f, 0.03547442f, -0.07625749f, 0.02950485f, 0.09982546f, 
    -0.13366084f, 0.01892375f, -0.07912555f, -0.01886161f, -0.08573937f, -0.05208356f, 0.07232969f, 0.09742629f, 
    -0.04539777f, 0.09953693f, -0.04073812f, 0.50893575f, -0.05447850f, 0.01663423f, -0.02399239f, -0.00526147f, 
    -0.04345823f, 0.03633020f, 0.04727145f, -0.11320741f, 0.09708353f, 0.03494459f, -0.03851843f, 0.17870533f, 
    0.05337447f, -0.07063290f, 0.06072699f, 0.08301882f, -0.17713411f, 0.01874921f, 0.06641020f, -0.00743198f, 
    0.05164544f, -0.05661957f, -0.04072719f, 0.00197797f, -0.03843422f, 0.32137451f, -0.28837678f, -0.15023461f, 
    0.04590878f, -0.00335402f, 0.03473518f, 0.01889812f, -0.01765109f, -0.01786209f, 0.11212112f, 0.17084660f, 
    -0.10901842f, -0.10649247f, -0.09760834f, -0.02515554f, 0.03051681f, 0.08478644f, 0.04459961f, 0.04860932f, 
    0.22855279f, -0.07239014f, 0.10414200f, -0.03221004f, 0.00324658f, -0.03357149f, 0.01182549f, 0.07199882f, 
    0.05528608f, 0.32696253f, 0.04360009f, 0.10123422f, -0.06693643f, -0.05381935f, 0.03056778f, 0.00564607f, 
    -0.19773164f, -0.39475891f, -0.06065072f, -0.26964167f, 0.12659222f, 0.04531858f, 0.09508446f, 0.10711163f, 
    0.00167341f, -0.00120115f, 0.22332124f, -0.23457363f, 0.19521816f, -0.01140069f, 0.05569473f, -0.07673276f, 
    0.07950981f, 0.08280157f, 0.02050594f, 0.19888781f, -0.00613112f, -0.06959437f, -0.00857789f, 0.07081505f, 
    -0.09536305f, 0.07093246f, 0.06197086f, 0.11839332f, 0.01204215f, 0.01199709f, 0.21570879f, -0.04623821f, 
    -0.17855018f, -0.07104976f, 0.00557834f, 0.10993022f, -0.05313740f, -0.04280648f, -0.19581592f, -0.00119811f, 
    -0.07384969f, 0.08542323f, -0.02713470f, -0.05611326f, -0.02195562f, 0.06335393f, 0.28098679f, -0.32063243f, 
    0.03430106f, -0.00033234f, 0.06138515f, 0.06193693f, 0.00096450f, 0.00693227f, 0.04381999f, 0.04232261f, 
    -0.03396649f, -0.08526231f, 0.08189410f, -0.02586130f, -0.02495478f, 0.03437621f, -0.13672473f, 0.08380988f, 
    -0.10513905f, -0.02162922f, -0.14355567f, -0.07726725f, 0.08963693f, 0.05327629f, 0.00241899f, 0.00432694f, 
    0.07519777f, -0.03868946f, -0.11784453f, -0.13460325f, 0.10713771f, 0.04896390f, -0.02293427f, -0.06060044f, 
    -0.01593493f, -0.19258945f, 0.00873427f, 0.08862694f, 0.08460234f, 0.03395049f, 0.03197449f, 0.08439230f, 
    0.00267014f, 0.02884774f, -0.07516976f, -0.26476780f, -0.20089839f, -0.27045622f, -0.02029101f, -0.06268013f, 
    0.12668447f, 0.04780245f, -0.13056752f, -0.15171963f, -0.02355006f, 0.03020539f, 0.07706758f, 0.02851774f, 
    0.08799896f, -0.06717918f, 0.01421632f, 0.06808944f, 0.16373746f, -0.16664422f, -0.02974530f, 0.08143744f, 
    -0.00938553f, 0.16276190f, -0.02541476f, -0.09209336f, -0.08620664f, 0.06756529f, 0.08127875f, -0.06650936f, 
    0.02948933f, -0.08338703f, -0.05531804f, 0.18258682f, 0.00873460f, -0.00705914f, 0.03017516f, 0.09102488f, 
    0.29970950f, 0.04096580f, -0.02910868f, 0.11567864f, -0.02656511f, -0.00419265f, 0.13078688f, -0.03341424f, 
    -0.14430285f, -0.24686372f, -0.19454575f, 0.17228113f, -0.05149388f, 0.00767225f, -0.03092740f, 0.01471076f, 
    0.07317407f, -0.19684425f, 0.06349298f, 0.02734075f, 0.02979260f, 0.02628062f, 0.03817037f, 0.06927961f, 
    0.07015628f, 0.06943279f, 0.07562927f, 0.13199359f, -0.02515455f, 0.19367135f, -0.13979091f, -0.11147629f, 
    0.00039726f, -0.10244957f, -0.10176516f, 0.09952156f, 0.18724588f, 0.05099875f, 0.11275062f, 0.13283658f, 
    -0.06867076f, -0.08778205f, -0.01176510f, 0.06918275f, 0.10674933f, -0.02246398f, 0.00007708f, 0.10707841f, 
    -0.09723756f, 0.09598993f, 0.07540110f, 0.14474550f, 0.00477120f, -0.36580637f, -0.23268050f, 0.02208736f, 
    0.04330118f, 0.05573767f, -0.00781050f, 0.08620255f, -0.02734569f, -0.02869622f, -0.03642757f, -0.01799666f, 
    0.02160954f, 0.03938856f, -0.07537384f, 0.00192761f, -0.03363013f, -0.18221742f, -0.01855648f, 0.03627636f, 
    0.09985376f, 0.00001365f, -0.04629880f, 0.05189638f, 0.07962743f, 0.04218177f, -0.06532789f, -0.00264473f, 
    -0.21222101f, -0.11208715f, 0.05252503f, -0.00541015f, -0.03091067f, -0.18181826f, -0.13726027f, -0.02245711f, 
    -0.07452273f, 0.13656165f, -0.07122958f, -0.19454166f, 0.19792026f, 0.05804854f, -0.13628811f, 0.06858747f, 
    0.09048689f, 0.13206813f, -0.33605903f, -0.00791276f, 0.19547878f, -0.01385497f, 0.10957571f, -0.09271261f, 
    -0.06472892f, 0.05620509f, 0.06092380f, 0.05785764f, 0.02782845f, 0.07061071f, 0.10274322f, -0.01169539f, 
    -0.06352302f, -0.06345768f, -0.01991710f, 0.02944009f, -0.06725021f, 0.01501745f, -0.12066741f, -0.01134681f, 
    -0.05314208f, -0.00593234f, 0.00107931f, 0.03278184f, -0.02328880f, -0.00652795f, 0.03726753f, -0.14449471f, 
    -0.08598001f, -0.14985792f, -0.03358985f, 0.04892201f, -0.08942252f, -0.01547273f, 0.29643005f, 0.05202802f, 
    0.03261169f, -0.03876850f, -0.01519363f, -0.18116991f, 0.03760510f, -0.04760680f, 0.04439556f, 0.09259711f, 
    -0.00988488f, 0.24489146f, 0.09543651f, 0.01965060f, 0.08921275f, -0.08894317f, 0.15275218f, 0.09446009f, 
    0.04235478f, 0.09738809f, 0.00056511f, 0.12827149f, -0.00658296f, -0.14624918f, 0.00039704f, 0.14986153f, 
    0.07143507f, -0.13973346f, -0.17030779f, -0.18235068f, 0.09021507f, -0.18147610f, -0.15246917f, 0.00421314f, 
    -0.10542117f, -0.08854943f, 0.12560849f, 0.14717238f, 0.10326989f, 0.00015723f, -0.17576297f, -0.02184933f, 
    0.19963393f, 0.06040273f, -0.05865784f, 0.05786834f, 0.23202680f, -0.02748183f, -0.12819339f, -0.07509326f, 
    -0.00585344f, -0.04124153f, 0.09010102f, 0.05309987f, 0.05317629f, 0.20130202f, 0.10294657f, 0.07436495f, 
    -0.01372905f, -0.16836300f, -0.10065004f, -0.04055806f, -0.05717450f, -0.03423538f, -0.27168998f, -0.08944675f, 
    -0.19089788f, -0.13110882f, -0.02249714f, 0.06438045f, -0.07438709f, -0.05039842f, 0.25721785f, 0.07406541f, 
    -0.31118128f, 0.06286665f, 0.10003459f, -0.07958148f, 0.03955640f, -0.09900930f, -0.01346298f, 0.01381279f, 
    -0.15059361f, -0.00643516f, 0.22955075f, 0.09174816f, -0.01869202f, 0.00567232f, -0.09698536f, 0.18846360f, 
    -0.41885594f, -0.02965860f, -0.14864436f, 0.00684373f, 0.13181563f, 0.00550512f, 0.01066258f, 0.09756662f, 
    0.10865551f, -0.01084133f, -0.07372919f, -0.09896705f, 0.03692499f, 0.08054417f, 0.11187184f, 0.05321648f, 
    -0.08818219f, 0.01933869f, -0.21109369f, 0.17993926f, -0.03551092f, 0.11822424f, 0.01810822f, -0.13854979f, 
    0.09621603f, 0.01342261f, -0.09064806f, -0.06904770f, -0.04654939f, -0.23307614f, 0.11279709f, 0.03635904f, 
    0.07509319f, 0.05388646f, -0.08189081f, 0.05140225f, 0.15174925f, 0.16601743f, 0.10614835f, 0.02501144f, 
    -0.01933087f, 0.11259239f, -0.06121257f, 0.06984504f, 0.07202269f, 0.16082077f, -0.09889718f, 0.05811071f, 
    0.06667030f, 0.11309835f, -0.01842178f, -0.03833090f, 0.08264646f, 0.14905035f, -0.07693990f, 0.20908482f, 
    0.08565763f, 0.07419763f, -0.01489880f, -0.05541450f, -0.07025795f, -0.11746631f, 0.10645809f, -0.14297974f, 
    -0.06178402f, 0.21560764f, -0.04947853f, 0.07967255f, 0.02446280f, -0.04047457f, 0.06607990f, -0.00794692f, 
    -0.06858350f, -0.05937666f, -0.17051159f, 0.08359019f, 0.04707525f, 0.08658216f, 0.06316692f, 0.02255004f, 
    -0.03881570f, 0.16054066f, -0.01681664f, -0.10130999f, -0.08274142f, 0.05821734f, -0.04423800f, 0.04869280f, 
    -0.02385860f, -0.02101904f, 0.03611020f, 0.00376601f, 0.01249850f, 0.02891440f, 0.02616583f, 0.16175662f, 
    -0.00275145f, -0.07105482f, -0.06093629f, -0.05140369f, -0.02702872f, -0.06482244f, 0.13897583f, 0.08217913f, 
    0.07660689f, -0.03040305f, -0.23489068f, 0.02318086f, -0.08233357f, 0.03230714f, -0.09894063f, 0.08971843f, 
    0.01436150f, 0.05399872f, -0.09425107f, -0.00829763f, 0.06477422f, 0.14795642f, -0.17308247f, -0.11769723f, 
    -0.22914685f, 0.00792122f, 0.01285622f, -0.21277994f, -0.14846866f, -0.07364049f, 0.00658468f, -0.03071997f, 
    -0.23884384f, -0.01353753f, -0.05328210f, -0.11562711f, 0.00817694f, -0.04664414f, -0.06770486f, 0.13589805f, 
    0.06001003f, -0.03950661f, -0.05616546f, -0.04544417f, 0.04952042f, -0.01939380f, 0.00447860f, -0.06199147f, 
    0.15430737f, 0.04470669f, 0.25497183f, -0.12106752f, -0.05381253f, 0.01507858f, -0.10926966f, 0.02076967f, 
    0.13405141f, 0.10517357f, 0.10258368f, 0.06037910f, 0.01859847f, 0.00943186f, -0.03306117f, -0.14608325f, 
    -0.01646026f, -0.13682842f, 0.07631618f, -0.04803531f, 0.18674619f, -0.03034284f, -0.07571052f, -0.14420912f, 
    -0.04187033f, -0.00283543f, 0.05707885f, 0.19330324f, 0.07078841f, -0.18919648f, 0.05469350f, 0.06652046f, 
    0.17172115f, 0.05457976f, 0.04661032f, -0.12068997f, -0.14815032f, -0.06530890f, -0.28689781f, -0.02637923f, 
    0.07219724f, -0.04311821f, 0.05296825f, 0.00140858f, -0.06980822f, 0.09591140f, -0.05151008f, -0.07688641f, 
    -0.02345852f, -0.04722320f, 0.00558711f, 0.05743438f, -0.09644981f, 0.05134593f, 0.15055814f, 0.13129191f, 
    -0.05813507f, 0.15330328f, -0.02338712f, -0.01068236f, 0.05847027f, -0.09810157f, 0.09117582f, -0.06120301f, 
    -0.04276727f, -0.22320394f, 0.06456663f, 0.04277792f, -0.20665358f, -0.03174267f, -0.02645706f, -0.07276809f, 
    -0.23897369f, -0.10648924f, 0.13176565f, 0.03320532f, 0.05848715f, 0.12011239f, 0.13464694f, 0.02927243f, 
    -0.05186160f, -0.21411017f, -0.12937380f, -0.03234827f, 0.02559754f, -0.05215487f, -0.02397539f, -0.13856462f, 
    -0.13547884f, 0.12079786f, -0.05550380f, 0.16177222f, 0.18466091f, -0.00345910f, 0.05373089f, -0.02336683f, 
    -0.04027204f, -0.10042872f, 0.05009722f, -0.12424481f, 0.07805458f, -0.05084146f, 0.08126169f, 0.02509292f, 
    0.09684116f, 0.07769351f, 0.07198064f, 0.00660607f, 0.07980789f, -0.16955602f, -0.00114442f, 0.15918010f, 
    0.10666228f, 0.15969394f, -0.04982897f, 0.15773571f, -0.18377949f, 0.13548528f, -0.04753124f, 0.06002331f, 
    -0.03882763f, -0.11748040f, -0.03329332f, 0.14063846f, 0.07491031f, 0.02283277f, 0.00940807f, 0.09524982f, 
    0.19687207f, 0.10172767f, -0.02643361f, 0.05511627f, 0.01550705f, -0.07665734f, -0.07670303f, -0.21808769f, 
    0.03620693f, 0.02266598f, 0.01521424f, 0.07195677f, 0.20259947f, -0.01119440f, 0.06298287f, 0.03571533f, 
    -0.16533847f, 0.02092033f, 0.02252365f, 0.10062767f, -0.12699130f, -0.01397893f, -0.00160165f, 0.01919697f, 
    0.03167053f, -0.19911470f, -0.10571864f, 0.09574214f, 0.00387536f, 0.05812053f, 0.07728886f, -0.02344470f, 
    0.03377207f, -0.07503603f, 0.08824398f, 0.03268331f, 0.34087828f, -0.04543404f, 0.18285979f, 0.02218323f, 
    0.05382240f, -0.07974203f, 0.12394131f, -0.06462346f, 0.08566027f, -0.00435299f, -0.00368451f, -0.01348761f, 
    -0.03212360f, -0.03082205f, 0.11100551f, -0.08592302f, -0.10807595f, -0.06539245f, -0.06000984f, 0.06796557f, 
    -0.05986267f, 0.04025882f, 0.04464822f, -0.03915513f, 0.12869731f, -0.02899661f, 0.19750978f, -0.20400696f, 
    0.01290348f, -0.03392766f, 0.03356732f, -0.07340042f, -0.04847228f, 0.02489740f, 0.06575526f, -0.06555293f, 
    0.30300012f, -0.13346709f, 0.00682196f, 0.05460527f, -0.08362301f, 0.01104438f, -0.19930419f, 0.10431807f, 
    0.02642411f, 0.21434824f, -0.05569312f, -0.06362451f, 0.02459306f, 0.00861327f, 0.04258352f, 0.02314596f, 
    0.11001531f, 0.05661922f, 0.01761416f, -0.02846397f, 0.06811167f, 0.03734742f, 0.06852340f, 0.04132945f, 
    0.02261261f, 0.06647249f, -0.09161872f, 0.01664789f, 0.06687090f, 0.01875069f, 0.11915341f, -0.04194156f, 
    0.00163587f, 0.07399048f, -0.04960142f, -0.01213608f, 0.06026733f, -0.17651686f, -0.05616668f, -0.15419585f, 
    -0.28821167f, 0.12994367f, -0.03177736f, -0.00214088f, -0.02950144f, 0.08103270f, -0.06133457f, -0.09580561f, 
    0.02316890f, -0.01452700f, 0.04542273f, -0.09831267f, 0.02411455f, -0.15495665f, -0.10661943f, 0.00224066f, 
    -0.10115031f, 0.02618519f, 0.01186312f, -0.02019320f, 0.08008035f, 0.12316907f, -0.03608081f, -0.38386163f, 
    0.02099532f, 0.19688916f, 0.14294331f, 0.10693357f, -0.01701121f, -0.00248506f, -0.09046674f, -0.21402073f, 
    0.12460086f, -0.02620901f, -0.01378091f, 0.08799864f, 0.02026366f, 0.07028726f, 0.08713154f, 0.18095432f, 
    -0.07477444f, -0.02081367f, -0.06071118f, 0.06921595f, -0.04420004f, 0.01046028f, -0.01349802f, -0.06471307f, 
    0.10507154f, 0.00535265f, -0.00228962f, -0.00328821f, 0.03441240f, -0.14121582f, 0.09314963f, -0.00664005f, 
    0.05414115f, 0.13976043f, 0.05891721f, -0.04647687f, -0.06052804f, -0.01796971f, -0.05468714f, -0.06750873f, 
    -0.06597456f, 0.05773576f, -0.00077477f, 0.15963753f, 0.15118387f, 0.00263690f, -0.10900822f, -0.00291297f, 
    -0.10785793f, 0.09300523f, 0.04360550f, 0.00565272f, 0.09969520f, 0.10596239f, -0.10038017f, 0.09516611f, 
    -0.03504971f, 0.03796533f, 0.14639856f, -0.00130743f, -0.13249759f, 0.24029413f, 0.03094699f, -0.00687699f, 
    -0.03415994f, -0.03626406f, -0.09099768f, -0.00069860f, -0.14590494f, 0.20425569f, -0.18746120f, 0.10661787f, 
    0.05371855f, 0.08850453f, 0.14336555f, -0.09414350f, -0.05504181f, 0.03973471f, 0.03915755f, 0.28717384f, 
    -0.13070786f, -0.06723733f, 0.18311760f, -0.01158927f, 0.11363006f, 0.01774275f, -0.05799763f, -0.45912412f, 
    0.07176252f, 0.16439690f, 0.07466184f, 0.11877061f, -0.03573573f, -0.07122301f, 0.03697577f, -0.00519631f, 
    -0.03384990f, -0.07480507f, -0.09691670f, 0.09813534f, 0.04253461f, -0.03945361f, 0.02544637f, 0.09838667f, 
    -0.09823751f, -0.04357836f, 0.05791861f, -0.23368406f, 0.21495833f, 0.09228205f, -0.01959042f, 0.14463936f, 
    -0.01313954f, -0.01639912f, -0.09025321f, -0.30013376f, 0.03437985f, 0.01474439f, 0.01590821f, -0.07303532f, 
    0.11115105f, 0.04242158f, -0.03166578f, 0.03733948f, 0.05666960f, 0.07041913f, -0.02766665f, -0.08763210f, 
    -0.12406928f, 0.00610814f, 0.23084804f, -0.11455527f, -0.21876161f, 0.14360535f, 0.15088530f, -0.06597965f, 
    0.00770837f, -0.05947542f, -0.15086427f, -0.01806871f, -0.02279189f, 0.04649185f, -0.38623291f, -0.09551120f, 
    -0.16754410f, 0.05647425f, -0.12512046f, 0.08819741f, 0.03237067f, 0.02825367f, 0.04582676f, 0.06437805f, 
    0.02992620f, 0.07395223f, -0.00675883f, -0.08974930f, -0.07475667f, 0.03775024f, 0.06783455f, 0.00000819f, 
    -0.03802737f, -0.15653582f, 0.01207555f, -0.12359731f, -0.03768655f, 0.00327744f, -0.05675202f, 0.11977012f, 
    -0.05881978f, -0.01221160f, -0.04129514f, 0.07032325f, 0.06208686f, -0.00495102f, 0.08249552f, -0.03898214f, 
    0.02835895f, -0.08867672f, 0.03487225f, 0.00333717f, 0.13685715f, 0.09940618f, 0.08950221f, 0.02616125f, 
    -0.09370371f, -0.11804226f, -0.08323032f, -0.21886218f, 0.05589192f, -0.00829413f, -0.06739561f, -0.04621265f, 
    0.09061859f, 0.08595983f, 0.00974839f, -0.26464996f, 0.16206822f, -0.16822916f, 0.03287067f, 0.01359383f, 
    0.01797651f, 0.07082511f, 0.00529086f, 0.05064235f, -0.04255880f, -0.10564240f, 0.18085650f, -0.04270637f, 
    -0.06848569f, -0.10898134f, 0.00209300f, -0.11134602f, -0.03059869f, -0.19827591f, 0.17238423f, 0.06654543f, 
    0.00085594f, -0.02688767f, -0.00301815f, -0.11336112f, -0.08034802f, 0.08454990f, -0.37429294f, -0.47407010f, 
    -0.22025523f, 0.02632412f, 0.06685740f, -0.00424572f, -0.00177694f, -0.03016325f, 0.01385083f, 0.21713361f, 
    0.19867663f, -0.01747462f, 0.06038604f, -0.03591349f, -0.10820837f, -0.11912196f, 0.05648016f, 0.01713675f, 
    -0.42289039f, -0.05903684f, -0.00383772f, 0.08592458f, 0.03911610f, 0.00654988f, -0.00454992f, -0.18857943f, 
    0.02162162f, 0.09773157f, 0.11716356f, -0.02198573f, 0.03690236f, -0.01049668f, 0.08552679f, 0.00913293f, 
    0.04679074f, 0.01505134f, -0.12492210f, -0.09871461f, -0.14491533f, -0.07277633f, -0.00074311f, -0.08235095f, 
    -0.11766559f, 0.05673839f, -0.05456278f, -0.37895563f, -0.07878699f, -0.14595097f, 0.06992297f, 0.00712111f, 
    0.03454072f, 0.00973325f, -0.02235517f, -0.01533056f, -0.02338470f, -0.09279750f, -0.15396631f, 0.08114633f, 
    0.03024747f, 0.17728817f, -0.05820927f, -0.02133857f, 0.06233665f, -0.15367950f, -0.06336807f, -0.15074013f, 
    0.00333883f, -0.04272469f, -0.17428753f, -0.03643979f, 0.03456180f, -0.19859467f, 0.09956790f, 0.17927884f, 
    0.07340183f, -0.07099859f, -0.00368041f, -0.21117318f, 0.10074626f, 0.06002476f, -0.05799467f, -0.09320831f, 
    0.06113921f, 0.04447789f, 0.05412281f, -0.00279295f, 0.03262929f, -0.00429172f, -0.08524950f, -0.03352792f, 
    0.24949865f, 0.14595091f, 0.03502964f, 0.07658412f, 0.03496466f, 0.01671631f, 0.04934278f, 0.15223742f, 
    0.02985757f, -0.19718993f, -0.02333619f, -0.01542732f, -0.00489950f, -0.06031903f, 0.02080360f, -0.12560481f, 
    -0.09830785f, 0.02522827f, 0.16285229f, 0.10218964f, 0.09103692f, -0.12728979f, 0.01493275f, 0.04556666f, 
    -0.12843807f, 0.16244376f, -0.00333917f, -0.14824420f, -0.09709015f, -0.19824861f, 0.13179749f, 0.01443427f, 
    -0.02307516f, 0.05869740f, -0.05272763f, 0.05373183f, -0.07956218f, -0.21841599f, 0.07760293f, 0.10516764f, 
    -0.00899462f, 0.14540899f, 0.00630246f, 0.12889539f, 0.05988160f, -0.15303957f, 0.00522759f, -0.03019351f, 
    0.05503612f, -0.09735263f, 0.03824086f, 0.02210062f, -0.02458017f, -0.00180368f, -0.07582856f, -0.09987493f, 
    0.04905258f, 0.09296330f, 0.07256331f, -0.07560348f, -0.01641025f, 0.03202419f, 0.07112179f, 0.01357089f, 
    -0.00828742f, 0.06609918f, -0.06443484f, -0.11009463f, 0.08323599f, -0.03298567f, 0.03750458f, -0.02829448f, 
    0.06554603f, -0.06858300f, 0.16187534f, 0.08653236f, -0.02177061f, -0.08098347f, 0.02771887f, 0.01739252f, 
    -0.09246930f, 0.20806886f, -0.17895037f, 0.00541445f, -0.10076834f, -0.00801749f, 0.05912997f, 0.05232014f, 
    -0.14840956f, -0.05905877f, -0.01896571f, -0.08210275f, 0.09955729f, 0.00022643f, 0.02388224f, -0.04975653f, 
    0.00694942f, 0.03169605f, 0.00382626f, -0.10596998f, -0.11287103f, -0.03470075f, 0.02816523f, 0.04043596f, 
    -0.03489319f, -0.02949641f, 0.00050349f, 0.10456321f, -0.23673894f, -0.05750604f, 0.00352226f, -0.05163039f, 
    -0.00390188f, -0.05579372f, 0.03570904f, -0.00477987f, -0.12695383f, 0.18047807f, 0.17344688f, -0.26074249f, 
    -0.09168226f, -0.04332906f, 0.21908191f, 0.10949986f, 0.22502655f, 0.06185479f, -0.22839592f, -0.25320476f, 
    -0.02047512f, 0.05222323f, -0.13817734f, -0.03927487f, -0.11612761f, -0.00716192f, -0.05248550f, -0.34706804f, 
    -0.25659576f, 0.03315704f, 0.12837812f, 0.03528100f, 0.10252754f, -0.02589028f, 0.00264216f, 0.12010982f, 
    0.27647626f, -0.01834848f, -0.05066996f, 0.04869250f, -0.04636644f, 0.13574593f, 0.06216206f, 0.05530825f, 
    0.01808503f, -0.14578015f, -0.00368942f, 0.15976015f, 0.06977710f, 0.07957417f, 0.11455739f, -0.13645966f, 
    -0.00413802f, -0.04342286f, 0.14860493f, 0.29416010f, 0.16779117f, 0.18016756f, -0.06364988f, -0.16425167f, 
    -0.10646612f, 0.06656729f, 0.09448770f, 0.12087192f, -0.10372026f, -0.10240541f, 0.04284174f, -0.00244462f, 
    0.03755785f, -0.05423065f, -0.01080129f, 0.03623684f, -0.21253696f, -0.04078159f, 0.11524704f, -0.03954470f, 
    0.00466545f, -0.12293284f, 0.09053348f, -0.08945688f, 0.15677525f, -0.04518539f, 0.05979702f, -0.04907425f, 
    0.10499573f, -0.03243880f, 0.06580103f, -0.10475329f, 0.06310187f, 0.05787024f, -0.31335792f, 0.05497588f, 
    -0.05201250f, 0.05945165f, -0.02684252f, -0.03083702f, 0.10401129f, -0.04623962f, -0.00844351f, 0.19353056f, 
    0.26644608f, 0.01450280f, 0.12017758f, 0.05014918f, 0.00851257f, 0.02112729f, 0.08834136f, -0.03211121f, 
    -0.00887488f, -0.06139383f, -0.04671446f, -0.03992607f, 0.01077705f, 0.04070003f, 0.00287093f, -0.06035650f, 
    -0.00485682f, -0.00300148f, 0.00176636f, -0.04464354f, -0.00887189f, 0.03639715f, 0.02562088f, 0.00953692f, 
    -0.00751528f, -0.03553831f, -0.00242159f, -0.02703718f, -0.05105471f, 0.00746340f, 0.05075661f, -0.01874921f, 
    -0.05003701f, 0.04894527f, 0.03242592f, -0.00698257f, -0.05553697f, 0.01086105f, 0.01205795f, -0.04810224f, 
    -0.05558487f, -0.02939122f, -0.01307810f, 0.02345138f, 0.04010158f, -0.03849376f, -0.05516559f, -0.01873245f, 
    -0.05820316f, 0.01990491f, -0.06253709f, 0.01602112f, 0.01119094f, 0.04805634f, -0.02314895f, -0.02148268f, 
    0.03011263f, -0.04360973f, 0.01676414f, -0.06342366f, 0.01575091f, -0.01170535f, 0.01541865f, -0.04081590f, 
    -0.03724397f, -0.02139604f, -0.04589776f, 0.01656210f, -0.02466979f, -0.03718025f, 0.03856466f, 0.04195636f, 
    0.03938152f, 0.01558026f, -0.03139171f, -0.02406082f, 0.02645628f, 0.02799743f, -0.02011113f, -0.02882757f, 
    -0.01989165f, -0.05243207f, -0.05680320f, 0.04976000f, 0.01914750f, -0.00169632f, -0.00648814f, 0.00992383f, 
    -0.05971972f, -0.04311305f, -0.03676682f, 0.03480263f, 0.04291838f, -0.02900142f, 0.03253686f, -0.00466407f, 
    -0.02965689f, 0.04816742f, -0.01812707f, -0.02445021f, -0.04302548f, 0.03074571f, 0.03872108f, -0.04910006f, 
    -0.03676887f, -0.03361211f, -0.02528224f, 0.02873464f, -0.04029555f, -0.04397512f, -0.03336869f, -0.03071584f, 
    -0.04093594f, -0.02578323f, 0.03448612f, -0.00118516f, -0.03165343f, -0.01165928f, -0.00685273f, 0.02473659f, 
    0.02310468f, -0.01950627f, 0.03624793f, 0.02097055f, 0.01340272f, -0.05406449f, -0.04258284f, 0.02561723f, 
    0.01500175f, -0.02025761f, 0.01344237f, -0.01711254f, -0.01156334f, -0.03864941f, -0.04427625f, -0.03971907f, 
    -0.05655007f, 0.04938639f, -0.02266905f, -0.01435129f, 0.01119606f, -0.04023426f, -0.00727603f, -0.00340620f, 
    0.02605234f, 0.03105239f, 0.03809915f, 0.02566687f, -0.02901138f, -0.03118062f, 0.01873705f, 0.05133082f, 
    -0.01576448f, -0.00145880f, 0.03776549f, -0.04831583f, 0.02877624f, -0.04666823f, -0.06102705f, -0.02502894f, 
    0.00657471f, 0.02381352f, -0.02916719f, -0.01633012f, 0.03277459f, -0.03988890f, 0.01015732f, 0.02343028f, 
    0.02121931f, -0.04158303f, -0.01948869f, 0.02358802f, -0.01506676f, -0.01898268f, 0.01822033f, 0.02513681f, 
    0.00388479f, -0.04663372f, 0.02067282f, 0.05243409f, -0.03478136f, -0.04972110f, -0.03807515f, 0.01277151f, 
    0.00284154f, -0.06425255f, -0.04576846f, 0.03787433f, -0.00842302f, -0.01398346f, -0.03395074f, -0.05521435f, 
    -0.04592784f, -0.02448737f, 0.00875479f, 0.01476501f, 0.04454724f, 0.02175989f, 0.02067143f, 0.02585466f, 
    0.01402730f, -0.01512577f, -0.05473584f, -0.04279589f, -0.01589191f, -0.05447856f, 0.05040450f, 0.03092090f, 
    0.03890594f, -0.00121865f, 0.04188939f, -0.00059922f, -0.04401432f, 0.00739667f, 0.01038769f, 0.01483728f, 
    -0.04749865f, 0.02203410f, 0.01116524f, -0.04351996f, 0.00237948f, -0.02874436f, 0.00815894f, -0.04927929f, 
    -0.01332057f, -0.01158716f, -0.03298763f, 0.02694250f, -0.03015685f, -0.04024775f, 0.03989685f, -0.01141629f, 
    -0.04162716f, -0.05885920f, 0.00665335f, -0.04442468f, 0.04799066f, -0.03601557f, -0.03458669f, -0.02349637f, 
    -0.06067702f, -0.03700693f, 0.04401104f, 0.00965642f, 0.04307261f, 0.04512146f, -0.06100914f, 0.05025413f, 
    -0.03353256f, 0.04352730f, -0.04416896f, -0.01099110f, -0.02009839f, -0.00357920f, -0.03477292f, -0.05192679f, 
    -0.03109009f, 0.00800457f, 0.02063438f, 0.01191563f, -0.01067286f, -0.02765776f, -0.01610618f, -0.02601617f, 
    -0.04995456f, -0.01471046f, -0.02039641f, -0.05660606f, -0.05229401f, -0.01387363f, -0.06045768f, -0.00449449f, 
    -0.05835810f, -0.04988368f, -0.02162966f, -0.05125567f, -0.05134542f, 0.02987471f, -0.02924702f, -0.02551401f, 
    0.00291115f, 0.03304001f, -0.01260136f, -0.01989971f, 0.03528475f, -0.04523224f, 0.00615589f, -0.03541074f, 
    -0.01311144f, 0.02235759f, -0.02000079f, 0.01584352f, -0.03556546f, 0.02781967f, -0.01118530f, 0.00131439f, 
    -0.06402157f, 0.00479373f, 0.02918359f, 0.04443823f, -0.02607427f, -0.01771837f, -0.06331125f, -0.05663726f, 
    -0.05123500f, 0.03902952f, -0.02434107f, -0.02258256f, -0.05498056f, -0.04221977f, 0.00729018f, 0.04240144f, 
    0.00626282f, 0.02023884f, -0.03153223f, 0.03514931f, 0.00924771f, -0.01314008f, 0.04134952f, -0.01898711f, 
    0.02158352f, 0.04285350f, 0.00448599f, 0.03352794f, -0.01862942f, -0.07012350f, -0.00608423f, -0.04376883f, 
    0.03546777f, 0.03478560f, 0.00508851f, 0.00940941f, 0.01578535f, -0.04868369f, -0.03506899f, 0.04687824f, 
    0.02518729f, -0.06201459f, 0.01770989f, 0.02761642f, 0.00248521f, 0.04273406f, -0.01588367f, -0.04658823f, 
    -0.03885027f, -0.04235642f, -0.04733782f, 0.03444401f, 0.02716693f, -0.00885962f, 0.04408296f, -0.00415112f, 
    -0.04938375f, -0.00801860f, -0.05176625f, -0.05387332f, 0.01168572f, -0.05048802f, 0.01655187f, 0.02709111f, 
    0.02366977f, 0.04494872f, 0.00388733f, -0.06710565f, 0.00090276f, -0.04869439f, 0.01499800f, 0.01735250f, 
    0.03321552f, -0.05773377f, -0.02920734f, -0.00774864f, 0.04974411f, 0.01139093f, -0.01591837f, 0.04772887f, 
    -0.00307659f, 0.03574310f, -0.02200967f, -0.05532074f, -0.01366894f, 0.00297129f, -0.00813470f, -0.01728540f, 
    -0.00842801f, 0.01679941f, 0.00313180f, 0.03157679f, 0.05065705f, -0.04863513f, -0.01496457f, 0.04876494f, 
    0.00077785f, -0.06005938f, 0.02175764f, -0.03034303f, 0.02154810f, -0.01555305f, 0.00016188f, -0.00943525f, 
    -0.05820126f, -0.06078503f, -0.03646163f, -0.01104068f, 0.02956644f, 0.02710349f, -0.03843325f, 0.00176302f, 
    -0.01565136f, -0.00846423f, -0.00949550f, 0.02102209f, -0.05665740f, -0.05632889f, -0.04376061f, -0.02489693f, 
    0.01771911f, -0.02913252f, -0.03340692f, -0.04011651f, 0.01174581f, -0.05010448f, -0.03063628f, 0.05939740f, 
    -0.04072316f, -0.05346126f, -0.05053014f, -0.03881383f, -0.06512491f, -0.04490577f, -0.03434979f, 0.04736191f, 
    -0.03225159f, 0.02200537f, -0.05182624f, -0.05469561f, -0.02600681f, 0.02885975f, -0.03277096f, -0.05205454f, 
    -0.02596005f, 0.02788721f, -0.03694599f, 0.03880964f, 0.01884335f, -0.04263235f, 0.01260856f, 0.03365826f, 
    -0.02946756f, 0.01251576f, -0.05061149f, -0.04756545f, -0.02030973f, -0.05225372f, 0.02483495f, 0.00939785f, 
    -0.02446727f, 0.05782959f, -0.02609322f, 0.03176129f, -0.06347008f, 0.00579134f, -0.03479969f, -0.01146341f, 
    0.01204213f, 0.00817475f, 0.03086242f, -0.00327500f, -0.06116383f, 0.01714833f, -0.02009868f, -0.01272274f, 
    0.02251205f, 0.02416359f, 0.01550608f, 0.00615205f, -0.02973877f, -0.01691649f, -0.00311607f, -0.04905045f, 
    0.03403768f, -0.04538044f, -0.00726625f, 0.03396978f, -0.00041231f, 0.03890226f, 0.01355586f, 0.04746174f, 
    -0.05043190f, -0.00332875f, -0.04484644f, -0.02637567f, 0.02424000f, 0.03841709f, 0.00971557f, 0.03615940f, 
    0.00302636f, -0.00227811f, -0.00930993f, -0.04367355f, -0.03961621f, -0.03488580f, -0.03026702f, 0.04332467f, 
    0.04000447f, 0.04811953f, -0.00205391f, 0.02261786f, 0.00987701f, 0.03310547f, -0.03776165f, -0.01941861f, 
    0.04130436f, -0.00605446f, 0.05119451f, -0.05264287f, -0.00126297f, -0.03153725f, 0.01051701f, -0.06073263f, 
    -0.02876416f, 0.02310437f, 0.04075345f, -0.05724175f, -0.01149282f, -0.05400374f, 0.04863814f, 0.04735446f, 
    0.03376845f, 0.04551851f, 0.02596108f, -0.05721540f, -0.00584881f, -0.02881724f, -0.05195472f, -0.00493399f, 
    -0.00852614f, -0.01351262f, 0.03781170f, -0.00324072f, -0.03334726f, 0.01702982f, -0.04007344f, 0.02438434f, 
    0.04024013f, -0.06988052f, -0.01085291f, -0.02675876f, 0.05145022f, -0.05975117f, 0.03156976f, -0.01324701f, 
    0.02993325f, 0.02997184f, 0.03547061f, 0.02854867f, -0.06520276f, 0.00330951f, -0.05275684f, -0.05304597f, 
    -0.06317350f, -0.01995572f, 0.02679800f, -0.04917701f, -0.04236479f, 0.03053429f, 0.02008244f, -0.00253260f, 
    0.02886429f, -0.06597548f, -0.05777562f, -0.03455450f, -0.02665345f, -0.03524419f, -0.05793507f, 0.05024863f, 
    -0.06555136f, -0.02410012f, 0.01184226f, 0.04007768f, -0.00295597f, -0.01854840f, 0.03964289f, 0.00156820f, 
    -0.02597275f, -0.02270157f, -0.00547565f, 0.00936725f, -0.12100714f, 0.04570551f, -0.14334466f, -0.04797595f, 
    0.01310426f, -0.14595604f, -0.05929714f, -0.05810493f, 0.17520809f, -0.00039461f, -0.05181693f, 0.04065489f, 
    0.01591062f, -0.06829249f, -0.04906018f, 0.15063013f, -0.02487745f, -0.09285849f, 0.06385325f, -0.19886719f, 
    0.07662454f, -0.09305166f, -0.07031950f, -0.01736500f, 0.08171770f, 0.07495710f, -0.02437364f, 0.12642241f, 
    -0.05418386f, 0.02253436f, 0.00742360f, 0.08456119f, -0.10943388f, 0.05819716f, 0.06338417f, -0.12549995f, 
    -0.01581822f, 0.19296509f, 0.07512137f, 0.08896817f, 0.07615454f, -0.09870835f, -0.31606078f, -0.02808686f, 
    0.05596338f, 0.07410535f, -0.10000312f, 0.03272578f, 0.02177900f, -0.08367744f, 0.04614792f, 0.06654397f, 
    -0.05774805f, 0.04369582f, 0.06181601f, -0.00384375f, 0.05747655f, 0.02918409f, 0.04233099f, -0.09764817f, 
    -0.13540217f, 0.09949706f, 0.07970120f, 0.00801126f, -0.02410119f, -0.03183760f, -0.02215598f, 0.17123199f, 
    0.07564456f, -0.13668281f, 0.01350685f, 0.20502792f, 0.05854385f, 0.04688700f, 0.02717738f, -0.01150948f, 
    -0.04742105f, 0.02963279f, 0.14076623f, -0.04513855f, 0.01765211f, 0.01848910f, -0.01444626f, 0.15985060f, 
    0.08132885f, 0.15523368f, -0.12761511f, -0.12636764f, -0.03252517f, 0.20093758f, 0.17069633f, 0.13085926f, 
    0.04299912f, 0.02671997f, -0.06270706f, -0.03063122f, -0.11934649f, 0.00860689f, 0.11502923f, 0.01111518f, 
    -0.00255680f, 0.03232309f, 0.08183122f, -0.08843476f, 0.07264847f, 0.06736253f, -0.11305138f, -0.03552334f, 
    -0.06896940f, 0.08900302f, 0.12492969f, -0.11587522f, 0.13947417f, -0.29262424f, -0.12513235f, 0.03000740f, 
    0.13466229f, -0.11982601f, 0.01802744f, -0.07897750f, -0.26585108f, 0.06262419f, -0.08078437f, -0.21766725f, 
    -0.20651886f, -0.23308468f, -0.10489014f, 0.06061866f, -0.05703165f, 0.02511108f, -0.01322975f, 0.06837012f, 
    -0.04830886f, -0.02646276f, 0.18170044f, 0.03281518f, -0.01070427f, -0.05336654f, 0.02798412f, 0.07029887f, 
    -0.13369560f, 0.04291561f, 0.13556534f, -0.04195273f, 0.03149112f, -0.00998114f, -0.01053243f, -0.00819813f, 
    -0.17387731f, -0.26848152f, -0.07983617f, 0.07657535f, 0.10695895f, 0.02498098f, -0.15372153f, 0.03445755f, 
    0.03425724f, -0.13994597f, 0.25241366f, -0.20434619f, -0.05791225f, 0.04251058f, -0.11023588f, -0.11583703f, 
    -0.06379452f, 0.01309922f, 0.10218930f, 0.17844747f, 0.06498659f, -0.07193723f, -0.07069173f, -0.18614915f, 
    -0.08952712f, 0.13516895f, 0.08683900f, 0.05313385f, -0.10049966f, 0.03855299f, -0.09444333f, -0.07845713f, 
    0.06360216f, -0.08889397f, -0.05996942f, -0.02517582f, 0.01432530f, -0.24032414f, -0.28073362f, -0.10133309f, 
    0.07279859f, 0.10674589f, -0.04724900f, 0.08902226f, -0.05486611f, -0.10414194f, -0.05070143f, 0.02079699f, 
    0.02915400f, -0.03733197f, -0.00239745f, -0.05668677f, -0.00043401f, -0.02845907f, -0.11948761f, -0.11096601f, 
    -0.06379937f, 0.02492899f, 0.10916390f, -0.00117986f, 0.13179287f, -0.01751074f, 0.02057764f, 0.04656779f, 
    -0.27725279f, 0.01090038f, -0.05436312f, -0.05632496f, 0.06181233f, 0.14069980f, -0.00697651f, 0.12063780f, 
    -0.14476770f, -0.05054121f, 0.13576989f, -0.04104844f, 0.08668808f, 0.09594465f, 0.12629469f, 0.02851730f, 
    0.01427707f, -0.07009181f, -0.05857679f, 0.15161140f, 0.09351414f, 0.21816356f, -0.13936067f, 0.00973022f, 
    -0.12160436f, 0.03729257f, -0.07580699f, 0.00746674f, -0.12372489f, -0.27993041f, 0.00434468f, 0.04524771f, 
    0.13114844f, 0.07386669f, 0.02442991f, -0.01968295f, -0.03395047f, 0.15691239f, -0.09545632f, -0.08091990f, 
    -0.06459355f, -0.00473169f, -0.09215215f, 0.08545356f, 0.17490585f, -0.02318439f, 0.11365310f, 0.09609972f, 
    0.00857674f, -0.01830692f, 0.08945569f, -0.08396015f, 0.06595995f, 0.15310353f, -0.19217546f, 0.11521592f, 
    0.13212338f, 0.02733386f, -0.20813546f, -0.03943854f, 0.10862387f, -0.08075927f, 0.02070503f, -0.04545842f, 
    0.00206216f, 0.10512774f, 0.07915992f, 0.04498711f, 0.13586950f, -0.05283657f, 0.02019268f, 0.06506707f, 
    0.00189686f, -0.04808776f, 0.02281373f, -0.11905265f, 0.13926291f, -0.04489874f, 0.11220714f, 0.08879558f, 
    -0.05277510f, 0.19946276f, -0.04167554f, 0.06838439f, -0.06007189f, 0.04770743f, -0.00569204f, 0.01125606f, 
    -0.03751340f, 0.05991136f, -0.16810717f, 0.04009818f, -0.11190247f, 0.04056805f, -0.09259246f, 0.02381978f, 
    0.02671270f, -0.02422259f, 0.06208504f, -0.24408144f, -0.02090712f, -0.02110019f, 0.05822597f, 0.02096801f, 
    0.06060791f, 0.06305648f, -0.03482507f, -0.07358444f, -0.05740985f, -0.04432169f, -0.03498877f, 0.02190498f, 
    0.10687152f, -0.00526170f, -0.08915099f, 0.10237256f, 0.03488959f, 0.34327206f, 0.08478858f, -0.04679768f, 
    0.07585401f, -0.05817762f, -0.03478306f, 0.11219171f, 0.06978580f, -0.05744285f, 0.06098840f, -0.18968439f, 
    0.11584079f, -0.10020663f, 0.12929851f, 0.02984881f, 0.06910329f, 0.11090173f, 0.04837238f, -0.00903041f, 
    0.04338818f, 0.11865038f, 0.01692985f, -0.15187974f, 0.00521086f, -0.03122632f, 0.03956676f, -0.00145851f, 
    0.06955446f, -0.13351451f, 0.06170428f, 0.08559387f, 0.01527863f, 0.05618290f, 0.06313119f, -0.08185605f, 
    0.05528940f, -0.09284598f, -0.01557480f, 0.00142285f, 0.04073608f, -0.12268434f, -0.01560036f, -0.00892287f, 
    -0.06370184f, 0.09156157f, 0.04305456f, -0.08460826f, 0.23536971f, 0.04357396f, 0.05826559f, 0.04002215f, 
    -0.00157250f, 0.00130107f, -0.13435656f, 0.16858330f, 0.14000884f, -0.20537896f, 0.06585249f, -0.05814052f, 
    -0.03377942f, 0.06038395f, -0.02600373f, -0.03226712f, 0.16094689f, 0.05135608f, -0.01850409f, 0.07889307f, 
    0.12297497f, -0.11306512f, -0.04939444f, -0.01212852f, 0.07805160f, 0.04997549f, -0.14445180f, 0.22219263f, 
    0.05347024f, -0.08832350f, -0.14442477f, -0.04698802f, 0.11431486f, -0.09658354f, 0.00780940f, -0.12307795f, 
    0.06434944f, 0.12056281f, -0.06651520f, 0.12059063f, -0.13070224f, 0.01743889f, 0.01446729f, 0.33218589f, 
    -0.00173650f, 0.01107586f, -0.09727815f, -0.02449663f, -0.11624366f, -0.09151411f, -0.14987600f, 0.11676580f, 
    0.12164435f, 0.07312604f, 0.31706953f, 0.16615079f, -0.06102303f, 0.02654628f, 0.05619491f, -0.08001053f, 
    0.00779533f, 0.23315437f, -0.04628536f, -0.02483832f, -0.09554897f, -0.00515488f, 0.07673487f, -0.14393623f, 
    -0.04365085f, 0.03318693f, -0.11922859f, 0.11309022f, -0.12273070f, -0.03111343f, 0.02996488f, -0.20335658f, 
    0.01983232f, 0.11050833f, -0.07026281f, 0.14668398f, -0.09134261f, -0.19870177f, 0.05039330f, -0.04993024f, 
    -0.02636907f, 0.03844116f, 0.10678787f, -0.09611783f, -0.19484735f, 0.20268656f, -0.27916712f, 0.10943550f, 
    -0.02937123f, -0.10634717f, -0.08274774f, -0.03718660f, 0.05860389f, -0.03544588f, 0.34580588f, -0.02255666f, 
    0.05270096f, -0.07140354f, -0.04214646f, 0.06918987f, 0.05614439f, -0.00191900f, -0.36807594f, -0.02954780f, 
    -0.07399639f, 0.00845668f, 0.07753886f, -0.12311336f, 0.00071850f, 0.08499695f, 0.06267682f, -0.06071201f, 
    0.05666886f, 0.06471562f, 0.02786796f, 0.04684999f, -0.18844925f, -0.06614874f, 0.02420739f, -0.00517656f, 
    0.12064701f, -0.08308122f, 0.06229249f, -0.11713665f, 0.03566307f, 0.09594583f, -0.03379941f, 0.18230426f, 
    -0.02633353f, 0.09834952f, -0.08185815f, 0.18649340f, 0.07771958f, 0.08286544f, -0.01630551f, 0.07576784f, 
    -0.11824977f, -0.06398944f, 0.12189972f, -0.08953524f, 0.14152794f, -0.08521986f, 0.06720584f, 0.09799367f, 
    -0.05251757f, -0.14769839f, -0.06512117f, 0.05477306f, -0.15794827f, -0.06013886f, -0.02415121f, -0.00694661f, 
    -0.08469760f, -0.01521723f, 0.11139959f, 0.07432678f, -0.01355979f, 0.05567683f, -0.23591435f, 0.03416589f, 
    -0.00362650f, -0.03299172f, -0.03067241f, 0.09428340f, -0.02682273f, -0.04029961f, -0.16033702f, -0.11348581f, 
    0.04130754f, 0.04891000f, -0.12110043f, -0.03688684f, -0.01715511f, -0.09912658f, 0.07246286f, 0.04355212f, 
    0.02782276f, 0.00995861f, -0.11669137f, 0.02995775f, -0.03074037f, 0.03133450f, 0.02873948f, 0.00759445f, 
    -0.10471433f, 0.00207403f, 0.04748563f, 0.05586820f, 0.01190114f, -0.02223946f, -0.00348781f, 0.03808821f, 
    0.02705474f, -0.01246021f, 0.02789507f, 0.03679904f, -0.03826227f, 0.00619311f, -0.06522200f, 0.01436130f, 
    -0.05930851f, -0.02026482f, 0.02597679f, -0.03503197f, -0.04360324f, 0.05251606f, -0.06004247f, -0.00711969f, 
    -0.01318400f, -0.05545006f, -0.04063327f, 0.03391841f, -0.01045093f, -0.06103529f, -0.01790653f, -0.05031081f, 
    0.03718290f, -0.05982219f, 0.00325602f, -0.02330261f, -0.00509842f, -0.05394222f, 0.03253472f, 0.00936797f, 
    -0.00144640f, 0.03990102f, 0.00759407f, 0.03607222f, -0.03090412f, -0.03470641f, 0.00552225f, -0.04489673f, 
    0.01562172f, 0.04122476f, 0.03645978f, 0.02253716f, -0.01365901f, -0.03585221f, 0.00048267f, -0.05458915f, 
    0.03409265f, -0.05681536f, 0.01395802f, -0.01404078f, -0.02791538f, 0.02196618f, -0.07087643f, -0.00086318f, 
    0.00923435f, 0.04423375f, 0.01650506f, 0.04611217f, 0.02249080f, -0.05518883f, 0.01772084f, 0.02094045f, 
    -0.02220613f, -0.04017777f, 0.00141264f, -0.05905581f, 0.00631286f, -0.00604618f, -0.04913604f, -0.04133641f, 
    -0.00763134f, -0.04763513f, -0.04792051f, 0.00527386f, 0.03503856f, 0.00712785f, 0.02657230f, -0.02276590f, 
    -0.02246957f, -0.02222181f, -0.03393756f, 0.03156805f, -0.04832183f, -0.03576824f, -0.00242814f, -0.01710245f, 
    0.04416360f, 0.01051268f, -0.00235667f, 0.04345061f, -0.05631366f, 0.02329845f, 0.02948778f, -0.05609519f, 
    -0.04435550f, 0.02964399f, 0.00259764f, 0.00058070f, 0.03898000f, -0.03310400f, -0.01836524f, 0.01938087f, 
    0.03738991f, -0.06589849f, -0.00801534f, -0.00611013f, -0.00314179f, 0.03318175f, 0.04488692f, 0.01711926f, 
    -0.05042092f, -0.00186816f, 0.03878403f, 0.03706544f, -0.01839534f, 0.03125469f, 0.04527693f, 0.00631642f, 
    -0.06198535f, -0.06422342f, 0.01530171f, -0.06078725f, 0.00318335f, -0.00577596f, 0.04766236f, 0.01786364f, 
    0.03224381f, -0.02651661f, -0.00713683f, 0.01455220f, 0.04392771f, 0.00992893f, -0.02083919f, -0.01265903f, 
    0.01824482f, -0.05092631f, 0.00324555f, -0.05087747f, -0.00995588f, 0.04759868f, 0.03200976f, -0.05421343f, 
    -0.05403813f, 0.02838337f, -0.04057926f, 0.01178268f, -0.00730971f, -0.04497989f, -0.01459887f, 0.02228529f, 
    0.04857116f, -0.01081601f, -0.06826977f, -0.05540871f, -0.02405278f, 0.05194362f, -0.01712468f, -0.06337343f, 
    -0.00854672f, -0.05705464f, -0.05434963f, -0.04294729f, 0.01224710f, 0.03642715f, -0.03910659f, 0.01583357f, 
    0.03370912f, 0.02972768f, -0.03773979f, -0.02193938f, 0.04317044f, -0.02937276f, 0.02392368f, 0.02773823f, 
    -0.01411951f, 0.00022063f, 0.01060035f, -0.02060094f, 0.03683690f, 0.02404205f, -0.04279523f, 0.01625090f, 
    -0.04273115f, 0.04667809f, -0.05417279f, -0.04908516f, 0.02147989f, 0.01910024f, 0.03552663f, 0.03692723f, 
    0.04112448f, -0.05482490f, -0.02871130f, -0.02871008f, 0.02288722f, -0.02512304f, 0.01278450f, -0.05409908f, 
    -0.06534753f, 0.04427316f, -0.03116765f, 0.02550293f, -0.06076338f, 0.01269238f, -0.01085795f, 0.01197852f, 
    0.02612456f, -0.03681953f, -0.02549253f, 0.05536687f, -0.05808258f, 0.00841197f, -0.00583345f, -0.03924173f, 
    -0.04663828f, 0.00723496f, -0.03794105f, 0.00308388f, -0.05860914f, -0.01255463f, 0.00855304f, -0.04094255f, 
    -0.05236021f, -0.04144476f, -0.03532366f, -0.01042577f, 0.00969736f, -0.01082994f, -0.02208876f, -0.03750605f, 
    -0.05397483f, -0.02206178f, -0.05988873f, -0.02784427f, -0.05777787f, 0.03603355f, -0.05062599f, 0.01749761f, 
    0.05165382f, -0.02453141f, 0.02947747f, -0.05483017f, 0.03622511f, 0.04340423f, -0.00972982f, -0.04745875f, 
    -0.05470866f, -0.04050098f, -0.01217763f, -0.00308212f, 0.03085172f, -0.04518353f, -0.05519355f, 0.04288894f, 
    0.03305955f, -0.04980457f, -0.04447716f, -0.01640004f, -0.04204457f, -0.02423503f, -0.05719784f, 0.04199908f, 
    0.04292670f, 0.04735108f, -0.04836845f, 0.04880248f, 0.01513843f, 0.02373438f, 0.03442483f, 0.00316813f, 
    -0.04276443f, 0.04435603f, 0.04836946f, 0.04876314f, 0.05200895f, -0.01373797f, -0.04104466f, -0.05664121f, 
    -0.06537789f, 0.00550988f, -0.04435441f, -0.00298909f, -0.00198057f, 0.03086672f, 0.01156903f, -0.02543934f, 
    0.02905100f, 0.04897490f, 0.04012718f, -0.05549784f, -0.04179118f, -0.04217036f, -0.03487050f, -0.04892275f, 
    -0.01186046f, 0.02595825f, -0.05048021f, 0.00714101f, -0.00583297f, 0.00853357f, -0.05043737f, 0.01892437f, 
    -0.04886139f, -0.01656756f, 0.02463320f, -0.04456664f, -0.00337802f, -0.06440571f, -0.03066819f, 0.03194475f, 
    -0.04563612f, -0.02970374f, -0.02050877f, -0.05392599f, -0.02880753f, -0.00717430f, 0.01587985f, 0.00365440f, 
    -0.06676371f, -0.03160745f, 0.00814475f, -0.05369851f, -0.01808284f, -0.05272482f, -0.04066182f, 0.00645974f, 
    -0.03471218f, -0.04352168f, 0.02315610f, -0.05228638f, -0.00579492f, 0.00200705f, 0.02474083f, -0.02222882f, 
    0.00018004f, 0.01089088f, -0.02645445f, -0.06254973f, 0.04061250f, -0.06009128f, -0.02066296f, -0.00639069f, 
    0.04620879f, 0.00650539f, 0.04925849f, 0.01321521f, -0.00374038f, -0.02092608f, -0.00333149f, -0.01386923f, 
    -0.02785857f, 0.04020593f, 0.01518652f, -0.04006866f, 0.04310671f, 0.04365634f, -0.00924676f, -0.06313632f, 
    -0.05654225f, -0.00761352f, -0.06606700f, -0.04493720f, -0.04518297f, 0.02038949f, 0.01258254f, -0.00856828f, 
    -0.04010309f, 0.01822424f, 0.02428508f, -0.04913311f, -0.02905150f, 0.03403417f, -0.00993303f, 0.01844410f, 
    -0.03635719f, -0.01749409f, -0.02422422f, -0.02373534f, -0.03992669f, 0.04319334f, -0.01628364f, 0.02779313f, 
    0.02347982f, -0.06409479f, -0.01513913f, -0.03715689f, 0.00286883f, 0.00045456f, -0.00447694f, -0.00438519f, 
    0.01264156f, -0.05973402f, -0.00752413f, 0.01654734f, -0.02215607f, -0.02338258f, -0.03786864f, -0.04163433f, 
    0.05058211f, 0.02440501f, -0.01069352f, 0.01937849f, -0.00362010f, 0.00507212f, 0.03859217f, 0.00861905f, 
    0.00774253f, -0.01025569f, 0.04280489f, 0.02885943f, 0.04856943f, -0.02991381f, 0.04945179f, 0.03432298f, 
    -0.00240606f, -0.04837243f, -0.03685812f, 0.01643215f, -0.00375592f, 0.01647596f, -0.05991581f, 0.03202057f, 
    -0.00854017f, -0.00028994f, -0.02339809f, -0.02635177f, -0.00696027f, 0.03176647f, 0.01230430f, -0.02999332f, 
    0.01568543f, 0.01161269f, -0.05665594f, -0.02103360f, 0.01719027f, -0.01044564f, 0.01333859f, 0.00901175f, 
    -0.01073388f, 0.02628291f, -0.03774174f, 0.00839831f, -0.02279140f, -0.02419023f, -0.02635626f, 0.05292155f, 
    0.05095952f, 0.01577605f, 0.04473677f, 0.01010793f, -0.04879008f, -0.00084865f, 0.01225900f, -0.05825056f, 
    0.00477099f, -0.03466608f, -0.03966770f, 0.00381569f, -0.02713358f, 0.02093014f, 0.03352007f, 0.04446676f, 
    -0.04608994f, 0.03597454f, -0.05527817f, -0.00908147f, 0.02169301f, 0.01491280f, -0.00955150f, -0.03058199f, 
    -0.03211391f, -0.05596744f, -0.05185587f, -0.06440607f, 0.03786072f, 0.00272115f, -0.00475081f, 0.01586340f, 
    -0.05000621f, -0.04866194f, -0.06501561f, 0.03316253f, 0.03850248f, 0.04969872f, -0.06412638f, -0.02100690f, 
    -0.03327395f, 0.04284658f, 0.02871282f, 0.01226365f, 0.00568490f, 0.04570075f, -0.04090863f, 0.04092976f, 
    0.03734626f, 0.04666791f, -0.02538667f, 0.02997716f, -0.00171084f, 0.03411257f, -0.04239709f, -0.05096284f, 
    -0.00563526f, -0.01443474f, 0.01581355f, -0.01392514f, -0.01903487f, 0.03540019f, -0.02382715f, -0.02132575f, 
    0.00944392f, -0.02319102f, 0.00487299f, 0.04927276f, -0.02577252f, -0.04241636f, 0.01786028f, 0.02845002f, 
    0.00353345f, -0.01607518f, 0.03463911f, -0.00908438f, 0.03864148f, 0.00496948f, -0.00022312f, -0.02530253f, 
    0.02254574f, -0.03644852f, 0.01430475f, 0.00223398f, 0.01944631f, 0.00109714f, 0.03031391f, 0.00078277f, 
    0.00467073f, -0.01275345f, -0.02124985f, -0.04500808f, -0.00400302f, 0.01842530f, -0.00075038f, 0.03016674f, 
    -0.00381294f, 0.03974648f, -0.02877547f, -0.05085875f, -0.05678915f, -0.06891700f, -0.05413639f, -0.05141426f, 
    0.01371425f, 0.03676340f, -0.06651169f, -0.04475243f, 0.02742477f, -0.01443837f, -0.00932623f, -0.04769281f, 
    -0.02178173f, 0.04142673f, 0.00882621f, 0.03518090f, -0.02579021f, 0.00280421f, -0.00764882f, -0.05453413f, 
    0.00318417f, -0.04986893f, -0.01307336f, 0.03538807f, -0.02614661f, -0.03086636f, -0.03036262f, -0.00775934f, 
    -0.08228473f, -0.61610121f, 0.09437166f, 0.13333176f, -0.10418863f, 0.01693686f, -0.10318215f, -0.09468044f, 
    -0.05826572f, 0.07524969f, 0.39676976f, -0.09944411f, 0.02175336f, 0.05798184f, -0.08546686f, 0.10878398f, 
    -0.00922378f, 0.17458323f, -0.08072485f, -0.24643794f, 0.09599174f, 0.01271632f, -0.12280107f, 0.05715394f, 
    -0.26483172f, 0.02282526f, 0.01013753f, 0.05002926f, -0.26009282f, 0.14287855f, 0.13697593f, 0.12048727f, 
    0.01252500f, 0.09338573f, -0.06242955f, -0.08969708f, 0.19265035f, -0.02716983f, -0.04018980f, -0.02281239f, 
    -0.00519185f, 0.09648865f, 0.21342033f, -0.01640135f, -0.13470820f, -0.05662479f, 0.03448354f, 0.13347942f, 
    0.04622202f, 0.02623728f, -0.00995599f, 0.07570510f, -0.08406062f, 0.01055012f, -0.08460976f, 0.35352370f, 
    -0.04815550f, -0.01137328f, 0.09616926f, -0.25132215f, -0.05445435f, 0.11758632f, 0.07941949f, -0.00285792f, 
    0.06764984f, 0.09278420f, -0.02037283f, 0.04158491f, -0.08041632f, 0.10907049f, 0.10086190f, 0.09857024f, 
    -0.09071278f, 0.13930778f, 0.14711036f, -0.20053478f, -0.12474649f, 0.01769306f, -0.07466967f, 0.01248726f, 
    0.04986220f, 0.02224850f, -0.24894449f, 0.07997361f, 0.03115503f, 0.13935593f, 0.03243088f, 0.02251838f, 
    0.10720059f, 0.01159588f, -0.20102112f, 0.13393189f, -0.19006266f, -0.03304631f, -0.19351588f, -0.17799558f, 
    0.02171801f, 0.05903110f, -0.10951935f, -0.15046480f, 0.08639058f, 0.00770959f, -0.00887232f, 0.01960009f, 
    -0.02500705f, 0.05461960f, 0.02627501f, 0.02344149f, -0.09180786f, -0.04537075f, 0.05624209f, -0.02879333f, 
    -0.12803057f, 0.00227970f, 0.15389319f, 0.03917450f, 0.04885773f, 0.15694185f, -0.14680603f, -0.15968873f, 
    -0.17756493f, -0.09146536f, -0.07419575f, 0.20894368f, 0.09502792f, 0.00386861f, -0.04049000f, -0.00104305f, 
    0.02054041f, -0.07698087f, 0.02226789f, -0.01812669f, 0.04383614f, 0.05783256f, 0.10925750f, 0.12635861f, 
    0.28069901f, -0.02693587f, -0.05551908f, -0.20229162f, 0.14411262f, 0.02222724f, -0.04060379f, 0.06215847f, 
    -0.07902384f, 0.27796432f, -0.07101775f, -0.19677429f, 0.05130366f, -0.00514999f, 0.02180581f, -0.09993889f, 
    0.03078771f, -0.04688134f, -0.32764119f, -0.34708813f, -0.15067725f, -0.09495009f, -0.10331149f, -0.07746299f, 
    -0.29859543f, 0.05362190f, 0.13696247f, 0.15347981f, 0.17063703f, -0.11756802f, -0.00459040f, -0.08325236f, 
    -0.14104530f, 0.08424300f, -0.05718998f, 0.07925601f, 0.10119361f, -0.10996325f, -0.08571153f, 0.00340517f, 
    -0.05006045f, -0.04082885f, 0.05682402f, 0.04748608f, -0.04517082f, -0.27088091f, 0.11726353f, 0.05803791f, 
    -0.03956446f, -0.06923088f, -0.10098101f, 0.05766397f, -0.08596779f, -0.27364352f, -0.22905843f, 0.07784328f, 
    -0.17032318f, -0.12787804f, -0.04426731f, -0.07195619f, -0.01647957f, -0.04006147f, 0.25074592f, -0.34182039f, 
    -0.10396523f, 0.12189962f, 0.00779790f, -0.00718584f, -0.10611976f, -0.13249326f, -0.06218050f, -0.27237064f, 
    -0.25687504f, -0.11160248f, 0.06509829f, 0.03904460f, 0.10755605f, 0.07205948f, -0.12373362f, -0.17239390f, 
    0.13053180f, -0.17556991f, -0.14290971f, 0.13517609f, 0.00983408f, 0.14203736f, -0.07113136f, 0.10295761f, 
    -0.23894057f, -0.11873780f, -0.01338820f, -0.01487314f, 0.10295239f, 0.08969898f, 0.12448483f, 0.01794481f, 
    0.04828857f, -0.02048481f, 0.10363529f, 0.12383937f, 0.05437961f, -0.14300385f, 0.00653786f, 0.02928565f, 
    -0.07159642f, 0.04473133f, -0.08237999f, 0.20495163f, 0.15444903f, -0.03335565f, 0.16954209f, 0.00112108f, 
    0.00156204f, -0.03611729f, -0.05260311f, 0.12219027f, 0.06779847f, 0.01421937f, -0.02286514f, -0.04730260f, 
    -0.00249261f, 0.04581730f, -0.05557248f, 0.12537067f, 0.13283540f, 0.12474181f, -0.20376770f, 0.08608063f, 
    0.11398038f, 0.09567811f, -0.02174249f, 0.13245727f, -0.15496570f, 0.06087544f, 0.17759790f, 0.25335279f, 
    0.11652826f, -0.01727931f, -0.04302622f, 0.08029848f, 0.06694195f, 0.02044972f, -0.00242192f, -0.05713149f, 
    0.20664774f, 0.20397806f, -0.04646014f, -0.03465743f, 0.13989973f, 0.06346364f, 0.01690760f, 0.03232248f, 
    -0.00973821f, 0.07954881f, 0.07091848f, -0.22541934f, -0.07080198f, -0.08476715f, -0.03189020f, -0.11962309f, 
    0.02720409f, -0.16619636f, -0.07716086f, 0.03030767f, 0.01131206f, 0.04319372f, -0.01303873f, -0.00767823f, 
    -0.04328661f, 0.09798418f, -0.15694475f, 0.13487890f, 0.04603857f, -0.17683969f, 0.12559606f, 0.05555465f, 
    0.08622812f, -0.06821759f, -0.03971424f, 0.13721743f, 0.13060644f, 0.19424093f, -0.01898049f, -0.05868557f, 
    0.00721560f, -0.00200767f, 0.01719300f, -0.05595356f, 0.06572422f, 0.04955043f, 0.00134042f, 0.03246751f, 
    0.01740643f, 0.04227699f, -0.02248125f, -0.01201652f, -0.01106380f, -0.02063544f, 0.07597741f, -0.11240866f, 
    0.09853944f, -0.05821774f, -0.09503176f, -0.03118197f, 0.00521305f, -0.02611675f, -0.26468500f, -0.11641393f, 
    -0.13003704f, 0.02680033f, 0.03090505f, 0.01639961f, 0.09622743f, 0.11152960f, -0.10458585f, -0.01330116f, 
    -0.15165009f, -0.01941655f, 0.02753729f, 0.01593601f, 0.07987057f, -0.04718860f, -0.04504451f, -0.13268906f, 
    0.24629554f, 0.00907667f, -0.06720896f, 0.17849198f, 0.04553632f, 0.12318506f, -0.06207770f, -0.09278750f, 
    0.01210241f, 0.02459877f, 0.03776058f, -0.02401419f, -0.04073581f, -0.11122682f, 0.01992681f, 0.00038703f, 
    0.00458607f, -0.05536496f, -0.14161102f, -0.00292305f, 0.00772774f, 0.00191114f, 0.02870352f, -0.02833881f, 
    0.08216976f, -0.06696919f, 0.00671274f, 0.08887041f, 0.11045902f, 0.36037254f, -0.10356496f, -0.02745875f, 
    0.00323951f, 0.07780287f, -0.01048653f, -0.11119379f, -0.04018880f, 0.11344034f, 0.03224550f, 0.01173677f, 
    0.02539012f, 0.13894781f, -0.12354156f, 0.08860845f, 0.15946651f, -0.17427695f, -0.11081865f, -0.13932882f, 
    -0.02575767f, 0.14693545f, -0.06601200f, -0.08272561f, -0.14926584f, 0.05591746f, -0.20367615f, -0.06210489f, 
    -0.18787025f, 0.01290015f, 0.04767182f, -0.02611195f, -0.22180846f, 0.02241505f, -0.21362847f, -0.09481911f, 
    -0.11399142f, 0.13793549f, -0.09095585f, 0.14521368f, 0.04540598f, -0.09110090f, 0.01988183f, -0.02879372f, 
    -0.18821315f, 0.11213005f, -0.19287771f, 0.00112076f, -0.04070881f, 0.04858646f, -0.09203276f, -0.07451829f, 
    -0.10653080f, 0.00480193f, -0.09181682f, -0.15978974f, -0.07497989f, -0.14049092f, -0.01603859f, 0.11881776f, 
    0.08941718f, 0.01890562f, 0.41299650f, -0.32458130f, -0.08037888f, -0.01985182f, 0.14891112f, 0.04464774f, 
    -0.07450646f, -0.00397622f, -0.24483353f, 0.15154326f, 0.08528794f, 0.16693908f, -0.15378876f, 0.00691127f, 
    0.04096224f, 0.12741496f, 0.02986735f, -0.01363586f, -0.23530243f, 0.05322564f, -0.07393681f, 0.14895093f, 
    0.04341212f, 0.03819326f, -0.11332354f, -0.06867532f, -0.03250593f, 0.09522714f, -0.07193088f, -0.01269549f, 
    0.20725985f, -0.04509910f, 0.11520053f, -0.08010315f, 0.04172082f, 0.02510823f, 0.17945814f, 0.09403130f, 
    0.07724191f, -0.18553644f, -0.02585974f, -0.00465993f, -0.07066847f, -0.11005446f, -0.00304798f, 0.14723229f, 
    -0.01965518f, 0.06613766f, -0.13374746f, -0.11238013f, 0.02136450f, -0.13729788f, -0.12619619f, 0.06523956f, 
    0.04001702f, -0.16546418f, -0.00527876f, -0.04902432f, 0.01169048f, -0.14272586f, 0.21336687f, 0.04987102f, 
    0.05128526f, 0.04616459f, -0.13275927f, -0.05588317f, -0.04445916f, -0.03789590f, 0.06195396f, 0.16753103f, 
    -0.05002828f, 0.16617946f, 0.02773442f, 0.04401938f, -0.23932451f, 0.06084828f, 0.02809590f, 0.11664476f, 
    -0.02257822f, -0.03401365f, -0.04258063f, 0.01014806f, -0.03658040f, -0.00279890f, -0.09580007f, -0.05356498f, 
    -0.03150797f, -0.09061079f, 0.07537856f, 0.08609753f, -0.01433696f, 0.05496225f, 0.01965498f, 0.03185654f, 
    0.11740118f, 0.07033753f, 0.00404429f, 0.02175245f, -0.07157066f, 0.05799177f, 0.14498393f, 0.04552068f, 
    -0.11157423f, -0.03199257f, 0.02996340f, -0.03070242f, 0.18130249f, 0.14673819f, -0.13296612f, -0.16940951f, 
    0.10075694f, -0.02481221f, -0.14827129f, -0.01364544f, 0.06988002f, -0.07805809f, -0.00561508f, 0.16995330f, 
    0.04247732f, -0.13131073f, 0.10624608f, 0.06740309f, 0.04532953f, -0.01301690f, -0.06003394f, 0.03613980f, 
    -0.23387069f, 0.05024972f, 0.18801151f, -0.03936481f, 0.21185713f, -0.00944867f, -0.21799892f, -0.01525761f, 
    0.07719926f, -0.04235407f, 0.08073568f, -0.17242247f, 0.08729566f, -0.00484706f, 0.07341690f, 0.16494803f, 
    -0.11640451f, 0.10254859f, 0.14228335f, 0.14632273f, 0.10222788f, -0.04847531f, 0.10757882f, -0.09074999f, 
    0.16549158f, -0.01972594f, 0.05122326f, 0.08346862f, 0.22071783f, 0.25957131f, 0.15663061f, 0.12989911f, 
    -0.14621753f, 0.15762928f, 0.12560397f, 0.03785062f, -0.00198349f, -0.05529739f, -0.09555414f, -0.22403604f, 
    -0.10484477f, 0.01288027f, 0.07465307f, 0.01456857f, 0.02011384f, 0.01054024f, 0.10482327f, -0.16215542f, 
    0.01244667f, 0.10282061f, 0.00919512f, 0.03019357f, 0.06242905f, 0.04163653f, 0.04302306f, 0.03006887f, 
    -0.01263180f, -0.04346675f, 0.07585979f, 0.07020192f, 0.03225475f, -0.18637557f, -0.02340346f, 0.06234832f, 
    0.02824470f, -0.03338170f, -0.00021479f, 0.06715590f, 0.03673447f, 0.14688051f, -0.17171641f, -0.11785329f, 
    0.03602681f, -0.08416580f, -0.17960235f, 0.04603641f, 0.01258389f, 0.07987155f, 0.11300287f, 0.00363896f, 
    -0.05547706f, 0.17464328f, 0.20901103f, 0.14112128f, -0.17382975f, -0.09591793f, 0.10364682f, 0.06872710f, 
    -0.06909844f, 0.23207261f, -0.40745574f, -0.16337587f, 0.05456017f, 0.05072021f, 0.04315968f, -0.06244737f, 
    0.02448388f, -0.05758847f, 0.08298419f, -0.09023939f, 0.08309451f, 0.01061235f, -0.02113932f, 0.01800846f, 
    0.08343374f, 0.11860254f, 0.06477553f, -0.06059233f, -0.05255739f, 0.01982202f, 0.00466739f, -0.00187087f, 
    0.19116865f, -0.07406709f, -0.08294865f, -0.13491578f, 0.08078641f, -0.21708894f, -0.26175746f, 0.09132805f, 
    -0.05122542f, 0.03448590f, 0.03501175f, 0.13564244f, -0.16505165f, -0.06793718f, -0.12884799f, 0.05498002f, 
    -0.08746260f, -0.07004352f, -0.08244247f, 0.01180808f, 0.04764324f, -0.03409883f, -0.10186186f, -0.10881098f, 
    -0.03805246f, -0.13146108f, 0.04139115f, -0.12562591f, 0.07034577f, -0.07955963f, -0.14067784f, 0.10279064f, 
    -0.09553435f, 0.14458781f, -0.11959037f, -0.02197945f, -0.04735741f, -0.04452460f, 0.02905175f, 0.12054744f, 
    -0.01942939f, 0.19764255f, 0.09485310f, -0.10640801f, 0.04079969f, 0.09146027f, 0.00733683f, 0.07856324f, 
    -0.05656791f, -0.11645129f, -0.34775558f, -0.14061955f, -0.23532759f, -0.00435758f, 0.05324558f, 0.03552036f, 
    0.08511513f, 0.02386428f, -0.07964067f, -0.01171556f, 0.06549210f, 0.07476182f, 0.01430084f, -0.01835123f, 
    -0.02580401f, 0.04126589f, -0.00956595f, 0.08708571f, -0.15555252f, 0.08174877f, 0.11962000f, 0.13845080f, 
    0.02338394f, -0.12206201f, 0.13870786f, -0.17922816f, 0.02301719f, -0.27404106f, -0.27367535f, -0.00222876f, 
    -0.03064381f, -0.09893646f, 0.02221519f, -0.14668444f, -0.12521276f, -0.00945880f, -0.03831499f, -0.20145428f, 
    0.10626418f, -0.10593291f, -0.07864621f, -0.00249311f, -0.14126116f, -0.01489579f, -0.00838866f, -0.10482622f, 
    0.17996149f, -0.00981322f, 0.11360019f, 0.11603332f, -0.05479268f, -0.09886315f, -0.02271660f, -0.00085101f, 
    -0.21299092f, -0.05542955f, -0.13528882f, -0.08320141f, 0.09319977f, -0.10610208f, 0.02494792f, 0.00758586f, 
    -0.01058486f, 0.04297760f, 0.01559921f, -0.06703356f, 0.05479569f, -0.00859645f, -0.03140470f, 0.00815804f, 
    0.04106487f, -0.04275760f, 0.07883359f, 0.04493776f, 0.01930835f, -0.04929592f, 0.01606950f, 0.07965846f, 
    -0.03475819f, -0.10754846f, -0.09237393f, 0.06468912f, 0.08556500f, 0.03809056f, -0.13607685f, -0.02926698f, 
    0.10029573f, -0.06896250f, -0.03826687f, 0.05674245f, 0.01113983f, 0.03056976f, 0.13036315f, 0.03690462f, 
    0.02240896f, 0.01299568f, 0.02112959f, -0.10122001f, -0.03176793f, 0.02454654f, 0.18213044f, 0.22034156f, 
    0.09725775f, 0.02386932f, 0.04119505f, 0.07754336f, 0.05359336f, 0.05335677f, 0.00552303f, -0.30592906f, 
    -0.14042550f, 0.06263109f, 0.14095490f, -0.20369254f, -0.01492393f, 0.03825739f, 0.03912467f, 0.02649275f, 
    0.09177685f, -0.25620684f, 0.09433015f, -0.05573075f, -0.01077519f, -0.00499872f, 0.06417429f, -0.08342887f, 
    0.03875374f, -0.00645127f, 0.03390818f, -0.03176999f, 0.00053594f, 0.03319743f, -0.02389237f, -0.01248832f, 
    0.05593247f, -0.02443764f, 0.03738393f, -0.00396304f, 0.00635664f, 0.02149800f, -0.04502255f, -0.05295268f, 
    0.03424158f, 0.03445847f, -0.03208831f, 0.03582542f, 0.03768658f, 0.02071758f, 0.05088824f, 0.00427568f, 
    -0.03306581f, 0.04121278f, -0.01258956f, -0.04936703f, -0.05626610f, -0.02603645f, -0.05533965f, 0.02560363f, 
    0.01548492f, -0.03316887f, -0.02261719f, -0.01786330f, -0.02148636f, -0.06099432f, -0.05530058f, 0.04437802f, 
    -0.04539454f, -0.02528168f, -0.00405676f, -0.06280494f, 0.00389039f, 0.03696819f, 0.03122884f, -0.00737891f, 
    -0.03952517f, -0.05023909f, 0.04232752f, 0.03943028f, -0.00493455f, -0.06487501f, 0.00628167f, 0.02937012f, 
    -0.05493790f, 0.01226466f, 0.01495889f, 0.01956605f, 0.01638722f, 0.00396520f, -0.01130840f, -0.04227500f, 
    -0.02900488f, -0.02176678f, -0.03561842f, 0.04969252f, 0.03525134f, 0.02564044f, 0.01897896f, 0.02430704f, 
    -0.06211319f, -0.03598039f, 0.02213551f, 0.03298194f, -0.01628926f, -0.01501970f, 0.01614569f, 0.00585035f, 
    -0.00951092f, 0.01260293f, -0.01648366f, 0.00121426f, -0.02773505f, 0.04582759f, 0.04772414f, -0.06796706f, 
    -0.01563342f, -0.03766904f, 0.01992871f, 0.04541162f, -0.04608110f, -0.05063700f, -0.01030172f, -0.03415622f, 
    -0.03792495f, 0.01803646f, -0.01015100f, 0.03768747f, 0.03236017f, -0.03739728f, 0.02130283f, 0.00471797f, 
    0.03068252f, 0.02952354f, -0.00632802f, 0.02817747f, -0.02666601f, -0.05499703f, 0.03667747f, -0.03066632f, 
    -0.04020932f, -0.01117412f, -0.03652212f, -0.01857551f, -0.00416399f, -0.01850304f, 0.00885429f, -0.04437159f, 
    -0.02442736f, 0.00417091f, -0.02973096f, -0.01152350f, -0.00967266f, -0.02186960f, 0.03143746f, -0.00208142f, 
    0.00879123f, 0.01222488f, 0.02388555f, -0.00603403f, -0.04789209f, -0.00985469f, -0.03550084f, -0.00332440f, 
    0.04533575f, -0.06285928f, 0.03585562f, 0.02867271f, -0.01315467f, -0.01016329f, -0.02070176f, -0.01801757f, 
    0.03551836f, -0.03309432f, 0.01894873f, -0.01735605f, -0.00419335f, 0.02653504f, 0.04857552f, 0.04183580f, 
    -0.02329636f, 0.00109922f, 0.04273503f, 0.01380317f, -0.00864905f, -0.00153142f, -0.02030182f, 0.04804702f, 
    -0.05339785f, -0.01732932f, -0.02604564f, 0.01058586f, -0.03830985f, -0.01966058f, -0.01783480f, 0.01529330f, 
    -0.05916853f, -0.04300500f, -0.00561990f, -0.01385703f, -0.03459210f, -0.04222050f, -0.07007069f, 0.00608799f, 
    -0.04009715f, -0.02728142f, -0.04372192f, -0.03852800f, -0.03706842f, 0.00081075f, -0.03754801f, 0.04131007f, 
    0.02638489f, -0.01553585f, 0.04733656f, 0.02208953f, -0.03987762f, -0.01278214f, 0.01724498f, -0.06232411f, 
    -0.03860358f, 0.04913417f, 0.01059823f, 0.00166788f, -0.06666991f, 0.00058939f, 0.04160396f, 0.02742068f, 
    -0.02179079f, 0.05016182f, -0.05179410f, -0.03114523f, -0.04510888f, -0.06725522f, -0.03724005f, 0.02199832f, 
    0.04772212f, 0.02294832f, 0.01871489f, -0.00800470f, -0.04145933f, 0.01461077f, 0.03105043f, -0.03416122f, 
    0.02539888f, 0.04788340f, -0.02813598f, 0.04815497f, 0.01031303f, 0.05102391f, -0.00612927f, -0.03450726f, 
    0.01270592f, 0.01600808f, -0.00556159f, 0.02616631f, 0.04154274f, 0.05223184f, -0.02592501f, -0.05604358f, 
    0.02061692f, 0.02380282f, -0.03312117f, 0.00970711f, 0.04413355f, 0.03697377f, 0.03310043f, -0.00011806f, 
    -0.01482598f, -0.04861062f, 0.03741859f, -0.00638415f, -0.01715943f, -0.02494959f, 0.01352453f, 0.04669829f, 
    -0.03392626f, 0.00290340f, 0.05301858f, 0.01984205f, 0.00209733f, -0.01494844f, -0.03622817f, -0.02252596f, 
    0.04333357f, -0.01891267f, -0.02082145f, 0.02225522f, -0.01996987f, 0.03403709f, 0.04079156f, 0.04506788f, 
    -0.00437662f, 0.03187561f, -0.02359518f, -0.04589295f, 0.04173520f, -0.04676545f, -0.04449434f, -0.04946667f, 
    0.04003537f, -0.04069012f, -0.03911452f, 0.02750059f, -0.04501013f, -0.03414090f, -0.02327203f, 0.00424140f, 
    -0.04821719f, -0.02524596f, -0.04805085f, -0.06064224f, 0.00606786f, -0.02697363f, -0.02861989f, 0.01746523f, 
    -0.00630075f, -0.04761236f, 0.00072913f, -0.03552809f, 0.00243538f, -0.05715854f, 0.04338541f, 0.00005382f, 
    -0.03414076f, 0.00992437f, -0.06440783f, -0.00028625f, -0.05633790f, 0.01704498f, -0.05564336f, -0.06751021f, 
    -0.03752851f, -0.05223813f, 0.00676851f, -0.01461779f, 0.03819072f, 0.02059562f, 0.02910434f, -0.03713121f, 
    -0.04662098f, 0.00195094f, -0.03714518f, 0.04541746f, -0.04916388f, -0.01107805f, 0.00005159f, -0.04866946f, 
    -0.01014615f, -0.00318653f, -0.03250156f, 0.00683269f, -0.00378828f, -0.04371459f, 0.03663396f, -0.01378241f, 
    -0.03151176f, -0.02058512f, -0.06039214f, 0.02292221f, -0.00660984f, 0.04331963f, -0.02243761f, 0.02796092f, 
    -0.05416158f, -0.06198772f, -0.02968721f, 0.00830074f, -0.05412431f, 0.04461418f, 0.01793913f, 0.00812910f, 
    -0.04338691f, -0.06674103f, -0.05607203f, -0.06155322f, -0.03328697f, 0.01127007f, -0.06038003f, -0.05253760f, 
    0.02897228f, -0.00866134f, -0.01977728f, 0.00320787f, -0.04032475f, 0.00991332f, 0.03013449f, 0.05105085f, 
    0.00049325f, -0.03360320f, -0.05208276f, -0.01125341f, -0.02420403f, 0.02158505f, -0.07156579f, 0.04423600f, 
    -0.02879642f, 0.03111049f, -0.00690008f, -0.02415935f, 0.04758218f, -0.03331681f, -0.04230746f, 0.00035958f, 
    0.06450175f, -0.01179265f, -0.05845071f, 0.01036034f, 0.03923326f, -0.01015786f, 0.05038619f, -0.06983377f, 
    -0.00835795f, -0.07153606f, -0.03003297f, -0.03273026f, 0.00982430f, -0.02864348f, -0.05989810f, -0.03888854f, 
    0.02846166f, 0.01701183f, -0.02486156f, 0.03811187f, -0.04752750f, 0.01192048f, 0.02985395f, -0.05204747f, 
    0.03692757f, -0.02948701f, 0.00108759f, -0.02653421f, 0.03300640f, 0.04562549f, -0.02685268f, 0.01799551f, 
    -0.02451060f, -0.00696239f, 0.03965205f, -0.03569921f, -0.02066700f, -0.03098721f, -0.04434982f, 0.04231063f, 
    0.01461685f, 0.03807808f, 0.04568871f, 0.03970890f, -0.03589198f, 0.05933511f, -0.02507249f, 0.03768319f, 
    0.03695295f, -0.02895845f, -0.05622353f, -0.01025010f, -0.02794557f, -0.01871483f, -0.03794434f, -0.01675115f, 
    -0.05731701f, -0.05489046f, -0.06604768f, -0.00017339f, 0.01531317f, 0.00135483f, -0.03747984f, -0.06089102f, 
    -0.05770541f, 0.00335239f, -0.05540435f, -0.04640977f, -0.03981424f, -0.07418395f, -0.01905027f, 0.02319349f, 
    -0.01726912f, 0.01109817f, -0.03533348f, 0.02114092f, -0.02103939f, -0.03968723f, -0.03623731f, 0.03706126f, 
    0.00965245f, 0.03639680f, -0.03592146f, -0.01112131f, 0.01129738f, -0.06881553f, -0.01574799f, -0.05842565f, 
    -0.00658875f, 0.03736592f, -0.04001300f, 0.02369687f, 0.01599328f, 0.00072465f, 0.04350058f, -0.02543134f, 
    0.03369710f, -0.01760659f, -0.05741378f, -0.05150802f, 0.01567541f, -0.05703462f, -0.00148521f, 0.00741060f, 
    0.04737378f, 0.03284598f, 0.01458691f, 0.00662432f, -0.03999459f, -0.00274624f, -0.01726786f, 0.00375769f, 
    -0.03167553f, -0.05529509f, -0.00564662f, 0.01527140f, 0.00440609f, -0.03344642f, -0.00297721f, -0.00873550f, 
    -0.01319247f, -0.04607375f, -0.00582505f, -0.00690786f, -0.04886166f, -0.00084424f, 0.03369162f, 0.04137355f, 
    -0.06789451f, -0.02505988f, 0.00246846f, -0.05177369f, 0.00845945f, 0.04711993f, -0.04985930f, 0.04123562f, 
    0.02219400f, 0.00512803f, -0.06845785f, 0.03632773f, 0.04107881f, -0.01320458f, 0.02859921f, -0.06489910f, 
    -0.00448204f, -0.02279607f, -0.06168995f, 0.01664359f, 0.02358053f, 0.03365699f, 0.02352509f, 0.01370780f, 
    0.00640819f, 0.01648942f, 0.03734250f, -0.00025336f, -0.00599933f, 0.00596833f, 0.04299720f, -0.02677630f, 
    0.03681049f, -0.04770648f, -0.02625016f, 0.03106305f, 0.00980893f, -0.06120570f, -0.03548840f, 0.03438529f, 
    -0.00611981f, -0.04870073f, -0.02354054f, -0.00500888f, -0.04933053f, -0.04215752f, 0.01115731f, 0.00892617f, 
    -0.00835731f, -0.04663554f, -0.02939217f, -0.06157913f, -0.00268553f, -0.03219020f, -0.02076883f, -0.03856207f, 
    0.01237136f, 0.04237733f, -0.04741682f, -0.00816484f, 0.04046884f, 0.03955226f, 0.02353900f, -0.00944399f, 
    -0.03016516f, -0.04024018f, 0.02200340f, 0.04335585f, -0.02002654f, 0.02484883f, -0.04992264f, 0.00012625f, 
    0.12549442f, 0.14932442f, 0.15466680f, -0.06844638f, 0.00036461f, -0.18441078f, -0.08704743f, -0.03279639f, 
    -0.08727319f, 0.06844029f, 0.07029248f, -0.33523032f, 0.17371432f, 0.08962785f, -0.07690168f, -0.04110291f, 
    -0.04117873f, -0.08094466f, 0.13180049f, 0.11204048f, 0.07719444f, -0.01222163f, 0.15664700f, -0.03067931f, 
    -0.11711030f, -0.04672857f, 0.02916190f, 0.31897062f, 0.15178432f, 0.23679510f, 0.02206333f, -0.04947764f, 
    0.06705512f, 0.04937182f, 0.04320028f, -0.01908503f, -0.01574519f, -0.02259354f, 0.22441712f, -0.00352636f, 
    0.04911740f, 0.02526583f, -0.02584029f, 0.03425413f, 0.07477594f, -0.05943488f, -0.25224912f, -0.01472652f, 
    -0.14251995f, 0.10553426f, -0.17108256f, -0.05114498f, 0.01763674f, -0.03723571f, -0.07095593f, 0.01534693f, 
    -0.04102690f, -0.01703473f, 0.17169470f, -0.04072484f, 0.03341324f, -0.11472397f, -0.05905667f, 0.15502709f, 
    -0.04132786f, -0.18936819f, 0.09680194f, 0.03349080f, -0.06087144f, -0.05965086f, -0.10868432f, 0.02432289f, 
    -0.09600247f, -0.39601529f, -0.04541279f, 0.06054286f, 0.00663501f, -0.05233840f, -0.07386915f, 0.02116164f, 
    -0.06631187f, 0.18908347f, 0.13074897f, 0.08284143f, 0.05557542f, 0.03319425f, 0.11931764f, 0.01832320f, 
    -0.05515681f, -0.10878821f, -0.07551322f, 0.00625145f, -0.40326366f, 0.12438405f, -0.11240201f, -0.01827147f, 
    -0.20662966f, 0.12184738f, -0.00436224f, 0.08977918f, -0.17514858f, -0.10237075f, -0.15552966f, 0.02250427f, 
    0.21391019f, 0.02129765f, -0.05048245f, -0.06717293f, 0.05630532f, 0.15721568f, 0.22690289f, 0.04461828f, 
    0.03734114f, -0.01420088f, 0.04159515f, -0.09907439f, 0.16625789f, -0.08192725f, -0.06946227f, 0.03843086f, 
    0.03081120f, 0.00755466f, 0.07897697f, 0.01381387f, 0.08247704f, -0.08419000f, -0.19773622f, -0.32855666f, 
    -0.01498518f, -0.08734229f, 0.18034749f, 0.07245858f, 0.13742782f, -0.00703361f, -0.08001574f, 0.25535065f, 
    0.23239176f, -0.02746974f, -0.15670910f, 0.12468109f, 0.02920188f, 0.09005436f, 0.00969071f, -0.01632544f, 
    0.05703615f, 0.16811310f, -0.27800021f, -0.05783456f, -0.08786739f, 0.08291083f, 0.09603868f, 0.00484154f, 
    -0.04993113f, -0.34871796f, -0.09762187f, 0.10411242f, -0.00830138f, 0.00984223f, -0.06248468f, -0.05439226f, 
    -0.14700466f, 0.04840333f, 0.27380228f, -0.08339676f, -0.26935384f, -0.06854872f, 0.05152790f, 0.06540699f, 
    -0.00020457f, 0.00786579f, 0.09370891f, 0.02853265f, -0.04265776f, -0.10814927f, 0.04416508f, -0.05127473f, 
    -0.07393507f, 0.05144645f, -0.02055887f, 0.05664522f, 0.03936714f, -0.06301170f, 0.05626519f, -0.05457330f, 
    0.04965030f, 0.09662228f, 0.04596244f, 0.06227307f, 0.03539528f, -0.37280902f, -0.40498197f, -0.21932335f, 
    0.12648946f, 0.10038280f, -0.08928741f, 0.03800264f, -0.09318385f, -0.04617430f, 0.23642547f, -0.01574895f, 
    -0.08764465f, 0.09379516f, -0.09475728f, 0.09034631f, 0.04258505f, -0.09112369f, -0.08113496f, 0.22310409f, 
    0.21279733f, 0.16210145f, -0.00169110f, 0.04727900f, -0.07140703f, -0.06159452f, -0.00242097f, 0.14819415f, 
    0.16794500f, 0.03386286f, 0.11215627f, -0.07552052f, 0.04578246f, 0.08637932f, 0.01826167f, 0.04259484f, 
    -0.04458276f, 0.04954947f, -0.10676391f, -0.02309654f, 0.06617771f, 0.11617278f, 0.11960170f, 0.00953762f, 
    0.03817629f, 0.14727826f, -0.15282948f, 0.02495448f, 0.00143472f, -0.05765652f, -0.00159610f, 0.03257870f, 
    -0.05553576f, -0.13952272f, -0.07319771f, -0.00496885f, -0.03025994f, -0.21207660f, 0.01793996f, 0.00978011f, 
    0.13979125f, 0.03048018f, -0.05519139f, -0.02121722f, 0.08102106f, 0.00474572f, 0.10375219f, 0.02467471f, 
    -0.06786067f, 0.07076427f, 0.10390105f, -0.02376180f, -0.05120952f, 0.27764046f, 0.25080124f, 0.08554297f, 
    -0.07638784f, -0.03224046f, 0.15009186f, 0.14250459f, 0.08655345f, 0.05527604f, -0.14443983f, -0.04496947f, 
    -0.08408810f, 0.13083112f, 0.06239349f, -0.04129685f, -0.15945294f, 0.04209324f, 0.07742804f, 0.00014660f, 
    -0.01176639f, -0.12800936f, -0.07010412f, -0.05180963f, 0.00500640f, 0.01612387f, 0.07262219f, -0.02525594f, 
    0.07356674f, 0.17802599f, -0.03767455f, -0.19795656f, -0.17004617f, -0.12506835f, 0.02885055f, 0.01166288f, 
    -0.04978499f, 0.08434784f, 0.00241866f, -0.02605373f, 0.15986434f, 0.07109553f, 0.00338286f, 0.07468753f, 
    0.02242413f, 0.05417297f, 0.01408977f, 0.02743336f, 0.00016317f, 0.05862417f, -0.06098149f, 0.03645108f, 
    -0.17179771f, -0.01923856f, -0.20857695f, 0.10337777f, 0.18103522f, -0.13219741f, -0.12702802f, -0.03619788f, 
    -0.04945887f, 0.09656169f, 0.10402170f, -0.11818351f, -0.01725889f, -0.12564696f, -0.02988971f, -0.03702530f, 
    0.07979218f, 0.10702725f, -0.06032554f, 0.02866448f, 0.03989857f, 0.06260393f, 0.38719773f, -0.12498535f, 
    -0.09736611f, 0.02056995f, 0.13769487f, -0.02813879f, 0.06980683f, 0.01675228f, -0.12973732f, -0.17769149f, 
    -0.20183814f, 0.16595955f, 0.00010456f, -0.12097904f, -0.06234499f, -0.07806634f, -0.17006947f, 0.14235288f, 
    0.15314999f, -0.02088367f, 0.16556847f, 0.01508274f, 0.04043751f, 0.01836629f, 0.05025558f, 0.02079842f, 
    -0.08802193f, -0.14688966f, 0.36628073f, 0.08986110f, 0.01556557f, 0.12746625f, 0.08596473f, 0.15303956f, 
    0.08473479f, 0.01311072f, -0.01139521f, -0.14530726f, 0.05859715f, -0.19600129f, -0.11014389f, -0.09830683f, 
    0.02078067f, -0.14405446f, 0.18422474f, -0.02627279f, 0.27660576f, 0.03197609f, -0.03879945f, -0.10637096f, 
    0.02074778f, -0.10657527f, 0.01381588f, 0.23295923f, 0.02633069f, -0.21712825f, 0.20546500f, -0.03316748f, 
    0.05440399f, -0.09715440f, 0.05850169f, -0.02201019f, -0.02090880f, 0.08310634f, -0.13029233f, -0.02669860f, 
    0.03987077f, 0.09812977f, -0.00731352f, 0.15089417f, 0.13531643f, 0.08602644f, -0.00141594f, -0.03711835f, 
    -0.00678081f, -0.03858052f, 0.13246125f, -0.16015694f, -0.06397872f, -0.15006667f, 0.16388595f, -0.13433371f, 
    0.02375122f, 0.02912429f, -0.06225234f, 0.23242591f, -0.23161793f, -0.11813194f, -0.14104505f, 0.10468386f, 
    0.00775856f, -0.27515712f, 0.03349562f, -0.05026347f, -0.07425299f, 0.13939807f, -0.11327075f, -0.19914702f, 
    -0.08381844f, -0.05713462f, 0.21785656f, 0.10247105f, 0.02455906f, 0.04871860f, -0.16823439f, 0.03797147f, 
    -0.09217009f, -0.11529358f, -0.30229634f, -0.25971812f, -0.02020800f, -0.08904259f, 0.04374173f, -0.13313028f, 
    0.09809788f, -0.01676412f, 0.08706346f, 0.00890212f, 0.18507862f, 0.05914116f, -0.00253133f, -0.01910129f, 
    -0.07630758f, -0.00210186f, -0.14370643f, 0.18300168f, -0.06100247f, -0.15740487f, 0.17820865f, -0.13370794f, 
    0.11530650f, -0.00459536f, 0.02252167f, 0.11674111f, 0.14303908f, 0.07203335f, -0.01031197f, -0.12724824f, 
    -0.11164241f, -0.12555289f, -0.24345793f, -0.16961405f, -0.06507406f, -0.04426477f, -0.30670127f, -0.02388304f, 
    0.02121291f, -0.04914322f, 0.03969473f, 0.07986501f, 0.07503841f, -0.14768919f, -0.01013315f, 0.10842509f, 
    -0.28390765f, -0.22757734f, -0.02495978f, -0.39096209f, 0.03763537f, 0.04930107f, 0.05314383f, 0.12859751f, 
    0.16796975f, -0.07448386f, 0.09151205f, -0.02929682f, -0.12802030f, -0.15349552f, -0.00975144f, -0.14817666f, 
    -0.26700112f, 0.07012373f, 0.10979606f, 0.15681054f, -0.02226222f, -0.12004796f, 0.01788973f, -0.11917698f, 
    0.13007304f, 0.07835879f, -0.03656069f, -0.11965147f, 0.06935661f, 0.01250835f, 0.14949566f, 0.01205106f, 
    0.10257678f, 0.45160526f, -0.15174833f, -0.01579857f, 0.24217029f, -0.00310794f, 0.00498737f, 0.25500500f, 
    0.02027042f, 0.01545594f, 0.13788100f, -0.08417413f, 0.13849787f, 0.01128669f, 0.05189174f, 0.03395727f, 
    0.01023885f, 0.07053092f, -0.05492641f, -0.00635494f, 0.06428736f, -0.08029277f, -0.32353848f, 0.01884120f, 
    0.04840220f, 0.00144278f, 0.02231436f, -0.02317766f, -0.20401101f, 0.05401876f, 0.12494397f, -0.20050469f, 
    -0.09042755f, 0.12929480f, -0.14992352f, 0.01980078f, 0.10003155f, -0.13874410f, 0.31364053f, -0.06659843f, 
    0.26522505f, -0.26719576f, -0.11691614f, -0.01295231f, -0.00467694f, 0.07962836f, -0.03255134f, -0.06525506f, 
    -0.09716069f, 0.31086487f, 0.11607929f, 0.03867175f, 0.07996597f, -0.10742489f, 0.10822342f, 0.02569035f, 
    0.04692699f, -0.05642226f, -0.06042776f, 0.00841330f, -0.00204301f, -0.03538597f, 0.03985406f, -0.01909043f, 
    -0.04789986f, -0.01849777f, 0.04579752f, 0.00541840f, -0.01308009f, 0.02634374f, -0.03809625f, -0.00405672f, 
    -0.03366717f, 0.01163740f, -0.05162825f, 0.04445040f, 0.03744319f, -0.00862380f, 0.00655441f, 0.02759349f, 
    -0.05266277f, -0.05813965f, 0.01911929f, 0.00960005f, -0.05630543f, -0.01405932f, 0.02241900f, -0.00356934f, 
    -0.00097537f, -0.00753963f, -0.01572133f, -0.03069744f, -0.03482629f, -0.06556252f, -0.02987929f, -0.04806137f, 
    0.03306028f, 0.01971281f, 0.00274685f, -0.05739184f, 0.00845409f, 0.00484554f, 0.02447036f, 0.03226180f, 
    0.01359847f, -0.04941434f, 0.03996459f, 0.03473444f, 0.02161625f, -0.01594034f, -0.01661816f, -0.04283579f, 
    -0.02785379f, 0.02794672f, -0.04980618f, -0.01135708f, -0.01480248f, -0.01632772f, 0.02810972f, 0.04438478f, 
    -0.00880796f, -0.06233481f, -0.02356431f, -0.01997178f, 0.02656599f, -0.03566815f, -0.04042247f, 0.00984977f, 
    -0.01841323f, 0.00540827f, 0.02571204f, 0.00385811f, 0.01345565f, 0.01489984f, 0.00118755f, 0.00671300f, 
    -0.01263935f, -0.06170688f, 0.01304543f, -0.04266778f, 0.04688567f, 0.00906796f, -0.06387661f, -0.01906614f, 
    0.00068303f, 0.03760928f, -0.01182695f, -0.02394701f, -0.04020166f, 0.00783458f, -0.00010636f, -0.04683910f, 
    0.01101448f, -0.04848951f, -0.04347905f, 0.04507703f, -0.06104679f, -0.03412552f, -0.02353401f, -0.05203548f, 
    -0.05006834f, 0.00974947f, -0.01620052f, 0.02577576f, 0.01150793f, -0.02107412f, 0.03671159f, 0.03720900f, 
    0.00138534f, -0.00412705f, -0.06895781f, -0.02221127f, -0.03498602f, 0.04886844f, -0.00627501f, -0.01401444f, 
    0.05330699f, -0.01298828f, 0.02701049f, 0.05099025f, -0.03850448f, 0.01287998f, -0.04750817f, -0.06118867f, 
    0.04773193f, 0.04449875f, -0.06184081f, -0.06536989f, 0.02739629f, 0.00887741f, -0.03054867f, -0.00949306f, 
    -0.01475489f, -0.03641688f, 0.00112060f, -0.00905538f, 0.01965594f, 0.03812802f, 0.00999278f, -0.03806654f, 
    0.04529926f, 0.01127687f, -0.00304143f, -0.04314940f, 0.02098607f, 0.01179270f, -0.05060489f, -0.02909351f, 
    0.03989632f, -0.05210305f, 0.00208414f, 0.03649743f, -0.06286492f, 0.03959138f, 0.04741253f, -0.02455532f, 
    0.00772701f, 0.03136440f, 0.03786050f, -0.05856941f, -0.02931166f, -0.05139108f, -0.04341621f, 0.02310888f, 
    -0.05667762f, -0.00980721f, -0.06146375f, -0.02660535f, -0.05782141f, -0.02133604f, 0.02103584f, -0.02208685f, 
    -0.05248346f, -0.04229045f, 0.03327936f, -0.01492657f, 0.04559903f, 0.02082064f, -0.03603922f, 0.02652106f, 
    0.00082386f, 0.03317631f, 0.00400130f, 0.04135791f, 0.00446652f, -0.04043780f, 0.05208783f, 0.04267831f, 
    0.01257672f, -0.00354758f, 0.00710720f, 0.02101216f, 0.02273970f, -0.01794062f, 0.02192025f, -0.05787738f, 
    0.04256145f, -0.01362417f, -0.00365780f, -0.03097532f, 0.06200498f, -0.03773413f, -0.04489497f, -0.03518888f, 
    -0.04859454f, -0.03648543f, 0.03247207f, 0.01053188f, -0.02381870f, -0.02098395f, 0.00832326f, -0.06675427f, 
    0.03344002f, -0.04881229f, 0.02693884f, 0.04695791f, -0.01892353f, -0.04907313f, -0.04163884f, -0.02745457f, 
    -0.04131230f, -0.06122461f, -0.02320506f, 0.00864311f, -0.02210271f, -0.03529077f, 0.02358910f, 0.02227587f, 
    -0.05735767f, 0.02699995f, 0.00608584f, -0.02846271f, -0.03521345f, -0.06513380f, -0.03001762f, -0.03486707f, 
    0.03390322f, -0.04316399f, -0.00554501f, 0.03665790f, -0.00340030f, -0.03969973f, -0.04038871f, -0.00088968f, 
    -0.04725627f, -0.03881145f, -0.01420658f, 0.02536945f, -0.05760581f, 0.00823173f, -0.05712836f, 0.01457477f, 
    0.01704503f, -0.00695282f, 0.03802444f, -0.03776024f, -0.03638494f, 0.01695656f, 0.04638855f, -0.05925610f, 
    0.00141790f, 0.04465798f, -0.00199500f, 0.04309059f, 0.03090540f, 0.00872480f, 0.00452636f, -0.03875101f, 
    -0.00507860f, 0.00395307f, -0.04173266f, -0.05535103f, 0.02903563f, -0.06629601f, -0.01787497f, -0.03881340f, 
    -0.04086739f, -0.01170824f, -0.01071891f, 0.00230962f, 0.03644871f, 0.00499524f, -0.01081835f, -0.01959819f, 
    0.04063113f, 0.01969509f, -0.04021444f, -0.03892227f, -0.04487439f, -0.02808193f, -0.04925844f, 0.03311832f, 
    0.01888467f, -0.06694082f, -0.02938738f, -0.03371777f, -0.03977932f, 0.04490837f, 0.01234578f, 0.03754713f, 
    -0.02885165f, -0.01284636f, 0.01645212f, -0.03819466f, -0.06405358f, 0.04311753f, 0.04836044f, -0.03520022f, 
    -0.05609068f, -0.00896080f, 0.04686489f, -0.04927233f, -0.03801385f, 0.02647293f, -0.02906961f, -0.04029096f, 
    -0.02187566f, 0.00601494f, -0.06443293f, -0.04277136f, 0.02489102f, 0.04013249f, 0.01551729f, 0.04008427f, 
    -0.05239372f, -0.04621680f, -0.05180071f, -0.02040238f, -0.06089846f, -0.02935445f, -0.00932256f, 0.02649508f, 
    -0.00652382f, 0.03171966f, -0.01348505f, 0.00802684f, 0.02013482f, -0.01675136f, -0.02092591f, -0.01476061f, 
    0.01643785f, -0.04043275f, 0.00875782f, 0.00762228f, 0.02337562f, 0.02152209f, 0.02741452f, 0.00777878f, 
    0.02574257f, -0.03747635f, 0.00387706f, -0.03381458f, 0.02617991f, -0.06278898f, 0.00832111f, -0.06069363f, 
    0.01209140f, -0.05359567f, -0.05892383f, -0.02415012f, 0.03087407f, -0.00039889f, -0.00799825f, 0.02846313f, 
    -0.01054060f, 0.04294731f, -0.01505851f, -0.06539624f, 0.03365674f, 0.00524500f, 0.00410511f, 0.00694837f, 
    -0.00242097f, -0.01696615f, 0.03658425f, -0.05744959f, 0.00768680f, -0.05281315f, -0.00986910f, 0.05873149f, 
    0.04690389f, 0.05167505f, 0.01417167f, -0.05410630f, 0.00035261f, 0.01971190f, 0.02048077f, -0.04312673f, 
    -0.03188542f, -0.02174232f, -0.02414292f, 0.03617301f, 0.01318482f, 0.03940289f, 0.01953874f, -0.02425041f, 
    -0.01470407f, 0.02967767f, 0.00890475f, 0.03208575f, 0.01613018f, 0.02183521f, 0.02269994f, 0.01940136f, 
    -0.04206652f, -0.04018738f, -0.03945938f, 0.01599985f, -0.00314639f, -0.00707892f, 0.04274350f, -0.01443534f, 
    0.03422100f, -0.00738497f, 0.02939308f, 0.02687808f, 0.01744381f, -0.05270946f, 0.05518427f, 0.03771282f, 
    0.02846217f, 0.02242722f, -0.05858931f, 0.04695916f, 0.02806865f, -0.05409630f, -0.03789270f, -0.04276741f, 
    -0.06448141f, -0.04627556f, 0.01672375f, -0.00782217f, -0.02361589f, -0.01265884f, -0.03105286f, -0.05842746f, 
    -0.01292955f, 0.02891554f, 0.02832154f, 0.03153463f, 0.00719712f, -0.06614834f, -0.01709487f, -0.01620009f, 
    -0.04095743f, -0.04579511f, 0.00592991f, 0.01908880f, 0.02126839f, -0.01358450f, 0.02194933f, -0.05462423f, 
    -0.00390058f, -0.03704255f, -0.04492893f, -0.06115508f, 0.00914326f, 0.03754753f, 0.02413966f, -0.04968098f, 
    0.02875231f, -0.06272162f, 0.04659784f, -0.00189151f, -0.04226682f, -0.05810206f, 0.04743430f, 0.00388867f, 
    -0.04748788f, -0.00313028f, 0.03626749f, -0.06011271f, -0.03703698f, 0.01255884f, -0.04988116f, 0.02836608f, 
    0.01214319f, -0.00053014f, 0.00146088f, 0.01650753f, -0.02743298f, -0.04130633f, -0.04308326f, 0.01316945f, 
    -0.06217260f, -0.01270954f, 0.04623221f, -0.03283098f, -0.05723932f, -0.04185816f, -0.03546051f, 0.04714790f, 
    -0.06249996f, 0.04812207f, 0.01012989f, -0.04316391f, -0.04577265f, 0.02532784f, 0.04968812f, -0.04022441f, 
    0.01004176f, -0.01714859f, -0.00414367f, 0.05054100f, -0.01745771f, -0.05946929f, -0.04785429f, -0.00935080f, 
    -0.06761461f, -0.01351175f, 0.01837904f, -0.00092851f, 0.00255476f, 0.03958289f, 0.02084321f, -0.06553479f, 
    0.04539944f, -0.02817071f, 0.01037115f, -0.01132987f, -0.06411589f, -0.00618599f, -0.03023554f, -0.04306817f, 
    -0.03138192f, 0.00408317f, -0.04357097f, -0.01795748f, -0.00199724f, -0.05953263f, 0.02538898f, 0.01743722f, 
    -0.01200519f, 0.00566120f, 0.04861081f, -0.03651199f, -0.03595310f, 0.01490895f, 0.01212528f, -0.06417713f, 
    0.01135673f, -0.02180582f, 0.00551590f, -0.01852313f, 0.01091292f, 0.01795875f, -0.02442544f, 0.04292825f, 
    0.02370627f, 0.02643280f, -0.00873437f, -0.00484530f, -0.04709105f, 0.01726128f, -0.04254480f, 0.00230745f, 
    -0.03936387f, -0.04547469f, -0.02398536f, 0.04474154f, -0.04488759f, 0.01036633f, -0.03682366f, -0.00983274f, 
    -0.00216244f, 0.01985768f, 0.01418831f, 0.04871440f, -0.00640629f, -0.06191320f, -0.00225982f, 0.02664586f, 
    0.00509421f, 0.01471726f, -0.02046551f, 0.00834104f, 0.02296211f, -0.04972444f, -0.02751611f, 0.00982836f, 
    -0.02277956f, 0.01934546f, -0.04040933f, 0.00834115f, -0.00149367f, 0.03935580f, 0.03097812f, -0.06127677f, 
    -0.01991839f, -0.00300731f, 0.01293663f, 0.02554255f, 0.00860908f, -0.00801405f, 0.04761032f, -0.03191992f, 
    0.00456357f, -0.00024712f, 0.00523829f, -0.05051514f, -0.05941638f, -0.02867944f, 0.05223355f, -0.02426889f, 
    0.05085709f, 0.00712400f, -0.01103993f, -0.06065622f, 0.02120727f, -0.04431596f, 0.02168660f, -0.00731069f, 
    -0.04762173f, 0.03087496f, 0.04637429f, 0.03793709f, -0.02281163f, 0.04687647f, -0.02149691f, -0.05610962f, 
    0.04097441f, -0.05977650f, 0.02468756f, -0.00193364f, -0.04335811f, 0.01324313f, 0.02858844f, 0.03924996f, 
    0.01940221f, 0.04110013f, -0.02178775f, -0.04808912f, 0.02869537f, 0.02741299f, 0.02818950f, -0.01176691f, 
    0.01623047f, 0.01699569f, -0.06022315f, -0.04640655f, -0.03531922f, 0.00458985f, -0.00654165f, -0.00292475f, 
    -0.03747673f, 0.01493969f, 0.04521795f, 0.01347655f, -0.06217355f, 0.01125975f, -0.02970590f, 0.05178700f, 
    -0.00338998f, -0.03572656f, 0.03035269f, 0.00043300f, 0.03288918f, 0.00500340f, -0.04096495f, -0.03480282f, 
    0.01648970f, 0.01247827f, -0.02377426f, 0.00405594f, 0.04600125f, 0.00641164f, 0.02365687f, 0.00686275f, 
    0.01537013f, -0.03226205f, -0.02449227f, -0.05709873f, -0.04299254f, 0.03846792f, -0.01358381f, 0.01206747f, 
    -0.05755452f, 0.00981317f, 0.01265409f, -0.06407156f, 0.02715651f, -0.02625351f, -0.00065786f, 0.00685659f, 
    0.02129654f, 0.05373484f, -0.05707471f, 0.02510707f, -0.02581706f, -0.01145928f, -0.06498429f, 0.03321427f, 
    0.01665957f, 0.03041268f, -0.06706787f, 0.03040326f, 0.01285870f, -0.02291034f, 0.04485529f, -0.01557426f, 
    -0.06343067f, -0.00555020f, 0.00475002f, -0.00042083f, -0.02790132f, 0.02000852f, -0.06113533f, -0.05281653f, 
    0.04193198f, -0.06455778f, -0.06621920f, -0.04847196f, -0.02606885f, -0.03882165f, 0.03348340f, -0.03528253f, 
    0.03542968f, -0.00481510f, 0.00487454f, -0.06438436f, 0.00014945f, -0.02577737f, 0.05137740f, 0.02541617f, 
    -0.00645424f, -0.00268064f, -0.00771614f, -0.00259937f, 0.03814499f, -0.00218483f, 0.01854973f, 0.01169323f, 
    0.03898146f, -0.02307063f, 0.03226782f, -0.03336928f, -0.04740987f, 0.00222723f, -0.03625929f, -0.00844930f, 
    -0.06202639f, 0.04293123f, -0.04048090f, -0.04502264f, -0.00109420f, 0.00602682f, -0.02884162f, 0.01168814f, 
    -0.01024557f, 0.03063298f, -0.04658141f, -0.04371691f, -0.02677411f, -0.00028788f, -0.00989315f, 0.02580616f, 
    -0.04455984f, -0.05336064f, -0.03903798f, -0.05916255f, 0.04541655f, -0.05240897f, 0.00772239f, 0.00689568f, 
    0.01277379f, -0.05406557f, 0.01713173f, -0.04173050f, -0.04821847f, 0.03056411f, -0.04117865f, -0.04178910f, 
    0.05293605f, -0.04652293f, -0.04623473f, 0.04572894f, -0.06396179f, -0.04971925f, 0.04105396f, -0.03751751f, 
    -0.05124013f, -0.04392016f, 0.01943704f, 0.03736831f, 0.03563811f, 0.03067419f, -0.05711203f, -0.05113565f, 
    -0.00799953f, 0.01464486f, -0.00302050f, -0.01032096f, 0.03631331f, -0.06590196f, 0.01426208f, 0.03984637f, 
    0.01022905f, 0.01146877f, -0.03351848f, 0.04414559f, 0.00144345f, -0.04343024f, -0.00789323f, 0.01195533f, 
    0.02449894f, -0.06750911f, -0.03630241f, -0.06179974f, 0.01585447f, 0.03178618f, -0.02425227f, 0.00134237f, 
    -0.03983874f, 0.02737707f, 0.04791662f, -0.02674957f, -0.04892911f, 0.02685525f, -0.04135425f, -0.04897219f, 
    -0.00298402f, 0.00705816f, 0.04429097f, -0.01332303f, -0.01972847f, 0.01033618f, 0.03517371f, -0.05542190f, 
    -0.04841616f, -0.01639226f, -0.03739247f, 0.00419654f, -0.01283654f, -0.06233386f, -0.06658205f, -0.01715544f, 
    0.00981778f, -0.04189964f, -0.02589920f, -0.05258231f, 0.01873326f, -0.03838897f, -0.02112218f, -0.00118687f, 
    0.02926485f, 0.02605694f, 0.03922358f, -0.01047827f, -0.01359938f, 0.05112496f, 0.04928272f, -0.00674184f, 
    0.04392326f, -0.03377734f, -0.02486166f, -0.05731821f, 0.03071608f, -0.05632369f, -0.05966987f, -0.05886465f, 
    0.04309412f, 0.02858690f, 0.00171096f, -0.04173123f, 0.04197315f, 0.01975331f, -0.05187626f, -0.00241488f, 
    0.02421425f, 0.04410532f, -0.02650594f, 0.00257323f, 0.01936406f, -0.04721455f, -0.00967570f, -0.04862552f, 
    -0.00527620f, 0.00892205f, -0.03204130f, -0.05245361f, 0.04007279f, -0.01661619f, -0.02813700f, -0.00949338f, 
    0.04871744f, -0.03905797f, 0.01774297f, -0.00103345f, 0.02389817f, 0.00697246f, -0.06421282f, -0.06035646f, 
    0.01362620f, 0.01687321f, 0.00935931f, -0.04575274f, 0.00403874f, -0.06725731f, -0.04413226f, -0.00118096f, 
    0.02187302f, 0.01720142f, -0.06190050f, -0.05402008f, -0.01538156f, 0.00900014f, -0.03244214f, 0.03571760f, 
    0.04411558f, -0.03273744f, 0.02768795f, 0.03131236f, -0.04608982f, 0.03563678f, -0.04795308f, -0.01518611f, 
    -0.02624718f, -0.02541555f, -0.01135247f, 0.04799499f, 0.00025051f, 0.00480285f, 0.03955745f, 0.04219946f, 
    -0.00428210f, 0.00629460f, 0.01025695f, 0.04307119f, -0.01589516f, -0.01344669f, -0.03900291f, 0.01980931f, 
    -0.01973284f, -0.03125505f, -0.04068746f, -0.04288008f, -0.03026576f, -0.00997656f, -0.05867230f, -0.01637922f, 
    -0.02756944f, -0.00463751f, 0.01893423f, -0.00211388f, -0.07123434f, -0.03189818f, -0.00770367f, -0.00213000f, 
    0.04283397f, 0.01881091f, 0.03522473f, -0.04670923f, -0.03178694f, 0.04863534f, -0.05039343f, -0.00871659f, 
    -0.06177530f, -0.06074008f, 0.00461349f, 0.02077197f, -0.03682067f, 0.00369779f, -0.06815867f, -0.00382516f, 
    0.00054625f, 0.03149397f, 0.04514781f, 0.02898826f, 0.04179778f, -0.02686661f, -0.06447185f, 0.04895954f, 
    0.00951636f, 0.02641900f, -0.05887154f, -0.02435584f, -0.01077574f, -0.03876855f, 0.02374022f, -0.04910117f, 
    0.01999759f, 0.04840609f, -0.03341258f, 0.02877437f, 0.04734395f, 0.04294822f, 0.01368825f, 0.04152963f, 
    -0.01782359f, 0.02497119f, 0.04670274f, -0.04129403f, -0.01657139f, -0.01632943f, -0.03078284f, -0.04319932f, 
    -0.00658025f, -0.03858797f, -0.02317733f, -0.03495922f, -0.02748092f, 0.02738737f, -0.03227199f, -0.02568587f, 
    -0.04534279f, -0.05682832f, -0.00408706f, 0.00021569f, 0.00678205f, -0.02883609f, -0.05733692f, -0.04466229f, 
    -0.01526156f, -0.01347670f, 0.00753302f, 0.01721731f, -0.05647270f, 0.03361470f, 0.03929297f, -0.02232451f, 
    -0.05807514f, 0.05163662f, -0.03848026f, 0.05076135f, 0.02443198f, -0.04805436f, -0.00348365f, 0.00748351f, 
    0.02251662f, -0.05396574f, 0.03028087f, 0.04970609f, -0.00905531f, 0.02085220f, 0.00835618f, -0.04692854f, 
    -0.01140966f, -0.03776508f, -0.03750538f, -0.05382611f, 0.04117933f, -0.05516035f, -0.01750786f, -0.01764730f, 
    -0.03944411f, -0.04202279f, -0.01572114f, 0.01106557f, 0.00074311f, -0.00538096f, -0.05376399f, 0.04875049f, 
    0.00106016f, 0.02441014f, 0.04379801f, -0.05870165f, -0.04217951f, -0.01186833f, -0.00872245f, 0.01035081f, 
    -0.01557542f, 0.00590469f, 0.02378781f, -0.05246343f, -0.03106907f, 0.05324901f, -0.00539791f, 0.01359636f, 
    -0.04950034f, 0.00326697f, -0.02109589f, -0.03280618f, 0.02745529f, 0.04105454f, -0.02507493f, 0.01566120f, 
    -0.05176183f, -0.04293910f, 0.01478524f, 0.00883899f, -0.01187594f, 0.04257544f, -0.01278656f, 0.00950431f, 
    -0.06367007f, -0.06173676f, -0.03274475f, -0.04978326f, -0.01374080f, 0.01426711f, 0.01029069f, -0.02987346f, 
    0.04912453f, 0.00187159f, -0.05345891f, 0.02237330f, -0.02777749f, -0.01966451f, -0.02103434f, 0.00764250f, 
    -0.02364516f, -0.00924202f, -0.05648762f, -0.00593852f, 0.04156091f, -0.04953592f, 0.03790644f, -0.05709797f, 
    -0.01642242f, -0.01828234f, 0.02741848f, -0.01842856f, -0.04032595f, -0.04869653f, -0.04992310f, -0.03071523f, 
    0.00833258f, -0.05952914f, 0.03227023f, -0.05417468f, -0.01082455f, 0.00242420f, -0.02109261f, -0.04607794f, 
    -0.04231604f, 0.01288148f, 0.04751998f, 0.04006027f, -0.00424389f, 0.01125745f, 0.00116012f, -0.02742783f, 
    0.03018216f, 0.01718816f, 0.00952507f, -0.00749407f, 0.03286669f, 0.00847877f, 0.03372587f, 0.05123344f, 
    0.00163505f, -0.04543174f, 0.03006526f, -0.00510682f, -0.03020500f, 0.00185540f, 0.03688624f, -0.00576169f, 
    -0.31944674f, 0.10091699f, 0.15560758f, 0.02757485f, 0.06447333f, 0.08902895f, -0.01924731f, 0.05485321f, 
    -0.15377426f, 0.11914562f, 0.04098508f, -0.02680024f, 0.04860332f, 0.05868931f, 0.00107812f, 0.09212904f, 
    0.07276496f, 0.08030167f, -0.01272705f, 0.01847965f, -0.04829092f, 0.17883800f, -0.16466154f, 0.15048672f, 
    -0.00068064f, -0.14562608f, 0.06198449f, -0.07139054f, 0.17637694f, 0.12767676f, 0.08600695f, 0.12918749f, 
    0.21148053f, 0.02856508f, 0.08439170f, 0.07015541f, -0.26922813f, 0.17201135f, 0.05107670f, -0.14127494f, 
    0.03602412f, 0.03862645f, 0.03960608f, 0.09236399f, -0.11641509f, 0.00696755f, 0.08061457f, 0.25274432f, 
    0.02812886f, 0.05531675f, -0.09792043f, 0.02125133f, -0.01520539f, -0.03878314f, 0.04747697f, -0.13009873f, 
    -0.15974596f, -0.00329337f, -0.06509938f, -0.07699759f, 0.07553440f, 0.14357698f, 0.04070285f, -0.00242459f, 
    -0.01304981f, -0.06771723f, 0.04552330f, -0.01575827f, 0.06984079f, -0.06407441f, 0.06391084f, 0.09032586f, 
    0.02750700f, -0.10925892f, 0.03397629f, 0.12728491f, 0.09206542f, 0.12275013f, 0.03974924f, 0.03386595f, 
    0.10160080f, 0.08246874f, 0.23554814f, 0.16411623f, -0.00178274f, 0.11126821f, 0.08148888f, -0.05000098f, 
    -0.15054464f, -0.15683532f, -0.35000840f, -0.44333687f, -0.06291521f, 0.17117682f, 0.21471001f, 0.02795312f, 
    0.11070488f, -0.04877461f, 0.00525512f, 0.26399308f, -0.02023384f, -0.02287302f, 0.14703286f, 0.00161430f, 
    0.19745517f, 0.23247711f, 0.06650088f, -0.09440113f, -0.02864473f, -0.23427317f, -0.01539286f, -0.16736309f, 
    0.09607982f, -0.04064484f, 0.19260314f, 0.01750714f, -0.06575070f, -0.21726027f, -0.02878700f, -0.11153530f, 
    0.01971150f, -0.06168511f, -0.11395058f, -0.12386421f, -0.01179445f, 0.10267801f, -0.08279371f, -0.31127784f, 
    -0.04759806f, 0.00157681f, 0.01932783f, 0.15904213f, -0.19264886f, -0.35618314f, -0.18290924f, -0.05915980f, 
    -0.09216180f, -0.02884148f, -0.07101671f, -0.15000345f, -0.13394956f, -0.01977054f, 0.14014375f, 0.04429162f, 
    -0.22212388f, -0.24148977f, 0.09524239f, -0.07485816f, -0.06718646f, 0.04090529f, 0.12438054f, -0.09203424f, 
    0.02352818f, 0.34474814f, -0.08300760f, 0.31499663f, -0.05212196f, 0.04496624f, 0.02110381f, 0.19680747f, 
    0.24888308f, 0.12571813f, -0.03998999f, 0.15837520f, -0.02878225f, 0.00340848f, 0.00444612f, 0.07243814f, 
    -0.05580058f, -0.04916047f, -0.13792644f, 0.02665342f, 0.20856860f, -0.06254884f, 0.21087851f, 0.09843015f, 
    0.08537479f, 0.10736019f, -0.08596940f, -0.11032298f, -0.14492527f, 0.01424013f, -0.12517776f, 0.06105448f, 
    -0.01803870f, -0.02452630f, -0.08668271f, -0.17508210f, -0.01756863f, -0.16451108f, -0.26355314f, -0.13805671f, 
    0.02230782f, -0.13393579f, -0.01387771f, 0.05732633f, -0.16383584f, -0.12036057f, -0.06394449f, 0.02516078f, 
    0.00346784f, -0.29173997f, -0.15810876f, -0.09813638f, -0.07822886f, -0.05326768f, 0.00830824f, -0.04189070f, 
    0.29004711f, 0.16124034f, -0.15394162f, 0.00619053f, 0.05716594f, 0.14357336f, -0.07728442f, -0.16213070f, 
    -0.15472458f, -0.03646857f, 0.03846731f, -0.01337709f, 0.13488467f, -0.03435109f, 0.25755149f, 0.15989050f, 
    0.18800613f, 0.19160412f, 0.17395929f, 0.09009179f, 0.00930502f, 0.07894284f, -0.09710077f, -0.07871383f, 
    0.05516578f, -0.05130228f, -0.25781053f, -0.14179732f, 0.05579685f, -0.03820726f, 0.05433908f, -0.02358160f, 
    -0.13383070f, -0.11931253f, -0.09413292f, 0.15269813f, 0.00361535f, 0.13127059f, -0.10688195f, 0.04043523f, 
    0.03361374f, 0.00128863f, 0.20515290f, 0.23602296f, -0.09041875f, -0.02984747f, -0.02221921f, 0.06220391f, 
    0.02361501f, 0.09923004f, -0.13302162f, 0.02665651f, -0.11587828f, -0.13101074f, 0.10850474f, 0.23947419f, 
    -0.00435351f, 0.12071681f, -0.05427260f, 0.08981316f, 0.00990577f, 0.00867744f, -0.06777601f, -0.23382027f, 
    -0.04810784f, -0.01516631f, -0.11320806f, 0.02869857f, -0.03528848f, -0.05918222f, 0.23226635f, -0.22583185f, 
    -0.02084651f, 0.02624322f, 0.16853678f, 0.17416301f, 0.01398468f, -0.03937895f, -0.09394385f, 0.14409253f, 
    -0.00323934f, 0.00840365f, 0.03168086f, -0.01089828f, -0.05768391f, 0.01167651f, -0.00623827f, -0.01131437f, 
    0.00873354f, 0.03852601f, 0.04611715f, -0.02710324f, 0.02974223f, -0.05203563f, -0.05229523f, 0.02759334f, 
    0.01917411f, -0.02950373f, 0.02625060f, 0.01601683f, 0.01603756f, -0.01427742f, -0.04653696f, -0.04455625f, 
    0.02497783f, -0.01036665f, 0.01344627f, 0.03300054f, -0.03253732f, -0.06209213f, -0.05898675f, -0.06176475f, 
    -0.04746744f, -0.03728172f, 0.03357132f, -0.05823038f, -0.01542548f, -0.02978169f, 0.01474711f, -0.00576244f, 
    -0.01300490f, -0.01538848f, -0.01760364f, -0.05779713f, -0.00423282f, 0.00050403f, -0.03803670f, -0.02567478f, 
    -0.02190757f, 0.00915409f, -0.03929189f, -0.02214455f, 0.01651974f, -0.01795625f, -0.06223280f, 0.03133922f, 
    0.02803723f, -0.05650256f, 0.05053782f, -0.03002102f, -0.04253045f, -0.05026007f, -0.06223018f, 0.01174232f, 
    0.04005551f, 0.01145127f, -0.05049879f, -0.00465840f, -0.01091169f, 0.02785662f, -0.03545177f, -0.02295986f, 
    -0.01926466f, -0.02466438f, -0.05841234f, 0.01820518f, 0.02970418f, -0.00931267f, 0.03273541f, -0.06487911f, 
    0.00559069f, 0.03155051f, -0.05180892f, 0.03096326f, -0.01099824f, 0.03989366f, -0.01884594f, -0.02100840f, 
    -0.06366086f, 0.00781188f, -0.00773151f, 0.00891143f, -0.00029635f, -0.03645996f, -0.02200885f, -0.05032274f, 
    -0.04130738f, -0.02794514f, -0.05639397f, 0.02847704f, 0.02169947f, -0.03804836f, 0.01902225f, 0.03709292f, 
    -0.01983960f, 0.02559952f, -0.03441101f, 0.04572888f, -0.00097386f, -0.00511047f, 0.03431461f, -0.06352303f, 
    -0.01033342f, -0.00588092f, -0.01615579f, -0.02243364f, -0.06507231f, -0.00334138f, 0.04504598f, 0.03786400f, 
    -0.05105108f, -0.04245252f, -0.04747508f, 0.04289164f, -0.05626404f, -0.01775794f, -0.01141990f, 0.04729120f, 
    -0.03701212f, -0.02185231f, 0.00907002f, 0.00468737f, -0.01825702f, -0.05536932f, -0.06562816f, -0.03623189f, 
    0.00231562f, 0.03982231f, -0.00818152f, 0.02005908f, -0.02899886f, -0.05026830f, -0.02973552f, -0.06735431f, 
    -0.03817433f, 0.04480567f, -0.05918421f, -0.05017274f, -0.03226619f, 0.01599163f, -0.00602134f, 0.00120612f, 
    -0.01537509f, -0.06574164f, 0.00225703f, 0.04564350f, -0.00080100f, 0.04645592f, 0.01933045f, 0.04065094f, 
    0.01442552f, -0.05723200f, -0.01008459f, 0.01280149f, 0.00398304f, -0.05907370f, 0.04722066f, 0.01760598f, 
    -0.02267178f, -0.04664421f, 0.04388800f, -0.01706127f, -0.04168057f, 0.05351703f, -0.01357020f, 0.02835414f, 
    -0.03444207f, 0.00755636f, 0.01475036f, -0.05541104f, -0.00629505f, -0.03142083f, 0.05610419f, 0.00170339f, 
    0.04279980f, 0.02557051f, 0.03071479f, 0.02086674f, -0.00016456f, -0.03297888f, -0.05597753f, -0.05072428f, 
    0.00966585f, -0.01058977f, -0.00762159f, 0.04061314f, 0.01856794f, 0.03199075f, -0.00039464f, 0.02721187f, 
    -0.00259774f, -0.02390595f, 0.02352716f, -0.04447022f, 0.02886447f, -0.03829575f, 0.00158021f, 0.01804163f, 
    -0.05347102f, -0.05099218f, 0.01785818f, -0.01477484f, -0.05349497f, 0.03117948f, -0.02816015f, 0.04269583f, 
    -0.01627685f, 0.04514586f, -0.01364046f, -0.06508815f, -0.04530676f, -0.02187303f, -0.05274653f, -0.00731592f, 
    0.01337514f, -0.00271880f, -0.06681985f, 0.01788747f, 0.01529523f, -0.02823129f, -0.02388669f, 0.00022267f, 
    -0.02096020f, 0.04568986f, -0.01270487f, -0.04650497f, 0.03905262f, -0.05252578f, 0.02779059f, 0.04040929f, 
    0.04782718f, -0.01470186f, -0.04903535f, 0.03815010f, -0.01227349f, -0.06338410f, -0.04530038f, -0.02584975f, 
    -0.02504613f, 0.01117666f, -0.03122645f, -0.03001421f, 0.03955821f, -0.00679283f, -0.02447215f, -0.04978338f, 
    -0.03870756f, 0.02781594f, -0.06723525f, -0.04343943f, 0.00891559f, -0.06774958f, 0.03935560f, 0.01211157f, 
    -0.03229446f, -0.04215369f, -0.04602922f, -0.00627758f, -0.02405737f, -0.03562767f, 0.04093388f, 0.04316339f, 
    -0.03827327f, -0.01790286f, 0.02263392f, -0.03008031f, -0.05943543f, 0.02153041f, -0.06664105f, -0.00240389f, 
    0.04649204f, -0.05942829f, -0.06460335f, -0.04315878f, -0.04861929f, -0.01363794f, 0.00281107f, -0.03873115f, 
    -0.00161837f, 0.04148217f, 0.00257004f, -0.26170355f, -0.03362099f, -0.14537479f, 0.02198605f, 0.19756167f, 
    0.14374956f, -0.19236231f, 0.01786871f, 0.24040566f, 0.11387961f, -0.05999965f, 0.06396147f, 0.11074447f, 
    0.03449074f, 0.04411606f, -0.10641497f, -0.01308956f, -0.14963578f, -0.05329178f, 0.07455463f, -0.01191207f, 
    0.23790145f, 0.10780085f, -0.00196681f, 0.28520355f, 0.06791477f, 0.13944909f, -0.09591974f, 0.07188900f, 
    0.00943373f, 0.07653242f, 0.01084668f, 0.11990681f, 0.07240447f, 0.10390155f, -0.08132207f, -0.17373048f, 
    0.02780611f, 0.01688059f, 0.05920012f, 0.12558924f, 0.00646215f, 0.04179651f, 0.11908804f, -0.01466380f, 
    0.01732973f, 0.06191545f, 0.10603441f, -0.05024733f, 0.02765303f, 0.15268122f, -0.15344998f, -0.20596251f, 
    0.08500607f, -0.02137166f, 0.03888772f, 0.05207423f, 0.01955242f, 0.03998062f, -0.01455403f, -0.25793073f, 
    -0.23765378f, 0.03988130f, 0.01018323f, 0.10062600f, 0.13549092f, -0.03557599f, -0.13987885f, -0.18418404f, 
    0.23878224f, 0.12397017f, -0.19878869f, 0.18343253f, 0.08445635f, 0.06432906f, 0.04312486f, 0.03923535f, 
    0.03854506f, -0.02319603f, -0.06983084f, -0.06690808f, -0.11617696f, 0.01493779f, 0.05198711f, -0.00961225f, 
    0.02740902f, 0.09890637f, 0.18938990f, -0.13911757f, 0.04615026f, 0.05151458f, -0.11330373f, -0.00634571f, 
    0.14176810f, 0.00818288f, 0.00704274f, 0.11743790f, 0.32510525f, 0.27246317f, 0.13132682f, -0.06695250f, 
    -0.06010098f, 0.10218852f, 0.08347511f, 0.07436691f, -0.06273875f, 0.02448073f, 0.16795173f, 0.00549009f, 
    0.01192606f, 0.05742343f, 0.16597854f, 0.15606201f, 0.23867127f, -0.19257170f, -0.19769277f, -0.10393249f, 
    0.02329540f, 0.01101078f, 0.09196831f, -0.10407189f, 0.03333698f, -0.00056996f, -0.31933370f, -0.01069176f, 
    -0.04730939f, 0.01937492f, 0.05851763f, 0.01659557f, -0.05937942f, 0.05314184f, 0.00308472f, -0.01789829f, 
    -0.01830111f, 0.07440332f, 0.16960986f, 0.08908951f, -0.02299336f, 0.15161689f, -0.14462495f, -0.08603395f, 
    -0.18137293f, 0.09269255f, -0.08593959f, 0.08621874f, -0.06962372f, 0.06846161f, -0.04362194f, -0.08768564f, 
    0.01779811f, -0.27059370f, -0.01135793f, -0.07789160f, 0.08950084f, 0.06921636f, 0.06899272f, 0.08608558f, 
    -0.19033648f, 0.02456429f, 0.22177798f, -0.24307226f, -0.24541330f, 0.06149762f, 0.15915219f, 0.01247816f, 
    -0.10508242f, -0.03555492f, -0.06607524f, 0.30389413f, -0.06928322f, 0.09064906f, 0.08287730f, -0.09622123f, 
    0.06739042f, 0.14984591f, 0.10145664f, 0.11716294f, -0.17205313f, -0.06851017f, -0.14874226f, 0.12656952f, 
    -0.00578453f, -0.10692494f, 0.23867142f, 0.06831042f, -0.13960446f, 0.00708595f, 0.07338697f, -0.10250704f, 
    0.17788009f, 0.11257344f, 0.09860688f, 0.08998000f, -0.05421747f, 0.01545104f, -0.17097771f, 0.10598299f, 
    0.13653700f, -0.10952649f, 0.03609615f, -0.15676588f, -0.28759211f, -0.03615093f, 0.03060394f, 0.01589598f, 
    -0.11246785f, -0.05271651f, -0.08045247f, -0.07141986f, -0.09434430f, -0.05101319f, -0.00992931f, -0.05998112f, 
    -0.22298348f, -0.12536032f, -0.07202139f, 0.04941087f, -0.11412750f, 0.14057454f, 0.00114175f, -0.06702828f, 
    0.02827555f, -0.03624391f, 0.05916433f, 0.15700766f, 0.14067113f, -0.16470008f, 0.05637550f, 0.07299642f, 
    0.14933366f, -0.03669602f, 0.07338981f, 0.01376569f, -0.15345155f, 0.13686390f, 0.05174895f, 0.19622496f, 
    -0.07387730f, -0.12401545f, 0.03184428f, -0.16696852f, 0.01843266f, 0.28242028f, -0.03779380f, -0.03833010f, 
    0.08982256f, -0.18734103f, 0.03429601f, 0.03306668f, -0.02370278f, 0.03555597f, -0.24473906f, 0.03142340f, 
    0.12203656f, 0.08822501f, 0.03906368f, 0.07718576f, 0.05412080f, 0.03517755f, 0.09859455f, 0.22837366f, 
    -0.16209240f, -0.01105997f, -0.16775489f, 0.08688978f, 0.10322549f, 0.09043312f, -0.19219197f, -0.01011940f, 
    -0.06202309f, -0.08481612f, -0.00288616f, 0.05358356f, -0.04492203f, -0.02855237f, 0.12869549f, 0.24304457f, 
    0.00967364f, -0.13083887f, 0.17125010f, 0.01902603f, 0.01761330f, 0.03645259f, -0.13452257f, 0.03083648f, 
    0.15102904f, 0.44349891f, -0.29351255f, 0.05078986f, 0.01605882f, 0.01821378f, 0.19464558f, -0.02388926f, 
    0.19732520f, 0.15931980f, 0.14036517f, -0.02612723f, 0.02921607f, 0.02713892f, -0.05054104f, -0.01305378f, 
    0.12680328f, 0.00991424f, -0.32104295f, 0.05056555f, -0.10930322f, 0.02719942f, 0.04418860f, 0.08654633f, 
    -0.13568777f, 0.12150523f, 0.03403580f, 0.17950375f, -0.07667834f, 0.06874331f, -0.01352729f, 0.00492243f, 
    0.01698678f, -0.02978575f, 0.02040518f, 0.15267363f, -0.11425351f, -0.00848692f, -0.08582180f, 0.07789520f, 
    0.05609996f, -0.08328106f, -0.01001111f, 0.11481959f, -0.21447435f, 0.52710271f, 0.13816676f, 0.12024479f, 
    -0.10976776f, -0.01178526f, 0.11752801f, -0.03334115f, -0.18541363f, -0.05639379f, -0.08617344f, 0.13444702f, 
    0.03608361f, -0.03956980f, 0.06561078f, 0.11796977f, -0.00846793f, 0.01817084f, 0.07029562f, 0.00353419f, 
    0.10776550f, -0.09605891f, 0.06138911f, -0.04763797f, -0.10961970f, -0.00945871f, 0.10141952f, -0.05518018f, 
    0.15823178f, 0.02607377f, -0.03913030f, -0.18642302f, 0.01838162f, 0.02820352f, -0.00767668f, -0.00958318f, 
    0.01706074f, 0.20648025f, -0.00593725f, 0.15425806f, -0.09176540f, -0.02376984f, -0.04236136f, 0.02054982f, 
    -0.07846536f, -0.12119785f, -0.05872374f, 0.09097685f, -0.10849801f, -0.20082468f, -0.10458388f, -0.06532367f, 
    0.00981865f, 0.01572990f, 0.00597347f, 0.06664613f, -0.18374875f, 0.14174449f, -0.02510640f, -0.03085917f, 
    0.03487426f, -0.05841929f, 0.07886063f, 0.02097660f, -0.11911581f, -0.09155715f, 0.08821279f, 0.09715889f, 
    0.04410187f, 0.09770666f, -0.09164710f, -0.01195850f, 0.01150604f, -0.08830003f, -0.11217482f, -0.14379312f, 
    0.03642585f, -0.03305269f, 0.14499800f, -0.07955656f, -0.02816593f, -0.05475681f, -0.17855558f, -0.16562572f, 
    -0.03355924f, 0.00348017f, 0.09002733f, -0.04730914f, 0.10342590f, -0.08367547f, -0.18997107f, 0.05052938f, 
    -0.18000807f, 0.03746567f, 0.00128873f, -0.00878448f, -0.00727354f, -0.15717651f, 0.11232006f, 0.01358180f, 
    0.00402858f, -0.31482291f, -0.16589503f, -0.18300921f, -0.12487874f, 0.04544260f, -0.12220661f, 0.02535797f, 
    0.07508212f, 0.20686494f, -0.44595075f, -0.07274174f, -0.01983520f, -0.00510546f, 0.05427672f, -0.03738332f, 
    -0.10552764f, 0.04323790f, 0.04394051f, -0.41356149f, -0.04777225f, 0.09951752f, -0.15768029f, -0.06445988f, 
    -0.08095201f, -0.01430956f, 0.00210928f, -0.65842605f, -0.20311417f, 0.07110064f, 0.04212707f, 0.08770718f, 
    0.00741688f, -0.01849495f, -0.03902591f, -0.02982484f, -0.16085666f, 0.08430135f, -0.00284195f, 0.01224824f, 
    0.00728422f, 0.14370318f, -0.06604659f, 0.12411131f, -0.04851281f, -0.01089294f, -0.03155904f, 0.11203415f, 
    -0.07771969f, 0.00258164f, -0.07324928f, -0.16018613f, 0.18879463f, 0.01309983f, 0.13778760f, 0.13268380f, 
    -0.10213826f, 0.08628131f, -0.05271549f, 0.08086494f, 0.07716966f, 0.11775245f, -0.11156137f, -0.04961186f, 
    0.21587095f, 0.18848670f, -0.04753482f, 0.02674253f, 0.01259324f, 0.16753408f, 0.00901882f, 0.07408889f, 
    0.15270130f, -0.20191139f, -0.17071791f, 0.04933626f, -0.01924962f, -0.00301894f, 0.15605970f, -0.06488167f, 
    0.00577853f, -0.00321304f, 0.22482954f, -0.06801455f, 0.08273987f, 0.02708133f, 0.14222987f, -0.13779022f, 
    -0.01803274f, -0.06589584f, 0.16153297f, -0.25960132f, 0.10961786f, -0.09572468f, 0.03649907f, -0.05080143f, 
    -0.02889773f, -0.01197578f, 0.00699261f, 0.04052157f, 0.24383923f, 0.18117291f, 0.12570097f, 0.12558085f, 
    -0.16313162f, 0.13726139f, -0.05068890f, 0.04028138f, 0.03698989f, -0.17532516f, -0.04951493f, 0.12665057f, 
    0.07424258f, 0.05351356f, 0.02301728f, -0.09000588f, 0.02253231f, 0.20981364f, 0.11095256f, 0.12442543f, 
    0.14333393f, 0.05012797f, 0.04221889f, 0.07450622f, 0.04640629f, 0.05014122f, 0.06852424f, -0.23433952f, 
    -0.26481572f, -0.04396424f, 0.00585290f, 0.07273379f, 0.04523816f, 0.02840895f, -0.01879326f, 0.02961831f, 
    0.06733528f, 0.00122851f, -0.12438601f, 0.02107893f, 0.07339080f, 0.15481628f, 0.02855971f, 0.02602511f, 
    0.00785592f, -0.03462289f, -0.01629411f, -0.00229420f, 0.01964913f, 0.02127899f, -0.03608689f, -0.04031152f, 
    0.04653856f, 0.02732822f, 0.04873350f, -0.05057269f, 0.00218902f, -0.05121829f, -0.02062522f, 0.04508055f, 
    0.04749642f, -0.01584467f, -0.00449264f, 0.04385186f, -0.04176161f, -0.03010122f, 0.02954407f, -0.04071657f, 
    -0.02962621f, 0.02767967f, 0.03986687f, 0.02476278f, -0.01231996f, 0.04553885f, 0.01667619f, -0.03562495f, 
    0.04299803f, -0.02080596f, -0.01012746f, 0.04526721f, -0.01634065f, 0.02566368f, 0.00134140f, 0.02600704f, 
    -0.03364078f, 0.04059898f, -0.04871954f, -0.01168073f, -0.05780758f, -0.00865274f, 0.04666439f, 0.04244549f, 
    -0.01325686f, -0.06384330f, 0.00348990f, 0.04789664f, -0.00818006f, 0.00065622f, -0.06159177f, -0.02573499f, 
    -0.05114445f, -0.05087817f, -0.05206658f, -0.01506808f, 0.00947441f, 0.04266401f, -0.03772565f, 0.02952127f, 
    -0.03750441f, 0.04377878f, 0.04664971f, 0.00781185f, 0.00838985f, 0.03756745f, 0.04198034f, -0.04983040f, 
    -0.01492285f, -0.01242321f, -0.00639196f, -0.01883141f, -0.02318531f, 0.04689263f, -0.00757309f, -0.02547340f, 
    -0.04266236f, 0.00842058f, -0.04849675f, 0.01552684f, 0.00687987f, 0.01216986f, 0.03032700f, -0.05739121f, 
    -0.04233060f, -0.04506408f, 0.03286736f, 0.04748154f, -0.05438044f, -0.01545712f, 0.04804901f, 0.02095015f, 
    -0.00247994f, -0.06676678f, 0.04046286f, -0.06766148f, -0.00190552f, -0.05454203f, 0.03251156f, 0.04166946f, 
    -0.06405649f, -0.06839326f, -0.02823463f, -0.04115498f, -0.00750832f, -0.05461891f, -0.02268206f, 0.00552041f, 
    -0.04593099f, -0.03520567f, 0.04582060f, 0.04235432f, -0.05767643f, 0.01030492f, -0.03447977f, 0.00455610f, 
    0.03895482f, 0.04945042f, 0.02513828f, 0.03763701f, 0.00862462f, -0.02325227f, -0.03097343f, -0.01543509f, 
    0.03667404f, 0.02249736f, -0.05090338f, 0.05015742f, 0.02745920f, 0.02584272f, -0.05260082f, -0.00592892f, 
    0.00108316f, 0.03656718f, -0.00276034f, -0.05588881f, 0.01275882f, 0.00269412f, 0.00068578f, -0.01895095f, 
    0.04078322f, -0.01040610f, -0.06492637f, -0.05122767f, -0.01104984f, -0.02610850f, -0.01064923f, -0.03193133f, 
    0.01457243f, 0.00712785f, -0.00365648f, 0.05070000f, 0.02078190f, 0.02270757f, 0.04452008f, -0.00625479f, 
    -0.02070048f, 0.01112545f, 0.02349143f, -0.06046469f, -0.00586065f, 0.02822299f, -0.03822313f, 0.04008144f, 
    0.03321964f, 0.00302054f, 0.01206025f, -0.03410484f, 0.04197412f, -0.03662430f, -0.02207547f, -0.00564917f, 
    -0.00217975f, -0.03912170f, -0.06232520f, 0.01379757f, 0.02694818f, -0.01224202f, -0.00973104f, 0.00705968f, 
    0.02552831f, 0.03005883f, -0.05353336f, 0.04115174f, -0.01482949f, 0.01508704f, -0.05575524f, 0.05530773f, 
    -0.03827786f, 0.02631183f, 0.02996114f, -0.00693307f, -0.02382316f, 0.02010464f, -0.03755242f, -0.02489484f, 
    -0.03822200f, 0.03662932f, -0.01677220f, 0.01401670f, -0.01048116f, 0.00976813f, 0.02233378f, -0.01247373f, 
    0.02065211f, -0.04472192f, -0.00856562f, 0.00836986f, -0.00714442f, -0.00379944f, 0.01128057f, -0.01062671f, 
    -0.02956267f, -0.04266034f, -0.03322994f, -0.00562608f, -0.01159405f, 0.03469701f, -0.02150187f, -0.04931473f, 
    -0.03979424f, -0.05519482f, 0.04608679f, -0.05671510f, 0.02666832f, 0.03910385f, 0.03305650f, -0.06479450f, 
    0.01360869f, -0.06385009f, 0.01922412f, -0.01843766f, 0.02116067f, -0.03787601f, -0.03915907f, -0.06308119f, 
    -0.00038723f, -0.03330149f, 0.01625086f, -0.01271662f, -0.01660077f, 0.03187405f, -0.01249292f, -0.01700469f, 
    0.01922170f, 0.01831792f, 0.01445225f, 0.01304028f, -0.05922239f, -0.01356460f, 0.00038683f, -0.00323085f, 
    -0.02680258f, -0.04510697f, -0.06041469f, 0.00608364f, -0.04595354f, 0.02008263f, 0.03067409f, -0.05278276f, 
    -0.03558925f, 0.02176956f, -0.06488426f, -0.01435679f, -0.03408853f, -0.06044936f, -0.03891728f, -0.03655431f, 
    0.04564144f, 0.03700625f, -0.00326481f, -0.02613253f, -0.04239971f, 0.00766346f, 0.01226443f, 0.03480290f, 
    -0.02007630f, -0.04473783f, -0.04535031f, -0.03453450f, 0.04695285f, -0.01372133f, -0.04110091f, -0.05061560f, 
    -0.01833769f, -0.25431362f, -0.20336424f, -0.03954871f, -0.15559246f, -0.04883296f, 0.06598520f, -0.03510141f, 
    0.02948325f, 0.04658112f, 0.11358017f, 0.01028511f, -0.12882094f, 0.02949318f, -0.07337269f, 0.02548263f, 
    0.06351408f, 0.05739949f, -0.05259380f, 0.03703947f, -0.06469973f, 0.04978626f, 0.00984096f, -0.00546066f, 
    -0.08749389f, 0.04672849f, 0.05006675f, -0.17728582f, -0.21072799f, -0.01818703f, -0.08574095f, -0.01575911f, 
    0.11426976f, -0.04922004f, -0.02196701f, -0.03776162f, 0.01324408f, -0.01764775f, -0.20788729f, -0.08708268f, 
    0.06960388f, 0.03652506f, 0.00276891f, -0.06061336f, -0.07579097f, 0.09598185f, 0.08615822f, 0.07000643f, 
    0.04940249f, -0.20839964f, 0.02400088f, -0.06248243f, -0.11927464f, -0.05283152f, -0.20268871f, -0.04336296f, 
    0.03280481f, -0.09282047f, 0.04828419f, -0.16111818f, -0.00793662f, 0.02370184f, -0.01096852f, -0.08419721f, 
    0.13157250f, 0.06654307f, -0.09726532f, -0.12477456f, -0.03683336f, 0.05657659f, 0.01747021f, -0.12632631f, 
    0.03497088f, 0.16944270f, 0.04439261f, 0.16944274f, -0.06866506f, 0.00218606f, 0.12689292f, 0.01284763f, 
    0.11387981f, -0.09927359f, -0.07717018f, 0.13911319f, 0.08550928f, 0.05169447f, 0.09522983f, -0.03328915f, 
    -0.07017620f, 0.05665870f, 0.09067492f, 0.17990071f, 0.02987658f, 0.05105194f, 0.06453171f, -0.07169293f, 
    0.01949485f, 0.09076441f, -0.06115944f, -0.05767820f, -0.03852364f, 0.10154139f, -0.02063081f, -0.08701612f, 
    -0.08031624f, 0.06232141f, 0.05669147f, 0.03705794f, 0.17162040f, -0.31722465f, -0.08902206f, 0.05443323f, 
    0.01692513f, 0.13411888f, 0.03315703f, -0.06720562f, 0.07675778f, 0.03405183f, 0.12030564f, -0.16417275f, 
    -0.03686922f, -0.17722514f, 0.04789243f, -0.10425275f, -0.11480296f, -0.10526300f, -0.12609267f, -0.00504958f, 
    0.26012018f, 0.16172844f, -0.01981347f, -0.15600181f, 0.04574098f, -0.14788353f, -0.06286388f, 0.17586650f, 
    -0.12682948f, -0.09767339f, -0.07408587f, -0.03275789f, 0.14555864f, 0.00510917f, -0.07515717f, -0.03208778f, 
    0.14390570f, 0.07867164f, 0.04329107f, 0.03859841f, 0.04114184f, -0.04377872f, 0.15017273f, 0.05731888f, 
    0.05614645f, 0.49770835f, 0.00485288f, 0.03825227f, -0.04846293f, -0.01301324f, 0.06902493f, 0.09299068f, 
    -0.05676843f, -0.01366139f, -0.12164366f, -0.03364522f, -0.03613679f, 0.00878608f, 0.01566967f, -0.11014768f, 
    -0.08709642f, 0.08576418f, 0.04875877f, -0.13850187f, -0.21798766f, 0.00371717f, 0.02352238f, 0.05846168f, 
    -0.00869249f, -0.02035564f, 0.02589005f, 0.02534165f, -0.23739867f, 0.02610491f, -0.04015716f, 0.05806099f, 
    0.02254870f, 0.07214855f, -0.21912761f, -0.02712815f, -0.01235203f, 0.22270551f, 0.28106788f, -0.12669572f, 
    -0.01760017f, 0.10871925f, 0.04942662f, 0.00403047f, 0.09383729f, 0.04447080f, 0.15084320f, -0.29547447f, 
    -0.02809940f, 0.00648459f, 0.00204693f, -0.01810093f, -0.20086524f, -0.00658786f, -0.08154253f, 0.03661026f, 
    -0.16977149f, -0.04881117f, -0.01700013f, -0.04807301f, 0.04812665f, 0.07019322f, 0.02455579f, 0.13675712f, 
    0.32035941f, 0.01803522f, 0.01905500f, -0.09201077f, -0.03631433f, 0.08417883f, 0.11762076f, -0.03012740f, 
    -0.06845339f, 0.07580435f, 0.15027796f, -0.00085710f, 0.04391482f, 0.15068528f, 0.06167780f, 0.00973365f, 
    -0.08071283f, -0.02580662f, 0.25813028f, 0.18442026f, 0.06236982f, 0.07879162f, -0.04461258f, 0.04885410f, 
    0.16692731f, 0.00627184f, 0.01556540f, 0.00021963f, -0.00094824f, 0.03025645f, -0.05599012f, 0.06032151f, 
    -0.11629435f, 0.02399997f, -0.04442125f, 0.02554090f, -0.04456035f, -0.03546330f, -0.01702477f, 0.04558504f, 
    -0.02664445f, 0.04326380f, -0.09864612f, -0.00727532f, -0.06792960f, 0.06456772f, -0.30807436f, -0.11637966f, 
    0.00062770f, 0.04006452f, 0.02965510f, 0.00775983f, 0.01213602f, 0.10919351f, 0.14338440f, 0.10466067f, 
    -0.05282729f, -0.17098714f, 0.02547457f, 0.07784310f, -0.00074833f, 0.00795058f, -0.02492780f, 0.07734870f, 
    0.05002336f, 0.01594238f, 0.08111057f, 0.01842493f, -0.00915905f, 0.04464107f, 0.10661537f, 0.06589069f, 
    0.09463302f, 0.12638004f, -0.22720437f, -0.01754505f, 0.02699096f, 0.00039553f, 0.06322438f, 0.06914560f, 
    0.01859371f, 0.31427518f, -0.02337601f, -0.01424241f, -0.00361386f, 0.07406553f, 0.07367609f, -0.01716005f, 
    0.06342245f, -0.04107024f, 0.11183915f, -0.09091190f, 0.07290819f, -0.02315079f, -0.10266499f, -0.11735386f, 
    -0.14932473f, 0.07027902f, 0.15280463f, -0.00916531f, -0.00988948f, -0.08209614f, 0.01418486f, 0.08943272f, 
    0.04533447f, 0.05058989f, -0.04950923f, 0.04952998f, 0.05551883f, -0.03585860f, -0.10465557f, -0.01659811f, 
    0.10621762f, -0.01920791f, 0.05091039f, -0.00053818f, 0.06124930f, 0.21525946f, 0.04984127f, -0.51826715f, 
    0.07585788f, 0.06833245f, 0.10922461f, -0.02611514f, -0.08344210f, -0.06493989f, 0.16044661f, -0.06481052f, 
    -0.21957433f, 0.02608171f, 0.04352271f, -0.04866121f, 0.03864247f, 0.09260257f, 0.05960958f, 0.38818073f, 
    -0.07706621f, -0.02973856f, -0.04588214f, -0.01740825f, 0.08188668f, 0.02574957f, -0.02456813f, -0.07898746f, 
    0.26446569f, 0.09957933f, 0.04081112f, -0.18421043f, 0.03064463f, 0.02504047f, -0.08629745f, -0.08418556f, 
    -0.07440102f, 0.15238832f, 0.09482344f, -0.17632061f, -0.00999168f, 0.06238367f, -0.04867468f, -0.09018519f, 
    0.05126316f, -0.04700893f, -0.16163164f, -0.03589181f, -0.25018772f, -0.10435722f, -0.03715243f, -0.14915721f, 
    -0.06907802f, 0.00978913f, 0.03752827f, 0.12149183f, 0.11348365f, -0.00840917f, -0.05411772f, 0.00246629f, 
    -0.00481268f, 0.02738683f, 0.10023660f, 0.12999743f, -0.34288409f, 0.14567864f, -0.08227159f, 0.02303795f, 
    -0.11323635f, 0.02467823f, 0.13875037f, -0.04616646f, 0.07182801f, 0.34119794f, -0.11187148f, -0.09323522f, 
    -0.03251331f, 0.13080318f, 0.08540512f, -0.03528309f, -0.03727286f, -0.13331041f, 0.06771768f, 0.05115942f, 
    -0.05729976f, -0.03012757f, 0.05400053f, 0.02758606f, 0.02005329f, 0.02105354f, 0.07320975f, -0.23423339f, 
    0.20016438f, -0.05030144f, 0.01416990f, 0.09524360f, 0.04506326f, -0.04402643f, -0.02992852f, 0.01943082f, 
    -0.43254909f, -0.05037141f, -0.02438775f, 0.01788554f, 0.02741843f, -0.02757620f, -0.03124450f, -0.07249181f, 
    -0.01042114f, -0.02527988f, -0.23334438f, 0.04398476f, 0.02412287f, 0.15160991f, -0.01711872f, -0.07360002f, 
    -0.06660808f, -0.14830679f, 0.01763162f, 0.15149851f, -0.04419598f, -0.10705126f, -0.18879691f, 0.04218173f, 
    0.00423203f, -0.08552046f, 0.09549909f, -0.19075388f, 0.11392042f, 0.11719469f, 0.00710245f, 0.01106826f, 
    -0.06426433f, -0.03001463f, 0.03298350f, 0.14496611f, -0.13413833f, -0.15641153f, 0.14996982f, -0.03156410f, 
    0.10086224f, 0.00431659f, 0.04460339f, 0.01252893f, -0.02839179f, 0.36472496f, -0.28443378f, 0.06225521f, 
    -0.05233387f, 0.01644324f, 0.00020023f, -0.01457430f, -0.00296654f, -0.06892531f, 0.08666373f, 0.16356108f, 
    0.02106816f, 0.19788636f, 0.14585434f, 0.06652910f, -0.12277924f, -0.06270584f, -0.12059974f, -0.02391856f, 
    0.09401892f, -0.19647785f, 0.04804941f, 0.04742439f, 0.14779735f, -0.10992239f, 0.01649674f, 0.05677510f, 
    -0.15177299f, -0.06196727f, -0.02939852f, -0.06693434f, -0.00561950f, -0.04550794f, 0.01353139f, 0.07637963f, 
    -0.08852228f, -0.20114431f, 0.04671365f, -0.07767459f, 0.16656001f, -0.02248354f, 0.07185915f, 0.07144829f, 
    -0.03469694f, 0.00409929f, -0.02862387f, 0.14973029f, -0.02090788f, -0.01987977f, -0.03515359f, 0.09033102f, 
    0.02428785f, -0.03819735f, 0.00301621f, 0.08166263f, 0.03191535f, 0.06727894f, 0.00858517f, 0.05497352f, 
    0.07217570f, -0.13165824f, 0.04593865f, -0.01182427f, -0.23572958f, -0.00848988f, 0.19494507f, -0.08530910f, 
    -0.00251276f, -0.04405876f, 0.06755087f, 0.01160556f, -0.09328212f, -0.09184775f, 0.07289325f, -0.08095825f, 
    0.03301433f, 0.11723706f, 0.04720835f, -0.02117631f, -0.02752714f, 0.19027981f, -0.11264970f, -0.42562392f, 
    0.06095022f, 0.01325518f, -0.06426407f, 0.06718846f, -0.12145472f, -0.09407193f, -0.03394379f, 0.15365250f, 
    0.17012675f, 0.00652365f, -0.03736062f, 0.08078886f, -0.05752723f, 0.02760563f, -0.04918015f, -0.02303959f, 
    0.23491071f, 0.11854586f, -0.24354319f, 0.04266847f, 0.25079718f, -0.11712878f, 0.14743018f, -0.00451689f, 
    -0.02817897f, -0.04324960f, 0.06213062f, 0.02579597f, -0.01799118f, -0.05137393f, 0.00487450f, 0.10983811f, 
    0.17333192f, -0.04512378f, -0.02581948f, -0.13907050f, -0.03705354f, 0.19827536f, 0.13564566f, 0.10043523f, 
    0.08937333f, 0.02051054f, -0.06092309f, 0.24063587f, -0.14935006f, -0.30286959f, 0.12404002f, 0.16296831f, 
    -0.11114177f, 0.08082887f, 0.19438507f, 0.09990706f, 0.07304400f, 0.11531709f, -0.06781591f, -0.05772303f, 
    0.04268785f, 0.18154071f, 0.04149808f, 0.07393380f, -0.14656153f, 0.01866145f, 0.18390839f, 0.06902576f, 
    -0.11541909f, -0.08001405f, 0.02499777f, -0.08634131f, -0.07966792f, 0.17083174f, -0.18643312f, -0.00412592f, 
    -0.05021249f, 0.08652109f, 0.02651853f, -0.12159805f, -0.01839415f, -0.00477714f, 0.00242420f, -0.13970724f, 
    0.11016457f, 0.02597638f, 0.12251743f, -0.07274549f, 0.06295370f, -0.00718735f, 0.10256828f, -0.00965643f, 
    -0.20224589f, 0.06744011f, 0.15428074f, 0.08530459f, 0.05683829f, 0.05149162f, -0.18457469f, 0.01582913f, 
    0.19070123f, 0.13778023f, 0.21693356f, 0.08212915f, 0.07134687f, -0.00063823f, -0.06504446f, 0.00833394f, 
    0.01375852f, -0.03225681f, 0.11525830f, 0.02129460f, -0.02093129f, -0.04963430f, 0.11454993f, -0.00199637f, 
    0.00750155f, 0.06787244f, -0.14080121f, 0.02340143f, -0.12598249f, 0.05791300f, -0.06599941f, 0.04150134f, 
    0.05039214f, -0.04548578f, 0.03972528f, -0.02510179f, -0.01607048f, -0.15820692f, -0.06211384f, 0.05139574f, 
    0.11797098f, 0.09678867f, 0.00712362f, 0.03523109f, -0.02682109f, -0.08469740f, 0.08099064f, 0.17712507f, 
    0.03691773f, -0.03740881f, -0.18196344f, -0.00497960f, -0.10080314f, 0.11669799f, -0.28931591f, -0.16698839f, 
    -0.03126878f, 0.09918948f, 0.08164764f, 0.15274203f, 0.03810503f, 0.01426949f, -0.09632050f, -0.01045635f, 
    -0.14591603f, -0.22307509f, 0.06631589f, -0.09356127f, -0.00457139f, -0.00241642f, -0.13292651f, -0.17684986f, 
    0.13129905f, -0.01244353f, 0.15725549f, -0.09755081f, 0.08954277f, 0.03766442f, 0.01330144f, 0.15632559f, 
    0.14636183f, 0.04721295f, -0.15065968f, 0.11690117f, -0.04823140f, -0.05306751f, -0.03782352f, 0.05177291f, 
    0.06637986f, 0.18236437f, -0.23126167f, -0.02557718f, 0.02661016f, 0.08378409f, 0.05543406f, 0.18798473f, 
    -0.04541132f, -0.01864658f, -0.15293954f, -0.21074064f, -0.13443255f, -0.16137682f, -0.04412864f, 0.15030655f, 
    0.13492811f, 0.08790430f, -0.02895316f, 0.05846657f, 0.01935435f, -0.19944927f, -0.23794824f, 0.18181382f, 
    -0.12716815f, 0.00159896f, 0.01705086f, -0.10367626f, -0.16574755f, -0.14487050f, 0.03617222f, 0.00582147f, 
    0.30003193f, -0.11913281f, 0.03234684f, -0.14670512f, 0.01953762f, 0.03399016f, 0.23136730f, 0.17320557f, 
    -0.09388617f, 0.06841920f, -0.20195885f, -0.07784347f, 0.05347194f, 0.00759010f, 0.08037319f, -0.10060922f, 
    -0.03999133f, -0.19552383f, 0.08175934f, 0.11061638f, 0.00887042f, -0.03018489f, 0.05225921f, -0.13802376f, 
    0.09615060f, -0.11707663f, 0.13197555f, 0.05134091f, 0.02443633f, 0.06336293f, 0.16772731f, -0.09737537f, 
    -0.14262600f, -0.02177830f, 0.11085088f, 0.00454738f, 0.01003915f, 0.04450526f, 0.09795570f, -0.03017394f, 
    0.09943009f, 0.02776656f, 0.10363807f, -0.02878922f, 0.15614839f, 0.04752854f, 0.06175013f, -0.03253315f, 
    -0.12623098f, -0.02629601f, 0.19223823f, -0.05783045f, 0.05210179f, 0.09699725f, -0.00549189f, -0.07666310f, 
    -0.06686313f, -0.04740495f, 0.10005458f, -0.04758681f, 0.11999246f, 0.06427193f, -0.16840747f, 0.14916505f, 
    0.07176502f, 0.02149918f, -0.07327136f, -0.06404501f, -0.10407671f, 0.16404574f, -0.12035733f, -0.16261539f, 
    0.20658879f, 0.08812238f, -0.08452344f, 0.10606540f, 0.08390965f, 0.01514958f, 0.05835028f, -0.08428021f, 
    0.14143376f, 0.03928518f, 0.07683504f, 0.12376901f, 0.12084392f, 0.08227302f, -0.06018873f, -0.19030137f, 
    -0.01885564f, 0.21950497f, 0.06458464f, 0.02044716f, 0.01925715f, -0.03635575f, 0.03058582f, 0.10947783f, 
    -0.03466412f, -0.05668954f, 0.02014092f, 0.02415693f, -0.05013646f, 0.01883273f, 0.01630807f, -0.05909289f, 
    -0.06327346f, -0.04932591f, -0.05600788f, 0.04697836f, -0.03019707f, 0.04116687f, -0.01793891f, -0.04018345f, 
    0.04371638f, 0.02429712f, 0.02011833f, -0.05066465f, 0.01729510f, -0.00721272f, 0.00687165f, -0.05100372f, 
    0.03953796f, 0.04283513f, -0.00200462f, -0.04049860f, -0.03412149f, 0.01809032f, -0.02039466f, 0.04986668f, 
    -0.00064840f, 0.01957091f, 0.00654293f, 0.02225485f, -0.03660462f, -0.05981271f, -0.04011171f, -0.04745720f, 
    0.04991358f, -0.06257007f, -0.00908345f, -0.01555780f, 0.03969411f, 0.02912831f, 0.01963438f, 0.03924021f, 
    0.05663855f, -0.04711415f, 0.04600132f, -0.00397060f, 0.03269056f, -0.06476633f, -0.06227239f, 0.00797868f, 
    0.02243227f, -0.02395186f, 0.05388942f, 0.01591793f, -0.00418542f, -0.01474356f, -0.00354884f, -0.03641930f, 
    -0.04456589f, -0.05886700f, 0.00675237f, 0.00457765f, 0.04880326f, -0.03698840f, -0.02487759f, -0.04945707f, 
    -0.05216338f, -0.00983830f, -0.05377016f, -0.00433657f, 0.05350998f, 0.04375636f, -0.06255690f, -0.00988033f, 
    0.02691010f, -0.00694717f, -0.03769754f, -0.02519952f, -0.01554923f, 0.00024733f, 0.04507043f, -0.00488705f, 
    -0.03380698f, -0.04257468f, -0.03263745f, 0.01529618f, 0.00483495f, -0.02813777f, -0.05190866f, -0.00024765f, 
    0.01042802f, -0.06243985f, -0.05205430f, 0.00909534f, -0.01312290f, 0.00011849f, -0.05723339f, -0.06300517f, 
    0.04829929f, -0.05014711f, 0.00993624f, -0.00536212f, -0.05664169f, 0.00838176f, 0.00003618f, 0.02542949f, 
    -0.02670275f, -0.01145140f, 0.03960662f, -0.06646002f, 0.04499484f, 0.04807357f, -0.01310759f, -0.05858049f, 
    0.02690999f, 0.00112854f, -0.01241861f, 0.02958001f, -0.03223961f, -0.01546644f, -0.01703075f, 0.04819568f, 
    0.03848089f, -0.00377874f, -0.04901706f, 0.04555529f, 0.04718452f, -0.00535129f, -0.02346660f, 0.00104944f, 
    0.00358832f, 0.02359128f, -0.03945508f, -0.01744823f, -0.05633538f, -0.01459751f, -0.05969521f, -0.02153235f, 
    0.04805806f, 0.01093944f, -0.04403269f, 0.04561185f, -0.01015966f, -0.05954904f, 0.01560867f, -0.03120795f, 
    -0.03494884f, -0.00977860f, 0.05721595f, -0.04841187f, -0.04786897f, -0.05068432f, 0.03907784f, 0.03607333f, 
    0.05193320f, -0.02945843f, -0.00341587f, -0.00441473f, 0.02527702f, -0.00386323f, -0.03453318f, 0.02907819f, 
    -0.00543855f, 0.00435028f, -0.05442119f, 0.02527900f, 0.02404911f, 0.00436979f, -0.04646780f, 0.00225786f, 
    0.04560453f, 0.00025205f, 0.00591744f, -0.03327849f, 0.04354334f, -0.04509529f, -0.00984984f, -0.00977065f, 
    -0.03409583f, 0.01190776f, -0.03908652f, -0.02530785f, -0.03466231f, -0.04827170f, -0.03812854f, 0.01834509f, 
    -0.00614729f, -0.05080366f, -0.06844243f, 0.02182591f, -0.04308273f, 0.03152640f, -0.06055912f, -0.01684605f, 
    -0.00826511f, 0.02099862f, -0.00652531f, -0.02072427f, 0.04402496f, 0.01341205f, -0.02018311f, 0.02775895f, 
    -0.02429317f, 0.04207904f, -0.05666292f, -0.03464596f, -0.05751932f, -0.05838512f, 0.04324738f, 0.04698220f, 
    -0.03505205f, 0.05033344f, 0.01454807f, -0.03347534f, -0.01002555f, 0.04525042f, -0.00003671f, -0.01138280f, 
    0.03848243f, -0.02365162f, 0.02694447f, -0.01082794f, 0.03478547f, -0.05863651f, -0.01884371f, 0.00592701f, 
    0.02328604f, 0.02447302f, 0.03879274f, 0.05349387f, 0.02686030f, 0.01022587f, 0.02747300f, 0.01275363f, 
    0.03706899f, -0.01382952f, 0.03630392f, 0.01545432f, 0.01282257f, -0.04624137f, 0.04973826f, 0.03761373f, 
    -0.03153614f, 0.04613444f, 0.00929829f, -0.03135761f, -0.03722031f, -0.01107372f, -0.02793835f, -0.01977662f, 
    0.01818543f, -0.04952396f, -0.06546192f, 0.01309041f, -0.02096060f, -0.03339741f, 0.02118602f, -0.05417026f, 
    -0.03270509f, 0.00078686f, -0.00672826f, 0.03910177f, -0.02715483f, 0.00156133f, -0.05467362f, -0.02946367f, 
    0.03617414f, -0.03129353f, -0.06211390f, 0.03257178f, 0.02714540f, 0.03821894f, -0.03335075f, 0.00703774f, 
    -0.01262460f, -0.03373957f, -0.04652535f, -0.02578996f, -0.03626823f, -0.01939352f, -0.03975866f, -0.05573263f, 
    0.03109589f, 0.02297789f, 0.03934393f, -0.02503031f, -0.02299104f, 0.03916559f, -0.01001961f, 0.03574110f, 
    -0.04106826f, -0.01805054f, -0.03102239f, -0.06008475f, -0.04460744f, 0.01043566f, -0.03280650f, 0.00778275f, 
    0.00184218f, -0.04611012f, 0.00239988f, 0.02967571f, -0.05743068f, -0.05954186f, 0.00529314f, -0.03348047f, 
    0.03943108f, -0.05398121f, 0.01737802f, 0.01439689f, 0.03279217f, -0.04225730f, -0.02560258f, 0.04751156f, 
    -0.02275534f, -0.02971368f, 0.04077908f, 0.03520035f, 0.01678047f, 0.00519691f, -0.04490647f, 0.00760262f, 
    -0.05716901f, 0.03906491f, 0.00158894f, -0.00706896f, -0.03519911f, 0.03664030f, 0.03067850f, 0.00226042f, 
    -0.04420174f, -0.00657834f, -0.03869955f, -0.04581813f, 0.03117295f, -0.05408718f, -0.06193009f, 0.05023233f, 
    0.02100891f, 0.00829314f, 0.00412395f, -0.04241517f, 0.02123384f, 0.04960917f, 0.03675348f, 0.04743873f, 
    0.01950421f, -0.06395905f, -0.06210690f, -0.04096335f, -0.02966228f, -0.05379261f, 0.01700995f, 0.02733571f, 
    0.03461250f, -0.02577842f, -0.05054090f, 0.04429579f, 0.03705734f, -0.01212581f, 0.02717831f, 0.02020534f, 
    0.02781139f, -0.00985696f, 0.03982414f, -0.00948626f, -0.06207469f, 0.02249511f, 0.00649099f, 0.01709037f, 
    -0.04275642f, 0.01772138f, -0.05228921f, 0.01093068f, -0.01788009f, -0.04832445f, -0.02810132f, -0.02071987f, 
    -0.00488053f, -0.01822757f, 0.01000240f, 0.01989266f, -0.01070297f, -0.05641577f, -0.01223242f, -0.06134351f, 
    -0.04348099f, -0.04875863f, -0.05716704f, -0.05466994f, -0.03958279f, -0.03200058f, -0.04242688f, -0.01034500f, 
    0.00271607f, 0.01499916f, 0.04469030f, -0.03140092f, 0.03393210f, 0.04790903f, -0.04388819f, 0.02780111f, 
    0.04772118f, 0.01759844f, 0.02196215f, -0.03080632f, -0.03407364f, -0.01701210f, -0.02685076f, -0.03008115f, 
    -0.01901641f, -0.02870493f, -0.03505155f, 0.03828237f, 0.03069569f, 0.03421088f, -0.01037766f, 0.02433427f, 
    0.03475571f, 0.04814694f, -0.05116500f, -0.03290335f, 0.05274389f, -0.05689606f, 0.03729858f, 0.02469364f, 
    -0.03378184f, -0.02035038f, 0.06051921f, -0.04243976f, 0.02603782f, -0.04075048f, -0.04841118f, -0.02761426f, 
    -0.03471949f, -0.00895546f, -0.03845801f, 0.00944706f, -0.01229238f, 0.03506381f, -0.04856216f, 0.01074080f, 
    0.04215605f, 0.03564398f, -0.00171951f, 0.02767098f, 0.00895524f, -0.05946794f, -0.04629039f, 0.02673445f, 
    -0.04327727f, 0.01053162f, -0.01885840f, 0.02199239f, 0.04019205f, 0.00762335f, -0.02052702f, -0.04149112f, 
    -0.01671500f, 0.04776023f, -0.06017585f, -0.02168193f, 0.02699695f, 0.05034146f, 0.02860004f, -0.02537301f, 
    -0.02827369f, -0.05085987f, 0.03179016f, -0.05318210f, -0.01850685f, -0.00916303f, -0.06355324f, -0.06433754f, 
    0.05583856f, 0.00357642f, 0.00312044f, -0.03900931f, 0.02614604f, -0.01125131f, -0.02862976f, 0.02018061f, 
    0.02081238f, 0.00806538f, -0.02777674f, 0.02388364f, 0.02254999f, 0.01699239f, 0.02924652f, -0.04161996f, 
    -0.04298990f, 0.02244564f, -0.02955250f, -0.04003979f, 0.04228839f, -0.05547461f, -0.03768553f, 0.02095615f, 
    0.05698463f, 0.00518248f, 0.02963553f, -0.00252571f, -0.04629024f, 0.03471616f, -0.05613841f, 0.04092498f, 
    0.03169227f, 0.00067454f, -0.05967143f, 0.02285185f, 0.03050484f, 0.04529124f, -0.04857411f, -0.00389145f, 
    0.01244423f, -0.03274417f, -0.05009028f, 0.03339647f, -0.03519297f, -0.01082415f, -0.01912443f, -0.00575718f, 
    0.00261108f, -0.05993232f, 0.02969550f, -0.03724372f, -0.05444770f, 0.02800618f, 0.00781810f, -0.02085115f, 
    -0.02141837f, -0.05432511f, -0.03418584f, -0.02213416f, -0.01186635f, 0.05313879f, 0.01085338f, -0.06043108f, 
    -0.02232063f, -0.06106638f, -0.05252652f, -0.01046657f, 0.04513083f, -0.00754851f, -0.05679280f, -0.02865921f, 
    -0.04372010f, 0.05077082f, 0.00123446f, 0.06294420f, 0.01618239f, -0.03271194f, -0.00059594f, 0.00646115f, 
    0.05106330f, -0.00113856f, -0.06434333f, -0.00362962f, -0.03067490f, 0.00370036f, -0.05028439f, -0.05126507f, 
    -0.00445835f, -0.00807261f, -0.04642866f, 0.02099866f, -0.05026567f, 0.04679917f, -0.03264144f, 0.00132425f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.00714293f, 0.05018245f, -0.03990551f, 0.01088461f, 0.13506557f, 0.01038874f, -0.00689680f, 0.04614659f, 
    0.02721193f, -0.05774543f, -0.00231464f, 0.16654798f, 0.01289410f, 0.06941688f, -0.03541867f, -0.03599197f, 
    0.06384269f, 0.05723933f, 0.02738564f, 0.03560400f, 0.04382396f, 0.02143308f, 0.17927161f, -0.01274253f, 
    0.05219004f, 0.01839761f, -0.01037004f, 0.03418874f, 0.08054538f, 0.06037262f, 0.04418161f, 0.02722302f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.27765936f, 0.20038918f, -0.17280681f, -0.31632844f, -0.25277263f, 0.09808560f, -0.00358958f, 0.37186989f, 
    -0.14192028f, 0.12611286f, -0.13580133f, -0.16252357f, 0.19653198f, 0.08405842f, 0.03509905f, -0.08848535f, 
    0.27421120f, 0.12060924f, 0.09522171f, -0.12787047f, 0.17765185f, -0.09762948f, 0.10510018f, 0.16541146f, 
    0.10247766f, -0.21544380f, -0.06755970f, 0.01236218f, -0.30425352f, 0.22493014f, -0.03449250f, 0.01838859f, 
    0.42315733f, 0.40268654f, -0.09922040f, 0.26582778f, 0.42801976f, -0.05165275f, -0.10894591f, 0.26163504f, 
    -0.11161361f, -0.10844681f, 0.02469445f, 0.20284924f, -0.10976270f, -0.31175339f, 0.16107292f, -0.07979126f, 
    -0.08422402f, 0.14078774f, 0.01267233f, 0.12973642f, 0.09843639f, -0.01347147f, -0.39810753f, -0.11153815f, 
    0.04469939f, 0.13473536f, -0.06006428f, 0.09559690f, -0.06310698f, 0.03670892f, 0.02145237f, 0.01954604f, 
    -0.15534246f, 0.19627579f, -0.09629004f, 0.00595566f, -0.26756239f, 0.04161685f, -0.13182066f, 0.43972129f, 
    0.11369155f, 0.16248012f, -0.08798289f, -0.02522536f, 0.13436215f, -0.24712054f, 0.15252720f, 0.08038057f, 
    0.16539553f, 0.21667778f, 0.01643361f, -0.01882257f, -0.07864231f, 0.08675555f, 0.11374552f, -0.16629298f, 
    0.13935512f, -0.13740200f, -0.00543656f, -0.34877440f, 0.15669228f, 0.21307614f, -0.01955399f, 0.16897635f, 
    0.20182844f, -0.07621350f, -0.23403046f, -0.30915284f, 0.15182391f, 0.12885168f, 0.12929392f, 0.12246810f, 
    -0.06732178f, 0.01459186f, 0.02614659f, -0.34435961f, -0.08373933f, 0.22554249f, 0.00321420f, -0.08182197f, 
    0.13234206f, -0.21330465f, 0.04490579f, -0.17796987f, -0.01180126f, -0.11832942f, -0.10080632f, 0.09446213f, 
    0.15782592f, -0.07952540f, -0.04249416f, 0.24767852f, 0.06681130f, 0.03316104f, 0.01991327f, -0.10318100f, 
    -0.09740293f, -0.08711335f, 0.02708226f, 0.16990280f, -0.11726537f, 0.01159007f, 0.10442242f, -0.15321259f, 
    0.05037865f, -0.00620536f, 0.16516998f, -0.09020483f, -0.16401885f, 0.05452693f, -0.02588750f, 0.00293170f, 
    -0.01713953f, -0.17775302f, 0.08464648f, 0.09351226f, 0.02804637f, -0.00840965f, 0.00785414f, -0.10975860f, 
    -0.08002049f, 0.00300855f, 0.11136788f, -0.06194363f, 0.09228730f, -0.16466624f, 0.07396678f, 0.02800656f, 
    0.33027110f, 0.38583577f, -0.18992129f, 0.26168624f, 0.22469503f, 0.05037689f, -0.08735882f, 0.20601872f, 
    -0.20783174f, -0.14790590f, -0.04342914f, 0.23133540f, -0.22669682f, -0.11277149f, 0.17430919f, -0.16486274f, 
    -0.04684011f, -0.18816566f, 0.11688951f, -0.06759864f, -0.00536734f, -0.03054923f, -0.07654724f, 0.00851269f, 
    0.23944604f, 0.00568152f, -0.06684626f, -0.25165051f, 0.07872435f, 0.07073384f, 0.14159687f, 0.15624726f, 
    -0.33854184f, -0.02896538f, -0.01489773f, -0.31782910f, 0.17084301f, 0.10109551f, 0.14562467f, 0.00377142f, 
    0.25326675f, -0.00083047f, 0.01299257f, -0.08980480f, -0.20090847f, 0.17618109f, 0.11869689f, 0.05369730f, 
    0.10259311f, -0.25352189f, -0.14659773f, -0.18100756f, 0.06796301f, 0.16200681f, 0.29624030f, 0.05295931f, 
    -0.14455502f, 0.20739342f, 0.14545391f, 0.23182876f, 0.24611044f, 0.15911740f, 0.02896799f, 0.09570433f, 
    0.26149264f, -0.24985746f, -0.38043365f, 0.37733245f, 0.09553307f, -0.03636277f, -0.13112797f, 0.00228835f, 
    0.05664792f, 0.12532496f, 0.01897219f, -0.13116081f, 0.27907395f, 0.27778596f, -0.02812569f, -0.08415396f, 
    0.18144780f, -0.30786049f, -0.13127163f, 0.11494201f, 0.16897428f, -0.12613893f, 0.11431295f, -0.12649810f, 
    0.17165433f, 0.22457218f, 0.11070286f, -0.11104295f, 0.19998474f, -0.12779628f, 0.08471029f, -0.02451281f, 
    0.00191286f, 0.13396078f, -0.17302501f, 0.13389340f, -0.07398901f, 0.08856560f, 0.10878384f, 0.10833487f, 
    0.08031969f, -0.17526755f, -0.01100170f, -0.01310287f, -0.16120163f, -0.06963997f, -0.02865927f, 0.09904312f, 
    -0.15865850f, -0.11025874f, 0.16877383f, -0.08873037f, -0.15604772f, -0.05912375f, -0.16276935f, 0.00639999f, 
    -0.14346500f, -0.03204443f, 0.07045384f, -0.06449740f, 0.05504301f, -0.09103683f, 0.18402824f, -0.14472692f, 
    0.08966426f, -0.13657387f, 0.14948180f, -0.01459535f, 0.42625299f, -0.07506017f, 0.07461352f, -0.04627211f, 
    0.35204294f, 0.15394516f, -0.14217870f, -0.14052980f, 0.33313549f, -0.15975925f, 0.15339279f, -0.16956164f, 
    -0.01118253f, -0.13653328f, 0.06792666f, 0.14850326f, -0.06003343f, 0.03042740f, 0.04581554f, 0.18143485f, 
    -0.00196868f, 0.08369742f, -0.14446016f, 0.23388694f, 0.08589062f, -0.09685474f, -0.14492682f, 0.11058178f, 
    0.07374556f, -0.05670916f, 0.08989227f, 0.14741895f, 0.33469647f, -0.13017394f, -0.12389459f, -0.13338362f, 
    0.15909378f, 0.10688009f, 0.10228227f, 0.14169127f, -0.22278652f, -0.37062010f, 0.03030950f, 0.04933606f, 
    -0.11264798f, -0.27835655f, 0.16262515f, -0.07891046f, 0.15397125f, 0.16764612f, -0.00596966f, 0.16953257f, 
    -0.11096517f, -0.03197068f, -0.15640076f, -0.18923892f, 0.15286793f, 0.14800027f, -0.15928626f, 0.04914897f, 
    0.26532370f, 0.17053792f, 0.38797194f, 0.46930328f, 0.41661251f, 0.05268717f, 0.14117134f, -0.06720584f, 
    -0.00966372f, -0.00925571f, -0.08605360f, -0.16878341f, -0.19555098f, -0.14330488f, 0.13376741f, -0.13473341f, 
    0.14232254f, 0.27338743f, 0.14524874f, 0.01340796f, 0.02059208f, 0.13524127f, -0.00888586f, 0.06435102f, 
    -0.15289524f, 0.04972325f, -0.15418553f, -0.20649062f, 0.36160079f, 0.06408641f, 0.06705539f, -0.00737790f, 
    -0.35907954f, -0.23335372f, 0.20455292f, -0.20245788f, -0.26902032f, 0.11201047f, 0.13482687f, -0.20540486f, 
    0.07024044f, -0.05294172f, 0.06232298f, 0.27150187f, -0.19380653f, -0.21557787f, 0.11426757f, 0.09912129f, 
    0.03411584f, 0.10705006f, 0.13596888f, 0.15233529f, 0.02344405f, 0.16493210f, 0.18702015f, 0.03692364f, 
    0.18463355f, 0.36363474f, 0.05875955f, 0.13815312f, -0.21741740f, 0.23012932f, -0.15769117f, 0.10266414f, 
    0.05530889f, -0.20763400f, -0.21915324f, 0.29898608f, -0.15025638f, -0.08445664f, -0.12699591f, 0.03795971f, 
    -0.06163491f, -0.04943728f, -0.17176935f, 0.02728647f, 0.05133522f, -0.21472047f, -0.17441401f, -0.02839321f, 
    -0.06170791f, 0.10276194f, -0.07638013f, -0.12128996f, 0.03987207f, 0.14428473f, -0.00277335f, -0.14795272f, 
    0.04641797f, 0.38481608f, -0.01492364f, 0.21935898f, 0.09876131f, -0.11608222f, 0.02421264f, 0.00097825f, 
    0.38575950f, -0.17489569f, 0.00733797f, 0.11200647f, 0.16401607f, 0.02150187f, 0.15290235f, -0.12774727f, 
    0.40202317f, 0.09719715f, -0.02439530f, -0.31191400f, 0.46268162f, -0.22056736f, -0.16041248f, 0.01100962f, 
    -0.50956053f, 0.07941408f, -0.17454101f, -0.11808789f, -0.07738109f, 0.02851467f, -0.16504142f, -0.03338064f, 
    0.33395272f, -0.24643402f, -0.14005205f, 0.34562585f, 0.02915115f, 0.08594665f, -0.12117206f, -0.11222414f, 
    -0.18397048f, 0.01282724f, -0.40849164f, -0.29902261f, -0.03891282f, -0.02482092f, 0.15884891f, 0.35153463f, 
    -0.08027871f, 0.17270271f, 0.02205037f, -0.00958532f, 0.25441894f, 0.15176339f, 0.09340864f, -0.02350008f, 
    0.25793883f, 0.27653083f, -0.09947755f, -0.13176762f, -0.13497257f, -0.01459715f, 0.09204830f, -0.08600716f, 
    0.07215545f, -0.27642581f, -0.07392488f, -0.17225292f, -0.13441099f, 0.22911878f, -0.06211676f, 0.09539777f, 
    0.35334906f, 0.21525057f, 0.14257857f, 0.37438071f, 0.30020696f, -0.12132304f, -0.04749488f, 0.23377816f, 
    -0.12054386f, 0.08443285f, 0.08050054f, 0.19354375f, -0.16568215f, -0.20410304f, 0.12404075f, -0.16413943f, 
    0.21067771f, 0.32704750f, 0.06515907f, -0.07096912f, 0.16485828f, 0.01113707f, 0.01051634f, 0.10442282f, 
    -0.15246196f, 0.13454926f, 0.11868263f, -0.28717473f, 0.24664995f, -0.23943575f, -0.12490132f, 0.07987168f, 
    0.35042819f, 0.24339879f, -0.09982490f, 0.18989423f, 0.23228535f, 0.16091371f, 0.05212602f, -0.23454840f, 
    0.00433404f, 0.15905285f, -0.02134700f, 0.26471737f, -0.32453522f, 0.20226495f, -0.09685127f, 0.06103173f, 
    -0.10087460f, 0.09275851f, -0.07388013f, 0.10083029f, -0.05118230f, -0.15177150f, -0.15717974f, -0.07634908f, 
    0.03629883f, -0.03170944f, -0.10991775f, -0.31825384f, -0.01633366f, 0.18013573f, -0.05712069f, -0.01572695f, 
    0.19665284f, 0.20013097f, -0.02935030f, -0.21857139f, 0.27189848f, -0.04265092f, -0.16701877f, -0.10130029f, 
    0.24476148f, 0.00190911f, -0.05488591f, 0.39241415f, -0.31173313f, 0.24133584f, 0.14710234f, -0.04300652f, 
    -0.24082379f, 0.25016645f, 0.01160180f, 0.01192297f, -0.14217561f, -0.04359162f, 0.01427878f, 0.16442059f, 
    -0.12158039f, 0.09439813f, -0.04810674f, 0.24023096f, -0.20278373f, 0.13719049f, -0.10450678f, -0.15223233f, 
    -0.04930108f, -0.21252558f, -0.29269454f, 0.25292084f, 0.12321492f, -0.03544084f, 0.10946142f, 0.02124912f, 
    0.00947277f, -0.12091471f, -0.13986538f, -0.11739022f, 0.42597130f, 0.20045969f, 0.02723940f, 0.01647789f, 
    0.41444027f, 0.31707028f, -0.12827671f, -0.00136479f, -0.14692725f, -0.05332838f, -0.03566260f, 0.05998960f, 
    0.16524874f, -0.11238923f, -0.14379007f, -0.12941444f, -0.28069162f, -0.10555522f, -0.04566605f, -0.00454783f, 
    -0.30666128f, -0.04974234f, -0.04119068f, -0.47204468f, 0.11669672f, 0.08688404f, 0.04007828f, 0.01500247f, 
    0.19380790f, -0.07086539f, 0.06804015f, -0.03787393f, -0.09452727f, -0.08910209f, -0.05191679f, -0.03974045f, 
    -0.35179490f, 0.21390085f, 0.09699034f, -0.01866758f, -0.00243995f, -0.10508219f, 0.30577397f, -0.17986596f, 
    0.25312570f, -0.02545778f, 0.07879665f, 0.33948511f, -0.10851025f, -0.07438108f, -0.17068711f, 0.03867128f, 
    0.25725520f, -0.15868077f, 0.35894388f, 0.37808350f, -0.07722126f, 0.16398191f, 0.13679558f, 0.08819686f, 
    -0.43801925f, -0.00215361f, 0.12577167f, -0.06471922f, 0.05505113f, 0.32342583f, -0.07794937f, -0.02871635f, 
    -0.04394777f, -0.39005002f, 0.13049452f, -0.09293626f, -0.07522206f, -0.08614326f, -0.14938748f, -0.09802391f, 
    0.24062294f, -0.20449942f, 0.16741128f, 0.09110071f, -0.03421111f, -0.09897517f, 0.00394041f, 0.05764724f, 
    -0.17679390f, -0.15269077f, 0.28405541f, -0.15930155f, 0.06996755f, -0.06858076f, -0.00423135f, -0.09544032f, 
    0.26721275f, 0.05764351f, -0.12911905f, 0.15588161f, -0.09826820f, 0.09904380f, -0.00628329f, -0.12515117f, 
    -0.41594616f, 0.30150005f, 0.07880732f, 0.15596992f, 0.14732639f, 0.11297493f, 0.36289787f, 0.16473399f, 
    -0.03805807f, -0.06780607f, 0.03563392f, 0.34557652f, -0.29916215f, -0.16220666f, 0.14681238f, 0.08067769f, 
    -0.16735111f, -0.26164138f, 0.02774749f, -0.43289512f, 0.22178565f, -0.01555564f, -0.07352432f, -0.13084713f, 
    0.33310950f, 0.05312140f, 0.15229061f, -0.05692475f, 0.16669093f, -0.23396149f, -0.02296966f, 0.01104396f, 
    0.03995654f, 0.24552104f, 0.00931031f, 0.13444497f, 0.15777743f, -0.04736115f, 0.08356928f, 0.11949522f, 
    0.27347982f, 0.07196538f, 0.14210504f, 0.03495112f, -0.02416365f, -0.02431431f, 0.01816474f, -0.05113652f, 
    0.01574011f, 0.36038148f, -0.22078907f, -0.01826041f, 0.18846667f, -0.13776964f, 0.05445042f, 0.42720008f, 
    -0.11801867f, 0.01268617f, 0.16757657f, 0.17263201f, -0.18389393f, -0.11378620f, -0.15038159f, 0.10657504f, 
    0.45524511f, -0.09548727f, -0.09544612f, -0.04682072f, 0.09741473f, 0.04163722f, -0.09765361f, -0.09972347f, 
    0.06622934f, -0.12791896f, 0.16358383f, -0.20802577f, 0.04168063f, 0.23160496f, 0.08674460f, 0.02599963f, 
    -0.32850549f, -0.31595951f, 0.34334621f, 0.15167467f, 0.10478038f, 0.09272600f, -0.13830565f, -0.07838409f, 
    0.06960473f, 0.02629063f, -0.18057489f, -0.07891372f, 0.09242455f, -0.34803170f, -0.17531918f, 0.06123970f, 
    0.16788012f, 0.42732745f, -0.16508153f, 0.10292681f, -0.00149515f, -0.17673910f, 0.14794068f, 0.12189684f, 
    0.16256897f, 0.09803053f, -0.11930130f, -0.39518261f, 0.44182652f, -0.02864884f, 0.14296757f, -0.08096959f, 
    0.32997093f, 0.26996711f, -0.06038112f, 0.18314549f, -0.22021762f, 0.13892742f, -0.03799427f, -0.22875537f, 
    -0.21596359f, -0.12351695f, 0.00535080f, 0.40689960f, 0.24217708f, -0.36185780f, -0.08239592f, 0.15002528f, 
    0.01603648f, 0.25269911f, -0.09529094f, -0.08235415f, 0.14112961f, 0.18401305f, -0.26213866f, -0.10941111f, 
    0.03008606f, 0.48975173f, -0.08600342f, 0.16667818f, 0.34181660f, 0.21787761f, -0.05150516f, -0.16757986f, 
    -0.09400301f, -0.10504124f, -0.12403432f, 0.08755105f, 0.02598012f, 0.04723235f, -0.01647244f, 0.03164057f, 
    -0.10932761f, 0.00343364f, -0.06693290f, -0.18499157f, -0.05724349f, -0.11177458f, -0.13335130f, -0.05865655f, 
    -0.15798698f, 0.02115875f, 0.06786154f, -0.14536890f, 0.09538158f, -0.10923464f, 0.12737343f, -0.13153949f, 
    -0.07921704f, -0.18363270f, -0.17627673f, -0.02835632f, -0.09839358f, -0.03713561f, 0.10515339f, 0.16008839f, 
    0.22467116f, 0.14101952f, -0.08189718f, 0.16428904f, 0.24623348f, -0.13122141f, 0.09024255f, -0.02773991f, 
    -0.05689285f, 0.12513770f, 0.12379380f, 0.32430136f, 0.07931702f, -0.30865851f, 0.08929908f, 0.07106917f, 
    0.21621093f, -0.17368063f, -0.07840828f, -0.06989366f, -0.01320473f, -0.06426013f, 0.01618522f, 0.14877705f, 
    0.15438136f, 0.35739902f, 0.10488932f, -0.27176952f, 0.43265048f, -0.21311587f, -0.09647912f, -0.04188537f, 
    0.29043907f, 0.17050773f, -0.06391012f, 0.06753309f, -0.11575707f, 0.14618942f, 0.05166901f, -0.03151054f, 
    -0.03108703f, 0.17436019f, 0.02832942f, -0.13577068f, -0.13625759f, 0.21126510f, -0.01116838f, 0.09140638f, 
    -0.58232528f, -0.20914884f, 0.15524696f, 0.04505396f, 0.05578381f, -0.02793261f, 0.29594484f, 0.15062569f, 
    0.32289347f, 0.13447015f, 0.05159840f, 0.04736707f, 0.16158526f, 0.07855708f, -0.00905106f, 0.05759548f, 
    -0.05053389f, 0.05761407f, 0.00786327f, -0.17627862f, 0.05554938f, 0.09464329f, -0.11848227f, 0.05919970f, 
    -0.14994110f, 0.01226227f, -0.05733263f, -0.05470268f, -0.13659418f, 0.04638430f, -0.03783145f, 0.08116440f, 
    -0.01411383f, 0.04097410f, 0.16298690f, -0.05882282f, 0.08488059f, -0.06418449f, -0.11507757f, 0.03269399f, 
    -0.00236062f, -0.16799055f, 0.09515652f, -0.12459818f, -0.17419165f, -0.11164943f, 0.03594799f, -0.04885915f, 
    -0.41401410f, -0.17345670f, 0.23741560f, -0.23916575f, -0.16541649f, 0.02719155f, -0.03439517f, -0.08430873f, 
    0.18387109f, -0.06402056f, -0.08967458f, 0.07152667f, 0.12723668f, -0.49768934f, -0.00557930f, 0.02424686f, 
    -0.27357203f, 0.07284143f, -0.00087527f, -0.02088116f, -0.07126018f, 0.06792446f, 0.12225407f, -0.07106234f, 
    0.18420631f, 0.35263041f, -0.07395352f, -0.11312703f, 0.28665620f, 0.25960812f, 0.00065794f, -0.08083580f, 
    -0.19368991f, -0.14394833f, 0.15616961f, -0.25621668f, 0.38685966f, 0.11205490f, -0.12436048f, -0.22289357f, 
    0.30994105f, -0.13984075f, 0.14980882f, 0.28245234f, -0.08623394f, 0.13625963f, 0.07539646f, 0.06726814f, 
    0.24807155f, -0.02947599f, -0.00150007f, 0.01069379f, -0.01615455f, 0.15253498f, -0.07964924f, 0.10197550f, 
    -0.02361447f, 0.29063228f, 0.00460661f, 0.33077347f, -0.19240330f, 0.13924159f, -0.05115267f, -0.11809401f, 
    -0.20331939f, 0.02665246f, 0.29069263f, 0.02682515f, 0.23652118f, -0.14698102f, 0.11031839f, -0.11150695f, 
    0.20186119f, -0.17149423f, 0.03530398f, 0.20310234f, -0.03209030f, -0.28200036f, 0.00512469f, 0.05735531f, 
    -0.07518573f, 0.04045806f, 0.17615023f, -0.12826884f, 0.17013675f, -0.01183731f, -0.06537536f, 0.11155424f, 
    -0.09822383f, 0.20820822f, -0.15366991f, 0.30713332f, -0.12589200f, 0.30485803f, 0.05303539f, -0.14697821f, 
    0.09713301f, -0.05137780f, -0.15848452f, -0.15276833f, -0.11439306f, 0.13234900f, 0.14137001f, -0.07857447f, 
    -0.07416410f, -0.15001477f, 0.05236236f, -0.13443775f, 0.08533970f, 0.07309240f, 0.11360839f, 0.08357870f, 
    -0.02955887f, -0.08690075f, -0.17521796f, -0.01768785f, 0.03795201f, 0.11110805f, 0.03940056f, 0.04908919f, 
    -0.12515923f, 0.00337246f, -0.11720014f, -0.18212053f, 0.00322446f, 0.04977185f, -0.02209334f, 0.12660715f, 
    -0.07477602f, -0.26617658f, -0.15080728f, 0.03371006f, -0.21603392f, -0.14663123f, -0.11845689f, -0.45744020f, 
    -0.12302595f, -0.14892037f, -0.17453876f, -0.02014880f, 0.01680478f, -0.24645743f, 0.16490115f, -0.17335545f, 
    -0.12469861f, 0.05003665f, -0.05340301f, 0.13750906f, 0.06599378f, -0.11162311f, 0.06920045f, -0.05261818f, 
    0.02435749f, 0.31068406f, 0.16712584f, 0.24901740f, 0.06063889f, 0.34492907f, 0.06453487f, 0.00994516f, 
    -0.11409070f, -0.10885529f, 0.04084792f, -0.26002365f, 0.07331046f, 0.07023328f, -0.08494980f, -0.08814815f, 
    0.12295996f, -0.06013647f, 0.14748755f, 0.01148526f, -0.13633952f, 0.10367856f, 0.04988535f, -0.14985658f, 
    -0.04107001f, -0.04327923f, 0.07124344f, -0.06691772f, 0.16928691f, 0.08833915f, 0.29454726f, -0.05550304f, 
    -0.16340616f, 0.29607600f, 0.04934646f, 0.33242005f, -0.10185025f, 0.29385868f, 0.17398395f, 0.13832338f, 
    -0.26142558f, 0.14641446f, 0.23652092f, 0.32875749f, 0.25027516f, 0.06311086f, -0.05270091f, 0.00476357f, 
    0.31462026f, -0.15863886f, 0.12888068f, 0.03612517f, -0.56593800f, 0.07742342f, 0.01264092f, -0.01731255f, 
    -0.33598986f, 0.00854932f, 0.00520039f, 0.03937444f, -0.09411674f, -0.00506151f, 0.33366480f, -0.14485924f, 
    -0.04941996f, -0.00891877f, 0.00039275f, -0.20455290f, 0.07699616f, -0.08809832f, -0.09341504f, -0.00559212f, 
    0.20508610f, 0.22652119f, -0.24180350f, 0.19591214f, -0.34627488f, 0.16467148f, 0.09618202f, 0.34741625f, 
    0.16892181f, 0.04508492f, 0.07845669f, 0.00012113f, 0.28357172f, 0.25353432f, -0.15173630f, 0.04667671f, 
    0.14907910f, 0.14789833f, 0.02208899f, 0.14762926f, 0.02386795f, 0.15002456f, 0.01274951f, -0.07500023f, 
    0.33162540f, -0.26137874f, 0.06988890f, -0.07457647f, -0.12429913f, -0.18950489f, -0.07750987f, 0.13754539f, 
    0.00225643f, 0.10841404f, 0.16944014f, -0.14797798f, -0.07743824f, 0.03757427f, -0.12804733f, -0.15042025f, 
    0.16502966f, -0.17321600f, 0.01624500f, -0.25140724f, -0.19171093f, -0.31755063f, -0.00080401f, 0.14928049f, 
    -0.03207073f, -0.33197615f, 0.01814150f, -0.08743823f, -0.08726285f, -0.00812446f, 0.05477864f, -0.00155625f, 
    0.11139925f, -0.17256546f, 0.03440751f, 0.00662087f, -0.03853330f, -0.06724153f, 0.15033963f, -0.04303277f, 
    0.04343894f, -0.00613279f, -0.08017640f, -0.16700651f, -0.15230703f, -0.17649244f, -0.08670355f, -0.00216247f, 
    0.08068710f, -0.00696811f, 0.05365836f, 0.02754084f, 0.10886138f, -0.04152494f, 0.09151297f, 0.15147397f, 
    -0.11738737f, -0.10620668f, -0.06054656f, 0.15731248f, -0.05052670f, -0.17189717f, 0.13013165f, -0.00434306f, 
    -0.01399788f, -0.13317533f, -0.07556164f, -0.06085414f, -0.07418447f, -0.14039992f, -0.15415347f, -0.02229421f, 
    -0.07197409f, 0.03136805f, 0.20513496f, 0.11694044f, -0.31755188f, -0.12406561f, 0.03966093f, 0.41964963f, 
    0.01733593f, 0.11394957f, 0.08305219f, -0.12217447f, 0.06222777f, -0.27729061f, -0.02490527f, 0.11000478f, 
    -0.19022121f, 0.50179458f, 0.13262326f, -0.03240662f, 0.10447467f, 0.03542959f, 0.01615101f, -0.15656184f, 
    0.22008444f, -0.17905635f, 0.12871531f, -0.28684446f, 0.25212929f, 0.10943402f, 0.04369266f, -0.12885842f, 
    -0.27747080f, -0.28496137f, 0.05457339f, 0.02203453f, -0.09754651f, -0.10990281f, 0.00077461f, 0.10296260f, 
    0.11585854f, -0.14133044f, 0.05367669f, -0.06648659f, 0.19840044f, 0.06032868f, 0.02920949f, -0.07314478f, 
    0.09718855f, -0.06387350f, 0.06618886f, -0.14800195f, -0.01838039f, -0.15171467f, 0.12132051f, 0.05312011f, 
    -0.07703859f, 0.14536902f, 0.00875538f, -0.07851959f, 0.53644621f, -0.16690685f, -0.04523229f, -0.07893401f, 
    -0.45360777f, 0.09115141f, 0.01439814f, -0.73850745f, 0.17889348f, 0.03138448f, -0.13126017f, 0.18112019f, 
    -0.04890652f, -0.14542855f, -0.06368173f, 0.15545622f, -0.19366246f, -0.41267073f, 0.07356082f, -0.11379252f, 
    0.36584148f, 0.33676451f, -0.03900451f, 0.13746999f, 0.05350960f, -0.07680131f, 0.16090880f, -0.06251329f, 
    0.04792048f, 0.34116697f, -0.06504323f, -0.21860886f, -0.20130631f, 0.30749407f, -0.05903511f, 0.01323625f, 
    -0.00505112f, 0.01073235f, -0.05012243f, 0.26921666f, 0.31090772f, -0.07360876f, -0.14388745f, -0.22617202f, 
    0.14940774f, 0.03361318f, -0.01068759f, 0.24084657f, 0.05598471f, 0.35974318f, -0.07837249f, -0.04245879f, 
    -0.25771517f, -0.15846041f, 0.03504729f, -0.03293486f, 0.06469119f, -0.00911112f, -0.14137226f, -0.13395551f, 
    0.20193507f, 0.05684231f, -0.15601383f, 0.34983230f, -0.00668725f, 0.06725773f, 0.03227079f, 0.01852188f, 
    -0.04991017f, 0.20733765f, -0.28807133f, -0.41669801f, -0.29998121f, -0.11858321f, -0.07114623f, 0.20193438f, 
    -0.23290186f, 0.10287046f, -0.06968389f, 0.25714046f, 0.14114387f, 0.08473405f, -0.02384281f, 0.03296243f, 
    0.34750503f, 0.28938514f, -0.12348890f, -0.16015834f, 0.07764897f, -0.14156270f, 0.25114629f, 0.05565153f, 
    0.21359815f, -0.11468398f, 0.08013309f, 0.03097726f, -0.37949428f, 0.04731104f, -0.08137000f, -0.01901390f, 
    -0.09001232f, -0.18995355f, -0.06504528f, 0.29015762f, 0.17165346f, -0.14660476f, 0.00766748f, -0.34214684f, 
    0.26120695f, 0.12935178f, -0.07891570f, -0.14839292f, -0.25943071f, 0.46689296f, -0.15113777f, 0.02579146f, 
    0.20506258f, -0.16120143f, -0.15246350f, 0.13770600f, 0.05927769f, -0.06279163f, 0.21737377f, 0.11521012f, 
    -0.04734911f, 0.14453031f, 0.12711284f, 0.07751273f, 0.23617969f, 0.13879564f, -0.07332721f, 0.03481169f, 
    -0.00015071f, -0.10940143f, -0.08556280f, -0.32341355f, -0.18010525f, 0.12689860f, 0.15968749f, -0.30024487f, 
    0.03505536f, 0.16855490f, 0.10439527f, -0.00850785f, -0.08874252f, 0.44303679f, 0.14618786f, 0.19489574f, 
    0.40449089f, 0.15563785f, -0.03357713f, 0.02052796f, 0.00484098f, 0.16385426f, 0.20563824f, -0.15937670f, 
    -0.02613576f, 0.07989375f, -0.03821898f, 0.53196305f, -0.30785078f, 0.25065538f, -0.04631307f, -0.17077869f, 
    -0.19922635f, -0.35107756f, 0.10554408f, 0.20636109f, 0.02481083f, -0.01686047f, -0.05884193f, -0.11103791f, 
    -0.19565259f, -0.08238730f, -0.14065039f, 0.14073871f, -0.05650881f, 0.25474310f, -0.08715206f, 0.14260364f, 
    0.19130035f, 0.26928157f, -0.07610501f, 0.04948709f, 0.03819623f, -0.04567391f, 0.34506181f, 0.15315238f, 
    0.20232704f, 0.29536906f, -0.04971041f, -0.36357161f, 0.17590061f, 0.03785482f, -0.10526842f, -0.00182385f, 
    -0.05146584f, 0.05686584f, 0.29485565f, -0.36992139f, -0.05991832f, -0.07422683f, 0.07234258f, -0.12489887f, 
    -0.14518861f, 0.03348638f, -0.08858630f, 0.02860936f, -0.18675759f, -0.52836835f, 0.10805170f, -0.12495240f, 
    0.03269771f, 0.27228263f, -0.07862277f, 0.16290991f, 0.09695356f, 0.17206989f, 0.12430145f, -0.11208171f, 
    0.05616340f, 0.23370628f, -0.13485909f, 0.19606377f, 0.20373113f, 0.17904432f, -0.05625005f, -0.08783463f, 
    -0.08749593f, 0.22047700f, -0.35589635f, -0.19007213f, -0.07281326f, -0.08238030f, -0.04204572f, 0.36004245f, 
    -0.22832105f, -0.15317945f, -0.01221894f, 0.18935116f, 0.07684401f, 0.34157827f, -0.03681217f, 0.01710982f, 
    0.33249828f, -0.17079847f, -0.00570098f, 0.03062643f, -0.01444168f, 0.05512723f, 0.21642409f, -0.01269702f, 
    0.18360080f, -0.22112256f, -0.13818303f, -0.09802183f, -0.15084010f, 0.13335094f, -0.01815393f, -0.14748041f, 
    0.37163931f, -0.24335675f, -0.27816698f, 0.29365280f, -0.39691579f, 0.08031933f, 0.12396287f, -0.10797647f, 
    0.15590556f, -0.01130490f, -0.08281197f, 0.00568791f, 0.23303571f, 0.34324840f, -0.07219675f, -0.02763015f, 
    -0.13281165f, 0.15871759f, -0.07841587f, 0.03850949f, -0.04877990f, -0.14062870f, 0.15884879f, 0.03761762f, 
    0.35963562f, 0.17235425f, -0.01416273f, 0.05686505f, -0.26832765f, -0.00953333f, -0.08945904f, 0.10796324f, 
    -0.02964552f, -0.09251781f, -0.06894532f, 0.06480521f, 0.03727619f, 0.00354706f, -0.16877159f, -0.06457736f, 
    -0.00742592f, 0.12073621f, -0.17077856f, -0.16825865f, 0.09246165f, 0.06781768f, -0.10481075f, 0.12814265f, 
    0.13681008f, 0.08807076f, 0.06013667f, 0.08857961f, 0.00528647f, 0.15228051f, -0.09811555f, 0.11601780f, 
    -0.07281859f, -0.10814330f, 0.10479243f, -0.12174764f, 0.08600868f, -0.18212768f, 0.12690181f, -0.08201490f, 
    0.40913987f, -0.00921995f, 0.25989974f, 0.19496085f, -0.26042297f, 0.08685508f, 0.15803696f, -0.15048558f, 
    -0.00192916f, 0.04649786f, 0.04482119f, -0.16266853f, 0.47689348f, 0.05240662f, -0.16013193f, -0.07831790f, 
    -0.30230036f, 0.15722962f, -0.12863231f, 0.15564865f, -0.16729753f, 0.07547048f, -0.19589546f, -0.12463489f, 
    0.33665562f, -0.12980585f, -0.16267256f, 0.02256522f, 0.02913156f, -0.05061125f, -0.07405779f, -0.13197683f, 
    0.29666644f, -0.02471432f, -0.44549590f, 0.11076347f, -0.13752441f, 0.14294192f, 0.12330864f, 0.02004362f, 
    0.22577038f, -0.06280980f, 0.08879690f, -0.22986326f, 0.34335586f, 0.18258019f, -0.15605369f, 0.11881490f, 
    0.30980566f, -0.17225906f, -0.08799613f, -0.14692082f, -0.16008951f, 0.01980574f, 0.15360127f, -0.15209413f, 
    0.05599117f, 0.10766414f, -0.15347271f, 0.30746815f, -0.02146775f, -0.28706032f, -0.07861167f, 0.04493963f, 
    -0.02958317f, -0.17219962f, -0.06721143f, 0.04771358f, 0.05888738f, -0.04819977f, 0.05644274f, 0.11549372f, 
    0.08286723f, 0.09325039f, 0.00411052f, -0.06224864f, -0.00331222f, 0.11041376f, 0.13043529f, 0.16415696f, 
    -0.16625713f, -0.03781748f, -0.07898735f, 0.14877039f, -0.14664966f, 0.08057129f, -0.11138801f, -0.10543472f, 
    -0.07048927f, 0.01581955f, -0.16968921f, -0.11841387f, -0.11799851f, -0.09785900f, 0.00146688f, -0.09149421f, 
    0.31586647f, 0.27884594f, 0.27896154f, 0.21437785f, 0.34756696f, -0.11766432f, 0.13824680f, 0.18927932f, 
    0.08232087f, 0.14663291f, -0.02943308f, -0.07661773f, -0.39350778f, 0.38253582f, -0.10948476f, -0.10112608f, 
    -0.26070297f, -0.06123680f, -0.03189253f, -0.02655614f, 0.15342702f, 0.03043076f, 0.21431719f, -0.09920125f, 
    0.09736919f, -0.29711056f, 0.03464811f, -0.05716031f, -0.00882240f, -0.17334296f, 0.00121998f, -0.03038592f, 
    -0.20514393f, -0.28049257f, -0.19094791f, -0.11546078f, -0.30131680f, -0.10453009f, -0.06635820f, 0.30805895f, 
    -0.05526409f, 0.03114541f, 0.15622002f, -0.09239656f, 0.33663046f, -0.02955373f, -0.06759514f, -0.09677832f, 
    0.15368706f, 0.09117410f, 0.04966437f, 0.15320365f, 0.01943530f, 0.16291374f, 0.19058317f, 0.03147352f, 
    0.37030354f, 0.10470697f, -0.16054106f, -0.17978333f, -0.18238138f, 0.11826466f, 0.07264753f, 0.02534905f, 
    0.11162136f, 0.23529738f, -0.38466537f, 0.30748588f, -0.21013771f, -0.09996051f, -0.15558910f, 0.29994687f, 
    -0.23120278f, -0.10139550f, -0.06968561f, 0.07957815f, 0.21683003f, 0.03442655f, 0.09325095f, -0.07389741f, 
    0.21589515f, -0.16067314f, 0.13278526f, -0.00008741f, 0.04315626f, 0.16595106f, 0.23151737f, 0.04559032f, 
    0.16540712f, 0.29170078f, -0.09795431f, -0.10388451f, 0.09315488f, 0.21723032f, 0.01173826f, -0.01382877f, 
    0.09413233f, -0.06937020f, -0.08247577f, -0.26423329f, 0.37662366f, -0.11968920f, -0.16435346f, 0.22376832f, 
    0.35397619f, -0.17868580f, 0.02511272f, -0.15067676f, 0.31633654f, -0.03765585f, -0.16343889f, -0.08994297f, 
    -0.19337769f, -0.22963536f, -0.12094761f, 0.06115386f, -0.02857339f, 0.12705295f, 0.23393673f, -0.08441725f, 
    0.29436710f, -0.32398799f, 0.13932271f, 0.17650135f, -0.20045505f, -0.06459991f, 0.08539098f, -0.12501858f, 
    0.07361142f, 0.03095484f, -0.00641009f, 0.15816909f, 0.11515795f, -0.10196777f, -0.07653061f, 0.00604873f, 
    0.04941161f, 0.08830070f, 0.11074089f, -0.14610477f, 0.06035118f, 0.05244523f, 0.04968690f, -0.02056246f, 
    0.18933393f, 0.01608690f, 0.02105996f, -0.17461640f, 0.04160286f, 0.17569223f, 0.05363697f, 0.15154313f, 
    -0.07574471f, 0.28432614f, 0.02699459f, -0.04460962f, -0.03369378f, -0.22767690f, -0.03793387f, -0.11757002f, 
    -0.15460747f, -0.21409732f, -0.17470749f, -0.40297073f, 0.32094875f, -0.00218798f, 0.03050255f, -0.14780745f, 
    0.15365577f, -0.11478810f, -0.08344586f, 0.00265706f, 0.27695772f, 0.04164049f, 0.04686851f, 0.07855747f, 
    -0.14267866f, -0.12172300f, 0.16366783f, -0.16898099f, -0.16938986f, 0.03927300f, 0.01529484f, -0.14466502f, 
    0.33505881f, -0.07159585f, -0.03989014f, 0.13188870f, 0.05387663f, 0.03936102f, 0.17184447f, 0.14774290f, 
    -0.05242674f, -0.03708593f, -0.07244104f, 0.52245629f, 0.23697662f, 0.03721518f, -0.09695982f, -0.03300267f, 
    0.10039197f, 0.01933135f, -0.06540757f, -0.14725927f, 0.11162130f, 0.33825791f, -0.10983846f, -0.06637527f, 
    -0.08455308f, -0.22332029f, 0.13968892f, -0.16504976f, -0.06229479f, -0.16328968f, 0.18984169f, 0.16138101f, 
    0.28057250f, 0.27362889f, 0.15410322f, -0.18208988f, 0.04819673f, -0.17191944f, -0.01674345f, -0.12984614f, 
    0.41198531f, 0.02554651f, 0.17928025f, 0.00400882f, -0.10268871f, 0.00066802f, -0.11750725f, 0.21264055f, 
    0.09074666f, -0.08845042f, -0.09407640f, 0.10903480f, -0.05738304f, -0.32914609f, 0.17776550f, 0.15153605f, 
    0.23397845f, 0.47237921f, 0.13700470f, 0.08408319f, 0.12794013f, -0.12306917f, -0.02941587f, 0.13767999f, 
    0.15269722f, -0.12212965f, 0.09028255f, -0.30522338f, 0.21615148f, 0.20438847f, -0.04875020f, -0.05272053f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.19799007f, -0.07925705f, 0.18623668f, 0.10620640f, 0.14890803f, 0.24972372f, 0.12074919f, 0.24484155f, 
    0.05876791f, -0.05073071f, 0.19819880f, 0.08164260f, -0.04376970f, 0.03135535f, -0.11915145f, -0.04214607f, 
    0.16127202f, 0.00757684f, 0.16993986f, 0.09253514f, 0.07134065f, -0.18778585f, -0.08103334f, 0.02126239f, 
    0.23706640f, 0.14971422f, 0.16328169f, -0.20777504f, 0.32727361f, 0.06719379f, -0.02428240f, -0.05515919f, 
    -0.08506233f, 0.08700191f, -0.08523267f, 0.17586455f, 0.00006894f, 0.23134458f, -0.08123046f, 0.15219636f, 
    -0.11631019f, 0.07728431f, -0.13755178f, 0.33185267f, -0.04741762f, 0.19488929f, 0.20168856f, -0.19716734f, 
    0.24172825f, -0.01124715f, 0.24193120f, -0.03045537f, -0.12311610f, 0.13815418f, -0.00552832f, -0.05764180f, 
    0.12356131f, -0.03351761f, 0.26060525f, -0.02418344f, -0.16250332f, 0.22840038f, 0.25976306f, 0.17181760f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.35246772f, -0.05608377f, 0.14129321f, 0.13026604f, 0.01308428f, -0.06053747f, 0.04879264f, 0.00200195f, 
    -0.11215659f, 0.17044777f, -0.06736386f, -0.02913224f, -0.15273164f, -0.20311381f, -0.06167760f, 0.36959434f, 
    0.11331455f, -0.31264982f, -0.22987001f, 0.45890602f, -0.17394225f, -0.08274834f, -0.47121224f, 0.05705409f, 
    0.20517442f, 0.20278631f, -0.06826745f, 0.09443854f, -0.00855248f, -0.34297732f, -0.10461867f, 0.11152104f, 
    -0.14579602f, 0.02389616f, 0.06139823f, -0.16493198f, -0.00726291f, -0.43366489f, 0.30615839f, -0.19675450f, 
    0.10543830f, 0.28263146f, 0.45637909f, 0.06518568f, -0.11451652f, 0.28893200f, -0.00122784f, 0.20736603f, 
    0.03466112f, 0.07804732f, 0.31440645f, 0.01629992f, -0.02266363f, -0.01001713f, 0.44687510f, 0.07069325f, 
    -0.20981345f, 0.24321643f, 0.18346117f, 0.20334023f, 0.14117803f, 0.04353651f, 0.04977839f, 0.26700848f, 
    -0.23841321f, -0.24030697f, 0.00411066f, -0.24661028f, 0.05782669f, -0.25639707f, 0.21398307f, -0.14894778f, 
    -0.11671958f, -0.15318358f, -0.26941302f, 0.03017525f, 0.49418139f, 0.15218189f, -0.62370563f, -0.07433450f, 
    0.02673159f, 0.02681699f, 0.24759191f, 0.07515461f, 0.06701397f, -0.03829190f, 0.42219436f, 0.13433611f, 
    -0.05669254f, 0.28072804f, 0.20872125f, 0.06422761f, -0.08065396f, -0.21913221f, -0.02731004f, 0.21289982f, 
    0.33751768f, 0.16201198f, -0.05078419f, 0.50284129f, 0.27971229f, 0.23512582f, -0.21694937f, 0.28165334f, 
    0.01038644f, -0.15476264f, 0.21032339f, 0.25722778f, 0.11159690f, -0.02582399f, 0.22852683f, 0.23847689f, 
    0.26402739f, 0.09651925f, -0.15830389f, 0.23875070f, 0.04269716f, -0.29393268f, -0.29744425f, 0.10817645f, 
    -0.17862132f, 0.02975036f, -0.01358898f, -0.33806372f, 0.10687490f, -0.11524450f, 0.09057355f, -0.02242086f, 
    0.29109985f, -0.36549288f, 0.14375114f, 0.33098823f, -0.01403416f, -0.07283814f, 0.16606678f, 0.10328155f, 
    0.11529911f, 0.13525164f, -0.15420830f, -0.13330944f, 0.02923521f, 0.09975813f, 0.07108624f, 0.38736111f, 
    -0.28885999f, -0.34794304f, 0.00501105f, 0.06547982f, 0.33437219f, -0.42570767f, 0.18625815f, 0.11223755f, 
    0.09101611f, -0.21462965f, -0.23913470f, -0.08671016f, -0.14724718f, 0.21449047f, 0.06384757f, 0.03805983f, 
    0.04761418f, -0.06312259f, 0.05414874f, -0.21807279f, 0.30957958f, -0.02734106f, 0.00618929f, -0.00991651f, 
    -0.12183109f, 0.00225832f, -0.25120756f, 0.12017268f, 0.00219397f, 0.34463000f, 0.16738003f, 0.33709276f, 
    0.10022987f, -0.01311236f, 0.30478871f, 0.15327008f, -0.09130444f, -0.12298169f, 0.47597477f, 0.01406659f, 
    -0.04214683f, 0.35650179f, 0.05827275f, 0.30993390f, -0.13295883f, 0.06932113f, 0.06530792f, -0.13468969f, 
    0.10398498f, 0.12683320f, 0.10784850f, -0.30040321f, -0.10337394f, 0.08917021f, -0.11493443f, -0.17435381f, 
    0.02456384f, -0.13613120f, -0.23223680f, 0.03098373f, 0.30628324f, -0.24772808f, -0.49228850f, 0.08971388f, 
    0.34003881f, 0.25985825f, 0.35333821f, 0.06236609f, 0.12061754f, 0.07226218f, 0.36568764f, 0.01302265f, 
    0.10258271f, 0.00161930f, 0.10402910f, -0.07307450f, -0.00609547f, -0.33659634f, -0.12099702f, -0.13790183f, 
    0.30706742f, 0.21506932f, 0.06673203f, -0.26825571f, 0.02712856f, -0.26548135f, 0.15629092f, 0.01803352f, 
    -0.05362723f, 0.11186913f, -0.05220804f, 0.17491637f, -0.12816392f, 0.31798983f, -0.16147922f, 0.33112863f, 
    0.01795452f, 0.09797165f, 0.11874229f, -0.11539558f, 0.02059018f, -0.16730952f, -0.14201871f, -0.03569831f, 
    -0.12786180f, 0.02731482f, -0.02579706f, -0.05946998f, -0.16666925f, -0.22385828f, -0.25066409f, 0.19359522f, 
    0.14837505f, -0.04106714f, 0.06253676f, -0.00344668f, 0.12572989f, 0.23058325f, 0.35951406f, -0.07107618f, 
    -0.03148763f, -0.18957417f, -0.04572199f, -0.28212306f, 0.44049767f, -0.10036885f, -0.62305135f, 0.25623819f, 
    -0.08927552f, -0.11864277f, 0.21869384f, -0.16323613f, 0.07225558f, 0.12792850f, -0.07235302f, -0.09686048f, 
    0.21682799f, -0.35557303f, 0.12948772f, 0.09696563f, 0.11237293f, -0.10005132f, 0.07443265f, 0.02186042f, 
    0.23754628f, 0.17987594f, 0.09864233f, 0.28472796f, 0.30559450f, -0.16083960f, -0.13848768f, -0.10505983f, 
    0.01134099f, -0.31046247f, -0.03677694f, 0.42107230f, -0.01037232f, 0.44834891f, 0.02432694f, 0.36891660f, 
    0.03408462f, 0.26280352f, 0.33380076f, -0.03925991f, 0.09888365f, -0.42291594f, -0.15129718f, -0.10430036f, 
    -0.14358050f, -0.01380883f, 0.28557178f, -0.15449132f, -0.06366097f, 0.07923521f, -0.06978787f, -0.02329558f, 
    0.26836205f, -0.39317301f, 0.03052670f, 0.19024539f, -0.07043318f, 0.02235023f, 0.20855539f, -0.13596934f, 
    0.07523306f, -0.12488546f, -0.16322592f, -0.13227358f, 0.12687756f, -0.13782120f, -0.24815646f, 0.15927620f, 
    -0.19929840f, 0.10407417f, 0.18290532f, -0.16148335f, 0.46020922f, -0.43060562f, 0.25516945f, 0.25559238f, 
    0.10937084f, 0.06806626f, -0.14746016f, 0.07049529f, -0.26552796f, 0.19345044f, 0.09516226f, 0.03012610f, 
    0.00898373f, 0.00317800f, -0.11251960f, -0.00265544f, 0.26195249f, 0.67149234f, -0.10581148f, -0.00509451f, 
    -0.10517639f, 0.06509065f, -0.38142255f, 0.12588377f, 0.01373013f, 0.17081685f, 0.16690160f, 0.08187038f, 
    0.10735755f, 0.06176353f, 0.18464406f, -0.04215015f, -0.02559774f, -0.29627284f, -0.43190801f, 0.09467345f, 
    0.11581115f, 0.23407121f, -0.13677561f, 0.26414692f, -0.26062194f, 0.19988480f, 0.06219644f, 0.06785964f, 
    -0.25740471f, 0.19819874f, -0.24164990f, 0.01395531f, 0.00211160f, 0.02952630f, 0.11488409f, 0.06056935f, 
    0.13187827f, 0.16210559f, 0.07850341f, -0.26078039f, 0.23712611f, -0.00781827f, 0.46953624f, -0.09928504f, 
    -0.11525100f, 0.05244048f, 0.25692186f, -0.36743498f, 0.41330361f, 0.30747536f, 0.47206688f, 0.07686043f, 
    -0.17055370f, -0.32894894f, 0.11855777f, -0.04254607f, -0.03651233f, 0.40466782f, -0.02330365f, 0.09718714f, 
    0.23292379f, 0.22843473f, 0.00534902f, 0.25699115f, -0.01009137f, 0.10318882f, 0.09031750f, 0.25185382f, 
    -0.11715669f, -0.16554916f, -0.18917777f, -0.03486274f, 0.42779416f, 0.07912688f, -0.15464793f, -0.10473388f, 
    -0.07213205f, 0.14562793f, 0.04596726f, 0.19259097f, -0.07468954f, 0.42110217f, -0.22563939f, 0.04579103f, 
    0.03534837f, -0.06796144f, -0.15381627f, 0.34907511f, -0.20335828f, 0.35299635f, 0.11157308f, -0.00208219f, 
    0.04370600f, 0.11915391f, 0.24799562f, -0.32985991f, -0.06688195f, 0.20084700f, 0.04849249f, -0.42287400f, 
    0.04241612f, -0.33241311f, -0.01251411f, 0.37628153f, 0.11565722f, -0.12588744f, -0.20172508f, 0.08121429f, 
    0.32250619f, 0.04326827f, 0.13938382f, -0.39909256f, -0.02389248f, -0.19316615f, 0.06383718f, -0.10864222f, 
    0.27862817f, 0.26482600f, 0.03385227f, -0.08767746f, 0.06338485f, 0.09754349f, -0.04092472f, 0.10716450f, 
    -0.21726951f, 0.05041312f, -0.04677291f, 0.03334901f, -0.02069920f, 0.35667279f, -0.07846334f, -0.17919111f, 
    0.09326220f, 0.25754115f, -0.36471856f, 0.30774915f, -0.25169894f, 0.17527051f, -0.11397551f, -0.24455407f, 
    0.08049553f, 0.14357688f, 0.09428880f, -0.06132549f, -0.08915181f, -0.25855759f, -0.70401847f, -0.03341007f, 
    0.05909599f, -0.01356451f, 0.00779697f, -0.30776235f, -0.12413488f, -0.25385007f, -0.15783255f, 0.26952699f, 
    0.01740758f, 0.03654329f, -0.03341953f, 0.01120945f, 0.00309464f, 0.05144079f, 0.07827301f, 0.03071768f, 
    0.06843815f, 0.00427862f, 0.06762873f, -0.03499564f, -0.07937609f, -0.01420040f, -0.10127927f, 0.00678083f, 
    -0.03597948f, 0.07485741f, -0.04677334f, 0.01087598f, -0.07290086f, -0.07154626f, 0.01667171f, -0.05039027f, 
    0.03222468f, -0.05285341f, -0.10098568f, 0.01922987f, -0.09350321f, 0.04716660f, 0.06397445f, -0.13263488f, 
    -0.05258646f, -0.08673398f, 0.10461985f, -0.00210286f, -0.04543356f, 0.10324186f, -0.08834240f, 0.03101318f, 
    -0.03393400f, 0.04685453f, 0.04092484f, 0.06618598f, 0.04142139f, 0.12036648f, -0.11273974f, -0.03368624f, 
    0.09677091f, 0.03467762f, -0.07303596f, -0.04625270f, -0.07297723f, 0.00085801f, -0.00617634f, 0.02682906f, 
    -0.05332744f, 0.03361188f, -0.04520619f, 0.01303476f, -0.11308087f, -0.03011505f, 0.02241966f, -0.11131777f, 
    0.36641282f, 0.26524383f, -0.00320864f, 0.48183292f, 0.04763672f, 0.19744587f, -0.16063060f, 0.22218569f, 
    0.01995826f, -0.08333690f, 0.12072758f, -0.25839239f, -0.15559077f, 0.05654227f, 0.21320838f, 0.29456165f, 
    0.15081483f, 0.16820489f, 0.10368650f, 0.13595974f, -0.11503153f, 0.13104546f, -0.35703653f, -0.09853873f, 
    0.28315446f, -0.32796809f, 0.17011082f, 0.03941311f, 0.21131811f, 0.21930444f, -0.07535401f, -0.04200426f, 
    -0.17679536f, -0.12762129f, 0.01277893f, -0.11495038f, 0.01148164f, -0.46277925f, 0.17940125f, -0.17077559f, 
    -0.06998461f, -0.17945014f, -0.10073404f, 0.11879433f, -0.00739217f, 0.29710490f, -0.10260290f, 0.08213787f, 
    -0.15577573f, -0.08122548f, 0.27858374f, 0.14539313f, -0.01441516f, 0.04788101f, 0.47120517f, 0.02074608f, 
    0.06089585f, 0.19185345f, 0.26953676f, 0.22978815f, -0.24733900f, 0.04067032f, 0.01918775f, 0.09181102f, 
    0.23825644f, 0.32596621f, 0.16063753f, 0.13100371f, 0.09673079f, 0.37250003f, -0.18439518f, -0.20582387f, 
    -0.00714409f, -0.21491052f, 0.22592540f, 0.16493031f, -0.04257390f, -0.36107206f, -0.06446611f, 0.12182143f, 
    0.25927603f, 0.32731470f, 0.21490194f, -0.44920352f, -0.02044413f, 0.07372361f, -0.29189354f, -0.20905757f, 
    0.17222963f, -0.20539403f, 0.15911239f, 0.09388669f, 0.02844410f, 0.29297993f, 0.03710909f, 0.09454629f, 
    -0.12299544f, 0.07246528f, 0.02927938f, 0.04672919f, 0.09695830f, 0.30573940f, -0.01279313f, -0.17562215f, 
    -0.10657986f, 0.32819951f, -0.30139160f, 0.14061520f, -0.19032194f, 0.11486674f, -0.18728049f, -0.32848591f, 
    -0.03023961f, 0.16929667f, 0.12870166f, -0.15385838f, 0.12041350f, -0.02617155f, -0.53431851f, -0.03179087f, 
    0.23525366f, -0.13757184f, 0.12908693f, -0.15440768f, -0.10253314f, -0.23458154f, -0.15870342f, 0.16001509f, 
    0.05811304f, -0.06855000f, -0.02705058f, -0.15539931f, -0.10384478f, -0.23189294f, -0.02316105f, -0.24107279f, 
    0.03453553f, 0.14349575f, -0.10271399f, -0.26901424f, 0.41999674f, 0.30592275f, 0.60497719f, 0.01807427f, 
    -0.31059560f, -0.25467426f, 0.19287045f, -0.12791881f, 0.29281625f, 0.08282031f, 0.51194423f, 0.26705992f, 
    -0.22492458f, -0.12992536f, -0.01291821f, 0.11750501f, -0.20705806f, 0.29869914f, -0.06504700f, 0.18912502f, 
    0.17034689f, 0.27106309f, -0.08393688f, 0.41777939f, 0.13499922f, -0.26957908f, 0.09896016f, 0.25700304f, 
    0.02784290f, 0.22956192f, -0.26305488f, -0.00632405f, 0.11993867f, 0.05943880f, -0.13564843f, 0.18007132f, 
    0.00859736f, 0.14544274f, -0.06496598f, 0.25305927f, 0.05072858f, 0.54785794f, -0.12450514f, 0.09420273f, 
    -0.22663988f, 0.11496521f, -0.01274749f, 0.09632371f, -0.14051442f, 0.24777520f, -0.04254923f, 0.12573950f, 
    0.05918071f, -0.10933493f, 0.00594313f, 0.04943651f, 0.10089887f, 0.08809889f, -0.00425436f, -0.06219958f, 
    -0.07685948f, -0.05686370f, 0.07719275f, -0.01395038f, -0.07620709f, 0.02268413f, -0.10516351f, 0.07668924f, 
    0.07248807f, -0.02053466f, 0.00348474f, -0.08071418f, -0.09778266f, -0.12468813f, -0.04615393f, 0.03416173f, 
    0.02139913f, 0.00656325f, -0.01519714f, -0.09853387f, 0.02024843f, -0.00043646f, 0.00330834f, -0.10227457f, 
    -0.04512585f, 0.10831445f, -0.02918249f, 0.07497135f, 0.04445190f, -0.00089916f, -0.01722605f, -0.05296040f, 
    0.11168776f, -0.10051958f, -0.09927708f, -0.08540527f, -0.02445485f, -0.09393238f, 0.02212163f, 0.04128752f, 
    -0.09526550f, -0.08114320f, -0.00345451f, -0.06969801f, 0.06315769f, -0.00974071f, -0.08608066f, -0.02378663f, 
    -0.07676089f, -0.08822513f, -0.12837723f, -0.00098540f, 0.03612113f, -0.08395009f, -0.04042109f, 0.02845378f, 
    -0.28626975f, 0.34367952f, -0.06043145f, -0.14273313f, 0.09568574f, 0.26438126f, -0.05441141f, 0.21608269f, 
    0.04715543f, 0.33066222f, 0.41335675f, 0.20311761f, -0.04302023f, 0.42807421f, 0.01936275f, -0.29760119f, 
    0.09785146f, 0.10086478f, 0.06284706f, 0.09902193f, -0.20858756f, 0.29187888f, -0.39156932f, -0.05980557f, 
    0.03246365f, 0.26894259f, 0.28326637f, -0.14301626f, 0.31804302f, 0.11399039f, -0.00953750f, 0.10910867f, 
    0.14726987f, 0.12409940f, -0.02929668f, 0.34802976f, -0.06426880f, -0.08174044f, -0.17446917f, 0.06224175f, 
    0.05713776f, -0.12057091f, 0.28364140f, 0.00829072f, 0.26668158f, -0.27442527f, 0.01926699f, -0.07223980f, 
    0.06655454f, 0.02903702f, -0.17450124f, -0.03574292f, -0.02459116f, 0.23140892f, 0.27909628f, 0.05403900f, 
    -0.22382195f, -0.00021706f, 0.09352446f, -0.03100653f, -0.03185954f, 0.06497682f, 0.21666472f, 0.14705126f, 
    0.00228707f, -0.37844449f, 0.14643547f, 0.12845358f, 0.05875592f, 0.02526696f, 0.20557633f, -0.05235882f, 
    -0.01355530f, -0.01424790f, -0.03287680f, 0.36231667f, -0.25445572f, -0.19360442f, 0.12823693f, 0.20854087f, 
    0.01699172f, -0.25836313f, -0.17979184f, -0.37425312f, 0.05371059f, -0.17391831f, 0.02019249f, -0.11139143f, 
    0.04454856f, 0.43796608f, -0.04060187f, 0.07900853f, 0.11909728f, 0.16163966f, -0.08683718f, 0.19559284f, 
    -0.43309817f, -0.20581470f, -0.04712911f, -0.34057739f, -0.01783192f, 0.48722357f, 0.21275608f, -0.21724001f, 
    0.09759814f, 0.46094620f, 0.02831492f, 0.10452887f, -0.41506192f, -0.02620938f, 0.17181361f, -0.30438361f, 
    0.15728660f, 0.15476798f, 0.02572496f, -0.06195084f, 0.14334160f, 0.00472089f, -0.23100455f, 0.11442569f, 
    0.33498850f, -0.01028814f, 0.22751980f, -0.03047160f, 0.04638296f, -0.22393341f, 0.07785515f, 0.18120387f, 
    -0.04366356f, 0.44037741f, 0.21665223f, -0.15641399f, -0.11873948f, 0.21768618f, -0.02501675f, -0.23745804f, 
    -0.06517924f, 0.20551208f, 0.23222210f, 0.11483885f, -0.04534800f, -0.01210958f, -0.05230361f, 0.08640525f, 
    0.08753639f, -0.00093315f, 0.20826869f, -0.13521886f, 0.09441120f, 0.00353688f, -0.02145760f, 0.24937928f, 
    0.23566206f, 0.21988767f, 0.09583434f, -0.10110792f, -0.04500047f, -0.28648800f, -0.11779938f, 0.12705567f, 
    0.12290470f, 0.27042863f, -0.04294572f, -0.04932928f, 0.06743127f, 0.05981522f, -0.03233094f, -0.00247513f, 
    0.05741674f, 0.10698965f, -0.33433959f, 0.34616056f, 0.04385407f, 0.09206339f, -0.29756841f, -0.15464111f, 
    -0.10422484f, 0.14907563f, -0.03340429f, -0.22831255f, 0.02926186f, -0.07853024f, -0.46121338f, -0.04879577f, 
    -0.05173910f, 0.03027726f, -0.10538673f, 0.14595342f, -0.07076577f, 0.04162396f, -0.18852499f, 0.12887408f, 
    -0.44676921f, 0.08140169f, -0.30893156f, -0.00454333f, -0.10968497f, -0.03975774f, 0.11401468f, -0.19845469f, 
    0.09130831f, 0.21093120f, 0.12165671f, -0.00935710f, 0.00456287f, 0.21064353f, 0.03090446f, -0.05927661f, 
    0.16372739f, -0.28130946f, 0.32254446f, -0.05826611f, 0.44619587f, -0.19795653f, 0.82014555f, 0.18542179f, 
    -0.03019873f, -0.10179543f, -0.08269060f, 0.07083232f, -0.04633124f, -0.02638759f, -0.01611602f, -0.04536721f, 
    0.22534145f, 0.02309179f, -0.02280231f, -0.23723623f, 0.12013776f, 0.37916395f, -0.25978202f, -0.16494106f, 
    0.02871964f, -0.33427599f, 0.02754158f, -0.07604281f, 0.30559379f, -0.10104356f, 0.11971875f, 0.16350438f, 
    0.09816069f, -0.04206952f, -0.10394325f, -0.07379740f, -0.11928466f, -0.14356734f, -0.02853964f, 0.02254945f, 
    0.33804429f, -0.37893218f, -0.28811508f, 0.25095078f, -0.11498715f, 0.20197704f, 0.13583595f, -0.20996936f, 
    -0.47584984f, 0.07351857f, -0.05966149f, -0.43869632f, 0.05072718f, -0.12384656f, 0.09297570f, 0.06810954f, 
    -0.10391938f, 0.17354915f, 0.00271292f, 0.14905713f, 0.17550184f, 0.44338453f, 0.28577781f, -0.52085525f, 
    0.12701781f, 0.37046891f, 0.20521951f, -0.21001136f, 0.13381609f, -0.12297548f, 0.41718721f, 0.05403579f, 
    -0.27339068f, 0.17884007f, 0.14789534f, -0.05082201f, 0.11251898f, 0.15699692f, 0.04993451f, 0.27612409f, 
    0.04527089f, 0.31213483f, 0.08588380f, 0.38592908f, 0.16205996f, 0.63165599f, -0.18134049f, 0.28218231f, 
    0.03167414f, 0.11478285f, -0.03562900f, -0.01326257f, 0.13890770f, -0.36224809f, 0.07825523f, -0.03051831f, 
    0.02279230f, 0.18393874f, -0.23558243f, 0.01020447f, 0.09732777f, 0.35452679f, -0.31715840f, 0.00393674f, 
    0.16101313f, -0.23874073f, -0.00960084f, -0.16045325f, -0.04354635f, -0.01091875f, 0.16033956f, 0.11328960f, 
    -0.22859119f, 0.23488866f, -0.01311043f, 0.17828935f, -0.02062104f, 0.19476222f, 0.16413543f, -0.13996395f, 
    0.11569703f, 0.23052387f, 0.22805393f, 0.32278612f, -0.11537126f, 0.08059840f, 0.13132411f, -0.37710658f, 
    0.07604725f, 0.17731091f, 0.22705507f, -0.22217304f, -0.00073758f, -0.24855411f, -0.00637635f, 0.08692144f, 
    0.21425006f, -0.06832506f, -0.01572740f, 0.01729234f, 0.11135264f, -0.08078253f, -0.04451938f, 0.01024918f, 
    0.33113766f, 0.27882376f, -0.00209014f, 0.11413744f, 0.14486822f, 0.07401686f, -0.29941985f, -0.07559089f, 
    0.05467443f, -0.46987355f, -0.00783270f, 0.26007950f, 0.15541224f, -0.24027292f, 0.07738663f, -0.00636376f, 
    -0.05407275f, 0.18081540f, -0.26628938f, -0.27946466f, 0.07429683f, -0.13386047f, -0.23085262f, 0.02168332f, 
    0.20384786f, -0.55231762f, -0.28188407f, 0.13832590f, 0.08765238f, 0.02377577f, -0.10745447f, 0.06571545f, 
    -0.10177280f, -0.10756336f, 0.00285161f, 0.07101034f, 0.09422600f, -0.04469031f, -0.14189312f, -0.14239740f, 
    0.08061628f, 0.00987548f, -0.08019611f, 0.05250089f, 0.00376561f, -0.04436690f, -0.03095394f, -0.05581454f, 
    -0.10266519f, 0.10850917f, 0.08375327f, -0.00881141f, -0.10740566f, -0.05663745f, 0.02035703f, -0.05880487f, 
    -0.14349928f, 0.07872978f, -0.07366774f, -0.04017220f, -0.03148903f, 0.07096152f, 0.10145713f, -0.02707416f, 
    0.03539794f, -0.09333205f, 0.02616319f, -0.06428653f, -0.13984247f, 0.07279945f, 0.07309498f, 0.04864328f, 
    -0.08917119f, 0.01097219f, -0.12386763f, 0.06732441f, -0.07799141f, -0.05396011f, 0.00467595f, -0.07577650f, 
    0.07804600f, 0.02992660f, -0.08008108f, -0.14164165f, -0.07575825f, -0.09887370f, 0.04480308f, 0.04917984f, 
    -0.02663204f, 0.05320109f, -0.14533563f, -0.03532536f, 0.02635343f, -0.03510640f, -0.04501564f, -0.11253965f, 
    0.05174825f, 0.02764682f, -0.05941522f, 0.08058938f, -0.02707417f, -0.11884990f, 0.10287585f, -0.00711261f, 
    0.06148149f, -0.14216493f, 0.09377882f, -0.11408327f, 0.01330118f, -0.11341436f, -0.09513380f, 0.09275226f, 
    0.06730490f, -0.04889604f, 0.00644490f, 0.04635778f, 0.07295962f, -0.09676985f, 0.01103330f, 0.04202067f, 
    -0.07677891f, -0.05884344f, -0.05905619f, -0.00957388f, 0.01025848f, -0.05185198f, -0.07640444f, -0.13836227f, 
    0.04335574f, -0.02202651f, 0.06456159f, 0.08518999f, -0.03814111f, -0.00453121f, 0.09709531f, -0.01820473f, 
    0.03164804f, 0.08776655f, -0.02771794f, -0.01241688f, 0.07510976f, -0.03601423f, -0.08514135f, -0.12036785f, 
    0.01140296f, -0.07684791f, -0.08757283f, 0.04993422f, -0.06080629f, -0.11389222f, -0.01173681f, 0.07427202f, 
    0.01991212f, 0.03946431f, -0.03315893f, 0.09697247f, -0.03050739f, -0.10613945f, -0.08034051f, 0.02981627f, 
    -0.14252840f, -0.29666349f, 0.07611775f, -0.06371360f, 0.08842556f, -0.03823068f, 0.40915626f, -0.05685716f, 
    -0.08257470f, 0.02912161f, 0.17123027f, 0.24857460f, 0.09061399f, -0.19111685f, -0.17358777f, -0.15122716f, 
    0.14699616f, 0.10006855f, -0.06420716f, -0.31783083f, 0.09276515f, -0.18128863f, 0.19277996f, 0.11648491f, 
    -0.06251623f, 0.39268512f, -0.29659599f, 0.08917664f, 0.09026878f, -0.00148863f, 0.05914277f, 0.18637633f, 
    0.09978046f, -0.05126955f, -0.07368499f, -0.01166976f, 0.21697129f, 0.63779634f, -0.12577267f, 0.04240851f, 
    -0.05792309f, 0.11242496f, 0.05481908f, 0.17585674f, 0.02574226f, -0.22149573f, 0.20969763f, -0.13583118f, 
    0.19584121f, 0.09326666f, 0.14213519f, -0.17386933f, -0.00860293f, -0.39941499f, -0.24816203f, 0.05513394f, 
    0.37101004f, -0.05908268f, -0.02895043f, 0.14532873f, -0.00054004f, 0.21418531f, 0.15907320f, -0.02985884f, 
    0.06970700f, -0.00098741f, 0.24945676f, 0.08591085f, -0.09870453f, 0.07242854f, 0.10608409f, 0.31387839f, 
    -0.07579219f, 0.14647841f, 0.41164786f, 0.31257004f, 0.02630690f, -0.21564032f, 0.04110789f, 0.19727050f, 
    0.00582721f, 0.03212237f, -0.20259579f, 0.36566839f, -0.09374574f, -0.11722393f, -0.68694502f, 0.36063910f, 
    0.09943303f, 0.64169139f, -0.12963708f, -0.03244556f, 0.18226208f, -0.22858042f, 0.11068159f, 0.06536978f, 
    0.05304495f, 0.05398204f, 0.01418516f, 0.03514586f, -0.02706782f, -0.00223020f, -0.07521807f, -0.03776171f, 
    0.06744839f, 0.14893441f, 0.59254014f, 0.18542331f, -0.06195864f, -0.22921854f, 0.16967838f, -0.27620047f, 
    0.03604766f, 0.17609961f, -0.12464491f, -0.18696837f, -0.00952521f, 0.04683047f, 0.18483308f, -0.05422440f, 
    -0.17660643f, 0.19710425f, -0.03317908f, 0.00170131f, 0.11850711f, 0.30155849f, 0.10856578f, 0.21461172f, 
    -0.08826659f, -0.06842853f, -0.05684231f, 0.10747471f, -0.03081733f, -0.12851317f, 0.25601357f, -0.25863495f, 
    -0.03074723f, 0.18737485f, 0.11542574f, -0.13805878f, 0.48884827f, 0.09649681f, 0.18897261f, 0.08855429f, 
    -0.22743607f, -0.36086145f, 0.09011640f, -0.23093675f, 0.43582842f, 0.12801708f, 0.09374964f, 0.44588783f, 
    -0.07713360f, 0.15607989f, 0.11058849f, -0.08100835f, 0.13293350f, 0.12210291f, -0.09264764f, 0.37185735f, 
    0.09485930f, 0.34993374f, -0.09266138f, 0.42648703f, 0.30584323f, 0.03060823f, -0.27252027f, 0.22900459f, 
    -0.03572319f, -0.00900508f, -0.07688283f, 0.26202518f, 0.17838016f, -0.03073408f, -0.03711229f, -0.04229205f, 
    -0.00666736f, 0.33618015f, -0.00478933f, -0.03968256f, 0.04657059f, 0.09600660f, -0.22321995f, 0.09986126f, 
    -0.31127217f, 0.13915442f, 0.06776848f, 0.26134032f, 0.01774982f, 0.40143305f, 0.05979367f, 0.04161309f, 
    -0.03282168f, 0.08470821f, -0.10021897f, 0.07497884f, 0.06121965f, -0.12999217f, 0.03075169f, 0.05694126f, 
    -0.01984677f, -0.14088129f, 0.10891343f, 0.00619519f, 0.02375289f, 0.08956078f, 0.05045422f, 0.05914310f, 
    0.05339494f, -0.12573062f, 0.05199589f, 0.09042525f, -0.01598801f, -0.02645786f, 0.03941305f, -0.07182063f, 
    -0.08711608f, -0.05747064f, 0.02737563f, -0.00436091f, -0.06635209f, -0.15446042f, 0.05088833f, -0.03214008f, 
    -0.00627228f, -0.03811781f, -0.12090503f, -0.01001018f, 0.08013673f, -0.06082269f, -0.03235189f, -0.04098056f, 
    -0.07585694f, -0.09834461f, -0.06309675f, -0.02783082f, -0.09359325f, -0.03783926f, -0.03561435f, 0.03763736f, 
    0.03121893f, -0.01692014f, 0.04130751f, 0.09426352f, 0.06716602f, -0.07464955f, -0.01312002f, -0.07776299f, 
    -0.05936401f, -0.06332043f, -0.04670786f, -0.10485274f, -0.08994931f, 0.02330207f, 0.05897176f, -0.02181475f, 
    0.23064266f, -0.48463172f, 0.30953571f, 0.22382630f, -0.11547577f, -0.01993139f, 0.19660322f, 0.50589359f, 
    0.05651948f, 0.07372379f, -0.13816738f, -0.07481851f, -0.07764287f, -0.06012696f, 0.42287955f, 0.33722058f, 
    -0.13061479f, -0.08040887f, -0.26463696f, 0.49720180f, 0.12932257f, -0.24367777f, -0.16356425f, 0.12198543f, 
    -0.03085567f, 0.37674916f, -0.12947664f, -0.07477957f, -0.09835498f, 0.36744082f, 0.04241209f, 0.16173190f, 
    -0.22525646f, -0.30907801f, 0.01527738f, -0.14292499f, -0.15903632f, 0.05878175f, 0.30099711f, 0.13420740f, 
    -0.04645165f, 0.20594358f, 0.50658178f, 0.00302253f, -0.12421192f, -0.01563460f, 0.22165394f, 0.07888991f, 
    0.15225357f, -0.20244364f, 0.07723887f, 0.27744383f, 0.10689608f, 0.08857801f, 0.54855496f, 0.01419513f, 
    -0.01519686f, 0.50689501f, 0.24993519f, 0.29810998f, 0.20217538f, 0.34866035f, 0.25112933f, 0.15706204f, 
    0.01249472f, -0.02726782f, -0.04359546f, -0.04708934f, -0.07019664f, -0.02242480f, 0.09401515f, -0.12757069f, 
    0.08966992f, 0.03457347f, 0.10917313f, -0.11867716f, -0.08392304f, 0.06313596f, -0.00402819f, -0.00276107f, 
    -0.02981867f, -0.11965724f, -0.01650525f, 0.01369434f, -0.11850240f, 0.02712978f, -0.00201897f, -0.10400990f, 
    0.10535781f, -0.04682410f, -0.07507744f, -0.00408322f, 0.03601460f, -0.06845535f, 0.07233547f, 0.03117345f, 
    0.00941313f, -0.09840186f, 0.04320268f, -0.12020236f, -0.05559130f, 0.01776655f, 0.03341936f, -0.07104139f, 
    -0.09390005f, -0.12509239f, 0.05451737f, 0.09885566f, -0.05922543f, 0.03527948f, -0.04832989f, -0.08492847f, 
    -0.12384127f, 0.01758597f, -0.07410701f, 0.06018466f, -0.02543391f, 0.07989717f, -0.08191861f, 0.03622730f, 
    0.07452939f, -0.00369620f, -0.05890170f, 0.09288344f, 0.09049124f, -0.12687886f, 0.05348105f, -0.08612444f, 
    0.47776750f, 0.31126863f, 0.30161008f, 0.47385451f, 0.04778541f, 0.46262211f, -0.15417489f, -0.08312800f, 
    -0.06215467f, -0.19699115f, -0.05799026f, 0.03271309f, -0.33080396f, -0.38595816f, 0.37858239f, 0.21803629f, 
    -0.05285528f, 0.17496276f, 0.04289853f, -0.01303743f, 0.07043859f, 0.17683214f, -0.15146162f, -0.08668736f, 
    0.18513489f, -0.42436498f, -0.01493022f, -0.09500994f, 0.03775755f, 0.36998370f, -0.01913607f, -0.18075410f, 
    -0.19006288f, -0.15245472f, 0.05478630f, -0.26209775f, -0.01371159f, -0.12360433f, 0.29466069f, -0.06397635f, 
    -0.02056308f, 0.25032830f, -0.48319438f, 0.10133020f, -0.03960939f, 0.13469265f, -0.25248685f, 0.06208667f, 
    0.00004769f, -0.03199353f, 0.12047636f, 0.15004332f, 0.12185124f, 0.20250520f, 0.05044900f, -0.12134470f, 
    0.37441629f, 0.13406397f, 0.22028124f, 0.18715149f, -0.18139158f, 0.02138643f, -0.03393412f, 0.09982604f, 
    -0.01834160f, -0.09270938f, -0.09871819f, 0.05195294f, 0.06622150f, 0.01684955f, -0.02719812f, -0.02209262f, 
    0.08221915f, 0.06093069f, 0.04888279f, -0.03413958f, 0.07293254f, -0.05706458f, 0.01127852f, 0.08990076f, 
    0.08061207f, 0.00373934f, -0.07325935f, -0.12454665f, -0.04927155f, -0.08993645f, 0.06532734f, 0.02472975f, 
    -0.02172899f, 0.01502004f, -0.11311592f, -0.00395772f, 0.01383043f, -0.01924164f, 0.06582752f, -0.11654323f, 
    -0.01448426f, -0.07351999f, -0.07867667f, 0.03288507f, 0.05655302f, 0.04680374f, 0.04451792f, 0.00535546f, 
    0.08741453f, 0.06794216f, -0.02363478f, -0.09107725f, 0.03397334f, -0.09635132f, -0.06921753f, 0.00918193f, 
    -0.11297978f, -0.05980704f, 0.07692977f, 0.06992617f, -0.09041541f, 0.04672895f, -0.05056436f, -0.11407007f, 
    -0.10843283f, -0.10298823f, 0.09660272f, 0.04078007f, 0.05262825f, -0.08628919f, -0.00332561f, -0.11494602f, 
    0.09732981f, -0.11526366f, -0.13086319f, 0.07535045f, 0.04335222f, 0.00447547f, -0.12718751f, -0.09929858f, 
    -0.06666537f, 0.07171678f, -0.00647326f, 0.03883660f, -0.08116251f, -0.07391888f, -0.11630283f, -0.07983752f, 
    -0.02426889f, -0.02083868f, 0.08856428f, 0.07118289f, -0.11967859f, 0.04133114f, -0.10701708f, 0.02379593f, 
    0.08159583f, 0.06548055f, -0.07430930f, -0.07044409f, 0.10539565f, 0.02647432f, 0.10246502f, -0.10157806f, 
    -0.05120606f, -0.09418285f, -0.08383593f, -0.02713758f, 0.08299798f, -0.03351074f, 0.06054954f, -0.07337120f, 
    -0.02702053f, -0.05857331f, -0.12380023f, 0.06437457f, -0.01634757f, 0.01996498f, -0.07016742f, -0.06722356f, 
    -0.10600448f, -0.04056923f, -0.12917127f, -0.09295320f, -0.09429638f, -0.06326258f, -0.05742031f, 0.11271167f, 
    -0.11465049f, -0.00931959f, 0.10116791f, 0.10133453f, -0.03897439f, -0.08413056f, 0.08323608f, -0.11240058f, 
    -0.01674041f, 0.22174422f, -0.02063041f, 0.28800273f, 0.00764254f, 0.05978671f, 0.13278598f, 0.43991598f, 
    -0.11839869f, 0.27326149f, 0.44233292f, 0.04281560f, -0.30544266f, -0.18014151f, 0.01301001f, 0.17214608f, 
    0.20608778f, 0.14520060f, 0.00065863f, 0.28941777f, -0.08756652f, -0.25693679f, -0.23258077f, 0.12638755f, 
    0.15739217f, -0.10057639f, -0.12391642f, 0.11242422f, 0.21247140f, -0.21240015f, -0.01502283f, -0.07569017f, 
    0.06783839f, -0.09905995f, -0.07863577f, -0.32869172f, -0.03984180f, -0.07938150f, 0.19002989f, -0.17286909f, 
    -0.07386056f, -0.24640863f, 0.48276937f, 0.02245858f, -0.05296528f, 0.04656354f, 0.07276416f, -0.08235914f, 
    0.07814605f, -0.05959154f, 0.09224269f, -0.16956806f, -0.00876587f, -0.16326238f, 0.63683975f, -0.05308546f, 
    0.06468307f, 0.05853974f, 0.14410698f, 0.32308936f, 0.02411489f, 0.25582770f, 0.20929384f, 0.00741204f, 
    0.08414918f, -0.08044989f, 0.00598231f, -0.07497488f, -0.01010268f, -0.05417513f, -0.00656363f, 0.08911227f, 
    0.04976872f, -0.01922421f, -0.03940711f, -0.04695679f, -0.00174896f, 0.00249137f, -0.12914729f, 0.05883188f, 
    -0.06321722f, 0.08524825f, -0.05879596f, 0.00105968f, -0.01348229f, -0.01778946f, 0.07701483f, -0.07985479f, 
    0.02974113f, 0.05421063f, -0.00538918f, 0.06359847f, -0.05645147f, 0.07472825f, 0.07790779f, -0.01254108f, 
    -0.11149745f, 0.09731603f, 0.08993457f, 0.10261811f, -0.05306598f, -0.09616861f, 0.03987617f, 0.10827850f, 
    0.08359598f, 0.00244829f, -0.02866938f, -0.11541869f, -0.03156429f, 0.03231655f, 0.01404661f, -0.08038781f, 
    -0.02458925f, 0.01265830f, -0.08139858f, -0.12981671f, -0.05851122f, 0.01006053f, -0.04267013f, 0.09516552f, 
    -0.09308591f, -0.13393968f, -0.01124219f, 0.10403341f, 0.07650615f, -0.00659815f, -0.01863999f, 0.07857144f, 
    0.09781436f, -0.36477920f, 0.09739359f, 0.09534377f, -0.05598193f, -0.18068331f, 0.30147848f, 0.33121127f, 
    -0.07454757f, 0.19948363f, -0.17363060f, -0.32670552f, 0.16529967f, 0.08889837f, 0.31400982f, 0.04504069f, 
    -0.28636569f, -0.04608627f, 0.08699780f, 0.11319634f, 0.37197244f, -0.28279212f, 0.63587773f, 0.34943825f, 
    -0.00069488f, -0.03253477f, -0.16791777f, 0.13217667f, -0.08657204f, 0.29380888f, -0.08561495f, 0.06576254f, 
    0.25424367f, 0.09306334f, -0.01185310f, 0.21055451f, 0.37125111f, 0.18159267f, -0.02789311f, 0.32570010f, 
    0.03114839f, -0.03133295f, -0.09295723f, 0.06192741f, 0.15311392f, 0.15107149f, 0.39316031f, 0.42925110f, 
    0.00237398f, -0.13952431f, 0.13488324f, 0.33573702f, 0.09450401f, -0.02549312f, 0.44227037f, -0.11681771f, 
    -0.07455102f, 0.31467953f, 0.06669390f, 0.29396090f, 0.04830852f, 0.38447389f, 0.19244385f, -0.19436336f, 
    -0.05348529f, -0.29611784f, -0.08489562f, 0.06603345f, -0.05359321f, -0.48476627f, 0.01953084f, -0.12303822f, 
    -0.05198313f, 0.14762987f, -0.38785091f, -0.04731569f, 0.13539973f, -0.13242818f, 0.26107526f, 0.06876310f, 
    -0.17395721f, -0.21043091f, 0.30221164f, -0.03685925f, 0.25238949f, -0.19022788f, 0.57515448f, 0.01820700f, 
    -0.16111574f, -0.12035820f, -0.28967354f, 0.00363702f, -0.44863832f, 0.10825950f, 0.09225470f, -0.13815925f, 
    0.19907193f, 0.06514660f, -0.07854991f, -0.24186835f, 0.28358489f, 0.35496056f, -0.09179726f, -0.32744241f, 
    0.09857955f, -0.12024789f, -0.22901337f, 0.02087303f, 0.22127478f, -0.05067553f, 0.29275832f, 0.35448310f, 
    -0.03731500f, -0.04759468f, -0.13982274f, 0.20475452f, -0.06166296f, 0.04266288f, -0.14333613f, -0.11355893f, 
    0.44170997f, -0.06183242f, -0.12764810f, 0.15977699f, 0.11923084f, 0.03964212f, 0.01159892f, 0.02314636f, 
    -0.07341287f, -0.08280163f, -0.13709636f, 0.06981794f, 0.08469255f, 0.05630770f, 0.00198539f, -0.00254134f, 
    0.03189457f, -0.13122432f, -0.03971607f, -0.07555581f, -0.03103464f, -0.05248453f, -0.10373601f, -0.00330830f, 
    -0.07320794f, -0.00962588f, 0.06178913f, -0.05541421f, -0.05911290f, -0.08277062f, 0.04276321f, -0.12096377f, 
    -0.05543730f, 0.03108032f, -0.09844686f, -0.04165825f, 0.03792850f, 0.03897938f, 0.00771597f, -0.08244118f, 
    -0.10114692f, 0.08027622f, -0.01614608f, -0.06217808f, -0.00879035f, -0.04123049f, -0.05527360f, 0.02336860f, 
    -0.08899772f, 0.01193507f, -0.10841987f, -0.04704417f, -0.02472145f, -0.04058580f, 0.05643329f, -0.02942062f, 
    -0.03219382f, -0.05385751f, 0.04984977f, 0.00102402f, -0.01518676f, -0.08719702f, -0.03764914f, 0.09311315f, 
    -0.10023859f, -0.11864282f, 0.07546350f, 0.03650026f, 0.00018823f, -0.02150477f, 0.00438681f, -0.09594528f, 
    0.44604817f, -0.30927098f, 0.20164211f, 0.20636441f, 0.07114936f, 0.13146497f, 0.05120831f, -0.09063708f, 
    0.06183598f, -0.14924659f, -0.21895747f, -0.19386066f, 0.12781955f, -0.30114815f, -0.24369183f, 0.54877281f, 
    0.08612859f, 0.22987287f, 0.15388620f, 0.47823063f, 0.04860849f, -0.33030778f, -0.05642692f, 0.04663380f, 
    0.09241467f, 0.06570143f, -0.18119696f, 0.01117028f, -0.11374960f, 0.00010474f, -0.01047467f, -0.06337624f, 
    0.00976129f, -0.16705960f, 0.01808099f, -0.42766881f, -0.05461706f, 0.36656907f, 0.23008573f, 0.00488462f, 
    -0.09546761f, 0.21433070f, -0.10632543f, 0.24632865f, -0.07860764f, 0.36502436f, -0.05284017f, 0.06338209f, 
    0.22426175f, -0.15138312f, 0.30784163f, 0.05834346f, -0.00911420f, -0.24478680f, -0.16495284f, -0.00976080f, 
    0.07128562f, 0.38270682f, 0.16898230f, 0.12290165f, 0.17036556f, -0.00196651f, 0.15482235f, 0.24127002f, 
    -0.13740495f, 0.04596556f, -0.06788808f, 0.09911805f, 0.09554221f, -0.07073453f, 0.08849644f, -0.13440104f, 
    -0.09502503f, 0.02373788f, -0.10589104f, 0.00513752f, 0.08996046f, 0.09303439f, -0.07919168f, -0.02016182f, 
    -0.07169040f, 0.01800216f, 0.07838865f, -0.12349540f, -0.04255280f, 0.06036709f, 0.05578920f, -0.06481246f, 
    -0.11372346f, 0.09903979f, 0.06800980f, 0.05836944f, -0.06841818f, -0.07875051f, -0.03284258f, 0.00189210f, 
    0.01318205f, -0.06996430f, -0.07260369f, 0.07548142f, 0.06673113f, 0.03356362f, 0.02621442f, 0.01102540f, 
    -0.00083351f, -0.08742295f, -0.08566325f, -0.06633811f, -0.02310519f, -0.12269314f, -0.05784322f, -0.07060304f, 
    -0.07197794f, -0.00102073f, 0.04618815f, -0.07156494f, -0.09556203f, 0.00893240f, 0.01464395f, 0.09897682f, 
    -0.11518914f, -0.04432059f, -0.11256660f, -0.12262319f, 0.02792966f, -0.10759411f, 0.10309782f, -0.10559334f, 
    -0.09016153f, 0.01111957f, -0.12226443f, -0.01539098f, 0.11173801f, -0.05936626f, -0.11510400f, 0.05769359f, 
    0.02883862f, 0.09649192f, -0.10861878f, -0.11464596f, -0.10901026f, -0.08388636f, -0.12004311f, 0.00331017f, 
    0.05331294f, 0.05484816f, -0.00055823f, 0.04385272f, -0.04545783f, 0.04929350f, 0.06208633f, 0.08666475f, 
    -0.08632292f, 0.07578883f, -0.09822126f, 0.08730166f, 0.03264458f, 0.08094259f, 0.03471054f, -0.09329015f, 
    0.04073960f, -0.09570430f, -0.09811723f, -0.10688975f, 0.07345124f, 0.01876897f, 0.05787617f, 0.00406341f, 
    0.01297764f, -0.01688626f, -0.10030144f, -0.06467426f, -0.05048808f, -0.04466434f, 0.08255032f, 0.04209584f, 
    -0.10072029f, 0.02122651f, 0.01099537f, 0.02917069f, -0.01997305f, -0.06226024f, -0.06851648f, 0.06547339f, 
    -0.01170348f, 0.04677793f, -0.00758804f, -0.12288523f, -0.10097946f, 0.06252103f, -0.08150297f, 0.03494200f, 
    0.23495613f, 0.04889458f, 0.03537288f, -0.00422113f, 0.02472017f, 0.13729443f, 0.05794185f, 0.12041910f, 
    -0.10881185f, -0.14695866f, -0.29651502f, 0.17180610f, -0.22913021f, -0.16675159f, -0.52214754f, 0.10160511f, 
    0.31132483f, 0.41873148f, 0.10416321f, 0.13126417f, -0.45401713f, -0.07971118f, -0.28984061f, -0.33826971f, 
    0.19636589f, -0.23681618f, 0.04440352f, -0.07233625f, 0.20322426f, 0.03797581f, -0.02678084f, -0.22165141f, 
    0.07282144f, -0.06592761f, -0.01401320f, -0.32629126f, -0.00300335f, -0.02076840f, 0.26306766f, -0.00144370f, 
    -0.05970964f, -0.10249992f, 0.23693633f, -0.15682307f, 0.09180852f, 0.23141962f, 0.20966236f, 0.29840377f, 
    0.15175955f, -0.15925470f, 0.34729201f, -0.03341977f, -0.09311713f, -0.17892542f, 0.44158775f, -0.02081256f, 
    0.17211115f, 0.00941451f, 0.26339814f, 0.02269568f, -0.08299498f, -0.25132769f, 0.11817680f, 0.14405379f, 
    0.04892443f, 0.38524273f, -0.11824795f, 0.17822109f, 0.04785948f, 0.41078293f, 0.04550546f, 0.35688710f, 
    -0.07418089f, 0.02016875f, 0.43278608f, 0.12860405f, -0.33357430f, -0.13988666f, -0.11615504f, -0.01370870f, 
    0.06770733f, 0.68276459f, 0.26080361f, 0.03415684f, -0.27011049f, -0.06244234f, -0.25313190f, -0.28266820f, 
    0.14771371f, -0.42329314f, 0.13246717f, 0.04685329f, 0.17512679f, 0.39071065f, -0.00034668f, -0.20769399f, 
    -0.03655618f, -0.15904227f, -0.07517906f, -0.09079075f, -0.11857259f, 0.11379124f, 0.21458828f, 0.31242770f, 
    -0.01452602f, -0.25843862f, -0.19707561f, -0.20731376f, 0.32082400f, -0.05758529f, 0.15386808f, -0.03539240f, 
    -0.05604699f, -0.25079593f, 0.21702419f, 0.12064947f, 0.00850007f, 0.12813526f, 0.27811897f, -0.03032823f, 
    0.36711913f, -0.19037068f, 0.21763350f, 0.01409450f, -0.02980092f, 0.05575285f, 0.25322208f, 0.06306486f, 
    -0.08194590f, 0.05635558f, -0.12955414f, 0.04051755f, 0.03827645f, -0.05748450f, 0.07408337f, 0.01946378f, 
    -0.07735289f, 0.08446006f, -0.05244101f, -0.13286704f, -0.10102893f, -0.07029687f, 0.05651837f, -0.05592873f, 
    -0.12487916f, -0.09620584f, -0.07140869f, -0.10735533f, -0.07346381f, 0.10242885f, 0.09450784f, -0.09712142f, 
    -0.12264205f, 0.07914533f, -0.00348038f, -0.08609542f, -0.11188743f, -0.15220955f, 0.04665770f, 0.06036587f, 
    0.09273522f, 0.03145631f, -0.09704269f, -0.10236327f, -0.14021967f, -0.06416816f, -0.04897725f, -0.08057691f, 
    0.00316911f, 0.07911234f, -0.09533389f, -0.07053662f, -0.06071990f, -0.07900906f, 0.09762811f, 0.00720127f, 
    -0.09984281f, -0.02567899f, -0.01757614f, -0.10223687f, 0.01353371f, -0.19037297f, -0.09729218f, -0.03594346f, 
    -0.10439400f, 0.07985786f, -0.02210058f, 0.03672783f, -0.05424689f, 0.06453849f, -0.00319892f, 0.02161978f, 
    -0.11818341f, 0.00792798f, -0.20921557f, 0.42790502f, -0.06347992f, -0.10482214f, 0.23172180f, -0.16580388f, 
    -0.12467229f, 0.16215603f, 0.13493165f, 0.12274837f, -0.05590829f, 0.04089640f, 0.22020401f, -0.18137659f, 
    -0.00798420f, -0.50086892f, 0.23469584f, -0.10036656f, 0.29320464f, -0.05080628f, 0.43102214f, 0.17944112f, 
    -0.15725896f, -0.17760900f, -0.12008750f, -0.00476849f, -0.06429239f, 0.03871397f, 0.00121057f, -0.10805892f, 
    0.26771003f, 0.12346430f, -0.00748828f, -0.18676031f, 0.04903356f, 0.11459758f, -0.04389081f, -0.14608689f, 
    -0.03234315f, -0.39746463f, -0.11499836f, 0.03161748f, 0.08883589f, -0.10531417f, 0.15113425f, 0.14879325f, 
    -0.04038665f, -0.03827578f, -0.10865253f, -0.00051073f, -0.00994785f, 0.00463766f, 0.23353250f, 0.07684013f, 
    0.34187192f, -0.10947388f, -0.29960400f, 0.33396384f, -0.12391449f, 0.15432596f, 0.02485039f, -0.01575237f, 
    -0.07494520f, 0.06593750f, 0.03638573f, -0.03836827f, -0.10919325f, -0.02005761f, 0.02013877f, -0.09460101f, 
    0.06694748f, -0.11675183f, 0.10236832f, 0.04917900f, 0.05770759f, 0.14925650f, 0.08600732f, 0.05910229f, 
    -0.10962557f, -0.06654912f, -0.00964460f, -0.05424012f, 0.06569326f, 0.02065276f, -0.03032844f, 0.05774269f, 
    -0.08693800f, -0.06609528f, -0.13682869f, 0.08604854f, -0.03049863f, -0.00738475f, -0.04066913f, -0.14080508f, 
    -0.06572986f, -0.03030489f, 0.00989656f, -0.00241091f, -0.00029283f, -0.08279026f, -0.12687236f, -0.11450863f, 
    0.00973600f, -0.05452240f, -0.00053951f, -0.00096774f, 0.06350521f, 0.05737223f, 0.05216600f, -0.00669920f, 
    0.02207442f, -0.14484172f, 0.03472895f, -0.04365794f, -0.09870449f, -0.17737590f, -0.07888511f, -0.07315034f, 
    -0.05920592f, -0.02425169f, -0.15168318f, -0.14995052f, -0.09511004f, 0.01576900f, -0.11862591f, -0.01584131f, 
    0.22388166f, 0.16637383f, -0.04800256f, -0.09289993f, -0.10668208f, -0.20039076f, 0.18332531f, -0.34901577f, 
    -0.07174364f, 0.18862361f, 0.05029167f, 0.12968545f, 0.05520292f, -0.11170325f, 0.38932672f, -0.26778197f, 
    -0.22495000f, -0.03970353f, 0.19461718f, -0.22897106f, 0.00821044f, 0.12803604f, 0.23647542f, 0.07676407f, 
    0.03194126f, -0.11820374f, -0.16969699f, -0.01984971f, -0.47758874f, -0.21146104f, 0.01996769f, 0.05750593f, 
    0.06043148f, 0.25510848f, -0.00443549f, 0.10452060f, 0.02446663f, 0.12950517f, 0.07855991f, 0.44894481f, 
    0.08507584f, -0.15944824f, 0.03177613f, -0.09314598f, -0.08735092f, -0.29689887f, -0.06627576f, 0.20188360f, 
    -0.45002887f, 0.02806591f, -0.43212879f, -0.08646517f, 0.07677165f, 0.16651189f, 0.26057076f, -0.11197342f, 
    0.00958672f, -0.36236501f, -0.45683768f, 0.19732310f, -0.08670807f, 0.04675621f, -0.16406125f, 0.09729346f, 
    -0.02495939f, -0.00478947f, -0.13182232f, -0.00491811f, 0.09479727f, -0.16496885f, -0.01370140f, -0.09825614f, 
    -0.04745535f, -0.00242243f, 0.07786036f, -0.02976665f, -0.04144807f, -0.10541913f, -0.09469989f, 0.04868361f, 
    0.03183284f, -0.06570923f, -0.10117766f, -0.12294474f, -0.02715714f, 0.01192059f, -0.09148492f, -0.10267946f, 
    -0.08711803f, 0.00497746f, -0.02985089f, 0.06494032f, 0.04711388f, -0.10917772f, -0.03383778f, -0.00218245f, 
    -0.15416361f, 0.00028001f, 0.07256192f, -0.01052063f, -0.11654881f, 0.07784134f, -0.12616494f, 0.11072150f, 
    0.04050528f, -0.01401349f, -0.11205280f, -0.04513856f, -0.07814852f, -0.09962677f, 0.03605084f, 0.03984474f, 
    0.00408352f, -0.06559953f, -0.08111400f, 0.09273330f, -0.01506850f, -0.02247364f, -0.04159658f, -0.11615553f, 
    0.01348719f, -0.05574361f, -0.04959899f, -0.12488144f, -0.01752602f, -0.04530492f, -0.12208254f, -0.07158151f, 
    -0.09175912f, 0.02668336f, 0.02442192f, -0.01750427f, 0.05093830f, 0.09471908f, 0.02590181f, -0.01472068f, 
    -0.07284168f, -0.09222309f, 0.10539919f, -0.13088249f, 0.10958205f, -0.03723521f, -0.00731554f, -0.06456489f, 
    -0.03326661f, 0.02858309f, -0.08663905f, -0.14363496f, 0.00718236f, -0.10748631f, -0.13699068f, -0.12766476f, 
    -0.00394565f, 0.01054511f, -0.10580370f, 0.01529962f, 0.09131629f, -0.03130944f, 0.01052347f, -0.10563784f, 
    0.00266300f, -0.06482020f, -0.02427761f, 0.05258105f, -0.03398765f, 0.01078193f, -0.06076188f, 0.05451094f, 
    -0.00888166f, -0.01941826f, -0.09093585f, 0.10248050f, 0.01549453f, -0.07053895f, 0.10534209f, 0.04552500f, 
    -0.14568093f, 0.10792134f, -0.08694664f, -0.12575012f, 0.11014355f, 0.02845944f, -0.08978295f, 0.05192497f, 
    -0.02218382f, -0.01287731f, 0.00441016f, -0.15475826f, 0.00831305f, -0.12960027f, 0.07454714f, 0.00609531f, 
    0.08881167f, 0.46436727f, -0.01313616f, -0.11097185f, -0.05157532f, -0.00854311f, -0.17025498f, 0.20266598f, 
    0.00903928f, 0.02039238f, 0.41343996f, -0.05075638f, 0.02085281f, -0.01597934f, -0.21614283f, 0.06050140f, 
    0.26309827f, 0.29716647f, -0.02556056f, 0.51175767f, -0.20877162f, 0.01830408f, -0.57017565f, 0.12114774f, 
    0.11304067f, 0.03501839f, 0.26660496f, -0.11046688f, 0.26209772f, -0.31662831f, 0.10244802f, 0.00480068f, 
    0.24891780f, 0.01010611f, -0.02307011f, 0.12875707f, -0.08698552f, -0.45376235f, 0.09248818f, 0.08170304f, 
    0.02934610f, -0.28930369f, 0.25021380f, 0.20772128f, 0.00852721f, 0.09739340f, 0.14677599f, 0.10555980f, 
    0.01460992f, -0.01409679f, 0.05833229f, 0.07308413f, 0.11293682f, -0.13260885f, 0.12748842f, -0.02475770f, 
    -0.36867401f, 0.03452534f, 0.17576148f, -0.07561059f, 0.18051900f, 0.10142107f, 0.10496852f, 0.11742350f, 
    0.06628148f, -0.34978163f, 0.09313768f, 0.30990326f, 0.06959335f, -0.04193881f, 0.20578878f, 0.49889126f, 
    0.04444152f, -0.08013387f, -0.05339740f, -0.03216081f, 0.16237292f, -0.04945377f, -0.02246477f, -0.10573612f, 
    -0.08516930f, -0.13291034f, -0.36013046f, -0.01869988f, -0.29879111f, -0.00161071f, -0.49952939f, -0.08024883f, 
    -0.04334173f, 0.29252815f, 0.18390198f, 0.02216421f, -0.02054427f, 0.37189218f, -0.07954127f, 0.20567617f, 
    -0.09864917f, -0.02472434f, 0.10203550f, 0.55531716f, 0.20630403f, -0.16346113f, 0.00304647f, 0.13649334f, 
    0.08283384f, 0.09848415f, 0.56325382f, -0.03952311f, -0.14645602f, -0.05089844f, 0.24025057f, 0.12031019f, 
    0.19458456f, 0.19299407f, 0.15426190f, 0.13432270f, -0.03099473f, 0.13251282f, 0.43760315f, 0.07253247f, 
    -0.31794190f, 0.18888469f, 0.20728084f, -0.22477259f, 0.13792047f, -0.05294315f, 0.17242183f, 0.07303319f, 
    0.26075599f, 0.31056046f, 0.05560591f, -0.09745236f, 0.01611794f, 0.06732871f, -0.27062166f, 0.04894560f, 
    -0.10891656f, -0.09067509f, -0.12588985f, 0.18756899f, 0.16878413f, 0.28098914f, 0.11229718f, 0.15501106f, 
    0.29767302f, 0.09814479f, 0.23405871f, 0.20862408f, -0.20413099f, 0.14787492f, -0.25215882f, -0.05560382f, 
    0.00195824f, 0.08912510f, 0.39551204f, 0.04813060f, 0.13462187f, -0.18907416f, 0.07304760f, -0.06151374f, 
    -0.07301910f, 0.05213358f, -0.02648360f, 0.17605807f, -0.08983329f, -0.49154606f, 0.06299018f, -0.16173241f, 
    -0.08914734f, 0.22808740f, 0.29681897f, 0.23191997f, -0.11196966f, 0.21702886f, -0.17204456f, 0.04485885f, 
    0.03308157f, 0.17989726f, 0.04385453f, 0.24034181f, -0.09243917f, 0.21208373f, 0.26910606f, -0.07875177f, 
    -0.37384892f, 0.12179387f, 0.07697997f, -0.22820275f, 0.22527933f, -0.14203659f, -0.13977154f, 0.29691264f, 
    -0.40209281f, 0.14872275f, 0.11106186f, -0.23766106f, 0.11832786f, 0.29865569f, -0.00571750f, 0.31943533f, 
    0.02301739f, 0.12065119f, 0.24023668f, 0.34416455f, -0.19812897f, -0.02746428f, 0.17756107f, -0.37719941f, 
    0.28442502f, 0.30909973f, 0.08922895f, 0.00174524f, -0.19139116f, -0.02668714f, 0.05607970f, 0.05258591f, 
    -0.01805229f, 0.20256551f, 0.01662144f, 0.08628368f, 0.31608790f, 0.13055930f, 0.06598626f, -0.02611263f, 
    -0.03953755f, 0.04945855f, 0.09142870f, -0.15052681f, -0.13154958f, 0.48345506f, 0.00428387f, 0.05147361f, 
    -0.09865190f, 0.18093942f, 0.20051603f, -0.25471830f, 0.24269558f, -0.28524050f, 0.20162761f, -0.36032012f, 
    0.15376534f, -0.11656745f, -0.09365012f, 0.12822324f, 0.03901117f, 0.23286411f, 0.24281104f, 0.10423772f, 
    0.30446920f, 0.04800025f, 0.00129187f, 0.12914179f, 0.15309335f, 0.12082881f, 0.27259815f, 0.08212151f, 
    -0.06637673f, 0.45834950f, 0.07698246f, -0.00957949f, -0.08025325f, 0.16777837f, -0.29113510f, -0.05638041f, 
    -0.08498046f, 0.08040544f, 0.15940891f, 0.33703792f, 0.04341040f, 0.13507460f, 0.26702756f, -0.05559015f, 
    0.32284480f, 0.19210064f, 0.01860911f, 0.05502302f, 0.16736326f, 0.29910257f, -0.05911582f, 0.23604216f, 
    0.18762906f, 0.40909472f, 0.24681307f, 0.14867048f, 0.23224057f, -0.14804469f, -0.00520998f, 0.23484789f, 
    0.00842384f, 0.15112372f, 0.04456616f, -0.11763191f, -0.21002834f, 0.06425969f, 0.17369142f, 0.15480559f, 
    -0.04651104f, 0.38890493f, -0.09543313f, 0.14284597f, 0.04354349f, -0.01759898f, -0.24067080f, -0.32994127f, 
    0.03233282f, 0.11362377f, -0.15801531f, -0.09228797f, 0.17147654f, 0.42769539f, -0.41852307f, 0.06774218f, 
    0.11698585f, -0.02044072f, -0.16830246f, 0.06266724f, -0.01158769f, -0.00074846f, 0.11202541f, 0.30846208f, 
    -0.14132591f, 0.23812793f, -0.12793340f, -0.20265779f, 0.02338209f, 0.06716411f, 0.19465680f, 0.03078288f, 
    0.11951136f, 0.02092229f, -0.08875893f, 0.37338841f, 0.13775501f, 0.28686410f, -0.23594470f, -0.27393955f, 
    0.11103133f, 0.42094997f, 0.33806872f, -0.19854492f, -0.02295853f, -0.11982448f, 0.15833145f, -0.09616386f, 
    -0.08352086f, -0.15684362f, 0.27641511f, -0.06972847f, -0.01805345f, -0.09658265f, -0.00874979f, -0.06323294f, 
    0.12147109f, 0.31071231f, -0.10949798f, 0.37599918f, 0.40247557f, 0.14808743f, -0.23309135f, 0.12132059f, 
    0.05785640f, -0.27118286f, 0.13890143f, -0.00871584f, 0.14802149f, -0.01884615f, 0.30366334f, 0.31135598f, 
    0.14198163f, 0.26407805f, -0.20245066f, 0.20514756f, 0.11197290f, -0.02287104f, -0.09878652f, -0.05108228f, 
    -0.03279082f, -0.22804667f, -0.01535202f, -0.31014082f, 0.22711454f, -0.20233044f, 0.09174471f, 0.03808250f, 
    0.03915767f, 0.01590129f, -0.05007156f, 0.22124194f, -0.06789604f, 0.28098813f, 0.01958518f, 0.56916195f, 
    0.05207985f, -0.10528451f, 0.07820749f, -0.00650119f, -0.01592906f, -0.18872221f, -0.17122750f, 0.21915086f, 
    0.08311971f, 0.48438138f, 0.11411124f, 0.31989107f, 0.04225508f, -0.24408810f, -0.29373521f, -0.13325334f, 
    0.24886476f, -0.25862893f, -0.04908051f, -0.07770245f, 0.29852986f, 0.31143156f, -0.02640477f, -0.14016023f, 
    0.05112875f, -0.21735083f, -0.06356825f, -0.01509552f, -0.02751278f, 0.09987092f, 0.27226248f, 0.18071559f, 
    -0.08767723f, -0.31480554f, 0.18467563f, -0.06902441f, 0.02124761f, 0.17411542f, 0.23738749f, 0.00031689f, 
    0.14306355f, -0.27526727f, 0.21552381f, 0.30741614f, -0.08824661f, -0.15490212f, 0.35715136f, -0.10521622f, 
    0.10695388f, 0.01957412f, 0.29248002f, 0.02866941f, 0.08685651f, 0.11469045f, 0.33234060f, 0.02112371f, 
    -0.02016315f, -0.21108432f, 0.05445347f, -0.22441545f, 0.02015283f, -0.36789349f, 0.17603855f, -0.10031840f, 
    0.04473500f, -0.00361048f, -0.15093346f, 0.25920227f, 0.39012820f, 0.06936624f, -0.69857627f, 0.06764130f, 
    0.08360597f, -0.22735754f, -0.09706200f, 0.27207348f, 0.00157442f, -0.28341120f, -0.18679443f, 0.11872031f, 
    0.11674314f, 0.59520882f, 0.16783664f, 0.08392904f, 0.07902808f, -0.46867126f, -0.09763307f, 0.30471110f, 
    0.23700613f, 0.20209657f, -0.05952815f, 0.37744752f, 0.27654144f, -0.19709577f, -0.24487504f, -0.09322280f, 
    -0.10590272f, 0.25908494f, 0.31773409f, 0.42617521f, -0.32479221f, 0.18643698f, 0.17372869f, 0.29187545f, 
    0.25752413f, 0.27739641f, -0.08853775f, -0.05847990f, 0.04664043f, -0.36896566f, -0.30243245f, -0.06003425f, 
    -0.53929305f, 0.17544353f, 0.04530417f, -0.42156294f, 0.05171220f, -0.15031390f, -0.12054203f, 0.23106846f, 
    0.27857000f, 0.02551226f, 0.26146939f, 0.13601610f, -0.05052711f, 0.07235486f, -0.13021700f, -0.45220786f, 
    -0.08649442f, -0.14415254f, -0.20258065f, -0.18632460f, -0.03440995f, -0.11706387f, 0.05682898f, 0.50674427f, 
    -0.13064323f, -0.07450371f, 0.04199521f, 0.25320849f, 0.05464179f, -0.11160289f, -0.03289839f, 0.15589906f, 
    0.21707581f, 0.10915421f, 0.02539309f, -0.04012797f, -0.07245100f, -0.25395817f, -0.05390372f, -0.04064337f, 
    -0.03284000f, -0.03171555f, 0.03401692f, -0.15232943f, -0.17290245f, -0.22884491f, 0.30715942f, -0.18907958f, 
    0.07752081f, 0.34450665f, -0.49153948f, 0.30772546f, -0.25554529f, 0.28239709f, -0.17485088f, 0.07083505f, 
    -0.08935639f, 0.20717822f, 0.14210072f, 0.02838177f, -0.07623228f, 0.14898311f, -0.20018223f, -0.03574982f, 
    -0.21679653f, 0.20215237f, 0.17426611f, 0.10873125f, -0.09441557f, 0.18693972f, -0.11142001f, 0.25550112f, 
    -0.00986965f, 0.04595672f, -0.05355268f, 0.00223804f, -0.09854375f, -0.08117285f, 0.02762385f, -0.09673800f, 
    0.03438690f, -0.04066875f, 0.03533266f, -0.11510593f, -0.00733840f, -0.10749167f, -0.10514778f, 0.01942955f, 
    0.09558016f, 0.11597373f, -0.07831763f, -0.11192339f, -0.06640748f, -0.05100802f, -0.05070180f, -0.04300493f, 
    -0.02785490f, -0.04448645f, 0.01813664f, -0.06220335f, 0.02119789f, 0.09948693f, -0.01753093f, -0.00142912f, 
    -0.04318501f, -0.11627232f, 0.03653564f, 0.04607858f, -0.09491083f, 0.00816323f, -0.05805521f, 0.04200812f, 
    -0.05549601f, -0.09705307f, -0.08270653f, -0.07381535f, 0.09311086f, -0.07079719f, -0.11102703f, -0.10509190f, 
    -0.09319380f, 0.05299307f, 0.10817535f, 0.07940386f, -0.06693232f, 0.07700716f, 0.07128540f, 0.00822340f, 
    -0.07277846f, 0.10845077f, -0.03934116f, 0.06365091f, -0.07060228f, -0.09307022f, 0.03765357f, -0.07763498f, 
    -0.06377921f, 0.13292900f, -0.09710631f, -0.07597840f, -0.04778890f, -0.05478010f, 0.00609019f, 0.00052849f, 
    0.10710052f, 0.05895501f, 0.08614080f, 0.09794059f, 0.07400757f, -0.06687927f, 0.00153350f, -0.12164006f, 
    0.00546893f, 0.04855648f, 0.00786505f, 0.05769452f, 0.06260708f, -0.12230715f, 0.06881794f, 0.01126359f, 
    -0.07337686f, -0.03619496f, 0.06540491f, 0.08303581f, -0.09492841f, -0.04486974f, -0.04777060f, -0.01283235f, 
    0.01848964f, -0.03007076f, -0.08480783f, 0.05654840f, 0.08772979f, -0.10943878f, -0.00197070f, 0.01481567f, 
    -0.07952596f, 0.02342339f, -0.08059143f, -0.11634798f, -0.03399378f, -0.14423025f, -0.09976492f, -0.07978404f, 
    -0.06830771f, -0.09075379f, -0.09094052f, -0.08819184f, 0.08150017f, -0.14092699f, -0.10480813f, -0.08157638f, 
    0.01041414f, -0.03766553f, -0.12598352f, -0.05011392f, 0.00719420f, -0.08057870f, 0.04227438f, -0.01713983f, 
    0.25730285f, 0.05350038f, 0.12721649f, -0.24845271f, 0.10625048f, -0.00352664f, -0.30471817f, -0.13608506f, 
    0.13062364f, -0.12553434f, -0.21654302f, 0.22038682f, 0.01593790f, 0.05266822f, 0.37704986f, 0.31712463f, 
    0.17898373f, 0.00022876f, 0.02157874f, 0.27455169f, -0.00237292f, 0.25856367f, 0.21257679f, 0.01400623f, 
    -0.09563012f, 0.27222425f, 0.04195456f, -0.09648099f, -0.16200034f, 0.16224997f, 0.02355159f, 0.04026245f, 
    -0.27322337f, -0.14402726f, -0.08859196f, -0.45061263f, -0.20237254f, 0.14458589f, 0.50899428f, 0.04860265f, 
    -0.06402592f, 0.78074098f, -0.17834796f, -0.13686861f, -0.08427405f, 0.20898488f, -0.11268059f, -0.03944339f, 
    0.18063857f, 0.13142368f, -0.02344479f, 0.32494286f, -0.01305656f, 0.82313234f, -0.19325216f, 0.06095299f, 
    0.30663136f, 0.05407213f, -0.01616399f, 0.14510693f, 0.07632332f, -0.10798914f, 0.09612861f, 0.32534701f, 
    -0.19512919f, 0.00165755f, 0.01353929f, 0.18578519f, 0.12584038f, 0.14391284f, 0.26915184f, -0.03872504f, 
    -0.07318157f, 0.03902344f, -0.00107802f, 0.35900274f, 0.11012720f, -0.04094160f, -0.06081253f, -0.30190504f, 
    0.26369089f, 0.29054615f, 0.18691744f, -0.63878465f, -0.09134115f, -0.31115133f, -0.04231663f, -0.18574592f, 
    0.19717114f, 0.05936219f, 0.22519767f, 0.02344141f, 0.09718465f, 0.21045075f, 0.02146436f, 0.16494432f, 
    0.07591657f, 0.21787924f, -0.03602205f, 0.63740897f, 0.24354857f, 0.34584075f, -0.43160766f, 0.14774394f, 
    -0.09278674f, 0.05795872f, 0.13822934f, 0.17013763f, -0.11589175f, -0.18848820f, 0.24859221f, 0.00479384f, 
    0.08016159f, 0.35144320f, -0.15009560f, -0.22821094f, -0.06072436f, -0.15512280f, -0.38075259f, -0.11423343f, 
    0.14256719f, -0.20237397f, 0.17574342f, -0.37981275f, -0.20783876f, -0.15714906f, 0.02585662f, 0.19216195f, 
    -0.10483973f, 0.26029363f, 0.08451010f, -0.10169222f, 0.05879983f, 0.07154576f, -0.08125457f, 0.33725098f, 
    0.06564347f, -0.01884165f, 0.16669613f, -0.01993859f, -0.02819011f, 0.37810963f, 0.18307476f, 0.06047161f, 
    0.21877655f, -0.13545726f, -0.10453535f, 0.31140831f, -0.14539483f, 0.18378845f, -0.36559224f, 0.06640396f, 
    0.00777271f, 0.17848200f, 0.40850264f, 0.02215410f, 0.20180954f, 0.11628168f, -0.03839065f, 0.24842639f, 
    -0.06440461f, 0.08928706f, 0.12614162f, 0.20397465f, -0.16779098f, -0.38639528f, 0.05451434f, 0.05015367f, 
    -0.03053682f, 0.06744030f, 0.54967815f, -0.08729000f, 0.03120752f, -0.04425553f, -0.11091972f, -0.15278442f, 
    0.12210920f, 0.10576639f, 0.03407701f, 0.16252740f, 0.09367205f, 0.18213321f, 0.41034371f, -0.11968541f, 
    -0.32775268f, 0.25633439f, 0.27288118f, -0.02634241f, 0.08842801f, 0.09914625f, 0.13832992f, 0.09088699f, 
    -0.03591532f, -0.01271555f, 0.07661180f, 0.00779686f, -0.05611306f, 0.03544465f, -0.12683946f, -0.11180928f, 
    0.02592525f, -0.19943695f, -0.41155109f, -0.36209959f, 0.47570005f, 0.36271611f, -0.09155281f, -0.15092504f, 
    -0.24023007f, -0.10115505f, 0.14375415f, -0.18764864f, 0.10776071f, -0.31654054f, 0.15288682f, 0.15571770f, 
    -0.15868837f, 0.00268350f, 0.26667023f, -0.06878129f, 0.12365619f, 0.27972358f, -0.11564514f, 0.26243204f, 
    -0.00335635f, 0.05912378f, 0.11061087f, 0.56081575f, 0.18724985f, -0.20573142f, -0.03741340f, 0.16231893f, 
    -0.04452593f, -0.06080497f, -0.18590355f, 0.10528386f, 0.11957060f, 0.15320326f, -0.09961182f, 0.17643057f, 
    0.01748782f, 0.25485337f, -0.11564232f, 0.07308566f, -0.11550373f, 0.18278190f, -0.00131240f, -0.08412579f, 
    -0.36256611f, 0.28234029f, 0.19037890f, 0.01856400f, 0.02645171f, 0.12110998f, -0.13022566f, -0.05702550f, 
    0.04034753f, -0.12985437f, -0.12225334f, 0.11693889f, 0.06264551f, 0.03025818f, -0.05398932f, -0.04045340f, 
    -0.12433198f, 0.05739379f, 0.11660509f, -0.06935791f, -0.00021114f, 0.02314092f, -0.09302130f, 0.09549622f, 
    -0.00197456f, -0.00450383f, 0.01693825f, -0.01065652f, 0.07013073f, -0.06662847f, 0.00315723f, -0.01586599f, 
    -0.14161102f, 0.06111098f, -0.02612024f, 0.01265881f, -0.13591059f, 0.11277963f, -0.00159448f, -0.05906998f, 
    -0.11942825f, -0.06383146f, 0.07433766f, 0.02206074f, 0.01692437f, 0.12413475f, 0.03426398f, -0.02502099f, 
    -0.03352030f, 0.05318696f, -0.05714670f, -0.13725537f, 0.06832901f, 0.05237705f, -0.02832989f, -0.11121131f, 
    0.07571544f, -0.05492486f, -0.12595797f, -0.09836211f, -0.08932912f, 0.04085432f, 0.04278456f, -0.06679748f, 
    0.03903368f, -0.11101884f, -0.10224613f, 0.05373225f, -0.10054007f, 0.03287499f, 0.02976391f, -0.01528207f, 
    0.29453778f, 0.05442502f, -0.03932628f, 0.01746444f, 0.07335512f, -0.29115194f, -0.06783783f, 0.11448604f, 
    0.10169186f, 0.16008294f, 0.20513034f, 0.15149134f, -0.09511076f, -0.38465661f, 0.19671687f, -0.06698869f, 
    -0.19522625f, -0.15437683f, 0.13792714f, -0.05864856f, 0.10766970f, 0.24503122f, 0.02282170f, 0.12142085f, 
    -0.10046948f, -0.18308263f, -0.28209025f, 0.07346476f, -0.25262329f, -0.19308060f, -0.09827644f, -0.21486199f, 
    0.01875348f, 0.18791597f, 0.08621167f, -0.19499658f, 0.13247414f, 0.07181232f, 0.19675423f, -0.08596007f, 
    -0.01444967f, -0.14706060f, 0.01821994f, -0.23451261f, 0.16017479f, -0.13584670f, 0.16262297f, 0.15247929f, 
    -0.13343543f, -0.11812300f, 0.02121352f, 0.10457045f, -0.09846710f, 0.22021288f, 0.31271935f, -0.05435237f, 
    0.15908395f, -0.16234954f, -0.20153376f, 0.19710463f, 0.11724353f, -0.04498802f, -0.02161003f, 0.07083257f, 
    0.22245246f, 0.17228736f, -0.06269936f, -0.01004269f, 0.11565969f, -0.30462295f, 0.13253619f, -0.49324229f, 
    -0.06778093f, 0.05582853f, 0.05762197f, 0.26875532f, -0.05206355f, -0.25828633f, 0.27818561f, -0.31764862f, 
    -0.11362142f, 0.12107489f, 0.11715920f, -0.38711056f, 0.06318905f, 0.21263726f, 0.14285682f, -0.00739821f, 
    -0.00095221f, -0.13812327f, 0.19330770f, -0.11848243f, -0.29209015f, -0.09321760f, 0.04098740f, 0.04814921f, 
    0.14942497f, 0.07250018f, 0.04744467f, 0.10128427f, 0.19184406f, -0.34338519f, -0.16775990f, 0.13228816f, 
    -0.01172744f, 0.05941458f, 0.16545200f, -0.12079526f, 0.07800212f, -0.18930452f, 0.08497676f, 0.25535789f, 
    -0.22005023f, 0.29102883f, -0.21256594f, 0.02411725f, 0.11799805f, 0.37036112f, 0.32202554f, 0.01660360f, 
    0.10536885f, -0.24859910f, -0.31135795f, 0.07533560f, 0.01948531f, 0.02151947f, -0.30823866f, 0.18607037f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.16659690f, 0.15216327f, -0.00416704f, -0.07465783f, 0.19590028f, 0.20722216f, 0.10702854f, 0.08518468f, 
    0.06202717f, 0.12281027f, 0.08079367f, -0.08326408f, 0.10674258f, 0.01140230f, 0.06720584f, 0.15554161f, 
    -0.07084509f, 0.16375546f, 0.10284825f, -0.07138103f, -0.05466876f, 0.04475138f, 0.09211301f, 0.15147522f, 
    -0.13011067f, 0.09274482f, 0.05015275f, 0.01079692f, 0.05891806f, -0.09562752f, 0.10553844f, -0.08066170f, 
    0.06862660f, -0.13911282f, -0.04399314f, 0.05482850f, 0.07854920f, -0.06573869f, 0.11641405f, 0.00509688f, 
    0.06356096f, -0.16594131f, -0.12487859f, -0.11757703f, -0.05089784f, 0.07970233f, 0.07741193f, -0.08056780f, 
    0.14123370f, 0.11256637f, -0.01913624f, 0.20182593f, 0.20410903f, 0.10199154f, 0.16885582f, -0.06983225f, 
    -0.09904380f, -0.11900607f, 0.20973159f, 0.17080873f, -0.01822598f, -0.08255994f, -0.19184004f, -0.30914307f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.00948952f, -0.12357533f, -0.01368955f, -0.56185168f, -0.27990898f, -0.08825694f, 0.24220927f, -0.57366914f, 
    0.09033923f, -0.00525014f, -0.36212397f, 0.33508322f, 0.08587740f, 0.15703177f, -0.16383491f, -0.05613176f, 
    -0.44737872f, 0.06484128f, -0.42438662f, 0.01546399f, 0.08444816f, -0.08344498f, 0.11958428f, 0.25027275f, 
    0.03600549f, 0.23189771f, 0.11574373f, -0.03694150f, 0.06584443f, -0.10684753f, -0.01389433f, -0.11183716f, 
    0.19213995f, -0.51439714f, -0.11103967f, -0.06432685f, 0.06420969f, 0.03189433f, -0.70425647f, -0.26520890f, 
    0.09439129f, -0.36265996f, -0.00848325f, -0.35411394f, -0.03873622f, -0.10174166f, 0.02342201f, 0.15238352f, 
    -0.06124809f, 0.14300911f, 0.13900752f, -0.54377311f, -0.00168568f, -0.29688084f, 0.01483591f, -0.11410021f, 
    -0.06097129f, 0.16511828f, -0.41884834f, 0.23343438f, 0.28979114f, 0.03903201f, -0.32561269f, -0.79238653f, 
    0.07732022f, -0.32285631f, -0.12643313f, -0.32989189f, -0.66051579f, -0.40039015f, -0.13893142f, -0.29126111f, 
    -0.09655297f, 0.13353565f, -0.11663190f, -0.09629834f, -0.03275292f, 0.14674452f, -0.06726472f, -0.31426835f, 
    0.07297470f, 0.00815451f, 0.07251080f, -0.11937070f, -0.02750096f, -0.45672020f, 0.03639629f, -0.47035658f, 
    0.12321401f, 0.15522569f, 0.08990495f, 0.24228634f, 0.01302096f, 0.08159850f, 0.16589990f, 0.02995000f, 
    -0.06747413f, 0.01161282f, 0.09695596f, -0.01102437f, 0.09706057f, 0.05124736f, 0.18622524f, 0.28631869f, 
    -0.10749212f, -0.07352446f, 0.10163505f, 0.18562242f, -0.10938758f, -0.12863564f, 0.16622044f, 0.06348897f, 
    0.21339534f, 0.29351667f, -0.02054904f, 0.10203007f, 0.21120179f, -0.60488659f, -0.02005800f, -0.05314835f, 
    -0.10332264f, 0.26214305f, -0.13462013f, 0.17378531f, -0.38269889f, -0.00445519f, 0.00229979f, 0.25505295f, 
    0.07291985f, 0.04328577f, -0.49051371f, -0.25402677f, -0.49911970f, -0.24541420f, -0.59450150f, 0.25863400f, 
    0.00678681f, -0.31493112f, -0.01191181f, -0.39706087f, 0.03986215f, 0.19397853f, 0.45726430f, -0.03891782f, 
    -0.32687142f, 0.24717943f, -0.19026364f, -0.06326711f, -0.06517719f, 0.35317099f, 0.32417384f, -0.07768895f, 
    -0.04169376f, 0.08227187f, 0.11931254f, -0.32213622f, -0.08049767f, -0.00640996f, -0.17259915f, 0.05457786f, 
    -0.35306120f, -0.40350014f, -0.04631387f, -0.17847742f, 0.12090111f, -0.05881949f, -0.07508337f, -0.44969654f, 
    0.04484280f, -0.44293389f, 0.07875167f, -0.12229104f, -0.08281928f, 0.07295918f, -0.17335007f, 0.24817628f, 
    0.01916325f, 0.30082178f, 0.20660433f, 0.03291048f, -0.18750843f, 0.37732670f, -0.13373104f, 0.01781461f, 
    0.00488810f, 0.15580589f, 0.34038910f, 0.15892382f, -0.25984553f, -0.00662170f, -0.11029529f, -0.08172005f, 
    -0.45133016f, 0.25109592f, -0.02800409f, 0.07462483f, 0.29902455f, -0.03302054f, 0.13656212f, -0.31672224f, 
    -0.12366422f, -0.21494983f, -0.28667691f, 0.10793637f, 0.06465752f, 0.05768190f, -0.61979103f, -0.02784363f, 
    0.30634460f, 0.23318663f, 0.01019725f, 0.11961340f, 0.03310522f, 0.05574792f, -0.27568668f, 0.19907302f, 
    -0.03518749f, -0.32279482f, 0.06139969f, -0.61479026f, -0.02348482f, 0.11037004f, -0.27079397f, 0.07425369f, 
    0.11625160f, 0.00925391f, 0.11730709f, -0.31158650f, -0.11724524f, 0.09805474f, 0.11455309f, -0.15744895f, 
    0.11528221f, 0.16858028f, -0.04688380f, -0.60766613f, -0.12675419f, -0.00061696f, -0.16571768f, -0.29003510f, 
    -0.12093430f, -0.17186047f, -0.14358631f, 0.31542113f, -0.17552492f, -0.00389420f, -0.25225073f, -0.13372461f, 
    -0.10541287f, -0.50586379f, 0.22152182f, -0.08314534f, 0.27520245f, 0.06326966f, -0.42915884f, -0.12492365f, 
    -0.24018009f, 0.22662573f, -0.00786084f, -0.00627452f, 0.02314691f, 0.27276409f, 0.01628330f, 0.16132136f, 
    0.12419967f, -0.22576302f, 0.07219822f, 0.14373775f, -0.02819739f, -0.31239220f, 0.00164640f, -0.05476440f, 
    0.07278167f, 0.17397565f, -0.43947756f, 0.04478735f, -0.05746198f, 0.19720323f, -0.13699752f, 0.02333422f, 
    0.01053337f, 0.05375969f, 0.06802927f, -0.01954785f, 0.05971337f, -0.00417949f, -0.44226804f, 0.04441840f, 
    0.12758683f, 0.34945086f, 0.03137425f, 0.16513550f, 0.08620862f, 0.07089551f, -0.17455529f, -0.00586905f, 
    -0.04059096f, -0.07889803f, -0.04934698f, -1.48173738f, 0.07059129f, 0.02775734f, -0.28845030f, -0.05263446f, 
    -0.13145339f, 0.02395632f, -0.02788873f, 0.04783040f, 0.02373483f, 0.08796807f, -0.00671319f, 0.01078904f, 
    -0.11220673f, 0.22107637f, 0.03959198f, -0.20800819f, 0.17262849f, 0.04581678f, 0.09332070f, -0.75349259f, 
    0.06723730f, -0.40952215f, 0.27016920f, -0.50369084f, 0.17098151f, 0.16592079f, -0.02246498f, 0.24906699f, 
    -0.06464853f, 0.15443379f, 0.15915082f, -0.13134106f, -0.09752422f, -0.25476605f, 0.18070158f, -0.52069509f, 
    0.09063945f, -0.32964596f, -0.18613829f, 0.03347418f, -0.11062784f, 0.18832041f, -0.04231808f, -0.10811300f, 
    0.01120745f, 0.22166513f, -0.10667686f, 0.21387912f, -0.06860591f, -0.09995928f, 0.20242386f, -0.06086575f, 
    0.21729128f, 0.13833441f, -0.07034970f, 0.11918115f, 0.01694978f, -0.03717887f, 0.19614825f, 0.11348306f, 
    -0.11262345f, 0.26310608f, 0.09301899f, -0.10408897f, 0.00015799f, -0.00673686f, -0.13260828f, 0.14588372f, 
    -0.23877132f, -0.08672024f, -0.44601184f, -0.31376088f, 0.24864474f, -0.52429259f, -0.02126838f, 0.01477044f, 
    -0.12977937f, -0.18713115f, 0.07758624f, -0.05060907f, -0.18690917f, -0.05654800f, 0.05499679f, 0.10382406f, 
    0.15034217f, 0.30514023f, 0.04746640f, 0.31287783f, 0.25216231f, -0.04634995f, -0.29287615f, -0.49491766f, 
    0.08119394f, -0.03793765f, -0.67611754f, -0.21449114f, 0.08545585f, -0.00179359f, -0.25231186f, -0.33528399f, 
    -0.50843370f, -0.25923392f, -0.79726064f, -0.08232875f, -0.14376090f, 0.08038612f, 0.15818323f, -0.11620363f, 
    -0.01405924f, 0.15976581f, 0.00803857f, -0.32440820f, 0.05612030f, -0.01720768f, 0.23957595f, 0.00665924f, 
    0.16973466f, -0.58810657f, 0.04571771f, 0.14733328f, 0.11715052f, -0.02076702f, 0.22317329f, -0.29877427f, 
    0.08574172f, -0.44386941f, 0.10800032f, -0.10977004f, 0.02205594f, -0.08773068f, 0.35239622f, 0.16542180f, 
    0.06162928f, -0.09386880f, -0.30869463f, 0.07532528f, 0.23197773f, 0.39171430f, -0.03656963f, 0.06236137f, 
    -0.09935604f, -0.21143568f, -0.27027681f, 0.07241428f, -0.05434150f, -0.08429333f, -0.38722825f, -0.64266276f, 
    -0.20945136f, 0.00886812f, 0.04863889f, 0.05556840f, -0.16218309f, -0.06319652f, 0.09218280f, -0.22523978f, 
    -0.02206688f, -0.43707743f, -0.18133278f, 0.18389469f, 0.04002859f, -0.22561151f, -0.00395356f, 0.13355984f, 
    0.23006722f, 0.13700622f, 0.18625490f, -0.12472823f, -0.05708993f, 0.11834392f, -0.24545458f, 0.07710874f, 
    -0.05914193f, -0.21599992f, 0.10533476f, -0.16909638f, -0.01442375f, 0.04242422f, 0.11520226f, -0.08724795f, 
    0.15199390f, 0.31670195f, 0.01039392f, -0.37056440f, -0.00923402f, 0.02105041f, 0.21120453f, -0.06321232f, 
    -0.02227930f, 0.27274582f, -0.03779184f, 0.75343078f, -0.09538288f, -0.04847846f, -0.43860200f, -0.08455320f, 
    -0.63925719f, -0.09948112f, -0.17289110f, 0.04742380f, -0.44330844f, -0.34702250f, -0.42549756f, 0.06553639f, 
    -0.09700477f, 0.06867570f, 0.00071047f, -0.56307739f, -0.21902883f, 0.02626182f, 0.40971896f, 0.49841216f, 
    -0.06004102f, -0.27069414f, -0.43983057f, 0.45753625f, 0.22138414f, -0.42467976f, -0.01503349f, 0.26473093f, 
    0.05803341f, 0.22481138f, 0.37000313f, -0.47955805f, 0.11003534f, 0.05723307f, -0.38514650f, 0.12833121f, 
    -0.23260906f, -0.22214241f, -0.16291836f, -0.00827110f, 0.08891112f, -0.37905869f, -0.53687406f, -0.39202178f, 
    -0.11503252f, -0.36938736f, -0.07009261f, 0.31913784f, 0.05799711f, -0.08307499f, -0.04054895f, 0.05855369f, 
    -0.52143508f, -0.30654556f, 0.00486932f, -0.03681402f, 0.09780306f, 0.11092156f, 0.38635015f, 0.23607971f, 
    0.03639212f, 0.00023273f, -0.05895411f, -0.11524580f, 0.02802575f, -0.01107781f, 0.13577072f, -0.24644037f, 
    0.20303901f, 0.02199050f, 0.18578452f, 0.01903552f, 0.09811520f, -0.15527284f, 0.05161379f, -0.09932448f, 
    0.11714383f, 0.13157581f, 0.02789197f, 0.07167375f, -0.00319511f, 0.05995514f, 0.09855946f, -0.31096035f, 
    0.27287564f, -0.09623247f, 0.09778367f, 0.20728236f, 0.17269406f, 0.10437347f, -0.21335663f, 0.18142240f, 
    -0.06055987f, 0.04887928f, 0.15711278f, 0.04476212f, 0.02677388f, -0.47868747f, -0.04557543f, 0.18975709f, 
    0.04985109f, -0.49485132f, 0.06798767f, -0.05878098f, -0.05980827f, -0.14516202f, 0.13024072f, 0.06765857f, 
    -0.05072836f, 0.04682511f, 0.01024029f, 0.20116507f, -0.00386388f, -0.13315517f, -0.08108213f, -0.11466192f, 
    -0.05076675f, -0.29265887f, -0.03352240f, 0.21085219f, 0.04220783f, -0.12292643f, -0.20284963f, -0.78856730f, 
    -0.05929608f, 0.04427640f, 0.08054540f, -0.37337336f, -0.08342207f, -0.03671574f, 0.06311232f, -0.16015016f, 
    0.15885030f, -0.69850415f, 0.04780117f, -0.44909140f, -0.12839258f, 0.26162186f, 0.36816320f, 0.10034104f, 
    -0.12800685f, 0.21751663f, -0.34317490f, -0.07525671f, -0.05872443f, -0.09244883f, -0.08837791f, -0.25527766f, 
    -0.34786427f, 0.00544618f, -0.42229727f, -0.18279707f, -0.04528537f, 0.02284077f, 0.00873106f, 0.03890182f, 
    0.09731271f, -0.17818107f, 0.10781578f, -0.29578868f, -0.08482936f, 0.24638125f, -0.29306120f, 0.31611443f, 
    0.17657672f, 0.21119507f, 0.38674462f, 0.09715573f, 0.02513839f, 0.29940003f, 0.25982851f, 0.10436673f, 
    -0.02593906f, -0.28590262f, 0.07761338f, -0.16513655f, 0.04318390f, 0.09051995f, 0.35129642f, -0.02168160f, 
    -0.13957562f, -0.44418475f, -0.11254630f, -0.13825326f, 0.07487100f, -0.05680275f, -0.14781848f, 0.15253639f, 
    0.03095394f, 0.00805480f, -0.13383877f, -0.43668106f, 0.09211923f, 0.08791998f, 0.16037816f, -0.52491045f, 
    -0.24048515f, 0.32220691f, 0.22537909f, 0.10749836f, 0.03820935f, -0.08551421f, -0.30984175f, 0.01222586f, 
    0.10731544f, -0.45115685f, 0.25696379f, -0.14885210f, -0.32747340f, -0.12321343f, -0.22879662f, -0.65445393f, 
    -0.11557365f, 0.20368508f, -0.15027881f, -0.05341277f, 0.33917543f, -0.09992220f, -0.05669558f, -0.04614342f, 
    -0.09506024f, -0.09099749f, 0.07641143f, 0.10165934f, 0.08901285f, 0.20437706f, -0.71521658f, 0.00679311f, 
    -0.67794377f, 0.03664801f, -0.07768760f, -0.04223305f, 0.04400928f, -0.12067008f, 0.04907853f, 0.18022460f, 
    -0.01024422f, -0.18270618f, -0.00430637f, -0.21938422f, -0.05881184f, -0.00867344f, -0.25250423f, 0.09033237f, 
    -0.05155754f, -0.48835474f, -0.11513421f, -0.19837110f, -0.09305353f, -0.08399823f, -0.17972592f, -0.10619128f, 
    -0.00130465f, -0.49640459f, -0.09469463f, 0.18172078f, -0.06267455f, 0.04332595f, 0.21631354f, 0.30476138f, 
    0.11412877f, -0.22257939f, -0.08812836f, 0.27103177f, -0.11953378f, 0.37064788f, -0.12399319f, -0.08940294f, 
    0.10978446f, -0.43711972f, 0.32223642f, 0.08284327f, 0.34144449f, -0.05076836f, -0.02779906f, 0.31436384f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.02031633f, -0.09654108f, 0.07824110f, 0.05623879f, 0.11050769f, 0.01517200f, -0.00191160f, -0.21799767f, 
    -0.02398151f, -0.06578224f, 0.11953042f, -0.07256161f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
