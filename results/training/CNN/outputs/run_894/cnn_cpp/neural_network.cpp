#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.77995139f, 0.50389540f, -0.80952621f, -0.07583319f, -0.66666961f, 0.26500395f, -0.07799234f, -0.45019430f, 
    -0.26264134f, -0.42798281f, -0.05557453f, 0.17869166f, 0.46679726f, 0.16528913f, -0.15664460f, 0.14735836f, 
    -0.14746113f, -0.22559403f, 0.04994391f, 0.03218440f, -0.01577765f, 0.00556348f, 0.21566236f, -0.13040848f, 
    -0.07020216f, -0.27683771f, 0.46467695f, 0.08186831f, -0.83826214f, 0.39181578f, 0.63471258f, -0.66197801f, 
    -0.74270850f, 0.18415287f, -0.13952969f, 0.06187803f, 0.17869587f, 0.37520438f, 0.22095592f, -0.00627630f, 
    0.00453483f, 0.08634878f, 0.05851323f, 0.19910462f, 0.19296081f, 0.10471056f, -0.07473938f, 0.03888917f, 
    0.01499908f, 0.08665834f, 0.88854688f, 0.92850548f, 0.68832636f, -0.60903507f, -0.56397969f, 0.29349151f, 
    -0.12191720f, -0.00653449f, -0.43985686f, -0.24805599f, 0.22411326f, 0.23861499f, -0.02984240f, 0.27460316f, 
    0.05727073f, 0.29270431f, -0.08273180f, 0.13563341f, 0.08354060f, -0.04632229f, -0.10761389f, -0.14201017f, 
    -0.02388685f, -0.15380906f, 0.32860816f, -1.12283254f, 0.29504269f, 0.16123687f, -0.34329081f, -0.33808213f, 
    0.28434107f, 0.92599022f, -0.06227512f, 0.11110280f, 0.32783321f, -0.03483116f, -0.05550813f, 0.08730150f, 
    -0.27373540f, 0.14747731f, 0.03267654f, 0.01221605f, -0.04920343f, -0.09559242f, -0.17153746f, 0.04912294f, 
    -0.06519809f, 0.13490966f, -0.00577530f, 0.00669274f, 0.48001301f, -0.15969905f, -0.36478809f, -0.36679134f, 
    0.47469610f, 0.49178749f, -0.10172530f, -0.55553228f, -0.29077682f, 0.10922670f, 0.03832350f, -0.06086891f, 
    -0.34810632f, -0.03440958f, -0.48215494f, -0.15911925f, 0.37496865f, 0.18646491f, 0.23348220f, -0.11935660f, 
    -0.13121863f, 0.12593575f, -0.14086276f, -0.12275302f, 0.04770134f, -0.59847403f, -0.60568565f, 0.52385449f, 
    0.78615087f, 0.33465689f, 0.48991516f, 0.57405180f, -0.38247317f, 0.00498939f, -0.43567812f, 0.22726902f, 
    0.18031915f, -0.03444213f, 0.43296325f, 0.36645320f, 0.02594709f, -0.06133295f, -0.21754330f, -0.05623898f, 
    0.28490734f, -0.15195297f, 0.21698487f, -0.07182391f, 0.00797702f, 0.08447613f, 0.44154555f, 0.37399319f, 
    -0.32575956f, 0.27117473f, 0.47571802f, -0.20467933f, 0.07200004f, 0.65345538f, 0.42998442f, -0.23476529f, 
    -0.18582094f, -0.15766561f, -0.00406332f, 0.24301048f, -0.27078816f, 0.27645412f, -0.36450437f, -0.25134119f, 
    -0.23962449f, -0.25870103f, -0.25317538f, -0.39985049f, -0.13663262f, -0.08630851f, -0.07762587f, -0.05293465f, 
    -0.81772661f, -0.61375034f, -0.61219531f, 0.05275922f, -0.36830387f, 0.07032309f, -0.05410320f, 0.24849398f, 
    0.36794350f, -0.25658950f, 0.07954909f, -0.05902202f, -0.14605954f, -0.26084578f, -0.01389207f, -0.11113683f, 
    0.27259776f, -0.09479310f, -0.03180365f, 0.08670773f, 0.17849278f, 0.03408384f, 0.29687688f, -0.09891496f, 
    -0.32091403f, -0.58282751f, -0.74021280f, 0.28737533f, -0.09802126f, 0.37463745f, 0.64437950f, 0.15836211f, 
    0.00793363f, -0.22243339f, 0.07957681f, 0.12132341f, 0.05518559f, 0.15635358f, -0.27433610f, -0.49309745f, 
    -0.04130062f, -0.26051021f, -0.29777789f, -0.20332867f, 0.12904717f, 0.09293735f, 0.01885365f, -0.06491793f, 
    -0.06666053f, 0.80912524f, -0.02924809f, -0.27315313f, -0.40050375f, 0.04771112f, 0.46123356f, 0.71945155f, 
    0.49134070f, 0.58460140f, 0.49213764f, -0.41354895f, 0.26845804f, -0.37290516f, 0.06057645f, 0.11392616f, 
    0.10009398f, -0.07039417f, -0.19923928f, 0.14746882f, 0.07878749f, -0.08599266f, -0.00414802f, -0.00741445f, 
    0.04642127f, -0.20175284f, 0.23450679f, -0.15366518f, -0.53999245f, -0.92146003f, -0.42741710f, 0.15681741f, 
    -0.45812598f, 0.05271903f, 0.51568860f, 0.12405732f, -0.18018860f, -0.06383281f, -0.29404432f, -0.05596591f, 
    -0.15079242f, 0.00670763f, 0.28555319f, -0.01633888f, -0.02634728f, 0.01180699f, 0.06021308f, 0.07710107f, 
    -0.08358439f, 0.13883168f, -0.03803519f, 0.43088380f, 0.23438671f, 0.53875804f, 0.89493763f, 0.70923734f, 
    0.58104897f, -0.00075997f, 0.01111256f, 0.00575115f, 0.10575650f, 0.14088918f, -0.24691336f, -0.27431527f, 
    0.02477055f, -0.32928026f, -0.10529041f, -0.06158680f, 0.05472293f, -0.06052863f, -0.17722261f, 0.24983431f, 
    -0.04236038f, -0.05723944f, -0.11131610f, 0.12048127f, -0.56734735f, -0.39036700f, -0.76565486f, -0.68129772f, 
    0.10556782f, -0.27566892f, 0.00742617f, -0.05171679f, -0.26749140f, -0.28639480f, -0.46654081f, 0.25715008f, 
    0.53432882f, -0.00819979f, 0.07997542f, 0.29935658f, 0.09763524f, 0.07252373f, 0.20569693f, 0.11337851f, 
    -0.10812276f, -0.05490260f, -0.00439719f, -0.06271122f, -0.06975502f, 0.74824637f, 0.48956132f, 0.62802458f, 
    0.67240494f, 0.41971514f, -0.12736551f, 0.39835426f, -0.23235787f, 0.20917501f, -0.14144027f, 0.35257050f, 
    0.36405176f, 0.25226486f, 0.20504668f, 0.09153267f, -0.03271307f, -0.28555512f, 0.18333773f, 0.22481462f, 
    -0.00525898f, -0.13732539f, 0.20576060f, 0.26153162f, 0.19671875f, -0.04298782f, -0.18278465f, -0.79161388f, 
    -0.26557088f, 0.40617773f, 0.22505468f, -0.75474429f, 0.81124604f, 0.15303573f, -0.86708629f, 0.27480510f, 
    0.11110593f, 0.11946283f, 0.07035533f, -0.12343235f, -0.07571300f, -0.21641493f, -0.07940723f, -0.02532553f, 
    0.18836243f, -0.33528903f, -0.02527220f, -0.18310475f, -0.04703419f, -0.10582572f, 0.02341802f, 0.52780682f, 
    0.00626667f, 0.43351090f, 0.54402471f, 0.30300829f, -0.10157546f, -0.63088232f, -0.25719517f, -0.45540839f, 
    -0.48969212f, 0.13832906f, 0.32837477f, 0.03294760f, 0.51612025f, -0.31562462f, 0.17125149f, 0.35248676f, 
    0.13296413f, 0.02269965f, -0.03261406f, -0.32600746f, -0.06087323f, -0.25650051f, 0.16177849f, 0.09502358f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13698649f, 0.23928009f, 0.24149548f, -0.21866243f, 0.19502126f, 0.06930810f, 0.03030233f, 0.16578194f, 
    0.28330988f, -0.01624485f, 0.30763716f, 0.15039279f, 0.17027482f, 0.04932292f, 0.14302589f, 0.08141723f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05425031f, 0.05847131f, -0.01910768f, -0.02995093f, 0.00161431f, 0.01546943f, -0.00485095f, 0.02707363f, 
    -0.05455770f, -0.03563055f, -0.07428128f, 0.03501778f, 0.03221296f, 0.03029499f, 0.00650089f, -0.06710423f, 
    -0.05298921f, -0.02826853f, -0.06008882f, 0.02537139f, 0.04021571f, 0.05634122f, 0.00296056f, 0.06237084f, 
    0.05204159f, 0.04115364f, -0.05212494f, 0.05290338f, 0.00607785f, -0.02670717f, -0.01158527f, -0.05940139f, 
    0.04054267f, -0.03971011f, -0.03675869f, -0.04966781f, 0.04123007f, -0.05524359f, 0.05884226f, -0.06213813f, 
    -0.01301758f, -0.00188003f, 0.01826213f, -0.06167388f, 0.03788935f, -0.07624030f, -0.02713341f, 0.00312680f, 
    0.00815212f, 0.03650896f, -0.02782281f, -0.05358110f, -0.04324808f, -0.00230764f, 0.01333757f, -0.02589135f, 
    -0.05480226f, -0.00300566f, 0.02460502f, 0.00195440f, 0.01764436f, -0.07148566f, -0.01657279f, 0.04842097f, 
    0.02230890f, -0.07092235f, -0.03979569f, -0.00087026f, -0.02903977f, 0.02946228f, 0.04556558f, 0.02893070f, 
    0.04495161f, -0.05634066f, -0.07761616f, 0.00705858f, -0.07750837f, -0.02561556f, -0.07163938f, -0.05625508f, 
    -0.00023542f, -0.05270799f, -0.01933282f, -0.01130361f, 0.03803690f, -0.05199296f, -0.03278599f, -0.04441504f, 
    -0.06574291f, -0.01852355f, 0.02071104f, -0.03509059f, 0.00097532f, -0.06761229f, 0.03877961f, -0.06147163f, 
    -0.03720460f, -0.02453753f, -0.05975330f, 0.05662466f, 0.00922091f, 0.05984409f, -0.02651128f, 0.02259883f, 
    0.05579706f, 0.02284519f, 0.04492622f, -0.02876386f, 0.04930808f, -0.06490862f, 0.01705464f, -0.04225410f, 
    0.00961199f, -0.04292514f, 0.02765249f, 0.05040131f, 0.02647254f, 0.04533700f, -0.06827632f, 0.06439299f, 
    -0.06088979f, -0.03817918f, -0.05214821f, 0.04528873f, -0.01316748f, -0.00269907f, -0.00841299f, 0.01703695f, 
    0.06443403f, -0.04534450f, -0.06374668f, -0.00121473f, 0.02386690f, -0.06801120f, 0.03034226f, 0.00836585f, 
    -0.02473995f, -0.00364043f, -0.00511272f, 0.05722424f, -0.01388047f, -0.00663349f, -0.04752455f, -0.04488238f, 
    0.04571950f, -0.01642651f, 0.02206658f, -0.05943572f, 0.05264402f, 0.05770257f, 0.02140006f, 0.02868303f, 
    0.05827535f, -0.05830839f, -0.01896788f, -0.06400144f, 0.02526220f, 0.06869229f, -0.01254255f, -0.06652545f, 
    -0.04255907f, 0.01752792f, -0.06478994f, 0.01737269f, -0.01737363f, -0.03488207f, -0.02531848f, 0.05578484f, 
    0.05883083f, -0.03223660f, -0.05563968f, 0.00676327f, -0.04521121f, 0.02262985f, 0.04345135f, -0.04545332f, 
    -0.05096688f, -0.06062716f, 0.02426980f, -0.06285867f, -0.04481038f, -0.01634090f, -0.02841937f, 0.06614522f, 
    0.00946308f, 0.00993873f, 0.05881504f, -0.01507420f, 0.02028345f, -0.00593322f, 0.05302278f, -0.02129034f, 
    -0.09825519f, 0.09593479f, 0.22602376f, -0.31573808f, -0.06256892f, -0.08427610f, 0.09383714f, 0.04692566f, 
    -0.01374443f, -0.01823828f, 0.05683322f, -0.05254916f, -0.21323642f, 0.17816913f, 0.14565346f, -0.44843844f, 
    -0.05658729f, -0.01581474f, -0.02310340f, 0.00643037f, 0.14954720f, 0.02148542f, 0.10953232f, -0.07091610f, 
    -0.05591229f, 0.17508683f, 0.04622709f, -0.07649342f, 0.05604842f, -0.00477620f, -0.10245246f, 0.04018248f, 
    0.00062199f, 0.04398490f, -0.01939957f, 0.03834796f, 0.45635492f, -0.16325106f, 0.12801680f, -0.18825740f, 
    0.02062939f, 0.01387834f, -0.07154062f, 0.09243609f, 0.01887831f, 0.04928008f, 0.07124172f, 0.11175197f, 
    -0.02598532f, 0.17803088f, 0.20861368f, -0.15245004f, 0.00076602f, 0.08352263f, -0.06372694f, -0.01317759f, 
    0.05751699f, 0.02256411f, 0.05844269f, 0.05769558f, 0.10173670f, -0.09419925f, -0.20623147f, 0.19135344f, 
    0.03516340f, 0.05647722f, 0.02175291f, 0.01612596f, 0.04386993f, 0.02862872f, -0.00465999f, 0.01047147f, 
    -0.06020849f, -0.06690900f, 0.12396386f, 0.05023028f, 0.06245613f, 0.01097573f, -0.07374274f, 0.11498450f, 
    0.00531495f, 0.05751844f, -0.05620551f, -0.01081392f, -0.00535354f, -0.04263151f, 0.03640950f, -0.05789605f, 
    -0.08630893f, 0.02192688f, -0.01658530f, 0.09977861f, 0.02999999f, -0.07411456f, -0.09554128f, 0.08680747f, 
    0.22259185f, 0.02789434f, -0.05235444f, 0.16158837f, 0.07140324f, -0.06063822f, -0.27168217f, 0.10630146f, 
    0.05396975f, 0.04620254f, -0.03030548f, -0.09454725f, 0.53435659f, 0.29561007f, -0.08921173f, -0.01770445f, 
    0.03768003f, -0.05690195f, 0.03619859f, 0.11866276f, -0.10916247f, -0.01389393f, 0.01209773f, 0.04313472f, 
    -0.17032729f, 0.03121648f, 0.27336738f, -0.15993181f, 0.05453274f, -0.00088107f, 0.08260813f, 0.10189898f, 
    0.06784783f, -0.08571733f, 0.05890124f, 0.05479887f, -0.20982793f, 0.01770075f, 0.00362402f, 0.33362278f, 
    0.15680602f, 0.09752452f, 0.00046382f, -0.06441700f, -0.02310816f, 0.08226243f, -0.03067630f, -0.01406974f, 
    -0.11322810f, -0.12196828f, -0.13223860f, -0.17421603f, -0.01429636f, 0.09264711f, 0.12379289f, -0.00882281f, 
    0.02840554f, -0.00883811f, 0.07740800f, -0.13938713f, 0.17262954f, -0.02391598f, 0.03363127f, 0.08859528f, 
    0.05596475f, -0.03296159f, -0.01639913f, -0.01000982f, -0.00728661f, 0.00116565f, -0.02902363f, 0.06013624f, 
    0.39429417f, 0.02632178f, -0.14057693f, 0.13426134f, -0.04871586f, 0.10525372f, -0.13869010f, 0.10567185f, 
    0.10107177f, 0.04269685f, 0.04145955f, -0.15856613f, -0.23517978f, -0.02132226f, -0.18566230f, 0.02915427f, 
    0.06986932f, 0.07387447f, 0.00915352f, -0.08013704f, 0.06118879f, 0.05711432f, -0.00817852f, 0.03623299f, 
    -0.03185793f, -0.54645628f, -0.06825862f, -0.13467073f, 0.09354350f, -0.06835710f, 0.12785493f, 0.10691904f, 
    0.03168337f, -0.00722075f, 0.04305863f, -0.09459884f, -0.05017243f, 0.00230078f, 0.01889107f, 0.31844872f, 
    -0.01182118f, 0.04202494f, 0.10457076f, 0.11626050f, -0.01323061f, 0.06352971f, 0.01002699f, -0.02452756f, 
    -0.10094507f, 0.00042680f, -0.04452935f, 0.13492976f, 0.01036592f, 0.04428075f, 0.04076739f, -0.05072678f, 
    0.10064262f, 0.03087220f, 0.00976747f, 0.12173064f, -0.88899410f, 0.03387213f, -0.31138247f, -0.16540240f, 
    0.11178113f, -0.08254711f, -0.01267410f, 0.11876406f, 0.03814768f, 0.09550091f, -0.06726950f, -0.04200805f, 
    0.01494481f, -0.40155002f, 0.00533289f, -0.05931892f, -0.05651978f, -0.05463710f, -0.04433362f, 0.00727558f, 
    -0.04511810f, -0.22495525f, 0.12042409f, -0.21972242f, 0.24344964f, 0.06856014f, 0.16923110f, -0.16094446f, 
    0.08463259f, 0.01997130f, -0.05671483f, -0.07421182f, -0.11063083f, -0.02866965f, 0.04663551f, -0.16408026f, 
    0.21646889f, 0.10788611f, -0.05620354f, 0.12635371f, 0.09186890f, -0.08499720f, 0.07769614f, -0.05812185f, 
    -0.03342059f, 0.00838195f, -0.06385370f, 0.15676747f, 0.22179545f, -0.37889424f, 0.08341633f, -0.00042960f, 
    0.13727440f, 0.02257914f, -0.00384967f, -0.03929393f, 0.10018238f, -0.12898727f, 0.09411303f, 0.06162576f, 
    0.09744520f, -0.21911800f, -0.00297344f, 0.12971765f, 0.12202812f, -0.03599842f, 0.00853673f, 0.11870634f, 
    0.02553101f, -0.07962341f, 0.06320046f, -0.01994215f, 0.31061304f, -0.13747899f, 0.31077564f, -0.12456540f, 
    0.16642310f, 0.05059655f, 0.07343161f, -0.06263965f, 0.04462614f, 0.06212405f, 0.02780881f, 0.04576840f, 
    -0.37929180f, -0.28922343f, 0.02349016f, -0.04254448f, -0.06014203f, -0.10507175f, 0.05797321f, 0.09355032f, 
    0.25926214f, 0.08087275f, 0.05336869f, -0.15694731f, 0.34154525f, 0.14312704f, 0.14333998f, 0.02988989f, 
    -0.06808773f, 0.23379514f, -0.02605356f, 0.02431059f, 0.07387098f, 0.02847032f, 0.07873490f, 0.16932850f, 
    -0.08079892f, -0.10678811f, -0.10777279f, -0.57309854f, -0.01967855f, 0.06334192f, 0.08168580f, 0.00416478f, 
    -0.06920013f, 0.07173414f, -0.01356691f, 0.02019204f, 0.14276567f, 0.04730312f, 0.30415139f, 0.22764686f, 
    -0.18223502f, -0.04941772f, 0.08558224f, 0.05710438f, 0.01564079f, 0.01555215f, -0.06709409f, 0.05457573f, 
    0.29960424f, -0.02728629f, -0.02062024f, -0.06995670f, -0.03521314f, 0.13884091f, 0.07946363f, 0.11431381f, 
    -0.04306057f, -0.14565544f, -0.07847749f, -0.11546847f, -0.15124111f, 0.09512550f, 0.13257904f, 0.20859264f, 
    -0.15562749f, 0.05131133f, -0.08078288f, -0.09372436f, 0.07150012f, 0.06311537f, 0.04241756f, 0.02812751f, 
    0.23269875f, 0.08104789f, 0.14641312f, 0.35389793f, -0.02751242f, 0.09747026f, -0.06233738f, 0.11660357f, 
    0.03535232f, 0.07374751f, 0.07250441f, -0.04712997f, -0.29446456f, -0.09598204f, 0.15519062f, -0.00319579f, 
    -0.05393042f, 0.09474116f, -0.00712664f, -0.04582987f, -0.03489137f, 0.06577653f, 0.02896711f, 0.02579605f, 
    0.19886298f, 0.22391085f, -0.06336431f, 0.09735859f, -0.04916979f, 0.23428348f, -0.02030263f, -0.00206210f, 
    0.00796529f, -0.07247370f, 0.12195943f, 0.04774252f, -0.23614432f, -0.38311753f, -0.05741930f, 0.00632123f, 
    0.08404575f, -0.09370912f, 0.03602092f, -0.13935271f, 0.06273392f, 0.01997435f, -0.01774672f, -0.00526018f, 
    0.31852859f, -0.02305772f, 0.06126747f, -0.15261494f, 0.03245282f, 0.07120516f, -0.08251607f, 0.08112781f, 
    -0.04056365f, -0.04815602f, 0.09051966f, -0.12719008f, -0.12791353f, 0.12795666f, 0.10702880f, -0.06004901f, 
    0.03608461f, 0.12770723f, 0.00928135f, 0.00396266f, -0.03262564f, 0.00721757f, -0.06685459f, -0.10520711f, 
    -0.14557745f, 0.26277626f, 0.26047239f, 0.19833726f, -0.04061831f, 0.20561409f, -0.05057242f, 0.00701129f, 
    0.07363091f, 0.00509320f, -0.09003892f, 0.03464475f, -0.15623719f, -0.34567651f, 0.03819003f, -0.05112064f, 
    0.09310486f, 0.14785022f, 0.12877886f, 0.00124595f, -0.12217553f, -0.14893810f, -0.07082602f, 0.08765118f, 
    -0.44657400f, -0.02523741f, -0.08871629f, 0.09416948f, 0.09600378f, 0.11493582f, -0.01183454f, 0.00046830f, 
    0.01409690f, 0.06135893f, 0.07058409f, 0.04361401f, 0.16536020f, -0.21736336f, 0.16666535f, -0.01540629f, 
    0.02708738f, -0.13597935f, -0.25637057f, -0.14711344f, -0.00914644f, 0.01369162f, -0.08708894f, 0.13416982f, 
    0.07283849f, -0.16715911f, -0.11964001f, 0.11249461f, 0.09041686f, -0.05967786f, -0.01612388f, 0.05119483f, 
    0.05277569f, -0.03291077f, 0.06847008f, -0.13331486f, 0.12657107f, 0.24101704f, 0.23855957f, 0.03248148f, 
    -0.11228804f, 0.03647382f, 0.04970460f, 0.13741754f, 0.04995463f, 0.04164790f, -0.09549224f, 0.00893417f, 
    -0.15299407f, -0.19543791f, 0.00847207f, -0.11426274f, 0.15927921f, 0.23115641f, -0.05078264f, 0.02759711f, 
    0.02675677f, 0.03070906f, 0.10016804f, 0.08755873f, 0.16552204f, 0.27900088f, 0.29923883f, 0.02431792f, 
    -0.17376953f, -0.09266905f, 0.12583153f, 0.11532843f, -0.09191521f, -0.00840805f, -0.01474339f, 0.01829547f, 
    -0.03804943f, 0.07747555f, -0.08121694f, -0.10673667f, -0.02551177f, 0.01699463f, -0.03582337f, 0.01108196f, 
    0.02973444f, -0.03534991f, 0.12885693f, 0.05458861f, 0.19868620f, 0.28900620f, 0.06661721f, -0.00345753f, 
    0.00976108f, 0.00726001f, 0.00990825f, -0.07670020f, -0.08998465f, -0.13394672f, -0.01979117f, 0.17485777f, 
    -0.16056950f, 0.42792326f, -0.00567034f, -0.14903055f, 0.08924524f, 0.05126002f, 0.00284826f, -0.03665674f, 
    0.11090197f, -0.03859550f, -0.04483258f, -0.12991256f, -0.00733371f, 0.14412849f, -0.15373777f, -0.22682868f, 
    -0.17594627f, -0.04841965f, -0.07550065f, 0.04363836f, 0.19434318f, -0.10662547f, 0.00630363f, 0.04593432f, 
    0.61981457f, 0.35565168f, 0.20324489f, -0.12998596f, 0.04787048f, 0.06962489f, 0.00366900f, -0.06938676f, 
    0.05562662f, 0.06160614f, 0.05951435f, -0.15138447f, 0.25943291f, -0.52870893f, 0.25040960f, -0.07030931f, 
    0.13544397f, 0.06949545f, 0.13542911f, 0.05126946f, -0.09841901f, -0.05584359f, -0.10914920f, 0.02884868f, 
    0.04788276f, 0.30976814f, 0.24105486f, 0.16253854f, 0.22287351f, 0.13936248f, -0.31016001f, -0.02861853f, 
    0.14369436f, 0.00992850f, 0.04397615f, 0.00186132f, 0.07520630f, 0.21050593f, -0.20505959f, -0.03445406f, 
    0.03036218f, 0.02901807f, -0.07079445f, -0.01095104f, 0.03710535f, -0.01415550f, 0.00039764f, 0.15270355f, 
    0.22474107f, 0.13961473f, -0.09861926f, 0.21289872f, 0.13785949f, 0.03754524f, -0.01326637f, 0.14956304f, 
    0.04277050f, 0.28632456f, 0.13407736f, 0.11628190f, -0.41825771f, -0.12161499f, -0.04613690f, -0.00257259f, 
    0.02714361f, 0.02468300f, -0.04982519f, 0.17261797f, 0.01766674f, -0.00619975f, -0.14736000f, -0.01530932f, 
    -0.66276884f, -0.01716001f, 0.05185235f, 0.03409157f, 0.28515297f, 0.09957386f, -0.10354625f, 0.20224239f, 
    0.02008776f, 0.21093449f, 0.00979691f, 0.06667116f, -0.14985292f, 0.53329784f, 0.01584604f, 0.27963534f, 
    0.00773226f, -0.05958521f, 0.02854491f, 0.15957718f, 0.04046311f, -0.03898763f, 0.10542293f, -0.07054503f, 
    -0.05018553f, 0.03679974f, 0.23386982f, 0.01674063f, -0.00912047f, -0.06737643f, 0.06012948f, 0.24066621f, 
    -0.01646992f, -0.12920116f, 0.01859335f, 0.21123669f, 0.29168862f, 0.39847425f, 0.17750597f, 0.31699896f, 
    0.17676337f, -0.03323628f, -0.11654643f, -0.10510842f, 0.06628679f, 0.16079935f, 0.01001294f, -0.10343284f, 
    -0.49369857f, -0.36947331f, -0.28345680f, 0.04915750f, 0.14866097f, -0.02657243f, -0.00104021f, -0.05099736f, 
    0.09519839f, 0.01357902f, -0.03582087f, -0.14638902f, 0.35974994f, 0.15069413f, 0.12712161f, 0.21358417f, 
    0.21334314f, 0.03521223f, -0.03928411f, -0.08805864f, 0.01847062f, -0.10881928f, 0.03828236f, 0.04190279f, 
    -0.41659927f, -0.07715590f, -0.25052214f, -0.11356018f, 0.04232313f, 0.00911470f, 0.00606925f, -0.02754164f, 
    -0.06351911f, 0.10104605f, 0.16016738f, 0.06072798f, 0.07038742f, 0.12864089f, 0.14584349f, -0.04400181f, 
    -0.05679269f, -0.05863178f, -0.06390876f, -0.01851306f, 0.02831854f, 0.09559381f, 0.08858067f, 0.05896283f, 
    -0.25423902f, 0.16743506f, -0.27328917f, -0.19197792f, 0.17229001f, -0.02279156f, 0.00729507f, -0.20918874f, 
    0.08725239f, -0.05686685f, 0.08597235f, -0.09004699f, -0.11437608f, -0.09504488f, -0.27355176f, 0.18173379f, 
    0.01966324f, 0.01796761f, 0.01120547f, 0.14266787f, 0.04429283f, -0.00677880f, 0.06904872f, 0.05806918f, 
    0.41799486f, 0.01844934f, -0.02159390f, -0.17039847f, -0.02643178f, 0.06275257f, -0.03384662f, -0.22448994f, 
    0.07445015f, -0.04757282f, 0.12375968f, 0.16427714f, -0.08126134f, -0.20752530f, -0.10647994f, 0.12052005f, 
    -0.14637911f, -0.02102960f, 0.21891196f, -0.06037139f, -0.05279521f, 0.03649187f, -0.07428864f, -0.09638599f, 
    -0.01796794f, -0.34422719f, -0.01617621f, 0.23558451f, 0.05531694f, 0.00574163f, 0.07286142f, -0.05246597f, 
    0.16333707f, -0.07659560f, -0.03545843f, 0.01755953f, 0.01274124f, 0.09230460f, -0.00356437f, -0.18545486f, 
    -0.03367966f, 0.02239979f, -0.07199217f, 0.08173254f, 0.01334351f, 0.03464334f, -0.01985928f, 0.06323534f, 
    0.11226847f, 0.00095377f, -0.30060720f, 0.07323701f, 0.32257882f, 0.03193997f, 0.05595231f, -0.04197216f, 
    -0.13255703f, 0.13274224f, 0.04175617f, 0.11061832f, -0.10901783f, 0.22255513f, -0.04519840f, 0.20693475f, 
    0.15207998f, -0.04903071f, 0.09634648f, 0.12306348f, 0.01079750f, 0.13981104f, 0.07208286f, -0.00795973f, 
    -0.21114197f, 0.04017343f, 0.25647056f, -0.19061847f, 0.10642522f, -0.04264749f, 0.10613600f, 0.11923316f, 
    0.10408258f, -0.14826192f, 0.07120690f, 0.07954687f, -0.09130655f, 0.25949350f, 0.04999634f, 0.35447487f, 
    -0.01091118f, -0.04918503f, 0.20228286f, 0.02723678f, 0.08940354f, 0.03980748f, 0.10951394f, -0.01931761f, 
    -0.11073101f, 0.21140368f, 0.05512185f, 0.36961365f, 0.03838506f, -0.00283768f, 0.10530277f, 0.12964858f, 
    0.03189203f, -0.09303624f, 0.02470575f, 0.03208929f, 0.19317237f, 0.25279862f, 0.13652839f, -0.01164655f, 
    0.19155028f, -0.08945105f, -0.03133314f, 0.20169275f, 0.00879702f, 0.02823530f, 0.12894066f, 0.05565727f, 
    -0.02739076f, 0.09238081f, -0.04615049f, -0.04772856f, -0.01015819f, -0.14724806f, -0.11260221f, 0.03450051f, 
    0.04914065f, -0.06630071f, -0.03162612f, -0.14321950f, 0.37702942f, -0.02750275f, 0.07868645f, 0.27470249f, 
    0.07949299f, -0.04790157f, -0.09540038f, -0.08125417f, -0.01084452f, -0.17400379f, 0.13792454f, 0.09323560f, 
    -0.15765890f, 0.10656071f, -0.29928547f, -0.00770084f, 0.17920609f, -0.09371041f, 0.16648065f, -0.05533993f, 
    -0.11750434f, 0.08979928f, 0.04496299f, 0.02530894f, -0.24245317f, 0.07268767f, 0.07814556f, -0.10490821f, 
    -0.00798525f, -0.08832836f, -0.18629405f, -0.02566536f, -0.06814875f, 0.04356802f, 0.15144849f, 0.02998067f, 
    0.25725502f, -0.19081520f, 0.17806087f, -0.13662018f, 0.04849739f, 0.04238689f, 0.16541930f, -0.00166240f, 
    -0.01115220f, 0.01269443f, 0.04595645f, -0.06781993f, -0.08339808f, -0.05486900f, 0.17446639f, -0.09132819f, 
    -0.05425201f, 0.08062078f, -0.00270650f, -0.02671089f, -0.04477898f, 0.12425380f, 0.08799198f, 0.13050283f, 
    0.06342090f, 0.11238371f, 0.30100715f, -0.34360555f, -0.00442358f, 0.02460274f, -0.00889230f, -0.11585335f, 
    0.02499863f, 0.02245132f, 0.26884535f, 0.08431399f, -0.30641440f, 0.09981441f, -0.01711367f, -0.11079220f, 
    -0.13072824f, -0.01651454f, -0.08286386f, -0.12828816f, 0.00265641f, 0.10506478f, -0.05836483f, 0.03885922f, 
    0.17099658f, -0.16051848f, 0.00968239f, -0.20237370f, 0.01587447f, -0.09635904f, 0.05206693f, 0.19421865f, 
    -0.01739460f, -0.04049388f, 0.00160489f, -0.13700390f, -0.34048170f, 0.37986985f, -0.15203905f, -0.11006573f, 
    -0.09939402f, -0.04977881f, 0.04421647f, 0.21420078f, -0.08875327f, -0.06233231f, 0.03685532f, -0.07064479f, 
    0.24377704f, -0.01715211f, 0.09201953f, -0.05636624f, -0.12305210f, -0.00198218f, -0.17208500f, 0.19864096f, 
    0.16672617f, -0.08190446f, 0.03942791f, -0.12590635f, 0.12297086f, -0.08277272f, 0.02420430f, -0.02555988f, 
    0.16236639f, 0.02270619f, 0.16835752f, 0.13848688f, -0.07369862f, -0.10191998f, 0.01683925f, -0.11772623f, 
    0.02055316f, 0.24057908f, -0.38584074f, 0.09426594f, 0.03483720f, 0.00790484f, -0.05976414f, 0.03143439f, 
    -0.06202830f, -0.08614847f, -0.00033549f, -0.03159795f, 0.37694463f, -0.25514242f, 0.12637244f, -0.18737391f, 
    0.12018815f, 0.00178587f, 0.03962198f, -0.12840694f, 0.08267485f, 0.07982173f, 0.05599530f, -0.02034665f, 
    0.21017146f, -0.30111060f, 0.21545815f, -0.29627591f, 0.04741442f, 0.03253078f, -0.00240339f, 0.01789481f, 
    0.03481129f, 0.07011181f, -0.10562927f, 0.00470038f, 0.16909410f, 0.02910508f, 0.00329607f, 0.17756326f, 
    -0.13283290f, 0.02565786f, 0.00690450f, 0.06790633f, -0.09671258f, 0.07387935f, 0.07892710f, 0.07385464f, 
    0.09793714f, 0.05147851f, 0.10141199f, -0.07815295f, 0.03645662f, -0.00971278f, 0.13834260f, 0.01040970f, 
    -0.11630043f, 0.06801820f, 0.05617323f, 0.07794078f, 0.06138567f, 0.03791936f, 0.06673278f, 0.24127361f, 
    -0.10867767f, -0.13230480f, -0.05145689f, 0.07028705f, 0.17711227f, 0.19678231f, -0.07477528f, 0.00739498f, 
    -0.58222085f, 0.06183149f, -0.09845380f, 0.24738467f, -0.06343845f, -0.01448785f, 0.03135745f, 0.11975280f, 
    0.10085130f, -0.06366012f, -0.05705133f, -0.06705735f, 0.05696674f, 0.01877751f, 0.11297097f, 0.04642963f, 
    0.09138851f, 0.02443320f, -0.03690597f, 0.10656811f, 0.17160808f, -0.05792520f, 0.17100684f, 0.07998447f, 
    -0.11983366f, -0.03352532f, 0.08844274f, 0.19444640f, 0.08201889f, 0.09466229f, -0.00676681f, 0.01637001f, 
    -0.05017996f, 0.02390517f, 0.03603808f, 0.15722243f, 0.46234134f, 0.08020568f, 0.11744331f, 0.04447385f, 
    0.09418014f, 0.01403817f, 0.10901818f, -0.06149153f, 0.02049656f, -0.06514971f, -0.13074391f, 0.07271103f, 
    -0.22427428f, -0.21288879f, 0.22750811f, 0.03157482f, 0.03006959f, -0.02971640f, 0.06647359f, 0.05325779f, 
    -0.02383973f, 0.07514932f, -0.02357849f, -0.13901779f, 0.22827946f, 0.24454077f, 0.09603146f, 0.06287750f, 
    0.16065860f, 0.08599959f, -0.03267094f, 0.14991468f, -0.06492486f, -0.09381440f, 0.11827409f, 0.03557799f, 
    -0.00368296f, 0.21004498f, 0.18266363f, 0.27560320f, 0.03110888f, 0.02567199f, 0.16998529f, -0.04777252f, 
    0.03590819f, 0.21846411f, -0.00418824f, 0.06586526f, -0.06353167f, 0.15562329f, 0.12189702f, 0.15430892f, 
    0.07066528f, -0.02902006f, 0.09252332f, 0.07934075f, 0.19368079f, 0.01289234f, 0.14024667f, 0.06985256f, 
    0.06047494f, 0.00924608f, -0.00990095f, -0.13862686f, -0.18121675f, -0.00730829f, 0.08161829f, -0.00333848f, 
    0.19262174f, 0.13131851f, 0.06498474f, 0.01386812f, 0.12542120f, 0.14247839f, -0.21051067f, -0.01180171f, 
    0.07451459f, -0.07709417f, 0.06888065f, 0.02722383f, -0.01668379f, 0.10169324f, 0.13287963f, -0.04846068f, 
    0.17345278f, 0.27555901f, -0.05601338f, -0.02484584f, 0.03324163f, 0.04513841f, 0.17798011f, -0.03860136f, 
    0.03561935f, 0.12200266f, 0.08703044f, 0.02219029f, -0.40123791f, -0.09819629f, -0.17558615f, -0.05633120f, 
    -0.05342733f, 0.08383307f, 0.17589249f, 0.10272949f, -0.09524844f, -0.08731208f, 0.07350412f, 0.08812296f, 
    0.27170813f, -0.15822929f, -0.09407239f, -0.03352550f, 0.08519655f, 0.03766700f, 0.11580881f, -0.06471417f, 
    -0.17063788f, 0.15853027f, -0.07432931f, 0.18696384f, -0.19539241f, -0.12498370f, -0.27492812f, -0.30597118f, 
    -0.13153332f, -0.01967584f, -0.09677870f, -0.13630819f, -0.15003815f, 0.14844885f, 0.05650038f, 0.15157527f, 
    0.21014549f, -0.05393489f, -0.23512326f, 0.26613393f, 0.03395383f, 0.03066315f, 0.07111690f, 0.09213793f, 
    -0.09319287f, -0.06046149f, -0.02145316f, -0.00169730f, -0.35737053f, -0.07273725f, -0.26567769f, -0.24732497f, 
    0.03941307f, 0.13420442f, -0.01335969f, 0.01529243f, 0.03026013f, 0.09765600f, 0.03569975f, 0.03163577f, 
    -0.15076981f, 0.12031725f, 0.05197597f, 0.01562311f, 0.24129157f, -0.05824165f, 0.06542424f, 0.05686344f, 
    0.09159142f, 0.18861167f, -0.01521936f, 0.05799050f, 0.23119353f, -0.00439699f, 0.19508000f, 0.02083215f, 
    0.09612044f, -0.04465051f, 0.12699701f, 0.05520207f, 0.06700698f, 0.13826370f, -0.01241880f, -0.04150563f, 
    -0.01043293f, -0.02958792f, -0.01384417f, -0.06785379f, 0.06015509f, 0.06582025f, -0.00937815f, 0.03958268f, 
    -0.05762612f, 0.02511617f, 0.02902717f, -0.03566436f, 0.04234666f, 0.02261247f, -0.07713430f, 0.00578801f, 
    0.03592383f, -0.04515472f, -0.07695939f, -0.01954415f, -0.05030301f, 0.00508458f, -0.01927543f, 0.02954154f, 
    -0.03620692f, -0.06566311f, -0.06224531f, -0.03067200f, -0.04583341f, -0.03605644f, 0.04949645f, -0.06352035f, 
    -0.04970885f, 0.00140777f, -0.04013702f, 0.05175853f, -0.03216657f, -0.00903601f, 0.01483942f, -0.00860497f, 
    0.06101684f, -0.00309564f, -0.01096808f, 0.00314633f, -0.04100233f, 0.01173211f, -0.00593530f, 0.06511380f, 
    0.00881711f, 0.03601740f, -0.02839717f, -0.06948433f, 0.04636385f, 0.05232375f, 0.06370448f, 0.05488845f, 
    -0.03147098f, 0.05700963f, -0.06439081f, -0.05076740f, 0.05883645f, 0.02528246f, 0.01060482f, 0.01911995f, 
    -0.01003992f, 0.05406660f, 0.04106452f, -0.05771238f, -0.00553060f, -0.03409236f, 0.01227620f, -0.04459544f, 
    -0.04081650f, -0.00073314f, -0.05945439f, -0.02511890f, 0.06059445f, -0.05936322f, -0.03622699f, 0.01557239f, 
    0.01537394f, -0.04438591f, 0.02129612f, -0.03357370f, 0.00906025f, -0.02698425f, -0.02467826f, -0.07492636f, 
    0.02237418f, -0.04720985f, -0.02594817f, 0.02370226f, -0.07024243f, 0.03030390f, 0.03040064f, -0.01184803f, 
    -0.06228525f, -0.05296785f, -0.06898578f, 0.03981079f, -0.06144938f, -0.06434061f, -0.04610307f, -0.02714189f, 
    0.02249779f, 0.00650834f, -0.05458747f, 0.02447351f, 0.05835500f, 0.01211009f, 0.04215873f, -0.03414454f, 
    0.04137296f, -0.00691921f, -0.01796054f, -0.05184783f, 0.03529510f, -0.02453963f, 0.02219789f, 0.00819729f, 
    0.03147775f, -0.00323647f, -0.05048566f, -0.01861433f, 0.04451914f, -0.04999407f, 0.00043840f, 0.01313005f, 
    -0.06817141f, -0.01614524f, -0.03441076f, -0.07327858f, 0.02091850f, -0.04788999f, -0.01129172f, -0.03725987f, 
    -0.04784002f, -0.04654448f, -0.02660513f, -0.01943918f, -0.06837071f, 0.04600208f, -0.07184001f, -0.03898716f, 
    -0.02201083f, 0.04916923f, -0.05081156f, -0.07395900f, -0.01877855f, 0.03732652f, -0.07353555f, 0.00720257f, 
    0.02048642f, -0.06897617f, 0.03418690f, -0.03305705f, -0.06325115f, -0.01446383f, -0.03914003f, -0.02824868f, 
    -0.01778896f, -0.00295222f, 0.04816416f, -0.07329789f, 0.02610274f, -0.01038000f, 0.01619014f, -0.05781026f, 
    -0.03827810f, -0.01644169f, -0.05948156f, 0.05587016f, 0.00184206f, 0.02735911f, 0.02435483f, 0.04349105f, 
    0.05898116f, 0.06512866f, -0.00267281f, -0.07368863f, 0.05369726f, -0.00826881f, -0.02219092f, 0.05011983f, 
    0.01203942f, 0.03223542f, -0.07459493f, -0.01067482f, 0.01518340f, 0.01300548f, -0.05676071f, -0.06811344f, 
    -0.04681318f, 0.01187062f, -0.03969297f, -0.00517929f, -0.02390353f, 0.03278328f, -0.03106923f, 0.01491232f, 
    -0.04733559f, -0.07163166f, 0.00484030f, 0.04127026f, 0.01151777f, 0.03163177f, -0.04578866f, -0.03237657f, 
    -0.07788965f, -0.05791993f, -0.07743341f, 0.02888836f, -0.04376332f, 0.01996803f, 0.03725665f, 0.03037774f, 
    -0.02066147f, -0.06798654f, -0.04616868f, 0.03874437f, -0.07588267f, 0.01095697f, -0.03951602f, -0.02002181f, 
    -0.04158271f, -0.00440242f, 0.05362451f, -0.06000102f, -0.04626105f, 0.02899794f, 0.04066404f, 0.01785454f, 
    0.02423686f, -0.02237103f, -0.00395082f, 0.06498927f, -0.05967536f, 0.04987009f, -0.01716877f, 0.03413469f, 
    0.05757030f, 0.05678935f, -0.00458747f, 0.02787699f, -0.05250854f, -0.05627730f, -0.00892667f, 0.05495548f, 
    -0.04150261f, -0.01536685f, 0.05327727f, -0.07386795f, -0.04185785f, -0.03483606f, -0.02446365f, -0.04177155f, 
    0.00827393f, -0.06360046f, 0.01813073f, -0.05693645f, -0.06034465f, -0.05610237f, -0.06271164f, -0.01138955f, 
    -0.00802156f, -0.00987818f, -0.01097352f, -0.04721097f, 0.02893346f, -0.02109662f, -0.03039054f, -0.01414139f, 
    0.00950736f, -0.07209865f, -0.02962165f, -0.00054618f, -0.05894019f, -0.00365637f, 0.04087076f, -0.00250645f, 
    0.05644019f, -0.03348347f, -0.03343918f, 0.02483634f, 0.01583600f, 0.00259177f, -0.07597491f, -0.06144747f, 
    -0.04494414f, -0.03962976f, 0.01871741f, 0.01214522f, -0.05188755f, -0.01519229f, -0.02434360f, -0.06661297f, 
    -0.01111581f, 0.05737036f, 0.02724375f, -0.04332160f, -0.00028725f, 0.05361086f, 0.03189323f, 0.02058654f, 
    0.06118601f, -0.03775590f, 0.06482977f, -0.01759555f, 0.03724205f, 0.02828457f, 0.06073105f, 0.04344314f, 
    -0.02087579f, -0.03470180f, -0.01607102f, 0.02635776f, -0.06177062f, 0.01552104f, -0.03257200f, -0.06522021f, 
    0.00266852f, -0.01030442f, 0.04270804f, -0.02230180f, 0.05619237f, -0.00508414f, 0.04210941f, 0.03732599f, 
    -0.07708527f, -0.02555035f, -0.02951968f, 0.00171851f, 0.05078696f, -0.06822671f, 0.05246845f, 0.02700892f, 
    0.05756457f, -0.03523738f, -0.06550664f, 0.05528617f, -0.05463111f, -0.01401000f, 0.05268232f, -0.07552307f, 
    -0.04017762f, -0.02117250f, 0.06468435f, -0.05011815f, 0.04566368f, -0.00795351f, 0.00400778f, -0.02883293f, 
    -0.02710053f, -0.00990809f, 0.01666458f, 0.04843360f, -0.01263632f, 0.00629827f, -0.05339319f, -0.05899385f, 
    -0.06472418f, 0.01907208f, 0.01188959f, 0.05536733f, -0.06765018f, -0.01069751f, -0.05042179f, -0.05396402f, 
    -0.04037729f, -0.04212620f, -0.04876647f, 0.06213935f, 0.04681745f, 0.06307527f, 0.02343643f, -0.00875280f, 
    0.01423484f, 0.03324927f, 0.00617406f, -0.07738572f, 0.04406504f, -0.04695592f, 0.00065060f, 0.00653829f, 
    0.02553737f, -0.06098513f, 0.02137328f, 0.05497781f, -0.01616610f, -0.01487891f, -0.01755476f, 0.01643198f, 
    -0.04791263f, -0.05272504f, 0.04760580f, -0.06727562f, -0.05014845f, 0.05207943f, -0.01186858f, -0.03050177f, 
    -0.06138943f, -0.03321464f, 0.01819144f, -0.03260940f, -0.02853641f, 0.05706138f, -0.07543541f, 0.01990116f, 
    0.03341512f, -0.02911471f, 0.01046944f, 0.01922730f, -0.03582631f, -0.01731472f, -0.00209416f, -0.03228578f, 
    -0.02688010f, -0.03277881f, -0.03983682f, -0.04568016f, -0.07078423f, -0.03214927f, -0.03038118f, -0.07114588f, 
    -0.00124849f, 0.04796175f, 0.00701377f, -0.02025422f, -0.05923709f, 0.05157632f, -0.02042931f, -0.03592056f, 
    0.01250646f, 0.05460681f, -0.04735808f, -0.00685014f, -0.00853147f, 0.00084762f, 0.01779565f, 0.04775835f, 
    -0.05375567f, -0.06358837f, -0.04047434f, 0.05858158f, 0.00951672f, 0.02901186f, -0.06473242f, -0.00696712f, 
    -0.07855999f, 0.01378048f, 0.06051574f, 0.03074106f, -0.07253438f, 0.01444208f, 0.01958953f, 0.03166883f, 
    -0.00322252f, -0.03695984f, -0.07935636f, 0.03586477f, -0.04385258f, -0.04938040f, 0.02745046f, -0.04858119f, 
    0.05897978f, -0.02849033f, -0.03445224f, -0.06488407f, 0.00882934f, 0.05542041f, 0.01262686f, 0.03850144f, 
    -0.07337912f, -0.00623645f, -0.06680573f, -0.03803287f, 0.04530138f, 0.02736981f, -0.01044811f, -0.08073825f, 
    -0.08277506f, -0.03856711f, 0.05871157f, 0.00076333f, -0.02919074f, 0.05474216f, 0.01572241f, -0.00454096f, 
    -0.03209332f, -0.01736286f, 0.00894482f, -0.00374221f, -0.06402100f, 0.00133764f, 0.04744583f, -0.06218183f, 
    0.05312939f, 0.05972269f, -0.04937403f, -0.02884686f, 0.04108563f, 0.04943588f, 0.02379710f, -0.05581191f, 
    0.01803440f, -0.01009208f, 0.02125229f, -0.02704509f, -0.08051138f, -0.04756711f, -0.04654315f, -0.05941169f, 
    -0.08140643f, 0.01289510f, -0.00581789f, -0.05585590f, 0.02534503f, 0.04611805f, -0.05292205f, -0.07668369f, 
    -0.05820968f, -0.07021128f, 0.02209923f, -0.07197920f, -0.02453946f, 0.02293445f, -0.07518455f, -0.06295269f, 
    0.02701663f, 0.03522432f, -0.01234616f, -0.00523230f, -0.06262262f, 0.02578299f, 0.03730676f, 0.06091883f, 
    -0.02352058f, -0.04062940f, 0.05272993f, 0.00133057f, 0.02416502f, 0.04206851f, 0.04660299f, -0.00655340f, 
    0.02889194f, 0.01186553f, -0.03223933f, 0.01894985f, -0.04818285f, 0.03582256f, -0.01773714f, -0.05341568f, 
    0.05808540f, 0.02639870f, -0.04734672f, -0.00897710f, -0.03442004f, 0.03236629f, 0.02227038f, -0.00451338f, 
    0.01797437f, -0.05744243f, 0.02778164f, 0.00903974f, 0.05378081f, 0.05174357f, 0.01128909f, 0.01752332f, 
    0.04195827f, -0.00603544f, -0.07255440f, -0.04738436f, -0.02238317f, 0.02578953f, -0.00508393f, 0.02319464f, 
    0.19051164f, 0.12584916f, 0.02539954f, 0.09383865f, -0.20055301f, 0.09469862f, -0.06158100f, 0.08748680f, 
    0.00163592f, -0.08909902f, -0.06044010f, 0.03903283f, 0.09415809f, -0.03187507f, 0.12389180f, -0.06836715f, 
    0.06964855f, -0.02193562f, 0.09674911f, -0.06429172f, 0.03433402f, 0.01691893f, 0.04692356f, 0.17991854f, 
    -0.13937950f, 0.32151818f, 0.02673763f, 0.03385647f, 0.00042456f, -0.00173387f, 0.01949532f, 0.07451559f, 
    -0.01149098f, 0.05362007f, 0.14419055f, 0.02811593f, 0.02853183f, 0.03565073f, 0.25456372f, -0.09140687f, 
    0.09429686f, -0.02770791f, -0.08999272f, -0.06140570f, 0.15156652f, -0.00575514f, -0.05872141f, -0.08910606f, 
    0.17026529f, 0.14690249f, 0.27150106f, 0.06223569f, -0.02694687f, 0.13719751f, 0.05455453f, 0.16726366f, 
    0.11801565f, -0.02827464f, 0.09181017f, 0.09805769f, -0.52024812f, -0.03509785f, 0.22969142f, 0.22633564f, 
    -0.11683477f, 0.10518600f, 0.08174881f, 0.01224498f, 0.08330747f, 0.07627999f, 0.04249651f, 0.13516311f, 
    0.03332819f, 0.10120518f, 0.16928387f, -0.08851706f, -0.09049901f, 0.16198775f, -0.16021267f, -0.15617655f, 
    0.09265826f, -0.05910262f, -0.02350782f, -0.06919200f, -0.11069445f, -0.11178645f, -0.01109032f, -0.13121410f, 
    0.05711148f, -0.01916775f, 0.03247465f, 0.09659339f, 0.00633244f, -0.17857008f, -0.08410276f, -0.05543301f, 
    -0.22674924f, 0.15321651f, -0.15435003f, -0.11875983f, -0.04612844f, 0.06918403f, 0.00962914f, -0.06631930f, 
    -0.09016648f, 0.02778483f, -0.04870801f, -0.15553188f, 0.32904372f, 0.01560273f, -0.23750611f, -0.35045519f, 
    0.04278830f, 0.09051383f, -0.11123268f, -0.13458464f, -0.07549076f, -0.07878106f, -0.02530048f, 0.02795425f, 
    0.12046801f, -0.32217515f, 0.08136681f, -0.25890803f, 0.05897786f, 0.07012355f, 0.03903088f, -0.14717931f, 
    0.08330471f, 0.04476012f, -0.11611562f, 0.02005773f, -0.12934193f, -0.06974763f, 0.12498331f, 0.43768495f, 
    -0.19719219f, -0.11371773f, -0.05281837f, -0.04013070f, 0.10069381f, 0.10193775f, 0.02945473f, 0.00695387f, 
    -0.51689732f, -0.17886716f, -0.13924839f, -0.11116926f, 0.13672350f, -0.05267660f, -0.05156754f, -0.03137184f, 
    -0.07021331f, 0.13610139f, 0.17478633f, 0.09588586f, 0.01567305f, -0.05830608f, 0.00258369f, 0.21132672f, 
    -0.00680521f, -0.05840148f, 0.10142788f, 0.04843907f, 0.09168724f, 0.04697286f, 0.07246464f, -0.04412023f, 
    -0.28470856f, 0.13926697f, -0.01132723f, -0.10650291f, 0.14096372f, -0.08408560f, -0.01267200f, 0.03209006f, 
    0.11926598f, -0.01869836f, -0.03859609f, 0.00765003f, 0.08193787f, -0.00757072f, 0.13282461f, 0.29579246f, 
    -0.11265671f, 0.03525125f, 0.18065867f, -0.11008916f, 0.01075107f, -0.08400879f, -0.02327745f, 0.28225261f, 
    0.41548002f, -0.45048371f, 0.00656529f, -0.31797621f, -0.11116309f, -0.03105024f, 0.05184175f, 0.07334227f, 
    -0.02114308f, 0.00468975f, -0.11443803f, 0.07572328f, 0.36921379f, -0.15942413f, 0.18000750f, 0.04459023f, 
    -0.03848634f, 0.02837745f, -0.01252385f, 0.02548785f, 0.07542207f, -0.01112654f, -0.13755248f, -0.03125552f, 
    -0.16232604f, 0.14276284f, -0.03619263f, -0.18091810f, -0.17184049f, -0.07220042f, 0.06488451f, 0.00956957f, 
    0.02587069f, 0.05085953f, -0.02684153f, 0.04792966f, 0.20047235f, 0.23328234f, 0.01167077f, -0.37572199f, 
    -0.22436395f, 0.03341796f, -0.01751993f, 0.01512127f, 0.05794295f, 0.05157795f, 0.02548319f, -0.06233471f, 
    0.31543127f, -0.13768747f, 0.30619818f, -0.20022275f, 0.02458193f, -0.14080809f, 0.15974602f, 0.01706516f, 
    0.00669298f, -0.01937000f, -0.04001862f, 0.07145470f, -0.02204655f, -0.07622965f, -0.07445940f, 0.14425501f, 
    0.07371324f, 0.12323140f, -0.05428109f, 0.17695692f, -0.17547435f, 0.02347495f, 0.12625067f, -0.10234150f, 
    0.01351866f, 0.02349212f, 0.08305813f, -0.02659958f, 0.00737361f, -0.19250463f, 0.13409783f, 0.19385949f, 
    0.18388614f, 0.16512442f, 0.03275684f, 0.01046582f, 0.23650967f, 0.08351833f, -0.04688720f, -0.14083125f, 
    -0.01404860f, -0.02644750f, 0.14101848f, 0.08620023f, 0.19079885f, 0.07638250f, 0.06919011f, 0.08688289f, 
    0.39868286f, 0.01935124f, -0.32309678f, 0.00299424f, 0.16173953f, -0.06899204f, 0.21519233f, -0.04051451f, 
    -0.01792437f, 0.03034656f, 0.02942402f, 0.08153053f, 0.20465057f, -0.20545554f, -0.12856439f, -0.31334996f, 
    0.05015364f, -0.02627858f, 0.17851241f, -0.12588404f, -0.04828979f, 0.01863150f, 0.11200189f, 0.17394847f, 
    0.01724864f, -0.38427007f, 0.03110631f, -0.34094852f, -0.08668944f, 0.04826342f, 0.10825172f, -0.01348881f, 
    0.15953217f, 0.13134719f, 0.05596305f, 0.11905618f, 0.08872269f, -0.25324419f, -0.01385432f, 0.48375008f, 
    -0.23990737f, -0.05135257f, -0.07213590f, 0.01135833f, 0.07523311f, 0.04126326f, -0.00035968f, 0.11458635f, 
    -0.19729848f, 0.19052623f, -0.10093780f, -0.18761076f, -0.15060717f, -0.25277704f, 0.15565398f, 0.15591444f, 
    0.01608943f, 0.06485681f, 0.01588108f, 0.11907403f, 0.03838632f, -0.13618656f, -0.04821117f, 0.16519763f, 
    -0.23393300f, -0.18941809f, -0.24680810f, 0.00336993f, 0.00870862f, 0.12112940f, -0.19225509f, -0.05229092f, 
    -0.12440973f, 0.24275069f, -0.04340631f, 0.17382930f, 0.09142671f, 0.11381813f, 0.05622279f, 0.14808543f, 
    0.11539565f, 0.04807478f, -0.14380521f, 0.05962158f, 0.02160924f, 0.02392798f, 0.05745452f, 0.33622748f, 
    -0.01800046f, 0.04022288f, 0.08666854f, 0.12003171f, 0.04856953f, 0.00835434f, -0.15320176f, -0.08001050f, 
    -0.05018693f, -0.14987752f, 0.18888080f, 0.01707647f, 0.29281947f, 0.03843043f, -0.12683591f, 0.14040090f, 
    -0.05796532f, -0.12589401f, -0.14149687f, -0.00998891f, 0.42277271f, -0.19441417f, 0.09938487f, 0.16712907f, 
    -0.03147685f, -0.08181660f, 0.08259285f, 0.11372861f, 0.07282379f, -0.09851351f, -0.13694528f, -0.01611805f, 
    0.65250188f, -0.00344326f, 0.07976862f, 0.08199057f, -0.08163539f, -0.11343380f, 0.26136813f, 0.03426752f, 
    0.05295388f, 0.05870163f, -0.02664213f, -0.12901001f, -0.27283388f, -0.31225184f, -0.05485244f, 0.03544484f, 
    -0.09630707f, 0.18175046f, -0.16150634f, 0.10782704f, -0.04699310f, 0.02050876f, 0.03012698f, -0.00064905f, 
    0.17638041f, 0.07973141f, 0.18852893f, 0.43420878f, 0.18661471f, -0.06261524f, -0.03853383f, -0.07466679f, 
    -0.11558599f, 0.03827801f, 0.00735408f, -0.10522489f, 0.31430939f, 0.21426491f, 0.08858132f, 0.14346540f, 
    0.11500664f, 0.00557060f, 0.01964878f, -0.00997656f, 0.06461058f, 0.01036160f, 0.17111023f, 0.01479633f, 
    -0.15176967f, 0.11118639f, -0.15340285f, -0.00336814f, 0.06534876f, -0.07097660f, 0.00280143f, 0.00415779f, 
    0.27895465f, 0.10839288f, 0.13380022f, 0.09411263f, 0.04426780f, -0.08025163f, -0.29469210f, -0.12742479f, 
    0.11270225f, -0.11226481f, -0.12624693f, -0.04453710f, 0.11562017f, 0.09830166f, 0.03897553f, 0.05225669f, 
    -0.20213377f, 0.01202736f, 0.09680098f, 0.12574215f, 0.20235473f, 0.04210673f, 0.05471971f, -0.10410725f, 
    0.16688769f, 0.13373019f, 0.16899902f, 0.12274460f, -0.64063472f, 0.01210531f, -0.14930587f, 0.09575950f, 
    0.03524348f, -0.07363112f, 0.13115586f, 0.22628304f, -0.05973078f, -0.10039089f, -0.05174589f, -0.01522300f, 
    0.22531368f, -0.03887392f, 0.02023451f, -0.04803408f, 0.01501884f, -0.07185920f, -0.01446514f, -0.01113931f, 
    -0.02934656f, -0.04712976f, -0.07073699f, 0.15769903f, 0.30931091f, -0.23089261f, -0.15021990f, -0.24924688f, 
    0.00996161f, 0.01863995f, -0.03992015f, 0.00033097f, -0.04663070f, 0.10303584f, 0.01601232f, 0.00262637f, 
    0.10960902f, 0.02147179f, -0.36788896f, 0.16657659f, 0.04438280f, -0.07062649f, -0.09460891f, -0.00021607f, 
    0.16089031f, 0.05358656f, 0.00820079f, 0.02818810f, 0.22592978f, -0.08694910f, -0.21893583f, -0.27451965f, 
    -0.01034073f, 0.01603358f, -0.07636224f, -0.21967910f, 0.10348688f, -0.07414254f, 0.02789018f, 0.03307507f, 
    -0.44353750f, 0.21651059f, -0.20524581f, 0.11061382f, 0.18659011f, 0.01243293f, 0.09164157f, -0.00195278f, 
    0.00663709f, 0.03246363f, 0.18287419f, 0.05241952f, 0.18312663f, -0.11882351f, 0.09132056f, -0.13420920f, 
    0.12055798f, -0.06593420f, 0.00293470f, 0.05553254f, -0.05226767f, 0.03749354f, 0.01648878f, -0.00463715f, 
    0.20658116f, 0.35244480f, -0.02047070f, 0.33774140f, -0.21323428f, -0.12938070f, 0.27139631f, 0.17578930f, 
    -0.07354423f, 0.01980202f, -0.03004340f, 0.07893585f, -0.19535562f, 0.25719634f, -0.09482586f, 0.17315774f, 
    -0.01683475f, -0.13399142f, -0.01764866f, 0.00191849f, -0.15879408f, 0.01159446f, -0.17938083f, -0.13463613f, 
    -0.13090335f, 0.01838265f, -0.04895719f, -0.05197410f, -0.14427446f, 0.02786084f, 0.08312019f, -0.08879188f, 
    -0.05782706f, -0.10339798f, 0.07369231f, -0.11731336f, -0.06010294f, 0.34414977f, 0.14522044f, 0.09266510f, 
    0.23926876f, -0.06256007f, 0.08416072f, -0.13102318f, 0.19105393f, 0.01814753f, 0.14867812f, 0.14403079f, 
    -0.07409471f, 0.14942953f, -0.18778458f, 0.08669516f, -0.05354219f, -0.12801425f, -0.03163477f, -0.01285392f, 
    -0.12088481f, 0.10773575f, -0.21763049f, -0.13293791f, -0.31111661f, -0.15301472f, 0.18975359f, -0.39614445f, 
    -0.07163765f, -0.01920396f, -0.04786474f, 0.07739750f, -0.13153356f, 0.04645481f, -0.24173126f, -0.05869934f, 
    0.25427049f, -0.02528257f, -0.06182498f, 0.06873800f, -0.16501459f, 0.09844422f, -0.03393708f, -0.09040779f, 
    -0.20349577f, -0.14243142f, 0.04227201f, 0.09101018f, 0.22473121f, 0.17739300f, 0.35408369f, 0.48593313f, 
    0.07461804f, 0.19553038f, 0.08199496f, 0.04069170f, -0.05487315f, 0.08338355f, 0.04187400f, -0.18977331f, 
    0.14383791f, 0.11568075f, -0.10799363f, 0.02754430f, -0.09591050f, 0.09468320f, 0.17345729f, 0.11440273f, 
    -0.12774111f, 0.08563278f, -0.02695859f, 0.08910269f, 0.34463307f, -0.12520109f, 0.02533222f, -0.02608217f, 
    -0.00559443f, 0.07018289f, -0.03129517f, -0.25993198f, 0.08174828f, 0.06136286f, -0.06394500f, -0.03050247f, 
    0.34070459f, 0.18071665f, 0.12516530f, 0.33223608f, 0.19954899f, 0.03028123f, 0.01763820f, 0.20643605f, 
    -0.02331921f, 0.09507940f, 0.09211835f, -0.14497608f, 0.03690249f, -0.01917054f, -0.17080960f, -0.09227113f, 
    -0.06000150f, 0.05740905f, -0.07488477f, -0.15174715f, -0.10226838f, 0.02510592f, -0.07089575f, 0.03433429f, 
    0.21099411f, 0.15622954f, 0.48084366f, 0.31096175f, 0.15482290f, 0.18690322f, 0.06170998f, 0.02471316f, 
    -0.10812581f, 0.10732914f, -0.03161837f, 0.02372072f, -0.17691062f, 0.05427656f, -0.08175936f, -0.03754449f, 
    -0.03761689f, 0.00083281f, -0.02367444f, 0.02064559f, -0.03525416f, -0.08384226f, -0.10680784f, -0.09728445f, 
    0.10939538f, -0.06186220f, 0.35063720f, -0.18253590f, -0.02183083f, 0.02311605f, -0.07443595f, 0.01747376f, 
    -0.07399985f, -0.01884357f, -0.24724182f, -0.02843205f, 0.05109411f, -0.08396835f, -0.19680043f, 0.20720664f, 
    -0.12054279f, -0.10359829f, 0.03778837f, 0.05346399f, -0.00749767f, -0.13619742f, -0.06953335f, -0.20791291f, 
    -0.07807819f, 0.01666715f, 0.01316461f, 0.04856454f, -0.05656523f, 0.01467080f, 0.01107844f, 0.01152103f, 
    0.00749157f, -0.06308791f, 0.01527440f, 0.04356169f, 0.03966404f, -0.05871444f, -0.07341588f, 0.03018094f, 
    0.02906215f, -0.00591823f, -0.01133774f, -0.04939288f, -0.05013316f, -0.03032796f, -0.03455239f, 0.00946262f, 
    -0.01322559f, 0.00322037f, 0.02297173f, -0.05222965f, -0.02908080f, -0.05448800f, -0.04888296f, 0.04142306f, 
    -0.07143861f, -0.03920949f, -0.02031683f, -0.05499416f, -0.08132469f, -0.03468865f, 0.04983030f, 0.03725113f, 
    -0.07986402f, -0.08016808f, -0.02497722f, -0.08062334f, 0.01760820f, -0.07421660f, -0.00841107f, -0.02587350f, 
    -0.07096275f, 0.04209632f, -0.00572976f, -0.05328304f, -0.03261362f, 0.02026180f, -0.06067512f, -0.03899219f, 
    0.05996734f, -0.01190609f, -0.05180281f, 0.00631588f, -0.04287545f, -0.07503013f, 0.04831697f, -0.07226062f, 
    -0.06267244f, -0.02652142f, 0.01710574f, -0.06599311f, 0.05631538f, -0.01564007f, -0.00054377f, -0.07711241f, 
    0.01080807f, 0.00432141f, -0.06082691f, -0.06452732f, -0.00046943f, -0.07401571f, 0.03976740f, 0.05904168f, 
    0.05618964f, -0.06529862f, 0.01189680f, 0.04874308f, -0.04501392f, 0.05026483f, -0.06502135f, 0.01766125f, 
    -0.04731177f, 0.05774518f, -0.05996070f, -0.06633745f, 0.06732526f, -0.00199908f, 0.01146580f, -0.07841096f, 
    0.03457614f, -0.01236424f, -0.03875933f, 0.04187776f, -0.04590677f, -0.04319999f, -0.04090929f, 0.04438118f, 
    0.04119928f, 0.04672052f, -0.04447881f, -0.00927174f, 0.03146286f, -0.04080163f, 0.00266087f, 0.00010387f, 
    0.01547419f, 0.04455872f, 0.06095063f, 0.00574891f, -0.02803674f, -0.04654578f, 0.05367343f, -0.01701447f, 
    0.03293632f, -0.06402382f, -0.07526183f, -0.02134016f, 0.05248329f, -0.01486061f, 0.05467590f, 0.03596043f, 
    0.02619329f, 0.03967090f, 0.00128395f, -0.01604671f, -0.01192298f, -0.00214325f, 0.00874403f, -0.07159491f, 
    -0.06416543f, 0.04575734f, -0.00330536f, 0.06378572f, 0.00925937f, -0.02853379f, -0.05543440f, -0.02516234f, 
    -0.06146523f, -0.00655053f, -0.07118677f, -0.06080300f, 0.02145669f, -0.04257349f, 0.02196694f, -0.02350530f, 
    0.02381434f, -0.05592517f, 0.04648994f, -0.00120604f, 0.00799676f, 0.01044113f, 0.03267107f, -0.01676080f, 
    -0.03302382f, 0.02775439f, 0.01916811f, 0.03895383f, -0.05551414f, -0.02063573f, 0.05036825f, -0.05089313f, 
    -0.02636236f, 0.03435288f, -0.04866597f, 0.05383099f, -0.06712984f, 0.05411864f, 0.04858438f, -0.01648949f, 
    -0.08063059f, 0.03559571f, 0.02172382f, 0.06025326f, 0.04872654f, -0.00346700f, 0.04904054f, -0.00269008f, 
    0.00381477f, -0.03863371f, 0.05670392f, 0.05517209f, -0.07849155f, -0.02758967f, -0.05698437f, -0.02810903f, 
    0.00829578f, 0.04241860f, -0.04160026f, 0.02075331f, -0.04558961f, -0.07302851f, 0.00173168f, 0.03358143f, 
    -0.01200937f, -0.05412915f, 0.05454866f, -0.05720032f, 0.00593393f, -0.02380168f, -0.02963422f, -0.00973716f, 
    0.02031439f, -0.03860288f, -0.03976523f, -0.00861224f, -0.05247725f, 0.05015203f, 0.02947234f, -0.03640516f, 
    0.03916724f, 0.03841020f, 0.03069114f, -0.04335886f, 0.02534436f, 0.04642632f, 0.00926301f, -0.00866751f, 
    0.02939988f, -0.01308568f, 0.01464203f, 0.03223903f, 0.01366927f, -0.03962160f, -0.04462633f, 0.01675864f, 
    -0.03031005f, 0.06142423f, -0.08019862f, -0.08837835f, 0.02005166f, 0.02527343f, 0.02136922f, 0.01644140f, 
    0.04750754f, -0.06707654f, -0.01094471f, 0.00381242f, 0.01050249f, -0.08288322f, -0.01202611f, -0.07220346f, 
    0.02446968f, -0.03897672f, 0.02580485f, -0.03349353f, -0.08038937f, 0.03498340f, -0.06294318f, -0.05123039f, 
    0.02378652f, 0.00304646f, 0.02903850f, 0.00597019f, 0.05145430f, -0.06677276f, 0.05536894f, -0.06298713f, 
    -0.05738206f, -0.00024495f, -0.06536070f, -0.05594106f, -0.03350971f, -0.06997263f, -0.02511659f, 0.03461993f, 
    -0.05160447f, 0.01228451f, 0.03574181f, 0.04265053f, 0.05750671f, 0.04290350f, 0.02135094f, -0.00701414f, 
    -0.02727395f, 0.02729402f, -0.02304554f, -0.03651616f, -0.07404095f, -0.07563052f, -0.03429907f, -0.00701306f, 
    0.03605083f, 0.05319824f, 0.04036997f, -0.06420490f, 0.05394053f, -0.02512151f, 0.04464350f, -0.01814234f, 
    0.00215110f, -0.05986613f, -0.03472962f, -0.06806023f, -0.07685524f, -0.03488164f, 0.03287546f, 0.00465660f, 
    -0.02575506f, -0.04945299f, -0.03461883f, -0.07963873f, 0.02373733f, -0.01865203f, 0.04099616f, -0.02985686f, 
    -0.01352203f, -0.03702119f, 0.01238784f, -0.02733455f, 0.05368686f, -0.02364191f, -0.03571767f, 0.00420195f, 
    -0.00118261f, -0.04564055f, -0.08095661f, -0.02419389f, 0.05763962f, 0.01291144f, -0.08513813f, 0.00084541f, 
    0.04177268f, -0.03881461f, 0.00247060f, -0.02036790f, -0.07507441f, -0.00494666f, 0.00529834f, 0.05073028f, 
    -0.04250132f, -0.03234890f, -0.01456657f, -0.00961679f, 0.02772063f, -0.01705986f, -0.00921348f, 0.03524103f, 
    0.05317769f, -0.04305668f, -0.07662864f, 0.00637291f, -0.08024321f, -0.04424058f, 0.01738348f, 0.04170909f, 
    -0.03085446f, 0.01420600f, -0.02086509f, -0.04570683f, -0.03164971f, -0.09522277f, -0.03313440f, 0.00745570f, 
    -0.00492968f, -0.07282553f, -0.04722865f, -0.01356223f, 0.04919099f, -0.07521151f, 0.04172958f, 0.02127927f, 
    0.02508518f, -0.01581690f, -0.02155285f, 0.03443923f, 0.04778719f, -0.01205840f, 0.00435974f, 0.03811460f, 
    0.00313980f, -0.00196684f, 0.01738843f, -0.05703487f, -0.07296627f, 0.03790228f, -0.02971763f, -0.03850577f, 
    0.16003589f, -0.25290194f, 0.13988902f, 0.36000234f, -0.00148946f, -0.04776802f, -0.06707970f, 0.13536660f, 
    0.02135025f, 0.05020018f, -0.11829273f, 0.17020719f, -0.11954913f, -0.11054199f, 0.04106124f, 0.30638030f, 
    -0.07589151f, 0.01633889f, 0.06287114f, -0.05274779f, -0.14371924f, 0.15396921f, -0.03598029f, 0.06859096f, 
    -0.06276307f, 0.16837725f, -0.11102153f, 0.33817020f, -0.12433937f, 0.04907671f, 0.03472102f, -0.05917313f, 
    -0.06431185f, -0.04697083f, -0.07395353f, -0.07500859f, -0.34024110f, -0.24520004f, -0.18886694f, -0.01938757f, 
    0.01816437f, 0.02207445f, 0.08773911f, -0.01407237f, -0.10547837f, 0.12510127f, -0.03371484f, -0.00323129f, 
    0.12411821f, -0.18000560f, -0.02643092f, -0.03849949f, -0.10184497f, 0.03936954f, -0.05089511f, 0.12363358f, 
    0.04194498f, -0.05150965f, 0.07813998f, -0.02901019f, 0.05510891f, -0.04339741f, 0.07773987f, -0.03772081f, 
    0.16625902f, 0.04812654f, 0.00312575f, -0.00875695f, 0.04293737f, 0.05712382f, 0.00083065f, -0.16103223f, 
    -0.31035414f, 0.26986894f, 0.23779492f, -0.07703976f, -0.13016155f, 0.01470487f, 0.06344732f, -0.03936809f, 
    0.02116943f, -0.01592851f, 0.00567824f, 0.06535172f, -0.08180328f, -0.30897561f, -0.14836287f, -0.10889736f, 
    0.05155381f, 0.15971524f, 0.04439655f, 0.12214619f, -0.14188203f, -0.08485861f, 0.04607580f, -0.05418428f, 
    -0.20838682f, 0.00809450f, 0.11744125f, -0.11615440f, -0.03971657f, 0.05370057f, 0.28833321f, 0.03537627f, 
    0.00579363f, -0.03521511f, 0.11245156f, -0.00591764f, -0.14034861f, -0.31991470f, 0.06260526f, -0.07662320f, 
    -0.12319496f, -0.11178019f, -0.05875756f, -0.09494098f, -0.00651431f, -0.06257648f, -0.04384749f, 0.07526625f, 
    -0.09482722f, -0.26695758f, -0.30222028f, 0.15854000f, -0.01893078f, 0.02324443f, 0.08238929f, -0.04271687f, 
    0.20210889f, -0.03363474f, 0.03592347f, -0.14468294f, 0.24951649f, 0.15502180f, 0.21186754f, -0.12629081f, 
    -0.28784576f, 0.03833368f, 0.15373437f, 0.19730702f, 0.15022653f, 0.00666819f, -0.02634552f, 0.14666611f, 
    -0.10922165f, -0.11436011f, -0.08561090f, -0.11581002f, 0.06941353f, 0.12697706f, -0.04337312f, 0.14753930f, 
    -0.07643379f, -0.07964256f, 0.14314334f, 0.00073169f, 0.03574006f, 0.35385081f, 0.30697259f, -0.21990992f, 
    -0.22116350f, -0.07668506f, 0.05563833f, 0.08983190f, 0.09988213f, 0.13065229f, 0.05361271f, 0.04865867f, 
    -0.00693080f, 0.08118473f, -0.03619597f, -0.08409895f, -0.08436883f, 0.15637510f, 0.02488057f, 0.05396457f, 
    0.10020246f, -0.02062514f, 0.01454569f, 0.01616911f, 0.22234806f, 0.32252625f, 0.25727654f, -0.13617261f, 
    -0.01339791f, 0.14808768f, -0.01353378f, 0.00465576f, 0.00590017f, 0.00506984f, -0.00154915f, 0.12219579f, 
    -0.36543721f, -0.15812752f, 0.13319439f, -0.34090853f, 0.05267991f, -0.05512086f, 0.16632341f, -0.04480344f, 
    -0.16478050f, 0.05129622f, 0.03839167f, 0.03157262f, -0.05439052f, 0.13532794f, 0.14265424f, -0.25238571f, 
    0.04714337f, 0.00862574f, -0.05294964f, 0.00324399f, 0.03801648f, -0.13206121f, -0.09342022f, -0.06797215f, 
    -0.22349913f, -0.11443993f, 0.19110021f, -0.22581106f, 0.06064001f, -0.13017716f, 0.11359950f, 0.03461127f, 
    0.10899109f, 0.13930365f, -0.08001641f, -0.12374017f, 0.64629525f, 0.19916171f, 0.23437144f, -0.09830233f, 
    0.06675345f, 0.00429566f, -0.10656624f, 0.14022166f, -0.01871223f, 0.04180335f, 0.08227050f, 0.10984964f, 
    -0.15857057f, 0.05632322f, 0.17721553f, -0.06086161f, 0.09549098f, -0.04785237f, 0.05394050f, -0.14704596f, 
    -0.17982239f, 0.13619813f, -0.03584313f, -0.07591869f, 0.23434897f, 0.00842168f, -0.11514925f, 0.11253522f, 
    0.09731478f, -0.02467758f, -0.10973772f, 0.00354564f, 0.12836075f, -0.04939508f, 0.04875256f, -0.02466233f, 
    0.21059118f, -0.02025790f, -0.07865912f, -0.02455532f, -0.07179454f, -0.07500044f, 0.01198840f, 0.28877357f, 
    0.10825922f, 0.16329831f, 0.08875814f, 0.03544649f, 0.26070139f, 0.16989402f, 0.10707162f, 0.09407103f, 
    0.05683563f, -0.02259878f, -0.07567129f, -0.08087645f, 0.05478745f, 0.14062491f, 0.02115818f, 0.05859409f, 
    0.40869889f, 0.00078068f, 0.00644914f, 0.09334244f, 0.05067163f, -0.01714497f, -0.23309775f, -0.07525058f, 
    -0.04277277f, 0.02678403f, -0.02352238f, 0.01832823f, 0.12813839f, 0.21919304f, 0.05743024f, 0.03298477f, 
    0.16682385f, 0.02129275f, 0.20553033f, 0.29292086f, -0.06971335f, -0.10286158f, 0.19987677f, -0.09497488f, 
    -0.06720194f, 0.18874577f, 0.16764461f, -0.13578345f, 0.04143224f, -0.02123820f, 0.06063508f, 0.03184355f, 
    -0.06802349f, 0.09002922f, 0.06479525f, 0.11541731f, -0.18370025f, 0.03601499f, -0.22457682f, -0.05564072f, 
    0.07767666f, 0.02481217f, -0.03962950f, -0.14810795f, -0.14567356f, 0.08387197f, 0.06379177f, 0.01665590f, 
    0.33301914f, 0.10058565f, 0.04505386f, 0.01361575f, -0.00556866f, -0.02493162f, 0.12624219f, -0.05677836f, 
    0.05904088f, -0.11980422f, -0.24669975f, -0.13624366f, -0.10580947f, -0.01462111f, -0.19721772f, -0.04349053f, 
    -0.00981973f, 0.02884981f, -0.09980883f, -0.09535533f, -0.04364043f, 0.12900841f, -0.11279492f, -0.06075075f, 
    0.30762422f, -0.08621327f, -0.00458885f, 0.14020824f, 0.00956435f, 0.07668564f, -0.03286158f, 0.08552740f, 
    -0.05483002f, 0.16042249f, -0.11366872f, -0.02532914f, -0.08204712f, 0.04734180f, -0.00904507f, -0.02325779f, 
    0.09433750f, 0.09296049f, 0.02540461f, 0.13037975f, 0.11340556f, 0.14177313f, -0.08313793f, -0.19811501f, 
    -0.41153017f, -0.16635466f, 0.17894566f, 0.03576460f, 0.16211587f, -0.02948471f, -0.03268116f, 0.03378116f, 
    0.04977691f, 0.16411030f, 0.11296941f, 0.13955431f, -0.23008637f, 0.05382747f, -0.07432608f, -0.07327091f, 
    0.16435033f, 0.06562793f, 0.06403681f, 0.03650619f, -0.03432974f, 0.01519302f, 0.15460272f, -0.09090236f, 
    -0.00052970f, -0.10953577f, -0.04475742f, 0.24125752f, 0.17548560f, 0.01383840f, -0.00382159f, -0.00096625f, 
    0.09427681f, -0.07453306f, -0.08253670f, 0.14314294f, 0.12046088f, -0.17498511f, -0.30530500f, -0.02989853f, 
    0.00586677f, 0.00491522f, -0.05957221f, 0.09310380f, -0.01153674f, 0.12859792f, 0.20343737f, 0.02546909f, 
    -0.03828001f, 0.03669026f, -0.07168095f, -0.03424773f, 0.03310915f, 0.04343213f, 0.06883132f, 0.06497331f, 
    -0.06601440f, -0.00353841f, -0.03551523f, -0.04403732f, 0.50761724f, -0.14508745f, -0.09572680f, 0.18640010f, 
    0.06148791f, -0.07338064f, -0.05233109f, -0.01133562f, 0.12819266f, 0.06856899f, 0.06299985f, 0.05317969f, 
    -0.38777861f, -0.05636655f, 0.00186311f, -0.06574642f, 0.18731807f, 0.10638066f, -0.07888030f, 0.06819534f, 
    -0.00531952f, -0.05494733f, -0.10743383f, 0.25538555f, 0.23682150f, -0.10041792f, -0.04261859f, -0.10388424f, 
    -0.06394347f, 0.01146734f, 0.08144661f, -0.09340703f, 0.14946099f, 0.00880373f, 0.22081031f, 0.15054424f, 
    0.31507626f, 0.00030135f, 0.14913942f, 0.20877668f, -0.11563469f, -0.04692822f, -0.12104651f, -0.00555038f, 
    0.12823275f, -0.06662507f, 0.09295132f, -0.00192259f, 0.02895019f, -0.00548121f, -0.10677544f, 0.09589438f, 
    -0.02577955f, 0.03049130f, 0.13513638f, 0.14023612f, 0.08097214f, -0.12473852f, -0.04710334f, 0.04411075f, 
    -0.15074013f, 0.17571364f, -0.08136256f, 0.15143643f, -0.04609420f, 0.11761071f, -0.01043178f, -0.03563288f, 
    0.10726477f, 0.04682592f, 0.10894048f, -0.09171914f, -0.20565110f, 0.00054667f, -0.09400695f, -0.35396141f, 
    0.13831118f, -0.00728032f, 0.02267442f, -0.03979387f, -0.08557209f, -0.10705084f, 0.00112477f, 0.02162519f, 
    0.42641106f, 0.18745145f, -0.12309649f, -0.12070070f, 0.02261508f, 0.21077308f, 0.04072808f, -0.01779444f, 
    -0.07869530f, -0.01341805f, 0.05220789f, -0.12484473f, -0.16400132f, -0.01603467f, 0.00646566f, -0.33224607f, 
    0.04803840f, -0.01593471f, -0.08939355f, -0.14571270f, -0.04219808f, 0.06909040f, -0.01082330f, 0.09847020f, 
    0.60157651f, 0.09265058f, -0.21189992f, 0.09915847f, -0.00419258f, 0.17385712f, 0.00254563f, 0.06927473f, 
    0.04102556f, 0.00989625f, 0.04648996f, -0.06304725f, -0.08230863f, 0.12266203f, -0.18096124f, -0.44391888f, 
    0.07166820f, 0.07523292f, -0.06435888f, -0.05437384f, -0.06452850f, 0.11783294f, 0.01103747f, -0.11796696f, 
    0.31853032f, -0.20099708f, -0.23731479f, -0.07171623f, 0.08510556f, -0.08171874f, -0.02042348f, 0.03928330f, 
    -0.01810294f, 0.08109836f, 0.05133735f, -0.10016902f, 0.17764476f, -0.26019523f, -0.05412606f, 0.42279321f, 
    0.21711545f, -0.05109973f, 0.01572610f, 0.14356008f, 0.00226758f, 0.23923130f, 0.10565874f, 0.08082753f, 
    0.27011091f, 0.06910445f, -0.20625420f, 0.10588552f, 0.01624105f, 0.07792152f, 0.07125163f, -0.00968456f, 
    -0.00895651f, 0.03504127f, 0.13570616f, 0.14460309f, -0.31890398f, 0.14651076f, -0.20235516f, 0.00597520f, 
    -0.03789186f, 0.03431433f, 0.10525062f, 0.03882053f, -0.02670178f, 0.11700736f, 0.00877328f, -0.01291510f, 
    0.13133961f, -0.38384819f, -0.03311123f, 0.16831991f, 0.01077834f, -0.10046030f, 0.07208783f, -0.03976127f, 
    0.04748027f, -0.02405659f, 0.01272904f, -0.04738938f, 0.01479523f, -0.22154470f, 0.24645029f, 0.11265896f, 
    0.03907839f, 0.00925380f, -0.05424714f, -0.02957338f, -0.04722460f, 0.15498842f, 0.00562977f, 0.16622929f, 
    -0.07485285f, -0.07961249f, 0.01378553f, -0.04300221f, 0.15189801f, 0.02518409f, 0.07311412f, -0.14491285f, 
    -0.03755418f, -0.10950850f, -0.03103854f, -0.08114317f, 0.28955656f, 0.29036498f, 0.02164036f, -0.04673870f, 
    0.10963129f, 0.12815639f, 0.08725048f, -0.03329050f, 0.12645149f, 0.04659816f, 0.00722391f, -0.05710052f, 
    0.34806105f, 0.01312580f, 0.13571905f, 0.03854359f, -0.08907337f, 0.04778686f, 0.15116026f, 0.00956082f, 
    0.10556457f, -0.20014665f, 0.01949694f, 0.05173656f, 0.28567544f, -0.08768744f, -0.10081331f, -0.07808018f, 
    -0.03727131f, -0.01301814f, 0.09372132f, -0.00596294f, -0.04900225f, 0.09299701f, -0.15737270f, -0.04344615f, 
    0.13325903f, 0.04264421f, -0.02982881f, -0.02320301f, -0.13473195f, 0.13466160f, 0.02550767f, -0.02902902f, 
    0.20084019f, 0.12604032f, -0.11442783f, -0.10697709f, 0.28307715f, -0.39326009f, 0.01636227f, 0.03080950f, 
    -0.01330118f, 0.03488994f, -0.05811488f, 0.05352258f, 0.08862072f, -0.03740456f, 0.14468139f, 0.04472484f, 
    0.03743367f, 0.26066005f, 0.21722004f, -0.11385397f, -0.16389373f, -0.13447689f, 0.07598139f, -0.08315636f, 
    -0.17862697f, 0.09925003f, 0.13584878f, 0.06727424f, 0.37833905f, -0.19199467f, -0.04241179f, 0.17112409f, 
    0.24442378f, 0.10211764f, -0.03959595f, -0.11688263f, 0.12360051f, -0.03787109f, 0.06774347f, 0.00363681f, 
    0.16986729f, 0.32882428f, -0.10650551f, 0.05736934f, 0.15498555f, -0.01560010f, 0.05692290f, 0.09737729f, 
    0.03343122f, -0.04057710f, -0.00268481f, 0.06127049f, -0.15655451f, -0.17524001f, -0.22653963f, 0.05249245f, 
    0.19924343f, 0.12188101f, -0.15237296f, 0.00105734f, -0.10867207f, -0.05225243f, 0.06187353f, 0.08984645f, 
    -0.15552759f, 0.26894793f, -0.13400334f, 0.21494794f, -0.02194315f, 0.20102081f, -0.00161784f, -0.02028616f, 
    0.04360737f, 0.00515639f, 0.15818785f, 0.12880157f, 0.11139984f, 0.27187869f, -0.14940670f, -0.14786281f, 
    0.09044582f, 0.01627703f, 0.03249546f, -0.03217079f, 0.02822635f, -0.08744993f, -0.04582001f, 0.11227430f, 
    -0.53187436f, -0.14685035f, 0.22544317f, 0.00609924f, 0.04568018f, 0.01269579f, -0.10554872f, 0.00603453f, 
    -0.02099424f, 0.00295400f, 0.10788707f, 0.00202946f, 0.09887769f, 0.23944655f, 0.02333732f, 0.06520433f, 
    0.07568544f, -0.01922469f, 0.11693516f, -0.08236857f, 0.00475164f, -0.06046333f, 0.03274898f, -0.05156597f, 
    -0.14986283f, 0.40904093f, -0.20613025f, -0.07274964f, 0.01319882f, 0.15731592f, 0.08336332f, 0.06036456f, 
    0.07851470f, 0.03037955f, 0.04779940f, 0.13418734f, -0.37550658f, 0.24940361f, -0.04817379f, -0.07963020f, 
    -0.08067983f, -0.12816773f, 0.05942204f, 0.07281865f, 0.17233251f, 0.01887726f, -0.04880385f, -0.07361059f, 
    0.25861776f, -0.08370835f, -0.06646250f, 0.12326173f, -0.10317773f, 0.06053771f, -0.02210738f, -0.11496675f, 
    0.01079249f, 0.03836345f, 0.03344389f, 0.05891795f, -0.12817654f, 0.02760130f, -0.03683324f, 0.23792155f, 
    0.02785025f, -0.01387129f, 0.06844487f, 0.14348938f, -0.02756210f, 0.05412239f, 0.08239663f, -0.11812121f, 
    -0.10127200f, 0.23114644f, -0.16208154f, -0.10020131f, -0.04216936f, -0.00147921f, 0.14755280f, 0.13379051f, 
    -0.07572397f, 0.17052582f, 0.04937406f, -0.00781088f, -0.30684865f, -0.01568410f, 0.05778214f, 0.08347426f, 
    -0.09548391f, 0.05895462f, -0.15133175f, -0.04407868f, 0.09127294f, 0.03192751f, 0.09128457f, 0.08283731f, 
    0.02807584f, 0.04902532f, -0.14380637f, 0.08826456f, 0.09315460f, 0.13165088f, 0.15394226f, -0.00144489f, 
    -0.03638956f, 0.00621228f, -0.00997424f, 0.17188393f, -0.27914593f, 0.31030700f, -0.01715120f, -0.19661722f, 
    -0.00507498f, -0.05795027f, -0.03236863f, -0.01032784f, -0.02812950f, -0.07385036f, 0.06455322f, 0.03729904f, 
    0.13263066f, -0.08265733f, 0.07161827f, 0.17245908f, 0.12604901f, 0.00867016f, 0.03276992f, 0.18653952f, 
    -0.04724545f, 0.00082219f, -0.10831251f, 0.07535966f, -0.56418067f, 0.10657957f, -0.05242602f, -0.01823795f, 
    -0.03894219f, 0.11358666f, -0.03403484f, 0.05922335f, -0.05017573f, -0.04735694f, 0.05362998f, 0.05714744f, 
    -0.30408931f, -0.21560897f, 0.10950407f, -0.00701188f, 0.07595685f, -0.02071875f, 0.01498270f, 0.05281116f, 
    0.03236942f, 0.02180181f, 0.01741284f, 0.12198029f, 0.08283331f, -0.06013215f, 0.25917363f, 0.10607492f, 
    -0.01461282f, -0.02555430f, 0.20270683f, 0.08036732f, 0.04493733f, 0.03073728f, 0.04945593f, -0.00223105f, 
    0.36071676f, 0.04939182f, -0.23886438f, 0.09235830f, 0.00077720f, 0.10641792f, -0.00986233f, 0.12796746f, 
    0.00945673f, 0.06447275f, -0.05128507f, 0.18394515f, 0.56057310f, 0.06438994f, -0.01179880f, 0.30868527f, 
    0.18102737f, -0.03386381f, -0.00049909f, 0.13192931f, 0.06509640f, -0.05456179f, -0.18640599f, -0.15439530f, 
    -0.04933912f, -0.01802401f, -0.30628195f, 0.06157650f, -0.02094611f, -0.04858526f, 0.15491547f, 0.11284982f, 
    -0.03784764f, -0.05663180f, -0.19661041f, -0.23397055f, 0.17748043f, 0.42420903f, 0.22777928f, 0.07735611f, 
    -0.00419241f, 0.09345213f, -0.00720108f, 0.14643236f, -0.07381717f, -0.03591487f, 0.09632458f, 0.03129151f, 
    -0.19887617f, 0.12068520f, -0.15137254f, 0.01294665f, -0.11212031f, -0.07666868f, -0.03106215f, -0.07391934f, 
    -0.11816978f, 0.18966097f, -0.01102780f, 0.05582546f, 0.11557847f, -0.21698141f, 0.22206762f, 0.02246191f, 
    0.01806653f, -0.02901824f, -0.06634036f, -0.07811869f, -0.00135316f, -0.06813196f, 0.05386535f, -0.15490893f, 
    0.11889188f, 0.09853705f, 0.05626737f, 0.03862319f, -0.03477797f, -0.20745522f, 0.16188544f, 0.05286168f, 
    0.04288675f, 0.05490878f, 0.19548836f, -0.02421629f, 0.04319072f, 0.44337818f, 0.12821876f, 0.24756168f, 
    -0.13168068f, -0.06425857f, -0.15399389f, 0.06692587f, -0.03443071f, 0.22595030f, 0.00067120f, 0.05936075f, 
    0.30285421f, 0.01193535f, 0.23882611f, -0.07008903f, -0.16743308f, 0.02873517f, 0.20008852f, -0.07248953f, 
    0.00017574f, 0.17038141f, -0.02014353f, 0.22361198f, -0.60673159f, 0.05197287f, 0.01312252f, 0.20294502f, 
    -0.05876589f, 0.06387130f, 0.10547981f, 0.10580026f, 0.01364453f, 0.10720471f, 0.23489259f, 0.06400685f, 
    -0.01051156f, 0.21483682f, 0.02544189f, 0.05964602f, -0.07798772f, 0.07594572f, 0.12533332f, -0.05796744f, 
    0.04887062f, 0.08156782f, 0.00710983f, 0.08327562f, 0.15109172f, -0.14878444f, -0.10438042f, 0.06863102f, 
    -0.09140596f, -0.00951309f, 0.14311904f, 0.00294382f, 0.12293523f, -0.07746721f, 0.08645032f, -0.02026914f, 
    -0.10554357f, 0.10252643f, 0.18903877f, 0.12398881f, -0.12634572f, -0.28425059f, -0.02373257f, 0.11294546f, 
    0.13554926f, 0.02636396f, -0.13947016f, 0.02969945f, -0.14958595f, -0.10787144f, -0.10649977f, 0.03186478f, 
    0.14141701f, 0.11498806f, -0.00982023f, 0.02400597f, -0.04531183f, -0.07437925f, -0.10103769f, -0.15832007f, 
    0.10415532f, 0.05708539f, 0.41696003f, -0.10962521f, -0.01229429f, -0.03307122f, 0.04070216f, -0.09438786f, 
    -0.04393184f, 0.07085733f, 0.02170750f, 0.24877463f, -0.11638059f, -0.29817286f, 0.18368810f, 0.35534582f, 
    0.03486082f, 0.10565473f, 0.03483944f, 0.00020015f, -0.04194020f, 0.03795424f, -0.11639485f, -0.20491052f, 
    -0.08590567f, -0.03390014f, -0.03270392f, -0.05735847f, 0.00834579f, -0.00519024f, -0.05588649f, -0.02564802f, 
    -0.02738200f, 0.04544859f, -0.06654638f, -0.05590187f, -0.00342536f, 0.05140831f, -0.01621134f, -0.00117643f, 
    0.04852398f, 0.00160653f, -0.04692752f, -0.07076269f, 0.00410749f, 0.04612662f, -0.00768809f, -0.00233683f, 
    -0.02205032f, 0.06764288f, -0.01812752f, 0.04237296f, -0.01552802f, 0.05825964f, -0.01336162f, 0.05642396f, 
    -0.06119839f, -0.07013354f, -0.05212771f, -0.00903505f, 0.00655679f, -0.06382778f, 0.04480470f, -0.07467277f, 
    -0.03701867f, 0.05820127f, 0.01284214f, -0.00975541f, -0.02812224f, -0.07245591f, 0.03184298f, 0.04098333f, 
    0.01428873f, -0.01335606f, 0.02554652f, -0.07785278f, 0.02873936f, 0.04963736f, -0.06418616f, -0.04592235f, 
    0.05732740f, 0.02645397f, -0.02149276f, 0.01466738f, -0.02468428f, 0.03967147f, 0.03630590f, 0.06147109f, 
    -0.07636188f, -0.05082540f, -0.07125472f, -0.02076495f, -0.03050548f, -0.04197953f, -0.01763763f, -0.06769411f, 
    0.04196835f, -0.06583877f, -0.06836058f, -0.01122033f, -0.04673696f, 0.05792111f, -0.03679731f, 0.02431407f, 
    0.01529427f, 0.02081216f, -0.00656129f, 0.04223331f, 0.03501864f, 0.01974740f, 0.01316729f, -0.04650498f, 
    -0.01727108f, -0.02973143f, -0.02983083f, -0.02897928f, -0.03220140f, 0.03581887f, -0.06951395f, 0.05331898f, 
    -0.00524444f, 0.02256623f, -0.06698794f, -0.01000971f, -0.00286686f, 0.05480906f, 0.06447271f, -0.02045722f, 
    0.05463951f, -0.07734491f, 0.00127290f, 0.05715126f, 0.02925189f, 0.05328408f, -0.00217993f, 0.00055959f, 
    -0.03406655f, -0.01396454f, 0.03528800f, -0.04406774f, -0.03687707f, 0.04096563f, -0.03523335f, 0.02301987f, 
    -0.01713125f, 0.04262174f, -0.01392421f, 0.01548141f, -0.07392348f, 0.04937079f, -0.07795354f, -0.00570244f, 
    0.05676319f, 0.02331056f, -0.01410831f, -0.05683768f, 0.00769637f, -0.05146112f, -0.02947519f, -0.02039045f, 
    0.04826454f, 0.01641792f, 0.02301802f, -0.03044013f, 0.03293343f, -0.00884659f, -0.05157420f, -0.04209137f, 
    0.03010772f, -0.06250381f, -0.02464328f, 0.06065796f, 0.03009014f, 0.04033696f, -0.03376611f, 0.04635940f, 
    -0.02528519f, -0.05729850f, -0.06042318f, -0.02745849f, 0.05235694f, -0.00432541f, 0.06152748f, 0.01696387f, 
    0.02397184f, 0.06223613f, -0.00540225f, -0.04275984f, 0.01469516f, -0.00962024f, -0.06515169f, -0.03173925f, 
    -0.05034208f, -0.07515462f, -0.03834533f, 0.00536986f, -0.08095516f, 0.03365348f, -0.03789320f, -0.01212139f, 
    -0.01021773f, 0.01387617f, 0.00439535f, -0.01635074f, -0.04890166f, 0.04092762f, -0.04257054f, -0.00928035f, 
    0.02368797f, -0.02497195f, -0.07767475f, -0.07056268f, -0.04802066f, -0.01480151f, -0.01612502f, 0.05789015f, 
    -0.00395377f, 0.16644600f, -0.06196840f, 0.26308826f, -0.06612186f, 0.14962175f, -0.17204681f, 0.06607898f, 
    -0.10692609f, 0.15185162f, -0.09371141f, 0.22361463f, 0.18785027f, -0.02064804f, 0.14347218f, -0.19511437f, 
    0.02098219f, 0.01511814f, -0.02265565f, -0.11262005f, 0.05278424f, -0.14681882f, -0.15386181f, -0.10944758f, 
    -0.05330379f, 0.13220607f, -0.06153503f, 0.22290668f, -0.03152071f, -0.06583868f, 0.09962810f, 0.11808641f, 
    -0.00636009f, -0.19081630f, -0.27342159f, -0.25299805f, 0.86060286f, 0.06574175f, 0.02108146f, -0.02258456f, 
    0.06966894f, 0.19891575f, 0.02642753f, 0.17170952f, -0.14234126f, 0.11408562f, 0.07585970f, 0.17416668f, 
    -0.12920140f, 0.07392020f, -0.01665560f, -0.07564902f, -0.04030416f, -0.08673273f, 0.02596191f, -0.06513762f, 
    -0.17242539f, 0.28220204f, -0.04312748f, -0.01526622f, 0.45163494f, -0.20285933f, -0.06217076f, -0.05097760f, 
    0.18692409f, -0.20884271f, 0.03722999f, 0.02355004f, 0.03178364f, 0.12961484f, 0.11504741f, -0.35724032f, 
    -0.28652024f, 0.15333769f, -0.04144877f, -0.12234987f, -0.19607514f, -0.13127743f, 0.05573026f, 0.29972872f, 
    0.04884538f, 0.08239986f, 0.31934172f, 0.19916902f, -0.06882458f, 0.09163883f, 0.03706855f, -0.16476089f, 
    -0.04958033f, -0.10084555f, -0.19481695f, 0.03750201f, -0.18524709f, 0.18491866f, 0.03708437f, 0.05335921f, 
    0.01592091f, 0.08388460f, 0.20733735f, -0.02069087f, 0.01715154f, 0.04857592f, 0.19042848f, -0.01691377f, 
    -0.01084570f, 0.21996482f, 0.06931628f, 0.25861627f, -0.57206333f, -0.10379896f, -0.27444121f, 0.05690773f, 
    0.10861729f, 0.10898498f, 0.05867016f, 0.20106944f, 0.11655072f, -0.03641989f, 0.18301946f, 0.19901229f, 
    0.04127993f, 0.24077784f, -0.17993608f, 0.07941319f, 0.04311024f, -0.01728035f, 0.07862246f, 0.03251698f, 
    -0.07001356f, -0.03374477f, 0.07391750f, -0.00984426f, 0.20605101f, 0.24779852f, 0.13851760f, -0.16165790f, 
    -0.04744157f, -0.24825025f, 0.02074339f, -0.11250751f, -0.08386077f, 0.06048241f, 0.17646995f, 0.08874723f, 
    -0.04345502f, 0.01306632f, -0.08229630f, 0.21092270f, 0.02225086f, 0.07502548f, -0.01096830f, 0.01646357f, 
    0.16384400f, -0.08267162f, -0.30904788f, -0.09152621f, -0.10651809f, 0.16715388f, -0.07753280f, -0.34318909f, 
    -0.01335777f, -0.02558429f, -0.34838936f, -0.09269530f, -0.03504484f, -0.03889525f, -0.15465882f, -0.14616217f, 
    0.26139691f, -0.13282943f, 0.19439216f, -0.11125547f, -0.00839680f, 0.08229719f, 0.05691369f, 0.08223025f, 
    -0.04308931f, 0.10264750f, -0.04675736f, 0.22222427f, 0.25229108f, 0.28183746f, 0.34345233f, -0.08249583f, 
    0.04618949f, -0.02800933f, 0.05125207f, -0.04518936f, 0.05956711f, -0.06349830f, -0.18518089f, -0.23759966f, 
    0.10563271f, -0.18318313f, -0.22756419f, -0.02619718f, 0.23392849f, -0.03951594f, 0.03057606f, -0.15043543f, 
    0.10754453f, 0.04167870f, 0.15856081f, 0.04573669f, 0.32104561f, -0.03936013f, -0.14618219f, 0.38042748f, 
    0.20785835f, -0.01796578f, 0.00308160f, 0.13256678f, 0.07097805f, 0.17912394f, -0.01765360f, 0.09417549f, 
    0.05344104f, -0.01654379f, -0.23310712f, 0.17893790f, 0.09415222f, 0.06297107f, -0.01668321f, -0.09714958f, 
    0.08914311f, 0.04500899f, 0.11569130f, 0.24582201f, -0.46559802f, 0.08850555f, -0.34638560f, 0.16117287f, 
    -0.29525107f, 0.10526509f, 0.13926746f, 0.04994129f, -0.08538426f, 0.07479765f, -0.01187302f, -0.11208326f, 
    -0.02999010f, -0.27308911f, -0.20234987f, 0.20779984f, -0.05165228f, -0.12180938f, 0.17813234f, 0.03523623f, 
    0.18037802f, -0.11402865f, 0.06955070f, 0.10411031f, 0.00985807f, -0.19856247f, 0.15735646f, -0.00556643f, 
    0.06133229f, -0.07764484f, -0.04472720f, 0.02806635f, 0.00674159f, 0.09709160f, 0.07019321f, 0.08269829f, 
    -0.16486320f, -0.11463927f, -0.08278711f, 0.06192563f, 0.25753489f, -0.11461646f, 0.09362464f, -0.16848728f, 
    -0.14672914f, -0.02406423f, -0.01188960f, 0.08792144f, 0.25513896f, 0.38700837f, 0.04744159f, 0.18320657f, 
    0.05586749f, 0.06263627f, 0.01851088f, -0.01866426f, 0.17159346f, 0.01832163f, 0.09110361f, -0.01661329f, 
    0.36207533f, 0.04268837f, 0.23520364f, -0.16714419f, -0.20740943f, 0.07107154f, 0.27070391f, 0.10997357f, 
    0.15074940f, -0.17090365f, 0.13077813f, 0.07035282f, -0.18956578f, -0.04117474f, 0.01728267f, 0.07915377f, 
    0.03287788f, 0.02524270f, 0.04770326f, -0.07788057f, 0.00065914f, 0.11680883f, -0.06312244f, 0.04525727f, 
    -0.16339830f, 0.02780743f, 0.07711323f, 0.21405482f, -0.03267631f, 0.14630461f, -0.03141621f, -0.11240118f, 
    0.09307382f, 0.07963509f, -0.04395033f, -0.08975632f, 0.19137061f, -0.29558277f, 0.09969802f, -0.04260850f, 
    0.00805986f, -0.00294198f, -0.11893439f, 0.24122870f, 0.11642317f, -0.12254532f, 0.14098148f, 0.12353650f, 
    0.05452697f, 0.22798005f, 0.13464218f, -0.20731221f, -0.10127369f, -0.15602490f, -0.00516001f, 0.03305694f, 
    -0.01139691f, 0.05281244f, 0.13187909f, -0.07016353f, 0.09487677f, -0.23037811f, 0.07286526f, 0.09959847f, 
    0.18985191f, 0.11259298f, 0.01802386f, -0.13267954f, 0.11353599f, 0.01363423f, 0.12670457f, 0.03490962f, 
    0.04476051f, 0.22871973f, -0.04639268f, 0.13823764f, 0.06675217f, 0.03111356f, 0.15592891f, 0.14056228f, 
    0.02510782f, -0.04236406f, 0.12549993f, 0.06351254f, -0.22069088f, -0.10886618f, -0.02908955f, -0.05153559f, 
    0.01508963f, 0.03609905f, -0.15762378f, 0.06143171f, -0.04123554f, -0.06015890f, 0.04231099f, 0.07197112f, 
    -0.49060795f, 0.16632077f, 0.15538684f, -0.08801442f, -0.00955911f, 0.03550819f, 0.18329228f, -0.06868909f, 
    0.06862767f, 0.14039838f, 0.21283032f, 0.02546144f, -0.21831529f, 0.34705919f, 0.02013196f, -0.31761524f, 
    0.03340089f, 0.08066240f, -0.04349262f, -0.06754123f, -0.01888247f, -0.03257309f, 0.14272684f, 0.13316455f, 
    -0.60774279f, -0.12400293f, 0.29556790f, -0.09653663f, 0.11722956f, 0.02531472f, 0.02616004f, 0.09890177f, 
    0.09913494f, 0.05774624f, -0.03016413f, 0.09449020f, 0.27610472f, 0.05803713f, -0.05892990f, -0.13928764f, 
    0.00854219f, -0.11653497f, 0.08978201f, 0.04578420f, 0.06405466f, 0.03466294f, 0.04340491f, -0.03065388f, 
    -0.19895098f, 0.17251097f, 0.08179525f, -0.14164309f, 0.04380069f, 0.07105356f, 0.17655443f, 0.04588694f, 
    0.09747915f, 0.11730003f, 0.01422518f, 0.18204080f, 0.09168612f, 0.21597317f, -0.08151942f, -0.03255683f, 
    -0.01578070f, -0.04575169f, -0.06898060f, 0.11778760f, 0.13591184f, -0.05186853f, -0.08318558f, 0.02589506f, 
    0.10348473f, -0.11394494f, -0.10818080f, 0.03890505f, -0.04281808f, 0.12942640f, 0.00625634f, -0.02869582f, 
    -0.08464101f, -0.00715386f, -0.04713801f, 0.07871856f, -0.08597780f, -0.22503684f, -0.01372353f, 0.25121441f, 
    -0.03463949f, 0.01233770f, 0.09446697f, 0.10297902f, 0.14075477f, -0.11244115f, 0.05009146f, 0.03660386f, 
    0.02542902f, 0.10944859f, -0.10771617f, -0.03020573f, -0.05920928f, -0.05056768f, -0.04765448f, 0.16285560f, 
    -0.02247729f, 0.03844833f, -0.01512824f, -0.08650418f, 0.18344052f, 0.10354940f, 0.06902929f, 0.10082152f, 
    -0.00981630f, 0.01708843f, 0.12215401f, 0.05373116f, -0.09448449f, -0.03663478f, 0.13142347f, 0.00834489f, 
    -0.20596674f, -0.07365425f, 0.04847663f, 0.16211960f, 0.06827312f, 0.06486715f, 0.06638627f, 0.06066401f, 
    0.00177188f, -0.05994233f, 0.11194312f, 0.00890830f, -0.50738889f, 0.16945753f, -0.06809781f, 0.02103639f, 
    0.20782645f, 0.07528551f, -0.01978919f, -0.07285851f, -0.06338538f, 0.00554907f, 0.09883101f, 0.12466326f, 
    0.25550595f, -0.09938931f, -0.19846806f, 0.07917918f, 0.10082628f, 0.03664684f, 0.01649247f, 0.06271087f, 
    -0.04627625f, -0.05065521f, -0.12812209f, 0.03463657f, -0.47280666f, 0.10674243f, -0.02545407f, -0.00933494f, 
    0.10565569f, 0.10769386f, 0.06424521f, 0.09117147f, -0.12454588f, -0.00511052f, 0.09219762f, 0.10254003f, 
    0.44766882f, -0.03970895f, 0.01141330f, -0.02701929f, 0.01465082f, 0.08238315f, -0.06864949f, 0.00701557f, 
    0.01110887f, -0.00258363f, -0.01788383f, -0.08628377f, -0.11407047f, 0.24158597f, 0.10079218f, 0.07774342f, 
    0.09445925f, 0.06029083f, 0.02747585f, -0.00491594f, 0.05593887f, 0.15443687f, 0.01770150f, 0.06438757f, 
    -0.03310395f, 0.26277432f, 0.10179735f, 0.09565213f, -0.11633515f, -0.07360584f, -0.01481908f, 0.10663310f, 
    0.09392223f, 0.06352878f, 0.05376815f, -0.08738154f, -0.35355556f, 0.03177246f, 0.03091893f, -0.11212130f, 
    -0.02084881f, 0.01679802f, 0.10138109f, -0.07926633f, 0.08459972f, 0.20734730f, 0.10532993f, 0.04862526f, 
    -0.02146690f, 0.30360773f, -0.22326834f, 0.19543511f, 0.07880960f, 0.00098340f, -0.07431416f, -0.03529337f, 
    -0.05691947f, -0.13604943f, 0.11167717f, 0.27950999f, 0.15906632f, -0.22728345f, 0.06451239f, 0.03970344f, 
    0.01379976f, 0.05301667f, -0.08295819f, -0.00751776f, 0.16370264f, -0.04995396f, 0.04963640f, -0.00561782f, 
    0.07678338f, 0.04160081f, 0.23590565f, -0.08700993f, 0.03218534f, 0.11968987f, 0.02512852f, -0.00574740f, 
    0.21674185f, -0.09688222f, -0.02378411f, 0.14008698f, -0.02573403f, -0.25621527f, 0.19273241f, 0.08975575f, 
    -0.02454139f, -0.00159588f, 0.02405239f, -0.13034521f, 0.00129483f, 0.18242098f, 0.00369300f, 0.19274098f, 
    -0.30690709f, 0.04922728f, 0.18373404f, -0.09331504f, 0.06460755f, 0.26051396f, -0.06667256f, -0.29593107f, 
    -0.11311065f, -0.19377974f, -0.04779103f, -0.11259580f, 0.07513618f, -0.02716813f, 0.08310493f, -0.22259884f, 
    0.04703250f, 0.23677844f, 0.06897727f, 0.01173769f, -0.00457484f, -0.28184313f, 0.03073577f, -0.07627805f, 
    -0.07073531f, 0.07756162f, 0.07661733f, -0.06609555f, -0.01310222f, -0.02244616f, -0.16629890f, 0.08282080f, 
    0.13717367f, -0.05688962f, -0.07517292f, -0.19335292f, 0.73972833f, 0.05992120f, -0.17739467f, -0.18749575f, 
    -0.06731699f, -0.08784184f, -0.02933250f, -0.21122536f, -0.06202731f, 0.04934930f, -0.18920077f, 0.13400099f, 
    -0.09728687f, 0.09910233f, -0.00314949f, -0.00571224f, 0.09803538f, 0.09589745f, 0.01445391f, -0.14859985f, 
    0.24808122f, -0.12452511f, -0.06366715f, -0.11312736f, -0.21113233f, -0.07529522f, 0.13513750f, 0.14802872f, 
    0.11061475f, -0.04849715f, -0.11108772f, 0.00895008f, 0.08836938f, -0.03367425f, -0.00860758f, -0.09351490f, 
    -0.20395730f, -0.11301240f, 0.06759825f, -0.13180152f, 0.06787390f, 0.18011972f, -0.00445448f, -0.14880189f, 
    -0.02643872f, 0.14496991f, 0.36766011f, 0.06856087f, 0.30293375f, -0.06372526f, 0.08326204f, 0.11542337f, 
    0.11069725f, -0.08860296f, 0.16143610f, 0.04959251f, -0.03759054f, -0.04351284f, 0.11901351f, 0.05819480f, 
    0.59723729f, 0.08539528f, -0.12416667f, -0.16094874f, 0.04659769f, -0.05515970f, 0.05782082f, 0.09683403f, 
    0.11372432f, -0.08789700f, 0.06763238f, -0.04421815f, -0.04887274f, 0.07910299f, -0.32986209f, -0.03136468f, 
    -0.08826820f, 0.01984863f, 0.00302349f, -0.10392103f, -0.06780045f, -0.04440050f, 0.17063117f, 0.25572756f, 
    0.17119700f, -0.16243450f, 0.20283580f, -0.17238216f, -0.10269061f, 0.05817850f, -0.02106076f, 0.08315690f, 
    -0.13912411f, 0.01695647f, -0.00478303f, -0.11742239f, -0.37167782f, -0.06107562f, 0.16643587f, -0.18745215f, 
    -0.18182111f, 0.05475075f, -0.03858936f, 0.03304928f, 0.10258377f, 0.03298540f, -0.02251072f, -0.10561331f, 
    0.34381384f, 0.27161440f, 0.07159917f, -0.12611847f, 0.00610114f, 0.03414902f, 0.03784614f, -0.08590304f, 
    -0.05419815f, -0.01337317f, -0.10135309f, -0.03335403f, 0.42560393f, -0.20990163f, 0.13696314f, -0.07612434f, 
    0.00164093f, 0.04086749f, -0.02284420f, -0.01486392f, -0.05689880f, 0.02334805f, -0.04031999f, 0.03916415f, 
    0.24201752f, -0.10045206f, 0.22605345f, -0.30213609f, 0.01545286f, 0.02173574f, -0.19402260f, 0.05556155f, 
    -0.14882576f, 0.07985806f, -0.03154247f, -0.09557787f, 0.20576425f, -0.00028487f, -0.24032436f, -0.04876365f, 
    0.04867616f, -0.03040232f, 0.04604587f, 0.00456839f, -0.12430200f, -0.00134379f, 0.01283066f, -0.07951452f, 
    0.10779122f, 0.13650061f, 0.17964084f, 0.11638084f, 0.00222904f, -0.11246857f, 0.04494682f, 0.35955474f, 
    0.12884618f, 0.13307714f, 0.20081146f, 0.02597785f, -0.17254046f, -0.09886573f, 0.13067655f, -0.07465810f, 
    -0.04765401f, 0.13856557f, -0.00862962f, 0.06796703f, -0.15446484f, 0.03957921f, -0.05295575f, 0.20929515f, 
    -0.08313101f, -0.04407773f, 0.04378142f, 0.07760611f, 0.11389908f, 0.04626606f, -0.09238596f, 0.04566581f, 
    -0.02765432f, -0.04048593f, -0.11302733f, 0.02614148f, 0.45961359f, 0.12708372f, 0.09030609f, 0.08604157f, 
    0.13002262f, -0.06801328f, 0.01158055f, 0.04825358f, 0.08510555f, -0.04678230f, 0.09069905f, 0.08715161f, 
    -0.12250603f, 0.01026442f, 0.12788384f, -0.27103975f, 0.03405591f, 0.06944019f, -0.01549115f, 0.12040742f, 
    0.02017284f, 0.05671536f, 0.18151374f, 0.03723523f, 0.27164987f, 0.27901694f, 0.20737943f, 0.46192780f, 
    -0.08618300f, -0.02214690f, 0.07778357f, 0.09222087f, 0.06206851f, 0.14377014f, -0.10098743f, -0.07689755f, 
    -0.34024858f, -0.07332443f, 0.00156206f, -0.13239133f, 0.02728010f, -0.04897457f, 0.18104869f, -0.01289142f, 
    0.17953826f, -0.07270057f, -0.04682915f, 0.03194230f, 0.41688594f, 0.18191408f, 0.21564974f, 0.23247147f, 
    -0.07903005f, -0.11418465f, -0.03204441f, -0.01213773f, -0.03036941f, 0.10960519f, -0.14960383f, -0.07399869f, 
    0.05380899f, 0.01674277f, -0.02388515f, 0.12963384f, -0.12297019f, 0.04299954f, 0.05334382f, 0.12280735f, 
    -0.02115310f, 0.06304263f, 0.00343473f, 0.01806437f, -0.07184407f, 0.19305545f, 0.08429825f, 0.02364800f, 
    -0.01781194f, 0.09064475f, 0.04300738f, -0.03495382f, 0.10659011f, 0.08224008f, -0.01946115f, -0.09460145f, 
    0.06044765f, 0.17338042f, -0.11632073f, 0.04713720f, 0.14166100f, 0.07472837f, 0.03426060f, -0.01181616f, 
    0.04992379f, 0.03741862f, 0.13942660f, -0.00659553f, 0.33686522f, 0.14207575f, -0.15161259f, 0.08469336f, 
    0.14457953f, 0.01997004f, -0.05006561f, 0.10052248f, 0.01538088f, -0.07517965f, 0.01217746f, 0.04716284f, 
    -0.06218903f, -0.28541878f, 0.21104325f, -0.07290351f, 0.10896879f, 0.00510060f, -0.05572933f, -0.00199279f, 
    0.05853682f, 0.11547137f, 0.10148652f, -0.06455448f, -0.31932673f, 0.24597298f, -0.09686870f, 0.15244609f, 
    0.11890238f, -0.02519763f, 0.13887516f, -0.04955035f, -0.08926324f, -0.02643452f, 0.01884601f, 0.03342510f, 
    -0.17872974f, 0.11288736f, -0.19096267f, 0.19739349f, -0.03946136f, -0.06937551f, -0.05559973f, 0.08241776f, 
    0.03701719f, 0.02969356f, -0.00594112f, 0.09520825f, -0.31431544f, 0.31743246f, 0.01971746f, -0.21382363f, 
    0.01008599f, -0.06080190f, -0.11399638f, 0.08583333f, 0.07053374f, -0.04413392f, -0.00676479f, 0.00817280f, 
    0.41882956f, -0.06777381f, -0.15524139f, 0.04257254f, -0.05958201f, 0.04142546f, 0.04537315f, -0.12200125f, 
    0.02832247f, -0.05382127f, -0.03538864f, 0.13653506f, 0.05336206f, 0.06181863f, 0.09738939f, 0.39957914f, 
    0.04547632f, -0.04993168f, -0.02149891f, 0.06407059f, 0.02365466f, 0.13638845f, 0.06559888f, -0.06551034f, 
    -0.09042412f, 0.15884545f, 0.00119026f, -0.02634461f, -0.01363209f, -0.01680581f, 0.18995099f, 0.18964423f, 
    -0.08251631f, 0.12816466f, 0.15998739f, 0.03572611f, -0.47841698f, -0.11319973f, 0.15083791f, 0.10474671f, 
    -0.06955492f, 0.10828222f, -0.06050807f, -0.00007028f, 0.09257153f, 0.07985076f, 0.12733093f, -0.02978577f, 
    0.14932728f, 0.03320617f, 0.00797065f, 0.26772425f, 0.01032753f, 0.07683898f, 0.09534202f, 0.14836849f, 
    0.00375647f, 0.02312828f, 0.00679939f, 0.04106941f, -0.10268738f, 0.09010149f, -0.17998648f, -0.23547429f, 
    0.00237565f, 0.02974859f, 0.04402562f, 0.00200657f, -0.02594403f, -0.00367309f, 0.13566156f, -0.02237876f, 
    0.25572875f, -0.01343247f, 0.12637773f, 0.29923606f, 0.06721199f, -0.08808041f, 0.01737448f, 0.09266471f, 
    0.01837153f, 0.09234598f, -0.05342464f, 0.05384022f, -0.34686887f, -0.04101443f, -0.02823273f, -0.07867564f, 
    0.09237055f, 0.09904364f, -0.05982885f, -0.02196064f, 0.01196261f, -0.15210937f, -0.02416641f, 0.05796668f, 
    -0.44042248f, -0.10072493f, 0.21799804f, 0.01479589f, 0.13087480f, -0.07656258f, -0.04252141f, -0.08641074f, 
    -0.04551629f, 0.06276103f, -0.00563864f, 0.15394096f, -0.03383452f, -0.18169132f, 0.25615007f, 0.13802324f, 
    0.05852170f, 0.00116235f, 0.01588067f, 0.12565427f, -0.02882129f, -0.07278132f, -0.01071052f, 0.06356265f, 
    0.07933804f, 0.30726936f, 0.15936898f, -0.00387627f, 0.09189723f, 0.09587449f, 0.14133774f, -0.04912254f, 
    0.07122576f, 0.03822435f, -0.10668907f, -0.05414113f, -0.02747699f, 0.02807000f, 0.20551331f, -0.11979432f, 
    0.02768376f, 0.02732947f, 0.05800198f, 0.03329200f, -0.00023406f, -0.04780994f, -0.08282327f, 0.03283931f, 
    -0.12468927f, 0.12736642f, 0.17300214f, -0.15757024f, 0.05412865f, 0.14766820f, -0.04212481f, -0.05414368f, 
    0.00234937f, 0.02803744f, 0.04468979f, -0.00750720f, -0.38133967f, -0.03757140f, 0.22853662f, -0.05749684f, 
    0.16858864f, 0.08922978f, -0.01674270f, 0.01756564f, 0.00029881f, -0.00954929f, -0.22409901f, -0.02269082f, 
    0.08967954f, 0.19404750f, 0.24997452f, 0.03391961f, 0.03784278f, -0.00833771f, 0.01611440f, 0.10793315f, 
    0.14641879f, -0.00897853f, -0.05871578f, 0.01417356f, -0.54903394f, 0.38131252f, 0.10233986f, -0.03058366f, 
    -0.06080543f, 0.11940991f, 0.01345805f, -0.18295710f, 0.06871954f, -0.13009052f, -0.09594555f, -0.07524484f, 
    0.24231139f, 0.14130232f, 0.04715922f, -0.07220158f, -0.01813570f, 0.15578841f, 0.18672976f, -0.06626274f, 
    0.14331454f, 0.03207652f, 0.01706109f, -0.03061134f, -0.28916985f, -0.12616490f, -0.16078985f, 0.17168291f, 
    0.05249185f, 0.00105909f, 0.02841637f, 0.14587392f, -0.00904966f, -0.03751820f, 0.00528906f, -0.04125362f, 
    -0.47381380f, 0.18482462f, -0.05414115f, -0.21386297f, 0.10677898f, 0.04609626f, 0.01853929f, 0.16247950f, 
    -0.07213963f, 0.16871199f, 0.13961713f, -0.02025368f, 0.04329649f, -0.05616058f, -0.11176349f, -0.34907731f, 
    -0.02341322f, -0.07883736f, -0.12422815f, -0.01128162f, -0.00449153f, -0.03107967f, 0.10411362f, 0.02789509f, 
    0.17213051f, -0.28512707f, -0.04560224f, 0.03222473f, 0.03847521f, -0.04454001f, 0.18637612f, 0.08643872f, 
    0.04014004f, -0.05637195f, 0.00668873f, 0.09371813f, -0.04616581f, 0.11306611f, 0.04125362f, 0.32146770f, 
    0.03733671f, 0.13873379f, -0.16342182f, -0.18458635f, 0.00620007f, -0.03717092f, 0.07788615f, 0.09784659f, 
    -0.17478926f, -0.29386485f, 0.03699704f, 0.28489643f, 0.07939171f, -0.07032552f, -0.01186486f, -0.01556328f, 
    0.04929277f, 0.14121363f, 0.14998220f, 0.14625226f, -0.26189375f, -0.05909139f, -0.02971450f, -0.09734809f, 
    -0.12211993f, -0.01162179f, 0.10105171f, -0.07550572f, -0.07523166f, -0.20147489f, -0.06251705f, -0.05095860f, 
    -0.33911571f, -0.14656332f, 0.23948507f, -0.20845835f, 0.17231899f, -0.01093652f, -0.08147334f, 0.03890918f, 
    0.06823447f, 0.02940970f, 0.09527759f, -0.00946648f, 0.16151960f, 0.07919941f, 0.20878825f, 0.19918165f, 
    -0.04504720f, -0.00904897f, 0.03307557f, -0.10371154f, 0.01139872f, -0.09015832f, 0.01914386f, 0.17195447f, 
    -0.14777850f, 0.02344278f, 0.22609045f, 0.25500420f, 0.19010146f, 0.10137236f, -0.16818047f, 0.00735282f, 
    0.02949234f, 0.07767350f, 0.04607816f, 0.12835017f, -0.09104969f, -0.12727305f, 0.10317796f, 0.13279854f, 
    -0.07889927f, 0.07870267f, 0.08123552f, 0.04793959f, -0.14059645f, -0.05700003f, 0.02727357f, -0.01635413f, 
    0.37175611f, -0.01410104f, 0.14276922f, 0.23328516f, -0.04989972f, 0.05536429f, 0.10894483f, 0.00670994f, 
    0.02430043f, -0.02362346f, 0.01786988f, 0.08082384f, -0.17510344f, -0.54735923f, -0.25000447f, 0.02563391f, 
    -0.00264663f, 0.06273811f, 0.00707418f, 0.03782913f, -0.03557786f, 0.06146741f, 0.12592112f, 0.01672304f, 
    0.20136112f, 0.04129402f, -0.05936795f, 0.05929078f, 0.19057259f, 0.05568074f, 0.00238728f, 0.12736411f, 
    -0.11734838f, 0.14106110f, -0.06343967f, -0.03435352f, 0.38532364f, 0.24748065f, -0.01652156f, 0.05367673f, 
    0.12955631f, 0.07296634f, 0.02868637f, -0.06697150f, 0.05820595f, -0.02119582f, 0.04467039f, -0.01695760f, 
    -0.26018655f, 0.05512938f, 0.01229591f, 0.09022510f, 0.00537482f, 0.01538267f, 0.08585770f, 0.13334793f, 
    0.19825205f, 0.11655732f, 0.05078561f, 0.17487863f, -0.08735310f, -0.37236515f, -0.24282131f, -0.10579957f, 
    0.06632362f, 0.07850181f, 0.03134449f, -0.07690816f, -0.10811959f, 0.14648928f, 0.14929561f, 0.19108456f, 
    -0.29802212f, 0.03008257f, 0.09338988f, 0.09971525f, 0.12905812f, 0.03122463f, 0.01345018f, -0.02824077f, 
    0.17640795f, 0.07050624f, 0.10969728f, 0.01228734f, -0.39399213f, -0.16638757f, 0.09197136f, 0.01813408f, 
    0.01868234f, -0.09757470f, 0.03312001f, 0.03787007f, 0.04202096f, -0.08405019f, -0.07497916f, 0.08110366f, 
    0.03877502f, -0.11226381f, -0.17236443f, 0.13033172f, 0.17295228f, -0.04509880f, 0.02140894f, 0.01157888f, 
    0.04929504f, -0.05439065f, 0.08784312f, 0.08282395f, 0.07334703f, 0.11627171f, 0.02226722f, -0.47601479f, 
    -0.03017780f, 0.02220669f, 0.10506053f, 0.13692431f, -0.05492710f, -0.04881181f, -0.01431444f, 0.13903850f, 
    0.34836626f, -0.05245145f, -0.26786041f, 0.01033775f, -0.00015331f, 0.21782960f, 0.02913818f, 0.04407461f, 
    -0.06037780f, -0.15796901f, -0.03180077f, -0.01164781f, -0.02062455f, 0.14947541f, 0.08148409f, -0.35834676f, 
    -0.06517603f, -0.00609249f, 0.00774310f, -0.10443456f, -0.07011267f, 0.00215110f, -0.02749799f, 0.08991169f, 
    -0.10182685f, 0.11272550f, -0.18565987f, -0.00595941f, 0.04776157f, 0.00247401f, 0.11355369f, 0.16985407f, 
    0.08374895f, -0.04000770f, 0.18426067f, 0.08079334f, 0.36910218f, 0.30880037f, 0.19512351f, -0.40480196f, 
    0.04504340f, -0.06016472f, 0.05559037f, 0.07758842f, 0.05853580f, 0.08459008f, -0.08764079f, -0.02537215f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04045515f, -0.05156770f, 0.05740604f, -0.05133992f, 0.00596149f, 0.09072889f, 0.13187876f, 0.14073931f, 
    0.02631489f, -0.06822899f, 0.05255772f, 0.03719741f, 0.10665315f, 0.18964319f, -0.10226105f, 0.01310518f, 
    0.01731779f, 0.07577351f, -0.03342436f, 0.17955954f, 0.04760817f, 0.01928147f, -0.03544211f, 0.01388498f, 
    -0.07705655f, 0.21011494f, 0.06434905f, -0.05797835f, -0.14018728f, 0.14062917f, 0.11603567f, 0.09551743f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.06193231f, -0.26676261f, 0.24167775f, -0.13149397f, 0.12442968f, 0.33343473f, 0.37576157f, -0.04537831f, 
    0.16202725f, -0.13689393f, -0.09384844f, -0.20165005f, -0.05501991f, 0.31542614f, -0.45565411f, -0.11793876f, 
    0.02919477f, 0.12821765f, -0.33238980f, 0.23405559f, 0.23263867f, 0.20318271f, -0.02544388f, 0.12975875f, 
    -0.19403465f, 0.36321720f, -0.21736950f, -0.32048395f, -0.06451224f, 0.38750082f, -0.06847350f, 0.23295964f, 
    -0.06220822f, 0.02606802f, -0.06268973f, -0.15408610f, 0.08335170f, -0.11152134f, -0.08229210f, 0.14785895f, 
    -0.01011288f, -0.15181340f, 0.14289573f, 0.02117745f, -0.05466193f, -0.02840019f, -0.07772009f, 0.07819732f, 
    0.10046037f, -0.08301213f, -0.15588783f, -0.16138001f, -0.04977737f, -0.02738351f, -0.09795191f, -0.03051054f, 
    -0.15133694f, 0.03991100f, -0.13198282f, -0.10565348f, -0.03135403f, -0.13716461f, 0.10623271f, -0.08081765f, 
    -0.04115078f, -0.28231961f, -0.03252424f, -0.03120487f, -0.01960165f, 0.11028699f, 0.13642959f, 0.16917740f, 
    0.16820891f, 0.04308582f, 0.04730595f, -0.35712782f, -0.16254951f, -0.04496067f, 0.28223231f, -0.16028997f, 
    0.04263395f, 0.03805926f, 0.18999700f, -0.45185968f, -0.10851894f, 0.40024203f, 0.42784265f, -0.06458014f, 
    0.39487481f, 0.11408427f, -0.11396593f, -0.55599606f, 0.11344713f, 0.46111488f, 0.04380145f, -0.20630692f, 
    0.02209938f, 0.14446235f, -0.11747181f, 0.02594592f, 0.35623804f, -0.19427551f, -0.41388571f, 0.07410922f, 
    0.14043322f, -0.11252119f, -0.09110717f, -0.40080720f, -0.09272877f, 0.41286007f, -0.28786629f, 0.09171350f, 
    0.03714027f, 0.30158672f, 0.25373402f, 0.32664114f, -0.27225593f, -0.15963770f, 0.17189385f, 0.15542273f, 
    0.56166375f, -0.17601222f, 0.19911872f, -0.15878925f, 0.23230731f, -0.14234956f, -0.02621093f, 0.44902053f, 
    0.06227840f, -0.02478887f, 0.54710591f, 0.25094014f, -0.21416180f, -0.05736611f, 0.16054602f, 0.10643108f, 
    0.11276309f, 0.11530995f, 0.07100548f, -0.21631543f, 0.36068183f, 0.38854200f, -0.33093145f, 0.02639160f, 
    0.00930374f, 0.44541320f, 0.05956224f, 0.59645402f, 0.08857953f, -0.32883355f, -0.22275659f, -0.14154300f, 
    -0.12357206f, 0.26105449f, 0.02997236f, 0.07982234f, 0.05281371f, -0.13919125f, -0.37926459f, 0.47502771f, 
    0.15314646f, 0.09942713f, 0.36089817f, 0.16294605f, 0.11284539f, 0.52716303f, 0.13141796f, -0.12958582f, 
    -0.14213999f, 0.06181243f, -0.00805005f, 0.09493146f, -0.20053561f, -0.18060482f, 0.23523301f, 0.10933021f, 
    -0.09702925f, -0.02866151f, -0.16381976f, 0.24449350f, 0.38338795f, -0.14466666f, -0.23714860f, 0.10376327f, 
    -0.55478466f, 0.29899055f, 0.26020142f, 0.42136648f, 0.03343694f, -0.09499272f, -0.05446870f, 0.03987758f, 
    -0.14344941f, 0.46356478f, -0.39096478f, 0.38438082f, 0.40417036f, 0.14302661f, -0.15476061f, -0.09297482f, 
    0.07471580f, -0.14688000f, 0.09830668f, 0.29407510f, -0.45259869f, -0.28989801f, -0.25627351f, 0.04966577f, 
    0.04971536f, 0.17914905f, -0.07832959f, 0.10754442f, -0.18964371f, 0.22567880f, -0.26391688f, 0.06017696f, 
    0.24731663f, -0.01768254f, 0.40190944f, 0.51074654f, 0.19465505f, -0.15738738f, 0.44931412f, 0.06076777f, 
    -0.16725625f, 0.13715589f, 0.09407389f, -0.12099207f, -0.07270795f, -0.12782052f, 0.10566624f, -0.12668243f, 
    -0.07412095f, 0.14308432f, -0.01167885f, -0.17289616f, -0.03310648f, 0.00348409f, 0.00139599f, 0.08355787f, 
    0.09805947f, -0.07998357f, -0.16871913f, 0.15263662f, -0.09328470f, -0.05515764f, -0.11716665f, -0.07662608f, 
    -0.02674660f, -0.17046414f, 0.05602962f, -0.08656213f, -0.04977100f, -0.17377071f, -0.11825744f, -0.00073942f, 
    0.10008898f, 0.07128311f, 0.14599143f, -0.02911668f, -0.18741111f, 0.10868204f, -0.09433307f, 0.11499520f, 
    -0.04059968f, -0.02301932f, -0.00335788f, -0.12313201f, -0.09282005f, -0.05332194f, -0.13298360f, 0.11180004f, 
    -0.06157843f, 0.03915476f, -0.02671941f, 0.02804797f, -0.04752207f, -0.01717771f, -0.08189254f, 0.06190170f, 
    0.05706896f, 0.01157424f, -0.04859740f, -0.21358030f, 0.01741255f, -0.18216863f, 0.15120898f, -0.11976448f, 
    -0.07059443f, 0.21308465f, -0.49353987f, 0.23021139f, 0.33487096f, -0.20310569f, 0.30816132f, 0.02679377f, 
    0.05930285f, -0.15320955f, 0.16097011f, 0.39982894f, 0.25322524f, 0.33734834f, -0.12531370f, -0.14366418f, 
    -0.15450019f, 0.06354719f, -0.03049334f, -0.03705575f, 0.08780823f, -0.16268007f, -0.00552910f, -0.00290525f, 
    0.22030120f, -0.03566789f, -0.40801397f, 0.33140072f, 0.41585222f, -0.30412346f, -0.27236217f, 0.09276341f, 
    0.13112034f, 0.18127640f, -0.45940110f, -0.08916353f, 0.13080516f, 0.04017933f, -0.26929629f, 0.00250974f, 
    -0.01947599f, -0.11900649f, -0.11175728f, 0.09917076f, 0.12260954f, -0.38330618f, -0.48775935f, 0.10584466f, 
    -0.17209651f, -0.15066509f, 0.30690271f, 0.22541763f, -0.09350101f, 0.34970963f, 0.23651737f, -0.03063384f, 
    0.59866333f, 0.01070856f, 0.35118002f, 0.03440746f, 0.27598515f, -0.11972159f, -0.40878704f, -0.07144147f, 
    0.09869570f, 0.08471552f, -0.15873668f, -0.09221850f, -0.16399394f, 0.25885731f, 0.07424977f, -0.14240111f, 
    -0.12153865f, 0.01632923f, 0.02027315f, -0.03841006f, -0.02082917f, -0.04406736f, 0.10256489f, 0.08572333f, 
    -0.11678819f, -0.11595021f, 0.16803271f, 0.16726120f, 0.07725342f, -0.26713637f, 0.01783336f, 0.16051251f, 
    0.11789116f, -0.13193348f, 0.00488392f, 0.22377037f, 0.08522363f, 0.07177012f, -0.00932249f, -0.05957410f, 
    0.13560092f, -0.20259893f, 0.10442346f, -0.00119399f, 0.10436711f, -0.11024980f, 0.03181475f, -0.15709297f, 
    -0.05810225f, 0.00349935f, -0.08463477f, -0.09342905f, -0.09028531f, -0.08185523f, -0.00587084f, 0.15224738f, 
    -0.05587047f, -0.04914480f, 0.05620042f, -0.19365168f, -0.22306681f, 0.01299792f, -0.17568649f, -0.10091000f, 
    -0.22991292f, -0.07381520f, -0.06632975f, -0.12178952f, -0.17700768f, -0.02085109f, 0.07237993f, 0.10982510f, 
    -0.10456253f, -0.23512927f, -0.34927502f, 0.19258562f, -0.12730052f, -0.25314757f, 0.07466951f, 0.35510874f, 
    0.00332001f, -0.09560711f, 0.08164786f, 0.43683681f, -0.20202076f, -0.07513697f, 0.41689986f, 0.09147032f, 
    -0.02616980f, 0.20087600f, 0.02212798f, 0.05530208f, -0.16223817f, 0.46288076f, -0.05995484f, -0.10160721f, 
    0.19911155f, -0.06309048f, 0.37368503f, 0.18051091f, -0.29007587f, 0.34736174f, 0.59059423f, -0.10042026f, 
    -0.08441785f, -0.17799757f, 0.07586324f, -0.19585839f, -0.00490334f, -0.20765015f, -0.18469486f, -0.11631177f, 
    -0.16960187f, 0.15531616f, 0.15150401f, -0.15180659f, 0.09913462f, 0.05187110f, -0.14817944f, -0.13420807f, 
    -0.08377330f, -0.06014239f, -0.18011293f, -0.02828577f, 0.05414904f, 0.00551617f, -0.19718342f, -0.05374501f, 
    -0.08006185f, -0.21438484f, -0.13267149f, 0.10457225f, 0.07650418f, -0.01962142f, 0.01241029f, 0.08398382f, 
    0.05139671f, -0.03097069f, -0.33936173f, 0.22825247f, 0.07334830f, 0.16855915f, 0.13341077f, 0.16231039f, 
    -0.16041577f, 0.11432842f, 0.08824264f, 0.10049058f, -0.18629804f, 0.22971696f, 0.18035322f, -0.09228776f, 
    0.00474886f, -0.00609050f, 0.21279217f, -0.14306843f, 0.09549055f, -0.08233399f, -0.31745464f, 0.07809732f, 
    0.07832226f, -0.32872543f, 0.00706276f, 0.01021552f, 0.17170852f, -0.12060360f, 0.33131075f, 0.35929400f, 
    0.05745979f, -0.30785474f, -0.41714260f, -0.13919996f, -0.08721202f, -0.01154135f, 0.02361072f, 0.37028673f, 
    -0.05814132f, -0.05573839f, 0.09877220f, 0.45276186f, 0.67911947f, 0.29195940f, -0.58143544f, -0.10931934f, 
    -0.16553608f, 0.36642253f, -0.13961703f, -0.23069337f, 0.29736984f, 0.04529808f, 0.23445472f, -0.11294060f, 
    0.35629648f, 0.20996930f, -0.20123631f, -0.12060311f, -0.12221194f, -0.04766874f, 0.12065082f, 0.04496112f, 
    -0.04892917f, 0.12772380f, -0.44936320f, -0.18759887f, 0.02907144f, 0.10761195f, 0.13425279f, 0.02742394f, 
    0.15014344f, -0.13537961f, -0.16155635f, -0.22498153f, -0.05573528f, 0.00929398f, 0.14204663f, 0.04042431f, 
    0.05610575f, -0.26530379f, 0.26949686f, 0.12992325f, -0.29834524f, 0.37024066f, -0.16094589f, 0.15703702f, 
    0.03512314f, 0.00501231f, 0.30624345f, -0.35968474f, -0.16074777f, 0.29153553f, 0.30676416f, 0.14208329f, 
    -0.01411160f, 0.38642532f, -0.47898951f, -0.24300277f, 0.30966383f, 0.20184043f, 0.25840509f, 0.24490578f, 
    -0.14179482f, 0.03884247f, -0.04815327f, 0.18111672f, 0.49919090f, 0.13490930f, -0.45866290f, -0.16611147f, 
    -0.08448798f, -0.44974107f, 0.49408302f, -0.29817253f, -0.11598986f, 0.05191346f, 0.04239346f, -0.06647146f, 
    -0.09002709f, -0.13571630f, 0.27425542f, -0.23689818f, 0.23222709f, 0.07152864f, 0.07678375f, -0.11839890f, 
    -0.06263220f, 0.01086454f, -0.13610898f, 0.25690416f, 0.40937304f, 0.05574277f, 0.32604837f, -0.00378195f, 
    0.04052196f, 0.14922816f, 0.03672384f, 0.47278327f, 0.27581203f, 0.06399823f, 0.19286887f, -0.09435350f, 
    0.08278160f, -0.03825534f, -0.26721531f, -0.61551183f, 0.05813580f, -0.12294525f, 0.25689986f, -0.05265967f, 
    -0.04759780f, -0.11537871f, -0.31721461f, -0.06207072f, 0.25477743f, 0.32762635f, 0.67569363f, -0.07031241f, 
    0.11560858f, -0.24731585f, 0.02010974f, -0.14921187f, 0.34066281f, 0.50384611f, -0.29731041f, -0.02206146f, 
    -0.00883514f, -0.15739636f, 0.12911361f, -0.53085476f, -0.18788761f, 0.19322354f, 0.00933648f, 0.03309864f, 
    -0.01841014f, -0.24712312f, 0.19483978f, -0.07424738f, -0.02687541f, 0.21805614f, 0.00740000f, -0.05497765f, 
    -0.02564729f, 0.19064356f, 0.22563526f, -0.29581156f, -0.07787795f, 0.20460428f, 0.11813848f, -0.00330851f, 
    -0.04204328f, -0.07190748f, 0.20976707f, -0.34074774f, -0.44595212f, -0.56404889f, -0.08266912f, 0.23776141f, 
    0.09759359f, 0.02773898f, 0.09703007f, -0.06086478f, 0.13104011f, -0.31904587f, 0.61591184f, 0.07193081f, 
    0.13426915f, -0.32898363f, 0.38130748f, 0.22073632f, 0.23915799f, 0.27353677f, 0.37784937f, -0.15223026f, 
    -0.10685609f, -0.04269325f, -0.04659313f, -0.03424771f, -0.31967664f, 0.29950124f, -0.01499825f, -0.23492283f, 
    -0.15424022f, -0.10512229f, -0.17315210f, -0.17291400f, 0.02290348f, -0.12834097f, 0.11412627f, -0.16304968f, 
    -0.08232272f, 0.16682704f, -0.13882101f, 0.09851876f, -0.11789732f, -0.12248637f, 0.03640672f, 0.08898534f, 
    0.02040946f, -0.12437383f, -0.10512206f, -0.15156879f, -0.14042458f, -0.08312035f, -0.07305858f, 0.02198190f, 
    -0.01008647f, 0.05404010f, -0.00053233f, -0.14164229f, 0.07978925f, 0.10073924f, 0.04579036f, -0.03105325f, 
    -0.00345909f, 0.00305267f, -0.01669331f, -0.21228333f, -0.29016882f, -0.17965972f, -0.34738019f, 0.30984485f, 
    0.04353964f, -0.11273894f, -0.14272043f, -0.51595235f, -0.11947766f, 0.01702713f, -0.05165523f, 0.16058043f, 
    -0.03074937f, -0.21162486f, 0.30479723f, 0.50501043f, 0.16919620f, 0.20721129f, 0.35641974f, 0.03881991f, 
    0.42120627f, 0.12134657f, 0.42389098f, 0.00262833f, -0.35448653f, 0.33862582f, -0.38939005f, 0.17624047f, 
    0.06863751f, -0.34848699f, 0.05766649f, 0.20155776f, 0.06655791f, 0.22657502f, -0.32581300f, -0.05160952f, 
    -0.10650195f, 0.01288398f, -0.08019839f, -0.16204287f, 0.11420300f, 0.36492440f, -0.11447756f, 0.04761161f, 
    0.02526230f, 0.28943932f, -0.16051945f, -0.19356009f, 0.26401123f, -0.18440957f, 0.41161832f, -0.06301267f, 
    0.31492206f, 0.18866579f, -0.29694912f, -0.27819952f, 0.01795635f, 0.11664721f, -0.09295043f, 0.14990377f, 
    0.12201536f, -0.16380681f, 0.65316141f, 0.18579794f, -0.09065199f, -0.00892712f, 0.24912110f, -0.17969322f, 
    0.16086718f, -0.01979322f, 0.07019159f, 0.28395420f, 0.54514706f, -0.45111629f, 0.30916804f, 0.14684430f, 
    0.10607012f, 0.43105161f, -0.29141802f, -0.33318517f, 0.15927412f, 0.08465793f, 0.19385116f, 0.04902521f, 
    -0.01794595f, 0.24390197f, 0.05692158f, 0.25149062f, 0.14110748f, -0.09811015f, 0.33934227f, -0.03685700f, 
    0.08827530f, -0.34786016f, -0.16952601f, 0.30721933f, 0.25021189f, -0.05387869f, 0.00967246f, 0.09677739f, 
    -0.15844360f, 0.11749899f, 0.01651761f, -0.23940367f, -0.55833256f, -0.05578717f, -0.10067073f, 0.03268652f, 
    -0.05580990f, 0.46020111f, -0.34580746f, 0.07050820f, -0.13927916f, 0.37702265f, -0.15322140f, 0.08226834f, 
    0.12927358f, -0.17945105f, 0.09292255f, -0.19480821f, 0.04285600f, 0.24853472f, 0.29356331f, 0.46390015f, 
    -0.01564005f, 0.39781228f, 0.48050439f, 0.19238493f, 0.16549441f, -0.22751755f, -0.04903191f, -0.09979278f, 
    0.10900469f, -0.08981392f, 0.16835687f, 0.38196418f, 0.38864499f, -0.11059883f, 0.10003266f, 0.07464053f, 
    0.08606489f, 0.04358047f, -0.21783030f, -0.17236041f, 0.10351907f, 0.12677258f, 0.01967312f, -0.13209118f, 
    -0.35011753f, -0.02663489f, 0.34969738f, 0.14747922f, 0.27479634f, 0.07759049f, 0.49115387f, -0.25328815f, 
    -0.12247992f, -0.06104005f, 0.17742524f, 0.15506300f, -0.12946254f, -0.21202624f, 0.59089565f, 0.31366402f, 
    0.14897466f, 0.12231273f, 0.01751593f, 0.26336852f, 0.25837031f, 0.21011929f, 0.21866180f, 0.12519830f, 
    0.09123971f, -0.00863924f, 0.03447914f, -0.03083297f, -0.09211446f, 0.33939865f, -0.10069867f, -0.13046908f, 
    -0.29620734f, -0.02931974f, 0.25074089f, -0.20705539f, -0.19371992f, 0.22633153f, 0.64310789f, 0.29613563f, 
    0.07127631f, 0.24870825f, 0.58103997f, 0.27746090f, -0.07326017f, 0.18144719f, 0.17430918f, -0.06290475f, 
    0.02154174f, 0.04747575f, -0.04877660f, -0.38270205f, 0.21334589f, -0.28902853f, 0.05199459f, -0.10721096f, 
    -0.13269439f, 0.24095196f, 0.33338615f, 0.31887671f, 0.05427962f, -0.27229688f, -0.03554635f, -0.02146998f, 
    0.14106710f, -0.10436877f, 0.08059414f, 0.05779712f, 0.43759832f, -0.12087890f, -0.54082376f, -0.00264981f, 
    -0.11707282f, 0.19854824f, 0.23578337f, -0.26813301f, 0.18450348f, 0.07525067f, -0.18619521f, 0.03675438f, 
    0.13629574f, 0.06578080f, -0.08581029f, -0.07145343f, -0.15139233f, 0.10418967f, 0.28551626f, 0.07539720f, 
    -0.12676138f, -0.23471497f, 0.21797380f, 0.31650612f, 0.47469693f, -0.29260707f, 0.11888096f, -0.01262802f, 
    -0.10448365f, 0.28358787f, -0.11013067f, 0.35810375f, -0.07254995f, -0.03244963f, -0.05668080f, -0.21343383f, 
    0.04442203f, 0.01242097f, -0.40044880f, 0.07859033f, -0.00747532f, 0.30409500f, -0.51003075f, 0.24652033f, 
    -0.03126122f, -0.06401584f, -0.05583419f, 0.03849407f, -0.48867586f, 0.36204329f, -0.06432503f, -0.03660433f, 
    0.13884237f, 0.01701867f, -0.35375759f, 0.27580622f, 0.00875256f, 0.13340819f, 0.25080782f, -0.15744162f, 
    0.45481920f, 0.15136757f, -0.13853405f, 0.33963522f, -0.21793418f, 0.18898770f, 0.00519381f, 0.26580474f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.25548044f, -0.07807177f, 0.02892308f, -0.17517820f, 0.22067118f, 0.17174724f, 0.07558355f, -0.11287954f, 
    -0.17275394f, -0.05718654f, -0.22298519f, 0.14091639f, -0.18017490f, 0.24923646f, 0.13788992f, 0.04133443f, 
    0.20559074f, -0.01239723f, 0.11956611f, -0.12275510f, 0.06201978f, 0.14115781f, -0.18435913f, 0.33222595f, 
    0.10629955f, 0.13554285f, 0.14271609f, -0.10323095f, 0.23606528f, 0.02217321f, 0.27114531f, 0.08111443f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.54906440f, -0.01877694f, -0.14807791f, -0.06847800f, -0.16259183f, -0.27928516f, 0.25516427f, 0.09819710f, 
    0.14160968f, 0.33794552f, 0.30471957f, -0.01244546f, -0.05096570f, 0.19739293f, 0.04477859f, 0.32485777f, 
    0.29402506f, 0.14944226f, 0.27942118f, 0.17933150f, -0.70578927f, -0.48687327f, -0.17118834f, -0.48111391f, 
    -0.54506987f, 0.08025324f, -0.20469613f, 0.14431976f, 0.16342722f, -0.00389822f, -0.41732666f, -0.48859844f, 
    0.07359829f, 0.16843393f, -0.06003896f, -0.20908786f, 0.30610633f, 0.19531104f, -0.01452306f, 0.00903472f, 
    -0.13181578f, 0.17075706f, -0.45046973f, 0.07898094f, -0.10159850f, -0.48562059f, -0.14977890f, 0.03765691f, 
    -0.33354861f, -0.29228884f, -0.21241972f, 0.20725435f, -0.45697707f, 0.13194011f, 0.02409794f, -0.34500238f, 
    -0.04678778f, 0.26711056f, -0.24181882f, 0.25991118f, 0.10717603f, 0.43478191f, -0.01014611f, -0.78042459f, 
    -0.59377569f, -0.04210747f, -0.34213093f, 0.39540675f, 0.10358339f, 0.05311245f, 0.12978028f, 0.00659309f, 
    -0.04913510f, -0.20479074f, 0.39859933f, 0.02724314f, -0.15167332f, -0.33954337f, 0.01652028f, -0.15720025f, 
    -0.43315536f, -0.00968133f, 0.21465556f, -0.53469557f, 0.18159883f, -0.43699378f, 0.01657355f, 0.25495827f, 
    -0.04092849f, -0.07699805f, -0.39592743f, 0.12949423f, -0.46581522f, 0.42287639f, 0.06721282f, -0.13175412f, 
    -0.10156051f, 0.11175986f, 0.11643609f, -0.09961833f, -0.15573405f, -0.63993138f, -0.52817428f, 0.14927925f, 
    -0.15677921f, -0.17741607f, -0.00505544f, -0.14564729f, 0.06048940f, 0.18416719f, -0.00074093f, -0.61139244f, 
    0.43195748f, -0.03148638f, 0.25439361f, 0.24718830f, -0.09101527f, 0.15311620f, 0.00814590f, 0.18510357f, 
    0.20186396f, 0.00838016f, -0.42188120f, 0.20505714f, 0.17510249f, -0.89766192f, -0.06512444f, -0.06448675f, 
    0.28399172f, -0.12448325f, 0.32342291f, -0.11151846f, -0.31031188f, -0.05640750f, -0.04123198f, -0.15323660f, 
    0.16480322f, -0.26887017f, -0.06939664f, -0.22410178f, -0.14038974f, 0.09195767f, 0.09885514f, 0.05222720f, 
    -0.02354048f, 0.24066660f, 0.13743453f, 0.34556004f, 0.28593868f, -0.34734863f, 0.02477329f, -0.17475653f, 
    0.08834410f, 0.05917819f, 0.24338062f, 0.02375191f, 0.20247319f, -0.07664397f, -0.48257670f, -0.15806401f, 
    -0.04031939f, -0.12251210f, -0.57654285f, -0.08801110f, 0.05868870f, 0.24679898f, 0.24612312f, -0.06620606f, 
    -0.12764703f, -0.07514367f, -0.60910326f, 0.10246819f, -0.09041549f, 0.39324608f, -0.04598887f, 0.19588581f, 
    0.02856784f, -0.51017773f, -0.48557937f, 0.21987253f, -0.24747045f, -0.21269321f, 0.14775676f, -0.69231623f, 
    0.01807877f, 0.18809208f, 0.26247892f, 0.19229348f, 0.20225383f, -0.31946343f, -0.13118087f, 0.15069048f, 
    0.10582484f, 0.11515986f, -0.10018542f, 0.30495897f, 0.21631697f, -0.25864679f, 0.14849667f, -0.08264820f, 
    0.08240946f, 0.12612198f, 0.37479615f, -0.02874899f, 0.04390828f, -0.14141814f, 0.12958318f, -0.10920069f, 
    0.25734794f, -0.72870213f, -0.48032436f, -0.23004006f, -0.27398711f, -0.18503042f, 0.04801348f, 0.02747879f, 
    0.32593492f, 0.02751300f, 0.34117052f, -0.21977568f, -0.17878664f, 0.24485269f, -0.47075227f, 0.21197408f, 
    -0.61157078f, -0.16071625f, 0.33864996f, -0.26582727f, -0.75128001f, -0.11046878f, -0.02549379f, -0.14330995f, 
    0.05469384f, -0.42113513f, 0.07430711f, 0.08224820f, -0.17427981f, 0.27411747f, 0.02920087f, 0.16546239f, 
    -0.44706595f, -0.13894871f, -0.52221918f, -0.07184695f, 0.18249546f, 0.28349313f, -0.06548325f, 0.29788271f, 
    -0.05153573f, -0.11946601f, 0.23118533f, -0.23534441f, -0.01832331f, 0.27980283f, 0.20319031f, 0.16686343f, 
    -0.00706309f, 0.03333952f, -0.35270274f, -0.52070349f, -0.37465584f, 0.30669248f, 0.33141854f, -0.14935142f, 
    0.14331329f, 0.19641107f, 0.16729833f, 0.15058649f, 0.05655992f, -0.47725064f, -0.03703003f, -0.47061899f, 
    -0.06752276f, -0.06084995f, 0.09893556f, 0.20173641f, 0.03947566f, -0.42504084f, 0.05505843f, -0.33882764f, 
    0.05170501f, 0.04239603f, -0.47205934f, 0.14817093f, -0.64780122f, -0.18816835f, 0.37122589f, 0.15600096f, 
    0.01206569f, 0.05411001f, -0.17725194f, 0.40841195f, -0.10786068f, -0.18589132f, 0.23553967f, -0.04722573f, 
    0.00262107f, 0.13585754f, 0.08516332f, 0.00662836f, 0.02287552f, 0.04508862f, 0.02302201f, 0.33897868f, 
    -0.43995953f, 0.34188038f, 0.22670101f, 0.00591705f, 0.18600364f, -0.19769281f, 0.05927543f, -0.09524281f, 
    -0.16969813f, -0.83979434f, 0.30397341f, -0.10231926f, 0.10864702f, -0.07699810f, -0.12461161f, 0.03633237f, 
    0.33377260f, 0.02775529f, -0.18028215f, -0.59188604f, 0.26693776f, 0.19127852f, -0.12242340f, 0.14135459f, 
    0.10327742f, -0.38451767f, 0.10121593f, -0.14340726f, -0.13602592f, 0.13009447f, 0.01386947f, -0.30618766f, 
    0.03890491f, 0.39510903f, 0.11367078f, -0.81436187f, 0.06142234f, 0.10347878f, -0.09508669f, 0.44590095f, 
    -0.45858276f, -0.21112955f, -0.27213761f, -0.12178290f, 0.28708312f, -0.01101484f, 0.10522369f, -0.06677556f, 
    0.31859365f, -0.08901521f, -0.01743476f, 0.00235090f, 0.25342470f, -0.10333476f, -0.80376756f, 0.10032796f, 
    0.02927514f, 0.20015472f, -0.31407255f, -0.18424648f, 0.04668638f, -0.33082169f, -0.00543726f, 0.16706304f, 
    0.50183165f, -0.43334445f, 0.00137264f, 0.10557756f, 0.15222110f, -0.47472703f, -0.06190401f, -0.02756231f, 
    0.46755081f, -0.41255340f, -0.23499273f, -0.49251878f, -0.06894705f, -0.16168104f, 0.17664063f, 0.18171917f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.09041619f, -0.04616232f, 0.07008693f, -0.04674426f, 0.04264040f, 0.05456521f, -0.20437348f, -0.20910302f, 
    0.02405281f, -0.07602991f, 0.31338018f, -0.11834639f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
