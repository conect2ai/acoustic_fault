#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.08980274f, -0.75952214f, -0.97291130f, 0.68851662f, 0.27903819f, 0.20519897f, -0.44800261f, 0.34659478f, 
    -0.47135392f, 1.27329898f, 0.32865855f, -0.74741578f, 0.91762984f, 0.85513377f, -0.37438664f, -0.39425755f, 
    -0.23316118f, -0.26310828f, -0.84773117f, -0.78851467f, -0.87030709f, -0.10459654f, 0.85593957f, 0.55488539f, 
    0.06552023f, -0.72788185f, -0.22083342f, 0.79064673f, -1.21424055f, -0.01255159f, 0.86162651f, -0.71033812f, 
    0.06931005f, -0.12120215f, -0.20182088f, -0.70877540f, 0.91885173f, 0.90719187f, 0.73275584f, -0.14845321f, 
    -1.34099412f, 0.06575571f, -0.75981098f, -0.31053016f, -0.50994301f, 0.49939021f, -0.29465681f, 0.58938956f, 
    -0.76540720f, -1.18831325f, -0.31430060f, -0.21428552f, 0.71473986f, 0.74912149f, -0.93250442f, -1.50043559f, 
    -0.75815976f, -0.62111229f, -0.70188695f, 0.14988066f, 0.12596452f, 0.29307857f, 0.12806334f, -0.46498796f, 
    -1.08889794f, -0.15944292f, 1.34507549f, 0.82877851f, 1.29068136f, -0.15009806f, 0.12572408f, 0.24782565f, 
    -0.67582113f, 1.05612004f, -0.06054082f, 1.21668077f, -0.53796780f, -0.92149878f, -0.32481936f, -0.10256676f, 
    -0.63760084f, -1.74213290f, 0.35295025f, 0.50333983f, -0.28160626f, 0.30430838f, 0.28775889f, -0.33069652f, 
    -0.13086484f, 0.33397797f, 1.26729631f, 0.47033063f, 1.43306732f, 0.62972671f, 0.39040819f, 0.43507785f, 
    -0.00224793f, 0.01793310f, 0.34869179f, 1.40078688f, 0.84672940f, 0.91710317f, -0.73870969f, -0.56245798f, 
    0.11170502f, 0.55786419f, 0.22272608f, -0.11265996f, 1.41565001f, 1.37009823f, 0.14855543f, -0.34021500f, 
    0.19982751f, -0.21217465f, -0.23641163f, 0.55841345f, 0.30281818f, -0.75309741f, -0.23511139f, -0.97161275f, 
    -0.94253886f, 0.75226665f, 1.22929394f, 0.47293821f, 0.12112375f, 0.63843060f, -0.89767009f, 0.28229317f, 
    -0.44629893f, -0.50147128f, 1.10003936f, -0.59139001f, -0.11244290f, -0.22571304f, -0.73904520f, -0.45610061f, 
    -0.63481492f, -0.77638650f, 0.80232525f, -1.11563528f, -0.03641729f, -0.09575732f, 0.03466583f, 0.72607595f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12574816f, 0.01911198f, -0.11277401f, 0.26230553f, 0.20987524f, 0.24982862f, 0.24021621f, 0.36676538f, 
    -0.36868614f, 0.73516572f, 0.68146098f, 0.33459607f, -0.39445677f, 0.03308019f, 0.35710061f, -0.03989794f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03482167f, -0.49942428f, -0.13489765f, 0.11994896f, 0.22597152f, 0.14711426f, 0.10384258f, -0.06375451f, 
    0.03345212f, -0.28838745f, 0.01759799f, 0.09712894f, 0.00612427f, -0.08560953f, 0.00513543f, 0.13305001f, 
    0.16077878f, 0.13765304f, 0.45039219f, -0.03394646f, 0.08045731f, 0.11414074f, 0.00957630f, -0.01591977f, 
    -0.04385823f, 0.15375581f, 0.23790190f, 0.31745356f, -0.06215318f, 0.33178127f, 0.27353597f, 0.26439214f, 
    0.07017363f, -0.23926701f, -0.17507909f, 0.13530467f, 0.13039924f, 0.10252286f, 0.56507468f, -0.50832486f, 
    -0.35910639f, -0.28445494f, 0.21072824f, 0.13336268f, -0.01659562f, -0.33884811f, 0.15757337f, -0.08934857f, 
    -0.04898068f, -0.04180689f, -0.03863566f, -0.28397420f, 0.27232733f, 0.06214776f, -0.35597387f, -0.23716466f, 
    0.26992455f, 0.05568016f, 0.05532914f, -0.21499635f, 0.24958247f, -0.02675118f, 0.14831823f, 0.81025499f, 
    0.18220025f, -0.42908937f, 0.30061436f, 0.19704406f, 0.33080003f, 0.04163686f, 0.06972244f, 0.01303004f, 
    -0.61251432f, -0.25281700f, -0.16943309f, -0.08923989f, -0.05755109f, -0.14550276f, -0.03807304f, -0.04041908f, 
    -0.05569793f, 0.36672965f, 0.15496796f, 0.60692900f, -0.12569991f, -0.00851171f, 0.02054578f, 0.09177689f, 
    0.07133527f, 0.00641289f, 0.27909195f, -0.16551290f, 0.13363919f, 0.01424339f, 0.31513083f, 0.31452298f, 
    0.04923768f, -0.05866498f, -0.09679133f, 0.02777148f, -0.05813178f, 0.23858592f, -0.38196886f, -0.28012210f, 
    -0.11444661f, 0.04445288f, -0.02222320f, 0.16666622f, -0.08252403f, 0.20649160f, -0.08204629f, 0.11369497f, 
    -0.05880025f, -0.13943967f, -0.16677740f, -0.23282546f, -0.01254798f, 0.39631280f, -0.60387701f, -0.69960880f, 
    0.19705416f, -0.02219582f, 0.07215036f, 0.03840212f, -0.24623960f, -0.17332648f, 0.07103274f, -0.13141130f, 
    -0.36985391f, 0.17883523f, -0.01265360f, 0.09100741f, 0.01983514f, -0.09991283f, -0.06084345f, -0.22911948f, 
    -0.34816298f, -0.13174038f, 0.08216865f, 0.01045671f, -0.18153359f, 0.08980589f, 0.00087057f, -0.11007053f, 
    0.10830481f, 0.11911280f, -0.40893263f, 0.15524839f, -0.12836796f, 0.02284135f, 0.07467328f, 0.19319208f, 
    -0.07184979f, -0.38477889f, -0.42669898f, 0.11419814f, 0.07100888f, 0.09387394f, -0.06875144f, -0.09085727f, 
    0.18462875f, 0.20032609f, -0.20646603f, 0.28087053f, -0.24683833f, -0.03624957f, 0.16562685f, 0.16031998f, 
    0.00794890f, -0.09552480f, -0.02476427f, -0.15410154f, -0.56229949f, -0.20199224f, -0.08495541f, -0.05320356f, 
    0.16693017f, 0.14398193f, 0.24951935f, -0.00685648f, 0.69754195f, 0.17744413f, 0.03903190f, 0.24873582f, 
    0.13573104f, -0.01868977f, 0.01280715f, 0.08280513f, 0.04798323f, 0.14464736f, -0.02392404f, 0.10589429f, 
    0.07786097f, -0.26139212f, 0.02035886f, 0.13201633f, -0.00753448f, 0.15732159f, -0.21043062f, 0.14416559f, 
    -0.30131450f, -0.04617844f, 0.14445226f, -0.01339440f, 0.06505897f, 0.21137336f, -0.06312466f, -0.75789416f, 
    0.17593685f, -0.24580644f, 0.16145270f, 0.26105353f, 0.22971821f, -0.17125770f, -0.25296396f, -0.00319944f, 
    -0.38831788f, -0.00915896f, 0.25643811f, 0.24385138f, 0.10056286f, -0.15177692f, -0.10951435f, 0.09360550f, 
    0.03914654f, -0.66951931f, -0.29508004f, 0.07133397f, -0.02682876f, 0.05343774f, -0.14622289f, -0.05542110f, 
    0.13040942f, 0.05698457f, 0.63709223f, 0.08344454f, 0.36399254f, -0.07519218f, 0.09045247f, 0.17701176f, 
    0.12286022f, 0.24729085f, -0.03716143f, 0.86226374f, 0.37707675f, 0.08643727f, -0.10352431f, -0.23980013f, 
    0.11905938f, 0.22021730f, 0.18628262f, 0.00168891f, 0.72870356f, 0.06377017f, -0.00786844f, -0.19937079f, 
    0.01152043f, -0.16110398f, 0.09722152f, -0.12600447f, -0.00227357f, -0.72325838f, 0.34445095f, 0.09436606f, 
    0.04251845f, 0.24109523f, 0.02447760f, -0.10087236f, -0.11675335f, -0.18143483f, -0.08917053f, -0.09982438f, 
    0.12075727f, -0.07195027f, 0.10359044f, 0.00014771f, -0.50031805f, -0.05072219f, -0.31222150f, -0.00338167f, 
    -0.41644466f, -0.45714399f, -0.06364421f, 0.11934445f, -0.12733476f, 0.20772816f, 0.06170562f, 0.21854179f, 
    -0.05478959f, -0.05007689f, -0.00873297f, -0.06555977f, -0.08132663f, -0.00896219f, -0.08365180f, -0.03494051f, 
    -0.02985034f, -0.04084002f, -0.02415462f, 0.05791585f, 0.02820465f, 0.04190468f, 0.00417166f, -0.05238181f, 
    0.03379911f, 0.06150114f, -0.07364673f, -0.07266763f, 0.05064733f, -0.06904154f, 0.04478202f, 0.06474213f, 
    -0.00858565f, -0.09017975f, 0.07185650f, 0.01344830f, -0.02932994f, 0.03369475f, -0.05240796f, 0.00885883f, 
    0.02914851f, 0.05026782f, -0.00097214f, -0.00376811f, -0.07847191f, 0.06341784f, 0.00133078f, 0.01323420f, 
    -0.00005726f, 0.00486150f, 0.03496083f, -0.08891257f, 0.05106955f, -0.06915635f, -0.07199290f, -0.00652790f, 
    -0.02990625f, 0.01805567f, -0.05693367f, -0.01062607f, 0.05559821f, -0.07201026f, 0.02698788f, -0.01892622f, 
    0.02885349f, 0.01440991f, -0.03074844f, -0.00881776f, -0.04222777f, -0.05032941f, -0.08768475f, -0.03699173f, 
    -0.00582671f, 0.06211588f, -0.07016618f, 0.02652262f, -0.09040316f, -0.00682218f, -0.09377372f, 0.02380482f, 
    -0.07578399f, 0.00270071f, 0.02156774f, 0.07177629f, -0.01035197f, -0.05240708f, 0.01978273f, -0.03371732f, 
    0.06286377f, 0.00155173f, -0.07664359f, 0.01547282f, -0.09356347f, -0.05617811f, 0.06053127f, -0.00081903f, 
    0.00662659f, 0.04609753f, -0.06652430f, 0.05777400f, 0.06496066f, -0.04298042f, 0.04080545f, -0.09366852f, 
    -0.03698825f, 0.03378651f, 0.03457524f, 0.00749511f, 0.06533331f, -0.04578045f, -0.02682923f, 0.05010600f, 
    -0.08674914f, 0.00348859f, 0.01917270f, -0.03307895f, 0.06338698f, -0.08677440f, -0.07482655f, 0.05405428f, 
    -0.04364595f, -0.02639265f, -0.03156484f, -0.03063526f, -0.01305235f, -0.01888529f, -0.01593303f, 0.00331379f, 
    -0.00900017f, -0.06056975f, 0.01205955f, 0.05729287f, 0.04162570f, 0.03661064f, 0.04747396f, -0.05605795f, 
    0.04781384f, -0.07388936f, -0.00451907f, -0.03855305f, -0.06069623f, -0.00760586f, -0.02843188f, 0.03057715f, 
    -0.05583427f, -0.03287918f, -0.01736207f, -0.07625164f, -0.07227010f, -0.06743970f, 0.04161472f, -0.07741458f, 
    -0.00721001f, -0.07889064f, -0.02733584f, 0.07065174f, 0.03676411f, -0.03274007f, -0.00482473f, 0.03320328f, 
    0.03299653f, -0.04086623f, -0.06778983f, -0.07990082f, -0.04173085f, -0.08220113f, -0.06665733f, -0.06752480f, 
    0.01983921f, -0.00731789f, -0.03166373f, -0.05984616f, -0.03279443f, 0.04371496f, -0.07480764f, -0.02146254f, 
    0.05106116f, -0.00331627f, 0.03732479f, 0.00434937f, -0.07727823f, -0.04428219f, -0.06369904f, 0.00489576f, 
    -0.01469066f, -0.02735347f, 0.03233950f, 0.06553865f, 0.01106933f, -0.06360931f, -0.03297526f, 0.01111546f, 
    0.02385621f, 0.01017393f, -0.08335874f, 0.00932894f, -0.07968035f, -0.05838151f, -0.04378506f, -0.06501696f, 
    0.03740036f, 0.06049089f, 0.06635922f, -0.07863613f, 0.06386679f, -0.03869686f, 0.04963700f, 0.03182180f, 
    0.01306301f, -0.08967182f, -0.08379422f, 0.07290951f, 0.01246148f, -0.07403482f, -0.09765217f, -0.00956145f, 
    -0.06662627f, -0.02453078f, -0.01023888f, 0.03343332f, 0.04148501f, 0.00356578f, 0.05031975f, 0.04490146f, 
    -0.01415976f, -0.07077473f, 0.02784525f, -0.06347686f, -0.06698161f, 0.04023386f, -0.03943318f, -0.04390022f, 
    -0.04325002f, -0.01344265f, -0.06811016f, -0.00673615f, -0.04906175f, 0.01223583f, -0.00997403f, 0.03248334f, 
    0.01516795f, 0.03556506f, 0.01650333f, -0.02865461f, -0.02638214f, 0.05703707f, -0.01271364f, 0.05062682f, 
    0.03946055f, 0.00502723f, 0.05634530f, -0.03352681f, 0.04156332f, 0.04488642f, 0.02568186f, -0.07763921f, 
    0.01998557f, -0.02933154f, 0.02249883f, -0.03924804f, -0.02147731f, 0.00375611f, -0.08467562f, -0.00604416f, 
    -0.03379509f, 0.01439867f, -0.08131474f, -0.07234799f, 0.02897288f, -0.09552019f, 0.05634267f, -0.00551024f, 
    0.02716441f, -0.03406415f, -0.05339848f, -0.08610388f, -0.07448152f, -0.03067462f, -0.00611679f, 0.07646230f, 
    0.05938797f, 0.06002740f, 0.01792171f, 0.05096835f, -0.06490924f, 0.06259183f, -0.03879322f, -0.00626880f, 
    -0.02282270f, 0.06795562f, -0.03317654f, -0.02842729f, 0.05021712f, -0.01382803f, -0.01564498f, -0.06849131f, 
    -0.53280127f, -0.07182832f, 0.11968024f, 0.13273895f, 0.07083660f, -0.16689885f, 0.14460944f, -0.01102633f, 
    0.03169731f, -0.75337589f, 0.19257383f, 0.07952885f, 0.08819655f, -0.12012333f, -0.07126947f, 0.18863250f, 
    0.12089295f, -0.01336264f, 0.02931773f, 0.34920630f, -0.36080015f, 0.01517514f, -0.13150683f, -0.19570421f, 
    -0.04430495f, -0.05398295f, -0.10415207f, 0.65074950f, 0.54391640f, -0.43417251f, -0.11077398f, 0.03192548f, 
    0.24725631f, 0.09679895f, 0.15165077f, 0.05066518f, -0.02730700f, 0.08964930f, 0.14051323f, 0.06708653f, 
    -0.12137345f, 0.15865758f, -0.21921875f, 0.25770158f, 0.11743053f, 0.34052107f, 0.06425548f, -0.35683182f, 
    -0.16811989f, 0.08399297f, -0.01716855f, -0.13724954f, 0.07293907f, 0.14773314f, -0.67494535f, 0.25233692f, 
    -0.10239559f, -0.01369582f, 0.31057763f, 0.18687147f, 0.06422176f, -0.05278550f, 0.06320693f, 0.29662344f, 
    -0.13299666f, -0.25332382f, 0.01655659f, -0.05092315f, 0.02343689f, -0.07981432f, 0.01399282f, -0.06060165f, 
    -0.66972405f, -0.62747622f, 0.20900124f, 0.03254388f, 0.16049825f, -0.06387217f, 0.11367510f, -0.19413035f, 
    -0.00239110f, 0.42782277f, -0.45183289f, -0.31292444f, 0.07845549f, -0.06150930f, 0.02872500f, 0.04623483f, 
    -0.05231573f, 0.07282087f, 0.03845908f, -0.08291643f, 0.32419837f, -0.18387346f, 0.21277505f, -0.11791038f, 
    -0.05195751f, -0.00428432f, -0.16252707f, 0.20355381f, 0.12572709f, 0.18974304f, -0.15218049f, 0.02835953f, 
    0.38747343f, 0.17466715f, -0.11204304f, 0.22033776f, -0.34175313f, 0.05176264f, -0.02896386f, 0.26899442f, 
    -0.04145505f, 0.12028500f, -0.19896308f, -0.03272457f, -0.02042402f, -0.19644018f, -0.60805458f, -0.12802505f, 
    -0.06526688f, -0.17510746f, 0.15607731f, -0.02090887f, 0.04757902f, 0.00501269f, -0.08542047f, -0.78514016f, 
    0.01414440f, -0.00711072f, 0.29518738f, 0.07808428f, 0.34352919f, -0.21340966f, -0.26500306f, -0.57386124f, 
    -0.44978082f, 0.00272332f, 0.27564475f, 0.24043959f, 0.04936651f, 0.02717986f, -0.07524928f, 0.01586483f, 
    -0.31897983f, -0.11685210f, 0.32943085f, 0.09912436f, -0.06432885f, 0.12623821f, 0.16421877f, 0.02999261f, 
    -0.03054411f, 0.23178184f, -0.16039853f, 0.11673798f, -0.10717864f, -0.15466048f, 0.11738136f, -0.07857697f, 
    0.13198359f, -0.02438264f, -0.79250884f, -0.32448706f, 0.23687054f, 0.15028670f, 0.22762540f, 0.19185966f, 
    -0.22390111f, -0.07720883f, 0.42496923f, -0.21803015f, -0.00991183f, -0.08418410f, -0.12435075f, 0.10508324f, 
    -0.02004928f, -0.16075553f, -0.26252472f, -0.02250560f, -0.22545631f, 0.00400779f, 0.35993174f, 0.30266663f, 
    0.16004768f, -0.02751301f, -0.09093224f, 0.21223228f, 0.05968018f, 0.08883642f, 0.19095249f, 0.02094009f, 
    -0.28248882f, 0.27850646f, -0.31141278f, 0.05997930f, 0.06986849f, -0.02775065f, 0.22884971f, -0.20012817f, 
    0.04358209f, 0.40140343f, -0.17840236f, 0.07843923f, 0.00087352f, -0.04774290f, -0.09252469f, -0.30556715f, 
    -0.21848167f, 0.18832031f, -0.05764048f, -0.11309235f, 0.02359661f, 0.04653928f, -0.16834348f, -0.06348369f, 
    0.19246958f, -0.24482681f, -0.24060641f, 0.18171558f, 0.03520469f, 0.15925038f, 0.13788842f, 0.05334052f, 
    0.22134720f, 0.13389915f, -0.14712448f, -0.09375960f, -0.07781450f, 0.12790991f, -0.07768767f, -0.00497502f, 
    0.02583030f, 0.07853435f, 0.38577476f, 0.12988853f, 0.07905038f, 0.16498199f, -0.25619555f, 0.28756523f, 
    0.07348942f, 0.10028646f, 0.18172410f, -0.15663341f, 0.30582049f, 0.32110342f, -0.00019528f, -0.15562275f, 
    -0.20604347f, 0.18383558f, 0.12255635f, -0.21934347f, -0.10381093f, 0.08532666f, 0.21910228f, -0.18020006f, 
    -0.11518212f, -0.07724030f, 0.03269101f, -0.09874523f, -0.17705293f, -0.31714857f, -0.35466951f, 0.04022820f, 
    0.21582527f, 0.07669318f, 0.09216268f, -0.16737710f, 0.02684228f, -0.18244880f, -0.29326394f, 0.16327931f, 
    0.16223849f, 0.02955273f, 0.22184063f, -0.09419446f, -0.14881708f, -0.31805593f, 0.17779951f, -0.52190441f, 
    0.17268324f, 0.01344076f, -0.01594251f, 0.09771588f, -0.26672319f, 0.08582624f, -0.25540030f, 0.12188123f, 
    -0.02116517f, -0.08092850f, -0.05283896f, -0.03961762f, -0.02648490f, 0.06665167f, -0.04879138f, -0.04295695f, 
    -0.07828119f, -0.00017225f, -0.02222781f, 0.01237676f, -0.05584593f, -0.05037878f, -0.07180975f, -0.05196070f, 
    -0.03728621f, -0.07919393f, 0.06568983f, -0.08197983f, -0.06081262f, -0.06697822f, -0.03756800f, 0.04692410f, 
    -0.02001160f, 0.01206241f, 0.02571395f, -0.00511018f, 0.03590835f, -0.05676034f, -0.04206759f, 0.05338311f, 
    -0.00457753f, 0.07591214f, -0.04367646f, 0.04889945f, -0.00040106f, -0.03035099f, -0.02027520f, 0.07827108f, 
    0.06206525f, 0.01928778f, -0.01178589f, 0.02099076f, -0.00958334f, 0.01326156f, -0.05038460f, -0.07674664f, 
    -0.04665524f, 0.03084063f, 0.05902028f, 0.03413957f, -0.05043789f, 0.01350979f, 0.05581672f, -0.04272169f, 
    -0.00365825f, -0.01854527f, 0.06603692f, 0.03981267f, -0.06451844f, -0.05374629f, -0.07962586f, -0.07912380f, 
    -0.06302100f, -0.01280470f, 0.06253579f, -0.00699748f, 0.00807832f, -0.02249712f, -0.04475054f, -0.00471865f, 
    0.07434329f, 0.03497663f, -0.06962468f, -0.04492620f, -0.07053873f, -0.04161900f, -0.02081005f, -0.02550663f, 
    0.01422298f, 0.00599537f, -0.07268085f, -0.02446515f, -0.02984216f, 0.01318060f, 0.01916794f, 0.06886428f, 
    0.04682915f, -0.03686848f, 0.01596086f, -0.04658347f, -0.00687147f, 0.08028689f, 0.06604548f, -0.00130255f, 
    0.01070903f, -0.03241709f, -0.01884178f, -0.07484934f, -0.07970437f, -0.00440749f, 0.05626612f, 0.04257901f, 
    -0.06765559f, 0.03339586f, 0.08032370f, 0.04013560f, -0.07030495f, -0.03003093f, 0.00929264f, -0.05970944f, 
    -0.07198112f, 0.01719296f, 0.05364580f, -0.07284530f, 0.01658155f, -0.06685456f, 0.05051753f, -0.03793353f, 
    0.05874783f, -0.08313321f, -0.03126421f, -0.08186515f, 0.01712803f, 0.03516608f, 0.07388429f, -0.08122464f, 
    -0.00997643f, -0.06160501f, -0.00805759f, 0.07440444f, -0.04419350f, 0.05514278f, -0.06581046f, 0.02186713f, 
    0.00690251f, -0.02308246f, -0.08078729f, -0.00602603f, -0.03214839f, 0.00536429f, 0.02664531f, -0.07082944f, 
    0.01170692f, 0.07795530f, 0.19875686f, -0.15480523f, 0.01302744f, -0.05670832f, 0.05042535f, 0.12593479f, 
    -0.15546544f, -0.29954430f, -0.20932516f, -0.59752125f, -0.25423327f, 0.06680663f, -0.15092131f, -0.02620791f, 
    0.14678586f, -0.01826761f, 0.05492820f, 0.11792056f, -0.20634498f, -0.01984627f, -0.26649821f, 0.03973594f, 
    0.15572637f, 0.04831615f, -0.14809257f, 0.02527839f, 0.06584948f, 0.32531166f, 0.18193914f, 0.09406628f, 
    -0.12287094f, -0.03832344f, -0.07345561f, 0.11631422f, -0.58103406f, -0.16479744f, 0.38901308f, 0.22753274f, 
    -0.00501909f, 0.11781322f, -0.18019098f, -0.07505017f, -0.14961517f, 0.65033466f, 0.33930430f, 0.36907467f, 
    0.12202688f, 0.25804460f, 0.03060391f, 0.23880802f, -0.06470642f, 0.37193584f, -0.19787298f, 0.10983832f, 
    -0.05053560f, -0.19277096f, -0.08475799f, -0.12183803f, -0.44520089f, 0.10518339f, 0.18930648f, 0.62521172f, 
    0.22892123f, -0.28553528f, -0.03905386f, 0.47136644f, -0.02252986f, -0.13271721f, 0.40011537f, 0.00106439f, 
    1.05248559f, -0.34045616f, -0.28611344f, 0.00975808f, -0.20388745f, -0.15763068f, 0.09878743f, -0.12306076f, 
    0.05907878f, -0.19788158f, 0.08842529f, -0.18847591f, -0.06272300f, -0.22514403f, -0.05519973f, 0.21333799f, 
    0.27305874f, 0.07827874f, -1.28993499f, -1.14910996f, 0.03041786f, -0.00730238f, 0.08801980f, 0.19596112f, 
    0.05349081f, 0.16954149f, -0.02424246f, -0.32458079f, -0.31835535f, 0.20640723f, 0.26661807f, -0.06671209f, 
    0.17843980f, -0.01439787f, -0.16177662f, -0.09024180f, -0.79858238f, -1.29316974f, -0.11653739f, -0.22845131f, 
    -0.04108639f, -0.14994651f, 0.04223508f, 0.13200088f, 0.19206806f, -0.00016231f, -0.02636305f, 0.12750554f, 
    -0.02351335f, -0.05502485f, -0.27662262f, 0.16405904f, 0.28854373f, 0.16886798f, -0.07347214f, -0.00848132f, 
    0.26984838f, -0.00133851f, -0.04595468f, 0.17555164f, 0.04859350f, 0.00200579f, 0.02976678f, -0.05045127f, 
    0.09543407f, -0.04709943f, -0.12050909f, 0.04190819f, 0.13377269f, 0.05078078f, 0.26654455f, 0.02959659f, 
    0.07238271f, 0.00568525f, -0.00205550f, 0.06333409f, -0.03807207f, -0.05498347f, -0.08235647f, 0.01085852f, 
    -0.04262098f, -0.01445605f, -0.00776866f, -0.01098854f, 0.05227890f, -0.08141600f, 0.04701729f, -0.08944689f, 
    0.03049306f, -0.03238617f, 0.05978796f, 0.06911279f, 0.02418391f, -0.01662038f, 0.06473448f, 0.07433079f, 
    -0.06855649f, 0.00577637f, 0.01566358f, -0.08451457f, 0.02759440f, -0.06900776f, 0.04631203f, -0.06104755f, 
    -0.06908093f, 0.00834247f, 0.06649716f, 0.01276926f, -0.08451724f, 0.04641104f, 0.03417476f, -0.05709074f, 
    -0.01046245f, -0.01058290f, -0.08568725f, 0.06089678f, -0.03043233f, 0.02263774f, -0.07904489f, 0.00490407f, 
    -0.01106088f, 0.03353559f, 0.05729975f, 0.07551167f, -0.03712410f, 0.03983643f, 0.03628328f, -0.06547177f, 
    -0.05545199f, 0.01172232f, 0.07386753f, 0.00823915f, 0.07685566f, -0.03822736f, 0.00497647f, 0.03728679f, 
    -0.08970440f, -0.08737569f, -0.05534577f, 0.00477995f, -0.08372339f, -0.03804101f, -0.07341248f, -0.07733127f, 
    0.01443760f, 0.05259921f, 0.00948662f, 0.04191124f, 0.05569028f, 0.06424819f, -0.04519382f, 0.00386505f, 
    0.02213317f, -0.05617364f, 0.06173496f, -0.02821685f, -0.00471960f, -0.07001579f, 0.00787069f, 0.04040493f, 
    -0.08661121f, -0.07882305f, -0.02483752f, 0.02825349f, -0.06877972f, -0.01194700f, -0.04088329f, 0.06199067f, 
    -0.06844701f, 0.06795793f, -0.03697395f, -0.06645212f, -0.07195163f, 0.02417608f, 0.00127822f, -0.05994372f, 
    0.02390998f, 0.00577105f, 0.03170628f, -0.02910721f, 0.02178821f, -0.03990727f, -0.00516462f, -0.07710035f, 
    -0.00747252f, 0.03443142f, -0.03671304f, -0.03965821f, 0.01515141f, 0.01759836f, -0.03262011f, 0.03040013f, 
    0.03965599f, 0.02881947f, 0.00809070f, 0.02937358f, -0.04626479f, -0.07114810f, -0.03483387f, -0.00203645f, 
    -0.06066548f, 0.02937666f, -0.03697855f, -0.00279210f, -0.05816178f, 0.07348784f, -0.04132906f, -0.08046536f, 
    -0.08931697f, -0.05242582f, -0.06968052f, -0.03922149f, -0.00568579f, -0.06587690f, -0.07446676f, -0.07844993f, 
    -0.11280304f, -0.23135856f, 0.38316399f, -0.09989559f, -0.15053646f, 0.04009763f, -0.13704562f, 0.02770460f, 
    0.31817323f, 0.39916185f, 0.26638347f, 0.03028626f, -0.14872013f, 0.21753328f, 0.19793582f, -0.05027177f, 
    0.07865212f, -0.19249234f, -0.47050047f, -0.02158965f, 0.49368352f, -0.13797796f, 0.12102214f, 0.36756206f, 
    0.01176375f, 0.28057036f, 0.48974553f, 0.22394858f, 0.21729530f, -0.08817519f, -0.42381081f, 0.14349149f, 
    -0.14368643f, 0.05439396f, 0.16407190f, -0.05301139f, 0.34810099f, 0.29082364f, -0.34792611f, 0.06380646f, 
    0.10214206f, -0.04171294f, 0.14472917f, 0.09392864f, -0.02133662f, 0.19563948f, 0.23770992f, -0.58498800f, 
    -0.07877219f, -0.00362635f, -0.20966458f, -0.02885868f, -0.15625292f, -0.10102484f, 0.01829752f, -0.35698521f, 
    0.11090169f, 0.08692241f, 0.23787661f, -0.23686580f, 0.17468379f, -0.07806538f, -0.02184087f, 0.13990033f, 
    0.03183141f, 0.38757962f, -0.00329265f, -0.03655123f, 0.22455381f, -0.08952998f, -0.23298025f, -0.09198891f, 
    0.15746419f, -0.00110194f, -0.00785383f, -0.16268249f, -0.11582743f, 0.08084893f, -0.03076457f, 0.13466012f, 
    0.11125574f, 0.28487125f, 0.01842301f, -0.22918259f, -0.25973642f, -0.24193223f, -0.07863392f, -0.25018620f, 
    0.07098854f, -0.12332938f, -0.11853961f, -0.24053115f, -0.21425337f, -0.05473797f, 0.32667091f, 0.32544991f, 
    -0.17644493f, -0.13838255f, -0.20840029f, -0.26544148f, -0.02452493f, -0.23396657f, 0.10260227f, -0.01145090f, 
    -0.06917503f, 0.00115912f, -0.08014326f, -0.16242847f, -0.07543718f, 0.22783278f, 0.19021593f, 0.35967642f, 
    0.00720404f, -0.16141659f, 0.05528201f, 0.05033184f, -0.08081806f, 0.01330458f, -0.09972280f, 0.10355636f, 
    -0.20122425f, 0.10305651f, 0.00354049f, -0.03816673f, -0.19760023f, -0.05830608f, 0.06935968f, 0.37386799f, 
    -0.07875308f, 0.05580518f, -0.22088555f, -0.03357049f, -0.10815098f, 0.00676714f, 0.15478697f, -0.02282112f, 
    0.25312087f, 0.19717225f, 0.02691586f, -0.09612515f, 0.08879894f, -0.00342578f, -0.02944179f, -0.14494774f, 
    -0.17137466f, -0.25034368f, 0.21128896f, 0.02309836f, 0.21155839f, -0.25873956f, -0.10627374f, 0.15513633f, 
    -0.02411420f, 0.43051940f, -0.07026088f, 0.04557231f, -0.00529642f, 0.14228782f, -0.00414253f, -0.03815445f, 
    0.25504279f, 0.04114177f, -0.47599939f, -0.13282782f, 0.05232851f, -0.30892661f, -0.04961873f, -0.02824278f, 
    -0.12838435f, 0.00654271f, -0.19385244f, 0.01913297f, 0.28042290f, 0.11424408f, -0.16997583f, -0.23069490f, 
    -0.01228081f, 0.31870633f, 0.16684817f, -0.21184054f, -0.07396944f, 0.00511445f, -0.33397809f, 0.36318669f, 
    0.32271656f, -0.02799329f, -0.18670474f, 0.03671233f, -0.05061595f, 0.25060630f, 0.03926382f, -0.10541354f, 
    0.05718965f, -0.06314535f, 0.17351362f, 0.42503712f, 0.05618532f, -0.03245459f, 0.34482443f, 0.13014977f, 
    0.28650683f, 0.46494702f, 0.04436779f, 0.02946704f, -0.10713793f, 0.15894859f, -0.11113723f, 0.14270443f, 
    0.08943710f, 0.38905105f, -0.38648582f, 0.11547672f, -0.08536817f, -0.00351733f, 0.01049787f, 0.07900009f, 
    -0.22854571f, -0.55342901f, -0.50580353f, -0.11201397f, -0.12040603f, -0.28641027f, 0.05461964f, -0.30791920f, 
    -0.07372168f, 0.00210869f, 0.18882720f, 0.22379272f, -0.15912572f, 0.05534308f, 0.03110332f, 0.09005652f, 
    -0.02538533f, 0.12090541f, 0.11931457f, 0.25460643f, -0.14748473f, 0.60093147f, -0.03059692f, -0.04964602f, 
    0.18014674f, 0.06801930f, 0.19373718f, 0.18965892f, 0.06279629f, -0.06757756f, 0.48969582f, -0.05022888f, 
    0.05274173f, 0.07796729f, 0.27339894f, -0.16944033f, -0.02652044f, -0.46227226f, -0.03932384f, 0.28316718f, 
    -0.15204312f, -0.28620732f, -0.04007575f, -0.47846276f, 0.06900228f, 0.08404491f, 0.26370719f, 0.23967899f, 
    -0.34849823f, 0.39622688f, -0.11263349f, -0.23635601f, 0.10630172f, 0.10447495f, -0.12247188f, -0.19220567f, 
    -0.43572611f, -0.10018846f, 0.05476680f, 0.19687894f, 0.01455415f, -0.04515148f, -0.07635786f, -0.33201066f, 
    -0.42843077f, 0.10068588f, -0.16928791f, 0.25451300f, -0.09677419f, 0.28472739f, 0.04628582f, 0.19491157f, 
    0.61972326f, 0.14407052f, 0.53435254f, -0.05244678f, -0.02177387f, -0.03886930f, -0.19249254f, -0.07816621f, 
    -0.21252050f, -0.30362359f, -0.04037254f, -0.00618701f, 0.10504146f, 0.03923552f, 0.14770314f, 0.22667129f, 
    -0.03930718f, 0.08964138f, 0.16588359f, 0.31390855f, 0.35809761f, 0.29145536f, -0.29056120f, 0.05720619f, 
    0.08687333f, -0.04728766f, 0.26660666f, -0.51771766f, 0.13564430f, 0.23299374f, 0.14354043f, -0.03285396f, 
    -0.07377020f, 0.16942778f, -0.29998931f, -0.16045772f, -0.41296461f, 0.02415134f, -0.44760758f, -0.00659778f, 
    -0.00763060f, -0.06766901f, -0.04455749f, -0.06447674f, 0.02192201f, -0.76407611f, 0.14058702f, -0.33674291f, 
    -0.15707403f, -0.10470967f, 0.02622433f, -0.35354108f, 0.23326737f, 0.00823593f, 0.34246209f, 0.06125546f, 
    0.16866560f, 0.18912679f, 0.01278867f, -0.39962944f, 0.02826205f, -0.02827148f, 0.06009173f, 0.38203770f, 
    0.16453673f, 0.18141340f, -0.05717877f, 0.15528502f, 0.24130665f, 0.08271041f, -0.12261774f, 0.18789482f, 
    -0.19171606f, 0.08992515f, -0.19493236f, 0.12438391f, 0.06977577f, -0.13939729f, -0.27983108f, 0.08174926f, 
    -0.13933234f, 0.28577396f, -0.44919565f, -0.30835348f, -0.17157166f, -0.06520329f, -0.05058268f, -0.20823257f, 
    -0.03028640f, 0.18339413f, -0.08044719f, -0.05208995f, -0.20096914f, 0.02225695f, 0.02144009f, -0.12209981f, 
    0.11703043f, -0.09042260f, 0.36472613f, -0.37112737f, 0.18187524f, -0.20495306f, 0.05618320f, -0.21707205f, 
    0.05238132f, -0.21401101f, 0.20443556f, 0.02900996f, -0.41344416f, 0.33428371f, 0.11022168f, 0.19838138f, 
    0.18252626f, 0.12024370f, 0.03411420f, 0.07434117f, -0.17975761f, 0.45524096f, -0.20294674f, -0.12347947f, 
    0.05463408f, 0.09838855f, -0.00234597f, 0.16227266f, 0.22574539f, -0.10555078f, -0.02632237f, 0.14504205f, 
    0.03818016f, 0.03950578f, -0.21469405f, -0.06040898f, -0.13994846f, -0.08354958f, -0.07919783f, -0.07295801f, 
    0.30043072f, -0.28438732f, -0.09540763f, 0.20917715f, 0.00382833f, -0.09536986f, 0.14349410f, 0.08799236f, 
    -0.00397807f, -0.05530090f, 0.00776967f, -0.07817405f, -0.00999014f, 0.05435058f, -0.06801219f, 0.02267366f, 
    -0.07154879f, 0.03664488f, 0.00066656f, -0.02275571f, -0.04210995f, 0.06170586f, 0.00080965f, 0.04910349f, 
    0.02176975f, -0.02818571f, -0.05525696f, -0.05872901f, 0.03780952f, 0.05201645f, -0.06914864f, 0.06829020f, 
    0.02258678f, -0.05007995f, 0.04755426f, -0.07608039f, -0.06753169f, -0.04243893f, 0.00194494f, -0.08983854f, 
    -0.06923373f, 0.00422468f, -0.08585026f, -0.00759708f, -0.07446102f, 0.00601720f, 0.00570891f, -0.01555901f, 
    -0.08437603f, 0.06590617f, 0.07259303f, -0.05622242f, 0.04966521f, 0.02289690f, -0.04810918f, 0.02147548f, 
    -0.06195040f, 0.07057421f, -0.03043831f, -0.02305193f, -0.00469030f, -0.03705098f, 0.00724471f, -0.07653017f, 
    0.01480551f, -0.05919968f, -0.04654006f, -0.07551306f, -0.00784030f, -0.01238989f, -0.06088030f, 0.05154770f, 
    -0.04896940f, -0.06490714f, -0.06027565f, -0.08104271f, 0.06138247f, -0.07708944f, 0.04637347f, -0.05911247f, 
    -0.06394310f, 0.04758490f, -0.06475032f, -0.03203833f, -0.01992510f, -0.00725379f, -0.02179646f, 0.06394985f, 
    0.01135115f, -0.08750329f, -0.06927519f, 0.00642686f, -0.01252527f, -0.03314771f, -0.06275718f, -0.07138512f, 
    -0.05770726f, -0.02639570f, 0.00230152f, 0.04181338f, 0.06765562f, 0.00087860f, -0.05198849f, -0.03581501f, 
    -0.06300031f, -0.01431727f, 0.03764535f, -0.03909273f, -0.04674167f, -0.05652753f, 0.05992755f, 0.07291295f, 
    0.03866078f, -0.05039851f, 0.03423415f, 0.03924605f, 0.04219768f, 0.04288296f, -0.06838672f, -0.02100424f, 
    0.04538263f, -0.05690393f, 0.07674015f, -0.04796810f, 0.02930260f, -0.01609698f, -0.02249572f, 0.05681200f, 
    0.02995815f, -0.03457206f, -0.08191378f, -0.06907133f, 0.01534664f, 0.05324878f, -0.05276652f, 0.03359393f, 
    -0.04008869f, -0.02426990f, -0.00963804f, -0.00331214f, -0.03927873f, -0.05592048f, -0.03429920f, 0.01106238f, 
    -0.06380551f, 0.01448159f, 0.00868372f, -0.05724588f, -0.06930348f, -0.01821363f, 0.06606559f, -0.01450004f, 
    0.15728965f, 0.07818833f, 0.28832212f, 0.10695466f, 0.15933093f, 0.20729122f, 0.04025795f, 0.06624759f, 
    0.12984855f, -0.06250907f, -0.21865468f, -0.60137218f, -0.01667200f, -0.05833615f, -0.15989520f, -0.16706720f, 
    0.20204689f, -0.00571594f, 0.20961154f, -0.03725319f, 0.13018818f, 0.20162942f, -0.24660574f, -0.26889566f, 
    -0.04207039f, 0.07922453f, 0.17510302f, -0.06643882f, -0.20410596f, -0.13572916f, -0.08898102f, -0.19827019f, 
    -0.10644550f, -0.44305745f, -0.14628622f, -0.32714808f, 0.28950071f, -0.06146334f, -0.31615162f, -0.09584758f, 
    -0.24462526f, 0.38708800f, 0.09357680f, -0.05262084f, 0.23728295f, 0.17523219f, -0.37886086f, -0.04872255f, 
    -0.46325633f, -0.19333522f, -0.13324165f, 0.02917019f, -0.15004385f, -0.07664772f, 0.39484903f, 0.04194603f, 
    0.12013891f, 0.08572704f, 0.16780743f, -0.23061922f, 0.01858582f, 0.35242093f, 0.00256402f, -0.10740419f, 
    -0.10946015f, -0.03320076f, 0.16063601f, 0.09376173f, 0.20410603f, 0.21483096f, -0.03893698f, 0.08593673f, 
    0.36703625f, 0.12398886f, 0.22869584f, -0.06878243f, 0.12562689f, 0.24790484f, -0.08352664f, 0.22683920f, 
    0.07257051f, 0.04070737f, -0.04120260f, -0.12682334f, -0.17602946f, -0.14930555f, 0.11830977f, -0.10144556f, 
    0.05244220f, 0.05050376f, -0.33854276f, 0.22661529f, -0.17126742f, 0.16431607f, 0.03032572f, 0.23404157f, 
    0.04595262f, 0.03590405f, 0.02967637f, -0.27026513f, -0.34193560f, 0.10080364f, -0.23731625f, 0.22377357f, 
    0.11714049f, -0.00692716f, -0.06965508f, -0.10082967f, 0.00570793f, -0.29647630f, 0.54142940f, -0.16852917f, 
    0.10134804f, 0.01636921f, -0.17885409f, 0.16577241f, 0.00005769f, 0.30085307f, -0.14735469f, 0.02803007f, 
    0.24057318f, -0.17266789f, -0.25434014f, 0.03466840f, 0.01835985f, -0.19809383f, 0.19651468f, 0.48274326f, 
    0.16812885f, -0.00626535f, -0.02891787f, -0.08045499f, -0.16609667f, 0.42362750f, -0.10995693f, 0.45461947f, 
    -0.30790570f, 0.39846194f, 0.10026725f, 0.00666357f, 0.13014574f, 0.13579728f, -0.21079327f, -0.17414205f, 
    0.13406296f, 0.15750839f, -0.17010467f, -0.05121482f, 0.09367269f, -0.05900895f, 0.08814887f, -0.08862182f, 
    -0.20742065f, 0.23664847f, 0.15586686f, -0.01342704f, -0.18680392f, -0.00957207f, -0.23050936f, -0.16185634f, 
    0.10302793f, -0.05217892f, 0.15123458f, 0.55864102f, -0.04403929f, -0.00771807f, 0.18168573f, -0.14780459f, 
    0.12426345f, 0.10516207f, -0.22114876f, 0.24710838f, -0.05203369f, -0.14453197f, -0.09756330f, 0.10909841f, 
    -0.02258830f, -0.01809969f, -0.03864492f, -0.25448945f, 0.03958450f, -0.30867073f, 0.18171740f, 0.13169654f, 
    -0.06013647f, -0.05008823f, -0.13783969f, -0.27758479f, -0.01058043f, -0.18934198f, -0.18770194f, 0.29874298f, 
    0.04650755f, 0.07457336f, 0.20596968f, 0.08156860f, -0.01777210f, 0.22451706f, 0.15773322f, 0.87077636f, 
    -0.43675447f, 0.16338246f, -0.21955244f, 0.12392377f, -0.12969348f, 0.07547785f, -0.03760029f, -0.00841199f, 
    0.17401557f, 0.10713670f, 0.09369990f, 0.16385682f, -0.10100107f, -0.04915397f, 0.30818132f, -0.23754714f, 
    0.04173094f, -0.57782906f, -0.43654057f, -0.02119647f, -0.22685741f, 0.05717671f, -0.16955176f, 0.01513313f, 
    0.15907218f, -0.52320129f, 0.41938701f, -0.00311677f, -0.17669705f, -0.19124492f, -0.03922890f, -0.18840596f, 
    -0.15495723f, -0.00135837f, -0.20221452f, -0.01407837f, 0.06777616f, 0.14869379f, -0.13346717f, 0.08153354f, 
    0.04290327f, 0.11982686f, -0.02999702f, 0.42805308f, -0.61417878f, 0.08081803f, 0.17773136f, 0.02154017f, 
    0.18804717f, 0.10792147f, -0.21616912f, 0.19661517f, 0.17188412f, -0.49561739f, -0.15158950f, -0.04589886f, 
    -0.17253600f, 0.17231575f, -0.05133098f, -0.12407114f, 0.13214621f, 0.09185173f, 0.31425208f, 0.14730121f, 
    -0.00692688f, -0.20685326f, 0.10135412f, 0.15395345f, 0.32393071f, 0.07984450f, -0.36841762f, -0.12962931f, 
    -0.17083919f, -0.05481956f, 0.12124052f, 0.18315050f, -0.06728543f, -0.20342180f, 0.02017173f, -0.03410323f, 
    0.34036690f, -0.15703693f, -0.27476981f, -0.09478291f, 0.30681333f, 0.01326323f, -0.03127829f, -0.13952908f, 
    0.33148909f, -0.39787883f, -0.08870860f, -0.22248189f, 0.17420609f, -0.05768388f, 0.24435337f, 0.12269533f, 
    0.09794363f, 0.23904359f, -0.75742787f, 0.11088858f, -0.10876977f, -0.07513779f, -0.11780442f, -0.22385824f, 
    -0.08933926f, 0.12981641f, 0.48330495f, 0.08460344f, -0.21104106f, 0.05959352f, -0.23226577f, -0.11926617f, 
    0.11480200f, 0.16714293f, 0.13487527f, -0.22381663f, 0.18772589f, 0.26104772f, 0.31559891f, 0.21544392f, 
    0.02389072f, -0.11124145f, 0.15855016f, -0.25366157f, -0.24937807f, -0.08283633f, 0.07934627f, -0.11786978f, 
    0.01532719f, 0.08481488f, -0.14958864f, -0.13660607f, 0.06167447f, -0.39055017f, 0.20805259f, -0.22670059f, 
    0.17494632f, 0.25231686f, -0.05191902f, -0.07932964f, -0.10535034f, 0.00357463f, 0.18955511f, -0.76015246f, 
    0.13074932f, -0.02550142f, 0.10856243f, 0.21036719f, -0.37150371f, -0.03501245f, 0.17416784f, 0.42383510f, 
    0.37735790f, 0.24991758f, 0.11681318f, -0.13224709f, -0.09152278f, 0.24424487f, -0.09030174f, 0.12835169f, 
    -0.12932405f, -1.23734808f, -0.12243262f, -0.11794687f, 0.16977763f, 0.12503506f, 0.06238047f, 0.04089998f, 
    -0.08180173f, 0.00045330f, 0.18270658f, -0.75317752f, 0.01653977f, 0.26076865f, 0.14359106f, 0.01269658f, 
    -0.03748202f, -0.13424619f, -0.65545112f, -0.08782614f, 0.10523111f, 0.13539006f, 0.09378948f, -0.05988704f, 
    -0.20199548f, 0.06406291f, 0.39265925f, -0.02142177f, 0.13793585f, -0.07741442f, 0.07026169f, -0.16516827f, 
    0.20827959f, -0.08900606f, 0.11679235f, -0.07859110f, 0.06365015f, 0.14190859f, 0.03572067f, -0.11967544f, 
    -0.05307877f, -0.05954459f, -0.54168063f, -0.03308317f, -0.16957749f, 0.92360049f, 0.18969128f, -0.16519488f, 
    0.23669472f, -0.02854959f, 0.02425209f, -0.13433598f, -0.30009678f, 0.01142364f, -0.48603210f, -0.19078554f, 
    -0.81429571f, 0.07367533f, 0.27998149f, 0.27307898f, 0.15389034f, 0.07953180f, -0.14701982f, -0.63573122f, 
    -0.09377398f, 0.03824845f, -0.00709686f, 0.03578147f, 0.02709003f, 0.06520272f, 0.09743398f, -0.03974355f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.34917808f, 0.04280493f, -0.01845381f, 0.03359619f, 0.16152914f, 0.02956415f, 0.03048496f, 0.46859300f, 
    -0.03773627f, -0.05642772f, 0.19417305f, -0.20504522f, 0.06908914f, 0.01327386f, -0.01188149f, 0.25033486f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.72938353f, 0.12430105f, 0.02901853f, -0.12420902f, -0.29523909f, -0.48086369f, 0.00759992f, -0.09500451f, 
    -0.21958578f, 0.18757747f, -0.55687767f, 0.01536529f, 0.10211013f, -0.02014801f, -0.29813689f, -0.28248984f, 
    0.28692460f, -0.19052951f, 0.07540719f, 0.12188911f, 0.26649377f, -0.11474262f, -0.11276409f, -0.44016683f, 
    -0.17065366f, -0.63937181f, 0.00040247f, -0.20393854f, 0.05829484f, 0.06333441f, 0.35351771f, 0.59377086f, 
    -0.40214530f, 0.18927020f, -0.23193160f, -0.23396194f, -0.77241087f, -0.02398184f, -0.05693832f, -0.41087121f, 
    -0.01335352f, 0.21766859f, -0.06437980f, 0.69559723f, -0.19719562f, -0.59992659f, -0.72226346f, 0.82342243f, 
    -0.31059128f, -0.47258955f, 0.07715243f, 0.09181453f, -0.86911631f, -0.06979049f, -0.05950144f, 0.84044003f, 
    0.06019608f, 0.53396469f, -0.14001942f, -0.64974135f, -0.01305975f, 0.06424301f, 0.32831469f, -0.15780614f, 
    0.05786802f, -0.45281443f, 0.18405500f, -0.10345295f, -0.55977887f, 0.87302715f, 0.05370793f, -0.11239257f, 
    0.15084799f, 0.26250952f, 0.19959392f, -0.02240981f, 0.11439828f, 0.26929465f, -0.57641774f, -0.32491329f, 
    0.07118499f, 0.17287694f, 0.19363479f, 0.06692813f, 0.67792469f, -0.07797539f, 0.14312759f, -0.37319526f, 
    0.11832035f, -0.77349657f, -0.10828134f, 0.18156843f, -0.12412398f, 0.23397695f, -0.07715165f, -0.43095076f, 
    0.02162306f, 0.66688067f, 0.16541506f, -0.16408587f, 0.16956256f, 0.33540311f, -0.21624842f, -0.13642807f, 
    0.04072792f, -0.16428776f, -0.52689487f, -0.47856855f, 0.15764888f, -0.15532143f, -0.05703388f, -0.62927246f, 
    -0.26325729f, -0.61773920f, 0.22550750f, 0.22910622f, -0.12839204f, -0.30268428f, -0.05931982f, -0.12108051f, 
    -0.22981529f, 0.78192711f, -0.55412883f, 0.70447993f, -0.00976605f, 0.51028448f, 0.10487177f, -0.36413798f, 
    -0.69184023f, 0.12865515f, -0.01195339f, 0.03294395f, 0.05041558f, -0.10919158f, 0.23779479f, -0.39989886f, 
    -0.19462147f, -0.26766759f, 0.73324001f, -0.40920705f, -0.18901913f, -0.99105179f, 0.98117584f, -0.38223246f, 
    0.45597291f, -0.55571657f, -0.02333791f, 0.18721767f, 1.02217460f, 0.28088227f, 0.15934539f, -0.31793958f, 
    0.20954093f, 0.43242738f, 0.10920218f, -0.14927676f, -0.01204924f, -0.17799686f, -0.41412976f, -1.07377744f, 
    -0.68209934f, -0.27414393f, 0.02859260f, -0.06229211f, -0.43246904f, -0.19648612f, -0.11750603f, 0.74244863f, 
    0.18361574f, -0.48915014f, 0.34743735f, 0.48971808f, -0.11823969f, -0.44254041f, -0.25267231f, 0.39421627f, 
    -0.30601516f, 0.39362052f, -0.05070566f, -0.02873557f, -0.57601947f, -0.79358602f, 0.15738639f, -0.25299671f, 
    0.09209658f, 0.10163896f, 0.20124266f, -0.42733476f, 0.24477047f, 0.36026135f, 0.26254204f, -0.24909787f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19062905f, -0.02762416f, -0.17978862f, -0.24742034f, 0.07708049f, 0.47059533f, -0.18740082f, -0.88404369f, 
    -0.89851487f, 0.20255025f, 0.46425268f, 0.25382161f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
