#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.86849254f, 0.58031821f, 0.67060417f, -0.56132126f, -0.25791317f, -0.93382734f, -0.20964262f, 0.85349792f, 
    -0.07894383f, -0.45386785f, 0.28441310f, 0.45681342f, -0.35048354f, 0.12153245f, -0.11621831f, 0.00081809f, 
    0.21611059f, -0.02875565f, -0.04073971f, 0.26615781f, 0.32271335f, 0.01700012f, -0.18213731f, 0.07492867f, 
    -0.53615028f, -1.21248198f, 0.50811481f, -0.01808031f, -0.07075968f, 0.56461394f, -1.03204274f, 0.93368250f, 
    -0.47660929f, -0.55514151f, -0.42367408f, -0.40433940f, 0.32162151f, 0.44250509f, -0.12378424f, -0.06301567f, 
    -0.01804896f, -0.37425044f, -0.00496692f, 0.11829603f, 0.01399435f, 0.10251366f, 0.04587729f, -0.08473824f, 
    0.00195562f, -0.05030363f, 0.58037108f, 0.40012106f, 0.89185065f, 0.76435220f, 1.05364728f, -0.54178637f, 
    -0.45606709f, -0.50235599f, -0.84898144f, -0.22291316f, 0.27266613f, 0.17645566f, -0.07997305f, 0.31826118f, 
    0.22155957f, 0.07583731f, -0.27724487f, 0.20649987f, 0.21354227f, 0.30534667f, 0.12035145f, 0.08987740f, 
    0.18938562f, 0.06796977f, 0.08326741f, -0.52061915f, -0.57507640f, 0.44385266f, 1.15215802f, 0.60195476f, 
    0.27809462f, 0.15523273f, 0.15616545f, 0.11918853f, 0.04241756f, 0.23555966f, 0.21152152f, -0.24325776f, 
    0.05244787f, 0.09786956f, 0.51600170f, 0.34195727f, -0.22530816f, -0.29215127f, -0.20601435f, -0.07347423f, 
    -0.18412293f, -0.34316200f, 0.08479957f, -0.17061131f, -0.34907806f, 0.28146350f, 0.58563089f, 0.61165380f, 
    0.77362162f, 0.51768214f, 0.57132149f, 0.79131508f, 0.06411465f, 0.09484679f, -0.38843566f, 0.01229319f, 
    0.47460651f, 0.40174422f, 0.31035256f, -0.17328095f, 0.02663158f, 0.37874958f, 0.26954472f, 0.40118006f, 
    0.04829439f, 0.15950641f, 0.01704504f, 0.30852422f, 0.11541384f, -0.90060639f, -1.06994462f, -0.87638795f, 
    0.11374883f, 0.15872937f, 0.56616080f, -0.06873488f, 0.21565071f, 0.31001827f, -0.06270384f, -0.21969996f, 
    0.11645211f, 0.10160327f, 0.29598364f, -0.20769517f, -0.30302677f, 0.21905276f, -0.07126003f, -0.17537621f, 
    0.14758787f, -0.29004270f, 0.01723507f, -0.00242546f, -0.30217573f, 0.07328877f, -0.28871393f, -0.75772268f, 
    0.09398904f, -0.76132560f, -0.54358244f, -0.46899286f, -0.07606754f, -0.49341649f, -0.36666939f, -0.16999787f, 
    -0.28087163f, -0.03736755f, -0.06889483f, 0.26822165f, -0.50020814f, 0.20129001f, -0.09619476f, 0.14320891f, 
    -0.14825936f, 0.19430235f, -0.32405987f, 0.10612915f, -0.02245548f, 0.25948822f, 0.02168300f, -1.54112458f, 
    0.67790127f, 0.96407497f, -0.29627576f, -0.15722230f, 0.60714024f, 0.81113553f, -0.10377279f, -0.11075947f, 
    0.01961961f, 0.04610680f, 0.06488903f, 0.22244190f, -0.38725978f, 0.07121979f, -0.14580332f, -0.25577599f, 
    -0.14932084f, -0.29713553f, -0.41128308f, 0.23408715f, 0.21679515f, 0.09171549f, 0.15758562f, 0.02959101f, 
    1.17216766f, -0.04082097f, 0.43080899f, -0.28696400f, 1.13322973f, 0.09686676f, 0.15467709f, 0.40246058f, 
    0.30680129f, -0.01274826f, -0.42060855f, 0.24121998f, -0.29063234f, -0.19919182f, 0.12158810f, -0.17539392f, 
    0.05298178f, -0.06702451f, -0.16308904f, -0.42212218f, 0.12878716f, -0.09505539f, -0.26582113f, -0.10512117f, 
    -0.20051606f, 1.33465576f, 0.95113236f, -0.06218482f, -0.11186650f, -0.26758999f, -0.24792498f, 0.80304754f, 
    -0.65990615f, -0.07385146f, 0.22815938f, 0.32261688f, 0.29922697f, 0.07855595f, -0.02728589f, -0.30039757f, 
    0.01662078f, 0.06990399f, 0.07173006f, 0.02563460f, 0.09025658f, -0.05015885f, 0.25629181f, 0.06776428f, 
    0.12968427f, -0.03760937f, -0.52889419f, -0.85612184f, 0.16335033f, 0.13401997f, -0.84578574f, -0.29710990f, 
    0.47081825f, 0.73707569f, -0.25552046f, 0.00798915f, -0.23931378f, -0.14728871f, -0.20849162f, -0.00183076f, 
    -0.39302269f, -0.23378865f, 0.16742432f, 0.02486062f, -0.13448285f, -0.29833314f, -0.11404401f, -0.01315256f, 
    0.04420720f, -0.29577762f, 0.17379224f, -0.61305529f, -0.54763448f, -0.75658149f, -0.29903728f, -0.69964838f, 
    0.54493982f, 1.06661558f, -0.23045576f, 0.50038034f, 0.60626233f, -0.10518326f, -0.06962488f, 0.44432500f, 
    0.16941279f, 0.04427565f, -0.04894745f, -0.21215083f, 0.18282419f, 0.19540820f, -0.32196280f, 0.20067099f, 
    -0.05522252f, 0.20915206f, 0.26708153f, -0.01074061f, 1.21098459f, -0.42748165f, -0.93304288f, -1.07299054f, 
    -0.12286998f, 0.00110838f, -0.67672229f, 0.36282662f, 0.21722125f, 0.25344884f, -0.58235228f, 0.01603394f, 
    0.08044297f, -0.17081793f, -0.35612413f, 0.03523159f, 0.08871229f, 0.04259597f, 0.10731463f, 0.07185000f, 
    -0.00504951f, 0.20776251f, 0.04111812f, 0.08759103f, 0.05835431f, -0.08889306f, 0.22718723f, -0.03762900f, 
    -0.21662702f, -0.15685634f, 0.63638824f, 1.21788812f, 0.60943222f, 0.60436952f, 0.81544089f, -0.04523073f, 
    -0.35451391f, -0.08000115f, -0.42763552f, -0.34716392f, 0.04124864f, 0.05592612f, -0.17094234f, 0.16840853f, 
    -0.08532674f, -0.13166495f, -0.48083976f, -0.31911492f, -0.29189083f, 0.01684744f, 0.83206117f, 0.69909966f, 
    0.60741228f, 1.16755497f, -0.01152704f, -0.35664451f, 0.26060730f, 0.51476294f, 0.14322339f, 0.01728100f, 
    -0.61516702f, -0.45477107f, -0.49633694f, 0.17831635f, -0.20522165f, -0.49613610f, 0.16638449f, 0.22206107f, 
    0.13925621f, -0.01537152f, 0.11295627f, -0.05154144f, -0.10088341f, 0.12177413f, 0.13358942f, -0.38205850f, 
    -0.78306609f, -0.80967456f, -0.28970888f, -0.59089828f, -0.44511533f, -0.55190444f, -0.05982600f, 0.03709092f, 
    -0.05413829f, 0.37632143f, 0.26333508f, 0.22932959f, 0.29931960f, 0.49454027f, 0.16395578f, 0.19720900f, 
    -0.01083136f, 0.30299833f, -0.00531582f, -0.01489063f, -0.37885290f, -0.14386635f, -0.25182214f, 0.05649177f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.41261199f, 0.32542440f, 0.20755163f, 0.27433324f, 0.40830821f, 0.10296017f, 0.11258418f, 0.01462300f, 
    0.22797342f, 0.14445299f, 0.16695186f, 0.12892655f, -0.06846441f, -0.12769841f, 0.08052095f, 0.28375384f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.37244362f, 0.16132249f, -0.33847970f, -0.05477881f, 0.16369322f, -0.00761946f, 0.16079511f, 0.07219264f, 
    0.02979421f, 0.10852813f, -0.20248824f, 0.22114141f, -0.00266702f, 0.12638251f, -0.29193592f, -0.02630451f, 
    0.17419130f, -0.00974609f, -0.05923148f, -0.22979042f, 0.06500849f, 0.07931216f, 0.27728155f, 0.22469422f, 
    0.04479515f, -0.01216013f, -0.04032375f, 0.20241386f, 0.10281759f, 0.03132406f, -0.05319291f, -0.00205739f, 
    0.02542472f, 0.34816232f, 0.16119234f, 0.29194427f, 0.25729230f, -0.23457341f, 0.23662360f, -0.20132726f, 
    -0.12121908f, -0.02057568f, -0.31926072f, -0.01433664f, 0.07347939f, -0.13095501f, -0.08125774f, 0.05467527f, 
    0.08306109f, 0.15223627f, 0.12475526f, -0.01725895f, 0.06604659f, 0.12083487f, 0.01135761f, -0.07523871f, 
    0.03125853f, 0.29051682f, 0.18311393f, -0.02326354f, -0.15371439f, 0.16661474f, 0.26295221f, -0.02999062f, 
    -0.09312812f, -0.00607285f, 0.18304506f, -0.04825287f, -0.06460214f, -0.04761818f, -0.18360730f, -0.15006687f, 
    -0.06313629f, 0.08332527f, -0.11857395f, 0.17247774f, 0.10443447f, -0.00397614f, 0.23624215f, -0.25420800f, 
    0.07320976f, -0.05874475f, 0.05660749f, -0.10324258f, -0.20369340f, -0.00228209f, -0.44182569f, -0.17180921f, 
    -0.07763021f, -0.02200164f, -0.03335021f, 0.24135555f, 0.06224569f, 0.10264255f, -0.14023711f, -0.25902164f, 
    -0.17056321f, -0.03855156f, 0.44676772f, -0.09406322f, 0.13912764f, -0.17282486f, -0.07159889f, 0.06352720f, 
    0.11741363f, -0.17576180f, -0.00517369f, -0.11131486f, 0.12076767f, -0.10913628f, -0.05774025f, 0.06922879f, 
    0.14477563f, 0.00749893f, 0.21826376f, -0.26751009f, 0.26623863f, -0.07498693f, 0.04628321f, -0.00453409f, 
    -0.02755838f, 0.03364877f, -0.13173760f, -0.08604050f, -0.03224790f, -0.01290136f, -0.04942451f, -0.01304118f, 
    0.13933100f, -0.18471989f, 0.05346939f, -0.06333107f, 0.12513794f, 0.05664422f, 0.18394743f, 0.36267325f, 
    -0.11671930f, -0.00340526f, 0.18537202f, 0.11443539f, 0.05319422f, -0.13622116f, 0.30663291f, -0.20345567f, 
    -0.58939791f, -0.08424012f, -0.25076318f, 0.01296786f, 0.06037035f, -0.14120287f, 0.07338408f, -0.23751265f, 
    0.21930772f, -0.14700176f, 0.15025845f, -0.18013884f, 0.41615260f, 0.13592634f, -0.06481141f, 0.05402355f, 
    -0.16930296f, -0.06539523f, -0.15724705f, 0.19183849f, -0.27565598f, -0.08158101f, -0.06351116f, -0.03848974f, 
    -0.08326211f, 0.14407156f, 0.02474150f, -0.26763842f, 0.27214286f, 0.12101160f, -0.16153875f, 0.02722149f, 
    -0.06085436f, -0.03357968f, -0.00808386f, -0.10628766f, -0.02404290f, 0.12999833f, 0.17987309f, -0.06514377f, 
    0.38075572f, 0.04884955f, -0.11220121f, 0.03511843f, -0.04239964f, 0.19017272f, 0.11796436f, 0.19186579f, 
    0.04667613f, -0.06158681f, 0.01021861f, 0.04359186f, -0.06350526f, 0.04435190f, 0.03529593f, -0.08241533f, 
    0.00901320f, 0.00972008f, -0.04256940f, -0.06156676f, 0.04758070f, -0.04181273f, -0.01034918f, -0.04420287f, 
    -0.08383844f, -0.00647856f, 0.00737337f, 0.05577816f, -0.04011063f, 0.00216241f, 0.04410959f, 0.03498423f, 
    -0.03971432f, -0.07685524f, -0.01589139f, -0.03363236f, 0.05454490f, 0.06417610f, 0.04856317f, -0.06604526f, 
    -0.03849035f, -0.02900238f, 0.02787472f, -0.06091629f, 0.00527933f, -0.00617398f, 0.00522483f, -0.05618629f, 
    0.06463622f, 0.01624880f, -0.05024330f, 0.05852683f, -0.00491532f, 0.03196557f, -0.06660635f, -0.00325940f, 
    -0.04349084f, -0.03081905f, 0.00445702f, -0.06922300f, -0.07339448f, 0.05488664f, 0.04514984f, 0.00158934f, 
    0.02274477f, -0.03017471f, -0.03067098f, -0.07706843f, -0.02488208f, 0.05249037f, 0.06516139f, -0.00497073f, 
    -0.00861021f, 0.04054828f, 0.04227669f, -0.07339800f, -0.06420070f, -0.06757963f, -0.07269511f, -0.00861144f, 
    0.00414415f, 0.01059110f, 0.02558730f, -0.00257020f, -0.04502321f, 0.02216175f, 0.00080349f, 0.06082296f, 
    -0.07143598f, 0.04302897f, -0.03969686f, -0.06602918f, -0.01421420f, 0.00303154f, -0.00975471f, 0.03824005f, 
    -0.06738373f, 0.03416305f, -0.06455516f, 0.02360703f, -0.01854983f, -0.07402959f, -0.05790020f, -0.08123937f, 
    -0.03880106f, 0.04938620f, 0.00966828f, 0.00925697f, 0.04662275f, -0.01336799f, -0.00626895f, 0.02736669f, 
    -0.07654209f, -0.05757235f, -0.07474431f, 0.05134173f, 0.04871725f, -0.03786409f, -0.06008454f, 0.03251128f, 
    -0.03949615f, 0.01459920f, 0.01663409f, 0.02391522f, -0.04558124f, 0.00419217f, -0.02975869f, -0.05327220f, 
    -0.05576564f, -0.05088484f, 0.01452846f, -0.00703991f, 0.05783267f, 0.03026804f, 0.04160684f, 0.05030448f, 
    -0.06462291f, -0.06366937f, 0.05483098f, 0.02081320f, -0.06159415f, 0.02964279f, 0.00196659f, -0.05453250f, 
    -0.03958373f, -0.03410861f, -0.05301790f, -0.01553787f, 0.04457890f, -0.07543730f, 0.02242007f, 0.00601366f, 
    -0.04981456f, 0.02111458f, -0.06365877f, 0.01950099f, 0.02720715f, -0.03820222f, 0.04708603f, -0.00982092f, 
    -0.03588874f, 0.04558797f, 0.03843610f, -0.03252271f, -0.03166675f, 0.06408452f, 0.00827008f, 0.03586764f, 
    0.05911089f, -0.01322844f, -0.06526865f, 0.02111972f, -0.06441836f, -0.02037834f, 0.00407306f, 0.01626879f, 
    0.03032952f, -0.04917351f, 0.02102375f, -0.00029642f, -0.00851876f, 0.01489956f, 0.00715007f, -0.02597124f, 
    0.05312881f, 0.05809828f, 0.03451136f, -0.03759672f, -0.07053751f, -0.03118046f, -0.06313360f, 0.04193298f, 
    0.04044448f, -0.08419418f, -0.00397788f, -0.01143820f, 0.04938645f, 0.04705426f, -0.01460126f, 0.02001054f, 
    -0.08701368f, 0.07506444f, -0.03480201f, -0.13771395f, -0.26197049f, -0.12353963f, 0.10727210f, 0.17292282f, 
    0.08516710f, 0.00042014f, -0.09846630f, -0.06840443f, -0.23247878f, 0.33250657f, 0.08660717f, -0.02790940f, 
    -0.02449108f, -0.05704483f, 0.12608081f, 0.16359030f, -0.10733899f, -0.04775270f, 0.07837316f, -0.04532065f, 
    -0.09005732f, 0.04657405f, 0.15237384f, 0.23654535f, 0.26627406f, 0.05290512f, -0.09636807f, -0.09936375f, 
    0.07329013f, -0.10759079f, -0.08552390f, -0.16413559f, 0.01750690f, 0.46559533f, -0.01438900f, -0.15962687f, 
    0.03541900f, 0.12105202f, 0.15362625f, 0.06964824f, -0.04404486f, 0.15661666f, 0.06286015f, 0.03299023f, 
    -0.05055850f, 0.17599237f, -0.13953686f, -0.03348850f, -0.03233863f, 0.09571214f, 0.20055214f, 0.06677586f, 
    -0.15709551f, -0.15153058f, 0.00842004f, 0.07425848f, 0.11521220f, -0.10661376f, -0.52554303f, 0.27361518f, 
    0.01714483f, -0.10801123f, -0.06128566f, -0.03739477f, 0.06636090f, 0.06143048f, 0.16757068f, 0.15959910f, 
    0.07894937f, 0.03480142f, -0.00922020f, 0.01981724f, -0.04885868f, 0.10464417f, -0.14868970f, 0.42100376f, 
    0.07515523f, 0.15855896f, 0.14618346f, 0.15454680f, 0.04263386f, 0.26491562f, 0.04086727f, -0.31177139f, 
    -0.06617970f, 0.08392697f, 0.09902004f, 0.18073012f, 0.02160844f, 0.24038304f, 0.09109346f, 0.17938621f, 
    -0.05834203f, 0.11417920f, -0.11037780f, -0.05644986f, 0.17230977f, 0.14328520f, 0.12741908f, -0.02052316f, 
    0.25719571f, 0.11935265f, 0.15570982f, 0.15860969f, 0.43810722f, 0.13806881f, 0.24003127f, -0.22988315f, 
    -0.01119003f, -0.09634840f, 0.01389818f, -0.02361858f, 0.06521498f, 0.01081643f, -0.07438592f, -0.01495259f, 
    -0.35501894f, 0.30966800f, -0.16565253f, -0.07859731f, -0.07268053f, -0.11234502f, -0.02532789f, 0.07185715f, 
    -0.15923759f, 0.31685987f, 0.17498337f, 0.21099758f, -0.35836563f, -0.15904592f, -0.15938270f, -0.02280180f, 
    0.21016091f, 0.01575518f, -0.36171213f, 0.15868390f, 0.06124380f, -0.03403635f, -0.25656947f, 0.03312533f, 
    0.03024137f, -0.01957714f, -0.02214219f, 0.11995423f, -0.13515662f, -0.18244533f, 0.19224265f, 0.05877724f, 
    -0.10476545f, 0.12097955f, -0.06664547f, 0.11243436f, -0.42702723f, -0.26104650f, 0.04762332f, 0.16290060f, 
    0.16041319f, -0.19776617f, 0.27905130f, 0.34241551f, -0.05938914f, 0.18672220f, 0.08838671f, 0.05127472f, 
    -0.11340538f, 0.24967034f, 0.05888298f, -0.17933285f, -0.04251223f, 0.16210242f, 0.11343189f, 0.14931552f, 
    0.13115448f, 0.16129448f, 0.06149644f, 0.14747038f, -0.06510621f, -0.21849236f, -0.27590179f, 0.03966866f, 
    -0.07168282f, 0.04804723f, 0.04990892f, 0.15729208f, 0.15424332f, 0.14878651f, -0.08101381f, -0.04535330f, 
    -0.19206277f, -0.10382409f, -0.01902840f, 0.10005011f, -0.21385112f, -0.07590251f, 0.05532778f, 0.15591729f, 
    0.14887907f, 0.06212163f, 0.17409125f, 0.07230599f, -0.05888257f, -0.08095161f, 0.09721171f, 0.19183950f, 
    0.08364093f, -0.09010195f, 0.20675345f, 0.18373162f, 0.08242054f, -0.01432892f, 0.08969070f, 0.04386197f, 
    -0.04820567f, 0.33780223f, 0.19389142f, -0.12478036f, -0.06033807f, -0.04769692f, 0.08325980f, 0.10283832f, 
    0.06308101f, -0.15723325f, 0.01695431f, 0.21591483f, -0.33808330f, 0.37334418f, -0.28237656f, 0.17430620f, 
    0.16578129f, -0.03026165f, 0.09719815f, 0.17618899f, 0.13080513f, -0.04008768f, -0.00518771f, 0.04529721f, 
    -0.11773691f, 0.17344654f, -0.21992058f, -0.04806847f, 0.07393203f, 0.02800306f, 0.02887195f, 0.08050684f, 
    0.07840963f, 0.04217943f, -0.05341370f, 0.03647736f, -0.26557952f, -0.10805710f, -0.30773538f, -0.01968764f, 
    0.13000369f, -0.03722041f, 0.00955160f, -0.11187845f, 0.03675944f, 0.01039791f, -0.04013572f, 0.07955553f, 
    0.12962829f, -0.14092143f, 0.16689736f, -0.01838802f, -0.15857355f, -0.06469683f, 0.12261073f, 0.30008531f, 
    -0.02630529f, 0.00862237f, 0.03361778f, 0.21537796f, -0.26713598f, 0.06915376f, 0.32700634f, -0.04419062f, 
    -0.17274047f, -0.00383211f, 0.08123332f, -0.06498841f, -0.01270251f, -0.07992682f, 0.12806836f, 0.17416006f, 
    0.40292558f, -0.00066780f, 0.11839907f, -0.07143293f, 0.04380850f, 0.05753852f, 0.01649592f, 0.10185342f, 
    0.09375290f, -0.07503359f, 0.04739680f, -0.01856561f, -0.42012635f, -0.10297673f, 0.21614887f, -0.03234145f, 
    -0.01783848f, 0.07366218f, -0.07726204f, 0.05462117f, 0.14021823f, -0.03493206f, 0.01067162f, -0.10111617f, 
    -0.20452183f, 0.12048694f, -0.09749964f, -0.14181761f, 0.09172338f, 0.07715341f, -0.00760269f, 0.10845686f, 
    0.02532005f, -0.02135825f, 0.00502086f, 0.14172219f, -0.32571509f, -0.04659662f, -0.26021755f, -0.39370841f, 
    0.03780247f, 0.01791955f, -0.05032456f, 0.07624739f, 0.13688417f, 0.15693898f, 0.01360298f, 0.09098285f, 
    0.19187391f, -0.41748145f, 0.22257991f, -0.13327646f, -0.06325000f, 0.14531279f, 0.20401958f, -0.14884506f, 
    0.01535252f, -0.04275939f, 0.03691912f, 0.10270499f, 0.02794116f, -0.11022308f, -0.09944045f, -0.05869154f, 
    0.11656486f, 0.10383514f, -0.02284126f, -0.12090340f, 0.06126836f, -0.04132614f, 0.06452136f, 0.19418988f, 
    0.01745220f, 0.15201968f, 0.16316061f, 0.34592900f, -0.09548428f, 0.08190375f, -0.06003781f, 0.08848075f, 
    0.05133657f, -0.06303418f, -0.01424080f, 0.06466766f, -0.24664569f, -0.23327518f, -0.11919325f, 0.18920621f, 
    0.21799882f, 0.03129905f, 0.08353736f, 0.19007057f, 0.07345694f, -0.13359414f, -0.02968649f, 0.10265016f, 
    -0.06661746f, -0.00691324f, -0.06445079f, 0.05061481f, -0.00829775f, 0.00060548f, -0.02024297f, -0.01611664f, 
    -0.04461315f, 0.00157672f, -0.04785549f, 0.01895919f, 0.04624057f, 0.03171449f, 0.03477849f, -0.07047339f, 
    0.06481274f, -0.05983238f, -0.05924606f, -0.01793230f, -0.02280082f, -0.01138490f, 0.02196413f, -0.03832336f, 
    0.03659325f, -0.01765665f, -0.07771210f, 0.02908690f, -0.01834623f, -0.02955024f, -0.06146896f, 0.02479790f, 
    0.01391237f, -0.00121172f, -0.03520414f, -0.04467075f, -0.02813848f, 0.05216416f, 0.04313735f, -0.00317742f, 
    0.03682343f, 0.06108548f, -0.04964187f, 0.04279837f, -0.02858969f, -0.00882113f, 0.00248597f, -0.07700591f, 
    -0.01529378f, -0.05333871f, -0.01589732f, -0.06980357f, -0.06595734f, 0.05141542f, 0.00409257f, -0.06295963f, 
    -0.05366921f, -0.04058665f, -0.00918580f, -0.02904785f, 0.01152712f, -0.05119873f, 0.04288851f, 0.06104920f, 
    -0.05769590f, 0.03917039f, 0.04149691f, -0.02354494f, -0.04410522f, -0.07184404f, -0.04895376f, -0.01068493f, 
    -0.04666447f, -0.04974984f, 0.03182512f, -0.05736983f, 0.03239761f, 0.05284109f, -0.01797235f, -0.01960572f, 
    -0.01485783f, -0.03595124f, -0.01487471f, -0.05248562f, -0.04165841f, -0.04562572f, 0.00951438f, -0.03137070f, 
    0.03581656f, 0.00009981f, 0.00041939f, -0.03846071f, -0.02283370f, -0.00753514f, -0.07096399f, -0.00460009f, 
    -0.04135893f, -0.07496966f, -0.05170159f, 0.03983852f, 0.00960737f, -0.00745165f, 0.05242037f, -0.05501236f, 
    0.05577757f, 0.02088487f, 0.02092466f, -0.01597882f, -0.01123190f, -0.05269508f, -0.06180101f, -0.00875937f, 
    0.03278405f, 0.04796064f, -0.04003666f, 0.06343128f, -0.00192653f, 0.05578046f, -0.02877783f, -0.06309207f, 
    0.05863156f, 0.02885718f, 0.01728565f, 0.04316223f, -0.05817011f, -0.00607385f, 0.02600035f, 0.04517758f, 
    0.05944617f, -0.04552959f, -0.01240725f, -0.07613911f, -0.07637845f, -0.03085491f, 0.03330802f, -0.05400473f, 
    0.03089040f, -0.07252250f, -0.04052007f, -0.07398840f, -0.03071854f, 0.05222541f, 0.04280527f, -0.03467633f, 
    -0.01371199f, -0.06618287f, -0.02968911f, -0.01030425f, -0.01768237f, 0.02555425f, -0.00002990f, 0.02142050f, 
    -0.01698566f, -0.03537853f, -0.03901117f, -0.03853947f, -0.02485751f, -0.00112026f, 0.03203105f, -0.03802919f, 
    -0.02034016f, -0.00447601f, -0.04674225f, -0.07657049f, -0.05770678f, 0.01648104f, 0.01585963f, -0.07564586f, 
    0.02951151f, 0.03735530f, 0.01373088f, 0.02063736f, -0.01267208f, 0.02264971f, -0.05479061f, 0.06094892f, 
    -0.01656811f, -0.05738557f, -0.05162510f, -0.02304192f, -0.01117588f, -0.02159843f, -0.06692900f, 0.05389487f, 
    0.01259331f, 0.03729450f, 0.05153184f, 0.03909212f, -0.03050443f, 0.00774335f, 0.04064451f, -0.01063536f, 
    0.54584688f, -0.06961725f, 0.15825781f, -0.10216413f, 0.03410357f, 0.14470570f, 0.18326949f, -0.04196648f, 
    0.09874634f, 0.12331437f, -0.05677193f, 0.16516675f, 0.13233563f, -0.10446445f, 0.09896459f, 0.42582089f, 
    0.01371688f, -0.10112221f, 0.14636852f, 0.05794708f, -0.07497002f, 0.08435204f, 0.13078564f, 0.16142188f, 
    -0.16943340f, 0.05262715f, -0.13237163f, -0.36786270f, 0.16371630f, -0.12945858f, 0.04775200f, 0.03687178f, 
    -0.01223186f, 0.17225687f, 0.09767769f, 0.14501287f, -0.11098317f, 0.23649999f, 0.03100050f, -0.43978736f, 
    0.05224453f, -0.13953683f, -0.07143337f, 0.18634452f, 0.01608738f, -0.04038819f, 0.01924523f, 0.08819814f, 
    0.16296794f, 0.00974956f, -0.06900780f, -0.30868071f, 0.14370491f, -0.01349512f, -0.01728941f, 0.13239846f, 
    -0.15352379f, 0.08834626f, 0.10701376f, -0.05256634f, -0.02904841f, 0.03906560f, 0.14987244f, 0.19289945f, 
    0.04749089f, 0.01327134f, 0.18803670f, -0.09727541f, 0.05443949f, 0.04786196f, -0.01045238f, 0.08903524f, 
    0.16322185f, 0.02602655f, 0.00645409f, 0.20559207f, 0.03639789f, 0.16389003f, 0.16949496f, -0.05139359f, 
    0.00501596f, -0.04371213f, 0.16125378f, 0.09699100f, -0.15412422f, -0.02393227f, -0.17770433f, -0.16195747f, 
    0.05011012f, 0.09626469f, -0.12798344f, 0.02060783f, 0.05425544f, 0.15395305f, -0.11864997f, 0.08678883f, 
    -0.11868370f, -0.11826991f, -0.09785511f, 0.00009182f, 0.05125733f, 0.05563116f, -0.00785703f, -0.14854635f, 
    0.09709060f, -0.08120980f, 0.12558098f, 0.01246577f, -0.55206865f, -0.41459578f, -0.08824975f, 0.21769692f, 
    0.31672788f, 0.13823213f, -0.04783592f, -0.07053911f, 0.24369082f, 0.01394728f, -0.09753998f, -0.11161764f, 
    0.13480332f, 0.10109606f, 0.08877324f, 0.00864598f, 0.18308319f, 0.13402766f, 0.07111014f, -0.06975325f, 
    -0.08844690f, 0.10426287f, 0.20292696f, 0.10444662f, -0.32161257f, -0.03876488f, 0.04257325f, 0.38682088f, 
    -0.12523024f, 0.14303595f, 0.22151820f, 0.16873613f, 0.14621437f, 0.04817623f, 0.13517797f, -0.10106422f, 
    -0.22681782f, 0.38368073f, -0.31778103f, 0.76249927f, -0.11554423f, -0.01856088f, -0.09453077f, -0.04980044f, 
    0.18812867f, -0.00839439f, -0.08520323f, -0.12301680f, 0.03340351f, 0.06952339f, -0.08107481f, -0.03862921f, 
    -0.19471204f, -0.12259336f, 0.11162821f, 0.03185693f, -0.14208356f, -0.17057876f, 0.00062755f, 0.02497976f, 
    -0.19597599f, -0.08486932f, 0.13011770f, -0.53902346f, 0.18363492f, 0.11631709f, -0.13764119f, -0.12097468f, 
    0.00453306f, 0.01600688f, -0.01259351f, -0.03191482f, 0.06554461f, 0.14381871f, -0.08997179f, -0.18676241f, 
    0.18416771f, 0.11481686f, 0.08431516f, 0.04892268f, 0.09364045f, -0.04051932f, 0.02044630f, -0.00222559f, 
    -0.09196048f, 0.36851659f, 0.10938847f, -0.09103452f, 0.17543124f, 0.11476319f, 0.12482040f, 0.05985386f, 
    -0.04780012f, 0.03245282f, 0.04361998f, 0.13143322f, 0.04156454f, 0.50699711f, 0.13552950f, 0.00788027f, 
    0.24091506f, 0.20679428f, 0.06361787f, 0.18651664f, -0.09815629f, 0.07462282f, -0.08712018f, 0.03048374f, 
    -0.35178700f, -0.01309980f, 0.18785281f, -0.26390973f, 0.25244907f, 0.23679578f, -0.01403736f, -0.06264704f, 
    -0.01970594f, -0.19081344f, -0.01921005f, -0.07655481f, 0.38646016f, -0.14866708f, 0.07360438f, 0.02678352f, 
    -0.06081124f, 0.07431551f, 0.03217203f, -0.09321795f, 0.07017734f, -0.09025323f, 0.18551295f, -0.11389596f, 
    -0.20416144f, -0.26944304f, -0.06169410f, -0.11482030f, -0.08587568f, -0.16787212f, -0.00404012f, 0.07472906f, 
    -0.06034297f, -0.14233369f, -0.00081119f, 0.14848006f, 0.49940827f, 0.25965238f, -0.17608491f, -0.08528381f, 
    -0.22462989f, -0.11904201f, 0.10443629f, 0.06438155f, 0.06229944f, 0.03826399f, 0.12584299f, 0.00617894f, 
    0.20372723f, 0.17321621f, -0.20761444f, -0.32106847f, 0.00342823f, 0.21885353f, -0.05052072f, 0.03555837f, 
    0.01594702f, 0.14550690f, 0.03599781f, -0.06282630f, 0.27290538f, 0.08488847f, -0.08884909f, 0.02874984f, 
    0.00797388f, -0.11125398f, -0.06496820f, 0.09480204f, 0.09688859f, -0.02273060f, 0.02230384f, 0.12526838f, 
    -0.46400613f, -0.04161730f, 0.01918583f, -0.25401080f, 0.06560880f, 0.00626947f, 0.01068573f, 0.05469308f, 
    -0.13144451f, 0.10502901f, 0.05302010f, 0.17421225f, -0.57726592f, -0.10083563f, -0.08545091f, 0.12893812f, 
    -0.02513297f, 0.06368116f, 0.06763357f, 0.16569833f, -0.20012406f, 0.11570346f, 0.04983417f, 0.06725428f, 
    0.35892558f, -0.15367936f, 0.05386746f, -0.29623830f, -0.08235522f, 0.09609316f, -0.02770257f, 0.10704739f, 
    0.00484435f, 0.15173174f, 0.01393305f, 0.03231468f, 0.64168340f, 0.15787661f, 0.02588523f, -0.03250210f, 
    -0.17413871f, -0.17106648f, -0.11058211f, -0.15556581f, -0.00574939f, 0.08172210f, 0.09090731f, 0.14777753f, 
    -0.20676455f, 0.01743411f, 0.08713388f, 0.19672923f, 0.08101882f, 0.06600536f, 0.21067792f, 0.16306455f, 
    0.01749096f, 0.13793138f, -0.05813985f, 0.16605650f, -0.21567732f, -0.19939035f, -0.18498465f, 0.06397212f, 
    -0.15920201f, -0.06970055f, 0.08598120f, 0.09492929f, 0.17269342f, -0.14174441f, 0.01689427f, -0.07207423f, 
    -0.51919198f, -0.37720853f, -0.15680458f, -0.08660374f, 0.05842568f, 0.06700003f, 0.17325045f, 0.03627514f, 
    -0.08947909f, 0.12203209f, -0.09521972f, 0.24722500f, 0.23600513f, -0.01610612f, -0.00865107f, -0.16173463f, 
    -0.19018053f, -0.00931401f, 0.10358215f, 0.07921364f, 0.01980059f, 0.13228810f, 0.02763292f, -0.01004440f, 
    0.19085512f, -0.23769216f, 0.20070338f, 0.29379556f, -0.02664008f, 0.05348883f, -0.14459595f, -0.16901572f, 
    0.02462887f, -0.06742494f, 0.03993488f, -0.25633305f, 0.09809452f, -0.27116776f, 0.32601577f, 0.33365571f, 
    0.07335383f, -0.16583578f, 0.06254897f, 0.08697854f, 0.01965430f, 0.05233837f, 0.01193974f, -0.06718235f, 
    0.23595145f, 0.12517111f, -0.14684115f, -0.40293282f, -0.02432636f, -0.02652161f, 0.03337542f, -0.01883199f, 
    -0.09426239f, -0.10678551f, -0.07813812f, -0.03265632f, 0.08497476f, 0.28069451f, 0.09456199f, -0.43726292f, 
    0.09484451f, 0.13718963f, 0.19668357f, 0.14871123f, 0.01440700f, 0.17687386f, 0.05785194f, -0.06384832f, 
    0.16758950f, -0.24700178f, 0.02041669f, -0.09334505f, 0.06896137f, 0.05877780f, 0.02175975f, -0.00321699f, 
    -0.09037742f, -0.19028345f, -0.22870007f, -0.03641864f, -0.00359466f, -0.20893659f, -0.05864615f, 0.18803784f, 
    0.14924300f, -0.00055706f, 0.06822659f, -0.05575098f, 0.04601483f, 0.09123234f, 0.18048911f, 0.25255126f, 
    0.07902624f, 0.02698999f, -0.04492531f, 0.24263486f, -0.07800815f, 0.18746334f, -0.13423504f, 0.20653999f, 
    -0.08222121f, 0.10922780f, 0.00654206f, -0.00360657f, 0.36356464f, -0.31088695f, 0.12449670f, 0.09509846f, 
    0.15450199f, 0.17608190f, -0.00574276f, -0.03670775f, -0.09758285f, 0.18614060f, 0.02282670f, 0.34222052f, 
    0.03550640f, 0.10453707f, -0.29723197f, 0.05875538f, -0.11282983f, 0.05003029f, 0.15663625f, -0.00734561f, 
    -0.03431996f, 0.02821907f, 0.19978862f, 0.05332487f, -0.19247846f, 0.23979025f, 0.03895722f, 0.29164311f, 
    0.18288831f, 0.16386889f, -0.19477056f, 0.05745842f, -0.07456810f, 0.10686900f, -0.02529749f, 0.01970554f, 
    0.08867368f, 0.04084525f, -0.00965211f, 0.05768053f, 0.27555996f, 0.19198330f, 0.12240316f, -0.07184836f, 
    -0.12552768f, 0.23723070f, 0.21863982f, 0.20495324f, -0.44847620f, -0.05142908f, 0.02142301f, 0.07802710f, 
    0.05172785f, 0.16561279f, -0.14906944f, -0.00726734f, 0.06815024f, 0.06781919f, -0.15872386f, 0.02031364f, 
    0.20798363f, 0.54520315f, -0.20295604f, 0.60645795f, -0.06016805f, -0.00033678f, -0.03557414f, 0.15604362f, 
    -0.07959253f, 0.18896671f, -0.14322388f, -0.03032475f, -0.46396330f, -0.23024869f, 0.02995749f, 0.02083627f, 
    -0.00798708f, -0.18733883f, 0.26917356f, -0.00447889f, 0.06431108f, 0.04977371f, 0.02121260f, 0.04115698f, 
    -0.00980150f, 0.26836619f, 0.27950907f, -0.35690930f, -0.05087225f, -0.02679458f, 0.12257925f, -0.04082972f, 
    0.09867314f, 0.12299729f, -0.09475549f, 0.17697041f, -0.04448532f, 0.00658316f, -0.20233883f, 0.12996413f, 
    0.03042242f, 0.14321168f, 0.02399463f, -0.10475370f, 0.14830841f, -0.14855820f, -0.16930954f, -0.22520933f, 
    -0.43457794f, -0.21569598f, -0.22190793f, 0.19645257f, 0.09253680f, -0.11241768f, -0.13927023f, 0.09419207f, 
    0.05724850f, 0.18684478f, 0.01202260f, 0.07840642f, 0.48004407f, -0.27610040f, -0.38080692f, -0.24673195f, 
    -0.00262452f, -0.00062122f, -0.04808411f, 0.03911619f, 0.03174141f, 0.17851935f, 0.08549217f, -0.15273128f, 
    0.50648218f, 0.34917963f, 0.03531757f, 0.20370443f, -0.30406117f, 0.12750976f, 0.05391680f, -0.10659882f, 
    -0.03189275f, 0.08521722f, 0.06926730f, 0.19752352f, 0.14183076f, 0.11090688f, -0.06399553f, 0.24012534f, 
    0.17536765f, 0.12109945f, -0.12777187f, -0.20659773f, 0.05329745f, -0.03064970f, 0.10379390f, 0.07854418f, 
    0.06109560f, 0.11285190f, 0.16106302f, 0.09212694f, 0.02405700f, 0.11380998f, -0.17882073f, 0.02523740f, 
    0.03574586f, -0.00066147f, 0.12337773f, 0.11722346f, -0.09695692f, -0.33971575f, -0.06363285f, -0.15894631f, 
    0.20362575f, 0.15775807f, -0.09382407f, 0.16485611f, -0.16022724f, 0.14923768f, -0.10812365f, -0.18899520f, 
    -0.43394166f, -0.26930949f, -0.27061617f, -0.23692536f, 0.04585757f, 0.10678272f, 0.06149518f, -0.05758560f, 
    0.10777209f, 0.10756480f, 0.00134463f, 0.03126899f, 0.02566658f, -0.29533648f, 0.34754938f, 0.10446760f, 
    -0.05965843f, 0.05782304f, -0.04675796f, 0.06698953f, -0.06863242f, -0.03044466f, 0.09655191f, 0.05036874f, 
    0.04608463f, 0.40647724f, 0.18126686f, -0.10697126f, 0.04104391f, -0.08844472f, -0.05786898f, 0.12679902f, 
    0.03281370f, 0.03602546f, -0.05913686f, -0.03120588f, 0.31345999f, 0.42964801f, 0.10702322f, 0.08907199f, 
    -0.08837719f, -0.26995838f, 0.13105583f, 0.06248666f, -0.15321137f, -0.08500122f, 0.10861688f, 0.18588954f, 
    0.06520426f, 0.21693312f, -0.19778657f, 0.17356655f, -0.12015258f, -0.00048584f, 0.08203013f, 0.02772224f, 
    0.17298643f, 0.01788844f, -0.13619785f, -0.06421328f, 0.22270371f, -0.20738296f, -0.20053260f, -0.27633873f, 
    -0.00366999f, 0.05216016f, 0.09319665f, 0.14526424f, 0.09416869f, -0.03692013f, -0.02990742f, -0.09131654f, 
    -0.09700879f, -0.06334376f, 0.28229085f, -0.31019947f, 0.19435242f, 0.04438063f, 0.13777177f, 0.04076052f, 
    0.00720907f, -0.03271833f, 0.12897953f, 0.06111316f, 0.65993685f, 0.11734947f, -0.02511810f, -0.43078899f, 
    0.26906961f, 0.09899630f, -0.00610665f, 0.14644057f, 0.00397559f, 0.07002637f, -0.07352263f, -0.08372338f, 
    0.10026433f, 0.17045654f, -0.02793313f, 0.29730129f, -0.05402540f, -0.05455078f, -0.08830470f, -0.07929242f, 
    -0.07519011f, -0.04361358f, 0.06881963f, 0.03140245f, -0.43558985f, -0.52337539f, -0.19210309f, -0.31299558f, 
    0.15945534f, 0.14045438f, 0.06641440f, -0.09429257f, 0.06878296f, 0.23858371f, 0.10682937f, -0.08062337f, 
    0.02132146f, 0.35538688f, 0.01932299f, -0.24108873f, 0.15376294f, 0.07470901f, -0.04368835f, -0.07091305f, 
    -0.18834427f, -0.04940075f, 0.01661171f, -0.05854152f, -0.17696048f, 0.07950816f, 0.01138502f, -0.33611247f, 
    -0.09142373f, 0.07333868f, -0.12570778f, 0.01515539f, 0.02761303f, -0.13691971f, -0.04874387f, -0.04611006f, 
    -0.11334257f, -0.10475396f, -0.15044183f, 0.25713623f, 0.01268570f, -0.00712377f, -0.09171448f, -0.03843595f, 
    0.07753476f, -0.04791028f, -0.14398791f, -0.18732610f, 0.40360561f, -0.21079467f, -0.05573626f, 0.12056500f, 
    -0.21898085f, 0.04349627f, -0.10196191f, -0.05197990f, -0.06342840f, -0.04241465f, -0.04100819f, -0.01852431f, 
    0.19352284f, 0.03046565f, -0.25485107f, 0.27815631f, -0.19795756f, -0.05879267f, -0.08738819f, -0.03328763f, 
    -0.10247267f, 0.02263814f, 0.01332824f, 0.05383668f, 0.33057794f, 0.14943874f, 0.11435309f, 0.10755061f, 
    0.04794766f, 0.00690552f, -0.14810054f, 0.21621269f, 0.13036756f, -0.01940002f, 0.06094854f, 0.06039675f, 
    -0.08828924f, -0.02378389f, 0.00740214f, -0.15661450f, 0.21989225f, 0.09919557f, -0.13274547f, -0.11800516f, 
    0.13479050f, -0.04079626f, 0.01707912f, -0.10101228f, 0.53418756f, 0.36108309f, -0.24778196f, -0.21292441f, 
    0.01733065f, 0.12737027f, 0.02833502f, 0.01462729f, -0.09288578f, 0.04785729f, 0.06866872f, -0.12668276f, 
    -0.08173671f, -0.01324134f, -0.32404476f, 0.11826732f, -0.01045617f, 0.04711362f, 0.07848440f, -0.02442963f, 
    0.07740816f, 0.12378235f, -0.01658458f, 0.09899677f, 0.43175706f, 0.15020089f, 0.09956361f, -0.07107325f, 
    -0.21407923f, -0.10944160f, -0.07073176f, -0.02953655f, -0.00771656f, -0.00054027f, 0.02922830f, 0.02001937f, 
    0.03048206f, -0.11621647f, 0.24884573f, 0.16135702f, -0.06746719f, -0.00354374f, -0.14927983f, 0.00620021f, 
    -0.06936672f, 0.21767159f, -0.14223908f, 0.04373951f, 0.54659057f, 0.07223185f, 0.24865633f, 0.20105058f, 
    0.02195203f, 0.08858427f, -0.07884012f, 0.02214289f, -0.11689836f, 0.05329603f, -0.14816329f, 0.03959354f, 
    -0.17509241f, 0.10794926f, -0.06899008f, -0.05667390f, 0.12527557f, 0.05867775f, 0.05147175f, 0.02497960f, 
    -0.04503138f, 0.12280132f, 0.01179819f, 0.00809572f, -0.07643200f, -0.00007850f, 0.20203389f, 0.28482285f, 
    -0.02621050f, 0.00550609f, 0.09978516f, 0.24920070f, 0.05450941f, 0.20591369f, 0.15172261f, -0.00718882f, 
    0.17116250f, 0.14806458f, -0.10097159f, 0.16131590f, 0.13869682f, -0.11394256f, 0.11346150f, 0.00005770f, 
    0.05026841f, -0.04527527f, -0.10670038f, 0.01267347f, 0.50022548f, 0.23967330f, 0.18562178f, -0.10368843f, 
    -0.22192511f, 0.07846082f, 0.09324923f, 0.05542120f, -0.02698771f, 0.08697167f, -0.05934804f, -0.15852660f, 
    -0.09438413f, 0.19832586f, 0.01703825f, 0.45814991f, 0.02782331f, 0.03026312f, 0.01611878f, -0.00583343f, 
    0.04887274f, 0.12343401f, 0.12168783f, 0.02338761f, -0.17973597f, 0.23854838f, 0.38201427f, 0.38616297f, 
    0.24398136f, 0.03772322f, 0.06102778f, 0.07792974f, -0.03109399f, 0.14326245f, 0.09644300f, 0.17205377f, 
    0.17673951f, -0.06460204f, 0.18522763f, 0.14934975f, -0.11938246f, 0.06575646f, 0.07272686f, 0.06669959f, 
    0.03389958f, -0.00707999f, 0.04390881f, 0.25483167f, -0.43865082f, -0.11131886f, 0.18016419f, 0.07680940f, 
    0.13006264f, 0.08882719f, 0.15371028f, 0.17100319f, 0.11847010f, 0.11840326f, 0.04674350f, 0.02977074f, 
    -0.60634333f, -0.06269418f, 0.14421676f, -0.20012400f, -0.00471471f, 0.03706653f, 0.05265645f, 0.13519534f, 
    0.15849674f, -0.04789258f, 0.02830086f, 0.08450472f, -0.05437229f, 0.07421188f, -0.13576728f, -0.20029865f, 
    0.06006393f, 0.11354447f, 0.21066405f, -0.16052495f, -0.15247293f, -0.00571783f, 0.03912989f, 0.02385784f, 
    0.12464242f, 0.18595797f, 0.12618244f, 0.40823236f, -0.18321677f, -0.09971963f, 0.15400620f, -0.03396080f, 
    -0.08031559f, -0.01778129f, 0.06090826f, -0.11620432f, -0.22022483f, -0.01009451f, 0.14384149f, 0.19446214f, 
    -0.00528707f, -0.22051296f, -0.00612687f, 0.02032709f, 0.05808431f, -0.00163168f, 0.01096821f, -0.07579412f, 
    0.02174349f, -0.27695426f, 0.40093532f, -0.16558442f, -0.03930902f, 0.10335656f, 0.07321324f, -0.08077456f, 
    -0.19835332f, -0.19119562f, -0.01258292f, -0.10102403f, -0.59300697f, -0.28175372f, 0.01517018f, 0.22093317f, 
    0.08938447f, 0.10310742f, 0.01161886f, 0.18912299f, -0.05737133f, 0.05050665f, -0.08327489f, 0.00014802f, 
    0.16448574f, 0.01402042f, 0.27743340f, -0.02809356f, 0.07558700f, 0.31512424f, -0.07070010f, 0.05397079f, 
    0.11125041f, -0.25707805f, -0.00833120f, -0.09620880f, 0.16838087f, 0.42366388f, -0.30529726f, -0.17004456f, 
    -0.06188506f, -0.04129761f, 0.21838582f, -0.09897844f, 0.02629555f, 0.07383363f, 0.27507541f, -0.03480777f, 
    0.02244507f, -0.17416698f, 0.07074454f, -0.05143609f, -0.00710749f, -0.08266019f, 0.03121429f, -0.13236561f, 
    -0.03797425f, 0.05939215f, 0.02586632f, -0.03666170f, 0.05792541f, 0.30953732f, -0.03487155f, -0.22156632f, 
    -0.12970869f, 0.10299165f, -0.23299167f, -0.04421499f, -0.13264225f, -0.06361012f, -0.13549033f, -0.00376489f, 
    -0.00567207f, -0.22615699f, 0.06102639f, -0.17493618f, -0.21439546f, 0.10575758f, -0.09155341f, 0.01233288f, 
    0.00860220f, -0.01685845f, 0.19033121f, -0.08699898f, 0.08995029f, 0.06868443f, 0.13249853f, 0.10160710f, 
    0.22039017f, -0.03490391f, -0.02519186f, 0.01871082f, 0.10002595f, 0.04976771f, 0.05993905f, 0.17891441f, 
    0.06309731f, -0.04210889f, -0.01670193f, 0.01024452f, 0.02592031f, -0.01193407f, 0.04124742f, -0.04134170f, 
    0.03025179f, -0.07389178f, 0.03058707f, 0.04828590f, -0.07281894f, -0.02223923f, 0.02190856f, -0.05401443f, 
    -0.00015143f, 0.05209476f, 0.03136261f, -0.06952558f, 0.03489826f, -0.06124103f, 0.00981179f, 0.02920331f, 
    -0.02718714f, -0.05525609f, 0.01369342f, -0.05952929f, 0.04170847f, -0.05368703f, -0.06293498f, 0.03136455f, 
    0.05448382f, -0.02468093f, -0.03536498f, -0.00435222f, -0.07944556f, 0.04175665f, 0.06545677f, 0.00427645f, 
    -0.00560836f, -0.07104138f, 0.02231486f, -0.00126314f, -0.06615701f, 0.00603058f, 0.03210114f, 0.03405915f, 
    -0.01763547f, -0.05235444f, -0.01224622f, -0.06865859f, 0.01779579f, 0.03233114f, -0.08130118f, -0.06184774f, 
    0.05047980f, 0.05888538f, 0.04204108f, 0.04660990f, -0.03163441f, 0.05902803f, -0.07481663f, 0.02440503f, 
    -0.07943358f, -0.05915687f, 0.01388814f, -0.04860752f, 0.06380858f, 0.02229735f, -0.02291125f, 0.03628170f, 
    0.05155810f, -0.02669580f, -0.04411326f, -0.08310603f, 0.00330926f, 0.04611498f, -0.07659587f, -0.08032958f, 
    -0.02178707f, 0.03606987f, 0.04779648f, -0.01749689f, 0.02292989f, -0.02322133f, 0.04411564f, -0.05226655f, 
    -0.00790900f, 0.04243444f, -0.05742007f, 0.00516787f, -0.04806488f, 0.03200493f, -0.05427010f, 0.05637040f, 
    0.03863671f, 0.01231272f, -0.06910637f, 0.05818232f, -0.02430578f, 0.05284403f, -0.07352798f, -0.05330356f, 
    -0.05236918f, -0.04491434f, -0.05273000f, -0.05520297f, -0.02657866f, 0.06012154f, -0.02479099f, -0.07268933f, 
    0.01613808f, -0.01466771f, -0.01538195f, -0.05971395f, 0.03013431f, 0.02107366f, -0.06345560f, -0.05025437f, 
    0.00067135f, 0.00671821f, -0.06721160f, 0.03110255f, -0.04939462f, -0.01251013f, -0.00959112f, 0.02648671f, 
    -0.01549410f, -0.07473614f, 0.03933965f, -0.06987730f, 0.02816606f, 0.05500760f, 0.01962403f, 0.04321020f, 
    -0.05634628f, -0.05978156f, -0.05762747f, -0.03338166f, 0.02978317f, -0.02145908f, -0.07077833f, 0.06880921f, 
    -0.06089190f, -0.05629280f, -0.02079115f, 0.02849913f, 0.05529465f, 0.01090408f, 0.02997088f, -0.06580382f, 
    -0.01715692f, -0.06273077f, 0.05345067f, -0.02688129f, 0.06459809f, -0.06656417f, -0.06302705f, -0.01655781f, 
    -0.05357578f, 0.05199799f, 0.03258839f, -0.05840318f, 0.03027222f, 0.00446595f, -0.04408283f, 0.04724793f, 
    -0.02628002f, -0.06574558f, -0.04679291f, 0.04813441f, 0.00148340f, -0.02501881f, 0.05554322f, -0.05096750f, 
    -0.08301338f, -0.00605595f, 0.04821745f, -0.02052029f, -0.04282549f, -0.04264892f, 0.00138582f, 0.04867509f, 
    0.05572316f, 0.05303320f, 0.04607876f, -0.00458364f, -0.05948912f, -0.07699175f, -0.00321227f, 0.05837927f, 
    -0.00858249f, 0.25707236f, 0.17939296f, 0.21553229f, -0.02611643f, 0.18121925f, -0.02476853f, 0.02179502f, 
    0.04659967f, -0.01937361f, 0.07330359f, 0.08315922f, 0.12027841f, 0.09732229f, 0.17840864f, 0.26096424f, 
    -0.04104321f, -0.01880427f, 0.07405879f, 0.24432750f, -0.10548843f, 0.06333354f, -0.00590260f, 0.00099899f, 
    -0.08975381f, -0.12778762f, -0.34852356f, 0.25874579f, 0.18842804f, 0.02504834f, 0.06565188f, 0.03250679f, 
    0.11202845f, -0.07747199f, 0.06855828f, 0.10545009f, -0.27127331f, 0.06974303f, -0.03221096f, 0.21093535f, 
    0.08289277f, -0.13250247f, 0.03641558f, 0.04342277f, 0.01349639f, -0.01871762f, 0.03295694f, 0.13542493f, 
    -0.45951948f, 0.05419213f, -0.13565399f, -0.26176432f, 0.04149939f, -0.09466659f, 0.13119918f, 0.12320277f, 
    0.11413590f, -0.05748542f, 0.05660842f, 0.29277614f, 0.21683599f, -0.09857696f, 0.04414814f, 0.13876960f, 
    0.11971930f, 0.09724563f, 0.04227851f, 0.10624901f, 0.04464148f, 0.07118132f, 0.00032810f, 0.00347426f, 
    0.03917903f, 0.03855722f, -0.01359243f, -0.14496173f, -0.18021229f, 0.01547582f, -0.10422244f, 0.12642349f, 
    0.01913145f, 0.02545277f, 0.09081542f, -0.00665996f, -0.01190280f, 0.04707315f, 0.19700833f, -0.14051224f, 
    0.10794640f, -0.04112311f, -0.06985904f, 0.07003641f, 0.17826745f, 0.10318815f, 0.08308534f, 0.07675546f, 
    -0.25299406f, -0.07360779f, -0.30673459f, -0.27480069f, 0.09350335f, 0.13265683f, 0.03043563f, -0.16477168f, 
    0.06958674f, 0.04166545f, 0.15158010f, -0.03108256f, -0.41114470f, -0.13017713f, -0.03849621f, -0.16445345f, 
    0.02261765f, 0.04221602f, 0.05466976f, 0.01299534f, 0.08225737f, 0.09173444f, 0.06640559f, -0.03644173f, 
    0.23501448f, 0.44004345f, 0.22876452f, 0.11852980f, -0.08394723f, 0.19976003f, 0.11489213f, 0.02302903f, 
    0.13217668f, 0.11607721f, -0.13674115f, -0.08563559f, 0.26108661f, 0.35634398f, -0.02530434f, 0.16289625f, 
    -0.00998092f, -0.02128761f, 0.06513165f, 0.13662018f, 0.01663937f, -0.09056710f, 0.07074076f, 0.07400702f, 
    0.02442535f, 0.46316004f, -0.03551916f, 0.26812863f, -0.07669577f, 0.01680076f, 0.06353649f, -0.03406455f, 
    -0.08772955f, 0.08172178f, -0.03068398f, 0.12468713f, 0.36240298f, 0.31794208f, -0.07100803f, -0.20439720f, 
    -0.01361900f, -0.05607462f, 0.07225704f, 0.13637413f, -0.13494523f, 0.01011418f, -0.11208408f, -0.06214928f, 
    -0.35715881f, -0.49161524f, -0.39877343f, -0.18076399f, -0.00178204f, 0.09713324f, -0.05788359f, -0.02112398f, 
    0.06523848f, 0.19703595f, 0.15853536f, -0.03302231f, 0.17711571f, -0.08107946f, -0.04560001f, -0.22896720f, 
    -0.19485345f, 0.05731611f, 0.02399600f, -0.13309671f, 0.10334773f, -0.07310387f, -0.00409174f, -0.00140630f, 
    0.19279359f, -0.03216638f, -0.22851425f, -0.29503569f, -0.02802252f, 0.06404113f, 0.06684101f, 0.19756427f, 
    0.05258227f, 0.03887862f, 0.00289570f, -0.09418996f, 0.14551666f, 0.00203135f, -0.22464895f, -0.24395722f, 
    -0.19684324f, -0.02707190f, 0.07748009f, -0.00176425f, -0.01570596f, -0.06738633f, 0.12438287f, 0.02941086f, 
    -0.30602148f, 0.20244440f, 0.07041900f, -0.23297881f, 0.07339284f, -0.18135199f, 0.03576993f, 0.03773146f, 
    0.12198988f, 0.08706551f, 0.01483466f, 0.05613399f, 0.18752247f, 0.26190832f, -0.19596577f, -0.06752490f, 
    -0.00391005f, -0.01452938f, -0.13766578f, 0.18226686f, -0.05669431f, -0.18386665f, -0.02236121f, 0.14036326f, 
    0.51972121f, 0.31964332f, -0.31978795f, 0.02976384f, 0.00520080f, 0.01571077f, 0.02018920f, 0.01171987f, 
    -0.18345252f, 0.22882509f, 0.13139233f, -0.02026474f, 0.34834379f, 0.19883084f, 0.16426669f, 0.06988093f, 
    0.03545649f, -0.19612539f, 0.14226778f, 0.24256583f, 0.10032598f, -0.05270479f, -0.08041369f, 0.06214098f, 
    0.17047559f, -0.08096277f, 0.05878709f, -0.11564723f, 0.23013669f, 0.07454355f, 0.23880985f, 0.05619055f, 
    -0.00643822f, -0.01804049f, 0.07153437f, 0.01468261f, -0.51208037f, 0.13572672f, -0.29721916f, -0.11743098f, 
    -0.09659373f, 0.07033357f, -0.09500360f, -0.14656372f, -0.14836043f, 0.05834637f, 0.00155438f, -0.18435113f, 
    0.02610373f, -0.07778413f, -0.22266503f, 0.24798693f, -0.06748915f, -0.02771750f, -0.04768648f, 0.23257540f, 
    0.23871717f, 0.05269522f, -0.02534030f, 0.09734650f, 0.20849252f, -0.32085037f, 0.19412911f, -0.13302009f, 
    0.11416052f, -0.05706069f, -0.01359735f, -0.06975752f, 0.31264311f, -0.09354124f, -0.05173808f, 0.09791388f, 
    -0.16770759f, 0.08668525f, -0.14028199f, 0.12666222f, -0.14223167f, -0.09624790f, -0.06310525f, -0.07211372f, 
    0.04328870f, 0.00666372f, 0.08018121f, -0.09374879f, -0.00478600f, -0.16854213f, 0.00901518f, 0.22379847f, 
    0.17337692f, 0.06286599f, -0.03289461f, 0.05485983f, -0.07937645f, 0.01364968f, -0.00409184f, -0.09773511f, 
    -0.14063922f, -0.23622622f, 0.16838844f, 0.09901781f, 0.07692556f, 0.03704252f, 0.06269721f, 0.01610786f, 
    0.05989491f, -0.01087047f, 0.08925271f, -0.11528145f, -0.05904863f, -0.22694029f, -0.00533717f, 0.10471818f, 
    0.02725815f, -0.07876206f, 0.16171113f, 0.11270285f, -0.00975507f, -0.02271350f, 0.00090346f, -0.08050060f, 
    -0.06825867f, 0.23240349f, 0.05053630f, 0.08687641f, 0.08132536f, -0.07134123f, 0.01578385f, 0.05014113f, 
    0.03928062f, -0.14843118f, -0.11513830f, -0.05480858f, 0.15431510f, 0.22850351f, 0.08441911f, -0.01993915f, 
    0.11429252f, 0.20338610f, 0.29074165f, 0.21159098f, -0.24290225f, -0.11757752f, 0.06287944f, 0.06849455f, 
    -0.38569567f, 0.38083524f, -0.13071460f, -0.02985481f, 0.15164088f, -0.04281806f, -0.06580371f, 0.07284588f, 
    -0.03557729f, 0.11443533f, -0.02094945f, 0.02920328f, -0.28169054f, 0.31099325f, 0.20583807f, -0.12937246f, 
    0.17769980f, 0.23447473f, -0.06434032f, -0.08741084f, 0.05396041f, 0.14431292f, 0.15503308f, 0.13860813f, 
    0.11946271f, 0.08495241f, 0.36027890f, 0.34709901f, -0.11986031f, 0.03065813f, 0.04087090f, 0.00527616f, 
    0.01874524f, -0.06052837f, 0.01259054f, 0.10486241f, -0.07324987f, 0.02116446f, -0.01822121f, 0.04153362f, 
    -0.03277530f, 0.08825620f, -0.04884106f, -0.05731316f, -0.03998614f, -0.09466083f, 0.05186956f, 0.08488286f, 
    -0.23187214f, 0.20951843f, -0.05550057f, 0.07617202f, -0.18197444f, 0.06496903f, 0.07093231f, 0.02646648f, 
    0.11967582f, 0.20432119f, 0.10543493f, -0.07914010f, 0.32959667f, 0.42233637f, -0.25650167f, -0.17283753f, 
    -0.02066909f, -0.12013599f, 0.27242070f, 0.26274511f, 0.04067983f, -0.04870385f, -0.14260267f, -0.10513512f, 
    0.30320284f, 0.12840112f, 0.28838903f, 0.23289017f, 0.08881022f, 0.02157789f, 0.16535796f, 0.09580657f, 
    -0.03610189f, -0.06375461f, 0.03320561f, -0.07235754f, -0.42033857f, 0.34750992f, -0.04977983f, 0.23595093f, 
    0.03635448f, -0.10615502f, -0.00215585f, -0.00819422f, -0.03740836f, -0.01304800f, -0.00102230f, -0.14475745f, 
    0.16402897f, -0.32014561f, 0.30558568f, 0.02339997f, -0.21958657f, 0.08781486f, 0.00263097f, 0.15186720f, 
    0.02536185f, -0.01528476f, -0.06571162f, 0.12196967f, -0.03832097f, -0.31324264f, 0.12600015f, 0.11484769f, 
    -0.16098802f, -0.13170674f, -0.05425045f, 0.08071493f, -0.01127748f, 0.00503226f, 0.04744370f, 0.06052700f, 
    0.09626754f, -0.13833947f, 0.15717381f, 0.11245342f, -0.09396286f, 0.01265992f, -0.14403243f, 0.07447033f, 
    0.03461467f, -0.15216736f, 0.08073743f, -0.07147123f, 0.31423938f, 0.05481546f, -0.30233088f, -0.16791266f, 
    0.04281186f, -0.01596990f, 0.14411159f, -0.04686467f, -0.01918698f, 0.15555747f, 0.16646622f, -0.03767061f, 
    0.15694563f, -0.72801214f, 0.33366433f, -0.51644266f, 0.22623214f, 0.02034561f, 0.00796130f, -0.13129772f, 
    -0.06647295f, -0.02059590f, 0.07699850f, -0.14107534f, -0.25579169f, 0.03241722f, 0.10284721f, -0.28475153f, 
    0.19576092f, 0.14218843f, -0.19375548f, -0.11777108f, 0.14152311f, 0.04966091f, -0.02923050f, -0.06970967f, 
    -0.00265743f, 0.06661358f, 0.06200921f, 0.03724769f, -0.27214834f, -0.05525311f, -0.01579275f, 0.03203442f, 
    0.04967668f, -0.22536601f, 0.01120006f, 0.11358988f, 0.38260967f, 0.34472719f, 0.21621825f, 0.14413604f, 
    0.13057959f, -0.08419563f, 0.04755681f, 0.24627481f, -0.18045548f, 0.01664830f, 0.08757599f, 0.23160508f, 
    -0.28773841f, 0.14350687f, -0.08855489f, 0.14325182f, 0.00931027f, 0.01487529f, -0.01055622f, 0.18338825f, 
    0.08374424f, 0.07276896f, -0.06850103f, 0.03540887f, -0.26919982f, 0.07926196f, -0.04199437f, -0.06298797f, 
    0.02220484f, -0.05554657f, -0.00657838f, 0.01312304f, -0.02213178f, 0.11331901f, 0.18970403f, 0.20693612f, 
    0.36094823f, -0.02122356f, -0.14192863f, 0.55247658f, -0.05676617f, -0.13119766f, -0.00516642f, 0.06701862f, 
    0.00353917f, 0.02709134f, 0.12420985f, 0.31420162f, -0.35083234f, 0.22456148f, 0.04983941f, 0.02759629f, 
    0.10483237f, -0.06589742f, -0.12899116f, -0.00354238f, -0.06578547f, 0.02354558f, 0.03183797f, 0.18978675f, 
    -0.30817908f, 0.18070254f, 0.18873028f, -0.14226297f, 0.06599569f, -0.09771144f, -0.00893225f, 0.05382204f, 
    -0.05013151f, 0.04573859f, 0.07656843f, 0.13924661f, 0.15060517f, 0.06832448f, -0.18170582f, -0.15460581f, 
    0.04123115f, 0.10800455f, 0.01913742f, -0.04944139f, -0.01661242f, -0.03457388f, 0.05084784f, 0.05369947f, 
    -0.07312263f, -0.00350933f, 0.36426690f, 0.35085669f, -0.05181615f, 0.03677444f, 0.12019759f, 0.05851226f, 
    -0.05380749f, -0.09577741f, 0.04656618f, -0.00054058f, -0.62663305f, 0.07085656f, 0.23921053f, 0.05707508f, 
    -0.11318681f, 0.04066122f, -0.07682578f, 0.09072413f, 0.06690330f, -0.12286317f, 0.02960351f, -0.08240558f, 
    0.37504476f, -0.05051382f, 0.07801468f, -0.02489478f, -0.00635125f, -0.01387109f, -0.01161608f, 0.12273205f, 
    0.08783529f, -0.06885751f, -0.09769405f, -0.08768682f, 0.60218328f, 0.02943148f, -0.07289094f, -0.02509403f, 
    0.10320068f, -0.19243132f, -0.04060175f, -0.04817091f, 0.01151516f, 0.00492177f, -0.07153229f, -0.02236235f, 
    -0.48203242f, 0.37178737f, 0.15498264f, 0.24754444f, -0.03620784f, 0.04026712f, -0.04304287f, 0.08663096f, 
    0.13155529f, -0.05230350f, -0.10862518f, -0.17332676f, 0.03520405f, -0.02519639f, -0.33545399f, -0.17670017f, 
    -0.02125736f, 0.00130305f, 0.04776064f, 0.09063725f, 0.15737589f, -0.05275320f, 0.02925149f, 0.01178666f, 
    0.29524735f, -0.09791939f, 0.07646202f, -0.27178112f, 0.00702021f, -0.04872707f, -0.08908020f, -0.11605992f, 
    -0.06361701f, 0.03515458f, 0.25445610f, 0.07795039f, 0.12033564f, 0.16862306f, 0.05141991f, -0.41750890f, 
    0.08663645f, 0.02048597f, -0.23955771f, -0.00156873f, -0.02529586f, -0.02697041f, -0.01915458f, -0.15093192f, 
    0.31446394f, -0.05245601f, -0.12687714f, -0.00662795f, 0.00134789f, -0.03545539f, -0.29550183f, -0.10842931f, 
    -0.05960754f, -0.12149084f, 0.18453452f, -0.08661340f, -0.00057335f, 0.15214549f, 0.19652806f, 0.01535158f, 
    0.07506659f, 0.00230786f, 0.00565014f, -0.06384638f, -0.06423437f, 0.15632252f, 0.04476053f, 0.23510236f, 
    0.19574319f, 0.07652004f, 0.13219015f, -0.21792117f, 0.01863430f, -0.05393697f, 0.08944118f, -0.01911248f, 
    0.03829417f, 0.09674176f, 0.17803031f, 0.23339951f, 0.18594158f, 0.04662019f, 0.02094367f, -0.06784470f, 
    -0.17711174f, 0.04187285f, 0.19187537f, 0.16568954f, -0.01646481f, -0.01116929f, -0.04246252f, 0.10988674f, 
    -0.75512606f, -0.17605688f, 0.19001311f, -0.08120227f, 0.04381097f, -0.16054122f, 0.00861551f, -0.09848667f, 
    0.18020387f, 0.04432017f, 0.13218509f, -0.04775182f, -0.15593635f, -0.02434440f, -0.17084190f, 0.45666414f, 
    0.00874792f, -0.17361088f, -0.03541641f, -0.03607402f, -0.09816512f, -0.10579701f, 0.01082688f, 0.18748404f, 
    0.33212057f, 0.38325310f, -0.34025431f, 0.03227210f, 0.03636742f, 0.01692555f, 0.05375477f, 0.09157276f, 
    0.04197293f, 0.14223647f, 0.17712899f, 0.02856254f, 0.00105263f, 0.16900422f, 0.17618887f, 0.17585090f, 
    0.07284795f, -0.08600513f, -0.03794774f, 0.07001334f, -0.00391253f, -0.04743962f, 0.00597318f, -0.18176590f, 
    0.27515012f, -0.08956150f, 0.29731199f, -0.27425236f, 0.27846843f, 0.08814405f, 0.05483286f, 0.08917999f, 
    0.00898743f, 0.03074594f, -0.07167404f, 0.18194768f, -0.09449238f, 0.39173391f, -0.02678789f, -0.21320422f, 
    0.16169834f, 0.05485056f, -0.01727904f, -0.05501999f, 0.10950127f, -0.17892683f, 0.04879852f, 0.01333419f, 
    0.15917355f, -0.00883805f, -0.16537493f, -0.00461478f, 0.12169435f, 0.03143487f, -0.07533123f, -0.08367454f, 
    -0.03049122f, 0.00956057f, -0.10257318f, -0.14768152f, -0.50307727f, -0.34744874f, -0.15177791f, 0.02803627f, 
    -0.09199226f, 0.08765689f, 0.00195627f, -0.02489982f, 0.08375408f, -0.01549584f, 0.06490394f, 0.11018927f, 
    0.39139748f, -0.10348385f, 0.01153505f, -0.06870408f, -0.02353705f, 0.02436762f, -0.10271203f, 0.05354771f, 
    0.00669499f, -0.10687007f, -0.08266389f, 0.08531590f, 0.10403267f, -0.01003973f, 0.05054929f, -0.00399819f, 
    -0.05460487f, -0.01825828f, 0.27305195f, 0.00332086f, 0.09716205f, 0.01738248f, 0.02362911f, 0.00801888f, 
    -0.06646585f, -0.19498654f, 0.34262472f, 0.00707192f, -0.10390002f, 0.29246619f, -0.05017163f, 0.12824364f, 
    0.12655744f, 0.01829229f, -0.01234053f, 0.06187764f, 0.13055210f, 0.24870108f, -0.13215664f, -0.05524800f, 
    -0.02416370f, 0.16516997f, -0.03658772f, -0.05902344f, 0.03391264f, -0.00706023f, -0.04693387f, -0.03001709f, 
    -0.09381007f, -0.28671256f, -0.19586682f, 0.58080870f, 0.03937748f, -0.10022616f, -0.04201262f, -0.07382062f, 
    0.06438433f, 0.03038698f, 0.05982678f, -0.00270742f, 0.07569011f, 0.01626510f, 0.19777147f, -0.05092755f, 
    -0.09032484f, 0.01784658f, -0.00403747f, 0.17228660f, -0.06957894f, -0.05647310f, 0.10528733f, 0.10398187f, 
    0.27591029f, -0.23296019f, -0.01658864f, 0.31700990f, -0.05865820f, -0.04670902f, 0.10546736f, -0.11963924f, 
    -0.06671599f, -0.03109945f, 0.00102633f, -0.07510597f, 0.40024850f, -0.18037747f, 0.16382872f, 0.27216530f, 
    0.16090500f, 0.02868470f, 0.10903798f, 0.13374336f, 0.01515535f, 0.00705477f, -0.07443255f, -0.01748369f, 
    -0.27474785f, 0.12722151f, 0.23639713f, -0.45568243f, -0.03367969f, 0.08774580f, -0.15931365f, -0.04662663f, 
    -0.09710472f, -0.13495736f, 0.01199084f, -0.11734549f, 0.19319974f, -0.15186608f, -0.04960561f, -0.10470910f, 
    0.00653708f, 0.05660416f, 0.14546061f, -0.10961580f, 0.25518933f, -0.02737789f, 0.07148509f, -0.20717521f, 
    0.22354139f, -0.07442135f, -0.18661268f, -0.16175494f, -0.04415816f, 0.05773465f, -0.02193027f, -0.04508260f, 
    0.12220713f, -0.15539487f, -0.17836002f, -0.06352091f, -0.18841116f, -0.02945415f, -0.06951891f, 0.21393016f, 
    0.06458326f, 0.03288321f, -0.01532536f, -0.04275800f, -0.12403166f, 0.06769801f, 0.02316532f, 0.00343054f, 
    0.15678941f, -0.00512510f, -0.11498309f, 0.12491133f, -0.00790150f, 0.18443787f, 0.01507023f, 0.10800849f, 
    -0.04335100f, 0.12211383f, 0.00874920f, 0.05505666f, 0.56962240f, -0.01815680f, 0.03674648f, -0.01445488f, 
    0.08148428f, -0.17996250f, 0.01834927f, 0.06471374f, -0.00006433f, 0.08928259f, 0.00064680f, 0.14508198f, 
    -0.14051807f, 0.17459331f, -0.04770729f, -0.09843885f, 0.15426378f, 0.02106630f, 0.00101895f, -0.20840631f, 
    -0.13458243f, -0.12624902f, 0.10163471f, 0.01422583f, -0.84952652f, -0.08325786f, 0.28700396f, 0.03399550f, 
    -0.11355243f, 0.19306634f, 0.02667559f, 0.05146875f, -0.09213240f, 0.06518169f, -0.01995366f, -0.13811541f, 
    0.62473267f, -0.19077428f, -0.01632103f, -0.01635287f, 0.16106872f, 0.22298262f, 0.07729835f, -0.05325963f, 
    -0.11591613f, 0.15382621f, 0.10724777f, 0.15608218f, -0.17849824f, 0.18213795f, 0.10047875f, 0.06656364f, 
    -0.03500929f, -0.02470085f, 0.03667802f, 0.00307848f, 0.04158397f, 0.04753727f, 0.01713630f, 0.01719799f, 
    -0.04907272f, -0.14617579f, 0.14620964f, 0.45893818f, -0.09059603f, 0.21605003f, 0.11035664f, 0.20158541f, 
    0.01857163f, 0.13342214f, -0.07865011f, 0.02437593f, 0.01042626f, 0.15126413f, -0.09039659f, 0.11822354f, 
    -0.13474023f, -0.10429090f, 0.22162811f, 0.06796499f, 0.03600074f, 0.10963070f, 0.00688329f, 0.15244725f, 
    -0.36297935f, -0.02655299f, 0.18836135f, -0.08914227f, -0.15902308f, 0.07094421f, 0.22413877f, -0.05082947f, 
    0.01150515f, 0.22162412f, -0.05994083f, 0.14854284f, -0.09625965f, -0.15803072f, -0.13015266f, 0.24528968f, 
    0.05339054f, 0.04258120f, -0.02095052f, -0.01241247f, 0.15605898f, -0.11511139f, -0.09370445f, -0.09522497f, 
    -0.28985518f, 0.39626724f, -0.14786042f, -0.20034529f, 0.18386762f, 0.01885651f, 0.08649617f, 0.18417613f, 
    0.03532632f, 0.05557862f, -0.01197307f, 0.03029746f, -0.31594545f, 0.40982071f, -0.19784158f, -0.09779830f, 
    0.10783390f, 0.23121423f, -0.09133450f, -0.07757924f, 0.07044705f, 0.01560494f, 0.20081292f, 0.13829643f, 
    0.52249700f, 0.27518940f, 0.15996486f, 0.28086364f, 0.04414777f, 0.01223772f, 0.09668005f, 0.15623814f, 
    0.12000846f, 0.16211826f, -0.04920566f, 0.11583599f, 0.19194399f, 0.04117324f, 0.09018384f, -0.21628770f, 
    -0.04742149f, 0.11434044f, -0.14094576f, 0.12345638f, -0.09625500f, 0.01974062f, -0.01623282f, 0.08210631f, 
    -0.13566640f, -0.20934817f, 0.20219053f, 0.07004904f, -0.01772815f, 0.06151691f, -0.07996561f, -0.05424659f, 
    -0.07074313f, 0.08544213f, 0.06431211f, -0.08350197f, 0.18645296f, -0.07109192f, -0.25708884f, -0.16056323f, 
    -0.15300114f, -0.11548711f, 0.07938135f, 0.02107748f, 0.04714018f, 0.02127344f, -0.02248174f, -0.01209902f, 
    0.00929310f, 0.17152779f, -0.13626647f, 0.10482619f, -0.10018109f, -0.07948983f, 0.20317136f, -0.08525459f, 
    0.04800490f, -0.00796270f, 0.11641030f, -0.10776535f, -0.20883241f, 0.09714749f, -0.27905169f, 0.10222499f, 
    -0.11705391f, 0.06603246f, 0.02265219f, 0.06345893f, -0.03756462f, 0.08390101f, -0.01806151f, -0.03477136f, 
    0.07367989f, -0.13290833f, 0.40927151f, 0.10495765f, -0.14509737f, -0.01706288f, -0.02541562f, 0.15826647f, 
    0.16418366f, 0.01353204f, -0.07755561f, 0.12325047f, 0.47394040f, 0.08029085f, -0.03139649f, 0.13378340f, 
    0.13593736f, -0.08799493f, -0.01599458f, -0.02304455f, 0.17965557f, -0.03010990f, -0.02756308f, 0.00558559f, 
    -0.43888247f, 0.00719664f, -0.05293821f, -0.06833573f, -0.14929771f, -0.13761230f, -0.11232162f, 0.06960167f, 
    0.03941450f, -0.02403961f, 0.17848839f, -0.11181221f, 0.12741339f, -0.23738353f, -0.13143824f, -0.10665034f, 
    -0.01113973f, 0.03623438f, -0.06657607f, -0.07620120f, -0.00215650f, -0.02264021f, 0.03108247f, 0.02054439f, 
    -0.02564649f, -0.13045616f, 0.01505764f, -0.24620110f, 0.16214401f, -0.14743643f, 0.06371684f, -0.24951832f, 
    0.17009681f, -0.03307821f, 0.07211867f, -0.04939255f, -0.19147061f, -0.35666865f, -0.06507386f, -0.03184357f, 
    0.01467121f, 0.01916976f, -0.05486402f, 0.05163453f, 0.01265040f, -0.08888665f, -0.01004707f, -0.03882304f, 
    0.17214537f, 0.28363618f, 0.26054525f, -0.29499713f, 0.12339708f, -0.01269685f, -0.13224973f, 0.11298175f, 
    0.01837151f, -0.11644167f, -0.08711513f, -0.04130730f, -0.03902905f, 0.22203122f, 0.02275834f, 0.04149913f, 
    0.21148327f, 0.04268766f, 0.15342574f, 0.11845469f, -0.10258280f, 0.19922641f, 0.15101108f, 0.17862441f, 
    -0.04400964f, 0.06024091f, -0.06043931f, 0.00117181f, 0.05608450f, -0.03885810f, -0.03165296f, 0.05429397f, 
    0.04044101f, -0.01116417f, -0.03953077f, 0.02355942f, 0.01861469f, 0.05988034f, -0.06357867f, -0.03434697f, 
    0.05914268f, 0.05445969f, 0.02681539f, -0.02009572f, 0.04300846f, -0.04315762f, 0.00454685f, -0.06633804f, 
    -0.01563092f, -0.04669293f, -0.03406338f, -0.00155396f, 0.06217257f, 0.04101839f, -0.04119118f, 0.00047053f, 
    0.05385757f, 0.02623136f, -0.03270547f, 0.02394885f, 0.03125276f, 0.02314347f, -0.04128912f, -0.00322075f, 
    -0.04621909f, -0.03878997f, -0.06211358f, 0.00653449f, 0.04045400f, 0.01800096f, -0.02556133f, -0.02945484f, 
    -0.03041007f, -0.00727076f, 0.01753084f, 0.05760280f, -0.05282969f, -0.01023636f, 0.05228422f, 0.04859711f, 
    -0.03192220f, 0.03204093f, -0.03716384f, 0.04858444f, 0.03127176f, -0.05578095f, -0.03482378f, -0.04639393f, 
    -0.03307863f, 0.03333495f, 0.05969689f, -0.01473635f, -0.07357761f, 0.01169446f, -0.05080659f, -0.06618562f, 
    -0.00045974f, 0.00674819f, -0.07383352f, -0.04337959f, 0.04202199f, -0.02922787f, -0.01660031f, -0.03244620f, 
    -0.02413648f, 0.04171871f, -0.06023913f, 0.02175049f, -0.02084017f, -0.00772676f, -0.05752333f, -0.06813490f, 
    0.06084006f, -0.04738012f, -0.01580013f, 0.03723936f, 0.03455586f, 0.03020356f, -0.07781191f, 0.06094398f, 
    -0.00841371f, -0.02267440f, 0.03531817f, -0.01433220f, -0.01094221f, -0.05508674f, 0.02022797f, 0.02978553f, 
    0.02215992f, -0.00148242f, 0.00089157f, -0.06466912f, 0.04603789f, -0.00816143f, -0.04398265f, -0.06477882f, 
    -0.05121455f, -0.03047593f, 0.00788350f, -0.06636086f, -0.03206611f, -0.00053191f, 0.01831032f, -0.00352362f, 
    -0.05392263f, -0.03303061f, -0.06587400f, 0.05420697f, -0.00126357f, -0.03348599f, 0.04580228f, -0.00844562f, 
    -0.01145773f, -0.07687613f, 0.01281254f, -0.07760873f, 0.04274123f, -0.02097415f, -0.07725071f, -0.07550380f, 
    0.02159281f, 0.01717404f, -0.06881865f, -0.00486172f, 0.00489568f, -0.01067362f, -0.06093226f, -0.07961456f, 
    0.05079779f, 0.00965677f, -0.05481584f, 0.02473756f, -0.05124089f, -0.03374869f, -0.07417908f, 0.04334412f, 
    -0.03298645f, 0.01365441f, -0.06296525f, 0.05157987f, 0.02723869f, -0.05794877f, 0.04396006f, 0.00898983f, 
    -0.07516240f, 0.06223562f, -0.02361623f, -0.05488215f, 0.04522784f, 0.01176700f, -0.07570819f, 0.05138617f, 
    0.04746887f, -0.01942789f, -0.01656256f, -0.01184081f, -0.05906183f, -0.01423169f, 0.00434595f, -0.07739610f, 
    -0.07597698f, -0.07850113f, -0.00944628f, -0.02184578f, 0.04236353f, 0.00700937f, -0.00153059f, 0.01211941f, 
    -0.03236787f, 0.04410689f, -0.04084456f, 0.03849112f, 0.05553966f, -0.06067578f, -0.04360625f, -0.04139727f, 
    0.29879200f, -0.02028292f, 0.14570007f, -0.09645765f, 0.10476668f, -0.12105600f, 0.18165384f, -0.03358713f, 
    0.05436469f, 0.06701925f, -0.05346046f, 0.20801450f, -0.28501710f, 0.26932821f, 0.21932881f, 0.22005466f, 
    0.09101011f, 0.03982157f, -0.04254327f, 0.04382169f, -0.03205318f, -0.05411292f, 0.03738010f, 0.24745056f, 
    -0.14673077f, 0.19076659f, 0.48678190f, -0.13841404f, 0.15030301f, -0.10422264f, -0.09377540f, -0.07778241f, 
    -0.02846326f, 0.05093536f, 0.09050679f, 0.02899682f, 0.08305974f, -0.10084607f, 0.24713476f, -0.29295841f, 
    0.06213487f, -0.09978363f, 0.06672113f, 0.13719633f, 0.05255305f, 0.09348596f, -0.05869877f, 0.01003306f, 
    0.26164094f, -0.10827069f, 0.14527422f, 0.16402142f, 0.12733805f, -0.00958059f, 0.08703891f, 0.11873653f, 
    0.00750789f, 0.11529431f, -0.04382183f, -0.03659893f, -0.64247459f, 0.04672670f, 0.06893747f, -0.22763300f, 
    -0.07428355f, -0.04526674f, 0.17229277f, -0.02296279f, 0.02300007f, 0.04628421f, 0.02868430f, 0.04611440f, 
    0.20044158f, 0.06273299f, -0.03720465f, 0.12823521f, 0.03987131f, -0.04442351f, 0.19633591f, -0.13461192f, 
    0.03778135f, 0.06958806f, -0.07152387f, 0.02852434f, 0.02477456f, 0.08082005f, -0.26566976f, 0.02869665f, 
    0.08048768f, -0.12193448f, 0.05028201f, 0.14791971f, 0.03124864f, 0.04151351f, -0.15666719f, 0.00048666f, 
    0.20499720f, -0.05861713f, 0.36768970f, 0.22744751f, -0.02606718f, -0.09992489f, -0.04607515f, -0.00434061f, 
    0.02581808f, -0.01069901f, 0.00111325f, 0.05464920f, -0.35858613f, 0.01037832f, -0.13888684f, 0.26910108f, 
    0.15398110f, 0.27438003f, -0.15584897f, -0.09612673f, -0.01089495f, -0.13048762f, -0.08703770f, 0.07544777f, 
    -0.17764086f, -0.54340380f, 0.14652163f, -0.39317298f, 0.12464182f, 0.09208300f, -0.03071238f, 0.04626171f, 
    -0.11283992f, -0.12556937f, 0.20887025f, 0.22683276f, -0.51060611f, -0.19600102f, -0.01937969f, -0.16743316f, 
    -0.03265281f, 0.07267480f, 0.20123152f, -0.18534699f, -0.07079207f, 0.06309935f, 0.05894454f, -0.02050262f, 
    -0.58105052f, -0.02793863f, -0.14428633f, 0.04021907f, -0.10463014f, 0.03653640f, -0.02867577f, 0.01248857f, 
    0.28041792f, -0.04329945f, -0.00033569f, -0.00459172f, -0.27718270f, -0.22907986f, -0.25426918f, 0.15217112f, 
    -0.10457598f, 0.14427282f, -0.04661958f, -0.00404972f, 0.02422008f, -0.20531261f, 0.11261293f, 0.11165986f, 
    0.21781117f, 0.14732188f, 0.41657975f, 0.06453634f, 0.22406293f, 0.07128463f, -0.07323501f, -0.02403241f, 
    0.00277889f, 0.00749116f, -0.07399555f, 0.17893624f, -0.38694939f, -0.02444747f, 0.13062987f, -0.08690669f, 
    0.19567075f, -0.01776311f, -0.04882952f, 0.30032641f, 0.04501912f, -0.06656851f, 0.04346892f, 0.10517928f, 
    0.14479953f, -0.35509580f, -0.09669086f, 0.06370996f, -0.07586611f, 0.10155987f, -0.13604467f, 0.08293417f, 
    0.06937356f, -0.02426415f, 0.06147846f, -0.23446254f, 0.62302464f, -0.78177416f, -0.19930105f, -0.18278489f, 
    -0.22606842f, 0.01918205f, -0.01868512f, -0.00467832f, 0.04431886f, -0.00385142f, 0.07903638f, -0.12189487f, 
    0.18399088f, 0.11345849f, -0.38757312f, -0.55788207f, -0.07720975f, -0.06282210f, -0.00434847f, 0.03942328f, 
    -0.13322860f, 0.10635399f, -0.01936046f, 0.01150395f, 0.35850450f, 0.16520968f, -0.11583163f, -0.14780040f, 
    -0.04219086f, 0.19328156f, -0.23817615f, -0.01386736f, -0.06910116f, -0.02978833f, 0.10389061f, 0.14400703f, 
    0.51594651f, 0.05543301f, -0.15160897f, 0.11247528f, 0.04274619f, 0.17275041f, -0.09202773f, -0.00345735f, 
    -0.02663856f, 0.01024324f, -0.00799561f, -0.00488550f, 0.35813949f, 0.07799117f, 0.38692597f, 0.23093665f, 
    0.15339345f, 0.00874701f, -0.09773463f, 0.14922769f, -0.00227765f, 0.04389390f, 0.00689374f, 0.01793089f, 
    0.02153744f, -0.03668720f, -0.03527048f, -0.09915384f, 0.06555545f, 0.16315247f, -0.04397041f, 0.03872726f, 
    -0.02315188f, 0.02760478f, 0.03520795f, -0.09677887f, -0.02124780f, -0.30345422f, 0.01810043f, 0.10191913f, 
    0.11937812f, 0.19453514f, 0.01164439f, -0.19249995f, -0.07585478f, -0.06086107f, 0.04677169f, 0.14024889f, 
    -0.06036985f, 0.37235206f, -0.29166478f, 0.14926629f, -0.08751807f, 0.07523904f, -0.04515448f, 0.03037064f, 
    -0.08636393f, -0.09204884f, -0.07655944f, -0.00573722f, 0.20057130f, 0.21709296f, 0.09300479f, -0.15349349f, 
    0.19108561f, 0.05091245f, -0.01531595f, -0.02526570f, 0.01743106f, 0.00278888f, 0.08677396f, 0.07474678f, 
    0.15104163f, 0.15568624f, -0.16858755f, 0.27467546f, 0.05878992f, -0.06420926f, 0.04111625f, -0.03814263f, 
    0.12455396f, -0.04564298f, 0.06761771f, -0.01184846f, -0.01305101f, -0.05135537f, 0.09584543f, 0.12623015f, 
    0.14224885f, 0.05710208f, -0.23061343f, 0.09750530f, 0.12185730f, 0.10300887f, 0.00166237f, 0.00424570f, 
    0.35603049f, 0.05307383f, 0.01484268f, 0.11206421f, 0.11411264f, 0.07158244f, -0.08522556f, 0.21469244f, 
    -0.06096148f, -0.04120278f, 0.11072700f, -0.07390121f, 0.20145783f, -0.07116261f, 0.04868134f, -0.05351655f, 
    0.27860877f, -0.04776102f, 0.20899057f, -0.05857959f, 0.15065987f, 0.06189082f, -0.08069783f, 0.02258343f, 
    -0.08082906f, 0.23929140f, -0.09262280f, -0.00437469f, 0.08040474f, -0.13741077f, 0.04430967f, -0.05421742f, 
    0.06053634f, -0.04136439f, -0.23986365f, -0.00620014f, 0.09237427f, 0.14418843f, 0.01682233f, 0.05339572f, 
    -0.12452217f, 0.12066435f, -0.02093710f, -0.04221521f, -0.29877019f, -0.17480613f, -0.09531054f, -0.22414048f, 
    0.02110121f, -0.00556395f, -0.04224665f, -0.03799429f, 0.05153888f, -0.05750619f, -0.06115765f, -0.03717405f, 
    0.01815924f, 0.04897594f, -0.07771488f, -0.05885264f, -0.07765179f, 0.05574222f, 0.07215445f, 0.00760956f, 
    0.00115112f, -0.03541881f, 0.05310498f, -0.00603238f, 0.00142898f, -0.01634675f, 0.03673768f, -0.01202005f, 
    0.03447209f, 0.00784378f, -0.02893199f, 0.03494542f, 0.04670053f, -0.08647276f, -0.01125621f, 0.00886977f, 
    -0.03898335f, 0.04660387f, 0.00395888f, 0.05316859f, -0.05063378f, 0.03917091f, 0.01505512f, -0.06175065f, 
    0.00316961f, 0.01514078f, 0.00818603f, 0.04893642f, 0.00881839f, -0.05119512f, 0.02883689f, 0.01623619f, 
    -0.00097038f, -0.07406036f, 0.01337575f, -0.07912550f, -0.03186359f, 0.02684705f, 0.02280096f, -0.03137988f, 
    -0.07400148f, 0.00236721f, -0.00356415f, 0.04366089f, -0.04778441f, 0.02181583f, -0.06202817f, 0.05454488f, 
    -0.06789870f, 0.00762010f, -0.07357755f, -0.04341676f, 0.04275048f, 0.02729465f, 0.03125905f, 0.03734997f, 
    0.02202299f, -0.00561826f, -0.05793335f, -0.05724773f, -0.01762306f, -0.03298302f, 0.03520113f, -0.02430845f, 
    -0.06801348f, -0.03495606f, -0.06561197f, -0.01467470f, -0.03897939f, -0.00951752f, -0.05278012f, 0.00612122f, 
    0.03656088f, -0.04048450f, -0.07861183f, -0.04509345f, 0.00575589f, -0.03547093f, -0.00416168f, 0.04305547f, 
    0.03436352f, -0.04114363f, 0.04313822f, -0.03685398f, -0.03349326f, -0.04105273f, -0.08133762f, -0.07579377f, 
    -0.07000682f, 0.01173597f, -0.04792066f, 0.02783653f, 0.03627249f, 0.00887271f, 0.01014910f, -0.07947170f, 
    -0.04677646f, 0.04152139f, 0.01362252f, -0.04646377f, -0.04710859f, 0.00182038f, -0.08444787f, 0.04426333f, 
    0.04741562f, -0.07337604f, -0.00144660f, -0.00613689f, 0.01255208f, 0.02160078f, 0.06580573f, -0.00708568f, 
    0.04902920f, -0.01936397f, 0.04662149f, 0.06743496f, 0.00459210f, -0.01339221f, -0.02830243f, 0.03446696f, 
    -0.00408053f, -0.04647845f, -0.03272923f, 0.00447336f, -0.08411375f, 0.04302709f, -0.06369934f, -0.04353372f, 
    -0.01318775f, 0.03792870f, 0.02769297f, -0.01770211f, 0.01602758f, 0.06281873f, 0.00238319f, -0.00304171f, 
    0.02568988f, -0.03303070f, -0.08457858f, 0.00121339f, -0.08242589f, 0.04490180f, 0.04140205f, -0.06075561f, 
    -0.02469923f, 0.02814737f, -0.04962675f, -0.00877427f, -0.03497244f, 0.01821523f, 0.06845720f, -0.02636606f, 
    -0.05138357f, -0.01372739f, 0.02092949f, 0.01919164f, -0.05046449f, -0.06294748f, 0.01648401f, -0.07440430f, 
    0.02529879f, -0.02426957f, 0.03439616f, 0.01767220f, -0.00717616f, -0.03316858f, 0.01363495f, 0.02196653f, 
    -0.03420738f, 0.06319372f, 0.00105631f, -0.03471193f, -0.02671369f, -0.04968503f, -0.07661436f, 0.05921898f, 
    0.15164284f, -0.24577905f, -0.08836928f, 0.05223138f, -0.03373628f, -0.28680599f, 0.00517050f, -0.09951199f, 
    0.09037564f, 0.01737468f, -0.10205758f, 0.07344688f, -0.32701367f, 0.00964316f, 0.09402140f, -0.06322557f, 
    0.17020662f, 0.13612533f, 0.01776048f, -0.00616439f, 0.07239331f, -0.07417624f, -0.01567282f, -0.01796015f, 
    -0.15453111f, -0.06666373f, 0.25438377f, 0.38356963f, -0.13688639f, 0.07164600f, 0.01075558f, -0.07094559f, 
    0.01431599f, 0.06803185f, 0.03703583f, -0.06000748f, -0.31062689f, -0.12595499f, -0.04778939f, 0.23530038f, 
    -0.12518282f, 0.03419023f, 0.04349918f, -0.10965352f, 0.15849039f, 0.09514633f, 0.01007325f, -0.18680848f, 
    0.04676975f, 0.21205762f, 0.18948962f, 0.27326345f, -0.03846238f, 0.02176350f, 0.10331391f, -0.15471278f, 
    0.05630719f, -0.01573856f, -0.06137118f, -0.11273240f, -0.59619284f, 0.13237637f, -0.00423784f, 0.05209056f, 
    0.10308864f, 0.01427603f, -0.09923300f, -0.06831332f, -0.01648371f, 0.00073218f, 0.15308735f, -0.00196265f, 
    -0.07179894f, -0.16422345f, 0.35511988f, 0.17991385f, 0.03332741f, -0.14052168f, 0.12558886f, 0.05477865f, 
    0.01934062f, 0.07883576f, -0.10935055f, 0.11959920f, 0.18278535f, 0.35566193f, 0.21632664f, 0.02927499f, 
    -0.04103714f, -0.10016280f, 0.13919415f, 0.00645988f, -0.06490391f, -0.08811036f, -0.09675775f, -0.20723008f, 
    0.61099321f, 0.03757371f, 0.32124543f, 0.03770738f, 0.09770920f, -0.03125506f, -0.02283021f, -0.03821420f, 
    -0.00183585f, 0.00101614f, -0.08495042f, 0.00270771f, 0.58907187f, 0.25331753f, 0.11455940f, -0.09016985f, 
    -0.27920368f, 0.00536384f, 0.02345136f, -0.08222155f, -0.17179719f, 0.01377430f, -0.10153215f, 0.07902766f, 
    -0.16774997f, -0.13567981f, 0.05517880f, 0.08719826f, 0.07677019f, -0.09022749f, -0.12588553f, 0.08101334f, 
    0.02366319f, -0.16208164f, -0.08625530f, 0.11958144f, -0.19033851f, 0.03878979f, 0.09095754f, -0.16363733f, 
    0.11149261f, 0.05150764f, 0.03243423f, -0.02184203f, -0.03293565f, 0.00627572f, 0.05231946f, -0.03562082f, 
    0.24568449f, -0.34056696f, -0.03233070f, -0.60974866f, 0.02824801f, 0.05457279f, 0.03272178f, 0.14231530f, 
    -0.03679895f, 0.02730101f, 0.15564385f, 0.02992424f, -0.00801376f, 0.21847752f, 0.18235767f, 0.22208959f, 
    -0.03150479f, 0.08083503f, -0.10950901f, 0.00395153f, 0.00265533f, 0.10743859f, 0.22571559f, 0.15712859f, 
    0.59223092f, 0.24553947f, 0.23295011f, 0.72310317f, -0.08734348f, 0.04868016f, 0.16977528f, 0.07707181f, 
    0.06459263f, -0.01206835f, 0.10287662f, 0.04138122f, -0.16082120f, -0.06711877f, 0.13159819f, 0.29239312f, 
    0.04830268f, -0.26128751f, -0.24426650f, 0.24747343f, 0.22933191f, 0.16670372f, 0.03167393f, 0.08496489f, 
    -0.20150784f, -0.14110601f, -0.12020500f, -0.02947803f, 0.01554573f, -0.04675545f, -0.06028599f, 0.34625196f, 
    0.01250029f, 0.09144497f, -0.06347742f, 0.05589534f, 0.36608040f, 0.25547895f, -0.26495841f, -0.25439993f, 
    0.06741072f, 0.18430667f, -0.01386264f, 0.06935057f, -0.18197951f, 0.13766375f, 0.03976876f, -0.05738229f, 
    0.10230216f, -0.09829029f, 0.01546089f, 0.05454366f, 0.13550238f, 0.24236669f, -0.01331526f, -0.05727114f, 
    -0.17237851f, 0.08302250f, 0.06688945f, 0.09487083f, 0.14561632f, 0.15943897f, 0.00964895f, -0.00135372f, 
    0.05158258f, 0.08121789f, 0.02265754f, -0.19280562f, -0.18672325f, 0.07842974f, 0.13349530f, 0.11503333f, 
    0.01962648f, 0.13002552f, 0.24270880f, -0.08097977f, 0.01384065f, 0.04739088f, 0.01611982f, -0.15488923f, 
    0.04536115f, 0.06288052f, -0.03927570f, 0.04721846f, 0.35403681f, 0.01416257f, -0.13207802f, 0.14254834f, 
    -0.05978363f, 0.09669998f, -0.15204930f, 0.09015708f, -0.08921965f, -0.07436863f, 0.02458761f, -0.10574369f, 
    -0.03265442f, 0.28605464f, -0.08754235f, -0.10716691f, 0.08298836f, -0.02712956f, 0.01520354f, 0.11476617f, 
    -0.01718896f, 0.10946063f, 0.04402036f, 0.06762306f, -0.57857651f, -0.26560065f, 0.06088103f, 0.07649134f, 
    -0.07646100f, 0.10590313f, -0.03058959f, 0.01713308f, 0.08169168f, -0.02792004f, 0.03275129f, 0.02598990f, 
    -0.14885263f, 0.34572279f, 0.14232281f, 0.07225572f, 0.21533090f, 0.00140956f, -0.07189482f, 0.06819335f, 
    0.15999012f, -0.00401364f, -0.10010576f, 0.04000659f, 0.63958585f, 0.11898126f, -0.16674240f, -0.12332222f, 
    0.14463097f, -0.09678020f, 0.01614001f, -0.02729945f, -0.14486292f, -0.07134401f, 0.10834562f, 0.14286073f, 
    0.07442641f, 0.36256477f, -0.29223266f, 0.09403092f, -0.02963154f, -0.22477208f, 0.15188466f, 0.07695623f, 
    0.06637088f, 0.03164827f, 0.03872631f, -0.02059127f, -0.08784145f, -0.15209404f, -0.10423026f, -0.09509663f, 
    0.04400258f, -0.05609862f, -0.16747235f, 0.03945453f, 0.10832617f, -0.13261718f, -0.07125739f, 0.12558819f, 
    0.20718385f, 0.07536621f, 0.16642465f, -0.23009595f, 0.08592122f, -0.07050361f, 0.02605333f, 0.17162372f, 
    0.03550728f, -0.09091667f, -0.02644009f, 0.09893956f, 0.13761571f, -0.10822897f, -0.01087459f, -0.21050265f, 
    0.24991848f, 0.05485071f, -0.15591443f, 0.05946389f, 0.09523004f, -0.00284990f, -0.04441935f, -0.15350004f, 
    0.01097647f, -0.20824875f, -0.07503536f, 0.03689845f, -0.12668459f, -0.10738911f, -0.03616414f, 0.14269772f, 
    -0.04503975f, 0.07906855f, 0.06663245f, 0.07247785f, -0.08083224f, -0.07803675f, -0.02804365f, -0.07164474f, 
    0.05566127f, 0.13711576f, -0.09498008f, -0.01392007f, -0.05549064f, 0.01919702f, 0.14800674f, -0.03689571f, 
    -0.03804931f, -0.06431183f, -0.03358296f, 0.05215541f, -0.05679888f, -0.04928843f, -0.05448971f, -0.07143907f, 
    0.05409075f, -0.05696535f, 0.06235384f, 0.05151015f, -0.05314542f, 0.04559820f, -0.00463173f, 0.03304280f, 
    -0.05938503f, -0.04870380f, 0.03093974f, -0.04906454f, -0.05652423f, 0.00525469f, -0.06241928f, -0.05965096f, 
    -0.04061157f, 0.01339229f, 0.06570172f, 0.06358042f, -0.07493889f, -0.05004373f, 0.01514607f, 0.02377039f, 
    0.01929852f, 0.04054401f, 0.01630355f, 0.01146857f, 0.01596827f, 0.02431158f, 0.00972251f, -0.05388232f, 
    -0.02555139f, -0.06518812f, 0.01681162f, 0.00106965f, 0.04684804f, -0.07262375f, 0.05364399f, 0.03924241f, 
    0.00316753f, 0.04874003f, 0.00962763f, -0.06976657f, -0.06690599f, -0.04275577f, -0.05697361f, -0.06015398f, 
    -0.07668011f, 0.06156012f, 0.06414248f, 0.02318403f, 0.02723308f, 0.03063465f, -0.01168360f, 0.06497592f, 
    -0.07763598f, -0.04899772f, 0.03755637f, 0.03293568f, 0.05234865f, 0.06570609f, 0.06272220f, -0.06168481f, 
    0.00213618f, -0.05452915f, -0.01369028f, -0.02714578f, 0.03929441f, -0.04734519f, -0.01987572f, 0.02112855f, 
    0.00647528f, 0.06387112f, -0.04424908f, -0.06867129f, -0.04229795f, -0.05511970f, -0.06340834f, 0.03729799f, 
    0.00298989f, 0.00189588f, 0.00234453f, -0.04192889f, -0.00771785f, 0.00173132f, -0.04426938f, -0.04877910f, 
    0.02274257f, -0.03028760f, -0.00235630f, -0.00780083f, -0.01039744f, -0.07112960f, -0.07769441f, 0.03430298f, 
    0.03371688f, -0.06080431f, -0.01847036f, 0.02725316f, -0.06902654f, -0.01632426f, -0.02157913f, -0.02479853f, 
    0.03201043f, 0.06310689f, -0.04355568f, -0.04318273f, 0.03479202f, -0.03609751f, -0.00573660f, -0.00465789f, 
    0.05379911f, -0.00604790f, 0.00177065f, -0.06815202f, -0.00817283f, 0.06180823f, -0.04039601f, 0.04042412f, 
    -0.04166294f, -0.00442324f, -0.03278095f, 0.04731681f, -0.05762520f, -0.05203722f, -0.01522823f, -0.04969478f, 
    -0.01505973f, -0.04875880f, -0.00457761f, -0.07318151f, -0.04551011f, 0.04210830f, 0.01559748f, -0.04504472f, 
    -0.05805396f, -0.07525853f, 0.02584245f, -0.05513125f, 0.01065492f, -0.03207660f, 0.06682386f, -0.00141442f, 
    -0.06912993f, -0.07606988f, -0.06171015f, 0.02033082f, 0.00091221f, 0.01303004f, -0.01883166f, 0.06573211f, 
    -0.02216119f, 0.03750625f, -0.00202186f, -0.01847274f, 0.02162142f, -0.04747332f, 0.01441913f, 0.02276691f, 
    -0.04919321f, -0.02821126f, 0.01505812f, 0.01781402f, 0.04751206f, 0.00724822f, 0.02730659f, 0.05843025f, 
    0.02368944f, -0.02338666f, 0.05898578f, 0.06594784f, 0.03708307f, -0.05656420f, 0.05303632f, 0.02152331f, 
    -0.07753566f, -0.02650252f, -0.00687265f, 0.03780580f, 0.00505674f, -0.07069238f, 0.06575404f, -0.01723500f, 
    -0.37194583f, 0.17954803f, 0.20800366f, 0.04061249f, 0.16316760f, 0.17250031f, 0.01480097f, -0.03085145f, 
    0.10046700f, 0.06744580f, 0.10739374f, 0.04051625f, -0.11205794f, 0.09530789f, 0.01292954f, 0.16544500f, 
    -0.09541741f, 0.09484082f, 0.00612225f, 0.08493724f, 0.10041495f, -0.12109615f, -0.03591865f, 0.01310441f, 
    0.56602973f, 0.21422230f, -0.07002635f, -0.25254908f, -0.03206358f, -0.07619414f, 0.12430596f, 0.21506451f, 
    0.03106847f, 0.07474831f, -0.15924662f, -0.04091302f, 0.23978499f, -0.13836250f, 0.10341646f, -0.08102495f, 
    0.01528546f, -0.11884630f, 0.12823431f, 0.14585564f, -0.11211909f, 0.21035710f, 0.02262100f, 0.04042182f, 
    0.12054228f, -0.57948250f, 0.16713871f, 0.12243489f, 0.10723303f, 0.03205655f, -0.25019628f, -0.00285638f, 
    0.08556476f, -0.14831603f, -0.17020589f, -0.09979583f, 0.17197682f, -0.40946844f, 0.18730982f, -0.39491174f, 
    -0.09669670f, 0.00775201f, -0.12594594f, 0.01690056f, 0.07783128f, 0.13808705f, 0.13022664f, 0.13531102f, 
    -0.02764628f, 0.06712968f, -0.33911669f, -0.21179916f, -0.11948595f, -0.07984702f, -0.04120466f, -0.14845850f, 
    0.11395769f, -0.04292974f, -0.05613454f, -0.05326112f, 0.32012302f, -0.46087182f, 0.03030273f, 0.43169692f, 
    0.01590860f, 0.10028409f, -0.03493250f, -0.01934101f, 0.04130270f, -0.05714920f, 0.15982431f, 0.22789870f, 
    -0.10112888f, 0.01695372f, 0.02585517f, 0.23896219f, -0.40003043f, -0.14238857f, 0.08404066f, 0.27961946f, 
    -0.00000019f, 0.18777673f, 0.11090394f, 0.17728959f, 0.29763761f, 0.37074441f, -0.32635885f, 0.34864566f, 
    0.33554569f, 0.15974872f, -0.04257771f, 0.07323877f, -0.01086369f, -0.05388038f, 0.06295279f, 0.10515432f, 
    -0.23765071f, -0.18386316f, 0.21906920f, -0.27999884f, 0.01069348f, -0.02340900f, 0.10407775f, -0.07026593f, 
    0.06142877f, 0.11367549f, 0.12460903f, 0.03366263f, 0.27292019f, -0.29797992f, 0.09762287f, -0.13962235f, 
    0.02541234f, 0.17029700f, -0.04438258f, -0.14825624f, -0.05415663f, 0.09885743f, -0.05319348f, 0.15737717f, 
    -0.04178916f, 0.58999836f, -0.22183967f, -0.01394648f, 0.14388108f, 0.00969600f, -0.10835360f, 0.01963312f, 
    0.23377830f, -0.09922794f, -0.04713729f, -0.01809254f, -0.18327120f, -0.47472745f, -0.21567765f, 0.01341585f, 
    0.04321469f, 0.12328351f, 0.02036135f, -0.01784684f, 0.16189207f, -0.00210272f, 0.05384259f, 0.04141179f, 
    0.16406885f, -0.04668662f, 0.11831993f, -0.29144523f, 0.33287409f, -0.13206495f, -0.14891419f, 0.07370257f, 
    0.01980095f, 0.05621045f, -0.14605030f, -0.01258652f, -0.21775098f, -0.01892006f, 0.06832495f, -0.22131409f, 
    -0.05101863f, 0.11151452f, 0.25480697f, -0.11819826f, -0.01797750f, -0.01284720f, 0.06263959f, -0.06376365f, 
    0.43557298f, -0.31553337f, 0.28904635f, 0.06417541f, 0.00465626f, -0.09801782f, 0.03391760f, 0.06919432f, 
    0.09260488f, -0.07403740f, -0.20900558f, -0.01643039f, -0.23439397f, 0.21415092f, 0.25839010f, 0.13519797f, 
    0.07748406f, -0.10264052f, 0.01922179f, -0.00458600f, -0.05094870f, 0.03308136f, 0.02030204f, 0.06666216f, 
    -0.17242618f, -0.41090533f, -0.08268976f, 0.43612856f, 0.18276538f, -0.03519086f, -0.08804075f, -0.17655531f, 
    0.02392021f, 0.00988205f, 0.18523143f, -0.14035434f, -0.39048094f, 0.14626923f, 0.13227963f, -0.37441376f, 
    0.00046530f, -0.10070576f, -0.05730741f, -0.07427203f, -0.13329309f, 0.07971165f, -0.02667601f, 0.14993601f, 
    -0.22665894f, 0.28076014f, 0.19990543f, -0.13611260f, -0.03211677f, 0.00280245f, 0.18908046f, 0.01638627f, 
    -0.14260840f, 0.01603242f, 0.01701780f, -0.07076813f, 0.00675281f, 0.32879966f, 0.06779139f, 0.27929080f, 
    0.12375309f, 0.10570779f, 0.12999615f, -0.08348870f, 0.05396773f, -0.02043815f, 0.17924713f, -0.13036074f, 
    0.08701844f, 0.26885274f, 0.47050354f, 0.35446909f, 0.20062815f, 0.03326178f, -0.10420006f, -0.03493679f, 
    0.00721531f, -0.08932382f, -0.02120561f, 0.08071510f, -0.43598792f, 0.03928649f, 0.02207514f, -0.27280706f, 
    0.12766500f, 0.04610353f, 0.09604345f, 0.05479983f, 0.15492621f, 0.04753338f, -0.00554877f, -0.06572546f, 
    0.17640808f, -0.11356480f, -0.20928146f, 0.02096364f, 0.17629598f, 0.02550945f, -0.02560696f, -0.25898015f, 
    0.20671512f, 0.03700658f, 0.05322990f, 0.07839352f, 0.57823771f, -0.20362297f, -0.38499460f, 0.05860516f, 
    0.00748833f, -0.17928348f, -0.19364557f, -0.21353571f, 0.00614751f, 0.01188283f, -0.00960860f, 0.05749572f, 
    0.04209371f, 0.24180476f, 0.15906383f, 0.25623947f, 0.24810527f, 0.00248511f, 0.08578056f, 0.10568895f, 
    -0.17558734f, 0.09440572f, -0.01897873f, 0.05513566f, -0.48809278f, 0.21906485f, -0.00302638f, 0.18127444f, 
    0.12677072f, 0.07788896f, 0.16875029f, 0.11880541f, 0.07488906f, -0.12561840f, -0.00231064f, -0.13373685f, 
    0.17188831f, 0.37079656f, -0.20373644f, 0.03619353f, -0.22019181f, -0.08180667f, -0.25960937f, 0.12970950f, 
    0.05310142f, 0.14148127f, -0.01065079f, 0.01001749f, -0.26140124f, 0.27329889f, -0.00737122f, -0.09055885f, 
    -0.20393175f, -0.03125964f, -0.17143467f, -0.02156813f, -0.13074197f, 0.02123920f, 0.08363203f, -0.12912501f, 
    0.45827749f, -0.21655126f, -0.08399808f, -0.00981931f, 0.00480490f, 0.04979334f, -0.00056512f, -0.06747430f, 
    0.09175961f, -0.03472387f, 0.18851253f, -0.05303257f, 0.16366521f, 0.20112514f, -0.06984937f, -0.04783932f, 
    0.06012067f, 0.02975389f, -0.11435112f, 0.03880006f, 0.18192971f, 0.18111616f, -0.11039145f, -0.09666102f, 
    0.04242556f, 0.03377525f, 0.04024175f, -0.05838805f, 0.00291331f, -0.03947575f, 0.05159052f, 0.04232213f, 
    -0.02335567f, 0.05711388f, 0.01101228f, -0.03985039f, -0.04523196f, -0.02327404f, 0.06091939f, -0.05513843f, 
    -0.05610378f, -0.07511158f, 0.01423697f, -0.05729799f, -0.00455196f, -0.02441512f, -0.00072226f, 0.05802218f, 
    -0.03550847f, -0.02636673f, -0.03180942f, 0.00173205f, 0.01561509f, 0.05515100f, -0.04051278f, 0.01606247f, 
    0.03052271f, 0.04507558f, 0.05709099f, 0.07419163f, -0.03948006f, 0.00248963f, -0.07427552f, -0.04128052f, 
    -0.02758686f, 0.05653406f, -0.03109178f, -0.02227304f, -0.07781426f, -0.06724243f, -0.07193881f, 0.04182471f, 
    -0.03315724f, -0.02648892f, -0.06217865f, -0.05657548f, -0.01661918f, -0.03290862f, 0.03550404f, 0.03143786f, 
    -0.07524674f, -0.01369557f, -0.01416858f, -0.03351450f, 0.01996330f, 0.00123915f, -0.01767065f, -0.03969667f, 
    0.05613542f, -0.01282974f, -0.03255007f, 0.00083321f, -0.04305135f, 0.01950815f, -0.07851844f, 0.01273112f, 
    -0.06950234f, -0.04022363f, -0.07420830f, 0.03449062f, 0.03032866f, -0.00247156f, 0.03328618f, -0.06838508f, 
    -0.05214375f, 0.05819126f, -0.02023702f, -0.07513519f, -0.02699218f, 0.01895152f, 0.01735015f, -0.05227216f, 
    -0.07327374f, -0.07010835f, 0.01669723f, -0.07596929f, 0.00913488f, -0.00477362f, -0.02508759f, 0.02403787f, 
    -0.05416220f, 0.03139920f, -0.06353893f, 0.00897856f, 0.00741721f, 0.00975594f, -0.06639270f, -0.00252345f, 
    0.04982032f, 0.04555291f, 0.04884382f, 0.02102546f, 0.01832630f, 0.03967949f, -0.04387757f, -0.00000464f, 
    -0.06224091f, 0.05505105f, -0.06178624f, 0.05591775f, 0.02556156f, -0.05070636f, -0.04426454f, -0.03002252f, 
    0.02948684f, 0.04423334f, 0.05286188f, -0.01046985f, -0.03168991f, -0.01389672f, 0.01492516f, -0.00597264f, 
    0.06383885f, 0.02972874f, -0.04011952f, 0.01053771f, -0.02788929f, -0.01609867f, 0.04211761f, 0.02668234f, 
    0.04324764f, -0.01217109f, 0.03193282f, 0.00979000f, 0.00794503f, -0.01764294f, -0.01551491f, -0.01030490f, 
    -0.07247829f, -0.04417291f, -0.03123548f, -0.07743345f, 0.06711879f, 0.00125466f, -0.02645925f, -0.02381124f, 
    0.00061379f, 0.04008687f, 0.04798570f, -0.07382960f, -0.03679270f, -0.02874940f, -0.00079814f, -0.04909235f, 
    0.03963083f, 0.00345921f, -0.05737734f, 0.02174954f, 0.03367208f, 0.04307237f, 0.03822918f, 0.02377542f, 
    0.00459141f, -0.02192657f, 0.01620465f, -0.07013173f, -0.05193477f, -0.08047882f, -0.01841610f, -0.05732302f, 
    0.01290657f, -0.05452498f, 0.02423291f, -0.04746803f, -0.06332564f, -0.08311402f, 0.03984694f, -0.08184472f, 
    0.01718948f, -0.02906616f, -0.01845724f, 0.03528659f, -0.06220946f, -0.00036694f, 0.03254038f, 0.02281860f, 
    0.17129543f, 0.48046920f, -0.00009443f, -0.34384590f, 0.05056875f, 0.05140067f, 0.13307048f, -0.01073196f, 
    -0.02276842f, -0.07104039f, -0.01277689f, -0.08005365f, -0.30192766f, 0.26590672f, -0.00928900f, -0.22025013f, 
    -0.02086455f, 0.07279219f, -0.12423195f, -0.02186406f, 0.03134764f, -0.17503826f, -0.10945764f, -0.01179868f, 
    -0.15670893f, -0.05761609f, -0.13899416f, 0.30865026f, 0.12007564f, 0.03292139f, -0.07366388f, -0.02734206f, 
    0.17773622f, -0.09972180f, 0.02030565f, -0.24004744f, 0.25679523f, -0.22648750f, 0.06345299f, 0.14537065f, 
    -0.05203612f, -0.13804746f, -0.04811792f, -0.11500245f, 0.02869618f, -0.07289606f, -0.01437886f, -0.07864629f, 
    0.09595961f, 0.08472729f, -0.13170539f, 0.26910105f, -0.08356637f, -0.08712488f, 0.01072396f, 0.01579605f, 
    0.03408413f, -0.10813740f, 0.03096170f, 0.09592757f, 0.00492418f, -0.05274321f, 0.07701118f, 0.05152554f, 
    -0.05216244f, -0.02232938f, -0.15496260f, 0.11761736f, 0.16428582f, -0.00035644f, -0.00575652f, 0.12911431f, 
    -0.11443002f, -0.11714706f, -0.04832894f, -0.16933738f, 0.07384468f, -0.06109425f, -0.02586915f, 0.05155053f, 
    0.12212315f, -0.01782337f, -0.03116108f, -0.08258402f, 0.60395479f, 0.31670788f, -0.26274291f, -0.36244711f, 
    -0.05263959f, 0.15458290f, -0.01475668f, 0.08491575f, -0.01013989f, -0.03256318f, 0.02084355f, 0.02611958f, 
    -0.07115028f, 0.04582622f, -0.14972690f, 0.00544968f, 0.02314490f, 0.05237734f, 0.10804216f, -0.07412758f, 
    0.24447781f, 0.18884562f, 0.03226932f, 0.18026361f, 0.35980707f, 0.13945532f, 0.07780294f, -0.16568305f, 
    -0.14412926f, -0.03710883f, 0.03481011f, -0.00977125f, 0.05370989f, -0.02069841f, 0.07415280f, -0.00925795f, 
    -0.18609828f, 0.00750420f, 0.28325915f, 0.01908383f, -0.11213199f, -0.02638800f, -0.05629206f, 0.05768362f, 
    -0.04446960f, 0.13779932f, 0.02651409f, 0.10672282f, 0.44539952f, 0.02600377f, 0.32844272f, 0.23522480f, 
    -0.00961473f, 0.03066514f, -0.08184233f, 0.02256036f, -0.20718662f, -0.01511110f, -0.10586192f, -0.02569343f, 
    -0.35909659f, 0.14460576f, -0.08706600f, 0.05529333f, 0.02384781f, -0.04779966f, 0.04816544f, -0.00981680f, 
    0.07165245f, 0.07294460f, -0.06580714f, 0.16906855f, -0.08895773f, -0.02129603f, 0.10815254f, 0.30840856f, 
    -0.11707136f, -0.04983581f, 0.24222419f, 0.23604400f, -0.00971763f, 0.23327221f, 0.07938375f, 0.07490066f, 
    0.07926954f, 0.03902541f, -0.14152166f, 0.06132903f, 0.19882651f, -0.01184538f, 0.07953650f, 0.02524669f, 
    0.13649583f, 0.10504956f, -0.04115359f, 0.00021150f, 0.23900576f, 0.08723731f, 0.14327519f, -0.20208509f, 
    -0.30766770f, -0.01316951f, 0.18031417f, 0.16256283f, 0.15665908f, 0.13925646f, -0.06557187f, -0.03101384f, 
    0.19027355f, -0.32972443f, -0.14193845f, 0.04588716f, 0.04495353f, -0.02174971f, 0.01252734f, 0.17845476f, 
    0.08921837f, 0.16191165f, 0.02494194f, 0.11392423f, 0.53102630f, -0.46460751f, -0.41037691f, -0.07527888f, 
    0.01687658f, -0.02602861f, -0.01711785f, -0.00770039f, 0.06003337f, -0.00722805f, 0.23333766f, 0.08392982f, 
    -0.02406682f, 0.08693223f, -0.16075258f, -0.17586713f, 0.05558914f, 0.06009137f, 0.13397481f, 0.04982165f, 
    -0.09365982f, 0.27331275f, 0.03885310f, 0.36801067f, 0.20401174f, -0.03912600f, -0.00721797f, 0.09798931f, 
    0.12333829f, -0.04350073f, -0.20835322f, -0.03182511f, 0.00926073f, -0.09800632f, 0.01068094f, 0.23300378f, 
    0.39765769f, 0.18988006f, 0.15882100f, -0.03948745f, 0.17676163f, 0.16609254f, -0.01997049f, 0.05236172f, 
    0.04921013f, 0.17913269f, 0.17733788f, 0.04407060f, -0.04965151f, -0.02572241f, 0.49582329f, 0.14669149f, 
    0.03580061f, 0.03642203f, -0.00719664f, 0.02624770f, -0.09057460f, 0.02334209f, -0.16336146f, -0.07202771f, 
    -0.06013585f, -0.18713646f, -0.04629867f, -0.18638168f, 0.09352595f, 0.03316633f, 0.08729129f, -0.03399982f, 
    -0.00414531f, 0.04979072f, 0.03267777f, 0.06873501f, -0.31460872f, -0.24718642f, 0.04283311f, 0.08195354f, 
    -0.05231783f, 0.04442039f, 0.00788715f, -0.04709155f, -0.08458523f, -0.05776184f, 0.05158626f, -0.06171864f, 
    0.07368544f, 0.39524400f, 0.13854349f, -0.02292603f, 0.19384408f, -0.04245276f, -0.16168365f, 0.14915641f, 
    -0.02688513f, -0.15605718f, -0.14433515f, -0.09044807f, 0.11066136f, 0.08423209f, 0.13611521f, -0.02935292f, 
    0.21732286f, -0.00468026f, 0.18747230f, -0.08494029f, 0.12647299f, -0.02406230f, 0.02224606f, 0.06283953f, 
    0.04270048f, 0.12785329f, -0.22746487f, 0.15826270f, -0.05585949f, -0.14212796f, 0.11890148f, -0.13490105f, 
    0.18957999f, -0.07674331f, 0.01171577f, -0.08902870f, -0.10252465f, -0.13700259f, 0.09642442f, -0.00339516f, 
    -0.10724541f, -0.00895676f, -0.01737346f, 0.17190988f, 0.10893045f, -0.01522034f, 0.28088117f, 0.00087913f, 
    -0.02021817f, -0.16109572f, 0.02894021f, -0.02444695f, -0.05362899f, 0.05750351f, -0.00331658f, 0.00130862f, 
    0.15570289f, -0.11865665f, 0.16388081f, -0.04222435f, 0.77385235f, 0.04549756f, 0.02880215f, -0.05810519f, 
    -0.00872307f, -0.02381998f, -0.10521987f, -0.05696443f, 0.07926210f, -0.03064420f, 0.00348868f, 0.02084361f, 
    -0.01868716f, -0.03702820f, 0.00170701f, 0.23531081f, 0.10004110f, 0.01162972f, -0.04448628f, 0.06256647f, 
    -0.06925756f, -0.03773208f, -0.03898396f, -0.20472060f, -0.22532432f, -0.03550849f, 0.17475004f, -0.04077141f, 
    0.26432338f, -0.01126049f, -0.09827787f, -0.02928026f, -0.11844601f, 0.06263385f, 0.08487638f, 0.08465152f, 
    0.27173880f, 0.03219823f, -0.05683511f, 0.33441764f, -0.13461974f, 0.20268743f, -0.10226977f, -0.25037029f, 
    -0.12794107f, -0.05625227f, 0.16921844f, -0.11778387f, 0.08262794f, -0.27754191f, 0.17047295f, 0.25360775f, 
    -0.00539112f, -0.15915602f, 0.07012045f, -0.05240091f, 0.14784922f, -0.06246488f, 0.00040320f, -0.00525766f, 
    0.19799793f, 0.25996584f, -0.06047323f, 0.14260264f, -0.08663364f, -0.27529255f, -0.19488207f, -0.12813321f, 
    -0.11383085f, -0.34199482f, -0.16999204f, 0.00727934f, 0.08758834f, -0.11912248f, -0.09940831f, 0.21485405f, 
    0.18300286f, -0.33531684f, -0.02130817f, 0.19553733f, 0.03139156f, 0.07947855f, -0.02698222f, -0.32819483f, 
    -0.10298546f, -0.06061380f, -0.41205320f, 0.08191855f, 0.03806589f, -0.10558610f, -0.12301811f, 0.08950662f, 
    0.20668559f, -0.27817109f, -0.36661345f, -0.00508804f, -0.24714060f, -0.17602254f, 0.02030718f, 0.10163485f, 
    0.32586646f, -0.01638027f, 0.01531192f, 0.11646657f, 0.00922825f, 0.08175980f, 0.06755237f, 0.12020977f, 
    -0.13991840f, -0.16666889f, 0.11998016f, 0.15323515f, -0.15251222f, -0.06045402f, -0.01073118f, 0.10292253f, 
    -0.10575496f, 0.01914072f, -0.14357656f, -0.02691325f, 0.78943104f, 0.18689197f, 0.19010758f, -0.18895669f, 
    0.21699101f, -0.01875416f, -0.11432102f, 0.02118695f, -0.15888844f, -0.00576517f, 0.13512848f, 0.28324449f, 
    0.25594860f, -0.05180198f, -0.17768946f, -0.40175799f, -0.05377864f, -0.01453520f, 0.03772882f, -0.36154041f, 
    -0.20374398f, 0.10158076f, 0.08522283f, 0.06328502f, -0.23086128f, 0.21206416f, 0.17898619f, 0.11530992f, 
    -0.05009749f, 0.05812371f, -0.04458202f, -0.14604093f, 0.03497893f, 0.08978173f, -0.04137605f, -0.07847186f, 
    0.13640144f, 0.09220268f, 0.04304181f, 0.16621126f, 0.16027759f, 0.39473522f, -0.00417015f, 0.23523809f, 
    0.02560507f, 0.12545806f, -0.01679764f, 0.24186552f, 0.26398036f, 0.23536924f, 0.08477483f, -0.17916700f, 
    0.14082906f, 0.03975398f, 0.04359683f, 0.00143013f, 0.00521549f, -0.06938343f, -0.21553522f, 0.00689506f, 
    0.40240642f, 0.04929395f, -0.15556231f, 0.17204741f, 0.06478809f, 0.13631320f, 0.16537079f, -0.07714269f, 
    -0.25829411f, 0.26269558f, 0.05416661f, 0.03464811f, 0.19238371f, 0.12705041f, -0.18298608f, 0.01234258f, 
    0.01789790f, 0.05378486f, 0.34226894f, 0.25720495f, 0.10927466f, 0.09098768f, 0.12187774f, 0.17724352f, 
    0.28190273f, 0.30738491f, -0.05425700f, 0.05240585f, -0.15957345f, -0.08147594f, -0.07059050f, -0.32592848f, 
    -0.16533883f, -0.09625586f, 0.15090193f, 0.10517539f, 0.27064908f, -0.22635837f, -0.11578081f, 0.14650683f, 
    -0.03339259f, 0.00382640f, 0.02521322f, 0.12301086f, 0.11121802f, -0.10281204f, -0.27450636f, -0.19790511f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.15513952f, 0.02449533f, 0.11641901f, 0.09742018f, 0.02855879f, 0.24090932f, 0.08643320f, 0.08456980f, 
    -0.08470743f, -0.06578030f, 0.03453475f, 0.03042441f, 0.02605673f, 0.26052225f, 0.01919480f, 0.05455333f, 
    -0.02349389f, 0.00170184f, 0.18596561f, 0.02173066f, 0.11137745f, -0.02369162f, -0.07862818f, -0.13364069f, 
    0.09163389f, 0.02417006f, 0.06586119f, 0.03241926f, 0.04674855f, 0.01247194f, -0.00729668f, -0.04217670f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.46196485f, 0.03928795f, -0.17809105f, 0.29335612f, 0.08514673f, -0.66466063f, -0.19991189f, -0.20726261f, 
    0.37548551f, 0.01261975f, 0.27093709f, 0.16871786f, 0.11137652f, -0.54804564f, 0.18629245f, 0.35153931f, 
    0.00181003f, -0.18032013f, -0.05835406f, -0.01464495f, -0.54013950f, -0.12271228f, -0.05784976f, 0.31666815f, 
    -0.22501191f, -0.14338571f, -0.00252113f, -0.55109155f, 0.13659370f, -0.02836527f, -0.06719759f, 0.62695360f, 
    0.01104987f, 0.07423753f, 0.01979962f, -0.03323301f, -0.09954219f, -0.50133467f, -0.14140663f, -0.34539041f, 
    0.33058885f, 0.13657621f, -0.29784372f, -0.13857475f, -0.48702225f, 0.44169039f, 0.33440810f, 0.23555072f, 
    0.05396625f, -0.47325471f, 0.17896287f, 0.02099355f, -0.02306026f, 0.25957850f, -0.13351205f, 0.24552976f, 
    0.37617394f, 0.01348160f, -0.21369243f, 0.12954627f, 0.13713832f, -0.05604865f, 0.13732010f, -0.64633113f, 
    0.39985648f, 0.06674540f, 0.15331736f, -0.42616224f, -0.09980500f, -0.26642120f, 0.34026447f, -0.20748055f, 
    0.29746854f, 0.37055355f, -0.28529879f, 0.06337239f, 0.17706162f, -0.25519526f, -0.38289317f, -0.64001340f, 
    -0.28844202f, 0.25738835f, -0.10370518f, 0.11022542f, -0.62797463f, 0.13808799f, 0.13708545f, -0.03774371f, 
    0.15622877f, 0.00020156f, -0.30776784f, -0.55302829f, -0.11879890f, 0.42010963f, 0.18477587f, 0.20637123f, 
    -0.50922352f, -0.05673402f, 0.13318123f, -0.15222208f, 0.08464873f, -0.06020582f, 0.53142577f, -0.08918422f, 
    -0.96928287f, 0.00904439f, 0.26330307f, 0.06622997f, 0.34755552f, -0.63897783f, 0.19576833f, -0.01029046f, 
    0.25450113f, 0.12367283f, -0.12804145f, 0.11485270f, 0.06724855f, -1.03915644f, 0.12039996f, -0.16446148f, 
    0.25956833f, 0.09887701f, -0.08919483f, 0.33990464f, -0.01033710f, 0.05977649f, -0.84354806f, -0.12379896f, 
    0.03831476f, -0.09886045f, 0.36267814f, 0.17930883f, -0.15777446f, 0.14399713f, -0.20263705f, 0.10209726f, 
    -0.54730392f, 0.08278146f, -0.10073358f, -0.01276723f, -0.25313291f, 0.19549470f, -0.02314852f, -0.16097975f, 
    0.05236640f, 0.08453844f, 0.02517718f, -0.06732340f, 0.39886758f, -0.39317468f, 0.10977736f, 0.28675640f, 
    -0.51923549f, -0.03936828f, -0.37581071f, 0.20585269f, 0.06908838f, 0.21832424f, -0.30947113f, 0.19723132f, 
    0.23233466f, -0.15776953f, -0.02482919f, 0.22170936f, -0.10748293f, 0.07637858f, -0.64733350f, 0.01569183f, 
    0.19183350f, -0.79650807f, 0.30868119f, -0.01343750f, -0.15531649f, -0.22936442f, -0.00811820f, 0.28243929f, 
    -0.24356352f, -0.01580359f, 0.06183812f, 0.06370137f, 0.18135723f, -0.08417828f, -0.04083050f, 0.19446500f, 
    0.29920483f, -0.05135663f, -0.24562322f, 0.17580795f, 0.17115445f, -0.63065559f, 0.31235608f, -0.38696072f, 
    -0.05891116f, -0.00306374f, -0.12139200f, -0.01630106f, -0.14356557f, -0.02150351f, 0.41401011f, 0.36714691f, 
    0.00772347f, -0.02270027f, 0.03458357f, -0.13572900f, -0.56175727f, -0.17434382f, 0.04567799f, -0.60250014f, 
    -0.39505607f, 0.22628807f, 0.23785479f, -0.14300144f, 0.48726770f, 0.08167271f, 0.02342437f, -0.00126572f, 
    -0.22063835f, -0.01939947f, 0.49925509f, -0.92533088f, -0.10942582f, -0.11729023f, -0.11645757f, 0.14070216f, 
    -0.13900526f, 0.03079723f, -0.56814349f, -0.56881756f, -0.17087829f, 0.19823670f, -0.15313525f, 0.38717279f, 
    -0.27425000f, 0.21536554f, 0.17681855f, -0.05312692f, 0.11569560f, -0.35432002f, 0.05934908f, -0.17525876f, 
    -0.00727404f, 0.25539145f, -0.50390929f, 0.16172186f, -0.42526743f, 0.34083989f, 0.06440224f, -0.00145301f, 
    -0.56504148f, -0.02492386f, -0.39520416f, 0.37430027f, -0.01290425f, -0.13515398f, -0.19820404f, 0.45176533f, 
    0.44649455f, 0.12180934f, -0.74896848f, -0.52265155f, 0.03265921f, 0.10841517f, -0.17245692f, -0.60760403f, 
    -0.14811274f, 0.24727324f, -0.29352960f, 0.10898799f, -0.13707452f, 0.01216562f, -0.41341746f, -0.03484122f, 
    0.38985381f, -0.41018221f, -0.02650182f, -0.10550571f, 0.46211991f, -0.17704721f, 0.11699703f, 0.29831299f, 
    -0.08187812f, -0.06388355f, 0.24991821f, 0.33124465f, 0.06533303f, 0.34693980f, 0.35155788f, -0.29745752f, 
    -0.58161116f, 0.14922896f, 0.15295090f, 0.16308218f, 0.07433057f, 0.20565034f, -0.04370176f, 0.41750652f, 
    0.07662454f, -0.14735654f, -0.55519134f, 0.05874502f, 0.05772930f, 0.26116914f, -0.75743425f, -0.54097915f, 
    0.23729242f, 0.29680833f, -0.45398194f, -0.13946678f, -0.18090346f, 0.59425253f, -0.03256638f, -0.22218762f, 
    0.15206884f, -0.15543202f, -0.03448852f, -0.11717214f, 0.05495341f, -0.17586528f, 0.26570138f, 0.13669181f, 
    0.45272174f, 0.12812382f, -0.42330140f, -0.08950529f, -0.15135098f, 0.43047190f, 0.32985321f, -0.42571002f, 
    -0.45224833f, -0.04043510f, 0.25168628f, -0.04910436f, 0.25887412f, 0.60097897f, 0.35579208f, -0.05987229f, 
    0.35978854f, 0.03951014f, 0.08999709f, 0.08672343f, -0.15357853f, -0.19493614f, 0.06551829f, -0.75414056f, 
    -0.30038539f, 0.07517600f, -0.24454965f, -0.35915282f, 0.16582783f, -0.10445972f, 0.16860086f, -0.39348504f, 
    0.00081722f, 0.11007691f, 0.31410870f, -0.26323688f, 0.07481317f, 0.14977907f, -0.13021301f, 0.27778625f, 
    -0.22392350f, 0.12973374f, -0.10578249f, 0.05866129f, 0.15906838f, 0.09387307f, -0.11687659f, 0.40260011f, 
    -0.63412696f, -0.72148824f, 0.36160091f, -0.14707816f, -0.34540862f, 0.00267879f, -0.07477704f, -0.39265478f, 
    0.16419309f, 0.10975461f, 0.35899565f, 0.24885373f, 0.15675388f, 0.18947098f, -0.28457245f, -0.17266564f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04746538f, 0.13403995f, -0.21189104f, 0.04701105f, 0.10125478f, -0.04518646f, 0.06523044f, -0.06299953f, 
    0.02324010f, 0.02765605f, 0.23863071f, 0.06875055f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
