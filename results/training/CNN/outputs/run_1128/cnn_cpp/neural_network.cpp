#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.34289294f, -0.25588322f, -0.02830730f, 0.34061813f, 0.43553165f, -1.00749719f, -0.15326089f, -0.16539246f, 
    0.13387139f, 0.01059077f, -0.35166085f, 0.30493852f, 0.26241997f, -0.13853523f, -0.52129579f, 0.50250244f, 
    0.25333658f, 0.66663539f, 0.27165586f, -0.67751890f, -0.71346420f, -0.35159361f, 0.57289398f, 0.23638412f, 
    0.08944818f, 0.54515666f, -0.16201209f, -0.38812640f, -0.09344478f, -0.42992049f, -0.28875154f, 0.26570207f, 
    -0.69619608f, -0.17965843f, -0.10392347f, -0.21643998f, 0.69368678f, -0.85442489f, 0.68087828f, -0.22689494f, 
    0.12314717f, 0.02669419f, -0.07848749f, -0.01427613f, 0.61493140f, 1.02207839f, -0.32021028f, -0.20106114f, 
    0.16115750f, -0.33257967f, 0.22747788f, -0.13685966f, 0.14539264f, -0.13334940f, -0.74553126f, 0.19608100f, 
    0.10150649f, -0.07665237f, 0.44565400f, 0.47342399f, -0.51048839f, 0.30403915f, -0.69853628f, 0.61453193f, 
    0.36792523f, 0.21438348f, 0.07347060f, 0.24066654f, 0.24798499f, -0.03074703f, 0.76326978f, -0.36365837f, 
    0.41193077f, 0.41641429f, 0.35381857f, 0.03429768f, -0.27118689f, 0.66348451f, -0.22403921f, 0.05599417f, 
    -0.35899094f, 0.18790054f, 0.28063980f, 0.42807943f, -0.94868284f, 0.15408164f, 0.86939883f, 0.03782286f, 
    0.18862601f, 0.02671346f, 0.59368533f, 0.13801649f, 0.50868177f, 0.28077558f, -0.41004780f, 0.44931579f, 
    0.51991379f, 0.09305555f, -0.20899440f, -0.58246011f, 0.20292811f, -0.50969994f, -0.29229388f, -0.66032922f, 
    0.70135975f, -0.19957870f, -0.40251946f, -0.06551241f, 0.50744069f, -0.06831559f, 0.51393455f, -0.23852536f, 
    -0.39434186f, -0.16083752f, 0.04790294f, 0.22966988f, 0.12052684f, -0.80392754f, 0.12983449f, 0.37971613f, 
    -0.61896569f, -0.57500404f, 0.02852919f, -0.18032968f, -0.25555569f, -0.55828446f, -0.02761009f, 0.66716927f, 
    -0.13771936f, 0.31469336f, 0.22066966f, 0.67701882f, 0.01465569f, -0.45904243f, -0.16779871f, -0.38587323f, 
    0.79507613f, -0.41282892f, -0.44940984f, -0.66383195f, -0.63312709f, 0.68531209f, -0.16544583f, 0.18311413f, 
    0.56691939f, 1.04783964f, -1.03324354f, -0.04134822f, -0.06896763f, -0.45893157f, -0.36183795f, 0.35234326f, 
    0.23983797f, -0.59217757f, 0.23933437f, -0.11666420f, -0.11908104f, -0.49390328f, 0.45745993f, 0.28457600f, 
    0.77235997f, -0.38783008f, -0.38847139f, 0.38858771f, 0.17030707f, -0.29820544f, -0.10291053f, 0.56448734f, 
    -0.40596908f, -0.14471948f, 0.59279186f, -0.42267090f, -0.40143660f, 0.60657662f, 0.43826276f, 0.54494679f, 
    -0.33051351f, 0.14758131f, -0.28189856f, -0.37478986f, -0.08756553f, 0.61199963f, 0.58307028f, 0.40254888f, 
    -0.44153246f, -0.67212164f, -0.32039177f, -0.41759381f, -0.61289340f, 0.90226823f, 0.09939431f, 0.02578513f, 
    0.46158913f, -0.14069879f, -0.02563364f, 0.19941106f, -0.43923655f, 0.69422770f, -0.04788316f, -0.19090915f, 
    0.21495892f, -0.80590874f, 1.16756213f, -0.94543928f, -0.03405215f, -0.05034246f, 0.14669715f, 0.12845075f, 
    0.04784928f, 0.01427906f, 0.50333148f, 0.75324172f, -0.69999683f, 0.31106463f, -0.35618642f, 0.26377502f, 
    -0.65681911f, -0.18125387f, -0.06800566f, 0.31600702f, 0.48185357f, 0.54488784f, -0.01687500f, 0.61125326f, 
    0.03738198f, -1.02573383f, -0.67916274f, -0.38981915f, 0.85876185f, 0.36573052f, -0.07134398f, 0.17080058f, 
    -0.47079897f, -0.02556784f, -0.62853479f, 0.46841449f, 0.62492716f, 0.42301518f, 0.35012975f, -0.67499858f, 
    -0.48562428f, 0.05418375f, 0.40107581f, -0.00274668f, -0.09494866f, -0.41050911f, -0.03994232f, 0.16753341f, 
    0.08161139f, 0.24106993f, 0.48257080f, 0.59570253f, -0.44821969f, -0.23498425f, -0.43020698f, 0.80463964f, 
    -0.31860000f, -0.33630249f, -0.40179384f, -0.10972074f, -0.14673385f, 0.15215854f, -0.80967462f, -0.48611116f, 
    0.80300021f, -0.37312859f, 0.70484942f, 0.33174041f, -0.01893486f, -0.42520154f, 0.34515977f, 0.52389896f, 
    0.84083736f, 0.23866206f, -0.16710266f, -0.37822515f, -0.06553970f, -0.10190512f, -0.09069332f, -0.38857719f, 
    -0.05325443f, 0.10693820f, -0.61322683f, -0.89477599f, -0.74786383f, -0.24641661f, 0.08856717f, 0.32996878f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06934606f, 0.09832577f, 0.14549066f, -0.40742710f, 0.13113226f, 0.23430803f, -0.06029632f, -0.02644521f, 
    -0.22699359f, 0.05546948f, 0.06772655f, 0.06500349f, 0.26098329f, -0.08257905f, 0.14730407f, -0.14501466f, 
    -0.03193877f, 0.10318228f, 0.41002235f, 0.18079594f, 0.00723214f, -0.14435512f, -0.05953971f, -0.12455038f, 
    0.37226266f, -0.19752315f, 0.25600645f, 0.00142295f, 0.38460359f, 0.16632520f, -0.41632447f, 0.49167591f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.05216521f, -0.00074056f, -0.00502023f, -0.05307450f, -0.00370545f, 0.02132563f, -0.02487683f, 0.00742132f, 
    -0.02096071f, 0.04582075f, 0.02860751f, -0.06242712f, -0.00660257f, 0.02509540f, -0.04668787f, 0.04128779f, 
    -0.02268086f, 0.02514415f, 0.00340520f, -0.02625815f, -0.04796382f, -0.01610210f, -0.03208317f, -0.06602818f, 
    0.03381950f, 0.00603523f, -0.00955384f, 0.00043665f, -0.03815369f, -0.03944285f, -0.06251782f, -0.01174418f, 
    -0.04588001f, 0.02017494f, 0.01398346f, -0.02418202f, -0.01285603f, 0.03105551f, 0.01675273f, 0.03758621f, 
    -0.06770323f, 0.00242395f, -0.05672218f, -0.01971575f, 0.04343234f, -0.05927047f, 0.02812565f, 0.02945473f, 
    0.02161230f, -0.05788226f, -0.00704044f, -0.00000067f, -0.05603666f, 0.00771940f, -0.03159285f, 0.00619841f, 
    0.04059713f, -0.05314576f, 0.02651386f, 0.02181208f, 0.02949428f, -0.01925197f, 0.02406188f, -0.02930895f, 
    -0.01306843f, -0.06012604f, -0.01569282f, -0.00122859f, -0.01414207f, -0.05103156f, -0.05589208f, -0.05378027f, 
    0.04112825f, -0.00226142f, -0.00561361f, -0.01228147f, -0.02474479f, 0.00730915f, -0.01978649f, -0.02338595f, 
    -0.06082305f, 0.02694798f, -0.02161287f, -0.04569925f, -0.05947820f, 0.01852949f, 0.03960335f, 0.03079457f, 
    0.02260346f, -0.01525581f, -0.00583972f, 0.00600765f, -0.01713840f, -0.02657975f, 0.01711763f, -0.06259685f, 
    0.03204208f, 0.03197400f, -0.04141114f, 0.02723965f, 0.01855814f, -0.03168803f, -0.04277825f, -0.00381291f, 
    -0.05033907f, 0.03068971f, 0.04000476f, -0.05811938f, -0.06394672f, -0.02667723f, 0.00030978f, -0.01654859f, 
    -0.03325402f, -0.06304055f, 0.04679186f, 0.02547737f, -0.03999855f, -0.03150038f, -0.01048969f, -0.04087909f, 
    -0.00104703f, -0.05875722f, 0.03284263f, -0.00725030f, 0.04153000f, -0.00025410f, -0.02040948f, -0.00234949f, 
    0.04257746f, -0.04519678f, 0.04435971f, -0.04291286f, -0.03434648f, -0.06795654f, 0.04471470f, 0.04224649f, 
    0.03397272f, 0.02639222f, 0.04711544f, -0.06338486f, -0.03697724f, 0.04505678f, 0.00734271f, 0.04350865f, 
    -0.01487953f, 0.01845578f, -0.04962138f, 0.00764436f, 0.02008732f, -0.00389257f, -0.04781058f, -0.05270587f, 
    -0.03864281f, -0.00492987f, -0.06420787f, 0.00570090f, 0.02163594f, -0.02353675f, -0.00051368f, -0.02021765f, 
    -0.05932872f, 0.04588380f, -0.02965274f, -0.04571438f, -0.03453224f, 0.04579565f, -0.01347133f, -0.00957803f, 
    0.00368150f, -0.00877043f, 0.01420872f, 0.00487754f, -0.01333596f, 0.01796945f, -0.03629258f, -0.06290047f, 
    0.03054406f, -0.04653217f, -0.05697598f, -0.04990207f, 0.04206600f, -0.04442682f, -0.04515798f, -0.03070876f, 
    -0.06219772f, -0.00459633f, -0.03238609f, -0.06613399f, 0.01945186f, -0.04482234f, -0.00879996f, 0.01085737f, 
    0.02121796f, 0.03589534f, -0.02666140f, 0.01102686f, -0.03542405f, 0.02516035f, 0.00161948f, 0.00512251f, 
    0.04286490f, -0.06095950f, -0.01103389f, -0.02471690f, -0.03099467f, 0.00910924f, 0.01793820f, -0.00522268f, 
    0.02798744f, -0.00340800f, -0.05988495f, -0.06047250f, 0.02243128f, -0.01288843f, -0.01487294f, 0.03061965f, 
    -0.03793252f, -0.02553751f, -0.03049870f, -0.03888791f, -0.01115327f, -0.02735800f, -0.04406174f, 0.02224551f, 
    0.02431132f, 0.03659179f, -0.03453338f, 0.03645905f, 0.03780159f, 0.02492790f, 0.02574576f, -0.00024914f, 
    -0.00615809f, -0.06085252f, 0.02211158f, 0.04167021f, 0.04201641f, 0.01948437f, -0.05920207f, 0.04524206f, 
    -0.02452821f, -0.01736809f, 0.00920814f, 0.03913551f, 0.03462554f, -0.02239924f, -0.00232110f, -0.02189668f, 
    -0.04961397f, -0.02636950f, 0.05262355f, -0.02863262f, 0.02200589f, -0.02971147f, -0.03198547f, 0.00799188f, 
    -0.01692688f, 0.00345438f, -0.03335715f, -0.04585232f, 0.03512213f, 0.00417486f, 0.03909444f, 0.00284486f, 
    -0.01965195f, 0.01788094f, -0.05481163f, -0.00269513f, 0.04757239f, -0.03545300f, 0.02957454f, -0.03494738f, 
    0.00805579f, 0.02018256f, 0.01736511f, -0.02921266f, -0.02079313f, -0.02593263f, -0.05349574f, 0.04347327f, 
    -0.02672199f, 0.01054321f, 0.00605053f, -0.03026905f, 0.00004164f, -0.00836444f, -0.04329159f, -0.04013679f, 
    -0.20188963f, -0.67455864f, 0.18403950f, 0.05349238f, 0.15569119f, -0.13143502f, 0.09429277f, -0.08298200f, 
    -0.09691235f, 0.29554272f, -0.21530280f, -0.00628601f, 0.00452474f, 0.17607068f, -0.04461739f, 0.13664825f, 
    0.10280816f, -0.04137547f, -0.08771405f, 0.00965416f, 0.31683323f, 0.16915661f, 0.08521012f, -0.05243050f, 
    0.02375026f, -0.01249920f, 0.11236162f, 0.13790393f, 0.11470584f, -0.22299108f, -0.28885657f, -0.13907735f, 
    -0.26092187f, -0.05578676f, -0.10368872f, 0.12930381f, 0.21908756f, -0.25688127f, -0.16527487f, 0.21101344f, 
    0.08675902f, 0.05544884f, 0.08104762f, -0.20263633f, -0.04699646f, -0.07625663f, 0.08347531f, -0.06591241f, 
    0.03160900f, 0.09250684f, 0.01397143f, 0.18990432f, 0.00461339f, 0.15113936f, 0.13924830f, 0.11001290f, 
    0.30783051f, -0.19823523f, -0.18526499f, 0.05080301f, 0.02690942f, 0.00635440f, 0.15941612f, -0.07163503f, 
    -0.04957283f, -0.43130082f, -0.09798393f, 0.09963460f, 0.13890103f, 0.12170374f, 0.02063628f, -0.02261284f, 
    -0.14319709f, -0.09302098f, -0.11014228f, -0.07854308f, 0.09145561f, -0.05249562f, -0.01886072f, 0.06210392f, 
    0.03359576f, -0.26566213f, -0.42239496f, -0.23988070f, -0.00950038f, 0.27717981f, 0.09112404f, 0.05917965f, 
    0.08839153f, 0.07032289f, 0.10650658f, -0.06272475f, -0.28419742f, -0.02882549f, 0.19106765f, 0.04856452f, 
    0.18101327f, -0.01440579f, 0.04007960f, 0.02195577f, -0.15543966f, -0.04226727f, -0.06136108f, -0.10328885f, 
    -0.11451671f, 0.10178835f, 0.06485894f, 0.08593380f, 0.17105094f, -0.13327724f, -0.20175554f, 0.24203238f, 
    0.11125352f, 0.08062132f, 0.16385834f, -0.02037339f, -0.02665860f, -0.07597613f, 0.02979372f, -0.17259510f, 
    -0.04337856f, -0.04410103f, -0.14413342f, 0.11201903f, 0.02023444f, 0.31793949f, 0.26179308f, 0.10586566f, 
    0.07106063f, -0.13826874f, -0.11084763f, 0.07494743f, -0.03534637f, 0.08817887f, 0.19927868f, -0.07984947f, 
    0.01156864f, -0.49221948f, -0.10499089f, -0.20895040f, -0.14962825f, 0.24168122f, -0.14404985f, 0.02545753f, 
    0.09414179f, 0.04079225f, -0.34029964f, 0.07224014f, -0.19158219f, -0.08648384f, 0.17975116f, -0.10951861f, 
    -0.14424692f, -0.35848048f, -0.10002602f, 0.11276313f, 0.00671855f, 0.07286682f, 0.04997467f, 0.18159626f, 
    0.00453703f, 0.22714059f, -0.05973596f, -0.08970756f, -0.01995380f, 0.04514018f, -0.00936456f, 0.12907693f, 
    -0.01454746f, 0.00187012f, 0.03599008f, -0.08943332f, 0.01078457f, 0.22785436f, -0.21777549f, -0.12565908f, 
    -0.12647197f, -0.02639308f, 0.04194440f, 0.26158494f, -0.44447678f, -0.21581841f, -0.11618803f, 0.09447496f, 
    -0.04244159f, -0.12920773f, 0.03168096f, 0.12561110f, 0.11389481f, 0.30655763f, -0.05213992f, -0.00134124f, 
    -0.04643787f, 0.05007044f, 0.16927660f, -0.02833316f, -0.09016134f, 0.02261189f, -0.63226342f, -0.89212281f, 
    -0.33398163f, 0.11459190f, 0.10816060f, -0.08256233f, -0.03737367f, -0.05938800f, -0.05418000f, -0.12380694f, 
    -0.16295771f, 0.14981596f, -0.13331936f, 0.00150969f, -0.02451418f, 0.05929563f, -0.12249687f, 0.04608162f, 
    -0.04996557f, 0.19932945f, 0.31550804f, 0.07796220f, 0.04829551f, -0.07377645f, 0.08199783f, 0.02157393f, 
    0.05760574f, -0.15410310f, 0.26496431f, 0.48582110f, -0.33353329f, 0.04958615f, -0.19881067f, -0.05606557f, 
    -0.03202834f, -0.03152335f, -0.18658140f, -0.23588578f, 0.10372294f, -0.08180907f, 0.10450178f, 0.05238761f, 
    -0.04508266f, 0.05729741f, -0.10816848f, -0.11928383f, 0.31714547f, 0.35513067f, 0.08985175f, 0.02384957f, 
    -0.14673574f, 0.13734511f, 0.13108008f, 0.02807382f, -0.05180979f, -0.16200386f, -0.15279463f, -0.07085609f, 
    -0.06973340f, 0.13875724f, 0.23473088f, 0.08883356f, 0.15105815f, 0.17522143f, 0.25628516f, 0.33806163f, 
    0.05577339f, -0.01912241f, -0.02962351f, 0.03250198f, -0.08133347f, 0.16330732f, 0.06596712f, -0.03077975f, 
    -0.17387983f, 0.07495160f, -0.01291170f, -0.04070917f, 0.00318913f, -0.05864083f, -0.12697043f, -0.03409356f, 
    -0.16606656f, -0.41119084f, 0.10012523f, 0.01078163f, -0.00107992f, 0.08039951f, 0.03573155f, -0.08058842f, 
    -0.14607100f, 0.15228635f, -0.15298799f, -0.12226418f, 0.06100339f, -0.09011627f, -0.16941288f, -0.06114721f, 
    0.10255990f, -0.04319449f, 0.00840323f, -0.09627110f, -0.05929014f, 0.08401556f, 0.07610366f, 0.04532227f, 
    -0.37703890f, -0.28325742f, 0.03837271f, -0.01755374f, 0.22325192f, -0.02305194f, 0.01260760f, 0.01434080f, 
    -0.12745331f, -0.14562583f, 0.35027486f, 0.06467070f, 0.16006827f, -0.01670150f, 0.03134487f, -0.06331889f, 
    -0.07488546f, 0.06211986f, -0.00890783f, 0.10985097f, 0.06751087f, -0.13612306f, 0.08523245f, 0.13171978f, 
    0.25363508f, -0.19327337f, 0.05023661f, -0.11044966f, -0.13030133f, -0.06891670f, 0.02728272f, 0.00208335f, 
    0.19175261f, -0.18484530f, 0.07224926f, -0.08304064f, 0.15378615f, 0.29168949f, 0.02987710f, 0.08105115f, 
    0.01413010f, -0.07497791f, -0.11312439f, 0.05720368f, -0.03532076f, 0.03902084f, -0.00828899f, 0.09696215f, 
    0.07665532f, -0.24288025f, -0.05055949f, -0.13444048f, 0.16538377f, 0.05056753f, 0.00813951f, -0.04049262f, 
    -0.01803810f, 0.04806317f, -0.02922906f, -0.07531264f, -0.07640749f, 0.07042956f, 0.15981869f, 0.05617205f, 
    -0.11772666f, -0.01338010f, -0.19100003f, -0.17093241f, -0.04057788f, 0.22078319f, -0.04795695f, -0.12270726f, 
    0.09825591f, -0.04562590f, 0.24655421f, 0.09465200f, -0.25502631f, -0.10914189f, -0.04920767f, 0.19532022f, 
    0.01265803f, -0.01748689f, -0.18079315f, 0.20269530f, 0.00055333f, -0.12075791f, -0.01619500f, 0.05459604f, 
    -0.03953867f, 0.09510268f, -0.04055871f, 0.17477009f, 0.19150425f, 0.06861899f, -0.09333721f, 0.06307720f, 
    0.04788874f, 0.00025985f, -0.04077912f, -0.02437326f, 0.00781178f, 0.05691244f, 0.06346589f, 0.07649804f, 
    0.03951608f, -0.12223140f, 0.04750241f, -0.03495177f, -0.04655405f, 0.17300183f, 0.04130137f, 0.00324890f, 
    -0.12785254f, 0.10569182f, 0.16273257f, 0.03642668f, 0.16924797f, 0.25450224f, -0.14684986f, -0.09447988f, 
    -0.04826526f, -0.01635877f, 0.32252479f, -0.04439624f, 0.21930881f, -0.12605786f, -0.15446782f, -0.11856948f, 
    0.04977196f, 0.14749220f, -0.06579176f, -0.08285641f, 0.04119912f, -0.06682207f, -0.19277176f, -0.10501337f, 
    0.05520061f, 0.03186829f, -0.09890140f, -0.06931008f, 0.04860893f, -0.02565506f, 0.14659788f, 0.16093013f, 
    -0.25046995f, -0.15050581f, -0.05994399f, 0.04506747f, -0.07683451f, -0.06731449f, 0.04380508f, -0.01372305f, 
    -0.11236089f, 0.07046989f, -0.06704831f, -0.05111234f, 0.01726499f, -0.15519245f, -0.11965853f, 0.05728371f, 
    0.04845509f, 0.08841734f, 0.01719067f, 0.21788870f, 0.02418694f, 0.05144423f, 0.25975773f, 0.08099338f, 
    -0.08842521f, -0.01908452f, 0.05506318f, 0.22252740f, -0.12742427f, 0.20355093f, 0.06386968f, -0.08323506f, 
    -0.05527116f, 0.09378795f, 0.16874924f, 0.07773978f, -0.03720913f, 0.24265237f, 0.05272187f, 0.02443335f, 
    0.08326208f, 0.09386387f, -0.03498418f, 0.09198082f, 0.01659867f, -0.16482536f, 0.19561023f, -0.01679220f, 
    0.00671596f, 0.03331783f, -0.01008128f, 0.17203341f, 0.05392794f, 0.00571082f, -0.03549924f, 0.26366776f, 
    -0.00234341f, -0.17889772f, 0.18162185f, -0.03930361f, 0.16140391f, 0.01587394f, -0.09797337f, -0.15827569f, 
    -0.10492089f, -0.13100828f, -0.08151905f, -0.19682260f, -0.16064009f, 0.10805441f, 0.25506833f, 0.05233895f, 
    -0.15308729f, 0.06497944f, 0.03482717f, -0.06372294f, -0.20168322f, -0.02102533f, 0.03651606f, 0.04148545f, 
    -0.06160601f, 0.02071474f, -0.06826159f, -0.22604415f, 0.00631110f, 0.13305379f, -0.00987229f, 0.06716623f, 
    -0.17938687f, -0.01447506f, -0.18236141f, -0.69591689f, 0.05960771f, -0.10723614f, -0.10823736f, 0.03491342f, 
    -0.03705313f, 0.02444806f, -0.07696073f, -0.06212768f, 0.25925699f, 0.07200079f, -0.00759124f, 0.22311214f, 
    0.02954558f, 0.09884474f, 0.11953980f, -0.03768924f, 0.01103583f, 0.35488966f, 0.33376181f, 0.09462690f, 
    0.00452187f, -0.08635825f, 0.17452937f, 0.01955329f, -0.00124231f, 0.11360457f, -0.21387930f, 0.05582793f, 
    -0.00193010f, -0.01740462f, 0.17600036f, -0.00804530f, -0.03053923f, -0.04281677f, -0.09797738f, 0.05926026f, 
    0.12207232f, 0.26273954f, -0.01226815f, -0.03385728f, 0.06964041f, 0.13307245f, 0.16423765f, 0.11864105f, 
    0.05934099f, 0.00326697f, 0.06479312f, -0.05361438f, 0.03715376f, -0.09562658f, 0.08416394f, -0.02983028f, 
    -0.03507272f, 0.11780631f, -0.25331089f, -0.35885084f, -0.35513034f, -0.29446492f, 0.23108597f, 0.02337109f, 
    0.02030621f, -0.03018992f, -0.02877578f, 0.11678108f, -0.24467660f, -0.11257373f, -0.15327507f, -0.24843322f, 
    0.06478491f, 0.08864929f, -0.14173184f, -0.02342052f, 0.12519604f, -0.03178949f, 0.06672663f, 0.02700582f, 
    0.06983327f, -0.06526291f, 0.19140127f, 0.03720433f, -0.15161812f, 0.15848488f, 0.04513803f, -0.00533661f, 
    -0.13203290f, 0.13222365f, -0.05103307f, 0.15623042f, 0.01192512f, -0.06081947f, -0.08746022f, -0.09360281f, 
    0.06424238f, -0.11808030f, 0.01742093f, -0.07537721f, 0.14453337f, 0.07692610f, -0.03954363f, 0.15728560f, 
    0.25221291f, 0.02411516f, -0.05450461f, 0.08575125f, -0.19476712f, 0.25554046f, -0.04346537f, -0.05149308f, 
    0.05230544f, 0.20203128f, 0.15813522f, -0.09482832f, 0.07954761f, 0.07818196f, 0.22860551f, 0.02070624f, 
    0.00852737f, 0.02745395f, 0.06698743f, 0.17600161f, -0.08175149f, 0.03768611f, 0.10006846f, 0.08976491f, 
    -0.00610672f, 0.09268097f, 0.10023761f, 0.11827327f, 0.01121843f, 0.10196623f, -0.08689488f, -0.04063830f, 
    0.11805562f, -0.02237729f, 0.05530325f, -0.37534356f, -0.37492245f, -0.12515318f, 0.00791958f, 0.08718350f, 
    0.03198699f, 0.18483211f, -0.17604351f, -0.09344604f, -0.03031263f, -0.18172128f, 0.04827430f, -0.04366884f, 
    -0.05021762f, 0.00365299f, 0.02695104f, 0.05054567f, -0.04199658f, -0.36461765f, -0.32607386f, 0.22091401f, 
    -0.02164170f, -0.06559721f, 0.04844366f, 0.25723663f, -0.07012478f, 0.25136769f, -0.00304941f, 0.24088047f, 
    0.28035614f, -0.20815310f, -0.13041095f, -0.08528040f, 0.10673461f, 0.00216152f, 0.07825128f, -0.36432073f, 
    0.17424393f, 0.13892283f, 0.05280996f, -0.17124237f, -0.02826358f, -0.10003525f, 0.10001845f, 0.17851201f, 
    0.29909590f, 0.27397043f, -0.08772605f, -0.00841409f, 0.22112536f, 0.06572603f, -0.09922737f, 0.10333947f, 
    0.09526302f, -0.05308833f, 0.16937889f, -0.04583562f, -0.00158754f, 0.14102425f, -0.04756057f, 0.09231852f, 
    -0.00848021f, 0.01295370f, 0.01239853f, -0.11815612f, 0.17844090f, -0.07474130f, 0.10136013f, -0.02204098f, 
    -0.07668386f, 0.15216444f, -0.08289915f, 0.04217131f, -0.02523303f, -0.22884147f, 0.09850567f, -0.12910990f, 
    0.00041882f, 0.09123337f, -0.01950721f, -0.06046821f, -0.03231279f, 0.11240459f, 0.01666211f, 0.10015286f, 
    0.05516275f, 0.03165836f, -0.06142637f, -0.06014901f, 0.09083950f, 0.25368664f, 0.00732936f, -0.04969804f, 
    0.08974712f, -0.08756822f, -0.18153854f, 0.20573273f, -0.23605336f, 0.09707040f, -0.07946561f, 0.61374664f, 
    -0.42279464f, 0.00544042f, 0.09254306f, -0.11511876f, 0.03905528f, 0.11036941f, -0.08672916f, 0.13534111f, 
    0.23670499f, -0.03935303f, -0.01591180f, 0.04858373f, -0.11107507f, 0.12565023f, -0.22441454f, -0.00960853f, 
    0.29673067f, -0.02967276f, 0.03937990f, -0.05337290f, -0.12293049f, -0.05286236f, 0.06281063f, -0.02680477f, 
    0.02870066f, 0.01907881f, -0.76926321f, -0.39583161f, -0.07584275f, -0.37836868f, -0.05461390f, 0.17011467f, 
    -0.00294269f, -0.17459418f, 0.09585027f, 0.06424820f, -0.06060264f, 0.06060619f, 0.05533962f, -0.00913781f, 
    -0.25667351f, 0.19061516f, 0.15109588f, 0.13604440f, -0.04435738f, -0.05536078f, 0.00210364f, 0.00041421f, 
    0.18283096f, 0.02730633f, 0.08054941f, 0.00119843f, -0.54044509f, 0.01063747f, -0.62675029f, 0.06743557f, 
    -0.02693442f, 0.09664849f, 0.04472214f, -0.02562106f, -0.14527136f, -0.08154318f, -0.36414871f, -0.60636866f, 
    -0.06729907f, -0.00436980f, 0.06316838f, 0.20859022f, -0.02578807f, -0.13410658f, 0.15770268f, 0.03382527f, 
    -0.09292125f, 0.04130104f, 0.03397836f, 0.03752926f, -0.11934561f, -0.03801347f, 0.13139325f, -0.31222636f, 
    0.16608728f, 0.27436879f, 0.00877091f, 0.03145690f, 0.01985376f, 0.03139520f, -0.00345816f, 0.07764013f, 
    -0.00715135f, -0.01048709f, -0.31156805f, -0.18346664f, 0.02632971f, -0.00062227f, 0.05295702f, -0.02137513f, 
    -0.18822470f, 0.09000092f, 0.03387975f, 0.09904656f, 0.11630486f, 0.05307212f, 0.05918758f, -0.01898824f, 
    0.22448134f, 0.18677261f, 0.06331371f, -0.12468841f, -0.05347603f, 0.10014490f, -0.04625348f, -0.00359861f, 
    -0.03476190f, 0.03125211f, 0.07225753f, 0.26023549f, 0.23547372f, 0.11998662f, 0.14271782f, -0.05496024f, 
    0.06599451f, -0.07068306f, -0.13532698f, -0.08464491f, -0.04037713f, -0.05928320f, 0.04124061f, 0.09476819f, 
    0.10047439f, 0.03500364f, 0.15045127f, -0.05531693f, 0.17563914f, -0.04056570f, -0.11185605f, -0.22787239f, 
    0.00366960f, 0.25953221f, -0.03763785f, -0.14773215f, -0.24953048f, -0.15132971f, -0.06954543f, -0.01381937f, 
    0.18560821f, 0.09457117f, 0.24740411f, -0.03500482f, -0.24969798f, -0.23492941f, -0.08724327f, -0.01593203f, 
    0.14255707f, -0.03404216f, 0.10209569f, 0.05459960f, 0.00313929f, 0.07616974f, -0.03283270f, -0.01451137f, 
    0.02047597f, -0.12259880f, -0.05249066f, 0.09151260f, 0.07018173f, 0.08805198f, -0.01074742f, -0.31612381f, 
    0.00938912f, 0.04923938f, -0.00570419f, -0.03204529f, 0.04644805f, 0.10924882f, 0.01950172f, 0.20651995f, 
    -0.31295919f, 0.00813312f, -0.12526959f, -0.01274331f, 0.01988489f, 0.15286383f, 0.09151459f, -0.01307617f, 
    0.01633091f, -0.05764538f, 0.11907637f, -0.00297357f, 0.17830592f, 0.14006107f, 0.01594998f, 0.12946491f, 
    -0.14726044f, 0.01461893f, -0.04606125f, -0.07058284f, -0.20030758f, -0.20731212f, -0.12403215f, 0.00225782f, 
    0.17183214f, 0.06270758f, 0.10489946f, -0.02289268f, 0.10720592f, 0.01671549f, 0.11513148f, 0.24661340f, 
    0.07140464f, 0.00461077f, 0.00483184f, 0.07800625f, 0.01852312f, -0.20587274f, 0.13019677f, -0.02809276f, 
    -0.06757785f, -0.03819239f, 0.10920779f, -0.06661402f, -0.06734508f, -0.23615432f, -0.09033407f, 0.01412471f, 
    0.29199231f, 0.09854937f, 0.07151391f, 0.05348618f, 0.11184122f, 0.03750991f, 0.16892156f, 0.14156163f, 
    -0.00999418f, -0.01758495f, -0.39918727f, -0.25194147f, 0.17159928f, 0.09304327f, 0.07339431f, -0.04350638f, 
    -0.06924023f, -0.13581166f, 0.13688935f, 0.15084809f, 0.03642374f, 0.02919050f, -0.15430513f, -0.24979588f, 
    0.20236506f, -0.04910959f, 0.03178279f, -0.20851251f, 0.14776881f, -0.11367840f, 0.03000041f, -0.07722998f, 
    0.07428262f, -0.18375286f, 0.08161001f, 0.05985157f, 0.03771506f, 0.15084060f, -0.01182919f, -0.06607688f, 
    0.08058220f, -0.20963183f, -0.19894688f, -0.20537345f, -0.13830657f, -0.07516056f, -0.03982036f, 0.03383024f, 
    0.07009628f, 0.10518502f, -0.07034571f, -0.26269129f, -0.10144417f, 0.11884336f, 0.05000266f, -0.19732669f, 
    0.06836702f, 0.09883987f, -0.14499782f, 0.04140021f, -0.09245922f, 0.02524250f, -0.14542818f, -0.08780158f, 
    -0.22179711f, 0.19812955f, 0.16066632f, 0.16380768f, -0.11350241f, -0.08478446f, 0.03608426f, -0.01368570f, 
    0.17306367f, -0.05045617f, -0.16085994f, -0.13319363f, -0.13843416f, 0.02034255f, 0.02263100f, -0.14341831f, 
    0.05462809f, -0.00112932f, 0.03604634f, -0.01386452f, -0.11439318f, -0.05247791f, 0.11151396f, 0.07666848f, 
    0.12322975f, 0.18422100f, 0.16920394f, -0.22648887f, -0.05118524f, 0.00667254f, 0.06264210f, -0.07816470f, 
    0.02216291f, 0.06254821f, 0.00935162f, -0.12280262f, 0.08603991f, 0.17591429f, 0.00036516f, 0.02169357f, 
    0.10192183f, -0.06075385f, -0.02730919f, 0.06220733f, 0.09496316f, 0.12934230f, -0.08801783f, -0.14711621f, 
    0.03840974f, 0.11821598f, 0.10521976f, 0.16056752f, 0.06166704f, 0.14717373f, -0.12251000f, -0.02871526f, 
    0.16331096f, 0.06339227f, 0.06888383f, -0.16847651f, -0.07964101f, 0.27959681f, -0.03588600f, -0.08220059f, 
    0.00209558f, 0.03220349f, -0.07345354f, -0.09815831f, -0.05841103f, -0.01281579f, 0.10448895f, -0.08412415f, 
    0.01304147f, 0.12317213f, 0.20512460f, 0.07115521f, -0.17522779f, -0.13556176f, 0.04696095f, 0.11403307f, 
    0.12199233f, 0.10272858f, -0.00175540f, 0.14031801f, 0.03701031f, 0.08283482f, -0.08075922f, -0.14460483f, 
    0.02126687f, -0.06375965f, -0.02469049f, 0.04110814f, 0.04546379f, 0.03657786f, 0.00035657f, -0.02141224f, 
    0.04348073f, -0.03748538f, -0.05029316f, -0.04629285f, 0.00575571f, 0.01077135f, -0.00935508f, 0.04300572f, 
    -0.02250369f, -0.02741673f, -0.05066459f, -0.05257824f, -0.04585897f, 0.00977199f, -0.02193542f, -0.06042882f, 
    0.01923453f, -0.03010451f, 0.03253475f, -0.02238225f, 0.01311906f, -0.05828276f, -0.00470897f, -0.01923273f, 
    -0.04502880f, -0.04574361f, -0.04004584f, -0.01495207f, -0.04215057f, 0.03333275f, -0.00611366f, 0.02635759f, 
    0.02940426f, 0.04791896f, -0.02339044f, -0.03794049f, -0.05647394f, -0.06088218f, 0.00973067f, -0.04888760f, 
    -0.04311166f, 0.02537132f, -0.03157684f, -0.03741458f, -0.01773029f, 0.03766688f, -0.06136855f, -0.01980495f, 
    0.01865726f, -0.01520669f, -0.05705263f, -0.04090224f, -0.00374404f, -0.02194707f, 0.02763403f, 0.04367386f, 
    0.00312829f, -0.05644390f, -0.04394232f, -0.01138715f, 0.02176994f, 0.05093557f, 0.02220986f, -0.03425210f, 
    -0.06094290f, -0.00804257f, 0.00235462f, 0.01615007f, 0.04601707f, -0.02606630f, -0.02299334f, -0.01123999f, 
    -0.01051944f, 0.02862518f, 0.02255882f, -0.04554999f, 0.03901563f, 0.02058640f, 0.02262697f, -0.01748234f, 
    0.05112275f, -0.02922305f, 0.02625134f, -0.02637103f, 0.00067269f, -0.03840580f, 0.03793136f, -0.00580701f, 
    -0.02518692f, -0.02223575f, 0.00952410f, 0.00689555f, -0.00577038f, -0.00485692f, 0.03173870f, 0.04110046f, 
    0.00359437f, 0.02216365f, -0.00806960f, -0.02979713f, -0.01805962f, -0.03844960f, -0.02616257f, 0.04762564f, 
    -0.01017654f, -0.05866499f, -0.02088850f, -0.01055957f, -0.03045815f, -0.02312649f, -0.00322688f, 0.02310324f, 
    -0.02699677f, -0.03110776f, -0.01669165f, 0.01652224f, -0.03810244f, -0.05182912f, 0.03159065f, -0.03209274f, 
    0.00001974f, 0.00807093f, -0.05152827f, 0.03232732f, 0.04721288f, -0.06188157f, -0.05741929f, 0.05322650f, 
    0.04857634f, 0.04410541f, 0.04605649f, 0.00416419f, 0.04041806f, -0.00659298f, -0.01171694f, 0.03763834f, 
    -0.00818058f, 0.03826576f, -0.01067168f, -0.04474747f, 0.01068781f, -0.04667429f, 0.04069756f, -0.01113060f, 
    -0.00656526f, 0.02973416f, -0.02081336f, -0.05179856f, -0.05974057f, 0.03262540f, -0.04052855f, -0.03000614f, 
    0.00197500f, 0.04200833f, -0.02055534f, 0.00418145f, -0.04977018f, 0.04800412f, 0.02279172f, 0.02961072f, 
    0.02390295f, -0.02932435f, -0.05875041f, -0.01125311f, -0.03560105f, -0.06241573f, 0.05138371f, -0.02779599f, 
    0.03550207f, -0.04619064f, -0.04811690f, 0.04012278f, -0.00435968f, -0.00485528f, 0.04912073f, -0.01739207f, 
    -0.01934789f, 0.01843464f, -0.05495113f, -0.03839348f, 0.03681314f, -0.01556440f, 0.00576069f, 0.03933798f, 
    0.03223458f, 0.03564033f, 0.02608365f, 0.04503000f, -0.03574825f, -0.02996622f, 0.05246773f, -0.04836518f, 
    -0.05868313f, 0.02688815f, -0.05660028f, -0.00063967f, 0.03321581f, 0.01104403f, -0.06106241f, -0.02304884f, 
    -0.00901973f, -0.05277616f, 0.03021444f, -0.01610010f, 0.00691317f, -0.00260422f, -0.02064542f, -0.02326451f, 
    0.00689195f, 0.00529095f, 0.02448130f, -0.02599005f, -0.02396418f, -0.01163942f, 0.04554022f, -0.04184248f, 
    -0.02850189f, -0.01824254f, 0.03174256f, 0.00225139f, -0.04853570f, -0.04504024f, -0.05617547f, -0.03920217f, 
    -0.03360734f, -0.06428876f, 0.01249926f, 0.02956186f, -0.04061787f, 0.01400375f, -0.03589400f, 0.00322434f, 
    0.00403074f, 0.02990412f, -0.05461288f, -0.03816651f, -0.01823569f, -0.04154781f, -0.06093952f, -0.01816564f, 
    0.00612969f, 0.02382798f, -0.03254931f, -0.01966495f, -0.00769790f, -0.01917120f, -0.00364132f, 0.04041741f, 
    -0.03578767f, 0.01216557f, -0.01911684f, 0.02784414f, 0.01030010f, 0.00415433f, 0.00944742f, -0.02565248f, 
    0.01717437f, 0.03206099f, 0.04060175f, -0.00692103f, -0.05509024f, 0.01678012f, 0.00301765f, -0.01415460f, 
    -0.05393552f, 0.04794763f, -0.03799012f, 0.02400953f, -0.04601358f, -0.00658777f, 0.04969490f, 0.01167171f, 
    -0.02995998f, -0.03873869f, -0.00826775f, -0.06194592f, -0.00691992f, 0.03785045f, -0.04791848f, -0.04158150f, 
    0.02724367f, 0.03072141f, -0.01183159f, -0.02246129f, -0.06546032f, -0.00385174f, -0.03458345f, -0.02184035f, 
    -0.06173374f, 0.00626939f, 0.01261877f, 0.03297057f, 0.02589296f, 0.03122704f, 0.00100902f, -0.01347777f, 
    -0.04071510f, 0.00037913f, -0.04209222f, 0.03280666f, -0.04712705f, -0.04358175f, -0.05439239f, -0.00862036f, 
    -0.02637877f, 0.01084307f, -0.03678394f, 0.01476853f, -0.05553051f, 0.02659337f, 0.00781686f, 0.02597739f, 
    0.04896488f, 0.01880550f, 0.04277674f, -0.00587031f, -0.02265880f, -0.00804859f, 0.03585773f, -0.04811850f, 
    -0.05191634f, -0.04497230f, -0.01098455f, 0.02627972f, -0.02570518f, -0.00873133f, -0.02119679f, 0.02466469f, 
    -0.03286649f, 0.03953930f, -0.02456803f, 0.02492857f, -0.05206758f, 0.00371242f, 0.01894868f, 0.00690588f, 
    -0.04769691f, -0.01210070f, -0.05898683f, -0.04924471f, -0.02299494f, -0.00041241f, 0.01851679f, -0.03124324f, 
    -0.00894169f, -0.01197330f, 0.04480381f, 0.04656870f, 0.01941844f, 0.05055114f, -0.06289585f, -0.06431271f, 
    -0.05452000f, -0.06082510f, -0.03370702f, -0.01273564f, 0.00106622f, 0.05047042f, 0.01874071f, 0.02752921f, 
    0.00040189f, -0.05860516f, -0.04698928f, -0.01617717f, -0.00561359f, -0.06676587f, -0.04305973f, 0.01020038f, 
    -0.06658287f, -0.00331938f, 0.02571140f, -0.05744871f, -0.04794100f, -0.05439369f, 0.03451813f, 0.02041319f, 
    -0.04318027f, -0.02705538f, -0.04151575f, -0.05658479f, -0.06621289f, -0.05093608f, -0.02516479f, -0.00097645f, 
    0.01993801f, 0.05237874f, -0.05725783f, -0.04918354f, 0.00476501f, -0.01609464f, -0.03194031f, 0.03329610f, 
    0.01244935f, 0.01692713f, -0.05992932f, 0.04353754f, 0.00379779f, 0.01564677f, -0.05619144f, 0.02949313f, 
    -0.05628330f, -0.01795719f, 0.03339499f, -0.01486423f, -0.04190827f, 0.02768605f, -0.03578661f, -0.04885247f, 
    0.03863048f, -0.01740490f, 0.00299196f, 0.04671776f, -0.05092952f, 0.05009814f, -0.04568303f, 0.03054569f, 
    -0.00646864f, 0.01218695f, 0.04807038f, 0.01489627f, -0.02279188f, 0.04588744f, -0.05432566f, -0.01116735f, 
    -0.00651569f, -0.04885734f, -0.06077434f, -0.01121092f, 0.00192433f, 0.00560773f, 0.03282586f, -0.05113037f, 
    0.04699002f, 0.03947858f, -0.05918087f, -0.06632123f, -0.02457637f, 0.00119886f, 0.00718895f, -0.02892033f, 
    -0.06128724f, -0.00848822f, -0.04556968f, -0.04959692f, -0.05520125f, -0.02149964f, -0.02357303f, -0.06179092f, 
    -0.04114414f, -0.01116857f, -0.00726769f, 0.03419480f, 0.00357398f, -0.01561116f, 0.00625683f, -0.05183294f, 
    -0.00502139f, -0.03340328f, 0.04750010f, -0.05226011f, -0.05241719f, 0.00595072f, -0.00045625f, 0.02798993f, 
    -0.01618263f, 0.02768765f, -0.01844289f, 0.04428638f, 0.05130122f, -0.05920700f, -0.05577341f, 0.03615510f, 
    0.03737129f, -0.00046261f, -0.02438049f, 0.00224313f, -0.04351778f, 0.01005256f, -0.05950280f, -0.04599302f, 
    -0.02327673f, -0.00278771f, -0.02981090f, 0.02792437f, 0.01974817f, 0.04818999f, -0.06262963f, 0.03248877f, 
    0.00661253f, -0.02905707f, 0.01870371f, -0.01210792f, -0.01459240f, 0.00774570f, -0.00781590f, 0.04394457f, 
    -0.05383617f, -0.00731947f, -0.04106965f, 0.02232248f, -0.06788754f, 0.01540524f, -0.03421285f, 0.03348843f, 
    -0.04827745f, 0.02066109f, -0.05406334f, 0.01885652f, -0.00327903f, 0.05296125f, -0.05702972f, -0.02451531f, 
    -0.02200241f, -0.05996669f, 0.02691604f, -0.04692218f, 0.00019276f, 0.00045428f, -0.02228516f, 0.04190079f, 
    0.04840012f, 0.00820816f, 0.00315665f, -0.06985291f, 0.01412975f, 0.00849581f, -0.03161027f, -0.01740499f, 
    0.00842838f, 0.05352135f, -0.05040271f, 0.05048012f, 0.04358698f, 0.04916898f, -0.05680776f, -0.00442399f, 
    -0.01243623f, 0.02008090f, 0.02181778f, 0.02925352f, -0.01640271f, -0.03156013f, -0.05270981f, 0.05255225f, 
    -0.02372600f, -0.01462202f, 0.04457417f, -0.03141204f, 0.02425781f, -0.01961263f, -0.05604135f, 0.03197886f, 
    0.06060902f, 0.00288896f, -0.01091182f, 0.03903892f, -0.00205347f, 0.04507445f, -0.05265893f, 0.03371973f, 
    -0.02988357f, 0.00907336f, -0.01502965f, -0.00370486f, -0.03735921f, 0.04241681f, 0.01236697f, 0.05017017f, 
    -0.05982542f, -0.04687370f, 0.04880090f, -0.04723806f, 0.02767340f, -0.02156118f, 0.00525946f, 0.01958346f, 
    -0.05684871f, 0.00502028f, -0.05594656f, 0.03641629f, -0.03106540f, 0.04021778f, -0.00810522f, 0.01585497f, 
    -0.00800006f, -0.03958169f, 0.00040547f, -0.03023423f, 0.03185531f, -0.03669387f, -0.00236463f, 0.05066001f, 
    -0.04152568f, 0.02277706f, 0.03800153f, -0.00903947f, 0.04251519f, 0.02515922f, -0.05479934f, -0.02492635f, 
    0.00240531f, 0.03705600f, -0.03117587f, -0.04298464f, 0.03586319f, 0.03504987f, 0.01538627f, -0.05497641f, 
    0.03308162f, -0.04275566f, -0.01760902f, -0.03921087f, 0.00871100f, -0.04656595f, -0.03136585f, -0.03282650f, 
    -0.04002881f, -0.05700001f, -0.02395397f, 0.05184995f, -0.02082762f, 0.03421319f, -0.04298082f, -0.03059030f, 
    -0.04643665f, 0.02627472f, 0.03075035f, -0.01271924f, -0.00972490f, -0.03562585f, -0.04105875f, -0.00061366f, 
    0.01404704f, -0.04607994f, -0.03750219f, 0.01108980f, -0.01292645f, -0.02505909f, -0.03819747f, 0.05190961f, 
    -0.00150542f, -0.04304124f, -0.06412155f, 0.00277858f, -0.01590701f, -0.04564967f, 0.00948157f, 0.03984188f, 
    0.03282368f, -0.03886646f, 0.01304094f, -0.03854466f, -0.01267735f, 0.00621254f, -0.02435112f, -0.00098513f, 
    -0.00749994f, -0.01783172f, 0.03516883f, -0.05825403f, -0.04480004f, -0.04119001f, 0.00479695f, 0.05245967f, 
    0.05087317f, -0.03290057f, 0.03249957f, 0.05059522f, 0.01476395f, -0.03360395f, 0.03165035f, -0.01631605f, 
    -0.05020246f, 0.04212790f, -0.05611346f, -0.02050473f, -0.01282010f, -0.03994319f, -0.05277911f, -0.02695245f, 
    -0.02319073f, -0.02975987f, -0.04748927f, 0.01888858f, -0.00643303f, 0.00297394f, -0.05398004f, -0.01766567f, 
    -0.05737018f, -0.02536104f, 0.01175619f, 0.02198348f, -0.03064159f, 0.00234539f, 0.02719716f, 0.05731562f, 
    0.01616141f, 0.00741950f, -0.05598954f, -0.01493787f, -0.05220813f, 0.04327887f, 0.00450222f, -0.06462096f, 
    -0.03817493f, 0.00196076f, 0.03185618f, -0.02879189f, -0.02833914f, -0.06626134f, -0.00666322f, 0.04486314f, 
    0.03599599f, -0.03651209f, 0.02887861f, 0.01981913f, -0.02690393f, 0.02800235f, -0.03937018f, 0.05048160f, 
    -0.01065715f, 0.04256977f, -0.05932128f, 0.00380065f, -0.01730333f, -0.02242557f, -0.00359404f, 0.03083957f, 
    -0.04009774f, -0.06129436f, -0.04806902f, -0.04073884f, 0.02397476f, 0.00298218f, -0.03183126f, -0.03933929f, 
    -0.01509501f, -0.00750509f, 0.00126376f, 0.03105653f, 0.01518424f, 0.04908820f, -0.03237838f, -0.00781608f, 
    0.01914605f, 0.03759766f, 0.00229223f, -0.00132851f, 0.01053706f, 0.00861729f, 0.03554814f, -0.00532930f, 
    0.03026830f, -0.01883728f, 0.00651988f, -0.04960722f, -0.06632231f, -0.03206744f, -0.03231280f, -0.03801516f, 
    -0.04804579f, -0.01545069f, -0.02110414f, 0.04367106f, 0.00457830f, -0.01326079f, 0.03878366f, -0.00722467f, 
    0.01991217f, -0.05280518f, -0.00789396f, -0.01693848f, 0.04374817f, -0.05614048f, -0.00607072f, 0.02003362f, 
    -0.05950353f, 0.05931441f, -0.01310953f, 0.04552095f, -0.04259764f, -0.01616211f, 0.02108384f, -0.03888076f, 
    -0.03482638f, 0.02891842f, -0.01689742f, 0.05074057f, 0.03117527f, -0.01064417f, 0.01657977f, 0.01682813f, 
    -0.01146575f, -0.02122695f, 0.04238818f, -0.01210049f, -0.04374731f, -0.01763963f, -0.03154956f, -0.04004665f, 
    -0.03768207f, 0.00464286f, 0.01007755f, 0.02279548f, -0.05555292f, 0.00084283f, 0.04023581f, -0.04922992f, 
    0.03293504f, -0.03777053f, -0.03358651f, -0.00098057f, 0.04605841f, 0.01293631f, -0.04912358f, 0.00058093f, 
    0.04615764f, 0.00310734f, -0.00576245f, 0.05154025f, 0.04453939f, -0.02655910f, -0.01228406f, -0.05903232f, 
    -0.05616554f, -0.01217888f, 0.04216749f, -0.02338203f, 0.01042796f, 0.02251134f, -0.04685115f, -0.05651401f, 
    -0.06086366f, 0.01443180f, 0.02207361f, 0.03381789f, -0.02765098f, 0.04939651f, 0.00890898f, -0.02141776f, 
    -0.04661663f, -0.03498919f, 0.04282401f, -0.01471943f, 0.00391473f, 0.00157793f, -0.03750526f, -0.01257562f, 
    0.01184735f, 0.03157822f, -0.01137147f, -0.02232629f, 0.04898170f, -0.04473146f, -0.06479914f, 0.02390924f, 
    0.28290424f, 0.00440602f, -0.05976170f, -0.02134807f, -0.12620436f, 0.23654449f, 0.21226715f, 0.04976735f, 
    0.08585718f, 0.04202747f, -0.00758425f, -0.05977111f, -0.03733650f, 0.09610355f, -0.12869598f, 0.04881190f, 
    0.14644183f, -0.00078013f, 0.18687026f, 0.11817663f, 0.19138554f, -0.04489653f, -0.05463639f, -0.04460622f, 
    -0.10762919f, 0.06327220f, -0.04258646f, 0.01451130f, 0.16051596f, 0.08887903f, 0.04111584f, -0.07389844f, 
    0.17356823f, 0.09873901f, 0.21883889f, -0.06291283f, -0.13517565f, -0.05530539f, -0.37292430f, -0.07449640f, 
    0.12423185f, 0.03283830f, -0.02287817f, -0.03804194f, 0.13112248f, -0.24934736f, -0.14706452f, -0.14723144f, 
    0.16937588f, 0.24119841f, -0.00192600f, -0.06910465f, -0.13402426f, -0.06358383f, -0.24255377f, 0.01544339f, 
    -0.12794052f, 0.05046226f, 0.02405723f, -0.06101134f, 0.05896140f, 0.11386533f, -0.00551981f, -0.26808497f, 
    0.10345798f, -0.08269466f, 0.05576307f, 0.08640407f, 0.02120239f, 0.09176631f, 0.17525570f, -0.18835317f, 
    -0.27276427f, -0.05994903f, 0.11077894f, -0.02754359f, -0.08693719f, -0.03312737f, 0.06374522f, 0.16710235f, 
    -0.01027817f, 0.11786757f, 0.13520186f, -0.42609006f, 0.10276709f, 0.02163946f, -0.00324894f, -0.02295380f, 
    -0.00187306f, -0.12176766f, -0.36363596f, -0.12456168f, -0.03063906f, 0.15949494f, 0.12386797f, -0.02580275f, 
    0.02678966f, 0.00862857f, -0.06732547f, 0.06581049f, 0.10306906f, -0.12607431f, 0.15992013f, 0.00860420f, 
    0.01652101f, -0.00003771f, -0.01914392f, 0.05732405f, -0.21244271f, -0.13833605f, -0.19437090f, 0.06511845f, 
    0.14629193f, 0.11669137f, -0.04279587f, -0.14358644f, -0.00082876f, 0.11434383f, -0.14392610f, 0.14253435f, 
    0.17487159f, 0.11240137f, -0.15291087f, 0.06711898f, 0.05978559f, 0.16358179f, -0.16034102f, 0.14427432f, 
    -0.03341233f, 0.04181263f, -0.04929700f, 0.07398100f, 0.05098549f, -0.07052375f, 0.08967774f, 0.22055097f, 
    0.08016044f, 0.38583165f, 0.04108721f, 0.18243977f, 0.04253356f, -0.08196793f, 0.28268182f, 0.05231681f, 
    -0.04316244f, -0.22844215f, -0.13744959f, 0.01795098f, -0.12433810f, 0.26526427f, -0.16260050f, 0.18332222f, 
    -0.12414216f, 0.27411294f, -0.01828494f, -0.02401271f, -0.14353521f, 0.05944892f, 0.03785873f, 0.04067197f, 
    0.17388859f, -0.14408374f, 0.01501495f, -0.01659344f, -0.22245243f, -0.01051351f, -0.00462176f, -0.06793705f, 
    -0.01068658f, -0.03997573f, 0.00810319f, -0.31599337f, -0.03659540f, 0.07192756f, -0.07622845f, 0.18419510f, 
    0.03753005f, -0.26798850f, -0.04753669f, -0.24088563f, 0.02547248f, -0.26842347f, 0.13022198f, 0.17124017f, 
    0.00790254f, 0.02596816f, -0.10765376f, -0.12152387f, 0.00253319f, -0.36801207f, -0.12726256f, 0.04626812f, 
    0.14915437f, 0.21221073f, -0.08745167f, 0.01832947f, 0.04233161f, -0.00423016f, 0.11275429f, 0.41261542f, 
    -0.16633075f, -0.06086830f, 0.02970958f, 0.00168404f, -0.03691569f, 0.17905760f, -0.22804070f, 0.03518917f, 
    0.14353883f, 0.10761277f, -0.02418078f, -0.00857645f, -0.01687055f, -0.11499295f, 0.06148664f, 0.06379337f, 
    0.05663816f, 0.25373554f, 0.12154663f, 0.12356172f, -0.01086051f, -0.07613558f, 0.03993515f, -0.00406619f, 
    -0.03416950f, -0.14746046f, 0.06498887f, 0.20441420f, 0.13050124f, 0.00013692f, -0.17124961f, -0.05745400f, 
    -0.01501804f, -0.00802901f, -0.00724313f, -0.10262281f, -0.04740825f, -0.14545327f, 0.14403610f, -0.06510235f, 
    -0.02411715f, -0.06157404f, -0.05508607f, 0.16573052f, 0.10510985f, 0.20936817f, 0.08971176f, -0.06376731f, 
    0.05198874f, 0.00560755f, 0.00269239f, -0.02693842f, 0.07253335f, 0.09439833f, 0.09241150f, -0.07403089f, 
    0.13593726f, -0.05035371f, -0.04802053f, 0.08305120f, -0.01327598f, -0.06171243f, 0.17253853f, 0.29530582f, 
    -0.01386022f, 0.07691164f, -0.01924887f, -0.14679341f, -0.13532181f, 0.03883018f, -0.25181937f, -0.16662262f, 
    0.22348587f, 0.08457427f, 0.04133746f, 0.11292777f, -0.07365148f, -0.11236886f, 0.01658421f, 0.16161065f, 
    0.18463857f, 0.21062134f, 0.10752174f, 0.18632959f, 0.09673982f, 0.07991509f, 0.01761324f, 0.03804861f, 
    -0.23501834f, -0.00611463f, -0.01991267f, 0.19969945f, -0.14398189f, -0.36380270f, 0.19938573f, 0.42113492f, 
    0.18708950f, -0.25187901f, -0.18022679f, -0.04985789f, 0.04497455f, -0.00603121f, 0.17372639f, 0.07414708f, 
    0.35113958f, 0.01948997f, 0.09392065f, 0.16269334f, 0.11635140f, 0.17287479f, -0.00324650f, 0.16964425f, 
    -0.02328448f, -0.14640042f, 0.11831703f, -0.04539409f, 0.16617444f, -0.09742374f, 0.05249421f, -0.15613079f, 
    -0.16385400f, 0.16980319f, -0.21076138f, -0.18705285f, 0.53953898f, -0.26480395f, -0.23625273f, -0.03299418f, 
    0.02848514f, 0.08113278f, 0.05391735f, 0.13675763f, -0.03976003f, 0.33644035f, 0.17689857f, -0.06981017f, 
    -0.08736985f, -0.01966510f, 0.02136661f, 0.04885525f, 0.04431857f, 0.30324432f, -0.03400525f, 0.04094153f, 
    0.11149356f, -0.01391621f, -0.05857114f, 0.06748555f, 0.19817470f, 0.01694043f, 0.12099313f, 0.10300413f, 
    0.10345951f, -0.11061297f, -0.18220322f, -0.18475281f, -0.15852642f, -0.03135405f, 0.04868964f, 0.29433972f, 
    -0.09092978f, 0.19983387f, -0.08051261f, -0.33860222f, -0.18322735f, -0.01601601f, -0.02206259f, 0.03289536f, 
    0.13324210f, 0.11649723f, 0.00328973f, 0.00169652f, -0.30870774f, -0.16495377f, -0.10598527f, 0.13889305f, 
    0.08410606f, 0.19532457f, 0.08144106f, 0.11970959f, -0.20979999f, -0.28192464f, -0.17109704f, 0.05129492f, 
    0.18769352f, 0.08295153f, 0.20616119f, 0.05849720f, -0.11492110f, -0.09044240f, -0.02048001f, 0.05336557f, 
    -0.15608928f, -0.10023054f, -0.04389974f, -0.21683474f, 0.23531058f, -0.14283113f, -0.16772364f, 0.01482938f, 
    0.19617209f, 0.00869905f, 0.07882997f, -0.02237919f, 0.08651566f, 0.04513048f, -0.11163620f, -0.07600158f, 
    -0.03619815f, 0.02190123f, -0.06522416f, 0.16307880f, 0.08821219f, -0.02065037f, -0.10001374f, 0.08962286f, 
    0.00806764f, -0.03766739f, -0.00888338f, -0.05092487f, 0.02988373f, -0.00512216f, 0.15707685f, -0.30485058f, 
    -0.48859099f, -0.31941640f, -0.04394279f, -0.11340263f, 0.07534733f, 0.02459839f, -0.08353404f, -0.00892077f, 
    -0.21977891f, -0.24975297f, -0.25662717f, 0.08861284f, -0.01299671f, -0.17223181f, -0.06598922f, -0.00013350f, 
    0.09008849f, 0.12975049f, -0.50714505f, -0.00409490f, -0.00880745f, 0.05787407f, 0.13912351f, 0.09633365f, 
    0.00106263f, 0.21215521f, 0.33022323f, -0.07057804f, 0.04770365f, -0.07182307f, 0.20297052f, -0.06065085f, 
    0.26683480f, 0.23312344f, 0.03636848f, 0.19211389f, -0.03416399f, 0.00226941f, 0.10340586f, -0.07293355f, 
    0.22622038f, 0.22008647f, 0.08069239f, -0.11235466f, -0.02899830f, 0.14588279f, -0.18559670f, -0.02771346f, 
    -0.08111880f, -0.04111503f, 0.11536983f, 0.07260012f, 0.14976175f, 0.10689461f, 0.01108853f, 0.02560280f, 
    -0.22308312f, -0.06873572f, -0.16751483f, 0.18681049f, 0.30307490f, 0.15078193f, -0.53564286f, -0.35404864f, 
    0.22888121f, -0.01103726f, 0.05951659f, -0.08784354f, 0.19902705f, -0.12319900f, 0.15207814f, 0.02506954f, 
    -0.12081800f, -0.04357941f, -0.07763570f, -0.24725002f, -0.03109272f, 0.20768066f, 0.25207266f, -0.02742756f, 
    -0.16324231f, 0.12028421f, 0.05890723f, -0.25231585f, -0.01195268f, 0.24501921f, 0.09628224f, -0.04065782f, 
    -0.07195078f, -0.32756051f, 0.41611779f, 0.14592896f, -0.15864863f, -0.02729064f, 0.20175274f, 0.02331706f, 
    -0.21247543f, -0.23689690f, -0.05227611f, 0.06024042f, -0.01178031f, -0.17978574f, 0.02817156f, 0.05140206f, 
    0.20024838f, 0.16196245f, 0.12593782f, -0.14489508f, -0.03157789f, 0.07210065f, -0.03758979f, 0.15298478f, 
    0.09916696f, -0.07047919f, 0.02649475f, -0.01382403f, -0.06393900f, 0.20897721f, 0.27635539f, 0.08491894f, 
    0.00664546f, -0.01430446f, 0.09481781f, 0.10164385f, -0.02823843f, -0.02382802f, 0.15044522f, -0.13647205f, 
    -0.04967732f, 0.12690198f, 0.17458944f, -0.00263552f, -0.28324622f, -0.00469556f, -0.17534609f, -0.12609664f, 
    -0.29473042f, -0.20069665f, -0.07339821f, 0.05341155f, 0.09722991f, 0.00347443f, 0.08970948f, -0.26362064f, 
    -0.11856079f, -0.01907302f, 0.13794868f, 0.08121338f, -0.16181032f, 0.10536614f, 0.13076143f, -0.03521245f, 
    0.23127788f, -0.16983368f, -0.02796570f, -0.19850284f, 0.14399818f, 0.01876700f, -0.13686565f, 0.12299515f, 
    0.03635794f, 0.01423878f, -0.15834738f, -0.24933569f, -0.02581534f, -0.05771178f, 0.04962993f, -0.06270712f, 
    -0.28839976f, -0.33922905f, 0.04715231f, 0.10327415f, 0.54042375f, 0.09808818f, 0.15675080f, -0.05853603f, 
    -0.08310506f, -0.09898395f, 0.08038686f, 0.37749505f, 0.27395022f, 0.52133816f, 0.10541468f, 0.06234091f, 
    -0.15787455f, -0.10204732f, -0.08934482f, 0.11711077f, -0.02899000f, 0.00794610f, -0.08627775f, -0.06000504f, 
    -0.08618204f, -0.05276879f, 0.12359150f, -0.05482065f, -0.06193601f, -0.26533899f, 0.14876062f, 0.00633955f, 
    -0.07072404f, 0.06617507f, -0.01640046f, 0.26670122f, 0.08317661f, 0.10397197f, 0.11368975f, 0.04506060f, 
    -0.57766056f, -0.13128364f, -0.09378545f, 0.04503127f, 0.19685742f, -0.05259088f, 0.17845291f, -0.05538922f, 
    0.03776842f, -0.06846763f, -0.13269505f, -0.09466933f, -0.04983762f, 0.13562001f, 0.01952448f, 0.04961650f, 
    -0.06348601f, -0.17049161f, -0.34799537f, -0.04105163f, 0.00872265f, -0.07178852f, 0.10980415f, -0.06482281f, 
    0.08089858f, -0.04079081f, 0.08453713f, -0.71498722f, -0.03723922f, -0.06535898f, -0.16277920f, 0.13818265f, 
    -0.08199390f, -0.13498500f, 0.21558338f, 0.06418374f, -0.11256740f, -0.15125327f, -0.18709613f, -0.09145483f, 
    -0.09154422f, -0.13596012f, 0.08261483f, 0.24952282f, 0.17991358f, 0.13376664f, 0.05397514f, 0.18466736f, 
    0.07163170f, 0.11831544f, 0.03380235f, 0.08353040f, 0.12872331f, 0.06011619f, 0.09523582f, 0.11986702f, 
    0.12808847f, -0.05950923f, 0.01812443f, -0.02797178f, -0.05778794f, 0.24885114f, 0.35243431f, 0.22125012f, 
    0.06522499f, 0.07662955f, 0.12769133f, 0.11725795f, -0.03237219f, 0.13972993f, -0.26443732f, 0.16290033f, 
    -0.28416809f, 0.11467107f, 0.14072318f, -0.17954896f, 0.16716978f, 0.18876334f, 0.09712741f, 0.40658247f, 
    0.41221973f, 0.04957581f, 0.22155392f, 0.13139173f, -0.01233263f, -0.09839334f, 0.04411189f, -0.24984756f, 
    0.14339529f, 0.44919178f, 0.30674022f, 0.09409333f, -0.02854821f, -0.09423219f, -0.10987885f, -0.14682418f, 
    -0.21392687f, 0.04989646f, 0.13901594f, -0.06703184f, 0.05402043f, 0.18074079f, -0.07655796f, 0.04486116f, 
    -0.18491289f, 0.12849553f, -0.05949615f, 0.12479777f, -0.31972677f, 0.05101152f, 0.03337611f, 0.06275272f, 
    0.10515907f, 0.09482800f, -0.09336609f, 0.05838792f, 0.02996256f, -0.19534625f, -0.08758572f, -0.06838253f, 
    -0.06864144f, 0.36011675f, 0.06164247f, 0.21345344f, 0.41210362f, 0.26670387f, 0.38178724f, -0.03793433f, 
    0.00773948f, 0.03061388f, 0.06836103f, 0.11062589f, -0.02391060f, -0.17741801f, -0.05943710f, -0.12790485f, 
    -0.15210739f, -0.04234049f, 0.07699537f, -0.04788371f, -0.02905254f, -0.01902412f, -0.00380993f, -0.00845966f, 
    -0.07222936f, -0.06639877f, 0.20376140f, 0.07567779f, -0.03387940f, 0.00804938f, 0.12592533f, 0.12860738f, 
    -0.13008076f, -0.30374953f, -0.00074116f, -0.01221809f, 0.09708704f, -0.09891665f, 0.30753919f, 0.00958128f, 
    -0.04689719f, -0.22914092f, 0.05649239f, -0.04425069f, 0.13235103f, 0.00656745f, -0.22921920f, -0.18786551f, 
    0.00131102f, -0.25800258f, 0.01133262f, 0.37565932f, 0.14231466f, 0.02594375f, -0.04364568f, 0.05057233f, 
    0.00554457f, 0.11548559f, 0.19133686f, -0.21662475f, -0.17224450f, -0.03048101f, -0.00112866f, 0.01249794f, 
    0.11732347f, 0.11123277f, -0.04906294f, -0.06245160f, -0.10328649f, 0.05208430f, -0.02102626f, -0.03442109f, 
    0.01637963f, -0.22451085f, -0.26914373f, -0.30258986f, 0.24409313f, 0.02957958f, 0.35957757f, 0.08609287f, 
    -0.06522000f, 0.05094844f, 0.01214832f, 0.16864203f, 0.09805480f, -0.07916176f, 0.25262770f, 0.66554862f, 
    0.02243693f, 0.09529772f, -0.10239866f, 0.03511513f, 0.13883275f, 0.26377398f, 0.02147454f, -0.15058132f, 
    -0.15506355f, -0.12034614f, 0.07026687f, -0.19652265f, -0.15309989f, -0.05402087f, -0.06280267f, 0.38104513f, 
    0.31627876f, 0.36690158f, 0.13330354f, 0.01837623f, 0.03173148f, 0.02445060f, -0.03963471f, 0.01829249f, 
    0.06086246f, 0.04320622f, 0.24593960f, 0.12842919f, -0.03854607f, 0.18706739f, 0.00164907f, 0.13723052f, 
    -0.08313598f, -0.17600425f, -0.04781574f, 0.12922293f, 0.01602117f, 0.18176632f, 0.00645825f, 0.04171867f, 
    0.14354724f, -0.27007416f, 0.13118598f, -0.41953352f, -0.25624043f, -0.04964167f, -0.10296902f, 0.12998240f, 
    0.06423124f, -0.04430860f, 0.06374199f, 0.34551221f, -0.35065499f, -0.36146539f, 0.26767623f, -0.21569963f, 
    -0.14857563f, 0.09062912f, -0.12849243f, 0.11421549f, -0.26915574f, 0.05647145f, 0.11854348f, 0.09675208f, 
    0.11881830f, 0.05892303f, 0.17945887f, 0.10331197f, -0.33566639f, -0.11083120f, -0.09757049f, 0.28292632f, 
    -0.03437031f, -0.17464660f, 0.30316052f, 0.06753825f, 0.07720327f, -0.05623151f, 0.08457386f, 0.08505862f, 
    -0.28361639f, -0.04211655f, 0.28504550f, 0.19216193f, -0.01569452f, 0.03722317f, 0.24912494f, -0.08028455f, 
    -0.07505851f, 0.14756106f, -0.02005070f, 0.04049787f, 0.12910806f, 0.11920810f, 0.10895389f, 0.02815242f, 
    -0.05705917f, -0.00491341f, 0.00773688f, -0.03973742f, -0.04452236f, 0.05343478f, 0.06911514f, 0.19363499f, 
    0.10208039f, -0.05555423f, -0.05511364f, -0.15648949f, -0.07460687f, 0.19820344f, 0.08725052f, 0.06673238f, 
    -0.04167911f, 0.04800711f, 0.04492535f, 0.06957775f, 0.13491167f, -0.17515202f, 0.04012894f, -0.06572078f, 
    0.06697693f, 0.10521077f, -0.04814634f, 0.15313812f, -0.25998917f, 0.11035968f, 0.12262345f, -0.13504224f, 
    0.02241183f, -0.04265469f, -0.00302735f, 0.08655535f, -0.19203168f, 0.06723915f, 0.12682435f, -0.05589917f, 
    0.07472527f, 0.08419524f, 0.03787854f, 0.12298235f, -0.13471244f, 0.08915521f, 0.01036802f, -0.20037365f, 
    0.11815652f, 0.00281366f, -0.10554460f, 0.07003856f, -0.04017574f, 0.01622375f, -0.09146054f, 0.16742255f, 
    0.22301352f, -0.04792348f, 0.10518015f, 0.18671352f, 0.03221553f, 0.11882392f, 0.15234667f, -0.26975596f, 
    -0.10439238f, -0.03524408f, -0.27172205f, 0.04753673f, -0.06636180f, -0.16444370f, 0.09121297f, 0.01880783f, 
    -0.28308967f, 0.22174492f, 0.37383920f, -0.07024194f, 0.03706769f, 0.48377249f, 0.07191606f, 0.01839925f, 
    0.02319220f, 0.07267597f, -0.03748644f, 0.17881306f, 0.01833911f, 0.07700130f, -0.16956216f, -0.11280770f, 
    0.00552711f, -0.01961930f, -0.03514265f, 0.20763530f, -0.20594887f, 0.08173362f, 0.18147001f, -0.06466877f, 
    0.12951362f, 0.00146755f, -0.00284493f, 0.08356627f, 0.10208659f, -0.30552742f, -0.24562149f, 0.24042863f, 
    -0.00055635f, 0.12774135f, 0.11942003f, 0.16558380f, 0.12617776f, 0.25096542f, 0.18390973f, -0.24058616f, 
    -0.16151543f, -0.15340416f, -0.00521339f, -0.11122896f, -0.06075240f, 0.16696475f, -0.01461316f, -0.02629136f, 
    0.15701906f, 0.06036867f, -0.15796557f, 0.08006974f, 0.17541017f, -0.03170338f, -0.24749067f, 0.08315547f, 
    0.26311338f, 0.06915686f, 0.01032325f, -0.22689775f, 0.10767521f, 0.11964571f, 0.00913741f, 0.03191081f, 
    0.18499593f, 0.12700784f, 0.00483111f, 0.00275397f, -0.09021515f, -0.10937160f, 0.10784884f, -0.08792976f, 
    0.27349782f, 0.28228253f, -0.10894582f, 0.09267089f, 0.00970203f, -0.05595604f, -0.27030963f, -0.24069408f, 
    -0.09896567f, 0.74980932f, -0.31453866f, -0.51494575f, -0.06675666f, -0.03795074f, -0.05032091f, 0.17782588f, 
    0.09632400f, 0.08403713f, 0.09097262f, 0.36321282f, -0.12277827f, -0.12320240f, -0.05592569f, -0.00042606f, 
    0.04755394f, -0.02031701f, 0.09489090f, 0.04833642f, 0.07551550f, -0.08758273f, 0.12537901f, 0.08369426f, 
    0.13732816f, -0.14819530f, -0.14046203f, 0.10436671f, 0.05148426f, -0.34306523f, -0.13354605f, -0.02541513f, 
    -0.05420675f, -0.05353154f, -0.01956373f, 0.09757053f, 0.11282743f, 0.34019631f, -0.46262956f, -0.06829554f, 
    -0.05513078f, 0.06084430f, 0.15361412f, 0.06852270f, 0.31200051f, -0.08546660f, 0.06935778f, 0.21058041f, 
    -0.02735189f, -0.25896358f, -0.04812492f, 0.12060838f, -0.01063694f, 0.14893559f, -0.01414922f, -0.16754031f, 
    -0.08265173f, 0.11710898f, -0.11058015f, -0.09288272f, -0.01905341f, -0.06459905f, -0.04218454f, -0.05280059f, 
    -0.46904781f, -0.06712390f, 0.22791205f, -0.04579115f, -0.14548630f, -0.18922336f, 0.07691246f, 0.01899542f, 
    -0.09106421f, -0.23846716f, -0.42430332f, 0.00876694f, 0.12302648f, -0.02349625f, -0.11292908f, 0.23707831f, 
    0.03555557f, -0.08909228f, -0.10336541f, -0.14303079f, 0.07708390f, 0.13025637f, 0.10651333f, 0.22148530f, 
    -0.16697368f, 0.03487925f, 0.10499174f, -0.00062950f, -0.10576291f, 0.12182813f, -0.07871497f, -0.01640027f, 
    -0.14324453f, -0.09196490f, -0.06872412f, 0.24353625f, 0.54496253f, -0.03796445f, -0.03360952f, -0.07141777f, 
    -0.14574386f, 0.11148813f, 0.02149924f, 0.03627090f, -0.14929481f, -0.21607484f, -0.17459612f, 0.14085209f, 
    -0.05817179f, 0.19122308f, -0.08431127f, 0.10413148f, 0.14204775f, -0.09618878f, 0.25637347f, 0.13057059f, 
    -0.14534071f, -0.18973149f, 0.06994932f, 0.06234399f, -0.09851599f, 0.02009916f, 0.15732116f, 0.05421200f, 
    0.29484522f, 0.29709685f, -0.21357928f, -0.25365451f, -0.30539554f, 0.03340917f, 0.16587897f, 0.13696906f, 
    -0.17018385f, 0.12577845f, 0.08309680f, -0.13723241f, -0.05202742f, -0.34070507f, -0.07821123f, 0.09791869f, 
    0.02310448f, 0.23247714f, 0.22707823f, -0.22320998f, -0.16885771f, -0.11049043f, 0.16057228f, 0.03533500f, 
    -0.01737232f, -0.19337125f, 0.21624696f, 0.29420987f, -0.23303671f, -0.24051607f, -0.14568929f, -0.24325143f, 
    0.13373241f, -0.01793525f, 0.02276125f, 0.19235444f, -0.08401292f, -0.08449153f, 0.05019896f, 0.00924546f, 
    0.17027059f, -0.00199595f, -0.05230211f, -0.04100977f, 0.23024912f, -0.10845320f, 0.22879477f, 0.04240446f, 
    0.04985487f, 0.07326613f, 0.09167717f, 0.01444179f, 0.00015121f, 0.21067744f, 0.17796403f, 0.02643791f, 
    0.00682346f, -0.12792058f, 0.02899685f, 0.13124847f, 0.13428852f, 0.14997460f, -0.06174017f, -0.14285932f, 
    0.02893904f, 0.13981085f, -0.02672074f, 0.19913268f, 0.09183829f, -0.00561066f, 0.12266516f, -0.09614709f, 
    -0.26045960f, -0.27697259f, -0.08131054f, -0.01134896f, -0.13188660f, -0.11797998f, -0.01218195f, 0.08442189f, 
    -0.07520036f, -0.07832045f, 0.10286167f, 0.02776053f, -0.19071224f, 0.15110578f, 0.01149707f, 0.02153327f, 
    0.02722511f, 0.08318648f, -0.09968506f, -0.12632585f, -0.03388484f, -0.00827990f, 0.04499227f, 0.11187858f, 
    -0.14989683f, 0.09669520f, 0.35753068f, 0.14347096f, -0.01722706f, 0.10234853f, 0.03321279f, 0.12556776f, 
    0.12496860f, -0.16166821f, 0.01953121f, -0.12826535f, 0.07540485f, -0.20516500f, 0.06966872f, 0.19218157f, 
    0.10620545f, 0.10021502f, -0.07369982f, 0.04038905f, 0.01516801f, 0.02650023f, 0.26370427f, -0.25735083f, 
    -0.14318614f, -0.09715638f, 0.13007940f, 0.09692640f, 0.03144055f, -0.16735201f, 0.36554843f, 0.03150813f, 
    -0.26454863f, 0.05009133f, -0.36507297f, 0.03374106f, 0.05658212f, -0.14426501f, 0.02304421f, -0.32232979f, 
    0.37137961f, -0.01028916f, -0.08423594f, -0.22010899f, -0.04722223f, 0.07697108f, -0.07185060f, -0.66991287f, 
    -0.21957523f, 0.07282677f, 0.07213390f, -0.00788834f, -0.37478292f, 0.06672790f, 0.12659854f, -0.00647761f, 
    -0.24827999f, -0.18978818f, -0.04663354f, 0.04200032f, -0.05606058f, 0.08254357f, 0.09534366f, 0.03870343f, 
    -0.04320039f, -0.41866812f, -0.17543861f, -0.22979197f, 0.05190261f, 0.19620289f, -0.05747339f, -0.19223474f, 
    0.01883890f, 0.09134027f, -0.10433576f, 0.03530688f, -0.03143502f, -0.08103400f, -0.07552936f, -0.17545095f, 
    0.00281294f, 0.00939090f, 0.11038993f, -0.10297585f, -0.27663422f, -0.13212824f, -0.03150830f, -0.03508891f, 
    0.01063932f, 0.03471015f, -0.02039644f, 0.00853216f, -0.08860572f, -0.04388896f, 0.02562852f, 0.07056894f, 
    0.06893729f, -0.02602788f, -0.16646731f, 0.17541689f, 0.08965939f, -0.33838564f, -0.06537243f, 0.02142406f, 
    0.20621608f, 0.15578599f, 0.21503255f, -0.04366414f, 0.10250957f, 0.00301753f, -0.04738193f, 0.01118791f, 
    -0.60458964f, 0.18800987f, -0.06776531f, -0.00749742f, 0.02577086f, -0.15727052f, -0.05306411f, 0.09298182f, 
    -0.03787905f, 0.12461637f, -0.00313058f, -0.06754567f, -0.07671742f, -0.02228793f, 0.12019514f, 0.06232858f, 
    0.00836284f, -0.49971783f, 0.01175404f, -0.04650560f, 0.00479360f, 0.06415932f, 0.06279356f, -0.05659831f, 
    0.10795275f, 0.15517299f, -0.09624435f, -0.04773708f, -0.15725978f, 0.08060882f, 0.09093035f, 0.15997092f, 
    0.11781113f, 0.19643725f, 0.04781849f, -0.11201081f, 0.06576034f, 0.03997172f, -0.05430207f, -0.02100427f, 
    -0.02996062f, 0.01766848f, 0.00332053f, 0.01786871f, 0.11312210f, -0.15182255f, -0.11472628f, -0.11824254f, 
    -0.24367321f, 0.01473126f, -0.08987155f, -0.09807468f, 0.18918632f, 0.18177241f, 0.06274636f, -0.06521767f, 
    0.14965764f, 0.01441918f, 0.00422996f, 0.02077674f, 0.25779185f, -0.02307411f, 0.13239475f, -0.02116308f, 
    0.08471121f, 0.10249989f, -0.05135883f, 0.08765527f, 0.02317923f, 0.01884264f, -0.19701184f, 0.02175897f, 
    -0.04006501f, 0.11054686f, 0.12412867f, 0.01689194f, -0.02031238f, -0.11379326f, -0.03267059f, 0.02216874f, 
    0.19591987f, 0.23278375f, -0.04045560f, -0.07703746f, -0.16573788f, -0.03880876f, 0.07980922f, 0.00041996f, 
    0.01675227f, 0.14255391f, 0.12864293f, -0.05270360f, 0.01546666f, -0.12346552f, -0.35515553f, -0.05874971f, 
    0.05804669f, -0.06248555f, 0.24357633f, 0.23344697f, -0.03689806f, -0.02814944f, -0.04001676f, -0.02504988f, 
    -0.04976458f, 0.05009919f, -0.10310730f, 0.21526153f, 0.07013632f, 0.13530487f, -0.04848834f, 0.06873826f, 
    0.03043525f, 0.08194561f, 0.08857815f, -0.17446993f, -0.03071136f, -0.17005007f, 0.09878626f, 0.16507787f, 
    -0.11826729f, -0.00035021f, -0.01089304f, -0.05737413f, 0.01455735f, 0.09157526f, -0.06217850f, 0.00503932f, 
    -0.00578473f, 0.02783036f, -0.09974709f, 0.11724021f, 0.12223778f, 0.03150101f, -0.12140857f, -0.26606965f, 
    0.06554285f, -0.00549706f, -0.08130267f, 0.12754552f, 0.06204733f, -0.07952530f, 0.10375840f, -0.00311524f, 
    0.10719548f, -0.02483948f, -0.03393475f, 0.08004753f, 0.00174912f, -0.21419665f, 0.02922118f, 0.13667491f, 
    0.27019504f, 0.16825202f, -0.09774435f, -0.11956458f, 0.11775733f, 0.14189896f, 0.11386564f, 0.21561573f, 
    -0.47562444f, -0.30768147f, 0.04398102f, -0.12306979f, -0.13561659f, 0.12011728f, -0.00242509f, -0.01569127f, 
    -0.09124877f, 0.01674353f, -0.10568793f, 0.12829533f, -0.09070235f, -0.17759751f, -0.01356756f, 0.10280831f, 
    0.20551491f, 0.00298617f, -0.03009284f, -0.07584769f, 0.05525652f, 0.03390084f, 0.07971143f, -0.07317755f, 
    0.13294016f, -0.11067420f, 0.13510904f, -0.27188900f, -0.07116308f, 0.15183456f, -0.09055325f, 0.08114746f, 
    -0.04681000f, -0.11861615f, -0.19712678f, -0.17867069f, -0.00398366f, -0.16090596f, -0.14864315f, 0.08918022f, 
    0.00515853f, 0.06404185f, -0.05719296f, -0.00544614f, -0.05784041f, -0.05405053f, 0.06584094f, -0.12525776f, 
    0.17861821f, 0.22896345f, -0.02561939f, 0.05153256f, -0.02711114f, 0.17044927f, -0.05485772f, 0.05481827f, 
    -0.13472854f, 0.05411623f, -0.00054021f, 0.25224543f, -0.26622903f, 0.12196924f, 0.09832437f, 0.05979956f, 
    -0.10549318f, 0.18877795f, -0.12950860f, -0.18412766f, -0.10700212f, 0.08449972f, -0.04601451f, 0.01408528f, 
    -0.02579890f, -0.04105549f, 0.21061806f, 0.04049442f, -0.04863169f, -0.13825446f, 0.02116009f, 0.17048839f, 
    0.10850687f, -0.23105657f, 0.13599375f, 0.06072888f, -0.16933995f, 0.04600967f, -0.23025143f, -0.03935229f, 
    -0.07047514f, -0.19077522f, 0.15676002f, 0.00710823f, 0.13718189f, 0.01063347f, -0.01618095f, 0.19307041f, 
    0.10053068f, -0.03765689f, 0.02728052f, 0.04464386f, -0.07172567f, 0.12545294f, -0.02153511f, -0.11422589f, 
    0.00463692f, 0.12292694f, -0.01024952f, 0.07310348f, 0.08607724f, 0.04451598f, -0.07579568f, -0.16012788f, 
    0.10002530f, -0.02644694f, 0.11911532f, 0.02005873f, -0.09250741f, -0.05870122f, -0.09261480f, 0.18637341f, 
    -0.02086632f, -0.10922417f, -0.25105327f, 0.04717804f, 0.04592542f, -0.11210615f, -0.04962981f, 0.00194277f, 
    0.12520252f, 0.09823674f, -0.05285443f, 0.09303909f, -0.33873037f, -0.17376927f, 0.04689290f, 0.18413779f, 
    0.04941279f, -0.04456218f, -0.02768696f, 0.08924599f, -0.04221580f, 0.15812214f, 0.07905808f, -0.00483823f, 
    -0.26393014f, 0.10142833f, 0.23239970f, -0.06226650f, -0.02224066f, -0.12291252f, 0.42574075f, 0.13645582f, 
    0.08164052f, -0.16974628f, -0.09719947f, 0.13224365f, 0.01369409f, 0.04420415f, -0.02833993f, 0.29945928f, 
    0.24147663f, -0.03111725f, -0.01436792f, -0.11532369f, -0.04477137f, -0.00444161f, 0.01104533f, 0.21284574f, 
    -0.22990952f, 0.11536972f, 0.03756379f, -0.09662728f, -0.21487914f, 0.00338672f, -0.00107840f, 0.07343699f, 
    -0.25510436f, -0.07085913f, 0.10399538f, -0.04413905f, 0.23681608f, -0.02474327f, 0.02777395f, 0.09578745f, 
    -0.11777220f, 0.01603095f, 0.04311908f, -0.01100382f, 0.13638188f, 0.08153721f, -0.07575316f, 0.15777084f, 
    -0.02406159f, 0.07787984f, 0.15849271f, 0.13166201f, 0.06214630f, 0.09136868f, 0.07068988f, -0.05352621f, 
    -0.06860223f, -0.13096601f, -0.04883721f, 0.08665873f, -0.13598417f, 0.16239296f, 0.12275817f, 0.09827513f, 
    0.15327460f, 0.23320939f, -0.03990236f, -0.09004954f, -0.01432175f, 0.13768238f, 0.11482538f, 0.07258042f, 
    -0.02193314f, 0.00456505f, -0.10790936f, -0.06334255f, -0.00397207f, -0.20356523f, 0.08769802f, 0.01479143f, 
    -0.14071071f, 0.17210221f, 0.01370722f, -0.17448616f, 0.03816277f, 0.13742885f, -0.06467704f, 0.04218791f, 
    -0.03680847f, 0.00372057f, 0.09928957f, 0.11235578f, 0.07941014f, -0.12691523f, 0.04331825f, -0.14425418f, 
    0.11039697f, 0.02425730f, 0.00888360f, -0.00849118f, -0.02277042f, -0.27859032f, -0.14056516f, -0.10783105f, 
    0.03284510f, -0.02582154f, -0.09217772f, 0.08535223f, 0.17457852f, -0.11169756f, 0.13461375f, 0.04198008f, 
    0.14662121f, -0.18347329f, 0.10370449f, 0.02293117f, 0.09020241f, -0.05220905f, 0.04785487f, -0.10658122f, 
    -0.11147329f, 0.01954187f, -0.04055140f, -0.04191436f, -0.24087465f, 0.15076923f, 0.04053206f, -0.06802796f, 
    -0.05232449f, 0.14340699f, -0.01438755f, 0.12050373f, -0.03759395f, -0.04043311f, 0.09409329f, -0.34637308f, 
    -0.17043434f, -0.26335385f, -0.06483614f, 0.02034575f, 0.02577024f, 0.01944781f, 0.21862108f, 0.09895552f, 
    -0.13973010f, 0.09882072f, 0.09032355f, -0.02725316f, 0.02594725f, 0.06168050f, 0.03736037f, 0.11238198f, 
    -0.05193941f, 0.10046398f, -0.02011531f, 0.00148293f, -0.04133861f, 0.04925077f, -0.02551717f, 0.18296546f, 
    -0.05426174f, 0.17791475f, 0.23736358f, 0.11324963f, -0.16834080f, 0.17772038f, 0.15534332f, 0.12316968f, 
    0.12795836f, -0.03626343f, 0.11358886f, -0.02365066f, -0.23956971f, -0.01861203f, 0.14518513f, 0.15585160f, 
    -0.02854489f, -0.04162806f, -0.06077111f, 0.02879348f, -0.02774638f, 0.00438560f, -0.01712395f, -0.27581036f, 
    -0.11650268f, -0.08403730f, -0.07338457f, -0.18075396f, -0.02914100f, -0.05721925f, 0.20778391f, 0.02895802f, 
    -0.13046928f, 0.04934391f, -0.14106254f, -0.02475756f, 0.29840499f, -0.02346455f, -0.32272351f, -0.22584559f, 
    0.64952886f, 0.03499186f, -0.14969510f, -0.21770237f, 0.23416595f, 0.28209147f, -0.01919278f, -0.15341239f, 
    -0.04426413f, 0.03025563f, 0.13683712f, 0.02979798f, -0.25097901f, 0.24985078f, 0.06143646f, -0.02938414f, 
    -0.10598303f, -0.01294282f, -0.04736806f, 0.06956016f, -0.08624419f, 0.07827668f, -0.09205944f, 0.00603206f, 
    0.02344077f, -0.09220047f, -0.22168458f, -0.12192138f, -0.06316067f, 0.06361169f, -0.12821573f, -0.31621203f, 
    0.02451267f, 0.05644735f, -0.09520008f, 0.15135364f, 0.01284140f, -0.01230866f, 0.16026373f, 0.02099103f, 
    0.13197272f, -0.08361484f, 0.06610592f, -0.09154077f, -0.10026348f, -0.16278438f, 0.02521316f, 0.02010945f, 
    0.04793078f, 0.01050644f, -0.08229371f, -0.05566651f, -0.07126244f, -0.05414898f, 0.09401555f, -0.15116091f, 
    0.00985048f, -0.10883360f, -0.02212489f, 0.02166482f, -0.11004807f, -0.17370662f, -0.04553060f, -0.04455160f, 
    -0.01192849f, 0.16196747f, 0.16865766f, -0.20604119f, 0.00278507f, 0.16624779f, 0.08655087f, 0.08002608f, 
    -0.14285553f, -0.06039625f, -0.21534397f, -0.15479095f, 0.04459345f, -0.08430856f, -0.07879075f, -0.04120325f, 
    -0.18339223f, -0.00322338f, -0.05812204f, -0.04499430f, -0.18180022f, 0.05795114f, 0.07200883f, 0.04379845f, 
    0.00139277f, -0.25130460f, -0.26310053f, 0.01419157f, -0.12881947f, -0.14566804f, -0.00889143f, -0.00286502f, 
    0.07573690f, -0.10836472f, 0.07176396f, 0.21835057f, -0.06799636f, -0.03046857f, 0.03811871f, 0.20228051f, 
    0.08700977f, -0.03584698f, 0.35353896f, 0.13435669f, -0.11785968f, 0.18692136f, -0.00046366f, 0.05760775f, 
    0.07123716f, 0.11097211f, -0.13096394f, 0.31938902f, 0.12390343f, 0.29763630f, 0.02535668f, 0.10742271f, 
    0.12441331f, 0.17158660f, -0.08477289f, -0.05762614f, -0.23532067f, -0.16794232f, 0.07330722f, -0.15444781f, 
    0.15096663f, -0.05581807f, -0.02046707f, -0.04062231f, -0.03522889f, 0.50411755f, -0.19526790f, -0.04149243f, 
    -0.36226827f, 0.18267879f, 0.04930978f, 0.07231840f, -0.09480318f, -0.04080315f, -0.79438573f, -0.49552876f, 
    0.32627648f, -0.02887047f, -0.00546861f, -0.22401024f, 0.10210075f, 0.17559156f, 0.07246350f, -0.03833114f, 
    -0.03556667f, -0.10577129f, 0.12424787f, 0.09642493f, 0.03905472f, -0.06980832f, 0.04592973f, -0.07367831f, 
    0.08184648f, -0.57529896f, -0.34661564f, 0.09745954f, -0.02228752f, 0.11613097f, -0.09214476f, -0.13517837f, 
    -0.08882547f, -0.15696663f, -0.59782064f, 0.06644741f, -0.24310292f, -0.11177371f, -0.04808015f, -0.08490416f, 
    0.01354870f, -0.03388334f, -0.40802798f, -0.31001756f, 0.21723968f, -0.08890233f, 0.17314060f, -0.01307286f, 
    -0.00806754f, 0.13779561f, 0.08267967f, -0.23711793f, 0.16953632f, 0.30835989f, 0.04570994f, 0.16021255f, 
    0.09990883f, -0.02348687f, 0.07424223f, 0.01238776f, 0.00601989f, -0.17466757f, -0.02730618f, -0.23500906f, 
    0.04438009f, -0.19704284f, 0.04615071f, 0.00903566f, 0.00516342f, -0.00276996f, 0.16602282f, 0.08821178f, 
    -0.06861487f, 0.09952506f, -0.03387564f, 0.00794353f, -0.11242715f, 0.03749187f, 0.18813489f, -0.09059749f, 
    -0.10564805f, -0.15731682f, -0.40177238f, 0.07707085f, 0.12560585f, 0.02032558f, 0.09504394f, 0.08110223f, 
    0.20408857f, 0.28443110f, -0.22871912f, -0.28279111f, -0.31861788f, 0.01856352f, 0.14528610f, 0.18313508f, 
    -0.27242124f, -0.58095020f, -0.98862898f, 0.01022696f, -0.04577883f, -0.05834585f, 0.13387528f, 0.13019398f, 
    -0.23558010f, -0.24250329f, -0.31529129f, 0.25989547f, -0.14191663f, 0.06881505f, 0.02749593f, 0.01167033f, 
    0.29491198f, -0.07486123f, -0.61021227f, -0.25169429f, 0.01769999f, 0.00187579f, 0.02153879f, -0.00861818f, 
    0.28596818f, 0.02606753f, 0.15373121f, 0.40247929f, -0.26271656f, -0.07541439f, -0.18886384f, -0.13605966f, 
    0.18904041f, 0.05719996f, 0.06630256f, 0.01167061f, -0.08430447f, 0.15365161f, -0.12379352f, -0.00432520f, 
    0.00865944f, -0.13792279f, 0.13644297f, -0.11304834f, -0.05078814f, 0.13439034f, -0.07525100f, 0.01977474f, 
    -0.11658705f, -0.01116404f, -0.12258964f, -0.11339390f, -0.07269035f, 0.05364750f, -0.12209133f, -0.41205105f, 
    0.15593050f, -0.28886440f, -0.10360970f, -0.13294274f, 0.09612627f, 0.23761694f, -0.04229434f, -0.19294645f, 
    -0.59247035f, 0.11184900f, -0.14427483f, -0.33583134f, 0.05324890f, -0.00292010f, 0.06349536f, 0.08882149f, 
    -0.35447687f, -0.47958827f, -0.31327841f, 0.02483180f, 0.10001095f, 0.18815045f, 0.00604913f, -0.00181141f, 
    0.07941838f, 0.47725567f, 0.04592841f, -0.12869401f, 0.04909952f, 0.25422987f, 0.09989304f, -0.08683456f, 
    0.02835146f, 0.08878119f, -0.30791506f, -0.00706037f, -0.21719013f, 0.21281318f, -0.00584237f, 0.05462994f, 
    0.14407687f, 0.05809753f, -0.12482614f, 0.11535122f, -0.22670773f, -0.24199291f, -0.00001971f, -0.03594174f, 
    -0.00735301f, 0.12269676f, 0.16387001f, -0.05317993f, 0.09352560f, 0.28386241f, 0.07129318f, -0.07255476f, 
    0.14807564f, 0.03343360f, 0.13383818f, 0.00412583f, 0.12587920f, 0.50653630f, -0.37213239f, -0.06872918f, 
    -0.06502771f, 0.04662259f, 0.12271566f, 0.06841623f, -0.01480316f, -0.11013988f, 0.04876341f, -0.34284928f, 
    0.50218952f, 0.12414148f, 0.11911717f, -0.02163831f, -0.11732554f, -0.13922323f, -0.10158901f, 0.09258253f, 
    0.18656833f, 0.15602349f, -0.01898307f, -0.06752570f, -0.14527522f, -0.05536765f, -0.03710316f, 0.10266926f, 
    -0.40673444f, 0.28586072f, -0.36404964f, -0.03979425f, -0.24759330f, 0.02445521f, 0.03129136f, -0.03298581f, 
    -0.01551219f, -0.14842060f, 0.08255753f, -0.08833628f, -0.07169918f, -0.01109928f, 0.11878630f, -0.02538837f, 
    -0.05567547f, -0.00264003f, 0.01361586f, 0.22987072f, -0.01912442f, 0.03142828f, -0.05636546f, 0.11866487f, 
    0.05925660f, 0.03227260f, -0.09867904f, 0.11607507f, 0.04026359f, 0.15892707f, -0.28282031f, 0.02559514f, 
    0.09042290f, -0.05991662f, 0.11542397f, -0.05672642f, -0.36048168f, -0.11298171f, -0.16334641f, 0.08220664f, 
    0.15253192f, -0.08249813f, 0.02013339f, 0.06134193f, -0.07208830f, -0.26360077f, -0.06185105f, -0.19835329f, 
    -0.10097534f, 0.15621999f, 0.05078298f, 0.11872772f, 0.03579945f, 0.06554157f, 0.00693025f, -0.34971789f, 
    0.19952622f, -0.22546382f, -0.18251246f, -0.07567905f, -0.10013483f, -0.00313539f, 0.08993702f, -0.22200792f, 
    0.06841555f, -0.06421039f, 0.24182211f, 0.04852431f, 0.07275815f, 0.06354009f, -0.08552243f, 0.13687858f, 
    -0.40094060f, -0.38670555f, -0.00118025f, 0.04111895f, 0.07344585f, -0.16597956f, 0.11944770f, 0.05655564f, 
    -0.01993336f, -0.12003819f, -0.46808273f, 0.20889974f, -0.04909797f, 0.16365843f, -0.42959231f, 0.13969769f, 
    0.08244953f, -0.04676862f, -0.07907242f, -0.25309873f, 0.17008463f, 0.16154279f, 0.12721044f, 0.00454876f, 
    -0.03070075f, 0.03236284f, 0.08686192f, -0.10578362f, 0.11891937f, 0.08560509f, -0.09782475f, 0.19799848f, 
    0.11182990f, 0.01480234f, 0.01665927f, -0.00003847f, -0.08598222f, -0.27485916f, -0.02554365f, -0.09252311f, 
    0.06220150f, 0.02310311f, -0.07589463f, 0.15154427f, -0.06249833f, 0.07459980f, 0.20067638f, 0.14609204f, 
    -0.14283779f, 0.11615247f, -0.03173994f, 0.09903044f, 0.09756938f, 0.09102988f, 0.21095315f, 0.02122933f, 
    -0.03239516f, -0.13093267f, -0.07527994f, -0.06720640f, 0.19184522f, 0.02570973f, 0.04007484f, 0.39634207f, 
    0.10082068f, 0.00821931f, -0.51482928f, -0.02730051f, -0.29933965f, -0.04616881f, -0.01827904f, -0.03733769f, 
    0.33533570f, -0.41484207f, -0.81101084f, -0.21798773f, 0.17297463f, -0.10886148f, 0.03862347f, -0.02269013f, 
    -0.04012419f, 0.06096709f, -0.02529316f, 0.17276376f, -0.03013182f, 0.02417615f, -0.08533929f, 0.06963929f, 
    -0.00695436f, 0.24788831f, -0.14480279f, -0.12243342f, 0.09356524f, -0.00242519f, 0.06553192f, -0.05191194f, 
    0.06060668f, 0.15709078f, 0.07127979f, 0.16645829f, -0.01812246f, -0.15283985f, -0.12365734f, -0.14767361f, 
    0.17180842f, 0.13646424f, 0.04667605f, 0.01923014f, -0.19442628f, 0.05125590f, 0.09665133f, -0.03651501f, 
    0.16547514f, -0.11893582f, 0.02247332f, 0.05274948f, -0.09979998f, -0.18472794f, -0.02159107f, -0.27082375f, 
    0.11294300f, 0.28479496f, -0.01002303f, 0.00941957f, 0.04086901f, 0.13154531f, -0.37691614f, -0.03494522f, 
    0.12610818f, -0.43864954f, -0.13864027f, -0.13431424f, -0.06906186f, -0.13914049f, -0.17931552f, -0.41625455f, 
    0.33439818f, -0.16483699f, 0.02965469f, -0.11397974f, -0.00339921f, 0.15012698f, -0.01813555f, -0.14032029f, 
    0.01613250f, -0.29055089f, 0.03123124f, -0.13666692f, -0.05690143f, 0.03864705f, 0.16856645f, 0.06044012f, 
    0.16246893f, 0.23008600f, -0.10462369f, -0.08916397f, -0.07248263f, -0.07969150f, 0.03652628f, 0.09094533f, 
    -0.01549842f, 0.00771837f, -0.18895754f, 0.11654978f, -0.03724924f, 0.07914104f, -0.02456507f, 0.17706504f, 
    0.07458292f, 0.06569475f, -0.02603246f, -0.08701617f, -0.02580475f, -0.07589969f, -0.03226376f, -0.00670140f, 
    0.09723189f, -0.04303259f, -0.12995127f, 0.02043150f, 0.00841232f, 0.14088722f, -0.01051928f, 0.02681608f, 
    0.06524026f, -0.00676112f, 0.12444253f, 0.07550910f, 0.03323811f, 0.18181989f, 0.05984655f, 0.22556624f, 
    -0.12878719f, 0.14696273f, 0.03867191f, 0.04964400f, 0.05013424f, 0.13787465f, -0.07640308f, -0.39598370f, 
    0.25666323f, -0.02833549f, 0.01109681f, -0.17783216f, -0.09167131f, -0.10018883f, 0.00852367f, 0.14463802f, 
    0.26760548f, 0.22234721f, -0.18013498f, -0.03051160f, -0.08596193f, -0.01378482f, 0.10537367f, 0.04637261f, 
    0.04239619f, -0.01484322f, -0.03366129f, -0.03195756f, -0.00331785f, -0.03197015f, -0.00988853f, -0.04096768f, 
    -0.00785305f, 0.04341244f, 0.02023779f, -0.01926710f, -0.04195473f, 0.04465585f, 0.04309797f, 0.01462455f, 
    -0.02713222f, 0.01164712f, 0.00617076f, -0.06521569f, 0.04375386f, 0.03599195f, -0.04099355f, -0.05971083f, 
    -0.04172699f, -0.03300615f, -0.05516852f, 0.01282053f, 0.04735485f, 0.02121465f, -0.05811118f, 0.02273353f, 
    -0.03786977f, -0.03914001f, -0.04177018f, -0.01342141f, 0.02497192f, -0.05636360f, -0.04047621f, 0.04943689f, 
    -0.00544899f, 0.00103838f, -0.03873844f, -0.00843568f, -0.02691689f, 0.02772554f, -0.02682821f, 0.02607280f, 
    -0.03224910f, -0.05876429f, -0.04028546f, -0.05912930f, -0.00653528f, 0.04585856f, 0.00942453f, -0.04404248f, 
    -0.01407475f, -0.00977178f, -0.03659518f, 0.04809373f, 0.04874485f, 0.00961730f, -0.04466432f, -0.05375676f, 
    0.01532195f, 0.02157524f, 0.04028771f, 0.00729695f, -0.04084108f, 0.00386918f, 0.01189482f, -0.04303803f, 
    0.01610489f, -0.00711484f, 0.00189049f, 0.01408494f, -0.03072460f, 0.02929423f, 0.01490021f, -0.04058051f, 
    -0.05825745f, -0.05921903f, -0.01574204f, -0.05395584f, 0.00578748f, 0.02381353f, -0.05200789f, 0.02151882f, 
    0.05233926f, -0.01562404f, 0.03901686f, 0.00355509f, -0.04983780f, 0.01752159f, -0.03712764f, -0.05110682f, 
    -0.01886205f, -0.01920859f, -0.02819247f, -0.03051436f, -0.04268653f, -0.00015742f, 0.02440182f, -0.02665710f, 
    -0.02736236f, -0.00429107f, -0.02699698f, -0.04040538f, -0.04819045f, 0.03040185f, -0.05847666f, 0.01788609f, 
    -0.06194485f, -0.05016444f, 0.05649563f, 0.00714314f, 0.05276881f, 0.04692372f, -0.04777569f, 0.04050007f, 
    0.02580781f, -0.00920633f, 0.00616157f, -0.04218376f, -0.03531247f, 0.03584915f, 0.04633053f, -0.04734901f, 
    0.05684650f, 0.06221762f, 0.05825376f, -0.03453360f, 0.02324907f, 0.04727737f, -0.01611169f, -0.01459688f, 
    -0.04068650f, 0.04573185f, -0.05507188f, -0.05873810f, 0.04962882f, 0.03353935f, -0.05400569f, -0.02902110f, 
    -0.02051884f, 0.02743115f, -0.00179224f, 0.02977631f, -0.05668536f, -0.03045564f, -0.06056881f, 0.03547829f, 
    -0.00611124f, -0.01977601f, 0.00601041f, 0.05112914f, 0.02142685f, -0.03250691f, -0.01486641f, 0.01625104f, 
    -0.05667017f, 0.00981198f, 0.03759026f, 0.05095278f, -0.01629055f, 0.05727227f, 0.00996254f, 0.03626304f, 
    -0.05610308f, -0.01521787f, -0.01823355f, -0.02301765f, 0.00560427f, -0.03025037f, -0.05839660f, -0.03526772f, 
    -0.01637662f, -0.01448910f, 0.01904299f, -0.02071894f, -0.00793195f, 0.00170074f, 0.00244318f, -0.04132468f, 
    0.00999010f, 0.00726940f, -0.04611773f, -0.03655979f, 0.00893587f, -0.03112050f, 0.02664495f, 0.01753845f, 
    -0.05694510f, -0.05577903f, 0.01046805f, 0.01995614f, 0.04828016f, -0.04446215f, 0.01649030f, -0.02248287f, 
    0.00329649f, 0.01929986f, -0.02059406f, -0.04733369f, 0.03197017f, -0.03978823f, 0.01366333f, -0.02451025f, 
    -0.06261626f, -0.03024029f, 0.01474591f, -0.05051455f, 0.03450364f, 0.01583170f, -0.03082645f, 0.02544113f, 
    0.00625733f, 0.05498743f, 0.02336522f, -0.00361889f, -0.04542925f, 0.05626519f, 0.04241515f, -0.01735764f, 
    0.04313450f, -0.02135691f, 0.01982759f, -0.02937239f, 0.00623046f, 0.01358613f, 0.00243156f, 0.00860097f, 
    -0.02227244f, 0.00165848f, -0.02285276f, -0.00161652f, -0.04027116f, 0.01197230f, -0.04566463f, 0.00189376f, 
    -0.01320171f, -0.02987084f, -0.04411517f, -0.00261191f, -0.01472542f, -0.02391798f, 0.01286063f, 0.04696260f, 
    0.00226379f, 0.01265046f, -0.06113666f, -0.03462828f, -0.02240534f, -0.04891735f, -0.04781336f, 0.02194080f, 
    -0.01121827f, -0.00654001f, -0.04544180f, -0.05596458f, 0.00664277f, -0.01129730f, -0.04062654f, 0.01246699f, 
    -0.01988336f, -0.04808697f, 0.02092929f, -0.00702721f, 0.01810779f, 0.04169754f, 0.05495280f, 0.04400915f, 
    0.00774875f, -0.00555358f, -0.02523287f, 0.02683160f, 0.02729975f, -0.02083950f, 0.02149581f, 0.02997201f, 
    0.04604226f, -0.01969378f, -0.04095404f, -0.03030997f, 0.02742810f, -0.03787986f, 0.03434926f, -0.01101388f, 
    -0.13978735f, 0.05445076f, -0.05744625f, -0.06675578f, 0.08112447f, -0.06511318f, 0.28659865f, 0.17757687f, 
    -0.08476278f, -0.13743594f, -0.00413488f, -0.01307381f, 0.17717263f, 0.00635191f, -0.06629413f, -0.10331406f, 
    -0.27446628f, -0.18713361f, -0.20799229f, 0.25206167f, 0.17432934f, -0.22755407f, -0.07226128f, 0.17172824f, 
    0.08269309f, -0.00375117f, 0.07455428f, -0.32463574f, -0.30100587f, -0.04405225f, 0.03778070f, 0.27348295f, 
    -0.22531864f, 0.07443282f, 0.13928989f, 0.24458854f, 0.18500346f, -0.06559740f, -0.00191211f, -0.03527058f, 
    0.03702661f, -0.13785712f, -0.06834568f, -0.03209295f, -0.23682933f, 0.11667352f, 0.04758073f, 0.11214843f, 
    -0.09361182f, -0.13044499f, 0.13396531f, -0.07812805f, 0.04225830f, 0.09571683f, 0.05953280f, 0.18359895f, 
    -0.06725261f, 0.00571019f, -0.03125653f, -0.08135898f, 0.04434666f, 0.09981467f, 0.15085749f, 0.17315833f, 
    -0.08219112f, -0.00712661f, -0.04084802f, -0.03124987f, 0.11739930f, -0.00682329f, 0.06776291f, -0.09924190f, 
    -0.04492807f, 0.03040728f, 0.13568041f, -0.06992321f, -0.01159011f, 0.00372797f, 0.15590425f, 0.05798985f, 
    0.01328025f, 0.22977036f, 0.06774971f, 0.03906233f, -0.05984422f, 0.10553732f, -0.03964115f, -0.19800122f, 
    0.08979472f, 0.04883170f, 0.30051276f, 0.00203388f, 0.07543276f, -0.09727081f, -0.00025850f, -0.05950082f, 
    0.07828446f, 0.00274056f, -0.08508347f, 0.02311702f, -0.09978423f, 0.09497011f, -0.17841096f, -0.02277886f, 
    0.09282246f, 0.16647051f, 0.19140643f, 0.09830706f, 0.29960129f, -0.06280138f, -0.06875250f, -0.05191917f, 
    0.06505074f, -0.02593790f, -0.01578519f, -0.06166780f, 0.00826714f, -0.21385802f, 0.05755108f, -0.00834326f, 
    -0.01930847f, -0.05601199f, 0.05713965f, 0.09385417f, 0.10152269f, 0.15960112f, -0.14769627f, 0.05626697f, 
    0.01508183f, 0.18129532f, 0.03205093f, -0.08679628f, -0.01169465f, -0.08620506f, 0.15483527f, -0.25730231f, 
    -0.31900993f, 0.10565706f, -0.02359315f, 0.05209852f, 0.01722707f, 0.00413729f, -0.14240304f, 0.04843432f, 
    0.38000512f, 0.11186009f, -0.09950302f, -0.05681874f, 0.03721003f, 0.06001933f, 0.02268560f, -0.10465010f, 
    -0.00913635f, -0.02194615f, -0.08839849f, 0.20597996f, -0.05932870f, 0.03864831f, -0.15840039f, 0.03443465f, 
    -0.09736902f, -0.14841929f, -0.03351227f, 0.11119378f, -0.03490079f, -0.01427692f, 0.08937400f, -0.08677442f, 
    -0.01599620f, -0.08024056f, -0.01188791f, -0.00955690f, -0.02943941f, -0.10712563f, 0.09716022f, 0.06568536f, 
    -0.01110597f, -0.00034217f, 0.10654941f, 0.12995046f, -0.29274720f, -0.16103719f, -0.02469551f, -0.09850743f, 
    0.09130435f, 0.01030642f, 0.12433256f, 0.29465717f, 0.02736174f, 0.15968363f, 0.10742605f, 0.06090847f, 
    0.10626164f, -0.03630555f, -0.09475178f, -0.13402838f, 0.02395750f, -0.00941547f, -0.28280389f, -0.33034718f, 
    0.19952434f, 0.10398385f, -0.11725841f, -0.15127712f, -0.00306345f, 0.07381385f, -0.19467892f, -0.15761647f, 
    0.03029702f, 0.14880188f, 0.18704633f, 0.01048172f, -0.02415827f, 0.09706296f, 0.00610898f, 0.08454097f, 
    -0.02012039f, 0.25018710f, 0.12521248f, -0.11052585f, -0.12999573f, -0.00486397f, -0.22127631f, 0.01847137f, 
    -0.02216276f, -0.20540842f, 0.08833104f, 0.32356560f, -0.17251420f, -0.14970100f, 0.02104782f, -0.16201453f, 
    0.20393091f, 0.24159113f, -0.13226697f, -0.18421763f, -0.04036563f, -0.11063877f, 0.14333639f, 0.03278563f, 
    0.08502214f, 0.10623702f, -0.24889995f, -0.23142649f, 0.11168031f, 0.03404948f, -0.11288511f, -0.01441878f, 
    -0.07717992f, -0.25654513f, -0.03890883f, -0.49526510f, -0.10740058f, -0.12214008f, 0.21053466f, -0.06276572f, 
    -0.02303961f, -0.05557699f, 0.05625835f, 0.24108687f, 0.22281277f, -0.18776706f, 0.17623250f, 0.46924755f, 
    -0.05083545f, 0.06721865f, 0.18927430f, -0.03905439f, 0.05891332f, 0.18525587f, 0.21080227f, -0.01425367f, 
    0.02961965f, -0.14599992f, 0.15333410f, -0.10940396f, 0.16694382f, 0.07901946f, -0.15058866f, -0.08629698f, 
    -0.02723541f, -0.01688382f, -0.07773744f, -0.19313255f, -0.08590046f, 0.03930760f, 0.07142363f, -0.00398002f, 
    -0.06486002f, -0.17422079f, 0.05185524f, -0.17647484f, 0.17608222f, -0.10288339f, 0.07170281f, 0.03536483f, 
    0.21681638f, 0.13658597f, -0.17135762f, -0.07741184f, 0.06447370f, 0.08151878f, 0.01762046f, 0.41532546f, 
    0.29944271f, 0.31954536f, 0.07508836f, 0.29254672f, 0.06162259f, -0.11625915f, 0.05328700f, 0.00175098f, 
    -0.05439818f, 0.01077351f, -0.04173859f, -0.35450470f, -0.08531820f, 0.17207518f, -0.11622195f, -0.01329248f, 
    -0.01852099f, -0.08344524f, 0.10360213f, -0.01622697f, 0.37575564f, 0.07663515f, 0.00392474f, -0.01814115f, 
    0.00293194f, 0.26452941f, -0.00044731f, 0.11057175f, 0.01209901f, -0.10611925f, 0.22983019f, -0.04627142f, 
    0.14956844f, 0.19354844f, -0.03680734f, 0.11376960f, -0.17750449f, -0.03712805f, -0.03753620f, -0.46701550f, 
    -0.20045221f, -0.14053775f, -0.11451926f, 0.04603629f, -0.12509282f, 0.09533290f, -0.04811535f, 0.03979749f, 
    0.04066966f, -0.03755583f, 0.03065996f, 0.08201785f, 0.11372942f, 0.05937391f, 0.15581845f, 0.04773019f, 
    -0.18400675f, -0.17171955f, -0.12060603f, 0.01670159f, 0.04768633f, -0.07553976f, -0.12960592f, -0.12859391f, 
    -0.12131728f, 0.33773348f, 0.00625219f, -0.06130461f, -0.11846479f, 0.16338308f, 0.07900165f, 0.09863516f, 
    0.04114861f, 0.10418119f, -0.08355968f, 0.12748241f, 0.13664894f, -0.06444216f, 0.01637635f, 0.10140009f, 
    0.11032543f, 0.05236506f, 0.03741205f, -0.24382266f, -0.00527859f, 0.11956365f, -0.28165370f, -0.11335272f, 
    0.03119456f, -0.12469448f, 0.03664372f, 0.06730857f, 0.04076508f, -0.14588961f, 0.07826879f, 0.11179581f, 
    0.16460925f, 0.08481637f, 0.13607287f, 0.14149660f, 0.02922640f, -0.24837631f, -0.07550399f, -0.11073318f, 
    -0.10226799f, 0.16552742f, 0.16305044f, -0.10543501f, -0.10793798f, 0.10831998f, -0.07411009f, -0.26278779f, 
    -0.26762629f, 0.02390791f, 0.00544664f, -0.13714224f, 0.09348483f, -0.05134607f, -0.07867341f, -0.49394643f, 
    -0.26523861f, -0.64579451f, 0.17786799f, -0.10976397f, 0.00433825f, 0.34529880f, 0.18949910f, -0.12222355f, 
    0.15571995f, -0.62037027f, -0.05354072f, 0.20520705f, 0.03383036f, -0.03060732f, 0.15144746f, 0.00913454f, 
    0.01002647f, 0.10247447f, 0.19596870f, -0.04907383f, 0.04324686f, -0.02306026f, 0.07367947f, 0.17029844f, 
    0.08498742f, -0.02253539f, 0.15466806f, -0.03703975f, 0.30060926f, 0.13014279f, 0.05879857f, 0.16596557f, 
    0.17676421f, -0.02839535f, 0.11648134f, 0.18941925f, -0.14713994f, -0.08566623f, 0.14156324f, -0.09249620f, 
    0.14860240f, -0.09611344f, 0.01904367f, -0.09890572f, -0.68971664f, -0.27844924f, 0.09188086f, 0.00182196f, 
    0.00577849f, -0.03317346f, -0.02737713f, -0.10392722f, 0.01884627f, -0.12729414f, -0.02166965f, 0.18953982f, 
    -0.06944431f, -0.15208568f, 0.02140043f, 0.04961068f, 0.08680220f, -0.01843173f, -0.05340323f, -0.46372274f, 
    -0.04106003f, 0.14980286f, 0.12475394f, 0.02158294f, 0.20240387f, 0.09745227f, -0.05973144f, -0.12669048f, 
    -0.17792451f, -0.10413615f, 0.16701946f, -0.02518261f, 0.08442682f, 0.12341937f, 0.21560812f, 0.16320740f, 
    -0.11490472f, 0.03753943f, 0.19612823f, 0.12233604f, 0.08609974f, 0.12648320f, 0.12580776f, 0.10161682f, 
    0.20486763f, -0.40633255f, 0.06598665f, 0.27017796f, -0.17535298f, -0.10736041f, -0.20309308f, -0.15944895f, 
    -0.08842389f, 0.03324720f, -0.12514476f, -0.17265360f, 0.15707083f, 0.08555914f, -0.07226161f, 0.24951306f, 
    0.12160447f, 0.11813492f, 0.11780623f, 0.03627743f, 0.06664740f, 0.01723902f, 0.16214404f, -0.04822311f, 
    -0.10985735f, 0.12669982f, 0.11225292f, 0.04653405f, 0.02934363f, 0.19396929f, 0.05401952f, -0.02097619f, 
    -0.01439883f, -0.17162576f, 0.06679546f, -0.02569763f, 0.00610040f, -0.19329302f, 0.02841776f, 0.01110580f, 
    0.04911762f, 0.03884729f, 0.02643892f, -0.14724593f, -0.00123807f, -0.06723747f, -0.19333269f, -0.26549706f, 
    0.12729724f, 0.23965426f, -0.02668876f, -0.03323631f, 0.00998633f, -0.00021851f, 0.00821658f, -0.19712999f, 
    -0.17078525f, -0.23349468f, 0.15378954f, 0.01203134f, -0.03886252f, 0.11257049f, 0.05415971f, 0.02452223f, 
    -0.03754792f, 0.04847801f, 0.02292108f, 0.01972537f, -0.02390505f, -0.02735612f, 0.02897741f, -0.06204538f, 
    -0.01370529f, -0.06329127f, -0.05508384f, -0.00735900f, 0.04365237f, 0.04348104f, 0.04728141f, 0.02654361f, 
    -0.00736013f, -0.02518093f, 0.00064381f, -0.00599825f, -0.05497060f, -0.04549861f, -0.01008611f, -0.05264586f, 
    -0.01405768f, -0.04852328f, 0.03095784f, -0.05750777f, -0.02784833f, 0.05365372f, 0.01686509f, 0.00814140f, 
    -0.04037454f, -0.01305227f, 0.04399355f, -0.05681876f, -0.02494343f, 0.04690203f, -0.01600635f, -0.01077459f, 
    0.03081911f, -0.02049845f, -0.03839276f, 0.00064143f, 0.01949449f, 0.03556457f, -0.00208394f, 0.02806763f, 
    -0.03813811f, 0.02521543f, -0.00657366f, -0.06419306f, 0.01144832f, -0.00785241f, -0.04514230f, 0.04124369f, 
    0.00602143f, -0.06418967f, 0.00643960f, 0.04277699f, -0.06409349f, 0.05128476f, -0.03381166f, 0.02270614f, 
    -0.04822021f, 0.04693409f, -0.05838706f, -0.00076430f, -0.03974671f, 0.04497054f, 0.05149007f, -0.03198473f, 
    -0.04816871f, 0.03666563f, 0.00480112f, 0.04397383f, 0.00408736f, 0.04740280f, -0.00934792f, 0.02205157f, 
    -0.04725436f, 0.01175803f, 0.02104607f, -0.01303849f, 0.00548169f, -0.06337364f, -0.04897019f, -0.05354707f, 
    -0.00729924f, 0.00785760f, -0.03397183f, 0.02165943f, 0.00197667f, 0.00776069f, 0.02563638f, -0.02722871f, 
    0.04490556f, 0.03238210f, 0.00170702f, -0.02819441f, -0.03982265f, 0.01012552f, -0.03653862f, -0.00196023f, 
    -0.03044384f, -0.00571904f, -0.05996860f, -0.04353582f, -0.02578678f, -0.06486936f, 0.05165485f, 0.03848867f, 
    0.02483670f, 0.03648245f, 0.04881036f, -0.04365555f, -0.01602583f, 0.02588245f, -0.01462876f, 0.03968702f, 
    0.01158052f, 0.01749226f, -0.01895766f, -0.04817935f, 0.00514361f, -0.00150673f, -0.02474964f, 0.02298199f, 
    -0.01471677f, -0.04234157f, -0.02740880f, -0.03529474f, 0.00092536f, -0.02392221f, -0.02116303f, 0.04635891f, 
    0.00985793f, 0.04623850f, 0.02118361f, 0.03747311f, -0.05114979f, -0.00175282f, 0.00592052f, -0.01422463f, 
    -0.03489630f, -0.00455411f, -0.05006745f, 0.02473160f, -0.00019967f, -0.00327160f, 0.05425755f, -0.02827467f, 
    -0.03041826f, -0.05769463f, -0.04609091f, -0.02019090f, -0.00044378f, 0.02980120f, 0.04425114f, -0.06427754f, 
    -0.04693523f, 0.02448871f, 0.01405368f, -0.01575947f, -0.00923978f, -0.04478065f, -0.03141641f, -0.04420173f, 
    0.01847740f, 0.03558091f, -0.00946651f, -0.03809758f, 0.00640589f, -0.03435692f, -0.00165752f, 0.01693270f, 
    0.00008702f, 0.01342743f, -0.02044317f, -0.05749919f, 0.02011150f, -0.06121023f, -0.05232884f, -0.02351315f, 
    -0.05286982f, -0.00113676f, -0.02779958f, -0.04654164f, 0.02903641f, 0.03683263f, -0.03692317f, 0.04464188f, 
    -0.04519631f, -0.00042172f, -0.00562133f, -0.06364895f, -0.06009571f, -0.05303086f, -0.00468484f, 0.00565819f, 
    -0.04794841f, -0.00529349f, -0.04702845f, 0.04267000f, -0.03940123f, -0.02137760f, -0.04583851f, 0.04204627f, 
    0.02316299f, 0.04365016f, -0.03229184f, -0.05570462f, 0.03477746f, -0.01233494f, -0.01350074f, 0.00086066f, 
    -0.04981092f, -0.00819280f, -0.03351676f, -0.02545680f, -0.05938854f, -0.06132532f, -0.00730412f, -0.01307280f, 
    -0.05092882f, 0.05815733f, -0.03761220f, 0.05801531f, -0.02258085f, -0.01422446f, 0.04190270f, -0.01497364f, 
    0.02979166f, 0.04984526f, 0.00376689f, -0.02863370f, 0.00403778f, -0.01499407f, 0.01429376f, -0.02464668f, 
    -0.01943705f, -0.03447116f, -0.02217304f, -0.00052438f, -0.03920419f, 0.00237172f, -0.05414469f, -0.01945213f, 
    0.00439343f, 0.01070525f, 0.00734503f, -0.02421419f, -0.01270035f, -0.01557090f, -0.05304430f, 0.01930041f, 
    -0.01075467f, -0.04157948f, -0.01303207f, -0.00045945f, 0.00246872f, 0.01789622f, 0.00060548f, 0.01367351f, 
    0.00546714f, -0.01753202f, -0.02902227f, -0.05843634f, -0.06471208f, -0.00900380f, -0.00345036f, 0.00973867f, 
    0.03262398f, 0.01536313f, -0.02630419f, 0.05788349f, 0.04628615f, 0.04261936f, -0.00877993f, -0.00914400f, 
    0.00836171f, -0.05364306f, 0.04494087f, -0.01184584f, -0.00026988f, -0.00590358f, 0.02545246f, 0.01651349f, 
    -0.31226569f, 0.10664523f, -0.03147241f, 0.12533082f, -0.36056739f, -0.04294480f, 0.21239375f, -0.02309153f, 
    -0.13809799f, -0.06691665f, -0.19127719f, -0.03028843f, -0.21821992f, -0.10651741f, -0.15608436f, 0.08056864f, 
    0.12943977f, -0.00958717f, 0.23135772f, -0.19967896f, 0.11312913f, -0.00256262f, -0.02361341f, 0.12418953f, 
    0.17533085f, -0.03514827f, 0.13137731f, -0.06227511f, 0.13837068f, 0.15344305f, 0.00851842f, 0.06046643f, 
    0.10290562f, 0.22382228f, 0.15547316f, 0.21263273f, 0.35183829f, -0.10382332f, -0.08323278f, -0.15907787f, 
    0.11004078f, 0.07092769f, 0.11876752f, 0.12575784f, 0.15772924f, 0.02728368f, 0.09921528f, 0.05697171f, 
    -0.09760055f, 0.02335083f, 0.13045061f, 0.00650045f, 0.14624692f, -0.15154773f, 0.17254774f, -0.14087133f, 
    -0.29932690f, 0.05803926f, 0.11966801f, -0.10052293f, -0.12460193f, -0.18080375f, -0.23961553f, 0.07965521f, 
    -0.02898938f, -0.11376308f, -0.13409278f, -0.01360815f, 0.18591440f, -0.04859992f, -0.13743921f, -0.01902441f, 
    0.01694062f, -0.02822101f, -0.21272282f, -0.23572233f, -0.13711864f, -0.19730346f, -0.31736183f, 0.14435805f, 
    -0.11153051f, 0.24059795f, -0.05767988f, -0.15218119f, -0.33436146f, -0.20256825f, -0.15167025f, 0.08164681f, 
    -0.07479668f, -0.00170033f, 0.06612604f, -0.00017971f, -0.14927751f, -0.16023773f, -0.26283261f, 0.07824068f, 
    -0.16998410f, 0.09553190f, -0.02879880f, 0.34301537f, -0.01842803f, 0.02848991f, 0.21274331f, 0.01411014f, 
    0.09678555f, 0.04037742f, 0.04138863f, -0.22137173f, 0.23497643f, 0.01085293f, -0.03271399f, -0.05023400f, 
    0.19681773f, 0.16536391f, -0.07096092f, 0.09631447f, -0.03633865f, 0.24259114f, 0.06591577f, 0.18638335f, 
    0.16222622f, 0.07560848f, 0.13729815f, 0.13319685f, 0.17182587f, -0.27801281f, -0.04910868f, -0.08528489f, 
    -0.21934950f, 0.02525713f, -0.08061193f, -0.15123183f, -0.21837808f, 0.14304516f, -0.18328507f, 0.17894728f, 
    -0.08765060f, 0.12312033f, -0.00432677f, -0.15250051f, 0.13940503f, 0.02892762f, 0.05387691f, 0.08952128f, 
    0.04767618f, 0.03415284f, -0.32052213f, 0.03774606f, -0.08144768f, -0.13135436f, 0.09183484f, 0.10964375f, 
    0.02559464f, 0.13787696f, -0.14718057f, -0.06955352f, -0.10013962f, -0.06920493f, -0.14665042f, 0.18871681f, 
    0.08665352f, 0.06838731f, 0.31107152f, -0.01880766f, -0.03353650f, 0.18978319f, 0.05464765f, -0.18755890f, 
    0.23370090f, 0.21907383f, -0.03249542f, 0.19619690f, -0.01731196f, -0.13858750f, 0.11026625f, 0.01275790f, 
    0.01112610f, 0.05346032f, 0.15021566f, -0.09137328f, -0.03918296f, 0.08041120f, 0.08859495f, 0.05417341f, 
    -0.10070504f, -0.14265746f, -0.27073967f, 0.08602231f, -0.46608183f, -0.03970885f, 0.05200563f, -0.12766616f, 
    -0.19233197f, -0.04897946f, 0.23831460f, 0.01780797f, 0.19355769f, -0.09119713f, 0.40597469f, -0.04201950f, 
    0.16117691f, 0.09369111f, 0.08955293f, 0.00277945f, 0.01307700f, 0.13481702f, 0.23933645f, -0.11574854f, 
    -0.02065115f, -0.13096164f, -0.03581895f, -0.36736411f, 0.17128274f, 0.06079745f, 0.14827837f, 0.18557166f, 
    -0.00514793f, -0.02749441f, -0.12223402f, 0.18784928f, 0.05803336f, -0.06427346f, 0.30737275f, 0.03895884f, 
    0.16090740f, 0.02728461f, 0.00038081f, -0.18876711f, -0.15022381f, 0.02757029f, 0.14170225f, 0.03681016f, 
    0.10103406f, 0.00313532f, 0.10094085f, 0.03127546f, 0.07916987f, 0.26930663f, -0.23733456f, -0.13598898f, 
    -0.02593403f, -0.02978491f, -0.10601889f, -0.20825502f, -0.10503011f, -0.13237885f, 0.03116554f, -0.12569056f, 
    -0.25092337f, 0.08303596f, 0.06583743f, 0.13869284f, 0.20698655f, 0.08000680f, 0.05484996f, 0.07076468f, 
    -0.01544950f, 0.14816569f, 0.05421337f, -0.06759520f, 0.03383046f, 0.02288714f, 0.01640121f, 0.04951084f, 
    0.02777180f, 0.10315056f, 0.15275009f, -0.05427157f, 0.08080535f, 0.08912508f, 0.11958840f, 0.08541329f, 
    0.00207295f, -0.15774813f, -0.09198604f, -0.15757112f, 0.06911954f, 0.06612211f, -0.37536570f, 0.21955685f, 
    0.06789732f, 0.11042644f, 0.07736199f, 0.03292966f, 0.07954103f, 0.13214830f, -0.02238834f, -0.20848754f, 
    0.10514362f, 0.01551344f, -0.01168879f, -0.00603569f, -0.04730926f, -0.22688559f, 0.16651942f, 0.28652206f, 
    0.18617402f, -0.03344548f, -0.03405675f, 0.05925606f, 0.07336822f, 0.06953403f, -0.08770759f, 0.11822925f, 
    0.10460664f, 0.33126682f, -0.18566036f, -0.13906392f, -0.29434881f, 0.00927869f, 0.11181641f, -0.02439933f, 
    0.06093927f, 0.00622381f, -0.14098896f, -0.25238892f, 0.06592821f, -0.41135252f, -0.15708697f, -0.09697592f, 
    -0.32351190f, 0.16467057f, 0.06946971f, -0.10929106f, 0.37006658f, 0.12833130f, 0.17026591f, 0.00850186f, 
    -0.04277975f, 0.12601809f, -0.03106575f, 0.18588561f, 0.25039968f, 0.31305131f, -0.03831139f, -0.02059826f, 
    -0.07266394f, 0.02179640f, 0.09602176f, -0.09460686f, -0.00255791f, 0.05437073f, -0.04821603f, 0.05439520f, 
    0.18426286f, 0.06924509f, 0.02802488f, 0.01164843f, -0.11396424f, -0.33677414f, 0.03018157f, 0.28500125f, 
    0.13480493f, 0.20647052f, -0.05409633f, -0.10885938f, 0.06762640f, -0.03535403f, -0.00924937f, 0.00838524f, 
    0.07847412f, 0.11553354f, 0.11566514f, -0.00360445f, 0.04602684f, 0.13333619f, -0.02299131f, -0.08130832f, 
    -0.03340978f, 0.37958270f, 0.23814674f, 0.07345873f, -0.13379495f, -0.09866951f, 0.11988316f, 0.03555376f, 
    0.12136661f, -0.03002039f, 0.24964941f, 0.17867756f, 0.16060720f, -0.06632733f, 0.02472411f, -0.03327733f, 
    0.09180386f, -0.08033194f, -0.02212045f, -0.20335902f, -0.08761455f, -0.13006122f, 0.06477129f, -0.06956864f, 
    -0.04608220f, -0.16111773f, -0.11179826f, -0.05835665f, 0.09241667f, -0.16357470f, 0.10133763f, 0.05309544f, 
    0.10440187f, 0.06177256f, 0.13743009f, -0.00461996f, 0.07809229f, -0.25571749f, -0.07934118f, -0.06367193f, 
    -0.02490971f, -0.07703672f, -0.01709793f, 0.02880669f, -0.01133807f, -0.22012731f, 0.06006816f, 0.19723545f, 
    0.10388944f, 0.22982672f, -0.06561720f, 0.07132188f, -0.13382782f, -0.24191120f, -0.04035832f, -0.41097569f, 
    -0.07290635f, -0.17186365f, 0.04730593f, -0.00660518f, 0.03918122f, 0.07154276f, -0.01323694f, -0.05218078f, 
    0.02239005f, -0.24455671f, 0.13505250f, -0.05779292f, 0.09392352f, -0.01116480f, -0.06742778f, 0.08584297f, 
    0.15765654f, 0.14576614f, -0.09755439f, 0.07314032f, -0.10850126f, 0.06002430f, -0.12033431f, -0.05459074f, 
    0.09200968f, 0.09891143f, 0.07417611f, 0.24332128f, 0.06332228f, 0.01924715f, 0.09055012f, 0.19123796f, 
    -0.04992657f, 0.19305368f, 0.01203915f, -0.00718951f, -0.08473920f, 0.03179136f, 0.07936983f, 0.05158901f, 
    0.02923485f, -0.04329751f, -0.14682198f, 0.06185628f, -0.07555590f, 0.01756456f, -0.02507220f, 0.03351065f, 
    0.04325051f, -0.12145982f, 0.16907452f, -0.13244158f, -0.00670484f, 0.10142625f, 0.08424453f, 0.17270897f, 
    -0.15601298f, -0.15284687f, -0.07726979f, -0.00143992f, -0.01632642f, 0.06296705f, -0.13741277f, 0.16889180f, 
    0.34821498f, -0.06290273f, -0.11928587f, -0.14501944f, 0.23176111f, 0.17559922f, 0.05817312f, -0.06042841f, 
    -0.04375770f, 0.13690749f, 0.04507343f, -0.01263421f, -0.18130766f, 0.01682069f, -0.04066698f, 0.14213109f, 
    0.01691161f, 0.11441203f, 0.23354410f, 0.04326278f, -0.01603415f, -0.07749331f, 0.03059712f, 0.08068936f, 
    0.13717076f, -0.22602224f, -0.06866403f, -0.08567142f, -0.04134014f, 0.01459919f, 0.09509853f, -0.13155268f, 
    -0.12902214f, -0.19903371f, 0.16550419f, 0.11483258f, 0.15689044f, 0.02544017f, 0.04449664f, -0.07665390f, 
    0.22231692f, 0.21509142f, 0.07953452f, -0.02734390f, -0.00366111f, -0.10647219f, -0.15189584f, 0.06131228f, 
    -0.04414651f, 0.04866960f, 0.05352077f, 0.16008753f, 0.00919012f, -0.09908444f, -0.14792044f, -0.07660726f, 
    0.00469615f, -0.14071402f, -0.07340828f, -0.12643479f, -0.20638001f, -0.29134130f, -0.21379541f, -0.30285880f, 
    -0.12190449f, -0.05778775f, 0.04460561f, 0.06926121f, -0.04105505f, 0.01237659f, 0.08304746f, -0.11319837f, 
    0.12137946f, -0.07785127f, 0.04030916f, -0.19159384f, 0.14709535f, -0.06316843f, 0.13710569f, -0.02397756f, 
    -0.16665277f, -0.13515727f, 0.11366579f, -0.01102148f, -0.04906784f, 0.07584906f, 0.07628510f, 0.05975668f, 
    0.26596689f, 0.41373453f, -0.18054272f, -0.06951992f, -0.18651693f, 0.06343552f, 0.07517922f, -0.14706002f, 
    0.02077992f, 0.14520958f, -0.03444086f, -0.09428134f, 0.00119822f, 0.14480725f, -0.02209267f, 0.09889068f, 
    -0.09600695f, 0.07140984f, 0.10427643f, 0.17019080f, 0.23823203f, -0.09115472f, -0.09466854f, -0.07791885f, 
    0.09286208f, 0.05179040f, 0.09457610f, -0.15178032f, 0.45038065f, 0.30700988f, -0.07696059f, -0.30105671f, 
    0.06556470f, 0.19955161f, 0.06500053f, -0.15237917f, -0.07182992f, 0.08860632f, -0.25205362f, -0.06095274f, 
    -0.01732663f, 0.29015252f, -0.06204591f, 0.02731161f, 0.19817752f, 0.17370801f, -0.35041839f, 0.20528480f, 
    -0.06332003f, -0.08443858f, 0.05520978f, -0.06480768f, 0.08497086f, -0.13443905f, -0.54820555f, 0.15342993f, 
    -0.03464644f, 0.00243289f, -0.06645251f, -0.02523310f, -0.02280985f, 0.14912991f, -0.04402339f, -0.00397115f, 
    0.39188057f, 0.15524888f, 0.01863011f, -0.05568007f, -0.06221727f, 0.23850812f, 0.16768284f, 0.04121842f, 
    -0.37097254f, 0.23197149f, -0.03111398f, -0.21792603f, -0.24209502f, -0.10214084f, 0.01851169f, 0.13739124f, 
    0.05266613f, -0.25293162f, 0.08292502f, -0.27300212f, -0.05359545f, -0.10302419f, -0.02994277f, -0.01697984f, 
    0.13256386f, 0.10106224f, -0.27398756f, 0.04670470f, -0.00616127f, 0.08015885f, 0.18453728f, -0.10120058f, 
    -0.02129805f, 0.18292259f, -0.14083420f, -0.28229293f, 0.18041280f, -0.00960116f, 0.03740941f, 0.23723435f, 
    0.03851723f, -0.06316873f, -0.01482124f, 0.03284120f, -0.11410316f, -0.04223564f, -0.11600538f, -0.05053227f, 
    -0.04051229f, 0.05957120f, -0.03238938f, 0.04447979f, 0.01096209f, -0.33274496f, -0.12522532f, 0.16612224f, 
    0.06225246f, 0.06893231f, -0.10176934f, 0.13318874f, -0.01879450f, 0.02569925f, -0.20072356f, 0.05790860f, 
    -0.03017623f, -0.12377038f, -0.16052467f, -0.05336649f, 0.04241884f, -0.26147664f, 0.02224609f, -0.22761719f, 
    -0.37589854f, 0.38480023f, 0.08694286f, -0.01282030f, -0.27790073f, -0.01276734f, 0.06532647f, 0.20445396f, 
    -0.28072113f, -0.46871170f, 0.00602461f, 0.18016404f, 0.16924553f, -0.03983983f, -0.09403019f, 0.13394018f, 
    -0.03594011f, 0.09564618f, 0.13490702f, 0.01685808f, 0.10206725f, -0.03036045f, 0.24377076f, -0.07311731f, 
    0.11258535f, -0.07941296f, -0.30638206f, 0.05993568f, -0.08351371f, -0.02751492f, 0.01382998f, 0.04192023f, 
    -0.04906778f, 0.00199234f, -0.09787715f, -0.44211531f, -0.09530671f, 0.04881765f, -0.11242335f, -0.02556952f, 
    0.05908870f, -0.11602984f, -0.00079007f, -0.09262789f, -0.15879446f, -0.20476507f, -0.02434288f, -0.10577269f, 
    0.05672891f, -0.04433724f, -0.03620251f, 0.04364070f, -0.05270505f, -0.13248283f, -0.24235129f, 0.38904679f, 
    -0.01900795f, 0.08218598f, -0.00041342f, 0.07725893f, 0.07252111f, -0.12005779f, -0.24712895f, 0.56628859f, 
    0.07528049f, 0.10526517f, -0.19639914f, -0.23577200f, 0.01492859f, -0.08965294f, -0.03006331f, 0.01883462f, 
    0.16419114f, 0.16861004f, -0.03471351f, -0.17525518f, -0.08012585f, 0.04304404f, -0.16606651f, 0.01982502f, 
    -0.14577599f, 0.13888320f, -0.14544389f, -0.02724532f, 0.02883879f, 0.10839330f, 0.07851277f, -0.06285803f, 
    0.04864289f, -0.09784198f, -0.38287655f, 0.31467882f, -0.10762406f, 0.08646591f, -0.03489305f, 0.09065308f, 
    0.07872915f, -0.00565824f, -0.20311940f, 0.00753629f, -0.12687092f, -0.02746469f, 0.06908971f, -0.02018693f, 
    -0.14046346f, -0.01068265f, -0.00405627f, -0.21414678f, -0.04569570f, 0.04607052f, 0.14211853f, -0.00200351f, 
    0.10515020f, -0.05762384f, -0.10581928f, -0.04094500f, -0.01307607f, 0.11910596f, 0.19169375f, -0.02698683f, 
    0.10008305f, -0.02808256f, 0.06194211f, 0.08201682f, -0.04681983f, -0.09086701f, 0.15076886f, 0.38457406f, 
    -0.00162909f, -0.11683780f, -0.08030223f, 0.03682547f, -0.01067669f, -0.01250353f, -0.30427179f, 0.14276618f, 
    -0.02603585f, -0.14812389f, -0.03862183f, 0.08845733f, 0.17297308f, -0.05569914f, -0.04850236f, -0.12569955f, 
    0.21160850f, 0.23575068f, -0.04481345f, 0.01130504f, -0.14883836f, 0.04690052f, 0.12490501f, 0.07242858f, 
    -0.03712386f, -0.06462261f, 0.08345193f, 0.00671744f, -0.00623392f, -0.28479615f, 0.06046172f, 0.14639503f, 
    0.12862267f, 0.02348725f, -0.01598569f, 0.03304199f, -0.02071659f, -0.08939174f, 0.01001013f, 0.18248461f, 
    0.09850702f, 0.13537149f, 0.17792691f, 0.01047573f, 0.11186258f, -0.09515548f, 0.12568943f, -0.04701642f, 
    -0.08263799f, 0.03071544f, 0.09253229f, 0.11798269f, 0.00590786f, 0.23272265f, -0.05710635f, 0.11381887f, 
    -0.11979757f, 0.09625504f, 0.10170600f, -0.16690594f, -0.16764946f, -0.12443161f, -0.36575821f, 0.00005832f, 
    0.01331984f, 0.00845863f, 0.08689614f, 0.12523496f, 0.00058200f, 0.10211040f, -0.16092759f, -0.23373389f, 
    0.00147985f, 0.27000391f, -0.00403502f, 0.09962123f, 0.02863671f, -0.03220756f, -0.33288452f, -0.14890456f, 
    0.03189579f, 0.04593401f, 0.14075574f, -0.16279420f, 0.04361433f, -0.04641247f, 0.07521498f, -0.21637858f, 
    -0.25864834f, 0.07611541f, 0.12338645f, 0.07476845f, 0.07874889f, 0.04480758f, 0.18147004f, 0.11471786f, 
    -0.44699955f, -0.24423243f, 0.09331885f, 0.03620794f, -0.05716052f, 0.01661414f, 0.01312641f, -0.03111575f, 
    0.03208037f, -0.13604255f, -0.23991515f, 0.08435957f, -0.06209403f, -0.02647252f, -0.05855988f, -0.08467723f, 
    0.07689524f, 0.14280696f, -0.53853613f, -0.45005289f, -0.02846472f, 0.13311802f, 0.01786515f, 0.20064589f, 
    0.02016670f, 0.00121547f, 0.11348674f, -0.09927230f, 0.20349364f, 0.16940573f, 0.03147394f, 0.04017722f, 
    -0.00489053f, 0.07169799f, 0.02628697f, -0.23809218f, -0.11544939f, -0.09322152f, -0.10655388f, 0.00402856f, 
    -0.02409633f, 0.09199816f, 0.08492113f, 0.02430530f, 0.09975151f, -0.03497905f, 0.15164337f, -0.02733693f, 
    0.07642677f, 0.15210085f, 0.03217466f, 0.02876111f, 0.02834984f, 0.03275290f, -0.09453648f, -0.13877788f, 
    0.10660895f, -0.00158335f, -0.20171352f, -0.03117954f, 0.07154820f, 0.01677662f, 0.05392966f, 0.19596063f, 
    0.30215323f, 0.28326997f, -0.01015292f, -0.18073426f, -0.04054769f, -0.20166555f, 0.14477171f, 0.05455370f, 
    -0.43077976f, -0.39077672f, -0.22941209f, 0.16521627f, -0.18430358f, 0.10331132f, -0.15090765f, 0.03248882f, 
    0.15913537f, 0.09830109f, 0.06474756f, 0.25289240f, -0.16048208f, 0.03314660f, 0.12463777f, 0.04526350f, 
    0.20138074f, 0.12049076f, -0.22073187f, -0.08926070f, -0.11182579f, 0.01458136f, 0.05450987f, 0.02725588f, 
    0.18959510f, 0.17030892f, 0.09794617f, 0.13985096f, -0.05558275f, 0.14181961f, -0.07968208f, 0.02692531f, 
    -0.03873538f, 0.12402605f, -0.00853715f, 0.12523533f, 0.16208552f, -0.06049657f, -0.00624797f, 0.03849394f, 
    -0.03485956f, 0.04156275f, 0.05428633f, 0.02495638f, -0.20111474f, -0.29365388f, -0.44739959f, -0.39482507f, 
    0.18266389f, 0.06617636f, -0.03845948f, -0.03764824f, 0.07998830f, -0.02782935f, -0.31979752f, -0.37626630f, 
    0.19386154f, -0.18510565f, 0.14173105f, 0.00258407f, -0.19650611f, 0.10616460f, 0.11665094f, -0.00106423f, 
    -0.13476406f, 0.08587696f, 0.02220285f, -0.00312378f, -0.13351005f, -0.06547838f, 0.02422152f, 0.25500271f, 
    0.01148485f, -0.21747121f, -0.00421292f, 0.01575783f, 0.06546880f, 0.15288901f, -0.01105709f, 0.09497711f, 
    0.16514641f, 0.20798250f, -0.00243553f, -0.13036224f, 0.06055703f, 0.07639623f, 0.06246716f, -0.01438303f, 
    -0.04899536f, -0.06693134f, 0.10548817f, -0.20584150f, 0.08842187f, 0.08428420f, 0.14576308f, 0.12765677f, 
    0.03290729f, 0.10722849f, 0.10032219f, 0.09977764f, -0.15959825f, 0.07157009f, -0.10236048f, 0.11835264f, 
    0.11654680f, 0.01597175f, 0.07338384f, 0.08294424f, 0.25538191f, 0.17369114f, 0.21929924f, -0.01524672f, 
    0.12586659f, 0.03158978f, 0.03886990f, 0.02715077f, -0.24951987f, 0.11423947f, 0.04657796f, -0.04524131f, 
    0.04384102f, 0.04516118f, 0.08810355f, 0.00622371f, -0.03661090f, -0.21260937f, -0.62364221f, -0.46071672f, 
    0.05038999f, 0.04715426f, 0.01509348f, 0.08643594f, -0.02453520f, 0.00275833f, -0.11820829f, 0.13949326f, 
    0.13396922f, 0.07020979f, 0.08648466f, 0.11180682f, 0.10803561f, -0.06747686f, 0.06467663f, 0.06196440f, 
    0.10388388f, 0.23878489f, 0.20438866f, -0.23803493f, -0.13480036f, -0.04595863f, 0.08313894f, -0.04435044f, 
    0.08348476f, 0.02198103f, 0.04614851f, 0.15960477f, 0.03366501f, 0.00586214f, -0.23072392f, 0.01925838f, 
    -0.01539978f, -0.01060288f, -0.06171921f, -0.20151004f, 0.11083996f, 0.14267461f, -0.03917452f, 0.24324735f, 
    0.02337881f, -0.05087962f, -0.01804174f, -0.14807482f, 0.13728695f, 0.35390246f, 0.12025894f, 0.11351851f, 
    -0.15219091f, 0.05631936f, 0.01199958f, 0.12770163f, 0.38821524f, 0.09110476f, -0.26367572f, -0.09120587f, 
    0.06797283f, 0.17089744f, 0.05802799f, -0.08255669f, -0.19029161f, 0.36693120f, -0.33160675f, 0.10242186f, 
    -0.12877382f, 0.00218936f, 0.23286399f, 0.02487787f, 0.02794269f, -0.06039997f, -0.08689196f, 0.10997757f, 
    -0.14239901f, -0.01781994f, -0.01163474f, -0.10566869f, -0.26661927f, 0.04774896f, 0.26305148f, 0.26759326f, 
    -0.14035314f, 0.31677192f, -0.09954180f, -0.10772949f, 0.12112457f, -0.02757386f, 0.10563798f, 0.10363289f, 
    -0.04892157f, 0.15973027f, 0.05956961f, -0.18527916f, 0.00714047f, -0.19171531f, -0.13710774f, 0.10581158f, 
    0.15436590f, 0.03814994f, 0.14293170f, -0.15856379f, -0.01479777f, -0.16029873f, -0.08760466f, -0.02042069f, 
    0.09743565f, -0.13014184f, 0.14802983f, 0.11097379f, 0.14831686f, -0.11175451f, 0.03773522f, -0.08638119f, 
    0.11193802f, -0.02192807f, -0.03169963f, -0.11940947f, 0.29660532f, -0.23687021f, -0.15024771f, -0.04235389f, 
    0.09423392f, 0.05673031f, -0.04385617f, 0.03150096f, 0.28813803f, -0.04120179f, 0.07169958f, -0.02468336f, 
    0.25357321f, -0.04948798f, 0.05553311f, -0.18030939f, 0.10727967f, -0.15753233f, 0.07224360f, 0.32691959f, 
    -0.17853786f, 0.01532569f, -0.09041443f, 0.00737988f, 0.08671603f, 0.05212140f, 0.05953643f, 0.21627437f, 
    -0.00468605f, 0.11821515f, -0.18964982f, -0.00298475f, -0.22778705f, 0.10969733f, 0.11215091f, -0.38346291f, 
    0.07913084f, -0.13987947f, -0.15275393f, -0.05718701f, 0.08644716f, 0.10227928f, -0.06540165f, -0.05115962f, 
    0.57411295f, 0.32861486f, -0.00140070f, -0.08620030f, -0.09533998f, 0.08440463f, 0.15000637f, -0.21910490f, 
    -0.10002704f, -0.23761640f, 0.10467938f, 0.11921097f, -0.06424507f, -0.03693580f, 0.04590829f, -0.10570802f, 
    -0.01551628f, -0.01120413f, -0.18443784f, 0.23946458f, -0.19776262f, 0.08563381f, 0.03747924f, 0.13330263f, 
    0.00936297f, -0.04469595f, 0.02200135f, -0.12311263f, -0.18102013f, -0.23930106f, 0.06928031f, 0.11646475f, 
    -0.15815736f, -0.01517149f, 0.15598534f, 0.09408993f, -0.20822221f, 0.04510466f, 0.02390124f, 0.06139868f, 
    0.06072673f, -0.01754548f, 0.03021636f, 0.04900594f, 0.08414082f, 0.16162978f, 0.36964092f, -0.10192316f, 
    -0.15044664f, -0.10159343f, 0.02444858f, 0.07637630f, -0.08165344f, -0.22900885f, -0.35625261f, -0.52180523f, 
    0.57679677f, -0.14917780f, -0.02070006f, -0.31750110f, 0.02321866f, -0.10215855f, -0.08573608f, -0.01038143f, 
    -0.00501532f, 0.06164963f, -0.01432956f, -0.11090179f, -0.28710589f, 0.01520708f, 0.05356719f, 0.16135812f, 
    -0.10644981f, 0.07928754f, -0.04110423f, -0.13961335f, 0.00381387f, 0.00874843f, 0.11894893f, 0.02049064f, 
    -0.03357809f, 0.02365342f, 0.17495124f, -0.26310262f, 0.03061575f, 0.09749769f, -0.12008502f, -0.03027533f, 
    0.21030127f, 0.01349934f, -0.44726521f, -0.00299373f, -0.07952990f, -0.11646620f, -0.01683248f, -0.07522738f, 
    0.06846929f, -0.13174947f, 0.01025561f, -0.11059622f, 0.11903515f, -0.01024468f, 0.05223282f, 0.11106723f, 
    -0.05916364f, 0.03530365f, 0.10909408f, -0.10291341f, -0.10960823f, 0.15796396f, 0.09938861f, -0.03312492f, 
    -0.12979522f, -0.04549061f, -0.06641274f, 0.09933461f, -0.05643588f, -0.01462692f, -0.03381052f, -0.17056550f, 
    0.00215766f, 0.18425424f, 0.03623509f, -0.08060227f, 0.08338567f, 0.03638553f, 0.08753791f, 0.33893439f, 
    -0.03268347f, 0.09137227f, 0.09539530f, -0.11471102f, 0.10307896f, 0.01988706f, 0.05077125f, -0.09423768f, 
    -0.02554151f, 0.22660932f, -0.16547589f, 0.03772237f, -0.23295139f, 0.13158098f, -0.11008004f, 0.09511674f, 
    0.13587222f, -0.17589228f, -0.12776162f, -0.10041536f, -0.01531052f, 0.16667984f, 0.01409390f, -0.00427542f, 
    0.00257810f, 0.18580341f, -0.13598554f, -0.07240205f, -0.11196942f, -0.13105735f, 0.00216928f, -0.05881267f, 
    0.05120796f, -0.29888874f, -0.08575067f, 0.11902156f, 0.02291147f, 0.06103915f, 0.11227971f, 0.07930541f, 
    -0.02970910f, 0.08328077f, -0.04605404f, 0.26224273f, -0.04824272f, -0.05669546f, 0.19600345f, 0.11101703f, 
    0.11474633f, 0.01478017f, -0.02890430f, -0.04200692f, -0.07815274f, 0.03758797f, 0.05912816f, 0.02106459f, 
    -0.02175388f, -0.12695010f, 0.10258093f, 0.00547755f, -0.08063081f, -0.45569083f, 0.22362074f, 0.02510052f, 
    -0.03957372f, -0.06588457f, -0.16065444f, 0.12522912f, 0.14007270f, 0.09368484f, 0.11478604f, -0.19179462f, 
    0.00680238f, -0.01635737f, 0.04272143f, 0.18562950f, -0.05251179f, -0.06506588f, -0.01357424f, -0.01979722f, 
    0.26277146f, -0.06883186f, -0.05672452f, 0.03613117f, 0.08366997f, -0.02081692f, -0.30337682f, -0.10380908f, 
    0.11677946f, 0.26426861f, -0.10043223f, -0.01080757f, 0.04162394f, 0.11172121f, 0.16027507f, -0.19754314f, 
    -0.06741626f, 0.03579329f, -0.06499973f, -0.16504310f, -0.05915271f, 0.10596712f, -0.20635140f, -0.11006516f, 
    -0.12557063f, 0.14303762f, 0.22132127f, 0.34377354f, -0.08558368f, -0.12802115f, 0.04040628f, -0.09791353f, 
    -0.06017181f, -0.14163756f, -0.05040531f, 0.16012087f, 0.01664945f, 0.11675467f, -0.02857960f, 0.10994616f, 
    0.14994003f, 0.14353667f, 0.04614914f, 0.08390540f, 0.09223808f, -0.07519075f, 0.07453584f, -0.02973210f, 
    0.01997961f, -0.01896072f, 0.12055130f, 0.17137294f, -0.06231130f, 0.24053812f, 0.09026007f, 0.10963339f, 
    -0.01853402f, 0.03086579f, 0.04579818f, -0.05327111f, -0.09791650f, -0.05761960f, -0.16996151f, 0.17838015f, 
    -0.16207173f, 0.07710498f, 0.15203254f, 0.01401087f, 0.15215150f, -0.08420409f, -0.15032743f, 0.11352459f, 
    0.22900811f, -0.22747900f, 0.05550397f, 0.08284181f, 0.02979585f, -0.05588346f, 0.09043822f, -0.02518455f, 
    -0.15199091f, 0.23661786f, 0.06459307f, 0.10583916f, 0.08419233f, -0.18332562f, -0.01586476f, 0.15320443f, 
    -0.18051669f, 0.03048963f, -0.09372216f, 0.08584676f, 0.11855207f, 0.11877704f, 0.07985862f, 0.11226425f, 
    -0.23443380f, 0.04974780f, -0.20704331f, -0.00574880f, -0.09617724f, -0.19204602f, -0.05061511f, 0.01081076f, 
    0.06230754f, 0.15774778f, -0.11235524f, 0.28942522f, -0.00605146f, -0.09862636f, -0.22542849f, -0.07229031f, 
    0.04806365f, 0.16752775f, 0.00914811f, 0.11297231f, 0.19112188f, 0.38506612f, 0.21819302f, 0.17753504f, 
    -0.19795175f, 0.11466993f, 0.03430627f, -0.07931864f, -0.13044780f, -0.14010327f, -0.04163114f, 0.04764638f, 
    0.12237941f, 0.12293191f, -0.00984180f, 0.05939791f, -0.00064359f, -0.01194157f, 0.07026549f, 0.01064444f, 
    -0.13405664f, 0.08756077f, 0.08701103f, 0.37176952f, 0.02798604f, 0.01068226f, -0.03141898f, 0.11030902f, 
    -0.04899382f, -0.07869747f, 0.05425464f, 0.09659867f, 0.08734461f, 0.10174652f, 0.10828543f, 0.08638002f, 
    0.07949815f, -0.37607801f, -0.07358424f, -0.01942345f, 0.13569206f, 0.01601748f, -0.17506669f, -0.22522679f, 
    -0.00423974f, -0.09298313f, -0.26743656f, -0.16728221f, -0.02319420f, 0.06449376f, 0.10544226f, 0.20904975f, 
    0.13538340f, 0.20137861f, 0.17966844f, -0.03230084f, -0.10980623f, 0.06271366f, -0.15282293f, 0.05137796f, 
    -0.01116694f, -0.01382925f, -0.18734734f, 0.00655931f, -0.08677309f, -0.15365756f, 0.08002214f, -0.00498991f, 
    0.15687227f, -0.07819137f, -0.19122210f, -0.36884934f, 0.08188716f, -0.02290351f, -0.17918496f, -0.00808384f, 
    0.01071692f, 0.07881481f, -0.04400006f, 0.16580386f, 0.10689045f, -0.22276464f, -0.19728085f, 0.15031946f, 
    0.06718431f, 0.15309520f, 0.06306574f, 0.20931819f, 0.19019157f, 0.12717916f, 0.21093562f, 0.26832169f, 
    -0.18026717f, 0.20421298f, -0.23423879f, -0.05896615f, 0.01306011f, -0.12129216f, -0.16578129f, 0.18403149f, 
    0.17240146f, 0.12457056f, -0.02312172f, -0.10910039f, -0.02975176f, 0.00293055f, 0.04434466f, -0.01187467f, 
    0.03666139f, 0.01091356f, -0.01484713f, -0.01354744f, -0.02059494f, -0.05882623f, -0.02058328f, -0.01636948f, 
    0.02431690f, -0.01855280f, -0.06265272f, 0.00636217f, 0.00373323f, -0.02638216f, -0.00683530f, -0.03930281f, 
    -0.04371753f, 0.03188622f, -0.02500385f, -0.01232028f, 0.05169506f, -0.03640686f, 0.03711753f, -0.03953442f, 
    -0.04000432f, -0.05418760f, -0.04704690f, 0.00341575f, -0.01026595f, -0.03557232f, -0.00998824f, 0.05808981f, 
    -0.05019775f, 0.04562006f, -0.03579183f, -0.02562092f, 0.02749102f, -0.04106586f, 0.04667591f, -0.02533043f, 
    -0.05294983f, 0.02305801f, -0.03012344f, -0.02447933f, -0.04749967f, 0.02180419f, -0.02783732f, -0.04347087f, 
    0.01434825f, -0.03883436f, -0.00724587f, -0.03766596f, -0.05843589f, -0.03636800f, -0.04883914f, -0.05347550f, 
    -0.00658549f, 0.02080471f, -0.02881921f, 0.00450303f, -0.03827915f, 0.00924650f, -0.03376744f, -0.02587673f, 
    -0.04219940f, 0.03774578f, 0.01036322f, 0.02163542f, 0.02796245f, 0.01464399f, 0.02739823f, 0.05092704f, 
    -0.03308715f, 0.01778650f, -0.00362633f, 0.03598117f, -0.06354044f, -0.00335022f, -0.04262817f, -0.05126160f, 
    -0.05583840f, 0.01852547f, 0.05145701f, 0.03007453f, 0.01741033f, 0.03135376f, -0.00032174f, -0.01059842f, 
    0.05191153f, -0.02162662f, -0.04831136f, 0.01263719f, 0.01072485f, -0.04165173f, 0.00950957f, -0.00311456f, 
    -0.04119200f, -0.03114585f, 0.02145213f, -0.00037128f, -0.00595650f, -0.00636041f, 0.02091355f, 0.01274674f, 
    0.00626449f, -0.00365429f, 0.04084781f, 0.03727990f, -0.02048705f, -0.02481392f, 0.00687347f, -0.02479458f, 
    0.05127370f, 0.01435092f, -0.00466338f, -0.00827871f, -0.04026430f, -0.01240021f, 0.00448277f, -0.04659513f, 
    -0.00765109f, -0.04837688f, 0.01149423f, 0.05392285f, 0.04625256f, 0.02891450f, 0.02029678f, 0.01103876f, 
    0.03662242f, -0.06332030f, -0.05082419f, 0.02594285f, -0.01224566f, 0.01481685f, 0.05302234f, -0.03213024f, 
    0.05250220f, 0.00208607f, -0.04546851f, -0.04261311f, -0.03549421f, 0.04076675f, 0.04094328f, -0.03462900f, 
    -0.01748006f, -0.04366837f, -0.04553061f, -0.00585874f, -0.04830033f, 0.04325466f, -0.00552415f, -0.01025475f, 
    0.04549247f, -0.01906791f, -0.06075598f, -0.05002476f, 0.01375722f, 0.00759070f, 0.03991966f, -0.02356799f, 
    -0.04755834f, 0.05055171f, -0.05175475f, -0.06500541f, 0.01572613f, 0.00122094f, 0.02339927f, 0.05314420f, 
    -0.00881176f, -0.06218244f, -0.01707734f, -0.01760512f, 0.01220629f, -0.06076071f, 0.00983592f, 0.02639002f, 
    0.03395176f, 0.03938658f, 0.04192870f, 0.01423737f, 0.03427149f, -0.02406758f, -0.04052636f, -0.03034315f, 
    -0.00988304f, 0.04817786f, 0.02160452f, -0.02906047f, 0.05245613f, -0.04075396f, -0.06045377f, -0.01655820f, 
    0.04184112f, -0.00786372f, -0.02677553f, 0.00210446f, 0.02519624f, 0.00699173f, -0.04283283f, 0.02508782f, 
    -0.02738666f, 0.00281124f, -0.05217309f, 0.00672532f, 0.03966883f, -0.00171773f, 0.03263389f, -0.01150425f, 
    0.01258172f, 0.02800095f, -0.02244892f, -0.02525689f, 0.00272361f, 0.05006154f, 0.00228351f, 0.01983080f, 
    -0.04626376f, 0.02788934f, -0.01366364f, -0.03187560f, 0.01059913f, 0.02843285f, -0.04206325f, -0.00970976f, 
    0.04144803f, 0.00041854f, -0.03405563f, 0.02238199f, -0.04482417f, 0.02275262f, 0.04631222f, -0.03942413f, 
    -0.03449589f, 0.05067166f, 0.02552545f, 0.04220633f, -0.05489052f, -0.04999146f, -0.04537749f, 0.02454766f, 
    0.01655702f, 0.01324944f, -0.04689367f, -0.04101760f, 0.00087761f, -0.03342205f, -0.04795058f, 0.04582071f, 
    0.03783776f, -0.04074153f, 0.03523476f, -0.01567519f, -0.03126404f, 0.03622538f, 0.02245740f, 0.02602889f, 
    -0.05367815f, -0.01994766f, -0.06131132f, -0.04687900f, -0.02464234f, 0.00752117f, -0.02237783f, -0.04303094f, 
    -0.01960451f, -0.05103333f, -0.00296245f, 0.03694555f, -0.00709679f, -0.00917334f, -0.00155823f, 0.04550076f, 
    0.04286615f, 0.01462511f, -0.06259622f, -0.00127201f, -0.05513982f, 0.04188858f, -0.04993546f, -0.03736418f, 
    -0.00688112f, 0.02776253f, -0.04261791f, 0.00606136f, -0.05891557f, -0.00537704f, -0.06145151f, -0.06199059f, 
    -0.05507937f, -0.06642984f, 0.12496230f, -0.00419603f, -0.00359433f, -0.13001306f, 0.00236661f, 0.36661813f, 
    0.21671119f, 0.02225470f, 0.08525576f, -0.19968046f, -0.17928801f, -0.19246668f, 0.02433421f, 0.10353009f, 
    0.00132460f, 0.14282541f, 0.01216773f, 0.08457301f, 0.16158184f, 0.05716702f, 0.23320128f, -0.01480371f, 
    0.19725139f, -0.14539419f, 0.12355270f, -0.27518392f, 0.22366552f, 0.33584225f, 0.12550130f, -0.04042174f, 
    -0.07978371f, 0.25716093f, 0.03809690f, 0.21832539f, 0.32185826f, -0.16919690f, -0.20427704f, -0.01375351f, 
    -0.01390312f, -0.02689233f, -0.05328361f, 0.02097448f, 0.11628228f, 0.82765031f, -0.05512876f, -0.02539526f, 
    0.20399439f, -0.06299127f, 0.13810934f, -0.11114708f, 0.06376911f, 0.16420034f, -0.56551105f, -0.02561156f, 
    0.06830307f, -0.05342766f, 0.08158865f, -0.25023401f, 0.05872480f, -0.03034835f, -0.03707036f, 0.11009584f, 
    -0.31262660f, 0.26453236f, -0.13017355f, -0.06602655f, -0.06165379f, -0.01674828f, 0.16158473f, 0.28820693f, 
    -0.04267611f, -0.22714320f, -0.13492182f, -0.01177045f, -0.05969279f, -0.31773862f, -0.11860809f, -0.11438457f, 
    -0.02570635f, 0.07109008f, -0.55230469f, 0.07689882f, -0.35427418f, -0.15488024f, -0.06007251f, -0.05455859f, 
    0.10937844f, 0.03989467f, -0.21742313f, -0.15442304f, -0.01566158f, -0.13886158f, -0.00862304f, -0.16743897f, 
    0.18394999f, -0.01641200f, 0.24614914f, -0.25390446f, 0.31701431f, 0.09373154f, 0.13250773f, -0.04389733f, 
    -0.01152605f, 0.13660629f, 0.20610493f, 0.06260813f, 0.18742220f, 0.12314212f, -0.11123518f, -0.05437409f, 
    -0.08984192f, 0.05261782f, 0.06663392f, 0.09669448f, 0.20627314f, -0.22099410f, -0.05163557f, 0.13346416f, 
    -0.03662203f, 0.05603136f, -0.00528640f, 0.15435863f, 0.20107767f, 0.02166063f, 0.04590467f, -0.28487349f, 
    0.01342387f, -0.22042093f, -0.08008800f, -0.22362310f, 0.05844035f, -0.01644078f, -0.10755304f, -0.15981062f, 
    -0.02204210f, 0.09152839f, -0.02989256f, -0.25281608f, -0.04465470f, 0.01646813f, -0.17051668f, 0.03737233f, 
    0.37875894f, -0.38426036f, -0.42667967f, 0.05973586f, -0.06981695f, 0.17721450f, 0.07118856f, -0.21357135f, 
    0.25561479f, -0.01808726f, -0.14794703f, 0.20368156f, -0.22172314f, 0.05708204f, -0.03181092f, -0.05219730f, 
    0.12956814f, -0.05814090f, -0.11033417f, -0.12285173f, 0.08583524f, 0.10950874f, 0.15581159f, 0.21386433f, 
    0.13494974f, 0.11161834f, -0.01411515f, -0.21849348f, 0.08350787f, 0.29626036f, 0.08410072f, 0.09017988f, 
    0.01203036f, 0.10488138f, 0.10322563f, -0.06027037f, 0.01639300f, -0.20797177f, 0.02172370f, 0.20169660f, 
    0.08664774f, -0.07488937f, 0.03061300f, 0.10316541f, 0.06137235f, -0.02901267f, -0.10216450f, 0.00241512f, 
    -0.16772705f, -0.00118612f, -0.27879861f, 0.05516188f, -0.07694201f, 0.05258752f, -0.39526552f, -0.29664004f, 
    0.21167432f, 0.08863302f, -0.09250183f, 0.02618556f, -0.05313646f, -0.13420334f, 0.26124057f, -0.37501734f, 
    -0.32833841f, -0.16458002f, -0.13241005f, -0.10425923f, -0.06580477f, 0.01523375f, 0.17890766f, 0.03906699f, 
    -0.46245143f, -0.08491054f, -0.02779580f, -0.01501135f, 0.28197205f, 0.02054597f, 0.10920537f, 0.13628571f, 
    0.19137727f, -0.26119879f, 0.34403047f, 0.23929183f, -0.05912153f, 0.11406130f, 0.10687058f, 0.19164459f, 
    -0.04409618f, -0.02624503f, -0.19190741f, -0.51693386f, 0.28408831f, -0.08541992f, 0.02189314f, -0.01037534f, 
    0.22943909f, 0.04626065f, 0.23291332f, -0.13774952f, -0.10705252f, -0.12623632f, -0.04017624f, 0.05643047f, 
    0.04044439f, -0.00939423f, -0.03452506f, 0.12721287f, -0.05508855f, 0.26104784f, 0.38357207f, 0.18748055f, 
    0.07884297f, 0.08947610f, 0.10333622f, 0.22983003f, 0.13337392f, -0.03212752f, 0.26274890f, -0.07871196f, 
    -0.01600997f, 0.15134361f, 0.08896362f, 0.07679604f, 0.07898314f, 0.00235163f, -0.39977226f, -0.40752181f, 
    0.34663960f, -0.07185060f, -0.00423126f, -0.15271343f, 0.06712165f, 0.02212475f, -0.04295682f, -0.19072500f, 
    0.08059613f, 0.06487510f, -0.01828815f, 0.10316428f, -0.02475659f, 0.10840756f, 0.16186462f, 0.17533989f, 
    -0.16544488f, 0.35407794f, -0.02766694f, -0.18496220f, 0.00112463f, -0.14051886f, 0.07930563f, 0.04600527f, 
    -0.03337520f, 0.06510518f, -0.09669773f, -0.16326001f, -0.11292309f, 0.01565935f, 0.04349156f, 0.04624402f, 
    -0.10564421f, 0.27214089f, 0.11539033f, -0.03206032f, 0.26268411f, -0.04235024f, 0.00388699f, -0.04230811f, 
    0.00670586f, 0.18920913f, -0.22636816f, -0.55255157f, 0.25830427f, 0.20360817f, -0.18180959f, -0.14935517f, 
    0.01548993f, -0.01935641f, -0.02386872f, 0.12177508f, -0.05463776f, -0.07386784f, -0.13638502f, -0.18949553f, 
    0.19090812f, -0.03936934f, 0.03485097f, 0.28606963f, -0.11536600f, 0.24002996f, 0.00206715f, 0.20439942f, 
    0.14234231f, 0.05759571f, -0.32797661f, 0.22838652f, -0.07670747f, 0.09804507f, -0.41240069f, 0.12985726f, 
    -0.08423899f, 0.11770412f, 0.09814254f, 0.13850565f, -0.03020947f, -0.14011931f, -0.01287281f, 0.01217632f, 
    -0.06205715f, 0.05213411f, 0.02863661f, 0.22474314f, 0.09116737f, 0.03238629f, 0.00781102f, 0.13948317f, 
    -0.09356422f, -0.26837137f, -0.08966988f, -0.03735778f, -0.10397184f, -0.23774138f, 0.07737949f, -0.02168851f, 
    0.12264144f, -0.19025271f, -0.30509457f, -0.09956225f, -0.21015912f, -0.02032538f, -0.13968447f, -0.00875767f, 
    0.28662267f, -0.11424291f, -0.22384296f, -0.05518284f, 0.07974300f, 0.01279216f, -0.07390586f, -0.16883954f, 
    0.09704985f, -0.08706726f, 0.19939584f, -0.05792127f, 0.13727070f, -0.08783362f, 0.05563506f, 0.05815581f, 
    -0.15780310f, 0.22269730f, 0.23791446f, 0.11305432f, -0.21067429f, 0.10617478f, 0.03475529f, -0.00087420f, 
    -0.00482601f, 0.13787970f, -0.05101477f, -0.02365334f, -0.00836539f, -0.29120880f, -0.00457820f, 0.33804333f, 
    -0.23748797f, -0.14256057f, -0.15521669f, 0.15600282f, -0.04682926f, -0.03328276f, -0.07055451f, -0.18348028f, 
    -0.18430923f, 0.10365646f, 0.05803558f, -0.09895296f, 0.12284214f, 0.02163775f, 0.10693908f, -0.15711848f, 
    0.01712168f, -0.32556653f, 0.18984383f, -0.14866590f, 0.12980500f, -0.24293886f, -0.22072349f, -0.15712057f, 
    0.74860698f, 0.17055482f, -0.73446441f, 0.14952028f, -0.01423181f, -0.15056171f, 0.08929130f, -0.03572995f, 
    -0.01719098f, 0.35487130f, -0.09666020f, -0.17215133f, 0.02885852f, 0.06291056f, -0.02973263f, -0.07303376f, 
    -0.22480817f, 0.18388264f, -0.04489943f, -0.01469340f, -0.02060307f, 0.02898572f, 0.07838342f, -0.04364623f, 
    -0.04025688f, 0.19761719f, -0.24371283f, -0.28246567f, 0.16000870f, 0.03790981f, 0.16784103f, 0.04141460f, 
    -0.14190534f, 0.31292841f, -0.05360600f, 0.02931013f, 0.11984855f, 0.10888627f, 0.20980860f, 0.01800375f, 
    -0.04230626f, -0.09579315f, 0.10091320f, -0.08012706f, -0.28323665f, -0.13559447f, -0.03464422f, 0.17815705f, 
    -0.17698233f, 0.38540220f, 0.04740325f, 0.23576781f, -0.09458474f, 0.15365145f, -0.90730053f, -0.32447198f, 
    0.11599630f, -0.08537873f, -0.02114896f, 0.03044542f, -0.26473942f, 0.03688342f, 0.13174202f, -0.05768903f, 
    0.12536931f, -0.10532116f, 0.16717961f, -0.07526682f, -0.33700532f, 0.08066270f, 0.07422723f, -0.04103360f, 
    0.01134409f, 0.05096929f, 0.23756039f, 0.12925637f, -0.06604441f, -0.01215084f, 0.08528720f, 0.15296260f, 
    0.12612285f, -0.78775495f, 0.18870901f, 0.11296462f, 0.15778229f, 0.02032877f, 0.01313198f, 0.17529285f, 
    0.10373272f, 0.03754694f, -0.06932134f, -0.04828596f, 0.04137855f, -0.10340706f, -0.12629661f, 0.08402757f, 
    0.01800023f, -0.02957140f, 0.08809378f, 0.06697055f, -0.08924587f, 0.13068087f, -0.18170492f, -0.19961898f, 
    0.03145400f, 0.05418890f, 0.14169525f, -0.04351174f, -0.29165131f, 0.10981759f, 0.11438625f, 0.11441655f, 
    0.16329925f, -0.01257746f, 0.16541646f, 0.04709434f, -0.01393520f, -0.23286436f, -0.03400706f, 0.19875494f, 
    -0.05887462f, 0.14773726f, 0.14040419f, 0.01626225f, 0.23275788f, 0.15717711f, -0.10269765f, 0.19030409f, 
    0.39844131f, -0.11698761f, -0.13058731f, -0.16236576f, -0.04011126f, -0.23781170f, -0.06275696f, -0.26492733f, 
    -0.15796639f, 0.14661665f, -0.05502030f, -0.08944971f, -0.05670267f, -0.00928200f, -0.14216830f, -0.15150611f, 
    -0.02208067f, 0.01093809f, -0.14060548f, -0.09141614f, -0.04098983f, 0.00041748f, 0.07945745f, -0.16394611f, 
    0.15522169f, -0.05298919f, -0.02441601f, -0.07211914f, -0.00855310f, 0.03949714f, -0.01568322f, -0.02958922f, 
    -0.07161113f, 0.07843981f, 0.12675004f, -0.04448164f, 0.17691381f, -0.10977519f, -0.10252750f, 0.07180504f, 
    0.15421726f, 0.10763598f, -0.14414631f, -0.29137892f, 0.00782778f, 0.10080846f, -0.15321743f, -0.01019256f, 
    -0.08976284f, -0.02396889f, 0.00010295f, -0.03045142f, -0.09773752f, 0.16037022f, -0.02981827f, 0.05884955f, 
    -0.03923960f, -0.07707016f, 0.14057349f, -0.01105260f, -0.10760839f, -0.08203954f, 0.02634060f, 0.00155686f, 
    0.00035281f, 0.04225735f, 0.06096741f, 0.04778287f, 0.05647996f, 0.02385786f, 0.02824808f, -0.31355074f, 
    -0.26202780f, 0.00951993f, 0.06088311f, -0.05174636f, 0.10228709f, -0.07414856f, 0.08934698f, -0.02286774f, 
    0.04417318f, 0.00228406f, -0.06616195f, -0.09508526f, 0.11770347f, 0.16084512f, 0.10307786f, -0.12181032f, 
    0.02082562f, -0.03940639f, -0.03451182f, 0.02577932f, -0.37600052f, -0.20614500f, -0.18306097f, 0.05661345f, 
    -0.31297395f, 0.05973477f, 0.01549392f, -0.06004239f, -0.03415293f, -0.08398917f, -0.11880624f, 0.04965926f, 
    0.04222140f, -0.01799866f, -0.26246291f, 0.03284349f, -0.08521140f, 0.18076073f, -0.15319815f, -0.07575858f, 
    -0.02058146f, 0.09009361f, -0.05740907f, -0.04147549f, 0.07559717f, 0.01398106f, -0.07594958f, 0.06412490f, 
    -0.01367248f, -0.12293687f, 0.05390225f, -0.30058178f, -0.03172551f, 0.23134623f, 0.08103716f, -0.02381711f, 
    0.10131815f, -0.02846258f, 0.02161753f, 0.04946622f, -0.09949153f, -0.11244261f, -0.01125616f, 0.00625439f, 
    0.07674562f, 0.02173502f, -0.02304957f, -0.04065130f, -0.22650875f, -0.16976601f, -0.01177838f, 0.03299649f, 
    -0.17608418f, 0.10022825f, -0.35866246f, -0.08831442f, -0.06487346f, 0.03873625f, -0.15703692f, 0.12070550f, 
    0.35074729f, 0.00189433f, 0.12797268f, -0.02663628f, 0.09645008f, -0.10853991f, -0.08634067f, -0.29386380f, 
    -0.20703542f, -0.06310463f, -0.14477244f, 0.08720293f, 0.10587706f, 0.02531621f, -0.02340241f, -0.04357764f, 
    0.13687935f, 0.32951218f, 0.06893316f, 0.08264200f, -0.01894034f, -0.21881260f, -0.01884454f, 0.18547089f, 
    0.11074986f, 0.00697162f, -0.08127885f, -0.10286680f, -0.14274283f, -0.00395142f, 0.01586455f, -0.09914359f, 
    0.08171951f, 0.11978699f, -0.09324591f, -0.02136501f, -0.07256955f, 0.05204822f, -0.00490017f, 0.11994153f, 
    0.01109716f, 0.22186345f, 0.01249957f, 0.03822147f, 0.13784045f, 0.10024116f, 0.01200257f, -0.05960546f, 
    -0.15692773f, 0.04436133f, 0.07404777f, -0.16874489f, -0.30761719f, -0.43286765f, -0.14279890f, 0.03326148f, 
    0.24122523f, 0.23945595f, 0.02232656f, 0.03137293f, 0.04219944f, 0.08688684f, 0.12240922f, -0.22448583f, 
    -0.34187245f, -0.10780483f, 0.01959497f, 0.22468695f, -0.06060095f, -0.09337538f, -0.11628348f, 0.08556834f, 
    -0.00875947f, -0.21262325f, 0.22795469f, -0.16082703f, -0.16117099f, 0.15638165f, -0.09391791f, 0.16416661f, 
    0.09094454f, -0.07443202f, -0.01225892f, -0.10098054f, -0.17067286f, -0.09169289f, 0.20702267f, 0.07152972f, 
    0.18762355f, 0.00747643f, -0.33426735f, 0.19736707f, 0.04874200f, -0.15261212f, 0.00765700f, 0.04520040f, 
    -0.06242370f, 0.10007199f, 0.17466737f, -0.19483411f, -0.09900024f, 0.16738006f, -0.00657577f, 0.20851901f, 
    0.06425726f, 0.02781923f, 0.07873013f, -0.09307842f, -0.19380738f, 0.00127600f, -0.22717229f, -0.20085517f, 
    -0.13155776f, 0.20140025f, 0.01987391f, 0.01502174f, 0.08589332f, 0.12396532f, 0.12995853f, 0.09696156f, 
    0.08362295f, 0.05530564f, 0.06108246f, -0.12968479f, 0.06109859f, -0.05801530f, -0.18316925f, 0.09811920f, 
    -0.15529008f, 0.01356378f, 0.13604337f, -0.11746874f, 0.00580267f, -0.08252402f, -0.05705662f, 0.15669611f, 
    0.10982315f, -0.23356214f, -0.27141705f, -0.14412493f, -0.10246394f, -0.13537687f, -0.25809243f, 0.07860196f, 
    0.15485452f, 0.18636757f, 0.04205618f, 0.08037442f, 0.10396180f, -0.13374986f, -0.21486200f, -0.29858688f, 
    0.05139683f, -0.01607816f, -0.00444358f, 0.03003031f, 0.01926657f, 0.03768705f, -0.04984133f, 0.01332165f, 
    0.00507612f, 0.02405553f, 0.00728440f, 0.01364426f, -0.01289097f, -0.05651769f, -0.00558709f, 0.05304517f, 
    -0.01449410f, 0.05093246f, 0.01637798f, 0.01282428f, -0.02812275f, -0.05098944f, -0.06012921f, -0.06082967f, 
    0.01284355f, 0.01044906f, -0.01962419f, -0.02445024f, -0.00344422f, -0.04712940f, -0.06725253f, -0.02592188f, 
    -0.01358158f, -0.03341561f, 0.00749341f, -0.04686153f, -0.03678879f, 0.01173577f, -0.01004704f, 0.03885772f, 
    0.03335942f, -0.05277585f, 0.01533350f, -0.04342452f, -0.01876154f, 0.00184389f, 0.03961275f, -0.03290799f, 
    -0.05197988f, 0.02350426f, 0.03905480f, -0.05866858f, 0.02336399f, 0.03372566f, 0.01831779f, -0.01889614f, 
    0.04279103f, 0.02134073f, 0.00615348f, 0.02393611f, 0.01911653f, -0.00916575f, 0.01766607f, -0.04768717f, 
    0.03724506f, 0.00806874f, -0.01313651f, 0.01879213f, 0.01897174f, 0.03612624f, -0.03855880f, -0.01425384f, 
    0.03061634f, 0.02037340f, -0.04785163f, -0.00978781f, -0.01188881f, -0.02732675f, 0.02122758f, 0.01161432f, 
    -0.04712722f, -0.05566309f, 0.01075526f, -0.00967380f, -0.02553435f, -0.01652025f, -0.03739732f, 0.01111011f, 
    0.02892685f, -0.02479604f, 0.05113027f, -0.04681177f, -0.04230934f, -0.04638254f, 0.04207860f, -0.00319662f, 
    -0.02269597f, 0.05006194f, -0.02848533f, 0.00705541f, 0.00846898f, 0.00879054f, -0.01206001f, 0.01590710f, 
    -0.05418451f, 0.00294521f, 0.03689312f, -0.01324574f, -0.06724838f, -0.01596734f, 0.00161188f, -0.05411068f, 
    0.00082317f, 0.02101828f, -0.05664380f, 0.04693901f, -0.03212209f, 0.03959396f, -0.01492642f, -0.06331255f, 
    -0.02532759f, 0.02027312f, 0.03151928f, -0.01022022f, -0.06611565f, 0.01591338f, 0.00729428f, -0.02498366f, 
    -0.03742480f, 0.00315780f, -0.04574970f, -0.05764850f, 0.02119924f, -0.04795210f, 0.03535428f, -0.06357831f, 
    -0.07061180f, -0.05985376f, -0.06338890f, -0.03876730f, -0.05002620f, -0.03159513f, -0.05415028f, 0.03350410f, 
    0.04858479f, 0.01250252f, 0.04053780f, -0.00035796f, -0.03796702f, -0.02754031f, -0.03443646f, 0.00454320f, 
    -0.04048814f, 0.03343827f, -0.03023267f, 0.02543633f, 0.04887627f, -0.02998840f, -0.00879089f, 0.00402531f, 
    -0.04728532f, -0.01559149f, -0.03270984f, 0.04808237f, -0.01382534f, -0.01290669f, 0.03949058f, -0.05192411f, 
    0.02771397f, -0.06357485f, -0.02781348f, 0.03237428f, 0.02688101f, -0.02948109f, -0.00935784f, -0.06664692f, 
    -0.01313280f, -0.05273248f, -0.02905709f, 0.00797572f, -0.04854135f, -0.02480071f, -0.06950214f, -0.02721803f, 
    -0.05486061f, -0.06825936f, 0.00798324f, -0.03045128f, 0.03240424f, -0.05476674f, 0.02733718f, -0.02705633f, 
    0.00093898f, -0.00417472f, 0.01252739f, -0.01310988f, 0.03127630f, -0.02862887f, 0.01623307f, 0.02959976f, 
    0.04241283f, -0.04039362f, -0.01346263f, -0.01685800f, -0.04059929f, -0.01150455f, -0.04872902f, 0.00756402f, 
    -0.04903316f, -0.03787502f, -0.02291863f, -0.00287511f, -0.03054258f, -0.02236684f, -0.05463033f, 0.02127030f, 
    0.05290993f, -0.06537785f, 0.04864402f, 0.04280145f, -0.02543848f, 0.00117998f, -0.04221380f, -0.00716614f, 
    -0.01487587f, -0.00762292f, 0.03505462f, 0.04637530f, 0.01971125f, -0.00168399f, -0.02763503f, -0.06184456f, 
    -0.05380548f, 0.02225584f, 0.02201064f, -0.02292448f, 0.04764933f, 0.00963866f, 0.01414458f, 0.04432719f, 
    -0.01133500f, 0.04046083f, -0.00582439f, -0.01553126f, 0.02465202f, 0.02011346f, -0.04654191f, 0.03297190f, 
    -0.01649850f, -0.00751947f, -0.03811136f, 0.00080146f, 0.03579131f, 0.02355571f, 0.02392439f, -0.01314455f, 
    0.00142713f, -0.01222731f, -0.04033708f, 0.00406072f, -0.04680577f, 0.02014364f, 0.02218207f, 0.03147101f, 
    0.02776827f, 0.00941471f, -0.01167246f, -0.03972571f, 0.03099070f, -0.05162401f, 0.04630809f, -0.05129323f, 
    0.03585072f, -0.04976537f, -0.04105753f, -0.05078469f, 0.05229496f, -0.02776014f, -0.04651784f, 0.01883122f, 
    0.01646644f, 0.00082923f, 0.01785177f, 0.02275765f, -0.03508754f, 0.00011263f, -0.00743846f, 0.04077712f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.04921089f, 0.12172636f, 0.01278694f, -0.00119295f, -0.03896198f, -0.00898187f, 0.04191868f, -0.02441667f, 
    0.02189174f, 0.28789827f, 0.12033739f, -0.03732208f, 0.13944009f, -0.05235200f, 0.21016294f, -0.00306622f, 
    0.08065514f, -0.05507499f, 0.06594803f, 0.13490513f, 0.03882852f, 0.11220209f, 0.06111452f, 0.02717291f, 
    0.04379491f, -0.03518169f, -0.01224456f, -0.00586858f, 0.22086149f, 0.09258677f, 0.15913674f, 0.04737342f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05114206f, -0.41602871f, 0.02130091f, 0.22209090f, -0.10250355f, 0.13967790f, -0.06367086f, -0.05657336f, 
    0.34828222f, 0.14935398f, 0.05253401f, -0.02548072f, -0.14330962f, -0.15921851f, 0.20576905f, -0.03902261f, 
    -0.02523479f, -0.05291622f, -0.00491551f, -0.11433958f, -0.07305789f, -0.01355064f, -0.00941255f, 0.33659139f, 
    -0.00148699f, 0.30804825f, -0.31953835f, -0.06192977f, 0.43181092f, -0.03769297f, 0.17167635f, 0.00225328f, 
    0.00100810f, 0.09831323f, -0.05514413f, -0.06520261f, -0.08918160f, -0.13509557f, 0.01082102f, -0.14364110f, 
    -0.14860861f, -0.08731120f, -0.09141506f, -0.16374868f, -0.04181125f, -0.08015898f, 0.13170280f, 0.05077340f, 
    0.17513593f, 0.13759728f, -0.08489123f, -0.16600567f, -0.14890888f, -0.10317849f, -0.01175394f, 0.03682695f, 
    -0.06163670f, -0.10837759f, 0.16992478f, 0.16106136f, -0.06063098f, -0.16007291f, -0.10966092f, 0.06100228f, 
    0.02764976f, -0.31878066f, -0.00325097f, -0.41060784f, -0.16362929f, -0.12669976f, 0.06024377f, 0.16682917f, 
    0.25861770f, 0.12151346f, -0.15527317f, -0.11057945f, 0.40675625f, -0.13127352f, 0.28900030f, -0.47953698f, 
    -0.17772365f, -0.11625481f, 0.21621023f, 0.24520071f, -0.17798659f, 0.33394608f, 0.18725596f, 0.19347818f, 
    0.21620204f, 0.24254017f, -0.19271445f, 0.11054119f, 0.07718908f, 0.16859633f, 0.02798775f, 0.10327766f, 
    -0.15810841f, 0.04700056f, -0.08333854f, -0.13663688f, -0.12194138f, 0.14079838f, -0.16936973f, 0.01389539f, 
    0.03057997f, -0.17199530f, -0.01624638f, -0.18108127f, -0.06842235f, 0.02070671f, -0.20530224f, -0.10824046f, 
    0.08350868f, 0.06938285f, -0.03940197f, 0.02072312f, 0.17388177f, 0.11586222f, -0.06821176f, -0.16681013f, 
    -0.22149174f, -0.15826008f, 0.11851452f, 0.16410355f, -0.17239964f, -0.10462424f, -0.07606663f, -0.04082715f, 
    -0.06160382f, -0.09346214f, 0.20604929f, 0.14131862f, 0.36036074f, -0.13701232f, 0.14952913f, 0.06869660f, 
    0.14133456f, -0.29542685f, 0.36739036f, -0.01435041f, -0.29359293f, 0.00653026f, -0.18125229f, 0.71213645f, 
    0.57198703f, -0.07719954f, -0.16808091f, -0.34552243f, -0.16894299f, -0.00694057f, -0.02697149f, 0.02969384f, 
    0.25610858f, 0.11660279f, 0.03544226f, 0.14724849f, -0.03588446f, 0.42682588f, 0.18751207f, 0.01343905f, 
    -0.17252517f, -0.07361799f, 0.15881357f, -0.78202569f, -0.03800246f, 0.15089093f, -0.00028781f, 0.05086666f, 
    0.07030812f, 0.34638289f, 0.20542043f, -0.28168035f, -0.09982358f, 0.27244958f, -0.03436687f, 0.62442613f, 
    -0.00450943f, -0.11996946f, -0.00832468f, 0.03714676f, -0.07603013f, -0.00466551f, -0.31223118f, -0.29283407f, 
    0.02984818f, -0.64738202f, -0.04617256f, -0.16548684f, 0.18308873f, 0.44159478f, 0.48508379f, 0.01044945f, 
    0.13434933f, 0.40118656f, -0.07589492f, 0.18569976f, 0.17707224f, -0.07248943f, -0.08330308f, 0.05951041f, 
    -0.05300525f, 0.24942493f, 0.13736340f, -0.22983910f, -0.14666304f, 0.08363017f, -0.10147380f, 0.55702668f, 
    0.42792457f, 0.18040243f, -0.04920604f, -0.02276413f, 0.00166925f, 0.12452815f, -0.09187748f, -0.67509770f, 
    0.22267060f, -0.15704004f, 0.13333465f, 0.15133567f, -0.14674932f, -0.03894919f, 0.01443139f, 0.03758604f, 
    -0.12424251f, -0.01086100f, 0.10749885f, 0.04292062f, 0.13613364f, -0.10346200f, 0.15111898f, 0.05038496f, 
    -0.11425135f, -0.18142278f, -0.07156212f, -0.18269366f, 0.05931102f, -0.05523356f, 0.10175125f, -0.06476507f, 
    -0.03033188f, 0.16794452f, -0.03352125f, -0.08479495f, 0.16851863f, 0.00380602f, -0.02685775f, -0.01481083f, 
    -0.03539937f, -0.08933698f, -0.08149513f, -0.08865188f, 0.15247397f, 0.06431925f, -0.03942303f, 0.10050929f, 
    -0.01214631f, 0.34808958f, 0.17255785f, 0.02576343f, 0.19051223f, 0.17942594f, 0.01227888f, 0.14198266f, 
    0.00918818f, 0.24227488f, 0.19331279f, 0.20442170f, 0.42803472f, 0.13542740f, 0.16467069f, -0.31549159f, 
    -0.15207879f, -0.06433991f, -0.17170605f, -0.11769364f, -0.15904570f, -0.07788036f, 0.04850508f, -0.65959054f, 
    -0.02377693f, -0.34947363f, 0.30620831f, -0.10227315f, -0.31458110f, -0.19071627f, -0.03608784f, 0.05047151f, 
    0.06015277f, -0.10031862f, 0.34180939f, -0.59601212f, 0.00455180f, 0.09284920f, 0.18324547f, 0.04564202f, 
    -0.18591121f, 0.27849656f, 0.10029621f, -0.00422494f, 0.73713392f, -0.23530601f, 0.35123712f, -0.18089311f, 
    0.05594237f, -0.02537350f, -0.23215190f, 0.25356722f, 0.05644679f, 0.40097344f, -0.26536638f, -0.76747382f, 
    -0.21308307f, 0.40243036f, 0.05060499f, -0.05223116f, 0.18058644f, 0.40249783f, 0.17656147f, 0.06072995f, 
    0.16420668f, -0.24661045f, 0.07011523f, 0.12818874f, -0.17632219f, 0.00024255f, 0.09664603f, 0.01064958f, 
    -0.10029206f, 0.11335452f, 0.13737205f, 0.12633085f, 0.22651349f, -0.21234857f, 0.19522664f, -0.16587178f, 
    -0.03749641f, 0.06652781f, 0.33548686f, -0.10936508f, -0.14526215f, 0.02825232f, 0.08853419f, 0.18000086f, 
    -0.17404917f, 0.33669364f, -0.05322027f, 0.13111573f, -0.02971706f, 0.27023354f, -0.16906337f, 0.15291043f, 
    0.08167053f, -0.29950246f, 0.09894234f, -0.40084049f, 0.07504389f, 0.02232093f, 0.15306738f, 0.05668050f, 
    0.33383018f, -0.09663817f, 0.29362252f, -0.11794733f, 0.05453637f, -0.00448630f, 0.26444158f, -0.03404616f, 
    0.33263811f, -0.02282093f, -0.02414104f, 0.11700971f, -0.10697131f, 0.26005828f, 0.01445869f, 0.61096776f, 
    0.07107282f, 0.37795129f, 0.00791642f, 0.16564323f, 0.27298325f, 0.59593678f, 0.29141343f, 0.15892096f, 
    -0.08965385f, 0.70197922f, 0.29967895f, -0.19254918f, -0.33141106f, -0.17947412f, -0.09527286f, -0.10021149f, 
    -0.27982789f, -0.03719470f, 0.28452489f, 0.23016235f, -0.15646712f, 0.09796084f, -0.09414285f, 0.01099483f, 
    0.48721853f, 0.15356556f, 0.18850873f, -0.24693617f, 0.05368257f, 0.00950018f, -0.38330224f, 0.10611960f, 
    0.00108711f, -0.42052647f, 0.33123398f, 0.08112752f, -0.15994892f, 0.32464567f, 0.15561146f, 0.04446236f, 
    -0.12417615f, 0.30513260f, 0.04511411f, -0.17223828f, -0.33133939f, -0.07901441f, -0.14121896f, -0.12641899f, 
    -0.24403277f, 0.34626049f, 0.28376159f, 0.25453064f, 0.27155811f, -0.15501814f, 0.21819501f, -0.53721327f, 
    -0.09171334f, 0.12366325f, 0.33079743f, 0.02433240f, 0.02036917f, 0.12723538f, 0.12802328f, -0.54363835f, 
    -0.26241568f, 0.28600350f, 0.01664493f, -0.14428294f, 0.08189718f, -0.25161195f, -0.26398423f, 0.15868483f, 
    -0.15208408f, -0.50224495f, -0.29751998f, -0.20020761f, 0.35779783f, 0.14837965f, 0.04823494f, -0.02171942f, 
    0.14096184f, 0.32084584f, 0.02325747f, -0.20547421f, -0.14955677f, 0.23924819f, 0.07326649f, 0.56920969f, 
    0.00880478f, 0.03014816f, -0.37944996f, -0.01581497f, 0.02864851f, 0.20487002f, -0.02652173f, 0.25806418f, 
    0.47242251f, -0.49309170f, -0.16218750f, -0.04939037f, 0.26122960f, 0.17139655f, 0.36918053f, 0.05672967f, 
    -0.16229710f, 0.61522436f, 0.04034169f, 0.19233604f, -0.05263961f, -0.12185702f, -0.14940302f, 0.06217813f, 
    -0.60698634f, 0.20944232f, 0.29295456f, -0.19832470f, -0.16520350f, -0.31349728f, 0.04645259f, 0.22077401f, 
    0.43275338f, 0.11381228f, -0.27290508f, 0.05885280f, 0.14593156f, -0.00594319f, -0.06506748f, -0.54196626f, 
    0.13080214f, -0.20977922f, 0.34454417f, 0.08972920f, 0.24979325f, 0.27370772f, -0.16454405f, -0.02490060f, 
    0.04880480f, 0.15500376f, -0.17023245f, -0.05642591f, -0.08511678f, 0.16104268f, 0.03748509f, -0.01209050f, 
    0.12131377f, -0.20819724f, -0.05609872f, 0.04489027f, -0.15077734f, -0.08416958f, -0.00411166f, -0.08362985f, 
    -0.17417206f, -0.12106819f, -0.10704039f, -0.19397897f, -0.01680648f, -0.00868360f, -0.07788932f, 0.11472866f, 
    -0.17702553f, -0.03197728f, -0.06003281f, -0.17149349f, 0.05025820f, -0.13177198f, -0.00294320f, 0.15789776f, 
    -0.13980614f, -0.07198530f, -0.07762621f, 0.02718340f, -0.24392076f, 0.15510212f, 0.10533810f, -0.12055551f, 
    -0.37245217f, 0.04295343f, 0.17345177f, -0.10268457f, -0.29833198f, -0.38760397f, 0.17771254f, -0.49315161f, 
    -0.23421307f, -0.04637912f, 0.04481684f, 0.34015876f, 0.06245755f, 0.00657672f, 0.10579739f, 0.27702326f, 
    0.06712322f, 0.18724743f, 0.24578565f, 0.12745540f, 0.36401492f, 0.28267014f, 0.18954769f, 0.10339691f, 
    -0.14591099f, -0.26871553f, 0.01214859f, 0.32238477f, -0.42271227f, -0.16619508f, 0.15968534f, 0.08871318f, 
    0.31584105f, 0.11455517f, 0.20253542f, 0.12085401f, -0.01322345f, -0.16871491f, 0.15382087f, -0.41965625f, 
    -0.20263921f, -0.12026831f, 0.00308179f, -0.45893371f, 0.06011776f, -0.19813810f, 0.04260337f, 0.69929701f, 
    0.36334988f, -0.12792924f, 0.11141465f, -0.07499981f, -0.15668258f, -0.02791037f, 0.18930414f, 0.12170032f, 
    0.01624073f, 0.21309747f, -0.00557714f, -0.40274999f, 0.06708807f, 0.14799805f, -0.09544260f, 0.15274951f, 
    0.39618623f, -0.09045774f, -0.04746336f, 0.14503264f, -0.16836843f, 0.29526472f, -0.08869053f, 0.36490166f, 
    0.41120434f, -0.07118882f, -0.12513389f, -0.06875734f, 0.15827703f, 0.15400901f, -0.41661328f, 0.53587586f, 
    0.41627440f, -0.60272145f, 0.14183210f, 0.15647733f, 0.29779264f, -0.03733361f, 0.27106851f, 0.06287586f, 
    -0.12500846f, -0.15541840f, 0.00071624f, -0.13650914f, -0.03142891f, 0.15788718f, 0.16535296f, 0.04481363f, 
    -0.15809016f, 0.04883021f, -0.16784328f, 0.00551040f, 0.15990035f, -0.03555302f, -0.04818393f, -0.01947121f, 
    -0.02513989f, -0.15233186f, -0.07788305f, -0.02549708f, -0.16833223f, -0.12648875f, 0.02911314f, 0.06937380f, 
    -0.00819346f, -0.09321664f, -0.00148723f, 0.03963327f, -0.06110338f, 0.03936155f, -0.04572719f, 0.05704835f, 
    -0.16896516f, -0.42058212f, 0.07900766f, 0.12074087f, -0.12808247f, -0.02442153f, -0.07829797f, -0.02287225f, 
    0.18134941f, -0.03962969f, 0.24581927f, 0.28555557f, 0.73145229f, -0.01391765f, 0.53124666f, -0.66712666f, 
    -0.18819100f, -0.15656917f, -0.29806811f, -0.14303663f, -0.06929338f, -0.02206968f, 0.23803107f, 0.03244436f, 
    0.27365243f, 0.06536812f, -0.11887927f, -0.05914132f, 0.15554635f, -0.18251185f, 0.15319939f, 0.10602695f, 
    -0.12499354f, -0.04067399f, -0.06237903f, 0.08003161f, 0.04940188f, -0.11336828f, 0.10693800f, 0.03969298f, 
    -0.18290101f, -0.03431150f, -0.07393306f, -0.05532210f, -0.12767799f, 0.07521359f, -0.08174089f, 0.12653853f, 
    0.06270083f, 0.16495267f, -0.17029278f, -0.09323187f, -0.14600271f, -0.21614285f, 0.05965674f, 0.11410568f, 
    -0.17764699f, -0.13927642f, -0.17587471f, -0.07073665f, 0.10362627f, -0.18638439f, -0.12158427f, 0.17569278f, 
    -0.03473440f, 0.12638526f, -0.10729650f, -0.05437610f, 0.29470733f, -0.16899505f, -0.14983913f, -0.08373388f, 
    -0.08297581f, -0.24054115f, -0.07809231f, 0.07150990f, -0.40310475f, 0.10535213f, 0.10772429f, 0.13127463f, 
    0.39233947f, 0.12425499f, 0.21255849f, -0.15955120f, 0.16495506f, -0.11863688f, 0.22121015f, -0.09742206f, 
    0.24754088f, 0.20023905f, -0.04128452f, -0.03581293f, -0.43634307f, 0.16264780f, -0.02432142f, 0.16637769f, 
    -0.05341173f, 0.00797244f, 0.17307977f, 0.46051487f, -0.25675407f, -0.08266887f, 0.05601280f, -0.07532213f, 
    0.19635014f, -0.08309004f, 0.24584481f, 0.55142421f, 0.19593349f, -0.13528101f, 0.04732896f, 0.06466296f, 
    0.25495285f, -0.17250100f, -0.07509641f, -0.68160844f, -0.10901591f, 0.13181658f, -0.48129693f, -0.03318941f, 
    -0.02909123f, -0.25469163f, 0.32558811f, 0.07043829f, -0.35927913f, -0.22383611f, 0.20173337f, -0.00367024f, 
    -0.16669111f, -0.12187146f, -0.11682449f, -0.17368980f, -0.08161446f, 0.17373405f, -0.18265635f, 0.16816093f, 
    -0.13891868f, 0.07452071f, -0.06511304f, -0.19088177f, -0.06148217f, -0.06942908f, 0.00522985f, -0.16099285f, 
    -0.10838664f, -0.02444894f, -0.16555135f, -0.12451326f, 0.10026969f, 0.05495436f, 0.09596087f, -0.12856427f, 
    0.01449670f, 0.03687645f, 0.08406883f, -0.04892679f, 0.00023108f, -0.19145137f, -0.08495549f, 0.04516520f, 
    0.16253866f, 0.10998189f, 0.40267399f, -0.56278723f, -0.43962958f, 0.04877802f, -0.07808200f, 0.08510535f, 
    -0.11575917f, 0.25390553f, 0.33612946f, -0.21649498f, -0.15597020f, -0.22042073f, 0.02193417f, -0.35609484f, 
    -0.17924953f, 0.06772171f, 0.26171225f, 0.03462086f, 0.11151224f, -0.15377903f, -0.05108282f, 0.04476323f, 
    -0.14164717f, 0.16498949f, -0.09039070f, 0.10210498f, 0.27008915f, 0.41723311f, -0.04709831f, -0.05640915f, 
    -0.04566885f, -0.05889608f, -0.38212937f, 0.05118927f, 0.14365305f, -0.05639255f, 0.03377815f, 0.02936610f, 
    0.32073516f, 0.24312930f, -0.21766993f, -0.14495206f, -0.03317325f, 0.36248901f, -0.20948121f, 0.46379286f, 
    -0.35784903f, 0.05376812f, -0.18085347f, 0.04757366f, -0.00826111f, 0.05629252f, 0.32527941f, 0.27359033f, 
    0.28288892f, -0.25211197f, -0.07694337f, 0.16594848f, 0.21781860f, -0.10692588f, 0.15287945f, 0.00733071f, 
    -0.00563345f, -0.13382165f, 0.03479724f, -0.15111516f, -0.03001576f, -0.00543471f, 0.07465446f, 0.16191080f, 
    -0.08628347f, -0.08978935f, 0.08512363f, -0.16347094f, -0.17033355f, 0.07193580f, -0.07486488f, -0.04848085f, 
    0.13142188f, 0.07410577f, 0.14033438f, 0.05068395f, 0.08405650f, -0.11527989f, -0.05935344f, -0.02823253f, 
    0.04177050f, -0.15195329f, -0.13097014f, -0.09380826f, -0.06045736f, 0.11633594f, -0.13006185f, 0.00294499f, 
    -0.01490390f, 0.12002086f, -0.20000744f, -0.03299963f, -0.19677508f, -0.03821556f, 0.14433251f, -0.11187872f, 
    -0.20585276f, 0.07657523f, 0.10220487f, -0.03523295f, -0.06294455f, 0.08035067f, 0.01715872f, -0.06341100f, 
    -0.02740686f, -0.03441712f, -0.11956777f, -0.11405724f, -0.13197312f, -0.14299975f, -0.02100830f, -0.11901361f, 
    -0.07074175f, -0.17146300f, -0.06891768f, 0.07812824f, -0.13714871f, -0.04945179f, -0.12640624f, 0.08631472f, 
    0.09277401f, 0.61382258f, 0.20302184f, -0.12004607f, -0.05044199f, -0.04554101f, 0.11925903f, -0.12204586f, 
    0.05112483f, -0.05023979f, 0.34176168f, -0.22591142f, 0.62703693f, -0.14600390f, 0.18066165f, -0.42311871f, 
    0.09252661f, 0.02113149f, 0.12475572f, 0.31821293f, -0.11373798f, 0.33184713f, -0.14716640f, 0.10528731f, 
    -0.54456377f, -0.16391550f, 0.29640663f, 0.08467469f, -0.10137108f, 0.28242722f, 0.08196681f, -0.16171591f, 
    0.08713443f, -0.15208748f, -0.04155558f, 0.08987150f, -0.01955881f, 0.12929752f, 0.11931440f, -0.11775269f, 
    0.17857760f, -0.28764388f, -0.11298770f, -0.09650843f, -0.21202919f, 0.04068040f, -0.21524897f, 0.05098151f, 
    0.05173229f, 0.00110564f, -0.23115303f, -0.00448291f, 0.10895412f, 0.01675712f, 0.10185289f, -0.03252574f, 
    -0.05871424f, -0.02238772f, 0.11535290f, 0.10640113f, -0.01861391f, -0.12027310f, -0.14920457f, 0.07054927f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.21928382f, 0.09176058f, 0.03369231f, 0.01389709f, -0.19539529f, 0.19747645f, -0.14875714f, -0.04379867f, 
    0.04630058f, 0.24628648f, -0.02506126f, 0.28945485f, 0.22908585f, 0.05831299f, 0.29539907f, 0.08085897f, 
    0.13564107f, 0.46774089f, -0.16233549f, 0.24335837f, 0.02177991f, 0.25051957f, -0.05701279f, -0.15421934f, 
    -0.07452496f, 0.15281333f, -0.00503793f, 0.18180400f, -0.16666202f, -0.16098505f, -0.06265615f, 0.02516620f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.13845029f, -0.06266321f, 0.04309196f, 0.01137909f, 0.19534162f, -0.05429897f, -0.09369437f, -0.15166706f, 
    -0.00409314f, 0.41000250f, 0.15054709f, 0.14637971f, -0.19041957f, 0.12192277f, -0.19023782f, 0.12181524f, 
    0.13465767f, 0.01018311f, -0.65044028f, -0.15582696f, 0.13359667f, -0.04787260f, -0.15931956f, -0.25533545f, 
    -0.52072465f, -0.04669845f, 0.12839796f, -0.24497019f, -0.12892313f, 0.07088241f, 0.38418272f, 0.00448335f, 
    -0.24663511f, -0.07069038f, 0.18891461f, -0.10156033f, -0.05719033f, -0.34571341f, 0.16969720f, -0.10504881f, 
    -0.07307363f, -0.20236380f, 0.13003218f, 0.14314350f, -0.14363390f, 0.02795330f, -0.11227436f, 0.22998792f, 
    -0.13875484f, 0.21703616f, -0.25928497f, -0.18026675f, -0.02094342f, -0.24242115f, 0.13533810f, 0.07054946f, 
    -0.27796474f, -0.00990223f, 0.22844422f, -0.04877456f, -0.02330289f, 0.10498727f, -0.06726547f, -0.14121565f, 
    0.16367880f, -0.02632574f, -0.15246132f, 0.01380941f, 0.41229105f, -0.59325480f, 0.04719440f, -0.00754635f, 
    0.06357592f, -0.13558532f, 0.15876342f, -0.16413754f, -0.39626819f, 0.18694822f, 0.15719457f, 0.30722880f, 
    -0.07456557f, 0.19845998f, 0.27473956f, -0.51793706f, 0.05948374f, 0.36490560f, 0.06563444f, 0.05458726f, 
    0.34466946f, -0.04307608f, -0.53003895f, 0.11959781f, -0.03151855f, 0.09135536f, -0.17922659f, 0.04003137f, 
    0.25189498f, -0.11665615f, 0.36675802f, 0.11488657f, 0.14988570f, -0.27420866f, -0.40430868f, -0.03553207f, 
    -0.14672723f, 0.19691667f, 0.30089673f, 0.15300375f, -0.38136292f, 0.30324230f, -0.27724326f, -0.19741349f, 
    -0.01856589f, 0.01958945f, 0.25424910f, -0.33753616f, 0.10637812f, 0.20940076f, 0.04099255f, 0.13279383f, 
    0.42941511f, -0.11622766f, 0.24159430f, -0.19803621f, -0.02842472f, -0.04247127f, -0.29244372f, -0.14136772f, 
    0.26535273f, -0.10448485f, 0.47700718f, 0.06606801f, -0.28983420f, 0.01935257f, -0.12681732f, 0.11076777f, 
    -0.15056996f, 0.37000519f, -0.16420634f, 0.09941047f, -0.42172477f, 0.24108654f, 0.26589060f, -0.00820903f, 
    0.08616959f, 0.19890012f, -0.26218936f, -0.01591823f, -0.04504914f, 0.32845566f, 0.12995645f, -0.52868080f, 
    -0.82342237f, -0.13792017f, -0.08061584f, 0.02097706f, -0.10329019f, -0.02393344f, -0.18545337f, 0.08963812f, 
    0.09750028f, -0.03652157f, 0.13819370f, -0.20928860f, 0.51024199f, -0.48432964f, -0.07055563f, 0.07695041f, 
    0.07747682f, -0.16823514f, 0.15773791f, 0.27608675f, -0.14862379f, -0.07232745f, -0.13533376f, -0.07806956f, 
    0.09435367f, 0.14615324f, 0.00322146f, -0.17726670f, 0.12678851f, -0.12367570f, 0.08354620f, 0.41709381f, 
    0.05190593f, 0.04379198f, 0.06242928f, -0.13197292f, 0.00597815f, 0.14963116f, -0.24317704f, -0.00216335f, 
    0.12601292f, 0.04783651f, 0.08065073f, 0.13959385f, -0.35777244f, 0.06097123f, 0.22255148f, -0.08751282f, 
    0.09669602f, -0.10674831f, -0.05212075f, -0.04716650f, -0.15044659f, 0.25230899f, -0.06248583f, 0.39844900f, 
    -0.03130083f, 0.27786750f, -0.08552101f, 0.19746773f, 0.07847533f, -0.03622971f, 0.22263618f, -0.27463022f, 
    -1.00825548f, -0.15862207f, 0.21602406f, 0.26633111f, -0.12059307f, 0.05669025f, 0.22252519f, 0.16541298f, 
    0.01336344f, -0.02668943f, -0.01144819f, 0.14445490f, 0.40808842f, 0.07965663f, 0.17008924f, 0.03187530f, 
    -0.41162255f, 0.07677317f, -0.09238331f, 0.17181303f, -0.00551878f, -0.31906790f, 0.31299379f, -0.00760014f, 
    0.08377615f, -0.19386531f, -0.26131734f, 0.34154239f, -0.02811041f, 0.05226065f, 0.03016096f, 0.06343259f, 
    0.17420696f, 0.11002146f, -0.52690721f, 0.07948235f, -0.13172171f, -0.10820188f, -0.15092745f, 0.21005802f, 
    -0.03968318f, -0.07866667f, 0.05958632f, 0.16625726f, 0.07776430f, -0.00427584f, -0.08279005f, -0.00908815f, 
    -0.08142159f, -0.15019794f, -0.11259279f, 0.15140805f, -0.26660541f, 0.06503575f, -0.18075618f, 0.13887218f, 
    -0.16827336f, -0.05810737f, -0.10530325f, -0.12011095f, 0.03403632f, -0.11412390f, -0.04254242f, -0.01892555f, 
    -0.18410519f, 0.13308202f, 0.04078593f, 0.03593268f, 0.11334931f, 0.02478924f, -0.11045603f, -0.12635286f, 
    0.07843159f, 0.16805284f, -0.40149510f, 0.07890855f, 0.38367230f, 0.40415749f, 0.36550561f, 0.02066118f, 
    -0.10528950f, 0.31649363f, -0.20466644f, -0.04371149f, 0.04437354f, -0.29715994f, 0.19476780f, 0.30977023f, 
    0.10290799f, -0.11110986f, -0.42457497f, 0.24256352f, 0.00130282f, -0.30351368f, -0.12366404f, 0.00454524f, 
    -0.05977805f, -0.11884012f, 0.29459772f, 0.08026277f, -0.16501518f, -0.13646719f, -0.02987255f, 0.00975273f, 
    0.06648910f, 0.10696092f, 0.12555653f, 0.01082746f, -0.00814546f, -0.54984528f, 0.21178769f, -0.02931483f, 
    -0.15639050f, -0.20584959f, -0.05313472f, 0.05387166f, 0.48818904f, 0.33474085f, -0.50853628f, 0.22705403f, 
    -0.13268439f, 0.27096111f, 0.14726152f, -0.01945328f, 0.12520318f, -0.08936580f, 0.14831223f, -0.10189897f, 
    -0.22948115f, -0.02809657f, 0.29450876f, -0.02965869f, -0.08178313f, 0.09806751f, 0.24278893f, 0.01031098f, 
    0.06291360f, 0.06465000f, -0.08825486f, -0.02504258f, -0.52165037f, 0.01615229f, -0.31229138f, -0.03653108f, 
    0.02645237f, -0.62363607f, 0.09948848f, -0.12488201f, -0.20583443f, 0.18651588f, -0.04188532f, -0.18909051f, 
    0.15521494f, 0.17851460f, 0.08556681f, 0.06141725f, -0.13992795f, 0.33499262f, 0.08511131f, 0.01570642f, 
    -0.36416793f, 0.15662532f, -0.34677705f, -0.15505652f, 0.01798516f, -0.11650620f, -0.09758925f, 0.11873762f, 
    0.25215331f, 0.06328271f, -0.02794801f, -0.16229278f, -0.02507981f, 0.04435908f, -0.01585728f, -0.00598562f, 
    0.24990995f, -0.01466846f, -0.06570758f, 0.14310047f, -0.09413443f, 0.02431932f, -0.03083820f, -0.30237621f, 
    -0.06740692f, -0.24342155f, 0.70543915f, 0.30314025f, 0.12058856f, 0.44929892f, -0.10206747f, 0.00209746f, 
    0.43283644f, -0.00901371f, 0.03939246f, 0.00094783f, -0.08889428f, -0.17198704f, 0.28497362f, 0.05375253f, 
    -0.03423525f, -0.12181078f, -0.13410711f, 0.02599830f, 0.05256401f, -0.10537502f, -0.15988082f, -0.03812964f, 
    -0.13565572f, -0.00520385f, -0.14757693f, 0.05522010f, -0.09361932f, -0.08445198f, -0.01795464f, 0.17453983f, 
    0.16391198f, 0.01217079f, 0.00542221f, -0.07334386f, -0.10506056f, 0.04558856f, -0.15706956f, -0.04136865f, 
    0.00260645f, -0.03366484f, -0.07762273f, -0.10176356f, 0.06437533f, -0.01338896f, -0.02617722f, -0.02426358f, 
    0.07510294f, 0.03210392f, 0.34765309f, -0.01875531f, -0.21802789f, 0.32477948f, -0.04334666f, 0.06097894f, 
    0.05132760f, 0.13090225f, 0.03479346f, -0.02975693f, -0.25729448f, 0.17158747f, -0.09061503f, -0.06636639f, 
    0.15087454f, 0.17485316f, -0.35427940f, -0.22742252f, -0.15866806f, 0.06376065f, 0.20107561f, -0.03969471f, 
    -0.73656183f, 0.17905807f, 0.53461844f, -0.15834701f, -0.01731776f, 0.05377603f, 0.14457287f, -0.15255331f, 
    -0.14221369f, 0.04586966f, 0.26523244f, -0.09838535f, -0.27703342f, 0.13097361f, 0.14838096f, 0.14989239f, 
    0.24002260f, 0.50781745f, 0.04371557f, 0.07809389f, 0.06943026f, 0.48123872f, -0.21385300f, 0.09980441f, 
    0.01772245f, -0.03319817f, -0.21330868f, -0.15120472f, 0.17335404f, 0.20972371f, 0.03152778f, -0.00576725f, 
    0.15296784f, -0.12561689f, 0.50260359f, -0.17693450f, 0.08050530f, -0.12777576f, 0.16493350f, -0.15823814f, 
    -0.26620340f, 0.15763479f, 0.02883917f, -0.09026141f, 0.04302285f, 0.16488867f, 0.24181598f, 0.10861853f, 
    0.04807961f, 0.40308648f, -0.06028230f, 0.25458118f, 0.13798773f, -0.02912242f, 0.25739664f, 0.35955128f, 
    0.14080900f, 0.34530431f, -0.44835028f, 0.04404405f, 0.07358382f, -0.06724668f, 0.13208517f, -0.04643814f, 
    -0.33543250f, 0.03725580f, 0.09062707f, -0.08587055f, -0.14597563f, 0.07415937f, 0.52146387f, -0.04141567f, 
    0.02972544f, 0.17841916f, -0.11498380f, 0.03180457f, -0.04234388f, -0.48654193f, 0.10214378f, 0.02362861f, 
    0.23369135f, -0.00887303f, 0.29206517f, -0.02421684f, 0.11818209f, 0.32776958f, -0.70746160f, 0.30736119f, 
    -0.17812784f, 0.11891562f, -0.17835335f, -0.13393094f, 0.05591488f, -0.01151657f, 0.03746024f, 0.04283269f, 
    0.31867456f, 0.10719710f, -0.16322707f, -0.35013133f, -0.01302456f, 0.00793956f, 0.11817966f, -0.19613437f, 
    -0.14544341f, 0.05889208f, -0.16178747f, 0.06133922f, 0.04700037f, 0.08731455f, -0.15541068f, -0.09833021f, 
    -0.10345003f, 0.23792577f, 0.01864675f, 0.02166115f, 0.72638696f, 0.27300802f, -0.33599782f, 0.23907579f, 
    0.04579165f, 0.08665349f, 0.16861819f, 0.23995443f, -0.10249360f, 0.03127264f, -0.09302594f, -0.20312908f, 
    0.65440464f, -0.13252659f, 0.68196064f, -0.75813234f, 0.08002363f, -0.20064574f, 0.33991936f, -0.12583098f, 
    0.32044670f, 0.09367950f, 0.30522814f, 0.06788395f, -0.14193690f, 0.02938829f, -0.24612673f, 0.01866525f, 
    -0.22689708f, 0.26243389f, 0.17361757f, 0.29585603f, -0.26116487f, -0.18920811f, 0.01694671f, -0.02952741f, 
    -0.09583286f, 0.13941042f, -0.00363071f, -0.00374532f, -0.04383300f, 0.41083819f, -0.13225940f, -0.40423670f, 
    -0.33515614f, -0.14803550f, 0.09172731f, 0.00966160f, -0.01851302f, -0.13722737f, 0.27326578f, 0.00747449f, 
    0.20159276f, 0.03692911f, -0.05537576f, -0.05205682f, -0.35631078f, 0.15063380f, -0.41186580f, -0.07161283f, 
    0.01359611f, -0.36022586f, -0.05839501f, -0.57164806f, 0.26004952f, 0.10530484f, -0.19243127f, -0.28948262f, 
    -0.10108388f, -0.11869217f, 0.18230899f, -0.08792555f, 0.16954373f, 0.29818591f, 0.00187701f, 0.11921143f, 
    0.03269086f, 0.07155313f, -0.23715559f, -0.06614260f, -0.08065642f, 0.13245288f, -0.39727309f, 0.04849292f, 
    0.05310877f, 0.09189753f, 0.06579507f, -0.14561020f, -0.10195242f, -0.09609186f, -0.13486776f, 0.02607609f, 
    -0.20789443f, -0.12117478f, -0.02876651f, -0.03003989f, 0.07108553f, -0.05935824f, -0.12144446f, -0.12317724f, 
    -0.02527485f, -0.19157162f, -0.06943082f, -0.17309365f, 0.11302653f, -0.09816496f, 0.06917676f, 0.05567690f, 
    -0.06713584f, -0.12656753f, -0.04429090f, -0.15419748f, -0.14313659f, -0.13673116f, 0.10500645f, -0.14523149f, 
    0.19776943f, 0.11489791f, 0.40090704f, 0.13931340f, 0.01433848f, -0.37398067f, -0.40743327f, 0.04381775f, 
    -0.14156686f, -0.00719609f, 0.07158136f, 0.31804532f, -0.43166336f, -0.10723044f, 0.28923264f, -0.22430988f, 
    -0.17564753f, 0.08645706f, 0.37083244f, 0.33923405f, 0.13674869f, 0.33319733f, -0.03747421f, 0.03180432f, 
    -0.02903354f, 0.00919623f, -0.59307975f, 0.17273645f, 0.08726050f, -0.04043849f, 0.21963388f, 0.04111710f, 
    -0.02658194f, 0.00105603f, -0.00650329f, -0.02272939f, 0.06611906f, -0.61823553f, 0.02035313f, 0.09665906f, 
    0.08295720f, 0.18896037f, 0.22029783f, 0.04330955f, -0.04165557f, 0.31703404f, -0.34529036f, 0.27027208f, 
    0.08016729f, 0.13209759f, 0.26902679f, -0.29927337f, -0.13496630f, 0.39398661f, -0.15157823f, -0.16003285f, 
    0.62029511f, 0.13698933f, -0.15064195f, -0.29597247f, -0.15713160f, -0.13067287f, -0.08593998f, -0.04918110f, 
    0.23447882f, -0.08831096f, -0.12512386f, -0.03926788f, 0.09309814f, 0.04120474f, 0.16287258f, -0.05010583f, 
    -0.90278751f, -0.25847152f, -0.29994124f, 0.18835770f, -0.25191131f, -0.60226768f, 0.42851239f, 0.14324833f, 
    -0.10237359f, 0.03865178f, -0.12315717f, 0.19312380f, 0.06550840f, -0.05236181f, 0.04186828f, -0.21233088f, 
    -0.26495326f, 0.09256522f, -0.07174864f, 0.32900614f, 0.01540027f, 0.12496468f, -0.22710325f, -0.02659252f, 
    -0.09688914f, -0.11176860f, -0.15354699f, 0.06765732f, -0.13238630f, 0.03527227f, 0.01938688f, -0.13119896f, 
    -0.12687525f, 0.05091929f, 0.06459735f, -0.10182712f, 0.12765928f, -0.19725744f, -0.16293497f, -0.17548612f, 
    -0.10332873f, -0.19345957f, 0.05339605f, -0.03499746f, -0.17416881f, -0.00634243f, 0.03294623f, 0.06465402f, 
    -0.08085683f, -0.16724730f, 0.14590433f, -0.10376899f, 0.08145787f, 0.02112088f, -0.02195431f, 0.03708259f, 
    0.00422879f, -0.15762217f, -0.39339784f, -0.04215888f, -0.01515517f, 0.08358143f, -0.03347267f, 0.07113216f, 
    0.19553620f, -0.19768284f, 0.05779120f, -0.25691092f, 0.03017686f, 0.10177147f, -0.24073419f, -0.46010047f, 
    -0.11232366f, -0.11667892f, 0.26387137f, -0.14268154f, -0.00852224f, 0.06906690f, -0.06172131f, 0.09559079f, 
    0.13465852f, -0.17660864f, -0.04508048f, 0.08927752f, 0.03564133f, -0.06884028f, -0.18237163f, 0.14867423f, 
    -0.06482084f, 0.08981349f, -0.05931231f, -0.10729136f, 0.64143735f, 0.20501761f, 0.21979707f, -0.09914053f, 
    -0.15027350f, 0.04300709f, -0.09799399f, 0.25961587f, 0.45994273f, -0.24521397f, -0.06045508f, 0.05063929f, 
    -0.13560952f, -0.12379976f, -0.43660855f, 0.30846760f, -0.00538661f, -0.07870188f, 0.10125704f, 0.31805649f, 
    0.37607539f, -0.06226395f, -0.37603307f, -0.30900651f, 0.14544989f, -0.11546049f, 0.04263475f, 0.15775442f, 
    0.29109269f, 0.11005887f, 0.27118170f, -0.02784793f, 0.07060046f, 0.11308270f, -0.24175856f, -0.06090026f, 
    -0.30823794f, 0.01017305f, 0.26807368f, 0.26504722f, 0.07778231f, 0.14895707f, -0.22528930f, -0.05689286f, 
    0.09577198f, 0.29807553f, 0.06103785f, 0.10669671f, 0.15380044f, 0.07748456f, 0.09702226f, 0.43702194f, 
    -0.40644926f, 0.04426024f, 0.90585423f, -0.18109284f, -0.14494090f, 0.14604487f, -0.08736452f, 0.01481249f, 
    0.33026037f, 0.07797004f, -0.10489225f, -0.10127384f, 0.80035311f, -0.60494334f, 0.30534849f, 0.02086296f, 
    0.00951908f, -0.12578562f, -0.05691621f, 0.08574379f, -0.08459606f, -0.19120501f, -0.11757962f, 0.25837252f, 
    -0.14749944f, 0.07466796f, 0.33513796f, -0.28997147f, -0.08865275f, 0.21985410f, -0.00198750f, -0.25408483f, 
    0.06540074f, -0.18972969f, 0.01845684f, -0.23774657f, -0.11006843f, 0.10459246f, -0.12236235f, -0.01694361f, 
    0.16045174f, -0.03197611f, -0.10172474f, 0.01398526f, 0.45235735f, 0.21106568f, 0.05043248f, 0.00351481f, 
    0.17611246f, -0.02796682f, -0.10216252f, 0.17052369f, 0.25184307f, -0.30932662f, 0.60646838f, 0.23615888f, 
    0.09185678f, 0.11636008f, 0.51053858f, 0.48569128f, -0.11552898f, 0.35901991f, 0.21608619f, -0.15789409f, 
    0.66354632f, 0.11179194f, -0.32603815f, 0.23265317f, 0.05046046f, -0.15247874f, -0.07335354f, -0.00947301f, 
    0.27415761f, 0.06039908f, 0.25807700f, 0.14892991f, 0.05252440f, 0.14592396f, -0.38941675f, -0.07856746f, 
    -0.65181702f, 0.05627884f, 0.22293380f, 0.15363623f, -0.01184883f, -0.27615112f, 0.14370105f, -0.05400381f, 
    0.14633217f, 0.25444576f, 0.14987552f, -0.03407117f, 0.09554984f, -0.02125186f, 0.09843051f, -0.05000450f, 
    -0.53012174f, -0.04227921f, 0.51274955f, 0.16583735f, -0.13199748f, -0.12037136f, 0.09466925f, -0.03866715f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.05898867f, -0.22143163f, 0.12090838f, -0.11818288f, 0.33499324f, -0.29048362f, 0.44108438f, -0.15943804f, 
    0.02861488f, -0.13011734f, 0.19895035f, 0.26392990f, 0.04960429f, -0.14692435f, -0.00414564f, 0.04609235f, 
    0.30358985f, 0.23761268f, 0.13888919f, 0.08816539f, 0.26038232f, -0.13518229f, 0.18264502f, 0.30285063f, 
    0.20479295f, -0.03534932f, 0.14486903f, 0.28484729f, 0.06326281f, -0.12386408f, 0.07555857f, 0.23848696f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.08316953f, -0.30377108f, 0.13831313f, -0.18110141f, -0.75386125f, 0.08561422f, -0.16356114f, 0.27820751f, 
    -0.18308288f, 0.36210704f, -0.17799462f, -0.23148727f, -0.09380298f, -0.16394530f, 0.01569957f, -0.49841136f, 
    -0.06791845f, -0.23806010f, -0.08139493f, -0.84267539f, -0.92300129f, -0.09096596f, -0.35534132f, -0.67953187f, 
    0.23815237f, 0.02444122f, 0.02089951f, 0.26808265f, -0.72050864f, -0.02594828f, 0.09199312f, -0.70547330f, 
    -0.48654139f, 0.00092265f, 0.27818504f, 0.19297966f, 0.14105316f, -0.02322611f, 0.16238922f, 0.06935679f, 
    -0.10535552f, 0.23451361f, 0.09969956f, 0.15202695f, -0.22278929f, -0.04148011f, -0.14326096f, -0.28556353f, 
    0.05532545f, 0.06110061f, -0.93796486f, -0.08544045f, 0.51842153f, -0.08202942f, -0.08389743f, 0.52821791f, 
    0.54590797f, 0.00360643f, -0.03308034f, -0.09822077f, 0.05914157f, 0.06649925f, 0.04121007f, 0.10960653f, 
    -0.03736263f, -0.11596338f, -0.00535181f, -0.28988007f, -0.00180506f, -0.09926561f, 0.18348683f, -1.03197908f, 
    0.05252920f, 0.00917549f, -0.11146434f, -0.85513544f, -0.11004304f, 0.17062661f, 0.26605096f, 0.17137015f, 
    0.22562924f, -0.59632182f, 0.37343481f, 0.14783680f, -0.66200650f, -0.02141263f, -0.62507820f, -0.75367314f, 
    -0.56265908f, 0.17129619f, 0.11940581f, -0.11812647f, 0.23171037f, -0.62526041f, -0.15685222f, 0.46300402f, 
    -0.38035488f, -0.20882604f, -0.30035847f, 0.03989853f, -0.25999483f, -0.38452771f, -0.12938942f, -0.14630334f, 
    -0.39926276f, -0.07953769f, -0.91753006f, -1.03243470f, 0.33328921f, 0.04335421f, -0.50077796f, 0.30173522f, 
    0.27641156f, -0.84120554f, 0.40251222f, -0.23714678f, -1.34723508f, 0.11065101f, -0.07838330f, 0.04084535f, 
    -0.39954451f, 0.00518393f, -0.64623028f, 0.05963064f, -0.15503360f, 0.00576576f, 0.15117505f, -0.54215521f, 
    -0.15622835f, -0.16915050f, -0.09281277f, -0.37544587f, -1.03641236f, 0.02859553f, -0.46792531f, 0.11752705f, 
    0.06452002f, 0.05596266f, 0.25502995f, -0.19762294f, 0.27517739f, -0.08383209f, -0.09143325f, -0.11713332f, 
    -0.10187809f, 0.07159184f, -0.04262636f, -0.08206809f, -0.01873687f, -0.01088406f, 0.07830143f, -0.72868097f, 
    0.03732638f, 0.02966285f, -0.04385762f, 0.19037233f, 0.24029668f, 0.21883149f, 0.06679411f, 0.09431577f, 
    0.53617001f, 0.14818482f, 0.14741498f, -0.13812351f, -0.00764037f, 0.31068647f, -0.20709760f, 0.10283653f, 
    0.15683793f, 0.13780265f, -0.48563233f, -0.74887723f, -0.18736559f, -0.01998085f, 0.22101480f, -0.02031757f, 
    0.22709437f, -0.07800710f, -0.27994403f, 0.25684860f, -1.23891592f, 0.06716471f, -0.04469956f, -0.22556651f, 
    0.04137551f, -0.02795259f, -0.41331062f, 0.14287110f, 0.06672613f, 0.28752798f, -0.12960418f, 0.10711171f, 
    0.32800227f, 0.37990156f, -0.60079622f, -0.22603148f, -0.18333048f, -0.25339723f, 0.27206871f, -0.38677445f, 
    -0.19132175f, -0.66025138f, 0.34158504f, 0.40136027f, -0.28896415f, 0.04883758f, 0.34183210f, 0.21734314f, 
    -0.02783988f, 0.31497034f, 0.37073153f, -0.12212341f, 0.20244612f, -0.08258836f, -0.64355046f, -0.03553506f, 
    -0.12551863f, -0.04156054f, 0.34067333f, -1.05052149f, 0.15595505f, -0.27791378f, -0.63688183f, -0.36981612f, 
    -0.17781542f, -0.05111239f, 0.19924980f, 0.23014133f, -0.16014946f, 0.10093082f, -0.04010352f, -0.38352501f, 
    0.09029625f, -0.25123724f, 0.03224467f, -0.43754935f, 0.23434448f, 0.17273913f, -0.35062850f, -0.04234488f, 
    -1.00319719f, 0.19050013f, 0.19033435f, 0.09826872f, -0.33002439f, -0.01291108f, -0.15524715f, 0.06211329f, 
    -0.22997051f, 0.06635074f, -0.19131169f, -0.38310093f, 0.04735658f, 0.50444537f, -0.13654120f, -0.20942546f, 
    0.13499494f, -0.21214162f, -0.09278173f, -0.03542599f, 0.43284035f, -0.57006091f, 0.26502222f, -0.18838659f, 
    -0.00054499f, -0.62370676f, -0.27277678f, 0.09126368f, 0.24052122f, 0.01552401f, 0.18669342f, 0.20234647f, 
    -0.03389405f, -0.18076470f, -0.77803630f, 0.39543107f, -0.49310067f, -0.16957563f, 0.32638875f, -0.13422307f, 
    -0.49567068f, 0.12505876f, -0.47556442f, -0.54997289f, -0.29466102f, -0.52702367f, -0.11754354f, -0.20280643f, 
    0.13494235f, -0.00784815f, 0.01972534f, -0.69930720f, -0.35420603f, -0.38397238f, 0.18303776f, -0.33383670f, 
    -0.00586567f, -0.02557816f, 0.17251268f, -0.19929965f, -0.24827488f, 0.10018742f, -0.41797104f, 0.02310870f, 
    0.15158592f, 0.32933906f, 0.45850053f, -0.08702812f, -0.34060436f, 0.16478890f, -0.30313179f, 0.00774698f, 
    -0.63867366f, 0.04105754f, -0.83174044f, 0.37598431f, -0.08042151f, -0.20720364f, -0.15943350f, -0.21124156f, 
    -0.36350420f, -0.29442063f, -0.63512754f, 0.04823095f, -0.01886935f, 0.19271265f, -0.11576162f, -0.13764809f, 
    -0.23163824f, -0.71980363f, 0.30229640f, -0.88683772f, 0.26079774f, 0.05008447f, -0.45201200f, -0.58438987f, 
    -0.16711199f, -0.46668208f, -0.46572381f, 0.29871848f, -0.33937758f, 0.01368920f, 0.45336875f, -0.49284723f, 
    0.30281895f, 0.15594335f, -0.72977197f, -0.23649742f, 0.09551904f, -0.04719173f, 0.12083770f, 0.38134915f, 
    0.21058236f, 0.06829216f, -0.36209619f, 0.58053845f, 0.25974435f, 0.14263789f, -0.25492489f, -0.94950300f, 
    0.10353199f, -0.78328383f, -0.10681469f, -0.15891710f, -0.20216745f, -0.00027518f, 0.26799324f, 0.13723765f, 
    -0.25960487f, 0.03042331f, 0.08180972f, 0.17297782f, -0.24626857f, -0.05762343f, -0.08284831f, 0.00160480f, 
    -0.61359251f, -0.14762817f, -0.73084313f, -0.14421749f, 0.34892073f, -0.52158105f, -0.46840769f, 0.20630223f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.15643673f, 0.39910850f, 0.17246540f, 0.19771457f, 0.01630178f, -0.32576057f, -0.08503130f, -0.18059702f, 
    0.18528412f, 0.08400687f, 0.11985480f, -0.12257268f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
