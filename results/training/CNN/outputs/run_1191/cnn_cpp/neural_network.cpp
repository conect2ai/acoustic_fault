#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.00062518f, 1.72348547f, -1.29699922f, -0.76741272f, 0.01937058f, -0.07676030f, 0.13698612f, 0.14052138f, 
    -0.01952891f, 0.28996205f, 0.47960669f, 1.42246187f, 0.28277269f, -0.65568131f, 0.50002182f, -0.28413621f, 
    -0.25241667f, -0.28164783f, 2.13039923f, -1.42759717f, -0.54150254f, 0.12022887f, -0.17899257f, -0.14898434f, 
    -0.13427220f, 0.22608685f, 0.02386976f, 0.72470218f, 0.79056036f, 0.36724225f, 0.32641426f, -0.93160945f, 
    -0.84308904f, -0.16248325f, 0.27036706f, -0.17001303f, -0.43814343f, -0.04017743f, 0.42707402f, -0.40951139f, 
    -0.91516519f, -0.63758081f, 0.51090914f, 0.92391080f, 0.81401163f, -0.69036275f, -0.63443547f, -0.01957979f, 
    -0.22463085f, -0.72093785f, -0.77987009f, -0.42182797f, -0.36569342f, -0.45350081f, -1.83680260f, -0.26472610f, 
    1.50725722f, 0.48772493f, -0.34291729f, 0.63221771f, 0.06154616f, 0.15660614f, -0.06323816f, -0.89377069f, 
    -0.12170488f, -0.47496071f, 0.29596692f, 0.79826093f, 0.90302414f, -0.75439423f, -0.00627691f, -0.68596357f, 
    0.32560569f, -0.23454443f, -0.82302827f, -1.07691491f, -0.68209559f, -1.54210031f, 0.20363440f, -0.38823605f, 
    0.48071668f, 0.21630405f, -1.11855793f, -1.50965476f, 0.40807396f, 0.59867007f, 0.18016295f, 0.25162223f, 
    0.25896549f, -0.07662401f, -1.10227025f, 0.47162274f, -0.45570707f, 0.08973861f, 0.45987484f, -0.23327889f, 
    1.04864430f, 0.63839525f, 0.23754448f, 0.20255336f, -0.31938943f, 0.96033204f, -0.36548689f, 0.07748956f, 
    0.16758411f, 0.07988881f, 0.06300277f, 0.76731914f, 0.38029295f, 0.49243405f, -0.15721835f, 0.09040527f, 
    0.42049110f, -0.26147422f, -0.24987459f, 0.41882116f, 0.10067696f, -1.09032393f, -0.97184741f, -0.48437259f, 
    -0.20275322f, 0.91317976f, -1.04610384f, -0.85576928f, -0.67891431f, -0.44020236f, -0.01944404f, 0.82344711f, 
    0.01996790f, 0.06422753f, -0.67929924f, 0.90459448f, -0.37224483f, -0.77970815f, -0.49539408f, 0.86100429f, 
    0.43414265f, 0.37645015f, 0.14262444f, 1.14040208f, 0.33439714f, 0.49418268f, 0.28820735f, 0.04809219f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.16734318f, 0.22988151f, -0.20259842f, 0.97717339f, 0.24981068f, -0.86102724f, -0.10687090f, 0.09950158f, 
    0.64824247f, 1.07077217f, 0.33314228f, 0.10684686f, 1.20574093f, 0.59758717f, -0.17503144f, 0.78106421f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03081864f, -0.02546260f, -0.03259260f, -0.03499194f, 0.05091763f, -0.07604427f, 0.05297096f, 0.04768813f, 
    -0.08637385f, -0.07832751f, -0.04532708f, -0.03395173f, 0.01395454f, -0.02974132f, 0.04383126f, -0.09363324f, 
    0.01653876f, 0.02139712f, -0.00854194f, -0.04906049f, -0.06622319f, -0.08245763f, 0.00425486f, -0.07178766f, 
    -0.05424724f, -0.07275046f, -0.00641974f, -0.04981966f, 0.06010238f, -0.09220491f, -0.02774708f, -0.06496054f, 
    -0.08463798f, -0.06806073f, -0.04503742f, -0.03656781f, -0.03409920f, -0.02340051f, 0.03580603f, 0.01876446f, 
    0.03025651f, 0.00164417f, 0.01794893f, -0.07113297f, 0.07209661f, 0.07022164f, -0.02036614f, -0.00244924f, 
    -0.01642973f, -0.01976048f, 0.01712961f, -0.07094366f, -0.05303155f, -0.07482704f, -0.01789045f, 0.05966959f, 
    0.02906409f, -0.07907445f, 0.05232468f, -0.03002281f, -0.01731263f, 0.02936355f, -0.00292033f, 0.07895547f, 
    -0.07308943f, 0.04032892f, -0.01630593f, 0.05416622f, -0.03520949f, -0.01530065f, -0.04190219f, 0.03548344f, 
    -0.07026123f, -0.01639602f, -0.02007386f, -0.00404275f, 0.04064107f, -0.01623120f, 0.03248015f, -0.06580381f, 
    -0.05461135f, -0.05257672f, -0.01472518f, 0.03114125f, -0.04208305f, -0.02487391f, -0.02131653f, -0.02728547f, 
    -0.00032282f, 0.06593908f, -0.04367719f, -0.08295863f, -0.02037595f, -0.03213356f, 0.04893226f, 0.05885651f, 
    0.00693247f, 0.01328834f, 0.02555466f, 0.06801093f, 0.00130959f, 0.03541090f, -0.00390664f, 0.00695196f, 
    0.00637800f, 0.00686363f, -0.05271221f, 0.07421200f, -0.07519583f, -0.02163395f, -0.08916744f, -0.06377900f, 
    0.05333316f, -0.06673440f, -0.06944303f, 0.05570739f, 0.02313595f, -0.07832587f, 0.00722613f, -0.04774237f, 
    0.04824640f, -0.06149771f, -0.06991854f, -0.05264987f, 0.01492832f, -0.00548561f, 0.07599966f, 0.02076749f, 
    0.04406371f, 0.05846376f, -0.02046255f, -0.03829490f, 0.05245256f, -0.01920346f, 0.02152888f, -0.04033851f, 
    0.06096444f, -0.05265228f, -0.00879460f, 0.03845173f, 0.04251246f, -0.00181428f, 0.03879998f, -0.09787659f, 
    -0.80923539f, -0.57222426f, -0.36416045f, 0.00615921f, 0.12769344f, 0.11171406f, -0.09975640f, 0.04954555f, 
    -0.13913023f, 0.01386189f, 0.21753532f, -0.29476437f, 0.13491462f, -0.09484266f, 0.06055911f, 0.11675948f, 
    -0.00416125f, 0.10010748f, 1.04216349f, -0.73834640f, -0.43841165f, -0.12100293f, -0.11150889f, -0.05961180f, 
    0.05373352f, 0.23298077f, 0.03006660f, -0.74171573f, 0.42026973f, -0.04993825f, -0.31605002f, -0.31808949f, 
    0.11778146f, 0.01042563f, 0.21473633f, 0.16747290f, -0.16732535f, -0.36377433f, 0.08092377f, -0.03153510f, 
    -0.17512266f, -0.21686552f, -0.06404162f, -0.09796052f, -0.08310363f, 0.19488308f, -0.32294783f, -0.32491761f, 
    -0.27244085f, -0.42437106f, -0.54271525f, -0.07017501f, 0.15507154f, -0.18682460f, 0.81014347f, -0.54448342f, 
    -0.71352810f, -0.06764773f, 0.04506561f, -0.18470354f, -0.08373851f, 0.01195588f, 0.08305164f, -0.26582083f, 
    0.36328578f, 0.15061724f, -0.07560705f, -0.00082937f, -0.02570401f, 0.05121029f, -0.03056383f, -0.08005711f, 
    -0.31067920f, -0.70968634f, -0.00045052f, 0.06169651f, -0.17978552f, -0.04159635f, 0.06705159f, 0.18916483f, 
    0.09615950f, 0.56238896f, 0.40141958f, -0.17994948f, 0.05542054f, 0.28397214f, 0.32016265f, 0.04562700f, 
    -0.06926398f, 0.00496389f, 0.19147319f, -0.16380911f, -0.14192252f, -0.04924466f, 0.21937756f, 0.13278881f, 
    0.08215651f, 0.07113519f, 0.19391862f, 0.16177745f, -0.11401270f, -0.15524763f, -0.18788092f, -0.02264510f, 
    0.05975780f, 0.08682865f, 0.07706679f, -0.00797107f, -0.15223192f, 0.43173054f, 0.22195125f, 0.00904800f, 
    0.16110852f, 0.06150443f, 0.16928676f, 0.19413818f, 0.16161004f, 0.23091598f, 0.25822315f, 0.22892022f, 
    0.10419646f, 0.15588626f, -0.05627846f, 0.14594920f, 0.07172360f, -0.08713422f, -0.62544012f, 0.24420267f, 
    -0.15197988f, -0.01742064f, -0.15116033f, -0.05740187f, -0.23744139f, 0.10394606f, 0.05057586f, -0.52368009f, 
    0.10293425f, 0.03852332f, -0.21482128f, -0.04269788f, -0.10952556f, 0.04845196f, -0.03702381f, -0.01010849f, 
    0.20217414f, -0.00822052f, 0.13377877f, -0.15650216f, 0.03917423f, 0.34041587f, 0.20611297f, 0.23714224f, 
    0.14672723f, -0.78315771f, -0.68184376f, 0.14568019f, -0.03869223f, -0.08789076f, 0.09417963f, -0.23025659f, 
    -0.02448330f, -0.26165253f, -0.73050004f, -0.58533925f, -0.67662299f, 0.18232331f, 0.41522610f, 0.05527660f, 
    -0.04646970f, 0.09475370f, -0.53741664f, -0.67879117f, -0.43948737f, 0.05510418f, 0.10372640f, 0.04444730f, 
    0.12079199f, 0.08060884f, 0.14307359f, 0.00482561f, 0.19397116f, 0.06039624f, 0.22773206f, 0.04870783f, 
    0.33772871f, -0.04312648f, 0.24752337f, 0.13874343f, 0.22403088f, 0.02799751f, 0.57133186f, 0.29471946f, 
    0.03866679f, -0.15277712f, -0.02556279f, 0.23252529f, 0.01110287f, -0.09549469f, 0.41328233f, 0.36008257f, 
    -0.01835416f, 0.04677129f, -0.05446200f, -0.09750424f, -0.12616548f, -0.13045931f, -0.26163992f, 0.46982762f, 
    -0.16481914f, -0.09277689f, -0.06791879f, 0.00166487f, -0.25070781f, -0.20877491f, -0.22196621f, -0.28996429f, 
    0.36508942f, 0.60035580f, 0.55641937f, -0.09357332f, 0.08664791f, 0.31325430f, 0.14150247f, 0.04286738f, 
    -0.00347458f, 0.33733499f, -0.24273084f, 0.08596632f, -0.13565105f, -0.12508495f, -0.07971535f, -0.01735433f, 
    -0.06514992f, 0.24360411f, 0.38325346f, 0.11680379f, 0.25781927f, 0.03361168f, -0.06285827f, 0.01414825f, 
    0.25978133f, 0.34147972f, 0.18353558f, -0.42238542f, -0.26973316f, -0.01161644f, -0.12140384f, -0.26477602f, 
    -0.23156849f, 0.16122597f, 0.29795617f, 0.26776186f, -0.30269638f, -0.13200226f, 0.04381337f, 0.02277023f, 
    0.01737422f, 0.16372466f, 0.34212521f, 0.27586627f, 0.20559180f, 0.25171828f, 0.15737844f, -0.23041461f, 
    0.08621377f, -0.03323862f, -0.16422993f, 0.01686228f, -0.02907571f, 0.07348895f, -0.23768754f, -0.32785457f, 
    0.06921142f, 0.04975148f, 0.02005640f, 0.14632721f, -0.29180712f, -0.23344162f, -0.24438345f, -0.21142484f, 
    -0.21070825f, 0.13654117f, -0.03135964f, -0.01777536f, -0.18653961f, -0.06030585f, 0.05448724f, 0.14572808f, 
    0.30896702f, 0.76890081f, -0.33986318f, -0.03970610f, 0.01533632f, -0.22107707f, -0.01251746f, 0.16498077f, 
    0.22657825f, -0.04146941f, 0.09474335f, -0.45338163f, 0.02839510f, 0.11069278f, 0.10263046f, 0.02971524f, 
    0.29539070f, 0.20007119f, -0.24390961f, 0.49387673f, -0.15691146f, 0.05172708f, -0.17688081f, -0.11773405f, 
    0.23582122f, 0.49304241f, 0.07659946f, 0.04893241f, -0.01148284f, 0.21626903f, -0.13785411f, -0.15350235f, 
    0.04604389f, 0.11759380f, 0.07295457f, 0.08916204f, 0.23375767f, 0.01487164f, -0.22458720f, 0.00431122f, 
    -0.00464504f, -0.03114574f, -0.31876525f, -0.15534027f, -0.23738547f, 0.36641172f, 0.45026892f, 0.13859200f, 
    0.30153123f, 0.04990879f, 0.27194199f, -0.23399958f, -0.02517092f, -0.10431871f, 0.31812131f, -0.22034596f, 
    -0.53277791f, 0.21593109f, -0.03117691f, 0.13484316f, -0.10515993f, 0.20876980f, -0.04547735f, -0.29831713f, 
    0.00551537f, 0.01496030f, 0.00952204f, 0.31449598f, 0.43190560f, -0.05480138f, 0.00942395f, 0.11295282f, 
    0.28666982f, 0.34868112f, -0.00231425f, 0.41060704f, 0.08888469f, 0.24417171f, -0.13579373f, 0.14046791f, 
    -0.26655567f, -0.36120650f, -0.25362051f, -0.16813566f, -0.03667008f, 0.06127775f, 0.13111848f, -0.04953110f, 
    0.15042576f, 0.07572307f, 0.21099554f, -0.08661974f, -0.05151739f, 0.17049861f, 0.08179592f, 0.04961860f, 
    0.09530371f, -0.43701202f, -0.38887468f, -0.10033485f, -0.22695436f, -0.12058634f, -0.13323808f, 0.28070256f, 
    0.04670928f, -0.00723149f, 0.01883076f, -0.11375259f, -0.03204132f, 0.10972822f, -0.05691849f, 0.14357968f, 
    -0.07456777f, 0.26773754f, -0.09065232f, -0.09711871f, -0.38693553f, 0.11329407f, 0.24689472f, 0.08021330f, 
    0.13400100f, 0.01400704f, 0.06343927f, 0.07381448f, 0.09649763f, 0.21763860f, 0.08961920f, 0.06814341f, 
    -0.16762783f, 0.13486475f, 0.43144232f, 0.02612290f, 0.23529701f, 0.18445133f, 0.18586576f, 0.27166304f, 
    0.04299139f, 0.15538830f, 0.21551043f, 0.05959773f, 0.15036701f, -0.07684221f, -0.03984992f, 0.12622090f, 
    0.03486374f, -0.02757956f, -0.04189885f, 0.01957449f, -0.07703956f, -0.03836279f, 0.05817362f, -0.00797778f, 
    0.04591855f, 0.05906564f, -0.05293373f, 0.06527517f, 0.01878618f, -0.03446293f, 0.07887327f, 0.05951402f, 
    -0.00069583f, -0.04366768f, 0.01380185f, 0.03997803f, -0.07328319f, -0.03093483f, 0.00594245f, -0.05852208f, 
    -0.02905932f, -0.05077660f, -0.05071539f, 0.04473501f, -0.09458061f, 0.05176926f, 0.04947871f, -0.01836198f, 
    -0.02595219f, -0.08682779f, -0.00085051f, -0.08272815f, 0.01683523f, 0.04857626f, -0.00015083f, -0.04945352f, 
    0.02993465f, -0.06899816f, -0.06775785f, -0.03632854f, -0.00383193f, -0.02926480f, -0.04530049f, -0.03232772f, 
    0.00023873f, -0.06014868f, -0.03577093f, -0.02452785f, -0.05302732f, -0.04995834f, 0.04870561f, 0.01816818f, 
    -0.07425893f, -0.00035967f, 0.03447007f, 0.01207643f, -0.00029010f, -0.08017610f, 0.00843259f, 0.03475112f, 
    0.07477362f, -0.06758211f, 0.01333035f, -0.04393674f, 0.01132534f, 0.03031497f, 0.01659059f, 0.01194975f, 
    0.00874641f, 0.05195007f, 0.01932669f, -0.00222179f, -0.02274676f, -0.00462774f, 0.05185616f, -0.06304978f, 
    0.03779215f, 0.04075676f, -0.04159488f, -0.01067133f, 0.02596975f, 0.04128634f, -0.06800143f, -0.03641922f, 
    -0.04109696f, -0.04882449f, 0.06922259f, -0.03346711f, -0.02970306f, -0.00778238f, -0.02594066f, 0.06610874f, 
    0.03415356f, 0.03284568f, -0.04666847f, -0.04399323f, -0.02404445f, -0.02719402f, 0.00058181f, -0.02617683f, 
    -0.00048790f, -0.04762431f, -0.00976811f, 0.07390329f, -0.08575404f, -0.05567896f, -0.08541243f, 0.02028807f, 
    -0.09046534f, 0.05268265f, -0.08561803f, 0.01693651f, 0.01441346f, -0.01896749f, -0.06860805f, 0.02922364f, 
    -0.04413733f, -0.00078402f, 0.03570105f, -0.06553765f, -0.02037194f, -0.03757172f, 0.01082572f, -0.06176518f, 
    0.01986827f, -0.03622569f, 0.01316204f, -0.01654643f, -0.04216921f, -0.00491108f, -0.07548083f, 0.00586706f, 
    -0.04201442f, -0.03526241f, 0.04109829f, -0.05610123f, 0.01129950f, -0.05383696f, -0.05418491f, 0.06154878f, 
    0.02378518f, 0.03869835f, 0.02046651f, -0.07935531f, -0.06875970f, 0.03673489f, 0.06182984f, 0.05773391f, 
    0.01183285f, -0.05609200f, -0.05930080f, -0.08784866f, -0.06796664f, -0.01646325f, -0.01779181f, -0.04727127f, 
    -0.08061608f, 0.01920717f, 0.05604716f, -0.01792691f, 0.03718811f, -0.06975341f, 0.02606977f, -0.02842083f, 
    -0.03407679f, 0.01981432f, -0.00258363f, 0.03278358f, -0.00881180f, -0.00439994f, -0.06923469f, -0.02856679f, 
    0.04595965f, 0.00639673f, -0.03648814f, 0.03217224f, -0.06875996f, -0.03142985f, 0.07600302f, -0.04135055f, 
    -0.07800951f, -0.00598375f, -0.03021324f, 0.03940337f, 0.03772550f, -0.09219465f, 0.07631577f, -0.00560299f, 
    0.00694581f, -0.03387986f, 0.05103565f, -0.02805669f, -0.01676953f, -0.01548410f, -0.07198073f, -0.02645249f, 
    0.00167591f, 0.00677287f, -0.05669836f, -0.02678219f, 0.01584961f, -0.07484572f, -0.04513305f, 0.06292260f, 
    -0.01884823f, -0.04848985f, -0.02217249f, 0.07667746f, -0.03882459f, -0.03934201f, 0.03083801f, -0.02711650f, 
    -0.03195645f, 0.05948308f, -0.03048678f, -0.05239444f, 0.06380130f, 0.05481597f, 0.02849373f, -0.00025805f, 
    -0.01270915f, -0.05446931f, 0.05353181f, -0.02345343f, -0.02749909f, 0.07217430f, -0.06799089f, -0.06077934f, 
    -0.00136953f, -0.03094522f, -0.09293316f, -0.01872811f, -0.00163742f, -0.02266889f, -0.08300198f, -0.08098685f, 
    -0.00966662f, -0.04863301f, 0.01968713f, -0.03399519f, -0.02850425f, 0.03177781f, 0.05283526f, -0.00825336f, 
    0.07199538f, 0.01681018f, 0.06099311f, -0.02834528f, -0.05601588f, -0.03252133f, -0.06153473f, 0.06643728f, 
    -0.07218890f, -0.04287086f, 0.00378700f, 0.02846129f, 0.05090224f, 0.02278512f, -0.07836093f, 0.05444898f, 
    -0.07800175f, -0.06489432f, 0.02711901f, -0.06837422f, 0.00291780f, -0.06819289f, -0.08062814f, 0.07350827f, 
    -0.00077597f, 0.07670711f, -0.02849719f, 0.06258307f, 0.05736950f, 0.00579503f, 0.07524864f, 0.03131304f, 
    0.02177749f, -0.07153840f, -0.05617871f, 0.00199984f, -0.01731993f, -0.06040014f, -0.07486308f, -0.05836331f, 
    0.23962449f, -0.93157768f, -0.51463866f, -0.04397396f, 0.50954801f, -0.23348497f, 0.00986843f, -0.08782320f, 
    -0.02053398f, 0.40761513f, 0.30421421f, -0.12545490f, -0.03000915f, -0.07662704f, -0.19172978f, 0.19030173f, 
    0.03796240f, 0.19622616f, -0.84137011f, 0.17907719f, -0.52633876f, 0.15249276f, 0.63428372f, 0.04336824f, 
    -0.07771229f, 0.24145767f, 0.19294821f, 0.61320907f, 0.53296477f, 0.13388732f, -0.05039438f, -0.23771451f, 
    -0.00745115f, 0.09837113f, 0.14470933f, 0.12032539f, -0.13646488f, 0.09176879f, 0.18202923f, -0.03365499f, 
    -0.08842678f, 0.01070246f, 0.13349482f, 0.16747956f, 0.16285260f, 0.55636388f, -0.11466407f, -0.48564553f, 
    -0.67755735f, -0.81305361f, 0.13982350f, 0.06822561f, -0.26685885f, -0.05626575f, -0.07254317f, -0.88055766f, 
    -0.72946811f, 0.08668022f, -0.16244118f, 0.07161078f, 0.32534668f, 0.24654514f, 0.11820565f, -0.49014550f, 
    -0.36807066f, -0.15387166f, -0.09627363f, -0.01102453f, 0.07297651f, -0.08424692f, -0.20015447f, 0.07465909f, 
    -0.42591318f, -0.06691338f, 0.23515527f, -0.03495644f, -0.27028343f, -0.07264281f, 0.12440421f, 0.17124137f, 
    0.06709399f, -0.96891230f, -0.50960577f, -0.36891973f, -0.05366459f, 0.50318617f, 0.13533436f, -0.05098551f, 
    -0.11664575f, 0.09728391f, -0.19743726f, -0.53398263f, -0.34670216f, 0.05850152f, 0.13565874f, -0.00340929f, 
    0.30809456f, 0.01802168f, 0.06206386f, 0.40394655f, 0.07508191f, -0.20130844f, -0.21165828f, -0.19183758f, 
    -0.13830836f, -0.20107670f, -0.12991491f, -0.02312944f, 0.24130674f, 0.41159004f, 0.18131006f, -0.09660494f, 
    0.28336480f, 0.20382419f, 0.10829373f, -0.04148903f, 0.00969986f, 0.04836040f, -0.41388264f, -1.28476858f, 
    -0.18705480f, 0.25887677f, 0.05187310f, 0.09047104f, -0.04434115f, 0.18347253f, -0.14847286f, 0.15168938f, 
    0.44064835f, -0.07565502f, -0.11734372f, -0.17600174f, 0.01951910f, 0.12815131f, 0.33259970f, 0.28768325f, 
    0.52701902f, 0.12659733f, -0.09994517f, 0.03115249f, -0.15948254f, 0.09724616f, -0.06874762f, 0.02025932f, 
    -0.83424056f, 0.37674049f, 0.00594156f, 0.11406785f, 0.17707425f, 0.15183587f, 0.05378597f, 0.16573498f, 
    0.18013209f, -0.34434143f, 0.24452953f, 0.39102975f, 0.02309708f, -0.11206964f, -0.20592067f, 0.15960903f, 
    0.09561986f, 0.11918481f, 0.73353386f, -1.17088079f, 0.61948961f, -0.44245753f, -0.05098781f, 0.83063692f, 
    -0.12666340f, -0.12400311f, -0.02459757f, 0.49992362f, 0.03080183f, 0.39947388f, 0.19010083f, 0.11912300f, 
    -0.08720188f, 0.22117029f, 0.05205509f, 0.28225192f, 0.00632318f, 0.05008137f, -0.31562972f, 0.04913544f, 
    0.14456147f, 0.07302541f, 0.02944473f, 0.00875575f, 0.06975524f, -0.41326636f, -0.52271992f, 0.15873691f, 
    -0.03791768f, 0.12911184f, 0.06631047f, 0.20886849f, 0.29527858f, 0.20246318f, -1.05475318f, 0.11679205f, 
    0.01333173f, -0.01375965f, 0.14494559f, -0.22258848f, -0.10953852f, -0.43115097f, -0.09402309f, -0.12433132f, 
    -0.10523555f, -0.31221443f, 0.14186944f, -0.25870046f, -0.23355234f, -0.14469095f, -0.31748077f, 0.15856689f, 
    -0.02982071f, 0.33895934f, -0.17881700f, -0.16011424f, -0.15822500f, -0.13175212f, 0.02560964f, 0.02226450f, 
    -0.06529073f, 0.21633001f, -0.43371215f, -0.25652969f, -0.02789296f, 0.16577043f, 0.17436916f, 0.01491120f, 
    0.19207431f, -0.20309214f, -0.53084493f, -0.34932098f, -0.20964178f, -0.31211329f, -0.12508911f, 0.03007918f, 
    0.10017101f, 0.33779517f, -0.01475143f, 0.15185110f, 0.23592359f, 0.03850235f, 0.22255386f, 0.05936249f, 
    0.20721351f, -0.06381175f, -0.15212041f, 0.10351573f, 0.46945441f, 0.12248386f, 0.21644606f, 0.47120738f, 
    0.09239561f, -0.01019410f, 0.29885152f, 0.15198094f, 0.11805885f, -0.20944078f, 0.05828283f, 0.12809077f, 
    -0.14083828f, 0.32998618f, -0.18307674f, 0.22797155f, 0.04502904f, -0.05528894f, -0.65649980f, 0.32993692f, 
    -0.29114595f, 0.00451141f, -0.43231481f, 0.17504153f, -0.25201362f, -0.09912270f, -0.09269965f, 0.32378742f, 
    -0.00782251f, 0.19611056f, 0.18118057f, -0.07095669f, -0.11967111f, -0.07093802f, 0.20211510f, -0.07487418f, 
    -0.04932219f, 0.04213674f, 0.10969969f, -0.12172303f, 0.22236876f, -0.09992126f, 0.23269735f, -0.07645637f, 
    -0.14148881f, -0.31414533f, -0.11664306f, -0.20103179f, -0.02312861f, 0.06339088f, -0.01175515f, 0.18031500f, 
    0.05090070f, -0.07914580f, -0.69051892f, 0.23828514f, 0.95017463f, -0.18950351f, 0.17969207f, 0.19544479f, 
    -0.02534241f, 0.31426513f, 0.15316617f, -0.10584141f, -0.23083408f, -0.03548223f, 0.08649943f, -0.05998522f, 
    -0.00526681f, -0.03408827f, -0.00237780f, -0.17339225f, -0.11540652f, 0.19073988f, -0.02817951f, 0.10591601f, 
    -0.00021677f, -0.17891750f, -0.26232028f, -0.25051028f, -0.41971165f, 0.27662018f, 0.33105806f, 0.13059598f, 
    0.15245438f, -0.02939319f, 0.23319459f, -0.23748875f, -0.25697652f, -0.04008554f, 0.54429787f, 0.95388311f, 
    -0.44894427f, -0.01746203f, 0.01173247f, 0.15853921f, 0.10272750f, -0.00134711f, -0.18040431f, 0.39964998f, 
    0.28070459f, 0.17648865f, 0.09685387f, 0.00159063f, 0.57018512f, -0.06734027f, 0.04714997f, -0.05168062f, 
    -0.16095306f, 0.06646735f, 0.24912421f, 0.02295851f, 0.15919158f, -0.15361546f, -0.06525888f, -0.14852497f, 
    -0.15267129f, 0.23207311f, -0.20441835f, 0.44513044f, -0.04177818f, -0.26672527f, -0.29203266f, -0.10722581f, 
    0.13387462f, 0.02177145f, 0.14788839f, -0.01107605f, 0.11640350f, 0.26954263f, 0.12921911f, -0.05475915f, 
    0.10322604f, -0.13504857f, -0.34836525f, -0.12135153f, 0.03599741f, -0.09684053f, -0.00009129f, 0.12109437f, 
    0.02829813f, 0.16437449f, -0.27144101f, -0.25376540f, -0.17802273f, -0.33667320f, 0.07353690f, 0.08801350f, 
    -0.04208447f, -0.02232291f, 0.01297517f, -0.02594724f, -0.09945170f, -0.04859962f, -0.06580470f, -0.19141880f, 
    0.06108747f, 0.05176421f, 0.23760501f, 0.11200426f, 0.28804111f, 0.29523620f, 0.03138985f, -0.09529445f, 
    0.42564973f, -0.07960795f, 0.08068734f, 0.07583138f, 0.16646104f, 0.41843483f, 0.18458360f, 0.16563974f, 
    -0.07913601f, 0.10151755f, -0.01082694f, 0.03083756f, 0.12684524f, 0.03617504f, -0.12896629f, -0.14763755f, 
    0.15484895f, 0.41387537f, -1.36275995f, -0.06088633f, -0.29422212f, 0.26295909f, 0.19758289f, 0.22224385f, 
    -0.03521412f, -0.32773665f, -0.33498698f, -0.18627462f, -0.08562307f, 0.30965763f, -0.05663931f, -0.22167996f, 
    -0.01206879f, -0.12842438f, 0.54735798f, 0.23986155f, -0.60521173f, 0.06499760f, -0.02340868f, -0.23517013f, 
    0.08647700f, -0.01043783f, -0.08778274f, 0.21172564f, -0.61555749f, 0.16366376f, 0.35415694f, 0.45713457f, 
    -0.00525978f, 0.35636893f, -0.04427354f, 0.01323046f, -0.11509574f, -0.58179605f, -0.37509313f, -0.09740660f, 
    -0.08246627f, -0.13567439f, 0.30710977f, -0.28107032f, 0.11056419f, -0.22811697f, -0.44549707f, -0.03864614f, 
    -0.28586632f, -0.18630926f, -0.15156500f, 0.15596721f, 0.15976539f, 0.13137792f, -0.65104926f, -0.30353695f, 
    -0.06984121f, -0.35772383f, -0.39820868f, -0.00938245f, 0.07591671f, -0.14987271f, -0.02047115f, 0.27123156f, 
    0.17794980f, 0.04136394f, -0.14775792f, -0.16422415f, 0.10852884f, 0.01033465f, 0.02867809f, 0.18185849f, 
    0.20906872f, -0.04361669f, -0.95651138f, 0.28287879f, 0.24636211f, -0.04010791f, 0.17124082f, 0.11649916f, 
    -0.05208096f, -0.02742406f, 0.48413369f, 0.61033708f, 0.07470148f, 0.48528698f, 0.27003774f, 0.00201328f, 
    0.15400884f, 0.34557837f, -0.94053185f, 0.29880235f, 0.19897746f, 0.06006208f, -0.01793213f, -0.08021355f, 
    0.01463010f, 0.25746909f, -0.05067299f, 0.08719228f, -0.35103351f, -0.38047454f, -0.11721274f, -0.11169902f, 
    0.03004384f, 0.20986909f, -0.21747723f, -0.25180480f, 0.19925104f, 0.13407280f, 0.29235983f, 0.16080342f, 
    0.16941535f, 0.20469025f, 0.26912636f, 0.31863946f, 0.10382220f, -0.05805583f, -0.40434474f, -0.25266260f, 
    -0.06638611f, -0.16620992f, -0.13436139f, -0.16698900f, 0.01737473f, 0.27421767f, -0.31098241f, -0.40647939f, 
    -0.34839782f, -0.22704220f, -0.07467774f, -0.12931028f, -0.26188979f, -0.15820044f, 0.34275714f, 0.11813833f, 
    0.14417641f, -0.22400308f, 0.14704458f, 0.10834321f, -0.00793707f, -0.05208091f, 0.10824932f, 0.16315587f, 
    -0.10312506f, -0.36323172f, 0.70323277f, 0.05790923f, 0.41108593f, 0.70070821f, 0.10201038f, 0.07070367f, 
    0.40284470f, 0.04888065f, 0.14916772f, 0.23738819f, -0.02369808f, 0.00728333f, -0.10701165f, 0.00214832f, 
    0.00392862f, -0.24978933f, 0.34940293f, -0.99997121f, -0.61530018f, -0.25312930f, 0.08341804f, 0.37032720f, 
    -0.02651057f, -0.24991986f, 0.03560315f, -0.02057013f, -0.18215925f, -0.03176146f, -0.05527989f, 0.00126197f, 
    0.05319141f, 0.09716740f, 0.19803239f, 0.18867116f, -0.22611313f, 0.02685572f, -0.26496947f, -0.05492666f, 
    0.02938435f, 0.06611516f, 0.11949158f, 0.19168584f, 0.21849774f, -0.13701537f, -0.11326288f, -0.52519822f, 
    -0.20420323f, 0.14915556f, 0.06216506f, 0.31363606f, 0.11456239f, 0.17384434f, -0.52301621f, -0.75372964f, 
    0.35263264f, 0.15779178f, 0.29963109f, -0.02624397f, -0.06325653f, -0.10695185f, 0.13155106f, -1.04900050f, 
    0.04300785f, 0.00413966f, 0.08744003f, -0.12953635f, -0.19043441f, -0.01669812f, -0.24083316f, -0.11090054f, 
    -0.20845179f, 0.25357842f, 0.22319475f, 0.14074945f, 0.07182161f, -0.20775674f, 0.16420037f, 0.07782709f, 
    0.14333962f, 0.00392038f, 0.25449848f, -0.20747575f, 0.04404129f, -0.02512744f, -0.36465579f, 0.02577347f, 
    -0.08768754f, -0.09852549f, -0.47904900f, 0.01139123f, 0.02501962f, 0.16225219f, 0.23679104f, 0.08484425f, 
    0.30039757f, 0.33814338f, 0.11057368f, 0.19610542f, 0.31545895f, 0.11260743f, -0.07824367f, 0.04711689f, 
    0.35922951f, -0.09348793f, -0.22244550f, 0.52731645f, 0.07972383f, -0.04911806f, 0.10989419f, 0.03702435f, 
    0.19866544f, -0.01796075f, 0.05259085f, 0.18761081f, 0.10178924f, -0.17644061f, 0.31471032f, 0.37367621f, 
    -0.02367521f, -0.00060938f, 0.04293422f, -0.21870846f, -0.24956772f, -0.10899255f, -0.35377628f, 0.15868831f, 
    0.04192934f, -0.08343429f, -0.06349315f, -0.27773109f, -0.05078619f, -0.37785438f, -0.25570437f, 0.06127462f, 
    -0.01631033f, 0.15248908f, 0.00767241f, -0.00928684f, -0.05795967f, -0.35007712f, -0.20337327f, 0.18231057f, 
    -0.03859830f, -0.07110343f, -0.05186429f, -0.03452212f, 0.04343266f, 0.00529208f, -0.07880096f, 0.02472065f, 
    0.03117323f, -0.04700254f, -0.09302634f, -0.00078618f, 0.05889738f, -0.07914080f, -0.08838029f, -0.02611800f, 
    -0.00541414f, -0.04720157f, -0.00153997f, -0.07875888f, 0.04919942f, 0.00154900f, -0.01811431f, 0.07474240f, 
    -0.08561551f, -0.06791109f, 0.00645236f, -0.02895686f, 0.00712379f, 0.02367741f, -0.00311792f, -0.05233086f, 
    0.04693205f, 0.05130370f, 0.00742445f, 0.03225425f, -0.00469410f, -0.05858700f, -0.07086445f, 0.02686091f, 
    -0.06080238f, 0.05161411f, -0.03430302f, -0.06225269f, 0.02487625f, 0.04868743f, -0.01570228f, -0.01271810f, 
    0.03576998f, 0.02942202f, -0.02624107f, 0.02974815f, -0.05627993f, -0.02388510f, -0.04474530f, -0.07203089f, 
    0.05487323f, -0.01775189f, -0.07780650f, 0.02246222f, -0.07061595f, 0.07092676f, -0.03197259f, 0.00947997f, 
    -0.03652629f, 0.00679406f, -0.09781121f, 0.03446794f, -0.09806248f, -0.08255180f, -0.03223015f, 0.00047608f, 
    0.03825126f, 0.01411167f, 0.07102676f, -0.09252474f, 0.03922754f, 0.05419510f, -0.06093906f, 0.00357234f, 
    -0.08603403f, 0.05312596f, -0.00893908f, -0.07216073f, 0.00042395f, 0.04080695f, 0.00545867f, -0.07663792f, 
    -0.06206027f, -0.03091002f, -0.07857559f, 0.01432319f, -0.04214083f, -0.08413026f, 0.05475805f, -0.02522671f, 
    -0.01472348f, -0.01242198f, 0.01294298f, -0.02318699f, 0.00438154f, 0.05548001f, -0.09207286f, -0.00328005f, 
    0.06496879f, 0.06968602f, -0.04384309f, -0.07520454f, 0.01952157f, 0.00108971f, -0.04891705f, 0.00906416f, 
    0.05819320f, 0.06929788f, 0.05150172f, -0.01154412f, 0.02604211f, -0.06489336f, -0.01626679f, 0.05457727f, 
    0.01441146f, -0.09885758f, -0.06876990f, -0.02311475f, 0.04663504f, 0.02611077f, -0.01645033f, -0.03292245f, 
    -0.04454077f, 0.05333638f, 0.03646949f, -0.00259953f, -0.04562679f, -0.08267529f, 0.03573530f, -0.02136696f, 
    -0.08288570f, -0.05223244f, -0.03232439f, -0.04156135f, 0.02987879f, 0.05007701f, 0.01627912f, -0.06601965f, 
    -0.03717115f, -0.08781645f, 0.07164615f, -0.02564441f, -0.03232305f, -0.01470570f, -0.01496550f, 0.00885458f, 
    0.00420124f, -0.01838780f, 0.03965661f, -0.06252731f, 0.01585999f, -0.03124374f, 0.01480187f, -0.03767837f, 
    -0.03636349f, 0.01325316f, 0.01933536f, -0.06887913f, 0.02901823f, 0.03009552f, -0.02944077f, -0.08869194f, 
    -0.05057235f, 0.07278951f, -0.12888323f, 0.05371747f, 0.07147127f, -0.03678672f, 0.02132371f, -0.01236045f, 
    0.05410872f, 0.02303981f, -0.06834670f, -0.03576639f, 0.02406471f, -0.04381159f, -0.03061755f, -0.05416690f, 
    -0.00925180f, -0.00797402f, -0.07409344f, 0.06283297f, -0.01661689f, -0.00394695f, 0.06613026f, -0.02783711f, 
    -0.03674927f, -0.08632263f, 0.02517766f, 0.05017870f, 0.00764739f, -0.07772465f, -0.03269511f, -0.04242519f, 
    -0.02340765f, 0.01762772f, -0.05688935f, -0.02181452f, 0.03314313f, -0.07919655f, -0.02917928f, -0.04327519f, 
    -0.08688717f, -0.07888386f, 0.03758668f, -0.01321354f, -0.08653302f, -0.02498419f, -0.01587923f, 0.05406130f, 
    -0.00744088f, -0.06743994f, -0.07898934f, -0.05334316f, 0.06593868f, -0.10671344f, 0.03885160f, -0.05970224f, 
    -0.09991083f, 0.07733922f, 0.01616408f, -0.04242434f, 0.05587312f, -0.04534701f, -0.09439152f, -0.03682441f, 
    -0.03387122f, -0.09299850f, 0.00983870f, 0.06695862f, -0.02426426f, 0.04870208f, -0.06819262f, 0.06009457f, 
    0.03755664f, -0.09662114f, 0.01106639f, -0.04425114f, -0.08854059f, 0.05563087f, 0.02068437f, 0.01022180f, 
    0.04431356f, -0.07862111f, 0.02176105f, 0.01977357f, -0.05429684f, 0.05708808f, 0.08055365f, -0.04613930f, 
    -0.03599662f, 0.02138687f, 0.02847438f, -0.03661235f, 0.05009779f, 0.00914910f, 0.06473944f, -0.04287999f, 
    -0.01208432f, 0.05980300f, -0.08533756f, 0.05444337f, 0.02279952f, 0.04339395f, 0.04341001f, -0.05941534f, 
    0.06650028f, -0.07549643f, 0.03184583f, -0.12253010f, 0.02281746f, -0.03152186f, -0.02290577f, -0.05299180f, 
    0.00418358f, -0.00340974f, -0.01787489f, -0.04238199f, -0.07479710f, 0.02940280f, -0.01319593f, -0.00280561f, 
    -0.26599807f, -0.23855157f, -0.85832298f, -0.20673072f, -0.67918748f, -0.28504303f, 0.00665368f, -0.09639066f, 
    -0.28995124f, -0.14499059f, -0.41579363f, -0.94781047f, 0.09344068f, -0.06117309f, -0.10873917f, 0.11140496f, 
    -0.03341781f, 0.08791530f, 1.10803795f, 0.91172528f, -0.58610505f, -0.15218297f, -0.08197784f, -0.13726705f, 
    -0.02013762f, 0.11557344f, -0.09033775f, -0.28821605f, -0.45960009f, -0.33655766f, -0.20079216f, -0.35363024f, 
    -0.18727747f, 0.02707188f, 0.08607496f, 0.12180945f, 0.30011067f, 0.20865580f, 0.19164230f, -0.20340644f, 
    0.23467469f, -0.06984901f, -0.14013591f, 0.13422661f, 0.35228601f, 0.59054977f, 0.23359716f, 0.13570787f, 
    0.19234109f, -0.04413163f, 0.14118336f, 0.15209307f, -0.01613325f, -0.14404765f, -0.31207007f, -0.00337508f, 
    0.47498152f, 0.08714709f, 0.14007822f, 0.02796424f, -0.15210974f, 0.19192794f, 0.24732430f, -0.01284688f, 
    -0.36248091f, 0.38238043f, -0.10723136f, 0.12308937f, 0.01159681f, 0.16608360f, 0.12668584f, -0.06812739f, 
    -0.11677404f, 0.28022918f, 0.00180817f, -0.19571906f, -0.08860470f, -0.18595248f, -0.10080162f, -0.02565368f, 
    0.07548660f, 0.41989598f, 0.16837551f, -0.69208616f, 0.28830355f, -0.08973049f, 0.28189784f, 0.06818050f, 
    -0.16649596f, -0.11650039f, 0.08979265f, -0.20877650f, 0.09054065f, 0.12228957f, 0.36047876f, 0.06419566f, 
    0.03651890f, 0.10490529f, 0.08274654f, 0.23917326f, 0.15878436f, -0.33567935f, -0.07913649f, 0.26009384f, 
    0.03252567f, 0.35679626f, 0.07323163f, -0.09567885f, -0.10028202f, -0.53081715f, -0.29954785f, 0.13563710f, 
    -0.19216537f, 0.15701412f, 0.00968828f, 0.17982706f, -0.30381241f, 0.51300454f, 0.03314208f, 0.48929435f, 
    0.07480987f, 0.21830052f, 0.43894109f, 0.10962743f, -0.05350200f, -0.09983635f, -0.63555962f, 0.74970460f, 
    0.40939811f, -0.01034717f, 0.03136147f, -0.01247493f, 0.14138868f, -0.07630321f, -0.18537763f, -0.12735672f, 
    -0.50429881f, -0.23798780f, -0.13395455f, -0.05700717f, -0.08654489f, -0.08277873f, -0.11089744f, 0.11619066f, 
    0.30806991f, -1.01050007f, -1.90938711f, 0.11296626f, -0.17920351f, 0.16235818f, -0.16092360f, 0.30248937f, 
    -0.35617459f, -0.09077185f, -0.05135177f, -0.19403580f, 0.08319673f, -0.31075320f, 0.01586882f, -0.18535782f, 
    0.11388903f, -0.08318494f, 0.74073201f, -0.97447252f, -0.39314285f, -0.37827274f, 0.10599132f, -0.31925380f, 
    0.15360940f, -0.00224744f, -0.17188574f, -0.11126576f, -0.59061795f, -0.10683115f, -0.07770542f, 0.11064915f, 
    -0.00638306f, 0.08361533f, 0.18298958f, 0.15850367f, 0.07673779f, 0.36630696f, 0.76917273f, -0.13709213f, 
    -0.28841442f, -0.11693586f, -0.19844639f, 0.04266695f, -0.03016368f, 0.13666002f, 0.15326598f, 0.51780975f, 
    0.00382852f, -0.03578457f, 0.02290970f, 0.12475777f, -0.07524301f, -0.08419275f, -1.17075241f, -0.56229013f, 
    -0.42523229f, -0.14678736f, -0.02517481f, -0.09613660f, 0.19147703f, 0.10728419f, 0.22791313f, -0.64693224f, 
    -0.32381919f, -0.30385619f, -0.21861878f, 0.00406644f, 0.06381531f, 0.42610160f, -0.14796968f, 0.04021175f, 
    0.29303440f, 0.47837296f, 0.65946746f, -0.00371415f, 0.14039728f, 0.07217854f, 0.16365676f, -0.14277394f, 
    0.03781720f, -0.04309950f, -0.32955793f, 0.02335709f, -0.01071468f, 0.07717777f, 0.27568984f, 0.00941729f, 
    0.30784276f, 0.02548458f, 0.32577428f, 0.33472252f, 0.20305708f, 0.10199596f, -0.19518620f, 0.31933123f, 
    0.38587326f, 0.04391069f, -0.19806102f, 0.05167182f, -0.69763762f, -0.65709335f, 0.09998336f, -0.16576530f, 
    -0.31565821f, -0.40868583f, -0.00450879f, -0.34886655f, 0.11488171f, -0.86004776f, -0.51781893f, 0.16819979f, 
    0.09327016f, -0.01193060f, 0.15902899f, 0.10889721f, 0.25985515f, -0.19289576f, 0.08829957f, 0.30202794f, 
    0.11643433f, 0.09690562f, -0.01043169f, 0.16227165f, 0.10063722f, -0.03198287f, 0.26483890f, 0.10078638f, 
    -0.57200527f, 0.00206348f, -0.18808222f, 0.04973795f, 0.24550252f, 0.19477692f, -0.03929226f, -0.13505316f, 
    -0.55323404f, -0.66795921f, 0.00197049f, -0.32237577f, 0.16097869f, 0.01280134f, 0.26723126f, 0.43621269f, 
    1.16044819f, -1.06468904f, -0.61346775f, -0.23095196f, -0.33374211f, -0.17639555f, -0.01147019f, 0.11243066f, 
    -0.07774234f, -0.29485556f, -0.13217132f, 0.36788669f, -0.05208049f, 0.04152829f, -0.14267834f, 0.06934437f, 
    0.15867651f, 0.05309160f, -0.07587280f, 0.15497409f, -0.26960149f, -0.21765129f, -0.32829946f, -0.24697277f, 
    -0.19666564f, -0.24168085f, -0.11696912f, -0.07510630f, -0.09873860f, 0.55545318f, -0.00343210f, 0.08684316f, 
    -0.04377322f, 0.25334519f, 0.03540970f, 0.07265470f, 0.12182168f, -0.74118763f, 0.02983101f, -0.15312646f, 
    -0.05157511f, -0.21197705f, 0.07459179f, 0.10505886f, 0.05489388f, -0.69833845f, -0.23017901f, 0.34127024f, 
    -0.04360252f, -0.07045109f, -0.01576838f, 0.11618955f, 0.21960641f, 0.16182034f, 0.43761459f, -0.36822540f, 
    -0.52351791f, 0.16600008f, -0.13093038f, 0.14276959f, -0.12868404f, -0.16239111f, 0.18863243f, -0.15191957f, 
    0.20756465f, 0.25271171f, -0.03760123f, -0.16260219f, -0.09156164f, -0.00795663f, -0.04702699f, 0.00274173f, 
    -0.10955091f, -0.13828738f, 0.45436892f, -0.03931578f, -0.07229269f, 0.03083131f, 0.08843201f, 0.17078908f, 
    -0.00986865f, -0.46150056f, 0.01446104f, 0.79965365f, -0.13933507f, 0.19464314f, 0.26949596f, 0.07604117f, 
    0.03937239f, 0.22789799f, -0.06378128f, -0.26829085f, 0.02136466f, -0.01555597f, 0.18234089f, 0.01831101f, 
    0.23835520f, 0.18012677f, 0.04283760f, -0.00690441f, -0.37118867f, -0.20879625f, -0.05347892f, -0.18977566f, 
    -0.13552190f, -0.16429722f, 0.26052955f, 0.27603391f, -0.06871487f, 0.17951249f, -0.08463214f, -0.02361655f, 
    0.24164648f, 0.06841093f, 0.25094828f, 0.12752801f, 0.28618744f, -0.34902894f, 0.27585515f, 0.41471869f, 
    0.10665028f, 0.05757532f, 0.28026402f, 0.05199242f, 0.08135677f, -0.13163529f, 0.04717169f, -0.61330026f, 
    -0.16214824f, 0.00070199f, 0.15312316f, -0.34339768f, -0.15434854f, -0.04495597f, -0.08821470f, -0.23999467f, 
    0.22188865f, -0.11580501f, -0.10300993f, 0.00720043f, -0.14984582f, 0.22844683f, 0.20553592f, 0.11904200f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.01490311f, 0.45807943f, 0.20328684f, -0.16251700f, 0.00308404f, -0.03115900f, 0.33222142f, 0.52872223f, 
    -0.16714011f, 0.61917824f, 0.23098944f, -0.05296478f, 0.00851048f, -0.26217842f, 0.25649008f, 0.38955671f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.16419528f, -0.60329276f, 0.29676133f, 0.10180087f, -0.01341876f, 0.01927496f, 0.17942636f, -0.33918929f, 
    0.01284519f, -0.39406893f, -0.22565676f, -0.10229480f, 0.11716582f, 0.88085926f, 0.13895932f, -1.38225162f, 
    -0.08499578f, 0.31042197f, -0.12792426f, -0.24245667f, -0.06901982f, -0.11071035f, 0.26124734f, 0.25517073f, 
    -0.70526028f, -0.01796374f, 0.34006307f, -0.09255644f, -0.15640289f, 0.71624911f, 0.16847435f, -0.37146258f, 
    -0.25858638f, 0.95690727f, -0.70138252f, 0.38704872f, 0.04591059f, 0.00404140f, -0.51608533f, -0.42951360f, 
    -0.22063358f, -0.08163646f, -0.03422726f, -0.05710787f, -0.04732938f, -0.48698556f, -0.42280659f, 0.57204902f, 
    0.22038198f, 0.26050615f, 0.39211157f, 0.56378800f, 0.16129617f, 0.03939675f, -0.75477368f, -0.54663002f, 
    0.38271391f, -0.63537687f, -1.16670942f, -0.07249750f, -0.02401588f, -0.32106045f, -0.31716079f, -0.07610829f, 
    0.19663762f, -1.04264545f, 0.25754809f, -0.09855353f, -0.11249890f, -0.08750368f, 0.04565561f, 0.14735325f, 
    0.30289596f, -0.56489503f, -0.08442710f, -0.10860303f, -0.24605319f, -0.14368948f, 0.76187170f, -0.35141104f, 
    -0.12560631f, -0.80243468f, 0.10602418f, -0.05916345f, 0.22173961f, 0.12871999f, -0.13066420f, 0.21506016f, 
    -0.39534619f, 0.11350219f, 0.06329080f, 0.10213628f, -0.25814494f, -0.08920895f, 0.52519339f, 0.03520614f, 
    0.01169023f, 0.32981980f, -1.63165116f, 0.19629741f, -0.10284061f, 0.13579151f, -0.27245766f, -0.36959434f, 
    0.03182814f, 1.13805640f, -0.00096440f, -0.03312713f, 0.04558400f, -0.82056993f, -1.43637824f, -0.21937697f, 
    -0.23556055f, 0.11366913f, -0.10976433f, -0.12919708f, -0.12751701f, -0.07296643f, 0.73914921f, -0.37557855f, 
    0.36866146f, -0.58405566f, -0.21328035f, 0.13301763f, -0.04833465f, 0.70329958f, -0.80033708f, -0.03672550f, 
    0.07804750f, 0.63605314f, 0.30751911f, -0.48797214f, -0.20457175f, 0.03091975f, 0.57539624f, -0.36712518f, 
    -0.54201788f, 0.03759570f, 0.43682665f, -0.22893170f, 0.13360055f, 0.26652050f, -1.17599702f, 0.23070997f, 
    -0.13351549f, -1.54993677f, -0.08820815f, 0.13953823f, -0.24337168f, -0.20441154f, -0.32860756f, 0.08410501f, 
    0.17404605f, 0.91996163f, -1.20097280f, 0.22317584f, -0.14709555f, -0.67050886f, -0.23198146f, 0.37226287f, 
    -0.11795286f, 0.25404575f, 0.41469669f, -0.57972431f, 0.24104917f, 0.08237533f, -1.31341791f, 0.39722490f, 
    -0.02172347f, -0.62578273f, 1.08119357f, 0.02783544f, 0.00515661f, -0.36164242f, -0.80464560f, 0.07806957f, 
    -0.06181813f, -0.53322774f, -0.30396348f, -0.50774276f, -0.20988962f, 0.13988152f, 0.06079687f, 0.51246661f, 
    0.62312198f, -0.19337825f, -0.05116310f, -0.21754189f, 0.00540131f, -0.81701988f, -0.30185246f, 0.52255690f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.50655854f, 0.12129854f, -0.27518976f, 0.02899088f, -0.33641118f, 0.46159345f, 0.16358088f, -0.38241643f, 
    0.12503155f, -0.06316439f, 0.03167168f, 0.22355403f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
