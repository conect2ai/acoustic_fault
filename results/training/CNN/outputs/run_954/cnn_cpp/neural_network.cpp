#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.21958470f, -1.06510496f, 0.19496597f, 0.11554608f, -0.62458366f, 0.38575688f, 0.02247898f, 0.51584393f, 
    -0.38681304f, 0.18940820f, -0.44430014f, -0.25411975f, -0.47655326f, -0.10117931f, -0.29181260f, 0.16721174f, 
    0.41750845f, 0.01726984f, -0.19502357f, 0.06832814f, -0.01777814f, 0.23037872f, -0.07201214f, -0.28516161f, 
    -0.01873820f, -0.47825521f, -0.87386650f, 0.27240774f, 0.96277928f, -0.41241387f, -0.70285118f, -0.12217872f, 
    0.80266219f, -0.44575396f, -0.10668302f, 0.32023093f, 0.28256807f, 0.11667039f, 0.13399369f, 0.31606928f, 
    0.05594872f, 0.32888061f, -0.05106102f, -0.06499005f, -0.37138426f, 0.13173684f, -0.21725042f, -0.15786849f, 
    0.11515256f, 0.12479810f, -0.96293843f, 0.16483587f, -0.61654478f, 0.00015826f, -0.31868348f, 0.19327444f, 
    -0.57953238f, 0.12701252f, 0.36207181f, -0.14611213f, -0.13344143f, 0.20528805f, -0.03878433f, 0.20407556f, 
    -0.31271878f, -0.15658595f, 0.19143571f, -0.12689881f, -0.44797045f, -0.39137906f, 0.12144505f, 0.40100279f, 
    0.35363659f, -0.31537148f, 0.19106142f, 0.50902539f, -0.17136936f, -0.58502108f, -0.77794856f, -0.60949260f, 
    0.33526194f, 0.22241421f, 0.47753811f, 0.61987913f, -0.39019200f, 0.09099314f, -0.07383482f, -0.50068742f, 
    -0.13130000f, -0.00021059f, 0.34459975f, 0.16060820f, -0.07970572f, 0.07376369f, 0.13253175f, -0.03357357f, 
    0.04020192f, 0.13829555f, 0.01534454f, -0.00620311f, -0.54276353f, 0.10468967f, -0.31372562f, -0.44653335f, 
    -0.64587080f, 0.68673635f, 0.06184567f, 0.22502936f, 0.47066656f, 0.40901169f, -0.36390975f, -0.52774066f, 
    -0.29500678f, -0.21276349f, -0.34269708f, -0.13000979f, -0.13922451f, -0.26924032f, -0.29351205f, 0.23653160f, 
    -0.04815389f, -0.06043499f, -0.07873745f, -0.01775936f, -0.14215782f, 0.65565324f, 0.70533574f, -0.36725789f, 
    0.35977826f, 0.32443675f, -0.48434654f, -0.19852042f, 0.43626437f, 0.36390445f, 0.40880677f, -0.35212556f, 
    -0.15688509f, 0.35839629f, 0.17099963f, 0.17828819f, 0.39567819f, 0.27351722f, -0.06878287f, -0.35368621f, 
    0.00461588f, 0.26624379f, -0.02126507f, 0.18090062f, 0.20216128f, -0.13435999f, -0.29639319f, -0.50631684f, 
    -0.77700216f, -0.50340408f, -0.25954133f, 0.59525251f, 0.42883226f, 0.21511610f, 0.19506519f, 0.05390472f, 
    -0.51382983f, -0.07075323f, -0.20451538f, -0.02312403f, 0.03258094f, 0.07522827f, -0.12191244f, 0.28295091f, 
    0.23512267f, -0.09564812f, 0.31990317f, -0.29618984f, -0.33068290f, -0.13789335f, 0.34093460f, 1.17071044f, 
    0.65036172f, 0.32208794f, -0.51196694f, 0.07651304f, -0.23343393f, 0.08011510f, -0.33485219f, 0.41112322f, 
    0.37988356f, 0.16913429f, 0.17183392f, -0.01832742f, -0.14459839f, 0.00657852f, -0.10388346f, -0.00756356f, 
    -0.19192037f, 0.06381188f, 0.18924929f, -0.09760004f, 0.26720890f, 0.10327104f, 0.06763235f, -0.20426174f, 
    0.33729813f, 0.01312420f, 0.64516807f, 0.61757421f, -0.14144160f, 0.20851333f, -0.35518393f, -0.38887516f, 
    -0.49045402f, 0.30960369f, 0.36548281f, 0.55182058f, 0.27598271f, 0.12201193f, 0.23241086f, -0.37412396f, 
    -0.28769469f, 0.19064027f, 0.04466881f, -0.36153823f, 0.30497512f, -0.17715545f, -0.44740507f, -0.03468978f, 
    -0.02962778f, -0.23380859f, 0.43874678f, 0.76500809f, 0.24348791f, -0.56338745f, -0.65849769f, 0.48988014f, 
    -0.07881416f, 0.00200448f, -0.15030800f, 0.09091454f, 0.15317813f, -0.05657846f, 0.09845641f, -0.43284255f, 
    -0.22717574f, -0.20327181f, 0.22049648f, -0.16161783f, -0.43409547f, -0.12563649f, 0.07961486f, -0.15061615f, 
    0.10710214f, -0.25616452f, 0.59205240f, 0.46781906f, -0.72906214f, 0.43699726f, -0.54371047f, -0.55847937f, 
    -0.23270223f, 0.52364707f, 0.33843100f, -0.07989928f, -0.34418607f, -0.39452440f, 0.31881410f, 0.15174685f, 
    0.17316143f, 0.17624643f, -0.33399636f, -0.04381076f, -0.16241260f, 0.41589990f, 0.20456830f, -0.25034469f, 
    0.31181684f, -0.26450482f, -0.32833955f, -0.12901577f, -0.78816158f, -0.82738441f, -0.43826312f, -0.23149838f, 
    -0.77164173f, 0.02653158f, 0.32420453f, -0.34756091f, 0.24929364f, 0.28295749f, -0.21760909f, 0.06810810f, 
    -0.39589196f, 0.34047008f, 0.18713939f, 0.15048859f, 0.15593441f, -0.14564021f, -0.00745506f, 0.04340229f, 
    -0.10342597f, 0.01482342f, 0.40033603f, 0.02935768f, 0.93579400f, 0.69422215f, 0.14371102f, 0.06023591f, 
    -0.59532005f, -0.06969428f, -0.12458368f, -0.08315398f, 0.22003669f, 0.18708941f, 0.34997386f, 0.09343803f, 
    0.08105827f, 0.01692578f, -0.47281253f, -0.22681440f, 0.12218415f, 0.12452786f, -0.20156972f, -0.32527718f, 
    0.14865336f, -0.20074615f, -0.39287013f, -0.01579970f, 0.10988896f, 0.84626460f, -0.52771878f, -0.48964587f, 
    -0.40952975f, 0.12689842f, 0.74617910f, 0.41979760f, 0.11746691f, 0.14782917f, 0.32775575f, -0.44070125f, 
    0.63887006f, -0.48256600f, 0.07834489f, 0.29184675f, 0.05091114f, 0.01821844f, -0.03659141f, 0.11650044f, 
    0.10206511f, -0.11227398f, -0.16440630f, -0.16118969f, 0.18175898f, -0.14879619f, -0.27076828f, 0.79619139f, 
    0.77000123f, -0.65557092f, 0.03675048f, -0.53017879f, 0.36098418f, 0.23167023f, 0.26220334f, 0.43020260f, 
    -0.15505812f, 0.28672779f, -0.59613079f, -0.31334072f, -0.20324481f, 0.01415389f, -0.09462348f, -0.07547373f, 
    0.09486628f, -0.06092818f, 0.11043986f, 0.04921456f, 0.14560822f, -0.04749873f, 0.29757956f, -0.40300912f, 
    0.39435130f, 0.56775600f, 0.50659603f, 0.13919590f, 0.63444799f, 0.11547727f, -0.79257119f, -0.56111711f, 
    -0.65399307f, 0.40948734f, 0.16750839f, -0.29277802f, -0.04759603f, -0.25805366f, -0.25953656f, -0.20551942f, 
    -0.19995487f, -0.03851611f, -0.11924911f, 0.18471186f, 0.14919691f, -0.01837831f, -0.07436918f, -0.02920960f, 
    -0.71613777f, 0.27564290f, 0.56360847f, -0.11280027f, 0.01088639f, -0.40155309f, -0.19668567f, -0.50718462f, 
    0.13238591f, 0.55357331f, -0.32071468f, 0.40673420f, -0.28768140f, 0.07268894f, -0.00288566f, -0.51754516f, 
    -0.26009688f, 0.24135874f, -0.09295423f, -0.26440194f, 0.30501801f, -0.14721039f, -0.32094997f, 0.17479979f, 
    -0.29303807f, 0.76209337f, 0.67682528f, 0.16680725f, -0.55080539f, -0.16212660f, 0.29507387f, 0.01578888f, 
    0.17729512f, 0.07512259f, 0.42108658f, -0.21436559f, 0.22498386f, 0.24337611f, -0.00097719f, 0.16483425f, 
    0.05408615f, 0.11874823f, 0.17154971f, 0.12149247f, -0.19718486f, -0.49641335f, -0.27554882f, -0.10198457f, 
    -0.35532320f, 0.39933294f, -0.06245882f, 0.91302788f, -0.55912322f, -0.62992597f, 0.37886989f, 0.67814368f, 
    -0.45654362f, -0.72962397f, -0.04734682f, -0.26138759f, 0.25832507f, 0.05166434f, -0.01473200f, 0.11575782f, 
    0.15064976f, -0.13729092f, 0.14890832f, 0.38583526f, 0.01972673f, 0.19780676f, 0.32911733f, -0.17084803f, 
    -0.14061671f, -0.23750316f, -0.15402879f, 0.90693778f, -0.04583661f, -0.27633271f, 1.04127192f, 0.32535404f, 
    -0.06970005f, -0.04725252f, 0.53947687f, -0.29791862f, 0.00086843f, 0.08164617f, 0.16567509f, 0.44749781f, 
    -0.24500294f, 0.15827398f, -0.20452894f, -0.09642559f, -0.00141668f, -0.20674452f, -0.01908760f, -0.28493497f, 
    0.03174982f, -0.07460684f, 0.28270194f, 0.07371468f, 0.45487496f, -0.16836607f, -0.71075130f, -0.38872027f, 
    -0.04011025f, 0.16599499f, 0.54915106f, -0.26276803f, -0.25394171f, -0.46628463f, 0.34689644f, 0.20364138f, 
    0.28692365f, -0.01961311f, 0.30807745f, -0.18952081f, -0.09147682f, 0.28583613f, 0.09696551f, 0.33066350f, 
    0.15071367f, 0.02868516f, -0.16540042f, -0.07451502f, 0.09999647f, -0.66184902f, -0.84303015f, 0.46295580f, 
    0.23969139f, 0.33400235f, 0.61934894f, 0.71279508f, -0.21495007f, 0.20158276f, -0.68611914f, 0.17669715f, 
    -0.05062150f, -0.17688023f, 0.51055682f, 0.40085191f, 0.12945060f, 0.13417687f, -0.36960146f, -0.36280420f, 
    0.22698052f, -0.01188679f, 0.04937990f, -0.13137731f, 0.19591115f, 0.39241901f, 0.25819799f, -0.73721790f, 
    -0.96325248f, -0.35344824f, -0.18718848f, -0.57881451f, 1.02130377f, 0.63569951f, -0.48193389f, 0.30985227f, 
    0.36557546f, -0.10224543f, 0.30770984f, -0.10036674f, -0.19243491f, -0.29365975f, 0.11560095f, -0.03140759f, 
    -0.08997258f, -0.06772332f, -0.12615977f, 0.01002246f, 0.25858843f, -0.13662390f, 0.10685732f, 0.21234094f, 
    -0.64952946f, -0.52203077f, -0.40081593f, 0.10449368f, -0.22864904f, -0.84214967f, -0.39706287f, 0.10997256f, 
    -0.16690296f, -0.18553038f, -0.40847671f, 0.46440464f, -0.19450755f, -0.31104213f, 0.28776267f, 0.16595407f, 
    0.04161121f, 0.34549710f, 0.24805693f, -0.15030447f, 0.19822448f, 0.22454311f, -0.04771914f, -0.39605379f, 
    -0.82261670f, -0.23685713f, -0.25387439f, -0.41400936f, -0.28868720f, -0.60897428f, 0.51366049f, 0.32019740f, 
    -0.04309924f, 0.11564566f, 0.21718930f, 0.33574444f, 0.38536826f, -0.04116453f, -0.00054047f, -0.44841525f, 
    -0.19881427f, 0.52402806f, -0.31208652f, -0.28004733f, 0.44715515f, 0.45621839f, -0.16843522f, 0.16054444f, 
    -0.26434866f, -0.76120400f, 0.48548886f, 0.17894530f, -0.56769329f, -0.01370536f, -0.55165923f, -0.20619787f, 
    0.16506293f, 0.39049459f, -0.25819868f, -0.08037259f, -0.10837948f, -0.56567550f, 0.09285247f, -0.26674154f, 
    -0.32754806f, 0.17941733f, -0.28009123f, -0.03065218f, 0.32593387f, 0.16303785f, 0.39564577f, -0.10182716f, 
    -0.04439810f, -0.44669440f, 0.51192564f, 0.57606345f, 0.67489600f, -0.01286490f, -0.59846514f, 0.20412827f, 
    -0.14428113f, 0.16553815f, -0.12401353f, 0.69570756f, 0.44125283f, 0.27877790f, -0.34638292f, -0.23257746f, 
    0.05878564f, 0.15296589f, 0.02643253f, -0.35675812f, -0.12679072f, 0.08013284f, -0.22210789f, -0.02410424f, 
    0.29631859f, -0.12037951f, -0.23110840f, -1.26894069f, 1.14042461f, -0.07885070f, -0.47455496f, -0.28476310f, 
    0.11360824f, 0.41773668f, -0.09971780f, 0.36308709f, -0.37551054f, -0.27213064f, 0.14540456f, -0.14608367f, 
    -0.00755183f, -0.18766627f, -0.13563059f, 0.04590218f, -0.11493234f, -0.20102693f, -0.12935354f, -0.01586702f, 
    -0.18829010f, -0.02371495f, 0.13373746f, 0.03088125f, 0.56970805f, 0.30723149f, 0.38702846f, 1.02609921f, 
    0.26626524f, 0.22928175f, 0.37543720f, 0.31584048f, 0.25814614f, -0.05420696f, -0.41988745f, -0.13998677f, 
    0.11096799f, 0.05678209f, -0.27510092f, 0.03350658f, -0.31659928f, -0.07227178f, -0.25367492f, -0.31237471f, 
    0.24975286f, -0.47041291f, -0.36969388f, 0.18143949f, 0.00770325f, -0.57693684f, 0.34275725f, -0.42874900f, 
    0.29555851f, 0.76365286f, 0.13722859f, 0.59760934f, 0.64477146f, 0.00866217f, 0.36692587f, -0.09925902f, 
    -0.13276851f, 0.14971532f, -0.03296405f, 0.36145261f, -0.15069267f, -0.00561489f, 0.17881534f, 0.19218843f, 
    0.17877726f, 0.13106409f, 0.14098430f, 0.06883065f, 0.35140213f, -0.46385887f, -0.52559984f, 0.12039566f, 
    -0.57782763f, -0.10306356f, -0.70103878f, 0.25556380f, 0.49189410f, -0.66275287f, 0.27887243f, 0.55695838f, 
    0.30431703f, 0.16865450f, 0.20171133f, 0.02527027f, 0.03363274f, 0.14152187f, -0.17262354f, 0.35642737f, 
    0.25706357f, -0.16135086f, 0.02308196f, -0.33817634f, -0.02607678f, -0.09699503f, 0.20066519f, -0.06786884f, 
    -0.55700815f, 0.58929384f, 0.68302697f, -0.17373708f, -0.66500938f, -0.33306640f, 0.23116180f, -0.02578492f, 
    0.04869472f, -0.04711680f, -0.24027868f, -0.35745347f, 0.19990872f, -0.55527782f, 0.25674331f, -0.01184701f, 
    -0.04475322f, -0.31334287f, 0.14993335f, -0.28635818f, -0.27222282f, 0.23422509f, -0.15526271f, -0.19894521f, 
    -0.21665873f, -0.04459963f, -0.55401903f, -0.80929679f, 0.08462423f, -0.35468337f, -0.48895693f, -0.03530230f, 
    -0.26478392f, -0.72964174f, -0.03664658f, 0.52317441f, -0.00801153f, 0.10825425f, 0.06146867f, -0.01303391f, 
    0.07507184f, 0.13768943f, 0.26125681f, 0.29866576f, -0.34155273f, 0.07755121f, 0.03385294f, -0.23013975f, 
    -0.10126676f, -0.60018009f, 0.37431452f, 0.90190333f, -0.53250998f, -0.57715464f, -0.21927959f, -0.05852754f, 
    0.28072020f, -0.56971323f, -0.41373754f, 0.05933758f, 0.46093693f, -0.19149631f, 0.49439824f, -0.19142745f, 
    0.16113587f, 0.28785393f, -0.17245041f, -0.00905472f, 0.33313903f, -0.07750888f, 0.04684066f, 0.12268087f, 
    -0.01076795f, 0.11851339f, 0.43947345f, 0.63857961f, 0.61027569f, 0.41583562f, 0.72651285f, 0.37567294f, 
    0.40818676f, 0.38450095f, -0.38645771f, -0.15766484f, 0.22896193f, -0.16143751f, -0.29292649f, -0.05323459f, 
    0.12851134f, -0.13893352f, -0.09244288f, 0.19364497f, 0.20045552f, 0.04799958f, 0.28465861f, 0.00326211f, 
    0.35631445f, 0.20998314f, 0.39776126f, 0.76318049f, 0.84890133f, 0.66217345f, 0.52318478f, 0.38987735f, 
    -0.01266465f, -0.72012269f, -0.37260702f, -0.11144626f, -0.20476097f, 0.16396470f, 0.44627473f, 0.05067443f, 
    0.13844742f, -0.02979022f, 0.28147838f, -0.14125957f, 0.38583082f, 0.25652486f, 0.16413616f, -0.16984795f, 
    0.40276974f, -0.06462806f, 0.05319870f, 0.37769374f, -0.38961685f, -0.67529589f, -0.47952154f, -0.37540117f, 
    -0.30977631f, -0.10458943f, 0.76709116f, -0.09021704f, -0.20913407f, 0.44663990f, -0.46773881f, 0.21988857f, 
    -0.12792186f, 0.09993640f, 0.02253824f, 0.06604881f, -0.25810239f, -0.11659693f, -0.28015080f, -0.24882159f, 
    -0.21752396f, -0.23319995f, -0.38436049f, -0.03021033f, -0.30223760f, -0.65089726f, -0.58874100f, -0.71257168f, 
    0.10517330f, 0.11087643f, 0.22360595f, 0.12110928f, 0.01341840f, 0.36020398f, 0.25052965f, -0.03834367f, 
    -0.05687142f, 0.19884717f, -0.37216502f, -0.14834087f, -0.21607819f, 0.10164014f, 0.28813368f, 0.15928368f, 
    0.00611365f, 0.28310916f, 0.20339642f, -0.16447182f, 0.19630426f, -0.06922132f, 0.54336745f, -0.07535599f, 
    0.14610970f, 1.04927754f, 0.76272160f, 0.38364023f, 0.19553280f, -0.13974784f, -0.11014193f, 0.09132119f, 
    0.03952913f, 0.06308872f, 0.11340140f, -0.09162963f, -0.12531580f, 0.21681373f, 0.43984237f, 0.30537254f, 
    0.16082992f, 0.45414448f, 0.12528825f, 0.25710383f, -0.35632864f, -0.33087915f, -0.12007940f, -0.69145322f, 
    -0.99544448f, 0.01894741f, 0.45188081f, 0.07177355f, 0.36169773f, 0.89591634f, 0.58844608f, -0.49342245f, 
    -0.17724693f, 0.09797650f, -0.14750262f, -0.21758407f, 0.04562357f, 0.02227355f, -0.41121957f, -0.01033495f, 
    -0.30031189f, 0.06776507f, -0.32104453f, -0.32840419f, 0.23964308f, 0.04384215f, -0.11482419f, 0.07129153f, 
    -0.97155881f, 1.18837094f, 0.14279024f, -0.89379990f, 0.91023815f, 0.19527225f, 0.35321960f, -0.35712093f, 
    -0.14883925f, -0.24296224f, -0.08649599f, -0.08514300f, -0.04503884f, -0.21039782f, -0.09560548f, 0.16693062f, 
    -0.02853311f, -0.05711314f, -0.24547595f, -0.24798429f, 0.01478851f, 0.03348884f, 0.08092220f, 0.09610254f, 
    0.02974056f, -0.04637874f, 0.72953057f, 0.38044432f, 0.28805649f, 0.45113316f, 0.48786148f, -0.42277202f, 
    -0.45976463f, -0.52253675f, 0.41219944f, 0.31755722f, -0.48110116f, 0.09331448f, -0.24762200f, -0.27442735f, 
    0.05083404f, 0.11593328f, -0.31182557f, -0.02264586f, 0.14979185f, 0.16699204f, 0.25399688f, 0.05947276f, 
    0.12256090f, -0.22186980f, -1.02280116f, -0.15991934f, 0.13604888f, -0.26390186f, 0.19005691f, 0.67253178f, 
    0.39375243f, 0.28754690f, 0.20533782f, 0.17966469f, 0.57066447f, -0.27736074f, -0.06626398f, -0.20961596f, 
    0.20844232f, -0.37518689f, -0.12580505f, -0.10943072f, -0.21494003f, -0.19421339f, 0.07077734f, 0.03859191f, 
    0.38221601f, -0.09689167f, -0.29035136f, 0.77237481f, 0.47701445f, 0.01049569f, -0.69134897f, -0.60107821f, 
    0.12210501f, -0.40019545f, -0.09519608f, -0.28821778f, 0.09754924f, 0.16871597f, -0.09371734f, 0.31340146f, 
    0.31615254f, -0.01159751f, 0.33538017f, -0.30655020f, 0.19524099f, 0.18908201f, 0.18368144f, 0.30432239f, 
    0.17066427f, -0.02462208f, -0.21515240f, 0.43153942f, -0.47981620f, -0.71644318f, -0.32115340f, -0.51128185f, 
    0.35864502f, -0.76756251f, -0.19184227f, 0.22363323f, -0.07911097f, -0.04900200f, 0.24698085f, 0.34402305f, 
    0.24133395f, -0.11453579f, 0.29567876f, -0.15396027f, 0.01185699f, -0.22796990f, -0.30227712f, 0.24990173f, 
    0.15512221f, -0.43249357f, 0.23009734f, -0.17326607f, 0.38813803f, 0.17104156f, 0.28239357f, 0.04997126f, 
    -0.19114599f, 0.64951158f, 0.46603689f, -0.52365923f, -0.94592041f, -0.51609755f, -0.44898295f, 0.33553013f, 
    -0.04938717f, -0.15711387f, 0.40872723f, -0.19585209f, 0.08824880f, 0.12370523f, 0.23868406f, -0.25536880f, 
    -0.28081748f, -0.14510132f, 0.08526970f, 0.26036432f, 0.15995102f, 0.23674293f, -0.16595250f, 0.00922878f, 
    -0.33646798f, -0.12805733f, -0.14780349f, -0.60779423f, -0.61150438f, -0.52048922f, -0.14651498f, 0.31493655f, 
    0.54112822f, 0.00045372f, -0.36367238f, -0.13216819f, -0.23894815f, 0.01850309f, 0.25954080f, -0.00859460f, 
    0.23471792f, 0.38242158f, -0.13927874f, -0.11596967f, 0.25317144f, -0.15741074f, 0.26904979f, -0.11542476f, 
    -0.41775158f, 0.12126991f, 0.62402523f, 0.06234327f, 0.27489176f, -0.30689669f, -0.57150149f, -0.50220001f, 
    0.18243104f, -0.33310032f, 0.33783394f, -0.11883915f, 0.02907601f, 0.24164255f, -0.36335942f, -0.37456799f, 
    0.27430299f, 0.19868082f, -0.09734240f, 0.25233459f, -0.03126941f, 0.24978793f, -0.08427323f, -0.46547776f, 
    -0.34262219f, -0.69524467f, 0.14115614f, 0.71035212f, 0.17105643f, -0.88571000f, 0.25757924f, -0.54156798f, 
    -0.52670097f, 0.09198067f, 0.35002339f, 0.38631523f, -0.21601565f, -0.06114241f, 0.07084724f, -0.27507380f, 
    0.12247088f, 0.20677835f, -0.22235641f, 0.37980074f, -0.19153967f, -0.21001704f, 0.31896397f, 0.41938603f, 
    -0.18344353f, 0.65167308f, -0.23179387f, 0.39515561f, 0.82511073f, 0.54020011f, -0.58170450f, 0.11372145f, 
    -0.46438569f, -0.47064915f, -0.08576767f, -0.19073682f, -0.37731472f, -0.08506694f, 0.09251438f, -0.10088503f, 
    -0.23486568f, 0.10880476f, 0.08468581f, 0.18205962f, -0.40074554f, -0.27347770f, -0.13047260f, -0.36925140f, 
    -0.24879450f, -0.01772163f, 0.90576327f, -0.34490427f, 0.82133037f, 0.49078712f, -0.29455709f, 0.61611813f, 
    -0.71823633f, -0.19624808f, 0.11479693f, -0.11365176f, 0.19804208f, 0.15037575f, -0.17375551f, 0.03739530f, 
    -0.18779680f, 0.14210890f, 0.02902326f, 0.10386989f, 0.00703758f, 0.29560801f, 0.37237933f, 0.45875680f, 
    0.19491000f, 0.05818444f, 0.37336242f, -0.79961485f, 0.26369765f, 0.17373453f, 0.62275541f, 0.24113639f, 
    0.10740249f, 0.74137926f, -0.15466578f, 0.35682672f, 0.34120548f, -0.31672040f, -0.48205948f, 0.18157935f, 
    0.00163991f, 0.28322670f, 0.51776880f, 0.15014751f, -0.29832259f, 0.49528658f, 0.27319515f, -0.00686819f, 
    -0.04356471f, -0.39528346f, -0.19561948f, -0.12082890f, 0.72622478f, 0.26367339f, -0.53095824f, -0.92361170f, 
    -0.40740114f, 0.20979865f, 0.35558683f, 0.47244576f, 0.14165445f, -0.23954546f, -0.28434163f, 0.14721276f, 
    0.14198047f, 0.18522333f, -0.36782685f, -0.16620041f, 0.00853818f, 0.09536324f, 0.50556731f, -0.17895877f, 
    0.10970138f, -0.15837173f, -0.23313226f, -0.11927687f, 0.23831567f, -0.60877025f, -0.90394956f, -0.56620330f, 
    -0.01357273f, 0.42903608f, 0.40979409f, -0.26141763f, -0.57602161f, -0.18663867f, -0.15805802f, -0.24733868f, 
    0.43865192f, 0.27936041f, 0.20221749f, 0.27769783f, -0.00939444f, -0.22826029f, -0.28808773f, -0.29796585f, 
    0.09126195f, 0.02370599f, 0.10702523f, 0.30675077f, -0.00110528f, -0.07488176f, 0.31183276f, 0.07598140f, 
    0.42646486f, -0.01349696f, 0.81420797f, -0.79232609f, -0.57287472f, -0.25741252f, -0.57906127f, -0.73583680f, 
    -0.03641276f, -0.00992367f, 0.27788162f, 0.30729625f, 0.21071216f, 0.13890341f, -0.01153798f, 0.03084340f, 
    0.08450923f, 0.19655739f, 0.13848965f, -0.06327204f, -0.02069411f, 0.06097766f, 0.23371239f, -0.28738520f, 
    -0.98592204f, -0.38376904f, 0.19260925f, 0.10984014f, -0.16976498f, 0.72073966f, 0.72882080f, -0.24987864f, 
    0.54498482f, -0.02729767f, -0.26919284f, -0.38516468f, -0.19863006f, -0.29413325f, -0.03532149f, -0.26048899f, 
    -0.24035646f, -0.21617971f, -0.14144936f, -0.02558594f, 0.07837617f, -0.04926612f, 0.28602326f, 0.09912518f, 
    0.27011204f, -0.53412700f, 0.40047309f, 0.71253538f, 0.58474761f, 0.53838295f, 0.40450642f, 0.31139228f, 
    -0.15089838f, 0.33868322f, 0.09591495f, -0.17340368f, 0.00899637f, -0.00686557f, -0.34100494f, -0.40316072f, 
    -0.05620474f, -0.12464080f, 0.09750818f, -0.37986115f, 0.24770392f, 0.29384178f, -0.01048827f, -0.27374753f, 
    -0.00095597f, 0.31314525f, 0.40308937f, 0.66082883f, 0.66584468f, 0.12668051f, -0.10000756f, 0.24433587f, 
    0.25799370f, 0.42517951f, 0.37797618f, -0.29244533f, 0.03800252f, -0.00867396f, 0.22963583f, -0.30416211f, 
    -0.35479206f, -0.17558075f, -0.09531562f, -0.12883572f, -0.22724736f, -0.46540949f, 0.21468957f, -0.29887432f, 
    0.10264209f, 0.22026722f, 1.16254437f, 0.64003301f, 0.60161585f, 0.87028265f, 0.86009872f, 0.12484500f, 
    0.09599580f, -0.23540635f, 0.53916937f, -0.38779894f, 0.08182877f, 0.00199896f, -0.12178952f, -0.06181926f, 
    -0.01817217f, 0.06452809f, -0.16978045f, 0.06333064f, 0.06660729f, 0.20672819f, -0.06104880f, -0.15488212f, 
    0.25448373f, -0.18329306f, -0.08920630f, 0.34931049f, -0.07180862f, -0.72347581f, -0.72306216f, -0.02103895f, 
    0.18184061f, -0.29172093f, 0.04783572f, 0.57994306f, 0.62851065f, -0.24427435f, -0.29077262f, -0.20670795f, 
    -0.33095220f, 0.21616392f, 0.03806496f, -0.04976680f, -0.32764375f, 0.16596355f, 0.31573111f, 0.08419813f, 
    -0.15476961f, -0.01761369f, -0.17848423f, -0.54753649f, 0.80594575f, 0.19347921f, 0.47158056f, -0.47101459f, 
    -0.37459275f, 0.30529505f, -0.65411365f, -0.04017957f, -0.76469451f, -0.41350773f, 0.23049663f, 0.38808230f, 
    0.34631917f, 0.04373654f, 0.03636441f, 0.26044625f, -0.23220280f, -0.28751159f, 0.03486185f, -0.48399436f, 
    0.02890541f, 0.19490701f, 0.30310726f, -0.10649946f, 0.21091776f, -1.11575651f, 0.76608169f, -0.21788113f, 
    -0.54875505f, -0.45998931f, -0.02733290f, 0.78843981f, 0.00253156f, -0.01402006f, 0.36434737f, -0.35342389f, 
    -0.02176521f, 0.15846203f, -0.19846286f, 0.37563163f, 0.15313485f, -0.07087606f, -0.12861015f, 0.03175059f, 
    -0.05490038f, 0.27344713f, 0.30512643f, 0.32719386f, 0.17887792f, 0.34650454f, -0.24135676f, -0.25410223f, 
    -0.45171916f, -0.06254084f, -0.43172553f, 0.71450776f, 0.55195582f, -0.22964412f, 0.70142978f, 0.45510691f, 
    0.14304715f, 0.11446448f, -0.05990571f, 0.02402332f, -0.05550878f, 0.04000542f, 0.21250932f, -0.24762465f, 
    0.17045884f, -0.08521356f, -0.19278601f, -0.38515854f, -0.17085591f, 0.06567088f, -0.33689135f, 0.33986700f, 
    -0.20268473f, 0.29461205f, 0.62075704f, 0.44612980f, 0.09580054f, 0.45382205f, 0.61663860f, 0.32468942f, 
    -0.09190040f, 0.11031510f, -0.29053083f, -0.41186553f, -0.24800850f, -0.46435106f, 0.26745403f, 0.14592636f, 
    -0.22556041f, 0.50452852f, -0.09359837f, -0.27660057f, 0.04010354f, 0.22948399f, 0.31131461f, -0.38539633f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00902306f, 0.10860278f, 0.18153855f, 0.10747059f, -0.18206310f, 0.19991049f, -0.08632856f, 0.07148736f, 
    0.13750881f, 0.08013300f, 0.12124549f, 0.17268275f, 0.25816622f, 0.12553133f, 0.23246002f, -0.01112500f, 
    0.00947793f, 0.27335507f, 0.18250574f, 0.03015676f, 0.19948763f, -0.02220571f, 0.20362170f, 0.07411390f, 
    0.22322503f, 0.06356529f, 0.15133871f, 0.16677585f, 0.15159433f, 0.14334366f, 0.11945511f, -0.04387305f, 
    0.06764609f, 0.30251122f, 0.32321486f, 0.00678220f, -0.09162185f, 0.15917361f, -0.00629371f, 0.12812920f, 
    0.10645689f, 0.09639363f, 0.07118971f, 0.23795891f, 0.26055649f, 0.04545202f, 0.36176282f, 0.16113503f, 
    0.05800400f, -0.16496150f, 0.13007537f, 0.01454063f, -0.05636682f, 0.21741578f, 0.30684498f, 0.05602471f, 
    0.03983792f, 0.20263676f, 0.31797990f, 0.14575391f, 0.20566300f, 0.07472108f, -0.12394448f, -0.06273443f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03781978f, 0.03701225f, 0.11731248f, 0.04498152f, 0.00485976f, 0.03732778f, 0.03468118f, 0.07285487f, 
    -0.05066776f, 0.00198398f, 0.00782528f, 0.03664134f, -0.22120157f, -0.04860101f, -0.12147225f, 0.25159547f, 
    0.08160724f, 0.05486806f, 0.05609621f, -0.04444944f, 0.03234605f, 0.02168498f, 0.01039981f, -0.06762507f, 
    0.21107450f, -0.10134268f, -0.13652514f, -0.09989742f, 0.07373338f, -0.11872597f, -0.04764414f, 0.07813505f, 
    -0.04600940f, 0.04636221f, -0.05863386f, -0.12390431f, 0.13320617f, 0.06612599f, -0.04958478f, -0.29283938f, 
    -0.00234798f, 0.10552415f, -0.02929785f, -0.16691868f, -0.03903177f, 0.06095504f, 0.11023742f, -0.05662115f, 
    0.27587828f, -0.00759884f, -0.00755717f, -0.02529475f, 0.01536003f, 0.13171089f, 0.04438753f, -0.01537351f, 
    -0.02805261f, 0.05264551f, -0.02258381f, 0.02580217f, 0.01602242f, -0.02317592f, -0.01537270f, 0.00809300f, 
    -0.10231374f, 0.05072090f, -0.00796936f, -0.00569525f, -0.06147565f, 0.07009989f, 0.00839104f, -0.05719157f, 
    0.09132064f, 0.00016134f, -0.03066277f, -0.25173122f, 0.01494097f, -0.00944326f, 0.06002619f, 0.07132234f, 
    0.04249073f, -0.00082693f, 0.01200324f, 0.11831424f, 0.14975235f, 0.11033030f, -0.00395023f, -0.31838632f, 
    -0.03470414f, -0.00382501f, 0.00549995f, 0.10599606f, 0.04789924f, -0.03689390f, 0.06891800f, -0.00056764f, 
    -0.12584561f, -0.03573710f, -0.09021726f, 0.09165370f, -0.20002006f, -0.00152962f, 0.12512764f, -0.10480396f, 
    -0.05625937f, 0.08124296f, -0.09603421f, -0.10236285f, -0.05358900f, -0.05685486f, -0.02864614f, 0.18329668f, 
    -0.07383465f, 0.01591548f, 0.04309710f, -0.14157820f, 0.01329023f, 0.05731053f, 0.00464528f, -0.04144586f, 
    -0.14015917f, 0.05272526f, -0.11044807f, -0.03821950f, -0.12897263f, 0.08253315f, 0.01375343f, 0.03397462f, 
    -0.02509438f, 0.01516540f, 0.06296404f, 0.01506666f, -0.51986742f, -0.08812775f, -0.08332437f, -0.13161555f, 
    0.11512131f, 0.02699148f, -0.02321828f, -0.01117583f, -0.00896530f, -0.04614756f, 0.01671457f, 0.05348353f, 
    -0.12114329f, 0.04988538f, -0.09761440f, -0.08693247f, 0.04830467f, -0.07696887f, 0.00630610f, -0.09586055f, 
    -0.01572424f, 0.06286373f, -0.05077864f, -0.05598236f, 0.21549889f, -0.10161768f, 0.03965858f, -0.19729708f, 
    -0.05366618f, 0.03627086f, -0.03571527f, 0.02480816f, -0.04095480f, -0.00267996f, 0.08347169f, 0.00067915f, 
    -0.12653773f, 0.04260910f, 0.06896324f, -0.02888512f, -0.01691819f, -0.02408494f, -0.04569249f, -0.17527464f, 
    0.02129661f, -0.06186774f, -0.00852774f, -0.03326465f, -0.17879923f, 0.22812210f, 0.11731291f, -0.02025900f, 
    -0.03621617f, -0.14141412f, 0.00105536f, -0.03693451f, 0.00560560f, -0.00346734f, 0.00260196f, -0.03250458f, 
    -0.24387179f, -0.02535578f, 0.10258525f, 0.13824755f, -0.05797997f, -0.00686646f, 0.02766101f, -0.05843804f, 
    -0.02807766f, 0.02783143f, -0.00362665f, -0.07506815f, 0.03125697f, -0.04610965f, 0.04467040f, -0.28082541f, 
    -0.02893349f, 0.06035448f, -0.03821888f, 0.06158489f, 0.09122186f, 0.01687456f, -0.06844185f, -0.02915557f, 
    -0.03667538f, -0.04787674f, 0.15218733f, -0.09415232f, -0.17601523f, 0.03359149f, 0.11683776f, -0.02654034f, 
    0.05598520f, -0.00324154f, -0.01043400f, 0.04825585f, 0.20511815f, -0.03464020f, -0.10559019f, 0.18242826f, 
    -0.06884479f, -0.02357747f, -0.11163735f, 0.05071578f, -0.05599373f, 0.03475020f, 0.00726923f, 0.05494799f, 
    -0.42438751f, -0.09390423f, 0.04812636f, -0.06413656f, -0.06610356f, -0.04128879f, 0.09261218f, -0.01162876f, 
    -0.02224547f, 0.00408225f, -0.02636978f, 0.08823130f, -0.28917393f, 0.02576709f, 0.12576491f, 0.04832606f, 
    0.07150563f, -0.02225207f, 0.11431883f, 0.06722379f, 0.12342598f, -0.00514962f, 0.05120458f, -0.02140458f, 
    -0.53618109f, 0.26079673f, 0.04879655f, -0.16731501f, 0.02180728f, -0.02888050f, 0.03277034f, -0.06352295f, 
    0.00060387f, 0.00130839f, -0.06613504f, 0.05150538f, -0.05161806f, -0.26108697f, 0.18348111f, 0.00421639f, 
    -0.00990710f, 0.11862604f, -0.00695075f, 0.05298915f, -0.09189802f, -0.07895611f, 0.02100325f, 0.02293215f, 
    -0.17262383f, 0.01284242f, -0.12482890f, -0.05840456f, -0.00660956f, -0.06869602f, -0.01991387f, 0.06708062f, 
    -0.07623871f, -0.06973671f, -0.01393027f, 0.03795665f, -0.12850165f, -0.00237845f, -0.05107981f, 0.14422426f, 
    -0.02172598f, 0.06322902f, -0.02985982f, -0.05459641f, -0.04154610f, -0.11357303f, 0.04645832f, 0.11883155f, 
    -0.11998662f, 0.01137008f, -0.02992469f, 0.05091857f, -0.09198490f, -0.13041249f, 0.14273755f, -0.00620555f, 
    0.01099764f, 0.04514973f, 0.02840362f, 0.03929010f, 0.53373283f, 0.06913025f, 0.02789907f, -0.09015160f, 
    -0.00816999f, -0.00685539f, 0.02356064f, -0.02871678f, -0.01021762f, -0.05304605f, -0.14934650f, -0.13592881f, 
    0.04594436f, 0.05996857f, -0.10507197f, 0.20608391f, -0.01718767f, 0.01909186f, 0.13557467f, -0.00954459f, 
    -0.08494154f, 0.01288001f, 0.08226676f, -0.04224778f, -0.12686542f, 0.15796921f, 0.14878790f, 0.02074051f, 
    -0.02705215f, 0.06760845f, -0.03599134f, -0.05906085f, 0.02072927f, -0.00383080f, -0.10876571f, 0.02489030f, 
    0.41560754f, 0.02260692f, -0.12333816f, -0.11093802f, -0.06169089f, -0.07880800f, 0.03571156f, -0.03404510f, 
    0.06511939f, -0.01821929f, -0.04277496f, -0.01538620f, 0.18576056f, -0.08073192f, -0.17186771f, 0.36552650f, 
    -0.11503427f, 0.05762190f, 0.01310753f, 0.06829105f, 0.07079809f, -0.08124843f, -0.04098347f, -0.03963238f, 
    -0.17489292f, -0.12067237f, 0.07036303f, -0.12312887f, -0.01944701f, -0.02093888f, 0.04568604f, 0.03899996f, 
    -0.06418554f, -0.14150776f, -0.07938063f, -0.08389749f, -0.68800694f, 0.19831833f, 0.09206482f, 0.00757164f, 
    0.12267114f, 0.14988135f, -0.00261313f, 0.05560223f, 0.04224744f, -0.10035837f, 0.00290448f, -0.04249417f, 
    0.02440918f, -0.01578607f, 0.09502164f, -0.04455068f, -0.11866549f, -0.09048104f, 0.03030496f, -0.04366630f, 
    -0.04733034f, -0.09057769f, -0.06178251f, 0.04007035f, 0.15810400f, -0.02360295f, 0.06250980f, -0.06242827f, 
    -0.14622995f, -0.15438779f, -0.04065101f, 0.08655388f, 0.07659965f, -0.02225368f, -0.13813996f, 0.06427976f, 
    0.02823457f, -0.10576960f, 0.01387908f, -0.16029780f, -0.03242848f, 0.04034078f, 0.02944780f, 0.04868130f, 
    0.08268294f, -0.04119322f, 0.02110196f, -0.10780791f, 0.11260530f, 0.16610524f, -0.13066755f, 0.00066338f, 
    0.09038401f, -0.00731642f, 0.06578682f, 0.06424718f, 0.01303390f, -0.05821240f, -0.02834851f, -0.00064812f, 
    0.16773818f, -0.10944995f, -0.13750838f, 0.24321254f, -0.19918469f, 0.08179454f, 0.07924766f, 0.05222853f, 
    -0.03951164f, 0.06583181f, 0.02821779f, 0.06100487f, -0.18697983f, 0.22169070f, 0.12018152f, -0.12445860f, 
    0.05972188f, 0.03345510f, -0.00218547f, 0.04729501f, -0.00646475f, -0.01151359f, -0.08228824f, 0.06773140f, 
    -0.04357230f, -0.11529389f, 0.25562963f, -0.16381745f, -0.03579266f, -0.05387021f, 0.07117993f, -0.06721118f, 
    0.00590449f, -0.14984140f, -0.04072650f, -0.00404180f, 0.00695138f, 0.08307323f, 0.07965688f, -0.08534018f, 
    -0.02155116f, -0.12183826f, -0.04394271f, -0.02600947f, -0.05396710f, -0.03564607f, 0.00347568f, 0.02841112f, 
    0.15475054f, -0.04076312f, 0.12720801f, -0.06282674f, 0.04040250f, 0.06341511f, -0.08598993f, 0.00924059f, 
    -0.07155185f, 0.00016866f, 0.05388184f, 0.10105214f, -0.09184588f, 0.05770304f, 0.10314427f, -0.29193220f, 
    -0.02609293f, 0.05557112f, 0.00820916f, -0.03681620f, -0.06955700f, -0.03628594f, -0.11109289f, 0.06049449f, 
    -0.22015637f, -0.03835312f, -0.13875937f, -0.00577981f, -0.02999721f, 0.03624236f, 0.01605764f, 0.01784996f, 
    0.05303134f, 0.01000438f, 0.04072079f, -0.07546828f, -0.04787746f, 0.02054535f, 0.18581198f, -0.03633469f, 
    -0.01896030f, -0.00482118f, 0.08587459f, -0.05962591f, -0.00154138f, 0.07222225f, -0.04464310f, -0.09594642f, 
    -0.07971404f, -0.17737110f, 0.05129857f, 0.13036537f, -0.04688394f, -0.11834268f, 0.01102265f, -0.00136756f, 
    0.03635408f, -0.04992354f, -0.03614059f, -0.13072056f, -0.02782310f, -0.00334238f, 0.01139653f, 0.06230088f, 
    0.00238983f, -0.00402060f, 0.01732589f, -0.05312056f, -0.07747714f, 0.00151003f, 0.02864470f, -0.09462526f, 
    0.07255940f, -0.33666173f, -0.34715685f, 0.27461591f, 0.01525193f, -0.06525302f, -0.02880290f, 0.01210880f, 
    0.10597501f, -0.01684263f, -0.01887627f, -0.00434141f, 0.25374758f, -0.00421387f, -0.10974743f, 0.23973690f, 
    -0.18953165f, -0.03962908f, 0.11968516f, 0.02606169f, -0.05454871f, -0.04139055f, -0.04027327f, -0.04587007f, 
    0.25036836f, -0.16972607f, -0.06141115f, 0.20742092f, 0.09474211f, -0.09315485f, -0.05987419f, -0.00681599f, 
    -0.02763448f, 0.00722862f, -0.07623175f, 0.04858617f, 0.13242453f, 0.12252586f, 0.16527522f, 0.26093432f, 
    -0.11355071f, 0.09391471f, -0.00358728f, -0.06002304f, 0.03218476f, 0.03700608f, -0.15921475f, 0.07437745f, 
    -0.10670362f, 0.01840250f, 0.00156274f, -0.29542071f, 0.07010674f, -0.03062082f, -0.04936430f, -0.07952619f, 
    -0.15183678f, 0.11556129f, -0.05220160f, 0.11171990f, -0.25038931f, -0.23376253f, 0.04245854f, 0.00718445f, 
    0.08184401f, 0.03308736f, -0.03777174f, 0.00131887f, -0.07212074f, -0.05265917f, 0.10350028f, -0.12430190f, 
    0.15661854f, 0.12423261f, 0.01888199f, -0.11194251f, -0.13768046f, -0.03362729f, 0.00780488f, 0.03748624f, 
    -0.05290962f, -0.04911691f, -0.09318636f, -0.16172963f, -0.17195512f, 0.30250132f, 0.00665819f, -0.09283032f, 
    -0.05775400f, 0.12884171f, -0.12347860f, -0.05873373f, -0.05643126f, 0.05901490f, 0.01363946f, 0.00362903f, 
    -0.05495594f, 0.11060457f, 0.06165437f, 0.15490295f, 0.01831108f, 0.09396052f, 0.03776558f, -0.02398436f, 
    -0.15338477f, 0.10837938f, -0.16386507f, -0.04141513f, 0.04543249f, -0.00587986f, -0.10839336f, 0.22104074f, 
    -0.02222510f, -0.09356240f, 0.04084254f, -0.05990395f, -0.03831318f, 0.02967246f, -0.08994824f, 0.03258504f, 
    0.08973709f, 0.06900323f, -0.07385492f, 0.05467267f, -0.20508473f, -0.01142827f, -0.01240376f, 0.11648129f, 
    0.07866597f, 0.00223767f, -0.11898451f, -0.10363952f, 0.19797282f, -0.09143386f, 0.03110953f, -0.20928244f, 
    0.02679360f, -0.09658290f, 0.11894771f, -0.08407050f, -0.09207815f, -0.09823234f, 0.02186227f, 0.09840936f, 
    -0.05307475f, -0.14848408f, 0.11763421f, -0.15597391f, -0.07831210f, -0.06340442f, -0.01277898f, -0.04969987f, 
    -0.08188475f, 0.03383918f, 0.00209871f, -0.03837821f, 0.48109823f, 0.02218775f, 0.11856224f, -0.27662292f, 
    0.08437358f, 0.09621136f, -0.04871508f, 0.02883924f, 0.03898071f, -0.05664445f, -0.03352597f, 0.08799702f, 
    0.31510842f, 0.10670824f, -0.03640289f, -0.04237253f, 0.05853380f, 0.00804334f, -0.03069159f, 0.03532775f, 
    0.03189793f, 0.02776906f, -0.00362991f, 0.02973753f, 0.05528472f, 0.15189530f, -0.00808305f, 0.19145894f, 
    -0.07851081f, 0.05705451f, 0.05518755f, 0.01059060f, 0.03774530f, 0.07337660f, 0.07728703f, -0.09716977f, 
    -0.11780468f, -0.00919954f, -0.10623339f, 0.07842493f, -0.00267999f, -0.01116492f, 0.03009888f, -0.00479212f, 
    0.16909947f, 0.08648644f, -0.02776081f, -0.15475246f, -0.37560976f, 0.10130540f, -0.13130036f, 0.18174826f, 
    -0.13176224f, -0.10686924f, -0.11673547f, 0.01495551f, -0.09101086f, -0.03993025f, 0.02808064f, 0.02961326f, 
    -0.28690410f, -0.05415978f, -0.20139088f, -0.09197260f, 0.09283592f, -0.01886026f, -0.03203155f, 0.04340923f, 
    0.16432987f, -0.26216665f, 0.03637541f, -0.13548209f, 0.09993941f, -0.33823499f, 0.04814826f, -0.19465859f, 
    0.00308247f, 0.05173324f, 0.02509351f, 0.02470179f, 0.00893626f, 0.04353347f, -0.06781296f, -0.04419018f, 
    -0.39661884f, -0.01427152f, 0.00881622f, 0.01678031f, 0.01426236f, -0.12624551f, 0.02436332f, -0.04403257f, 
    0.06895792f, 0.04440051f, 0.02110810f, -0.06842455f, 0.14216226f, -0.08725361f, 0.02330089f, -0.03126043f, 
    -0.08879737f, -0.10129169f, -0.05059473f, 0.03118540f, -0.06023350f, -0.00324495f, -0.06813557f, 0.11502159f, 
    0.04322799f, 0.00181919f, -0.08303432f, -0.14533246f, 0.11883418f, -0.05164370f, -0.01531613f, 0.05003996f, 
    0.02164051f, 0.08454314f, -0.03711114f, -0.01454374f, 0.24675786f, 0.03651105f, 0.06038918f, 0.15447259f, 
    -0.06035687f, -0.17383811f, 0.04361625f, -0.04512025f, -0.08723883f, 0.00202051f, -0.03715727f, 0.02081307f, 
    -0.13623546f, 0.18652782f, 0.08479521f, 0.07201841f, -0.13896687f, -0.02888853f, -0.08444212f, -0.01746411f, 
    0.08330870f, -0.03176256f, 0.02574611f, -0.02518059f, -0.17038986f, 0.11689480f, -0.16596943f, -0.01437895f, 
    -0.12451365f, -0.00792335f, -0.03281428f, -0.05607304f, -0.02620420f, -0.19012351f, -0.01609580f, 0.11246652f, 
    0.04011324f, -0.22026572f, 0.04139268f, -0.05219727f, -0.07402858f, -0.13310727f, -0.10087398f, 0.09865521f, 
    -0.02409838f, 0.05613712f, -0.06217435f, 0.14093626f, 0.28027895f, -0.08110048f, -0.01333539f, -0.00297870f, 
    -0.11756201f, 0.01337905f, 0.05266730f, 0.09105583f, 0.06069564f, 0.04849006f, 0.06545931f, 0.07497504f, 
    0.18342207f, 0.01362377f, -0.00618341f, -0.00488424f, -0.07411313f, 0.01999661f, -0.12481649f, 0.00687663f, 
    -0.04824297f, -0.10715226f, 0.03099601f, 0.02305933f, 0.35274279f, -0.20356528f, 0.12728506f, -0.12063748f, 
    0.09238779f, 0.08611775f, -0.06178090f, -0.06327629f, 0.04076395f, 0.07557239f, -0.11889737f, 0.01797575f, 
    -0.17496929f, 0.17769781f, -0.04827807f, -0.01994750f, 0.03824942f, -0.03002202f, 0.04100862f, 0.06017704f, 
    0.12752578f, -0.02197546f, -0.00827080f, -0.12946808f, -0.04048230f, -0.27812424f, -0.08263125f, 0.00269311f, 
    -0.11930723f, 0.17022754f, 0.00053983f, -0.03386715f, -0.14026244f, -0.00207090f, -0.06510764f, -0.07450747f, 
    -0.07603768f, 0.07762104f, -0.23095505f, -0.04141953f, -0.02734706f, -0.04701991f, 0.04051241f, -0.04870668f, 
    -0.07902324f, -0.05766101f, -0.03572121f, -0.05576383f, 0.19404556f, 0.15886860f, 0.07941411f, -0.13685314f, 
    -0.01360738f, -0.04912040f, -0.04086727f, -0.01687642f, 0.00000320f, -0.10248215f, 0.08580637f, 0.00145781f, 
    -0.24474490f, -0.06839779f, -0.01066265f, -0.21478641f, -0.03427922f, -0.12397225f, -0.08894012f, 0.00256238f, 
    -0.01961331f, 0.03538162f, 0.06539679f, -0.10368148f, 0.01808704f, -0.04473448f, 0.12662382f, 0.27364329f, 
    -0.02200756f, 0.03564043f, 0.02569153f, 0.06389952f, 0.11441015f, -0.03464641f, -0.10307670f, 0.01879590f, 
    0.22312297f, -0.09951744f, -0.02865303f, -0.03001161f, 0.07349345f, 0.03901739f, -0.08494970f, 0.11531287f, 
    0.00265621f, 0.06804580f, -0.02176020f, -0.03202458f, 0.00103853f, 0.04773701f, -0.06148524f, 0.03640144f, 
    0.01454389f, 0.10411849f, -0.02933455f, -0.00066686f, -0.08784236f, 0.07967425f, -0.02136106f, 0.01281920f, 
    0.42749831f, -0.25327709f, -0.11089329f, -0.08613715f, -0.03257461f, -0.03589832f, -0.00219616f, -0.00962069f, 
    0.03048469f, -0.07060459f, 0.08893762f, -0.03046397f, -0.06586099f, -0.03558586f, 0.04210381f, -0.25696117f, 
    0.13601197f, -0.08525915f, 0.15761612f, -0.07675901f, 0.05320454f, 0.03807190f, 0.06041165f, 0.00599216f, 
    0.08433639f, 0.04202478f, -0.08100544f, -0.03000172f, 0.06437513f, 0.13306397f, 0.03026548f, 0.06300718f, 
    0.07260653f, -0.20110777f, -0.06901658f, -0.00253045f, -0.18510954f, 0.09760346f, -0.06460913f, -0.26447073f, 
    0.01732633f, -0.01086644f, 0.10289984f, 0.07882481f, -0.01634675f, -0.05559372f, -0.03070638f, -0.16751640f, 
    -0.03647096f, 0.04707706f, 0.09374341f, 0.04938769f, -0.11617421f, -0.14799966f, -0.01606898f, -0.09039062f, 
    -0.10327958f, -0.02655084f, 0.03781451f, 0.00518653f, -0.62079865f, -0.00217731f, -0.11925440f, -0.26815167f, 
    -0.02539683f, 0.01905991f, -0.01236909f, 0.01482745f, -0.02788838f, -0.07688857f, 0.02736873f, -0.03674472f, 
    0.24181603f, 0.14500342f, 0.00841372f, 0.27950373f, -0.10229670f, 0.02472115f, -0.10309166f, 0.01918313f, 
    0.01413667f, -0.02799726f, 0.01256311f, -0.02833803f, 0.12967248f, 0.07799593f, -0.04389074f, -0.03867252f, 
    0.13109066f, 0.02786908f, -0.11259542f, -0.01066800f, 0.01870431f, 0.11688903f, 0.05998604f, 0.06936744f, 
    -0.03989394f, -0.10157045f, -0.02867002f, -0.02150681f, -0.07237450f, -0.10481381f, 0.03189994f, 0.14454837f, 
    -0.07543154f, -0.01762448f, -0.03434899f, 0.04524496f, -0.21243148f, 0.10743812f, -0.04346044f, -0.00099774f, 
    0.00057974f, -0.07526023f, -0.05848382f, -0.15031005f, -0.11295106f, -0.03713931f, -0.00982529f, 0.05549842f, 
    0.11580581f, -0.00524337f, 0.11368809f, -0.12088998f, 0.04549231f, 0.04736064f, 0.04158774f, -0.00555221f, 
    -0.04720804f, 0.14789204f, 0.11127602f, 0.01475968f, -0.18803568f, 0.10932282f, -0.28543848f, -0.03071912f, 
    0.03381206f, -0.04626258f, 0.05334873f, -0.06242910f, 0.03056294f, 0.04588572f, -0.02251500f, -0.02959898f, 
    0.09923044f, 0.11462013f, 0.06489147f, 0.15616848f, -0.14577007f, 0.01813189f, 0.01569668f, 0.03639771f, 
    -0.05731872f, 0.04903920f, 0.05164307f, 0.05831787f, 0.17118916f, -0.07922487f, 0.17812586f, 0.11407011f, 
    -0.08566064f, -0.03998855f, 0.04971129f, -0.02209458f, 0.05356175f, 0.08666679f, 0.00206757f, 0.06340561f, 
    0.04392773f, 0.08230856f, 0.00017675f, 0.03250667f, -0.02082244f, -0.01963023f, -0.04923249f, -0.14219770f, 
    -0.12590604f, 0.05746572f, -0.04011635f, -0.07400575f, 0.09798323f, 0.01434491f, -0.16598772f, -0.12930663f, 
    0.15408982f, -0.07907671f, 0.10257962f, 0.04833131f, 0.04814911f, -0.00327101f, 0.07131664f, 0.14437880f, 
    0.14599136f, -0.14374848f, 0.11978188f, 0.17134403f, -0.06908377f, 0.01936138f, -0.02899902f, 0.02160687f, 
    -0.04410707f, -0.01026364f, 0.03515778f, -0.09152643f, 0.08286414f, 0.09748569f, -0.16700841f, 0.08517562f, 
    -0.16918841f, 0.07712328f, 0.01579405f, -0.07065496f, -0.10970561f, -0.03652398f, -0.00013898f, -0.02089983f, 
    -0.17134772f, 0.05930411f, -0.20927584f, -0.40066573f, -0.04318740f, 0.06716390f, 0.00750290f, 0.02728872f, 
    0.03952121f, 0.11516164f, -0.03193644f, 0.07627361f, 0.24848551f, -0.04320151f, 0.12354774f, 0.04134045f, 
    0.00774966f, -0.00348484f, 0.00630970f, -0.01537529f, -0.13802272f, -0.03846899f, 0.08099621f, -0.04534242f, 
    -0.02759753f, 0.05940071f, -0.11664496f, -0.02855178f, 0.05285019f, 0.05246909f, -0.06960487f, -0.00948384f, 
    0.03459010f, -0.00886494f, -0.06503532f, -0.09736584f, 0.15790316f, -0.04708798f, 0.00915920f, -0.11362436f, 
    0.00403739f, -0.06456687f, 0.03677212f, 0.03290365f, 0.01415097f, 0.03581669f, 0.03127426f, -0.00806859f, 
    0.20237520f, -0.08539793f, 0.09723311f, -0.03819406f, 0.10743447f, 0.00360489f, -0.09360366f, 0.10972436f, 
    -0.11875294f, -0.01218375f, 0.03198911f, -0.09533889f, -0.08514871f, -0.08718604f, 0.05131402f, -0.19791545f, 
    0.07583988f, 0.02180217f, 0.05484197f, 0.05839160f, -0.07700562f, -0.09024306f, 0.00195123f, -0.00447429f, 
    -0.05879654f, -0.14578103f, -0.26559126f, -0.11676445f, 0.02737875f, -0.01055032f, -0.00513479f, -0.02261790f, 
    -0.06359009f, 0.08196978f, 0.03443546f, 0.12365966f, 0.00862683f, -0.01526731f, -0.17978980f, 0.08943452f, 
    0.01147232f, 0.00025495f, -0.05699287f, 0.01997312f, -0.01668989f, -0.05899585f, 0.00329063f, 0.04855666f, 
    -0.19081484f, -0.14435661f, -0.10048165f, 0.09902272f, -0.03256382f, 0.03956833f, -0.03262920f, -0.01108360f, 
    -0.01723354f, -0.06315961f, 0.24005356f, 0.04395648f, 0.01135803f, -0.26174009f, -0.13315652f, -0.01692396f, 
    -0.09710066f, 0.07373138f, -0.03651985f, 0.06445853f, 0.05604930f, 0.01883410f, -0.07954796f, -0.06826634f, 
    -0.03074700f, 0.08628890f, 0.13543430f, 0.01639926f, -0.20717348f, -0.01528453f, 0.00665984f, 0.04574058f, 
    0.01974058f, 0.08410005f, 0.13781939f, 0.03617528f, 0.06797071f, -0.01037535f, -0.22393423f, 0.01012535f, 
    0.13904451f, 0.05497564f, -0.08487993f, -0.05694503f, -0.01700342f, 0.11128160f, 0.00250631f, -0.06080624f, 
    0.23379992f, -0.07836967f, 0.16008331f, -0.25972438f, 0.09549046f, -0.12652241f, 0.06031525f, 0.15320188f, 
    -0.01168996f, -0.09914155f, 0.08462088f, -0.03186621f, 0.21830653f, -0.08596934f, -0.04169957f, -0.12480089f, 
    -0.02285442f, -0.02943287f, 0.01160281f, 0.06612366f, 0.05174370f, 0.01432687f, -0.04999933f, 0.02412936f, 
    -0.14398506f, -0.00082732f, 0.01312186f, -0.00869719f, 0.07549985f, 0.06552083f, 0.02974147f, 0.00429479f, 
    0.05120649f, 0.12122524f, -0.06700446f, 0.15437755f, 0.16629364f, -0.15197267f, -0.03251206f, 0.09610673f, 
    0.02402788f, 0.02156620f, -0.00365205f, -0.03584764f, 0.08406960f, -0.07189354f, -0.15119083f, 0.18104827f, 
    0.12205099f, -0.00886896f, 0.06006923f, 0.16613300f, -0.09656502f, 0.08051375f, 0.00594195f, 0.12260259f, 
    0.07988066f, -0.01411737f, 0.15395784f, -0.04194611f, 0.19952428f, 0.11882441f, 0.08465566f, 0.14324020f, 
    -0.04965703f, 0.01107535f, 0.02237640f, 0.07550733f, -0.04335567f, -0.00088047f, 0.09359509f, -0.21727340f, 
    0.21499418f, -0.06504623f, 0.10126822f, 0.31150600f, -0.05677652f, -0.06800546f, 0.01994352f, 0.02568929f, 
    -0.07984315f, -0.03009278f, 0.01086019f, 0.04639717f, 0.08103328f, -0.04492778f, 0.10850275f, -0.18482482f, 
    0.03368973f, -0.03873788f, -0.01393104f, 0.08539226f, 0.03177731f, 0.05189757f, -0.09148657f, -0.03195499f, 
    0.01286673f, 0.01224153f, -0.00270149f, -0.13158517f, -0.02806018f, -0.00945949f, 0.04678908f, 0.02877926f, 
    0.05090916f, -0.01231257f, -0.05939069f, -0.00693324f, -0.23873095f, 0.06556223f, -0.15666473f, -0.35073122f, 
    0.06532350f, -0.04267548f, -0.05217889f, -0.00242733f, 0.04191311f, 0.02142344f, 0.00927370f, 0.02892155f, 
    -0.03242688f, -0.12434224f, -0.07120993f, -0.02857767f, 0.11581944f, -0.04212331f, -0.09268285f, -0.10927737f, 
    -0.07080975f, 0.09347790f, 0.01735306f, 0.03810043f, 0.09087465f, 0.06565683f, 0.02100471f, 0.22517365f, 
    -0.06365731f, -0.01212042f, -0.03288162f, 0.01694864f, 0.06341085f, 0.01276965f, -0.09402671f, 0.05957658f, 
    -0.03772017f, -0.06589077f, 0.07119429f, -0.02407777f, -0.08523521f, -0.01869298f, 0.06007838f, -0.07687256f, 
    0.00769052f, -0.05144354f, -0.01124946f, -0.06409990f, 0.47211137f, -0.11143526f, -0.14395922f, -0.01342336f, 
    -0.09796102f, 0.04440208f, -0.01275649f, -0.01705673f, 0.01786122f, 0.03614288f, -0.02271836f, -0.12632474f, 
    -0.06878418f, -0.01556874f, -0.03372642f, -0.03995195f, -0.04618736f, -0.07031591f, -0.05634795f, -0.14653502f, 
    -0.03363887f, -0.01178832f, -0.19738886f, 0.00043852f, -0.15573041f, 0.07303420f, 0.02771616f, 0.23091383f, 
    -0.04163409f, -0.13297586f, -0.00623279f, 0.09996629f, -0.00015782f, -0.06482505f, 0.04054420f, 0.01185412f, 
    0.15884653f, 0.19007023f, 0.04706308f, 0.12947671f, -0.00008279f, 0.04282899f, 0.03793026f, 0.03728089f, 
    -0.10900113f, 0.07461984f, 0.08194782f, -0.01490164f, 0.03617098f, -0.00708965f, -0.10825620f, 0.00239034f, 
    0.05826237f, -0.01229132f, 0.06910739f, 0.02211332f, 0.01112605f, -0.05689111f, -0.06597618f, -0.12359891f, 
    0.02796357f, 0.14929634f, 0.05372447f, 0.25117469f, -0.13589467f, -0.09410324f, 0.05075416f, 0.06324171f, 
    0.00367233f, -0.01613765f, -0.02825223f, 0.06343827f, -0.03692752f, 0.17203648f, 0.00408825f, -0.24422532f, 
    0.04868335f, -0.00286182f, 0.04964948f, 0.05617406f, 0.02893932f, -0.08280997f, 0.08644415f, -0.05700367f, 
    -0.02726390f, -0.05180115f, 0.07132036f, -0.00469318f, -0.05879842f, 0.11695378f, 0.01243011f, -0.01569822f, 
    0.00806903f, 0.06743888f, -0.04181833f, 0.00028223f, 0.11697146f, 0.12899123f, -0.16815788f, -0.03497745f, 
    0.09467341f, 0.08212104f, 0.11946075f, -0.02006796f, -0.02003574f, 0.06421503f, 0.01565219f, -0.05603241f, 
    -0.06751701f, -0.06221651f, -0.10359161f, 0.06333925f, -0.07066970f, 0.05210030f, 0.09075157f, 0.02996393f, 
    -0.07476218f, -0.03137731f, -0.03089052f, -0.09728860f, 0.47284201f, -0.14717802f, -0.08455517f, 0.18891293f, 
    -0.21864246f, -0.10505852f, -0.06502846f, -0.16027124f, 0.01324484f, 0.04760774f, 0.07111679f, 0.02513857f, 
    -0.03130428f, -0.03009168f, -0.01957489f, -0.07342149f, -0.02981611f, 0.01287333f, 0.04043827f, -0.01772829f, 
    -0.11348581f, 0.08326861f, -0.02297151f, -0.05392541f, -0.07290750f, 0.06845838f, 0.15923056f, -0.01432839f, 
    0.00236637f, -0.04900038f, 0.03186025f, 0.11579740f, 0.00288447f, -0.10588208f, 0.06907342f, -0.06047366f, 
    0.20818020f, -0.05446242f, -0.11437766f, 0.02677407f, -0.02641146f, 0.02999884f, 0.01483614f, 0.04188340f, 
    -0.04946863f, -0.05983965f, 0.03405543f, 0.05762172f, 0.16797988f, -0.10645211f, -0.13012114f, -0.09830435f, 
    0.04627300f, -0.00070000f, 0.01829577f, -0.06708356f, 0.04294503f, -0.00120791f, -0.04580805f, 0.04763794f, 
    0.20533077f, -0.12451563f, -0.09936073f, -0.17185199f, -0.08191937f, 0.06850797f, 0.10994256f, 0.00646956f, 
    0.05617608f, -0.02885073f, 0.08336354f, -0.02235221f, -0.03537047f, -0.01674397f, 0.07332207f, -0.08763444f, 
    0.05821213f, 0.04084096f, 0.04356274f, 0.05464996f, -0.08753610f, 0.03105438f, 0.03228635f, -0.02529828f, 
    -0.05460479f, -0.12403854f, -0.00255749f, -0.15833935f, 0.04075361f, -0.06567530f, 0.10589305f, -0.00525400f, 
    -0.03544928f, -0.05482908f, -0.03260455f, -0.04649816f, 0.14002261f, 0.06455334f, 0.02623325f, 0.00962097f, 
    0.06480287f, 0.03145205f, -0.01848002f, 0.02317510f, -0.06524555f, 0.06575427f, 0.06008931f, -0.05221029f, 
    0.02810584f, -0.09726121f, 0.05628994f, -0.16062544f, -0.10468505f, -0.08137280f, -0.01672943f, 0.05181195f, 
    -0.05634307f, -0.09114103f, 0.00253679f, 0.00918858f, 0.31019083f, -0.19814070f, 0.04164873f, -0.00725703f, 
    -0.03606065f, -0.05172957f, 0.07646611f, 0.01318102f, 0.08665415f, -0.03865041f, 0.02060322f, -0.05085218f, 
    0.24161518f, 0.05469730f, 0.07614782f, 0.16126437f, -0.07453251f, -0.06272003f, 0.00289846f, 0.01253304f, 
    -0.03781494f, 0.05283328f, -0.03538796f, 0.06489772f, -0.42065623f, -0.34802505f, -0.01220367f, -0.09550510f, 
    -0.06526877f, 0.05064694f, -0.02771104f, -0.04902330f, 0.02249640f, 0.01581380f, 0.02308470f, -0.01579244f, 
    0.29859123f, 0.05458532f, 0.00953006f, 0.10749746f, -0.05630925f, -0.06003442f, -0.03227951f, 0.04613160f, 
    0.00080273f, -0.10576148f, -0.02754657f, -0.02753231f, 0.06691346f, -0.12161818f, -0.20674352f, -0.03276384f, 
    -0.09863540f, 0.09569721f, -0.00433750f, -0.05766965f, -0.06278800f, -0.01554215f, 0.05859469f, 0.01203479f, 
    0.03163509f, 0.03564504f, 0.09463381f, -0.07184017f, -0.03132574f, 0.07706789f, 0.04374741f, 0.16284925f, 
    -0.07323181f, -0.09623601f, 0.01187462f, -0.10302665f, 0.14633495f, 0.03307803f, -0.34657919f, -0.19398110f, 
    0.03040166f, 0.01121943f, -0.04065774f, -0.03834853f, -0.10340048f, -0.00378344f, 0.01457899f, -0.01812252f, 
    -0.15224512f, -0.01801190f, -0.01458505f, -0.05825349f, 0.13161978f, 0.02507510f, -0.03921817f, 0.02097967f, 
    0.02542854f, 0.09706408f, 0.00426282f, -0.09283427f, 0.06078373f, 0.00055999f, -0.06401386f, 0.07376097f, 
    -0.10743362f, 0.04592757f, -0.03594454f, 0.02905036f, 0.00535111f, -0.10162709f, 0.01734819f, 0.02658894f, 
    0.15910219f, -0.02664659f, 0.12636806f, 0.00416193f, 0.09859496f, -0.01827061f, -0.06410949f, 0.05034352f, 
    -0.02349859f, 0.00866188f, 0.01843216f, -0.13177937f, -0.06222996f, -0.07647882f, -0.29223102f, 0.03045037f, 
    -0.12135199f, 0.14806159f, -0.11256482f, 0.06018610f, -0.05110454f, 0.11053386f, -0.02293898f, -0.05119331f, 
    -0.38378432f, 0.00462539f, -0.05217505f, -0.20581949f, 0.00964713f, -0.07783306f, -0.00461278f, -0.05291168f, 
    -0.13205604f, -0.05556704f, -0.00387419f, -0.14904013f, 0.11593764f, 0.06781116f, -0.16859628f, -0.07619640f, 
    -0.04241320f, -0.00464628f, -0.00649954f, 0.03831636f, 0.03427674f, -0.07897627f, -0.09514943f, -0.05014406f, 
    0.01885469f, 0.00432374f, -0.00755333f, -0.06785002f, 0.16072188f, -0.01630417f, -0.01013838f, -0.01847154f, 
    0.01978928f, 0.00476341f, 0.02887847f, 0.03812554f, -0.03619288f, 0.07218026f, -0.05457283f, -0.04186850f, 
    0.04266853f, 0.02942926f, 0.01398422f, -0.10686469f, -0.08347921f, 0.06079340f, -0.02903469f, -0.14057709f, 
    0.29936874f, 0.03316080f, 0.01930281f, -0.05483406f, -0.10365342f, -0.12351641f, 0.05597845f, 0.12297982f, 
    0.01620798f, 0.06374302f, 0.02150133f, -0.14265840f, 0.11531320f, -0.05883758f, 0.00015696f, 0.09936155f, 
    -0.13073403f, -0.04387691f, -0.14785337f, -0.02708520f, -0.01196228f, 0.02993033f, -0.07239570f, 0.11416173f, 
    0.01043931f, -0.12306785f, 0.02450940f, 0.09595109f, 0.06818438f, 0.04060991f, 0.00371271f, -0.03518553f, 
    -0.05458055f, -0.16053699f, -0.12961736f, 0.00471062f, 0.17155531f, -0.02171550f, 0.10272752f, 0.02624960f, 
    -0.06181887f, -0.02973789f, -0.08398355f, 0.08806809f, 0.16557316f, -0.01471500f, -0.01917989f, -0.09231106f, 
    0.20106170f, -0.23215160f, -0.23150207f, -0.06360599f, -0.01902800f, 0.07308035f, 0.00044384f, -0.09609435f, 
    -0.03089318f, 0.07220405f, -0.05621558f, 0.01928748f, 0.04996442f, 0.12593083f, -0.04035459f, 0.06524435f, 
    0.03910236f, 0.04247835f, 0.01467218f, -0.10238051f, 0.01675498f, 0.08783337f, 0.01246238f, 0.03303408f, 
    0.26583350f, -0.02250346f, 0.05139994f, 0.04181376f, -0.10652366f, 0.01385019f, -0.04770793f, -0.02907464f, 
    -0.03993794f, 0.01626752f, -0.06315976f, 0.05202352f, -0.23711248f, 0.01736881f, -0.02711624f, -0.09954428f, 
    -0.04978650f, 0.05617797f, 0.05523658f, -0.03566680f, -0.03045691f, -0.05376435f, -0.04418031f, 0.00802226f, 
    0.25759521f, -0.12361920f, -0.09817962f, -0.11282743f, -0.03489236f, -0.04475576f, -0.04827582f, -0.12638588f, 
    0.01423526f, -0.00483962f, -0.03641504f, -0.06583858f, -0.03570585f, -0.04154168f, -0.11464880f, -0.10274629f, 
    0.00979760f, -0.04250056f, -0.03242413f, -0.01855928f, -0.06257100f, 0.00600045f, -0.06518710f, -0.03208880f, 
    -0.18077904f, -0.00353545f, 0.08252171f, -0.02434671f, -0.06146472f, 0.03082645f, -0.01176657f, -0.00840249f, 
    -0.08275416f, -0.05385451f, 0.08975885f, -0.06167599f, -0.09188607f, -0.18640672f, 0.09876100f, -0.14472918f, 
    -0.17774135f, 0.04747370f, -0.08154571f, -0.00414239f, -0.04178194f, -0.06881805f, 0.01500179f, -0.02545688f, 
    0.39402384f, -0.10176296f, -0.20160611f, -0.03086552f, -0.04947126f, 0.02665256f, -0.18851449f, 0.03985389f, 
    -0.01562090f, 0.00235023f, 0.08043782f, -0.05596679f, 0.03267889f, 0.04344951f, -0.08777715f, -0.00491393f, 
    0.12396453f, 0.03473352f, 0.00272871f, 0.02153399f, 0.02233977f, 0.11906256f, -0.15920417f, -0.01714259f, 
    -0.29487568f, -0.07236040f, 0.01063303f, -0.06924579f, 0.06693872f, 0.09251387f, -0.06427395f, -0.03952000f, 
    0.03578024f, -0.02721959f, -0.03407368f, -0.04185419f, 0.15132406f, -0.10016668f, 0.00392118f, -0.07627061f, 
    -0.02021270f, 0.05741175f, 0.06918224f, -0.01598749f, -0.02878461f, -0.02289794f, -0.04855308f, 0.02527368f, 
    -0.21974139f, 0.14376402f, -0.11921495f, 0.03694885f, 0.01170951f, -0.05624416f, 0.06386396f, -0.07778203f, 
    -0.10128056f, 0.01463945f, -0.03526587f, 0.05829550f, 0.00188330f, -0.38906267f, 0.05908044f, -0.15024565f, 
    -0.09548385f, -0.00632802f, -0.14225470f, -0.02756982f, -0.02656571f, 0.01094787f, 0.05663844f, -0.08338096f, 
    -0.00008384f, 0.05679285f, -0.24621794f, -0.06157499f, 0.11759987f, 0.04940753f, -0.01106737f, -0.08626989f, 
    -0.02247811f, -0.04582846f, -0.07818112f, -0.10818014f, 0.28223711f, 0.01161465f, 0.05433337f, 0.27078453f, 
    -0.08515800f, -0.04860768f, 0.07228915f, 0.03225528f, 0.07446498f, 0.12052295f, 0.15538630f, -0.02606284f, 
    -0.16087268f, -0.03434161f, 0.06212018f, 0.09579328f, 0.05668502f, 0.04858538f, -0.01416892f, -0.04395567f, 
    0.00743921f, 0.06583340f, -0.06523843f, 0.01681861f, -0.04798763f, 0.02488676f, -0.10942207f, 0.02220204f, 
    0.02131842f, 0.07800096f, 0.04646071f, -0.01962000f, 0.02320541f, 0.07321531f, -0.02129477f, 0.09462103f, 
    0.09590040f, -0.02543935f, -0.06081260f, 0.00872326f, 0.07907525f, 0.00227534f, -0.02022161f, 0.01295781f, 
    -0.07185876f, 0.07079574f, 0.00168456f, -0.01494887f, -0.03131551f, -0.02881111f, 0.07536292f, 0.18520425f, 
    -0.00522133f, 0.07247674f, 0.12803811f, 0.07523220f, 0.01798491f, -0.08416870f, -0.03535912f, -0.03652362f, 
    -0.29577029f, -0.04301694f, 0.02213085f, -0.28461114f, 0.05761867f, -0.01012954f, -0.00889229f, -0.00147574f, 
    -0.05602800f, 0.01979610f, -0.10344378f, -0.10440484f, 0.25533539f, 0.09948427f, -0.12212368f, 0.13435888f, 
    0.03228485f, 0.06150677f, -0.12959462f, 0.08093954f, -0.04308829f, 0.01018812f, 0.05508404f, -0.00485979f, 
    0.22902630f, 0.02130338f, 0.14569779f, 0.04989627f, -0.00146713f, -0.02827951f, 0.08519682f, 0.08207208f, 
    -0.03258016f, 0.02928383f, 0.07493151f, -0.00232246f, -0.18137814f, 0.03093806f, -0.04013747f, -0.02924419f, 
    0.01152212f, 0.03077403f, -0.04216469f, 0.03665379f, -0.01227437f, -0.00668467f, 0.02252151f, -0.13130066f, 
    0.11204904f, -0.08648095f, 0.07662382f, -0.05224071f, 0.01578924f, -0.00447192f, -0.00133704f, 0.06008825f, 
    -0.03657530f, 0.02501271f, 0.00277429f, -0.03084699f, 0.04578857f, 0.01674478f, 0.21810339f, -0.10732616f, 
    0.02254654f, -0.07783640f, 0.09439374f, -0.04226259f, -0.06056783f, -0.03602924f, 0.03371399f, -0.01142405f, 
    0.20527917f, 0.17162462f, -0.07663201f, 0.04346436f, -0.13919106f, 0.00701551f, 0.02282302f, 0.02811739f, 
    0.02407349f, 0.10381931f, 0.02222277f, -0.01605065f, -0.01996857f, -0.22448394f, 0.07820503f, -0.12159716f, 
    -0.16645521f, 0.08691698f, 0.00896037f, 0.00266803f, 0.03852304f, 0.01130113f, -0.06276111f, 0.04859264f, 
    -0.20078868f, 0.08840090f, -0.02620088f, -0.20128335f, -0.04847478f, 0.04476820f, 0.01450059f, 0.10305107f, 
    -0.00819903f, -0.09081629f, -0.00261004f, -0.06189289f, 0.09038354f, -0.20548856f, -0.14387608f, 0.04722302f, 
    -0.08143460f, -0.04147918f, -0.01318097f, -0.03711701f, 0.02969189f, -0.07861174f, -0.07185473f, -0.00498683f, 
    -0.11268678f, -0.05431846f, -0.05659691f, -0.02848342f, -0.01238246f, -0.06422929f, 0.02957020f, -0.00384469f, 
    -0.03716568f, -0.02014423f, 0.08601937f, 0.01525130f, -0.17755981f, -0.24912450f, -0.16667916f, -0.06936004f, 
    -0.07427404f, 0.01812169f, 0.06996775f, 0.09601409f, -0.02644709f, -0.09191724f, -0.02960991f, 0.00002993f, 
    -0.12982965f, -0.16308004f, -0.03234812f, 0.13667360f, -0.03699842f, 0.04867207f, 0.07327168f, -0.12852636f, 
    0.01911938f, 0.03297764f, -0.06743792f, 0.03101165f, -0.48759618f, 0.28168440f, -0.10709207f, 0.14482808f, 
    0.04618160f, 0.04639837f, 0.03607447f, 0.08910973f, -0.06092685f, 0.06004287f, 0.02086429f, 0.05675855f, 
    0.31778246f, -0.15913345f, -0.07311794f, -0.03478983f, -0.04579336f, 0.10448899f, 0.02500270f, 0.04104787f, 
    -0.04790975f, 0.00968892f, 0.04487626f, 0.06869966f, 0.14357343f, -0.08610653f, 0.05062484f, -0.03600366f, 
    -0.05691577f, -0.12122861f, -0.10150179f, -0.01706054f, -0.00857432f, 0.04772821f, -0.02367426f, -0.06687495f, 
    0.01378618f, -0.25352213f, -0.34958059f, 0.05171826f, -0.15345442f, 0.00146376f, 0.00711087f, 0.01601516f, 
    0.01321584f, 0.08518774f, -0.05783116f, 0.01229098f, -0.14906488f, -0.00159788f, -0.12919003f, 0.06080437f, 
    -0.01038753f, 0.07197897f, 0.07652180f, -0.00100507f, -0.14049593f, 0.04953058f, 0.10622892f, 0.05303277f, 
    -0.29908270f, 0.11749551f, 0.02861607f, -0.13630180f, 0.10750348f, 0.15905033f, -0.01858917f, -0.00785107f, 
    -0.03850827f, -0.01375279f, 0.08974810f, 0.03505283f, 0.12586930f, -0.03282715f, 0.04724498f, 0.21993874f, 
    0.12176523f, -0.02001531f, -0.12252378f, 0.03261104f, 0.02360933f, 0.06896538f, -0.04533845f, 0.01027033f, 
    0.10298036f, 0.26128811f, 0.11245020f, 0.19294921f, -0.01837613f, -0.01775490f, 0.03022255f, -0.05094910f, 
    -0.05521150f, 0.06451000f, -0.02425881f, 0.06644040f, -0.11989915f, -0.13364497f, -0.15529291f, -0.07183529f, 
    -0.11037041f, -0.05322256f, 0.06729360f, 0.07358668f, 0.03162199f, 0.02721388f, -0.10873847f, 0.02385751f, 
    0.45076731f, 0.22753140f, 0.05307646f, -0.03280092f, -0.01143852f, -0.00501630f, -0.01465597f, -0.03828334f, 
    -0.04672898f, -0.06200799f, -0.07744098f, 0.01030570f, 0.33714634f, -0.09922630f, 0.08230911f, 0.01520239f, 
    -0.01347137f, -0.02240055f, 0.07096434f, -0.00661346f, 0.01199287f, -0.01598887f, 0.04022452f, -0.06744431f, 
    0.05764871f, 0.02602035f, 0.00209670f, -0.06887305f, -0.15522990f, 0.00792543f, 0.03746341f, 0.03777426f, 
    -0.02036913f, -0.08728230f, -0.00435814f, 0.03421664f, -0.00992998f, 0.03705090f, 0.03965653f, 0.14524639f, 
    -0.03699109f, -0.07806441f, -0.00689459f, -0.08910041f, 0.02536848f, -0.10264371f, 0.03788823f, -0.07096301f, 
    -0.03169211f, -0.14205748f, -0.01879514f, 0.03767483f, -0.02960163f, 0.00710160f, 0.00871766f, -0.00821834f, 
    -0.05554440f, 0.09678805f, -0.14048351f, 0.08023664f, 0.15624622f, 0.10354793f, 0.03956060f, 0.03981020f, 
    0.01446792f, 0.06925366f, 0.05373843f, -0.02392138f, 0.08429737f, -0.02111663f, 0.01203490f, 0.07356796f, 
    -0.05764941f, 0.13499503f, 0.10693876f, -0.04676780f, -0.03897664f, -0.08785956f, -0.11489209f, -0.00741894f, 
    -0.01634450f, 0.04807444f, -0.05756954f, 0.10169751f, 0.00532851f, 0.26767123f, 0.06032013f, -0.03313535f, 
    0.02351316f, 0.10883500f, -0.00045231f, 0.06412250f, -0.07832879f, 0.08664486f, 0.07243982f, 0.03190423f, 
    -0.33360681f, -0.16273397f, -0.10347230f, 0.11929303f, -0.10968832f, 0.02368300f, -0.00541631f, 0.12206937f, 
    -0.00822192f, 0.02178388f, -0.01594318f, -0.03724089f, 0.16925913f, 0.34934852f, 0.10581695f, -0.07871206f, 
    -0.06210365f, 0.12708496f, 0.02742706f, 0.08029072f, -0.04062038f, 0.05032901f, -0.05409171f, -0.04855643f, 
    -0.05579216f, -0.40997681f, -0.23800951f, -0.02446860f, -0.00545804f, -0.09203725f, 0.07371849f, -0.08387333f, 
    0.06817217f, 0.05177055f, 0.00280036f, 0.01300344f, -0.26996759f, 0.11045294f, 0.02528727f, -0.08296734f, 
    -0.10230049f, -0.03707389f, 0.04193031f, -0.05874316f, 0.02756645f, -0.06636511f, -0.07888899f, 0.04777244f, 
    -0.00125618f, 0.05012203f, -0.10777631f, -0.19531539f, -0.02378160f, 0.03051260f, -0.03374266f, -0.08067734f, 
    0.03069162f, -0.12467881f, -0.01933107f, 0.07879595f, 0.03990541f, -0.08025015f, 0.14427634f, 0.08527604f, 
    0.02701201f, -0.02401980f, 0.04754315f, 0.05055017f, -0.04693563f, 0.07214269f, -0.02076875f, -0.03336158f, 
    -0.00608049f, 0.03272051f, 0.00661098f, 0.04640328f, -0.09400491f, 0.06487545f, -0.03728167f, 0.05182763f, 
    0.09946296f, -0.05498739f, -0.07583052f, 0.04960930f, -0.08429995f, 0.12721349f, 0.21506360f, -0.00821613f, 
    0.04379770f, -0.04514299f, 0.02414807f, -0.01648417f, 0.02237426f, -0.03991314f, -0.03704411f, 0.02818617f, 
    -0.59200346f, -0.39033645f, 0.08609058f, -0.05855745f, -0.09299110f, -0.07231875f, -0.08965814f, -0.02346712f, 
    0.00485671f, -0.03964996f, 0.07835183f, -0.05767002f, -0.03355432f, -0.35072204f, -0.32596236f, 0.27326062f, 
    -0.02914388f, 0.02299912f, 0.00139634f, 0.04091106f, -0.04472385f, -0.08812019f, -0.10134903f, -0.16409963f, 
    -0.06021329f, -0.02643961f, -0.06778607f, 0.05790583f, -0.02918591f, -0.04309523f, -0.02010329f, -0.00562533f, 
    -0.03973510f, 0.09081522f, 0.03261800f, 0.06579435f, 0.03579372f, 0.06019002f, -0.11454976f, -0.08523196f, 
    -0.23378342f, -0.21208978f, 0.09739980f, 0.07292099f, -0.10938349f, -0.07972018f, -0.05975215f, -0.02794931f, 
    -0.25352949f, -0.16905175f, -0.01836599f, 0.13517468f, -0.03985289f, 0.04275645f, 0.12784308f, -0.09698436f, 
    0.03880880f, 0.05522439f, -0.06021714f, -0.05612112f, 0.06731699f, 0.03903876f, 0.10080931f, -0.06023808f, 
    -0.06868496f, 0.01994435f, 0.06660479f, 0.05428764f, -0.03193654f, -0.05502994f, 0.00099528f, 0.00565345f, 
    0.44527447f, 0.18164174f, 0.17758057f, 0.00616341f, -0.02410529f, 0.02158942f, -0.04947206f, 0.09033847f, 
    0.01696761f, 0.03176122f, -0.12584607f, -0.12898299f, 0.11720657f, -0.10496081f, -0.07062178f, 0.16254032f, 
    0.02870497f, -0.05234056f, -0.06509473f, 0.04310920f, 0.02239355f, -0.03423252f, 0.06096390f, -0.02456475f, 
    -0.00449430f, 0.15175676f, 0.01120461f, -0.09494057f, 0.00104570f, -0.03972574f, -0.00476049f, 0.03655579f, 
    0.13735771f, -0.06346342f, 0.03699642f, -0.08401564f, -0.02277589f, -0.19473858f, -0.01841964f, -0.14589979f, 
    -0.04469153f, 0.06244878f, -0.01051867f, 0.03157280f, 0.00508112f, 0.09754641f, 0.02436341f, -0.00637099f, 
    0.12122910f, 0.12409875f, -0.00083690f, 0.12317251f, -0.03806169f, -0.11586627f, 0.00084706f, -0.12572512f, 
    -0.01463521f, -0.05997319f, -0.03485575f, -0.02562721f, 0.24542081f, 0.07676084f, 0.15735136f, 0.15748160f, 
    0.01156100f, -0.03394967f, -0.06592433f, -0.03322065f, 0.02440023f, 0.01170859f, -0.00108457f, -0.13879263f, 
    0.03123973f, 0.18176898f, -0.02850400f, 0.08279626f, 0.07825637f, 0.06635123f, 0.00217789f, -0.02740429f, 
    -0.07265127f, -0.09343079f, -0.04143201f, -0.07458157f, 0.06889199f, 0.05211516f, 0.10015465f, 0.19807322f, 
    0.03744595f, 0.07624485f, -0.11103819f, 0.00867668f, 0.03088900f, 0.00366393f, -0.03340729f, -0.00354069f, 
    -0.31702331f, 0.17163759f, 0.13530385f, 0.09781794f, 0.14387247f, -0.01907817f, -0.02089811f, 0.05445670f, 
    -0.04218638f, 0.02837097f, -0.11076204f, -0.21545836f, -0.20806360f, -0.10483772f, 0.14606175f, 0.17027357f, 
    0.06543572f, 0.10540693f, 0.11032477f, -0.09750290f, 0.00384417f, -0.01134380f, 0.05209175f, 0.05636308f, 
    -0.02144839f, -0.38396767f, -0.32279235f, 0.15790465f, -0.04773392f, -0.00507897f, -0.04351419f, 0.11330324f, 
    -0.10229997f, -0.02858116f, -0.02597638f, -0.02860580f, -0.26348162f, 0.13143250f, -0.13091774f, 0.06428853f, 
    0.06624816f, -0.03716848f, 0.04836399f, -0.00871337f, 0.02462966f, -0.09787992f, -0.00273105f, -0.02464056f, 
    -0.02194130f, -0.28421235f, 0.02412971f, 0.05658778f, -0.04024864f, 0.00552237f, 0.12157340f, 0.02675348f, 
    -0.15714881f, 0.12148379f, -0.03655006f, 0.13485758f, 0.17716236f, 0.16525064f, -0.06084223f, 0.15750162f, 
    -0.08229143f, 0.03153215f, -0.09303981f, 0.05045328f, -0.02762698f, 0.03418287f, 0.06218725f, -0.10654949f, 
    -0.07624167f, 0.01506657f, 0.17004804f, 0.10580806f, 0.10371658f, 0.09563726f, 0.02557723f, -0.09697440f, 
    -0.01290856f, -0.00581826f, -0.02572635f, -0.15160766f, 0.00713239f, -0.02239981f, 0.05583776f, -0.02547709f, 
    -0.00131537f, -0.06138504f, 0.03568128f, -0.06706621f, -0.06877989f, 0.03147480f, -0.06261285f, -0.03183409f, 
    -0.30667809f, -0.07654041f, -0.17960858f, -0.00588302f, -0.03950171f, 0.12117019f, -0.00226372f, -0.05978190f, 
    0.03283363f, 0.05090868f, 0.00751070f, -0.00334144f, -0.26435953f, -0.28365621f, -0.17427158f, -0.05259447f, 
    -0.07717550f, -0.08920417f, 0.03436336f, -0.03066306f, -0.05919326f, 0.03903701f, 0.04162496f, 0.13350162f, 
    -0.10635501f, -0.26266453f, -0.09683144f, -0.01045903f, -0.01703588f, 0.05491137f, 0.00473999f, -0.00016915f, 
    0.00148476f, -0.04202385f, 0.03069791f, -0.05116849f, -0.11779557f, 0.08315809f, 0.02759781f, -0.09767830f, 
    -0.04930307f, 0.08945371f, 0.03477921f, 0.02164084f, 0.03181069f, 0.00026233f, 0.03360947f, 0.03626959f, 
    0.18824859f, -0.23575898f, -0.11221939f, 0.09385481f, 0.01708688f, -0.00703200f, -0.01575688f, 0.05422864f, 
    0.01938888f, 0.03886387f, -0.04308229f, -0.10782892f, -0.27528298f, 0.26068357f, 0.10864072f, -0.20770597f, 
    -0.01130882f, 0.03258929f, 0.01716179f, 0.09880353f, 0.01141472f, -0.05930310f, -0.08835876f, 0.03835580f, 
    -0.08890286f, -0.01870857f, -0.07293885f, -0.14379925f, -0.08318887f, 0.01185684f, -0.10344667f, -0.12386179f, 
    0.01584144f, -0.03478054f, 0.09813116f, -0.00607529f, -0.26685095f, -0.08269864f, 0.04528362f, -0.18260972f, 
    -0.08751626f, -0.06905063f, 0.03184598f, -0.05607878f, -0.02268350f, -0.03802874f, 0.05911598f, -0.00058508f, 
    -0.30420277f, -0.08289108f, 0.07783494f, 0.01095544f, 0.01898719f, 0.12411989f, -0.19122200f, -0.03902813f, 
    -0.05308973f, 0.12376051f, 0.03197333f, 0.16319484f, -0.30476785f, -0.06814910f, -0.10991533f, -0.06406513f, 
    0.05208336f, 0.05718355f, -0.07790691f, 0.09124598f, -0.06302726f, -0.00931368f, -0.12447330f, -0.05301081f, 
    0.35772035f, -0.14081478f, -0.02650930f, -0.23728724f, 0.02784264f, 0.10202934f, -0.04134197f, 0.08634834f, 
    0.02120160f, -0.03429425f, 0.01972085f, 0.02432439f, -0.18618730f, 0.06610239f, 0.13251607f, 0.06760951f, 
    -0.03121250f, -0.01771676f, 0.05528396f, -0.00562169f, 0.07380213f, 0.01279401f, 0.11028305f, 0.06805372f, 
    0.02399646f, -0.14757535f, 0.04220333f, 0.17980802f, 0.00688960f, 0.05309059f, -0.01153072f, 0.07551328f, 
    0.06272680f, -0.00923572f, 0.04377721f, 0.00043184f, 0.22221924f, -0.17068839f, 0.04415475f, 0.16091439f, 
    -0.08806550f, 0.04096668f, 0.10713334f, -0.08993776f, 0.04461581f, 0.18487866f, -0.02539389f, -0.02413730f, 
    -0.35023904f, -0.04391931f, 0.07040266f, 0.20045125f, 0.01529922f, -0.20745713f, 0.08900375f, 0.04904380f, 
    -0.03830703f, 0.04343549f, -0.06367055f, -0.04098077f, -0.13582909f, -0.29739955f, 0.01457841f, -0.10840154f, 
    -0.05924178f, -0.05909703f, -0.04136959f, -0.01165374f, 0.07763837f, 0.04613875f, -0.06018483f, 0.06042249f, 
    -0.30317184f, -0.22403327f, 0.13033487f, -0.11540731f, 0.05508648f, -0.07702933f, -0.11732052f, -0.05579907f, 
    0.05826413f, -0.09693433f, -0.04953437f, 0.10721663f, -0.13175769f, -0.15268210f, 0.11216543f, -0.05834150f, 
    0.03618615f, 0.07133117f, 0.09976681f, 0.10003945f, 0.09723374f, -0.00311231f, 0.02562862f, -0.06697948f, 
    0.31796223f, -0.10346886f, -0.05462920f, -0.01577303f, 0.11775267f, 0.03603871f, -0.06453308f, -0.25451460f, 
    0.07798127f, 0.02026088f, -0.02627268f, 0.00453766f, 0.04233471f, -0.00544239f, -0.11587789f, 0.12101442f, 
    0.01436840f, -0.13676520f, 0.06134234f, 0.17108452f, 0.10213199f, -0.06054954f, 0.00510746f, -0.07317651f, 
    -0.10946732f, -0.30259576f, 0.10970157f, -0.06647830f, -0.13747716f, -0.00904643f, 0.10687580f, 0.05333691f, 
    0.00002292f, 0.04454369f, -0.04092278f, -0.00558811f, -0.39621696f, 0.16787709f, 0.04020216f, 0.13102098f, 
    0.16343009f, -0.09936579f, 0.02746227f, -0.15019935f, 0.07728241f, -0.01905815f, 0.04690913f, -0.05429517f, 
    0.06894528f, 0.06996984f, -0.00330997f, -0.01301335f, -0.08094744f, -0.13832182f, 0.08927864f, 0.01781029f, 
    -0.00075240f, -0.05949444f, 0.00481081f, 0.02974927f, -0.19601128f, 0.20409065f, 0.14739190f, -0.26030302f, 
    0.03315097f, 0.00131988f, -0.00086692f, 0.10341281f, 0.04206304f, -0.04395395f, 0.01482401f, 0.01226568f, 
    0.02231974f, 0.12723510f, 0.06764762f, -0.00658923f, -0.06367067f, -0.09474390f, -0.16803683f, 0.06306496f, 
    0.03715459f, 0.03336046f, -0.00979243f, 0.14324935f, -0.09749395f, -0.25985047f, -0.00777776f, -0.05065380f, 
    -0.06030020f, 0.02554393f, 0.00729685f, 0.04379322f, -0.02883462f, 0.02413805f, 0.15256266f, 0.02802612f, 
    -0.02190607f, 0.01922302f, -0.10309061f, 0.05667135f, 0.05316859f, 0.02057711f, 0.07559225f, 0.01166672f, 
    -0.10830815f, -0.06458165f, 0.02618217f, 0.01762772f, 0.19250448f, 0.12043297f, 0.04088903f, 0.06109955f, 
    -0.05624446f, -0.04842090f, -0.02570729f, -0.04354410f, -0.02149525f, 0.02364408f, -0.04207061f, -0.02737039f, 
    0.03442207f, 0.07628439f, 0.10213473f, -0.07450796f, 0.05118285f, 0.08402033f, -0.00384926f, -0.10128955f, 
    0.01969938f, -0.03430592f, 0.00788643f, -0.01179130f, -0.20997138f, 0.20586665f, -0.12644647f, -0.44872940f, 
    -0.07547545f, -0.15189147f, -0.05739808f, 0.06936523f, -0.02700556f, -0.27640766f, 0.05908798f, -0.13058768f, 
    -0.23996462f, -0.00060813f, 0.02908411f, 0.00082399f, 0.08324605f, 0.05156800f, 0.00008371f, -0.02546409f, 
    0.03425876f, 0.01246860f, -0.01854600f, 0.03956730f, 0.18281864f, -0.14314426f, -0.18254569f, 0.27403384f, 
    -0.01271091f, 0.02612182f, 0.08309820f, 0.00355101f, 0.08439649f, 0.05937892f, -0.06764148f, 0.03399448f, 
    -0.12640303f, 0.18604144f, 0.08754902f, -0.14089610f, 0.03174945f, 0.02117009f, 0.03044288f, -0.03382077f, 
    0.03852005f, 0.01078960f, 0.02057110f, -0.05736725f, 0.28266385f, 0.18679665f, -0.03231115f, -0.12563039f, 
    -0.05641155f, -0.06621082f, 0.11351608f, -0.12672150f, -0.02567451f, -0.05305045f, 0.04956169f, 0.01790849f, 
    -0.25671345f, -0.18737073f, 0.06214051f, -0.20901443f, -0.02997299f, 0.07250238f, -0.19279528f, 0.04283337f, 
    0.01453800f, 0.00385589f, 0.01396228f, 0.02921660f, 0.31365791f, 0.15131159f, 0.01896810f, -0.14105278f, 
    0.10139618f, -0.01543091f, 0.14285982f, -0.04595513f, 0.06886161f, 0.04470332f, -0.05157229f, 0.08587733f, 
    0.19730714f, 0.16646092f, -0.04480841f, -0.01767534f, -0.02101578f, -0.01600613f, 0.11485241f, 0.13329320f, 
    -0.07595082f, 0.01518038f, 0.04399433f, 0.11480376f, -0.01955154f, -0.08192462f, -0.10852548f, 0.12324046f, 
    -0.14662875f, 0.16282910f, 0.13676198f, -0.16340515f, 0.01664042f, -0.08588278f, -0.01429331f, -0.10600557f, 
    -0.15005738f, -0.09212402f, 0.15628265f, 0.07528499f, 0.11468743f, 0.05825595f, -0.01891631f, 0.00983191f, 
    -0.04985856f, 0.13480206f, -0.03016359f, -0.04872687f, -0.15136260f, -0.16270143f, 0.03780205f, -0.05879056f, 
    0.09120808f, 0.11989027f, -0.03819846f, 0.02121263f, -0.05761584f, -0.03702398f, -0.02722480f, 0.00990272f, 
    0.10627718f, 0.18607296f, 0.00657527f, 0.09213550f, -0.04009808f, -0.09226756f, 0.09432484f, 0.00290933f, 
    0.18381096f, -0.07927814f, 0.09872500f, -0.03468546f, 0.26921600f, -0.15286025f, 0.04497987f, -0.25189716f, 
    -0.18546991f, -0.01207164f, 0.03598544f, -0.09989051f, -0.13809213f, 0.02194385f, 0.03428412f, 0.01904018f, 
    0.11338346f, 0.02457925f, -0.07403350f, 0.06999668f, -0.00223348f, -0.08064923f, 0.02366030f, 0.03275420f, 
    -0.00178061f, -0.12790820f, 0.07381372f, -0.18389788f, -0.28914091f, -0.04589405f, 0.13061954f, 0.11766551f, 
    -0.10243274f, -0.07639377f, -0.00851137f, 0.06594823f, 0.11094552f, -0.15632522f, 0.05884295f, -0.09454697f, 
    -0.37762436f, 0.07692469f, 0.20721817f, 0.25917748f, 0.07548986f, -0.04335306f, 0.03911445f, 0.14467967f, 
    0.00006350f, 0.00560389f, 0.00201977f, 0.12793888f, -0.25456282f, -0.00893333f, -0.10550785f, 0.10996979f, 
    0.12270619f, 0.11351701f, -0.02161980f, -0.01711580f, 0.07181833f, 0.04721188f, 0.05986659f, -0.10475782f, 
    0.11152482f, 0.09345570f, -0.22736794f, -0.05271748f, 0.10553718f, 0.07406360f, 0.04384840f, 0.06183328f, 
    0.04176875f, -0.03793445f, -0.11893619f, -0.11537278f, -0.56676835f, 0.02767601f, -0.25756860f, -0.11259103f, 
    0.06837045f, -0.04614590f, 0.01721437f, -0.02374594f, 0.03767654f, 0.01986038f, -0.04764624f, 0.14905202f, 
    0.16538744f, 0.37077999f, -0.11582079f, -0.14538768f, -0.04337587f, -0.00501816f, 0.00713563f, 0.01029333f, 
    -0.02110916f, 0.04751059f, -0.05927370f, 0.00473180f, -0.17147276f, 0.07974398f, -0.04109121f, 0.11526890f, 
    -0.09091531f, 0.15760770f, -0.15966231f, -0.06606169f, -0.04456005f, 0.00351880f, -0.08170729f, -0.07398184f, 
    0.05025331f, 0.24128243f, -0.16464718f, -0.04799097f, 0.03449420f, 0.12894458f, 0.08168987f, -0.00921990f, 
    -0.11895603f, -0.06411693f, 0.05449300f, 0.07043225f, 0.09270614f, -0.18447489f, 0.02249797f, -0.01838889f, 
    0.02378967f, -0.04253295f, 0.08655006f, 0.03703852f, -0.06155438f, -0.04692655f, 0.00462643f, -0.12598450f, 
    -0.04009768f, 0.06659073f, -0.02367756f, 0.00379108f, 0.09864845f, -0.04283832f, -0.03941281f, 0.12287711f, 
    -0.04979026f, 0.01031697f, -0.04352359f, -0.00404213f, -0.08882693f, 0.16187930f, 0.25305131f, 0.06246740f, 
    -0.10225096f, 0.05010574f, -0.14736845f, -0.06268807f, -0.01356650f, 0.01751563f, 0.00824925f, 0.05188923f, 
    0.08497188f, -0.06993456f, 0.03308481f, 0.08528479f, -0.08686010f, 0.06649360f, 0.11464696f, 0.03222978f, 
    -0.00683917f, 0.09441774f, 0.05924105f, -0.03220369f, -0.23587705f, 0.02138225f, 0.10581341f, 0.00139998f, 
    -0.08122012f, 0.01922931f, -0.17184052f, 0.00250835f, -0.04610543f, -0.08066605f, -0.12939934f, 0.15002576f, 
    -0.28796646f, -0.14384322f, 0.23968475f, -0.05590631f, -0.11082612f, -0.02977263f, -0.04543335f, -0.02799146f, 
    0.03085928f, 0.03505938f, -0.15985732f, 0.02129297f, -0.09779819f, 0.09926829f, 0.08384924f, 0.02270182f, 
    0.05966577f, 0.06714429f, -0.05458626f, 0.04265134f, 0.09518411f, 0.04027893f, 0.03761879f, 0.10581259f, 
    -0.15558116f, 0.15229701f, 0.13750824f, -0.00192360f, 0.00824930f, 0.03477724f, -0.03563615f, 0.01243187f, 
    0.09887830f, -0.24517207f, -0.06012896f, -0.05460767f, -0.30433029f, 0.01087965f, -0.09406997f, -0.08056746f, 
    -0.03640017f, 0.00739881f, 0.06972630f, 0.09778132f, 0.00384719f, -0.00489438f, 0.01410428f, 0.01832560f, 
    -0.05108882f, -0.18724607f, 0.15784261f, 0.01816880f, -0.10441947f, 0.01828299f, -0.03171810f, -0.05776899f, 
    0.09120463f, -0.10736690f, -0.02595157f, 0.03425293f, -0.37271839f, 0.08577831f, -0.00584174f, -0.03697984f, 
    0.02713275f, 0.01650767f, -0.02447600f, 0.05180988f, 0.08225927f, -0.09134040f, -0.11328401f, 0.01021503f, 
    -0.08077610f, -0.11160187f, 0.17431381f, 0.15172218f, -0.03007965f, -0.04158797f, -0.01372158f, -0.12802199f, 
    0.11982802f, -0.07611502f, 0.02813983f, -0.06955718f, -0.60387647f, -0.04505524f, -0.02869675f, 0.08389602f, 
    0.05323283f, 0.03236226f, -0.03964945f, 0.08233269f, -0.13989806f, -0.10190539f, 0.16196385f, 0.05220514f, 
    -0.16029738f, 0.16791943f, -0.08732488f, 0.01025482f, -0.01172484f, 0.01420995f, 0.04811448f, 0.01579050f, 
    -0.10852401f, -0.03667292f, 0.02404962f, 0.01190073f, -0.07243689f, 0.06804029f, 0.05260269f, 0.02324337f, 
    0.02782735f, 0.00776364f, 0.02542097f, 0.05830956f, 0.04390888f, 0.01112429f, 0.00332784f, 0.07465435f, 
    0.19583820f, 0.07647231f, 0.01034057f, -0.00326067f, 0.01511290f, -0.08110111f, 0.05537113f, 0.05020507f, 
    0.05228943f, -0.02253877f, 0.05569386f, -0.06663445f, 0.01329452f, -0.19848748f, -0.04831446f, 0.26021463f, 
    -0.01499020f, 0.07515399f, 0.08297840f, 0.02591254f, 0.01862769f, -0.00393809f, 0.04119717f, -0.01531952f, 
    -0.17799227f, 0.04496799f, 0.18791804f, 0.01803335f, -0.10984548f, 0.11835829f, -0.14235519f, -0.07955104f, 
    -0.02016080f, -0.06742850f, 0.13769254f, 0.00273060f, -0.08933851f, -0.16836354f, 0.00758436f, 0.02890255f, 
    -0.06853316f, -0.19873378f, 0.01349872f, -0.00681303f, -0.03166232f, -0.06432985f, -0.10648785f, -0.03390637f, 
    -0.20143785f, 0.11457648f, 0.08883753f, 0.24090351f, -0.00359661f, 0.00288525f, 0.08123795f, 0.00205080f, 
    0.04125062f, -0.00602345f, -0.02357492f, 0.02591980f, -0.02423920f, 0.02251558f, -0.05712063f, -0.07074662f, 
    -0.04648045f, 0.01022608f, 0.01652750f, 0.08167832f, 0.09936267f, -0.03214325f, 0.01638731f, -0.11268899f, 
    -0.02705524f, 0.24833174f, -0.23269175f, 0.01994709f, 0.07534548f, -0.13206482f, 0.06137659f, 0.00989834f, 
    0.06727025f, -0.05277431f, -0.07108764f, -0.08647121f, 0.00132534f, -0.06044811f, -0.08407582f, -0.12383606f, 
    0.12669778f, 0.01711713f, -0.02952195f, 0.11153682f, 0.03536456f, -0.03719010f, 0.03792675f, 0.02270511f, 
    -0.28176424f, -0.03241206f, -0.01543456f, 0.08694220f, 0.05582865f, 0.18549670f, 0.07693695f, 0.00770431f, 
    -0.06536031f, 0.04472096f, -0.13238469f, 0.21865557f, 0.04749025f, -0.05193063f, -0.24502054f, 0.01544502f, 
    0.17651010f, -0.06412774f, 0.06414329f, -0.04850209f, 0.04494010f, 0.08773168f, -0.20914428f, 0.06791776f, 
    0.25511712f, 0.02842295f, -0.13684715f, -0.02327995f, 0.10862447f, -0.05240383f, -0.00253126f, -0.08509897f, 
    -0.06541251f, -0.08742745f, -0.11785128f, -0.18616697f, 0.07679616f, 0.02139520f, 0.08010385f, -0.15431400f, 
    -0.02789278f, 0.04099865f, 0.04593839f, -0.03867820f, 0.02640736f, -0.03502733f, 0.04717162f, 0.08626832f, 
    0.00459186f, -0.01247421f, -0.18400121f, -0.10741942f, 0.10175713f, 0.22940633f, -0.12080172f, -0.08680369f, 
    0.19758612f, 0.04849149f, 0.05678545f, 0.00436839f, 0.02814038f, -0.02896344f, -0.07179553f, -0.07157201f, 
    0.00212281f, -0.16161704f, 0.02359094f, 0.03050627f, 0.05141747f, -0.05904955f, -0.06013143f, -0.05453890f, 
    0.17167756f, -0.01562243f, 0.00687356f, 0.09026127f, 0.04926416f, 0.10216218f, 0.03292681f, 0.11814366f, 
    -0.13697349f, 0.02195637f, 0.14877252f, 0.03508686f, -0.08984388f, 0.01428571f, -0.11862867f, 0.17079926f, 
    -0.03914138f, -0.13744010f, -0.12753348f, 0.02370850f, 0.09387047f, -0.08198325f, -0.03953660f, -0.15015295f, 
    0.21725480f, 0.05120766f, 0.04777518f, 0.05985003f, 0.12952821f, -0.17130156f, 0.00174003f, -0.04423481f, 
    -0.02257697f, 0.03016807f, -0.07062010f, -0.06339210f, -0.41700858f, -0.08903453f, -0.02882193f, -0.04168307f, 
    0.18578239f, 0.18397124f, 0.05000116f, 0.06601496f, -0.04630831f, -0.00174688f, -0.15544055f, 0.02129424f, 
    0.13449220f, 0.15803032f, -0.00652686f, 0.13482082f, -0.03585040f, 0.06383982f, -0.03700016f, -0.02869702f, 
    -0.05118527f, -0.22012931f, 0.05024796f, -0.06662983f, -0.15291223f, -0.10307265f, 0.06057937f, -0.00859034f, 
    0.02008765f, -0.06533572f, -0.13844049f, -0.09234031f, -0.11852299f, -0.00636125f, -0.01998770f, -0.03032961f, 
    0.20299144f, -0.08366812f, -0.03087703f, -0.07637198f, -0.07137355f, -0.04754389f, -0.08394344f, -0.04069416f, 
    -0.08284070f, 0.12737623f, -0.08584430f, 0.05266799f, -0.04439429f, -0.13088736f, 0.20372196f, 0.10896017f, 
    -0.05734979f, 0.06599686f, 0.00387220f, -0.00968126f, -0.01377751f, 0.02306619f, -0.00466424f, -0.00098706f, 
    -0.13224590f, 0.07503761f, -0.11778290f, 0.10943398f, 0.07023375f, 0.01855252f, -0.06562863f, 0.04507862f, 
    -0.04259481f, -0.05198614f, -0.10274784f, -0.12045976f, 0.11454006f, -0.05596691f, 0.04715676f, 0.01116015f, 
    -0.01808526f, -0.01217617f, 0.05622630f, -0.07275036f, -0.07180472f, 0.01761753f, 0.03541707f, 0.04452074f, 
    -0.15419595f, -0.08868642f, 0.04005688f, 0.00262841f, -0.01119185f, -0.01747532f, 0.00091759f, -0.03362185f, 
    -0.02595450f, 0.11166418f, 0.04380952f, 0.03128973f, -0.21083121f, 0.05364878f, 0.06169733f, -0.27988121f, 
    -0.11967287f, 0.09809855f, 0.00344637f, -0.05453845f, -0.13250750f, -0.21120121f, -0.04051856f, 0.00664452f, 
    -0.13219742f, 0.05820121f, 0.02909287f, 0.12948328f, 0.00812306f, -0.05619706f, 0.02834106f, 0.05208356f, 
    0.00799617f, 0.14007424f, 0.13948096f, 0.01754998f, -0.37696218f, 0.13150676f, 0.01350606f, 0.04097091f, 
    0.02882709f, 0.12532300f, 0.06753615f, -0.07513890f, -0.08041196f, 0.12045439f, -0.16535607f, 0.14421356f, 
    -0.40659705f, -0.09951089f, -0.14014092f, -0.02217815f, 0.08700237f, -0.00869204f, -0.08964113f, 0.09016842f, 
    0.05992090f, 0.02074839f, 0.04402389f, -0.01360685f, 0.02592829f, -0.12011310f, -0.11968402f, 0.00025894f, 
    0.01829454f, -0.02370431f, -0.08771338f, 0.10275463f, 0.00054455f, 0.04698589f, 0.04417638f, -0.03100981f, 
    -0.39127493f, -0.26074541f, -0.15251021f, 0.08227665f, 0.10765908f, -0.11201011f, -0.02958689f, 0.08290780f, 
    0.13325115f, 0.12466267f, 0.05249430f, -0.01641806f, 0.14760645f, -0.21175578f, 0.09100335f, 0.26044106f, 
    0.01845827f, -0.08729219f, -0.01380858f, 0.13986108f, 0.04455157f, 0.07365807f, -0.20485437f, -0.07305101f, 
    0.14213628f, -0.02142487f, -0.11097330f, 0.05229454f, 0.10151654f, -0.09309046f, 0.00014589f, 0.00827982f, 
    0.02840022f, -0.04286246f, -0.04797022f, -0.09836243f, -0.16500594f, -0.28902709f, 0.13725510f, 0.30078167f, 
    0.08616327f, -0.06148171f, -0.14887661f, 0.00754338f, 0.10570381f, 0.01282110f, 0.05652788f, -0.05603287f, 
    -0.03794011f, 0.03701571f, 0.25271863f, -0.05687255f, 0.02433732f, -0.03919820f, 0.00012279f, -0.03876645f, 
    -0.02531680f, -0.08311404f, -0.17043947f, -0.09381602f, -0.25092575f, 0.14575268f, 0.09551753f, -0.22673573f, 
    0.04970007f, -0.14471118f, 0.09306722f, -0.00134290f, -0.04574410f, -0.01782253f, -0.01374616f, -0.06408616f, 
    -0.30601612f, -0.08344514f, -0.20152864f, 0.02830655f, 0.05767554f, 0.03918837f, -0.03204947f, -0.06592557f, 
    0.04614178f, -0.12710193f, 0.15305769f, 0.03352675f, 0.06054535f, 0.11561158f, -0.18087700f, -0.00098138f, 
    0.01422772f, -0.12882379f, 0.11604460f, -0.07339954f, 0.13026495f, 0.02808457f, 0.08386170f, 0.06654259f, 
    0.02555072f, -0.09298647f, -0.03845929f, 0.08478463f, 0.04174608f, -0.09143223f, -0.06365091f, -0.00510105f, 
    -0.12052068f, 0.06320895f, -0.08444853f, 0.17475586f, -0.11613651f, -0.14735715f, 0.01884301f, 0.20226987f, 
    -0.10808039f, -0.08532944f, -0.01381289f, 0.08156559f, -0.00345375f, 0.10045888f, -0.05623534f, 0.08376869f, 
    0.00186393f, -0.00473199f, 0.11173551f, -0.00544305f, -0.01488400f, 0.10099941f, 0.01826981f, 0.01617141f, 
    0.15852283f, 0.10425278f, -0.01145372f, -0.01175037f, 0.09169646f, 0.00772940f, -0.05059178f, 0.01077986f, 
    -0.08559250f, 0.13846704f, 0.07215758f, 0.00523179f, -0.16078338f, 0.00268561f, 0.13182248f, 0.19996691f, 
    -0.21587683f, -0.05805096f, -0.25309879f, -0.13667509f, 0.10903241f, 0.04916188f, -0.04657009f, 0.03622472f, 
    -0.06608712f, -0.09857728f, -0.00874257f, 0.01220514f, -0.20624602f, 0.01718660f, -0.05016788f, -0.14308469f, 
    -0.01480540f, 0.18058500f, -0.09390617f, 0.02722911f, -0.05198175f, -0.00516090f, 0.02490406f, -0.18983620f, 
    -0.10219244f, 0.16364558f, 0.20977543f, -0.35107777f, 0.02712149f, -0.07179500f, -0.10149142f, 0.05594202f, 
    0.11620296f, 0.19106229f, 0.07550423f, 0.28721368f, -0.33901599f, 0.11642583f, -0.07460552f, -0.06777073f, 
    0.10486677f, -0.03142472f, 0.02871282f, -0.10356132f, -0.06895214f, -0.04548134f, -0.02786816f, -0.22816016f, 
    -0.09336557f, -0.20652939f, 0.26204661f, 0.32007188f, -0.02130087f, -0.01726397f, 0.04001253f, 0.04118830f, 
    0.01514577f, -0.00389416f, 0.05453712f, -0.07696862f, -0.18504651f, -0.05773630f, 0.11824779f, 0.05695051f, 
    -0.06764009f, -0.10309933f, 0.12012544f, -0.00625787f, 0.07460926f, 0.17109133f, -0.12300836f, -0.01274545f, 
    -0.27610818f, -0.15471199f, 0.02872468f, -0.03291680f, 0.08086919f, -0.16797242f, 0.14893749f, -0.04707440f, 
    0.10001478f, -0.06433310f, -0.17203052f, -0.04201407f, -0.13643929f, 0.16622585f, 0.01587551f, 0.00783656f, 
    0.00451499f, -0.04835271f, 0.00993218f, 0.04574628f, 0.09896347f, 0.00922780f, 0.10170812f, 0.06292944f, 
    -0.18246287f, -0.18363708f, -0.09587873f, 0.03585069f, -0.04054201f, -0.04424822f, 0.06075605f, -0.10976341f, 
    -0.06587311f, 0.05218177f, -0.06968857f, 0.23147172f, 0.03035138f, -0.03597356f, 0.02169584f, 0.22817381f, 
    -0.10896509f, 0.00198386f, 0.03414255f, 0.01359323f, -0.00108998f, -0.08922189f, -0.06300125f, 0.11850603f, 
    -0.07411180f, -0.08852942f, -0.01725977f, 0.14799806f, -0.01965391f, 0.03665296f, -0.05223157f, 0.11904434f, 
    -0.04772781f, -0.04077243f, -0.05271417f, 0.16537796f, 0.06399605f, 0.08031782f, -0.01962183f, -0.16832153f, 
    0.02617401f, -0.02911214f, 0.01767472f, 0.02408074f, -0.05021956f, 0.11236575f, 0.07361627f, -0.17820406f, 
    0.06534989f, 0.06481440f, 0.06308740f, -0.24635464f, 0.07392375f, 0.01543502f, 0.27255872f, 0.00145935f, 
    -0.02188731f, 0.01626791f, -0.06142458f, 0.10495415f, 0.02386139f, 0.14476746f, 0.19534953f, -0.01274952f, 
    -0.04408590f, -0.07258788f, -0.04152038f, -0.00356072f, -0.05523274f, -0.06858230f, 0.12411246f, 0.06433056f, 
    0.03974003f, -0.03855569f, -0.05936392f, 0.19561082f, -0.05365166f, -0.03936159f, 0.03479644f, 0.01031930f, 
    0.00747919f, 0.01276478f, 0.01201277f, 0.13726911f, -0.14774631f, 0.15755068f, 0.20857944f, -0.16912338f, 
    0.02350135f, -0.02530749f, 0.00332319f, -0.16639818f, -0.04466670f, 0.04611114f, 0.13343547f, 0.06336407f, 
    0.21330102f, 0.05177453f, 0.00608353f, 0.05269343f, -0.03538961f, 0.08945491f, -0.16297095f, -0.07016082f, 
    0.16415380f, -0.03931789f, 0.00198288f, 0.04590952f, -0.31102338f, -0.07861645f, 0.00531201f, -0.01349674f, 
    -0.11206945f, 0.10585292f, 0.05063891f, 0.05964968f, -0.05695258f, 0.18398327f, 0.19092062f, 0.10911872f, 
    0.13649169f, 0.02470936f, 0.01081971f, 0.09390071f, -0.10989858f, -0.04796959f, -0.02466625f, 0.02291283f, 
    -0.18767713f, -0.00891715f, 0.21004218f, 0.22000737f, -0.17187728f, 0.15010148f, -0.11740827f, -0.25401103f, 
    0.00245245f, 0.06855406f, 0.11794177f, 0.05137367f, -0.04651399f, -0.02727190f, -0.13349567f, -0.15439054f, 
    -0.00564875f, 0.04188370f, 0.12328414f, -0.13464004f, -0.02253205f, -0.16410287f, -0.08456183f, -0.01702313f, 
    0.06572008f, -0.14104752f, -0.02307201f, -0.01794139f, 0.05728732f, 0.02432205f, 0.07397091f, -0.01396657f, 
    -0.05692955f, 0.05324587f, -0.03589293f, -0.07446864f, -0.02337326f, -0.12565544f, 0.05753423f, -0.16855614f, 
    0.06282726f, 0.06401939f, 0.00703332f, -0.00620248f, 0.03606097f, 0.07647226f, 0.01542715f, -0.05665955f, 
    0.02589864f, 0.03195172f, 0.03077441f, 0.09932434f, 0.15268502f, -0.11714964f, -0.10880493f, -0.10894001f, 
    0.10267840f, -0.11737163f, -0.13677335f, -0.17489827f, 0.00114102f, 0.07088625f, -0.07578272f, -0.03157082f, 
    -0.17679802f, 0.13080437f, 0.20452158f, 0.30763376f, -0.11199322f, -0.09391651f, 0.07518049f, 0.04373033f, 
    0.04964229f, -0.06714903f, -0.06836947f, 0.03154482f, -0.40737632f, -0.18601267f, -0.08504064f, 0.09408348f, 
    -0.08262694f, 0.05020402f, 0.11130035f, -0.04320829f, 0.13420087f, 0.07902742f, 0.13204463f, 0.00132928f, 
    -0.20232297f, -0.01578275f, -0.07785265f, -0.18178992f, -0.00529176f, -0.01790745f, -0.02166462f, -0.26018837f, 
    0.01545455f, -0.05179463f, 0.01287986f, -0.04910858f, -0.07152063f, 0.22594823f, 0.11489357f, -0.13981977f, 
    -0.02769306f, -0.04329575f, 0.04368939f, -0.08333787f, 0.03216674f, -0.08215377f, -0.07324727f, 0.11184276f, 
    -0.09922621f, -0.19983307f, 0.02110232f, -0.07518946f, 0.01229408f, 0.08609103f, -0.00605952f, 0.02542934f, 
    -0.11696295f, -0.02566131f, -0.00186787f, 0.18160346f, 0.13452154f, -0.18978791f, 0.16734001f, -0.10897966f, 
    -0.01373691f, -0.01451693f, 0.19478242f, -0.01914583f, 0.13291113f, -0.04883936f, 0.01391486f, -0.03779120f, 
    -0.03519027f, 0.11602888f, 0.17632256f, -0.06142679f, -0.04080819f, -0.10046379f, -0.10348398f, -0.01786107f, 
    -0.19088359f, 0.06149508f, 0.01649571f, -0.00591419f, -0.17861968f, 0.04685099f, -0.15936933f, 0.09861070f, 
    0.03665465f, -0.06719179f, -0.07883020f, -0.08664369f, 0.00174949f, -0.05156427f, 0.09854084f, -0.01962056f, 
    0.10812398f, -0.03926549f, -0.12093026f, -0.15108129f, -0.17076744f, 0.08095721f, 0.03146312f, -0.02072334f, 
    -0.01027355f, 0.04103887f, 0.00744564f, 0.15306216f, -0.34577027f, 0.23275495f, 0.14536344f, -0.04317375f, 
    0.06213799f, -0.01640981f, -0.03694940f, 0.03376335f, 0.03426290f, -0.00634367f, 0.07230025f, -0.13562679f, 
    -0.06010415f, -0.13495375f, -0.17962824f, -0.08873168f, -0.05299935f, -0.10930093f, -0.01908915f, 0.04828883f, 
    -0.04035554f, 0.03983163f, -0.01598224f, 0.01424116f, -0.55732930f, 0.16660139f, 0.11246486f, 0.22203262f, 
    0.04534543f, 0.15926643f, 0.01730476f, 0.02110568f, -0.08246028f, 0.08864475f, 0.03022446f, 0.02186568f, 
    0.14818028f, 0.07871564f, 0.08632652f, -0.10736974f, -0.01433881f, -0.11192823f, -0.11531365f, 0.08575401f, 
    0.06607331f, -0.04008904f, -0.07768749f, -0.04326943f, 0.15171209f, -0.11060341f, 0.23043315f, -0.19858666f, 
    0.09858201f, -0.05434273f, 0.08942764f, 0.06478409f, 0.00915847f, 0.12467878f, 0.02082207f, 0.19918057f, 
    -0.24699965f, 0.13790116f, 0.17289320f, 0.15576996f, 0.02736145f, 0.05461645f, 0.07694495f, 0.06773864f, 
    -0.00379893f, 0.03319533f, 0.05716829f, 0.11475176f, -0.35550067f, 0.05624449f, -0.25125077f, -0.28455228f, 
    -0.02698354f, -0.07781459f, -0.02066050f, -0.13412467f, 0.04401353f, 0.01557355f, 0.12078027f, -0.10521987f, 
    -0.19369845f, 0.09637070f, 0.03158894f, 0.26353332f, 0.07335351f, 0.01139014f, -0.00352465f, 0.09859885f, 
    0.04515340f, 0.15123504f, -0.04297915f, 0.03944362f, -0.12550800f, -0.17169176f, 0.03229488f, 0.03162685f, 
    -0.08406065f, 0.09434249f, -0.01146346f, 0.09590052f, 0.01530112f, -0.00674248f, -0.03268902f, 0.00968835f, 
    -0.19382381f, 0.03679030f, 0.08712064f, 0.27297431f, -0.03022066f, -0.04305846f, 0.02254006f, -0.05454348f, 
    -0.00673425f, -0.04007124f, 0.03001168f, -0.07569340f, 0.27726346f, -0.05615243f, -0.03169674f, -0.07807807f, 
    0.05896023f, 0.00436554f, -0.01766123f, 0.04713205f, 0.05096745f, -0.09276962f, 0.02727892f, 0.08587118f, 
    0.12244958f, -0.07022068f, 0.00238673f, -0.13159341f, 0.12242830f, -0.08322926f, -0.05647417f, -0.15914102f, 
    0.04113908f, 0.08051697f, 0.09309900f, 0.13609700f, -0.08771405f, 0.12559469f, -0.13472259f, 0.30652142f, 
    0.06790766f, 0.03037273f, -0.01404296f, 0.01429086f, 0.09758563f, -0.00127446f, -0.09751976f, -0.10092042f, 
    0.17621255f, -0.16015683f, -0.03495325f, 0.20890464f, 0.07482845f, 0.09373982f, 0.02476617f, 0.03327154f, 
    0.04623571f, -0.01019902f, -0.16227242f, -0.05092888f, 0.14812948f, -0.05234364f, 0.12455361f, -0.09195681f, 
    -0.06524313f, -0.00222808f, 0.01139352f, -0.06985067f, -0.00883291f, 0.17327528f, 0.09703564f, -0.03982273f, 
    -0.04588714f, -0.11652923f, -0.25166783f, 0.13399836f, 0.00725833f, 0.03402509f, 0.03186040f, 0.07153954f, 
    0.09613241f, -0.14366418f, -0.04579743f, -0.14873432f, 0.27315810f, -0.27145797f, -0.07562816f, 0.03817846f, 
    -0.03495372f, 0.09120313f, -0.06234338f, 0.05563997f, 0.03344178f, -0.02458313f, 0.12888093f, -0.18084627f, 
    -0.07625479f, -0.05494754f, -0.06406005f, -0.05936700f, 0.06594586f, 0.02679452f, 0.02189763f, -0.02377063f, 
    0.09727382f, -0.02883163f, 0.01964023f, 0.02916770f, -0.15291403f, 0.02945414f, -0.04194937f, -0.29250008f, 
    -0.10419375f, 0.00152791f, -0.02922500f, 0.03410529f, -0.08730423f, -0.04205620f, -0.02136498f, -0.00317102f, 
    -0.13834256f, -0.10073376f, -0.04648703f, -0.09809580f, -0.06065593f, -0.03918633f, 0.01711454f, -0.04470560f, 
    -0.11584897f, -0.02669218f, -0.02025434f, 0.14712410f, -0.07032043f, 0.00253829f, -0.03433502f, -0.17737183f, 
    -0.05744148f, 0.03347056f, 0.11460246f, -0.15968783f, -0.12460270f, 0.09814138f, 0.14257851f, 0.18566659f, 
    -0.16552210f, 0.18622802f, -0.03240683f, 0.27632022f, -0.02418074f, 0.17732181f, -0.05308348f, 0.06571469f, 
    0.04313815f, 0.10141116f, 0.02732380f, -0.05009495f, 0.17830792f, -0.21192506f, -0.01868194f, 0.20273280f, 
    0.00684510f, 0.05545177f, 0.13722631f, -0.03222772f, -0.03749444f, 0.03013068f, -0.04110442f, 0.13747343f, 
    -0.00002468f, 0.01740520f, 0.05882600f, -0.16008741f, -0.11073382f, -0.02990362f, 0.04235481f, 0.10687188f, 
    -0.04358919f, 0.08081210f, 0.11069410f, 0.02715037f, -0.09270679f, -0.26989117f, 0.05811518f, 0.08067659f, 
    -0.00755537f, 0.03092466f, -0.09109586f, 0.09918377f, -0.00287864f, 0.05184707f, -0.10544945f, 0.07366183f, 
    -0.11164200f, -0.06713434f, -0.02233049f, 0.14743763f, -0.03152445f, 0.01869972f, 0.04911394f, -0.04227803f, 
    -0.01221676f, 0.10108083f, -0.04735114f, -0.01110312f, 0.04579834f, 0.08169009f, -0.01101509f, -0.39298257f, 
    0.01703636f, -0.01294969f, 0.07434539f, 0.09189770f, -0.07726790f, 0.02408087f, -0.02577114f, -0.00404927f, 
    -0.05170358f, -0.09929373f, -0.07552119f, -0.00203160f, -0.09645442f, 0.03284786f, 0.02061262f, 0.08953241f, 
    0.10595834f, -0.16886985f, 0.01762634f, 0.12427929f, -0.00543845f, -0.05775418f, -0.10840048f, 0.09092826f, 
    0.02847033f, 0.12456396f, 0.02817434f, -0.06270153f, -0.08626141f, -0.11321745f, 0.05751098f, -0.08740029f, 
    0.03481221f, 0.03058009f, 0.11333527f, -0.11919130f, 0.00733054f, -0.08003852f, -0.02590322f, 0.11591950f, 
    0.07896069f, 0.00814876f, -0.09074837f, 0.05908147f, -0.10715076f, 0.24394256f, 0.08192935f, -0.15134533f, 
    -0.00114694f, 0.01368064f, 0.03615152f, -0.02185578f, 0.07317977f, -0.02506506f, -0.15573657f, -0.17918661f, 
    0.06996315f, -0.15709122f, -0.00151147f, -0.08626676f, -0.11784767f, 0.03564836f, 0.01709041f, -0.16148272f, 
    -0.03334196f, -0.06479719f, 0.15446250f, 0.18753441f, 0.01860094f, -0.06275693f, -0.02606364f, -0.22693424f, 
    -0.05864144f, -0.01902908f, 0.02162495f, -0.08624207f, -0.05035755f, 0.03943964f, -0.18189372f, 0.12557666f, 
    0.20094457f, -0.00777945f, -0.02636322f, -0.27198735f, -0.19940645f, 0.09309398f, 0.08650967f, -0.01554850f, 
    -0.09347242f, -0.17157772f, -0.06592303f, -0.22628109f, 0.32797819f, -0.56537753f, 0.05561854f, 0.00415143f, 
    -0.04310337f, 0.02854346f, -0.01663846f, -0.01962682f, 0.07779963f, 0.03057625f, 0.09521813f, 0.08179731f, 
    -0.14552540f, -0.09257405f, -0.08314509f, 0.00858107f, 0.09366640f, -0.02034977f, 0.01938359f, 0.06590991f, 
    -0.11808150f, 0.02187202f, -0.15803395f, 0.01633523f, 0.12620385f, 0.07653330f, -0.08452808f, -0.19922049f, 
    0.12725244f, 0.09419509f, 0.13353233f, 0.04280625f, -0.12556590f, -0.03767715f, 0.16094522f, -0.05732394f, 
    0.14460756f, -0.18475074f, -0.07683400f, 0.06509750f, -0.10823558f, -0.04615891f, -0.06419776f, 0.12516411f, 
    -0.06119730f, 0.04790833f, -0.00187871f, 0.02888228f, 0.08806141f, -0.08011349f, -0.19753926f, 0.26170355f, 
    -0.00492463f, 0.16569173f, -0.02889809f, -0.00318492f, -0.00054655f, -0.10884909f, -0.03071064f, -0.14520931f, 
    -0.05394337f, 0.08875886f, 0.07725267f, 0.09921259f, -0.02228416f, 0.05539504f, -0.01388641f, -0.03105925f, 
    0.15863606f, -0.00178823f, 0.06116347f, -0.07204664f, 0.11611127f, -0.15941881f, -0.20798586f, -0.11135202f, 
    -0.03828314f, -0.07185774f, 0.09890280f, 0.02015532f, 0.00605802f, 0.07581504f, 0.02196370f, -0.08107095f, 
    -0.11168882f, 0.11475915f, -0.14710568f, -0.09753231f, 0.05541199f, -0.05574225f, 0.01171810f, -0.10781249f, 
    -0.05872366f, -0.13168567f, -0.05206605f, -0.14054915f, 0.07294980f, 0.03662438f, -0.01652293f, -0.30528691f, 
    -0.02239058f, -0.00964327f, 0.00422646f, -0.08697313f, 0.06692613f, 0.03233971f, -0.02971992f, -0.03988270f, 
    0.24393779f, 0.12100925f, -0.20537372f, 0.02596637f, -0.02688798f, 0.09851710f, -0.00788514f, -0.01670809f, 
    -0.08972670f, 0.06995730f, -0.07752440f, -0.10173270f, 0.27552870f, 0.16442244f, 0.01477189f, -0.32867038f, 
    0.01520735f, 0.06812126f, 0.08426586f, 0.06207396f, 0.01313609f, 0.03347365f, -0.01414181f, 0.04319883f, 
    -0.23659225f, 0.04348483f, 0.01927834f, -0.11930919f, -0.02052901f, 0.04408593f, -0.06923491f, -0.06883651f, 
    -0.06171702f, -0.01080143f, 0.03035051f, -0.17352428f, 0.17743278f, -0.16007888f, 0.01800827f, 0.06702118f, 
    0.01139255f, 0.10355440f, 0.06935412f, 0.10580927f, -0.02731727f, -0.11516353f, -0.14015123f, -0.26759219f, 
    0.07924557f, -0.02629468f, -0.23411584f, 0.15723477f, 0.04211922f, -0.06231258f, 0.11518891f, 0.01167407f, 
    0.04791299f, 0.03782444f, -0.01586886f, -0.02025742f, 0.05924733f, -0.03618816f, -0.05447945f, -0.26059487f, 
    -0.08033308f, -0.09170978f, 0.00358496f, -0.16385259f, 0.02664755f, -0.12012003f, -0.00232064f, -0.09095585f, 
    0.10590605f, 0.19135386f, 0.07057458f, -0.18918306f, -0.02237161f, 0.11795028f, 0.00134349f, 0.01135574f, 
    0.03793493f, -0.11216765f, -0.02067521f, -0.10647707f, 0.13246380f, -0.42824146f, 0.14268535f, -0.18650305f, 
    0.02416512f, -0.05025654f, -0.00813740f, -0.05209134f, -0.06794368f, -0.06244319f, 0.16749325f, 0.08339876f, 
    0.30167875f, -0.27656525f, 0.05965641f, -0.10375760f, -0.08362956f, 0.01960484f, 0.11381564f, 0.01057536f, 
    0.03982518f, 0.09549960f, 0.03338130f, 0.09059962f, 0.03796203f, 0.08145020f, 0.13656858f, -0.05410569f, 
    -0.04651499f, -0.05586307f, 0.08769386f, 0.04875552f, -0.04192147f, 0.06011426f, 0.05396076f, 0.12078871f, 
    -0.16157511f, 0.30444321f, 0.16230784f, -0.37252656f, -0.05795807f, 0.00049536f, 0.04041775f, 0.00258059f, 
    0.01469391f, 0.03251694f, 0.02429824f, 0.02119912f, -0.49228215f, 0.01460704f, -0.09689111f, -0.18974115f, 
    -0.00560551f, 0.07586368f, 0.04752958f, 0.12940252f, -0.01451831f, -0.04284972f, 0.16742431f, -0.10175363f, 
    -0.06928983f, -0.09416750f, -0.27229771f, 0.10413873f, 0.04495112f, 0.09534080f, -0.11654022f, -0.01807796f, 
    -0.10418221f, 0.04388025f, 0.10103136f, -0.03663129f, 0.11419750f, -0.02082270f, -0.12763560f, 0.18511707f, 
    -0.07068033f, 0.03050165f, -0.00873821f, -0.01412239f, -0.14221005f, -0.07513820f, -0.09698618f, -0.13656394f, 
    -0.10294417f, -0.13670310f, -0.07750034f, 0.01500850f, -0.05648455f, 0.13596521f, 0.03485048f, 0.01009176f, 
    -0.06699498f, 0.07311006f, 0.07683036f, 0.09120803f, 0.09175667f, -0.12400616f, 0.10684624f, -0.11268719f, 
    0.06854097f, 0.07745948f, 0.04961879f, 0.05252686f, -0.11752288f, 0.14590697f, 0.08847264f, 0.09378508f, 
    0.08875476f, 0.02783243f, 0.11752620f, 0.13309768f, 0.07390511f, 0.06095661f, 0.00842593f, 0.02355027f, 
    -0.07656707f, -0.02070723f, 0.01988848f, -0.00637164f, 0.30737910f, 0.05253506f, 0.08965329f, -0.04314678f, 
    -0.09595971f, 0.00389326f, 0.03503264f, -0.12527296f, -0.00034580f, -0.01636887f, -0.02611019f, 0.04834487f, 
    -0.02392272f, 0.11184118f, 0.08866151f, 0.18549885f, 0.04609438f, -0.02339727f, 0.06139132f, 0.01491692f, 
    -0.11366125f, 0.05490475f, 0.01391864f, -0.06944767f, 0.08977662f, 0.16485289f, -0.01596840f, 0.14341329f, 
    0.06057421f, 0.09811289f, 0.01037418f, -0.02305090f, 0.03576932f, 0.03765154f, -0.03767401f, -0.06151101f, 
    0.12300206f, 0.20759816f, 0.02798743f, 0.16379109f, 0.11190361f, 0.01362138f, 0.04850608f, 0.02175024f, 
    0.01988641f, 0.02968090f, 0.02678397f, -0.00493548f, -0.14076903f, 0.11979826f, 0.00141292f, -0.20575307f, 
    0.05274182f, 0.02666413f, -0.07332398f, -0.01212451f, 0.00994882f, -0.05057514f, -0.01886743f, -0.06466791f, 
    0.14289594f, 0.10594230f, 0.12111722f, 0.21411778f, 0.03439470f, 0.06897933f, 0.05005872f, -0.03845328f, 
    0.01918335f, -0.00873081f, -0.04639102f, -0.05854959f, -0.27830523f, -0.15309432f, -0.20744514f, -0.09434787f, 
    0.04787513f, 0.04884937f, -0.10471379f, -0.01048441f, -0.01661542f, 0.01880491f, 0.00887829f, -0.08733517f, 
    -0.00493931f, 0.05448281f, -0.10487998f, -0.11207628f, -0.02461552f, -0.06851973f, 0.04731863f, -0.02302706f, 
    -0.11535004f, -0.03210418f, -0.10847362f, -0.06036658f, 0.11699682f, -0.22678570f, 0.11447655f, -0.02686894f, 
    0.08374840f, 0.11795863f, 0.02395168f, -0.06594647f, -0.08453952f, -0.05202634f, -0.02684318f, 0.00120573f, 
    0.00885416f, 0.11436828f, -0.02859616f, -0.07273257f, -0.06545986f, -0.03849357f, 0.01612956f, 0.00110599f, 
    0.01524908f, -0.04593702f, 0.00974432f, -0.06773677f, 0.22097754f, 0.13980027f, 0.21179929f, 0.06192620f, 
    0.05879065f, 0.02729768f, -0.01967187f, -0.08236688f, -0.06072242f, 0.03903282f, 0.01550012f, -0.05511218f, 
    -0.16489835f, 0.03366268f, -0.11767767f, -0.19913532f, -0.01559935f, -0.00608586f, 0.04075187f, -0.00783891f, 
    -0.07827154f, 0.07069227f, -0.00090226f, -0.05516717f, -0.08458571f, -0.09022795f, -0.16025876f, 0.02581503f, 
    -0.07653674f, 0.06907130f, -0.10669495f, -0.01918648f, 0.07382140f, 0.03701939f, -0.05555703f, -0.04209638f, 
    0.13789016f, -0.26270747f, -0.07799693f, -0.11005987f, 0.07589687f, 0.01622964f, -0.01246723f, -0.06674676f, 
    -0.00088243f, -0.07256626f, -0.06390467f, -0.00946277f, -0.11478563f, -0.08045500f, 0.03380668f, 0.13609697f, 
    -0.04846470f, -0.08183679f, 0.03444676f, -0.09788549f, 0.00001535f, 0.04138863f, 0.08150949f, 0.02937744f, 
    0.07970858f, -0.15243530f, 0.00318717f, -0.12400056f, 0.12918882f, 0.02409538f, 0.01048666f, -0.09044000f, 
    0.00472224f, -0.04026650f, -0.04995863f, -0.04411022f, -0.13096319f, -0.08702983f, -0.11456656f, -0.09132504f, 
    0.05225706f, 0.00732398f, -0.03694803f, 0.08776794f, -0.02361269f, -0.02622880f, -0.01547564f, -0.09103613f, 
    -0.13017909f, 0.14843123f, -0.05192117f, 0.12318348f, 0.04003016f, -0.04182673f, -0.06516358f, 0.04369850f, 
    0.02516202f, -0.05566864f, -0.02117842f, -0.06903682f, -0.04298011f, 0.20096216f, -0.11329331f, -0.15750368f, 
    0.03330993f, 0.02319287f, 0.01285944f, -0.02844132f, -0.04121514f, -0.06464721f, -0.03918076f, -0.02369987f, 
    -0.04984822f, 0.02962101f, -0.01346018f, 0.04387090f, -0.09764957f, -0.06924891f, -0.00349939f, -0.05889486f, 
    -0.00993341f, 0.00495106f, -0.07529806f, -0.05186719f, -0.14217091f, 0.01595392f, 0.16237766f, -0.15701996f, 
    -0.03853156f, -0.03495923f, -0.02574616f, -0.01832670f, 0.04395164f, 0.00441114f, 0.02559338f, -0.02218411f, 
    0.16054474f, 0.11664775f, 0.15958445f, -0.03154950f, -0.07174160f, 0.00800025f, -0.02481888f, -0.07342139f, 
    -0.01332070f, 0.00998540f, -0.07390090f, -0.04515161f, 0.19371535f, 0.20752411f, 0.02439854f, 0.12614183f, 
    0.06973589f, -0.01067888f, -0.04246782f, 0.01873739f, -0.04803805f, 0.01781601f, -0.06321362f, -0.08032185f, 
    0.14363205f, -0.02289407f, 0.14439492f, 0.04881196f, 0.06110354f, -0.02178328f, -0.00162198f, -0.07157169f, 
    -0.04622840f, 0.05527126f, 0.03192503f, 0.01724873f, -0.00053009f, -0.03630213f, 0.11962169f, 0.09075504f, 
    0.13881190f, 0.07400443f, -0.03245318f, -0.09198230f, -0.09299587f, -0.11908236f, -0.04829343f, -0.07324637f, 
    -0.12954423f, -0.09159013f, -0.01363979f, -0.18039364f, 0.11353036f, 0.07662005f, 0.00399418f, 0.01562870f, 
    0.04886473f, -0.01278510f, -0.06736185f, -0.01596149f, -0.04547484f, 0.02091738f, 0.09069154f, 0.11601736f, 
    0.14909799f, -0.14607731f, 0.07487623f, -0.02479318f, -0.03944200f, -0.00342531f, -0.07550265f, -0.07026349f, 
    -0.07531394f, 0.03665429f, -0.03168397f, -0.21284722f, -0.05378055f, -0.01052702f, -0.00804561f, -0.11953351f, 
    -0.00429659f, -0.00135129f, -0.04278604f, -0.05574884f, -0.06991769f, -0.03581152f, 0.03010072f, -0.05612883f, 
    -0.02202355f, -0.02139150f, -0.01919756f, -0.02536471f, -0.06754281f, 0.01714955f, -0.01851462f, -0.00726587f, 
    -0.07055204f, 0.18456727f, 0.07542513f, 0.05002979f, 0.03065165f, -0.00739424f, 0.05122541f, 0.03824053f, 
    0.00497303f, 0.01735642f, 0.01912676f, -0.03686746f, 0.29819667f, -0.01396770f, -0.01946717f, -0.06239991f, 
    -0.18448851f, 0.07113217f, 0.01654346f, -0.06710818f, -0.05168898f, 0.06512155f, -0.06064277f, -0.03087214f, 
    0.07196314f, 0.08975248f, 0.05570029f, 0.18884254f, 0.08309163f, 0.02560571f, -0.03605713f, 0.02854344f, 
    -0.01308933f, -0.03819735f, -0.11471833f, -0.14961784f, 0.21106550f, -0.23551908f, 0.08519896f, 0.21867096f, 
    0.10540619f, -0.05017273f, 0.04054908f, -0.02814715f, 0.02135514f, -0.06873328f, -0.12654324f, -0.08728656f, 
    -0.08557986f, -0.06345518f, -0.04023347f, -0.08902882f, -0.01951312f, -0.00116319f, 0.04287317f, -0.03528431f, 
    -0.01012012f, -0.00741093f, 0.02558131f, -0.05137685f, -0.24725360f, -0.04232117f, -0.17222163f, -0.11160059f, 
    -0.03149844f, -0.11352888f, -0.03225630f, -0.04137197f, -0.09361558f, 0.04603084f, -0.02554073f, 0.01745248f, 
    0.03595309f, 0.08865123f, 0.16780943f, 0.07686358f, 0.04089254f, 0.13025779f, 0.03321594f, 0.05200727f, 
    0.02170195f, -0.05673019f, -0.02625767f, 0.05652132f, -0.14084333f, 0.05117754f, 0.18337215f, 0.05671137f, 
    0.14015129f, 0.02481160f, 0.07799525f, -0.05422663f, -0.04915493f, 0.04086136f, 0.01115409f, -0.02214982f, 
    -0.16078848f, 0.07831131f, -0.03581679f, -0.03946739f, -0.01952613f, 0.05096584f, 0.04420746f, -0.08217317f, 
    0.04482568f, -0.07283802f, 0.05545465f, -0.07841694f, 0.03910937f, -0.01655069f, 0.15341718f, -0.01811334f, 
    0.03185897f, -0.02849505f, -0.03513299f, 0.10410155f, 0.00093118f, 0.01461510f, -0.03035972f, 0.01333735f, 
    -0.06205664f, -0.03503935f, 0.14327730f, 0.20635708f, 0.01741846f, -0.06625651f, -0.07406877f, 0.00918274f, 
    0.00750566f, -0.08223207f, -0.01943836f, 0.00135496f, -0.25673038f, -0.03259273f, -0.03511387f, -0.04868065f, 
    0.01613668f, -0.02268775f, -0.03280164f, -0.02386521f, -0.02232723f, 0.05467166f, -0.01398193f, 0.00806925f, 
    -0.12056374f, 0.05460632f, 0.04038205f, 0.06392197f, 0.05400503f, -0.00198465f, -0.01720497f, -0.04148772f, 
    -0.06472353f, 0.06605927f, 0.02678316f, 0.03280273f, -0.17481571f, 0.00065914f, -0.03555389f, 0.06789318f, 
    -0.07740872f, -0.05987289f, -0.05750841f, 0.00185049f, -0.00624439f, -0.03323171f, 0.04558420f, -0.06891275f, 
    0.09577058f, -0.09030949f, 0.05581493f, 0.07418908f, -0.01421992f, -0.03072692f, 0.01434087f, -0.05260507f, 
    -0.06470041f, 0.01119494f, 0.01119263f, 0.02362068f, -0.24010283f, 0.00695095f, -0.13763201f, 0.15818548f, 
    -0.01310091f, -0.04471062f, -0.07471363f, -0.05377961f, -0.03447921f, 0.06784632f, 0.05661548f, -0.00320342f, 
    -0.00185943f, 0.02256788f, -0.01246561f, 0.01833135f, -0.06228415f, -0.08185615f, -0.09814356f, -0.10545289f, 
    0.00893811f, -0.04432761f, 0.01026670f, -0.16058913f, 0.03406702f, -0.03876838f, -0.01786775f, -0.01387755f, 
    -0.03500547f, -0.03773844f, 0.00713635f, -0.01873435f, -0.04667392f, -0.03832254f, -0.08171083f, -0.07108071f, 
    0.22994724f, -0.06307483f, 0.15610780f, -0.11281753f, -0.11123596f, 0.04079739f, -0.08450976f, 0.01705884f, 
    -0.02941935f, 0.06324312f, -0.05102229f, -0.06379518f, 0.18354127f, -0.03358359f, 0.06082210f, 0.06161093f, 
    -0.16187119f, -0.04676032f, 0.06274901f, -0.04244191f, -0.04952244f, 0.02021318f, -0.07517723f, -0.10722788f, 
    -0.12922311f, 0.12317277f, -0.16960712f, -0.09168129f, -0.05819776f, -0.04051493f, -0.00376316f, -0.07545052f, 
    -0.04525929f, -0.01047241f, -0.03691927f, -0.03532983f, -0.16016364f, 0.01144039f, 0.07395497f, -0.16794227f, 
    0.06992485f, -0.06921102f, 0.00141483f, -0.04013431f, -0.02101846f, -0.03877832f, 0.06900461f, 0.03710189f, 
    0.03893872f, 0.06136484f, -0.14964958f, -0.02862731f, -0.02837804f, -0.01906470f, 0.03065774f, -0.01196844f, 
    0.03337490f, 0.04598802f, -0.00282418f, -0.04223667f, -0.16373754f, 0.03903772f, 0.10730973f, 0.06102666f, 
    0.02574281f, 0.04978460f, 0.04042685f, 0.01179506f, -0.03253725f, -0.00037630f, -0.06233746f, -0.01209385f, 
    -0.00469687f, -0.23863189f, -0.05927140f, 0.17824812f, -0.08189937f, -0.06627689f, -0.01935604f, -0.01206784f, 
    0.03861712f, -0.06310847f, -0.01664262f, -0.01837884f, 0.16987810f, -0.06277257f, 0.07491244f, -0.05169301f, 
    -0.04527971f, 0.01229262f, -0.06128988f, 0.07297584f, 0.07593014f, 0.07651156f, 0.02564503f, -0.01684835f, 
    -0.15317014f, -0.06891091f, -0.05366191f, -0.21435642f, -0.03363277f, 0.01959626f, -0.06541172f, -0.08842228f, 
    -0.05431987f, 0.02161160f, -0.03296975f, -0.03569899f, 0.00436156f, -0.01687026f, -0.09791734f, -0.21514837f, 
    0.02883959f, 0.02461226f, -0.06282411f, -0.05375092f, -0.03301459f, 0.03211184f, -0.04267397f, -0.04351377f, 
    -0.21526100f, 0.10341925f, -0.07131595f, -0.14645606f, -0.10373046f, -0.01565634f, 0.05297345f, -0.08184336f, 
    -0.06504718f, -0.01370704f, -0.01205741f, -0.05124576f, -0.01712060f, 0.07798129f, -0.00018936f, 0.08148650f, 
    0.02545910f, 0.01935872f, -0.04120031f, -0.09413353f, 0.04350818f, -0.02664075f, 0.02441568f, -0.02758016f, 
    -0.20153318f, -0.12019442f, -0.10780295f, 0.14124061f, 0.00677731f, -0.12803327f, -0.06639472f, -0.01546217f, 
    -0.10726232f, 0.01308809f, 0.04484169f, -0.03626295f, 0.16881864f, 0.03068688f, 0.11114952f, 0.12447219f, 
    0.17888364f, 0.00367662f, 0.03491781f, 0.01176984f, 0.00327278f, -0.06153613f, -0.02379490f, -0.01946500f, 
    -0.15264545f, 0.16003425f, -0.03642310f, 0.02130131f, 0.04080263f, 0.00207897f, -0.03082332f, 0.08223841f, 
    0.06719951f, -0.03014038f, -0.01691112f, -0.03079744f, 0.13397951f, -0.21327646f, 0.00330414f, -0.11358815f, 
    -0.00181574f, 0.05391558f, -0.05996940f, -0.09438259f, -0.01660035f, 0.02505176f, 0.05801424f, -0.10383971f, 
    -0.20729503f, -0.13654906f, 0.06997805f, -0.18299770f, -0.03238430f, -0.08960222f, -0.05341667f, 0.02731944f, 
    0.10184333f, -0.04994188f, -0.09544958f, 0.05660863f, 0.03807609f, -0.20780434f, 0.20538524f, -0.10080575f, 
    -0.02471535f, -0.11461649f, 0.00397537f, 0.04782691f, -0.00655214f, 0.00995490f, 0.04699086f, 0.15584405f, 
    -0.23408246f, -0.06237718f, 0.23247673f, -0.09038034f, -0.00378508f, -0.02844062f, -0.03468375f, -0.00926683f, 
    0.06282166f, -0.13956138f, -0.01869219f, -0.01610885f, 0.03402065f, 0.24130543f, -0.02414847f, -0.04598440f, 
    -0.10115399f, 0.00744930f, -0.04023386f, -0.00617562f, 0.01364813f, -0.05108654f, -0.02779283f, 0.02849369f, 
    -0.00643177f, -0.02921531f, 0.07164708f, -0.02523976f, 0.00846890f, -0.04112423f, 0.07806754f, 0.03993345f, 
    -0.04691612f, -0.15667886f, -0.04413630f, -0.05925556f, -0.01571368f, 0.01056236f, -0.03750299f, 0.10277274f, 
    0.07337782f, -0.04655819f, -0.05705286f, -0.02964887f, 0.03623458f, -0.04335421f, -0.06609602f, 0.03811358f, 
    -0.10070512f, 0.01170734f, 0.13891725f, -0.07703628f, -0.07754460f, 0.10481837f, -0.10682783f, 0.04422769f, 
    -0.06433737f, 0.03256603f, -0.00194856f, -0.09105756f, 0.16357997f, -0.00803295f, -0.15951711f, -0.00726671f, 
    0.05273427f, 0.03799787f, 0.03661587f, -0.04927325f, -0.04380684f, 0.01698089f, -0.09900477f, 0.05679228f, 
    0.14401011f, 0.01714843f, -0.03888318f, -0.00653225f, -0.05263442f, -0.00559493f, -0.04446410f, 0.02829077f, 
    0.03372164f, 0.02034595f, 0.12506840f, -0.05534733f, 0.15578462f, -0.18696183f, -0.10348425f, -0.14645511f, 
    0.02254549f, -0.06018163f, 0.00343524f, -0.05133455f, 0.02192323f, -0.01321463f, 0.08115333f, -0.12842922f, 
    -0.17142282f, -0.07494900f, -0.11945447f, -0.12125111f, 0.06426383f, -0.06152299f, -0.07482910f, -0.02554980f, 
    0.05656474f, -0.01488578f, -0.02245369f, -0.08788653f, -0.23033093f, 0.14604783f, 0.04992051f, -0.24076305f, 
    0.02689157f, 0.02599802f, -0.03820161f, -0.07509232f, 0.00105068f, 0.07389146f, -0.09008941f, -0.04673224f, 
    0.08266848f, -0.03060912f, -0.08390210f, -0.01623071f, 0.05653134f, 0.00038060f, -0.02011381f, 0.01503964f, 
    -0.02937654f, -0.01610647f, 0.04446807f, 0.06628528f, 0.08306001f, 0.19594686f, -0.12049390f, 0.05427689f, 
    -0.19654490f, -0.03411236f, 0.04999721f, -0.07329647f, -0.01717409f, 0.05981847f, -0.01838163f, 0.12311010f, 
    0.17778347f, 0.00934168f, -0.12374897f, 0.05166039f, 0.04462231f, 0.02855427f, 0.06876996f, -0.01308854f, 
    0.00588204f, 0.00262988f, -0.08716604f, 0.06557171f, -0.06675756f, -0.07967968f, -0.09453341f, 0.09564834f, 
    -0.02380458f, -0.08420482f, -0.01528147f, 0.06793943f, 0.08762264f, -0.02212164f, -0.12860037f, 0.00110789f, 
    -0.06882810f, -0.09533802f, 0.07931246f, -0.16367950f, -0.04537717f, 0.02079121f, 0.01389529f, 0.05138922f, 
    0.10735777f, -0.14316744f, -0.02566198f, -0.03847801f, 0.05996543f, 0.14131151f, -0.24641456f, 0.02486278f, 
    0.04587368f, -0.02388214f, -0.17781280f, -0.10041667f, -0.05406356f, -0.00618281f, 0.03744611f, 0.03856971f, 
    -0.02625101f, 0.02024606f, -0.16221896f, -0.16267672f, 0.01585837f, -0.08693663f, -0.18088250f, 0.00224158f, 
    0.06923628f, 0.04664100f, 0.07184907f, 0.09565734f, 0.02102493f, -0.10157111f, -0.00971233f, 0.05522508f, 
    0.06390406f, -0.01196497f, 0.03094414f, -0.07132577f, 0.05652439f, 0.02195845f, -0.01239205f, -0.02340175f, 
    -0.02161058f, 0.11064031f, -0.17803985f, -0.11825327f, -0.05348262f, -0.01886467f, -0.09848743f, -0.10016470f, 
    0.04460839f, 0.02944755f, 0.02195037f, 0.04050957f, -0.01712427f, -0.17616042f, 0.06586070f, 0.02037198f, 
    -0.09976120f, -0.04691150f, -0.01046937f, -0.16140145f, -0.13941105f, 0.11230881f, -0.08182903f, 0.07063024f, 
    -0.01848098f, 0.11261477f, 0.05346080f, -0.05232077f, 0.06156645f, 0.01387961f, -0.01523220f, 0.01552919f, 
    0.02088420f, -0.02443472f, 0.00415755f, -0.01225823f, -0.30942920f, 0.05566428f, -0.05426482f, -0.18901084f, 
    -0.12894320f, -0.04493780f, -0.07892296f, 0.05103307f, 0.03126609f, -0.04645521f, 0.07021826f, 0.05911295f, 
    0.07012262f, -0.03865035f, 0.10782393f, 0.03133760f, -0.02454023f, 0.04617542f, -0.09347355f, 0.06174773f, 
    0.02764075f, 0.03481752f, 0.04717678f, 0.02863849f, -0.02651764f, -0.03008728f, -0.13967545f, -0.27939057f, 
    0.16203815f, -0.06283933f, -0.05015611f, 0.09501201f, 0.06813502f, -0.00866250f, -0.15071601f, -0.11940569f, 
    0.15438995f, 0.02143682f, -0.18362044f, -0.03691308f, 0.10210259f, -0.03304107f, 0.03554180f, -0.06019615f, 
    -0.04752441f, -0.05738612f, -0.13849744f, 0.08999743f, 0.05355808f, 0.01658947f, -0.14186847f, -0.12980600f, 
    -0.01432457f, -0.02020443f, -0.27579248f, -0.08958031f, 0.06918191f, -0.08805326f, -0.01399276f, -0.00937009f, 
    0.15321216f, -0.15018043f, 0.09840179f, 0.11600258f, 0.04105499f, 0.00958748f, -0.01262775f, -0.04119135f, 
    0.00904776f, -0.05715272f, 0.03995127f, -0.09898356f, 0.12794153f, 0.04893335f, 0.03148601f, 0.17132105f, 
    -0.13095398f, -0.14607254f, -0.03191552f, -0.04499023f, 0.03997768f, -0.00416576f, 0.03834707f, -0.06564520f, 
    0.11440291f, 0.09362447f, 0.00411390f, 0.12302324f, -0.05875352f, 0.06283673f, -0.08680584f, -0.00422549f, 
    -0.04398347f, -0.00355957f, 0.19537398f, 0.06355081f, -0.10240147f, -0.26963589f, 0.01513900f, -0.13440850f, 
    0.07751584f, -0.08502370f, 0.07115921f, -0.08511192f, 0.00760618f, -0.01371364f, 0.00513717f, 0.04647887f, 
    -0.24376597f, 0.02543901f, -0.17769767f, -0.29444402f, 0.01287973f, 0.02378953f, -0.14108124f, 0.09034482f, 
    -0.05472333f, 0.02316041f, 0.05325362f, 0.05678199f, 0.16748016f, -0.07197721f, -0.09304979f, -0.19290543f, 
    0.07666425f, -0.01304714f, -0.00141177f, -0.07669877f, -0.05113503f, 0.02665749f, -0.01132992f, -0.00332911f, 
    0.11600896f, 0.04569900f, -0.03003572f, 0.10083216f, 0.04324264f, 0.04887762f, -0.03929529f, -0.03476716f, 
    -0.02837870f, 0.03215944f, 0.01512136f, 0.04611109f, -0.11137981f, -0.14288235f, -0.02116536f, 0.09691558f, 
    0.12675063f, 0.05981801f, 0.00587965f, -0.01548094f, -0.02366209f, 0.04517179f, 0.11670008f, 0.04358730f, 
    -0.13764200f, -0.01366927f, 0.04000927f, 0.03512124f, 0.03687880f, 0.09113259f, 0.03632703f, -0.20512924f, 
    -0.01699045f, 0.05392345f, -0.03276655f, -0.01515811f, -0.15371674f, -0.08601876f, 0.16650762f, 0.16510485f, 
    -0.02673379f, -0.01015592f, -0.00217972f, 0.02228617f, 0.03325165f, -0.08372235f, -0.00102583f, -0.07708746f, 
    -0.01748553f, 0.07315961f, 0.11785322f, 0.17901166f, 0.00769331f, -0.11218325f, -0.03767401f, 0.08478738f, 
    0.04013441f, 0.09301312f, 0.07806373f, 0.07458407f, 0.01157764f, -0.18902381f, 0.09511088f, -0.01394769f, 
    0.00208458f, -0.04032594f, 0.02190482f, -0.04207668f, -0.03096036f, -0.03353954f, -0.11479045f, -0.00750955f, 
    -0.01970732f, 0.04075730f, -0.09652406f, 0.06706636f, 0.08729891f, -0.10751299f, -0.06629306f, 0.00893343f, 
    -0.00194089f, -0.02459722f, 0.02903664f, -0.01562217f, -0.10352729f, -0.07618499f, -0.04027202f, 0.08476043f, 
    0.06240651f, -0.08465326f, 0.01092463f, 0.00851676f, 0.10162175f, 0.06905030f, -0.07395522f, -0.00532203f, 
    0.00636555f, -0.09550662f, 0.08751849f, 0.11927310f, 0.01900716f, -0.04559100f, 0.04514949f, -0.06416555f, 
    0.01427508f, 0.02309139f, 0.01943700f, -0.08795433f, 0.07877398f, 0.12021912f, -0.16648327f, -0.13694273f, 
    0.01527359f, -0.02506489f, -0.13261801f, 0.00191185f, 0.04423757f, 0.04022101f, 0.05951788f, 0.03371814f, 
    -0.14215253f, 0.03146043f, 0.13646135f, -0.15998732f, -0.02139802f, 0.03520007f, -0.11578583f, -0.08730906f, 
    0.05994938f, 0.03439588f, -0.02304335f, 0.09140772f, -0.16768625f, -0.01150213f, -0.19174349f, 0.05145695f, 
    0.02516346f, 0.06054479f, -0.07545184f, -0.01800533f, 0.05970837f, 0.04893535f, 0.10508193f, 0.14227560f, 
    -0.15858737f, 0.01686717f, -0.08391694f, -0.22463867f, 0.01836635f, 0.00704235f, -0.04411859f, -0.02317106f, 
    0.00247852f, -0.00478843f, -0.07092176f, 0.11920462f, -0.07947996f, -0.06888918f, -0.08126183f, -0.04999172f, 
    -0.11749302f, -0.08789579f, 0.15016429f, 0.03080169f, 0.09068077f, 0.01218777f, -0.00541008f, -0.13208070f, 
    -0.13031004f, -0.04503381f, -0.16830261f, -0.13375875f, -0.04822800f, 0.00309779f, 0.12574372f, -0.10205809f, 
    0.02178140f, 0.06799936f, -0.04047770f, 0.09553583f, -0.18417954f, -0.11150806f, -0.11024141f, 0.18092650f, 
    0.10980735f, -0.03294791f, -0.00597606f, -0.06922076f, 0.07003028f, -0.01812219f, 0.12186366f, 0.03590098f, 
    0.03273060f, 0.05050611f, 0.12409294f, -0.01076059f, 0.01964529f, 0.05581504f, -0.01940673f, -0.06459883f, 
    0.02900876f, 0.08533832f, -0.00559240f, -0.00276662f, 0.02139182f, 0.06856117f, 0.03609910f, 0.09929945f, 
    -0.00348790f, -0.11856093f, -0.12886041f, 0.03959591f, 0.08247616f, -0.05732597f, 0.02405897f, -0.00532529f, 
    0.01295926f, 0.19700539f, -0.25827730f, 0.01166826f, -0.08976324f, 0.04461836f, -0.17641599f, -0.03928981f, 
    0.07112764f, 0.01451156f, 0.02183524f, -0.12066039f, -0.20338342f, 0.07026239f, 0.04655358f, -0.05880655f, 
    0.04733812f, -0.02964571f, -0.04072790f, -0.11839076f, 0.03975498f, 0.03760727f, -0.01676749f, 0.03126450f, 
    -0.18486938f, -0.18830997f, -0.09116987f, -0.05673798f, -0.02506318f, 0.00520859f, -0.07174966f, 0.00525387f, 
    0.09816774f, 0.07432520f, 0.04482660f, -0.01282051f, 0.11484694f, -0.11169482f, 0.09359648f, 0.14106971f, 
    0.01595375f, -0.01777436f, 0.05417412f, -0.09655081f, 0.04631036f, -0.03362474f, -0.16835061f, -0.09929771f, 
    0.15695262f, -0.00088134f, 0.03179245f, 0.09623706f, -0.02801123f, -0.07449085f, -0.05642422f, -0.01833603f, 
    0.08746955f, -0.02155638f, -0.02108864f, -0.06555666f, 0.09616333f, -0.06608167f, 0.02452376f, 0.08750386f, 
    0.16305129f, -0.05335797f, -0.04959611f, -0.01275030f, 0.00085936f, -0.10844889f, -0.03125899f, -0.08762402f, 
    0.01134638f, -0.12992583f, 0.08237561f, 0.19345909f, 0.09562220f, 0.05758104f, -0.04657962f, -0.09647538f, 
    -0.06470904f, 0.04623260f, 0.02424871f, -0.04133629f, -0.16680951f, 0.15390497f, -0.00983521f, 0.12248100f, 
    -0.12097489f, 0.02996593f, -0.08542566f, -0.00032172f, -0.00463554f, 0.07193471f, -0.12762147f, -0.10524582f, 
    0.13152477f, 0.26894894f, -0.20013492f, -0.15280849f, 0.04661301f, 0.04999053f, 0.02418206f, -0.08923947f, 
    0.17179687f, 0.04935953f, 0.08308556f, 0.03903532f, 0.10089860f, 0.12298885f, 0.02166761f, 0.14006756f, 
    -0.00366866f, 0.00602871f, 0.05580087f, -0.02477205f, -0.00510094f, 0.04498291f, 0.02358437f, -0.04695045f, 
    0.10231736f, 0.00869257f, 0.09754412f, 0.12237301f, -0.17938717f, -0.04282783f, -0.02896680f, 0.02159128f, 
    -0.05121562f, -0.06958462f, 0.00009623f, 0.03837957f, 0.17237346f, -0.06883366f, 0.04891650f, 0.11839041f, 
    -0.08405844f, -0.06954437f, -0.00325883f, -0.14177606f, -0.04207078f, -0.01260134f, 0.00833755f, 0.11554915f, 
    0.47069794f, 0.09699761f, -0.19054964f, -0.20643708f, 0.07069300f, -0.01114804f, 0.09894591f, -0.04049732f, 
    -0.21864422f, -0.04855504f, 0.03293282f, 0.01469314f, 0.04710328f, 0.11493412f, -0.14481020f, -0.01830278f, 
    -0.00690530f, -0.07340062f, 0.07191548f, -0.06537899f, 0.03836782f, 0.06939046f, 0.00717513f, -0.04899635f, 
    -0.18000309f, -0.26322490f, -0.03162459f, 0.34638131f, -0.05466438f, -0.10358813f, 0.01168749f, 0.06618789f, 
    0.02347183f, 0.02770841f, 0.04198651f, 0.09205404f, -0.01930338f, 0.08211136f, 0.10878060f, 0.05604247f, 
    0.02266734f, -0.00073140f, 0.02147651f, 0.22709674f, -0.01166405f, -0.11339645f, 0.02131416f, -0.06084274f, 
    -0.18232441f, -0.06321543f, 0.08045025f, -0.09667929f, 0.07089858f, -0.05511624f, -0.10631809f, -0.00036504f, 
    0.05450706f, 0.01193114f, 0.07711742f, 0.03151944f, -0.00809191f, -0.07363180f, -0.02339920f, -0.02132181f, 
    0.06780252f, 0.03978734f, 0.02225583f, -0.11223163f, -0.06941949f, -0.10501540f, 0.00140745f, 0.02131749f, 
    -0.24442163f, 0.03438997f, 0.11768319f, 0.04620204f, 0.10456141f, -0.00019572f, 0.06524520f, -0.08384648f, 
    -0.03659282f, -0.13796945f, -0.03860756f, 0.11633750f, 0.16367003f, 0.13509752f, 0.09672606f, 0.08105158f, 
    -0.05524004f, 0.12021228f, -0.08677778f, -0.06538047f, -0.12268954f, -0.05279308f, -0.03500891f, -0.03760478f, 
    -0.08968718f, 0.15385994f, -0.11502407f, -0.29542038f, 0.03831758f, 0.12567636f, 0.09864113f, -0.14563890f, 
    -0.08535840f, 0.10596669f, 0.05393395f, -0.03104286f, 0.14626220f, -0.04725819f, 0.19189011f, 0.10040633f, 
    -0.09050574f, 0.00556112f, -0.01642253f, -0.00203388f, -0.03893466f, 0.12307578f, 0.05948460f, 0.04560117f, 
    -0.18250877f, 0.16073772f, 0.19575989f, -0.03165797f, -0.08053795f, 0.05719735f, 0.07101572f, 0.02315852f, 
    -0.00352077f, -0.13120538f, 0.15531498f, -0.05647350f, -0.08334658f, -0.11415305f, -0.14265074f, 0.05214649f, 
    -0.06245051f, 0.05409793f, -0.03652466f, 0.00683687f, -0.14504746f, -0.11220961f, -0.02132497f, 0.07728143f, 
    -0.06936251f, 0.15763637f, 0.17073976f, 0.02295644f, 0.02757718f, 0.06369311f, 0.01210488f, -0.02203515f, 
    0.03253981f, 0.02477843f, -0.02047311f, -0.08384077f, -0.00484733f, 0.40679574f, -0.15595190f, 0.23258652f, 
    -0.03256202f, -0.02969006f, 0.06548179f, 0.14810787f, 0.16281538f, 0.04639517f, 0.04525638f, 0.01045674f, 
    0.17473640f, -0.36837336f, 0.27776310f, -0.06683673f, 0.06251945f, -0.04463727f, -0.06203754f, -0.00730768f, 
    -0.10126345f, 0.02031696f, 0.05904523f, 0.00757198f, -0.23457567f, 0.13657591f, -0.17710763f, -0.12893115f, 
    0.07844766f, -0.06631889f, -0.04374267f, -0.00091549f, -0.00819780f, -0.02827951f, 0.05296676f, 0.07909461f, 
    -0.01623846f, -0.44488972f, 0.10869268f, -0.08641685f, -0.09819005f, 0.11676876f, 0.15918909f, -0.07083856f, 
    0.03173901f, 0.01396921f, 0.00487325f, 0.01744381f, 0.10515684f, 0.06663952f, 0.20417750f, 0.08828034f, 
    -0.03755110f, 0.05708217f, 0.03053379f, 0.07202139f, 0.03192808f, 0.07047808f, -0.11859758f, -0.06160581f, 
    -0.26491943f, 0.13079374f, 0.19352521f, -0.21723340f, -0.07719190f, 0.00590377f, -0.00042076f, 0.06923856f, 
    -0.05936471f, -0.06153575f, -0.09468185f, -0.06867322f, -0.33483613f, 0.16575618f, -0.37739864f, -0.25411066f, 
    0.07928865f, -0.02093432f, 0.00841468f, 0.08876874f, -0.04084070f, -0.04513876f, 0.05216244f, 0.03427590f, 
    -0.14247599f, 0.11993892f, 0.01422471f, 0.10355547f, 0.05285852f, -0.08277667f, 0.01180215f, -0.03561026f, 
    -0.02447151f, -0.08474990f, 0.00994874f, 0.02824461f, 0.26050740f, 0.10982645f, -0.22573222f, 0.11133123f, 
    0.04133829f, -0.05859334f, 0.05719457f, 0.00656246f, 0.06173068f, 0.01678343f, 0.05819036f, 0.05227113f, 
    -0.20116475f, -0.06705154f, -0.00373903f, 0.16286369f, -0.04235534f, 0.01017930f, -0.05671375f, 0.07572218f, 
    -0.10324581f, 0.13074672f, -0.05417091f, -0.02510258f, -0.00252304f, 0.05515927f, 0.06635834f, 0.08652943f, 
    0.01206982f, 0.17856090f, -0.00674646f, 0.02701875f, -0.10962828f, 0.06460606f, -0.10171367f, 0.02092576f, 
    0.15631878f, -0.35514840f, 0.05787211f, 0.12001938f, -0.06315888f, 0.07496189f, -0.03610025f, -0.08617240f, 
    -0.04089738f, 0.12119175f, -0.14942996f, -0.02886181f, -0.00504984f, -0.41852489f, 0.08275330f, 0.08713830f, 
    -0.07622351f, -0.02271439f, -0.13724452f, -0.01694968f, 0.07227793f, 0.06375529f, 0.14540403f, 0.03614888f, 
    0.28196687f, 0.08932479f, 0.14301136f, 0.00312282f, 0.02643819f, -0.04600258f, 0.05766505f, -0.05652654f, 
    0.11830858f, 0.01694927f, 0.03549833f, -0.00897921f, 0.10797551f, -0.39014882f, 0.06636477f, 0.10475831f, 
    -0.06258719f, -0.06120163f, 0.02973364f, 0.08347643f, -0.06424791f, 0.04631942f, 0.13708836f, -0.02102787f, 
    -0.27283442f, 0.01335034f, -0.16267247f, 0.03353230f, 0.11251655f, -0.02531287f, -0.08209615f, -0.10699625f, 
    0.02630625f, 0.00245972f, -0.06100494f, 0.10810933f, 0.34524322f, -0.21970768f, -0.06174511f, -0.09103969f, 
    0.04801007f, 0.04437864f, -0.04831060f, 0.02600831f, -0.07753074f, -0.06874552f, 0.00725484f, -0.06813091f, 
    -0.36205962f, -0.11835145f, 0.16241321f, -0.10002126f, -0.02055906f, 0.01609357f, 0.03823223f, 0.05252489f, 
    0.04726889f, -0.00718657f, -0.20905259f, -0.03279736f, 0.19520627f, 0.04241660f, 0.28740668f, 0.04654222f, 
    -0.04439877f, 0.00669583f, 0.01806006f, 0.03627480f, 0.16628619f, -0.00065911f, 0.09930980f, 0.05179447f, 
    -0.08708601f, -0.13111314f, -0.00730473f, 0.09284290f, -0.00460120f, 0.10310961f, -0.05045177f, 0.02075031f, 
    0.14971417f, 0.10697116f, -0.05020142f, -0.09651590f, 0.09447557f, -0.07553449f, 0.14664392f, -0.11436669f, 
    0.11145265f, -0.02342403f, -0.14843100f, 0.08290970f, 0.06375164f, -0.01523044f, 0.01549455f, 0.10322645f, 
    -0.12465848f, 0.07485048f, -0.19854599f, -0.08861350f, 0.13263477f, 0.01289014f, -0.03420338f, -0.07464577f, 
    -0.13689290f, -0.02817623f, -0.16434823f, -0.08880106f, -0.06040906f, 0.12029349f, 0.06856067f, -0.27022043f, 
    0.06260474f, -0.10655341f, -0.04698465f, -0.06869595f, -0.17002299f, 0.00799887f, -0.03862321f, -0.25233722f, 
    -0.10397496f, -0.31055674f, -0.06856765f, -0.11219667f, -0.07371505f, 0.01190541f, 0.00608743f, 0.09337319f, 
    0.14999232f, 0.07034536f, 0.01762476f, 0.02361573f, -0.01168498f, -0.33481494f, 0.14593424f, 0.13712688f, 
    0.03637251f, -0.07936619f, -0.05171736f, -0.07059264f, -0.09134408f, 0.02817870f, -0.03555161f, 0.02024004f, 
    -0.15221874f, 0.25870019f, -0.21400000f, -0.01371572f, 0.10788356f, -0.06219030f, 0.01479056f, -0.14298418f, 
    -0.07989400f, 0.08325878f, -0.05194112f, -0.04001420f, 0.30782548f, 0.03813395f, -0.13410641f, 0.09598783f, 
    0.03790408f, 0.05139881f, -0.11738741f, 0.09070428f, -0.03696291f, 0.02412293f, 0.09006977f, 0.06669888f, 
    0.14479779f, -0.39398411f, -0.03358277f, -0.16766776f, 0.00724440f, 0.10364207f, -0.03398509f, -0.00973079f, 
    -0.11616378f, -0.13245052f, 0.16111539f, -0.13613869f, -0.14659648f, 0.06110570f, 0.04640497f, -0.28000548f, 
    -0.12679246f, -0.00503895f, -0.03816345f, 0.09006458f, 0.08054634f, -0.06907314f, -0.03076927f, 0.09646435f, 
    -0.18721721f, -0.02079920f, 0.02298634f, 0.08525772f, -0.02407378f, -0.02129304f, -0.06945118f, -0.06234455f, 
    0.12487084f, 0.01749661f, 0.07891779f, -0.06247212f, -0.10541321f, -0.00304327f, 0.21440028f, 0.01683847f, 
    0.00790949f, 0.08486360f, -0.03283354f, -0.14625919f, 0.00192849f, 0.01508367f, -0.03539512f, 0.01574394f, 
    0.01888593f, -0.14283174f, -0.12036453f, 0.04584839f, 0.00434161f, 0.02570477f, 0.11789549f, -0.04456297f, 
    0.00496177f, -0.14354840f, 0.06578768f, -0.12475857f, -0.14935084f, 0.21496254f, -0.13008136f, -0.24485666f, 
    0.12379969f, -0.00553995f, -0.14432730f, 0.00511475f, 0.00271164f, -0.06241247f, -0.11019602f, -0.08816994f, 
    0.03705587f, -0.12109467f, 0.15954602f, -0.11094593f, 0.01157420f, 0.02545444f, -0.05674303f, 0.01741120f, 
    0.09175783f, -0.03178488f, -0.01017757f, -0.04309759f, -0.14826608f, -0.00931315f, -0.11596600f, -0.02329166f, 
    0.06219309f, 0.04098166f, 0.06527131f, 0.00368215f, -0.03856336f, 0.00304337f, -0.06089164f, 0.05861573f, 
    -0.19834954f, 0.02004069f, 0.12825397f, -0.07265070f, 0.02337459f, 0.04029265f, -0.09646025f, 0.04593375f, 
    0.12287252f, -0.01990404f, 0.00456239f, -0.04056701f, -0.28769460f, -0.01992350f, -0.10909285f, -0.24495868f, 
    0.05870484f, -0.21619232f, 0.02380191f, 0.06645905f, -0.14074685f, -0.00842807f, -0.03239078f, -0.04075367f, 
    0.42607781f, 0.17662051f, -0.13376886f, -0.40964058f, 0.04632693f, -0.04039751f, 0.12946306f, -0.05105517f, 
    -0.14641899f, 0.00640335f, -0.05333734f, -0.11878993f, 0.22847772f, -0.19882017f, 0.10615864f, 0.02971652f, 
    -0.00062291f, -0.04569608f, 0.08645049f, 0.05713463f, 0.11801542f, -0.06846669f, -0.03255841f, 0.08303509f, 
    -0.20874587f, 0.04565580f, 0.21056323f, 0.14588173f, 0.06727432f, 0.07759614f, -0.04914107f, 0.09715711f, 
    0.05309739f, 0.09933912f, -0.01917703f, -0.04912723f, -0.15232532f, -0.00721884f, -0.22357079f, 0.35033393f, 
    0.04547619f, -0.00109915f, 0.00907195f, 0.00571790f, 0.06678928f, -0.01340831f, -0.02143058f, -0.08387592f, 
    0.01403023f, -0.11649393f, -0.31705514f, -0.24898154f, -0.05371159f, -0.01485031f, 0.04018998f, 0.00771657f, 
    -0.01105004f, 0.00693001f, 0.00499200f, -0.07871433f, 0.06886907f, 0.04153826f, -0.01619612f, 0.06408221f, 
    -0.02808183f, -0.05623627f, -0.09668992f, 0.04724518f, 0.05268097f, 0.07225631f, 0.06698303f, 0.01075916f, 
    0.01801037f, 0.23585075f, -0.14642759f, -0.17501502f, 0.04243120f, 0.08065989f, 0.08991959f, -0.05291667f, 
    -0.12158705f, 0.00800727f, 0.06241772f, 0.02179641f, -0.04995329f, -0.07960410f, 0.06001978f, -0.14680259f, 
    0.10407202f, 0.03211990f, -0.04197863f, -0.09883846f, -0.02524842f, 0.01879460f, -0.05508079f, 0.08942079f, 
    -0.34204695f, 0.09868495f, -0.08505639f, -0.15437126f, 0.01039487f, 0.01503711f, 0.04018011f, 0.00876413f, 
    -0.05092441f, -0.00240215f, -0.08105262f, 0.01739606f, -0.04023013f, 0.18387619f, -0.00620396f, 0.06162010f, 
    0.02084903f, 0.03418417f, 0.03463240f, 0.10473870f, 0.02322183f, -0.03639970f, 0.05533647f, 0.01432322f, 
    0.09856010f, 0.06410563f, 0.05148984f, -0.10861164f, 0.03620780f, 0.04353174f, 0.08290337f, -0.03931953f, 
    -0.06729896f, 0.06984764f, -0.00783230f, -0.00792880f, 0.33292058f, -0.47472525f, 0.16022246f, -0.06515510f, 
    0.01704140f, -0.11650258f, -0.01087440f, -0.07212708f, -0.04309246f, -0.06998800f, 0.06608373f, 0.11986306f, 
    -0.39781857f, -0.18553478f, -0.02150659f, -0.09055685f, 0.08497036f, -0.02088794f, -0.04006842f, 0.11954288f, 
    0.19615948f, 0.02208405f, 0.01109905f, -0.01025805f, 0.16503851f, 0.05298874f, -0.13172847f, 0.10259895f, 
    0.24481465f, 0.01357196f, -0.00264101f, -0.04925149f, -0.03085839f, -0.10650484f, 0.09792920f, -0.04926855f, 
    -0.00278088f, 0.02617447f, 0.00489647f, 0.12269735f, -0.03721158f, -0.07825615f, -0.00967329f, -0.10931583f, 
    -0.05069497f, 0.02639953f, -0.05297841f, -0.05241884f, -0.08563420f, 0.08648897f, -0.04684636f, -0.00667843f, 
    0.05948995f, 0.09445191f, -0.00775625f, 0.02563057f, -0.02529836f, 0.05470897f, -0.02546886f, 0.09445259f, 
    0.09101315f, -0.00694118f, 0.04630065f, -0.04248439f, 0.01372125f, 0.01406335f, 0.07609531f, 0.10139020f, 
    0.04527803f, -0.03275298f, 0.16777885f, 0.05083254f, 0.01590231f, -0.14189421f, 0.12649691f, -0.10794020f, 
    -0.09323562f, 0.02969290f, 0.02069925f, -0.10758840f, 0.05627457f, 0.03304731f, -0.06154817f, -0.03971903f, 
    0.01752014f, -0.06715048f, -0.01165500f, -0.07355820f, -0.13643666f, -0.09591987f, 0.02680493f, -0.05159293f, 
    0.07533211f, 0.02585206f, -0.10172175f, -0.02681143f, -0.22324756f, -0.08190096f, -0.08091538f, 0.09024086f, 
    0.05661115f, 0.01620504f, 0.03937510f, 0.06451326f, -0.04405593f, 0.01478852f, 0.06976882f, 0.08838448f, 
    0.19739793f, 0.07274690f, 0.01643441f, -0.08742553f, -0.14713906f, 0.04206670f, -0.09070516f, -0.02952279f, 
    -0.00833955f, 0.03295606f, -0.05110586f, -0.11557989f, -0.55289370f, -0.42920771f, 0.08810554f, -0.00265307f, 
    0.08354039f, 0.06640297f, 0.01465035f, -0.07022767f, 0.14130317f, 0.11642168f, -0.05714348f, -0.00197286f, 
    -0.07538861f, -0.03273602f, 0.05637236f, 0.19710319f, 0.07186668f, 0.02077040f, -0.05840076f, 0.06122053f, 
    -0.00457749f, 0.06263374f, 0.09930171f, 0.01048749f, -0.26714686f, 0.03553354f, -0.05714874f, -0.12345577f, 
    0.04205219f, 0.01772459f, -0.03518115f, -0.00567193f, -0.05175692f, -0.15645391f, -0.06594751f, -0.03619318f, 
    -0.37530878f, -0.17825210f, 0.02190469f, -0.00820209f, 0.09522364f, 0.05024207f, 0.05741064f, -0.00811055f, 
    0.07181662f, 0.09802549f, -0.06324670f, -0.00863331f, -0.02655329f, -0.09459054f, 0.05149834f, -0.07411768f, 
    0.06572951f, 0.18811958f, 0.04508004f, -0.06436016f, 0.03435712f, 0.03211598f, 0.05566695f, 0.01522703f, 
    -0.47640023f, -0.18097661f, 0.14215706f, -0.04496021f, 0.11215694f, 0.03230622f, -0.05300362f, -0.11868313f, 
    -0.00207145f, -0.05943494f, 0.03124054f, 0.06013371f, 0.02256470f, -0.01919364f, -0.03162202f, -0.05818033f, 
    0.02016749f, 0.11993250f, -0.01193188f, 0.00783711f, 0.08598772f, -0.14203562f, -0.00523912f, -0.01488361f, 
    -0.26401994f, 0.14396639f, -0.14805305f, 0.00475305f, 0.04263747f, 0.05131198f, -0.07983799f, 0.01090576f, 
    0.05584836f, 0.09036740f, -0.16419043f, 0.00924635f, -0.16765529f, 0.26821101f, -0.13269934f, -0.11517999f, 
    0.06080279f, -0.01317969f, 0.01558226f, 0.00485957f, 0.03225747f, -0.05082038f, 0.01533377f, -0.10280877f, 
    0.04730473f, 0.16960955f, -0.06040899f, 0.04520656f, 0.03809998f, -0.00619185f, -0.04667891f, 0.11462743f, 
    -0.04064094f, 0.01518963f, -0.01126596f, -0.14214113f, -0.29395977f, -0.16573173f, 0.03557443f, 0.11906526f, 
    0.03849624f, 0.00969278f, -0.09741844f, -0.12120215f, 0.03808068f, -0.08860675f, 0.15273777f, 0.04329407f, 
    -0.04950427f, -0.13394801f, -0.13898817f, -0.05331144f, 0.10778828f, -0.01712112f, -0.05739368f, 0.13306467f, 
    0.07723499f, 0.10839164f, 0.07638171f, 0.00031929f, -0.37999722f, -0.41454160f, -0.17492166f, 0.02780690f, 
    -0.05652246f, 0.02509069f, -0.04574109f, 0.01919079f, 0.10713580f, -0.03718469f, -0.04562699f, 0.06546518f, 
    0.09368771f, -0.10716136f, 0.05005276f, 0.07125518f, 0.03485665f, 0.01356412f, -0.07031213f, 0.07608125f, 
    0.07603320f, 0.09951477f, 0.03446585f, -0.04690418f, 0.11130459f, 0.06375845f, -0.13336775f, 0.03345437f, 
    -0.02123665f, 0.06265815f, 0.00430641f, 0.11439160f, 0.03853849f, 0.01102856f, -0.04767182f, -0.01941830f, 
    0.19777432f, 0.10265353f, -0.04955186f, -0.09680631f, -0.05375128f, 0.11317369f, 0.05483684f, -0.06171107f, 
    0.00271565f, -0.06743199f, 0.08780846f, -0.12449981f, -0.03762637f, 0.10359534f, 0.05393904f, -0.00043148f, 
    0.00197735f, -0.06144289f, 0.02071906f, -0.07147057f, -0.07136400f, 0.07100111f, 0.02886006f, -0.07137161f, 
    0.12669320f, 0.00856584f, -0.12435035f, -0.01792517f, -0.05000746f, 0.04511664f, 0.14245585f, -0.01140000f, 
    0.00479244f, 0.15001780f, 0.15265986f, -0.03942313f, -0.10750305f, -0.00499728f, -0.02753047f, -0.01496355f, 
    0.14394741f, -0.05088516f, -0.04032706f, -0.00043105f, 0.07363442f, 0.11312519f, -0.13902295f, -0.02483462f, 
    -0.42032573f, -0.11738053f, -0.01631205f, 0.03108050f, 0.12953071f, -0.04123998f, 0.03481699f, -0.16148329f, 
    -0.06415815f, -0.07897932f, -0.00157494f, 0.14212577f, -0.27229780f, -0.08842967f, -0.05707663f, 0.06140751f, 
    -0.02036998f, -0.00462111f, -0.06361616f, 0.00416707f, 0.01591166f, -0.02933300f, 0.00707963f, -0.09339304f, 
    -0.29726696f, -0.12513235f, -0.17825387f, -0.22890031f, -0.02800448f, 0.04057350f, -0.12533452f, -0.03551136f, 
    0.00465908f, -0.16189827f, -0.09099018f, -0.06407790f, 0.04123920f, 0.01274666f, -0.13741605f, 0.08301170f, 
    0.07609879f, -0.03363115f, -0.02408950f, 0.04864668f, 0.04031840f, 0.15890855f, 0.09688474f, 0.05164099f, 
    0.08616740f, 0.12502092f, -0.10427917f, 0.05342338f, 0.04306626f, -0.05603540f, 0.03876424f, 0.05048666f, 
    0.02143924f, -0.01063893f, 0.09005050f, 0.01081939f, -0.08693560f, 0.08331168f, 0.01631143f, -0.02776035f, 
    0.03586677f, -0.27578327f, -0.11390591f, -0.02606643f, 0.03815761f, -0.09459431f, 0.03613624f, 0.09554549f, 
    0.30010381f, 0.02754030f, -0.01188027f, -0.16267824f, 0.08403479f, 0.00535402f, 0.03814550f, -0.00952703f, 
    -0.08443822f, 0.13199484f, -0.06041352f, -0.06828309f, -0.17627227f, 0.07666124f, -0.14441149f, 0.01002101f, 
    0.06730372f, 0.06198410f, 0.05864661f, 0.11621182f, 0.03883677f, 0.08271288f, 0.05012360f, 0.06347019f, 
    -0.32151994f, 0.01605890f, -0.24471967f, -0.17114316f, 0.02098175f, 0.06119170f, -0.02380643f, 0.03328752f, 
    0.03342190f, 0.11477370f, 0.02684877f, 0.07751042f, -0.34723702f, -0.16586371f, -0.02293854f, -0.28776985f, 
    0.04423872f, -0.02052393f, -0.06508278f, -0.08885907f, 0.06007138f, 0.10179918f, 0.06438940f, 0.12394366f, 
    0.16431856f, 0.04423575f, -0.07908738f, -0.03518117f, -0.13895713f, -0.12466420f, -0.01669094f, -0.10932845f, 
    -0.06294792f, -0.17754915f, -0.07911631f, -0.12724859f, 0.19725855f, 0.00335855f, 0.02847080f, 0.11492631f, 
    -0.00575606f, -0.08787195f, -0.03697431f, 0.05939098f, 0.08762817f, 0.07204657f, 0.03262002f, -0.01991769f, 
    -0.25644395f, -0.14036615f, -0.16515908f, -0.23721118f, 0.03463639f, -0.18701953f, -0.18688112f, 0.09854101f, 
    -0.11661018f, -0.02830662f, 0.15867621f, 0.08253933f, 0.23986627f, 0.07368415f, -0.01574725f, 0.06648700f, 
    -0.07855880f, -0.11002491f, -0.05191660f, -0.03383274f, -0.03470983f, 0.02933853f, -0.16830209f, -0.10321574f, 
    -0.27513283f, 0.14691718f, -0.27381861f, -0.11893362f, 0.15653907f, -0.04737638f, -0.02556737f, -0.03908139f, 
    0.12577578f, 0.07064994f, -0.02585992f, 0.05541480f, -0.16853531f, 0.04565274f, -0.11993465f, -0.08796806f, 
    0.14588784f, -0.03975533f, 0.04208376f, 0.00932418f, 0.11928441f, 0.02541104f, 0.00649601f, 0.09450158f, 
    0.12667608f, 0.05491234f, -0.04090203f, 0.00368067f, -0.05971483f, -0.15887730f, 0.04719468f, 0.05848832f, 
    0.04050927f, 0.01286912f, -0.12095703f, 0.01472698f, -0.26251030f, -0.11401571f, 0.04549579f, 0.08300368f, 
    0.12574787f, -0.05131866f, -0.02825481f, 0.09095015f, 0.03967518f, 0.02663917f, 0.01068888f, 0.15027615f, 
    0.15523058f, 0.13773803f, 0.02475957f, -0.08541270f, 0.07820988f, 0.08089262f, -0.00869506f, 0.05668839f, 
    0.01074824f, 0.09782910f, 0.05007697f, 0.00391859f, 0.03544994f, 0.06347614f, -0.03501878f, -0.17961961f, 
    0.08876199f, 0.07497525f, 0.03907690f, 0.12128787f, 0.09558570f, 0.01680026f, 0.05077400f, 0.07481908f, 
    0.23219188f, 0.13851844f, 0.21301061f, 0.07728847f, 0.08419595f, -0.00166035f, 0.14782770f, -0.04874146f, 
    0.04445852f, 0.08618803f, 0.00852642f, 0.08407827f, 0.31122503f, 0.08941168f, 0.03076289f, 0.13997427f, 
    0.06550817f, -0.00144715f, 0.12643482f, -0.03408694f, 0.04298241f, 0.11271296f, 0.07883814f, 0.02000504f, 
    0.27014768f, 0.17952664f, 0.01413129f, 0.11345861f, 0.01896543f, -0.04698098f, 0.01965530f, -0.09488029f, 
    0.05200512f, -0.04008940f, 0.08678785f, 0.17754604f, -0.27698478f, -0.06156955f, 0.06239166f, -0.08827442f, 
    -0.08046893f, -0.03762238f, -0.16666512f, 0.03460005f, -0.15932840f, -0.07422087f, -0.05172101f, -0.21535237f, 
    -0.43157914f, -0.08667745f, 0.09106212f, -0.04712761f, 0.09640956f, -0.01170150f, 0.03394137f, -0.00769536f, 
    0.02493384f, 0.12362251f, 0.08306410f, 0.12658574f, -0.00162792f, 0.02826954f, -0.14610152f, 0.04711443f, 
    0.00087470f, -0.08913071f, -0.22044188f, 0.06152552f, -0.05151041f, 0.05565549f, 0.00242724f, 0.06811091f, 
    -0.20551050f, -0.12477028f, 0.12797444f, -0.02137173f, -0.06233438f, 0.04283119f, -0.09378258f, 0.02357756f, 
    0.06408088f, -0.08803352f, 0.03659531f, -0.06324796f, 0.34735477f, 0.08598597f, -0.04898166f, 0.04114016f, 
    0.01742062f, -0.10879936f, 0.11232945f, -0.05928100f, -0.00208122f, -0.06056727f, 0.02308027f, -0.00897040f, 
    0.15974934f, 0.09077636f, 0.02079653f, -0.15837264f, -0.00148001f, 0.02126627f, 0.01893814f, 0.16713619f, 
    -0.00692898f, 0.17281955f, 0.04115699f, 0.10659444f, 0.27316546f, -0.04567036f, -0.20169699f, -0.06234823f, 
    -0.09972391f, -0.08774536f, -0.06725550f, 0.04087722f, 0.01047808f, -0.01046945f, -0.22620563f, 0.01518527f, 
    0.16776630f, 0.01278203f, -0.04980165f, -0.08280959f, -0.00566349f, -0.12005516f, -0.06226663f, 0.07318164f, 
    0.01828442f, -0.11744612f, -0.00699038f, -0.02019778f, -0.23267126f, -0.11587781f, -0.18132246f, -0.11530074f, 
    0.06690225f, 0.07651511f, -0.10884223f, -0.00034614f, 0.01875336f, -0.02557959f, -0.01455067f, -0.10231168f, 
    -0.55411565f, -0.30063525f, -0.09032682f, -0.19421537f, 0.05764391f, -0.05199361f, -0.01819631f, -0.01432377f, 
    0.05857341f, 0.03719807f, 0.03219635f, 0.06768025f, 0.00874426f, -0.24392463f, 0.01436718f, 0.02899284f, 
    0.01596698f, 0.01768142f, -0.00956423f, -0.08692089f, 0.05659461f, 0.05914599f, -0.18902101f, -0.00096744f, 
    -0.11513609f, -0.07052752f, 0.14039397f, -0.03437213f, 0.13768716f, 0.00409424f, 0.02794201f, 0.05311554f, 
    0.05612440f, 0.01838547f, 0.01443562f, 0.05117666f, -0.03369852f, 0.00943167f, -0.05776690f, 0.03077035f, 
    -0.10480060f, 0.01240359f, 0.04516273f, -0.05500741f, 0.07322723f, 0.19336277f, 0.05157429f, 0.00437060f, 
    0.07984328f, 0.14049217f, -0.03744270f, 0.03125700f, -0.00604610f, -0.09378773f, 0.00217791f, -0.01369210f, 
    -0.02211136f, -0.01664900f, -0.10015978f, 0.02319807f, -0.11165883f, -0.28436762f, -0.10700331f, -0.15195610f, 
    0.05059660f, -0.05579247f, -0.00380832f, 0.00673651f, -0.08626810f, -0.03811985f, 0.00289806f, 0.03409584f, 
    0.05449825f, -0.05501003f, 0.02226212f, -0.06960174f, -0.17876619f, 0.01944954f, -0.03505864f, 0.04458471f, 
    0.09953249f, -0.04449197f, 0.00148923f, -0.10896343f, -0.34212989f, 0.24599971f, -0.03277175f, -0.04559507f, 
    -0.05514389f, 0.04251010f, -0.07119178f, -0.06510971f, 0.01405885f, -0.01318141f, 0.05786155f, -0.02787029f, 
    0.13779782f, 0.04349731f, 0.00336711f, -0.10944279f, -0.04192821f, 0.04920378f, 0.03631719f, -0.21363151f, 
    -0.04499735f, 0.07019889f, 0.05397837f, 0.01946549f, -0.09759070f, -0.07355835f, -0.02623097f, 0.00757225f, 
    0.12317113f, -0.02879764f, -0.01680232f, 0.01993160f, -0.17356995f, 0.03947721f, -0.00117363f, -0.17219405f, 
    -0.10679945f, -0.10293216f, -0.06239004f, -0.00325712f, -0.02084615f, -0.02876027f, -0.06938165f, -0.02630204f, 
    -0.05957484f, -0.02600520f, 0.03867802f, 0.09031445f, -0.06118302f, 0.24591787f, -0.06200699f, -0.02253099f, 
    0.13628414f, 0.00890446f, 0.01173752f, 0.11994768f, -0.01311835f, -0.04586463f, -0.05772482f, -0.02668679f, 
    0.12895966f, -0.11949616f, -0.02598161f, 0.08332273f, -0.13985628f, 0.03339307f, 0.00011176f, -0.16049552f, 
    -0.04930151f, -0.02997193f, 0.04015538f, -0.05965591f, 0.38991830f, 0.18599527f, -0.05372902f, 0.15069203f, 
    -0.02365687f, 0.02381377f, -0.05867357f, -0.05329737f, 0.03807083f, -0.01442459f, 0.03333033f, 0.06813417f, 
    0.24640453f, -0.03951049f, -0.00538533f, -0.00502800f, 0.10872695f, -0.06446010f, -0.02313941f, 0.02900425f, 
    0.10257761f, -0.04297268f, -0.01765784f, 0.05901413f, 0.40513754f, 0.10053583f, 0.00101704f, -0.07957312f, 
    -0.05502089f, 0.01421825f, -0.12034693f, -0.00060387f, 0.02810349f, 0.07352292f, 0.05414412f, 0.01764577f, 
    -0.18486539f, 0.21305139f, -0.04844528f, -0.04740458f, 0.06002820f, 0.01198364f, -0.04155259f, 0.07676703f, 
    0.00359859f, -0.06588798f, -0.00436569f, -0.09755494f, -0.08338373f, 0.21090630f, 0.06812964f, -0.03936294f, 
    -0.01782500f, -0.05266301f, 0.04283057f, -0.14510882f, 0.04413394f, 0.02933054f, 0.00361340f, -0.00652312f, 
    0.31746528f, 0.13655408f, 0.02989275f, -0.23307657f, 0.02193348f, -0.06545042f, -0.12051402f, -0.02826949f, 
    0.06426939f, 0.06887152f, 0.00606528f, 0.06038293f, -0.05024058f, -0.27548653f, -0.12981103f, 0.04483312f, 
    -0.03132683f, -0.11159284f, 0.12208924f, 0.11392817f, -0.05247949f, 0.08450757f, -0.07175835f, -0.08017836f, 
    0.06993955f, 0.15023902f, -0.04070141f, -0.07099016f, -0.05782799f, 0.08047655f, 0.08050140f, 0.14335027f, 
    0.11794814f, -0.00703279f, 0.04018046f, 0.02658123f, 0.26067352f, -0.14321423f, -0.08883822f, 0.02873870f, 
    -0.02729742f, -0.01268937f, 0.02272403f, -0.11303541f, 0.03060054f, 0.00143024f, 0.05907676f, 0.01691886f, 
    0.13081077f, -0.16182618f, -0.00484837f, -0.06094466f, -0.00508570f, 0.08867545f, 0.01012864f, 0.13452144f, 
    0.09654809f, 0.10691340f, -0.04301016f, 0.09805405f, -0.00850039f, -0.00983199f, -0.03315986f, 0.13091366f, 
    -0.04075331f, -0.07668319f, 0.03452216f, 0.02085686f, 0.07307915f, 0.08700948f, -0.08612348f, -0.01969092f, 
    0.13740309f, -0.04828526f, -0.09078858f, 0.39705780f, 0.06406805f, 0.13394091f, 0.02122845f, -0.04275885f, 
    0.04443418f, -0.03266929f, 0.00518112f, 0.06300791f, -0.36329189f, -0.06279068f, -0.02444648f, 0.04864001f, 
    0.19018319f, -0.12633410f, 0.01624027f, -0.07819818f, 0.13223334f, 0.03486819f, -0.03217873f, 0.11366381f, 
    0.14179298f, -0.15561195f, 0.07220566f, 0.03501663f, 0.04628733f, 0.05774963f, 0.03299253f, -0.17864214f, 
    -0.09722780f, -0.03543389f, -0.02826158f, -0.03112117f, -0.07057145f, -0.14919744f, 0.20642580f, 0.03820388f, 
    0.08648964f, -0.13473687f, -0.07832169f, 0.01797134f, -0.12238955f, 0.03055274f, 0.06965960f, 0.10344778f, 
    -0.04233919f, 0.01852358f, -0.06808008f, 0.11455772f, 0.08418524f, 0.03254705f, 0.02807755f, -0.01577869f, 
    0.02603178f, 0.01009649f, -0.02570362f, -0.06455193f, 0.16874562f, 0.13882697f, -0.11030669f, -0.02897763f, 
    -0.00479870f, -0.23648700f, -0.12560557f, -0.01773112f, 0.02069312f, -0.07046057f, 0.01360355f, 0.00855115f, 
    -0.21127933f, 0.14037481f, -0.01485867f, -0.03135280f, -0.05983340f, 0.03935714f, -0.05289473f, -0.16810107f, 
    0.01319443f, -0.02276808f, 0.02995635f, -0.06994876f, -0.11133856f, 0.08056163f, -0.03136861f, 0.08703563f, 
    -0.20744711f, 0.09037020f, -0.11099958f, 0.04013719f, 0.12417341f, -0.12402308f, -0.05307570f, 0.10433293f, 
    0.35266516f, -0.14368187f, 0.07591097f, -0.18509431f, -0.02636946f, -0.02184336f, -0.05547873f, 0.09196921f, 
    0.02289908f, 0.03496392f, 0.03584809f, 0.08680046f, -0.34249458f, 0.12463486f, -0.03985798f, -0.04761842f, 
    -0.10517270f, 0.08509382f, -0.04267149f, -0.05152375f, 0.03764104f, -0.01747049f, 0.04109792f, 0.12119350f, 
    -0.14829029f, -0.15395407f, -0.06425820f, -0.22123079f, 0.06353007f, -0.01748644f, -0.05011305f, -0.00003022f, 
    0.06552982f, 0.07432130f, 0.06843347f, 0.00690306f, -0.12934752f, -0.03124457f, 0.04804258f, -0.01138807f, 
    0.03543085f, 0.01793314f, 0.02737342f, 0.08666615f, -0.05114349f, -0.09437911f, -0.10579265f, 0.01606332f, 
    0.23190695f, -0.00738703f, -0.10299668f, 0.07092398f, -0.03192186f, 0.05123596f, -0.02738737f, -0.00778358f, 
    0.02276123f, -0.03729976f, -0.21598829f, -0.12702046f, -0.10369690f, 0.14906305f, 0.01255063f, -0.22224335f, 
    0.04653750f, 0.01976960f, -0.08788265f, 0.09747686f, 0.04789749f, -0.04115365f, -0.00675685f, -0.07185274f, 
    0.02226226f, -0.03131401f, -0.08131140f, 0.12062286f, 0.00405032f, -0.00306020f, 0.00124928f, -0.11971503f, 
    -0.03532071f, -0.02906799f, -0.09622300f, -0.16731319f, 0.01278770f, 0.03585369f, 0.04712999f, 0.10327115f, 
    -0.19417754f, -0.00737975f, -0.07416221f, 0.02967765f, 0.00547581f, -0.04960926f, 0.06872516f, -0.02485981f, 
    0.18946169f, -0.16716871f, -0.12278233f, -0.01248037f, 0.04894438f, 0.02677354f, 0.10492188f, -0.01624544f, 
    -0.04734040f, -0.00196352f, -0.06341745f, 0.00096383f, 0.37585738f, 0.08498958f, -0.20916918f, -0.00329744f, 
    0.07320875f, -0.00694467f, 0.00275392f, 0.03964089f, 0.02214374f, -0.07079070f, -0.04792456f, -0.03609469f, 
    0.06302859f, 0.06650179f, -0.21416359f, -0.05413507f, -0.03187448f, 0.06173647f, 0.03163156f, -0.01078533f, 
    0.00268966f, -0.00674439f, 0.04513190f, -0.00086693f, 0.10823487f, -0.02654649f, 0.08873409f, -0.05100351f, 
    -0.11660248f, -0.13987969f, -0.00172730f, 0.01403393f, 0.03618990f, 0.00418171f, -0.03230253f, 0.02555295f, 
    -0.08262701f, -0.12164622f, 0.12218184f, 0.00141493f, 0.04454765f, -0.01292417f, 0.09227189f, 0.00403088f, 
    -0.01330486f, -0.11222007f, -0.11641942f, -0.03926049f, -0.28496787f, -0.16593046f, 0.12716299f, -0.01973755f, 
    0.06735138f, 0.02664244f, 0.02448526f, -0.05567994f, 0.07021000f, 0.02944399f, 0.09251690f, 0.09000261f, 
    -0.13744730f, 0.04026072f, 0.01078498f, 0.32118842f, -0.03897294f, 0.12028043f, -0.01795017f, 0.09091398f, 
    0.00271555f, 0.01541839f, 0.10482997f, 0.09109138f, 0.21239057f, -0.22209072f, -0.08851392f, 0.01210835f, 
    -0.08543663f, 0.00829356f, -0.09199671f, 0.05170350f, 0.03504460f, -0.06431203f, 0.04454301f, -0.06858464f, 
    -0.13771744f, -0.18568824f, 0.01412050f, -0.01874470f, -0.07227898f, 0.16587855f, -0.01222540f, 0.02614460f, 
    -0.11382974f, 0.07771058f, 0.10050313f, 0.03433837f, 0.24914184f, 0.01647365f, -0.10448288f, 0.12950960f, 
    0.05580300f, -0.05801199f, -0.07392863f, 0.00730324f, 0.04755683f, -0.01042180f, -0.09776656f, 0.03435767f, 
    -0.19893856f, 0.12202898f, -0.02826378f, -0.12803508f, -0.01501587f, 0.06534009f, 0.10478397f, -0.04528624f, 
    0.02515344f, 0.03160275f, -0.05116990f, -0.06215117f, 0.16899975f, -0.23832048f, -0.14180544f, 0.30197197f, 
    -0.00249825f, -0.02482192f, 0.07342404f, 0.01893551f, 0.00569034f, 0.02424225f, 0.02879515f, -0.06653196f, 
    0.19533898f, 0.05901530f, -0.14733136f, 0.00046414f, -0.03346262f, 0.09890404f, -0.04816159f, -0.00232771f, 
    0.02496989f, 0.02377088f, -0.05791603f, -0.01898956f, 0.08220437f, -0.05688097f, 0.03824453f, 0.05913218f, 
    0.04603486f, 0.04857165f, 0.04650507f, -0.01403222f, 0.04854016f, -0.06204261f, 0.02104030f, 0.07998101f, 
    -0.05592065f, 0.16187313f, -0.15890460f, -0.01758537f, 0.12679674f, -0.00381315f, -0.14312576f, 0.00828539f, 
    -0.05106319f, -0.04905622f, 0.05335528f, -0.07645759f, 0.01958971f, 0.04684229f, -0.17891154f, -0.20545159f, 
    0.19613703f, -0.09749188f, -0.04538591f, -0.10380413f, 0.03289181f, 0.02323736f, -0.02574010f, 0.08340292f, 
    0.13178103f, -0.19351865f, 0.02629584f, -0.14518340f, 0.12885313f, -0.06111822f, -0.07195933f, 0.04561839f, 
    0.00745001f, -0.10667074f, -0.02205320f, -0.01080111f, -0.15748042f, -0.06120494f, 0.03191258f, -0.11733322f, 
    -0.17634088f, -0.02193717f, 0.00674353f, 0.05625986f, -0.08344761f, -0.00866232f, -0.02514875f, 0.06000314f, 
    -0.24153630f, 0.01874736f, -0.21829709f, 0.17595221f, -0.02703678f, 0.04761956f, 0.02563740f, -0.02390828f, 
    -0.10437334f, 0.02853754f, -0.10747376f, -0.10515859f, 0.20143428f, 0.02154194f, 0.02139220f, 0.09821476f, 
    -0.00460690f, -0.01486113f, -0.00372023f, 0.02659926f, -0.00718243f, -0.03162248f, -0.02432494f, 0.14848423f, 
    -0.05125889f, 0.03571787f, -0.04541330f, 0.19348001f, 0.04636600f, -0.12471884f, 0.01834637f, 0.10982492f, 
    0.05692107f, -0.06212221f, -0.10642355f, -0.11318829f, -0.40566003f, 0.13788944f, -0.10178147f, -0.01544180f, 
    0.05830156f, 0.02000826f, 0.05104955f, -0.03274648f, 0.05274582f, -0.00938413f, 0.04362874f, -0.08124436f, 
    -0.21625805f, -0.33674559f, -0.15605402f, -0.19602488f, -0.03292654f, -0.00167917f, 0.04359076f, -0.00812348f, 
    -0.00969534f, 0.08502257f, -0.09087979f, 0.03160447f, -0.06481355f, -0.03643145f, -0.15478879f, -0.28495365f, 
    -0.00731312f, 0.00979687f, -0.01713720f, 0.07711782f, 0.17249617f, 0.06558494f, -0.01265432f, 0.02444183f, 
    0.16928457f, -0.16704631f, -0.17097481f, -0.05491817f, -0.03187900f, 0.02426712f, -0.04245383f, -0.01596066f, 
    0.07589888f, -0.00275494f, 0.01559014f, -0.00111923f, 0.14373617f, 0.07567303f, -0.00083671f, 0.15850730f, 
    -0.03625432f, -0.07864794f, -0.11914221f, -0.03188821f, 0.04039328f, 0.01296978f, 0.01576664f, 0.06686109f, 
    0.22057694f, -0.05842558f, -0.16456808f, 0.05102044f, -0.02025349f, -0.10345975f, 0.05030897f, 0.00139584f, 
    0.09291692f, 0.00760782f, -0.06738075f, -0.03243360f, -0.18372427f, 0.05702804f, -0.03830723f, 0.09495178f, 
    -0.09919926f, 0.05936756f, -0.14631279f, 0.10941733f, -0.15754186f, -0.00001312f, 0.01544638f, -0.08400216f, 
    0.07496432f, -0.20847921f, 0.02477115f, -0.01978262f, -0.02647390f, -0.02111714f, 0.12528756f, 0.13886112f, 
    -0.06288476f, -0.04388356f, -0.10133626f, -0.03514653f, -0.32976457f, -0.14765537f, -0.06270388f, -0.26398766f, 
    0.08374792f, 0.05671693f, -0.06117278f, 0.04225588f, -0.04221726f, -0.05412105f, -0.05231902f, -0.25985241f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03077001f, 0.06320187f, -0.02868852f, 0.00699790f, 0.03674165f, 0.03301496f, 0.03379375f, -0.04431862f, 
    -0.02142967f, -0.01794782f, 0.04244475f, -0.01264308f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
