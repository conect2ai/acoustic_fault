#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.90243894f, -1.05186439f, -0.40949768f, 0.70322078f, 0.26913074f, 0.14632189f, 0.46132097f, 0.12187221f, 
    0.49449235f, 0.17588028f, 0.11360023f, 0.04738120f, -0.14473194f, 0.12752926f, 0.05174193f, -0.12268911f, 
    -0.22830774f, 0.03270840f, 0.39725232f, 0.06668564f, -0.13613792f, -0.18234898f, 0.16759413f, -0.03616500f, 
    -0.09631269f, 1.01546907f, -0.18780345f, -0.57981974f, -0.43961984f, -0.78779685f, 0.30431893f, 0.27775723f, 
    0.32461983f, -0.13503253f, -0.14115429f, 0.28111866f, 0.30788586f, 0.20691310f, -0.38108876f, -0.06426803f, 
    0.10155060f, -0.26663762f, -0.02872241f, -0.44465679f, 0.53694075f, -0.14933167f, -0.34940276f, 0.11219462f, 
    0.38400331f, 0.16736378f, 0.97653377f, -0.10175602f, 0.17482592f, 0.44891840f, -0.44004324f, -0.06452929f, 
    -0.11429592f, 0.10272706f, -0.49781308f, -0.42065084f, -0.35473958f, -0.04790002f, 0.58374447f, -0.56075847f, 
    -0.05508921f, -0.03260681f, 0.16189630f, -0.15766029f, 0.12561363f, 0.19980401f, -0.05423673f, 0.15095469f, 
    -0.23042427f, -0.14746509f, 0.34343392f, -1.23614287f, 0.13027105f, 0.31436095f, 0.21367978f, 0.47114843f, 
    0.29418361f, 0.21874335f, -0.10706329f, -0.41317382f, -0.31584203f, 0.41575080f, -0.37853214f, -0.15701909f, 
    -0.18556719f, -0.23546036f, -0.16726936f, 0.04376888f, 0.03402968f, -0.17898406f, -0.17916745f, -0.13980035f, 
    0.05742527f, -0.17129919f, -0.02279713f, -0.40238056f, -0.68559909f, -0.67521828f, -0.73670965f, -0.51472688f, 
    -0.38723716f, 0.32998335f, 0.17420283f, -0.33933052f, -0.33990306f, 0.26187482f, -0.49651998f, -0.45032397f, 
    -0.26461551f, 0.15141685f, -0.17656572f, 0.15442838f, 0.16853248f, -0.16470833f, -0.37779567f, -0.40210122f, 
    -0.14903499f, -0.08799282f, 0.10012592f, 0.03695161f, -0.13915409f, 0.04391250f, -0.18804260f, -0.10176148f, 
    -0.11069987f, 0.67630172f, -0.05873185f, 0.26740336f, 0.20799159f, 0.48742807f, 0.25230598f, 0.07264357f, 
    -0.21228082f, -0.18811609f, -0.34573755f, 0.10015061f, -0.24820255f, 0.08129959f, 0.21742386f, -0.31460321f, 
    -0.24478771f, -0.19783555f, -0.39336264f, -0.40170586f, 0.16196559f, 0.19708569f, -0.63396144f, 0.51300782f, 
    -0.64453322f, -0.82079226f, 0.19494858f, -0.34153906f, -0.08901975f, 0.60225612f, 0.74178356f, 0.26913098f, 
    0.10833222f, -0.06143862f, 0.19626829f, -0.22300799f, -0.28827098f, 0.08650890f, -0.37711415f, 0.20990001f, 
    -0.25420216f, 0.17849173f, -0.19022211f, 0.28298372f, -0.07753237f, 0.00376332f, 0.36156726f, 0.59579432f, 
    0.04605553f, -0.09527700f, 0.34738681f, -0.46724626f, 0.38497430f, 0.03444217f, -0.31353116f, 0.02147022f, 
    0.12623483f, 0.26527411f, 0.15615088f, -0.39396557f, -0.01875112f, 0.28884986f, 0.21353166f, -0.01717802f, 
    -0.05944738f, 0.09275661f, -0.31961936f, 0.05409320f, -0.03266998f, -0.02915913f, 0.02822836f, 0.06762269f, 
    0.07002044f, 0.00389147f, -0.54587317f, -0.14511363f, -0.28112805f, -0.27940023f, -0.19713175f, 0.02354952f, 
    -0.13101965f, 0.47996247f, -0.06836878f, 0.00680370f, 0.46664053f, -0.26041302f, 0.16151337f, -0.42693946f, 
    -0.39588407f, 0.23872183f, 0.21839879f, -0.09040384f, -0.36057660f, 0.28678057f, -0.35771710f, 0.11799282f, 
    0.53105122f, 0.20834725f, -0.76551270f, -0.07109289f, 0.43614283f, 0.37020576f, 0.50452691f, 0.20605505f, 
    -0.25431985f, -0.22253320f, 0.30774525f, -0.18445504f, 0.00100908f, -0.00353655f, -0.17047992f, -0.46595386f, 
    -0.02429589f, 0.34485850f, -0.15833573f, -0.24485058f, -0.10706954f, -0.30743557f, 0.12218407f, 0.11445155f, 
    0.01283843f, 0.07339986f, 0.12663357f, 0.36009395f, 0.42843130f, 0.32961288f, 0.06492747f, 0.19446081f, 
    -0.22997053f, -0.03017347f, 0.03589775f, 0.03998230f, -0.00775168f, 0.16841936f, 0.05485515f, -0.10066842f, 
    -0.48479962f, -0.10676285f, -0.07757398f, 0.24567239f, 0.11414738f, -0.28869155f, 0.01645623f, -0.19938387f, 
    0.04132294f, -0.12480298f, 0.40038607f, -1.14242649f, -0.09462073f, -0.53140712f, -0.82441413f, -0.34857240f, 
    -0.02022692f, 0.19284901f, -0.09566432f, 0.31691977f, 0.22531535f, -0.09872589f, -0.45907158f, -0.47483709f, 
    -0.46166199f, -0.14278397f, 0.23248698f, 0.28249592f, 0.03563558f, 0.22747090f, -0.09323777f, -0.10397671f, 
    -0.19816874f, -0.17013378f, -0.09978908f, -0.40584406f, -0.66360754f, -0.23765281f, -0.11490442f, -0.16071273f, 
    -0.12769796f, -0.30449340f, -0.44779974f, -0.47815847f, -0.45682856f, -0.06548320f, -0.06793419f, 0.39121920f, 
    -0.36688775f, -0.02091128f, -0.15122244f, 0.05066228f, 0.03305079f, 0.03755876f, -0.13674246f, -0.28552592f, 
    0.13721938f, 0.36856189f, 0.27753571f, 0.30073813f, 0.26777038f, -0.57397282f, -0.13131839f, 0.03035009f, 
    -0.34689045f, -0.11953744f, -0.60689622f, -0.51651555f, -0.39888832f, 0.06265396f, 0.05032296f, -0.03684936f, 
    -0.24048862f, -0.35892925f, 0.47707617f, 0.21300772f, -0.16784659f, -0.04738704f, -0.01826815f, -0.07434373f, 
    0.21550848f, -0.14281833f, -0.25509265f, -0.44089544f, -0.39898416f, -0.23590373f, 0.49573979f, 0.24280915f, 
    0.33313850f, 0.51790535f, -0.53388971f, -0.69204980f, -0.64395791f, -0.60088301f, -0.47359550f, -0.57257241f, 
    0.14918907f, -0.15066740f, 0.43207914f, -0.02484663f, 0.15316370f, 0.35524195f, -0.29696432f, -0.12221124f, 
    0.04801138f, 0.19295923f, -0.14716375f, 0.10300712f, 0.13178703f, 0.06930571f, -0.05875065f, 0.37966162f, 
    -0.10985028f, 0.57859236f, -0.06525857f, -0.84458178f, -0.12275363f, 0.10576318f, -0.28381583f, -0.63838565f, 
    -0.66150814f, 0.44340158f, -0.30371818f, -0.20702530f, 0.26014507f, 0.04577182f, -0.10581702f, 0.00153335f, 
    -0.02228829f, -0.12710232f, -0.36305320f, -0.06417505f, -0.17841467f, -0.21302235f, -0.35603201f, -0.17078283f, 
    -0.47721323f, -0.21299675f, 0.31076843f, -0.30533078f, -0.56917787f, -0.81812352f, -0.62118304f, -0.56679100f, 
    -0.33064747f, -0.45032808f, 0.45901981f, -0.27934927f, 0.36022213f, -0.40535569f, 0.08136690f, -0.49608597f, 
    -0.24498440f, -0.35547549f, -0.48478472f, -0.44462177f, 0.03722623f, 0.07539511f, -0.31254217f, -0.05963164f, 
    0.14598693f, -0.52845508f, 0.36636713f, -0.06000960f, -0.15485761f, -0.13998136f, 0.48388883f, -0.08799693f, 
    -0.02734438f, 0.01235073f, 0.45028251f, 0.05112553f, 0.18154900f, -0.37538436f, 0.36032921f, -0.32826060f, 
    -0.26170102f, -0.27896440f, 0.01862045f, 0.29804778f, -0.01206600f, 0.08339434f, 0.17748047f, 0.31640717f, 
    -0.13585654f, -0.07620016f, 0.17443536f, -0.75885338f, -0.82423586f, -0.59000427f, -0.55720192f, 0.27249223f, 
    0.34103936f, 0.34410924f, 0.05171251f, 0.38218221f, 0.39714924f, 0.41731521f, 0.08216082f, -0.23863341f, 
    0.31679559f, 0.25893858f, 0.29819691f, -0.18565522f, -0.05204177f, -0.29065359f, -0.16057748f, 0.03197745f, 
    -0.16393283f, 0.01167069f, -0.01981236f, -0.48779228f, -0.67110324f, -0.25572017f, -0.28098094f, 0.28263295f, 
    -0.57502329f, -0.68891841f, -0.12204666f, 0.17652342f, -0.26688245f, 0.05419333f, 0.01839802f, -0.26772943f, 
    0.69687015f, -0.38708371f, 0.25762257f, -0.17406294f, 0.18772453f, 0.20418736f, 0.15319318f, -0.06074692f, 
    0.08458036f, -0.19296175f, -0.16145536f, 0.18594986f, -0.60604680f, -0.36926860f, 0.10208532f, 0.19015682f, 
    -0.72177321f, 0.05657355f, -0.42602009f, -0.83486485f, -0.64617181f, -0.44160429f, 0.03910958f, -0.23276760f, 
    -0.13190816f, -0.55290329f, -0.23298912f, 0.17707579f, 0.32229412f, 0.14731576f, 0.01028814f, -0.02787687f, 
    0.02538588f, 0.04616312f, -0.06711545f, 0.08158776f, 0.39928520f, 0.68233567f, 0.54354167f, 0.17235175f, 
    0.06819530f, -0.39057380f, -0.45364350f, -0.01373237f, 0.10642330f, 0.17568421f, -0.29540998f, -0.01979516f, 
    -0.09463147f, -0.13290611f, 0.13848637f, -0.25835213f, -0.07180028f, 0.18738762f, -0.00454162f, -0.03102913f, 
    -0.22758515f, -0.55380642f, -0.05976477f, -0.50983083f, -0.51297283f, -0.67053103f, 0.61072868f, 0.37839663f, 
    0.20308642f, 0.30643356f, 0.09397747f, 0.14018764f, 0.27311814f, 0.12138308f, 0.31595260f, 0.08331406f, 
    -0.00204333f, -0.07508213f, 0.03618888f, 0.14926453f, -0.34284812f, -0.16180046f, -0.04943823f, 0.12109772f, 
    -0.17728025f, -0.13740577f, 0.25488487f, -0.02624264f, 0.20391832f, 0.20454392f, -0.06836963f, -0.59588271f, 
    -0.30498102f, 0.51824164f, 0.46275190f, -0.05464078f, -0.22991954f, -0.33120891f, 0.29541525f, 0.03612690f, 
    -0.03800062f, 0.16997643f, -0.29575187f, -0.38725796f, 0.69131124f, -0.04832608f, 0.00471993f, 0.14933760f, 
    -0.26560718f, -0.13985512f, 0.22062160f, 0.25236666f, 0.03663279f, 0.02609158f, -0.14264910f, 0.07718816f, 
    -0.07852796f, 0.35131770f, -0.26702541f, 0.02139100f, 0.40456948f, -0.48294774f, -0.35167944f, -0.26840138f, 
    -0.00789831f, -0.22998393f, 0.07170905f, -0.35281748f, 0.00448660f, 0.24732275f, -0.48317057f, 0.22612515f, 
    0.05368008f, -0.12636328f, 0.23394337f, -0.27791539f, -0.02604604f, -0.09165663f, 0.03181586f, 0.36813191f, 
    0.35684538f, -0.27369136f, 0.12213899f, 0.50536597f, -0.42607656f, -0.57128245f, -0.28616405f, 0.17687266f, 
    0.17816488f, 0.14881347f, -0.00344886f, 0.16707793f, 0.05840629f, 0.30970600f, 0.03573539f, 0.02022517f, 
    -0.31854612f, -0.36821690f, 0.10245672f, 0.13176654f, -0.47823700f, 0.07829396f, 0.36629605f, 0.49401182f, 
    0.20976923f, -0.14997439f, -0.36955205f, -0.64743602f, 0.28329760f, 1.24585974f, 0.56079650f, 0.00978161f, 
    -0.89729667f, -0.81356120f, -0.36862704f, 0.12036175f, 0.00697849f, 0.26517886f, 0.06107794f, 0.32609761f, 
    0.13241728f, -0.20691778f, 0.00430274f, 0.04873337f, -0.01927145f, 0.03742399f, -0.11316865f, 0.17208362f, 
    -0.11649191f, 0.20282389f, -0.25766614f, 0.11842851f, 0.00060362f, 0.41581330f, 0.73371726f, 0.19870973f, 
    -0.42920005f, 0.23379333f, -0.09822993f, -0.08986451f, -0.34636787f, -0.21335655f, -0.14529093f, 0.06932274f, 
    0.24648184f, 0.08301058f, -0.15780602f, -0.12519898f, 0.02860115f, -0.01337771f, 0.14054383f, -0.09068887f, 
    0.13799070f, 0.39184174f, -0.22388229f, -0.32305947f, -0.18948667f, -0.71064442f, -0.99034727f, -0.63406181f, 
    -0.59744060f, 0.54007471f, 0.56431538f, 0.16120096f, -0.16954356f, -0.07871301f, -0.08608810f, 0.12898411f, 
    0.07251942f, -0.07781602f, 0.31254947f, -0.23718534f, -0.43034738f, 0.04489937f, -0.07659045f, -0.40410000f, 
    0.27874622f, -0.28612623f, -0.12044080f, -0.07071953f, 0.17851259f, -0.94636196f, -0.51992756f, 0.47424489f, 
    0.28023756f, 0.69469780f, -0.22243141f, -0.32042000f, -0.05970486f, 0.34378448f, 0.41453236f, 0.46327308f, 
    0.04245073f, -0.00344311f, 0.00813158f, -0.24759001f, -0.08745601f, -0.21840446f, -0.21238279f, -0.30744222f, 
    0.07589892f, 0.38611856f, 0.09692863f, -0.02114426f, 0.16411884f, 0.08455670f, -0.48506409f, -0.66559875f, 
    -0.08761466f, 0.61907971f, -0.63895428f, 0.66961598f, 0.10888007f, -0.15586430f, -0.14211488f, 0.54502034f, 
    -0.12492857f, -0.28926450f, 0.07407380f, 0.30833304f, 0.20563021f, -0.23543486f, -0.01194879f, -0.24864267f, 
    -0.00559984f, 0.15841970f, 0.01189611f, -0.00283319f, 0.30846605f, 0.01226146f, 0.01221626f, 0.00695385f, 
    0.19784504f, -0.37829784f, -0.10860433f, 0.24414380f, 0.00218134f, -0.03303822f, -0.04415666f, -0.20883672f, 
    -0.15412512f, -0.16975126f, 0.14890788f, -0.30978602f, 0.49009183f, -0.04603389f, -0.12495036f, -0.02353523f, 
    -0.33777869f, 0.13419929f, -0.04722266f, 0.25854734f, 0.43573400f, 0.06541767f, 0.38523036f, 0.06520897f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.07097346f, 0.49222091f, 0.18481575f, 0.07676951f, -0.05020267f, 0.34302220f, 0.29618719f, 0.21384045f, 
    0.47621605f, 0.31232068f, 0.13091975f, -0.06628612f, -0.06989529f, -0.03037606f, 0.06588095f, 0.11060561f, 
    0.14327870f, 0.21282963f, 0.19459732f, -0.00745215f, 0.10120334f, 0.00176626f, -0.21007475f, 0.13577239f, 
    0.30679998f, 0.10542957f, 0.20924507f, 0.33560547f, 0.01117746f, 0.27976182f, 0.45235980f, 0.06879306f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00184731f, -0.00690043f, -0.25985920f, 0.00302849f, 0.06730967f, 0.00412183f, 0.15302180f, 0.03353084f, 
    0.10067512f, 0.02249566f, 0.11699869f, 0.07441029f, -0.00277413f, -0.26287484f, -0.06808452f, 0.05808029f, 
    0.00345007f, 0.06718846f, 0.04415445f, 0.11745025f, 0.08373825f, 0.03154797f, 0.00862930f, -0.02180486f, 
    -0.11701343f, -0.10985457f, 0.06798907f, 0.28796086f, -0.22154389f, -0.04852553f, -0.33844495f, -0.07829547f, 
    -0.05626355f, 0.01557311f, 0.06562090f, 0.02577219f, 0.26200697f, 0.46292517f, -0.09726611f, -0.16290092f, 
    -0.00300609f, -0.00179676f, 0.01314170f, 0.02318048f, 0.01148395f, 0.03011619f, 0.08602900f, 0.17105488f, 
    0.39424315f, 0.20402069f, 0.11401961f, 0.07243092f, 0.17402337f, 0.14734805f, 0.06836398f, -0.01386881f, 
    0.06031881f, 0.05290683f, 0.01302322f, -0.00244083f, 0.01913207f, -0.02070662f, -0.21890195f, -0.04716593f, 
    -0.05353438f, -0.00417657f, 0.01652817f, -0.03449805f, 0.11487386f, 0.02078939f, -0.05326965f, -0.02677188f, 
    -0.09955018f, -0.22290982f, 0.01725262f, -0.24421816f, 0.08166581f, 0.20370327f, -0.07663445f, -0.10076828f, 
    0.14828433f, 0.08865440f, 0.07588843f, -0.02050766f, -0.25948641f, -0.01279112f, -0.11304045f, 0.07831101f, 
    -0.11084773f, -0.03455135f, -0.06705109f, 0.06963553f, -0.09202338f, -0.02520290f, 0.16612035f, -0.02821851f, 
    0.26513600f, 0.02602588f, -0.03718485f, 0.07330796f, 0.36980277f, 0.13612470f, -0.05233221f, 0.07335784f, 
    0.19609097f, -0.00738709f, 0.09192353f, 0.04753685f, 0.04080017f, 0.22955553f, -0.05030325f, 0.19470297f, 
    -0.09110438f, -0.01625368f, 0.03452174f, -0.11026905f, 0.00909169f, 0.15754074f, 0.11462841f, 0.23909725f, 
    -0.10318171f, 0.01311280f, 0.15236205f, 0.16721128f, -0.09609812f, -0.08039514f, -0.07024649f, 0.01882976f, 
    -0.02768732f, 0.00718717f, 0.07746463f, 0.06417422f, 0.40086797f, 0.22455220f, 0.08875468f, -0.04359076f, 
    0.15648405f, 0.11007055f, 0.08720184f, -0.01635835f, -0.01967795f, 0.07196243f, -0.02816733f, 0.11053360f, 
    0.38659808f, 0.31521112f, 0.11732363f, -0.12007587f, 0.17685208f, 0.25545090f, 0.05673588f, 0.21694513f, 
    -0.05263545f, 0.00801850f, 0.05598913f, 0.09310417f, 0.29824534f, 0.18128566f, 0.22746888f, -0.23313734f, 
    0.27603310f, -0.05576007f, -0.08521941f, 0.17491375f, 0.06636277f, 0.00495468f, 0.02648040f, -0.13430794f, 
    0.30088601f, 0.14110911f, 0.29825222f, -0.11393084f, -0.00883835f, -0.11318279f, -0.03411970f, 0.20806898f, 
    0.01477923f, 0.01441368f, 0.04774623f, -0.03793202f, -0.03118858f, -0.10695241f, 0.13805369f, -0.06942286f, 
    -0.05347590f, 0.07490022f, 0.01232971f, 0.11644328f, -0.09613696f, -0.01982627f, 0.05443919f, 0.10644918f, 
    0.27649128f, 0.22167586f, -0.06667157f, -0.10156275f, 0.17044570f, 0.08386692f, 0.09347186f, 0.18110217f, 
    0.08030125f, -0.01310876f, 0.12028591f, -0.07858723f, -0.09549589f, -0.19124356f, 0.01009687f, -0.07737947f, 
    -0.01032522f, 0.07214390f, 0.05238802f, -0.03327705f, -0.03782051f, 0.23399548f, 0.01334110f, 0.00723193f, 
    -0.04494846f, -0.25985381f, -0.22093818f, 0.04601990f, 0.08894041f, 0.17991698f, 0.12775867f, 0.04860102f, 
    0.07200727f, 0.01033310f, -0.27274445f, -0.02497206f, 0.47637191f, 0.20100614f, -0.04266920f, -0.26426545f, 
    0.21319127f, 0.20170563f, 0.19140804f, 0.19882131f, -0.00532389f, -0.02386635f, 0.02122961f, -0.01906275f, 
    0.32741505f, 0.38312933f, -0.03246780f, -0.05584649f, 0.09865335f, 0.05327031f, 0.00605127f, 0.16701582f, 
    0.02928846f, 0.08858012f, 0.01280734f, 0.11906149f, -0.18169570f, -0.16092867f, 0.04569983f, 0.03460812f, 
    -0.01313031f, 0.06487781f, -0.10840964f, 0.05674690f, -0.16162673f, -0.07141975f, -0.09746970f, 0.08396869f, 
    -0.14600223f, -0.06537401f, -0.02298291f, -0.01852740f, -0.01989888f, -0.04672957f, -0.06293982f, -0.02407171f, 
    -0.05141130f, 0.03342230f, 0.09254347f, 0.12709647f, -0.11271574f, -0.01891321f, 0.04291384f, -0.03417573f, 
    0.04555851f, -0.17521209f, 0.20866792f, 0.03449870f, 0.16317105f, -0.02359401f, -0.01076023f, 0.05818415f, 
    0.28131068f, 0.30536342f, 0.19590290f, 0.03037519f, 0.04316239f, 0.05587211f, -0.06077110f, -0.18994878f, 
    0.01049094f, 0.00714494f, 0.11605276f, 0.01293899f, -0.13841829f, -0.24204142f, 0.08456731f, -0.17606987f, 
    0.09226708f, 0.03364679f, -0.02943430f, -0.00232744f, -0.06756669f, -0.07165397f, 0.02957552f, -0.10281204f, 
    0.35503337f, 0.68865019f, -0.00551799f, -0.32093322f, -0.06808850f, -0.20857558f, -0.02749135f, -0.19446370f, 
    0.03670670f, -0.07406794f, -0.00849536f, 0.07838851f, -0.02679550f, 0.08000118f, 0.25866231f, -0.14713182f, 
    -0.02824197f, -0.09352226f, -0.09829074f, 0.01186777f, -0.02863545f, 0.02126958f, -0.02829465f, -0.03901834f, 
    0.21860059f, -0.14171667f, -0.34061185f, 0.07520001f, 0.15513831f, 0.34045267f, 0.05051020f, 0.06274115f, 
    0.03924562f, -0.09691981f, -0.02452754f, -0.14238331f, -0.20928831f, 0.12487472f, 0.03885523f, -0.23992907f, 
    -0.20590158f, -0.07453717f, 0.15865213f, 0.05650752f, 0.13531880f, 0.02428322f, 0.07926072f, 0.16179805f, 
    -0.17441517f, -0.02739617f, -0.05152221f, -0.00338078f, 0.11222992f, 0.03240175f, 0.10985105f, 0.04905577f, 
    0.25424308f, -0.03687264f, 0.11089127f, -0.03420891f, 0.01151571f, 0.03646415f, 0.00336656f, 0.05250298f, 
    0.04667288f, 0.16258322f, -0.09531336f, -0.08084784f, -0.12044616f, -0.05430530f, 0.07655606f, 0.06388763f, 
    -0.00601326f, -0.01741502f, 0.01044041f, 0.03982085f, 0.02569930f, 0.01800529f, -0.00117388f, -0.04241046f, 
    -0.04117971f, 0.03706716f, -0.04303864f, -0.05033262f, 0.01513390f, 0.02107333f, 0.02336445f, -0.02357101f, 
    -0.00894913f, 0.03405369f, -0.03208549f, -0.04055759f, -0.02137410f, -0.04985840f, -0.02926839f, -0.04187884f, 
    -0.01405368f, -0.00227524f, -0.02560211f, -0.04052491f, -0.04603532f, 0.03532990f, 0.02869700f, 0.03242364f, 
    -0.04742402f, -0.02701302f, -0.03724486f, -0.01358024f, 0.05418735f, 0.00124080f, 0.03248702f, -0.02392624f, 
    -0.01490261f, 0.02928595f, -0.03667927f, 0.00545240f, 0.00158721f, 0.02524818f, -0.00137432f, 0.03781853f, 
    -0.01160351f, 0.00826092f, -0.03493883f, -0.03091944f, -0.00991199f, -0.04658003f, -0.01589625f, -0.01369467f, 
    -0.03545866f, -0.04416742f, 0.02531823f, -0.02197181f, 0.03125183f, 0.00228162f, -0.04246309f, 0.00767927f, 
    0.03632766f, 0.02429172f, 0.01709713f, 0.04088981f, 0.02413559f, -0.01769600f, -0.02915008f, -0.04435276f, 
    -0.00277445f, -0.01719238f, -0.02501862f, -0.04365015f, 0.00053060f, 0.04443573f, 0.02493179f, -0.02802665f, 
    0.00972035f, -0.00330701f, 0.04414617f, 0.00788775f, -0.00858824f, 0.00477884f, 0.01318730f, -0.02806859f, 
    0.01784773f, -0.02191462f, -0.02472019f, 0.00871926f, 0.00881972f, 0.03208216f, -0.02093124f, 0.02304183f, 
    0.01501103f, -0.00260253f, -0.00535934f, 0.02877491f, 0.01188573f, 0.01489655f, -0.00682823f, -0.03421320f, 
    -0.04862966f, -0.00989102f, -0.00278091f, -0.00550688f, -0.00114699f, -0.02805620f, -0.03860917f, -0.03874931f, 
    0.01881622f, -0.04883285f, -0.04720629f, -0.03606470f, -0.02865985f, -0.01563403f, -0.05426504f, -0.01310245f, 
    -0.04486141f, -0.00632415f, -0.01452820f, -0.02519030f, 0.03538808f, -0.00565474f, -0.00983008f, -0.05813836f, 
    -0.00984646f, -0.02271099f, -0.05665945f, 0.01396419f, -0.01647232f, -0.04035772f, 0.02535218f, 0.04605400f, 
    -0.00382163f, -0.05420472f, 0.04187603f, 0.02081185f, -0.02169358f, 0.03459186f, 0.02595425f, -0.05385725f, 
    -0.00896787f, -0.03175178f, 0.01391810f, 0.00383252f, -0.00670964f, -0.04354575f, -0.01325503f, 0.04398291f, 
    -0.01243824f, -0.03232943f, -0.01107699f, -0.03253033f, 0.02481304f, -0.02546284f, 0.04194194f, -0.00609970f, 
    0.02445416f, -0.05039819f, 0.02133701f, 0.03112237f, -0.00088428f, -0.00301530f, 0.04730688f, -0.05175658f, 
    -0.04262838f, -0.01957209f, 0.03987604f, -0.01433321f, -0.05026624f, -0.00749747f, -0.05531439f, -0.05232231f, 
    -0.02827939f, 0.03121649f, -0.00788275f, 0.01510195f, -0.03893852f, -0.03206699f, -0.02439898f, -0.04456495f, 
    -0.00666581f, 0.00364846f, -0.04621758f, -0.00344674f, -0.04049928f, -0.04230576f, -0.03554328f, 0.02997405f, 
    0.03596875f, -0.00684707f, -0.04946173f, 0.02113763f, -0.00652806f, -0.02895328f, 0.03258755f, 0.04785533f, 
    -0.04101330f, -0.05046472f, -0.02670247f, 0.00560721f, -0.00921253f, -0.05326474f, 0.01956449f, 0.00718156f, 
    -0.05335779f, -0.01540500f, -0.03784301f, -0.02818387f, 0.02952333f, -0.00055901f, -0.03628480f, 0.03717440f, 
    0.04324357f, 0.04292673f, -0.04247583f, -0.05001078f, -0.02746376f, -0.01532822f, -0.05451890f, 0.04241360f, 
    0.04014047f, 0.00863272f, 0.00584269f, 0.01610814f, -0.02992314f, -0.02506708f, -0.01323002f, -0.04288621f, 
    -0.04129411f, 0.02297708f, -0.05083246f, -0.03291491f, 0.01110546f, 0.04202318f, 0.02863029f, -0.04088577f, 
    0.05098450f, -0.00799024f, 0.01179742f, 0.02047634f, 0.01871942f, -0.00484881f, 0.01481728f, -0.04511581f, 
    -0.01847371f, -0.01433529f, -0.03907015f, 0.02546078f, -0.04720132f, -0.01475043f, -0.00840074f, -0.03014852f, 
    -0.00222977f, -0.02304591f, -0.00252168f, 0.03483377f, -0.02059749f, 0.03509909f, 0.01564715f, -0.02109654f, 
    -0.03924374f, 0.01050994f, -0.02681302f, -0.04602629f, -0.01913204f, 0.02504445f, 0.02840043f, -0.05722851f, 
    -0.01079458f, -0.00178934f, -0.03924795f, 0.03128326f, -0.00190864f, 0.02772227f, -0.01587358f, 0.03624744f, 
    -0.03408553f, -0.03278344f, 0.03890970f, -0.01081099f, -0.01248375f, 0.04079252f, -0.03147756f, 0.03610741f, 
    -0.01614762f, -0.00679677f, -0.01658669f, -0.03118776f, -0.02620248f, -0.02625944f, -0.03458652f, 0.00130969f, 
    0.00763710f, -0.00633892f, -0.05042049f, -0.00111823f, -0.01814251f, -0.05777499f, 0.01799607f, 0.02574886f, 
    0.01097712f, -0.00611834f, 0.00278651f, -0.01769247f, 0.00444810f, 0.00960237f, 0.01737452f, 0.01171496f, 
    0.03932048f, -0.01704763f, 0.02465625f, -0.03663920f, 0.01669847f, -0.02420545f, -0.00189551f, -0.05197248f, 
    -0.02606626f, -0.05914775f, -0.01536650f, -0.02966135f, 0.02134292f, -0.05721546f, 0.02135243f, -0.02310229f, 
    -0.03164878f, 0.03407070f, -0.02473216f, -0.03258727f, 0.04014517f, 0.02177295f, -0.00320580f, -0.01387775f, 
    0.04432423f, -0.01056026f, -0.01990915f, -0.00317797f, 0.03624100f, -0.04064027f, -0.04347061f, 0.00324125f, 
    0.01673019f, 0.03439968f, 0.03503487f, 0.00766469f, -0.00252098f, -0.00976494f, -0.00224807f, -0.02564058f, 
    -0.02025713f, -0.00373974f, 0.00597250f, -0.04817644f, -0.01182430f, -0.03561508f, -0.00146647f, 0.00905096f, 
    0.04014922f, -0.01973201f, -0.02327245f, -0.05454205f, -0.01956416f, 0.02745400f, 0.00781591f, 0.01675319f, 
    -0.05325122f, -0.01392899f, -0.02200895f, 0.01789729f, 0.01077308f, -0.00564294f, 0.02971978f, -0.03547823f, 
    -0.03326167f, 0.01755969f, -0.00763879f, 0.02662778f, 0.01537736f, -0.04630939f, 0.00212951f, 0.01521080f, 
    0.00022564f, 0.00796963f, -0.00571555f, 0.02446923f, -0.00948665f, 0.01036698f, 0.02866019f, 0.00026458f, 
    -0.01530884f, 0.00212979f, -0.00536454f, 0.01415717f, -0.03596179f, -0.04714571f, 0.01901007f, -0.01715361f, 
    -0.04809360f, 0.02797414f, -0.00061981f, 0.00342356f, -0.05290183f, -0.05353589f, -0.04469370f, 0.03003731f, 
    -0.00588178f, -0.02832399f, 0.00767867f, 0.02913978f, -0.00566048f, 0.04380469f, -0.03690525f, 0.03219552f, 
    0.03246129f, 0.02101655f, -0.01596284f, 0.01912022f, -0.01205314f, -0.01335071f, -0.05680722f, 0.00001700f, 
    -0.02394450f, 0.03909110f, -0.01434383f, 0.01256101f, -0.02370381f, -0.00171942f, 0.01116061f, -0.01867470f, 
    0.03698885f, -0.00627013f, 0.03490563f, -0.01812887f, -0.03340606f, -0.01897266f, -0.00235440f, 0.01550911f, 
    0.01399063f, 0.01078592f, 0.01600338f, 0.00621434f, 0.01306486f, 0.00414843f, -0.03394032f, -0.01137877f, 
    -0.02773811f, 0.00955552f, 0.04309044f, 0.02295155f, 0.02557784f, -0.01559595f, 0.00789358f, 0.02956649f, 
    -0.02402988f, 0.02420413f, -0.00473742f, -0.02070811f, -0.04576334f, -0.00900566f, 0.01547620f, -0.03213773f, 
    -0.00165347f, -0.04032445f, -0.05095316f, -0.03473650f, -0.01882345f, 0.00093096f, 0.02106765f, -0.05308568f, 
    0.01808897f, 0.01627567f, -0.02202609f, -0.04696686f, -0.04226890f, -0.00933485f, 0.00114566f, 0.01670550f, 
    -0.05577208f, -0.01166938f, -0.02833543f, 0.01846847f, -0.03525682f, 0.00693491f, -0.01513882f, -0.02714400f, 
    0.00507787f, -0.00166735f, 0.02873144f, 0.03806851f, -0.03907218f, 0.04191400f, 0.02630663f, 0.00472122f, 
    0.01922191f, -0.05547787f, 0.03069274f, -0.03171687f, -0.03852144f, 0.03537593f, -0.04839396f, 0.00105383f, 
    0.03525896f, -0.00746836f, -0.00854037f, 0.04283898f, -0.01643987f, -0.05579755f, -0.04912590f, 0.01371939f, 
    0.01144041f, -0.01656878f, 0.00083656f, -0.05361045f, -0.04410034f, -0.01625758f, -0.05383117f, 0.02239787f, 
    0.01872795f, -0.03380720f, 0.02021315f, -0.02971159f, 0.04353666f, 0.03179115f, -0.04731472f, 0.02245970f, 
    0.00850702f, -0.02546972f, 0.00393188f, -0.00690556f, -0.02193409f, -0.00465952f, 0.03930167f, -0.02144089f, 
    0.00718063f, 0.01314510f, 0.03762483f, 0.02127575f, 0.01191251f, -0.03129932f, -0.03840201f, 0.02106846f, 
    0.03173814f, -0.03828922f, 0.02822168f, -0.04469559f, -0.02273424f, -0.04834733f, -0.04870614f, 0.02398408f, 
    0.01643754f, -0.03541129f, 0.04373185f, -0.00382545f, -0.04502380f, -0.01730550f, 0.01958194f, -0.04207013f, 
    -0.02428847f, 0.02877901f, 0.04089273f, 0.02104729f, -0.04606044f, 0.01589567f, -0.01094811f, 0.04456490f, 
    -0.02963931f, -0.05293018f, -0.02220893f, 0.03531028f, 0.03735496f, -0.02852193f, -0.01831770f, -0.02758864f, 
    -0.01535668f, -0.03861346f, -0.00858488f, 0.01568966f, -0.04465796f, -0.00092271f, -0.04733608f, -0.03311195f, 
    -0.05526442f, -0.02370406f, 0.02982089f, 0.02883456f, 0.00923398f, 0.01220153f, -0.05155315f, -0.01426855f, 
    0.02907458f, -0.03076398f, -0.02172210f, -0.02889164f, -0.02799347f, 0.02932906f, 0.01416134f, -0.00818645f, 
    0.02854987f, -0.00866783f, -0.05555299f, 0.00834976f, -0.02087715f, -0.04733879f, 0.02272295f, 0.00688269f, 
    -0.02927104f, 0.00351048f, -0.00253173f, -0.00825777f, -0.00414458f, 0.03475632f, 0.03441324f, 0.02026612f, 
    -0.03427602f, 0.02918805f, -0.05248288f, 0.01098352f, -0.03269337f, -0.00141450f, 0.03430581f, -0.00424008f, 
    0.00291280f, 0.02835877f, -0.03026021f, -0.03925263f, -0.00975450f, -0.01833371f, -0.04609744f, 0.01145130f, 
    0.00945660f, -0.05409045f, 0.01444092f, -0.03272022f, -0.04631749f, -0.04299361f, 0.01739660f, -0.00063740f, 
    0.02005322f, -0.01857402f, 0.00723858f, -0.01933743f, -0.01777329f, -0.00852810f, 0.05324148f, 0.03097594f, 
    0.02361330f, 0.01148503f, 0.03443410f, -0.02465999f, 0.02211753f, -0.02265638f, 0.00527126f, -0.02319581f, 
    -0.01570869f, 0.00994390f, -0.00379637f, -0.00695754f, 0.01887209f, -0.01105125f, 0.03909944f, -0.02136257f, 
    -0.01549095f, -0.01956794f, -0.04312659f, 0.03284260f, -0.01141624f, -0.04021487f, -0.02406065f, -0.05547666f, 
    0.04416182f, -0.02616210f, -0.02073904f, -0.01085574f, -0.05234936f, 0.04061457f, -0.02839904f, -0.04986562f, 
    0.00329552f, -0.00766441f, -0.04324988f, -0.02218197f, 0.03240197f, -0.05068163f, -0.04866038f, -0.04189443f, 
    -0.00842248f, 0.03689202f, -0.05143555f, 0.04239638f, -0.04986185f, -0.00522916f, 0.02655402f, -0.03396822f, 
    -0.01577255f, -0.01788037f, 0.03586387f, -0.04278048f, 0.00616343f, -0.00641096f, -0.03616972f, 0.00134325f, 
    0.03895364f, 0.03037092f, 0.03268295f, -0.02997783f, 0.02189904f, 0.00981028f, -0.01768128f, -0.02783941f, 
    0.04256609f, -0.03300927f, 0.04098838f, 0.01233014f, -0.03002381f, -0.04628054f, 0.04402237f, 0.00747203f, 
    0.03760586f, -0.04742240f, 0.03247114f, -0.03790481f, 0.02998250f, -0.05423111f, -0.05353733f, 0.03507926f, 
    0.00203633f, -0.02203544f, -0.05267481f, -0.03698037f, -0.05124484f, 0.02057134f, -0.00284214f, 0.03598941f, 
    -0.03452433f, -0.05484151f, 0.04139520f, -0.03893510f, -0.04529389f, -0.05332232f, 0.01812954f, -0.00058820f, 
    0.00988518f, -0.03441527f, 0.03945479f, -0.03512902f, -0.05618297f, 0.03282583f, 0.00254892f, 0.01301219f, 
    0.01589932f, -0.01190967f, -0.02088683f, 0.00052232f, 0.03962235f, -0.04148914f, -0.02371883f, 0.03618054f, 
    -0.04341233f, -0.04042758f, 0.04562570f, -0.04445153f, 0.02042316f, -0.05560876f, -0.01842446f, -0.00860824f, 
    -0.33414397f, -0.30995625f, 0.02215518f, 0.28554919f, -0.04875395f, -0.06426284f, -0.08783719f, 0.00820276f, 
    0.16014591f, -0.03646738f, 0.06393528f, 0.12821503f, 0.56497830f, 0.03986774f, 0.14943253f, -0.18269739f, 
    0.11156400f, 0.19165674f, 0.01940388f, 0.13244088f, 0.07859296f, 0.05899672f, 0.00561945f, -0.11084718f, 
    0.38585874f, -0.26782647f, 0.10896268f, -0.18778838f, -0.08676077f, -0.08578858f, 0.09849180f, 0.00303425f, 
    0.02349837f, -0.03729941f, -0.00098312f, 0.10041466f, -0.33504856f, -0.09883513f, 0.17583381f, 0.08824790f, 
    0.08502883f, 0.00463550f, 0.10629883f, 0.12552691f, 0.27627799f, 0.03507975f, 0.09787689f, 0.00735843f, 
    -0.09997703f, 0.14563343f, 0.04653031f, -0.17623654f, 0.03679227f, 0.02761515f, 0.06636152f, 0.03605966f, 
    0.02430156f, -0.08414337f, 0.09640560f, -0.11584355f, 0.08558451f, -0.18479635f, 0.17987250f, 0.34444404f, 
    -0.08715346f, 0.00139596f, -0.06272593f, 0.01157097f, 0.16931151f, -0.07559337f, 0.15584619f, 0.27045333f, 
    -0.51279306f, 0.07803679f, 0.40471527f, -0.11417450f, -0.01759931f, -0.10143141f, -0.03608111f, 0.12363244f, 
    -0.04645668f, 0.10253564f, 0.08250099f, 0.05133761f, 0.26876861f, 0.02626130f, -0.11421379f, 0.00847571f, 
    0.12456755f, 0.00132044f, 0.10976303f, 0.01194697f, 0.13849369f, 0.13632968f, -0.05085895f, 0.01444675f, 
    0.37232533f, 0.08686933f, 0.14144853f, 0.01619957f, -0.02839722f, 0.01008443f, 0.13475543f, 0.13820688f, 
    -0.05319379f, 0.18728748f, -0.14336088f, 0.17624024f, 0.18858254f, -0.31616291f, 0.21160701f, 0.24627590f, 
    -0.07640228f, -0.01806117f, -0.14629230f, 0.04818968f, 0.18362659f, -0.04731320f, -0.01107413f, 0.01461049f, 
    0.06491153f, -0.09438753f, -0.06122789f, 0.09482408f, 0.03445637f, 0.09727069f, -0.04119711f, -0.04590806f, 
    -0.00704858f, -0.01306527f, -0.08954488f, 0.02300016f, -0.47301590f, 0.19029097f, 0.07690029f, -0.11225002f, 
    -0.05691015f, 0.00060300f, 0.11718547f, 0.09283262f, -0.01269680f, -0.04541606f, 0.04800441f, -0.13873507f, 
    -0.14534822f, 0.08213155f, 0.10125548f, -0.10710712f, 0.01678997f, -0.05457081f, -0.02060510f, -0.09777071f, 
    -0.05196859f, -0.07524529f, -0.12625234f, -0.13325103f, -0.12655239f, 0.02861180f, 0.12559395f, 0.05995893f, 
    0.02011646f, -0.24999425f, 0.07043963f, -0.09699051f, -0.00899124f, 0.04893923f, 0.10925017f, 0.05084135f, 
    0.30535144f, 0.13411580f, -0.25094211f, -0.21217856f, -0.00407181f, -0.08771258f, 0.10161054f, -0.11895853f, 
    0.02818948f, -0.07431402f, -0.03233640f, 0.01075468f, 0.17208166f, 0.12909205f, -0.07783026f, -0.17650726f, 
    0.00583919f, 0.04538693f, -0.00479522f, -0.06183121f, 0.01531744f, -0.01951779f, 0.07359415f, 0.12108997f, 
    -0.08797642f, 0.02472483f, -0.10124280f, -0.12043550f, -0.03700357f, 0.02845691f, 0.06918471f, -0.08768086f, 
    0.10932364f, 0.03052342f, 0.07694029f, 0.11615148f, -0.42215884f, -0.09228057f, 0.24319172f, 0.07434744f, 
    0.08743545f, 0.12245736f, -0.01799939f, -0.03313884f, 0.09681581f, 0.16757171f, 0.12681627f, 0.06454090f, 
    0.17912771f, 0.26497477f, 0.18928191f, -0.32172763f, -0.09712782f, -0.06061261f, -0.10099478f, 0.15493216f, 
    0.13747744f, 0.00614082f, 0.20010954f, -0.16285743f, 0.06974505f, -0.01013374f, 0.26760352f, 0.12395152f, 
    0.14462665f, -0.16984473f, 0.23570523f, 0.04620241f, -0.01350169f, -0.08096365f, 0.04410210f, 0.06928837f, 
    0.03132923f, 0.18371196f, 0.05590177f, -0.12646976f, 0.04708685f, 0.05332649f, 0.12115334f, -0.05390426f, 
    -0.00578497f, -0.03236464f, 0.09496066f, -0.06868711f, 0.26795581f, -0.05181972f, -0.19384813f, -0.17239618f, 
    0.04966488f, 0.00737621f, 0.17786711f, 0.05252265f, 0.14388937f, 0.05667817f, 0.10503399f, -0.15890667f, 
    0.14128372f, -0.07096335f, 0.08500965f, -0.06739168f, -0.06155977f, -0.05255916f, -0.06286974f, -0.08814728f, 
    -0.02379546f, -0.08745430f, -0.13054813f, -0.11667838f, -0.03862969f, -0.31217533f, -0.02536327f, 0.27486935f, 
    0.21084614f, 0.16556895f, 0.18633494f, 0.00819139f, 0.17646286f, -0.00809158f, 0.06411809f, 0.06481855f, 
    -0.01902450f, -0.00381858f, -0.09201925f, -0.20533597f, 0.23556855f, 0.04047401f, 0.12521337f, 0.08702809f, 
    0.04799330f, -0.06867118f, -0.04402566f, 0.12563601f, -0.21729247f, 0.15789023f, -0.09504317f, -0.26051688f, 
    -0.00534041f, -0.10788743f, 0.03417684f, -0.03055107f, 0.08246054f, 0.17323597f, -0.06065637f, -0.05237737f, 
    0.18598957f, -0.40513700f, 0.23621292f, -0.01687304f, 0.08495080f, 0.04600501f, 0.04470827f, -0.16909449f, 
    0.08997636f, -0.06133043f, 0.09958050f, -0.04475174f, 0.07740752f, -0.10437518f, -0.01592631f, -0.00543539f, 
    0.11984315f, 0.07766404f, 0.07606861f, 0.04635038f, -0.05018306f, 0.04803731f, -0.02546140f, -0.06381074f, 
    -0.08746750f, 0.06347133f, -0.00892878f, -0.32522196f, -0.11929316f, -0.08751598f, -0.07657301f, -0.01148054f, 
    0.06297515f, 0.00824628f, 0.00563966f, 0.08133111f, -0.06142099f, -0.15753506f, 0.05252720f, 0.49471027f, 
    0.03893022f, -0.01430104f, 0.09857987f, -0.01189738f, 0.15275858f, -0.09838621f, 0.22443187f, 0.01383070f, 
    -0.06089585f, -0.03378207f, -0.20192684f, 0.20589219f, 0.09045630f, -0.00800169f, -0.01016905f, 0.18362325f, 
    0.18607868f, -0.04022577f, -0.06435723f, 0.12124994f, -0.07812029f, -0.11032200f, -0.00354894f, -0.17747331f, 
    0.12846266f, 0.05401817f, 0.00512799f, 0.00015352f, 0.00157846f, 0.04111458f, -0.20295034f, -0.09547010f, 
    -0.32741538f, 0.04459658f, 0.02323894f, -0.04102183f, -0.08214404f, 0.12818386f, 0.11269916f, 0.11725639f, 
    -0.00652198f, 0.15918839f, -0.03153915f, -0.06359655f, -0.28072757f, 0.07784881f, 0.00441858f, 0.23904186f, 
    0.04184555f, -0.03401517f, 0.07250523f, -0.03297618f, 0.03704540f, 0.02794748f, 0.05185477f, -0.05095892f, 
    0.04286023f, 0.36436802f, 0.05149016f, 0.01817472f, -0.01744342f, 0.04404704f, 0.22217375f, 0.12784578f, 
    0.02201124f, -0.04241477f, -0.04550165f, -0.07261894f, -0.05543125f, -0.12538272f, -0.20131497f, -0.16901520f, 
    0.01505486f, 0.06409526f, 0.08175322f, -0.06605235f, -0.00147643f, 0.19091779f, 0.03838355f, 0.09290080f, 
    -0.26637930f, -0.08665944f, 0.18407853f, 0.15376423f, -0.09418377f, -0.04741141f, -0.05128068f, -0.14530332f, 
    -0.03659478f, -0.07395993f, 0.01923788f, 0.18926445f, -0.12201578f, 0.03877494f, -0.08953148f, -0.02816583f, 
    0.05322176f, -0.01555433f, -0.00095652f, 0.08146366f, -0.12179697f, 0.21885601f, 0.15925768f, 0.08529336f, 
    0.46450195f, 0.08898810f, -0.13833514f, 0.38485828f, 0.10339199f, 0.14412309f, -0.15976831f, 0.31382611f, 
    0.03607978f, -0.01146035f, -0.16983119f, -0.04882387f, 0.04583687f, 0.10533098f, -0.02246496f, 0.11916658f, 
    0.07719347f, -0.06223592f, 0.04223331f, 0.08417052f, 0.11114613f, 0.11978514f, 0.05554809f, 0.04096031f, 
    0.05669116f, 0.00096045f, -0.00251549f, 0.29257986f, 0.08669312f, 0.03076601f, -0.03299509f, 0.17946468f, 
    0.02477585f, -0.03144332f, 0.01830344f, -0.05125414f, -0.25113660f, 0.18121903f, -0.19515018f, -0.15341835f, 
    0.02587588f, 0.00270164f, -0.06609537f, -0.00713249f, -0.15776168f, -0.11240753f, -0.02252291f, 0.06418616f, 
    0.07502643f, 0.13884346f, -0.02085526f, -0.11730029f, 0.03919066f, -0.08104724f, 0.01468994f, 0.03311687f, 
    -0.03491842f, -0.06293243f, -0.00248347f, -0.04111888f, 0.13075905f, 0.02538905f, 0.08014967f, 0.18046835f, 
    -0.08807424f, -0.01580111f, 0.01408314f, -0.02282211f, 0.00544630f, 0.03070145f, 0.09048706f, 0.10485324f, 
    -0.00610008f, -0.20694004f, -0.19498001f, 0.05347800f, 0.00826456f, -0.02427387f, 0.02857455f, -0.16195859f, 
    -0.08079812f, -0.02131855f, -0.02174650f, -0.04631479f, -0.03462391f, -0.12999122f, -0.05150048f, 0.09798283f, 
    0.01606686f, 0.19855259f, 0.01545773f, -0.10820800f, 0.05023539f, 0.02018892f, 0.03707035f, 0.08877104f, 
    -0.15827511f, -0.03072317f, 0.27415830f, 0.17423296f, 0.15610224f, 0.06439419f, 0.08893485f, -0.16313049f, 
    0.03922620f, -0.05458106f, -0.02609245f, 0.02698755f, -0.15190801f, 0.06744244f, 0.02114728f, 0.04086343f, 
    0.19296210f, -0.03946565f, -0.07139158f, -0.16767839f, -0.00623126f, 0.14315765f, 0.14397992f, 0.19736014f, 
    -0.05214263f, -0.16747880f, -0.11721000f, -0.17373715f, -0.00226869f, -0.09773421f, -0.06649783f, -0.02565340f, 
    -0.02320492f, 0.05666002f, 0.06384946f, 0.08514120f, 0.02468162f, 0.04025057f, -0.09813103f, 0.18649468f, 
    0.17384945f, -0.01290770f, -0.00609907f, 0.08838050f, 0.10547541f, -0.03580832f, 0.11116371f, 0.00466229f, 
    -0.02827207f, 0.25356197f, 0.05312915f, 0.16600505f, -0.05906213f, 0.11243596f, 0.11698358f, 0.11446466f, 
    -0.10360462f, -0.02948373f, 0.05138579f, 0.16121455f, -0.04274754f, -0.36789322f, 0.07665478f, -0.02896562f, 
    -0.15371081f, -0.01754908f, -0.14793405f, -0.17381848f, -0.00963884f, -0.03217809f, 0.04164147f, -0.03567657f, 
    -0.24308674f, -0.17701456f, -0.00001527f, 0.25030699f, -0.12862884f, -0.16088165f, -0.03325146f, -0.22068931f, 
    -0.06663702f, 0.05896335f, -0.03236563f, -0.05806015f, 0.08297640f, -0.04249148f, -0.00428007f, -0.05528977f, 
    -0.09682766f, -0.12413695f, -0.15294716f, -0.06597859f, 0.03707404f, 0.08508765f, 0.14912108f, 0.03020305f, 
    -0.07648998f, 0.11277694f, 0.04719416f, -0.11497763f, -0.01233198f, -0.02403150f, -0.00350988f, 0.04254274f, 
    -0.12067433f, 0.00723378f, 0.00900087f, 0.01990549f, 0.04270653f, -0.05015051f, -0.02061252f, 0.06653295f, 
    -0.01412854f, 0.06290381f, 0.02845315f, -0.19437875f, 0.06180393f, -0.10986707f, 0.12399693f, 0.02654011f, 
    0.24465074f, -0.23140489f, 0.05746656f, -0.04285121f, -0.07508748f, 0.04609698f, -0.12920159f, 0.25458139f, 
    0.02378008f, 0.00558488f, 0.06749779f, -0.03537596f, 0.19536819f, -0.03732912f, -0.17480834f, 0.20597464f, 
    0.02019234f, 0.01878681f, 0.01592523f, 0.10628568f, 0.07840189f, -0.00370460f, -0.03541080f, 0.01875021f, 
    -0.20212452f, 0.40757227f, -0.30318949f, 0.49772841f, -0.02889055f, -0.07013898f, -0.02753880f, 0.00470407f, 
    -0.10640787f, -0.00781953f, -0.00363597f, 0.10155661f, 0.02111806f, 0.44907835f, -0.08446536f, 0.19573826f, 
    0.01868889f, 0.05342646f, 0.10469394f, 0.01749442f, -0.05510800f, -0.07899272f, 0.03445895f, -0.00258312f, 
    -0.24072391f, 0.28715423f, 0.38578525f, 0.49239418f, -0.06663945f, -0.00258819f, 0.13804774f, -0.07184748f, 
    -0.05723143f, 0.09643292f, 0.07362430f, 0.03545604f, 0.06625681f, -0.03468464f, -0.39032593f, -0.10415675f, 
    0.17347887f, -0.08868942f, 0.00180707f, -0.02207045f, -0.07099470f, -0.01670381f, 0.18824121f, 0.07422777f, 
    -0.32486057f, 0.04378771f, 0.14798185f, 0.33256400f, 0.14746009f, 0.01370861f, 0.20051846f, 0.01152397f, 
    0.03553275f, -0.13469580f, -0.03865834f, 0.15743762f, -0.08541730f, -0.06728043f, -0.03977145f, 0.03672726f, 
    -0.00193031f, 0.14805049f, -0.07187983f, -0.02585569f, -0.00944448f, 0.01941489f, -0.03376331f, 0.02849966f, 
    -0.27843499f, 0.04632327f, -0.04255712f, -0.08827412f, -0.07231451f, 0.06677473f, -0.03081775f, 0.00852405f, 
    -0.06238951f, 0.07239393f, -0.05147300f, 0.02113909f, 0.50304574f, 0.11377054f, -0.03031902f, 0.03129840f, 
    0.14214328f, -0.05206476f, 0.13414943f, 0.02514307f, 0.06135026f, 0.05943690f, -0.10340802f, 0.02675048f, 
    0.54879093f, 0.32289630f, 0.39672330f, -0.24586059f, -0.19623600f, -0.04861308f, 0.01339542f, -0.14345568f, 
    -0.01247878f, -0.08312622f, 0.00135685f, -0.02115218f, 0.05360144f, -0.43514410f, -0.17139116f, -0.06124967f, 
    0.13438855f, -0.02437315f, -0.00648286f, -0.00343099f, -0.00525952f, 0.26801997f, 0.13167635f, 0.04932508f, 
    0.06416902f, 0.00917062f, 0.26755291f, 0.23048976f, 0.03283076f, 0.00174709f, 0.08541855f, 0.15369193f, 
    -0.00629347f, -0.02580391f, 0.07768265f, -0.07559162f, 0.00129516f, 0.26764107f, 0.10893389f, 0.00162949f, 
    0.05797220f, 0.03571613f, -0.02069603f, -0.00145559f, 0.07778095f, 0.24518232f, 0.03541399f, 0.00781562f, 
    -0.43873790f, 0.17543875f, 0.05436047f, -0.03382202f, -0.06618129f, -0.03867994f, -0.10840614f, 0.23621055f, 
    0.04647794f, 0.11324669f, 0.06174739f, -0.06935116f, 0.19451188f, 0.04844651f, 0.00268194f, 0.11102844f, 
    0.01627116f, -0.00004097f, 0.07620142f, -0.05068684f, 0.05848118f, 0.03475745f, -0.06340570f, -0.08536669f, 
    -0.23665354f, -0.02744740f, 0.06466965f, -0.02865111f, -0.14469402f, 0.16964379f, -0.00465083f, 0.08073768f, 
    0.05265881f, 0.07535782f, -0.01164320f, -0.14156759f, 0.18018268f, 0.00760506f, -0.02270334f, 0.15508333f, 
    0.05368305f, 0.08086717f, 0.10596315f, 0.14464054f, 0.01027096f, 0.16666768f, -0.00794519f, 0.09836442f, 
    0.24046370f, 0.22832097f, 0.12755634f, -0.03488062f, -0.10689826f, -0.01113098f, -0.01064887f, -0.10731925f, 
    0.00120263f, 0.06519259f, 0.00518074f, 0.02829014f, -0.08291824f, -0.01263860f, 0.07312977f, 0.19368769f, 
    0.02652533f, 0.06378052f, 0.01752180f, 0.00569195f, 0.01343558f, 0.06773913f, -0.13117480f, -0.13396795f, 
    -0.15108135f, -0.05523907f, -0.01543937f, 0.15958463f, -0.07829282f, 0.02976784f, 0.05973585f, -0.10088250f, 
    -0.12605645f, -0.06689519f, -0.09442616f, -0.07872707f, -0.18313959f, -0.13490483f, -0.15336780f, -0.05173254f, 
    0.02620583f, 0.17874816f, 0.14003924f, -0.00241358f, 0.19114743f, 0.03665122f, 0.10845969f, 0.13757552f, 
    0.00602102f, -0.04871105f, -0.00681731f, -0.11810581f, -0.16537902f, 0.07645395f, 0.10624016f, -0.10874487f, 
    -0.13112926f, 0.02686201f, -0.03160244f, 0.04502954f, -0.06171332f, -0.07860103f, 0.22074237f, -0.12459137f, 
    0.07283726f, -0.18778308f, 0.19685310f, -0.08703808f, 0.01271657f, 0.00964909f, 0.04727588f, -0.01558555f, 
    -0.26255131f, -0.07756873f, 0.01705817f, 0.10295424f, -0.02871664f, 0.03839414f, -0.03075190f, -0.06146489f, 
    -0.06859352f, 0.03848503f, 0.00677877f, 0.05615195f, 0.05011170f, 0.20630278f, -0.02934423f, 0.05428338f, 
    0.04089919f, -0.02731580f, 0.09696151f, 0.04242415f, -0.11571459f, -0.10163127f, -0.15008520f, 0.02750798f, 
    0.03844692f, 0.08726428f, -0.10369425f, -0.03771072f, -0.06587862f, 0.01086611f, -0.01437682f, -0.01687769f, 
    -0.09357436f, 0.06443590f, 0.13327450f, 0.02305298f, -0.35274765f, -0.06132807f, -0.00450428f, 0.10126764f, 
    -0.08796486f, -0.12343635f, -0.04421266f, -0.07807083f, 0.04833763f, 0.02137639f, -0.02614661f, -0.08642530f, 
    -0.15228623f, -0.13370891f, -0.00998211f, 0.16004291f, -0.08066380f, 0.09492061f, -0.00274721f, -0.15588813f, 
    -0.02301288f, -0.00470687f, -0.06196047f, -0.15431167f, 0.04864264f, 0.06644103f, 0.05954728f, -0.04088723f, 
    0.00255414f, 0.01143111f, -0.05191305f, -0.06648968f, 0.24193586f, 0.03669887f, 0.05152438f, 0.35144776f, 
    0.38852984f, 0.22774516f, 0.11688051f, 0.04593353f, -0.13853368f, -0.10410604f, 0.01916821f, -0.03009684f, 
    -0.03879992f, -0.01158413f, 0.01392634f, -0.04479047f, -0.25343290f, 0.07000057f, -0.02092996f, -0.00377178f, 
    -0.15077601f, 0.07516617f, 0.03906481f, 0.03175626f, -0.05545141f, -0.15342519f, 0.04032140f, -0.06693488f, 
    0.07916317f, -0.05796916f, -0.06055620f, -0.04953203f, 0.02648981f, -0.00190166f, -0.02360160f, -0.00002023f, 
    -0.08001637f, -0.05772997f, -0.09078630f, -0.02621793f, -0.00211430f, -0.05359489f, 0.19761969f, -0.23507595f, 
    -0.05765324f, 0.02345608f, 0.03390277f, 0.19911601f, -0.05040173f, -0.02158851f, -0.08082140f, 0.03272854f, 
    -0.86583871f, 0.10647351f, -0.33496654f, 0.36883959f, 0.07943984f, -0.02491234f, -0.00337706f, 0.01563798f, 
    -0.15301248f, -0.02903538f, -0.04308901f, 0.08702218f, 0.32485160f, 0.38327903f, 0.13086700f, -0.00866978f, 
    -0.09431884f, -0.06697769f, -0.08709037f, -0.10575342f, -0.01456241f, -0.03240469f, 0.14092164f, 0.09584508f, 
    0.00330106f, 0.23745129f, 0.41951394f, 0.15405217f, -0.18027113f, -0.06467451f, 0.04006762f, 0.05884796f, 
    0.04823436f, 0.05610916f, 0.06600004f, 0.09030634f, -0.20732641f, 0.17074640f, -0.25182039f, 0.22920939f, 
    0.13310111f, -0.01496355f, -0.08030751f, -0.01567900f, -0.00304793f, 0.02968608f, -0.10532719f, -0.00408625f, 
    0.01474721f, 0.27665910f, 0.02751293f, 0.01881263f, -0.04377637f, -0.04915775f, 0.02981068f, -0.03394282f, 
    -0.05087015f, 0.04987811f, 0.03937511f, 0.08411242f, -0.01777537f, -0.08179785f, -0.02975844f, 0.10799422f, 
    0.06407181f, -0.00731839f, -0.16720808f, 0.11251661f, -0.00026408f, -0.18233535f, -0.01128531f, -0.00055111f, 
    -0.21623550f, -0.07046167f, 0.32361293f, 0.04792844f, 0.02961405f, -0.05988834f, -0.14755806f, 0.03410263f, 
    -0.05847552f, 0.09979121f, -0.11286134f, 0.11339043f, -0.08209205f, -0.00019633f, 0.03706871f, -0.12887222f, 
    0.07211152f, 0.11650486f, -0.30358055f, -0.01004922f, -0.00623854f, -0.01170549f, 0.16949043f, 0.00947357f, 
    -0.11007410f, -0.19463153f, 0.01839199f, -0.06106386f, 0.22227839f, -0.00451899f, 0.02787521f, 0.34549361f, 
    0.11415385f, -0.07764138f, -0.06780969f, -0.06878720f, -0.29207283f, -0.17057291f, 0.25635332f, 0.47388425f, 
    0.08010790f, 0.01508920f, -0.10196026f, -0.06758496f, 0.06459478f, -0.11981052f, -0.13477968f, 0.07009741f, 
    -0.38810372f, 0.03456801f, -0.07011534f, 0.05463109f, -0.07430781f, -0.04711674f, -0.12319920f, 0.04787428f, 
    -0.04965723f, -0.04391265f, -0.05164260f, 0.00709330f, -0.01683192f, 0.04315602f, -0.06402688f, 0.07965928f, 
    0.02280694f, 0.03299645f, -0.01847578f, 0.08198858f, -0.10434428f, -0.04945865f, -0.03489330f, 0.01778178f, 
    0.03630792f, 0.13981441f, 0.14957790f, 0.09110092f, -0.05556160f, 0.00534344f, 0.10539778f, 0.07646889f, 
    -0.02592719f, 0.01521774f, -0.01917372f, 0.12181789f, -0.00883552f, -0.08668831f, -0.07568116f, -0.12579308f, 
    0.10200611f, 0.00685290f, -0.08701540f, -0.02000888f, 0.11148608f, 0.13332307f, -0.09257791f, 0.02216196f, 
    -0.00156337f, 0.19998156f, 0.18281323f, 0.00330159f, -0.17101859f, -0.00196467f, 0.15610416f, -0.00815472f, 
    -0.08229409f, -0.02402407f, 0.02748759f, 0.04622499f, -0.05238960f, -0.25381750f, 0.21890698f, -0.02848581f, 
    -0.03377546f, 0.11412011f, -0.12212265f, -0.03971671f, -0.03831016f, -0.04218489f, 0.13070014f, -0.12129693f, 
    -0.06119177f, -0.21307696f, -0.13649333f, 0.30734921f, 0.02896196f, -0.01522055f, 0.03540022f, -0.03354061f, 
    0.07007984f, 0.00376073f, -0.03630542f, 0.01735286f, -0.33837512f, -0.08341111f, 0.03667100f, 0.12136456f, 
    0.00969634f, -0.16870651f, -0.08609881f, -0.01311821f, -0.03182120f, -0.01520407f, 0.02051276f, 0.06388259f, 
    0.00412664f, 0.20250249f, 0.22077802f, 0.05557103f, 0.02476464f, -0.07714489f, 0.19838753f, 0.05117578f, 
    0.07434923f, 0.01200203f, 0.07349005f, 0.03214462f, -0.10315276f, 0.09129146f, 0.05160903f, 0.21992631f, 
    -0.08665580f, -0.09741130f, -0.04306994f, 0.01993740f, -0.08771256f, 0.09135530f, -0.06428258f, 0.13276348f, 
    0.02740621f, 0.13816412f, -0.05411494f, 0.15595402f, 0.21128210f, 0.17595868f, 0.05904422f, 0.21270691f, 
    0.07662854f, 0.00823058f, -0.12332514f, -0.03940707f, 0.14238265f, 0.26687065f, -0.12415114f, 0.29295349f, 
    -0.00575325f, 0.15246189f, -0.02226595f, 0.05873051f, 0.07184619f, 0.05981331f, -0.11696342f, -0.11389096f, 
    -0.01666415f, 0.11608490f, 0.23154826f, 0.20866442f, -0.01202141f, 0.10562527f, 0.07760215f, -0.02203021f, 
    -0.00046234f, 0.03185896f, 0.02946637f, 0.04776065f, -0.01148736f, 0.14077528f, -0.05422262f, 0.05242503f, 
    0.03616252f, -0.04670746f, 0.03535658f, -0.08126094f, 0.14443278f, 0.03016622f, 0.05764753f, -0.01756895f, 
    0.04470973f, 0.08029158f, 0.24093515f, -0.13005611f, 0.07439858f, -0.08018683f, -0.00143950f, 0.05109619f, 
    0.01134277f, -0.09234806f, -0.02710189f, -0.04675430f, -0.20246865f, 0.25639719f, 0.22456145f, 0.18484576f, 
    -0.12760267f, -0.07854350f, -0.11630496f, -0.01338360f, -0.10672359f, 0.03674220f, 0.03625213f, 0.03147819f, 
    -0.04868245f, -0.13327970f, 0.15391968f, 0.06600782f, -0.02973547f, 0.17199512f, 0.11164904f, -0.00656989f, 
    0.02232900f, 0.00441225f, 0.09064527f, 0.07276938f, -0.03666547f, 0.00426414f, -0.18336917f, -0.08962187f, 
    0.04362160f, -0.03276712f, 0.02897650f, -0.08284943f, 0.18059675f, 0.10248092f, 0.11084215f, 0.00264142f, 
    -0.02641877f, -0.15855481f, -0.16209301f, 0.06590998f, 0.03049939f, 0.08029356f, -0.03953718f, -0.05249828f, 
    0.11106075f, -0.00427266f, 0.05529970f, 0.08432353f, -0.05110498f, -0.05291464f, -0.11106787f, 0.10996140f, 
    0.01458479f, 0.11385997f, -0.12285625f, 0.07125565f, -0.01221823f, 0.11552468f, -0.11549514f, -0.00164542f, 
    -0.03669246f, 0.08379213f, -0.00227888f, 0.08279932f, -0.04203055f, 0.22739078f, 0.14473972f, 0.05062324f, 
    0.04117664f, 0.01834969f, -0.09186559f, -0.05077330f, 0.06130311f, 0.23007858f, 0.04883137f, -0.09527683f, 
    0.06066953f, -0.18937010f, -0.00708451f, -0.17420456f, 0.15564726f, -0.01277574f, -0.07052996f, -0.01582726f, 
    0.02874396f, -0.30059430f, 0.43421143f, 0.02453318f, 0.07390761f, 0.11473684f, -0.04566102f, 0.15253805f, 
    -0.00417225f, -0.11192491f, -0.04269846f, 0.01013179f, -0.19314322f, -0.49698767f, 0.06895158f, 0.34594515f, 
    0.02742122f, 0.08407567f, 0.02329684f, 0.10783086f, -0.02793774f, -0.07393628f, -0.08879697f, 0.05014053f, 
    0.13609947f, 0.03077286f, 0.08900855f, -0.09581233f, -0.00840236f, -0.05959273f, -0.09626247f, 0.07246420f, 
    0.10616656f, 0.07456750f, -0.03975568f, -0.08388762f, -0.17569095f, 0.09289882f, 0.26711544f, 0.24487309f, 
    -0.00428209f, 0.04628981f, -0.07823791f, -0.05802721f, 0.02621083f, -0.09705891f, -0.13324350f, 0.12694755f, 
    0.04710090f, 0.13421968f, -0.18520294f, 0.16357115f, -0.08435725f, 0.07970718f, -0.06218246f, 0.05496863f, 
    0.09181801f, 0.15757115f, -0.07932245f, -0.00347991f, 0.08862673f, 0.06484097f, -0.04742013f, -0.02328851f, 
    -0.10836095f, 0.13013290f, 0.06022337f, -0.02344584f, 0.07023633f, 0.05200900f, -0.05199105f, -0.13769358f, 
    -0.11680630f, 0.06744964f, 0.06543620f, 0.11129655f, 0.00763666f, -0.02597201f, 0.03231633f, 0.05723104f, 
    0.07882132f, -0.12842801f, 0.08979490f, -0.06547235f, 0.46877277f, 0.20074375f, -0.00904054f, -0.31098804f, 
    0.05655658f, -0.02821883f, 0.28168780f, -0.07275796f, 0.24320403f, 0.05199845f, -0.07743656f, 0.02308763f, 
    0.13606437f, 0.03662139f, -0.66564286f, 0.05012520f, -0.09060842f, 0.04902222f, -0.16582233f, -0.23131618f, 
    -0.01084257f, -0.04983115f, -0.02143895f, 0.08422774f, -0.08012120f, 0.01221108f, 0.08923550f, -0.26174933f, 
    0.09069110f, 0.09278826f, 0.04137852f, 0.10923328f, 0.01298734f, 0.06015698f, -0.12781045f, 0.00701337f, 
    0.30287033f, 0.04424443f, 0.43197700f, 0.21460064f, 0.14395921f, 0.13983575f, 0.01295904f, 0.15514903f, 
    0.05938034f, -0.04811932f, 0.03945032f, -0.02388051f, 0.27187285f, -0.02473297f, 0.20698220f, 0.23045532f, 
    -0.02411707f, -0.07027800f, 0.04927786f, -0.00097629f, 0.17908688f, 0.16818881f, -0.10569463f, -0.07669312f, 
    -0.40986535f, 0.55134934f, -0.00408336f, 0.24785526f, 0.05835204f, -0.02768703f, 0.11154268f, -0.16516635f, 
    -0.00046141f, 0.08538299f, -0.09241441f, 0.20607933f, 0.11221482f, -0.05004172f, -0.04548074f, 0.02187208f, 
    -0.06698529f, 0.01493997f, -0.05641108f, 0.02031776f, 0.14319578f, 0.13473418f, 0.23246661f, -0.00324336f, 
    0.03747161f, -0.04245333f, -0.23854718f, 0.06987982f, 0.17424178f, 0.28262961f, -0.05266479f, -0.02872819f, 
    0.13333802f, 0.06474614f, 0.00979131f, 0.06655344f, 0.31460512f, 0.06975170f, 0.06512757f, 0.07035860f, 
    -0.01726740f, -0.02862639f, -0.05044748f, -0.01227526f, -0.02741558f, 0.11937641f, -0.33854124f, 0.18828949f, 
    -0.19253781f, 0.05014535f, 0.00677567f, -0.13302574f, 0.00130234f, 0.04990605f, -0.03380943f, -0.05171052f, 
    0.06729504f, -0.03614011f, 0.00232923f, 0.04456483f, 0.17776145f, 0.31692716f, 0.28660059f, 0.04362082f, 
    0.10475963f, 0.02074250f, 0.07845356f, -0.08412477f, 0.07607158f, 0.03926626f, 0.01106083f, -0.07966217f, 
    -0.08734579f, -0.17493601f, -0.07501512f, 0.00965377f, 0.02095797f, 0.01851646f, -0.00632670f, 0.18898623f, 
    -0.08334104f, -0.04214673f, -0.10171664f, 0.05653213f, -0.05558572f, -0.02384437f, 0.09200298f, 0.06162451f, 
    0.07804029f, -0.03813147f, -0.05709254f, 0.10641097f, 0.05191021f, -0.00395466f, 0.17415868f, -0.09046557f, 
    -0.03536578f, -0.16878228f, -0.49744895f, -0.20040148f, -0.12668251f, -0.25505954f, -0.04718600f, -0.27327126f, 
    -0.04069720f, -0.10822583f, 0.03436169f, -0.02356608f, 0.13334306f, -0.39219850f, 0.02730058f, -0.43581021f, 
    -0.00278182f, 0.04134306f, -0.02016293f, -0.03260960f, -0.02872344f, -0.03371257f, -0.05819641f, 0.01345021f, 
    -0.05520043f, -0.05098637f, -0.38933006f, -0.22088248f, 0.08193292f, 0.03247050f, 0.01988364f, 0.22655211f, 
    0.15186672f, 0.04722492f, -0.09816920f, -0.04004996f, -0.03167268f, -0.05247293f, 0.02099923f, -0.03233633f, 
    0.03180488f, 0.14050451f, 0.06867033f, 0.01383500f, -0.12036353f, -0.09228136f, 0.19504325f, -0.02263110f, 
    0.20460235f, -0.06994385f, 0.16791523f, -0.06883986f, -0.05196216f, 0.03584768f, -0.02177343f, -0.12151475f, 
    0.03200109f, 0.14503185f, 0.02072898f, 0.14084651f, -0.31492367f, -0.20609403f, -0.25566587f, 0.02884632f, 
    -0.02382775f, 0.06392536f, 0.04657706f, -0.01408056f, 0.05110498f, -0.06423344f, 0.07085035f, -0.04726474f, 
    -0.04423407f, 0.12611060f, -0.02803053f, -0.12212978f, 0.04355929f, 0.04965562f, -0.04387970f, 0.13147312f, 
    0.03187476f, 0.05802143f, -0.09146170f, 0.04305076f, -0.06891551f, -0.04625528f, -0.00864197f, -0.04477255f, 
    0.00108230f, -0.00799513f, -0.00693757f, 0.08151068f, -0.05179499f, -0.00919447f, -0.10487387f, 0.10923383f, 
    -0.07957952f, -0.00572069f, -0.03870332f, 0.01878747f, -0.05069010f, -0.07460304f, 0.04201694f, -0.02268735f, 
    -0.03660681f, -0.00347021f, -0.04513437f, 0.07516842f, -0.12604174f, 0.04376328f, -0.15359157f, -0.09349675f, 
    0.01647081f, 0.06427376f, 0.01053996f, 0.03522300f, 0.03508614f, 0.01416771f, 0.12471055f, 0.05188489f, 
    -0.12172446f, -0.03795958f, -0.09831331f, -0.17975494f, -0.05906925f, -0.21283187f, 0.28101525f, -0.10641025f, 
    -0.08409782f, -0.02739823f, 0.12900653f, 0.07022952f, 0.04375921f, -0.01532925f, -0.06056213f, -0.10070907f, 
    -0.04487841f, 0.00676897f, -0.13035583f, 0.23690198f, 0.19406538f, 0.07209263f, 0.00800974f, 0.04644181f, 
    -0.18610966f, 0.07075362f, -0.34220752f, 0.13854867f, -0.04831805f, -0.04552802f, 0.10165719f, 0.13666961f, 
    -0.03615806f, -0.06817335f, -0.08528975f, -0.01061589f, 0.00125208f, 0.33592010f, -0.21978118f, -0.08148266f, 
    0.04914000f, -0.04679830f, -0.00245058f, 0.00764834f, -0.04452769f, 0.03792614f, 0.11174129f, -0.04062529f, 
    0.07425548f, 0.20300896f, 0.32621795f, 0.02267854f, 0.02633141f, 0.11449778f, 0.14703868f, -0.00293344f, 
    0.10089774f, -0.05790417f, 0.01899844f, 0.05836710f, -0.21465577f, -0.08131731f, -0.08544604f, 0.18290925f, 
    0.12122928f, -0.03638131f, -0.07313329f, 0.23407638f, 0.08054394f, 0.05331777f, 0.09405368f, 0.16946937f, 
    -0.09064305f, -0.08678884f, 0.48057505f, -0.03193887f, -0.01188312f, 0.01147174f, -0.06310279f, 0.02055861f, 
    0.01630294f, -0.07487626f, 0.21306969f, -0.04476244f, -0.10912025f, -0.14770038f, -0.05317332f, 0.06182941f, 
    0.14907518f, 0.03591970f, 0.07011253f, 0.05264425f, -0.03477502f, -0.08123682f, 0.07595639f, 0.04018336f, 
    -0.01587750f, 0.17153654f, -0.03185491f, 0.11299454f, 0.17657930f, 0.02171801f, -0.08129096f, -0.08465333f, 
    0.01674172f, 0.03997374f, 0.01331700f, 0.14567782f, -0.14404497f, -0.17152491f, 0.23677452f, -0.02900207f, 
    -0.03845243f, -0.13440768f, 0.16078618f, 0.13687775f, -0.22826320f, 0.05808751f, 0.09441901f, -0.10397705f, 
    -0.15487386f, 0.02946765f, 0.20049287f, -0.10001300f, 0.02979885f, 0.03897771f, -0.01197122f, 0.14375491f, 
    0.00109445f, -0.15166926f, -0.04924795f, 0.05067011f, -0.10240890f, 0.08282218f, -0.16726540f, 0.16394384f, 
    -0.02499732f, 0.16829196f, -0.07262542f, -0.06627811f, -0.10854400f, 0.06492755f, 0.15748553f, 0.06292073f, 
    0.20295198f, 0.06565045f, -0.29323912f, 0.15651433f, -0.04852134f, 0.10219291f, 0.03606939f, -0.03623957f, 
    -0.04165821f, 0.07575580f, 0.03797486f, 0.08750910f, -0.06265819f, 0.13820896f, -0.06832673f, -0.11270333f, 
    0.02447610f, -0.02201163f, -0.04987407f, -0.14138360f, -0.03832699f, 0.16065830f, 0.00176904f, -0.10189683f, 
    0.28522831f, -0.26610497f, 0.35416231f, -0.40041068f, 0.21105367f, -0.07063638f, -0.11972354f, 0.02516495f, 
    0.00694748f, 0.06551963f, 0.09356244f, -0.13011463f, 0.07033567f, -0.01494155f, -0.02546825f, 0.03321533f, 
    -0.17009225f, 0.01695144f, 0.03346131f, 0.01386059f, -0.20358999f, -0.02086250f, 0.10238051f, -0.12224632f, 
    0.01481947f, 0.12755820f, 0.09603894f, -0.08473913f, 0.12370060f, -0.11855513f, 0.01508369f, -0.03930773f, 
    0.02153396f, -0.10622272f, 0.01977361f, -0.08912777f, -0.32129934f, 0.15636131f, -0.18125333f, 0.06543658f, 
    0.11778028f, -0.08325699f, 0.01831476f, 0.03518268f, -0.23384072f, 0.18028419f, 0.00703730f, 0.00643807f, 
    -0.03845318f, -0.19637205f, 0.08406424f, 0.28891021f, -0.03487359f, 0.07586811f, 0.03371332f, -0.04246540f, 
    0.00157808f, 0.14882879f, -0.06929522f, -0.01297577f, 0.50637937f, -0.23609272f, 0.09166609f, 0.04883025f, 
    0.08250081f, 0.11040331f, -0.05366240f, 0.03307109f, 0.07534619f, 0.15852499f, 0.12507904f, 0.17549580f, 
    0.27911463f, 0.13631806f, 0.01217187f, -0.02192514f, -0.01809557f, -0.01727665f, 0.11982924f, -0.02220729f, 
    -0.05025489f, 0.04441738f, 0.01535837f, -0.06362611f, 0.23075414f, 0.11061201f, -0.00130737f, -0.23327933f, 
    0.11331420f, -0.00239016f, 0.11561326f, 0.00529201f, 0.04432603f, 0.08993044f, 0.08479965f, 0.14768739f, 
    0.56909037f, -0.01833331f, 0.23147543f, 0.03106873f, -0.05548071f, 0.06516589f, 0.10292237f, 0.24055684f, 
    -0.05506604f, -0.03000434f, 0.00716847f, -0.03437272f, -0.13959552f, -0.17911825f, 0.28995594f, 0.16494927f, 
    -0.14938547f, 0.11100587f, 0.13029963f, 0.09087642f, 0.11045069f, 0.14344136f, 0.09958749f, 0.15093040f, 
    0.18075593f, 0.09445329f, 0.05014520f, -0.01775548f, -0.06912497f, -0.01224549f, 0.07127218f, 0.02607210f, 
    0.02294007f, 0.11229129f, 0.01469287f, 0.03759588f, 0.16285489f, 0.07199351f, -0.05729492f, -0.05805566f, 
    -0.09522866f, 0.06161400f, 0.00026657f, -0.15540701f, -0.01232224f, -0.11809069f, -0.22980744f, 0.06005443f, 
    -0.19435441f, -0.15147918f, -0.01215818f, 0.12026738f, 0.04698035f, -0.04523765f, -0.05551473f, -0.05338193f, 
    0.00424684f, 0.07356094f, -0.12688717f, 0.03719265f, 0.12250282f, 0.26852736f, -0.04756239f, 0.05580645f, 
    0.03207444f, -0.11387932f, 0.13128766f, 0.00931752f, 0.09349842f, -0.03692086f, 0.01725958f, -0.12706263f, 
    0.18045564f, 0.03676723f, -0.10311767f, 0.13271864f, -0.12283200f, -0.05936835f, 0.06278154f, 0.00577119f, 
    0.04972768f, 0.04463148f, -0.04316191f, -0.05716358f, -0.05078223f, 0.04200366f, 0.14361346f, -0.00064193f, 
    -0.04220006f, 0.00468261f, -0.04907525f, 0.05282144f, 0.01402045f, 0.16230075f, 0.09865206f, 0.29178089f, 
    0.25078958f, -0.04225308f, -0.05744770f, 0.15277110f, 0.10640350f, 0.05706004f, -0.03450070f, 0.08501886f, 
    0.00557573f, 0.05462028f, 0.07652931f, 0.06193025f, -0.29910505f, 0.13588451f, 0.23090760f, -0.07969529f, 
    0.03494646f, 0.03956080f, -0.01469174f, 0.11196510f, 0.13038802f, -0.07401974f, -0.06351450f, -0.14540690f, 
    0.05775169f, -0.03069646f, -0.09181594f, 0.20098679f, -0.02452370f, 0.00721613f, -0.11863950f, -0.07974100f, 
    -0.07963843f, -0.06469636f, -0.14059803f, -0.25904974f, 0.23605257f, 0.15296796f, 0.28562772f, 0.05349792f, 
    -0.06889720f, 0.16358627f, 0.03023817f, 0.07200272f, 0.00949904f, -0.10157727f, -0.13419993f, 0.14702538f, 
    0.01489599f, 0.19320348f, -0.22701482f, 0.03840510f, 0.00175658f, -0.09074859f, -0.05310233f, 0.12657887f, 
    -0.13846035f, 0.01237346f, -0.04355528f, 0.08241285f, 0.13306005f, -0.06302920f, 0.09580480f, -0.21147001f, 
    0.06540716f, 0.06799519f, -0.10346312f, 0.01168969f, 0.01601334f, -0.00540528f, 0.03516037f, 0.10994613f, 
    0.30783927f, -0.06025096f, -0.18469132f, 0.11518976f, 0.17499293f, 0.03438609f, -0.09802246f, 0.02459197f, 
    -0.14736924f, 0.02446953f, 0.01238657f, -0.02944882f, -0.43609694f, 0.23781997f, 0.28560579f, -0.12726806f, 
    0.02010233f, -0.02621391f, -0.02543584f, -0.11903705f, -0.08237568f, 0.05566005f, -0.04922434f, -0.18446419f, 
    0.05932907f, 0.22813211f, -0.11463905f, -0.05189559f, 0.03127608f, -0.03778890f, -0.12597337f, -0.07706046f, 
    0.01633141f, -0.27322879f, 0.00890176f, -0.02893915f, 0.07693720f, 0.04756841f, 0.00534888f, 0.00879501f, 
    0.06322125f, 0.07376840f, 0.04951322f, 0.15978867f, 0.08377696f, -0.23952886f, -0.03469682f, -0.12200455f, 
    0.19153319f, 0.08064420f, 0.33675790f, 0.48919562f, -0.01893164f, -0.12210240f, -0.07634624f, 0.01426747f, 
    0.18949085f, 0.15823799f, 0.08428838f, 0.30752516f, 0.15700422f, 0.17310067f, 0.12747818f, -0.20825206f, 
    0.10506176f, -0.17123434f, -0.00356553f, 0.00917201f, -0.19366939f, -0.11784029f, -0.07734419f, -0.20834772f, 
    -0.19687535f, 0.07376965f, 0.02815451f, -0.51323956f, 0.20958890f, 0.06848688f, 0.18596335f, 0.14878501f, 
    -0.13347043f, -0.18386292f, -0.31782347f, -0.20450656f, 0.08605751f, -0.19341883f, -0.08342497f, 0.26139486f, 
    -0.01557467f, 0.04801105f, -0.08633366f, -0.16214155f, -0.05260959f, 0.23765190f, 0.16917190f, 0.28655800f, 
    0.16171338f, 0.06972697f, 0.11650829f, 0.14317493f, -0.05903948f, 0.10935052f, -0.07564680f, -0.03495922f, 
    0.05738319f, -0.07896724f, 0.02710377f, 0.19644316f, 0.01752142f, 0.08540278f, 0.06541452f, 0.12640792f, 
    -0.10457315f, 0.01418724f, 0.09364366f, -0.03290712f, 0.02393370f, 0.35196760f, 0.19402598f, 0.07598183f, 
    -0.16998383f, 0.10964706f, 0.39304799f, 0.05623299f, 0.12577453f, -0.18229161f, -0.23342361f, 0.12714200f, 
    -0.09873409f, -0.03020782f, -0.08095556f, -0.14044702f, 0.20710342f, -0.14704981f, -0.05224252f, -0.06565098f, 
    -0.02828487f, 0.01554031f, 0.04750138f, 0.02129187f, 0.04067865f, -0.04511825f, 0.00275590f, 0.13959612f, 
    0.14673087f, 0.28096503f, 0.08639404f, -0.11753711f, -0.05014070f, -0.16922389f, -0.04082581f, 0.06416132f, 
    -0.02175343f, -0.04006885f, -0.11409239f, -0.10941914f, 0.03923051f, -0.26677641f, 0.10878804f, 0.06266858f, 
    0.26518819f, -0.01972162f, -0.01923232f, 0.04788152f, 0.13214748f, 0.21646251f, 0.12786463f, -0.06914760f, 
    -0.07282789f, -0.25597534f, -0.00396571f, 0.20660064f, 0.22608089f, 0.14786680f, 0.02782417f, 0.02529983f, 
    -0.23609866f, 0.05008641f, -0.07052181f, -0.15696365f, 0.02561832f, 0.03278000f, 0.17103195f, 0.15073143f, 
    0.10240856f, 0.02700670f, 0.02208398f, 0.06753567f, 0.07526884f, 0.05865997f, 0.17604920f, 0.33011782f, 
    0.15033267f, 0.14474496f, -0.02185582f, -0.08293203f, -0.10445735f, 0.03713980f, 0.01159556f, -0.15439688f, 
    -0.07969974f, -0.09993928f, -0.10436907f, -0.14488889f, 0.01678584f, 0.12711522f, -0.05635940f, -0.03978356f, 
    0.04147992f, 0.18923481f, -0.01581057f, 0.01122391f, 0.22577970f, 0.09134188f, 0.16694702f, 0.41889405f, 
    0.28773656f, 0.19387303f, 0.04649324f, -0.01990730f, -0.01671016f, 0.05103078f, 0.19906716f, 0.23269697f, 
    0.02851771f, 0.01653100f, -0.03108945f, -0.03646724f, -0.05060143f, 0.04276051f, 0.11822435f, -0.05334781f, 
    0.09740661f, -0.08113313f, 0.00549048f, -0.04706790f, 0.15761898f, 0.17936689f, 0.17699960f, 0.29263246f, 
    0.09523362f, 0.28943512f, -0.18950161f, -0.11956348f, 0.04056994f, 0.03105383f, 0.04579573f, -0.03792705f, 
    0.02525204f, 0.05063230f, -0.00959654f, 0.03536026f, 0.05698678f, 0.02927635f, -0.11361269f, -0.01789574f, 
    -0.01423971f, 0.05658324f, -0.03844791f, -0.00799267f, 0.09898019f, -0.27941135f, -0.23359223f, -0.05688416f, 
    0.35972661f, 0.37598452f, 0.46348855f, 0.10135492f, -0.01821893f, -0.02934690f, -0.01541768f, -0.16385894f, 
    0.00946909f, 0.05171180f, -0.02038647f, 0.22204910f, 0.17506562f, -0.01794747f, 0.15173744f, -0.07898556f, 
    -0.16830312f, -0.06960445f, 0.00402434f, -0.11386890f, 0.10610899f, -0.09140578f, 0.10962440f, -0.14906532f, 
    0.22601223f, 0.22654040f, -0.14962874f, -0.18214267f, -0.15495816f, -0.10212515f, 0.06820414f, 0.07745308f, 
    -0.13162480f, -0.02684648f, 0.03008034f, -0.08248834f, -0.25929052f, -0.09209588f, -0.05773273f, -0.01870929f, 
    -0.02288081f, 0.04125897f, 0.04574893f, -0.20237154f, 0.34658110f, 0.28784052f, 0.27383384f, 0.66843027f, 
    0.16834664f, -0.17925692f, -0.04946909f, 0.23511539f, 0.10328984f, 0.13623013f, 0.15599783f, 0.00121580f, 
    -0.02837895f, -0.14515707f, -0.00812746f, 0.20849389f, -0.34047756f, -0.39943048f, -0.20306258f, -0.14970365f, 
    0.13147059f, 0.06107272f, -0.07311375f, -0.10569257f, 0.03283386f, -0.33998141f, -0.13985355f, -0.11016674f, 
    -0.17999093f, -0.04195097f, 0.00997367f, 0.02805570f, 0.19011761f, 0.09049075f, -0.05375336f, 0.14290152f, 
    -0.19461441f, -0.17473161f, -0.08585811f, -0.46608755f, -0.00445923f, 0.20807987f, -0.01555723f, -0.05712453f, 
    0.02190365f, 0.00831849f, 0.08942838f, -0.11992984f, -0.11525576f, -0.23516572f, -0.15403257f, -0.00228861f, 
    0.13253289f, -0.00128756f, 0.24581622f, -0.02451310f, 0.18375894f, -0.07315776f, -0.16976407f, -0.10153575f, 
    -0.12650554f, -0.04647500f, -0.08689055f, -0.02380119f, 0.02587994f, -0.13010271f, 0.27463943f, 0.05524018f, 
    0.23693587f, 0.11842566f, -0.03905789f, -0.02626998f, -0.09582735f, -0.26462081f, -0.02335582f, 0.34287083f, 
    0.37784716f, 0.14498888f, 0.09397473f, 0.20827822f, 0.01634599f, -0.02126013f, -0.05299171f, -0.15830009f, 
    -0.00025088f, 0.00054074f, 0.02818898f, 0.08843572f, -0.27335382f, 0.28995219f, 0.29815099f, 0.28672549f, 
    0.22805996f, 0.03747562f, -0.11861801f, -0.05238633f, -0.17421472f, -0.00053961f, -0.12995879f, -0.09903801f, 
    0.23236953f, 0.16211990f, -0.01678246f, 0.00512474f, -0.25407833f, -0.09707927f, 0.01704727f, -0.13842186f, 
    0.13406080f, -0.26243255f, 0.04268901f, -0.06284184f, -0.11384858f, -0.12713009f, -0.21996067f, -0.00785321f, 
    0.14139283f, 0.10388365f, -0.13763899f, 0.11823081f, -0.10456830f, -0.52402270f, -0.33956566f, -0.33741015f, 
    0.32019693f, -0.24513479f, 0.02190450f, 0.08415148f, -0.06857616f, -0.04910308f, -0.15860307f, -0.04175644f, 
    0.09127092f, 0.03907057f, -0.10615621f, 0.10634280f, 0.29066303f, -0.18515976f, 0.34444594f, -0.29822835f, 
    0.05063762f, 0.13747279f, -0.00989627f, 0.05122757f, -0.10458822f, 0.01672366f, -0.01165703f, 0.13005543f, 
    0.44157857f, -0.16422750f, 0.27059636f, -0.46655908f, -0.12280086f, -0.01041181f, -0.08145212f, 0.16624697f, 
    -0.05115417f, -0.02914125f, 0.11134692f, -0.10958368f, -0.02625442f, -0.27950096f, -0.01131914f, 0.28298604f, 
    -0.01066050f, -0.01257042f, -0.02009157f, 0.01039205f, 0.09297455f, -0.04330002f, -0.04397067f, -0.16306478f, 
    0.03912906f, 0.24493204f, 0.10356022f, 0.05357135f, 0.05647805f, -0.01959253f, 0.01025049f, 0.15766133f, 
    0.09379981f, -0.07535852f, 0.00971410f, -0.20780040f, 0.01171265f, 0.01706192f, 0.19499801f, 0.11015581f, 
    -0.01067831f, 0.10307296f, -0.01739972f, -0.17917618f, 0.06152698f, -0.12980801f, -0.14539777f, -0.16263625f, 
    -0.49214253f, -0.05317989f, 0.30182603f, -0.45820567f, -0.14839585f, -0.04862694f, 0.10404483f, -0.16849533f, 
    -0.00197477f, -0.05576555f, -0.04440710f, 0.03991952f, 0.03426097f, -0.02353560f, 0.09543995f, -0.03366286f, 
    -0.00857225f, 0.08084187f, -0.00089513f, 0.01412670f, 0.05232494f, 0.12185983f, -0.13182850f, -0.03296867f, 
    0.05460360f, 0.06213429f, 0.11508418f, -0.22183120f, -0.08930375f, 0.13042547f, -0.01343148f, -0.07549229f, 
    -0.01944256f, 0.05976353f, 0.02931221f, 0.03163771f, 0.29665768f, -0.22807220f, 0.17308369f, 0.25566208f, 
    -0.05929567f, 0.01227496f, -0.01218938f, -0.06997589f, 0.02918893f, 0.00629867f, 0.13450746f, 0.05400386f, 
    0.16721472f, 0.05816432f, 0.25118214f, 0.28528687f, -0.00326562f, 0.06934377f, -0.04825904f, -0.01241723f, 
    0.09120321f, -0.08449667f, 0.05824564f, -0.03804124f, -0.18639179f, 0.01384066f, 0.03796608f, -0.03225089f, 
    0.01766952f, -0.21402723f, -0.07847081f, -0.03928793f, 0.02080505f, -0.02881815f, -0.12122266f, -0.04804858f, 
    -0.07118010f, 0.10465651f, 0.34272811f, 0.25602537f, -0.04569261f, 0.05006992f, 0.11004416f, 0.16457836f, 
    0.03136045f, 0.03685138f, 0.14906354f, 0.10722470f, 0.02189876f, 0.13542555f, 0.03274780f, 0.03617152f, 
    0.03355387f, -0.18551767f, 0.05390658f, -0.09810352f, 0.02208042f, 0.12095927f, -0.02202379f, 0.04034510f, 
    0.04832651f, 0.24241814f, 0.02180313f, -0.10884900f, -0.17983003f, 0.02424548f, -0.07813324f, 0.23684010f, 
    -0.15239213f, 0.01445225f, 0.00387761f, -0.01901960f, 0.11615764f, 0.30906579f, 0.00515526f, 0.02033652f, 
    0.01862573f, -0.07123266f, 0.02717861f, 0.11361624f, -0.02997701f, 0.00063068f, -0.16499867f, -0.21048471f, 
    -0.16154343f, 0.08936040f, 0.24083014f, 0.31590995f, -0.06472138f, 0.02331095f, 0.06964099f, 0.03882806f, 
    0.12954076f, -0.05712127f, 0.06560817f, 0.05341816f, 0.21313684f, 0.24197939f, -0.05734888f, -0.08579796f, 
    -0.05247679f, -0.11129009f, 0.16520803f, -0.03219863f, -0.00875857f, 0.01509997f, -0.15967941f, 0.02519087f, 
    0.14267313f, -0.23357162f, 0.09368454f, -0.21563309f, -0.08751541f, -0.14505556f, -0.16434892f, -0.06915092f, 
    0.01163398f, -0.02609423f, -0.02227115f, -0.09458046f, -0.04793712f, 0.40574870f, 0.22319804f, 0.26968926f, 
    -0.00300515f, -0.27265745f, 0.07522704f, 0.07188607f, 0.03786163f, 0.05731029f, -0.08121344f, 0.03425973f, 
    0.06751604f, 0.07211278f, 0.11718629f, 0.06174078f, 0.01950418f, 0.24503128f, 0.09468967f, 0.09501987f, 
    0.13085397f, -0.03557235f, 0.03408306f, 0.06252051f, 0.07631499f, 0.08443250f, -0.10762511f, 0.02528066f, 
    0.10569925f, -0.04919462f, 0.05420027f, -0.01192885f, -0.06357801f, -0.20187707f, 0.05897418f, 0.11490778f, 
    0.43751016f, 0.12885000f, 0.10857253f, 0.18579546f, -0.03934792f, 0.02057693f, -0.02639351f, 0.01385514f, 
    0.09510548f, -0.00534565f, 0.07945492f, 0.04439612f, 0.02321133f, -0.10598042f, -0.06632577f, 0.18556368f, 
    -0.02352992f, 0.04213275f, 0.13702363f, 0.13036464f, 0.08479916f, 0.10024807f, -0.05203183f, 0.07616012f, 
    -0.08503339f, 0.06943567f, 0.06587262f, 0.04417618f, 0.13135940f, 0.14427668f, 0.10906572f, -0.01421144f, 
    -0.04798944f, -0.03977526f, -0.05004830f, 0.08273911f, -0.16519217f, 0.18767723f, 0.07324161f, -0.27372202f, 
    0.01155201f, -0.05084360f, 0.29403916f, 0.03140543f, -0.08938434f, -0.11589593f, 0.11819190f, 0.00009860f, 
    0.09031194f, -0.38302451f, 0.25569573f, -0.26061893f, -0.01485246f, -0.00391394f, -0.02115486f, -0.04905024f, 
    -0.02844693f, -0.08972052f, 0.07992663f, -0.01970020f, 0.29301596f, -0.14231005f, 0.11669162f, -0.16206715f, 
    -0.00684182f, 0.01565047f, 0.04973726f, 0.04646006f, 0.03111526f, 0.00278033f, 0.02911764f, 0.05040387f, 
    0.33465651f, -0.11704529f, 0.06588358f, -0.15653473f, -0.14432780f, -0.10220097f, -0.22072877f, 0.15121107f, 
    0.13877523f, -0.06613848f, -0.11225283f, -0.17164990f, 0.03427245f, 0.10764813f, -0.21737729f, 0.43208930f, 
    -0.06648448f, 0.04185721f, -0.00954021f, -0.12665726f, 0.05949815f, -0.04652914f, -0.16254148f, 0.12264823f, 
    0.55710322f, 0.16174033f, -0.30298856f, -0.05360374f, -0.13425758f, 0.04318203f, 0.06572506f, -0.04227146f, 
    0.06368904f, 0.15328772f, 0.01308234f, -0.09198815f, 0.06090055f, 0.08770983f, 0.04506577f, -0.02322498f, 
    0.02770287f, 0.02341715f, 0.11115112f, 0.12209371f, -0.05965990f, 0.02074865f, -0.02465019f, -0.01953952f, 
    0.52419794f, -0.06824542f, 0.10197472f, 0.03579292f, -0.09449100f, -0.16759920f, 0.08751547f, 0.17215016f, 
    0.06676458f, 0.09343968f, 0.05577816f, 0.04182777f, -0.35948530f, 0.27081186f, -0.33455956f, -0.25753060f, 
    0.11101982f, -0.04108500f, -0.06623518f, 0.03787959f, -0.04180728f, 0.15498306f, -0.10466108f, -0.01455390f, 
    -0.26071215f, 0.16538805f, -0.31857941f, -0.07894545f, 0.35570771f, -0.16718002f, 0.08918111f, 0.05826271f, 
    -0.02721289f, 0.14115368f, -0.21621877f, -0.23457655f, 0.20920558f, 0.15861101f, 0.23643492f, 0.19406508f, 
    -0.06584516f, 0.01629537f, -0.06062661f, 0.12578070f, 0.09825566f, 0.00959370f, 0.04227414f, 0.16972521f, 
    -0.20999935f, -0.16013050f, 0.23200466f, 0.02248852f, -0.01036261f, 0.00575624f, -0.08439528f, 0.03159849f, 
    0.13602500f, -0.12003410f, 0.02349047f, 0.15024517f, 0.19254650f, -0.10174020f, 0.03886746f, -0.00803699f, 
    -0.06632044f, -0.08376475f, -0.01091100f, -0.04583472f, -0.01887365f, 0.31384265f, 0.02773039f, 0.12109388f, 
    0.18883654f, 0.34118921f, -0.45007744f, 0.30477273f, -0.13448289f, 0.00677168f, 0.15478638f, -0.24549940f, 
    -0.00502387f, 0.08215382f, -0.20804141f, 0.03261415f, -0.24902530f, -0.25126368f, 0.09793188f, -0.32519239f, 
    -0.04172784f, 0.06033984f, -0.29256260f, -0.01399765f, 0.14873219f, -0.01901162f, 0.06617732f, 0.29510838f, 
    -0.00405071f, -0.07275970f, -0.16483808f, -0.05180090f, -0.11648221f, 0.07889277f, -0.02512912f, 0.01445228f, 
    -0.09148833f, 0.06193350f, 0.00172477f, -0.05719194f, 0.26512367f, -0.08830051f, 0.19050331f, -0.19795388f, 
    -0.04340178f, 0.08282375f, -0.11655130f, -0.09664071f, 0.24694017f, 0.01621448f, 0.10504524f, -0.25178665f, 
    0.04567124f, 0.05737749f, 0.15919590f, -0.21134894f, 0.10482472f, -0.07447001f, -0.08013825f, 0.11086595f, 
    -0.14928113f, -0.11844549f, 0.14726019f, -0.13028675f, -0.07384042f, 0.17066154f, 0.07180569f, 0.08665098f, 
    -0.01068090f, -0.10273994f, 0.04351586f, 0.04918405f, 0.12116916f, -0.03652159f, 0.16315837f, 0.31021038f, 
    0.17584987f, 0.01891646f, 0.11729614f, 0.04568779f, 0.11235560f, 0.18138126f, 0.06201269f, 0.01968416f, 
    0.05574739f, -0.14936635f, -0.07920814f, -0.10544686f, -0.00824010f, -0.02885353f, 0.16957991f, 0.25526881f, 
    0.04492778f, 0.21541876f, 0.04752973f, 0.00074335f, 0.08040313f, 0.04421115f, 0.05308847f, 0.13067025f, 
    -0.75560260f, 0.33878005f, -0.06149442f, 0.24214992f, 0.16693299f, -0.06304038f, -0.03978144f, 0.06440023f, 
    0.11591597f, -0.00894243f, 0.00557717f, -0.08108266f, -0.01747579f, 0.42781565f, -0.00724953f, 0.16635734f, 
    0.21636508f, 0.16290723f, -0.13371339f, -0.04962206f, 0.09789786f, -0.00488407f, -0.01214765f, 0.08067869f, 
    0.12603058f, 0.27398512f, 0.07096194f, 0.19893162f, 0.18231665f, 0.09583371f, -0.00388671f, 0.06379219f, 
    -0.01267181f, 0.01836961f, -0.02148987f, 0.03935489f, 0.09873004f, -0.09995387f, -0.04285834f, -0.19560724f, 
    0.02310101f, 0.03339823f, -0.11267715f, 0.03521318f, 0.06059685f, -0.15591137f, 0.17119391f, -0.04971014f, 
    0.33219573f, -0.07411621f, 0.29831597f, 0.04424864f, 0.07066768f, 0.01659809f, 0.10074620f, -0.09150752f, 
    0.15443860f, 0.03501037f, 0.05933733f, 0.18661627f, 0.14505318f, -0.23226900f, 0.03980843f, -0.09547997f, 
    0.05439098f, 0.13252375f, -0.09613807f, 0.06865727f, 0.03422627f, -0.03924942f, 0.06334107f, 0.21364108f, 
    -0.05550534f, 0.11637095f, 0.23883371f, -0.13018154f, 0.04631687f, 0.05073841f, -0.03068243f, 0.28151700f, 
    -0.06147008f, -0.06104034f, 0.05512151f, 0.03837431f, -0.19345030f, -0.11120934f, -0.16625044f, 0.11698531f, 
    0.10232900f, 0.05846263f, 0.07110516f, -0.13837154f, 0.41754568f, 0.03254662f, 0.18843381f, 0.28179374f, 
    -0.16865858f, -0.14631559f, -0.05573877f, -0.00215479f, 0.09621044f, -0.05596060f, -0.12073760f, -0.09295543f, 
    0.12936018f, -0.33556920f, -0.00912526f, 0.05860885f, 0.34615403f, -0.18647972f, -0.29143494f, 0.11509661f, 
    0.04143412f, -0.02651566f, -0.08206988f, -0.11462484f, -0.12492651f, -0.00996694f, -0.12645257f, 0.07534678f, 
    -0.24618267f, 0.08163307f, 0.28643993f, 0.10356656f, 0.09388362f, 0.05539041f, 0.08885612f, 0.20510565f, 
    -0.12476142f, -0.19548504f, 0.04572694f, -0.23301509f, -0.12229119f, 0.11732388f, -0.36431742f, 0.22372283f, 
    0.08612153f, -0.00346015f, -0.03391793f, -0.25602543f, 0.11445221f, -0.19001773f, -0.01264469f, -0.36601758f, 
    0.37622172f, -0.05551438f, 0.56331980f, -0.24344622f, -0.02932353f, -0.12443372f, 0.02253313f, 0.03743890f, 
    0.00670412f, -0.04449573f, 0.09502917f, -0.06331877f, -0.06508761f, -0.07355847f, -0.12366582f, 0.24920063f, 
    0.03010200f, -0.21390073f, 0.13332477f, -0.10622416f, 0.01344109f, -0.12394232f, -0.07520536f, -0.01672829f, 
    0.01240322f, -0.02941407f, 0.17182121f, 0.01935690f, 0.11025768f, -0.02009073f, 0.14598618f, 0.11279779f, 
    0.17020518f, 0.04366425f, -0.07760733f, 0.05747028f, 0.39177448f, 0.15699832f, 0.05102470f, 0.03546207f, 
    0.05300680f, 0.11990634f, -0.12673710f, 0.23182081f, -0.02211362f, -0.02170782f, -0.25724378f, -0.21383488f, 
    0.45854375f, -0.26839837f, 0.20456113f, -0.04969512f, -0.14833744f, -0.02470389f, -0.02856621f, 0.00116795f, 
    0.13655183f, 0.02541618f, -0.12065364f, 0.01112483f, 0.06157976f, -0.00316750f, -0.22786726f, -0.05981783f, 
    0.04252249f, 0.08904439f, 0.18194498f, -0.06557012f, -0.14484233f, -0.10441094f, -0.54416013f, -0.30082732f, 
    0.15459538f, 0.02469192f, 0.03223760f, -0.06991248f, -0.00717617f, 0.01625973f, 0.03756221f, 0.06284334f, 
    0.05589030f, 0.24167432f, -0.01653430f, 0.08813696f, -0.46435311f, 0.19713886f, -0.16713588f, 0.04863198f, 
    -0.05940669f, -0.21413116f, -0.12430757f, -0.04699265f, -0.22389001f, 0.20547651f, -0.09043834f, -0.08609798f, 
    -0.19703211f, 0.24351038f, 0.28693363f, 0.09535240f, 0.38630140f, -0.19760963f, 0.17481941f, 0.23118424f, 
    -0.16730824f, 0.09329543f, -0.17354000f, -0.18194127f, -0.05539316f, 0.07539950f, 0.20432240f, 0.47660366f, 
    -0.10176777f, 0.02075866f, -0.08005209f, -0.02962419f, 0.07910431f, 0.00989494f, 0.04662931f, 0.14107180f, 
    -0.26416820f, -0.04318578f, -0.06232311f, -0.00913972f, 0.03676786f, -0.04345686f, -0.06696647f, 0.02503441f, 
    0.02987477f, -0.01269348f, -0.06806896f, 0.21569249f, 0.07305835f, -0.08456911f, -0.07471400f, -0.18582577f, 
    0.02904779f, -0.10787585f, 0.02621489f, -0.00787289f, -0.07022066f, 0.19999568f, 0.00300070f, 0.15288042f, 
    0.57720029f, 0.01977651f, -0.22946155f, 0.09329475f, 0.04035894f, 0.01991653f, -0.11401673f, 0.10067144f, 
    -0.06159506f, -0.01461975f, 0.09457810f, -0.15310624f, -0.19190834f, -0.12175467f, 0.07484954f, -0.19608144f, 
    -0.02294862f, 0.14237234f, -0.08837447f, -0.07914479f, 0.05046166f, -0.06558180f, 0.00785044f, 0.16760151f, 
    -0.13276123f, 0.07536463f, -0.02988877f, -0.05660165f, -0.05383943f, -0.16055964f, 0.02300585f, 0.01257066f, 
    -0.13421382f, 0.05411042f, -0.08818933f, -0.16136967f, -0.07456868f, 0.05102317f, -0.06905756f, -0.16867122f, 
    0.07697760f, 0.04141080f, -0.12096774f, -0.12800942f, -0.02661411f, -0.14441079f, 0.17663383f, -0.02904486f, 
    0.05015673f, 0.02989901f, 0.07649859f, -0.12220553f, 0.07820747f, -0.03956401f, 0.06481159f, 0.04972538f, 
    -0.09177168f, -0.00271955f, 0.00510508f, -0.13450247f, 0.06561957f, -0.16782121f, -0.03156216f, 0.09768834f, 
    -0.01526103f, -0.03568076f, 0.11965920f, 0.19584258f, 0.08785667f, -0.00133320f, 0.25419322f, 0.31184396f, 
    0.02657585f, -0.07249802f, 0.05111759f, 0.18649450f, 0.15927438f, -0.02610658f, 0.03284479f, -0.09665071f, 
    0.02306193f, -0.02038878f, -0.07075097f, -0.02533409f, 0.09747697f, -0.04554612f, 0.04584544f, 0.18265444f, 
    -0.03842343f, 0.06937391f, 0.12645623f, 0.08920656f, 0.10690047f, 0.02699521f, -0.06362035f, 0.21796650f, 
    -0.21516982f, 0.24717551f, 0.36384216f, 0.50782210f, 0.12579380f, 0.14296879f, 0.04469583f, 0.12710179f, 
    -0.02565035f, -0.05321468f, 0.03258336f, -0.05621683f, 0.02345750f, 0.39639500f, 0.08514860f, 0.63427877f, 
    0.08505195f, 0.13706799f, -0.05171106f, 0.07403032f, 0.11851096f, -0.03098144f, 0.08631276f, 0.02444389f, 
    0.04534513f, 0.12164408f, 0.32521701f, 0.42467767f, 0.03033528f, -0.05399732f, 0.07164825f, -0.04174392f, 
    -0.00377114f, 0.00002557f, 0.04215742f, 0.05184344f, 0.15622024f, 0.06093082f, -0.08551326f, -0.05100099f, 
    -0.00460560f, -0.02068561f, -0.21266890f, -0.18463349f, 0.00171615f, -0.12875527f, 0.13605677f, -0.15895861f, 
    -0.15213732f, 0.06418113f, 0.21296893f, 0.02900044f, 0.07885764f, -0.05149851f, 0.26565260f, -0.08957661f, 
    0.07325963f, 0.02131081f, -0.04363361f, 0.06514820f, 0.01189939f, -0.19998915f, 0.14946410f, 0.08269633f, 
    0.09137108f, 0.13049631f, -0.12529045f, 0.07498521f, 0.01393910f, 0.01547209f, 0.09360747f, 0.09021790f, 
    -0.09713591f, -0.11831232f, 0.18343386f, 0.37599364f, 0.01699853f, -0.03720601f, 0.00729750f, 0.06921107f, 
    -0.09582237f, -0.02198616f, -0.06672729f, -0.02517648f, 0.04058986f, -0.07189731f, -0.08681490f, 0.03239566f, 
    -0.01826700f, 0.03218459f, 0.06566636f, 0.00056927f, 0.41413459f, 0.14054686f, 0.20640543f, 0.11695002f, 
    -0.03389753f, -0.14769232f, -0.11382435f, -0.16517009f, 0.17462257f, 0.05724828f, -0.07856335f, 0.00537453f, 
    -0.06662690f, -0.12387249f, -0.11603239f, -0.09599778f, 0.20609680f, -0.07097168f, 0.05461968f, 0.15233420f, 
    -0.02750772f, 0.12075102f, -0.28446841f, -0.12554024f, -0.12986155f, -0.09458636f, -0.21715811f, -0.16359331f, 
    -0.01037850f, 0.03213130f, 0.24444368f, 0.23543695f, 0.10543483f, 0.08696343f, -0.12941976f, 0.16991293f, 
    -0.28271493f, -0.02467574f, -0.10105101f, -0.21807382f, -0.05042677f, 0.13833939f, -0.06407256f, 0.28653547f, 
    -0.00060983f, -0.12540466f, 0.06147078f, -0.28061202f, -0.07911442f, 0.00465822f, -0.13026525f, -0.35725930f, 
    0.07593331f, 0.04355963f, 0.48487511f, 0.08792478f, -0.02715418f, -0.08868902f, 0.06339158f, 0.09281469f, 
    -0.02371757f, 0.05460913f, 0.02440146f, 0.09869840f, 0.01654040f, -0.08378599f, 0.00695800f, 0.20952517f, 
    0.04028015f, 0.02117129f, -0.04733879f, -0.08699046f, -0.03833013f, -0.11029272f, -0.15959580f, 0.04409673f, 
    -0.12617503f, 0.00905133f, 0.05724476f, 0.07110664f, 0.10790684f, -0.07542547f, 0.03726808f, 0.14533833f, 
    0.02313020f, 0.05175250f, -0.06013447f, 0.05874841f, 0.15886454f, 0.00049678f, 0.06219945f, -0.30957210f, 
    -0.03752518f, 0.13330679f, -0.11134485f, -0.01121866f, 0.03177218f, -0.10357478f, -0.19023046f, -0.28212494f, 
    0.12322816f, -0.11606333f, -0.07512482f, 0.03602190f, 0.04479508f, 0.07145415f, -0.05706139f, -0.00658691f, 
    0.01495344f, -0.02813420f, -0.24285543f, -0.09959410f, -0.06502226f, 0.05761255f, 0.02218291f, -0.12695371f, 
    0.09774765f, -0.02931497f, -0.03568585f, 0.00299109f, -0.13602668f, -0.19695622f, -0.40289778f, -0.42560700f, 
    0.03399033f, 0.01880930f, -0.05077100f, 0.03244525f, -0.05163083f, 0.02692828f, -0.03670616f, -0.03016905f, 
    -0.04992002f, 0.04686671f, 0.03676449f, -0.04174158f, 0.01713371f, 0.00049700f, 0.02395910f, 0.03600854f, 
    -0.03047683f, -0.02836973f, -0.03206525f, 0.01975538f, 0.03055088f, 0.00597918f, -0.04398436f, 0.03071937f, 
    -0.01829353f, -0.04775755f, -0.02093627f, -0.03925529f, 0.00302014f, -0.01869266f, 0.03400676f, 0.02907928f, 
    0.02147132f, -0.04267301f, 0.00713492f, -0.00584732f, -0.06291210f, -0.04458271f, -0.02468938f, -0.01516525f, 
    -0.03453542f, -0.02891531f, 0.04072325f, 0.04123372f, -0.00360592f, -0.05518089f, 0.02654804f, -0.02145629f, 
    0.01142323f, 0.03923951f, -0.00728939f, 0.00249426f, 0.00251293f, -0.05262053f, 0.02843715f, -0.01267094f, 
    -0.02536282f, -0.02370172f, -0.03341145f, 0.03968624f, -0.02341015f, 0.04877051f, 0.01419456f, 0.04284368f, 
    -0.01628200f, -0.03337844f, -0.00844233f, 0.02746168f, -0.04530074f, -0.02742852f, 0.03296317f, -0.03411181f, 
    0.05465018f, -0.00895565f, 0.00919192f, -0.04230218f, -0.01065986f, -0.00891464f, 0.02976342f, 0.02258492f, 
    0.03815781f, 0.01113924f, -0.04426994f, -0.03849899f, -0.03601188f, 0.02177442f, -0.00418610f, 0.01385425f, 
    0.03719410f, 0.04114750f, -0.03047125f, -0.04327428f, -0.00793654f, -0.04110115f, -0.00246931f, 0.01519359f, 
    0.00396696f, 0.00316520f, 0.03390947f, -0.04859100f, -0.05133772f, 0.02718860f, -0.01707312f, -0.01926081f, 
    -0.01115696f, 0.01889896f, 0.01339895f, -0.02323401f, -0.03923170f, -0.03713562f, 0.05285817f, -0.00860606f, 
    -0.03088491f, 0.01059441f, -0.00319852f, -0.01248466f, 0.02858110f, -0.02106085f, 0.04941880f, -0.03950482f, 
    0.00453081f, 0.02653209f, 0.03323299f, 0.02196545f, 0.02819145f, -0.01608407f, -0.00169906f, -0.04109278f, 
    -0.03146769f, 0.02358749f, -0.00591261f, 0.03914719f, -0.00042534f, -0.02891064f, -0.05752521f, 0.00246001f, 
    -0.01985393f, -0.00403162f, -0.05229961f, 0.00901168f, -0.03394184f, 0.00919910f, -0.04519119f, 0.02923368f, 
    0.02442129f, 0.03004845f, -0.03404708f, -0.00257095f, -0.00053688f, 0.03957823f, 0.04354831f, 0.01384171f, 
    -0.01420869f, 0.02509109f, 0.04521904f, -0.05330794f, 0.03503935f, -0.05894505f, 0.02955857f, -0.01857650f, 
    -0.04445088f, -0.03252870f, -0.04420636f, -0.05597298f, 0.03067411f, 0.01023792f, 0.03451522f, -0.05014727f, 
    -0.02528631f, -0.01033906f, 0.03565650f, 0.02190680f, 0.04593508f, 0.01394913f, -0.04149546f, -0.00834430f, 
    -0.05191604f, -0.04776602f, 0.01124778f, 0.02824214f, -0.05742220f, 0.03738948f, 0.03010701f, -0.03553680f, 
    -0.03606815f, 0.02581881f, 0.03603578f, 0.03078775f, -0.03904378f, -0.05538756f, -0.04944251f, -0.02013744f, 
    0.01082862f, -0.05877319f, -0.02058371f, -0.02619189f, 0.00403251f, 0.00024507f, -0.00287000f, 0.01623202f, 
    -0.00819036f, 0.04570556f, -0.01849165f, -0.01378172f, -0.02227863f, 0.01134862f, 0.04086744f, 0.00356327f, 
    0.01403291f, -0.02552256f, -0.04302398f, -0.03564915f, -0.03669804f, 0.02826841f, -0.02278526f, -0.04241788f, 
    -0.01309006f, 0.03598954f, 0.05279825f, -0.02806105f, 0.03780222f, -0.04571483f, 0.03044149f, 0.02871289f, 
    0.00419388f, 0.01506428f, 0.04485757f, -0.04738581f, 0.02641362f, 0.00634718f, 0.02027477f, 0.01521069f, 
    -0.04213209f, -0.01921747f, 0.02492369f, 0.00871200f, 0.01433514f, -0.02215329f, 0.00161084f, -0.01240227f, 
    -0.04750911f, 0.00712090f, -0.03241335f, 0.03330668f, 0.04391222f, 0.02020469f, -0.01598677f, 0.01650642f, 
    -0.01185628f, -0.00001773f, 0.04250110f, -0.04184268f, -0.01649512f, -0.05326696f, -0.02916669f, -0.03543413f, 
    -0.03863798f, -0.02822798f, -0.02242748f, -0.05126082f, -0.04304677f, 0.03607958f, -0.00522266f, 0.00789397f, 
    -0.00912618f, -0.05722339f, 0.02650261f, -0.04053149f, -0.01305035f, -0.04856902f, -0.02106630f, 0.00305982f, 
    -0.01846073f, -0.02736581f, -0.03902594f, -0.04495739f, -0.03362929f, 0.00550978f, -0.04569697f, -0.05500796f, 
    -0.05281210f, 0.00930826f, 0.00477746f, -0.01703512f, 0.01459954f, -0.03500601f, -0.00711936f, -0.00730244f, 
    -0.04765655f, -0.05819071f, 0.00422619f, -0.02681752f, 0.00874691f, -0.00528591f, -0.00402984f, 0.01708334f, 
    -0.00608311f, 0.02882880f, -0.05845733f, 0.01837008f, 0.00085282f, -0.01258947f, -0.05681802f, -0.05463674f, 
    0.03052386f, 0.01488898f, -0.01640631f, -0.02327081f, 0.01699677f, -0.02396687f, -0.01168649f, -0.05444303f, 
    0.01626620f, 0.01246939f, -0.00319949f, -0.03851768f, -0.00450217f, 0.04681580f, 0.04293124f, 0.01842774f, 
    -0.04841197f, 0.02020890f, -0.00946419f, 0.01935782f, 0.01897313f, 0.00994656f, -0.04475987f, -0.01358140f, 
    0.01506257f, -0.00247617f, -0.01875715f, -0.01532521f, -0.03699871f, -0.01758930f, -0.01524281f, -0.00181167f, 
    -0.00385107f, -0.00869112f, 0.02631173f, -0.01275751f, -0.05613386f, -0.05677003f, -0.03569856f, -0.01755279f, 
    -0.03368196f, 0.03425854f, -0.02661655f, -0.01209973f, 0.03143679f, 0.02007461f, 0.02966273f, 0.01301455f, 
    0.00872976f, 0.00210848f, 0.02105573f, 0.02646887f, -0.00080285f, -0.02545972f, -0.01549577f, 0.02300206f, 
    -0.00678776f, -0.03558619f, -0.02122199f, 0.01401266f, 0.03048853f, 0.01783378f, -0.04253783f, 0.03074965f, 
    0.01780363f, -0.01995402f, -0.02514555f, 0.02986341f, 0.02868354f, -0.00200261f, -0.01322286f, 0.02919035f, 
    0.00859563f, -0.00831232f, 0.04205237f, 0.00151896f, -0.00503410f, 0.00941754f, 0.01792982f, 0.00257855f, 
    -0.15634154f, 0.31449383f, -0.08180314f, -0.37006480f, -0.01029305f, 0.13778831f, -0.00917588f, -0.05240731f, 
    0.00719640f, 0.02899832f, 0.15926453f, -0.13647798f, -0.32622826f, 0.14451197f, 0.22452380f, 0.33436781f, 
    -0.15663059f, 0.00612153f, 0.11905988f, 0.05101714f, 0.00952586f, 0.10384118f, 0.05397597f, -0.02529923f, 
    -0.30742681f, 0.28241226f, 0.30857646f, 0.32761627f, -0.06602305f, 0.09654897f, 0.02615359f, -0.09257974f, 
    -0.00768610f, 0.05195658f, 0.04677743f, 0.05608664f, 0.08769296f, 0.02731401f, -0.12933588f, -0.14338629f, 
    0.03048240f, 0.10801646f, 0.09280173f, 0.04517345f, 0.00784852f, 0.09252699f, 0.09647100f, 0.08221231f, 
    -0.24564935f, -0.25995770f, -0.24341488f, 0.13259596f, -0.13509990f, -0.01584879f, 0.13109131f, 0.04574525f, 
    -0.05130386f, 0.09736144f, -0.05857930f, 0.12995225f, 0.04423956f, 0.32666215f, 0.00024456f, -0.28047365f, 
    0.00673141f, -0.07290474f, -0.17846352f, -0.01414149f, 0.16978495f, 0.20641550f, 0.14637241f, 0.09978244f, 
    0.91915298f, 0.17672409f, -0.15712194f, 0.17179598f, -0.12329357f, -0.06390546f, 0.11545957f, 0.18791364f, 
    0.08591367f, 0.08702996f, 0.11873182f, -0.11026711f, -0.08894628f, 0.08467900f, 0.10155376f, 0.07575978f, 
    -0.01621749f, -0.04703638f, 0.08224929f, 0.04301189f, 0.06784938f, -0.00734866f, 0.06850227f, 0.01059925f, 
    -0.07827552f, 0.00230314f, 0.12502602f, 0.24418885f, 0.22437340f, 0.00582484f, 0.20060754f, 0.10782216f, 
    0.12541188f, -0.00920417f, 0.16909626f, -0.04922521f, -0.36109492f, 0.51029289f, -0.09148586f, -0.10933118f, 
    0.00020179f, 0.00598781f, -0.04628011f, -0.08758242f, -0.12589356f, -0.01833539f, 0.12077289f, 0.22738302f, 
    0.04590059f, 0.18089542f, -0.02964868f, -0.23789577f, -0.11554291f, -0.08939810f, -0.02020429f, 0.00134846f, 
    0.00759096f, 0.13443351f, -0.03227502f, -0.01144277f, 0.19750933f, -0.28700146f, -0.11338880f, 0.08095469f, 
    0.08213346f, 0.03193934f, 0.05405298f, 0.13405898f, -0.09137724f, 0.03770239f, -0.02527589f, -0.07969294f, 
    -0.17516614f, -0.26432782f, -0.21160863f, 0.09885595f, -0.02008350f, -0.08998140f, 0.00326790f, -0.02868822f, 
    -0.12251527f, 0.05713940f, 0.00302514f, -0.00718641f, -0.07870921f, -0.18026334f, -0.22899577f, -0.04580750f, 
    0.06364196f, 0.14601940f, 0.17974524f, 0.01818522f, 0.07100989f, 0.01227447f, -0.05429371f, -0.12652329f, 
    -0.23533423f, -0.40842184f, 0.13263088f, 0.22740506f, 0.20335260f, 0.17136993f, 0.13738632f, -0.17431833f, 
    0.07783183f, -0.13254021f, -0.11301489f, -0.00107243f, -0.17377141f, -0.18004383f, 0.08505901f, 0.18428253f, 
    0.04853980f, 0.08121826f, 0.15160343f, 0.07341041f, 0.14736795f, 0.03426166f, 0.13352145f, 0.06107720f, 
    -0.10183378f, -0.37512013f, 0.06862748f, 0.03769723f, 0.09352607f, 0.04779252f, 0.09847379f, 0.03712403f, 
    0.02385865f, 0.07400718f, 0.03759940f, 0.09119125f, 0.15895325f, 0.11411072f, 0.13457674f, 0.25205728f, 
    -0.07409796f, -0.05097590f, 0.03544898f, 0.05584202f, 0.07758276f, 0.10936005f, 0.11938445f, 0.08234795f, 
    -0.44066045f, 0.10614032f, -0.09909248f, 0.24019921f, -0.14998722f, 0.02108693f, 0.07801652f, 0.26826560f, 
    0.00282652f, 0.10395779f, 0.00705264f, -0.05187257f, -0.23330930f, -0.05893417f, -0.32172453f, -0.06802049f, 
    0.05648106f, 0.15411612f, -0.00443328f, 0.09837886f, -0.00803557f, 0.09991065f, -0.03467270f, 0.00440559f, 
    -0.28691345f, -0.45289660f, -0.03301248f, 0.34603339f, 0.01214264f, -0.07081113f, 0.02998760f, -0.17854519f, 
    -0.07542370f, -0.01203886f, -0.08089004f, 0.00852488f, -0.00217365f, -0.03614685f, 0.08744340f, -0.09211929f, 
    -0.16610616f, -0.07728568f, -0.01251235f, 0.06589192f, -0.02358747f, 0.10039876f, 0.00166287f, -0.19172594f, 
    -0.20042869f, 0.11869220f, 0.05462053f, -0.34554216f, -0.11680227f, -0.10557319f, -0.10948092f, -0.05835769f, 
    -0.06653517f, 0.10889473f, 0.01369191f, 0.03992615f, 0.09123453f, 0.42296034f, -0.01898381f, -0.11966914f, 
    0.03250620f, 0.07670504f, -0.00285655f, -0.09842319f, -0.05228311f, 0.14648014f, 0.16221622f, 0.03597300f, 
    0.19288367f, -0.16748193f, -0.11744346f, 0.05877733f, -0.10789941f, 0.11349358f, 0.05080352f, 0.10637243f, 
    0.08650466f, 0.20378049f, 0.05101183f, -0.05727468f, 0.29104334f, -0.00908752f, 0.17114197f, 0.08564493f, 
    -0.06986870f, 0.00651138f, 0.00796449f, 0.08101467f, -0.03651224f, 0.07081479f, 0.19479406f, 0.21371514f, 
    -0.30212748f, 0.14654218f, -0.46781841f, 0.43679887f, 0.08015253f, 0.31426647f, -0.04881592f, -0.06669047f, 
    0.00045716f, 0.05901798f, -0.00440432f, 0.08637457f, 0.11257212f, 0.45628408f, -0.06228852f, 0.00502866f, 
    -0.12631325f, 0.05940961f, 0.02777762f, -0.16478509f, -0.00253771f, 0.01075514f, -0.00992753f, 0.00490924f, 
    -0.26495007f, 0.02238277f, 0.12958708f, 0.21941680f, 0.00806007f, -0.15658303f, 0.07173742f, 0.21055251f, 
    -0.02013130f, 0.06215844f, 0.17520902f, -0.01111215f, 0.23281325f, 0.01155308f, -0.23860499f, -0.36174965f, 
    0.05525936f, 0.07906039f, 0.02073123f, -0.04549456f, 0.02662261f, 0.11500150f, 0.16405815f, 0.10927223f, 
    -0.29165000f, 0.24612579f, 0.19047584f, 0.06265268f, 0.14527316f, 0.15298454f, 0.02236332f, 0.06661792f, 
    0.01562699f, 0.13987423f, 0.08577680f, 0.05769470f, -0.01925319f, 0.00220364f, 0.07085852f, -0.06174174f, 
    0.03160198f, 0.04060774f, 0.14566144f, 0.12744077f, -0.04976099f, 0.13492097f, 0.23219627f, 0.10900663f, 
    -0.11381460f, -0.15213375f, 0.16624495f, 0.21273188f, 0.05127672f, 0.08357742f, 0.02859678f, 0.03150353f, 
    0.09506079f, 0.03766233f, 0.02798861f, 0.04993847f, -0.00239216f, 0.18318434f, -0.03668842f, -0.01871006f, 
    0.00237124f, 0.05099614f, -0.01472155f, 0.00595979f, -0.03630498f, 0.03369446f, 0.15085936f, -0.01467269f, 
    0.08829883f, 0.03203478f, 0.07822161f, -0.07251699f, 0.23978691f, 0.03065373f, 0.21247040f, 0.12880175f, 
    0.05809628f, -0.02203554f, 0.04216503f, 0.01570614f, -0.43849781f, -0.12485740f, 0.15626501f, 0.17495196f, 
    0.05289337f, -0.00306747f, -0.01183837f, -0.06025749f, 0.03844945f, -0.00427912f, 0.07334875f, 0.09680367f, 
    -0.42149544f, -0.00934441f, 0.06509795f, -0.14109576f, -0.09391245f, 0.02984373f, 0.07488775f, -0.06489414f, 
    -0.01524037f, 0.02150404f, 0.05657936f, 0.04259440f, -0.03355172f, -0.03750127f, 0.02806015f, 0.22984648f, 
    0.01202892f, -0.04000864f, -0.04884135f, 0.01126573f, 0.15736111f, 0.12996538f, 0.16996013f, 0.12266367f, 
    -0.10748493f, 0.03101146f, 0.33039030f, 0.19827135f, 0.14685930f, -0.12245122f, -0.02396987f, 0.03574515f, 
    0.08221732f, 0.05766507f, 0.03925942f, 0.08417403f, 0.10241897f, 0.08218390f, 0.02785524f, -0.02961738f, 
    -0.04207032f, -0.00575175f, 0.08938315f, -0.00084060f, -0.03054394f, -0.07440240f, -0.05825818f, 0.06311999f, 
    0.16511416f, 0.15723361f, 0.24660970f, 0.10065882f, -0.11409537f, -0.12861279f, 0.07248245f, 0.03175945f, 
    -0.08843518f, -0.03499739f, -0.02867720f, 0.06896701f, -0.14566450f, -0.11571222f, 0.00425738f, -0.03225515f, 
    0.08440977f, -0.08181001f, -0.00602361f, 0.01220246f, 0.13444172f, -0.07392857f, 0.08059425f, -0.19401366f, 
    0.04696038f, -0.11526838f, -0.09293708f, -0.00645987f, 0.09884626f, 0.03627379f, 0.05140287f, 0.03770764f, 
    -0.05347072f, -0.00423608f, -0.09584928f, -0.10272056f, -0.56716472f, 0.08956126f, 0.14044093f, -0.08619264f, 
    -0.02302908f, 0.10246592f, 0.23319690f, 0.19487749f, 0.07949944f, -0.02013962f, 0.10878585f, 0.05223921f, 
    -0.24071307f, -0.03541433f, -0.06149388f, -0.30958265f, -0.23069170f, -0.28714371f, -0.15020135f, -0.18590015f, 
    0.05854555f, -0.02817463f, -0.05491937f, -0.04012680f, -0.25247830f, -0.17972255f, -0.08128558f, -0.04908173f, 
    0.00959681f, 0.06021549f, 0.15277448f, 0.03357537f, -0.09979987f, 0.00526321f, -0.07388514f, -0.02466700f, 
    0.12832414f, -0.07926670f, -0.10496573f, -0.03062230f, 0.14435360f, 0.04812695f, 0.11532672f, -0.08085989f, 
    0.13680582f, 0.09755894f, 0.01441776f, 0.03657657f, -0.10516946f, 0.03450327f, -0.03108342f, -0.17035280f, 
    -0.01766756f, 0.22219890f, 0.06731033f, -0.17242779f, 0.11716522f, -0.02037808f, 0.10188394f, 0.12622017f, 
    -0.16901724f, 0.02328155f, -0.01303977f, -0.11377781f, 0.01187188f, 0.08166165f, 0.03378351f, -0.09393632f, 
    0.03468322f, -0.02372889f, -0.05559685f, -0.03550273f, -0.07418453f, -0.07485925f, 0.08676309f, 0.06386742f, 
    0.04067805f, 0.00760027f, -0.11242419f, 0.04493745f, 0.13228710f, 0.09049840f, -0.03656646f, 0.10938197f, 
    0.03624740f, 0.32409245f, 0.25797722f, -0.06036964f, 0.01403434f, -0.05312106f, -0.00457176f, 0.13428275f, 
    0.00121780f, 0.01869661f, 0.25635058f, 0.00323099f, -0.18206932f, -0.22563313f, 0.11092873f, 0.01656394f, 
    0.21990199f, 0.08563957f, 0.17656064f, -0.12946254f, -0.01883464f, 0.07803924f, 0.02284501f, 0.00760922f, 
    -0.19251177f, 0.00896963f, 0.02054705f, -0.22513339f, -0.09239061f, -0.08064227f, 0.04355576f, -0.17612235f, 
    0.00147677f, -0.03081909f, 0.04072284f, 0.00772247f, 0.14973690f, 0.01069026f, -0.10184500f, -0.02993293f, 
    -0.05192608f, 0.03727295f, 0.12003776f, 0.05736410f, 0.31234258f, 0.15325302f, 0.14092119f, -0.12775309f, 
    0.12270348f, -0.13913962f, -0.10325964f, -0.05289525f, 0.03314696f, 0.02720824f, -0.04074480f, -0.05650009f, 
    -0.00521853f, -0.05517818f, -0.08929626f, -0.08743757f, -0.02576795f, -0.06813992f, 0.07349911f, 0.16987130f, 
    0.09516107f, 0.04045234f, -0.00782511f, 0.00065551f, 0.03913014f, 0.06580422f, -0.10071934f, 0.02334747f, 
    0.00497183f, -0.11073934f, 0.00574227f, 0.05317470f, 0.10289822f, 0.12456079f, 0.03770401f, 0.16201827f, 
    -0.08023780f, 0.08117937f, -0.04698005f, 0.00823149f, 0.01029888f, 0.13684720f, -0.10584839f, 0.12177705f, 
    0.07395138f, 0.01387840f, -0.04237445f, -0.11246869f, 0.05090703f, 0.00438801f, -0.15807930f, 0.00741521f, 
    -0.06067367f, -0.47375917f, 0.19871280f, 0.34903142f, 0.26510453f, 0.05127308f, 0.06339888f, 0.08757222f, 
    0.04081283f, 0.01550517f, 0.13532926f, -0.03874508f, 0.03979382f, -0.23327069f, -0.10322250f, 0.23788184f, 
    0.13240261f, 0.08296061f, 0.05750221f, 0.00176078f, 0.04326949f, 0.03099980f, -0.02930811f, 0.03122295f, 
    -0.35096565f, 0.15534973f, 0.07496554f, -0.27979961f, -0.03406823f, -0.13161063f, -0.02275159f, -0.05892293f, 
    -0.10103976f, 0.02486298f, -0.10613770f, 0.01718235f, -0.05323571f, -0.10428265f, 0.16707486f, 0.16080163f, 
    0.09119519f, 0.10230883f, 0.08452983f, 0.03834031f, 0.08036273f, -0.02821801f, -0.04089893f, -0.26507059f, 
    -0.00922058f, -0.12022541f, -0.05228230f, 0.22522633f, 0.08503886f, -0.01259529f, 0.00610352f, 0.03921930f, 
    0.06621803f, 0.15216199f, -0.02548620f, 0.18115264f, -0.03241608f, 0.03761851f, 0.04753332f, -0.05900159f, 
    0.06584791f, -0.02976761f, 0.08630048f, 0.04719726f, 0.07547591f, 0.06923104f, -0.07649495f, -0.01458673f, 
    0.02116407f, 0.07078940f, 0.04273896f, 0.11661031f, 0.14451601f, -0.06837257f, -0.18480989f, -0.03606233f, 
    -0.02880692f, 0.11503904f, 0.11272545f, 0.09608218f, 0.28843400f, 0.03569550f, 0.21155600f, -0.29048294f, 
    0.11078572f, -0.03380767f, 0.19348454f, 0.30543268f, 0.00946765f, 0.10930814f, 0.05683706f, -0.11118238f, 
    0.48718178f, 0.05151085f, -0.02338232f, -0.08705906f, 0.24967341f, -0.17321847f, 0.05001091f, 0.19422840f, 
    0.06008011f, -0.10791110f, -0.10593671f, 0.08526123f, -0.31019524f, -0.04664334f, 0.25476235f, 0.25466630f, 
    0.10041498f, 0.14949392f, -0.00475615f, 0.04406980f, 0.06501503f, 0.01213856f, 0.29608753f, 0.09082879f, 
    -0.11081050f, -0.16639754f, -0.25534523f, -0.00636513f, 0.03211170f, -0.06854547f, -0.12128486f, 0.09609319f, 
    0.05696447f, 0.05056563f, 0.02756169f, 0.08612707f, 0.28611699f, 0.09157198f, 0.09213687f, 0.18195608f, 
    -0.01285241f, 0.03072380f, 0.02453482f, -0.04223091f, 0.04960453f, 0.19578798f, 0.02244931f, -0.04820880f, 
    -0.22274584f, -0.12365272f, 0.18569796f, -0.20671201f, 0.13420083f, -0.09988840f, -0.02967465f, -0.05113995f, 
    -0.12891737f, 0.13596252f, 0.12879296f, -0.09454741f, 0.34218854f, 0.05970309f, -0.03799386f, -0.02308522f, 
    -0.05721396f, 0.10466050f, -0.04306356f, 0.01055477f, 0.09430831f, 0.01476647f, 0.05049745f, -0.03762450f, 
    -0.12291899f, 0.04288603f, 0.05311175f, -0.21561420f, -0.10729530f, 0.09699361f, -0.02079737f, 0.03183674f, 
    -0.07635456f, -0.04893087f, -0.13805719f, 0.02607269f, 0.12417138f, 0.09193025f, 0.15096997f, -0.03509681f, 
    0.03587076f, 0.10019043f, -0.10628254f, 0.03687634f, -0.04774109f, 0.10378725f, 0.06935190f, -0.14854053f, 
    0.26340312f, 0.03759618f, 0.25694531f, 0.17865369f, 0.06083089f, 0.06722929f, 0.00152759f, -0.11790274f, 
    -0.02494665f, 0.07104928f, -0.04052647f, -0.07808803f, 0.04334724f, -0.15106094f, -0.02635957f, -0.12201244f, 
    0.03100506f, -0.21183476f, -0.01603190f, -0.03889726f, 0.07283464f, 0.03318459f, 0.08146737f, 0.11479394f, 
    -0.16780095f, -0.16770035f, -0.01477283f, -0.02879517f, -0.04656357f, -0.06878589f, 0.06551044f, 0.03617242f, 
    0.01520012f, -0.06784426f, 0.00439379f, -0.06788743f, -0.12636268f, -0.04957852f, -0.14467633f, -0.06905955f, 
    0.07814660f, -0.12955381f, 0.09070829f, -0.10028481f, 0.09987834f, 0.08922625f, 0.11688920f, 0.15893492f, 
    0.64656228f, 0.13781975f, -0.21336263f, -0.01090540f, 0.05724892f, 0.04107435f, 0.11217546f, 0.03369355f, 
    -0.08710283f, -0.15808877f, -0.04394113f, 0.03679797f, 0.13385278f, -0.07009204f, 0.20929521f, 0.20101060f, 
    -0.02005027f, 0.14241795f, 0.15153114f, 0.04857761f, 0.06840404f, 0.05486458f, 0.04354309f, 0.15341190f, 
    -0.06207609f, 0.00603562f, -0.18679154f, 0.13748893f, -0.02061795f, 0.00616367f, 0.10851054f, -0.01964017f, 
    0.04106189f, -0.04263496f, 0.04533224f, 0.05850376f, -0.10390443f, -0.01248009f, 0.11688056f, -0.13846803f, 
    -0.00499268f, 0.06836724f, -0.02600180f, -0.14777769f, -0.00855257f, -0.03991154f, -0.00427534f, -0.01086001f, 
    0.02718464f, -0.19321355f, 0.08963695f, -0.24710943f, 0.00488704f, -0.13297468f, -0.01282918f, 0.03461186f, 
    0.08247811f, 0.21948545f, 0.07262325f, 0.00216265f, -0.22750440f, -0.21492924f, -0.28949466f, 0.08810954f, 
    0.08000344f, -0.24786763f, 0.13626327f, -0.05927872f, 0.00640338f, 0.00836271f, 0.03942186f, -0.00192819f, 
    -0.17686807f, -0.12129132f, 0.03724778f, -0.01340006f, 0.01598405f, -0.01015986f, -0.01414710f, 0.14572585f, 
    0.03612747f, -0.01491750f, -0.01974522f, 0.02236000f, 0.16839316f, 0.03221224f, 0.09878836f, 0.03606570f, 
    -0.01692877f, 0.01430448f, 0.26392424f, 0.11567883f, 0.28572622f, 0.10003687f, 0.11338291f, 0.07033604f, 
    0.42380583f, -0.01991819f, 0.11820928f, 0.20488153f, 0.04936068f, 0.01108356f, 0.02812596f, -0.01892426f, 
    0.01946672f, 0.01461938f, -0.04609833f, -0.12681659f, -0.09584934f, 0.03623890f, -0.08104158f, -0.03437228f, 
    0.14299306f, 0.10446734f, 0.03207010f, -0.02580839f, 0.01653673f, -0.05841840f, 0.00124612f, -0.18598607f, 
    0.04290926f, -0.12171721f, -0.16481097f, 0.09893362f, 0.17952472f, 0.04080292f, 0.11938663f, -0.10300684f, 
    -0.17485105f, -0.10522535f, -0.15832061f, -0.09165875f, -0.03161385f, 0.22636688f, 0.06525659f, -0.07240112f, 
    -0.10751255f, -0.16809803f, 0.08422461f, -0.16134943f, 0.21885957f, 0.06191291f, -0.07914656f, -0.10311353f, 
    0.12838779f, -0.22949928f, 0.13247223f, 0.04712266f, 0.05922388f, 0.15290464f, -0.02193186f, 0.09753321f, 
    -0.12967087f, -0.17225370f, 0.02098722f, -0.11265870f, 0.34221393f, -0.03986972f, 0.07498529f, -0.01683956f, 
    0.16141772f, 0.07350288f, -0.04627392f, 0.05339128f, -0.00739120f, -0.11712128f, 0.03207163f, -0.03001636f, 
    -0.06957657f, -0.23238422f, -0.19380507f, -0.35924891f, -0.02086632f, -0.21084769f, -0.08132575f, 0.07402035f, 
    0.01922882f, 0.10937904f, -0.02669325f, 0.11982611f, -0.22064219f, 0.07798510f, 0.19104829f, 0.22393464f, 
    0.05570919f, 0.00724469f, -0.09514058f, -0.04872908f, 0.06276096f, 0.04711344f, -0.09446204f, -0.09284349f, 
    0.00829179f, -0.08062086f, -0.17275262f, -0.09494902f, 0.03524194f, -0.00644037f, -0.27098361f, 0.00948045f, 
    -0.09241053f, -0.10325137f, 0.04396265f, -0.09877443f, 0.05092577f, -0.06326225f, -0.08746208f, -0.05386416f, 
    0.03202907f, 0.05787818f, 0.07809185f, -0.01106564f, -0.03219920f, -0.15881635f, -0.08947363f, -0.09543946f, 
    -0.03083271f, -0.02206103f, -0.11316133f, 0.02936602f, 0.10054342f, 0.05332594f, -0.04449592f, -0.00440529f, 
    -0.15279536f, 0.06199863f, -0.04010190f, -0.01836093f, -0.10127304f, -0.05954908f, 0.25586227f, -0.04336319f, 
    0.12379507f, 0.08063325f, 0.20156623f, 0.07260557f, 0.07821465f, 0.14202289f, 0.00817990f, 0.16716419f, 
    0.10038210f, 0.40039071f, 0.08680514f, -0.09161443f, -0.23055537f, 0.17842796f, -0.33119297f, 0.10386814f, 
    -0.09796920f, -0.11387703f, 0.12382379f, -0.16184112f, -0.00143870f, -0.13633874f, -0.32985649f, 0.06855350f, 
    0.04155230f, -0.04351195f, 0.05132432f, -0.00306830f, -0.15430771f, 0.02978962f, -0.07811642f, -0.09415682f, 
    0.10852861f, 0.05249615f, 0.25456250f, 0.37273452f, -0.06064653f, 0.02043211f, -0.07040792f, 0.07234971f, 
    0.11933620f, 0.07008324f, -0.07622619f, 0.01606511f, -0.00010997f, 0.20573790f, 0.14802808f, 0.04301191f, 
    -0.00507978f, -0.04117445f, -0.11058449f, -0.24401662f, 0.00374655f, 0.06640879f, -0.12502131f, -0.18611676f, 
    0.21659485f, 0.14107822f, 0.10924964f, -0.15532012f, 0.13624524f, 0.10375693f, 0.04769532f, -0.12815298f, 
    0.05228465f, 0.04688686f, -0.02552086f, 0.02569840f, -0.17164184f, 0.13864084f, 0.06642502f, 0.08929104f, 
    -0.10503883f, 0.00842549f, -0.06097861f, -0.01910971f, -0.00280357f, 0.08645555f, 0.14471535f, 0.04406254f, 
    -0.15180053f, -0.06010663f, 0.04272044f, 0.02274723f, 0.08322881f, 0.15258630f, -0.01097090f, 0.06706724f, 
    0.14823742f, 0.00182113f, 0.21777549f, -0.22684833f, -0.11141229f, 0.50349373f, -0.19369136f, 0.23677993f, 
    -0.02519885f, 0.01156497f, 0.02895053f, 0.03399639f, -0.10912864f, -0.09568471f, 0.00470847f, 0.08969762f, 
    0.07285208f, 0.16694030f, 0.30453604f, -0.00600286f, -0.06578021f, -0.20023943f, -0.12592873f, -0.05396223f, 
    -0.02623426f, 0.05564773f, -0.00869329f, -0.01675153f, 0.38126957f, 0.02570354f, 0.16445920f, 0.23377535f, 
    0.08666403f, -0.14739174f, -0.08827223f, -0.18417861f, 0.06766624f, 0.08274254f, -0.12246884f, 0.15872429f, 
    -0.04123374f, -0.09767191f, 0.01867695f, 0.18037970f, -0.04546506f, 0.06932577f, -0.01479533f, 0.08536054f, 
    -0.05944405f, 0.05187694f, 0.04842839f, 0.09180804f, 0.01820846f, -0.06394317f, -0.11062755f, -0.12998930f, 
    0.07517079f, 0.02692488f, 0.04630494f, 0.12156849f, -0.05316961f, 0.04220722f, -0.00799797f, -0.12158650f, 
    -0.10719802f, -0.05122667f, 0.28848043f, -0.01386788f, -0.05487261f, 0.00323597f, -0.10958574f, -0.06134785f, 
    -0.06836606f, -0.04069684f, 0.07545350f, 0.03761024f, -0.27493396f, -0.00218881f, 0.25213021f, -0.03418966f, 
    0.02733082f, -0.01443243f, 0.07674863f, 0.15404119f, 0.09402501f, 0.05295673f, -0.03297716f, -0.06894451f, 
    -0.07177184f, -0.18811810f, -0.06053962f, 0.07401981f, 0.00712464f, 0.05801721f, 0.00968343f, 0.09635583f, 
    -0.06241178f, 0.10344922f, 0.09379540f, -0.02382848f, 0.22711903f, 0.14819509f, -0.05171570f, 0.04290611f, 
    0.00221807f, 0.11605011f, 0.13296768f, -0.04241357f, -0.16380545f, -0.04419249f, -0.20872520f, 0.10684807f, 
    -0.18529336f, -0.26459715f, 0.04173837f, 0.15488835f, -0.11144639f, -0.03526117f, -0.00525688f, -0.16478135f, 
    0.03438826f, 0.17230313f, -0.08101011f, 0.19666718f, -0.28055924f, 0.07813823f, -0.26644722f, 0.05857337f, 
    -0.04442384f, -0.16727465f, -0.11101390f, 0.03732131f, -0.05969118f, -0.08227053f, 0.02218315f, -0.16373479f, 
    -0.12841009f, -0.25673443f, -0.06883112f, 0.21677695f, -0.06881969f, 0.08299724f, -0.09014646f, 0.09192314f, 
    0.02515082f, -0.02378383f, -0.13633771f, -0.00624266f, -0.17451990f, 0.11003439f, 0.19061793f, -0.03440822f, 
    0.03922484f, -0.05444798f, -0.28779370f, -0.10861807f, -0.06328993f, -0.02595500f, -0.07539922f, 0.18273824f, 
    0.20404294f, 0.13348234f, 0.20663916f, 0.12668341f, -0.10238876f, -0.14819686f, -0.04399244f, 0.04020736f, 
    -0.17452361f, 0.01219740f, 0.12381515f, 0.00666834f, -0.20801915f, 0.34980625f, -0.01456781f, 0.11874151f, 
    -0.03673515f, -0.06091714f, 0.08075007f, 0.12505642f, 0.07449903f, 0.00099947f, 0.07671054f, 0.08127403f, 
    0.14530139f, -0.07141411f, 0.03091332f, 0.08988789f, -0.14387359f, 0.03439869f, 0.04525037f, 0.06360184f, 
    -0.01112438f, 0.00459155f, 0.06836755f, -0.01521432f, 0.25583169f, 0.11795121f, 0.08528315f, -0.12098638f, 
    -0.03437171f, 0.20714229f, -0.03390789f, 0.19694787f, -0.05236103f, 0.04678637f, 0.12012421f, 0.02900350f, 
    -0.07914622f, 0.57393754f, -0.46675348f, 0.11604809f, -0.14895384f, -0.24625082f, 0.03781514f, 0.11840995f, 
    -0.17405592f, -0.05448295f, -0.04609361f, 0.02942248f, 0.41031051f, 0.56086081f, 0.07455912f, -0.05523084f, 
    -0.12666142f, -0.19339058f, -0.06769213f, -0.02042057f, -0.06104618f, -0.03639729f, 0.17068788f, -0.02541611f, 
    0.15976699f, -0.00621719f, 0.31767005f, 0.37087280f, -0.03791091f, 0.06075799f, -0.05435457f, 0.07480937f, 
    -0.01297219f, -0.02550419f, 0.05780191f, -0.13672212f, -0.26804465f, 0.15079398f, -0.42608017f, -0.03702678f, 
    0.09737022f, -0.15744887f, -0.01924201f, 0.03055078f, -0.00053370f, 0.01722103f, -0.15938157f, 0.14354211f, 
    0.04267866f, 0.32760060f, 0.28574437f, 0.10536921f, 0.05743552f, 0.05264936f, 0.02452070f, -0.08126248f, 
    -0.08061231f, 0.03513980f, 0.09279948f, 0.03094071f, 0.01500136f, -0.11133692f, -0.04503516f, 0.01182727f, 
    0.06896688f, -0.05866897f, 0.01869575f, 0.08907451f, 0.08175740f, -0.22117265f, 0.09873354f, 0.05358620f, 
    -0.07385071f, -0.01789155f, 0.19053484f, 0.04668348f, -0.10921793f, 0.08246104f, -0.03517075f, -0.01703641f, 
    0.17121765f, 0.10122253f, 0.08893631f, 0.04135917f, -0.19923456f, 0.31929249f, 0.36752158f, -0.05527508f, 
    -0.00506799f, 0.01313328f, 0.03459739f, -0.06003928f, -0.04309153f, -0.00502191f, 0.14850883f, 0.11458048f, 
    0.00159813f, 0.14630057f, 0.01863493f, -0.10200103f, 0.12329932f, 0.02145769f, 0.19808212f, 0.02263255f, 
    -0.04945657f, -0.05842752f, -0.03186053f, -0.04560890f, -0.10127620f, -0.30179983f, -0.00581461f, -0.00151473f, 
    0.07313224f, 0.04403536f, 0.07727767f, -0.03703475f, 0.07274936f, 0.14380068f, -0.05717268f, 0.00689410f, 
    -0.28808036f, -0.17897554f, -0.03593198f, 0.08248224f, -0.18533158f, -0.05021444f, 0.00573501f, 0.05896458f, 
    0.03671027f, -0.07612251f, 0.01354252f, 0.13800918f, 0.19851492f, 0.07084934f, 0.19759396f, -0.07683725f, 
    -0.00026669f, -0.12038436f, -0.00533518f, 0.00637630f, 0.07527591f, 0.25336388f, 0.29787761f, 0.10366675f, 
    0.37634921f, 0.31408939f, -0.04812516f, 0.37279233f, 0.05495769f, -0.27318144f, 0.16395982f, 0.02367235f, 
    -0.05384516f, 0.11170942f, -0.16047348f, 0.03308449f, 0.02263251f, -0.13076064f, -0.02043240f, -0.14764774f, 
    0.04729886f, -0.11099166f, -0.00715256f, -0.02815515f, 0.10888930f, 0.13685066f, -0.06663693f, 0.01749291f, 
    0.04536174f, 0.05355663f, 0.02409153f, 0.08184531f, 0.08283789f, -0.00822381f, 0.25449738f, 0.15257981f, 
    -0.01689402f, 0.07493414f, 0.01307624f, 0.09668161f, -0.02206769f, -0.07751660f, 0.25133899f, -0.17791541f, 
    0.08434873f, 0.03536331f, -0.04398695f, 0.00992241f, 0.02956848f, 0.00310287f, -0.03423251f, 0.10200939f, 
    -0.01064880f, -0.11008830f, -0.21068643f, -0.28055906f, -0.04778347f, -0.04921819f, 0.02654271f, -0.00402886f, 
    0.03295165f, 0.01987596f, -0.05816493f, -0.08952759f, -0.21655427f, -0.13068628f, -0.03211661f, 0.13799062f, 
    -0.07764318f, -0.11394908f, -0.00906500f, 0.03250162f, 0.04905472f, 0.03782836f, -0.00213050f, 0.01195597f, 
    -0.18246344f, -0.25334534f, -0.11396275f, 0.13415259f, -0.03959249f, -0.11025473f, -0.00910474f, -0.10145663f, 
    0.02997339f, 0.06746086f, -0.04033443f, -0.03765964f, -0.11412949f, -0.10632110f, -0.06216048f, 0.20768169f, 
    -0.06845297f, 0.09945854f, 0.13979435f, -0.02884488f, 0.04338335f, 0.01698081f, 0.03577593f, 0.13224518f, 
    -0.12174430f, 0.01292956f, -0.11535252f, 0.19131249f, 0.15399759f, 0.15364505f, 0.13826720f, -0.05797572f, 
    0.02726381f, -0.10859123f, -0.03788434f, -0.03356651f, 0.02664451f, 0.24074547f, -0.02608681f, 0.02899971f, 
    0.23070142f, 0.03795537f, -0.04031438f, 0.09904078f, 0.14029413f, 0.06977151f, 0.01918444f, -0.14730750f, 
    -0.12551120f, -0.21623343f, -0.05454545f, 0.10744749f, -0.06161685f, -0.00150428f, 0.01689939f, 0.03690121f, 
    0.06036479f, 0.18343915f, 0.02827682f, 0.05652362f, 0.16398297f, 0.11744029f, -0.09777449f, 0.14606847f, 
    0.01854007f, -0.18597940f, -0.08123340f, -0.02516424f, 0.09511189f, -0.02468228f, 0.17608649f, 0.13324891f, 
    0.08108497f, 0.16029534f, 0.42232287f, 0.03333899f, -0.07052696f, 0.00146765f, 0.05627434f, 0.12211130f, 
    -0.02256102f, -0.00362497f, 0.10866731f, 0.08449036f, -0.33462033f, -0.25093558f, -0.04283750f, 0.26820043f, 
    -0.10465334f, -0.15524317f, -0.17347047f, 0.08691499f, 0.01709931f, 0.05419536f, -0.01176097f, 0.05568671f, 
    -0.31249195f, -0.24161765f, 0.13508150f, 0.22043306f, -0.01012013f, -0.07164262f, 0.15400334f, -0.12065232f, 
    0.02252738f, 0.02811247f, 0.05645174f, 0.00917148f, -0.00451830f, 0.08341434f, -0.11424544f, -0.08435758f, 
    -0.02846153f, -0.04961423f, 0.11280899f, 0.00017130f, 0.06677805f, 0.10023233f, 0.16856603f, -0.02677294f, 
    -0.35204449f, -0.01001857f, -0.13795856f, -0.28312239f, -0.11267757f, -0.08815522f, 0.00077407f, -0.09751471f, 
    -0.00779393f, -0.01841955f, -0.06807195f, -0.07172030f, 0.09756267f, 0.08890817f, -0.28484124f, 0.06146286f, 
    -0.02930267f, 0.12329958f, -0.05395402f, -0.06499955f, -0.09926156f, -0.03583853f, 0.10047749f, -0.06526094f, 
    -0.04289819f, -0.23691998f, -0.08740347f, 0.05732451f, 0.15969479f, 0.08469480f, 0.27089468f, 0.28995886f, 
    0.09479761f, 0.07100308f, 0.04409187f, -0.06540649f, 0.02290943f, 0.31629890f, -0.14068989f, 0.07852771f, 
    -0.07228936f, -0.13528755f, -0.08617763f, 0.08254244f, 0.11219128f, 0.11068246f, -0.00210088f, 0.19570704f, 
    0.25416994f, -0.35348442f, 0.15562421f, 0.35399964f, -0.02048322f, 0.23463666f, -0.03038668f, 0.07620557f, 
    -0.01841330f, 0.07913785f, 0.08053119f, 0.01649868f, 0.02963400f, 0.13195264f, -0.16458055f, 0.08266231f, 
    0.04786094f, 0.14027888f, 0.07265899f, -0.06695413f, 0.03455308f, 0.01576081f, -0.01733839f, 0.04280232f, 
    -0.16158175f, 0.00091495f, 0.45902881f, 0.09727257f, -0.07448374f, -0.08815642f, 0.10736384f, 0.17912698f, 
    -0.01256694f, 0.07716864f, 0.08935645f, 0.09610983f, 0.24348326f, -0.28313509f, -0.36463189f, 0.16850348f, 
    0.10024380f, -0.03224793f, -0.09382314f, -0.07839208f, -0.03089445f, 0.02791697f, -0.00926376f, 0.11596065f, 
    0.12252379f, 0.02040510f, 0.19597171f, 0.14932619f, -0.01281473f, 0.02354781f, 0.07944003f, 0.05293087f, 
    -0.02721608f, 0.08823276f, 0.04320251f, 0.17521225f, -0.10281265f, -0.10794890f, -0.02776473f, -0.06677563f, 
    -0.02416865f, -0.02850940f, 0.07928053f, 0.14863795f, 0.00807319f, 0.06224210f, 0.00279801f, 0.03701354f, 
    -0.06461736f, -0.16796765f, -0.33546859f, -0.24714759f, -0.00650997f, 0.03598427f, 0.02995265f, -0.02049695f, 
    0.02417208f, -0.00932088f, -0.08668187f, -0.19461136f, 0.00935755f, 0.01692121f, -0.17595936f, 0.38614249f, 
    -0.02291763f, 0.32175845f, -0.01712811f, 0.10721914f, 0.25996530f, 0.00954049f, 0.00564386f, 0.12584390f, 
    0.45498896f, 0.00925740f, 0.00838577f, 0.48090643f, -0.06127810f, -0.08379225f, 0.09570117f, -0.13129830f, 
    0.06502665f, 0.05218904f, -0.00282017f, 0.05640266f, -0.04653004f, 0.27410871f, 0.21720742f, -0.13828914f, 
    0.11425491f, -0.11330908f, 0.06551945f, 0.16526625f, 0.15950078f, -0.10395999f, 0.07707815f, -0.09643007f, 
    -0.18529959f, 0.08601550f, -0.05434968f, -0.16941947f, 0.12425254f, -0.04231260f, 0.09490160f, 0.04094395f, 
    -0.03595490f, 0.05559959f, -0.02341780f, 0.11234258f, -0.04578426f, -0.06165203f, -0.06865022f, -0.05107759f, 
    -0.02344268f, -0.01623315f, -0.10617094f, 0.02790028f, 0.04999225f, -0.18713380f, 0.05251524f, 0.20908789f, 
    0.11802323f, -0.33782083f, -0.27939159f, 0.08208703f, -0.09501311f, 0.19246355f, 0.06342235f, 0.25646019f, 
    0.22237122f, 0.04326905f, 0.10954639f, 0.20180762f, -0.08838559f, 0.10612493f, -0.02286697f, -0.03450733f, 
    0.05290204f, -0.00872209f, 0.00455242f, -0.00162833f, 0.08343384f, 0.12035367f, -0.03288961f, 0.01484756f, 
    0.07708970f, -0.14583874f, 0.15699074f, 0.36020041f, -0.03009409f, 0.14423160f, 0.03929823f, 0.17411378f, 
    0.19059703f, 0.17667410f, -0.00285873f, 0.08936852f, 0.06490716f, 0.26101768f, 0.01135752f, 0.04366849f, 
    -0.13852626f, -0.09339624f, 0.00850985f, -0.11859133f, 0.12532558f, -0.19572651f, 0.03423514f, 0.13373852f, 
    0.29408020f, 0.37979797f, 0.16506787f, 0.05211647f, -0.07316357f, -0.12852809f, -0.06754756f, -0.06737465f, 
    -0.02122816f, 0.00090625f, -0.06738283f, 0.10616846f, -0.16621424f, 0.00803996f, -0.20845920f, -0.14366454f, 
    -0.06129001f, 0.07251898f, 0.12112838f, 0.06198189f, -0.09258424f, -0.07544813f, -0.02878636f, -0.09659994f, 
    -0.09208121f, 0.08774569f, 0.17665221f, 0.16667369f, 0.19811672f, 0.17089243f, 0.08232313f, 0.11928979f, 
    0.03707231f, 0.09437152f, 0.03976199f, 0.02644395f, 0.05489201f, -0.08645151f, 0.21174820f, 0.08604389f, 
    0.09534092f, -0.05194064f, -0.10770362f, -0.03901555f, 0.05753447f, -0.06741031f, -0.07579350f, -0.14268780f, 
    -0.07827856f, 0.16483426f, 0.22716230f, 0.10522186f, 0.08838642f, 0.07166930f, 0.06264646f, -0.07631233f, 
    0.04554932f, -0.08645930f, -0.05608768f, -0.01170001f, 0.23892365f, 0.24443352f, -0.04024661f, 0.38576999f, 
    0.13726842f, 0.14981924f, -0.00264017f, -0.03071431f, 0.02649424f, -0.09370659f, 0.02955896f, -0.01130331f, 
    0.03460736f, -0.07159585f, 0.33582833f, 0.27981380f, 0.09873008f, 0.07966414f, 0.03611742f, 0.02745599f, 
    0.03826564f, -0.02932530f, 0.17593201f, 0.14550731f, -0.15003820f, -0.11076241f, 0.13905099f, 0.07677743f, 
    0.08979261f, 0.06940872f, -0.02888669f, 0.07298822f, 0.08177280f, 0.34830704f, 0.09722611f, 0.03362557f, 
    -0.24745958f, -0.21736860f, -0.56496716f, -0.16870885f, -0.01174719f, 0.03925016f, 0.08611067f, 0.24967268f, 
    0.05288058f, -0.16330595f, -0.08265263f, -0.22006096f, 0.23073086f, -0.08865915f, 0.35949746f, 0.02044770f, 
    0.21948135f, 0.14204755f, 0.07425158f, 0.02778712f, 0.01166443f, -0.05530882f, -0.00727482f, 0.04084188f, 
    0.07129569f, 0.16376764f, 0.32135001f, 0.27166745f, 0.20730205f, 0.05045284f, 0.11021718f, -0.10024266f, 
    -0.01186652f, 0.01609978f, 0.15109731f, 0.13118838f, 0.12797944f, -0.08780621f, -0.07718594f, 0.06182694f, 
    0.02536537f, 0.06136805f, -0.08755691f, 0.05065852f, -0.01288188f, -0.18757789f, -0.05944143f, -0.50917405f, 
    0.09059943f, 0.28616655f, 0.27772081f, 0.04432297f, -0.07848260f, -0.12802386f, -0.18704326f, -0.11620847f, 
    -0.11315075f, -0.05085564f, 0.03112859f, -0.04378796f, 0.17878428f, -0.19597414f, 0.23588958f, -0.04256055f, 
    0.06283262f, 0.01911109f, 0.20490418f, 0.00712809f, -0.00133853f, 0.03762034f, 0.01667350f, 0.06186701f, 
    0.11924739f, 0.15711270f, 0.13431813f, -0.04574274f, 0.05122507f, 0.14959493f, -0.15928024f, -0.02393399f, 
    0.09148446f, 0.05057839f, 0.05829252f, 0.10462980f, -0.21090122f, -0.15843961f, 0.04700946f, 0.04650483f, 
    -0.04380718f, 0.05053629f, 0.01746380f, 0.01040617f, -0.08060812f, 0.24746807f, 0.22216040f, -0.07207440f, 
    0.15965658f, 0.16112754f, 0.27775681f, 0.02586459f, -0.08091265f, 0.07984100f, 0.18521596f, 0.01087878f, 
    0.16395612f, 0.05611539f, -0.00378159f, 0.08983380f, 0.14097627f, 0.12183495f, 0.14772882f, 0.24419890f, 
    -0.04043068f, -0.04911944f, 0.06511532f, -0.01555697f, 0.00499285f, 0.05428420f, -0.13730410f, -0.11852839f, 
    -0.39017063f, -0.06270471f, -0.29810569f, -0.04133468f, 0.02621997f, 0.17529379f, 0.09760638f, 0.10431214f, 
    0.20778152f, 0.10724184f, -0.09370486f, -0.09936083f, 0.23620404f, -0.18314008f, 0.05089777f, -0.20266344f, 
    -0.12627463f, -0.11527706f, 0.15627274f, 0.02408632f, 0.03337328f, 0.11272947f, 0.19704211f, 0.06055968f, 
    -0.29642996f, -0.22995049f, -0.17602916f, 0.06823073f, 0.12116766f, 0.12540446f, 0.10561270f, 0.17276873f, 
    0.14930826f, 0.12033041f, -0.05526823f, 0.04848472f, -0.07150342f, -0.04167653f, 0.05277494f, -0.10038976f, 
    0.00817446f, 0.11279081f, 0.01460485f, -0.16433625f, 0.03255397f, 0.08258010f, 0.01228391f, 0.10483823f, 
    0.02763902f, 0.01334907f, -0.05004834f, 0.01076672f, 0.00762003f, 0.02634122f, -0.02139022f, -0.00541322f, 
    -0.04397595f, 0.04735669f, 0.02949361f, -0.01559641f, -0.00465172f, -0.03662743f, -0.04019535f, -0.02352454f, 
    -0.00025394f, -0.04293355f, 0.00581534f, -0.05452435f, 0.01674705f, -0.04097861f, -0.02789607f, -0.02091563f, 
    -0.01818358f, -0.00577627f, -0.00437463f, -0.00696277f, 0.00006302f, -0.03702774f, -0.01814177f, 0.00625621f, 
    -0.00737440f, -0.01930550f, 0.01267261f, 0.00410088f, -0.00671385f, -0.04659567f, -0.03655849f, -0.02866591f, 
    -0.03345229f, -0.02171530f, 0.02791831f, 0.00536482f, -0.00552038f, -0.00410208f, -0.02398752f, -0.05589231f, 
    -0.05021132f, 0.03606225f, -0.03065040f, 0.02693613f, 0.02440322f, 0.03721990f, -0.04408390f, -0.03212209f, 
    -0.05879824f, 0.01364162f, 0.01012576f, 0.02032498f, 0.00404046f, -0.03680062f, -0.00400502f, -0.00838381f, 
    -0.04832327f, 0.03296917f, -0.01875562f, -0.01541724f, 0.00491230f, -0.01994419f, 0.03385266f, -0.03691941f, 
    -0.02283107f, -0.03437243f, 0.03311748f, -0.02158637f, -0.03315813f, -0.02593081f, 0.00683864f, -0.02221945f, 
    -0.05074599f, 0.03284623f, -0.05313250f, 0.03034120f, -0.03724671f, 0.00078319f, 0.01305198f, 0.00865334f, 
    0.01343776f, -0.01044812f, 0.01753790f, -0.02371323f, -0.03627368f, 0.03752889f, -0.05234877f, -0.03333260f, 
    0.00542737f, 0.02903417f, -0.03405804f, -0.03605639f, 0.01176425f, -0.00349269f, -0.00392694f, -0.03000442f, 
    -0.04910886f, -0.05784261f, -0.03330788f, -0.00263889f, 0.04169049f, -0.03174417f, 0.04562323f, 0.01711754f, 
    -0.05014873f, 0.03941115f, 0.02179588f, -0.02790486f, 0.00970888f, 0.00180087f, 0.02428165f, -0.03960162f, 
    0.01735137f, -0.04751686f, -0.01878419f, 0.03793646f, -0.04105955f, -0.05547527f, 0.03490086f, -0.05722425f, 
    -0.02568673f, -0.06067728f, 0.01985742f, -0.02005320f, 0.00263220f, -0.03457452f, 0.00911321f, 0.01725591f, 
    -0.00512637f, -0.00908184f, -0.05460327f, 0.00890056f, -0.01962373f, 0.03857131f, 0.03642241f, -0.03702161f, 
    0.03130321f, -0.05619868f, -0.05206086f, -0.02438639f, -0.04414535f, 0.00652869f, 0.03269776f, 0.00737284f, 
    -0.04413661f, 0.02752040f, -0.04582235f, -0.01717151f, 0.00723662f, -0.03628683f, -0.04960276f, -0.05812049f, 
    0.02679503f, 0.00660335f, -0.04361678f, -0.04276113f, 0.00742029f, 0.01899874f, 0.02641103f, -0.01438822f, 
    -0.03805674f, 0.02897071f, -0.03719792f, 0.03581160f, -0.05292075f, -0.03189325f, -0.01473176f, 0.04733963f, 
    -0.01119015f, -0.05557589f, -0.02396401f, -0.03225042f, 0.03443598f, -0.04188728f, 0.03431745f, -0.03070295f, 
    0.02747748f, -0.04547735f, 0.02612652f, 0.01536506f, -0.02544813f, -0.02077314f, -0.03449869f, 0.00562052f, 
    -0.00334213f, 0.01435192f, 0.01274598f, 0.01074704f, 0.00502354f, -0.02472135f, 0.03812188f, -0.00782148f, 
    -0.00903255f, 0.03232315f, -0.04793360f, -0.03719202f, -0.02514579f, -0.03906134f, -0.02499145f, 0.00960237f, 
    -0.03280594f, 0.01231803f, 0.03477412f, 0.03321205f, 0.00584578f, -0.04262893f, -0.00641734f, -0.01199628f, 
    0.00747493f, -0.02203679f, -0.00443000f, 0.03167708f, 0.00467825f, -0.03028729f, -0.03718816f, 0.03921229f, 
    0.01495528f, -0.02512766f, 0.02845920f, -0.02112831f, -0.00001277f, -0.04593677f, -0.02845303f, -0.02369894f, 
    -0.04703430f, -0.02220365f, 0.01950314f, -0.00015108f, 0.03905708f, -0.00151508f, -0.05975467f, 0.04524180f, 
    -0.01455398f, 0.03317194f, -0.01184342f, 0.03499256f, -0.04289587f, -0.00797169f, -0.02965638f, -0.00905425f, 
    -0.04231173f, -0.02015627f, -0.02785647f, 0.03567893f, -0.01657952f, 0.00598823f, 0.02599676f, -0.03514857f, 
    0.02330576f, 0.00304211f, 0.00614719f, -0.00035491f, 0.02790566f, 0.02979406f, -0.00341130f, 0.02361198f, 
    -0.02880983f, -0.00839952f, 0.02562328f, -0.03592452f, 0.00050278f, -0.05778856f, -0.03906817f, 0.03908718f, 
    -0.01051896f, -0.00080249f, 0.02429878f, -0.05701546f, -0.03384257f, 0.00353335f, -0.04744699f, -0.05963937f, 
    0.01703038f, 0.01909473f, -0.02631915f, 0.02786615f, -0.02710483f, 0.03978203f, -0.01558051f, 0.00096459f, 
    -0.02245225f, 0.02883499f, -0.04941026f, 0.03274121f, 0.03721874f, -0.03560273f, -0.05078754f, 0.04497440f, 
    -0.01878192f, -0.03262355f, -0.00871386f, -0.00982564f, 0.01972207f, -0.04740539f, 0.03540697f, -0.01968615f, 
    0.00624007f, 0.03139744f, -0.01999586f, -0.01287361f, -0.01633504f, 0.01183635f, 0.00563019f, -0.02810432f, 
    0.03972493f, 0.00438920f, -0.02263848f, -0.04545520f, -0.01234186f, -0.00942396f, -0.01685227f, -0.05585415f, 
    -0.03253954f, 0.00310858f, 0.01230008f, -0.04893287f, -0.02699773f, 0.03715967f, -0.02866266f, 0.02279340f, 
    -0.02206280f, 0.03027242f, -0.00710883f, 0.02305540f, 0.00234124f, 0.01907261f, -0.00157517f, -0.00363437f, 
    0.00213579f, 0.04428793f, -0.05575183f, -0.03962301f, -0.03572558f, -0.04502041f, -0.00942239f, 0.01112393f, 
    0.04085616f, -0.02695401f, -0.02171554f, -0.03957463f, -0.02504765f, -0.01168630f, 0.02106036f, -0.00215985f, 
    -0.00372126f, -0.05200403f, -0.01216940f, 0.02149383f, 0.03485542f, -0.01209738f, 0.02780265f, 0.00412800f, 
    0.00703925f, -0.03127892f, -0.05715040f, 0.01333374f, 0.00196585f, 0.03605546f, 0.01897469f, -0.03642228f, 
    0.00684058f, -0.05922371f, 0.02608245f, -0.05140844f, 0.01541217f, -0.03506251f, -0.01502027f, -0.03575198f, 
    0.03236486f, 0.01632551f, -0.02504250f, -0.03254387f, -0.05850754f, 0.02517705f, 0.00825295f, -0.03844103f, 
    -0.07672683f, -0.05207291f, 0.34396979f, 0.03162171f, 0.03514949f, -0.14213945f, -0.07348256f, -0.08438813f, 
    0.01448262f, -0.07800079f, 0.13516711f, -0.01167379f, 0.03561426f, 0.01626221f, 0.16461715f, -0.28142491f, 
    0.02767134f, 0.14672613f, -0.04713085f, 0.11397451f, 0.17963487f, -0.00521531f, 0.13136972f, -0.01042781f, 
    -0.26559833f, -0.45298657f, -0.28430834f, 0.40133440f, 0.12605137f, 0.09014734f, -0.17382325f, -0.04401065f, 
    0.12651092f, -0.01550937f, -0.00281469f, 0.17477502f, -0.02204411f, 0.30285615f, 0.32556975f, 0.02696696f, 
    0.00559184f, 0.13917737f, 0.10944254f, 0.12074796f, 0.05455793f, -0.21597338f, -0.22233701f, -0.09906866f, 
    0.01450149f, 0.11097976f, -0.15367445f, -0.06366026f, 0.16722676f, 0.05762708f, 0.07866395f, 0.09538141f, 
    -0.06546766f, -0.00564496f, -0.07068782f, -0.15192777f, 0.22241710f, 0.02888624f, 0.10356192f, 0.17991798f, 
    -0.10555103f, -0.02543872f, -0.02010282f, -0.07646767f, 0.21032186f, -0.12625913f, 0.10688824f, 0.10121787f, 
    -0.24501355f, 0.13579041f, 0.14056844f, 0.09939558f, -0.05547931f, 0.06011237f, 0.22910708f, -0.30605024f, 
    0.08544914f, 0.00651529f, 0.12813410f, 0.27878085f, -0.05198143f, -0.06423735f, -0.13131806f, -0.19882242f, 
    -0.02839280f, 0.02749445f, -0.13597938f, 0.02163433f, 0.14015900f, 0.06200321f, 0.01547704f, 0.08611566f, 
    0.23659046f, 0.03576594f, 0.14650629f, 0.00788881f, 0.15310298f, -0.02253305f, 0.22512788f, 0.01246568f, 
    -0.01810615f, 0.04130267f, -0.01981094f, 0.23644538f, 0.11748050f, -0.00318975f, 0.33682811f, 0.18045840f, 
    -0.17977782f, -0.13788627f, -0.16944091f, -0.23793985f, 0.10954018f, 0.00906898f, -0.06181569f, 0.10478910f, 
    -0.12922299f, -0.14078009f, -0.11180212f, 0.34918904f, -0.05580647f, 0.12446744f, -0.07479294f, -0.10024390f, 
    0.10644393f, -0.16012980f, 0.03646516f, 0.17161551f, -0.25329804f, 0.13138889f, 0.10695982f, -0.08358780f, 
    0.13131954f, 0.04514887f, 0.12567227f, 0.03452758f, -0.07196324f, -0.12201604f, -0.02460995f, -0.28662169f, 
    -0.08316031f, 0.13097957f, 0.18299010f, -0.14084725f, 0.21236876f, 0.02190989f, 0.00155353f, 0.19825765f, 
    0.01914728f, -0.04193773f, 0.04842836f, 0.13500917f, 0.01844915f, 0.21020322f, 0.19462575f, 0.13186014f, 
    0.02972768f, -0.14809072f, 0.01302554f, 0.12946746f, -0.27618980f, 0.00401972f, -0.14672482f, -0.19744168f, 
    0.07800829f, -0.12145083f, -0.37174422f, -0.11371980f, 0.11976196f, 0.09677480f, -0.01263442f, 0.04658237f, 
    0.06281079f, -0.06079050f, -0.05167071f, -0.00143198f, 0.25641420f, -0.01909628f, -0.15306531f, -0.08686675f, 
    -0.04581490f, 0.18347512f, 0.01669391f, 0.22216858f, -0.12028528f, -0.06387045f, -0.16042957f, -0.08411426f, 
    0.22822660f, 0.01731220f, -0.03192198f, -0.06331842f, 0.10318985f, 0.20062396f, 0.08884943f, 0.13978904f, 
    0.11424941f, -0.04128294f, 0.02670190f, -0.03230103f, -0.23866196f, -0.21103849f, 0.12339877f, -0.07781849f, 
    0.00163209f, 0.04101624f, -0.03579328f, -0.15510562f, 0.14518563f, 0.36145258f, 0.22169200f, 0.05823832f, 
    0.01887041f, -0.15357210f, 0.19116817f, -0.26299861f, 0.12127657f, 0.02543705f, -0.19254300f, 0.17959547f, 
    0.09025559f, -0.01817051f, 0.03403796f, -0.09506622f, 0.04408801f, 0.32633793f, -0.10863071f, 0.08139672f, 
    0.22056384f, 0.15687416f, 0.27045888f, 0.13916874f, -0.16415623f, 0.07655805f, -0.13509758f, -0.00882747f, 
    0.16516700f, 0.15416701f, 0.04453085f, -0.18241076f, 0.17629693f, 0.18588451f, 0.15815511f, 0.08922830f, 
    0.00296683f, -0.06083057f, 0.09939660f, 0.16105410f, -0.21900122f, -0.02276821f, -0.26521444f, -0.02179913f, 
    0.11633726f, 0.16670397f, 0.15484993f, 0.13808228f, -0.21249275f, -0.21836220f, -0.18782812f, -0.40612099f, 
    -0.27033746f, -0.11479318f, -0.08728114f, 0.10153526f, -0.19800714f, -0.18182777f, -0.16304760f, -0.29819295f, 
    0.15221618f, -0.08185811f, 0.04646470f, 0.03557238f, 0.15232950f, -0.08150712f, -0.11695258f, -0.09738504f, 
    0.07655107f, -0.02408982f, 0.07958914f, 0.16804102f, -0.05195924f, 0.21685550f, 0.01271027f, 0.09846466f, 
    -0.20849817f, 0.20014074f, -0.11062053f, -0.09296146f, 0.06531055f, -0.02284375f, 0.34562954f, -0.10100204f, 
    0.13031550f, 0.08478124f, 0.09015400f, 0.17972815f, -0.01987038f, -0.02014964f, -0.07451046f, -0.08372372f, 
    -0.03021424f, -0.15932512f, -0.09495895f, -0.12601732f, 0.16724031f, 0.07074973f, 0.04946532f, 0.08221732f, 
    0.57200140f, -0.23081219f, 0.22312510f, -0.23104602f, 0.00043316f, 0.16236940f, 0.01450171f, -0.04657275f, 
    0.07336878f, -0.03116246f, 0.02425779f, -0.14143172f, -0.04067912f, -0.19944650f, 0.03647098f, 0.16038994f, 
    0.11855281f, 0.09600794f, 0.08366408f, 0.00480708f, 0.01042886f, 0.03851192f, -0.18359125f, -0.03400473f, 
    -0.00568700f, -0.09272946f, -0.24664430f, -0.43180817f, 0.05415712f, 0.08724594f, 0.05679252f, 0.20552641f, 
    0.03284404f, -0.04049288f, 0.04109445f, -0.00813549f, -0.12051439f, -0.21011591f, 0.38656685f, 0.17570712f, 
    -0.13689223f, 0.13350824f, 0.10897036f, -0.01416128f, 0.04327829f, -0.08199724f, 0.17861193f, -0.04467941f, 
    -0.08009019f, -0.07257476f, -0.00018543f, 0.00189157f, -0.11051209f, 0.02238653f, -0.17556295f, 0.14229316f, 
    0.13942276f, 0.18164226f, 0.06917998f, 0.00138390f, -0.00013138f, -0.00866999f, -0.07280502f, -0.04904678f, 
    0.00115076f, 0.08926079f, 0.15377730f, -0.17119084f, -0.05340956f, 0.32567915f, 0.07173501f, -0.06632218f, 
    -0.12824661f, -0.13387233f, 0.01653591f, 0.11445169f, 0.06260503f, 0.00737215f, 0.02884884f, 0.09876364f, 
    -0.05962093f, 0.17205571f, -0.16289891f, 0.06410483f, 0.54857177f, -0.14948253f, -0.18038251f, -0.09140993f, 
    0.02458560f, 0.08799670f, -0.01522993f, -0.05088024f, 0.14619139f, 0.16556120f, -0.20593111f, 0.01385138f, 
    0.42865291f, -0.04707503f, 0.01483762f, -0.30964217f, -0.32261920f, -0.03829698f, -0.12754987f, 0.18411864f, 
    -0.02089384f, 0.08561821f, 0.10810555f, -0.05391806f, -0.04342001f, -0.06397121f, 0.07445331f, 0.26229343f, 
    -0.00004850f, -0.10849865f, -0.03063037f, 0.05620647f, 0.07713356f, -0.02188927f, -0.04425798f, 0.05407302f, 
    0.22417416f, 0.38960427f, 0.44165033f, 0.04861615f, 0.20065531f, -0.03026866f, -0.04822293f, 0.18910596f, 
    0.04544843f, -0.11277968f, 0.04237208f, -0.13442895f, -0.36393294f, -0.29728052f, -0.17545573f, 0.00446995f, 
    -0.02595652f, 0.11891910f, 0.05109720f, 0.06998457f, 0.01483440f, -0.17017236f, -0.22522862f, -0.00841497f, 
    -0.32058769f, 0.22063793f, 0.25679961f, -0.07100894f, -0.09327452f, 0.30116898f, -0.11272716f, 0.05349514f, 
    0.15617926f, -0.00485437f, 0.05658087f, 0.04666094f, -0.08210404f, 0.03628713f, -0.05505978f, 0.03325212f, 
    -0.00737478f, -0.00254095f, -0.04592209f, 0.00668678f, 0.03791842f, 0.12820746f, 0.05212497f, -0.05303679f, 
    0.03360499f, 0.08833335f, 0.14343369f, 0.04585002f, -0.03164004f, 0.41517207f, -0.08640787f, 0.00128964f, 
    0.14164856f, 0.19271460f, -0.04016578f, -0.19153567f, -0.07999139f, -0.22564033f, -0.26779336f, 0.20526296f, 
    -0.07616268f, 0.00740196f, 0.05597716f, 0.09391505f, -0.03249382f, -0.08709859f, -0.05489193f, 0.11229032f, 
    -0.21783672f, -0.15513214f, 0.05970499f, -0.03811126f, -0.01538026f, -0.03211977f, -0.02734063f, 0.06374929f, 
    0.04939638f, -0.05042678f, 0.12116158f, 0.07967384f, -0.10102484f, 0.36246121f, 0.24912442f, -0.05513235f, 
    0.04235399f, -0.10945118f, 0.02523514f, -0.02148191f, -0.03617178f, 0.00916834f, -0.03569923f, 0.03405655f, 
    0.10742741f, 0.33400860f, 0.45272174f, 0.18351787f, 0.00759550f, 0.08655432f, 0.08759899f, 0.15325288f, 
    0.00507196f, 0.01165767f, -0.01111741f, 0.02947893f, 0.12000860f, 0.22973983f, 0.23044138f, 0.04964638f, 
    -0.04390218f, -0.19224514f, -0.10859704f, -0.01344980f, 0.04059412f, 0.04045595f, 0.03217599f, 0.00324259f, 
    -0.18023418f, 0.30645397f, 0.21644658f, -0.23448943f, -0.06221367f, -0.00006030f, -0.03396755f, 0.31566179f, 
    -0.11468321f, 0.09394730f, 0.17389381f, 0.05725797f, 0.18705708f, 0.22278748f, 0.05477202f, -0.04428470f, 
    -0.01047241f, -0.12245667f, -0.01229626f, 0.01002964f, -0.15308113f, -0.12407604f, 0.00270079f, -0.04098718f, 
    -0.07477427f, 0.29336461f, 0.33269000f, 0.25944477f, -0.01087528f, 0.08142552f, -0.01443795f, -0.01458584f, 
    -0.06326207f, -0.12107235f, 0.00921848f, 0.07916671f, -0.13009696f, 0.16169576f, -0.01134408f, -0.05411519f, 
    0.02099436f, 0.04353390f, 0.07623199f, 0.05947820f, 0.02307334f, 0.03189486f, -0.04322721f, -0.07052348f, 
    0.24409688f, 0.10780249f, -0.06487261f, 0.00352751f, 0.03360593f, -0.00317779f, -0.01245341f, -0.13364203f, 
    0.02903950f, 0.05455962f, 0.00567639f, 0.02672407f, 0.02231805f, 0.38151264f, 0.40685838f, 0.16451697f, 
    -0.03974589f, -0.13620850f, -0.08788171f, -0.01319698f, -0.00950477f, -0.00388469f, -0.00112180f, 0.00969843f, 
    0.27242821f, 0.31751141f, 0.18329988f, -0.00414010f, 0.08689260f, 0.15471880f, -0.02233504f, 0.12253079f, 
    0.00783120f, -0.07543260f, -0.04956316f, 0.02498717f, 0.06129995f, -0.03904124f, -0.12347239f, -0.05903345f, 
    0.05483181f, -0.08166455f, -0.11355019f, 0.00587367f, 0.00674872f, -0.09179249f, 0.06458458f, 0.28938222f, 
    0.13784829f, -0.25070113f, -0.15082394f, -0.03482991f, -0.04688073f, -0.02533203f, -0.06670137f, 0.03734547f, 
    -0.06149499f, -0.05588445f, -0.02861045f, 0.00253072f, -0.19156952f, -0.12889424f, 0.17032629f, 0.21376549f, 
    -0.08610556f, 0.02263215f, 0.07027546f, -0.02564735f, 0.02863511f, 0.03655939f, -0.01781068f, 0.01151720f, 
    0.06797138f, 0.25017032f, 0.24145579f, 0.02498332f, 0.03369182f, 0.09485703f, -0.06849629f, -0.03265118f, 
    -0.08631404f, -0.02422421f, 0.00811635f, 0.10197024f, -0.07825103f, -0.04033290f, 0.27685243f, -0.12035062f, 
    -0.04238237f, 0.04273927f, 0.10973549f, 0.08788885f, -0.14997022f, 0.03794627f, -0.08684031f, -0.21427342f, 
    -0.36718240f, 0.39561391f, 0.21596508f, -0.17628729f, 0.00025214f, -0.09544969f, 0.10245199f, 0.06683452f, 
    -0.04918057f, -0.08646674f, 0.09847965f, 0.09971581f, -0.08799393f, -0.13763958f, -0.03876654f, -0.14866795f, 
    -0.04788098f, -0.13217326f, 0.07050464f, -0.00726459f, 0.02662166f, 0.11265533f, 0.01538080f, -0.05153201f, 
    0.30851457f, 0.19702657f, 0.06554050f, 0.00039074f, -0.07191662f, 0.10438381f, -0.10686200f, 0.01361970f, 
    0.15406743f, -0.02986063f, -0.11258382f, -0.20757611f, -0.34946713f, 0.10991672f, -0.00860393f, 0.22167946f, 
    -0.04570220f, 0.05331044f, 0.15890212f, 0.03466665f, 0.02345059f, -0.05958924f, -0.10616440f, 0.10106126f, 
    -0.00279886f, 0.26862049f, -0.02550213f, 0.10187328f, -0.02010206f, 0.07061271f, 0.14120710f, 0.03670128f, 
    0.06742388f, 0.03477128f, 0.01777930f, -0.10963434f, 0.03117883f, 0.10155516f, 0.02813437f, 0.10757865f, 
    -0.04103667f, 0.02911387f, -0.00697585f, 0.01090152f, -0.03591860f, -0.03784364f, -0.08105779f, -0.07009674f, 
    -0.00804549f, 0.03233487f, 0.04353216f, 0.00460686f, 0.03209169f, 0.02083512f, 0.04372696f, -0.03803088f, 
    0.02118352f, -0.00054665f, -0.01415057f, 0.02583117f, 0.01594930f, -0.03954555f, 0.02942657f, -0.03825840f, 
    -0.03491582f, -0.03385469f, -0.00716533f, -0.03157569f, -0.01298916f, -0.05448854f, -0.01936005f, -0.04983967f, 
    -0.01513655f, 0.00250104f, 0.03344730f, 0.03434755f, -0.05231680f, -0.02033370f, -0.04555517f, 0.03163994f, 
    0.03262605f, 0.01293905f, -0.00533374f, 0.02506385f, 0.00318943f, 0.00496300f, -0.03025850f, -0.05863567f, 
    0.01147897f, -0.02851610f, -0.00212367f, 0.01243255f, -0.00190020f, 0.03011538f, -0.04030190f, -0.01028247f, 
    0.00627728f, 0.02151169f, 0.02789310f, 0.01978113f, -0.02652159f, -0.02457553f, -0.00004903f, 0.00569198f, 
    0.03330629f, 0.04210069f, -0.03883836f, 0.01300475f, -0.00290664f, 0.04963849f, 0.03590902f, -0.03072076f, 
    -0.01994532f, 0.00455254f, 0.01963988f, -0.01263319f, 0.04661152f, 0.02580707f, 0.01331654f, -0.03248916f, 
    0.01543671f, -0.01730508f, 0.00585842f, 0.04512603f, -0.05255666f, -0.02094371f, 0.03798386f, 0.02548383f, 
    0.02211159f, -0.01101907f, 0.03554754f, -0.04865649f, 0.04851915f, 0.03699752f, 0.03227248f, 0.03956069f, 
    0.02329275f, -0.01446794f, -0.04895987f, -0.01837660f, -0.03789319f, -0.04658710f, -0.02840341f, 0.02044682f, 
    -0.04796928f, -0.03494804f, 0.01639586f, -0.05666954f, -0.03967279f, -0.00531875f, 0.03295145f, 0.03732047f, 
    -0.01230707f, -0.01217861f, 0.04365271f, 0.01553875f, -0.02610401f, 0.00925989f, 0.01905102f, 0.00390580f, 
    -0.03541427f, -0.02850419f, -0.02647936f, -0.05447796f, -0.02610786f, 0.01146530f, -0.03110866f, -0.01871429f, 
    -0.04989685f, -0.01943150f, 0.01552648f, -0.04930095f, 0.02395572f, -0.00186514f, 0.01310430f, -0.00321450f, 
    0.03987424f, 0.01374623f, -0.00615299f, -0.05153384f, 0.03318550f, -0.02304242f, 0.03099880f, -0.02387516f, 
    -0.05039618f, 0.02531760f, -0.01932236f, 0.04070337f, -0.01021262f, -0.01988528f, -0.04417960f, 0.01340286f, 
    -0.02902172f, -0.03355046f, -0.04496334f, -0.04822716f, 0.03838442f, -0.02635284f, -0.04617012f, -0.06173818f, 
    0.03185120f, -0.05524318f, 0.02022172f, 0.04617792f, 0.00638591f, 0.01401475f, 0.03947480f, -0.01930370f, 
    0.01307223f, -0.05148773f, 0.00277800f, -0.00875422f, -0.01546367f, 0.02394606f, 0.01050652f, -0.00314974f, 
    0.03958387f, -0.03474859f, 0.03776324f, -0.00135118f, 0.04835295f, -0.01044121f, 0.00200243f, 0.04035521f, 
    0.02842801f, -0.03064883f, -0.00513475f, 0.01477811f, -0.01713986f, -0.04397617f, 0.01702999f, -0.03542801f, 
    -0.02114332f, -0.05020107f, -0.02399855f, -0.01380114f, -0.04695856f, -0.03564734f, 0.03979482f, 0.03779861f, 
    0.01159342f, -0.04213899f, -0.00856336f, -0.02029284f, 0.02527600f, 0.02326367f, 0.01893106f, 0.03906988f, 
    -0.02654362f, -0.05184007f, -0.03173952f, -0.01067294f, -0.04945190f, -0.05115699f, -0.03307113f, -0.02908170f, 
    0.00079198f, -0.05815946f, 0.04226048f, 0.02944055f, 0.03743729f, -0.03517122f, -0.03747698f, 0.02549903f, 
    -0.04316945f, -0.00468779f, -0.04361540f, 0.03332104f, 0.04255617f, -0.01278612f, 0.00663971f, -0.04816210f, 
    0.03456518f, 0.03178298f, 0.03609514f, -0.00226376f, -0.02658741f, 0.02214951f, 0.02118527f, 0.00313134f, 
    0.04448985f, -0.00810189f, 0.00886852f, -0.04684110f, 0.00205236f, 0.04137302f, -0.03835914f, -0.04331727f, 
    -0.01954528f, -0.03781370f, -0.04467103f, 0.01210324f, -0.01937418f, 0.03479161f, -0.02445252f, -0.03731888f, 
    0.00286526f, -0.01847110f, 0.01401275f, -0.00601685f, -0.03574748f, 0.00368462f, -0.00644304f, -0.04036113f, 
    0.01814828f, -0.02704711f, 0.03134036f, -0.02822986f, -0.03277702f, -0.03347107f, 0.03384030f, -0.04346845f, 
    0.05091200f, -0.04483657f, -0.04105696f, 0.04826337f, -0.01951686f, 0.04497792f, -0.03052105f, -0.00919028f, 
    -0.00221056f, 0.01814434f, -0.02128087f, 0.00751059f, -0.00494579f, -0.01489666f, -0.05652317f, 0.02325702f, 
    -0.00537152f, -0.01918247f, -0.02102068f, -0.03841040f, -0.04822031f, 0.04238771f, -0.02906577f, -0.04016672f, 
    -0.01142531f, 0.00174907f, -0.03031687f, -0.03810704f, 0.00042835f, -0.05054086f, -0.04837893f, 0.00922441f, 
    -0.00253743f, -0.00329656f, 0.01641957f, -0.00520253f, 0.03059543f, -0.04189907f, 0.02955562f, -0.02916111f, 
    0.00013876f, -0.02727344f, 0.02276644f, 0.00866928f, 0.01984729f, -0.02828752f, 0.01232965f, 0.04084828f, 
    -0.04668525f, 0.01548614f, -0.01919928f, 0.02299794f, -0.01117995f, -0.03876600f, 0.04212737f, -0.04702598f, 
    -0.01345073f, -0.02476627f, 0.02187305f, 0.00587343f, 0.04749890f, -0.03605456f, -0.01451805f, 0.01869891f, 
    -0.05056771f, 0.04383852f, 0.03706602f, 0.00170456f, -0.01870979f, 0.04464817f, -0.04153742f, 0.02125228f, 
    0.02051816f, 0.04116539f, 0.03804162f, -0.05124991f, -0.02776101f, -0.05337907f, -0.02602424f, -0.04574034f, 
    0.02600033f, 0.03826959f, 0.02831247f, 0.02993177f, -0.00428778f, 0.03814843f, -0.02073901f, 0.00105507f, 
    0.03896571f, -0.00832494f, 0.00313639f, 0.01703678f, -0.02243257f, 0.00424589f, -0.03758898f, 0.00975587f, 
    0.02497978f, -0.04374760f, -0.00224103f, -0.05298401f, -0.01324460f, -0.01629409f, -0.00599847f, -0.00066718f, 
    -0.01042424f, -0.04346801f, -0.04742658f, -0.02243770f, 0.00139690f, 0.04640800f, 0.00368759f, 0.02057667f, 
    0.00445933f, 0.03821741f, -0.00630924f, -0.03793677f, -0.01638492f, -0.02830829f, -0.01586208f, -0.00944861f, 
    -0.01448268f, -0.03547955f, 0.01311922f, -0.00932419f, 0.02041983f, -0.02216219f, -0.04616342f, -0.01047059f, 
    -0.02192375f, -0.04000244f, -0.04492797f, -0.01847479f, -0.03376212f, -0.04306595f, -0.02655126f, -0.03086446f, 
    0.02319877f, 0.01381026f, -0.00741696f, -0.02782772f, -0.03795739f, 0.02440216f, -0.01061075f, 0.00808273f, 
    0.00014507f, 0.03721794f, -0.01056399f, -0.01984050f, -0.04116098f, -0.03239627f, 0.03632263f, 0.01379645f, 
    0.04152497f, -0.04265517f, 0.01028580f, -0.05334636f, -0.02028542f, -0.04902265f, -0.03734122f, -0.05303835f, 
    -0.03022277f, -0.00357196f, -0.02402035f, 0.03423011f, -0.02947271f, -0.05324467f, 0.02272612f, 0.03680586f, 
    0.03906725f, -0.00357555f, 0.02722439f, -0.04312063f, 0.03042105f, 0.02249552f, -0.01506133f, -0.05557590f, 
    0.00110331f, 0.02392304f, -0.00323758f, 0.03661061f, -0.03750156f, -0.04003664f, -0.00880982f, 0.04159129f, 
    -0.02915521f, -0.04366458f, 0.02293157f, -0.01815663f, -0.05402841f, 0.03989617f, 0.04229562f, -0.00204987f, 
    0.03417337f, -0.02279644f, 0.00563039f, 0.02377715f, 0.03081231f, -0.02671547f, -0.04695922f, -0.04434898f, 
    -0.04729309f, 0.00447559f, -0.02923240f, 0.03884869f, 0.01657188f, 0.01975265f, -0.04285872f, 0.02395691f, 
    -0.00566617f, -0.03510354f, -0.05181926f, -0.00450115f, -0.05515296f, 0.00934053f, 0.04775266f, 0.01235015f, 
    0.04139116f, -0.02643661f, -0.05325297f, -0.04114752f, 0.04506594f, 0.03768677f, 0.01606245f, 0.00045814f, 
    0.01541063f, 0.01208994f, -0.00219942f, -0.03283855f, -0.01892862f, 0.01037396f, -0.03772124f, -0.03584256f, 
    -0.03680583f, 0.00161033f, 0.02505544f, 0.04129960f, -0.05023382f, 0.00175702f, -0.02804868f, 0.01461995f, 
    -0.01528475f, -0.00563375f, -0.05093886f, -0.01417837f, 0.00531300f, -0.03906083f, 0.02692930f, -0.04901683f, 
    0.01199686f, 0.01890369f, 0.00913137f, -0.00304086f, -0.01532788f, -0.05142352f, 0.02341934f, -0.00344853f, 
    -0.03306394f, -0.03327646f, -0.05185612f, -0.02017747f, -0.04275722f, -0.00478730f, 0.03552382f, 0.00959655f, 
    0.01239799f, -0.05520082f, -0.01279913f, -0.04307662f, -0.04231418f, -0.01708359f, 0.01477624f, 0.02785749f, 
    0.04110554f, 0.02991862f, -0.05588484f, 0.01559217f, 0.03821004f, -0.04930240f, 0.00809790f, -0.02615319f, 
    -0.05118002f, -0.01560726f, -0.03336539f, -0.04930314f, -0.04710210f, 0.02913906f, -0.01581152f, 0.03411203f, 
    0.03869399f, 0.03404212f, 0.04517036f, -0.05634062f, -0.01213182f, -0.05498141f, 0.02449200f, -0.05180574f, 
    0.04000470f, 0.02166676f, -0.03705283f, -0.00290740f, 0.02387551f, 0.01672669f, -0.02168837f, -0.04619758f, 
    0.00776465f, -0.05966462f, -0.05164332f, 0.01430439f, 0.02087218f, 0.04155839f, 0.00145686f, -0.01033244f, 
    -0.04965688f, 0.00367586f, -0.01739959f, 0.01152337f, -0.03148196f, 0.03832418f, -0.03433452f, 0.00950688f, 
    -0.00155441f, 0.00769281f, 0.01720271f, 0.04261123f, -0.01660540f, -0.04887191f, -0.01949829f, 0.03040981f, 
    0.00024734f, -0.03504546f, -0.03756808f, -0.00682061f, -0.02731563f, -0.00332283f, 0.00870503f, -0.05171333f, 
    -0.01871533f, -0.01143713f, 0.03109352f, 0.01328798f, -0.02857309f, -0.04144037f, -0.02790661f, 0.00475937f, 
    -0.03675384f, -0.04784450f, 0.04388026f, 0.01545962f, -0.01589381f, 0.02409224f, -0.04977245f, -0.04659817f, 
    -0.04969658f, -0.02608584f, -0.03462116f, -0.05441546f, 0.02860801f, -0.02649124f, 0.02890133f, -0.01631368f, 
    0.01998724f, 0.01827540f, -0.01259078f, 0.01369006f, 0.02833790f, 0.03447212f, 0.02796417f, -0.02623332f, 
    -0.01828024f, 0.04019299f, -0.00017077f, -0.04739794f, -0.03280612f, 0.00416611f, 0.00295232f, -0.03257878f, 
    -0.03206349f, 0.00460560f, 0.03552866f, -0.01910434f, -0.01711621f, -0.03997167f, 0.01420038f, 0.02325488f, 
    -0.01740974f, 0.00423949f, 0.00657538f, 0.00879157f, 0.02002086f, -0.02419694f, -0.01292754f, 0.01634184f, 
    -0.04298626f, -0.05201176f, -0.01279155f, -0.01794568f, 0.01543310f, 0.02600486f, 0.04421719f, -0.03848147f, 
    -0.04622709f, 0.01105200f, -0.05074081f, -0.02742952f, 0.03350671f, -0.02074747f, -0.02973945f, -0.01514862f, 
    0.04429859f, -0.01170308f, 0.04303555f, -0.05280142f, 0.00793431f, -0.03583771f, 0.00737186f, 0.00593835f, 
    -0.01921585f, -0.00507584f, -0.02432585f, 0.01400140f, -0.05461482f, 0.03879921f, -0.03127061f, 0.03006854f, 
    -0.01969391f, 0.01014808f, 0.01264334f, -0.01059411f, 0.03888881f, 0.01517328f, -0.04857257f, 0.01815670f, 
    0.00808882f, 0.03723663f, -0.01082887f, -0.05104713f, -0.00095617f, -0.04216158f, -0.01815196f, -0.03767380f, 
    0.02830462f, -0.00000217f, -0.04786967f, -0.02098341f, 0.00851405f, 0.00924535f, -0.01566336f, 0.02476936f, 
    -0.03841627f, -0.02069165f, -0.04621804f, -0.01357129f, 0.01314531f, 0.02550215f, 0.00535825f, -0.02539625f, 
    -0.05201438f, -0.00940382f, -0.00775944f, -0.01474353f, -0.04218599f, -0.03369701f, 0.02439810f, -0.01247458f, 
    -0.00283526f, -0.04404905f, 0.00381221f, 0.02219096f, -0.01974730f, 0.03727793f, -0.01288835f, -0.01293796f, 
    -0.04981850f, -0.03834357f, 0.03968948f, -0.05377686f, -0.00133912f, -0.03247299f, -0.01856568f, -0.01616670f, 
    0.00136029f, 0.00817993f, -0.01722439f, -0.03375764f, -0.01218911f, -0.03119497f, 0.00323965f, -0.05169330f, 
    -0.03634377f, 0.00920948f, 0.00155455f, 0.03899233f, 0.01000940f, -0.01870177f, -0.03009617f, -0.01966875f, 
    -0.02662644f, -0.00129228f, 0.01379419f, -0.01810279f, -0.04658510f, 0.03311859f, 0.03620281f, -0.02008686f, 
    -0.00645266f, 0.11155955f, 0.19031101f, -0.19868073f, -0.04523045f, 0.06621292f, -0.13960448f, 0.02387565f, 
    -0.07054858f, -0.00648248f, -0.14875273f, -0.00859085f, 0.14190321f, 0.05108947f, -0.14561558f, 0.05829870f, 
    0.04826253f, 0.02384645f, -0.15739462f, -0.19892232f, 0.02874433f, -0.06951152f, 0.10968120f, 0.15704057f, 
    0.14508286f, -0.15007143f, 0.04697492f, -0.03968140f, 0.03123465f, 0.07117825f, 0.13840988f, 0.04058518f, 
    0.01167937f, -0.02689737f, 0.12928030f, 0.00351558f, 0.26016167f, -0.35703442f, 0.18990819f, 0.16901921f, 
    -0.07592702f, -0.09201296f, -0.02424233f, 0.01963693f, -0.01048523f, 0.01375975f, -0.20354457f, -0.09801938f, 
    -0.08424935f, 0.01794291f, -0.09712350f, 0.12809512f, 0.11621010f, -0.05343667f, -0.07710953f, 0.13768697f, 
    -0.11627752f, -0.02116005f, -0.01828315f, 0.00878851f, 0.02717029f, 0.21330889f, 0.07590614f, -0.05916470f, 
    -0.01762470f, -0.03892872f, -0.00197254f, 0.15488936f, -0.10500065f, -0.09325461f, -0.06567648f, -0.14996834f, 
    -0.04720478f, 0.11856387f, -0.19532306f, 0.25374123f, -0.22447042f, -0.13930123f, 0.27327746f, 0.05392357f, 
    0.05541177f, -0.04225523f, 0.00365315f, 0.13800330f, 0.09838882f, -0.04567941f, -0.01558184f, -0.07047417f, 
    0.12292421f, 0.03761492f, -0.00225502f, -0.08846106f, 0.19665231f, 0.10775072f, -0.03768104f, 0.00951733f, 
    -0.29399180f, 0.11965737f, 0.05969733f, 0.01759098f, -0.18740875f, -0.00246138f, 0.15923336f, -0.06890199f, 
    0.05225615f, -0.04104355f, 0.02579541f, 0.00895367f, 0.30671087f, -0.29316604f, 0.31600493f, -0.15588486f, 
    -0.00207015f, 0.08143918f, -0.00608069f, 0.02946396f, -0.10573886f, 0.01762122f, 0.08228940f, 0.00063600f, 
    0.03450754f, 0.01051025f, -0.10859908f, 0.13726322f, 0.06610050f, 0.00159457f, -0.01982256f, -0.03467787f, 
    0.03950483f, -0.03440140f, -0.03056092f, 0.07498724f, -0.08411534f, -0.21459632f, -0.02430297f, 0.22527556f, 
    0.03218985f, -0.06016459f, -0.14528990f, -0.05244427f, -0.08799635f, -0.00935776f, -0.10477220f, -0.02589483f, 
    0.08019498f, 0.16352475f, 0.17406508f, 0.32927358f, -0.02675233f, 0.00206407f, 0.05319340f, 0.02085109f, 
    0.02989458f, 0.05820110f, 0.16255955f, -0.01887171f, -0.12471934f, 0.10546924f, -0.08034320f, 0.16471444f, 
    -0.06516072f, 0.25359845f, 0.02530320f, 0.04402043f, -0.01264787f, -0.05583175f, -0.06840208f, 0.17660679f, 
    -0.14058106f, 0.02816994f, -0.13045759f, 0.20278399f, -0.01556217f, 0.20031603f, 0.04966854f, 0.16344571f, 
    0.04299151f, 0.08132342f, -0.02344302f, 0.04548281f, 0.28531349f, 0.14738008f, -0.15182151f, 0.18756607f, 
    0.06572556f, -0.06892960f, 0.09733180f, 0.12336131f, -0.07925917f, 0.02049086f, -0.03106937f, -0.15523235f, 
    -0.10347758f, 0.06586611f, 0.26962602f, 0.27593088f, -0.03744227f, 0.18100783f, 0.10824306f, 0.05249736f, 
    -0.12759624f, -0.01691462f, -0.03892034f, 0.14588267f, 0.23933883f, 0.33079222f, -0.10398588f, 0.01791767f, 
    -0.02501788f, -0.15629038f, 0.14209619f, 0.03820229f, 0.07277090f, 0.01804936f, -0.10766152f, 0.04371916f, 
    0.14489198f, 0.09094885f, 0.09253551f, 0.06641585f, 0.04531680f, 0.06057168f, -0.09483504f, -0.02402775f, 
    -0.02988726f, -0.00549861f, 0.21372701f, 0.04016981f, -0.30028272f, 0.25934854f, 0.09594609f, 0.28953797f, 
    -0.26574996f, 0.02006958f, -0.25059667f, -0.08966283f, -0.04430499f, 0.05342975f, -0.10740709f, 0.00180980f, 
    0.09071795f, -0.14647125f, 0.07550471f, 0.16266407f, 0.02816412f, 0.01493739f, 0.08566498f, 0.00666271f, 
    -0.02360379f, -0.06427254f, 0.07115312f, 0.04293067f, 0.05742352f, 0.06435065f, -0.01369885f, 0.04264263f, 
    -0.06568249f, -0.02389890f, 0.15114962f, -0.09459911f, -0.03760718f, 0.05277640f, -0.09371985f, 0.10357796f, 
    -0.03119669f, 0.14042887f, -0.05598369f, 0.04714593f, -0.01151841f, 0.09928866f, 0.03241482f, -0.08322927f, 
    0.19184203f, 0.06722463f, -0.00068576f, 0.05311295f, 0.06359795f, 0.12909983f, -0.16650839f, -0.25240785f, 
    -0.06671121f, 0.11637508f, -0.17137390f, -0.05331888f, -0.13812357f, 0.07272738f, -0.06115174f, -0.02917937f, 
    -0.22853066f, -0.02568416f, -0.16607003f, 0.08473493f, -0.07832406f, 0.05228377f, 0.19572392f, 0.06066562f, 
    0.00613332f, 0.09618471f, -0.10813194f, -0.00173710f, 0.14372391f, 0.10947832f, 0.18824230f, -0.04550071f, 
    0.03773377f, -0.02883433f, -0.01427770f, 0.00002464f, -0.02617685f, 0.12259775f, 0.17575283f, 0.11091441f, 
    -0.39659032f, -0.43698245f, 0.23519008f, 0.17138180f, 0.13793917f, 0.35280818f, 0.01380760f, 0.16369797f, 
    0.09048172f, 0.00546950f, -0.02799153f, 0.05107696f, -0.17424922f, -0.36043930f, 0.01305781f, 0.09746980f, 
    -0.13722302f, 0.03700622f, -0.05764469f, 0.00843610f, 0.00999414f, 0.06419483f, -0.04629102f, 0.05547806f, 
    0.31628525f, 0.19812687f, 0.27056178f, 0.14342500f, 0.01204531f, -0.04947292f, -0.02519463f, 0.04457100f, 
    0.11961139f, 0.08666626f, 0.00106068f, 0.02998426f, 0.09997237f, 0.14600317f, 0.08189291f, 0.00425690f, 
    -0.07077654f, 0.08653985f, -0.05138237f, -0.01666654f, -0.01122866f, 0.01187255f, -0.22659755f, 0.25988865f, 
    0.27459192f, 0.10857100f, -0.05383875f, -0.15526552f, -0.18940744f, 0.11241858f, -0.01794533f, -0.01920332f, 
    -0.06438918f, 0.26385966f, 0.09062234f, -0.02854882f, 0.10881317f, 0.04219053f, 0.06622596f, 0.04802501f, 
    -0.10116963f, -0.01841831f, 0.05960497f, 0.02628244f, 0.09791359f, 0.09575912f, 0.03336827f, -0.03351715f, 
    0.28343967f, -0.01494593f, -0.16662729f, -0.12458915f, -0.04858688f, 0.02470230f, 0.03794653f, 0.01407418f, 
    -0.00394413f, -0.06767599f, 0.01179377f, 0.18363403f, 0.00289370f, -0.18935767f, -0.14023982f, 0.12449851f, 
    0.01920064f, 0.10855900f, 0.04832818f, 0.06153990f, 0.21319290f, 0.14715618f, 0.02898947f, 0.03339135f, 
    0.42679483f, 0.15177925f, 0.12314879f, 0.27375746f, -0.07401611f, -0.10585985f, 0.01554065f, -0.07549360f, 
    0.02339452f, -0.01779455f, 0.00883890f, 0.01575784f, 0.48153260f, -0.03983466f, -0.03985474f, -0.25801787f, 
    -0.07178758f, 0.05335258f, 0.09445757f, 0.06570687f, -0.01662200f, -0.01174768f, 0.12213363f, 0.00507848f, 
    -0.06370866f, -0.70888186f, -0.88990158f, -0.53873485f, 0.02958310f, 0.01991256f, 0.06984530f, -0.06625394f, 
    -0.07245083f, -0.05109394f, -0.06742312f, 0.00970099f, 0.09687563f, 0.10545792f, 0.10254238f, -0.10496368f, 
    0.02995275f, 0.01176490f, 0.00817132f, -0.03463031f, 0.12410861f, 0.02733029f, 0.12928735f, 0.00935031f, 
    -0.26059088f, -0.33708796f, -0.22783595f, -0.14774953f, -0.09087136f, 0.11607884f, 0.16800311f, -0.00415586f, 
    0.09605452f, 0.22934696f, 0.14861219f, 0.03781246f, 0.08638776f, 0.09240729f, 0.11006217f, 0.12877794f, 
    0.06056065f, 0.03855250f, -0.02308927f, -0.01842388f, 0.20155282f, 0.27018088f, -0.04505014f, -0.00744845f, 
    -0.40789357f, -0.37897080f, -0.28683612f, 0.02779274f, 0.19812618f, 0.13229048f, 0.26275626f, -0.04309530f, 
    0.05746309f, 0.09466786f, -0.00352423f, 0.03373858f, 0.47423503f, 0.07211810f, 0.24362105f, -0.02019937f, 
    -0.08551118f, 0.01209409f, -0.03599758f, 0.01046783f, 0.00299924f, 0.24675448f, 0.08668749f, 0.19453864f, 
    0.28381604f, 0.31237748f, 0.27052021f, 0.31096351f, -0.06847773f, -0.04255943f, -0.06276657f, -0.02184900f, 
    -0.02077337f, -0.01506443f, -0.00782175f, 0.05384142f, -0.10626557f, -0.58769840f, -0.49738643f, -0.19666973f, 
    -0.14979658f, -0.03466805f, -0.12017713f, -0.12374064f, -0.00860436f, -0.09537965f, -0.08696551f, 0.04451388f, 
    -0.09645349f, -0.34973359f, -0.21422267f, -0.15809947f, 0.06641436f, 0.15947638f, -0.02268457f, -0.07598998f, 
    -0.04347058f, -0.08497845f, -0.03908354f, -0.03103324f, 0.09801948f, -0.13446729f, -0.14229195f, -0.05809795f, 
    0.10442875f, 0.17110254f, 0.08696943f, 0.12255253f, 0.04389404f, -0.12106062f, 0.02938472f, 0.01102246f, 
    0.03116569f, 0.09490428f, -0.00041162f, 0.10631721f, -0.05142039f, -0.02369142f, -0.05274928f, 0.24859932f, 
    -0.05058331f, -0.02379732f, 0.00880632f, -0.10109728f, 0.30815500f, 0.01640464f, -0.00408251f, 0.13819541f, 
    0.05650236f, -0.06671602f, 0.19470678f, 0.14962062f, 0.03990306f, 0.00907871f, 0.10991735f, 0.01149411f, 
    -0.07610551f, -0.26741886f, -0.18881240f, -0.10483866f, 0.15306720f, 0.08393120f, 0.08056469f, 0.23003885f, 
    -0.06638202f, 0.04625410f, 0.10018730f, 0.04196671f, 0.10142508f, 0.02197874f, -0.07398559f, -0.00869642f, 
    -0.06324936f, 0.00496387f, 0.07338636f, -0.04189530f, 0.03760314f, 0.23824574f, 0.01210111f, -0.00253849f, 
    -0.06043214f, -0.34077340f, -0.30008179f, -0.05536920f, 0.03068175f, 0.11806691f, 0.00895657f, 0.01738517f, 
    0.12363661f, 0.11082797f, 0.02111654f, -0.06740495f, 0.32301131f, -0.12230238f, -0.50898057f, -0.25443950f, 
    -0.04327605f, -0.04685031f, 0.07552715f, 0.02453684f, -0.00076331f, -0.10290426f, -0.06194778f, 0.00279559f, 
    -0.07373177f, -0.29407164f, -0.30764687f, -0.24734166f, 0.16517289f, 0.00140383f, -0.22859219f, 0.10291564f, 
    -0.09618533f, -0.01210830f, -0.02701503f, -0.03388852f, 0.00889391f, 0.00980650f, 0.01007204f, 0.09925497f, 
    -0.03172947f, 0.04901062f, 0.00513350f, 0.02769216f, 0.05389151f, -0.04323799f, 0.02325071f, 0.03961165f, 
    0.20725290f, 0.22041258f, 0.18759610f, 0.22440483f, -0.00436262f, -0.00448136f, 0.00414025f, -0.01868780f, 
    0.06194850f, -0.01977933f, -0.03672772f, -0.01678645f, 0.08220582f, 0.03055794f, 0.11750068f, -0.11344521f, 
    0.04427500f, 0.13670871f, 0.20261583f, 0.10416079f, -0.00390527f, -0.06083886f, 0.01659735f, -0.10693257f, 
    0.00579966f, 0.08491846f, -0.00882005f, 0.03630173f, 0.06970886f, -0.14044389f, 0.08480722f, -0.10540137f, 
    -0.03750741f, 0.00393084f, -0.06653497f, -0.03453951f, -0.03310098f, -0.12199082f, -0.05307865f, 0.04326317f, 
    0.04611627f, 0.02152192f, 0.03962148f, 0.10703146f, 0.02831798f, 0.02121233f, 0.02464877f, -0.12119696f, 
    0.18520088f, 0.07690855f, 0.18993993f, -0.19513910f, -0.01859486f, 0.04044751f, 0.03438717f, 0.05945245f, 
    -0.03587336f, 0.06237640f, -0.00041063f, 0.07474396f, 0.32901454f, 0.21430226f, 0.37282848f, 0.14672488f, 
    -0.01903638f, 0.00534681f, 0.03017967f, 0.05361224f, -0.00533598f, 0.01663996f, 0.05047166f, 0.05098974f, 
    -0.48724300f, -0.89120173f, -0.73720372f, -0.13122964f, -0.03010431f, 0.01344530f, 0.11587309f, 0.06256598f, 
    0.08364397f, -0.02442295f, -0.02548753f, 0.01409257f, 0.27870971f, 0.10451687f, -0.09370682f, -0.05381814f, 
    -0.05466892f, 0.12307208f, 0.01669042f, 0.04601364f, -0.00636578f, -0.02100782f, -0.07287232f, 0.04967675f, 
    0.25133833f, -0.18751775f, -0.15001462f, -0.17114700f, -0.03618096f, 0.05976694f, -0.00856411f, 0.09934904f, 
    0.05499599f, -0.02980628f, 0.05543562f, -0.00747747f, -0.05212468f, 0.02617371f, 0.00747627f, -0.00744201f, 
    0.10378422f, -0.01889401f, 0.00658592f, -0.05709305f, -0.13952257f, 0.01855220f, -0.02032290f, -0.03688710f, 
    -0.26075849f, 0.14272326f, 0.13125202f, -0.10738989f, -0.07818550f, -0.05581144f, 0.02275330f, 0.02671759f, 
    0.04461253f, 0.02713335f, -0.00965137f, -0.07138951f, 0.35670614f, -0.07494418f, -0.11536223f, 0.06038159f, 
    -0.09972830f, -0.01826717f, -0.16763106f, 0.05928256f, 0.16253233f, -0.04180425f, -0.19954982f, -0.07561911f, 
    -0.07460276f, -0.05232460f, 0.50124580f, 0.04685431f, -0.20970626f, 0.29887006f, -0.00155069f, 0.17634003f, 
    -0.00807721f, -0.00665396f, 0.14528270f, -0.11693138f, 0.28470322f, 0.05961118f, -0.02731857f, -0.14913774f, 
    0.07722496f, 0.02019147f, 0.01156094f, 0.12837462f, 0.14185019f, 0.03839663f, 0.03242587f, 0.16676612f, 
    0.12372784f, 0.05944229f, 0.07514942f, -0.01159246f, 0.10424515f, 0.00071815f, 0.04015271f, -0.02373713f, 
    -0.06593797f, 0.07279453f, -0.07437517f, -0.02127852f, -0.16040258f, 0.27280498f, 0.02178757f, 0.26767537f, 
    -0.04127605f, 0.11479401f, -0.02980522f, 0.05550064f, 0.14385395f, -0.08937805f, 0.04626180f, 0.15043651f, 
    -0.24953298f, 0.30138147f, 0.13279928f, 0.03550640f, -0.16403157f, 0.26119068f, 0.05929499f, 0.13901584f, 
    0.10332275f, -0.11807210f, 0.19587192f, 0.10949801f, 0.01229951f, 0.25806433f, 0.01143928f, 0.15467291f, 
    0.05992379f, 0.07138641f, 0.01388120f, -0.05702708f, -0.08251414f, 0.02105113f, -0.02690818f, -0.00851068f, 
    0.02156609f, 0.11203963f, 0.14613836f, 0.09768456f, 0.02148870f, 0.29738072f, 0.06565272f, 0.10834619f, 
    0.12645707f, 0.06578644f, 0.02932648f, -0.07823367f, 0.08391224f, 0.17466174f, -0.04212843f, 0.51824093f, 
    -0.18317883f, -0.05032378f, -0.01348194f, -0.05942647f, -0.01482116f, 0.01770163f, 0.05729742f, 0.11547712f, 
    -0.04745477f, 0.14512128f, 0.07908116f, 0.21903662f, -0.05332357f, -0.08894208f, 0.04094125f, 0.05650922f, 
    -0.04099312f, -0.14531928f, 0.01223378f, -0.02276479f, -0.05093144f, 0.19434340f, 0.06551799f, -0.00820425f, 
    0.07384142f, 0.11818217f, 0.12582071f, 0.16804747f, -0.03180155f, 0.06541225f, -0.06550172f, -0.07221910f, 
    -0.14667201f, -0.04681693f, -0.01878839f, -0.21812028f, -0.03096317f, -0.01653777f, -0.01112215f, 0.02605351f, 
    -0.14940085f, -0.12661408f, -0.05678634f, -0.02083545f, 0.06819718f, 0.09255388f, -0.08389939f, -0.15827844f, 
    -0.00612364f, 0.05505414f, 0.01055106f, 0.06022325f, 0.01772236f, 0.01935771f, 0.08080289f, -0.02599669f, 
    -0.35962129f, -0.31258807f, 0.11745893f, -0.20454238f, 0.01298332f, 0.07512111f, 0.00270704f, -0.16543579f, 
    -0.08815396f, -0.01863308f, 0.02353783f, 0.06684321f, -0.00899946f, -0.32922316f, -0.06203794f, -0.35381731f, 
    -0.00337992f, -0.05520449f, 0.08667595f, -0.09172120f, -0.00333337f, -0.01535667f, 0.14133932f, 0.08405971f, 
    -0.08974195f, -0.15407346f, 0.05192018f, -0.34512383f, 0.07324370f, 0.04587543f, -0.02904402f, -0.11879405f, 
    -0.01645216f, -0.03333318f, 0.05781057f, 0.07095058f, -0.21420030f, 0.15377545f, 0.25737089f, 0.26122907f, 
    0.03541737f, -0.02515834f, 0.07720576f, 0.19942088f, 0.03469005f, 0.27569810f, -0.02487021f, -0.04794726f, 
    0.03819599f, 0.50440937f, -0.10727780f, -0.01355128f, -0.07821120f, -0.04705746f, -0.05489976f, 0.16132003f, 
    0.03544002f, -0.02434853f, 0.06069774f, -0.01297060f, 0.04051188f, 0.34387907f, -0.00306237f, -0.20067634f, 
    0.04089290f, 0.20987961f, 0.04242319f, 0.01541784f, -0.09168995f, 0.07013505f, 0.00282324f, -0.03650460f, 
    0.02976828f, -0.00795109f, -0.27698126f, -0.22145422f, 0.01255553f, 0.13341117f, 0.00299548f, -0.06346682f, 
    -0.06757193f, -0.15506600f, 0.08344445f, -0.02719658f, 0.09900886f, -0.00801138f, 0.04321405f, -0.00735844f, 
    0.00255553f, -0.04553406f, -0.03729676f, -0.01877004f, -0.11892362f, 0.01983057f, -0.09057845f, 0.00601861f, 
    0.05252369f, 0.08765568f, 0.05549355f, -0.00797424f, -0.08953665f, -0.08619596f, -0.05173345f, 0.06246230f, 
    -0.20369436f, -0.04381777f, -0.03483852f, -0.03524711f, -0.05447308f, 0.09332505f, 0.23885028f, 0.03618575f, 
    -0.00010525f, 0.03811060f, 0.04127018f, 0.08582871f, 0.07968283f, -0.07516889f, -0.03894317f, 0.07003989f, 
    -0.00837126f, 0.12853256f, -0.00898276f, -0.15211956f, -0.02352200f, 0.17485911f, 0.10745998f, 0.14491066f, 
    -0.01461258f, 0.05719379f, -0.00055249f, 0.15944268f, 0.04028147f, -0.46453968f, 0.18305087f, -0.21917486f, 
    -0.00067788f, 0.03318691f, 0.09135226f, 0.02152225f, -0.19320674f, 0.01777183f, -0.14450797f, -0.06836109f, 
    -0.48169383f, 0.60817021f, -0.31263193f, 0.18222323f, 0.16519891f, 0.01355102f, -0.13473405f, -0.11683249f, 
    -0.01153173f, -0.04145473f, 0.03221449f, -0.05165955f, -0.04447902f, 0.28634906f, 0.28665057f, 0.22140777f, 
    -0.09024031f, -0.06973490f, 0.10772026f, 0.06094940f, -0.13270350f, 0.04432980f, -0.04982851f, -0.07183138f, 
    0.06559014f, 0.26661643f, 0.00583034f, -0.00561162f, -0.16489814f, 0.11572496f, 0.00660476f, -0.00766473f, 
    0.05517249f, -0.04057248f, -0.07139935f, -0.05514745f, -0.08695688f, 0.22228368f, 0.04300417f, -0.12302927f, 
    -0.04114655f, 0.15260613f, 0.21994975f, 0.06242167f, -0.05811646f, -0.16486059f, 0.07130971f, -0.05862739f, 
    -0.15162691f, 0.18704055f, 0.12042493f, 0.17788115f, 0.07237951f, 0.12256645f, 0.09275411f, 0.10069825f, 
    0.04711369f, 0.16386940f, -0.01180852f, -0.04741264f, -0.16154718f, 0.03853546f, -0.06435186f, 0.05474818f, 
    0.13306677f, 0.03120126f, -0.16076906f, -0.07827622f, -0.14183910f, -0.07351855f, -0.00081461f, 0.00118047f, 
    -0.03066538f, -0.03468679f, -0.04058345f, -0.01365181f, 0.00271792f, -0.02682531f, -0.01508535f, -0.00694662f, 
    0.01474378f, -0.02804159f, -0.04456951f, 0.02222527f, 0.00146809f, -0.01540305f, -0.01116220f, 0.02138092f, 
    -0.01130307f, -0.04247531f, -0.03613887f, 0.04065751f, -0.01535604f, -0.04943133f, -0.02528576f, -0.03093726f, 
    0.00997820f, 0.03530312f, -0.03490082f, 0.00966837f, 0.03754106f, 0.01747967f, 0.00236999f, -0.03047559f, 
    -0.02051491f, 0.00541484f, -0.02902061f, -0.01211219f, -0.01441724f, -0.03799104f, -0.01844265f, -0.01270445f, 
    0.05029520f, -0.04500794f, -0.04661195f, -0.02287527f, 0.00487655f, -0.04143185f, -0.01928656f, -0.04025396f, 
    0.00752198f, 0.01658122f, -0.01355112f, 0.01746392f, -0.03434218f, 0.01032970f, -0.04029304f, -0.01409403f, 
    -0.04732151f, -0.03533912f, -0.00105133f, 0.01055894f, 0.03994443f, -0.00521393f, -0.03649560f, 0.00264821f, 
    0.01764526f, 0.01313447f, 0.00094586f, 0.03794763f, 0.02886152f, -0.02701048f, -0.00909686f, 0.04021004f, 
    -0.02727588f, -0.00345963f, -0.01366182f, -0.04935447f, 0.02284372f, 0.03346656f, 0.02227613f, 0.02118755f, 
    -0.00208101f, -0.00351223f, 0.04375448f, -0.01821306f, 0.01154259f, -0.03774180f, -0.02749704f, 0.03248732f, 
    -0.04640732f, 0.04448067f, -0.00344615f, 0.04761928f, 0.03129071f, -0.04399160f, -0.03679077f, -0.02702608f, 
    -0.02764619f, 0.02959692f, -0.04321141f, 0.00911125f, -0.01091692f, 0.04316163f, -0.00639670f, 0.00704205f, 
    -0.04300755f, -0.02044262f, -0.04920429f, 0.01492781f, -0.00622251f, 0.02775172f, -0.04105159f, 0.02520130f, 
    -0.00251744f, 0.02935315f, -0.01756320f, -0.00882397f, -0.04625580f, -0.00004777f, 0.04093248f, -0.02334167f, 
    -0.02130686f, -0.02398724f, -0.04333229f, -0.03010991f, -0.00058070f, 0.04721802f, -0.02831179f, 0.03261121f, 
    -0.02691931f, -0.01242887f, 0.00944120f, -0.01986006f, -0.00788729f, 0.01785614f, -0.04937720f, -0.04984130f, 
    -0.04509969f, 0.02562087f, -0.02224157f, 0.03856835f, -0.01930384f, -0.02591631f, -0.02740983f, -0.03474228f, 
    0.00930411f, -0.03288452f, -0.02293181f, 0.04096454f, -0.02497841f, 0.02703934f, 0.03193212f, -0.00104010f, 
    -0.00127408f, -0.04068561f, 0.02663149f, -0.01193495f, -0.01339179f, -0.03121081f, 0.01865944f, 0.03536011f, 
    0.00282342f, 0.02275032f, -0.03013336f, -0.00450969f, -0.03315106f, -0.02142084f, -0.02995273f, 0.00880398f, 
    0.01203255f, 0.02551316f, -0.03298261f, -0.03298403f, -0.05025738f, 0.01703664f, 0.00502674f, 0.03784789f, 
    -0.04164984f, -0.03023402f, 0.03745755f, -0.04814513f, -0.00461308f, 0.02670663f, -0.03176771f, 0.02991675f, 
    -0.04695846f, 0.01740242f, -0.03670024f, 0.04187861f, -0.02979573f, 0.01684829f, -0.01990412f, 0.05069816f, 
    -0.04475441f, 0.00026766f, -0.01795558f, -0.02504627f, 0.02541715f, 0.01232518f, -0.03812956f, -0.03926784f, 
    -0.02148012f, -0.00202265f, -0.02762455f, 0.04538164f, 0.02429697f, -0.04499121f, 0.04020052f, -0.04218792f, 
    0.04889952f, -0.04006644f, -0.01470407f, 0.04518713f, 0.02826511f, 0.04896779f, 0.03930511f, -0.04800568f, 
    0.02790239f, 0.02866919f, 0.02047860f, -0.01503599f, 0.04331650f, -0.03478947f, -0.00668257f, 0.01956668f, 
    -0.01277070f, -0.00189298f, -0.02704090f, -0.04470934f, -0.03069475f, 0.02085214f, -0.01561179f, -0.04733275f, 
    -0.04979326f, -0.02784308f, -0.01802252f, -0.00814972f, 0.00829318f, -0.01547205f, -0.02128402f, -0.00651895f, 
    -0.04403632f, 0.02423108f, 0.03620340f, -0.01055380f, -0.02264236f, -0.00129362f, -0.04332871f, 0.03829062f, 
    -0.01192760f, -0.03089898f, -0.00245821f, 0.03669665f, 0.03322809f, -0.02942997f, -0.02366094f, -0.05001235f, 
    -0.04827007f, -0.02914293f, -0.03417325f, 0.03247622f, 0.05022561f, -0.01507621f, 0.01638719f, 0.02914010f, 
    0.03127289f, 0.03802649f, 0.02211168f, 0.03695775f, -0.01260382f, 0.02911728f, 0.02971262f, -0.02274004f, 
    -0.02509987f, -0.03183412f, -0.04915968f, -0.00554087f, 0.00896806f, 0.03278797f, -0.03117132f, 0.02766470f, 
    0.04260429f, -0.01680575f, -0.05064223f, -0.04803465f, -0.01910537f, 0.01740145f, 0.00595680f, 0.01019143f, 
    -0.01916471f, -0.04867537f, -0.01333643f, -0.02367949f, -0.03759918f, -0.01716112f, 0.02629185f, 0.04645393f, 
    0.02468215f, -0.00142552f, 0.03860162f, -0.02761292f, 0.03197579f, -0.00493759f, 0.00029152f, -0.03395402f, 
    0.03392710f, -0.00471830f, -0.04477647f, -0.01682402f, 0.00476695f, -0.03188163f, -0.00293627f, -0.03123693f, 
    0.00592149f, 0.03767380f, -0.03263257f, 0.03967210f, -0.00910379f, 0.01389936f, 0.04005255f, 0.02811092f, 
    0.00447049f, -0.02098334f, 0.03030892f, 0.00657218f, 0.03415306f, 0.03458131f, 0.00490423f, -0.02807475f, 
    0.04334568f, -0.01140625f, -0.02989647f, -0.03106412f, 0.04947713f, -0.02228472f, -0.03559836f, -0.00701969f, 
    0.01797573f, -0.01424202f, -0.02055119f, 0.02473884f, 0.02557905f, 0.03369946f, -0.00123135f, -0.01259803f, 
    0.02483246f, 0.01347713f, -0.03988995f, -0.00648090f, -0.04962898f, 0.02256294f, 0.00929486f, 0.00292796f, 
    -0.03426536f, 0.02516276f, -0.01081952f, 0.01127760f, -0.02091003f, -0.02321575f, 0.01219518f, 0.02261112f, 
    -0.04158708f, -0.02590638f, -0.05049451f, -0.04780847f, 0.01687853f, 0.01056595f, 0.04062108f, 0.00295348f, 
    0.00568323f, -0.00964657f, 0.02890638f, 0.00194607f, 0.03965376f, 0.00475026f, -0.04389323f, 0.04485523f, 
    0.02180992f, -0.04928922f, -0.00169074f, -0.04034501f, -0.04446673f, 0.00219147f, -0.02072700f, 0.01680287f, 
    0.44141972f, -0.00126558f, -0.19848382f, -0.11042638f, -0.00983785f, 0.03211241f, 0.01691923f, -0.02491453f, 
    -0.06714033f, -0.06957071f, 0.08374582f, -0.03407691f, 0.22080857f, 0.01266797f, 0.00463848f, 0.03140405f, 
    -0.07705367f, 0.02286083f, 0.49454504f, 0.04495217f, 0.12511492f, 0.12097380f, -0.10984671f, 0.02544920f, 
    0.20522141f, 0.11778416f, -0.31762075f, 0.08494069f, -0.10270348f, -0.04139250f, -0.17854275f, -0.20532098f, 
    -0.08758001f, 0.04212975f, -0.01192772f, 0.00203255f, 0.27791181f, 0.03573710f, -0.17488009f, -0.29725274f, 
    -0.05909679f, -0.01426401f, 0.02898510f, 0.13187364f, -0.05617207f, 0.05065799f, 0.03268139f, -0.03283563f, 
    0.38148811f, -0.05794955f, 0.25384638f, 0.09408204f, 0.12722902f, 0.08869404f, 0.04334009f, 0.07592442f, 
    0.05273541f, -0.02656635f, 0.00257356f, -0.09085905f, 0.21130101f, 0.00673120f, 0.12511827f, -0.05507800f, 
    0.04755099f, -0.01093613f, 0.04979987f, -0.06464581f, 0.10467122f, 0.04325661f, -0.15177009f, -0.22426489f, 
    0.05466322f, 0.08156013f, -0.12137888f, 0.01668911f, 0.10397651f, 0.05640679f, 0.01955851f, -0.28045478f, 
    -0.03302497f, 0.06543688f, -0.02288785f, 0.04345478f, -0.04502846f, 0.01692515f, 0.05477734f, -0.00910265f, 
    -0.06842127f, 0.04696507f, -0.06349311f, 0.03185498f, 0.00659107f, 0.03347431f, 0.16829200f, 0.05821585f, 
    -0.15654242f, -0.23987132f, -0.32118246f, -0.05053325f, 0.14933822f, 0.21417138f, -0.12581937f, -0.05855730f, 
    0.10430566f, 0.11424353f, 0.06769451f, -0.06770506f, 0.38579077f, 0.23549391f, 0.00148252f, -0.03227472f, 
    0.05405616f, -0.00069275f, 0.12084022f, -0.01660354f, 0.04758357f, 0.20186990f, -0.11418490f, 0.16804069f, 
    0.06036510f, 0.11101044f, 0.22065863f, -0.11534949f, -0.00836140f, 0.02213050f, -0.12093428f, -0.02748703f, 
    0.06375775f, -0.00305595f, 0.06158441f, 0.11161377f, 0.40601549f, 0.13966946f, -0.02715208f, -0.05178823f, 
    0.06064388f, -0.00378677f, 0.04839980f, -0.12972380f, -0.05349561f, -0.10103273f, -0.19168963f, 0.01658434f, 
    0.08582802f, -0.01969476f, -0.04916750f, 0.17620809f, 0.03405701f, 0.14130430f, -0.02466769f, 0.16338710f, 
    -0.03135389f, -0.01405678f, -0.05087351f, 0.03219039f, 0.12113332f, -0.00295389f, 0.00189067f, 0.00958693f, 
    0.15350604f, 0.07958682f, 0.07235817f, 0.15028164f, -0.00443585f, -0.08408096f, -0.02681496f, -0.22356516f, 
    -0.07237411f, 0.00899913f, -0.09140461f, -0.02071575f, -0.17971547f, -0.17494188f, -0.00359690f, -0.03896314f, 
    -0.12399936f, 0.03197724f, 0.07489093f, 0.04237885f, 0.01628844f, -0.06534411f, 0.14508379f, -0.19471742f, 
    0.01876495f, -0.15607372f, 0.03162032f, 0.13927729f, -0.09969371f, -0.05717102f, 0.07028922f, 0.02573499f, 
    0.03553158f, 0.09840959f, -0.15379599f, 0.07415722f, 0.01867271f, 0.00795689f, -0.03386427f, 0.24750566f, 
    0.01166199f, -0.08760320f, -0.12590137f, -0.06754243f, 0.17698067f, -0.04377567f, -0.00634613f, -0.15847470f, 
    -0.00883162f, 0.06669925f, 0.13927247f, 0.05245601f, -0.25207436f, -0.04989301f, 0.04020413f, -0.06660217f, 
    -0.04116458f, -0.29715249f, -0.02640058f, 0.02389871f, -0.02189383f, 0.02036392f, 0.02660202f, -0.04645413f, 
    0.09056202f, 0.12998243f, -0.01384715f, 0.11686161f, 0.05507677f, -0.17024937f, -0.24260271f, -0.08746224f, 
    0.01171698f, 0.11052695f, 0.03682189f, 0.06446011f, -0.01627286f, -0.11677160f, -0.00881322f, -0.04633312f, 
    0.15337582f, 0.16261321f, 0.00659826f, -0.09143387f, 0.05952930f, -0.06107948f, -0.14458956f, 0.25500211f, 
    0.03443705f, 0.07425724f, -0.14107016f, 0.02868512f, -0.16295087f, 0.04318005f, 0.12879619f, -0.03025249f, 
    -0.06916622f, -0.04365938f, -0.01958197f, 0.03213942f, 0.01323490f, -0.06674518f, -0.08221775f, 0.27252266f, 
    0.03639447f, 0.05895253f, 0.01810728f, 0.07806815f, 0.00971535f, -0.05000044f, 0.03944930f, 0.00361935f, 
    -0.00222206f, 0.02170406f, 0.02734420f, 0.06304590f, 0.07254861f, 0.07793932f, 0.01646230f, -0.08756302f, 
    0.02425882f, -0.11326424f, 0.04891993f, -0.00210905f, 0.01387894f, 0.06424991f, 0.09471381f, -0.02442952f, 
    -0.06471928f, -0.01991149f, 0.06278002f, 0.03753465f, -0.00382502f, -0.18769759f, -0.00163168f, -0.17847708f, 
    -0.04330322f, -0.03341987f, 0.09772024f, -0.02801156f, -0.00063054f, -0.00125806f, -0.00764974f, 0.09796596f, 
    -0.05816437f, 0.04245107f, 0.11740125f, 0.12960768f, -0.07121979f, 0.04662832f, 0.27942488f, -0.00247400f, 
    0.18369876f, 0.15491618f, -0.26208970f, -0.08084858f, -0.15239123f, -0.13534594f, 0.12592383f, -0.03997865f, 
    0.00490695f, -0.00771204f, 0.00232366f, -0.08854545f, 0.16955769f, 0.34622183f, -0.11330322f, -0.26466736f, 
    -0.09227806f, -0.11072279f, 0.04084592f, -0.00699364f, -0.03262734f, 0.04019919f, 0.05891911f, -0.03765896f, 
    0.09011314f, -0.18450625f, 0.01911448f, 0.01228550f, -0.06126806f, 0.15440954f, 0.14997014f, -0.01330191f, 
    0.03362800f, -0.05732597f, 0.06012413f, 0.16197252f, 0.27168125f, 0.09825448f, -0.06307025f, 0.03797348f, 
    0.13584238f, -0.05143498f, -0.04365711f, 0.07423905f, 0.08749814f, 0.14795099f, -0.14418988f, 0.07011952f, 
    0.37060848f, -0.14797580f, 0.25469711f, -0.24862643f, -0.04119393f, -0.02485403f, -0.07334823f, -0.08056427f, 
    -0.12529740f, -0.05821517f, 0.14869313f, -0.22737248f, 0.04311303f, 0.04238722f, -0.00202785f, 0.07093168f, 
    0.02428577f, -0.11915929f, 0.12769815f, 0.06374564f, -0.05106755f, -0.03979802f, 0.08639465f, 0.09358721f, 
    -0.38874400f, -0.27847245f, -0.16211061f, 0.13376418f, 0.07188845f, -0.03898395f, 0.09709956f, 0.02833324f, 
    0.01104415f, 0.01667148f, 0.14566912f, -0.04417399f, -0.27647960f, 0.06184568f, 0.23686896f, -0.01339101f, 
    0.03887238f, 0.16945259f, 0.20520554f, 0.13975883f, 0.01062679f, 0.24955261f, 0.06581409f, 0.03852000f, 
    0.02213577f, 0.21000476f, -0.13485493f, 0.13900103f, 0.00962676f, -0.18547626f, -0.03557015f, 0.05145325f, 
    0.03674787f, -0.03636191f, -0.18717904f, 0.07554792f, -0.59650218f, 0.18238038f, 0.04053961f, 0.02763467f, 
    0.04674741f, 0.13320050f, 0.00352625f, -0.05567988f, 0.12694688f, -0.04813069f, 0.20133969f, 0.06947540f, 
    -0.30159682f, 0.07046559f, 0.06970177f, -0.02834497f, -0.13528547f, -0.05194400f, 0.00632031f, -0.00939280f, 
    -0.00472941f, -0.01661581f, -0.01436791f, 0.06038801f, 0.13102548f, -0.22580838f, -0.06618719f, -0.00175685f, 
    -0.02656782f, -0.05828580f, -0.04080559f, -0.07521913f, 0.09093314f, 0.14908485f, 0.01384259f, 0.19007863f, 
    0.43431589f, -0.15915644f, 0.11148297f, -0.09166855f, 0.18891729f, 0.08806693f, -0.16209915f, 0.15200442f, 
    -0.10837861f, 0.18122916f, 0.04182792f, -0.00127768f, -0.04164644f, 0.18888704f, -0.08925732f, 0.05807622f, 
    0.01748346f, 0.03256082f, 0.14184961f, 0.17952672f, 0.15366542f, 0.04788618f, 0.13610034f, 0.17986317f, 
    0.26797816f, 0.02977835f, 0.08644378f, 0.18956648f, 0.12098349f, -0.05185605f, 0.01862062f, 0.22241050f, 
    -0.11390512f, 0.15393843f, 0.01190453f, -0.04981584f, -0.36860964f, 0.29197779f, -0.20455644f, -0.03667884f, 
    -0.06266746f, -0.03175849f, -0.12192099f, -0.03574655f, -0.02898183f, -0.17466128f, 0.02465541f, 0.03189015f, 
    0.04437008f, 0.02397046f, 0.12937844f, 0.03916719f, -0.02338229f, -0.06410359f, 0.04638284f, -0.01286403f, 
    0.01284432f, 0.05858222f, -0.05241503f, -0.04993780f, -0.02781982f, 0.11008833f, 0.19882245f, -0.04558826f, 
    -0.05821511f, -0.01824876f, 0.18050881f, -0.01596508f, -0.02714431f, 0.00678119f, 0.11136186f, 0.14780420f, 
    -0.07502836f, -0.05930512f, -0.08540754f, -0.13090393f, 0.00486579f, -0.12546082f, 0.00704275f, -0.01612322f, 
    0.05689760f, 0.00261982f, -0.13273998f, -0.10172853f, -0.06343210f, -0.12381111f, 0.19277112f, 0.03366835f, 
    0.02711505f, -0.19173788f, 0.09512585f, -0.08607677f, 0.08182298f, 0.06802127f, 0.05026884f, -0.06757515f, 
    0.21424198f, 0.08132810f, 0.18549518f, 0.07836869f, 0.15859094f, -0.09196085f, 0.02336072f, -0.09077305f, 
    0.06695955f, -0.08373799f, -0.04597677f, -0.01292819f, -0.21071196f, 0.18947287f, 0.23238064f, 0.20164193f, 
    0.16134688f, 0.20185019f, 0.06527778f, -0.01953019f, 0.07585150f, 0.03162268f, 0.08986504f, 0.14309090f, 
    0.01771056f, -0.05933925f, -0.03244896f, 0.03368112f, -0.02050812f, -0.11941820f, -0.01294960f, -0.01012385f, 
    0.06367068f, 0.04721274f, 0.11854405f, -0.03876766f, -0.11023343f, -0.16811725f, 0.16297109f, 0.03687640f, 
    0.11751655f, 0.05567856f, -0.09236947f, -0.02012619f, 0.08743574f, 0.13432674f, 0.18753999f, 0.12424995f, 
    -0.35711408f, -0.03249181f, 0.00780185f, -0.07021977f, -0.13572478f, -0.10986136f, 0.09956317f, 0.20019349f, 
    0.07186467f, -0.02511777f, 0.04303068f, -0.05049935f, 0.09999726f, -0.37184089f, 0.13064496f, 0.04701515f, 
    0.16851568f, -0.12198016f, 0.08610915f, 0.09365035f, 0.04890984f, -0.09382156f, 0.10080636f, -0.03583948f, 
    -0.26700681f, 0.01814618f, 0.22503507f, 0.27748764f, -0.04827536f, -0.10409897f, 0.00453881f, -0.10703538f, 
    0.04844851f, 0.00258664f, -0.18864082f, -0.02620205f, 0.10770435f, -0.10175552f, -0.06274509f, -0.12453178f, 
    0.02945376f, 0.07301718f, -0.04193650f, 0.14487402f, 0.19059329f, 0.05606848f, 0.26469976f, -0.25092953f, 
    0.05626645f, -0.07108670f, 0.15389708f, 0.01927763f, -0.04030992f, -0.09019103f, -0.12063940f, -0.06418020f, 
    -0.13774832f, -0.00262711f, -0.00521427f, -0.11665450f, 0.15050423f, -0.06438074f, 0.04745803f, 0.34235778f, 
    0.17120507f, -0.06748138f, 0.19560662f, -0.02423485f, 0.24428169f, 0.01587135f, 0.05417029f, 0.01571534f, 
    0.28374988f, -0.13031518f, 0.15115198f, -0.01355065f, -0.01442044f, 0.10308435f, -0.15195572f, 0.05164640f, 
    0.09849473f, -0.09788089f, -0.01606541f, -0.06149176f, 0.08145154f, 0.22230408f, -0.12618107f, 0.05367688f, 
    0.01237280f, -0.02091757f, 0.17304695f, -0.08058504f, 0.13598965f, 0.11354347f, 0.09528947f, -0.07656842f, 
    0.34834883f, 0.07265190f, -0.05926342f, 0.10219229f, 0.01357672f, -0.08440009f, 0.05593567f, -0.06160343f, 
    -0.06793112f, 0.01224962f, -0.03899758f, 0.05379558f, 0.25443387f, 0.27558744f, -0.10173517f, 0.06081578f, 
    0.12482428f, -0.07185367f, 0.09217136f, -0.00290568f, 0.03998334f, 0.03275932f, -0.01194577f, -0.07824423f, 
    -0.39061868f, -0.10265474f, 0.05604868f, -0.04011940f, 0.00280744f, -0.12524982f, -0.01973877f, 0.14908880f, 
    -0.17040466f, -0.00230220f, 0.05996577f, 0.06552138f, 0.02659490f, -0.20018022f, -0.09182774f, 0.08908385f, 
    -0.02438732f, -0.09473480f, 0.02050068f, -0.07911448f, 0.17329419f, -0.00266721f, 0.20605654f, -0.05690828f, 
    -0.38174531f, 0.02279544f, -0.09801586f, 0.29136431f, 0.22872838f, -0.08501232f, -0.00972694f, 0.09420823f, 
    0.11928709f, -0.07128514f, -0.06934249f, 0.07385249f, 0.00763606f, -0.11134660f, -0.04601268f, -0.20757528f, 
    0.02369906f, 0.17122744f, 0.09497482f, 0.04222196f, 0.05241327f, -0.06158113f, -0.14769058f, 0.01608801f, 
    -0.28276342f, 0.33236793f, -0.00422161f, -0.01008960f, 0.10247263f, 0.00103033f, -0.07350443f, 0.06228071f, 
    -0.28106979f, -0.09104649f, 0.06676856f, -0.07011358f, -0.15741824f, -0.04224990f, -0.07849129f, -0.02091753f, 
    0.04222330f, 0.03020003f, 0.01837123f, -0.10360743f, 0.19784716f, 0.12500253f, 0.16407301f, 0.00820131f, 
    -0.52232879f, -0.17254771f, -0.38382307f, 0.23933256f, 0.10908659f, -0.00258144f, -0.31438807f, 0.01221050f, 
    0.05835710f, -0.03721926f, -0.02726978f, 0.04648204f, -0.04130026f, 0.29199114f, 0.17932409f, -0.02491292f, 
    -0.05066643f, 0.00097758f, -0.09030272f, -0.08287580f, -0.09586611f, -0.21792328f, -0.08139420f, 0.14315787f, 
    0.02449341f, -0.04152090f, 0.04705422f, 0.17687245f, 0.07908296f, 0.09055858f, -0.06081991f, -0.03328421f, 
    0.00270548f, -0.01110257f, -0.07083537f, -0.02266975f, 0.07899144f, 0.09735123f, -0.05156362f, -0.04917413f, 
    0.02000702f, 0.02417592f, 0.06578260f, -0.06922682f, 0.00259605f, 0.02888006f, -0.03732540f, -0.05088462f, 
    0.38202998f, 0.15758947f, -0.13651699f, 0.30869487f, 0.07721215f, 0.10599480f, -0.09794831f, -0.10456102f, 
    0.00786773f, -0.00333753f, 0.10202702f, 0.27544972f, -0.28561458f, -0.17876528f, -0.19009285f, -0.04848100f, 
    -0.14467455f, 0.06190427f, -0.15796092f, -0.01505998f, 0.06587511f, 0.03212192f, 0.22323634f, 0.04243778f, 
    0.02343673f, 0.01338367f, -0.07390215f, 0.09482396f, 0.20075192f, 0.15639146f, 0.02817712f, 0.13158813f, 
    0.08625387f, -0.00600927f, 0.17081685f, 0.08589864f, -0.17906336f, 0.16559590f, 0.01540327f, -0.04887414f, 
    -0.07303786f, -0.03422760f, 0.00297992f, -0.14553264f, -0.03827284f, -0.01195580f, -0.07913156f, 0.09119138f, 
    -0.37610739f, -0.20681669f, -0.14474173f, -0.04372044f, -0.06965090f, 0.03141996f, -0.09978426f, -0.09898212f, 
    0.02512421f, 0.00250476f, 0.13563885f, 0.14127043f, 0.22897293f, 0.07133134f, 0.12305190f, 0.07760912f, 
    0.08582398f, 0.03638670f, -0.01093671f, -0.07594424f, 0.02932760f, 0.01046419f, -0.00082245f, 0.08949714f, 
    0.19736789f, 0.04201446f, 0.04535786f, -0.04533946f, 0.12751000f, 0.04012110f, 0.07776936f, 0.25546980f, 
    -0.00850147f, -0.01373084f, 0.07495873f, 0.09303240f, 0.03384968f, 0.01300464f, 0.02755341f, 0.04266472f, 
    0.14236106f, -0.04283808f, -0.00867989f, 0.16049862f, -0.13771388f, -0.01791526f, -0.02857997f, -0.10157365f, 
    -0.05128860f, -0.25944588f, -0.17219664f, -0.07205525f, 0.25942987f, 0.03200275f, -0.00308800f, -0.00164268f, 
    0.00746129f, -0.04258911f, -0.01727892f, 0.03430143f, -0.11829577f, -0.14213926f, 0.09221765f, 0.08237302f, 
    -0.04978760f, 0.19327070f, 0.03388055f, 0.08578220f, -0.01460032f, 0.00777315f, -0.14460173f, 0.01090788f, 
    0.22317152f, -0.02365515f, -0.05698813f, -0.03243508f, 0.16155741f, 0.09413718f, 0.11892738f, 0.18065125f, 
    -0.06052577f, -0.08175336f, -0.05416901f, -0.06294263f, -0.10481155f, -0.11678501f, -0.03953075f, -0.04516802f, 
    0.08138530f, 0.06525962f, 0.02906561f, -0.04195406f, -0.01107069f, 0.11233146f, 0.26782125f, 0.04545759f, 
    -0.12783812f, -0.15778674f, 0.12633072f, 0.15568575f, 0.14044653f, 0.07105075f, 0.05231841f, -0.02810853f, 
    0.00414815f, 0.10984842f, -0.06915533f, 0.10020031f, -0.07615215f, -0.01819705f, -0.25335315f, -0.05912655f, 
    0.11514967f, 0.16263907f, -0.00815099f, 0.08492528f, -0.00144899f, -0.01875417f, 0.01196739f, -0.00467180f, 
    -0.01864582f, 0.00823956f, 0.02022869f, 0.00933784f, 0.05506629f, 0.01969377f, 0.05633842f, 0.11344377f, 
    0.02715597f, 0.02288170f, 0.04655277f, 0.09382851f, -0.34660110f, -0.17680404f, -0.04229999f, -0.02058770f, 
    0.00362448f, -0.00159816f, -0.12770037f, -0.00984917f, -0.02992665f, 0.08657367f, -0.06759780f, -0.05219786f, 
    -0.37798500f, -0.33822450f, -0.11838362f, -0.01596385f, -0.03341227f, -0.04310933f, -0.08485706f, -0.01919096f, 
    -0.05214884f, 0.06738284f, 0.09923254f, 0.12640928f, -0.09818657f, 0.13227451f, -0.15801127f, -0.07166640f, 
    0.02127839f, -0.09414612f, -0.00129209f, 0.13125816f, 0.15607627f, 0.22768338f, -0.00457038f, 0.13412283f, 
    0.02736017f, 0.10208493f, -0.00652760f, 0.03538585f, -0.20080239f, -0.00122597f, 0.13081719f, -0.06704806f, 
    0.10169738f, 0.08396470f, 0.13927680f, 0.01230014f, 0.26063582f, -0.06190771f, 0.07312066f, 0.09519929f, 
    0.11748872f, -0.00686150f, -0.20051897f, -0.03079710f, 0.24190603f, 0.01657304f, 0.11945981f, -0.10054231f, 
    0.18003415f, 0.25179943f, -0.06702831f, -0.04527019f, -0.06757861f, 0.01611933f, -0.00963772f, 0.00614175f, 
    0.01675184f, -0.06245997f, 0.00899950f, 0.09475471f, -0.28877407f, -0.10606786f, -0.14733672f, 0.06636398f, 
    -0.00942774f, -0.11693627f, -0.12926207f, -0.07443539f, 0.04878172f, 0.02851994f, 0.01247986f, 0.06689268f, 
    0.09093461f, 0.01410086f, 0.01447243f, 0.11259989f, 0.21244216f, 0.10285924f, 0.05905553f, 0.08672766f, 
    -0.06765485f, 0.05460174f, 0.11425354f, -0.03315698f, -0.26884183f, 0.07894423f, 0.27055040f, -0.18746060f, 
    -0.08918757f, -0.01018072f, 0.02744655f, 0.18726724f, 0.13884459f, 0.02420742f, 0.01187471f, 0.16648628f, 
    -0.35892576f, 0.01485387f, 0.23502493f, 0.04515503f, 0.02126704f, -0.01002582f, -0.14620388f, 0.03377040f, 
    0.01102927f, 0.10535244f, 0.13964231f, -0.03213157f, 0.08722824f, -0.06317388f, 0.00785439f, 0.07795765f, 
    -0.03591596f, 0.06471059f, 0.07265392f, -0.09385175f, 0.08906413f, 0.12595303f, 0.07824093f, 0.05511359f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00864224f, -0.01324731f, -0.01741666f, 0.17241041f, 0.08349248f, 0.10106381f, 0.03260675f, 0.12638144f, 
    -0.06065755f, -0.03291043f, 0.08915726f, 0.01096166f, -0.05978711f, -0.04432473f, 0.13284647f, 0.04831918f, 
    0.05934829f, 0.02963497f, 0.19988249f, 0.08199528f, -0.05135134f, 0.15097453f, 0.01408518f, -0.01014307f, 
    0.04392906f, 0.04762963f, 0.16165760f, 0.17048396f, 0.01114917f, -0.04154297f, 0.15370029f, -0.00448502f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.27792194f, 0.10459580f, 0.14629415f, -0.11755598f, -0.13279976f, -0.41086590f, -0.09640080f, -0.09994452f, 
    0.23227158f, 0.33603689f, -0.17644578f, 0.09275924f, -0.07613546f, -0.13256475f, -0.59390062f, 0.10689936f, 
    -0.39595142f, -0.29811183f, -0.76640677f, -0.16503048f, 0.11202946f, 0.14312232f, 0.13820009f, 0.12418626f, 
    -0.09884181f, -0.06705543f, -0.08818330f, 0.40039644f, 0.12028489f, 0.04057637f, -0.67224514f, 0.09575783f, 
    0.10445667f, -0.00866103f, 0.01790583f, 0.04920270f, -0.06435613f, 0.51384789f, -0.17012867f, 0.37935612f, 
    -0.13006935f, -0.14853442f, 0.23464809f, -0.25376967f, -0.90012777f, -0.08009045f, -0.26745200f, -0.24086978f, 
    0.25857815f, 0.38814169f, -0.29654786f, 0.03572020f, -0.03026737f, -0.01100300f, 0.29513073f, -0.07197741f, 
    -0.10316098f, -0.05924328f, 0.30114278f, 0.00290246f, 0.04763201f, 0.19337131f, -0.29304317f, 0.00178993f, 
    -0.15375961f, 0.07175017f, -0.16949935f, -0.12192097f, 0.28168598f, 0.15422261f, -0.03605967f, 0.28116855f, 
    -0.74714184f, -0.01893943f, -0.18889721f, 0.36181521f, 0.02011015f, 0.07098392f, 0.09000346f, 0.07915780f, 
    -0.21896917f, 0.57099998f, 0.13768609f, -0.30521828f, 0.00400296f, -0.19837201f, -0.01270006f, 0.11860371f, 
    0.11939972f, -0.12199728f, -0.52200145f, 0.25761849f, 0.06225243f, 0.00678565f, -0.04924601f, 0.08070842f, 
    0.05161297f, -0.00733630f, 0.07211529f, -0.61440533f, 0.29758298f, -0.20218456f, 0.06332173f, -0.05524899f, 
    0.31085581f, -0.00548720f, -0.59643894f, 0.06529309f, 0.24707718f, -0.12225225f, 0.32295561f, -0.58430511f, 
    0.15313105f, 0.30860478f, -0.10471032f, 0.01642882f, 0.12137266f, -0.18708834f, -0.12388023f, -0.12350857f, 
    -0.00792906f, 0.04531289f, -0.30490440f, -0.33941367f, 0.02127185f, -0.01095164f, 0.01245637f, 0.33262014f, 
    -0.13286225f, 0.04377398f, 0.09737761f, -0.06169496f, 0.10835263f, 0.13973095f, 0.33224621f, -0.56472802f, 
    -0.04326682f, 0.26930162f, 0.34544158f, 0.17605878f, 0.24261722f, -0.10036343f, -0.36940101f, -0.06931920f, 
    -0.65583289f, -0.15052418f, 0.06978179f, 0.05998366f, -0.04000392f, -0.28064549f, 0.12133592f, -0.14414781f, 
    0.05306801f, 0.18576689f, 0.24490638f, -0.25149429f, -0.05268870f, -0.29439420f, -0.24675490f, -0.14869612f, 
    -0.02151165f, 0.07281771f, -0.06589804f, 0.29138321f, -0.14062476f, -0.60604066f, 0.19787575f, -0.07594660f, 
    -0.49975324f, -0.37029260f, 0.08733629f, 0.10121216f, -0.00238800f, -0.07655013f, -0.32520071f, 0.10117480f, 
    0.06795064f, -0.50342739f, -0.20349504f, 0.35833710f, -0.06046586f, 0.47140875f, 0.14602302f, 0.15693627f, 
    0.15056208f, -0.04255356f, -0.14304723f, -0.02989683f, 0.04087859f, -0.26999611f, 0.04951709f, 0.06300640f, 
    -0.58624417f, 0.04825204f, 0.10709133f, 0.30621317f, 0.22997594f, 0.37954628f, -0.10844236f, 0.23502995f, 
    -0.26215190f, 0.08947960f, -0.47438374f, -0.31538439f, -0.16371472f, -0.05575107f, 0.30080622f, 0.28430516f, 
    0.09262749f, -0.65093219f, 0.30160826f, -0.05719936f, -0.07579511f, -0.17319554f, -0.64472276f, 0.15823604f, 
    0.09824285f, 0.02373978f, -0.25973213f, 0.19998439f, -0.11139172f, -0.33139333f, -0.07014376f, -0.22949620f, 
    -0.35850167f, 0.03811344f, -0.10160626f, -0.13457701f, -0.15936695f, 0.00848259f, -0.28639507f, -0.15681659f, 
    -0.19905478f, -0.27269953f, 0.23976968f, 0.49931481f, 0.48207828f, -0.00733964f, 0.15112956f, 0.02038261f, 
    0.04489110f, -0.18402284f, 0.10027300f, 0.06819724f, -0.06435039f, -0.28993842f, -0.34528390f, 0.06442560f, 
    -0.02096401f, 0.13423678f, 0.15152542f, -0.49414644f, 0.05262862f, 0.32379702f, -0.25767753f, -0.37929389f, 
    0.23851858f, -0.10454136f, -0.14868307f, -0.02655898f, 0.18202232f, -0.28702110f, -0.51365054f, 0.01736802f, 
    -0.36067140f, -0.69473422f, -0.08192520f, -0.18494187f, -0.50106794f, -0.04659043f, 0.29618990f, -0.37592950f, 
    -0.42159840f, 0.18067977f, 0.28556046f, 0.23255126f, 0.01351729f, 0.26136464f, -0.69848776f, -0.07778157f, 
    -0.13106923f, -0.20948656f, 0.24084878f, -0.19422747f, -0.01255146f, 0.09662686f, 0.02314824f, 0.01956578f, 
    -0.30999601f, -0.07943087f, 0.09208170f, 0.27619576f, -0.27702045f, -0.08191954f, 0.27989537f, 0.14870846f, 
    0.35279810f, 0.37401602f, 0.44861329f, 0.01160374f, -0.06398272f, 0.08396775f, -0.29628798f, 0.19132963f, 
    0.40160012f, -0.12811081f, 0.17257559f, -0.60245347f, 0.14502709f, 0.29035604f, -0.36471543f, 0.10663554f, 
    0.00564299f, -0.07651548f, -0.24037737f, -0.53721744f, -0.05465108f, -0.25032690f, 0.00846020f, 0.02885802f, 
    -0.08436091f, 0.06766839f, -0.07884512f, -0.19461553f, -0.13235715f, 0.27142650f, 0.22124612f, -0.35042948f, 
    0.17183557f, -0.55113012f, 0.26835126f, -0.75298828f, -0.23587692f, 0.03490541f, 0.48003304f, -0.24757807f, 
    -0.24673542f, 0.37200508f, -0.01548469f, 0.01798198f, -0.06967653f, 0.25763598f, 0.06559059f, 0.16428792f, 
    -0.01935133f, 0.13777481f, -0.49905670f, 0.46944997f, 0.09205925f, -0.54368496f, -0.45249879f, 0.06746961f, 
    -0.00940753f, -0.00972375f, -0.13722238f, 0.24591623f, 0.24056573f, 0.21105413f, -0.31208044f, -0.52309334f, 
    0.39835721f, -0.10089623f, 0.07953033f, -0.43196473f, -0.00703371f, -0.12067396f, 0.09358940f, 0.18582198f, 
    0.16129515f, 0.29142243f, -0.20394941f, 0.13071389f, -0.07405218f, -0.49221915f, 0.12725127f, -0.11395948f, 
    0.16135225f, -0.66794968f, -0.12194449f, 0.08581857f, -0.11641984f, -0.24672903f, 0.45934710f, -0.47650841f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03945565f, 0.09279048f, 0.17143060f, 0.06115803f, -0.09970576f, -0.10146314f, 0.15789668f, -0.02297150f, 
    0.12449475f, -0.00318991f, -0.12048978f, 0.16836929f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
