#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.65103585f, 0.11973551f, 0.42137647f, 0.77649540f, 0.65864545f, -0.36326006f, -0.49554396f, -0.56319588f, 
    -0.50622565f, -0.07829832f, -0.09629692f, 0.27255854f, 0.01467220f, 0.36008054f, -0.23397839f, 0.01789260f, 
    -0.06167525f, 0.34004432f, 0.11158440f, -0.26132062f, -0.15996598f, 0.21389200f, -0.19489934f, -0.13034654f, 
    0.22251849f, 0.03841885f, -0.60875762f, 0.62368506f, 0.17890237f, 0.37862822f, 0.50445420f, -0.34890100f, 
    0.34137148f, -0.18969394f, -0.41133726f, 0.08048914f, -0.18924347f, 0.00876638f, 0.45726463f, 0.15406261f, 
    0.28260472f, 0.13086018f, 0.14031740f, 0.07539309f, 0.15193303f, 0.00612474f, 0.30509862f, 0.11688823f, 
    -0.10898233f, 0.19111602f, -0.43608236f, 0.88629967f, -0.18515098f, 0.03446882f, -0.08321781f, 0.25198764f, 
    0.73223990f, 0.33287853f, 0.09652571f, 0.53680652f, -0.07076721f, -0.13966712f, 0.12059312f, -0.61680692f, 
    -0.16977336f, -0.05626936f, -0.12786913f, -0.09623813f, 0.05191869f, -0.28810471f, -0.09586394f, -0.15985565f, 
    -0.18594967f, -0.00953279f, 0.12832350f, 0.86828691f, 0.26381883f, -0.58009231f, 0.58618420f, 0.21162689f, 
    0.14059339f, 0.23066051f, -0.34895757f, 0.23767604f, 0.39207473f, 0.14408915f, 0.23714432f, -0.14986818f, 
    -0.18666251f, -0.18736756f, -0.05404260f, -0.33460480f, 0.01224037f, -0.13001135f, 0.15132816f, -0.06250982f, 
    0.11391614f, 0.16750123f, 0.14320166f, 0.00045961f, 0.48228198f, 0.45330000f, 0.56806850f, 0.62772399f, 
    0.63585997f, -0.40845889f, 0.36802563f, -0.22695540f, -0.61638385f, 0.21741550f, 0.13091595f, 0.05107414f, 
    0.20001645f, 0.24308428f, 0.25306317f, -0.19750917f, -0.05604718f, -0.13559459f, 0.06061482f, 0.06728175f, 
    0.30312529f, -0.08186571f, 0.06727293f, 0.25608036f, 0.05762089f, -0.87882191f, -0.53950614f, -0.71649754f, 
    -0.01648409f, 0.24770001f, 0.16873208f, 0.83004922f, 0.43597469f, 0.14003849f, 0.27233592f, -0.12207887f, 
    -0.04129071f, 0.21288091f, 0.28392866f, 0.16583949f, -0.24364184f, 0.14233898f, -0.27103987f, 0.16017166f, 
    -0.24670862f, 0.09901687f, 0.12208824f, -0.19353999f, 0.04632229f, -0.01157632f, -0.14756379f, 0.08753458f, 
    -0.52779913f, -0.78476512f, -0.56842017f, 0.31261706f, 0.10019356f, 0.30432808f, 0.34589675f, 0.08735194f, 
    0.44007924f, 0.22216170f, -0.21422896f, 0.09438304f, 0.10819805f, 0.42831841f, -0.03268844f, 0.17146148f, 
    0.13739114f, 0.27922562f, -0.18244971f, -0.09915077f, -0.04094035f, -0.54655904f, 0.29352066f, -0.22370878f, 
    -0.43993589f, -0.50532466f, -0.47056127f, -0.22466840f, -0.08359347f, -0.50806552f, -0.31651092f, -0.15099110f, 
    -0.12675031f, -0.40476173f, 0.33032072f, 0.36592436f, 0.09913172f, 0.07047609f, 0.19694681f, 0.24583566f, 
    -0.13284351f, 0.05670029f, 0.00105021f, 0.12604623f, 0.17598504f, 0.29733396f, 0.07672003f, -0.08175344f, 
    -0.18548748f, -0.19231990f, -0.09030016f, 0.06617606f, 0.53300166f, -0.15137650f, -0.34617591f, -0.52927113f, 
    -0.47961986f, 0.02846599f, 0.42165500f, 0.39643568f, 0.05653464f, 0.15860443f, 0.11021762f, 0.50859785f, 
    0.11585172f, 0.15629935f, 0.02445088f, -0.05746663f, -0.30155167f, -0.29188681f, -0.02482869f, -0.05636017f, 
    0.35009399f, 0.08908709f, -0.40592727f, -0.18752126f, 0.79249597f, 0.48636839f, -0.26056284f, 0.00582718f, 
    0.05530984f, -0.02743503f, -0.25053546f, 0.22457756f, 0.14994074f, -0.38162184f, -0.15204529f, -0.06959953f, 
    0.38672680f, 0.50996435f, -0.15595134f, -0.27805707f, 0.01978171f, 0.19178030f, 0.30192164f, -0.22941676f, 
    0.44073671f, -0.07316571f, 0.46173304f, 0.30685592f, -0.30961418f, -0.85258234f, -0.44450915f, -0.11278721f, 
    0.00839790f, -0.12417180f, 0.33218750f, -0.11502782f, -0.46646407f, -0.08395293f, -0.28858408f, -0.39294580f, 
    0.08925958f, -0.11258750f, -0.00000598f, 0.15398543f, 0.07879856f, 0.03333576f, 0.05480425f, 0.15689519f, 
    -0.38338631f, -0.06859722f, 0.14684220f, -0.05421802f, -0.30294630f, 0.10972624f, -0.67116475f, -0.34795517f, 
    -0.53117406f, 0.57858413f, 0.12663075f, -0.61415970f, -0.18174568f, -0.13321163f, 0.17397361f, 0.10182701f, 
    0.21599598f, -0.34370106f, 0.02404097f, -0.18058962f, -0.06351855f, 0.21016991f, 0.31400687f, 0.22452739f, 
    0.27860770f, -0.40887409f, -0.12407027f, 0.20661500f, -0.37955433f, -0.22077321f, -0.13198839f, 0.37957066f, 
    0.45112443f, 0.41866654f, 0.43649739f, -0.83071852f, 0.37194118f, -0.53936678f, 0.20223792f, 0.13730185f, 
    -0.38901517f, 0.06998068f, -0.04614183f, -0.27476078f, -0.14796999f, 0.24888189f, -0.10972651f, -0.19808526f, 
    0.12068955f, -0.15323612f, -0.14994344f, -0.12411743f, 0.20866327f, 0.98254752f, 0.40474591f, 0.37607527f, 
    -0.50660002f, 0.17289189f, -0.33958319f, 0.05816827f, -0.10119492f, 0.08800436f, 0.39412081f, -0.06587342f, 
    0.15655099f, 0.02662002f, 0.00864738f, 0.06423414f, -0.05947273f, -0.05640274f, 0.11315037f, 0.08824379f, 
    0.12760507f, -0.31082094f, 0.13136733f, -0.13007461f, -0.09303844f, 0.20357902f, 0.53391546f, 0.34141716f, 
    0.68635851f, 0.30256128f, -0.22404374f, 0.37468317f, 0.06165627f, 0.55525661f, 0.03276350f, -0.29485574f, 
    -0.49266675f, -0.40740022f, -0.33345914f, -0.26429385f, 0.22866534f, -0.34717053f, 0.16363910f, -0.03129064f, 
    0.16932270f, 0.19784528f, -0.16543697f, 0.09117945f, -0.16941744f, 0.21920384f, -0.03302943f, -0.46350792f, 
    -0.79112154f, -0.27434292f, -0.26725802f, -0.45143503f, 0.43948326f, 0.63579625f, 0.20301232f, 0.35083356f, 
    0.36077666f, -0.27602559f, -0.18128809f, -0.46836662f, -0.28418624f, -0.13750964f, -0.03651252f, 0.06090462f, 
    0.12695859f, 0.01798283f, -0.01034249f, -0.20178866f, 0.03546194f, -0.24707431f, -0.09300068f, -0.06464572f, 
    0.70912659f, -0.88305283f, -0.74902374f, 0.44525078f, 0.04548200f, -0.81446868f, 0.21226688f, 0.08579486f, 
    -0.13868646f, 0.03746639f, -0.16490501f, 0.23369081f, 0.10621183f, 0.22314996f, 0.05008599f, -0.25695965f, 
    -0.01312271f, -0.03742451f, -0.06117560f, -0.10317243f, 0.12409328f, -0.12147518f, 0.08343347f, 0.05137290f, 
    0.07410975f, 0.08439440f, -1.12832546f, -0.26733363f, 0.26239118f, 0.08377323f, -0.78225368f, 0.20796598f, 
    0.52484077f, -0.18776901f, 0.00823673f, 0.01121009f, -0.08416994f, -0.21057732f, -0.20064463f, -0.03273299f, 
    0.13149236f, 0.14280240f, -0.02670162f, -0.08505792f, -0.16240081f, -0.02188580f, -0.20508976f, 0.05487248f, 
    0.40323231f, 0.11284226f, -0.28059357f, 0.70469636f, 0.50303584f, 0.34169608f, 0.45092097f, 0.67842269f, 
    -0.10636508f, -0.28149065f, 0.37190282f, -0.34105164f, 0.19369456f, 0.11730586f, 0.00454977f, 0.06304414f, 
    -0.19197766f, 0.05660018f, -0.30114993f, -0.10868262f, -0.37291428f, -0.18993600f, -0.04101023f, -0.20877244f, 
    -0.14351512f, 0.09191316f, -0.22527629f, 0.01494908f, -0.24722958f, 0.04414070f, -0.20135967f, -0.20306256f, 
    -0.56925893f, -0.16505280f, 0.35652271f, 0.30389664f, -0.63889766f, -0.59562206f, 0.06828583f, -0.13884906f, 
    -0.43098387f, -0.51527876f, -0.30931064f, -0.01699321f, -0.06045011f, -0.15137559f, -0.31866905f, 0.16876608f, 
    0.17020844f, -0.20851870f, 0.20622654f, -0.33794183f, 0.10595620f, 0.46287504f, 0.73770994f, -0.33099598f, 
    -0.00949429f, 0.12651418f, 0.35286412f, 0.21822101f, 0.04326570f, -0.40556017f, 0.07078604f, 0.65476871f, 
    0.00490671f, 0.12619905f, -0.13511851f, -0.14539988f, -0.10060102f, -0.33705267f, -0.28695527f, 0.09768501f, 
    0.14987358f, 0.23739429f, 0.23725982f, 0.23315275f, 0.02448963f, -0.31549466f, 0.16914921f, 0.58121198f, 
    0.62058640f, 0.51455796f, 0.39077488f, 0.40729123f, 0.27818364f, 0.19488464f, 0.16182861f, -0.15931812f, 
    -0.11453643f, 0.01548610f, 0.07599154f, 0.06432416f, 0.32599112f, 0.24281542f, 0.29624689f, 0.18602477f, 
    0.14684851f, 0.22959743f, 0.02096825f, -0.01526485f, -0.11131889f, 0.10108376f, -0.10572104f, 0.02331608f, 
    -0.22137655f, -0.38793337f, 0.34348062f, 0.06017286f, -0.52942121f, -0.63062745f, -0.59102249f, -0.62431616f, 
    0.20187674f, -0.28273964f, -0.00712151f, 0.21153446f, 0.05251450f, 0.21255513f, -0.26726273f, -0.64017361f, 
    -0.15553813f, 0.34176183f, -0.11596966f, 0.13205655f, 0.22220950f, 0.11298180f, 0.03666401f, 0.58722264f, 
    -0.28093439f, 0.64353770f, -0.05261429f, 0.07677257f, 0.22530323f, -0.94333553f, -0.13477649f, 0.19343323f, 
    0.19785027f, 0.07178698f, 0.16494033f, -0.16855080f, -0.22232784f, 0.16181925f, 0.07888913f, 0.13102269f, 
    -0.33309108f, -0.32486027f, 0.01694102f, 0.05641566f, 0.03296456f, 0.33921096f, 0.19516872f, 0.11660221f, 
    -0.47657713f, -0.12172316f, -0.28509668f, -0.08300061f, 0.23468035f, -0.71787035f, -0.44839600f, 0.14282656f, 
    -0.08753587f, -0.04432004f, -0.41963723f, 0.10695525f, 0.26971498f, -0.07418542f, -0.29277968f, 0.38674802f, 
    -0.24646182f, 0.24080303f, -0.21216138f, 0.05107699f, -0.15084277f, 0.05525961f, 0.24564178f, 0.10565966f, 
    -0.11984693f, 0.31911358f, -0.25904152f, -0.79384243f, -0.72824168f, 0.16479784f, 0.41763249f, -0.43154466f, 
    0.05401934f, -0.05100279f, 0.15788126f, -0.05460541f, -0.11002918f, -0.28632215f, -0.09677014f, -0.21218501f, 
    -0.09418517f, 0.36509809f, -0.08572219f, 0.19684871f, 0.09703761f, -0.04317182f, -0.18892202f, 0.24279889f, 
    0.32000279f, 0.27891672f, 0.43255508f, 1.02836645f, -0.54351556f, -0.13957450f, -0.77212542f, 0.16266058f, 
    -0.24436679f, -0.61784345f, -0.29026410f, -0.24754800f, 0.13818681f, 0.18421131f, 0.09910528f, 0.17287061f, 
    -0.14087369f, -0.13239500f, 0.07496506f, -0.07840936f, 0.15759420f, -0.27859408f, -0.17057064f, -0.06039571f, 
    0.09448466f, -0.20364344f, -0.07886608f, 0.61437923f, 0.38653287f, 0.81836969f, 0.42374441f, -0.24429670f, 
    -0.31906503f, -0.48813996f, -0.22327791f, -0.00349067f, -0.19909209f, 0.30768281f, -0.01819658f, -0.23170626f, 
    0.24183115f, -0.13625646f, 0.01817201f, -0.04187414f, 0.10560566f, -0.07229970f, -0.05481505f, -0.12588440f, 
    0.02043202f, 0.19864744f, 0.36558890f, -0.22831883f, -0.89264083f, -0.38641837f, -0.17217562f, -0.12402091f, 
    0.36632529f, -0.23027816f, 0.88887197f, 0.11789909f, -0.34502068f, -0.42778331f, 0.08418347f, -0.14115724f, 
    0.15432838f, -0.18166655f, 0.15244742f, 0.09831005f, 0.16823910f, 0.09153616f, 0.13045996f, 0.23241866f, 
    0.06011107f, -0.15069626f, -0.02365219f, 0.03151643f, -0.09610944f, 0.00736662f, 0.58914405f, 0.59267825f, 
    0.78113925f, -0.64057177f, -0.24595182f, 0.49169382f, -0.36913997f, 0.04130875f, 0.11021429f, 0.21279252f, 
    0.30345073f, 0.11611420f, 0.05262416f, 0.02358249f, -0.04828750f, -0.15829544f, 0.23279908f, 0.17900763f, 
    0.04302635f, 0.01695415f, 0.26334488f, 0.16825800f, 0.01031379f, 0.14687213f, -1.17786109f, -0.20880628f, 
    -0.19526267f, -0.25265202f, -0.36964649f, 0.41507423f, -0.28364554f, -0.12852143f, 0.11567961f, 0.44703248f, 
    0.25820351f, -0.11010955f, -0.02321780f, -0.07182067f, -0.23024428f, -0.09013672f, 0.36712778f, 0.21999598f, 
    -0.13372800f, -0.36752221f, -0.03643466f, -0.29061189f, 0.22273336f, -0.08833389f, 0.06632230f, -0.51731843f, 
    -0.82667863f, 0.08959644f, 0.34499943f, 0.31868264f, 0.50525570f, 0.48722282f, -0.46860471f, 0.07449188f, 
    -0.08601163f, -0.22873235f, 0.25057811f, -0.12746125f, 0.38917810f, -0.00280140f, -0.26694506f, -0.10237112f, 
    -0.36782157f, -0.22349297f, 0.07138600f, -0.14365812f, 0.11623529f, 0.05177630f, 0.06707814f, -0.10415628f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02345313f, 0.09071461f, -0.10775279f, 0.24429385f, 0.19050430f, 0.17753226f, 0.45615894f, 0.31142560f, 
    0.36337978f, 0.26134974f, -0.14265743f, 0.08238976f, 0.10742734f, 0.17867957f, 0.05213411f, -0.04543166f, 
    0.30653557f, 0.05452314f, 0.21037060f, -0.05290169f, -0.21112943f, -0.03569542f, 0.11341940f, 0.16360988f, 
    0.18225761f, 0.15636015f, 0.16371259f, 0.14561042f, 0.14642461f, 0.04526534f, 0.02355516f, -0.00480236f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.10860993f, -0.11776025f, -0.03274139f, -0.04925393f, 0.08262315f, 0.06538296f, -0.04981015f, 0.08994606f, 
    -0.01851388f, -0.02774695f, 0.14993097f, -0.08420685f, -0.31869921f, 0.03536363f, 0.08155664f, 0.16079725f, 
    -0.09870624f, 0.11525878f, -0.10025384f, 0.04158236f, 0.03737831f, 0.10572465f, 0.07293052f, 0.16522183f, 
    0.04044683f, 0.15989166f, -0.07321461f, -0.02379102f, -0.04659490f, 0.07491405f, -0.06399141f, -0.00374436f, 
    -0.01526328f, -0.14324500f, 0.07925902f, -0.03144415f, 0.32666415f, -0.31801614f, -0.09898272f, -0.01095718f, 
    0.15134184f, -0.12786290f, 0.11399556f, -0.02881954f, 0.08969945f, 0.15088870f, 0.03860632f, 0.04576999f, 
    0.15042378f, 0.07693788f, -0.01296828f, 0.09560789f, 0.07172511f, 0.12691961f, 0.00687526f, -0.01805350f, 
    0.06887299f, 0.16328290f, 0.06285994f, 0.06160603f, 0.38231158f, 0.28281653f, -0.05692854f, 0.02964901f, 
    -0.03414121f, -0.09476361f, -0.01193319f, 0.19730374f, 0.02967752f, 0.06030916f, -0.03219408f, -0.12153773f, 
    0.08439000f, 0.06690058f, 0.02038350f, 0.01388870f, -0.04812263f, -0.07437182f, 0.16624463f, 0.09159185f, 
    -0.00111060f, 0.12025898f, -0.01660180f, 0.10532875f, 0.06362345f, 0.10431916f, 0.12049705f, -0.07103972f, 
    0.01778322f, -0.01098069f, 0.09991810f, -0.03819716f, -0.07530882f, 0.01141699f, 0.11537877f, 0.02286656f, 
    0.20421138f, -0.06273137f, -0.02920412f, -0.02451481f, 0.10034143f, -0.05325063f, -0.03437023f, -0.00417483f, 
    -0.13151002f, -0.02321970f, 0.01718849f, 0.12579784f, 0.05328744f, -0.16344373f, -0.14035460f, 0.05096368f, 
    0.05749252f, -0.02010729f, -0.11738578f, 0.01491711f, 0.05105047f, 0.06932197f, 0.03614078f, 0.13689391f, 
    0.02331278f, -0.07974247f, 0.03707436f, -0.00487097f, 0.09379410f, -0.03450545f, 0.00962718f, 0.11316782f, 
    -0.04223972f, -0.08419876f, -0.04573578f, -0.06172894f, 0.22239280f, 0.13097343f, -0.04059829f, -0.00440338f, 
    -0.01284886f, -0.12245730f, -0.06532475f, -0.02418707f, 0.08358334f, 0.02992598f, 0.09564003f, -0.01325317f, 
    0.33327675f, -0.22081949f, -0.15429798f, 0.14307387f, 0.09579600f, 0.18521343f, 0.01488510f, 0.18337421f, 
    -0.11859302f, -0.01273274f, -0.05597323f, -0.02025660f, 0.07758513f, -0.02173659f, 0.06954674f, 0.06833953f, 
    0.15020697f, -0.07272573f, 0.05662161f, 0.00204201f, -0.02318198f, -0.02317273f, 0.06488603f, 0.10269748f, 
    -0.14211364f, 0.04325124f, -0.05963441f, -0.01435861f, -0.07684732f, 0.04111607f, -0.01930366f, -0.01182144f, 
    -0.00773287f, 0.05510601f, -0.04909093f, -0.04175001f, 0.41934481f, 0.16634072f, -0.11268748f, 0.04154854f, 
    -0.05230397f, -0.08806522f, -0.02452790f, 0.00966499f, 0.07823673f, -0.02534552f, -0.08843488f, -0.07708614f, 
    0.43720379f, -0.44853136f, -0.14637561f, -0.02336193f, -0.04131628f, 0.12889348f, 0.04765646f, 0.07836753f, 
    0.04094676f, 0.05566743f, -0.05097969f, 0.01827739f, 0.27239344f, -0.15436803f, -0.04909321f, 0.09891897f, 
    -0.17700885f, -0.00137931f, -0.04269920f, -0.09561791f, 0.11453406f, 0.07560458f, -0.03968711f, 0.08671726f, 
    0.10172618f, -0.06203179f, 0.08455183f, 0.06466702f, 0.14993022f, 0.04294480f, -0.02426175f, -0.01898369f, 
    -0.01739122f, 0.03676114f, 0.00593699f, 0.00648674f, -0.20910001f, 0.06755985f, -0.07877361f, -0.02095404f, 
    -0.02239864f, -0.02984010f, 0.06157905f, -0.09168005f, -0.01379833f, -0.03315822f, -0.16364625f, -0.05376535f, 
    -0.19783722f, 0.04869912f, -0.06084627f, 0.03507745f, -0.12425748f, -0.00386904f, 0.03862245f, 0.02016417f, 
    0.05091960f, -0.05910473f, -0.15146635f, -0.20005345f, 0.07820452f, -0.00988877f, 0.00727470f, -0.10594734f, 
    -0.06135958f, -0.02910739f, -0.03310593f, 0.08370128f, 0.02555575f, 0.10854971f, 0.06647757f, 0.00700166f, 
    0.14989652f, -0.05035692f, 0.04139819f, -0.08959877f, 0.11048430f, 0.01020375f, 0.10261122f, -0.21717361f, 
    -0.03899467f, 0.19223887f, -0.13330500f, -0.07939156f, -0.31953740f, 0.08815412f, 0.32396403f, 0.02141079f, 
    0.00949294f, 0.04580922f, 0.06831978f, 0.01732725f, 0.03135915f, 0.05628996f, 0.10294788f, -0.08809299f, 
    0.05975256f, 0.13160217f, 0.01242550f, -0.18805228f, 0.01615257f, 0.05649978f, -0.01534395f, 0.00008693f, 
    -0.05805198f, 0.00113085f, 0.00671879f, -0.00650626f, 0.01816545f, -0.04778804f, 0.28615281f, -0.18666086f, 
    0.01210062f, 0.05644341f, 0.02985816f, -0.08343616f, -0.01039211f, -0.09001304f, 0.05927808f, -0.00234006f, 
    -0.04100254f, -0.11333416f, -0.06896590f, -0.18636356f, 0.16476934f, -0.16167109f, -0.01043897f, -0.05384708f, 
    -0.03554782f, 0.04177612f, 0.05280876f, -0.02507864f, -0.20036089f, 0.08675022f, -0.09631562f, 0.05129260f, 
    0.07724858f, 0.00213535f, 0.04821800f, 0.01182959f, 0.04641526f, 0.08285772f, 0.01961737f, 0.14007826f, 
    0.21259350f, 0.18048277f, -0.01733585f, -0.01442612f, -0.03208127f, 0.03619711f, -0.10356656f, -0.00550013f, 
    -0.06296679f, 0.03750546f, -0.02768851f, 0.02645884f, 0.11699534f, -0.10473573f, -0.09407655f, -0.08492691f, 
    -0.07649621f, 0.03241273f, -0.01232739f, 0.04067354f, 0.07809439f, 0.02893670f, 0.14405079f, 0.05450589f, 
    -0.09807525f, 0.25763941f, 0.17417127f, 0.24649511f, 0.04409616f, -0.07548061f, -0.00912399f, -0.06931356f, 
    -0.02509177f, -0.14262895f, 0.01320138f, -0.02767178f, 0.54016918f, -0.10227182f, -0.04507535f, -0.00978140f, 
    -0.08941304f, 0.01028285f, 0.00925514f, -0.05352176f, -0.03218831f, -0.00303316f, -0.06694979f, -0.08308682f, 
    -0.01728304f, -0.04621553f, -0.03215339f, -0.04500093f, -0.02140490f, -0.04213913f, -0.06564929f, -0.00898028f, 
    -0.03136493f, 0.02440170f, -0.03647869f, -0.00425825f, 0.00286657f, 0.00480075f, -0.02543480f, -0.03095739f, 
    -0.05970429f, -0.05041323f, -0.04535145f, 0.02632961f, 0.00316585f, -0.05557888f, 0.00083588f, -0.00670324f, 
    -0.02505969f, -0.00101575f, -0.04214023f, -0.03710596f, 0.00432793f, -0.05329744f, 0.00743134f, -0.03793151f, 
    0.01143878f, 0.02613387f, 0.01384804f, -0.01232403f, -0.05215248f, -0.05382233f, 0.00139838f, -0.06033122f, 
    0.00239691f, -0.05645522f, 0.00167088f, 0.00162378f, -0.04277691f, 0.03320163f, -0.05447727f, -0.00009726f, 
    -0.00147989f, -0.03422990f, 0.01632596f, 0.01564912f, -0.02478713f, 0.03556103f, -0.06467604f, -0.04664617f, 
    0.00124312f, -0.01069521f, -0.05092726f, -0.04417370f, -0.06552255f, 0.01543934f, 0.02613949f, -0.00525833f, 
    -0.02357342f, -0.02543782f, 0.01579179f, 0.02471718f, 0.03103788f, -0.02573594f, 0.00156939f, -0.03149327f, 
    -0.01502710f, -0.01987692f, -0.05381849f, -0.02086392f, -0.04207565f, 0.02517881f, -0.02341189f, 0.03085285f, 
    -0.06579892f, -0.05441139f, -0.03150043f, 0.00657645f, -0.04565275f, -0.03119487f, -0.00164798f, -0.01892198f, 
    0.02370285f, 0.03360353f, -0.06130687f, -0.00939922f, -0.02989471f, 0.01308844f, -0.04930678f, 0.02478657f, 
    -0.03277284f, 0.03981382f, 0.01582474f, -0.01536819f, -0.01450905f, -0.02257877f, 0.01791351f, -0.02839880f, 
    0.00709483f, 0.02289320f, -0.05459051f, -0.05814804f, 0.03275574f, -0.04874601f, -0.03963169f, -0.02502614f, 
    -0.04250654f, -0.05169862f, -0.02898938f, 0.00149007f, -0.00057197f, -0.01800049f, -0.05787034f, -0.03719638f, 
    -0.02444200f, -0.06444902f, -0.05253693f, -0.06048168f, -0.04306554f, -0.04701295f, -0.04036760f, -0.03569722f, 
    -0.01072407f, -0.06200362f, -0.01280659f, -0.06610931f, -0.01091895f, -0.04540290f, -0.03132522f, 0.01360634f, 
    -0.03373417f, -0.03363793f, 0.01981103f, -0.03161467f, 0.01955799f, 0.00227377f, 0.01083298f, -0.00881818f, 
    0.00338255f, -0.05975987f, -0.03240000f, -0.05419663f, -0.02546403f, -0.05830535f, -0.04501576f, -0.01157766f, 
    -0.04390378f, 0.03094039f, 0.03684606f, -0.04267814f, 0.01017482f, -0.05462554f, -0.05811195f, -0.04479412f, 
    -0.04424750f, 0.04523318f, -0.03387034f, -0.03198070f, -0.01672792f, -0.03675752f, -0.02182393f, 0.02774439f, 
    0.00277937f, 0.03403604f, -0.00724056f, -0.01594453f, 0.01307661f, 0.01499269f, 0.02014620f, 0.01519645f, 
    0.01599562f, 0.01703913f, 0.01671639f, -0.05380240f, 0.00462633f, 0.03477965f, -0.01343353f, -0.00152058f, 
    0.01447878f, -0.00104975f, -0.05904415f, 0.02418926f, -0.00250241f, 0.03225616f, -0.01256186f, -0.03719864f, 
    -0.05138006f, -0.06183977f, -0.05193283f, -0.01577314f, -0.00960314f, 0.00248937f, 0.01335695f, -0.01991575f, 
    -0.00381895f, -0.05505848f, -0.03171761f, -0.03989278f, 0.03179211f, 0.01730368f, 0.00316428f, -0.04505913f, 
    -0.05744768f, -0.06184169f, -0.01853431f, -0.05434406f, -0.03343639f, -0.02474406f, -0.03450716f, -0.04431470f, 
    0.00982457f, -0.03463244f, 0.02439530f, -0.01924301f, 0.03210725f, -0.03031152f, -0.06445500f, -0.04054844f, 
    -0.04051558f, -0.01430152f, -0.02340422f, -0.05901062f, -0.05162916f, -0.00546140f, 0.01803730f, -0.01396861f, 
    0.02473046f, 0.00768109f, -0.05578085f, -0.06332281f, -0.06612894f, -0.06193291f, 0.00135041f, -0.04407335f, 
    0.02555118f, -0.00271304f, -0.05630433f, -0.04562632f, -0.05091082f, -0.06137649f, -0.03240335f, -0.00677018f, 
    -0.00281185f, -0.04524207f, -0.01494618f, -0.04242711f, 0.01871361f, 0.01901941f, -0.06634025f, -0.03314568f, 
    0.00226004f, -0.05466225f, -0.00647997f, 0.01706314f, 0.01106959f, -0.04265223f, 0.03733169f, 0.04768000f, 
    0.02113065f, -0.01962544f, -0.01268383f, 0.00052372f, -0.02451112f, 0.00697136f, -0.05611480f, 0.02775861f, 
    0.01305198f, 0.02467090f, -0.01963292f, -0.06331311f, 0.03040448f, -0.00338060f, -0.06176612f, -0.06583034f, 
    0.01880148f, -0.05314660f, 0.04939955f, -0.03852014f, -0.03953106f, 0.03140314f, -0.02233687f, 0.00519268f, 
    -0.04909271f, -0.02536517f, -0.06453802f, -0.05299367f, -0.00654558f, 0.01446594f, -0.00046240f, 0.02144617f, 
    0.01864979f, -0.01695683f, -0.01335172f, -0.03195040f, -0.02438689f, 0.03443151f, -0.00151339f, -0.01628545f, 
    -0.05910221f, -0.00585040f, -0.04451635f, -0.05118329f, -0.00196766f, -0.05422108f, -0.05671868f, -0.01576439f, 
    -0.02656098f, 0.02814219f, 0.02237201f, -0.04556052f, 0.00316824f, 0.03443374f, -0.04850786f, -0.06010168f, 
    -0.02258353f, 0.02734709f, 0.02208757f, 0.02755708f, 0.01831439f, -0.01053326f, -0.05948083f, 0.04038708f, 
    -0.05697979f, 0.00565507f, -0.02170426f, -0.03370548f, -0.01306345f, -0.01805455f, -0.03051626f, 0.04969032f, 
    -0.04507789f, -0.00452376f, -0.06610602f, -0.01525187f, -0.05306048f, -0.04113402f, -0.00275998f, -0.03552291f, 
    0.01062900f, -0.04768126f, -0.05740342f, -0.00416113f, -0.05274130f, -0.06014394f, 0.01460629f, 0.04261300f, 
    -0.04656192f, -0.04951870f, 0.01249501f, -0.03729108f, -0.03168579f, -0.06193826f, -0.01262437f, -0.00091662f, 
    0.01136838f, 0.00592515f, -0.02316009f, -0.02089203f, -0.03367120f, -0.00849322f, -0.05598615f, -0.05449471f, 
    0.03697061f, -0.03657148f, -0.00488886f, -0.06241544f, -0.04076263f, -0.03201674f, 0.04081442f, -0.01218174f, 
    -0.06185962f, -0.00196406f, 0.01404013f, 0.01041453f, 0.01245048f, -0.05971726f, -0.02755229f, -0.04054069f, 
    -0.13574113f, -0.05534821f, 0.25571951f, 0.09305779f, -0.00345303f, 0.08312416f, -0.04262994f, 0.05894057f, 
    0.09074309f, -0.09037319f, 0.02482617f, 0.10375372f, 0.03743262f, 0.11833018f, 0.03106224f, -0.03360447f, 
    0.12385965f, 0.02317382f, 0.18059936f, 0.07438202f, 0.04725077f, -0.06446430f, -0.03636359f, 0.05101919f, 
    -0.25619248f, -0.00650666f, 0.08851393f, -0.04116759f, 0.02781763f, 0.10622959f, 0.11608215f, 0.14277573f, 
    0.08113567f, 0.12188546f, 0.00738802f, -0.00173814f, 0.11683846f, 0.01063402f, -0.04541283f, -0.14696224f, 
    -0.11053892f, -0.00011859f, 0.06013119f, 0.03788879f, -0.01832883f, -0.12113331f, 0.04119578f, -0.05197158f, 
    -0.24217877f, 0.00482480f, 0.28553611f, -0.08016226f, -0.00930193f, -0.00211631f, 0.08599108f, 0.11959347f, 
    0.01799379f, -0.00931374f, 0.05754451f, -0.04313269f, 0.06954914f, 0.20071076f, -0.21897691f, -0.03543615f, 
    -0.02264607f, -0.03957839f, 0.11430039f, 0.05308826f, -0.05978848f, -0.05088420f, 0.05170681f, 0.11513320f, 
    0.14271508f, -0.12708288f, 0.09945542f, 0.03954531f, -0.16960034f, 0.03678979f, 0.15695542f, 0.01293112f, 
    0.00913920f, 0.05161148f, 0.06423657f, 0.06857082f, 0.09904019f, -0.05578559f, 0.10512250f, 0.09850583f, 
    0.08001100f, 0.17077853f, 0.04535189f, 0.11380950f, -0.02263946f, -0.05071818f, -0.01839648f, 0.07357214f, 
    -0.05356145f, -0.03637091f, 0.29633075f, 0.13159502f, -0.01609067f, -0.03444265f, -0.01101230f, -0.02519031f, 
    0.20907897f, -0.08524177f, 0.00067871f, -0.08641873f, 0.14914151f, 0.06933109f, 0.10078178f, 0.12871970f, 
    0.04605330f, 0.21762341f, 0.08626509f, -0.03726045f, 0.07535967f, 0.07391397f, 0.06503698f, -0.07032356f, 
    -0.00823720f, -0.29991305f, 0.26833251f, 0.01537187f, -0.00710521f, -0.12726603f, 0.33019090f, -0.02302814f, 
    -0.01798176f, 0.10236056f, 0.04160409f, 0.08103419f, 0.04886588f, -0.05835885f, 0.18439183f, -0.05115762f, 
    0.09372116f, -0.06337733f, 0.09411611f, 0.05299522f, -0.07367881f, -0.00396623f, 0.09286883f, -0.03767018f, 
    0.17163190f, 0.20172425f, -0.09488346f, -0.04383493f, 0.17909880f, 0.08379398f, 0.04052975f, 0.05419652f, 
    -0.04328506f, 0.21995836f, 0.12858365f, -0.08975967f, -0.15715006f, -0.13889964f, 0.20135739f, -0.09037646f, 
    -0.17209239f, -0.05708278f, 0.12866735f, 0.06709664f, 0.03965444f, -0.05188965f, 0.02757522f, -0.02705682f, 
    0.15961364f, -0.08728130f, 0.11108294f, 0.03805408f, -0.03895986f, 0.00775892f, 0.09500050f, 0.09711239f, 
    0.09671880f, 0.03188189f, 0.09640283f, 0.08639364f, 0.00613144f, -0.09291480f, -0.14095850f, 0.15463974f, 
    0.04622559f, -0.03679312f, 0.08504268f, 0.09041887f, -0.07719970f, 0.04926354f, 0.21455117f, 0.11722907f, 
    0.05342668f, 0.03932981f, 0.10345309f, 0.14463352f, 0.12800892f, -0.00572850f, 0.00689124f, -0.14230157f, 
    -0.12576364f, -0.00096611f, 0.01875442f, 0.16174120f, -0.00112987f, -0.06021018f, -0.01467417f, 0.21164867f, 
    0.01616454f, -0.05678261f, -0.17628074f, 0.12715553f, -0.04886883f, -0.02983693f, 0.03699926f, -0.03627716f, 
    0.27045116f, 0.17989725f, -0.07095890f, -0.07569867f, -0.03510560f, 0.15417367f, 0.12935314f, 0.08429584f, 
    -0.04241396f, 0.06594229f, 0.03872787f, 0.06627801f, 0.21493821f, -0.05575629f, 0.17491777f, 0.22736360f, 
    -0.04498822f, 0.03148751f, 0.08407241f, 0.09718129f, -0.11219198f, 0.00963450f, 0.18865433f, 0.09331545f, 
    -0.26097691f, 0.05071455f, 0.03050387f, -0.15220758f, -0.06526523f, -0.09275938f, 0.05480310f, -0.02378426f, 
    -0.15478134f, 0.09497111f, -0.07408667f, -0.05707665f, 0.01338525f, 0.21970859f, -0.24170849f, -0.05756026f, 
    -0.00291702f, 0.05924923f, 0.20377871f, 0.18160886f, -0.03890273f, -0.00062924f, -0.03065475f, 0.01254733f, 
    0.16955963f, 0.05175219f, 0.11465920f, 0.16553321f, 0.03544389f, -0.10998411f, -0.00160836f, 0.03132744f, 
    0.07618314f, -0.15079999f, 0.23638424f, 0.03648029f, -0.00025855f, -0.02318169f, 0.00620877f, 0.28413904f, 
    0.10719536f, 0.08196495f, -0.00746242f, -0.05669516f, 0.02644524f, -0.07653754f, -0.00637391f, -0.05369107f, 
    0.18013045f, -0.04751736f, -0.03129679f, 0.30001965f, 0.08179278f, 0.17620115f, -0.05042753f, -0.01519377f, 
    -0.03998161f, 0.05170275f, -0.01238701f, 0.04989717f, 0.07069328f, -0.20886283f, -0.00800556f, 0.24591364f, 
    0.16141447f, -0.10282211f, 0.09934088f, 0.13862577f, 0.05828619f, 0.14702380f, 0.11469039f, -0.04785918f, 
    -0.04925784f, -0.25782192f, 0.24782296f, 0.11527094f, 0.01798998f, 0.14181228f, 0.32859862f, 0.15022877f, 
    0.05842420f, 0.06328045f, 0.02572548f, 0.06279892f, -0.20740671f, -0.01866378f, 0.08998134f, 0.02063119f, 
    -0.09609491f, -0.00923270f, 0.05801090f, 0.14532045f, 0.00095385f, 0.06149630f, 0.05458021f, -0.03236952f, 
    -0.17020543f, 0.18171558f, -0.00317008f, 0.05576904f, 0.10035086f, 0.04545236f, 0.05498112f, 0.10985219f, 
    0.07726628f, -0.02105782f, -0.04169532f, 0.05515603f, -0.57927710f, 0.15662186f, 0.05564685f, -0.14609842f, 
    -0.00835912f, 0.06421786f, 0.02104923f, 0.01830280f, 0.06264035f, -0.09378613f, -0.15975460f, -0.06483671f, 
    -0.02486159f, 0.19545278f, -0.03484038f, 0.04088014f, 0.07980105f, -0.00957180f, -0.01326765f, 0.22441854f, 
    -0.01529725f, 0.05815900f, 0.12862605f, 0.10935616f, -0.20268424f, 0.32923794f, -0.07173949f, -0.00921016f, 
    0.06301443f, 0.07070158f, -0.03990466f, 0.21219517f, 0.04216613f, -0.00079812f, 0.00466761f, 0.00981018f, 
    0.11869589f, -0.13307148f, -0.08620524f, 0.10207603f, 0.05465898f, -0.02241612f, 0.00754870f, 0.04897227f, 
    0.02285526f, -0.06022106f, 0.15419517f, -0.04863732f, -0.24746223f, -0.00629430f, 0.06471637f, 0.05548563f, 
    -0.09314115f, -0.00414005f, -0.04591789f, 0.12220117f, 0.04685755f, 0.11007341f, 0.09421503f, 0.11059899f, 
    -0.22052705f, 0.07787226f, -0.04163682f, -0.05256275f, -0.04040042f, 0.11645356f, -0.19712861f, -0.04368800f, 
    -0.06500077f, -0.13098583f, 0.07587599f, -0.08795258f, 0.27116847f, -0.34329990f, -0.10500088f, 0.09954008f, 
    0.21836978f, -0.03888184f, 0.03022526f, -0.06660090f, 0.11205278f, 0.08533024f, 0.01880059f, 0.05238926f, 
    0.21772590f, -0.05266519f, -0.18867992f, 0.14133437f, 0.05245743f, 0.10034922f, 0.10410562f, 0.06229233f, 
    0.11247907f, 0.08024460f, 0.10232296f, 0.06076087f, 0.14972664f, 0.23619518f, -0.03130254f, 0.13048744f, 
    0.01924290f, -0.02615589f, -0.07886430f, 0.13623095f, 0.01159615f, 0.02495593f, 0.00542161f, -0.15996607f, 
    0.12787238f, 0.12333235f, 0.13883710f, -0.06859247f, 0.14168914f, 0.02497696f, 0.06327381f, -0.01019410f, 
    -0.02976057f, 0.06915288f, -0.04254673f, -0.01763534f, 0.19573906f, 0.17862350f, -0.07245703f, -0.09234118f, 
    -0.00165524f, 0.01891889f, 0.15903570f, 0.03349628f, 0.02849199f, 0.13291410f, 0.11235960f, -0.04737874f, 
    0.12165540f, 0.01153285f, -0.05964070f, 0.01289930f, 0.09417442f, 0.05044523f, 0.07134197f, 0.07101444f, 
    -0.13284820f, 0.06625677f, 0.05459500f, 0.11058164f, -0.18570569f, -0.01493117f, 0.03024634f, -0.03608958f, 
    0.05731355f, -0.15420847f, -0.04513671f, 0.01215355f, -0.04472576f, 0.03861982f, -0.01761437f, 0.19621283f, 
    0.13821276f, 0.20630175f, 0.18561755f, -0.11992133f, 0.00383620f, 0.16208075f, -0.14094165f, 0.06313613f, 
    0.01554940f, -0.04999243f, -0.06758881f, -0.01047779f, 0.07397754f, 0.24592610f, -0.05700481f, -0.04311687f, 
    -0.13370664f, -0.06413373f, -0.02842083f, 0.12257499f, 0.09157942f, 0.16048126f, 0.05306327f, -0.07642166f, 
    0.17701498f, -0.11498868f, -0.08608732f, 0.27121988f, -0.03945110f, 0.11343360f, -0.02217600f, 0.07047214f, 
    -0.11233186f, -0.02413088f, -0.00635512f, 0.07406987f, 0.36664131f, 0.00184246f, -0.24482305f, 0.19100025f, 
    0.11287413f, -0.08358417f, 0.02436851f, -0.07401564f, 0.08925748f, 0.06115133f, 0.06933941f, 0.10191990f, 
    -0.09023042f, -0.13688359f, 0.01432510f, -0.05050806f, 0.04953933f, 0.08648705f, 0.00488477f, -0.06505045f, 
    0.00736848f, -0.01891001f, -0.00944458f, -0.11612266f, 0.20550697f, -0.01076450f, 0.00055423f, -0.08778827f, 
    -0.08784338f, -0.03127747f, -0.01504875f, -0.01640215f, 0.00840110f, -0.03535439f, -0.07362099f, -0.17362422f, 
    -0.05571166f, -0.14915048f, -0.12120664f, 0.08728204f, 0.15349628f, -0.01779257f, 0.04678223f, 0.22810528f, 
    0.08741301f, 0.02261620f, -0.00508920f, -0.03068669f, -0.30167341f, 0.18404908f, -0.02017780f, 0.11977254f, 
    0.05035956f, -0.01489126f, 0.07434019f, -0.04215921f, 0.01849954f, 0.02799076f, -0.03758267f, 0.18165264f, 
    -0.04513847f, -0.19556960f, 0.10715239f, 0.15319532f, 0.17366861f, -0.00310350f, -0.10496664f, -0.03344209f, 
    0.12837927f, 0.08141152f, -0.00607013f, -0.04544855f, -0.43343914f, 0.16121432f, -0.06823902f, -0.12361147f, 
    -0.05958727f, -0.00086168f, -0.05481518f, -0.02195494f, 0.01798465f, 0.03709972f, -0.17460306f, 0.01655086f, 
    0.05485512f, -0.11012019f, 0.01294560f, 0.09345672f, -0.09484246f, -0.06731279f, 0.02860465f, 0.01317395f, 
    0.15884613f, -0.02806867f, -0.17425980f, -0.17741214f, -0.04852374f, 0.00463367f, 0.00424517f, -0.13883455f, 
    -0.05585473f, -0.14981191f, -0.14484797f, 0.04666415f, -0.02665337f, 0.13511728f, 0.09495071f, -0.01235385f, 
    0.30779004f, -0.03686502f, -0.02785392f, 0.03208938f, 0.09738771f, 0.02786078f, 0.10359197f, -0.03475681f, 
    -0.02454115f, 0.22852854f, -0.14479002f, 0.03553334f, 0.09696916f, -0.05065501f, 0.15195322f, -0.10028303f, 
    0.00015065f, -0.09163958f, 0.07707833f, 0.07114198f, 0.03357240f, 0.05729498f, 0.05205745f, 0.12379309f, 
    -0.05928941f, 0.32335407f, -0.02046319f, -0.32847834f, -0.00591480f, -0.00926360f, -0.01198733f, 0.01952969f, 
    -0.00963520f, 0.09719439f, 0.04519841f, -0.01991689f, 0.26265591f, 0.04820195f, 0.21251826f, -0.08739834f, 
    -0.07061575f, -0.00637272f, 0.01277320f, -0.12957828f, -0.00818802f, -0.10884435f, -0.01191168f, 0.04130192f, 
    0.35897169f, -0.12826501f, -0.19274208f, -0.18214893f, 0.10281938f, -0.10939016f, -0.17074668f, -0.10933308f, 
    0.03623239f, 0.05551957f, 0.19386053f, 0.04601458f, 0.27201235f, -0.07458082f, -0.07940023f, 0.05784795f, 
    0.13889430f, -0.02474176f, -0.08494730f, -0.06159816f, 0.05434505f, -0.06723625f, 0.05358916f, 0.05233358f, 
    0.11644957f, 0.17734358f, 0.07338215f, -0.01143124f, -0.11943109f, -0.01531935f, -0.07430799f, -0.03200779f, 
    -0.14136556f, 0.06492408f, -0.01146615f, -0.01515177f, 0.41595581f, -0.20629837f, -0.18281764f, 0.05495416f, 
    -0.02724239f, -0.12889549f, -0.02128263f, 0.02376772f, 0.05140745f, 0.02922640f, 0.08911972f, 0.08874872f, 
    -0.11072683f, 0.08050280f, 0.20124350f, 0.06204843f, -0.11384828f, 0.05354973f, 0.00031304f, 0.05545113f, 
    -0.03862539f, -0.13229856f, -0.07789753f, -0.06607351f, 0.31377053f, -0.00221486f, -0.07450060f, 0.10167649f, 
    -0.01757853f, -0.07628392f, 0.04281297f, -0.17549807f, -0.07941474f, -0.01714359f, 0.03985031f, 0.01724422f, 
    -0.02624797f, -0.21792264f, -0.01596794f, 0.29749271f, -0.04548103f, 0.03768645f, 0.02589227f, 0.07097694f, 
    0.07938077f, -0.14900859f, 0.10503540f, -0.03675424f, -0.02551317f, 0.09908061f, -0.04266394f, 0.06847530f, 
    -0.09254307f, 0.05442482f, 0.01018226f, -0.04663052f, 0.10776161f, 0.06569047f, -0.00916448f, 0.04961285f, 
    0.29443404f, 0.22456321f, 0.10916483f, 0.06628124f, -0.04181382f, 0.08283581f, -0.09374925f, 0.00146590f, 
    -0.09558669f, -0.05055224f, 0.02422080f, 0.05470550f, 0.26616085f, 0.02691170f, 0.05718059f, 0.27299452f, 
    0.02624656f, -0.06321794f, -0.08134238f, -0.01798238f, -0.08587743f, 0.03759195f, 0.01312120f, -0.02863146f, 
    0.05556737f, 0.01791354f, 0.03962847f, 0.18986735f, -0.06694195f, 0.00697575f, 0.10497618f, 0.03296652f, 
    0.02458496f, -0.03779792f, 0.06733268f, -0.06055484f, -0.11494858f, 0.19116296f, -0.01074717f, 0.02732167f, 
    0.05751099f, 0.01891633f, -0.14815782f, -0.04494104f, 0.01659362f, 0.06066479f, -0.00890759f, -0.04186481f, 
    -0.12561288f, 0.17972764f, -0.03051072f, -0.06798290f, 0.13550600f, -0.01663292f, -0.14479022f, 0.01144835f, 
    -0.00436580f, 0.03896351f, 0.02111818f, 0.13359439f, -0.26007655f, -0.11426181f, 0.19514835f, 0.00065592f, 
    -0.02335257f, -0.05530265f, 0.09949366f, 0.06956858f, 0.04627754f, 0.11896650f, -0.00064664f, 0.01289395f, 
    -0.28089359f, -0.00074687f, -0.01776264f, 0.00589939f, -0.00600276f, 0.00328811f, -0.07941799f, -0.08971795f, 
    0.03641546f, 0.05128917f, 0.06519163f, 0.22809245f, -0.24180949f, -0.09230848f, 0.01509433f, 0.16716059f, 
    0.02752275f, -0.01085007f, -0.00849521f, 0.09990711f, 0.04652088f, 0.07937053f, -0.07545604f, 0.13013576f, 
    0.19012147f, 0.00410801f, 0.04809203f, -0.31869385f, 0.03805401f, 0.03142169f, -0.15715940f, 0.14630580f, 
    0.06612312f, -0.00808180f, 0.02519309f, 0.08018170f, -0.09590773f, -0.07153218f, 0.07909940f, -0.10809383f, 
    0.04695107f, 0.02536483f, -0.05671956f, 0.10821230f, 0.14338931f, 0.09800334f, -0.01096378f, 0.05293177f, 
    -0.22506228f, -0.14485364f, 0.01346297f, 0.01426928f, -0.05216570f, -0.05902421f, 0.03248965f, 0.03201047f, 
    -0.10797521f, -0.04234855f, -0.00766530f, 0.00421684f, 0.38112411f, 0.12337976f, -0.09510873f, -0.12229366f, 
    0.08036913f, -0.03562246f, -0.03113388f, -0.03606348f, -0.09155923f, 0.00334551f, 0.02464211f, -0.02465801f, 
    0.25947893f, 0.11669827f, 0.08156277f, 0.32349467f, 0.01918052f, 0.02729028f, 0.09194876f, 0.07123262f, 
    -0.07749753f, 0.06705798f, 0.10289782f, -0.06317464f, -0.10089885f, 0.05386544f, 0.17202537f, -0.13717817f, 
    0.14255725f, -0.03350832f, -0.06518909f, -0.01399544f, 0.15166475f, 0.07238694f, -0.05022281f, 0.04689404f, 
    -0.18560988f, -0.16109802f, 0.10971341f, 0.09720060f, -0.03156551f, 0.07113666f, -0.02771921f, 0.14317870f, 
    -0.00074610f, 0.00324604f, 0.09337487f, 0.02446703f, -0.34296322f, 0.06902350f, -0.01050367f, 0.07940773f, 
    -0.04399309f, 0.09884783f, 0.03774286f, 0.04658415f, 0.06394083f, -0.02869470f, -0.02162338f, 0.06165478f, 
    -0.01140470f, 0.00237801f, 0.17511757f, 0.25678381f, 0.04881910f, 0.00779883f, -0.06583003f, 0.01326082f, 
    0.04441006f, -0.02973245f, -0.04444438f, -0.12764797f, -0.23636402f, -0.11179809f, -0.10299817f, -0.02924543f, 
    0.04042284f, -0.01961122f, 0.06960200f, -0.04466380f, 0.00529778f, 0.02768703f, -0.17781213f, -0.00960897f, 
    0.07043198f, 0.22276638f, 0.21439941f, 0.06060907f, 0.12569818f, -0.02272671f, 0.06646612f, -0.01211509f, 
    0.07226160f, -0.00559764f, -0.03119514f, 0.02830536f, 0.13934907f, 0.09585633f, 0.21807572f, 0.23829867f, 
    0.02659796f, -0.10182040f, -0.02572514f, -0.05463690f, 0.11776119f, 0.07949056f, -0.02421299f, -0.03156383f, 
    -0.31235889f, -0.06505350f, -0.03044184f, -0.13398188f, 0.03522648f, 0.09415832f, 0.09618113f, 0.02557294f, 
    -0.03603028f, 0.05865452f, -0.09699389f, 0.05753131f, 0.16394089f, -0.00230049f, 0.00048352f, -0.01089483f, 
    -0.02639544f, -0.01384467f, -0.01794444f, -0.00952189f, 0.07430777f, -0.00461673f, -0.09933241f, -0.03446928f, 
    -0.21331848f, -0.19423617f, 0.06600718f, -0.08523332f, -0.11503410f, -0.09707094f, 0.04120823f, 0.04514374f, 
    0.03362956f, -0.00507422f, 0.09777428f, -0.01575839f, -0.04678768f, 0.11129731f, 0.24287441f, -0.24011931f, 
    -0.05032685f, 0.10700942f, 0.09133493f, 0.10085765f, 0.03656573f, -0.13807239f, -0.00288975f, 0.12338631f, 
    0.10214657f, 0.23729850f, -0.09455522f, -0.14872824f, -0.01357567f, 0.10966998f, -0.11376374f, 0.07817294f, 
    0.02182459f, -0.10472046f, -0.00614262f, 0.03655383f, 0.11322525f, -0.03967218f, -0.09146147f, 0.26103082f, 
    0.06212987f, 0.01837102f, 0.09145744f, 0.01604364f, 0.02822155f, -0.12508328f, 0.06538681f, -0.02038643f, 
    -0.14127767f, 0.05422086f, 0.10897051f, -0.17269142f, -0.06132549f, -0.01921773f, -0.01643823f, -0.06884991f, 
    0.08536376f, 0.01761053f, 0.03408472f, 0.02187073f, 0.17342846f, -0.01555255f, -0.15292984f, 0.17100629f, 
    0.03653889f, -0.04624226f, 0.04032334f, 0.08427755f, 0.05220978f, 0.01411415f, 0.09952729f, 0.02169323f, 
    -0.09752671f, -0.17235771f, 0.04603419f, 0.00541542f, 0.08633272f, 0.07448682f, -0.11985570f, 0.06944335f, 
    0.15038496f, -0.07794868f, -0.05866150f, 0.02020880f, -0.29839930f, -0.04886717f, -0.01833278f, 0.02891564f, 
    0.01761220f, -0.01515235f, 0.07332733f, -0.10077199f, -0.14279245f, -0.00456838f, 0.09415195f, 0.01626072f, 
    0.53614450f, 0.31806004f, -0.07871117f, -0.14365849f, -0.24650332f, -0.07819694f, 0.08263774f, 0.03317108f, 
    -0.09549755f, 0.07073381f, 0.12077066f, 0.25611082f, -0.05017370f, -0.03748516f, 0.08271304f, 0.36499128f, 
    -0.03426718f, 0.07747351f, 0.06952022f, -0.12109312f, -0.02261600f, -0.01584545f, 0.08614110f, 0.12410009f, 
    0.07797904f, 0.07034254f, -0.01271653f, -0.26614630f, -0.02558534f, -0.03663822f, 0.04920113f, -0.04103591f, 
    -0.00871938f, -0.03113046f, -0.02060543f, -0.01307462f, 0.02426506f, -0.08570332f, 0.23907159f, -0.15397672f, 
    0.05521757f, -0.02048084f, 0.10128538f, 0.08803527f, 0.18193416f, 0.08432147f, 0.00801313f, 0.04443875f, 
    0.66564482f, 0.27185640f, 0.13311146f, -0.16841249f, -0.03921970f, 0.05807051f, 0.02551621f, -0.01347359f, 
    -0.07161327f, 0.03329965f, 0.09366594f, 0.10395990f, -0.36689860f, -0.06118879f, -0.04598264f, -0.21049958f, 
    0.05126095f, 0.13317527f, -0.01459576f, 0.03893768f, -0.00058059f, -0.03488932f, 0.08965433f, -0.10374995f, 
    -0.15070960f, -0.24116834f, -0.19873351f, 0.09870894f, 0.22637339f, 0.04149430f, 0.00257744f, -0.11949790f, 
    0.06438807f, -0.00201079f, -0.07678008f, 0.01015140f, -0.25942785f, -0.15598984f, -0.00764623f, -0.04626832f, 
    0.03910997f, -0.11386778f, -0.04888975f, -0.00978467f, 0.02915999f, -0.06397795f, 0.12529433f, -0.02375196f, 
    0.03782165f, -0.01369269f, 0.06730663f, 0.01487322f, 0.09446108f, -0.02961469f, -0.05219931f, 0.17793131f, 
    -0.06206576f, -0.01341066f, 0.12445064f, 0.20701382f, 0.15621006f, 0.15941928f, 0.08389854f, -0.31278759f, 
    0.10050183f, 0.07046714f, -0.04006603f, -0.13789324f, 0.00261451f, 0.05038809f, -0.06508621f, 0.04381850f, 
    0.12052684f, 0.07293387f, -0.09841329f, 0.25303394f, 0.07260799f, 0.01126283f, -0.14116965f, -0.11080009f, 
    0.06299167f, -0.11775155f, 0.08975573f, -0.08030287f, -0.08610117f, -0.06514969f, -0.40552723f, 0.31010589f, 
    0.05160968f, -0.00868877f, 0.04821197f, 0.16051540f, 0.00338036f, 0.01261276f, 0.04496981f, 0.06543517f, 
    -0.09695856f, -0.09557045f, 0.11750859f, 0.08135767f, -0.04897718f, 0.13653123f, -0.02418957f, 0.00368988f, 
    0.06226594f, -0.04182185f, 0.02893836f, 0.00382774f, 0.36824924f, 0.39193562f, 0.25871480f, 0.15158540f, 
    0.04941433f, -0.04030283f, 0.12277003f, 0.05571581f, -0.07619640f, -0.01269702f, 0.03571987f, -0.06579134f, 
    0.04706127f, 0.17946552f, 0.05099890f, 0.06456050f, -0.16938224f, -0.01498529f, 0.01031350f, 0.02210662f, 
    -0.07872403f, 0.02950881f, -0.04921502f, -0.07097797f, 0.05817980f, 0.02525169f, -0.28169674f, -0.22910851f, 
    0.06107727f, 0.02841165f, -0.02226277f, -0.04836982f, 0.06365424f, -0.04239568f, -0.17417076f, -0.11278184f, 
    -0.25056219f, -0.32018548f, 0.00923067f, -0.07735226f, 0.04392380f, 0.08031384f, 0.01949797f, -0.01219365f, 
    0.14191069f, 0.07403029f, 0.05824580f, -0.09473663f, -0.07670730f, 0.22877009f, -0.13290274f, -0.05372871f, 
    0.07796632f, 0.16269647f, 0.12280521f, -0.10691090f, 0.05211511f, -0.00004263f, -0.03724625f, -0.05485299f, 
    -0.03203686f, -0.25194702f, 0.23741733f, 0.15359004f, -0.05495451f, 0.07102053f, 0.05296208f, -0.02486369f, 
    0.13388793f, -0.00524969f, -0.07582144f, 0.02141839f, -0.24954855f, 0.12067258f, -0.17045541f, -0.02802055f, 
    0.00836340f, 0.08635457f, 0.07592083f, -0.09286325f, 0.11000916f, 0.02722116f, -0.05607231f, -0.03974900f, 
    -0.02434508f, 0.03990716f, 0.24903028f, 0.42615876f, -0.11349724f, 0.15366083f, -0.04915676f, 0.08216935f, 
    0.07389101f, -0.17566651f, -0.03672063f, 0.08742943f, -0.04539493f, -0.03102720f, 0.41746664f, 0.05745482f, 
    0.10344986f, 0.19122726f, -0.12664811f, -0.05988039f, 0.04221499f, 0.01524887f, -0.02711638f, 0.03285476f, 
    0.03692104f, -0.24237026f, -0.05704152f, 0.19633633f, -0.05406030f, -0.04854503f, 0.05358233f, -0.04173737f, 
    0.01152126f, 0.05570028f, -0.06460945f, 0.15334544f, 0.21677971f, 0.14109913f, -0.04375462f, 0.09982895f, 
    -0.06949691f, -0.08442690f, 0.10704117f, 0.04106446f, -0.05328611f, -0.06639973f, 0.03500347f, 0.06285284f, 
    -0.26638710f, -0.04493409f, -0.19775774f, -0.15338379f, 0.03814546f, 0.11868650f, -0.13001023f, -0.06794417f, 
    -0.11600943f, -0.07209109f, 0.14312311f, -0.04760628f, 0.11088349f, -0.22399123f, 0.16595721f, -0.03043807f, 
    0.01511711f, -0.02485397f, -0.00394711f, 0.05405172f, 0.01439658f, 0.01670271f, -0.00854029f, -0.06623319f, 
    0.12016585f, 0.23648581f, 0.18216982f, 0.22297807f, 0.09977601f, -0.04210125f, -0.12734939f, 0.04843645f, 
    -0.04098365f, -0.09540524f, -0.09968966f, -0.02988166f, 0.42106393f, 0.33917013f, -0.19124889f, 0.11678591f, 
    -0.02238397f, -0.13412639f, -0.08772563f, -0.07219099f, -0.10553885f, 0.03215749f, 0.03991871f, 0.06937704f, 
    -0.00491121f, -0.06978703f, 0.00184435f, -0.01712611f, 0.07273255f, 0.11565775f, -0.03754875f, 0.11695699f, 
    0.09261049f, 0.08132824f, -0.01965025f, -0.09436897f, 0.65043306f, 0.19073878f, 0.14841034f, 0.07497872f, 
    -0.02264093f, -0.04180340f, 0.06044484f, -0.03404411f, -0.07438282f, -0.00418187f, 0.15188351f, 0.02712614f, 
    -0.18503109f, -0.34946615f, -0.27155542f, -0.03057762f, 0.08380002f, 0.05127126f, 0.09090409f, -0.15365559f, 
    0.16856080f, -0.07228384f, -0.14946418f, -0.01087705f, 0.10279155f, -0.08537539f, 0.15451212f, 0.13964017f, 
    -0.00980240f, 0.23423187f, 0.16150102f, -0.04430720f, -0.04502364f, 0.13358878f, 0.12763731f, -0.01751712f, 
    -0.01162492f, 0.02192618f, -0.01938688f, 0.02039605f, -0.03690777f, -0.05804434f, 0.00309873f, -0.01165211f, 
    0.03727783f, -0.03768574f, 0.01274046f, 0.02219878f, -0.05217407f, -0.01513911f, -0.05180690f, 0.01968163f, 
    0.00410152f, 0.02837984f, -0.01019366f, -0.01690050f, -0.03015259f, -0.02405619f, -0.01685778f, -0.04404067f, 
    0.02208037f, 0.02681485f, -0.03487510f, -0.00694444f, 0.01478805f, -0.02640235f, -0.00452025f, -0.03686520f, 
    -0.04375771f, -0.03611922f, 0.02215303f, -0.05280305f, 0.02169239f, -0.00642914f, -0.01536649f, 0.01735694f, 
    0.02579928f, -0.01771027f, -0.04968081f, -0.04586773f, -0.04670715f, 0.04351620f, -0.01903758f, -0.02422319f, 
    0.02635572f, -0.02566266f, 0.03416284f, 0.02019308f, 0.03856671f, 0.02156020f, -0.00235145f, -0.05626716f, 
    -0.04696646f, 0.00956271f, 0.02474226f, -0.00723091f, 0.00984442f, -0.05462519f, -0.05009199f, 0.03132880f, 
    0.01886745f, -0.05678876f, 0.02589218f, 0.00207064f, 0.01315201f, -0.05071003f, -0.01736980f, -0.03242500f, 
    -0.04978907f, -0.04614642f, 0.01732464f, -0.02825891f, -0.05109368f, 0.03505685f, -0.00181273f, -0.00759192f, 
    -0.03173836f, -0.05348826f, -0.01204657f, 0.02564827f, 0.03345913f, -0.01976216f, -0.01637769f, -0.00713980f, 
    -0.01174993f, -0.02076562f, 0.00764630f, -0.05300988f, 0.04004165f, -0.01150596f, 0.01724001f, -0.01630534f, 
    -0.00693283f, 0.02076762f, -0.01514607f, -0.04816829f, -0.04893086f, -0.00565225f, 0.00164939f, -0.00429866f, 
    -0.05659503f, -0.03788268f, 0.01668276f, -0.00745062f, 0.04221399f, 0.04114375f, -0.05374843f, -0.04644847f, 
    -0.01864502f, -0.02205800f, 0.03202813f, -0.01116262f, 0.03617780f, -0.04469166f, 0.01438885f, 0.04031165f, 
    -0.05332178f, -0.01871918f, -0.04226485f, 0.00322304f, 0.00646316f, 0.03863302f, -0.04825663f, 0.00553584f, 
    0.01029448f, 0.04156769f, 0.02943633f, 0.00655036f, -0.00074397f, -0.02856970f, -0.03680237f, 0.04231706f, 
    0.01401332f, 0.01932604f, 0.00402102f, 0.03153722f, -0.01216328f, -0.04746993f, 0.01667999f, -0.02673824f, 
    0.00709099f, -0.01684220f, 0.01951237f, -0.04685136f, -0.00710166f, -0.03120087f, 0.02795650f, -0.02828328f, 
    -0.02579782f, -0.02228673f, 0.00010524f, -0.00892287f, -0.04102546f, -0.02954891f, -0.02075046f, -0.04871710f, 
    0.01357692f, 0.03005898f, -0.04162231f, -0.03556108f, 0.03274668f, -0.00617710f, 0.02677890f, 0.01898810f, 
    0.01451541f, 0.00184089f, -0.01639676f, 0.03463581f, 0.03786951f, -0.05583845f, 0.03819792f, -0.02964338f, 
    0.00477643f, 0.03493047f, 0.02723953f, -0.03678008f, 0.03486192f, -0.01372304f, -0.02726394f, 0.01572561f, 
    0.04273100f, 0.01654644f, 0.04332413f, -0.02891577f, -0.03895102f, 0.04295797f, -0.00341067f, -0.04713503f, 
    -0.01077618f, -0.05393630f, 0.03007105f, -0.02998455f, -0.04166804f, -0.04254718f, 0.00758784f, -0.00419602f, 
    0.00643687f, -0.00633343f, -0.04123499f, -0.02633873f, 0.02393766f, 0.00055949f, -0.03892815f, 0.02745627f, 
    -0.01396559f, 0.01256677f, 0.00223091f, -0.04688327f, -0.01154824f, -0.00017232f, -0.04317574f, 0.03345273f, 
    0.02031268f, -0.01846926f, -0.01659746f, -0.01923820f, -0.00424637f, 0.04284140f, -0.02538777f, 0.03574878f, 
    -0.04409456f, -0.02151549f, -0.04781419f, 0.00782476f, -0.01199223f, -0.01664631f, 0.02981180f, 0.00881546f, 
    -0.05658288f, 0.02351010f, -0.01122414f, -0.02476623f, 0.01170433f, 0.02650410f, 0.01592382f, 0.02969059f, 
    0.04393929f, -0.03683615f, -0.03917038f, -0.05061908f, 0.03446498f, -0.02743579f, -0.02852051f, -0.04195555f, 
    0.02122109f, -0.02072359f, 0.00090886f, -0.00560982f, -0.04758589f, -0.01884685f, 0.03123108f, 0.01974024f, 
    -0.03724404f, -0.03617968f, -0.04244816f, 0.01846546f, -0.01298079f, -0.01727289f, -0.00441182f, 0.00900004f, 
    -0.05544387f, -0.05456953f, -0.01931727f, -0.00033707f, 0.03044454f, -0.03891057f, -0.03471019f, 0.01504287f, 
    0.01066258f, 0.03657605f, 0.03918134f, -0.04634947f, -0.02608678f, -0.04639243f, -0.03846684f, 0.02951899f, 
    -0.00626429f, 0.04230385f, -0.04828619f, 0.03339407f, -0.03748749f, -0.01069488f, -0.01987937f, -0.04970894f, 
    -0.00112247f, 0.00377685f, 0.03439301f, 0.04472224f, -0.04226852f, -0.02962220f, 0.00539563f, -0.02901181f, 
    -0.04920131f, 0.03185041f, 0.00170554f, 0.00353914f, -0.01835091f, 0.01331649f, 0.03102894f, 0.03110987f, 
    0.00926793f, 0.02481543f, -0.02275268f, -0.02264385f, 0.03152185f, 0.01386534f, -0.03050104f, -0.01225270f, 
    -0.04973905f, -0.02862319f, -0.03934260f, -0.03781930f, 0.02186017f, -0.02972958f, 0.00021152f, -0.04696595f, 
    -0.04354042f, 0.00751967f, -0.01763521f, 0.00861604f, 0.02800278f, -0.00974551f, 0.02628020f, -0.03375007f, 
    0.03507852f, -0.02029642f, -0.03397365f, -0.01238765f, 0.01719954f, 0.04270894f, -0.02245234f, -0.00693208f, 
    -0.03490273f, 0.03607516f, 0.03855667f, 0.02218948f, 0.00236542f, -0.04303826f, -0.05085672f, 0.03461891f, 
    0.02577213f, 0.03190692f, -0.00706974f, -0.04290658f, -0.05374467f, -0.05111475f, -0.03309980f, 0.00693712f, 
    -0.01977240f, 0.02898166f, 0.03542427f, -0.03261565f, 0.03536503f, -0.01156180f, -0.04462187f, 0.02206761f, 
    -0.01658393f, 0.00782387f, 0.02594307f, -0.03700255f, 0.04197896f, 0.03864376f, 0.02102796f, -0.00917456f, 
    -0.04045076f, 0.00530691f, 0.01237592f, -0.04023612f, 0.03634145f, 0.03177873f, 0.02999348f, -0.01852553f, 
    -0.02981346f, 0.02356032f, -0.01576435f, 0.00293011f, -0.01900292f, -0.05603856f, -0.03091199f, -0.03955361f, 
    -0.07824323f, -0.23439673f, -0.05164187f, 0.32703030f, 0.10863750f, -0.02269017f, -0.01971560f, -0.01346199f, 
    0.08386489f, 0.02321132f, 0.19454303f, 0.03574406f, -0.28140479f, -0.01048042f, 0.24912369f, 0.18937609f, 
    0.00921895f, -0.09062449f, -0.12196179f, 0.16121034f, 0.15102775f, 0.09418052f, 0.16147859f, 0.01304606f, 
    -0.20741321f, 0.19562483f, -0.09378155f, -0.04027189f, -0.05279735f, 0.03777869f, -0.11069200f, 0.04982777f, 
    0.00143442f, -0.03325537f, 0.00532648f, -0.10565941f, 0.05352196f, -0.27540359f, -0.03568856f, -0.00730878f, 
    0.14078814f, -0.01738096f, 0.01329799f, -0.09212106f, 0.05706617f, -0.02252676f, 0.02755287f, -0.08848637f, 
    -0.11280285f, -0.15458119f, -0.12801833f, 0.18282443f, 0.06101887f, -0.06122292f, 0.08859363f, -0.01624531f, 
    0.10074887f, 0.05530687f, 0.02951717f, 0.04185369f, -0.02262772f, 0.09233149f, 0.15092923f, 0.05193650f, 
    0.04921060f, -0.00748947f, 0.08643256f, -0.01990284f, -0.04485023f, -0.02471000f, -0.01182030f, -0.06167598f, 
    0.22556104f, 0.27131754f, 0.14394802f, 0.04731218f, 0.02225731f, 0.03486236f, -0.02478501f, -0.10196338f, 
    -0.13505755f, 0.00590460f, -0.03657071f, 0.10876744f, 0.29802278f, 0.17839995f, -0.11282857f, 0.11424734f, 
    0.06543373f, 0.16765527f, 0.02833549f, -0.00540327f, 0.04944671f, 0.11625491f, 0.09128087f, -0.02304240f, 
    0.16387911f, -0.05013444f, 0.00957285f, 0.01084350f, 0.07130498f, 0.03947073f, 0.13937049f, -0.00540564f, 
    -0.04156214f, 0.04126358f, 0.14935979f, 0.13632140f, 0.01724453f, -0.16640449f, 0.15991318f, -0.00282688f, 
    0.00220653f, -0.09654491f, 0.04342142f, 0.13660383f, 0.01175533f, 0.06148959f, -0.03954900f, 0.21490985f, 
    -0.03293393f, 0.07867049f, -0.00922163f, -0.07965887f, 0.01238769f, 0.16759214f, -0.13326047f, -0.01285920f, 
    0.09322730f, 0.11339183f, -0.01712436f, -0.06739074f, 0.17587970f, 0.10444975f, 0.22646786f, 0.18531685f, 
    -0.04865443f, 0.05393131f, 0.00303123f, 0.16654919f, 0.16889973f, 0.01617081f, 0.00884778f, -0.05337420f, 
    0.22067182f, -0.01263592f, 0.18783979f, -0.13583080f, -0.18150871f, -0.04149431f, -0.02302402f, 0.01004554f, 
    0.14082274f, -0.03925261f, 0.04073852f, 0.10180517f, -0.30643898f, -0.22238277f, -0.21894917f, -0.06869075f, 
    -0.01568880f, 0.04374117f, 0.05825996f, -0.11068142f, 0.07086418f, 0.12245016f, 0.09581457f, 0.02059887f, 
    0.13308682f, -0.06699369f, 0.03784109f, -0.28926989f, 0.00792209f, 0.09898477f, -0.08586495f, -0.11670963f, 
    0.09434761f, 0.05429858f, 0.19848694f, 0.06644119f, 0.05365719f, 0.24534175f, 0.26394972f, 0.32589245f, 
    -0.05975384f, -0.01202122f, 0.07417277f, 0.00566698f, -0.05684083f, -0.02084021f, -0.04722971f, -0.22014095f, 
    0.00932749f, 0.34075007f, 0.11798492f, -0.02039295f, 0.08630580f, -0.00847353f, 0.00327933f, 0.02117590f, 
    0.16387545f, -0.07715306f, -0.02406800f, 0.01318573f, -0.16066715f, 0.20460856f, 0.17083943f, -0.06804848f, 
    0.08019005f, 0.17619605f, 0.05330716f, 0.00523183f, -0.03518518f, -0.00329195f, -0.07767086f, 0.06535306f, 
    0.01896659f, 0.00562993f, 0.10121752f, -0.07698983f, 0.17699753f, -0.01426701f, -0.02010746f, 0.09682571f, 
    0.08021905f, -0.02405947f, -0.04563648f, 0.01421053f, 0.18710904f, 0.06622878f, 0.10066659f, -0.03201925f, 
    -0.07169545f, 0.13376531f, -0.10982214f, 0.12369639f, -0.11314023f, -0.05218266f, 0.14918420f, -0.13896425f, 
    0.14792888f, 0.03968529f, -0.06287916f, -0.13203065f, -0.05924826f, 0.05835033f, 0.13321473f, 0.05377296f, 
    0.04500007f, 0.09896483f, -0.03716053f, 0.03866524f, -0.11708689f, 0.10073777f, -0.03016617f, -0.15098234f, 
    0.03997824f, -0.04324254f, -0.05062813f, 0.05103986f, -0.04355900f, 0.05093528f, 0.17235629f, -0.02773760f, 
    0.31075421f, 0.08721052f, 0.07974544f, 0.29791749f, 0.00078477f, 0.03758994f, -0.06843490f, 0.06804602f, 
    0.13019758f, 0.08662039f, -0.01054972f, 0.04384743f, -0.10382861f, -0.08819469f, -0.06913947f, 0.11123908f, 
    0.10490301f, 0.12082376f, -0.08338792f, -0.03992941f, 0.10382694f, 0.07327195f, -0.09944907f, 0.21586457f, 
    0.20585792f, 0.14698698f, 0.15405649f, 0.21666692f, 0.05764687f, -0.01975775f, 0.05712650f, -0.07275565f, 
    0.07382608f, 0.02055471f, -0.03911435f, -0.05501010f, -0.15144485f, 0.14145383f, -0.02803402f, 0.33838561f, 
    0.08839554f, 0.06038306f, 0.07819337f, -0.15505588f, 0.02284528f, -0.04562012f, -0.05832947f, -0.12889625f, 
    -0.02747213f, 0.06270042f, -0.18380795f, -0.00914193f, 0.00348881f, -0.10617772f, 0.02077916f, -0.02175600f, 
    0.08119904f, 0.05808104f, 0.07506264f, -0.03726584f, 0.01542622f, -0.09682141f, 0.01935699f, 0.11578147f, 
    0.05998130f, 0.08412364f, 0.00333733f, -0.11209404f, -0.07612289f, -0.05674130f, 0.12794827f, 0.01433097f, 
    -0.21156605f, 0.05068988f, 0.09362078f, -0.06049512f, -0.03467713f, -0.20788041f, 0.16511342f, -0.09904081f, 
    0.01699774f, 0.05901577f, 0.03275821f, 0.06792554f, 0.08982096f, -0.08818558f, -0.16785645f, 0.08876791f, 
    0.17592762f, 0.03325673f, -0.05747205f, 0.05503249f, 0.13221817f, 0.01616117f, 0.13930120f, 0.13511139f, 
    0.06839686f, 0.16257268f, 0.24631606f, 0.04232998f, 0.06824770f, 0.08979098f, 0.03977289f, -0.08794013f, 
    -0.05524832f, -0.06054193f, 0.05525970f, -0.01284138f, -0.18860753f, 0.10488924f, 0.18257192f, -0.04923383f, 
    0.00210405f, -0.14101098f, 0.01841862f, 0.11952148f, 0.02480801f, 0.08751000f, -0.15617849f, 0.03179539f, 
    0.03523586f, -0.00610988f, -0.00822257f, -0.03866636f, -0.04180678f, 0.02794984f, 0.01497091f, 0.00601379f, 
    0.01207794f, 0.01229510f, -0.04176685f, 0.01598390f, 0.02826711f, 0.01885865f, 0.01751689f, 0.02129656f, 
    -0.01452258f, 0.01004896f, 0.03076765f, -0.04095913f, 0.00866260f, -0.00022337f, -0.03314317f, -0.02747927f, 
    -0.02905290f, -0.02856936f, -0.02979395f, -0.02512140f, 0.01701820f, -0.04643223f, 0.00699639f, -0.04497730f, 
    -0.03207325f, -0.04469071f, 0.00176716f, 0.00938044f, -0.00415320f, -0.02377041f, 0.04240839f, -0.01576026f, 
    0.03253542f, -0.00850185f, -0.05337523f, -0.03421897f, -0.04636245f, -0.03911918f, -0.01063717f, 0.03783496f, 
    0.03918573f, 0.01501242f, 0.00803233f, -0.03576763f, -0.01857486f, -0.01486346f, -0.02829331f, 0.01856922f, 
    -0.04136241f, 0.01007661f, -0.05342548f, -0.04352647f, -0.04742711f, 0.03104877f, -0.05424760f, -0.01437215f, 
    -0.05093903f, -0.05482471f, 0.00925643f, -0.00614223f, -0.02865029f, 0.00419990f, 0.02767307f, -0.05504186f, 
    0.00935975f, -0.00496389f, 0.03032649f, 0.02833962f, -0.03039986f, 0.02982713f, -0.02757681f, 0.01382857f, 
    -0.02828712f, 0.03205371f, 0.02278281f, 0.02557507f, -0.03944050f, 0.00950601f, 0.03421535f, -0.02344129f, 
    0.02701376f, -0.02995551f, 0.00658530f, 0.01929177f, -0.04920705f, -0.01548975f, -0.04412792f, -0.02800665f, 
    0.03216587f, -0.03768542f, 0.03564659f, -0.00644323f, 0.01828434f, -0.03191294f, 0.02124697f, 0.00731325f, 
    0.01094616f, -0.03630963f, -0.05078960f, -0.01702540f, -0.02959818f, 0.03186626f, 0.00135151f, -0.05130535f, 
    0.00903489f, -0.04418822f, 0.01921305f, -0.04429108f, -0.05576639f, -0.05195851f, 0.02075257f, 0.03764156f, 
    0.01317688f, 0.00643964f, 0.00808643f, -0.04968751f, -0.01907229f, -0.01028481f, -0.02965737f, -0.01320115f, 
    0.02968943f, 0.00440842f, -0.04006683f, 0.02343439f, -0.00978084f, 0.01771835f, -0.00605261f, 0.00734855f, 
    0.00796657f, -0.05133575f, -0.03143854f, 0.03391201f, 0.01788485f, 0.02495700f, 0.03308621f, -0.03861007f, 
    0.02110299f, 0.02203840f, -0.05193280f, 0.00067992f, 0.00391478f, -0.05013277f, 0.02292475f, 0.00793484f, 
    -0.02310505f, 0.00334196f, 0.03947172f, -0.02503404f, 0.02847262f, 0.00102020f, -0.04960152f, -0.02604396f, 
    0.00958336f, -0.01463196f, 0.00434089f, 0.00091828f, -0.03299541f, -0.01101907f, -0.03949815f, -0.01430468f, 
    0.02116366f, 0.01891495f, -0.00033279f, -0.03975730f, 0.01789897f, -0.02835451f, -0.04060452f, -0.01523947f, 
    0.03469243f, 0.01460580f, 0.02530994f, -0.02667619f, -0.03875195f, -0.01133896f, -0.01114492f, 0.04491938f, 
    0.01734314f, 0.03284909f, -0.05253061f, -0.01714069f, 0.03834782f, 0.01109332f, 0.03901554f, 0.02875917f, 
    -0.01668509f, 0.02557569f, -0.04717065f, -0.03293876f, 0.04451324f, -0.00079460f, -0.01180784f, -0.04084214f, 
    0.01223417f, -0.04430458f, 0.00291712f, -0.02447473f, 0.04423138f, -0.04355160f, -0.03128110f, 0.01206174f, 
    0.04288656f, -0.01927785f, -0.01837827f, -0.00089006f, 0.02271189f, -0.03536790f, 0.03374166f, 0.03263422f, 
    -0.05115873f, -0.04327996f, -0.01911215f, -0.01601246f, 0.01914442f, 0.00749347f, -0.05395003f, -0.00548581f, 
    -0.03741385f, -0.01736563f, -0.02511215f, -0.00263681f, -0.00393820f, 0.02195346f, -0.05483897f, 0.03964074f, 
    0.00699075f, 0.02371307f, -0.03743639f, 0.04185563f, 0.01954077f, -0.01796104f, -0.03700876f, -0.02974289f, 
    -0.02681371f, 0.02227141f, -0.03807279f, -0.01734267f, -0.04395884f, -0.05187160f, 0.02874847f, 0.02764959f, 
    -0.05092376f, -0.04161518f, 0.03027980f, 0.00818921f, 0.04287739f, -0.01208144f, 0.00701579f, -0.02101526f, 
    0.00925973f, 0.00289159f, -0.05457050f, -0.00467351f, 0.04030273f, -0.05550842f, -0.00327579f, 0.02749478f, 
    -0.04668020f, 0.04168109f, -0.01608324f, -0.02358336f, -0.04894009f, -0.04306571f, 0.04102560f, -0.05233586f, 
    -0.03881863f, 0.03600958f, 0.03511933f, -0.03369962f, -0.03111193f, 0.02969924f, -0.05060657f, -0.03242687f, 
    0.03963701f, 0.03785325f, -0.02084549f, 0.01565925f, 0.04356854f, 0.01566182f, 0.00974959f, 0.00552201f, 
    0.02727347f, -0.00830630f, -0.00276044f, -0.01249658f, -0.02378298f, -0.01129660f, 0.01159541f, 0.02718216f, 
    -0.02036161f, -0.01434185f, -0.05605832f, -0.02763331f, -0.00991341f, -0.04219583f, 0.04427154f, -0.03121128f, 
    -0.00731452f, -0.04806570f, -0.03262063f, 0.01091910f, -0.01017158f, -0.01791115f, 0.00178561f, -0.05565635f, 
    -0.01778117f, -0.02970710f, 0.02412100f, -0.03885661f, 0.02406645f, -0.05550537f, -0.02629907f, 0.01580139f, 
    0.00608219f, -0.01657834f, 0.01565006f, 0.02379226f, 0.01677541f, -0.02299145f, -0.00114785f, -0.01928964f, 
    -0.03265677f, -0.04993267f, 0.02533493f, -0.05605863f, 0.02255540f, -0.04902428f, 0.00524629f, -0.01500964f, 
    -0.04665375f, 0.00252596f, -0.01786489f, -0.03416631f, -0.01750620f, 0.03052133f, -0.03014891f, -0.02194966f, 
    -0.05222749f, 0.02965971f, -0.01135635f, -0.05099213f, -0.02964265f, -0.04863815f, -0.00694312f, -0.03441679f, 
    0.01930047f, 0.00131213f, 0.04487866f, -0.02576505f, 0.01155915f, -0.02420233f, -0.04089348f, -0.04785918f, 
    -0.01229818f, 0.04027966f, -0.03769613f, -0.01191314f, -0.05098383f, -0.03719831f, 0.01535184f, 0.03651162f, 
    -0.01624242f, -0.01163661f, 0.00252168f, -0.00590254f, 0.02445502f, 0.00882365f, -0.01201969f, -0.00877147f, 
    0.00219419f, 0.04201685f, -0.00403846f, 0.01851728f, -0.01905049f, -0.04378348f, 0.00791243f, -0.02322316f, 
    0.28607014f, 0.06751338f, 0.04373665f, -0.15077808f, 0.02834956f, 0.02196081f, -0.01144025f, 0.04919427f, 
    -0.00086338f, -0.05343212f, -0.11059728f, -0.11209002f, 0.01811053f, -0.06438421f, 0.00098705f, -0.03692289f, 
    -0.10016185f, 0.08618864f, -0.04833043f, -0.14793293f, -0.04811060f, 0.05831901f, -0.12330852f, -0.07625598f, 
    0.06647529f, 0.02696196f, -0.05386630f, 0.04455608f, 0.01897102f, -0.10443959f, 0.03217126f, -0.05306966f, 
    0.04563036f, -0.02376995f, 0.10076889f, 0.26061967f, 0.15157011f, 0.15563881f, -0.01067877f, 0.16929841f, 
    -0.11940765f, -0.02598850f, -0.10454699f, 0.07395021f, -0.03380155f, 0.10759117f, -0.01499153f, 0.13196822f, 
    0.10850445f, 0.03209411f, 0.13229898f, 0.05558963f, -0.01720282f, 0.05242366f, -0.11218321f, -0.05969959f, 
    -0.06839969f, 0.01585666f, 0.02227234f, -0.01624629f, 0.03078396f, 0.02564751f, -0.07088934f, 0.00712019f, 
    -0.06154636f, 0.06281936f, -0.02302922f, 0.03310486f, 0.09884535f, 0.09542801f, 0.05575322f, 0.08887422f, 
    -0.22528788f, -0.12821852f, -0.14540367f, -0.10816266f, 0.00743031f, -0.01464293f, -0.00525679f, 0.10511008f, 
    0.10735092f, 0.03352914f, 0.11755802f, 0.02630535f, -0.07057814f, 0.03294611f, 0.18194404f, -0.26303977f, 
    -0.01061724f, -0.05519072f, 0.00058256f, 0.01840666f, -0.02927832f, -0.00394659f, 0.05485284f, -0.09469405f, 
    -0.20885713f, 0.14579570f, -0.13505436f, -0.03337731f, -0.03336750f, -0.03188198f, -0.02518891f, 0.08591953f, 
    0.02595840f, -0.04847523f, -0.11089196f, -0.12385421f, 0.06873359f, -0.10338001f, -0.09654704f, 0.02666852f, 
    0.07826886f, 0.07795262f, -0.07552555f, -0.08184318f, -0.02485915f, -0.08548213f, 0.07324157f, -0.06883885f, 
    0.05859939f, 0.04349764f, -0.13771911f, 0.02591386f, 0.06582437f, 0.06916024f, 0.08552890f, 0.18349619f, 
    -0.09751386f, -0.10024942f, -0.03317073f, -0.01147049f, -0.03800906f, 0.02147194f, -0.20085658f, -0.07419825f, 
    0.00477138f, -0.04341132f, 0.00552941f, -0.05615155f, -0.04125896f, -0.04899972f, 0.03808432f, 0.08489185f, 
    0.15352468f, -0.17220530f, -0.04102962f, 0.14830224f, 0.18798678f, 0.08632947f, 0.01285836f, 0.11427551f, 
    -0.04461758f, 0.03460278f, 0.02442141f, 0.11038601f, 0.25797561f, 0.17768140f, 0.07263842f, 0.19064149f, 
    0.01073100f, -0.07969029f, -0.03161735f, 0.03925486f, -0.02772764f, -0.03734208f, -0.03256266f, 0.09679804f, 
    0.01949001f, 0.06211755f, -0.00304699f, 0.24897350f, -0.06459007f, -0.10710825f, 0.01865956f, 0.12987342f, 
    0.07248843f, 0.04038567f, -0.12730904f, -0.07259500f, 0.10297226f, -0.21369001f, -0.14894626f, -0.35672638f, 
    0.02122057f, -0.01575083f, -0.05696522f, -0.02445080f, 0.08606188f, 0.07333397f, 0.12151244f, 0.15080535f, 
    0.33497971f, -0.24861532f, 0.03212040f, -0.04803504f, -0.01288301f, 0.01619582f, 0.08487426f, -0.03996656f, 
    0.03414221f, 0.02343648f, -0.00309653f, 0.05334205f, 0.27833340f, -0.25166389f, 0.10408561f, 0.07122341f, 
    -0.03982380f, -0.08011423f, 0.07998445f, -0.01557557f, 0.07600445f, 0.00292258f, -0.02840916f, -0.02688907f, 
    0.15615332f, -0.03292583f, -0.02893301f, 0.18512994f, -0.09912676f, -0.04019177f, -0.04527524f, -0.04243957f, 
    0.02591560f, 0.12688889f, 0.05126726f, 0.13588819f, -0.11099616f, 0.00699692f, -0.02728067f, 0.05699320f, 
    0.12413315f, -0.17589374f, 0.13881527f, -0.08269028f, 0.05421500f, 0.03550229f, -0.14337529f, 0.14239419f, 
    -0.05402872f, -0.02327220f, -0.02710863f, 0.24911350f, -0.02055623f, -0.05913590f, 0.02149975f, 0.03611213f, 
    0.09779132f, -0.06357288f, 0.04648588f, -0.14842670f, 0.02945605f, -0.22293277f, 0.10656615f, 0.04083462f, 
    -0.12912235f, 0.00049624f, 0.01758814f, -0.09444302f, -0.01537267f, 0.04505641f, -0.10306543f, 0.03843382f, 
    -0.09599397f, -0.00457897f, -0.06896508f, -0.30595884f, 0.05854508f, 0.06574134f, 0.12605007f, -0.13332932f, 
    -0.12609632f, -0.04104331f, 0.01338716f, -0.04316305f, -0.04204806f, 0.13137144f, 0.19586283f, -0.11898798f, 
    -0.06495778f, -0.00984784f, 0.13518330f, 0.09450966f, -0.10832205f, 0.11522681f, 0.13845314f, -0.08378065f, 
    -0.11744353f, 0.06679877f, 0.08459897f, -0.28631455f, 0.03664419f, -0.02148378f, -0.04784855f, 0.08812105f, 
    0.01418568f, -0.08700093f, 0.03991716f, 0.01890826f, 0.07127500f, 0.10499708f, 0.09546723f, -0.38962656f, 
    -0.06872229f, 0.09275806f, -0.03413797f, -0.04456922f, -0.01319599f, -0.03330934f, 0.08536537f, 0.12513933f, 
    0.27404711f, -0.00463065f, -0.05517374f, 0.08882368f, 0.05148101f, 0.04937413f, -0.07629219f, 0.07419153f, 
    0.02928830f, 0.06907523f, 0.01019278f, 0.06041751f, -0.01071136f, 0.00257957f, -0.14546853f, 0.00659786f, 
    0.11164204f, -0.05586692f, 0.04356176f, 0.05878034f, 0.01322183f, 0.04907953f, -0.09332545f, 0.06860712f, 
    0.11606269f, 0.03890266f, 0.02490317f, 0.07603943f, -0.00815396f, 0.18403073f, -0.03948784f, 0.10293546f, 
    -0.00608202f, 0.01855817f, 0.01088743f, -0.03808428f, 0.19524574f, -0.14748897f, 0.12866631f, -0.02287176f, 
    -0.03740426f, -0.05387536f, -0.00300457f, -0.01361388f, -0.01210996f, -0.06117178f, -0.06062087f, -0.11721586f, 
    -0.13178119f, 0.10219542f, -0.03207335f, -0.03003604f, 0.03768383f, -0.14996442f, -0.03670264f, 0.03817123f, 
    -0.03906452f, 0.04578138f, -0.01703382f, 0.08660006f, 0.44721380f, -0.33577132f, -0.04920290f, 0.05817699f, 
    -0.03453080f, 0.06761634f, -0.02307259f, -0.10501073f, -0.02018641f, -0.08675151f, 0.16017279f, -0.01818035f, 
    -0.12854376f, 0.06710296f, -0.10629427f, -0.20692500f, -0.10534863f, -0.11546746f, -0.03218318f, 0.00167048f, 
    -0.13581359f, 0.14201677f, -0.08948663f, -0.07497725f, 0.37890819f, 0.12332674f, -0.34913394f, -0.24746202f, 
    0.03121714f, 0.00361218f, 0.07435724f, -0.00961738f, 0.00566065f, 0.05411550f, -0.05790575f, 0.01661944f, 
    0.64358926f, -0.16245864f, 0.17971092f, 0.03964796f, 0.00601202f, 0.00838773f, 0.04662271f, -0.08022659f, 
    0.07659987f, 0.06113000f, -0.04011297f, 0.09381388f, -0.12273168f, 0.23811178f, 0.10085909f, 0.14368677f, 
    -0.00431036f, 0.01861442f, 0.06378242f, 0.04841172f, 0.03967251f, 0.04404155f, 0.07022640f, 0.03036747f, 
    0.15571240f, 0.09273165f, -0.12301237f, -0.17438167f, -0.05869405f, 0.03531232f, -0.02315400f, -0.06184546f, 
    -0.07570566f, -0.05677695f, -0.04293227f, -0.06119645f, 0.36563444f, 0.06558639f, 0.08592251f, 0.02078193f, 
    0.05170212f, 0.00521303f, -0.12788272f, 0.09832489f, 0.02460346f, 0.05855057f, -0.04807910f, 0.06794106f, 
    0.14629175f, 0.05525428f, 0.24013428f, 0.01521321f, -0.02482286f, -0.07002687f, 0.09496644f, 0.20154937f, 
    0.00687132f, -0.03914207f, -0.01967400f, -0.15728197f, -0.28129971f, -0.00484378f, 0.26935944f, -0.01154001f, 
    0.07013369f, -0.05638588f, 0.10730111f, -0.07725269f, -0.07865605f, -0.00447007f, -0.12889037f, -0.01796846f, 
    -0.12362339f, -0.11591136f, -0.00005666f, -0.04199535f, -0.05329592f, -0.02179806f, -0.08070272f, -0.06639241f, 
    0.04400541f, 0.15966444f, 0.04719602f, -0.10061093f, -0.03946318f, 0.03212509f, -0.21187340f, 0.19438094f, 
    0.01923525f, -0.01903453f, 0.03882365f, 0.01978751f, 0.10080589f, -0.04112433f, 0.24674258f, 0.05931737f, 
    0.12658153f, 0.12264708f, -0.06067370f, -0.01965820f, 0.16978668f, -0.13101731f, 0.05170671f, 0.02799422f, 
    0.04410364f, -0.03338392f, 0.03094702f, 0.01110987f, -0.05042014f, -0.03550738f, 0.11963932f, -0.14494599f, 
    0.03751255f, 0.17418262f, 0.02346152f, -0.06761306f, 0.03504738f, 0.12618859f, -0.14828365f, 0.00802546f, 
    -0.50998884f, 0.12268429f, -0.09427514f, 0.10774489f, 0.00218829f, -0.16165772f, 0.08634004f, 0.02833723f, 
    -0.08693842f, -0.03336199f, -0.02937634f, -0.00901424f, 0.12713377f, 0.05639612f, 0.05934826f, -0.11578348f, 
    0.27751228f, 0.01223681f, -0.03018545f, 0.00863133f, -0.02930047f, -0.00620973f, -0.03271351f, -0.01996032f, 
    -0.03732279f, 0.11089937f, -0.16963327f, 0.18266425f, 0.06949946f, -0.00597112f, -0.02954540f, 0.03825364f, 
    -0.10188412f, -0.02961604f, -0.07078020f, 0.08998977f, 0.17192167f, 0.24955113f, 0.21926011f, 0.08391921f, 
    0.19417788f, 0.07320286f, 0.07324181f, 0.14428023f, 0.10091326f, 0.09444737f, 0.07321795f, 0.18742642f, 
    0.15462607f, -0.15082663f, -0.11867564f, 0.10595992f, -0.16205329f, 0.03743605f, 0.06000701f, 0.04629135f, 
    -0.10907280f, 0.08516341f, -0.03339136f, -0.02509012f, 0.28615269f, -0.02700746f, -0.18605717f, 0.09935440f, 
    -0.03619273f, -0.03136075f, -0.05501497f, 0.04445823f, -0.00073383f, 0.08469762f, 0.12853862f, 0.03600345f, 
    -0.38474676f, 0.21635631f, -0.10801823f, 0.02986789f, -0.00296111f, -0.01449824f, -0.06194714f, -0.02807315f, 
    -0.03618408f, -0.06034053f, 0.10488980f, -0.13364108f, 0.22789082f, 0.07405728f, -0.22659366f, 0.17013732f, 
    0.01831871f, -0.04742939f, 0.00580099f, -0.02401210f, 0.09328756f, 0.01041754f, 0.03270328f, 0.06028467f, 
    0.09379971f, -0.01960568f, -0.03997764f, -0.13417980f, 0.09566709f, 0.08249845f, -0.10225914f, -0.18600863f, 
    -0.03136237f, -0.04293253f, 0.11840756f, 0.01132814f, 0.12461204f, 0.10251350f, -0.00956981f, 0.27412221f, 
    0.01851713f, 0.05148818f, 0.04806678f, -0.16823487f, -0.00586984f, 0.06262962f, -0.08057850f, 0.12829278f, 
    -0.30714014f, -0.11148773f, -0.06913415f, -0.18696178f, -0.04614635f, 0.04903224f, -0.00958148f, -0.08730089f, 
    0.06551552f, -0.08093939f, -0.06474163f, -0.05922947f, 0.14932525f, 0.00109952f, -0.00171419f, -0.19893587f, 
    0.06537396f, -0.04230249f, -0.03853935f, -0.01177854f, -0.07125572f, -0.08416946f, 0.12818308f, -0.11444145f, 
    -0.03262890f, -0.22267345f, 0.02021868f, 0.05391453f, 0.05503246f, -0.01968676f, 0.01546752f, 0.09707689f, 
    0.00357805f, -0.00960826f, 0.07198890f, 0.09412939f, 0.12259048f, 0.13568226f, 0.25044686f, -0.17016195f, 
    0.12140085f, 0.06238544f, -0.00031647f, 0.14791855f, 0.01377325f, 0.00917720f, 0.13706343f, 0.05504306f, 
    -0.53281450f, 0.13163561f, 0.23332115f, -0.26576117f, -0.04758182f, -0.05476927f, -0.00856476f, 0.04796189f, 
    -0.05473663f, -0.01951864f, -0.07076923f, -0.01450684f, -0.09068299f, 0.11127412f, 0.04081952f, -0.03462649f, 
    -0.01519379f, -0.06031165f, -0.06129140f, 0.00701908f, 0.06713489f, 0.05002085f, 0.06100582f, 0.01860360f, 
    0.54549241f, 0.06933907f, 0.05889999f, 0.03723959f, -0.00684701f, 0.14183617f, -0.10674727f, -0.01670595f, 
    0.07508376f, -0.09710214f, 0.05723706f, -0.09098921f, -0.06689847f, 0.13640061f, -0.02771463f, 0.05042576f, 
    -0.07736844f, 0.06712261f, 0.07483562f, -0.07551251f, 0.01867642f, 0.11720823f, -0.02455377f, 0.08159189f, 
    0.13937324f, -0.05359362f, 0.02239226f, 0.22606272f, 0.15009373f, 0.06092571f, -0.03186537f, 0.09098385f, 
    -0.00714568f, 0.10316768f, 0.04441091f, -0.16132858f, 0.03541581f, -0.07657977f, -0.10522876f, -0.05478105f, 
    0.01357426f, 0.05232639f, -0.07135164f, -0.03382513f, 0.02240875f, 0.01387227f, 0.04781311f, -0.06011428f, 
    -0.01464342f, 0.04470091f, -0.00829936f, 0.04137970f, 0.00962184f, -0.00542325f, 0.00633272f, 0.00151925f, 
    -0.04455524f, 0.00164102f, 0.03216150f, -0.02811603f, 0.01902411f, -0.00847534f, 0.02810372f, 0.03132927f, 
    -0.00740778f, 0.00095728f, -0.05582906f, -0.04038109f, 0.03785834f, -0.04375194f, 0.01665492f, -0.00945231f, 
    0.02265037f, -0.04088607f, 0.01997058f, -0.02240362f, 0.01798644f, -0.02373263f, 0.02559582f, 0.01230439f, 
    -0.02242330f, -0.01931755f, -0.02179037f, -0.02167156f, 0.01932986f, 0.01370588f, -0.03726825f, -0.00689796f, 
    -0.04766289f, -0.00814484f, 0.01515669f, -0.05679277f, -0.02733623f, -0.04823704f, -0.03754405f, 0.01383181f, 
    -0.01411265f, -0.01631893f, -0.01238584f, -0.03583775f, -0.01424734f, -0.01354213f, -0.03752211f, -0.00142328f, 
    -0.00616089f, 0.02155800f, 0.00918868f, -0.03923960f, -0.04184858f, 0.01896130f, 0.00918073f, -0.01543898f, 
    -0.00066434f, -0.01106862f, 0.02980830f, 0.03422653f, -0.02351951f, -0.00797514f, -0.00416628f, -0.03530840f, 
    0.03481417f, -0.00411741f, -0.03347380f, 0.01662606f, -0.04073457f, 0.04326708f, -0.03190271f, -0.04145825f, 
    0.02374919f, -0.02210855f, -0.00611785f, -0.00561665f, -0.03553507f, 0.02311282f, 0.00353961f, -0.02224806f, 
    0.01549459f, 0.01138202f, 0.01319244f, -0.03253016f, 0.01603899f, 0.00524848f, -0.03189438f, -0.04711366f, 
    0.04555657f, 0.03855613f, 0.03554174f, -0.05084773f, -0.03355769f, -0.01765636f, -0.04297594f, 0.02985406f, 
    0.00948983f, -0.00679119f, -0.02809258f, 0.01200955f, -0.05703473f, -0.03085132f, -0.01442266f, -0.04672873f, 
    0.01579309f, 0.03768981f, 0.02398786f, 0.02986768f, 0.03674971f, 0.02887807f, -0.02942982f, 0.00017809f, 
    -0.04355097f, -0.00455702f, -0.04025830f, 0.01446466f, -0.01228663f, -0.02723453f, 0.03311048f, 0.02645490f, 
    0.00414639f, -0.02311181f, -0.01237073f, -0.05518518f, -0.03969862f, 0.02900795f, 0.00087303f, -0.03197187f, 
    -0.03427382f, -0.02020157f, 0.03631397f, 0.04022500f, -0.02218148f, -0.05109821f, 0.01119273f, -0.04067934f, 
    -0.01689568f, -0.01755106f, -0.03170379f, 0.03080488f, -0.02415451f, 0.00042232f, -0.05515186f, -0.05196423f, 
    0.00161651f, -0.03523854f, 0.00084590f, -0.00697778f, -0.03579003f, 0.00647450f, 0.01117513f, -0.05469488f, 
    0.00480251f, 0.04294239f, 0.00863667f, 0.03685251f, 0.02272049f, 0.04981018f, -0.03087338f, -0.05083572f, 
    -0.04729407f, 0.02852821f, 0.01532934f, -0.03995770f, 0.02181140f, -0.00150535f, 0.01804590f, -0.01703054f, 
    -0.00162786f, -0.02704696f, 0.04345464f, -0.06083916f, -0.04054529f, 0.00470746f, 0.01216037f, 0.01277714f, 
    0.03828659f, -0.04747951f, -0.01670266f, -0.04333705f, -0.04196937f, -0.00459805f, -0.02457063f, -0.03245012f, 
    -0.01496368f, 0.00979964f, -0.04317165f, -0.01919893f, -0.00270265f, 0.01024438f, 0.03247682f, -0.03417896f, 
    -0.01185367f, -0.05096687f, 0.01542704f, -0.01537417f, 0.01384991f, 0.04301170f, -0.04572094f, -0.01299036f, 
    0.01794041f, -0.05726691f, 0.01824289f, -0.01788678f, -0.00307708f, 0.03861967f, -0.05030283f, 0.00244694f, 
    0.02137528f, 0.00877685f, 0.01337014f, -0.00933010f, -0.02516657f, 0.02380682f, 0.03386457f, 0.03038051f, 
    -0.04563691f, -0.05352000f, -0.05041574f, -0.00407989f, -0.03142444f, 0.01640702f, -0.04291942f, -0.00693288f, 
    0.01403892f, -0.04696703f, 0.03797820f, -0.00874270f, 0.04110208f, 0.01364182f, 0.00842935f, -0.05727426f, 
    -0.02857806f, -0.03476994f, -0.04814056f, -0.04793821f, 0.01574697f, -0.00810100f, 0.01838669f, 0.03146335f, 
    -0.00901011f, 0.01661822f, -0.02152242f, 0.02670000f, 0.00333999f, -0.05343762f, -0.00174527f, 0.03274839f, 
    0.03233419f, -0.05053281f, 0.03910118f, -0.00709335f, 0.01977824f, -0.04265709f, -0.02294722f, -0.05544900f, 
    -0.05370549f, -0.01866000f, -0.00991913f, 0.03268409f, 0.03703079f, 0.03921827f, -0.04388887f, 0.02847567f, 
    -0.00110134f, -0.02663465f, -0.04452172f, 0.01571306f, 0.03928905f, 0.01144207f, -0.04385769f, 0.00346063f, 
    -0.02051089f, 0.00999909f, -0.03532554f, -0.03752889f, 0.00180427f, 0.01471765f, -0.02538636f, -0.00036909f, 
    -0.03043735f, -0.00007736f, 0.00811735f, -0.01377956f, -0.05381100f, 0.00758199f, -0.00664284f, 0.02663214f, 
    -0.02804796f, -0.02655917f, -0.01852584f, -0.05407214f, 0.00378351f, -0.03879672f, -0.01357859f, 0.04711330f, 
    0.02257304f, 0.02237904f, -0.05022950f, -0.01928410f, 0.04057878f, 0.00785878f, -0.03353634f, -0.04733067f, 
    -0.01261018f, -0.02363992f, -0.04627134f, -0.05618559f, 0.01509103f, -0.02158933f, -0.01456905f, -0.00283586f, 
    0.01661319f, 0.00149585f, -0.05172696f, -0.01400095f, 0.04223200f, 0.02721719f, 0.03567004f, 0.00261234f, 
    -0.02110189f, 0.01086710f, 0.01378099f, -0.05676621f, 0.04349171f, -0.00438766f, -0.02688973f, -0.05675252f, 
    0.01852620f, 0.00466773f, 0.02547327f, 0.00454091f, 0.03861898f, 0.03782464f, 0.02405508f, -0.05504901f, 
    0.01398721f, -0.01465063f, -0.02799141f, -0.01836217f, -0.05447712f, -0.01126134f, -0.04126077f, 0.02713776f, 
    -0.01446455f, -0.02493592f, -0.05607723f, -0.05764303f, -0.04278434f, 0.03394898f, 0.02044433f, 0.03891606f, 
    -0.00086504f, 0.02378465f, 0.01145943f, -0.04330589f, 0.02231856f, -0.03112692f, -0.04825715f, 0.03542989f, 
    -0.03238986f, 0.02504354f, 0.03494480f, -0.05659517f, 0.03298279f, -0.02109495f, 0.04653660f, -0.03577415f, 
    -0.00554682f, 0.04052442f, 0.00470649f, -0.05418105f, -0.00251576f, 0.04015444f, 0.00881394f, -0.04208674f, 
    0.00412590f, -0.01862914f, -0.01803967f, 0.03557261f, -0.02069085f, -0.04230089f, -0.01429354f, 0.01376319f, 
    -0.01073997f, -0.03001658f, -0.05003560f, -0.05757128f, 0.02510789f, 0.01903305f, 0.00708964f, -0.02399550f, 
    0.00467472f, 0.02024643f, -0.00451674f, -0.00442934f, 0.01324682f, -0.02560438f, -0.04190433f, 0.01230938f, 
    0.01692609f, -0.00426056f, -0.02319574f, -0.03904178f, -0.00532015f, -0.03718801f, -0.01431569f, 0.03967336f, 
    -0.04981187f, -0.04122619f, 0.03982927f, -0.02559245f, -0.05659635f, -0.05089145f, -0.03046942f, 0.00438659f, 
    -0.03845252f, 0.02353582f, -0.04925807f, 0.03104820f, 0.03954339f, 0.04244475f, 0.02807935f, -0.01901419f, 
    -0.01398172f, -0.05227545f, 0.03846335f, -0.06039050f, -0.03906802f, 0.03104530f, 0.00012883f, 0.01863377f, 
    0.03985964f, -0.03737029f, -0.02454793f, -0.00323305f, -0.00506274f, 0.01801678f, -0.00631634f, -0.03629714f, 
    0.01021919f, 0.00048439f, 0.02478354f, -0.00358898f, 0.04154746f, 0.03411755f, -0.02021819f, 0.01078327f, 
    0.02159583f, -0.04321872f, -0.05259107f, -0.02041590f, 0.01607068f, -0.00120641f, 0.04044359f, 0.02562128f, 
    -0.04603025f, 0.04269426f, 0.03085414f, 0.03473768f, -0.02450989f, -0.02905770f, -0.02889504f, 0.02597870f, 
    0.02902457f, -0.03670248f, -0.04398023f, -0.01610921f, 0.02079687f, -0.00834334f, -0.02170122f, -0.01681758f, 
    -0.03480132f, 0.02339336f, -0.03663590f, -0.04903307f, 0.01568439f, -0.03806481f, -0.05482714f, -0.03715972f, 
    -0.00938038f, -0.00159084f, -0.03215131f, -0.02493626f, -0.01129774f, -0.00918975f, 0.02974369f, 0.03952051f, 
    0.00460734f, 0.03648982f, 0.00861203f, 0.04168294f, -0.02474142f, 0.04106374f, -0.04041522f, 0.03210872f, 
    0.03635141f, 0.03096384f, -0.02282839f, 0.03135736f, -0.03475182f, -0.01556527f, 0.03283162f, -0.03552544f, 
    -0.00731625f, -0.01259953f, 0.00228496f, 0.00524812f, 0.00860996f, -0.04445125f, 0.00538049f, -0.01485288f, 
    0.01875519f, -0.01506727f, -0.01734322f, -0.00018873f, -0.04731073f, -0.03937347f, 0.03926603f, 0.00946267f, 
    -0.02000363f, -0.01190175f, -0.02170367f, -0.04280333f, -0.03837286f, -0.03317806f, -0.05796513f, -0.03041154f, 
    -0.01862103f, 0.00612297f, 0.03226706f, -0.04488709f, -0.01375359f, -0.04305936f, -0.03872273f, -0.05102294f, 
    -0.05958862f, -0.02404951f, -0.02373096f, 0.00589049f, -0.05510628f, -0.00156895f, -0.03499185f, -0.05284476f, 
    0.02403500f, 0.02848223f, -0.01740698f, 0.03422833f, -0.01058557f, -0.00675473f, -0.01041032f, -0.04417707f, 
    0.01662404f, -0.04932305f, -0.00397646f, -0.03425100f, -0.03032814f, -0.01627472f, 0.04052188f, -0.05118171f, 
    0.01401919f, -0.03987056f, -0.03624873f, 0.01257283f, 0.00438960f, 0.01000798f, 0.04279775f, -0.01673991f, 
    0.01138062f, -0.04460436f, -0.00622696f, 0.02866656f, -0.04931580f, -0.00720169f, 0.00804487f, -0.03631739f, 
    -0.00763650f, 0.00360933f, 0.00039966f, -0.04263636f, 0.04251657f, -0.03677206f, 0.02088203f, -0.00169875f, 
    -0.02307495f, -0.04634082f, 0.02417572f, -0.02198203f, -0.03667177f, -0.02048923f, 0.02804139f, 0.02237665f, 
    -0.01016640f, 0.00809591f, -0.04370344f, -0.03955266f, 0.02247946f, 0.03469294f, 0.01741917f, -0.05108770f, 
    -0.02254654f, -0.03236422f, -0.02172284f, -0.05358148f, -0.05177387f, -0.02089383f, -0.00988570f, -0.03568954f, 
    0.00822938f, 0.00983150f, -0.04349611f, -0.02413440f, 0.00002398f, 0.02525901f, 0.00430428f, 0.01734933f, 
    -0.01352270f, -0.00092122f, 0.00697040f, 0.02020269f, -0.05148314f, -0.00411771f, -0.05556736f, -0.05442468f, 
    0.03029418f, 0.03845637f, -0.02807086f, -0.02755361f, -0.05674735f, -0.02906226f, 0.02239719f, 0.01083144f, 
    -0.03606954f, -0.01183164f, 0.02870759f, 0.01698687f, -0.00319850f, -0.04619480f, -0.00682579f, -0.02756717f, 
    -0.01024660f, 0.01045682f, 0.02720438f, -0.04008646f, -0.04059294f, 0.00831405f, -0.02630730f, 0.00020515f, 
    -0.02337205f, 0.02923974f, -0.00868880f, 0.01092344f, -0.01023802f, -0.01303260f, 0.01561546f, -0.01074368f, 
    -0.01420427f, 0.00907633f, -0.00518698f, 0.02482320f, 0.03334412f, 0.03133425f, -0.04018149f, 0.03150452f, 
    -0.00140073f, -0.02674318f, -0.01022337f, -0.00089523f, -0.03665541f, 0.00196037f, 0.03852168f, -0.01312499f, 
    -0.05044012f, -0.01791636f, 0.02303692f, -0.01972198f, 0.01915054f, -0.00155988f, 0.01524128f, 0.02394382f, 
    0.02268489f, 0.02857194f, -0.04575638f, 0.02982181f, -0.05446507f, -0.00667697f, 0.02804215f, -0.04846604f, 
    -0.00654606f, 0.00924889f, 0.00067782f, -0.00163115f, -0.02428062f, 0.03033279f, -0.00447184f, -0.04143987f, 
    -0.00391500f, 0.02429125f, -0.04528333f, 0.04363975f, -0.03607451f, -0.03799077f, -0.00098830f, 0.01846111f, 
    -0.04525740f, -0.01213913f, 0.00818234f, 0.03374407f, 0.01133611f, 0.01324948f, -0.05373380f, -0.00180699f, 
    0.00901963f, 0.02347762f, 0.00760953f, 0.02864210f, 0.01659770f, 0.03542586f, -0.01179866f, -0.02369197f, 
    -0.01053570f, 0.01373180f, -0.00088443f, -0.01715184f, -0.01035508f, 0.03902537f, 0.01098720f, 0.02312208f, 
    0.00288055f, 0.01098878f, -0.04929991f, 0.00706113f, -0.03866063f, 0.00299589f, -0.01022174f, 0.00214024f, 
    0.02508796f, -0.04086661f, -0.01310534f, 0.00818448f, 0.00872327f, -0.00171109f, 0.00365654f, -0.04462824f, 
    -0.05699020f, 0.01648453f, -0.04408530f, 0.02768510f, 0.03545852f, 0.02373221f, -0.02599636f, 0.02353050f, 
    0.04155343f, 0.00942083f, -0.01227638f, -0.03339434f, -0.02274946f, -0.02339100f, -0.04932773f, -0.03557771f, 
    -0.02341245f, 0.14600739f, 0.10547596f, -0.16567335f, 0.06630741f, 0.06534334f, -0.05636301f, -0.00738501f, 
    -0.02660952f, 0.12284882f, -0.11760806f, -0.13083643f, 0.08864558f, 0.01813534f, -0.04550206f, -0.11779816f, 
    0.01515191f, 0.04229810f, -0.09030160f, -0.04670984f, -0.11328380f, 0.04516851f, -0.11147149f, -0.01385103f, 
    0.24721412f, -0.15995520f, 0.02588353f, 0.07138030f, 0.08633159f, -0.09282419f, 0.14994091f, 0.04170882f, 
    0.02898210f, 0.04687623f, 0.02836267f, 0.09494942f, 0.09912214f, 0.09706232f, -0.04481250f, 0.07204124f, 
    -0.01622155f, 0.09248865f, 0.05378211f, 0.11661390f, 0.01500050f, 0.15808196f, 0.06848998f, 0.07178746f, 
    0.01501137f, 0.12828159f, -0.05676804f, 0.00080888f, 0.14847867f, 0.03628686f, -0.09259897f, -0.01567009f, 
    0.06357814f, 0.08173572f, -0.00443682f, 0.03148176f, 0.40116245f, -0.03757224f, 0.08856964f, 0.17300957f, 
    -0.07489553f, -0.01909492f, 0.05465319f, 0.08858159f, 0.07578501f, -0.02279100f, -0.00033724f, 0.03139360f, 
    -0.00199779f, -0.07667085f, 0.13532016f, 0.04138414f, -0.08176013f, -0.05972480f, 0.20866583f, 0.19595169f, 
    0.05611914f, -0.00151941f, 0.00949233f, -0.08241598f, -0.07241337f, 0.08175017f, 0.02362701f, -0.25248745f, 
    0.05324001f, -0.06380893f, 0.02787530f, 0.01639260f, -0.04605643f, -0.03685159f, -0.04895446f, -0.03675449f, 
    0.22180179f, 0.07319557f, -0.01430812f, 0.02244089f, 0.00689919f, -0.00688224f, 0.02569352f, 0.00344376f, 
    0.01388587f, 0.00956095f, -0.09598406f, -0.24287927f, 0.15020438f, -0.04234158f, -0.18354255f, 0.14416993f, 
    0.01956518f, 0.09517614f, -0.03787261f, 0.00422595f, 0.08546486f, -0.04840251f, 0.23986533f, -0.08144038f, 
    -0.16187347f, 0.18855670f, 0.02222113f, 0.03694810f, -0.01068864f, -0.01794880f, 0.20565936f, 0.06396506f, 
    -0.12949936f, -0.03023043f, -0.07310709f, 0.05831980f, -0.04236291f, 0.16707158f, -0.10906124f, -0.22417064f, 
    -0.07366899f, 0.09974930f, 0.06241099f, -0.14216603f, -0.08255571f, -0.02432560f, 0.04010123f, 0.05878844f, 
    0.23892196f, -0.08174278f, -0.13417637f, 0.23205353f, 0.15488735f, 0.04976562f, 0.04712400f, 0.09267437f, 
    -0.06726427f, -0.02194523f, -0.08310361f, 0.12592870f, -0.04248825f, 0.10328449f, 0.14821146f, 0.10369349f, 
    0.12089179f, 0.04039217f, -0.01193237f, 0.10714983f, 0.02221544f, 0.03832020f, -0.07742802f, 0.10226671f, 
    -0.28889024f, -0.00502812f, -0.05409763f, -0.00982825f, 0.09074348f, -0.05175032f, -0.06114437f, 0.06783259f, 
    0.02147266f, -0.02563501f, -0.12148616f, 0.09741881f, 0.16381137f, -0.20741907f, -0.02211214f, -0.06346276f, 
    -0.08369680f, 0.07994902f, 0.10763679f, 0.10073245f, 0.00515595f, 0.09949361f, 0.05177090f, 0.14241736f, 
    0.32666948f, -0.10831238f, -0.14358154f, -0.04779001f, -0.01355313f, 0.00904557f, 0.04175658f, 0.02737892f, 
    -0.03603817f, 0.14574203f, -0.01207912f, -0.01910135f, 0.42679074f, -0.23849808f, -0.06038366f, 0.11327995f, 
    -0.05085869f, -0.12705156f, -0.10285795f, 0.05878280f, 0.01293911f, 0.14167050f, 0.13286121f, 0.00905781f, 
    0.10588938f, -0.00399572f, -0.22578892f, 0.00236794f, 0.01974554f, -0.07872177f, 0.04396987f, -0.05117543f, 
    0.01706168f, 0.03463183f, 0.05960628f, 0.07934632f, -0.15551217f, 0.13215159f, -0.16191091f, -0.03342137f, 
    -0.00447473f, -0.10307382f, 0.05904741f, -0.05013923f, 0.09224736f, 0.08015925f, -0.00457340f, 0.13806854f, 
    -0.02606835f, -0.00703933f, -0.19492789f, 0.04990470f, 0.08744681f, -0.02034320f, -0.07131586f, -0.00349650f, 
    -0.00598986f, -0.03146740f, 0.11479190f, -0.05199752f, 0.08277963f, -0.17220849f, -0.13097033f, 0.03814610f, 
    -0.13577403f, 0.04247446f, -0.02569404f, -0.00732013f, 0.01810288f, -0.05930583f, -0.06141790f, 0.06428707f, 
    -0.06426504f, 0.06690580f, -0.04945023f, -0.36838353f, 0.02139682f, 0.02649643f, 0.09037286f, -0.09423184f, 
    -0.07176408f, -0.01682496f, -0.01809483f, -0.09887828f, -0.23144969f, 0.09755421f, 0.24992141f, -0.17056233f, 
    -0.01847039f, 0.11041605f, 0.05852407f, 0.08885232f, -0.02462257f, -0.00118250f, 0.25672221f, -0.06175348f, 
    -0.09989772f, 0.07085301f, -0.03415406f, -0.05315797f, 0.06899055f, 0.04030902f, 0.05068202f, 0.15216565f, 
    0.00067340f, 0.02924345f, 0.00087970f, 0.13951899f, -0.08097098f, -0.02012957f, 0.02169193f, -0.12732349f, 
    0.05655687f, 0.00259212f, -0.05349160f, -0.05244609f, -0.01999334f, 0.03514098f, 0.11209555f, 0.07626677f, 
    -0.03399415f, -0.08086949f, 0.04246755f, -0.09553510f, -0.00714258f, 0.01993377f, 0.05434231f, -0.00233676f, 
    0.04114781f, 0.08365890f, 0.04384913f, 0.06389998f, -0.15939222f, 0.15865402f, -0.00861229f, -0.17656654f, 
    0.06266041f, -0.02365306f, 0.01593118f, 0.00393807f, 0.01259011f, 0.10488541f, -0.03565028f, 0.07296968f, 
    0.32710698f, -0.00385829f, 0.03909934f, 0.14755929f, 0.00700366f, 0.07901601f, -0.10126135f, 0.17580190f, 
    -0.04474569f, 0.01117477f, -0.01810498f, 0.01231863f, 0.01378244f, -0.04334603f, 0.14548779f, -0.03570226f, 
    -0.07587229f, 0.06300006f, 0.01192838f, -0.08581232f, -0.02802013f, 0.06299526f, -0.02927697f, 0.00628795f, 
    0.11918818f, 0.17435960f, 0.04075833f, 0.04594233f, -0.10505958f, -0.04014003f, -0.00707808f, 0.08490921f, 
    -0.10921750f, 0.17174371f, 0.01570304f, 0.05770092f, 0.51099473f, -0.18488893f, -0.02663401f, 0.15003739f, 
    0.02570367f, 0.05194386f, -0.12678373f, -0.02294053f, 0.12858777f, -0.06202281f, 0.12986068f, -0.05769277f, 
    -0.09997746f, 0.32109582f, 0.02422304f, -0.22937025f, 0.06841128f, -0.03222406f, -0.01704548f, -0.01519841f, 
    -0.04980990f, 0.17689632f, 0.01829980f, 0.13674182f, 0.24618307f, -0.00411967f, 0.00305342f, -0.11944114f, 
    0.15826990f, -0.11753657f, 0.05294152f, 0.20424083f, 0.02975485f, 0.03689522f, 0.05142820f, -0.00427356f, 
    0.15130697f, -0.14418669f, -0.00780902f, 0.06133434f, -0.02768274f, -0.00231412f, 0.15011632f, 0.00170076f, 
    0.02726698f, 0.10155376f, -0.04193749f, 0.07764202f, -0.36271217f, 0.27708167f, 0.13521937f, -0.15473877f, 
    0.04592198f, 0.09636419f, 0.03392327f, 0.00900141f, 0.03018080f, -0.03748276f, 0.05937096f, 0.01361262f, 
    0.00704071f, 0.11517051f, -0.04215060f, -0.08098526f, 0.01249775f, -0.06460157f, 0.01154714f, -0.00089282f, 
    0.02060381f, -0.02289786f, 0.01837038f, 0.12093870f, -0.06725313f, -0.26277369f, 0.16749628f, 0.06666550f, 
    0.02968230f, 0.09844459f, 0.09126750f, 0.05252142f, 0.10271519f, 0.04942240f, 0.09986534f, 0.06776228f, 
    0.10762656f, 0.05286422f, 0.17922431f, 0.24184981f, 0.04143716f, 0.03986423f, 0.06587493f, 0.07114030f, 
    -0.03793440f, -0.09500889f, 0.07011290f, -0.06594183f, 0.12314260f, 0.11596801f, -0.06659999f, 0.09192319f, 
    0.17677537f, 0.09237494f, 0.01986985f, 0.01660204f, 0.09904703f, -0.01915847f, -0.05409930f, 0.07029925f, 
    0.13495260f, 0.04153585f, 0.01519724f, -0.05468986f, 0.01375798f, 0.05371067f, 0.00309692f, 0.08656862f, 
    0.07572855f, 0.04203969f, 0.08758766f, -0.00171855f, 0.17897946f, 0.14744981f, 0.06709673f, -0.04967245f, 
    0.05605123f, 0.06589316f, 0.13857825f, 0.05427831f, 0.11013994f, 0.01928348f, 0.07843421f, 0.02800931f, 
    -0.06998713f, 0.12615624f, -0.05988161f, 0.25919530f, 0.00390099f, -0.01556703f, 0.08932982f, -0.10979808f, 
    0.12033250f, 0.05113063f, 0.04611250f, -0.07780087f, 0.09296754f, -0.01225385f, 0.07587088f, 0.18380664f, 
    0.12306391f, 0.14460704f, 0.10621538f, -0.00338676f, 0.05461107f, 0.01614662f, 0.02780983f, -0.05496002f, 
    -0.17296144f, 0.21581067f, 0.14315739f, -0.12320621f, -0.04682457f, -0.08450678f, 0.07737375f, -0.03932216f, 
    0.19743301f, 0.04057797f, 0.11581243f, 0.06873826f, -0.22032657f, -0.03295887f, 0.16169046f, 0.05207628f, 
    -0.00305081f, 0.10122451f, 0.07519714f, 0.04988735f, 0.06558689f, 0.13577852f, 0.07795121f, -0.10075277f, 
    0.12161499f, 0.11081687f, 0.00103724f, -0.18872683f, 0.17224211f, 0.02323259f, -0.01315962f, -0.04931458f, 
    0.02036891f, 0.02058018f, 0.01110184f, 0.12127431f, -0.04744371f, 0.20951730f, 0.18213762f, 0.29269847f, 
    0.03841297f, 0.11864146f, 0.07881027f, -0.00252541f, -0.04191151f, 0.01909084f, 0.07196940f, 0.04394315f, 
    -0.20218033f, 0.46895650f, 0.02396279f, -0.10408247f, 0.15090266f, 0.06988840f, 0.05864542f, -0.00694717f, 
    0.02156157f, 0.04756455f, 0.05367002f, -0.00354076f, -0.02383674f, 0.15078744f, 0.05866224f, -0.11141665f, 
    0.14497501f, 0.13271147f, 0.01317747f, 0.08566421f, -0.00246366f, 0.00285738f, 0.12304644f, 0.03306005f, 
    -0.15717874f, 0.16748528f, -0.02848399f, -0.15942264f, -0.04536014f, 0.01503786f, 0.05917271f, 0.06199274f, 
    -0.01302070f, -0.08576941f, 0.15938467f, 0.03897915f, 0.34030110f, -0.01856489f, 0.05432512f, 0.04409282f, 
    0.03521568f, 0.17537953f, 0.03294956f, 0.10454645f, 0.05618354f, 0.00664632f, 0.31596562f, 0.01670985f, 
    0.24427839f, -0.06288131f, -0.07868674f, -0.05109669f, 0.05217466f, 0.12538268f, -0.06212475f, 0.01876407f, 
    -0.09487117f, 0.10146312f, 0.16233362f, 0.17283463f, 0.04266485f, 0.01389685f, -0.03753179f, 0.04328287f, 
    0.12651615f, 0.08437754f, 0.08606386f, 0.02795176f, -0.02866325f, -0.12686333f, -0.01492411f, 0.12268108f, 
    0.05675481f, 0.09845742f, 0.04802032f, 0.24210075f, 0.01628249f, 0.00547468f, -0.00738585f, 0.07553130f, 
    0.11430264f, 0.05006924f, 0.21098967f, 0.19871457f, 0.02909101f, 0.08768380f, -0.02306915f, -0.03924411f, 
    0.07662404f, 0.05557978f, -0.02833435f, -0.01073255f, 0.03572451f, 0.06815063f, -0.01052861f, 0.19248874f, 
    0.14279944f, 0.00910868f, 0.05541669f, 0.25218767f, 0.22943670f, 0.12844230f, 0.02283413f, -0.00696278f, 
    -0.00148035f, 0.03536705f, 0.07933349f, 0.02527562f, -0.06048783f, 0.14221340f, -0.16898625f, 0.42986941f, 
    0.18590449f, 0.05209513f, 0.05803036f, 0.01334228f, -0.00901807f, 0.13476470f, -0.00780478f, -0.05325620f, 
    -0.29894438f, 0.18067110f, 0.14923170f, 0.12365220f, 0.06019149f, -0.00962431f, 0.13297223f, -0.08814053f, 
    0.04721804f, 0.02839278f, 0.00585894f, -0.01842378f, 0.07544180f, 0.22085841f, 0.33032000f, -0.08886094f, 
    0.03129945f, 0.01828574f, 0.02022657f, -0.06741640f, -0.02100344f, 0.09551342f, 0.08200016f, 0.03165894f, 
    0.01755958f, -0.18741181f, -0.03364246f, 0.05915947f, 0.11961988f, 0.07226099f, 0.15064293f, -0.03164658f, 
    0.10243046f, 0.06864617f, 0.12340938f, 0.09828407f, -0.02311025f, 0.11689917f, 0.13947637f, -0.00519861f, 
    0.09903251f, 0.16075648f, 0.01208411f, 0.04292185f, -0.00403866f, 0.13299313f, -0.01833688f, 0.06818268f, 
    0.17812245f, -0.06496725f, 0.05894372f, 0.02590987f, 0.09860057f, 0.13936713f, 0.17138362f, -0.02790808f, 
    -0.10589276f, 0.14477231f, 0.14464357f, 0.13032974f, -0.15498145f, 0.09554167f, 0.16706513f, -0.14961100f, 
    0.13062121f, 0.05005673f, 0.02308111f, 0.18930762f, 0.09296868f, 0.07390155f, -0.10892709f, 0.12016618f, 
    -0.02055350f, 0.04004367f, -0.05930907f, -0.01405921f, 0.04212435f, -0.03394830f, -0.02374075f, -0.05354514f, 
    -0.01656657f, 0.00131946f, 0.00299771f, 0.02564470f, -0.05077317f, 0.04103698f, -0.01240327f, -0.02932741f, 
    0.03788411f, 0.04527548f, -0.02032706f, 0.01753836f, -0.00336673f, 0.01877135f, -0.03910154f, 0.02930530f, 
    0.02560719f, -0.04075883f, 0.03140878f, 0.00615551f, 0.05025699f, -0.03411702f, -0.04026993f, -0.02387785f, 
    0.02096369f, 0.04082210f, 0.00202739f, 0.03041010f, -0.00846113f, 0.03943484f, -0.03806546f, -0.01876044f, 
    -0.04879658f, -0.04094063f, 0.04261726f, -0.04990819f, 0.04289649f, -0.00754243f, 0.01711727f, -0.02788043f, 
    -0.01752706f, -0.01023329f, -0.02550150f, -0.00193176f, -0.00524428f, -0.03791434f, 0.00345889f, -0.01892294f, 
    -0.00030622f, -0.01904250f, 0.04005399f, -0.04481908f, 0.04587406f, -0.02861744f, 0.01111806f, 0.02429383f, 
    0.00805796f, -0.03699886f, 0.03397925f, -0.04411981f, 0.02681947f, -0.02485350f, 0.01159346f, -0.03681886f, 
    0.02348193f, 0.02824396f, -0.04780525f, 0.00780668f, -0.01234370f, 0.02058063f, -0.05420441f, 0.01102288f, 
    0.03072357f, -0.04844299f, -0.00896433f, -0.03705388f, 0.02027034f, -0.01341355f, 0.00377166f, -0.01123234f, 
    0.03552124f, 0.01085227f, 0.02462098f, -0.03932283f, -0.01186446f, 0.02442429f, 0.02275630f, -0.03816454f, 
    0.02318579f, -0.02447605f, -0.02175136f, 0.01591946f, -0.01614866f, -0.01678847f, 0.01587492f, 0.04319790f, 
    0.00732256f, -0.02161045f, -0.03076720f, 0.01926562f, 0.03740391f, -0.05557898f, -0.02745755f, -0.02477370f, 
    -0.02507659f, -0.01101383f, -0.04368029f, -0.01264235f, -0.02434224f, 0.00481931f, -0.03780827f, 0.02180194f, 
    0.02170031f, -0.02638531f, 0.02338045f, 0.01142395f, 0.01848101f, 0.01904524f, 0.02769388f, 0.04643443f, 
    0.02486401f, -0.00560754f, 0.03185840f, -0.03004985f, -0.02054265f, 0.03819334f, 0.04487361f, -0.03939224f, 
    0.02501990f, 0.02555199f, 0.01554372f, -0.00971305f, -0.02675342f, 0.01815077f, -0.03204734f, -0.00789165f, 
    0.02414321f, -0.01009695f, -0.04360394f, -0.01423801f, -0.01489878f, 0.04392768f, 0.00242115f, 0.03970419f, 
    -0.03896160f, -0.03263640f, -0.03215493f, 0.02630545f, 0.00918933f, 0.04980052f, 0.04073217f, 0.01885914f, 
    0.03881848f, 0.03520238f, -0.02947953f, -0.00314254f, 0.00749237f, -0.02466223f, 0.02739388f, -0.00547494f, 
    0.04123912f, 0.01255033f, 0.00312601f, -0.00843688f, -0.03474139f, 0.02270511f, -0.02254441f, 0.03488856f, 
    -0.04835928f, -0.01485861f, 0.02703397f, -0.03126448f, -0.02253320f, -0.04081052f, 0.00657487f, -0.01268369f, 
    -0.03324971f, 0.04119450f, -0.01400573f, 0.02350562f, -0.05508404f, 0.04432818f, 0.00926893f, -0.04330683f, 
    -0.01532504f, -0.00197407f, -0.01677593f, -0.03693713f, 0.04032282f, -0.01174546f, 0.00537924f, 0.01477202f, 
    0.02879735f, 0.02029719f, 0.02166968f, -0.04138632f, -0.03070001f, 0.03676193f, -0.04684349f, -0.01986920f, 
    -0.03879609f, -0.01551486f, -0.05250150f, -0.02691528f, 0.01933025f, -0.03863651f, -0.03840696f, 0.03989846f, 
    -0.00129819f, -0.00342880f, 0.03497205f, -0.01651742f, 0.03316433f, 0.04559422f, 0.01100574f, -0.01963283f, 
    0.01513974f, 0.02676467f, 0.02112307f, -0.02980973f, -0.02371373f, -0.02927083f, 0.00404106f, -0.05123895f, 
    0.02626850f, -0.04456625f, 0.01892583f, 0.05110219f, -0.00393421f, -0.02087107f, 0.00568849f, 0.00650217f, 
    0.00540984f, -0.05216524f, 0.01986413f, -0.02563610f, -0.03476843f, -0.01090364f, -0.04707654f, -0.00997995f, 
    -0.05249701f, -0.05278252f, -0.03565830f, 0.03523152f, 0.02498384f, -0.01091101f, 0.03068584f, -0.01030432f, 
    -0.03111084f, -0.04217734f, 0.02197826f, -0.04977025f, 0.01828204f, 0.00534622f, -0.03989961f, 0.01085820f, 
    0.01598067f, 0.03048345f, -0.00958889f, -0.00585533f, 0.01719821f, 0.03068523f, -0.04413389f, -0.01627954f, 
    -0.00046899f, -0.02360790f, -0.03189919f, -0.02172038f, 0.00410502f, 0.03364003f, 0.01222285f, -0.04352745f, 
    -0.03354077f, 0.03345494f, 0.00237322f, -0.00809622f, -0.05078059f, -0.01804925f, 0.00256614f, -0.01619699f, 
    0.01709588f, 0.00561443f, -0.01400618f, -0.00611764f, -0.04324999f, -0.02650435f, 0.01493467f, 0.02134897f, 
    -0.02552529f, -0.04281290f, -0.05208883f, -0.01901141f, -0.01391728f, 0.03299262f, -0.05419799f, -0.05631310f, 
    0.00729734f, 0.02836270f, 0.01874225f, 0.00020098f, -0.03179843f, 0.02428191f, 0.02793804f, -0.03970794f, 
    0.00697769f, 0.00196676f, -0.03615937f, -0.02076968f, -0.05538028f, -0.02896948f, 0.02430525f, -0.04372776f, 
    -0.03586726f, 0.04533987f, -0.04347822f, 0.00792116f, 0.02973744f, 0.00344503f, -0.02129278f, 0.03786222f, 
    -0.02334641f, -0.02300962f, -0.04132325f, -0.02943001f, 0.05981785f, -0.04270180f, -0.03672569f, 0.01709266f, 
    -0.05549616f, 0.03918823f, -0.00003782f, -0.00531512f, 0.03969555f, -0.04083928f, -0.01915720f, 0.00520768f, 
    -0.00693379f, 0.03147946f, -0.00572125f, -0.02434668f, 0.02815740f, -0.03554468f, 0.02648346f, -0.01377731f, 
    0.01383686f, -0.00187535f, -0.02883056f, 0.00417478f, -0.02898760f, 0.00643941f, -0.04317487f, 0.03505497f, 
    0.00328830f, 0.03447393f, 0.03545578f, 0.04556509f, 0.00583419f, -0.04578709f, 0.01570369f, -0.02778287f, 
    0.03633573f, 0.00252164f, 0.02890316f, -0.05442102f, 0.00986481f, -0.02944057f, -0.02594233f, -0.02846872f, 
    0.04112513f, 0.03105172f, 0.05101503f, 0.01134852f, -0.04559851f, 0.04177022f, -0.06357770f, 0.04009280f, 
    0.03487057f, -0.01098847f, -0.03071448f, 0.02895862f, -0.04952237f, 0.02382121f, -0.05895531f, -0.02614679f, 
    0.01373705f, -0.03729052f, 0.03142960f, -0.05554836f, 0.00510892f, 0.01131987f, -0.05133749f, -0.03135846f, 
    -0.00108075f, -0.01924745f, -0.01740404f, 0.01776503f, -0.01672574f, 0.03774388f, 0.01081583f, -0.03419508f, 
    -0.01680565f, -0.01417493f, -0.02747974f, -0.04777110f, -0.02874822f, -0.03743684f, -0.01400057f, -0.00341298f, 
    -0.01562458f, -0.03934525f, 0.02311012f, -0.00291942f, -0.00619033f, -0.00397203f, -0.04581988f, -0.04884889f, 
    0.01012899f, -0.01315917f, -0.00997051f, 0.00261517f, 0.02950146f, 0.01572653f, -0.01563812f, -0.04586918f, 
    0.02684166f, -0.02461859f, -0.05043944f, 0.01446756f, -0.05119820f, -0.03964188f, -0.00805867f, 0.01356620f, 
    0.00806637f, -0.00735156f, 0.04415902f, 0.02561182f, 0.00600330f, -0.02556001f, 0.02081811f, 0.03089147f, 
    -0.03175906f, -0.01562568f, -0.03417450f, -0.03711548f, -0.03138015f, -0.01406538f, -0.05510454f, 0.01931712f, 
    0.03259223f, -0.04336190f, -0.04667478f, 0.01393882f, 0.04512176f, -0.02011642f, 0.03610835f, 0.01148722f, 
    -0.04417992f, -0.01943589f, -0.04760826f, -0.01572352f, 0.02081595f, 0.01294970f, -0.00592385f, 0.03446061f, 
    -0.05526880f, 0.01569551f, -0.00003595f, -0.02244848f, -0.00611067f, 0.02253166f, 0.01299955f, -0.05081250f, 
    -0.00922490f, -0.05327348f, 0.02080185f, 0.01573393f, 0.01818029f, -0.00362347f, -0.04716079f, 0.03716971f, 
    -0.03669069f, -0.01300629f, -0.00237061f, 0.03193258f, 0.02924558f, -0.01379569f, 0.02814455f, 0.03434547f, 
    0.03236740f, 0.03189421f, 0.04436584f, 0.03228239f, -0.03616365f, -0.00227175f, 0.04190058f, -0.05234361f, 
    -0.03698153f, -0.03070938f, -0.04555916f, -0.02781710f, -0.02839755f, 0.00905354f, -0.04988901f, -0.04316720f, 
    0.03959600f, 0.01853398f, -0.03350466f, -0.00262742f, 0.03890834f, -0.00580714f, 0.03758961f, -0.05055444f, 
    -0.02718181f, -0.01490704f, -0.01921561f, -0.01267654f, 0.00155948f, -0.01562399f, -0.02189942f, -0.02415272f, 
    0.00307359f, 0.03902658f, -0.02026730f, -0.01818713f, -0.04510060f, -0.01885986f, 0.03391645f, -0.00188484f, 
    -0.02044042f, -0.00461290f, -0.05833370f, -0.04642785f, 0.04036110f, 0.01243533f, -0.04226308f, 0.02924878f, 
    0.00992455f, -0.02013837f, -0.04736507f, 0.00434674f, -0.03216592f, 0.02749488f, -0.01239098f, 0.02956619f, 
    0.01118503f, 0.03418973f, -0.01879089f, -0.04366577f, 0.03464007f, -0.05205811f, 0.04151986f, 0.02669206f, 
    0.01558233f, -0.05530933f, -0.02072489f, -0.02162908f, 0.02744010f, 0.01196661f, 0.00478325f, -0.05593586f, 
    -0.03096591f, -0.04618824f, -0.03525183f, -0.00846791f, 0.02865879f, 0.01867288f, -0.04731470f, -0.03287127f, 
    -0.00253747f, -0.03120715f, -0.02422269f, 0.05085160f, 0.01175716f, -0.02815883f, -0.03563273f, -0.03172897f, 
    0.00650108f, -0.00848449f, 0.00266200f, -0.01374148f, 0.04620020f, 0.01137800f, -0.02050937f, 0.01079502f, 
    -0.01958319f, 0.00155479f, 0.00019299f, -0.00221256f, -0.00854134f, 0.04165090f, 0.04389226f, -0.05353396f, 
    -0.01792336f, -0.02981508f, 0.03053393f, 0.01914895f, -0.00682507f, 0.01639945f, -0.02999032f, 0.03637815f, 
    -0.03945068f, -0.04559756f, -0.01962612f, -0.04381720f, 0.04400437f, -0.03208309f, 0.03149665f, -0.03204897f, 
    0.01943503f, 0.01064513f, -0.01487283f, -0.01428484f, -0.02419706f, 0.00932275f, -0.02546239f, -0.01135568f, 
    0.02011509f, -0.03724944f, -0.05303205f, -0.01874998f, -0.04667761f, 0.01692904f, 0.03725266f, 0.02234577f, 
    -0.02029463f, -0.05073630f, -0.03497677f, -0.00627058f, 0.04245853f, -0.04693401f, 0.02042911f, 0.01589538f, 
    -0.02682466f, -0.00166736f, -0.03082065f, -0.00630957f, -0.02619879f, 0.00477964f, 0.02062217f, 0.04219018f, 
    0.05172776f, -0.04530526f, 0.01874852f, -0.02001458f, -0.00915971f, 0.00441901f, -0.05499087f, 0.04448492f, 
    0.01917662f, -0.03485683f, -0.04827459f, 0.01725890f, -0.01773358f, 0.00782002f, 0.01734940f, -0.03324859f, 
    0.03281941f, -0.01978721f, -0.00542981f, 0.03006362f, -0.03425790f, -0.03564338f, -0.00419481f, -0.02611343f, 
    0.02358973f, -0.01966319f, -0.01489185f, -0.00519699f, -0.00364567f, -0.01288763f, 0.01874721f, -0.03771174f, 
    -0.02943384f, -0.01177098f, 0.02241729f, 0.01999149f, -0.00759280f, -0.03431827f, 0.03652230f, 0.00500432f, 
    -0.05533000f, 0.00011128f, -0.03074553f, 0.03485575f, -0.04638712f, 0.03929941f, 0.03750620f, 0.03759686f, 
    -0.01413900f, 0.00484016f, 0.01229032f, 0.02397509f, 0.02621160f, -0.00899301f, -0.00982706f, 0.03655678f, 
    -0.01638779f, 0.02720698f, 0.01428214f, -0.01818855f, -0.04177113f, 0.03229660f, -0.03631440f, -0.01748317f, 
    -0.01176968f, 0.02068496f, 0.01892683f, -0.01832828f, 0.01192620f, -0.04319940f, -0.02375966f, -0.03835820f, 
    0.02657364f, -0.00572728f, 0.01086159f, -0.01211975f, 0.02085850f, 0.03286171f, 0.00568218f, -0.01688625f, 
    -0.02317644f, -0.05695686f, -0.04975309f, -0.01429614f, -0.04044654f, -0.02870599f, 0.00206243f, -0.01230346f, 
    0.02769059f, -0.02939792f, -0.02473081f, -0.02949341f, -0.01695218f, 0.00456926f, -0.00408919f, -0.02479978f, 
    -0.00164030f, -0.04380640f, 0.04395728f, 0.00509583f, 0.01605806f, 0.01995165f, -0.00213664f, -0.01267928f, 
    -0.00646345f, 0.01140171f, -0.04102573f, 0.04738078f, -0.05166419f, -0.00747194f, 0.02709469f, 0.02495267f, 
    0.03302476f, -0.02945441f, 0.02549523f, 0.03500970f, -0.01141524f, 0.03901527f, -0.01468524f, -0.00198819f, 
    0.01286728f, -0.00383261f, -0.01047983f, 0.00148573f, 0.04292863f, 0.03994004f, 0.01666603f, -0.02391109f, 
    0.03183071f, -0.02518194f, 0.03113841f, 0.03003829f, -0.04630752f, 0.01401688f, -0.00802049f, 0.00489103f, 
    0.03209813f, 0.00218391f, -0.01222472f, -0.02655964f, -0.00331208f, 0.02093711f, 0.03680503f, -0.00008982f, 
    0.03849418f, 0.00603415f, 0.01137037f, -0.00269881f, -0.03554839f, -0.01275382f, 0.03085818f, -0.01032438f, 
    -0.00882581f, 0.04225287f, -0.05258702f, 0.00333825f, -0.00548588f, -0.04438935f, -0.01425953f, 0.00482828f, 
    -0.04786503f, 0.04198285f, 0.03904864f, 0.00489129f, -0.04058751f, -0.02311301f, 0.00045185f, 0.02007403f, 
    0.00424099f, 0.03632307f, -0.04489563f, 0.01225809f, 0.02358957f, -0.02416396f, 0.01486350f, 0.01757938f, 
    -0.04929744f, 0.01601677f, -0.04294338f, -0.02377124f, 0.03949508f, 0.04575335f, -0.05064150f, -0.02578244f, 
    -0.02801828f, -0.01616009f, -0.03636706f, -0.02337221f, -0.01557158f, 0.01895729f, -0.03673569f, 0.04498198f, 
    -0.01386169f, -0.04529587f, -0.04440162f, -0.04224309f, -0.01161364f, -0.05187682f, -0.02147213f, 0.00955551f, 
    -0.02254711f, -0.02281150f, -0.03137042f, -0.00808108f, -0.02448965f, 0.00197923f, -0.03924849f, 0.00855510f, 
    0.04129049f, 0.02038729f, -0.04636454f, -0.01274559f, 0.02437792f, 0.01541976f, 0.01503159f, -0.01483145f, 
    -0.04215776f, -0.02407490f, -0.03853706f, -0.02103176f, 0.00590252f, -0.01261523f, -0.02211128f, 0.02241774f, 
    -0.03899563f, -0.00613471f, 0.01730879f, -0.05103164f, 0.02019370f, -0.05278051f, 0.01045158f, 0.01263307f, 
    0.02480016f, 0.04267919f, 0.02408944f, -0.03396046f, -0.03137017f, -0.01164647f, -0.02409668f, 0.02299558f, 
    -0.04648316f, -0.04558988f, 0.01389353f, -0.05246092f, -0.04020553f, 0.00638898f, -0.01426109f, -0.01729258f, 
    0.03338216f, 0.03202328f, -0.01889788f, -0.01475592f, -0.00450225f, 0.04342645f, -0.01315143f, 0.02243306f, 
    -0.02308006f, 0.03293162f, -0.03906550f, -0.04965208f, 0.03220749f, -0.02108910f, 0.00512949f, 0.03203291f, 
    -0.02962233f, -0.03613660f, 0.00452935f, 0.02409538f, -0.02802968f, -0.04494080f, 0.01543148f, 0.00219482f, 
    -0.04635982f, -0.05410780f, 0.02590113f, 0.00093033f, 0.04407185f, -0.04195093f, 0.04151721f, -0.03917200f, 
    -0.02270989f, 0.00525901f, 0.03022079f, -0.01456589f, 0.03181293f, 0.04290839f, 0.04207737f, 0.01464093f, 
    0.01852200f, 0.01043056f, -0.05155225f, -0.01955332f, -0.04317733f, 0.03547722f, -0.04625802f, -0.05466921f, 
    -0.03354838f, -0.04962207f, -0.03742114f, -0.05448948f, -0.01804161f, -0.01828563f, -0.04514124f, 0.04026066f, 
    -0.00946474f, 0.01462499f, 0.02099069f, -0.02164966f, 0.01331022f, 0.00591008f, -0.02236626f, 0.02687452f, 
    -0.04276543f, -0.01961217f, 0.01931454f, -0.02335127f, -0.02468845f, -0.00094207f, 0.02290349f, -0.01083277f, 
    -0.03627369f, 0.00168615f, 0.04043704f, 0.01101989f, 0.02584196f, 0.04094412f, 0.04328612f, 0.02405778f, 
    -0.04535311f, -0.05320777f, -0.01500830f, -0.02809153f, 0.03340555f, -0.02900995f, -0.01641602f, -0.00313604f, 
    0.00608848f, -0.00532992f, -0.04897649f, 0.01516788f, -0.01753274f, -0.04470850f, -0.01616215f, -0.05531512f, 
    -0.01857892f, -0.00634425f, 0.02612878f, 0.03617702f, 0.01160566f, -0.01991450f, -0.01798855f, 0.02865434f, 
    0.03076102f, -0.04982370f, -0.00963719f, 0.04188928f, -0.03200832f, 0.01071585f, 0.01512715f, 0.03581870f, 
    -0.01035985f, -0.03860512f, -0.03468605f, -0.01168816f, -0.00203254f, -0.04039956f, 0.00766382f, -0.00601288f, 
    -0.02409558f, 0.01318440f, 0.03792966f, -0.03113712f, 0.01883676f, -0.03522440f, -0.04966795f, -0.02425548f, 
    -0.03547793f, -0.01603711f, -0.02270407f, -0.03703342f, -0.04895622f, -0.02212223f, -0.02402611f, -0.03056114f, 
    -0.00530713f, -0.04486283f, 0.00253463f, -0.03160187f, -0.01281183f, 0.03240606f, -0.02709570f, 0.01315342f, 
    0.00646956f, -0.04768603f, -0.02055402f, -0.01630213f, 0.00978977f, -0.04012165f, 0.01576590f, 0.02535723f, 
    0.03822083f, 0.01168926f, -0.02230010f, -0.05037728f, -0.04976976f, 0.03665579f, 0.01125351f, 0.02779885f, 
    -0.01664145f, 0.02740964f, -0.02684456f, -0.05525872f, 0.03880923f, -0.02354022f, -0.04984529f, -0.03580821f, 
    -0.02275542f, -0.03040758f, -0.03409652f, -0.01732067f, -0.00149608f, 0.00500552f, 0.00162686f, -0.02783549f, 
    -0.02947021f, -0.02548318f, 0.01620706f, -0.02156535f, -0.02163325f, 0.00011409f, -0.03156114f, 0.00161005f, 
    0.00112693f, -0.04635983f, 0.00255043f, -0.04830191f, 0.02764292f, -0.01946690f, -0.01842750f, -0.01912646f, 
    -0.04524497f, -0.00422663f, 0.04203964f, -0.05061156f, -0.00974874f, 0.03366442f, 0.01808259f, -0.00460483f, 
    -0.05520149f, -0.01274236f, -0.02376679f, -0.01457118f, -0.00918753f, -0.02839962f, -0.03434074f, -0.04134418f, 
    -0.02058671f, -0.01700649f, -0.02131243f, -0.01872498f, -0.04671332f, -0.05056423f, 0.00559868f, -0.01195612f, 
    0.03169303f, -0.00653093f, 0.04586038f, 0.02112745f, -0.00717367f, -0.02064389f, -0.01477757f, 0.03922661f, 
    -0.00380332f, -0.01155576f, 0.00379048f, 0.01887560f, -0.02297967f, -0.03223170f, -0.04457907f, 0.03696132f, 
    0.00500674f, 0.03520654f, -0.01483168f, 0.00140806f, 0.03915012f, -0.05566163f, 0.00719145f, 0.03880470f, 
    0.02538817f, 0.03288269f, -0.02348750f, 0.02763648f, -0.00847788f, -0.00432246f, -0.04253535f, 0.02284538f, 
    0.00838558f, 0.03825605f, 0.01993596f, 0.04580337f, 0.00011942f, -0.01546447f, -0.04075277f, -0.01329647f, 
    0.20366365f, -0.10209694f, -0.04597402f, 0.26790985f, -0.19558166f, -0.14501882f, 0.00362316f, 0.00666531f, 
    -0.11919037f, -0.03339503f, 0.00813885f, 0.10659364f, -0.05067246f, 0.01632805f, -0.12237538f, 0.08236792f, 
    -0.06423380f, 0.01877518f, 0.03568049f, -0.09598096f, 0.02710058f, 0.04106345f, 0.06948222f, -0.15546118f, 
    0.21391334f, 0.27340871f, 0.19169948f, -0.09016233f, -0.00604127f, 0.05689909f, 0.01540773f, -0.15482588f, 
    0.09758849f, 0.04471872f, 0.07085893f, -0.06046822f, -0.01620966f, 0.00632639f, 0.02267585f, 0.15400603f, 
    -0.19942153f, -0.09179039f, -0.17023614f, 0.00520437f, -0.01785743f, -0.04826394f, 0.00189479f, -0.09399177f, 
    0.07004907f, -0.13277255f, 0.05633406f, -0.05568476f, -0.22539550f, -0.02684809f, -0.02577800f, 0.03007072f, 
    -0.04828318f, -0.10082660f, -0.00860893f, -0.05489551f, -0.11515821f, 0.31860900f, -0.05825766f, -0.15904622f, 
    0.10809284f, 0.09724310f, -0.14999563f, -0.00453150f, 0.03207989f, -0.00140979f, -0.01767416f, 0.04326797f, 
    0.18553606f, 0.04968386f, -0.12378977f, -0.11637448f, 0.09167980f, 0.06251673f, 0.00966026f, -0.09763394f, 
    0.07128194f, 0.05474535f, 0.00276214f, 0.05314864f, 0.04579602f, 0.09238222f, 0.24687174f, 0.15208937f, 
    0.00652627f, 0.00267613f, 0.02787086f, -0.05264642f, -0.05060014f, 0.02566208f, -0.09134815f, 0.04096919f, 
    -0.31110045f, -0.10705005f, 0.05241898f, 0.00651454f, -0.06991487f, -0.11306690f, -0.07326989f, -0.12902553f, 
    0.04966754f, 0.08865388f, 0.07144871f, -0.01293442f, -0.02078711f, -0.05898416f, 0.00109255f, -0.00934207f, 
    -0.01168656f, 0.01291195f, -0.08232588f, -0.00739684f, 0.04370672f, 0.08326127f, 0.00297358f, -0.05933502f, 
    0.29472330f, -0.16476089f, -0.11089334f, -0.07058305f, 0.14378297f, -0.09467997f, -0.05326627f, -0.07540397f, 
    -0.06894301f, 0.01164817f, 0.04264801f, 0.02383550f, 0.11194841f, -0.12120719f, 0.22189125f, -0.02074000f, 
    0.12866725f, 0.07398468f, -0.02804211f, 0.14796156f, 0.01983351f, 0.02469359f, -0.09340462f, 0.01088614f, 
    -0.39428630f, 0.06783728f, 0.09694719f, -0.16344181f, -0.17420830f, -0.11425214f, 0.08858839f, 0.06896596f, 
    -0.02437796f, -0.00728273f, -0.02612066f, -0.11498572f, 0.21786389f, -0.07534232f, -0.08465436f, -0.26841560f, 
    0.01031761f, -0.10023350f, 0.01142201f, 0.03338102f, -0.09410302f, -0.06679487f, -0.08000016f, -0.06157872f, 
    0.25327730f, 0.06850065f, 0.05161025f, 0.31129846f, -0.26557049f, -0.08782655f, 0.05745488f, 0.00590120f, 
    0.02043351f, -0.03816924f, -0.00694508f, 0.00215773f, 0.28066605f, 0.41827247f, 0.14392547f, 0.08463338f, 
    0.28858358f, 0.19168791f, 0.05552206f, 0.04622079f, 0.07256740f, 0.07457639f, 0.03632479f, 0.07941229f, 
    0.30774871f, -0.01445888f, 0.23039417f, 0.18398525f, -0.11411939f, -0.02966162f, -0.03103514f, -0.13370587f, 
    -0.07486602f, 0.02521427f, 0.00638987f, 0.01766984f, 0.10529186f, 0.05096624f, 0.08422482f, 0.06694789f, 
    0.00302500f, 0.10941812f, -0.03242793f, -0.04091471f, 0.00680669f, 0.05136768f, 0.02521451f, -0.06550390f, 
    -0.33094350f, 0.05835937f, 0.13485584f, -0.02014315f, -0.12621038f, -0.00507090f, 0.06883375f, -0.04808959f, 
    -0.07809785f, -0.04460681f, -0.05134863f, -0.12675300f, 0.21273120f, 0.05373848f, 0.11528277f, 0.17044815f, 
    0.03326826f, 0.05726131f, 0.06544215f, -0.09355199f, 0.00349602f, 0.05970313f, 0.05832296f, -0.11365705f, 
    -0.17567943f, -0.07401718f, 0.17357935f, -0.00107017f, -0.06205297f, 0.06110125f, 0.01418773f, -0.07965794f, 
    0.01757697f, 0.06087013f, -0.09833551f, -0.07247349f, -0.23552269f, 0.16236331f, 0.17646360f, 0.22664040f, 
    -0.02575969f, 0.03231843f, 0.03287043f, -0.12843259f, 0.13628489f, 0.03635098f, 0.06131271f, 0.04729114f, 
    -0.03640822f, -0.00839354f, 0.03148843f, 0.00069446f, -0.18076941f, -0.04434324f, -0.01477879f, -0.06405769f, 
    0.00972139f, -0.10950848f, 0.00418362f, -0.01382590f, 0.28462666f, -0.10117951f, -0.11966541f, 0.06837118f, 
    -0.05306261f, -0.06084870f, -0.10044674f, -0.05301707f, -0.07058972f, -0.08127265f, 0.00408940f, -0.12859978f, 
    0.13693632f, -0.08249339f, 0.20572475f, 0.12397408f, -0.00726085f, -0.00951082f, -0.01743270f, -0.02583466f, 
    -0.01407890f, -0.08532400f, 0.04900143f, -0.01493965f, 0.29135799f, 0.11847008f, 0.22119473f, -0.14487092f, 
    0.09826077f, 0.02958674f, 0.11184511f, 0.10409752f, -0.04336829f, -0.01190749f, -0.01176068f, -0.03028952f, 
    -0.21171321f, 0.23668510f, 0.00877481f, 0.03863293f, -0.05607330f, 0.03914847f, -0.04348423f, 0.03960478f, 
    -0.15538272f, 0.01269554f, -0.04578745f, -0.02618109f, 0.05593869f, -0.02507547f, -0.10871764f, 0.12336937f, 
    -0.19973381f, -0.04657836f, -0.00316123f, 0.01034868f, 0.02369323f, -0.03058014f, 0.00870208f, -0.05785833f, 
    -0.06522991f, 0.25382882f, 0.15465996f, -0.05983848f, 0.10771642f, 0.13918936f, 0.00880971f, 0.08153161f, 
    0.02048437f, -0.00266890f, 0.00748575f, -0.03844515f, -0.28975746f, 0.15181291f, -0.19949827f, 0.11398872f, 
    0.04121013f, 0.01645293f, -0.06227411f, -0.01352138f, 0.01053679f, 0.03203703f, -0.04067302f, 0.00922812f, 
    0.13738042f, 0.14451607f, -0.01463133f, 0.17933069f, 0.31828949f, 0.09579264f, -0.06539337f, 0.09278447f, 
    0.10904490f, -0.04204288f, -0.02484619f, -0.14912471f, -0.36455280f, 0.06965738f, 0.08593706f, 0.01771023f, 
    -0.01179004f, -0.05374270f, 0.08585623f, 0.04844636f, -0.14873347f, -0.08936726f, 0.00068884f, -0.06838032f, 
    0.16160484f, 0.11657722f, 0.13619362f, -0.10225735f, 0.00278251f, -0.03554678f, -0.08882671f, 0.08288167f, 
    0.09367188f, 0.04354181f, 0.06947654f, 0.00607915f, -0.10592653f, 0.11701194f, 0.01915798f, -0.00132636f, 
    -0.00127779f, -0.00700449f, 0.00786769f, -0.04205820f, 0.07370062f, 0.06873129f, -0.01507752f, -0.02064428f, 
    0.16398843f, 0.01351039f, -0.07698219f, 0.24233547f, -0.03721289f, -0.06181107f, 0.08628509f, -0.04541069f, 
    -0.11473632f, -0.08935428f, 0.03929069f, -0.00552530f, 0.24936368f, -0.13988207f, 0.04151616f, 0.14266320f, 
    -0.00785877f, 0.00107369f, 0.08378407f, 0.03856156f, 0.00757700f, 0.04856560f, -0.07708190f, 0.14244556f, 
    0.14794099f, 0.18161376f, -0.02735384f, 0.21975985f, -0.00762180f, -0.00821149f, -0.07052512f, 0.05221628f, 
    0.14296240f, 0.15761210f, 0.01423023f, 0.07218099f, 0.01963397f, -0.03883732f, -0.02726473f, 0.05107790f, 
    -0.00901984f, 0.14424075f, 0.05189956f, 0.08657665f, 0.05863067f, -0.03441916f, 0.03795007f, -0.06308571f, 
    -0.13218376f, -0.00700524f, -0.02044859f, 0.10473590f, 0.05574961f, -0.01794227f, 0.03352840f, 0.01428636f, 
    -0.05012124f, 0.06337631f, 0.06427471f, 0.14186682f, -0.12145988f, -0.06838842f, -0.01960605f, -0.20420912f, 
    0.18708959f, 0.06864184f, 0.16463310f, 0.08149819f, -0.00494258f, 0.07567019f, 0.10949026f, 0.01883774f, 
    0.20494516f, 0.11396012f, -0.09144506f, -0.05082043f, 0.01547006f, 0.05322978f, 0.01789519f, 0.03116394f, 
    -0.03184875f, -0.05854313f, -0.03123354f, 0.10015159f, 0.05726612f, 0.06162187f, -0.11120668f, 0.03277069f, 
    0.03767695f, -0.02441698f, 0.02482708f, 0.07661326f, 0.03910730f, -0.03713519f, -0.09665103f, 0.04824495f, 
    -0.08249577f, 0.06234565f, 0.06365067f, 0.03886449f, 0.00860769f, 0.03591728f, 0.03536814f, 0.14388490f, 
    -0.04654711f, -0.08810907f, 0.02913705f, -0.04458450f, -0.06006951f, 0.03772601f, -0.15100567f, -0.07556570f, 
    0.05732064f, -0.06645437f, -0.00111971f, -0.07837135f, 0.04941366f, 0.03668934f, 0.18425559f, -0.00830729f, 
    0.27206245f, -0.19898432f, -0.14591423f, 0.14703037f, 0.14289907f, 0.13261640f, -0.06538071f, 0.04165956f, 
    0.02368706f, -0.06811030f, -0.11613309f, 0.06480668f, 0.10909832f, 0.14974615f, 0.08338053f, 0.16350636f, 
    0.00106423f, -0.00086406f, -0.05493807f, 0.03191259f, -0.00979009f, 0.01095803f, -0.02786794f, 0.16992979f, 
    -0.09128299f, 0.17441940f, 0.06799657f, 0.02813660f, 0.08226032f, 0.00207119f, -0.00142703f, 0.06072786f, 
    0.02294633f, 0.02750011f, -0.12929597f, -0.05743305f, -0.02704439f, -0.18827885f, -0.06479280f, -0.05391249f, 
    -0.09887094f, 0.02816593f, -0.10647517f, -0.03425232f, 0.01119246f, 0.04139912f, -0.09645499f, -0.04097766f, 
    -0.00008697f, -0.09603816f, -0.23361893f, -0.07817203f, 0.05338587f, 0.09887253f, -0.00628205f, 0.13744755f, 
    -0.00015419f, -0.00911726f, 0.05433657f, 0.01210800f, -0.14527875f, -0.04360200f, -0.05354866f, 0.03255804f, 
    0.05278280f, -0.05768709f, -0.01070611f, -0.04400580f, 0.11610095f, -0.01123896f, 0.02956579f, 0.04460759f, 
    0.13622010f, -0.11197983f, 0.11957064f, 0.14960442f, -0.04696228f, 0.05548814f, -0.00041739f, -0.00832909f, 
    0.07645284f, 0.01040122f, -0.02314299f, 0.07202918f, -0.25493240f, 0.04805372f, -0.06644854f, -0.11920859f, 
    0.09960810f, 0.01764114f, 0.09196556f, 0.02694408f, 0.09843164f, -0.04802849f, -0.00769047f, 0.07449928f, 
    0.06189842f, 0.14921558f, -0.07792831f, 0.11763681f, -0.02178025f, -0.05362213f, 0.00012178f, 0.04355909f, 
    0.00417910f, -0.06087003f, 0.04494816f, 0.01715250f, 0.18331406f, -0.06939851f, 0.07535429f, 0.05180512f, 
    -0.09837747f, 0.05250233f, 0.00836765f, 0.11071534f, 0.06971952f, 0.06999590f, -0.07040827f, 0.04815176f, 
    0.03652379f, 0.02488234f, 0.03311205f, -0.18341471f, 0.09846230f, 0.09117049f, 0.18801564f, -0.07386465f, 
    -0.06906110f, 0.11541554f, 0.02605535f, -0.01345586f, -0.24801114f, 0.08014494f, 0.42784977f, -0.12110405f, 
    -0.06286282f, 0.07140020f, 0.13846062f, -0.00143485f, 0.00677069f, 0.00745820f, 0.00552735f, 0.05655572f, 
    -0.07472422f, 0.14879149f, -0.10583404f, -0.21815361f, 0.03165954f, 0.08847746f, 0.11172295f, 0.05979950f, 
    0.03674760f, -0.03918775f, 0.08028119f, 0.07806611f, -0.12264344f, -0.10339519f, 0.01107037f, -0.10408239f, 
    -0.03591361f, 0.03017669f, 0.07615613f, -0.05500710f, 0.02972411f, -0.10377239f, 0.04486052f, 0.16246694f, 
    0.24454528f, -0.05075624f, -0.02943170f, -0.08884138f, 0.09045873f, -0.05819173f, -0.02374526f, -0.13687550f, 
    -0.00542997f, 0.03474189f, 0.04065626f, 0.05420161f, -0.06596791f, 0.17766146f, 0.04110137f, 0.00162859f, 
    0.08908910f, -0.03722095f, -0.00081030f, 0.05261740f, 0.06492847f, 0.07214394f, -0.09766183f, 0.09590659f, 
    -0.05470676f, -0.04447554f, -0.06905276f, -0.07413019f, 0.00054030f, 0.03248712f, -0.01379753f, -0.02061165f, 
    0.05295489f, 0.01724707f, -0.01662857f, 0.09999339f, 0.24349511f, -0.24854934f, 0.17348833f, -0.03784671f, 
    -0.10684931f, -0.03235023f, -0.00114387f, 0.04507660f, 0.03078284f, 0.05136581f, 0.07755861f, 0.01605245f, 
    -0.09323173f, -0.08386335f, 0.12993133f, -0.02361375f, -0.07050047f, -0.02956065f, 0.01257038f, -0.05383255f, 
    0.00701196f, 0.00405004f, -0.05833767f, 0.16486003f, 0.30161282f, -0.15732686f, -0.03664068f, 0.08615562f, 
    -0.06933849f, 0.00369622f, -0.00883046f, -0.11315997f, -0.08211444f, 0.02787223f, 0.07925650f, 0.00933503f, 
    0.03119791f, -0.00922764f, 0.01218079f, -0.00697045f, 0.02587743f, -0.05607978f, -0.03867321f, -0.05820267f, 
    -0.02901603f, -0.01269337f, -0.03467629f, -0.03482886f, 0.02520045f, 0.03002281f, 0.02122675f, 0.03719602f, 
    0.00697984f, -0.02096447f, -0.00942740f, -0.02858393f, -0.01140002f, -0.01864326f, -0.00672871f, -0.04638635f, 
    -0.04635200f, 0.04713205f, -0.04881201f, -0.01672746f, -0.00526188f, -0.00789711f, -0.03957735f, 0.03117156f, 
    0.03734876f, -0.02987288f, -0.03926818f, 0.03244058f, -0.05232557f, 0.01581280f, -0.05287644f, 0.02199050f, 
    -0.02972423f, 0.01976898f, -0.01518981f, -0.01177660f, -0.03407020f, -0.05386620f, 0.00105007f, -0.02342096f, 
    -0.04076919f, 0.01002197f, -0.00142056f, -0.00323154f, -0.03803652f, 0.02711478f, -0.02126044f, 0.02936704f, 
    -0.01358576f, -0.02985906f, -0.01925115f, -0.03907133f, 0.01266663f, 0.03390463f, -0.04168178f, -0.01366162f, 
    0.01843428f, 0.03429076f, -0.01061463f, -0.02314204f, -0.03322443f, 0.04400949f, -0.03989272f, -0.03033797f, 
    -0.01960408f, 0.01724289f, -0.04364980f, -0.01653647f, -0.04219934f, -0.03410298f, -0.00140362f, 0.02999678f, 
    0.03736351f, 0.01776489f, -0.05603438f, -0.00378087f, 0.02459923f, -0.02719454f, 0.03645755f, -0.01493728f, 
    -0.05793088f, -0.01683840f, -0.04030600f, -0.05500161f, 0.00044871f, 0.03108325f, -0.04981912f, 0.02245400f, 
    -0.00795094f, -0.01418425f, -0.04400919f, -0.03357933f, -0.03064414f, 0.03931470f, -0.01965914f, 0.04193142f, 
    -0.04503361f, 0.01243227f, -0.03000955f, 0.00028918f, 0.02460416f, -0.03833336f, 0.00229503f, -0.02624737f, 
    -0.04220171f, -0.01804728f, 0.00158126f, 0.03370976f, -0.04579420f, 0.03511288f, -0.04238276f, 0.01929356f, 
    -0.00452410f, -0.00278359f, 0.04474118f, -0.03884724f, -0.02037248f, 0.03701334f, 0.02106124f, -0.03950432f, 
    0.04080294f, -0.03323963f, 0.00318854f, 0.02413512f, 0.01669000f, -0.01714856f, -0.06124440f, -0.02427594f, 
    -0.01683206f, -0.04969003f, 0.02172721f, 0.01640932f, 0.00283461f, -0.04635208f, 0.00607199f, -0.02100024f, 
    -0.02451194f, 0.04104009f, -0.03099633f, 0.01851713f, -0.01617776f, 0.01883828f, 0.02331755f, -0.01973324f, 
    0.02859356f, -0.02279096f, 0.03581613f, -0.04310661f, -0.01673930f, -0.02660952f, -0.03878482f, -0.05009579f, 
    -0.05856883f, -0.00727883f, -0.05454640f, 0.03300584f, -0.03625159f, -0.04705948f, -0.05322357f, -0.01393374f, 
    0.00999585f, -0.01569135f, -0.00094650f, -0.00083938f, 0.02463123f, 0.01623254f, -0.05782755f, 0.01555615f, 
    0.01586207f, -0.02303085f, 0.03145065f, -0.00188674f, 0.00436666f, 0.03755105f, -0.01196171f, -0.03049634f, 
    -0.02161320f, 0.04428722f, -0.01107200f, 0.04637975f, 0.03918324f, -0.02663250f, -0.00462409f, 0.00798949f, 
    -0.05109266f, -0.01145963f, 0.02272342f, 0.00501158f, -0.04926933f, 0.02674992f, 0.00798567f, 0.00112726f, 
    0.04543868f, -0.03464510f, -0.02281216f, 0.01289070f, 0.01410049f, 0.04292665f, 0.03082012f, -0.03880363f, 
    -0.04090928f, -0.05312534f, 0.03515002f, -0.00100805f, 0.02627738f, -0.00662631f, 0.00126904f, -0.02362910f, 
    -0.00631716f, 0.00638249f, -0.00797705f, -0.03987370f, 0.03734107f, -0.03490213f, 0.00444185f, 0.01517119f, 
    -0.04271348f, 0.04302606f, -0.00852989f, -0.03969576f, -0.01102203f, 0.02204924f, -0.00242595f, -0.02266762f, 
    -0.04585210f, -0.03766038f, -0.03383207f, 0.01364941f, 0.03710586f, 0.01012188f, 0.04370469f, -0.02238231f, 
    -0.01456506f, -0.00762162f, 0.01085968f, -0.02325385f, 0.04552013f, 0.03613264f, 0.00171102f, 0.03673709f, 
    -0.02407851f, -0.05900346f, -0.04661392f, 0.00793331f, -0.00460187f, -0.01157137f, 0.03633852f, 0.02354977f, 
    -0.03069724f, 0.01287657f, 0.03045720f, -0.02107359f, 0.02786364f, -0.01644968f, -0.03203308f, -0.00590846f, 
    0.02469894f, -0.05222638f, 0.01050075f, -0.02929710f, 0.04500855f, 0.02535154f, 0.04301247f, -0.05441141f, 
    -0.04250174f, 0.02239774f, -0.01579075f, 0.02078510f, 0.02556949f, -0.05298806f, 0.03256124f, -0.01571214f, 
    -0.01376501f, 0.03229475f, -0.02483296f, -0.01541147f, 0.02800022f, 0.01652121f, 0.01150095f, -0.04155589f, 
    -0.00087568f, 0.01386450f, 0.03043967f, -0.02622655f, 0.01212304f, 0.01920578f, 0.02158418f, 0.00443829f, 
    0.00907352f, -0.02146768f, 0.02057621f, 0.02871436f, 0.03150025f, -0.04779164f, 0.01070786f, 0.02137498f, 
    0.01565984f, -0.03997459f, 0.04274489f, -0.02558996f, -0.02431181f, -0.04327007f, 0.02274419f, -0.01678916f, 
    -0.00973975f, -0.03048689f, -0.05114134f, -0.03851385f, -0.04190956f, -0.02639209f, 0.02107284f, -0.01181209f, 
    -0.00443342f, -0.03533275f, -0.04433173f, -0.01576331f, 0.01944468f, 0.03243284f, -0.02812316f, 0.01024666f, 
    -0.04483495f, 0.00761537f, -0.00835007f, 0.03931558f, 0.01198046f, 0.03198433f, -0.01336610f, -0.00498194f, 
    -0.04688543f, -0.02590084f, -0.05183862f, -0.04751839f, -0.02002983f, -0.00251824f, -0.03479644f, -0.01671634f, 
    0.02470996f, -0.04429644f, -0.00435742f, -0.03284252f, -0.00724921f, -0.00051152f, 0.01997780f, 0.03208978f, 
    0.02080609f, 0.04685907f, 0.02262240f, -0.05003421f, -0.01005448f, 0.04230756f, -0.03083088f, -0.00658594f, 
    0.01115201f, 0.01516534f, 0.03344005f, -0.05325661f, -0.03959642f, -0.04324497f, -0.01296516f, -0.03799129f, 
    -0.03302696f, 0.03065823f, -0.02990036f, -0.03047810f, -0.02023395f, -0.03844549f, -0.03139684f, -0.01295073f, 
    -0.00415695f, -0.01135032f, 0.02151853f, -0.04737313f, 0.03794502f, 0.01558551f, -0.04061211f, 0.01714360f, 
    0.08608165f, 0.05005981f, 0.22429696f, -0.20734951f, 0.06826589f, 0.09742074f, 0.03884942f, 0.04285363f, 
    0.07354413f, -0.02698393f, 0.02562396f, 0.17584191f, -0.03989959f, 0.04410848f, 0.12974906f, 0.10628565f, 
    0.08074642f, -0.00803602f, 0.08251861f, -0.00990500f, 0.02890960f, 0.06325801f, 0.14967571f, 0.14812870f, 
    -0.45019367f, 0.00567786f, -0.01939777f, 0.02383199f, 0.02031539f, 0.09741913f, -0.12002078f, -0.00306165f, 
    0.07521679f, -0.05546740f, 0.02598196f, 0.03772685f, -0.23850849f, 0.09010863f, 0.04849997f, -0.20467073f, 
    -0.12259694f, 0.03599963f, -0.05598606f, -0.09297830f, 0.03211901f, -0.04126830f, -0.02077555f, 0.06798562f, 
    -0.13425227f, 0.08065756f, 0.38329214f, -0.09041119f, 0.00947154f, 0.07943481f, 0.04828067f, 0.00393960f, 
    0.01458079f, 0.01249313f, 0.09889523f, 0.09680486f, -0.21330522f, -0.13637751f, -0.20840919f, -0.11209154f, 
    0.02188372f, 0.03492424f, 0.10937559f, -0.07244931f, -0.02930888f, 0.09563777f, 0.08033304f, 0.06847037f, 
    -0.02940838f, -0.14622284f, -0.22185068f, -0.04681795f, 0.05458875f, 0.10144155f, -0.03689890f, -0.08540232f, 
    0.10288905f, 0.12910356f, 0.09324211f, 0.11335442f, 0.22366935f, -0.06603362f, -0.08590460f, -0.03220734f, 
    -0.04672941f, 0.15570538f, -0.07640190f, 0.10018856f, 0.10730460f, 0.02602998f, 0.11067388f, 0.10598696f, 
    -0.10386125f, 0.21272747f, 0.02046301f, -0.03870065f, -0.06564185f, 0.00055160f, -0.04311307f, 0.11444458f, 
    0.11023402f, -0.04402903f, -0.00167392f, 0.08021030f, 0.12163064f, 0.20996854f, 0.26669285f, -0.18741049f, 
    0.00859662f, 0.15193835f, 0.02450298f, -0.02478966f, -0.01542076f, 0.21675764f, -0.13731013f, -0.05632889f, 
    0.15806721f, -0.28025430f, 0.04781307f, 0.29542148f, 0.09769362f, -0.02276887f, 0.04658243f, 0.07680842f, 
    0.03368371f, 0.03906663f, 0.03791033f, -0.00862389f, 0.21969284f, -0.14188598f, -0.18403047f, 0.21008047f, 
    0.13494849f, -0.17905733f, -0.01850173f, 0.08071404f, -0.05976347f, 0.04570649f, 0.09937102f, 0.08147940f, 
    0.16297491f, 0.10394906f, -0.01302287f, -0.06401242f, 0.22691652f, 0.11935287f, -0.01845914f, 0.02228665f, 
    0.04836997f, 0.08884166f, 0.14654393f, -0.05858521f, -0.02028325f, 0.00797543f, 0.25805178f, 0.29998189f, 
    -0.13364412f, -0.02627069f, 0.01125595f, 0.02981880f, 0.02769267f, -0.06816833f, 0.10698938f, -0.03131795f, 
    0.18184349f, -0.06859490f, 0.09854875f, 0.12859586f, -0.05131494f, 0.03727867f, 0.04838130f, 0.05274125f, 
    0.13976206f, 0.03199857f, -0.10892993f, 0.01471284f, -0.10710475f, -0.18543372f, -0.41432193f, -0.13410671f, 
    0.02627003f, -0.00402739f, -0.08946823f, -0.22075184f, -0.05753882f, -0.03642789f, 0.04990945f, -0.00443584f, 
    -0.18515265f, -0.13918450f, 0.20268178f, 0.04393960f, 0.14006844f, 0.04740931f, 0.03847278f, -0.02661320f, 
    0.08254845f, -0.02455237f, 0.15499219f, 0.10854192f, -0.20674957f, -0.06271727f, 0.17224701f, -0.10975331f, 
    0.05188602f, -0.04999471f, 0.12092522f, 0.03814931f, 0.04897799f, -0.00073226f, -0.02386695f, -0.02303918f, 
    0.08399419f, 0.07368328f, 0.15275100f, 0.05814118f, 0.09265517f, 0.10651989f, 0.02440983f, 0.13505304f, 
    0.01536339f, 0.05214180f, 0.06441787f, 0.15434903f, 0.02492918f, -0.41694081f, 0.14964421f, 0.10860912f, 
    0.09194357f, -0.07358955f, 0.08208268f, 0.12939957f, 0.06243351f, -0.03500360f, -0.04580888f, 0.06067741f, 
    -0.09337213f, -0.04203006f, 0.06067138f, 0.24016012f, -0.00675185f, -0.07243901f, 0.03907846f, 0.09819840f, 
    0.02488401f, 0.00897265f, -0.12154756f, 0.00922918f, 0.00791023f, 0.09526466f, 0.03749011f, -0.19007109f, 
    0.10380004f, -0.01393696f, 0.00198705f, -0.05436701f, -0.00997853f, 0.02428871f, 0.10282029f, -0.02429373f, 
    0.14864846f, 0.13177264f, 0.04526109f, 0.30989853f, -0.05025056f, -0.05600963f, 0.11667172f, 0.04686943f, 
    -0.07565107f, 0.05365542f, 0.08094200f, 0.14729142f, -0.09785233f, 0.22937490f, 0.02280817f, 0.20409119f, 
    -0.03446080f, -0.06281891f, 0.13238518f, 0.00266581f, 0.04539891f, 0.06103473f, 0.00124671f, 0.07784616f, 
    0.16350308f, 0.07929726f, 0.07549175f, -0.09009054f, 0.04414345f, 0.08395461f, 0.01294906f, -0.00427452f, 
    -0.01056128f, -0.01142684f, 0.02794768f, 0.04721531f, 0.10882410f, -0.10555666f, -0.08801088f, -0.02205483f, 
    -0.05076528f, -0.01316568f, 0.01816498f, 0.03666027f, 0.13905813f, 0.12757075f, -0.08377172f, -0.00010294f, 
    0.30586749f, -0.03828567f, 0.12514631f, 0.50967407f, 0.14209223f, 0.13692026f, 0.01109625f, 0.21797550f, 
    0.10602184f, 0.07482712f, 0.04996026f, 0.07282075f, 0.01899500f, 0.04030525f, 0.06629176f, 0.04831214f, 
    0.14367522f, 0.05978867f, 0.01886042f, 0.03528078f, -0.02534957f, 0.03697811f, 0.01267069f, 0.11611723f, 
    -0.00997317f, -0.06651709f, -0.24195962f, 0.17038269f, 0.11715686f, 0.07153030f, 0.15263835f, 0.05752273f, 
    0.02539096f, 0.05318923f, 0.01052992f, 0.08648127f, -0.05773169f, 0.06634295f, 0.23983803f, -0.01102528f, 
    0.10051031f, -0.02619323f, -0.00611631f, 0.00076619f, 0.03338462f, -0.03393591f, 0.08688276f, -0.06107813f, 
    -0.34088251f, 0.08475065f, -0.09177922f, -0.00225181f, -0.01947321f, -0.01785244f, 0.13868204f, -0.00588230f, 
    0.07196001f, -0.02574629f, 0.07666457f, 0.18292132f, 0.02150048f, 0.14482835f, 0.03195695f, 0.01100986f, 
    0.03609564f, 0.06237356f, 0.05533778f, 0.08610040f, 0.04839063f, 0.07852310f, 0.10172591f, -0.05801326f, 
    0.04597832f, 0.09382549f, -0.05068079f, 0.02268205f, -0.04026126f, -0.00667522f, 0.11595184f, -0.12450941f, 
    -0.10657624f, -0.00535336f, -0.06370290f, 0.06469006f, 0.24071991f, -0.11707194f, -0.04465002f, 0.01617458f, 
    0.03939727f, 0.03414510f, 0.01221232f, 0.01215643f, -0.04815285f, -0.04744832f, -0.03517734f, 0.00339630f, 
    -0.21193069f, -0.15764560f, 0.00523369f, -0.28625005f, 0.01453509f, 0.06706248f, 0.06240880f, 0.08500944f, 
    0.10430129f, 0.16100109f, 0.01957246f, 0.01323955f, -0.32304811f, 0.14761274f, -0.00156799f, -0.19153534f, 
    0.01476704f, 0.10708110f, -0.08698019f, 0.06053054f, 0.04593492f, 0.04174507f, 0.11065150f, -0.02998837f, 
    -0.16142255f, -0.05320226f, -0.04302128f, -0.25724134f, -0.03934781f, -0.00164419f, 0.06359347f, -0.03150761f, 
    -0.09488924f, -0.10556734f, 0.01283181f, -0.02662971f, -0.11084097f, -0.09873388f, 0.00765888f, -0.11712810f, 
    0.12353382f, 0.04429463f, 0.07209872f, -0.06644598f, 0.02096680f, 0.08410551f, 0.02515519f, 0.09004318f, 
    0.00112051f, -0.26089099f, -0.03258903f, -0.10278422f, 0.04335437f, 0.07866490f, 0.00258282f, 0.00729610f, 
    0.14720374f, -0.01852213f, -0.11180808f, -0.17005935f, 0.18035766f, -0.02567380f, -0.09148335f, 0.15096378f, 
    -0.03928975f, -0.04588653f, -0.18276413f, 0.02734999f, 0.07348480f, -0.04512259f, -0.12818670f, -0.05398135f, 
    0.02247136f, 0.03502204f, 0.14188747f, 0.14120850f, 0.02071298f, 0.01077829f, 0.07469689f, 0.08504896f, 
    0.05257381f, 0.06721819f, -0.00844705f, -0.12215330f, -0.02878362f, 0.15130286f, 0.14016211f, -0.00695098f, 
    0.03006841f, 0.01029443f, 0.09856270f, -0.06294537f, -0.14692155f, 0.00925805f, 0.03832734f, -0.13767172f, 
    0.00707111f, 0.18402642f, 0.06089131f, 0.06710951f, -0.09535472f, 0.07248567f, -0.03556254f, -0.18969686f, 
    0.02272514f, 0.12658817f, -0.01331625f, 0.10651042f, -0.10985523f, 0.12417466f, 0.00513689f, 0.11211932f, 
    -0.01770140f, 0.15012185f, 0.11904929f, 0.11733988f, -0.01933189f, 0.01798509f, -0.12883091f, 0.05419314f, 
    -0.10778588f, 0.25254890f, 0.12823893f, 0.07559086f, -0.01250381f, -0.18521932f, 0.04774142f, -0.03766544f, 
    0.04102514f, 0.12269502f, 0.10615487f, -0.02064881f, -0.00580384f, 0.06934077f, -0.08709215f, -0.07768323f, 
    -0.03564805f, -0.02683324f, 0.13088840f, 0.02973942f, 0.12054755f, 0.04927555f, -0.00914325f, -0.03752026f, 
    -0.09101429f, -0.27028275f, -0.06834757f, -0.02156021f, 0.02933969f, 0.05445794f, 0.03905655f, 0.06719720f, 
    -0.00178717f, -0.06879742f, 0.10633262f, 0.12033581f, -0.16011374f, -0.00206554f, -0.05298875f, -0.13599440f, 
    0.06367573f, 0.06261471f, 0.16668972f, 0.13961428f, -0.01956661f, 0.01307472f, 0.10912578f, 0.10765334f, 
    -0.24264131f, 0.18477045f, 0.17538404f, 0.20002221f, 0.06281137f, -0.11075970f, -0.02654222f, -0.09470164f, 
    0.09699523f, 0.12589151f, 0.08333874f, 0.09032556f, 0.04142638f, 0.38508135f, 0.01697539f, 0.11419347f, 
    0.18627377f, 0.08464538f, 0.04889347f, 0.01782634f, -0.03637204f, 0.07920241f, 0.01609333f, -0.01861111f, 
    -0.05390844f, 0.00671450f, -0.17476432f, -0.12080277f, 0.05359780f, -0.01298134f, 0.01103351f, 0.03567047f, 
    0.05644750f, 0.09289064f, 0.13527495f, -0.00599040f, 0.25826088f, 0.29277536f, 0.14421213f, 0.15702474f, 
    -0.03888671f, 0.04092583f, -0.09630526f, 0.03263713f, -0.01442201f, 0.15025105f, 0.05134314f, 0.16985226f, 
    -0.06214437f, -0.06595786f, 0.15734394f, 0.02381335f, 0.06748773f, 0.02179831f, -0.06413761f, 0.03682631f, 
    -0.00376680f, 0.06357419f, 0.13303973f, 0.10530783f, -0.25074333f, -0.03342134f, -0.05872005f, -0.05906437f, 
    0.09708954f, -0.00677067f, 0.02870462f, -0.00228457f, -0.05750493f, -0.11335841f, -0.08358747f, -0.04533653f, 
    0.22206502f, 0.03324614f, 0.01599526f, 0.23425655f, 0.02029743f, -0.04655341f, -0.16243303f, 0.16488712f, 
    0.21416429f, -0.24096788f, 0.07804121f, -0.02524056f, 0.53213429f, -0.10874096f, -0.37212920f, 0.10607313f, 
    0.07463405f, -0.10472350f, -0.03381213f, 0.05336835f, -0.05479546f, -0.01331840f, 0.00817207f, 0.02738673f, 
    0.05798708f, 0.10042913f, 0.02594207f, 0.30327168f, -0.00552107f, -0.02541207f, -0.05924143f, -0.02289007f, 
    0.04282356f, 0.03333554f, 0.02130972f, -0.00348259f, 0.26671237f, -0.02943825f, -0.04570585f, 0.18866494f, 
    -0.07285138f, -0.01437327f, 0.00099850f, 0.07811318f, -0.05067195f, 0.18417791f, -0.03046287f, 0.00939936f, 
    0.14994001f, 0.01156205f, 0.21819934f, 0.23703672f, -0.07415621f, 0.18159536f, -0.00043295f, 0.11086573f, 
    0.06214456f, 0.00532980f, -0.01376670f, 0.06764567f, 0.43786025f, -0.11748101f, -0.06319641f, -0.11773600f, 
    -0.07783516f, 0.07290816f, -0.08409422f, 0.06384934f, -0.01706301f, -0.09249842f, 0.02808460f, -0.01680877f, 
    0.11392649f, 0.10220177f, 0.13928707f, 0.19547473f, 0.02739691f, 0.04166199f, 0.05325537f, 0.09115003f, 
    0.03982864f, -0.03900207f, 0.00135428f, -0.06573910f, -0.04825593f, 0.19305155f, 0.09942470f, 0.10553269f, 
    0.15998273f, -0.01032145f, -0.10655684f, 0.00026519f, -0.11598377f, -0.00434746f, -0.05331981f, 0.03621120f, 
    0.15564743f, -0.02951505f, -0.29516900f, -0.20636736f, -0.06677654f, 0.13801290f, 0.12868716f, 0.13721749f, 
    0.02656576f, 0.16713192f, 0.01820794f, -0.12122409f, -0.23001534f, 0.21282454f, 0.07729678f, 0.11123913f, 
    0.10489907f, 0.00991935f, 0.01394676f, 0.08941740f, 0.02171765f, 0.04050216f, 0.05322403f, 0.11455442f, 
    -0.04945253f, 0.15170024f, -0.03771744f, 0.10391454f, -0.08520842f, -0.18068491f, -0.02781023f, 0.00802680f, 
    -0.06653880f, 0.08336695f, 0.01231771f, -0.02506692f, 0.34484223f, 0.11281648f, -0.09058939f, -0.10668379f, 
    0.02726883f, 0.00310751f, 0.01613052f, 0.14892097f, 0.02408834f, 0.01888416f, -0.01221109f, -0.01463496f, 
    0.49382392f, -0.12592995f, 0.07410219f, -0.03766618f, -0.03046397f, -0.04391159f, 0.07090950f, -0.05119902f, 
    -0.01617497f, 0.08159582f, -0.02959196f, -0.03074694f, -0.07379704f, 0.09305573f, 0.11731569f, 0.07666852f, 
    0.08995238f, 0.05990342f, 0.12308448f, 0.11560984f, 0.08766071f, 0.09799532f, 0.07733169f, 0.04820373f, 
    0.17499568f, 0.18464655f, -0.19514456f, 0.10602207f, -0.00285046f, -0.02788373f, -0.00044954f, 0.00499569f, 
    -0.01506040f, -0.05014573f, 0.03050705f, 0.02821844f, -0.00702935f, -0.12910214f, -0.01051546f, -0.02913301f, 
    0.06608557f, 0.06496531f, -0.09825660f, 0.08021583f, 0.00669375f, -0.01842717f, -0.04162588f, 0.04447258f, 
    -0.01447685f, -0.19521783f, 0.17630230f, -0.06859235f, 0.07630087f, -0.00052755f, -0.03084397f, 0.08405182f, 
    -0.08593323f, -0.05685107f, -0.07752955f, -0.07950944f, -0.33624414f, -0.18628398f, -0.09740684f, -0.01795387f, 
    0.12637210f, -0.02287300f, 0.09592505f, 0.01251559f, 0.01664275f, -0.02448639f, -0.08729953f, 0.02357886f, 
    0.02825047f, -0.01542741f, 0.05779872f, 0.06523050f, 0.02087897f, 0.11126566f, 0.05925530f, 0.07029021f, 
    0.04227529f, 0.15486626f, -0.00009090f, -0.00108934f, -0.20509979f, 0.23081395f, -0.06087087f, 0.12449940f, 
    0.08899909f, -0.01039153f, 0.06780387f, 0.03434410f, 0.01458336f, 0.04300000f, -0.03759370f, -0.00317223f, 
    -0.02055488f, 0.28512630f, 0.16616695f, -0.10302074f, -0.08995335f, 0.08245844f, -0.05754974f, 0.03638981f, 
    0.05783692f, -0.00636875f, 0.03509549f, 0.15656219f, -0.38383999f, 0.08797786f, -0.11597350f, -0.04759714f, 
    0.04674449f, 0.13699237f, -0.01507223f, 0.02318170f, -0.05471786f, 0.10259162f, -0.05816370f, 0.02417189f, 
    -0.30858365f, 0.12271865f, -0.04638482f, 0.21744472f, -0.08387041f, -0.20460448f, -0.03638109f, -0.08596151f, 
    -0.07102838f, -0.04062109f, 0.00473575f, 0.05309494f, 0.33387455f, 0.09066992f, -0.04486492f, -0.04826543f, 
    0.14476031f, 0.04556337f, 0.04308832f, -0.00623264f, 0.02018633f, 0.06421027f, -0.00209933f, 0.03347317f, 
    -0.03367493f, 0.13444619f, -0.00090816f, 0.13939761f, 0.08708373f, 0.03174857f, 0.04952427f, -0.03736493f, 
    -0.12636206f, -0.01771231f, 0.01407919f, 0.03890967f, -0.25885448f, -0.10159139f, 0.07935377f, -0.10585951f, 
    0.08550967f, 0.03189990f, 0.02002751f, 0.07682358f, -0.00202604f, 0.03992185f, -0.02094164f, 0.09525361f, 
    -0.43703672f, -0.01738293f, -0.23324877f, 0.14051992f, 0.07042290f, -0.06410266f, 0.04654698f, 0.09896705f, 
    -0.04721263f, 0.06038948f, 0.04615817f, 0.07499037f, -0.28458691f, 0.28061071f, -0.23879923f, 0.22532524f, 
    0.18007374f, 0.07714219f, 0.03334666f, 0.12688316f, -0.09223004f, 0.04244349f, 0.05011152f, 0.08247270f, 
    -0.25282732f, -0.06163760f, 0.08182032f, 0.02917273f, -0.06705416f, 0.03266372f, -0.08944385f, -0.01568217f, 
    0.06027732f, 0.01506056f, 0.10372540f, -0.10452268f, -0.13742505f, 0.23622712f, -0.14308582f, -0.04006958f, 
    -0.03609693f, 0.04066687f, -0.08852106f, 0.07017837f, 0.11096293f, 0.13425189f, -0.01857548f, 0.02491379f, 
    0.12435354f, 0.16582923f, 0.07865353f, -0.07806528f, 0.11654501f, 0.12214316f, -0.06020633f, -0.12271718f, 
    0.00931965f, -0.01827219f, 0.10962972f, 0.14224093f, 0.03000529f, 0.14733306f, 0.13377477f, 0.25146201f, 
    0.08465723f, 0.06702397f, -0.12588938f, -0.08035969f, 0.08608159f, 0.03987342f, -0.09611048f, 0.00604894f, 
    -0.14947695f, -0.20619446f, 0.08413979f, -0.03277838f, 0.06996688f, 0.06417216f, 0.05797242f, 0.22445893f, 
    0.04078069f, -0.10364459f, 0.04239713f, 0.08780760f, 0.47578332f, -0.08107285f, 0.06178102f, -0.13981749f, 
    0.02435479f, -0.09520604f, -0.05494506f, 0.11582754f, 0.00870149f, -0.02674987f, -0.04450740f, 0.10209152f, 
    -0.13817625f, -0.06713280f, -0.22981796f, -0.03348467f, 0.00649696f, -0.02921006f, 0.06006626f, 0.11450601f, 
    -0.00315826f, 0.01259255f, 0.03858491f, 0.05916031f, 0.10612301f, -0.15841076f, 0.07318809f, 0.13624446f, 
    0.06416227f, -0.07606823f, 0.02192550f, 0.08720492f, -0.10943408f, -0.00306038f, 0.09919054f, 0.15801309f, 
    -0.13129111f, 0.09743708f, 0.16640764f, -0.30889639f, -0.07132933f, 0.04617256f, -0.03437245f, -0.08081938f, 
    -0.02902153f, -0.09097745f, 0.04530217f, 0.01326837f, 0.35285109f, 0.10605694f, 0.12581827f, -0.04694675f, 
    -0.06448932f, 0.02386299f, -0.03623932f, -0.06522983f, 0.07258324f, -0.08170902f, 0.10756606f, -0.09297419f, 
    0.14927925f, -0.00507099f, -0.02274770f, -0.02065661f, -0.03282848f, 0.12535198f, 0.01904441f, -0.09968174f, 
    0.06538172f, -0.11055787f, 0.03948207f, -0.06912214f, 0.25369960f, 0.13262394f, 0.00839200f, 0.24454878f, 
    -0.00126521f, 0.01875931f, 0.02364991f, 0.00283610f, -0.03150695f, 0.16493122f, -0.03698575f, 0.05732067f, 
    0.14264432f, -0.43409517f, -0.11742983f, -0.23096968f, -0.03287226f, 0.12088265f, 0.10421009f, 0.06719252f, 
    0.11175278f, 0.02830407f, -0.12296956f, -0.05361209f, -0.31233498f, 0.09396548f, -0.15687756f, 0.15433808f, 
    0.08547926f, -0.05521855f, 0.00338322f, -0.04734445f, -0.07754686f, 0.03736097f, -0.06936124f, 0.05396986f, 
    -0.00678019f, 0.04507132f, -0.00380397f, 0.03945009f, 0.02474485f, -0.06137607f, -0.00004145f, 0.04964132f, 
    0.01497517f, -0.03803999f, 0.01852736f, 0.02110889f, 0.03162839f, -0.02471378f, -0.01335688f, 0.03008293f, 
    0.01775048f, 0.01261222f, -0.01944228f, 0.02944579f, -0.04344438f, -0.03310548f, 0.03341399f, -0.01688857f, 
    -0.00636110f, -0.02897193f, -0.01490133f, 0.02043595f, -0.03984126f, -0.00981396f, 0.03475600f, -0.03259961f, 
    -0.02474741f, 0.03181633f, -0.01470518f, -0.04187428f, -0.01405479f, 0.00338329f, -0.04413292f, 0.01078508f, 
    -0.04035143f, -0.04870839f, -0.01744453f, -0.01811921f, 0.01843916f, -0.04731115f, -0.00214813f, 0.02613349f, 
    0.00608823f, 0.03516920f, 0.01136319f, -0.01861802f, 0.00658801f, -0.00344149f, -0.04795223f, -0.02281351f, 
    0.02206898f, -0.03132140f, 0.00771871f, -0.01264018f, -0.03073423f, -0.01588801f, -0.03883244f, 0.02243965f, 
    0.02573153f, -0.02307129f, 0.00571399f, 0.02882982f, -0.01603759f, 0.02383735f, 0.02669796f, 0.01271330f, 
    -0.00387522f, -0.06230625f, -0.01355795f, 0.03718275f, 0.04236562f, 0.01149255f, -0.02250423f, 0.03265569f, 
    -0.03786981f, -0.05261834f, -0.05148779f, -0.04060689f, -0.02925308f, 0.03467337f, -0.01057200f, 0.00240794f, 
    0.01458696f, 0.01061544f, 0.00597093f, 0.02301872f, -0.03143856f, -0.00811721f, -0.04198388f, 0.00518530f, 
    0.01769880f, 0.03176831f, 0.02696198f, 0.00234898f, -0.03341968f, -0.02801603f, 0.02090558f, -0.03313215f, 
    -0.03495887f, 0.01990634f, 0.00602427f, -0.05841055f, 0.00416939f, -0.03262844f, -0.02184343f, 0.03932735f, 
    0.01384612f, -0.03202935f, -0.03644569f, 0.02894986f, -0.00885691f, 0.01268541f, -0.00572016f, 0.02822500f, 
    0.03845431f, 0.04088081f, 0.02742707f, 0.05116189f, -0.03587645f, -0.00734940f, 0.01321722f, 0.00068554f, 
    0.01441817f, -0.01315227f, 0.04020734f, -0.00232933f, 0.02155414f, 0.02912530f, 0.01340645f, -0.00442218f, 
    -0.01997261f, 0.04249233f, 0.00702760f, 0.02398952f, -0.01094167f, 0.00931298f, 0.00497144f, 0.01326122f, 
    -0.04455281f, -0.03780573f, 0.04620540f, -0.06572379f, 0.01294984f, -0.01544950f, 0.02756645f, 0.03812316f, 
    -0.00237814f, -0.02068554f, 0.01455521f, -0.05435317f, -0.00746016f, 0.01422001f, -0.04252584f, 0.00135646f, 
    -0.02974718f, -0.05150001f, 0.03734514f, 0.01070906f, 0.03150596f, 0.00949720f, 0.01035776f, -0.02537025f, 
    0.05807687f, 0.03418605f, -0.03836039f, 0.01802659f, -0.03113731f, 0.02108838f, 0.04144323f, -0.02644852f, 
    0.02329613f, 0.01761191f, -0.04760743f, 0.03781042f, 0.01269913f, 0.02807683f, -0.01230715f, 0.02341599f, 
    0.05060488f, -0.02216618f, -0.03401163f, 0.00996133f, -0.02464829f, -0.02948956f, 0.03121018f, 0.05725789f, 
    -0.06031128f, 0.01371231f, -0.01841620f, 0.00170385f, 0.00010701f, 0.02957020f, -0.00938836f, -0.03591460f, 
    0.02009813f, 0.03653567f, -0.04600467f, -0.03407108f, -0.00800058f, -0.03296638f, -0.01013959f, -0.00212914f, 
    0.02778912f, -0.05305927f, -0.05400188f, -0.03953563f, -0.01884233f, -0.04148326f, 0.01608634f, 0.03411106f, 
    -0.01361906f, -0.02841989f, 0.00933609f, 0.02632200f, 0.00262759f, -0.05165530f, 0.02163109f, -0.03299651f, 
    0.00132808f, -0.01976227f, -0.00068671f, 0.04089858f, 0.01391406f, -0.02326320f, -0.04186611f, -0.03600672f, 
    -0.01185623f, 0.03351321f, -0.05124350f, -0.01062726f, -0.00052926f, -0.03661707f, 0.04410167f, -0.00884682f, 
    -0.03999336f, -0.00447352f, -0.01058725f, 0.01742426f, 0.02762903f, -0.05524724f, 0.02453453f, -0.02605469f, 
    -0.00987013f, 0.03846037f, -0.03405356f, -0.03998560f, -0.01590756f, -0.01310659f, -0.03064027f, -0.03619047f, 
    -0.04306669f, 0.01014616f, 0.02341136f, 0.02081734f, -0.01330739f, 0.03781037f, 0.04072380f, -0.01765460f, 
    -0.03630178f, -0.05375536f, -0.05300866f, 0.00411567f, -0.02327396f, 0.03580576f, 0.01232891f, -0.01982129f, 
    -0.03753061f, -0.02747287f, -0.03309391f, 0.05316617f, -0.03964471f, -0.02375308f, 0.03988215f, 0.02064282f, 
    -0.01250829f, -0.00200506f, -0.04660883f, 0.02189386f, -0.02394384f, -0.04579479f, 0.02370898f, -0.03154879f, 
    -0.04610039f, 0.00155170f, 0.01355893f, -0.01142406f, -0.00589709f, -0.01690196f, 0.01041782f, -0.02518753f, 
    -0.02200347f, -0.01718870f, -0.01516474f, -0.02433096f, 0.00737234f, -0.04254596f, 0.00785239f, -0.00066890f, 
    -0.03641212f, -0.02883695f, -0.04540126f, -0.01686794f, -0.00701666f, 0.00901765f, 0.04087071f, -0.05049510f, 
    -0.05483057f, -0.01742105f, 0.01506404f, 0.03211776f, -0.02846298f, 0.01792444f, -0.04813059f, -0.01485331f, 
    0.02368410f, 0.05052298f, -0.01948242f, -0.01789613f, -0.02384504f, -0.05207415f, -0.00042463f, -0.03342899f, 
    -0.05328367f, -0.00068033f, -0.04069964f, 0.03557729f, 0.01324582f, -0.03245979f, 0.01353069f, 0.04871346f, 
    -0.03910593f, -0.04913668f, -0.03819814f, 0.00336888f, -0.04234936f, -0.01692617f, -0.01883331f, 0.01832481f, 
    0.00645813f, 0.02511738f, 0.02222557f, -0.01138741f, 0.00676518f, -0.03368446f, -0.00810202f, -0.02789408f, 
    -0.00679794f, 0.00958317f, -0.02254078f, 0.01601180f, -0.01161824f, 0.00900606f, 0.03712086f, -0.01061860f, 
    -0.04350370f, 0.02775279f, -0.03067448f, -0.00601053f, -0.01110037f, 0.01519310f, 0.02329655f, 0.03879303f, 
    -0.01791303f, -0.01545311f, -0.03228403f, -0.01522345f, -0.05114150f, 0.00573578f, 0.00126148f, 0.03897223f, 
    0.02310054f, 0.00259260f, 0.02815180f, 0.02815590f, 0.01037499f, -0.01308978f, -0.02121404f, 0.01774169f, 
    0.03605441f, 0.03977267f, 0.02048074f, 0.00031686f, -0.04952429f, 0.04259375f, -0.00914528f, 0.00152180f, 
    0.04249666f, -0.05154299f, 0.03014922f, -0.04276177f, -0.02720388f, 0.00369373f, -0.05644679f, -0.04981874f, 
    -0.00431205f, 0.03441799f, -0.01882073f, -0.00542548f, -0.04557440f, -0.00286527f, -0.05430591f, 0.02696557f, 
    0.04480756f, -0.03768727f, 0.03893288f, 0.03579964f, 0.02257138f, -0.00049111f, 0.01642832f, -0.00745560f, 
    -0.02833534f, -0.02572181f, -0.05259849f, -0.01715047f, 0.01908946f, 0.01045344f, -0.02680804f, 0.02458250f, 
    0.00079177f, -0.01875003f, 0.00541299f, 0.03078011f, 0.01343169f, -0.01155358f, -0.00028362f, -0.00113526f, 
    -0.02722545f, -0.00546227f, -0.01594800f, 0.00416592f, -0.01034878f, 0.04342004f, -0.04864066f, 0.03841178f, 
    -0.01396449f, -0.04468673f, 0.02739279f, -0.04142542f, -0.02501900f, 0.02085012f, 0.01662871f, 0.00424015f, 
    -0.02098367f, 0.03169299f, 0.00175072f, -0.03638111f, -0.02662165f, 0.00586621f, -0.00962945f, 0.03625129f, 
    -0.03169852f, 0.00382624f, -0.01630448f, -0.00198688f, 0.00081390f, 0.00328676f, 0.04965435f, 0.02721651f, 
    -0.04752922f, -0.00021793f, 0.00595841f, -0.03533687f, 0.02768957f, 0.01231699f, 0.01727047f, -0.00560816f, 
    0.03208678f, 0.04266759f, -0.03162310f, 0.03393356f, 0.01935375f, -0.02076951f, -0.03174422f, -0.01199376f, 
    -0.02920693f, -0.02601193f, 0.01835337f, -0.04940523f, -0.03388119f, -0.00321787f, 0.00967633f, -0.04466289f, 
    -0.00854804f, -0.01978418f, 0.01959530f, 0.04147958f, 0.02385718f, -0.04437328f, -0.02556965f, -0.04252663f, 
    0.00460964f, -0.01301817f, -0.03986681f, -0.05568943f, -0.02749413f, -0.02742820f, 0.02403963f, -0.05221929f, 
    -0.01891556f, -0.03254419f, -0.00821621f, -0.00451003f, 0.04399632f, 0.02483086f, 0.00282193f, -0.05303966f, 
    -0.04081091f, 0.01626674f, 0.03377539f, 0.02602554f, 0.02864381f, -0.05029966f, 0.01131459f, 0.00374568f, 
    -0.01028153f, 0.01880704f, 0.02481657f, -0.02574921f, -0.04449082f, 0.03758099f, 0.01485652f, -0.02577912f, 
    -0.03946490f, 0.04427352f, 0.03429227f, -0.00024639f, -0.01766954f, 0.02767789f, -0.01914742f, -0.03770524f, 
    -0.03773246f, 0.01490003f, 0.03140385f, 0.01927587f, -0.01104410f, -0.04518385f, -0.04462856f, -0.00770303f, 
    -0.01278990f, -0.04829425f, -0.03483834f, -0.03857264f, 0.00131485f, 0.01653971f, -0.00755052f, -0.03324790f, 
    0.02146919f, -0.04403695f, -0.05398478f, -0.01372311f, 0.00372966f, 0.04479199f, 0.03429215f, 0.03253775f, 
    -0.01093308f, -0.02265667f, 0.04452360f, -0.04365689f, 0.00886405f, 0.02676258f, -0.03714022f, -0.05050821f, 
    -0.03093288f, -0.04934501f, 0.04411009f, -0.01503937f, 0.03529824f, 0.02960896f, -0.02554040f, -0.03061613f, 
    0.02666902f, -0.03708668f, -0.01666250f, 0.00643098f, -0.02701816f, 0.00660625f, -0.02432932f, 0.01505754f, 
    0.02560883f, 0.02629066f, 0.02222366f, -0.04466907f, -0.01029626f, -0.01185470f, -0.04851112f, -0.05131643f, 
    -0.02428485f, -0.02667522f, 0.00464185f, -0.04146030f, -0.01728948f, 0.00976614f, 0.00065250f, -0.01141174f, 
    -0.03830589f, -0.05470578f, 0.02329212f, -0.00065931f, 0.03667806f, 0.02988212f, -0.01461241f, 0.02396011f, 
    -0.02373496f, 0.04318172f, 0.02071009f, -0.01030106f, 0.00163790f, 0.03928979f, -0.01264330f, -0.00979763f, 
    0.04442597f, -0.05482439f, -0.01619995f, -0.04607768f, -0.03630102f, 0.00203327f, -0.00490559f, -0.00895683f, 
    0.03634484f, -0.02226372f, 0.03116658f, -0.00845363f, -0.04721111f, 0.02886975f, -0.02733722f, 0.02455543f, 
    -0.01738262f, 0.04005791f, -0.00331925f, 0.01496587f, -0.00104338f, -0.04262400f, -0.05390795f, 0.01481674f, 
    0.04212653f, -0.01154345f, -0.03855661f, -0.02664128f, -0.05429419f, 0.01653656f, 0.01789883f, 0.00493768f, 
    0.02004820f, 0.01941923f, -0.00843923f, -0.04653206f, 0.00126777f, -0.00427928f, -0.00063724f, -0.01918202f, 
    -0.01028116f, 0.03106578f, -0.01329166f, -0.02526196f, -0.05041235f, 0.01393762f, -0.04464430f, -0.03567534f, 
    0.01026506f, -0.00650249f, 0.01286786f, -0.04021440f, 0.03969296f, -0.01636258f, 0.02340894f, 0.01513519f, 
    0.04227852f, -0.01986625f, -0.00248841f, -0.02985195f, 0.00664848f, -0.00345964f, 0.01012370f, 0.01981816f, 
    -0.03929273f, 0.01849043f, -0.03594350f, 0.03074763f, 0.03619748f, -0.03183893f, 0.00072250f, 0.00983099f, 
    0.02092884f, -0.02138034f, -0.02261018f, 0.00784223f, -0.04915468f, -0.04191899f, 0.04002336f, -0.05577208f, 
    0.01231540f, -0.02693513f, 0.01251499f, 0.00445967f, -0.03787103f, 0.02299120f, 0.01612287f, 0.01410814f, 
    -0.04917755f, -0.05004990f, 0.02532944f, -0.04210439f, -0.03520938f, 0.03488274f, 0.01479662f, 0.00187700f, 
    -0.02548780f, -0.01382956f, -0.05463118f, -0.03710762f, 0.01973702f, -0.02473466f, 0.00211014f, -0.03199135f, 
    -0.02190663f, -0.00622166f, -0.05333125f, 0.02689321f, 0.01588505f, 0.00662818f, -0.02399343f, -0.00056967f, 
    -0.00290315f, 0.03761061f, -0.03926181f, -0.00067589f, -0.01505595f, -0.03924480f, -0.01650538f, 0.02295668f, 
    -0.03947579f, 0.00156369f, -0.02981216f, -0.03483156f, 0.00588644f, -0.00164034f, -0.04174645f, 0.01148744f, 
    -0.01172811f, 0.02213109f, -0.03876447f, -0.02481929f, 0.02835796f, -0.00444587f, 0.00211123f, 0.03324792f, 
    -0.03210831f, -0.05587733f, 0.02876717f, -0.04102100f, -0.05193415f, -0.02519677f, -0.01239338f, -0.04089993f, 
    0.01534465f, -0.04278162f, 0.01228952f, 0.03329662f, 0.03886383f, 0.03235672f, -0.01479477f, 0.00357172f, 
    0.00929373f, -0.02577329f, -0.02414311f, 0.00859802f, -0.00514428f, -0.00688460f, -0.04487731f, 0.00508073f, 
    0.02937533f, 0.00027364f, 0.04732640f, -0.01996201f, -0.02005875f, 0.03007430f, 0.04757632f, 0.03828618f, 
    -0.01200383f, -0.05595689f, 0.00256748f, -0.01238351f, -0.03859728f, 0.01769999f, 0.00208776f, 0.01902297f, 
    0.00422354f, -0.01396439f, 0.02332461f, -0.04882243f, -0.05571336f, 0.01629401f, -0.00185250f, -0.04964124f, 
    -0.03797865f, -0.01712930f, -0.03650803f, -0.03075120f, 0.02428143f, -0.00549785f, -0.02082401f, -0.02580448f, 
    0.03790118f, 0.04124754f, -0.04856551f, -0.01491140f, -0.02648595f, 0.03762676f, -0.02625322f, 0.03904596f, 
    0.04147815f, -0.02177823f, -0.00977394f, 0.01878040f, 0.02347662f, -0.05101062f, 0.00293456f, -0.05376014f, 
    0.02630442f, 0.01925815f, 0.01755974f, 0.00737710f, -0.01424414f, 0.01409865f, 0.03221841f, 0.00328641f, 
    0.02781287f, -0.00841277f, -0.04401956f, -0.04532621f, -0.05458928f, -0.05896366f, 0.01140149f, 0.01818639f, 
    0.01004212f, -0.02340664f, 0.00331706f, -0.03598753f, 0.00541589f, -0.02577919f, 0.03325016f, 0.03432512f, 
    0.04409196f, 0.03763677f, -0.01000424f, 0.01748365f, -0.02779988f, -0.00794473f, 0.02404350f, 0.00506096f, 
    -0.05772825f, 0.02034145f, 0.03518586f, 0.00765930f, -0.02497972f, -0.00513860f, 0.01136166f, 0.03098384f, 
    0.02124386f, -0.00963773f, -0.03501874f, -0.03084031f, -0.03876386f, 0.02082865f, 0.02548839f, 0.02819766f, 
    -0.03381700f, -0.01496419f, -0.01487298f, -0.03934215f, -0.05155914f, -0.04040084f, -0.04520791f, -0.04104312f, 
    0.01798681f, -0.04902034f, 0.03392345f, -0.04103338f, -0.00618823f, 0.03770146f, 0.04328028f, -0.03171313f, 
    0.03141706f, -0.00113509f, 0.02283413f, -0.03255581f, 0.02536591f, -0.02989370f, -0.02732502f, 0.01384494f, 
    0.01517703f, 0.03857707f, 0.03527719f, 0.00956316f, -0.01159819f, -0.05147936f, -0.05464989f, 0.04097947f, 
    -0.01929307f, 0.03250884f, 0.00332585f, 0.04175007f, 0.01941046f, 0.02796927f, -0.03952536f, -0.05430642f, 
    -0.03180156f, -0.03991103f, 0.03965209f, 0.00316569f, -0.04902654f, -0.04931849f, 0.02252890f, 0.00128800f, 
    -0.03419962f, -0.05841105f, 0.03739874f, 0.03315867f, 0.00525211f, -0.00212790f, 0.02693070f, 0.00473539f, 
    -0.04822565f, -0.02483658f, 0.03122335f, 0.03935611f, 0.00153977f, 0.02783409f, 0.02220794f, -0.01104886f, 
    -0.02572401f, 0.00180801f, 0.01965539f, -0.03904716f, -0.01883539f, 0.01632771f, -0.05042043f, 0.01619254f, 
    0.03028814f, -0.00541020f, -0.05314015f, -0.00959886f, 0.03196560f, -0.04688589f, -0.03808226f, 0.03061448f, 
    0.04242489f, 0.01828164f, -0.04740858f, -0.02067577f, -0.05266583f, -0.01218390f, 0.03579524f, -0.05313334f, 
    -0.00136874f, -0.01400438f, 0.03218428f, 0.01750033f, 0.00094523f, -0.05116429f, 0.00348794f, 0.01297738f, 
    -0.00517470f, 0.00128598f, 0.02237159f, -0.00484121f, 0.01518566f, -0.04075674f, 0.00914140f, 0.03062228f, 
    0.01418236f, -0.04588808f, 0.03033946f, -0.04246584f, -0.03173690f, -0.04481180f, -0.00289825f, -0.01718856f, 
    0.00911773f, -0.02424719f, 0.01854269f, 0.03491978f, -0.01509850f, -0.00679448f, 0.03846906f, 0.04163097f, 
    0.04360528f, -0.02477179f, 0.03740925f, 0.01828467f, -0.03677062f, -0.02513505f, 0.01372198f, -0.02753909f, 
    0.01811697f, -0.00298342f, -0.02464927f, 0.03518587f, -0.03197206f, -0.02242025f, -0.05930518f, 0.02312547f, 
    0.04921573f, -0.05703441f, 0.04148496f, -0.04733825f, 0.01968298f, 0.02729018f, -0.02208252f, 0.04730934f, 
    0.01329144f, -0.02061217f, 0.03176300f, -0.04291569f, 0.00109511f, 0.02586701f, -0.02163276f, 0.01439517f, 
    0.00627761f, -0.00943453f, -0.03378041f, 0.02269728f, -0.00566762f, -0.01011212f, -0.05072946f, -0.00259059f, 
    -0.04952414f, 0.03228896f, 0.01210093f, 0.01280185f, 0.00011865f, -0.01083482f, 0.00318766f, 0.00640539f, 
    0.00626011f, -0.03171317f, -0.04204227f, 0.02277797f, 0.01448979f, 0.01697816f, 0.03864613f, 0.02458474f, 
    -0.00711508f, -0.03784759f, -0.02332396f, -0.02045875f, 0.00352343f, 0.01613194f, -0.03058465f, -0.04841677f, 
    -0.04758336f, -0.01096035f, 0.02321853f, -0.00660418f, 0.01966539f, 0.02319618f, -0.02123468f, -0.04170685f, 
    -0.00144828f, 0.01922395f, 0.01179415f, 0.00962959f, -0.03675352f, 0.03308022f, -0.04566792f, 0.03501214f, 
    -0.02864380f, 0.02584035f, -0.01607568f, 0.01382707f, 0.00164845f, -0.00503456f, 0.02140993f, -0.00494669f, 
    0.02075350f, -0.01850760f, -0.02306024f, -0.00651017f, -0.03341430f, 0.00567524f, 0.03516321f, -0.00302649f, 
    0.03585199f, -0.02662802f, -0.03230002f, -0.04169773f, -0.02556638f, -0.00310771f, -0.01795597f, -0.03669226f, 
    -0.01623248f, -0.03466836f, -0.02183094f, 0.02608088f, -0.00739731f, 0.00479483f, -0.01703324f, 0.01496132f, 
    -0.04086257f, 0.03998272f, 0.01990645f, 0.01673069f, -0.05914892f, 0.01118682f, -0.02827890f, 0.03484820f, 
    0.00723799f, -0.04995203f, -0.00921716f, 0.01632179f, 0.02056395f, 0.02213078f, -0.05006694f, -0.04765680f, 
    -0.02202724f, -0.02871828f, 0.00967040f, -0.02511138f, -0.03756796f, 0.04476995f, -0.01171549f, 0.05077439f, 
    -0.01363305f, -0.01552296f, -0.04258684f, 0.00323529f, 0.03007369f, 0.04155841f, 0.00295780f, 0.03556015f, 
    -0.00733021f, -0.03896988f, -0.04543044f, 0.01904991f, -0.04271894f, 0.00403881f, 0.02575512f, 0.03995541f, 
    -0.02816350f, 0.04475443f, 0.01835241f, 0.03019953f, 0.03996333f, -0.03151157f, -0.04792741f, -0.02524997f, 
    0.30701649f, 0.13562167f, 0.34417358f, 0.37712276f, -0.16728185f, -0.16168010f, -0.09014357f, -0.07218418f, 
    0.14232382f, -0.01690765f, -0.02652824f, 0.11737246f, -0.05629229f, 0.20847781f, 0.16037440f, 0.04912397f, 
    0.05754990f, 0.12996030f, -0.05401693f, -0.14777337f, 0.04921302f, -0.04262560f, -0.03758373f, -0.22590300f, 
    0.32890388f, 0.08307058f, -0.04278871f, 0.06796382f, 0.09834263f, 0.00643652f, 0.12747571f, 0.02651484f, 
    -0.05968050f, -0.05464016f, 0.22496486f, 0.04301184f, 0.44548133f, -0.07499108f, 0.10477009f, 0.23563299f, 
    -0.08712813f, -0.08689711f, 0.00405253f, 0.00265248f, -0.09349152f, -0.08513810f, -0.07347611f, -0.03447365f, 
    0.24641435f, 0.12590966f, 0.36970425f, 0.39220056f, -0.23082052f, -0.20090175f, -0.10664283f, -0.00005568f, 
    0.12449042f, 0.06863588f, 0.05704693f, -0.06882551f, -0.18612655f, 0.16473711f, -0.28142336f, -0.11016443f, 
    0.16406219f, 0.16761647f, 0.15869547f, 0.07806921f, 0.09130209f, -0.15324999f, 0.11225930f, -0.02969897f, 
    -0.03635352f, -0.06401747f, -0.23570018f, 0.02125382f, 0.10326323f, 0.02790780f, 0.04876756f, -0.00761491f, 
    -0.01320307f, -0.05511015f, 0.08857084f, -0.04468479f, -0.23191953f, -0.16457511f, 0.08821655f, -0.07266851f, 
    0.12605947f, 0.05791176f, 0.02103508f, -0.03087586f, -0.04489780f, 0.03975984f, -0.00362931f, 0.02070014f, 
    -0.08331215f, -0.04078827f, 0.15169884f, 0.02737281f, 0.07122330f, -0.11711841f, 0.02803021f, 0.02674246f, 
    0.09509919f, -0.03035338f, 0.04868129f, 0.04056171f, 0.33471516f, 0.12020615f, -0.02852045f, 0.10307965f, 
    0.10364017f, 0.05219117f, -0.03480386f, -0.06376733f, 0.09926692f, 0.00361197f, -0.07358792f, -0.10488689f, 
    -0.13348119f, -0.19766881f, -0.10163738f, 0.07028627f, -0.06268024f, -0.01705154f, 0.17511009f, 0.03199676f, 
    -0.01991799f, -0.01517025f, 0.04044423f, -0.05648639f, -0.14538562f, -0.20299074f, -0.04172921f, 0.04843135f, 
    0.05768732f, 0.04271434f, 0.03759624f, -0.10922551f, 0.00242883f, -0.31378210f, -0.00749551f, -0.22582512f, 
    0.08155785f, -0.07686304f, 0.13027403f, -0.29130393f, 0.09643079f, -0.01500524f, -0.05865321f, 0.04320098f, 
    0.02401202f, 0.11385912f, -0.04061069f, 0.05855970f, 0.02708048f, 0.11160801f, 0.15944453f, -0.09745360f, 
    -0.14871666f, -0.05104651f, -0.02545492f, 0.09625060f, 0.06645063f, -0.08757929f, -0.04005355f, 0.03490964f, 
    0.25360754f, 0.39353818f, 0.24403882f, 0.10945377f, -0.09383558f, -0.04527779f, -0.01960019f, -0.08925177f, 
    0.11042432f, 0.11642827f, 0.11431889f, 0.12781531f, -0.08850168f, -0.19099577f, 0.02707854f, 0.11065694f, 
    0.10038874f, 0.09237897f, 0.08048241f, 0.12585853f, -0.11524378f, -0.03005543f, 0.03387033f, 0.06328615f, 
    0.18786630f, 0.06056897f, -0.17074119f, -0.16951290f, -0.06032899f, -0.02039416f, 0.02687782f, -0.15015480f, 
    -0.04543812f, -0.08082920f, -0.01895629f, -0.05115215f, -0.14166318f, -0.05178564f, -0.18784559f, -0.01844100f, 
    0.06635987f, -0.09974191f, -0.09685009f, -0.00435250f, 0.02816791f, -0.06763963f, -0.03975619f, -0.04416440f, 
    0.15041414f, 0.14701381f, 0.21869461f, -0.02095154f, -0.12169528f, 0.03626058f, 0.01195779f, -0.01562687f, 
    -0.07090981f, 0.03513381f, -0.10142078f, 0.07641164f, -0.23820813f, -0.00278251f, -0.19501941f, -0.07562552f, 
    0.06935328f, 0.04172809f, 0.08080479f, -0.08132833f, -0.10205821f, -0.01938432f, 0.03264865f, 0.10573046f, 
    -0.20978546f, 0.28606626f, -0.05480955f, 0.03831599f, -0.06630168f, -0.00808537f, -0.03968162f, 0.02906059f, 
    0.01884290f, 0.09308892f, 0.14438398f, -0.04051610f, 0.20704766f, 0.11041989f, 0.01678315f, 0.27662471f, 
    -0.03662930f, 0.07468909f, 0.12460271f, 0.15444183f, 0.04458392f, 0.08623077f, -0.04000597f, 0.07307000f, 
    -0.27319905f, -0.01756151f, 0.21072762f, -0.16874829f, -0.02635720f, -0.13947962f, -0.00515124f, -0.16294017f, 
    -0.05184180f, -0.04931112f, 0.13657312f, -0.05679321f, -0.26104721f, 0.14763157f, 0.30781817f, 0.17321257f, 
    -0.04051636f, 0.09771721f, 0.02460020f, -0.12938483f, 0.12164502f, 0.02471257f, -0.00062917f, -0.04166553f, 
    -0.12019299f, 0.04364076f, -0.16248043f, -0.03233904f, -0.02623807f, 0.00341806f, -0.01818268f, -0.00906246f, 
    -0.03831574f, 0.07894014f, -0.06504858f, -0.01030556f, -0.08591020f, -0.20683944f, 0.08538903f, -0.07349312f, 
    0.17660192f, -0.07718900f, 0.08800586f, 0.01283688f, 0.15589254f, -0.09992912f, -0.00646693f, 0.01307059f, 
    -0.03912614f, -0.00251891f, -0.03027735f, -0.07371517f, -0.06145130f, -0.04574212f, 0.13712560f, -0.05015431f, 
    0.04170009f, 0.05106866f, -0.10605600f, 0.00907646f, -0.14562026f, 0.23120899f, 0.26924950f, 0.29292408f, 
    -0.15667291f, -0.10233063f, -0.01517535f, -0.08604728f, 0.08437549f, 0.08246719f, -0.08660660f, -0.00039493f, 
    -0.52835733f, 0.00840464f, -0.08646671f, -0.22866116f, 0.07726702f, 0.03327111f, 0.14299144f, 0.01253755f, 
    -0.00789500f, -0.01412542f, -0.02290407f, 0.04775507f, -0.16558713f, 0.01225316f, 0.08774880f, 0.05033809f, 
    -0.05025716f, 0.03855661f, -0.02104761f, -0.10044247f, 0.03260917f, 0.05043535f, -0.12137784f, -0.13733657f, 
    0.20893373f, -0.08173913f, -0.06992403f, -0.01278275f, 0.16145450f, 0.02863280f, -0.07137115f, 0.14970972f, 
    0.00984920f, 0.19949985f, -0.06563040f, 0.11798257f, -0.05803677f, 0.08602619f, 0.03231548f, -0.18100512f, 
    0.12171279f, 0.06601126f, -0.09292117f, 0.13970976f, -0.03662429f, 0.00955065f, -0.00485693f, -0.05870028f, 
    0.00115591f, -0.02260699f, -0.04719009f, -0.02359162f, -0.02326885f, -0.00055839f, -0.00350791f, -0.01969159f, 
    -0.00242444f, -0.03519510f, -0.05312219f, -0.01946593f, 0.00607450f, -0.01850141f, -0.01216106f, 0.02124092f, 
    0.00277252f, -0.01759002f, 0.02404060f, -0.00737656f, -0.01189056f, 0.02807061f, 0.00632704f, 0.04402936f, 
    0.03325084f, 0.02732689f, -0.04144917f, 0.03098144f, -0.03759053f, 0.00061763f, 0.00870090f, -0.03317901f, 
    0.00167124f, -0.02210039f, 0.02671104f, 0.00096964f, -0.02949911f, 0.02994853f, -0.01571005f, -0.04236357f, 
    0.03801592f, 0.03142120f, -0.02299402f, -0.03559183f, -0.02562505f, 0.03614336f, -0.04148082f, 0.02552402f, 
    0.00612564f, 0.01119937f, -0.00302434f, -0.03565217f, -0.05616404f, 0.02310022f, -0.03962473f, 0.04119021f, 
    -0.02954672f, 0.00199084f, -0.01137877f, -0.03625817f, 0.01986842f, -0.04937492f, -0.04308760f, 0.01808125f, 
    0.02023297f, 0.01456154f, -0.00136778f, -0.02526268f, -0.03822034f, -0.03919842f, -0.05641123f, -0.04628868f, 
    0.01931228f, 0.03124619f, -0.05125980f, 0.03174517f, 0.02633409f, -0.00981014f, -0.02770914f, 0.01950625f, 
    -0.02375718f, 0.03818825f, 0.04195218f, -0.02092574f, 0.02751597f, -0.02227578f, -0.02702401f, 0.04163408f, 
    -0.04816361f, 0.03427945f, 0.02476232f, 0.03183743f, -0.04689145f, -0.05419774f, 0.02066060f, -0.01979142f, 
    -0.03923269f, -0.02789120f, 0.00503140f, -0.03046183f, 0.00038868f, 0.01217266f, 0.03882485f, -0.03534402f, 
    -0.00294227f, -0.02686097f, -0.05078250f, 0.00112044f, 0.02529526f, -0.00238396f, -0.00570658f, -0.00278142f, 
    0.00798394f, -0.00116824f, -0.00764544f, 0.03800695f, 0.02303062f, 0.00097940f, -0.01480293f, 0.02367813f, 
    -0.04830423f, 0.02356556f, -0.02003627f, -0.01805462f, 0.00642134f, -0.04576573f, 0.00687128f, -0.01489588f, 
    -0.05842979f, -0.00870426f, 0.01993319f, 0.01150844f, 0.03251230f, 0.03662841f, -0.03932897f, -0.00578112f, 
    -0.03504068f, -0.05600258f, -0.01651073f, -0.00755211f, -0.05233577f, -0.02075479f, 0.03167805f, 0.00499277f, 
    0.03026037f, -0.02833360f, -0.00502585f, -0.00064085f, -0.02463945f, -0.05508839f, 0.01362318f, -0.00889352f, 
    0.03159116f, -0.00287189f, -0.05667244f, -0.00941967f, -0.05297178f, -0.03998902f, -0.00757434f, -0.03208959f, 
    0.03173213f, -0.03239705f, 0.01146000f, 0.02079224f, 0.00035513f, -0.03960108f, 0.00531632f, 0.00559955f, 
    -0.02806089f, -0.01945825f, -0.03764515f, 0.01611578f, -0.02510513f, -0.02680582f, -0.01601132f, -0.00380772f, 
    0.02685135f, 0.01172249f, 0.03274848f, 0.03023844f, -0.03305485f, -0.04257761f, -0.01620192f, 0.00297725f, 
    -0.02301344f, -0.04944399f, 0.02623193f, -0.04512086f, 0.03385081f, -0.01711828f, -0.02483314f, -0.04249929f, 
    0.04275910f, 0.01607978f, 0.01359577f, 0.00177978f, 0.01225016f, -0.03940289f, -0.00598915f, -0.01571173f, 
    -0.05137121f, 0.01097119f, -0.03500151f, -0.01068828f, -0.02954431f, -0.05696108f, -0.05676804f, 0.04138085f, 
    -0.01365109f, 0.01070977f, -0.00277546f, 0.01960515f, -0.01200236f, 0.00796490f, 0.03823756f, -0.03283501f, 
    -0.02987270f, -0.03100341f, -0.02758782f, -0.04553661f, -0.00928300f, 0.04194046f, -0.03242732f, -0.04495335f, 
    -0.03103069f, -0.04208385f, -0.04293445f, 0.00078882f, -0.04206103f, -0.02804272f, 0.01246702f, 0.01021420f, 
    0.03874542f, -0.03928095f, -0.04816287f, -0.02043953f, 0.04106601f, -0.05107613f, 0.03372601f, 0.02712182f, 
    -0.04072900f, 0.01551888f, -0.04394650f, -0.02956483f, 0.04314855f, 0.03447846f, 0.03566262f, -0.04683968f, 
    -0.03061168f, 0.03786862f, 0.01367890f, 0.01114598f, -0.05451282f, -0.00498508f, 0.05508636f, 0.01391708f, 
    -0.00466401f, -0.01711924f, -0.05056705f, 0.01249475f, 0.02099873f, -0.03423532f, -0.04298033f, -0.02647838f, 
    -0.02417132f, 0.03988805f, -0.04690137f, 0.01044495f, 0.00664992f, -0.01753311f, -0.01623493f, -0.02337446f, 
    -0.03428250f, 0.03332195f, 0.00855649f, 0.01007468f, 0.03661562f, 0.02834157f, 0.04154907f, -0.03433783f, 
    -0.03692356f, -0.02181730f, 0.02190506f, -0.01302819f, 0.00359925f, -0.03916262f, 0.04167364f, -0.02515795f, 
    0.01926506f, -0.04614329f, -0.02524311f, -0.01644359f, 0.02432418f, 0.00401316f, 0.00748965f, 0.03996263f, 
    -0.00966635f, 0.00274352f, -0.02754438f, -0.01117633f, -0.05531911f, -0.04420130f, 0.03972735f, -0.02434522f, 
    -0.03453709f, -0.03372126f, -0.01457812f, -0.02910631f, 0.01633854f, 0.03500910f, -0.02172077f, 0.03133780f, 
    -0.05119830f, 0.01473914f, -0.04609396f, -0.05250216f, 0.02755380f, 0.01618456f, -0.03090392f, 0.03731127f, 
    0.03295824f, 0.01045660f, 0.03977467f, 0.00014124f, -0.05255569f, 0.02768635f, 0.03399616f, -0.03380665f, 
    0.04208064f, -0.03072194f, -0.03238272f, -0.03949414f, 0.02850985f, -0.01285129f, -0.02185034f, -0.05502058f, 
    0.04299509f, -0.05734436f, -0.00034671f, -0.01242250f, 0.00432320f, -0.01900749f, 0.00430121f, -0.01481409f, 
    -0.03668639f, 0.02912453f, -0.02965110f, 0.01100560f, -0.04890230f, 0.03562747f, -0.02888637f, 0.01540582f, 
    -0.01458523f, 0.00147354f, 0.03675667f, 0.03798666f, -0.01672613f, -0.00459487f, -0.05117125f, 0.01453614f, 
    0.01014819f, -0.02373954f, -0.01199342f, 0.02851994f, 0.02770982f, 0.04168996f, -0.02359924f, -0.01494415f, 
    -0.00677343f, 0.00154815f, 0.01480713f, -0.05098630f, -0.01933793f, -0.05411689f, -0.01524140f, -0.04737554f, 
    0.04188526f, 0.03298175f, -0.00624372f, 0.00560620f, 0.02327729f, 0.00563709f, 0.01187122f, 0.03677866f, 
    0.22240606f, -0.05982445f, -0.00584408f, 0.49136737f, 0.10632006f, 0.08754767f, 0.08817803f, -0.12119821f, 
    0.05850630f, -0.08331525f, -0.18363246f, -0.04507510f, -0.14469589f, -0.15577894f, 0.04521994f, 0.06878061f, 
    -0.13876593f, 0.17888612f, -0.04622355f, -0.03068030f, -0.18719471f, -0.16639112f, -0.14334588f, -0.37981081f, 
    0.06648260f, -0.01079681f, 0.02293734f, 0.06084044f, 0.18199238f, 0.00750958f, 0.20493248f, 0.17540726f, 
    0.01533975f, 0.16919346f, 0.03587450f, 0.11933430f, 0.40386754f, 0.08534496f, -0.04746054f, 0.15443225f, 
    -0.01110410f, 0.13287905f, -0.08361880f, 0.25260526f, -0.07284380f, -0.01073240f, 0.17752789f, -0.10440894f, 
    0.07671877f, -0.08093600f, -0.02179307f, 0.31347677f, -0.00326863f, -0.10006681f, -0.11985174f, -0.06102360f, 
    0.03080429f, 0.04875606f, -0.11188267f, -0.09244946f, -0.05820106f, 0.23775718f, 0.19107109f, 0.12315708f, 
    0.07408755f, -0.03900053f, 0.08282220f, -0.03101359f, 0.03095012f, -0.03560768f, -0.02632177f, 0.13053384f, 
    0.03019843f, 0.04629228f, 0.06306028f, 0.10641638f, -0.07592882f, -0.04231898f, 0.07612943f, 0.00496037f, 
    0.07374351f, -0.08160557f, 0.02326661f, -0.13321854f, 0.03719594f, 0.02613292f, 0.00031945f, 0.07241032f, 
    0.00617893f, -0.07644241f, -0.14474359f, 0.02241292f, -0.02175486f, -0.06897601f, -0.16552219f, -0.03821857f, 
    -0.05785161f, -0.11306307f, 0.20921482f, 0.22072485f, 0.11535586f, -0.00224746f, 0.17504229f, 0.00401810f, 
    -0.03288347f, -0.02123592f, -0.08973926f, -0.25231284f, 0.03337626f, 0.01393264f, 0.20677504f, 0.18465734f, 
    -0.03047547f, 0.05473692f, 0.10858013f, -0.04740818f, -0.10245269f, -0.19463472f, 0.12313996f, -0.23303819f, 
    -0.14035007f, 0.18126409f, -0.14596686f, -0.14226112f, -0.15210918f, 0.10770909f, 0.05450725f, -0.13439639f, 
    -0.10575302f, 0.14498663f, -0.02042652f, 0.19415876f, -0.19910069f, 0.21932645f, 0.20316474f, 0.00909231f, 
    -0.11421317f, 0.08380764f, 0.10474542f, -0.01119778f, 0.05806926f, -0.25405014f, -0.11770167f, 0.12802196f, 
    0.38051134f, -0.15223692f, 0.22259374f, 0.02025514f, -0.10323786f, -0.03764490f, 0.01606204f, -0.04956812f, 
    -0.03750513f, 0.22590557f, -0.00825364f, 0.17850718f, 0.05599484f, 0.09447697f, -0.27275103f, -0.16064222f, 
    -0.07220981f, 0.03433525f, 0.03039970f, 0.11723729f, 0.08934994f, 0.08081491f, -0.07935774f, 0.08238003f, 
    -0.08753792f, -0.15295030f, 0.07539859f, -0.14866160f, -0.00872121f, -0.06812053f, 0.08261959f, 0.10835534f, 
    0.03821900f, -0.00276650f, 0.25871509f, 0.18895471f, -0.09123521f, -0.16755909f, 0.38308260f, -0.03627883f, 
    -0.13982880f, 0.14597943f, 0.15962933f, 0.23126253f, -0.04223229f, 0.00518231f, 0.18838842f, 0.16773152f, 
    0.45558110f, 0.46573976f, 0.11062419f, -0.05468118f, 0.04783783f, -0.04697474f, -0.04748982f, -0.08087606f, 
    0.02388090f, 0.16442856f, 0.02797976f, 0.02945478f, 0.27742976f, 0.17703368f, 0.17396605f, 0.20906436f, 
    0.02585115f, -0.04807129f, -0.08645182f, 0.02954980f, -0.06504124f, 0.05302918f, 0.05157503f, -0.02377254f, 
    0.44886699f, 0.03227293f, -0.11608392f, 0.11740926f, -0.07789109f, -0.13546222f, 0.16436364f, 0.01902040f, 
    0.03514948f, 0.22841528f, -0.06552379f, 0.09656084f, -0.05052517f, 0.44072273f, 0.05314691f, -0.14325239f, 
    -0.01125724f, -0.02042950f, 0.01267948f, -0.10642768f, -0.14887182f, 0.20672752f, 0.08245852f, 0.13723350f, 
    0.13892637f, 0.09187642f, -0.03426966f, 0.07562425f, 0.08304848f, 0.07927209f, 0.06178876f, -0.03502134f, 
    -0.03304686f, 0.15033051f, 0.26450336f, -0.00586700f, -0.21759230f, -0.21391870f, 0.05177446f, 0.10003899f, 
    -0.14066456f, -0.02402295f, 0.18563171f, 0.07496983f, 0.02511535f, -0.09164672f, -0.10537903f, -0.05570098f, 
    -0.03250172f, 0.00711830f, 0.05762393f, -0.14513372f, 0.05131751f, -0.08734395f, -0.14488715f, 0.02330464f, 
    0.03286786f, -0.20475857f, 0.08849439f, -0.19516236f, 0.06589200f, -0.21977095f, -0.20793310f, 0.06286547f, 
    0.00566144f, 0.06958868f, -0.03920987f, 0.08818289f, -0.04873587f, 0.05944259f, 0.04538700f, -0.07996619f, 
    -0.13011895f, 0.21205485f, -0.00391399f, 0.24347912f, -0.04439868f, -0.12360246f, -0.07138965f, -0.05085548f, 
    0.08068621f, 0.12091763f, 0.05113241f, 0.00490108f, 0.08616319f, 0.05729648f, -0.11286928f, 0.12993111f, 
    -0.00544845f, -0.16271220f, -0.02923345f, -0.10985100f, -0.11220486f, 0.00604068f, 0.01913390f, -0.02635604f, 
    0.35197556f, -0.08700493f, -0.17102376f, 0.00089693f, -0.22399804f, 0.12785245f, 0.08454284f, 0.02422553f, 
    0.05123229f, 0.18110207f, 0.07478809f, 0.09047412f, 0.20626022f, -0.19150831f, -0.19394480f, 0.04732297f, 
    -0.15299058f, 0.02353275f, 0.01198765f, 0.02758184f, 0.09701736f, 0.04979153f, -0.10771034f, -0.09898241f, 
    -0.35020572f, 0.11156081f, 0.32353416f, -0.02725009f, -0.10300006f, -0.08052123f, -0.02924419f, 0.10672870f, 
    -0.15666196f, 0.05492838f, 0.02619600f, -0.06375033f, 0.09860512f, -0.09030697f, -0.05260486f, 0.03914085f, 
    0.01383302f, -0.02013526f, -0.09095577f, -0.04514324f, 0.00411822f, 0.01662666f, -0.14883195f, -0.11247407f, 
    0.50014246f, 0.13087147f, 0.11484796f, -0.15974018f, -0.02426392f, -0.01254223f, -0.10815568f, 0.26175627f, 
    0.04076939f, 0.18135783f, -0.02197164f, -0.08041605f, 0.17188148f, -0.10831936f, 0.17958406f, 0.15891425f, 
    0.06606027f, -0.05846707f, -0.09843601f, -0.01556641f, 0.03851867f, -0.01685807f, 0.17156096f, 0.07742935f, 
    0.03173173f, -0.16052264f, 0.18950540f, 0.28131956f, -0.08719528f, 0.01811240f, -0.10594305f, -0.00007294f, 
    0.00164860f, -0.03898663f, 0.22281337f, 0.03159695f, -0.29533458f, 0.10049853f, 0.13531958f, 0.22639692f, 
    -0.04639982f, 0.04463571f, -0.02179126f, 0.01029508f, 0.21762203f, 0.07789320f, 0.17614757f, 0.06480674f, 
    0.00022257f, 0.30680066f, -0.02914124f, -0.20469104f, -0.10712833f, 0.06902768f, -0.20540829f, 0.03260976f, 
    0.07275001f, -0.06757382f, 0.08642105f, -0.02736578f, 0.17415403f, -0.58814454f, -0.16587783f, -0.00260006f, 
    -0.02843203f, -0.17176075f, -0.00890641f, -0.14499347f, 0.15241520f, 0.08525009f, -0.03204794f, -0.05557414f, 
    -0.13674434f, -0.07025515f, 0.12755114f, 0.11737323f, -0.16631588f, 0.15877987f, 0.03844902f, 0.03377059f, 
    0.06913686f, 0.04726344f, 0.04034797f, -0.00009819f, 0.01565969f, 0.41318902f, -0.26622337f, -0.13073197f, 
    -0.01766759f, -0.09571158f, 0.00451333f, 0.15074301f, 0.05082246f, 0.13831890f, -0.05074190f, -0.09123741f, 
    0.01148361f, -0.08745897f, -0.13826744f, -0.41887274f, 0.01016294f, -0.01898351f, 0.06340739f, 0.03771430f, 
    -0.04659917f, 0.13359815f, 0.08476596f, 0.21747202f, -0.08584595f, -0.11299466f, 0.02477290f, -0.07680776f, 
    0.00674258f, 0.12577842f, 0.26430571f, 0.01226653f, -0.09559238f, 0.11134151f, 0.15960254f, 0.16071595f, 
    0.16770703f, -0.00041904f, 0.12834398f, -0.00121302f, 0.07160190f, -0.06762659f, 0.00809058f, -0.00635342f, 
    0.01123874f, 0.04551070f, 0.13867296f, 0.18781738f, -0.05621514f, -0.02851510f, -0.04171873f, 0.27712724f, 
    -0.05130699f, -0.06055060f, -0.06374949f, 0.09499206f, 0.05249918f, -0.00880591f, -0.03697820f, 0.27237892f, 
    -0.10883267f, -0.29031578f, 0.19756112f, -0.26597807f, 0.00547291f, 0.06258655f, 0.04399910f, 0.08166753f, 
    -0.01768282f, 0.04330146f, 0.00127708f, -0.00085252f, 0.06772947f, 0.04177224f, -0.00656345f, -0.17135493f, 
    0.09995345f, 0.00390752f, 0.01674976f, 0.10188740f, 0.04557673f, 0.15658370f, 0.09437719f, -0.00395240f, 
    0.20062561f, 0.04286130f, 0.00717833f, 0.06176187f, 0.00377163f, 0.00502290f, -0.05140630f, 0.12721933f, 
    -0.00422161f, -0.01324279f, 0.03691263f, -0.07441911f, -0.20113297f, -0.29477778f, 0.02935787f, -0.21306722f, 
    0.00958001f, -0.06312360f, 0.01687630f, -0.08472073f, -0.03012057f, 0.01584683f, 0.14467530f, 0.06305081f, 
    -0.03752439f, 0.05154376f, -0.01913756f, 0.20640199f, -0.14317231f, -0.01378960f, -0.08959867f, -0.16383904f, 
    0.03139837f, 0.06105496f, 0.10141811f, -0.07287416f, 0.25490946f, 0.14521477f, -0.18210800f, -0.10435094f, 
    -0.00713210f, -0.07672999f, -0.03210535f, 0.09467334f, 0.14854354f, 0.00921773f, -0.06789493f, -0.05076989f, 
    0.02546528f, -0.44412184f, 0.02398502f, 0.21249934f, 0.00432287f, 0.09169400f, -0.06865969f, 0.04710881f, 
    0.07745405f, -0.10272440f, -0.06678466f, 0.06500742f, -0.17668004f, -0.11272659f, -0.07087667f, 0.22168420f, 
    -0.07487362f, 0.11896066f, 0.03711781f, 0.03102994f, 0.11566000f, -0.01042457f, -0.07270374f, 0.07401424f, 
    0.00854351f, 0.01433685f, 0.11557367f, 0.01616416f, -0.03903662f, -0.01355455f, -0.05678760f, -0.03668091f, 
    0.10355295f, -0.06783318f, -0.04781527f, -0.05224131f, -0.02468206f, 0.13800329f, -0.00135602f, 0.06662672f, 
    0.04874539f, 0.13109177f, 0.13428473f, -0.01943365f, 0.12749414f, -0.11235420f, -0.00386973f, -0.03833807f, 
    -0.45554423f, 0.19294226f, 0.06825576f, -0.25230360f, -0.07857907f, 0.00185211f, 0.06396755f, 0.04802404f, 
    0.05619619f, 0.07450165f, -0.17729148f, -0.11094774f, -0.05721692f, 0.23425443f, -0.07326400f, 0.01856722f, 
    0.04679403f, -0.07806597f, -0.12131076f, 0.06784461f, 0.10693751f, 0.20096913f, 0.12275609f, 0.05075332f, 
    0.22579363f, 0.07770413f, 0.25319359f, -0.09586533f, 0.08709672f, 0.09685057f, 0.09396731f, -0.00947283f, 
    0.14257248f, 0.08140970f, -0.16948152f, 0.05532800f, -0.14970902f, -0.08943931f, 0.25327018f, 0.25959420f, 
    0.08546413f, 0.00278919f, -0.08580708f, -0.07521078f, 0.12569183f, -0.06165943f, -0.05298402f, 0.07817121f, 
    0.12914240f, -0.08290310f, 0.00088580f, 0.02958434f, -0.02220312f, 0.06498986f, 0.13719045f, -0.01885658f, 
    -0.05220503f, 0.04347929f, 0.02060081f, 0.03295784f, -0.09613552f, -0.10602127f, 0.38743585f, -0.24052523f, 
    0.10580090f, 0.15227684f, 0.12064993f, 0.13800685f, 0.11368669f, -0.03753825f, -0.04977350f, 0.05828800f, 
    -0.17318054f, 0.10331567f, -0.02591176f, -0.27556628f, 0.04067264f, 0.01394159f, 0.05662518f, 0.01063291f, 
    -0.08864030f, -0.03951038f, 0.01337823f, 0.00803825f, -0.33716860f, 0.11943150f, -0.03234834f, 0.17519933f, 
    -0.06983886f, -0.09853458f, 0.02034464f, -0.04353654f, -0.02679236f, -0.01113413f, 0.12680542f, 0.06127764f, 
    -0.15101291f, 0.17779943f, 0.02035407f, -0.08385035f, 0.01652385f, -0.04386972f, 0.02276810f, 0.01251822f, 
    0.16402589f, 0.01305882f, -0.02007446f, 0.02177755f, -0.47292697f, 0.01881907f, -0.25921232f, 0.10756187f, 
    -0.10247432f, 0.08170011f, -0.06138109f, 0.02001152f, 0.01716080f, 0.09035050f, 0.10926636f, 0.04195577f, 
    -0.19587007f, 0.03183799f, -0.05337147f, 0.11953369f, 0.08686379f, 0.02279990f, -0.01790120f, 0.05459310f, 
    0.05295761f, -0.25365722f, -0.03943977f, -0.08070165f, -0.04384149f, 0.11408743f, -0.00640636f, 0.08392931f, 
    -0.05552053f, -0.12879066f, -0.06268220f, 0.03493045f, 0.00041147f, 0.00783607f, 0.00109446f, -0.02586517f, 
    0.02056234f, 0.02609006f, -0.02555965f, 0.03408842f, 0.01025487f, 0.01584110f, 0.00205024f, 0.00354958f, 
    -0.04471483f, -0.01345100f, -0.01331033f, -0.02143646f, -0.00505038f, 0.01180358f, 0.00093188f, -0.02555960f, 
    -0.00598535f, 0.03941943f, -0.00429034f, 0.00393232f, -0.03927478f, -0.00718485f, 0.04388420f, 0.00316391f, 
    0.04011743f, 0.02328189f, -0.04715193f, 0.01776700f, -0.05414950f, -0.02799702f, 0.02124310f, -0.00880768f, 
    0.04171740f, 0.03208552f, -0.02187008f, -0.05523687f, 0.04221282f, 0.00066010f, -0.01359051f, 0.02387343f, 
    -0.01699874f, 0.02056235f, 0.04313479f, -0.05268425f, 0.02526813f, -0.03036981f, -0.03003252f, 0.03615970f, 
    -0.01013696f, 0.01353607f, 0.02219521f, 0.03159011f, -0.03966379f, 0.03371956f, -0.00792704f, -0.04185666f, 
    0.02147273f, -0.01884880f, 0.01661120f, 0.04010571f, -0.05193453f, -0.05318815f, -0.00360890f, -0.01496573f, 
    -0.00117148f, -0.00208644f, 0.04009125f, 0.01712547f, 0.00689529f, -0.00875739f, 0.01047453f, 0.04220297f, 
    -0.05001908f, 0.03392577f, 0.03075100f, -0.04492434f, -0.03866784f, 0.03485692f, 0.01798560f, 0.00630411f, 
    0.02702555f, 0.00017921f, 0.00760632f, -0.03063003f, -0.04936166f, -0.04172359f, -0.00268834f, -0.01810003f, 
    -0.04510223f, 0.03029863f, 0.02368825f, 0.02745931f, -0.03958164f, -0.04949245f, -0.01477726f, 0.01331499f, 
    -0.01494475f, -0.00199535f, -0.03029644f, -0.02267455f, 0.02037571f, 0.03784664f, -0.02831203f, -0.02515997f, 
    -0.01166665f, 0.03669653f, 0.03783393f, -0.01398801f, -0.02766183f, -0.04478699f, -0.04121519f, 0.02468795f, 
    0.00273355f, -0.00505226f, -0.01401744f, 0.00885412f, 0.00995281f, -0.03240808f, 0.04626235f, -0.02791731f, 
    0.03963750f, 0.03478042f, -0.05020827f, 0.05084366f, 0.01402515f, 0.02230915f, -0.04887190f, -0.00426143f, 
    0.03031696f, -0.01899426f, 0.00607894f, 0.00854548f, -0.04834334f, -0.03227983f, 0.01043859f, -0.05313594f, 
    -0.04964979f, -0.05246732f, 0.00229435f, 0.03818458f, 0.03042555f, -0.01431683f, 0.03561787f, 0.02128401f, 
    0.04915030f, 0.04805283f, 0.01662314f, -0.01198720f, -0.02511084f, -0.01636313f, 0.00484951f, -0.05191626f, 
    -0.01211325f, -0.01141044f, 0.00301026f, -0.01123944f, 0.01113539f, -0.03309025f, -0.04038559f, -0.01511122f, 
    -0.04646116f, 0.01160984f, 0.02483312f, -0.02336313f, -0.01649350f, -0.01110609f, 0.01202334f, 0.01117804f, 
    0.01728257f, 0.01823212f, -0.01281227f, -0.05153868f, 0.04493281f, -0.01638693f, -0.00004668f, -0.04396619f, 
    -0.01833041f, -0.05522441f, -0.02193414f, 0.00817324f, 0.01748106f, -0.05366845f, 0.00148548f, -0.00158452f, 
    0.01000996f, -0.02899670f, -0.03291958f, -0.02725972f, -0.04657087f, -0.03106151f, 0.00769141f, -0.02092208f, 
    -0.02585627f, 0.03173189f, 0.02142910f, -0.02920625f, -0.00181539f, -0.02478843f, -0.00942106f, 0.00415057f, 
    -0.04670174f, -0.01321327f, -0.05637525f, 0.01370913f, -0.01804199f, 0.03275692f, 0.00080922f, -0.04587937f, 
    -0.05215720f, 0.02557646f, -0.02146357f, -0.01556493f, 0.00794350f, -0.04592108f, -0.05031592f, -0.05548890f, 
    0.00717750f, -0.02546833f, 0.02682762f, -0.04117313f, -0.03821595f, -0.02526765f, 0.01257476f, 0.01828468f, 
    -0.02776306f, -0.04027844f, -0.00484672f, -0.03968074f, -0.02974888f, 0.01668301f, -0.01709600f, -0.02915869f, 
    -0.00299812f, 0.01787391f, 0.01516197f, 0.00102643f, 0.02257530f, 0.04128446f, 0.02561816f, 0.02768530f, 
    -0.03546322f, -0.03545116f, 0.00635367f, 0.02731793f, -0.00661289f, -0.00232002f, 0.00118000f, 0.03240624f, 
    0.02629721f, 0.01536656f, -0.02447857f, 0.00176338f, 0.03001996f, 0.03008711f, 0.02293142f, 0.00279272f, 
    0.01845074f, -0.02483700f, 0.02702315f, -0.04988041f, -0.03097443f, -0.02401448f, -0.03375100f, -0.01298833f, 
    -0.02474123f, -0.02926219f, -0.03835917f, 0.00674007f, 0.00894489f, 0.04174159f, -0.02408277f, 0.03052963f, 
    0.04605209f, -0.03715493f, -0.02770636f, 0.02628166f, -0.01359287f, 0.00726770f, -0.00109782f, -0.03051238f, 
    -0.01828876f, -0.04370436f, -0.00039412f, -0.04751068f, -0.01479708f, -0.03005750f, 0.02660739f, -0.04876037f, 
    0.03114595f, 0.02282610f, 0.03238155f, -0.01960040f, 0.03499376f, -0.01233185f, -0.04847123f, 0.03216219f, 
    -0.00805382f, 0.02636034f, -0.05433156f, -0.01878733f, -0.00949781f, 0.04050329f, 0.02999862f, 0.00494350f, 
    0.04056895f, 0.03545552f, -0.02968230f, -0.03383767f, -0.00680000f, 0.03457236f, -0.03616131f, -0.03439717f, 
    -0.04939481f, -0.02483048f, -0.03815353f, 0.00096410f, -0.05591351f, 0.00198349f, -0.00565214f, -0.01960476f, 
    0.02136436f, -0.03508924f, 0.03992077f, 0.03397423f, -0.03389062f, 0.01052551f, 0.03852810f, -0.00244050f, 
    0.02174084f, -0.04307371f, -0.03958309f, -0.03797675f, 0.03495174f, -0.01776148f, -0.00176262f, -0.00960542f, 
    -0.05288716f, 0.02848519f, -0.03299426f, -0.03829515f, -0.05359959f, -0.03735090f, -0.04701533f, 0.02532151f, 
    0.01171607f, 0.01295937f, -0.04919852f, 0.03715487f, 0.00937141f, -0.03154373f, 0.02227989f, 0.00347635f, 
    -0.01601281f, -0.02225718f, 0.02572768f, 0.03663258f, -0.03960479f, -0.02438871f, -0.02155662f, 0.00502973f, 
    0.04061113f, -0.00060454f, 0.02716867f, 0.02860564f, -0.01118424f, 0.00444204f, -0.04471954f, 0.02933646f, 
    -0.01735358f, -0.01256455f, -0.04438799f, 0.00844612f, -0.01123217f, -0.05449154f, -0.00164598f, -0.00410104f, 
    0.04374344f, -0.00871136f, -0.05176834f, 0.02099364f, 0.01487502f, 0.00408398f, -0.02073209f, 0.03100344f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00234829f, -0.02247403f, 0.11398025f, 0.02776055f, -0.06132891f, 0.00860185f, -0.03188700f, 0.11179297f, 
    0.01309682f, -0.05031796f, -0.08560029f, 0.00063825f, -0.05831384f, -0.04307172f, 0.07392235f, -0.00599255f, 
    -0.01458272f, 0.02679370f, -0.02845095f, 0.01405634f, 0.02514778f, 0.11375228f, 0.05832618f, 0.02977717f, 
    -0.00711941f, -0.02630510f, 0.03431057f, -0.07029776f, -0.00236193f, -0.05260864f, 0.08020064f, 0.04316575f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.20442013f, 0.16566102f, 0.17952760f, 0.00046087f, 0.39751375f, 0.22494520f, -0.01271863f, -0.14436485f, 
    0.09072162f, 0.04802854f, -0.04615815f, 0.12878715f, -0.16671215f, -0.29667631f, -0.16749784f, 0.10781749f, 
    0.15473957f, -0.14681286f, 0.42655826f, -0.02177749f, 0.12458692f, 0.23973797f, -0.22588010f, 0.02385143f, 
    0.16590245f, -0.15802109f, -0.12614183f, 0.31461310f, -0.12972948f, -0.14786753f, 0.29770267f, 0.06325943f, 
    0.59503651f, 0.04744780f, 0.17637046f, 0.38345903f, 0.03084942f, -0.04752083f, 0.16525950f, 0.26719180f, 
    0.04379091f, 0.03927838f, -0.24751236f, -0.01038002f, -0.15237534f, 0.28796855f, -0.12810737f, -0.00942022f, 
    -0.04181043f, 0.11189387f, -0.09266773f, 0.10724723f, -0.14608732f, 0.18705669f, -0.24844864f, -0.47671455f, 
    -0.08093341f, -0.03823825f, 0.07926369f, -0.14767307f, 0.06170627f, 0.12316778f, 0.49683321f, -0.13910380f, 
    -0.05376253f, 0.06741062f, 0.01948127f, -0.14707127f, 0.08254746f, 0.07248019f, -0.05267794f, -0.11554673f, 
    -0.08378024f, 0.10829631f, -0.04629526f, 0.08344015f, -0.15873539f, -0.16389102f, -0.04894134f, -0.09111252f, 
    0.00780581f, -0.16536145f, 0.06525952f, -0.06238160f, 0.15053245f, -0.06827545f, -0.16595715f, -0.01694357f, 
    -0.16978711f, 0.12642516f, -0.02794325f, 0.02550860f, -0.00037141f, 0.08473191f, -0.16645049f, 0.00164943f, 
    -0.45247743f, -0.10283397f, -0.03459653f, -0.12674950f, -0.19362333f, 0.09479454f, -0.02862319f, -0.03045065f, 
    0.05651186f, 0.05032280f, 0.16534257f, -0.15506051f, -0.06352198f, 0.10582622f, 0.28878829f, -0.14899789f, 
    0.06529590f, -0.01571517f, -0.29312113f, -0.03121276f, -0.03607060f, 0.27521417f, 0.14120984f, 0.19852962f, 
    -0.00347839f, -0.05894572f, 0.14634062f, 0.25158763f, 0.17208794f, 0.22004911f, -0.64258659f, 0.08650602f, 
    0.26109487f, -0.14362676f, 0.13307104f, -0.21625806f, -0.31900769f, 0.02088471f, 0.12015485f, 0.20826095f, 
    -0.00988719f, -0.29764527f, -0.01297339f, -0.14579241f, 0.15833558f, 0.27183285f, 0.18081437f, 0.16045457f, 
    -0.18211828f, -0.16451631f, -0.41665801f, 0.11243682f, -0.08571411f, -0.04539817f, -0.37492806f, -0.24085823f, 
    -0.11594556f, 0.00811913f, 0.14071193f, 0.25566354f, -0.05238055f, -0.04978266f, 0.06404749f, 0.12902498f, 
    -0.08430685f, 0.06479189f, -0.03483164f, 0.06426806f, -0.03684244f, -0.08878046f, 0.03608216f, -0.11495546f, 
    -0.14753892f, -0.10231510f, 0.06919431f, 0.01735876f, 0.04632996f, 0.06868973f, -0.17131537f, -0.01921030f, 
    -0.12091224f, -0.08183550f, 0.08256857f, 0.01911823f, 0.09431397f, -0.11609679f, -0.04378965f, 0.09789883f, 
    -0.00864922f, 0.01845112f, 0.14055961f, 0.15315174f, 0.16086298f, 0.11902074f, -0.15604219f, 0.03075740f, 
    -0.00300533f, -0.03065943f, 0.05352476f, 0.08118758f, -0.01796600f, -0.15632127f, -0.00543595f, -0.05390350f, 
    0.00117954f, -0.11897871f, -0.01617180f, -0.04655470f, -0.07930376f, 0.03152762f, -0.05622050f, -0.06513523f, 
    0.03006572f, 0.02228563f, 0.00421370f, 0.09419006f, 0.06318489f, -0.14710899f, 0.05194326f, -0.11242458f, 
    -0.12276967f, -0.16298960f, -0.16184178f, 0.05916269f, -0.07218010f, -0.17311068f, 0.02672049f, 0.12423322f, 
    -0.04105206f, -0.14885396f, -0.02640113f, 0.04475815f, -0.02031843f, -0.04614062f, -0.02478966f, -0.15743679f, 
    0.13358437f, 0.12958926f, -0.11014088f, 0.05096252f, 0.10962752f, -0.09639336f, 0.09496299f, 0.07407897f, 
    0.16933693f, 0.05002614f, -0.03575802f, -0.13065957f, -0.04043316f, -0.04059517f, -0.03804079f, -0.08322770f, 
    0.01940351f, -0.03160832f, -0.13985436f, -0.00637290f, 0.09885783f, 0.08388589f, -0.07847787f, 0.17264169f, 
    0.01076731f, 0.11345702f, -0.04437973f, -0.12277969f, -0.00202150f, 0.14271058f, 0.14650847f, 0.02393769f, 
    0.10285534f, 0.04447008f, -0.11410197f, 0.05706023f, -0.09492529f, -0.03028700f, -0.05425818f, 0.00031176f, 
    -0.04686629f, 0.07313785f, -0.15615439f, -0.13560539f, -0.17303102f, 0.00531545f, 0.06551202f, 0.01377779f, 
    0.01533833f, -0.12200809f, 0.13270970f, -0.16519670f, 0.11661783f, -0.06293570f, 0.06884859f, 0.13728587f, 
    -0.08355454f, 0.06511033f, 0.11042323f, -0.10417161f, 0.68170774f, -0.15540211f, 0.15486179f, 0.11098121f, 
    0.02181659f, -0.24307774f, 0.08383040f, -0.08471847f, -0.12629089f, -0.20314507f, 0.05553126f, -0.10697837f, 
    -0.15966710f, 0.14270519f, 0.40553916f, 0.13866752f, -0.07585973f, -0.27330425f, -0.34982809f, 0.14187430f, 
    -0.15181729f, -0.08543228f, -0.01195243f, 0.75552285f, -0.00979538f, 0.33547071f, 0.18119931f, 0.06959885f, 
    -0.33226830f, 0.12362754f, 0.03053411f, -0.09449679f, 0.06787526f, 0.37482247f, 0.14344957f, 0.10689276f, 
    -0.14012679f, -0.15109998f, -0.20779945f, 0.04227095f, 0.15826315f, -0.37368366f, 0.36505607f, 0.11598412f, 
    -0.04038328f, -0.02706026f, 0.25025055f, -0.20747770f, 0.10491728f, 0.38735655f, 0.33470035f, 0.09815940f, 
    0.13203751f, -0.13617834f, -0.11061923f, -0.25807124f, 0.05090028f, -0.06137775f, -0.33814830f, -0.04753779f, 
    0.20100810f, -0.11392707f, 0.23636279f, -0.06325097f, 0.28571391f, -0.07665122f, -0.07778165f, -0.22493078f, 
    -0.02599197f, 0.36114889f, 0.37908074f, -0.14876467f, 0.13527335f, 0.41155708f, 0.03632486f, -0.03926475f, 
    -0.02018874f, -0.09046000f, -0.12802790f, 0.32906535f, -0.04048977f, 0.24919283f, -0.17186056f, 0.34582949f, 
    0.14296812f, 0.12195042f, 0.08242595f, 0.05556900f, -0.13175422f, -0.38435721f, 0.27615023f, -0.10885640f, 
    0.08242499f, 0.02372889f, 0.20358722f, -0.08514310f, -0.58040267f, 0.10511444f, -0.01859461f, -0.12052271f, 
    0.07613683f, -0.03498217f, -0.00963319f, 0.02193764f, -0.03935235f, 0.30742905f, 0.18608081f, 0.06491154f, 
    -0.01544922f, 0.08450308f, -0.32630464f, 0.05434944f, -0.00291583f, -0.11460423f, 0.13425297f, -0.13748333f, 
    0.01381603f, 0.13159226f, -0.08598059f, 0.10736156f, -0.13524655f, 0.40519691f, -0.11643709f, -0.03687821f, 
    -0.16618766f, -0.09104132f, -0.14908029f, -0.17271580f, 0.28608319f, -0.03885093f, 0.06414412f, 0.35874584f, 
    -0.18052031f, -0.32831529f, 0.17222431f, -0.01749310f, 0.17978114f, -0.34244576f, 0.21439409f, -0.02305737f, 
    0.04479295f, -0.05175744f, 0.53867006f, -0.23765236f, 0.15574689f, -0.04866488f, 0.09598038f, 0.14336389f, 
    0.00110918f, 0.03617395f, -0.15781327f, 0.00053035f, -0.11694473f, 0.18930812f, 0.36220047f, 0.03946370f, 
    0.02530715f, 0.09174342f, 0.30271792f, -0.13737287f, -0.43396440f, 0.04541361f, -0.07282750f, 0.24689591f, 
    -0.03034190f, -0.19468187f, -0.07056892f, 0.09529293f, -0.06599704f, 0.02016127f, 0.20655054f, -0.12814085f, 
    0.09962819f, 0.15394765f, -0.20582327f, -0.15357256f, 0.01782165f, 0.03372884f, 0.42334643f, -0.03692277f, 
    0.01806889f, -0.01059266f, -0.06228321f, -0.34430093f, -0.09314253f, 0.05183650f, 0.11881278f, 0.15618815f, 
    0.04389148f, 0.01888883f, -0.09372198f, 0.11635642f, 0.08831078f, 0.16625237f, 0.06877147f, -0.17145632f, 
    -0.15935381f, 0.21090648f, 0.04338752f, -0.09008587f, 0.15927827f, 0.37508053f, 0.11687618f, 0.06511153f, 
    -0.11905307f, -0.17060807f, -0.25688949f, 0.24470581f, -0.16797286f, -0.22916123f, 0.12345315f, 0.36591622f, 
    0.13173351f, 0.00797280f, 0.16543122f, -0.00840519f, 0.15945061f, 0.50976378f, -0.36711991f, 0.09615742f, 
    0.04191025f, -0.04911267f, -0.23793957f, 0.03327374f, 0.18152657f, 0.23041125f, -0.05578339f, 0.05387515f, 
    -0.16280465f, 0.51150692f, -0.18375230f, 0.00860272f, 0.11685477f, 0.27787802f, 0.05712071f, 0.16127530f, 
    -0.06266677f, 0.05046454f, -0.43616721f, 0.31144601f, 0.01217803f, 0.16472799f, -0.34225902f, -0.26068053f, 
    0.03651298f, -0.12723395f, 0.10533499f, 0.33082342f, -0.06973691f, 0.30361813f, -0.37611267f, 0.13485225f, 
    0.19287819f, 0.10409001f, -0.04148687f, 0.15214944f, 0.05453744f, 0.51710951f, 0.00929759f, -0.11011588f, 
    -0.14368054f, 0.43961769f, -0.18863027f, -0.10074211f, -0.02058692f, -0.16651863f, -0.27409184f, -0.05707430f, 
    -0.08646686f, 0.13499050f, 0.40864658f, -0.13627622f, 0.13339691f, -0.00645406f, 0.24032640f, 0.09088141f, 
    -0.09364172f, 0.15034895f, -0.03385502f, 0.17326456f, 0.11949081f, 0.32797816f, 0.27339146f, 0.03068991f, 
    0.24893843f, -0.18053766f, 0.09327266f, -0.10772643f, -0.30634415f, 0.19819760f, 0.01023360f, 0.03430023f, 
    -0.06997639f, -0.07027137f, -0.25158316f, -0.05137943f, 0.05067388f, 0.05448526f, 0.24217530f, -0.00226809f, 
    -0.15309519f, 0.01728544f, 0.15106286f, 0.11904269f, -0.15568303f, 0.37138394f, -0.07489340f, -0.43038929f, 
    -0.02582853f, -0.14249884f, 0.07793447f, -0.15894340f, -0.12328945f, -0.34646097f, -0.03547819f, -0.08584140f, 
    0.10741442f, -0.11620773f, 0.31997105f, 0.06051131f, -0.21917793f, -0.30298170f, -0.10600132f, 0.25634998f, 
    0.01507873f, -0.15674019f, 0.16515218f, -0.07363199f, 0.10173528f, -0.07567470f, 0.08665994f, -0.06214153f, 
    -0.09782285f, 0.09714124f, 0.31362122f, -0.44809449f, -0.06620486f, -0.09082148f, 0.13052347f, -0.60045427f, 
    -0.02944187f, -0.15400267f, -0.15416966f, -0.12503432f, 0.08120469f, 0.27737245f, -0.00216636f, 0.15308742f, 
    -0.08293468f, 0.01514554f, 0.27426574f, -0.09487907f, -0.17549984f, 0.01884064f, 0.04766771f, -0.08672313f, 
    -0.16145310f, -0.02160243f, 0.21869934f, 0.01907485f, -0.13174057f, -0.29797307f, 0.15365194f, -0.03784025f, 
    0.00310621f, 0.15251346f, 0.31386682f, 0.04659997f, -0.00789078f, 0.18897705f, -0.03604708f, 0.07121588f, 
    0.05530530f, 0.16291681f, -0.08819160f, 0.41977975f, -0.09745479f, -0.44946453f, 0.14370231f, -0.11009477f, 
    -0.05955665f, -0.12539975f, -0.17207114f, -0.01435474f, 0.00606780f, 0.09248523f, -0.01289786f, -0.10437594f, 
    -0.16057892f, -0.00127141f, 0.00676630f, 0.08205452f, -0.07204647f, 0.04457124f, -0.14875083f, 0.17639063f, 
    0.11089250f, 0.14525768f, 0.01134715f, 0.04938808f, -0.01336856f, 0.01382425f, -0.16728760f, -0.15131813f, 
    -0.09695442f, -0.13862914f, 0.12208833f, 0.08754819f, 0.10221747f, 0.05523720f, -0.06409350f, -0.10276762f, 
    -0.45417967f, 0.00656932f, 0.27782285f, 0.04148806f, 0.13597789f, 0.10665239f, 0.12499940f, 0.09875467f, 
    -0.03758065f, -0.43608207f, -0.28715017f, -0.09452862f, 0.05346158f, -0.33827639f, 0.09429391f, 0.04561485f, 
    0.00630501f, 0.03612708f, 0.17223249f, -0.04373418f, 0.08476809f, 0.18305410f, 0.44075221f, 0.28059617f, 
    -0.01672044f, -0.14248542f, 0.06127859f, -0.04153412f, -0.05083770f, 0.13665035f, -0.07894754f, 0.01588145f, 
    -0.00494883f, -0.11980762f, 0.31060657f, -0.07712380f, 0.13582931f, -0.34194154f, 0.17286170f, -0.03955135f, 
    -0.00190783f, 0.28121918f, 0.18468270f, -0.12700664f, -0.00542868f, 0.13011368f, -0.02692076f, 0.10107594f, 
    0.15030028f, -0.07158652f, 0.32666340f, -0.34509492f, -0.09635156f, 0.17845261f, 0.13409932f, -0.35126999f, 
    0.02831430f, -0.11497233f, 0.11176103f, -0.25501990f, -0.08528966f, 0.33161211f, 0.00133138f, 0.01067914f, 
    -0.13909650f, 0.11654449f, 0.19533913f, -0.48103350f, 0.06003966f, 0.17028922f, 0.15642783f, -0.30678549f, 
    0.13885655f, -0.05797010f, 0.49498096f, 0.03249214f, -0.09392875f, 0.09564782f, 0.19556448f, 0.02618040f, 
    -0.06582668f, 0.11679915f, 0.54309964f, -0.08247938f, -0.01355844f, 0.09894811f, 0.08038981f, 0.12041008f, 
    0.06677622f, 0.10941941f, -0.11334217f, 0.29195699f, -0.09993842f, -0.21642619f, 0.12292280f, -0.11523192f, 
    -0.16087577f, -0.04571513f, 0.26304618f, -0.21872051f, -0.25970319f, -0.39917827f, -0.08473965f, 0.12330034f, 
    -0.01215215f, 0.08178129f, -0.26897243f, -0.17388310f, -0.14121903f, 0.17276724f, 0.15686531f, 0.15292366f, 
    -0.06170646f, 0.05507160f, -0.05417289f, 0.05876442f, 0.15527973f, -0.12757048f, 0.21570119f, -0.11600674f, 
    -0.00405673f, -0.00051520f, 0.00241444f, 0.28160125f, -0.08086748f, 0.48817506f, -0.10601661f, -0.00383923f, 
    0.11672653f, -0.15059808f, 0.00683323f, 0.09184740f, -0.35867187f, 0.16123581f, 0.14244477f, -0.20681424f, 
    -0.10480215f, -0.05413470f, 0.59830135f, 0.09413131f, 0.10223230f, 0.56639677f, 0.16007231f, 0.15966821f, 
    -0.15393680f, -0.12003750f, -0.02067094f, 0.02694445f, -0.06295821f, -0.15792370f, -0.06619639f, 0.39815155f, 
    -0.00697783f, -0.11275955f, -0.11382788f, 0.00288120f, -0.04421435f, -0.00516048f, 0.03841945f, 0.02571267f, 
    0.04966504f, 0.00876570f, 0.15158370f, 0.41182980f, -0.08732888f, -0.32827401f, 0.08943141f, 0.29398695f, 
    -0.03010268f, -0.26877707f, -0.54715627f, -0.14716576f, -0.04540922f, -0.20618132f, 0.21060061f, -0.02242460f, 
    0.01961311f, -0.13576585f, -0.40909678f, 0.07302236f, 0.15130980f, 0.27708331f, 0.08983880f, -0.04463951f, 
    0.09017697f, 0.10894943f, -0.17632017f, -0.15102607f, -0.01953651f, 0.02498225f, 0.27050295f, -0.07061494f, 
    0.27768841f, -0.15616031f, -0.10736589f, 0.45761079f, 0.09509009f, 0.54404992f, 0.01156763f, 0.17724107f, 
    -0.13904677f, -0.07831386f, -0.27462095f, -0.11039419f, 0.15799420f, -0.31779727f, -0.03102791f, 0.16672672f, 
    -0.02389064f, 0.10767069f, -0.05784597f, 0.24980663f, -0.14068516f, 0.13486190f, -0.09724922f, 0.10128197f, 
    0.13675404f, 0.07639997f, 0.00611230f, 0.12650289f, 0.06338711f, -0.33072969f, 0.10554488f, -0.00473269f, 
    0.04549950f, 0.01111205f, 0.12468836f, 0.15776543f, 0.38512385f, 0.29569983f, 0.13839875f, -0.22814071f, 
    0.11831824f, 0.53970498f, -0.14756362f, 0.08273806f, -0.00965371f, 0.16443366f, -0.15730375f, -0.17430826f, 
    0.13388576f, 0.13389093f, -0.02809730f, 0.34574693f, 0.03336337f, 0.19791764f, 0.03965165f, -0.21383879f, 
    -0.17234387f, -0.16695368f, -0.04783455f, 0.14094882f, 0.09951333f, 0.08340968f, 0.46374756f, 0.03734809f, 
    0.27154443f, -0.07601190f, -0.12356150f, 0.35851547f, 0.30897692f, 0.03194596f, -0.12189133f, 0.00063997f, 
    -0.14560048f, 0.03159210f, 0.63795000f, -0.03949376f, -0.04750966f, 0.13853617f, 0.10395215f, 0.08476162f, 
    -0.08715580f, 0.05857579f, 0.26896796f, -0.06769408f, 0.04793923f, -0.27857819f, 0.14488350f, 0.47352260f, 
    -0.01506765f, 0.08457021f, 0.01419917f, -0.24109870f, 0.16805363f, -0.11634009f, -0.11431699f, -0.14719401f, 
    -0.04154434f, -0.10269091f, -0.01074762f, 0.17639287f, 0.35191399f, 0.16306792f, -0.16989218f, 0.25486070f, 
    -0.06139616f, -0.31749022f, 0.27508536f, -0.15108252f, 0.11714000f, -0.27847615f, 0.20759861f, 0.15162860f, 
    0.03390829f, -0.14611109f, 0.36366424f, 0.11491954f, 0.09041339f, -0.36301008f, -0.13050491f, 0.30968237f, 
    0.00524016f, -0.08053474f, 0.01473010f, -0.05897339f, 0.17692026f, -0.08751009f, 0.35139969f, -0.13429442f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.07950949f, 0.12433033f, 0.06589879f, -0.00543800f, -0.07460030f, 0.13311869f, -0.06809729f, 0.04780684f, 
    -0.15541559f, -0.12825637f, 0.23339367f, 0.09296133f, 0.07463558f, 0.16398206f, 0.21951027f, 0.06988852f, 
    0.15209109f, 0.03306135f, 0.17131467f, 0.03528268f, 0.12333233f, -0.16007681f, 0.17587386f, 0.15188515f, 
    -0.08567753f, -0.08893258f, 0.21208099f, 0.11042061f, 0.11991499f, 0.18017712f, 0.07663142f, 0.10763253f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.12664971f, -0.20706660f, 0.06351101f, -0.28465578f, -0.65351540f, 0.01111835f, 0.12734811f, -0.03892722f, 
    0.09761515f, 0.27877888f, -0.18081637f, -0.00324418f, -0.17945655f, 0.33708611f, -0.13412458f, 0.14814584f, 
    -0.25641420f, 0.42474738f, -0.49204633f, -0.63260150f, 0.01627936f, -0.13118048f, 0.10830303f, 0.12712398f, 
    0.26923975f, -0.07677720f, 0.20302661f, -0.50996041f, -0.11909212f, 0.15176199f, 0.14873672f, 0.17628893f, 
    0.37392381f, 0.20577128f, 0.07001002f, -0.36847842f, -0.10212041f, 0.15932591f, 0.03920546f, 0.02166142f, 
    0.15674685f, 0.13561709f, -0.42758048f, 0.26326022f, -0.19833098f, -0.38265795f, -0.33351496f, -0.11413472f, 
    0.13451868f, 0.24937786f, -0.08563413f, 0.27704161f, 0.17538317f, -0.02717921f, -0.30437633f, 0.18111332f, 
    -0.08541917f, -0.26464728f, 0.12842304f, -0.06640945f, 0.21248832f, 0.27601084f, 0.12664312f, -0.18196993f, 
    -0.16417207f, 0.23998666f, 0.14331749f, -0.11111729f, 0.53349054f, -0.12705369f, -0.03112126f, -0.03205557f, 
    -0.11361213f, 0.08729019f, -0.67030680f, -0.01512703f, 0.35706314f, -0.37135375f, 0.12077953f, 0.32114848f, 
    0.27971843f, -0.07486223f, -0.12214729f, -0.27948147f, -0.21752143f, -0.15369341f, -0.72565693f, -0.18379186f, 
    -0.02403015f, 0.05809426f, 0.37358439f, -0.36884001f, -0.26919115f, 0.00533312f, 0.10235188f, -0.00758335f, 
    -0.17049044f, 0.34116572f, 0.10431095f, -0.33814606f, -0.19671802f, -0.18142799f, -0.07585735f, 0.07419851f, 
    0.04694333f, -0.21452962f, -0.02885412f, -0.19281092f, -0.00519860f, 0.00801046f, 0.32362524f, -0.01820896f, 
    -0.34828421f, 0.32106498f, -0.11111332f, 0.16174433f, -0.19844103f, 0.16013055f, 0.21211331f, 0.39576921f, 
    -0.26781505f, 0.22548303f, -0.62566513f, 0.15180843f, -0.48198342f, 0.25405988f, -0.53248936f, -0.27565685f, 
    0.11685415f, -0.28456652f, -0.07618049f, 0.20632696f, 0.27911013f, 0.14966400f, 0.11202903f, 0.08768803f, 
    -0.04176755f, 0.43652630f, -0.03855842f, -0.04412955f, 0.12120812f, 0.00995444f, 0.11847299f, -0.16339111f, 
    -0.19832978f, -0.50379932f, -0.05064679f, -0.09026494f, 0.29588529f, -0.18244144f, 0.28375626f, -0.05937934f, 
    0.02138319f, 0.34335661f, -0.03553434f, 0.21636225f, -0.24625653f, -0.20794953f, -0.40684429f, -0.00437496f, 
    0.35005704f, -0.07046968f, 0.16043596f, -0.10879363f, -0.03690877f, -0.06089773f, -0.12371860f, 0.14683157f, 
    0.08947020f, -0.06806799f, 0.39167264f, -0.07515779f, -0.24648173f, 0.07885491f, 0.12134933f, -0.23818749f, 
    -0.14207870f, 0.17773862f, 0.25254562f, -0.26251528f, 0.25377071f, -0.04817338f, 0.14237404f, -0.31114683f, 
    0.20375368f, -0.55981183f, -0.33745426f, -0.06584162f, 0.20283280f, 0.16130845f, -0.28539327f, 0.10123991f, 
    -0.17180645f, -0.17746845f, -0.00520441f, 0.35204837f, 0.03477948f, 0.14624703f, -0.03509628f, 0.06598681f, 
    -0.10123625f, -0.34960571f, 0.09015475f, 0.04763124f, 0.22468127f, -0.55432725f, -0.01097603f, 0.12951848f, 
    0.52324688f, -0.01051957f, 0.18468116f, -0.46826899f, 0.17877637f, 0.07035164f, -0.21190956f, 0.15020604f, 
    0.05782017f, 0.13989013f, 0.08807791f, -0.15865876f, -0.13067581f, 0.23230863f, -0.55865282f, -0.39516872f, 
    -0.06461917f, -0.17224842f, 0.11309972f, -0.00813203f, -0.11784501f, -0.14950159f, 0.12459111f, 0.08180191f, 
    -0.16963851f, 0.05528658f, 0.20846432f, -0.46307096f, -0.09894913f, 0.33336315f, 0.12569876f, -0.29488152f, 
    0.06113655f, -0.10500119f, 0.19040070f, 0.38729781f, 0.14676061f, -0.06040860f, -0.08753039f, 0.27296916f, 
    0.15261382f, 0.05668334f, -0.13558359f, -0.23700197f, -0.41079858f, -0.59342754f, 0.28415230f, -0.02594697f, 
    -0.08927691f, 0.12557286f, -0.17043622f, 0.03699977f, -0.07896135f, -0.03345110f, 0.00129179f, -0.12371520f, 
    0.09172462f, 0.33280197f, -0.17867059f, 0.09200398f, -0.45918226f, 0.25378954f, -0.43362865f, 0.25108260f, 
    0.39187980f, -0.35374308f, -0.36185047f, -0.29095110f, -0.49063683f, -0.03547123f, -0.21122013f, -0.22540751f, 
    -0.66548353f, -0.23592976f, -0.34294403f, 0.12986694f, 0.19104493f, 0.09651067f, 0.32957488f, 0.26987934f, 
    -0.42657119f, -0.55476582f, 0.06502016f, 0.28220978f, -0.30241889f, -0.11785350f, -0.00128934f, -0.06424759f, 
    0.13229196f, -0.44302267f, 0.17785016f, 0.30616811f, -0.11982939f, -0.05773650f, 0.23727861f, 0.13959093f, 
    -0.48673913f, -0.50410581f, -0.18179056f, -0.52453864f, 0.11183072f, 0.01084387f, 0.17748527f, 0.04489044f, 
    0.27428529f, -0.18301427f, 0.43628225f, -0.19682619f, -0.34865755f, -0.05650183f, 0.37628067f, -0.03946571f, 
    -0.29932368f, 0.34886685f, 0.11180120f, -0.76528889f, 0.41124940f, 0.03000715f, -0.15821770f, -0.14180559f, 
    -0.16816491f, -0.62558722f, -0.19393726f, 0.07792574f, 0.03923923f, 0.02647136f, 0.28579602f, -0.35779941f, 
    -0.35312477f, -0.43974042f, 0.33404487f, -0.02594158f, 0.15301470f, -0.12550578f, -0.19925590f, -0.05453058f, 
    -0.30129555f, -0.12676886f, 0.28769311f, 0.31935048f, 0.11468027f, -0.03179767f, -0.02625877f, 0.10738324f, 
    -0.49216181f, -0.06494732f, 0.09947489f, 0.21468601f, -0.41503918f, 0.14567035f, -0.14043663f, -0.15487264f, 
    0.06984124f, -0.42907116f, 0.20430978f, -0.30908993f, 0.13094784f, -0.21918228f, 0.24435395f, 0.30467233f, 
    0.03067615f, 0.41899002f, -0.14334385f, -0.36147141f, -0.28722206f, 0.00161370f, 0.34393191f, -0.20162129f, 
    -0.58661532f, 0.00024678f, 0.09217344f, 0.16775379f, 0.32035771f, -0.10093057f, 0.07221162f, -0.10049966f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.01968979f, 0.07455242f, -0.08833457f, -0.02749540f, 0.07762405f, -0.05220060f, 0.07771203f, -0.18248576f, 
    0.08856867f, 0.20032744f, 0.27501452f, 0.05474235f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
