#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.48353884f, -0.15242653f, -0.31883937f, -0.42607975f, -0.10325859f, 0.31890285f, 0.06447759f, 0.18130983f, 
    0.26734364f, -0.12616636f, 0.09491801f, 0.00128361f, 0.16888776f, -0.12333459f, 0.08108563f, 0.22295576f, 
    0.19143589f, -0.06454221f, -0.27777305f, -0.17611818f, -0.13850272f, -0.06939553f, -0.14190893f, -0.09413478f, 
    -0.24427152f, 0.49711397f, 0.35316202f, 0.61363465f, 0.18417241f, 0.09014151f, -0.51379716f, -0.04411604f, 
    0.06611443f, 0.18356031f, 0.15808614f, 0.20641649f, -0.11035866f, -0.18386751f, 0.16100124f, -0.07748917f, 
    0.05430408f, 0.07107832f, 0.00945662f, -0.11399926f, -0.04848783f, 0.02872602f, -0.00165840f, -0.29468265f, 
    0.22774184f, 0.07316044f, 0.44483089f, 0.32633445f, 0.29230914f, -0.08257881f, -0.10544489f, -0.35481364f, 
    0.33221024f, -0.17169513f, -0.36837688f, 0.00755549f, 0.11914977f, 0.15277298f, 0.16103847f, -0.07557411f, 
    -0.01306376f, -0.09315473f, -0.20097432f, -0.13595994f, -0.09345882f, 0.38878033f, -0.25540465f, 0.49671736f, 
    0.19309095f, -0.00996878f, -0.08163720f, 0.33920237f, -0.29013413f, 0.14057815f, 0.41952240f, -0.42992565f, 
    -0.40216401f, -0.06200359f, 0.37526092f, 0.05201324f, 0.23073068f, -0.14900583f, 0.17361201f, -0.11445339f, 
    -0.53630215f, 0.44619828f, -0.21770790f, 0.20290837f, 0.00158185f, 0.04456506f, 0.01546316f, 0.27804694f, 
    -0.16836312f, -0.00355388f, -0.16378811f, -0.28659329f, 0.07199926f, -0.63444507f, -0.37805286f, 0.10626040f, 
    0.24041145f, 0.29431379f, 0.27532539f, -0.42165357f, -0.34294808f, -0.15160200f, 0.42306793f, 0.36866054f, 
    -0.04024802f, -0.13548021f, -0.36057216f, 0.25086695f, 0.26250058f, 0.35757652f, 0.21213809f, 0.05157004f, 
    0.10823371f, -0.19217010f, -0.14815463f, -0.31933516f, -0.41619506f, 0.16990782f, 0.44198990f, 0.43713608f, 
    0.07421036f, -0.43176323f, -0.43502152f, -0.30237877f, 0.17054540f, 0.28043905f, 0.03275771f, -0.01659001f, 
    -0.13567176f, 0.56971169f, -0.31280494f, -0.01804282f, 0.12876922f, 0.16874947f, -0.32160088f, 0.00256524f, 
    -0.21915658f, -0.21075682f, 0.14729236f, 0.12104744f, -0.02596084f, 0.11626596f, 0.32882747f, -0.63115394f, 
    -0.45801461f, 0.21254365f, -0.19781806f, 0.19999531f, -0.05614173f, -0.47274461f, -0.16725956f, 0.27672744f, 
    -0.30445153f, -0.23823279f, -0.00100577f, 0.39411604f, -0.10950533f, -0.16620223f, 0.11882567f, -0.18727669f, 
    -0.17022370f, -0.11499450f, -0.16391909f, -0.14342602f, -0.23965435f, 0.06880921f, -0.33735368f, 0.02681346f, 
    -0.17581460f, -0.12191496f, 0.27434108f, -0.21877062f, 0.30600312f, -0.18434659f, -0.12692201f, 0.09156765f, 
    -0.39036748f, 0.30095494f, -0.50620413f, 0.39735529f, -0.53211594f, 0.53836149f, -0.25987995f, -0.22998683f, 
    0.08362966f, 0.09739351f, 0.11784555f, -0.06113930f, 0.17978114f, 0.15153162f, -0.35674241f, 0.07900029f, 
    0.56603813f, 1.10688972f, 0.43998730f, -0.08946613f, -0.35588327f, -0.61581898f, -0.50070572f, -0.23167281f, 
    -0.22790101f, -0.47928390f, 0.00278966f, -0.29255435f, -0.20684732f, -0.08193994f, -0.24912304f, 0.03351753f, 
    0.00004212f, 0.11177581f, 0.08924408f, 0.13138650f, -0.07484367f, 0.14847642f, -0.13936502f, 0.24196534f, 
    0.08918699f, -0.56199855f, -0.11601245f, 0.17064147f, 0.30859584f, 0.03289105f, -0.63858110f, -0.56315953f, 
    -0.18950154f, -0.27241141f, 0.11479791f, 0.34215581f, 0.57610232f, -0.51951116f, -0.02330753f, 0.14292867f, 
    0.11456483f, 0.03315271f, -0.28891429f, -0.29192531f, -0.50782895f, -0.23742637f, 0.31965333f, 0.11081777f, 
    -0.10283069f, 0.34067637f, -0.89901429f, -0.46324548f, -0.55021942f, -0.26084530f, 0.47085431f, 0.07099105f, 
    -0.20171750f, 0.16288717f, 0.34980378f, 0.44026577f, 0.09641518f, -0.13754959f, -0.23903765f, -0.15221442f, 
    -0.01416476f, 0.12082877f, -0.30741191f, -0.01758087f, -0.24467915f, -0.45405743f, -0.22640042f, 0.08348900f, 
    0.20335081f, -0.00177072f, 0.09069766f, -0.81093252f, 0.71990407f, 0.34655720f, -0.12816025f, 0.13776603f, 
    -0.36923230f, 0.21586943f, 0.28653628f, 0.09541927f, 0.05825063f, -0.31232199f, -0.10899559f, -0.33186990f, 
    0.29175431f, 0.33743426f, 0.24632804f, 0.24442048f, -0.28278005f, -0.01754288f, -0.26341820f, -0.09388198f, 
    0.11250599f, -0.12215282f, -0.27984396f, 0.13409036f, -0.12567374f, -0.01111826f, -0.09877308f, 0.34003335f, 
    0.09517256f, 0.06016864f, 0.21375260f, -0.06087193f, 0.16688274f, 0.41825521f, 0.06403311f, -0.12182308f, 
    0.04861100f, 0.23782571f, -0.10807861f, -0.52500725f, 0.25618395f, 0.20308885f, -0.29452261f, -0.37533912f, 
    0.08504770f, 0.16246027f, 0.29222292f, -0.00458994f, 0.30637839f, -0.16116743f, 0.10995763f, -0.45393822f, 
    -0.38514841f, 0.20660536f, -0.40225700f, -0.31161222f, -0.01017430f, -0.48325789f, 0.22435197f, -0.15898135f, 
    -0.02859800f, 0.15413225f, 0.17992322f, -0.18369417f, 0.11832563f, 0.02996752f, -0.09344607f, -0.03955286f, 
    -0.25121164f, 0.13983881f, 0.38922682f, 0.05853328f, 0.13347927f, 0.24739861f, 0.29978451f, 0.25076640f, 
    -0.22982378f, -0.68934387f, -0.08067841f, -0.22325726f, 0.14134081f, 0.30106598f, 0.03613661f, 0.07062776f, 
    -0.14590649f, 0.20262465f, -0.08469393f, -0.21217637f, -0.05390514f, -0.16201234f, -0.04092363f, -0.23372556f, 
    -0.13568985f, 0.19356865f, 0.09510521f, -0.18179898f, -0.40376657f, -0.38734540f, -0.39056781f, -0.13706802f, 
    0.22689317f, -0.05148220f, 0.07541054f, 0.07349981f, 0.36372486f, 0.29147261f, 0.14957218f, 0.23676503f, 
    -0.18404306f, -0.21043442f, 0.59574044f, 0.15125906f, -0.22404265f, -0.32037586f, -0.34437564f, 0.10004376f, 
    -0.25324786f, -0.30890849f, 0.45301676f, -0.00350054f, 0.18331821f, -0.14348966f, -0.11339631f, 0.23370744f, 
    0.98164636f, -1.19353127f, -0.57270980f, -0.13247319f, -0.44772500f, 0.62596798f, 0.01286106f, 0.53570813f, 
    0.20297647f, 0.00876381f, 0.56630915f, 0.06272039f, -0.14761825f, -0.30060109f, 0.02511337f, 0.15351862f, 
    -0.28419238f, 0.28545839f, -0.07920403f, -0.20295174f, -0.20084952f, -0.12135636f, 0.24511571f, -0.06458002f, 
    -0.00824410f, -0.11070742f, 0.73461920f, 0.70475608f, -0.94434428f, -0.11462560f, 0.01854793f, -0.14722008f, 
    0.16658264f, -0.28068385f, -0.33462900f, 0.03152538f, 0.02767132f, -0.04734387f, 0.24746895f, -0.22150029f, 
    -0.12737599f, -0.16351613f, -0.03784584f, -0.06395289f, -0.03275749f, 0.27298036f, -0.15517510f, -0.26423821f, 
    -0.34028304f, -0.50868583f, -0.82653284f, -0.63111466f, -0.12181025f, 0.20913680f, 0.48414281f, -0.07659604f, 
    -0.42004868f, -0.56049013f, -0.13140005f, 0.07759882f, -0.24026535f, -0.24026679f, -0.22431043f, -0.26632607f, 
    -0.18259180f, -0.18258837f, -0.20619054f, -0.22965892f, 0.11528309f, 0.15199569f, 0.18446448f, -0.29943511f, 
    -0.40770787f, -0.10478105f, 0.16167563f, 0.65664506f, -0.71899873f, -0.20417279f, 0.31310982f, 0.37857819f, 
    -0.16783428f, -0.06853747f, 0.20106819f, 0.07737204f, -0.42072409f, 0.13302614f, 0.00704820f, -0.02752251f, 
    -0.24284521f, 0.37819096f, -0.09219361f, 0.01471771f, -0.11353064f, 0.09567761f, 0.26062620f, -0.19296661f, 
    -0.12807903f, 0.06426428f, 0.01866239f, -0.27075535f, 0.66056716f, 0.62839359f, 0.22565497f, -0.14060752f, 
    0.11988433f, 0.21340162f, -0.56215709f, -0.32743198f, -0.18880416f, -0.18975894f, -0.04877346f, 0.03448642f, 
    -0.04091346f, 0.16628018f, 0.21664226f, 0.15781201f, 0.08086744f, 0.28473347f, -0.11995792f, 0.08667055f, 
    -0.04410620f, 0.22794434f, 0.02326261f, 0.13090082f, -0.18783137f, -0.64885563f, 0.15357730f, -0.00131091f, 
    0.22573511f, 0.11227816f, 0.48777258f, -0.78966081f, -0.54550791f, -0.17031389f, 0.69232565f, -0.15040529f, 
    0.01067687f, 0.03509551f, 0.39924335f, 0.16303730f, -0.03264260f, -0.05197576f, -0.20587310f, 0.12014089f, 
    0.03362519f, -0.14653413f, 0.33650473f, -0.01982081f, -0.00368033f, -0.10968815f, 0.44367656f, 0.14511892f, 
    0.19918218f, 0.29034507f, -0.04226602f, 0.26955628f, -0.05880293f, -0.08175035f, 0.03453735f, 0.24735184f, 
    -0.09254912f, 0.26623034f, -0.21496560f, -0.38269386f, -0.17196000f, -0.17412709f, 0.29658484f, 0.06548562f, 
    -0.05258369f, -0.04719106f, -0.32278308f, -0.22761400f, -0.09984782f, -0.53480577f, -0.55754751f, -0.21569699f, 
    0.01214306f, -0.57614034f, -0.47135213f, -0.15379375f, 0.20415366f, 0.23274921f, 0.07407852f, -0.15569022f, 
    -0.36526215f, 0.11410090f, 0.23638695f, -0.14369267f, -0.04947615f, -0.24338469f, 0.03897914f, -0.14273909f, 
    0.08148823f, -0.36952242f, -0.23917745f, 0.15411645f, 0.17957456f, 0.13895379f, 0.32911441f, 0.45334983f, 
    0.53770888f, -0.27769431f, -0.82885355f, -0.48421979f, -0.56943679f, -0.00706972f, 0.57846552f, 0.83889425f, 
    0.07578748f, -0.21737827f, -0.49807510f, -0.02932331f, -0.40636024f, -0.02220898f, -0.29788721f, -0.22233044f, 
    0.18157673f, 0.26675883f, -0.04784877f, 0.22029071f, 0.05201375f, -0.16959228f, -0.09154882f, 0.12492143f, 
    0.13117523f, -0.73075223f, -0.60940665f, -0.53854018f, 0.57623458f, 0.45021772f, -0.28207272f, 0.68229115f, 
    0.02620840f, -0.05258022f, -0.37115934f, -0.12861475f, 0.19964764f, -0.14929353f, 0.43800932f, -0.20250718f, 
    0.05385714f, 0.07421418f, -0.09130319f, 0.14396191f, 0.15087017f, -0.06451944f, -0.03850972f, 0.13378201f, 
    0.03838455f, 0.10174765f, 0.47771177f, 0.14296085f, 0.28805783f, 0.05500528f, 0.35526633f, 0.12664084f, 
    -0.26016381f, -0.09943122f, -0.14650530f, 0.50259775f, 0.21209061f, -0.05658051f, -0.12770939f, 0.03345194f, 
    0.17919663f, -0.09731065f, -0.26960427f, -0.26233763f, 0.28744993f, -0.19346493f, -0.14330696f, -0.08524390f, 
    -0.01125551f, 0.15853719f, 0.13835138f, -0.64207250f, -0.14533803f, 0.03959714f, -0.39186305f, -0.24451552f, 
    -0.26102594f, -0.25426731f, -0.40385222f, -0.32274690f, 0.02456930f, 0.25366685f, 0.22268999f, -0.06923193f, 
    -0.28968790f, -0.07336589f, 0.12875748f, 0.32587898f, 0.26299033f, 0.25698090f, -0.01616798f, 0.15467565f, 
    0.05941833f, -0.16587554f, -0.19983017f, -0.03733671f, 0.83455843f, -0.35840768f, -0.33339462f, 0.27943167f, 
    0.51358342f, -0.56977361f, 0.12522358f, 0.16097069f, -0.31418982f, -0.21877261f, -0.32964218f, 0.11974493f, 
    0.14857349f, 0.04713828f, 0.09496570f, 0.02552714f, -0.15829551f, 0.15701047f, 0.03130839f, -0.32151154f, 
    0.17951605f, -0.02682189f, 0.20862968f, 0.27982304f, -0.14815025f, -0.06190740f, 0.07576913f, 0.18071049f, 
    -0.13191780f, 0.38722122f, 0.31790277f, 0.06544483f, -0.22815646f, 0.18597582f, 0.31703413f, 0.07219692f, 
    0.07727093f, -0.10389417f, -0.01604085f, 0.13045335f, -0.33677450f, 0.05344270f, -0.07087688f, -0.06777208f, 
    -0.12878726f, 0.12515539f, 0.30307531f, 0.16332570f, -0.29610544f, 0.10643494f, 0.53567892f, 0.24851009f, 
    -0.16974936f, -0.03971916f, -0.01544028f, -0.43571651f, -0.34339342f, -0.20145519f, -0.52922213f, -0.61356938f, 
    0.06918719f, 0.40962347f, 0.35418758f, -0.07836713f, -0.34872061f, -0.27657253f, 0.14257543f, 0.02501576f, 
    -0.25660306f, 0.16631661f, -0.18381560f, -0.14493187f, -0.28265095f, -0.21127087f, -0.26916248f, -0.78894883f, 
    -0.49122760f, -0.69040859f, -0.36904508f, -0.32340610f, 0.18938062f, 0.10258940f, 0.57161850f, 0.58714962f, 
    0.30803660f, -0.03299564f, 0.17177711f, 0.18260625f, 0.09418972f, -0.03414644f, 0.08028074f, -0.09862998f, 
    0.20699804f, 0.34567076f, -0.07822511f, 0.17496933f, -0.27874577f, 0.37792337f, -0.16744588f, -0.25786775f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22088362f, 0.04059362f, 0.00200445f, 0.04990420f, 0.04922055f, 0.33224219f, 0.15803131f, 0.16071042f, 
    0.10000261f, 0.35689753f, -0.19159399f, 0.22682856f, -0.12547825f, -0.02264387f, -0.01632695f, 0.31725705f, 
    0.09948194f, -0.16566516f, -0.00148050f, 0.15044776f, 0.12251395f, 0.09531847f, 0.03328850f, 0.09620848f, 
    0.02032059f, 0.22676505f, 0.15555806f, -0.09664160f, 0.10789280f, 0.05193899f, 0.11987223f, 0.02608131f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01471079f, 0.00351812f, 0.01799652f, 0.01463891f, 0.02086087f, -0.04961670f, 0.03189342f, -0.03437136f, 
    0.04553064f, -0.02378364f, -0.01061236f, -0.02823493f, -0.04253890f, -0.00894516f, 0.02812517f, -0.00946952f, 
    -0.00324285f, -0.03772743f, -0.02287998f, -0.04502893f, 0.00934511f, 0.01702687f, -0.04092955f, -0.01894766f, 
    -0.02477198f, -0.01563339f, -0.00983984f, 0.01471288f, 0.00636397f, -0.02848210f, -0.00686166f, -0.03052727f, 
    0.03475922f, 0.00781373f, -0.00655240f, 0.03562693f, 0.03850533f, 0.01664270f, -0.01437837f, -0.04609231f, 
    -0.04198967f, -0.03815183f, -0.01161301f, -0.05346602f, -0.03931114f, -0.02550210f, -0.04977735f, -0.02141649f, 
    -0.03426275f, -0.01894789f, -0.04847368f, 0.02985470f, -0.03906764f, 0.01295064f, 0.01662626f, 0.02584046f, 
    -0.01221785f, -0.05259859f, -0.04353594f, -0.02210775f, -0.00234071f, 0.02786184f, 0.00820708f, 0.00669479f, 
    -0.05151447f, -0.04963113f, -0.01630768f, -0.04750461f, -0.02271131f, -0.02885034f, -0.01625717f, 0.00963128f, 
    -0.04477733f, 0.02365441f, -0.02937201f, -0.01681101f, 0.02196600f, 0.01128611f, -0.00501333f, -0.03834412f, 
    -0.00160551f, -0.01234201f, -0.05330736f, 0.01010975f, -0.03867625f, 0.03527903f, -0.04811481f, -0.04633069f, 
    -0.01097745f, 0.02044495f, -0.03489704f, -0.03510522f, -0.03332073f, -0.00768633f, 0.02167544f, -0.00028515f, 
    -0.00200225f, 0.00356730f, -0.03046091f, -0.00589908f, 0.04481346f, -0.02448865f, -0.02904848f, -0.01949262f, 
    -0.01273087f, 0.01539914f, -0.05297299f, -0.01690339f, 0.01976218f, -0.03016075f, -0.05023530f, 0.02527197f, 
    -0.04203253f, 0.02369585f, -0.03550100f, 0.02562921f, 0.02274385f, 0.00788091f, -0.05187031f, -0.00162840f, 
    -0.03029862f, -0.04961886f, 0.03290694f, -0.02907283f, 0.03788407f, -0.04243008f, -0.02144428f, -0.02636510f, 
    -0.02210707f, -0.04908651f, 0.00686577f, -0.00410654f, -0.01695807f, -0.03234496f, -0.02613524f, 0.03204628f, 
    0.02668566f, -0.00060133f, 0.03797084f, 0.02778105f, -0.04775990f, -0.01604427f, -0.03200221f, 0.00129175f, 
    0.04196035f, -0.00346726f, 0.04098332f, 0.00795062f, -0.04334050f, 0.00539903f, 0.03260960f, 0.01951442f, 
    0.01530457f, 0.01453177f, 0.01407728f, 0.03184053f, -0.00715506f, -0.03682248f, -0.01070340f, 0.01887608f, 
    0.00945261f, 0.00847048f, 0.04628509f, 0.01338561f, 0.03951553f, -0.04276321f, -0.01172218f, -0.04759436f, 
    -0.01036862f, 0.02833330f, 0.00221317f, -0.04815600f, 0.03241379f, -0.02591396f, 0.01243257f, -0.00251610f, 
    -0.01485141f, -0.01158552f, 0.04913616f, 0.04140314f, -0.01643844f, -0.02866338f, 0.01604025f, -0.00851178f, 
    0.02947750f, 0.00543439f, -0.01431125f, 0.00259429f, -0.03810371f, -0.04170652f, -0.03125273f, 0.00620510f, 
    0.05043489f, -0.04594266f, -0.02786238f, -0.03653643f, -0.03340713f, -0.02167289f, -0.03664874f, 0.04088770f, 
    0.02520838f, -0.00929231f, 0.01894862f, 0.00738857f, 0.00712445f, -0.02360847f, -0.03733550f, -0.01175944f, 
    0.01764019f, -0.02748073f, -0.05570069f, -0.01446986f, -0.02658765f, -0.00184949f, -0.01830537f, 0.01832827f, 
    0.00039913f, 0.01554240f, -0.01827614f, -0.03446130f, -0.00614669f, 0.02717838f, -0.01863183f, 0.00308288f, 
    0.00718012f, 0.00509520f, -0.02151155f, -0.01039763f, 0.03442507f, 0.02482896f, 0.00801100f, 0.01115126f, 
    0.00519635f, 0.02909827f, 0.00606308f, 0.02337112f, -0.03193483f, -0.01674110f, 0.01302295f, -0.00127879f, 
    0.03934111f, 0.00250048f, 0.00976512f, 0.02145912f, 0.02005486f, 0.03839321f, 0.01585006f, 0.03286680f, 
    -0.03952170f, 0.03694971f, 0.02970791f, -0.03144156f, -0.05045845f, -0.02932931f, -0.03360456f, 0.00466473f, 
    -0.03277418f, 0.00686340f, -0.03391643f, 0.00165847f, -0.03010108f, -0.01183834f, 0.00228376f, 0.03663909f, 
    -0.03849735f, 0.00861928f, 0.01834801f, 0.02968928f, -0.04100793f, 0.03608356f, 0.02499485f, -0.05502643f, 
    0.04410247f, -0.03398673f, 0.02058583f, -0.03792930f, -0.04149722f, -0.02428602f, -0.00216869f, 0.03202773f, 
    0.03343582f, -0.02852428f, -0.05518065f, -0.04787657f, -0.04480779f, 0.01827899f, 0.00159779f, 0.00329093f, 
    0.01931048f, -0.01706458f, 0.00555138f, 0.02488610f, -0.01899263f, 0.00047504f, 0.04487405f, 0.00301434f, 
    -0.00623247f, -0.04005050f, -0.04079590f, 0.00329013f, -0.00521852f, 0.01604771f, -0.01260432f, -0.04777751f, 
    -0.03746933f, 0.04477111f, 0.00906510f, -0.04725883f, -0.03370463f, 0.01505426f, -0.02979916f, -0.03109939f, 
    -0.04252079f, -0.00705805f, -0.00526834f, 0.00386111f, -0.00897426f, -0.02455151f, -0.03168801f, -0.00567843f, 
    0.02169079f, -0.03133301f, -0.01781259f, 0.02205643f, -0.04288197f, -0.04006649f, -0.00202861f, -0.01439772f, 
    0.03624743f, 0.03057540f, 0.02170222f, 0.05046303f, -0.01959311f, -0.02989585f, 0.04241432f, -0.02701884f, 
    -0.01407112f, -0.02842764f, -0.02375388f, 0.04005499f, -0.04021928f, -0.02023211f, -0.01820523f, -0.04465410f, 
    0.02548236f, 0.03820932f, -0.01586495f, -0.04170866f, -0.04988452f, -0.01412413f, -0.02076831f, -0.01717539f, 
    0.02186499f, 0.03683921f, 0.01025594f, -0.03304932f, -0.03653675f, -0.04631469f, -0.02696055f, 0.00729516f, 
    -0.02939348f, 0.02923701f, -0.03989629f, 0.01428410f, 0.04070029f, -0.00211608f, 0.02898120f, 0.00020750f, 
    0.02571552f, -0.03437522f, -0.03952717f, -0.04886522f, 0.03744075f, -0.01946190f, 0.03666576f, 0.03176119f, 
    0.02796931f, 0.00721267f, -0.03879043f, -0.05015126f, 0.00080426f, -0.01833770f, -0.04464239f, 0.03407423f, 
    -0.26856858f, -0.26315176f, -0.16236591f, 0.15780778f, -0.04458449f, 0.02050197f, 0.02581025f, -0.12637855f, 
    -0.09121434f, 0.11505124f, -0.12723592f, -0.09226150f, -0.14222407f, 0.11114444f, 0.15753983f, -0.04939853f, 
    -0.04861442f, -0.04645973f, -0.05565625f, -0.05141865f, -0.03381068f, 0.02598626f, 0.08687794f, 0.06183985f, 
    -0.29877988f, 0.28905797f, 0.07623105f, 0.04525416f, -0.06302617f, -0.00759440f, -0.12650281f, 0.04355805f, 
    -0.00900028f, 0.08090533f, 0.09150963f, 0.03036513f, -0.11933759f, -0.11766015f, 0.11657861f, -0.04647568f, 
    -0.04297863f, 0.12252240f, -0.06418846f, -0.15332970f, -0.01989826f, 0.08595970f, -0.21452518f, -0.05765604f, 
    -0.01121218f, 0.22058314f, -0.28006262f, 0.05124185f, 0.01870532f, 0.04442274f, 0.11402852f, 0.02056608f, 
    -0.03894038f, 0.05838094f, 0.02356072f, 0.08155315f, -0.00202218f, 0.14253075f, 0.13201174f, 0.06726497f, 
    0.03021144f, -0.00551887f, -0.18176647f, -0.05339803f, 0.02714320f, 0.03357071f, -0.05005098f, 0.13682669f, 
    0.07785110f, -0.19227131f, -0.15297414f, 0.02556386f, 0.04351496f, 0.06915503f, 0.13530345f, 0.00588680f, 
    0.06403683f, 0.01208967f, 0.02883131f, -0.15780462f, 0.26042020f, 0.08672284f, -0.09196153f, -0.18040073f, 
    -0.00451660f, -0.01270516f, 0.01027606f, 0.22102603f, 0.07908550f, 0.18942945f, -0.06663605f, -0.04896219f, 
    -0.34572595f, 0.13839380f, 0.34850600f, 0.20996788f, -0.01810190f, -0.00853785f, -0.01729901f, 0.00270453f, 
    0.02477058f, -0.01920594f, -0.03057422f, -0.01684948f, 0.32062653f, 0.07586819f, -0.02259983f, -0.02872851f, 
    0.08891366f, 0.00422707f, -0.00550423f, 0.20682324f, 0.11735418f, 0.08327644f, 0.11895911f, 0.06199377f, 
    0.31298295f, -0.12457249f, -0.15291083f, -0.25136712f, 0.19194783f, 0.21635737f, 0.04002504f, -0.09335823f, 
    0.13030033f, 0.03210765f, -0.02153388f, 0.11763667f, 0.22803554f, 0.11812284f, 0.19819316f, -0.10863543f, 
    -0.11578950f, 0.06722805f, 0.04886834f, -0.08227459f, -0.14498822f, 0.03465369f, 0.02088303f, 0.15129484f, 
    -0.02676388f, 0.06429328f, -0.07138276f, -0.20055650f, -0.13556916f, -0.03204615f, -0.06830359f, -0.09330108f, 
    -0.00579287f, 0.05687677f, 0.18497086f, 0.28229737f, 0.19451922f, -0.02319229f, -0.21789831f, 0.13180476f, 
    0.19267564f, 0.05583692f, 0.17876628f, -0.12352289f, -0.04135115f, 0.09159689f, 0.02594746f, 0.12139696f, 
    -0.05511418f, -0.25031483f, 0.03913635f, 0.22129989f, 0.06532391f, -0.04560054f, -0.04871655f, 0.05688190f, 
    -0.15500759f, 0.03742972f, -0.09287884f, -0.09654170f, 0.05908943f, 0.08291883f, 0.17875543f, -0.11497325f, 
    -0.09035747f, -0.10491547f, 0.07808897f, 0.03901971f, -0.02150985f, 0.08802889f, 0.05505330f, 0.04159611f, 
    -0.23429571f, -0.22361648f, -0.14687814f, -0.16266005f, 0.08110055f, -0.02211565f, 0.18509102f, 0.01405867f, 
    0.00889295f, 0.14898130f, 0.05579012f, 0.05509097f, -0.10520731f, 0.07996926f, 0.25927019f, 0.29084852f, 
    -0.20506813f, 0.01684104f, -0.05928968f, 0.17694566f, 0.02508001f, 0.15119529f, 0.10982464f, -0.04660491f, 
    0.25133198f, 0.34919423f, -0.10212335f, -0.23802067f, 0.23870137f, 0.05415811f, 0.11219383f, 0.08609498f, 
    0.06704956f, -0.08868152f, 0.01230283f, -0.10321033f, 0.02704067f, -0.04670637f, -0.04987398f, 0.05048484f, 
    0.03849783f, 0.08002101f, -0.00861232f, -0.06370534f, 0.04241792f, 0.18097876f, -0.14691025f, 0.00456487f, 
    -0.41910329f, 0.04285659f, 0.12324860f, -0.18950525f, -0.12628086f, -0.16856848f, -0.08997463f, 0.19137526f, 
    0.00907903f, 0.03878264f, 0.09048386f, 0.02624171f, 0.22421126f, -0.21723995f, 0.22667629f, -0.47519782f, 
    -0.00589501f, 0.13487816f, -0.02325823f, -0.15097056f, -0.15853469f, 0.00665883f, 0.14531210f, -0.06780953f, 
    -0.25249574f, 0.09397225f, 0.16613849f, -0.05047609f, -0.09232014f, 0.01981431f, -0.11295907f, -0.10164026f, 
    0.03724204f, 0.07781991f, -0.17132373f, -0.10626211f, -0.09691350f, -0.15410605f, -0.22000247f, 0.33620656f, 
    0.12886959f, 0.05846576f, 0.07071523f, 0.08377587f, 0.06486991f, -0.04488510f, -0.00536324f, 0.20937221f, 
    0.36624935f, -0.17260431f, -0.09443820f, 0.36764047f, 0.11784609f, -0.00146230f, 0.00026878f, 0.07604247f, 
    0.03871954f, -0.00163424f, -0.08331406f, 0.02401569f, 0.55077755f, 0.26772660f, -0.54343998f, -0.52038544f, 
    0.14857484f, -0.07643308f, 0.20882387f, 0.07325540f, -0.02609358f, -0.02558552f, 0.00139033f, 0.05332917f, 
    -0.04797688f, 0.10968666f, 0.15600756f, -0.15129569f, 0.00885447f, -0.09097626f, -0.06861535f, -0.07332790f, 
    0.00562986f, -0.04163012f, 0.03260380f, 0.11964321f, 0.22275741f, 0.02387571f, -0.23290457f, -0.02866303f, 
    0.11889335f, 0.04377260f, 0.00102129f, 0.13162540f, 0.00166023f, -0.03487373f, -0.06801660f, -0.04782920f, 
    -0.25054157f, 0.36195871f, 0.10826620f, 0.12535818f, 0.10859953f, -0.09896515f, 0.05718777f, -0.15136018f, 
    0.14789388f, 0.15510637f, -0.02037850f, 0.08803554f, 0.02194433f, -0.04217757f, 0.06879554f, -0.16801646f, 
    -0.04533668f, -0.01611328f, -0.02525060f, -0.07252312f, 0.00920095f, 0.11658685f, 0.07016595f, 0.13397421f, 
    -0.07360216f, 0.07017865f, 0.07083281f, 0.22205727f, 0.08630393f, 0.03239650f, -0.07125020f, 0.22779629f, 
    0.00255203f, -0.04284752f, 0.02183952f, 0.15029609f, 0.56975418f, -0.49167061f, -0.38595703f, -0.18198025f, 
    0.16152853f, 0.09159778f, 0.12430318f, 0.08468150f, 0.02185081f, -0.04239579f, 0.09837716f, -0.05413648f, 
    -0.00593431f, 0.03693640f, -0.01014076f, -0.01881046f, 0.01303475f, -0.01241652f, 0.00008238f, 0.01431009f, 
    0.03017883f, 0.04267476f, -0.04383960f, 0.03792221f, -0.03563210f, -0.02791011f, 0.00510884f, 0.02468052f, 
    0.02596908f, -0.02547493f, -0.05034724f, 0.02354866f, 0.00235057f, 0.03191535f, -0.03751040f, 0.00952441f, 
    0.01622429f, 0.04932463f, -0.04306998f, -0.01312421f, -0.02115785f, -0.05127724f, 0.02399198f, -0.04194828f, 
    -0.02903644f, -0.03996126f, -0.05008294f, 0.03049896f, 0.02275926f, -0.05508865f, 0.04044437f, -0.05449883f, 
    0.00810189f, -0.01987577f, -0.03439375f, 0.01862485f, 0.03313706f, 0.01097066f, 0.03235240f, 0.01217499f, 
    -0.01075073f, 0.03648824f, -0.01469249f, -0.01733346f, -0.03192212f, -0.04589697f, -0.04262949f, 0.00430170f, 
    -0.00084822f, -0.00368954f, 0.01364835f, -0.00437929f, 0.04851657f, -0.04325029f, -0.02787545f, -0.05261250f, 
    0.00040212f, -0.00286162f, 0.01984770f, 0.03021426f, -0.03354031f, -0.00979021f, -0.00489290f, 0.02234821f, 
    -0.03805618f, 0.03195747f, 0.01279886f, 0.01549069f, -0.01484320f, -0.05456332f, -0.01434178f, -0.01267276f, 
    -0.03583243f, -0.02282522f, 0.02673975f, -0.05582289f, 0.00033360f, -0.03391279f, -0.05020052f, -0.00625181f, 
    0.01349739f, 0.00858433f, 0.02307032f, 0.02487151f, -0.02625952f, -0.00776607f, -0.02174987f, -0.05242715f, 
    -0.01734179f, 0.03504822f, -0.01093882f, 0.05817198f, -0.00088917f, -0.03131282f, 0.03049653f, 0.02853303f, 
    -0.00794258f, -0.00486585f, -0.05098771f, -0.01636206f, 0.03191447f, 0.03535888f, -0.03406353f, -0.02087579f, 
    0.01079613f, -0.02653683f, 0.02640497f, 0.03930508f, -0.03888903f, 0.02157533f, 0.05178391f, -0.02619416f, 
    -0.05026009f, -0.03588818f, -0.02764457f, -0.05773526f, -0.03268217f, 0.03621590f, -0.03643293f, -0.03620905f, 
    0.04501882f, -0.01506256f, 0.03703586f, 0.01997243f, 0.02939998f, -0.04628422f, 0.03462688f, -0.03013681f, 
    -0.04758981f, -0.03983514f, -0.05162773f, 0.03664659f, 0.01929870f, -0.03059344f, -0.04564518f, -0.01935066f, 
    -0.03620226f, -0.01797260f, -0.02290680f, -0.01256050f, 0.04142558f, 0.04855835f, -0.02696920f, -0.00265665f, 
    0.01234229f, -0.03340662f, 0.00690207f, -0.03883360f, -0.00292847f, -0.02393444f, 0.02892759f, 0.02319284f, 
    -0.02924023f, -0.02009685f, -0.01626497f, 0.02646181f, -0.02426236f, 0.02308786f, -0.04839919f, -0.01714305f, 
    -0.01564599f, -0.01219524f, -0.00229024f, 0.03776171f, -0.04015754f, -0.01839706f, -0.04926152f, 0.02050708f, 
    -0.01243912f, 0.02835481f, 0.02290608f, 0.01331621f, 0.03242327f, -0.04221816f, 0.00038402f, -0.00588226f, 
    0.01887513f, -0.04000220f, -0.01243932f, 0.02379887f, 0.01018290f, 0.02921791f, 0.00245842f, -0.04057570f, 
    -0.01025602f, 0.03358036f, -0.05301526f, 0.01178026f, -0.01109888f, 0.01738596f, -0.02980190f, 0.02765770f, 
    -0.01179849f, 0.02792301f, -0.03679410f, -0.05127491f, -0.05304532f, 0.02820657f, -0.05149589f, -0.01370945f, 
    -0.00073635f, 0.00430126f, -0.02186780f, -0.03575964f, -0.01265351f, 0.01696206f, -0.00719450f, 0.01092616f, 
    0.03493171f, -0.06137180f, -0.01144379f, -0.01995557f, -0.01191416f, 0.02595097f, -0.04092444f, -0.03894404f, 
    -0.01982259f, 0.01649112f, -0.04699101f, 0.03136968f, -0.01553039f, 0.01740331f, 0.00735089f, -0.02102568f, 
    0.04444281f, 0.04128965f, 0.01934607f, 0.03826746f, 0.03047690f, -0.05034793f, -0.05499160f, -0.05520468f, 
    -0.05712847f, -0.04239244f, 0.02345572f, -0.00361999f, 0.03555265f, -0.03093339f, 0.04375101f, -0.03905078f, 
    -0.02743664f, -0.01164307f, 0.03678647f, -0.02892546f, -0.01061222f, 0.01689365f, -0.02697727f, 0.03776086f, 
    -0.02756191f, 0.00921818f, -0.02947794f, -0.01550187f, 0.03747110f, 0.00017513f, -0.00673840f, -0.04121153f, 
    -0.04389990f, 0.01061756f, -0.05726110f, -0.02553402f, 0.03782866f, 0.04388649f, 0.02126085f, -0.00989472f, 
    0.04721099f, -0.02717321f, 0.00957957f, 0.01527765f, 0.00749212f, 0.04961934f, 0.04564011f, -0.00156649f, 
    -0.01984606f, -0.02752307f, 0.01085991f, -0.02327735f, -0.01371059f, 0.00147476f, 0.02509033f, 0.00984303f, 
    0.03352471f, 0.00964968f, 0.00921980f, 0.03827439f, -0.05025676f, -0.00616095f, -0.02951403f, -0.01081487f, 
    -0.04838236f, -0.05480389f, -0.02051119f, 0.04527547f, 0.02522765f, 0.01426479f, -0.02915311f, -0.01448399f, 
    0.01476020f, -0.01032400f, 0.02377883f, -0.02427755f, -0.00670552f, 0.00493318f, 0.00012637f, 0.03867716f, 
    -0.05605561f, -0.00451811f, 0.04088062f, 0.00515794f, 0.00447312f, 0.00797047f, -0.04511745f, 0.02786638f, 
    -0.02152874f, -0.02508038f, -0.04887570f, -0.04317452f, 0.02790843f, -0.03824715f, 0.00344872f, -0.01132522f, 
    0.03843118f, 0.01787577f, -0.01557302f, -0.02375212f, -0.00251728f, 0.02176353f, -0.05002724f, -0.04611291f, 
    0.00238326f, -0.03078006f, -0.03614836f, 0.03907754f, 0.01550149f, 0.02992766f, 0.01477506f, -0.03714074f, 
    0.03218698f, 0.03484931f, 0.01450848f, 0.03510424f, 0.00233708f, -0.00282570f, -0.00161347f, -0.00153472f, 
    0.01883889f, -0.00623321f, -0.01123633f, 0.03689685f, -0.04504857f, 0.00722113f, 0.01724953f, -0.04730235f, 
    -0.01047287f, -0.05713585f, -0.04335974f, 0.03188072f, -0.05191965f, 0.01257591f, -0.01708383f, -0.03266328f, 
    0.02635886f, -0.02017931f, 0.03375998f, 0.02185038f, 0.00435546f, 0.03477812f, -0.04362695f, 0.04242231f, 
    0.02331297f, 0.01377946f, -0.02136881f, 0.04828574f, -0.00295822f, -0.02949391f, 0.03493096f, -0.02149699f, 
    0.03143496f, 0.02526184f, -0.00752003f, -0.02724596f, -0.03728704f, -0.05205986f, -0.01951567f, 0.01239591f, 
    -0.01057829f, -0.00019599f, -0.01694136f, 0.02293905f, 0.02195575f, 0.02291655f, -0.00815374f, -0.01275230f, 
    -0.01557186f, -0.00690416f, 0.03618585f, -0.03197299f, 0.01395241f, -0.04470319f, -0.05361335f, 0.02215761f, 
    -0.03926557f, 0.01965350f, 0.03707498f, 0.01039721f, 0.00453389f, -0.05474505f, 0.04307086f, 0.02757911f, 
    -0.01502584f, -0.03482201f, 0.01657105f, -0.01850796f, -0.00022964f, 0.00996989f, 0.00711681f, 0.01147268f, 
    -0.05237544f, -0.02079646f, 0.02361279f, -0.00511994f, -0.01068225f, -0.04617656f, -0.05065018f, -0.05463953f, 
    0.01829667f, -0.01858728f, -0.04202580f, 0.01780442f, -0.02781937f, 0.02527978f, -0.04012673f, -0.04731595f, 
    0.01027202f, 0.01057283f, -0.02978629f, -0.01631868f, 0.00589395f, 0.00703245f, 0.03813780f, 0.01819774f, 
    -0.01318710f, 0.00620897f, -0.02001096f, -0.01219159f, 0.02957356f, -0.01633888f, -0.04877866f, 0.02788012f, 
    -0.05285159f, -0.03935187f, -0.03138572f, -0.05409602f, -0.00367085f, 0.04061176f, -0.04680342f, 0.00032132f, 
    -0.03197950f, -0.01916797f, -0.02645308f, -0.04271088f, -0.05580303f, -0.04527557f, 0.04217043f, -0.00343907f, 
    -0.04766977f, -0.05033610f, -0.02305895f, 0.03459033f, -0.02441074f, -0.00625628f, -0.01274749f, 0.01298542f, 
    -0.03909881f, -0.00100897f, 0.03326939f, 0.03098889f, -0.04035658f, -0.02308213f, -0.00032205f, 0.03542922f, 
    -0.05015600f, -0.03932526f, -0.02596482f, -0.03152689f, -0.05428000f, -0.01086634f, -0.02459328f, -0.00856704f, 
    -0.03533991f, -0.03624449f, -0.01394103f, 0.01462724f, -0.05452453f, -0.00121104f, 0.04396754f, 0.00988451f, 
    -0.01898148f, 0.01471779f, 0.03911371f, 0.04727018f, -0.03589193f, 0.03004172f, 0.03645358f, -0.05090192f, 
    0.02331905f, -0.04540074f, -0.00409370f, 0.01475812f, 0.00514575f, -0.01397767f, -0.00487060f, -0.01018055f, 
    -0.00638054f, -0.01455629f, 0.02746648f, 0.04473373f, 0.03398947f, 0.03970372f, -0.03641806f, 0.02478621f, 
    -0.00125641f, -0.03098876f, -0.05221158f, -0.00869354f, -0.05426073f, -0.01059188f, -0.03081861f, 0.02605711f, 
    0.00956273f, 0.00511906f, -0.04726007f, -0.05417978f, -0.00759922f, 0.04284177f, -0.04797532f, -0.04320520f, 
    0.04126025f, 0.03722536f, 0.02387665f, 0.03934953f, 0.01272806f, 0.02641729f, 0.00423719f, 0.00927895f, 
    -0.03885896f, 0.04318842f, -0.01686766f, 0.02992963f, -0.00176461f, 0.02214289f, -0.00149701f, 0.01446092f, 
    -0.04645979f, -0.01835005f, -0.01041548f, -0.03850431f, 0.02181823f, -0.00579918f, -0.03842300f, -0.04061923f, 
    -0.04841384f, 0.00934308f, 0.00147306f, -0.03799371f, 0.00215356f, -0.04806596f, 0.03283795f, -0.02262794f, 
    -0.04586030f, -0.00299670f, -0.05189951f, -0.05240821f, -0.02803562f, -0.00126562f, 0.01555676f, 0.02149711f, 
    -0.00924386f, 0.02538079f, -0.01722967f, -0.01451688f, -0.00903230f, -0.03837806f, -0.02045345f, 0.04825033f, 
    0.04323471f, 0.00678601f, -0.01115714f, -0.02264421f, 0.03161562f, -0.01425503f, 0.00894305f, 0.03886019f, 
    -0.05224396f, 0.02900329f, -0.00195269f, -0.04990597f, 0.03114021f, 0.03673723f, -0.03632900f, -0.03003113f, 
    -0.03811228f, -0.04404204f, 0.03028927f, 0.01249800f, -0.01504805f, 0.02829086f, -0.05010055f, -0.04668980f, 
    0.01328636f, -0.04380488f, 0.01829773f, -0.05227043f, -0.00359134f, -0.00884978f, -0.02783473f, 0.03060757f, 
    0.00657040f, 0.02876574f, -0.01126107f, 0.01916644f, -0.00347124f, 0.04371195f, 0.03744515f, -0.04812098f, 
    0.03531951f, -0.02080642f, -0.03248858f, -0.02054276f, -0.00708245f, 0.01682279f, -0.00913306f, -0.00781131f, 
    0.00044992f, -0.02629849f, -0.00330710f, 0.00954999f, -0.01413761f, -0.02887497f, -0.04842677f, 0.01475901f, 
    0.03522122f, 0.01884133f, -0.04602075f, 0.02402216f, -0.02159134f, 0.04782882f, 0.03336114f, 0.03014836f, 
    -0.04624545f, 0.01433494f, 0.03543188f, -0.04502569f, -0.04077435f, -0.03029604f, -0.04313774f, -0.01663265f, 
    0.00625987f, -0.00074266f, -0.02646459f, -0.02301863f, -0.01300019f, -0.01577120f, 0.00402564f, -0.01045405f, 
    0.03375014f, 0.04534022f, 0.02172631f, 0.03569487f, -0.03259885f, -0.03133983f, -0.04550814f, -0.01790497f, 
    0.04360829f, -0.03241563f, 0.04369673f, 0.04697838f, -0.00357912f, -0.03905699f, 0.00158824f, -0.04038847f, 
    -0.03400981f, -0.01062413f, -0.05000138f, -0.05553001f, -0.02030760f, -0.00803469f, 0.00704043f, -0.04217179f, 
    -0.03341677f, 0.01227475f, -0.00385364f, -0.01432877f, 0.03280646f, -0.03566745f, -0.04569506f, 0.00771861f, 
    0.04031351f, -0.05069026f, -0.04432907f, 0.01175941f, -0.02148820f, 0.01929016f, -0.03468962f, -0.01789064f, 
    0.03418089f, 0.04099406f, 0.00289661f, -0.02688947f, 0.00984803f, -0.01917251f, -0.01584421f, 0.00004255f, 
    0.00822935f, 0.02717531f, -0.00235470f, -0.01822786f, 0.01837092f, 0.04005454f, -0.03159527f, -0.00334336f, 
    -0.04167458f, -0.02911427f, -0.03044447f, 0.01852378f, 0.01776372f, -0.01989179f, -0.03445673f, 0.03270634f, 
    0.03438935f, -0.03488233f, 0.00001994f, -0.04995564f, 0.03272613f, -0.00612537f, 0.04172876f, -0.02631579f, 
    0.04545010f, 0.04458104f, -0.01750030f, -0.03134930f, -0.00121269f, 0.03141672f, -0.03762039f, -0.01220344f, 
    -0.05120407f, 0.03312111f, -0.00796578f, -0.00477427f, -0.01224064f, 0.04298710f, -0.00634435f, 0.03470050f, 
    0.03722692f, -0.04744586f, -0.03792007f, -0.00639378f, -0.00863719f, 0.03720928f, 0.00135834f, -0.04815111f, 
    -0.10136781f, 0.02402709f, 0.01176865f, -0.00125498f, -0.03893433f, 0.03743195f, -0.01918659f, -0.03757797f, 
    -0.03079484f, 0.12024493f, 0.10997015f, 0.00029171f, 0.07192533f, 0.19392695f, 0.16965647f, -0.25874847f, 
    0.00582862f, -0.02562915f, -0.09400476f, 0.02029594f, -0.15161866f, -0.07665708f, 0.00881764f, -0.17004351f, 
    0.30535141f, 0.14492729f, -0.01669336f, -0.10355599f, -0.15566410f, 0.12540288f, -0.19639863f, -0.09493156f, 
    -0.05153185f, 0.06030263f, 0.00880079f, 0.02592352f, 0.13897230f, -0.00515391f, -0.21231741f, 0.17568779f, 
    -0.00195950f, -0.08625839f, 0.28205743f, -0.13758115f, 0.06248328f, 0.08725630f, -0.12314132f, 0.09947741f, 
    -0.12663874f, -0.05748507f, -0.14178009f, 0.12845908f, -0.03861212f, 0.12664178f, 0.24900192f, 0.09919740f, 
    -0.02890339f, 0.06058777f, 0.01637326f, -0.08333169f, 0.30541092f, -0.01010909f, 0.16977151f, -0.10210417f, 
    0.14562064f, 0.01852373f, 0.11024087f, -0.04641448f, 0.03130531f, 0.11535738f, 0.04764294f, -0.00313797f, 
    0.03306562f, -0.07645230f, 0.02309627f, 0.09694009f, 0.09504567f, -0.04681772f, 0.15910077f, 0.00058310f, 
    0.05253920f, 0.06339729f, 0.16343077f, 0.01074216f, -0.14427470f, -0.09020296f, -0.04656209f, 0.31816825f, 
    0.07742845f, 0.03793052f, 0.11524795f, 0.00864968f, 0.02030268f, -0.04695632f, 0.15703852f, -0.07138738f, 
    0.02378631f, -0.25980729f, 0.48177648f, -0.38457581f, 0.13235176f, -0.02992731f, -0.08629847f, 0.03189243f, 
    -0.11529060f, -0.11244919f, 0.03011286f, -0.03495238f, 0.12837684f, -0.06824164f, -0.27491724f, -0.12026700f, 
    -0.06268892f, -0.29207730f, -0.03757298f, 0.12768488f, 0.06115963f, 0.11029037f, 0.14629403f, 0.10196760f, 
    -0.06640749f, -0.16417214f, -0.24523459f, -0.12659504f, -0.11355227f, -0.08572583f, -0.10759918f, 0.23228726f, 
    0.07168322f, 0.14314669f, 0.04869645f, 0.07366703f, 0.11829601f, 0.04763021f, -0.13682930f, -0.17783204f, 
    0.15252149f, -0.05304015f, -0.03790296f, 0.06651352f, 0.08666442f, -0.01124632f, 0.07592221f, 0.20865849f, 
    -0.28176367f, -0.03178649f, -0.11578163f, -0.09674442f, 0.00532771f, -0.06124846f, 0.12968415f, 0.06803718f, 
    0.01695447f, 0.02656379f, -0.02591600f, 0.03614797f, -0.11387029f, -0.35974538f, 0.01469718f, -0.02994566f, 
    -0.07940509f, -0.25087789f, -0.17174850f, 0.19490127f, 0.00303984f, 0.04447098f, 0.03581132f, -0.08344997f, 
    0.25818691f, -0.12615897f, -0.10973076f, 0.15787764f, 0.00508737f, 0.10597949f, -0.09993547f, -0.04125446f, 
    -0.09586072f, 0.22282970f, -0.07421266f, -0.14891975f, -0.01680062f, -0.04012965f, -0.15461884f, -0.04668353f, 
    0.07668672f, 0.01718858f, 0.04617305f, 0.01478259f, -0.07384863f, 0.16210741f, -0.11261310f, 0.16578881f, 
    -0.11478859f, 0.40141129f, -0.11253959f, 0.22332855f, -0.09152214f, 0.17708680f, 0.07531030f, 0.14606480f, 
    0.02909898f, 0.03282359f, 0.01883325f, 0.12490140f, 0.10978405f, -0.31951353f, 0.26256484f, -0.41292974f, 
    0.17011929f, -0.00710464f, -0.10029577f, 0.08573642f, -0.16890754f, 0.06934129f, 0.18089107f, -0.08336605f, 
    0.09547963f, -0.13841055f, -0.16803725f, 0.12897512f, -0.07368906f, -0.12187101f, 0.13646016f, -0.10804854f, 
    0.05101033f, -0.07717752f, 0.20678045f, 0.01671555f, -0.05174704f, 0.11517625f, -0.18261167f, 0.19181013f, 
    -0.00527999f, 0.09565313f, -0.06197194f, -0.07502481f, 0.16238205f, -0.07293970f, 0.09338092f, 0.17394742f, 
    -0.00883540f, -0.09332035f, 0.24889641f, -0.10254516f, 0.08420569f, 0.05368730f, -0.05767103f, -0.05387446f, 
    -0.03158002f, 0.02844407f, -0.12254618f, -0.00039899f, -0.06718202f, -0.09547536f, -0.14366525f, 0.27894089f, 
    0.30555648f, -0.03572926f, -0.02058582f, 0.16589954f, -0.03919958f, 0.01348014f, -0.03470184f, 0.14628048f, 
    -0.19562288f, 0.14234863f, -0.07925610f, -0.05241166f, -0.05730305f, -0.09234291f, -0.01623798f, -0.06920441f, 
    -0.16986948f, 0.05329300f, -0.04783484f, -0.03887173f, -0.23654333f, -0.16416040f, 0.09156343f, 0.17829272f, 
    0.00722000f, 0.07625733f, -0.02704071f, 0.16348124f, -0.11690976f, 0.07197092f, -0.02718161f, 0.01349340f, 
    0.34982038f, 0.25579947f, 0.24776757f, 0.28006727f, 0.03724596f, 0.14670286f, 0.04075868f, -0.05675891f, 
    -0.03866878f, -0.03653102f, 0.11234027f, 0.05395634f, 0.00968770f, -0.06126837f, 0.04992756f, 0.14893137f, 
    0.12628612f, 0.12965940f, 0.11028337f, 0.05483825f, 0.09963743f, -0.10434702f, 0.05558472f, -0.00169949f, 
    0.12272695f, 0.12826799f, -0.03500889f, -0.09825560f, -0.04086706f, -0.00462870f, 0.01745244f, 0.08283497f, 
    -0.08979658f, -0.08260884f, 0.03870480f, 0.01193310f, -0.17591509f, -0.07223316f, 0.04520086f, 0.05093568f, 
    -0.27307802f, 0.09621023f, -0.09153711f, -0.23154517f, -0.07866233f, -0.09563792f, -0.15653442f, -0.13638374f, 
    0.23357230f, 0.09310168f, -0.15360950f, -0.00900081f, -0.11034557f, 0.08452047f, -0.03070960f, -0.08553340f, 
    -0.04604186f, 0.08300783f, 0.11242449f, 0.09401776f, -0.20940924f, -0.00461682f, -0.15815875f, -0.18060690f, 
    0.05810967f, 0.05774509f, -0.03492890f, 0.07822239f, -0.06847498f, 0.00120378f, -0.05061241f, 0.07148786f, 
    -0.04550369f, -0.00862234f, 0.07086056f, 0.04312653f, -0.00220555f, 0.02150816f, 0.03740997f, -0.16813008f, 
    -0.06202101f, 0.01891748f, 0.05055581f, 0.17057133f, -0.33874145f, -0.03558566f, -0.12866972f, 0.05023548f, 
    -0.10133728f, 0.24034657f, 0.09972172f, 0.01033367f, -0.03412627f, 0.03240033f, 0.02699260f, -0.06670252f, 
    -0.00852023f, 0.02038987f, -0.02852602f, 0.02939510f, 0.00781902f, -0.03487875f, -0.02440859f, 0.02545114f, 
    0.01242387f, -0.04482015f, 0.01381677f, -0.02776019f, -0.01616633f, 0.02446093f, 0.02696286f, -0.00362792f, 
    -0.05353751f, 0.02773897f, 0.04020173f, -0.00611815f, -0.02250060f, -0.03776136f, 0.03597426f, 0.03086429f, 
    0.03452400f, -0.03385121f, -0.00879278f, -0.05408890f, -0.03101015f, 0.02974498f, 0.03514609f, -0.02052750f, 
    0.02364449f, 0.01440553f, -0.01415011f, 0.00230962f, -0.05105555f, 0.04277906f, -0.04830454f, 0.02916641f, 
    0.01623202f, 0.02409873f, -0.01339407f, 0.00433459f, 0.03024547f, -0.05622377f, -0.04302560f, 0.01830674f, 
    -0.03664882f, -0.01902794f, -0.05445843f, -0.03117841f, -0.05478254f, 0.01632285f, 0.02631381f, -0.04910885f, 
    -0.02725971f, -0.00931733f, -0.05542694f, -0.04412682f, -0.02673491f, -0.04587683f, 0.00905308f, -0.00959481f, 
    -0.00194566f, -0.05548962f, 0.00381027f, -0.04607643f, -0.04734524f, -0.00490474f, -0.01894764f, 0.02923983f, 
    0.03452813f, -0.02440798f, -0.00724981f, 0.03361303f, -0.02449352f, -0.05421546f, -0.00184764f, -0.02260732f, 
    -0.03729738f, -0.05364148f, 0.03990725f, 0.01860077f, 0.01869221f, -0.01518706f, -0.02982451f, 0.00056052f, 
    -0.03289624f, -0.03176707f, 0.03989514f, 0.02387484f, 0.02199220f, -0.05323987f, 0.02029490f, -0.03346860f, 
    -0.05018847f, 0.02435281f, -0.01367669f, 0.01221272f, 0.03637072f, -0.01052118f, -0.02561127f, -0.00329374f, 
    -0.05698364f, -0.02226096f, -0.01371490f, -0.03010951f, -0.04273368f, -0.01640789f, -0.03421414f, 0.02549487f, 
    0.00897786f, -0.01578524f, -0.02801150f, -0.02321269f, -0.04454068f, -0.01838619f, -0.03936147f, -0.00158514f, 
    0.03254011f, -0.02411851f, -0.04614299f, 0.00095702f, -0.01873712f, 0.01382620f, -0.00307660f, -0.03546606f, 
    0.03880335f, 0.00732516f, -0.02727031f, -0.05028754f, -0.02816361f, -0.05370074f, 0.01144328f, -0.04797701f, 
    0.01531381f, -0.03374490f, -0.04951852f, -0.04700172f, -0.00876141f, -0.03216930f, 0.01197091f, 0.03997934f, 
    0.02299091f, 0.02898451f, 0.02477745f, 0.03569145f, 0.03062047f, -0.00947872f, -0.02617982f, -0.00881184f, 
    0.00338220f, 0.00567532f, -0.02431383f, -0.05655390f, -0.02235034f, 0.01726578f, -0.00605556f, -0.03347956f, 
    0.00456709f, -0.03874528f, 0.02250760f, 0.02072118f, 0.00296065f, 0.02170154f, 0.04291749f, -0.05369211f, 
    -0.02607930f, -0.02773504f, -0.00436362f, -0.00357069f, 0.03216387f, 0.03139617f, -0.03100661f, -0.03598199f, 
    0.03498732f, -0.02276528f, 0.01648428f, -0.05077322f, -0.02846701f, -0.03437328f, -0.01033966f, -0.02422218f, 
    -0.04516877f, -0.04102054f, -0.03958114f, 0.03248223f, -0.05256673f, 0.01818309f, 0.03920482f, 0.03636363f, 
    -0.02300609f, -0.01265579f, -0.02374205f, -0.03843176f, 0.01148187f, 0.02958272f, -0.04731815f, -0.05145285f, 
    0.02764776f, -0.05430338f, -0.01465805f, 0.02405144f, -0.02190911f, 0.02766648f, 0.00240551f, 0.03235735f, 
    0.04174418f, -0.04714011f, -0.01530262f, -0.04047005f, -0.04992604f, -0.01720967f, -0.05684056f, -0.00255576f, 
    -0.01621868f, 0.03493674f, 0.02857015f, -0.03014226f, -0.00299526f, -0.03713758f, 0.01542474f, -0.04918711f, 
    0.02459962f, 0.00949261f, -0.02765824f, 0.02747914f, -0.01557368f, -0.00314398f, 0.01779979f, 0.03722822f, 
    -0.02947846f, 0.02970525f, 0.01283022f, 0.02362684f, -0.00172558f, -0.01924886f, 0.01836454f, -0.04906438f, 
    0.03759821f, 0.04104869f, 0.03021714f, -0.01031386f, -0.02763862f, 0.02593361f, -0.01431459f, -0.00591007f, 
    0.02574205f, 0.02708436f, 0.02923177f, -0.01263982f, 0.01054663f, -0.00501462f, 0.02011163f, -0.01461921f, 
    -0.00282419f, -0.02500199f, 0.01511896f, -0.05534161f, 0.00403716f, -0.01619904f, 0.04055768f, -0.05525357f, 
    -0.05509862f, -0.01817781f, -0.02426370f, -0.00132449f, -0.00688841f, -0.02822889f, 0.04198500f, 0.00774481f, 
    0.02715694f, -0.04426008f, 0.01980408f, -0.02189940f, 0.00007931f, -0.00969973f, -0.04530534f, -0.03383821f, 
    -0.04552614f, -0.03313006f, 0.00322036f, -0.05551606f, 0.02535919f, -0.03265457f, -0.01986636f, -0.04108435f, 
    -0.01075268f, -0.03927746f, -0.02201884f, -0.01908028f, -0.00415847f, 0.01563554f, -0.00743600f, -0.05672272f, 
    0.02425951f, 0.02356589f, 0.03553114f, -0.04667185f, 0.04239764f, -0.00143470f, -0.05306711f, 0.01401009f, 
    -0.02998356f, 0.03785729f, -0.04024991f, -0.00514838f, 0.03353689f, -0.04390654f, -0.02898409f, -0.03684650f, 
    0.03733903f, -0.02321238f, -0.00497163f, -0.03143577f, 0.02417127f, -0.04014936f, -0.03119515f, 0.02579551f, 
    -0.02990910f, -0.02594097f, -0.01667913f, -0.02486926f, 0.02335092f, 0.00858384f, -0.03296690f, -0.00544816f, 
    0.01200590f, 0.02803800f, 0.00612789f, 0.04069569f, -0.05369812f, -0.02706096f, -0.00154384f, -0.00198447f, 
    -0.01005489f, 0.01996795f, -0.05462450f, -0.00467800f, 0.02978038f, -0.04954948f, -0.05482139f, -0.04884142f, 
    -0.03109108f, -0.01714574f, 0.00954067f, 0.00705931f, -0.04851134f, -0.03908456f, -0.00153300f, 0.01288361f, 
    -0.01843942f, -0.02049255f, 0.02799018f, -0.01270390f, -0.03946003f, -0.01583277f, -0.02380827f, 0.01381633f, 
    0.01761226f, 0.01309593f, 0.00441498f, 0.00999870f, 0.01433747f, -0.01930195f, -0.02547206f, 0.03404095f, 
    -0.01925810f, 0.03033278f, -0.02001005f, 0.01512149f, 0.03119746f, -0.02886747f, -0.05785679f, 0.00054211f, 
    -0.00140518f, -0.02404722f, -0.02303163f, -0.00401774f, -0.05670385f, -0.05770751f, -0.01010489f, 0.01793189f, 
    -0.01629532f, -0.02741159f, 0.01274473f, 0.03368256f, 0.00855958f, 0.01204471f, 0.02243045f, -0.05808898f, 
    0.02166388f, 0.02315295f, 0.02326125f, -0.03154102f, -0.00247408f, -0.02261345f, -0.00933648f, -0.01641326f, 
    -0.00565866f, -0.02627985f, 0.00533549f, -0.00894783f, -0.05265481f, -0.02544842f, -0.00463016f, 0.00170390f, 
    -0.05401094f, 0.03687176f, 0.01780749f, -0.01053840f, 0.01121041f, -0.01858049f, 0.03250492f, -0.05878576f, 
    0.03841240f, 0.01499194f, -0.05157108f, 0.01938684f, -0.04379888f, 0.02076592f, 0.01373176f, -0.01612525f, 
    -0.05513626f, -0.00581411f, 0.04137757f, -0.03604403f, -0.02769311f, 0.01541393f, 0.03020978f, 0.03722716f, 
    -0.02970994f, -0.04024804f, -0.04072206f, -0.03342113f, -0.03207743f, -0.03088444f, -0.01334974f, 0.02802588f, 
    -0.02737413f, 0.02215016f, 0.02488144f, -0.03827821f, 0.01051095f, -0.03817919f, 0.01545335f, -0.02736925f, 
    -0.01468597f, -0.04223724f, 0.02931070f, 0.03504245f, -0.05410700f, -0.02981967f, -0.04909496f, 0.02545665f, 
    0.02568345f, -0.04315902f, 0.02402689f, -0.05051861f, -0.04602269f, 0.01089435f, 0.00975253f, -0.03417125f, 
    0.01616410f, 0.00356014f, 0.03094023f, 0.01394300f, -0.03585969f, -0.01695490f, -0.00016574f, -0.02199000f, 
    -0.01068830f, 0.02544771f, -0.02094378f, 0.01894469f, -0.03090066f, -0.02634289f, -0.01291310f, -0.02282194f, 
    -0.01007332f, 0.04475996f, -0.00277744f, -0.03769089f, -0.01131703f, 0.01797224f, 0.01086989f, -0.05706717f, 
    -0.00757098f, -0.05142450f, -0.03790244f, -0.05442683f, 0.03233348f, 0.01291408f, 0.01189625f, -0.00772067f, 
    0.03895987f, -0.03251463f, -0.03333385f, 0.03753794f, -0.01387380f, 0.03866260f, 0.04437706f, -0.04472847f, 
    -0.03829575f, -0.00329020f, 0.03922976f, -0.03895759f, -0.03144993f, 0.00896847f, -0.05397905f, 0.01055660f, 
    -0.03774763f, 0.01016080f, 0.05147912f, -0.00718513f, 0.03276153f, -0.04403866f, 0.03199435f, 0.04069620f, 
    0.01867229f, 0.02035857f, -0.03540830f, 0.02389702f, -0.02586580f, -0.03166770f, 0.02290743f, -0.01516660f, 
    0.01391449f, -0.05063898f, -0.01978270f, -0.05709531f, -0.01278329f, 0.04128551f, 0.03971557f, 0.00759524f, 
    0.01730274f, -0.04681528f, 0.03494047f, 0.00258955f, -0.03118142f, 0.02345917f, -0.01178151f, 0.03816084f, 
    -0.01642603f, -0.03705724f, 0.00015133f, -0.02090679f, -0.04839507f, -0.04989097f, -0.00117122f, 0.01713076f, 
    -0.05652319f, -0.02173044f, -0.01451549f, -0.05602545f, -0.00234302f, -0.02886642f, 0.00826889f, -0.00891163f, 
    -0.02675160f, 0.01049469f, 0.01987096f, 0.03882847f, 0.01268652f, 0.01059547f, -0.03653738f, 0.02616635f, 
    -0.05770276f, -0.02371384f, 0.01484828f, 0.01785344f, -0.04575158f, -0.03017436f, -0.00604484f, -0.05386631f, 
    0.03943497f, 0.03022648f, -0.03543872f, -0.01844259f, -0.00819166f, -0.05300659f, 0.03290717f, 0.02033865f, 
    -0.05189878f, -0.01909996f, -0.01613423f, -0.04234026f, -0.00000173f, 0.01350608f, -0.04151918f, 0.03175686f, 
    0.01515503f, -0.02431786f, -0.00167102f, -0.00383849f, 0.03898155f, -0.05106005f, 0.03521699f, 0.00816743f, 
    -0.04939083f, 0.03968756f, -0.04432980f, -0.01156295f, 0.01384439f, -0.03785972f, 0.01387492f, -0.02852785f, 
    0.03200432f, -0.04729960f, 0.03934867f, -0.03691155f, -0.02056217f, 0.00056184f, -0.03524233f, -0.04294003f, 
    0.03805782f, 0.03527268f, -0.01124952f, -0.01313787f, 0.01362109f, -0.04756882f, -0.02153721f, -0.05363852f, 
    0.00362636f, 0.02583471f, -0.02786021f, 0.00596173f, -0.00354215f, -0.00095730f, -0.00335605f, -0.02629258f, 
    -0.02253738f, 0.00040186f, -0.02870605f, 0.02286231f, -0.01862297f, -0.05083699f, -0.04206695f, -0.04152068f, 
    -0.05095724f, -0.03932309f, 0.05035828f, -0.05128727f, -0.04967531f, -0.03301698f, -0.05635579f, 0.01693502f, 
    0.00965820f, 0.02774229f, 0.03001223f, -0.00568615f, -0.05540164f, 0.00618074f, -0.00262486f, -0.03603106f, 
    -0.02151558f, -0.05585557f, 0.03256110f, -0.04542129f, 0.03054975f, -0.00223597f, 0.01745781f, -0.01380403f, 
    -0.05120753f, 0.00305022f, -0.04605784f, 0.00625587f, -0.01417443f, 0.01222713f, -0.01501670f, -0.05892651f, 
    0.00431459f, -0.01544116f, 0.02352503f, -0.03712540f, 0.03511517f, -0.03280013f, 0.02114336f, -0.02791133f, 
    0.04030552f, -0.02114481f, -0.03966608f, 0.00635598f, -0.05486803f, -0.05278968f, -0.02348105f, -0.01185431f, 
    -0.03045271f, -0.03260219f, -0.02737892f, 0.01478639f, -0.04801451f, -0.02567171f, -0.03940792f, 0.01155076f, 
    -0.01198473f, 0.01796277f, 0.00036478f, -0.02332521f, 0.03245500f, 0.02814229f, 0.04289653f, 0.03113369f, 
    -0.06178617f, -0.00183064f, -0.01948408f, -0.02735877f, 0.00918516f, -0.03146504f, -0.01409725f, 0.03312743f, 
    0.01837621f, 0.01148987f, -0.04207320f, 0.02572347f, 0.02540998f, -0.00240399f, 0.01385664f, -0.03893246f, 
    0.02229127f, 0.00716502f, -0.04537597f, -0.02013147f, -0.02046390f, 0.00643401f, -0.05977296f, 0.02343806f, 
    -0.02802536f, 0.02451074f, 0.02226160f, 0.03188754f, -0.04978186f, -0.00156435f, -0.00421460f, -0.00895872f, 
    -0.02954944f, -0.00445701f, 0.01499948f, -0.03423353f, 0.02704905f, -0.02251288f, 0.03460919f, -0.02537947f, 
    0.03084114f, 0.00188148f, -0.05596016f, -0.02300335f, -0.00390970f, -0.05717847f, 0.01062342f, -0.04696975f, 
    0.01259841f, -0.04961338f, -0.00701954f, 0.01301958f, 0.00350718f, -0.03568339f, 0.01048195f, -0.04067451f, 
    -0.00035318f, 0.04192660f, -0.04443675f, -0.03727100f, -0.04921819f, -0.05389142f, -0.03681103f, -0.03397328f, 
    -0.02305949f, -0.25502160f, -0.18928079f, 0.02376367f, -0.02363896f, -0.02299058f, -0.04800164f, 0.02732717f, 
    0.06996450f, 0.04727512f, -0.02495600f, -0.30306867f, -0.08931640f, 0.23222674f, 0.03960581f, 0.09948908f, 
    0.01588049f, 0.01619105f, -0.05610888f, -0.10025894f, -0.01753707f, -0.03417654f, -0.02095907f, 0.06825929f, 
    -0.14302874f, 0.10434915f, -0.01523958f, 0.04566106f, 0.09778905f, -0.14027599f, -0.00841295f, -0.00011846f, 
    0.07711701f, 0.14650963f, 0.02902562f, -0.01579613f, -0.01578276f, -0.14874156f, 0.24661922f, -0.01535469f, 
    0.00012493f, 0.04534154f, -0.08050514f, -0.07464955f, -0.03484238f, -0.09757855f, 0.06362874f, -0.21470633f, 
    0.03097077f, -0.03597685f, -0.26818547f, -0.12979361f, -0.00121683f, -0.04178438f, 0.09504888f, 0.02140529f, 
    -0.11060922f, 0.02735701f, 0.05226405f, -0.07756336f, 0.05669542f, 0.01046895f, 0.09618855f, 0.01869419f, 
    0.12372699f, -0.01494029f, 0.08442730f, -0.10384414f, -0.00934324f, -0.09152849f, 0.03141423f, 0.12211469f, 
    0.26094672f, 0.02984229f, -0.02470162f, -0.04729462f, 0.08212325f, 0.09885368f, 0.14959824f, -0.00598690f, 
    0.08876511f, 0.01297280f, 0.10014915f, -0.25556874f, 0.20699409f, -0.04211463f, -0.06169498f, 0.05286243f, 
    0.12987524f, 0.05249641f, 0.10160058f, 0.26013228f, 0.06354626f, 0.23693247f, -0.06126362f, 0.18590082f, 
    -0.17949820f, 0.08186860f, -0.27335876f, 0.04795907f, 0.07467274f, 0.05531048f, 0.13766512f, 0.00032031f, 
    0.02743229f, 0.00320528f, -0.04561624f, 0.13030326f, 0.12437668f, 0.17474778f, 0.12456717f, -0.18966225f, 
    0.06722465f, 0.13482893f, -0.02663494f, 0.17360063f, 0.02402135f, 0.15714180f, 0.06650466f, 0.13181326f, 
    -0.04497818f, 0.13268100f, -0.00682056f, -0.23515055f, 0.10480051f, 0.19027670f, 0.17331040f, 0.14693753f, 
    0.01106682f, 0.01087193f, -0.02901824f, 0.10061572f, -0.26510340f, 0.12260270f, 0.30669636f, 0.06529765f, 
    -0.03070636f, -0.05524027f, -0.08936200f, -0.00193747f, -0.01243426f, 0.10567197f, -0.06344172f, 0.02989065f, 
    -0.01052583f, 0.00707177f, 0.00571127f, -0.02233551f, -0.18394206f, -0.04781327f, -0.09292947f, -0.03491263f, 
    0.03722873f, 0.15288734f, 0.07570015f, 0.16247417f, 0.13260607f, 0.14837553f, -0.07324614f, 0.01730945f, 
    0.14177500f, -0.00082170f, 0.14797065f, -0.09562430f, -0.10544532f, 0.16204794f, 0.04847344f, 0.22138987f, 
    -0.05026703f, -0.06632683f, 0.14426321f, 0.08103253f, 0.11190484f, -0.01898450f, -0.02190141f, 0.11128261f, 
    -0.05483673f, -0.07829814f, -0.00590465f, -0.25793537f, -0.08825266f, 0.04033661f, 0.17211707f, 0.19190390f, 
    -0.05030580f, -0.09758873f, 0.06021385f, -0.00904535f, 0.02231185f, 0.05445401f, 0.19907691f, 0.03455318f, 
    0.56719595f, -0.25091976f, -0.39776516f, -0.13699466f, 0.08286849f, -0.07397501f, -0.06656245f, 0.08758899f, 
    0.09398613f, 0.01751306f, -0.13004631f, -0.02289111f, -0.13915366f, -0.02993155f, -0.03696490f, 0.23771307f, 
    -0.10888360f, 0.10480198f, 0.10165300f, 0.26798147f, 0.04024161f, 0.07190832f, -0.03313925f, -0.07355526f, 
    0.34566173f, 0.29777843f, 0.13076770f, -0.21281980f, 0.12537847f, 0.02076724f, 0.19352466f, 0.00365644f, 
    -0.01117325f, -0.04352614f, 0.03896375f, -0.05315424f, 0.09865157f, -0.14682962f, 0.04281985f, -0.10788269f, 
    0.03070013f, -0.00009600f, -0.03460223f, -0.10277940f, -0.20642041f, -0.03031909f, 0.03747905f, -0.08666133f, 
    -0.23092508f, 0.02472463f, -0.16153526f, -0.04141349f, 0.02759361f, 0.08259483f, 0.19365110f, 0.11016548f, 
    0.03865173f, -0.04312034f, -0.05605759f, 0.04503584f, 0.04492791f, -0.12497216f, 0.02114583f, -0.24373053f, 
    -0.08746701f, 0.13735776f, -0.02504250f, -0.13751939f, -0.12302919f, 0.05955184f, 0.06977466f, -0.12978376f, 
    -0.10880236f, 0.03217728f, 0.15457888f, -0.03333364f, -0.05255837f, -0.03678772f, -0.07404448f, -0.06401619f, 
    -0.24525654f, -0.22918433f, -0.11102212f, -0.34001875f, -0.06060543f, -0.14597043f, -0.05802020f, 0.04780081f, 
    0.13674018f, 0.19315532f, 0.13275529f, 0.13965517f, 0.09956765f, -0.07269640f, 0.13520768f, 0.18767661f, 
    0.42043805f, -0.07420986f, -0.11469595f, 0.15743910f, 0.09356622f, -0.01375483f, 0.00403137f, 0.07091654f, 
    0.15771082f, 0.02664376f, -0.09027198f, 0.04857014f, 0.20119637f, 0.07785430f, -0.16521190f, -0.25712636f, 
    0.06488678f, -0.08716991f, 0.22357140f, -0.00898337f, -0.00358923f, -0.05859542f, -0.00936943f, 0.09283829f, 
    -0.11899225f, 0.20687976f, 0.01347759f, 0.16653442f, 0.00187753f, -0.04191435f, -0.05135772f, -0.04629985f, 
    -0.00181880f, -0.12443174f, -0.11601423f, 0.11357766f, 0.08231197f, 0.24693128f, 0.05129582f, -0.04486716f, 
    0.09483645f, 0.10156464f, -0.06328911f, 0.21326599f, -0.04427699f, -0.05998643f, 0.02929641f, -0.01822758f, 
    -0.23852623f, 0.22472128f, 0.01392608f, -0.05547724f, 0.09980317f, 0.18922387f, 0.12144352f, -0.13169804f, 
    0.08435224f, 0.05750958f, -0.08162510f, 0.01190696f, 0.02037985f, -0.01307167f, 0.04035767f, 0.11674730f, 
    -0.06747641f, -0.02452722f, -0.07198199f, -0.07277585f, 0.00300440f, 0.19665784f, 0.02640889f, 0.20320922f, 
    0.14184798f, 0.09032066f, -0.17872182f, 0.05229224f, 0.07704628f, 0.06358632f, 0.03990836f, 0.20725651f, 
    -0.07358275f, -0.06207592f, 0.01505926f, 0.03814573f, -0.04721212f, -0.33864048f, -0.31375018f, -0.23469786f, 
    0.03473130f, 0.11081138f, -0.05851621f, -0.05787718f, -0.02130495f, -0.05449149f, 0.04138954f, -0.09900083f, 
    0.15987428f, -0.19802435f, -0.00310759f, -0.04375550f, -0.08122405f, 0.01647565f, 0.05980015f, 0.04408704f, 
    -0.05031379f, -0.17558484f, -0.00559844f, -0.03594672f, 0.23191224f, 0.08886086f, 0.21069387f, 0.19221281f, 
    -0.02781732f, -0.02768987f, -0.07065554f, -0.01307931f, 0.06931338f, -0.04686097f, -0.06033900f, 0.04130542f, 
    0.20702419f, 0.10330599f, 0.07296738f, 0.18488918f, 0.03560041f, -0.13779466f, -0.00597415f, -0.02208879f, 
    -0.01849507f, 0.05935496f, -0.05636900f, -0.01419577f, 0.01486608f, 0.00884665f, 0.02776473f, 0.03877088f, 
    0.12863663f, -0.13136630f, 0.09923985f, 0.22340597f, -0.03556379f, 0.02426210f, 0.09258054f, 0.00193049f, 
    0.10039029f, 0.06350431f, -0.02154620f, 0.07224323f, -0.00028583f, -0.16449849f, 0.06078643f, -0.08945539f, 
    -0.10365111f, -0.08960517f, 0.18095128f, 0.12359028f, 0.06000589f, -0.05691857f, 0.45176691f, -0.15552498f, 
    -0.03650776f, -0.03177528f, 0.07306211f, -0.04283047f, -0.04174574f, -0.01708262f, 0.06183642f, -0.00177323f, 
    -0.00261998f, 0.03172983f, -0.03160587f, -0.08664954f, -0.00662921f, -0.12166540f, 0.00855647f, 0.07896078f, 
    -0.03166126f, 0.17145431f, 0.22942151f, 0.11869504f, 0.05089645f, 0.20131992f, -0.08137015f, -0.08838093f, 
    0.11703630f, -0.00208992f, 0.01927014f, 0.08215445f, 0.04232683f, 0.03638541f, 0.13415681f, -0.08295076f, 
    0.50746667f, 0.27324471f, 0.19784357f, 0.16380021f, 0.05751214f, -0.11262349f, -0.15010341f, -0.01211867f, 
    -0.00287088f, 0.02987357f, -0.00828241f, 0.00164379f, -0.36399877f, 0.28849488f, 0.31018528f, 0.03600925f, 
    0.07635618f, 0.29296005f, -0.26389340f, -0.12469662f, -0.11859205f, -0.18973063f, -0.10157193f, -0.12375715f, 
    -0.25468430f, -0.17378147f, -0.23269971f, -0.06923671f, -0.06647631f, 0.01919614f, -0.00871032f, -0.08049644f, 
    -0.00037993f, -0.07162892f, 0.10034183f, 0.12149227f, -0.28932646f, 0.16338180f, 0.15901563f, 0.13272665f, 
    0.03074435f, 0.06043143f, -0.07112779f, -0.00281210f, 0.15205139f, 0.14838977f, -0.11017064f, -0.28197896f, 
    0.14686616f, 0.09266572f, 0.10026087f, 0.05063995f, -0.02463356f, 0.06805146f, 0.01017625f, -0.04208034f, 
    -0.00737891f, -0.12076757f, -0.08840659f, -0.30014110f, 0.12706396f, 0.39298427f, 0.29994705f, 0.01409155f, 
    -0.09989867f, 0.16707939f, 0.18780589f, -0.05434938f, 0.05359291f, 0.01410667f, 0.00115642f, -0.04431983f, 
    -0.18113309f, -0.18074247f, -0.12317921f, -0.07669020f, -0.01388506f, 0.06582718f, -0.13889022f, 0.07794280f, 
    0.07644699f, -0.01457477f, 0.16191882f, 0.11360645f, 0.19001269f, 0.20095798f, -0.08734711f, 0.10451120f, 
    -0.01343407f, 0.01012046f, 0.00765928f, -0.00420658f, -0.07870718f, 0.08084323f, -0.02843411f, -0.16317868f, 
    0.60001403f, -0.60986984f, -0.25765839f, -0.10399902f, -0.07036433f, -0.12307516f, -0.06938089f, 0.01074504f, 
    0.06011090f, -0.08554795f, -0.06177633f, 0.05031076f, 0.05023101f, -0.06437541f, -0.06311085f, 0.12658615f, 
    0.03823755f, -0.05041946f, -0.03392021f, -0.01782694f, 0.10376171f, -0.10253675f, 0.12002701f, 0.08341026f, 
    0.14181668f, -0.05599134f, 0.07302144f, -0.18889435f, 0.13688591f, 0.08194304f, -0.03288528f, -0.05654272f, 
    -0.11880461f, -0.04837009f, -0.10037663f, -0.06137058f, 0.18700488f, -0.04903375f, 0.18197978f, 0.12589845f, 
    -0.04379161f, -0.16440280f, 0.05461209f, 0.00719530f, -0.14144516f, 0.20286681f, 0.26058659f, 0.01520878f, 
    0.23394075f, 0.18580963f, -0.02830730f, 0.09047920f, -0.18987571f, -0.02181908f, -0.10135520f, -0.01519247f, 
    -0.08234690f, 0.04289760f, -0.01712304f, 0.03294840f, -0.23912323f, 0.21116184f, -0.01471999f, -0.10208999f, 
    -0.09054548f, 0.06103300f, 0.03680792f, 0.14037208f, -0.05887728f, 0.06522165f, -0.04799175f, -0.08075539f, 
    0.28282237f, 0.06959018f, 0.14754930f, 0.09086200f, -0.01717797f, 0.01940714f, 0.06852631f, -0.00040257f, 
    -0.05284622f, -0.14117849f, 0.12585415f, 0.12553783f, 0.09598218f, 0.04318539f, -0.20912826f, -0.10020017f, 
    0.10233863f, 0.12211945f, 0.08414552f, -0.11696757f, 0.00095743f, -0.02895680f, -0.01921028f, 0.00507392f, 
    -0.23656796f, -0.11163575f, -0.23297344f, -0.21555495f, 0.01783217f, -0.02241672f, -0.07918233f, -0.01127211f, 
    -0.02820649f, 0.00490956f, 0.03295803f, -0.05314910f, -0.03790804f, -0.31829706f, -0.07012402f, 0.02286453f, 
    -0.03316848f, 0.04602200f, -0.00056817f, -0.24790193f, -0.18776380f, 0.07527538f, -0.04905186f, 0.05381150f, 
    0.09424343f, 0.07056549f, 0.02987554f, 0.22311293f, -0.02538632f, -0.03043075f, -0.03286388f, -0.04545540f, 
    0.06143797f, 0.03622728f, 0.01372439f, 0.02836508f, 0.05002288f, 0.32784846f, 0.11125191f, -0.05173830f, 
    0.11053938f, 0.03906032f, -0.00049915f, 0.08033235f, -0.01004131f, -0.01843177f, 0.05066999f, 0.00500911f, 
    0.45523882f, 0.19686827f, 0.30968049f, 0.07320564f, -0.24999177f, -0.03786324f, -0.00694491f, 0.19618124f, 
    -0.04753045f, -0.02000875f, -0.03259797f, -0.08892835f, 0.15092145f, 0.20931849f, 0.07490582f, 0.21335074f, 
    0.02470691f, 0.07562421f, -0.03232552f, 0.01928903f, -0.05635643f, -0.01715326f, -0.11335151f, -0.20986982f, 
    0.17177168f, 0.07548046f, 0.17996989f, -0.03276742f, -0.00164589f, -0.30258983f, 0.00442626f, 0.12161133f, 
    -0.00885701f, 0.06105587f, 0.10391904f, -0.03325999f, -0.16659060f, -0.33160332f, -0.14065008f, -0.08413291f, 
    0.06273884f, -0.04321012f, 0.00294645f, -0.08309997f, -0.11882885f, -0.00219466f, 0.02920013f, -0.05830229f, 
    -0.00897061f, -0.05785951f, 0.04676002f, 0.07112244f, -0.03776017f, 0.08054366f, 0.13872957f, -0.12610514f, 
    0.01921225f, 0.10512496f, -0.02443963f, 0.28492576f, -0.34724021f, -0.31969568f, 0.14311124f, 0.14433652f, 
    -0.09522379f, -0.02613669f, -0.31400147f, 0.07807081f, 0.08618716f, -0.17952023f, 0.01444696f, 0.00914866f, 
    -0.18983507f, 0.12945837f, 0.15429619f, 0.03471317f, 0.05479464f, -0.01200055f, -0.18676212f, -0.03912476f, 
    0.04401749f, -0.18472463f, -0.07742152f, -0.01404852f, -0.26033536f, 0.12090056f, -0.16850093f, -0.10665194f, 
    0.01163275f, 0.10724951f, 0.06118561f, -0.15029936f, 0.11105904f, 0.10316522f, -0.18963774f, 0.16827337f, 
    0.19960269f, -0.03825603f, -0.05965747f, 0.18797952f, 0.12013792f, -0.03494674f, 0.11553174f, 0.13010372f, 
    0.13177705f, 0.07353020f, 0.12947680f, 0.24369556f, -0.28340685f, -0.34785146f, 0.15374058f, -0.02356161f, 
    -0.08953030f, 0.11326469f, -0.20772083f, -0.13824198f, -0.09156752f, -0.13263632f, -0.09411152f, -0.01437714f, 
    0.02387769f, -0.02695611f, 0.17063217f, 0.16340056f, 0.06054973f, 0.06890369f, 0.02741638f, -0.03268047f, 
    -0.00992180f, 0.09109493f, 0.04813811f, 0.18398638f, -0.27020988f, 0.14834966f, -0.27680048f, -0.41751567f, 
    -0.11926292f, -0.13158242f, 0.06823207f, 0.07069924f, 0.06257760f, 0.07753236f, -0.12530158f, -0.03429683f, 
    -0.12359342f, 0.37258521f, 0.55421811f, 0.10968816f, 0.20173728f, 0.11350746f, -0.23308779f, 0.16837715f, 
    0.05632585f, -0.16462180f, -0.11094873f, -0.09878064f, 0.12296598f, 0.06170658f, 0.06554328f, 0.08963800f, 
    -0.07583835f, 0.06397995f, -0.04163509f, -0.02341404f, -0.00670971f, -0.03150146f, -0.15229414f, -0.00839397f, 
    0.14481831f, 0.20298935f, 0.11759210f, 0.12997764f, 0.16439624f, 0.13154525f, 0.03159523f, -0.00637566f, 
    -0.01039210f, -0.03395441f, 0.02498051f, 0.13865691f, 0.30383655f, -0.25035185f, -0.24713516f, 0.02706153f, 
    0.12544765f, -0.03500999f, -0.08711877f, -0.04562722f, 0.06297330f, -0.02305647f, -0.11493787f, 0.03350619f, 
    0.04509684f, -0.17891818f, -0.14139023f, -0.07272479f, 0.12419323f, 0.07336840f, -0.16148064f, -0.03858600f, 
    -0.13969193f, -0.14511123f, -0.10428851f, -0.20825325f, 0.12984073f, 0.06865105f, 0.02966464f, 0.13596845f, 
    0.02976163f, 0.05724572f, -0.04960398f, -0.01456029f, -0.01606535f, -0.16503599f, 0.07695815f, -0.12481782f, 
    0.00419626f, 0.05057790f, -0.13767600f, 0.23829265f, 0.18854019f, 0.06397760f, -0.00243962f, -0.02079360f, 
    0.12646502f, 0.06817099f, -0.03343748f, 0.17912991f, 0.28492090f, 0.04018228f, -0.31657496f, -0.29188928f, 
    -0.06185073f, -0.03184070f, -0.13041976f, 0.09250871f, 0.05570380f, -0.08481286f, -0.08835448f, -0.04389399f, 
    -0.25641632f, 0.28148949f, 0.05305445f, -0.19976756f, -0.07877397f, 0.05932752f, 0.10346843f, -0.06405556f, 
    0.02258225f, 0.09984608f, -0.06423748f, 0.19490799f, 0.20117886f, 0.24652505f, -0.06072723f, 0.13878049f, 
    0.22843181f, -0.16699415f, -0.17505325f, -0.14127165f, 0.19761559f, 0.01989571f, -0.00325910f, 0.06383541f, 
    0.04500562f, 0.09245053f, -0.00222981f, 0.04058434f, 0.04909633f, 0.06134559f, -0.00948312f, 0.08685932f, 
    -0.00154966f, 0.11133324f, -0.10012384f, 0.08249258f, -0.10626730f, -0.05204986f, -0.19201303f, 0.14088483f, 
    -0.34979531f, -0.06537800f, 0.11891589f, -0.06053221f, 0.10817364f, 0.08953074f, -0.00997594f, 0.18558685f, 
    -0.52017111f, 0.22117327f, 0.11441916f, -0.04808064f, 0.08646229f, -0.02092122f, -0.23090635f, -0.00142445f, 
    -0.04804263f, 0.00105811f, -0.09708527f, -0.10576050f, 0.01879677f, -0.04399239f, 0.02338150f, -0.01272205f, 
    0.05981073f, 0.05851838f, -0.07000282f, 0.08941084f, 0.04613276f, -0.02084757f, 0.09827085f, 0.16189444f, 
    -0.08925726f, -0.11112466f, -0.12138382f, -0.06058927f, 0.16929546f, -0.08520880f, -0.09624010f, 0.01621961f, 
    0.08815845f, 0.19696999f, -0.01020467f, 0.20441613f, 0.18635997f, 0.16212380f, -0.03588855f, 0.20041978f, 
    0.11016081f, -0.00448402f, 0.01795348f, -0.20329072f, -0.18749820f, -0.16952789f, -0.14805831f, -0.14247216f, 
    0.02773846f, 0.52738565f, 0.24467210f, 0.08856185f, 0.03024942f, 0.02301861f, -0.03535313f, 0.11373300f, 
    0.11237412f, 0.04331861f, 0.01205147f, -0.01789316f, 0.29250982f, -0.19111905f, -0.03711056f, -0.19594869f, 
    -0.00840409f, 0.07093143f, 0.20273061f, 0.03637505f, -0.06155827f, 0.04550568f, -0.03089290f, -0.13811734f, 
    -0.42135593f, -0.18020503f, 0.22973408f, -0.08909260f, -0.05094542f, -0.08848134f, -0.15369228f, -0.18151230f, 
    -0.20843305f, -0.10159802f, -0.02967000f, -0.02032987f, 0.23718010f, 0.05543838f, 0.01553376f, 0.23645735f, 
    0.16229820f, 0.08083943f, 0.02247412f, 0.04987210f, 0.28318441f, 0.08478152f, 0.02923792f, 0.18733102f, 
    -0.22174786f, -0.08717117f, -0.01966494f, 0.17319307f, -0.12321423f, -0.16129045f, 0.15431175f, -0.17961611f, 
    -0.26563630f, -0.17077909f, -0.01769945f, -0.07662982f, 0.19417123f, -0.11140038f, -0.01787541f, -0.04226337f, 
    0.25935727f, -0.05859613f, -0.11343803f, -0.01718935f, -0.07259637f, -0.16700098f, -0.07575984f, -0.04972260f, 
    0.03569040f, 0.19950353f, 0.06619077f, 0.08356708f, 0.06342079f, 0.07664497f, -0.09047761f, -0.01302304f, 
    0.01474985f, -0.03568604f, 0.02982127f, 0.09133374f, 0.31691214f, 0.19401355f, 0.07611316f, 0.40033260f, 
    -0.05518281f, 0.02470697f, 0.22220281f, -0.08257424f, 0.03744750f, 0.03972598f, 0.07495216f, 0.04022750f, 
    0.14363071f, 0.00673231f, 0.10212976f, 0.08742879f, 0.01416630f, 0.02528021f, -0.02696273f, -0.04063380f, 
    0.08041839f, 0.04654564f, 0.01056780f, 0.31930783f, -0.49851951f, -0.47832546f, -0.42557362f, -0.01204911f, 
    0.08719330f, 0.23670664f, -0.05096094f, -0.03542348f, 0.08922514f, -0.07461677f, 0.05947424f, 0.10582947f, 
    0.04942883f, -0.31722534f, -0.29224196f, -0.20699458f, 0.21867545f, 0.12583071f, -0.07834785f, -0.08526152f, 
    0.09327576f, 0.04151937f, -0.06434502f, -0.07215601f, -0.17663777f, 0.10552815f, 0.07854667f, -0.16572705f, 
    -0.01940812f, 0.07473772f, -0.19463308f, -0.18227179f, 0.01266741f, -0.01062334f, 0.10017041f, 0.14858985f, 
    0.17954206f, -0.18922302f, 0.13147831f, 0.04550919f, 0.12402128f, -0.05593764f, -0.02230142f, 0.12691694f, 
    0.18301913f, -0.01284327f, -0.02366422f, 0.10716495f, -0.45765805f, -0.28762823f, -0.11739470f, -0.00254514f, 
    -0.00078874f, 0.16216995f, -0.08327078f, -0.08805761f, -0.05074681f, -0.07181871f, -0.01410287f, 0.04591519f, 
    0.26938087f, 0.12076224f, 0.21416947f, 0.13933101f, 0.10590451f, 0.09397717f, 0.06173383f, -0.06908008f, 
    0.03888816f, -0.06204846f, 0.05642774f, 0.12730482f, -0.11112344f, -0.02207758f, -0.05619190f, -0.19697762f, 
    -0.08033108f, 0.03651799f, 0.02024233f, 0.09496505f, 0.04859751f, -0.06791978f, -0.07644294f, 0.08255927f, 
    -0.19240417f, 0.19072795f, -0.09638353f, -0.00859001f, 0.14622784f, 0.18222855f, -0.06979242f, 0.08511683f, 
    0.14715150f, -0.10182667f, -0.03245938f, -0.15796541f, -0.04477311f, 0.09298955f, 0.15318449f, 0.09827089f, 
    0.15518509f, -0.02805371f, 0.04861815f, -0.02368255f, -0.10485159f, 0.00679537f, -0.12298656f, 0.09366628f, 
    0.18887070f, 0.36459997f, 0.22798941f, 0.34486997f, 0.13581374f, 0.07155516f, 0.07581442f, 0.00231377f, 
    0.01040636f, -0.00602997f, -0.09818453f, 0.10406283f, -0.21975942f, -0.20356414f, -0.32460919f, 0.14830133f, 
    0.18510070f, -0.13409540f, -0.12770151f, -0.07260438f, 0.11869952f, 0.07484473f, -0.10028072f, 0.04611574f, 
    0.08078633f, -0.17862828f, -0.11498892f, -0.03861808f, 0.07816870f, 0.07942433f, 0.02243955f, -0.01227991f, 
    0.04138679f, -0.07271681f, -0.13194399f, -0.19444111f, 0.03536840f, 0.11254858f, 0.16763043f, 0.27451423f, 
    0.08644633f, 0.13638775f, -0.00640488f, 0.18950570f, -0.04586511f, -0.00501364f, 0.06831637f, -0.09024182f, 
    0.07283907f, 0.15980013f, 0.08150487f, 0.05854264f, 0.17913228f, -0.00604259f, -0.02194386f, -0.00777625f, 
    0.11649460f, 0.05502631f, 0.11736794f, 0.17570910f, -0.04446691f, -0.03047118f, -0.24530934f, -0.03784045f, 
    0.07833382f, 0.02648412f, 0.00799321f, -0.01244470f, -0.05918304f, -0.02493248f, -0.09002940f, -0.03191928f, 
    0.30755231f, 0.20677814f, 0.04249492f, 0.05961618f, -0.04499309f, -0.06757279f, -0.01636626f, 0.00779085f, 
    0.07279707f, 0.02270775f, -0.09900612f, 0.05133075f, 0.21301953f, 0.12123585f, -0.26241314f, 0.21799321f, 
    0.25285548f, -0.07650069f, -0.06900620f, -0.10325376f, 0.07403914f, 0.00495707f, -0.11156284f, 0.13867433f, 
    0.15720330f, 0.03370797f, 0.07780741f, 0.07566191f, -0.04499783f, 0.06222108f, -0.05864431f, 0.01080440f, 
    0.09589272f, 0.08154435f, -0.07180601f, 0.03624093f, 0.01053475f, -0.17056476f, -0.07924449f, -0.19788703f, 
    -0.21332626f, -0.04201983f, -0.05888594f, -0.06405316f, 0.07206763f, -0.07601724f, 0.13584462f, 0.09637436f, 
    -0.15277576f, -0.06857625f, -0.33101383f, 0.02660386f, 0.14530917f, 0.02573318f, -0.04384673f, -0.09838410f, 
    0.01006419f, -0.05580085f, -0.07798602f, 0.01097920f, 0.01237800f, 0.03158455f, -0.16820197f, 0.14647856f, 
    -0.05154944f, -0.00089667f, -0.07220819f, 0.11556499f, 0.20273168f, 0.01281738f, 0.15181434f, 0.02750753f, 
    -0.06323138f, -0.21190645f, -0.06190227f, -0.18499516f, 0.10931749f, -0.03314949f, -0.10973477f, -0.00882007f, 
    -0.09620944f, 0.05265671f, 0.13918139f, 0.27394846f, 0.33117765f, 0.27922568f, 0.19266678f, 0.10070021f, 
    -0.00573776f, 0.11727562f, 0.18516788f, 0.08284516f, -0.13833097f, -0.07963397f, -0.02152300f, -0.16923974f, 
    0.04135230f, 0.33506081f, 0.21003276f, 0.01122965f, 0.05381297f, 0.07589976f, 0.13115509f, 0.04357773f, 
    0.06711079f, 0.03462939f, 0.01591760f, -0.07838731f, -0.00197736f, -0.15613793f, 0.32075763f, 0.04366345f, 
    -0.14598145f, 0.04639986f, 0.14422990f, 0.07279383f, 0.03126610f, 0.07721055f, 0.04438471f, -0.14119120f, 
    -0.43596655f, -0.48562360f, -0.09055248f, -0.10978319f, 0.03077701f, 0.08195058f, -0.02054305f, -0.14757605f, 
    -0.12479433f, -0.02589200f, 0.02605400f, -0.06820129f, 0.08510397f, 0.17927395f, 0.12176098f, 0.26065385f, 
    0.01832656f, 0.10388393f, -0.12749705f, 0.15243371f, 0.09931551f, 0.17458718f, 0.06097116f, 0.03573155f, 
    -0.28850630f, -0.35353175f, -0.06014849f, -0.27275866f, -0.04493340f, 0.10870153f, 0.13171495f, -0.16546072f, 
    -0.15614583f, -0.06856960f, -0.02085225f, -0.05940872f, 0.09781995f, -0.34642830f, -0.07564050f, -0.17595178f, 
    0.12072529f, 0.03416651f, 0.02169987f, -0.03978254f, 0.12576984f, -0.05394199f, 0.00043330f, -0.02766063f, 
    0.16286258f, 0.19208078f, -0.15345961f, -0.04347583f, 0.10715668f, 0.09711783f, -0.06418979f, -0.08243030f, 
    0.03146449f, 0.02413010f, 0.04822506f, 0.01890219f, -0.02726965f, 0.35702500f, 0.25132391f, 0.34172550f, 
    -0.12382039f, -0.07111467f, 0.05237654f, 0.11290001f, -0.00682095f, 0.09595534f, -0.02203520f, -0.04361496f, 
    0.18923204f, 0.09088916f, 0.31586468f, -0.01903141f, -0.05014299f, -0.05034910f, 0.01041465f, -0.07700885f, 
    -0.04325995f, 0.25390205f, 0.07896531f, 0.10215344f, 0.11180524f, 0.12428950f, -0.01455403f, 0.13293898f, 
    -0.06842203f, 0.07258851f, 0.04903372f, -0.00814070f, 0.06923120f, 0.03075754f, -0.07944727f, 0.03089545f, 
    0.56567067f, -0.04922874f, -0.01013793f, -0.16003843f, 0.07124122f, 0.12409555f, -0.01560109f, 0.02128503f, 
    0.07959893f, -0.01977297f, -0.03043601f, -0.06312715f, 0.03428034f, 0.12528059f, 0.09131128f, -0.16523047f, 
    -0.07853535f, -0.01608077f, 0.03687752f, -0.09420664f, 0.17238556f, -0.05678669f, -0.02013437f, 0.17892280f, 
    -0.05354597f, -0.20930722f, 0.05666282f, 0.10790008f, -0.05060351f, 0.21563172f, 0.03571839f, 0.02690509f, 
    0.35299602f, 0.06269066f, -0.02876335f, 0.11195230f, 0.03849130f, 0.13019951f, 0.13516402f, -0.25465694f, 
    -0.09137923f, 0.17197506f, 0.14825356f, 0.11795904f, 0.01529138f, 0.00811693f, -0.08029164f, -0.11231881f, 
    0.11516352f, 0.02832866f, -0.06707540f, 0.03770155f, 0.19799730f, -0.02685909f, 0.05710324f, -0.02483134f, 
    0.02461658f, 0.01924484f, 0.21772264f, 0.06418758f, -0.00944818f, -0.22805470f, -0.11807702f, 0.03025522f, 
    0.15248650f, -0.07230955f, -0.02854056f, 0.00258590f, 0.19469471f, 0.01242926f, 0.09568606f, -0.16651177f, 
    0.14430560f, -0.12283376f, -0.09294473f, -0.36997467f, -0.21951273f, 0.01838612f, 0.15590099f, 0.15961514f, 
    -0.09703016f, -0.10311032f, -0.03723338f, -0.06629965f, -0.39424825f, -0.07830332f, -0.24019541f, -0.09777645f, 
    -0.01970559f, -0.01574164f, -0.18545389f, -0.02837710f, -0.05221374f, 0.13237652f, -0.10440039f, 0.08554485f, 
    -0.05287088f, 0.23369631f, 0.22574994f, 0.30246043f, 0.16387187f, -0.00293724f, -0.08027876f, 0.01480012f, 
    -0.20981552f, -0.03072679f, -0.09106861f, -0.03925454f, -0.07344427f, 0.12868933f, -0.04331244f, 0.13072056f, 
    0.06200087f, -0.02456261f, 0.06290292f, -0.08490727f, 0.24682155f, 0.06160281f, 0.10381366f, -0.05336860f, 
    0.01707804f, 0.08658548f, 0.12829712f, 0.16766816f, 0.08237864f, 0.05649935f, 0.08208223f, -0.05543275f, 
    -0.02014123f, -0.05122739f, -0.00502488f, -0.04876959f, -0.02564784f, -0.09037864f, 0.02212738f, -0.01374506f, 
    -0.18511656f, -0.06461164f, 0.00263778f, 0.05223229f, -0.04356744f, -0.14864397f, 0.04067544f, -0.11085752f, 
    0.11689975f, 0.13088252f, 0.35413033f, -0.20733185f, 0.04847644f, 0.00496555f, -0.01252148f, 0.07090887f, 
    -0.02090166f, 0.24238425f, -0.08694491f, 0.18852624f, 0.09882127f, 0.14240524f, 0.08410979f, 0.15751787f, 
    0.10313078f, 0.06681118f, -0.04061072f, 0.06086332f, 0.19152823f, 0.08529824f, -0.21601363f, 0.05847980f, 
    0.64886022f, 0.12155479f, 0.39927900f, 0.12020361f, -0.04436760f, -0.20133516f, -0.13170698f, -0.05918730f, 
    -0.02842317f, 0.11675087f, 0.03820365f, 0.15718043f, 0.22579373f, -0.12376499f, 0.07446068f, -0.36536431f, 
    0.12564428f, -0.06545385f, 0.06821144f, -0.03322035f, 0.06171455f, -0.14539984f, 0.07654066f, 0.26875198f, 
    -0.10327671f, -0.10841494f, -0.23507924f, 0.13363141f, -0.09703337f, -0.05930967f, -0.08974347f, -0.24756131f, 
    0.14417763f, 0.13091160f, 0.28026351f, -0.01395675f, -0.04109902f, 0.02693108f, 0.10713571f, 0.17219366f, 
    -0.04770735f, -0.03299850f, 0.00083436f, -0.00152305f, 0.19157064f, 0.15052108f, 0.06630401f, 0.17189875f, 
    0.28632963f, 0.06896692f, -0.03707962f, 0.01604414f, 0.11660997f, 0.15010750f, 0.15920982f, -0.04233314f, 
    -0.14844182f, -0.06794621f, -0.09724372f, -0.02065130f, -0.17908049f, 0.29463279f, -0.31855908f, 0.16376011f, 
    0.09762480f, -0.09896518f, 0.05116105f, -0.02641533f, -0.10208222f, -0.05319893f, 0.05200025f, -0.00529184f, 
    0.12353310f, -0.00212116f, 0.00550260f, 0.09825296f, -0.07449781f, 0.02572441f, 0.05195216f, -0.04035349f, 
    0.06388909f, 0.17465162f, 0.11188529f, 0.50232160f, 0.17727911f, -0.00851635f, 0.25499910f, -0.12400149f, 
    0.06714089f, 0.03549489f, 0.02562391f, 0.18809839f, -0.17055559f, -0.07052017f, -0.07403553f, -0.13490322f, 
    0.09159118f, 0.03765224f, 0.23638867f, -0.43061638f, -0.01501960f, -0.12664938f, 0.08951006f, 0.03762690f, 
    0.05677810f, -0.04505745f, 0.12816937f, -0.15427059f, -0.37508041f, -0.32287291f, 0.24469122f, 0.25542021f, 
    0.06029934f, 0.08255730f, -0.08527477f, 0.15445289f, -0.03277328f, -0.11764104f, 0.04097140f, -0.08058989f, 
    0.26684821f, 0.07016626f, 0.10959454f, 0.19961692f, -0.06624038f, 0.05197738f, 0.09204795f, -0.08522086f, 
    -0.03414367f, 0.09864692f, 0.05409852f, -0.14586350f, -0.15100284f, -0.04241326f, -0.00586754f, -0.08154126f, 
    -0.19735587f, -0.03135494f, -0.25682658f, -0.25319502f, 0.07050911f, 0.04014460f, -0.12552671f, 0.09896357f, 
    0.34090883f, -0.03194890f, -0.03830358f, 0.02590476f, -0.02244394f, -0.01497474f, 0.07469841f, -0.00174618f, 
    -0.16208763f, -0.12698060f, 0.03941905f, -0.12921360f, 0.12125004f, 0.10132296f, 0.07227386f, 0.19366674f, 
    0.06059153f, 0.02837163f, -0.04439877f, 0.04016272f, -0.06156180f, 0.00651061f, -0.05004737f, -0.13333912f, 
    0.02560437f, -0.04482800f, -0.02485507f, -0.11223183f, -0.02371389f, -0.08165042f, 0.21600781f, 0.04026038f, 
    0.08622122f, 0.06615034f, -0.15535785f, 0.12869206f, -0.29008365f, 0.33741099f, 0.20380978f, 0.12704527f, 
    -0.13300286f, -0.09303560f, -0.12117842f, -0.06673578f, 0.00198453f, 0.06751011f, 0.08856422f, 0.15731497f, 
    0.03432281f, 0.30294335f, 0.03908600f, 0.01895925f, -0.02915756f, 0.00127037f, 0.03980523f, -0.00957615f, 
    0.12928358f, 0.11258557f, 0.13547638f, 0.18185243f, -0.11085276f, -0.13620943f, -0.18052402f, -0.18837385f, 
    -0.04283045f, -0.04767485f, 0.03189809f, -0.05077165f, -0.08627893f, -0.02368548f, -0.05869270f, -0.14620800f, 
    -0.06442500f, -0.11604636f, -0.09262661f, -0.10123324f, 0.03995876f, 0.11524094f, 0.02624719f, 0.00146564f, 
    0.03036016f, -0.12383112f, -0.01632262f, -0.00517717f, 0.11391042f, -0.02440024f, -0.20571966f, 0.03889601f, 
    0.00289224f, 0.08854301f, 0.02469934f, 0.03467933f, 0.24725817f, 0.13915254f, 0.17360845f, 0.17042391f, 
    -0.15985467f, 0.02159821f, 0.18456753f, -0.08628026f, 0.16213635f, 0.22625004f, 0.06400508f, 0.16846478f, 
    0.08379915f, 0.21440330f, 0.00475513f, -0.01893712f, 0.21115117f, 0.24420634f, -0.33541542f, 0.29254946f, 
    0.11268878f, 0.06086359f, 0.06403448f, 0.10628075f, 0.07124235f, 0.05481511f, 0.04786134f, -0.01695615f, 
    -0.22591063f, -0.03058385f, 0.15041031f, 0.09609605f, -0.04349452f, 0.12877072f, 0.02247953f, 0.10639132f, 
    0.10818809f, 0.05969291f, -0.09072330f, 0.15586013f, 0.08884928f, -0.01743245f, 0.34079406f, 0.21671677f, 
    -0.06181485f, 0.22374582f, 0.02825580f, -0.13249908f, 0.03109610f, -0.01301524f, 0.05900159f, 0.26935005f, 
    0.00812169f, -0.02534720f, 0.08317649f, 0.27183542f, 0.04597608f, 0.21921556f, 0.29214105f, 0.13171776f, 
    0.04892466f, -0.00770851f, 0.05695452f, -0.03091831f, 0.18472977f, -0.11922161f, -0.10933693f, 0.22800007f, 
    0.08331475f, -0.04456810f, 0.27682793f, 0.10317589f, 0.10507391f, -0.05804098f, 0.23716173f, -0.03242736f, 
    0.19794828f, -0.15954401f, 0.16410625f, 0.22000791f, 0.02239968f, -0.17598534f, -0.07281902f, 0.06350685f, 
    0.08917772f, 0.15398833f, 0.18027157f, -0.01083092f, 0.32612804f, 0.13608770f, -0.18132119f, -0.05715190f, 
    -0.11943866f, -0.01441804f, 0.11554687f, 0.00561110f, -0.00383095f, -0.08149958f, 0.22784485f, 0.25633687f, 
    -0.09000919f, -0.09631911f, -0.08699957f, -0.07530976f, -0.00973736f, -0.08015018f, -0.11943851f, 0.02749953f, 
    -0.05652365f, -0.00751890f, -0.11689080f, 0.04247709f, -0.10326101f, -0.19084038f, -0.09243517f, -0.01956714f, 
    0.06976974f, 0.00962627f, -0.00135931f, 0.17530984f, 0.06989266f, -0.03939222f, -0.05345864f, -0.03492051f, 
    0.16584347f, 0.22155902f, 0.07793178f, 0.10615171f, -0.06088180f, -0.01593029f, 0.21380940f, -0.04491001f, 
    0.21132897f, 0.03509420f, 0.17398985f, 0.22631882f, 0.04289506f, -0.08598211f, 0.15970038f, -0.06183311f, 
    0.00367612f, -0.01051021f, -0.09558009f, 0.01974507f, 0.20202941f, -0.03776544f, 0.18751690f, 0.30508301f, 
    -0.64701778f, 0.22867210f, 0.46863586f, 0.12139080f, 0.05016304f, 0.11454079f, 0.01959440f, -0.00114215f, 
    0.00022690f, 0.07868161f, 0.35034320f, 0.05909666f, 0.07699864f, 0.28827417f, 0.24269538f, -0.06261923f, 
    -0.04542593f, 0.12294932f, 0.10674197f, -0.12125315f, 0.07081717f, 0.19744492f, 0.08701565f, 0.07749750f, 
    -0.22847559f, -0.21438631f, 0.02517511f, 0.28993443f, 0.02084152f, 0.04526903f, 0.08975381f, 0.17641814f, 
    0.00675708f, 0.17434469f, 0.16313609f, 0.18579786f, -0.08344852f, 0.14206797f, 0.04223655f, -0.00136680f, 
    0.12241648f, 0.13232222f, -0.03800234f, 0.06171869f, 0.17935455f, 0.00316333f, 0.12137024f, -0.00105098f, 
    0.02190052f, -0.22177096f, 0.06566301f, -0.05032769f, 0.10908128f, 0.20474003f, 0.04805860f, -0.02170598f, 
    0.05165046f, -0.14193317f, -0.06912556f, -0.05442649f, 0.11641890f, -0.31027916f, 0.14328893f, 0.02553083f, 
    0.06386697f, 0.04661210f, 0.16092637f, 0.13443963f, 0.30251393f, 0.04425486f, -0.02789119f, 0.13537650f, 
    0.03272273f, 0.05074090f, 0.01111089f, 0.01712522f, -0.00083854f, 0.00061222f, 0.05890756f, 0.06367416f, 
    0.34761170f, 0.24307834f, 0.21318725f, 0.11420126f, -0.14032789f, 0.09610362f, 0.11069073f, 0.10231503f, 
    -0.00038782f, -0.10220470f, -0.03916197f, 0.14328662f, 0.10651613f, 0.12256767f, -0.00376075f, -0.04390311f, 
    -0.21282421f, -0.00270784f, -0.03381148f, 0.11114372f, 0.09104838f, -0.01150947f, 0.12159385f, 0.15231726f, 
    -0.08264933f, 0.08358947f, 0.13534607f, 0.25393307f, -0.20574349f, 0.25574782f, 0.05951075f, 0.08225381f, 
    0.12632911f, 0.07396791f, -0.05987034f, 0.20769697f, -0.00699390f, 0.06029806f, -0.02594345f, -0.01513383f, 
    0.05855784f, -0.10594140f, 0.04866975f, -0.15346752f, 0.02641862f, -0.04940476f, -0.01207448f, 0.03541676f, 
    0.01020540f, 0.01782680f, -0.06768313f, 0.01081842f, -0.12966312f, -0.34545478f, -0.04453840f, 0.08291408f, 
    0.05613780f, 0.09105381f, 0.24279487f, 0.04992459f, 0.02551893f, 0.08005653f, 0.04732447f, 0.02010730f, 
    -0.09222427f, -0.18232308f, -0.08052697f, 0.02226141f, 0.23860696f, 0.00131060f, 0.07691562f, 0.13536203f, 
    0.03631699f, 0.04097842f, -0.06952891f, -0.02299252f, -0.08808033f, -0.08997474f, -0.07041279f, -0.09451555f, 
    -0.03482566f, -0.06903243f, 0.01509902f, -0.08383520f, 0.07309922f, -0.15438235f, -0.03005746f, -0.00510588f, 
    -0.09222838f, 0.02270393f, 0.20321755f, 0.16316897f, 0.02400166f, 0.22977504f, 0.12228779f, -0.04058298f, 
    0.18583715f, 0.09160642f, 0.02232209f, 0.05784813f, 0.19908220f, 0.15266596f, 0.18290581f, 0.11134944f, 
    0.01560614f, -0.10874930f, 0.00874533f, 0.02297611f, 0.09116931f, 0.16531153f, 0.00318177f, 0.18668917f, 
    0.01755039f, -0.05662556f, -0.00421709f, -0.04838981f, -0.05233887f, 0.02207563f, 0.00652526f, -0.02963258f, 
    -0.02428491f, -0.05529858f, -0.01589994f, -0.05380297f, 0.03760795f, -0.05619044f, -0.04758039f, -0.01765312f, 
    -0.00457225f, 0.01671658f, 0.03217015f, -0.05087696f, -0.00580872f, 0.01880718f, -0.02699851f, 0.00641724f, 
    0.04152173f, -0.04406427f, 0.02262254f, -0.03777646f, -0.02787642f, -0.01968876f, 0.02589155f, -0.04331308f, 
    -0.02601925f, -0.00812703f, 0.00427446f, 0.00656032f, -0.05159738f, -0.00184767f, -0.05819455f, -0.00093488f, 
    -0.04085802f, 0.00937637f, -0.00209597f, -0.01860739f, -0.01254047f, -0.02725170f, -0.03061512f, -0.01445918f, 
    0.01532294f, 0.04329107f, -0.04520193f, -0.03585206f, -0.04322138f, -0.03232897f, -0.04843853f, -0.04344803f, 
    0.03874404f, -0.03543321f, -0.01217251f, -0.00292768f, -0.04916687f, -0.02525154f, -0.04500535f, 0.00317057f, 
    0.00143406f, -0.03803314f, -0.03454901f, -0.03189953f, 0.00477035f, -0.01987262f, -0.04146012f, -0.01065183f, 
    -0.01436909f, 0.02446546f, -0.03707969f, 0.01015457f, -0.03625918f, -0.03498960f, -0.02185557f, 0.02993962f, 
    0.02509671f, -0.05241073f, -0.03008556f, -0.03320993f, -0.04771074f, 0.02886995f, 0.02734235f, -0.01575211f, 
    0.02999941f, -0.05336927f, -0.02050126f, 0.03318161f, 0.01118535f, 0.03462126f, -0.01926993f, 0.03609540f, 
    -0.05124234f, 0.03586239f, 0.01585233f, -0.01489316f, 0.02431473f, -0.02573818f, -0.03291522f, -0.05791847f, 
    -0.03886670f, -0.03359318f, 0.00958867f, -0.01685794f, -0.05019127f, -0.03391901f, -0.04782816f, -0.04492797f, 
    -0.00330333f, 0.02617525f, -0.02164978f, -0.02724224f, 0.01204544f, -0.04514508f, -0.00307960f, 0.01440900f, 
    -0.01684853f, -0.01868350f, -0.03279731f, -0.03755390f, -0.04903374f, -0.04738576f, 0.01860854f, -0.02906280f, 
    -0.01520722f, -0.04983498f, -0.01700365f, 0.02685603f, 0.02166841f, -0.03400251f, -0.01295991f, -0.05100378f, 
    -0.02394232f, -0.00604950f, -0.00806793f, -0.05837078f, -0.05544180f, 0.00476925f, 0.03024546f, 0.02862473f, 
    0.00817656f, 0.00731640f, -0.03162026f, -0.03509855f, 0.01480310f, -0.02726097f, -0.03393219f, -0.00240922f, 
    -0.05703540f, 0.04269249f, -0.02975519f, 0.01014861f, 0.01896866f, 0.01152067f, 0.01170558f, -0.04774615f, 
    -0.02474897f, -0.01563276f, 0.02815117f, -0.05459001f, -0.00192663f, 0.00679376f, 0.04531561f, -0.01447615f, 
    -0.03005337f, -0.02462383f, -0.04246377f, 0.04129412f, 0.02296241f, -0.05357138f, 0.01571175f, -0.00067117f, 
    -0.01481046f, 0.03972729f, -0.02280230f, -0.01716988f, -0.00643092f, -0.05081360f, -0.05012834f, -0.01720490f, 
    0.00210431f, 0.03975182f, 0.01706071f, 0.01955055f, -0.03100085f, -0.01832474f, -0.03026074f, -0.01120276f, 
    0.03029105f, -0.05315251f, 0.02392167f, -0.01048292f, -0.03919061f, -0.04433463f, 0.03504298f, -0.05623121f, 
    -0.01202531f, 0.04157188f, 0.01684681f, -0.04162915f, 0.00331389f, -0.00738480f, -0.02556841f, 0.03992180f, 
    -0.02976681f, -0.01662042f, 0.01403162f, 0.02041443f, 0.03007907f, -0.03793786f, 0.02148318f, -0.03587909f, 
    -0.01082189f, 0.02722201f, 0.04228460f, 0.01074480f, -0.02399893f, -0.00845630f, -0.04505101f, -0.01439862f, 
    0.02937464f, -0.01686472f, -0.00054372f, 0.00673793f, -0.04974041f, -0.01454212f, -0.02466854f, -0.00583777f, 
    0.00388631f, 0.02202035f, -0.03536562f, -0.03156425f, -0.03582864f, -0.01765641f, 0.02272421f, 0.03533572f, 
    0.00258469f, 0.02043457f, 0.00060537f, -0.00764167f, 0.02863535f, 0.02290137f, -0.01727012f, -0.05401432f, 
    -0.00807742f, -0.01069774f, 0.00906366f, 0.01919360f, 0.00976492f, 0.01932455f, 0.04359879f, -0.00061822f, 
    0.03697529f, 0.01298357f, -0.00593192f, 0.00580020f, -0.04090739f, 0.04595755f, -0.04798838f, 0.01623660f, 
    -0.00285156f, -0.02314859f, -0.05081784f, -0.02346578f, 0.02741534f, -0.05114308f, 0.02720519f, 0.00902382f, 
    0.04299404f, 0.02031017f, 0.01928021f, -0.05791423f, 0.01750589f, -0.04930254f, 0.01916774f, -0.00217596f, 
    -0.05482700f, -0.05195784f, -0.01278237f, -0.00262103f, -0.02200717f, -0.02301993f, -0.05105538f, -0.03108838f, 
    -0.00954611f, -0.03682062f, -0.04738884f, -0.04845421f, 0.03415923f, -0.00407845f, -0.05784709f, 0.01695297f, 
    -0.04999521f, 0.04126017f, -0.01038340f, 0.04055545f, -0.05196282f, 0.01004832f, -0.02461391f, -0.05408730f, 
    -0.04492953f, 0.03451424f, -0.05330517f, -0.05096583f, 0.00785536f, 0.03944844f, -0.00179367f, -0.02244183f, 
    -0.02736874f, 0.05092351f, -0.03947278f, -0.03106595f, -0.02008169f, 0.00657442f, -0.01156318f, 0.03447402f, 
    -0.00983515f, -0.03949825f, 0.03357324f, 0.03916106f, 0.00272333f, 0.02706975f, 0.00416793f, -0.02856082f, 
    -0.05625634f, -0.05182760f, 0.01293685f, -0.04904082f, -0.00588794f, 0.04113588f, -0.01218590f, -0.03500049f, 
    -0.02159221f, 0.00885181f, -0.03378232f, 0.01129633f, 0.02675410f, -0.03155288f, -0.04916802f, 0.01858138f, 
    0.03707087f, 0.03168210f, -0.04985937f, 0.02000536f, -0.00346046f, 0.02824323f, -0.03604311f, -0.04052661f, 
    0.00321656f, 0.01594426f, -0.04776589f, 0.03589523f, -0.02090448f, -0.01508383f, 0.02658328f, 0.01794694f, 
    -0.03071129f, -0.02992392f, 0.03802272f, -0.04695564f, -0.00815485f, -0.00921421f, -0.00108166f, -0.04675558f, 
    0.01006244f, -0.00346645f, 0.01533919f, -0.00357639f, 0.01545005f, -0.03976340f, -0.00743417f, 0.00072411f, 
    -0.03406193f, 0.01087223f, 0.03175926f, -0.00108266f, 0.03122853f, -0.00936695f, -0.00799520f, -0.00085753f, 
    0.06974760f, -0.18588637f, 0.16370423f, 0.09313214f, -0.06710348f, -0.00853482f, 0.10168140f, -0.11943255f, 
    0.00464666f, 0.14028259f, -0.04373235f, 0.03423545f, 0.00071751f, -0.00504552f, 0.11300025f, 0.14389907f, 
    -0.12811613f, -0.07999741f, -0.10435459f, -0.00830545f, 0.09601799f, -0.04096617f, -0.03367269f, 0.05748887f, 
    0.07106927f, 0.19794445f, 0.01304091f, -0.08775657f, -0.00990164f, -0.11502454f, 0.00894699f, 0.00343003f, 
    0.05245564f, -0.07287289f, -0.00141169f, -0.10072429f, -0.12631923f, -0.00103636f, 0.12368460f, -0.15714633f, 
    0.01487080f, 0.06234786f, -0.01477217f, -0.16566992f, 0.01567277f, 0.02264705f, -0.11954289f, 0.01717647f, 
    0.07013748f, 0.11258012f, -0.03006739f, 0.13997942f, -0.06094473f, 0.02022082f, 0.18009904f, 0.08391310f, 
    0.19625823f, 0.06695363f, 0.13366082f, 0.19329417f, -0.12016686f, 0.02473000f, 0.19391292f, -0.11487127f, 
    -0.16318002f, 0.04960949f, -0.15925747f, -0.14882664f, 0.06152011f, 0.00956222f, -0.08124591f, -0.10280839f, 
    0.11031834f, -0.10387984f, 0.10282805f, 0.00263151f, 0.04483364f, 0.02256605f, -0.03993727f, 0.03373851f, 
    -0.04002994f, 0.03802507f, 0.13476065f, 0.04372295f, 0.06501982f, 0.09046476f, -0.23549199f, -0.46173441f, 
    0.05661594f, -0.07875154f, 0.11296651f, 0.17889172f, 0.12763910f, 0.05148113f, -0.01782066f, -0.21500474f, 
    0.06777094f, 0.35143876f, 0.25230077f, 0.08407626f, -0.10308554f, -0.07419423f, -0.08138712f, 0.06862210f, 
    0.05102368f, -0.02855575f, -0.08674344f, -0.00313496f, -0.13072488f, 0.10790048f, 0.01931736f, 0.10754742f, 
    0.08424433f, 0.19731045f, -0.24156031f, -0.05731975f, -0.04853976f, -0.01422975f, -0.12460405f, -0.09482020f, 
    0.18095128f, 0.10233539f, 0.20948656f, 0.10688093f, 0.28592807f, 0.08542270f, -0.07865667f, -0.24193969f, 
    0.04878464f, -0.07854806f, -0.00486446f, 0.03864503f, -0.01442721f, 0.02498552f, 0.00263780f, 0.21875906f, 
    0.03403364f, 0.05044389f, 0.01532428f, -0.24589263f, 0.01186361f, 0.05173765f, -0.08036976f, -0.08011054f, 
    0.13433875f, 0.02580877f, 0.01518748f, -0.09811869f, 0.00621673f, 0.02739017f, -0.05213163f, -0.06279535f, 
    0.02121896f, -0.11378002f, -0.06806157f, -0.24836975f, 0.13319585f, 0.25057384f, -0.01822948f, 0.16477789f, 
    0.01554790f, 0.04340525f, 0.23912966f, -0.11931854f, 0.03570715f, -0.08973578f, 0.00723917f, -0.09733357f, 
    -0.06934728f, -0.03403509f, 0.02751173f, 0.12338527f, 0.18322238f, -0.00461488f, -0.01857037f, -0.04948945f, 
    0.00105397f, 0.08193004f, -0.03975679f, 0.16159935f, 0.22298385f, 0.12128746f, -0.14570194f, -0.11383390f, 
    0.04955447f, -0.05833989f, -0.14758550f, 0.06835274f, -0.04240850f, -0.02966779f, -0.09639889f, -0.14401869f, 
    0.29808044f, -0.10662798f, 0.21565677f, -0.26636150f, -0.11100857f, -0.16364759f, 0.14150256f, -0.09786837f, 
    -0.04009208f, 0.14549246f, 0.03610381f, 0.12283086f, -0.04536114f, 0.15197696f, 0.00298124f, 0.11772826f, 
    -0.03788078f, -0.00770747f, 0.03490537f, -0.02210491f, 0.07839512f, 0.03553711f, 0.07379360f, 0.28690094f, 
    0.10382541f, 0.18474682f, 0.12838587f, -0.12361187f, 0.16309205f, 0.01923046f, -0.15418977f, 0.15700537f, 
    0.05655349f, 0.05465807f, -0.12743001f, -0.01823132f, 0.16066618f, -0.16124880f, 0.02472954f, 0.07236620f, 
    -0.12329432f, -0.05203019f, 0.03799998f, 0.02581992f, 0.03350458f, 0.25182745f, -0.08101079f, 0.13426231f, 
    0.00982094f, 0.24224479f, -0.08173265f, -0.21203603f, -0.10433402f, -0.13132812f, -0.07259037f, 0.11068875f, 
    -0.06821307f, -0.00129704f, 0.02942073f, 0.01210676f, 0.09406637f, 0.14824642f, 0.08144239f, -0.19851451f, 
    -0.00717100f, 0.09685525f, -0.14224617f, -0.12683211f, -0.03834911f, -0.00990481f, 0.08021814f, -0.01665970f, 
    0.08679624f, 0.04272303f, 0.16645180f, -0.04102947f, 0.02045227f, 0.00827757f, 0.00044107f, -0.00604371f, 
    0.06029946f, 0.05220495f, -0.00262826f, 0.18627411f, 0.11602701f, 0.11466308f, -0.08693519f, 0.00509199f, 
    0.08895610f, 0.12004171f, 0.06057793f, 0.06556495f, -0.10862646f, -0.16376600f, -0.10273140f, -0.04015201f, 
    0.16427706f, 0.21141897f, 0.00327698f, -0.13050896f, 0.04316941f, 0.00124520f, 0.13130334f, 0.11499227f, 
    -0.03060830f, 0.02794217f, -0.06988410f, -0.00947715f, 0.27131033f, -0.16072834f, -0.30378246f, -0.35428029f, 
    0.08410697f, -0.06340933f, 0.17995512f, 0.05588299f, -0.10346076f, 0.06358553f, -0.05052662f, -0.09242135f, 
    0.02048433f, -0.02203666f, 0.10430871f, -0.10288316f, -0.08693720f, -0.05985786f, -0.08793736f, -0.14266925f, 
    -0.04453145f, 0.01209280f, -0.06709261f, -0.02338333f, 0.27856943f, 0.28812727f, 0.04905392f, 0.06396277f, 
    0.16507711f, 0.10260218f, -0.02982570f, 0.08044633f, 0.16586715f, 0.06953228f, 0.01753699f, 0.07140069f, 
    0.18898149f, 0.32441556f, 0.16422862f, 0.20271853f, -0.01586184f, -0.16793208f, 0.03948362f, -0.11595650f, 
    -0.10397094f, -0.10757735f, -0.08743053f, -0.20742452f, 0.24161564f, 0.01160219f, 0.01043598f, 0.00105854f, 
    -0.01154232f, -0.01634825f, -0.13729765f, -0.05160043f, -0.02736603f, -0.05314168f, -0.11074640f, -0.23568331f, 
    -0.00856149f, 0.06906443f, 0.07621647f, -0.01098576f, 0.04226534f, -0.03275809f, 0.02712462f, 0.20778686f, 
    0.07349285f, 0.02976913f, -0.01050595f, 0.12503110f, 0.36106965f, -0.12296423f, -0.04689781f, 0.19970751f, 
    0.03626291f, 0.08354480f, 0.06548209f, -0.20906393f, 0.02391659f, 0.00714663f, 0.16789372f, 0.13443378f, 
    -0.03210118f, 0.02086786f, 0.02266220f, -0.00977307f, -0.01933829f, 0.04927090f, -0.03280268f, 0.04595315f, 
    -0.05619355f, -0.05638446f, -0.00308127f, -0.02144215f, 0.03111755f, -0.00015564f, -0.02853951f, 0.01459907f, 
    -0.02322304f, 0.01254163f, 0.00396428f, 0.00067542f, -0.00495277f, 0.03662427f, 0.00760073f, -0.02840218f, 
    -0.04985482f, -0.00241091f, -0.00714194f, 0.04230807f, -0.05574528f, 0.00929649f, 0.02390438f, 0.03161483f, 
    0.00709831f, -0.01814417f, 0.03890497f, -0.03956439f, -0.02437630f, -0.02325962f, -0.03945898f, 0.02982839f, 
    -0.01230252f, 0.04385384f, -0.01787870f, -0.03621512f, -0.00919646f, -0.03998248f, -0.02041240f, -0.03507861f, 
    0.00944611f, 0.02262411f, -0.04568741f, 0.01007541f, 0.02703700f, 0.03503789f, 0.02735794f, 0.02046280f, 
    -0.05473239f, 0.03841773f, 0.00514789f, 0.02821985f, 0.00261863f, -0.04396205f, 0.00933610f, 0.04144732f, 
    -0.03435140f, 0.04097731f, -0.02106016f, -0.03223602f, -0.05646711f, -0.04517629f, 0.01746783f, -0.02244568f, 
    -0.00020373f, -0.02310072f, -0.04795214f, -0.03466139f, 0.03951919f, 0.03503890f, -0.03959224f, -0.03687330f, 
    -0.00160910f, -0.01119939f, -0.03595554f, 0.02291274f, -0.02117056f, 0.02019901f, 0.02350165f, -0.00403186f, 
    -0.03250860f, -0.04777272f, -0.02763852f, 0.01677623f, -0.01011299f, -0.01039149f, -0.04521802f, -0.05634431f, 
    0.01458833f, 0.00938607f, -0.04308429f, -0.00839051f, 0.03692458f, 0.01741746f, 0.04974393f, 0.03784752f, 
    -0.04163052f, -0.00535544f, 0.01032640f, -0.03788261f, 0.01110496f, 0.02987468f, 0.04084012f, 0.02954176f, 
    -0.01640878f, 0.04125810f, -0.04094104f, 0.00316173f, -0.02368173f, -0.00350297f, 0.04502114f, -0.02808299f, 
    -0.02340489f, 0.01868539f, 0.04989634f, -0.04764335f, 0.03360128f, 0.04701304f, 0.00131066f, 0.01095529f, 
    -0.02408529f, 0.02352858f, -0.00942180f, 0.01151532f, 0.01298777f, -0.02022268f, 0.04625776f, 0.00814378f, 
    -0.04460299f, -0.02097252f, -0.04701477f, -0.03385844f, -0.02008154f, 0.04037956f, -0.01648654f, -0.03951198f, 
    -0.02508163f, -0.02119448f, 0.03749686f, -0.01859488f, -0.04242781f, 0.00222348f, -0.02913125f, -0.02504752f, 
    0.02977104f, -0.02898700f, -0.02851526f, -0.00123436f, -0.02855355f, -0.01989974f, -0.05546677f, -0.03549615f, 
    -0.01388150f, -0.01571119f, -0.01756141f, 0.01973118f, -0.01131038f, 0.00367664f, 0.00071327f, -0.02635737f, 
    -0.01082772f, 0.01200298f, 0.03667142f, 0.03228461f, 0.02862639f, -0.00256639f, -0.04431307f, 0.04200130f, 
    -0.04026724f, 0.01522064f, 0.03466413f, -0.03067797f, -0.04560972f, 0.02181366f, -0.05463737f, 0.01319119f, 
    -0.02463064f, 0.02135384f, -0.03966224f, -0.04857050f, -0.00195325f, 0.04118874f, -0.00239241f, 0.01017207f, 
    -0.03960465f, 0.01160306f, -0.00433608f, 0.05101668f, 0.00107203f, 0.02560616f, 0.01607550f, 0.03439514f, 
    -0.01063458f, 0.01095697f, -0.03987769f, -0.05328022f, -0.02781416f, 0.00337658f, -0.01882187f, -0.02428053f, 
    -0.00886706f, -0.02309840f, -0.01788124f, -0.04224952f, 0.04581219f, -0.00345500f, -0.04369279f, 0.00174495f, 
    0.01238434f, -0.01889668f, -0.05495879f, 0.04186175f, 0.03255067f, 0.02328600f, 0.02818029f, 0.01999977f, 
    -0.00821746f, -0.05322709f, -0.05136617f, 0.03802103f, 0.02495453f, -0.00729045f, 0.04051958f, 0.01206114f, 
    -0.02064858f, -0.03915747f, -0.03917940f, 0.00771489f, 0.01855034f, -0.05439952f, -0.05113732f, -0.01078709f, 
    0.02616932f, 0.02487545f, -0.01304497f, 0.05214185f, -0.04169836f, -0.02709719f, -0.01522232f, -0.04207496f, 
    -0.04204477f, -0.02783101f, 0.05024475f, -0.02381124f, 0.01544134f, 0.00169915f, -0.04491194f, 0.05510493f, 
    0.02753195f, 0.02594359f, 0.01577546f, 0.00284678f, -0.03330343f, -0.04283343f, -0.00537596f, -0.00556382f, 
    -0.02765719f, 0.02024596f, 0.00814514f, 0.01686954f, -0.01399470f, -0.02615596f, -0.02025061f, 0.04447827f, 
    -0.01167992f, -0.03620373f, -0.01080787f, -0.00101181f, -0.05738778f, -0.02836904f, -0.00805319f, 0.01960296f, 
    -0.04366587f, 0.01762337f, 0.02297382f, 0.02440801f, 0.00759020f, -0.04082694f, -0.01985888f, 0.01613388f, 
    -0.02253123f, 0.01997254f, -0.02596385f, -0.03536846f, -0.02118839f, -0.03375503f, 0.02539059f, 0.00929871f, 
    0.04471926f, 0.02715335f, -0.01813119f, -0.03587766f, -0.03894585f, -0.02186603f, 0.01909889f, 0.03337459f, 
    0.00114717f, 0.02863915f, -0.05963366f, -0.04801099f, -0.03352744f, -0.02153106f, -0.01432549f, -0.03547340f, 
    -0.03931743f, 0.02917276f, -0.02772728f, 0.02140617f, 0.01306831f, -0.00430980f, -0.01621983f, -0.00637991f, 
    0.02632248f, 0.00664503f, -0.04538697f, -0.00000979f, -0.04776645f, -0.00459970f, -0.05091660f, -0.03517558f, 
    0.02660361f, -0.03340812f, 0.03719772f, 0.02889672f, 0.00180200f, -0.05831235f, -0.01878015f, 0.00736006f, 
    0.01304540f, 0.00785405f, -0.04452337f, -0.02525770f, -0.01298974f, -0.04574034f, -0.00401646f, -0.04338044f, 
    -0.00141430f, -0.01251328f, -0.00766050f, -0.01908202f, 0.01782165f, -0.02141729f, -0.03636040f, -0.01823984f, 
    0.01924837f, -0.03981973f, 0.04268680f, -0.01393069f, -0.05494980f, -0.03010749f, 0.03569687f, -0.02521961f, 
    0.00111627f, 0.02772623f, -0.05694905f, -0.04632578f, 0.01414999f, 0.00151080f, -0.00894090f, 0.03369148f, 
    0.00720836f, -0.04165182f, -0.04596002f, -0.03682670f, -0.03508104f, 0.01260955f, 0.03750604f, -0.02041362f, 
    0.00854669f, 0.04425085f, 0.03197971f, 0.02155206f, 0.04074553f, 0.04293852f, 0.05315014f, 0.04254366f, 
    -0.10727353f, -0.17021814f, -0.06791884f, 0.07683335f, 0.01002110f, 0.07073287f, -0.05603884f, -0.08669544f, 
    -0.08116199f, -0.00728380f, -0.17008713f, -0.00038265f, -0.15719777f, -0.17837119f, 0.14309856f, -0.00095947f, 
    -0.17209621f, -0.04495955f, -0.04748992f, -0.00013825f, -0.00595495f, 0.17211851f, 0.10334232f, 0.12256607f, 
    -0.30831182f, -0.06854516f, 0.14994474f, -0.01979024f, 0.02231472f, -0.15965950f, -0.02854736f, -0.00416462f, 
    -0.03618475f, 0.12905870f, 0.09830292f, 0.03678684f, -0.31510258f, 0.04112906f, 0.21137036f, -0.12220868f, 
    0.03234993f, 0.08189259f, -0.22800344f, 0.09425526f, -0.03235508f, 0.06483541f, -0.02469685f, -0.07344438f, 
    0.08193103f, 0.20496343f, -0.24507153f, 0.07173165f, 0.02354306f, -0.06007997f, 0.05872350f, -0.00530210f, 
    -0.12158154f, -0.06508013f, 0.08057000f, 0.18232329f, -0.07736067f, -0.32137606f, 0.53544086f, -0.09599701f, 
    0.01696275f, 0.18254356f, -0.05020771f, -0.06665207f, -0.08918607f, 0.06386065f, 0.07267187f, 0.26854169f, 
    0.04249940f, 0.26726487f, -0.06185874f, 0.27789423f, -0.00477352f, -0.07870376f, 0.06058925f, 0.06447504f, 
    0.06677718f, 0.00997867f, -0.03612902f, -0.11546674f, -0.12607704f, 0.28162318f, 0.08778273f, 0.04173588f, 
    0.04996244f, 0.08428816f, 0.06576129f, 0.10360333f, 0.08702608f, 0.11452275f, 0.05540127f, -0.01901673f, 
    -0.03795007f, -0.35572466f, 0.36758134f, -0.04060442f, 0.01137816f, -0.05188698f, -0.24305297f, -0.14912789f, 
    0.07061071f, 0.07127575f, -0.10150731f, -0.00397057f, 0.20954469f, 0.34239200f, 0.17786160f, -0.06872363f, 
    0.15555908f, 0.21176085f, 0.01454433f, 0.22481766f, -0.02939750f, 0.06239058f, -0.03288705f, 0.14903034f, 
    0.01741266f, 0.38251454f, -0.14579459f, -0.05781942f, 0.18334267f, 0.07282646f, 0.03337165f, -0.08449042f, 
    -0.07512619f, -0.00472013f, -0.01333690f, 0.29279676f, 0.18938293f, -0.23316407f, 0.27482864f, -0.05289272f, 
    0.03308620f, 0.01127110f, -0.08803429f, -0.05371423f, -0.03478832f, 0.08908831f, -0.09056187f, 0.04689831f, 
    -0.11061764f, 0.04730060f, -0.13068224f, -0.17427458f, -0.09700079f, 0.01971551f, 0.07470368f, -0.06324143f, 
    0.07966916f, 0.24637698f, 0.25167999f, 0.10857613f, 0.37574831f, 0.30782855f, 0.13068953f, 0.39368156f, 
    0.00598197f, 0.15651670f, 0.27499789f, -0.03046643f, 0.05060605f, -0.01979970f, 0.07588010f, 0.06236705f, 
    0.06761857f, -0.18341939f, -0.01061429f, 0.10198552f, 0.04915889f, -0.04250532f, -0.19705537f, -0.07640684f, 
    -0.06918281f, 0.04815900f, -0.10180356f, -0.13268764f, 0.01387880f, -0.07323269f, -0.05422957f, -0.07177453f, 
    -0.00126516f, 0.02264320f, 0.02789411f, 0.09223216f, -0.10418805f, -0.05545890f, 0.03572033f, -0.05637144f, 
    -0.04458128f, 0.26121292f, -0.34146801f, 0.19396213f, 0.12082314f, 0.07253504f, -0.00698403f, 0.12454627f, 
    -0.02784314f, 0.07928387f, -0.04260961f, 0.04901550f, 0.06276087f, -0.17531051f, 0.11966997f, 0.13497947f, 
    -0.17671096f, -0.13370061f, 0.00177395f, 0.06046389f, 0.12981410f, -0.12369327f, -0.07939878f, -0.09499948f, 
    -0.06839073f, 0.33381653f, -0.11236107f, -0.04733757f, 0.15852164f, 0.04947925f, -0.02978312f, 0.03437153f, 
    -0.11904085f, -0.13360761f, -0.14400208f, -0.22154479f, -0.20423599f, 0.12879652f, -0.06687258f, 0.15109468f, 
    -0.15533839f, -0.05572660f, -0.07775777f, 0.02099776f, -0.08213414f, 0.20237049f, -0.01872224f, -0.00421545f, 
    -0.35782033f, -0.11762778f, -0.15153979f, -0.05742568f, -0.01526013f, -0.15087375f, -0.09626185f, 0.03934925f, 
    -0.02467264f, 0.19550149f, 0.05701039f, 0.05482771f, -0.27497968f, 0.24222623f, -0.08397817f, 0.05913588f, 
    0.10451142f, -0.05291455f, 0.02997476f, 0.00494817f, -0.09898107f, 0.13327350f, 0.06298286f, 0.06068744f, 
    -0.36109143f, 0.00192618f, -0.07341775f, -0.04735917f, -0.09580740f, -0.01972298f, -0.08740456f, -0.05814261f, 
    -0.03756408f, -0.03504845f, -0.18413852f, -0.25214195f, 0.41419822f, 0.15021794f, 0.23184100f, 0.27110744f, 
    -0.03685163f, 0.10922932f, 0.23330200f, 0.08305636f, -0.02882195f, -0.05148563f, 0.07807615f, 0.08113120f, 
    0.58886182f, 0.25134158f, 0.19729944f, 0.32926106f, 0.16767047f, 0.09182329f, -0.13627015f, 0.08239385f, 
    0.05125343f, 0.02153431f, 0.01251226f, -0.05043614f, 0.01185206f, 0.41229674f, -0.03900007f, 0.03974076f, 
    0.10885621f, 0.16405459f, 0.15888071f, -0.03363055f, -0.02709740f, 0.03016374f, 0.07130378f, 0.07006058f, 
    -0.35672778f, 0.16494612f, -0.08486995f, -0.07523698f, -0.10464717f, -0.08433545f, -0.09523539f, -0.04857103f, 
    0.03752592f, 0.07224912f, 0.00125740f, 0.10634218f, 0.28446832f, 0.15070577f, 0.08011217f, 0.01907843f, 
    0.07973745f, -0.03666628f, -0.08470227f, 0.22588070f, -0.12253878f, -0.00086646f, -0.03381747f, 0.02578272f, 
    -0.18685155f, 0.27954841f, 0.10921308f, 0.20185934f, -0.09861933f, 0.12704179f, -0.00210609f, 0.04861913f, 
    -0.01327626f, 0.04645835f, 0.14267619f, -0.01065616f, -0.10014682f, -0.05110903f, -0.15852740f, -0.14662310f, 
    0.05310073f, -0.04682129f, 0.01550343f, -0.03535293f, 0.01501619f, 0.15817301f, 0.11082406f, 0.14124414f, 
    0.06924727f, -0.05098401f, 0.06250783f, 0.14131089f, 0.05822924f, 0.10262426f, 0.06794697f, 0.15621036f, 
    -0.07355576f, -0.00193762f, -0.10429537f, -0.00966022f, 0.17911553f, -0.05238305f, -0.11413598f, 0.01744983f, 
    0.21952891f, 0.05783086f, 0.03414118f, 0.07448569f, -0.05406407f, 0.08217621f, 0.07261306f, -0.07816901f, 
    0.04468989f, -0.05250660f, -0.01176446f, 0.03875514f, -0.04177747f, -0.04052102f, -0.01988868f, 0.00895406f, 
    0.04170648f, 0.03364029f, -0.01491762f, 0.02304777f, 0.02829322f, 0.01725409f, -0.02676563f, -0.03718451f, 
    -0.02624202f, -0.03873014f, 0.01125430f, 0.03772467f, -0.00696081f, 0.03423784f, -0.00709181f, -0.04249519f, 
    -0.02782178f, 0.01142417f, 0.03240288f, 0.02793728f, -0.05601082f, 0.03137022f, 0.02704143f, -0.05109511f, 
    0.02102321f, 0.01444723f, 0.02455228f, -0.01595393f, -0.00076372f, 0.00803558f, 0.03901007f, -0.01094406f, 
    -0.05250933f, -0.00974147f, -0.03673256f, -0.00385571f, 0.00723429f, 0.03805193f, 0.01843332f, -0.02327960f, 
    -0.02077957f, 0.02151620f, 0.00437367f, 0.02676299f, -0.00210997f, 0.02326857f, -0.01885347f, -0.03546733f, 
    0.03345277f, -0.05206977f, 0.02657329f, -0.03660243f, 0.02407047f, -0.04887919f, 0.02770413f, -0.01650838f, 
    -0.00459017f, -0.01486875f, -0.03051468f, -0.02230037f, 0.04153483f, 0.00980040f, 0.02731100f, -0.00540597f, 
    0.04660797f, 0.01665537f, -0.04212098f, -0.03163972f, 0.00368590f, 0.02746020f, -0.03989451f, 0.00942713f, 
    -0.01821019f, -0.04675378f, -0.04652029f, -0.03382726f, -0.04122319f, -0.02264927f, -0.00077107f, 0.03785142f, 
    -0.04421746f, -0.04208991f, -0.05434250f, 0.04952127f, -0.02860396f, 0.00987257f, -0.04282328f, 0.03351026f, 
    0.04159000f, 0.00627600f, 0.03055667f, 0.01620835f, -0.04279521f, 0.02200511f, -0.03560646f, -0.01477096f, 
    -0.01175351f, 0.02997803f, 0.01150252f, -0.00576508f, -0.01544559f, 0.00656934f, -0.02766551f, -0.05009210f, 
    -0.02129433f, 0.02126359f, -0.00649280f, -0.04198426f, -0.00026461f, 0.01211968f, -0.05351210f, 0.04812523f, 
    0.02973608f, -0.01801124f, 0.00607780f, -0.00355991f, 0.01868122f, 0.03576233f, 0.02989023f, -0.03180579f, 
    -0.04830210f, -0.00815342f, 0.00663739f, -0.00999577f, 0.00483471f, -0.05429431f, 0.01664156f, 0.04273779f, 
    -0.05380116f, -0.03408290f, 0.01140956f, 0.00515056f, -0.01247779f, 0.01609241f, 0.02662888f, -0.05054726f, 
    0.02303235f, 0.04327535f, -0.03313763f, 0.03994270f, -0.04441423f, -0.01427970f, -0.00378536f, -0.05424691f, 
    0.02946520f, 0.03583751f, 0.04015062f, 0.02464399f, 0.01441081f, -0.05207132f, -0.04670722f, -0.00247654f, 
    -0.05271373f, 0.03655018f, -0.02001898f, -0.04022505f, 0.04077922f, -0.03290728f, -0.03357774f, -0.00139595f, 
    -0.03705852f, 0.02366013f, -0.01298462f, -0.01905713f, 0.03761923f, 0.04130257f, 0.00853694f, -0.00045677f, 
    0.00807606f, 0.02095268f, -0.04003161f, 0.02884925f, 0.02057903f, -0.05540506f, 0.00568390f, -0.01675791f, 
    -0.04971064f, -0.02184479f, 0.03544752f, -0.04935674f, -0.03807407f, 0.00253639f, 0.04257692f, -0.04573798f, 
    -0.04421977f, -0.01989479f, -0.00094349f, 0.02533149f, 0.04054510f, -0.02693584f, 0.02898672f, -0.02257935f, 
    0.00386399f, 0.01333631f, 0.01201031f, -0.03376484f, -0.02448669f, -0.05610819f, -0.00686751f, 0.01688600f, 
    0.04236746f, -0.05802616f, -0.00651836f, 0.01712335f, -0.00233509f, -0.01152282f, 0.00852059f, -0.01474325f, 
    -0.04060004f, 0.04265855f, 0.04072856f, 0.03942074f, 0.02400483f, -0.03891322f, 0.04934193f, 0.00744888f, 
    0.04442254f, -0.05007169f, -0.04500809f, -0.02576950f, 0.00854126f, -0.00456788f, -0.02847413f, 0.01418415f, 
    0.03097895f, 0.03280913f, -0.05762805f, -0.03287157f, -0.03500823f, -0.04204021f, 0.00761983f, 0.03437767f, 
    0.01228409f, -0.01089597f, -0.02091011f, -0.03888207f, -0.01582181f, 0.02721488f, -0.00189874f, -0.01679109f, 
    0.01126564f, 0.00874410f, -0.01860061f, 0.03738230f, 0.00231983f, -0.00416800f, -0.03323819f, -0.04317536f, 
    -0.00887212f, -0.04150567f, -0.01262050f, -0.01375337f, 0.02834921f, -0.01265410f, -0.02187670f, -0.03425131f, 
    -0.02240379f, 0.02366342f, -0.00391178f, -0.05114351f, 0.01893870f, -0.03069120f, -0.05671354f, 0.04949646f, 
    -0.00379197f, -0.00169292f, -0.01704175f, 0.04100938f, 0.01869046f, -0.04959252f, 0.02056026f, 0.02831168f, 
    -0.04272164f, 0.04887434f, 0.03070584f, 0.02327377f, -0.03553977f, -0.04574474f, -0.02756615f, -0.00485959f, 
    -0.02214358f, -0.02351126f, 0.02507560f, 0.04501495f, -0.00669833f, -0.01850707f, -0.01075719f, -0.04536254f, 
    -0.02193862f, -0.03372902f, -0.05237394f, -0.02019849f, 0.04798537f, -0.04087130f, -0.04653956f, -0.03554101f, 
    -0.03435749f, -0.05520894f, -0.05207311f, 0.01582525f, -0.03233752f, -0.05664097f, 0.04264465f, 0.03919380f, 
    -0.03158183f, -0.03168404f, -0.05163637f, -0.05829045f, -0.05066142f, -0.03158269f, -0.01833323f, -0.04025467f, 
    -0.04662022f, 0.00514608f, 0.01576458f, -0.05075530f, 0.01504999f, 0.03794633f, -0.02773119f, 0.03924397f, 
    0.01110014f, 0.03184823f, -0.04420768f, -0.02658572f, -0.02314509f, -0.02254133f, 0.01695655f, 0.01395933f, 
    0.00763823f, -0.05649289f, 0.03250145f, 0.04174058f, -0.01377718f, 0.00139714f, 0.01320864f, 0.01726348f, 
    -0.04921374f, -0.03167097f, 0.01574819f, 0.03214611f, 0.01174480f, -0.01124371f, 0.02245539f, 0.03541479f, 
    -0.04204743f, 0.03861466f, 0.04163598f, -0.01199797f, -0.02676727f, -0.03081654f, 0.02824147f, -0.02069607f, 
    -0.04673282f, -0.04288187f, -0.00059902f, -0.02438015f, 0.03385660f, 0.01667636f, -0.00651096f, 0.02654737f, 
    -0.00647064f, 0.03741362f, 0.02065080f, 0.04841954f, -0.02760183f, 0.01391195f, -0.00500505f, -0.05395509f, 
    0.04761425f, -0.05733827f, -0.00440574f, -0.00889350f, -0.02807343f, 0.01155245f, -0.03965204f, 0.00572310f, 
    -0.04890943f, 0.04149481f, 0.01421705f, 0.00312950f, -0.00605223f, 0.03990363f, -0.00642469f, -0.00136766f, 
    0.00753427f, -0.02936503f, 0.01374698f, 0.00870253f, -0.03720377f, -0.02119847f, -0.02372251f, -0.03281563f, 
    -0.03303849f, 0.03804550f, 0.03402598f, -0.01057292f, 0.01302772f, 0.00582966f, 0.01449729f, 0.03853029f, 
    -0.04930297f, 0.01415638f, -0.00248076f, 0.02441740f, -0.03476619f, -0.04215626f, -0.02433641f, -0.03631132f, 
    -0.05284157f, 0.02608055f, 0.02694167f, 0.01646897f, 0.04227490f, 0.00471172f, 0.01596312f, -0.04636471f, 
    -0.00320684f, -0.01498584f, 0.03730686f, 0.03788840f, -0.05117845f, -0.03771430f, -0.05150051f, -0.01747869f, 
    0.03024951f, -0.01828624f, -0.02242529f, -0.00495760f, 0.03820023f, 0.03447411f, 0.03477145f, -0.02941854f, 
    -0.01285201f, 0.00627478f, -0.04668461f, -0.03427768f, -0.04434216f, 0.01176245f, -0.04831470f, -0.01761940f, 
    -0.05377826f, 0.02207287f, 0.03021869f, -0.04250119f, -0.01383332f, -0.00590770f, 0.00846433f, 0.00031004f, 
    -0.02095339f, 0.03160262f, -0.00418909f, -0.02849576f, -0.05400877f, -0.05390551f, -0.02488165f, -0.01741057f, 
    0.01359703f, 0.00249629f, -0.00125026f, -0.02681418f, 0.03784033f, 0.02377582f, -0.03811838f, 0.00879896f, 
    -0.00640771f, -0.00946316f, -0.00237805f, -0.03217623f, -0.00831856f, 0.03898937f, -0.02093331f, -0.02332821f, 
    -0.02045365f, 0.03983826f, -0.04408085f, 0.00745471f, -0.02052354f, -0.04529680f, 0.01488427f, -0.00640824f, 
    -0.02561270f, -0.03273129f, -0.04402120f, 0.01617956f, -0.00381107f, -0.04001686f, -0.03889905f, -0.01321868f, 
    -0.05517824f, -0.02265850f, 0.00051654f, 0.03306241f, -0.03524790f, -0.03255095f, -0.04333840f, -0.02655929f, 
    -0.00776176f, 0.00575386f, 0.00916336f, -0.04014937f, 0.03555071f, -0.02618066f, -0.01031393f, 0.00161635f, 
    -0.00412313f, -0.03174380f, 0.01832619f, 0.01828603f, 0.02239713f, 0.00270775f, 0.02217301f, 0.02733601f, 
    0.02859120f, -0.05842448f, 0.01010457f, -0.04779669f, -0.02008095f, 0.00638712f, 0.01539864f, -0.03865926f, 
    0.00885022f, 0.01671513f, 0.00269277f, 0.01813903f, 0.02226463f, 0.00807851f, -0.03569848f, 0.01202572f, 
    -0.01439160f, -0.05260492f, -0.01976312f, -0.03538946f, -0.01380601f, -0.00822795f, -0.03405733f, -0.00943380f, 
    -0.02140485f, 0.04080791f, 0.00542038f, 0.04521587f, -0.00989313f, 0.01892136f, 0.00854523f, 0.02451844f, 
    -0.05129278f, 0.01394312f, 0.01415713f, -0.04275870f, 0.02823422f, 0.01576014f, -0.00308904f, -0.05358595f, 
    0.02176918f, -0.03898116f, -0.04691615f, -0.00357189f, 0.03127708f, -0.03183527f, -0.02250304f, 0.02481888f, 
    -0.01654115f, -0.00482837f, 0.03029260f, -0.05787054f, 0.01044842f, 0.00819262f, -0.03622355f, 0.03294911f, 
    -0.05369894f, -0.01152236f, -0.01250898f, -0.01291885f, -0.04166334f, 0.02415379f, -0.05014198f, 0.01920772f, 
    0.04164988f, -0.00890522f, 0.01965115f, 0.04009406f, 0.00742745f, -0.01926756f, -0.04341778f, 0.03460663f, 
    -0.04703937f, -0.02744616f, -0.00730274f, 0.00468680f, 0.03911792f, -0.02425428f, -0.02299238f, 0.03055247f, 
    -0.04927754f, 0.03609590f, -0.05926936f, -0.05654033f, -0.02005372f, -0.01369392f, -0.05086657f, 0.00437648f, 
    -0.05656802f, -0.04233415f, -0.00583195f, -0.00900418f, 0.00730209f, -0.04631253f, -0.02690346f, -0.01996190f, 
    -0.00209760f, 0.00940692f, 0.01409918f, -0.03943042f, 0.01483338f, -0.00946778f, -0.04047890f, 0.00516063f, 
    -0.01986920f, 0.04250310f, -0.03152030f, 0.01043086f, -0.01998887f, 0.02106688f, 0.03184575f, 0.01194062f, 
    -0.00178720f, 0.00318953f, -0.04723968f, 0.00594785f, -0.02565673f, -0.04727907f, 0.02845417f, 0.03017667f, 
    -0.02891953f, 0.03098326f, 0.03177040f, -0.00019562f, 0.02191391f, 0.02233369f, -0.00210133f, -0.00179982f, 
    -0.03268095f, -0.03559146f, 0.01823998f, 0.01663599f, 0.02444576f, -0.03777516f, -0.00974125f, 0.03058876f, 
    -0.03102345f, 0.02610006f, 0.03663145f, -0.04560687f, -0.01457471f, -0.01832593f, 0.01829323f, -0.04586375f, 
    0.03041682f, 0.00837008f, -0.04810818f, -0.04290333f, -0.05737449f, -0.01786260f, -0.04956645f, 0.02311289f, 
    0.02840236f, -0.04924843f, -0.00695058f, 0.01279303f, -0.03548603f, -0.01031872f, -0.03467546f, 0.00268403f, 
    -0.00247144f, 0.00147624f, 0.00960422f, -0.04057506f, 0.00394995f, 0.01406495f, -0.03629182f, 0.02065605f, 
    0.02316511f, -0.00495315f, -0.03462121f, -0.03731837f, -0.04245638f, -0.01773137f, 0.01691947f, 0.03877569f, 
    0.03067468f, 0.02550206f, 0.01831132f, 0.03769056f, -0.02718649f, 0.02432339f, 0.00315554f, 0.00793228f, 
    0.00266960f, -0.04891900f, 0.00399326f, -0.01633083f, 0.00126335f, 0.03260356f, 0.03034493f, -0.04637001f, 
    0.00815448f, -0.00460491f, -0.04659986f, 0.03698122f, -0.03172665f, 0.02603012f, -0.03070913f, 0.00414206f, 
    0.00719904f, -0.00505193f, -0.02954205f, 0.00686806f, 0.03201383f, 0.03650245f, 0.01469637f, 0.04409572f, 
    0.00235072f, -0.00948356f, 0.04058676f, -0.01299134f, -0.05329346f, 0.01640662f, 0.00503940f, 0.01141393f, 
    -0.03244209f, 0.02745168f, -0.00036483f, 0.00338721f, -0.03664135f, -0.02097358f, 0.03794502f, -0.05349000f, 
    -0.00115818f, -0.02084716f, -0.01218925f, 0.00259158f, -0.01879224f, 0.00796889f, 0.00499667f, -0.02037323f, 
    0.00168816f, 0.02836365f, 0.00596419f, -0.03414570f, -0.03479155f, -0.02863149f, 0.03153169f, -0.00609775f, 
    0.03198870f, -0.03043520f, -0.03575553f, -0.03148486f, -0.02099974f, 0.01817450f, -0.02028458f, 0.04006881f, 
    0.00219752f, 0.03314118f, -0.04246011f, 0.00862496f, 0.02357267f, 0.02649605f, -0.03909323f, -0.03304494f, 
    -0.00146008f, 0.00673898f, 0.03965844f, -0.04361966f, -0.02629683f, -0.05297161f, 0.01797972f, -0.04460344f, 
    -0.00968518f, -0.01139106f, -0.01796224f, -0.01025881f, -0.00723621f, 0.01597091f, 0.01904448f, 0.02785199f, 
    0.03313718f, -0.01202769f, 0.00160994f, -0.03653703f, 0.01692571f, -0.04525710f, 0.03397330f, 0.00899571f, 
    0.00357937f, -0.00338809f, -0.00328054f, 0.00559284f, 0.03172719f, 0.00347167f, -0.03041080f, -0.01533281f, 
    -0.02013461f, -0.05546749f, -0.04164916f, 0.02766164f, -0.04319615f, 0.03869216f, -0.03552702f, -0.04639016f, 
    -0.01993626f, -0.02512467f, 0.01481556f, 0.02687540f, 0.02544174f, 0.00772783f, 0.01230344f, 0.02561824f, 
    -0.02930170f, 0.03162485f, -0.05239224f, -0.00002405f, -0.04893545f, -0.01736456f, -0.02790816f, -0.00686730f, 
    -0.03398419f, 0.00869698f, 0.03911684f, -0.04476027f, -0.00463440f, -0.05300569f, -0.03574751f, 0.03060478f, 
    0.00747789f, 0.00081622f, -0.04827622f, -0.00648737f, -0.02707543f, -0.05272195f, -0.01705540f, 0.02311956f, 
    0.01241457f, -0.01664059f, 0.04352249f, 0.03092114f, 0.05546017f, -0.04070087f, -0.03809832f, 0.00566663f, 
    -0.00151999f, 0.02430122f, 0.01459533f, 0.00716185f, 0.00251578f, -0.03720479f, -0.02059461f, -0.03876544f, 
    0.02434571f, 0.01407288f, 0.00222504f, -0.00387652f, -0.02137301f, -0.04357143f, 0.01076392f, -0.00371026f, 
    0.03001893f, 0.04526447f, 0.02031274f, -0.04739931f, 0.01437074f, -0.04089430f, 0.04184745f, -0.03327269f, 
    0.00590969f, -0.05666878f, -0.00040509f, -0.05552924f, -0.02772819f, -0.00092519f, -0.02052268f, -0.02920099f, 
    -0.00384868f, -0.00609817f, 0.00155234f, -0.03352522f, 0.01288617f, -0.02327576f, 0.03300859f, -0.03389348f, 
    -0.02607502f, -0.01414945f, 0.02866809f, -0.03752594f, 0.03835930f, -0.00119546f, 0.02920464f, -0.00482543f, 
    -0.01929575f, 0.04079755f, 0.03295233f, -0.00399430f, -0.00118591f, -0.04479854f, -0.00646137f, 0.01036658f, 
    -0.00775774f, -0.03573015f, -0.02911904f, -0.02777344f, -0.04021003f, -0.00826662f, 0.01135955f, -0.04887948f, 
    0.03352879f, -0.03689293f, -0.01154960f, 0.00722948f, -0.00012235f, -0.01922171f, -0.01929844f, -0.00244524f, 
    -0.04305993f, -0.03583675f, -0.03536184f, 0.04122362f, -0.05627340f, -0.03540817f, 0.02005639f, -0.00034531f, 
    0.00566568f, -0.03881498f, -0.01324156f, -0.01016275f, 0.04597671f, -0.02649350f, 0.04517225f, -0.04645606f, 
    -0.02905199f, 0.00719121f, 0.02024040f, 0.02959253f, -0.01122464f, 0.03610707f, -0.00887142f, 0.00786178f, 
    -0.02603536f, 0.01579617f, 0.04053104f, -0.04314194f, -0.00784040f, -0.00529611f, -0.03537405f, -0.02667548f, 
    0.03179567f, 0.03638979f, 0.04343842f, -0.03474969f, 0.00300033f, -0.03823549f, -0.00353055f, 0.01304334f, 
    -0.00483232f, 0.04295778f, -0.00530134f, -0.00336649f, -0.01430472f, -0.04281917f, 0.02920227f, 0.05080424f, 
    0.02250677f, 0.03418468f, -0.01998515f, 0.02264814f, 0.03953198f, 0.02152357f, 0.02455718f, 0.02773214f, 
    0.00602375f, 0.00850380f, 0.02625494f, -0.02917318f, -0.04651141f, 0.00099214f, 0.03483893f, -0.01294221f, 
    0.03922099f, -0.01895906f, 0.02569539f, -0.00072483f, 0.02888157f, -0.03957183f, 0.02110157f, 0.02988398f, 
    -0.02354333f, 0.00658593f, -0.04730592f, -0.00762818f, -0.04092493f, 0.00898034f, 0.03078448f, 0.00382677f, 
    -0.01920657f, -0.01631164f, 0.03448673f, -0.05285516f, -0.03634737f, 0.01224045f, 0.02641248f, -0.03179163f, 
    0.02606771f, 0.00853697f, -0.05479065f, 0.02612629f, -0.01187477f, -0.04600373f, 0.01486530f, 0.02154293f, 
    -0.03617195f, -0.01020363f, -0.04152150f, 0.01247110f, -0.02317288f, 0.01960848f, 0.03053207f, -0.03900179f, 
    0.02943766f, -0.04683053f, -0.05138710f, 0.01129534f, 0.00624973f, 0.01735942f, -0.03412331f, -0.04271578f, 
    -0.00071783f, 0.02749318f, -0.04351274f, 0.03696548f, 0.00487577f, -0.00220886f, 0.01348957f, -0.01272375f, 
    -0.04875649f, -0.01130175f, 0.03225379f, 0.02117679f, -0.03186053f, 0.03105067f, -0.01752156f, -0.00236566f, 
    0.02880604f, 0.01625027f, -0.03712246f, 0.04270805f, -0.02083598f, 0.03080006f, -0.04209530f, 0.02882506f, 
    0.04139577f, -0.04103412f, -0.05379742f, -0.02976349f, -0.05122053f, 0.00623831f, -0.01881741f, 0.01676261f, 
    0.04129716f, -0.04670004f, -0.02524836f, -0.01067258f, 0.03143429f, 0.01265930f, 0.01201809f, -0.02785089f, 
    0.03062649f, -0.00738576f, 0.04690623f, 0.03087711f, -0.02287175f, 0.03046642f, 0.04117024f, -0.00422652f, 
    0.03669020f, -0.04235359f, 0.02347012f, -0.00415240f, -0.01782423f, -0.03100606f, 0.03611916f, -0.03057523f, 
    0.04181379f, -0.03367177f, -0.02864624f, 0.04414688f, 0.00764860f, 0.00492730f, -0.05826096f, -0.02128867f, 
    0.02451966f, -0.00109197f, -0.03441510f, 0.02085220f, -0.04817176f, 0.01941289f, -0.01809445f, -0.04257371f, 
    -0.01978592f, 0.01027494f, -0.02280787f, -0.05635047f, -0.01744298f, -0.03170329f, -0.03117651f, -0.02195242f, 
    -0.05748452f, 0.01385518f, -0.00182476f, -0.02990866f, 0.01924670f, 0.01953759f, -0.00124303f, 0.00202849f, 
    -0.05485965f, -0.03631357f, -0.03267727f, 0.00609001f, -0.03782284f, -0.00877794f, 0.02480746f, 0.03809739f, 
    0.03125741f, -0.05108989f, 0.02492733f, -0.05011351f, 0.01499274f, 0.02621911f, -0.05190036f, 0.02810348f, 
    0.00121937f, -0.01189607f, 0.03482540f, 0.04595463f, 0.04362938f, 0.03551686f, 0.01119697f, -0.03022180f, 
    0.03110620f, -0.17784971f, -0.10047563f, 0.07580473f, 0.03970586f, 0.06651562f, 0.09931924f, -0.01842489f, 
    0.11321262f, -0.05266186f, -0.00469735f, -0.02330314f, -0.21880777f, -0.03503349f, 0.03304131f, 0.06459361f, 
    0.13702817f, -0.01324131f, -0.06059651f, 0.05408058f, 0.05058824f, -0.02009523f, 0.08229958f, 0.15518504f, 
    -0.20384148f, -0.05565174f, -0.15075950f, -0.01036379f, 0.01807527f, -0.20786178f, -0.10840412f, -0.12039290f, 
    0.06821396f, 0.09284075f, -0.01470550f, 0.07006366f, -0.07016920f, -0.07443409f, 0.04628572f, 0.18090022f, 
    0.03068541f, -0.07974666f, -0.03123743f, -0.06619834f, 0.08111230f, -0.08360177f, 0.08006659f, 0.00814905f, 
    0.11796556f, 0.04357472f, -0.14659208f, -0.15536626f, -0.02759951f, -0.04731657f, 0.08108092f, 0.05266644f, 
    -0.03808678f, -0.12482601f, 0.22094256f, -0.08437821f, -0.20462491f, -0.14995299f, -0.01480245f, -0.10847364f, 
    0.06029489f, -0.05581135f, 0.13441332f, -0.01462260f, 0.01735290f, 0.12402923f, -0.04137412f, 0.22649463f, 
    0.33870170f, -0.06054724f, 0.20454331f, 0.08727932f, -0.00093983f, -0.03499957f, 0.05992034f, -0.04431742f, 
    0.11987148f, -0.16303721f, 0.07965845f, -0.14988756f, -0.12001594f, -0.02842507f, -0.27782187f, 0.06443584f, 
    0.16938639f, -0.04312448f, 0.02785925f, 0.12148519f, 0.03933492f, 0.03455015f, 0.05076846f, 0.17905810f, 
    -0.12179781f, 0.17593266f, 0.06371606f, -0.13100107f, 0.25782546f, -0.16225463f, -0.29098216f, -0.06198921f, 
    0.03586834f, 0.01567588f, 0.02399292f, 0.07800881f, 0.02421367f, 0.18952699f, 0.22395034f, -0.00610893f, 
    0.08602030f, 0.11679289f, -0.06116081f, 0.22113198f, 0.10866980f, 0.00837094f, -0.10046650f, 0.14675899f, 
    -0.03990829f, 0.12970279f, 0.01793854f, 0.01003978f, -0.11321914f, 0.08193442f, 0.11147039f, 0.10884190f, 
    0.08308050f, -0.08850489f, -0.11974217f, 0.07143382f, -0.52371293f, -0.17791022f, 0.08134055f, 0.04064439f, 
    0.17571744f, -0.05373000f, -0.17640074f, 0.10504999f, 0.25151297f, 0.09148408f, -0.26701817f, 0.11576267f, 
    -0.10135812f, -0.18976784f, -0.11650280f, -0.09442662f, -0.07438266f, -0.00760277f, -0.05381194f, 0.00566951f, 
    0.06150154f, 0.12182026f, 0.17669119f, -0.03648359f, 0.03375062f, 0.05862895f, 0.29687586f, 0.19165878f, 
    0.09846415f, -0.02874293f, 0.07385077f, 0.14643814f, -0.00603285f, 0.01241434f, 0.11736799f, 0.08755936f, 
    0.01635543f, -0.14962558f, -0.02170481f, 0.15971376f, 0.07954039f, 0.07747753f, -0.05085687f, 0.03360999f, 
    0.01868273f, -0.01426267f, 0.02522386f, -0.16348147f, -0.01770362f, -0.15023491f, -0.30337942f, -0.01978312f, 
    -0.00695216f, 0.00399661f, 0.08973151f, -0.02168100f, 0.04133325f, 0.02134079f, 0.07162035f, 0.02008876f, 
    0.54269928f, 0.01548414f, -0.30012634f, -0.03772134f, -0.05419150f, 0.03877970f, 0.00444481f, -0.19578514f, 
    0.06240689f, -0.04795295f, -0.09211201f, -0.11787254f, -0.17196512f, -0.13394661f, -0.19276708f, -0.00050802f, 
    0.12401982f, -0.12822179f, -0.09267502f, -0.01339517f, -0.17167571f, 0.10522915f, 0.02617024f, -0.04734286f, 
    0.32062960f, 0.08178142f, 0.18150814f, -0.02722782f, 0.01836715f, -0.18395057f, 0.05042933f, 0.11591288f, 
    0.09857808f, -0.05647018f, -0.00752187f, -0.13108371f, 0.05244849f, -0.20103344f, -0.02207877f, -0.03320510f, 
    0.03671373f, -0.03340062f, 0.02321665f, -0.03951497f, -0.05690616f, -0.04253431f, 0.06863394f, 0.11628696f, 
    -0.28990859f, -0.05837166f, -0.16437483f, -0.06305774f, -0.09028648f, -0.10252789f, 0.01810171f, -0.14037833f, 
    -0.00608351f, 0.01845671f, 0.03121956f, 0.10735966f, -0.20120123f, -0.09922872f, 0.08899282f, 0.25144514f, 
    0.17128570f, 0.08108990f, -0.02700343f, 0.06784140f, 0.04682773f, -0.05428329f, 0.01542462f, 0.04287162f, 
    -0.17224802f, -0.08913771f, -0.04023323f, -0.09046812f, 0.11684003f, -0.00562131f, -0.08483468f, 0.09472788f, 
    -0.24848883f, -0.19742711f, -0.07004104f, -0.26060870f, 0.02742671f, 0.14572641f, 0.06893639f, -0.03312988f, 
    0.01828909f, 0.09009624f, 0.17545488f, -0.04028489f, 0.04120505f, -0.03298718f, 0.03281215f, 0.07122818f, 
    0.31533262f, 0.28958130f, 0.12112154f, 0.20349976f, -0.03812556f, 0.03742765f, -0.11698303f, -0.13687918f, 
    0.03723451f, 0.01857474f, -0.00439945f, 0.00683645f, 0.16550183f, -0.22055079f, 0.21293662f, 0.05761538f, 
    0.09946949f, 0.05455277f, 0.25889105f, 0.04761339f, 0.11038645f, 0.01170250f, 0.00204344f, 0.09107077f, 
    -0.34165236f, -0.07279208f, 0.07564984f, -0.02772189f, 0.03014369f, -0.02753741f, -0.06366820f, 0.04796552f, 
    0.06580330f, 0.02040603f, 0.05261403f, 0.17124371f, -0.04301052f, 0.25165707f, 0.02072758f, -0.08162288f, 
    0.03358057f, 0.08972324f, -0.12324571f, 0.17077732f, -0.09864830f, -0.02261419f, 0.06157477f, 0.00796476f, 
    -0.07464729f, 0.01938818f, 0.08929010f, -0.09447998f, -0.16147068f, 0.09558803f, -0.08276034f, -0.17558368f, 
    0.08492970f, 0.03316237f, 0.05142597f, 0.03998904f, -0.12810971f, -0.12822388f, -0.14587048f, -0.07676748f, 
    0.00803876f, -0.03927021f, -0.01522192f, 0.02300546f, 0.12986626f, 0.08816852f, 0.15421654f, 0.08943455f, 
    0.18628791f, 0.14410181f, -0.18579006f, -0.05873875f, -0.07930285f, -0.03551068f, -0.04901571f, -0.11701164f, 
    -0.09711317f, -0.04063847f, 0.01053515f, -0.15055229f, -0.16256066f, -0.04485689f, -0.05259980f, 0.16836035f, 
    0.10417405f, 0.16262342f, 0.12785134f, -0.09195329f, 0.05135034f, -0.02626734f, -0.06561372f, -0.12310736f, 
    -0.09711804f, -0.16705111f, 0.03315618f, -0.11748993f, 0.00206300f, 0.07105873f, -0.12731506f, 0.00378542f, 
    0.01833479f, -0.07688274f, -0.04832690f, -0.06070866f, 0.09682035f, 0.04032953f, 0.24230453f, -0.00563603f, 
    0.04735494f, -0.09504222f, 0.00336904f, 0.07303863f, -0.09996142f, 0.02993304f, -0.00484176f, -0.04480456f, 
    -0.03591967f, 0.17137104f, -0.06499223f, -0.02662821f, -0.03291401f, 0.03221802f, -0.04703776f, 0.04085849f, 
    -0.01422150f, 0.10071501f, 0.06998318f, 0.06297783f, 0.00860167f, -0.00853626f, -0.11814518f, 0.02704698f, 
    0.11577861f, -0.19092594f, 0.09171419f, 0.13031614f, 0.07893667f, 0.00804239f, -0.01755931f, 0.02070348f, 
    0.01827415f, 0.11337882f, -0.14869776f, 0.01759274f, -0.11153551f, 0.00655714f, -0.03548999f, 0.02285316f, 
    -0.12137323f, 0.12807904f, 0.16239303f, -0.08854422f, 0.02673815f, -0.09968009f, 0.48523566f, -0.06667791f, 
    0.23573774f, 0.00786936f, 0.02789538f, 0.05083878f, -0.03318958f, -0.05027350f, 0.24016945f, -0.03045323f, 
    0.02630322f, 0.24147296f, 0.09132054f, 0.19863944f, 0.09784653f, -0.00136865f, 0.06513247f, 0.08223400f, 
    0.11173431f, -0.01344818f, 0.14036939f, 0.04690171f, 0.19677588f, 0.05987322f, -0.04094213f, 0.26023951f, 
    0.03817838f, -0.08339392f, 0.05371952f, -0.08211827f, -0.06714648f, 0.15426737f, 0.14833181f, 0.04381673f, 
    0.37460887f, -0.06543306f, 0.41455564f, -0.03509972f, 0.03102504f, -0.05396343f, -0.15470871f, 0.16410787f, 
    -0.08540316f, -0.06401323f, -0.08473606f, -0.12698457f, 0.21116999f, 0.33185017f, 0.13302350f, 0.06731885f, 
    0.10824901f, -0.00339999f, 0.00026747f, 0.01385646f, -0.00409507f, 0.06616665f, 0.07196802f, 0.19658639f, 
    -0.46589085f, -0.03370702f, -0.29258442f, -0.08504705f, 0.02728330f, 0.04887690f, 0.08239093f, -0.02258933f, 
    -0.04829444f, 0.04605089f, 0.05221714f, 0.11754216f, -0.09132953f, -0.07276510f, -0.05396269f, -0.16066946f, 
    0.10069118f, -0.02991190f, -0.09120931f, 0.20931590f, 0.08516366f, -0.13006423f, 0.01330660f, 0.15159413f, 
    -0.11009100f, -0.02503907f, -0.13280268f, 0.00080629f, 0.06176826f, -0.03105524f, 0.09470160f, 0.01202237f, 
    0.05897626f, 0.11029443f, 0.03406908f, 0.07680788f, 0.13298744f, 0.00071019f, 0.43632877f, -0.05242326f, 
    -0.10384487f, 0.01820071f, -0.12478182f, 0.18163259f, 0.05209333f, -0.00063728f, 0.07890266f, 0.02710916f, 
    0.10301140f, 0.00988213f, -0.01657794f, 0.03653165f, 0.10405492f, 0.13062930f, -0.12861039f, 0.03650045f, 
    -0.06905421f, 0.00118470f, -0.08754846f, -0.15066329f, -0.01425010f, -0.05594465f, -0.18783006f, 0.03256360f, 
    -0.03285841f, 0.02646464f, 0.02121884f, 0.10295434f, 0.08892449f, 0.01503535f, 0.10638583f, 0.19829312f, 
    0.01894269f, -0.30662969f, -0.14457062f, 0.19299360f, -0.07703882f, 0.08506925f, -0.03747732f, 0.19252993f, 
    0.01616813f, 0.03609580f, 0.04125282f, 0.04761782f, 0.01612252f, -0.04174341f, 0.26522171f, -0.06790346f, 
    0.18670562f, 0.03957962f, -0.00982821f, -0.06075803f, 0.03176028f, -0.06083167f, -0.00719625f, -0.12657186f, 
    -0.11813162f, -0.09351823f, 0.03021405f, 0.04201024f, -0.08123068f, -0.01002218f, 0.02218255f, -0.21971661f, 
    0.06720337f, 0.05011429f, 0.18863541f, 0.09247806f, 0.08814199f, 0.01629476f, 0.00267227f, 0.10062850f, 
    -0.01946626f, -0.08013451f, -0.03916807f, 0.02762702f, -0.00611591f, 0.00702980f, -0.10266488f, 0.24917853f, 
    0.06422494f, 0.14583790f, 0.12143659f, -0.07181384f, 0.08904668f, 0.09624059f, 0.03004229f, 0.08202226f, 
    -0.00233795f, 0.06606522f, 0.01694452f, -0.10614678f, -0.38122001f, 0.12009086f, 0.02665024f, 0.01836168f, 
    0.14861862f, -0.08224042f, 0.10426240f, 0.31871396f, 0.01861719f, 0.09794959f, -0.06785637f, -0.09736539f, 
    -0.17165458f, 0.01831391f, -0.24572484f, -0.08543735f, 0.00915191f, -0.08966135f, 0.03913831f, -0.01373978f, 
    0.03744862f, -0.04379266f, -0.13683939f, -0.12616509f, 0.05859980f, 0.13895081f, 0.02806765f, 0.11186045f, 
    0.02868994f, 0.16582911f, -0.06917395f, -0.02911448f, 0.02138904f, -0.04095972f, -0.11925467f, -0.03814290f, 
    0.14779414f, 0.17443758f, 0.07929054f, 0.11179199f, 0.07391252f, 0.11330983f, -0.21253571f, 0.00440273f, 
    -0.17889102f, 0.02687945f, 0.10741832f, 0.09842894f, -0.05722594f, -0.01366309f, -0.17140010f, 0.32613632f, 
    0.03129591f, 0.22234668f, 0.05344952f, 0.02071537f, -0.06015223f, -0.05770545f, 0.00666532f, 0.08579916f, 
    0.08600887f, 0.11287792f, -0.05918854f, 0.03910924f, -0.01276007f, 0.03165107f, 0.00171167f, 0.00666894f, 
    0.01451777f, 0.01006288f, 0.03686264f, 0.13548245f, 0.06035134f, 0.22328806f, 0.32074407f, 0.24154466f, 
    -0.10682431f, -0.13924369f, 0.09230086f, -0.09729692f, -0.06739167f, -0.05111067f, 0.04213158f, -0.12961641f, 
    0.45687255f, -0.16650614f, -0.12751150f, -0.09372525f, -0.02723685f, 0.31290698f, -0.02571523f, 0.29548830f, 
    -0.06730051f, 0.03462908f, 0.04408034f, -0.06425638f, -0.18214197f, 0.16060275f, -0.15874079f, 0.05778449f, 
    -0.04487216f, 0.07234596f, 0.03493810f, -0.00837794f, 0.03934855f, -0.03697208f, -0.07529587f, 0.09183697f, 
    0.33395806f, 0.14632936f, 0.28852284f, -0.08925695f, -0.09570917f, -0.14076735f, -0.06265032f, -0.17687801f, 
    -0.00156091f, 0.06114462f, 0.08358768f, -0.01683384f, -0.26312494f, -0.38868654f, -0.16526884f, -0.18658975f, 
    0.02211734f, -0.06266012f, 0.16778636f, 0.16501732f, 0.07559091f, 0.02133679f, -0.00384944f, -0.15307519f, 
    0.14849636f, -0.25899777f, -0.00740795f, -0.01475376f, -0.02678540f, -0.06910630f, -0.01223647f, 0.05161783f, 
    0.05337543f, 0.12189677f, 0.20298390f, 0.04272574f, -0.37634170f, -0.27572462f, -0.22884966f, 0.12296310f, 
    0.18969533f, 0.19577013f, -0.03233241f, 0.06386063f, 0.05283754f, -0.03288471f, -0.04626827f, 0.15953889f, 
    0.17153849f, -0.10183703f, -0.19058795f, 0.06476396f, 0.05208423f, 0.09128621f, 0.08374302f, -0.00251247f, 
    0.09300530f, 0.07084422f, -0.04688727f, -0.11375005f, -0.12971233f, -0.01276469f, 0.10402765f, -0.03471187f, 
    0.08821901f, -0.02406958f, 0.11187730f, -0.14787841f, 0.07216132f, -0.12001625f, 0.17865412f, 0.12470608f, 
    0.19139075f, -0.08455721f, 0.07489890f, -0.01639399f, 0.03579528f, 0.02550313f, 0.13761957f, 0.09500539f, 
    0.09595791f, 0.03291334f, -0.01009877f, -0.02286819f, -0.34108591f, -0.22382979f, -0.04404299f, -0.05157496f, 
    0.02921920f, 0.03418257f, 0.05399969f, 0.00309541f, 0.05075720f, 0.04862940f, -0.12749763f, 0.01516630f, 
    0.37665641f, 0.00626101f, 0.09619935f, -0.01763376f, -0.02523131f, 0.02224882f, 0.04809915f, -0.02125110f, 
    0.02522869f, -0.04248612f, 0.21265429f, 0.03280659f, 0.06272321f, -0.12503077f, -0.22136889f, -0.15351269f, 
    0.12604843f, -0.14709422f, 0.08930266f, 0.13483439f, 0.06163179f, -0.12355970f, -0.08795683f, 0.15894584f, 
    -0.06443000f, 0.18209212f, -0.47934002f, -0.12755400f, 0.05981344f, 0.02987434f, -0.05325824f, 0.05083020f, 
    0.02675080f, -0.06138033f, 0.00907002f, 0.05465147f, -0.13679478f, 0.12360380f, 0.26181582f, -0.04861139f, 
    -0.04859330f, 0.03421555f, -0.04145123f, -0.03862572f, -0.01533567f, 0.06535316f, -0.10571437f, -0.12198735f, 
    0.16391942f, 0.23783012f, 0.25253108f, 0.15252899f, -0.07866748f, 0.06901151f, -0.02024946f, 0.04605852f, 
    0.03597446f, 0.03532123f, 0.03163256f, -0.00915631f, -0.85029942f, -0.17047630f, 0.09919165f, 0.43200824f, 
    0.20874432f, -0.03015721f, -0.17918114f, 0.00398848f, 0.13570808f, 0.11761896f, -0.09230996f, -0.00341325f, 
    0.06270192f, -0.11181433f, 0.04965886f, 0.03565619f, 0.08189382f, 0.08356100f, -0.02637687f, 0.11105128f, 
    0.06140498f, 0.02285005f, -0.09281993f, -0.24562277f, 0.01524222f, 0.23202543f, 0.19375429f, -0.07780494f, 
    0.06389324f, -0.13482724f, -0.08976488f, 0.09100232f, -0.09047621f, -0.07940236f, 0.05107813f, -0.02016140f, 
    -0.09025934f, 0.02104547f, 0.06301346f, -0.07031748f, 0.03995860f, -0.05583024f, -0.07782296f, 0.09903026f, 
    0.10433894f, 0.10123435f, 0.29929930f, -0.05550959f, -0.32203647f, -0.09417202f, -0.14981982f, 0.10020044f, 
    0.00866362f, -0.01704008f, 0.04525574f, -0.02025483f, -0.04064623f, 0.02879006f, -0.04185895f, -0.11582847f, 
    0.83703375f, -0.33435231f, -0.08421820f, -0.10846869f, -0.07985765f, -0.16214524f, -0.11967562f, 0.12886769f, 
    0.03395001f, 0.06554156f, -0.12438031f, 0.02151464f, -0.28738421f, -0.16581640f, -0.47639656f, 0.17231946f, 
    0.11066189f, 0.06800898f, 0.08028274f, 0.05434446f, -0.04117047f, 0.07582406f, 0.06730976f, 0.21451181f, 
    0.33665809f, 0.18146406f, 0.18017200f, -0.03217012f, -0.01999482f, 0.05591480f, 0.12532309f, -0.00681596f, 
    0.05311267f, -0.02191814f, -0.07148656f, -0.03449814f, 0.19550519f, -0.42425242f, 0.05478587f, -0.23499812f, 
    -0.03319266f, -0.06444330f, 0.07641733f, -0.12039031f, -0.09820019f, -0.08546223f, 0.23254125f, 0.10484621f, 
    0.20489271f, 0.23096427f, -0.23871878f, -0.12053932f, 0.08448192f, 0.12394595f, 0.11391129f, 0.02630646f, 
    -0.02846887f, -0.06816267f, 0.06042331f, 0.04832207f, 0.15736043f, 0.06433018f, 0.02516928f, -0.06212512f, 
    -0.05913191f, 0.11799879f, -0.03116493f, -0.08263633f, 0.11245605f, -0.01428104f, 0.05845797f, -0.03718016f, 
    0.02485156f, -0.34789693f, 0.01665964f, -0.10064666f, 0.09934564f, -0.04595754f, -0.08375175f, -0.05954375f, 
    -0.23960277f, -0.11192897f, 0.18423647f, 0.09757501f, 0.16809888f, 0.07008944f, -0.00055924f, -0.08028338f, 
    -0.01005225f, 0.06654003f, 0.14003012f, 0.00860924f, -0.12442109f, -0.14026463f, 0.06420974f, -0.13437168f, 
    0.21140678f, 0.07626022f, -0.00292935f, -0.11504629f, 0.10855755f, 0.04885676f, 0.20857546f, 0.02475305f, 
    0.06298688f, -0.03328107f, 0.03675109f, 0.06794938f, 0.30553076f, -0.21941763f, 0.08939450f, 0.05286304f, 
    0.03412075f, -0.05615893f, 0.21336435f, 0.01570275f, 0.16269934f, -0.03555330f, -0.08028430f, 0.06359946f, 
    -0.29127392f, -0.44994387f, -0.03509384f, 0.01193302f, 0.07223663f, 0.09688570f, 0.04395332f, 0.03653973f, 
    -0.14434160f, -0.03979746f, 0.05957874f, -0.04944020f, -0.00269297f, 0.36768782f, 0.04912319f, -0.01668687f, 
    0.00226944f, 0.11676420f, -0.09661786f, 0.02293644f, 0.14253636f, 0.02521969f, 0.00157498f, -0.05363009f, 
    -0.06995854f, -0.13656586f, -0.05702627f, -0.45843336f, -0.02729681f, 0.09047680f, 0.07941149f, -0.06109477f, 
    -0.00659723f, -0.08377195f, -0.10027526f, -0.09242354f, 0.15927930f, -0.34165224f, 0.03133487f, 0.12462387f, 
    0.10772301f, -0.00923139f, 0.03832623f, -0.00610330f, -0.02881622f, 0.01598501f, 0.01469687f, -0.05684984f, 
    0.21987937f, 0.15588658f, -0.33623901f, -0.12848581f, 0.05534821f, -0.06628229f, 0.01543317f, 0.03291555f, 
    -0.11740852f, 0.03370674f, 0.11534543f, -0.07646561f, -0.01665445f, 0.14496960f, 0.03231240f, 0.02645792f, 
    -0.03099516f, 0.12086587f, -0.12980664f, -0.08096417f, 0.08123810f, -0.01774471f, 0.01454917f, 0.06544508f, 
    0.12937155f, 0.01710367f, 0.00052902f, -0.06368044f, 0.01221717f, -0.12689815f, -0.20931864f, 0.02453665f, 
    0.12298024f, -0.12049951f, 0.03977803f, -0.05286267f, 0.05058262f, -0.03158939f, -0.07121033f, -0.01032462f, 
    -0.16766089f, -0.06494712f, -0.01796673f, -0.14058952f, -0.07938852f, 0.02863750f, -0.02716305f, -0.01610613f, 
    0.09604207f, -0.19999106f, -0.03912482f, -0.03619318f, -0.00939227f, -0.10485955f, -0.00060694f, -0.01470360f, 
    -0.00766258f, 0.19972524f, 0.00568160f, -0.01773249f, 0.11267234f, -0.02174563f, 0.04925590f, 0.07900450f, 
    -0.02605749f, -0.07329158f, -0.25742486f, 0.12364265f, -0.09104475f, -0.01405725f, 0.13607989f, -0.21717449f, 
    -0.10395472f, -0.17402406f, -0.07762697f, -0.15912688f, 0.05180696f, -0.04673786f, -0.07313095f, 0.02065914f, 
    -0.06600626f, -0.06829467f, -0.07495163f, -0.07570488f, 0.08354788f, -0.00420867f, 0.19627027f, 0.05908603f, 
    0.13673908f, 0.08190413f, 0.32127506f, 0.00665446f, -0.01373633f, 0.09102443f, 0.15415852f, 0.09765358f, 
    0.14360368f, 0.25582358f, -0.03030088f, 0.07775431f, 0.17614539f, 0.00763722f, 0.12071330f, 0.06584698f, 
    0.02606957f, -0.06001218f, -0.14205769f, -0.19825980f, 0.00348312f, 0.15072303f, 0.13138883f, 0.52248931f, 
    0.09621045f, 0.16914703f, 0.02249936f, -0.07906358f, -0.08603073f, 0.09895501f, 0.30976602f, 0.08207073f, 
    0.31863981f, -0.25898981f, -0.19531995f, -0.16771397f, 0.00091650f, -0.00198197f, 0.11484585f, -0.07397742f, 
    -0.02444812f, 0.04411800f, -0.07787808f, 0.01787488f, -0.11512736f, 0.11788824f, 0.15652876f, 0.06261994f, 
    0.12076043f, 0.08873641f, 0.06040649f, 0.13193971f, 0.04714734f, 0.09560336f, 0.10554113f, 0.23312154f, 
    -0.24401692f, 0.05774403f, -0.19350855f, -0.08750253f, -0.15922329f, 0.01129265f, 0.09603102f, 0.18767160f, 
    -0.11346788f, -0.04692479f, -0.08807767f, 0.03368956f, -0.17180251f, -0.01838765f, 0.08575464f, 0.00234146f, 
    0.08340721f, -0.06626765f, -0.13752706f, 0.13899814f, 0.15503047f, 0.04868357f, 0.04851507f, 0.14465427f, 
    -0.22083211f, -0.01447051f, -0.10669480f, -0.01080939f, -0.16218941f, -0.08282962f, 0.07334246f, -0.00817080f, 
    0.12823005f, 0.14374188f, 0.13823071f, 0.01020382f, 0.07848720f, -0.01389844f, 0.22753581f, 0.11257416f, 
    -0.06520937f, 0.09234890f, 0.04201273f, 0.14600275f, 0.04908616f, 0.16107026f, -0.00179781f, 0.18645787f, 
    0.13569978f, 0.08136776f, 0.10186499f, -0.09950950f, 0.03358076f, 0.09298395f, -0.04164552f, 0.10275444f, 
    0.00554395f, -0.09515409f, -0.11963396f, -0.19737023f, -0.01554552f, 0.04259026f, 0.08199744f, 0.22806872f, 
    -0.04559495f, -0.05707591f, 0.10437664f, -0.09385476f, 0.15022382f, 0.08751711f, 0.14326164f, 0.16871141f, 
    0.46655166f, 0.14273569f, -0.36781108f, 0.16239336f, -0.10978056f, -0.02616332f, -0.24996363f, 0.13451664f, 
    0.10438567f, -0.14848480f, -0.08121555f, 0.03608402f, 0.01813500f, -0.18123804f, 0.03493582f, 0.00266257f, 
    -0.00243482f, 0.01224344f, 0.04487552f, 0.14141025f, 0.02661179f, -0.19948752f, -0.25267652f, -0.27956435f, 
    -0.05668397f, -0.05046119f, -0.03357367f, 0.21301177f, -0.04268336f, 0.05802861f, -0.02638964f, -0.10450402f, 
    -0.01496681f, -0.01427829f, 0.01499215f, -0.03674687f, -0.15541197f, 0.08666649f, 0.08780528f, 0.03817762f, 
    0.10437011f, -0.03182673f, -0.15253434f, -0.06468587f, -0.09361417f, -0.00339650f, 0.13281490f, -0.17196491f, 
    -0.01409973f, -0.12487432f, -0.07662446f, -0.02626549f, 0.07059338f, 0.09057641f, 0.15081584f, -0.11794100f, 
    0.00165855f, 0.05601916f, 0.01096495f, 0.05891869f, -0.42446166f, -0.04084305f, -0.15428793f, 0.30621874f, 
    0.12792903f, -0.04712412f, 0.07328413f, 0.16196245f, -0.04883051f, 0.13569807f, -0.02131351f, -0.02243442f, 
    -0.05658112f, 0.11889116f, -0.10690818f, -0.03085637f, -0.02904175f, -0.12857358f, -0.07401532f, -0.09462630f, 
    -0.16677079f, -0.26926619f, -0.02209694f, -0.31281096f, 0.00188556f, 0.03239669f, 0.27481383f, -0.02154917f, 
    -0.06125847f, 0.11556210f, 0.17115095f, 0.26442009f, 0.09956118f, 0.08623626f, 0.00591322f, 0.03592429f, 
    0.28704682f, 0.07600243f, 0.17043021f, 0.11604847f, -0.00905930f, 0.05660556f, 0.04201523f, -0.10448664f, 
    0.03073265f, 0.05047543f, 0.01677651f, -0.06411832f, -0.24425104f, 0.09456723f, 0.29581571f, 0.36635640f, 
    -0.04204291f, 0.16695732f, 0.06960841f, 0.09801802f, 0.09992469f, 0.10722180f, 0.03401293f, 0.11157579f, 
    -0.04091011f, 0.15285982f, -0.08988753f, 0.04105658f, -0.12656747f, -0.02777418f, -0.07471113f, -0.08468191f, 
    0.08646026f, -0.00757252f, -0.03972486f, -0.03291451f, -0.17400877f, 0.00984762f, 0.21335657f, 0.02135441f, 
    -0.00893009f, -0.07933176f, -0.02148015f, 0.14657532f, -0.18527010f, -0.05958974f, 0.02821337f, -0.07972197f, 
    0.17172921f, -0.06175091f, -0.00921728f, -0.12696736f, -0.04193880f, 0.32563502f, -0.19667196f, 0.09386922f, 
    0.07485989f, 0.02542801f, 0.14992253f, -0.00636299f, -0.13211915f, 0.07232922f, -0.06769980f, 0.01300566f, 
    -0.10681356f, -0.02618087f, -0.01835156f, -0.00400467f, 0.16314819f, 0.17108271f, 0.08815610f, 0.09682004f, 
    0.09789121f, -0.11839209f, 0.02793579f, 0.03016620f, 0.09153880f, 0.06199514f, 0.07615612f, -0.03766635f, 
    -0.18205784f, -0.22924551f, 0.01249286f, -0.06187139f, -0.50397378f, -0.00922856f, -0.06285718f, -0.26114070f, 
    -0.19586058f, -0.18007655f, -0.16390535f, 0.07790488f, -0.06244487f, 0.09060919f, -0.01033815f, -0.15758865f, 
    0.19642699f, 0.28213349f, 0.01523170f, -0.03696896f, 0.06020078f, -0.02096083f, 0.01450443f, -0.10534678f, 
    0.06897776f, 0.10813285f, 0.09715925f, 0.14781235f, 0.11120348f, 0.03671867f, -0.12192048f, -0.08520175f, 
    -0.16054186f, -0.06581363f, 0.00867238f, -0.02286372f, 0.02745968f, -0.02438209f, -0.01911112f, -0.10613694f, 
    0.34623802f, -0.23721962f, 0.06590185f, -0.07211549f, -0.04611615f, 0.11526933f, -0.07857432f, -0.04151994f, 
    -0.03815189f, 0.03164507f, 0.03160704f, -0.23338345f, -0.04571744f, 0.11689890f, 0.03466929f, -0.04051492f, 
    -0.10014826f, 0.06349960f, -0.14106888f, -0.10471120f, 0.08809435f, 0.15590873f, 0.01413976f, 0.02199240f, 
    -0.08583297f, -0.19131537f, 0.04768166f, 0.01629240f, 0.13004605f, 0.04188256f, 0.02959263f, 0.06003836f, 
    0.03896996f, -0.01119515f, -0.01732737f, 0.02535572f, 0.19725898f, -0.13768733f, 0.26528350f, -0.04131720f, 
    -0.05179110f, 0.08809278f, 0.06727018f, -0.07794763f, -0.12781850f, 0.14586975f, -0.09079517f, -0.01189214f, 
    -0.03787696f, 0.17658640f, -0.04498310f, 0.13397281f, 0.08731250f, -0.01399459f, 0.15028779f, 0.01519626f, 
    0.02014148f, 0.11424467f, 0.01970518f, 0.05826184f, -0.38799310f, 0.03784062f, 0.12237290f, 0.29620874f, 
    0.02702233f, 0.17690754f, 0.04134957f, -0.04390197f, 0.10323054f, -0.05020593f, 0.14609376f, -0.02755626f, 
    0.09883000f, -0.47205445f, 0.10531391f, -0.50487161f, 0.06564053f, -0.07008120f, 0.06329150f, -0.10819128f, 
    0.00580161f, -0.03531805f, -0.05588083f, -0.03730405f, -0.09515119f, -0.05901290f, -0.17898634f, -0.13418245f, 
    0.03296515f, -0.06198971f, 0.02759222f, -0.03018852f, -0.05507478f, 0.11704440f, 0.07377162f, 0.08574750f, 
    0.12722656f, 0.32791215f, -0.19965447f, -0.06676817f, -0.05291532f, -0.00376523f, 0.04344158f, 0.18451785f, 
    -0.20407823f, 0.02306577f, -0.03412100f, 0.14525537f, 0.15071957f, -0.13929689f, 0.02443588f, 0.00548239f, 
    0.06660228f, -0.08747572f, -0.02197909f, -0.09062271f, 0.11912522f, 0.06024367f, -0.01653149f, 0.02714394f, 
    -0.21404243f, 0.05652270f, -0.02658688f, -0.02634016f, -0.07158452f, -0.05158672f, 0.17937551f, -0.07200051f, 
    -0.10264950f, -0.06251533f, -0.03576446f, -0.03970171f, -0.03052612f, -0.16617154f, 0.02296282f, 0.11775915f, 
    -0.14730346f, 0.01121007f, 0.02416055f, 0.00897981f, 0.04975747f, 0.06220579f, 0.03603779f, -0.02321844f, 
    0.34162068f, 0.01917415f, -0.00557059f, -0.01167944f, 0.01066300f, -0.00536608f, 0.06523442f, 0.00055402f, 
    -0.02034196f, 0.21326396f, -0.07835660f, 0.05240229f, 0.17330995f, 0.02610810f, 0.08869948f, -0.03096244f, 
    0.14895131f, -0.03375936f, 0.04183597f, -0.05765281f, -0.08390480f, 0.01310513f, -0.20103852f, 0.06810936f, 
    0.01176769f, 0.75277734f, -0.19952472f, 0.17159791f, -0.04760836f, 0.09496559f, -0.11508772f, 0.06293203f, 
    0.11509166f, 0.03867847f, -0.09565909f, 0.21844216f, 0.58262098f, -0.31247881f, 0.12628630f, -0.23010236f, 
    0.15053749f, -0.06898790f, -0.03104683f, 0.07461245f, 0.02804305f, -0.03273264f, 0.01497365f, 0.00863324f, 
    -0.13486744f, -0.01942774f, -0.37029475f, 0.24244180f, -0.08301011f, 0.01606869f, -0.01214967f, -0.07350459f, 
    -0.01706786f, 0.01405760f, 0.08572635f, 0.00320417f, -0.31749701f, 0.28858176f, -0.12764063f, 0.23056731f, 
    -0.19965060f, 0.03123648f, -0.12100697f, 0.00264767f, 0.18519865f, 0.02695761f, 0.23175804f, -0.00009611f, 
    0.15769097f, -0.30702978f, 0.04612024f, 0.16719511f, 0.03075233f, 0.03785229f, 0.02905548f, -0.07056134f, 
    -0.01552735f, -0.02811580f, -0.16020258f, 0.07022693f, -0.35352820f, 0.12959503f, -0.38035825f, 0.36572033f, 
    0.13333181f, -0.13138349f, 0.00660534f, 0.14265445f, -0.08022343f, 0.03500282f, 0.06889188f, 0.14341052f, 
    -0.09686964f, 0.16962966f, 0.02966528f, -0.05855814f, -0.07785431f, -0.10168401f, -0.08216996f, -0.00162344f, 
    -0.09790869f, 0.15637468f, 0.06049113f, 0.09772226f, 0.19032153f, -0.07602187f, 0.35058525f, -0.03822591f, 
    -0.08040094f, -0.00223021f, 0.19135936f, 0.11782496f, -0.13406600f, 0.06459372f, 0.05964144f, -0.11526009f, 
    0.27791700f, 0.36267439f, 0.36558282f, 0.15207708f, 0.06458989f, 0.10232556f, 0.11425364f, -0.07597549f, 
    0.18147080f, -0.01750344f, -0.08883149f, -0.13178279f, -0.31180248f, 0.07260326f, 0.42667213f, 0.05070662f, 
    0.01455322f, 0.19305821f, 0.06277327f, 0.06478539f, 0.05086425f, 0.01682127f, 0.01077907f, -0.08734047f, 
    -0.01258777f, 0.18097763f, -0.08915509f, 0.03642416f, -0.15215060f, -0.03467008f, -0.04968650f, 0.03863728f, 
    -0.07768231f, 0.04646316f, 0.02749417f, -0.12537633f, -0.06287941f, -0.22246449f, -0.02496460f, -0.07315408f, 
    -0.08870215f, 0.10260066f, -0.16427504f, -0.13652623f, -0.02563218f, -0.05611575f, -0.12039652f, 0.00225925f, 
    -0.12159245f, 0.08115350f, -0.00156342f, 0.09039100f, -0.18985370f, 0.08303176f, -0.06851814f, -0.18627268f, 
    -0.22398251f, -0.10053554f, 0.19292448f, -0.04329720f, -0.08732433f, -0.02778757f, -0.05556869f, -0.04261900f, 
    0.13252488f, -0.01326760f, 0.01874399f, 0.12560688f, -0.03042938f, 0.08638669f, -0.05557606f, -0.00088820f, 
    -0.06492249f, -0.16426027f, -0.05494562f, -0.02093070f, 0.06308393f, 0.06324333f, 0.10720625f, -0.08647820f, 
    0.00449133f, -0.00198532f, -0.12430752f, 0.17685519f, -0.31488362f, 0.37643504f, 0.14382213f, 0.13078214f, 
    -0.12254455f, 0.16619939f, -0.04372350f, 0.08896936f, -0.01387234f, 0.09655053f, -0.01751247f, -0.08930223f, 
    0.05381816f, 0.12758373f, 0.01223849f, -0.04427953f, 0.00188965f, -0.02450163f, 0.12268473f, 0.01676003f, 
    0.19352449f, 0.03973795f, 0.08450156f, 0.04499135f, 0.08806860f, 0.19962156f, 0.10345048f, 0.03897803f, 
    0.05596061f, -0.08162756f, -0.01055171f, -0.07338187f, -0.04026135f, 0.03031511f, 0.07306228f, 0.03119965f, 
    -0.05167944f, 0.11270871f, 0.03578675f, 0.08236546f, -0.01224763f, 0.00215407f, -0.07573057f, 0.17700118f, 
    0.11532877f, -0.03257916f, 0.04289483f, 0.02367911f, 0.28323528f, -0.11314375f, -0.05813172f, 0.11100558f, 
    0.00487416f, 0.06802205f, 0.04759835f, -0.21266519f, 0.14453310f, 0.20817357f, 0.08196512f, 0.07615905f, 
    -0.12858011f, -0.03223780f, 0.00901759f, -0.24748760f, 0.22798587f, -0.00273017f, 0.08482926f, 0.05855947f, 
    0.04990919f, 0.02785233f, 0.00647227f, 0.04709962f, 0.27331132f, 0.24762329f, -0.48924211f, 0.36315876f, 
    0.11169913f, 0.12563537f, 0.06848342f, -0.03007925f, 0.13984074f, 0.09201197f, 0.08875953f, 0.10044830f, 
    -0.02150187f, -0.19881947f, 0.30010819f, -0.08746045f, -0.04943338f, 0.04233675f, 0.11729030f, -0.00344156f, 
    -0.00630130f, 0.00853049f, -0.18151666f, -0.15226816f, -0.00907444f, 0.13629480f, -0.07889885f, 0.14243101f, 
    -0.02324677f, 0.11115126f, 0.16372763f, 0.07620838f, 0.05622220f, 0.22771062f, 0.08026541f, 0.03068617f, 
    -0.13765229f, 0.25059560f, 0.05493632f, -0.01173803f, 0.06988028f, -0.00897535f, 0.07918777f, -0.11389539f, 
    -0.00983931f, -0.00164465f, 0.02689136f, 0.05767085f, 0.04512971f, -0.44044882f, -0.16468242f, 0.22225718f, 
    0.03242266f, 0.04527496f, 0.06218134f, 0.09105728f, 0.03836325f, -0.00918433f, 0.16252324f, 0.02917008f, 
    -0.03195770f, -0.37398630f, 0.11881213f, -0.00329477f, -0.13851079f, -0.16917583f, -0.05733911f, 0.12754521f, 
    0.11086851f, 0.03669704f, -0.08351652f, -0.08738858f, 0.24752073f, 0.14762928f, 0.06402934f, 0.16457774f, 
    -0.09299438f, 0.10234854f, 0.07521622f, -0.06598769f, -0.06864014f, 0.06989089f, 0.08175205f, 0.30329138f, 
    -0.04381707f, -0.04838002f, 0.00497535f, -0.13413563f, -0.01558559f, -0.00985405f, -0.06475639f, 0.03205360f, 
    0.01508917f, -0.07184413f, 0.04163550f, 0.11968705f, -0.23962806f, -0.48423591f, -0.18295380f, -0.16061406f, 
    0.31503463f, 0.05122907f, 0.07205294f, -0.02846816f, -0.00923069f, 0.03918627f, -0.07607691f, 0.00748386f, 
    -0.05095912f, -0.00127573f, -0.17161575f, 0.09514464f, -0.11396166f, -0.09385771f, 0.08160643f, -0.00534676f, 
    0.07170802f, 0.01894396f, -0.02854006f, 0.08498769f, 0.19804808f, 0.12770078f, 0.11710991f, 0.14132871f, 
    0.04042762f, -0.05048950f, 0.08316607f, -0.04905487f, 0.30856863f, 0.14086808f, 0.06816587f, 0.29615441f, 
    -0.30682951f, 0.44424379f, 0.29094756f, -0.38536310f, -0.12030248f, 0.01560780f, 0.15562244f, -0.08592995f, 
    0.28904724f, 0.03642599f, 0.12297750f, 0.19807252f, -0.06850395f, 0.20969956f, -0.00280565f, -0.20673607f, 
    -0.08909821f, -0.01824168f, -0.15250549f, 0.18261522f, -0.09286089f, 0.21046610f, 0.06355178f, -0.15212262f, 
    -0.00785888f, -0.02516678f, 0.27850595f, 0.12792960f, -0.04604272f, 0.03745440f, 0.08728714f, 0.29752216f, 
    -0.02488898f, -0.05352651f, -0.13719769f, -0.00267253f, 0.11848607f, 0.06167671f, -0.05570045f, -0.00938773f, 
    0.22542150f, 0.14018227f, 0.06791057f, -0.06425820f, 0.31799889f, 0.03173736f, -0.00413735f, -0.00831258f, 
    -0.21505867f, -0.04694812f, 0.18842155f, -0.10874071f, -0.07659450f, -0.10763545f, -0.05289925f, 0.07274766f, 
    0.07217345f, -0.04563987f, 0.09985530f, 0.02396549f, 0.38570476f, -0.43503737f, 0.17555626f, -0.03926995f, 
    0.15059026f, 0.26402983f, -0.03636644f, 0.20309544f, -0.03210591f, 0.22419651f, 0.04091481f, 0.06501514f, 
    0.05889706f, 0.09994688f, 0.15241170f, -0.04068484f, -0.03583907f, 0.01920238f, -0.08174534f, -0.09022877f, 
    0.15298560f, -0.01625847f, 0.11351048f, -0.06678426f, -0.48275313f, -0.21552292f, -0.06073063f, -0.19018357f, 
    0.01478004f, 0.06358512f, -0.00105447f, 0.07968538f, 0.14323162f, 0.03429630f, -0.08347346f, 0.12493885f, 
    -0.35418630f, 0.07878246f, -0.11454524f, 0.12176371f, -0.22275072f, 0.15218951f, 0.25966290f, -0.10368531f, 
    -0.02171447f, -0.01508232f, -0.10426662f, -0.00907735f, 0.30579904f, -0.05535576f, 0.16528186f, -0.20658511f, 
    0.07748211f, -0.10022876f, 0.28330144f, 0.20965107f, 0.06869961f, 0.09967631f, 0.12402750f, 0.01104598f, 
    0.06974256f, 0.19810657f, 0.20738663f, 0.02437420f, -0.00371808f, -0.10521431f, -0.06493261f, 0.03875755f, 
    0.08458901f, 0.02957757f, 0.07373148f, 0.03619878f, -0.23772845f, -0.32755354f, -0.18038979f, -0.10381538f, 
    0.18286002f, 0.17548028f, -0.00719039f, 0.21101293f, -0.04559692f, -0.09693717f, 0.02455505f, -0.01459085f, 
    -0.09121720f, 0.09380810f, 0.05346754f, 0.07165255f, 0.00102474f, -0.11931007f, 0.16170837f, -0.23282738f, 
    0.08731488f, 0.04689190f, -0.03475973f, 0.10832483f, 0.04245562f, -0.04550045f, 0.11298745f, -0.08973657f, 
    -0.03652677f, -0.00469525f, -0.08509341f, 0.10097815f, 0.11117547f, 0.08123633f, 0.13784058f, 0.17202598f, 
    -0.25034583f, -0.08355846f, -0.01346069f, 0.05263599f, 0.11738726f, 0.18351373f, -0.13114551f, -0.03236307f, 
    0.10914449f, -0.20496747f, -0.00199896f, 0.05689040f, 0.00199805f, -0.00683915f, -0.04727761f, 0.11038414f, 
    -0.17128766f, 0.07760230f, 0.08068976f, 0.04499559f, -0.01871030f, -0.07831588f, 0.06299336f, -0.00180316f, 
    -0.01350897f, -0.11655087f, -0.05356813f, -0.13110049f, -0.11712106f, -0.05968122f, -0.01295005f, 0.06627325f, 
    0.11177746f, -0.20592758f, 0.03797884f, -0.00499391f, -0.37315306f, -0.36337647f, -0.29701635f, 0.15740943f, 
    0.18890616f, 0.08901756f, 0.05440247f, 0.02136043f, 0.00755806f, -0.07213685f, -0.09652243f, 0.02062096f, 
    -0.33106226f, -0.10570686f, -0.26371431f, 0.23753139f, 0.22873147f, 0.00394459f, 0.25169268f, 0.07654455f, 
    0.13668010f, -0.09616273f, -0.21987641f, 0.05484438f, 0.06330162f, -0.13638985f, -0.12760466f, -0.10680179f, 
    0.10286660f, -0.05156342f, -0.01498794f, 0.12886940f, -0.00064868f, -0.07080970f, 0.20445418f, 0.13222902f, 
    0.00252171f, -0.06034363f, 0.16250882f, -0.20233653f, 0.15614255f, -0.09579840f, -0.05374000f, -0.03293257f, 
    0.08875658f, 0.07059706f, 0.08722014f, 0.00132762f, -0.30750108f, -0.03627654f, -0.48412788f, 0.19900459f, 
    0.08127639f, 0.01620744f, 0.05861986f, 0.18523042f, 0.10849376f, -0.03678893f, 0.09691565f, -0.08968702f, 
    0.09676038f, -0.03307892f, 0.25739425f, -0.12711638f, -0.04370279f, 0.02597421f, -0.11509053f, 0.06901022f, 
    0.07368413f, 0.01484662f, 0.03115530f, 0.09845427f, 0.28893057f, 0.05297415f, -0.03226648f, -0.13180143f, 
    -0.00498278f, -0.16743143f, -0.04022613f, -0.03908016f, -0.03009459f, -0.04799854f, -0.13180998f, 0.19700639f, 
    0.20980586f, 0.55791354f, -0.44947633f, 0.60285193f, 0.05919009f, 0.18162403f, 0.05052698f, 0.26886541f, 
    0.05073850f, 0.02656033f, -0.01970204f, -0.13694696f, -0.01915045f, 0.09355881f, 0.38925755f, 0.20285118f, 
    0.04045720f, 0.18637416f, 0.17578626f, -0.05849334f, 0.04032879f, -0.15612206f, -0.13620785f, -0.03826397f, 
    -0.19255996f, -0.13458434f, 0.27912036f, 0.22275914f, -0.00787650f, 0.05922245f, 0.04128670f, -0.07289878f, 
    0.20879753f, -0.09528172f, 0.04007447f, -0.03256957f, -0.36684620f, 0.00011974f, -0.19916999f, 0.12655452f, 
    -0.06297646f, -0.10455493f, -0.11165988f, 0.07464354f, -0.02558154f, 0.07438511f, 0.04797995f, 0.02416749f, 
    0.25989625f, -0.28137934f, -0.00887505f, 0.11998870f, 0.13103002f, 0.08201210f, -0.23096372f, 0.03410231f, 
    0.07850995f, -0.00357846f, -0.10560963f, -0.20303357f, 0.03286009f, 0.22514254f, 0.30745506f, -0.05055347f, 
    0.09516326f, 0.02087304f, -0.06936482f, 0.06420786f, -0.05085862f, -0.08699588f, -0.06397669f, -0.05861792f, 
    -0.18611832f, 0.21673495f, 0.03047136f, -0.09138766f, 0.04252772f, 0.00566891f, 0.07253050f, 0.05232859f, 
    0.28056866f, -0.19026524f, 0.27945977f, 0.05880089f, -0.13929155f, -0.10661820f, -0.04999231f, 0.10938752f, 
    -0.10572442f, -0.08221322f, -0.16397400f, -0.06462172f, 0.18598677f, -0.04481248f, 0.31049126f, 0.03175590f, 
    0.22114417f, -0.53797573f, 0.21284512f, -0.32003006f, -0.01282953f, -0.05908190f, 0.01455966f, -0.01829540f, 
    0.07498024f, -0.16610348f, 0.04544981f, -0.22963470f, -0.28242218f, 0.32760268f, -0.29782003f, 0.33549076f, 
    0.08490415f, 0.02982518f, 0.03397138f, -0.20271097f, 0.07249564f, 0.04286113f, -0.15273370f, -0.01062310f, 
    -0.00358814f, -0.09746165f, 0.44380689f, -0.02907158f, 0.02335156f, 0.16327630f, 0.00884768f, 0.10038073f, 
    0.10445370f, 0.11583495f, -0.10272080f, 0.12651034f, 0.20739782f, -0.43206784f, 0.16062427f, -0.36482599f, 
    0.17433037f, -0.08768184f, 0.06125007f, -0.04066865f, -0.06790449f, -0.05011221f, 0.01055618f, 0.06689025f, 
    0.07400190f, 0.21299052f, -0.32659003f, 0.01598585f, 0.15839122f, 0.27101028f, 0.16839445f, 0.10114629f, 
    0.06590362f, -0.05597740f, 0.03929274f, -0.12808065f, 0.09164603f, -0.05987171f, 0.27873486f, -0.11432821f, 
    -0.11526612f, 0.01096692f, 0.04130235f, -0.02434973f, 0.25922796f, -0.01000661f, -0.16846754f, -0.07273031f, 
    0.27530220f, -0.33107731f, -0.14453202f, -0.01991485f, 0.04737091f, 0.00220633f, 0.17097011f, -0.01604812f, 
    0.15509579f, -0.06482096f, 0.15127237f, 0.11051762f, 0.02153861f, 0.23816028f, -0.09804024f, -0.02300540f, 
    0.02280335f, 0.02370404f, -0.03539022f, -0.18038265f, 0.03237358f, -0.10510810f, -0.05928817f, -0.05006535f, 
    -0.43045861f, -0.06596935f, -0.14551793f, -0.26396289f, 0.03284975f, -0.01532970f, -0.06415428f, 0.08210011f, 
    -0.17288093f, 0.03823890f, 0.08078035f, 0.11759248f, -0.01043478f, -0.24050318f, 0.06963091f, 0.08593673f, 
    -0.10088335f, -0.07269847f, -0.03618104f, 0.04042211f, 0.00932249f, 0.04912110f, -0.12628250f, 0.06019030f, 
    -0.18688986f, -0.43451694f, 0.00701478f, 0.10778727f, 0.13269810f, -0.01148380f, 0.12333983f, -0.06578613f, 
    -0.00539746f, -0.01042358f, -0.18711942f, 0.04268474f, -0.00210055f, 0.22899489f, 0.27120984f, 0.22256106f, 
    0.17010622f, 0.02838030f, 0.16857834f, 0.15680754f, -0.02894469f, 0.09645272f, 0.17777807f, 0.03239298f, 
    -0.04639001f, -0.40360558f, 0.00345394f, -0.32944706f, 0.30865756f, 0.13087630f, 0.11679759f, 0.22661312f, 
    0.09620158f, -0.07841080f, -0.14630164f, -0.08072245f, 0.06664876f, -0.12864998f, 0.00439718f, 0.09390119f, 
    -0.00821702f, -0.11676425f, -0.01466390f, -0.12978816f, 0.05500498f, -0.09108125f, 0.04571744f, -0.08012440f, 
    0.27807671f, 0.20453382f, 0.11014966f, 0.02088226f, 0.06924838f, 0.00299265f, 0.00563587f, 0.05830134f, 
    0.01365827f, 0.00318097f, 0.17453167f, -0.17492577f, 0.05403161f, -0.03608486f, 0.10274684f, -0.06720049f, 
    0.00915757f, -0.23898324f, -0.00081373f, 0.05010783f, 0.12234938f, 0.01249359f, -0.04893780f, 0.12229339f, 
    -0.14798900f, -0.02570375f, 0.07256939f, -0.05966467f, -0.13809299f, 0.01424333f, -0.02497450f, -0.03856478f, 
    -0.06135438f, -0.03023981f, -0.07796368f, 0.00101866f, 0.22529210f, 0.04804185f, 0.27969629f, -0.00706670f, 
    -0.06984822f, -0.12471872f, -0.02059712f, 0.02666016f, -0.03807968f, 0.05753872f, 0.04870893f, -0.13080527f, 
    0.16702582f, 0.31094688f, 0.11205774f, -0.05291064f, -0.07903329f, 0.01799392f, -0.08084489f, 0.00319085f, 
    -0.12293556f, -0.07553962f, 0.07379919f, 0.10626293f, -0.00713770f, 0.01728503f, -0.17032908f, -0.00411906f, 
    -0.00579012f, 0.01565586f, 0.33610943f, 0.05918306f, 0.04589720f, 0.14509222f, -0.21113776f, 0.08357260f, 
    -0.16229814f, 0.23302811f, -0.06909198f, 0.17644484f, -0.05689778f, 0.22365314f, 0.05584488f, 0.05245011f, 
    0.05543491f, 0.03910078f, -0.01634716f, -0.04008629f, 0.23219775f, 0.22188637f, 0.24413517f, -0.06709199f, 
    0.15714827f, 0.00634136f, -0.15497200f, 0.14236510f, 0.06178293f, 0.00877364f, 0.12615255f, -0.06228785f, 
    -0.31134838f, -0.07373792f, -0.03069340f, 0.12924285f, 0.03076608f, -0.00721361f, 0.10026057f, 0.15509136f, 
    -0.01646009f, 0.16943301f, 0.08836936f, 0.12023751f, 0.18866657f, 0.04207452f, 0.19271596f, 0.07065532f, 
    0.02768462f, 0.02848891f, -0.09903693f, -0.13670176f, 0.01071402f, 0.03013434f, 0.11645661f, -0.16205804f, 
    0.38407627f, 0.02941791f, 0.46674639f, 0.23873238f, -0.15456493f, -0.09033599f, -0.08627892f, 0.11184170f, 
    -0.18120414f, -0.07695580f, -0.07373241f, -0.06954276f, 0.06610105f, -0.05027116f, -0.14446388f, 0.33883819f, 
    -0.01320365f, -0.06032918f, -0.01901915f, -0.02012409f, 0.04934398f, -0.01253467f, 0.11702432f, 0.01166397f, 
    -0.05266113f, -0.31389767f, -0.13563398f, 0.04603125f, 0.04227224f, -0.09108787f, -0.13495268f, -0.06996038f, 
    0.11892842f, 0.14853515f, 0.18341374f, 0.05062251f, 0.30569926f, 0.14608951f, -0.16220841f, -0.14016710f, 
    -0.00500947f, 0.09771876f, 0.13239065f, 0.00821791f, 0.11134309f, -0.20348948f, 0.23585673f, 0.14254819f, 
    0.00855941f, 0.04502318f, 0.02901196f, 0.03904489f, 0.13579316f, -0.00097541f, 0.08995214f, 0.02211416f, 
    -0.07802434f, -0.03873243f, -0.01370329f, 0.03637267f, 0.04309520f, -0.12837046f, 0.10136411f, 0.07108682f, 
    -0.06330708f, -0.03517757f, -0.07805128f, 0.07201475f, 0.00216133f, -0.18580131f, -0.09332004f, -0.16437401f, 
    0.04040721f, -0.02350072f, -0.06596124f, -0.05454624f, 0.00971974f, 0.03446843f, -0.13573357f, -0.06624863f, 
    -0.06257449f, 0.01421936f, -0.08356131f, 0.11136934f, 0.04719972f, 0.11795443f, -0.08564422f, -0.08608975f, 
    0.00499059f, 0.09460106f, -0.09053908f, 0.09098932f, 0.12206382f, 0.12585463f, -0.04532250f, 0.09684870f, 
    -0.30720943f, -0.22532201f, 0.26792741f, 0.12978533f, -0.06794010f, 0.06097461f, 0.14353806f, -0.03080942f, 
    -0.04515632f, 0.14089096f, 0.20323987f, 0.08791319f, 0.01148766f, 0.11839828f, 0.41862991f, -0.11121091f, 
    0.03550906f, 0.10748988f, -0.05019749f, -0.26049298f, -0.01079497f, -0.02911602f, 0.20459463f, 0.02466336f, 
    -0.23413514f, -0.16509840f, -0.02800510f, 0.13359527f, 0.07362675f, -0.07548727f, -0.04097162f, -0.03336165f, 
    0.06446416f, 0.16582124f, 0.24874167f, 0.13948205f, 0.04989184f, 0.15456496f, -0.00347715f, 0.15453792f, 
    -0.01952278f, 0.01573628f, -0.02872136f, 0.02474897f, 0.09790624f, 0.14676991f, -0.13117953f, 0.22774769f, 
    0.29076329f, 0.14555675f, 0.22547626f, -0.03330564f, 0.08090035f, 0.03320572f, -0.11744368f, 0.00835249f, 
    -0.05293828f, -0.01670752f, 0.01210157f, -0.07390319f, -0.11323521f, 0.08129967f, 0.17554300f, -0.09653463f, 
    0.14734016f, -0.13032347f, 0.14048102f, 0.11672284f, -0.11020218f, -0.05804868f, -0.04405927f, 0.02818675f, 
    -0.06220318f, 0.02763772f, -0.04693268f, 0.06216631f, -0.06812445f, 0.04067094f, 0.02339840f, 0.00204994f, 
    0.15625939f, 0.28175601f, -0.07160348f, 0.12500668f, -0.13521267f, 0.03018249f, -0.01774072f, 0.18096231f, 
    0.06431365f, -0.07921284f, -0.16681845f, -0.02282757f, -0.05413231f, 0.03171878f, -0.13931257f, -0.13394283f, 
    -0.08499795f, -0.08178351f, -0.01013778f, -0.04469919f, -0.00471142f, -0.07237364f, 0.03758460f, 0.04639009f, 
    -0.23487933f, -0.01432671f, 0.10548470f, 0.19290218f, -0.23539110f, 0.12774701f, -0.34164023f, 0.16374686f, 
    0.12001456f, 0.07927444f, -0.16182192f, 0.12809505f, -0.08875951f, -0.18858002f, -0.02444488f, -0.05714520f, 
    0.43260482f, 0.14659658f, 0.03138370f, -0.07475299f, -0.12436739f, -0.02176490f, 0.03091700f, -0.00305770f, 
    -0.05976998f, 0.07846639f, 0.14998882f, 0.06685615f, -0.10690018f, -0.18122983f, 0.02422786f, 0.14390662f, 
    -0.02137653f, -0.13007893f, 0.16264391f, -0.15809895f, -0.08127803f, -0.05320588f, -0.11153349f, -0.08580747f, 
    0.59164137f, 0.14201742f, 0.00085001f, 0.25058034f, 0.09138267f, -0.12674008f, -0.14403939f, 0.23656650f, 
    -0.14517090f, -0.04210017f, 0.06443499f, -0.03823030f, -0.05426349f, 0.18167539f, 0.01308243f, -0.04846153f, 
    -0.04326978f, 0.12317884f, 0.05187882f, -0.03416396f, -0.14595430f, -0.11107834f, -0.05698559f, -0.02621208f, 
    -0.01957652f, 0.05090529f, 0.41181058f, 0.07821082f, 0.01842759f, 0.00695526f, 0.03309562f, -0.03065667f, 
    0.10918017f, 0.11735986f, -0.03927038f, 0.06390203f, 0.12661333f, -0.20222598f, -0.07978222f, -0.07049165f, 
    0.03850127f, -0.12721479f, 0.02663573f, 0.07458325f, 0.06691197f, -0.05280294f, -0.05779470f, 0.00278203f, 
    -0.00199785f, 0.03411387f, 0.01732756f, 0.01544689f, -0.02577234f, 0.00776649f, -0.02913569f, 0.03678253f, 
    -0.05706676f, 0.01612782f, -0.03597429f, -0.01412398f, 0.03303580f, 0.01135191f, -0.05615349f, 0.02925924f, 
    -0.04796205f, 0.02644879f, -0.04120597f, -0.03914709f, -0.05682341f, -0.01726583f, 0.01623170f, 0.03340887f, 
    0.03423076f, 0.03068562f, 0.03025399f, -0.04677502f, -0.04068124f, 0.02509779f, -0.03744495f, 0.00704684f, 
    0.00382983f, 0.02474378f, 0.00286416f, 0.01274624f, -0.04009854f, -0.00846580f, -0.04289431f, 0.03855572f, 
    0.03560904f, -0.04194656f, -0.00463101f, 0.04036094f, 0.03208771f, 0.03147827f, 0.01444013f, 0.00319763f, 
    0.01993512f, -0.01242642f, -0.02819748f, -0.02256733f, 0.03491538f, 0.02821745f, 0.01627481f, -0.05488547f, 
    -0.02820784f, 0.02134359f, 0.02777604f, 0.02859650f, 0.02836226f, -0.00233677f, -0.00552175f, -0.01916868f, 
    -0.04776089f, -0.00936834f, 0.02063285f, -0.04406789f, -0.03014356f, -0.04963869f, -0.02601236f, 0.00965975f, 
    0.03806208f, -0.05052201f, 0.02646390f, -0.03482266f, -0.03855549f, 0.02109118f, 0.02336114f, 0.03440689f, 
    -0.05816063f, -0.01177284f, -0.04415450f, -0.01005821f, -0.01207194f, 0.01237880f, 0.00527753f, 0.02246559f, 
    -0.02428966f, 0.00324445f, 0.03071472f, 0.00437006f, 0.02224292f, -0.04405997f, 0.03640389f, -0.03181143f, 
    -0.05423496f, 0.03732393f, -0.03910260f, 0.00443740f, -0.01966651f, -0.05413470f, 0.03251248f, -0.02578101f, 
    -0.04000220f, -0.01263659f, -0.01617150f, 0.02668264f, -0.05489866f, -0.03406635f, -0.01045211f, -0.05398817f, 
    -0.02187382f, -0.00686803f, -0.02398763f, -0.02732840f, 0.03915427f, -0.04993435f, 0.02367726f, -0.00795292f, 
    0.01276065f, -0.01825170f, 0.02559945f, 0.00706230f, -0.01225832f, 0.01960903f, -0.00708608f, -0.01821818f, 
    -0.02245057f, -0.04728176f, 0.04032067f, -0.03951629f, -0.04286975f, 0.01306711f, -0.02137077f, 0.02755305f, 
    -0.02913688f, -0.01066391f, 0.03039716f, 0.03069730f, -0.05514909f, 0.03007163f, 0.02143320f, 0.04508803f, 
    -0.03896960f, -0.01494608f, -0.05782532f, -0.04243171f, -0.02522968f, -0.01445339f, 0.00993370f, -0.05462861f, 
    -0.02543158f, -0.04844737f, 0.03603691f, -0.04575279f, -0.01627888f, 0.03494541f, 0.01556170f, -0.04164996f, 
    -0.05502689f, -0.05105371f, -0.02364291f, 0.01879717f, 0.01847784f, -0.02330434f, -0.01936218f, 0.00409228f, 
    0.04406404f, -0.01391716f, 0.02543966f, 0.01948325f, 0.01532969f, 0.00232951f, 0.03492443f, -0.01703780f, 
    0.02353350f, -0.02873491f, -0.02467868f, -0.01578894f, 0.03442996f, 0.01185416f, -0.00606513f, -0.03961651f, 
    -0.05564443f, -0.01251891f, 0.00571690f, -0.00779718f, -0.04175346f, 0.02535240f, 0.03035548f, -0.01792410f, 
    -0.02046889f, 0.01537285f, -0.04131929f, 0.02382291f, -0.05716167f, 0.04253671f, -0.02302580f, 0.04406603f, 
    -0.02790370f, -0.02151734f, 0.00289237f, 0.01243385f, -0.01671613f, -0.04013257f, -0.02849052f, -0.03746948f, 
    -0.01863717f, -0.04143379f, -0.02890167f, -0.04339229f, 0.02333389f, -0.03944306f, -0.01427280f, -0.02657258f, 
    -0.03272325f, -0.03163145f, -0.02101264f, -0.01376271f, 0.03798610f, 0.00690493f, -0.01722364f, 0.00252263f, 
    0.03907678f, 0.02636162f, -0.03780574f, -0.00422106f, 0.00336845f, 0.02342398f, -0.01404342f, 0.03671364f, 
    -0.05296426f, -0.02200172f, 0.01939671f, 0.03472004f, -0.04123494f, 0.03729596f, -0.05273084f, -0.04819333f, 
    -0.01224782f, -0.01245846f, 0.03345456f, 0.00113066f, -0.03460312f, -0.04390381f, -0.01480838f, -0.03222921f, 
    -0.02352070f, -0.04562225f, -0.01386362f, -0.04187851f, -0.02155142f, 0.03198151f, -0.00572797f, 0.02899184f, 
    -0.04015434f, 0.03415844f, 0.02830848f, 0.01970732f, -0.01286024f, -0.02679715f, 0.02589209f, -0.02728563f, 
    -0.05879305f, 0.03649940f, 0.04131076f, 0.03636577f, -0.01465166f, 0.00457164f, -0.00743864f, 0.01574061f, 
    -0.00678046f, -0.04469338f, -0.05075807f, 0.01596392f, -0.03455139f, -0.03893907f, 0.02200039f, -0.00391954f, 
    -0.01800779f, 0.01349006f, -0.02037537f, -0.01678358f, 0.02927956f, 0.03662223f, 0.02600082f, -0.03762217f, 
    -0.04832072f, 0.02190281f, 0.01827690f, -0.04878176f, -0.02025963f, 0.00112403f, 0.03979839f, -0.01733482f, 
    -0.00324846f, -0.00324974f, 0.03854541f, 0.04067884f, -0.03758861f, -0.05705203f, -0.04723340f, -0.00444939f, 
    -0.05940825f, -0.02081085f, 0.03940235f, 0.01354888f, 0.00810451f, 0.01116124f, 0.00886697f, 0.03110304f, 
    -0.01049820f, 0.01270891f, 0.02322142f, -0.02408412f, -0.01283272f, -0.05266403f, -0.00681352f, -0.00808990f, 
    -0.02461014f, 0.01944087f, 0.02963304f, 0.00201052f, 0.01401490f, 0.02709889f, -0.05356682f, 0.00252368f, 
    -0.03120611f, -0.05797604f, 0.01778009f, -0.04753449f, 0.01071920f, 0.03873952f, -0.04374551f, -0.02297296f, 
    0.01401162f, -0.00928039f, 0.02116445f, 0.03527118f, -0.02724583f, 0.02381339f, 0.02263781f, 0.00120598f, 
    0.02563077f, 0.02176927f, -0.01049011f, 0.02058550f, -0.00456179f, 0.02328777f, -0.02603924f, -0.03286680f, 
    -0.01282873f, -0.02706448f, 0.00918625f, 0.00234411f, 0.00762920f, -0.00755972f, -0.05170691f, 0.00604300f, 
    -0.02126579f, 0.03752820f, -0.04800691f, 0.02485437f, 0.01611417f, 0.03651719f, 0.04044540f, -0.04024728f, 
    -0.02037462f, -0.04925619f, 0.00817931f, -0.05206238f, 0.02142656f, 0.03990901f, 0.03508113f, -0.03930643f, 
    -0.00118128f, 0.01859840f, 0.02396162f, -0.03041893f, 0.03052375f, -0.02540348f, -0.04197808f, -0.04233880f, 
    -0.00963933f, -0.07059215f, -0.07164220f, -0.07912472f, 0.07867644f, 0.03981025f, 0.01056954f, 0.00277967f, 
    0.04206213f, -0.11622430f, -0.03888421f, -0.04418150f, 0.09049828f, 0.08059958f, 0.19937588f, 0.13071229f, 
    0.08406180f, -0.14926575f, -0.10771231f, -0.02769972f, -0.16750896f, -0.13940431f, 0.01939492f, -0.02655096f, 
    -0.00969016f, 0.12313092f, -0.12510170f, 0.06755830f, 0.02576637f, -0.21605749f, -0.15054318f, 0.01992915f, 
    0.06915999f, -0.00459570f, -0.09782785f, 0.10614179f, 0.23643509f, -0.19458076f, -0.01294350f, 0.25828972f, 
    0.07067022f, -0.14887303f, -0.00176666f, 0.02821488f, -0.07103485f, 0.00865603f, 0.13229407f, -0.08815038f, 
    -0.09940787f, 0.01806335f, -0.13990943f, -0.29321131f, -0.08613959f, -0.10853274f, 0.04292426f, 0.10867863f, 
    0.00161651f, 0.08243027f, 0.14898607f, -0.05464662f, 0.13864702f, 0.04721854f, -0.00494642f, 0.07604810f, 
    0.32118276f, 0.07798657f, 0.22324158f, -0.04450776f, 0.08255720f, -0.01219134f, 0.15989362f, 0.13909972f, 
    0.10709644f, 0.16755666f, 0.10984118f, 0.10860390f, 0.10021526f, -0.12203738f, 0.11717150f, 0.06151557f, 
    0.05376675f, -0.05280988f, 0.03592613f, -0.16537619f, 0.15326583f, 0.14402328f, -0.15322392f, 0.24453031f, 
    0.07985616f, 0.14665461f, 0.14336798f, 0.16289397f, 0.10915072f, 0.18494762f, 0.15479830f, -0.03888530f, 
    0.32921240f, -0.04469910f, 0.19347972f, -0.13704152f, 0.05224263f, -0.01488060f, -0.19957060f, 0.02294372f, 
    -0.08018293f, 0.00790768f, -0.03952602f, 0.00812577f, -0.01804246f, 0.20869814f, 0.06791134f, 0.00982344f, 
    0.05515007f, 0.13083430f, -0.07279137f, 0.13225554f, 0.08190168f, 0.10883147f, -0.00813381f, 0.32123154f, 
    -0.54047805f, -0.17701833f, 0.05083854f, -0.04441306f, -0.07980151f, -0.08349633f, 0.09401291f, 0.06959660f, 
    -0.06427469f, -0.04073154f, -0.04378695f, 0.15053461f, -0.26605648f, 0.00756422f, 0.10885331f, 0.12202293f, 
    0.18921398f, -0.07125194f, -0.16214871f, 0.14866666f, 0.11290071f, 0.01584188f, 0.02136545f, 0.21670298f, 
    -0.06167720f, -0.08684272f, -0.02843215f, 0.11917612f, -0.12719810f, -0.16672140f, -0.10421329f, -0.09308761f, 
    0.13438794f, 0.11059699f, 0.14321752f, -0.10393892f, 0.01218005f, -0.03802684f, 0.23634672f, -0.15391758f, 
    0.11600253f, 0.06700028f, -0.08178003f, 0.05981527f, 0.02624457f, 0.10080504f, 0.07088054f, 0.11494079f, 
    0.07623757f, -0.04717343f, -0.13194831f, 0.08265394f, 0.07191703f, 0.14980352f, -0.05933498f, 0.04839748f, 
    -0.00876767f, -0.09323988f, -0.10537298f, -0.19553715f, -0.09639149f, -0.02891897f, -0.14276429f, 0.34118044f, 
    0.02367346f, -0.03920326f, -0.02421294f, 0.06952179f, 0.31101540f, -0.04692388f, 0.20379505f, 0.38123867f, 
    0.33195806f, 0.04984353f, -0.17585255f, -0.17320180f, -0.08342119f, 0.08044845f, -0.10308687f, -0.04342337f, 
    0.14319758f, -0.03761114f, 0.04676670f, -0.00045169f, -0.10284228f, -0.03320428f, 0.20315610f, -0.19796275f, 
    0.10073206f, 0.12728293f, -0.10755429f, 0.07049824f, -0.11851323f, -0.05662046f, -0.07084902f, -0.39122483f, 
    -0.09784305f, -0.01838605f, 0.31205663f, 0.08952931f, 0.01140130f, -0.09173937f, 0.01431400f, -0.01474500f, 
    0.10827986f, 0.04962259f, 0.05142546f, -0.01351263f, 0.18159500f, 0.02136597f, 0.08542798f, 0.12577564f, 
    0.15863264f, 0.01781829f, -0.03674449f, -0.03065682f, 0.04222853f, -0.03778510f, -0.06583647f, 0.03299166f, 
    -0.09352136f, 0.02413645f, 0.00264683f, -0.12274887f, 0.04294769f, -0.01237903f, -0.06123924f, -0.02942636f, 
    -0.06323111f, 0.03105770f, 0.01369534f, -0.03902455f, -0.32839385f, -0.21356396f, 0.11902175f, 0.10340640f, 
    0.14790089f, 0.10619579f, -0.09486494f, 0.30880859f, 0.08829509f, 0.14757659f, -0.06459305f, -0.10375208f, 
    0.01699211f, 0.10979543f, -0.07976122f, 0.04745674f, 0.06062080f, 0.03566844f, -0.06376278f, -0.03863002f, 
    -0.10211118f, -0.26487347f, -0.09590214f, -0.23724270f, -0.22720028f, 0.10745953f, 0.08936905f, -0.13385284f, 
    0.01501677f, 0.16991851f, -0.01369310f, 0.04721582f, 0.10150694f, 0.04095207f, -0.11381739f, 0.14241251f, 
    0.14935224f, 0.14368196f, 0.03435854f, 0.00741351f, -0.07477508f, 0.13136895f, 0.03919847f, -0.02298841f, 
    -0.00737877f, 0.09131785f, 0.21164343f, 0.07114470f, -0.15569086f, -0.16458836f, 0.06489445f, 0.27871615f, 
    0.15720598f, 0.06076820f, 0.20677306f, 0.08232076f, 0.07321063f, 0.00966896f, 0.02664411f, 0.16639860f, 
    0.06521465f, 0.23879668f, 0.13065097f, 0.11430537f, 0.02495239f, -0.04130112f, -0.06542711f, -0.06042035f, 
    0.06437327f, -0.10636959f, -0.02222159f, 0.13461916f, -0.16365139f, 0.11760502f, 0.15710025f, -0.13553353f, 
    0.00180246f, -0.01734083f, -0.03586100f, 0.17809342f, -0.08986130f, -0.00394137f, 0.06949624f, -0.08518346f, 
    0.42011711f, 0.01219824f, -0.06904847f, 0.05444066f, 0.00571390f, 0.17989314f, -0.00614110f, -0.01937511f, 
    0.09045187f, -0.00384551f, 0.04298461f, 0.00604262f, -0.15357071f, 0.04393139f, -0.09008615f, 0.13892186f, 
    -0.13454762f, -0.04296213f, -0.10546636f, -0.00620753f, 0.07083092f, 0.15605415f, 0.09842255f, 0.03609936f, 
    0.22777434f, 0.08075418f, 0.01315295f, -0.06754802f, -0.05776805f, -0.05807702f, -0.12153426f, -0.13433516f, 
    -0.09988226f, -0.15604895f, 0.06985503f, -0.07125222f, -0.52531117f, -0.40789190f, -0.28378490f, -0.13835075f, 
    -0.08276463f, -0.16887353f, 0.13797517f, -0.06047898f, -0.11796921f, -0.05443883f, 0.07880016f, -0.17359583f, 
    -0.04217863f, 0.14752683f, 0.03048930f, -0.05565992f, -0.05105451f, -0.07041679f, -0.10138746f, 0.04276472f, 
    0.03384562f, -0.01659543f, -0.01133022f, 0.13835983f, 0.02680920f, -0.28452048f, -0.21855766f, -0.21153994f, 
    -0.01866142f, 0.09836618f, 0.10880812f, -0.08075095f, 0.05725105f, 0.07229507f, -0.06016068f, -0.18697019f, 
    -0.03235640f, -0.18413928f, 0.06550755f, -0.02510658f, 0.12630491f, 0.26230729f, 0.24836501f, 0.07088761f, 
    -0.14128143f, -0.17071542f, 0.04221842f, 0.06349290f, -0.09398464f, 0.07320247f, -0.17803095f, -0.31574076f, 
    -0.02365418f, -0.02538750f, -0.00453472f, 0.18357749f, 0.05530131f, 0.00211932f, 0.10609929f, 0.12470322f, 
    -0.18802346f, 0.06911568f, 0.26308557f, 0.08385323f, 0.11016445f, 0.15615858f, -0.03297102f, 0.01252955f, 
    0.01026581f, 0.06729878f, -0.04875019f, -0.02500660f, 0.09874570f, 0.11171966f, 0.04703739f, -0.03078548f, 
    0.00741537f, -0.00245273f, -0.09304761f, 0.21862870f, -0.05194483f, -0.03092329f, 0.07110761f, -0.19541307f, 
    -0.15624222f, 0.11555523f, 0.03560238f, 0.09089428f, -0.05960216f, 0.12844777f, -0.06730639f, 0.23076235f, 
    0.06262446f, 0.07915226f, -0.08065712f, 0.24145795f, 0.12113890f, 0.01954367f, 0.51269734f, 0.14174497f, 
    -0.07687812f, 0.08541322f, -0.12241564f, -0.21402204f, -0.04572419f, -0.12739466f, 0.08551778f, 0.09944385f, 
    0.27797574f, -0.09775981f, -0.02582421f, 0.45087034f, -0.03960336f, 0.11888768f, 0.17426306f, 0.11966557f, 
    -0.01428179f, -0.02840825f, -0.08863091f, -0.22240397f, 0.05610384f, -0.00643130f, 0.09495834f, 0.24086151f, 
    0.03805421f, -0.01555394f, 0.26572186f, -0.03245321f, -0.04226468f, -0.09996900f, 0.09076192f, -0.05557609f, 
    0.22291462f, 0.11548685f, 0.15797830f, 0.17858987f, 0.11901608f, -0.03868973f, -0.05259907f, 0.04286820f, 
    0.00742983f, 0.10176560f, 0.11178775f, -0.05996260f, 0.23393853f, 0.00757808f, -0.18896769f, -0.26916477f, 
    -0.20566158f, -0.09177115f, 0.16438839f, -0.09709431f, 0.00005538f, -0.02077014f, 0.23810457f, -0.05390184f, 
    0.13459931f, -0.02356212f, 0.02675182f, -0.01827188f, 0.11178920f, 0.02644692f, 0.04019612f, -0.02626842f, 
    0.04736705f, 0.10557790f, -0.07173198f, 0.06097674f, 0.11191189f, 0.13750331f, 0.21676822f, 0.14369290f, 
    -0.15345868f, 0.01010051f, -0.06132276f, 0.12980500f, 0.01811348f, -0.17263092f, -0.10161332f, -0.13862987f, 
    0.08478878f, 0.19227132f, 0.10590311f, -0.11897464f, -0.09233960f, -0.08093832f, 0.04481491f, -0.00913401f, 
    0.16779411f, -0.02205857f, 0.16202673f, 0.24267261f, -0.08704057f, -0.02583888f, 0.14681816f, -0.14094743f, 
    -0.07219292f, 0.07103693f, -0.08728324f, -0.06730815f, -0.00732384f, 0.03190212f, 0.05729013f, 0.01262618f, 
    -0.45112622f, -0.16034314f, 0.35908473f, 0.30282384f, 0.11071330f, 0.12580165f, -0.01185240f, 0.16636901f, 
    -0.11652693f, -0.02422475f, 0.19925101f, -0.12132715f, 0.07161357f, 0.20177914f, 0.08830898f, 0.14257848f, 
    -0.06094408f, 0.09213462f, 0.15584806f, -0.22046027f, 0.14192687f, -0.05672558f, 0.03068849f, 0.17273089f, 
    -0.24065331f, -0.10966630f, 0.04007558f, 0.14867756f, 0.03988588f, 0.09998138f, -0.04333314f, 0.01975323f, 
    -0.04290649f, 0.24534862f, 0.12748191f, 0.11541314f, -0.17497723f, 0.15972848f, 0.02601864f, -0.22680455f, 
    -0.01843267f, 0.03049776f, -0.02868168f, 0.17408147f, -0.02041772f, -0.04283940f, 0.02220322f, 0.05789489f, 
    0.49474081f, -0.08772596f, 0.01171718f, 0.14364086f, 0.17773958f, 0.36825752f, 0.21371594f, 0.13767381f, 
    -0.01957198f, -0.04095244f, -0.02058548f, -0.08653809f, -0.02443004f, 0.24748383f, -0.06799426f, -0.01630459f, 
    -0.12440498f, -0.11772246f, 0.24841437f, -0.10400054f, 0.26456836f, -0.06545231f, -0.15425724f, 0.07955801f, 
    0.02235970f, -0.09267386f, -0.15020917f, -0.04348672f, -0.10053152f, 0.07700966f, 0.10222489f, 0.07980347f, 
    0.29148248f, 0.23792367f, 0.24325049f, 0.22316217f, 0.20546120f, 0.20966955f, 0.15681377f, 0.11261381f, 
    -0.04254603f, -0.12992488f, -0.04030704f, 0.02593080f, -0.01829831f, 0.07886548f, 0.00808227f, -0.22189172f, 
    -0.17317478f, -0.07555556f, 0.03528858f, -0.10567760f, 0.13117777f, -0.00997020f, 0.04096312f, 0.11161712f, 
    -0.13631402f, 0.00810444f, 0.15492499f, 0.13667090f, -0.32636729f, 0.37359816f, -0.01191707f, 0.25305444f, 
    0.05357987f, 0.10174602f, -0.34323934f, 0.05896685f, -0.08314457f, 0.02515523f, -0.00234693f, -0.14230175f, 
    0.05328422f, -0.22845887f, -0.22969095f, -0.14520794f, 0.02724253f, 0.10339873f, 0.07054839f, -0.10419355f, 
    -0.02767045f, 0.10429104f, -0.03200064f, -0.07410400f, 0.15671681f, -0.11190666f, 0.20669462f, 0.22621185f, 
    0.03104760f, -0.05339971f, 0.27388006f, -0.05700971f, 0.02605368f, 0.05553481f, -0.03709972f, -0.01121314f, 
    0.04774686f, -0.33174154f, -0.07992656f, -0.02455046f, 0.27117980f, 0.06166498f, -0.01408556f, 0.31068426f, 
    -0.20558476f, 0.02408092f, -0.03097181f, -0.12676495f, -0.05234290f, 0.04897258f, -0.03432421f, -0.10472006f, 
    0.05698762f, 0.03460804f, 0.07685332f, -0.18804675f, -0.01496399f, -0.10212498f, -0.02538015f, -0.05657249f, 
    0.08573279f, 0.05844780f, 0.30149114f, 0.18899933f, 0.10275861f, -0.01034169f, 0.17853725f, 0.05696177f, 
    0.09248269f, 0.17891957f, 0.09163406f, 0.06177889f, 0.27486190f, 0.29208496f, 0.27564329f, -0.01439044f, 
    0.14256428f, -0.26029953f, -0.11892524f, 0.21201944f, 0.09165103f, 0.07268746f, -0.12963173f, 0.04997508f, 
    -0.01284291f, 0.02869486f, -0.05542761f, 0.01406786f, 0.00623854f, -0.01726072f, -0.01727248f, -0.02263114f, 
    0.01221015f, 0.04637915f, -0.00072898f, -0.05917328f, -0.04278399f, -0.01706702f, 0.03562607f, 0.01964590f, 
    0.03551994f, 0.00390806f, 0.00944473f, 0.01438653f, 0.02885983f, 0.03643874f, 0.00788373f, 0.04271757f, 
    -0.02888271f, 0.03135449f, 0.03360487f, 0.00670859f, -0.05161862f, 0.01082672f, 0.00174355f, 0.03702318f, 
    -0.04102613f, 0.04408732f, -0.03521655f, -0.02154157f, 0.00087762f, 0.00455589f, -0.05409757f, -0.03040168f, 
    -0.01107279f, 0.02424360f, 0.03604019f, -0.01055659f, -0.04433648f, 0.02626184f, 0.00888068f, -0.04986553f, 
    -0.04326933f, 0.00208247f, -0.03590810f, -0.02129361f, 0.02342135f, -0.04824777f, 0.02340636f, 0.02981612f, 
    0.02865319f, 0.01407208f, -0.00533358f, -0.00595716f, 0.00476043f, -0.05195690f, -0.05289999f, -0.00515961f, 
    -0.05077890f, 0.03568562f, 0.02483458f, 0.02875044f, -0.00054665f, -0.05306083f, -0.03681706f, 0.04074471f, 
    0.04042154f, -0.01408639f, -0.05201304f, 0.00265477f, 0.03826890f, -0.02261167f, -0.00383899f, -0.02167989f, 
    -0.05563535f, 0.01638514f, -0.01900828f, -0.01610847f, 0.02797093f, -0.05167959f, 0.04052433f, -0.01600146f, 
    0.02535666f, -0.04570386f, -0.00134426f, -0.03138622f, 0.02830872f, -0.03016852f, -0.00761042f, -0.01645997f, 
    -0.05902451f, 0.02303171f, -0.01393594f, -0.04802825f, -0.02861522f, 0.03570221f, 0.01149622f, 0.02386708f, 
    0.04093521f, -0.03686735f, -0.00722944f, 0.00762719f, 0.01771194f, -0.03427473f, -0.04264352f, 0.00540930f, 
    0.01185276f, 0.03760740f, -0.01033281f, -0.02981401f, 0.00717803f, -0.03701383f, -0.00300583f, 0.01671130f, 
    0.00103694f, 0.03577797f, 0.04270726f, 0.02813259f, 0.01621477f, 0.00116548f, -0.04536407f, -0.05049084f, 
    0.02487675f, 0.01487198f, -0.00391717f, 0.01148513f, 0.01368995f, 0.00504621f, 0.02057922f, 0.00187598f, 
    -0.03662411f, -0.03387887f, -0.05253400f, -0.05723890f, -0.05210761f, -0.05186994f, -0.03864067f, -0.01852203f, 
    -0.03522992f, -0.01076541f, -0.01673402f, -0.00486122f, -0.02309021f, 0.00495281f, 0.03568143f, 0.03879510f, 
    -0.01539663f, 0.00528562f, -0.04180448f, -0.02981317f, 0.03356811f, -0.01025613f, 0.03553983f, -0.00496743f, 
    -0.02619501f, -0.02081386f, 0.01763003f, -0.01158584f, -0.00413247f, -0.04800062f, 0.00323138f, 0.03112463f, 
    0.02879502f, 0.02612182f, 0.01515086f, -0.01144564f, 0.03067788f, 0.03110730f, 0.03855870f, -0.00985267f, 
    0.01108257f, -0.01600520f, 0.00771113f, 0.03523133f, -0.03532911f, -0.04612707f, 0.03972887f, 0.03221450f, 
    -0.01588277f, -0.02066851f, -0.03595490f, -0.02983053f, -0.01011390f, -0.02696355f, -0.01765006f, 0.02546542f, 
    0.02403819f, 0.01644137f, 0.03055596f, -0.00945362f, -0.02186383f, -0.01460509f, 0.03311543f, -0.00416539f, 
    -0.03684019f, 0.00867581f, 0.00485129f, 0.03946187f, -0.02337378f, -0.02791081f, 0.03038669f, 0.04160991f, 
    -0.04956632f, -0.03686370f, 0.03785645f, 0.03333326f, 0.04031677f, -0.03835871f, -0.00216561f, 0.04064460f, 
    0.00121126f, 0.00580569f, -0.05366465f, 0.04486730f, 0.01111532f, -0.04913612f, -0.03526531f, -0.00372180f, 
    -0.04128969f, -0.03616972f, 0.03527496f, 0.04348099f, -0.03818853f, -0.05615747f, 0.03163821f, -0.02819414f, 
    -0.02537574f, 0.01935495f, 0.03704829f, -0.05027247f, -0.02863051f, -0.01404869f, -0.04316384f, -0.01109731f, 
    -0.03506416f, -0.04554101f, 0.04049451f, -0.04146380f, -0.01649298f, 0.02314236f, -0.04514357f, 0.01747078f, 
    -0.04426397f, -0.02611828f, -0.03679222f, 0.00043636f, 0.01742256f, 0.01289704f, 0.02415124f, 0.02517103f, 
    -0.02831608f, -0.04889128f, 0.00608132f, 0.01987457f, -0.01944609f, -0.04227886f, -0.04583189f, -0.02176726f, 
    -0.02712482f, 0.03761753f, -0.00156299f, 0.02417786f, -0.05045447f, -0.04179004f, 0.01837682f, -0.04539197f, 
    -0.05125955f, -0.00854680f, -0.00641098f, 0.00096103f, -0.01177206f, -0.05321826f, 0.00471089f, 0.04120954f, 
    0.04007381f, 0.01336593f, -0.03756317f, 0.02004529f, 0.00329376f, 0.04553168f, -0.00628946f, -0.02885664f, 
    0.00484543f, -0.00075169f, -0.03793576f, 0.03673087f, 0.01729578f, -0.03194861f, -0.02613876f, 0.04302034f, 
    -0.03404361f, -0.01431383f, 0.01712879f, -0.01411829f, 0.02586999f, -0.03890831f, 0.01124562f, 0.01086852f, 
    -0.04070920f, 0.02931271f, -0.00640111f, 0.02441512f, 0.01348517f, 0.04025130f, -0.01195664f, 0.00549265f, 
    -0.02939746f, -0.04401613f, 0.02807742f, 0.01140914f, 0.01465279f, -0.03156448f, 0.02054253f, 0.02922861f, 
    -0.02053971f, -0.00440450f, 0.03877532f, -0.05501818f, -0.04038938f, 0.03735840f, 0.03561898f, -0.03438215f, 
    -0.01205394f, -0.05380018f, -0.02944415f, -0.02744750f, -0.04934089f, -0.02205535f, -0.01530138f, -0.03333217f, 
    0.03793569f, 0.01057845f, -0.03869767f, -0.05326114f, -0.03113571f, 0.03719168f, 0.00281774f, 0.02030036f, 
    0.01028098f, 0.01110247f, 0.04110345f, -0.02342312f, 0.01441077f, 0.02576293f, 0.00011379f, 0.02656366f, 
    -0.05359591f, -0.02581536f, -0.03415253f, -0.04089843f, -0.01290066f, 0.04097802f, -0.04901449f, 0.01408673f, 
    -0.02265147f, 0.02218358f, 0.04091978f, 0.00114636f, -0.04785849f, 0.03776990f, 0.03715083f, -0.01483191f, 
    -0.04448205f, -0.00828892f, -0.05526628f, -0.00093298f, -0.02317727f, -0.03250553f, -0.00630115f, -0.00423136f, 
    -0.01628914f, -0.02648699f, -0.04689174f, -0.00476286f, -0.02947687f, 0.01663719f, -0.00288216f, -0.05594817f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02199960f, -0.05180139f, 0.03813551f, 0.04337276f, 0.11834595f, -0.00658433f, -0.04222934f, 0.05546623f, 
    -0.03015083f, -0.07676281f, 0.05991824f, 0.13970701f, 0.11627077f, -0.03520846f, -0.06609060f, -0.03474944f, 
    -0.00589677f, -0.01762060f, -0.02690351f, -0.05494688f, 0.01953546f, 0.14523458f, -0.00053300f, 0.15555225f, 
    0.11214164f, 0.15368772f, 0.05768429f, 0.06495418f, -0.01549717f, 0.19225770f, -0.06377451f, -0.03389079f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.16574812f, 0.02659501f, 0.01062175f, 0.02182296f, -0.12910123f, 0.15810826f, -0.00899595f, 0.18378274f, 
    0.28706825f, -0.00139858f, 0.18888196f, 0.05229214f, -0.23480636f, 0.15947467f, 0.20319141f, -0.01982355f, 
    0.02922276f, 0.05741807f, 0.10461560f, 0.01773403f, 0.22353984f, -0.03928408f, 0.41460314f, 0.24967998f, 
    -0.10165798f, 0.17895941f, 0.32134375f, -0.19945343f, -0.00718269f, 0.18682362f, -0.16156982f, 0.11001328f, 
    0.17214714f, -0.12036566f, -0.12705147f, 0.10729009f, 0.23850177f, 0.00133725f, -0.02515086f, -0.30536154f, 
    -0.19280191f, 0.17134877f, 0.14958887f, 0.10019398f, 0.01347181f, -0.09461068f, 0.20238803f, 0.10728837f, 
    0.15285221f, 0.04480334f, 0.05970275f, -0.07061429f, -0.20196131f, -0.01691436f, -0.40696573f, 0.02592314f, 
    0.50271958f, 0.31804466f, -0.44779044f, 0.18900913f, 0.13106674f, 0.17188460f, -0.10250498f, -0.05629951f, 
    0.00352228f, 0.22183385f, 0.02243537f, -0.09238342f, 0.16313300f, 0.07025464f, 0.16367885f, 0.12126886f, 
    0.18489370f, 0.38127077f, 0.12469827f, -0.12848124f, -0.15589225f, 0.16966803f, 0.35530663f, -0.07671717f, 
    -0.02038884f, 0.02807834f, -0.13003124f, -0.10505112f, 0.34351856f, 0.28937697f, 0.13085818f, -0.01200396f, 
    -0.21403821f, 0.23843749f, 0.14122048f, 0.05166101f, -0.00192851f, 0.26135093f, -0.23025572f, 0.04671767f, 
    -0.16307579f, -0.16244176f, 0.08191245f, 0.11184797f, -0.00873906f, 0.11360925f, 0.06467254f, -0.00682643f, 
    0.42267677f, -0.45478997f, -0.34211996f, -0.09257505f, 0.07350610f, -0.16399209f, -0.00641173f, 0.08176609f, 
    -0.32162932f, -0.00647884f, 0.00407264f, -0.08403463f, -0.08406897f, -0.08573270f, -0.36198270f, -0.11960694f, 
    0.00717087f, 0.31716630f, -0.17396039f, 0.19042939f, -0.06151861f, 0.06725754f, 0.19008584f, -0.05890386f, 
    -0.00735304f, -0.30889726f, 0.00387994f, 0.04260844f, 0.10795147f, -0.09511589f, 0.03507155f, -0.18788566f, 
    -0.18879505f, -0.08531883f, 0.00949115f, -0.17662756f, 0.28139371f, 0.14424931f, -0.33858502f, -0.14209847f, 
    -0.22172540f, -0.01968004f, -0.01153047f, -0.07326702f, -0.06838049f, 0.22509524f, -0.02610168f, 0.12783472f, 
    -0.31841141f, 0.03866646f, 0.56034803f, 0.21971241f, -0.04924573f, 0.18085971f, 0.18557805f, 0.11531677f, 
    -0.12924184f, 0.40401679f, -0.04667139f, 0.02271438f, 0.14844653f, 0.16851945f, 0.14840280f, -0.04002707f, 
    -0.16817632f, -0.03221217f, -0.30775726f, -0.16381583f, 0.15036757f, 0.10832774f, 0.07529137f, 0.06330185f, 
    -0.00414606f, 0.15980899f, -0.11188394f, 0.00695452f, -0.13543284f, 0.17513546f, -0.17144164f, -0.18892731f, 
    -0.19689234f, 0.24102342f, -0.09757598f, 0.03680926f, -0.06080656f, -0.12665354f, -0.03600330f, 0.06845739f, 
    0.01829702f, 0.69306320f, -0.04791898f, -0.05745539f, 0.32897133f, -0.01193482f, -0.03691634f, 0.23139723f, 
    -0.01584593f, 0.12664355f, -0.18835716f, -0.26963848f, 0.03446404f, -0.05595605f, 0.10556396f, -0.14128673f, 
    0.14532776f, 0.03876815f, 0.16122170f, 0.11146452f, 0.08016719f, 0.29979908f, -0.29409313f, -0.23903736f, 
    -0.07223105f, 0.16638163f, -0.16007645f, 0.02435159f, 0.14450423f, 0.19534560f, -0.11279000f, 0.08619218f, 
    -0.00510247f, -0.04126782f, 0.02310411f, 0.13551483f, 0.06973332f, 0.14822020f, -0.09715616f, 0.21728851f, 
    0.18177649f, -0.40265378f, -0.44249213f, 0.21597268f, -0.14391294f, -0.02719022f, 0.29592338f, 0.06714892f, 
    -0.08182508f, -0.00295186f, 0.04336592f, 0.12902416f, -0.21818599f, 0.36072585f, -0.06815782f, 0.00676546f, 
    -0.25905624f, -0.15950508f, -0.20578456f, 0.22374305f, -0.16837610f, 0.10670827f, 0.05871917f, -0.06889947f, 
    -0.15129378f, 0.24290971f, -0.09975656f, -0.03281079f, 0.04464536f, 0.09720420f, -0.15598881f, 0.00951428f, 
    0.02026056f, -0.16456042f, -0.23563261f, 0.15029822f, 0.12313820f, -0.10688177f, 0.35698390f, -0.00980594f, 
    -0.34349155f, 0.04890147f, -0.08218195f, 0.04763491f, -0.10679525f, -0.04717973f, 0.14114030f, -0.15764628f, 
    -0.30946577f, -0.05760136f, -0.03839973f, 0.32834548f, -0.04121553f, 0.00032160f, 0.13054305f, 0.05895969f, 
    -0.14219140f, -0.07793019f, 0.08014463f, -0.08137031f, -0.11572278f, 0.11374334f, -0.09668234f, 0.19778143f, 
    0.00456323f, -0.02024019f, 0.06868272f, 0.30110982f, -0.10187455f, -0.04554780f, -0.17634173f, 0.15921263f, 
    0.17653854f, 0.18339828f, -0.13179171f, -0.15982801f, 0.11244072f, -0.08051313f, 0.29294601f, 0.01566027f, 
    0.33265519f, -0.14767241f, -0.19397372f, -0.12897058f, -0.03599095f, -0.04672676f, -0.14298829f, 0.13464175f, 
    0.10690807f, -0.03334473f, -0.03325605f, 0.00064948f, -0.35431767f, 0.01285938f, 0.10825500f, 0.09413663f, 
    0.18387581f, 0.03371383f, 0.26530236f, 0.19116601f, -0.02221358f, -0.04348060f, -0.05201816f, 0.17890629f, 
    -0.07254104f, -0.01269037f, 0.01459963f, 0.13146624f, -0.22255385f, 0.15039797f, 0.27276391f, -0.24586885f, 
    -0.32997769f, -0.30800256f, 0.45595351f, 0.02484512f, 0.03977466f, -0.22601146f, 0.38210180f, -0.13307372f, 
    -0.08072669f, -0.15755913f, -0.06923653f, -0.12840763f, 0.28419945f, -0.16163418f, -0.13151014f, 0.12731732f, 
    -0.09442809f, -0.20687415f, 0.22365117f, 0.31134936f, 0.07544729f, -0.09162199f, -0.08104712f, -0.15103950f, 
    -0.05727512f, -0.09171651f, -0.12750424f, -0.14970748f, -0.00792426f, 0.17470911f, -0.08150637f, 0.30144086f, 
    0.38567618f, -0.03602552f, -0.24264690f, 0.30051932f, 0.14594269f, 0.22346291f, -0.04192023f, 0.06357947f, 
    -0.10058049f, 0.28745946f, -0.16789861f, 0.01500282f, -0.10466427f, 0.08960531f, 0.17140079f, -0.00148949f, 
    0.09875876f, -0.33893791f, -0.50315386f, 0.10084714f, -0.16570663f, -0.05860865f, 0.32412335f, -0.12581211f, 
    -0.09922642f, 0.16465254f, -0.00692439f, 0.13405347f, -0.13973291f, 0.15731843f, -0.07254902f, 0.00824689f, 
    -0.33645520f, 0.29172978f, 0.22715458f, 0.35924527f, -0.12175795f, 0.05400307f, -0.09122418f, -0.10290417f, 
    -0.00616667f, 0.15361986f, 0.17495471f, 0.08364800f, -0.19462667f, 0.16260360f, -0.06278853f, -0.32982346f, 
    -0.02157755f, 0.32525596f, 0.03542420f, -0.34909412f, 0.24175726f, -0.11763791f, 0.30959928f, -0.14805779f, 
    0.22550435f, -0.05368707f, -0.04092494f, -0.13032849f, -0.12937155f, -0.02945829f, -0.36754295f, -0.27519900f, 
    -0.43649918f, -0.08902683f, 0.33612934f, 0.25087351f, -0.14505571f, -0.01799353f, 0.25785154f, -0.16879006f, 
    0.04179705f, -0.03472059f, -0.03594574f, -0.17563869f, 0.16140313f, 0.10496786f, -0.04390507f, -0.02288645f, 
    -0.01278640f, -0.05140466f, -0.13481319f, -0.10800789f, -0.10001569f, 0.06056333f, -0.22125916f, -0.09557603f, 
    0.04692203f, 0.13183111f, 0.09927349f, 0.13256475f, 0.27492407f, -0.12673329f, 0.07930983f, -0.26252496f, 
    -0.33117610f, 0.23097168f, -0.12466997f, 0.26052445f, 0.17197543f, 0.12174340f, -0.26476336f, 0.03097869f, 
    0.05938259f, -0.01407555f, -0.00756088f, -0.00178965f, -0.02028386f, 0.04549967f, -0.02063988f, 0.10220017f, 
    -0.12780081f, -0.18073334f, -0.05721113f, -0.18966831f, 0.20547092f, -0.01245966f, -0.46822342f, 0.06308436f, 
    -0.10738868f, -0.16513836f, 0.09378494f, -0.17439704f, 0.06912386f, 0.26432276f, -0.20852180f, 0.33652619f, 
    0.25176561f, 0.15354033f, 0.06680892f, -0.05348995f, 0.10788640f, 0.23374611f, 0.01020712f, -0.03912779f, 
    -0.06976323f, 0.28705516f, 0.15736359f, -0.06173584f, -0.36824223f, -0.03279661f, -0.17790440f, 0.42865774f, 
    -0.09279536f, -0.20059884f, 0.06858864f, -0.02317908f, 0.04081249f, -0.16299802f, 0.20889711f, -0.02696254f, 
    0.01788089f, -0.09680752f, 0.16069800f, -0.12787570f, -0.22266343f, -0.10773916f, 0.00147144f, -0.03060093f, 
    -0.20595141f, 0.20393167f, 0.43735692f, -0.13096605f, -0.13136625f, 0.01044530f, -0.00249296f, 0.11895166f, 
    -0.03147396f, -0.04088303f, -0.13747196f, 0.10052849f, -0.17095317f, 0.00947010f, 0.01319403f, 0.09446897f, 
    -0.09784348f, 0.08036592f, -0.05695555f, -0.15630414f, -0.05297418f, 0.11489309f, 0.02592801f, 0.11259029f, 
    -0.12550807f, 0.07156443f, 0.02429064f, 0.16680220f, -0.09830403f, 0.02429613f, -0.17899324f, -0.03649034f, 
    -0.00333665f, -0.01659001f, 0.08844721f, -0.09017601f, 0.17632776f, -0.20627441f, 0.10056630f, -0.09627048f, 
    0.06731074f, 0.08648147f, 0.11810450f, -0.00114376f, -0.08964492f, -0.07379995f, 0.11494485f, -0.22855408f, 
    0.29819053f, 0.05517322f, 0.00869054f, -0.21289946f, 0.07084373f, 0.15280026f, -0.19644713f, -0.15319687f, 
    0.40405664f, -0.10611267f, 0.10004292f, -0.07808404f, -0.18877956f, 0.33367682f, -0.56997269f, 0.21522525f, 
    0.14904095f, -0.33459154f, 0.02210304f, 0.26724708f, -0.00051745f, -0.13447458f, 0.36031032f, 0.10403500f, 
    -0.00422111f, -0.25734210f, -0.10908365f, 0.10117699f, -0.14764130f, 0.00367472f, -0.00639941f, 0.20351775f, 
    0.20378008f, 0.38192666f, 0.39333820f, -0.03413676f, -0.21861719f, -0.07777172f, 0.27040875f, 0.03380329f, 
    0.29733360f, -0.04112890f, -0.02193811f, -0.09426626f, 0.20195127f, 0.19892538f, 0.46056920f, 0.23139186f, 
    0.16480759f, -0.16109651f, 0.41392264f, -0.07360707f, -0.14839995f, 0.06246279f, 0.18718940f, -0.11765815f, 
    0.17341964f, 0.45779055f, 0.16617715f, -0.10178526f, 0.08419419f, -0.00374058f, 0.14013912f, 0.35777405f, 
    -0.02704902f, 0.11536784f, 0.29043844f, -0.17187996f, -0.00919280f, -0.09142644f, -0.19768143f, -0.05454430f, 
    0.34469709f, 0.16849549f, -0.03563258f, -0.06405839f, 0.17665862f, 0.10394645f, 0.30767372f, 0.18491933f, 
    0.15802315f, -0.31881815f, -0.19758482f, -0.28322399f, -0.03067671f, -0.14771618f, 0.00529658f, 0.03145061f, 
    0.11874335f, -0.15116301f, -0.14019528f, 0.10149452f, 0.14985932f, 0.13490000f, -0.03719406f, 0.18476000f, 
    0.24636491f, -0.56715399f, -0.13669781f, 0.14803985f, 0.27604711f, 0.15708983f, -0.12860020f, 0.08876983f, 
    -0.58706981f, 0.12904251f, -0.06995662f, -0.07642364f, -0.31327096f, -0.22649853f, 0.21706469f, -0.04670873f, 
    0.09415681f, 0.14236486f, 0.15795974f, -0.15003359f, 0.10884725f, -0.18781491f, 0.12558512f, 0.07458027f, 
    -0.12760584f, -0.20526132f, -0.08290334f, -0.04786900f, -0.09319542f, 0.05518589f, 0.15212621f, -0.00087627f, 
    -0.22964139f, -0.39107180f, 0.05570095f, 0.08681358f, 0.29306123f, 0.17864698f, -0.25997630f, 0.15581976f, 
    -0.17383078f, -0.13629323f, 0.18531603f, -0.08617420f, 0.01884149f, -0.00704603f, 0.04950563f, 0.26333034f, 
    -0.12558973f, 0.27641103f, 0.31192774f, -0.02924854f, 0.08783873f, 0.41825294f, 0.12174828f, -0.06959230f, 
    0.01696495f, -0.17354849f, -0.01380628f, 0.00222154f, -0.11651123f, 0.15020765f, -0.08245616f, -0.10795040f, 
    -0.08107791f, 0.08405747f, -0.07933459f, -0.00847672f, -0.15292376f, -0.17327258f, -0.01769436f, -0.15252081f, 
    -0.00029235f, -0.03298551f, -0.09846264f, -0.10759588f, -0.01968431f, -0.14631978f, -0.12093602f, 0.00755312f, 
    0.07869581f, -0.15328930f, -0.06601828f, -0.12615202f, 0.04654495f, 0.10695692f, -0.16131286f, 0.17652676f, 
    -0.10840726f, -0.02574801f, -0.02247733f, -0.07640001f, 0.23514400f, -0.11866334f, -0.08211926f, -0.21339618f, 
    -0.20939040f, -0.12068276f, -0.02925854f, 0.49698389f, 0.20477776f, -0.16880636f, -0.21133524f, 0.09044351f, 
    0.17517996f, 0.05454714f, 0.08051886f, 0.03732986f, -0.15521131f, 0.22234921f, -0.21084899f, 0.20558409f, 
    0.60258961f, -0.06271970f, -0.68190110f, 0.30238765f, 0.04679046f, 0.00924626f, 0.24963768f, 0.11480629f, 
    0.03848894f, 0.41817623f, 0.14057350f, -0.12134781f, -0.14898849f, -0.04771757f, -0.07322063f, 0.43599448f, 
    -0.15430349f, -0.07725175f, -0.11041657f, -0.16115943f, 0.04531083f, 0.03852951f, -0.11767967f, -0.01201894f, 
    0.30086210f, -0.16418146f, 0.08650117f, -0.08778283f, 0.09003854f, -0.07728046f, -0.35022923f, 0.30932888f, 
    -0.07827162f, 0.14845559f, -0.20306081f, 0.07517112f, 0.09316979f, 0.28444922f, -0.00787477f, 0.16205654f, 
    -0.07960777f, -0.35364053f, -0.04594041f, 0.08014163f, -0.09948574f, -0.00062056f, 0.15729365f, -0.21108554f, 
    0.16617945f, 0.37734964f, 0.37142542f, 0.33206865f, 0.04862545f, -0.01689286f, 0.39382258f, 0.15871237f, 
    0.07171819f, 0.08271721f, 0.00764891f, 0.03120380f, -0.04845696f, 0.27201772f, 0.53353095f, 0.04530621f, 
    0.03822990f, -0.20543055f, 0.44797334f, -0.04710343f, 0.07343104f, 0.32707211f, -0.01564546f, 0.05382108f, 
    0.03217290f, 0.33021322f, 0.07756348f, -0.17441006f, -0.34412202f, -0.10226462f, -0.04085465f, 0.17620966f, 
    0.15148371f, -0.17411463f, -0.37491658f, 0.20206007f, -0.02141357f, -0.11634094f, 0.39110935f, -0.16224675f, 
    -0.03857057f, 0.16831405f, 0.12857261f, 0.12361723f, -0.44367138f, 0.01762025f, -0.15139426f, 0.08360747f, 
    -0.12162732f, -0.07690762f, 0.08526348f, 0.19954105f, -0.02605772f, 0.05379594f, -0.19121890f, 0.10182159f, 
    -0.11204038f, 0.12139883f, -0.12974814f, 0.09522182f, -0.06634016f, 0.12930256f, -0.07077531f, 0.20523246f, 
    -0.04417964f, -0.10951957f, -0.08221482f, 0.03397577f, -0.00024357f, -0.09559266f, -0.03500142f, -0.11294752f, 
    -0.13987182f, 0.07458472f, 0.10466138f, 0.17259812f, 0.12011404f, -0.23854695f, -0.17379624f, -0.14601678f, 
    -0.12739216f, -0.21304889f, -0.13044208f, -0.02998154f, 0.08640836f, 0.03921607f, -0.18355753f, 0.05580242f, 
    0.02192907f, 0.22755477f, -0.03535952f, 0.12521055f, -0.19209453f, 0.00597026f, 0.08469483f, -0.16798995f, 
    -0.39624384f, 0.36409158f, 0.23596762f, 0.21548237f, 0.22267766f, -0.06913135f, 0.34225595f, -0.13755241f, 
    -0.05130845f, -0.10594618f, -0.15941978f, 0.13616051f, -0.19053614f, -0.27542549f, -0.19838563f, -0.48061064f, 
    0.16172537f, 0.18842693f, -0.08492342f, 0.03206743f, 0.06389067f, -0.46253964f, 0.17255135f, 0.03130664f, 
    -0.15820889f, -0.44425243f, 0.11058002f, -0.11009812f, 0.04238981f, -0.13905793f, -0.03261587f, -0.33796933f, 
    0.17621073f, 0.01776716f, 0.15231383f, 0.30397692f, 0.16458145f, 0.12056047f, -0.09959541f, -0.05234724f, 
    -0.05821978f, -0.07661852f, -0.09001072f, 0.03079252f, 0.11315226f, -0.08270039f, -0.24164127f, 0.20607248f, 
    0.38217995f, 0.19530044f, 0.14930265f, -0.12569962f, 0.13502571f, 0.11223303f, 0.16954893f, -0.06917680f, 
    -0.13441107f, 0.02757029f, -0.01608506f, -0.12422800f, 0.02468405f, -0.01746344f, 0.02048655f, -0.52560204f, 
    -0.25485465f, 0.33427620f, 0.15832789f, 0.04987736f, 0.26337028f, -0.12683599f, 0.17616247f, -0.12883627f, 
    -0.29892436f, -0.08399736f, -0.12634081f, 0.05578451f, -0.27342650f, 0.04189346f, -0.19285101f, -0.31555495f, 
    -0.02130629f, 0.00059496f, 0.24479394f, 0.23058526f, 0.05071783f, -0.28171381f, 0.24616574f, 0.09103355f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.10468069f, 0.14541359f, -0.03817913f, 0.09365493f, 0.15220098f, 0.15813291f, -0.00608632f, 0.02311671f, 
    -0.09668628f, 0.15112841f, -0.10528977f, 0.07810661f, 0.18261480f, -0.04520685f, -0.07548343f, 0.01121578f, 
    -0.09793931f, -0.05299234f, 0.10101157f, -0.08696214f, -0.11301756f, -0.04576381f, 0.35984510f, -0.12235291f, 
    0.06439690f, 0.03601960f, 0.06176750f, -0.05181990f, 0.12754939f, 0.08854593f, 0.07982992f, -0.16621804f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.11156686f, -0.28804019f, 0.13302492f, -0.35054591f, -0.56616306f, -0.25857437f, 0.14139564f, -0.14109834f, 
    -0.00583596f, 0.08667902f, 0.27467489f, -0.34509110f, -0.07844584f, -0.03361598f, 0.27987614f, -0.47268596f, 
    0.22573093f, -0.15393603f, -0.14296161f, 0.21990170f, 0.30324164f, -0.18075229f, -0.56007332f, 0.13599654f, 
    -0.55111307f, -0.17663385f, 0.05608992f, -0.09402535f, -0.11545336f, 0.00643859f, -0.45717233f, -0.27160740f, 
    0.01617489f, 0.15361163f, 0.14862633f, 0.09328204f, -0.63436204f, -0.22873877f, -0.03852849f, 0.17938432f, 
    0.12499179f, -0.16146676f, -0.53296620f, 0.29778799f, 0.26863363f, -0.72590876f, 0.01293847f, -0.09534296f, 
    -0.20165049f, -0.11763705f, -0.26213720f, 0.23551261f, 0.26703015f, -0.17333797f, -0.09779999f, -0.06473189f, 
    0.08864068f, 0.00289084f, 0.06684967f, 0.39159504f, -0.13799635f, -0.35113889f, -0.05069631f, -0.69736707f, 
    -0.07547205f, 0.50703174f, 0.14965105f, -0.74430019f, -0.24947463f, 0.09945371f, -0.14895625f, -0.05753752f, 
    -0.45359844f, 0.07990719f, -0.79955477f, 0.03554971f, -0.34206426f, 0.04932135f, 0.08020213f, -0.00820989f, 
    -0.35353366f, -0.21704908f, -0.54148734f, -0.12551087f, -0.27122408f, -0.53199029f, 0.08422684f, -0.08244794f, 
    0.12877743f, -0.22933461f, 0.10161003f, -0.11825694f, 0.10856256f, 0.37350374f, 0.35346466f, 0.13800986f, 
    -0.42104271f, 0.04542048f, -0.08672446f, -0.17570779f, -0.17442943f, 0.13085726f, 0.31423807f, -0.32313061f, 
    -0.05470176f, 0.00541558f, -0.13855238f, -0.12294917f, -0.27905020f, 0.39952871f, -0.58144528f, -0.32729018f, 
    -0.03469886f, -0.09027085f, 0.19015326f, 0.00057004f, 0.09826621f, -0.49019274f, -0.48135057f, 0.01017910f, 
    0.00081681f, 0.14030232f, -0.07339630f, -0.03195883f, -0.08870525f, 0.30288354f, -0.18972920f, 0.09734277f, 
    -0.10399667f, -0.34253928f, 0.02957278f, 0.28521997f, 0.40244731f, -0.29661325f, -0.18456934f, 0.13578583f, 
    -0.57520145f, -0.25456831f, 0.27293879f, -0.05410615f, 0.24764572f, 0.20163521f, 0.10797067f, -0.11989205f, 
    -0.16811125f, 0.11245494f, 0.13444448f, 0.17701285f, -0.03517088f, 0.07517909f, -0.21954764f, -0.02109079f, 
    -0.25008294f, -0.48439732f, 0.02607499f, -0.00751281f, -0.18995714f, -0.00450107f, 0.23272784f, 0.14840497f, 
    -0.02492009f, -0.28090674f, 0.13344240f, 0.01344344f, 0.45570958f, 0.00585305f, 0.11024181f, -0.18713446f, 
    -0.25069681f, -0.34350222f, -0.11136095f, -0.09601316f, -0.12594698f, 0.05229479f, -0.15392815f, 0.18592697f, 
    0.22495608f, -0.12768194f, -0.05308216f, 0.11431820f, 0.06493370f, 0.00793828f, 0.20263487f, -0.09090603f, 
    -0.49012342f, 0.18055308f, 0.05186303f, -0.00332557f, -0.05447281f, -0.55425292f, -0.05905250f, -0.66719615f, 
    0.03412338f, 0.22580002f, -0.41088298f, 0.17324150f, 0.27962732f, -0.09734548f, -0.35798502f, -0.50268656f, 
    -0.15998437f, 0.12205064f, -0.50280815f, 0.10359076f, -0.39590055f, -0.41341382f, -0.06462226f, 0.27465007f, 
    -0.39348951f, 0.05171018f, -0.42224795f, -0.47522980f, -0.26550972f, 0.42866081f, 0.05527920f, 0.04005946f, 
    0.25529504f, -0.33991992f, -0.38149038f, -0.54068351f, 0.01203156f, 0.11840816f, 0.28367355f, 0.24206188f, 
    0.23399016f, 0.13195583f, 0.02237430f, 0.22388208f, -0.02460403f, 0.21197289f, 0.02002610f, -0.33079517f, 
    0.18048815f, 0.03797134f, -0.11726213f, -0.31696823f, 0.21544635f, 0.49653968f, -0.17969528f, -0.28359553f, 
    0.37729335f, 0.02882372f, -0.31135291f, -0.35886598f, -0.18993406f, 0.16560479f, -0.08055546f, -0.11679836f, 
    -0.50862485f, -0.09972271f, -0.44291511f, 0.04781046f, -0.01357446f, 0.28310582f, -0.24117692f, 0.15777291f, 
    -0.44916680f, -0.14006126f, 0.15511459f, -0.14764132f, -0.02568622f, 0.38064235f, 0.42655444f, -0.11444215f, 
    0.06416759f, -0.05884076f, -0.34873915f, 0.19640015f, 0.23847038f, -0.42504892f, -0.17139053f, 0.12947500f, 
    0.02041290f, 0.08364712f, -0.42332375f, -0.44914988f, 0.16398072f, -0.31575453f, 0.00801395f, -0.06970835f, 
    0.02488602f, 0.27336705f, -0.82880372f, 0.04813929f, 0.31203526f, -0.11424018f, -0.55267978f, -0.31353402f, 
    -0.01850977f, -0.25489053f, -0.40457386f, -0.18697196f, 0.21583509f, -0.03199959f, -0.64547110f, -0.03669624f, 
    0.16799356f, 0.14936812f, 0.36000118f, 0.05755363f, 0.08795357f, -0.00336074f, 0.11662157f, -0.27875787f, 
    0.21493851f, 0.14572869f, -0.65788281f, -0.08398983f, -0.44292068f, 0.18069051f, 0.30170137f, -0.09335118f, 
    -0.02711775f, -0.33380398f, 0.10237478f, -0.06602255f, -0.12342808f, 0.18873827f, 0.12647724f, 0.21584241f, 
    -0.50574553f, 0.00119076f, -0.50395823f, -0.23293678f, -0.20556575f, -0.15348981f, -0.29278547f, -0.35158482f, 
    -0.46005830f, 0.05539711f, -0.06792644f, 0.09844112f, -0.40493172f, -0.25537112f, -0.48845628f, 0.19021928f, 
    0.07119823f, 0.11701601f, 0.53692615f, -0.10704453f, 0.18182059f, -0.18140869f, 0.01767643f, -0.15655231f, 
    0.33901840f, 0.37233984f, -0.28138858f, -0.44703960f, -0.26382592f, -0.17666493f, 0.13421145f, -0.59988374f, 
    -0.94926924f, 0.07499152f, -0.08571512f, 0.16103205f, 0.13363133f, 0.04771989f, 0.07117103f, 0.23127894f, 
    0.25248015f, -0.36400652f, -0.28782094f, 0.19338991f, 0.05642583f, 0.06187527f, -0.46225491f, -0.15016277f, 
    -0.70215416f, -0.00022904f, 0.26677451f, -0.22278185f, -0.46090320f, -0.02200746f, -0.09462131f, -0.05315837f, 
    0.29117706f, -0.15173762f, 0.15492909f, -0.13946362f, 0.10275055f, -0.45875174f, -0.14518374f, -0.12587209f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.28970397f, -0.00110331f, 0.34230259f, -0.14623158f, -0.22041403f, 0.12804563f, -0.11375655f, -0.28040493f, 
    0.28321564f, 0.10601535f, -0.11517613f, -0.06463103f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
